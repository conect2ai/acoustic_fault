#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.57225597f, -0.48297212f, -0.82847625f, -0.05050144f, 0.56230801f, -0.20214526f, 0.46774539f, 0.40360343f, 
    0.65343881f, -0.48327187f, -0.37300798f, 0.25327137f, -0.17836055f, 0.30200297f, -0.04810830f, -0.06273949f, 
    0.00866844f, -0.10740199f, -0.05197654f, 0.04442285f, 0.14663714f, -0.09388509f, 0.00363617f, 0.00744144f, 
    -0.01212246f, 0.23705044f, 0.41143247f, 0.28980801f, -0.10399015f, 0.04804914f, -0.45061398f, -0.14943798f, 
    0.01728028f, 0.32361084f, 0.23259373f, 0.32005772f, -0.09986927f, -0.24310994f, 0.27088758f, -0.22457843f, 
    -0.03563740f, -0.03927935f, -0.08959077f, -0.05563408f, 0.03415712f, -0.02368996f, 0.26102492f, -0.17371698f, 
    -0.28170487f, -0.24555491f, -0.01714078f, -0.12550762f, -0.33141157f, -0.40978843f, -0.04665108f, -0.56735426f, 
    -0.55937749f, -0.58807826f, -0.56041121f, -0.62823820f, 0.38246295f, -0.30560070f, 0.29305580f, 0.61610436f, 
    0.10397674f, -0.14380291f, -0.11578828f, -0.20322850f, -0.11100231f, 0.09825242f, -0.12800556f, -0.08869224f, 
    0.21027756f, -0.08421075f, 0.10842282f, -0.22352694f, -0.92271763f, -0.20879976f, 0.23421977f, 0.16139020f, 
    0.19570932f, -0.29229441f, -0.37169686f, -0.65551823f, -0.60586190f, -0.14740638f, -0.04437670f, -0.12565738f, 
    -0.42144924f, -0.30625245f, -0.01835788f, 0.14271076f, -0.25067362f, -0.29604799f, -0.32003438f, -0.08962300f, 
    0.08313761f, 0.01778026f, 0.00568521f, -0.13459484f, -0.36548117f, -0.71534562f, -0.57757348f, -0.25096774f, 
    -0.04208226f, -0.14446874f, 0.04935787f, -0.05344692f, 0.17053249f, 0.36454284f, -0.03877614f, -0.35416165f, 
    -0.49907747f, -0.31338698f, 0.08021725f, 0.12551124f, 0.38425004f, -0.19461145f, -0.06712843f, -0.06982446f, 
    -0.32387599f, -0.19905494f, -0.07548602f, -0.22609591f, 0.08480597f, -0.62050766f, -0.25046524f, -0.33383799f, 
    0.07098260f, -0.60811728f, 0.37604445f, 0.15591314f, -0.30562556f, -0.27909720f, 0.45977363f, -0.21677110f, 
    -0.05382617f, -0.03084627f, -0.21135089f, -0.00003999f, 0.29330894f, -0.02101208f, -0.00124409f, 0.22540557f, 
    0.19214021f, -0.04368233f, -0.30496135f, -0.07394891f, -0.14703473f, -0.26881200f, 0.06573709f, 0.94191968f, 
    -0.09977985f, -0.56175840f, 0.04247645f, 0.20521799f, -0.31531283f, -0.00211879f, -0.23591302f, -0.36813784f, 
    0.21422735f, -0.06442800f, -0.16355141f, 0.42313507f, -0.03300951f, 0.32978943f, -0.30308527f, -0.31740689f, 
    0.39843786f, -0.21849123f, 0.12219181f, 0.31177527f, 0.06187056f, 0.16482705f, -0.04038132f, 0.40908027f, 
    0.03889288f, -0.39539510f, -0.51361740f, -0.82409370f, 0.24058959f, 0.01322494f, 0.06820361f, -0.01423059f, 
    0.14746955f, 0.17115207f, -0.06177017f, -0.05850168f, -0.12377161f, -0.00178330f, -0.35205638f, 0.04193269f, 
    0.04371405f, -0.15986687f, -0.13808738f, 0.26347074f, 0.04589336f, -0.32474074f, 0.31200951f, 0.48010045f, 
    -1.00659120f, 0.01920388f, -0.93606776f, -0.53650653f, -0.12418170f, 0.17070304f, 0.31846389f, -0.33246896f, 
    -0.09574458f, 0.92462111f, 0.13135424f, 0.21373059f, 0.28939769f, 0.05490479f, 0.14999579f, -0.13543619f, 
    -0.04692926f, 0.01039389f, -0.05682441f, 0.24501860f, 0.25224125f, -0.10654201f, 0.14960940f, -0.19061576f, 
    0.06451987f, 0.05912266f, -0.16999671f, 0.22832628f, 0.12447312f, 0.26099744f, -0.06973347f, -0.01554312f, 
    0.19933547f, 0.19374306f, 0.14977597f, 0.08772554f, 0.07899991f, -0.35611287f, 0.30571017f, 0.21965449f, 
    -0.08095329f, 0.08185048f, -0.05144199f, -0.00602797f, -0.17878051f, 0.11150970f, -0.06349575f, 0.02811544f, 
    0.12306505f, 0.05641331f, -0.90177196f, -0.79721612f, 0.20684133f, 0.82350874f, 0.56971604f, 0.57206732f, 
    -0.38035733f, -0.51583850f, 0.01581751f, 0.18180667f, 0.07011757f, -0.24944009f, -0.36198288f, 0.25778851f, 
    -0.07048470f, -0.10144535f, -0.18573929f, 0.19444315f, 0.32659546f, 0.13578233f, -0.08607574f, -0.29855528f, 
    0.02013388f, -0.09176974f, -0.04799971f, -0.28047997f, 0.06348640f, -0.70149046f, -0.53410757f, -0.03175229f, 
    0.45426878f, 0.29958826f, 0.31753266f, 0.13514674f, -0.08691777f, -0.11840923f, 0.50938559f, -0.32717541f, 
    -0.20812966f, -0.05668802f, -0.25855562f, -0.39190677f, 0.28298047f, 0.11194273f, -0.39701530f, 0.05015175f, 
    0.07999668f, 0.19135126f, 0.23358501f, 0.33754876f, -0.11055718f, -0.26333198f, -0.48906285f, 0.21178892f, 
    0.64888108f, 0.24739105f, 0.26264670f, 0.02602210f, -0.01427042f, 0.10269532f, -0.16178951f, -0.21317397f, 
    -0.20201464f, -0.11047386f, -0.19018689f, 0.21624546f, -0.02213778f, -0.10976224f, -0.18346880f, -0.44550332f, 
    -0.36556807f, 0.08975919f, -0.40478358f, -0.38164747f, -0.58558184f, -0.10137045f, -0.38343894f, -0.01052702f, 
    0.11223611f, 0.29168192f, 0.71313763f, -0.54452032f, -0.37500355f, -0.36198837f, 0.14804254f, -0.19170730f, 
    -0.32206845f, 0.30971396f, -0.46911362f, 0.08900446f, -0.00051649f, -0.09460992f, 0.14104556f, 0.09335483f, 
    -0.08684263f, 0.20579319f, -0.06683578f, -0.31238732f, 0.12426434f, 0.36346415f, -0.32445613f, 0.11145791f, 
    0.59204483f, 0.71236557f, -0.15518647f, -0.62474525f, -0.83913982f, -0.12461049f, 0.08191474f, 0.24870524f, 
    -0.29971749f, -0.11579669f, -0.00082954f, 0.10742152f, 0.10945437f, -0.09460616f, 0.38618198f, 0.19966544f, 
    -0.09156013f, -0.16141547f, -0.12530144f, -0.13724375f, -0.27165890f, -0.07514399f, -0.30424199f, 0.22815558f, 
    -0.16952026f, 0.51566124f, 0.40169615f, 0.74102777f, 0.04029350f, -0.15886232f, -0.14164455f, -0.29870927f, 
    -0.26168707f, -0.16270018f, -0.16246244f, 0.16467650f, -0.19567257f, 0.16725734f, -0.08809365f, -0.21079288f, 
    0.02540804f, -0.00791741f, -0.13397324f, 0.04474048f, 0.10431903f, -0.22626443f, 0.11192064f, 0.10916867f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19592935f, 0.14581902f, -0.00202545f, 0.07530380f, -0.28444433f, -0.05512935f, 0.12234361f, 0.07969164f, 
    0.31157205f, 0.09442817f, 0.32129443f, 0.07914309f, 0.06710654f, 0.10095281f, 0.02869229f, 0.32139221f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30700937f, 0.09955658f, -0.09468330f, 0.09532662f, 0.01724381f, 0.00669334f, 0.07204352f, 0.00053466f, 
    0.09402636f, 0.01452801f, 0.01355614f, -0.04581860f, 0.06730239f, -0.05739132f, 0.06541502f, -0.02639249f, 
    -0.12218795f, 0.01066977f, -0.00786485f, 0.02004751f, 0.11751425f, 0.00735862f, -0.04809009f, -0.01420381f, 
    -0.08957824f, -0.07742649f, 0.02098247f, 0.03268981f, -0.02484437f, -0.09470651f, -0.06336213f, -0.14680935f, 
    -0.14733030f, -0.16702089f, -0.02117335f, -0.11363974f, -0.09146697f, -0.07232787f, -0.06472643f, 0.03723501f, 
    0.04345795f, 0.06527165f, 0.00132156f, -0.14173901f, -0.13605334f, -0.02582300f, -0.18261434f, 0.02714357f, 
    0.10740976f, 0.06042564f, -0.03133397f, 0.10072999f, 0.07041620f, -0.01156158f, 0.11567371f, -0.06682397f, 
    -0.02066824f, 0.05449939f, -0.05328805f, 0.20629047f, 0.16479558f, -0.01710549f, 0.04026578f, 0.15919471f, 
    -0.06117097f, -0.04735802f, 0.08521619f, -0.04120460f, -0.04569411f, 0.03358424f, -0.08119759f, 0.07337917f, 
    0.20812406f, -0.06469157f, 0.15596534f, 0.10646400f, -0.07610417f, -0.05023492f, -0.05740107f, -0.01431875f, 
    0.02887830f, -0.25592732f, -0.05936607f, -0.10771790f, 0.10764200f, 0.04497466f, 0.09292989f, -0.03115848f, 
    0.05429658f, -0.13645127f, 0.03463355f, -0.08813737f, -0.06766584f, 0.00015141f, -0.02606322f, 0.04042217f, 
    0.28947538f, 0.01199288f, 0.05437278f, 0.12588830f, 0.15433225f, 0.06736860f, -0.02965167f, -0.13889898f, 
    -0.00736039f, -0.07340272f, -0.05741937f, 0.18274233f, 0.17495234f, -0.01285095f, -0.06513429f, 0.06437060f, 
    0.05905744f, 0.08732135f, -0.02148454f, 0.01372825f, 0.01048540f, -0.12998743f, -0.06398273f, -0.09077231f, 
    -0.05276209f, -0.08092908f, 0.07677567f, 0.06265425f, -0.01092283f, 0.08538075f, 0.04923009f, 0.14276995f, 
    -0.13355696f, 0.16640189f, 0.12781467f, -0.16808638f, 0.05466465f, 0.11631567f, 0.08276162f, 0.18116234f, 
    0.23339032f, -0.15698840f, -0.02041934f, -0.03830680f, -0.27402604f, -0.14747912f, -0.02421333f, -0.02141968f, 
    0.04102368f, -0.07553815f, -0.01759165f, 0.27409583f, -0.08502993f, -0.09806561f, -0.01177659f, 0.02079024f, 
    0.25065979f, 0.44844690f, 0.26232216f, 0.32470423f, 0.15239665f, -0.01991122f, -0.11558446f, -0.22025341f, 
    -0.06741221f, -0.06347234f, 0.23910160f, 0.03534954f, -0.16143787f, -0.04467211f, -0.17183866f, -0.13243800f, 
    -0.06715067f, 0.01162222f, -0.32399780f, 0.14170916f, -0.13452473f, 0.15527360f, 0.06622165f, 0.01551802f, 
    0.08305608f, 0.13144848f, 0.00591297f, 0.23668844f, -0.04301219f, 0.18347627f, 0.04220420f, 0.18984364f, 
    0.09763161f, -0.11475149f, -0.09312589f, -0.01879293f, 0.04406605f, -0.06936938f, -0.03843492f, 0.00112583f, 
    0.01366859f, -0.06006939f, 0.02865364f, 0.03493379f, -0.07807268f, 0.00735304f, 0.04014848f, 0.00090212f, 
    0.00502818f, -0.04916372f, -0.00800209f, -0.00395262f, 0.07506010f, -0.02063170f, -0.06244877f, 0.02022708f, 
    -0.05111912f, 0.01085654f, -0.02919133f, 0.01278267f, 0.02216823f, -0.05705472f, 0.01696099f, -0.07410804f, 
    0.02256625f, -0.03287016f, -0.00531822f, -0.06879435f, 0.03353741f, 0.02503596f, -0.02135396f, -0.01293165f, 
    0.03584242f, 0.04018433f, 0.04067434f, -0.07571721f, -0.00068838f, -0.00457629f, 0.03734332f, -0.05400076f, 
    -0.01757845f, -0.05246994f, -0.04768980f, 0.02034517f, -0.03899776f, 0.03837729f, -0.04806039f, 0.00966290f, 
    -0.07303341f, -0.07997290f, 0.03901954f, -0.05197964f, 0.01417220f, 0.05358469f, 0.03604731f, 0.01222599f, 
    -0.03418596f, -0.07460551f, -0.03720686f, -0.02105915f, 0.01371267f, -0.03208149f, 0.03512552f, -0.00980425f, 
    -0.00706282f, 0.03242575f, 0.02536652f, 0.03967400f, -0.03532282f, -0.01111237f, 0.05510337f, -0.07714663f, 
    -0.05496103f, -0.04591695f, -0.02816080f, -0.03701774f, -0.06224197f, -0.04169837f, -0.01528488f, 0.05391437f, 
    0.03580913f, -0.04521871f, 0.01045565f, 0.01703620f, -0.03497764f, -0.05217887f, 0.05421534f, -0.01045048f, 
    -0.06263623f, -0.03645045f, 0.01488860f, -0.01977621f, 0.02084492f, -0.01266428f, -0.07829759f, -0.07750621f, 
    -0.04045125f, 0.04851025f, -0.03513566f, -0.01427115f, 0.00676204f, -0.00885952f, 0.02715637f, 0.03290612f, 
    0.02941022f, 0.05083667f, -0.07373465f, 0.03403745f, 0.01874254f, 0.01954404f, -0.03830338f, 0.03896157f, 
    -0.04812173f, -0.07890284f, -0.07306598f, 0.05150392f, 0.00577459f, -0.08121727f, -0.03320010f, -0.08067083f, 
    0.03845192f, -0.03524967f, 0.01181052f, -0.06225511f, 0.00375063f, 0.00870236f, -0.00965100f, -0.05697118f, 
    0.00986675f, -0.00106846f, -0.07258822f, -0.00899129f, -0.03743825f, 0.01892605f, 0.05208185f, -0.00285663f, 
    -0.02897839f, -0.03461962f, 0.00315638f, 0.02857465f, -0.06085534f, 0.00856338f, -0.05515882f, 0.02239810f, 
    0.05372444f, 0.06153464f, -0.07237242f, -0.06671639f, -0.03553143f, -0.04287422f, 0.02625548f, -0.01367971f, 
    -0.07735924f, 0.01984186f, -0.07619916f, -0.04302519f, -0.06479737f, -0.06380901f, -0.04106717f, 0.01606208f, 
    0.02614060f, 0.05922855f, -0.07068233f, 0.05410802f, 0.03666039f, 0.00889609f, -0.08175877f, -0.02105139f, 
    -0.05295340f, -0.00614060f, 0.03241886f, -0.05857343f, 0.02939106f, 0.01873260f, 0.04588143f, -0.07219102f, 
    -0.01715340f, -0.02818210f, 0.02893666f, -0.00347822f, -0.07431198f, -0.08023231f, 0.00905311f, 0.00260840f, 
    -0.00915983f, 0.05272388f, 0.01755513f, 0.05553508f, 0.00912713f, -0.01369685f, -0.03267051f, -0.03307697f, 
    -0.00112033f, -0.09873319f, -0.24144137f, 0.43257102f, -0.05406229f, -0.01285627f, 0.01011561f, 0.18652612f, 
    0.17672704f, 0.05198272f, 0.14117163f, 0.03543632f, 0.24216013f, -0.10209250f, 0.24488975f, 0.04998722f, 
    -0.04066501f, -0.06268258f, -0.12675589f, -0.05473385f, 0.06068334f, -0.02427839f, -0.02592884f, 0.10957904f, 
    -0.08166248f, 0.08659434f, 0.17819600f, 0.12178271f, -0.09751636f, 0.07007164f, 0.05263313f, 0.02618429f, 
    0.03029281f, -0.04060097f, -0.00619988f, -0.02132634f, 0.00702157f, -0.17429833f, -0.01353915f, 0.05631712f, 
    -0.07381081f, 0.10700747f, 0.01894189f, -0.00983857f, -0.15290977f, -0.01542349f, 0.02137819f, 0.05711889f, 
    -0.03301454f, 0.00877528f, 0.13594134f, -0.04857847f, -0.06684723f, 0.04393774f, 0.19793326f, 0.03530401f, 
    -0.02327813f, 0.27379954f, 0.14651214f, 0.28488368f, 0.06874437f, 0.06420778f, 0.06555106f, 0.15392047f, 
    -0.06576476f, -0.02610053f, 0.21529983f, -0.03185268f, 0.04084525f, -0.01451396f, -0.06990565f, 0.13228211f, 
    0.12819660f, -0.07141172f, 0.00508538f, 0.13829699f, 0.11455550f, 0.06404138f, -0.15788163f, 0.04598784f, 
    -0.29664561f, -0.33528960f, -0.33114243f, 0.05061112f, -0.01059508f, 0.15560059f, 0.11850749f, -0.03777440f, 
    -0.10784270f, 0.05758468f, -0.00188319f, -0.04960984f, -0.19705249f, -0.00969066f, -0.08444890f, -0.20183595f, 
    0.49421254f, 0.22687766f, -0.01735631f, 0.20719971f, -0.16194004f, -0.06861103f, -0.07237979f, -0.10022774f, 
    0.07589406f, 0.00005520f, 0.03130198f, -0.07562409f, 0.11037097f, 0.01312513f, -0.03996018f, 0.13139208f, 
    -0.12240431f, -0.10197232f, 0.18333460f, -0.18691646f, -0.14797838f, -0.00727028f, -0.28405842f, -0.16786829f, 
    0.07166036f, -0.21276760f, -0.01323611f, 0.10818554f, 0.09348057f, -0.06995109f, 0.06418810f, 0.08724876f, 
    0.06907123f, 0.12520099f, 0.08450582f, 0.06586589f, -0.01946951f, 0.02173318f, -0.04616514f, -0.04247591f, 
    -0.04556512f, -0.11614885f, -0.10516912f, 0.09516992f, -0.20667280f, -0.16309313f, -0.13403428f, -0.11320949f, 
    -0.00146269f, -0.12487417f, -0.07425591f, 0.25922909f, -0.07871073f, -0.00645964f, -0.04967770f, 0.10683521f, 
    0.23497805f, 0.05626687f, 0.32520610f, 0.32845810f, -0.03489592f, -0.10263229f, -0.07474474f, -0.05551430f, 
    -0.11969056f, 0.00235798f, 0.10831494f, 0.04733742f, -0.26780307f, -0.10108733f, -0.04543534f, -0.30188009f, 
    -0.04029924f, 0.08171038f, 0.18005775f, 0.14295557f, 0.04535628f, 0.00953458f, 0.11130119f, 0.02459151f, 
    -0.07757756f, 0.12392193f, 0.19254269f, 0.23350008f, 0.35785368f, 0.27825427f, -0.06772145f, -0.15639441f, 
    0.04489167f, -0.20249754f, -0.10066481f, -0.15144633f, -0.20297083f, -0.10277425f, -0.06960606f, -0.20784833f, 
    0.20498331f, 0.14277637f, -0.17261471f, -0.05391942f, 0.05832748f, -0.41377974f, 0.08551245f, -0.15632652f, 
    0.02662531f, 0.11656287f, -0.00002062f, -0.00587645f, -0.17354238f, -0.03813323f, -0.05409601f, 0.01809479f, 
    -0.10769291f, -0.03606250f, -0.03216875f, -0.16314782f, 0.03202922f, -0.08415778f, -0.00441782f, 0.24436590f, 
    0.14269947f, 0.05974421f, -0.09195913f, 0.02060503f, -0.04709671f, 0.04519770f, -0.03829195f, 0.16581964f, 
    0.00794553f, 0.05568307f, -0.01013060f, -0.14865631f, 0.03812816f, 0.02887613f, -0.29268035f, 0.06944083f, 
    0.15360992f, 0.01112161f, -0.01629334f, 0.09405594f, -0.18496284f, -0.06888086f, -0.02383048f, 0.04823128f, 
    -0.03085951f, 0.09014117f, 0.12610246f, 0.04256260f, 0.13319366f, 0.11666809f, 0.05136769f, 0.12203299f, 
    -0.10523525f, 0.14251371f, 0.17020550f, 0.18662220f, 0.03460217f, 0.00859155f, 0.01285105f, 0.10622189f, 
    0.11916713f, 0.08091678f, 0.03649411f, -0.19328800f, 0.10687681f, 0.09925731f, 0.16484636f, 0.25503799f, 
    -0.45366025f, 0.12326232f, -0.22492483f, 0.31680200f, 0.01902791f, 0.15844658f, 0.16748859f, -0.07126103f, 
    -0.22211021f, -0.28851771f, -0.22276945f, -0.30285415f, -0.06574418f, 0.00015509f, -0.11364425f, 0.13782616f, 
    -0.13077226f, 0.03136724f, -0.08300641f, 0.08155284f, -0.06159291f, -0.16120696f, -0.11616743f, -0.07309770f, 
    0.47132581f, -0.01819994f, 0.09639188f, 0.26781306f, 0.03059204f, -0.05253688f, 0.05637250f, -0.20678288f, 
    0.00042908f, -0.01426982f, -0.01296494f, 0.12924434f, 0.09757809f, -0.16858745f, -0.16667393f, -0.07721210f, 
    -0.14995901f, -0.13708249f, -0.24569139f, -0.37352228f, -0.22341058f, -0.04835049f, -0.08564953f, -0.05974445f, 
    0.09529789f, 0.09502356f, 0.01670542f, -0.02109542f, 0.00897165f, 0.09459221f, 0.01173180f, -0.02083510f, 
    0.03456028f, -0.03603115f, 0.01406935f, 0.06026756f, 0.13944928f, -0.02327201f, 0.11572634f, 0.14269896f, 
    0.11039072f, -0.11573028f, -0.03190992f, -0.10985073f, -0.20461427f, -0.18717901f, 0.09648771f, -0.07134680f, 
    0.25418359f, -0.09987379f, -0.04466677f, 0.32953981f, -0.10739410f, -0.15141688f, -0.00076458f, 0.00769125f, 
    0.11408602f, 0.28001139f, 0.23738228f, 0.32471162f, 0.08755388f, 0.17445441f, -0.12579474f, -0.17268175f, 
    -0.16629353f, -0.01283133f, -0.03818449f, 0.11609865f, -0.14306393f, -0.07060421f, -0.02911313f, -0.22888124f, 
    0.24547355f, 0.15068625f, 0.09199223f, 0.10876769f, -0.06604648f, -0.18626156f, 0.03966604f, 0.11301120f, 
    0.01691468f, 0.06444939f, 0.04872181f, -0.00009990f, -0.10218141f, 0.26587331f, 0.21557122f, 0.32940528f, 
    0.22315408f, -0.02201772f, 0.04934043f, -0.10049868f, -0.39338401f, -0.19538045f, -0.09401649f, -0.27563554f, 
    -0.11044757f, -0.09749819f, -0.11530845f, -0.11689053f, 0.08536709f, -0.02674444f, -0.21298479f, 0.08166752f, 
    0.14736828f, 0.11854362f, 0.10034564f, 0.10407008f, -0.36006194f, -0.20641766f, -0.24419817f, 0.15154831f, 
    -0.04309613f, -0.06939945f, 0.01233778f, -0.24548927f, 0.05465039f, -0.09276575f, 0.00565554f, 0.10681595f, 
    0.24935296f, 0.37999469f, 0.11837050f, -0.12908253f, -0.00753652f, 0.09826218f, -0.02657935f, 0.20378719f, 
    0.00758829f, -0.06706057f, -0.09924519f, -0.06828182f, 0.19225869f, 0.11037430f, 0.20519932f, -0.20201513f, 
    0.07651500f, 0.06625446f, -0.04530402f, 0.04473121f, 0.00742510f, 0.02805451f, 0.12858669f, -0.06762352f, 
    0.16449931f, 0.03306900f, 0.15421435f, -0.00717602f, -0.00384030f, 0.00590339f, -0.00208253f, 0.05021925f, 
    -0.10293542f, -0.07823745f, 0.11904156f, 0.00664562f, -0.02579902f, 0.04964705f, -0.12124891f, -0.19580433f, 
    0.04646608f, 0.06428768f, 0.06103368f, 0.13693233f, -0.07596742f, -0.04673820f, 0.07534889f, 0.04333694f, 
    -0.08224206f, 0.06713311f, -0.37542188f, 0.01216150f, -0.07800802f, 0.01471129f, 0.17189801f, 0.00648311f, 
    0.18435644f, 0.07149097f, -0.08184604f, 0.01782006f, 0.16950732f, 0.12865084f, 0.01983722f, -0.15740180f, 
    -0.00589348f, -0.02359042f, -0.00549746f, 0.04050685f, 0.03109906f, -0.15197583f, -0.13493316f, -0.17650960f, 
    -0.02937850f, 0.15704036f, 0.14575200f, -0.23157875f, -0.18004946f, -0.02977731f, 0.10899051f, 0.06165013f, 
    -0.09671808f, -0.03140761f, -0.01747609f, 0.11290866f, -0.11897033f, -0.25444189f, -0.06092672f, -0.06870912f, 
    -0.09599306f, 0.01126901f, -0.12357715f, 0.05326052f, -0.04650093f, 0.14966601f, 0.03804419f, 0.10083402f, 
    0.15965976f, -0.25548512f, 0.21524882f, 0.00162811f, -0.05679017f, -0.03247410f, -0.13087948f, -0.00333948f, 
    -0.08774403f, -0.02177209f, -0.03881028f, -0.04173389f, 0.10213484f, 0.09168328f, -0.04799187f, -0.13536164f, 
    0.07119410f, 0.05089070f, -0.10102122f, -0.00453990f, 0.10833859f, -0.01029098f, -0.02036574f, 0.05393781f, 
    0.02626733f, -0.19643097f, -0.00193465f, 0.05332030f, 0.02742676f, 0.05607190f, -0.03010800f, -0.07800893f, 
    -0.05232330f, -0.00261371f, -0.04425703f, -0.04354226f, 0.22420120f, -0.00339007f, 0.15200187f, 0.11872147f, 
    -0.09183248f, 0.07518581f, 0.02363633f, -0.00601452f, 0.07901361f, -0.06882482f, -0.02014157f, -0.08136112f, 
    -0.20945947f, -0.08776951f, 0.17415728f, -0.01169681f, 0.10935204f, 0.07523894f, -0.11245228f, 0.08273932f, 
    -0.07437419f, -0.12702772f, 0.10488594f, -0.18036632f, -0.33473238f, -0.62962401f, -0.01303471f, -0.18926248f, 
    0.00343426f, 0.06504302f, -0.05631888f, -0.03409462f, -0.05502025f, 0.05303735f, -0.05469477f, 0.05345259f, 
    0.13956362f, -0.51997739f, -0.19020909f, 0.05372879f, 0.12648694f, 0.12586446f, 0.06095651f, 0.00009952f, 
    -0.03830365f, 0.14988743f, 0.06974923f, 0.05223017f, 0.14432783f, -0.04083487f, 0.22778268f, -0.05259531f, 
    -0.00301660f, 0.00765228f, -0.18606097f, 0.03938408f, -0.12350710f, 0.00237829f, 0.11155266f, 0.10275432f, 
    -0.05350018f, -0.10416862f, 0.09892005f, -0.08449539f, 0.02280385f, 0.00037897f, -0.10052870f, -0.01587628f, 
    0.11971344f, -0.03525975f, -0.09612135f, 0.09071214f, 0.15901449f, 0.05229326f, 0.28092396f, -0.01490120f, 
    -0.16529189f, -0.01790307f, 0.15318117f, -0.00494809f, 0.07208168f, 0.03162354f, 0.03492793f, -0.06649314f, 
    0.02905452f, -0.14144389f, 0.01286799f, -0.18368363f, -0.03504178f, -0.08911189f, -0.07126413f, -0.02269154f, 
    0.00699049f, -0.10025840f, 0.13508306f, 0.07879423f, 0.00976015f, 0.13926616f, -0.14036839f, -0.02521652f, 
    -0.00277122f, -0.16990459f, 0.12501377f, 0.16898739f, -0.00847986f, 0.08575418f, 0.05830914f, -0.02738670f, 
    -0.11148024f, -0.10208643f, 0.07052950f, -0.16370228f, 0.15569596f, 0.05891947f, 0.10477938f, 0.14872792f, 
    -0.08663596f, 0.01289394f, 0.03624897f, -0.03161569f, -0.15752456f, -0.11544130f, -0.08428757f, 0.05230427f, 
    0.16077682f, 0.06260783f, 0.03759906f, 0.03108986f, 0.05923953f, 0.04526867f, -0.09519409f, 0.05760356f, 
    -0.24825463f, -0.23865855f, -0.20600307f, 0.03334032f, 0.05515005f, 0.12349696f, -0.04983345f, 0.15176107f, 
    -0.00963055f, 0.03104852f, -0.08316106f, -0.12812901f, -0.08356322f, -0.02237537f, 0.06117524f, 0.05267619f, 
    0.02395370f, -0.09356567f, -0.04595131f, -0.06558714f, -0.00352890f, 0.03749014f, -0.05683250f, 0.11771780f, 
    0.13487671f, 0.09348538f, 0.11356771f, 0.07608725f, 0.21116987f, -0.10480949f, 0.24733254f, 0.07772259f, 
    0.10228033f, 0.07084206f, 0.17221788f, 0.03440758f, -0.31792155f, -0.06921216f, -0.26127332f, -0.11403007f, 
    -0.12043658f, 0.27545536f, 0.02968664f, 0.07154434f, 0.09264632f, -0.17548659f, 0.14428623f, 0.05220314f, 
    -0.13767815f, 0.20617954f, -0.06491458f, -0.03903791f, 0.05470085f, 0.04428206f, -0.00144178f, 0.05110147f, 
    0.00401703f, -0.24284670f, 0.02933529f, -0.09818059f, 0.15380062f, 0.23734483f, 0.18926407f, 0.02454571f, 
    0.02746554f, -0.20879941f, 0.02513509f, 0.12947690f, 0.05373066f, -0.00554873f, -0.09654960f, -0.00883785f, 
    0.33026126f, -0.00813865f, 0.30971414f, 0.06808382f, 0.10023841f, -0.11088119f, 0.12746394f, 0.06506918f, 
    -0.05976664f, 0.15446702f, 0.08667055f, -0.11895372f, 0.36946851f, 0.27184275f, -0.04670993f, -0.35937336f, 
    -0.10985271f, -0.04485714f, -0.12028698f, -0.01532821f, -0.11132986f, 0.03623885f, -0.00989079f, -0.02595944f, 
    0.11666016f, -0.06934611f, -0.26824680f, -0.10828547f, 0.06075727f, -0.09887839f, -0.02556415f, 0.01894098f, 
    0.05268715f, 0.02928050f, -0.05658564f, -0.12896489f, -0.33586910f, -0.28362799f, -0.12633859f, -0.29645929f, 
    -0.07475726f, -0.10704717f, 0.01259244f, -0.03149237f, 0.07921846f, 0.06044379f, -0.00496765f, -0.08535919f, 
    0.32954872f, 0.32710293f, 0.08406890f, 0.20377623f, -0.02367866f, -0.01097751f, 0.11406470f, 0.13180177f, 
    0.04140175f, -0.03984918f, 0.03935510f, 0.00176572f, 0.28158459f, -0.02691208f, 0.12411280f, 0.03598733f, 
    0.03997077f, -0.00278814f, 0.00625906f, -0.00280576f, -0.03309156f, 0.04685922f, 0.02676607f, -0.00984337f, 
    0.33744293f, 0.27761504f, -0.04242656f, 0.09838329f, 0.19401023f, 0.11154821f, 0.12391528f, -0.07714023f, 
    0.00860149f, 0.03679667f, -0.11577131f, 0.03942863f, 0.19368047f, 0.28078020f, 0.08668113f, 0.00768134f, 
    0.08892429f, 0.23726161f, 0.01541891f, -0.18897316f, 0.06621685f, -0.15044019f, -0.08328234f, -0.14720404f, 
    -0.17245708f, -0.04567821f, -0.09158788f, 0.14323299f, -0.03405624f, 0.09951919f, -0.03080405f, -0.04590763f, 
    -0.02214823f, -0.06753390f, 0.00405147f, 0.01642254f, 0.35518393f, 0.06797017f, 0.24208567f, 0.16497745f, 
    0.12575868f, 0.08126780f, 0.01369964f, -0.12545216f, -0.02497414f, -0.04067504f, 0.07285079f, -0.04680490f, 
    0.13971002f, -0.00052155f, -0.05463843f, 0.00110605f, 0.06437551f, 0.01613605f, 0.04694278f, -0.02443194f, 
    -0.19107461f, -0.17593269f, 0.02587728f, -0.04062489f, -0.27340940f, -0.25709081f, -0.21474868f, -0.23583460f, 
    -0.01924101f, 0.01718894f, -0.02047019f, -0.01731773f, -0.07599966f, -0.06295963f, 0.02098467f, 0.10747088f, 
    0.11592931f, 0.02022482f, 0.20919715f, 0.01054294f, -0.16675429f, -0.18299843f, -0.02989192f, -0.20165749f, 
    -0.05010944f, -0.09929107f, -0.10484757f, -0.00234584f, 0.31311831f, 0.05295536f, -0.08189353f, 0.33833942f, 
    0.11858478f, 0.01825550f, 0.00789732f, -0.01230378f, -0.02085863f, 0.00401971f, 0.01394874f, 0.03330151f, 
    -0.04859548f, -0.14493868f, -0.15898621f, -0.05511780f, 0.01972176f, 0.00386923f, 0.04418135f, 0.04237012f, 
    -0.20840545f, 0.20809519f, 0.01783315f, -0.06347779f, 0.25109893f, 0.07115366f, -0.11494492f, -0.02246018f, 
    -0.11150124f, -0.15399168f, -0.01114180f, -0.20433570f, 0.06668075f, -0.01459831f, -0.09598885f, -0.00573459f, 
    -0.04071801f, 0.06923504f, -0.02469494f, -0.31500351f, 0.04309231f, -0.04970988f, 0.11128558f, -0.02863993f, 
    0.06199814f, 0.05844750f, -0.06760571f, 0.01860549f, -0.54625416f, -0.53437340f, -0.35152385f, -0.20113683f, 
    -0.07296084f, -0.05842742f, -0.07107431f, 0.03786280f, 0.04243485f, -0.04832560f, -0.00978324f, 0.07904412f, 
    0.45754924f, -0.13356671f, -0.23483045f, 0.12537910f, -0.06837475f, 0.18370545f, 0.08406152f, 0.00317846f, 
    0.05040022f, -0.04561723f, 0.03715225f, 0.06783997f, -0.09079313f, 0.05414105f, 0.22622819f, -0.10281387f, 
    -0.07761408f, 0.07356109f, -0.07222936f, 0.05180231f, -0.03367965f, 0.06904721f, -0.03459521f, 0.04940828f, 
    0.05472519f, -0.23942289f, 0.05605084f, 0.04807947f, 0.05565206f, 0.10052155f, 0.11757612f, 0.08305648f, 
    -0.02805258f, 0.06007429f, -0.03703270f, -0.09712245f, 0.01592310f, 0.13930893f, -0.03490809f, 0.16271102f, 
    0.00548864f, -0.01435503f, 0.14509532f, 0.02254816f, -0.07144480f, 0.00338684f, -0.10232915f, 0.11698270f, 
    0.19482674f, 0.05745907f, -0.06881253f, -0.07087004f, 0.06198137f, 0.00238239f, 0.07664930f, -0.00955924f, 
    -0.02093048f, 0.04142186f, -0.00742407f, 0.14012915f, 0.11071637f, 0.03183810f, -0.02709277f, 0.12864441f, 
    0.07513268f, 0.02806130f, 0.15831897f, -0.00098513f, -0.06511034f, 0.02874394f, 0.01725838f, 0.00217962f, 
    -0.15637243f, -0.14194861f, 0.20838195f, 0.05742561f, -0.06982276f, 0.07716615f, -0.07018426f, 0.01727548f, 
    -0.12123606f, 0.01021927f, 0.09206188f, 0.16918206f, -0.08735663f, -0.11470553f, 0.01879543f, 0.24045394f, 
    0.10815358f, 0.11031757f, -0.08801653f, 0.04055442f, -0.11832637f, 0.02752820f, -0.10693458f, 0.06967543f, 
    0.21458660f, -0.15659049f, -0.31699625f, 0.21864007f, 0.18518734f, -0.02702563f, 0.07705431f, 0.03998271f, 
    -0.07465819f, 0.04397431f, -0.04336908f, -0.15987182f, -0.03966356f, 0.03855575f, 0.05111005f, -0.13366607f, 
    -0.01152068f, -0.03296645f, 0.09372580f, -0.05447948f, 0.01305230f, 0.04670979f, -0.07688375f, 0.12177880f, 
    0.16900504f, 0.48506504f, -0.25944021f, -0.09888878f, 0.27514762f, 0.05289367f, 0.08538506f, -0.03959288f, 
    0.06261525f, -0.03436727f, 0.06810630f, -0.05868351f, -0.01940856f, -0.03151012f, -0.22270699f, 0.10373015f, 
    0.05025395f, 0.14188462f, 0.01083386f, -0.19836795f, -0.05908976f, -0.16384250f, 0.23842952f, 0.06122107f, 
    0.07510972f, 0.20592132f, -0.16596508f, 0.03793107f, 0.04507954f, 0.00577287f, -0.02763375f, -0.05160050f, 
    -0.00835556f, -0.02453748f, -0.03583551f, -0.03689516f, 0.01778465f, 0.37678182f, -0.12814674f, 0.07451051f, 
    0.07250661f, 0.03250495f, -0.06191951f, -0.00119700f, -0.10154336f, -0.00856548f, 0.00373679f, -0.03174670f, 
    0.17958547f, 0.11094721f, 0.37435925f, -0.08181345f, 0.12662125f, -0.12387406f, -0.01397397f, -0.05000038f, 
    -0.04112000f, 0.03593322f, 0.03428473f, 0.00803556f, 0.13863282f, 0.40370238f, -0.08728395f, -0.16370274f, 
    -0.13090621f, -0.13669929f, -0.00128414f, 0.01363498f, 0.05605546f, 0.11624885f, 0.05491412f, -0.10145502f, 
    -0.19279917f, 0.44835705f, 0.39160061f, 0.24184053f, -0.32499823f, 0.06852897f, -0.22839768f, -0.04223535f, 
    0.09650466f, 0.03026126f, 0.07251825f, -0.06466088f, 0.27758431f, 0.00171935f, -0.04159752f, -0.08140139f, 
    -0.10940544f, -0.30310467f, -0.00960096f, 0.07166187f, -0.09419727f, 0.00146899f, -0.11217655f, 0.01293506f, 
    -0.21205819f, 0.08423759f, -0.00323546f, -0.03030499f, 0.10505902f, -0.03021736f, 0.00267283f, -0.16691580f, 
    0.04907018f, 0.05059846f, -0.01239239f, 0.04700800f, 0.00223658f, -0.10082624f, 0.10167710f, -0.04232774f, 
    -0.01583927f, 0.06017258f, 0.08063159f, -0.05654294f, 0.06999560f, 0.00390627f, 0.06807957f, 0.02086894f, 
    -0.10289788f, 0.16830817f, -0.01291994f, 0.05976408f, -0.04443247f, 0.03563006f, -0.01294046f, -0.02754043f, 
    0.18588524f, 0.05866947f, -0.22607426f, -0.07074171f, 0.09547948f, -0.04092247f, 0.23431979f, 0.02133392f, 
    0.03085094f, 0.17231035f, 0.07416818f, 0.05961748f, -0.06020282f, 0.06984588f, -0.05003749f, -0.17563151f, 
    0.25691667f, -0.45260161f, -0.08630706f, -0.02424162f, 0.12475891f, -0.11034328f, 0.08662953f, -0.05411283f, 
    -0.06749146f, 0.16184369f, -0.14938344f, 0.16147949f, 0.13485706f, -0.00731303f, -0.03059767f, -0.19031824f, 
    0.05193615f, 0.21385321f, 0.09008652f, 0.01564619f, 0.10747322f, -0.00958224f, -0.01664688f, -0.11700479f, 
    0.20231135f, 0.17564321f, 0.22315028f, 0.10067373f, -0.15140468f, 0.02687860f, 0.07109071f, 0.30273676f, 
    0.05417221f, 0.08478765f, 0.03104021f, 0.06327240f, -0.04427982f, 0.07085197f, -0.13433106f, 0.01324814f, 
    -0.29365468f, 0.00737507f, 0.08325125f, -0.11867571f, 0.00439815f, -0.05920658f, -0.10694159f, -0.04552994f, 
    0.03669513f, -0.06902972f, 0.03316779f, 0.01095312f, -0.00681615f, 0.12276933f, 0.03138416f, 0.20068258f, 
    0.09713937f, 0.02072749f, -0.01173041f, 0.06379692f, -0.05558130f, 0.19272080f, 0.18092906f, 0.01755197f, 
    -0.38101724f, 0.10811920f, 0.17422710f, 0.08729163f, 0.12811077f, 0.00399654f, -0.25409034f, -0.16749847f, 
    0.03370348f, -0.06785369f, 0.15491505f, -0.06513956f, -0.05876638f, -0.09797359f, -0.03684232f, -0.02484295f, 
    0.22303215f, -0.04782905f, -0.04975397f, -0.08375109f, -0.12785527f, -0.13147640f, -0.00947370f, 0.23817050f, 
    0.17424512f, 0.17773105f, 0.00971604f, 0.17664716f, 0.20929101f, 0.08769018f, 0.12070786f, 0.04882346f, 
    -0.67092395f, -0.08982872f, -0.15036404f, -0.07153944f, -0.23712891f, 0.13465242f, -0.03593608f, -0.09039526f, 
    0.07176279f, -0.16335765f, 0.04066762f, 0.00663650f, -0.18426311f, 0.03763210f, -0.17295617f, 0.21883741f, 
    -0.24905241f, -0.17548840f, -0.17172885f, -0.04186516f, 0.10530798f, -0.01136273f, -0.15596421f, 0.00078782f, 
    -0.45456061f, 0.51989466f, 0.32064560f, -0.44048968f, 0.02587843f, 0.05206582f, -0.22267759f, 0.00061233f, 
    0.05719686f, 0.05775650f, 0.04288404f, 0.09219940f, -0.19880040f, -0.01458600f, -0.26984641f, -0.08382850f, 
    -0.11247286f, -0.11328241f, 0.17804809f, -0.13097134f, -0.03921753f, 0.06260907f, -0.10348700f, -0.01360624f, 
    0.30938390f, 0.25890249f, -0.21711814f, 0.06839208f, 0.11711316f, 0.18774258f, 0.03786560f, 0.22477619f, 
    0.16685072f, 0.10085294f, 0.00672558f, -0.07083905f, 0.08951513f, 0.12221204f, -0.17880508f, 0.17341469f, 
    0.07958493f, 0.09987952f, -0.13763046f, 0.10090651f, 0.07194350f, -0.03403688f, 0.12894724f, 0.12743534f, 
    -0.04084610f, 0.02418705f, -0.28589439f, 0.08055794f, 0.10012781f, 0.13638933f, -0.03672829f, 0.24867277f, 
    -0.09528078f, 0.02677159f, 0.15417077f, -0.15646225f, -0.10101938f, -0.05963157f, -0.12161954f, -0.12364139f, 
    0.18804258f, 0.22829771f, -0.14368172f, 0.13188921f, -0.03420895f, -0.09010447f, 0.04435383f, 0.01990393f, 
    -0.00918567f, 0.16984138f, -0.11594380f, 0.14870961f, -0.17528836f, 0.15892071f, 0.12349422f, 0.03517466f, 
    0.04634519f, 0.08111135f, -0.06728932f, -0.09640732f, 0.18393289f, -0.09362802f, -0.01579432f, 0.23794949f, 
    -0.10483714f, -0.09968185f, 0.13101618f, -0.03389775f, 0.00139635f, -0.06539556f, 0.02581609f, -0.05638977f, 
    -0.10710286f, 0.36059964f, 0.19818479f, -0.19704463f, -0.03936337f, -0.10898355f, 0.15081379f, 0.03798294f, 
    -0.18034628f, -0.12597640f, 0.02991128f, -0.12256783f, -0.20504636f, -0.10957389f, 0.11608987f, -0.16258007f, 
    -0.00200506f, -0.01380274f, -0.06989072f, -0.08064058f, -0.00359730f, 0.00156067f, 0.08784267f, -0.12192304f, 
    -0.20089038f, 0.08167817f, -0.02686869f, 0.08481376f, 0.04729941f, 0.21621814f, 0.03837774f, -0.12434909f, 
    -0.09728310f, -0.04917963f, -0.17235368f, -0.01864166f, 0.30825803f, -0.06538321f, 0.14666668f, 0.09944669f, 
    0.02512019f, 0.06807891f, -0.05733253f, -0.05148463f, 0.19397518f, -0.06760589f, 0.12132239f, -0.04873635f, 
    0.17509480f, 0.08948799f, -0.05708114f, -0.24254622f, -0.03496413f, 0.05176986f, 0.04844989f, -0.07633988f, 
    -0.05867777f, -0.04203030f, 0.03966570f, 0.01992034f, -0.02100602f, -0.03069548f, 0.29135558f, 0.26327869f, 
    0.16039380f, -0.06732532f, -0.11080816f, -0.03663955f, 0.03312508f, -0.03453862f, 0.19568738f, 0.08034305f, 
    0.01154109f, -0.20611815f, 0.04747273f, -0.11180592f, -0.13303861f, 0.24382949f, 0.19762442f, 0.13312794f, 
    -0.03589140f, 0.11706052f, -0.11713533f, -0.01333398f, -0.33195350f, -0.38152006f, 0.09800272f, 0.06104774f, 
    0.04019980f, 0.07902510f, -0.02039647f, 0.03461969f, 0.08754655f, 0.02172192f, -0.02848360f, 0.13475788f, 
    -0.05464809f, -0.03691219f, -0.03154788f, -0.01358280f, 0.03047480f, 0.04308810f, -0.04285582f, -0.07334469f, 
    -0.03918239f, 0.02253904f, -0.03515631f, -0.00136724f, -0.05799910f, 0.02117721f, -0.02753191f, -0.06689559f, 
    -0.05163217f, -0.05570197f, -0.01159990f, -0.00405888f, -0.05477183f, 0.00710507f, 0.01790724f, -0.04892101f, 
    0.06206692f, -0.02807942f, -0.01465540f, -0.05710951f, -0.05987379f, -0.00234801f, -0.03138751f, -0.05516032f, 
    0.06537820f, -0.04107333f, -0.04253286f, -0.00551739f, -0.07620696f, 0.03786910f, -0.04254579f, -0.05193702f, 
    -0.02787839f, -0.04639878f, 0.03656597f, 0.02859224f, -0.02977642f, -0.05768952f, -0.01412504f, -0.06828681f, 
    -0.01743624f, -0.05902194f, -0.02151490f, 0.05320577f, -0.04235228f, 0.05665454f, -0.02314879f, 0.02199789f, 
    0.06012931f, -0.06916625f, 0.04558861f, -0.03867324f, 0.00468282f, 0.01372405f, -0.02884141f, 0.02329981f, 
    0.02416957f, -0.06410892f, 0.02104663f, 0.04692820f, -0.01557719f, -0.06896220f, -0.00613061f, 0.04791190f, 
    0.00831531f, 0.03107324f, 0.00604974f, -0.05570397f, 0.04395744f, 0.04538160f, -0.02494625f, 0.05036380f, 
    0.01336903f, -0.03692214f, -0.01035587f, 0.04222573f, -0.06423468f, -0.06957680f, 0.01403892f, -0.07134245f, 
    -0.05914834f, 0.01210312f, -0.00258391f, -0.07621592f, 0.00083132f, -0.01455256f, -0.02005323f, 0.06348293f, 
    -0.01053893f, -0.05265566f, 0.02635972f, 0.04844589f, 0.03185458f, 0.06155368f, -0.00722062f, -0.00667455f, 
    -0.07484731f, -0.02931112f, -0.04261174f, -0.01060038f, -0.06944097f, -0.03002757f, 0.02364690f, -0.04974126f, 
    0.01330260f, -0.04250765f, 0.05811329f, -0.05544871f, -0.03968939f, 0.03997133f, 0.03368528f, -0.07269324f, 
    -0.05873509f, 0.01447633f, -0.05793585f, -0.05609335f, 0.04918409f, 0.01030771f, -0.04118831f, -0.01857659f, 
    -0.04078973f, 0.03147673f, -0.02046859f, -0.00825233f, 0.05027721f, -0.04442313f, -0.03308690f, -0.03565211f, 
    0.04049139f, -0.07240085f, -0.02969559f, -0.04010108f, -0.02447436f, -0.05156786f, 0.04017912f, 0.05865541f, 
    -0.03969483f, -0.00859591f, 0.02195044f, -0.07537109f, -0.04363563f, -0.00682542f, 0.01805329f, 0.04497031f, 
    -0.01565703f, 0.05514444f, 0.02263167f, 0.05966372f, 0.00996301f, 0.01621204f, 0.03188241f, -0.06243635f, 
    -0.05473764f, -0.01439614f, 0.04640022f, 0.00882408f, 0.04409429f, -0.02140094f, 0.00216896f, -0.06373744f, 
    0.03876873f, -0.02542478f, -0.00154693f, 0.01921326f, 0.02494785f, -0.04461480f, -0.06867677f, 0.02835823f, 
    -0.06937248f, -0.02162204f, 0.05675221f, -0.05933880f, 0.05731658f, -0.02837506f, 0.03671248f, -0.05462627f, 
    0.01374301f, 0.02756077f, 0.00499375f, -0.00532396f, -0.07042966f, 0.02764582f, -0.01404387f, 0.06367310f, 
    0.20895545f, -0.14027596f, -0.09175791f, 0.04902117f, 0.04472934f, 0.00464072f, -0.00748466f, 0.03982664f, 
    0.06481086f, 0.04238182f, 0.04655724f, -0.01752003f, -0.39437941f, -0.22468081f, -0.05668189f, -0.03981026f, 
    -0.15434074f, -0.10807870f, -0.09511060f, -0.02042152f, 0.14187050f, 0.10229592f, -0.09625369f, 0.01996469f, 
    0.38512030f, 0.38266292f, 0.20202604f, 0.13750513f, 0.00902167f, -0.01798950f, 0.16540866f, 0.18366741f, 
    0.02673982f, -0.07041055f, 0.05533773f, -0.14104027f, -0.09279839f, 0.07831158f, 0.09910785f, 0.28099480f, 
    -0.00123969f, -0.01102282f, -0.16606367f, 0.27872926f, -0.00439957f, 0.01561673f, -0.05152421f, -0.04228668f, 
    0.15608700f, 0.31106126f, 0.17809017f, 0.06988791f, 0.19216284f, -0.01546163f, 0.06889868f, 0.02651484f, 
    -0.06385185f, 0.03215768f, -0.10612237f, 0.11454759f, 0.18291594f, 0.34190086f, -0.05740304f, -0.04305306f, 
    0.01195292f, -0.07258684f, 0.03356289f, -0.11017629f, -0.06573977f, -0.09020060f, 0.07093079f, 0.02725607f, 
    0.03417552f, -0.01334888f, 0.02981455f, 0.08502994f, -0.01235275f, 0.06614237f, 0.06441971f, 0.11098098f, 
    -0.05100126f, -0.07908610f, 0.01587312f, 0.02213033f, 0.40765470f, 0.19888830f, 0.27461752f, 0.10353907f, 
    -0.03439254f, 0.05927911f, 0.05848050f, -0.01637719f, -0.11387312f, 0.01830191f, -0.02431107f, -0.03577725f, 
    0.26274076f, 0.22248177f, 0.01838798f, 0.09677369f, 0.07184630f, -0.06989421f, -0.01009998f, -0.11734793f, 
    -0.08976626f, 0.03139415f, 0.08955757f, 0.05456964f, -0.20695244f, -0.25791499f, -0.13870415f, 0.00409387f, 
    -0.06275204f, -0.05335887f, 0.01100517f, 0.04922095f, -0.02556192f, 0.10346434f, 0.04212156f, 0.04063257f, 
    -0.17942339f, 0.28654367f, 0.20284849f, 0.15585423f, -0.22174960f, 0.00521105f, -0.05900853f, -0.05836067f, 
    0.14680329f, -0.03192699f, -0.05084578f, -0.05233994f, 0.39066866f, 0.28316054f, 0.12854338f, 0.23137508f, 
    0.21116900f, -0.12699404f, 0.04984900f, -0.10318194f, -0.06013003f, 0.04504627f, 0.08535837f, -0.00384798f, 
    -0.04822824f, -0.15099320f, -0.10128485f, 0.11373539f, -0.05907792f, 0.04642413f, 0.00138665f, -0.03688487f, 
    -0.28926808f, 0.06275584f, 0.05622857f, 0.11245590f, -0.07615799f, 0.29678172f, -0.15118381f, 0.11512589f, 
    -0.25765938f, 0.24990037f, -0.02704371f, -0.18766089f, -0.09828731f, -0.09387581f, -0.06225874f, -0.08150335f, 
    -0.16079661f, 0.24089929f, 0.29753879f, -0.16145794f, -0.29722095f, -0.16124222f, 0.01611956f, -0.09216591f, 
    0.00256058f, 0.06652442f, 0.02380217f, -0.01578015f, -0.20801221f, -0.13489108f, -0.17095898f, -0.11365923f, 
    -0.18064794f, 0.02828552f, 0.05327381f, -0.06275582f, 0.00586778f, 0.09969386f, -0.00218565f, -0.03895385f, 
    0.18666685f, -0.19600010f, -0.27518657f, 0.32453170f, -0.05253170f, 0.17780180f, -0.01509217f, 0.09607741f, 
    0.00330638f, 0.04372808f, 0.07545589f, -0.05384401f, 0.18203503f, 0.02593264f, 0.15328935f, 0.04535656f, 
    -0.05807369f, 0.12532045f, -0.05085684f, 0.14445740f, 0.00468398f, -0.05844964f, 0.06714801f, -0.07669912f, 
    -0.12567441f, -0.31364256f, -0.01136475f, -0.14626257f, -0.00162741f, -0.20488742f, -0.00687377f, -0.15237971f, 
    -0.05019609f, -0.09458226f, -0.03281634f, 0.01435665f, 0.07752030f, -0.03637636f, 0.11557084f, -0.00890268f, 
    -0.10741039f, -0.02322046f, 0.08522196f, -0.06393930f, 0.00345863f, 0.06873740f, 0.00897372f, 0.02874045f, 
    0.20990038f, 0.07776830f, 0.10344323f, 0.03932510f, 0.14012706f, 0.07781639f, 0.25436905f, 0.02706380f, 
    0.02750405f, 0.09697618f, 0.21805233f, 0.12363550f, 0.09252964f, 0.18235005f, -0.05952333f, 0.15217535f, 
    -0.03913675f, 0.08567817f, 0.15014768f, -0.10373519f, -0.00692679f, -0.01366842f, 0.06113075f, 0.02843095f, 
    0.05063726f, -0.14225005f, 0.11058556f, -0.11261732f, 0.09993406f, -0.03122679f, -0.05635954f, 0.09303696f, 
    -0.07314089f, -0.15971732f, 0.08833783f, -0.01765955f, 0.02072401f, -0.00649709f, -0.05274484f, -0.16027290f, 
    0.18033084f, -0.03324561f, 0.02861978f, 0.09323196f, -0.02666399f, -0.00104559f, -0.08115517f, 0.03823965f, 
    0.01200864f, 0.00730686f, -0.21655318f, 0.14206599f, -0.01306350f, -0.00961563f, -0.04045869f, 0.08791970f, 
    0.07051191f, -0.02445477f, -0.12260468f, 0.08646607f, 0.08268037f, 0.07088381f, -0.03991467f, 0.04029380f, 
    -0.02837279f, -0.01253206f, -0.00723335f, -0.06131628f, -0.02916685f, -0.07424939f, -0.00311740f, 0.01656681f, 
    0.13628612f, 0.00549135f, -0.13529523f, 0.19926593f, 0.21237677f, -0.09407381f, 0.04711369f, 0.07518166f, 
    0.00407836f, 0.08525611f, 0.19991240f, 0.03020306f, -0.18678878f, 0.12368470f, -0.09593630f, 0.06161492f, 
    0.08715555f, 0.13526551f, 0.00583248f, 0.10381455f, -0.21149918f, -0.05158423f, -0.06843087f, 0.08087488f, 
    -0.07881381f, 0.03810694f, -0.01895839f, 0.22961600f, -0.06061573f, -0.05182618f, 0.04148629f, 0.12952612f, 
    0.08590388f, 0.07247612f, 0.09117638f, 0.01606093f, 0.02425695f, 0.15146483f, -0.11779675f, 0.15861836f, 
    0.00460653f, -0.09321634f, 0.04168179f, 0.17680356f, -0.00312030f, -0.04469736f, -0.08509012f, -0.01396526f, 
    0.05087458f, -0.00795397f, -0.13672198f, -0.20929122f, 0.14424482f, -0.11335281f, 0.01224110f, 0.05365247f, 
    -0.04344112f, 0.08511691f, 0.07617857f, 0.16643278f, 0.19685122f, 0.26084509f, -0.36465478f, -0.23021823f, 
    -0.05876145f, -0.11486688f, -0.08390468f, -0.10578334f, -0.07897501f, 0.03735580f, -0.01167249f, 0.00571740f, 
    0.18076640f, -0.46911991f, -0.06727645f, -0.04325004f, 0.05468004f, 0.08907273f, 0.04042735f, 0.00815553f, 
    0.20334385f, 0.04441473f, 0.08310247f, 0.20418310f, 0.01051334f, 0.14730883f, 0.16110033f, -0.03169763f, 
    -0.00337299f, 0.01069809f, -0.03136513f, 0.03798013f, -0.10183325f, -0.01922065f, 0.10263216f, 0.05309564f, 
    0.09413020f, -0.03169506f, 0.18136947f, -0.02002759f, -0.20621978f, 0.00683326f, 0.03625886f, 0.15159096f, 
    0.07321053f, 0.05878513f, 0.02079968f, 0.07009696f, 0.23974565f, -0.09553672f, 0.18220975f, -0.25008622f, 
    -0.12210278f, -0.03896130f, 0.05057870f, -0.00877960f, 0.08380038f, 0.04863722f, -0.01349894f, 0.07184567f, 
    0.15053843f, -0.07677075f, -0.14500980f, -0.22739454f, -0.03418368f, 0.02760355f, 0.02012915f, -0.11703413f, 
    0.04413053f, 0.03487147f, -0.03745811f, 0.14832330f, 0.18913576f, 0.12701975f, -0.22836468f, 0.03491671f, 
    -0.04802653f, -0.03506245f, 0.16779765f, 0.08287138f, 0.05262978f, -0.17484802f, -0.04862630f, -0.16313271f, 
    -0.11418938f, -0.07582249f, 0.00536594f, 0.05328070f, 0.12082742f, 0.12819286f, -0.13207686f, -0.00079771f, 
    -0.13526829f, 0.05509772f, -0.01312915f, 0.00237636f, -0.12503742f, -0.14604305f, -0.12687121f, -0.02837369f, 
    0.23124622f, 0.06663644f, 0.05712825f, 0.10643266f, -0.03243310f, -0.11369739f, -0.04081436f, 0.04593585f, 
    -0.15442282f, -0.03428535f, -0.44088456f, -0.06856017f, -0.08950292f, 0.07922238f, 0.08123145f, 0.26476631f, 
    0.01784202f, -0.15607750f, -0.12995329f, -0.02575937f, 0.02824822f, 0.13920924f, -0.01644957f, -0.07965810f, 
    -0.01798219f, 0.02398350f, -0.02757768f, -0.02078194f, 0.04740319f, 0.08571889f, 0.03303280f, 0.17560123f, 
    0.42983106f, -0.03417314f, -0.08318661f, -0.10320645f, 0.12593740f, -0.13219815f, 0.15635101f, -0.05688706f, 
    0.11422815f, -0.04221154f, 0.11957708f, 0.09434964f, -0.09610306f, -0.16784669f, -0.20951875f, 0.13864809f, 
    -0.20668311f, 0.18455726f, 0.06275308f, 0.10183542f, 0.05977418f, -0.14512016f, 0.03956937f, -0.12789345f, 
    -0.16177142f, -0.04028757f, -0.07410578f, 0.04630006f, -0.01669874f, 0.03325820f, -0.02794148f, -0.03539954f, 
    0.07732004f, -0.06588709f, -0.14815190f, -0.10281948f, 0.21531487f, 0.10879117f, -0.10057203f, 0.18654752f, 
    -0.01434198f, -0.09394260f, 0.09434790f, -0.04053898f, -0.04211809f, 0.01159394f, -0.11183359f, 0.02489707f, 
    0.12682939f, 0.10144956f, 0.14237452f, -0.06016753f, 0.21438448f, -0.08095816f, 0.09786189f, -0.01625102f, 
    -0.06770156f, -0.03983616f, -0.04890573f, -0.06787144f, 0.39110714f, 0.11867838f, 0.09560036f, -0.29110044f, 
    -0.11763071f, -0.15505835f, -0.10973841f, -0.05325992f, 0.02968612f, 0.01638957f, -0.01916137f, -0.09216011f, 
    0.41652015f, 0.23560481f, 0.05420287f, 0.07323811f, -0.12400414f, -0.09230746f, -0.08217897f, -0.13454244f, 
    -0.03525808f, 0.06031262f, 0.01504480f, 0.10954767f, -0.03415340f, 0.01759162f, 0.13164856f, 0.07240020f, 
    -0.08829582f, -0.08253131f, -0.07159708f, -0.13213272f, 0.05701215f, -0.03221920f, -0.15783729f, 0.03505322f, 
    0.04630855f, 0.33105582f, 0.06304095f, 0.21179157f, 0.05864875f, 0.05971262f, 0.30358922f, 0.14093883f, 
    0.04741503f, -0.01794549f, 0.04010504f, 0.01369394f, -0.01190668f, 0.13913651f, 0.18589275f, 0.06211705f, 
    0.16886508f, 0.06704718f, 0.08917468f, 0.30074683f, 0.07432104f, 0.05429659f, 0.01925958f, -0.07762704f, 
    0.09955701f, 0.18389359f, 0.09785733f, 0.12356854f, 0.12858890f, -0.09167065f, -0.19560491f, -0.22352065f, 
    0.09473518f, 0.03326642f, -0.31008938f, -0.10804433f, 0.08321112f, 0.11405402f, 0.10427463f, -0.29765913f, 
    0.07920907f, 0.05248101f, -0.24399795f, 0.02470330f, 0.05799483f, 0.05652231f, -0.04102227f, -0.17304464f, 
    -0.08744442f, -0.10256353f, -0.02313298f, 0.03124148f, -0.19825953f, 0.07410132f, 0.15089060f, 0.09984649f, 
    -0.03238709f, 0.00153894f, -0.01532663f, 0.03361513f, 0.21855925f, -0.03852474f, -0.06131799f, -0.31143397f, 
    -0.07633074f, 0.27048483f, 0.03519978f, 0.02771069f, -0.01681370f, -0.02036718f, 0.06554687f, -0.06892268f, 
    0.00023072f, -0.20834577f, -0.05939456f, -0.39704368f, -0.02036145f, -0.02076095f, 0.03991852f, 0.02527873f, 
    0.00856744f, 0.05067082f, 0.04688549f, 0.00754218f, 0.04670418f, -0.02283619f, 0.12047638f, 0.09240431f, 
    -0.19518207f, -0.07306816f, -0.14751694f, -0.11774255f, 0.00391521f, 0.00828397f, 0.09968320f, -0.03423560f, 
    -0.03868153f, 0.02042868f, 0.03248305f, 0.00768552f, -0.05304191f, 0.14085509f, -0.09274644f, 0.04981705f, 
    0.12910070f, -0.04943877f, -0.10624634f, 0.07011876f, 0.26328480f, 0.00041892f, -0.03625593f, -0.04064498f, 
    -0.05127518f, 0.10765408f, 0.17455380f, -0.12922089f, 0.22989739f, 0.10886268f, -0.13221049f, -0.02976463f, 
    0.04658725f, -0.00392449f, 0.04607520f, 0.12296766f, 0.02546890f, -0.00034508f, -0.08125138f, -0.08629871f, 
    -0.14913848f, -0.26229340f, -0.19280948f, -0.16017893f, -0.14330117f, -0.08857942f, 0.05719454f, 0.15952349f, 
    0.12472083f, 0.28775966f, -0.02427716f, -0.04099808f, 0.01980991f, 0.04251489f, 0.10430074f, 0.04762330f, 
    -0.41848698f, -0.02205318f, 0.02191536f, -0.04363830f, -0.00491008f, 0.17078772f, 0.03123629f, -0.02797008f, 
    -0.05283660f, -0.12024251f, -0.03038884f, -0.16604556f, 0.16177407f, -0.06531893f, 0.11580332f, 0.19365430f, 
    -0.08628060f, -0.02306109f, -0.01686760f, -0.03366476f, -0.03624364f, -0.04194240f, -0.01425144f, -0.05761569f, 
    0.59130847f, 0.05239887f, -0.27781975f, 0.24085285f, 0.11546510f, -0.22489232f, 0.06159895f, -0.16134346f, 
    -0.12470017f, 0.03533420f, 0.07214564f, 0.12604365f, -0.00386951f, 0.08662642f, 0.22194742f, -0.01121787f, 
    -0.10429535f, -0.00967812f, -0.04399712f, 0.03138435f, 0.01310238f, 0.05021268f, 0.00743248f, -0.10362581f, 
    0.01639190f, -0.21051762f, -0.08191101f, -0.01582615f, 0.10940910f, -0.05604785f, 0.10791343f, -0.00363225f, 
    -0.11548892f, 0.00049992f, -0.00727579f, -0.03251277f, -0.10755090f, 0.12936108f, -0.02687650f, 0.16324139f, 
    -0.02791072f, -0.00207222f, 0.03608088f, 0.11196317f, 0.03009119f, 0.11905643f, 0.02574128f, -0.02801340f, 
    0.17884527f, 0.01465693f, 0.14730076f, 0.08822153f, 0.02340447f, -0.12176098f, -0.10552184f, 0.04376138f, 
    0.04032015f, 0.00789743f, 0.01404965f, -0.03819941f, 0.05549921f, 0.04594660f, -0.05428122f, -0.10935505f, 
    0.12634233f, 0.12749642f, -0.05480445f, 0.09949367f, -0.03604363f, -0.03272559f, 0.09744045f, 0.00103763f, 
    -0.17211354f, -0.10293614f, 0.20030817f, -0.13163240f, -0.12944496f, 0.03025132f, 0.21316868f, 0.09601755f, 
    0.00200664f, 0.05910084f, 0.03244695f, 0.01879024f, 0.00742861f, -0.01077659f, -0.04754494f, -0.06606985f, 
    0.01266748f, 0.11233784f, 0.04771270f, 0.11702938f, 0.09654479f, -0.02591289f, 0.11312277f, 0.02654030f, 
    -0.16251756f, -0.26939940f, -0.10005160f, -0.18079558f, 0.16663146f, -0.01878043f, -0.07508235f, -0.03435405f, 
    -0.08259019f, 0.06796028f, -0.05361651f, -0.06861110f, -0.09485362f, -0.01862761f, 0.03962463f, -0.01996287f, 
    -0.07323609f, -0.10196052f, -0.18237297f, -0.12897542f, 0.05849367f, 0.07535741f, 0.06129390f, -0.01173375f, 
    -0.05909747f, 0.28748277f, 0.02780836f, -0.00339829f, 0.23264463f, -0.00621736f, 0.13799456f, 0.19591822f, 
    0.25106081f, -0.06709426f, 0.24067582f, 0.01340442f, 0.01850602f, -0.08284077f, 0.01623572f, -0.05281512f, 
    0.14106004f, 0.01447960f, 0.15219466f, 0.02541211f, -0.01034320f, 0.04749138f, 0.12850314f, 0.25121808f, 
    -0.01519863f, 0.24171758f, -0.11557954f, 0.17869128f, -0.04405153f, -0.02178031f, -0.01650547f, -0.05689007f, 
    -0.08744200f, -0.03083997f, -0.10087844f, -0.04848321f, -0.11696034f, 0.20864837f, 0.09190969f, 0.08799137f, 
    0.08550753f, 0.01048334f, -0.00748505f, -0.03010890f, 0.03943190f, 0.01471940f, -0.02740211f, 0.13364771f, 
    0.06051793f, -0.05342000f, -0.00570107f, -0.04026384f, 0.09482690f, -0.07925010f, 0.08206395f, 0.20219031f, 
    -0.13615590f, 0.04887366f, -0.04359689f, -0.08863916f, 0.12740937f, 0.13705164f, -0.15605441f, -0.09677374f, 
    -0.13937894f, -0.02459943f, -0.02597665f, -0.20372032f, -0.01889203f, -0.01503055f, 0.01341111f, -0.04983236f, 
    0.49498689f, 0.11091294f, 0.12320753f, -0.09691590f, 0.04907364f, 0.03416135f, -0.04153254f, -0.03117521f, 
    0.06146387f, 0.11411583f, 0.10168543f, 0.06553023f, 0.02873335f, 0.11747917f, 0.05292431f, 0.09824906f, 
    -0.07380578f, 0.02120066f, -0.01208461f, 0.02761493f, 0.16586246f, -0.12317075f, 0.03606638f, 0.09056430f, 
    0.15186560f, 0.15003876f, -0.34919044f, -0.14326796f, 0.05872823f, 0.02737078f, 0.17921956f, 0.20439680f, 
    -0.08473937f, -0.12893213f, 0.02648741f, -0.00653611f, 0.03224607f, -0.41322601f, -0.40347451f, -0.03935385f, 
    0.22610746f, 0.06444799f, -0.08670148f, 0.11976206f, -0.05658199f, -0.09681092f, -0.14034700f, -0.05862125f, 
    0.03912178f, -0.32993478f, 0.16375421f, 0.15080956f, -0.00216646f, -0.01217760f, -0.28987497f, -0.24591243f, 
    -0.05350301f, -0.18291681f, -0.26092625f, 0.10117434f, -0.30432805f, -0.08228658f, -0.25298503f, -0.55521697f, 
    -0.01967114f, -0.16418891f, -0.33068547f, -0.19008374f, -0.09503185f, -0.12517066f, -0.05902450f, -0.09877439f, 
    0.05614221f, -0.05062827f, -0.11291081f, 0.13662313f, 0.11084023f, 0.07059762f, 0.08796702f, 0.04047243f, 
    -0.02586428f, -0.10992549f, -0.05028604f, -0.02501510f, 0.06024304f, 0.09757283f, -0.05152705f, -0.15708496f, 
    0.03473694f, -0.07830206f, -0.13690916f, 0.23065172f, -0.02471606f, 0.07689282f, -0.05119724f, 0.02249089f, 
    -0.27392963f, -0.02024958f, -0.10899484f, -0.26019675f, 0.00230264f, -0.00401754f, 0.01594052f, -0.01495157f, 
    -0.10457439f, 0.05197007f, -0.04171564f, 0.03853346f, 0.01585027f, 0.07110651f, 0.13540412f, 0.15427510f, 
    -0.07958436f, -0.01264930f, 0.00111720f, -0.04963644f, 0.02584368f, -0.07183996f, 0.03839834f, -0.08576762f, 
    0.09948635f, 0.12523866f, 0.06239719f, 0.04266785f, -0.18443525f, 0.25165403f, 0.00079890f, 0.13571176f, 
    0.22683562f, 0.05351930f, 0.10287569f, -0.06030985f, 0.00467364f, 0.03472875f, 0.08580657f, 0.09909492f, 
    -0.04126961f, -0.34478420f, -0.10872456f, -0.05115865f, -0.02524833f, 0.08908445f, 0.04537627f, 0.04369234f, 
    0.05088173f, -0.25123993f, 0.10703944f, 0.01598062f, -0.00800244f, 0.09422106f, -0.07703491f, -0.03924230f, 
    -0.05345679f, -0.00836626f, -0.20237207f, -0.01474403f, -0.21134046f, 0.09251289f, -0.39046934f, 0.03952369f, 
    0.14811282f, 0.27277628f, -0.14148198f, -0.13586330f, 0.05016213f, 0.13907123f, 0.08819830f, -0.05020026f, 
    -0.30758500f, 0.18454604f, 0.15336925f, -0.01705397f, -0.08865976f, 0.09582856f, -0.02535737f, 0.03955917f, 
    -0.05495064f, -0.06464054f, 0.00417243f, -0.04702801f, 0.45250270f, 0.24941890f, 0.28576383f, 0.39818475f, 
    -0.14670394f, -0.05483322f, -0.06757426f, 0.05281523f, -0.01169539f, -0.03485899f, 0.11128423f, 0.05008172f, 
    0.55600095f, -0.31631175f, -0.33786795f, -0.02090357f, 0.11292482f, 0.00615010f, 0.05070037f, -0.03693172f, 
    0.03912668f, -0.00304695f, 0.01308358f, 0.01926137f, -0.08323831f, -0.02868459f, 0.17060664f, -0.11563626f, 
    0.03597844f, 0.00011474f, -0.07743457f, 0.02841186f, -0.03530835f, -0.00716383f, -0.00750269f, -0.12678833f, 
    0.19745912f, -0.05158518f, 0.05443618f, -0.04822721f, -0.00880652f, -0.02081732f, 0.14706206f, 0.15042406f, 
    -0.03702354f, 0.04446702f, 0.13784637f, 0.10810352f, 0.18220174f, 0.04075835f, 0.09810697f, 0.04207577f, 
    0.04578525f, 0.00611494f, 0.16971895f, 0.05402667f, 0.01248990f, 0.12497050f, -0.02027754f, 0.05249234f, 
    0.27378005f, 0.10699079f, -0.04944327f, -0.13344958f, 0.07632869f, 0.02015625f, 0.07381565f, -0.14521447f, 
    0.08362615f, 0.04178683f, -0.09252015f, 0.09215277f, 0.12175746f, 0.16086349f, -0.08163304f, 0.06040386f, 
    0.06395163f, 0.11502989f, 0.09746902f, -0.07863426f, 0.00810353f, -0.06804854f, -0.08031105f, -0.02669006f, 
    -0.05351143f, 0.00424268f, 0.10921444f, -0.00945980f, -0.00410185f, 0.05660098f, -0.04711934f, -0.00620455f, 
    -0.04119055f, -0.10195180f, 0.14663132f, 0.08223704f, -0.02110882f, -0.15035115f, 0.02696825f, 0.04029389f, 
    0.16265501f, 0.07853927f, -0.15678237f, -0.00256267f, 0.04128834f, 0.06279733f, 0.07890996f, -0.00182307f, 
    -0.19978812f, -0.24713822f, -0.30894408f, -0.00965984f, 0.01799108f, 0.13966577f, 0.06068066f, -0.01478732f, 
    -0.17114693f, -0.10857803f, -0.05297492f, -0.08829543f, 0.00723727f, 0.01363425f, 0.00919524f, -0.01026171f, 
    -0.08245742f, -0.02986030f, 0.00024841f, 0.05731998f, 0.04556882f, -0.00342358f, -0.08014344f, 0.10221322f, 
    0.14283268f, 0.21068560f, 0.03154596f, -0.17915958f, 0.09938756f, -0.20623581f, 0.09983907f, -0.10820743f, 
    0.24138558f, -0.12418418f, 0.16272976f, 0.00229950f, -0.11357192f, 0.04563333f, -0.21110314f, 0.04631958f, 
    -0.01180449f, 0.10125633f, 0.17183885f, 0.09802285f, 0.02792654f, 0.04973902f, -0.02431927f, 0.02974990f, 
    -0.05559355f, 0.00203406f, -0.19578163f, -0.00936823f, 0.02045993f, 0.02902804f, -0.02367409f, 0.02117165f, 
    -0.19630155f, 0.04784925f, -0.11469642f, -0.02318426f, 0.13041203f, 0.43010515f, -0.36246377f, 0.04754624f, 
    0.00135472f, -0.10272830f, -0.12880567f, -0.15465447f, 0.08485968f, 0.01033725f, -0.02615540f, 0.00285224f, 
    0.02366856f, 0.14470991f, 0.33717248f, -0.26215723f, 0.19020163f, 0.00486229f, 0.03231592f, 0.09081559f, 
    0.03288747f, 0.03148633f, -0.04334622f, 0.03486504f, 0.03580782f, 0.09056466f, -0.04629859f, 0.10428011f, 
    -0.03614035f, -0.13760889f, -0.09839348f, -0.05213699f, -0.00958247f, 0.02098135f, 0.02335688f, 0.01408848f, 
    -0.04032473f, 0.01494068f, -0.09642155f, 0.07389803f, -0.02221621f, -0.03320621f, 0.01876019f, 0.05652380f, 
    0.06872168f, -0.03712497f, 0.10433231f, -0.13773108f, 0.30385256f, 0.01453821f, 0.09866386f, 0.09316643f, 
    0.05074249f, -0.00172675f, -0.05870773f, 0.05735914f, -0.03457583f, -0.06301385f, -0.09089234f, 0.00982275f, 
    -0.16047367f, -0.26115292f, -0.24553922f, -0.36185321f, 0.07526538f, 0.02388751f, -0.07906445f, -0.01541735f, 
    0.06918523f, 0.01237874f, 0.00975985f, 0.06085435f, -0.08464513f, -0.36060199f, -0.03267353f, -0.01444524f, 
    0.04034407f, 0.07930277f, 0.16911538f, -0.10750353f, -0.01349550f, 0.06666274f, 0.11297768f, 0.04329626f, 
    0.04901062f, -0.19460787f, -0.28066561f, -0.35871243f, 0.00868080f, 0.06971376f, 0.23698503f, 0.13854453f, 
    0.06432504f, 0.09143804f, 0.20825024f, 0.23295711f, -0.28799334f, 0.00776213f, -0.21112478f, -0.21149765f, 
    -0.08515453f, -0.05780178f, 0.10300512f, 0.17693657f, -0.05437952f, 0.13445269f, 0.02741586f, 0.15259808f, 
    0.04216473f, -0.08808525f, 0.04344527f, -0.13044147f, 0.14616750f, 0.17413902f, 0.07872184f, 0.00986707f, 
    -0.07354766f, -0.12198173f, -0.04351033f, 0.01529502f, -0.07798751f, -0.04116074f, -0.19878162f, -0.08456555f, 
    0.22101760f, -0.01347813f, 0.02133685f, 0.09264708f, -0.00992574f, -0.01548553f, -0.09532637f, -0.00542197f, 
    -0.27883309f, -0.05173350f, -0.17780907f, -0.29417926f, -0.05186565f, -0.05225002f, -0.02737175f, 0.16188842f, 
    0.09968740f, 0.05513040f, -0.02683979f, 0.01855412f, 0.01260125f, 0.13111070f, 0.05382837f, 0.06452131f, 
    0.06680188f, -0.05808088f, -0.10094481f, -0.06611104f, -0.08161026f, 0.01394089f, -0.05676412f, 0.02225712f, 
    0.03665133f, -0.08195050f, 0.01497580f, 0.17692670f, 0.18278800f, 0.06581410f, 0.08398591f, 0.04014254f, 
    0.10106128f, 0.18994813f, 0.20068128f, 0.06258150f, -0.29546398f, 0.08359174f, -0.03707229f, 0.04063366f, 
    -0.01885288f, 0.12906750f, -0.18709823f, 0.00384943f, -0.03605019f, -0.15212536f, 0.22111014f, 0.02564907f, 
    0.03271127f, 0.15000039f, 0.07746904f, -0.02635199f, -0.05860266f, -0.02749771f, -0.01880530f, 0.10038225f, 
    0.26610145f, 0.08176697f, 0.16220936f, 0.04580484f, -0.01435880f, -0.00350945f, 0.19926776f, 0.07992348f, 
    -0.01274533f, -0.09827224f, 0.06223806f, 0.08643114f, -0.04068641f, -0.02284240f, -0.16014434f, 0.04973179f, 
    0.30079675f, -0.07359736f, -0.06568323f, 0.00440370f, 0.13020088f, 0.15732795f, 0.19032499f, 0.13443169f, 
    0.05745125f, 0.11733311f, 0.03279611f, 0.11731577f, 0.23390608f, 0.14562342f, 0.00397687f, 0.01424005f, 
    0.06586546f, -0.07806391f, -0.15739156f, -0.06728583f, -0.05868842f, -0.07566486f, 0.05995707f, -0.04447528f, 
    -0.25547144f, -0.14722349f, 0.17380467f, -0.07234225f, 0.05142627f, -0.18920322f, -0.01873544f, -0.00728949f, 
    0.19493765f, 0.17752740f, 0.09582753f, 0.05719407f, -0.17006156f, -0.02928859f, -0.30303395f, 0.15230818f, 
    0.10924692f, 0.03330286f, -0.02672435f, 0.00000868f, 0.03720243f, -0.02129303f, -0.00032331f, 0.15440243f, 
    -0.10226344f, 0.11867496f, 0.00617376f, -0.15338527f, 0.10409502f, 0.10762523f, -0.06197165f, -0.20115346f, 
    -0.05734440f, -0.04373941f, 0.01688274f, 0.00309044f, -0.08777339f, 0.04860039f, 0.14661027f, -0.23067442f, 
    0.01951946f, 0.13862532f, 0.06996024f, -0.08207720f, 0.14166836f, 0.01579311f, 0.06314494f, 0.04035672f, 
    -0.11901908f, -0.14117700f, 0.21286710f, 0.04328355f, -0.03642596f, -0.05198439f, -0.00636673f, 0.11680994f, 
    0.07757102f, -0.17574173f, 0.02823611f, 0.18570270f, -0.33581284f, -0.01681290f, 0.11949434f, -0.10267008f, 
    -0.00342385f, -0.09312696f, 0.05815459f, 0.29570210f, 0.02911159f, 0.13814983f, 0.05181435f, -0.08127809f, 
    -0.09577576f, -0.01011169f, -0.37533683f, -0.34141845f, 0.22249222f, 0.10782293f, 0.02898054f, -0.06294367f, 
    0.14633347f, -0.04273222f, -0.06392781f, -0.19245538f, -0.05907818f, 0.11979432f, 0.17423332f, -0.17110416f, 
    -0.05920394f, 0.05250544f, -0.02075266f, 0.04874505f, -0.05914861f, -0.08490461f, -0.09205163f, -0.05114910f, 
    -0.20527320f, 0.08817921f, 0.46848652f, 0.07723708f, -0.08628795f, -0.02504336f, 0.01531947f, 0.17620976f, 
    0.03421687f, 0.08927529f, 0.07909771f, 0.11544588f, -0.13924380f, -0.15190493f, -0.03701861f, 0.21534318f, 
    -0.10553198f, -0.08538308f, -0.16880915f, -0.01966641f, 0.01440849f, 0.11697040f, 0.09293377f, -0.00201005f, 
    -0.16332407f, -0.40043905f, 0.33178064f, 0.23000513f, 0.02983843f, -0.04090403f, 0.01653611f, 0.10013930f, 
    0.13986561f, 0.03918197f, 0.05353083f, 0.09124780f, -0.26813680f, 0.17080584f, 0.21732117f, -0.23838112f, 
    0.00722916f, -0.09240690f, -0.08707151f, -0.24688393f, -0.01459235f, -0.15097569f, -0.06789778f, 0.01964087f, 
    0.05101349f, -0.07010941f, 0.30738786f, -0.10200273f, -0.11665040f, -0.03437973f, 0.10805331f, 0.00319840f, 
    0.19687782f, 0.08770330f, -0.00677697f, -0.00546555f, 0.00470984f, -0.16692203f, 0.16739191f, -0.13347073f, 
    0.06456013f, 0.07845690f, -0.03407448f, 0.04971087f, -0.06771240f, 0.09676516f, -0.00812050f, -0.03141506f, 
    -0.13475804f, -0.26371482f, -0.28477037f, 0.15707378f, 0.16823314f, 0.17094557f, -0.16084068f, 0.11394259f, 
    0.11002527f, 0.04188419f, 0.08570873f, 0.01902254f, -0.20434584f, -0.36032867f, 0.28827456f, 0.15303162f, 
    0.19204585f, 0.01106026f, -0.03568298f, 0.09862483f, -0.14884968f, -0.09271625f, 0.08029708f, 0.04257656f, 
    0.32578751f, 0.30773288f, 0.01241542f, 0.23888670f, -0.08497755f, -0.18150990f, -0.07378335f, -0.04120894f, 
    0.04881022f, 0.05147550f, 0.02974530f, 0.00267197f, -0.17213339f, -0.11376015f, -0.15664466f, 0.22549033f, 
    -0.20571929f, -0.20768186f, -0.02709694f, -0.07479388f, 0.00400256f, 0.04386267f, -0.13824522f, 0.09822578f, 
    0.02711027f, 0.08985476f, -0.14372714f, -0.25874647f, 0.13169788f, 0.08645609f, 0.21891707f, 0.06752910f, 
    0.02375728f, 0.14459744f, -0.03067764f, -0.08254716f, -0.05157804f, -0.02842840f, -0.14262770f, -0.06160826f, 
    0.23788364f, 0.02676218f, 0.06253348f, 0.15932064f, -0.02388406f, 0.12369360f, 0.04133592f, 0.00476132f, 
    -0.01515783f, 0.19242680f, 0.16335148f, 0.19110592f, 0.13865812f, -0.09398685f, 0.03797565f, -0.15617368f, 
    -0.02792337f, 0.07967510f, -0.12713905f, 0.14463750f, 0.15932554f, -0.08300415f, 0.15174702f, -0.09116974f, 
    0.10140970f, 0.06776216f, -0.05543685f, -0.13278173f, -0.02301264f, 0.03821240f, 0.14132854f, 0.01608039f, 
    0.01651692f, -0.13332377f, -0.35409832f, 0.06821582f, -0.03645572f, 0.09091306f, 0.15288422f, 0.04318895f, 
    0.08177231f, -0.07201376f, -0.16202489f, -0.09628898f, 0.29912388f, 0.13132206f, 0.04757436f, -0.10516468f, 
    -0.02583440f, 0.24715702f, -0.10311154f, -0.01152747f, -0.04753766f, -0.10842529f, -0.19857979f, -0.28039441f, 
    0.18864554f, 0.11821581f, 0.17155704f, -0.04218537f, -0.04974443f, 0.11752164f, 0.07969540f, -0.05117900f, 
    0.12050568f, 0.01605220f, -0.01778133f, 0.03385160f, -0.21526760f, -0.25785124f, -0.01105285f, 0.13802268f, 
    -0.23592894f, -0.10817041f, -0.05165522f, -0.07779291f, -0.06094769f, 0.13653475f, 0.09386973f, -0.07956004f, 
    0.08128648f, 0.10024622f, 0.05562741f, 0.05338025f, 0.07564803f, 0.11512011f, -0.01292005f, -0.04057570f, 
    0.15434538f, -0.02978576f, -0.01737267f, 0.04433680f, 0.34350467f, 0.11453909f, 0.17519471f, -0.08105412f, 
    0.18381812f, -0.02463878f, 0.06320731f, -0.09054461f, -0.05174268f, 0.02540500f, -0.22081777f, -0.18291101f, 
    0.03702713f, -0.05234214f, 0.08436406f, 0.23795034f, -0.01394321f, -0.03004400f, 0.08770993f, -0.00067140f, 
    0.12398439f, 0.20461564f, -0.01336224f, 0.20906636f, -0.06383566f, -0.00674119f, -0.34738305f, -0.00196690f, 
    0.04488150f, 0.26379740f, 0.04170327f, -0.01511935f, 0.00069556f, -0.00842284f, 0.10312172f, -0.02410832f, 
    -0.33428490f, 0.16840203f, -0.13669860f, -0.17551880f, -0.04631005f, -0.04948904f, -0.09425559f, 0.12569673f, 
    0.06747103f, 0.04658707f, 0.00573599f, -0.02562492f, -0.22999372f, -0.02537357f, -0.00422259f, 0.21902728f, 
    -0.06026259f, 0.01107873f, 0.17536505f, -0.00057018f, 0.04658377f, 0.01431759f, -0.10574574f, -0.18772322f, 
    0.25456789f, 0.38379273f, 0.01752260f, 0.36196816f, -0.03156776f, 0.02439141f, 0.03853579f, -0.01478622f, 
    -0.01306073f, 0.03193628f, 0.20997548f, 0.01042444f, 0.15892591f, 0.07524236f, -0.02507019f, 0.01678320f, 
    -0.06594095f, -0.03007098f, -0.04823476f, 0.08332953f, 0.12969913f, -0.08777761f, 0.02730541f, -0.00594934f, 
    -0.36122215f, -0.23651259f, -0.11175612f, -0.01110837f, 0.01293963f, -0.18094884f, 0.17598765f, -0.09262928f, 
    -0.16669342f, -0.01215681f, 0.08748931f, 0.00158433f, -0.40202776f, -0.21006468f, 0.02223416f, 0.09029141f, 
    0.08872910f, -0.04841792f, -0.11416431f, -0.02830715f, -0.11538372f, -0.01652134f, -0.10746012f, -0.03654058f, 
    -0.01440055f, 0.16122730f, 0.08083668f, 0.18367071f, 0.09993203f, -0.05716053f, -0.05552031f, -0.09462927f, 
    -0.04002918f, 0.16879356f, 0.00709594f, -0.07016252f, 0.01155435f, -0.01738662f, -0.00964219f, 0.08923654f, 
    -0.10785851f, 0.02169613f, -0.10642676f, -0.12912534f, 0.14059538f, 0.06368949f, -0.01420597f, 0.07685406f, 
    0.08896283f, -0.17942993f, 0.02892569f, 0.02733842f, -0.03602950f, -0.12290238f, 0.11237632f, 0.05207399f, 
    -0.00627581f, -0.23855674f, 0.01830169f, 0.04266664f, 0.14380823f, 0.25867951f, 0.03300828f, -0.20402427f, 
    0.06474691f, -0.02977531f, 0.01460552f, 0.16348249f, -0.07395709f, 0.08452311f, -0.12759562f, -0.02698313f, 
    0.09525213f, 0.13391255f, 0.11414111f, 0.12813745f, 0.03204397f, -0.08682042f, -0.12142579f, 0.02014853f, 
    -0.00188092f, 0.13128464f, -0.00918969f, 0.07063296f, 0.02732573f, -0.00539599f, 0.03636862f, 0.10215405f, 
    -0.05161787f, 0.10819586f, -0.02939372f, -0.10470498f, -0.00293999f, -0.09436129f, -0.02982718f, -0.07944946f, 
    -0.22079870f, -0.07903510f, -0.07960369f, 0.35886553f, 0.07388535f, 0.23964784f, -0.11955740f, 0.27941063f, 
    0.15440351f, 0.10831287f, 0.24535951f, -0.03797127f, 0.12996060f, 0.33048287f, 0.14856741f, 0.01965713f, 
    0.19969216f, -0.19733709f, 0.01756899f, 0.10335331f, -0.27416661f, 0.10252693f, -0.17070957f, -0.00374138f, 
    -0.12829298f, -0.05608946f, -0.03300214f, 0.38066769f, 0.00100279f, -0.00839983f, -0.04760705f, -0.04874612f, 
    -0.01809831f, 0.14121972f, 0.22974549f, 0.23832986f, -0.32321024f, -0.12709224f, -0.25574568f, 0.05168069f, 
    -0.05232586f, 0.17028829f, 0.15214545f, 0.11934681f, -0.05695807f, 0.03750756f, -0.05107130f, -0.08615761f, 
    -0.19876260f, 0.00426750f, -0.39088106f, -0.11231131f, 0.04875147f, 0.04330468f, 0.13774289f, 0.12599051f, 
    0.01432811f, -0.02881847f, 0.13255137f, 0.04445294f, 0.19775254f, 0.06956350f, -0.23087214f, 0.03732012f, 
    0.01704496f, 0.07658974f, 0.02618441f, -0.01508187f, 0.01377058f, 0.03223849f, 0.03514539f, -0.09620219f, 
    -0.02149285f, 0.25422215f, -0.00568502f, 0.05505645f, -0.00876513f, 0.06730948f, -0.01776560f, 0.14362049f, 
    -0.00079686f, 0.02783175f, 0.14406559f, -0.05008921f, 0.07158595f, -0.06359625f, -0.04902746f, -0.06571448f, 
    -0.07979765f, 0.06825821f, -0.05306023f, 0.01639940f, 0.06035852f, 0.07136189f, 0.05960459f, 0.02204080f, 
    -0.14361158f, -0.37287086f, -0.17434733f, -0.08972709f, 0.12830660f, -0.01139643f, -0.06618980f, -0.12242072f, 
    0.03930303f, -0.07250927f, -0.06323500f, -0.06941599f, -0.16547741f, -0.06121932f, -0.25671726f, 0.19166364f, 
    -0.06548099f, -0.04070882f, -0.04096563f, -0.08226112f, -0.06549409f, -0.06684158f, -0.07399526f, 0.02973632f, 
    0.06374461f, 0.15082461f, -0.16004561f, -0.14124309f, 0.06571308f, 0.08013341f, 0.18131383f, 0.00661288f, 
    -0.14744000f, 0.00529369f, 0.24291275f, 0.04569929f, 0.06752206f, 0.02007976f, -0.11666808f, 0.17415297f, 
    0.01929059f, 0.03099262f, 0.31657681f, -0.10510965f, 0.05047362f, -0.03254955f, -0.03778730f, 0.16576290f, 
    0.20800789f, -0.12386007f, 0.13125202f, -0.10728838f, 0.14638226f, 0.06532748f, -0.10524542f, 0.02308945f, 
    -0.17751901f, -0.09161323f, 0.16459005f, -0.06373680f, 0.04331576f, -0.00764897f, 0.06542046f, 0.31863558f, 
    0.11761031f, -0.15407927f, 0.07953602f, -0.01839854f, -0.05339103f, -0.08770888f, -0.12724555f, -0.10766210f, 
    -0.12833412f, 0.11716087f, -0.06735998f, 0.33816844f, 0.11452813f, 0.06192797f, 0.16333541f, 0.09787101f, 
    0.14918116f, 0.06951057f, -0.15604471f, -0.09031425f, 0.05174007f, 0.10842472f, -0.06680746f, 0.02714819f, 
    0.07358459f, 0.03537110f, 0.05837214f, -0.01546763f, 0.01718732f, -0.01014568f, 0.02260376f, 0.06970869f, 
    -0.31902766f, 0.34335589f, -0.29311579f, 0.16566651f, 0.23016544f, 0.01096526f, 0.07259305f, 0.09462942f, 
    0.08001679f, 0.01885101f, 0.15573992f, 0.08923456f, -0.13972320f, 0.01533459f, 0.09141558f, 0.27183267f, 
    0.25201994f, 0.06354806f, -0.21368667f, -0.02538675f, -0.16927016f, 0.06169543f, 0.12090556f, -0.00113498f, 
    -0.11250335f, 0.14569800f, -0.18372841f, -0.12102271f, -0.00561323f, 0.02642102f, -0.02224293f, 0.10707807f, 
    0.00721897f, 0.20923066f, 0.17721203f, 0.15101807f, -0.13991174f, 0.17628002f, -0.14276302f, 0.06564610f, 
    -0.09790761f, -0.15688221f, 0.10519498f, -0.15628587f, -0.15722120f, -0.20451635f, 0.02181792f, -0.11090723f, 
    0.13282491f, 0.16867471f, -0.19987498f, -0.13244802f, -0.07885759f, -0.10647295f, 0.09375548f, 0.08267584f, 
    0.06086144f, 0.11091673f, 0.00414748f, 0.11951277f, 0.01209832f, 0.40563378f, -0.12510681f, 0.03763497f, 
    0.04282126f, 0.05616952f, 0.00489683f, -0.08192086f, -0.02195028f, 0.03437838f, 0.02525229f, -0.05070244f, 
    0.01501485f, 0.00889443f, -0.11289805f, 0.22114675f, 0.00205401f, 0.12534595f, -0.11145646f, 0.19937010f, 
    -0.12952378f, -0.07610586f, -0.00706636f, -0.05848633f, 0.18057896f, -0.11821897f, 0.15441532f, 0.05233791f, 
    -0.15091951f, -0.02394330f, -0.08348503f, 0.09631243f, 0.05544622f, -0.04925261f, 0.11614826f, -0.15130526f, 
    -0.10247327f, -0.39658704f, -0.02582801f, 0.18930250f, 0.00958952f, 0.03602406f, -0.19563957f, -0.15915008f, 
    -0.02623201f, -0.09010390f, -0.09144615f, 0.01149123f, -0.27530864f, 0.03150103f, 0.02566248f, 0.34400368f, 
    -0.06599279f, 0.00610333f, -0.02944348f, -0.06999206f, -0.06718439f, -0.06596540f, 0.04325558f, 0.01924376f, 
    -0.13659945f, -0.07468974f, -0.12234641f, -0.02425488f, 0.08331279f, -0.02557373f, 0.03337554f, 0.10334018f, 
    -0.01620850f, 0.07683492f, 0.16792689f, 0.20742290f, -0.00077585f, -0.11290519f, -0.06630073f, 0.10465093f, 
    0.07463232f, -0.01400447f, 0.15644498f, -0.02559601f, -0.05210578f, 0.00732076f, -0.04607140f, 0.11228663f, 
    0.13926795f, -0.10363095f, 0.27127841f, -0.12306854f, 0.06273238f, 0.08647671f, -0.06116171f, 0.13023245f, 
    -0.03247182f, -0.14197582f, 0.05279548f, -0.08693326f, -0.18342482f, 0.03841151f, 0.15252887f, 0.22276041f, 
    0.01320978f, -0.05008042f, 0.02882608f, 0.04412804f, -0.02006442f, 0.06892630f, -0.14652731f, 0.06213046f, 
    -0.04689562f, -0.00701660f, -0.08178742f, 0.27968466f, 0.14462972f, -0.17436878f, -0.01775402f, 0.11189429f, 
    0.05632149f, 0.01295904f, -0.03579070f, 0.02785622f, 0.06098771f, 0.05213814f, -0.14716417f, 0.04649395f, 
    0.07471474f, -0.03084759f, 0.01577872f, -0.06645177f, -0.11661261f, 0.08908333f, -0.08509888f, -0.06763157f, 
    -0.24587886f, 0.29791585f, -0.12667498f, 0.27638829f, 0.34348997f, 0.15994997f, 0.02170927f, -0.01999965f, 
    0.03723586f, 0.07172961f, 0.11477914f, 0.04487563f, -0.14741017f, 0.02890280f, -0.05076455f, 0.11516666f, 
    0.03047747f, -0.03626611f, -0.19937871f, -0.00321138f, -0.22176139f, -0.06873173f, 0.25818151f, 0.02773564f, 
    -0.03346287f, 0.18722388f, -0.14549805f, -0.02214012f, 0.06669375f, 0.00297839f, -0.04122747f, 0.09870370f, 
    0.04328032f, 0.08350177f, 0.23777230f, 0.17826577f, -0.29210845f, 0.03621969f, 0.12072236f, 0.06658725f, 
    -0.08386478f, -0.10695010f, -0.02191156f, 0.10013080f, -0.20233485f, 0.03261623f, -0.04505817f, -0.04558566f, 
    0.35707206f, -0.04965134f, -0.00829667f, 0.14842886f, -0.01245602f, -0.12131326f, 0.12755018f, 0.04740019f, 
    0.16616312f, 0.23502630f, -0.01783010f, 0.02761441f, 0.14728731f, 0.44672704f, -0.16723423f, -0.17322960f, 
    -0.06075889f, -0.06813743f, -0.01186576f, -0.09093989f, -0.11480062f, -0.04487316f, -0.03999324f, -0.11781695f, 
    0.02642751f, -0.05667978f, 0.01066075f, -0.05312400f, 0.01323101f, -0.04951103f, 0.05988580f, 0.05811570f, 
    0.01036847f, 0.00667007f, -0.08619510f, -0.03801052f, -0.00751023f, -0.06120708f, -0.02517620f, 0.01655708f, 
    0.01827658f, 0.01260509f, 0.04258348f, -0.05997083f, 0.01069858f, -0.01829826f, 0.04786992f, -0.05987805f, 
    -0.03948641f, -0.01999025f, 0.00920940f, 0.02139138f, -0.07326908f, -0.06508063f, 0.04587078f, 0.01477950f, 
    -0.04113149f, 0.00157483f, 0.04194753f, 0.05105253f, 0.00601299f, 0.01884900f, -0.00441610f, -0.02759113f, 
    -0.06416389f, -0.03368741f, -0.03209432f, -0.01554154f, -0.05242882f, 0.02721306f, -0.04659174f, 0.00264399f, 
    -0.05703338f, 0.04437940f, 0.02890786f, -0.07691865f, -0.03262142f, 0.01736482f, 0.02823455f, -0.00282741f, 
    -0.05149804f, -0.00418743f, 0.02330697f, -0.01915251f, 0.02145388f, 0.01235297f, 0.06295311f, -0.01460090f, 
    0.06590277f, 0.02493302f, -0.07581712f, -0.02096047f, 0.04945920f, 0.03972580f, -0.06944717f, -0.06688032f, 
    -0.06034689f, 0.04871583f, 0.04611316f, 0.04530592f, 0.01495473f, -0.07760119f, 0.03904271f, -0.08011910f, 
    -0.00600648f, -0.04961784f, 0.05273996f, 0.02431541f, 0.00230442f, -0.02566785f, -0.06506400f, 0.05050097f, 
    0.03989605f, 0.03795157f, -0.02044302f, -0.07866594f, 0.03203005f, 0.01926482f, -0.02955987f, -0.04207575f, 
    0.00396904f, -0.03564917f, -0.05211582f, -0.01979179f, -0.05345676f, -0.07963286f, 0.01611301f, -0.02815092f, 
    0.05498374f, -0.07997169f, 0.02974861f, -0.00772738f, -0.07891924f, -0.04479017f, -0.07193673f, -0.00483863f, 
    -0.03338115f, 0.04862023f, -0.05017022f, -0.05048288f, 0.05173775f, -0.01386319f, -0.01908565f, -0.01225694f, 
    0.03881042f, -0.00237092f, -0.00829121f, 0.02060710f, 0.00377589f, 0.06020774f, -0.01494597f, -0.05098853f, 
    -0.04603235f, 0.00216215f, -0.05890780f, 0.04035121f, 0.02824028f, -0.06067892f, -0.02876977f, 0.03844108f, 
    -0.00510464f, 0.05580972f, -0.04564632f, -0.04346766f, 0.03982263f, -0.01171558f, -0.04676889f, -0.04501783f, 
    -0.06161598f, 0.04902111f, -0.08375259f, -0.07518296f, 0.03531491f, -0.06877160f, -0.06690121f, 0.01745660f, 
    0.05848516f, -0.05604479f, -0.01851101f, -0.04930049f, -0.00762007f, -0.07043547f, -0.04894399f, -0.06722843f, 
    0.00943748f, -0.01319280f, 0.05921482f, 0.05305711f, 0.01900178f, -0.05484924f, -0.01283096f, -0.01071081f, 
    -0.04664515f, -0.05047949f, 0.05614145f, -0.02440059f, -0.03543961f, 0.00638202f, -0.02856635f, 0.04678530f, 
    -0.01059651f, -0.04944680f, -0.01425379f, -0.06333464f, -0.00066050f, -0.00636839f, 0.04511854f, 0.04455568f, 
    0.06434997f, 0.06290588f, 0.03023028f, -0.00390697f, 0.04128535f, -0.02510783f, -0.04052743f, -0.00377005f, 
    0.37140340f, 0.10417353f, -0.12223291f, 0.11791845f, 0.04300094f, -0.11564805f, -0.01177003f, -0.17003086f, 
    0.07622217f, 0.01860574f, 0.07729203f, 0.16314767f, -0.05721743f, 0.12229372f, 0.27404740f, 0.00652984f, 
    -0.03624384f, -0.06405801f, -0.05371252f, -0.06562714f, -0.18467385f, -0.07693972f, -0.07619958f, -0.20650308f, 
    0.16195333f, 0.10149843f, 0.10071764f, -0.04923513f, 0.06792610f, 0.03296079f, 0.14487989f, 0.09821261f, 
    -0.07850284f, 0.01194008f, -0.04869423f, 0.05911236f, 0.09287824f, 0.28055114f, 0.16484000f, 0.13680461f, 
    0.10167427f, -0.00358397f, 0.15953976f, 0.12156682f, -0.09364351f, 0.07104376f, 0.00622424f, 0.02604760f, 
    0.17497782f, 0.11653923f, 0.06268933f, -0.04782511f, 0.04884719f, 0.05927777f, -0.10391169f, -0.04242200f, 
    -0.09391525f, -0.20767505f, -0.02056889f, -0.15732157f, -0.02747987f, 0.23482223f, -0.10147001f, -0.09250215f, 
    0.15448937f, 0.18313029f, -0.06904936f, -0.00199198f, -0.02295228f, 0.12314130f, 0.11709564f, -0.11822221f, 
    -0.10118018f, -0.16384943f, -0.07824983f, -0.23685266f, -0.05247260f, 0.03573075f, 0.15250510f, 0.12924208f, 
    -0.02298428f, 0.14730075f, 0.14786589f, 0.16941291f, 0.11494204f, -0.14023273f, -0.04614329f, -0.11749011f, 
    0.14410926f, 0.17576766f, -0.01637941f, 0.00910506f, 0.05914468f, -0.01799267f, 0.19076672f, 0.00756066f, 
    -0.47340643f, -0.19558595f, -0.13158733f, -0.32205752f, 0.13355477f, -0.02367218f, -0.02956338f, -0.01604448f, 
    -0.02879582f, 0.13197076f, -0.08517034f, -0.02151084f, -0.13913372f, 0.06542327f, 0.17338257f, 0.06441660f, 
    -0.04926993f, -0.14317514f, -0.13095789f, -0.19569235f, 0.00521968f, 0.11217515f, 0.09965547f, -0.00816822f, 
    -0.06290598f, 0.25573251f, 0.01574291f, 0.03497067f, 0.17269759f, -0.00755170f, 0.15304215f, -0.03218690f, 
    0.06412806f, 0.05744864f, 0.14305970f, 0.07125757f, 0.01822279f, -0.12157356f, -0.07219087f, -0.10677028f, 
    0.17102909f, 0.30242985f, -0.02898349f, -0.12235662f, 0.02878656f, 0.09244201f, 0.13903578f, 0.23028833f, 
    -0.03856769f, 0.25808465f, -0.09682302f, 0.10540460f, -0.09426548f, -0.00200811f, 0.09610364f, -0.19783360f, 
    -0.23151736f, -0.19527397f, -0.15931982f, -0.19836013f, -0.12034129f, 0.13596220f, -0.10648606f, 0.19705026f, 
    0.23092833f, 0.04173550f, 0.09063055f, -0.16777143f, 0.10524883f, -0.02522662f, 0.11618342f, 0.11671468f, 
    0.05842342f, 0.22097862f, 0.24186514f, -0.10374944f, 0.09484002f, 0.04948451f, -0.02550685f, 0.29985020f, 
    -0.15868515f, -0.15481023f, -0.09889475f, -0.29357389f, 0.06948925f, -0.04465824f, 0.07783252f, 0.04818252f, 
    -0.13920201f, -0.05696505f, 0.02125490f, -0.18640150f, -0.02886705f, -0.05540259f, 0.01646817f, 0.11136656f, 
    -0.18352650f, 0.27151099f, 0.12702182f, 0.03810742f, 0.08189677f, -0.13281080f, 0.01526495f, -0.15546815f, 
    0.13746074f, 0.05414884f, 0.00508224f, 0.05384896f, -0.09439716f, 0.09364892f, -0.18046051f, -0.04348388f, 
    -0.05996195f, -0.00764359f, 0.02974403f, 0.03360453f, 0.03586502f, -0.06363247f, -0.05398435f, -0.14533252f, 
    -0.02397144f, -0.15892363f, -0.50529319f, -0.61710584f, 0.16708332f, 0.08287344f, 0.00588022f, 0.00027425f, 
    -0.17454112f, 0.01525792f, 0.04272386f, 0.04932659f, 0.06980263f, -0.06872605f, -0.33291781f, -0.11171994f, 
    0.10260382f, 0.00249003f, -0.00609016f, 0.04670826f, -0.04388881f, 0.00922652f, -0.00858753f, 0.03710311f, 
    0.02082325f, 0.05103022f, 0.08746740f, 0.23083618f, -0.01160079f, -0.01293169f, 0.06848922f, 0.04325801f, 
    0.09299982f, 0.03030676f, 0.05917729f, -0.15852739f, -0.22191097f, -0.19653353f, 0.06854369f, -0.06499424f, 
    0.07678575f, 0.17359720f, -0.13127646f, -0.07804370f, 0.09615815f, 0.12938614f, 0.06290915f, 0.14347069f, 
    -0.07002546f, -0.00048894f, -0.25103018f, -0.08592349f, 0.11314961f, -0.00144063f, 0.04998025f, -0.02969993f, 
    0.19466867f, -0.08359081f, -0.05111054f, -0.18255733f, 0.25498658f, 0.12371343f, -0.06921349f, -0.04179864f, 
    0.00839927f, -0.16034329f, 0.10979905f, -0.08222128f, 0.02036517f, -0.06423789f, 0.07115306f, 0.00605332f, 
    0.06503312f, 0.12267769f, 0.43539733f, -0.01100420f, 0.00681252f, 0.10160020f, -0.10923435f, -0.24088256f, 
    0.08050684f, 0.08082793f, 0.11515735f, 0.16745293f, -0.16384085f, -0.18028116f, -0.10144489f, 0.03061629f, 
    -0.04082302f, 0.03251448f, -0.00647335f, 0.02838568f, 0.01445238f, -0.00048285f, 0.03264745f, -0.09261600f, 
    -0.00701547f, -0.06530789f, 0.10041915f, 0.02505717f, -0.22104292f, 0.05545135f, -0.09161001f, 0.10150178f, 
    0.03004874f, 0.04124954f, -0.04067771f, -0.02103441f, 0.03985283f, 0.12252793f, 0.43158165f, 0.03137092f, 
    0.25805610f, -0.22722524f, -0.05217568f, -0.00779733f, -0.00438384f, 0.13493648f, -0.03973245f, 0.11123919f, 
    0.18753704f, -0.07511012f, 0.14747503f, 0.07961761f, 0.00965738f, 0.04362409f, 0.07314657f, 0.02561193f, 
    -0.00961555f, 0.38211653f, 0.12089659f, 0.08408616f, 0.20026477f, -0.14801094f, -0.31925794f, -0.17004968f, 
    0.07264833f, 0.08551250f, 0.09506959f, 0.03873900f, 0.07906789f, -0.00297155f, 0.10877946f, 0.05931531f, 
    -0.17150323f, 0.12018162f, -0.33663771f, -0.07299943f, -0.02834151f, 0.19154295f, 0.02202748f, 0.18925281f, 
    0.01152559f, -0.07610840f, -0.04454635f, 0.07511585f, -0.24677512f, -0.37207055f, 0.07246947f, 0.33133560f, 
    0.07691330f, -0.00600298f, -0.00169565f, 0.07706991f, -0.03770883f, -0.00092093f, 0.06438136f, 0.06598596f, 
    -0.15748537f, -0.01265186f, 0.01630979f, -0.29356155f, 0.04042516f, 0.05532110f, 0.08541255f, -0.07070042f, 
    0.10541548f, 0.02729299f, -0.00018334f, -0.04325189f, 0.15469831f, 0.11083663f, -0.05100298f, -0.13849129f, 
    0.01409907f, -0.03625344f, -0.05753397f, -0.04693736f, -0.14102575f, 0.03456285f, 0.08114991f, -0.07007663f, 
    -0.09009012f, -0.25165203f, -0.00517886f, -0.15497763f, 0.11324256f, -0.03730857f, -0.03863337f, -0.14553699f, 
    0.01039172f, -0.03045582f, -0.04320009f, 0.03587183f, 0.14789656f, -0.36107105f, -0.04756976f, -0.16300043f, 
    -0.00450042f, -0.03638373f, 0.05608248f, -0.18552083f, 0.02189336f, -0.01687050f, 0.06724827f, 0.07843410f, 
    -0.12728453f, -0.42532790f, -0.45089281f, -0.28205898f, -0.22446688f, 0.01474716f, 0.27346024f, 0.15125661f, 
    -0.00845653f, -0.09474771f, 0.04925676f, -0.03117657f, -0.09262798f, -0.09646693f, -0.22973213f, 0.07029589f, 
    -0.01028628f, 0.09591370f, 0.23683752f, 0.07799648f, -0.02612296f, -0.01390941f, -0.13575761f, -0.04889918f, 
    -0.04264211f, 0.08086827f, 0.05727128f, -0.06223482f, 0.21784948f, -0.06194021f, -0.04213363f, 0.09379302f, 
    -0.03020277f, 0.13289292f, 0.07159892f, -0.12705803f, -0.23757856f, -0.18820836f, -0.08638874f, 0.23413822f, 
    0.17691614f, -0.11438157f, 0.15991877f, -0.04186730f, -0.01818909f, -0.06121587f, 0.12448284f, 0.14358397f, 
    0.06338690f, -0.14745633f, -0.04155382f, 0.00248558f, -0.02704374f, 0.06168361f, 0.06117848f, 0.18101053f, 
    -0.01709685f, -0.08345432f, -0.04976509f, -0.00723302f, 0.09498838f, 0.09245914f, 0.00898528f, -0.16123328f, 
    -0.05340866f, 0.04143601f, -0.00233502f, -0.05432718f, 0.06331283f, 0.01056944f, 0.03933984f, 0.07932535f, 
    0.36336449f, 0.04166620f, 0.00015469f, -0.07038307f, 0.12734637f, -0.05440071f, 0.16679108f, 0.12403546f, 
    0.09824134f, 0.10290640f, 0.13708661f, 0.11744499f, -0.26229790f, -0.05792069f, -0.13833900f, 0.25056738f, 
    -0.16825844f, -0.09672651f, 0.09505651f, 0.20436960f, 0.08048923f, -0.03368603f, 0.05234047f, 0.01942985f, 
    -0.05388877f, -0.02077892f, -0.01133309f, -0.18492042f, -0.05444836f, -0.04542520f, 0.01359002f, -0.00911456f, 
    0.12221453f, 0.19750297f, 0.07403021f, -0.09108166f, 0.23626243f, 0.05590995f, 0.28802967f, -0.00586229f, 
    0.17991726f, -0.27984327f, 0.02110062f, 0.10844377f, 0.01672776f, -0.05398898f, -0.07712529f, 0.15712672f, 
    0.20036112f, -0.07631107f, -0.12053564f, 0.14864969f, 0.07303569f, 0.13390240f, 0.09925061f, 0.05062392f, 
    -0.04603125f, 0.02524492f, 0.00133223f, 0.12195021f, 0.12074909f, 0.06678873f, 0.16658752f, 0.05016591f, 
    0.10864957f, -0.04434704f, -0.16004586f, -0.07679700f, 0.02518128f, -0.13157590f, -0.04970087f, -0.01484056f, 
    -0.06488324f, -0.08392355f, -0.04297421f, 0.03438688f, -0.06895176f, -0.06581452f, -0.07131247f, 0.01466758f, 
    -0.07058252f, 0.01400664f, -0.03253174f, -0.02731041f, -0.03753701f, 0.03422931f, 0.01284440f, 0.02435977f, 
    -0.00821664f, -0.02608415f, -0.04905259f, -0.02572194f, 0.05078747f, 0.01731473f, -0.05773614f, 0.00162012f, 
    0.00489892f, -0.00324478f, 0.01947941f, -0.06049713f, 0.05213851f, 0.04520395f, 0.04853018f, -0.01114319f, 
    0.06499811f, -0.03399268f, -0.04604200f, -0.00399120f, -0.07707513f, -0.07451161f, -0.01812034f, -0.04359064f, 
    -0.00926034f, -0.01446952f, 0.04193074f, 0.00027743f, -0.07352351f, -0.05040289f, -0.00419347f, -0.01321949f, 
    0.01346985f, 0.02250052f, -0.03241930f, 0.01567998f, 0.05690865f, -0.00059778f, 0.04791437f, -0.06157712f, 
    0.02098740f, -0.06915787f, -0.04222783f, -0.02659219f, 0.01501125f, -0.03035590f, -0.06700630f, 0.03531539f, 
    -0.04059090f, -0.01724606f, -0.05483958f, -0.04151754f, -0.03229329f, -0.01290358f, -0.05427044f, 0.04520338f, 
    0.01662847f, 0.00106273f, -0.06484316f, -0.01323744f, -0.00981403f, -0.04174648f, 0.04898063f, 0.05326487f, 
    -0.00022491f, 0.02654021f, 0.02675188f, 0.00984601f, 0.01459099f, -0.01814177f, -0.06970656f, -0.07767982f, 
    -0.00698048f, 0.05355877f, -0.00671009f, 0.01084003f, 0.02943689f, 0.01142296f, -0.02487069f, 0.01202193f, 
    0.03942006f, -0.07057811f, 0.05158991f, -0.01048172f, -0.04959584f, -0.07252975f, -0.06724980f, -0.00550291f, 
    0.00115929f, 0.01994282f, -0.07811001f, 0.03334625f, 0.04018980f, -0.02036467f, -0.00989241f, -0.01272320f, 
    -0.08350340f, -0.06522483f, -0.04329552f, 0.00265605f, -0.07573519f, -0.03681287f, -0.01003138f, 0.04396064f, 
    -0.02942263f, 0.04972739f, -0.03887776f, 0.00639678f, -0.02448028f, -0.05000880f, -0.01165283f, 0.01293756f, 
    0.05836622f, -0.04557541f, 0.05992943f, -0.03964254f, -0.04050585f, 0.05557442f, -0.06812329f, -0.02284425f, 
    -0.05854379f, 0.03685844f, -0.03124222f, 0.02534003f, 0.01996492f, -0.02011970f, 0.00483377f, 0.04152708f, 
    -0.02640126f, -0.01288551f, -0.01399945f, 0.00757580f, 0.01816639f, -0.05759312f, 0.01547603f, 0.05641410f, 
    -0.06903573f, 0.00974611f, -0.03632900f, -0.06702699f, -0.00610596f, -0.04475354f, -0.05773796f, -0.00741540f, 
    0.05874928f, 0.04058643f, -0.01984405f, 0.06144776f, -0.00987030f, 0.01341079f, -0.06407115f, 0.04978606f, 
    0.01207062f, 0.01508253f, -0.05284986f, 0.02032339f, 0.04749408f, 0.01940858f, -0.07406270f, 0.06130807f, 
    0.05970928f, 0.01934018f, -0.04208182f, 0.00324758f, -0.01255511f, -0.06506642f, 0.05170999f, 0.01880269f, 
    -0.05150913f, -0.04968316f, 0.04957823f, -0.05182313f, 0.04030792f, 0.00813952f, -0.03669956f, -0.05786441f, 
    -0.02606967f, -0.04182894f, 0.03648220f, -0.00250767f, -0.06772558f, -0.05529590f, -0.01473775f, 0.03439226f, 
    0.05448377f, -0.01566034f, -0.04514619f, 0.05330785f, -0.06054119f, -0.05564672f, 0.04860021f, 0.05849898f, 
    0.02142958f, -0.06068067f, 0.00730920f, -0.06915852f, 0.00339333f, -0.00177008f, -0.05186394f, 0.06043815f, 
    -0.04533917f, -0.02751488f, -0.05114086f, -0.04138318f, 0.01809350f, -0.06602079f, 0.04369017f, -0.06224392f, 
    -0.02685422f, 0.00295564f, 0.00062161f, 0.04821483f, -0.03525870f, -0.00353730f, 0.00148496f, 0.03779943f, 
    0.05901208f, -0.06032581f, 0.00956579f, -0.03398708f, 0.03866862f, -0.04040172f, -0.04951250f, 0.03446563f, 
    0.02318896f, -0.07251807f, -0.07860532f, 0.02379031f, -0.08036007f, -0.05008745f, -0.01627719f, 0.02338895f, 
    0.03971808f, -0.05872485f, -0.01099448f, 0.05340540f, -0.02873274f, 0.03302488f, 0.05720842f, 0.02069922f, 
    -0.01994520f, 0.05148773f, 0.00785353f, 0.05444226f, 0.04408113f, -0.00485144f, 0.02860491f, -0.02636154f, 
    0.00449804f, -0.05480724f, 0.00361652f, -0.06693249f, -0.03495399f, -0.03741383f, 0.00304825f, -0.05730559f, 
    -0.07230616f, -0.00182195f, -0.04239736f, 0.06746945f, 0.01586406f, 0.02629834f, 0.02827102f, 0.07478584f, 
    0.02720451f, -0.00139891f, 0.01574373f, -0.06581898f, -0.03058125f, 0.03149518f, 0.01389087f, -0.00872119f, 
    0.05074577f, -0.04581301f, 0.05993722f, -0.00302890f, 0.02101036f, -0.02428375f, 0.04008174f, -0.03966133f, 
    0.03280189f, -0.06249121f, -0.05381840f, -0.02478740f, 0.02927997f, 0.02049231f, -0.05286895f, 0.05757231f, 
    0.00967116f, 0.00767265f, 0.04095721f, 0.03185758f, -0.03463254f, -0.04016776f, -0.02895395f, -0.01485248f, 
    0.01563224f, 0.04608419f, 0.04177299f, -0.04816401f, -0.03707152f, -0.02629070f, 0.01399395f, -0.07524299f, 
    -0.02696791f, -0.04164867f, -0.04529024f, 0.03972350f, -0.06686582f, -0.02029964f, 0.05204164f, -0.05063838f, 
    0.03624360f, -0.05873465f, -0.02831108f, -0.05593041f, 0.05165985f, 0.02906828f, -0.03849521f, -0.05872844f, 
    0.00647170f, 0.02621857f, 0.05044143f, 0.01979140f, 0.01576835f, -0.05937958f, -0.00506909f, -0.01708159f, 
    -0.02727519f, -0.03808435f, -0.00716831f, 0.04351385f, -0.04441207f, 0.00704483f, -0.00373031f, -0.07352218f, 
    -0.04083952f, 0.05605718f, 0.02403102f, 0.02818100f, 0.01311092f, -0.01271999f, -0.00207590f, -0.00301666f, 
    0.06202852f, -0.05762821f, 0.01554390f, 0.04212798f, 0.00248433f, -0.06918191f, -0.07703873f, -0.03743475f, 
    -0.06988632f, -0.07614733f, 0.03519604f, 0.03773753f, 0.01192583f, -0.03093053f, -0.07674864f, 0.06181424f, 
    -0.00877819f, -0.07263958f, -0.07030961f, -0.02153349f, -0.01388118f, -0.01551719f, -0.01520883f, -0.07702228f, 
    0.09489113f, 0.31157255f, 0.02735869f, 0.24322604f, -0.19853041f, 0.16746458f, 0.00099402f, 0.03277703f, 
    -0.00233276f, -0.05930989f, 0.10214695f, -0.03432801f, 0.11285198f, 0.06247468f, 0.10691612f, 0.07767802f, 
    -0.10758167f, -0.00734729f, -0.10399172f, -0.00356018f, -0.03928505f, -0.12511334f, -0.10600898f, 0.02053706f, 
    -0.31472862f, -0.31386533f, 0.10690083f, 0.17537434f, -0.02419724f, -0.00706075f, 0.06645382f, -0.14291520f, 
    -0.03137156f, 0.02035263f, 0.00355311f, 0.04197180f, -0.27075750f, -0.05289416f, 0.07993398f, 0.36211789f, 
    -0.05361704f, 0.06028321f, 0.00640219f, 0.00561891f, -0.02424036f, 0.03806003f, -0.08146008f, -0.01684485f, 
    -0.06889499f, 0.27239713f, -0.04688941f, 0.06290757f, 0.05561121f, 0.00084901f, 0.05007504f, -0.16749409f, 
    0.07882036f, 0.05996551f, -0.02362394f, 0.08972923f, 0.07859663f, -0.00348385f, 0.19021168f, 0.32133752f, 
    -0.06963405f, 0.10802922f, 0.07647922f, -0.13704860f, -0.02566995f, 0.08670650f, -0.09662809f, -0.09341616f, 
    0.12802738f, -0.29359674f, 0.17740342f, -0.08972644f, -0.03738092f, -0.00951155f, -0.02516117f, 0.00004351f, 
    -0.10873453f, -0.09842326f, 0.07388349f, 0.19743663f, -0.01243037f, 0.04603804f, 0.03926944f, 0.12997402f, 
    -0.00525381f, 0.03547850f, -0.00819589f, 0.09847646f, -0.06168682f, 0.02251690f, -0.00884959f, 0.00752817f, 
    -0.27125239f, 0.02544655f, -0.04284549f, 0.21374105f, -0.06838097f, -0.11044948f, 0.10850441f, 0.20756479f, 
    0.05325314f, 0.05853336f, -0.03340088f, -0.08942767f, -0.01082167f, -0.01110173f, -0.02355062f, 0.07616758f, 
    -0.12584756f, 0.00893406f, 0.07197135f, -0.08988269f, -0.03980171f, -0.03743378f, -0.02445429f, -0.02515427f, 
    -0.31927973f, 0.27465123f, -0.29534218f, 0.13554247f, 0.17229463f, 0.03480165f, -0.01670232f, 0.17537196f, 
    0.18997657f, 0.02096656f, 0.11661378f, 0.06580889f, -0.10729365f, 0.11367343f, 0.04030593f, 0.26335174f, 
    -0.04372592f, 0.01795445f, -0.04026048f, 0.06955004f, -0.19403863f, 0.15233578f, -0.12648541f, -0.00163206f, 
    -0.19001009f, 0.17229819f, -0.17314985f, 0.10996630f, -0.03429772f, 0.05529172f, -0.09748758f, 0.03661025f, 
    0.00902216f, -0.16604170f, 0.03244702f, 0.05321258f, -0.36248147f, 0.01392857f, -0.19249620f, 0.31359860f, 
    0.01668577f, 0.08328301f, -0.01710084f, 0.06111607f, 0.01280195f, 0.02391934f, 0.07536698f, -0.10858521f, 
    -0.20300460f, 0.17700741f, -0.12211856f, -0.17490833f, 0.06833379f, 0.00043442f, 0.02698605f, 0.08705736f, 
    -0.08461077f, -0.00712279f, -0.09750946f, -0.07057442f, 0.08729188f, 0.36316624f, -0.34289992f, 0.00960226f, 
    -0.15365034f, -0.03408178f, -0.01765506f, -0.12203072f, 0.04808965f, 0.03525166f, -0.08688264f, -0.04943066f, 
    0.07780295f, -0.07455140f, -0.02678418f, 0.24707766f, 0.04427157f, -0.07383959f, -0.04178530f, -0.10309244f, 
    0.15204497f, 0.06335068f, 0.14535853f, 0.09406817f, 0.02763931f, 0.06022533f, 0.00027186f, 0.08099627f, 
    0.00576078f, -0.00633385f, 0.00839396f, 0.01237858f, -0.08807639f, 0.02577423f, 0.06277172f, 0.02835486f, 
    0.01077372f, 0.08036373f, -0.07770739f, -0.26707470f, -0.00454336f, -0.09365164f, 0.06989522f, 0.00380456f, 
    -0.01862956f, 0.09811242f, 0.02728542f, 0.02037381f, 0.19750872f, -0.01493973f, 0.21828446f, -0.08848879f, 
    0.08755944f, -0.08274625f, 0.04881178f, 0.07504428f, 0.06567910f, 0.02841982f, -0.01642849f, -0.07156186f, 
    0.20128280f, 0.15697511f, 0.13222326f, -0.07586072f, 0.07437637f, -0.00358364f, 0.02624096f, 0.04314139f, 
    0.18822880f, -0.07357230f, -0.01964359f, -0.15512365f, 0.00010620f, 0.16546665f, -0.13530639f, -0.26194486f, 
    -0.00792152f, 0.12280272f, 0.03763654f, 0.10779189f, 0.16166142f, -0.06255057f, -0.04669188f, -0.16082311f, 
    -0.05659458f, -0.07427502f, -0.03300857f, -0.04249611f, -0.09476506f, -0.06852580f, 0.15346941f, 0.08157472f, 
    -0.13989803f, -0.08119307f, 0.00217504f, -0.00580024f, 0.09347405f, 0.00617263f, -0.14309479f, -0.33693844f, 
    0.17029913f, 0.14064099f, 0.03982310f, -0.00955136f, -0.05653099f, -0.14496572f, 0.03625237f, -0.09981611f, 
    -0.13344018f, 0.03131254f, -0.00953188f, -0.22008897f, -0.01959600f, 0.06229962f, -0.00222979f, 0.15444082f, 
    -0.12039828f, -0.05270140f, 0.02668032f, 0.04202183f, 0.06807613f, 0.07751241f, 0.08402415f, 0.06893424f, 
    -0.08515773f, 0.01458247f, -0.06652288f, -0.09742647f, -0.00384445f, 0.10004349f, 0.14909126f, 0.08826590f, 
    0.23262903f, -0.19530749f, 0.07771567f, 0.03676653f, 0.01873202f, 0.03322708f, 0.11684840f, 0.24493645f, 
    0.23870128f, 0.05266808f, 0.19336586f, 0.01262343f, -0.12837148f, -0.00910720f, 0.07362941f, -0.00698611f, 
    -0.09436673f, 0.08930834f, 0.11987031f, 0.12501365f, -0.12838559f, 0.10418114f, -0.07457463f, 0.03550769f, 
    -0.05773667f, -0.00670240f, 0.02362088f, 0.19265488f, -0.01222327f, -0.02799277f, -0.02571169f, -0.00098878f, 
    0.05157951f, -0.08911388f, -0.11807465f, -0.07845002f, 0.20135978f, 0.01670902f, -0.08136707f, 0.13349056f, 
    0.05603418f, -0.00115452f, 0.13687290f, 0.07062666f, 0.20249507f, 0.11921315f, 0.01828635f, 0.05987529f, 
    -0.16863042f, 0.05700083f, -0.08416288f, -0.28190795f, 0.28293461f, 0.02350738f, 0.09830779f, 0.14776582f, 
    -0.12301002f, -0.08413105f, -0.09576765f, -0.04929570f, 0.40418297f, -0.37906784f, -0.09963656f, -0.12926015f, 
    -0.14191508f, -0.11500063f, -0.03975095f, -0.05248689f, -0.04106091f, -0.06958453f, 0.01778441f, 0.04897857f, 
    0.09678043f, -0.09803370f, 0.04426498f, -0.14165962f, -0.02631066f, 0.09739953f, -0.05506127f, 0.14027517f, 
    -0.02845240f, -0.32138595f, -0.11418319f, -0.06215445f, 0.00072474f, 0.12691826f, -0.08160734f, -0.01237038f, 
    -0.02875799f, 0.01300896f, 0.08581866f, 0.04565671f, 0.05767235f, 0.03551485f, 0.07119479f, -0.02371437f, 
    0.00416105f, -0.00681024f, -0.01989288f, 0.16683049f, 0.14909242f, 0.25010210f, 0.15443426f, 0.09709933f, 
    -0.00850087f, 0.07088280f, -0.00802298f, 0.02129383f, 0.00344146f, -0.22149342f, -0.36312464f, -0.22657612f, 
    -0.22342548f, -0.21705392f, -0.31902814f, -0.48529714f, -0.09350163f, -0.04797079f, -0.02272758f, 0.17623790f, 
    0.00213847f, -0.09299768f, -0.14094500f, -0.07255345f, 0.13740538f, 0.31163114f, 0.16889295f, 0.04474266f, 
    -0.21649426f, -0.02502642f, -0.19262891f, 0.00762295f, 0.26193467f, -0.10481543f, 0.17059878f, 0.29919684f, 
    0.04758503f, 0.15159872f, 0.05471238f, -0.10180909f, -0.03687257f, -0.07608517f, -0.05369464f, -0.08652475f, 
    0.03490129f, 0.15770559f, -0.02311686f, 0.05981412f, -0.16879299f, 0.06788088f, -0.17082073f, 0.16263945f, 
    0.13704051f, 0.21177243f, 0.01230002f, 0.05634130f, -0.07082586f, 0.01605524f, 0.02556825f, 0.19024825f, 
    0.18848702f, 0.07042861f, 0.01904481f, 0.15247314f, -0.03634141f, -0.01362984f, 0.06876256f, 0.14772227f, 
    0.39368376f, -0.05772220f, -0.14691004f, 0.00477920f, 0.14521241f, 0.09069566f, -0.04015550f, 0.13726914f, 
    -0.01869304f, -0.05195395f, 0.11142059f, 0.02122616f, -0.00162362f, 0.02145903f, -0.03942715f, -0.08076237f, 
    0.09304975f, 0.10960337f, 0.08196639f, 0.07636756f, 0.15132958f, 0.08519588f, 0.10874453f, 0.02355217f, 
    0.75876200f, -0.29605514f, -0.27670926f, -0.00762174f, -0.18292773f, -0.05945205f, -0.17252113f, -0.38461313f, 
    -0.41646844f, -0.13030341f, -0.08157248f, 0.08940003f, 0.33870056f, 0.02304623f, 0.05538750f, 0.06891857f, 
    0.18339851f, 0.14092582f, 0.04318295f, 0.02966104f, -0.00911372f, -0.13375260f, 0.02941960f, 0.12930974f, 
    0.24603626f, 0.07234307f, 0.22110990f, -0.12712859f, 0.05816443f, -0.07435810f, -0.00146835f, -0.07950562f, 
    0.17840064f, 0.35593197f, -0.13218105f, -0.22012450f, 0.15402119f, -0.09078633f, 0.12445766f, 0.14264809f, 
    -0.21638176f, 0.19541977f, 0.19458985f, -0.17126864f, -0.05737111f, -0.00401311f, 0.04241034f, 0.12953326f, 
    -0.06197758f, 0.05122178f, -0.18183677f, -0.03533275f, -0.02091067f, -0.17300318f, -0.16217579f, -0.38881773f, 
    -0.09679211f, -0.20922849f, 0.02630646f, 0.16412778f, -0.03231723f, 0.07153338f, 0.04977192f, 0.05392980f, 
    0.00156653f, -0.04818318f, 0.07966613f, 0.02165977f, 0.08613437f, -0.02097484f, 0.02450732f, 0.01532564f, 
    -0.26466143f, 0.21097618f, 0.24504295f, -0.26676500f, 0.02015847f, -0.08638386f, -0.03759335f, 0.04348608f, 
    0.01410853f, 0.01622462f, -0.00053049f, -0.00425352f, -0.00154188f, 0.03241613f, -0.24364895f, -0.01907348f, 
    -0.06528405f, -0.07620502f, 0.07348644f, -0.04642243f, 0.01451745f, -0.02626829f, -0.02119668f, 0.02279628f, 
    0.04954900f, 0.31966558f, -0.00161878f, 0.15035428f, -0.10397398f, -0.02387919f, -0.01753224f, 0.01440459f, 
    0.01535916f, 0.05739681f, -0.03468762f, 0.05228051f, -0.07049500f, -0.12613484f, 0.05802938f, -0.06104253f, 
    0.03281560f, 0.02515462f, -0.18302831f, 0.09693551f, -0.05266134f, -0.06858919f, 0.00807614f, -0.02406331f, 
    -0.21008256f, -0.05289413f, 0.08864431f, 0.14475186f, -0.06801495f, 0.07114340f, 0.01646867f, 0.22526267f, 
    0.02838993f, -0.00386757f, -0.14570034f, -0.04348816f, -0.06439690f, -0.14683796f, 0.14929177f, -0.06888989f, 
    -0.09300648f, -0.01752215f, -0.14986759f, 0.07813320f, -0.00756224f, 0.03826187f, 0.01518615f, -0.02570066f, 
    0.06802595f, 0.24893352f, -0.12501214f, 0.01962951f, -0.11607718f, -0.04681761f, 0.17163338f, 0.07197718f, 
    0.10104423f, 0.11750416f, -0.14153638f, -0.09267149f, 0.04330762f, 0.13729337f, 0.06563891f, -0.07151745f, 
    -0.17541964f, -0.14310816f, 0.17349955f, 0.05932684f, 0.15635987f, 0.05732966f, 0.06492281f, 0.05372859f, 
    0.28781018f, 0.18969624f, 0.17006724f, -0.19887923f, -0.15661508f, -0.17697559f, -0.12563467f, -0.07484863f, 
    0.04590538f, 0.06209848f, 0.18937786f, 0.11904753f, 0.11004061f, -0.00842075f, 0.05800379f, -0.07781059f, 
    0.08286573f, 0.07688329f, 0.02277895f, -0.01110351f, -0.06481996f, -0.01562809f, 0.00717509f, -0.13196568f, 
    0.08959528f, -0.51571804f, 0.06648000f, 0.06900807f, -0.19870186f, 0.01699229f, -0.20109148f, -0.03700389f, 
    -0.25772870f, 0.04085361f, -0.06653856f, 0.10795084f, 0.22837383f, 0.07333222f, 0.10801757f, -0.08463713f, 
    0.06219551f, -0.07109050f, 0.07896747f, 0.16652389f, 0.16507404f, -0.02218914f, -0.03814368f, 0.14112616f, 
    0.17604694f, -0.23633371f, 0.13928506f, -0.04439022f, 0.04384082f, -0.08223671f, -0.06071658f, -0.02597372f, 
    0.11925789f, 0.07120252f, -0.00631610f, 0.12147766f, 0.01466457f, -0.32069820f, 0.27592525f, -0.05951648f, 
    -0.10061376f, 0.15714142f, 0.05811835f, 0.15423180f, 0.07806684f, 0.02462604f, -0.01122600f, 0.03910985f, 
    -0.00373455f, -0.21691200f, -0.31102201f, 0.19873224f, -0.09676426f, 0.18147567f, -0.01545845f, -0.04598009f, 
    -0.00248338f, 0.04875813f, 0.01413061f, 0.03191080f, -0.19462124f, -0.42202052f, 0.17843635f, 0.07593878f, 
    0.10317536f, 0.11065498f, 0.06951237f, 0.05907772f, 0.10511933f, -0.08246221f, -0.07796200f, 0.05261246f, 
    0.04058171f, -0.05675852f, -0.06937703f, -0.07168708f, 0.05248652f, -0.02177045f, 0.05462835f, 0.04067677f, 
    -0.02557534f, -0.06556841f, -0.06624219f, 0.02869200f, -0.01186312f, 0.02458550f, 0.02004616f, -0.06069305f, 
    -0.02263786f, -0.00529920f, 0.00626480f, 0.01724831f, 0.02843275f, -0.04874015f, 0.04391563f, 0.06224591f, 
    0.01249037f, 0.03625206f, 0.03638218f, -0.02430893f, -0.04347091f, -0.07089989f, -0.05792297f, -0.06948505f, 
    0.04983533f, 0.04976207f, 0.06280819f, 0.00467952f, -0.07300254f, -0.07650299f, 0.06233378f, -0.03914063f, 
    -0.02126195f, 0.01270810f, -0.02699373f, -0.06581841f, -0.04280160f, 0.00522141f, 0.04099910f, -0.04635609f, 
    0.00430234f, -0.06549561f, -0.07014325f, 0.06310397f, -0.03489807f, -0.04218739f, 0.01241667f, -0.05950164f, 
    -0.05693753f, 0.01628184f, -0.00203356f, 0.03875499f, 0.00282328f, -0.04411224f, -0.07687204f, 0.02981510f, 
    0.02678091f, 0.04457426f, -0.05223652f, 0.05847283f, -0.01301594f, 0.00262754f, 0.04555748f, -0.02577593f, 
    0.00588311f, -0.06530743f, 0.00859367f, 0.01734454f, -0.05091597f, 0.02236095f, 0.04367246f, -0.04810157f, 
    0.01647592f, -0.05241230f, -0.00382010f, -0.00447374f, -0.00471031f, 0.03303762f, 0.03098913f, 0.05331294f, 
    0.01971703f, -0.04163744f, -0.01671165f, -0.06727089f, -0.02484767f, 0.01516085f, -0.05788992f, -0.05458743f, 
    0.05584490f, -0.07216088f, -0.02698300f, -0.03313550f, -0.07707190f, -0.07485218f, 0.00160888f, 0.00905307f, 
    0.04297864f, -0.02966664f, -0.04223348f, 0.02615525f, -0.02430423f, 0.00845940f, 0.00945914f, -0.00711228f, 
    0.02097269f, -0.00389621f, 0.00962282f, -0.01835546f, 0.03500087f, -0.01183391f, 0.06399394f, -0.07120647f, 
    -0.06969360f, 0.02730952f, 0.02686703f, -0.03171164f, -0.07126252f, -0.07750363f, -0.01270077f, -0.01538976f, 
    -0.07363899f, -0.03256575f, -0.02066964f, 0.02418807f, -0.00434392f, 0.00862092f, -0.01539276f, 0.04055783f, 
    -0.00834838f, -0.01634602f, -0.06710781f, -0.06360780f, -0.07042173f, -0.03410412f, 0.01446325f, -0.01539141f, 
    0.04598236f, 0.04276583f, 0.05982027f, -0.04050542f, -0.01603002f, -0.02835480f, 0.02479428f, -0.06723429f, 
    -0.03107870f, -0.07539663f, -0.07874551f, 0.04244712f, 0.05624155f, 0.03005558f, -0.02807996f, 0.00823257f, 
    0.04947704f, 0.03246642f, 0.04517078f, -0.05086520f, -0.01125353f, -0.02609618f, 0.01005928f, -0.02581012f, 
    -0.06790647f, -0.04187322f, -0.07668421f, -0.00266600f, -0.06102575f, -0.04024481f, 0.03361233f, 0.05543011f, 
    0.05287667f, -0.07748438f, 0.06168596f, -0.03735812f, 0.01978199f, -0.07050900f, 0.02048508f, 0.02231228f, 
    -0.07356157f, -0.06532685f, -0.02001460f, -0.03585005f, 0.06204900f, 0.04947622f, 0.00623190f, 0.03441395f, 
    0.37539434f, 0.31163278f, 0.29079145f, -0.23105748f, -0.07686400f, -0.00554539f, 0.10737346f, 0.00400025f, 
    0.22942932f, 0.09229919f, 0.14642550f, 0.30512837f, 0.13760629f, 0.13907818f, 0.07306159f, 0.12066914f, 
    -0.02180664f, 0.01493090f, -0.07641367f, -0.01084253f, 0.15795091f, 0.01507427f, 0.11521957f, 0.12680332f, 
    0.46834195f, 0.01285411f, -0.44991931f, -0.28613785f, 0.11572541f, 0.17353004f, 0.35125554f, 0.24214497f, 
    0.02488458f, -0.07589003f, 0.02917140f, -0.06863233f, -0.65934414f, -0.68131918f, -0.45187166f, -0.22068083f, 
    0.34592146f, 0.16047494f, -0.00851526f, 0.01531066f, -0.13925822f, 0.00610608f, -0.05747729f, -0.00844199f, 
    -0.56078547f, -0.61702877f, -0.34955007f, 0.10731906f, -0.25774193f, 0.06368763f, 0.00744345f, 0.20788121f, 
    -0.11310975f, -0.17325377f, -0.03540248f, 0.07803033f, -0.88283253f, -0.11744726f, -0.61277950f, -0.26930106f, 
    0.10491604f, -0.15395273f, -0.07541572f, -0.13965651f, -0.13714853f, -0.02558593f, -0.00749342f, -0.04187712f, 
    0.11971860f, 0.06082090f, -0.12270627f, 0.11249486f, 0.17689511f, 0.22779395f, -0.01734973f, -0.08618864f, 
    -0.16845147f, -0.13157588f, -0.02852243f, -0.12565750f, -0.06451424f, -0.02794243f, -0.20135729f, -0.08746697f, 
    0.17818563f, -0.21098901f, 0.10494561f, 0.06795428f, -0.08948818f, -0.12509714f, 0.08592997f, -0.16978863f, 
    -0.44565475f, 0.01622588f, 0.02627663f, -0.35242453f, -0.13013569f, 0.03544597f, 0.10910949f, 0.17117314f, 
    -0.09207601f, 0.06364305f, -0.10491233f, -0.13050652f, 0.18717095f, 0.05517819f, 0.16603415f, 0.10953806f, 
    -0.02859320f, 0.00198319f, 0.04597215f, -0.02935062f, 0.01686382f, 0.05780191f, 0.06666552f, 0.02984808f, 
    0.06389415f, 0.09249285f, -0.11123691f, -0.28089941f, -0.19791663f, 0.14608261f, 0.01585234f, 0.00993851f, 
    0.25437671f, 0.04470488f, 0.12221149f, 0.01967267f, 0.00132633f, -0.01790806f, 0.05554472f, 0.20239499f, 
    0.01891457f, -0.34208968f, 0.00992879f, -0.15415558f, -0.02898213f, 0.05889390f, -0.01315019f, 0.09891719f, 
    0.07903138f, -0.02210825f, 0.14091073f, -0.13860618f, -0.09794930f, 0.05718926f, -0.05257695f, 0.01447147f, 
    0.01928461f, 0.14643675f, -0.08444059f, -0.01787555f, -0.40423399f, -0.12913021f, -0.21536773f, -0.02501416f, 
    0.31251788f, 0.03282741f, -0.11480981f, -0.21032052f, -0.00427625f, 0.04065148f, -0.04659970f, 0.00245158f, 
    -0.10689441f, 0.16859151f, 0.07182808f, 0.01854715f, -0.06584284f, 0.34118149f, 0.19300725f, 0.15812992f, 
    0.09776417f, 0.02366991f, 0.05725108f, 0.08557776f, 0.12398072f, 0.11840061f, 0.38076231f, 0.45347646f, 
    -0.03964626f, 0.03581969f, -0.01790662f, -0.04497196f, -0.04464003f, -0.01746453f, 0.03009089f, 0.10048991f, 
    0.20699583f, -0.00108780f, 0.04456820f, 0.16715765f, -0.14806220f, 0.03598101f, -0.09864788f, -0.00379886f, 
    -0.04711987f, 0.07156381f, 0.08245248f, 0.16648692f, -0.00717397f, -0.14249842f, 0.02494029f, 0.15797062f, 
    -0.05768865f, -0.08218936f, -0.04148113f, -0.06454166f, 0.06080493f, 0.02272203f, -0.02004921f, 0.01210820f, 
    -0.11269359f, -0.06069667f, 0.17827690f, 0.17432465f, -0.04085815f, -0.05490483f, 0.09235860f, -0.01260487f, 
    0.01568990f, 0.02980960f, -0.08481395f, 0.02964051f, -0.15945055f, 0.04398055f, 0.25773168f, 0.24785902f, 
    -0.05302053f, 0.05769749f, 0.06972006f, 0.12331182f, 0.07627808f, 0.07159503f, 0.07507887f, 0.02334845f, 
    -0.13435072f, 0.02752055f, 0.17467013f, 0.05825910f, 0.05001612f, -0.09155308f, -0.20789200f, -0.17075217f, 
    0.03616607f, 0.04075910f, -0.16259992f, 0.14294404f, -0.06155426f, -0.06854729f, 0.18558067f, 0.05760734f, 
    -0.00327146f, -0.09899132f, -0.12830998f, 0.18404344f, 0.03647049f, 0.09055424f, 0.04476746f, -0.08411207f, 
    0.10962814f, -0.13793200f, -0.01498925f, -0.09682564f, 0.02057581f, 0.05441905f, -0.03520674f, 0.08627648f, 
    0.03805441f, -0.05973401f, -0.08801777f, 0.05908601f, 0.01518563f, 0.16014977f, 0.17825986f, -0.05608458f, 
    -0.00737575f, 0.18006289f, 0.07281993f, 0.15981767f, -0.14032638f, 0.07029802f, -0.10107649f, -0.00497295f, 
    -0.27343673f, -0.07268282f, -0.06301389f, 0.00144178f, 0.02228279f, -0.09495679f, -0.06063633f, 0.17008027f, 
    0.04353245f, -0.02009637f, -0.11355664f, -0.00322128f, -0.00449099f, -0.05261531f, -0.08197974f, 0.11900011f, 
    -0.00453312f, -0.04325132f, -0.00064483f, -0.05908221f, -0.05306697f, 0.05154663f, -0.11125425f, -0.14227529f, 
    -0.37892273f, 0.04122604f, -0.00022334f, 0.32713133f, 0.01973425f, 0.07679798f, 0.01223652f, 0.14965746f, 
    0.00824506f, 0.06278594f, -0.04719619f, 0.05954348f, 0.03585609f, 0.07556384f, 0.20383817f, -0.03478346f, 
    -0.07698949f, -0.01165816f, 0.01470342f, -0.00747796f, -0.03787000f, 0.11155943f, -0.06459025f, -0.06311656f, 
    -0.19278108f, 0.01175820f, 0.08020847f, 0.01033025f, 0.07728510f, -0.06805979f, -0.07359236f, 0.05171564f, 
    0.09791958f, -0.12184721f, -0.09925374f, 0.07553481f, -0.27968919f, -0.20874690f, 0.10090997f, 0.26949170f, 
    0.08344558f, 0.13776827f, -0.00243725f, 0.04570772f, -0.04894746f, 0.14447919f, 0.04459979f, -0.03829269f, 
    -0.11769913f, 0.00114506f, 0.00881940f, 0.27969265f, 0.12395052f, 0.02479415f, -0.00909013f, -0.14407155f, 
    0.03632387f, 0.00518693f, 0.07923407f, -0.09770667f, 0.23334828f, 0.18900952f, 0.05726773f, -0.01963227f, 
    -0.00616177f, -0.00592675f, 0.02847693f, -0.08138936f, -0.04156851f, -0.11228757f, -0.07900639f, -0.04175080f, 
    0.30496037f, 0.24657492f, 0.17012393f, -0.23236388f, -0.13470884f, 0.00441467f, -0.01481210f, -0.17664012f, 
    0.05963279f, 0.07739102f, 0.04444587f, 0.22688402f, -0.36914098f, -0.06314920f, -0.12288261f, -0.12123214f, 
    -0.11147634f, -0.16901797f, -0.02486783f, -0.20825385f, -0.05427808f, -0.09506253f, 0.02133581f, 0.00594634f, 
    0.00231351f, -0.03654252f, -0.06392607f, 0.28523165f, 0.18798721f, 0.13295199f, 0.19795421f, 0.19051825f, 
    0.01860662f, 0.17008191f, 0.04342071f, -0.03320568f, -0.00741324f, 0.15661418f, -0.19720909f, 0.07589386f, 
    0.05757093f, 0.16897687f, 0.03532313f, 0.04909138f, 0.07894271f, 0.04726300f, 0.06017550f, -0.00479819f, 
    -0.02806951f, 0.15612806f, -0.08559375f, 0.14539853f, -0.02402593f, -0.07376284f, -0.13471247f, -0.00408943f, 
    -0.07983381f, -0.00373421f, -0.14349757f, -0.07512682f, 0.10295811f, -0.07942095f, 0.17259674f, 0.19848338f, 
    0.02928538f, 0.16761442f, -0.12508526f, -0.02026338f, -0.16543192f, 0.05232633f, 0.00652431f, -0.10090815f, 
    -0.37085110f, -0.21590970f, -0.00900806f, 0.14440055f, 0.11401040f, 0.08002553f, 0.09405334f, -0.08496606f, 
    0.04023514f, 0.24113651f, 0.12270354f, 0.23346089f, 0.05097402f, -0.03120526f, 0.21325533f, 0.42355323f, 
    0.03051627f, 0.18358557f, 0.10392966f, 0.05653773f, 0.14350170f, 0.14394981f, 0.17729081f, 0.13011758f, 
    0.19692126f, -0.25217324f, -0.11853812f, 0.23204607f, 0.01148207f, -0.08079301f, 0.23219919f, 0.03344826f, 
    0.00547187f, 0.06681694f, -0.01368569f, 0.01592574f, -0.25755394f, -0.12340533f, -0.13265842f, -0.21875459f, 
    -0.21084937f, -0.10662509f, -0.00886383f, -0.11380275f, -0.06456011f, -0.02626018f, 0.16563569f, 0.08854956f, 
    0.10729978f, 0.38668463f, -0.24026708f, -0.22173020f, -0.00937604f, -0.03601324f, -0.01767321f, 0.00590436f, 
    -0.08808562f, -0.07211733f, -0.16615270f, 0.01235449f, 0.24754572f, 0.08005715f, 0.20884775f, 0.19350682f, 
    0.01795573f, 0.08292187f, 0.13305010f, 0.05535628f, 0.14022033f, 0.05754754f, -0.03378520f, 0.00603476f, 
    0.12827222f, 0.03744471f, 0.08533129f, -0.16481051f, -0.07650904f, -0.00795498f, -0.10797460f, -0.17439401f, 
    -0.04818478f, -0.18893497f, -0.09216321f, -0.14181647f, -0.05584700f, -0.07785395f, 0.01440281f, 0.03165347f, 
    0.11324462f, 0.22184478f, -0.08887377f, 0.10126559f, 0.01576432f, -0.09863965f, 0.24564672f, -0.02164786f, 
    -0.20460948f, 0.19103570f, 0.03301051f, 0.01646672f, -0.09168447f, -0.03690679f, -0.17383096f, -0.05103317f, 
    -0.10250686f, -0.15289122f, -0.02867259f, -0.24651307f, -0.37440935f, 0.15537982f, 0.05601650f, 0.16734451f, 
    -0.13807525f, -0.14151368f, -0.02889273f, 0.07078643f, 0.01847834f, 0.04075650f, -0.09831352f, 0.01220591f, 
    -0.14638565f, -0.51002395f, -0.02057926f, -0.02862945f, 0.04464258f, -0.15693352f, 0.12988485f, -0.04618047f, 
    0.14004089f, 0.17764463f, 0.02724596f, 0.08717946f, -0.14719705f, -0.14619334f, -0.16220069f, 0.12561613f, 
    0.08901032f, -0.01239978f, 0.01053263f, -0.13316481f, -0.07880362f, 0.02668261f, -0.01825123f, 0.23821998f, 
    0.04616989f, 0.22167176f, 0.08393349f, -0.04057293f, 0.07959080f, 0.01017579f, -0.03375404f, 0.01520629f, 
    0.02725354f, -0.05296476f, -0.04764884f, -0.08415286f, 0.08911169f, 0.04857631f, 0.14161289f, -0.17605607f, 
    0.01427032f, -0.05210619f, -0.03333072f, -0.01729723f, 0.14335112f, 0.06863660f, 0.15860322f, 0.00199633f, 
    0.00181375f, -0.14869839f, 0.19622868f, 0.00243053f, -0.11023352f, -0.02036909f, -0.01072581f, 0.14502326f, 
    0.07281160f, -0.17632578f, 0.08287854f, 0.03405088f, -0.22225742f, -0.08953978f, 0.10670944f, -0.15500890f, 
    0.03928607f, -0.07818546f, 0.01329409f, 0.25225079f, -0.07924430f, -0.02825527f, 0.07383084f, 0.04050362f, 
    -0.23688589f, 0.21665455f, -0.25380072f, -0.12594426f, 0.03258644f, 0.07237834f, 0.11350132f, -0.09176891f, 
    0.08790931f, 0.13101837f, -0.00797586f, -0.12169726f, -0.05186868f, 0.05915806f, -0.02676311f, -0.16099545f, 
    -0.08303796f, 0.07205237f, 0.02229656f, 0.03011199f, -0.01785224f, -0.02983138f, 0.01114198f, 0.11409354f, 
    -0.00572925f, -0.08436415f, 0.28575444f, -0.09859848f, -0.05696808f, 0.06013228f, -0.03754689f, 0.07584967f, 
    0.10857906f, 0.01325784f, 0.02781731f, -0.04118020f, -0.00782415f, -0.07387169f, -0.03210210f, 0.08493204f, 
    -0.01621228f, -0.02792961f, -0.11461604f, 0.10652605f, -0.06719706f, 0.06193516f, 0.00115441f, 0.06606922f, 
    0.22849280f, -0.33924705f, 0.33163559f, 0.06127429f, -0.07667740f, -0.04296167f, 0.04069494f, 0.10005417f, 
    -0.06956949f, -0.04080583f, -0.02758445f, 0.12248485f, -0.13989879f, -0.02676035f, 0.08335509f, -0.16455841f, 
    -0.05052401f, -0.09963953f, -0.10129092f, -0.21579044f, 0.05799935f, -0.10423039f, 0.09382761f, 0.01455719f, 
    0.14665526f, -0.07599729f, 0.06167293f, 0.04584773f, 0.05131308f, -0.04034917f, 0.06037326f, -0.03937179f, 
    0.14405429f, 0.06333485f, -0.13042080f, -0.03082011f, 0.07591747f, -0.01338738f, 0.23347498f, -0.15287583f, 
    0.00899124f, 0.06107881f, 0.01128879f, -0.08808663f, -0.08426892f, 0.10405060f, 0.10798476f, 0.01034338f, 
    0.20199375f, -0.21181931f, 0.05267333f, 0.29552794f, 0.24285501f, 0.04370312f, -0.07303946f, -0.01599659f, 
    0.10654227f, -0.08407915f, 0.03271854f, -0.10301078f, -0.09224493f, -0.39866695f, 0.28502035f, -0.03544309f, 
    0.21503375f, 0.14961740f, 0.02260857f, 0.09628531f, -0.02610683f, 0.00201224f, 0.08242349f, 0.02094030f, 
    0.02021653f, -0.05990585f, 0.04175296f, -0.07076550f, -0.06625234f, -0.01389356f, -0.09292410f, -0.04023860f, 
    -0.06803821f, -0.07405838f, -0.00248255f, 0.00822503f, 0.04905772f, -0.03809556f, -0.01227182f, -0.01195187f, 
    -0.03045122f, -0.07445740f, -0.02101295f, -0.01746204f, 0.00133629f, -0.01464180f, 0.04225501f, -0.03200774f, 
    0.00226758f, 0.05420054f, -0.00047814f, 0.07139071f, 0.04601081f, -0.06678128f, 0.04451524f, -0.03917001f, 
    -0.01807071f, -0.07248634f, 0.06870012f, -0.01455489f, -0.05630599f, 0.02954205f, 0.04391471f, 0.06963835f, 
    0.01482375f, -0.03073935f, -0.00322872f, -0.05381139f, -0.06551074f, 0.01480382f, -0.00544205f, 0.07306383f, 
    0.01976462f, 0.02630660f, -0.04048576f, 0.00777363f, -0.03602650f, -0.00105587f, -0.01224268f, 0.01928520f, 
    0.04794698f, 0.06256796f, 0.03226491f, 0.01786140f, -0.01417989f, 0.01612447f, 0.02826829f, -0.06382516f, 
    0.04651926f, -0.04969252f, 0.02206911f, 0.01056772f, -0.01002111f, 0.00164695f, 0.03981623f, -0.02807371f, 
    -0.05538625f, -0.00139172f, 0.00896751f, -0.06472962f, -0.06829553f, -0.00293559f, 0.05909837f, 0.01190302f, 
    0.00891016f, -0.05500872f, -0.02890915f, -0.08009363f, 0.03072822f, 0.00345937f, -0.02572051f, 0.04955857f, 
    0.01630085f, -0.03972276f, -0.04757612f, 0.01252714f, -0.07470296f, 0.00973182f, 0.01423328f, -0.02402931f, 
    0.02979577f, 0.01792673f, 0.00803570f, -0.06819237f, 0.07376549f, 0.05030908f, -0.06192784f, -0.05719588f, 
    -0.02506207f, -0.06151402f, 0.03664355f, 0.01213527f, -0.02405756f, 0.03230393f, -0.06851143f, 0.04065232f, 
    0.01966459f, -0.03367146f, -0.05730670f, -0.08921410f, 0.02541321f, -0.03147691f, -0.06108852f, -0.04220772f, 
    0.03548225f, -0.05538610f, 0.03280206f, 0.00898797f, -0.05895387f, -0.06038748f, 0.03645638f, -0.00533808f, 
    0.00196288f, -0.05470589f, 0.05593257f, 0.02423376f, -0.04075309f, 0.02799086f, -0.02096410f, -0.00515331f, 
    -0.07408676f, -0.06842938f, 0.02887482f, -0.04079344f, -0.04367979f, 0.00943126f, -0.05350417f, -0.06541796f, 
    -0.02901847f, -0.02756974f, -0.06978993f, 0.01331778f, 0.02914980f, -0.05933668f, -0.06506339f, -0.02626872f, 
    -0.04563735f, -0.07271498f, 0.02810540f, -0.01682974f, -0.00938618f, -0.00109176f, -0.02740319f, 0.01625760f, 
    0.01771751f, -0.03482488f, 0.01289706f, 0.00962501f, 0.01252814f, -0.08559726f, -0.04022437f, -0.00104519f, 
    -0.02485068f, 0.06876856f, -0.06133200f, 0.00085994f, 0.03405286f, 0.04974064f, 0.06392322f, -0.05377652f, 
    -0.00180409f, -0.03154415f, -0.04065096f, -0.06337706f, 0.04099061f, -0.00632339f, -0.00991100f, -0.06698537f, 
    -0.04999445f, 0.04084415f, -0.03521888f, 0.04501580f, -0.01158310f, 0.03871244f, -0.05168837f, 0.00879155f, 
    0.51646233f, -0.23492804f, -0.22282936f, 0.30221498f, -0.26162148f, 0.05974024f, 0.11902992f, -0.03146808f, 
    0.06292056f, 0.08232375f, 0.01178714f, -0.09432878f, -0.01219878f, -0.14422265f, 0.13687615f, 0.02916006f, 
    0.03681374f, -0.01282732f, -0.16529192f, 0.13633260f, 0.18679939f, -0.04127142f, 0.03432767f, 0.04332232f, 
    -0.10880239f, 0.04459239f, 0.21910435f, 0.21783026f, 0.07374381f, 0.06771994f, 0.15641160f, 0.05561814f, 
    -0.16298966f, -0.07738274f, 0.03439989f, 0.01156299f, 0.07745240f, -0.06389014f, 0.24378988f, 0.06512664f, 
    0.08109895f, 0.01358886f, 0.10197585f, 0.09074329f, -0.01354693f, -0.01460493f, -0.03572600f, 0.02292453f, 
    0.10664991f, 0.14649549f, 0.14245762f, 0.13960922f, 0.10471414f, 0.00494670f, -0.05205289f, -0.22371843f, 
    0.01147903f, 0.05083130f, -0.20102575f, 0.20552097f, 0.17977199f, 0.14493911f, 0.30121034f, 0.24145031f, 
    -0.10317061f, -0.09221295f, 0.09905568f, 0.03385282f, -0.12058317f, 0.00083620f, 0.04064037f, -0.07346613f, 
    0.09799007f, -0.06783020f, -0.00807599f, 0.04097529f, 0.06561962f, 0.01442075f, -0.08075476f, 0.02962547f, 
    -0.02119118f, -0.17619208f, -0.08117261f, 0.00606628f, 0.03940728f, 0.14915098f, 0.15885714f, -0.01887297f, 
    0.02524768f, 0.16742773f, -0.10912995f, 0.05213262f, -0.01852863f, 0.19096252f, -0.08033992f, -0.01550787f, 
    0.49232835f, -0.29707903f, -0.20178322f, 0.13438216f, 0.06207043f, 0.02388699f, -0.03019621f, -0.02067880f, 
    0.10701765f, 0.00030542f, -0.08910626f, -0.05996063f, 0.14060335f, -0.03592445f, -0.11676653f, 0.08301293f, 
    -0.08461972f, -0.02300082f, -0.06772365f, -0.07077496f, -0.03595665f, 0.00414538f, -0.07876355f, 0.06112292f, 
    0.13216764f, -0.09063992f, 0.00579056f, -0.08250651f, -0.06596407f, -0.02969444f, -0.00545135f, 0.03398714f, 
    -0.16606088f, -0.02707834f, 0.00479152f, 0.04302914f, 0.01826373f, 0.25093237f, -0.15492243f, 0.00355878f, 
    0.00276318f, -0.09199952f, 0.14920159f, -0.08175787f, 0.04675923f, 0.02278918f, -0.12039189f, -0.15954633f, 
    -0.03915360f, -0.09351395f, 0.05027663f, 0.16677082f, -0.06423092f, -0.07733724f, -0.02082976f, 0.05713378f, 
    0.09545037f, 0.04838668f, 0.05940764f, 0.18089505f, -0.07127460f, 0.10319946f, -0.21893191f, -0.22647992f, 
    -0.00601679f, 0.25357282f, -0.00841410f, 0.09371583f, -0.14734545f, 0.04500470f, -0.12626457f, 0.00018853f, 
    -0.31734487f, 0.06411220f, 0.18365996f, 0.06626955f, 0.01592664f, -0.03895053f, -0.07478140f, -0.20097619f, 
    0.02695687f, -0.07209719f, 0.13740957f, 0.14188917f, 0.13225402f, 0.22562897f, -0.19644135f, -0.01692618f, 
    -0.15672767f, -0.21705796f, -0.06860804f, -0.11519599f, 0.02821134f, 0.08845667f, -0.05260659f, -0.14401659f, 
    0.11452404f, -0.41056231f, -0.09498852f, 0.13401374f, -0.07012194f, 0.11470997f, 0.00574472f, 0.03582758f, 
    0.16573225f, 0.05561662f, -0.03484141f, -0.05601849f, -0.24306510f, -0.35796323f, 0.01312195f, 0.07455818f, 
    -0.02823891f, -0.09099510f, -0.11895078f, 0.07309188f, 0.11051776f, 0.03640765f, 0.08260959f, 0.13561939f, 
    0.13161467f, 0.27473950f, 0.42476746f, 0.18730569f, -0.04453314f, -0.10589323f, 0.07344466f, 0.10321726f, 
    0.04494481f, -0.03827356f, 0.02813089f, -0.03891256f, 0.11270887f, 0.02328079f, 0.33907658f, 0.09467601f, 
    -0.06664726f, -0.01709017f, -0.01902327f, 0.07855088f, -0.03291535f, 0.04542737f, -0.02245568f, 0.00154650f, 
    0.10983623f, 0.22676559f, 0.17058070f, 0.07473958f, 0.03518640f, -0.08821512f, 0.02956845f, -0.14470354f, 
    -0.13151054f, 0.06776537f, -0.15957376f, 0.19663356f, 0.26733267f, 0.31360129f, 0.11621708f, 0.28792110f, 
    0.04134569f, -0.20589790f, 0.23394738f, -0.02297178f, -0.04365934f, -0.06758181f, 0.02372035f, -0.02383361f, 
    0.10507476f, 0.02224832f, 0.05277764f, 0.06793065f, 0.14650680f, 0.14320698f, -0.07810051f, -0.01946407f, 
    -0.04145968f, -0.13767061f, -0.00420065f, -0.01251034f, 0.24986242f, 0.26462376f, 0.19143361f, 0.05997305f, 
    -0.07279190f, 0.14264439f, -0.02502056f, -0.02837641f, -0.16047399f, 0.07350738f, -0.08074797f, -0.07429040f, 
    0.19375697f, 0.31868976f, -0.09856509f, 0.24828422f, 0.13130966f, -0.02941254f, 0.04178031f, 0.13565797f, 
    -0.02114636f, 0.02778672f, -0.05054527f, 0.00013433f, -0.25336879f, -0.16903159f, -0.20023936f, 0.06745569f, 
    0.04723324f, -0.05694554f, -0.01184613f, 0.01817532f, 0.07431628f, 0.05437392f, -0.08430310f, 0.00413132f, 
    0.05718623f, 0.04576400f, 0.12586279f, 0.17813720f, -0.12601115f, -0.15637353f, -0.01538691f, -0.01534011f, 
    0.05491150f, 0.04186833f, -0.05879658f, -0.02553590f, 0.14537935f, 0.27963188f, -0.05506939f, 0.06640489f, 
    0.13131779f, 0.00205285f, -0.07402935f, -0.08649544f, -0.19778554f, -0.03499252f, 0.03675767f, -0.14384665f, 
    -0.27876225f, -0.13180783f, -0.08071420f, 0.07286459f, -0.02699470f, 0.02697168f, 0.00641253f, 0.11986424f, 
    -0.03135594f, 0.02341472f, 0.06007172f, 0.10302432f, -0.09853366f, 0.24988888f, -0.16698788f, 0.05554740f, 
    -0.25288877f, 0.12444866f, -0.05623634f, 0.00223861f, -0.08017416f, -0.06116063f, -0.04063797f, -0.14102316f, 
    -0.12288115f, 0.26358348f, 0.30755553f, -0.06144894f, -0.18522160f, -0.19026291f, -0.02469437f, -0.26606187f, 
    0.11317307f, -0.01710984f, 0.19909802f, 0.11946331f, 0.02302084f, 0.17004898f, -0.27529424f, -0.27360928f, 
    -0.15265208f, -0.03187934f, -0.01314266f, 0.07985492f, 0.02783513f, 0.01595775f, -0.04331442f, -0.02239950f, 
    -0.31501636f, 0.23138160f, 0.19923456f, -0.00968277f, -0.10585131f, 0.05274116f, -0.27831435f, 0.11583120f, 
    0.17848550f, 0.01690463f, 0.06883150f, -0.00723417f, -0.03233833f, -0.03445231f, -0.17466955f, -0.01479547f, 
    -0.08201381f, -0.24735324f, 0.09851807f, -0.20802011f, -0.05953312f, 0.00463821f, -0.16956882f, 0.12007388f, 
    0.06356580f, 0.23052809f, -0.01813166f, 0.08001089f, -0.02024125f, 0.00883020f, 0.05773713f, 0.02628715f, 
    0.15667516f, 0.13980308f, -0.02007829f, -0.01398173f, 0.10371878f, -0.06770851f, 0.13828772f, -0.06368602f, 
    0.09448075f, 0.10615730f, -0.01464061f, 0.00214963f, 0.08801407f, -0.06105036f, 0.05281948f, -0.10285100f, 
    0.05095293f, 0.20020187f, 0.04542621f, -0.02587914f, -0.03127323f, -0.00878189f, -0.05325112f, -0.05862170f, 
    0.14221817f, 0.14495687f, -0.00473050f, -0.22120908f, 0.17726618f, 0.08949029f, 0.01633640f, -0.09957104f, 
    0.01898053f, 0.13728647f, -0.00561602f, 0.11347414f, 0.03830378f, 0.04724485f, -0.06951846f, -0.12130506f, 
    0.12630729f, -0.27352554f, -0.12640017f, 0.17913711f, -0.00266767f, 0.09595454f, 0.04549230f, -0.03373215f, 
    -0.17172854f, 0.15492532f, -0.13764560f, 0.10623489f, 0.08198556f, 0.00186676f, 0.00414992f, -0.10636825f, 
    0.02343541f, 0.08148034f, 0.02668759f, 0.10988804f, -0.04093428f, 0.05506159f, 0.03502784f, -0.12094614f, 
    0.02164777f, 0.36441442f, 0.07130588f, -0.13891190f, -0.16927320f, 0.01064323f, 0.13406132f, 0.17155746f, 
    0.01361760f, 0.05425103f, 0.08839119f, -0.09915909f, -0.07356671f, 0.05084904f, -0.01184183f, -0.00859456f, 
    -0.15852855f, 0.07637895f, 0.04652824f, -0.03112681f, -0.01940566f, -0.03758872f, 0.02656109f, -0.08381993f, 
    0.07838245f, -0.14265826f, -0.04071105f, -0.06482568f, -0.13795239f, 0.03346260f, -0.04381784f, 0.06246255f, 
    0.03826215f, 0.02037022f, -0.16965777f, -0.04875036f, 0.12024079f, 0.05842305f, 0.14347462f, 0.00694044f, 
    -0.05176176f, 0.09441819f, -0.01238100f, 0.09020545f, 0.01250552f, 0.03836702f, -0.11271540f, -0.10799827f, 
    -0.11582201f, -0.17756966f, 0.14674968f, -0.01900863f, -0.08592747f, 0.02589069f, -0.09425898f, 0.01458756f, 
    0.05391735f, -0.06849416f, -0.11328711f, 0.02236074f, 0.02322891f, -0.21204652f, 0.03704617f, 0.25500914f, 
    0.06091450f, 0.12845658f, 0.14106999f, 0.03224091f, 0.02918606f, 0.02014268f, 0.08167285f, -0.02812386f, 
    -0.32720742f, 0.12042944f, -0.09692477f, -0.23346627f, 0.03019555f, 0.15663075f, 0.02462971f, -0.06281136f, 
    0.04308629f, -0.10202793f, -0.00319485f, -0.03157153f, -0.07140849f, -0.38008833f, -0.10841347f, -0.09308713f, 
    0.01907049f, -0.05922039f, -0.03780995f, 0.05385452f, 0.03028750f, -0.10924143f, -0.12026915f, -0.09825647f, 
    -0.03439180f, -0.01730909f, 0.04990517f, 0.06460252f, -0.04540255f, 0.05600595f, -0.04069059f, -0.07292798f, 
    0.02880646f, 0.00301690f, 0.00882338f, -0.05339483f, -0.06080287f, 0.00300441f, 0.03102307f, -0.06416223f, 
    -0.07025697f, 0.00342586f, -0.02572658f, 0.01686112f, -0.02525680f, 0.01146560f, -0.03967353f, -0.02123415f, 
    0.00665724f, -0.05984149f, -0.07176653f, -0.02998853f, 0.00404629f, 0.03644864f, 0.05996617f, 0.02649053f, 
    0.00558253f, -0.01366676f, -0.04987805f, 0.04044427f, 0.01980579f, -0.02091873f, -0.02773143f, -0.07703557f, 
    -0.01894501f, 0.03202513f, 0.04225035f, -0.04774768f, 0.05745981f, 0.00049418f, 0.03815587f, -0.06152746f, 
    0.05956150f, -0.01109578f, -0.03425058f, -0.02969277f, -0.06601977f, 0.02024398f, 0.01654361f, -0.01773923f, 
    -0.04336266f, 0.01511545f, 0.00010359f, -0.06496163f, -0.01671461f, 0.05052517f, -0.05980197f, 0.03564277f, 
    0.03452078f, -0.05275261f, 0.02902580f, -0.03738157f, -0.02690335f, 0.06349269f, -0.00337224f, -0.04112440f, 
    -0.00781268f, -0.01941394f, 0.06368658f, -0.06374514f, -0.01091757f, 0.06408168f, -0.00175170f, 0.01743633f, 
    0.04367257f, 0.05828998f, -0.00205417f, 0.01293962f, 0.00794770f, -0.02249386f, -0.03652667f, -0.00040713f, 
    0.02678655f, -0.02485033f, 0.01094585f, 0.02799581f, 0.03646836f, 0.02642842f, -0.00942317f, -0.06911243f, 
    -0.03422678f, -0.01726672f, -0.00716088f, -0.06684946f, -0.01498172f, 0.02967510f, -0.06064571f, 0.05929818f, 
    -0.03454164f, 0.03253397f, -0.06703889f, -0.05486956f, -0.00059252f, 0.00005462f, 0.05217795f, -0.02428610f, 
    0.01988126f, -0.05660952f, -0.04265535f, -0.01023023f, -0.07551380f, -0.06900308f, 0.02333671f, -0.02060091f, 
    -0.00341420f, 0.02426435f, 0.06466044f, 0.02293339f, -0.02521012f, 0.04278822f, -0.01950575f, 0.03254169f, 
    -0.06674254f, -0.06193479f, -0.04207772f, -0.03399809f, 0.01487895f, -0.02037226f, -0.01346523f, -0.05835078f, 
    -0.00459221f, -0.01892386f, 0.01219924f, 0.02400521f, -0.03771776f, -0.05193636f, -0.05608407f, -0.00405749f, 
    0.00799936f, -0.06500757f, 0.00299411f, 0.03882676f, 0.06034687f, -0.05329101f, -0.07096605f, -0.01816002f, 
    -0.02067622f, -0.03385358f, 0.05460819f, 0.05329638f, 0.01290737f, 0.05888593f, -0.07715321f, -0.00350972f, 
    0.01675135f, -0.02389872f, 0.06452146f, -0.07320291f, 0.05922765f, 0.06264271f, -0.07151169f, 0.03725526f, 
    -0.06967989f, -0.01900451f, 0.01786574f, -0.03388306f, -0.06443737f, -0.00948865f, 0.02064267f, 0.06636522f, 
    0.00629162f, 0.03499302f, -0.02767667f, -0.05361504f, 0.02916055f, -0.05597373f, -0.02656618f, -0.00508204f, 
    -0.01329274f, -0.06411625f, 0.02795063f, -0.04500091f, -0.02275006f, -0.03911689f, -0.05035448f, -0.06817053f, 
    -0.27809510f, 0.22176775f, 0.22270975f, 0.03332949f, -0.08182181f, 0.18986194f, 0.02540021f, 0.01050508f, 
    0.09796851f, 0.04065812f, 0.09853920f, 0.00029566f, 0.13040648f, 0.08607725f, -0.06218010f, -0.02989781f, 
    -0.08570176f, -0.09206655f, -0.11179863f, 0.01893964f, -0.17811126f, -0.12292766f, 0.00791572f, -0.03699996f, 
    -0.32954034f, -0.46237615f, -0.07099511f, -0.01665630f, 0.10153513f, -0.03121629f, -0.10710000f, -0.10205968f, 
    0.01897303f, -0.04867081f, -0.05166018f, 0.05550134f, -0.17758229f, -0.14157960f, -0.11803973f, 0.19485612f, 
    -0.03133309f, 0.06658617f, 0.12695913f, -0.09274813f, 0.01326481f, -0.04842232f, -0.00245328f, 0.07829706f, 
    -0.16766211f, 0.13101095f, -0.22423173f, -0.06489334f, -0.03220435f, 0.05353107f, 0.10914687f, 0.08309323f, 
    0.04629669f, 0.05532502f, 0.14980067f, -0.09180923f, -0.07920010f, -0.21340181f, 0.07606878f, 0.18627699f, 
    0.07944095f, 0.15744267f, 0.12234074f, -0.02091563f, -0.00785185f, 0.06508054f, -0.11204410f, 0.00898606f, 
    -0.00746569f, -0.26838008f, 0.17264169f, -0.08642431f, 0.12982211f, -0.00387589f, -0.10945597f, 0.04017516f, 
    -0.02694775f, 0.00315738f, 0.17296597f, -0.01356217f, -0.09376930f, 0.03339416f, 0.07324184f, 0.31807160f, 
    0.10458328f, -0.15071344f, 0.28481096f, 0.11591995f, 0.00159120f, -0.00029799f, -0.01688167f, -0.02243404f, 
    -0.20747840f, 0.03597737f, 0.09512687f, 0.21152949f, -0.02545247f, -0.02027940f, 0.04535723f, 0.06826806f, 
    0.15659894f, 0.12251412f, 0.01760949f, -0.04785869f, -0.05019912f, 0.01658909f, -0.02002394f, -0.12863186f, 
    -0.03133466f, -0.06357083f, 0.04528673f, 0.00255700f, 0.05193956f, 0.03324763f, 0.12104059f, 0.12610783f, 
    -0.24534225f, 0.30739978f, -0.28694820f, 0.06784675f, 0.32402843f, 0.09523091f, 0.16815642f, 0.30363256f, 
    0.06988458f, 0.10287573f, 0.17978682f, 0.05976630f, -0.34049761f, -0.03037591f, 0.15782095f, 0.18391313f, 
    -0.13531327f, -0.00632338f, -0.00111703f, 0.08471716f, 0.02063718f, 0.12518768f, -0.15192378f, 0.09014055f, 
    -0.11772567f, 0.23038675f, -0.08597492f, -0.07159761f, 0.01201482f, -0.01380865f, 0.05372016f, 0.02864617f, 
    0.02944469f, -0.05928506f, 0.07328451f, 0.00186250f, -0.21030158f, 0.01049064f, -0.01356584f, 0.20605023f, 
    0.14437474f, -0.04763448f, 0.12650102f, 0.10162506f, -0.08384865f, -0.01013751f, 0.13098928f, -0.03724156f, 
    0.20617792f, -0.00264209f, -0.22323598f, 0.11470328f, -0.03357958f, 0.13850495f, 0.08091771f, 0.10849061f, 
    -0.07775625f, 0.03512375f, -0.15103118f, -0.05399612f, -0.10343753f, 0.38713315f, -0.22038861f, 0.03867646f, 
    -0.05438204f, 0.06499422f, -0.04680465f, -0.01123624f, -0.08701781f, 0.01556879f, 0.01373426f, 0.02745943f, 
    0.38410768f, 0.20180093f, -0.11082563f, 0.11605425f, -0.03977563f, 0.05614133f, 0.04637795f, -0.09656988f, 
    0.05561714f, 0.08073704f, 0.05467569f, -0.00952939f, -0.10409366f, 0.01790615f, 0.06574669f, -0.12780985f, 
    -0.04376728f, -0.01887887f, -0.04856471f, 0.00339304f, -0.09784395f, 0.09071501f, -0.07927587f, -0.05420961f, 
    0.02196194f, -0.09401987f, -0.11596279f, -0.02254698f, 0.03999326f, 0.03681793f, 0.24106868f, 0.07900982f, 
    -0.01659224f, 0.00737365f, 0.00891203f, -0.03654226f, 0.04576644f, 0.17981637f, -0.06687540f, 0.10159697f, 
    0.04009074f, 0.04054591f, 0.13350993f, 0.03556561f, 0.02986129f, -0.07860061f, -0.02022565f, 0.02552834f, 
    0.20226517f, 0.20519525f, 0.03778692f, -0.02633508f, 0.06143430f, -0.07761766f, 0.06324646f, -0.00575257f, 
    -0.05928047f, 0.01873677f, -0.11801122f, -0.09915835f, 0.07921330f, 0.15083827f, -0.08858155f, -0.05249021f, 
    0.10568710f, 0.23858964f, -0.04001881f, -0.09731561f, -0.13784459f, -0.01949548f, -0.00910180f, -0.15115525f, 
    -0.20086645f, -0.15901734f, 0.09004489f, 0.11388089f, -0.16153058f, -0.01105064f, 0.15360980f, -0.09752183f, 
    -0.15520462f, 0.04273770f, 0.10552102f, 0.15547659f, 0.05681388f, -0.13118738f, -0.16141473f, 0.00971007f, 
    -0.03850371f, 0.13908842f, -0.08825828f, -0.05498460f, -0.00616661f, -0.01586720f, 0.04974300f, -0.08787908f, 
    0.08142849f, -0.16418351f, -0.07792623f, -0.08998535f, 0.04801658f, -0.00226805f, 0.20982598f, 0.12605213f, 
    -0.21095106f, -0.14259830f, -0.10254287f, -0.06828938f, -0.05302947f, 0.06192928f, 0.01856337f, -0.01217733f, 
    -0.18613186f, 0.00188187f, 0.03470916f, -0.02928638f, 0.02703267f, 0.04230230f, 0.13628615f, 0.09888013f, 
    0.14171651f, 0.42004606f, -0.15513918f, -0.13839912f, 0.14235936f, -0.06206274f, 0.16283727f, 0.07357174f, 
    0.20640726f, -0.09567315f, -0.02266133f, -0.08789848f, -0.00516744f, -0.05887764f, -0.12674299f, -0.00547819f, 
    -0.10367104f, 0.16539335f, 0.09758223f, -0.09202472f, 0.02282514f, 0.07354756f, 0.10747182f, -0.01759448f, 
    -0.02466746f, 0.07337400f, -0.21481839f, 0.02188443f, -0.08941723f, -0.04426982f, -0.07318354f, -0.03717164f, 
    -0.09307115f, -0.11907920f, -0.14187172f, -0.14122906f, -0.02032073f, 0.37576029f, -0.20281446f, 0.21229549f, 
    0.09581178f, 0.00058021f, -0.12884608f, -0.11464097f, 0.01271439f, -0.07125393f, 0.08901817f, -0.03298884f, 
    -0.24460980f, 0.12398909f, 0.24201865f, -0.23613000f, 0.03140887f, -0.06912490f, -0.00760013f, 0.02405558f, 
    -0.01779179f, 0.07021914f, -0.06760111f, -0.17203671f, 0.03158844f, 0.16641691f, -0.22430182f, 0.08076771f, 
    -0.22893898f, -0.05960427f, 0.01674254f, -0.13865919f, -0.04749933f, 0.09134010f, 0.05872801f, 0.05386799f, 
    -0.09712583f, 0.44009829f, 0.04224165f, -0.39424312f, -0.02485857f, 0.00448954f, 0.04435439f, -0.15037993f, 
    -0.06458499f, -0.05846225f, -0.14097847f, 0.08866238f, -0.06031652f, 0.00921639f, -0.15490514f, -0.21223456f, 
    0.01353216f, 0.01792433f, 0.10202589f, -0.04575190f, -0.13911147f, 0.03880358f, 0.05036961f, -0.13765942f, 
    -0.01390420f, -0.20937103f, -0.12989450f, 0.19770727f, 0.12881710f, 0.12652557f, -0.02311651f, -0.07860935f, 
    0.01580337f, -0.02179830f, -0.07737771f, -0.01570184f, -0.07678780f, 0.08936783f, -0.22352502f, 0.20789360f, 
    0.07892236f, 0.00659459f, 0.00013574f, -0.01369115f, 0.01732768f, 0.06627760f, -0.03072498f, 0.09001620f, 
    -0.10385627f, -0.05375250f, -0.17792299f, -0.01261028f, -0.06486721f, 0.07416451f, 0.06505436f, 0.21266975f, 
    -0.14398143f, 0.00845778f, 0.06121873f, 0.01384671f, -0.11624575f, -0.15096220f, 0.01649718f, 0.25030759f, 
    0.03881851f, 0.13365965f, 0.01075630f, -0.09068839f, -0.05485813f, 0.06146019f, 0.02246067f, -0.04106523f, 
    -0.14085940f, 0.14205056f, 0.05140391f, 0.08012696f, -0.01614071f, 0.06323368f, -0.09763672f, -0.05921583f, 
    -0.00045602f, 0.07595228f, 0.04822003f, -0.05414742f, -0.13587844f, -0.10243714f, 0.04851308f, 0.39387575f, 
    -0.10249689f, -0.15156829f, 0.04867127f, -0.08940241f, 0.05591447f, 0.02079863f, 0.07772525f, 0.12520893f, 
    0.14910363f, -0.13279139f, 0.21292649f, 0.10786820f, 0.13486913f, -0.09891041f, 0.13485079f, -0.01677044f, 
    -0.04989897f, -0.03064683f, 0.07834673f, -0.07752528f, -0.05580187f, -0.12951943f, -0.15322717f, -0.28854334f, 
    -0.06492966f, -0.06942696f, 0.04864267f, -0.05804727f, -0.10245226f, -0.06712226f, -0.05414882f, 0.04474059f, 
    -0.02986314f, 0.41221517f, -0.11079103f, -0.13801995f, 0.04413034f, 0.07027667f, -0.04510841f, -0.05767302f, 
    -0.06804693f, 0.01229245f, -0.00894495f, 0.02459782f, 0.12520905f, 0.01519302f, 0.12148323f, 0.23601213f, 
    0.08117484f, -0.06536677f, -0.01411331f, 0.01452109f, 0.11330260f, 0.04401985f, 0.05919900f, 0.19630429f, 
    0.14465807f, 0.13397668f, -0.04107491f, -0.28137019f, -0.00984390f, -0.06423145f, 0.02542824f, 0.03833634f, 
    -0.08200882f, 0.19432165f, -0.01794602f, -0.02338416f, 0.04281442f, 0.08217079f, 0.23791355f, -0.06960566f, 
    0.10585500f, -0.14981236f, -0.09442774f, -0.05090123f, 0.02318211f, 0.01842001f, -0.01798242f, 0.04012643f, 
    0.32286921f, -0.06133183f, -0.09118972f, 0.19088103f, -0.17125456f, 0.14934464f, 0.05120179f, 0.14071831f, 
    -0.12841281f, 0.07549902f, -0.11148290f, 0.03595704f, -0.34254980f, 0.19140998f, 0.11700129f, 0.11820365f, 
    0.03689777f, -0.04837660f, 0.01337600f, 0.00098776f, -0.00349976f, -0.00581161f, 0.03524375f, 0.06543557f, 
    -0.54161841f, 0.25363880f, 0.46544150f, -0.21541280f, -0.00326334f, -0.03956243f, -0.14406422f, -0.02049986f, 
    0.12563460f, 0.06404559f, 0.15191995f, 0.04174620f, 0.07207347f, 0.06990577f, -0.26953375f, -0.09121033f, 
    0.08249307f, -0.19397865f, 0.05355004f, -0.04720273f, -0.03824069f, 0.03383597f, -0.06975098f, 0.11031348f, 
    -0.04798891f, 0.23658277f, -0.06545440f, -0.09656020f, 0.01816396f, -0.02525487f, -0.08444984f, -0.08509214f, 
    0.07038852f, 0.13367666f, 0.03294706f, 0.13684082f, 0.05676953f, -0.06726036f, 0.05334865f, -0.17771623f, 
    0.02278942f, 0.09269624f, -0.00181753f, 0.01775065f, 0.15148473f, 0.08002533f, 0.17705156f, 0.03719686f, 
    -0.18378162f, 0.01378723f, 0.05609543f, -0.04394269f, -0.13301404f, 0.07347979f, -0.05064519f, 0.12958947f, 
    0.03325447f, -0.11375930f, 0.05655191f, -0.17992009f, -0.03179743f, -0.10862408f, 0.12115861f, -0.06681871f, 
    0.02973399f, -0.01678635f, 0.02136974f, 0.12011534f, -0.04769421f, 0.02344314f, -0.03465331f, -0.07922175f, 
    -0.01558225f, -0.04719292f, -0.13503093f, -0.09029838f, 0.10337049f, -0.00923976f, 0.13935442f, -0.03440409f, 
    0.12051344f, 0.06043425f, -0.09591422f, -0.07269625f, 0.04937984f, 0.05476075f, -0.03220780f, -0.13713682f, 
    0.04963037f, 0.06994626f, 0.17036550f, 0.05546433f, 0.10265195f, -0.03790821f, 0.00998256f, -0.11188389f, 
    -0.00178300f, 0.20259394f, 0.34178969f, -0.14229302f, -0.09039379f, 0.03395219f, 0.02000373f, 0.12232484f, 
    0.00412578f, 0.03456268f, 0.04633585f, 0.05902494f, -0.12192808f, 0.01551903f, 0.04772305f, -0.15677401f, 
    0.02129437f, -0.04519707f, 0.00208404f, -0.01192884f, -0.00299685f, -0.03582358f, 0.01639679f, -0.02708659f, 
    0.08899494f, -0.17515160f, 0.17363887f, -0.04408529f, -0.06926677f, 0.05130334f, 0.11023239f, 0.01868553f, 
    -0.06706923f, 0.09621205f, -0.14844249f, 0.02256262f, -0.09761033f, 0.15176690f, 0.26944250f, -0.04814205f, 
    -0.21326625f, 0.06036283f, 0.03325576f, 0.14775078f, 0.27073705f, 0.08645680f, -0.07423363f, -0.12647761f, 
    0.02823468f, -0.08885031f, 0.23568939f, -0.05549984f, -0.11948022f, -0.06532551f, 0.04782109f, -0.08019657f, 
    0.15034500f, -0.12186032f, -0.03722478f, -0.02878116f, 0.16509010f, -0.18032575f, 0.31206834f, 0.16734560f, 
    0.21290725f, 0.15950264f, 0.05008321f, 0.16392641f, 0.07289211f, 0.05272147f, 0.09899670f, 0.00001951f, 
    -0.18603566f, -0.09958056f, -0.19080634f, 0.03868830f, -0.04351641f, 0.20980710f, 0.00306890f, 0.02718315f, 
    0.02261735f, -0.05693546f, 0.04401657f, -0.06043216f, -0.09912247f, -0.26095870f, 0.21158080f, 0.13190286f, 
    0.10237382f, 0.10361656f, -0.03461499f, -0.03039483f, 0.04346080f, -0.11219814f, -0.05276810f, 0.01144549f, 
    0.00402241f, 0.05067009f, 0.01003407f, 0.00047687f, -0.03894966f, 0.04361575f, 0.02668143f, -0.07426006f, 
    0.03291756f, 0.01546408f, 0.04580417f, -0.06093956f, -0.06914064f, -0.06874721f, -0.05766170f, 0.04519543f, 
    0.02709838f, -0.07120767f, -0.08983213f, -0.08713749f, -0.08295382f, -0.04069557f, -0.02107710f, -0.03930574f, 
    0.00436040f, -0.07545009f, -0.02917040f, 0.02247884f, 0.05646987f, 0.02261818f, -0.07606135f, -0.02641525f, 
    -0.07625005f, -0.00432280f, 0.05258119f, -0.03300940f, 0.01565042f, -0.00842210f, 0.02564703f, -0.00433627f, 
    0.01266775f, -0.05165534f, -0.00058185f, -0.04901659f, -0.05313080f, 0.00492914f, 0.03459102f, -0.00586990f, 
    -0.05926125f, 0.04196525f, -0.06160429f, -0.05787566f, 0.03787312f, -0.05227336f, 0.04246658f, -0.04065838f, 
    0.03287717f, 0.00315780f, -0.05201080f, 0.01955870f, -0.05164534f, 0.01693988f, 0.00608400f, 0.03917954f, 
    0.00302124f, -0.05395715f, 0.00873807f, -0.02995311f, -0.00129935f, -0.04421069f, -0.01439328f, -0.00737520f, 
    -0.04145371f, -0.00418483f, 0.03929353f, 0.01349193f, 0.02739377f, 0.04777157f, -0.00694643f, -0.01691049f, 
    -0.00791808f, 0.00892578f, -0.00977679f, -0.03554799f, 0.04977711f, -0.02562938f, 0.00457961f, -0.02024960f, 
    -0.00148406f, -0.01296182f, -0.03944460f, 0.03277537f, -0.07505371f, 0.00864784f, -0.02764510f, -0.06461743f, 
    -0.08082865f, 0.06452590f, -0.07033753f, -0.03040378f, -0.07657303f, 0.00621357f, -0.06977434f, -0.05122616f, 
    0.04986106f, 0.04576064f, -0.00870419f, 0.04432086f, -0.06574920f, -0.02534340f, -0.05200271f, -0.04613352f, 
    -0.05984846f, -0.06840558f, 0.01521054f, 0.03309086f, -0.03669011f, 0.01304939f, -0.06024030f, -0.06838819f, 
    0.00042762f, -0.01884176f, -0.00050396f, 0.05728504f, 0.02530028f, -0.06220583f, -0.05019252f, 0.05765107f, 
    -0.00951352f, 0.05542440f, -0.04131389f, 0.04143397f, -0.02089415f, -0.02148772f, 0.04594988f, -0.02299393f, 
    0.01281282f, -0.05020148f, -0.01477598f, 0.06273849f, -0.02613220f, -0.03993540f, 0.00848731f, -0.02000455f, 
    -0.04001448f, -0.05904165f, -0.02631507f, 0.03456923f, -0.05005573f, 0.05772338f, -0.01105873f, -0.08005058f, 
    0.00585262f, 0.06637439f, 0.00714129f, -0.07826606f, -0.07837076f, 0.02355433f, -0.03537289f, 0.03627023f, 
    -0.00821916f, 0.03442317f, -0.04846742f, 0.05447448f, 0.04247576f, 0.02208966f, -0.03071677f, -0.01332750f, 
    -0.01660926f, -0.02417705f, -0.07621772f, -0.03900695f, -0.01267833f, -0.00963912f, -0.05869510f, 0.04939921f, 
    -0.06422798f, 0.01790327f, 0.04706714f, -0.04530555f, 0.03643035f, 0.03513720f, -0.00188377f, -0.07177481f, 
    -0.04008469f, -0.05050688f, -0.07214332f, -0.07067035f, -0.02848455f, -0.07308672f, -0.04626261f, -0.06405173f, 
    0.04056495f, 0.03298652f, -0.01236280f, -0.07685655f, 0.04949868f, -0.04978666f, 0.01404503f, -0.07041477f, 
    0.02435980f, -0.07814121f, 0.03957050f, -0.04392800f, -0.06165882f, -0.05246821f, -0.02696795f, 0.02932957f, 
    -0.03914546f, -0.05021473f, 0.03608490f, 0.02154604f, 0.03898959f, 0.00196014f, 0.03259944f, 0.00174826f, 
    -0.00439615f, -0.05850628f, 0.01113284f, 0.03111478f, -0.03612408f, 0.02092510f, 0.02488159f, 0.03184956f, 
    0.00511003f, 0.02438030f, 0.03998236f, -0.01952094f, 0.05259896f, 0.03813984f, 0.02270325f, 0.02427166f, 
    0.03981151f, 0.04405407f, -0.05700533f, -0.01425278f, -0.02416467f, -0.07445253f, 0.02745265f, -0.03081580f, 
    0.03133604f, -0.01945849f, -0.05424247f, -0.02878265f, -0.06577411f, -0.06735984f, 0.02093475f, -0.02238006f, 
    0.00652391f, -0.00954320f, -0.06891322f, 0.03127268f, 0.04329891f, -0.04125936f, -0.06419491f, -0.01975485f, 
    0.05982812f, 0.03590839f, -0.00818064f, 0.06030839f, -0.00082140f, -0.04302892f, 0.01328517f, -0.06382656f, 
    -0.05882867f, 0.00291217f, -0.07139270f, 0.02113137f, -0.00748305f, 0.01451662f, -0.03554020f, -0.01925037f, 
    -0.06128344f, -0.04755482f, -0.07243603f, -0.04458198f, 0.00465724f, 0.01915302f, -0.05216124f, -0.02165953f, 
    -0.06825747f, -0.05569519f, -0.00944201f, 0.02934669f, -0.05807344f, 0.06111863f, -0.07886581f, -0.03972441f, 
    0.04642714f, -0.06355295f, -0.07633512f, 0.05219994f, 0.00773565f, 0.02865806f, -0.02343839f, -0.00752283f, 
    0.03036029f, -0.03672455f, -0.08070118f, -0.04336533f, 0.02911123f, 0.03018466f, -0.05602571f, 0.03046898f, 
    -0.07453723f, -0.01175583f, -0.06877772f, 0.05455533f, 0.04627182f, -0.06641387f, -0.07185095f, -0.01971371f, 
    -0.00125474f, -0.04028535f, -0.07263412f, 0.02172839f, -0.04339215f, -0.00085391f, -0.03287001f, 0.04985694f, 
    0.00793496f, -0.06744698f, -0.01691546f, 0.03512437f, 0.05269024f, -0.05819684f, 0.01468008f, 0.05718450f, 
    -0.03788221f, -0.04820634f, 0.05775890f, 0.00871477f, -0.03556297f, 0.03950457f, -0.05147292f, -0.08006887f, 
    -0.04877789f, -0.02189310f, 0.02818722f, -0.04570117f, -0.07112122f, -0.01119495f, -0.06308047f, 0.04620644f, 
    0.05503757f, -0.07208433f, -0.05404212f, -0.04376338f, 0.02708556f, 0.01713043f, 0.04886811f, -0.03390172f, 
    -0.04674676f, 0.03495148f, 0.03286959f, 0.04126536f, 0.01748371f, 0.04869916f, -0.05969788f, 0.04958753f, 
    -0.02677977f, 0.02570751f, 0.03740559f, 0.02938177f, -0.03718159f, 0.01883056f, -0.01198829f, -0.06932830f, 
    -0.02088931f, -0.04944173f, 0.03408271f, -0.06307398f, -0.01998784f, 0.01285648f, -0.02170144f, -0.06242470f, 
    -0.04164241f, -0.05358334f, -0.06192018f, -0.05551979f, 0.05474132f, 0.01528469f, 0.06186013f, -0.00663366f, 
    0.06817013f, -0.09881078f, 0.04158210f, -0.13536905f, 0.09123115f, -0.09885135f, -0.08571590f, -0.12767544f, 
    0.03660318f, 0.11864118f, -0.01480766f, 0.05473183f, -0.30781141f, -0.20063242f, -0.17816277f, -0.00770460f, 
    -0.00620620f, -0.03420396f, -0.04606314f, -0.08449159f, 0.20848121f, 0.08904031f, -0.06502224f, 0.18788795f, 
    -0.02770718f, 0.15277641f, 0.14756733f, 0.27912322f, 0.19742963f, 0.14182256f, -0.05757113f, 0.11472593f, 
    -0.03171602f, -0.01682036f, -0.04489693f, -0.10833848f, -0.17453402f, 0.14654307f, 0.00037462f, 0.16398779f, 
    0.02715866f, 0.14528617f, 0.06172108f, 0.20433758f, 0.05591284f, -0.00737878f, 0.01187000f, 0.09991664f, 
    -0.12153414f, -0.15092106f, -0.08835311f, 0.07615840f, -0.08208268f, -0.11767860f, -0.22646789f, 0.12216104f, 
    0.00157858f, -0.03647551f, -0.02559195f, 0.22093931f, -0.11778461f, -0.20436102f, 0.03073662f, -0.03969415f, 
    0.05927994f, -0.15139323f, -0.16479675f, 0.12317055f, -0.14602920f, 0.07674362f, -0.00877597f, 0.10245378f, 
    -0.18457472f, 0.28220198f, -0.09745134f, -0.10270789f, 0.10088988f, 0.13523676f, 0.16253017f, -0.01830754f, 
    0.16304812f, -0.06681385f, -0.17657898f, -0.16710082f, -0.03694392f, 0.08687571f, 0.15562262f, 0.18577887f, 
    -0.12877388f, 0.03328137f, -0.01715716f, -0.01940033f, 0.03346515f, -0.01942552f, -0.23136733f, 0.01204987f, 
    0.06718791f, 0.01495207f, 0.17722186f, 0.04960231f, 0.09617832f, -0.00362588f, -0.04712113f, -0.01176677f, 
    0.00538736f, 0.02963514f, 0.02090329f, -0.03824572f, -0.20903140f, -0.24721152f, 0.04283880f, 0.02408765f, 
    0.05592897f, -0.23246585f, -0.13089012f, -0.05249181f, -0.06876279f, 0.07379153f, 0.06945495f, -0.09971327f, 
    -0.17211771f, 0.02824217f, 0.16983902f, 0.11116923f, 0.02833607f, 0.04658810f, 0.02577626f, -0.10020910f, 
    -0.07639287f, 0.02632326f, -0.12993340f, -0.03660482f, 0.15532954f, 0.04377174f, 0.01311085f, -0.09081291f, 
    0.09703650f, -0.03205029f, -0.04662381f, -0.27343583f, 0.21630585f, -0.05463075f, 0.07259686f, -0.06650524f, 
    0.11778780f, 0.10507391f, 0.08082863f, -0.14528026f, -0.02409561f, -0.00555549f, 0.03107249f, -0.13264638f, 
    0.02799940f, -0.10513809f, 0.01956052f, 0.07578185f, -0.10896263f, -0.01347835f, 0.45059881f, -0.14322735f, 
    0.09744842f, 0.06705517f, -0.04474630f, -0.01804608f, -0.09183419f, 0.06721455f, -0.06155284f, -0.19585656f, 
    -0.00328144f, -0.19654532f, 0.04699415f, 0.25264207f, -0.07066009f, 0.14811702f, -0.11554112f, -0.14917758f, 
    0.04307894f, 0.21098766f, 0.03421562f, -0.08357389f, -0.19061643f, -0.00021061f, 0.31822363f, 0.01415891f, 
    0.13141495f, 0.11713812f, 0.14780481f, 0.07536862f, -0.02918949f, -0.08635484f, -0.18604092f, -0.03027352f, 
    0.02081557f, 0.14675708f, 0.18395172f, 0.16251072f, -0.10130461f, 0.24167694f, -0.03823886f, 0.15249167f, 
    0.05201964f, 0.09446920f, 0.00021656f, -0.04469200f, 0.13873278f, 0.00469898f, 0.15610223f, 0.10513204f, 
    0.05428816f, -0.01647294f, -0.05478992f, 0.12161786f, -0.02845360f, -0.10161895f, 0.10361982f, 0.08299244f, 
    -0.01709080f, -0.02599145f, -0.03494879f, -0.21549445f, -0.05393706f, -0.06272946f, -0.02657519f, -0.22236846f, 
    -0.08790278f, -0.06213050f, -0.04377141f, 0.03589508f, 0.20159627f, -0.03743967f, 0.26816934f, -0.02621105f, 
    0.02213064f, 0.15727508f, 0.04692204f, -0.10949556f, -0.08626625f, -0.00218372f, -0.02682006f, -0.10405456f, 
    0.10123638f, 0.23044439f, -0.02075002f, -0.12406389f, -0.04212978f, -0.02056986f, 0.15055709f, -0.17537127f, 
    -0.00287548f, 0.00971548f, 0.00748421f, -0.02664922f, 0.06059343f, 0.18525927f, 0.09107876f, 0.06583662f, 
    -0.02014888f, 0.05590000f, 0.16217898f, -0.01157786f, -0.01816772f, -0.00251699f, -0.07853777f, -0.07512040f, 
    0.15377107f, -0.33294457f, 0.02184882f, -0.02725891f, 0.14340611f, 0.01071533f, -0.06853724f, 0.00889780f, 
    -0.18659319f, -0.03405495f, 0.06376015f, 0.08574111f, 0.03703684f, 0.00381377f, -0.11699594f, -0.09017368f, 
    0.16632426f, 0.06929290f, 0.01788265f, 0.01176209f, -0.08442078f, 0.01702884f, -0.00285747f, -0.15309782f, 
    -0.26695591f, 0.10585566f, -0.11239111f, 0.17286117f, -0.05674852f, 0.07094225f, 0.17328511f, 0.26957747f, 
    -0.02160462f, 0.06845234f, -0.07200373f, -0.02651907f, 0.00341976f, 0.07186768f, 0.08065467f, 0.18861121f, 
    -0.11272923f, -0.02193640f, -0.00443786f, 0.04265495f, -0.02569380f, 0.03189867f, 0.03819165f, 0.15140732f, 
    -0.03376619f, 0.14979489f, 0.03954844f, -0.00036409f, 0.04284792f, 0.04323821f, 0.12074882f, 0.12119414f, 
    0.12131957f, 0.11844035f, 0.10668597f, 0.02700164f, -0.29974642f, 0.21042866f, -0.11525848f, 0.02652190f, 
    -0.19777128f, 0.11847492f, 0.00240642f, 0.03988490f, -0.04330171f, 0.09538189f, -0.14081649f, -0.17040788f, 
    -0.17259721f, 0.04869565f, -0.12506747f, -0.10911816f, -0.07828771f, -0.08047387f, -0.00197380f, 0.03586344f, 
    0.07188041f, -0.14590594f, 0.08662355f, 0.01888551f, -0.05476675f, 0.32799304f, -0.09227885f, 0.23350076f, 
    0.09385522f, -0.06822076f, 0.02695441f, 0.23121113f, -0.04882551f, 0.05345945f, 0.03407396f, -0.01904899f, 
    -0.27633357f, 0.01687041f, 0.21802928f, -0.15923755f, -0.01684648f, 0.06187089f, -0.00261718f, 0.12434976f, 
    0.06446808f, 0.00234785f, -0.03885500f, 0.00291003f, 0.17667231f, 0.28284982f, -0.18968758f, 0.13866958f, 
    -0.14181125f, -0.05990800f, -0.07490440f, -0.02743378f, -0.08486795f, 0.02023793f, -0.04685884f, 0.04438015f, 
    -0.36671564f, -0.11974059f, 0.02502990f, -0.20270991f, 0.01565063f, -0.08335271f, -0.04302264f, 0.04331547f, 
    0.11649064f, 0.15983321f, 0.05880165f, 0.05027224f, -0.17408237f, -0.16697717f, -0.35431126f, 0.06545100f, 
    0.02576166f, 0.08182555f, 0.05962305f, -0.14442809f, 0.03574876f, 0.08845078f, 0.14577942f, 0.01375962f, 
    0.10400850f, 0.11582629f, 0.07989940f, -0.07031078f, 0.18575333f, 0.06538630f, -0.22169597f, -0.05541429f, 
    -0.02565397f, -0.14334433f, -0.15433018f, -0.04160945f, -0.08771555f, 0.04414483f, -0.01429325f, -0.08361571f, 
    0.15703893f, 0.05756027f, 0.08110993f, -0.01476262f, -0.00293437f, -0.01485673f, 0.17093201f, 0.03089686f, 
    -0.03844097f, -0.18314353f, 0.05550178f, 0.09587690f, -0.06589976f, -0.06953634f, -0.01613777f, 0.29592460f, 
    -0.09384134f, -0.12888861f, 0.16539946f, 0.11717396f, -0.31647995f, -0.06208355f, 0.07182321f, -0.09510423f, 
    0.10608974f, 0.02594413f, 0.02513646f, 0.21586020f, -0.06278303f, -0.05767177f, 0.14024113f, 0.08583346f, 
    -0.21119057f, 0.19717753f, -0.26607916f, -0.18164043f, 0.16014761f, 0.20837200f, 0.03847806f, -0.04488778f, 
    0.16783239f, -0.00006114f, -0.01678556f, -0.09955461f, -0.02810192f, 0.11338908f, 0.10026833f, 0.07730759f, 
    -0.00295209f, -0.13283154f, 0.04359822f, 0.03356351f, 0.06241095f, -0.01860962f, -0.03163303f, 0.00778760f, 
    -0.29463121f, 0.10899737f, 0.29812697f, -0.09737446f, -0.04347069f, -0.12803915f, -0.08528961f, 0.06181976f, 
    0.04341148f, 0.00331069f, 0.04778059f, 0.04634657f, -0.06826729f, -0.15078647f, -0.06768834f, 0.05123595f, 
    0.08364335f, -0.15093997f, -0.10418557f, 0.09350850f, 0.03036115f, 0.07895865f, 0.02988165f, -0.05862962f, 
    -0.06566742f, -0.08810692f, 0.28350684f, 0.26920119f, 0.08360610f, 0.00308293f, 0.05684797f, -0.10031086f, 
    -0.00474317f, -0.04491706f, 0.08740713f, 0.05817655f, -0.22619732f, 0.13595460f, 0.08381726f, -0.14540495f, 
    0.07069659f, -0.06369759f, -0.17091338f, -0.15813175f, 0.02188467f, -0.00940307f, 0.04054326f, 0.07880700f, 
    0.12336763f, -0.00398810f, 0.14220935f, -0.17118849f, -0.01589432f, 0.01062664f, 0.09235051f, -0.03901076f, 
    0.08499873f, 0.12033606f, 0.00079652f, -0.01061025f, -0.07133684f, -0.07114225f, 0.35889989f, 0.00925767f, 
    0.02666768f, -0.04303988f, -0.03213647f, -0.08077644f, 0.02528121f, 0.03372348f, -0.08268092f, 0.15016934f, 
    0.27070388f, -0.44294566f, -0.16399375f, 0.28042042f, 0.05406191f, 0.20150629f, 0.01456120f, 0.10236438f, 
    -0.02156734f, 0.07616519f, 0.01709524f, -0.02888832f, -0.18622568f, -0.35049722f, 0.36474821f, 0.07083779f, 
    0.18009333f, 0.14988150f, 0.00266014f, -0.00361615f, -0.10271037f, -0.12709835f, 0.02353991f, 0.12351560f, 
    0.04714412f, -0.15162387f, -0.19449024f, -0.24993590f, 0.15182045f, -0.19064726f, -0.16995035f, -0.09943076f, 
    -0.00157263f, 0.10363235f, -0.03947801f, -0.01596992f, -0.10306721f, 0.08016789f, 0.07208239f, 0.13543442f, 
    0.05419283f, -0.00792247f, 0.00014135f, -0.41143808f, 0.13873668f, -0.00721050f, 0.06699066f, 0.23230609f, 
    0.34684101f, 0.38869113f, 0.20475031f, 0.21137819f, 0.04246673f, 0.15732466f, 0.07825831f, 0.37497440f, 
    -0.04652780f, -0.05122075f, 0.01047312f, -0.12049951f, 0.25021055f, 0.16374366f, 0.12179294f, -0.09855165f, 
    0.15927799f, 0.06772454f, 0.03546498f, 0.20192869f, -0.00178937f, -0.16596393f, 0.03596472f, -0.05544748f, 
    0.08272809f, -0.10177721f, 0.07908033f, 0.02863884f, 0.03659315f, 0.07448897f, -0.10975651f, 0.07027966f, 
    0.08432084f, 0.06472464f, 0.24789590f, 0.16895589f, 0.05279829f, -0.06570535f, -0.26120752f, -0.23013131f, 
    0.02059917f, -0.02647051f, 0.04328551f, 0.15849105f, 0.15982603f, 0.01584743f, 0.05972511f, 0.17782566f, 
    -0.49357808f, 0.52863103f, -0.44148606f, 0.29919747f, 0.06993370f, 0.21863537f, 0.16136849f, 0.00959002f, 
    -0.01284637f, -0.12511352f, -0.27358004f, -0.34745723f, -0.09754428f, -0.07469238f, -0.15846460f, 0.01547262f, 
    0.03071621f, 0.09258633f, 0.01116631f, 0.06682074f, -0.21266563f, -0.10128389f, -0.07776285f, 0.07267800f, 
    0.19093814f, 0.14175983f, -0.16215037f, -0.17599584f, -0.02755472f, -0.22966327f, -0.03273796f, -0.17242517f, 
    0.10132373f, -0.02781442f, -0.00850189f, -0.09577064f, 0.12401041f, 0.03026368f, 0.23172434f, -0.22798413f, 
    -0.00060971f, -0.17849255f, -0.38796613f, -0.45935854f, 0.03251367f, 0.08257049f, -0.16199319f, -0.11018620f, 
    0.37950394f, -0.09177782f, 0.18224205f, -0.05242803f, -0.08844805f, 0.07631166f, 0.00361767f, -0.03709680f, 
    -0.07914618f, -0.00188627f, -0.21727006f, 0.11137348f, 0.33562267f, -0.01540435f, -0.16091914f, -0.10468600f, 
    0.08909067f, 0.05446690f, -0.03873895f, -0.09960914f, 0.02602378f, -0.02631669f, 0.02073399f, -0.02506514f, 
    0.25522649f, -0.10252176f, 0.06073871f, 0.25995162f, -0.01034508f, -0.13540541f, -0.02083872f, -0.05907612f, 
    0.20028616f, 0.04682858f, 0.07782182f, 0.12406939f, 0.22236842f, 0.10865950f, 0.25839445f, -0.04772175f, 
    -0.09946667f, 0.00193010f, -0.13607889f, 0.10426284f, -0.23689312f, -0.08219837f, -0.12539455f, -0.34049934f, 
    0.32761881f, 0.17679018f, 0.42412093f, 0.26220140f, 0.18312220f, 0.05217262f, 0.01214922f, 0.13454206f, 
    -0.01199569f, -0.01507863f, 0.01449358f, -0.05367756f, 0.13568953f, -0.05100139f, 0.35528049f, 0.05244467f, 
    0.24849181f, 0.04466444f, 0.04953050f, -0.01721620f, -0.19406989f, -0.14439736f, -0.26287976f, -0.18711632f, 
    0.03065745f, -0.04889676f, -0.06483914f, 0.00836808f, 0.04286633f, -0.06510916f, 0.04453300f, -0.00143621f, 
    0.01249145f, 0.03534019f, -0.05962350f, -0.02185394f, -0.00093840f, 0.02149243f, 0.05209177f, -0.08927276f, 
    -0.01742836f, 0.03930240f, -0.07227728f, -0.06420113f, -0.08148833f, -0.04535026f, -0.05623315f, -0.09104320f, 
    -0.01628939f, 0.00679430f, -0.04222493f, -0.01463366f, -0.00523000f, -0.01451697f, 0.04539375f, 0.01973249f, 
    -0.06521295f, -0.01675883f, 0.03456640f, 0.04460593f, -0.02557792f, 0.01849939f, 0.05424055f, -0.02758483f, 
    0.00724854f, 0.02662203f, 0.01351294f, -0.03715819f, -0.07651998f, 0.04380940f, -0.03650901f, -0.06890196f, 
    0.03914406f, -0.05905904f, -0.03650479f, -0.03060556f, -0.07330254f, 0.04422069f, 0.01226059f, 0.04402328f, 
    0.03430806f, 0.03989152f, -0.05764648f, 0.04332798f, 0.03273314f, -0.05223012f, 0.08144460f, 0.03161780f, 
    -0.01683755f, -0.05690391f, 0.03362699f, -0.04029937f, 0.04231290f, -0.03731946f, -0.01675549f, 0.02919339f, 
    0.02523517f, -0.00283264f, -0.01002397f, -0.07232405f, -0.04482131f, -0.02292302f, 0.01398826f, 0.01961983f, 
    0.01058927f, 0.03244529f, -0.04624769f, -0.07240042f, 0.01101150f, 0.00367341f, 0.02481420f, 0.06718796f, 
    -0.01216389f, -0.07081118f, 0.02180967f, 0.02118468f, -0.00334957f, -0.05500671f, -0.08211057f, -0.06531141f, 
    -0.02322832f, -0.04702441f, 0.03617045f, 0.02571492f, 0.05021393f, -0.04612717f, 0.03912300f, -0.01765977f, 
    0.01740178f, -0.04345668f, -0.08373012f, -0.05724614f, 0.03583252f, -0.06779503f, -0.08941920f, -0.01361367f, 
    0.03192745f, 0.04278547f, 0.00324689f, 0.03246285f, -0.04340168f, 0.02767742f, 0.01091585f, 0.03421859f, 
    0.03878092f, -0.06723747f, 0.04933951f, 0.04303661f, -0.04614799f, 0.01843644f, -0.04247101f, -0.06968750f, 
    -0.01242092f, -0.03397129f, 0.05347400f, -0.06094601f, -0.02679165f, -0.03081415f, -0.02493820f, 0.00188822f, 
    -0.02034844f, -0.02221256f, 0.04335769f, -0.00985895f, 0.01279877f, -0.03731631f, 0.05734264f, 0.02538826f, 
    -0.04363726f, -0.08147167f, -0.05992216f, 0.05119163f, 0.00755952f, -0.07446288f, -0.03032103f, -0.00264551f, 
    -0.05149883f, 0.00379465f, -0.04239277f, 0.05147931f, -0.03993073f, -0.01711894f, 0.03889871f, -0.01827429f, 
    -0.01079604f, -0.04101363f, 0.00407402f, 0.01647150f, -0.03562677f, -0.04083918f, 0.03366805f, 0.05372585f, 
    -0.06307270f, -0.00188396f, 0.02992457f, -0.03137863f, 0.02498746f, 0.04034686f, -0.03940567f, -0.02734425f, 
    -0.01257563f, -0.02806635f, -0.05853214f, 0.05238952f, 0.01843860f, 0.04366540f, -0.01540110f, 0.03053067f, 
    0.03639852f, -0.02375286f, -0.06176978f, -0.01941495f, -0.02237279f, -0.02561385f, -0.05451953f, 0.04536124f, 
    -0.03968989f, -0.19431217f, 0.01322854f, -0.01562955f, -0.10837673f, -0.09786549f, -0.07385235f, 0.01410099f, 
    0.11686047f, 0.11258318f, 0.02612196f, -0.03585295f, 0.09011360f, -0.12068961f, -0.02954015f, 0.06975593f, 
    -0.03774998f, -0.06859988f, 0.03191017f, 0.00798155f, 0.03386879f, 0.07979362f, 0.00170391f, 0.20085956f, 
    -0.05392164f, 0.29414722f, 0.23716781f, 0.10985436f, 0.09584852f, 0.17401512f, 0.05130482f, -0.03529422f, 
    0.03035100f, 0.06110561f, -0.12670845f, -0.03125882f, 0.16036388f, 0.18447848f, 0.27008620f, -0.12700620f, 
    0.07743385f, 0.05877826f, 0.14169498f, 0.06021018f, 0.09047102f, 0.00357619f, 0.11815100f, -0.00131354f, 
    0.01202960f, -0.07488092f, 0.10612419f, 0.01932561f, -0.02286319f, -0.09958154f, -0.09349225f, 0.03950086f, 
    -0.03206675f, -0.07815464f, -0.04420170f, -0.02543790f, -0.24434485f, -0.02301087f, 0.17312369f, -0.18147269f, 
    -0.03642655f, -0.08108544f, -0.13150595f, 0.25719759f, -0.01032697f, 0.02848417f, -0.01390038f, -0.08199163f, 
    -0.06945921f, 0.16818073f, -0.06085277f, -0.06247424f, 0.01977540f, -0.12068083f, 0.15911591f, -0.10907869f, 
    0.06160947f, -0.01172941f, -0.16106124f, -0.10007106f, -0.11700793f, -0.02636822f, 0.02533373f, -0.15559874f, 
    -0.10567787f, 0.11829797f, 0.02277249f, 0.04732496f, 0.08320730f, 0.02741459f, -0.10997713f, -0.02498951f, 
    -0.12288035f, -0.19653946f, 0.07231686f, -0.23936032f, -0.04477569f, -0.07439741f, -0.05261396f, 0.15022708f, 
    0.11042077f, 0.06233843f, 0.02248631f, -0.00172498f, -0.06125005f, -0.10130343f, 0.10430487f, -0.01490987f, 
    -0.02158884f, -0.08738726f, -0.03225691f, -0.08612672f, -0.09685481f, 0.05767819f, -0.00581150f, -0.11889280f, 
    -0.09252056f, -0.27237722f, 0.16078964f, -0.02166850f, -0.04424816f, -0.05503171f, 0.11791284f, 0.01857794f, 
    0.02577203f, -0.04650855f, -0.07308369f, -0.07250629f, -0.12572618f, 0.01256032f, -0.01100012f, -0.25873017f, 
    0.01096116f, -0.05351004f, 0.01837694f, -0.05024016f, 0.19731358f, 0.02730317f, 0.07262734f, -0.02977802f, 
    0.13793992f, -0.07539418f, 0.09951592f, -0.17071927f, -0.06438942f, -0.04943313f, -0.04520543f, -0.04331339f, 
    -0.00764982f, -0.09924608f, -0.18543032f, -0.09450803f, -0.13012204f, 0.03218378f, 0.30321869f, 0.03368141f, 
    0.06149475f, 0.06435931f, -0.03792313f, -0.04320127f, -0.02402071f, 0.08630933f, 0.04243943f, -0.02349888f, 
    -0.12626874f, -0.26124820f, 0.11995463f, 0.18763474f, -0.03895914f, 0.12299904f, -0.15084717f, 0.02963378f, 
    0.18394265f, 0.02850912f, 0.08752325f, -0.13722481f, 0.08033726f, -0.24624233f, 0.27071908f, 0.03232121f, 
    -0.04678101f, 0.05133876f, 0.06591709f, 0.04980275f, -0.03304839f, -0.07912488f, 0.04074696f, 0.03004691f, 
    0.19868688f, 0.21032119f, -0.14121257f, -0.17955472f, 0.04329210f, -0.16115089f, 0.18675944f, -0.06927740f, 
    -0.00028572f, 0.04232440f, -0.02952954f, 0.13007863f, -0.16544157f, -0.00990437f, -0.09452952f, -0.33376321f, 
    -0.12259638f, 0.16807523f, -0.09074091f, 0.04153371f, 0.08824866f, -0.03879559f, 0.12170995f, 0.03309737f, 
    -0.11567941f, -0.35581017f, -0.15012188f, 0.15830640f, 0.05774903f, 0.13488233f, 0.07136015f, -0.00473609f, 
    -0.03879101f, -0.06638465f, -0.03321332f, -0.15502435f, -0.24880479f, 0.05244028f, -0.24529932f, 0.26499248f, 
    -0.12422471f, 0.02827243f, 0.07151377f, -0.02459468f, 0.00136746f, 0.04201435f, -0.07643420f, 0.02861214f, 
    -0.13477451f, -0.06106229f, -0.14023937f, 0.08755710f, -0.07532808f, 0.02242569f, 0.07528695f, 0.21239679f, 
    -0.03512302f, 0.03073469f, -0.00674031f, 0.07616850f, 0.00919058f, -0.30004463f, 0.05524690f, 0.18102023f, 
    -0.01498694f, 0.04322450f, 0.00567925f, -0.06848785f, -0.05227470f, -0.07915593f, -0.09743677f, 0.14512147f, 
    -0.11907166f, 0.00730472f, 0.21253850f, 0.18304878f, 0.06297993f, 0.09079927f, 0.00337157f, -0.15713757f, 
    -0.02101408f, -0.05272135f, -0.07961269f, -0.05173871f, -0.14867131f, 0.02679370f, 0.09895086f, 0.38699979f, 
    -0.00347243f, -0.04568302f, 0.09925578f, -0.05324840f, -0.03872013f, 0.14559306f, 0.02599080f, 0.16830130f, 
    0.46971956f, -0.28214881f, 0.19249427f, 0.31897074f, 0.10925919f, -0.00249772f, 0.11794399f, -0.00854718f, 
    -0.02735856f, -0.06391077f, -0.02479087f, -0.01715904f, -0.04908350f, -0.11126074f, -0.26959419f, -0.49228612f, 
    0.03271735f, -0.21991524f, 0.04728851f, -0.14477083f, -0.09581867f, -0.15657055f, -0.03551338f, -0.07174610f, 
    -0.10760757f, 0.28688651f, -0.10434805f, -0.04489496f, 0.04822432f, 0.04143865f, -0.05664152f, 0.06444104f, 
    -0.08904597f, 0.08896750f, 0.07796440f, 0.09769718f, 0.16982649f, 0.05505852f, 0.16078362f, 0.13925490f, 
    0.12721151f, -0.16659777f, 0.14446503f, -0.00612711f, -0.00583958f, 0.14456064f, 0.20586252f, 0.21040161f, 
    0.10649460f, 0.15930988f, -0.14227453f, 0.00717428f, -0.12207694f, -0.05330794f, -0.08134177f, -0.02950959f, 
    0.15236127f, 0.19635142f, 0.04532997f, 0.04040723f, -0.01485172f, 0.07318933f, 0.06744172f, -0.10732760f, 
    -0.00758036f, -0.05846750f, 0.07054793f, 0.05280461f, -0.08509994f, -0.07834347f, 0.05840578f, -0.15715432f, 
    0.26450422f, -0.08627360f, -0.11859121f, 0.31237799f, -0.12670392f, -0.02433366f, -0.04129875f, -0.02948304f, 
    -0.01996810f, 0.18239304f, -0.10108956f, 0.10874812f, -0.09423703f, 0.33887517f, 0.11105312f, 0.19225881f, 
    0.01605530f, -0.14353968f, -0.04709248f, 0.07096409f, -0.03956305f, -0.02446929f, -0.01017462f, -0.04847994f, 
    -0.00506027f, -0.04868954f, -0.02270135f, -0.08070568f, 0.02751372f, -0.03102822f, -0.00062382f, -0.03252109f, 
    -0.02159237f, 0.02933695f, 0.01717721f, -0.00819273f, -0.05187495f, 0.01226765f, -0.06068838f, 0.00254265f, 
    -0.07886764f, -0.09351349f, -0.11302707f, -0.09650101f, 0.00743632f, 0.00719561f, -0.02440557f, -0.10681289f, 
    0.03159732f, -0.07016304f, -0.04973037f, -0.00603579f, -0.01589260f, -0.06606380f, -0.04349174f, -0.07583265f, 
    -0.01502145f, -0.05339449f, 0.02599913f, 0.01874200f, -0.02718913f, -0.07405176f, -0.05582486f, 0.03718671f, 
    -0.01390986f, 0.01620306f, -0.04374235f, 0.05301117f, 0.00359560f, 0.03694148f, 0.00051832f, -0.06518341f, 
    0.02795803f, -0.02462806f, 0.01755438f, 0.04719639f, 0.03724103f, 0.03030569f, -0.03342203f, -0.02307454f, 
    0.00909066f, -0.04032245f, -0.03104606f, -0.03465884f, -0.06091876f, -0.02108137f, 0.00422868f, -0.02836473f, 
    -0.07192225f, -0.07620395f, 0.01710090f, 0.03938472f, 0.05470045f, 0.05143223f, -0.00953477f, 0.04650834f, 
    -0.06706212f, 0.03818872f, -0.08704197f, -0.04287190f, -0.08525101f, -0.09222081f, -0.00208723f, -0.10154244f, 
    -0.00918817f, -0.04361901f, -0.10259819f, -0.00181891f, 0.05112674f, -0.02275629f, -0.02261786f, -0.05206513f, 
    0.00064857f, -0.04798330f, 0.02435882f, -0.04002030f, -0.02110880f, 0.02921670f, -0.01495474f, -0.03179531f, 
    0.01464337f, -0.05116940f, 0.03595263f, 0.02737000f, -0.11049141f, 0.00750953f, -0.07689974f, -0.06262892f, 
    -0.00571130f, -0.06993747f, -0.09402467f, -0.04227871f, -0.05806222f, 0.00644130f, 0.02120309f, -0.02030420f, 
    0.00545792f, -0.01271754f, -0.09286761f, -0.03586441f, 0.00068758f, -0.02044940f, -0.07720314f, 0.03221292f, 
    -0.05759763f, -0.06399927f, -0.07905805f, -0.05097719f, 0.02472673f, -0.02311602f, -0.07865432f, 0.03975187f, 
    -0.05601216f, 0.02666987f, 0.03724826f, -0.03315121f, 0.01643955f, -0.00353993f, -0.01389103f, -0.01404113f, 
    -0.00277917f, -0.08894544f, -0.09713426f, -0.11394726f, -0.01269295f, -0.00324537f, -0.04481671f, 0.02509242f, 
    -0.02313803f, 0.03641996f, 0.02388078f, -0.06976536f, -0.01624070f, 0.01507971f, 0.06018161f, -0.03891199f, 
    -0.06308366f, -0.05025259f, -0.00413109f, 0.00056591f, -0.01851791f, -0.00425410f, -0.05985270f, -0.00131413f, 
    -0.03967993f, 0.01861832f, -0.00244444f, -0.03564954f, -0.06206893f, -0.04171353f, -0.05577002f, -0.06855086f, 
    0.03751535f, 0.02887681f, -0.01531993f, 0.07201522f, 0.04696175f, 0.04572381f, -0.05481746f, -0.02175373f, 
    -0.07092572f, -0.01689464f, -0.04835521f, -0.07105507f, 0.01363730f, -0.03197639f, -0.03456360f, -0.09108425f, 
    -0.08201504f, 0.01019999f, 0.02306210f, -0.03846363f, 0.02994817f, -0.05483418f, 0.01150511f, -0.06882132f, 
    -0.28834134f, 0.05189116f, 0.13342606f, -0.50044543f, -0.10034515f, 0.11134961f, -0.01325083f, -0.01991878f, 
    0.09842943f, 0.02315073f, -0.05211544f, 0.14765343f, -0.17218538f, -0.06054689f, -0.20725286f, -0.28960845f, 
    -0.00936402f, -0.06206746f, 0.09063023f, -0.15127522f, 0.00485692f, 0.02407072f, 0.05818592f, 0.05695910f, 
    -0.10202128f, -0.10305077f, 0.08560868f, 0.35112655f, 0.12688456f, 0.22053753f, -0.08319815f, 0.02350961f, 
    -0.05216087f, -0.03966690f, -0.08770769f, 0.01640928f, -0.05484061f, 0.03113235f, -0.03925605f, 0.16877760f, 
    -0.02721108f, 0.04256383f, 0.06220157f, 0.00592230f, 0.09199719f, 0.06530068f, 0.09594768f, 0.05795292f, 
    -0.16705151f, -0.08288386f, -0.07746135f, 0.03458735f, -0.13294572f, -0.01626558f, 0.00512514f, 0.27512443f, 
    -0.00566947f, -0.08294014f, -0.06447208f, 0.11832048f, -0.15705378f, -0.26929680f, 0.00040641f, 0.18475404f, 
    0.02044961f, 0.03023272f, 0.06159538f, 0.20620131f, -0.05014453f, -0.03923357f, -0.10108057f, 0.05781060f, 
    -0.13921252f, 0.25500521f, 0.00980765f, 0.04554626f, 0.06797688f, 0.13383566f, 0.03459233f, 0.05259543f, 
    0.14679679f, 0.05218048f, 0.01875125f, -0.06915022f, -0.19839703f, 0.05800791f, 0.06864382f, 0.46773303f, 
    -0.07522789f, -0.04468289f, 0.16560616f, -0.06044940f, 0.01066618f, 0.05842080f, -0.18524529f, 0.18200466f, 
    0.21316998f, -0.00154706f, 0.09450995f, 0.18584198f, -0.01342373f, -0.07486637f, 0.06100851f, 0.15347265f, 
    -0.07090124f, -0.05548060f, -0.08007992f, -0.14648584f, -0.13191143f, 0.02193432f, -0.01780321f, -0.29771367f, 
    0.03048777f, -0.16607508f, 0.01696475f, 0.08242487f, -0.05242690f, -0.05042904f, 0.04812286f, -0.05466320f, 
    -0.07746812f, 0.15513489f, 0.02686316f, 0.06811682f, 0.05803559f, 0.21093233f, -0.02618524f, -0.01462894f, 
    -0.09399620f, -0.06792922f, -0.05772041f, 0.12492974f, -0.00180416f, -0.01055094f, 0.12810133f, 0.11631047f, 
    -0.07173808f, -0.12162080f, 0.06097632f, 0.01566984f, 0.17807016f, -0.00601440f, 0.02823465f, -0.02604135f, 
    0.16168384f, 0.12433858f, 0.07612769f, -0.30663586f, -0.13464804f, -0.05427541f, -0.00449990f, 0.01534622f, 
    0.17678998f, -0.11081695f, 0.00564021f, -0.02840000f, 0.11079865f, -0.04663153f, 0.40850204f, 0.08446500f, 
    0.01915104f, -0.13721877f, -0.09899438f, 0.10629757f, -0.11262896f, 0.00279162f, 0.02131327f, -0.04426598f, 
    0.36799312f, -0.22537799f, -0.10851377f, 0.33610961f, -0.08904257f, 0.16393143f, 0.08668600f, 0.02508362f, 
    -0.06908267f, 0.14857632f, -0.06931079f, -0.09254842f, -0.07811717f, 0.16198447f, 0.20967230f, 0.01631386f, 
    0.14771871f, 0.05595859f, 0.01892415f, 0.08173054f, -0.06715773f, -0.05338388f, -0.01923373f, 0.04888919f, 
    -0.23091304f, -0.08989102f, 0.37372550f, -0.13239545f, -0.02102482f, 0.07048348f, -0.17592275f, 0.00475922f, 
    0.09016307f, 0.10796052f, 0.10815430f, 0.15790881f, 0.06104193f, 0.05031710f, -0.13752782f, -0.07313574f, 
    0.03949005f, -0.09084229f, -0.07581238f, -0.07216532f, -0.03915317f, 0.08866716f, 0.18369938f, 0.04556729f, 
    -0.11373743f, -0.17127146f, 0.12716977f, 0.11707926f, 0.06962796f, 0.10582986f, -0.15435402f, -0.14034814f, 
    -0.05637455f, -0.09226952f, -0.19187734f, 0.07219545f, -0.10717674f, 0.05787206f, 0.14924586f, 0.10441468f, 
    0.02842785f, 0.12089687f, 0.08106313f, 0.00927901f, 0.09211370f, -0.05996172f, 0.06455710f, 0.08602504f, 
    -0.06235596f, -0.10028342f, 0.01022049f, 0.01861482f, -0.03835351f, 0.04255730f, -0.08179616f, 0.09723590f, 
    0.00220480f, -0.28293964f, -0.03415710f, 0.04819192f, -0.17711118f, -0.12158658f, 0.11896390f, 0.16222034f, 
    0.02139151f, -0.08056063f, 0.10083874f, 0.23218133f, -0.03643255f, -0.06395690f, -0.12818307f, -0.05317993f, 
    -0.03214739f, -0.01997366f, 0.14948480f, -0.32552814f, 0.18494779f, 0.01021180f, 0.07578947f, 0.11110852f, 
    0.10469724f, 0.20822382f, 0.11296675f, -0.07191986f, -0.15330543f, 0.11741225f, 0.00889971f, 0.11938687f, 
    0.07798482f, -0.02267147f, 0.09873936f, 0.06453666f, -0.11549890f, 0.02551041f, -0.14213961f, 0.09804526f, 
    -0.26909530f, -0.04655736f, 0.14288402f, 0.05649449f, -0.03947827f, -0.00275716f, -0.07748923f, 0.34756520f, 
    -0.03016548f, 0.03736221f, -0.06444674f, -0.04429540f, -0.13016766f, 0.07076003f, -0.10069556f, -0.08387570f, 
    0.09110808f, -0.13287459f, 0.03103535f, -0.01867684f, 0.11012051f, 0.10565770f, 0.03190609f, 0.18878144f, 
    -0.14066070f, 0.23529817f, 0.10648575f, 0.09069397f, 0.15128702f, 0.12193555f, 0.04102729f, -0.06760139f, 
    0.11218933f, 0.03247665f, 0.08493071f, 0.01870640f, -0.29519615f, 0.08710333f, 0.17285676f, -0.00063983f, 
    -0.17085721f, 0.10312629f, 0.02853601f, -0.02289011f, 0.06865957f, 0.01790871f, 0.01246593f, 0.07231681f, 
    0.00867232f, 0.14696275f, 0.08374001f, -0.31129342f, -0.07410175f, -0.10187174f, -0.05255624f, -0.03196095f, 
    0.08798951f, -0.09814941f, 0.07356134f, -0.08170086f, -0.08032056f, 0.01066312f, 0.32730821f, 0.08950268f, 
    0.13512392f, 0.09773935f, -0.03185338f, 0.06494659f, -0.02282065f, 0.12801546f, -0.01270245f, 0.01767472f, 
    0.24399224f, -0.17083867f, -0.06497598f, 0.25630644f, -0.01738685f, -0.00843777f, 0.06338960f, -0.05203321f, 
    0.03394209f, 0.03311032f, -0.01010516f, -0.11050827f, 0.13603412f, 0.20980628f, 0.16576140f, -0.06205747f, 
    -0.00028614f, -0.03582738f, -0.14871189f, -0.03297685f, -0.10258678f, -0.03542599f, -0.13650040f, 0.04110597f, 
    0.74759680f, -0.26228690f, -0.32448134f, 0.08368758f, -0.06467321f, -0.10708185f, 0.21456781f, -0.06582341f, 
    0.06273088f, -0.03991083f, 0.10656657f, 0.05982451f, -0.18480310f, -0.03461718f, 0.18363966f, 0.02008823f, 
    -0.00787827f, 0.09784112f, -0.10120315f, -0.10862876f, 0.25966793f, 0.01302437f, 0.02033340f, 0.10617552f, 
    0.18809949f, 0.07706305f, 0.23306519f, 0.22002374f, 0.02322948f, -0.00160714f, 0.25211030f, 0.25792429f, 
    0.03352813f, 0.05503678f, 0.10758576f, -0.00726746f, -0.02406288f, 0.07537660f, -0.01732647f, -0.01123182f, 
    0.05243069f, 0.00433955f, -0.03011539f, 0.06023851f, -0.01796509f, -0.05147137f, 0.04870881f, 0.08052015f, 
    0.22615156f, -0.05768200f, 0.07367884f, 0.01417791f, 0.18504348f, 0.00287120f, -0.13563308f, -0.12050746f, 
    0.02925959f, 0.08497752f, -0.06740525f, 0.18437047f, 0.15924868f, 0.12945394f, -0.15934171f, 0.05149868f, 
    0.02247995f, -0.06525127f, 0.00865346f, -0.04143856f, -0.06147206f, -0.05373190f, 0.00856183f, 0.10676804f, 
    -0.28195089f, 0.08715242f, 0.10619958f, 0.23644333f, -0.11503018f, 0.11918999f, -0.04498057f, -0.00955632f, 
    -0.07717853f, -0.09241062f, 0.04195025f, 0.01481469f, -0.09983725f, -0.08205628f, 0.10702258f, -0.03517643f, 
    -0.05016530f, 0.13062307f, -0.25674635f, 0.07844727f, -0.05365906f, 0.03735282f, -0.01878642f, 0.10220021f, 
    0.26899371f, -0.29056925f, -0.39102933f, -0.00540100f, 0.10627485f, -0.01896783f, -0.05236758f, -0.07723504f, 
    -0.05832755f, -0.04175022f, -0.07407121f, 0.02878571f, 0.14053813f, -0.01612023f, 0.13404511f, 0.04669723f, 
    -0.05751405f, 0.03557208f, -0.02977053f, -0.10926217f, 0.06384800f, 0.04651164f, -0.02639908f, 0.06929988f, 
    0.27529112f, 0.11326926f, 0.10707296f, -0.14568247f, 0.01825111f, -0.10870767f, -0.00920664f, -0.09444553f, 
    -0.01502835f, -0.00046962f, -0.00853199f, 0.09151523f, 0.40951613f, 0.02815942f, -0.21892957f, 0.01292380f, 
    0.15754040f, 0.06476937f, 0.05621011f, -0.00240687f, -0.01528440f, -0.08510271f, 0.15618287f, 0.10009374f, 
    -0.02147047f, -0.09660041f, -0.08602973f, 0.18952914f, 0.11889718f, 0.00491716f, 0.02571763f, -0.00892417f, 
    0.04686020f, 0.06731007f, 0.06411683f, 0.08111736f, 0.01021405f, 0.08667348f, -0.15353684f, -0.01006484f, 
    0.02076329f, 0.07704621f, -0.10621467f, -0.16345435f, -0.13651210f, -0.09382912f, 0.02482099f, -0.07040700f, 
    0.09902738f, 0.16886707f, 0.42705864f, -0.00061022f, 0.20165792f, -0.20684984f, -0.10355920f, -0.17102937f, 
    0.14658424f, -0.00253191f, 0.08365116f, 0.00734906f, 0.36414373f, 0.28765601f, 0.13564780f, -0.01071803f, 
    -0.08584608f, -0.14288138f, -0.07749453f, 0.02636333f, -0.01585316f, 0.03679779f, 0.04756351f, -0.06698918f, 
    0.24223863f, -0.06393805f, -0.10633627f, -0.03605038f, -0.25263861f, -0.26772666f, 0.16036743f, -0.20135024f, 
    0.22081985f, 0.27273414f, 0.06287328f, 0.01962581f, -0.09987675f, -0.08599007f, 0.04859858f, 0.02519227f, 
    -0.03259297f, 0.00037322f, -0.04862384f, -0.17403205f, 0.13071164f, -0.09882471f, -0.05757196f, 0.34434906f, 
    -0.10920355f, 0.19775996f, 0.13844815f, 0.16968729f, 0.02435862f, 0.17493665f, 0.14781995f, 0.18471736f, 
    -0.02842445f, 0.00814509f, -0.00530237f, -0.00820321f, 0.08227007f, -0.05737022f, -0.03737823f, -0.15324619f, 
    0.00956597f, 0.05290065f, 0.07310039f, 0.09638170f, 0.07540129f, -0.09425068f, 0.07236554f, 0.00288634f, 
    -0.12494757f, -0.19720271f, 0.03701152f, 0.17388962f, 0.02025293f, -0.04644743f, -0.05588392f, 0.02561619f, 
    0.16225776f, 0.04200562f, -0.04742525f, 0.26740530f, 0.11071886f, -0.21057208f, 0.13578677f, 0.11356557f, 
    -0.10017773f, -0.11536138f, -0.13848276f, 0.14734249f, 0.12410714f, 0.08348604f, -0.02737992f, 0.19490518f, 
    -0.41675088f, 0.19622141f, -0.23819502f, 0.23873749f, 0.26203737f, 0.03090911f, 0.14214927f, -0.01087012f, 
    0.02505917f, -0.27227902f, -0.26713884f, -0.16233990f, -0.28936380f, 0.03645442f, 0.07900444f, 0.01780270f, 
    -0.17489223f, 0.19335690f, -0.05566465f, 0.06252401f, -0.13667892f, 0.01034991f, -0.05453600f, -0.03109507f, 
    0.88903058f, -0.12211081f, 0.06550637f, 0.28002170f, -0.03127584f, -0.23266421f, -0.11673630f, -0.00204810f, 
    0.18201482f, -0.00678917f, -0.09547146f, 0.00036256f, 0.07759096f, 0.00423804f, 0.04831970f, -0.14807759f, 
    -0.20649655f, -0.13728516f, -0.05979430f, -0.30708161f, -0.20598252f, -0.11763552f, -0.10149700f, 0.03989893f, 
    0.51587850f, -0.16439551f, 0.18453451f, -0.26231906f, -0.15286320f, 0.07922688f, -0.07606972f, 0.02867151f, 
    -0.05476127f, 0.10622150f, -0.18074606f, 0.07556033f, 0.04128126f, 0.06803490f, 0.13407911f, 0.00235592f, 
    -0.12928201f, -0.07487348f, 0.14946625f, -0.13055918f, 0.13825062f, -0.08167072f, -0.12393329f, -0.18486404f, 
    0.19164114f, -0.13117027f, 0.12023349f, 0.17503023f, -0.02465795f, -0.12667093f, 0.04570968f, -0.09055418f, 
    0.23456727f, -0.01152278f, 0.02380784f, 0.10355313f, 0.20157743f, -0.01296570f, 0.17505886f, -0.23606992f, 
    -0.05215227f, 0.19499636f, -0.19917639f, 0.21315292f, -0.08510674f, -0.01249710f, 0.17712058f, -0.31146434f, 
    -0.21180600f, -0.12515791f, 0.17896493f, 0.28308308f, 0.12378725f, 0.10747559f, -0.06534932f, -0.21171419f, 
    -0.01393593f, -0.02829337f, 0.12101570f, 0.03649168f, 0.17508262f, 0.15837273f, 0.21238317f, 0.04580623f, 
    0.00018375f, -0.25409976f, -0.18702374f, -0.00857090f, -0.23470466f, 0.03497586f, -0.12115014f, -0.20120946f, 
    -0.07597888f, -0.62406272f, 0.02307138f, -0.09662545f, 0.10757106f, 0.08162762f, -0.08049639f, 0.08337172f, 
    0.05376337f, -0.01126690f, 0.04614520f, 0.10447369f, -0.22069617f, -0.34057799f, 0.01039259f, 0.02963264f, 
    0.06304868f, -0.02015844f, 0.05234604f, -0.12408397f, 0.19790094f, 0.07359599f, 0.16574620f, 0.08158233f, 
    0.09011013f, 0.21720169f, 0.27227312f, 0.17805398f, -0.08683020f, -0.04574171f, -0.13767940f, 0.10384228f, 
    -0.14554869f, -0.03281116f, -0.13637429f, -0.09595323f, 0.01717234f, 0.09516065f, 0.21096434f, 0.01213582f, 
    0.00802335f, 0.04912202f, 0.05061891f, 0.16379285f, 0.12552194f, 0.00105328f, 0.04397763f, 0.05071596f, 
    -0.17743291f, -0.10237083f, 0.07614718f, 0.10506608f, -0.07199757f, 0.01322443f, -0.06848245f, 0.09232268f, 
    0.03766420f, -0.11574661f, -0.01916883f, 0.11318719f, -0.17146088f, 0.03882416f, 0.01710351f, -0.04668972f, 
    -0.05506207f, -0.17018145f, 0.00611139f, 0.23618214f, -0.17963335f, -0.16117710f, 0.04212871f, -0.07170802f, 
    0.06158569f, 0.22447656f, -0.05092244f, -0.07276448f, 0.28433770f, -0.02512136f, -0.11797396f, 0.01422159f, 
    0.30147263f, -0.06063287f, 0.10217164f, -0.15796550f, 0.05301024f, 0.15980622f, 0.16009833f, 0.13340187f, 
    -0.02578701f, -0.07506128f, 0.11892468f, 0.05325828f, 0.02272163f, -0.04139850f, -0.18987279f, 0.15197381f, 
    -0.10283922f, 0.04967406f, -0.01041452f, 0.07737932f, -0.08692382f, -0.09912544f, -0.14438918f, 0.01669546f, 
    0.06894404f, 0.06911476f, -0.10160535f, 0.00588006f, -0.21239750f, -0.24026956f, 0.03344849f, 0.06966020f, 
    0.08335876f, -0.08900513f, -0.01124247f, 0.09162653f, 0.08530205f, 0.16508739f, 0.01457082f, 0.06843035f, 
    -0.05698578f, 0.00900256f, 0.19069098f, 0.08522572f, -0.18555936f, 0.03579754f, 0.00877129f, -0.03024045f, 
    -0.02850364f, 0.05143690f, -0.08104780f, 0.12199990f, -0.08017656f, 0.07630455f, 0.05550108f, -0.11291172f, 
    0.09342249f, 0.08598715f, -0.04411088f, -0.14760268f, 0.03933315f, -0.08726797f, 0.09029511f, -0.01476334f, 
    -0.01655601f, -0.18497485f, -0.06731016f, -0.07693077f, 0.00176564f, 0.07345286f, -0.00920329f, 0.02736843f, 
    0.02479260f, -0.22246991f, 0.07335029f, 0.03132948f, 0.11143509f, -0.06389199f, 0.35527110f, -0.10267267f, 
    -0.20180455f, 0.01686734f, -0.03343442f, -0.06682494f, 0.03195864f, 0.17204489f, -0.18176585f, -0.02881727f, 
    0.28884643f, -0.04442180f, 0.19450954f, 0.12513773f, -0.18633878f, -0.00360422f, 0.00048396f, -0.06508639f, 
    -0.05348685f, 0.02665517f, 0.01844876f, -0.15356445f, 0.27413642f, -0.06734473f, 0.15162234f, -0.34731352f, 
    -0.02259099f, -0.07556782f, 0.10060695f, 0.01032823f, -0.07607995f, 0.03445048f, -0.13250539f, 0.02852269f, 
    -0.32946429f, -0.08742838f, 0.06119429f, -0.03477138f, -0.05828369f, 0.08933742f, -0.09667405f, -0.06818585f, 
    0.14299832f, 0.07860274f, 0.09555721f, -0.00614871f, 0.16527469f, 0.01854022f, -0.03501623f, -0.16390021f, 
    -0.12119514f, -0.07542074f, -0.13262294f, -0.04980910f, -0.08374085f, -0.11317507f, 0.00056823f, -0.08212367f, 
    -0.21507734f, 0.02578309f, 0.05700863f, 0.06982525f, 0.15418455f, -0.04966222f, -0.15725209f, -0.21849146f, 
    0.03052199f, -0.08662871f, -0.01891709f, -0.01383159f, -0.02611656f, 0.03125803f, 0.22822651f, -0.10083421f, 
    -0.01798530f, 0.03068640f, 0.03553392f, -0.07314925f, -0.00040698f, -0.01372954f, 0.14050096f, -0.13857588f, 
    -0.08008971f, -0.11488584f, -0.15928039f, -0.07390921f, -0.16157451f, -0.04806291f, 0.08338537f, 0.10331856f, 
    0.01768652f, -0.13669476f, 0.08257666f, -0.03319365f, -0.15769678f, -0.10840330f, 0.12891644f, -0.04845914f, 
    -0.11996062f, -0.03954308f, 0.08189055f, 0.25978225f, -0.09434011f, 0.09980027f, -0.05501087f, -0.04180122f, 
    0.01828211f, -0.01177283f, -0.14490984f, -0.16323949f, 0.16070217f, -0.08356450f, 0.03033430f, -0.04843908f, 
    -0.03253470f, 0.04644417f, -0.05469358f, -0.09978322f, -0.14986590f, -0.06147203f, -0.11122165f, -0.05347771f, 
    0.10905392f, -0.19511059f, 0.18347915f, -0.01350690f, 0.00631317f, -0.05578302f, -0.10632273f, -0.00114957f, 
    -0.10084835f, -0.07769047f, 0.08374771f, -0.11283001f, -0.10016125f, -0.04941278f, 0.05135884f, 0.23080078f, 
    0.01013738f, 0.13315398f, 0.02773723f, -0.08861165f, 0.09843593f, 0.09180871f, 0.03994695f, -0.05355767f, 
    -0.02416396f, -0.11029563f, -0.05440086f, -0.03404853f, -0.15202217f, -0.17807154f, -0.02471200f, -0.08103604f, 
    -0.08805446f, -0.24902356f, 0.07265509f, 0.08702293f, 0.05824452f, 0.03196516f, 0.15536727f, 0.22977415f, 
    -0.12829450f, 0.12334467f, 0.08808877f, 0.10991927f, -0.36137462f, 0.14897515f, -0.01579155f, -0.13336004f, 
    -0.24303773f, -0.11329686f, 0.06210982f, 0.07150777f, 0.09150304f, 0.00803581f, -0.00291530f, -0.13231196f, 
    -0.06209627f, -0.02444709f, 0.07648721f, -0.17534615f, -0.03103195f, -0.02023304f, 0.01122630f, 0.01101421f, 
    0.07757906f, -0.12209306f, -0.09195328f, -0.09711161f, -0.13766608f, -0.05719633f, 0.49270669f, -0.04695820f, 
    0.08565525f, -0.18325441f, -0.03153011f, 0.09587013f, -0.06197325f, 0.00173607f, -0.00117023f, 0.05262598f, 
    0.09991545f, -0.28379440f, -0.18371382f, 0.24912314f, -0.11217991f, 0.24660480f, -0.00381723f, -0.00598538f, 
    -0.00134004f, 0.09053015f, 0.05109502f, -0.11438691f, 0.07368356f, -0.14374101f, -0.04762258f, -0.08412790f, 
    0.09397984f, -0.02527979f, -0.07174817f, -0.12608927f, 0.02360028f, -0.12523165f, -0.00719450f, -0.03276666f, 
    0.23406801f, -0.14627714f, -0.15051103f, -0.03860627f, -0.02548216f, -0.14473069f, 0.26790637f, -0.27656198f, 
    0.04778647f, 0.20431048f, -0.08354187f, 0.04098841f, -0.08998512f, 0.02165372f, -0.01009035f, -0.18996783f, 
    0.06893297f, 0.03634768f, -0.14962934f, 0.09971266f, -0.00272462f, 0.01317437f, -0.05100865f, -0.08735617f, 
    -0.12623152f, -0.21190034f, -0.13125947f, -0.09041439f, 0.14880809f, 0.13220119f, -0.04684472f, -0.11522394f, 
    -0.02655872f, -0.02557532f, 0.05502959f, 0.07808676f, 0.09979040f, 0.27186325f, 0.02151797f, -0.09294552f, 
    0.05309398f, 0.01689505f, 0.06373078f, 0.04350094f, 0.00304510f, -0.02496568f, -0.02101993f, 0.04507889f, 
    0.08176563f, -0.00190615f, -0.04473829f, -0.01561757f, -0.02278661f, -0.14224641f, -0.00955095f, 0.04078151f, 
    -0.01710175f, -0.07196318f, -0.04757776f, -0.05417123f, -0.07600259f, -0.08706285f, 0.16119532f, 0.09714878f, 
    0.04233548f, 0.00623348f, 0.00454026f, 0.10882816f, -0.07756739f, 0.04063455f, 0.05282002f, -0.01628351f, 
    -0.31270263f, 0.01916600f, -0.05779140f, -0.16628261f, 0.13233222f, 0.00959492f, 0.17030662f, -0.04045594f, 
    0.09613764f, 0.04259178f, 0.14178197f, -0.05509464f, -0.17136323f, -0.14140908f, 0.00567963f, 0.10101309f, 
    0.05939144f, 0.19006203f, 0.01858229f, 0.06063567f, 0.13574101f, 0.07933531f, 0.20941888f, 0.17250571f, 
    0.28065982f, -0.48791322f, 0.12971656f, 0.08894826f, 0.07005090f, 0.16530494f, 0.00987386f, -0.01294252f, 
    0.02279500f, 0.08988425f, 0.07801394f, 0.02359986f, -0.09968400f, -0.11433756f, -0.08437695f, -0.12831581f, 
    -0.16135675f, -0.12771936f, -0.08431131f, -0.01962520f, 0.09265537f, 0.00251013f, 0.11851957f, 0.09784760f, 
    0.22330487f, 0.27581653f, 0.15078144f, -0.17973062f, -0.04001554f, -0.08506744f, 0.09239375f, 0.15716332f, 
    0.12739103f, 0.02302929f, -0.00061622f, -0.07241670f, -0.23922049f, 0.08106221f, 0.00901708f, -0.04165183f, 
    0.00068699f, 0.00859663f, 0.17607418f, -0.02641986f, 0.31536290f, 0.13234411f, 0.03757608f, 0.22176401f, 
    0.18604518f, 0.18218216f, 0.09407613f, -0.05585617f, -0.03071273f, -0.08747713f, 0.05605482f, -0.07837425f, 
    -0.01670580f, 0.09461158f, 0.00147123f, -0.11197075f, 0.08055314f, 0.22398566f, 0.04379158f, -0.26229778f, 
    0.18545201f, -0.03400090f, -0.11554983f, 0.01633588f, 0.11250754f, 0.08658129f, 0.13882512f, 0.04683178f, 
    0.08027210f, -0.08583599f, 0.08123464f, 0.18629909f, 0.02219887f, 0.00338394f, -0.06265122f, 0.06509401f, 
    0.03150360f, -0.03699150f, -0.12476954f, -0.05472666f, -0.04525227f, 0.11969532f, 0.15014443f, 0.23648231f, 
    -0.05708836f, -0.04010940f, -0.10432628f, -0.06228687f, -0.01294210f, -0.01355698f, 0.09866286f, 0.06586117f, 
    -0.15514152f, 0.37543058f, 0.34299362f, 0.12718633f, -0.05387393f, 0.09480971f, -0.35446647f, 0.22701602f, 
    -0.04385715f, 0.01732674f, 0.16555959f, 0.06499313f, 0.00944393f, -0.03854098f, -0.14772165f, 0.20459461f, 
    -0.16055633f, -0.03191377f, 0.02272210f, -0.09505402f, 0.03936563f, 0.07879405f, 0.04862369f, 0.10152864f, 
    -0.17645395f, 0.03890543f, -0.03281484f, 0.05807986f, -0.07729236f, 0.05085729f, -0.00275332f, -0.06502102f, 
    0.06138805f, 0.03639554f, -0.02838498f, -0.03153944f, -0.29724926f, -0.16684444f, -0.08649792f, 0.24164896f, 
    0.03440133f, 0.05767059f, -0.07065541f, 0.01832798f, -0.05672876f, -0.04483826f, 0.11982656f, 0.07404055f, 
    -0.27157673f, 0.15340553f, 0.00145359f, 0.04787057f, 0.12121167f, 0.01199361f, 0.00718956f, -0.14751177f, 
    0.00535563f, 0.21191433f, 0.18201354f, 0.05934174f, 0.08955073f, 0.02643813f, 0.11214641f, 0.09856133f, 
    -0.06147023f, -0.15800747f, 0.02532088f, 0.00964192f, 0.09368449f, 0.10828553f, 0.03103502f, 0.08201274f, 
    0.23826449f, -0.16072831f, 0.05615203f, 0.01061936f, 0.03088709f, 0.18824764f, 0.08067808f, 0.12211376f, 
    0.03004823f, -0.01946161f, -0.11218560f, 0.09573764f, 0.18288264f, 0.29122955f, 0.10203458f, 0.00446385f, 
    -0.00754323f, 0.11026902f, 0.02099681f, 0.08108226f, -0.15601362f, 0.10196111f, -0.19624929f, -0.15059172f, 
    -0.21910655f, 0.42866847f, 0.14123878f, 0.20629299f, 0.01078948f, -0.11443255f, 0.01561973f, 0.01063267f, 
    0.15707912f, 0.02875823f, 0.02714075f, -0.00510716f, -0.09137128f, -0.00854316f, -0.12820795f, 0.14106722f, 
    -0.03526076f, 0.01359524f, 0.04400538f, 0.01828986f, -0.11603764f, 0.04319870f, -0.00011357f, -0.04360957f, 
    -0.43968505f, 0.08773918f, -0.10902800f, 0.53432876f, 0.13029186f, 0.11944392f, 0.00518528f, 0.11134977f, 
    0.08210231f, 0.09750102f, -0.07601893f, 0.11378471f, 0.31117958f, 0.08455306f, 0.13800196f, 0.12280996f, 
    0.15844896f, -0.02030947f, -0.11677539f, 0.01056777f, -0.17950097f, -0.02273037f, -0.03930658f, -0.03910314f, 
    -0.04844078f, -0.05601245f, 0.07153507f, 0.05360722f, 0.01672777f, -0.00790880f, -0.13268031f, 0.10330354f, 
    0.05328440f, -0.04883989f, 0.16305199f, 0.21176025f, -0.29036838f, -0.33612442f, -0.06402557f, 0.26289260f, 
    0.04768370f, 0.21813928f, 0.12189128f, -0.00719004f, -0.17875081f, -0.02856996f, -0.02705686f, -0.07576930f, 
    -0.10809535f, 0.07565615f, -0.12567790f, 0.08498469f, -0.02860802f, 0.03878720f, 0.05342541f, 0.05045717f, 
    0.08118438f, 0.07401515f, 0.12571597f, 0.02896727f, -0.11976238f, 0.11310954f, -0.14356385f, 0.08543007f, 
    -0.04024027f, 0.04908101f, 0.10195610f, -0.07405921f, -0.01401029f, -0.09586943f, -0.18591632f, -0.06330295f, 
    -0.22397141f, 0.21374509f, 0.16555275f, 0.29313922f, 0.06687364f, -0.14114690f, -0.09806667f, 0.04932246f, 
    -0.08752650f, -0.05897424f, 0.27382413f, 0.03716110f, 0.13401419f, 0.04466067f, -0.06235777f, 0.07066874f, 
    0.01914494f, 0.07337052f, 0.00148369f, 0.00809094f, -0.02789470f, 0.01136501f, -0.11552319f, -0.01518970f, 
    -0.19717444f, -0.04874863f, -0.14552124f, -0.24583784f, -0.03838217f, -0.23418930f, -0.00906365f, -0.21145745f, 
    -0.17383732f, 0.00681212f, -0.01550299f, 0.00684247f, -0.20461074f, -0.19869553f, 0.13179143f, -0.06939770f, 
    0.03139313f, -0.09749284f, -0.18682146f, -0.08109986f, -0.00099099f, 0.05249185f, -0.04821722f, -0.08741786f, 
    -0.16361611f, 0.00256325f, 0.23958811f, 0.06423234f, -0.05050226f, 0.08522680f, -0.05229792f, 0.01133468f, 
    -0.03227232f, -0.00532484f, -0.00118928f, -0.05302175f, -0.32914931f, -0.10365018f, -0.05578899f, -0.26796448f, 
    -0.10490261f, 0.04810344f, -0.14916269f, -0.06746643f, 0.11141036f, -0.05522313f, 0.02988844f, -0.01664960f, 
    0.15053231f, -0.06029539f, 0.00375424f, -0.06961671f, 0.02093693f, -0.04384236f, 0.07202342f, -0.09193689f, 
    -0.03424834f, -0.12061863f, -0.19445135f, -0.11326737f, 0.10424492f, 0.27579755f, 0.03356899f, -0.39902234f, 
    0.04600884f, -0.16158286f, -0.01401139f, 0.02998634f, -0.11985357f, -0.02424905f, -0.07918134f, -0.15373306f, 
    -0.08786355f, 0.28618187f, 0.26588520f, -0.03923230f, 0.00167863f, -0.05271754f, -0.14516920f, 0.01868574f, 
    -0.20961863f, -0.09339910f, 0.08947839f, 0.11153975f, 0.03439012f, -0.07260949f, 0.05053890f, 0.12320029f, 
    -0.09034761f, -0.00211043f, -0.05701788f, -0.05815363f, -0.03578072f, -0.00858370f, -0.04631377f, -0.09330034f, 
    -0.29369727f, -0.35379824f, 0.04356238f, 0.31476277f, -0.08641794f, 0.06929942f, -0.14726476f, 0.04539703f, 
    0.11554793f, -0.00535477f, 0.20107500f, -0.02227696f, -0.07539151f, 0.18966635f, 0.21542843f, -0.12595861f, 
    0.03925531f, -0.15847127f, -0.03576359f, -0.00519935f, -0.26090917f, 0.02701215f, -0.05734024f, 0.11125375f, 
    -0.16645849f, -0.18365936f, 0.00632739f, 0.18818207f, 0.01351084f, 0.05078243f, 0.01180601f, -0.06650232f, 
    -0.00006752f, -0.01265755f, 0.00239230f, 0.16438101f, -0.15048288f, -0.12241954f, -0.15741910f, 0.17088142f, 
    -0.02900593f, 0.03393941f, 0.09348802f, 0.02236099f, -0.00085960f, -0.03024556f, -0.08459161f, -0.07636479f, 
    -0.24652921f, 0.04713105f, -0.32801712f, -0.06020469f, 0.13472202f, -0.05798377f, -0.01852469f, 0.07717257f, 
    0.01321842f, -0.02765354f, 0.12897305f, -0.03484188f, 0.08745788f, -0.20740652f, -0.10419856f, 0.02518885f, 
    -0.03389880f, -0.01206749f, -0.07751039f, -0.09078404f, -0.06827752f, -0.02068738f, -0.00257189f, -0.01809844f, 
    -0.16084009f, 0.13291451f, -0.07004715f, -0.15029261f, 0.04510052f, -0.07112008f, -0.07441665f, 0.02194177f, 
    0.18479350f, 0.18954088f, -0.05185183f, 0.05620975f, -0.01056729f, -0.05820908f, 0.06049494f, 0.13113317f, 
    0.04744362f, -0.14469594f, 0.02148490f, -0.00433302f, -0.10727411f, -0.03821655f, 0.01446996f, 0.02766494f, 
    0.21600679f, 0.19741808f, -0.05408885f, -0.15135697f, 0.16068789f, 0.13941588f, 0.04048495f, -0.01452153f, 
    -0.05001419f, -0.05887366f, -0.10430036f, 0.05581666f, 0.33459517f, 0.20864087f, 0.04929019f, -0.07108230f, 
    0.15607782f, -0.04337430f, 0.01222018f, -0.13490303f, -0.09880924f, -0.04515680f, 0.00766541f, -0.01085049f, 
    0.20729102f, -0.02553149f, 0.04771860f, -0.07035928f, 0.02191994f, 0.01641793f, 0.03211898f, 0.08870775f, 
    -0.21358919f, -0.27326801f, 0.06811342f, -0.26764622f, -0.06352149f, 0.13560128f, -0.01430417f, -0.18942441f, 
    0.14687623f, 0.15471178f, -0.00739323f, 0.14832951f, -0.10816141f, 0.01191624f, 0.03059178f, -0.09017049f, 
    -0.15678409f, 0.06349619f, -0.32850531f, -0.18557170f, -0.06852442f, 0.00169043f, 0.19750443f, -0.09642066f, 
    0.12956944f, 0.20601118f, -0.17482564f, 0.09056409f, 0.06074975f, -0.10185257f, -0.15935199f, -0.02329043f, 
    0.04344452f, 0.15951215f, 0.00720283f, 0.02892542f, -0.02980176f, -0.09685183f, -0.07301527f, -0.09789827f, 
    -0.17500934f, -0.04604522f, 0.05159876f, -0.13645394f, -0.04621301f, 0.04732861f, 0.09133392f, 0.10168588f, 
    -0.11750367f, -0.04359514f, -0.05446040f, -0.11018427f, -0.15666926f, 0.05701133f, 0.07359068f, -0.05771552f, 
    -0.07797088f, -0.12243782f, -0.11246765f, 0.02163832f, -0.05356704f, 0.12282427f, 0.07441959f, 0.14805298f, 
    0.23405316f, 0.06409147f, 0.26438943f, -0.14278364f, 0.16568695f, 0.14800079f, 0.14811410f, -0.03808508f, 
    0.09293829f, -0.04066471f, -0.08245615f, -0.10932604f, -0.20045270f, -0.04461843f, -0.05989468f, -0.21936415f, 
    -0.10235807f, 0.17735116f, -0.03051881f, -0.09254152f, 0.19452381f, -0.01770861f, 0.10449932f, 0.06482787f, 
    0.06619617f, 0.04044801f, -0.00893902f, -0.17609626f, -0.07762825f, 0.02098087f, -0.00803970f, -0.00539324f, 
    -0.10318615f, -0.08399080f, -0.04202931f, -0.14821821f, 0.19602980f, 0.26317668f, 0.17783025f, 0.10467766f, 
    0.09905203f, 0.02451214f, -0.19021671f, 0.11285160f, 0.06997468f, 0.05729927f, 0.14607695f, 0.13503033f, 
    0.00168975f, -0.16185138f, 0.23309198f, -0.14407170f, 0.03875273f, 0.22185130f, 0.16908564f, 0.19079641f, 
    -0.06216368f, -0.19734567f, -0.00701318f, -0.18005049f, 0.13035248f, -0.24758199f, 0.13264102f, 0.03077281f, 
    0.00718902f, 0.03693966f, 0.00331979f, -0.00595475f, -0.10893978f, -0.05557802f, 0.11402597f, 0.14225891f, 
    0.18198989f, 0.32926720f, -0.01471315f, -0.10306219f, -0.09350545f, -0.07093286f, 0.21395229f, -0.13802148f, 
    0.06041254f, -0.01648468f, -0.03859745f, -0.07137267f, -0.00384899f, 0.04658691f, 0.05133710f, -0.20006488f, 
    -0.08491589f, 0.02520004f, -0.07643636f, 0.13215777f, -0.09441637f, -0.03111990f, -0.02369452f, -0.12030107f, 
    -0.15119596f, -0.26442924f, -0.15803409f, 0.06481397f, 0.08494224f, 0.09965509f, 0.19209529f, -0.07168099f, 
    0.00271134f, -0.02422034f, 0.02693562f, -0.00106834f, 0.03615101f, -0.03268029f, -0.13646489f, 0.06350876f, 
    0.03403843f, 0.04684854f, 0.13691960f, 0.05432052f, -0.03506696f, 0.07849217f, -0.06297534f, 0.10843343f, 
    0.10581950f, 0.11309401f, -0.03414709f, 0.01985380f, 0.09420982f, -0.01132485f, 0.20332088f, 0.02853353f, 
    0.02674964f, 0.06491426f, -0.06548055f, 0.01600952f, 0.15968157f, -0.09993539f, 0.11467525f, 0.16630642f, 
    0.00807389f, 0.23971824f, 0.01999537f, -0.12189268f, 0.02557997f, -0.02781789f, -0.05707944f, 0.03278302f, 
    -0.06675103f, -0.11419603f, 0.09313924f, 0.13853310f, -0.10476504f, -0.03412669f, -0.06119326f, -0.00490276f, 
    -0.12107416f, -0.05009641f, 0.08605364f, 0.14872991f, -0.08509745f, -0.01821666f, -0.06587595f, 0.24985836f, 
    0.05823424f, 0.10471223f, 0.07237212f, -0.01902061f, 0.01135301f, 0.09156036f, 0.12435944f, 0.01437403f, 
    0.32308936f, -0.23679787f, -0.05468832f, 0.10343138f, 0.12476283f, 0.08618756f, 0.06982627f, -0.07716794f, 
    -0.04561324f, 0.00072584f, -0.03989499f, -0.03652789f, 0.07706754f, -0.01494743f, -0.08815589f, -0.25125033f, 
    -0.07825246f, -0.09413712f, 0.03766264f, -0.03886529f, 0.00075551f, -0.08827399f, 0.02914092f, 0.02385870f, 
    0.12646151f, 0.34349385f, -0.26047626f, -0.28032234f, 0.00990873f, -0.06239342f, -0.04552813f, 0.13683271f, 
    0.07646269f, -0.04229591f, 0.03988222f, -0.03466658f, -0.05584145f, 0.05146720f, 0.06423923f, 0.22902277f, 
    -0.11835989f, 0.04115743f, 0.18378536f, -0.02156931f, 0.07732880f, 0.10280310f, -0.02019312f, 0.12788768f, 
    0.10726000f, 0.15791790f, -0.06401416f, 0.03305021f, -0.04178859f, -0.09438643f, -0.03616558f, -0.09380157f, 
    -0.02320396f, 0.18522047f, -0.05247538f, -0.05076398f, -0.09176841f, 0.20152272f, -0.19268262f, -0.02219329f, 
    0.05263063f, 0.03823116f, -0.05717054f, 0.08626770f, -0.00233243f, -0.09817806f, 0.17242560f, 0.05903711f, 
    -0.08824244f, -0.00216879f, -0.07451461f, -0.05809682f, -0.01546831f, -0.05924951f, 0.01650387f, 0.05630272f, 
    -0.17341110f, 0.02379216f, -0.17287716f, 0.04868330f, -0.06587148f, 0.28587297f, -0.19577755f, 0.21369824f, 
    -0.17186359f, -0.08226580f, -0.07091193f, -0.11608453f, 0.03683136f, 0.05484645f, 0.05689139f, -0.00922346f, 
    0.16563421f, -0.20672579f, -0.03479795f, -0.35261974f, 0.08932818f, -0.07437051f, -0.27144277f, -0.10454206f, 
    0.03092723f, 0.10801987f, -0.03261853f, -0.01307353f, -0.29947361f, -0.19558330f, -0.35931548f, 0.12468161f, 
    -0.09284775f, 0.23151256f, -0.04573946f, -0.37840927f, -0.07468506f, -0.12130818f, -0.07079912f, 0.03886550f, 
    0.39589536f, 0.20943667f, 0.10501119f, 0.23962826f, -0.14311419f, 0.11084131f, -0.02350743f, 0.20068738f, 
    0.04152156f, -0.00199523f, 0.07176036f, -0.04453028f, 0.26150280f, 0.21395911f, 0.10410170f, 0.06359346f, 
    0.15020372f, 0.14656502f, -0.00055098f, 0.06796756f, -0.01845896f, 0.08973178f, 0.07754625f, 0.01432318f, 
    0.17941102f, -0.08152626f, 0.01774511f, 0.08834044f, 0.18670860f, 0.06367467f, -0.03328539f, 0.14237733f, 
    -0.11908396f, 0.09700842f, 0.40048331f, 0.28734437f, 0.05579591f, 0.05488956f, -0.12458644f, 0.04629037f, 
    0.03801556f, -0.01666991f, -0.03470354f, 0.06399076f, 0.12733729f, -0.04766851f, 0.07557391f, 0.25563410f, 
    -0.03650863f, 0.40112993f, -0.33982849f, -0.03370395f, 0.03487337f, 0.16996010f, -0.10021492f, -0.09864759f, 
    -0.04464087f, -0.24637884f, -0.02393540f, -0.54670537f, -0.08851186f, -0.13972546f, 0.00925254f, 0.22158402f, 
    0.10567702f, -0.12935024f, 0.14793982f, 0.00023886f, -0.11228152f, -0.06107177f, -0.11668382f, -0.05075655f, 
    0.02248075f, 0.16002673f, 0.06116729f, 0.11193886f, 0.10864330f, -0.28699544f, -0.14129396f, -0.20850271f, 
    -0.06299313f, -0.12172311f, -0.11097971f, 0.08103163f, -0.17533635f, -0.26278058f, -0.06506269f, -0.12536718f, 
    0.15733871f, -0.25941345f, -0.48528245f, -0.37948102f, 0.05382807f, -0.12217012f, -0.19337973f, -0.14061449f, 
    0.17162061f, 0.13959076f, 0.24647567f, 0.03978236f, 0.04155993f, 0.12763079f, -0.01240036f, 0.00753141f, 
    -0.13984914f, 0.00925515f, 0.07615752f, -0.00206238f, -0.01184199f, -0.26407275f, -0.28276634f, 0.01163886f, 
    0.13474733f, 0.00895363f, -0.16647385f, -0.03765328f, -0.12426439f, -0.01989693f, 0.14323390f, -0.21713667f, 
    0.19607072f, 0.05323407f, 0.02697974f, 0.11313510f, 0.06487725f, 0.08994488f, 0.00433234f, 0.03388287f, 
    -0.09554690f, 0.14738616f, 0.10989058f, 0.31169069f, 0.13676660f, 0.13500828f, -0.01587970f, -0.12905730f, 
    0.00608207f, -0.11614660f, -0.00647659f, 0.12463924f, -0.19608566f, 0.03905307f, -0.01879474f, -0.33809441f, 
    0.30508295f, 0.12346315f, 0.21804442f, 0.38843828f, -0.04969075f, -0.03234630f, -0.08083639f, 0.18224357f, 
    -0.12528726f, 0.05433918f, -0.07960758f, -0.03947861f, 0.03266750f, 0.05347137f, 0.29488793f, 0.02834421f, 
    0.22892825f, -0.05741205f, 0.07030161f, 0.14266653f, -0.22347505f, -0.22206140f, -0.45300248f, -0.29100782f, 
    0.22376025f, 0.13665968f, -0.02576578f, -0.00146652f, 0.03358521f, -0.00239264f, 0.04535152f, -0.08989486f, 
    0.13096236f, 0.03687476f, 0.15000542f, 0.14508688f, 0.04814026f, 0.23766182f, -0.00381926f, -0.10038754f, 
    -0.11716276f, 0.10966542f, 0.07433722f, -0.08295064f, -0.06180958f, 0.03803448f, 0.02581496f, -0.01819258f, 
    -0.24716055f, -0.42401788f, -0.23206769f, 0.06236571f, 0.01435592f, -0.01516819f, 0.14421110f, 0.14123492f, 
    -0.00537532f, 0.00218257f, 0.09552379f, -0.01860146f, -0.30934590f, -0.14430413f, -0.21479003f, 0.02032115f, 
    -0.01818951f, -0.06539197f, -0.00918319f, 0.26369932f, -0.02622682f, -0.04908641f, 0.06761462f, 0.13603258f, 
    -0.10048872f, -0.08892036f, -0.17054364f, 0.01973875f, 0.11104725f, 0.01165533f, 0.08023493f, 0.30301031f, 
    -0.02575074f, 0.02316564f, 0.07215042f, -0.03731658f, 0.03585751f, -0.29396862f, -0.16352814f, -0.06968384f, 
    0.02632659f, 0.05026456f, 0.00050143f, 0.14277747f, 0.13030317f, 0.03487202f, -0.02389411f, 0.09706132f, 
    -0.15830070f, -0.06312393f, 0.01623572f, 0.04573472f, -0.11755180f, -0.05647935f, 0.13879919f, 0.07213998f, 
    -0.04321110f, 0.10750355f, 0.12475616f, 0.06314218f, -0.14663318f, -0.17101856f, -0.05947666f, -0.01545599f, 
    -0.05841046f, -0.06184430f, 0.30478260f, 0.10723091f, -0.06667709f, 0.00690898f, -0.02844055f, 0.10102707f, 
    0.38351282f, -0.12894328f, -0.06476481f, -0.07142415f, 0.03068246f, -0.06814513f, -0.05420585f, 0.03702857f, 
    0.06050416f, 0.06103538f, 0.03597857f, -0.08829772f, 0.05170748f, 0.06020134f, 0.02488507f, -0.12280371f, 
    -0.08926127f, 0.03907602f, -0.02898109f, -0.00254421f, 0.02627053f, -0.05668357f, 0.15693490f, 0.03489376f, 
    0.14118652f, 0.03738863f, -0.25858653f, -0.10349080f, 0.33456260f, 0.16496065f, -0.11931055f, 0.26335949f, 
    0.01022396f, -0.00889879f, 0.22932559f, 0.10906043f, 0.19863786f, -0.04407294f, 0.18152064f, -0.06482536f, 
    0.12899777f, 0.01074050f, 0.18284769f, 0.04395593f, 0.00660061f, 0.05143824f, 0.04890108f, 0.09082344f, 
    0.23645286f, 0.21647307f, 0.07179161f, 0.17185503f, 0.03802295f, -0.13356870f, -0.01445293f, -0.08284558f, 
    0.07762349f, 0.22062029f, 0.24256822f, -0.04404913f, -0.08265182f, -0.15566921f, 0.07455205f, -0.00295073f, 
    -0.04681518f, -0.00892135f, 0.24746738f, 0.12459730f, -0.01198987f, 0.02427351f, 0.00134215f, 0.03142011f, 
    0.24279848f, 0.04824407f, -0.28071746f, -0.08555812f, 0.06260908f, 0.09326050f, 0.13222772f, -0.02937773f, 
    -0.17968835f, -0.03401546f, -0.01653010f, -0.01809075f, 0.06980792f, 0.04573571f, -0.09819645f, -0.24706568f, 
    -0.05015623f, 0.06106603f, -0.01622024f, -0.05840307f, -0.01740601f, 0.06294004f, 0.02750189f, -0.09514811f, 
    0.46189436f, -0.05407378f, -0.11803417f, 0.20090061f, 0.03015002f, 0.10059679f, -0.06781458f, 0.09397268f, 
    -0.07592202f, 0.10163427f, -0.01528507f, 0.08058824f, 0.20333534f, -0.01049607f, 0.20146467f, 0.05815832f, 
    0.03996136f, 0.00749107f, -0.01239528f, 0.00830889f, 0.05237524f, -0.01388616f, 0.06576043f, 0.01859091f, 
    -0.10629826f, 0.03180536f, 0.27372932f, 0.29600906f, 0.02266935f, 0.04486701f, 0.05798370f, -0.04245326f, 
    -0.01854529f, 0.06911269f, 0.00269013f, 0.06060672f, -0.15998414f, 0.21259350f, 0.33081132f, 0.20783129f, 
    0.05231412f, 0.08847264f, 0.17711641f, 0.17640643f, 0.08895914f, -0.08866492f, 0.05029629f, -0.00411033f, 
    -0.05391614f, -0.01225718f, 0.00074007f, 0.05027039f, -0.01650142f, -0.14944059f, -0.21953343f, -0.10862436f, 
    -0.04381463f, -0.08085399f, -0.16854499f, 0.13466403f, -0.00530034f, 0.09879480f, 0.01167342f, -0.01216044f, 
    -0.02464664f, -0.03059007f, -0.16268791f, 0.05822500f, -0.12578784f, -0.06563493f, -0.11610761f, -0.21132639f, 
    0.03450703f, -0.00903541f, 0.18373433f, 0.00460015f, -0.08437102f, 0.01267635f, 0.22012021f, -0.03301932f, 
    -0.09005731f, -0.04330116f, -0.02831326f, 0.20999822f, -0.07247359f, -0.06514218f, -0.01320133f, -0.13675660f, 
    -0.03401227f, 0.25334328f, -0.04061205f, 0.21034758f, 0.02428672f, 0.16811249f, -0.03936174f, 0.07545023f, 
    -0.21211047f, -0.13548209f, -0.14938402f, -0.20610899f, 0.03959387f, -0.11490887f, -0.03310887f, 0.14560461f, 
    -0.12091292f, -0.03919449f, -0.01524774f, 0.00364879f, 0.10982601f, 0.09639018f, 0.10810690f, 0.03327928f, 
    -0.03023028f, -0.03969834f, -0.07965414f, -0.00991030f, 0.00467886f, 0.06587449f, 0.04265435f, 0.04753157f, 
    -0.35199192f, 0.22991344f, 0.11213911f, 0.06794089f, 0.16672939f, 0.08757313f, 0.11464027f, 0.09950449f, 
    0.01681970f, 0.03739375f, 0.03076107f, -0.03405905f, 0.03401723f, 0.15306476f, -0.09454501f, -0.02989186f, 
    -0.10400549f, 0.16528593f, 0.14349772f, 0.00571837f, 0.06626808f, 0.12420447f, 0.17376682f, -0.06443425f, 
    -0.15437852f, 0.14839837f, -0.06581695f, -0.09767769f, 0.03979763f, 0.03669116f, -0.03838043f, -0.09438422f, 
    -0.15069377f, -0.38578537f, -0.07934871f, -0.15032619f, -0.32275552f, 0.06523272f, 0.15619329f, 0.16177100f, 
    0.07412945f, 0.13470343f, -0.18309508f, 0.02662554f, 0.04078597f, 0.05765474f, -0.02918620f, -0.08385415f, 
    -0.12162738f, -0.13597991f, 0.29803029f, 0.10881141f, 0.05178038f, -0.06007688f, -0.01941476f, 0.03506679f, 
    0.03965103f, 0.16815694f, 0.09328975f, -0.09995666f, 0.25411004f, 0.21405138f, 0.02909641f, 0.01493639f, 
    -0.05537253f, -0.10063729f, 0.04150787f, -0.07900321f, 0.09540367f, 0.04631327f, 0.04942418f, -0.03815811f, 
    -0.14538150f, 0.26522160f, 0.26088431f, -0.10014413f, 0.04451416f, 0.02938921f, -0.12874269f, 0.04133218f, 
    0.04365871f, -0.04184639f, 0.15515937f, 0.15548795f, -0.14999956f, 0.07891789f, -0.03419253f, -0.00399344f, 
    -0.02276252f, -0.08162960f, 0.02280934f, -0.15618145f, -0.30718949f, 0.01535106f, -0.02147767f, -0.05261342f, 
    0.04317462f, -0.06459225f, -0.16182624f, -0.06804471f, -0.09409869f, 0.12720494f, 0.07823971f, 0.11752511f, 
    0.04080316f, -0.01282347f, -0.01037296f, 0.09019771f, -0.02802342f, -0.18953906f, -0.26686102f, -0.00243216f, 
    0.01769256f, 0.14230517f, 0.02119676f, 0.08935138f, -0.02210665f, 0.07254817f, 0.00806831f, 0.10603883f, 
    -0.03608009f, 0.16330093f, -0.22575247f, -0.04585304f, 0.04569886f, 0.00587418f, 0.14694473f, 0.07949329f, 
    0.09091781f, -0.03651090f, 0.03393928f, -0.10407206f, 0.15013957f, -0.02008663f, -0.19270498f, -0.05587771f, 
    0.05289753f, 0.08069625f, 0.06656247f, -0.00525148f, 0.10193077f, -0.09554023f, -0.12728699f, -0.03856889f, 
    -0.00517404f, -0.25794682f, 0.04990573f, 0.02879828f, 0.09142312f, 0.07625394f, -0.05562748f, 0.00054530f, 
    -0.04914820f, 0.04240127f, 0.09389376f, 0.02526822f, 0.13118172f, -0.05248831f, 0.01124947f, 0.14550705f, 
    0.18468162f, 0.02105387f, 0.12356748f, 0.04734248f, 0.00824928f, -0.11017777f, 0.01354981f, 0.02864194f, 
    -0.33782941f, 0.35276064f, -0.11421969f, -0.07368517f, -0.06166791f, 0.03881512f, 0.17816354f, -0.01520408f, 
    -0.11856615f, -0.10329843f, 0.02047808f, -0.00540079f, -0.20367965f, -0.03606956f, -0.18204859f, -0.04940863f, 
    -0.10654566f, -0.11837061f, -0.04659680f, -0.02638392f, -0.05501621f, -0.00542862f, 0.04886975f, 0.03259484f, 
    -0.14078146f, 0.28823185f, -0.34688506f, 0.09458695f, 0.20792829f, -0.02601967f, 0.14167909f, -0.04749903f, 
    0.18462269f, 0.04168162f, 0.05963416f, 0.16781640f, 0.22386631f, -0.10582357f, 0.16535173f, 0.18797098f, 
    -0.00902945f, 0.14823823f, -0.05895884f, 0.06817836f, -0.06835200f, 0.03934808f, 0.02114412f, 0.18588948f, 
    -0.07647680f, 0.09488340f, -0.00438918f, -0.01367672f, -0.08512267f, -0.00280482f, -0.10762616f, 0.00636466f, 
    -0.13502380f, 0.05989727f, -0.01724641f, -0.07316781f, 0.02075449f, -0.14843293f, -0.21621537f, 0.37677133f, 
    0.08419321f, -0.11766642f, 0.19540459f, -0.07626626f, 0.02440718f, -0.02904141f, 0.10466122f, 0.08786445f, 
    0.05558686f, 0.32511261f, 0.02661445f, -0.11047705f, 0.10981797f, -0.02862264f, 0.01551526f, 0.12714666f, 
    -0.13055578f, 0.04218906f, -0.13769341f, -0.01944647f, 0.02531948f, 0.07313892f, 0.07521891f, 0.05677271f, 
    -0.05916705f, -0.00659589f, 0.05615760f, -0.01710000f, 0.02516915f, -0.05724353f, -0.07371418f, 0.07674876f, 
    0.37834156f, 0.02063894f, -0.29453436f, 0.22644544f, -0.18167053f, -0.10385286f, -0.11880009f, -0.04857780f, 
    -0.01810275f, 0.12303268f, -0.04939248f, -0.06061921f, 0.02495123f, -0.25234136f, -0.38108280f, -0.28726530f, 
    0.08284940f, 0.00674891f, -0.00037365f, 0.05149566f, 0.13393801f, 0.06585895f, 0.12700145f, 0.07221085f, 
    0.04557196f, 0.07053144f, 0.12314165f, 0.10493033f, 0.06199242f, -0.00214453f, 0.09258686f, -0.00385079f, 
    -0.11505844f, -0.07325437f, 0.11380739f, 0.09431919f, -0.00639565f, -0.14689624f, 0.07600092f, 0.03638606f, 
    0.12477433f, -0.02069768f, 0.12920105f, -0.08081336f, -0.04088460f, -0.04762493f, -0.10908765f, 0.10772622f, 
    0.15725955f, 0.08619503f, 0.10964824f, 0.17207116f, 0.06359360f, 0.10980282f, 0.08861561f, -0.17957559f, 
    0.20814766f, 0.27883250f, -0.13067541f, 0.22921352f, 0.21720746f, 0.01507839f, 0.25279936f, 0.18437067f, 
    0.00155970f, 0.13760978f, 0.18119411f, -0.07526529f, 0.09949631f, 0.08649796f, -0.03159134f, -0.01672254f, 
    -0.15391985f, -0.09651701f, -0.05079165f, -0.02448019f, 0.08063650f, 0.05327531f, -0.03691012f, 0.08162883f, 
    -0.13017064f, -0.30343080f, -0.21979606f, -0.15776296f, 0.22994807f, 0.19100462f, 0.30056113f, 0.01941262f, 
    0.04130679f, 0.03637164f, 0.08539461f, -0.00899915f, -0.20093459f, 0.06599104f, -0.03523245f, -0.14135170f, 
    0.23033148f, -0.05263457f, 0.11804157f, 0.18332925f, 0.00940418f, 0.22408055f, -0.00272167f, -0.03593027f, 
    0.23899491f, 0.03574286f, -0.08144579f, 0.00874370f, -0.00655377f, -0.17763083f, -0.39360854f, -0.23340929f, 
    -0.02259926f, 0.08546026f, -0.02155188f, -0.12313166f, -0.14418571f, -0.06724987f, 0.00035567f, -0.00136985f, 
    0.11171110f, -0.27801231f, 0.10202695f, -0.06918940f, -0.09112567f, -0.07908154f, -0.11814303f, -0.09399731f, 
    -0.02795233f, 0.07431225f, -0.04094396f, 0.00507221f, 0.17125712f, 0.18699156f, -0.00096761f, 0.30940145f, 
    0.23750934f, -0.05200342f, 0.05672979f, 0.01464264f, -0.08401804f, -0.02022677f, -0.23816666f, -0.07591110f, 
    0.00610788f, 0.01779697f, 0.05973929f, 0.18048549f, -0.02092978f, -0.10520256f, 0.06092367f, 0.20994292f, 
    0.08695532f, 0.43363053f, 0.22154002f, 0.29927289f, 0.12138171f, -0.16223471f, -0.20154281f, -0.11402337f, 
    -0.02111609f, -0.00070239f, 0.15792596f, -0.06383314f, 0.06500354f, -0.17455271f, -0.31812727f, -0.09746420f, 
    -0.15827841f, -0.01505276f, -0.32941765f, -0.03827593f, 0.16450147f, 0.04544176f, 0.04601644f, -0.10853358f, 
    0.28583139f, 0.20164050f, 0.01194710f, 0.22628662f, -0.48644188f, -0.36674801f, -0.09036185f, 0.11920740f, 
    0.10769236f, -0.07574312f, -0.18243857f, -0.20931250f, -0.08041489f, -0.07894414f, -0.06629318f, 0.00971862f, 
    0.02438861f, 0.05354879f, 0.05706642f, -0.03801538f, 0.02885604f, -0.04388303f, -0.06259576f, -0.04784716f, 
    0.04171802f, -0.01972349f, -0.00247603f, -0.02154802f, 0.03631607f, -0.06279640f, -0.05489422f, 0.03662682f, 
    -0.01382250f, 0.03407479f, -0.02585989f, 0.00763393f, -0.02278014f, 0.00350347f, -0.02028666f, 0.02796819f, 
    -0.02573914f, 0.04727900f, 0.05382761f, -0.05508910f, 0.05125560f, -0.00683158f, -0.03908780f, -0.06726369f, 
    -0.05286128f, -0.02964293f, 0.01792157f, -0.05075734f, 0.01002117f, 0.00555043f, -0.03490514f, -0.02760128f, 
    0.02610596f, 0.05374787f, 0.04018547f, 0.05885028f, -0.00868327f, -0.04370092f, 0.01608258f, -0.02959092f, 
    0.06403843f, -0.07186403f, 0.05076350f, -0.05447738f, -0.04401792f, -0.04909239f, 0.00216471f, -0.06579205f, 
    -0.05458251f, 0.05895681f, -0.07146212f, -0.01442772f, -0.05905250f, -0.00998290f, -0.02737274f, 0.01474918f, 
    -0.04020732f, -0.06690867f, -0.05780513f, 0.00431393f, -0.03854209f, 0.06699769f, 0.01572481f, -0.06338337f, 
    -0.06385979f, 0.02733360f, -0.02661802f, -0.01114888f, -0.02202246f, -0.05944002f, -0.03782288f, -0.05797502f, 
    -0.05361551f, 0.00047275f, 0.01815645f, 0.06064056f, -0.01040656f, 0.06401800f, 0.00634033f, 0.06357086f, 
    -0.03520958f, -0.04286763f, 0.02529430f, -0.02119319f, -0.02834929f, 0.06930558f, 0.04875578f, 0.01118147f, 
    -0.02093623f, 0.04683844f, -0.04627945f, -0.05880560f, -0.05095453f, -0.04172530f, -0.01425807f, -0.06629799f, 
    -0.06533330f, 0.01670860f, -0.06277776f, -0.02163659f, -0.05027980f, -0.02353963f, 0.06001754f, -0.02668042f, 
    0.04824029f, 0.05334522f, -0.02600187f, 0.03735143f, 0.02139434f, 0.06813905f, -0.01336595f, 0.01751364f, 
    -0.05619256f, -0.02548550f, -0.04942166f, 0.04535710f, -0.01216618f, 0.03852182f, 0.01381635f, -0.00532826f, 
    0.00922917f, 0.01837196f, 0.01307411f, -0.00252800f, 0.05362962f, 0.00312095f, 0.06530903f, -0.00112169f, 
    0.00554987f, 0.03840990f, 0.01535484f, -0.01952545f, -0.03478697f, -0.01229844f, -0.01239063f, -0.05153457f, 
    0.06636228f, 0.01845730f, 0.05818972f, 0.03265692f, -0.05063442f, 0.03295992f, 0.04447471f, -0.04181859f, 
    -0.03520748f, -0.06663670f, 0.02372651f, 0.00309923f, 0.03245533f, -0.01986295f, 0.02628838f, 0.01557344f, 
    0.02386827f, 0.05581371f, -0.02748421f, -0.06508521f, 0.02034827f, -0.05162161f, -0.05462071f, 0.01730894f, 
    0.05060871f, -0.06564086f, 0.05246445f, -0.05816721f, -0.05355429f, -0.00274056f, 0.04330704f, -0.04898749f, 
    -0.04286687f, 0.05592036f, -0.06916703f, 0.03352133f, -0.03173623f, -0.06830068f, 0.04844657f, -0.00340725f, 
    0.04016895f, -0.07074127f, -0.04559709f, 0.05838791f, -0.03115954f, 0.01177501f, -0.06688014f, -0.01852066f, 
    0.05219932f, -0.00425810f, -0.00771132f, 0.02102055f, 0.01352821f, 0.06984009f, -0.00677958f, -0.03464319f, 
    -0.03078812f, -0.04058485f, -0.06373895f, 0.01520467f, -0.04509677f, -0.00415528f, -0.00045824f, 0.00435390f, 
    -0.02603511f, -0.05614597f, -0.03085819f, -0.05079460f, -0.06772989f, -0.00409847f, 0.06097399f, -0.01005553f, 
    0.01728014f, -0.05115640f, -0.00267551f, 0.01833711f, -0.07125168f, -0.03743559f, -0.02641383f, -0.07704121f, 
    0.03838112f, -0.06174847f, -0.00173472f, 0.01515373f, -0.04873436f, -0.05132549f, -0.01193083f, -0.05027656f, 
    0.06191024f, -0.04245869f, -0.04948904f, 0.00039658f, -0.00083229f, 0.02012787f, 0.03559187f, -0.03253790f, 
    0.01669114f, 0.00735876f, -0.00510619f, 0.06556407f, 0.02328839f, -0.06869423f, -0.06194923f, 0.00844213f, 
    0.04344807f, 0.05534295f, -0.03737563f, -0.01562521f, -0.04734634f, 0.04862864f, -0.02045544f, -0.06446021f, 
    0.03961879f, -0.01331865f, 0.00756546f, 0.05862892f, -0.07493526f, 0.02513861f, 0.02408445f, -0.07520256f, 
    -0.01520952f, -0.00334972f, 0.03534918f, -0.01526288f, -0.03919556f, -0.00758334f, -0.04424023f, 0.02961706f, 
    0.04665600f, -0.04520527f, -0.02461860f, 0.00823365f, -0.02071360f, -0.02915529f, -0.05203512f, 0.04805139f, 
    0.06183219f, -0.03546210f, 0.04177217f, 0.02557082f, 0.05906336f, -0.01318775f, -0.01953057f, -0.03662772f, 
    -0.06175402f, 0.03877556f, -0.02232086f, -0.01019867f, -0.03615298f, -0.04600104f, -0.06886071f, 0.01953512f, 
    -0.01722496f, -0.01614491f, 0.05977968f, 0.05742717f, -0.07431278f, -0.06628168f, -0.06638014f, -0.03597635f, 
    0.04429737f, 0.07158854f, -0.01711968f, -0.02464559f, -0.02443046f, -0.04095718f, 0.01305364f, 0.05848736f, 
    -0.01974810f, -0.02964991f, 0.02155576f, -0.05899078f, 0.00262709f, -0.06056648f, 0.05123025f, -0.05728275f, 
    -0.03283158f, 0.01788927f, 0.03315599f, -0.05023434f, 0.05303442f, 0.02615963f, 0.06622273f, -0.04139158f, 
    0.05880354f, -0.00859354f, -0.02008948f, -0.01265111f, -0.03721834f, 0.07339425f, 0.06807186f, -0.04111386f, 
    0.02894129f, 0.01746421f, -0.00211928f, -0.05830197f, 0.00477540f, 0.06604380f, -0.03893971f, 0.05654225f, 
    -0.01932594f, -0.07455998f, 0.04774144f, -0.04509206f, 0.00656067f, -0.06704985f, -0.00490635f, -0.01855847f, 
    0.01177677f, 0.06457344f, -0.07189880f, -0.03145546f, 0.02455471f, 0.03071744f, 0.00281678f, -0.06234742f, 
    -0.01009510f, -0.04623230f, 0.03096621f, 0.01725697f, -0.06259857f, -0.05829209f, -0.00967911f, 0.04286322f, 
    0.04362338f, 0.01256921f, 0.02605365f, 0.02533070f, 0.03505555f, -0.02072478f, -0.05877507f, -0.00973052f, 
    0.02099391f, 0.04949554f, -0.03369958f, -0.04962913f, 0.00631659f, -0.07489800f, 0.03202055f, -0.05876371f, 
    0.02495079f, -0.46039739f, -0.10374205f, 0.13560736f, 0.02228148f, -0.06751817f, -0.10407057f, 0.08046612f, 
    0.14828578f, 0.09851579f, 0.09062283f, 0.16791332f, -0.12458936f, -0.09951246f, 0.14251687f, 0.22966222f, 
    0.05644277f, 0.01744617f, 0.04845634f, -0.10066241f, 0.09923977f, -0.01165981f, 0.07782197f, 0.10147235f, 
    0.23308496f, 0.33117074f, 0.20611349f, -0.19630703f, -0.12155018f, -0.05514454f, 0.07816235f, 0.17260963f, 
    0.05662520f, 0.00490394f, -0.00285535f, 0.04861439f, 0.19292818f, 0.01515987f, 0.21322283f, -0.24672146f, 
    -0.05352795f, 0.06886893f, -0.06511407f, 0.01442526f, 0.02820748f, 0.00965224f, 0.08958608f, 0.03421663f, 
    0.17740437f, -0.07061418f, 0.18827036f, -0.13587919f, -0.00301350f, 0.10135986f, 0.06105651f, -0.05072812f, 
    0.06163821f, -0.02931319f, -0.02167368f, 0.11399218f, 0.12873727f, 0.23835140f, -0.11477925f, -0.15581115f, 
    -0.04376250f, -0.04239022f, 0.04931897f, 0.11968564f, 0.09108532f, -0.12102696f, -0.07684097f, -0.04388485f, 
    0.02802916f, 0.10038766f, -0.16292703f, -0.02325323f, 0.03037130f, 0.08157133f, -0.02486676f, -0.03350400f, 
    0.05488766f, -0.00907653f, -0.17649952f, -0.00813583f, 0.07869048f, 0.08789130f, -0.00594131f, -0.27703470f, 
    0.09433147f, 0.11475653f, -0.01763386f, 0.07945581f, -0.11993033f, -0.10532084f, -0.00062437f, -0.06186299f, 
    -0.15006591f, 0.15423134f, -0.24380095f, -0.11329325f, -0.15183778f, -0.00989336f, -0.06585655f, 0.14445971f, 
    0.02871261f, -0.13729055f, 0.00366368f, -0.01554682f, -0.01355234f, -0.05628806f, 0.06866102f, 0.18259558f, 
    0.01137623f, -0.04387798f, -0.00122453f, 0.00360153f, -0.00042780f, 0.00584871f, -0.01292100f, -0.05039144f, 
    0.36484623f, -0.32720980f, 0.27140209f, 0.09515177f, -0.08344171f, -0.09124400f, 0.02973752f, -0.09967155f, 
    0.14598137f, -0.08189949f, -0.04990745f, 0.13325542f, 0.01638262f, 0.01702744f, -0.15884201f, -0.08118740f, 
    -0.10881419f, 0.04603159f, -0.13401417f, 0.02211291f, -0.05767680f, -0.15472406f, -0.03518477f, -0.14283901f, 
    0.01090028f, -0.12202281f, 0.09210236f, 0.11895302f, -0.01392903f, 0.08355515f, -0.01035114f, -0.03447172f, 
    0.15709040f, -0.02376338f, -0.02086982f, 0.15058923f, 0.18547796f, -0.03504902f, 0.00572987f, -0.00276117f, 
    -0.08911920f, 0.04021861f, 0.15279320f, 0.05383842f, -0.01453385f, 0.02796477f, -0.08090989f, -0.07746472f, 
    0.01163097f, 0.09263441f, 0.19218506f, -0.01946991f, 0.25773910f, -0.06034429f, -0.01082967f, -0.08072663f, 
    0.19267264f, -0.01500925f, 0.11957566f, -0.05081544f, 0.38861713f, -0.27601323f, 0.15157847f, -0.18354754f, 
    0.00599907f, 0.01634338f, 0.05516532f, 0.01720350f, 0.02018002f, -0.03029611f, -0.07171196f, -0.12421826f, 
    0.18670624f, 0.39705589f, 0.08995109f, 0.01585991f, -0.03647310f, -0.01990308f, -0.04470409f, 0.04121005f, 
    -0.04177290f, -0.00040801f, 0.04705105f, 0.07941354f, 0.28874290f, 0.00370618f, -0.10151540f, -0.03457606f, 
    -0.07347783f, -0.04054972f, 0.03257361f, 0.01063116f, 0.14969905f, 0.02120627f, 0.03728227f, -0.07877344f, 
    -0.13163497f, -0.20823261f, 0.04946619f, 0.28936529f, -0.06847474f, -0.14568457f, -0.03201760f, -0.01524928f, 
    0.05575473f, -0.00477364f, 0.02005110f, 0.03774361f, -0.34548977f, -0.18490140f, -0.02806542f, 0.35499164f, 
    0.03097046f, 0.04349484f, 0.02224608f, 0.07242486f, -0.00047348f, -0.01655795f, 0.07018381f, 0.09959961f, 
    -0.10105807f, -0.07749539f, -0.12445265f, 0.13354571f, 0.13328974f, 0.03712404f, 0.01630268f, 0.15267061f, 
    0.05088193f, 0.14886397f, 0.10396082f, 0.05625704f, -0.14716791f, -0.12829059f, -0.05701926f, 0.11949187f, 
    -0.06042666f, -0.14500397f, -0.11531765f, 0.02918279f, 0.07286204f, -0.02459445f, -0.01532552f, 0.14558691f, 
    0.02847486f, 0.09187533f, 0.06988115f, -0.02840769f, -0.05524238f, -0.01116338f, 0.03664774f, 0.13267246f, 
    -0.11384653f, -0.08965773f, 0.02878053f, -0.03414693f, 0.05089472f, 0.13355644f, 0.02557239f, 0.06088797f, 
    -0.09720205f, -0.20693871f, 0.29519749f, 0.20108235f, 0.00193763f, 0.09278730f, -0.09107463f, -0.03540773f, 
    -0.11399619f, 0.01914972f, 0.04190512f, -0.02799833f, 0.04917919f, -0.22632851f, -0.14457589f, 0.08930425f, 
    0.01621381f, 0.06310482f, 0.10855956f, 0.10154114f, 0.09039062f, 0.10537115f, 0.02235750f, -0.13285881f, 
    -0.07272103f, 0.02799994f, -0.04069813f, -0.13750748f, -0.00636074f, -0.15176821f, -0.13621852f, -0.27201617f, 
    -0.37139815f, -0.05027399f, -0.13507380f, 0.31796595f, 0.14244178f, 0.23870662f, 0.01916498f, 0.21581121f, 
    -0.00313716f, 0.07357121f, 0.21980530f, 0.06243358f, 0.27237985f, 0.18017599f, 0.18590495f, 0.08562028f, 
    0.04300337f, -0.14436044f, 0.00844533f, 0.21180344f, -0.09253926f, 0.20495090f, 0.06307109f, 0.03085969f, 
    -0.07890277f, 0.10194810f, 0.00383011f, 0.10265825f, 0.01045458f, 0.03210204f, -0.07451428f, -0.04053118f, 
    -0.02916835f, 0.14038482f, 0.11364513f, 0.09238192f, -0.20805749f, -0.33661714f, 0.15056534f, 0.09656715f, 
    0.01848524f, 0.06404774f, 0.02645554f, 0.03611122f, -0.00491075f, -0.07931486f, -0.10142920f, -0.04422130f, 
    0.18386458f, -0.08509272f, -0.32882592f, 0.13094637f, -0.06308206f, 0.24735688f, 0.07322028f, 0.02916253f, 
    -0.01511979f, 0.25440124f, 0.16705005f, 0.19868812f, 0.14195350f, 0.25428805f, -0.05755889f, -0.03064697f, 
    0.03598204f, -0.00377207f, 0.05064255f, -0.15998676f, 0.01062667f, -0.01857400f, -0.00229909f, -0.01133086f, 
    0.00618925f, -0.01453671f, 0.04112745f, 0.04382909f, -0.02053337f, 0.03014255f, -0.02931522f, -0.05308804f, 
    -0.05717948f, -0.06277496f, 0.00306830f, 0.01751121f, -0.04961257f, -0.03019808f, 0.02492638f, -0.06540640f, 
    -0.08046717f, -0.01759359f, 0.04336537f, -0.00758268f, 0.02167898f, -0.02312090f, -0.03399395f, 0.00266993f, 
    0.03617456f, 0.03687117f, 0.03733917f, -0.02282604f, 0.05069306f, 0.01585455f, 0.00169590f, -0.00718376f, 
    0.03069587f, -0.03022817f, -0.06193267f, -0.01506319f, -0.04166678f, 0.02751107f, -0.02104284f, 0.03618447f, 
    0.03506604f, -0.03195000f, 0.01452939f, -0.00149166f, -0.00955029f, 0.02929276f, -0.05492044f, 0.01743942f, 
    -0.06939856f, -0.05531258f, 0.03508040f, 0.02094443f, 0.02101242f, -0.08331181f, -0.04208811f, 0.02095412f, 
    0.03829264f, 0.06083773f, -0.06840590f, 0.04557162f, 0.00118096f, 0.04445745f, 0.04483850f, 0.00201182f, 
    -0.05272609f, 0.00350719f, 0.01489929f, -0.06731136f, -0.07875798f, 0.05096605f, 0.02025769f, 0.04204794f, 
    0.02210915f, 0.05830525f, -0.05069601f, -0.06790147f, -0.06395196f, 0.00718730f, -0.04436489f, -0.04758390f, 
    -0.03831434f, 0.05121119f, -0.00001916f, -0.06230270f, -0.07373770f, -0.01152986f, 0.00487843f, 0.02368036f, 
    -0.03457130f, -0.02909693f, 0.00585051f, 0.01147096f, -0.01863761f, -0.00132364f, 0.01587062f, -0.01877485f, 
    -0.06049114f, -0.07694058f, -0.05791117f, 0.01161842f, -0.07469383f, 0.03819417f, 0.03744693f, -0.06698854f, 
    0.04024000f, 0.01846109f, 0.06074022f, 0.02423143f, 0.00583194f, 0.02269563f, 0.05055534f, 0.00877777f, 
    0.05753770f, -0.07612157f, -0.02211666f, -0.05208457f, 0.01139263f, 0.02214058f, 0.05036046f, -0.03374124f, 
    -0.03635501f, 0.00343227f, 0.05164149f, 0.03127293f, -0.02347130f, -0.01580565f, 0.00905549f, 0.04535407f, 
    -0.05127544f, 0.01178291f, 0.01970212f, -0.06345164f, -0.06995784f, -0.06218901f, 0.02164533f, -0.04751034f, 
    -0.07616056f, 0.03271013f, -0.05962225f, 0.02694238f, 0.04232614f, -0.03920248f, 0.05623013f, -0.04991592f, 
    -0.04506208f, -0.02184385f, 0.00671988f, 0.03459640f, -0.00270080f, -0.00810300f, -0.01996719f, 0.05568047f, 
    -0.07440219f, -0.02308464f, -0.07451432f, 0.01824517f, -0.05606394f, 0.01102232f, 0.04712489f, -0.04266870f, 
    0.01328312f, 0.00827888f, -0.07962146f, -0.05864040f, 0.05322878f, -0.00882501f, 0.05483593f, -0.01018026f, 
    -0.05887039f, -0.04798657f, -0.02134194f, 0.02631500f, 0.03708398f, 0.04670677f, 0.01617188f, -0.05478919f, 
    -0.03580192f, -0.02568449f, 0.01881477f, 0.03977896f, 0.01274475f, -0.02314195f, 0.01511514f, 0.02408653f, 
    -0.04151563f, 0.00767802f, -0.04547096f, 0.02104118f, 0.02516870f, 0.02069078f, -0.02873066f, 0.00917659f, 
    -0.00381950f, 0.03146892f, -0.07338713f, -0.02538800f, -0.03277990f, -0.05097965f, 0.05842797f, -0.05946022f, 
    0.02431335f, 0.05010998f, 0.00197995f, -0.03051307f, -0.02329760f, 0.04279314f, 0.04820384f, -0.07797905f, 
    0.00229018f, -0.00146547f, 0.06274794f, -0.01296232f, 0.03609323f, -0.01066967f, -0.02537943f, 0.05541416f, 
    -0.03521733f, 0.02068611f, 0.02161264f, 0.01734453f, -0.00672953f, 0.05496785f, -0.03973244f, -0.02920408f, 
    -0.07138033f, -0.06286989f, -0.05586131f, 0.03246011f, 0.05611972f, -0.03431615f, -0.05025585f, -0.01168112f, 
    0.02498111f, 0.02604578f, -0.04448773f, -0.05433057f, 0.00224211f, 0.01916201f, -0.05836323f, 0.06101245f, 
    -0.02412155f, 0.03079500f, 0.01847401f, -0.07544463f, -0.00181082f, 0.01790833f, -0.06793551f, -0.00094698f, 
    0.04136684f, -0.00008368f, 0.00494173f, -0.03026372f, -0.06421308f, 0.02149445f, -0.05115051f, -0.02415678f, 
    -0.04282585f, -0.00490605f, -0.00209112f, -0.02137541f, -0.01103349f, 0.02320128f, 0.02281866f, 0.03030460f, 
    0.04020625f, 0.00763827f, -0.06992834f, 0.02055126f, -0.06723623f, 0.05944881f, 0.02426067f, -0.00916759f, 
    0.00088886f, -0.03285952f, 0.00688591f, -0.08248740f, 0.00652404f, 0.00055091f, -0.06149115f, 0.01407034f, 
    -0.03094478f, -0.02364579f, -0.00711957f, -0.02436309f, -0.05301660f, -0.07397342f, 0.02809312f, -0.07697624f, 
    -0.02902116f, -0.00136842f, -0.02698191f, -0.05573999f, -0.03610934f, -0.00988857f, -0.05745023f, 0.02474918f, 
    0.04282407f, 0.01895385f, -0.00200319f, 0.03269233f, -0.03555702f, 0.01992701f, -0.05682410f, -0.07516331f, 
    -0.01726715f, 0.04546751f, -0.02125059f, -0.06187943f, -0.06568480f, 0.04186627f, -0.04595612f, 0.03315558f, 
    -0.02164578f, -0.01816777f, 0.00131117f, -0.00186258f, 0.06138740f, -0.00829320f, -0.05080305f, 0.05488657f, 
    -0.01975400f, -0.03862653f, 0.01027731f, 0.00353219f, -0.00958215f, -0.00178841f, 0.01794986f, -0.02971492f, 
    0.02506025f, -0.08063222f, 0.05537456f, 0.02168652f, 0.03904483f, 0.04780111f, -0.05333462f, -0.07230015f, 
    -0.06161920f, -0.02501040f, 0.02441982f, -0.05563962f, -0.07255691f, 0.00695694f, 0.05144896f, -0.08129762f, 
    -0.03865292f, -0.04766978f, -0.06562027f, -0.01365067f, -0.00586405f, 0.04666890f, 0.00360613f, -0.05210666f, 
    -0.04274920f, 0.01219749f, -0.01241365f, 0.01138600f, -0.06451564f, -0.03170007f, 0.05050827f, -0.00264226f, 
    -0.03004986f, 0.00501560f, 0.00848929f, 0.01509833f, -0.07047303f, -0.06659723f, -0.05237285f, -0.03971351f, 
    -0.05215016f, 0.06503560f, 0.04962707f, -0.02895173f, -0.00658267f, 0.04468803f, 0.05826111f, 0.03829486f, 
    -0.03056190f, -0.03845224f, 0.05377642f, -0.07987937f, 0.04935375f, -0.05541896f, -0.03116436f, -0.02473999f, 
    0.18187381f, 0.18595476f, -0.01072312f, 0.16926169f, 0.17354508f, -0.21685249f, 0.07759301f, -0.03583211f, 
    0.13553396f, 0.12381053f, -0.01870471f, 0.16600282f, -0.05012842f, 0.26310733f, 0.01313504f, -0.12631159f, 
    -0.15223683f, -0.04038392f, 0.05394690f, -0.10172611f, 0.03964312f, 0.08137898f, 0.03486291f, -0.05685202f, 
    -0.26100117f, -0.28723854f, -0.19023497f, -0.01788534f, 0.12680244f, -0.00845113f, 0.07446039f, 0.08836894f, 
    0.06593724f, 0.00842500f, 0.04212827f, 0.03999830f, -0.11508797f, 0.05159032f, -0.23476468f, 0.01748102f, 
    -0.08570872f, -0.08462512f, -0.05943339f, 0.13247280f, -0.04924354f, 0.09942129f, 0.02586724f, 0.00690597f, 
    0.01746901f, 0.03084852f, 0.04232375f, 0.00248343f, 0.05868616f, -0.12932268f, -0.02909970f, 0.12884218f, 
    -0.03222419f, -0.20943685f, 0.05331599f, -0.11910491f, -0.00510459f, -0.12437090f, -0.08942099f, -0.06397893f, 
    -0.02828819f, 0.09134588f, -0.12893160f, 0.18883716f, -0.06141794f, -0.07883424f, 0.01966957f, -0.00224282f, 
    -0.02699410f, 0.05443824f, 0.05842663f, -0.07559247f, 0.10799208f, 0.06830543f, 0.18756530f, 0.11924810f, 
    0.04899372f, 0.11815412f, 0.05808208f, 0.11216359f, -0.11773248f, 0.00147283f, -0.02953941f, -0.04971131f, 
    0.04651611f, 0.12138584f, 0.21447663f, 0.10846358f, 0.05085738f, -0.06574295f, -0.12034805f, -0.05840153f, 
    0.16486321f, -0.17915730f, -0.11454622f, -0.08094455f, -0.01720975f, -0.07377332f, 0.01001374f, 0.15528569f, 
    -0.08509070f, 0.03819015f, -0.06166140f, -0.12032631f, 0.04568039f, 0.09163640f, -0.06723985f, -0.15842326f, 
    -0.04807410f, 0.01904435f, 0.01523589f, 0.00409715f, 0.06241938f, 0.08114556f, 0.11077316f, 0.07544913f, 
    -0.16910547f, 0.21608180f, -0.17694937f, 0.03913797f, 0.13548920f, 0.12160464f, 0.03083474f, 0.23475641f, 
    0.20971349f, -0.12049850f, 0.23670699f, 0.02902576f, 0.15994824f, -0.07005219f, 0.19926269f, -0.02214915f, 
    0.13474190f, 0.02941545f, 0.07565071f, 0.11663982f, -0.03538817f, 0.12472635f, 0.08859247f, 0.05095666f, 
    0.18945399f, 0.24674471f, -0.06154641f, 0.02458487f, -0.05735233f, -0.10254338f, -0.05399010f, 0.04064180f, 
    -0.04385858f, -0.11472063f, 0.09558333f, -0.10889988f, -0.04560781f, -0.03054595f, 0.08854681f, 0.20308667f, 
    0.10079463f, 0.13455296f, 0.10986368f, 0.10156689f, 0.06073619f, 0.02103630f, 0.21792081f, -0.02714488f, 
    0.22086170f, -0.12714481f, -0.26040930f, 0.04525562f, 0.01839690f, -0.04729243f, 0.18493661f, -0.13691513f, 
    0.01362069f, 0.00738498f, -0.10225829f, -0.00876481f, 0.26504228f, 0.23080501f, -0.07818291f, -0.21347344f, 
    -0.11344239f, 0.00797850f, 0.04669673f, -0.06951595f, -0.05658651f, 0.02896723f, -0.04818020f, -0.02811963f, 
    0.14024267f, -0.10118414f, 0.09669726f, -0.16248985f, -0.22447881f, -0.06233429f, -0.15105261f, -0.18357427f, 
    0.05896995f, 0.11629817f, -0.09069569f, 0.10215302f, -0.24997351f, 0.01589134f, -0.15665880f, -0.07801949f, 
    0.11251866f, -0.11039495f, -0.04056604f, -0.12235393f, -0.13095734f, -0.01987536f, -0.05126663f, 0.05334333f, 
    -0.04391947f, -0.05660235f, 0.02637653f, -0.01525189f, 0.04600587f, 0.17305470f, 0.10343980f, 0.10363384f, 
    0.07100739f, 0.06916341f, 0.10297647f, 0.03825091f, 0.08077168f, 0.19793466f, -0.06133632f, 0.05876756f, 
    0.12352121f, 0.08852781f, 0.17029372f, 0.12417275f, 0.12522219f, 0.14960109f, 0.02692006f, 0.16618618f, 
    -0.21211901f, 0.03405657f, -0.05268137f, 0.18307474f, -0.09690227f, -0.23676744f, -0.25351131f, -0.17510918f, 
    0.02478491f, -0.13072118f, -0.08308150f, 0.05029201f, -0.11013270f, -0.07837848f, 0.26492986f, 0.14846490f, 
    0.09328445f, -0.01276288f, -0.13447380f, -0.03358778f, 0.02733656f, 0.11442904f, -0.00495304f, -0.01701137f, 
    -0.29412338f, -0.13410592f, -0.14621884f, -0.09793670f, 0.22438104f, 0.05900899f, -0.02304703f, -0.08951546f, 
    0.30333298f, 0.07576518f, 0.14073981f, 0.07294632f, -0.13707876f, 0.04714440f, 0.28577712f, 0.37364370f, 
    -0.08998790f, 0.18664373f, 0.00510466f, 0.16180918f, 0.12373429f, 0.10372475f, 0.12700027f, 0.18048444f, 
    -0.09315126f, -0.23481423f, 0.03566505f, 0.12104230f, -0.00477813f, 0.03328153f, 0.09577870f, 0.02991471f, 
    0.07545622f, -0.05193422f, 0.05579547f, 0.02751427f, -0.26180360f, -0.08662678f, -0.10249503f, -0.09217294f, 
    -0.07007178f, -0.25365192f, -0.08969888f, 0.01302968f, 0.05536732f, -0.06393469f, 0.15942141f, 0.06124808f, 
    0.05208911f, 0.31913921f, -0.05495238f, -0.14822467f, -0.05505923f, -0.06533542f, -0.01387472f, -0.14177422f, 
    -0.00403078f, 0.00004499f, -0.15425949f, -0.04195159f, 0.04740748f, 0.08494601f, 0.29059231f, 0.15887555f, 
    -0.08673656f, 0.00350791f, -0.02343385f, 0.00225964f, 0.16881251f, 0.02327692f, -0.03022454f, 0.08757528f, 
    0.09252877f, 0.13559596f, 0.11560254f, -0.02273904f, -0.01253143f, 0.09737234f, 0.01925080f, -0.03744335f, 
    0.03386962f, -0.09369513f, -0.14998472f, -0.07854502f, -0.02198986f, -0.12064131f, 0.02826714f, -0.03742854f, 
    0.18841207f, 0.19777909f, -0.09347130f, -0.01742756f, 0.10232735f, 0.11196183f, 0.17414606f, 0.08813275f, 
    0.04579873f, 0.12214542f, 0.09821945f, 0.11534513f, -0.04054226f, -0.07616065f, -0.35124794f, -0.06376296f, 
    -0.05596561f, -0.08070005f, -0.13557728f, -0.19512331f, -0.29833242f, 0.02647128f, 0.20752965f, 0.22769347f, 
    -0.12949447f, -0.06171900f, 0.02783963f, 0.10460217f, 0.03443732f, -0.00818963f, -0.00039604f, 0.00319476f, 
    -0.00688782f, 0.20345187f, 0.00128481f, -0.40900999f, 0.06998838f, 0.03177021f, 0.05760198f, -0.05004876f, 
    0.13589826f, 0.13586012f, 0.01065793f, -0.09159382f, 0.11063597f, 0.08681908f, -0.01167987f, -0.10999461f, 
    0.04072648f, 0.03059997f, 0.01993420f, 0.08920199f, 0.03468907f, 0.06931244f, 0.09055640f, -0.13996169f, 
    -0.27036372f, -0.34091067f, -0.22479112f, 0.12330386f, 0.05826951f, -0.05810004f, -0.13363765f, -0.07549669f, 
    -0.03945122f, -0.10466096f, 0.01866896f, 0.11062808f, 0.04186275f, -0.25631770f, 0.01298629f, -0.08797979f, 
    0.07608522f, -0.01493626f, 0.04353337f, -0.03882793f, -0.04605278f, -0.09791623f, -0.03496850f, 0.02939788f, 
    -0.04770058f, -0.28617901f, -0.62234676f, -0.17041160f, -0.10918963f, 0.18137191f, 0.19520302f, 0.24174914f, 
    0.01964137f, -0.01067456f, -0.11641120f, -0.11522980f, -0.14894314f, -0.18212534f, -0.05470028f, 0.19205977f, 
    0.16348243f, 0.20338352f, 0.03559854f, 0.02453165f, -0.10724887f, -0.09356738f, -0.05134170f, -0.12278864f, 
    0.07198656f, 0.07512997f, 0.01427218f, 0.06169532f, 0.02662901f, -0.01870271f, 0.13639745f, 0.08394489f, 
    0.05301765f, 0.14339234f, 0.02183602f, -0.15172860f, 0.03416084f, -0.22317760f, -0.16777770f, 0.30147189f, 
    0.08820614f, -0.18571651f, 0.36942598f, 0.01984554f, 0.09153304f, 0.04333726f, 0.06924160f, 0.02094149f, 
    0.35294774f, -0.19391637f, 0.02381507f, -0.24740423f, 0.00350939f, -0.01102475f, -0.02982435f, 0.26610282f, 
    -0.10646771f, -0.00919466f, -0.01175797f, 0.00705246f, 0.13511001f, 0.14697658f, -0.07028162f, -0.16669704f, 
    0.10652590f, 0.00499667f, 0.05762981f, 0.00589857f, 0.14119095f, -0.11873388f, -0.00202836f, 0.04663911f, 
    0.36410952f, -0.15111993f, 0.00878713f, -0.18531612f, -0.01229871f, 0.16632916f, 0.03531967f, 0.09479921f, 
    -0.12076624f, 0.00999707f, 0.04226613f, -0.00127754f, 0.00423935f, 0.03134358f, -0.09370557f, 0.04963109f, 
    -0.12575372f, -0.09965394f, 0.25623518f, 0.21993986f, 0.13263552f, 0.13693576f, 0.00950726f, 0.09466618f, 
    0.07765802f, 0.10495136f, 0.01138817f, -0.06043517f, -0.03413944f, 0.00475009f, -0.03345504f, -0.04478705f, 
    0.00664043f, 0.19918570f, 0.03507575f, -0.07302333f, 0.27540004f, -0.05929942f, 0.29886475f, -0.09883553f, 
    0.14495589f, -0.14859849f, -0.01714800f, 0.19582078f, 0.02407481f, -0.03797255f, -0.09687687f, 0.14023829f, 
    0.04723252f, -0.24070664f, -0.28589782f, 0.03082709f, -0.21379243f, 0.24519961f, -0.04350569f, -0.04239786f, 
    -0.08294677f, -0.04563772f, -0.00050011f, 0.18443066f, 0.07008179f, 0.08182481f, 0.20650874f, 0.19552216f, 
    0.05453342f, -0.09618627f, -0.05350613f, -0.00719368f, 0.13215594f, 0.03626966f, 0.01138372f, 0.01850206f, 
    0.05341674f, -0.11653100f, -0.07495886f, -0.19032755f, 0.02836631f, 0.05289868f, -0.02146943f, -0.03127523f, 
    0.13987467f, 0.07457294f, -0.02934116f, 0.10127692f, -0.35392067f, -0.09105222f, -0.00525405f, -0.05124349f, 
    0.00053321f, -0.09721234f, -0.03412028f, -0.02448454f, -0.04272806f, 0.05912236f, 0.08822974f, 0.07378392f, 
    0.44277653f, 0.29356694f, 0.31225768f, 0.21646379f, 0.00684777f, 0.10600168f, 0.13146996f, 0.21694736f, 
    -0.09867917f, -0.06989706f, -0.07880412f, 0.05790170f, 0.23307872f, 0.37549862f, 0.30995056f, 0.06664897f, 
    0.03479724f, 0.00985945f, 0.05614671f, 0.02326712f, -0.05685005f, -0.03260866f, 0.06616437f, -0.11949975f, 
    0.30811393f, 0.04115347f, -0.11449928f, 0.01928032f, -0.06355852f, -0.11349267f, -0.07287285f, 0.02406465f, 
    -0.01658603f, -0.12091424f, -0.21049650f, -0.11628780f, 0.00837563f, 0.27275351f, -0.06429255f, -0.02188556f, 
    0.15207712f, 0.08583182f, -0.01187151f, 0.00414804f, -0.10990585f, -0.01219896f, -0.14877301f, -0.21952045f, 
    -0.02836860f, 0.10561223f, 0.03745569f, -0.04744187f, 0.10731880f, 0.05768874f, 0.17399967f, 0.16423579f, 
    0.04392790f, 0.18114272f, 0.21581945f, 0.19216923f, 0.18903209f, -0.01290445f, 0.22711387f, 0.24319229f, 
    0.06291091f, 0.00213056f, -0.01021182f, 0.10048059f, 0.04847618f, 0.07254075f, 0.12743679f, 0.01637110f, 
    -0.23885553f, -0.00626077f, -0.16038966f, -0.08311325f, -0.04255037f, -0.01717761f, 0.10358816f, 0.03704277f, 
    0.06598540f, 0.02314826f, -0.03778852f, 0.02555248f, -0.27866724f, -0.16829620f, 0.01711552f, -0.17417216f, 
    -0.09987213f, -0.00084394f, -0.04213414f, -0.03359038f, 0.05806179f, 0.09596645f, 0.21716143f, 0.14720766f, 
    -0.05583416f, 0.31533977f, 0.07342806f, -0.03630984f, -0.05570363f, 0.04551567f, 0.09472597f, -0.01388117f, 
    -0.01486938f, 0.03989941f, 0.03834930f, 0.05800738f, 0.10813502f, 0.15530589f, -0.02710410f, 0.06703911f, 
    0.05186845f, 0.08972653f, 0.06615202f, -0.03902551f, 0.14068025f, 0.11654480f, 0.13835584f, 0.05017467f, 
    -0.08732935f, 0.03706113f, -0.09396467f, -0.12824319f, 0.02841308f, -0.02954159f, 0.03605834f, -0.01613243f, 
    -0.12021337f, -0.21429016f, -0.06121534f, -0.28667551f, 0.00416389f, 0.15365791f, 0.19828534f, 0.25843450f, 
    0.14045136f, 0.18772262f, -0.00341816f, -0.11777220f, 0.00856672f, 0.02808386f, 0.06952263f, 0.12364756f, 
    0.13605376f, 0.20012026f, 0.32365128f, -0.05643347f, -0.00974095f, 0.19349241f, -0.10450961f, 0.00522343f, 
    -0.07262606f, -0.00126585f, -0.05775269f, -0.13961463f, -0.07272344f, -0.18508230f, -0.14034322f, -0.12818536f, 
    -0.15728687f, -0.00878162f, 0.00786519f, -0.03925486f, -0.02192594f, 0.05897524f, -0.03141173f, 0.20001851f, 
    0.14365189f, 0.01666245f, 0.07914019f, -0.17581956f, 0.03100757f, -0.29413003f, -0.17795780f, -0.05727120f, 
    0.10131398f, -0.01737846f, 0.10086804f, 0.19243985f, -0.20443091f, -0.09603890f, -0.31267291f, -0.12301868f, 
    -0.00397260f, 0.01868050f, 0.01780854f, -0.22576118f, 0.08094981f, 0.04791081f, 0.11969811f, -0.01820274f, 
    0.05523620f, 0.12313792f, 0.04998114f, 0.08069576f, 0.03660071f, 0.01740528f, 0.15429349f, 0.17941940f, 
    -0.05586949f, -0.04107257f, 0.00519304f, -0.00509285f, -0.24706085f, -0.13400817f, -0.13200206f, -0.03734516f, 
    0.00003053f, 0.04337981f, -0.02157347f, 0.08305742f, -0.05754862f, 0.08194304f, 0.01423296f, -0.00579214f, 
    -0.15079692f, -0.10582137f, 0.07157228f, 0.22645856f, 0.06779368f, -0.05327790f, -0.06299634f, -0.07410306f, 
    0.08209550f, 0.01189914f, -0.05156658f, 0.00817206f, -0.06271476f, -0.12316310f, 0.01766395f, -0.08409382f, 
    -0.01747185f, -0.06128811f, -0.14326170f, -0.08120098f, 0.08888588f, -0.12558979f, 0.02975332f, 0.04603025f, 
    -0.10697802f, 0.15757510f, -0.14385889f, 0.04278696f, 0.14402209f, 0.13699989f, 0.03042163f, -0.04166644f, 
    0.16560203f, -0.07424640f, -0.03504420f, -0.12777978f, 0.16489801f, 0.13918757f, 0.22708939f, 0.02097003f, 
    -0.03475351f, -0.13495375f, 0.10556104f, 0.05075661f, -0.03153450f, 0.01381629f, -0.05488593f, -0.00231962f, 
    0.01797885f, 0.13500258f, 0.24754708f, -0.10323892f, -0.04788418f, 0.01964955f, -0.04857138f, -0.12689525f, 
    0.08425416f, -0.00143256f, -0.02638377f, 0.01079081f, -0.08068670f, -0.21056786f, -0.13170293f, -0.00831632f, 
    0.01083000f, -0.06300623f, -0.09962735f, -0.09260783f, 0.07372969f, 0.00669868f, 0.16754498f, -0.08636810f, 
    -0.08022254f, -0.22605214f, 0.06211657f, 0.19762196f, -0.06290688f, 0.09288810f, -0.16841348f, -0.17812122f, 
    -0.03754028f, -0.05935802f, -0.03988265f, 0.06233588f, 0.41698402f, 0.04734577f, 0.18936384f, 0.20035313f, 
    0.23672479f, -0.19165391f, 0.02763570f, 0.00099587f, -0.06918206f, 0.06932454f, -0.00337860f, 0.00862346f, 
    0.09068857f, -0.04578431f, 0.15761730f, 0.14892167f, 0.00541262f, -0.06058181f, -0.07810304f, -0.04795263f, 
    0.01232291f, 0.22627346f, -0.02052904f, 0.09607545f, 0.07052629f, -0.40381169f, -0.01661535f, 0.01238364f, 
    0.03027620f, 0.15318589f, 0.08172323f, -0.09085119f, -0.02908982f, -0.06387275f, -0.13171399f, 0.02507907f, 
    -0.02279652f, 0.07080216f, -0.37703478f, -0.04283125f, 0.01285146f, -0.01059172f, 0.09200922f, -0.01461894f, 
    0.01939526f, 0.07988442f, -0.02226472f, -0.05359622f, -0.21632317f, -0.41942191f, 0.25753784f, 0.07996316f, 
    0.09949366f, -0.05407462f, 0.02508334f, -0.00215776f, -0.07866311f, -0.09371407f, -0.04267725f, 0.05179523f, 
    0.26748031f, 0.31869352f, 0.04988823f, 0.17471790f, -0.16845450f, -0.01474436f, -0.02791487f, -0.04805560f, 
    0.01318765f, -0.04439088f, 0.05175845f, -0.02525774f, 0.19649626f, 0.11052728f, 0.09314301f, -0.23430215f, 
    -0.04944903f, -0.05305646f, -0.12357691f, 0.00815107f, -0.11945407f, -0.05561394f, -0.10675525f, -0.19785073f, 
    -0.03296332f, -0.12995115f, -0.01303723f, 0.21525232f, 0.07429583f, -0.02191367f, 0.12379105f, 0.09834926f, 
    -0.01247862f, -0.07546794f, 0.15896367f, 0.06256390f, -0.17740351f, -0.04200660f, 0.01793464f, 0.16727479f, 
    0.01241089f, 0.08018926f, 0.03452967f, 0.02989160f, 0.06110860f, 0.00636603f, -0.07330157f, 0.01337299f, 
    0.09657969f, 0.08363886f, -0.14689523f, 0.08705777f, 0.00513386f, 0.02061138f, 0.01076057f, -0.09599915f, 
    0.09146348f, 0.18757132f, -0.19079523f, -0.09184754f, 0.07046346f, 0.08022814f, 0.03205867f, 0.14102137f, 
    0.09176084f, 0.07178487f, -0.00412967f, -0.08216050f, 0.12036058f, 0.00979008f, -0.09488171f, -0.08312507f, 
    -0.00006481f, -0.14665908f, 0.13903488f, 0.01740828f, -0.00438546f, -0.03991558f, -0.01980525f, 0.12002209f, 
    -0.19715813f, -0.02471978f, 0.13057257f, 0.10638172f, -0.03153982f, -0.11073168f, 0.10068268f, 0.07612780f, 
    0.11145095f, -0.03980002f, 0.07777079f, 0.13016117f, 0.04381503f, 0.09194252f, 0.17990398f, -0.01742933f, 
    -0.19959046f, -0.17308027f, -0.19205999f, -0.07619862f, -0.00919157f, 0.06675937f, 0.11877612f, -0.04632391f, 
    0.01895709f, 0.07055686f, 0.02502849f, 0.01191726f, 0.01873008f, 0.04900207f, -0.03368778f, -0.00342787f, 
    -0.06217011f, -0.00370976f, -0.04528380f, -0.01143381f, 0.10581182f, -0.14880446f, 0.09135836f, 0.10908286f, 
    -0.20169921f, 0.22965358f, -0.24775340f, -0.04339667f, 0.07770356f, -0.01692842f, 0.06433108f, 0.11621896f, 
    0.12860210f, 0.10391521f, 0.06098764f, 0.13387099f, 0.06095002f, -0.04537500f, 0.02822510f, 0.20930605f, 
    -0.06429779f, 0.00546268f, 0.14065285f, -0.04216277f, 0.06725543f, 0.08256127f, 0.05064641f, 0.02669727f, 
    -0.01403958f, 0.23687826f, -0.14363621f, 0.04461768f, 0.02067224f, 0.04596986f, -0.14601600f, -0.16825213f, 
    -0.17141232f, -0.04012155f, -0.25348386f, -0.15009758f, -0.11206964f, -0.09035287f, -0.12284787f, 0.20092946f, 
    0.21982361f, 0.07803825f, 0.10532374f, -0.15936494f, 0.05414315f, -0.08180752f, 0.06319879f, 0.04989978f, 
    -0.33303541f, 0.13399951f, -0.13465385f, -0.12231193f, -0.04693739f, 0.04286698f, 0.03043454f, -0.05539304f, 
    -0.15017870f, 0.01550219f, -0.13101520f, -0.00547320f, -0.04932050f, 0.09139591f, -0.21244937f, 0.17747827f, 
    -0.18517192f, -0.16454430f, -0.06488496f, -0.13098742f, 0.09039524f, -0.10477861f, -0.04442151f, -0.02289603f, 
    0.07811915f, 0.42455953f, -0.08623741f, 0.03206420f, -0.26902291f, -0.13543218f, -0.03869468f, -0.11575116f, 
    0.05771470f, 0.11464114f, 0.13370097f, -0.12046146f, 0.20739806f, -0.07012625f, 0.26629439f, 0.08459058f, 
    -0.11792844f, -0.12665837f, -0.20704769f, 0.14514741f, 0.10555657f, -0.12897794f, -0.08445924f, -0.04069647f, 
    -0.09062951f, -0.10657770f, -0.12201165f, -0.00015266f, 0.20363230f, 0.21797447f, -0.05938405f, -0.20112942f, 
    -0.01142353f, -0.05446771f, -0.09034868f, -0.01844532f, 0.15663351f, 0.04051589f, -0.16979730f, 0.08260451f, 
    0.20365521f, 0.12267144f, 0.06401642f, 0.05882293f, 0.04413810f, -0.04980725f, 0.00291640f, 0.02230721f, 
    -0.12087978f, 0.05169032f, -0.08434539f, -0.04246998f, 0.02951651f, -0.02513232f, 0.06628776f, 0.09867030f, 
    -0.11229593f, 0.08761486f, 0.06248709f, 0.06621877f, 0.09401749f, -0.07646579f, 0.28400519f, 0.16854089f, 
    0.13074540f, 0.03593943f, -0.06256611f, -0.09145352f, -0.05390537f, 0.19209351f, 0.05513483f, 0.07458955f, 
    -0.10077286f, -0.15520298f, -0.14999244f, 0.00155017f, 0.10905210f, -0.02753438f, 0.14648132f, 0.08093317f, 
    0.02947660f, -0.07684571f, -0.20807979f, -0.04577719f, -0.10419612f, -0.01129615f, -0.12932305f, 0.33141562f, 
    -0.07754756f, 0.29212064f, -0.16612625f, -0.10802898f, -0.10643978f, 0.05462866f, -0.16221853f, -0.03269166f, 
    0.54532683f, -0.09829232f, 0.06191358f, 0.28087017f, -0.06346428f, -0.02620408f, 0.05935114f, 0.04046782f, 
    -0.00032094f, -0.00248514f, -0.01923138f, 0.08353770f, 0.06162418f, -0.00810391f, 0.06483287f, 0.00159929f, 
    -0.21639188f, -0.14562891f, 0.10927420f, -0.16096394f, -0.13358122f, -0.03450265f, -0.10806523f, 0.10464863f, 
    0.21744825f, 0.32817900f, 0.04658138f, -0.22158994f, 0.06345678f, 0.08782225f, 0.08094787f, -0.03072632f, 
    0.03059003f, 0.07722528f, 0.03013127f, 0.01379284f, -0.10399673f, 0.09886494f, -0.13508621f, 0.05104325f, 
    -0.16423681f, 0.02242415f, 0.16976000f, -0.09948150f, 0.02823486f, -0.14142154f, -0.08627199f, -0.12958790f, 
    0.22051947f, 0.14286044f, -0.02685529f, -0.00309502f, -0.14784595f, -0.13312379f, 0.01745834f, 0.02754016f, 
    0.16291557f, 0.05194091f, 0.09869646f, 0.13500290f, -0.06543388f, 0.26779330f, -0.07304189f, -0.19934683f, 
    0.09670106f, 0.11406859f, -0.02323563f, 0.27729821f, -0.08872808f, -0.05279760f, 0.21114531f, -0.10029347f, 
    -0.26156303f, -0.20829898f, 0.30620542f, 0.02320504f, -0.27789584f, 0.04382055f, 0.00672047f, -0.04219023f, 
    0.06262476f, -0.08094981f, -0.01528426f, 0.06001030f, -0.03055211f, 0.39487025f, -0.01518650f, 0.31452993f, 
    -0.14576177f, -0.10310289f, -0.10568008f, -0.20188871f, -0.30302328f, -0.11139131f, 0.05341763f, -0.13279399f, 
    0.24636449f, -0.07584543f, -0.00835477f, -0.05927968f, -0.08599331f, 0.09390926f, 0.05978503f, 0.10622333f, 
    -0.00320486f, 0.03231462f, 0.08081103f, 0.08152142f, -0.18577589f, -0.09709655f, 0.13021670f, -0.04067996f, 
    -0.02474537f, -0.04224356f, -0.01655502f, 0.07653889f, 0.04378688f, 0.08792535f, -0.01748314f, 0.10336778f, 
    0.27323163f, 0.05515388f, 0.08414156f, -0.03982601f, 0.01716697f, 0.15163209f, 0.26992348f, 0.22428706f, 
    0.12945522f, 0.02096361f, 0.00609771f, 0.05081109f, 0.29944628f, 0.13807757f, -0.08554170f, 0.07967614f, 
    0.07585444f, 0.06274829f, 0.04660428f, 0.11159965f, 0.08924617f, 0.09073785f, -0.01911352f, 0.14064056f, 
    0.10657488f, 0.15704504f, -0.04369801f, -0.03515971f, 0.08200144f, 0.00083525f, 0.06508201f, -0.09661963f, 
    0.02953858f, -0.01597490f, -0.14262527f, 0.04498428f, 0.27990690f, 0.15381752f, -0.00365570f, 0.15781142f, 
    0.09327583f, 0.08084960f, 0.05625571f, -0.09483065f, -0.11495229f, -0.08253575f, -0.06347557f, -0.06129127f, 
    -0.12539420f, -0.18372056f, 0.02594219f, 0.12880282f, 0.00436915f, 0.13634591f, -0.05229031f, -0.07295932f, 
    -0.14418021f, 0.03204720f, 0.10620531f, 0.17305079f, 0.07473730f, -0.01646864f, 0.00602644f, 0.09773080f, 
    0.00397011f, 0.20822035f, -0.17520988f, -0.05354246f, -0.03908983f, -0.04087493f, 0.08622777f, -0.04042179f, 
    -0.10500129f, 0.07217821f, -0.29440519f, 0.20790592f, 0.07991632f, 0.15908031f, 0.30422029f, 0.05587327f, 
    -0.14233027f, -0.15185350f, -0.08494233f, -0.10406841f, -0.08498308f, 0.01976576f, -0.08059365f, 0.02649758f, 
    -0.14108288f, -0.04894295f, -0.00312700f, 0.04074187f, 0.03162683f, 0.01076814f, 0.04574873f, 0.11929193f, 
    0.05877868f, 0.44587079f, -0.08386809f, -0.24585052f, -0.04956474f, -0.17185372f, 0.08946915f, -0.03368355f, 
    0.26269189f, -0.01848923f, -0.00579721f, 0.05298714f, -0.00125810f, -0.06595919f, -0.12159599f, 0.19099161f, 
    -0.07566877f, 0.05231016f, 0.04110052f, 0.00002256f, -0.02136928f, 0.01663953f, 0.06204290f, -0.07259852f, 
    -0.11686691f, 0.05126461f, -0.15012164f, -0.20021701f, -0.03888942f, 0.08807456f, 0.03219131f, 0.05169757f, 
    -0.15741569f, -0.17560621f, -0.12350789f, -0.01351183f, 0.14063519f, 0.39532772f, -0.38258183f, 0.24749352f, 
    -0.00274247f, 0.03668341f, -0.19278459f, -0.18079607f, 0.04666116f, 0.04925361f, 0.16489105f, 0.00882806f, 
    -0.23133752f, 0.21549673f, 0.50250965f, -0.23170386f, 0.08515104f, -0.10302624f, -0.09001855f, -0.03288978f, 
    0.11412527f, -0.00467015f, -0.00610582f, 0.00058456f, 0.10542292f, 0.23175710f, -0.00111406f, 0.15385059f, 
    -0.07718221f, -0.03205729f, -0.07264121f, 0.04343548f, 0.06489483f, -0.01126964f, 0.03997522f, 0.08790377f, 
    -0.03248929f, -0.05513312f, -0.05146774f, -0.01213629f, -0.05380574f, 0.00893576f, -0.02436343f, -0.04896542f, 
    -0.01136184f, -0.06365145f, 0.06313927f, -0.01061317f, 0.05103587f, 0.05575554f, -0.01630694f, 0.01474746f, 
    0.04572553f, 0.03446732f, 0.04692592f, -0.05888181f, -0.01334678f, -0.03709886f, 0.01571575f, -0.05039832f, 
    0.01318740f, 0.03834572f, 0.00728536f, -0.06990186f, 0.01904644f, -0.06155871f, -0.05188747f, 0.05365504f, 
    -0.02031441f, -0.03971338f, 0.03539839f, 0.02202100f, 0.03264587f, -0.06686953f, -0.06669223f, -0.03989977f, 
    -0.01566848f, 0.05498348f, -0.07013210f, 0.05639037f, 0.04562727f, -0.01841115f, 0.04408066f, 0.01908235f, 
    0.00674140f, -0.03374074f, -0.00065576f, -0.05305859f, 0.03239841f, 0.05221280f, -0.06151756f, -0.07127184f, 
    0.06334806f, 0.03190310f, -0.01257056f, -0.03573184f, 0.03771356f, 0.04362464f, -0.02468209f, 0.04886789f, 
    -0.04536045f, -0.01541320f, 0.01434138f, -0.04895386f, -0.06190701f, -0.00895955f, 0.01289691f, 0.04299740f, 
    -0.04919587f, -0.06027655f, 0.05874806f, 0.05466968f, 0.05222264f, -0.00910794f, -0.00169439f, 0.02818945f, 
    0.02402801f, -0.05840722f, 0.06118357f, 0.04019754f, -0.01632892f, -0.04205140f, -0.02837115f, -0.07137194f, 
    0.06432329f, -0.07448404f, 0.01295931f, -0.00159364f, 0.02870265f, 0.05542719f, -0.04372983f, -0.07692131f, 
    0.05351488f, 0.04179811f, 0.04671032f, -0.05464400f, -0.01717986f, 0.00658986f, -0.05667319f, -0.00787454f, 
    -0.06167004f, 0.06405283f, 0.03970199f, -0.07883409f, -0.06076600f, 0.05782996f, -0.06639614f, -0.04584610f, 
    -0.05254501f, -0.02943909f, 0.01017567f, 0.03559437f, 0.06666046f, -0.04117718f, -0.05388407f, -0.04201588f, 
    -0.00857068f, 0.03987564f, -0.06550304f, -0.03933853f, -0.01826673f, -0.06546013f, -0.03350515f, -0.04944812f, 
    0.05199008f, -0.01121097f, -0.00561914f, -0.00776951f, -0.06495517f, 0.01365588f, 0.02485429f, -0.02898535f, 
    -0.01395594f, -0.02120830f, 0.02064933f, 0.02703531f, -0.01265716f, -0.05644967f, -0.05867268f, -0.05975818f, 
    -0.06005002f, -0.00504449f, 0.04946586f, -0.07857848f, 0.02862308f, -0.05796122f, 0.00713427f, 0.01780218f, 
    0.02073630f, -0.02815141f, -0.04719272f, 0.03686904f, 0.05255124f, -0.01020921f, 0.00446720f, -0.04398790f, 
    0.04783131f, -0.04700675f, 0.03583615f, 0.00954819f, -0.02856591f, 0.02294408f, -0.00422414f, -0.05282011f, 
    -0.05075347f, -0.06170743f, -0.05771233f, 0.01757316f, 0.06447776f, -0.07285264f, -0.03747120f, 0.03226953f, 
    -0.02413826f, -0.06790861f, -0.00459910f, -0.06970325f, -0.05934526f, -0.03620134f, -0.03134409f, -0.00990654f, 
    -0.05645300f, -0.07027523f, 0.00898043f, -0.05875083f, 0.02212573f, -0.02027267f, -0.00864969f, 0.01755721f, 
    0.06828615f, -0.10126817f, 0.05052038f, 0.30219600f, 0.01505233f, -0.07685807f, 0.09209491f, 0.03828342f, 
    0.04201338f, 0.04300034f, 0.07940754f, 0.15116444f, -0.26000977f, 0.02567550f, 0.01158913f, 0.05665002f, 
    0.05778393f, -0.02078603f, 0.11308610f, -0.01923440f, 0.08303174f, 0.03147246f, -0.01318818f, 0.07355751f, 
    -0.04268172f, 0.19703972f, 0.05688080f, -0.24454276f, -0.15149707f, -0.16414334f, 0.17278017f, 0.05576471f, 
    -0.11702325f, 0.08115640f, 0.06536604f, -0.10906775f, 0.13606392f, -0.07917160f, 0.04091871f, -0.15844691f, 
    -0.02792884f, -0.02125988f, -0.09023201f, 0.02879580f, 0.08907097f, -0.05128855f, -0.09843460f, -0.08602276f, 
    0.01780616f, 0.20767105f, 0.27833876f, 0.02773957f, 0.03826722f, -0.08771699f, 0.03553278f, -0.07876931f, 
    0.02490216f, 0.05334849f, -0.02731057f, -0.05057757f, 0.15576671f, 0.17413177f, -0.01347040f, -0.10430779f, 
    -0.16742308f, 0.04605616f, -0.05765654f, 0.05644083f, 0.15815236f, 0.00990170f, -0.04790761f, -0.00869326f, 
    0.03577913f, -0.21736082f, -0.13259941f, 0.14025600f, -0.12490393f, 0.02429336f, 0.08031972f, -0.08514348f, 
    0.03268463f, -0.07137499f, -0.04620435f, 0.10760803f, 0.10211289f, 0.23058699f, -0.00134206f, -0.45673797f, 
    0.01289287f, 0.03849572f, -0.03570729f, 0.01016107f, -0.10371523f, -0.03748149f, -0.03054423f, -0.09941690f, 
    0.10139865f, 0.22513790f, 0.17365405f, 0.14304465f, -0.00944915f, 0.14531365f, -0.08362668f, 0.04806533f, 
    -0.02822065f, -0.00505680f, 0.08465454f, 0.05786268f, -0.02840431f, -0.02584605f, 0.00995686f, 0.19245592f, 
    -0.04981076f, 0.16061142f, 0.00830701f, 0.07909357f, 0.11560788f, 0.08092650f, 0.04373745f, 0.05144711f, 
    0.13781397f, -0.35650340f, 0.11289979f, 0.08075833f, -0.05553347f, -0.00233602f, -0.17061046f, 0.08132423f, 
    0.19354106f, -0.00065983f, 0.09476347f, 0.04397101f, 0.12405335f, 0.01450077f, 0.18376535f, -0.11992157f, 
    -0.06009426f, 0.02190657f, 0.03800637f, -0.03107500f, -0.34353119f, -0.05292607f, -0.12842965f, 0.02595091f, 
    -0.07007147f, -0.16788100f, 0.11506648f, 0.12682466f, 0.09885447f, 0.01630820f, -0.03878988f, -0.00410987f, 
    0.09562109f, 0.14480229f, -0.04012876f, 0.03259315f, 0.19346808f, -0.03328687f, -0.22607411f, 0.14097479f, 
    -0.07641427f, 0.09664480f, 0.19560052f, 0.06293871f, 0.10979656f, 0.04362332f, 0.06131199f, -0.00025036f, 
    -0.39445969f, 0.13892561f, -0.10453171f, -0.34107909f, 0.34619388f, -0.10743944f, 0.04901644f, 0.00117267f, 
    0.01290767f, -0.22666623f, 0.00513921f, -0.11278804f, 0.07487207f, -0.51098561f, -0.16745047f, -0.17332159f, 
    0.00858837f, 0.07142150f, 0.11089753f, 0.06160238f, -0.06360386f, 0.05876740f, 0.01904193f, 0.04921080f, 
    -0.22085467f, 0.01498165f, 0.05875513f, -0.19759649f, 0.03477291f, 0.02130994f, 0.07585926f, -0.01107026f, 
    0.16127998f, 0.09316536f, -0.05827005f, 0.10850514f, 0.06705107f, 0.05793678f, 0.11212659f, -0.18413588f, 
    -0.04041831f, 0.06423728f, 0.07118362f, 0.05383414f, -0.07269327f, 0.07881018f, 0.03181557f, 0.00338062f, 
    0.03102502f, -0.13834870f, 0.00130505f, -0.03437037f, 0.20042235f, 0.18835296f, -0.03785357f, 0.03190850f, 
    -0.01680285f, 0.03689629f, -0.03875432f, 0.00324305f, -0.00739661f, 0.00964070f, -0.10512044f, -0.04280106f, 
    0.07958754f, 0.05385460f, 0.01456096f, 0.07125220f, -0.00454287f, -0.05539767f, 0.02742477f, 0.12850010f, 
    0.04425659f, -0.20756853f, -0.37752685f, -0.31960058f, -0.07747274f, 0.06429143f, 0.05480248f, 0.18335010f, 
    -0.15047915f, -0.05602066f, 0.18715644f, -0.16176397f, 0.03167859f, 0.01286453f, -0.38326976f, 0.01491505f, 
    0.17604128f, 0.13408439f, 0.12531981f, 0.17689897f, -0.08486804f, -0.06079686f, -0.23541290f, 0.00006591f, 
    -0.11863727f, -0.02955117f, 0.14295308f, -0.13541654f, -0.00023654f, 0.01907093f, 0.13392332f, 0.04097023f, 
    -0.02708294f, 0.14468916f, 0.01029169f, 0.10195950f, -0.30599147f, -0.16546211f, -0.13496406f, 0.25107580f, 
    0.02810669f, 0.04198723f, 0.17286064f, 0.12062990f, 0.03724097f, -0.10314061f, 0.01697858f, 0.06522528f, 
    0.04136568f, -0.09726215f, -0.34973237f, -0.04919218f, 0.08447241f, 0.01348443f, 0.16253059f, 0.08373608f, 
    0.06572665f, -0.04753266f, -0.20649397f, -0.14094120f, -0.03724993f, 0.16476534f, 0.04148035f, -0.25283512f, 
    0.04066103f, 0.03268105f, -0.00119397f, 0.00556853f, 0.07400342f, 0.05414424f, 0.03251287f, 0.11631524f, 
    0.06656465f, 0.25060222f, -0.13634008f, -0.20884866f, 0.17812559f, 0.12310717f, 0.21093799f, -0.07300934f, 
    -0.02990875f, 0.04264323f, 0.18489610f, 0.12187761f, -0.21564388f, -0.18844579f, -0.16293521f, 0.03723003f, 
    -0.20267598f, 0.17385896f, 0.07098030f, -0.06518739f, 0.25614926f, 0.11029419f, 0.22375891f, 0.03593876f, 
    0.08986836f, 0.14016235f, -0.18964016f, -0.23457222f, -0.14040558f, -0.02872398f, -0.03781712f, -0.02594748f, 
    0.15077919f, -0.00883107f, 0.10121261f, -0.20859207f, 0.11876336f, 0.17863059f, 0.23979729f, 0.05195282f, 
    0.06474508f, -0.05710919f, -0.09678349f, -0.09081182f, -0.08040776f, -0.06102608f, -0.07019079f, -0.00653489f, 
    0.53642076f, -0.11689015f, 0.03119221f, -0.05181427f, 0.04560985f, 0.13826430f, 0.21892218f, 0.14399791f, 
    -0.07618900f, 0.03376558f, 0.05640746f, -0.14959793f, 0.09435841f, 0.09556827f, 0.09341042f, -0.17946599f, 
    -0.05435247f, -0.03964166f, -0.02675646f, -0.06432667f, -0.13024779f, -0.04139246f, 0.01312672f, 0.06986903f, 
    -0.40763190f, -0.19421832f, 0.21131337f, -0.07596596f, 0.01392538f, 0.12244090f, -0.10115401f, 0.11179084f, 
    -0.04742660f, 0.01080228f, -0.04245197f, 0.06231917f, 0.03887944f, -0.03195235f, 0.07795593f, 0.10359213f, 
    0.06931330f, 0.00358606f, 0.08561451f, 0.01716167f, -0.01062069f, -0.09789559f, 0.01433871f, 0.05854684f, 
    0.15466982f, 0.21596092f, 0.21863480f, 0.11476494f, 0.01591670f, 0.04293578f, -0.28053185f, -0.04493808f, 
    0.10212020f, -0.10574761f, -0.11192632f, 0.04873277f, 0.03859334f, 0.02590258f, 0.03370649f, 0.02835025f, 
    -0.05066273f, 0.12744008f, 0.01250264f, -0.15617312f, -0.00530904f, -0.03969067f, 0.08862906f, 0.05207081f, 
    -0.17073984f, -0.14161266f, 0.01253952f, -0.04055011f, -0.03403519f, 0.10248143f, -0.05275201f, 0.05373480f, 
    -0.12367606f, -0.00739694f, 0.23379016f, 0.19921452f, -0.11957956f, -0.04101830f, 0.01724983f, 0.08263726f, 
    0.00351066f, -0.11845515f, 0.32246864f, 0.13555042f, -0.17006673f, 0.01960569f, 0.09151870f, 0.21769825f, 
    0.21145900f, 0.03197217f, -0.04421083f, -0.03331896f, 0.32870886f, 0.19467475f, -0.21054246f, 0.01066849f, 
    0.07068326f, -0.01348902f, -0.02071430f, -0.17369507f, -0.01830283f, -0.00248549f, 0.08112397f, 0.24820651f, 
    0.00421332f, -0.10483301f, 0.04944054f, -0.01122836f, -0.06723366f, 0.02327592f, -0.04540614f, -0.01224389f, 
    -0.48419702f, 0.11152290f, -0.08343053f, 0.23207682f, -0.02425037f, 0.06648903f, -0.03893651f, 0.03645074f, 
    0.24016763f, 0.11451317f, -0.04679492f, 0.08523924f, -0.06008148f, 0.06917276f, -0.01686616f, 0.14366892f, 
    0.08146799f, 0.01010769f, -0.05505074f, -0.03208604f, 0.02324892f, 0.06132846f, -0.04431143f, -0.01672320f, 
    -0.12854810f, -0.09715063f, 0.06775056f, 0.33439708f, 0.01871457f, -0.00829397f, -0.00501963f, -0.11640000f, 
    -0.10817660f, 0.02721157f, -0.12409846f, 0.07479866f, -0.23980372f, -0.15464121f, -0.14302556f, 0.00493104f, 
    -0.00291724f, 0.07910867f, -0.33640075f, -0.00616612f, -0.03285421f, -0.13333738f, 0.13341813f, -0.06886438f, 
    -0.01430143f, 0.10605708f, 0.07881881f, -0.10905404f, -0.06706879f, 0.04267190f, -0.01957108f, 0.07549415f, 
    0.23261084f, 0.01917473f, 0.18913934f, 0.20727485f, -0.00643124f, -0.12104598f, 0.26294494f, -0.01106004f, 
    -0.11022147f, -0.11100963f, 0.04064364f, 0.09946788f, -0.14874044f, 0.00407389f, 0.00619764f, -0.10568163f, 
    0.33233535f, -0.01164200f, 0.06626547f, 0.32848433f, -0.14988308f, -0.05363268f, 0.00582371f, -0.05919538f, 
    0.09913820f, 0.03484719f, 0.14805911f, 0.08345726f, 0.03140440f, 0.26108512f, 0.22787774f, -0.05312182f, 
    0.13795491f, 0.05319851f, 0.01318164f, 0.14289726f, 0.02088258f, -0.08899295f, -0.02732227f, 0.00367488f, 
    -0.00411614f, 0.03341785f, -0.05880230f, -0.03662816f, 0.00599420f, 0.01787276f, -0.01891946f, -0.07057072f, 
    -0.04263759f, -0.00980542f, -0.04199845f, -0.05355934f, 0.02744309f, -0.00065162f, 0.03990567f, -0.02779934f, 
    -0.00986602f, -0.00337308f, -0.07295911f, 0.06475941f, -0.03079220f, -0.02578352f, -0.03932697f, -0.04263544f, 
    0.00910812f, 0.01211562f, -0.01003524f, 0.02166317f, -0.02591633f, -0.00807387f, -0.04086863f, 0.05411011f, 
    -0.07126331f, 0.04186946f, 0.06394863f, -0.04419728f, 0.04424647f, -0.02468302f, -0.07133909f, -0.06327951f, 
    0.03990436f, 0.00330975f, -0.02147064f, -0.00988260f, -0.02147632f, 0.05718338f, -0.01879204f, 0.03121420f, 
    0.02907083f, -0.06131408f, 0.00218899f, 0.04142749f, -0.06850027f, 0.00719846f, 0.01024255f, 0.00527353f, 
    0.04678395f, -0.01421682f, -0.06587146f, -0.02096920f, -0.00951629f, -0.06743715f, -0.07078447f, -0.01647009f, 
    0.06029734f, 0.06505047f, -0.01734986f, -0.06096593f, -0.05910441f, -0.03947166f, 0.02216799f, -0.05741522f, 
    -0.00902032f, -0.04553902f, 0.05151647f, -0.02181098f, 0.03613500f, -0.05507658f, 0.00953643f, -0.05237879f, 
    -0.03940655f, -0.01711390f, 0.04917173f, 0.05762215f, -0.02291338f, 0.06038843f, 0.04651561f, 0.02788657f, 
    0.00585601f, -0.01809654f, 0.00287745f, 0.00671976f, 0.02105783f, -0.00804447f, -0.05430447f, -0.01084246f, 
    0.00423803f, -0.06616959f, -0.06142988f, 0.00705733f, 0.03339582f, -0.01868530f, -0.03066177f, -0.00346967f, 
    -0.06833757f, -0.00433111f, -0.01067746f, -0.05345150f, -0.05551378f, 0.06031502f, -0.06659060f, 0.03534956f, 
    0.00595478f, 0.03889716f, -0.00207582f, 0.05654345f, -0.04810551f, -0.02472271f, 0.04780369f, 0.00638388f, 
    0.03412040f, -0.01762535f, 0.06648964f, 0.01015791f, -0.03213366f, -0.01875461f, -0.01211986f, 0.05440971f, 
    -0.05780396f, 0.03061386f, -0.03206754f, 0.00557138f, 0.02196091f, 0.01138977f, 0.02090969f, -0.00669752f, 
    -0.02948137f, -0.04120245f, 0.03172427f, -0.06891944f, 0.01734412f, 0.06581150f, -0.06682857f, -0.01669171f, 
    0.02646985f, -0.01485612f, 0.03693556f, -0.04952084f, -0.05123586f, 0.02319877f, -0.06564905f, 0.06662096f, 
    0.06100946f, 0.01556438f, -0.06567653f, 0.05942757f, -0.07224714f, -0.04198371f, -0.06907761f, 0.01206005f, 
    0.03840809f, -0.07241685f, 0.00951093f, 0.00751171f, 0.05104363f, -0.06337092f, -0.00010422f, -0.05927937f, 
    -0.05784158f, 0.04378547f, -0.05170619f, -0.04314541f, -0.04127424f, 0.02826857f, 0.00680095f, -0.05343866f, 
    -0.05907844f, -0.04699457f, 0.01388932f, 0.02440526f, 0.03791891f, -0.05855192f, -0.03189648f, 0.06746982f, 
    0.03635047f, -0.07142481f, -0.03539131f, 0.03152888f, -0.05866381f, -0.06607661f, -0.02814258f, -0.04106027f, 
    0.02237330f, -0.24384697f, -0.01495241f, 0.01008387f, -0.02258798f, 0.08385464f, -0.10095412f, 0.08630675f, 
    0.00461587f, -0.00348482f, 0.08217447f, 0.17209019f, 0.08070844f, -0.00039174f, -0.01754430f, -0.05316383f, 
    0.00680835f, 0.02551403f, -0.05973724f, 0.04147396f, -0.14822976f, 0.01190104f, 0.16036142f, 0.07094423f, 
    -0.17568436f, -0.25526476f, 0.04984016f, 0.05296537f, -0.07336234f, -0.14252612f, -0.01761268f, -0.10473374f, 
    0.08976229f, -0.08334014f, 0.05519592f, 0.01627305f, -0.24958189f, -0.06186174f, 0.16212821f, 0.12877968f, 
    -0.14110449f, 0.00439359f, 0.05640234f, -0.06120921f, 0.11336885f, 0.08658101f, 0.12898426f, 0.05844393f, 
    -0.14305513f, -0.05022663f, 0.04498652f, 0.01580344f, 0.02329165f, -0.05652787f, -0.12391049f, 0.00902242f, 
    0.06532282f, -0.05489403f, 0.18001449f, 0.02648933f, -0.12587680f, -0.06662545f, 0.06489152f, 0.16924918f, 
    -0.03156248f, -0.14550525f, 0.04530367f, 0.10737383f, 0.07566098f, 0.06983478f, 0.05547946f, -0.05002253f, 
    -0.01901003f, -0.12855388f, 0.05643119f, -0.14235826f, 0.19779181f, 0.06391633f, -0.16712202f, 0.04406093f, 
    -0.01296292f, -0.05154580f, 0.09729981f, -0.01140971f, -0.13340294f, 0.12064625f, 0.09132260f, 0.03158630f, 
    0.07083888f, -0.09065104f, 0.21256478f, 0.18607193f, -0.05591379f, 0.04999963f, 0.00211058f, 0.05655740f, 
    -0.39967841f, -0.16217110f, 0.00197215f, 0.05396289f, -0.10962011f, 0.00122227f, -0.04340699f, 0.19417201f, 
    0.18138219f, 0.07035355f, -0.08985381f, 0.03150669f, -0.04790311f, 0.02405194f, -0.08524223f, 0.01325607f, 
    -0.02783160f, -0.02081151f, -0.06789155f, 0.04577817f, -0.07935151f, -0.05649136f, 0.12474840f, 0.15135752f, 
    -0.30111074f, 0.04775001f, -0.04081423f, 0.25644615f, 0.25417894f, 0.08037839f, 0.10322898f, 0.19824962f, 
    0.04459831f, 0.09114388f, 0.22451907f, 0.09291925f, -0.28373730f, 0.10452381f, 0.18915544f, 0.09875377f, 
    -0.08399185f, -0.01724247f, -0.02505186f, -0.01663402f, 0.02908431f, 0.11757090f, 0.04231337f, 0.00769386f, 
    -0.14525382f, 0.12647165f, 0.03693328f, 0.06725556f, -0.06394994f, -0.07660380f, 0.01211282f, 0.08360110f, 
    0.12431151f, 0.03839670f, 0.07548053f, -0.01953169f, -0.15289804f, -0.20609932f, 0.13767959f, 0.13677320f, 
    0.07472661f, -0.08487409f, 0.12401047f, 0.09467234f, -0.11237086f, 0.00827449f, 0.00988054f, -0.09832925f, 
    0.24889341f, 0.01072291f, -0.23908594f, 0.21587373f, 0.09579764f, 0.12911661f, 0.05691925f, 0.12399556f, 
    -0.03360096f, 0.01025151f, -0.00433946f, -0.09249981f, 0.13445872f, 0.30655897f, 0.05023208f, -0.10052324f, 
    0.02436572f, -0.04019602f, -0.08603324f, 0.02955784f, -0.05424465f, -0.07448474f, -0.00385169f, -0.02351788f, 
    -0.46462229f, -0.30637226f, 0.12127843f, 0.22124636f, -0.00303375f, 0.00806129f, 0.02681257f, 0.02215481f, 
    0.09642629f, 0.15854371f, 0.06928974f, 0.18395872f, 0.08771835f, -0.07880405f, -0.09844489f, 0.10259212f, 
    -0.04102404f, -0.01618035f, 0.00101671f, -0.03506923f, 0.01313408f, 0.07165419f, 0.08411615f, 0.24942046f, 
    -0.11687420f, 0.04854262f, 0.12886490f, -0.16682331f, 0.07273111f, 0.00878840f, -0.08076927f, -0.06719200f, 
    -0.04226221f, -0.04888511f, -0.06127589f, -0.11131120f, -0.04325181f, -0.04618293f, 0.23541676f, -0.19667420f, 
    -0.06630027f, 0.04819252f, 0.00696548f, -0.13253595f, -0.05404032f, 0.03671116f, 0.05413384f, -0.05237049f, 
    -0.19775479f, -0.14034085f, 0.31220621f, -0.02248175f, 0.00352064f, -0.02941941f, 0.06929575f, 0.15228274f, 
    -0.06416325f, -0.03116225f, 0.18940881f, 0.00709783f, -0.23666193f, -0.16592109f, 0.04261647f, -0.22523545f, 
    -0.12386328f, -0.09124152f, 0.12698291f, 0.33056691f, 0.11109034f, 0.08305866f, 0.07567298f, 0.14925447f, 
    0.04561460f, 0.06254116f, -0.05605777f, -0.21525368f, 0.33826378f, 0.11857439f, 0.01337054f, 0.07105684f, 
    0.14415379f, 0.02870837f, -0.10726970f, -0.11174510f, -0.14874732f, 0.14019176f, 0.13714236f, -0.20600417f, 
    -0.01974675f, -0.01797261f, 0.02921933f, 0.02458626f, 0.07278332f, -0.03199398f, 0.00082598f, 0.01723554f, 
    -0.06148416f, 0.13015284f, 0.30694062f, -0.02475268f, -0.03391840f, -0.04918093f, -0.07233302f, 0.04903127f, 
    0.24137065f, 0.11457629f, 0.01882589f, 0.11164925f, 0.11045993f, 0.03948395f, 0.03977703f, 0.15155220f, 
    0.11657836f, 0.04467124f, -0.01207479f, 0.00754162f, 0.04203449f, 0.08253027f, 0.12414283f, 0.06883733f, 
    -0.17111510f, -0.50080180f, 0.16880876f, 0.38162071f, 0.08926354f, 0.07253295f, 0.01009433f, 0.16928077f, 
    -0.12342760f, 0.12294456f, 0.07964952f, 0.21968880f, -0.20528400f, 0.05774431f, 0.28272027f, -0.17513289f, 
    0.12049086f, -0.07025436f, -0.26830116f, -0.06207122f, 0.00136605f, -0.05910750f, 0.02201349f, 0.13088371f, 
    0.05257831f, -0.02286699f, 0.25479984f, 0.04063179f, -0.06183786f, -0.03799308f, 0.01478823f, -0.03482756f, 
    0.22480172f, 0.21643953f, 0.12770747f, 0.17430876f, -0.00285767f, -0.28215075f, 0.32959715f, -0.09031086f, 
    0.02011703f, 0.00847397f, 0.16426769f, 0.04251447f, -0.10542668f, 0.07205901f, -0.04376523f, 0.04201661f, 
    0.21290407f, -0.26259792f, -0.35738119f, 0.29668877f, 0.03020007f, 0.12939692f, 0.07484574f, 0.05891774f, 
    0.10181617f, -0.00738411f, 0.12698971f, 0.00375523f, 0.01262578f, -0.34785232f, 0.18185098f, -0.08944282f, 
    0.22580726f, 0.11215609f, 0.02123208f, 0.07862313f, -0.11815659f, -0.02004741f, 0.02967330f, 0.04554468f, 
    -0.11539739f, 0.00302067f, 0.12104885f, 0.09288948f, 0.05622235f, 0.04713869f, 0.11041899f, 0.05803081f, 
    -0.19735104f, -0.27313635f, -0.29495639f, -0.05944050f, -0.01827082f, 0.09024595f, 0.10382486f, 0.07945026f, 
    0.15726653f, 0.00191266f, -0.01255304f, 0.06006557f, 0.06397321f, 0.02547200f, -0.00390796f, -0.04327004f, 
    0.30540776f, 0.31728366f, 0.08868737f, 0.31299412f, 0.25617203f, 0.19206259f, -0.27441159f, -0.05467947f, 
    -0.07363432f, 0.04356528f, -0.00127954f, 0.05587119f, 0.05453429f, 0.12189894f, -0.14687853f, -0.02350722f, 
    -0.04144763f, 0.07915698f, -0.03204699f, -0.14441904f, -0.07104647f, -0.05207584f, 0.09482069f, -0.02433283f, 
    0.00132659f, -0.11886375f, 0.00102604f, 0.05675104f, -0.27923974f, 0.01050051f, 0.02000184f, 0.08448098f, 
    -0.27825227f, -0.23853037f, -0.18496108f, 0.04743205f, -0.14531496f, 0.04110593f, 0.25873712f, 0.05310041f, 
    0.13929124f, 0.07625221f, -0.01217488f, -0.03093373f, -0.17936429f, -0.12565103f, 0.06149674f, -0.09596378f, 
    0.19985518f, 0.14318804f, 0.12349340f, 0.05052614f, -0.13971689f, 0.04070383f, -0.14180724f, 0.04104374f, 
    0.08742793f, 0.09025109f, 0.09396161f, 0.05113620f, 0.18267897f, -0.14055251f, 0.06409520f, 0.19461413f, 
    -0.15368865f, -0.10158815f, -0.20867737f, 0.03511872f, 0.13708314f, 0.11104194f, 0.15337695f, 0.01303188f, 
    -0.01424677f, -0.12879558f, 0.06463047f, -0.02708269f, 0.12578359f, 0.16564475f, 0.02846290f, -0.27421209f, 
    -0.07242175f, -0.02478165f, 0.18733419f, 0.06784522f, 0.08508185f, 0.00870177f, 0.06408409f, 0.09890264f, 
    0.00064557f, -0.07797816f, 0.08372145f, 0.08273076f, 0.08059461f, -0.11964976f, -0.13063245f, -0.11842507f, 
    -0.01557182f, -0.20518622f, 0.11468343f, -0.27233258f, -0.31841567f, -0.37715334f, -0.03801438f, 0.01765682f, 
    -0.20286644f, -0.26884341f, -0.31349707f, -0.09744859f, 0.31139028f, -0.04387841f, -0.07639959f, -0.08202910f, 
    0.11433654f, -0.01234170f, -0.15102471f, 0.06199126f, 0.35216916f, 0.12477025f, 0.29943818f, 0.18682922f, 
    -0.16209860f, -0.12590140f, 0.01615426f, -0.27989477f, -0.04149167f, 0.03528443f, 0.07781187f, -0.04001305f, 
    -0.12002481f, -0.14681482f, -0.28532386f, -0.09265192f, 0.11636984f, 0.02594079f, 0.20208094f, -0.23428077f, 
    -0.11513519f, -0.14471959f, -0.17010455f, -0.21081926f, 0.01917071f, 0.01285359f, 0.03782928f, 0.03584699f, 
    -0.17790110f, -0.04151613f, -0.03947269f, 0.18507309f, -0.24048808f, -0.18446366f, -0.19991410f, 0.01881879f, 
    0.15517534f, 0.06359477f, -0.01490403f, 0.11447257f, -0.03546819f, 0.16366698f, 0.34125561f, 0.34710756f, 
    0.05242556f, 0.08078632f, 0.03167159f, 0.09772921f, 0.05134429f, 0.03013640f, 0.05771148f, -0.03196627f, 
    -0.51320499f, -0.04051031f, 0.30151564f, -0.07136790f, -0.02473336f, -0.00281171f, -0.16661741f, 0.19086923f, 
    0.17353961f, -0.01869688f, 0.15424305f, 0.12457113f, 0.03314805f, -0.10735875f, -0.20439222f, 0.11194098f, 
    -0.07886989f, 0.04888783f, 0.11434746f, -0.13545866f, -0.03110684f, -0.03819597f, 0.01856193f, 0.05118565f, 
    -0.01364323f, 0.24306884f, 0.05797177f, -0.13075322f, -0.03171200f, -0.02557238f, -0.04160438f, 0.02596315f, 
    -0.02696658f, -0.00198725f, 0.04107576f, 0.01199188f, 0.00747569f, -0.21672601f, -0.07096651f, -0.04895822f, 
    -0.02056426f, 0.00948287f, -0.15351118f, -0.06355017f, -0.04990065f, -0.05105637f, 0.08490314f, 0.03303202f, 
    -0.00827738f, -0.07813299f, 0.06209579f, 0.04113458f, -0.02937817f, 0.04457116f, 0.09220719f, -0.05546441f, 
    0.04760316f, 0.09775823f, 0.17001393f, 0.03641662f, 0.08638979f, -0.02657886f, -0.04364567f, -0.04961662f, 
    -0.13391837f, 0.00575551f, 0.07739720f, -0.06591209f, 0.15552464f, -0.04468782f, -0.01291122f, 0.07753257f, 
    0.14646617f, 0.06330740f, -0.16647732f, 0.01640111f, 0.08646740f, 0.07067385f, -0.11694954f, 0.07274787f, 
    -0.01322336f, -0.09022180f, -0.17784376f, -0.06788667f, 0.17449555f, 0.18796587f, -0.03717500f, -0.13092397f, 
    0.09482379f, -0.00390115f, 0.04463271f, 0.10745493f, -0.08073994f, -0.02700103f, -0.09030931f, -0.05034931f, 
    0.02295184f, 0.40272433f, 0.07260074f, -0.00577529f, -0.07346285f, 0.00930142f, 0.00119300f, -0.03157097f, 
    0.05128996f, 0.04942757f, 0.09557118f, 0.02876486f, -0.00141103f, -0.03583739f, -0.09096207f, 0.02991574f, 
    0.07437173f, 0.01979806f, -0.04305110f, -0.00609997f, -0.03474908f, -0.00422635f, -0.07572827f, -0.06117210f, 
    0.10760091f, -0.44481644f, 0.05652203f, 0.25359437f, -0.07717058f, 0.10822804f, -0.11245935f, -0.06884302f, 
    -0.03512156f, 0.05260444f, -0.06043024f, 0.07406520f, 0.10396840f, -0.06130534f, 0.15773149f, 0.04132351f, 
    0.05922996f, -0.12615930f, -0.11824495f, 0.07039240f, -0.17801927f, -0.08735734f, -0.12565091f, -0.04676673f, 
    -0.04919911f, -0.20578469f, 0.15623738f, 0.18979327f, -0.03799277f, 0.08234239f, -0.00479599f, 0.09619784f, 
    0.10485324f, 0.12638158f, 0.11104357f, 0.24455905f, 0.16759533f, -0.22625326f, -0.05343289f, 0.06633753f, 
    -0.14851734f, 0.13404363f, 0.22300588f, 0.04409705f, -0.05318367f, -0.09357237f, 0.00107501f, -0.07705117f, 
    -0.00142948f, 0.14533910f, -0.23607136f, -0.06266133f, 0.06356047f, -0.05705783f, 0.13948989f, -0.05930026f, 
    0.03503020f, -0.12868425f, 0.03253605f, 0.06996312f, 0.07957525f, -0.21934889f, 0.10645685f, 0.01642116f, 
    0.05753198f, 0.11448164f, 0.09916753f, 0.09191599f, 0.01213138f, -0.05521101f, -0.01178957f, -0.12887853f, 
    -0.13608710f, -0.04049917f, 0.11108939f, -0.01234131f, 0.02926409f, -0.24901223f, 0.12694317f, -0.18762974f, 
    0.15757734f, 0.14216933f, 0.00710239f, 0.04452384f, -0.11344554f, 0.14242227f, -0.24380222f, -0.16505595f, 
    0.04068208f, 0.06121478f, 0.09103217f, -0.01708334f, 0.03124004f, 0.07621979f, 0.06285226f, 0.06877682f, 
    -0.26489055f, -0.39543593f, -0.33995143f, -0.29496139f, 0.00105921f, 0.09929819f, -0.02762197f, -0.03023110f, 
    0.03253185f, 0.06507298f, 0.01095851f, -0.06262932f, -0.13317958f, 0.00777407f, -0.25300321f, -0.18549083f, 
    -0.26600063f, -0.06359943f, 0.08496220f, 0.06350270f, 0.09148967f, 0.03978960f, -0.02302385f, 0.19779240f, 
    -0.20224740f, -0.12077942f, 0.12334372f, 0.05220246f, -0.04206351f, -0.00942501f, 0.08942275f, 0.16822465f, 
    -0.03361150f, -0.11934628f, 0.06380502f, 0.05719993f, -0.03755831f, -0.26285851f, 0.00079338f, 0.14714460f, 
    -0.07868373f, -0.00131447f, 0.02146521f, 0.10467710f, 0.00124824f, -0.02295016f, 0.01596349f, 0.08175633f, 
    -0.43807858f, 0.14873476f, 0.03595645f, -0.12766415f, 0.12752540f, 0.10594835f, -0.03197605f, -0.15253058f, 
    0.06117069f, -0.06919184f, -0.03781794f, -0.09955939f, -0.28627196f, 0.17300770f, 0.06607155f, 0.11972442f, 
    -0.00842245f, 0.12306418f, 0.08836745f, 0.02506917f, -0.01944790f, 0.00691634f, 0.07020430f, 0.13610068f, 
    0.21127598f, -0.22911142f, 0.38237885f, 0.20982838f, -0.07494756f, -0.01007953f, -0.00229838f, 0.09993164f, 
    -0.06929646f, 0.02976201f, 0.04243521f, 0.07728164f, -0.07780748f, -0.03452232f, -0.18414541f, -0.20194785f, 
    -0.04061403f, -0.06682782f, -0.07046844f, -0.05505364f, -0.04308037f, -0.01062173f, 0.06926952f, -0.02850550f, 
    0.27944714f, -0.03275849f, 0.01444109f, -0.10190958f, -0.02981872f, -0.04170610f, 0.05165213f, 0.08423959f, 
    0.17592968f, -0.13915291f, 0.02208121f, 0.15610847f, -0.06148844f, 0.02627094f, 0.51056886f, -0.03422349f, 
    -0.02796359f, -0.17874697f, -0.04889727f, -0.17971732f, 0.05369596f, 0.10700608f, 0.28929740f, 0.08603041f, 
    0.13830762f, 0.07617333f, 0.23538648f, 0.02481475f, -0.05258048f, -0.09602448f, 0.00203495f, -0.02316482f, 
    0.17378394f, 0.37203401f, 0.09801049f, -0.05382804f, 0.21844931f, -0.05508825f, 0.03166237f, -0.24853687f, 
    -0.12823774f, 0.00027200f, 0.22469780f, 0.02867987f, 0.06856211f, -0.05138187f, 0.08370782f, -0.00760432f, 
    0.18998022f, -0.06419663f, -0.30541968f, 0.18571605f, 0.01220136f, 0.02444971f, -0.06949683f, -0.05300442f, 
    0.25787097f, 0.00628409f, -0.08745328f, -0.03785012f, -0.05888275f, 0.04943864f, 0.27193943f, 0.04869894f, 
    0.02795228f, 0.00712998f, -0.10051098f, 0.04939611f, -0.14110900f, -0.04864359f, -0.02020134f, 0.01668848f, 
    -0.26446056f, -0.16029200f, 0.09414453f, 0.08174469f, -0.12600343f, 0.28657141f, -0.14905874f, 0.15643498f, 
    0.05573838f, 0.08283579f, 0.04760818f, 0.00773957f, 0.26670912f, -0.03699133f, 0.14279126f, 0.16592044f, 
    -0.03069683f, -0.06410553f, -0.14202528f, 0.02967431f, 0.00166165f, -0.14094205f, 0.05655271f, 0.04691661f, 
    -0.10382996f, -0.00898443f, 0.17548884f, -0.08004111f, -0.08501692f, -0.05117529f, -0.07347629f, -0.06554608f, 
    0.04216263f, -0.06738661f, 0.00270944f, 0.05819177f, 0.12766390f, -0.10624847f, 0.17004684f, -0.15307471f, 
    -0.05594235f, 0.07825248f, -0.06697311f, -0.15662923f, 0.04397149f, -0.00274221f, 0.03704092f, -0.06396464f, 
    -0.11993876f, 0.03483248f, 0.02798225f, 0.01134352f, -0.07966609f, 0.02134024f, 0.09275861f, -0.10789248f, 
    -0.03602147f, -0.01618592f, 0.13686505f, 0.02728331f, 0.00014401f, 0.07861461f, 0.09330892f, 0.08740126f, 
    -0.10703743f, -0.02863701f, 0.23888767f, -0.03047426f, 0.01376326f, 0.06848555f, -0.00721104f, -0.07320868f, 
    0.30204338f, -0.21454389f, -0.05923589f, -0.02555013f, 0.24089558f, 0.00049250f, -0.22529940f, 0.06756874f, 
    -0.10734744f, 0.00827345f, 0.02882841f, -0.01760420f, 0.02414908f, 0.13188526f, 0.00300900f, -0.12040041f, 
    0.09796958f, 0.04094423f, 0.11318836f, 0.15730757f, -0.08257096f, 0.02715792f, -0.07288776f, 0.03679921f, 
    -0.14491731f, 0.18716814f, -0.12215075f, 0.23226924f, -0.11945196f, 0.05344642f, 0.00816941f, 0.30676362f, 
    0.12115537f, 0.05156568f, -0.01100310f, 0.03983890f, 0.09660186f, 0.12375527f, -0.05420419f, 0.12639795f, 
    0.03193736f, 0.04609255f, 0.08980945f, 0.08589344f, 0.10308144f, -0.00744963f, -0.05666116f, 0.17339237f, 
    0.11616166f, -0.20646466f, 0.07311360f, 0.15103701f, 0.03935954f, -0.07866009f, 0.13107987f, 0.17023915f, 
    -0.03517311f, 0.10737623f, 0.10232892f, -0.00992509f, -0.30178794f, 0.13553931f, -0.09708630f, -0.07725936f, 
    -0.21505518f, 0.00871407f, -0.12363794f, 0.21308658f, -0.08901934f, -0.01582969f, -0.17596640f, -0.12734944f, 
    -0.14434795f, -0.07839986f, 0.04044558f, -0.06004024f, 0.02925596f, 0.04493626f, -0.08858524f, 0.17957185f, 
    0.14072853f, 0.02829332f, 0.06953327f, 0.01167377f, -0.00629742f, -0.03651318f, -0.06734855f, 0.04389779f, 
    -0.00390380f, 0.05010804f, 0.05403906f, 0.24667406f, -0.01708558f, 0.05849081f, -0.05480228f, -0.13154085f, 
    -0.17213817f, 0.10095377f, 0.03227139f, 0.00423962f, 0.03092676f, -0.02268046f, -0.01414238f, -0.10504570f, 
    -0.01808693f, -0.09179436f, 0.11510422f, 0.03460342f, 0.26055667f, 0.14152072f, -0.04292011f, -0.13916294f, 
    -0.05776482f, -0.08624103f, -0.10024200f, -0.00600019f, -0.04118633f, -0.05656166f, -0.07570165f, -0.08102580f, 
    0.27023825f, -0.36667493f, -0.15375218f, -0.05615321f, -0.02850739f, 0.02612498f, 0.08597680f, 0.04954425f, 
    0.04277944f, -0.06776624f, 0.05436655f, 0.11716584f, 0.13932739f, 0.01328625f, 0.18290947f, -0.01678137f, 
    -0.04651344f, 0.04171216f, -0.09618594f, -0.06825832f, 0.05553996f, 0.14731364f, 0.04532108f, 0.09268660f, 
    0.07766581f, -0.02609523f, 0.35077405f, 0.39342132f, -0.19836210f, 0.02516244f, 0.07548017f, 0.21069446f, 
    0.03389098f, -0.02959151f, 0.01017734f, 0.00240072f, -0.04530375f, -0.07554189f, 0.18269226f, -0.04285746f, 
    -0.12917364f, -0.01374689f, 0.02780266f, 0.09842184f, 0.00214552f, -0.02113287f, -0.02236350f, 0.00817492f, 
    0.17053476f, -0.30359146f, -0.14655681f, -0.16636629f, 0.08359893f, 0.06257737f, -0.11929880f, 0.02853918f, 
    0.01609340f, -0.02670730f, -0.12433952f, 0.20454222f, 0.21903817f, -0.07053110f, -0.36587089f, -0.09094399f, 
    -0.11481111f, -0.23289798f, -0.02032475f, 0.10250984f, 0.02810455f, -0.16551447f, -0.09461521f, -0.04070948f, 
    -0.05354043f, 0.11949849f, 0.06523164f, 0.16706213f, -0.01622605f, 0.08048726f, -0.05782158f, 0.16068424f, 
    -0.01905398f, 0.09038312f, -0.02175499f, 0.01082236f, -0.27404562f, -0.13655555f, -0.00250993f, 0.01265479f, 
    0.08126255f, 0.08915371f, -0.01100785f, 0.11827166f, -0.05680450f, 0.07555100f, 0.01974535f, 0.09551574f, 
    0.21079366f, -0.15198012f, -0.52321482f, -0.21548876f, -0.10641556f, -0.10129185f, -0.00784471f, 0.16413659f, 
    0.02475390f, -0.06503034f, -0.03745253f, -0.10006788f, 0.08279917f, 0.07768340f, 0.16652745f, -0.11401046f, 
    0.12473395f, 0.01048072f, 0.03933785f, -0.01387492f, 0.09635320f, 0.04149107f, -0.01567865f, 0.06697240f, 
    0.30895340f, -0.19416970f, -0.09945624f, -0.08585080f, -0.00372764f, 0.03039758f, 0.02377747f, -0.14003532f, 
    -0.11962298f, -0.08312912f, 0.16285108f, 0.10760331f, 0.38180792f, -0.02744874f, -0.19409642f, -0.00607001f, 
    -0.13633703f, 0.17784442f, 0.19673915f, 0.11959304f, 0.16855961f, -0.07041536f, 0.16456842f, 0.06022872f, 
    0.07116647f, 0.03683246f, -0.03608782f, 0.05520988f, -0.03579377f, 0.03470737f, -0.07741495f, -0.13639784f, 
    0.14981185f, -0.01942513f, 0.03165559f, 0.03725277f, 0.02516482f, -0.15355720f, 0.24427459f, 0.06332538f, 
    0.02232193f, 0.07169341f, 0.11471041f, -0.12272040f, -0.05507995f, -0.13608789f, -0.06606834f, -0.01113280f, 
    0.18241554f, 0.08890340f, 0.16930345f, 0.03556318f, 0.15400328f, -0.05671335f, 0.10336053f, -0.18756613f, 
    0.11450710f, 0.06080201f, 0.15781097f, -0.00068096f, 0.37325650f, 0.21785188f, 0.15070306f, -0.15598620f, 
    -0.08977042f, -0.08583139f, -0.06735139f, -0.07743498f, 0.02383714f, 0.05355616f, -0.01864278f, -0.10991997f, 
    0.02297165f, -0.03147531f, 0.06458905f, -0.08456029f, 0.04413265f, 0.04926343f, -0.01463235f, 0.06051160f, 
    -0.07951929f, -0.07438982f, -0.01054276f, 0.00834849f, 0.00780361f, 0.03980362f, -0.05650578f, -0.00685521f, 
    0.04293645f, -0.03951613f, 0.04720476f, 0.01403820f, 0.00244484f, 0.00077621f, 0.04941716f, -0.04719205f, 
    -0.01504884f, 0.00693668f, -0.00099224f, -0.00829465f, 0.00118494f, 0.04646192f, -0.05471011f, 0.01435989f, 
    0.04010132f, 0.03977907f, 0.02570898f, 0.05548916f, -0.06039526f, -0.03562341f, 0.02900044f, -0.00822581f, 
    0.06096542f, -0.07146966f, -0.00868748f, 0.05173314f, 0.01811573f, -0.04398172f, 0.03918469f, -0.02088379f, 
    -0.05944626f, 0.03748404f, -0.03853967f, -0.04100399f, -0.07268307f, 0.02468904f, 0.00700679f, -0.01424116f, 
    -0.01947050f, -0.03749793f, 0.01172450f, 0.01114200f, 0.03063288f, -0.05324364f, 0.02607406f, -0.06342803f, 
    -0.06953838f, 0.04389503f, -0.02380724f, -0.02371927f, 0.03428779f, -0.04709771f, -0.01569491f, -0.02206611f, 
    0.05704666f, 0.03888625f, -0.06839865f, -0.06644656f, 0.01941621f, -0.04100860f, 0.02831377f, -0.03185534f, 
    -0.08163705f, -0.06449196f, 0.02522575f, 0.04187404f, -0.01474315f, -0.06986912f, 0.03300769f, -0.00662568f, 
    -0.04140244f, 0.01592964f, 0.01225503f, 0.05560304f, -0.07341187f, 0.04145088f, 0.05447411f, -0.04319337f, 
    -0.03674000f, 0.00076484f, -0.05188912f, 0.00900372f, 0.00043720f, -0.05630184f, -0.00168437f, -0.07987101f, 
    0.01166834f, -0.05446216f, 0.02851251f, 0.03678823f, 0.01886146f, -0.08035354f, 0.01406467f, 0.02811387f, 
    0.05308180f, 0.02508518f, -0.03374632f, -0.00773072f, -0.07476600f, -0.07071657f, -0.01213260f, 0.00562221f, 
    -0.00043139f, -0.06563143f, 0.03526400f, -0.02278423f, -0.04844334f, 0.00812707f, -0.07509188f, 0.02116416f, 
    -0.04060793f, -0.01774141f, -0.04391409f, -0.07537396f, -0.00827680f, -0.03698445f, -0.03388376f, 0.02870851f, 
    -0.06744348f, 0.00129497f, -0.06248382f, -0.02793053f, -0.00841994f, -0.01468917f, 0.02942374f, -0.04078283f, 
    -0.02411893f, 0.06223587f, -0.00636857f, -0.00862278f, -0.04794292f, -0.04216854f, -0.04450356f, -0.07432799f, 
    0.01382242f, 0.02795722f, -0.07714010f, -0.00358917f, -0.05298725f, 0.03929912f, -0.01744783f, -0.06475943f, 
    -0.04851767f, -0.02840874f, -0.07962614f, -0.04552853f, -0.04100728f, -0.06151176f, -0.07023603f, 0.06481038f, 
    -0.03774109f, 0.03099057f, -0.04038659f, 0.01152851f, 0.05049586f, -0.01383550f, -0.02538933f, 0.04676983f, 
    0.04395786f, -0.01832445f, -0.03362766f, 0.05266600f, -0.05839963f, -0.01655260f, -0.05127908f, 0.06192137f, 
    0.04000427f, -0.06615358f, -0.02173623f, 0.04020153f, 0.02421981f, 0.01546112f, 0.04068260f, -0.03098435f, 
    -0.06403522f, 0.04706022f, -0.00762511f, -0.02291300f, 0.03281020f, -0.04272258f, 0.03968754f, 0.04727919f, 
    -0.00625811f, -0.00909779f, -0.00445772f, 0.02774754f, -0.02062217f, -0.01795651f, 0.02742671f, 0.04151631f, 
    -0.00125616f, -0.05000383f, 0.04297932f, -0.05933390f, -0.02555418f, -0.02359958f, -0.05082600f, 0.02105959f, 
    -0.05380360f, -0.04444071f, 0.06496593f, 0.04513716f, -0.03653692f, 0.00018140f, 0.05110015f, -0.04704974f, 
    -0.02092346f, -0.06504156f, -0.07405884f, -0.05466027f, -0.03880020f, -0.02108263f, -0.06170946f, -0.01587380f, 
    -0.02578955f, 0.00863182f, 0.04077401f, 0.00412623f, 0.01266266f, -0.05079308f, -0.02420220f, -0.05891028f, 
    -0.00765430f, 0.06792472f, -0.05698647f, 0.04971565f, 0.02038685f, -0.00717717f, -0.01738951f, 0.03530508f, 
    0.00503373f, -0.03806658f, -0.00469607f, -0.02496266f, 0.03919085f, 0.03579139f, -0.04087998f, -0.00935584f, 
    -0.06774833f, -0.02976293f, -0.01059463f, -0.06415062f, 0.02294793f, -0.00213585f, -0.06386836f, -0.06380766f, 
    0.01873042f, -0.08084260f, -0.08267767f, -0.06212367f, -0.08365829f, 0.03622779f, 0.05618626f, -0.08279042f, 
    -0.07059310f, 0.02279094f, -0.06056124f, 0.03983033f, -0.01092330f, 0.03282523f, -0.07778924f, -0.07972016f, 
    -0.04148654f, -0.07770865f, -0.08408331f, -0.08334489f, -0.05568264f, -0.07406375f, -0.07962804f, -0.05111284f, 
    -0.05070142f, -0.06554021f, -0.07050693f, 0.00462310f, 0.02480906f, -0.00865944f, -0.02640547f, -0.04184591f, 
    -0.01736738f, -0.03558009f, 0.03899191f, 0.02695832f, -0.07655022f, -0.04170301f, 0.03471382f, 0.02186320f, 
    -0.01539380f, -0.03901087f, 0.05019322f, -0.02057957f, -0.03063267f, 0.00566458f, 0.05275236f, 0.02695412f, 
    -0.04339403f, 0.04182871f, -0.07711270f, 0.02746788f, -0.01950217f, -0.03696310f, -0.03403171f, -0.03919285f, 
    -0.00432258f, 0.05256997f, -0.04132124f, 0.05370887f, -0.07615462f, -0.02034024f, 0.01674915f, 0.05054446f, 
    -0.02972868f, -0.01127908f, -0.06080611f, -0.00851270f, 0.04844634f, -0.00143133f, -0.02605200f, -0.07860242f, 
    0.00555507f, 0.02792975f, 0.05853005f, 0.01542069f, -0.01929583f, -0.02474544f, 0.02357577f, -0.05910074f, 
    -0.03973343f, -0.04335342f, 0.03399794f, -0.00954520f, -0.01791189f, -0.08404825f, -0.01483482f, -0.02363227f, 
    0.01519045f, 0.03374967f, 0.03067751f, 0.05177718f, -0.06167446f, -0.02604353f, 0.04058037f, -0.04378891f, 
    -0.01990352f, -0.05384336f, -0.08206228f, -0.08218434f, -0.00294053f, 0.04998439f, -0.05803910f, -0.00986547f, 
    -0.06087371f, -0.06427722f, -0.07138250f, -0.01176858f, -0.01844359f, -0.03492953f, 0.00570791f, -0.06824537f, 
    0.01085764f, -0.04162737f, 0.03690720f, -0.05313409f, 0.04101251f, -0.04124262f, -0.07428701f, -0.00134122f, 
    0.18855879f, 0.21452633f, 0.09968653f, 0.12566504f, 0.00002559f, -0.08937421f, 0.09145041f, -0.13081118f, 
    -0.01002851f, -0.02600308f, 0.06460591f, 0.06932877f, -0.11163241f, 0.15564561f, 0.24436374f, -0.00924022f, 
    -0.05114015f, -0.02848631f, -0.17002046f, 0.05054238f, -0.08731271f, -0.09102127f, -0.06285649f, -0.13267788f, 
    -0.18918128f, -0.32378757f, -0.14906807f, 0.10123652f, 0.03555230f, 0.06808116f, 0.11127394f, -0.09444862f, 
    0.02603016f, 0.06478888f, 0.02617012f, -0.09622174f, -0.08536039f, -0.03256438f, -0.19666025f, 0.19584046f, 
    -0.08451619f, 0.06536957f, 0.08077552f, -0.09747864f, -0.00077588f, 0.01565974f, -0.08988323f, 0.03030939f, 
    -0.08271512f, 0.14576423f, -0.05034903f, -0.03597045f, 0.06623271f, 0.02247885f, -0.02582353f, -0.00732803f, 
    -0.07486483f, 0.00451803f, -0.03915473f, -0.04467501f, 0.07203329f, -0.00493949f, 0.19609603f, 0.23667848f, 
    0.04945017f, 0.14735228f, -0.01401108f, -0.08150482f, -0.09627995f, -0.01042076f, -0.00507438f, -0.01337602f, 
    -0.14579007f, -0.19892560f, 0.24344616f, -0.06251420f, -0.01910357f, 0.08459042f, -0.15516339f, 0.05766998f, 
    -0.08614986f, 0.14527923f, 0.14627704f, 0.17492369f, -0.08626237f, 0.01993710f, -0.00320654f, 0.31481826f, 
    0.04361685f, 0.08706768f, -0.03929438f, -0.08512590f, -0.00215745f, 0.04217828f, 0.09283063f, 0.04455277f, 
    0.03614733f, -0.17064829f, -0.12442049f, 0.21350236f, 0.13941522f, 0.00042884f, -0.00031513f, -0.01590694f, 
    -0.10838563f, -0.05173994f, -0.02619268f, -0.07406237f, -0.08023050f, 0.05938000f, -0.17838298f, -0.20628391f, 
    -0.09033968f, -0.20141910f, 0.01280461f, -0.04999422f, -0.10778128f, -0.08493401f, -0.08618163f, 0.02581370f, 
    -0.11739085f, 0.41835290f, -0.25746074f, 0.04576977f, 0.22436580f, -0.00247270f, 0.11831837f, 0.06294807f, 
    -0.00883789f, 0.08098701f, 0.05960115f, 0.06703603f, 0.03507496f, -0.07294083f, 0.05597905f, 0.19871989f, 
    -0.09812524f, 0.05750441f, 0.12868766f, -0.05250950f, -0.00269387f, 0.08975874f, 0.19025733f, 0.16164714f, 
    -0.05693264f, 0.24448399f, -0.12227736f, 0.03351717f, -0.02329277f, -0.11085698f, -0.06639642f, -0.08616146f, 
    -0.06570338f, 0.03468509f, -0.01281004f, -0.02472134f, -0.19430871f, 0.15477988f, -0.14426146f, 0.03402073f, 
    0.02218659f, -0.01651131f, 0.14069013f, -0.02256462f, -0.00031707f, 0.06458929f, 0.10384520f, 0.06220712f, 
    0.15876336f, 0.10946035f, 0.04511766f, 0.07271487f, -0.04676621f, -0.15587695f, -0.01476411f, -0.00164881f, 
    -0.04368977f, 0.04887315f, -0.12907733f, -0.05611769f, -0.00627315f, 0.60733527f, -0.04860988f, 0.17531735f, 
    -0.15122610f, -0.08495642f, -0.05685115f, -0.09977791f, -0.05313790f, -0.02070714f, -0.03924686f, -0.00011564f, 
    0.03328571f, -0.02397525f, -0.06211110f, 0.04530903f, -0.06534537f, 0.00538624f, 0.04957020f, 0.04544968f, 
    0.03307663f, -0.07871246f, -0.06377558f, -0.01638108f, 0.02149215f, -0.03715656f, -0.00365137f, 0.01665382f, 
    -0.03355353f, -0.08050115f, 0.03006122f, -0.06138983f, -0.07502101f, 0.00133172f, 0.03641565f, -0.06639928f, 
    0.03785905f, -0.02440484f, -0.04235324f, 0.03706964f, -0.00099852f, 0.04009477f, -0.02331534f, -0.02576409f, 
    0.03530066f, -0.05823896f, -0.03876205f, -0.03306082f, -0.01372119f, -0.06420649f, -0.01121692f, 0.01752686f, 
    -0.04802563f, -0.03965284f, -0.06922973f, 0.03095764f, -0.00793243f, -0.02375817f, 0.02604762f, 0.03525849f, 
    0.06137469f, -0.00059015f, -0.00205972f, 0.06102220f, -0.03383287f, -0.00449061f, 0.00131795f, -0.00514444f, 
    -0.04029284f, 0.02191370f, -0.05916191f, -0.01929100f, 0.04245695f, 0.01016253f, -0.03057328f, -0.03882104f, 
    -0.05307719f, 0.00026144f, -0.06298293f, 0.03826155f, 0.03536316f, 0.04714538f, 0.00229197f, 0.03637136f, 
    -0.05961794f, -0.04790197f, -0.01980749f, 0.00243665f, -0.03670762f, 0.03713547f, -0.00754821f, 0.04667359f, 
    -0.04017975f, 0.03270385f, -0.02912747f, 0.00896619f, -0.01521336f, 0.00945504f, 0.01615488f, -0.04728734f, 
    -0.03082746f, -0.04675076f, 0.04843534f, 0.01363373f, 0.02760834f, -0.01729630f, 0.00318259f, -0.07785978f, 
    -0.05479981f, -0.05583482f, -0.07777915f, -0.04236979f, 0.03812139f, -0.03705175f, -0.03973374f, -0.05627988f, 
    -0.05310966f, 0.03107733f, -0.04559399f, -0.04863572f, 0.06196231f, -0.06715310f, -0.04240083f, -0.00436325f, 
    -0.05696779f, 0.04704229f, 0.00628247f, -0.05173621f, 0.05799789f, -0.05883957f, -0.07319757f, 0.02134757f, 
    0.02502897f, -0.07577835f, -0.06845855f, 0.04694127f, -0.03116164f, -0.03209973f, -0.01884412f, 0.03804601f, 
    0.04398744f, 0.00078333f, -0.02075378f, -0.00074828f, -0.07909700f, 0.05807023f, 0.02626638f, -0.03216426f, 
    -0.04569766f, -0.02932418f, -0.06607661f, -0.00502948f, 0.05044072f, 0.01195564f, 0.06238372f, 0.02821799f, 
    0.05777223f, 0.00748358f, 0.02470111f, -0.01010473f, -0.06968932f, -0.06189699f, 0.00502513f, 0.03076679f, 
    -0.02608373f, -0.06978253f, -0.06545461f, -0.05339485f, -0.04245797f, -0.04528321f, 0.01036171f, -0.00963418f, 
    -0.00397384f, -0.00037851f, -0.06248909f, -0.06614490f, -0.07126264f, -0.00978290f, -0.00330566f, 0.05677769f, 
    0.03272974f, -0.07990403f, -0.07121411f, 0.04594100f, 0.03199051f, -0.06185662f, -0.05195984f, 0.06261498f, 
    -0.06190144f, 0.02009497f, 0.00403900f, -0.01017138f, -0.03584231f, 0.00990984f, -0.04435413f, -0.02855139f, 
    -0.06638194f, -0.03493891f, -0.01122597f, -0.06617903f, -0.01445570f, -0.04600843f, -0.01126742f, -0.04106795f, 
    0.37346482f, 0.03920899f, -0.07402050f, 0.26143360f, -0.02110504f, -0.15940718f, 0.10538649f, -0.10244531f, 
    0.10483289f, 0.04180961f, 0.06051740f, 0.06926192f, -0.04609129f, 0.10103735f, 0.14141530f, 0.02314343f, 
    -0.02254035f, -0.00980993f, 0.05030174f, -0.03862384f, 0.01023445f, 0.10398134f, -0.06262706f, 0.09844296f, 
    0.19610511f, 0.39539304f, 0.20448031f, -0.10224953f, -0.13271002f, 0.04014082f, 0.24804287f, 0.22435404f, 
    -0.02461329f, -0.08106481f, 0.04990959f, -0.12024317f, 0.12889394f, -0.07095101f, 0.25680837f, -0.11235829f, 
    0.01831464f, 0.04085901f, -0.04074854f, 0.13778137f, -0.14563723f, 0.01405668f, 0.02751436f, -0.09407937f, 
    0.19639021f, 0.12925723f, 0.21346153f, 0.06399020f, -0.03445232f, -0.06167040f, -0.10201843f, -0.19532128f, 
    0.11833137f, 0.06279187f, -0.06470940f, -0.05878663f, 0.03958550f, 0.19766288f, -0.06245857f, -0.25302893f, 
    -0.13059564f, 0.04221862f, -0.23282565f, -0.07738517f, 0.09649704f, -0.01075669f, 0.03507664f, -0.05020763f, 
    0.11469247f, -0.00002140f, -0.11189713f, 0.14339577f, 0.02112874f, 0.04347901f, 0.04032247f, -0.01453862f, 
    -0.05151929f, -0.13452597f, -0.04851158f, -0.00238753f, 0.18774697f, -0.00297588f, -0.04319780f, -0.38451520f, 
    0.04076404f, 0.09154914f, 0.04020383f, 0.07977930f, -0.00803984f, 0.02080640f, 0.13028674f, -0.19127484f, 
    0.12825678f, 0.02870091f, 0.00802848f, -0.34169233f, -0.01614349f, -0.00346976f, -0.05716036f, -0.13770905f, 
    0.11179104f, -0.02145348f, 0.03261296f, 0.06541225f, 0.08847698f, 0.10801740f, 0.15670902f, 0.06904519f, 
    0.00074211f, 0.05709945f, -0.05947623f, -0.06333954f, 0.07403246f, 0.07815123f, 0.14683719f, -0.02072194f, 
    0.14576852f, -0.51588458f, 0.05291330f, 0.00393885f, -0.22381657f, -0.02899404f, -0.04413611f, 0.11285783f, 
    -0.05588520f, 0.09233665f, 0.04778581f, -0.07257464f, 0.26787513f, -0.05500741f, 0.06537470f, -0.00271082f, 
    0.15209471f, -0.01149025f, 0.03746978f, -0.06879172f, -0.09798228f, 0.03236934f, -0.09393765f, -0.01587678f, 
    0.04744961f, -0.16906202f, 0.23784602f, 0.47224423f, -0.12469354f, -0.04007650f, -0.02195514f, -0.06298835f, 
    -0.08975145f, 0.12023439f, -0.08355328f, -0.05120445f, -0.03190148f, -0.27091184f, -0.15099333f, 0.04099657f, 
    -0.08379328f, 0.16256887f, 0.21672280f, -0.07415360f, -0.02404528f, -0.12695265f, -0.07563297f, -0.05254937f, 
    -0.37164447f, 0.14273961f, -0.17895937f, -0.00759224f, 0.03587685f, 0.12287244f, 0.11903723f, 0.02708946f, 
    0.00282671f, 0.02487367f, -0.01071155f, -0.08327394f, 0.16680688f, -0.29751694f, 0.05856508f, 0.13232343f, 
    -0.10987286f, -0.06790508f, 0.06492385f, -0.05655461f, 0.03421434f, -0.04880675f, 0.01649435f, 0.03031417f, 
    0.08648582f, -0.32081917f, -0.52886826f, -0.01504230f, 0.34088534f, -0.15932178f, 0.26673236f, -0.06910100f, 
    -0.01673627f, -0.00374638f, -0.19390032f, 0.02053289f, -0.19233426f, -0.11731853f, 0.27098837f, -0.04258419f, 
    -0.12482017f, 0.24805893f, -0.09682633f, -0.06172338f, -0.04875804f, -0.07683145f, 0.02299254f, -0.20075217f, 
    0.11159386f, -0.07590303f, -0.09031317f, 0.00585411f, 0.09397658f, -0.04085433f, -0.18141630f, 0.02918607f, 
    -0.08510660f, -0.05957910f, -0.11251675f, -0.15818433f, 0.13434559f, 0.11333154f, -0.08388537f, 0.07944395f, 
    -0.12617615f, -0.10226978f, -0.02630569f, -0.04660145f, -0.27525607f, -0.04706237f, -0.10155668f, -0.01330595f, 
    0.06946862f, -0.15897849f, 0.04400257f, -0.06086675f, 0.09620273f, -0.01989787f, 0.03939776f, 0.18565527f, 
    -0.27183536f, -0.10828759f, 0.15243639f, 0.06940743f, 0.07943276f, 0.08838729f, -0.19139212f, 0.03875439f, 
    0.18238203f, 0.01898914f, 0.08365948f, -0.08628777f, -0.08939831f, -0.10258703f, -0.06810454f, 0.15226035f, 
    -0.19944488f, 0.22254227f, 0.00493543f, -0.05194341f, 0.06233575f, 0.07176499f, 0.01789643f, -0.08683270f, 
    -0.02463740f, -0.14154892f, 0.17051761f, -0.06617826f, -0.18063773f, -0.06048720f, -0.08602722f, 0.12179041f, 
    -0.01717984f, -0.15161158f, -0.08187567f, -0.08947942f, 0.01534001f, -0.14193887f, -0.02324550f, 0.21217759f, 
    0.12484702f, -0.22857451f, -0.15462984f, 0.04966563f, 0.20370378f, -0.06603746f, 0.03070607f, -0.13439119f, 
    -0.06258539f, -0.04348045f, -0.14125240f, -0.18541902f, 0.09917384f, -0.13364096f, -0.00246708f, -0.16831760f, 
    -0.03934681f, -0.09617483f, -0.12773596f, -0.16341490f, -0.04194703f, 0.06646920f, -0.03752026f, 0.04129139f, 
    0.22808440f, 0.18985082f, 0.08945336f, -0.06225387f, 0.15719159f, -0.09683669f, 0.03544260f, -0.01440401f, 
    -0.01597431f, -0.09704767f, 0.13699754f, -0.03668035f, -0.22343123f, -0.03822679f, -0.18534678f, -0.05305152f, 
    0.10900355f, -0.09354828f, -0.14377330f, -0.11524525f, -0.10950845f, -0.02424299f, 0.07983601f, 0.11593300f, 
    0.04890902f, 0.01054048f, -0.36366844f, 0.02282269f, 0.02356644f, 0.02874217f, 0.06635414f, 0.04685463f, 
    -0.06889383f, 0.05497390f, 0.01214791f, -0.00714846f, 0.07773172f, 0.41957361f, 0.08988465f, -0.16526347f, 
    0.00172341f, -0.29589191f, -0.11165784f, -0.09810019f, -0.13885991f, -0.03931798f, -0.15154283f, -0.00680494f, 
    0.32940540f, 0.00538979f, 0.15046118f, 0.01398494f, 0.00473935f, -0.05584570f, -0.01793299f, 0.16591142f, 
    -0.06664521f, 0.06513727f, -0.05482368f, -0.00171433f, 0.14679903f, 0.20187508f, 0.01143671f, -0.20022397f, 
    -0.02560941f, -0.04223627f, -0.08254300f, -0.09251137f, -0.20667058f, -0.04245530f, 0.05700756f, -0.06745279f, 
    -0.33718884f, 0.43530151f, 0.12583901f, -0.10861786f, -0.09020492f, 0.06092892f, -0.12418499f, -0.01860352f, 
    -0.04000948f, -0.05212280f, 0.00775741f, -0.07418049f, -0.05056167f, -0.04041710f, -0.21480814f, 0.04300676f, 
    -0.02724451f, 0.07354333f, 0.14835882f, -0.06467373f, -0.00888251f, -0.01241265f, -0.00549523f, -0.05886478f, 
    0.00242791f, -0.05576153f, -0.22513156f, 0.03293386f, 0.05960972f, 0.04179143f, -0.08899920f, -0.07126804f, 
    -0.04105731f, -0.02479605f, 0.08782253f, 0.03975948f, -0.18280488f, -0.12799618f, -0.30135053f, 0.18505004f, 
    0.15042774f, 0.06276888f, -0.06111055f, -0.13714248f, -0.10473848f, -0.03437556f, 0.06269784f, 0.02130487f, 
    -0.13785845f, 0.06749203f, -0.11719869f, 0.00610177f, 0.11249459f, 0.10757971f, 0.07178159f, 0.15611067f, 
    -0.03966951f, 0.17203991f, 0.17808531f, 0.02239611f, -0.10485460f, -0.15284821f, -0.06531372f, 0.10915443f, 
    0.06364937f, 0.13243268f, 0.12165580f, -0.15525123f, 0.09405501f, 0.13917610f, 0.12686661f, 0.25563157f, 
    0.18484257f, -0.05055030f, -0.11832583f, 0.01567113f, 0.10194185f, 0.12736571f, -0.11147898f, -0.03362246f, 
    -0.01693778f, 0.01748847f, -0.02431558f, -0.03668211f, 0.16854258f, 0.16580121f, 0.00370814f, 0.18772627f, 
    0.02570144f, -0.14198203f, 0.00169054f, -0.02705418f, -0.07143638f, 0.03289244f, -0.07785966f, -0.06237288f, 
    0.02033586f, 0.27127150f, 0.18320304f, 0.14108062f, 0.12382786f, -0.09174689f, -0.07925355f, -0.25287732f, 
    0.08789618f, 0.09388824f, 0.11971258f, -0.00201942f, -0.08540864f, -0.01267549f, -0.04656432f, 0.03618393f, 
    -0.03926413f, 0.05726549f, 0.05259063f, -0.01499235f, -0.10782382f, -0.05884975f, -0.03108118f, -0.16629347f, 
    -0.38227227f, 0.21238723f, -0.17388107f, 0.24015647f, -0.00804666f, 0.23366721f, -0.00192791f, -0.12963676f, 
    -0.18588828f, 0.03969292f, -0.10700893f, -0.07888381f, 0.02088132f, -0.09461568f, 0.03760686f, 0.15954731f, 
    0.25499654f, -0.19158456f, -0.22442767f, 0.01612623f, -0.09220863f, -0.03161835f, -0.03948890f, -0.00003606f, 
    0.08503681f, 0.12675297f, 0.03812546f, 0.12157695f, 0.05468034f, 0.02201367f, 0.04866938f, 0.07290247f, 
    0.06250598f, 0.36901888f, 0.30178112f, 0.21627159f, -0.12316158f, 0.02564070f, -0.14172186f, -0.01867191f, 
    -0.00694449f, 0.15103839f, 0.17859757f, -0.05206193f, -0.09961081f, -0.05338574f, 0.03140949f, -0.00141203f, 
    0.02619135f, 0.19736040f, -0.18997073f, 0.04890715f, -0.11884417f, -0.00471014f, -0.00718152f, 0.04334454f, 
    -0.06540750f, -0.07188532f, 0.05098565f, 0.15935569f, -0.32112968f, 0.05000901f, -0.06715361f, 0.13070463f, 
    0.02356687f, 0.17583796f, 0.08854813f, -0.00318965f, -0.03054451f, -0.01297961f, -0.04082417f, -0.02870607f, 
    0.11476639f, -0.08336343f, -0.00836507f, 0.20828867f, -0.04120274f, 0.01577979f, 0.08068987f, -0.05612692f, 
    -0.01006462f, 0.17712046f, 0.16508272f, 0.08342994f, 0.09405790f, 0.01141071f, 0.11100643f, 0.03351227f, 
    0.05034755f, -0.08114085f, -0.18610707f, 0.00088357f, -0.14284912f, -0.02664700f, 0.09713091f, 0.04241545f, 
    -0.05077319f, -0.23344459f, 0.02031824f, -0.38024715f, -0.01448984f, 0.01724293f, 0.04691011f, -0.19971648f, 
    -0.12648806f, -0.11666509f, -0.02825812f, 0.06149698f, 0.19254956f, 0.03076238f, 0.07890373f, -0.05423074f, 
    -0.01727178f, 0.02769865f, 0.08858482f, -0.10977993f, 0.07860274f, 0.04144348f, 0.03026803f, 0.00335173f, 
    0.07753394f, 0.00903341f, 0.12399684f, -0.01785985f, -0.07262465f, -0.09949257f, -0.02771730f, -0.18723179f, 
    0.05891991f, -0.09175118f, 0.08947194f, -0.11631552f, -0.05544531f, 0.15280853f, 0.06213877f, -0.05368746f, 
    -0.03707180f, 0.09485018f, 0.14475846f, 0.03018506f, -0.04766218f, 0.13762935f, 0.02195933f, -0.11926778f, 
    -0.08847249f, -0.18172328f, 0.06611405f, -0.20640090f, 0.27917880f, 0.07366364f, 0.03651422f, -0.07982751f, 
    0.01119054f, 0.03104624f, 0.06679510f, -0.03874983f, -0.08470768f, -0.03897550f, 0.04735359f, -0.05366159f, 
    0.15900776f, 0.14874202f, 0.04204763f, 0.03374868f, -0.01676956f, -0.03547388f, -0.07808783f, 0.04592134f, 
    -0.32187837f, -0.22228694f, -0.07760948f, -0.00223824f, -0.11284601f, 0.05473522f, 0.04372957f, 0.14677978f, 
    0.03591925f, 0.03899856f, -0.15230405f, -0.06080678f, -0.06091064f, 0.03122298f, -0.08015054f, 0.10072830f, 
    -0.01579405f, -0.00685471f, -0.04449296f, 0.04378225f, -0.09675009f, 0.08350664f, 0.13668920f, 0.19689433f, 
    0.18201780f, 0.25408208f, 0.13688871f, -0.00151446f, 0.22872338f, -0.23037581f, 0.18226080f, 0.10567795f, 
    0.26874015f, -0.00541538f, 0.25206175f, -0.01267594f, -0.47643360f, -0.00593895f, 0.04078089f, -0.04868611f, 
    -0.20818378f, 0.12462488f, -0.01905783f, -0.04898490f, -0.01442651f, 0.02596985f, -0.06711038f, 0.03985683f, 
    -0.08741773f, 0.17758405f, -0.03466397f, -0.04014893f, -0.05781468f, -0.12972280f, -0.07537657f, 0.00572668f, 
    0.00515156f, -0.02747784f, -0.02770119f, -0.16851342f, -0.02397865f, 0.22459915f, -0.12279316f, 0.10414241f, 
    0.16378400f, -0.13652813f, 0.00041200f, 0.04047918f, 0.01198907f, 0.07038806f, 0.05113671f, -0.08498367f, 
    -0.07786769f, 0.05233229f, 0.03902229f, -0.05756887f, 0.28826600f, 0.04070496f, -0.05568550f, 0.23991738f, 
    0.00579277f, 0.01712151f, -0.12370293f, -0.13335489f, 0.12263682f, 0.23864639f, -0.07874613f, -0.04110834f, 
    -0.05904390f, -0.05034586f, -0.02759965f, -0.06518222f, -0.05581018f, 0.00307991f, -0.03294189f, 0.04819198f, 
    0.05831074f, -0.04820856f, 0.05932430f, -0.02752599f, -0.00756558f, -0.02884125f, -0.00020278f, 0.02378495f, 
    -0.07730345f, 0.02240632f, -0.06326274f, -0.01036853f, 0.05422929f, 0.00375191f, -0.03287590f, -0.07456483f, 
    0.00679070f, 0.00207391f, -0.07331823f, 0.01736176f, 0.01360980f, 0.00093783f, -0.07215104f, 0.00123356f, 
    0.05752318f, 0.01161472f, -0.01388822f, -0.06757053f, 0.02368807f, 0.05411553f, -0.04079902f, -0.07089349f, 
    0.01553961f, -0.04078038f, -0.06978745f, -0.03977837f, -0.07762132f, -0.02322100f, -0.05709127f, 0.02277551f, 
    -0.07019941f, 0.00870765f, 0.01307055f, 0.00459652f, 0.02103041f, 0.01422453f, 0.00819988f, -0.02589890f, 
    0.03461775f, -0.04296946f, 0.05774264f, -0.02978608f, -0.03409600f, -0.04644627f, -0.00524299f, -0.05598485f, 
    -0.06246205f, -0.04934784f, 0.04371659f, -0.03722332f, -0.00275585f, 0.00753286f, -0.05713313f, -0.04725692f, 
    0.04686618f, -0.03393710f, -0.07697230f, 0.04139376f, -0.04114949f, 0.05955563f, -0.07923761f, -0.03983360f, 
    -0.01661746f, -0.07887974f, 0.04618677f, -0.07295727f, -0.07772734f, -0.00252639f, 0.05616196f, 0.01236997f, 
    -0.05429893f, -0.03447449f, 0.01218496f, 0.05432020f, 0.03258294f, -0.01852087f, 0.05513296f, -0.06125489f, 
    0.02543208f, 0.02048230f, -0.03539085f, -0.05680326f, -0.01092651f, -0.03950152f, -0.02495797f, -0.00619333f, 
    0.02852070f, -0.03694310f, -0.03588672f, -0.04871172f, 0.00689697f, 0.01812787f, 0.05199239f, -0.06297456f, 
    -0.04536363f, -0.03391276f, -0.04369459f, -0.02010175f, 0.05509289f, -0.00908187f, -0.04776533f, 0.01033588f, 
    0.05515204f, 0.00995331f, 0.02354328f, -0.02030361f, 0.03924254f, -0.06513976f, -0.04238437f, -0.01941826f, 
    -0.04015630f, -0.02491522f, -0.02833274f, 0.00996869f, 0.02420299f, -0.04852676f, -0.00667813f, -0.04417947f, 
    0.05845539f, -0.04971354f, 0.04447850f, 0.01556084f, -0.04619750f, 0.03529238f, 0.04648731f, -0.01747785f, 
    -0.02547900f, 0.06070458f, 0.05563156f, 0.03711405f, -0.06578036f, -0.01640017f, -0.04020871f, -0.05631970f, 
    0.02545819f, 0.03170056f, -0.03055695f, 0.04393128f, 0.04283733f, -0.01911124f, -0.06442431f, 0.00390453f, 
    -0.06116008f, -0.03464357f, -0.02052642f, 0.02748439f, 0.00337492f, 0.05637771f, 0.01464926f, -0.07251149f, 
    0.01364550f, -0.02458903f, 0.00480559f, -0.04468586f, -0.01943888f, -0.00036583f, 0.04187320f, 0.03865200f, 
    -0.01378701f, -0.01014526f, -0.05058872f, -0.03698276f, 0.03712896f, 0.01431446f, 0.05626877f, -0.07759666f, 
    0.01994979f, -0.02892955f, -0.04527675f, -0.07617337f, 0.04813827f, -0.00829846f, 0.01210780f, -0.02726676f, 
    0.05048807f, 0.04237622f, -0.02927127f, 0.05945324f, -0.00238730f, 0.02328535f, -0.02399146f, -0.06101720f, 
    0.39396337f, 0.17508143f, 0.25102296f, -0.28953007f, -0.09274509f, 0.02128309f, -0.14016894f, -0.06692187f, 
    -0.05633245f, 0.25113708f, 0.08674673f, 0.35579485f, 0.15027939f, 0.15005855f, -0.03701658f, 0.08665252f, 
    0.00297259f, -0.03821140f, -0.08419781f, -0.07432765f, -0.00273349f, -0.00758594f, 0.11219320f, -0.12087069f, 
    0.33358759f, -0.18400738f, -0.21560061f, -0.19139387f, -0.07483259f, -0.11732003f, -0.05528400f, 0.05058204f, 
    0.04910127f, -0.06018822f, 0.05343345f, 0.05761424f, -0.51926756f, -0.73749077f, -0.36098319f, -0.25164625f, 
    0.27413601f, 0.03889987f, 0.00273291f, -0.04875207f, -0.10499480f, 0.02011279f, 0.21858689f, 0.07286987f, 
    -0.38826561f, -0.35822922f, -0.50415856f, -0.07892554f, -0.04810675f, 0.33650249f, -0.06941238f, 0.14894272f, 
    0.07252490f, -0.01619112f, 0.06619612f, 0.22181043f, -0.42666352f, -0.01525996f, -0.38715050f, 0.02878951f, 
    0.12342703f, 0.07636137f, -0.14033583f, -0.27647576f, -0.02219053f, -0.05793711f, -0.01613085f, -0.05161912f, 
    0.20886369f, 0.09651176f, 0.00028099f, -0.02478343f, 0.33664128f, 0.06126922f, 0.00023062f, 0.03100203f, 
    -0.03284578f, 0.00018114f, -0.00956555f, -0.13061936f, -0.21576689f, -0.11325628f, -0.13168402f, 0.22073394f, 
    0.26041666f, -0.32251894f, 0.10855856f, 0.21385968f, 0.06914416f, -0.04582527f, 0.04803595f, -0.11620644f, 
    -0.43599302f, -0.04391931f, -0.26651311f, -0.18422858f, -0.17470270f, -0.08174584f, 0.00323764f, 0.12544073f, 
    -0.05612294f, 0.03571706f, -0.10824084f, -0.03774377f, 0.17545797f, 0.07914265f, 0.03701549f, 0.08494136f, 
    -0.05688455f, 0.04301211f, -0.01965198f, -0.06267308f, 0.14870471f, -0.08617187f, -0.02778076f, 0.05983641f, 
    0.19546090f, 0.21912889f, -0.11885519f, -0.10242984f, 0.10980944f, 0.17344490f, 0.05431660f, 0.11037239f, 
    0.08752392f, 0.14251679f, 0.21587451f, 0.17053236f, -0.30998582f, -0.30183583f, -0.03765701f, 0.10198386f, 
    0.07561424f, -0.15215018f, -0.07808069f, 0.10027008f, 0.16853830f, 0.20282924f, -0.17561889f, 0.08565283f, 
    0.06730224f, -0.03345186f, 0.16223690f, -0.08912493f, -0.02593786f, 0.03128122f, 0.05730233f, 0.08014636f, 
    -0.07797292f, 0.05415690f, 0.08368432f, 0.00008479f, -0.05604602f, -0.05654943f, -0.10111587f, 0.04230050f, 
    0.22876874f, 0.00962990f, -0.05655350f, -0.02344386f, -0.04839025f, 0.02419194f, -0.14398357f, 0.07862150f, 
    0.04659157f, 0.05846817f, -0.02107192f, 0.02210722f, -0.16258058f, 0.14336625f, 0.14975879f, 0.10721788f, 
    -0.14033568f, -0.01363387f, -0.05831284f, 0.06406213f, 0.48387212f, 0.19147642f, 0.28326827f, 0.31219047f, 
    -0.08948065f, -0.13344598f, -0.13958903f, -0.13925859f, -0.01499322f, -0.10358049f, -0.04087484f, 0.02624681f, 
    0.01481396f, -0.05862543f, 0.00953150f, 0.14408413f, -0.06998614f, 0.03601126f, -0.04999328f, 0.15714583f, 
    0.14962038f, 0.06233294f, 0.10676920f, 0.03435241f, 0.12627858f, -0.01652955f, -0.16964616f, -0.06311804f, 
    0.01193695f, 0.07565282f, 0.05296543f, -0.08148787f, 0.20505580f, -0.08035053f, 0.12050387f, 0.15260404f, 
    -0.23231623f, -0.03165888f, 0.17499803f, 0.14671674f, -0.11100585f, -0.02472024f, -0.01596278f, 0.02775035f, 
    0.02198871f, -0.03330982f, -0.04294276f, -0.07230955f, -0.15425257f, -0.18285109f, 0.08854534f, 0.09292859f, 
    -0.02162754f, 0.06600180f, -0.03910727f, 0.17138895f, 0.05775859f, -0.01603800f, -0.03581419f, -0.03495791f, 
    -0.18744060f, -0.13805291f, 0.00254802f, 0.04989073f, -0.00146701f, -0.00879121f, 0.09104946f, 0.16922386f, 
    0.15072677f, 0.16056851f, 0.08643317f, 0.32949913f, -0.12711139f, -0.27880165f, -0.03614806f, 0.12959862f, 
    -0.07759228f, -0.16865718f, 0.02548925f, 0.13258515f, 0.18849000f, -0.02146582f, -0.00843003f, 0.23912250f, 
    0.19221285f, 0.09747694f, 0.06153522f, -0.07567584f, 0.29670313f, -0.03150317f, -0.03375831f, 0.02092178f, 
    -0.16472033f, -0.36415946f, -0.29169205f, -0.29082680f, -0.10920676f, 0.14175889f, 0.13335882f, 0.09393880f, 
    -0.08333806f, -0.11538247f, 0.08880914f, 0.06363725f, -0.26630893f, -0.03952704f, -0.32891849f, -0.12750536f, 
    0.49959776f, 0.16446108f, 0.05328865f, 0.30618590f, -0.06481298f, -0.02276066f, -0.15668964f, 0.02178806f, 
    0.06331399f, -0.11163895f, -0.12673728f, 0.04047226f, 0.25903645f, -0.04164025f, -0.19645572f, -0.09187674f, 
    0.12800501f, 0.05586769f, -0.03744856f, -0.19629306f, -0.07415075f, -0.06428213f, -0.16955408f, -0.12874646f, 
    -0.13614377f, -0.24297313f, 0.06711553f, 0.11695812f, -0.02897738f, 0.13585852f, -0.03509308f, 0.04940166f, 
    0.02927863f, 0.14523377f, 0.00607248f, 0.06006930f, 0.04562912f, 0.10012829f, 0.13242771f, -0.01975915f, 
    -0.04785544f, -0.33326620f, -0.11900797f, 0.09624072f, -0.11393481f, -0.09320552f, -0.07182626f, -0.20062481f, 
    0.03835421f, -0.07016819f, 0.03290997f, 0.16437091f, 0.00484002f, -0.02219267f, -0.07828860f, 0.18155460f, 
    0.35171255f, 0.23169462f, 0.32278427f, 0.27045959f, 0.13672850f, -0.24425231f, 0.15460071f, -0.11733408f, 
    -0.08549078f, -0.02233533f, 0.09989007f, 0.27216339f, -0.27009255f, -0.02724620f, -0.20080486f, -0.36998212f, 
    0.14035776f, -0.09807909f, -0.26345229f, 0.29352486f, 0.07999409f, 0.17323643f, 0.18432441f, -0.11766813f, 
    0.17159492f, 0.19737059f, 0.22071186f, 0.16579205f, 0.28661841f, 0.26717132f, 0.02957099f, -0.11031856f, 
    0.17471673f, -0.04087962f, -0.02413516f, -0.00977697f, -0.23909971f, -0.17529468f, -0.24893439f, -0.12837534f, 
    0.26711142f, 0.26215762f, -0.10617443f, -0.01082144f, -0.11923537f, 0.01869850f, 0.09262913f, -0.13061491f, 
    -0.00646101f, -0.03789898f, 0.00119124f, -0.04424466f, -0.03559467f, 0.05402793f, -0.00928057f, -0.14112256f, 
    -0.21123880f, -0.04816123f, -0.09195420f, 0.07099698f, -0.01757105f, -0.05029674f, -0.07084325f, -0.12519838f, 
    -0.21173231f, -0.37456518f, -0.10946783f, 0.15456393f, 0.12775087f, 0.00479055f, 0.10911145f, -0.04020798f, 
    -0.02967641f, -0.02541455f, 0.02656728f, -0.01034826f, -0.17884097f, -0.05433821f, -0.20342033f, 0.29273632f, 
    -0.03328853f, 0.05003223f, 0.11727884f, 0.00307728f, -0.03309329f, 0.03558762f, 0.03656005f, 0.06081833f, 
    -0.00930519f, 0.02128781f, -0.19068068f, 0.00423018f, 0.09978395f, 0.00551156f, 0.07610354f, 0.01254554f, 
    -0.01105160f, -0.01832617f, -0.09525838f, 0.08948428f, 0.04570527f, -0.07220302f, 0.05775517f, 0.24827708f, 
    0.02332091f, 0.12118106f, 0.08045976f, -0.09798465f, -0.03370382f, 0.03669397f, 0.02670602f, -0.05581441f, 
    -0.05073508f, -0.29547700f, 0.05854055f, 0.02206105f, -0.04117384f, -0.02285222f, -0.08657500f, -0.04747550f, 
    -0.13684241f, 0.04128284f, 0.16088147f, 0.08251984f, -0.15384893f, -0.04866895f, 0.11712745f, 0.30626020f, 
    0.05085218f, -0.02766994f, 0.11318552f, -0.01985006f, 0.01285197f, 0.13646908f, -0.01969453f, 0.09604093f, 
    0.06029352f, -0.18855450f, -0.02934246f, 0.20388219f, 0.13924663f, 0.00824241f, 0.13958380f, -0.00763833f, 
    0.02496977f, -0.02267988f, 0.02965781f, -0.00724780f, -0.08136345f, -0.02918134f, -0.12770469f, -0.10868762f, 
    -0.16743961f, -0.09515821f, 0.02982702f, 0.01197341f, -0.08071439f, -0.07540590f, 0.00725437f, 0.17682594f, 
    -0.06185723f, 0.45933700f, -0.34601054f, -0.06066430f, 0.09006259f, 0.03087766f, 0.04432136f, 0.08712460f, 
    0.13397726f, -0.00981342f, 0.09485392f, 0.02423123f, 0.01461613f, 0.09847473f, 0.11863032f, 0.24387789f, 
    -0.05737179f, -0.02982132f, 0.07217810f, -0.03252881f, 0.03927999f, 0.15162726f, 0.05591661f, 0.06251844f, 
    0.12795074f, 0.22028160f, -0.18912010f, -0.04444823f, -0.00178258f, -0.04216804f, -0.05528734f, -0.10919624f, 
    0.00195799f, 0.07848286f, -0.05674051f, -0.07200344f, -0.15722094f, 0.12055226f, -0.11539638f, 0.13889647f, 
    0.11277786f, 0.02061254f, -0.06719226f, -0.04009782f, -0.09186371f, -0.04310863f, 0.03937113f, -0.12277577f, 
    -0.11091151f, 0.14019676f, -0.08949718f, -0.00906687f, -0.09537631f, -0.06123263f, -0.09431832f, 0.01388927f, 
    -0.10882702f, 0.00711220f, -0.10701817f, -0.08147762f, -0.13520700f, 0.54041415f, -0.19198509f, 0.20756394f, 
    -0.09204151f, -0.13842310f, -0.03668052f, -0.07445707f, 0.02711821f, 0.00194228f, 0.00171930f, 0.00383482f, 
    0.05662897f, -0.00287011f, 0.02479392f, -0.06110149f, 0.00729901f, -0.04320175f, -0.02133585f, -0.04530869f, 
    -0.01461759f, 0.04298215f, -0.03536614f, -0.06960668f, 0.00656216f, 0.00841320f, -0.06940775f, -0.02722690f, 
    -0.04372140f, -0.06258261f, 0.03375619f, 0.02548429f, -0.04559346f, -0.07595791f, -0.00028262f, -0.06560542f, 
    0.01163552f, 0.04516442f, 0.04307528f, -0.02433890f, -0.02963132f, 0.03213424f, 0.04793741f, -0.06212817f, 
    -0.05401194f, -0.02655944f, -0.04808996f, -0.01331295f, -0.04373338f, -0.01061148f, -0.00636424f, -0.06317616f, 
    -0.02152079f, -0.04273970f, -0.02886022f, 0.00650990f, -0.06195565f, -0.02738577f, -0.03448380f, -0.02109591f, 
    0.04368012f, 0.00900722f, -0.02571635f, 0.06195984f, -0.04246191f, -0.04155304f, 0.04984184f, 0.03549891f, 
    0.01159749f, 0.05899902f, 0.02888853f, 0.03544616f, -0.02281903f, -0.03107965f, -0.02704083f, 0.04373287f, 
    -0.06807455f, 0.05115518f, 0.06094573f, 0.04710839f, 0.01156001f, -0.03272934f, -0.05281761f, -0.00694887f, 
    0.04020095f, 0.05362921f, 0.05173439f, -0.02620420f, -0.07070754f, -0.05554836f, 0.04539416f, 0.03353095f, 
    0.06327343f, 0.04719259f, 0.05985535f, -0.03988183f, -0.02166541f, -0.02414189f, 0.05208581f, -0.06124627f, 
    0.04877406f, 0.06004673f, 0.00859059f, -0.02480014f, -0.05053321f, 0.03928996f, 0.02066389f, -0.01027344f, 
    -0.07856379f, 0.05584357f, -0.00712393f, 0.00568429f, 0.06419720f, 0.05431944f, -0.05974489f, -0.03653766f, 
    -0.06072848f, 0.03454117f, -0.01980616f, -0.02894132f, 0.05562144f, -0.02383606f, 0.05801429f, -0.01817034f, 
    -0.05893898f, -0.01204777f, -0.04728837f, 0.03908917f, -0.05958760f, 0.01545007f, -0.05328728f, -0.07529578f, 
    0.04132226f, -0.02745040f, 0.06126874f, 0.01517278f, -0.04254765f, 0.02906575f, 0.03519940f, 0.06045073f, 
    -0.07614221f, -0.04229995f, -0.01359611f, -0.03542978f, -0.08000205f, -0.01608399f, 0.06133782f, -0.04910830f, 
    0.02810490f, -0.00830259f, -0.00529918f, 0.01526979f, -0.07252174f, -0.02697938f, -0.02862890f, 0.01680111f, 
    -0.06177185f, -0.02462278f, 0.06533930f, 0.01927001f, 0.06255676f, -0.05630812f, 0.04966988f, -0.00351968f, 
    -0.06498441f, -0.03396682f, 0.06015734f, 0.03686461f, -0.02401613f, -0.04791091f, -0.03790326f, 0.03858681f, 
    0.05823737f, 0.01903470f, -0.04976502f, -0.00183943f, 0.02724288f, 0.01408608f, -0.05794690f, -0.06848319f, 
    -0.01752546f, -0.08204623f, 0.00160766f, -0.04348063f, -0.05222169f, -0.01593768f, 0.01359320f, -0.01686371f, 
    -0.07145038f, 0.04486322f, -0.03363660f, -0.06880360f, 0.05665030f, 0.06956224f, -0.04921805f, -0.03058668f, 
    -0.00364082f, -0.04979654f, -0.06531611f, -0.03435421f, -0.03882883f, 0.04654041f, -0.06701279f, -0.05633980f, 
    0.49298742f, 0.32294416f, -0.06024478f, 0.29068899f, -0.02129704f, 0.02934124f, 0.10843975f, 0.05435860f, 
    0.00527932f, 0.06263084f, 0.26357254f, -0.02377872f, 0.09108863f, 0.06948262f, 0.15977436f, 0.18365024f, 
    -0.02743371f, 0.04122223f, -0.05172759f, 0.06079396f, 0.17503415f, 0.00968492f, 0.02581934f, 0.08141813f, 
    -0.28886300f, -0.14170487f, -0.06630868f, 0.09774812f, -0.10644748f, 0.02405552f, 0.05095318f, -0.00780892f, 
    -0.00235226f, -0.11633877f, -0.05697057f, -0.04944264f, -0.19740912f, -0.18309845f, 0.03802795f, 0.09631628f, 
    0.06892342f, 0.09801973f, -0.00728541f, 0.04962468f, -0.16323234f, -0.05988135f, -0.00078292f, -0.11497931f, 
    0.06081265f, 0.05067897f, 0.19232556f, 0.14103773f, 0.02505243f, -0.07898676f, 0.00757283f, 0.03906838f, 
    -0.01290852f, 0.02045215f, -0.12637880f, 0.09499036f, 0.22559364f, 0.02612913f, 0.13114978f, -0.00248893f, 
    0.00852920f, -0.10056232f, 0.05316738f, 0.04862271f, -0.02734144f, -0.00062210f, 0.08735555f, 0.11700449f, 
    0.15893663f, -0.16259736f, 0.07599745f, 0.06294424f, -0.08646859f, -0.18266644f, -0.02568864f, -0.07155769f, 
    -0.23539016f, -0.21956043f, -0.15626751f, -0.04285911f, -0.00793318f, 0.06907536f, 0.03709936f, -0.14151032f, 
    -0.06226628f, -0.00105635f, -0.06055354f, -0.00880255f, -0.09646643f, 0.10718975f, -0.09637675f, -0.01711088f, 
    0.32248133f, -0.12167038f, -0.02178931f, -0.12688558f, 0.07906100f, -0.05900272f, 0.01444282f, 0.02524729f, 
    -0.08390006f, -0.04723858f, -0.07594790f, -0.01964630f, 0.13345440f, 0.04019145f, 0.07653340f, 0.20011543f, 
    -0.09141614f, 0.01389446f, -0.02414059f, 0.04780333f, -0.07130007f, -0.08334841f, -0.05052242f, -0.06319370f, 
    -0.00391418f, 0.10473920f, -0.08208223f, 0.05459974f, 0.04035985f, 0.29552779f, 0.03111359f, 0.40277663f, 
    -0.10993715f, 0.00329153f, 0.25539628f, -0.15858410f, 0.01785020f, 0.00951709f, 0.06153294f, -0.07779278f, 
    -0.18273692f, -0.32439041f, -0.09383414f, -0.07070803f, -0.25452974f, -0.06569681f, -0.17889909f, 0.04563195f, 
    0.08674926f, 0.04106198f, 0.07854372f, 0.20474692f, 0.04721970f, 0.08650447f, -0.05121054f, 0.04059905f, 
    -0.00941724f, 0.06186125f, 0.27631187f, 0.14077766f, -0.27898005f, -0.04604093f, -0.04939374f, -0.01120566f, 
    0.06435946f, 0.08367822f, 0.09203089f, 0.05649910f, -0.09969994f, -0.05885411f, 0.00622486f, -0.19196546f, 
    -0.19470273f, 0.04622407f, 0.00542512f, -0.04930624f, -0.19900298f, 0.27138999f, 0.07852011f, 0.10604728f, 
    0.00512490f, 0.20438218f, -0.00787548f, 0.19645847f, 0.26792353f, 0.24676144f, -0.03060865f, 0.16569106f, 
    -0.10071681f, -0.03204725f, -0.00488664f, -0.08141624f, 0.08238889f, 0.00995832f, 0.07343683f, 0.02963929f, 
    -0.05575940f, 0.02058108f, -0.04829821f, -0.07399761f, 0.02319088f, -0.02877158f, -0.07541978f, 0.02799493f, 
    -0.07012703f, -0.03065071f, -0.06457848f, 0.02335087f, -0.05222887f, -0.02828467f, -0.01145002f, 0.04264481f, 
    0.01149321f, -0.07071208f, -0.00801903f, -0.00252971f, -0.06864411f, -0.03230584f, -0.05527169f, -0.00406094f, 
    -0.04972928f, -0.06642082f, -0.10683708f, -0.02366525f, -0.04398397f, 0.02272484f, -0.04835509f, -0.05417411f, 
    -0.02003086f, 0.03115136f, -0.07281034f, -0.04562863f, -0.09723896f, 0.01973506f, 0.00596574f, -0.04542087f, 
    0.04590233f, -0.04389426f, -0.06097300f, -0.03526228f, -0.01981429f, -0.05429222f, 0.04653293f, -0.01272709f, 
    -0.07192261f, 0.03008024f, 0.01220489f, 0.01684143f, -0.03911711f, -0.00024910f, -0.05958079f, -0.02455868f, 
    0.03029849f, 0.04155245f, 0.04714235f, 0.04201521f, -0.06346995f, 0.03469503f, 0.00693632f, 0.00540298f, 
    -0.02648047f, 0.05453216f, -0.01709761f, -0.01237358f, 0.04502512f, 0.05813560f, -0.04953508f, 0.04944681f, 
    0.02810330f, 0.00676258f, 0.01608633f, 0.02330373f, -0.06894889f, -0.02456255f, -0.07825115f, -0.02794819f, 
    -0.08769718f, 0.02296135f, -0.01315329f, 0.02430343f, -0.03292689f, -0.09939861f, -0.03913586f, -0.04663347f, 
    -0.03767984f, 0.01838677f, 0.02548579f, 0.00423642f, 0.04415036f, 0.01145040f, -0.07556605f, -0.01101019f, 
    -0.08919503f, 0.03690271f, -0.06211154f, 0.02560795f, -0.09747624f, 0.01169064f, 0.04013911f, -0.00711973f, 
    -0.03030664f, 0.05331993f, -0.01749118f, 0.00400966f, 0.02630480f, -0.07359096f, -0.02204826f, 0.00784561f, 
    0.02993608f, -0.03602580f, -0.09400901f, 0.02796910f, 0.03564328f, 0.03787253f, 0.04809701f, -0.04304887f, 
    0.02064767f, 0.03557223f, -0.04352795f, -0.00387741f, -0.02601583f, -0.04282302f, -0.03442771f, -0.02533709f, 
    -0.00305165f, -0.00313570f, 0.01550443f, 0.00471122f, 0.03550186f, -0.02892518f, 0.00977640f, -0.00503769f, 
    -0.06624635f, -0.05775708f, 0.03200966f, 0.03050439f, -0.07919896f, 0.01446725f, -0.07671624f, -0.00023693f, 
    -0.00376303f, -0.07804324f, 0.05093829f, 0.02862534f, 0.01220030f, 0.04596676f, 0.01455149f, 0.02937200f, 
    0.02878625f, -0.03596372f, -0.02521731f, -0.03128635f, -0.05494446f, -0.06553289f, 0.02671070f, -0.05572869f, 
    -0.05207542f, 0.02705635f, -0.06386277f, 0.01768202f, -0.01642284f, -0.05458670f, 0.01642988f, 0.01162403f, 
    -0.04850841f, 0.02348548f, -0.04828753f, -0.01213797f, -0.00913024f, 0.01548510f, 0.03198339f, 0.01804414f, 
    0.04147300f, -0.04825775f, -0.02853178f, 0.01406818f, -0.01025345f, 0.04867063f, 0.03351985f, -0.05866685f, 
    0.01939244f, -0.01827155f, 0.02773256f, -0.07865304f, 0.00038974f, -0.08801685f, 0.02790037f, -0.06218816f, 
    0.01789922f, -0.31893578f, -0.26726735f, 0.20381588f, 0.00883281f, -0.11060568f, 0.02137050f, -0.00952025f, 
    0.13213247f, 0.05948829f, -0.00492605f, -0.03742649f, -0.18645303f, -0.41356689f, -0.08137094f, -0.15438060f, 
    -0.03062075f, -0.10477950f, -0.13902763f, -0.00860944f, 0.01073248f, 0.00721489f, 0.01849430f, -0.08559381f, 
    0.18870495f, 0.38113156f, 0.32670617f, 0.01226150f, -0.17436665f, -0.09205844f, 0.04891289f, 0.13757622f, 
    -0.10182696f, -0.03483742f, 0.01961206f, -0.01068875f, 0.27527016f, 0.09086458f, 0.44203678f, -0.09247620f, 
    -0.01477928f, -0.06706835f, 0.14698990f, 0.06009853f, 0.01432734f, 0.02280708f, -0.07323193f, -0.01805060f, 
    0.36012152f, 0.17215997f, 0.18717332f, 0.19144118f, 0.06287946f, 0.00392920f, 0.04583633f, -0.16428353f, 
    0.03952599f, 0.00743737f, -0.09694898f, -0.14777228f, 0.21766365f, 0.25369194f, 0.11867178f, 0.07003693f, 
    0.02505063f, 0.11255068f, 0.16019350f, 0.13962358f, 0.00442019f, -0.13834473f, -0.06572097f, -0.18724479f, 
    -0.07966361f, -0.06754507f, -0.10118714f, -0.01334714f, 0.04026654f, -0.04343482f, 0.11815425f, 0.04556864f, 
    0.02628386f, 0.01785841f, -0.05374861f, -0.00292474f, 0.31051469f, 0.15217230f, 0.12547451f, -0.18218526f, 
    0.11234123f, 0.08767167f, 0.13480556f, 0.07231709f, -0.02650577f, 0.06924316f, 0.08516955f, -0.05868730f, 
    0.02945640f, 0.09014013f, -0.02603942f, -0.02376873f, 0.03478149f, 0.15898116f, -0.08308642f, -0.02916154f, 
    0.03070707f, -0.06152011f, 0.03505268f, 0.09871454f, -0.27900788f, -0.28737813f, -0.16906340f, -0.10820866f, 
    0.03259899f, 0.02012885f, -0.00245217f, 0.01334563f, 0.13258578f, -0.05438956f, 0.14226900f, 0.10193092f, 
    0.25125900f, -0.27952951f, 0.25770295f, 0.09402714f, -0.14070913f, -0.06180944f, -0.05398257f, 0.11127710f, 
    -0.00564130f, -0.05233094f, 0.04675006f, 0.01619736f, 0.02045315f, 0.21190746f, -0.17138904f, 0.11570569f, 
    -0.02835969f, 0.11450770f, 0.12879522f, 0.10394556f, 0.03217154f, 0.01841470f, -0.18402156f, -0.04050789f, 
    -0.13370933f, -0.07750405f, 0.11458114f, 0.04727983f, 0.03664169f, 0.04206965f, -0.06331170f, -0.07136805f, 
    -0.02478644f, 0.12104316f, -0.06401851f, -0.08634810f, 0.19694771f, 0.08149064f, -0.02168306f, -0.02567054f, 
    0.04205677f, -0.07764032f, 0.06962797f, -0.03350600f, 0.06280611f, -0.03220175f, -0.08838011f, 0.05710742f, 
    -0.16177829f, 0.00138479f, -0.06762461f, -0.21154745f, 0.00005524f, 0.04803928f, 0.04317904f, 0.00166022f, 
    0.06778686f, -0.09716644f, -0.00923989f, -0.04867448f, -0.31251922f, -0.74105084f, -0.44403103f, -0.50564587f, 
    -0.00850848f, -0.11825021f, -0.16208467f, 0.01877585f, 0.02119115f, -0.09113272f, 0.01043995f, 0.00614173f, 
    0.15841573f, 0.03910221f, 0.07627966f, 0.16115092f, -0.04933104f, -0.16025427f, 0.05668980f, -0.16742735f, 
    0.05115528f, 0.16388889f, -0.01829967f, -0.06424537f, -0.16790181f, -0.09754203f, -0.00487768f, 0.04609274f, 
    -0.00620564f, -0.08824530f, -0.05533700f, 0.06098787f, 0.04254197f, -0.02965996f, -0.07234447f, -0.00069736f, 
    0.06696606f, 0.03865612f, -0.13410251f, -0.34744209f, 0.14071107f, 0.07522451f, 0.09886456f, -0.13573310f, 
    -0.07574740f, -0.08782183f, -0.02410310f, -0.13160831f, 0.20774698f, 0.13757716f, 0.09107890f, -0.18788317f, 
    0.21052755f, 0.00488018f, 0.13785547f, 0.01663502f, 0.03219355f, -0.03543425f, -0.01297795f, -0.04189602f, 
    0.12847626f, 0.05401279f, 0.16766395f, -0.03374976f, -0.08931226f, -0.15207811f, -0.03437312f, -0.10821822f, 
    -0.04908736f, -0.12047298f, -0.08913811f, -0.08990585f, -0.12955612f, 0.06617778f, 0.08599741f, -0.11264376f, 
    0.08337434f, -0.00803444f, -0.11478839f, -0.00704578f, -0.03540538f, 0.06619853f, -0.01808286f, -0.08462851f, 
    0.03614942f, -0.15220600f, -0.15189339f, -0.00148122f, -0.07507131f, -0.05115937f, 0.06221382f, -0.11588492f, 
    0.01910003f, -0.14513908f, -0.10367317f, -0.06934291f, -0.00061084f, 0.02506683f, -0.02812476f, -0.21735416f, 
    0.00214041f, 0.05743271f, -0.18464293f, -0.09168614f, -0.03560574f, -0.04249452f, -0.07281840f, -0.04329619f, 
    -0.22176635f, -0.21049649f, 0.20439850f, -0.02446562f, 0.02020337f, 0.11106439f, 0.01952503f, -0.07409142f, 
    -0.02519725f, -0.07494164f, -0.02988940f, -0.04666194f, -0.09229648f, -0.10557523f, -0.03441188f, 0.13971250f, 
    -0.10389309f, 0.00551205f, -0.00545829f, 0.03948879f, -0.03296959f, -0.03465362f, 0.09536116f, -0.01425505f, 
    0.02619869f, 0.22226945f, 0.22979221f, -0.17914112f, -0.19173089f, -0.20067461f, 0.09385169f, 0.04939384f, 
    0.15723453f, -0.03017808f, -0.13993141f, -0.23304762f, -0.24759817f, 0.01231392f, -0.00631727f, -0.20605414f, 
    -0.00138841f, -0.02207983f, -0.14720611f, -0.29101244f, 0.09608904f, 0.08072701f, -0.12831980f, 0.02148441f, 
    0.00566060f, -0.12761031f, -0.01922875f, -0.12696914f, -0.06806665f, 0.01122109f, 0.03471099f, -0.09046391f, 
    -0.18150045f, -0.04809957f, -0.14166090f, -0.12573227f, -0.07257704f, 0.20287600f, -0.33966607f, -0.09015639f, 
    0.17698310f, 0.01438921f, -0.22492565f, -0.12592922f, 0.04736939f, 0.00376257f, 0.01499960f, -0.04453955f, 
    -0.43871135f, 0.04453015f, 0.07049519f, -0.11981849f, -0.06455228f, 0.06747567f, -0.07229806f, 0.10878837f, 
    -0.00789932f, -0.08614913f, -0.13493074f, -0.07421809f, -0.06642194f, -0.17660810f, 0.03556907f, 0.23843010f, 
    -0.06406826f, -0.05152793f, 0.01527120f, -0.02289972f, -0.02017601f, 0.03330833f, 0.03790346f, -0.00428585f, 
    -0.01945203f, 0.27667379f, 0.12019096f, 0.16511399f, 0.00312493f, -0.11884253f, 0.09074927f, -0.11744084f, 
    0.18288703f, 0.16309215f, 0.05909752f, 0.08631138f, -0.03799802f, 0.13232522f, 0.03275651f, -0.20675363f, 
    -0.04512111f, -0.08331987f, -0.04019428f, 0.08806569f, -0.12983201f, -0.05985205f, -0.14223330f, -0.07283884f, 
    -0.24667098f, -0.28377566f, -0.18393716f, -0.19706760f, 0.09307178f, -0.11752445f, 0.00044390f, -0.13674118f, 
    0.04335667f, 0.06876606f, -0.06874046f, 0.07157826f, 0.07341956f, 0.09039027f, -0.00419262f, -0.05489791f, 
    -0.03478934f, -0.11230373f, 0.14877327f, 0.01747041f, 0.03857504f, 0.04317559f, 0.00699298f, -0.01332689f, 
    -0.01187042f, 0.05453775f, 0.15743618f, 0.03177440f, 0.06387958f, -0.01968238f, -0.00631075f, 0.19529940f, 
    -0.06944878f, -0.16262804f, -0.12441479f, -0.19013739f, 0.07329556f, -0.06574216f, 0.16228950f, 0.00204697f, 
    0.12173062f, 0.21574910f, 0.07562005f, 0.21683286f, -0.10630546f, 0.09114692f, -0.02400219f, -0.15100656f, 
    -0.03347277f, -0.23971069f, 0.02898838f, -0.21269086f, 0.03846402f, -0.02720039f, 0.18319318f, 0.06051615f, 
    -0.05847152f, 0.20544221f, 0.13519865f, 0.15383127f, -0.05942805f, -0.08460909f, -0.05171438f, -0.09951712f, 
    0.07742056f, 0.14712417f, 0.04856167f, -0.02599201f, 0.10370536f, -0.01764761f, 0.01596314f, 0.06287353f, 
    0.11547984f, -0.27272257f, 0.01015105f, -0.04329616f, 0.00242937f, -0.04017483f, 0.13118608f, 0.30067691f, 
    0.04651310f, 0.02180734f, 0.00167633f, -0.14327864f, -0.01865302f, 0.05571270f, -0.02667777f, -0.18775389f, 
    -0.13999455f, -0.09460443f, -0.01939491f, -0.01774975f, 0.08095186f, 0.00786687f, 0.13699637f, 0.16651617f, 
    0.17930663f, 0.29833227f, 0.03152024f, -0.14714135f, 0.14974006f, -0.04206572f, 0.10590682f, 0.23815177f, 
    0.10082626f, -0.06349529f, 0.24933927f, 0.07323591f, -0.25844711f, 0.03727328f, 0.21718636f, -0.08836997f, 
    -0.27447176f, 0.12782617f, 0.14107500f, -0.01995820f, 0.16974603f, 0.13618478f, 0.02508212f, 0.00770514f, 
    -0.03634939f, 0.14135541f, 0.00107171f, -0.05215717f, -0.05599124f, -0.05191676f, -0.01734434f, -0.07380360f, 
    0.02719051f, -0.06973587f, -0.01621857f, -0.34365949f, 0.04003468f, 0.21952984f, 0.05406181f, 0.19344115f, 
    0.18354243f, 0.10631132f, 0.04096361f, 0.08707877f, 0.23477159f, 0.05123700f, 0.22959879f, 0.09116256f, 
    -0.14842334f, -0.07565083f, 0.00128104f, 0.07352952f, 0.11016847f, -0.08854402f, -0.00297022f, 0.04586620f, 
    -0.10370359f, -0.17978747f, -0.14471576f, -0.18133855f, 0.14705363f, 0.31009969f, -0.02868673f, -0.01050772f, 
    -0.22317320f, -0.05641675f, -0.02476161f, -0.14056209f, -0.02019107f, 0.01332428f, 0.03620170f, -0.03736797f, 
    0.46117747f, -0.10645998f, -0.38229129f, 0.37091061f, 0.10364837f, -0.37323862f, 0.21634533f, -0.10913799f, 
    0.06428256f, 0.17073308f, 0.07160393f, 0.06513147f, -0.27058202f, -0.15061189f, -0.18616655f, 0.27021822f, 
    -0.11741302f, 0.03128137f, -0.12108701f, 0.00091862f, 0.07534722f, -0.04572467f, 0.05736426f, 0.11629208f, 
    0.21916576f, 0.18390435f, -0.00867082f, -0.25254947f, 0.06983491f, -0.00120512f, 0.23941191f, 0.09980894f, 
    -0.09464607f, 0.10406647f, 0.09825819f, -0.03462554f, 0.07386027f, 0.01620079f, -0.00634811f, -0.04993318f, 
    0.03524881f, 0.09544963f, 0.05767875f, 0.11405195f, -0.02851295f, 0.06417214f, -0.06477617f, 0.06371668f, 
    0.28891879f, 0.14129539f, 0.41760629f, 0.11820275f, 0.21800967f, -0.00401550f, -0.01029134f, -0.05781543f, 
    -0.16378263f, -0.05134328f, -0.06718940f, 0.18660463f, 0.07152458f, 0.14717059f, 0.05193261f, -0.05317900f, 
    0.07367975f, 0.12454289f, -0.04847385f, -0.00738808f, 0.02657576f, -0.08078162f, 0.14948367f, 0.04507239f, 
    -0.31080812f, -0.00866995f, -0.25858253f, -0.08451308f, 0.01310252f, -0.13460320f, 0.07292870f, 0.02443665f, 
    0.00278592f, -0.28505957f, -0.00874108f, -0.06715678f, 0.29081902f, 0.15376107f, 0.16815253f, -0.22526033f, 
    -0.01477276f, 0.04588189f, -0.02960691f, 0.11224969f, 0.03192046f, -0.05258217f, -0.01776616f, -0.10823987f, 
    0.17399961f, -0.17967138f, -0.01709813f, -0.10608360f, 0.05157077f, 0.07816429f, -0.00092633f, -0.17250378f, 
    0.07826955f, -0.08669703f, -0.05534990f, 0.02707065f, -0.17652446f, -0.31592035f, -0.07805973f, 0.08966425f, 
    -0.24023300f, -0.01576191f, -0.13223328f, -0.17825894f, -0.03152728f, 0.08825695f, 0.05906193f, 0.02747395f, 
    0.20044170f, 0.00961339f, 0.07788642f, 0.06443045f, 0.09380507f, -0.10823479f, -0.02158455f, 0.00759350f, 
    0.03657563f, 0.04498840f, 0.00058037f, -0.07817358f, 0.38518605f, 0.13008562f, -0.01665797f, -0.03870479f, 
    0.27843633f, -0.19470263f, -0.01518350f, 0.04553245f, 0.01380835f, 0.01799146f, -0.03766041f, 0.02058254f, 
    -0.05711905f, -0.18363649f, 0.03195306f, 0.41929874f, 0.08255891f, -0.02721589f, 0.11764089f, -0.00019528f, 
    -0.06259098f, 0.14310919f, 0.10412037f, 0.18844211f, 0.04988940f, 0.09404400f, -0.16777812f, -0.09486020f, 
    -0.07011565f, 0.16615805f, 0.10861179f, 0.01912804f, -0.00107518f, -0.02764042f, 0.02857048f, -0.01615711f, 
    -0.07385024f, 0.27867267f, -0.16542201f, -0.06864906f, 0.03837229f, 0.04600592f, 0.03205949f, 0.10625597f, 
    -0.03058171f, -0.08303634f, 0.11459198f, 0.01113325f, -0.28238532f, -0.29858947f, -0.08935519f, -0.03381561f, 
    -0.11483975f, -0.05283407f, 0.08782165f, -0.03560125f, -0.19875628f, 0.03103483f, 0.06554197f, -0.14685154f, 
    -0.19306047f, -0.27805266f, -0.10027704f, -0.18799411f, -0.10966208f, 0.06931505f, -0.03400778f, 0.05522398f, 
    0.17670196f, 0.16131127f, 0.06333272f, -0.01711562f, 0.20016222f, -0.26330295f, -0.05087361f, -0.04632545f, 
    -0.00687799f, 0.03598610f, -0.00017511f, -0.04945864f, 0.10261371f, -0.04498659f, 0.20635165f, 0.20885654f, 
    -0.03927078f, 0.15000515f, 0.18081045f, 0.14334947f, -0.01251968f, 0.04266277f, -0.25674337f, -0.00964290f, 
    0.06521495f, -0.03726284f, 0.01007375f, -0.01786491f, 0.00069564f, -0.12594347f, 0.14305849f, -0.09643313f, 
    -0.04162532f, -0.07788403f, -0.03259691f, -0.05775861f, -0.03718963f, -0.04585619f, -0.01973476f, 0.10430839f, 
    -0.06405022f, -0.17800950f, -0.01921023f, -0.01951750f, -0.11901917f, 0.04237123f, 0.15497792f, 0.16333157f, 
    0.09128476f, 0.13738333f, 0.26155776f, 0.29292604f, -0.05593719f, -0.10173984f, 0.00496237f, 0.14238429f, 
    -0.06771041f, -0.07415175f, 0.16880211f, 0.05231180f, 0.03013275f, 0.04161351f, -0.04818026f, 0.20811087f, 
    0.03250995f, 0.18604407f, -0.06203008f, 0.01146047f, 0.26856172f, 0.04367963f, 0.02268136f, -0.03621953f, 
    -0.16126978f, -0.30047545f, -0.26700541f, -0.35478193f, -0.12826616f, 0.17082395f, -0.02435932f, 0.07739107f, 
    0.10095633f, -0.15552954f, 0.06522583f, -0.02070660f, -0.17387162f, -0.07036039f, -0.21757501f, -0.08922260f, 
    0.37221038f, 0.27776235f, 0.04961455f, 0.26935908f, 0.05323926f, -0.05700605f, 0.00070384f, 0.15046711f, 
    0.10381768f, 0.04253046f, -0.00256701f, -0.09538391f, 0.17281908f, -0.07957750f, -0.10783528f, -0.05401953f, 
    0.03284879f, 0.04639770f, -0.01434164f, 0.00260487f, -0.04883194f, -0.04380446f, -0.15321727f, -0.10721494f, 
    0.20823054f, -0.19022048f, 0.27256566f, 0.20349443f, -0.07576438f, 0.07233974f, -0.08823080f, -0.00151693f, 
    -0.04188309f, 0.08174451f, -0.01301133f, 0.14888974f, -0.18820150f, 0.06035809f, -0.10657080f, -0.02189386f, 
    -0.05571667f, -0.13483308f, -0.10255781f, 0.04329803f, -0.09151067f, -0.26495576f, 0.01120379f, -0.04055440f, 
    0.05371624f, -0.16022815f, 0.03021922f, -0.07206902f, 0.04766081f, -0.04167179f, 0.06568627f, 0.14346419f, 
    0.23916855f, 0.22551739f, 0.17893131f, 0.25233984f, 0.20757526f, 0.05575116f, 0.28600913f, -0.08244199f, 
    -0.08692160f, -0.14742838f, -0.07532362f, 0.19819702f, -0.25971204f, 0.00570402f, -0.17528230f, -0.18963552f, 
    0.32751679f, -0.25637448f, 0.09694006f, 0.27138770f, -0.07240718f, 0.03717448f, -0.04969842f, -0.16312155f, 
    0.21614863f, 0.04709852f, 0.08676818f, 0.32408482f, 0.08239093f, 0.07857851f, 0.19584915f, -0.05339700f, 
    0.22264394f, 0.04057914f, -0.06853300f, 0.08892722f, -0.27456850f, -0.07928221f, -0.04972109f, -0.17149459f, 
    -0.14292495f, -0.09002191f, 0.13799189f, 0.13709368f, -0.12943351f, -0.02698356f, 0.03638928f, -0.11603239f, 
    0.10874218f, 0.10852638f, 0.04508755f, 0.03485227f, 0.06941114f, -0.00835405f, 0.03202479f, 0.02612251f, 
    0.08892915f, -0.17993140f, -0.05310070f, -0.09456959f, -0.08534380f, -0.07321693f, -0.07027214f, 0.13733138f, 
    0.00087311f, 0.22082457f, -0.04981179f, -0.09123407f, -0.03546013f, -0.05348857f, 0.06567085f, -0.03622162f, 
    0.01061734f, 0.01509828f, -0.03532960f, -0.01205461f, 0.15751132f, 0.08138750f, 0.09322451f, -0.31260303f, 
    0.09411144f, 0.02721622f, -0.03117979f, 0.09285701f, 0.02710498f, -0.08568333f, 0.02148675f, -0.13868898f, 
    -0.02564975f, 0.04894690f, 0.06049639f, 0.02640306f, -0.06062470f, -0.00139211f, -0.06300015f, -0.15088753f, 
    0.04299650f, -0.11085258f, -0.12037953f, -0.09424318f, 0.01814278f, 0.04861761f, -0.00175000f, -0.13408282f, 
    0.03164676f, -0.03502405f, -0.07224026f, 0.16215427f, 0.03669669f, -0.07182282f, 0.03868128f, -0.16232920f, 
    -0.04863009f, -0.04337240f, -0.30107826f, -0.08753748f, -0.06872886f, -0.21263136f, 0.05239561f, -0.06606587f, 
    -0.02312850f, 0.05927701f, -0.09701622f, 0.01651930f, -0.01356675f, -0.00205273f, -0.12146294f, -0.37528542f, 
    -0.01452562f, 0.19423866f, -0.10527588f, -0.02391915f, -0.03750572f, -0.03932977f, 0.04081665f, -0.19154829f, 
    0.11135405f, 0.04565624f, 0.13343476f, -0.14465488f, -0.15137924f, 0.08821365f, 0.07893196f, 0.09553223f, 
    -0.01457492f, -0.06964922f, -0.02072276f, -0.06641558f, -0.06277017f, 0.02364430f, 0.03076252f, 0.00768873f, 
    -0.09779817f, 0.04140063f, -0.03918330f, 0.02205819f, -0.06661557f, -0.01034749f, -0.04183780f, 0.02004810f, 
    0.21296005f, -0.19367053f, 0.18577950f, -0.15158924f, -0.20729335f, -0.09640621f, 0.08000755f, 0.06359444f, 
    0.08275463f, 0.02071198f, -0.07342666f, -0.14684036f, -0.24408603f, 0.09676099f, -0.01264398f, -0.22417830f, 
    -0.17863533f, 0.06546352f, 0.07936311f, -0.03990122f, 0.14862421f, -0.03796328f, -0.14601059f, -0.19979800f, 
    -0.07935335f, -0.20102845f, 0.16806698f, -0.11390866f, -0.14020713f, -0.12113335f, 0.02375455f, -0.07143081f, 
    0.10011765f, -0.20198846f, -0.09373008f, -0.03731333f, 0.11409710f, 0.03011440f, 0.10899017f, -0.09213407f, 
    0.08262492f, 0.13153574f, -0.02779371f, 0.12640005f, 0.18661444f, 0.12130454f, 0.00220755f, -0.01541251f, 
    -0.44292656f, -0.10077052f, 0.00943025f, -0.09351235f, 0.08861113f, 0.08667270f, -0.04851701f, -0.02642250f, 
    -0.01815031f, -0.17139390f, 0.03819174f, -0.15098357f, 0.05406863f, -0.36069271f, 0.09845319f, 0.02573866f, 
    -0.08285206f, -0.11941708f, -0.01426490f, -0.02206399f, -0.02707515f, 0.00756451f, -0.02258464f, -0.07113968f, 
    -0.05787819f, 0.00836178f, 0.01560750f, 0.01189552f, 0.05071182f, 0.02450073f, 0.05188834f, -0.01557047f, 
    0.03893161f, -0.06192205f, 0.05313275f, -0.06450235f, -0.05166804f, -0.06367801f, 0.01513664f, -0.05683536f, 
    -0.06484678f, -0.01843541f, -0.04729404f, -0.02891723f, 0.01106732f, 0.06351534f, 0.03817589f, 0.03947899f, 
    -0.07038587f, -0.06966341f, -0.01788256f, -0.01731785f, -0.06004584f, -0.00739024f, -0.00564381f, 0.05487982f, 
    -0.03686491f, -0.04238741f, 0.03890914f, 0.01333390f, 0.00619903f, 0.01997475f, -0.05569147f, -0.06046496f, 
    -0.03058833f, 0.02010522f, 0.00453241f, 0.06975838f, 0.03984337f, -0.05058084f, -0.05028272f, -0.04690922f, 
    0.06411952f, 0.01982466f, 0.02636532f, -0.05638981f, -0.03873938f, -0.02594651f, 0.03873382f, -0.00150293f, 
    -0.06542001f, 0.01138703f, 0.05290461f, -0.06596476f, -0.04322015f, -0.00276800f, -0.06477942f, -0.04959180f, 
    0.01065136f, -0.03281424f, -0.06975502f, -0.05504330f, 0.01100319f, -0.05438324f, -0.05315037f, -0.02101893f, 
    -0.06494036f, 0.04343075f, 0.03671803f, 0.04527660f, -0.03231668f, -0.06814981f, -0.00592833f, -0.06298201f, 
    -0.03332298f, -0.06632782f, 0.07076401f, 0.01103718f, -0.04062133f, 0.01963043f, 0.03771833f, 0.03836140f, 
    0.00650380f, -0.02856884f, -0.01192978f, -0.05988735f, 0.00995052f, -0.03806762f, -0.06562365f, 0.01012582f, 
    -0.06379871f, -0.03011012f, -0.04349344f, -0.03780702f, -0.00035423f, -0.01152587f, -0.01917931f, -0.06145675f, 
    -0.00513607f, -0.01034741f, -0.02319696f, 0.01821305f, -0.07072984f, -0.05918350f, -0.02486873f, 0.03077781f, 
    -0.05480409f, 0.05430462f, -0.03070617f, 0.05192178f, -0.02939900f, -0.03416171f, -0.06608462f, -0.06159521f, 
    -0.04557166f, -0.06960407f, -0.02535104f, 0.06291624f, 0.05890066f, -0.05798209f, -0.06220657f, -0.06277881f, 
    -0.04452391f, 0.05293759f, -0.03680462f, -0.04902880f, -0.06680340f, -0.05496738f, 0.00641069f, -0.04913837f, 
    -0.01609370f, -0.04976241f, 0.03447048f, 0.03965594f, 0.00333318f, 0.04538333f, -0.05284160f, -0.02656562f, 
    -0.03847906f, 0.03837498f, -0.04844757f, 0.01882087f, -0.01237155f, -0.01234928f, -0.05645480f, 0.02544742f, 
    0.03983250f, -0.02417233f, 0.00232568f, -0.03378331f, -0.06874634f, 0.03315452f, 0.00438031f, 0.04026916f, 
    0.00144694f, -0.00473940f, 0.01694735f, -0.04403708f, 0.02751388f, -0.05847814f, -0.03975916f, 0.05082117f, 
    -0.05673042f, -0.03535913f, 0.00417644f, 0.05068547f, -0.05553452f, -0.04390365f, 0.06191381f, 0.04511084f, 
    0.04847392f, 0.05191109f, 0.02493760f, -0.00977074f, -0.01757840f, 0.03971791f, -0.00219160f, -0.01372637f, 
    -0.00820505f, 0.05462445f, 0.07131136f, 0.02799601f, -0.02986940f, -0.05104255f, 0.07170292f, -0.01960256f, 
    -0.38149408f, 0.26810846f, 0.27222154f, -0.27259794f, -0.04707130f, 0.02086317f, -0.19972554f, 0.16148101f, 
    0.03901699f, 0.01286576f, 0.00950348f, 0.16908479f, 0.01469337f, -0.01781792f, -0.14517801f, 0.01237523f, 
    -0.09702903f, -0.02983411f, 0.08489651f, -0.08356380f, -0.13803269f, -0.04632452f, -0.02286926f, 0.01547548f, 
    0.03106546f, 0.19856118f, 0.00921344f, 0.08674793f, 0.00242237f, 0.02456007f, -0.13064538f, 0.04122844f, 
    0.16146310f, 0.12322581f, -0.05267525f, 0.08389815f, -0.15413611f, -0.08927183f, -0.17612903f, 0.10884343f, 
    -0.01377461f, 0.07110330f, -0.05012751f, 0.03189026f, 0.00507703f, 0.07930925f, 0.20419799f, 0.09808246f, 
    -0.11411553f, 0.02325053f, -0.15287945f, 0.00706732f, 0.02229980f, 0.01008683f, -0.08792318f, 0.04109176f, 
    0.00024429f, 0.04663143f, 0.18323724f, -0.05761881f, -0.06152297f, -0.02773786f, -0.09818762f, 0.00735076f, 
    -0.01149847f, -0.11526850f, -0.01642598f, 0.05651073f, -0.07922554f, -0.00030045f, 0.04834193f, 0.04918795f, 
    0.01175411f, 0.02846011f, -0.00932162f, -0.04594330f, 0.14032245f, 0.28392136f, 0.00798468f, 0.00415432f, 
    0.03104503f, 0.10544237f, 0.03121566f, -0.10859638f, 0.10620650f, 0.02590141f, -0.04140102f, 0.10094535f, 
    0.04463163f, -0.12381450f, 0.16917247f, 0.04614512f, 0.04195150f, 0.00707919f, -0.00995997f, 0.04952817f, 
    -0.37991175f, 0.40735954f, 0.01332838f, -0.03934930f, -0.10276412f, -0.17649582f, 0.07111658f, -0.05712009f, 
    0.01365881f, 0.02131524f, 0.08002650f, -0.02805997f, -0.15969320f, 0.03151704f, -0.10466725f, 0.00873618f, 
    0.07326978f, -0.06542531f, -0.02741481f, 0.00471468f, -0.04926679f, 0.06569300f, 0.03203358f, -0.12538199f, 
    -0.37574705f, -0.02059392f, -0.09477236f, 0.30817103f, 0.07189387f, 0.16579574f, 0.10495402f, -0.05154542f, 
    -0.16160342f, 0.01749163f, -0.14946532f, 0.11206575f, 0.16220854f, -0.13461365f, 0.14642633f, 0.06256563f, 
    -0.18795356f, -0.11186046f, -0.19112997f, 0.06301220f, -0.04467253f, 0.03305386f, 0.07790891f, -0.07461540f, 
    -0.05196729f, -0.03081832f, 0.00957822f, -0.02593550f, -0.04288560f, 0.01033557f, -0.01785148f, 0.08131173f, 
    -0.01185516f, -0.08168236f, 0.03183350f, 0.18093270f, -0.08456320f, -0.35655239f, 0.19459754f, 0.19383582f, 
    0.04848959f, 0.02284005f, 0.12298387f, -0.01535848f, -0.13174185f, -0.04891556f, 0.03147522f, -0.00901029f, 
    0.14950460f, 0.04840010f, -0.12426812f, 0.07361054f, -0.04698392f, 0.00119920f, 0.12469221f, 0.03298359f, 
    -0.08151994f, 0.08864037f, -0.02487713f, 0.04236361f, -0.18440740f, 0.04413860f, 0.15730444f, 0.09590920f, 
    0.03460835f, 0.13850336f, 0.08974697f, 0.00584267f, -0.03065146f, -0.00958016f, -0.06198505f, 0.05216610f, 
    0.28038633f, 0.06060122f, -0.02465138f, -0.16350371f, 0.07615010f, -0.03512105f, -0.10468528f, -0.16210449f, 
    -0.10150526f, 0.09516858f, -0.01189219f, -0.03014444f, 0.21961945f, 0.04698823f, -0.00906008f, -0.05668965f, 
    0.00283132f, -0.06448514f, -0.04628154f, -0.02412812f, 0.02153300f, 0.07564809f, 0.06369581f, -0.14073795f, 
    -0.12048030f, -0.16277337f, -0.00067796f, 0.09159335f, 0.09098386f, -0.07741338f, -0.09077229f, 0.01098200f, 
    -0.07608667f, -0.11173076f, -0.08617408f, 0.05343814f, -0.16853973f, 0.09216905f, 0.15813641f, 0.15865283f, 
    0.01793837f, 0.01239259f, 0.03197414f, 0.09694079f, 0.06455196f, 0.05280478f, 0.03862158f, 0.09796625f, 
    0.07721673f, -0.06352507f, -0.01139274f, 0.10800979f, -0.02806799f, -0.04639379f, -0.05989460f, 0.11350125f, 
    0.03665271f, -0.03656382f, 0.00290807f, 0.05050416f, -0.19759257f, -0.09764818f, -0.02602828f, 0.03683507f, 
    0.05061525f, -0.00060712f, -0.05765219f, 0.13351947f, -0.03798513f, -0.03309050f, 0.06756483f, 0.00402762f, 
    -0.00063028f, 0.00433591f, 0.12144957f, -0.26974592f, 0.05237989f, -0.07024927f, 0.12332353f, -0.02648208f, 
    -0.02267892f, 0.03515888f, 0.02014170f, -0.09993235f, -0.09271847f, -0.02499379f, 0.10717774f, 0.02124981f, 
    0.05601414f, -0.10184720f, 0.23129940f, 0.15124175f, -0.00053925f, -0.04774337f, 0.02993831f, 0.01994112f, 
    -0.31668726f, -0.18916728f, 0.00050824f, -0.19951357f, 0.01698137f, -0.04408747f, -0.06716757f, 0.12055505f, 
    -0.01572444f, 0.09644181f, -0.00842978f, 0.00380291f, 0.06769799f, 0.03893751f, -0.05021426f, 0.01171526f, 
    -0.06101622f, -0.06250034f, -0.15449426f, -0.09987433f, 0.07700731f, -0.13929309f, 0.11530612f, 0.03945984f, 
    -0.26324889f, 0.06830738f, 0.14178491f, 0.09708539f, 0.11309246f, 0.03331142f, 0.06618205f, 0.09312523f, 
    0.14935428f, 0.11465760f, 0.16043705f, 0.00040463f, -0.09354413f, 0.03808073f, -0.01631745f, -0.06330723f, 
    0.03170029f, -0.01398362f, 0.09971425f, 0.10393424f, -0.00053433f, 0.03299924f, 0.13926426f, 0.18824212f, 
    -0.01995167f, 0.16222231f, 0.10769466f, -0.10233737f, -0.02819129f, -0.04076742f, -0.04245007f, -0.01117835f, 
    -0.04349354f, 0.00179893f, 0.02035806f, -0.07314810f, -0.05268551f, -0.01083940f, 0.30908027f, -0.08536874f, 
    0.19984797f, -0.00270248f, -0.05464259f, 0.12383578f, -0.01799227f, 0.08028503f, -0.08100136f, 0.09007263f, 
    0.17815016f, -0.12868667f, -0.17377564f, 0.14116861f, 0.02464942f, 0.23164232f, 0.08540598f, 0.14329048f, 
    0.11943097f, 0.13749595f, 0.05459595f, 0.05936791f, 0.02978915f, 0.10954165f, -0.04277320f, -0.02500841f, 
    0.04296341f, 0.02915323f, -0.16309020f, -0.15347455f, -0.10138639f, -0.07213103f, 0.02732295f, 0.04152156f, 
    -0.06256374f, 0.08124073f, 0.01762128f, 0.00503901f, 0.06760147f, -0.05252823f, -0.03995062f, -0.02595141f, 
    0.02549336f, 0.07879480f, -0.03769641f, 0.06961051f, 0.02670142f, -0.04057114f, 0.07610701f, 0.03233559f, 
    -0.04670433f, -0.04569117f, -0.01031223f, 0.01812606f, 0.04597552f, 0.07246851f, -0.07491329f, 0.12788263f, 
    0.26027143f, 0.22559461f, 0.00073412f, 0.00267761f, 0.07125803f, 0.25338554f, -0.08499951f, -0.01419664f, 
    0.05086220f, 0.05213422f, -0.09170379f, -0.02626006f, 0.23551752f, 0.32301289f, 0.09171467f, 0.09055632f, 
    0.06971130f, 0.08575520f, 0.16521204f, -0.04339518f, -0.03220439f, -0.00907801f, 0.00760426f, -0.00172039f, 
    0.06863640f, 0.07496158f, -0.05050744f, -0.18959017f, -0.09619568f, -0.08952712f, -0.14787169f, -0.05435638f, 
    -0.04666904f, -0.12401251f, -0.02820096f, -0.00927379f, -0.02693260f, 0.23909993f, -0.00667963f, -0.09640268f, 
    0.09588949f, 0.00539188f, 0.08852367f, 0.15525158f, -0.20627594f, 0.09302207f, -0.01937108f, -0.13238132f, 
    0.03168705f, -0.02268458f, -0.03727959f, -0.08601536f, 0.09859503f, 0.11925943f, 0.13363786f, -0.12282239f, 
    -0.04764844f, 0.00469001f, 0.00008522f, -0.01732072f, 0.06086008f, -0.18152899f, -0.07653427f, 0.10422160f, 
    -0.05474219f, 0.16932751f, -0.02411140f, -0.04968887f, -0.01250634f, -0.02993506f, 0.00547376f, 0.01833779f, 
    -0.34570110f, -0.01829735f, -0.05414726f, -0.17480329f, 0.04972411f, 0.02345654f, 0.17149971f, 0.15360746f, 
    -0.01994747f, 0.04935684f, 0.03455260f, -0.06845698f, -0.20913731f, -0.02036451f, 0.13719492f, 0.02801649f, 
    -0.00559360f, -0.05926557f, -0.06315891f, 0.04046010f, -0.10891815f, 0.00513827f, -0.04341079f, -0.00830332f, 
    -0.29596040f, 0.30623227f, 0.19422354f, -0.05245598f, 0.03071022f, 0.02784094f, 0.16491050f, 0.06063490f, 
    0.03973192f, -0.06983371f, -0.11893558f, 0.03890655f, -0.14211957f, -0.02749252f, -0.12987570f, -0.11743016f, 
    -0.09303103f, 0.13257518f, -0.04921054f, -0.10777570f, 0.21545208f, -0.00205628f, 0.12440269f, 0.04803254f, 
    -0.05921928f, 0.11678535f, -0.04004578f, -0.31747589f, -0.12453499f, -0.03799563f, 0.04126627f, -0.04689731f, 
    -0.11375131f, -0.30266932f, -0.09194756f, -0.15437216f, -0.15419665f, 0.33463508f, 0.22225080f, 0.25929609f, 
    0.15544429f, -0.09763562f, -0.17604415f, -0.09292250f, 0.01961518f, 0.01671381f, 0.08006245f, 0.02081337f, 
    -0.07345887f, -0.06424652f, 0.49719316f, 0.00473889f, 0.02583471f, 0.11183703f, 0.08459569f, 0.12929164f, 
    0.03456251f, 0.20826410f, 0.01712064f, -0.19263862f, 0.04649435f, 0.11755537f, 0.09906407f, 0.09848224f, 
    -0.08683291f, -0.03366489f, -0.00429554f, 0.00249842f, -0.01256273f, 0.01672207f, -0.06386332f, 0.11609029f, 
    -0.48972067f, -0.15137173f, 0.06164113f, 0.05341981f, 0.11216692f, 0.08560237f, 0.03548529f, -0.01466014f, 
    0.08488529f, 0.14311892f, 0.16845649f, 0.11899349f, 0.18752182f, -0.06098976f, -0.02936867f, 0.06291024f, 
    0.01697723f, -0.07144441f, 0.02712318f, -0.08343847f, -0.12182380f, -0.05674163f, 0.10694992f, 0.06864464f, 
    -0.14889863f, 0.03603115f, 0.06892315f, -0.11201715f, 0.06262153f, 0.03297101f, -0.21597706f, -0.11490253f, 
    0.10217790f, -0.01376869f, -0.11860006f, -0.02391466f, -0.11787952f, 0.02483999f, 0.13603243f, -0.04170580f, 
    -0.02748896f, -0.00613316f, -0.01159325f, -0.00973782f, 0.10286497f, 0.08019628f, 0.21652204f, 0.00343099f, 
    -0.11856345f, -0.12660743f, 0.06985783f, -0.12271130f, -0.16912176f, -0.09836853f, 0.02716581f, 0.17468166f, 
    0.07421865f, -0.04767755f, 0.26855147f, -0.01380771f, -0.21239088f, -0.14163424f, 0.09924939f, -0.05752820f, 
    -0.04704021f, -0.08895421f, 0.01241827f, 0.31017804f, 0.01348221f, 0.15198152f, 0.03761472f, -0.04581361f, 
    -0.09778776f, 0.06944370f, 0.03526028f, -0.27721456f, 0.20012689f, -0.03132531f, 0.03748342f, 0.03373923f, 
    0.01480986f, 0.10570568f, -0.01878721f, -0.00974227f, -0.22366454f, -0.08754722f, -0.01417851f, 0.02185614f, 
    -0.02026079f, 0.11684721f, 0.18547338f, 0.01856012f, 0.01093451f, -0.02243869f, -0.12017342f, 0.09264320f, 
    -0.21755853f, -0.05360435f, 0.10907786f, -0.10077404f, -0.09614652f, 0.03925760f, 0.03970996f, 0.20106462f, 
    0.16250853f, 0.05427318f, 0.07325744f, -0.04189324f, -0.06194485f, 0.12095414f, -0.02683418f, 0.06705590f, 
    0.02370785f, -0.02040935f, -0.04534697f, -0.00519593f, -0.05209643f, 0.02541531f, 0.07811260f, 0.06190818f, 
    -0.11763353f, -0.08772237f, 0.10512640f, 0.11520180f, 0.14750734f, 0.06955072f, 0.19543591f, 0.16672327f, 
    0.01262575f, 0.10955193f, 0.05614122f, 0.14913546f, -0.28387070f, 0.01377971f, 0.16762720f, -0.19630815f, 
    -0.08927656f, 0.09109232f, 0.02759368f, 0.06147341f, 0.12525819f, -0.07541461f, 0.03453265f, 0.02250297f, 
    -0.00573020f, 0.12025242f, 0.09081968f, -0.16219883f, -0.06663829f, -0.02169251f, -0.04744462f, -0.01364295f, 
    0.22037795f, -0.13141692f, 0.12639694f, -0.15391383f, -0.09954216f, -0.13655886f, 0.42813528f, 0.09682605f, 
    0.12461407f, -0.07302362f, 0.05709660f, 0.11662940f, -0.00653727f, 0.15106285f, 0.10083248f, 0.01703283f, 
    0.24665166f, -0.34158987f, -0.07231058f, 0.34028426f, 0.01788383f, 0.16398910f, 0.09575872f, 0.07410673f, 
    0.04057630f, 0.07663557f, -0.06924067f, -0.11812036f, 0.09091983f, -0.12423953f, 0.02168038f, -0.25554806f, 
    0.07023767f, 0.08170526f, -0.00219008f, -0.02943796f, -0.06018703f, -0.05212529f, -0.02368229f, 0.07122074f, 
    0.29177296f, 0.04280347f, -0.17499210f, -0.01032682f, 0.05359028f, -0.39000699f, 0.01955622f, -0.03662718f, 
    0.12949611f, 0.04719265f, -0.03440908f, -0.04026945f, -0.10302753f, -0.01706411f, 0.20163903f, 0.11610948f, 
    0.06299394f, 0.02274701f, -0.01351132f, -0.19248822f, 0.17083150f, 0.07671108f, -0.05006633f, 0.11654452f, 
    0.20816213f, 0.20780028f, 0.02802232f, -0.08184651f, 0.13856818f, 0.18040922f, 0.03315606f, 0.17993319f, 
    -0.12458325f, 0.01097056f, 0.08713684f, -0.03511447f, 0.16913541f, 0.17642581f, -0.00967831f, 0.01052887f, 
    0.14195073f, 0.00524877f, 0.07399540f, 0.13959803f, -0.15715028f, -0.02760799f, 0.14627597f, 0.07643458f, 
    0.21260147f, 0.01270539f, 0.18439330f, -0.02210163f, 0.05794448f, 0.08717220f, -0.04667250f, -0.02424257f, 
    0.06053761f, -0.02492647f, 0.10210123f, 0.08882054f, -0.08423495f, 0.11965673f, -0.17715685f, -0.25522918f, 
    0.13330384f, 0.13298944f, -0.18591344f, 0.02753181f, 0.03350043f, 0.09596695f, 0.18275951f, 0.09383776f, 
    -0.35499609f, 0.28047758f, -0.44915956f, 0.10265429f, -0.05686652f, 0.04092152f, 0.32835183f, 0.01313622f, 
    -0.16803692f, -0.06149018f, -0.20693751f, -0.22173205f, -0.00012463f, -0.17028728f, -0.20439534f, -0.17481118f, 
    -0.00404063f, 0.20548370f, -0.12891950f, 0.07746147f, -0.18310964f, -0.15714146f, -0.06181292f, 0.04046573f, 
    0.05540889f, -0.19923443f, -0.04922248f, -0.34948787f, 0.12087531f, 0.02208598f, -0.02114591f, -0.19682595f, 
    0.11228818f, 0.00336193f, -0.14470994f, -0.03267751f, 0.15870418f, -0.01998077f, 0.16404468f, 0.05198459f, 
    -0.15375556f, -0.08033266f, -0.35456049f, -0.46614656f, 0.09491231f, 0.26056930f, 0.00721349f, -0.06290597f, 
    0.22164385f, 0.07420697f, 0.22805554f, 0.01278576f, 0.03545953f, 0.01509793f, 0.05051204f, -0.06869344f, 
    0.10912562f, -0.09887536f, -0.12538253f, 0.00582067f, 0.22628671f, -0.00746502f, -0.17436692f, -0.20280029f, 
    0.18160562f, 0.08073043f, -0.06136782f, 0.05878124f, -0.03916129f, -0.00598457f, -0.01472869f, -0.15462996f, 
    0.21450087f, 0.00752759f, 0.09762764f, 0.34497264f, 0.03312534f, -0.09343193f, 0.02505817f, -0.11399154f, 
    0.10916931f, 0.04854229f, 0.03786331f, 0.16408616f, 0.03072910f, 0.14618026f, 0.06138958f, -0.14364049f, 
    0.15336499f, 0.15289018f, -0.06361808f, 0.10226403f, -0.16939114f, 0.00952108f, -0.09412578f, -0.23974721f, 
    0.08036704f, 0.04599425f, 0.20188153f, 0.07695597f, 0.15220331f, 0.09189531f, 0.01368383f, 0.17240050f, 
    -0.00277385f, 0.01268124f, 0.02186530f, -0.10793988f, 0.08863451f, -0.08424107f, 0.20856604f, 0.03486940f, 
    0.04606460f, 0.06137706f, 0.03671037f, -0.14434254f, -0.17368616f, -0.05474509f, -0.08462263f, -0.12591122f, 
    -0.06486417f, 0.05829390f, -0.05387083f, -0.05797932f, -0.00161312f, -0.05096265f, -0.00600575f, -0.04032908f, 
    -0.06471267f, 0.04340161f, -0.01929254f, 0.02220500f, 0.00787222f, -0.03482214f, -0.02036542f, -0.01409835f, 
    0.04709857f, -0.04348043f, 0.03780462f, -0.06507770f, 0.01404883f, -0.05540158f, 0.03343206f, 0.04062431f, 
    0.04683664f, 0.03789023f, 0.01408966f, -0.00686600f, -0.07828043f, 0.03359600f, 0.02661880f, 0.01765212f, 
    -0.02659677f, 0.03156249f, 0.06695138f, -0.04007454f, 0.03479827f, -0.06032057f, 0.02027821f, 0.05518087f, 
    0.05953570f, -0.06014453f, -0.07414506f, 0.04360919f, -0.03285481f, 0.02071408f, -0.04398298f, 0.03874256f, 
    -0.02920369f, 0.03829397f, -0.01724981f, 0.02449486f, -0.05595070f, -0.06526893f, -0.01619047f, -0.04854341f, 
    -0.02000589f, -0.04615912f, 0.00104867f, -0.06304313f, 0.04545144f, -0.02661318f, 0.00857111f, -0.06083915f, 
    -0.03747895f, -0.01823658f, -0.04687011f, -0.08031899f, -0.06279580f, 0.01938907f, -0.05846602f, 0.00401758f, 
    0.01995869f, 0.01569197f, 0.01950367f, -0.05676319f, 0.04453319f, -0.05164547f, -0.06578463f, 0.04263994f, 
    0.04206552f, 0.03260408f, -0.04733360f, 0.01718932f, -0.01981897f, -0.06448527f, -0.07871854f, -0.05682028f, 
    0.00856867f, 0.02603149f, 0.03975089f, 0.04920215f, 0.01710804f, -0.02281831f, 0.04332437f, -0.01810139f, 
    -0.00509200f, 0.01495087f, 0.03201705f, -0.05094425f, 0.00841642f, 0.02362958f, -0.02082284f, 0.01930074f, 
    0.03223132f, 0.00300003f, -0.02238799f, -0.00367805f, -0.05759106f, 0.04632789f, -0.04071986f, -0.00288889f, 
    -0.01650325f, 0.04352768f, -0.06105405f, 0.02538645f, 0.01840350f, -0.00092803f, -0.07225380f, 0.03335039f, 
    -0.07023854f, -0.05814550f, 0.05815706f, 0.02692491f, -0.01012217f, -0.02890448f, 0.00185175f, -0.03614123f, 
    -0.00080444f, -0.02789691f, 0.03767071f, -0.01048649f, -0.03370796f, -0.00477999f, 0.00571966f, 0.01505575f, 
    -0.06452652f, -0.04289253f, -0.04995814f, -0.01931082f, -0.03549877f, -0.07782315f, -0.06764293f, -0.00944483f, 
    0.05157921f, 0.00295089f, -0.03686032f, -0.03586814f, -0.02588286f, -0.01374948f, -0.00749874f, 0.06380846f, 
    0.03400463f, -0.01600137f, -0.02656890f, -0.00582748f, 0.04110199f, 0.03027357f, -0.05543359f, -0.02350104f, 
    0.05399995f, -0.07263817f, -0.02941656f, 0.03801962f, -0.01804097f, 0.01424348f, -0.02558278f, -0.00532597f, 
    -0.06056297f, -0.07855099f, -0.06854722f, -0.03914790f, 0.02718552f, -0.02768685f, -0.06712849f, -0.00864141f, 
    -0.00330132f, -0.03570906f, -0.00081923f, -0.07204197f, 0.03729441f, 0.04944550f, -0.02755750f, -0.04603136f, 
    0.00710549f, -0.06072782f, -0.02424709f, 0.01042374f, -0.02339954f, 0.05291337f, -0.03570610f, -0.00605646f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01111330f, 0.03554033f, -0.01015406f, -0.08463668f, -0.04393632f, 0.12304983f, -0.14159767f, -0.06962942f, 
    0.22897227f, 0.04583485f, 0.02316855f, -0.10991752f, 0.03025129f, 0.02893990f, 0.09655047f, 0.13573855f, 
    0.11419561f, -0.02670399f, 0.07763556f, 0.15301865f, 0.01318255f, 0.15518293f, 0.05345526f, -0.01500534f, 
    -0.00104438f, 0.07981900f, 0.08788878f, 0.11270130f, -0.05159594f, 0.02062396f, 0.17072587f, 0.19600669f, 
    -0.04873006f, -0.05097925f, -0.02987493f, 0.32398054f, 0.17873365f, 0.09213584f, -0.02055835f, 0.06122143f, 
    -0.09434347f, 0.06696443f, 0.00620676f, 0.04033288f, 0.15105437f, 0.02406134f, -0.07225802f, 0.21798110f, 
    -0.07883710f, -0.05353459f, -0.04150318f, 0.10953268f, 0.02440210f, -0.16355278f, -0.06543282f, 0.10487275f, 
    0.03042697f, 0.02097794f, 0.03931727f, 0.12551711f, -0.05206339f, -0.06573091f, 0.11323129f, 0.08211349f, 
    0.12732597f, 0.07140632f, 0.07962015f, 0.04709760f, 0.01652411f, -0.16446571f, 0.08578309f, 0.05712498f, 
    0.17807387f, -0.11898535f, -0.00180966f, -0.03364181f, -0.03628381f, 0.12513833f, 0.02346498f, 0.02231913f, 
    0.21135281f, 0.11843176f, -0.00691756f, 0.09225598f, 0.00999077f, 0.12275915f, 0.01448084f, -0.00087265f, 
    0.05997305f, 0.08661941f, -0.04599759f, 0.00957486f, -0.04198037f, 0.17796524f, 0.21680997f, -0.09153606f, 
    -0.01592319f, 0.16073830f, 0.10876872f, -0.02891078f, -0.01333576f, 0.04367894f, 0.07885637f, -0.02937139f, 
    0.09139583f, -0.05031227f, 0.01031926f, 0.11046262f, -0.02481771f, 0.28940570f, -0.02466206f, -0.03351543f, 
    -0.04708306f, 0.09876931f, -0.06727624f, 0.02848672f, 0.01279792f, 0.25471640f, 0.05575423f, -0.09755316f, 
    0.09724142f, -0.04693807f, -0.00106144f, 0.06282090f, 0.00098358f, 0.20016427f, -0.12198336f, 0.03986808f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04281361f, -0.01209856f, 0.15781581f, 0.25981057f, 0.17955287f, -0.11158679f, 0.18626262f, 0.10174569f, 
    -0.07069331f, 0.01717204f, 0.08233012f, 0.10195398f, -0.02643508f, 0.00896029f, -0.00144738f, -0.09745269f, 
    -0.01191054f, 0.17340319f, -0.10812075f, -0.27273929f, 0.18691497f, -0.12629187f, -0.07861834f, -0.43920362f, 
    0.00130032f, 0.04816708f, 0.15020555f, -0.13694784f, -0.02187636f, 0.00925504f, -0.21084213f, 0.02553690f, 
    0.05493831f, -0.12745611f, 0.07729319f, -0.34205812f, -0.30764669f, -0.03206357f, -0.11174187f, -0.04778963f, 
    0.08553448f, 0.11961222f, 0.07270071f, -0.01572492f, -0.25699565f, 0.12828892f, -0.03173678f, -0.13111389f, 
    -0.08030052f, 0.03331835f, -0.21414588f, 0.08885293f, -0.14968739f, 0.21989079f, 0.01254144f, -0.09908266f, 
    -0.38504320f, 0.04881302f, -0.47249123f, -0.51230752f, 0.12589909f, 0.16420010f, -0.19962329f, -0.32020676f, 
    -0.04117322f, -0.15245980f, 0.04219640f, 0.32961404f, 0.07702286f, 0.11108878f, -0.31030378f, -0.23346256f, 
    -0.03001021f, 0.08751633f, 0.07608987f, 0.01055770f, 0.18168643f, -0.52200520f, 0.02062704f, -0.08616962f, 
    -0.43148586f, -0.08377372f, 0.00961705f, -0.00848338f, -0.11176085f, -0.16428289f, 0.20764154f, 0.19149983f, 
    -0.05728408f, 0.15294228f, -0.12736149f, -0.04143926f, -0.01671762f, -0.31959379f, -0.21647492f, 0.07067569f, 
    0.04994870f, 0.11208335f, -0.01091581f, -0.21267024f, 0.01872476f, 0.02600741f, -0.12705247f, 0.00543796f, 
    0.12341010f, 0.25660515f, 0.05655709f, -0.03747525f, -0.02113240f, -0.04116251f, -0.40694138f, -0.09042622f, 
    -0.07412487f, -0.16209938f, -0.01414456f, 0.15254080f, 0.14325237f, -0.12823668f, 0.20935890f, 0.04355207f, 
    0.11130942f, -0.04417423f, -0.08355746f, -0.38951939f, 0.04907302f, -0.32264429f, 0.27149361f, 0.06055029f, 
    0.13517818f, 0.07192987f, 0.01609317f, -0.51549709f, -0.00287813f, 0.05902054f, 0.12926094f, 0.04244554f, 
    0.22441229f, -0.22782524f, 0.01848456f, 0.06635822f, 0.07600983f, 0.05575086f, 0.21667674f, 0.10837737f, 
    0.24408956f, 0.15997925f, 0.04706880f, -0.20339222f, 0.04419679f, 0.10319819f, -0.15553696f, -0.25989547f, 
    -0.05944914f, 0.19839135f, -0.04556242f, -0.03031617f, 0.00913782f, 0.04584111f, 0.18589567f, 0.11679851f, 
    -0.13151637f, -0.15012467f, 0.04590491f, 0.30334169f, 0.11081596f, 0.02239643f, -0.23776495f, -0.11490637f, 
    0.21579587f, 0.11775041f, 0.10374594f, -0.05660981f, -0.01629890f, 0.07516618f, -0.25277099f, -0.03238623f, 
    0.01906569f, 0.02812044f, -0.21118824f, 0.13786054f, -0.48256418f, -0.52643824f, -0.05636168f, 0.01207575f, 
    -0.45714694f, 0.02456131f, -0.53361684f, -0.14785378f, 0.07498425f, -0.17800586f, -0.09858638f, -0.05997234f, 
    0.00712351f, -0.00193330f, 0.06915130f, -0.16014725f, 0.08188649f, -0.74644995f, -0.13814670f, 0.14982599f, 
    -0.00722383f, 0.25124931f, -0.01873593f, 0.02396273f, 0.08255803f, -0.04078644f, -0.02852374f, -0.05126074f, 
    -0.08117005f, 0.03659540f, -0.01006367f, 0.08364698f, -0.10685829f, 0.30580106f, -0.11125915f, 0.09918009f, 
    0.06346226f, 0.10998406f, -0.28534168f, -0.16668040f, -0.02083211f, 0.02161878f, -0.16468759f, -0.02091791f, 
    -0.07564072f, -0.48106727f, 0.07595401f, 0.01094612f, -0.03331944f, -0.00870927f, -0.05197309f, 0.02047971f, 
    0.37843850f, -0.32178703f, -0.10444946f, 0.10615099f, -0.05187770f, 0.47810593f, -0.22780083f, 0.10209761f, 
    -0.04757644f, 0.46149287f, -0.05314812f, 0.32122850f, 0.08943926f, 0.05610676f, 0.13799945f, -0.40526143f, 
    0.10474911f, 0.02160433f, -0.07303684f, 0.05504484f, 0.02276892f, -0.08838161f, -0.19490844f, -0.01821357f, 
    0.09070370f, -0.06257889f, 0.19215645f, 0.10746936f, -0.31831849f, -0.09747063f, -0.32850680f, 0.01289352f, 
    0.39368948f, -0.41278863f, 0.03629837f, -0.07209257f, 0.03703539f, -0.10389303f, -0.04714675f, -0.02069934f, 
    -0.02019863f, -0.14661174f, -0.08163495f, 0.17921385f, 0.19560383f, 0.14084870f, 0.13540526f, 0.10297292f, 
    0.02923114f, -0.44485086f, 0.07491539f, -0.24235976f, -0.05039253f, 0.07360388f, 0.17566463f, -0.05402799f, 
    -0.04164713f, -0.10364596f, -0.08342614f, -0.97719079f, 0.18499973f, 0.09461714f, -0.04637015f, -0.11643309f, 
    0.23995222f, 0.00558616f, -0.06324706f, -0.00354706f, 0.06430358f, -0.03738328f, -0.05089713f, 0.00184931f, 
    -0.07887882f, 0.04862271f, 0.01566537f, 0.07530313f, -0.12180936f, -0.37739384f, -0.02323489f, -0.02593694f, 
    0.24126707f, -0.01894211f, 0.09102543f, 0.14956619f, -0.14661914f, 0.26644081f, -0.06316854f, -0.03895161f, 
    0.12816918f, 0.03708771f, 0.04558749f, -0.31083307f, 0.10727745f, -0.54092920f, -0.01345381f, -0.07291263f, 
    -0.06818838f, -0.05227688f, -0.07053778f, 0.03274177f, -0.05775606f, -0.10865153f, -0.05055276f, -0.06242825f, 
    0.01236509f, 0.15290497f, -0.24645968f, -0.31963679f, -0.09786891f, -0.26225677f, 0.43998063f, -0.05539868f, 
    0.07319520f, 0.09410574f, -0.42658052f, 0.00591006f, 0.08225692f, 0.02679363f, 0.14224252f, -0.04414740f, 
    0.04175835f, 0.20625532f, 0.07792480f, -0.25366473f, -0.03233593f, 0.03412191f, 0.25784159f, -0.02355326f, 
    -0.44451812f, -0.20609759f, 0.07284150f, 0.09809522f, -0.01794429f, -0.55764633f, 0.18555970f, 0.15403023f, 
    0.05988616f, 0.17877659f, -0.02742403f, -0.38130093f, 0.08176132f, 0.21710861f, 0.03174084f, 0.01399524f, 
    0.08438959f, -0.02193194f, -0.07635177f, -0.13940604f, -0.10705056f, 0.02663043f, -0.25716516f, 0.05702310f, 
    0.10268841f, -0.08428937f, -0.06666113f, 0.12070896f, -0.16327287f, -0.02921540f, 0.08067973f, 0.20722130f, 
    -0.42217085f, -0.03873118f, -0.09084273f, 0.08124122f, -0.09701342f, -0.17103219f, -0.05053176f, 0.09396729f, 
    -0.38445875f, 0.09438861f, -0.16051629f, -0.36424071f, -0.03840839f, -0.09518459f, 0.16165784f, 0.24437064f, 
    -0.05517692f, -0.00365418f, -0.06593066f, -0.42793593f, 0.00828324f, -0.03785696f, -0.00525075f, -0.42346817f, 
    -0.01182111f, -0.20211737f, 0.07816732f, -0.66819239f, 0.01426481f, 0.12408263f, -0.26642793f, 0.01731147f, 
    0.10474215f, 0.04460742f, -0.31874847f, -0.04355674f, -0.03881700f, 0.00209655f, 0.36666623f, -0.46068111f, 
    -0.02032665f, 0.01292206f, 0.17062998f, -0.17729305f, 0.00951987f, 0.06929059f, 0.01605055f, -0.23067516f, 
    0.37826979f, 0.00019981f, 0.18714675f, -0.03611090f, 0.16666253f, 0.05340427f, 0.04307488f, -0.14686808f, 
    0.12267578f, -0.01611790f, -0.60256010f, -0.24062738f, 0.18744312f, 0.15906888f, 0.12617318f, 0.03272731f, 
    -0.02862287f, 0.09439433f, -0.04017912f, -0.07499839f, -0.27852651f, 0.07953246f, -0.02182171f, -0.03837821f, 
    0.05710669f, 0.11560192f, 0.01423156f, 0.03949729f, 0.01920117f, 0.06355206f, 0.08132684f, 0.05175149f, 
    0.05578242f, -0.54100895f, 0.04530401f, 0.04104754f, -0.04285930f, -0.00227497f, -0.36056501f, 0.16455783f, 
    -0.29297608f, 0.06352055f, -0.43559211f, 0.04772101f, 0.05813055f, -0.00608823f, 0.15646252f, 0.02517408f, 
    -0.31384709f, 0.20862025f, 0.09833880f, -0.12838504f, -0.02386363f, -0.29178712f, 0.01768818f, 0.36777425f, 
    0.05509530f, 0.01853175f, 0.01555705f, -0.08755871f, -0.08296406f, -0.18746373f, 0.04541882f, -0.01806110f, 
    -0.49772641f, -0.04753397f, 0.01098381f, 0.05216850f, 0.00727482f, -0.19573037f, 0.04435639f, -0.02285201f, 
    0.05173603f, -0.02897480f, 0.18273693f, 0.04001196f, 0.09168201f, -0.08899501f, 0.07665052f, -0.13425851f, 
    -0.03394718f, -0.00405482f, -0.06864773f, 0.03909408f, -0.16438164f, 0.01060988f, -0.03785830f, -0.40917853f, 
    0.09757946f, -0.05574763f, -0.36327356f, 0.06389125f, 0.00574723f, -0.13992512f, -0.20284018f, -0.10752548f, 
    0.05930480f, -0.29179907f, -0.08324397f, 0.10892207f, -0.03978018f, 0.01288949f, -0.11800057f, -0.26321918f, 
    0.10770202f, 0.15516959f, -0.04748293f, 0.09914082f, 0.05226767f, 0.02657753f, 0.05543667f, 0.04841959f, 
    0.12542656f, 0.09576559f, 0.09460094f, 0.07656899f, -0.15357377f, -0.20562944f, -0.01551664f, 0.11847322f, 
    0.02932032f, 0.05237240f, 0.13180070f, -0.09115015f, 0.05124955f, 0.23446018f, 0.01293385f, 0.10449219f, 
    -0.09235761f, -0.03341191f, 0.19105406f, -0.02657950f, 0.04953035f, 0.23292021f, 0.17049894f, -0.00381528f, 
    -0.24823895f, 0.09975993f, -0.09102857f, -0.24227372f, -0.22521380f, 0.18736573f, -0.32123384f, 0.01223390f, 
    -0.02666323f, 0.16540572f, -0.06147108f, 0.06103396f, 0.15042470f, -0.00843234f, -0.00098994f, -0.03260988f, 
    -0.46182469f, 0.06228395f, 0.09975141f, -0.00426897f, 0.10361604f, -0.19385378f, 0.00312986f, 0.00851038f, 
    -0.07655084f, -0.12357517f, -0.22929323f, 0.19637036f, -0.08051261f, -0.02920015f, 0.03231328f, 0.09537579f, 
    0.15357959f, -0.35469943f, 0.06679654f, 0.16730486f, -0.02400976f, 0.02552396f, -0.23643857f, -0.04622223f, 
    -0.04317919f, -0.17386314f, 0.03869691f, -0.23076399f, 0.05054728f, -0.03171619f, 0.28642794f, -0.16656925f, 
    -0.06215627f, -0.17478123f, 0.01069486f, 0.07659362f, -0.05818662f, -0.55157298f, -0.03738127f, 0.24595819f, 
    0.05872741f, 0.04830213f, 0.04339423f, -0.11194671f, -0.04284410f, -0.08340488f, -0.04550108f, -0.01893472f, 
    -0.39185295f, 0.04587850f, -0.48050293f, -0.29938906f, 0.15347123f, 0.16721189f, 0.00014358f, -0.02626818f, 
    -0.00872848f, -0.00352616f, -0.02153994f, -0.01816429f, -0.10041049f, -0.03541287f, 0.09480444f, 0.10790916f, 
    -0.09812253f, 0.03914961f, 0.13829367f, 0.37355375f, -0.05911562f, -0.25349671f, -0.25407618f, -0.16114156f, 
    0.01614228f, 0.23794019f, -0.01000796f, -0.05033273f, -0.04136736f, 0.05492926f, -0.19043362f, 0.02103168f, 
    -0.20367989f, -0.00519472f, 0.07046003f, -0.17913386f, 0.03564024f, -0.02580666f, 0.31069261f, -0.09165945f, 
    -0.01025940f, -0.01102569f, -0.09500399f, 0.07350469f, -0.04739202f, 0.01152254f, 0.00875204f, 0.11725080f, 
    -0.04679487f, -0.03869780f, 0.13398674f, 0.06058187f, 0.30351481f, 0.06861510f, -0.03353670f, 0.22020701f, 
    -0.43915588f, 0.02357235f, 0.03457232f, 0.18043919f, -0.04225466f, -0.12652834f, 0.26402277f, 0.08504881f, 
    0.15794322f, -0.12513897f, -0.03020362f, 0.37181628f, -0.17771006f, -0.04476233f, -0.21116844f, 0.10819731f, 
    -0.01036264f, -0.19708861f, -0.03592029f, 0.03443706f, 0.09977674f, -0.12666041f, -0.04039752f, -0.05183631f, 
    -0.02376469f, 0.05018767f, -0.14976113f, 0.16654658f, -0.06028614f, -0.21770932f, -0.02654860f, 0.00464551f, 
    0.06624000f, -0.13272835f, 0.22684637f, 0.06025779f, 0.08162172f, 0.00808162f, 0.11201178f, 0.03798125f, 
    -0.23748262f, 0.06427096f, -0.03309452f, -0.03543049f, 0.04351097f, 0.04727855f, -0.14636967f, -0.00757708f, 
    -0.11367052f, 0.03580322f, -0.15424326f, 0.11261994f, -0.06916088f, -0.27072793f, -0.44112647f, -0.18995802f, 
    -0.05969800f, -0.53259999f, 0.03168358f, 0.09850271f, 0.10039985f, 0.05436926f, -0.05727764f, -0.10739341f, 
    0.10510998f, -0.00365514f, -0.08525769f, 0.12043816f, 0.17357831f, 0.18814735f, 0.14372034f, -0.01220242f, 
    0.20200673f, 0.08017195f, -0.05697129f, -0.14892361f, -0.42516801f, -0.06872085f, -0.18918046f, -0.46509540f, 
    0.18304369f, -0.00419896f, 0.05920886f, -0.49129450f, 0.07807959f, -0.19774550f, -0.43010187f, -0.04989222f, 
    -0.11194038f, -0.19401079f, 0.16391407f, 0.21345183f, -0.14263228f, 0.14432935f, 0.20563564f, 0.13452013f, 
    0.03952616f, -0.42486748f, 0.20307477f, 0.23893204f, -0.07288861f, 0.06903514f, -0.03193324f, 0.03390119f, 
    -0.14151299f, 0.13442662f, -0.04661685f, -0.02021161f, -0.07812432f, -0.52412802f, -0.17221810f, -0.08224523f, 
    -0.37144029f, -0.54259282f, -0.08146750f, -0.00012824f, 0.16864365f, -0.28994086f, 0.21064824f, 0.22995280f, 
    0.07041904f, 0.06885147f, -0.15073705f, 0.03276498f, 0.18897560f, -0.61288154f, 0.04250695f, -0.06681357f, 
    0.09899001f, -0.07122277f, 0.12967430f, 0.17951675f, -0.64791715f, -0.40278560f, -0.38917080f, 0.16320588f, 
    -0.02613203f, 0.06804404f, 0.17248060f, 0.16601200f, 0.09561775f, -0.40755931f, 0.02980872f, -0.27654478f, 
    0.02966757f, 0.25154731f, 0.01016327f, -0.07451324f, -0.23399651f, 0.16146874f, -0.05884887f, 0.06197617f, 
    0.01689024f, -0.26437208f, 0.26156223f, -0.65729725f, 0.02372323f, -0.10221647f, 0.12196186f, -0.36585903f, 
    0.05063146f, -0.14817317f, 0.02737255f, 0.07969291f, 0.01475549f, 0.11390430f, 0.17111996f, -0.07548267f, 
    0.14036828f, 0.20788312f, 0.12347231f, -0.38550872f, -0.01087516f, -0.00031677f, -0.27399346f, 0.07349588f, 
    -0.40617788f, -0.23533028f, 0.17412484f, 0.03313370f, -0.00612867f, 0.09652136f, 0.18355450f, 0.01728779f, 
    0.00132826f, -0.00302340f, -0.06436509f, -0.18935446f, -0.08462811f, 0.02429181f, -0.53775203f, 0.19583149f, 
    0.00012739f, -0.03141389f, 0.04471225f, 0.18283297f, -0.17746268f, 0.13407803f, -0.40377489f, 0.08484443f, 
    0.00572110f, 0.05130189f, 0.17853698f, -0.05492812f, -0.07405615f, 0.05514712f, -0.22503905f, 0.11037839f, 
    -0.07572253f, -0.22247417f, -0.00586596f, -0.47133839f, 0.01617635f, 0.07425854f, 0.11827474f, 0.10248052f, 
    -0.11867138f, -0.11056396f, 0.00328977f, -0.24628411f, -0.37906504f, -0.01211057f, -0.40825337f, -0.11604892f, 
    0.06795926f, -0.26627770f, -0.19760664f, 0.08213913f, 0.03774737f, 0.00868806f, -0.19051045f, 0.02982342f, 
    0.22060131f, 0.23751099f, 0.06198768f, -0.34674701f, -0.09788908f, -0.32455084f, 0.07715876f, -0.05182590f, 
    0.22994412f, -0.41975924f, -0.18306206f, -0.05726320f, -0.22288315f, -0.03858059f, 0.02790284f, -0.02607808f, 
    -0.08078883f, -0.09510945f, 0.09081154f, -0.26240873f, -0.11997437f, 0.39138311f, -0.07932542f, 0.07355298f, 
    0.22315606f, 0.08105053f, 0.25345632f, -0.15655106f, 0.20292915f, 0.44309980f, 0.05959157f, 0.09716633f, 
    0.12057636f, -0.50728470f, -0.04406067f, 0.07929207f, 0.10810627f, -0.19788073f, 0.15650387f, 0.12146870f, 
    -0.57018107f, -0.14760002f, -0.02548370f, 0.01763866f, 0.02111892f, 0.06435229f, 0.05036635f, -0.06496660f, 
    0.10187665f, -0.44843987f, 0.24910465f, -0.24800354f, -0.26060295f, -0.11596344f, 0.12349290f, -0.19542307f, 
    -0.00212587f, -0.06907120f, 0.19466724f, -0.27647895f, 0.01439497f, -0.15667416f, -0.01586940f, 0.03070658f, 
    -0.09433530f, -0.02241967f, -0.07970142f, 0.26475385f, -0.04110201f, -0.07837866f, -0.33309326f, 0.06993566f, 
    0.06627021f, 0.31812197f, -0.34269366f, -0.29214120f, -0.00910588f, -0.17642942f, 0.19282623f, -0.13093276f, 
    0.00165996f, 0.03585746f, -0.07437781f, -0.12265330f, -0.23208234f, 0.05792298f, -0.25099167f, 0.27211618f, 
    0.05562809f, -0.03412229f, -0.26525012f, 0.05173281f, -0.19015473f, 0.04059723f, 0.26986504f, 0.06426278f, 
    -0.15102781f, -0.09282241f, -0.47913647f, -0.28994080f, -0.39205143f, 0.13961895f, -0.01145465f, 0.12774335f, 
    -0.18026194f, -0.25478852f, -0.07463729f, -0.45658344f, 0.00623946f, 0.33862108f, -0.17575116f, 0.04412252f, 
    -0.13454041f, 0.16607830f, 0.00506825f, -0.30705103f, -0.60003275f, -0.28721485f, 0.03243020f, -0.30431184f, 
    0.00985947f, 0.02477393f, -0.01999968f, 0.31253564f, -0.04022218f, -0.01625318f, -0.05839357f, 0.11268669f, 
    0.03044429f, -0.25467575f, 0.04457776f, 0.05670222f, -0.15908803f, 0.19507590f, 0.10578387f, -0.00121532f, 
    -0.31068364f, -0.37683505f, -0.05155477f, 0.04588799f, 0.12667139f, 0.11338957f, 0.15755117f, 0.06859080f, 
    -0.00587817f, 0.01270222f, -0.44887349f, 0.05688125f, -0.21666516f, -0.05558915f, -0.07223811f, -0.28316081f, 
    0.26900992f, 0.00886833f, 0.16987091f, 0.10779665f, -0.02010584f, -0.01946964f, -0.35248056f, 0.03660623f, 
    0.21869622f, -0.50064081f, -0.22077736f, -0.02511450f, 0.23243864f, -0.14160992f, 0.11990619f, -0.16937551f, 
    0.16843930f, -0.46370667f, 0.02927598f, 0.06785905f, 0.06732265f, -0.23446868f, 0.01188302f, -0.02244296f, 
    0.10331644f, 0.20340067f, 0.10267819f, 0.07808800f, -0.14109258f, 0.12490201f, -0.36967984f, 0.14333937f, 
    -0.06399062f, 0.00432296f, 0.32266474f, -0.16859713f, 0.01657007f, 0.11635927f, -0.11598572f, -0.30209345f, 
    -0.12797646f, 0.39826897f, 0.07851566f, 0.11330167f, 0.03357748f, -0.03677754f, 0.25440717f, -0.06495758f, 
    -0.21255846f, 0.14948162f, -0.25609398f, 0.22851925f, -0.03427099f, 0.06291605f, -0.26710641f, 0.18644024f, 
    -0.06983692f, -0.49872327f, 0.02126121f, -0.17556253f, -0.07153691f, 0.20257349f, -0.52423549f, -0.18964015f, 
    0.05606438f, -0.05698596f, -0.10350720f, -0.03781958f, -0.12127307f, 0.09112707f, -0.45460233f, -0.00247354f, 
    0.10458750f, -0.04085152f, 0.03018780f, 0.10125902f, 0.19620676f, -0.31976569f, -0.08858431f, -0.48520568f, 
    -0.33015114f, 0.02183949f, 0.00087613f, 0.00789463f, -0.07920369f, -0.24497570f, -0.01794225f, 0.10018986f, 
    0.14868358f, -0.23830834f, -0.05670437f, 0.23832387f, 0.14145195f, 0.18584219f, -0.12674761f, -0.21748434f, 
    -0.05478290f, -0.12889707f, 0.22796166f, -0.25646642f, 0.05626355f, -0.03482718f, -0.26193503f, 0.14427982f, 
    -0.02410503f, 0.22691552f, 0.05117300f, -0.03162817f, 0.06468140f, -0.30935273f, 0.25766206f, -0.12218004f, 
    -0.20285910f, -0.21205799f, -0.02769849f, -0.00459027f, -0.15072994f, -0.25776863f, -0.20461731f, 0.05974125f, 
    -0.04653844f, 0.06355510f, 0.06688596f, -0.44104981f, 0.17358558f, 0.19165508f, -0.05582472f, -0.02267131f, 
    -0.01166154f, -0.02990277f, -0.08235625f, -0.12499485f, -0.05602212f, 0.00312895f, 0.12114529f, -0.13842048f, 
    -0.21732788f, 0.06631004f, 0.26460361f, -0.54313332f, -0.42761165f, 0.21337424f, 0.14021449f, -0.24684250f, 
    0.02633577f, 0.09057173f, 0.07979146f, -0.09659937f, 0.20148823f, 0.08922387f, -0.02995567f, 0.01247089f, 
    0.12292230f, -0.13601933f, -0.24940772f, -0.23670571f, 0.31450093f, -0.22040072f, -0.56604803f, -0.25439903f, 
    0.05343341f, 0.30679452f, -0.27102455f, -0.13365199f, -0.05815252f, 0.01864664f, 0.23662965f, -0.23215277f, 
    0.28087658f, 0.21500489f, -0.27827367f, -0.07939721f, 0.04196202f, -0.08238183f, -0.35556972f, -0.07583577f, 
    0.38189176f, 0.03364506f, 0.05853397f, -0.14510964f, -0.05740818f, -0.15746905f, 0.18691270f, -0.41927648f, 
    0.03264485f, 0.01784820f, 0.02114596f, -0.12967446f, -0.05237222f, -0.17301081f, 0.39301911f, 0.00342723f, 
    0.01092480f, 0.04591058f, 0.05747420f, 0.00463443f, -0.43855110f, -0.02980209f, 0.23737273f, -0.07398031f, 
    -0.49682888f, -0.08842682f, -0.26742053f, -0.10086846f, -0.01720744f, -0.38301229f, -0.00713665f, -0.01639508f, 
    0.31054604f, 0.42838302f, -0.06191857f, 0.08565059f, -0.33717576f, -0.25509584f, 0.16843294f, 0.01654271f, 
    -0.45808706f, -0.20485888f, -0.22195949f, -0.29869482f, 0.07391191f, -0.03554920f, 0.06477889f, -0.08070871f, 
    0.01188041f, 0.11963323f, 0.01697285f, -0.28575617f, -0.08065434f, -0.07189500f, 0.26374355f, -0.07174999f, 
    -0.19440801f, 0.14016007f, 0.03239773f, -0.22404741f, 0.06651819f, 0.27284920f, -0.40613759f, -0.07758981f, 
    -0.38190281f, -0.15846360f, 0.27287492f, -0.03928181f, 0.18760592f, 0.21634284f, 0.31048822f, 0.27522230f, 
    0.07499297f, -0.06475408f, 0.03522036f, 0.00044655f, -0.14420070f, -0.29114217f, -0.05281965f, -0.10057911f, 
    0.08941871f, -0.06153048f, 0.25093469f, 0.00519544f, -0.26777554f, -0.42201668f, -0.26687109f, -0.02578824f, 
    -0.28364599f, 0.24570133f, -0.06037209f, 0.12272434f, 0.18900403f, -0.31341684f, 0.14152336f, 0.13244633f, 
    0.29547179f, -0.41717005f, 0.04292386f, 0.08266866f, -0.50976676f, 0.15398234f, -0.01213898f, -0.02896426f, 
    0.18613669f, 0.08112812f, 0.00728631f, 0.08547395f, -0.05209779f, 0.30853629f, 0.03262262f, 0.13182107f, 
    -0.09664490f, -0.21742669f, 0.11943424f, -0.24226655f, -0.09295897f, -0.04903206f, -0.37727228f, -0.10980205f, 
    -0.02734295f, -0.11728239f, -0.33676299f, -0.18330471f, 0.05781045f, -0.05698695f, 0.24624950f, -0.03796405f, 
    -0.30507186f, -0.52011359f, 0.18648612f, -0.27281511f, 0.01568224f, -0.14351098f, -0.42853725f, 0.29527655f, 
    0.00236113f, -0.12750962f, 0.00899964f, -0.36658263f, -0.07443992f, 0.11205382f, -0.33785862f, -0.54593664f, 
    -0.00850909f, -0.02239252f, 0.23798418f, -0.07305671f, 0.20894794f, 0.05794959f, -0.42981431f, 0.02441865f, 
    0.01341350f, 0.02001797f, 0.24829084f, -0.22977358f, -0.34279990f, 0.29385889f, -0.41696176f, 0.14569537f, 
    -0.27428183f, -0.40536067f, -0.00132294f, 0.06736600f, 0.21887384f, 0.15672778f, -0.20635292f, 0.12025518f, 
    -0.19717482f, -0.02713770f, 0.24765119f, -0.24110065f, -0.32115188f, 0.05681572f, 0.31799823f, 0.53469288f, 
    0.04998869f, 0.09029439f, -0.36282983f, -0.01500597f, 0.02748599f, -0.03677144f, 0.30307877f, 0.05253079f, 
    -0.28737956f, -0.39701879f, -0.02612466f, -0.28466126f, 0.18429960f, -0.61799121f, -0.21419385f, -0.06746732f, 
    -0.07231107f, 0.23311850f, -0.16206668f, 0.07900610f, 0.13243079f, -0.06727467f, -0.34228197f, -0.33700886f, 
    -0.04263010f, 0.05641268f, -0.23744129f, 0.19521822f, -0.15964696f, -0.12927265f, -0.01891897f, -0.20892313f, 
    -0.20597027f, 0.04193980f, -0.22076298f, 0.11465558f, -0.04902244f, -0.51331145f, 0.25433972f, 0.07108884f, 
    -0.47276202f, 0.18033187f, 0.02318890f, -0.24341233f, -0.19450772f, 0.01575097f, 0.00993301f, 0.12688109f, 
    0.12493537f, -0.54596609f, -0.07770459f, -0.06990721f, 0.14554006f, 0.11896625f, 0.03342207f, -0.05177382f, 
    0.09369326f, -0.47722319f, -0.23369129f, -0.03779830f, -0.27845743f, 0.09043474f, -0.33785510f, -0.04611943f, 
    -0.04982356f, -0.11964680f, 0.11299440f, 0.30956846f, -0.08797137f, 0.17746209f, 0.09264041f, -0.50465024f, 
    0.07956634f, -0.32089883f, 0.24156976f, 0.12794255f, -0.03996611f, 0.04358691f, 0.14005090f, 0.06511164f, 
    -0.22316383f, 0.21334979f, 0.00420932f, 0.11834850f, 0.07512552f, -0.01330149f, 0.04086644f, 0.03853824f, 
    -0.05944778f, 0.07190809f, 0.02863817f, -0.34787053f, -0.36382714f, -0.02634040f, -0.26345846f, 0.07311738f, 
    -0.25047404f, -0.04132120f, 0.06999002f, 0.08638357f, 0.04200610f, 0.14205523f, -0.16245925f, -0.00657939f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21424596f, 0.10331585f, 0.02291324f, -0.07501408f, 0.01787090f, -0.02166128f, -0.02866560f, -0.11060724f, 
    0.03383532f, -0.00105170f, 0.09613489f, 0.06023354f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
