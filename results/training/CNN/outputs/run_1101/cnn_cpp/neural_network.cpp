#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.13039088f, -1.48438132f, -0.73896486f, 0.28466621f, 0.74491918f, -0.57220155f, -0.67774206f, -1.49997878f, 
    -1.12479639f, 0.21711344f, 0.37677336f, -0.13134795f, 0.73678070f, 0.71199584f, 0.28153622f, -0.14472847f, 
    0.02113284f, -0.48231477f, -0.35989460f, -0.34990677f, 0.41444287f, -0.28678030f, -0.16273265f, 0.13689490f, 
    -0.12232915f, 1.44319868f, 0.97088325f, -0.32466200f, -0.62844342f, 0.18482438f, 0.72012395f, 0.28836524f, 
    0.38143259f, -0.51020205f, -0.83283728f, -0.37801164f, 0.22101066f, -0.00327826f, -0.23841026f, -0.36911935f, 
    -0.11586910f, -0.36664701f, 0.13388969f, -0.29213715f, -0.04357624f, -0.02476857f, 0.10391161f, -0.10909051f, 
    0.01112924f, -0.04296547f, -0.62702006f, 0.24472935f, 0.22675164f, -0.10421306f, -0.06901214f, -0.52120966f, 
    0.20161705f, -0.12149486f, 0.34932610f, 0.30727252f, 0.19732429f, 0.07472020f, -0.44544628f, 0.54534101f, 
    -0.58137316f, 0.17710333f, -0.04365722f, -0.47206983f, -0.57302910f, 0.19560388f, -0.14110817f, 0.48250416f, 
    0.48625672f, 0.09300946f, 0.30424464f, 1.43565333f, 0.87950397f, -0.89672482f, -0.31614637f, -1.33655858f, 
    -0.08780583f, -0.00347702f, -0.17473534f, 0.01960892f, 0.86704791f, 0.14650066f, 0.06469110f, -0.01423710f, 
    -0.09110980f, 0.01972012f, 0.00401634f, -0.14086398f, 0.35012770f, 0.13986899f, -0.51116264f, -0.01625291f, 
    -0.02979548f, 0.21475130f, -0.09470222f, 0.27594730f, 0.36426306f, 0.63495374f, 0.57462853f, 0.51126516f, 
    0.53057230f, -0.47537199f, -0.22088842f, -0.45561975f, 0.15583086f, -0.62739092f, -0.09058733f, -0.27898136f, 
    -0.13511753f, 0.27980819f, -0.39161366f, 0.05498976f, -0.13148916f, 0.17342684f, 0.04994659f, -0.06634850f, 
    0.11714684f, 0.04744299f, 0.00237384f, 0.22787586f, 0.03094177f, -0.04806595f, -0.22920404f, 0.53135717f, 
    0.05693814f, 0.54247177f, 1.03870308f, -0.08595660f, -0.35305393f, -0.55684316f, -0.32673168f, -0.24669538f, 
    0.53092617f, -0.03350551f, -0.29314557f, -0.20542458f, -0.60391784f, 0.07574429f, 0.11534765f, 0.28121671f, 
    -0.16340426f, 0.43484467f, -0.17248715f, -0.49980688f, 0.07702678f, -0.06850263f, -0.61192536f, -0.07507760f, 
    0.98137438f, -1.73654664f, -1.08616567f, -0.00571052f, 0.12695464f, 0.73284572f, 0.12433722f, 0.60216916f, 
    -0.58620447f, -0.38952485f, 0.29766566f, 0.05429850f, 0.20863183f, 0.02597836f, 0.20134416f, -0.17252013f, 
    -0.05310523f, 0.06944277f, -0.10876048f, -0.04721875f, -0.00184149f, -0.30191743f, -0.37503242f, 0.06883018f, 
    -0.47646832f, 0.04226354f, 0.13966246f, 0.59777647f, 0.60033143f, -0.07834992f, -1.40739095f, -1.07515955f, 
    -0.41670692f, -0.35628945f, -0.66682786f, 0.14941722f, -0.48418874f, -0.60520071f, -0.48056793f, -0.58665675f, 
    -0.60352200f, -0.23392744f, -0.57779986f, 0.03053834f, -0.11012513f, -0.31939253f, 0.15282674f, -0.20688863f, 
    -2.08064771f, -0.56456167f, -0.63186997f, -1.64915717f, -0.64197433f, 0.77810544f, 0.13105716f, -0.98199922f, 
    -0.88986498f, -0.16117521f, -0.53259373f, -0.54857939f, -0.70061904f, -0.75547594f, -0.65081060f, 0.16322261f, 
    0.16312857f, -0.24138118f, 0.03379820f, -0.31231502f, -0.14207651f, 0.08780633f, -0.00164042f, -0.07024347f, 
    -0.20170204f, -1.56337142f, -0.76114750f, 0.46977305f, -0.72912765f, -0.56842399f, 0.76469356f, 0.53483683f, 
    0.23958462f, 0.20060150f, 0.66650391f, 0.11174698f, -0.02763612f, 0.33049974f, 0.21543689f, 0.21645391f, 
    -0.07033349f, -0.07940524f, -0.06335429f, -0.16241020f, -0.00626109f, -0.03455175f, 0.10698693f, 0.23243982f, 
    -0.07312952f, -0.17820834f, 0.03188343f, 0.53875363f, 0.31701696f, 0.09851971f, -0.30818412f, -0.95685554f, 
    -0.45097685f, 0.37046245f, 0.62145704f, -0.31352496f, -0.12859458f, 0.26835179f, 0.96239901f, -0.39121771f, 
    -0.64180690f, 0.03486186f, 0.00882030f, 0.21906847f, 0.24216023f, -0.43851662f, -0.08551992f, 0.06528742f, 
    -0.20173687f, 0.00775039f, 0.24645604f, -0.55357820f, -0.36304611f, -0.15201961f, -0.34980074f, -0.19819373f, 
    -0.62200505f, -0.46469563f, -0.19440466f, -0.54064691f, -0.68694270f, 0.26651335f, -0.66188836f, -0.13522589f, 
    0.71642804f, -0.50695121f, 0.06041343f, -0.22016791f, 0.00516272f, 0.36013559f, 0.26348826f, -0.22107540f, 
    0.18199475f, 0.06047409f, 0.23851934f, 0.75735176f, 0.74360299f, 0.87633705f, 0.47569105f, -0.19640766f, 
    -0.08267008f, -0.46466383f, -0.14216001f, 0.50132972f, 0.09369268f, -0.28855276f, -0.34902254f, -0.31214067f, 
    -0.15766738f, -0.01695356f, -0.14924686f, 0.20267148f, 0.32458410f, 0.10889179f, 0.22038731f, -0.18015116f, 
    0.10988442f, -0.26441413f, -0.46410450f, -0.57637417f, -0.61181265f, -0.02118366f, 0.85042536f, 0.54317117f, 
    -0.43834126f, -0.01066445f, -0.60494310f, 0.18927599f, 0.28904253f, 0.10833192f, 0.29125750f, 0.10718018f, 
    0.13322473f, 0.48284844f, -0.48583078f, -0.22183380f, 0.08392040f, -0.27525741f, -0.19873001f, 0.26112440f, 
    0.19714540f, -0.23819533f, 0.45159730f, -0.15520434f, -0.25925377f, 0.40289766f, 0.34241867f, 0.32641095f, 
    0.21322742f, -0.15644109f, 0.16503058f, 0.38243797f, 0.62791097f, 0.49931362f, 0.25263408f, 0.35451415f, 
    0.11549132f, -0.08259968f, 0.03271451f, 0.12765582f, 0.43002567f, 0.25336874f, -0.13351910f, -0.13292725f, 
    -0.07617161f, 0.20643838f, 0.05840563f, 0.11443839f, -0.15649287f, -0.10751446f, 0.06713007f, -1.14770043f, 
    -0.37307206f, -1.05770028f, -0.71037149f, -0.46322587f, -0.01787103f, 0.28484404f, 0.95642710f, 0.95919180f, 
    0.62316549f, 0.28874129f, 0.53612238f, -0.25039327f, -0.15182370f, -0.26709935f, -0.45693895f, -0.20190281f, 
    -0.01739275f, -0.36976513f, -0.25843382f, -0.29169947f, -0.08354232f, -0.11118836f, 0.04467830f, -0.19754182f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30150712f, 0.67562824f, 0.46993756f, 0.54022408f, 0.08323082f, 0.65814650f, 0.60491735f, 0.12908952f, 
    -0.87299931f, 0.09555704f, 0.47194526f, 0.40373003f, 0.26728794f, 0.78782737f, 0.11647042f, 0.07241453f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.51753521f, 0.50173301f, -0.12094413f, -0.62497908f, 0.15637287f, 0.07624169f, 0.00598499f, 0.02396906f, 
    0.00459647f, -0.11188027f, 0.00428405f, -0.10986091f, -0.55576152f, -0.67208928f, -1.39757705f, 0.68920600f, 
    0.12462045f, -0.00012234f, -0.03741309f, 0.06678858f, 0.00500935f, 0.05937091f, -0.02458009f, -0.06712405f, 
    -0.25541648f, 0.22040989f, 0.23843750f, -0.14575170f, 0.04593749f, -0.13524900f, 0.04526517f, -0.04496966f, 
    -0.15653859f, -0.12179434f, -0.19978149f, -0.23741874f, -0.37340626f, -0.51135445f, -0.53016627f, 0.22891945f, 
    -0.05241205f, 0.18719967f, -0.11032514f, -0.20290327f, -0.32413635f, -0.14028078f, -0.07114030f, -0.02908090f, 
    0.13699257f, -0.02492893f, -0.01901389f, 0.02983524f, -0.03089309f, -0.08302606f, -0.04876773f, 0.09907288f, 
    0.03421074f, 0.08991803f, 0.02732315f, 0.05394818f, -0.19738302f, -0.22304641f, -0.50135422f, 0.32572865f, 
    -0.01190637f, -0.04890162f, -0.02670233f, -0.06651151f, -0.03529839f, -0.04699999f, 0.09156514f, -0.09168758f, 
    -0.61050397f, -0.46310815f, 0.12427557f, -0.01460010f, 0.01020381f, 0.11472867f, -0.19618295f, -0.25460091f, 
    -0.01944525f, -0.02173999f, 0.08164857f, -0.10169826f, 0.52564371f, 0.19036432f, -0.51589382f, 0.03736488f, 
    -0.15956378f, -0.23538503f, -0.06207919f, -0.15896352f, -0.14614515f, -0.09131746f, -0.06502702f, 0.20184952f, 
    0.56418765f, 0.52426040f, -0.22819763f, -0.27858186f, 0.04678546f, 0.55059409f, 0.16410324f, 0.22266437f, 
    -0.00684480f, -0.03299908f, -0.03009309f, -0.12537079f, 0.32165152f, -0.18611960f, 0.06912577f, -0.01961784f, 
    0.11796220f, 0.22353980f, 0.03568026f, 0.11210726f, 0.05313018f, -0.00665826f, -0.08575785f, 0.08809616f, 
    -0.18621030f, -0.40286186f, 0.11062285f, -0.13949159f, -0.05438738f, -0.18338078f, -0.34798428f, 0.05264094f, 
    0.02140566f, -0.03450372f, -0.06181256f, -0.04746674f, 0.39029020f, 0.22059128f, 0.00689760f, -0.35466596f, 
    0.08023608f, 0.04875356f, 0.11023081f, 0.04947787f, 0.02742705f, 0.00568715f, 0.04231434f, -0.14893198f, 
    -0.60541499f, -0.33328679f, 0.00589104f, 0.05774394f, 0.02452308f, 0.03648306f, -0.23105623f, -0.11190575f, 
    0.09340321f, 0.02983907f, -0.10608350f, 0.03733141f, -0.57663471f, -0.42704695f, -0.10868591f, 0.18189123f, 
    0.11561262f, 0.00514010f, 0.00440430f, 0.02268623f, -0.08100371f, -0.08515862f, -0.03399075f, -0.00088307f, 
    -0.03361078f, -0.06013215f, 0.06086376f, 0.12166216f, 0.03927103f, -0.02145497f, 0.02111421f, 0.10401828f, 
    -0.37962112f, -0.27240339f, -0.19802025f, -0.21759242f, 0.15890996f, -0.28413498f, 0.02862888f, -0.08014979f, 
    0.27159888f, 0.09272102f, 0.10915701f, 0.07919936f, -0.00851266f, -0.04500474f, -0.02944046f, 0.12129280f, 
    -0.41924611f, -0.19962031f, 0.11082086f, 0.01724443f, -0.07516655f, 0.03420386f, 0.32405007f, 0.18622606f, 
    0.10192253f, -0.09423832f, 0.08113553f, 0.06114127f, 0.93849540f, 0.12154689f, 0.01062138f, 0.15148021f, 
    -0.00223676f, -0.08072923f, 0.03280633f, -0.02475378f, -0.12137236f, 0.00398746f, -0.13405758f, 0.11713793f, 
    -0.14487785f, -0.10087939f, -0.07373378f, -0.07816874f, 0.24774100f, 0.14414740f, 0.03261757f, 0.10960646f, 
    0.04503122f, -0.04005766f, -0.05662131f, 0.11453853f, 0.26533985f, -0.50608367f, 0.51246899f, -0.46231323f, 
    0.16524051f, 0.01666656f, -0.06084681f, -0.02452153f, 0.15788890f, 0.11372393f, 0.06123462f, -0.25692907f, 
    -0.06659982f, 0.03727273f, -0.23360407f, -0.03691056f, -0.23228592f, -0.19682306f, -0.06784347f, -0.13136046f, 
    -0.05355307f, -0.02959757f, 0.03635280f, -0.00935345f, 0.25741217f, -0.03680535f, -0.24484761f, 0.28125960f, 
    -0.06823766f, -0.01114682f, -0.00759828f, -0.03245742f, 0.08444447f, -0.14490962f, 0.00151864f, 0.13991067f, 
    -0.39098653f, -0.33797663f, 0.03330260f, -0.18012880f, 0.21003293f, 0.24121001f, -0.50302219f, -0.15386567f, 
    -0.14854987f, 0.02799102f, -0.06246134f, -0.08595333f, 0.09167263f, -0.78018421f, -0.75066572f, -0.09028807f, 
    0.09374534f, -0.11945070f, 0.10606940f, -0.04236325f, 0.01336470f, -0.03629231f, -0.09694959f, -0.18439132f, 
    0.56657946f, 0.43747017f, 0.33069631f, 0.17838393f, 0.05938999f, -0.09885912f, -0.18510365f, -0.01961580f, 
    0.05591119f, 0.10060447f, 0.01611976f, -0.01159817f, 0.08445470f, -0.02300991f, -0.03396057f, -0.18892452f, 
    -0.11404743f, 0.02747609f, 0.07722038f, 0.02845853f, -0.28060064f, 0.12517601f, 0.20718928f, -0.24605592f, 
    -0.22764091f, 0.07031929f, 0.31950703f, -0.21901245f, -0.01010105f, 0.15327913f, -0.04022719f, -0.04047662f, 
    -0.00699396f, -0.14952552f, 0.07892590f, 0.12315842f, 0.04034130f, 0.00245062f, 0.27393270f, -0.13477188f, 
    0.08835630f, 0.11375216f, 0.25382787f, -0.20840688f, -0.02248241f, -0.10487697f, -0.00591286f, -0.04962672f, 
    0.06258694f, 0.02216013f, 0.16075203f, 0.18897684f, -0.00190840f, -0.09449567f, -0.16293982f, 0.13955501f, 
    0.03489910f, -0.08868980f, -0.02910854f, 0.01592889f, 0.25299254f, 0.00096737f, 0.37932530f, 0.03602438f, 
    -0.07315197f, 0.05327052f, -0.05161019f, -0.05007176f, -0.02585818f, 0.02677901f, -0.08161262f, 0.04631932f, 
    0.07292163f, 0.07138709f, 0.22249797f, 0.24142723f, -0.04926503f, -0.07374455f, -0.07139216f, -0.01123499f, 
    0.21376437f, 0.06234119f, 0.10325799f, -0.01630123f, -0.46712720f, -0.28171521f, -0.12396462f, -0.30824390f, 
    -0.11335762f, 0.11797228f, -0.05947573f, 0.02027922f, 0.03911685f, -0.11517414f, -0.25549409f, -0.15675136f, 
    -0.29949415f, -1.34715068f, -0.06720514f, 0.06998662f, 0.08166251f, -0.27572116f, -0.23726854f, 0.02164755f, 
    -0.13074158f, -0.00833525f, -0.02451242f, -0.08232146f, -0.01704334f, -0.23976079f, 0.29889891f, -0.76928174f, 
    0.05070208f, -0.17571266f, -0.03720253f, 0.04304035f, 0.03727973f, 0.03410523f, 0.00456340f, 0.03379237f, 
    0.21791187f, -0.33593604f, -0.28294230f, -0.18279158f, 0.08112253f, -0.00148164f, -0.04327911f, 0.03787038f, 
    -0.02868065f, -0.14692517f, -0.09039814f, 0.13862872f, -0.49962857f, 0.19655032f, 0.36799106f, -0.35603338f, 
    0.10306433f, 0.26042899f, -0.16891870f, -0.11735895f, 0.01549891f, -0.02150732f, -0.05215722f, 0.15544166f, 
    -0.35650283f, -0.00725014f, -0.13621876f, -0.20793872f, -0.07914536f, -0.05818753f, 0.14693475f, 0.04881902f, 
    -0.12552710f, -0.02267725f, 0.05421431f, -0.06138096f, 0.59016716f, 0.20912409f, -0.18996327f, -0.51906747f, 
    0.07792529f, -0.08031497f, -0.05459694f, 0.25489902f, 0.13068973f, -0.07292457f, 0.13065319f, -0.12666157f, 
    0.67657113f, 0.25482589f, 0.14479573f, 0.33551639f, -0.12415449f, 0.06221940f, 0.18494536f, -0.05820759f, 
    0.20151706f, 0.15674219f, 0.10595146f, -0.11341099f, 0.14767712f, 0.76457161f, -0.21392533f, -0.31859523f, 
    0.08432095f, -0.03474388f, 0.09504981f, -0.01176857f, -0.00766757f, -0.05430468f, 0.26385632f, -0.24580529f, 
    -1.38279057f, -0.19359726f, 0.63695562f, 0.34545529f, -0.07213025f, -0.27290583f, -0.00917671f, -0.08923036f, 
    0.04345052f, -0.06792343f, -0.05283125f, 0.10508385f, 0.56900972f, 0.02369430f, 0.41139188f, 0.44233558f, 
    -0.02116103f, 0.00487023f, 0.01158160f, -0.03622508f, -0.18648162f, -0.10315229f, 0.20034590f, -0.14152332f, 
    -0.22233281f, -0.20102195f, -0.08061051f, -0.02520826f, -0.17163819f, 0.12849241f, 0.03359979f, 0.05951815f, 
    -0.06617014f, -0.11570060f, 0.21076171f, -0.11191329f, -0.34074715f, -0.14935642f, -0.23454964f, -0.19193351f, 
    0.11213490f, 0.19977319f, -0.03611361f, 0.05622281f, -0.15061811f, -0.02919935f, 0.08551370f, -0.11944092f, 
    -0.19728386f, -0.04494995f, -0.12490521f, -0.10540234f, -0.01862910f, -0.00144892f, -0.01001194f, -0.07754469f, 
    0.07341272f, -0.23440938f, -0.02680782f, 0.08951727f, 0.28062287f, -0.16956405f, 0.01367164f, -0.09323274f, 
    0.02767011f, 0.07168541f, -0.00566018f, 0.13096134f, -0.00495236f, -0.05953417f, 0.09678896f, -0.09897138f, 
    -0.12992026f, -0.23815125f, -0.05234026f, 0.00322703f, 0.09323741f, 0.05215104f, -0.03974511f, -0.02905811f, 
    -0.17217904f, 0.07024648f, 0.03843885f, 0.25651941f, -0.26239389f, 1.20079589f, 0.10794575f, 0.26504147f, 
    -0.17308271f, 0.03837825f, 0.10425571f, -0.06884555f, -0.12098157f, -0.05964635f, -0.05697682f, -0.06111965f, 
    0.04054188f, 0.12184665f, -0.44900939f, 0.23605451f, 0.20845534f, 0.06224761f, 0.00404389f, 0.02359718f, 
    -0.27001941f, -0.05555297f, -0.07851513f, -0.07554759f, 0.08098248f, -0.09252993f, 1.13696182f, 0.44745907f, 
    0.08518862f, -0.03812967f, -0.24729607f, -0.21856961f, 0.15091342f, -0.03641127f, -0.01691150f, -0.02518315f, 
    0.30996299f, 0.03748833f, -0.16808352f, -0.14072375f, 0.04212931f, 0.11322149f, -0.24553378f, -0.05070410f, 
    -0.13870345f, 0.11055596f, -0.05546584f, -0.10926658f, -1.51179421f, -0.04951179f, -0.50226557f, 0.78478944f, 
    -0.48330462f, 0.27241090f, -0.54937047f, -0.15416631f, -0.02593869f, -0.09197812f, 0.13311154f, -0.04634335f, 
    -0.14091884f, -0.66019249f, -0.02218642f, 0.32195327f, -0.54471928f, -0.08753136f, -0.03392116f, -0.05048358f, 
    0.02777919f, -0.04895857f, 0.28442851f, 0.07139099f, -0.76991922f, 0.82829815f, 0.10507125f, -0.36019298f, 
    -0.11996263f, -0.19528298f, -0.03729476f, -0.52169120f, -0.29029131f, -0.13339166f, -0.19680455f, 0.28390014f, 
    1.11074758f, -0.19834022f, 0.10105518f, 0.49633625f, 0.02241345f, 0.02551315f, -0.19817249f, -0.02787244f, 
    -0.08009546f, 0.03518179f, 0.06880235f, 0.32535437f, -0.38756233f, 0.49223000f, -0.18917741f, 0.26161185f, 
    -0.02194602f, -0.02663533f, 0.02346439f, -0.12476908f, -0.17013523f, -0.12614265f, 0.03626047f, 0.05621885f, 
    0.39236385f, -0.37134549f, -0.16370818f, 0.43231082f, 0.08711688f, 0.02094687f, -0.07081802f, -0.08200301f, 
    -0.04393100f, 0.03775087f, 0.05014075f, 0.07229077f, 0.35727894f, -0.21820435f, 0.19646834f, 0.04683349f, 
    0.43590686f, 0.25720453f, -0.07720065f, 0.19087811f, -0.30774474f, 0.02559204f, -0.07343289f, 0.01103350f, 
    0.08368802f, -0.31956315f, -0.26243025f, -0.14084597f, -0.16528858f, -0.07775015f, -0.08112530f, -0.20562720f, 
    0.03181114f, 0.12347492f, -0.19937947f, -0.12973927f, -0.09816417f, -0.29146183f, -0.16837448f, 0.13667220f, 
    -0.08461826f, 0.15314835f, -0.17297839f, -0.14932249f, 0.10463243f, -0.07360799f, 0.06187793f, -0.32798696f, 
    0.43459103f, -0.06286672f, 0.78894269f, -0.13119498f, -0.43190390f, 0.17997007f, 0.22845438f, 0.20988864f, 
    0.21952707f, 0.30951384f, 0.07184202f, 0.09623961f, -0.21909447f, 0.18115123f, -0.22594863f, -0.27381891f, 
    -0.16560850f, -0.08898843f, -0.41062769f, -0.07313896f, -0.06074141f, -0.25392488f, 0.07893465f, -0.32189006f, 
    -0.71032393f, -0.41887870f, -0.71055603f, -0.04949852f, 0.40021151f, 0.26089475f, 0.21252102f, 0.10112802f, 
    -0.08468530f, -0.14768770f, 0.08223183f, -0.08291099f, 0.37408924f, -0.26342872f, -0.06779864f, 0.22747681f, 
    0.37463596f, 0.05677439f, 0.09399977f, -0.07577044f, -0.11598494f, 0.10931403f, -0.21581858f, 0.12071281f, 
    0.28945076f, 0.38659331f, 0.30018547f, 0.52753848f, -0.06616499f, -0.02112714f, -0.12237814f, 0.03377035f, 
    -0.16214429f, 0.04665347f, -0.11865039f, 0.11570890f, -0.36495951f, -0.24043533f, -1.29083967f, -0.09226353f, 
    0.09121256f, 0.08688223f, 0.06357444f, -0.03961532f, 0.02187497f, 0.01700450f, 0.19371544f, -0.09801847f, 
    0.09324215f, -0.02747633f, -0.24321972f, 0.20914468f, 0.08341361f, -0.13692009f, 0.03941644f, -0.17356926f, 
    -0.01141348f, -0.30134407f, -0.29482487f, -0.26639023f, -0.54210705f, -0.21238093f, -0.27975395f, 0.19455281f, 
    0.22313799f, -0.07723942f, -0.20791899f, -0.06038637f, -0.04353609f, -0.21822350f, 0.04896197f, 0.03535428f, 
    0.28530023f, 0.07933827f, 0.38297811f, 0.43862402f, 0.09700847f, 0.11694413f, 0.00282492f, 0.14240907f, 
    0.14950971f, -0.01115087f, -0.00493693f, -0.11795619f, 0.19494164f, -0.86840421f, -0.06139268f, 0.01974021f, 
    0.24547236f, -0.07806889f, -0.10325032f, 0.00534570f, -0.05773617f, 0.10116141f, -0.09268823f, 0.02731239f, 
    -0.89104503f, 0.05802501f, -0.11491981f, -0.37412304f, -0.31233722f, -0.38636795f, -0.05800505f, -0.17319132f, 
    -0.14350685f, -0.27423915f, 0.03864958f, 0.23567548f, 0.12080323f, 0.14040136f, 0.52406490f, 0.09950783f, 
    0.10362583f, 0.03006319f, 0.01639789f, 0.17973536f, -0.08976231f, 0.02960174f, -0.05224854f, 0.03330000f, 
    -0.48238036f, -0.21634008f, 0.04103580f, 0.35651928f, 0.09261479f, 0.07950902f, 0.03379174f, -0.15948437f, 
    0.07488237f, -0.03462687f, 0.02985229f, -0.00148893f, -0.13519683f, 0.26111835f, -0.02129142f, 0.05971527f, 
    -0.17147075f, -0.19832657f, 0.05306472f, -0.06331682f, 0.17361084f, -0.24772850f, -0.01642046f, 0.03244451f, 
    0.06774783f, -0.06248790f, -0.14406982f, -0.18730944f, -0.15552858f, -0.10668328f, 0.17478122f, -0.13342629f, 
    0.05027195f, -0.12477909f, -0.12198384f, -0.28252679f, -0.10635586f, 0.20446660f, 0.19269757f, 0.28362209f, 
    -0.23124701f, -0.08950184f, -0.23211819f, 0.25312147f, -0.01489553f, -0.03215197f, -0.10165384f, -0.07343058f, 
    0.35269907f, 0.36012682f, -0.36210251f, -0.02057914f, 0.07536660f, 0.00291829f, -0.05650340f, -0.21498698f, 
    0.20530981f, -0.04333132f, 0.05082553f, 0.21556395f, 0.13354474f, -0.05256114f, -0.29409835f, -0.20361871f, 
    -0.04383874f, -0.04964149f, 0.14225714f, -0.06646076f, 0.17849746f, 0.00264882f, -0.10286412f, -0.12874494f, 
    0.05892697f, 0.04193287f, -0.07751414f, -0.10193720f, 0.12790750f, 0.04637803f, 0.07276311f, 0.14780152f, 
    -0.03183626f, 0.00222970f, 0.05176973f, 0.04981406f, 0.20007038f, 0.30450115f, 0.08034555f, 0.04671207f, 
    -0.04068834f, -0.10819718f, 0.13627493f, 0.23357302f, 0.13788278f, -0.08806722f, 0.05600996f, 0.11008771f, 
    0.21011229f, 0.19095536f, 0.43616319f, -0.34154138f, 0.24129687f, 0.00520516f, -0.11929099f, 0.10919066f, 
    0.14587590f, 0.06475765f, -0.09977138f, 0.10337511f, -0.22671191f, -0.05950793f, -0.96321374f, -0.01777608f, 
    0.05842936f, 0.19944228f, 0.12855932f, 0.06424315f, 0.08699137f, -0.09704933f, 0.00802041f, -0.11241118f, 
    -0.30429327f, 0.08198233f, 0.30459845f, 0.26893359f, -0.26290309f, -0.23933104f, -0.06746667f, -0.03519023f, 
    0.06860700f, 0.04168201f, 0.09235348f, 0.23481946f, 0.69416285f, 0.05797894f, -0.63337028f, -0.07956201f, 
    -0.04511276f, 0.07916445f, -0.08575370f, 0.09723793f, 0.23172747f, -0.01603826f, -0.16768575f, 0.03233982f, 
    -0.15155666f, -0.18863925f, 0.05245828f, 0.08462911f, 0.35675925f, 0.08676268f, -0.00118393f, -0.01415904f, 
    -0.00520847f, 0.02918610f, -0.07809818f, 0.04237596f, -0.06616773f, -0.12997511f, 0.09756526f, 0.00767191f, 
    0.08055703f, 0.03554261f, -0.06382765f, 0.14105064f, 0.14902709f, 0.14039873f, 0.17912118f, -0.07273147f, 
    0.01565550f, -0.06932754f, -0.29557660f, 0.01771989f, 0.26206186f, -0.34407705f, 0.14298417f, 0.17051739f, 
    -0.06677808f, 0.02794793f, -0.16823651f, -0.26235068f, 0.01848905f, 0.38223803f, 0.17387895f, -0.39490524f, 
    -0.12597993f, -0.02973827f, -0.03108124f, 0.21917509f, 0.04620487f, -0.03544973f, -0.10401297f, -0.07557277f, 
    -0.50631100f, 0.42502871f, 0.26081419f, -0.48777992f, -0.06100656f, -0.20049433f, 0.22403261f, -0.00756789f, 
    -0.09870426f, -0.02292305f, 0.06725658f, 0.09088570f, -1.09098673f, -0.47253263f, -0.42830050f, -0.19335677f, 
    0.07314730f, -0.01776389f, -0.17220685f, -0.04145201f, 0.34009990f, 0.02005059f, -0.12945478f, -0.16144879f, 
    0.12048082f, -0.17404109f, -0.12893863f, 0.47379273f, 0.08060767f, -0.20273982f, -0.21606189f, 0.06736318f, 
    -0.04398604f, 0.09030708f, 0.08070765f, 0.08204596f, 0.09535436f, 0.04782997f, -0.03321891f, 0.11219826f, 
    0.13498208f, 0.35512322f, 0.28212431f, -0.18793759f, -0.06133648f, 0.13542339f, 0.01500649f, 0.32440934f, 
    -0.12513970f, -0.22317126f, -0.29389954f, 0.08139957f, 0.03042116f, 0.07805254f, 0.03193944f, -0.05935582f, 
    -0.09946486f, -0.07541177f, 0.00871083f, -0.40569836f, -0.71896911f, -0.06168099f, -0.57706124f, 0.49614963f, 
    0.24065493f, -0.14907816f, 0.01505451f, 0.10600772f, 0.15566984f, 0.06120116f, 0.06034786f, 0.41152203f, 
    -0.09088871f, -0.10648804f, -0.04903795f, 0.04542953f, -0.00404932f, -0.17650017f, -0.15969388f, -0.17826146f, 
    0.19824184f, 0.12423696f, -0.09967239f, 0.20543492f, -0.42324743f, -0.49026421f, -0.46486014f, 0.01469678f, 
    0.01337982f, -0.06600789f, -0.09518619f, -0.07702171f, 0.00946219f, -0.30866510f, 0.34282875f, -0.14947692f, 
    -1.52126157f, -1.21576083f, -0.70693982f, 0.39042205f, -0.07244968f, -0.17023699f, -0.09516084f, -0.14497088f, 
    -0.06917786f, 0.02454367f, -0.00124685f, 0.05652420f, -0.40531233f, -0.11665548f, 0.51488441f, -0.50152951f, 
    0.14317691f, -0.00845159f, 0.01079311f, -0.17066054f, 0.00117518f, 0.08136740f, -0.00323933f, -0.05777972f, 
    0.07261265f, -0.01945942f, 0.08743495f, 0.11658941f, -0.31290227f, -0.12968919f, -0.00578619f, 0.14819919f, 
    -0.07190946f, -0.13231982f, 0.31454960f, -0.31355882f, 1.36021149f, 0.04382766f, -0.69782901f, -0.03515340f, 
    0.00723931f, -0.32971466f, 0.35244635f, 0.18249987f, 0.20773417f, 0.12701045f, -0.02554114f, -0.10089625f, 
    -0.43944725f, -0.20474847f, -0.24521172f, -0.18088034f, 0.08639325f, 0.15932709f, 0.08094029f, -0.20243832f, 
    -0.05157587f, -0.09521423f, -0.15536956f, -0.04728266f, 0.00409330f, -0.03843007f, 0.03762043f, 0.08609261f, 
    0.29575181f, 0.22603135f, 0.03160263f, -0.12953910f, 0.10994238f, 0.02943200f, 0.04285634f, 0.15008391f, 
    0.87181854f, -0.18859306f, -0.23406026f, 0.30548820f, 0.03039609f, 0.18210171f, 0.29380590f, 0.40896770f, 
    -0.00158706f, 0.03991278f, 0.03604132f, 0.31713551f, -0.66731489f, -0.61382633f, -0.28112355f, -0.01012086f, 
    0.13926886f, 0.13650745f, -0.05871265f, -0.16296071f, 0.00308826f, 0.19603094f, 0.06680581f, 0.11051529f, 
    -0.81178010f, -1.58379841f, -0.47509041f, 0.05772410f, -0.15637133f, -0.02280770f, -0.10145216f, -0.46206337f, 
    -0.13910499f, 0.05913537f, 0.07135765f, -0.16107254f, -0.58268601f, 0.20652683f, 0.51026404f, 0.02449026f, 
    -0.11188290f, -0.02432669f, -0.16423638f, -0.11136764f, -0.13311696f, 0.03937951f, 0.10959480f, 0.35016495f, 
    0.21184802f, -0.14642987f, -0.38332513f, -0.60183823f, -0.07865480f, 0.06473507f, 0.40575826f, 0.02788758f, 
    -0.07745302f, 0.18699747f, -0.42936721f, -0.08553439f, -0.58525717f, -1.15653861f, -0.30891255f, -0.05461318f, 
    0.07243817f, -0.43113959f, -0.11516801f, -0.33816120f, -0.06912187f, -0.19769970f, -0.05959338f, -0.02773890f, 
    0.14009058f, 0.12130595f, 0.04701019f, -0.45789751f, 0.02181385f, 0.04851157f, 0.25154656f, -0.03943016f, 
    -0.13704368f, 0.05682670f, 0.17431337f, 0.06286694f, 0.26860896f, -0.06812140f, -0.16544625f, -0.00705481f, 
    0.06202050f, -0.02466430f, 0.11082165f, -0.06856991f, -0.08231329f, -0.04662330f, 0.02308546f, -0.24135986f, 
    0.23698814f, 0.09227816f, -0.10781127f, 0.08314071f, 0.02149020f, -0.04635166f, -0.02072553f, -0.00811892f, 
    -0.19442067f, -0.30178860f, 0.20768058f, -0.14445239f, -0.50868595f, 0.47720152f, 0.30594045f, 0.35828304f, 
    -0.20960493f, 0.04989504f, -0.17073327f, 0.12398952f, 0.06043680f, 0.23157591f, 0.04004962f, 0.10338921f, 
    0.22643548f, -1.56524110f, 1.01234376f, 0.16398934f, 0.00677825f, 0.03337770f, 0.00155620f, 0.26659119f, 
    -0.00213037f, 0.19530295f, 0.03167073f, -0.11501319f, -0.23616804f, 0.41668272f, -0.04648229f, 0.06342303f, 
    0.01622652f, -0.16020808f, 0.14006592f, 0.01677587f, 0.19029148f, -0.06331479f, 0.09545471f, -0.09899677f, 
    0.18076725f, 0.04535574f, -0.17788494f, 0.21004973f, -0.24343762f, 0.20460215f, 0.10584795f, 0.00386927f, 
    -0.04625287f, 0.08275811f, 0.03456793f, -0.17642199f, -0.50429928f, 0.11321048f, 0.24426465f, 0.07497659f, 
    -0.24035172f, -0.02225751f, 0.02923292f, 0.08872835f, -0.08397235f, -0.04898610f, 0.10101293f, -0.09890929f, 
    -0.10155321f, 0.01503256f, -0.05804187f, -0.14839794f, -0.02913965f, -0.08739334f, -0.02543506f, -0.05653573f, 
    0.06380714f, 0.09525513f, -0.00465560f, -0.01097075f, -0.08889963f, 0.16280329f, 0.07446918f, -0.19721472f, 
    0.02038858f, -0.09269625f, -0.09757280f, 0.07845511f, -0.18497935f, -0.01389566f, 0.01174932f, -0.22194244f, 
    -0.59897119f, -0.31327814f, -0.17566016f, 0.39794272f, -0.18182978f, 0.52051163f, -0.28661603f, 0.03375356f, 
    -0.09669244f, -0.18911864f, 0.18493530f, -0.23008502f, -0.03539274f, -0.22356559f, 0.54754972f, -0.01328731f, 
    -0.02740744f, -0.19569047f, -0.17548224f, -0.01739767f, -0.01068890f, 0.06235851f, -0.00757382f, -0.11642761f, 
    -0.44667751f, -0.73408586f, -0.18353437f, -0.71792573f, 0.05105762f, -0.22943015f, -0.12469095f, 0.54152846f, 
    0.03700874f, -0.16050711f, -0.15365662f, -0.08239173f, 0.82237709f, -0.56159037f, -0.24156848f, -0.37747237f, 
    0.06110794f, 0.09808955f, -0.17657422f, -0.06935188f, 0.20964456f, 0.08576687f, 0.22814861f, 0.32057571f, 
    0.07126052f, 0.00089832f, -0.21001408f, 0.14677997f, 0.03009667f, -0.08227908f, -0.12703381f, -0.21654545f, 
    0.00092996f, 0.00991684f, 0.00795679f, -0.01899718f, -1.55726624f, -0.66500491f, -0.48170906f, 0.17627466f, 
    -0.10068807f, -0.21761556f, -0.40832248f, -0.01060042f, 0.06394298f, 0.11510472f, 0.00095220f, -0.00553273f, 
    -0.04421597f, 0.19612545f, 0.06837487f, 0.16312101f, 0.00798775f, -0.01899084f, -0.01736071f, -0.11600766f, 
    -0.10500567f, 0.13804786f, 0.19525312f, 0.18059625f, -0.07404714f, 0.08724576f, -0.13173866f, -0.04021563f, 
    0.05458209f, -0.07449298f, 0.00932357f, -0.18183140f, 0.03054503f, 0.12328586f, -0.04391804f, -0.06077166f, 
    -0.00295212f, 0.08215011f, -0.00338117f, 0.00880988f, -0.01535164f, -0.09095551f, 0.03689660f, -0.11763114f, 
    -0.20510806f, -0.24043059f, -0.27837369f, -0.17814489f, 1.08869743f, -1.25239730f, -0.25139582f, -0.49258259f, 
    0.04619575f, -0.11729228f, -0.08521558f, -0.13145345f, 0.28677309f, 0.05985105f, -0.10306355f, -0.15993980f, 
    0.58953404f, -1.21271598f, -0.47096229f, -0.38715330f, -0.26375675f, 0.16707054f, 0.25870454f, -0.26898554f, 
    0.08349422f, 0.06168184f, 0.09646509f, 0.03251509f, -0.79631448f, 0.41248697f, 0.44869551f, 0.07542009f, 
    -0.35618514f, -0.11942908f, -0.07499221f, 0.03294298f, -0.10951590f, -0.07753392f, -0.20419911f, 0.10708178f, 
    0.28889433f, 0.06789899f, -0.12223434f, -0.18615930f, 0.24564943f, 0.08276039f, -0.08169069f, -0.05893273f, 
    0.13993961f, 0.29994398f, 0.33048245f, 0.35176668f, -1.08210099f, -0.13772251f, 0.29530784f, 0.32727247f, 
    0.10539782f, -0.08941607f, -0.06988752f, 0.08430709f, -0.08380142f, 0.14377497f, 0.21336728f, 0.25247008f, 
    0.05515003f, 0.28385508f, 0.28189465f, -0.01894450f, 0.02869924f, -0.21852084f, -0.05488591f, -0.14637899f, 
    -0.01224532f, -0.01799380f, -0.03211829f, 0.09563888f, 0.18376087f, 0.34973338f, 0.13920690f, -0.14753366f, 
    -0.26740700f, -0.03755087f, 0.08636823f, -0.02437798f, -0.03372608f, -0.12879471f, -0.12322576f, 0.04162510f, 
    -0.46973190f, -0.62193978f, -0.03668907f, 0.47864485f, 0.23197776f, 0.25615439f, 0.26655126f, 0.56054991f, 
    -0.32795760f, 0.12888190f, 0.06100925f, -0.28741756f, 0.27989683f, -0.68651658f, -0.24299416f, -0.59545940f, 
    -0.10799459f, -0.00118800f, -0.06785847f, -0.00445462f, 0.16794258f, 0.05466811f, -0.00873349f, -0.09345910f, 
    0.22217946f, -0.48760703f, -1.38298857f, -0.21300553f, -0.20986505f, 0.01970676f, 0.09074850f, -0.27530703f, 
    -0.01245743f, 0.00711269f, -0.06702431f, 0.04392723f, -0.47376785f, -0.68307835f, -0.43153000f, -0.41153634f, 
    -0.02655733f, 0.13753344f, 0.07512856f, 0.05297345f, 0.21113655f, -0.00129501f, -0.16978304f, -0.25087273f, 
    0.33418491f, 0.26636729f, -0.27616838f, 0.28798962f, 0.19347394f, -0.08362566f, 0.12520848f, 0.09662798f, 
    0.17911386f, -0.07088370f, 0.01623054f, 0.14810351f, 0.23860522f, -0.31325799f, 0.09564319f, 0.14815728f, 
    -0.09144191f, -0.04680092f, 0.02672867f, 0.14573546f, 0.12571375f, -0.04939013f, 0.13669734f, 0.16015515f, 
    -0.71213377f, -0.02651685f, 0.17383851f, 0.17491876f, -0.08329567f, -0.08644298f, -0.06020949f, -0.03628110f, 
    -0.56515920f, -0.44061404f, -0.36330813f, -0.37578195f, 0.25065219f, 0.27678204f, -0.13177137f, -0.04174953f, 
    -0.07508828f, -0.02778918f, 0.08143895f, 0.02710659f, -0.03428438f, 0.02830495f, -0.03429136f, 0.06437348f, 
    -0.49297652f, -0.01471532f, 0.08285930f, -0.17918456f, -0.20598359f, -0.10791516f, -0.06106234f, 0.01732201f, 
    0.08297981f, 0.17402846f, 0.01368643f, 0.14627612f, -0.35015059f, -0.14419389f, -0.24654187f, -0.04055508f, 
    0.07768521f, 0.08267038f, 0.13582864f, 0.14274868f, 0.19504395f, 0.02696899f, -0.01438773f, -0.09860674f, 
    -0.31602296f, -0.60130036f, 0.30210719f, 0.05986471f, -0.17271507f, 0.04022894f, -0.20032895f, 0.13007984f, 
    -0.09090012f, -0.14847180f, 0.08062012f, -0.04723832f, 0.11730458f, -0.01255447f, 0.02755123f, -0.11157167f, 
    0.05275362f, -0.02380449f, 0.20855244f, 0.06943499f, 0.13016069f, -0.02816537f, 0.12474237f, 0.01980275f, 
    -0.46992689f, 0.17551979f, 0.01059589f, 0.13190575f, 0.18148938f, 0.07195380f, 0.08726146f, -0.09656534f, 
    0.02622922f, -0.12374843f, -0.17880811f, -0.39969465f, -0.03154340f, 0.58627778f, 0.31323966f, -1.15962207f, 
    -0.13053635f, -0.40176269f, 0.16843209f, -0.17967312f, 0.03524489f, 0.13932252f, -0.11642963f, 0.07112101f, 
    -0.13452193f, -0.58197212f, -0.63441432f, 0.39997110f, 0.35993513f, 0.27287206f, 0.22526421f, 0.15418757f, 
    0.03848263f, -0.15076251f, -0.06558724f, -0.18188205f, -0.11615132f, -0.64670110f, 0.30816552f, -0.21363583f, 
    -0.03065803f, 0.33529803f, -0.09377580f, -0.02778158f, -0.12234635f, 0.28636611f, 0.05286605f, 0.11264145f, 
    -0.47260022f, 0.68053341f, -0.61621529f, -0.61681408f, -0.45627531f, -0.19152266f, -0.11355571f, -0.17706242f, 
    0.16301133f, 0.02770974f, 0.09276310f, -0.01096628f, -0.09106597f, -1.09865618f, 0.54545975f, -0.04025964f, 
    -0.02947165f, 0.24097179f, 0.06233594f, -0.04410410f, 0.03768562f, 0.05430281f, -0.00939538f, 0.06647473f, 
    -0.38208303f, -0.02910601f, 0.13191642f, -0.39672381f, -0.11540606f, 0.10100263f, -0.00825139f, 0.04496713f, 
    0.23457965f, 0.08569884f, 0.11576737f, -0.05798525f, -0.02497092f, 0.52118582f, -0.32730097f, 0.41271397f, 
    -0.16340646f, 0.03006380f, -0.28952748f, -0.14057946f, 0.02254870f, -0.20843482f, 0.04355095f, 0.18803948f, 
    -0.60278147f, 0.33543527f, -0.70557672f, 0.54698324f, 0.10362244f, -0.09003129f, 0.09345973f, 0.02591152f, 
    0.17998117f, 0.14114168f, -0.38053599f, -0.28112674f, -0.30263382f, -0.01693299f, -0.02500513f, -0.00867434f, 
    -0.26282084f, -0.44006225f, -0.10227432f, 0.28599620f, -0.08827498f, -0.18425840f, 0.04739256f, -0.16471305f, 
    -0.32231668f, 0.06551466f, -0.53103018f, -0.02856228f, 0.13968094f, 0.06496394f, 0.23061234f, -0.08870964f, 
    0.08559578f, 0.11153346f, -0.00986085f, 0.45245624f, -0.63715065f, -0.01665170f, -0.51602435f, 0.15362272f, 
    0.11447337f, -0.02200036f, 0.20524715f, -0.11801089f, 0.02683606f, -0.06030781f, -0.06080316f, -0.11352231f, 
    -0.19420961f, 0.02967355f, -0.07317638f, -0.00697755f, -0.04281653f, 0.12220467f, 0.18825884f, 0.00379239f, 
    0.06518313f, 0.07775659f, 0.24248284f, 0.08218248f, 0.45047405f, 0.16553640f, 0.76525378f, 0.12157281f, 
    0.18945466f, -0.39363676f, -0.02829600f, -0.15945393f, -0.09769703f, 0.19601209f, 0.13332085f, 0.13903710f, 
    -0.81572866f, 0.22312060f, -0.17077717f, 0.25983307f, -0.24722204f, 0.29086432f, 0.03788109f, -0.14276162f, 
    -0.13296728f, 0.24446732f, 0.02619258f, 0.01602468f, 0.02371797f, -0.36588392f, -0.05600207f, 0.31277189f, 
    -0.20837007f, -0.09540720f, -0.25942567f, 0.10835852f, 0.06785198f, -0.02924964f, 0.07212491f, 0.06849112f, 
    0.19044198f, 0.67753148f, 0.16549091f, -0.41352198f, -0.13101661f, 0.24203044f, 0.21097551f, 0.23788705f, 
    -0.13813464f, 0.32558808f, 0.20450778f, 0.50936311f, -0.19500126f, 0.70042259f, -0.60954177f, 0.35233292f, 
    -0.02887672f, 0.13224748f, 0.49904048f, -0.15017882f, -0.18895034f, 0.12817249f, -0.18023498f, -0.08393161f, 
    -0.51380700f, 0.18716541f, -0.40168139f, -0.42967343f, -0.40071654f, 0.12818570f, 0.01896865f, -0.47672057f, 
    0.01364125f, 0.20803939f, 0.05698039f, 0.27600792f, -0.31469098f, -0.28123158f, 0.24571368f, 0.41813418f, 
    -0.13098505f, -0.01374337f, 0.12073831f, 0.13858759f, -0.01468339f, -0.11762813f, -0.13198777f, -0.26834065f, 
    0.30742213f, -0.18036936f, 0.78658217f, 0.19446050f, 0.09122397f, -0.27337712f, 0.35615268f, 0.11579386f, 
    0.02673292f, 0.22314841f, -0.45820472f, -0.23448786f, -0.11620795f, -0.25860691f, -0.19088648f, 0.01171539f, 
    -0.28990611f, 0.09593834f, -0.18132792f, 0.12187711f, 0.23964395f, -0.02891155f, -0.34528032f, 0.02393962f, 
    0.23504937f, -0.87805599f, -0.37782151f, 0.01723084f, -0.14947745f, 0.14127769f, 0.18158470f, 0.09823371f, 
    -0.13258526f, -0.00444546f, 0.00729400f, -0.32510436f, 0.56226724f, 0.00933504f, 0.28706062f, -0.15212806f, 
    0.15412988f, -0.37395418f, 0.19798633f, 0.16395247f, -0.38911682f, 0.33380681f, 0.15360172f, -0.01144781f, 
    -0.24605347f, 0.53198338f, 0.40829369f, 0.20291907f, -0.25747097f, -0.10888030f, -0.20003311f, 0.17898966f, 
    -0.08991815f, 0.03160825f, 0.12441294f, 0.17394510f, -0.25631770f, 0.56727833f, -0.18332648f, 0.31022707f, 
    -0.11896859f, 0.14915852f, 0.05743177f, -0.04034570f, -0.04801740f, 0.34349656f, -0.05798474f, 0.21487522f, 
    0.02917640f, -0.06847677f, -0.20877592f, -0.37238571f, -0.12969968f, -0.42110702f, -0.28025332f, 0.05441811f, 
    -0.36548147f, -0.09978145f, -0.63600236f, -0.30284595f, -0.04303421f, -0.09872537f, 0.55778062f, -0.29490289f, 
    -0.42112184f, 0.07381327f, 0.24249028f, 0.00837942f, 0.03934430f, -0.18500933f, 0.10734671f, 0.07234672f, 
    0.04848291f, -0.31528080f, 0.00591570f, -0.70164084f, -0.21097589f, -0.29341963f, -0.01804070f, -0.11166347f, 
    -0.06627241f, 0.24798033f, 0.11740684f, -0.21116029f, -0.39360473f, 0.03650264f, -0.06294654f, -0.50990009f, 
    0.01407437f, 0.04105213f, -0.03962471f, -0.05495983f, 0.07314374f, -0.31538162f, -0.42543337f, -0.48145896f, 
    -0.79447049f, -0.50263995f, -0.66754454f, 0.06348442f, 0.10370154f, -0.44433174f, 0.09923321f, -0.49945959f, 
    0.14849578f, 0.02172893f, 0.20153092f, -0.04407681f, 0.05991996f, -0.03393298f, 0.04485878f, -0.21533436f, 
    -0.14673053f, 0.27904955f, -0.25653285f, 0.26675391f, -0.21420826f, 0.14405972f, 0.16207579f, 0.02397033f, 
    -0.18483736f, -0.23534431f, 0.48099661f, -0.02306719f, 0.23842348f, -0.17879243f, 0.01977230f, -0.09184554f, 
    0.08522183f, -0.02287911f, -0.16360569f, -0.53091747f, -0.06651691f, -0.15574129f, 0.58161581f, 0.28649297f, 
    0.13509583f, 0.16678089f, 0.25137934f, 0.22536655f, -0.41567877f, -0.12327068f, 0.05706429f, -0.07127397f, 
    0.77329034f, 0.16618405f, 0.48310739f, -0.43612152f, -0.10200665f, 0.11970999f, -0.28502452f, 0.18730660f, 
    -0.17652768f, -0.06135394f, -0.19907822f, -0.25452274f, -0.40513170f, 0.46226081f, -0.16287827f, 0.03258434f, 
    -0.17867856f, 0.09082513f, 0.28209221f, -0.21403059f, -0.14675058f, 0.05271949f, -0.19391118f, -0.00158793f, 
    0.29988608f, 0.69519210f, 0.31070873f, -1.05065095f, -0.12225805f, 0.15985358f, 0.40153989f, -0.11158304f, 
    0.22073209f, -0.14820459f, 0.07767670f, 0.14185415f, -0.87392366f, -0.05499689f, -0.00250998f, -0.04760299f, 
    -0.04757014f, -0.06857850f, 0.06156715f, -0.02965730f, 0.04663065f, 0.05407150f, 0.24963048f, 0.13398167f, 
    -0.00872661f, 0.10479964f, -0.14743076f, 0.02307510f, -0.30515134f, -0.05028955f, 0.11179818f, -0.06854202f, 
    0.05505737f, 0.01287802f, -0.00442914f, -0.09663969f, -1.00983834f, -0.00560703f, -0.59121025f, 0.24258685f, 
    0.12326082f, -0.06879382f, 0.29388091f, -0.27389652f, -0.16337384f, -0.21927604f, -0.25578079f, -0.00242211f, 
    0.52195346f, 0.04067193f, 0.86341757f, -0.14205213f, 0.12412521f, -0.06139979f, 0.02779657f, 0.35402620f, 
    -0.19682762f, 0.07745840f, 0.18901885f, -0.02122622f, 0.51413131f, -0.29305375f, 0.44090715f, 0.21635360f, 
    0.30406380f, -0.37180707f, -0.25721291f, 0.05238013f, 0.01118123f, -0.23598133f, -0.35905734f, -0.23835157f, 
    0.58351916f, -0.11248566f, 0.24647038f, -0.39510870f, -0.07218535f, -0.00867197f, -0.13717970f, 0.31592092f, 
    -0.03394290f, 0.14836195f, 0.05889928f, 0.07826008f, 0.24817361f, 0.14617026f, 0.60611147f, -0.26835009f, 
    -0.04572297f, 0.36387023f, -0.16098520f, 0.11685217f, -0.17949769f, 0.15182732f, -0.09382678f, -0.07858047f, 
    -0.01669834f, -0.01548913f, -0.20404494f, -0.19451083f, -0.17338462f, 0.15885128f, 0.14301950f, 0.05809348f, 
    -0.03427737f, -0.18614504f, -0.02108772f, -0.22932842f, -0.24657823f, -0.43271679f, -0.19131674f, -0.43210059f, 
    0.15869308f, 0.00551606f, -0.04421423f, -0.10556591f, -0.19174539f, 0.36583757f, 0.12334736f, 0.02036537f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.27878386f, 0.05224892f, 0.14227611f, -0.16195616f, -0.10261125f, 0.07080500f, 0.12751618f, -0.29812059f, 
    0.20518240f, 0.03813944f, 0.02850837f, -0.10853101f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
