#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27187279f, -0.06434920f, 0.07881877f, 0.29313549f, -0.74362689f, -0.85842359f, -0.46738741f, -0.60314804f, 
    0.04274842f, 0.42371488f, 0.56803417f, -0.55015361f, -0.15770042f, 0.36882260f, 0.42753229f, -0.44316027f, 
    0.14963700f, 0.14106001f, 0.09502023f, -0.55874777f, 0.07739206f, 0.05409552f, 0.04351810f, -0.23475260f, 
    -0.20537722f, 0.68554175f, -0.85935909f, -0.74728167f, -0.33183298f, -1.02835250f, 0.79038399f, 0.37478530f, 
    0.45202398f, 0.13951957f, 0.04032773f, 0.05825991f, 0.63794374f, -0.04252309f, -0.26434183f, 0.07005968f, 
    -0.09061121f, -0.05559649f, 0.01916596f, -0.30581933f, 0.05492536f, 0.27795267f, -0.24490288f, -0.13096187f, 
    0.34675375f, -0.00374176f, -0.43890348f, 0.73127604f, 0.62309700f, 0.34664777f, 0.39035082f, -0.89630932f, 
    -0.60960811f, -0.02485248f, 0.41859415f, 0.14385621f, -0.08223456f, -0.28256026f, -0.22248296f, 0.33295950f, 
    0.11849327f, 0.10635958f, -0.11393193f, -0.00895978f, -0.19108137f, -0.18686134f, -0.15946530f, 0.20269141f, 
    -0.01450436f, 0.35045379f, 0.09727608f, -0.66628087f, -0.66317880f, -0.55898815f, 0.07967678f, 0.24584529f, 
    0.76760364f, -0.08922025f, -0.29807901f, -0.04330716f, 0.63420111f, 0.42746842f, -0.23045079f, -0.11166333f, 
    0.12106277f, -0.01859495f, 0.01364950f, 0.15906399f, -0.09337074f, -0.19601640f, -0.32378232f, -0.22422977f, 
    -0.22188422f, -0.11210522f, 0.04122840f, -0.16122569f, -0.51936537f, -0.59171063f, -0.80459934f, 0.29949966f, 
    0.39124647f, -0.23366690f, 0.16785949f, -0.45431492f, -0.66374338f, -0.51773661f, 0.22375704f, -0.41741410f, 
    0.02376066f, -0.32528919f, -0.27140531f, 0.09982628f, 0.03975134f, 0.23319574f, 0.00827053f, 0.27457574f, 
    0.20436679f, -0.36856586f, 0.06096052f, -0.29482958f, -0.08707473f, 0.03496119f, -0.40200573f, 0.46528170f, 
    0.10753437f, -0.36426377f, -0.07614572f, -0.60522491f, -0.54267001f, -0.64964944f, -0.32632163f, -0.15546970f, 
    -0.18848981f, 0.10910591f, -0.57612222f, -0.08056161f, 0.05519267f, 0.27372360f, 0.41166115f, 0.09001824f, 
    0.02022057f, -0.11323789f, -0.13243887f, -0.17166212f, 0.29371548f, 0.33612832f, -0.68666959f, -0.59173065f, 
    -0.45435646f, -0.45522484f, -0.49019787f, 0.60668528f, 0.25116014f, -0.86298376f, -0.64984059f, 0.11462947f, 
    -0.18309338f, -0.21506260f, -0.51363993f, -0.38327608f, -0.30739054f, -0.31833994f, -0.43715850f, -0.37254223f, 
    -0.16426006f, -0.45173588f, 0.01374904f, -0.03202090f, -0.06144504f, 0.02409540f, -0.22478296f, 0.97669613f, 
    0.97377568f, -0.02610700f, -0.71996242f, -0.43897739f, -0.02809672f, 0.27999353f, -0.02733314f, -0.47120404f, 
    -0.39800677f, 0.00257987f, 0.23680893f, 0.38326243f, 0.09098686f, 0.04020151f, 0.39880207f, -0.40518045f, 
    0.08794542f, 0.24295393f, -0.40071175f, -0.16591944f, 0.03727086f, 0.00981089f, -0.02208642f, 0.03944470f, 
    0.69471294f, 0.60572761f, 0.24891166f, 0.36666501f, -0.10763063f, -0.17518044f, 0.10768285f, 0.13962477f, 
    0.11237161f, -0.31157190f, -0.09013974f, -0.10631891f, -0.16908059f, 0.14484230f, -0.30419371f, -0.22276084f, 
    0.02384914f, 0.15247270f, -0.07840645f, -0.10736626f, 0.07417022f, -0.09407151f, -0.26675519f, -0.35008192f, 
    -0.47361037f, -0.19452667f, 0.45786899f, 0.07489154f, -0.21900983f, 0.21642575f, -0.03914962f, -0.05576887f, 
    -0.06709677f, -0.20930436f, 0.32629728f, -0.09914689f, -0.01319483f, -0.02583001f, -0.11233059f, -0.18421334f, 
    0.61197329f, 0.24040662f, -0.02468972f, 0.29168046f, -0.11057249f, 0.01204023f, 0.16552931f, -0.40389457f, 
    0.05412243f, -0.49143529f, 0.69726193f, 0.56154293f, -0.86382133f, -0.90317053f, 0.44017267f, 0.02371774f, 
    0.17847487f, 0.51285249f, -0.13796052f, -0.57410496f, -0.25876722f, 0.00253593f, -0.10896396f, -0.08655385f, 
    -0.15857391f, -0.15329218f, -0.32325166f, 0.23339657f, 0.02207858f, -0.17914890f, 0.23120475f, 0.06283328f, 
    -0.09587028f, 0.11922469f, -0.04501497f, -1.13123918f, 0.31325728f, 0.23697251f, 0.01907498f, -0.18505113f, 
    0.31655586f, 0.60683388f, 0.16152202f, 0.42591551f, 0.07177602f, -0.14599243f, 0.23606633f, 0.24139644f, 
    -0.60308051f, -0.25151193f, -0.02499462f, 0.10904727f, -0.06022002f, -0.14304611f, -0.39124748f, -0.13347751f, 
    0.35253638f, -0.01396893f, -0.05299386f, 0.07405110f, 1.33491361f, -1.02167428f, -0.80010527f, -0.13252731f, 
    -0.43168935f, 0.07845079f, 0.26896921f, 0.33367378f, 0.10499784f, -0.27949163f, -0.18980420f, -0.22855999f, 
    0.10519712f, -0.27551565f, 0.05525556f, -0.03511683f, -0.15700734f, 0.06119007f, 0.01351368f, -0.01587004f, 
    -0.13296257f, -0.28250846f, -0.19879837f, -0.46164113f, -0.34346500f, -0.35577181f, 0.23813930f, 0.55051553f, 
    0.29798472f, -0.21566993f, -0.12770936f, 0.17064798f, 0.08332901f, 0.19284923f, 0.27224085f, -0.03944591f, 
    -0.25200254f, 0.16937314f, 0.57284725f, -0.30333203f, 0.06859209f, 0.11077372f, -0.51357675f, -0.07006737f, 
    -0.29290444f, -0.05874285f, -0.38405994f, -0.13876162f, 0.35103592f, 0.05779318f, 1.18273067f, 0.41193879f, 
    0.08780431f, 0.14011304f, -0.80117601f, 0.19794868f, -0.08756120f, -0.34659237f, -0.11232182f, 0.64757150f, 
    0.47700664f, -0.05032400f, -0.30296531f, -0.33492908f, -0.33989197f, 0.04417004f, -0.38048831f, 0.17493501f, 
    0.13873203f, -0.08645415f, -0.28084034f, 0.04801093f, 0.09931366f, -0.11384946f, 0.24348037f, -0.63465220f, 
    -0.67570657f, 0.20281734f, -0.02400414f, 0.32707080f, -0.22383146f, 0.47400424f, -0.26841635f, -0.10701451f, 
    0.36362022f, -0.08624820f, -0.06888220f, 0.10767037f, 0.13890772f, 0.18414152f, -0.32889861f, 0.11726578f, 
    -0.21765891f, 0.04691593f, -0.49622849f, -0.16898161f, 0.17344876f, 0.58475029f, 0.38300121f, 0.33269402f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34313568f, 0.32555717f, 0.25147140f, 0.23283495f, -0.15747879f, 0.08277135f, -0.00958565f, 0.37724960f, 
    0.02703881f, 0.18994895f, 0.32080704f, 0.35920197f, 0.01100513f, 0.45687816f, 0.45140412f, 0.31630728f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30841562f, -0.19855598f, -0.00910445f, 0.38195115f, 0.04950949f, 0.00685678f, 0.13222364f, 0.19420302f, 
    -0.05070283f, -0.04321586f, 0.03823868f, -0.10496268f, -0.33304724f, 0.05506789f, 0.00722889f, -0.05734750f, 
    -0.08114564f, -0.06426235f, -0.04872202f, -0.04560650f, 0.13240966f, 0.05780752f, 0.16759193f, 0.05259794f, 
    0.31208971f, -0.24929732f, 0.07852282f, 0.16990390f, 0.08829788f, 0.01181474f, -0.12354521f, 0.01170683f, 
    -0.06296332f, -0.00534417f, 0.06161396f, -0.10924076f, -0.61030841f, 0.03467183f, 0.17764950f, -0.05883593f, 
    0.00522559f, -0.07548671f, 0.00492966f, 0.04316007f, -0.00753886f, 0.14972813f, 0.01926464f, 0.23407388f, 
    -0.24010652f, 0.02706760f, 0.03217953f, 0.24050649f, -0.17768019f, 0.01084324f, 0.09332534f, -0.01675057f, 
    -0.05752292f, 0.04595061f, 0.14182484f, 0.03928183f, -0.03477864f, -0.09853940f, 0.23683858f, 0.16845734f, 
    0.02642148f, -0.08438387f, -0.06002694f, -0.11645753f, -0.07154707f, -0.02633047f, -0.02652506f, 0.02858322f, 
    -0.31753907f, 0.06690153f, 0.01251284f, -0.08067465f, 0.00775319f, 0.09334745f, -0.01977929f, -0.06084250f, 
    0.12105779f, 0.31835526f, 0.22191118f, 0.11686720f, 0.28958270f, 0.04161362f, -0.11483970f, -0.14902976f, 
    0.02283259f, 0.12982634f, 0.15860638f, 0.02282085f, 0.05760380f, 0.00004830f, -0.13886958f, -0.02475490f, 
    0.38573638f, -0.07828131f, 0.10859578f, 0.00162171f, 0.03107145f, -0.04447382f, 0.05793939f, -0.05092937f, 
    0.00056641f, 0.03679851f, 0.04111624f, -0.14825810f, -0.03866147f, -0.01893909f, -0.04115838f, -0.23667471f, 
    -0.07419778f, -0.10742500f, 0.14877315f, 0.32769409f, -0.06124635f, 0.10221350f, 0.14908211f, -0.29749498f, 
    0.34780851f, -0.00572601f, 0.24594747f, -0.56519401f, 0.02995108f, 0.19101940f, -0.27007565f, -0.01065305f, 
    -0.05863839f, 0.01259982f, 0.00654290f, 0.04564665f, -0.30020234f, -0.06444627f, -0.05387006f, -0.02526602f, 
    0.04354530f, -0.09450348f, -0.04564127f, 0.05067921f, -0.01113702f, 0.05709264f, 0.25541872f, 0.11365113f, 
    0.03148764f, 0.24235792f, -0.10490701f, -0.19171190f, -0.16394921f, 0.17163853f, 0.04405275f, -0.04534713f, 
    0.08471824f, -0.00738005f, 0.11669628f, -0.23867801f, 0.13911982f, 0.12323520f, 0.09384695f, 0.13505499f, 
    0.06156395f, -0.05428126f, -0.05060332f, -0.05424714f, -0.05330680f, 0.19115211f, 0.17369567f, 0.11274203f, 
    0.53522068f, 0.15802257f, -0.19547136f, 0.33451483f, 0.01427529f, -0.18112537f, 0.00935782f, -0.09511220f, 
    0.02733315f, 0.08038843f, -0.13228174f, -0.02664036f, -0.32272875f, -0.24526282f, -0.14036626f, 0.08211725f, 
    0.06427955f, -0.21562292f, -0.09338381f, 0.21077059f, 0.05283316f, 0.13968752f, -0.07970700f, -0.07787953f, 
    0.23242956f, 0.42297399f, 0.28421018f, 0.02769128f, -0.11278873f, -0.01214882f, 0.06646866f, 0.16792125f, 
    -0.03928902f, 0.03208059f, -0.16016129f, 0.14509913f, 0.40363628f, -0.02644929f, -0.00390430f, 0.02238171f, 
    0.01141753f, 0.08956047f, -0.07838804f, 0.10341240f, 0.03680646f, -0.01186765f, 0.09344035f, 0.06402674f, 
    -0.67938030f, -0.16164368f, -0.39629486f, -0.04897156f, 0.03965129f, 0.04536663f, -0.03272578f, -0.15530847f, 
    -0.01154645f, -0.08848186f, -0.04131124f, -0.11436341f, 0.25570571f, 0.17700408f, -0.11852267f, 0.14730707f, 
    -0.01212566f, -0.08957928f, -0.02399884f, -0.03710707f, -0.03661909f, 0.08376392f, 0.03828976f, 0.00534991f, 
    0.23335664f, -0.03688779f, 0.28914225f, 0.13232036f, 0.13846841f, 0.13612075f, -0.08926665f, 0.07049333f, 
    0.05311752f, -0.01378865f, 0.02974405f, 0.04650068f, 0.31302619f, 0.27949646f, -0.05478686f, 0.14319767f, 
    0.15994167f, 0.05724571f, 0.24496509f, 0.22378744f, 0.07325562f, -0.03984156f, -0.03136358f, 0.02931131f, 
    0.32377335f, 0.19735774f, 0.03454839f, 0.10061263f, 0.00537274f, 0.19767752f, -0.00977129f, 0.08654003f, 
    0.08250052f, -0.06567270f, 0.02571395f, 0.09940425f, -0.05203448f, -0.03805561f, -0.09237497f, 0.02340016f, 
    -0.14944106f, 0.13905340f, 0.33214870f, 0.02647426f, -0.04047299f, 0.02750231f, 0.03319649f, 0.09940596f, 
    -0.19766679f, -0.32972834f, -0.53801149f, -0.15672895f, -0.05215916f, -0.08902346f, 0.13320035f, -0.06349355f, 
    -0.05390774f, -0.05055723f, 0.01419306f, 0.19004467f, -0.17628810f, -0.11569615f, -0.22034468f, 0.09645326f, 
    -0.10272125f, 0.02020938f, 0.04675097f, -0.15512986f, 0.05292672f, -0.04634745f, 0.06587274f, 0.13338691f, 
    -0.21440877f, -0.27827036f, -0.49643266f, 0.19387773f, -0.00576463f, 0.09139102f, 0.24290816f, 0.05126507f, 
    -0.06630306f, -0.00402476f, -0.04089257f, 0.01740288f, 0.11531296f, 0.14990288f, 0.11593160f, 0.08410355f, 
    0.02086392f, -0.05828315f, 0.01236241f, -0.01252114f, 0.01506316f, 0.10903420f, -0.07697551f, -0.08752134f, 
    0.25039721f, -0.24031052f, 0.11247339f, 0.02099715f, 0.07816110f, -0.06848592f, -0.03920102f, 0.10178079f, 
    0.09744429f, -0.04300552f, -0.03214978f, 0.28548884f, -0.44415155f, -0.16968802f, -0.30464083f, -0.00824773f, 
    -0.04675925f, 0.09712367f, 0.01957761f, -0.09066827f, -0.02535680f, -0.00596641f, -0.07500105f, -0.15768154f, 
    -0.14824538f, -0.47256964f, -0.19625099f, -0.11558688f, -0.13864890f, 0.13512874f, 0.00752383f, 0.02847247f, 
    -0.03769105f, 0.03332080f, -0.03728439f, -0.01639480f, 0.03503734f, 0.10146338f, 0.09914848f, 0.11902004f, 
    -0.00628098f, 0.04365371f, 0.04921097f, -0.19827315f, -0.04564776f, -0.01628234f, 0.14046520f, 0.06030300f, 
    0.25852796f, -0.10064847f, 0.04809630f, 0.13966051f, 0.11116090f, 0.04942165f, 0.03879671f, 0.11328143f, 
    0.16995095f, 0.00267969f, 0.09250863f, 0.03589220f, -0.50559831f, -0.23369154f, -0.13549739f, 0.09667400f, 
    -0.06396700f, -0.04128235f, 0.07563137f, 0.09518525f, 0.07819355f, -0.01261792f, 0.13807416f, 0.09441562f, 
    0.46082041f, -0.05221757f, 0.26523980f, 0.01834562f, 0.10117729f, -0.05907856f, -0.06915969f, -0.02467263f, 
    -0.05323590f, 0.06133851f, 0.00346780f, -0.07842658f, -0.20126605f, -0.22877121f, 0.36197436f, -0.22056314f, 
    0.00253556f, 0.12636672f, -0.06218177f, -0.00159247f, 0.16582999f, 0.15004396f, -0.00272421f, 0.20796381f, 
    -0.09126307f, 0.15169525f, 0.02993328f, -0.05851195f, -0.10170253f, 0.00080555f, 0.25865167f, 0.08969189f, 
    0.06571292f, 0.08390903f, 0.02105127f, 0.09375197f, -0.01573111f, -0.02519019f, 0.23936878f, 0.03189355f, 
    0.01587116f, -0.07915096f, -0.11415096f, -0.10110805f, -0.09201299f, -0.05127005f, 0.05118682f, 0.03708075f, 
    -0.27193385f, 0.00604847f, 0.02107104f, -0.28061420f, 0.11004920f, 0.07872435f, 0.07007068f, -0.10349272f, 
    0.04758592f, 0.06498458f, 0.10545249f, 0.07452110f, -0.03702050f, 0.15995765f, -0.13642888f, 0.11884547f, 
    0.09392858f, -0.06003325f, 0.00296117f, 0.13098152f, -0.02875219f, -0.03135457f, -0.00804281f, -0.04899670f, 
    -0.06113348f, -0.07530275f, 0.17771269f, 0.05922167f, 0.09658901f, -0.02878440f, 0.03005685f, -0.04118845f, 
    -0.05503711f, 0.00191937f, -0.00175112f, -0.22152060f, -0.06630304f, 0.01582494f, 0.10638817f, -0.19168639f, 
    0.01289440f, -0.03301774f, 0.11488586f, 0.35221770f, -0.11980588f, 0.10810355f, 0.25311106f, -0.16501491f, 
    -0.06091052f, 0.09453498f, 0.19637443f, -0.46247745f, 0.05427424f, 0.09533805f, -0.12381304f, -0.07898469f, 
    0.11748006f, 0.02915626f, 0.01759654f, 0.06831671f, -0.33684364f, -0.01348933f, -0.16829421f, 0.14334984f, 
    0.12687035f, -0.08631123f, 0.00434404f, -0.01131642f, 0.08831535f, 0.08133069f, 0.29862335f, 0.21487594f, 
    -0.01238101f, -0.10812514f, -0.15114097f, 0.00906927f, -0.07513023f, 0.13871169f, 0.17602573f, 0.07798953f, 
    -0.01624655f, 0.16557649f, 0.11926404f, -0.13241036f, 0.14167170f, 0.05076658f, 0.03995192f, 0.03162716f, 
    -0.05847577f, -0.15895097f, -0.07985059f, 0.02642787f, -0.04925912f, 0.07293136f, 0.12174613f, 0.07348744f, 
    -0.01589489f, 0.03109702f, -0.05768782f, 0.24527808f, 0.00237221f, -0.05836075f, 0.04211311f, -0.02671157f, 
    -0.05264639f, -0.05919437f, 0.03557342f, 0.01134546f, -0.04020385f, -0.21915594f, 0.00705099f, -0.05249075f, 
    0.02492053f, -0.07404155f, -0.15545326f, 0.17056413f, 0.20229411f, 0.11040393f, -0.03619826f, -0.03352150f, 
    0.49779955f, 0.25234085f, 0.20201917f, -0.14361373f, 0.05727134f, 0.04919029f, 0.15059532f, 0.46899125f, 
    -0.15961899f, 0.00460592f, 0.02600418f, 0.00754864f, 0.16091482f, -0.42532527f, -0.34506932f, -0.11767402f, 
    0.17146587f, 0.19256774f, -0.06388692f, 0.05334730f, 0.08767194f, 0.25849721f, 0.17344213f, 0.03748073f, 
    -0.28831121f, -0.06554001f, -0.05320114f, -0.18506029f, -0.01502192f, 0.00103734f, -0.09820520f, -0.26241010f, 
    0.03818609f, 0.06462570f, -0.13341103f, -0.01850831f, -0.01135322f, 0.01938286f, -0.06360234f, -0.13480367f, 
    0.05613166f, -0.07683638f, -0.10942793f, -0.12696323f, -0.01760413f, -0.02807279f, 0.06498120f, -0.02897645f, 
    0.40637752f, 0.27554864f, 0.11089496f, 0.14257284f, 0.11211164f, 0.15168959f, 0.30675858f, 0.17689651f, 
    -0.02599437f, -0.11849418f, 0.01671174f, 0.03928034f, 0.25785643f, 0.14034691f, -0.05242454f, 0.03064594f, 
    0.11449318f, 0.05145689f, 0.17337863f, -0.00169819f, 0.05703370f, 0.06804491f, 0.09663212f, 0.13870315f, 
    0.41795775f, 0.31058508f, 0.08594563f, -0.09347717f, 0.10243355f, 0.14823529f, 0.03397275f, 0.09557009f, 
    0.04408095f, 0.04145340f, -0.10575728f, -0.12242170f, -0.13188575f, -0.12149519f, -0.17260784f, 0.03496888f, 
    -0.02004554f, -0.00599129f, 0.20445573f, 0.01888783f, 0.04387875f, 0.09749893f, -0.02846503f, 0.11013871f, 
    -0.29918334f, -0.19428608f, -0.16071562f, 0.10438922f, -0.09410025f, -0.00160423f, 0.01777204f, -0.07963336f, 
    -0.21679810f, 0.11232053f, -0.15009642f, -0.21035829f, -0.27596584f, 0.14134057f, -0.10896952f, -0.05901348f, 
    -0.05816606f, -0.00278527f, 0.15545180f, -0.12791014f, -0.14416550f, 0.03281218f, 0.02428382f, -0.01354485f, 
    0.10907006f, -0.16362716f, -0.24780260f, 0.23443121f, -0.06057977f, 0.00124916f, 0.16360880f, 0.02055188f, 
    0.14879110f, 0.01355605f, 0.00933666f, 0.10092992f, 0.02168967f, 0.12509234f, 0.14745858f, 0.02678942f, 
    -0.06828146f, -0.02542671f, -0.04097548f, 0.00715742f, -0.06347337f, 0.17868941f, -0.05870824f, 0.15602501f, 
    0.56262767f, -0.32978711f, -0.25697231f, 0.07167579f, 0.09193996f, -0.05492152f, -0.16859239f, 0.13514352f, 
    -0.20158003f, -0.07964161f, -0.02052209f, -0.18389519f, -0.32467034f, 0.21807778f, -0.00558543f, 0.04378837f, 
    -0.15787548f, -0.04960892f, -0.04135669f, 0.01950331f, -0.11101153f, -0.00732075f, 0.03580480f, -0.07827373f, 
    -0.04199668f, -0.00233552f, -0.23210736f, 0.23738693f, -0.19561860f, -0.12500845f, -0.05116527f, -0.13302936f, 
    -0.05406945f, -0.01055183f, 0.02224176f, 0.04390290f, -0.14715271f, 0.12049519f, 0.06782989f, -0.06415494f, 
    0.06101914f, -0.06143484f, 0.10522044f, -0.05462356f, 0.20117520f, 0.13701257f, 0.19319920f, 0.15174828f, 
    0.62653595f, -0.30790201f, -0.58286554f, -0.27327842f, 0.03478236f, 0.07898119f, 0.19403900f, 0.18728885f, 
    0.08572152f, 0.08436622f, 0.07860029f, -0.11644824f, 0.19640613f, -0.04401003f, -0.40014002f, 0.05445695f, 
    -0.04395887f, -0.16863887f, 0.03386598f, -0.06724437f, 0.04034837f, 0.16345902f, -0.06270342f, -0.06108233f, 
    0.18020308f, 0.27516055f, -0.05203865f, -0.02270052f, -0.02440218f, 0.03151998f, -0.16459998f, -0.07850487f, 
    -0.18472373f, 0.00494184f, -0.06214509f, 0.02834401f, -0.23632510f, 0.11992515f, -0.25589934f, -0.10533684f, 
    0.03427111f, -0.04763362f, -0.01423799f, 0.07777708f, -0.02500439f, 0.03365684f, 0.10625943f, 0.15877105f, 
    -0.57213205f, -0.23728356f, -0.78325903f, 0.31237888f, -0.24183381f, -0.17317957f, -0.07803252f, -0.35830855f, 
    -0.05783785f, -0.07371628f, -0.03827890f, -0.02041934f, -0.19598587f, -0.45452091f, -0.50365186f, -0.00604599f, 
    -0.01954032f, 0.02493920f, 0.01755065f, -0.14269607f, -0.08377515f, -0.05293522f, -0.11019263f, -0.11350673f, 
    -0.85055906f, -0.74417305f, -0.73818493f, -0.15821321f, -0.01382884f, 0.09337740f, -0.01644338f, -0.09401485f, 
    0.01726160f, 0.10331086f, 0.06296663f, 0.00699568f, 0.53119624f, 0.12812778f, -0.06958356f, 0.10575641f, 
    0.17547232f, 0.01163367f, 0.23162423f, -0.01954340f, -0.04748312f, -0.05663724f, 0.03003297f, -0.05664015f, 
    0.27052540f, 0.06529009f, 0.24174771f, 0.12901770f, -0.01440515f, 0.07927702f, 0.10944355f, -0.01895082f, 
    0.04415174f, 0.14526948f, 0.08376428f, 0.16352856f, -0.03861561f, 0.03221933f, -0.00139834f, -0.02509098f, 
    -0.02661939f, 0.13392405f, 0.30744809f, 0.14725256f, 0.18021432f, 0.38254347f, 0.24935606f, 0.04258258f, 
    0.18545587f, 0.02156465f, 0.11359961f, -0.12169555f, 0.02503220f, -0.08207627f, -0.14051454f, -0.11735962f, 
    -0.05767092f, 0.02329816f, -0.02371334f, -0.09742270f, -0.02100289f, 0.09924233f, 0.33287570f, 0.28881237f, 
    -0.02137303f, -0.05376807f, -0.06563140f, -0.01473917f, 0.04054894f, 0.14235841f, 0.06996261f, 0.13846275f, 
    0.07649951f, 0.03448878f, -0.21724974f, -0.25610071f, -0.13364008f, -0.06522344f, -0.02231951f, -0.01929869f, 
    0.25719425f, -0.12161261f, 0.08239001f, -0.04300986f, 0.37866235f, 0.29888555f, 0.27448186f, 0.08246991f, 
    0.01427389f, -0.00504773f, -0.02419609f, -0.11041114f, 0.08912273f, 0.11921091f, 0.16840275f, 0.17554034f, 
    0.77265239f, 0.11416073f, -0.14007775f, 0.33429736f, -0.04458161f, -0.05245554f, 0.06258626f, -0.02515209f, 
    -0.02770117f, 0.01260648f, 0.00238706f, -0.01652294f, -0.16801670f, -0.13182376f, -0.10673533f, -0.01925331f, 
    -0.16175078f, -0.23327981f, 0.08527500f, 0.04298353f, -0.14999387f, -0.25521758f, -0.29540822f, -0.06513850f, 
    -0.03381537f, 0.23344068f, 0.34714156f, -0.02553229f, 0.13488586f, 0.21420793f, -0.05803414f, 0.11782793f, 
    0.02307740f, 0.05580005f, -0.07845431f, 0.18770695f, -0.04475395f, -0.00367901f, 0.14853658f, 0.30642852f, 
    0.10768851f, 0.09933294f, -0.03075328f, -0.03617369f, 0.13961801f, 0.10760322f, -0.03329258f, -0.01036216f, 
    -0.10354089f, 0.07525630f, 0.31127855f, -0.05301036f, -0.00321992f, -0.03916929f, 0.05961804f, -0.00336215f, 
    -0.02971050f, 0.04444562f, -0.10131557f, 0.16492733f, 0.15507820f, 0.05876236f, 0.00786747f, -0.08904993f, 
    0.10071974f, 0.10546090f, 0.10742865f, 0.06387944f, 0.20660460f, -0.11310700f, 0.04170425f, 0.21996155f, 
    0.49668410f, 0.30132163f, 0.02206209f, -0.00057956f, 0.06291501f, 0.25041676f, 0.04971281f, 0.10684846f, 
    -0.08668634f, -0.01093707f, 0.03309565f, -0.01204785f, 0.30841887f, 0.24327704f, 0.03873280f, 0.25383800f, 
    0.08282485f, 0.16924937f, 0.04966667f, 0.29344013f, -0.04534666f, -0.02896174f, 0.02757274f, 0.01762898f, 
    0.14077358f, 0.10069909f, 0.25124654f, 0.13959396f, 0.14243855f, 0.01160882f, 0.04752278f, 0.01907178f, 
    -0.21230385f, -0.18450265f, -0.03554939f, 0.14960662f, -0.25815547f, -0.20991999f, -0.19710037f, 0.05353298f, 
    0.11945242f, 0.09260526f, -0.19758897f, -0.24947564f, -0.01088145f, 0.10965815f, 0.08665188f, -0.16110861f, 
    -0.48572972f, -0.32990620f, -0.16226906f, -0.06041514f, -0.00211821f, 0.02585137f, -0.07662551f, -0.03157245f, 
    0.13504662f, -0.05429786f, -0.02305437f, -0.05021157f, -0.07057004f, -0.15883608f, 0.05531413f, -0.04680061f, 
    -0.03167990f, -0.11457419f, -0.05193204f, -0.16618648f, 0.01336254f, -0.11507648f, -0.05003636f, -0.02929015f, 
    -0.13355300f, -0.07645621f, -0.26342389f, 0.06383314f, 0.05507410f, 0.09015763f, -0.05769819f, -0.03590031f, 
    -0.02694790f, -0.05874940f, -0.00160557f, -0.11391938f, 0.12993355f, -0.07635940f, -0.13196433f, -0.05581579f, 
    0.05380472f, -0.03582319f, 0.09344622f, 0.05158141f, 0.03230233f, 0.00055683f, -0.00825170f, 0.06290399f, 
    -0.05709004f, -0.11388418f, 0.17168172f, 0.05326729f, 0.02994113f, 0.00390019f, -0.13078851f, -0.22381382f, 
    0.20282812f, 0.03848252f, 0.16330831f, 0.13001128f, -0.28822634f, -0.21883295f, 0.05923113f, -0.09004664f, 
    -0.00695038f, 0.03624336f, 0.04524900f, 0.10966729f, 0.04972507f, -0.08731395f, 0.06049876f, 0.01987574f, 
    -0.51895416f, -0.15807107f, -0.41238877f, -0.08845466f, 0.08896343f, 0.02609908f, -0.00420551f, 0.00955419f, 
    0.01999393f, 0.00089553f, -0.02469981f, 0.03500202f, 0.11121499f, -0.00146880f, -0.03396434f, 0.09297656f, 
    0.03207146f, 0.20295595f, -0.07978611f, -0.13545217f, 0.06041210f, -0.14337815f, -0.10053192f, 0.00001900f, 
    0.03027545f, 0.00255053f, -0.00834815f, -0.07855123f, -0.03990117f, -0.02709555f, 0.03754142f, -0.07848199f, 
    -0.02677783f, -0.03582019f, -0.02914262f, 0.00517758f, -0.02775656f, 0.01910991f, -0.04821308f, -0.03490399f, 
    0.04357786f, 0.02239299f, 0.05214915f, 0.05303090f, -0.02039419f, -0.04753654f, -0.00278948f, -0.01550349f, 
    -0.04993400f, -0.04717450f, -0.03305737f, -0.04894856f, -0.03535224f, -0.06901374f, -0.00761384f, 0.03895406f, 
    0.02731421f, 0.04292667f, -0.06573275f, -0.00943567f, -0.05050304f, -0.04862987f, -0.03815823f, 0.05297354f, 
    -0.02303618f, 0.03314135f, -0.05428072f, -0.02265656f, 0.03950762f, -0.05257852f, -0.04669918f, 0.00273160f, 
    0.03569159f, -0.05104104f, 0.05331386f, -0.05176873f, -0.02924084f, -0.03128731f, -0.03890974f, 0.02339139f, 
    -0.07893442f, 0.03846546f, 0.03454233f, 0.03732670f, -0.07465156f, -0.01658962f, -0.00212726f, -0.05148836f, 
    0.05536302f, 0.01528239f, -0.02256586f, -0.02212883f, -0.02589372f, -0.00233115f, -0.01183686f, -0.02209691f, 
    -0.05260394f, -0.02649603f, 0.06058569f, -0.07090396f, 0.01634436f, -0.04899440f, -0.02080254f, 0.03529856f, 
    0.06285881f, 0.02218384f, 0.05619205f, 0.02556838f, -0.04289687f, -0.07260373f, 0.03582224f, 0.02167290f, 
    0.00965368f, -0.01390145f, 0.02650500f, -0.02487582f, 0.00440091f, 0.01592340f, 0.04053246f, -0.05376958f, 
    -0.06259311f, 0.02145048f, -0.04247006f, 0.05107873f, -0.00175926f, 0.03144716f, 0.05635734f, 0.00502173f, 
    -0.01039553f, 0.00382908f, -0.01765918f, 0.06016495f, -0.05096482f, -0.01864929f, -0.00549435f, -0.00323050f, 
    -0.01513239f, -0.00067307f, 0.06497754f, 0.01332500f, 0.03756660f, -0.04246161f, -0.02255875f, 0.02189883f, 
    -0.00120030f, 0.02818376f, 0.03840054f, -0.05054846f, -0.07249357f, 0.01666867f, -0.02226267f, 0.02668048f, 
    0.00159444f, -0.05894489f, -0.04602326f, 0.06150449f, 0.04491474f, 0.04887353f, 0.02972152f, -0.02905462f, 
    -0.04227490f, -0.07627384f, 0.01541908f, -0.04199819f, -0.02884089f, 0.05869185f, -0.05608759f, 0.06230314f, 
    0.06101732f, 0.02523353f, -0.05741788f, 0.02525158f, -0.00730189f, -0.00337876f, -0.07281322f, -0.02344101f, 
    0.06192549f, 0.01818632f, -0.03596897f, -0.04456539f, -0.07801439f, -0.07486059f, 0.05893270f, -0.07503960f, 
    0.04350870f, -0.00412157f, -0.04550697f, 0.05024667f, -0.06765112f, -0.04348363f, -0.00029108f, 0.01117343f, 
    -0.07582720f, -0.06495496f, -0.03819988f, 0.06212439f, -0.07662901f, 0.05013857f, -0.03039584f, -0.02443675f, 
    -0.06660776f, 0.00503470f, -0.02911829f, -0.07879162f, 0.05409597f, 0.06103111f, -0.07899248f, -0.06731130f, 
    -0.05616609f, -0.01368766f, 0.01903820f, -0.01354956f, -0.04665446f, 0.02180531f, 0.02208886f, -0.07868665f, 
    0.04783886f, 0.00649269f, 0.02312499f, 0.29243061f, 0.22674842f, 0.15357965f, 0.19762594f, 0.00511854f, 
    -0.03438402f, -0.02884136f, -0.04115423f, 0.05758329f, -0.50474870f, 0.05157134f, -0.04362252f, 0.11378469f, 
    -0.18658277f, 0.13804363f, -0.12323953f, 0.24348167f, 0.21675985f, -0.00736290f, 0.03139218f, -0.16696371f, 
    0.29139718f, -0.00966453f, 0.20802273f, 0.03484362f, -0.07380056f, -0.09700304f, 0.19354458f, -0.02899117f, 
    -0.01326481f, 0.08177916f, -0.00131987f, 0.04298262f, -0.26983210f, 0.02461589f, -0.00761168f, -0.14077421f, 
    -0.14457971f, 0.04591917f, -0.00322698f, 0.12523137f, 0.03985774f, -0.04726230f, -0.24537852f, 0.09473674f, 
    -0.06847096f, 0.05575324f, -0.35375643f, -0.03724061f, 0.05327844f, 0.18525943f, 0.17853130f, 0.13396248f, 
    -0.03775657f, -0.13273753f, 0.00758064f, 0.04332033f, -0.12764668f, -0.11778317f, 0.23183100f, 0.17627920f, 
    0.38467970f, 0.14018853f, -0.07949495f, 0.12257268f, -0.05920016f, 0.03874782f, 0.12341973f, 0.07462064f, 
    -0.09959265f, -0.12642044f, 0.05561910f, -0.33301386f, 0.07525286f, -0.10981931f, 0.12083478f, 0.26203933f, 
    0.05538220f, 0.03312042f, -0.10111385f, -0.13591570f, -0.26465055f, -0.21194057f, -0.03946135f, 0.15628858f, 
    0.04587588f, -0.03711877f, -0.15200438f, 0.13430995f, -0.07182921f, 0.02043175f, 0.07788761f, 0.04953446f, 
    -0.40331823f, -0.10401442f, 0.04970857f, 0.03772775f, -0.00907585f, -0.04985463f, -0.03067378f, -0.06814319f, 
    -0.29821637f, -0.17477278f, -0.17799172f, -0.39214256f, -0.15116663f, -0.04747254f, 0.06803724f, -0.35234490f, 
    -0.02619169f, 0.12002405f, 0.12475996f, 0.14337640f, -0.20439097f, -0.03693946f, 0.07430136f, -0.11756803f, 
    -0.08058227f, 0.05636583f, 0.13226399f, 0.06399914f, -0.00718877f, -0.10656574f, -0.09179303f, 0.07011259f, 
    0.06353164f, 0.01356169f, -0.00282169f, 0.30791274f, 0.30913910f, 0.01897564f, 0.08522999f, -0.12323079f, 
    -0.14565289f, -0.11434975f, 0.03769032f, 0.02997051f, 0.31818560f, -0.03772429f, 0.12502468f, 0.08308048f, 
    -0.12418088f, -0.02333840f, -0.11798993f, 0.14302944f, 0.08708768f, 0.01901390f, -0.02281978f, 0.28010759f, 
    -0.24315417f, 0.09024980f, 0.00606446f, -0.27605340f, 0.20419241f, 0.26088271f, 0.11414202f, -0.12684743f, 
    -0.09020162f, -0.01387029f, -0.07930645f, 0.10224215f, 0.07797762f, 0.25200802f, 0.08001911f, 0.09936500f, 
    0.00037131f, 0.19715871f, -0.02839803f, 0.32437712f, 0.04052697f, -0.16192201f, -0.11251719f, 0.07748555f, 
    0.07073417f, -0.07137870f, -0.13440113f, 0.05450779f, 0.11571456f, -0.05928402f, 0.05761976f, -0.05672051f, 
    -0.02612508f, 0.04402950f, -0.05276650f, 0.10961586f, 0.21178572f, 0.29282564f, 0.16681975f, 0.07156746f, 
    0.25528342f, 0.10491522f, 0.03170109f, 0.36237371f, 0.03676340f, 0.12632845f, -0.06049976f, -0.19316648f, 
    0.23260312f, -0.05700421f, -0.07911620f, 0.08365054f, 0.14299232f, 0.50224686f, 0.47582120f, 0.09796970f, 
    -0.32776520f, -0.24799846f, -0.16685399f, -0.11989366f, -0.05694941f, 0.03451544f, -0.21321434f, 0.01991515f, 
    -0.33323765f, -0.02283952f, -0.07186467f, 0.33650032f, 0.13631749f, 0.15768839f, 0.03979117f, -0.11491518f, 
    -0.25510013f, -0.25980103f, -0.08344454f, -0.28938013f, 0.47089735f, 0.03008355f, 0.48290914f, -0.03570516f, 
    -0.07226025f, 0.05650740f, -0.15293980f, 0.06855860f, 0.31403080f, 0.31825373f, 0.02146290f, 0.32672736f, 
    -0.04059214f, 0.04283319f, 0.08077388f, 0.13951384f, 0.12766212f, 0.35685676f, 0.01323805f, 0.23777437f, 
    0.10554567f, 0.02466687f, 0.02144396f, 0.17250468f, -0.07151329f, -0.10052159f, 0.14953429f, 0.17402740f, 
    0.13867731f, 0.04691399f, 0.10985795f, 0.39374247f, -0.05071107f, -0.04615821f, -0.16205105f, -0.31590095f, 
    -0.15071930f, -0.04398588f, 0.02863528f, 0.21451613f, 0.00392474f, 0.07711561f, 0.03308420f, 0.02919156f, 
    0.19059458f, 0.19774942f, 0.27679428f, 0.34088528f, -0.10583327f, 0.57964110f, -0.32524902f, 0.21626909f, 
    0.10378881f, -0.14557156f, 0.08359873f, -0.02095575f, -0.12829204f, -0.10118096f, 0.04395486f, -0.11129807f, 
    -0.04098192f, -0.17399441f, -0.16117965f, 0.10111729f, -0.17169848f, -0.02455502f, 0.22072072f, -0.04754662f, 
    0.25465214f, 0.09801907f, 0.14872925f, 0.33750468f, 0.06679943f, -0.26851273f, -0.19991300f, -0.19131534f, 
    0.08189358f, -0.08915154f, 0.20762014f, -0.09701095f, 0.18956687f, 0.18987504f, 0.08608556f, 0.11960194f, 
    -0.13456957f, 0.04145755f, -0.05168529f, -0.02542553f, 0.21680410f, -0.14541142f, -0.01051695f, -0.12927784f, 
    -0.07734248f, -0.08908255f, -0.03298692f, -0.13741502f, 0.31723347f, 0.28341249f, 0.07971626f, 0.23352848f, 
    -0.14221555f, -0.24527012f, -0.20885873f, -0.13070740f, 0.15333197f, 0.05851323f, 0.23117067f, 0.02066609f, 
    -0.28187165f, 0.11601923f, 0.10510191f, -0.14928411f, -0.04429319f, -0.10692917f, 0.29779699f, 0.26541528f, 
    0.22898610f, 0.15724610f, 0.32895964f, 0.27545115f, 0.03500946f, 0.09939666f, -0.02482126f, 0.05137068f, 
    -0.15712452f, -0.16975957f, -0.28377196f, -0.16339247f, -0.27946177f, 0.12538034f, 0.01724670f, 0.19921659f, 
    -0.03202629f, -0.43484539f, -0.11509280f, -0.00951123f, -0.00300303f, 0.13171636f, 0.15188685f, 0.05480525f, 
    -0.00542002f, -0.09037721f, -0.11175498f, -0.03549065f, 0.05327041f, -0.11184854f, 0.04290328f, 0.09433999f, 
    -0.03697737f, 0.00911486f, -0.15351643f, -0.07726927f, -0.13506095f, -0.45649117f, -0.24567673f, -0.56626707f, 
    -0.51202643f, 0.16963480f, 0.15456752f, -0.25847313f, -0.03110446f, -0.00222772f, -0.00580025f, 0.05950882f, 
    -0.00105972f, 0.06660002f, 0.11684926f, 0.12586530f, 0.53321117f, -0.21578218f, 0.10009906f, 0.09617648f, 
    0.02253197f, -0.01426311f, 0.31616217f, -0.03663251f, 0.09720064f, 0.10320082f, -0.17639591f, 0.10741919f, 
    0.34123650f, 0.19265582f, 0.18961307f, -0.10072330f, 0.07448657f, -0.17589717f, -0.07841974f, -0.00387536f, 
    -0.08257824f, -0.09723086f, 0.07151356f, 0.03346559f, 0.30861080f, -0.03615973f, -0.27415171f, 0.04547527f, 
    -0.03258444f, -0.06458896f, 0.14392947f, -0.01946718f, 0.03961238f, -0.05928300f, 0.12919042f, -0.03008947f, 
    0.05903134f, -0.06012304f, 0.15337312f, -0.08986764f, -0.04336441f, -0.23810847f, -0.04858021f, -0.12563221f, 
    -0.00798118f, -0.13648100f, -0.05750026f, -0.01520682f, 0.01308118f, 0.16126969f, -0.10617364f, -0.09468000f, 
    -0.18084538f, 0.03134354f, -0.10563483f, -0.18221146f, -0.04009836f, -0.09138534f, -0.12924172f, -0.11660068f, 
    0.33782607f, 0.17919393f, 0.19345593f, 0.37481642f, -0.04972085f, -0.13756765f, 0.08375805f, 0.12548532f, 
    0.08291069f, -0.03326086f, 0.02340975f, -0.00807861f, 0.00264513f, -0.09540265f, 0.39763421f, -0.06233933f, 
    -0.04794298f, 0.10326844f, -0.05882128f, 0.05794444f, 0.07974388f, 0.02540725f, 0.09313387f, 0.13342775f, 
    0.10807484f, 0.14292186f, 0.10453661f, -0.03455404f, -0.12629892f, -0.13405201f, -0.22279868f, 0.00897929f, 
    0.04124250f, -0.21290113f, 0.13228281f, 0.24802718f, 0.11377323f, 0.02553997f, 0.07260261f, 0.26216051f, 
    0.15240158f, 0.03582989f, -0.11288650f, -0.05970952f, 0.02664910f, -0.23806500f, -0.13821833f, 0.21215041f, 
    0.06777937f, 0.33748013f, 0.15729374f, 0.23839247f, -0.16205119f, 0.04079432f, 0.06137697f, 0.05622859f, 
    -0.35363388f, 0.02706375f, 0.10829686f, -0.11503841f, 0.07275268f, -0.05856305f, -0.31969592f, 0.08112561f, 
    -0.03632579f, 0.12908989f, 0.05526397f, -0.08453990f, -0.10609624f, -0.03649542f, -0.17648838f, -0.15793745f, 
    0.28254977f, 0.09627318f, 0.21325029f, 0.27410594f, 0.02620300f, -0.00502047f, 0.06641786f, -0.19696125f, 
    0.11678986f, 0.05767675f, -0.01103218f, 0.05217068f, 0.13397805f, -0.14719681f, 0.07224303f, -0.15467986f, 
    0.10009927f, 0.10301632f, 0.16085929f, -0.13155919f, 0.10526264f, -0.19510001f, 0.09240973f, -0.12243114f, 
    -0.23250911f, 0.35836974f, 0.73244506f, -0.37408552f, -0.05900840f, 0.06656335f, -0.21230520f, -0.03419454f, 
    -0.05192210f, -0.04929389f, 0.16078477f, -0.04160009f, 0.00921576f, -0.05074231f, -0.12311796f, -0.02370612f, 
    0.00945523f, 0.22935240f, 0.15697858f, -0.08954071f, -0.11468098f, -0.12061483f, -0.01535893f, 0.02696212f, 
    0.19171385f, -0.00934855f, -0.02146038f, -0.27819872f, 0.12541598f, -0.00230204f, 0.05465050f, 0.09215331f, 
    0.09371001f, -0.11730032f, -0.02796358f, 0.06150151f, -0.14443941f, -0.08320715f, 0.10377645f, -0.13420722f, 
    0.03834040f, 0.00553089f, 0.01576617f, 0.00008190f, 0.04452985f, 0.06718675f, 0.39596599f, 0.06188000f, 
    0.50487757f, -0.10384459f, -0.27044824f, -0.03622920f, 0.07903764f, -0.19098233f, -0.16909957f, -0.21340778f, 
    0.18938872f, -0.15840960f, 0.03239017f, 0.02361811f, 0.12170652f, -0.12840573f, 0.26258889f, -0.10274165f, 
    0.04561377f, -0.03688714f, -0.17177397f, 0.00096492f, -0.09517661f, -0.00334849f, 0.03054093f, 0.03573952f, 
    -0.11061584f, 0.19000174f, -0.00710548f, -0.12846974f, 0.12176359f, -0.13657774f, 0.14322536f, 0.08508277f, 
    -0.04833121f, -0.19609894f, -0.04399697f, 0.06562411f, -0.14907926f, -0.09470565f, 0.04091488f, 0.02289348f, 
    -0.02504146f, -0.07044268f, 0.00648778f, -0.10498094f, -0.00018738f, -0.07600790f, -0.03232444f, 0.11068077f, 
    -0.11708444f, -0.11668365f, 0.08942265f, -0.04579975f, -0.16653261f, 0.06309605f, 0.09879766f, 0.08004163f, 
    -0.00562588f, 0.05745509f, 0.07030348f, -0.01143460f, -0.32792461f, 0.16884486f, 0.14446868f, -0.24089217f, 
    -0.08623148f, -0.11551756f, -0.12576032f, 0.22658247f, 0.21046589f, 0.06173542f, 0.14364484f, 0.03556719f, 
    -0.44673368f, 0.10225958f, 0.07856021f, -0.06412867f, -0.12807205f, 0.08400782f, -0.11508776f, 0.05576708f, 
    0.01819792f, -0.01993442f, -0.04879109f, -0.01099413f, -0.24440771f, 0.00314149f, 0.00281183f, -0.04756860f, 
    0.01509224f, -0.00084043f, 0.18260713f, 0.07647138f, -0.06774539f, 0.07054161f, 0.02926484f, -0.02251533f, 
    0.45333162f, 0.18690965f, 0.57335961f, -0.01118044f, -0.25534913f, -0.35585344f, 0.02734451f, -0.11157383f, 
    0.01501007f, 0.13387184f, 0.08180585f, 0.02593367f, -0.07193498f, 0.22221932f, -0.03678630f, 0.32596621f, 
    0.02883323f, 0.17904371f, -0.09351123f, 0.05840517f, -0.09379230f, 0.27060467f, 0.04002688f, 0.07948675f, 
    0.18420994f, 0.06781312f, -0.00132609f, 0.09824792f, 0.08995942f, -0.05438172f, 0.01864076f, 0.01660961f, 
    -0.12734643f, -0.00473745f, 0.11973773f, 0.03485299f, 0.24440224f, 0.23496453f, -0.03644415f, 0.12698036f, 
    -0.04690517f, -0.20919430f, 0.05296907f, -0.08854764f, 0.19145943f, -0.16679367f, 0.05629726f, -0.12812564f, 
    -0.29944086f, 0.20479713f, 0.30243951f, -0.15631227f, -0.27458099f, 0.14362305f, -0.09605329f, -0.10317954f, 
    0.00423202f, 0.06948517f, 0.19077617f, -0.06824166f, 0.01483618f, -0.23582345f, -0.01764745f, -0.06230139f, 
    -0.09195785f, 0.00976954f, -0.13810460f, 0.23737991f, 0.24736725f, 0.04690856f, -0.03808206f, 0.06432630f, 
    0.01481445f, 0.00914297f, -0.02875751f, 0.01665338f, -0.07457848f, 0.04624551f, -0.04940949f, 0.03538251f, 
    -0.05344114f, 0.01677766f, -0.07578256f, -0.07620798f, -0.07182040f, -0.02224152f, -0.05272927f, 0.04206995f, 
    -0.01493591f, -0.07171196f, 0.01757436f, 0.00015394f, -0.05545362f, -0.02220169f, -0.01350276f, 0.03319909f, 
    0.00440891f, -0.07280178f, -0.02501428f, 0.03008972f, -0.08233468f, -0.05787092f, 0.01282656f, 0.00089428f, 
    -0.05103294f, -0.01691268f, -0.07811723f, 0.02623098f, -0.03653359f, -0.08613527f, 0.05440162f, -0.05549179f, 
    -0.07032559f, -0.01055818f, -0.01179816f, -0.08254177f, -0.06741823f, -0.02762525f, 0.00491029f, 0.03015210f, 
    -0.05296455f, -0.04550567f, -0.00516698f, -0.01335929f, -0.02911026f, 0.01267285f, 0.01581731f, -0.01356355f, 
    0.04321227f, -0.07356363f, 0.01663230f, -0.04154087f, 0.02062458f, 0.05441255f, -0.08665816f, 0.02476992f, 
    0.02583532f, 0.05723435f, 0.02955192f, 0.01993891f, -0.04508171f, -0.06116256f, 0.00777975f, -0.03490102f, 
    -0.00813755f, -0.04125353f, -0.02316897f, -0.08274058f, -0.03855820f, -0.02985936f, 0.03898165f, -0.00251501f, 
    0.00478229f, -0.04416994f, -0.00102098f, -0.07570128f, 0.00166450f, -0.07828850f, -0.01528728f, -0.07402709f, 
    0.05205689f, -0.01112486f, -0.02683258f, -0.01610647f, -0.07565528f, -0.03201206f, -0.07028496f, -0.05601643f, 
    0.04022586f, 0.02087251f, 0.03569815f, -0.06690639f, -0.08616232f, -0.08740246f, -0.05315293f, 0.03232149f, 
    -0.05098810f, -0.06710127f, -0.03326526f, 0.02273100f, -0.07446420f, -0.05043445f, -0.06918392f, -0.01504936f, 
    -0.04918812f, 0.03785165f, -0.06640818f, -0.03508022f, -0.05640828f, -0.08616806f, 0.04510445f, 0.00314889f, 
    -0.03331833f, 0.00958910f, -0.05135291f, 0.03909116f, -0.00800252f, -0.01834698f, -0.07765643f, -0.03935953f, 
    0.05027543f, -0.01184700f, -0.00379231f, -0.07078789f, 0.02592224f, 0.03297250f, -0.00357456f, 0.01874816f, 
    -0.03233961f, -0.06589136f, 0.01047326f, 0.03959495f, 0.04229612f, -0.06606378f, -0.00547615f, -0.07424676f, 
    0.00190309f, -0.04629387f, -0.03302715f, -0.01129978f, -0.02465565f, -0.03483471f, 0.01778623f, 0.00460591f, 
    0.00717290f, -0.03146813f, -0.02062883f, -0.01163397f, -0.04604572f, -0.05357198f, -0.08585843f, 0.03760010f, 
    -0.05174987f, 0.04638036f, -0.01629320f, 0.01302267f, -0.04375948f, -0.00196015f, -0.08184230f, -0.02244068f, 
    -0.03582376f, -0.01686683f, 0.05253489f, -0.03293263f, -0.03167090f, -0.01288717f, -0.08535053f, 0.00716645f, 
    0.00072280f, -0.01806858f, 0.00725546f, 0.01036271f, 0.03988221f, -0.00706420f, 0.03936103f, 0.03443403f, 
    -0.00973085f, 0.03097928f, 0.03836386f, -0.04785293f, -0.05701581f, -0.00548905f, -0.03022961f, -0.05592384f, 
    -0.33824727f, 0.31722853f, 0.15491986f, -0.24486373f, -0.14405574f, 0.11322709f, -0.09778514f, 0.16594613f, 
    -0.06722395f, -0.08095511f, -0.12429298f, -0.28007355f, 0.36699021f, -0.39414439f, -0.11426169f, -0.56996167f, 
    0.01461012f, -0.05970841f, -0.08411440f, -0.06043682f, 0.04676646f, 0.19030443f, -0.15909199f, -0.21244243f, 
    0.10488816f, 0.38769689f, 0.35265252f, 0.31472746f, -0.07612617f, -0.07230656f, -0.03476973f, -0.11546725f, 
    -0.01527440f, 0.04489261f, -0.04676103f, 0.07818493f, 0.22377789f, -0.14342123f, -0.09016588f, -0.06266812f, 
    -0.06577200f, -0.01810727f, -0.07740814f, -0.00005259f, 0.06315218f, -0.08973595f, 0.01288614f, 0.03033731f, 
    -0.40658700f, -0.07200819f, -0.18199119f, -0.35441223f, 0.18051481f, 0.05770735f, -0.19700566f, 0.22424039f, 
    -0.12581633f, -0.05565087f, -0.01998802f, -0.05723998f, -0.12747014f, -0.43377832f, -0.16431087f, -0.18269698f, 
    0.17514905f, 0.14951715f, 0.08036199f, 0.10252375f, -0.08756504f, -0.07971942f, -0.05052124f, -0.08326247f, 
    -0.25844601f, -0.31521827f, -0.10755060f, -0.12604147f, -0.01812202f, 0.07753848f, 0.05768483f, 0.14286360f, 
    -0.00666858f, -0.14127831f, -0.08483409f, -0.07240254f, -0.00164760f, 0.20295024f, -0.01330000f, 0.06102240f, 
    -0.07887123f, 0.03235266f, -0.03186608f, 0.08268151f, -0.01571204f, 0.03311481f, 0.02089722f, -0.07703074f, 
    0.11492774f, 0.03008226f, 0.07551489f, 0.18498525f, 0.04887855f, 0.08181569f, 0.06525854f, 0.09321687f, 
    0.12138276f, 0.02111273f, 0.05436816f, 0.17877842f, 0.01722643f, 0.16296665f, -0.03327692f, 0.09495240f, 
    0.06018171f, 0.02336674f, 0.12717080f, -0.12585054f, 0.04079029f, 0.05905239f, -0.05659218f, 0.01499680f, 
    0.42564875f, 0.19261669f, 0.04697278f, 0.17684579f, 0.04821415f, -0.18112922f, -0.01684043f, 0.00439364f, 
    0.00873299f, -0.02956160f, -0.00702436f, -0.13592491f, 0.21847393f, 0.16136253f, 0.03119843f, 0.04230419f, 
    0.02158175f, 0.05148332f, -0.05027905f, -0.04322004f, 0.11793666f, -0.23720457f, -0.10890688f, -0.00552063f, 
    0.21903917f, -0.24597609f, 0.05360460f, -0.24560815f, 0.07133202f, -0.26610333f, -0.07814737f, 0.01687799f, 
    0.07236113f, -0.07573179f, -0.08994362f, -0.24166635f, 0.11960772f, 0.13576271f, 0.15585144f, 0.16378473f, 
    -0.07700510f, 0.04880395f, 0.04857747f, -0.13772799f, 0.06622621f, -0.02352864f, -0.05240710f, -0.02780994f, 
    0.40537319f, 0.36385825f, 0.06449065f, 0.22067109f, -0.11475988f, -0.03423667f, -0.03652571f, 0.04942198f, 
    -0.00893817f, -0.01260826f, -0.00894173f, 0.07751451f, 0.06019715f, -0.03571562f, 0.05503830f, 0.11707229f, 
    0.01631605f, -0.00088426f, 0.01225346f, -0.08686588f, -0.05591477f, -0.09475312f, 0.05346778f, -0.08750240f, 
    0.12217577f, 0.10319130f, 0.13909286f, 0.04710585f, 0.22254443f, -0.08038050f, 0.01205635f, 0.17200042f, 
    0.00971385f, 0.11458708f, 0.13370645f, 0.01949353f, 0.23531890f, -0.53536648f, -0.25033858f, -0.38587263f, 
    -0.05873305f, 0.03463133f, 0.03295867f, 0.21093595f, 0.01809244f, -0.08749151f, 0.02600613f, -0.10887916f, 
    0.20450777f, 0.01210987f, 0.25304171f, 0.07066534f, 0.25770280f, -0.08200764f, -0.12905395f, -0.07779276f, 
    0.12217449f, 0.04077681f, -0.10867350f, 0.02269431f, -0.08900740f, 0.08330666f, -0.12919863f, 0.32432181f, 
    -0.10155372f, -0.11781541f, -0.04047947f, -0.08572371f, 0.11716478f, -0.00543047f, -0.01598062f, 0.10136139f, 
    0.25756779f, 0.01887183f, 0.32493082f, -0.19017561f, -0.06965743f, 0.08786946f, 0.32981065f, 0.08539876f, 
    0.02752632f, 0.06571107f, -0.01317806f, -0.05635799f, 0.34047469f, 0.26453814f, -0.00197721f, -0.32371157f, 
    0.03252832f, -0.02032312f, 0.12068336f, -0.01367321f, -0.06340889f, 0.05786397f, 0.05179829f, -0.04245407f, 
    0.18031594f, 0.23727468f, -0.04422549f, -0.20923239f, -0.01928391f, 0.12620072f, 0.11384045f, 0.19990481f, 
    0.03456034f, -0.00765593f, -0.08205678f, -0.07560781f, 0.00773620f, -0.03121730f, -0.09636227f, -0.05732853f, 
    -0.04044314f, 0.19516644f, 0.16454427f, 0.16933985f, 0.00045424f, 0.10221688f, -0.05863762f, 0.16428065f, 
    0.23388804f, 0.09571189f, 0.11758700f, 0.07231315f, -0.01291821f, 0.02654401f, -0.05492560f, -0.06901014f, 
    -0.13072957f, -0.00234753f, -0.07896119f, -0.07218842f, -0.28632200f, 0.10288732f, -0.07090563f, -0.06784327f, 
    0.11454225f, -0.09341707f, -0.02918470f, -0.03112987f, -0.00076607f, -0.05710188f, 0.14316253f, -0.10758328f, 
    -0.08246356f, -0.12245688f, -0.30671233f, -0.30789909f, -0.11455370f, 0.15077759f, -0.15027869f, 0.07682667f, 
    0.12002244f, 0.00446637f, -0.07181320f, 0.02779632f, -0.55838728f, -0.00565807f, -0.13458391f, 0.29432356f, 
    0.00143565f, -0.00765729f, -0.06595354f, 0.04885987f, 0.17359467f, -0.01846405f, 0.06200867f, -0.01408799f, 
    0.31169653f, -0.62487441f, 0.19267321f, -0.34372744f, 0.08832917f, -0.01782466f, -0.00598029f, 0.21494576f, 
    -0.07965874f, -0.00592299f, -0.04756530f, -0.13526873f, 0.11792348f, -0.02795999f, -0.02538955f, 0.30107769f, 
    0.05792532f, -0.06258065f, 0.09985313f, -0.05983727f, 0.06583220f, 0.09808296f, 0.03624028f, 0.11845190f, 
    0.40320393f, 0.08684389f, 0.12382920f, 0.22004269f, -0.05774121f, -0.06536070f, 0.02704749f, 0.05988261f, 
    -0.19088018f, -0.05528250f, -0.07369063f, 0.04329747f, -0.11797963f, -0.12668692f, -0.10795668f, -0.02279540f, 
    0.25597796f, -0.05097633f, 0.12912638f, -0.21363780f, -0.02346344f, -0.07057925f, 0.01695597f, -0.17132373f, 
    -0.02050930f, 0.06324968f, -0.07508020f, -0.00917692f, -0.04069010f, -0.02261890f, -0.01081267f, -0.03015431f, 
    -0.06109009f, -0.05008832f, -0.04745421f, 0.04315808f, -0.02907955f, 0.02294952f, 0.02501996f, 0.00456164f, 
    0.01158801f, -0.02778642f, -0.05238332f, 0.06350640f, -0.03892706f, -0.05821547f, 0.06141454f, 0.01265443f, 
    0.01594897f, 0.06124542f, 0.02246616f, 0.05953065f, 0.03677885f, 0.02252229f, 0.06104071f, -0.07521029f, 
    -0.06168743f, 0.06170718f, -0.00034949f, 0.02469931f, -0.06175404f, -0.07145665f, 0.01488152f, -0.03074943f, 
    -0.04821512f, -0.04720487f, 0.04974697f, 0.06111562f, 0.01925081f, 0.04669806f, -0.05136910f, -0.04691141f, 
    -0.05926758f, 0.01137556f, -0.04938526f, -0.03165250f, 0.06615438f, -0.01134456f, -0.04069478f, 0.05465333f, 
    0.02233418f, -0.04734851f, -0.04593608f, -0.01887383f, 0.05057424f, -0.07443878f, -0.03952822f, 0.05177775f, 
    -0.06319652f, -0.06346651f, -0.05650171f, -0.03262823f, -0.05125176f, -0.02895713f, -0.06822366f, 0.00832641f, 
    0.05077289f, 0.02353322f, 0.04269281f, 0.00598169f, 0.01569426f, 0.00453574f, -0.00453376f, 0.05119301f, 
    -0.01829534f, 0.00948758f, 0.02260208f, -0.07214733f, -0.06315602f, -0.03182423f, 0.01937027f, -0.06517698f, 
    -0.02160170f, -0.07072268f, 0.03455469f, -0.00157393f, -0.04540895f, -0.00641348f, -0.03769515f, -0.02350377f, 
    0.02776564f, -0.05752442f, 0.05444155f, -0.02092639f, -0.01772019f, -0.00100470f, -0.03766211f, 0.01901749f, 
    0.05013140f, 0.05008802f, -0.02866691f, -0.04677646f, -0.04473416f, -0.03881641f, -0.05674726f, 0.06344531f, 
    0.02234258f, 0.01317891f, -0.02915383f, 0.03861424f, -0.03923383f, 0.01614366f, 0.00627746f, 0.03150625f, 
    -0.04253835f, 0.05201870f, -0.05262326f, -0.06668983f, -0.03402146f, 0.05711816f, 0.03505924f, 0.06395384f, 
    -0.01130731f, 0.06467042f, 0.03867590f, 0.04864264f, -0.06064892f, 0.06165753f, -0.04563334f, -0.04863002f, 
    0.04996394f, -0.03603863f, -0.07382436f, -0.02518191f, -0.01773674f, -0.01960965f, 0.03951470f, -0.06055063f, 
    -0.00787034f, -0.05052267f, 0.01338787f, 0.05862205f, 0.02026659f, 0.00296914f, 0.02326874f, 0.00027366f, 
    0.06216890f, -0.05941428f, -0.00293861f, 0.03556332f, -0.05732171f, -0.07141639f, -0.07139061f, 0.00763709f, 
    -0.06551173f, -0.06603424f, -0.03964506f, 0.03413484f, -0.02137696f, -0.02325702f, -0.05600708f, 0.05089988f, 
    -0.02274104f, -0.01322342f, -0.00104493f, 0.03876524f, -0.07127926f, 0.00363808f, 0.02095340f, -0.06200138f, 
    -0.07087470f, -0.01673710f, -0.04998611f, -0.07584716f, -0.06815618f, 0.01152139f, -0.05420300f, -0.06412860f, 
    0.00226617f, 0.00299883f, 0.03683617f, -0.01870080f, 0.02759543f, -0.06231631f, 0.04804313f, -0.07010639f, 
    0.32367063f, -0.17150517f, 0.05418837f, 0.29962835f, -0.01636833f, 0.09233034f, -0.02773657f, -0.14576970f, 
    0.09008486f, -0.03953783f, 0.14708303f, -0.00472534f, -0.33577171f, 0.08256304f, -0.17412579f, 0.40897650f, 
    -0.00575202f, -0.13736542f, 0.34900531f, -0.20562682f, -0.03985376f, 0.08937827f, -0.05558231f, -0.03276340f, 
    0.19197328f, 0.11015962f, 0.48009491f, -0.26503348f, -0.06748405f, -0.10942350f, -0.11307990f, -0.04913469f, 
    -0.21900775f, -0.22609167f, -0.14435016f, -0.13516554f, 0.13885888f, -0.06860789f, 0.02158938f, -0.34711367f, 
    0.00941938f, 0.19229341f, 0.05755568f, 0.01726582f, 0.14178617f, 0.08323500f, 0.08399124f, 0.18502918f, 
    0.49433157f, 0.37291655f, 0.00099711f, 0.14277577f, 0.14070472f, 0.30043781f, 0.11603671f, 0.05992632f, 
    0.04883097f, -0.15340179f, 0.01558810f, 0.03362715f, 0.28546488f, 0.31160933f, 0.18175934f, 0.25008056f, 
    0.18124649f, -0.02571288f, -0.13098238f, 0.23530884f, -0.26297227f, -0.10659245f, -0.33034700f, -0.16374911f, 
    0.04434581f, 0.15566328f, -0.10823356f, 0.19433722f, 0.20361096f, -0.03783162f, 0.12765135f, 0.00967639f, 
    0.02066266f, 0.02707752f, 0.28663453f, 0.27755538f, -0.13313526f, 0.34776136f, -0.32511273f, 0.70164400f, 
    0.13431296f, -0.15008983f, -0.09305397f, -0.08608739f, -0.12310258f, 0.04312191f, -0.07075401f, -0.30273703f, 
    0.00848206f, -0.14551410f, 0.13721482f, 0.05179182f, 0.02995041f, -0.20444882f, 0.02291570f, 0.06847545f, 
    0.18943600f, 0.22031443f, -0.03531281f, 0.10538098f, 0.05309494f, 0.10305559f, 0.08857636f, -0.13693316f, 
    -0.00077053f, 0.01295798f, 0.10848812f, 0.03167761f, 0.09888478f, 0.12765089f, 0.27216157f, -0.06067773f, 
    -0.18588762f, 0.16342826f, -0.31386334f, 0.20462391f, 0.16897118f, -0.15240769f, -0.05876211f, -0.03289248f, 
    -0.05360245f, 0.03010695f, -0.17914601f, -0.33455265f, 0.10539296f, 0.06178535f, -0.02187691f, -0.05510320f, 
    -0.01500976f, -0.07646751f, 0.04584976f, 0.05642883f, 0.09084246f, 0.11865155f, 0.31687769f, -0.01111772f, 
    -0.26933771f, -0.20868619f, 0.02517921f, 0.27161968f, -0.02701298f, -0.07742737f, 0.29866359f, 0.20064943f, 
    0.08724155f, 0.37415853f, 0.20886266f, 0.33506972f, 0.00380169f, -0.08398543f, 0.01783669f, -0.30297124f, 
    -0.24518749f, -0.07269371f, -0.25619563f, 0.09823019f, -0.09725409f, 0.09662993f, -0.08584015f, 0.10255011f, 
    -0.07592907f, -0.22320367f, -0.12294450f, 0.27312237f, -0.05414514f, 0.00708954f, 0.08158951f, -0.02656384f, 
    -0.08208020f, -0.29563135f, 0.05911408f, -0.02863455f, 0.13744543f, -0.16044727f, -0.17477517f, -0.23328306f, 
    0.08813883f, 0.01002331f, -0.07090218f, -0.11375779f, 0.08960623f, -0.29701313f, -0.43418294f, -0.48083845f, 
    0.09328394f, -0.12868936f, -0.05311080f, 0.29992783f, 0.16161588f, 0.19076824f, 0.01924930f, 0.03851420f, 
    0.13048309f, -0.04489489f, -0.03028432f, 0.04124989f, -0.58343750f, 0.26706061f, 0.41984656f, 0.10058786f, 
    0.01463096f, 0.03450395f, 0.00689807f, -0.01465712f, -0.00739961f, 0.12355005f, 0.16449420f, 0.04152748f, 
    0.16258365f, -0.16614282f, -0.02985477f, 0.23205762f, 0.05519935f, 0.06861164f, 0.03757124f, 0.02860676f, 
    -0.04761770f, -0.00613791f, -0.04903480f, 0.00654239f, -0.13597101f, -0.20167632f, 0.37020835f, -0.00799545f, 
    0.07265957f, 0.11987470f, -0.05941392f, -0.05966203f, -0.02711982f, 0.00993409f, 0.06285389f, 0.23548092f, 
    -0.34204400f, -0.06218693f, -0.04123211f, -0.12442209f, -0.02350900f, 0.10384586f, 0.02651937f, 0.17806002f, 
    -0.00741445f, -0.00924949f, -0.06152416f, 0.00297513f, -0.29092255f, -0.32253286f, 0.31244346f, 0.08128586f, 
    -0.03638265f, -0.05353457f, -0.05608031f, 0.13482249f, -0.13123366f, 0.05395618f, 0.05340132f, -0.09961797f, 
    -0.31791726f, -0.15591961f, 0.27331021f, -0.06243093f, -0.00323832f, 0.11552496f, -0.05569528f, -0.04325403f, 
    0.02176708f, 0.18870921f, 0.09766565f, 0.12483713f, -0.12950796f, 0.32510510f, 0.01460055f, -0.06833712f, 
    0.04136910f, -0.11578117f, 0.02415596f, 0.09777777f, 0.09561665f, 0.06384001f, 0.16733934f, 0.00469143f, 
    -0.02196299f, 0.00589104f, -0.03092510f, -0.02728104f, -0.02410574f, 0.02578134f, 0.01690054f, -0.05946250f, 
    0.06649649f, -0.05098727f, 0.03146752f, -0.14083633f, 0.03037746f, -0.09271539f, 0.00456439f, -0.18607576f, 
    -0.02138854f, -0.06923315f, 0.07719256f, 0.30624890f, 0.10708175f, 0.11159873f, 0.16356210f, 0.04798389f, 
    0.20217636f, 0.04747143f, 0.45873868f, -0.44228843f, 0.07606211f, -0.11676975f, -0.08166324f, 0.01032238f, 
    0.15023382f, 0.04375999f, 0.00712118f, -0.01349607f, 0.07505206f, 0.06952902f, 0.09668583f, 0.22032724f, 
    0.13707565f, -0.07204217f, -0.03502249f, -0.02761496f, 0.13584495f, 0.06318421f, 0.19136368f, 0.18222140f, 
    -0.34009865f, 0.07825025f, -0.14120741f, -0.08830381f, -0.08179332f, -0.04307586f, 0.13422428f, -0.06937377f, 
    -0.03925787f, 0.13698487f, 0.22818117f, -0.12124848f, 0.13593078f, 0.16213799f, 0.09943037f, 0.13358743f, 
    -0.00484489f, -0.05588769f, -0.05647278f, 0.02732196f, -0.04549370f, 0.02236605f, 0.07349039f, 0.06466433f, 
    -0.03646798f, 0.22705297f, 0.00944678f, 0.07061619f, 0.00139158f, 0.01095121f, 0.05765231f, 0.06381427f, 
    0.06797329f, 0.01808042f, -0.00811655f, 0.02554061f, 0.07894529f, -0.06929053f, 0.05310744f, 0.11581941f, 
    -0.05959986f, -0.01286869f, -0.19332270f, 0.14157143f, 0.00766328f, 0.10802054f, 0.01437510f, 0.01775406f, 
    0.04579730f, -0.07545810f, 0.02569632f, 0.00182606f, 0.04088160f, -0.03288800f, -0.06704733f, -0.01338814f, 
    0.00067486f, 0.02067403f, -0.04094921f, -0.01978283f, 0.05950058f, 0.03749791f, 0.00902544f, 0.01717466f, 
    -0.07168639f, -0.02550571f, 0.03395610f, -0.02557533f, 0.03890469f, -0.01874488f, -0.03176580f, -0.07934996f, 
    0.06280802f, -0.04946322f, -0.04048413f, -0.05376517f, -0.04133269f, -0.02910899f, 0.00685400f, -0.03085342f, 
    0.02718113f, -0.00155635f, 0.03450976f, -0.02203398f, 0.02372330f, -0.02335880f, 0.02738211f, 0.06051636f, 
    0.02621403f, -0.04308071f, -0.04332685f, -0.02016781f, 0.03260090f, -0.02554536f, 0.05384766f, 0.05931219f, 
    -0.05729859f, 0.03155988f, -0.05837549f, 0.05181498f, -0.03899495f, 0.03813936f, -0.08045764f, 0.05791770f, 
    0.01207354f, -0.00031577f, -0.03376801f, 0.00671245f, -0.06541349f, -0.00901216f, -0.07056639f, -0.01938822f, 
    -0.03941870f, -0.07265166f, -0.02184649f, 0.01641807f, -0.00161247f, -0.05363574f, -0.00393204f, -0.04967705f, 
    0.06340586f, 0.01584843f, 0.03536813f, 0.01134217f, -0.06615449f, -0.02736272f, -0.06344046f, 0.02092706f, 
    -0.03593291f, 0.04373085f, 0.01100831f, -0.05812454f, -0.07166331f, 0.02809424f, -0.02407918f, -0.06218410f, 
    0.06465737f, -0.03749991f, 0.04559624f, -0.00712242f, -0.05738783f, 0.05896011f, -0.00648233f, -0.01537185f, 
    -0.06676074f, 0.03272618f, -0.06038098f, 0.00409602f, -0.02708295f, 0.03445550f, -0.07272623f, 0.03359403f, 
    0.02620566f, 0.02549631f, 0.02735941f, 0.03346041f, -0.05594138f, 0.03128693f, -0.00674297f, 0.00499271f, 
    -0.06144170f, -0.05416958f, -0.06448725f, 0.05259404f, -0.07002636f, -0.03461615f, 0.00451077f, -0.03142794f, 
    -0.00658929f, 0.02447935f, 0.00595053f, 0.03184003f, -0.05378171f, 0.04491067f, -0.02388945f, -0.00221722f, 
    -0.07483353f, 0.02725007f, -0.04672671f, 0.03729329f, -0.04500816f, 0.04106907f, -0.01390974f, -0.07661325f, 
    -0.06905279f, 0.02316149f, 0.02374892f, -0.02668072f, -0.05246798f, -0.03637496f, 0.01632019f, 0.01087603f, 
    -0.00166597f, 0.04530681f, -0.00635232f, -0.01531368f, -0.03514297f, 0.05667367f, 0.00233780f, 0.01409496f, 
    0.02772052f, 0.03953466f, -0.05692361f, -0.06340264f, 0.02556343f, 0.02675872f, 0.01721597f, 0.04231580f, 
    -0.07490020f, -0.06130684f, -0.07266934f, -0.03836663f, 0.00436674f, -0.07151202f, 0.03858459f, -0.03305406f, 
    -0.00992056f, -0.00251392f, -0.04789605f, -0.07615156f, -0.00395346f, 0.05203152f, -0.02648447f, 0.00801688f, 
    0.01223205f, -0.05727999f, -0.00178163f, 0.06263082f, -0.01683312f, -0.07948922f, 0.04966250f, -0.06570535f, 
    -0.01405624f, 0.03554955f, -0.06496137f, -0.07387381f, -0.00657335f, -0.07126226f, 0.04504498f, -0.03772362f, 
    -0.06391262f, -0.06280784f, -0.00395972f, -0.03556503f, -0.07258090f, 0.04636694f, 0.01363724f, -0.01149665f, 
    -0.03772965f, -0.04978886f, -0.05857208f, -0.08625820f, -0.04496371f, 0.04373846f, -0.00119221f, -0.04759555f, 
    -0.04934271f, 0.03855917f, -0.06625055f, -0.04198733f, -0.06415965f, -0.06106117f, -0.07377799f, -0.03993835f, 
    -0.04702234f, 0.01236549f, -0.06745774f, -0.05664849f, 0.03640715f, -0.08290402f, -0.01774588f, -0.05603654f, 
    -0.02160980f, -0.00679644f, 0.00261969f, 0.00864500f, -0.07816643f, -0.08210996f, -0.09014321f, -0.07201972f, 
    -0.08281174f, 0.01170591f, -0.02455706f, -0.08251183f, -0.07083194f, -0.03785031f, -0.06562046f, 0.04647956f, 
    -0.03335376f, 0.03932990f, -0.01815939f, -0.00903912f, -0.08611694f, -0.00094210f, -0.08162758f, 0.00177618f, 
    0.04294059f, -0.01953927f, -0.06834430f, -0.08130261f, 0.05027151f, 0.00792412f, -0.02805468f, 0.01345297f, 
    -0.03594557f, 0.00333016f, 0.00189262f, -0.04314787f, -0.05162949f, -0.07444473f, -0.00454174f, -0.01163732f, 
    -0.03572886f, 0.04461662f, -0.00294139f, 0.05053521f, 0.01815333f, -0.03889277f, -0.03197105f, 0.04156238f, 
    -0.09443622f, -0.02916036f, -0.00984956f, -0.02820232f, -0.07405430f, 0.02890565f, 0.02801907f, -0.01196092f, 
    -0.07433379f, -0.08641779f, 0.02246538f, -0.05099339f, 0.05107360f, -0.01806471f, -0.08632337f, 0.05028275f, 
    -0.01072992f, 0.00050776f, 0.00414746f, 0.04417667f, 0.01068511f, 0.01570672f, -0.04943398f, -0.01741802f, 
    0.02711168f, -0.01265055f, -0.01070526f, -0.08963406f, -0.07739560f, -0.01246088f, -0.02398445f, -0.08571046f, 
    0.02558794f, -0.08095697f, -0.09682851f, 0.03288432f, 0.02582766f, -0.01806506f, 0.00849413f, -0.02490209f, 
    -0.03433394f, -0.04687954f, -0.03208470f, -0.06034765f, -0.07034262f, -0.02844067f, 0.04866397f, 0.01786078f, 
    0.03293655f, 0.05209096f, 0.03806948f, -0.02305811f, -0.05164744f, -0.03751044f, 0.04236232f, -0.04407265f, 
    -0.04548988f, 0.02874102f, -0.04937502f, 0.02003223f, 0.05959031f, -0.02540953f, -0.02442722f, -0.03297111f, 
    -0.03168452f, 0.04999640f, 0.02260695f, -0.01806408f, 0.05060771f, 0.02404458f, -0.06486305f, -0.03594568f, 
    0.02188985f, 0.02686158f, -0.08044639f, -0.03474164f, -0.00541070f, -0.07041345f, -0.01804986f, 0.04770299f, 
    0.01911667f, -0.03399397f, -0.01682048f, -0.05175551f, -0.06265137f, -0.06458703f, 0.00397033f, -0.09039748f, 
    -0.03209756f, 0.00378701f, 0.03748057f, -0.09576374f, -0.02411629f, -0.08000860f, -0.04555724f, -0.00702995f, 
    0.05207684f, -0.02993562f, -0.06710449f, 0.03350019f, -0.01168562f, -0.04169652f, -0.06560832f, -0.09406833f, 
    -0.06697439f, 0.01553553f, -0.05736839f, -0.09843240f, -0.05282439f, 0.03482936f, 0.02539425f, -0.02297639f, 
    -0.14475660f, 0.25364468f, 0.04769469f, 0.10569471f, 0.21370314f, 0.13084517f, 0.12197136f, 0.17478889f, 
    -0.14035980f, 0.03977387f, -0.04105565f, 0.22326006f, 0.27742362f, 0.72679728f, 0.50936949f, 0.41690531f, 
    0.06915502f, 0.13959625f, -0.13769734f, 0.00081532f, 0.11468288f, 0.17443523f, 0.01205711f, 0.00081357f, 
    -0.29925555f, -0.09153055f, -0.22873084f, -0.02545620f, -0.10355593f, 0.03840933f, 0.01688760f, -0.00881595f, 
    -0.03559526f, 0.05782654f, -0.05392923f, 0.06504896f, -0.18732110f, 0.15014315f, -0.07044198f, 0.02630422f, 
    0.15650940f, 0.07010940f, 0.24666956f, 0.18593283f, -0.04755144f, -0.12273425f, -0.04630939f, 0.06583693f, 
    -0.12074270f, -0.02397752f, -0.12211500f, 0.32858336f, 0.10594422f, 0.08456346f, -0.22055422f, -0.08028731f, 
    -0.05135494f, 0.03733010f, 0.05275152f, 0.06102757f, -0.17842726f, -0.00431936f, 0.17554694f, 0.42234057f, 
    0.14795588f, 0.26985043f, 0.03601439f, 0.14621922f, 0.12922607f, 0.12688489f, 0.04525653f, 0.02565741f, 
    -0.16206682f, -0.10282890f, 0.12577540f, 0.36942157f, 0.17946669f, 0.05008106f, 0.04771057f, 0.04428361f, 
    0.07987307f, -0.01746704f, 0.01460435f, 0.08140619f, -0.11192717f, -0.32745776f, -0.02943266f, -0.09265818f, 
    -0.12128785f, -0.02130965f, -0.06692640f, -0.39582968f, 0.05098106f, -0.14799702f, -0.02443559f, -0.11987188f, 
    -0.31033513f, -0.11624597f, -0.27604884f, -0.18323714f, -0.12300148f, -0.13390222f, -0.05722914f, -0.06840810f, 
    -0.02213611f, -0.13274781f, -0.05382473f, -0.00863171f, 0.13138993f, -0.21778075f, -0.04276208f, -0.13033196f, 
    -0.26613539f, -0.04375352f, 0.04733209f, -0.08772720f, 0.20657137f, 0.05100515f, -0.11269020f, -0.12286953f, 
    0.09264202f, -0.12398267f, 0.34412026f, 0.34047556f, -0.02625687f, 0.02323382f, -0.03585462f, -0.13586186f, 
    0.01959303f, -0.08534025f, -0.03520428f, 0.09717284f, 0.41669744f, 0.00136598f, 0.45314458f, -0.06139893f, 
    0.00247713f, -0.03314869f, 0.01634302f, 0.03014427f, -0.04398451f, -0.07965633f, -0.11316529f, 0.08346932f, 
    -0.07504728f, 0.63220525f, 0.06096032f, 0.25206649f, -0.05312009f, 0.10812390f, -0.22074805f, 0.02953712f, 
    0.27678749f, -0.06583815f, -0.00111549f, 0.16627003f, -0.01429997f, -0.03326643f, 0.04778954f, -0.21586250f, 
    -0.05386448f, -0.02970597f, -0.05028532f, -0.15724395f, 0.05863683f, -0.01794711f, 0.06132049f, 0.03562693f, 
    -0.19194646f, 0.12166655f, -0.33159050f, -0.02580287f, 0.03559139f, -0.06609519f, -0.12015414f, -0.00946955f, 
    0.23044588f, -0.08525516f, -0.07111724f, -0.11093965f, 0.00039890f, 0.20373736f, -0.07500090f, -0.05407867f, 
    -0.05946869f, 0.07264879f, 0.01471023f, 0.10818940f, 0.08427739f, 0.07957764f, 0.02551172f, 0.05002836f, 
    -0.09233148f, -0.06592928f, -0.23429787f, -0.17039822f, 0.18876961f, -0.15037209f, 0.10110941f, 0.12483224f, 
    0.16491875f, 0.04628259f, 0.11786588f, 0.08831965f, 0.17168520f, -0.02912413f, -0.02605271f, 0.06617822f, 
    -0.01582169f, -0.07562025f, 0.08487359f, 0.14984982f, 0.14174525f, 0.11508071f, 0.09939833f, 0.10383552f, 
    0.21137464f, 0.18669778f, -0.29748252f, -0.29784983f, -0.07220990f, -0.21742517f, -0.21598093f, -0.02341278f, 
    -0.04483151f, 0.01031922f, -0.09741258f, -0.04703292f, -0.16582853f, 0.14398763f, -0.14932801f, 0.19465527f, 
    0.06462653f, -0.19133964f, 0.08600444f, 0.14250459f, -0.01453988f, 0.05299796f, 0.16942674f, -0.04302459f, 
    -0.20548244f, -0.19612402f, -0.06185062f, 0.00811574f, -0.05040626f, -0.31114584f, 0.21102186f, -0.28978497f, 
    -0.00794690f, 0.00381831f, -0.00643612f, -0.13032997f, -0.01777291f, -0.02028419f, -0.21821329f, -0.27366903f, 
    -0.14014322f, -0.00029036f, 0.04107506f, -0.22985539f, -0.03785675f, -0.08763308f, -0.04849001f, 0.05543217f, 
    0.19412370f, 0.03569091f, -0.03665620f, -0.09348162f, -0.05028744f, 0.02499852f, 0.07532582f, 0.12707835f, 
    -0.01693401f, 0.18588202f, -0.04008368f, -0.00706454f, 0.43614730f, -0.26091716f, 0.26847216f, -0.15582734f, 
    -0.09609102f, -0.03878016f, 0.14839497f, -0.00022272f, 0.03372366f, 0.05191685f, -0.13399656f, 0.13138366f, 
    0.23931412f, 0.19256990f, 0.15817644f, -0.13444318f, -0.04188534f, -0.18058497f, -0.08045414f, 0.00720259f, 
    -0.26933637f, 0.01939145f, 0.10845951f, -0.06265777f, -0.06364514f, -0.01645136f, -0.00593976f, -0.01192262f, 
    0.03025192f, 0.13136408f, 0.06619785f, 0.14306526f, -0.13064185f, 0.02569113f, 0.01505696f, 0.01118447f, 
    0.11349329f, -0.00260384f, 0.46321297f, -0.00710163f, -0.10636908f, -0.04954132f, 0.10001675f, 0.01774982f, 
    -0.23822166f, 0.14592887f, 0.07151843f, 0.12645073f, -0.36807552f, -0.07793568f, 0.19472499f, 0.03415360f, 
    -0.14911592f, -0.01087071f, -0.03119499f, -0.01659781f, 0.09438910f, 0.30142295f, -0.10994269f, 0.03009715f, 
    0.29211843f, 0.21036570f, -0.05235570f, 0.21228859f, -0.03485613f, 0.05550931f, 0.03103757f, -0.05530016f, 
    0.02426412f, -0.03057605f, 0.11779980f, -0.00804874f, 0.19705783f, 0.22784287f, 0.16414607f, -0.14173029f, 
    0.11004160f, 0.00227025f, 0.10629957f, -0.03654928f, 0.09520358f, 0.12172208f, 0.02278768f, 0.15684004f, 
    0.26730651f, 0.39439976f, 0.61358303f, -0.06224602f, -0.12784457f, -0.07635843f, 0.01524475f, -0.03830405f, 
    -0.03211349f, 0.06190775f, 0.16999283f, -0.00645645f, -0.12136225f, -0.11191768f, -0.16706245f, -0.19576909f, 
    -0.11930502f, -0.11479317f, 0.01378935f, 0.03765255f, 0.02958537f, 0.19069526f, 0.06081206f, 0.18154678f, 
    0.02623352f, -0.04758897f, -0.06889060f, -0.06639638f, -0.04051483f, -0.02968621f, 0.05122648f, 0.04302928f, 
    -0.03997277f, 0.03300161f, -0.01504580f, -0.02830058f, -0.01551297f, -0.03142672f, 0.05266391f, -0.04930304f, 
    0.00857972f, -0.06259510f, -0.07422401f, -0.07925458f, 0.02101768f, -0.03495323f, 0.00752526f, 0.00291217f, 
    -0.06580967f, -0.00926290f, -0.06537282f, -0.05850418f, -0.06038831f, -0.04979621f, -0.05933361f, 0.06177406f, 
    0.05169491f, -0.02203367f, -0.02779465f, 0.04629211f, -0.03917489f, -0.02257228f, 0.03666151f, -0.08029015f, 
    -0.06792627f, -0.03711320f, 0.01621511f, -0.00195622f, 0.01073246f, 0.02682518f, -0.08232919f, -0.04738346f, 
    0.05706534f, -0.02677518f, -0.00219217f, 0.03353930f, -0.02163404f, -0.01201882f, -0.04306601f, -0.05354024f, 
    0.01335957f, -0.04309789f, 0.05169422f, 0.01481095f, -0.06852894f, -0.00777473f, -0.02515080f, -0.01674888f, 
    -0.07545712f, -0.03330094f, -0.01111991f, -0.06656950f, 0.01762530f, -0.07238991f, 0.00453572f, 0.05500081f, 
    -0.04186289f, -0.03355570f, -0.04637360f, -0.03611941f, -0.05449564f, -0.03086044f, -0.03925112f, 0.04365037f, 
    0.04636461f, -0.06354294f, 0.05695749f, 0.01583520f, -0.03600676f, 0.06090729f, -0.06216634f, -0.00586581f, 
    0.04590099f, -0.04387693f, 0.06095911f, 0.01267863f, -0.02703751f, -0.08768241f, 0.04811436f, -0.00480225f, 
    0.04848552f, 0.04600555f, 0.05612615f, 0.03991306f, 0.00124655f, -0.05621648f, 0.06266837f, -0.04485385f, 
    0.03963539f, -0.06595033f, 0.04459405f, -0.00296006f, -0.02077288f, -0.07051813f, -0.04421444f, 0.05717856f, 
    -0.00816103f, 0.05117100f, -0.05303152f, -0.00398913f, -0.00301891f, 0.03396320f, 0.06078050f, -0.02351074f, 
    -0.04872118f, 0.04006829f, 0.02896743f, 0.04285666f, -0.03134347f, 0.00738672f, -0.06210609f, -0.05800914f, 
    -0.05855246f, -0.07247757f, 0.01074646f, -0.04988603f, 0.01150456f, -0.04829866f, 0.05864412f, -0.03094212f, 
    0.03344836f, 0.00340641f, -0.02467360f, -0.02746044f, 0.05750879f, -0.06352001f, 0.05687186f, 0.00043434f, 
    0.02719280f, -0.00857936f, 0.03588611f, -0.01872807f, -0.02301897f, -0.04217496f, -0.04032740f, 0.04487812f, 
    0.03590588f, -0.02359262f, 0.03488309f, 0.04142883f, -0.00623550f, 0.05014483f, -0.01885871f, -0.06609505f, 
    -0.04193700f, -0.03728737f, 0.01792189f, -0.05464478f, -0.00421941f, -0.03917001f, -0.01378368f, 0.02107954f, 
    0.03441448f, -0.00517400f, 0.06209748f, -0.01204130f, 0.04954913f, -0.02395213f, -0.03792991f, -0.03193115f, 
    0.04844510f, -0.06934603f, -0.01013617f, -0.00720852f, -0.01457160f, 0.01330568f, -0.02469745f, 0.03245850f, 
    -0.06196154f, -0.04636183f, 0.01400993f, -0.00025924f, -0.08930323f, -0.05902181f, -0.03280057f, -0.03273803f, 
    -0.05929061f, -0.03642465f, -0.00408053f, -0.07112902f, -0.00576356f, 0.04649345f, -0.05359082f, 0.04302865f, 
    0.00415125f, -0.07073613f, -0.07457254f, -0.02536011f, 0.01951136f, 0.00697275f, 0.04733139f, 0.05281376f, 
    0.06081301f, -0.06829426f, -0.00608868f, -0.04954230f, -0.04251481f, -0.06296820f, -0.03885966f, -0.06937123f, 
    -0.05880074f, -0.04561843f, -0.00458837f, -0.00389150f, 0.03935902f, 0.00271190f, -0.05354775f, 0.02232973f, 
    -0.06353434f, 0.03132556f, -0.04290452f, 0.01839620f, -0.05069962f, 0.01321806f, 0.00123376f, -0.04641239f, 
    -0.03019890f, -0.03920264f, 0.00128006f, -0.00789113f, 0.01484910f, -0.05149316f, 0.02467987f, -0.01275553f, 
    0.02392958f, 0.01970303f, -0.01912460f, -0.02541095f, -0.05136846f, -0.03199513f, 0.04025050f, -0.03120131f, 
    -0.00977983f, -0.05786873f, 0.01409136f, -0.02984230f, -0.07023251f, -0.01845421f, 0.06826410f, 0.00763177f, 
    -0.05783407f, 0.01992328f, -0.00216153f, -0.01962470f, -0.01408930f, 0.01520483f, -0.00794592f, -0.07232551f, 
    -0.06085279f, -0.07720591f, 0.01599928f, -0.01806331f, 0.03234020f, -0.06156942f, -0.07384589f, -0.05218913f, 
    -0.03631904f, 0.05056598f, 0.02543730f, 0.03142172f, -0.03843490f, -0.00880531f, -0.00563315f, -0.00114790f, 
    -0.01719457f, 0.03479933f, -0.01145235f, 0.03380002f, 0.02598263f, -0.06352848f, 0.02221090f, -0.05667481f, 
    -0.04275826f, -0.00732089f, -0.00923429f, 0.05834614f, -0.04401539f, 0.06360504f, -0.04693465f, -0.01861025f, 
    0.02897700f, -0.07663264f, 0.04174616f, -0.02621036f, 0.02943693f, 0.02747377f, -0.05321596f, 0.02044788f, 
    -0.00398330f, 0.04576268f, 0.02518750f, -0.04010716f, 0.03058061f, -0.04437203f, 0.04838291f, -0.02104568f, 
    -0.01073327f, 0.04484299f, 0.05733430f, 0.04175420f, -0.03239309f, 0.05056591f, -0.04913014f, 0.01081476f, 
    0.00906384f, 0.01127485f, -0.00229189f, 0.03538783f, -0.00933133f, -0.03600192f, -0.04098114f, 0.05829610f, 
    -0.01261589f, -0.05804544f, 0.03864127f, 0.03235998f, -0.01719546f, 0.06242601f, -0.02192026f, 0.03859169f, 
    0.01754613f, -0.05955805f, -0.01858668f, 0.05053975f, -0.05798643f, 0.02409423f, -0.04217285f, -0.00952225f, 
    -0.02078613f, -0.01441366f, -0.02333523f, -0.01868705f, -0.02942208f, -0.04308226f, -0.06401440f, 0.05552495f, 
    -0.00553480f, 0.04363609f, 0.06040097f, -0.04910520f, 0.03713322f, -0.06544970f, -0.07400579f, -0.07135045f, 
    -0.02380427f, -0.03996083f, -0.05917419f, -0.02249440f, -0.07112429f, -0.06312732f, -0.03048552f, 0.03802771f, 
    0.05212595f, -0.00847703f, 0.02379074f, 0.03303082f, 0.04270453f, -0.06065919f, 0.01390970f, -0.03448315f, 
    -0.02601563f, 0.01002831f, -0.04668547f, -0.00718411f, -0.03190514f, -0.00564855f, 0.01502409f, 0.00377421f, 
    -0.10233422f, -0.01633506f, 0.16943312f, 0.14055069f, -0.02354642f, -0.00777670f, -0.10381623f, -0.02264767f, 
    -0.11315612f, -0.00150843f, 0.08372110f, -0.01060307f, -0.12702206f, -0.12624043f, -0.27551898f, 0.21311353f, 
    0.00101108f, 0.05560121f, 0.04088935f, 0.17455657f, -0.08894437f, -0.06908788f, 0.03763564f, -0.08958135f, 
    0.33999053f, 0.07728254f, 0.29754588f, -0.32278275f, -0.08830195f, -0.11625583f, -0.08415741f, 0.01283025f, 
    0.03632114f, 0.07951407f, -0.03617150f, 0.03150243f, -0.21075401f, 0.29153636f, -0.44756001f, 0.10115678f, 
    0.05004848f, -0.01945587f, 0.03443537f, -0.14014408f, -0.02990798f, 0.03265030f, 0.13540989f, 0.03851736f, 
    0.17880480f, 0.26096454f, -0.05611754f, 0.20078222f, 0.11124770f, 0.08426869f, -0.06032172f, 0.10124561f, 
    0.01821191f, -0.04787746f, 0.01135441f, -0.06547239f, 0.17588243f, 0.30179903f, -0.00095199f, 0.13569443f, 
    -0.17859836f, 0.00898194f, 0.06083007f, -0.04842287f, -0.01574357f, 0.03643033f, -0.07232032f, 0.00067520f, 
    0.03925928f, 0.06786240f, -0.38457620f, 0.16797821f, 0.02217454f, -0.00108179f, 0.00974027f, -0.08669665f, 
    -0.02952463f, 0.00247812f, 0.04719145f, 0.05716999f, -0.02809389f, -0.03739805f, 0.23987685f, 0.22887041f, 
    -0.10200704f, 0.24937475f, -0.10349858f, 0.04130555f, -0.16423693f, 0.15901086f, 0.16208050f, 0.08626096f, 
    0.21248785f, -0.07976099f, 0.15511002f, -0.05527233f, -0.13177684f, -0.08870883f, -0.15302321f, 0.02028737f, 
    0.06785982f, 0.11455159f, 0.15220919f, 0.02857389f, 0.12369426f, 0.20046365f, 0.03515430f, 0.02411343f, 
    -0.15668522f, -0.09565724f, 0.08275392f, -0.06869842f, -0.07462751f, -0.21726827f, -0.00568523f, 0.25341275f, 
    0.42742926f, 0.06330254f, 0.04458393f, 0.47773987f, -0.29181072f, 0.19174677f, -0.11089336f, 0.04845271f, 
    -0.07430133f, 0.06498199f, 0.11284841f, 0.09048679f, 0.33536839f, -0.04897527f, 0.18526022f, -0.42168531f, 
    0.08631178f, 0.02737950f, 0.11559862f, 0.02531161f, -0.25481442f, -0.12957022f, -0.13304576f, -0.18864112f, 
    -0.06835146f, 0.05140237f, -0.16661672f, 0.12558898f, 0.13566348f, -0.04374186f, -0.14478609f, 0.28074536f, 
    -0.08402839f, 0.09710039f, 0.06471772f, -0.05520127f, -0.10796806f, -0.15806668f, 0.22492623f, -0.24103731f, 
    0.01565254f, 0.04036426f, 0.09409741f, -0.06301048f, 0.03328491f, 0.11377039f, -0.05073998f, -0.02989509f, 
    -0.36306065f, 0.01022682f, 0.14963794f, 0.23709536f, -0.11953136f, -0.02974211f, 0.04209835f, -0.12323564f, 
    -0.06445640f, -0.03474236f, 0.08824602f, 0.04241455f, 0.10952657f, 0.22643782f, -0.05068358f, -0.06707839f, 
    0.04143247f, 0.18259677f, 0.22892663f, -0.05506183f, -0.09668934f, 0.17819712f, -0.01580086f, -0.03693467f, 
    0.00520641f, 0.00525673f, 0.01885307f, 0.26641122f, 0.15743335f, -0.01904310f, 0.17620033f, 0.23683746f, 
    -0.00219871f, 0.02172578f, -0.06930340f, 0.03487702f, -0.01055457f, -0.08055208f, 0.44999221f, -0.13195628f, 
    -0.03798964f, -0.12245744f, 0.03137688f, -0.04141034f, 0.18833940f, -0.08947474f, 0.21834141f, 0.00736033f, 
    0.44878846f, -0.25823724f, -0.47576639f, 0.03882571f, 0.03653550f, -0.18075308f, -0.01511960f, -0.04798703f, 
    0.10992985f, -0.03218852f, -0.04828627f, 0.00432819f, -0.00209140f, -0.12519580f, 0.07135917f, 0.05903053f, 
    -0.05271611f, 0.00942144f, 0.03532471f, 0.08177124f, 0.05218608f, 0.01862717f, -0.05435807f, 0.10159797f, 
    -0.34942737f, -0.08086295f, 0.24418041f, 0.16828330f, -0.14146130f, -0.04871471f, -0.05777238f, -0.05144490f, 
    0.04291002f, 0.02397091f, -0.05497714f, 0.23434493f, 0.00945779f, -0.09396216f, 0.23378861f, 0.21944599f, 
    -0.02711337f, 0.04428845f, -0.06070054f, -0.09811308f, 0.04778390f, 0.05762941f, -0.04047331f, 0.05142566f, 
    -0.18237285f, -0.09370723f, 0.30910346f, 0.04513159f, -0.07710563f, 0.14513101f, 0.10557017f, 0.28587136f, 
    0.16167265f, 0.11276986f, 0.09515998f, -0.00785826f, -0.11411629f, 0.17238729f, 0.02666690f, -0.26158318f, 
    -0.19227277f, -0.00824487f, 0.02654530f, 0.08979457f, 0.17397834f, -0.04707881f, 0.25279778f, 0.04322843f, 
    -0.02570887f, 0.03162638f, -0.12634751f, -0.25520059f, -0.09290984f, -0.07871655f, -0.06955972f, 0.05316867f, 
    0.05539106f, -0.12436415f, 0.15087843f, -0.14549357f, -0.05891968f, -0.16527005f, 0.00554622f, -0.29710504f, 
    -0.06308009f, -0.18153897f, 0.07634485f, 0.23158906f, 0.08483368f, 0.04385799f, -0.00608924f, -0.01020278f, 
    0.18879211f, 0.39496586f, 0.89348930f, -0.44928065f, -0.13603956f, 0.02956329f, -0.04456627f, -0.04211978f, 
    -0.14672320f, 0.03870456f, 0.18877724f, -0.01928357f, -0.37053877f, -0.11184094f, -0.08973535f, 0.20433551f, 
    -0.00930938f, 0.00840234f, -0.06087603f, -0.07033909f, 0.10471761f, -0.07291796f, -0.01889209f, 0.04749623f, 
    -0.01515941f, 0.03860971f, 0.13020848f, -0.07188819f, 0.01616353f, 0.07437456f, -0.21604641f, -0.11913697f, 
    -0.02901722f, -0.18665361f, 0.05575915f, -0.12242287f, 0.21966141f, 0.27227208f, -0.15969086f, 0.04834619f, 
    0.03406978f, -0.11429074f, -0.05699755f, -0.16993782f, 0.17474517f, 0.06130967f, -0.09538588f, -0.02818415f, 
    0.51292193f, 0.39505470f, 0.13383864f, -0.21356095f, 0.00492945f, -0.11851346f, -0.16327757f, -0.00776907f, 
    0.12481503f, 0.02787808f, 0.01301819f, 0.01742797f, -0.03987982f, -0.24479151f, -0.10465116f, -0.00629024f, 
    -0.04511095f, -0.02325857f, 0.00612874f, 0.26256597f, 0.18683270f, 0.03157213f, 0.06551199f, -0.04097495f, 
    -0.06503128f, -0.01370648f, 0.02180859f, 0.00822186f, 0.03191919f, 0.04489144f, -0.03068880f, -0.00739985f, 
    0.02890534f, -0.06168662f, -0.00839191f, 0.03729618f, -0.04222801f, 0.03005098f, -0.02369592f, -0.01969545f, 
    -0.04095506f, -0.00104719f, -0.06745073f, -0.02010202f, 0.04478579f, 0.04346585f, -0.04231831f, 0.04911750f, 
    -0.02996280f, -0.02403045f, 0.00699396f, -0.01384005f, -0.03412540f, -0.01994141f, -0.00622355f, -0.04532073f, 
    0.05339839f, -0.00490788f, 0.03549892f, -0.02654378f, 0.03039889f, 0.03044979f, -0.00165889f, 0.02138554f, 
    -0.03142743f, 0.04009039f, -0.05068539f, -0.02045049f, 0.00128483f, -0.06840922f, 0.03880360f, -0.04830016f, 
    0.04623508f, -0.03014903f, 0.03609601f, -0.02470786f, -0.05672773f, 0.00173038f, 0.05568508f, 0.04299179f, 
    -0.02662299f, -0.04661387f, -0.07272942f, -0.03447073f, 0.03733254f, 0.05036895f, -0.06860566f, 0.03499531f, 
    -0.04102477f, 0.05639908f, 0.06458092f, 0.03216481f, -0.04989427f, 0.03627388f, 0.00185447f, 0.02377657f, 
    0.06655629f, -0.02876280f, 0.00761361f, 0.06004719f, -0.02555625f, 0.02837265f, -0.03084948f, -0.06528364f, 
    0.01088448f, -0.04427036f, -0.06090479f, 0.04275797f, -0.02901695f, 0.00914821f, 0.06541623f, 0.00470326f, 
    0.02282768f, -0.00370921f, -0.06043587f, -0.05191189f, 0.01592722f, -0.07586987f, -0.03649821f, 0.01394603f, 
    -0.03091034f, -0.06371806f, -0.03335505f, -0.07731313f, -0.06508192f, -0.00116210f, 0.02753289f, 0.04726234f, 
    0.00472751f, -0.01496129f, -0.07046426f, -0.04006775f, 0.03438879f, -0.01873787f, -0.01712870f, -0.00956021f, 
    0.05109303f, -0.03224199f, -0.05378855f, 0.01241526f, -0.07091816f, -0.01778998f, -0.01111980f, 0.01440366f, 
    -0.06207456f, -0.07363433f, 0.00035975f, 0.05525842f, 0.06383191f, 0.02844946f, -0.05226413f, 0.05531056f, 
    0.03046562f, -0.00958991f, 0.05839961f, -0.05355353f, 0.04449181f, 0.04533390f, 0.01062850f, -0.04913143f, 
    -0.05245138f, 0.03364256f, -0.03436488f, 0.06158008f, 0.03924470f, -0.06794306f, -0.01130086f, -0.07515836f, 
    0.06304479f, 0.04834064f, -0.02347030f, 0.02487685f, -0.04145589f, -0.04293666f, -0.05198405f, -0.04142899f, 
    -0.04183321f, -0.02461232f, -0.03466600f, -0.06952214f, -0.06320969f, -0.04594043f, -0.00230690f, -0.06371799f, 
    -0.03979150f, 0.00864270f, 0.01816726f, -0.07080613f, -0.05154802f, -0.05927074f, 0.01328305f, -0.01538138f, 
    0.06134939f, -0.02670362f, -0.00249969f, -0.05264322f, -0.02335076f, -0.05750915f, -0.02974791f, -0.01869148f, 
    -0.05293095f, -0.04989360f, -0.01419983f, 0.05031020f, -0.02771115f, -0.06479771f, -0.04609406f, -0.06778452f, 
    0.02808663f, 0.04481335f, 0.00484276f, -0.00638750f, -0.01005823f, 0.01787992f, 0.02828017f, 0.02567495f, 
    0.00616706f, -0.00323701f, -0.00652922f, -0.07018273f, 0.01404826f, -0.02022480f, 0.01812057f, -0.01677103f, 
    -0.02694857f, -0.03108205f, -0.00968619f, 0.02940728f, 0.05242271f, 0.06122985f, 0.05783337f, -0.03724239f, 
    0.04562058f, -0.07070532f, -0.03085187f, -0.07994247f, 0.04904778f, -0.07961459f, -0.02426859f, 0.04125899f, 
    0.05652187f, 0.05611426f, -0.04998448f, 0.03796175f, 0.03078161f, -0.01160934f, 0.03348513f, 0.05440269f, 
    -0.04808469f, -0.02960624f, 0.00217694f, 0.03694852f, 0.01744569f, -0.07545106f, -0.00396375f, 0.03505849f, 
    -0.01060859f, 0.01325653f, 0.00253196f, 0.04918322f, -0.06922556f, -0.07067627f, 0.00093792f, 0.05913708f, 
    -0.01333721f, -0.02399309f, -0.01914942f, -0.02168213f, -0.07153068f, -0.02995057f, -0.03027672f, -0.00450939f, 
    -0.02721029f, -0.06397974f, -0.06642592f, -0.03731763f, -0.00710725f, -0.07092649f, -0.02839453f, -0.03495209f, 
    -0.02147687f, -0.01846273f, 0.04338854f, -0.03094993f, 0.06053375f, -0.00286756f, 0.01814970f, 0.00261330f, 
    -0.04537034f, -0.07948738f, 0.02631353f, -0.00000541f, -0.05341082f, -0.01131767f, 0.04676197f, -0.02098140f, 
    0.04160613f, -0.05370327f, -0.05546619f, 0.02728985f, 0.01859239f, -0.01261814f, 0.06044438f, 0.05386924f, 
    0.02762754f, 0.01251488f, -0.05499052f, -0.06450617f, -0.07359314f, -0.03100510f, -0.07127536f, 0.01819899f, 
    -0.03055052f, 0.01177988f, -0.00830302f, 0.03906363f, 0.01726502f, 0.00733179f, -0.00073638f, -0.07879006f, 
    -0.02029167f, -0.03802842f, -0.03374656f, 0.01502308f, 0.00841195f, -0.06756203f, -0.03546392f, 0.04163842f, 
    0.04805044f, 0.05055882f, 0.03906368f, -0.04997502f, -0.07978965f, 0.04208048f, 0.02681190f, -0.04508792f, 
    -0.00883876f, 0.05167692f, 0.04993706f, 0.03971530f, 0.04216238f, -0.06703907f, -0.04241246f, -0.05314403f, 
    -0.04578853f, -0.01517426f, 0.00329869f, -0.03277046f, -0.00261439f, 0.03647095f, -0.06314389f, 0.00970647f, 
    -0.06574649f, -0.04153689f, -0.02099830f, -0.02282153f, -0.01956678f, -0.03105095f, 0.03573543f, -0.07176311f, 
    0.01799124f, 0.02978963f, -0.08103301f, -0.06773689f, 0.00367117f, -0.00788874f, 0.03998652f, 0.00752315f, 
    -0.07139625f, 0.01443895f, 0.01043287f, -0.07471314f, -0.04114561f, -0.05482864f, -0.04826519f, -0.03574790f, 
    0.02549500f, -0.00861294f, -0.07910593f, -0.03222822f, -0.06234786f, -0.00390160f, 0.00721405f, -0.00286472f, 
    -0.07017878f, 0.01264429f, 0.03186274f, -0.03752095f, 0.00314679f, 0.06069006f, 0.02094932f, -0.02094486f, 
    0.00289413f, 0.02901119f, 0.03930229f, -0.04287004f, -0.01121277f, 0.00036842f, 0.01058869f, 0.00659457f, 
    -0.07556643f, -0.04328949f, 0.01699342f, -0.03332678f, -0.03570348f, -0.01201348f, 0.04312890f, -0.05725829f, 
    -0.01943754f, 0.06749309f, 0.20452966f, -0.19889466f, 0.07568219f, 0.15532051f, -0.10334102f, 0.09737655f, 
    0.06522721f, 0.08265413f, 0.21368319f, 0.12520449f, -0.09184874f, -0.23445652f, -0.19921653f, 0.11575425f, 
    -0.04207211f, 0.02431500f, 0.22895131f, 0.12306501f, 0.13690454f, 0.07539698f, -0.01920385f, 0.00624048f, 
    0.41396835f, 0.13022898f, 0.64137924f, -0.06814418f, -0.00929541f, -0.27250594f, -0.13186204f, -0.04391433f, 
    -0.01241290f, -0.01425115f, -0.04401897f, 0.04012317f, -0.04017726f, -0.05541655f, -0.01949489f, -0.21379797f, 
    0.05909323f, 0.04517696f, 0.02700262f, -0.09498402f, 0.10604738f, -0.06690800f, -0.02257041f, 0.12751259f, 
    0.23136579f, 0.24478906f, -0.10987324f, -0.20677987f, 0.07792772f, -0.02525640f, 0.23528141f, 0.01809177f, 
    0.05842594f, -0.08524189f, -0.09458387f, 0.05583392f, 0.00909380f, 0.11662917f, 0.08053942f, -0.02075819f, 
    0.00246310f, 0.00656753f, -0.14917424f, -0.07082038f, 0.01702675f, -0.02238545f, -0.03223328f, 0.05268337f, 
    0.29075658f, 0.16344790f, -0.00025120f, -0.01852618f, 0.04612734f, -0.08121386f, 0.15931562f, -0.00062398f, 
    0.01368361f, 0.00625576f, -0.13480721f, 0.03311661f, -0.39565048f, -0.32581091f, 0.08054205f, -0.06631356f, 
    -0.01535153f, 0.00183871f, -0.21227498f, -0.01486848f, -0.06473983f, 0.03080892f, 0.13666785f, 0.07742367f, 
    -0.28118315f, 0.08873899f, 0.24587174f, 0.13027655f, -0.06953244f, -0.08842741f, -0.44375205f, -0.02237828f, 
    -0.10088998f, -0.07768253f, -0.07350514f, -0.16385828f, -0.21567510f, -0.01597379f, 0.07461586f, -0.03801888f, 
    0.03778912f, 0.00251525f, -0.02544150f, 0.11472086f, -0.23001786f, -0.13204342f, 0.05819209f, 0.01936418f, 
    0.33850077f, 0.22786053f, 0.08357333f, 0.28505707f, -0.16248159f, -0.00411899f, -0.05105596f, 0.11543621f, 
    0.03330763f, 0.00159038f, 0.14995241f, -0.02333369f, 0.16767165f, -0.02238696f, -0.15469076f, 0.09980300f, 
    0.00854749f, 0.02775628f, 0.01429553f, 0.06997290f, -0.04157212f, 0.05287676f, 0.00976652f, 0.23560891f, 
    0.34496725f, -0.01942641f, -0.05122565f, 0.18462650f, 0.09874099f, 0.12411608f, 0.13280402f, -0.03945355f, 
    -0.03389693f, 0.07525471f, 0.08464976f, -0.14748062f, 0.14408673f, -0.00720440f, 0.26644602f, -0.08776146f, 
    -0.05785248f, -0.12813506f, -0.01158433f, 0.02985922f, 0.06953122f, -0.15508504f, 0.25759625f, -0.02888695f, 
    -0.64080763f, 0.26053742f, 0.38267806f, -0.00404649f, 0.00345746f, -0.01220480f, -0.11819994f, -0.06704329f, 
    -0.13572019f, -0.05156223f, 0.03153507f, 0.07891923f, -0.10314109f, -0.06419982f, 0.04688293f, -0.19349350f, 
    0.04484149f, 0.08347816f, -0.00659237f, -0.15917550f, 0.14992140f, 0.06789752f, 0.01634348f, 0.10228828f, 
    0.41437584f, 0.03820059f, -0.26298580f, 0.08413127f, 0.26134640f, 0.02497242f, 0.16282146f, -0.00561895f, 
    -0.05714948f, 0.07065006f, 0.01786560f, 0.18464537f, -0.35666877f, 0.12080524f, -0.13765734f, 0.22977723f, 
    -0.01477619f, 0.14604782f, 0.03425587f, 0.19373438f, 0.24641474f, -0.10148040f, 0.08799698f, -0.10594084f, 
    0.41637751f, 0.20377870f, 0.07922564f, -0.16306470f, 0.09999668f, -0.10720566f, 0.07978902f, -0.05805492f, 
    -0.03942290f, 0.03685006f, 0.09050205f, 0.12343548f, -0.21716303f, 0.39500576f, -0.16780643f, 0.11543525f, 
    -0.08063622f, 0.08608406f, 0.03070939f, -0.06581423f, -0.07110549f, 0.05011274f, -0.10341868f, -0.11757566f, 
    0.30028847f, 0.05435726f, -0.47603878f, -0.04496550f, 0.06591073f, 0.20459396f, 0.26442218f, -0.04952988f, 
    -0.09589067f, 0.02521504f, 0.05102049f, -0.15627953f, 0.03625673f, 0.05339356f, -0.03457443f, 0.25452340f, 
    0.00210908f, -0.05573655f, 0.17857693f, -0.18220752f, 0.02096657f, 0.00167350f, 0.08173745f, -0.05818352f, 
    0.06229958f, -0.18328656f, -0.47226790f, -0.20729193f, -0.05659641f, 0.01493424f, 0.14018838f, -0.03234971f, 
    0.04591701f, 0.00682264f, 0.00938085f, -0.13501157f, -0.10953541f, -0.16575636f, 0.09438154f, 0.08185056f, 
    0.08807100f, 0.07114287f, -0.06483886f, 0.15029886f, 0.03848248f, -0.05187611f, -0.09517229f, -0.02430359f, 
    -0.40768874f, 0.09092938f, 0.08097876f, -0.09348973f, 0.01035197f, 0.04856953f, -0.04365091f, -0.11373078f, 
    -0.40934700f, -0.05922019f, -0.23876862f, -0.22005746f, -0.08858071f, -0.01226915f, -0.00449788f, -0.14540112f, 
    0.01996903f, 0.18984535f, 0.06571462f, 0.02071849f, -0.14999807f, 0.04458714f, -0.04541859f, -0.11090825f, 
    -0.19242404f, -0.18523648f, 0.11993267f, 0.23266190f, -0.13654479f, 0.15134542f, -0.02216060f, 0.02262580f, 
    0.04908554f, 0.00851745f, 0.00721492f, 0.20366819f, -0.14640769f, -0.08604090f, 0.06071751f, -0.04796569f, 
    -0.19738388f, -0.00250504f, -0.08497390f, 0.01521646f, 0.25211585f, 0.23420879f, 0.13383280f, 0.14754128f, 
    -0.27369717f, -0.05509415f, -0.11668611f, 0.08407164f, 0.07452011f, 0.18673152f, 0.12147437f, 0.28313512f, 
    -0.09430240f, 0.03633672f, -0.33676133f, -0.18310632f, -0.00449843f, 0.16572586f, 0.12788571f, -0.11153654f, 
    -0.00600070f, -0.05212213f, -0.04811070f, 0.05777298f, 0.01615460f, 0.30777952f, 0.15716408f, 0.11428975f, 
    -0.02169876f, -0.03663142f, 0.05478460f, 0.37478805f, -0.02446997f, 0.01621882f, 0.00018315f, -0.05813289f, 
    -0.07277121f, -0.02130221f, -0.05304319f, -0.08695059f, -0.12075154f, 0.16552474f, -0.02816343f, -0.09228620f, 
    0.02183732f, 0.02282625f, -0.04976466f, -0.08322052f, 0.00202646f, 0.24040501f, 0.02397556f, 0.17240968f, 
    -0.07803726f, 0.04867447f, 0.02171384f, 0.32317129f, 0.11115806f, -0.04178397f, 0.08214975f, 0.21715488f, 
    -0.07116777f, 0.08568855f, -0.00848004f, -0.02569265f, 0.12054653f, 0.08415871f, 0.08472387f, 0.16283911f, 
    -0.07075348f, -0.17045431f, -0.01768043f, 0.28056946f, 0.13680147f, 0.02422348f, 0.00176117f, -0.04469943f, 
    0.10249635f, -0.00941528f, -0.09419609f, -0.06983693f, -0.03580629f, -0.15577941f, -0.16260844f, 0.18226524f, 
    -0.14602189f, 0.07144179f, -0.19914362f, 0.05792240f, -0.49846157f, 0.39451393f, -0.27007529f, 0.29867622f, 
    -0.03723585f, -0.22178964f, 0.15164822f, 0.16883959f, 0.04656640f, -0.09699041f, 0.05394226f, 0.21518140f, 
    -0.24376722f, -0.24325164f, 0.13052118f, 0.21703528f, -0.19735952f, -0.08826127f, 0.04854679f, -0.13254137f, 
    -0.11304954f, -0.01578885f, -0.07445014f, -0.08200479f, 0.07465810f, 0.01329850f, 0.11426565f, -0.07255396f, 
    -0.00874345f, 0.11838232f, 0.05538889f, -0.18360953f, -0.01777508f, -0.07955516f, 0.06571957f, -0.00742583f, 
    -0.03957209f, 0.08418496f, 0.15726091f, -0.00152995f, 0.10835113f, -0.13874082f, 0.03739663f, 0.14659877f, 
    -0.08609406f, 0.01212346f, -0.05437388f, -0.08771677f, 0.51234150f, -0.42130366f, 0.07154083f, -0.16676901f, 
    -0.11840743f, 0.12374663f, 0.08136205f, -0.06851634f, -0.07769582f, 0.26854321f, 0.15259708f, 0.03066071f, 
    0.28336209f, -0.16345124f, 0.07383455f, -0.15462628f, -0.02704419f, -0.07658903f, -0.12082033f, -0.07814460f, 
    -0.02446343f, 0.04544658f, 0.03998676f, -0.19741537f, -0.02687864f, -0.00914938f, -0.04772690f, -0.15030091f, 
    0.00724632f, -0.04624786f, 0.05665798f, 0.38344908f, 0.05002869f, 0.04319401f, 0.16064408f, -0.01034015f, 
    0.15612504f, -0.01815703f, 0.18885225f, -0.30662253f, -0.04665349f, 0.24422047f, -0.31035396f, 0.14934346f, 
    -0.10301898f, 0.10637921f, -0.03089027f, 0.10110595f, -0.32185677f, -0.20973666f, 0.06940608f, -0.23171090f, 
    -0.03913315f, -0.06222084f, -0.03409835f, 0.00196518f, 0.04653154f, -0.04901064f, 0.03661723f, -0.04781807f, 
    0.07256372f, 0.18665501f, -0.00869612f, -0.08625367f, -0.11830229f, 0.05983745f, -0.23652135f, 0.15444005f, 
    -0.04439615f, -0.01769954f, -0.00668619f, -0.03500387f, 0.01220532f, -0.04746780f, 0.19171636f, 0.02751034f, 
    0.18649696f, 0.06026391f, 0.08816975f, 0.01889858f, 0.15887111f, 0.27845398f, 0.09756430f, 0.19866987f, 
    0.48862755f, 0.23300007f, 0.07818194f, 0.02065832f, 0.02070036f, -0.14452212f, 0.08723488f, -0.03785291f, 
    0.09310877f, -0.01435425f, -0.07196687f, 0.04321846f, -0.17002033f, 0.05217744f, -0.18107249f, 0.11001370f, 
    0.11906509f, -0.07201502f, 0.22535808f, 0.10780338f, -0.07838257f, 0.06505796f, -0.09729092f, -0.05603146f, 
    -0.06524082f, -0.03612967f, -0.04755862f, -0.08476741f, 0.01014377f, -0.07831305f, -0.07594794f, 0.03997472f, 
    -0.04687477f, -0.09400240f, -0.04327563f, -0.02388839f, -0.05875738f, -0.01739365f, -0.06719971f, 0.00944319f, 
    0.03253429f, 0.01956767f, 0.01954981f, 0.05192776f, 0.01573821f, -0.08331303f, -0.01736918f, -0.02570106f, 
    -0.08089942f, 0.01996874f, 0.03226627f, 0.02330235f, -0.07956579f, -0.07501291f, -0.00003280f, 0.00708016f, 
    -0.09123346f, 0.02376744f, -0.05770983f, 0.01404225f, -0.08295733f, 0.03768409f, -0.03169060f, -0.01692115f, 
    -0.08806054f, -0.08254454f, -0.00278783f, 0.01402115f, -0.02682993f, 0.02386306f, -0.04220520f, -0.01021565f, 
    -0.06655043f, -0.06869129f, -0.03301759f, -0.05400649f, 0.03649093f, 0.00690410f, -0.02590506f, -0.04676744f, 
    -0.07756658f, -0.03495542f, -0.03042988f, 0.02824678f, 0.04015306f, -0.06240715f, -0.04078651f, -0.06892624f, 
    -0.04202049f, -0.08122651f, -0.03689254f, 0.00811404f, -0.00802680f, -0.00668579f, -0.04427077f, -0.09559627f, 
    -0.05998011f, 0.01144555f, -0.03913599f, 0.03649778f, -0.06029817f, -0.09447575f, -0.05008810f, -0.09646664f, 
    0.03517514f, -0.10339813f, -0.06398437f, 0.03792024f, 0.04922558f, 0.03992441f, -0.03047463f, -0.05868740f, 
    -0.03012743f, -0.01515509f, -0.08851083f, 0.02683865f, -0.02572258f, -0.06716266f, -0.03879358f, -0.05516478f, 
    -0.08116711f, -0.01119529f, 0.02129414f, -0.07544095f, -0.06282451f, -0.06499395f, -0.05028790f, -0.00679308f, 
    0.03638192f, 0.01541949f, -0.01866299f, 0.06502240f, -0.07417540f, -0.05031100f, -0.02425868f, -0.04287087f, 
    -0.02247747f, 0.02977016f, -0.07706121f, -0.06414899f, -0.05950551f, -0.05807424f, -0.00109374f, -0.07798586f, 
    0.04331912f, -0.01887203f, -0.08898337f, 0.02754843f, -0.02738472f, 0.03039775f, -0.03361293f, -0.00201112f, 
    -0.00435741f, -0.04046617f, -0.02752161f, 0.04527288f, -0.08913010f, 0.03412668f, -0.08472503f, -0.01880950f, 
    0.00094531f, -0.04831098f, 0.04394366f, 0.02845146f, -0.02342512f, 0.02071091f, -0.04561395f, 0.03097559f, 
    -0.08609921f, -0.05360656f, -0.01698574f, -0.08108766f, -0.05991227f, -0.07631353f, 0.04795191f, -0.01662390f, 
    -0.01088659f, -0.09515203f, -0.04929659f, -0.05287179f, 0.02447015f, -0.08752570f, -0.01810291f, 0.04896372f, 
    -0.05972652f, 0.03045219f, -0.04049438f, -0.02567595f, -0.05437220f, 0.00520065f, -0.09027599f, -0.05415022f, 
    -0.02003986f, -0.00463970f, -0.00499066f, -0.02002793f, -0.08280902f, 0.01032540f, -0.07121304f, 0.05173551f, 
    -0.01425369f, -0.03904605f, 0.01319848f, -0.07185324f, -0.01334780f, 0.06866246f, 0.04457847f, 0.05170099f, 
    0.04450887f, -0.04948891f, -0.03714374f, -0.03554136f, -0.02457076f, 0.00782601f, 0.04706442f, -0.01769356f, 
    -0.00320737f, -0.28695258f, 0.08156471f, 0.00429253f, -0.00730104f, 0.12040029f, -0.03931405f, 0.10280714f, 
    -0.08540694f, -0.06568343f, 0.19914515f, -0.16920500f, 0.00771277f, 0.04809411f, -0.36746687f, -0.02347867f, 
    -0.07948076f, 0.08297578f, 0.12621987f, -0.04465613f, 0.12132131f, 0.06989684f, -0.11369853f, -0.07638419f, 
    -0.27953827f, -0.12355465f, 0.25149435f, -0.07823689f, 0.02257362f, 0.01542419f, -0.12927021f, -0.00850658f, 
    -0.05625482f, 0.11996090f, 0.05467067f, -0.00329981f, -0.16196081f, -0.18836392f, 0.20380768f, -0.37779415f, 
    -0.02708214f, -0.01668137f, 0.06501280f, 0.21972513f, 0.06085945f, -0.00112269f, -0.01718144f, -0.01317418f, 
    -0.20504372f, -0.04570472f, -0.07667892f, -0.01466442f, -0.18679291f, -0.13072644f, 0.25459674f, -0.03491863f, 
    -0.04115719f, 0.02340282f, 0.02877402f, 0.08554875f, -0.08792467f, -0.14610252f, 0.15658306f, -0.11967818f, 
    0.21404848f, 0.04868433f, -0.21767522f, -0.08102392f, 0.00006062f, 0.01808840f, -0.04180214f, -0.01695695f, 
    -0.00470506f, 0.09727761f, 0.34654149f, -0.28185603f, -0.07931082f, -0.09764996f, 0.01593618f, -0.02152423f, 
    -0.00353552f, 0.04381318f, 0.05633478f, -0.08935476f, 0.16614719f, -0.04985496f, -0.20108609f, 0.05355019f, 
    -0.08860660f, 0.05285488f, 0.31372213f, 0.02720978f, 0.06508324f, -0.22193550f, -0.15317225f, 0.01311339f, 
    0.28423601f, 0.12930052f, 0.01490076f, -0.06715565f, 0.00600362f, -0.01664663f, -0.13603139f, 0.07291985f, 
    0.01699519f, 0.01138224f, 0.03846076f, -0.09635106f, -0.07117271f, -0.11253479f, 0.01948400f, 0.04581389f, 
    -0.07148404f, -0.10496995f, -0.04035452f, 0.39946398f, -0.31895271f, -0.15293746f, 0.24275717f, -0.07086558f, 
    -0.08413687f, 0.32097858f, 0.03532679f, -0.27304947f, -0.01634903f, -0.06572370f, 0.05479965f, -0.08738113f, 
    0.11836569f, -0.07016725f, -0.16130021f, 0.23902535f, -0.05701756f, 0.05472355f, 0.07096383f, -0.06401935f, 
    0.03360334f, -0.06459986f, 0.08642276f, 0.13683312f, 0.04592719f, 0.04355262f, 0.10014307f, 0.11710685f, 
    0.13452968f, 0.26800892f, -0.34770158f, 0.11228384f, -0.06768840f, 0.11690183f, 0.05008022f, -0.36101767f, 
    -0.00444598f, 0.05724756f, 0.11921065f, -0.05697733f, 0.25128153f, 0.02407679f, 0.16121724f, -0.13789041f, 
    -0.03084513f, -0.03096165f, -0.08918951f, 0.00052370f, -0.01656897f, -0.00210220f, -0.00966604f, 0.16711709f, 
    0.18075402f, 0.25479221f, 0.24563454f, -0.13128851f, 0.14968237f, -0.01308909f, -0.11799877f, -0.02020475f, 
    0.14700173f, 0.02494501f, 0.08771705f, 0.09757742f, -0.11618596f, 0.00798706f, 0.03535397f, -0.12456109f, 
    -0.30934709f, -0.07191737f, 0.23357913f, 0.17513001f, 0.03243976f, 0.25684240f, 0.02815439f, -0.08451907f, 
    0.01593866f, 0.02318068f, 0.00069348f, -0.05843964f, -0.02958232f, -0.07172657f, 0.05258229f, -0.01492597f, 
    0.00824122f, -0.05541213f, -0.00515149f, -0.01756299f, 0.02721386f, -0.06262513f, -0.02830221f, -0.01269688f, 
    -0.04605176f, 0.04331739f, 0.01919449f, 0.06405880f, 0.02481356f, -0.03575259f, 0.06507938f, -0.04282589f, 
    -0.04493747f, -0.00127286f, 0.00238573f, 0.05785513f, -0.05545199f, -0.02150195f, 0.04909375f, -0.04843110f, 
    0.05159611f, 0.03427925f, -0.05288625f, 0.05381509f, -0.06870250f, -0.06638938f, 0.01969618f, 0.01676314f, 
    0.02409784f, -0.07617835f, -0.00701916f, -0.03958120f, 0.05260611f, -0.00826520f, 0.01821198f, 0.00155325f, 
    0.00909147f, -0.06664207f, -0.00719508f, -0.03267460f, -0.06801625f, 0.05949609f, 0.00424829f, -0.03471525f, 
    0.00271761f, 0.03812839f, 0.05195097f, 0.03830571f, 0.04168384f, -0.05689488f, -0.02397761f, -0.00219277f, 
    -0.04308106f, -0.07420792f, 0.04138712f, 0.00280279f, -0.06268101f, -0.07009958f, 0.05080148f, -0.02897875f, 
    -0.04041449f, -0.02505817f, -0.00307641f, -0.03829199f, -0.06301972f, 0.03801946f, -0.01083813f, 0.05235485f, 
    0.03051947f, 0.00229548f, -0.02764313f, 0.01556348f, -0.07661857f, 0.05546013f, 0.01789144f, 0.00652108f, 
    0.02290116f, 0.03158553f, -0.03972363f, -0.04372685f, 0.03893952f, -0.05969914f, -0.02443362f, -0.01596193f, 
    -0.02732307f, 0.03245428f, -0.05485496f, -0.07194562f, 0.01868943f, -0.03434517f, -0.03074634f, 0.03724945f, 
    0.05431318f, 0.02038565f, 0.00568628f, 0.05626063f, -0.02553423f, 0.01792283f, -0.00368187f, -0.07240662f, 
    -0.07740214f, -0.00139873f, -0.05745626f, -0.01611094f, 0.02669788f, 0.02096844f, -0.07580420f, -0.06909696f, 
    0.02353323f, -0.06923445f, -0.07256308f, -0.01544362f, -0.02876443f, -0.06606907f, 0.01141457f, -0.03302090f, 
    0.01773391f, 0.03957109f, 0.01687231f, 0.00109813f, -0.06610014f, 0.03723563f, -0.00231307f, -0.07127965f, 
    -0.04534004f, -0.07758247f, 0.00721078f, -0.00648265f, 0.01236002f, -0.06923360f, -0.06218183f, -0.00682681f, 
    0.01289236f, 0.02212362f, -0.03101986f, 0.01845275f, -0.00312048f, 0.03397188f, 0.02495543f, 0.02945229f, 
    0.05338654f, 0.00821555f, -0.01040784f, -0.07213365f, 0.05530718f, -0.04537558f, 0.01256045f, -0.03462956f, 
    -0.03239146f, -0.06741414f, 0.05002862f, 0.02818141f, -0.07276390f, -0.02314908f, 0.06040218f, -0.02072253f, 
    -0.05663729f, 0.02195487f, -0.07744480f, 0.05692238f, 0.02179674f, 0.03519519f, -0.03646702f, 0.02491338f, 
    -0.07209345f, -0.07015775f, 0.02561833f, -0.03986895f, -0.02271939f, 0.01419401f, -0.02507227f, 0.01932337f, 
    0.04852888f, -0.07585602f, 0.04961124f, 0.02687365f, 0.03222472f, 0.01509701f, -0.01162843f, -0.03219609f, 
    -0.30058566f, 0.10139579f, 0.25132093f, -0.17239125f, 0.09899225f, 0.06772858f, -0.03187154f, 0.18552244f, 
    -0.00205690f, 0.06146964f, 0.00651310f, -0.05320524f, 0.07568273f, -0.32729316f, 0.15592314f, -0.42735583f, 
    -0.01733319f, 0.06977412f, 0.04368759f, 0.01537119f, 0.10890913f, 0.13202398f, 0.07940847f, -0.10854942f, 
    0.05387545f, 0.02881834f, 0.25259432f, 0.28126451f, -0.07998134f, -0.27701113f, 0.03712860f, -0.18923362f, 
    0.15536566f, -0.00487661f, -0.05494526f, 0.00307316f, 0.23307207f, -0.38732755f, 0.24205339f, -0.16017044f, 
    -0.04531964f, 0.03996998f, -0.09168138f, -0.15215506f, -0.00591703f, -0.07009348f, -0.00790067f, -0.11842997f, 
    -0.07575408f, 0.12148186f, 0.05641164f, -0.31731549f, 0.26082721f, -0.11004441f, 0.12169658f, 0.30010179f, 
    0.08146266f, -0.16049194f, -0.16263333f, 0.09532925f, -0.02987625f, -0.04826728f, 0.12597188f, 0.05426243f, 
    0.16355748f, 0.16864854f, -0.03321726f, 0.05507871f, 0.00927143f, 0.07246822f, 0.04191740f, 0.10351001f, 
    0.08947745f, 0.18027671f, 0.45536366f, -0.08373515f, 0.17209142f, 0.11284667f, 0.14380227f, 0.22969432f, 
    0.21193823f, -0.07981966f, -0.20091063f, -0.28302881f, -0.56544006f, 0.05411647f, 0.05857359f, -0.10280806f, 
    -0.20666075f, -0.10721033f, -0.16126724f, 0.01077748f, 0.31376138f, -0.00837967f, 0.11025425f, 0.12037396f, 
    -0.18077952f, 0.27508184f, 0.11186258f, 0.14270790f, -0.04724753f, -0.07274435f, -0.30666977f, -0.06852972f, 
    -0.07579669f, -0.22152106f, -0.02516732f, -0.20931542f, -0.16591640f, 0.02581332f, 0.02812807f, 0.04849729f, 
    0.10797114f, 0.06756377f, -0.03781939f, -0.03126350f, -0.18782170f, -0.06242769f, -0.07321430f, 0.05987982f, 
    0.36023027f, 0.37436143f, 0.31207654f, 0.27393645f, -0.11105153f, -0.38827196f, 0.14610332f, -0.05007523f, 
    0.02178189f, -0.03041676f, 0.11695436f, 0.02825653f, 0.19974771f, 0.22242244f, 0.03975624f, 0.25180918f, 
    -0.18570185f, -0.01359953f, -0.15234672f, 0.01058915f, 0.22358103f, -0.04443973f, -0.10013837f, 0.32419387f, 
    0.38333029f, -0.04330934f, 0.02789069f, 0.07716184f, 0.09719820f, -0.13026667f, 0.00024582f, -0.13786210f, 
    -0.08706500f, 0.02188404f, 0.00614566f, -0.26290619f, 0.15732338f, 0.29326025f, 0.01247030f, 0.26150665f, 
    -0.16237751f, -0.03838455f, -0.17234473f, -0.13014980f, 0.08128134f, -0.18022671f, 0.02243358f, -0.11879349f, 
    -0.08927825f, 0.32321200f, 0.25736627f, -0.16343282f, -0.10583163f, 0.04001391f, -0.29933944f, -0.00704270f, 
    0.11108537f, -0.02622979f, -0.01785213f, 0.07295556f, 0.18252577f, -0.25814432f, 0.17301862f, -0.24493475f, 
    -0.21428581f, 0.22097412f, 0.03951242f, 0.11382816f, 0.27258700f, 0.11284346f, 0.33311474f, 0.12563907f, 
    -0.10485274f, 0.09819601f, -0.16592823f, -0.19432753f, -0.04485178f, -0.10020071f, 0.08480362f, 0.02771211f, 
    0.04345783f, 0.07254672f, -0.10514207f, -0.27044678f, 0.69370729f, 0.07978847f, 0.05130794f, -0.30713490f, 
    -0.08051857f, -0.02947123f, -0.14082989f, -0.11348622f, 0.00595051f, 0.15270436f, 0.02643497f, 0.01279713f, 
    -0.61385125f, 0.10295237f, -0.23988390f, 0.01223601f, -0.14878553f, 0.09471415f, 0.11960019f, 0.00037393f, 
    0.03039988f, 0.04057104f, -0.09248925f, 0.03205465f, 0.24454150f, 0.05562272f, 0.20523304f, 0.22523871f, 
    -0.11115066f, -0.00897659f, -0.07616452f, 0.08299395f, 0.07677595f, 0.10061721f, -0.03198165f, -0.19075455f, 
    -0.05794768f, -0.29807803f, 0.17149675f, 0.00962831f, 0.15298910f, -0.06191717f, 0.10745516f, -0.01852146f, 
    -0.00318295f, -0.05135709f, -0.02947245f, -0.03604137f, 0.19411308f, -0.05095536f, -0.25542000f, -0.25446343f, 
    0.15907504f, 0.12348410f, 0.17786571f, 0.09060677f, 0.03232540f, -0.01922623f, 0.08259544f, 0.14176653f, 
    0.19351281f, 0.05852581f, 0.22996165f, -0.03794850f, -0.10627276f, 0.00694995f, -0.02092706f, 0.13176204f, 
    -0.02321674f, -0.05691563f, -0.00156337f, -0.07991587f, 0.25512117f, -0.13138624f, -0.24163204f, -0.17352851f, 
    -0.16811137f, -0.02775148f, 0.20591989f, -0.05539827f, 0.05893595f, 0.00051817f, -0.04168828f, 0.08376911f, 
    0.14726441f, -0.01477435f, -0.19154184f, -0.10306615f, -0.02043863f, -0.07739154f, -0.02417583f, 0.08636775f, 
    -0.03006305f, 0.05092517f, 0.06191650f, 0.10240330f, -0.16120254f, 0.03669615f, -0.14476708f, 0.08504024f, 
    0.09801707f, 0.07611977f, 0.06261399f, -0.12385983f, 0.13840875f, 0.01154501f, -0.00960557f, 0.01199241f, 
    -0.18839641f, -0.15933858f, -0.12238895f, -0.03755341f, 0.00443220f, -0.04799417f, 0.17198971f, -0.01264663f, 
    0.06988975f, 0.08208502f, -0.12304562f, 0.14015405f, -0.25024411f, 0.08713324f, 0.26349771f, 0.11368438f, 
    -0.18662402f, 0.04448231f, 0.01950984f, 0.00888996f, 0.14835870f, 0.04847131f, -0.12922648f, 0.03871640f, 
    0.20533517f, -0.00591378f, 0.07566354f, -0.15789935f, 0.06699511f, -0.05975436f, -0.22121641f, -0.14154427f, 
    0.10974037f, -0.07523658f, 0.02756518f, 0.15441827f, -0.06138208f, 0.00668105f, -0.08332323f, 0.18737380f, 
    0.00746753f, 0.09428333f, 0.07562375f, -0.08290988f, 0.06862964f, 0.09258186f, -0.26192254f, 0.02214191f, 
    0.63529694f, -0.00832786f, 0.00048362f, -0.30191621f, -0.09114877f, -0.01828431f, 0.05273728f, -0.00284975f, 
    0.14575206f, 0.04106319f, 0.01423782f, 0.09475990f, -0.01681884f, 0.07230779f, 0.20932224f, 0.10344421f, 
    -0.15753470f, -0.01051319f, 0.21389264f, 0.12265310f, -0.01272461f, 0.03567448f, 0.18338606f, -0.08178165f, 
    0.13711484f, -0.03576351f, -0.08868166f, 0.50287199f, 0.08755700f, 0.09196267f, -0.00326513f, -0.15478361f, 
    0.23724534f, -0.06801138f, 0.05531031f, 0.15226193f, -0.20255472f, 0.73610383f, 0.50508916f, 0.29125795f, 
    -0.13683595f, -0.23464938f, -0.00708261f, 0.07550192f, -0.15808749f, -0.01259245f, -0.08193953f, 0.12578759f, 
    0.24351911f, -0.10784052f, -0.30886954f, 0.17279024f, 0.01178702f, 0.10513064f, -0.03659976f, 0.09775905f, 
    -0.22220612f, -0.14428656f, -0.02233731f, -0.26520875f, 0.07767197f, 0.16621974f, 0.23730010f, 0.18226619f, 
    0.17072012f, -0.12681954f, -0.06879061f, 0.00898254f, -0.00615151f, 0.23389934f, 0.20771411f, 0.20624568f, 
    -0.24310640f, -0.10475148f, -0.11378958f, 0.12495593f, -0.00652652f, 0.11063685f, -0.22606099f, 0.07521144f, 
    0.05925585f, 0.02852937f, -0.01374338f, 0.07475339f, -0.29846850f, -0.04994879f, 0.19065653f, 0.29661101f, 
    -0.14351420f, -0.17646563f, 0.01164617f, 0.14246081f, -0.11501508f, -0.05944307f, -0.32837206f, -0.25592682f, 
    -0.42949656f, -0.26563430f, -0.07451627f, 0.25696135f, -0.03118815f, 0.07032757f, -0.03714455f, -0.08329155f, 
    0.11241019f, 0.23749535f, 0.17168356f, 0.18568672f, 0.10267404f, 0.38421795f, 0.33409959f, -0.00819011f, 
    0.10529870f, 0.00479954f, -0.08560317f, 0.06240199f, -0.09322361f, 0.06521545f, 0.04157278f, -0.15023391f, 
    0.01452278f, -0.12705263f, -0.07274792f, -0.23618446f, -0.18034478f, -0.08994445f, 0.04054577f, -0.01637087f, 
    0.28557199f, 0.12646873f, 0.15159656f, 0.13373224f, 0.34925613f, -0.09674397f, 0.06435834f, -0.13459493f, 
    -0.02081909f, -0.05146755f, 0.13021488f, 0.11869881f, 0.31475541f, 0.10868436f, 0.19225965f, 0.08378506f, 
    0.16153218f, -0.05355573f, 0.34988937f, -0.15587136f, -0.04979926f, 0.11183250f, -0.22967215f, -0.14788033f, 
    -0.22708686f, -0.06162411f, 0.05007589f, -0.10836150f, 0.22668739f, 0.09955923f, 0.10886779f, -0.21056840f, 
    0.18299937f, -0.11498974f, -0.21938042f, -0.11728520f, -0.05206127f, 0.15617044f, 0.20953183f, -0.04894968f, 
    -0.50257313f, 0.29772228f, 0.01829735f, 0.01600009f, -0.02418958f, 0.17960238f, 0.19051825f, 0.07877724f, 
    0.13943681f, 0.24458882f, 0.30132166f, 0.24481769f, -0.03418579f, 0.03794548f, 0.05237461f, -0.11984035f, 
    0.04604878f, -0.08798433f, -0.08864119f, -0.04878096f, 0.07505765f, 0.24958034f, 0.23605001f, 0.26066718f, 
    -0.20713960f, -0.15416090f, 0.03555220f, 0.08865754f, -0.02688523f, 0.03894934f, -0.04238831f, 0.02572066f, 
    -0.10659932f, 0.08499122f, 0.06750078f, -0.12714283f, 0.04846392f, 0.07491888f, -0.21673124f, 0.18227196f, 
    0.17135300f, 0.06518108f, -0.23521690f, 0.05582262f, -0.17030600f, -0.06571317f, -0.25110060f, -0.14499465f, 
    0.28841767f, 0.14418921f, -0.00562720f, -0.08621681f, 0.05083461f, 0.00505390f, 0.05909499f, 0.03610272f, 
    -0.13450985f, 0.03381728f, 0.12854055f, 0.20911098f, -0.19248034f, 0.08032169f, 0.01322759f, 0.31837383f, 
    0.04017529f, 0.10130654f, 0.02444582f, 0.03842720f, 0.05291892f, 0.06155439f, 0.11574537f, 0.08826271f, 
    0.51804483f, 0.16319120f, 0.12871143f, -0.07846034f, 0.11757589f, -0.05665362f, -0.15946233f, -0.09567584f, 
    -0.09968256f, -0.01690637f, 0.12807232f, 0.03463579f, -0.28049153f, 0.17948189f, -0.16260274f, 0.00780734f, 
    0.20890667f, 0.02977283f, 0.03383904f, -0.15980014f, -0.14707454f, 0.08358000f, -0.00403471f, -0.00948327f, 
    0.20676099f, 0.33333841f, -0.23486403f, 0.06415024f, 0.05644877f, 0.17147322f, -0.08491829f, 0.03522496f, 
    -0.07097372f, -0.08857618f, 0.04642712f, -0.12028635f, -0.03260946f, 0.07500286f, 0.03285241f, 0.30722719f, 
    -0.17851306f, -0.07020702f, 0.13643996f, -0.04342235f, -0.14925669f, -0.02961399f, -0.12861736f, -0.01729545f, 
    0.04649825f, -0.05126162f, -0.45375913f, 0.13941468f, -0.00820541f, 0.07941771f, 0.04792689f, -0.17094870f, 
    0.00449141f, 0.01020055f, -0.06790966f, 0.08255087f, -0.08447389f, -0.05427358f, 0.13752531f, 0.21702510f, 
    0.21319234f, 0.18347324f, -0.09198526f, 0.02852309f, -0.10426696f, -0.03364101f, 0.04458963f, 0.00068114f, 
    -0.28350693f, 0.10882262f, -0.01701578f, 0.01516228f, -0.15266129f, 0.02603627f, 0.05840499f, -0.16367757f, 
    -0.17195433f, 0.11093903f, -0.19239576f, -0.12740569f, 0.14367726f, 0.10146285f, 0.13005820f, -0.08207017f, 
    -0.11377301f, 0.14877629f, -0.01305386f, -0.09290043f, 0.05059852f, 0.08231815f, -0.01434638f, -0.09460431f, 
    0.30591151f, -0.08502986f, 0.15765300f, 0.41024429f, -0.15693477f, 0.08949271f, 0.00870596f, -0.09639832f, 
    -0.06763334f, -0.06432950f, 0.05674814f, 0.17016126f, 0.20517907f, 0.14151785f, 0.20858543f, 0.10880727f, 
    0.07823409f, -0.02217887f, -0.02944168f, -0.08896699f, -0.17703119f, 0.03530038f, -0.07315204f, 0.15126000f, 
    -0.01956070f, 0.09627172f, 0.03717731f, 0.10767205f, 0.06536108f, 0.15577084f, -0.03109501f, 0.15114349f, 
    0.05816973f, 0.01568875f, -0.07636323f, -0.08477829f, -0.02845286f, 0.11384145f, 0.12977844f, -0.06482830f, 
    0.04747430f, -0.14916374f, -0.07942446f, -0.04496329f, 0.02779338f, -0.01121831f, 0.23697348f, -0.06752659f, 
    -0.39644295f, -0.08174373f, -0.05763201f, 0.50571436f, -0.09028953f, 0.06200146f, 0.03247520f, -0.12932506f, 
    -0.24488807f, 0.03136877f, -0.11087836f, -0.13964903f, -0.20356335f, 0.31496081f, -0.00583031f, 0.00753323f, 
    0.03469247f, 0.04148096f, -0.11903945f, -0.00742829f, 0.10152201f, 0.11194842f, -0.03002522f, 0.34842882f, 
    -0.07827713f, 0.02169580f, -0.06791326f, -0.07180531f, 0.01909433f, 0.02733417f, -0.00852687f, 0.02649952f, 
    0.02937672f, -0.06891165f, -0.06173986f, -0.05712884f, -0.02854380f, -0.07119326f, -0.00922351f, 0.04820197f, 
    0.03748487f, 0.04630769f, 0.04155084f, -0.04028907f, -0.02121500f, 0.01344092f, -0.01680608f, -0.02057707f, 
    -0.04897160f, 0.00443039f, 0.01018786f, 0.02783687f, 0.02831242f, 0.00460348f, 0.03678347f, -0.04902154f, 
    0.04842231f, -0.04964578f, -0.04452385f, 0.04980356f, -0.00166745f, 0.00689310f, -0.03862031f, 0.00531593f, 
    0.06089992f, -0.02557930f, -0.03588936f, -0.05894698f, -0.06497547f, -0.04436162f, 0.00539991f, 0.06018006f, 
    0.02300452f, -0.04406494f, 0.05498382f, 0.05943646f, 0.03908214f, -0.02389931f, 0.01965155f, -0.02244621f, 
    0.01000359f, 0.05247978f, 0.05360093f, 0.06140257f, -0.05987661f, -0.04743841f, -0.01544565f, -0.01032349f, 
    0.03680605f, 0.03131992f, -0.06500890f, 0.00104495f, 0.03935327f, -0.02592178f, -0.03513760f, -0.00255457f, 
    0.02535769f, 0.01931610f, -0.00222700f, 0.02618063f, -0.00582037f, -0.00838633f, -0.02754365f, 0.00955929f, 
    -0.02626803f, 0.02834889f, -0.02854812f, 0.05253860f, -0.02426080f, 0.05449256f, -0.02447795f, -0.02091248f, 
    -0.01783848f, 0.01040838f, -0.07942852f, -0.03092119f, -0.01213922f, 0.00338197f, -0.00346254f, -0.00549208f, 
    -0.02649618f, -0.03130341f, -0.02937935f, -0.05945146f, -0.04878465f, 0.03035395f, -0.07328075f, -0.03871204f, 
    0.05706326f, 0.00576591f, -0.02146233f, -0.06627604f, 0.00113811f, -0.05513834f, 0.02900656f, -0.00771189f, 
    0.03882298f, 0.05631898f, 0.04974150f, -0.05445958f, 0.04091418f, 0.02281772f, 0.03063003f, -0.05833255f, 
    -0.06356483f, -0.01679020f, -0.08047149f, 0.06223895f, -0.02435762f, -0.02419097f, -0.06894670f, -0.03514091f, 
    0.00761026f, 0.05740605f, -0.05801517f, -0.05677665f, 0.01579138f, -0.03145371f, 0.01470983f, 0.00259519f, 
    -0.05852661f, -0.05728060f, -0.08016780f, -0.04459411f, -0.06800169f, -0.01696230f, -0.02810375f, 0.02759309f, 
    -0.02363794f, -0.03961626f, -0.06448964f, -0.05923937f, 0.03126919f, -0.07338175f, 0.03705434f, -0.07655022f, 
    0.05482741f, 0.03232219f, -0.05519633f, -0.04136151f, -0.01247813f, -0.00583313f, -0.02114889f, 0.01567732f, 
    -0.07991266f, -0.03463628f, -0.00958098f, -0.02476419f, -0.01245447f, -0.04901319f, -0.06194995f, -0.07514324f, 
    0.04496469f, 0.05245567f, -0.01328156f, 0.02693807f, -0.06993827f, 0.04892676f, -0.08008078f, 0.03391732f, 
    -0.03619433f, -0.00535425f, 0.02360683f, 0.00927456f, 0.03162314f, -0.02973114f, -0.05857432f, -0.06441910f, 
    -0.05585500f, 0.03718814f, 0.06027455f, 0.05778244f, -0.07001241f, 0.01162152f, 0.02370455f, 0.02477019f, 
    0.12921292f, -0.01677218f, 0.22461395f, -0.16992262f, 0.07353504f, 0.05373253f, 0.05425596f, 0.22676602f, 
    0.05225874f, -0.01826864f, 0.02162372f, -0.16321982f, 0.16987029f, -0.34944147f, -0.39078632f, -0.21776879f, 
    0.07351052f, 0.16742355f, 0.06788028f, -0.07425369f, 0.17032820f, 0.10332488f, 0.06531827f, -0.04676111f, 
    -0.25380293f, 0.09453611f, 0.42304292f, 0.01989287f, 0.13670497f, -0.02608426f, -0.04096088f, 0.06610225f, 
    -0.02576928f, -0.02255755f, -0.08130500f, 0.15297838f, 0.01437575f, -0.21401811f, 0.21631511f, -0.21097022f, 
    -0.10922850f, 0.08760034f, 0.08794118f, 0.20177427f, 0.27202207f, -0.03670801f, -0.00579087f, 0.07548851f, 
    0.26310602f, -0.06485549f, 0.22756371f, -0.19202630f, -0.03785643f, -0.04353645f, 0.39651164f, 0.01526117f, 
    -0.09183104f, -0.00051175f, 0.00451484f, 0.07742178f, 0.30428544f, 0.15480782f, -0.03580065f, -0.34128827f, 
    0.29516330f, 0.05408407f, 0.04913164f, 0.11199680f, -0.04828248f, 0.01547309f, 0.09742051f, 0.04501879f, 
    0.21708547f, 0.12746754f, 0.21571589f, -0.16634431f, 0.02297658f, -0.04323074f, 0.10081353f, 0.00058870f, 
    -0.11024091f, -0.21263658f, 0.07641803f, -0.04891940f, 0.19533619f, 0.01212571f, -0.38855276f, -0.01776042f, 
    -0.08451848f, 0.09175962f, 0.05381896f, 0.04752368f, 0.05440761f, 0.06927443f, -0.12136440f, -0.14426810f, 
    0.11825749f, -0.14022295f, -0.11152142f, 0.06532625f, 0.05614671f, 0.09579138f, 0.02545017f, 0.11221968f, 
    -0.01571143f, 0.05939998f, 0.00287927f, -0.01682574f, -0.20364329f, 0.01638110f, -0.06528702f, 0.11058423f, 
    0.09808606f, -0.02981076f, -0.00820323f, 0.19137800f, -0.15614519f, 0.02640258f, 0.22731100f, -0.12993014f, 
    -0.28175274f, 0.13430953f, -0.38186258f, -0.29322994f, 0.06538787f, 0.05553364f, 0.00316130f, 0.06306507f, 
    0.03778599f, -0.08239798f, -0.05152860f, 0.05195105f, -0.44372776f, -0.01539252f, -0.24900405f, 0.08165355f, 
    -0.08053367f, -0.08299983f, 0.06897097f, 0.13911758f, 0.18910050f, 0.06194356f, 0.15695614f, 0.06651694f, 
    0.22560622f, -0.38551208f, -0.17566104f, -0.07174934f, -0.10357637f, 0.01024869f, -0.01477790f, -0.18191917f, 
    0.04713890f, 0.00971566f, 0.11357670f, -0.00046278f, 0.07627764f, -0.17326909f, 0.05096759f, 0.20177868f, 
    0.06215306f, -0.00526856f, -0.03400447f, 0.03227551f, 0.00059683f, 0.10298305f, -0.04221419f, 0.15308471f, 
    0.47961366f, 0.05482919f, -0.21083306f, -0.06543572f, 0.09806017f, 0.07974078f, -0.04301660f, -0.00762951f, 
    0.08808458f, -0.01467064f, 0.03725855f, 0.08783428f, -0.06971674f, -0.10176978f, 0.12363513f, 0.00955294f, 
    -0.04488777f, 0.02614197f, 0.05414693f, 0.09466806f, 0.15113272f, -0.08219186f, -0.00398510f, -0.21917200f, 
    0.19337867f, 0.19300836f, 0.44031230f, 0.59269756f, 0.01261804f, 0.14228521f, 0.11276641f, 0.22861208f, 
    -0.11247242f, -0.05469659f, -0.14752077f, 0.05448388f, -0.26692867f, -0.29082194f, -0.41388762f, -0.03463116f, 
    0.04606541f, 0.11900757f, -0.06730846f, 0.21873316f, 0.08038127f, -0.17772402f, 0.11120620f, -0.20869341f, 
    0.40655166f, 0.05122779f, 0.48303410f, 0.14408970f, 0.11291651f, -0.03934624f, -0.10672099f, -0.10668553f, 
    0.02827458f, 0.06707188f, 0.04152140f, 0.09582087f, -0.28301173f, 0.11025237f, -0.27793789f, -0.27145746f, 
    -0.06711253f, 0.00213859f, 0.06210113f, 0.01940279f, 0.03852384f, -0.00758047f, -0.16280116f, 0.05978009f, 
    0.24777341f, 0.30068764f, 0.19620192f, 0.37806103f, -0.07305051f, 0.40478414f, -0.08435751f, 0.19380791f, 
    -0.04329213f, 0.04622830f, 0.00538846f, 0.06610446f, 0.25729662f, 0.20316033f, 0.50468981f, 0.41138276f, 
    0.33478475f, 0.10587166f, 0.02253390f, 0.19751869f, 0.02631127f, -0.00781881f, 0.08557062f, -0.08178591f, 
    -0.00515598f, 0.05605727f, -0.09929380f, -0.07443502f, 0.08939174f, 0.04500724f, 0.17628624f, 0.27724633f, 
    0.14760482f, 0.01963426f, 0.05456924f, 0.02410316f, -0.22216624f, 0.09990157f, -0.21050021f, 0.20893678f, 
    -0.05808613f, 0.36965522f, -0.04678972f, 0.07543815f, 0.01087452f, 0.18931484f, -0.05925094f, -0.08421742f, 
    0.12397150f, -0.10700408f, -0.05444763f, 0.14305450f, 0.10152669f, 0.01799179f, -0.01251232f, -0.07405745f, 
    0.07425542f, 0.18587740f, 0.01643672f, -0.14686485f, 0.00078007f, -0.00592192f, 0.00903224f, -0.13634290f, 
    -0.08079317f, -0.12441055f, -0.02869355f, -0.08015092f, -0.19025470f, -0.04960174f, -0.07007530f, -0.28987002f, 
    -0.04177774f, 0.25348401f, -0.39040187f, 0.13696328f, 0.00019936f, 0.17705701f, -0.06273577f, 0.02370218f, 
    0.07136528f, -0.05621156f, 0.04605359f, 0.04922083f, 0.29131332f, -0.05075578f, -0.05671027f, -0.35185462f, 
    0.02750514f, 0.03847280f, 0.09794325f, -0.08383548f, 0.01485252f, -0.23493731f, 0.13221994f, -0.02968653f, 
    0.05190590f, -0.34276611f, -0.23824826f, -0.11951327f, 0.08388208f, 0.06004315f, 0.00402512f, 0.33197752f, 
    -0.02918734f, -0.02953697f, -0.32014030f, -0.21478871f, -0.08909046f, -0.05949338f, -0.05759830f, -0.04383489f, 
    -0.05298851f, 0.02978756f, -0.11057841f, -0.01414900f, 0.01086159f, 0.29578632f, 0.04871415f, -0.01808471f, 
    0.25505337f, -0.02375388f, -0.45142558f, 0.53963780f, 0.14544019f, -0.04771754f, -0.08085162f, 0.00343213f, 
    0.05671122f, 0.08882587f, -0.04164250f, 0.11994956f, 0.09391750f, 0.04776386f, -0.00076078f, -0.03330166f, 
    0.16439436f, -0.06865080f, -0.12943670f, -0.17801949f, 0.16642398f, 0.17415288f, -0.04479334f, -0.05159300f, 
    -0.28404650f, -0.15634796f, 0.14120235f, 0.33641770f, 0.05765088f, 0.23510778f, -0.08604511f, -0.13542503f, 
    -0.05859773f, -0.00919024f, -0.02682969f, 0.11668748f, -0.56588989f, 0.15194778f, 0.04587020f, 0.46425036f, 
    -0.07440500f, -0.07813419f, 0.02934358f, 0.14320366f, -0.11407832f, -0.05520502f, 0.08819017f, 0.01270498f, 
    0.12823923f, -0.05623899f, 0.11500813f, -0.06236776f, -0.07392310f, 0.10215528f, -0.04109403f, 0.05358664f, 
    -0.02664927f, 0.03092596f, -0.00478352f, -0.08681592f, -0.09810752f, 0.08270158f, -0.17272979f, 0.01343395f, 
    0.07394251f, -0.00684195f, -0.08266339f, -0.12181257f, 0.04226255f, -0.02386930f, 0.05128073f, 0.10271968f, 
    -0.03078435f, 0.12551300f, -0.23716053f, 0.05567148f, 0.12734984f, 0.16771828f, -0.05848757f, 0.01070575f, 
    -0.03651386f, 0.02955780f, -0.05940984f, -0.09237230f, -0.29710972f, 0.01708573f, 0.21106064f, 0.11494072f, 
    -0.13766323f, -0.07163247f, -0.07839015f, 0.01987131f, -0.04315859f, -0.10642876f, -0.13487162f, -0.09870369f, 
    -0.06493116f, -0.10477701f, -0.05425794f, 0.10794048f, 0.08102123f, -0.05107284f, 0.02279010f, 0.01061792f, 
    -0.05401850f, -0.01036641f, -0.03715659f, 0.08664773f, -0.12280960f, 0.06632580f, 0.34051713f, 0.23295476f, 
    -0.06988038f, 0.01670804f, -0.07019471f, 0.00670612f, -0.00336584f, 0.05217760f, 0.11899794f, 0.10636968f, 
    0.00186506f, 0.09006737f, 0.17979845f, -0.04187384f, 0.01941803f, -0.07793206f, -0.08389252f, 0.00926881f, 
    0.03046605f, -0.02158614f, 0.05916048f, -0.02451965f, 0.11240844f, 0.09458062f, 0.06332876f, -0.11317988f, 
    -0.13324019f, -0.03186125f, 0.04140288f, 0.08908014f, -0.08960057f, -0.14732969f, 0.13314267f, 0.24279621f, 
    0.47944671f, 0.12223077f, 0.25098771f, 0.34036818f, -0.21116166f, 0.16206022f, -0.04105040f, -0.01101570f, 
    -0.03247924f, -0.09944450f, 0.06465048f, -0.00085452f, 0.40366504f, 0.01251540f, 0.10731803f, -0.29182577f, 
    0.17111072f, 0.07074778f, 0.03984354f, 0.02577795f, -0.17311887f, -0.12880628f, 0.11428208f, 0.00637577f, 
    -0.31931230f, 0.25379634f, -0.17941637f, 0.26558557f, -0.06586047f, 0.02794221f, 0.00691618f, 0.24651659f, 
    -0.13625582f, 0.16513057f, 0.09074008f, -0.05540449f, 0.13054040f, 0.01113120f, 0.20904697f, -0.21985377f, 
    -0.02480147f, 0.03313578f, -0.00526875f, -0.06859674f, -0.12468358f, -0.13276595f, 0.01623162f, 0.01031921f, 
    -0.55566323f, 0.12927084f, 0.23585612f, 0.02107789f, 0.01191735f, 0.02604616f, -0.06592114f, -0.01152544f, 
    0.05406591f, 0.03713204f, -0.07077584f, 0.08949398f, 0.14290382f, 0.12905250f, -0.08451688f, -0.15339795f, 
    0.03822187f, 0.24044324f, -0.00617305f, -0.14032654f, -0.05252489f, 0.17861529f, 0.06912566f, 0.11148795f, 
    -0.14030243f, 0.07309679f, -0.07851145f, 0.30281898f, 0.07847717f, 0.02994779f, 0.07551434f, -0.09654783f, 
    0.09334540f, -0.04943291f, 0.01085630f, 0.13946347f, -0.11096065f, 0.35112336f, 0.52897578f, 0.20593512f, 
    -0.07359437f, -0.11650580f, 0.02155707f, 0.08147044f, 0.03902741f, -0.17130053f, -0.05395113f, 0.10281727f, 
    0.53159142f, 0.01729061f, -0.43608677f, 0.08829577f, -0.08489704f, -0.03056544f, 0.07390313f, 0.06767905f, 
    -0.04473808f, -0.09673762f, 0.04962812f, -0.07201001f, 0.14097129f, 0.02325132f, -0.20318136f, 0.12482716f, 
    0.00348233f, -0.12696961f, 0.06739525f, 0.03903796f, 0.01549718f, 0.12579231f, 0.17117560f, 0.02464993f, 
    -0.28680351f, -0.16963810f, 0.00877478f, 0.12533641f, -0.04901998f, 0.04178867f, -0.31293479f, -0.03861495f, 
    0.01449046f, -0.00530781f, -0.08809985f, -0.02717283f, -0.23030472f, -0.08589689f, 0.16045217f, 0.29253584f, 
    -0.16447179f, 0.01525335f, 0.04172850f, 0.13751994f, -0.02355671f, -0.03560116f, -0.19704421f, -0.19039357f, 
    -0.23253173f, -0.26271519f, -0.14381886f, 0.25319591f, -0.04224930f, 0.03159900f, 0.11836774f, -0.04706682f, 
    0.16405575f, 0.16186036f, 0.13805334f, 0.12069723f, -0.02401137f, 0.18493390f, 0.55420542f, 0.04827854f, 
    0.08106443f, 0.09336372f, -0.03342763f, 0.04884605f, -0.07091802f, -0.08901303f, 0.03398172f, 0.13313505f, 
    -0.10774152f, 0.15871984f, 0.04262785f, -0.19255675f, -0.08698068f, -0.05123751f, 0.05948077f, -0.06661800f, 
    0.10760158f, -0.02768843f, 0.05908208f, 0.09287682f, 0.37664950f, -0.12865581f, -0.02432431f, -0.04098710f, 
    -0.05124088f, 0.08772580f, 0.11023151f, -0.03416561f, 0.25641254f, -0.04582809f, -0.06797926f, 0.10374476f, 
    -0.00801084f, 0.09621342f, 0.58670366f, 0.08793306f, -0.07877880f, 0.12708279f, -0.06068891f, -0.03319636f, 
    -0.28353441f, -0.06226832f, 0.08958792f, 0.08841392f, 0.16680881f, -0.06244529f, 0.09113521f, 0.04762945f, 
    -0.03993392f, 0.00487683f, -0.15115485f, -0.17513147f, -0.05747062f, 0.13432185f, -0.00083193f, -0.03033901f, 
    -0.31272793f, 0.16766110f, 0.21429245f, -0.11197405f, 0.07478005f, 0.14230035f, 0.13601650f, 0.12862392f, 
    0.07352503f, 0.11750837f, 0.02729306f, 0.23075782f, 0.06227765f, 0.10493683f, -0.04139479f, -0.18208694f, 
    -0.02736304f, 0.00835780f, 0.00335215f, -0.15599625f, 0.10385445f, 0.16998085f, 0.13723569f, 0.08605193f, 
    -0.14013569f, -0.07537541f, 0.40982649f, 0.10412288f, -0.07738094f, -0.02726681f, -0.08723765f, -0.06573158f, 
    -0.07704184f, -0.05201514f, 0.21225998f, -0.15888685f, -0.03038781f, 0.13090093f, -0.21134679f, 0.08489875f, 
    0.06606642f, 0.13068284f, -0.05378569f, 0.10530446f, -0.03728801f, 0.00375440f, -0.09979453f, 0.09878158f, 
    0.04412567f, -0.00532243f, -0.01467345f, 0.07348850f, -0.00638007f, 0.03482466f, -0.05825891f, -0.00386993f, 
    -0.00857814f, 0.06700265f, 0.03626451f, -0.04644025f, 0.03310667f, 0.03891479f, 0.04852196f, -0.00375240f, 
    -0.03869159f, -0.06459305f, 0.00408988f, -0.05177065f, 0.04269460f, 0.02479688f, -0.02059685f, 0.00568583f, 
    0.02145100f, -0.04655706f, 0.00799840f, -0.06875900f, -0.03466695f, -0.00116050f, -0.04258099f, -0.06406570f, 
    0.05449733f, -0.03440745f, 0.03037407f, 0.00387642f, -0.07414140f, -0.06394061f, -0.04413129f, -0.01312259f, 
    0.03411437f, 0.06736298f, -0.02920738f, -0.01369227f, -0.05790310f, -0.05364072f, -0.04254856f, 0.01856341f, 
    0.00148681f, -0.00511613f, 0.02376876f, -0.01189772f, -0.01119831f, 0.04910731f, 0.04111782f, 0.04785291f, 
    0.06755032f, -0.01348346f, -0.01627855f, -0.04528486f, -0.06997415f, 0.00444276f, -0.02783185f, 0.02951884f, 
    -0.02861903f, -0.05107734f, -0.06947839f, 0.05233729f, -0.03909126f, -0.03926883f, -0.06312911f, 0.03829645f, 
    -0.04520067f, -0.02385602f, -0.02844531f, 0.07114729f, -0.02748553f, -0.01988119f, 0.02222649f, -0.04340364f, 
    -0.01684387f, 0.06107805f, -0.01872605f, -0.04487684f, 0.05067068f, -0.00553269f, 0.01850748f, -0.00998452f, 
    -0.06784249f, -0.00146505f, -0.05145502f, -0.03012209f, -0.02317913f, 0.04756045f, -0.02756339f, -0.04808775f, 
    0.02589932f, 0.02025988f, -0.01091341f, 0.06602436f, 0.00922872f, -0.02676361f, 0.03546667f, -0.00964515f, 
    0.01463669f, -0.06575618f, -0.02479012f, 0.02461384f, 0.01409378f, 0.01717198f, 0.02624395f, -0.03248398f, 
    0.02132550f, -0.06532092f, 0.00310254f, 0.05399018f, -0.01762583f, 0.00476965f, -0.02634723f, -0.03055522f, 
    0.02460861f, -0.01727311f, 0.02178131f, -0.05508081f, 0.02676859f, -0.01788765f, -0.01939533f, -0.02191705f, 
    -0.00304330f, -0.06937031f, 0.06695876f, 0.04691554f, 0.04889006f, -0.01600348f, -0.06549452f, -0.07294302f, 
    -0.07208453f, -0.04236241f, 0.05069555f, -0.00748752f, 0.01065365f, -0.04802198f, 0.00195973f, -0.06988395f, 
    -0.05202441f, 0.00653587f, 0.04808668f, -0.03689713f, 0.03549619f, 0.03120844f, -0.07068081f, -0.05613362f, 
    -0.04503853f, -0.00759163f, 0.04626467f, 0.00607471f, 0.03119160f, -0.05239748f, 0.04337844f, -0.02147298f, 
    0.06391564f, 0.01153773f, -0.06645446f, 0.03375498f, -0.05444779f, 0.00595638f, 0.03248262f, 0.05674769f, 
    -0.07463507f, 0.04551492f, 0.04764920f, -0.07558763f, -0.01400952f, -0.02586925f, 0.01797439f, 0.02755190f, 
    0.04251830f, -0.02083309f, 0.03423786f, -0.04641767f, -0.05322284f, 0.04377908f, 0.00706371f, 0.04631880f, 
    -0.02105768f, -0.00793869f, -0.00665687f, 0.06058394f, -0.02933201f, 0.04382784f, -0.01883619f, -0.01910645f, 
    -0.14795192f, 0.05874543f, -0.20857957f, 0.13514486f, -0.03172361f, -0.01591011f, 0.12740034f, -0.06308713f, 
    0.01792329f, 0.09252334f, -0.11153397f, -0.01161073f, 0.48421925f, 0.42828453f, 0.41803047f, 0.04115001f, 
    -0.14776927f, 0.00262972f, -0.10913882f, 0.00958476f, -0.01351684f, -0.02738728f, -0.09792970f, 0.06227445f, 
    -0.41737771f, -0.15305685f, -0.48700416f, 0.12199643f, -0.23272140f, 0.19612655f, 0.07255426f, 0.07174339f, 
    0.00921472f, -0.07060599f, -0.08414804f, -0.04297550f, 0.26319656f, 0.18532033f, -0.09486743f, 0.23552461f, 
    0.05803450f, -0.15686506f, -0.05285648f, 0.12440453f, 0.04103217f, 0.05847089f, 0.06769356f, -0.11561994f, 
    -0.31261462f, -0.30682990f, -0.01077094f, 0.19122827f, -0.04929500f, -0.03502836f, -0.31998831f, -0.19911604f, 
    -0.06752212f, 0.00866069f, 0.01023953f, -0.08085088f, -0.24580657f, -0.21011323f, -0.06731690f, 0.09952096f, 
    0.09623096f, 0.18560129f, 0.06541229f, 0.06335863f, 0.05074120f, -0.03014580f, 0.02859868f, 0.10954977f, 
    -0.11641995f, -0.15551950f, 0.10073593f, 0.24061099f, 0.01887387f, -0.00650341f, 0.01071156f, 0.03846968f, 
    -0.04636887f, 0.10470835f, 0.02870820f, -0.06169151f, 0.27714267f, -0.01579053f, 0.09714568f, -0.12845616f, 
    0.03145953f, -0.13354924f, 0.19813220f, -0.01783287f, 0.05685828f, 0.09690274f, -0.06918374f, 0.13866082f, 
    0.31104517f, 0.13639860f, -0.14980054f, -0.16983542f, -0.07794964f, -0.03644300f, 0.08398474f, 0.07116901f, 
    0.09179073f, -0.02363995f, 0.07291211f, 0.18193683f, 0.16863111f, -0.00391318f, -0.06136895f, 0.08915955f, 
    -0.03454353f, 0.04450731f, 0.00856003f, -0.03328801f, 0.19262964f, -0.01580295f, -0.12989794f, 0.18860735f, 
    -0.16427952f, 0.03899421f, 0.25999361f, -0.04072563f, 0.13295674f, -0.07837320f, 0.19896278f, 0.00172974f, 
    -0.06061394f, 0.07318071f, -0.07485777f, 0.05114323f, 0.30163395f, -0.09671740f, 0.37223411f, -0.04080494f, 
    -0.05751386f, -0.05989562f, 0.03779138f, -0.00879266f, 0.16986680f, 0.06723799f, -0.15958136f, -0.13439168f, 
    -0.16882317f, 0.37862232f, 0.22917596f, -0.10409751f, -0.10721757f, -0.07097378f, -0.01144656f, -0.13309164f, 
    0.16083321f, -0.09884642f, 0.00133483f, 0.27005306f, 0.00808380f, 0.29850632f, -0.01197346f, -0.10059983f, 
    0.02154593f, 0.15792111f, 0.00506646f, -0.11963829f, 0.06265374f, -0.03415075f, -0.12338290f, 0.08726525f, 
    0.48980853f, 0.18806316f, 0.29005864f, -0.24619359f, -0.01335724f, -0.02986117f, 0.09724676f, -0.00300147f, 
    0.10784001f, 0.05414899f, 0.01032005f, -0.09703624f, 0.06072691f, 0.04041219f, -0.07034785f, 0.12855378f, 
    -0.03651539f, 0.04442567f, 0.20171013f, 0.21290390f, -0.19013233f, 0.08358136f, 0.11057539f, 0.04275513f, 
    0.02065751f, 0.01697937f, 0.01195102f, -0.02485656f, -0.03379349f, -0.07225491f, -0.01933718f, -0.00552844f, 
    -0.07691613f, 0.01765142f, 0.05841740f, -0.05193608f, -0.02260453f, -0.05672711f, -0.00319134f, -0.06247425f, 
    -0.06247707f, -0.02955829f, -0.02119755f, -0.01687344f, -0.08131152f, 0.03860608f, -0.01279737f, -0.00040539f, 
    0.00890030f, -0.05630811f, 0.05010626f, 0.00016358f, -0.05505994f, 0.05853637f, -0.03672098f, -0.01329545f, 
    -0.06370466f, 0.03496841f, -0.05672373f, -0.06002041f, 0.02846353f, -0.01285020f, -0.06077979f, 0.01127288f, 
    0.02600983f, -0.05373971f, 0.03878138f, -0.01891753f, 0.05670797f, 0.02424783f, -0.05223933f, -0.07175312f, 
    0.03685359f, 0.03764299f, -0.01225030f, -0.03060566f, -0.06501770f, 0.00428465f, 0.05448706f, -0.02884169f, 
    0.01231308f, -0.06987969f, 0.04335584f, 0.04329981f, -0.04502063f, 0.02181931f, -0.06530981f, -0.02591837f, 
    0.00085651f, -0.07240871f, -0.05957597f, -0.04160177f, -0.05543064f, 0.04898823f, -0.05474813f, -0.02347645f, 
    -0.06534164f, 0.01234031f, -0.06036589f, -0.06580032f, 0.06797546f, 0.03157391f, -0.00320745f, 0.00343660f, 
    -0.01939565f, 0.02923968f, 0.00278952f, -0.06505178f, -0.00346064f, 0.03216718f, 0.00187978f, -0.01996725f, 
    0.00404796f, 0.04396962f, 0.02711661f, -0.02869147f, -0.00663475f, -0.03007511f, 0.00337573f, -0.06749866f, 
    0.05863009f, 0.05643038f, 0.03670801f, -0.06150306f, 0.05248035f, 0.01539648f, -0.01650960f, 0.04563102f, 
    0.04294363f, -0.00743508f, 0.00830858f, -0.05675969f, -0.05104871f, 0.05627477f, -0.06735716f, -0.00516918f, 
    0.00804759f, -0.02299996f, -0.04042929f, 0.05794224f, 0.05869998f, 0.01844626f, 0.01500033f, 0.03685120f, 
    -0.00509264f, 0.00756741f, -0.04847333f, -0.05453308f, -0.05372990f, -0.03555817f, 0.03824829f, 0.01324884f, 
    -0.03941087f, -0.00959318f, -0.04469221f, -0.04011638f, 0.02189242f, -0.02878928f, 0.00947992f, -0.02098064f, 
    -0.03013339f, -0.07235715f, -0.07840552f, 0.06087593f, 0.05851802f, -0.05158626f, 0.04617518f, 0.01869873f, 
    0.03089567f, -0.03103104f, -0.02874088f, -0.00366888f, 0.05266318f, -0.00542463f, 0.02315567f, -0.06894866f, 
    0.01629411f, -0.03661416f, 0.05831404f, 0.02008709f, -0.02765895f, 0.04649866f, -0.02114471f, 0.04947824f, 
    -0.06835144f, 0.06306259f, 0.00266642f, -0.06284858f, -0.05670270f, 0.00416831f, -0.04803789f, -0.04941400f, 
    -0.03939789f, -0.02507405f, -0.01457923f, -0.02980955f, -0.04058713f, -0.01939201f, -0.07783304f, -0.05678373f, 
    0.01389000f, -0.01192211f, -0.03336704f, -0.07583730f, -0.00750006f, -0.02090167f, -0.00552903f, 0.02078272f, 
    0.03039160f, 0.06275852f, 0.05803332f, -0.05243360f, -0.05926694f, -0.06243206f, -0.05383269f, 0.00124642f, 
    -0.16946647f, -0.06355907f, -0.05572417f, 0.08418673f, 0.10183273f, 0.01691302f, -0.02391473f, -0.30543578f, 
    0.18760608f, 0.01777968f, 0.02005064f, 0.14778019f, -0.15695064f, 0.19324024f, 0.58639878f, 0.02831995f, 
    -0.16035816f, -0.02665620f, 0.00141303f, 0.08468673f, -0.04460997f, -0.06551887f, -0.01534418f, 0.19346686f, 
    0.06476609f, -0.20472266f, -0.26340553f, 0.05109410f, -0.08636881f, 0.05890039f, 0.03637319f, 0.01935188f, 
    -0.07346367f, -0.09950180f, -0.05869628f, -0.02012439f, 0.33508074f, -0.10988141f, 0.12021296f, 0.16759442f, 
    0.08596206f, 0.00680862f, -0.04537659f, -0.08013653f, -0.01477306f, 0.00771434f, 0.06771211f, 0.00851006f, 
    -0.33536351f, -0.02305280f, -0.10805768f, -0.24972826f, 0.13112341f, -0.05774117f, -0.14809564f, 0.08354983f, 
    0.11591269f, -0.04945359f, -0.02463992f, -0.06450795f, -0.39135137f, -0.20762998f, 0.20502888f, 0.06370111f, 
    -0.24183382f, -0.16372365f, -0.13503525f, 0.08454604f, -0.00690619f, -0.00827918f, -0.00709780f, -0.12095907f, 
    -0.15039082f, -0.11123529f, 0.14631580f, 0.16591375f, 0.15363918f, 0.09579545f, -0.07633183f, 0.05176280f, 
    0.10902814f, 0.13729779f, -0.10519110f, 0.02712015f, -0.15362255f, 0.14862114f, 0.43030605f, 0.02477557f, 
    -0.06924193f, -0.09521167f, 0.06842547f, 0.05994049f, 0.19406806f, 0.02192105f, 0.18909448f, 0.11811288f, 
    -0.03046429f, 0.08805199f, 0.03969433f, -0.02276938f, -0.03609033f, -0.03334528f, -0.07620858f, 0.06613290f, 
    -0.01470686f, -0.23087080f, 0.06408457f, 0.03666794f, 0.02778061f, -0.00493956f, 0.04180918f, 0.02105980f, 
    0.01083047f, 0.05190430f, -0.07137927f, 0.02278726f, 0.03601918f, 0.01473847f, 0.18497790f, 0.31912020f, 
    0.22433823f, 0.06662356f, 0.43330044f, 0.05646732f, -0.09328941f, -0.10050499f, 0.12604202f, -0.00080033f, 
    0.05441800f, -0.04188367f, -0.00954040f, -0.00435833f, 0.17157759f, 0.09302997f, 0.08148219f, 0.18741493f, 
    0.07089490f, 0.06710166f, -0.12868391f, -0.05771070f, 0.11873353f, -0.09226603f, -0.02397740f, -0.01719468f, 
    -0.23850760f, 0.16924228f, 0.18416767f, 0.12994818f, -0.12759505f, -0.14099762f, 0.07467035f, 0.06942046f, 
    -0.10194523f, 0.16302900f, 0.22769417f, 0.08010579f, 0.10968154f, 0.19516861f, -0.05304662f, 0.04608541f, 
    0.01824937f, 0.05373036f, -0.05272603f, -0.05687510f, -0.08368474f, -0.23776862f, 0.03718063f, -0.01741622f, 
    -0.59280342f, 0.18881010f, 0.55465764f, -0.32885492f, -0.02844976f, 0.13185672f, 0.03555239f, 0.12987776f, 
    0.07906722f, 0.01353478f, 0.07095353f, -0.04552575f, 0.10151733f, -0.09299795f, -0.13926572f, -0.02683010f, 
    0.11249071f, 0.12893534f, -0.01911938f, 0.05591242f, -0.09227086f, -0.04764469f, 0.11624123f, 0.04189286f, 
    0.08106745f, -0.12211830f, -0.34631327f, 0.22356832f, -0.11432641f, 0.06219016f, -0.04351569f, -0.10534804f, 
    0.12497950f, -0.22594495f, 0.33119830f, -0.09283873f, -0.05158398f, -0.12225530f, -0.29370537f, -0.19520760f, 
    -0.07387531f, -0.19803441f, 0.04007425f, 0.15784885f, 0.05651716f, 0.03191883f, 0.05089306f, 0.15737201f, 
    0.23703867f, 0.24826442f, -0.19789338f, -0.02351617f, -0.29684579f, 0.07370356f, -0.11100714f, -0.07913064f, 
    -0.12386377f, -0.12354072f, 0.05582999f, -0.05155097f, -0.14878921f, 0.00921230f, -0.18633316f, 0.07911253f, 
    -0.01978701f, -0.07217815f, -0.21089748f, 0.09141868f, 0.10244553f, 0.02056271f, 0.37001085f, -0.00939814f, 
    -0.16314113f, -0.09494045f, 0.00564323f, -0.04192337f, -0.10349673f, -0.20589492f, -0.03260900f, 0.12941293f, 
    -0.02082000f, 0.03803965f, 0.09456784f, -0.11895414f, -0.01090611f, -0.26453772f, -0.10429673f, -0.26437947f, 
    -0.11991380f, -0.27399793f, -0.22483499f, 0.09712442f, -0.10490027f, -0.06120196f, -0.12404273f, -0.11909365f, 
    -0.27167735f, -0.39850906f, -0.33031458f, 0.04603212f, 0.04606646f, 0.06339054f, -0.05695264f, 0.19256426f, 
    0.11360122f, 0.21865705f, 0.24684691f, 0.21939339f, 0.40851653f, 0.19740115f, 0.39494580f, -0.01182067f, 
    -0.03604729f, -0.08418092f, 0.24769808f, 0.18347844f, -0.07488909f, 0.18606469f, -0.10527644f, 0.09571025f, 
    0.35374758f, 0.09167325f, 0.19264355f, -0.05174011f, -0.18650575f, -0.04443439f, 0.13618430f, -0.00531398f, 
    0.10190462f, 0.00908184f, 0.06689598f, 0.11485457f, 0.11892159f, 0.02980123f, -0.07346176f, 0.12250911f, 
    -0.06959113f, 0.31798553f, 0.18472552f, 0.10215019f, 0.10418905f, 0.12390432f, 0.17074113f, -0.04943082f, 
    0.26802602f, 0.15292689f, 0.22688098f, -0.09120690f, -0.00842823f, 0.09094442f, -0.03838256f, 0.07722861f, 
    -0.12804714f, 0.16614577f, -0.03294789f, -0.00174623f, -0.01406239f, -0.00821022f, 0.43630156f, 0.03514872f, 
    -0.01375243f, 0.06965715f, -0.04644888f, -0.11947360f, -0.03861634f, 0.15505125f, 0.09317723f, -0.05873955f, 
    -0.03200254f, 0.18738973f, 0.00974573f, -0.16065086f, 0.03303964f, -0.07092755f, 0.21221438f, 0.10041562f, 
    0.08950882f, 0.05532614f, 0.20795622f, 0.27409875f, 0.28924415f, 0.27414608f, 0.18519607f, -0.09769774f, 
    -0.09655993f, 0.02557047f, 0.09539569f, -0.02357376f, 0.04768569f, 0.08713962f, 0.05201848f, 0.15733717f, 
    0.42063895f, 0.19966577f, 0.30661097f, 0.10521670f, -0.15293181f, -0.05683890f, 0.07298683f, 0.01859985f, 
    0.00306088f, 0.00108214f, 0.06499376f, -0.11330055f, -0.14558575f, -0.27770147f, -0.14973205f, -0.17915195f, 
    -0.00141953f, -0.01895213f, -0.16110587f, -0.07163521f, -0.12326159f, -0.18329994f, -0.33934358f, -0.14430529f, 
    -0.08678209f, 0.22362588f, 0.46873340f, 0.33459359f, -0.01322108f, 0.23401031f, -0.10537583f, 0.06855025f, 
    -0.07356240f, -0.06188219f, -0.15537058f, -0.09730916f, 0.15448584f, -0.00595290f, 0.17422363f, -0.08322830f, 
    0.05407320f, 0.00255875f, -0.19265833f, -0.04801603f, -0.04977821f, 0.05380176f, 0.13014011f, 0.00483858f, 
    -0.41746390f, -0.29491070f, 0.35891077f, 0.40784425f, -0.10321043f, 0.16205770f, 0.06342750f, -0.06513552f, 
    0.09434389f, 0.01315467f, -0.11754467f, -0.08344235f, 0.00466204f, -0.01552068f, 0.28176138f, -0.03221205f, 
    0.02207004f, 0.10877026f, -0.04951170f, -0.05545942f, 0.17415424f, -0.09015761f, -0.10734840f, 0.20411223f, 
    0.07468110f, 0.27168566f, 0.35705602f, 0.21937193f, 0.07722426f, 0.27089754f, -0.14731666f, 0.35582438f, 
    0.05696753f, -0.00204058f, 0.06118002f, 0.16885862f, 0.27038598f, 0.04415306f, 0.32838929f, 0.35531202f, 
    0.21222258f, 0.20755596f, -0.00359789f, 0.37462810f, -0.02421840f, -0.02152624f, 0.09114887f, -0.07160985f, 
    -0.12464915f, 0.12216947f, 0.35623848f, 0.16084728f, 0.12347671f, 0.12865458f, -0.11273042f, 0.22109063f, 
    0.19314903f, -0.05991212f, 0.02398711f, 0.14436890f, -0.30262080f, 0.19050337f, -0.36573967f, 0.05354464f, 
    -0.16652158f, 0.03811719f, 0.10284777f, -0.16618773f, 0.07444634f, 0.23840824f, 0.27765372f, -0.01934965f, 
    0.04254387f, -0.33383018f, -0.30355141f, 0.13663746f, -0.16294797f, -0.05541670f, -0.00866632f, -0.06750228f, 
    0.29997322f, 0.11077345f, -0.00197864f, 0.12269851f, -0.13025145f, -0.08927192f, -0.07637530f, -0.12161683f, 
    -0.17188890f, -0.16398241f, 0.11935072f, -0.06119005f, 0.13102154f, 0.02039675f, 0.16086021f, 0.14676224f, 
    0.39900866f, 0.15854958f, -0.33310080f, 0.02335643f, -0.07128838f, -0.15084420f, -0.02218810f, 0.05626049f, 
    0.18976311f, -0.00853430f, -0.07947868f, -0.04107990f, 0.30172119f, 0.04989434f, 0.00203381f, 0.02575367f, 
    0.15103932f, -0.11486939f, -0.08598869f, -0.01472413f, 0.03985989f, -0.11298022f, 0.03158224f, 0.03461374f, 
    0.11549212f, 0.09013656f, -0.02436124f, -0.00503934f, 0.10644060f, -0.13113305f, -0.06396253f, 0.07918136f, 
    -0.01442577f, 0.02178916f, 0.02462359f, 0.05252928f, -0.21182539f, -0.08208244f, -0.03808789f, 0.18380889f, 
    -0.05522849f, -0.09623457f, -0.07804455f, -0.14809668f, -0.03087662f, -0.00950937f, -0.08441163f, -0.01224399f, 
    0.11389028f, -0.02219551f, -0.37862188f, -0.03536368f, -0.00795988f, 0.01124483f, -0.04504097f, 0.09468376f, 
    0.17266385f, 0.02306017f, -0.20329480f, -0.00593784f, 0.22889109f, 0.03618114f, 0.28685778f, 0.04037367f, 
    -0.00530848f, 0.06742479f, 0.12746869f, -0.05886356f, 0.12052680f, -0.18567829f, 0.02076000f, -0.23418598f, 
    0.04550867f, -0.05815148f, 0.05662633f, -0.02521326f, -0.04603790f, -0.06235764f, -0.01119612f, -0.02261177f, 
    -0.07398842f, -0.05867970f, -0.03946367f, -0.00309631f, 0.00049783f, 0.06049495f, 0.04140175f, -0.03196851f, 
    0.04555441f, 0.06466556f, -0.06712663f, -0.03778058f, 0.00536626f, -0.03478382f, 0.05524318f, 0.04690343f, 
    0.01908185f, -0.04979771f, 0.00748845f, 0.05740441f, 0.00849917f, -0.07632915f, -0.00151580f, -0.03479826f, 
    0.03769198f, -0.05157985f, -0.07605882f, -0.04947387f, 0.03095574f, -0.03693848f, 0.03668768f, -0.04685036f, 
    0.00041782f, 0.03226585f, 0.03588686f, 0.00011415f, 0.06271199f, -0.01019329f, -0.01435433f, 0.02585568f, 
    -0.03925309f, -0.05766534f, 0.02146342f, 0.03573259f, -0.05195877f, 0.02498797f, -0.02951424f, 0.00265249f, 
    -0.06198091f, -0.04551436f, 0.04061320f, 0.05442604f, -0.03164472f, -0.01462867f, 0.00819349f, -0.06334870f, 
    0.00581602f, 0.02069412f, -0.04997478f, -0.06327962f, -0.00978085f, -0.00909099f, -0.04562215f, 0.01334287f, 
    0.00274784f, 0.02107821f, -0.00928998f, -0.07132170f, 0.00826826f, 0.04048210f, -0.05385171f, -0.06922951f, 
    0.05643384f, -0.02783233f, -0.01479913f, -0.03066183f, 0.06321645f, -0.00351545f, -0.07193045f, 0.00135230f, 
    0.00524976f, 0.03609854f, -0.01598267f, 0.02695621f, -0.07678187f, 0.05525788f, 0.01195762f, 0.02885903f, 
    -0.06399875f, -0.06295694f, -0.07298301f, -0.06323533f, 0.00260837f, -0.05801619f, -0.01755292f, 0.02504381f, 
    0.00695377f, 0.04594370f, 0.00081740f, 0.06269924f, 0.01512074f, 0.00710093f, 0.01077477f, -0.07686062f, 
    -0.01840336f, -0.02897639f, -0.05226351f, -0.01136381f, -0.01318967f, -0.03962468f, 0.06193274f, -0.07431252f, 
    -0.00987393f, -0.07715052f, 0.01487077f, 0.04234587f, -0.04694362f, -0.01538126f, 0.06307727f, 0.00058180f, 
    0.02527833f, -0.03993900f, 0.05094636f, -0.05599458f, -0.05661201f, -0.06467241f, -0.01899722f, 0.04860064f, 
    -0.06837188f, 0.04465935f, 0.03495535f, -0.02796045f, -0.07718118f, -0.00341560f, 0.01408793f, 0.00766267f, 
    -0.04937202f, -0.00231534f, 0.03355889f, -0.07747811f, 0.03452613f, -0.01093487f, -0.03976486f, -0.01786008f, 
    0.00025020f, -0.05929426f, -0.02568026f, -0.02972279f, -0.07115925f, 0.01742028f, 0.04833553f, -0.03074188f, 
    0.00148222f, 0.03118360f, -0.06692927f, -0.03751342f, 0.00242118f, -0.03544961f, -0.01647683f, -0.02771337f, 
    -0.07017358f, 0.04399569f, -0.05822976f, 0.00433291f, -0.02707263f, -0.05493851f, -0.03783493f, -0.06491861f, 
    0.01059818f, -0.03484845f, 0.01029987f, 0.03776408f, 0.01816268f, -0.05425142f, 0.02131214f, 0.04110984f, 
    -0.07435054f, 0.01848156f, -0.00582307f, 0.04189416f, -0.05437055f, 0.05547098f, 0.02037688f, -0.04035822f, 
    0.28598657f, 0.02253041f, 0.05434316f, 0.02066128f, -0.20182432f, -0.14412896f, 0.15333499f, 0.17580341f, 
    -0.08583121f, -0.18551271f, -0.06021801f, 0.10213929f, -0.08491092f, -0.24338426f, -0.25287941f, -0.24107306f, 
    0.12699477f, 0.01210810f, -0.05549241f, -0.37654573f, -0.09944901f, -0.05234012f, 0.09288887f, 0.06827881f, 
    0.03687702f, 0.28839782f, 0.08566012f, 0.05589605f, 0.02569729f, 0.21276195f, -0.07579365f, -0.23123749f, 
    -0.13191816f, -0.17066589f, -0.15636504f, -0.28966027f, 0.42324698f, -0.01943577f, 0.19808857f, -0.06937137f, 
    -0.19618608f, 0.02324055f, -0.10404729f, -0.17485744f, 0.26809746f, 0.10893696f, 0.26478031f, -0.07147621f, 
    0.32275674f, 0.07132448f, -0.08304805f, -0.11541587f, 0.19010726f, -0.01612693f, 0.21612862f, 0.18031345f, 
    -0.04111456f, 0.14445734f, 0.16450372f, -0.07332116f, 0.09405665f, 0.03146179f, 0.00690484f, -0.03274069f, 
    -0.00897254f, 0.04220817f, 0.15820694f, 0.15699351f, -0.13393094f, -0.26068091f, -0.19950143f, 0.05416004f, 
    0.11325406f, -0.05173410f, -0.11317169f, -0.07975458f, -0.11517562f, 0.16323167f, 0.06340467f, 0.11505307f, 
    0.09464932f, 0.02154695f, 0.19885181f, 0.16618513f, -0.01571908f, 0.51677132f, 0.12491286f, 0.12794083f, 
    -0.05951452f, -0.13936526f, -0.01493016f, 0.03406950f, 0.07852811f, -0.04011180f, -0.23807104f, 0.00616235f, 
    0.00390734f, -0.09960192f, 0.16349956f, 0.16259310f, -0.29691499f, -0.00545851f, 0.31588042f, 0.19204630f, 
    0.12142284f, 0.24046902f, 0.04849220f, 0.21874189f, -0.10319703f, 0.26104802f, -0.16065703f, 0.00391828f, 
    0.01150906f, 0.03595318f, 0.17907953f, -0.12626784f, -0.11378258f, 0.01790193f, 0.05487721f, -0.02537242f, 
    0.28334475f, 0.22107722f, -0.07681020f, 0.22220127f, -0.04830618f, -0.06977834f, 0.13269663f, -0.12076162f, 
    -0.00282572f, 0.10130849f, 0.22179730f, -0.07788735f, 0.16208722f, 0.22110470f, 0.08917639f, 0.14430967f, 
    -0.09297514f, 0.12052654f, -0.30135185f, -0.28742588f, -0.09471759f, 0.06509257f, 0.02644409f, 0.00320327f, 
    0.18229468f, -0.01969588f, -0.07490532f, 0.08273860f, 0.01706273f, 0.01347633f, 0.19730558f, 0.02626124f, 
    -0.08269265f, 0.19573262f, 0.19665408f, 0.23734792f, 0.03369137f, 0.12344261f, 0.04854804f, 0.11527960f, 
    -0.21709271f, -0.16197383f, -0.08198242f, 0.04372129f, -0.00809903f, -0.16422983f, 0.00204455f, -0.05418264f, 
    -0.20310898f, -0.07250399f, 0.08181816f, 0.07321396f, -0.28643543f, 0.00269136f, -0.01627041f, -0.10278108f, 
    -0.14901689f, 0.03176387f, -0.03401073f, -0.01845898f, 0.01389342f, -0.19651632f, -0.17232731f, 0.00269710f, 
    -0.04691346f, -0.22518721f, -0.27425909f, -0.10396739f, -0.08545417f, -0.21989363f, -0.40050074f, 0.07613807f, 
    -0.23799884f, 0.45498341f, 0.69520742f, 0.00797699f, -0.02640057f, -0.04917431f, -0.04078142f, -0.02533206f, 
    0.16281368f, 0.11556724f, 0.01407131f, 0.01926030f, 0.48567110f, 0.03731198f, 0.23302628f, 0.06459808f, 
    0.03648635f, 0.03115451f, 0.15876652f, -0.08315981f, 0.03651195f, 0.14640315f, -0.05192484f, 0.09382463f, 
    -0.39166749f, -0.31866863f, 0.24678843f, 0.16136140f, -0.01206058f, -0.02063394f, 0.08965978f, -0.02933749f, 
    0.09260627f, -0.06993557f, -0.05225211f, -0.03220930f, 0.16975929f, 0.03004879f, 0.08287020f, 0.10203312f, 
    0.01686345f, -0.00856849f, 0.01788283f, -0.18324266f, 0.02335130f, 0.14250505f, 0.16436909f, 0.25973764f, 
    0.18002690f, 0.16308147f, 0.68141258f, 0.12995255f, -0.04706028f, -0.03459702f, 0.00949424f, 0.18910432f, 
    0.08818932f, -0.05174129f, -0.00819803f, -0.06898593f, 0.52694196f, 0.49936071f, 0.10410822f, 0.00317079f, 
    -0.15504859f, 0.13021070f, 0.05660479f, 0.11516374f, -0.00374616f, -0.04492146f, 0.01895944f, -0.11949806f, 
    0.32374761f, 0.47272050f, 0.39572248f, 0.50313264f, -0.09709924f, -0.08800782f, -0.19503762f, -0.05172613f, 
    -0.00221125f, 0.06508718f, -0.06525892f, 0.21272495f, -0.05648712f, -0.10344731f, -0.16588445f, -0.22578965f, 
    -0.15459621f, 0.00957968f, 0.03003912f, 0.02376511f, 0.04134133f, 0.13899687f, 0.19704826f, 0.02675057f, 
    -0.26376686f, -0.36546668f, -0.27405661f, -0.04702578f, -0.02319347f, -0.05751495f, -0.00734304f, 0.11637731f, 
    0.24927197f, 0.05716956f, 0.15150994f, 0.24628089f, -0.04066328f, -0.04901187f, -0.15241601f, 0.09072808f, 
    0.06844470f, -0.01770667f, 0.03739809f, 0.01587825f, 0.12056843f, -0.06936206f, 0.19179426f, 0.23256303f, 
    0.20552973f, 0.02876310f, -0.31408030f, -0.10083777f, 0.05177606f, 0.09826415f, -0.08186569f, 0.14318845f, 
    -0.00308670f, -0.08645874f, -0.02031268f, -0.19868207f, -0.21444312f, -0.12019616f, -0.25406006f, 0.07908562f, 
    0.03721365f, 0.01389254f, -0.02144733f, -0.05736463f, -0.09862518f, 0.04549423f, 0.19647719f, 0.11256195f, 
    0.30336946f, -0.01805244f, 0.25508121f, 0.03393192f, -0.05984480f, -0.06856934f, 0.06161339f, -0.12736064f, 
    0.11803076f, -0.03046466f, 0.19799884f, 0.19993433f, -0.37844950f, -0.56389415f, -0.18080737f, 0.14151743f, 
    0.08462331f, -0.03169014f, 0.05608289f, -0.11262739f, -0.03314542f, -0.19863066f, 0.13568057f, -0.14210106f, 
    -0.40069529f, -0.22368726f, -0.09692427f, -0.42413154f, -0.06805466f, 0.11219525f, -0.17846647f, 0.07192434f, 
    0.05409802f, 0.00277451f, 0.07139157f, -0.00428385f, 0.08872917f, 0.13446705f, 0.13216676f, 0.16731416f, 
    0.12447593f, 0.05719159f, 0.16608459f, -0.14266324f, -0.13173132f, -0.25880590f, 0.04321599f, -0.25700045f, 
    0.02974829f, 0.21439344f, -0.08421795f, -0.49137983f, 0.13990164f, -0.00714651f, -0.02583561f, -0.02665509f, 
    0.21773125f, 0.14472011f, 0.14212485f, 0.08627515f, 0.16556908f, 0.18725356f, 0.28507346f, 0.22696353f, 
    0.09900002f, 0.06149637f, 0.16335565f, -0.21569705f, 0.01275187f, 0.28763485f, -0.15952432f, -0.00573067f, 
    0.23548536f, 0.06734047f, 0.07832553f, -0.18147957f, 0.08280826f, -0.02478890f, 0.06012786f, 0.21288215f, 
    0.03930264f, -0.10034296f, 0.07312300f, 0.07802542f, -0.12094321f, 0.00012596f, -0.15071230f, 0.20429957f, 
    0.05618129f, 0.14270727f, 0.10911064f, 0.01659403f, -0.01851203f, 0.04076009f, 0.06960902f, 0.04950072f, 
    0.09903979f, 0.18177715f, -0.11689270f, -0.16033398f, 0.06730179f, -0.12979102f, 0.10020690f, -0.17858075f, 
    0.03810292f, 0.09186374f, 0.01836203f, -0.08520870f, -0.05169329f, 0.18217932f, -0.33010957f, -0.13078214f, 
    -0.34908140f, -0.02808079f, 0.00041308f, -0.09320471f, -0.00353468f, 0.09676109f, -0.13453096f, -0.03112677f, 
    0.19838372f, 0.06462036f, -0.05901013f, 0.10361779f, -0.00632964f, 0.03950269f, 0.09513455f, -0.26074830f, 
    -0.09332570f, 0.03627124f, 0.04910508f, 0.18711358f, 0.03772210f, -0.11720431f, 0.08709779f, -0.09827411f, 
    0.11999448f, -0.06906679f, -0.24150372f, -0.06585263f, -0.06453305f, -0.08108927f, 0.08192474f, 0.06550442f, 
    -0.34042326f, -0.21284892f, -0.08713033f, -0.16096407f, -0.05911488f, -0.08634977f, -0.09804967f, 0.14352711f, 
    -0.02560790f, -0.07358861f, -0.04594338f, 0.11071180f, -0.09408205f, -0.00592305f, -0.06118206f, 0.04354632f, 
    0.12662451f, 0.11114985f, 0.00945199f, 0.08944502f, 0.24728945f, 0.02026105f, -0.05786498f, 0.09464116f, 
    0.24868582f, -0.14538172f, 0.22559500f, 0.13077182f, 0.14569066f, -0.12206276f, -0.09336555f, 0.03120157f, 
    -0.13570993f, 0.14599161f, 0.02097445f, -0.06111399f, -0.30477259f, -0.14324701f, -0.30218974f, 0.26512098f, 
    -0.02429117f, 0.10552638f, 0.01109586f, 0.12052070f, 0.01297073f, 0.20503747f, -0.08987561f, 0.16801174f, 
    0.17287056f, 0.16341105f, 0.24795157f, 0.17285313f, 0.09834515f, 0.09648555f, -0.01476664f, -0.20241709f, 
    0.14844988f, 0.19543046f, 0.17443524f, 0.12520602f, -0.14926288f, -0.18045005f, 0.12157618f, -0.00813825f, 
    0.06696394f, 0.02893268f, 0.15653725f, 0.01387027f, 0.22753932f, -0.05883301f, 0.31492451f, -0.06769134f, 
    -0.33065125f, 0.06267899f, -0.00682994f, -0.16343726f, -0.14442548f, -0.04924506f, -0.02578397f, 0.08010378f, 
    -0.12704189f, -0.00536398f, 0.00578466f, 0.01297855f, -0.15572147f, -0.00221442f, 0.01354900f, 0.08427148f, 
    0.23865053f, 0.05580614f, 0.07637461f, 0.07675574f, 0.20541289f, -0.18923734f, -0.08747745f, 0.08559342f, 
    0.23397659f, 0.11343382f, -0.08334880f, -0.24922320f, 0.07949558f, 0.07699233f, 0.14229611f, 0.03216590f, 
    -0.00237940f, 0.06679283f, 0.00314772f, 0.23125479f, -0.35172793f, -0.13684492f, 0.33246240f, -0.02359091f, 
    0.04424716f, 0.14192215f, -0.03544846f, 0.14764839f, 0.09357940f, -0.07200723f, 0.32440975f, 0.08735634f, 
    0.12113496f, 0.11327539f, -0.17287464f, 0.17206372f, 0.18011913f, -0.09618090f, 0.06689517f, -0.01317480f, 
    0.08351611f, -0.01138692f, -0.09869101f, 0.02211372f, 0.38948369f, -0.30182853f, 0.47751343f, -0.23894963f, 
    0.00051370f, 0.11922906f, 0.04708977f, -0.05857727f, 0.08208581f, 0.06118419f, -0.20091735f, -0.19947226f, 
    0.08498025f, -0.23930034f, -0.19850340f, -0.47756231f, 0.02639291f, -0.00619027f, 0.03674775f, -0.04859676f, 
    0.00876907f, 0.00622907f, -0.06717991f, 0.09238856f, 0.02302849f, -0.08691016f, -0.04713672f, 0.13797583f, 
    0.19591272f, 0.00985281f, 0.09197930f, 0.12177585f, 0.07154825f, -0.09229472f, 0.07673650f, 0.13251393f, 
    -0.18148577f, -0.36788502f, -0.02115626f, -0.48815602f, -0.07651868f, 0.03830210f, 0.18697959f, 0.26142532f, 
    0.02983840f, -0.06599583f, 0.00081262f, -0.01202626f, -0.31032833f, 0.09556545f, 0.03725619f, -0.02731095f, 
    0.11397600f, 0.01872928f, -0.03965026f, 0.11826506f, 0.17051885f, 0.02298465f, 0.10967256f, 0.07024591f, 
    -0.46307811f, 0.11645182f, -0.10581115f, 0.10996331f, 0.04879159f, 0.05566411f, 0.03543305f, -0.18192846f, 
    -0.14439677f, -0.03210517f, -0.11914548f, -0.12631139f, -0.17916155f, -0.15176617f, -0.02836603f, -0.02458310f, 
    0.15184815f, 0.16309114f, -0.02567503f, -0.24352288f, -0.05291440f, 0.26663613f, -0.10494259f, -0.06557281f, 
    -0.60243231f, 0.15334974f, 0.04061989f, 0.05257598f, -0.08099595f, -0.03774590f, 0.17079584f, -0.03980388f, 
    -0.01278233f, 0.02555813f, 0.12059154f, 0.04141247f, 0.13211720f, 0.22671239f, -0.11239299f, 0.42438653f, 
    -0.08641512f, 0.01408129f, -0.02535661f, -0.13635571f, 0.29507074f, 0.16291063f, 0.05518917f, 0.14019038f, 
    -0.25637585f, -0.41685098f, 0.28478310f, -0.06108044f, -0.03617477f, -0.09003904f, 0.12853573f, -0.04171551f, 
    0.07257267f, -0.05362156f, -0.03500484f, -0.06622620f, 0.11662287f, 0.28723434f, -0.11953679f, 0.13115914f, 
    -0.06660075f, -0.05948510f, -0.11383393f, 0.07450720f, 0.05214414f, 0.03071432f, 0.16205396f, -0.03808540f, 
    -0.22702305f, -0.00898075f, 0.03339132f, -0.03518487f, 0.01528022f, 0.01827805f, -0.01707262f, 0.05966862f, 
    0.08157153f, 0.13716790f, 0.03391833f, 0.01551933f, 0.32592478f, -0.18417943f, -0.04128767f, -0.01786141f, 
    -0.08652461f, 0.13507986f, -0.22066903f, -0.12619868f, 0.07094092f, -0.03443541f, 0.03035236f, 0.17121467f, 
    0.01929202f, 0.04566582f, 0.01670361f, -0.00416391f, -0.04548071f, 0.06176782f, 0.02077556f, 0.04978061f, 
    -0.00395090f, -0.02962396f, 0.03902431f, 0.01532302f, 0.06426366f, 0.02928338f, -0.05938411f, -0.04952659f, 
    -0.03246908f, 0.05105564f, -0.02935067f, 0.04815167f, 0.04138625f, 0.01030497f, -0.06132121f, -0.04304048f, 
    -0.01928443f, -0.00462446f, 0.05871634f, -0.05140997f, -0.01209004f, -0.01556014f, 0.01853919f, 0.04785261f, 
    0.00530830f, -0.01893554f, -0.05826236f, -0.05051471f, -0.00452554f, 0.06397028f, 0.00633360f, 0.06055086f, 
    -0.05056812f, -0.07667523f, 0.04722242f, 0.00154800f, -0.07397161f, 0.01805731f, -0.03734851f, 0.05284403f, 
    -0.04990962f, -0.04125933f, 0.00222914f, -0.00769012f, 0.01734930f, -0.00220541f, -0.07801674f, -0.03861855f, 
    0.00167775f, -0.07465767f, -0.01051969f, 0.03396592f, -0.05440514f, -0.05335095f, -0.01586164f, -0.04858759f, 
    0.05524623f, 0.05794270f, -0.03312503f, 0.01873138f, -0.04023067f, -0.01851790f, -0.04803310f, -0.01711797f, 
    -0.04011664f, 0.04330475f, -0.06909055f, 0.01005766f, 0.05114935f, -0.02348991f, 0.05244002f, -0.03373403f, 
    -0.04117559f, -0.04937390f, 0.00944378f, 0.03218921f, -0.07005213f, 0.03506425f, 0.01752474f, -0.05224373f, 
    0.02575473f, 0.03490664f, 0.01607120f, -0.05936268f, -0.03898229f, -0.03935789f, -0.03130395f, -0.03389212f, 
    -0.02663898f, -0.03860591f, 0.05171879f, 0.03520511f, -0.03195053f, 0.04259058f, -0.07157820f, -0.07496291f, 
    -0.02706602f, -0.04781893f, 0.06229208f, -0.06315153f, -0.04928941f, 0.04918240f, 0.04822074f, 0.06587754f, 
    -0.05736818f, -0.05968630f, 0.04359536f, -0.02584099f, -0.04039156f, 0.01328439f, -0.01384027f, -0.01515408f, 
    -0.05514869f, -0.06619167f, 0.04283172f, 0.03991368f, -0.02381092f, 0.03932297f, -0.03135085f, -0.02521670f, 
    -0.05035476f, -0.01899453f, 0.02855222f, -0.01215487f, -0.02645904f, -0.07268286f, -0.01091337f, -0.03010058f, 
    -0.05939868f, 0.05252500f, -0.06399205f, -0.00434289f, 0.00382043f, -0.05292596f, -0.05759265f, -0.07491818f, 
    -0.00440018f, -0.04018725f, -0.06261478f, 0.06357323f, -0.07411607f, -0.07080844f, 0.01896356f, 0.04486567f, 
    -0.06063752f, 0.00225763f, -0.03234114f, 0.05766248f, 0.02142560f, 0.05980235f, -0.01613309f, -0.02778269f, 
    -0.03005018f, -0.05984115f, 0.05206685f, -0.04959443f, -0.06013514f, -0.00228297f, -0.02584272f, 0.02557450f, 
    0.03131561f, 0.01616790f, -0.02747402f, -0.07792208f, -0.03481768f, -0.02381077f, -0.06785522f, -0.00110094f, 
    0.00381625f, 0.00087716f, -0.06898105f, 0.04453801f, 0.00362399f, 0.05931632f, 0.04954651f, 0.00011849f, 
    -0.03672745f, 0.03299025f, -0.00471407f, 0.00323024f, 0.06078213f, 0.01344680f, -0.01868393f, -0.05678973f, 
    0.00947800f, 0.01038314f, -0.04110290f, -0.05791709f, 0.01193434f, 0.05394058f, -0.01274017f, -0.07480486f, 
    -0.02459832f, -0.06997739f, 0.04184641f, -0.07159597f, 0.05602639f, -0.06223573f, -0.02721071f, -0.01368148f, 
    -0.05894846f, -0.07654202f, -0.06556498f, -0.01935936f, -0.04572303f, 0.03541497f, -0.01702680f, -0.06564439f, 
    0.03387084f, 0.00265441f, -0.03536412f, -0.04984080f, -0.02144068f, -0.04702137f, -0.05959295f, 0.02200985f, 
    -0.01824717f, -0.00264465f, -0.01435288f, 0.04911286f, 0.02861174f, -0.00856896f, -0.01233337f, -0.03512433f, 
    -0.02840820f, -0.03829709f, 0.03223027f, -0.05040378f, -0.01712846f, 0.02104650f, 0.06460570f, -0.07626518f, 
    -0.04393077f, -0.01894171f, -0.01434840f, -0.04094529f, -0.03638743f, 0.06626440f, 0.03874842f, 0.05081061f, 
    -0.03781853f, 0.04285198f, -0.02018313f, 0.06111534f, -0.07016710f, 0.01411631f, 0.04989690f, -0.06916620f, 
    -0.04279618f, -0.03511683f, -0.02249782f, 0.05896578f, 0.00597849f, 0.00132732f, -0.02677521f, -0.02927643f, 
    0.00887694f, 0.05341742f, -0.04540662f, 0.03249101f, 0.04487592f, -0.00766569f, -0.00293010f, 0.06941317f, 
    0.04440117f, 0.02958293f, -0.03918929f, -0.05472412f, -0.07529508f, -0.06712119f, 0.03641818f, -0.02345026f, 
    -0.06496388f, 0.00353912f, 0.00137223f, -0.03926188f, 0.00483636f, -0.05690183f, -0.01341328f, -0.00015524f, 
    -0.05848469f, 0.05307057f, 0.03288583f, -0.02954479f, -0.05123005f, -0.03953805f, 0.04086451f, -0.04631215f, 
    -0.06084428f, -0.02549597f, -0.03251555f, -0.02129185f, -0.05714622f, -0.01080141f, 0.03572175f, -0.05493301f, 
    -0.00469276f, 0.00920271f, -0.06586746f, 0.04170124f, 0.05465301f, 0.00352809f, -0.02563089f, 0.04218391f, 
    -0.02528547f, -0.00376486f, -0.02276041f, 0.02695800f, 0.01410463f, -0.01354577f, 0.02723980f, -0.00222786f, 
    -0.03347937f, -0.00958098f, 0.00877313f, 0.02770831f, -0.01267581f, 0.04638601f, 0.03928457f, 0.02654919f, 
    0.03411433f, -0.03136631f, -0.02469626f, -0.04723568f, -0.03195111f, 0.05323275f, -0.00334738f, -0.02954728f, 
    -0.01631822f, -0.05478395f, 0.05802562f, 0.04671589f, -0.02289865f, -0.04402912f, 0.01304701f, -0.05012098f, 
    0.00250805f, -0.04045103f, -0.06781754f, 0.00758493f, -0.02444795f, 0.01061436f, 0.00250054f, 0.06345272f, 
    -0.06878469f, -0.05073705f, 0.03307662f, -0.07576995f, 0.00927507f, 0.02533486f, 0.04889917f, -0.03104076f, 
    0.04413359f, 0.06080734f, -0.07525742f, 0.00515444f, -0.03743041f, -0.01954601f, -0.03803211f, -0.03736096f, 
    0.04674631f, -0.06421608f, 0.04081649f, -0.01570853f, 0.03338587f, -0.05488725f, 0.00206908f, -0.02561484f, 
    0.03080576f, 0.00846059f, -0.01682538f, 0.05385806f, 0.01952940f, 0.01414688f, 0.00799381f, -0.02341095f, 
    -0.03871378f, 0.02363971f, -0.04715808f, 0.02546602f, -0.00131948f, 0.01456845f, -0.05699100f, 0.04621811f, 
    -0.07455297f, -0.04233618f, -0.07767833f, -0.07453984f, 0.01457344f, -0.06836817f, -0.06680387f, 0.03798500f, 
    0.06470159f, 0.03722294f, -0.01655927f, -0.04672439f, 0.02773809f, 0.03954128f, 0.01442915f, -0.04803792f, 
    -0.01461953f, 0.04994145f, 0.01630339f, 0.03235980f, 0.01334211f, -0.02456205f, -0.07350667f, 0.02770241f, 
    -0.05644688f, 0.04365910f, -0.01010282f, 0.01176680f, -0.05869434f, -0.01000935f, -0.02775960f, 0.01189256f, 
    0.01165133f, -0.03484201f, 0.03655564f, -0.03800267f, -0.00410261f, 0.05126349f, 0.02366346f, -0.06787638f, 
    -0.00563303f, 0.06217077f, 0.02540408f, -0.05685796f, -0.04386926f, 0.00600486f, -0.01145082f, 0.00347719f, 
    -0.04979663f, -0.06813759f, -0.00033092f, 0.03373275f, 0.00749080f, -0.06525087f, -0.05378365f, -0.06944009f, 
    0.00327765f, -0.04980341f, -0.06922479f, -0.03866282f, -0.01145577f, 0.04502479f, -0.00208174f, 0.06449412f, 
    0.05223766f, 0.05993778f, -0.04701582f, 0.02268748f, -0.03897190f, -0.04558882f, -0.01049066f, 0.01138593f, 
    -0.02781241f, -0.07482504f, 0.01194277f, -0.04852974f, -0.00681790f, -0.00260626f, -0.04020566f, 0.05380471f, 
    -0.05016010f, -0.00080063f, 0.04475833f, 0.04256984f, -0.07207546f, -0.00285269f, -0.00297428f, -0.03408335f, 
    -0.07583909f, -0.04001905f, -0.06228179f, 0.02353573f, -0.07748799f, 0.00912478f, -0.01219639f, -0.02561660f, 
    -0.01464764f, -0.00829492f, -0.06123399f, -0.06738347f, -0.05897310f, -0.03008286f, -0.02418939f, 0.04479755f, 
    0.00353919f, 0.01476546f, -0.02241096f, -0.02805897f, 0.02870788f, -0.06495449f, -0.02881960f, -0.03044827f, 
    -0.04232341f, 0.03988773f, 0.00866353f, -0.04437684f, -0.03198583f, -0.03125123f, -0.07133877f, 0.05863215f, 
    -0.06663381f, -0.01490964f, -0.04386378f, 0.05434881f, 0.05292447f, 0.06465082f, -0.02478482f, 0.04652986f, 
    0.04291513f, 0.00726563f, -0.01121556f, -0.04104899f, -0.03872804f, 0.05634889f, -0.03136301f, 0.00544837f, 
    -0.00331376f, -0.01182342f, 0.04572597f, 0.01627630f, 0.01820743f, 0.02759926f, 0.03037842f, 0.04234133f, 
    0.02404888f, 0.04170340f, -0.01304467f, -0.07488062f, -0.03269008f, 0.04063585f, 0.05320572f, -0.05179654f, 
    -0.02527426f, 0.04237323f, 0.01915958f, 0.01936038f, 0.00095935f, -0.06145206f, 0.04877610f, -0.07626928f, 
    -0.04173442f, -0.02938965f, 0.06282616f, 0.05814629f, -0.07461155f, -0.01811942f, -0.05614611f, -0.04118185f, 
    0.03791722f, 0.01237485f, 0.00705660f, 0.04268361f, 0.03460285f, -0.04254919f, 0.01083152f, -0.02308435f, 
    -0.05982550f, -0.02377488f, -0.05134850f, -0.03476350f, 0.01473221f, -0.00553093f, -0.06251736f, -0.06758440f, 
    -0.20269921f, -0.12182108f, -0.11484272f, -0.09419618f, 0.24249572f, 0.13529867f, 0.11018664f, 0.13885500f, 
    -0.02269797f, 0.06047271f, 0.12860440f, 0.10018254f, -0.22042827f, 0.29665264f, 0.22370881f, 0.57196891f, 
    -0.04236646f, 0.05838753f, 0.10926306f, 0.17831658f, 0.19068570f, 0.02360714f, 0.11119518f, 0.03687892f, 
    0.30356705f, 0.05074196f, 0.07603877f, -0.22729863f, -0.08892539f, -0.22722711f, -0.10599142f, 0.07375362f, 
    -0.18453455f, -0.04122519f, 0.04456438f, 0.05100884f, -0.43964508f, 0.09289382f, -0.21192558f, -0.01911440f, 
    0.12846582f, 0.00695769f, 0.14820877f, 0.04865706f, 0.00481888f, -0.09453364f, -0.03989233f, 0.15995155f, 
    -0.22654873f, 0.02970793f, -0.44439176f, -0.00209267f, 0.00803781f, -0.11801006f, -0.03927719f, -0.18559417f, 
    0.02619421f, -0.10878690f, -0.08326412f, 0.02439447f, -0.26411891f, -0.08458780f, 0.02143838f, 0.12013304f, 
    -0.02841484f, 0.01696911f, -0.10071260f, -0.21503395f, -0.08319257f, -0.01315843f, -0.06511686f, 0.08459738f, 
    -0.07151584f, 0.00342713f, 0.14850615f, 0.03079792f, 0.13358490f, 0.01738965f, 0.14921743f, 0.04664540f, 
    0.00185716f, 0.16290095f, -0.06228154f, -0.06681406f, 0.15081583f, -0.52815419f, 0.31804630f, -0.18950373f, 
    -0.02389041f, 0.02566259f, -0.06681602f, -0.22681364f, 0.05700323f, 0.04378938f, 0.03008006f, 0.02984005f, 
    -0.18644483f, 0.01058336f, 0.07651776f, -0.27426115f, -0.01990225f, -0.23899011f, -0.39973921f, -0.06250479f, 
    -0.25158459f, -0.17230575f, -0.20198092f, -0.24064808f, 0.08550805f, -0.29285040f, 0.19624287f, -0.09065124f, 
    -0.01817128f, 0.02888232f, -0.00474002f, 0.39853647f, -0.15109044f, -0.02619644f, -0.04878188f, -0.15084904f, 
    0.36911184f, 0.09123876f, 0.54974651f, 0.07389556f, -0.14057612f, 0.07952883f, -0.04936732f, 0.06385718f, 
    -0.10032342f, 0.08562756f, -0.00494116f, 0.17766316f, 0.02236186f, -0.18511340f, 0.18868391f, -0.12829064f, 
    0.06782179f, 0.01591423f, 0.10819590f, 0.00189428f, -0.02527834f, 0.03978488f, 0.10008495f, 0.27412125f, 
    0.01896570f, 0.62660313f, -0.15304783f, 0.42735749f, 0.03944260f, 0.14930841f, -0.15023264f, -0.04996563f, 
    0.09708582f, 0.10211078f, 0.07604799f, -0.04766707f, 0.14229578f, 0.11932896f, 0.21082559f, -0.24416682f, 
    0.02881320f, -0.01285580f, -0.03310037f, 0.15607835f, 0.03330284f, 0.00257105f, 0.20190996f, 0.06697238f, 
    -0.25795597f, 0.51045716f, 0.18774353f, -0.13647367f, 0.09268856f, -0.19257690f, -0.18805708f, -0.03375500f, 
    0.05473038f, 0.04164474f, -0.07730310f, 0.00666161f, -0.19016078f, -0.04427267f, 0.00760531f, -0.13183118f, 
    -0.11439738f, 0.09958635f, 0.11253741f, 0.16330749f, 0.19796990f, 0.35405076f, -0.08620682f, 0.20221123f, 
    -0.07487604f, -0.03315391f, -0.01193538f, -0.01431690f, -0.00611005f, -0.00352387f, -0.03162036f, -0.00755065f, 
    0.03060382f, -0.02900941f, -0.03924150f, -0.03721049f, 0.04767364f, -0.07096288f, -0.05561926f, 0.00585524f, 
    0.00818187f, -0.03525407f, -0.02967120f, -0.05343020f, 0.03578072f, -0.04247955f, 0.03619435f, 0.04211413f, 
    -0.01215339f, -0.03518524f, -0.00729250f, -0.01486947f, -0.03316730f, 0.03612720f, -0.01733721f, -0.02416208f, 
    0.06216653f, -0.01083272f, 0.01969028f, -0.03290260f, -0.05854774f, -0.06419144f, 0.03234052f, -0.04691135f, 
    -0.06056155f, 0.04743552f, -0.08035316f, -0.05860957f, 0.01172151f, -0.00303179f, -0.07384955f, 0.00182967f, 
    -0.01026657f, 0.05881701f, 0.02525948f, -0.03809145f, -0.05232413f, -0.02600429f, -0.07052693f, -0.03628226f, 
    0.00161864f, -0.06655199f, -0.00295513f, 0.03837060f, 0.04598814f, -0.03232539f, 0.04719956f, 0.06150488f, 
    0.02021698f, -0.05921517f, -0.00706344f, -0.03493826f, 0.04738168f, 0.05140353f, -0.03532143f, 0.00031425f, 
    -0.04337181f, -0.03108527f, -0.01622644f, -0.01595471f, -0.00066671f, -0.00407317f, -0.04465525f, 0.04167275f, 
    0.01783033f, -0.00726157f, 0.00108926f, -0.03783811f, 0.00043291f, -0.02573801f, 0.02389833f, -0.02245837f, 
    -0.05052437f, 0.00688051f, -0.03693498f, -0.03965457f, 0.03918938f, -0.06774089f, 0.05890886f, 0.01081953f, 
    -0.01729153f, -0.02999701f, 0.03068347f, -0.06302849f, -0.03717655f, -0.00885217f, 0.04312857f, 0.05209900f, 
    -0.02813726f, 0.00266841f, -0.03694973f, 0.03053927f, -0.03263310f, -0.05978549f, -0.01948098f, -0.01465605f, 
    0.01332004f, 0.04994479f, -0.00233102f, -0.05940244f, -0.05312002f, -0.07704653f, 0.00996353f, 0.04384048f, 
    0.05946586f, -0.06566686f, -0.04356001f, 0.04311857f, -0.02179514f, 0.00418128f, 0.04825577f, -0.04203529f, 
    -0.07376353f, -0.00637274f, 0.02133832f, -0.04368978f, 0.03995833f, -0.01773838f, -0.00713579f, 0.04334366f, 
    -0.08088486f, 0.02480852f, 0.03015486f, -0.05474426f, 0.03173036f, 0.04434338f, -0.05085781f, -0.02513375f, 
    0.00428051f, -0.00724478f, 0.05487682f, 0.03904651f, -0.06506877f, -0.00180516f, -0.01521469f, -0.04081767f, 
    -0.00015824f, 0.04714245f, 0.05657702f, 0.03427342f, -0.03606383f, 0.01665180f, -0.04398371f, -0.01640820f, 
    0.04739798f, -0.06076081f, 0.01505614f, -0.03090759f, -0.00534141f, 0.03063577f, 0.01003356f, -0.06746929f, 
    0.05171122f, -0.00673203f, 0.03283269f, -0.02674882f, 0.00296793f, 0.04340866f, -0.06679612f, 0.05240984f, 
    -0.01386033f, -0.05433071f, -0.02004469f, 0.01167572f, 0.05440511f, -0.01740888f, -0.08242259f, 0.01036856f, 
    0.04973191f, 0.02892538f, 0.00749581f, 0.02310890f, -0.07873760f, -0.05932794f, 0.03545906f, 0.04759387f, 
    0.11629952f, 0.06946971f, -0.03199725f, 0.13374959f, 0.22442882f, 0.09142973f, 0.05640348f, 0.03712197f, 
    0.07719209f, 0.06847306f, 0.02005569f, -0.00633141f, 0.07491519f, 0.38810316f, 0.26300842f, 0.01416246f, 
    -0.02720520f, 0.02531676f, -0.22087395f, 0.07948969f, 0.12164166f, 0.03579018f, -0.08098185f, -0.05162727f, 
    -0.32611445f, -0.12370359f, -0.06899638f, 0.34366992f, 0.05013436f, 0.15844159f, 0.11762815f, -0.04589448f, 
    -0.08917286f, -0.02716633f, -0.12033115f, 0.05884281f, -0.06796036f, 0.23164162f, 0.23161614f, 0.31990066f, 
    -0.02241869f, 0.07255574f, 0.04244573f, 0.17165560f, 0.04638973f, 0.02138714f, 0.00761938f, 0.19194268f, 
    0.04430110f, -0.04971500f, 0.12208042f, -0.03625450f, -0.12111665f, 0.15108435f, 0.03522577f, -0.00192617f, 
    -0.13331842f, 0.00468321f, 0.03751129f, 0.06855750f, 0.01420516f, 0.06773344f, 0.01544359f, -0.02410939f, 
    0.18534361f, 0.18814093f, 0.21116313f, 0.14521116f, -0.03118212f, -0.03983275f, 0.19039539f, -0.06341087f, 
    -0.09271279f, 0.01920430f, 0.07515331f, -0.19274363f, 0.08211263f, 0.02662755f, -0.02708230f, 0.04910293f, 
    0.01616653f, -0.04529911f, 0.14647074f, 0.05156400f, -0.02521312f, -0.01051486f, -0.36954612f, -0.06390899f, 
    0.09167300f, -0.04675682f, 0.07397515f, -0.09298321f, -0.09593317f, 0.12085216f, 0.01003514f, -0.07589462f, 
    -0.09449226f, -0.13736415f, -0.20925765f, 0.06770820f, 0.13912280f, 0.03095837f, 0.04750075f, -0.13494971f, 
    -0.01251258f, -0.00803479f, -0.07943214f, -0.01714680f, -0.16740876f, -0.16437800f, -0.19817375f, -0.26887843f, 
    -0.07303721f, -0.01960414f, -0.00836727f, 0.04608242f, 0.20963055f, 0.27728331f, 0.01914218f, -0.18023981f, 
    -0.33095926f, -0.23636857f, -0.30775630f, -0.24702267f, 0.14024422f, 0.07907439f, -0.07851065f, 0.03997356f, 
    0.20101555f, 0.00584865f, -0.13337001f, 0.14123033f, -0.08745825f, 0.17975727f, 0.22997728f, 0.13490480f, 
    -0.11611678f, -0.18940550f, 0.01979814f, -0.02113961f, 0.19845834f, 0.04738813f, 0.09699719f, 0.03438595f, 
    -0.20472212f, -0.12673530f, 0.10892773f, -0.24173202f, 0.04289008f, -0.08444277f, -0.03725500f, 0.13145287f, 
    0.08922459f, 0.06450598f, -0.01664737f, 0.09509782f, -0.02948219f, -0.03585030f, 0.03972654f, 0.24159193f, 
    0.01932865f, -0.02052733f, -0.08906183f, -0.08073151f, 0.06526340f, 0.26882231f, -0.02327295f, 0.17529711f, 
    0.40198597f, -0.22839096f, -0.49124271f, 0.29576492f, 0.08248992f, 0.02272902f, 0.08610315f, 0.17075963f, 
    0.13415079f, -0.12665665f, -0.24571972f, 0.03594089f, -0.06887059f, 0.06634951f, -0.00898917f, 0.23705089f, 
    0.17346488f, -0.03859345f, -0.03171426f, 0.02974034f, -0.07353433f, -0.20131460f, -0.09139342f, -0.19359541f, 
    0.01857176f, -0.14014883f, -0.21167725f, -0.31507921f, 0.00870855f, 0.13745236f, 0.13135770f, 0.24277045f, 
    -0.16319138f, 0.00274204f, 0.02515586f, 0.05614303f, 0.20105752f, 0.06639729f, -0.07327155f, 0.04621589f, 
    0.07574815f, 0.14570232f, -0.06229905f, 0.13047658f, 0.05814621f, 0.25119945f, 0.19194478f, -0.08112671f, 
    -0.21776666f, 0.22668950f, -0.19841929f, -0.28949347f, -0.33669189f, 0.01363759f, -0.18303317f, -0.23316222f, 
    -0.03112585f, 0.10437317f, -0.01283053f, 0.06293591f, -0.05515563f, -0.00306953f, -0.24474861f, -0.23745102f, 
    0.10378377f, -0.01957495f, 0.03363115f, 0.10970750f, 0.00361624f, 0.04412050f, -0.12760225f, -0.07781695f, 
    0.07144633f, 0.12167650f, -0.27126744f, -0.00457580f, 0.18736327f, -0.10131027f, 0.20499904f, -0.03797682f, 
    -0.09571930f, -0.18765326f, 0.07511322f, -0.05538981f, -0.14692646f, -0.05143161f, -0.15828006f, 0.13349889f, 
    0.13952227f, 0.15492892f, -0.02943874f, -0.17332895f, 0.03294967f, 0.02008771f, 0.06150153f, 0.21863723f, 
    0.27829561f, -0.01619208f, -0.08597203f, -0.06852385f, 0.13450848f, 0.05564706f, 0.09798347f, 0.09775940f, 
    -0.09974572f, -0.06358570f, -0.12323044f, -0.09522444f, 0.06638213f, -0.29736495f, -0.02230075f, -0.07947528f, 
    -0.07251330f, -0.17541091f, 0.10111268f, -0.00910493f, 0.04111326f, -0.01443029f, -0.03971898f, 0.06897174f, 
    -0.12491100f, 0.10437176f, 0.00271094f, -0.06378395f, -0.21339902f, -0.17686579f, -0.13738620f, -0.07054165f, 
    -0.19568814f, -0.01525743f, -0.03683608f, -0.08584802f, -0.05566422f, -0.05491727f, 0.15434524f, 0.07031219f, 
    -0.04918395f, 0.18573052f, 0.09112074f, 0.01414040f, -0.24725890f, -0.14527240f, -0.01011511f, -0.07672672f, 
    0.27446216f, 0.27581796f, 0.36520392f, 0.56769639f, -0.10135816f, -0.41066802f, 0.30889496f, -0.04568854f, 
    0.03002991f, 0.10132645f, 0.06626572f, 0.19056810f, 0.25772747f, 0.02135117f, 0.36568150f, -0.03780442f, 
    -0.09618250f, 0.09873822f, 0.10694885f, 0.00493843f, 0.07278030f, 0.13385627f, -0.20820032f, 0.10833726f, 
    0.27467725f, 0.41058269f, -0.34227541f, 0.20495844f, 0.12915120f, 0.13303968f, -0.08329283f, 0.09517859f, 
    -0.06310149f, -0.06793753f, -0.10293210f, -0.15869214f, 0.09358162f, 0.28013280f, 0.09573666f, -0.19737372f, 
    -0.10291643f, 0.10032478f, -0.06911832f, -0.06693944f, 0.11812821f, 0.03667252f, -0.07622659f, -0.09284028f, 
    0.15155523f, 0.35636079f, 0.18389773f, 0.02594322f, -0.14391862f, -0.19025388f, -0.11338434f, -0.21798979f, 
    0.05868753f, 0.00601007f, 0.07116600f, 0.01032090f, 0.04794372f, 0.09139744f, 0.14293025f, -0.33607560f, 
    -0.19976012f, -0.04616804f, 0.15343860f, 0.19642124f, 0.34350264f, 0.46251273f, 0.27919057f, 0.21569978f, 
    -0.13797335f, -0.13934313f, -0.08430800f, 0.13181682f, -0.00869908f, 0.00356928f, -0.06858370f, 0.01760067f, 
    -0.09272776f, 0.19877133f, 0.11950609f, -0.13284346f, 0.09964104f, -0.63410622f, -0.26641834f, -0.01446568f, 
    -0.08263912f, -0.04038618f, 0.10721792f, 0.07285097f, 0.23535006f, -0.14565310f, 0.02885408f, -0.04220673f, 
    0.55710560f, 0.26590255f, 0.10936070f, -0.03120819f, -0.10993374f, -0.07134261f, -0.05596453f, -0.12856169f, 
    0.09755334f, 0.08727213f, 0.05975238f, 0.00142036f, 0.30010694f, -0.11816204f, -0.30385110f, -0.24470532f, 
    -0.10703907f, -0.04614956f, 0.03443728f, 0.01982027f, 0.02169107f, 0.11732092f, -0.16714709f, -0.11833617f, 
    0.00688307f, 0.12636088f, 0.01755412f, -0.06999870f, -0.09817614f, 0.01010813f, -0.31575274f, -0.21063982f, 
    -0.05962275f, -0.04102342f, -0.16345343f, -0.12379396f, -0.07424045f, -0.18963990f, 0.06905092f, 0.32036310f, 
    -0.10881928f, -0.14424329f, -0.14704913f, -0.03415281f, 0.01602080f, 0.00328191f, -0.04403000f, -0.02597848f, 
    -0.25362733f, -0.50945050f, -0.60279292f, -0.11329791f, 0.06386404f, -0.08538962f, 0.25369823f, 0.13777877f, 
    -0.05550571f, -0.15827605f, -0.00099523f, 0.03175822f, -0.20009753f, 0.19047937f, 0.13306923f, 0.27780107f, 
    0.01343945f, 0.11755019f, 0.14188100f, 0.13593429f, -0.00499386f, 0.18687019f, 0.19436531f, 0.01652268f, 
    -0.09191837f, 0.24877372f, 0.15992747f, -0.00504322f, -0.11357683f, -0.00797839f, -0.14549097f, 0.01567713f, 
    0.06921724f, -0.03236056f, 0.10431024f, 0.02293129f, 0.02289917f, 0.10561942f, -0.01947442f, 0.03969495f, 
    -0.00000477f, 0.08048500f, 0.03464944f, 0.08747455f, 0.06355882f, -0.06145271f, 0.00286868f, 0.09700113f, 
    -0.30342957f, 0.32435155f, 0.13757767f, 0.26745597f, -0.18656239f, -0.12518993f, 0.00719839f, -0.02227246f, 
    -0.00893030f, -0.08402452f, 0.10412283f, -0.04385684f, 0.28344658f, 0.16564929f, 0.02735762f, -0.19956233f, 
    -0.00260967f, 0.08909021f, 0.12974484f, 0.05466893f, 0.07384368f, -0.01304429f, -0.12382692f, 0.01280787f, 
    0.07016177f, -0.51472557f, 0.06444877f, -0.12398899f, 0.18326616f, -0.01216642f, -0.08884463f, 0.06237468f, 
    0.02905988f, -0.27860567f, -0.17514993f, -0.09872683f, 0.25795665f, 0.20836164f, 0.00331002f, -0.10698991f, 
    0.00893384f, 0.00791775f, -0.03031962f, -0.05549502f, 0.17774375f, 0.01662049f, 0.13236523f, -0.04200668f, 
    0.02051007f, 0.30328712f, 0.21875231f, 0.31606004f, -0.08761705f, -0.03673672f, 0.01448969f, -0.06613328f, 
    0.05832226f, 0.11360677f, 0.13391379f, -0.03599679f, 0.20129097f, -0.12330130f, -0.15314168f, -0.08990233f, 
    -0.03093736f, 0.02967744f, 0.06853825f, 0.10258071f, 0.10104860f, 0.02346323f, 0.02268034f, -0.00927449f, 
    0.20080318f, -0.02844805f, -0.15195414f, 0.02757366f, -0.00417786f, 0.01893306f, 0.15224420f, -0.02853935f, 
    0.11394656f, 0.05669476f, 0.03691166f, -0.08378521f, 0.33635747f, -0.09023109f, 0.03187001f, -0.30006799f, 
    0.02420020f, -0.20725852f, -0.12814423f, -0.01494304f, -0.02638092f, -0.05572518f, 0.22173549f, 0.21425952f, 
    -0.23914546f, 0.02456831f, -0.44022939f, 0.21393488f, 0.02152218f, 0.05814288f, 0.02943455f, -0.01917115f, 
    0.17690383f, -0.04233794f, -0.06042224f, -0.07309376f, 0.38285500f, -0.08187667f, 0.28784478f, 0.06317599f, 
    -0.14717157f, -0.10041887f, -0.10471091f, -0.08886224f, 0.06881206f, 0.12877978f, -0.02978934f, -0.05098186f, 
    0.04574537f, -0.27051401f, 0.38256896f, 0.12312493f, 0.05467596f, -0.04319328f, -0.01496395f, 0.04316643f, 
    0.02994477f, -0.00755814f, -0.07403164f, 0.07815647f, 0.12481651f, -0.09900479f, 0.03629124f, -0.08135259f, 
    0.16273510f, 0.03071659f, 0.12500088f, 0.16273123f, 0.06060855f, 0.00620333f, 0.07712283f, 0.14120430f, 
    0.10880247f, 0.04282681f, 0.07779466f, -0.01123680f, 0.05958775f, 0.19294631f, 0.01917434f, 0.06313988f, 
    0.08058722f, -0.00932505f, 0.20492941f, 0.12673075f, 0.13102752f, 0.17346314f, -0.23208305f, -0.15461668f, 
    -0.02367897f, -0.12131633f, 0.16943870f, 0.16772684f, 0.09402400f, 0.04972190f, -0.08601561f, 0.09132919f, 
    0.15383783f, 0.18210863f, -0.15549698f, 0.10046654f, 0.06570466f, -0.04096867f, 0.07037017f, -0.05777107f, 
    0.05918321f, 0.08559760f, 0.09442580f, 0.10911749f, -0.12728001f, 0.04385033f, -0.11654111f, 0.01332492f, 
    -0.03864530f, -0.10913705f, -0.06330276f, -0.07671900f, 0.24354443f, 0.17500156f, 0.04266826f, -0.12582123f, 
    -0.38873839f, -0.06033767f, -0.17304479f, -0.29999301f, 0.14843720f, -0.01601738f, 0.11098801f, -0.06787299f, 
    -0.02912664f, -0.04326863f, -0.03624093f, -0.19996700f, -0.25666335f, 0.21349232f, -0.11523615f, 0.28510332f, 
    -0.09626328f, -0.12603252f, -0.17168988f, -0.10401121f, 0.12263321f, 0.16160734f, 0.04626727f, 0.00242128f, 
    0.10051126f, -0.25549570f, 0.26533538f, -0.27667814f, -0.01942781f, -0.13375176f, -0.00797774f, -0.10511018f, 
    0.05744815f, -0.14582202f, -0.03090660f, 0.22791193f, 0.00412377f, 0.07723365f, -0.13486335f, 0.16892768f, 
    -0.04253067f, 0.03198800f, -0.01999530f, -0.09092464f, -0.06371360f, 0.07132764f, -0.16828699f, 0.14421441f, 
    0.63976699f, -0.31458277f, -0.20410033f, -0.16105749f, -0.01854956f, 0.04537229f, 0.14067531f, -0.04932510f, 
    -0.02218773f, 0.04660812f, 0.04674610f, -0.15120341f, 0.12626986f, -0.23141006f, -0.03112146f, 0.12579344f, 
    0.07176788f, -0.10620099f, -0.08772647f, 0.21830899f, -0.06411509f, -0.17213152f, 0.07278574f, -0.18245430f, 
    0.00397957f, 0.04526363f, 0.00262128f, 0.02373497f, 0.00314379f, -0.05572511f, -0.02816562f, -0.07515626f, 
    -0.07491577f, -0.07194363f, 0.04737708f, -0.05430199f, -0.01017596f, -0.03151223f, -0.06326235f, 0.05836459f, 
    -0.02109202f, -0.01821841f, 0.05023218f, -0.08136468f, 0.00744423f, -0.03283593f, 0.05597805f, -0.04628021f, 
    -0.07396424f, 0.06342625f, -0.07355347f, 0.00861673f, 0.01306467f, 0.03558184f, 0.00720792f, -0.00398482f, 
    0.06224778f, -0.07799679f, 0.02678983f, 0.00370859f, -0.05735087f, -0.04142265f, -0.04277013f, -0.04550602f, 
    -0.06682104f, 0.01117134f, -0.02030178f, 0.05727486f, -0.03459627f, 0.05425234f, 0.03643372f, -0.02458611f, 
    0.05649717f, -0.04121862f, 0.04328565f, 0.04590444f, -0.06675932f, 0.04801179f, -0.07590042f, -0.06050785f, 
    -0.05141181f, -0.03455248f, -0.08168216f, 0.00279684f, 0.04459527f, 0.00552735f, 0.00831751f, -0.06656410f, 
    -0.06074547f, -0.01904611f, -0.02511218f, -0.05507338f, -0.00591143f, -0.06963353f, -0.01444058f, 0.03461195f, 
    -0.04568339f, 0.05014685f, 0.06178314f, -0.02228360f, -0.00221738f, -0.05659687f, -0.07647696f, 0.02729403f, 
    -0.04942200f, -0.05962079f, 0.04009775f, 0.00505965f, 0.00906947f, 0.02024045f, 0.00536657f, 0.02830908f, 
    -0.07296042f, -0.06940845f, 0.02265351f, -0.00997144f, -0.01174358f, -0.02079429f, -0.00721420f, 0.01668680f, 
    0.04249753f, -0.03842765f, 0.06098607f, -0.05323250f, 0.03702770f, -0.05475519f, 0.03830874f, 0.02467258f, 
    0.03481447f, -0.05922772f, 0.05817930f, -0.04390769f, -0.01989038f, 0.04549950f, -0.07779616f, -0.00017187f, 
    0.04076083f, 0.06262452f, -0.00756866f, -0.05751308f, -0.01589320f, 0.03812779f, -0.03543767f, -0.03987624f, 
    -0.03418919f, 0.01989548f, -0.05757486f, -0.06612911f, -0.02025747f, 0.02570390f, -0.02922081f, -0.05742368f, 
    0.02769170f, -0.03724420f, 0.05825650f, 0.02391584f, -0.07036873f, -0.00527845f, -0.06097795f, 0.03385415f, 
    0.02368072f, 0.01776594f, 0.05225286f, -0.07266915f, -0.03104477f, -0.06487817f, -0.03629843f, 0.00822059f, 
    -0.02641835f, 0.05443736f, -0.00767085f, -0.00434255f, -0.00406454f, 0.04428235f, 0.01057684f, -0.05764620f, 
    -0.06027324f, -0.01519065f, -0.03192373f, 0.01529488f, 0.05216925f, -0.06064321f, -0.06020665f, 0.03511669f, 
    -0.00199972f, 0.01226209f, 0.00784523f, -0.04957258f, -0.04054432f, -0.06374100f, -0.06695344f, -0.02447773f, 
    -0.06660318f, 0.03938786f, -0.03691596f, -0.05903806f, 0.04961232f, 0.05022177f, -0.05780683f, 0.01408735f, 
    -0.00307558f, 0.00536737f, 0.06094706f, 0.03294510f, -0.06178698f, 0.01992986f, -0.04576148f, -0.02100231f, 
    -0.04821675f, -0.02544896f, -0.01173953f, -0.02348832f, -0.06621189f, 0.02320827f, 0.01886638f, 0.01278709f, 
    0.15491299f, 0.22340211f, -0.11518266f, 0.21374273f, 0.15229866f, -0.18923299f, 0.10106380f, 0.22800776f, 
    0.00341636f, 0.09333906f, -0.00096142f, -0.06054288f, 0.24475822f, -0.19796762f, 0.08361342f, -0.22646601f, 
    0.05281543f, -0.12406646f, -0.30600190f, 0.17309375f, -0.02524623f, 0.00495105f, 0.17207676f, 0.01843203f, 
    -0.17926961f, -0.06053220f, -0.34612831f, 0.01923231f, 0.00433218f, -0.03598872f, 0.02934506f, -0.04182739f, 
    0.04641210f, -0.00273333f, -0.15450551f, 0.02642725f, -0.14965481f, 0.40897161f, -0.05794588f, 0.58201581f, 
    0.08706060f, -0.10931001f, -0.11461443f, -0.09715962f, -0.01917188f, -0.08213462f, 0.11398335f, 0.11105968f, 
    -0.22271232f, -0.24298587f, 0.30440396f, 0.12260869f, -0.01956507f, 0.01677979f, 0.09735318f, 0.12329096f, 
    0.00373340f, 0.02270882f, 0.08334559f, 0.01724730f, 0.17710429f, 0.03543599f, 0.04133532f, -0.16903034f, 
    0.10187432f, 0.12779699f, 0.26314858f, -0.05699705f, 0.00715582f, 0.00203433f, 0.07349569f, 0.00344200f, 
    -0.02768829f, 0.06933472f, -0.05602591f, -0.11819033f, -0.03660992f, 0.05786617f, 0.07773600f, 0.05657512f, 
    0.11178800f, 0.03223961f, -0.16907540f, -0.11622965f, 0.31252035f, -0.18317039f, -0.00127964f, -0.21950199f, 
    -0.12072406f, 0.04763987f, 0.16239633f, 0.07355034f, 0.10585520f, 0.18619466f, -0.00721301f, 0.21533994f, 
    0.21188425f, -0.04738822f, -0.06053140f, -0.03417564f, -0.10315719f, -0.06535421f, 0.12244403f, -0.07375728f, 
    -0.19426119f, 0.03328855f, 0.02193622f, -0.11991318f, -0.20979497f, 0.16035847f, -0.10163993f, -0.23446932f, 
    0.06881026f, -0.05453650f, 0.09441400f, 0.01201038f, 0.24079709f, 0.22737989f, -0.00011312f, -0.00665299f, 
    0.09742985f, -0.18166173f, 0.04245201f, -0.17243963f, -0.04530493f, 0.21913846f, -0.10482494f, 0.03111332f, 
    0.07577132f, 0.08619008f, 0.00466658f, 0.00049323f, -0.54419243f, -0.14201175f, 0.12211329f, 0.13362819f, 
    -0.09985875f, -0.10902274f, -0.07818878f, -0.12218675f, 0.11627176f, -0.05454881f, 0.01121794f, -0.00908008f, 
    0.13713448f, -0.33673140f, 0.19480391f, -0.23469916f, 0.01849544f, -0.07700956f, -0.23493929f, 0.23099975f, 
    -0.19985498f, -0.05053500f, -0.14056143f, -0.17406160f, 0.00051516f, 0.09726438f, -0.02263783f, 0.24656042f, 
    0.09425420f, 0.01850842f, -0.01101318f, -0.19553888f, 0.09983348f, 0.23338075f, -0.13806027f, 0.05989341f, 
    0.60234386f, 0.01793139f, -0.07473891f, 0.11175156f, -0.21586064f, -0.01876016f, 0.13678518f, -0.02481647f, 
    0.10221427f, 0.02381355f, -0.06324561f, 0.00660881f, -0.28253245f, 0.04993144f, -0.06980883f, 0.03661459f, 
    0.25796825f, -0.09126943f, 0.25540140f, 0.03421508f, -0.07986648f, -0.04016535f, 0.10176931f, -0.03255399f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21145691f, -0.03546475f, 0.04131063f, -0.00820869f, 0.08885363f, -0.00906422f, 0.05743079f, 0.19810365f, 
    -0.04736970f, 0.05990577f, 0.00500062f, -0.07467668f, -0.09312603f, 0.08264855f, -0.03741766f, -0.12189426f, 
    0.06334637f, -0.04054711f, 0.00926569f, 0.05084909f, 0.22810617f, -0.07523368f, -0.00416726f, -0.13693342f, 
    0.19092458f, -0.06961513f, 0.03902666f, 0.11025207f, 0.13526900f, 0.24369074f, 0.00928618f, 0.09520918f, 
    -0.02069765f, 0.15059923f, 0.12693267f, 0.00922611f, -0.06217123f, 0.03484678f, 0.11828721f, 0.00856527f, 
    -0.09374031f, -0.02480077f, -0.03695008f, 0.09382469f, -0.00619205f, 0.08548650f, 0.04639928f, 0.05147989f, 
    -0.03322442f, -0.08924840f, -0.01977335f, 0.01022910f, 0.12670363f, 0.05670133f, -0.03265852f, -0.04238646f, 
    0.17144449f, -0.07345729f, 0.04751475f, 0.11506416f, -0.01262331f, 0.05403379f, 0.04633735f, 0.13286661f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.51693273f, 0.29706869f, -0.21356776f, 0.27523115f, -0.19599342f, 0.23942691f, 0.09787706f, -0.30999568f, 
    0.02949795f, 0.05990944f, -0.53537309f, -0.06625056f, -0.00549565f, 0.30959424f, 0.04521796f, 0.35110784f, 
    -0.56567645f, 0.00089647f, -0.11724223f, -0.13526396f, -0.23269747f, -0.07623871f, 0.02073859f, 0.11330765f, 
    -0.70735788f, 0.09820171f, -0.10676387f, 0.23291086f, 0.11511432f, -0.24283975f, -0.09962208f, -0.13642153f, 
    0.10248099f, -0.17006691f, 0.05160316f, -0.54244041f, 0.07620997f, -0.08591359f, 0.28524384f, 0.01806082f, 
    -0.08088595f, -0.82419944f, 0.05321721f, -0.33060363f, 0.09539887f, -0.31804398f, -0.51584446f, 0.06208155f, 
    0.06844006f, 0.31029660f, 0.15892211f, 0.18727301f, 0.07718604f, -0.07231862f, 0.07256307f, -0.07360610f, 
    -0.52140599f, -0.01691270f, 0.12913884f, -0.05887776f, -0.00898977f, -0.06309282f, -0.04318818f, -0.13214754f, 
    -0.12281219f, 0.14600523f, -0.18851000f, 0.16447178f, 0.46518311f, -0.00275210f, -0.05132074f, -0.40167832f, 
    -0.66432172f, 0.53720313f, 0.06562097f, -0.01745423f, 0.27805230f, 0.14385925f, -0.04015518f, -1.07260060f, 
    -0.29990378f, -0.13473099f, 0.05683492f, -0.00044340f, 0.28417522f, 0.10634406f, -0.02944343f, -0.05060547f, 
    0.19075018f, 0.01653669f, -0.11232354f, 0.15889430f, -0.43116170f, 0.19827510f, -0.04830225f, 0.15559137f, 
    0.01691263f, 0.32368630f, 0.17307985f, -0.62348896f, -0.28379390f, 0.09787925f, 0.17996953f, -0.11782133f, 
    -0.26910391f, -0.14451210f, 0.00174725f, 0.06073318f, -0.01826318f, -0.17292660f, 0.47682068f, -0.05349037f, 
    0.05430092f, 0.20087942f, 0.18268533f, 0.14287187f, -0.21926437f, -0.04598563f, 0.09337969f, 0.01309461f, 
    0.16720042f, -0.01713424f, -0.27450281f, 0.30412856f, 0.14484559f, -0.03347252f, 0.09056208f, 0.15006845f, 
    -0.11418760f, -0.39682820f, -0.09418389f, -0.83597445f, -0.88903904f, 0.05875369f, 0.01853912f, 0.15417628f, 
    0.18286657f, 0.31866735f, 0.09769722f, -0.13356872f, -0.13235787f, -0.38790199f, 0.03524210f, -0.37389573f, 
    0.24540816f, 0.02768582f, -0.03435006f, 0.08978265f, -0.01634714f, -0.05222498f, -0.00435773f, -0.43016049f, 
    0.09283096f, 0.02569806f, -0.04264040f, 0.18478058f, -0.28544927f, 0.11883678f, -0.01842805f, -0.04696847f, 
    0.04656773f, 0.26765049f, -0.02165612f, 0.25352797f, -0.36309603f, 0.04932226f, 0.00947397f, -0.51430535f, 
    0.02765256f, 0.08868193f, 0.09489563f, 0.05846971f, 0.01847409f, 0.22134605f, -0.16272864f, 0.03043467f, 
    -0.05857035f, -0.53742218f, 0.04709584f, 0.21497032f, 0.03338977f, -0.06902571f, -0.02410802f, -0.07647233f, 
    0.48819134f, -0.09443247f, 0.11558109f, -0.23971307f, -0.44392124f, -0.16871272f, 0.07365308f, -0.27991417f, 
    -0.03185901f, -0.05754626f, 0.01341483f, 0.02820625f, -0.30594993f, 0.12189370f, -0.03058340f, -0.12611924f, 
    0.10422718f, 0.08340961f, 0.31956777f, -0.04985321f, 0.15286039f, -0.49424183f, 0.10926784f, 0.13477127f, 
    0.05854755f, 0.03721244f, 0.07538224f, 0.12139098f, -0.43641537f, 0.06140589f, 0.08690791f, 0.26508847f, 
    -0.01671673f, 0.08358222f, 0.09657468f, 0.26945406f, -0.22475681f, -0.34899664f, -0.12161641f, -0.16830905f, 
    0.11121834f, 0.04282388f, -0.70929688f, 0.18062951f, 0.40043038f, -0.01216787f, -0.44163948f, 0.06378110f, 
    0.37229860f, 0.06903791f, 0.06170734f, -0.34515998f, -0.00807272f, 0.04439378f, -0.02179872f, 0.13577384f, 
    -0.03351112f, 0.12521835f, 0.01893525f, 0.21494119f, -0.57387537f, 0.08432399f, 0.08683004f, 0.08055988f, 
    0.15070522f, 0.10218138f, -0.27455014f, 0.18100086f, 0.01963258f, -0.59086049f, -0.09025003f, -0.57173020f, 
    -0.01782945f, 0.22415704f, -0.16221169f, -0.10346746f, -0.21972884f, 0.13303021f, -0.01959038f, -0.23370488f, 
    0.35130146f, 0.03244617f, -0.73927045f, 0.08179316f, 0.25526997f, -0.01690419f, -0.09731153f, 0.19398807f, 
    -0.08108167f, -0.01526543f, -0.11664715f, 0.14784515f, -0.50675374f, 0.09901985f, 0.11097180f, 0.00736793f, 
    0.03760835f, -0.12703556f, -0.03104655f, -0.31928891f, -0.28962749f, 0.03100183f, -0.04627694f, -0.08974197f, 
    -0.09227837f, -0.36923856f, -0.05065557f, 0.18487146f, -0.10694776f, 0.01177563f, 0.04632051f, 0.25749159f, 
    -0.05964783f, 0.11943251f, 0.04447054f, 0.12984581f, 0.11597694f, -0.12415570f, -0.85710245f, 0.23341754f, 
    -0.00836377f, -0.19731104f, 0.10984547f, -0.11349012f, 0.05663396f, 0.01258806f, -0.06718078f, 0.05101527f, 
    -0.50440246f, -0.09107324f, 0.26863545f, -0.79034799f, 0.18959597f, 0.19150962f, -0.08137257f, -0.01868738f, 
    0.30572066f, -0.05705069f, 0.29417360f, 0.22583878f, -0.10355735f, 0.02443877f, 0.07615037f, 0.33529201f, 
    -0.13193068f, -0.44462514f, 0.06726260f, 0.08014791f, -0.04560077f, 0.31853664f, 0.05376168f, -0.24447398f, 
    0.11211795f, -0.04048598f, -0.09875835f, -0.11168208f, -0.23013180f, -0.03991945f, 0.03725354f, -0.15477055f, 
    0.20713079f, 0.06581818f, 0.03981062f, 0.05142026f, 0.01069997f, 0.16691993f, -0.08580321f, 0.23727912f, 
    0.10081982f, 0.24073820f, -0.03842548f, -0.40082958f, -0.20684576f, -0.11992760f, 0.31134945f, 0.32959613f, 
    -0.27638268f, -0.50541806f, -0.12117872f, -0.29694977f, 0.07659587f, -0.30870453f, -0.49266139f, 0.20526206f, 
    -0.05344076f, -0.49925631f, -0.02877293f, -0.16827989f, -0.00321972f, 0.09198003f, -0.02668239f, -0.06634609f, 
    -0.11668935f, -0.01999407f, 0.19995904f, -0.05427412f, -0.28683972f, 0.10746264f, -0.02389763f, 0.25847238f, 
    0.21944676f, -0.59462476f, 0.12671986f, -0.41112944f, 0.41449627f, -0.22922443f, 0.09489347f, -0.09809691f, 
    0.13642374f, -0.71475822f, 0.00699507f, -0.10703985f, -0.39494437f, -0.56946111f, -0.12002552f, 0.13983950f, 
    0.17602701f, 0.08769911f, -0.05631318f, 0.06965020f, 0.29688892f, -0.01885010f, 0.04833296f, -0.46558157f, 
    0.05518782f, 0.10121363f, 0.09535933f, -0.62337327f, 0.07627020f, 0.15008228f, -0.07145125f, 0.19373445f, 
    0.00823749f, -0.95012122f, 0.09516895f, 0.24110207f, -0.06468663f, -0.00312326f, 0.12107673f, -0.58185297f, 
    -0.24375975f, 0.06621916f, -0.07416324f, 0.21289386f, 0.01119576f, 0.01658839f, 0.26482549f, -0.46601355f, 
    0.11370663f, -0.14064008f, -0.81416714f, 0.04217788f, -0.00272383f, 0.03529111f, -0.09954355f, -0.06515653f, 
    0.23490323f, 0.02068739f, 0.09233022f, 0.37113604f, -0.14182445f, 0.19673419f, -0.04830062f, -0.08095384f, 
    -0.31078720f, -0.53840458f, 0.00911468f, -0.24669446f, -0.31645757f, -0.28420103f, 0.05585755f, 0.20946339f, 
    0.25501922f, 0.13921073f, 0.08486056f, 0.09034096f, 0.10242042f, -0.26740175f, -0.06023894f, 0.39242733f, 
    0.05019012f, 0.01078840f, -0.00577130f, -0.70454705f, -0.05651571f, -0.04280732f, -0.03850264f, 0.09436348f, 
    0.09356606f, -0.10710695f, -0.05158875f, 0.08409271f, -0.23465788f, -0.47815755f, -0.01215014f, 0.15367009f, 
    -0.03097552f, 0.39223203f, -0.00755349f, -0.04340963f, -0.62132287f, -0.03621823f, -0.02156800f, 0.02493411f, 
    0.26890931f, 0.00608264f, 0.07191809f, 0.05347784f, -0.02649807f, 0.29641861f, 0.09106258f, 0.02916819f, 
    0.02911692f, 0.34749660f, -0.41021338f, -0.45403132f, 0.07922545f, -0.11138732f, 0.09872662f, -0.03589816f, 
    -0.41000298f, -0.09355029f, -0.38586777f, 0.22426774f, 0.24000117f, 0.08523514f, 0.03704422f, -0.38677207f, 
    -0.15164578f, -0.21965060f, 0.11948734f, 0.01355322f, -0.36752078f, 0.03407502f, -0.08219685f, 0.38900623f, 
    -0.43740365f, 0.17182156f, 0.16032584f, -0.10183257f, -0.30783537f, 0.16540563f, 0.04829735f, -0.02431003f, 
    -0.09328326f, -0.05107681f, 0.05946461f, -0.10391255f, 0.09729094f, 0.11038782f, -0.07636798f, -0.11826254f, 
    0.13759178f, 0.10034043f, 0.11463113f, 0.36545837f, 0.45929244f, -0.25795785f, -0.07533508f, -0.13639049f, 
    0.01809054f, 0.34016609f, -0.28312957f, -0.31287020f, 0.26739556f, 0.01461869f, -0.13577226f, 0.12782685f, 
    -0.08451635f, 0.17524195f, -0.10534630f, -0.29253379f, 0.01931280f, 0.03690000f, -0.24672569f, -0.69905883f, 
    0.08304119f, -0.27378491f, -0.69288176f, 0.19068496f, 0.38922521f, 0.06341877f, -0.03784825f, -0.01197147f, 
    0.20090646f, 0.08037862f, -0.11687540f, 0.18247762f, 0.27884600f, 0.02884370f, 0.02814491f, -0.22580855f, 
    -0.06776585f, 0.32738093f, -0.13186456f, 0.07363064f, 0.09108801f, -0.24629305f, -0.05600869f, -0.62624240f, 
    0.31352532f, -0.25630733f, 0.27565917f, -0.10101820f, 0.25047117f, 0.15120058f, -0.01208383f, -0.31830081f, 
    0.10783602f, 0.06172536f, 0.06828457f, -0.23224272f, -0.08980816f, 0.00550478f, 0.06472591f, -0.55565828f, 
    0.18897812f, -0.03757755f, 0.07898436f, -0.66474235f, -0.26677096f, -0.33325776f, 0.09042841f, -0.44127548f, 
    -0.07325206f, 0.01730910f, 0.25497574f, 0.18560553f, -0.12328756f, -0.06183741f, -0.16500261f, -0.41786990f, 
    -0.59183931f, 0.14079881f, -0.03881848f, 0.10530701f, -0.02368352f, 0.15937322f, 0.06635631f, 0.03792594f, 
    0.04785353f, 0.38390052f, 0.02000078f, 0.06388441f, 0.21662030f, -0.02655644f, 0.10016213f, 0.02751556f, 
    -0.85697889f, 0.02348626f, 0.08617884f, -0.39192596f, -0.06217254f, 0.45818093f, -0.10034589f, 0.42898694f, 
    -0.02035555f, 0.09966124f, -0.43714133f, 0.20592867f, -0.32794642f, -0.14531240f, -0.03391596f, 0.48118562f, 
    -0.35160112f, -0.55732620f, -0.30310741f, -0.06981867f, -0.22290879f, -0.36176917f, -0.08986209f, -0.79161447f, 
    -0.10199466f, -0.05291917f, -0.06377780f, 0.35186949f, 0.13792889f, 0.00413431f, -0.09168263f, 0.28807771f, 
    -0.07859979f, -0.11133357f, -0.07789181f, -0.18981391f, 0.33805919f, 0.27865189f, 0.02540556f, -0.07883472f, 
    -0.03179018f, -0.01473673f, 0.15368785f, -0.03682365f, 0.22753079f, -0.03527441f, -0.72736526f, 0.20695885f, 
    0.27611342f, 0.02986457f, -0.04388423f, 0.31336585f, -0.02554636f, -0.12840876f, -0.24799187f, 0.04923828f, 
    0.01078942f, -0.63996053f, -0.41968510f, -0.28226498f, -0.34204936f, -0.01418271f, 0.02400403f, 0.02148081f, 
    0.27973756f, 0.07752973f, 0.16062196f, 0.61549914f, -0.53762013f, -0.53178066f, -0.07543352f, 0.30188870f, 
    0.31859380f, -0.48045853f, 0.17423297f, -0.41823459f, -0.04643610f, -0.39623123f, 0.04667621f, -0.03285991f, 
    -0.32533976f, 0.10583852f, -0.00471424f, -0.06692964f, -0.30234367f, 0.38375506f, -0.02894733f, 0.15013380f, 
    -0.00554790f, 0.11203358f, 0.09308636f, -0.57440478f, 0.22945656f, -0.07444428f, 0.03331849f, 0.33736134f, 
    0.06875917f, 0.00580404f, -0.01940121f, 0.10943078f, 0.20122987f, 0.49236292f, -0.00949997f, -0.07964267f, 
    -0.02869512f, -0.65811133f, -0.42049539f, 0.26451826f, 0.18166278f, 0.10102417f, -0.26135147f, -0.01841996f, 
    0.29756656f, 0.22834483f, 0.10742880f, -0.17189214f, 0.10462164f, 0.07460786f, 0.25983018f, -0.39981949f, 
    0.09327255f, 0.00267827f, 0.04214422f, 0.14328076f, -0.55811650f, 0.03956082f, 0.08697444f, 0.07742392f, 
    0.21146333f, 0.09516120f, -0.18323974f, -0.46997339f, -0.04476035f, -0.27636072f, 0.02808070f, 0.33866772f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.10247688f, 0.02243531f, -0.03686858f, -0.09175487f, -0.04186724f, 0.15342335f, -0.04851590f, -0.14250107f, 
    -0.02178534f, -0.00644106f, 0.11155525f, -0.01666868f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
