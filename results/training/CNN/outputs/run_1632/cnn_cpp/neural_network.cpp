#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.56676263f, -0.52871436f, 0.06446825f, 0.79233497f, -0.70524621f, 0.05328839f, 0.05670917f, -0.08167564f, 
    0.24257661f, 0.51563948f, 0.53132141f, -0.35966697f, -0.67727047f, -0.74305785f, -0.54021966f, -0.33640352f, 
    -0.50692642f, -0.44441655f, 0.55109221f, 0.10329247f, 0.01377650f, 0.11834686f, 0.64040333f, 0.44619375f, 
    -0.47641113f, -0.54662246f, -0.61220080f, -1.20904076f, 1.15261662f, -0.09350763f, -0.68854159f, 0.70251381f, 
    -0.57960087f, 0.09574599f, 0.14738096f, -0.36554673f, -0.84707272f, -0.70860302f, -0.21091895f, -0.79416913f, 
    -0.77360958f, 0.23262961f, 0.24597956f, 0.46854767f, -0.33908153f, -0.67733985f, -0.22060131f, 0.11851505f, 
    0.79032242f, 0.40036473f, 0.29335141f, 0.39347783f, 0.19730040f, -0.29149842f, 0.94046402f, -0.78515261f, 
    -1.03581548f, 0.20560490f, 0.87368435f, 0.05413252f, -0.09282802f, -0.16111432f, -0.43999660f, -0.52305353f, 
    0.54417461f, 0.67208958f, -0.46442625f, -0.48004448f, 0.47462261f, -0.40407085f, -0.32091326f, 0.63544101f, 
    0.57912588f, 0.62856036f, 0.16241781f, 0.24623907f, -0.82012117f, 0.45607084f, -0.11170133f, 0.03138066f, 
    -0.18288113f, 0.40193361f, -0.68563443f, -0.64503986f, 0.17856486f, 0.44670382f, 0.39409965f, -0.58095187f, 
    0.58544481f, 0.28372094f, 0.61373883f, 0.96668577f, 0.01648083f, -0.71948099f, -0.27332848f, 0.01702139f, 
    -0.14918694f, 0.46079266f, -0.13457708f, -0.01805026f, 0.57562900f, 0.79331863f, -0.78019279f, -0.64334667f, 
    -0.26379192f, 0.42465311f, 0.03254335f, 0.53599620f, 0.36171967f, -0.09354003f, 0.37765703f, 0.29030034f, 
    0.08509489f, 0.46439606f, 0.05408965f, 0.32175443f, -0.35392514f, 0.33230177f, -0.40291709f, -0.65110517f, 
    -0.13355617f, -0.18161175f, -0.81002259f, 0.57883447f, 0.80639434f, 0.40645704f, -0.60443813f, -0.41233045f, 
    -0.07102108f, -0.04087337f, -0.50934869f, -0.24186343f, -0.45756271f, -0.51921314f, -0.46241942f, -0.96585357f, 
    -0.95457095f, -0.16114211f, 0.54859215f, 0.47646451f, -0.54622984f, -0.30614302f, -0.43605185f, 0.02643698f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04593301f, -0.18472797f, 0.04736106f, 0.08677418f, 0.36978066f, -0.24686091f, -0.03525824f, -0.09064756f, 
    0.18675166f, 0.10017242f, 0.30796206f, 0.00796152f, -0.06614483f, 0.02086850f, -0.21150410f, -0.07885699f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21788041f, 0.02788296f, -0.04960875f, -0.23822913f, 0.12292685f, 0.01448007f, -0.07397349f, -0.15923588f, 
    -0.09576894f, -0.12161883f, 0.11076074f, 0.21579207f, 0.16274826f, -0.01064854f, -0.00703796f, 0.02935877f, 
    0.15792243f, 0.08399193f, 0.00686997f, 0.11377410f, -0.19975874f, 0.38506946f, -0.04426033f, -0.36906898f, 
    -0.64086759f, -0.03512352f, -0.16789404f, -0.09031659f, -0.18654056f, 0.09860829f, 0.03841261f, -0.05735467f, 
    -0.05016501f, 0.05622445f, -0.01316127f, -0.07899412f, -0.06983578f, 0.04501624f, -0.03794727f, -0.03476525f, 
    0.40397587f, 0.00151832f, 0.21008679f, 0.31251088f, 0.18864828f, -0.13545388f, -0.10267802f, 0.01077104f, 
    -0.02024415f, -0.03166688f, -0.11996939f, 0.09987397f, 0.09640186f, -0.03035010f, -0.06165745f, 0.05988488f, 
    0.01122515f, 0.00354142f, 0.10309450f, 0.12239021f, -0.32456052f, 0.00374089f, 0.12633193f, -0.35952353f, 
    -0.12647016f, 0.09976527f, 0.13985807f, -0.35427842f, 0.04712597f, 0.10215609f, 0.03088586f, 0.06132016f, 
    0.12868762f, 0.14693731f, -0.00181731f, 0.00546963f, 0.02152877f, -0.11113048f, -0.06751389f, -0.13769293f, 
    -0.06311609f, 0.11003210f, -0.04752415f, -0.09754315f, -0.09758889f, 0.02087289f, 0.10870945f, 0.18420140f, 
    -0.01625002f, 0.14859888f, 0.02187725f, 0.07525042f, 0.01261666f, 0.02610830f, 0.00542254f, 0.12489934f, 
    0.06316543f, 0.06018128f, -0.15843445f, -0.08534247f, 0.12040796f, -0.11798408f, -0.02699138f, 0.09414806f, 
    -0.03543047f, -0.29329893f, -0.05789375f, -0.14023858f, 0.01512249f, -0.20217748f, 0.09777424f, 0.10156442f, 
    0.03561231f, 0.00356791f, 0.09731619f, 0.06412025f, 0.07944548f, -0.10482801f, 0.06978659f, -0.03927397f, 
    0.56854624f, -0.27109569f, 0.03899824f, -0.09053463f, -0.24196696f, 0.05851661f, -0.13497789f, 0.14126024f, 
    -0.04516236f, 0.11057164f, 0.19491719f, -0.11107998f, 0.02104801f, -0.07159856f, 0.09910108f, 0.10594738f, 
    -0.03502521f, -0.08613025f, -0.07352561f, 0.09171848f, -0.46353808f, 0.34793589f, -0.32563874f, 0.26550975f, 
    -0.09278411f, 0.30739388f, -0.17295641f, 0.19170871f, -0.13520779f, -0.03701894f, -0.00694503f, 0.00193765f, 
    0.00608712f, -0.01978699f, -0.13392563f, 0.07002833f, 0.11151338f, 0.16007480f, -0.06512675f, -0.08895263f, 
    -0.16918387f, 0.11742336f, -0.01553895f, -0.11660817f, 0.14644435f, -0.05578214f, -0.09074384f, 0.11002970f, 
    -0.02163124f, -0.09982106f, -0.04249369f, -0.01766931f, -0.01171148f, 0.12550883f, -0.04249899f, 0.03771397f, 
    0.03010027f, -0.17391226f, 0.16407163f, -0.06672236f, 0.44765040f, -0.36665976f, -0.04671469f, -0.02423534f, 
    -0.15853149f, -0.06770252f, 0.02151402f, 0.09441902f, -0.12840135f, -0.06184099f, 0.07158095f, 0.12208238f, 
    0.09947564f, 0.09332026f, -0.09066945f, -0.05920728f, 0.17216209f, -0.00055672f, 0.24948768f, 0.06671702f, 
    -0.14267941f, 0.13169599f, -0.26025078f, -0.13730030f, -0.01897335f, -0.06876524f, -0.10491632f, -0.04762364f, 
    0.03410567f, -0.03245019f, 0.09036367f, -0.06758240f, -0.08350684f, 0.11984953f, -0.07001115f, 0.03548018f, 
    0.12756534f, -0.16404915f, 0.19102375f, 0.06552495f, 0.05782878f, 0.15179482f, -0.27065778f, -0.07489283f, 
    -0.11554238f, -0.00429502f, -0.04418661f, -0.04708115f, 0.04551599f, -0.04758200f, -0.01952130f, -0.16939105f, 
    0.00134747f, 0.06347035f, -0.09886717f, 0.13147578f, 0.12600340f, 0.11163265f, 0.21487314f, -0.00441548f, 
    0.21158747f, 0.08217622f, 0.08491095f, 0.03465344f, 0.07367647f, -0.21682058f, 0.02271644f, -0.03210799f, 
    -0.06348988f, -0.19802670f, 0.05434024f, 0.05791021f, -0.03779500f, 0.00205530f, -0.04407536f, 0.00823229f, 
    -0.08614722f, -0.01125738f, 0.01350734f, 0.00946823f, -0.03010995f, -0.01024017f, -0.10892537f, -0.10057649f, 
    -0.26402903f, -0.04417245f, 0.04709702f, -0.09868915f, 0.12908995f, 0.00669474f, 0.11722817f, 0.10682483f, 
    -0.07256389f, 0.21642624f, 0.02743254f, -0.04891399f, 0.14062625f, 0.01688486f, 0.07791471f, 0.22763100f, 
    0.24405307f, 0.21841174f, 0.21305135f, -0.10485703f, -0.10638014f, 0.20202111f, 0.02402534f, -0.01291065f, 
    0.02895181f, 0.01350667f, 0.15121005f, 0.00776741f, 0.11237876f, -0.09132606f, -0.10300031f, -0.24435334f, 
    -0.10503908f, 0.07556079f, 0.05245571f, -0.05714444f, 0.39915863f, 0.13620013f, 0.05480317f, -0.12001682f, 
    -0.12237767f, -0.01063241f, 0.09971701f, 0.01248779f, 0.27562869f, -0.03997517f, 0.19296509f, -0.05884348f, 
    -0.00576731f, -0.06693341f, -0.08318295f, 0.21676964f, -0.03536165f, 0.03480328f, 0.07153293f, 0.00497569f, 
    -0.01769172f, -0.14095843f, -0.12327294f, 0.12176012f, 0.06921662f, -0.06220942f, -0.06456241f, -0.05683268f, 
    0.19892277f, 0.03016652f, -0.08137050f, -0.06590631f, 0.03265453f, 0.17557979f, 0.01629239f, -0.17938559f, 
    -0.07703559f, -0.13829315f, 0.19084880f, 0.11230297f, 0.06545476f, 0.59982151f, 0.11096653f, 0.12120686f, 
    -0.11746927f, 0.14506425f, 0.13355368f, -0.06487193f, 0.03972924f, 0.08207948f, -0.01214311f, 0.04018278f, 
    0.11352964f, -0.00583724f, -0.19331500f, 0.13379580f, 0.13182023f, 0.04684035f, -0.06210072f, 0.05801967f, 
    -0.02183053f, -0.26256812f, -0.01997887f, 0.05594241f, -0.27463943f, -0.06068291f, -0.11765346f, -0.22690487f, 
    -0.02763196f, 0.07558010f, 0.16383889f, 0.14454886f, 0.08679106f, 0.18499531f, 0.01707454f, -0.09781394f, 
    -0.01928376f, 0.01200928f, 0.01089629f, 0.03996048f, -0.12151234f, -0.01022017f, 0.36891025f, 0.47926718f, 
    -0.14524888f, 0.14248091f, -0.12174010f, 0.09203819f, 0.22558178f, 0.22221255f, 0.08995320f, 0.01191564f, 
    -0.00604445f, 0.01297003f, -0.18727979f, 0.12766288f, 0.03936042f, 0.06635585f, -0.11200055f, 0.12489314f, 
    0.04796569f, 0.30188361f, 0.32196462f, 0.07447871f, 0.15360817f, -0.09297226f, -0.06820833f, 0.03517953f, 
    0.02808250f, 0.08783922f, 0.03109296f, 0.03439748f, -0.06778421f, -0.01369464f, 0.00612799f, 0.03267126f, 
    0.03281866f, -0.16769384f, 0.07234295f, -0.00444305f, 0.31236812f, 0.08248941f, -0.06533846f, -0.03074223f, 
    0.05488091f, -0.31500682f, -0.25096011f, -0.17062062f, -0.05857315f, 0.07210350f, 0.01745186f, 0.05774198f, 
    0.04260790f, 0.11374836f, 0.04714018f, 0.15385525f, -0.07504053f, 0.12006267f, -0.12987031f, -0.04326637f, 
    0.24250542f, -0.02520008f, 0.00035080f, 0.23589790f, -0.16463543f, 0.07678460f, -0.04887933f, 0.15696800f, 
    -0.02478794f, 0.23808929f, 0.17773160f, 0.02471535f, -0.16312243f, 0.09624366f, 0.06758074f, -0.13364853f, 
    -0.02508710f, 0.02581180f, -0.05511866f, -0.08438871f, -0.61650163f, -0.51618868f, -0.02970278f, 0.07074051f, 
    -0.13086677f, -0.02820041f, 0.00209800f, -0.03521421f, 0.10418899f, -0.01477787f, 0.01244233f, -0.10774949f, 
    0.05848163f, 0.02216640f, -0.12745294f, -0.08830650f, 0.11631493f, 0.01075951f, 0.03757827f, 0.07167684f, 
    -0.02182075f, -0.35025269f, -0.45452723f, -0.02779864f, -0.15698749f, 0.01359968f, 0.02812107f, 0.01335270f, 
    -0.02817151f, -0.23498477f, -0.08465461f, -0.09065082f, 0.16159153f, -0.08886886f, 0.06085281f, -0.07461420f, 
    -0.07112014f, -0.04050394f, 0.05797163f, 0.14484592f, 0.08541854f, -0.31720555f, -0.13082200f, -0.03779947f, 
    -0.35278612f, -0.21711276f, -0.14473321f, -0.05362642f, 0.13222036f, -0.04118261f, 0.05080613f, -0.06221255f, 
    0.02667571f, -0.05633321f, 0.01634642f, 0.01757060f, 0.11110139f, 0.00030441f, 0.10851754f, -0.08534721f, 
    -0.29330423f, -0.35623178f, -0.56374866f, -0.09740958f, -0.34882751f, 0.13714336f, 0.03923097f, 0.01076805f, 
    -0.05312547f, 0.01518507f, -0.08840962f, -0.06926135f, 0.13554941f, -0.11957540f, 0.02766907f, -0.06187189f, 
    0.07362600f, 0.09402057f, -0.07700976f, 0.11658636f, -0.65453380f, -0.26872218f, 0.06683509f, 0.13513036f, 
    -0.22967839f, -0.07867395f, 0.01308822f, -0.03240128f, -0.08093714f, 0.06471188f, -0.21689238f, 0.00852098f, 
    0.02807335f, 0.07756563f, 0.06454216f, 0.03952733f, 0.00985269f, 0.01666587f, 0.05081832f, 0.15765531f, 
    0.20042923f, -0.23615742f, -0.19361660f, -0.20835300f, -0.19506063f, -0.11190701f, -0.14264366f, -0.01736520f, 
    0.02017456f, -0.05381970f, 0.02135154f, 0.11906892f, -0.01860552f, 0.07190190f, 0.13291931f, 0.10378016f, 
    -0.09717723f, 0.02359453f, 0.08766168f, 0.19189465f, 0.35244754f, 0.36669210f, 0.28937909f, 0.14074269f, 
    0.11242483f, -0.01619808f, -0.09684589f, 0.03757011f, 0.04345330f, 0.19141932f, 0.02161380f, 0.00365069f, 
    0.04601493f, 0.07676324f, 0.17781471f, -0.08725677f, -0.11493535f, -0.21030526f, 0.04878882f, -0.02933549f, 
    0.01910350f, 0.09222122f, 0.28390485f, 0.11010224f, 0.09024420f, 0.11501467f, 0.22575594f, 0.10071304f, 
    0.04176964f, -0.00986334f, 0.16859527f, 0.04187401f, -0.02887228f, 0.10026529f, -0.01848666f, 0.08285531f, 
    0.07736099f, -0.06538437f, 0.04414254f, 0.18992266f, 0.38239267f, -0.02909412f, 0.34988919f, -0.01985035f, 
    0.08034923f, -0.09375540f, 0.05578020f, 0.12767972f, 0.10324198f, -0.08874145f, 0.14132690f, 0.05758777f, 
    -0.01704343f, -0.07498494f, 0.00036803f, 0.01287227f, 0.00452149f, 0.06806968f, 0.02050706f, -0.04434077f, 
    0.14839861f, 0.19465636f, 0.04192258f, -0.08007434f, -0.11481740f, 0.01493385f, -0.04448501f, 0.16780831f, 
    0.07252336f, -0.07887446f, 0.00335168f, 0.02373191f, 0.12678441f, -0.12232714f, -0.11256131f, 0.01691608f, 
    0.06598988f, 0.07293791f, -0.04702854f, -0.17792602f, -0.10284474f, -0.00689279f, -0.43461469f, -0.33095270f, 
    -0.46158001f, -0.08754243f, -0.09580470f, 0.00214405f, -0.11341494f, -0.14590402f, -0.13100187f, 0.02919164f, 
    0.00343595f, 0.01938258f, 0.13585690f, -0.09057328f, 0.02932125f, 0.14559960f, 0.11191630f, 0.00815968f, 
    0.15655719f, -0.24371658f, -0.15950668f, -0.15734945f, 0.32221991f, -0.10596349f, 0.00293162f, -0.01141131f, 
    -0.05435675f, -0.08606563f, -0.05038304f, -0.04361248f, 0.04744588f, 0.07572914f, -0.17045943f, 0.13527520f, 
    0.02656404f, 0.01237134f, 0.09987756f, 0.12587199f, -0.97013217f, -0.29135752f, 0.01450714f, -0.25292102f, 
    0.27348000f, -0.10835224f, 0.17025411f, -0.27208877f, 0.02836891f, 0.28899989f, 0.13185556f, -0.00519740f, 
    0.08545751f, 0.10550374f, 0.12656188f, 0.00719514f, 0.12302579f, 0.01646496f, 0.24775499f, 0.02641721f, 
    -0.46587852f, 0.14611638f, 0.24280784f, 0.06992861f, -0.08256346f, 0.02917784f, -0.04979469f, 0.09275256f, 
    0.06840272f, 0.02434128f, -0.05555567f, 0.04573006f, 0.04973737f, -0.03153647f, -0.00771793f, 0.14646177f, 
    0.04198151f, 0.02435333f, 0.13561665f, -0.07700777f, -0.17389154f, -0.14142706f, 0.09383032f, 0.15723650f, 
    -0.08807158f, -0.11065518f, -0.05958033f, -0.14288577f, -0.13081717f, -0.09668966f, -0.12458463f, 0.07118619f, 
    0.15376858f, 0.04818919f, -0.04349010f, 0.12917598f, 0.02932410f, -0.07625391f, -0.01593020f, -0.08183303f, 
    0.47012877f, 0.06393905f, 0.01824675f, 0.23711115f, -0.51025879f, 0.14588523f, 0.09974737f, -0.08933189f, 
    0.26732656f, -0.07794295f, 0.12725432f, 0.08776583f, 0.26641613f, -0.03118309f, 0.06555631f, 0.18015058f, 
    0.02327638f, 0.11363962f, 0.01363502f, 0.12092578f, -0.17284323f, 0.12505099f, -0.32398710f, -0.21680406f, 
    0.34267265f, 0.11831762f, -0.02541164f, 0.20592818f, 0.03456918f, 0.12856986f, 0.04907861f, 0.01852257f, 
    -0.10481784f, 0.01632784f, -0.01215721f, -0.11215556f, 0.37237543f, -0.13679816f, 0.02747253f, -0.03680611f, 
    0.48234457f, -0.11163335f, -0.01584846f, -0.06487385f, 0.05335663f, -0.06638435f, 0.06040097f, 0.15201473f, 
    0.04150104f, -0.02225550f, -0.03517845f, 0.00012138f, 0.00996281f, -0.00141886f, -0.05960244f, 0.01627353f, 
    0.10412834f, -0.13389298f, 0.06383555f, -0.01589815f, 0.23588356f, 0.22828104f, 0.08719507f, 0.01518907f, 
    -0.09765434f, -0.04576089f, -0.02121684f, -0.17638743f, -0.10135686f, -0.00419629f, -0.07792825f, 0.10165942f, 
    0.17973459f, 0.03830415f, 0.02062319f, 0.03064509f, -0.00043905f, -0.01374140f, -0.05872140f, -0.02791952f, 
    0.44241148f, -0.08240077f, -0.19014986f, -0.15707827f, 0.09053935f, -0.06885349f, -0.02217364f, 0.07968373f, 
    0.13243440f, 0.08282537f, -0.00796782f, -0.05459053f, -0.06670535f, 0.07261875f, -0.06716739f, -0.07976639f, 
    0.03266123f, -0.21717888f, 0.19934756f, 0.11189930f, 0.36164317f, 0.07504618f, -0.22061379f, -0.34303391f, 
    0.24089842f, 0.03346594f, 0.06754439f, 0.10347819f, 0.08944980f, -0.04998173f, -0.06166727f, -0.06087235f, 
    -0.07241148f, 0.02539638f, 0.04998793f, 0.02575453f, 0.02584124f, -0.02918469f, 0.08548231f, -0.00553936f, 
    0.19262488f, 0.02238360f, -0.02918702f, -0.07491879f, 0.13862266f, -0.12162279f, -0.03673300f, -0.01123537f, 
    -0.10790301f, -0.14313291f, -0.04351839f, 0.06122469f, 0.06548929f, -0.10420938f, -0.15488937f, 0.05772102f, 
    -0.01218185f, 0.03592333f, -0.09791345f, -0.02646798f, -0.20311049f, 0.06377883f, 0.11134032f, 0.05517357f, 
    -0.27938423f, -0.06022077f, -0.00198663f, -0.14559123f, 0.17644161f, -0.18000612f, -0.05440014f, -0.00766052f, 
    -0.10267328f, 0.12366466f, 0.05965017f, -0.05323101f, -0.07092297f, 0.10138193f, -0.20055778f, -0.15023541f, 
    0.17599910f, 0.11765192f, 0.03370559f, 0.20076863f, -0.04054356f, 0.09941527f, -0.03585404f, 0.07381785f, 
    0.04677070f, 0.04829551f, -0.03276969f, -0.06582281f, 0.04201245f, 0.01033670f, 0.05455060f, -0.15207244f, 
    -0.12731719f, 0.11733188f, 0.24189502f, 0.20579645f, 0.03360546f, 0.08805376f, 0.20233731f, 0.32435462f, 
    -0.11920539f, 0.01453306f, 0.03518807f, -0.08081235f, 0.14494608f, 0.05443220f, 0.02617091f, -0.08629880f, 
    0.12534980f, 0.07078993f, -0.10180910f, 0.16485472f, 0.07184455f, -0.00801050f, 0.09009732f, 0.10653339f, 
    -0.01477481f, -0.02756249f, -0.01081984f, 0.00065660f, -0.02110590f, -0.05467724f, 0.03455495f, 0.00392984f, 
    -0.05678370f, -0.04862813f, 0.04322872f, -0.02058273f, -0.03509964f, 0.05247402f, 0.00393223f, -0.04272272f, 
    -0.04347011f, -0.00316771f, -0.02316327f, 0.01749909f, 0.02396887f, 0.00390166f, 0.01194913f, -0.00926146f, 
    0.00335854f, -0.03385796f, 0.03094144f, -0.00806711f, 0.01509471f, -0.01384522f, 0.02410948f, 0.01316435f, 
    -0.02718724f, -0.03665673f, -0.00991381f, 0.04681532f, -0.02945355f, -0.03852835f, -0.04520999f, -0.03771041f, 
    0.03569541f, 0.01863808f, 0.03155340f, 0.01350046f, -0.02880937f, 0.02650632f, 0.04947445f, -0.00243844f, 
    0.02465537f, -0.02353293f, -0.01419125f, -0.05662666f, -0.04858928f, 0.02394598f, -0.05110484f, -0.04310865f, 
    0.03556844f, -0.05179311f, -0.01102704f, -0.02346481f, -0.04866750f, 0.01452060f, -0.03842394f, -0.04619500f, 
    -0.05469815f, -0.02892674f, -0.01639161f, -0.05466822f, -0.00106789f, 0.01118735f, -0.02770509f, -0.01668629f, 
    -0.04745746f, 0.03878488f, -0.00755844f, -0.03685630f, 0.00784519f, -0.05289349f, 0.04202978f, -0.01769941f, 
    -0.00223375f, -0.01276608f, 0.03942946f, 0.02082776f, -0.00167928f, 0.00252646f, 0.02358810f, 0.00684168f, 
    0.00466147f, -0.03780911f, -0.04159905f, -0.03110626f, -0.02717327f, -0.02532141f, -0.03438589f, -0.02839904f, 
    0.00397439f, 0.04538455f, 0.04281603f, -0.04158755f, 0.00383332f, 0.03086537f, 0.01307629f, -0.01530785f, 
    0.00888891f, 0.01170987f, -0.01390787f, 0.03298742f, -0.05243964f, -0.05114520f, -0.02879132f, -0.03145390f, 
    -0.03663563f, -0.03996846f, 0.03633498f, -0.01280519f, -0.06110194f, -0.03312458f, 0.03930864f, 0.02150642f, 
    0.01763499f, -0.03502896f, 0.04539764f, 0.04159376f, -0.04046277f, -0.06027175f, -0.05278607f, -0.01727341f, 
    -0.05091847f, 0.01893906f, 0.04841726f, -0.03000696f, -0.05430516f, -0.01074658f, 0.02037593f, -0.04261800f, 
    0.03572223f, -0.00354420f, 0.00299607f, -0.03338696f, 0.04301305f, 0.04587766f, 0.01264850f, 0.03967892f, 
    -0.02906276f, -0.00595932f, -0.01200459f, -0.00653436f, -0.04149844f, -0.03856213f, -0.02657530f, -0.02691571f, 
    0.03521881f, 0.04296725f, -0.03189914f, 0.03476225f, -0.02150624f, -0.02600187f, -0.03162903f, -0.04757775f, 
    0.03660606f, 0.01977636f, -0.03431677f, 0.04044326f, 0.00182064f, -0.02957126f, -0.06118399f, 0.03188433f, 
    -0.04008326f, -0.02893657f, 0.04527304f, -0.03222494f, 0.02027404f, -0.01550017f, -0.03207643f, -0.03877134f, 
    0.00728615f, 0.04403356f, -0.02928033f, -0.05060961f, -0.01868059f, -0.05400831f, -0.05805557f, 0.03356682f, 
    -0.03597439f, 0.04834162f, -0.01606226f, -0.03828904f, -0.04443960f, -0.00952219f, -0.06272389f, -0.02656578f, 
    0.04209755f, -0.03998998f, -0.01579003f, 0.04523953f, -0.02177330f, -0.02853252f, 0.03917585f, 0.04446745f, 
    0.04490644f, -0.01146606f, 0.02244146f, 0.02467874f, 0.00867671f, -0.04135101f, -0.03624827f, -0.05971373f, 
    -0.01578024f, -0.01738623f, -0.05733543f, 0.03360436f, -0.04719264f, -0.02956179f, -0.02297988f, -0.00218984f, 
    -0.05197131f, -0.02912957f, -0.03258080f, 0.01776198f, 0.01914098f, -0.04452185f, 0.04581629f, -0.05520640f, 
    -0.02799554f, -0.02104605f, 0.02415238f, 0.01967593f, -0.05478786f, -0.03679135f, -0.04192784f, 0.04196566f, 
    -0.04982269f, 0.02168089f, 0.02346645f, 0.01753912f, 0.00288190f, -0.00353404f, 0.02399072f, 0.01987650f, 
    -0.01469410f, 0.02025191f, 0.01427263f, -0.03702908f, -0.04794483f, 0.03872342f, -0.00525652f, -0.05086004f, 
    -0.04885992f, -0.03480098f, -0.03072098f, 0.00504328f, -0.03942199f, -0.05316282f, -0.01765052f, 0.01502411f, 
    0.04965949f, 0.01360105f, 0.00426636f, -0.02624930f, -0.01001847f, 0.00059863f, -0.01540828f, 0.02348929f, 
    -0.05226528f, 0.01869745f, -0.04688127f, 0.02694664f, -0.05222203f, -0.03627937f, 0.02621948f, 0.01608875f, 
    -0.03775922f, 0.03979545f, 0.03425306f, 0.00825228f, -0.03933641f, -0.05620270f, 0.04449857f, 0.01882719f, 
    0.00416990f, 0.04281957f, -0.01740265f, -0.04488655f, -0.03208780f, -0.04522263f, 0.04767648f, 0.02966041f, 
    -0.02008286f, 0.00589175f, -0.00512360f, 0.04183626f, 0.01911565f, 0.02852675f, -0.01671617f, 0.01529277f, 
    0.01939022f, -0.03190824f, -0.00608395f, 0.04381252f, -0.04907044f, -0.04097998f, 0.03329508f, 0.02009481f, 
    -0.06094155f, 0.03744012f, -0.03941834f, -0.05007550f, -0.04453102f, -0.02592603f, -0.01159784f, -0.02578682f, 
    0.00101462f, 0.01513886f, -0.00443973f, -0.00333498f, 0.04138068f, 0.03440405f, -0.01540480f, -0.05852636f, 
    -0.00790627f, 0.00072635f, 0.18485290f, -0.05028122f, -0.23514602f, -0.07937043f, 0.12723574f, -0.02247124f, 
    0.06175631f, -0.25332192f, -0.02704362f, 0.14671890f, 0.06796447f, -0.07045032f, 0.06438594f, 0.04660807f, 
    -0.15583609f, -0.03563756f, -0.12462857f, -0.23051952f, -0.01985669f, 0.12766944f, -0.17419446f, -0.03805852f, 
    -0.05367581f, 0.18144271f, -0.01745644f, 0.14080648f, 0.13034488f, 0.25686264f, -0.10188468f, -0.00146796f, 
    -0.03958152f, -0.04185084f, -0.07305771f, 0.10797545f, 0.20561190f, 0.06323070f, 0.06597650f, 0.19195569f, 
    -0.06441092f, -0.13083883f, -0.12240281f, 0.09404012f, 0.21342605f, -0.17505509f, -0.15861288f, 0.06843369f, 
    0.09374353f, 0.00022421f, -0.05547989f, 0.10075486f, 0.11367683f, 0.06638593f, -0.02834024f, 0.09929945f, 
    0.17804392f, 0.17803392f, 0.04787759f, 0.11611160f, -0.39115414f, -0.20903672f, -0.18004946f, -0.11467578f, 
    -0.09075592f, 0.08892483f, 0.21656044f, -0.20540358f, -0.11117577f, 0.21296987f, 0.02485779f, 0.00453493f, 
    -0.05526845f, -0.01111007f, -0.05620708f, 0.11083735f, 0.09538396f, -0.03131872f, -0.03230483f, 0.07699731f, 
    0.04662785f, 0.18699814f, 0.26289496f, -0.04538500f, -0.21545537f, 0.14892961f, -0.20894097f, 0.04858471f, 
    0.09332393f, 0.01948681f, -0.00900932f, 0.07278918f, 0.00021454f, -0.02155848f, -0.02388874f, 0.11312419f, 
    0.00406617f, -0.00869729f, -0.03083207f, -0.03935165f, 0.09436908f, 0.30606875f, 0.16622312f, 0.34443301f, 
    0.36704674f, -0.36296809f, -0.08208747f, -0.23678042f, 0.04015743f, -0.25687420f, -0.01609515f, -0.05016107f, 
    0.05786638f, 0.08729409f, -0.04591114f, 0.12743115f, -0.10193393f, -0.25365171f, -0.02968533f, 0.08944200f, 
    0.02760909f, -0.61410731f, 0.07168961f, -0.01017961f, -0.46622273f, 0.00583672f, -0.27907577f, -0.06923645f, 
    0.21968432f, 0.01776525f, -0.20312119f, -0.00094671f, -0.15398896f, 0.02834693f, 0.06987228f, 0.06096053f, 
    0.14113924f, 0.01101604f, -0.05085523f, 0.20360757f, -0.28885087f, 0.44005099f, -0.08911410f, 0.01739451f, 
    -0.28798723f, 0.13822281f, -0.19328821f, 0.12265305f, -0.01444456f, -0.19404417f, -0.02422382f, -0.08031295f, 
    0.09680931f, -0.07402508f, -0.05042119f, -0.09079152f, 0.21969387f, 0.16267385f, 0.05598659f, 0.08759904f, 
    0.10335633f, -0.01086370f, -0.30560282f, 0.19537115f, -0.08963863f, 0.06737656f, 0.18007196f, 0.15826301f, 
    0.00706916f, -0.15688699f, -0.06222375f, 0.08804666f, -0.09743566f, 0.02657941f, -0.00835842f, 0.03466723f, 
    0.21915063f, -0.05717084f, 0.03546005f, -0.00432323f, 0.20849262f, -0.03666496f, 0.21097516f, 0.04043895f, 
    -0.20753178f, -0.24725276f, -0.20600605f, -0.16712257f, -0.11637212f, -0.32747859f, 0.02179592f, 0.06149471f, 
    -0.06296297f, 0.02770467f, 0.10639483f, -0.10689665f, -0.05807548f, 0.08357965f, 0.03879990f, -0.12320744f, 
    -0.07166205f, 0.32709754f, -0.18280126f, 0.25009385f, -0.01701864f, 0.04379238f, 0.08672299f, -0.02972431f, 
    0.04716582f, 0.10102675f, 0.05502366f, -0.11449534f, -0.10165034f, 0.00356383f, 0.00748346f, 0.12179799f, 
    0.05129085f, -0.13599241f, -0.00466415f, 0.01151400f, -0.14582944f, 0.52782583f, -0.08225822f, 0.16403614f, 
    -0.12141462f, 0.16298258f, 0.02554344f, -0.05613583f, 0.05386993f, 0.07073387f, -0.09049496f, -0.14537659f, 
    -0.01166927f, -0.06674241f, -0.07645738f, 0.07048926f, -0.04925131f, -0.19811641f, -0.02844760f, -0.03998612f, 
    -0.00072929f, 0.00557701f, -0.00422339f, -0.08772680f, 0.34219694f, -0.09476306f, -0.00878012f, 0.03938853f, 
    0.14294487f, -0.23167047f, 0.12360440f, 0.15252888f, 0.10858890f, 0.07285994f, 0.03853223f, 0.08514832f, 
    -0.09329718f, -0.02266512f, -0.16899388f, -0.07741743f, 0.24259797f, 0.00645555f, 0.33776250f, 0.05154961f, 
    0.00745398f, -0.06075772f, -0.09356806f, 0.03184516f, 0.14291500f, 0.12529583f, -0.04235471f, 0.14527120f, 
    0.04521251f, -0.09757433f, -0.09449454f, -0.12240656f, -0.22519583f, -0.18789038f, -0.19627093f, -0.01287540f, 
    0.10092143f, -0.01550710f, -0.06695578f, 0.10277481f, -0.19998001f, -0.05383838f, 0.10138678f, -0.00932600f, 
    0.10280035f, 0.08242251f, 0.05025750f, 0.01493230f, 0.10942297f, 0.10248230f, -0.00153411f, 0.17282918f, 
    0.01982682f, 0.19917466f, 0.03920835f, 0.18592708f, 0.28055742f, 0.08210471f, -0.07775858f, 0.23767255f, 
    -0.16042878f, -0.20877914f, 0.06949231f, -0.20654427f, 0.12867491f, -0.14048496f, 0.03146062f, -0.08503433f, 
    0.01114177f, 0.12498419f, 0.17223632f, 0.06607668f, 0.11920235f, 0.05695203f, 0.00280126f, 0.14155021f, 
    0.00055300f, -0.00459921f, -0.06268530f, -0.06454027f, -0.04675204f, 0.04321561f, -0.00219612f, 0.04273849f, 
    -0.03918744f, -0.01883586f, 0.02628649f, -0.03300177f, -0.02003264f, -0.01234085f, 0.01126598f, -0.00296808f, 
    -0.02960119f, 0.02498411f, 0.04278201f, -0.01936923f, -0.05303890f, -0.00697480f, 0.02155713f, 0.00786447f, 
    0.03364235f, -0.04227568f, -0.02722857f, 0.00168642f, 0.03318308f, -0.03831488f, 0.03000312f, -0.01083340f, 
    0.01882917f, 0.00777972f, -0.00722691f, -0.05992844f, 0.02563507f, -0.05243413f, 0.01272624f, -0.01111094f, 
    -0.04480644f, -0.01558566f, -0.02693836f, -0.02545658f, 0.01856710f, -0.05554277f, -0.02941476f, 0.01614633f, 
    0.04066329f, -0.02592700f, -0.01293223f, -0.03655080f, -0.01805790f, 0.03837838f, 0.00258172f, -0.05649719f, 
    -0.00324314f, -0.05646461f, 0.01318267f, 0.04434995f, -0.04452933f, -0.01706587f, -0.05086584f, 0.03489611f, 
    0.02797906f, -0.01591550f, 0.02626434f, 0.00398213f, -0.05796209f, 0.02841311f, -0.04153980f, -0.06208856f, 
    -0.00581836f, 0.02961907f, 0.04636251f, 0.02339370f, -0.03339648f, 0.03228566f, -0.01959950f, -0.03513915f, 
    0.01459752f, 0.01001047f, 0.02760095f, -0.00885543f, -0.02850748f, -0.04662750f, 0.00464983f, 0.00016313f, 
    -0.00702803f, -0.03757625f, -0.00701976f, -0.03431575f, -0.04543807f, 0.01912841f, 0.03897945f, 0.02163866f, 
    -0.05989592f, 0.00987137f, -0.01681489f, 0.01486149f, -0.06232533f, 0.03463315f, -0.01733082f, -0.04635087f, 
    -0.02688248f, -0.00306809f, -0.01503685f, 0.01592636f, 0.02309098f, 0.03029942f, -0.02929223f, 0.00221945f, 
    -0.00961051f, -0.02464835f, 0.02328818f, 0.03541905f, -0.03612849f, -0.06272803f, -0.02756831f, -0.04420156f, 
    -0.05437177f, -0.03248958f, -0.05872006f, -0.05530166f, -0.03182987f, -0.01462916f, 0.03203125f, 0.00329591f, 
    -0.05798985f, 0.02111276f, -0.00151089f, 0.00492185f, 0.04115214f, 0.02390332f, -0.00294572f, 0.02759610f, 
    -0.01447729f, -0.01196051f, -0.02615419f, -0.01824049f, -0.04979651f, 0.04359290f, 0.03177064f, 0.00155193f, 
    -0.01859406f, -0.04813468f, 0.04387625f, -0.00422444f, 0.01146635f, 0.02491952f, 0.00321260f, 0.03329287f, 
    -0.03948371f, -0.02989667f, -0.04002740f, -0.02263476f, -0.00431507f, 0.04232598f, 0.03945871f, 0.03217808f, 
    -0.05438847f, 0.01601971f, 0.00231721f, 0.01027572f, -0.02076159f, -0.01579634f, 0.03487863f, 0.02374885f, 
    -0.06047114f, -0.03515090f, 0.04103585f, 0.00263324f, -0.04735140f, -0.01793449f, 0.00622225f, -0.06036506f, 
    0.04416116f, -0.06148519f, -0.00132523f, 0.03702886f, -0.03804386f, 0.00595613f, 0.02336229f, 0.03688954f, 
    0.00710968f, 0.04263005f, 0.02181590f, 0.01209480f, -0.02087913f, -0.05170580f, -0.03033768f, 0.04483603f, 
    -0.03226129f, 0.03941471f, 0.01910258f, -0.01824007f, 0.00909044f, -0.06460627f, 0.02012279f, 0.00194719f, 
    -0.00920179f, -0.03272009f, -0.04651078f, -0.01216252f, -0.05029518f, -0.05824292f, -0.00104505f, 0.03839514f, 
    -0.00392802f, 0.04460272f, 0.02052983f, 0.00264926f, 0.00520358f, 0.04156340f, 0.03048625f, -0.05938048f, 
    0.03319303f, 0.02595550f, -0.02392363f, -0.04420149f, -0.03899672f, -0.01770041f, -0.02752663f, -0.05425548f, 
    0.02518796f, -0.03985969f, 0.02814581f, -0.03142724f, -0.03500086f, 0.02136084f, -0.01207077f, -0.02228935f, 
    0.00477890f, 0.02405478f, -0.02865539f, 0.01418968f, -0.06294613f, -0.03761208f, 0.00199111f, 0.00180133f, 
    0.02837237f, -0.06087542f, -0.05997058f, -0.04980462f, -0.03223459f, 0.03517886f, 0.04481891f, 0.04485166f, 
    -0.00451996f, -0.04215980f, -0.02026289f, 0.02958894f, -0.05696980f, -0.02034603f, 0.01657869f, -0.02521585f, 
    -0.03656748f, -0.06524283f, 0.00472077f, 0.00972797f, 0.00378994f, -0.05875030f, -0.06029416f, -0.03637069f, 
    0.03915239f, -0.02351410f, 0.04142069f, -0.02721343f, 0.01966804f, -0.02377561f, -0.05560673f, 0.00157166f, 
    0.00313698f, 0.00275566f, -0.05164031f, 0.04067571f, -0.06299895f, 0.04205098f, -0.00573889f, -0.00769885f, 
    -0.05677068f, 0.03477534f, 0.01819619f, -0.01770398f, -0.06009199f, 0.00971190f, 0.03619657f, 0.00693582f, 
    -0.05507281f, 0.00165309f, -0.00292598f, -0.03843712f, -0.00145245f, 0.04319972f, 0.01527231f, -0.01375662f, 
    0.01685164f, -0.05868720f, -0.01886945f, -0.04500874f, 0.02210549f, 0.04537905f, 0.00443650f, 0.02732696f, 
    0.03351320f, 0.05089315f, -0.01999247f, -0.03772394f, -0.00814657f, -0.04129695f, 0.00779741f, 0.01277668f, 
    0.00817894f, 0.03610583f, -0.02841092f, 0.00784330f, -0.03955028f, -0.02715843f, 0.01255379f, -0.01455808f, 
    0.11827242f, 0.01602351f, 0.06029759f, -0.09149455f, 0.09849844f, 0.00109739f, 0.00488708f, 0.03578246f, 
    0.04340646f, 0.01852848f, 0.02068088f, 0.09836572f, 0.16636334f, -0.12031077f, 0.06157387f, 0.07415257f, 
    -0.03592200f, 0.04430474f, 0.09186804f, 0.04078575f, 0.04102158f, 0.42993659f, -0.12225310f, 0.16972104f, 
    -0.04225476f, -0.08316197f, -0.00685356f, -0.14305645f, 0.27042457f, 0.30860388f, -0.07296508f, 0.05235578f, 
    -0.02224335f, 0.03637939f, -0.03719651f, -0.14481334f, 0.07728890f, -0.27709517f, -0.11866672f, 0.17589954f, 
    0.32678735f, 0.19886686f, 0.16993280f, 0.12904379f, 0.25537902f, -0.01777258f, -0.00655619f, 0.07395303f, 
    -0.00154919f, 0.00974060f, 0.06503461f, 0.14042251f, -0.00611253f, 0.07463382f, 0.07335622f, 0.14506403f, 
    -0.01855247f, -0.00335179f, 0.09568878f, -0.00081593f, -0.18864112f, -0.21122165f, -0.11649498f, -0.35680950f, 
    -0.26489508f, 0.05212749f, 0.02568688f, 0.00218296f, -0.05261226f, 0.09698023f, 0.00933463f, 0.04781236f, 
    0.06557060f, -0.03366736f, -0.01582732f, 0.05604357f, 0.00680153f, -0.05663569f, 0.10887647f, -0.05645141f, 
    -0.31611857f, -0.14054002f, -0.37286213f, -0.12857787f, -0.32636893f, 0.06054673f, 0.10352497f, 0.04808676f, 
    0.01715554f, 0.14011216f, -0.04062513f, 0.06904751f, -0.06574735f, -0.03358505f, -0.03424864f, -0.05519454f, 
    0.03428556f, 0.08473762f, -0.16264109f, 0.12709826f, 0.21459448f, 0.05199429f, 0.02096557f, 0.07852425f, 
    -0.10103490f, 0.01002435f, -0.05078067f, 0.02514221f, 0.07924606f, -0.03528152f, 0.03266385f, -0.13219872f, 
    -0.25797385f, 0.00079356f, -0.03151337f, -0.15941435f, -0.09467871f, -0.03296439f, 0.05575935f, -0.05246368f, 
    0.17766006f, -0.40372536f, -0.16100670f, -0.61703056f, -0.40949279f, 0.04536004f, -0.00693596f, 0.15751246f, 
    -0.01132958f, -0.02168255f, 0.00372084f, -0.04261149f, -0.15312676f, -0.12645344f, -0.17152704f, -0.02076849f, 
    0.05391838f, -0.04354626f, 0.04701082f, 0.08089238f, 0.02159695f, 0.38008791f, 0.31986240f, 0.11850510f, 
    -0.16205619f, -0.18065603f, -0.03261520f, -0.02905197f, -0.34995663f, -0.00818394f, 0.01339744f, -0.07495884f, 
    0.08400187f, -0.03413638f, 0.03905833f, -0.09190655f, 0.15753900f, 0.16853988f, -0.18946405f, 0.05062641f, 
    0.31945199f, 0.35031199f, 0.18613581f, 0.07969910f, 0.11627915f, -0.05884895f, -0.07638246f, -0.04996647f, 
    0.05121025f, -0.07416531f, -0.00289366f, 0.01406881f, 0.02024093f, 0.06897992f, 0.05570085f, -0.02012033f, 
    -0.10484444f, 0.04206932f, 0.03895367f, -0.01088760f, 0.33262646f, -0.17073616f, 0.04164416f, -0.01906753f, 
    -0.14774200f, -0.06322728f, -0.02056462f, 0.12160988f, -0.20540278f, 0.03990461f, 0.03472993f, 0.00107977f, 
    -0.10516283f, 0.05542144f, -0.26414981f, -0.08739096f, 0.07792491f, 0.09480185f, 0.01772914f, 0.05989725f, 
    0.19395426f, 0.26967973f, 0.18547529f, 0.09120769f, 0.16476220f, -0.08879241f, -0.03818688f, -0.03420642f, 
    0.05830532f, 0.02226364f, 0.09063822f, -0.08852576f, 0.07960782f, 0.13410288f, 0.01284660f, 0.12614492f, 
    0.01449342f, -0.08115619f, 0.03080647f, -0.07090429f, -0.13567145f, 0.05653740f, 0.03221666f, 0.09432177f, 
    0.02983333f, -0.02334402f, -0.04585143f, -0.09927379f, -0.03865364f, 0.20452006f, -0.07712783f, -0.14519075f, 
    0.00380393f, 0.00450401f, 0.01878103f, 0.03428634f, -0.01176847f, 0.00759399f, -0.12424082f, -0.05562331f, 
    0.31070971f, 0.11486244f, 0.18197724f, 0.11819866f, 0.08443589f, -0.00737218f, -0.04711268f, -0.00358043f, 
    0.06418028f, 0.03448578f, 0.11434852f, -0.03782369f, -0.11269761f, -0.02226031f, 0.06409274f, -0.18868908f, 
    -0.11443068f, 0.07444947f, 0.06393634f, -0.09679843f, -0.36941209f, -0.16551171f, -0.05793173f, -0.18886818f, 
    -0.19697589f, 0.11757170f, 0.22607501f, 0.13908708f, 0.02276547f, 0.15633696f, 0.27192593f, 0.17640761f, 
    -0.07015960f, 0.06523704f, -0.00042136f, -0.00903750f, -0.02215839f, -0.11770846f, -0.01182669f, 0.07295980f, 
    -0.31288624f, -0.05363814f, -0.22292548f, -0.16820151f, 0.19729206f, 0.23968598f, 0.05482387f, -0.16466475f, 
    0.02978913f, 0.27197254f, -0.05332945f, 0.05225906f, 0.03785547f, 0.04307745f, 0.04586072f, -0.12422098f, 
    0.10630290f, -0.01246363f, 0.09111376f, 0.20181695f, -0.08742285f, -0.82721901f, -0.77668780f, -0.68370050f, 
    -0.39539734f, -0.23552860f, 0.08389498f, -0.22610301f, -0.01753257f, -0.03201135f, -0.01200904f, -0.04815651f, 
    -0.03627808f, -0.08622129f, 0.02306842f, -0.04835162f, -0.03169677f, 0.00614307f, -0.03367485f, 0.01615979f, 
    -0.13451430f, 0.11397220f, -0.15483668f, 0.25347716f, 0.00542889f, 0.05882205f, -0.09093045f, -0.04946098f, 
    0.06655020f, 0.15430525f, 0.04764827f, 0.10332458f, 0.19422734f, 0.01456556f, -0.02638504f, 0.01440653f, 
    0.00691115f, 0.01629874f, 0.15903190f, 0.06689605f, -0.09430003f, -0.52480334f, -0.11149595f, -0.01264115f, 
    0.12458222f, 0.13452415f, 0.11750745f, 0.00894267f, 0.01706368f, -0.09958424f, -0.10214178f, 0.01818359f, 
    0.01278262f, -0.04737952f, 0.03261811f, 0.05862729f, 0.00442996f, -0.00039066f, -0.04639240f, -0.14947154f, 
    -0.11280737f, 0.13042340f, 0.30637446f, 0.01078090f, -0.00462019f, -0.05838295f, 0.00261209f, -0.12161913f, 
    -0.18687540f, -0.09809957f, -0.05711741f, -0.00669183f, -0.12551869f, 0.01560870f, 0.13331982f, 0.00352474f, 
    -0.10809319f, -0.11433697f, -0.06196907f, -0.15474333f, 0.36485070f, -0.03260045f, 0.16834033f, 0.04674335f, 
    0.29764515f, 0.09616616f, -0.01735160f, 0.34628716f, 0.13661291f, -0.09938805f, -0.04247427f, 0.10638448f, 
    0.05902179f, 0.10913152f, 0.13862278f, 0.13682316f, 0.00031001f, 0.19887216f, 0.07703863f, 0.10083923f, 
    -0.15289792f, -0.15298432f, -0.20960824f, 0.14615458f, 0.19901291f, -0.02783033f, 0.21196575f, -0.07319239f, 
    0.08874173f, -0.10126321f, -0.04739270f, 0.01564936f, -0.01452944f, 0.05486469f, -0.01859038f, 0.04499663f, 
    0.03869128f, 0.02735211f, 0.06480581f, 0.21386734f, -0.21581571f, -0.31726167f, -0.15055232f, -0.09333811f, 
    -0.16027659f, 0.07957903f, -0.07172333f, 0.11560009f, 0.09765844f, 0.03700722f, 0.10965465f, 0.19224632f, 
    0.03598556f, 0.12041627f, 0.18722732f, -0.19965294f, -0.11713661f, 0.03479633f, -0.03744343f, -0.08944678f, 
    -0.20647405f, 0.28472862f, 0.15888228f, 0.05411494f, 0.35557798f, 0.01755228f, 0.10371737f, -0.12014008f, 
    0.02644819f, -0.09853835f, 0.05168002f, -0.04523893f, 0.01621188f, -0.00349136f, 0.05411885f, 0.00835843f, 
    0.02533647f, 0.02850874f, 0.17276165f, -0.01996344f, 0.68561661f, -0.47960910f, 0.43013987f, -0.08724717f, 
    0.37697244f, 0.09264015f, 0.08846452f, 0.19261272f, 0.17085904f, 0.12275057f, -0.13321903f, -0.03135493f, 
    -0.01890423f, -0.11523397f, 0.05678638f, 0.12926547f, -0.01124120f, 0.00288156f, 0.09119269f, 0.18918225f, 
    0.08260257f, 0.06808454f, 0.49072590f, 0.24960865f, 0.07152038f, -0.01984775f, -0.05139912f, -0.15050679f, 
    0.09541825f, 0.10267675f, -0.07102314f, -0.07376952f, -0.04026284f, -0.05574856f, 0.03460237f, 0.12428453f, 
    0.03961065f, 0.22773321f, 0.01849691f, 0.04671666f, -0.02261947f, 0.16867660f, -0.01985014f, 0.15505953f, 
    0.14407626f, 0.02046353f, 0.03979309f, 0.13342594f, 0.21759282f, 0.23578151f, 0.15258521f, -0.03577301f, 
    0.02475038f, 0.06871955f, 0.12582280f, -0.07171400f, -0.01428683f, -0.01012189f, 0.00682090f, -0.06688016f, 
    0.19189827f, -0.10463645f, 0.61967212f, 0.17438178f, 0.10460527f, -0.00228060f, 0.00127158f, 0.04115803f, 
    0.09039574f, 0.00786120f, -0.14485975f, -0.01177235f, 0.06255980f, -0.03564629f, -0.06113083f, 0.02772683f, 
    -0.00998414f, 0.33609360f, -0.02338170f, 0.01372662f, 0.21085028f, -0.29209194f, 0.46971262f, -0.11618731f, 
    0.04194881f, 0.09655803f, 0.03231653f, 0.01512180f, -0.07442562f, 0.01259258f, -0.05743809f, -0.05027218f, 
    0.00565128f, 0.10109273f, 0.02977993f, -0.11510307f, -0.06450590f, 0.17322047f, -0.04890425f, 0.11091744f, 
    -0.05185547f, -0.08534022f, 0.16953340f, 0.18045329f, -0.18112056f, 0.01516681f, -0.09806943f, 0.00038517f, 
    0.07879231f, 0.03262119f, 0.10634975f, 0.11290290f, 0.07536993f, 0.15572000f, 0.16989097f, -0.02121419f, 
    0.08966766f, 0.09553993f, 0.01962288f, -0.03251002f, -0.29505157f, -0.29131758f, -0.21004085f, 0.14533874f, 
    -0.01938855f, -0.02789561f, -0.06640434f, -0.00786005f, -0.05517963f, -0.11588144f, 0.08688248f, -0.03807697f, 
    -0.10735895f, -0.04404154f, -0.15841560f, -0.04945023f, -0.05714847f, 0.03836387f, -0.04170948f, -0.06769756f, 
    -0.36662224f, -0.15313767f, -0.22906414f, 0.05450722f, 0.11330581f, 0.00834253f, -0.11056365f, 0.17579742f, 
    0.02207273f, -0.00625428f, -0.09064053f, 0.01476221f, -0.04330812f, 0.02364429f, 0.10776839f, 0.14625496f, 
    0.14473768f, 0.11345644f, -0.01802690f, -0.09832775f, -0.44812414f, -0.09465460f, 0.01411013f, 0.21057852f, 
    0.24752326f, 0.11742018f, -0.02266503f, 0.18716748f, -0.06678347f, 0.06286512f, -0.07727211f, -0.02233853f, 
    -0.01247772f, -0.02138904f, 0.01646998f, 0.12031932f, 0.02883499f, 0.06395008f, 0.05052752f, 0.05611914f, 
    0.06174241f, 0.18393956f, 0.17039722f, 0.01009098f, 0.11112094f, -0.02847337f, -0.06225782f, 0.09147061f, 
    -0.09253515f, -0.03114858f, 0.18190274f, -0.04948108f, -0.04259780f, 0.06275743f, 0.04724562f, 0.04411164f, 
    -0.08173382f, -0.15894622f, -0.15271446f, -0.02838351f, 0.16789949f, 0.02621326f, -0.13108167f, 0.25383309f, 
    -0.00965187f, 0.28474113f, 0.23125260f, 0.19348958f, -0.02773697f, -0.10843822f, 0.02977904f, 0.00192605f, 
    0.04035153f, -0.01219738f, -0.01565458f, 0.08734679f, 0.14569150f, 0.13262941f, 0.08046089f, 0.23312071f, 
    -0.23754898f, 0.08027135f, -0.05639338f, -0.13367392f, 0.04249230f, 0.06823368f, 0.07576139f, 0.02781717f, 
    -0.05338921f, 0.05936192f, 0.03831676f, 0.02281769f, 0.06242762f, -0.05690977f, -0.06370721f, -0.02585921f, 
    0.16141079f, 0.13756692f, 0.05691091f, 0.26919439f, -0.19378202f, 0.00316271f, -0.22113611f, 0.34594581f, 
    -0.02302451f, 0.13310732f, -0.05343951f, 0.10896144f, 0.13396725f, -0.12620960f, 0.00065213f, -0.01584216f, 
    0.00926701f, -0.01292676f, 0.05054630f, 0.15342911f, 0.07328603f, 0.08732755f, 0.11993161f, 0.08398323f, 
    -0.05177042f, -0.02838493f, 0.26579162f, 0.36137900f, -0.15384136f, 0.01585250f, 0.04494921f, 0.09095571f, 
    0.06393170f, 0.04859082f, 0.15385774f, -0.01595975f, 0.06597704f, -0.09859203f, 0.01469130f, -0.05641409f, 
    0.03752697f, -0.11350241f, 0.20829026f, -0.04510812f, 0.23617980f, 0.22524397f, 0.45372608f, -0.08131115f, 
    0.10224036f, -0.05563578f, -0.16932453f, -0.18682076f, -0.14126001f, 0.06001954f, 0.09910937f, -0.04007085f, 
    -0.05072060f, 0.01331011f, -0.04949981f, -0.01239059f, -0.01014327f, -0.05032282f, -0.04700356f, 0.00640695f, 
    -0.38791010f, -0.14999424f, 0.21236345f, -0.39525646f, 0.10874503f, -0.02186228f, 0.05310760f, 0.02031075f, 
    0.09231840f, -0.07406539f, -0.01979126f, 0.23287268f, 0.09818274f, 0.03161892f, -0.03606625f, -0.05734655f, 
    0.15644044f, 0.13957417f, 0.12786205f, -0.03503483f, -0.37803832f, 0.06903186f, -0.66238868f, 0.31393567f, 
    -0.06249541f, -0.22831348f, 0.29134753f, -0.02040637f, 0.17335056f, 0.08360739f, -0.01212082f, -0.11028406f, 
    0.00472269f, 0.13014017f, 0.02288653f, -0.00793411f, -0.01427524f, 0.07973595f, 0.12540609f, -0.00166840f, 
    0.26600978f, 0.18592204f, -0.07587288f, 0.16497876f, 0.41190451f, 0.06645261f, 0.08971699f, 0.05740724f, 
    -0.05112608f, 0.08274969f, 0.10227533f, -0.11576313f, -0.04955188f, -0.02932795f, 0.07272249f, 0.05271976f, 
    -0.04938459f, -0.16833521f, 0.03114276f, 0.10848909f, -0.10873102f, 0.42761174f, 0.32746485f, -0.22249529f, 
    0.11910778f, -0.00964197f, -0.20864555f, -0.01155740f, -0.00314738f, -0.10749618f, -0.02104471f, 0.16341293f, 
    0.01577283f, 0.05376418f, -0.01102571f, 0.09677337f, -0.16880031f, 0.09819318f, -0.12043025f, 0.10015654f, 
    0.45241359f, 0.01903385f, -0.74659848f, -0.01404761f, 0.27115566f, 0.16399767f, 0.12971121f, 0.11204806f, 
    -0.00767189f, 0.15141940f, 0.03032781f, -0.03681451f, 0.01050008f, -0.11960079f, 0.03436534f, 0.13937061f, 
    -0.06682192f, 0.11725391f, 0.02885857f, -0.01599474f, -0.27923584f, -0.31455579f, -0.73948336f, 0.35831586f, 
    0.10144342f, 0.08872837f, 0.10404830f, 0.10963079f, 0.17889386f, 0.05943722f, 0.03149458f, 0.10942316f, 
    -0.01138956f, -0.11852489f, 0.01731849f, 0.05378669f, 0.04677179f, -0.04117257f, 0.13399765f, -0.11332110f, 
    0.16850837f, 0.33498105f, 0.03849015f, 0.03583051f, 0.15490183f, 0.01625970f, 0.00094165f, -0.11418027f, 
    -0.05420347f, 0.04963702f, 0.07124630f, -0.04830853f, -0.15845010f, -0.10414728f, -0.01803967f, 0.02102851f, 
    -0.05800264f, -0.06482908f, 0.05641821f, 0.12905744f, -0.06930745f, 0.02431484f, 0.28300801f, -0.31852385f, 
    -0.12218136f, -0.03993187f, 0.02745867f, -0.08711829f, -0.06349908f, -0.10629972f, 0.01448147f, 0.02412763f, 
    0.06978168f, -0.03068133f, 0.06313559f, 0.05645946f, -0.06294014f, -0.03606731f, -0.04801371f, -0.12258244f, 
    -0.19546734f, -0.28353140f, 0.03398689f, 0.08469609f, -0.19487369f, -0.11451532f, 0.09842575f, -0.11485793f, 
    -0.00282205f, -0.11359660f, -0.07385428f, -0.01300659f, -0.07849454f, 0.10612998f, 0.01804241f, 0.00904802f, 
    0.04399249f, -0.07823054f, 0.24127175f, 0.08248755f, -0.17690748f, -0.37024456f, 0.07619586f, 0.02123275f, 
    -0.09332058f, -0.15077531f, -0.06822427f, -0.17112535f, -0.00997326f, -0.01010006f, -0.02989541f, 0.09769787f, 
    0.02394402f, 0.08265442f, -0.11406673f, -0.04181646f, 0.02094864f, -0.07510541f, 0.06948728f, 0.06787600f, 
    0.13536148f, -0.06789406f, 0.05056562f, 0.26934525f, -0.19422370f, -0.06918144f, -0.00507347f, -0.01586587f, 
    -0.01230558f, 0.07670191f, 0.03591190f, -0.01561145f, -0.04538545f, 0.00389474f, -0.07190836f, -0.04235850f, 
    0.00261583f, 0.06131105f, 0.03645107f, 0.14305449f, 0.10183910f, -0.44949901f, -0.21285331f, 0.01341143f, 
    0.14364065f, 0.08706747f, -0.20174639f, 0.06364597f, -0.12095475f, -0.17647861f, 0.07184599f, 0.05894363f, 
    -0.00781694f, 0.05519700f, 0.09602243f, 0.20634547f, -0.09844458f, -0.03633879f, -0.04404642f, -0.23314960f, 
    -0.09903181f, 0.12973866f, 0.19066094f, -0.06843166f, 0.20549588f, -0.15398057f, -0.03417794f, -0.06712687f, 
    -0.09110400f, -0.14474116f, -0.04702299f, -0.12662946f, 0.00821537f, 0.03319851f, -0.03173165f, 0.09949662f, 
    -0.00163208f, -0.12428271f, -0.20656104f, -0.11315287f, 0.05551632f, 0.20958860f, -0.06005324f, -0.00504639f, 
    0.39435175f, -0.15428908f, 0.04894065f, 0.17258506f, -0.04397039f, -0.06759393f, 0.04730288f, 0.08668201f, 
    0.10371877f, -0.03418579f, 0.18450092f, 0.03131425f, 0.04164565f, 0.09690922f, 0.13564025f, -0.10312638f, 
    -0.08655314f, -0.15368985f, -0.12472727f, 0.04606055f, 0.04806019f, 0.05571171f, 0.04816546f, -0.05323252f, 
    0.09954252f, -0.03463570f, 0.02261536f, 0.07055128f, 0.11358579f, 0.02615135f, 0.07358483f, 0.07104854f, 
    0.14477834f, 0.09224398f, 0.25948721f, 0.01829368f, -0.25686264f, -0.04877970f, -0.07648543f, -0.01490239f, 
    -0.21537270f, -0.07546978f, -0.00665205f, -0.00159699f, -0.07687443f, 0.00509098f, 0.15367597f, 0.03858332f, 
    0.23219132f, 0.02398282f, 0.02020321f, -0.17149922f, -0.05408944f, 0.00533145f, -0.01855878f, 0.07657038f, 
    -0.12836592f, -0.02287342f, -0.15327984f, 0.04225811f, 0.27015775f, -0.02526024f, 0.17071028f, -0.17880012f, 
    0.10353360f, -0.03824054f, 0.02542883f, -0.07761024f, 0.06628352f, -0.07188530f, -0.06975220f, 0.05585317f, 
    -0.02830303f, 0.08546708f, -0.07537613f, 0.07435879f, 0.48679310f, -0.14410630f, 0.12392630f, -0.08554668f, 
    0.07933607f, 0.23364957f, 0.11779680f, 0.22263037f, 0.08736033f, 0.13997002f, -0.18280166f, 0.03343079f, 
    0.05036278f, -0.03606569f, 0.06711221f, 0.08085946f, 0.13901755f, -0.11670138f, 0.11387645f, 0.06191831f, 
    0.15275963f, 0.10182549f, 0.31670386f, 0.24721943f, -0.12506977f, 0.05451342f, -0.01784860f, 0.01482588f, 
    0.06533587f, -0.01315656f, 0.01319269f, -0.06090252f, -0.02921407f, -0.00992564f, -0.11643381f, 0.02630477f, 
    0.09538732f, 0.05101008f, -0.12136850f, 0.06277113f, -0.22264856f, 0.11749983f, -0.05019021f, 0.01828798f, 
    -0.00911596f, 0.08227701f, 0.01437911f, 0.01109583f, 0.10970458f, 0.06684282f, -0.00152973f, -0.02041024f, 
    -0.03166653f, 0.03464558f, -0.03926576f, -0.02072706f, -0.00836256f, -0.06006889f, -0.00005478f, 0.05057930f, 
    0.29971671f, 0.08882879f, 0.34130388f, 0.18159962f, -0.03591117f, 0.03387144f, -0.01553851f, 0.15448678f, 
    0.13042213f, -0.06085393f, -0.12672493f, -0.00200403f, 0.01461150f, 0.00757558f, -0.01709763f, -0.04991044f, 
    -0.08294214f, 0.07462516f, 0.05229880f, 0.05839298f, 0.37909070f, 0.06827246f, 0.06343785f, -0.21119061f, 
    -0.00029822f, 0.06039540f, 0.06553098f, 0.01796884f, -0.04110287f, -0.21211304f, -0.15539260f, 0.01234398f, 
    0.03267215f, 0.02815549f, 0.02809875f, -0.05730584f, 0.03026707f, 0.01300420f, 0.05522403f, 0.11022904f, 
    -0.21318704f, 0.18611673f, 0.18202147f, 0.10078073f, -0.09339815f, -0.07030649f, -0.01507023f, -0.02328628f, 
    0.02534051f, -0.05146372f, -0.10878865f, -0.05479563f, 0.09942883f, 0.02078941f, 0.01494234f, -0.02633058f, 
    -0.00181044f, -0.04472288f, -0.08044702f, -0.05873961f, -0.20802838f, -0.28694895f, -0.00014041f, 0.12936620f, 
    -0.03448474f, -0.13929021f, -0.25016847f, 0.02776772f, 0.04550367f, -0.05941752f, -0.12009182f, -0.03228785f, 
    -0.16411878f, -0.10572397f, -0.07052949f, -0.00923840f, 0.03265883f, 0.14772296f, -0.02128456f, -0.01747646f, 
    -0.00275899f, -0.00147715f, -0.17597012f, 0.05295857f, 0.13843082f, -0.01239104f, -0.14777324f, 0.11419036f, 
    -0.01104970f, -0.00421051f, 0.05614581f, 0.08572944f, 0.09540085f, 0.07992848f, 0.02470504f, 0.21678898f, 
    0.13490498f, 0.11802217f, 0.06574580f, -0.22406000f, -0.34262794f, 0.05159352f, -0.30873039f, 0.11388652f, 
    0.08624626f, 0.20276682f, 0.04027954f, -0.01010226f, -0.07615271f, 0.09771180f, 0.02662246f, 0.01937037f, 
    -0.08300383f, 0.06460706f, -0.04645132f, 0.14111228f, -0.01457961f, 0.08082938f, 0.03339018f, 0.03126640f, 
    -0.08707699f, 0.11864945f, -0.18404076f, 0.07470702f, 0.03166188f, -0.04645512f, 0.01850074f, -0.09150126f, 
    -0.16186491f, 0.02195015f, -0.09920751f, -0.06944142f, 0.09036982f, -0.06812902f, -0.20822459f, -0.02266669f, 
    0.12769355f, 0.11873417f, 0.12296548f, 0.15045385f, -0.05424897f, -0.37086001f, 0.00648560f, -0.09008056f, 
    -0.32252532f, -0.02588333f, -0.17924796f, -0.32445556f, -0.20882186f, -0.11154892f, 0.07407998f, 0.06596573f, 
    0.12152342f, -0.00037297f, 0.06539879f, 0.05130545f, -0.16327041f, -0.09725659f, -0.10279630f, -0.26850823f, 
    0.17714967f, -0.23209143f, 0.08049967f, -0.01985985f, 0.18946451f, 0.00052996f, 0.10110059f, -0.01914598f, 
    -0.11744143f, -0.12428294f, -0.09971631f, -0.06771591f, 0.09594142f, 0.01229328f, 0.08918972f, 0.11814893f, 
    -0.13765737f, -0.11298625f, -0.11787801f, -0.29145068f, -0.21131642f, 0.06788126f, 0.22588192f, -0.12799567f, 
    0.22152558f, 0.06045017f, 0.00804908f, 0.05958445f, 0.22031549f, -0.03888992f, -0.07866424f, 0.16981097f, 
    0.02403944f, -0.00498473f, 0.25361872f, 0.17070499f, -0.08007514f, -0.03319789f, 0.17339584f, -0.06766637f, 
    -0.18152332f, -0.07396153f, -0.09701450f, 0.21400779f, -0.02709245f, 0.10510723f, 0.22400054f, 0.12618917f, 
    0.12552087f, 0.07915562f, 0.05120940f, 0.14761457f, 0.07970905f, 0.11259845f, 0.09887870f, 0.10218839f, 
    0.14584342f, 0.17757559f, 0.03376530f, 0.10572334f, -0.22610098f, -0.26253662f, -0.27289796f, -0.03950217f, 
    -0.06211751f, 0.08534972f, 0.06075089f, 0.02483621f, 0.03286606f, -0.09942791f, 0.24405739f, 0.17402184f, 
    0.11905303f, -0.05032812f, 0.10914436f, -0.01688356f, 0.03691078f, 0.12605214f, 0.01859516f, -0.01513767f, 
    0.22248283f, 0.16145907f, 0.36432636f, 0.01856545f, -0.05597902f, -0.16537063f, -0.00854352f, 0.02803421f, 
    -0.02722797f, -0.09220628f, 0.05864754f, -0.14507358f, 0.07198119f, -0.09211811f, 0.08674251f, 0.03004821f, 
    -0.12488227f, -0.07111279f, -0.02719250f, 0.06441820f, 0.37372875f, -0.35181794f, 0.00394741f, 0.12509403f, 
    -0.04049176f, 0.21415101f, 0.10983148f, -0.03806149f, -0.08076192f, 0.18998328f, -0.12674227f, 0.20599079f, 
    0.03534897f, -0.04976612f, 0.03578715f, 0.00234101f, 0.09796920f, -0.20637164f, -0.15120766f, 0.19415444f, 
    0.01631281f, -0.13410395f, 0.36073592f, 0.06312218f, -0.02593883f, 0.04871244f, 0.04765771f, -0.19302240f, 
    0.09740766f, 0.20122792f, 0.02786970f, 0.05487892f, 0.11259045f, 0.07707820f, -0.07742697f, 0.08495355f, 
    -0.00514703f, 0.09736838f, 0.03652783f, 0.03499080f, 0.17966299f, 0.00386394f, -0.34915015f, 0.12390414f, 
    0.03976133f, 0.04709461f, 0.16621165f, 0.01368148f, 0.08801260f, 0.13378088f, 0.03179479f, 0.03357271f, 
    -0.08459771f, 0.02129002f, 0.06759975f, 0.02321789f, 0.07279816f, -0.03247624f, 0.03092243f, 0.12325899f, 
    0.17446020f, -0.22424348f, 0.42568362f, 0.07930356f, -0.06404812f, -0.08708465f, 0.00626043f, -0.19414112f, 
    0.02597497f, 0.11041912f, -0.15125293f, 0.04507386f, 0.02374494f, 0.09233841f, -0.02741648f, -0.05805730f, 
    0.03864083f, 0.01906607f, -0.07496198f, 0.13115485f, 0.34949759f, 0.01446906f, 0.19681856f, -0.23627582f, 
    -0.11572085f, 0.09730336f, -0.26062581f, -0.16986677f, -0.00422706f, 0.04931231f, -0.09321623f, 0.04654804f, 
    -0.02208194f, 0.09009606f, 0.12539609f, -0.01855605f, 0.06862862f, 0.13631636f, -0.02820941f, 0.12100875f, 
    -0.10445058f, -0.15007775f, -0.13365227f, 0.13733357f, -0.00566605f, -0.05929695f, 0.04592043f, -0.13108568f, 
    -0.06994005f, 0.02014927f, 0.00075518f, -0.11680540f, 0.03025642f, 0.05126891f, 0.03803003f, 0.00514624f, 
    0.09118345f, 0.07329981f, 0.10298301f, -0.01571680f, -0.17943975f, -0.21713735f, -0.23114607f, -0.12015028f, 
    -0.01843291f, -0.11447179f, -0.13272440f, -0.01521439f, 0.04341328f, -0.23070745f, -0.06107536f, -0.04463053f, 
    -0.13111001f, 0.03724387f, -0.00774573f, 0.00101704f, 0.11790846f, 0.14543989f, 0.02457159f, 0.10693620f, 
    -0.22192909f, 0.02714753f, 0.09043720f, 0.20943588f, -0.08315730f, 0.11783420f, -0.20827292f, 0.08290941f, 
    0.10950299f, -0.05214924f, 0.08555581f, 0.07063875f, 0.13462977f, -0.09761464f, 0.03636651f, 0.16332188f, 
    0.01370223f, -0.07836362f, -0.29991260f, -0.26024526f, -0.34972778f, -0.06573313f, 0.23275883f, 0.31663367f, 
    -0.05492297f, 0.11286974f, -0.06165046f, 0.05914263f, 0.18647845f, -0.10677357f, 0.11030398f, 0.07569082f, 
    0.08670323f, -0.08992518f, -0.01816581f, 0.13905889f, -0.12366941f, -0.08141872f, -0.05907422f, 0.01789741f, 
    0.13382831f, -0.26853532f, 0.19120748f, -0.21409170f, 0.09339104f, -0.08334605f, 0.15908590f, -0.01977469f, 
    -0.11636010f, -0.10913771f, 0.18330918f, 0.03106395f, -0.00519183f, -0.01862587f, 0.10700697f, -0.06609736f, 
    0.08227937f, 0.19565630f, -0.04406965f, -0.14916727f, -0.00387708f, 0.29044047f, 0.29994544f, -0.18098713f, 
    0.21065937f, -0.12263854f, -0.09203274f, -0.03345682f, 0.04521210f, 0.05920689f, 0.06152657f, -0.00386066f, 
    0.04488079f, -0.00070608f, 0.04878612f, 0.00440121f, -0.05180924f, 0.04158597f, 0.12017029f, -0.05181562f, 
    0.28586420f, 0.31140089f, 0.31276932f, 0.32221848f, -0.14070523f, -0.05295282f, -0.03751170f, 0.08446342f, 
    0.05928170f, -0.01809571f, 0.13960180f, -0.06659875f, 0.03772780f, 0.09124403f, 0.03472605f, 0.01918027f, 
    0.01879902f, -0.08326395f, -0.07619239f, 0.22732678f, 0.27244800f, 0.19373281f, -0.06580624f, -0.18038955f, 
    0.00565872f, -0.06005473f, 0.17583822f, -0.14290115f, -0.16458966f, -0.08635463f, -0.02694461f, -0.08217899f, 
    0.05007798f, -0.02101193f, -0.00815606f, -0.25223556f, 0.04852153f, -0.05591254f, -0.06508393f, -0.02936361f, 
    0.41883087f, -0.00608776f, -0.18123314f, -0.29840073f, 0.04087030f, 0.06386811f, 0.06980044f, -0.01703477f, 
    -0.07071024f, -0.10627499f, -0.00494115f, -0.15375666f, 0.00069279f, 0.00351222f, 0.06963294f, 0.07398394f, 
    0.00198086f, 0.06441335f, 0.02269988f, -0.18311180f, 0.13290837f, 0.12843110f, -0.18488532f, -0.22300826f, 
    -0.20879751f, -0.06554415f, 0.13311739f, -0.00535576f, 0.06147627f, -0.04141827f, 0.04613289f, -0.04599823f, 
    0.12713702f, -0.04646539f, 0.07188661f, -0.06600955f, 0.09342558f, -0.01339529f, -0.03757632f, 0.00058123f, 
    0.29872367f, 0.03502080f, -0.50653172f, 0.13564707f, 0.09250226f, 0.06299739f, 0.07010991f, 0.29103425f, 
    -0.07767010f, 0.04741395f, -0.01548678f, -0.03016693f, -0.12036976f, 0.02452686f, -0.00546573f, -0.00415452f, 
    -0.10263430f, 0.08568441f, -0.08836129f, 0.15483901f, 0.20921943f, 0.39091974f, 0.37795669f, 0.07937972f, 
    0.16808890f, 0.09830747f, -0.00712758f, -0.11334131f, -0.07987322f, -0.11274622f, 0.09577131f, 0.04372368f, 
    -0.01536275f, 0.06084853f, 0.02999070f, -0.01986014f, 0.03652748f, -0.07316384f, 0.06906612f, -0.07723978f, 
    -0.11427492f, 0.19429401f, 0.16504145f, -0.13969788f, 0.08239903f, -0.00430357f, -0.08720136f, -0.00951546f, 
    -0.08986788f, -0.16705297f, 0.01645960f, 0.01362147f, -0.00982466f, 0.01549766f, 0.00373875f, 0.01545340f, 
    0.04348506f, -0.05459899f, -0.11029008f, -0.11031923f, -0.13247284f, -0.27778873f, -0.39918566f, 0.05811077f, 
    -0.10928816f, 0.04246553f, 0.05521164f, 0.12044938f, -0.17689995f, 0.26566976f, 0.04334266f, 0.03750539f, 
    0.04242964f, -0.15492505f, -0.12011643f, -0.04215848f, 0.06654188f, -0.06601051f, 0.07983159f, 0.06452215f, 
    -0.20554595f, 0.20342666f, 0.24957405f, -0.04614866f, 0.00606994f, -0.16486232f, -0.23330203f, -0.10762640f, 
    -0.05448854f, -0.13857649f, 0.05689288f, 0.03785345f, -0.02301165f, 0.00366216f, 0.06440786f, -0.07015008f, 
    0.06547680f, -0.00830453f, 0.12985942f, 0.09225912f, 0.27662858f, 0.15468720f, 0.16818127f, -0.07117666f, 
    0.06161496f, -0.16570398f, 0.00807224f, 0.01359249f, 0.00849150f, -0.09026726f, 0.03562377f, 0.01975696f, 
    0.03539930f, 0.00072684f, 0.01010991f, -0.12262966f, 0.11671829f, -0.00301316f, 0.13471816f, -0.02550008f, 
    0.03237705f, 0.15414067f, 0.14925930f, -0.04721835f, -0.17009464f, 0.04035118f, 0.09643166f, 0.03178807f, 
    -0.00138268f, -0.02267932f, 0.07282729f, -0.06842171f, 0.04781679f, -0.03723830f, -0.04232451f, -0.15196282f, 
    -0.05041854f, -0.05441625f, -0.11963005f, -0.02958052f, -0.09243868f, 0.00992701f, -0.28265727f, 0.11583241f, 
    -0.05917516f, 0.10863899f, 0.20744583f, 0.22138883f, 0.10540066f, 0.22170772f, 0.01675194f, 0.15576555f, 
    -0.08422229f, 0.10156354f, 0.03048287f, -0.00986316f, -0.01570332f, 0.15134589f, 0.01349133f, 0.03677895f, 
    0.44695213f, 0.30545568f, 0.19661845f, -0.40177900f, 0.05808724f, 0.11679357f, -0.02553153f, -0.04947127f, 
    -0.01825544f, 0.11732417f, -0.03800279f, -0.05074260f, -0.06672215f, -0.09031650f, -0.04334484f, -0.06159605f, 
    -0.11584733f, 0.19517173f, 0.04563976f, -0.13408002f, 0.37331200f, 0.24616292f, -0.41366178f, -0.54542714f, 
    0.00024044f, 0.21719700f, 0.08876409f, 0.11788055f, -0.06061047f, 0.11913150f, -0.15193515f, -0.00526510f, 
    -0.04854773f, 0.16254485f, 0.03569883f, 0.00133258f, -0.00214681f, 0.06911728f, 0.09973495f, 0.13297933f, 
    0.04439030f, -0.05180497f, 0.28547165f, 0.04732414f, -0.03953390f, -0.06951072f, 0.06620163f, 0.00818571f, 
    -0.02922625f, 0.05949530f, 0.01085046f, 0.04840302f, 0.06670544f, -0.02749539f, 0.09643653f, 0.01600937f, 
    -0.00061511f, 0.04886541f, 0.12991929f, -0.12269029f, 0.52430212f, 0.14044128f, 0.03603697f, 0.16187824f, 
    0.08781950f, 0.13743447f, -0.17903845f, -0.11669495f, 0.03187374f, 0.14077309f, -0.00786981f, -0.09379418f, 
    -0.00904450f, -0.07733506f, 0.05750377f, 0.14151321f, -0.00547509f, -0.12299744f, 0.07391930f, 0.07547607f, 
    0.28408235f, 0.14496255f, 0.03340802f, 0.30929619f, 0.18156257f, -0.07961944f, -0.03478982f, 0.05224789f, 
    0.05563032f, -0.07541103f, 0.00931928f, 0.00498908f, -0.07192157f, 0.12538309f, 0.14632803f, 0.23330231f, 
    -0.02690372f, 0.00650260f, 0.02639693f, -0.09901302f, -0.28738272f, -0.00267150f, -0.25443152f, 0.46361461f, 
    0.06966428f, -0.13381006f, 0.04515168f, 0.11363596f, 0.04339830f, 0.13552862f, 0.00691881f, -0.03749262f, 
    -0.09676958f, -0.07407383f, -0.03501682f, 0.05089543f, -0.02514514f, 0.03288295f, -0.06640352f, 0.09414981f, 
    0.25675151f, -0.34043843f, -0.04379436f, -0.05643602f, -0.09081086f, 0.11623683f, -0.11466825f, -0.04348033f, 
    -0.04416440f, -0.01240714f, -0.09035588f, -0.01962182f, -0.04043912f, -0.09285099f, 0.01866208f, -0.02641419f, 
    -0.01470201f, 0.06319400f, 0.05588300f, -0.10771338f, 0.12555850f, 0.12411278f, -0.16382226f, -0.01315657f, 
    -0.19476239f, -0.03670015f, -0.01155570f, -0.01790616f, 0.02013951f, -0.00209649f, 0.00506594f, -0.14378108f, 
    -0.09295759f, 0.12924883f, -0.07212408f, -0.09484962f, -0.08476867f, 0.04768375f, 0.03527777f, -0.00777412f, 
    -0.52504015f, -0.58373982f, -0.53590518f, 0.12056089f, -0.20028651f, 0.10668816f, 0.08807591f, 0.22308511f, 
    0.16969620f, -0.06343328f, -0.17354500f, 0.04677996f, -0.15376638f, 0.00319919f, -0.07126505f, 0.01209373f, 
    0.02187217f, 0.12054948f, 0.12116348f, 0.28060475f, 0.33399045f, -0.09634992f, 0.51756299f, -0.00206893f, 
    -0.19825120f, 0.15474950f, 0.06045271f, 0.24831115f, 0.05739451f, 0.06123415f, -0.02964483f, -0.05130893f, 
    0.16022667f, -0.08350586f, 0.05263472f, 0.00986529f, 0.31023580f, 0.17148417f, -0.07583130f, 0.12190127f, 
    0.43211162f, 0.17558548f, 0.21694575f, 0.01569253f, -0.13813154f, 0.05627154f, -0.03479394f, 0.03135190f, 
    0.01431831f, -0.01237872f, -0.01171160f, 0.01727803f, 0.00450796f, 0.00497534f, 0.05116324f, 0.07452711f, 
    0.07303455f, 0.07221616f, 0.10216675f, -0.08527505f, -0.05687126f, -0.08652140f, -0.18973117f, 0.11464761f, 
    -0.25510564f, -0.11234666f, -0.04210468f, 0.05340823f, 0.01686445f, 0.01665134f, -0.17054771f, -0.06164619f, 
    0.03610810f, -0.11820661f, -0.03230641f, -0.06946736f, -0.05517997f, 0.08460020f, -0.13955736f, 0.02050324f, 
    0.43759039f, 0.24870658f, 0.20948331f, 0.18515587f, -0.05037037f, -0.03715770f, -0.10506377f, -0.09849413f, 
    0.11778035f, 0.05710335f, -0.02439206f, 0.06713139f, -0.04175605f, -0.00465932f, -0.03857173f, 0.10940898f, 
    0.03484662f, 0.02411410f, 0.05899597f, 0.07108119f, 0.01302338f, 0.02465734f, 0.32740769f, 0.07277366f, 
    -0.14555764f, 0.05990287f, -0.07459208f, -0.00583264f, 0.06406286f, 0.03989154f, -0.07026825f, -0.02632579f, 
    0.05317742f, 0.11092451f, -0.00814148f, 0.09327840f, 0.08941408f, -0.06897967f, -0.07090567f, 0.02538414f, 
    0.20374787f, 0.12752821f, 0.19022623f, 0.11236105f, -0.00407421f, -0.05157180f, 0.04457230f, -0.00092660f, 
    0.02382525f, -0.01705057f, -0.01258741f, -0.02518972f, -0.06957226f, 0.04091010f, -0.07322157f, -0.08307364f, 
    -0.04045624f, 0.04393895f, -0.09349832f, -0.11678808f, -0.42136845f, -0.34223214f, -0.10786569f, 0.26224720f, 
    0.00621934f, -0.07356063f, 0.05313171f, 0.17860648f, 0.08905898f, 0.14154355f, 0.07888073f, 0.12494053f, 
    -0.08513904f, 0.10716581f, 0.06987584f, -0.05821771f, 0.01961529f, -0.09527965f, -0.08714630f, -0.18069232f, 
    0.25789434f, -0.01541232f, 0.13967562f, -0.33831912f, 0.11316587f, 0.27596679f, -0.01875197f, -0.13106713f, 
    0.03878939f, 0.23754825f, -0.10448282f, -0.07613646f, -0.04114692f, 0.02343364f, -0.06188729f, -0.05734519f, 
    -0.06248935f, -0.09858713f, 0.10917435f, 0.05989144f, 0.12358468f, -0.30981672f, -0.72320539f, -0.43047047f, 
    -0.32665214f, 0.15152924f, -0.10012802f, -0.03943986f, -0.08538255f, 0.11952399f, -0.05010765f, -0.01182428f, 
    -0.01286100f, 0.13615896f, 0.03433304f, 0.05979338f, 0.00535177f, 0.04397725f, 0.08476711f, 0.24820016f, 
    0.13126120f, 0.27160823f, -0.38002926f, 0.27113447f, -0.00920381f, 0.02778937f, -0.10084973f, 0.05985862f, 
    0.02901331f, 0.05463820f, -0.10199950f, 0.12768044f, 0.15464406f, -0.15695632f, -0.04696449f, -0.02425665f, 
    0.13015400f, 0.03597960f, 0.28611290f, 0.01542469f, -0.19673921f, -0.15304531f, -0.29056168f, -0.31257647f, 
    -0.37244043f, -0.12927532f, -0.18231522f, -0.06133374f, -0.15868413f, -0.15305208f, -0.10483544f, -0.09452695f, 
    0.00094940f, -0.00702935f, 0.00900635f, 0.09386978f, -0.11936361f, -0.07562693f, -0.03208980f, -0.24045314f, 
    0.41576153f, -0.03102090f, 0.22526638f, 0.21624909f, 0.21022196f, -0.09717168f, 0.09869847f, -0.06352749f, 
    -0.02422374f, -0.18937054f, -0.08141208f, -0.03035243f, -0.00074051f, -0.03106498f, -0.14834443f, 0.14183694f, 
    -0.04003966f, -0.11923694f, -0.03093064f, -0.21878242f, -0.24497482f, -0.24581921f, 0.45956710f, -0.18995750f, 
    0.19699730f, 0.03156263f, 0.16615653f, 0.06417561f, 0.11942612f, 0.18806179f, 0.05608477f, 0.09068318f, 
    -0.05909533f, 0.04162934f, 0.18652241f, 0.02007937f, -0.13804480f, -0.00939982f, 0.01938442f, 0.01465815f, 
    -0.32781807f, 0.13415952f, -0.06383229f, 0.07983951f, 0.12218571f, -0.04810381f, 0.10670275f, -0.00182392f, 
    0.13327193f, 0.00351435f, -0.12108802f, 0.08395889f, 0.14353590f, 0.06954733f, -0.03332905f, 0.19214047f, 
    0.02873108f, 0.11863402f, 0.00591964f, -0.01537695f, -0.08123451f, -0.35671845f, -0.31583467f, 0.01511016f, 
    -0.05824059f, -0.06826632f, 0.01061762f, -0.02486736f, -0.12681706f, -0.06493860f, -0.10151772f, 0.10528426f, 
    0.01991838f, -0.00449014f, 0.16675143f, -0.01979995f, -0.09676281f, 0.00546353f, 0.02210546f, -0.16068105f, 
    0.39093623f, 0.39624494f, 0.11834934f, 0.28979728f, -0.28543684f, 0.04705325f, 0.06713957f, 0.02846505f, 
    0.08348998f, -0.00894932f, 0.05931421f, -0.15699299f, 0.00167147f, -0.00723110f, 0.01846708f, 0.09467337f, 
    -0.14931716f, -0.01269595f, -0.07217801f, 0.10888615f, 0.05546047f, -0.43070450f, 0.36478344f, 0.05392871f, 
    0.23488918f, 0.05011348f, -0.14750005f, -0.00487028f, 0.12916060f, 0.07623326f, 0.08465165f, 0.10282853f, 
    -0.19432409f, -0.02447501f, -0.03609692f, 0.04905479f, 0.16693948f, 0.01789848f, 0.05847609f, 0.02065897f, 
    0.26234388f, -0.05172699f, 0.22494127f, 0.24657661f, -0.00325577f, -0.00371221f, -0.03979678f, 0.09615999f, 
    0.05517771f, -0.08038698f, 0.00954460f, 0.16176344f, -0.03685698f, 0.05521076f, -0.07800484f, -0.06539782f, 
    0.03165487f, 0.14256321f, 0.07870252f, -0.07581016f, 0.38572082f, -0.08022317f, -0.22053538f, 0.13102344f, 
    -0.16714066f, 0.00819457f, 0.08904420f, -0.16580516f, 0.06998506f, 0.18057586f, -0.00488425f, -0.05844998f, 
    0.01833797f, -0.01964735f, 0.00129188f, -0.17325208f, 0.03372540f, -0.15244222f, 0.12082921f, -0.06045445f, 
    0.15118760f, -0.26084605f, 0.50056833f, -0.14641581f, -0.01520696f, -0.13728637f, 0.02059543f, -0.11676949f, 
    0.04878009f, 0.05091927f, -0.15002570f, 0.09065079f, 0.02130622f, 0.12778510f, 0.01795096f, -0.11389998f, 
    0.08168566f, -0.00753294f, 0.13189760f, 0.03596080f, 0.23501408f, -0.04717547f, 0.48521093f, -0.49178064f, 
    0.05375779f, -0.01937753f, -0.01057782f, 0.01158735f, -0.05021562f, -0.02284478f, -0.01137539f, -0.02350725f, 
    -0.03063482f, 0.19064756f, 0.06667865f, -0.03048331f, -0.00269218f, 0.01052387f, 0.16493984f, 0.18848085f, 
    0.29176843f, -0.08932599f, 0.14648080f, 0.09535549f, 0.03656150f, -0.05921904f, -0.07391164f, -0.11690346f, 
    -0.09092545f, -0.10442954f, -0.04990833f, 0.01169970f, 0.09462664f, -0.03461268f, -0.13044003f, 0.07098085f, 
    0.04197069f, 0.03203548f, -0.09117673f, 0.01254063f, -0.49614099f, -0.10716531f, -0.35071048f, 0.14785276f, 
    -0.16244647f, 0.01591765f, -0.02307549f, -0.04667912f, -0.03439092f, -0.14656448f, 0.11218013f, -0.02942483f, 
    -0.06119714f, 0.20524676f, -0.04965401f, -0.03800470f, -0.06632974f, -0.00732934f, 0.00777474f, 0.10614043f, 
    -0.07138138f, 0.22577345f, -0.07267693f, 0.13820149f, 0.04267960f, 0.18658985f, 0.06286333f, 0.17709047f, 
    0.06290205f, -0.02995666f, -0.08401300f, 0.03411269f, 0.07573899f, -0.14922930f, 0.02189515f, -0.17295846f, 
    -0.08425250f, -0.10939891f, -0.16014843f, -0.11845433f, -0.00979641f, 0.15991330f, 0.24232268f, 0.25119299f, 
    0.07014005f, 0.15705283f, -0.01208003f, 0.11618443f, 0.17868043f, -0.06524481f, 0.13609366f, 0.07324249f, 
    0.04571011f, -0.09709559f, -0.06043818f, 0.16588466f, -0.10902607f, -0.10770247f, -0.03419221f, -0.06475965f, 
    -0.13565879f, -0.00861578f, 0.15258603f, -0.70828444f, 0.27821168f, -0.11751554f, 0.10113864f, -0.17155184f, 
    -0.24112101f, -0.30998835f, 0.18100709f, 0.00269288f, 0.11513171f, 0.05636012f, -0.01303669f, 0.09114567f, 
    -0.03269780f, 0.11830993f, -0.29437906f, -0.21521433f, 0.00927204f, 0.62877458f, 0.43474913f, 0.10338661f, 
    -0.10046612f, -0.11580440f, 0.15742156f, -0.04489863f, 0.28060493f, 0.34394950f, 0.12776615f, -0.08774334f, 
    -0.00159266f, -0.08254603f, -0.06525248f, -0.15706982f, 0.19117726f, 0.01175660f, 0.09675611f, 0.15084137f, 
    0.24084264f, 0.01096422f, -0.17713436f, -0.01407916f, -0.16083691f, 0.02686351f, -0.13176359f, 0.10704966f, 
    0.02897118f, 0.13626167f, 0.05258367f, 0.03127016f, 0.06081261f, -0.06039261f, -0.04079573f, -0.07353882f, 
    0.01414642f, 0.15563568f, 0.26878512f, 0.24263361f, -0.00878607f, 0.24194999f, 0.00718291f, -0.03896040f, 
    -0.34527943f, 0.19738813f, -0.07208608f, -0.21740583f, 0.05628862f, 0.10543607f, 0.19245213f, -0.06401705f, 
    -0.01145276f, 0.13578857f, -0.02933740f, -0.04193917f, 0.08142258f, -0.09149982f, 0.07594415f, 0.04998374f, 
    0.25404596f, 0.15663816f, 0.22897719f, 0.10008024f, 0.04986081f, 0.12020873f, 0.07275667f, 0.14289276f, 
    -0.05384613f, 0.09768388f, 0.12387399f, -0.04123286f, -0.03882741f, 0.03647911f, 0.00240421f, -0.02347991f, 
    -0.00315488f, 0.00352138f, -0.13893618f, 0.03567727f, 0.11602413f, 0.20460285f, -0.06650319f, -0.26530188f, 
    0.33833829f, 0.06161492f, -0.08102986f, -0.12262094f, 0.03870042f, -0.18884304f, 0.11494559f, 0.03955310f, 
    0.07206706f, 0.02862432f, 0.04924259f, 0.10572731f, 0.02740058f, 0.02385686f, -0.00188883f, -0.09667050f, 
    0.47917256f, 0.29656228f, 0.23920840f, -0.14821066f, -0.02143474f, -0.00667614f, 0.07851085f, 0.14729469f, 
    -0.13652605f, 0.05295738f, 0.12920839f, 0.00479959f, 0.03260177f, -0.06826806f, 0.21851541f, 0.06012269f, 
    -0.03380790f, -0.11499192f, 0.10269564f, -0.06345233f, -0.22483101f, 0.47841924f, -0.39573231f, 0.00531806f, 
    -0.01801842f, -0.01677759f, 0.08277246f, -0.08515529f, -0.25711215f, 0.18505384f, 0.15993838f, 0.07608398f, 
    -0.05775027f, -0.14905840f, -0.00414518f, -0.12533984f, 0.01344515f, 0.01459889f, -0.04982228f, 0.16370925f, 
    -0.24040624f, -0.11478535f, -0.18738276f, -0.45868877f, 0.18315414f, -0.04639794f, 0.05146608f, -0.06295478f, 
    0.03791650f, -0.02140811f, -0.00195637f, -0.04936898f, 0.00789270f, -0.01460150f, -0.01352359f, -0.05561595f, 
    0.04297432f, -0.04108590f, 0.03784267f, -0.16712914f, 0.43732482f, -0.15492170f, -0.10848098f, -0.21647887f, 
    -0.03488167f, 0.02820845f, -0.03478954f, 0.24758619f, -0.27296948f, -0.19620052f, 0.13021290f, 0.21356164f, 
    0.02349920f, 0.00453924f, -0.03993649f, 0.12964664f, -0.03264861f, 0.19090132f, -0.14854082f, 0.07995666f, 
    -0.23333248f, 0.02107231f, -0.33031875f, -0.13829646f, 0.09476122f, 0.02688575f, -0.01807117f, -0.11651091f, 
    0.02884630f, 0.24211621f, 0.25246507f, -0.07725866f, -0.16276054f, -0.01791287f, 0.02326341f, 0.02745894f, 
    -0.01129466f, -0.09192941f, 0.06409266f, -0.02863190f, -0.16101263f, 0.18077052f, -0.19887109f, 0.16554952f, 
    -0.08588742f, -0.12316848f, -0.00503866f, -0.16846770f, 0.04128305f, 0.13887556f, 0.14588469f, -0.09580149f, 
    -0.02473191f, -0.12844156f, 0.04479334f, -0.05227310f, -0.01202884f, 0.03295464f, 0.02335094f, -0.09804441f, 
    0.09775666f, -0.11781256f, -0.39662603f, -0.35096318f, 0.06890788f, 0.01827961f, 0.01504855f, -0.01095408f, 
    -0.21404043f, -0.06081694f, 0.14170429f, 0.08078301f, -0.09384058f, -0.03324399f, -0.01646526f, 0.01945250f, 
    0.05898988f, 0.07955235f, -0.03032025f, -0.10236420f, 0.38704181f, 0.37747139f, 0.24165693f, -0.17023827f, 
    0.01082331f, 0.03207717f, 0.06274831f, -0.02168416f, -0.04709635f, -0.13948460f, 0.07129312f, 0.05829244f, 
    0.00125778f, 0.01281463f, 0.03128559f, -0.04712139f, -0.13063718f, -0.09405464f, -0.03367309f, -0.05419832f, 
    0.17918512f, 0.15769623f, 0.60592198f, -0.00214420f, -0.05600315f, 0.09219646f, 0.15317968f, -0.09960712f, 
    0.12983321f, 0.06140467f, 0.09639034f, 0.02025817f, 0.04852821f, 0.06326187f, 0.07646176f, 0.00011406f, 
    0.17713480f, 0.02121091f, -0.05253236f, 0.21247891f, 0.43634123f, 0.15861888f, 0.32189119f, -0.14161746f, 
    0.07302706f, 0.02166049f, 0.16355816f, 0.07019096f, 0.15003613f, 0.04563200f, 0.15407917f, 0.00141787f, 
    0.09304514f, -0.02354276f, 0.18081069f, 0.00583775f, -0.00072879f, -0.00683963f, 0.11595320f, -0.02463741f, 
    -0.18290615f, -0.16134611f, 0.37457916f, -0.20173003f, -0.28097606f, -0.11901190f, 0.09013403f, -0.04332241f, 
    -0.09122016f, -0.05048446f, -0.09163961f, -0.04555621f, -0.25734583f, 0.02841201f, 0.10677991f, -0.04556639f, 
    -0.15229578f, -0.01725838f, -0.44249666f, -0.29967374f, 0.08440437f, -0.12905288f, 0.09510730f, 0.23102607f, 
    0.57036048f, 0.04240997f, 0.17408314f, 0.18489082f, 0.27423596f, 0.14038385f, -0.08645491f, -0.06095065f, 
    -0.00070480f, -0.10532060f, 0.01297869f, 0.09482749f, 0.24231929f, 0.13445881f, 0.19126143f, 0.09498531f, 
    -0.21307866f, 0.14022416f, -0.10705643f, 0.10395452f, -0.09852188f, 0.02869745f, -0.11612082f, 0.15547575f, 
    0.04836365f, -0.02661492f, 0.12694594f, 0.10968231f, 0.01599823f, 0.12091302f, 0.06330529f, 0.10598143f, 
    0.29309118f, 0.10169107f, 0.16189308f, 0.27574643f, 0.52808017f, -0.07009632f, -0.24159896f, 0.05904836f, 
    -0.04114027f, 0.02394859f, 0.06233781f, 0.03663161f, -0.24530709f, 0.09656974f, -0.00218516f, -0.16795412f, 
    0.08853151f, -0.02019035f, -0.05998128f, 0.08699115f, 0.06230121f, -0.03236555f, 0.09827012f, 0.21600884f, 
    0.40372729f, -0.00430528f, 0.10952798f, -0.03218450f, 0.11051719f, 0.06168266f, -0.12842235f, 0.01594050f, 
    0.05345479f, -0.00420796f, 0.05966362f, -0.10258015f, 0.01251125f, 0.01045514f, 0.03333935f, -0.00372279f, 
    -0.07676162f, 0.01070930f, 0.01915304f, 0.11172064f, 0.22621600f, 0.46951288f, 0.08681810f, -0.09009714f, 
    0.05870580f, -0.09130739f, -0.00087596f, 0.04519068f, -0.13230711f, -0.70005661f, -0.06412076f, -0.14110528f, 
    0.10695431f, -0.10849917f, 0.02654052f, -0.05883453f, 0.05580012f, -0.31092682f, 0.00983092f, 0.11164078f, 
    -0.20058699f, -0.02510010f, -0.10125754f, 0.32942137f, 0.06950568f, 0.06017246f, -0.20870426f, 0.05098578f, 
    0.12944080f, -0.01516341f, -0.11483122f, -0.03156399f, 0.00690981f, 0.10901142f, -0.01966645f, 0.06487034f, 
    0.14383526f, 0.20647551f, 0.21061040f, 0.13181424f, 0.20386608f, 0.42192334f, 0.20253430f, -0.09683333f, 
    -0.06589861f, -0.08884703f, 0.06448393f, -0.06296345f, -0.01617575f, -0.21853717f, -0.04810781f, -0.16718069f, 
    -0.01663519f, -0.07137553f, -0.05820635f, -0.01741589f, 0.03539345f, -0.11776644f, 0.26942444f, -0.14960721f, 
    -0.03346951f, 0.03469843f, -0.10437323f, -0.02925034f, -0.12837684f, 0.19577689f, 0.04612868f, 0.00181480f, 
    -0.15796672f, -0.28475207f, -0.11869104f, -0.09389820f, -0.18726656f, -0.26141036f, 0.02646082f, 0.11147004f, 
    0.19290458f, 0.09979496f, -0.19674294f, -0.03525313f, -0.25504634f, 0.12299411f, 0.00383985f, 0.13045132f, 
    -0.07861405f, -0.31703210f, -0.26886845f, -0.12108734f, -0.28855509f, -0.41462022f, 0.03951740f, -0.04238689f, 
    -0.13753378f, 0.00784098f, 0.16325982f, -0.11652504f, -0.21174894f, -0.01833199f, -0.10743029f, -0.32512313f, 
    -0.13495885f, 0.16388659f, 0.25218126f, 0.15406390f, 0.10974384f, 0.06467208f, 0.02082099f, 0.00041975f, 
    -0.07819693f, -0.05817179f, -0.05104196f, -0.19984287f, -0.13578530f, -0.21749140f, -0.13997495f, 0.15917704f, 
    0.04310309f, -0.07970065f, -0.11691908f, -0.16316478f, 0.05297059f, 0.25662923f, 0.09231231f, 0.33915091f, 
    0.10641657f, -0.00115856f, 0.10604049f, -0.00518696f, -0.03648977f, -0.03023136f, 0.08857318f, -0.11857362f, 
    -0.18032670f, -0.30013850f, -0.10124000f, -0.04712966f, -0.10329929f, -0.24857733f, -0.03969447f, -0.32223400f, 
    -0.11939670f, 0.02596627f, 0.02244058f, -0.08678966f, 0.03827941f, -0.00147304f, -0.07223116f, 0.05713496f, 
    -0.12407493f, -0.32224476f, -0.01738611f, 0.02523227f, 0.07842156f, -0.20529659f, -0.05724072f, 0.13075043f, 
    -0.06868495f, -0.17089112f, -0.30074582f, 0.01999930f, 0.14044981f, 0.08107628f, 0.21643707f, 0.21614534f, 
    0.19700724f, -0.14504468f, -0.02294077f, 0.11565869f, -0.08309284f, 0.27774170f, 0.13640450f, 0.00892252f, 
    -0.02550565f, -0.01811576f, -0.03403640f, -0.08358615f, -0.25536406f, -0.09804907f, -0.26476708f, -0.33550027f, 
    0.08823416f, -0.02722914f, -0.09947074f, 0.00439977f, 0.07848407f, -0.04282594f, 0.13881683f, -0.09063363f, 
    0.03715411f, 0.26034307f, 0.01682108f, 0.05664527f, 0.01632772f, 0.09491411f, 0.03031069f, -0.04598669f, 
    0.01595887f, 0.25704265f, 0.18116422f, 0.28409261f, 0.08436206f, 0.21407543f, -0.18085796f, 0.10229354f, 
    0.13041669f, -0.00561767f, 0.03658449f, -0.04411402f, -0.01367460f, 0.09620186f, -0.06061893f, 0.00951166f, 
    -0.03160398f, 0.25318545f, 0.10840141f, -0.05983938f, 0.20693643f, 0.25204584f, 0.26311430f, 0.12684095f, 
    -0.32806268f, 0.33809236f, 0.04665685f, -0.23273367f, -0.13477041f, -0.04180542f, 0.08744007f, 0.08932435f, 
    0.06191285f, 0.08510311f, -0.06036920f, 0.12741514f, -0.05981242f, -0.04114129f, 0.05253430f, -0.05360844f, 
    -0.23332067f, 0.11804482f, -0.26675513f, -0.30437532f, -0.07485858f, -0.57017875f, 0.14493662f, 0.06810638f, 
    0.35710821f, -0.15744418f, 0.08641770f, 0.00156782f, 0.10000225f, -0.00675148f, -0.07136004f, -0.14936045f, 
    0.01734420f, -0.15967055f, -0.00318786f, -0.02745510f, 0.09364808f, 0.12631252f, 0.15555649f, 0.11133121f, 
    -0.29538444f, 0.06082420f, -0.19911902f, -0.21511568f, -0.13367391f, 0.03009196f, 0.09562168f, 0.10826549f, 
    0.10481536f, 0.16162713f, -0.09195884f, -0.18842573f, 0.04002050f, -0.05877489f, 0.02814498f, 0.18038446f, 
    0.14916036f, -0.02243061f, 0.28695726f, 0.15449271f, 0.56049532f, -0.14629926f, -0.35694894f, -0.27433065f, 
    0.16741058f, 0.07686440f, 0.00465728f, -0.16569138f, -0.03535689f, 0.04031694f, -0.00037673f, -0.11782081f, 
    0.20007879f, 0.04604468f, 0.05832332f, 0.05606304f, 0.04077397f, -0.06856637f, 0.20099758f, 0.18071271f, 
    0.10200891f, -0.06044327f, -0.18810584f, 0.05065896f, 0.08581376f, 0.01866303f, 0.05311851f, 0.04844580f, 
    -0.03028138f, 0.00107196f, 0.05865237f, -0.04029448f, -0.01986278f, -0.01457058f, -0.08655691f, 0.06204789f, 
    0.02552676f, 0.17811307f, 0.01226631f, 0.16087048f, -0.27573147f, -0.01249252f, 0.12580487f, -0.05896370f, 
    0.18685664f, 0.04225811f, -0.05279518f, 0.12347855f, 0.11813529f, 0.07714951f, -0.13896695f, 0.02797537f, 
    0.02031531f, 0.00631128f, 0.02119860f, -0.01185661f, -0.15307119f, -0.29567736f, -0.09556697f, -0.04177202f, 
    -0.19538972f, 0.20121384f, 0.14709115f, 0.10235434f, 0.24490052f, 0.00071862f, 0.00461126f, -0.12057704f, 
    -0.03739760f, -0.02501713f, -0.13111314f, 0.02150319f, 0.16789156f, 0.05397795f, 0.06650174f, 0.12877212f, 
    0.19291577f, -0.01219416f, 0.25754702f, 0.00977563f, 0.52403569f, 0.36786130f, -0.13154469f, -0.62531394f, 
    0.48360196f, -0.11712428f, 0.22190264f, 0.09488986f, -0.06390093f, -0.04469164f, 0.09740491f, -0.00956775f, 
    0.02670240f, -0.01998422f, 0.05503229f, -0.05200666f, 0.12538889f, 0.02003363f, 0.12126292f, 0.01387507f, 
    -0.00256112f, -0.02990441f, 0.26885912f, -0.27027461f, -0.06895372f, 0.05642494f, 0.08387677f, -0.07655840f, 
    0.18754043f, 0.12583749f, 0.04450418f, -0.07721996f, -0.03071208f, 0.06286652f, 0.13096513f, 0.07900487f, 
    0.12405732f, 0.28226051f, -0.13130033f, -0.06394509f, 0.07872624f, 0.49995247f, 0.21877304f, 0.22644107f, 
    0.41181546f, -0.07386567f, -0.10701863f, 0.12655471f, 0.03103853f, -0.18964601f, 0.15567468f, 0.00939698f, 
    -0.04816052f, 0.09851430f, 0.24104586f, 0.06839836f, -0.19279534f, -0.07548366f, -0.13531131f, -0.31000876f, 
    0.13257755f, -0.14672963f, 0.50716138f, -0.05042082f, 0.21952856f, -0.05760762f, 0.11056194f, -0.02281932f, 
    0.06450111f, 0.08973074f, 0.04520923f, -0.07007725f, -0.06640265f, 0.10677540f, -0.01478621f, 0.00129688f, 
    0.08898030f, -0.00328963f, -0.05060538f, -0.00854279f, 0.40057412f, -0.04657041f, 0.10942968f, -0.19178683f, 
    0.22784300f, 0.07202487f, 0.08938658f, -0.19232868f, -0.06752401f, 0.20679317f, 0.21144436f, -0.05892472f, 
    0.06141824f, -0.07190334f, 0.01468994f, -0.07641330f, -0.13299406f, -0.25817594f, -0.18042739f, -0.15113778f, 
    -0.04985895f, 0.03929460f, -0.05444475f, -0.10731545f, -0.03158601f, 0.05108632f, -0.00947967f, 0.12077990f, 
    0.07195341f, 0.19985065f, -0.05920128f, -0.05389605f, 0.05589335f, 0.04073487f, -0.01586002f, 0.09886099f, 
    0.03787804f, 0.02794197f, -0.07351048f, -0.07331346f, -0.24803650f, -0.13039008f, -0.22177699f, 0.17685685f, 
    0.16165099f, -0.04409328f, -0.08913753f, -0.02350832f, -0.00361402f, -0.27484977f, 0.08101881f, -0.00416906f, 
    0.03010228f, -0.09097543f, -0.09737949f, 0.07310904f, -0.33087313f, -0.09246291f, -0.22685073f, -0.42062879f, 
    -0.13470711f, -0.18446510f, -0.12916315f, -0.01237275f, -0.00640757f, -0.12755400f, 0.02972162f, -0.01634498f, 
    -0.02202308f, 0.03886714f, -0.13589182f, -0.07296684f, 0.01042810f, -0.12291469f, -0.06419554f, -0.02771407f, 
    0.06616580f, 0.28037065f, 0.06162539f, 0.14441158f, -0.22758688f, 0.03100972f, 0.04580884f, 0.27880812f, 
    0.30039141f, -0.01782739f, 0.09464783f, 0.00193869f, -0.03139689f, -0.01513201f, -0.12427069f, 0.08072603f, 
    0.01550113f, 0.05195878f, 0.10409825f, -0.03664804f, 0.11810779f, 0.11698381f, 0.03221567f, 0.02319231f, 
    -0.04714452f, 0.10049064f, -0.09837297f, 0.07534992f, 0.05615855f, 0.13073032f, -0.11364087f, 0.06834128f, 
    0.17262773f, 0.01837407f, -0.16132708f, 0.06823597f, 0.03799076f, -0.10713147f, 0.07169431f, 0.12054495f, 
    -0.06520282f, -0.00617181f, -0.08493636f, -0.06964591f, -0.39775044f, 0.22633958f, -0.23685946f, 0.06277822f, 
    -0.26614591f, 0.08083206f, -0.05313304f, -0.01995490f, -0.09025862f, 0.31230986f, -0.00173774f, 0.02502876f, 
    0.04558958f, 0.02088229f, 0.05463986f, -0.00965682f, 0.15282595f, -0.08159187f, -0.08989704f, 0.16873875f, 
    0.31138378f, 0.06757338f, -0.08719600f, 0.03825623f, 0.01664526f, 0.02790032f, -0.00271778f, 0.07870905f, 
    0.09423128f, 0.13957612f, 0.03506589f, 0.26780742f, 0.04342799f, 0.04170926f, 0.11519165f, 0.10491946f, 
    0.03261425f, -0.09098411f, 0.30315638f, 0.17806062f, -0.06751121f, -0.58333278f, 0.06008673f, -0.06560047f, 
    -0.13726757f, 0.13516703f, -0.13707066f, -0.20791022f, -0.12010583f, 0.32075283f, 0.05737976f, -0.00994419f, 
    -0.13387804f, 0.02883980f, -0.13679661f, -0.01650087f, -0.00270806f, 0.01601288f, -0.17974362f, -0.06781449f, 
    -0.24588004f, 0.25886935f, 0.20809384f, 0.23359892f, -0.01816086f, -0.11912586f, -0.10347486f, -0.10512325f, 
    0.06645747f, 0.12949458f, -0.01710016f, 0.06996138f, 0.01123811f, -0.00845976f, -0.02983799f, -0.03799941f, 
    -0.03622304f, 0.00415717f, -0.30581784f, -0.03090840f, 0.21950021f, 0.04504571f, 0.27217376f, 0.23459454f, 
    0.24631895f, -0.03199610f, -0.03206656f, 0.06425429f, 0.01232583f, 0.08651362f, -0.12548119f, 0.03040470f, 
    -0.14598745f, -0.15028240f, 0.00092748f, 0.06266022f, -0.08560370f, -0.08305705f, 0.00260407f, -0.05319955f, 
    -0.01119491f, -0.11858697f, 0.76930875f, 0.00691139f, -0.39443412f, -0.07525001f, -0.10296088f, -0.08763977f, 
    0.00590521f, 0.01315026f, -0.13747272f, -0.04957751f, -0.05664355f, 0.04354163f, 0.05671238f, -0.07788672f, 
    0.10249895f, -0.28911287f, -0.02227263f, -0.03304180f, -0.51681966f, 0.19612832f, -0.25117746f, -0.10168056f, 
    0.04489651f, -0.17304729f, -0.26681873f, -0.02501503f, -0.14818951f, -0.21812662f, 0.09164966f, -0.01043253f, 
    0.04560356f, 0.04429451f, -0.04757493f, -0.00319720f, -0.05242818f, 0.36174297f, -0.01356384f, 0.02097393f, 
    0.17100735f, 0.08140769f, -0.18435174f, 0.04557232f, -0.02814910f, 0.02093371f, 0.03999102f, 0.06933308f, 
    0.00654560f, 0.06219130f, 0.07352484f, 0.17714407f, 0.03472126f, 0.17266610f, 0.19694324f, -0.08414679f, 
    -0.07526071f, 0.01345833f, 0.13147037f, -0.02313084f, 0.29438150f, -0.05949583f, 0.52707660f, 0.11877131f, 
    0.02221422f, -0.11473718f, 0.03608146f, -0.05251768f, 0.04553041f, -0.01777775f, 0.01319232f, -0.05549803f, 
    0.05628869f, 0.05471309f, 0.05424161f, 0.05934507f, 0.06383200f, -0.00747914f, 0.00226501f, -0.05261926f, 
    -0.04780626f, 0.04815486f, -0.08571497f, -0.13803704f, 0.02749239f, -0.00784208f, 0.03306174f, -0.05551338f, 
    -0.11980248f, 0.00705774f, 0.13600582f, 0.05417861f, 0.08003872f, 0.13111317f, 0.10421406f, 0.11181041f, 
    0.01232826f, -0.08727964f, -0.04911050f, -0.04226607f, -0.34054580f, 0.00830360f, -0.18100947f, 0.12040386f, 
    0.05166759f, 0.13703200f, 0.01782901f, 0.01166335f, -0.13303863f, 0.05006847f, 0.13623963f, 0.05929135f, 
    0.03632307f, 0.12965499f, 0.04253117f, 0.05040262f, -0.15478894f, -0.05702107f, -0.01348998f, -0.06109921f, 
    0.16837341f, -0.02676661f, 0.02438547f, 0.02285760f, 0.12408830f, -0.04010645f, 0.09140755f, 0.10046718f, 
    0.08199824f, 0.08015949f, 0.10611145f, 0.02600642f, -0.06224217f, -0.02203730f, 0.09885070f, 0.00427833f, 
    -0.11877546f, -0.08284040f, 0.03617850f, 0.11576968f, 0.08326220f, 0.08641116f, 0.12216608f, -0.00748488f, 
    0.02910075f, 0.24985291f, 0.16539557f, 0.06023986f, 0.07329836f, -0.03249034f, 0.19053347f, 0.05655874f, 
    0.18027538f, 0.09957164f, 0.09567908f, 0.02265037f, -0.01426355f, -0.24520786f, -0.00510664f, 0.05741559f, 
    -0.20308600f, -0.11874083f, -0.03819168f, 0.31642142f, -0.05979809f, 0.02577821f, 0.06283353f, -0.18224961f, 
    0.00924435f, 0.02405867f, -0.03460639f, 0.07103948f, 0.06987313f, -0.14455737f, -0.04674445f, -0.17666540f, 
    0.01881946f, -0.00712071f, -0.06400939f, 0.30818945f, 0.24775517f, -0.23773350f, 0.61967731f, 0.38667899f, 
    0.01377803f, -0.17553343f, 0.01428674f, -0.23103723f, 0.09298255f, -0.15887281f, -0.00684506f, 0.04423252f, 
    0.10063583f, -0.24210741f, -0.07079107f, -0.00355110f, 0.08889414f, -0.05670631f, -0.20973851f, -0.16515613f, 
    0.01697744f, -0.20995240f, 0.07806551f, -0.28638294f, -0.08881706f, -0.05287357f, -0.04987670f, 0.02028609f, 
    -0.25185159f, -0.07954033f, 0.25241384f, 0.07401684f, 0.00118495f, 0.07850735f, -0.00677832f, 0.24018279f, 
    0.07345378f, 0.02653194f, -0.09476490f, 0.18570909f, 0.32860744f, -0.11662325f, -0.08527042f, 0.28692827f, 
    0.00906766f, 0.06050529f, -0.13869734f, 0.06063437f, -0.04238907f, 0.01054003f, 0.06509633f, 0.05241048f, 
    -0.04783934f, 0.03502871f, -0.05625358f, -0.07469778f, -0.07083114f, -0.01574836f, -0.02050234f, -0.08954172f, 
    -0.14859939f, -0.19328883f, -0.17700170f, -0.22932674f, 0.45127410f, -0.10137562f, -0.05819477f, -0.11031525f, 
    -0.14217259f, -0.10406261f, -0.13871489f, -0.02492592f, 0.08578047f, -0.16600792f, -0.00894415f, 0.00794435f, 
    -0.02888792f, 0.13411577f, 0.08486127f, -0.01665536f, -0.62383467f, 0.36091360f, -0.13409558f, 0.12098991f, 
    0.08234045f, 0.05518952f, 0.06024069f, 0.01422624f, 0.13394518f, 0.01864439f, -0.03042824f, 0.05846287f, 
    -0.05543108f, 0.09771050f, 0.10692398f, 0.06432547f, -0.02181292f, 0.13154319f, 0.18923990f, -0.14834180f, 
    -0.08989251f, -0.06251221f, 0.21749353f, 0.41386610f, -0.24559830f, 0.18525870f, -0.02607727f, 0.19012867f, 
    0.02241218f, 0.19480655f, 0.08696586f, -0.05129410f, 0.05461969f, 0.00293701f, 0.03322420f, -0.11336510f, 
    0.09970280f, 0.12031054f, -0.01572418f, 0.11668288f, -0.28256634f, 0.02184517f, -0.04140829f, 0.08373864f, 
    -0.02421841f, -0.05768567f, -0.07614310f, -0.21997158f, -0.16601771f, -0.24629827f, 0.37345451f, 0.11874418f, 
    0.18462658f, 0.17295752f, 0.09882510f, -0.02928870f, 0.00199105f, 0.13495235f, -0.02877337f, 0.01285442f, 
    -0.02976189f, -0.25675529f, 0.14586887f, -0.35563928f, 0.07052969f, -0.09046602f, 0.05477749f, -0.21856895f, 
    0.24981019f, -0.11111616f, -0.04050490f, 0.04782099f, 0.13126746f, -0.03111508f, 0.07582797f, -0.00200629f, 
    0.08600511f, -0.04623055f, 0.02004867f, -0.13362741f, -0.08265030f, 0.26439518f, -0.49763903f, 0.33043298f, 
    -0.49505669f, 0.27215773f, -0.00298856f, 0.15916085f, -0.06268552f, 0.42961404f, -0.12903233f, -0.01574287f, 
    -0.00863401f, -0.06480437f, 0.05407410f, 0.10059410f, -0.04561763f, 0.14676854f, -0.09480614f, 0.22816372f, 
    -0.03541321f, 0.03576564f, -0.07722528f, -0.14209665f, 0.13753529f, 0.01165488f, 0.07295995f, 0.02860027f, 
    -0.01015770f, 0.09554203f, 0.03930978f, -0.10446683f, 0.04330719f, -0.06946553f, -0.05534261f, 0.13206966f, 
    0.09866291f, -0.21297497f, 0.10040773f, 0.10998286f, -0.08773860f, -0.05739036f, 0.16666423f, -0.29977858f, 
    -0.02835963f, 0.07811043f, -0.10530840f, -0.14725423f, -0.12392237f, -0.06816153f, 0.09806383f, 0.21969847f, 
    0.23225187f, 0.20243530f, 0.06026768f, 0.07928846f, -0.04822374f, 0.01899641f, -0.01272578f, 0.21689533f, 
    0.25832486f, 0.41219074f, -0.51403278f, 0.25474098f, 0.19121487f, 0.19567086f, 0.02761210f, 0.07806317f, 
    0.06952465f, 0.13444681f, 0.14508098f, -0.09571008f, -0.09453166f, -0.02456741f, -0.03476737f, 0.08121157f, 
    0.06646467f, -0.01447801f, 0.14962941f, -0.00598465f, 0.04584073f, 0.43492088f, -0.52684075f, 0.35779488f, 
    -0.19248374f, 0.11877754f, -0.08926284f, 0.02390009f, 0.14861818f, -0.10898042f, -0.03344995f, 0.04573523f, 
    0.04895717f, -0.00375397f, 0.14279060f, 0.13363677f, 0.14077751f, 0.09120169f, 0.00455986f, 0.00067840f, 
    -0.29842955f, 0.08740047f, -0.11829130f, -0.03061847f, 0.17554988f, -0.12799837f, -0.04550015f, -0.23208803f, 
    -0.07292513f, -0.07522546f, 0.06578564f, 0.07800571f, 0.02983654f, 0.19264087f, 0.08480688f, 0.07284464f, 
    0.11662456f, 0.06586771f, 0.08866809f, -0.01886101f, 0.03171520f, -0.10209080f, 0.40715227f, -0.28241116f, 
    -0.13242708f, -0.05822827f, 0.00640738f, -0.04351049f, 0.08112475f, 0.06257003f, -0.15925480f, 0.04121278f, 
    -0.07353498f, -0.07847725f, -0.17573829f, -0.01509342f, 0.17061308f, 0.07046100f, -0.07598160f, 0.02459079f, 
    -0.08760913f, -0.03906658f, 0.22115672f, 0.23176369f, -0.12699015f, 0.04336892f, -0.23863418f, -0.03543388f, 
    0.10463608f, 0.01517516f, 0.09447016f, -0.01602372f, 0.04875666f, 0.01819689f, 0.02724170f, -0.00762908f, 
    0.07678141f, -0.08915852f, 0.02754037f, -0.16305104f, -0.37892368f, 0.01849831f, -0.07243954f, 0.13650943f, 
    -0.26294753f, 0.00065859f, -0.00122942f, -0.11017352f, 0.18810397f, 0.12229314f, 0.03557336f, -0.19826531f, 
    -0.01067750f, 0.03447292f, 0.00609035f, 0.00989341f, -0.11794572f, 0.01371190f, 0.01181065f, 0.05726122f, 
    -0.02422653f, -0.00479148f, 0.03589975f, 0.00608300f, 0.01510205f, -0.00418407f, -0.05461399f, -0.04649971f, 
    -0.04875094f, 0.01875985f, 0.02215779f, 0.01725939f, 0.02859548f, -0.00441713f, 0.02651021f, 0.01966655f, 
    -0.01111680f, -0.02794905f, -0.04589547f, 0.03606218f, 0.05700755f, 0.04183339f, -0.01974715f, -0.00679155f, 
    -0.05268826f, 0.04496348f, 0.00000078f, -0.03899483f, -0.00246112f, 0.01706384f, -0.02101347f, 0.03216996f, 
    -0.05375998f, -0.00640563f, 0.02278695f, 0.04805789f, 0.04120489f, 0.02406462f, -0.04537397f, -0.02488721f, 
    -0.02993898f, -0.03208391f, -0.00176249f, -0.01688714f, -0.05039526f, -0.04288549f, -0.01363898f, -0.00032194f, 
    0.01112533f, -0.05439466f, 0.03537234f, 0.01740190f, 0.02304268f, -0.00061071f, -0.03682190f, 0.00646636f, 
    0.02570354f, 0.03534182f, -0.05515489f, 0.02130087f, 0.04974515f, -0.03279401f, -0.00015900f, -0.03682835f, 
    0.05906389f, -0.03882533f, -0.02690024f, -0.02426441f, 0.01249450f, -0.00590837f, -0.00366446f, 0.04616932f, 
    0.04774451f, 0.04666912f, -0.04214340f, -0.00498817f, 0.00493544f, -0.00195434f, -0.02671633f, -0.02263813f, 
    -0.03955144f, -0.04820416f, 0.00601089f, -0.05471094f, -0.00532224f, 0.03428754f, 0.01521032f, -0.02414186f, 
    0.03206874f, -0.03017505f, -0.02163177f, 0.01439609f, 0.04385945f, -0.04215755f, -0.04898614f, 0.02077864f, 
    0.05316090f, -0.01212509f, 0.00004488f, -0.03419178f, 0.03201294f, -0.06894916f, -0.01402576f, 0.00293546f, 
    0.02868307f, 0.02164339f, -0.03870161f, -0.02224131f, -0.05112058f, -0.05328763f, 0.01092416f, 0.03809505f, 
    0.04330571f, -0.04188688f, 0.02655023f, -0.00286487f, 0.03572135f, -0.04964741f, -0.02976666f, -0.04130666f, 
    -0.03094582f, 0.01708946f, -0.03935671f, -0.04257179f, -0.03154806f, 0.03629112f, -0.05076116f, 0.00694508f, 
    0.00135003f, -0.05822051f, -0.02705763f, -0.05478293f, -0.00012999f, -0.02156526f, -0.06834828f, -0.01395390f, 
    0.02225881f, -0.06424179f, 0.03545907f, -0.02347253f, -0.01712298f, -0.03846141f, -0.02021451f, -0.03415453f, 
    -0.04706958f, 0.04042044f, -0.02509650f, -0.00155432f, 0.00468246f, -0.03138892f, 0.03482720f, 0.03345618f, 
    -0.06479613f, 0.01061286f, -0.03739341f, 0.02194421f, 0.00529944f, 0.04657393f, 0.04598251f, 0.02026707f, 
    0.02571512f, -0.04027614f, 0.04249204f, -0.04656046f, -0.01337804f, 0.00806864f, -0.05673582f, -0.04368003f, 
    0.01794099f, -0.04745933f, 0.03270664f, -0.04814051f, -0.00862055f, -0.03296015f, -0.00593789f, -0.03423667f, 
    -0.04581596f, 0.04943934f, 0.00571237f, 0.01796537f, -0.00015355f, -0.01592506f, -0.04566846f, 0.00584828f, 
    0.01327904f, 0.03094473f, -0.02057889f, -0.04480791f, -0.03578135f, -0.03173862f, 0.03383922f, -0.05467974f, 
    -0.03337181f, -0.04543779f, 0.00749169f, 0.04501142f, 0.03965078f, 0.01180183f, -0.00935471f, -0.03547049f, 
    0.02023138f, 0.04180174f, 0.00638072f, -0.01826244f, -0.04913454f, 0.01135312f, -0.04637797f, -0.02058397f, 
    0.04108565f, -0.02346267f, -0.01241334f, -0.02282093f, -0.03740054f, -0.03173145f, -0.01097144f, -0.04945491f, 
    -0.05046445f, -0.01041156f, 0.02705992f, 0.04857698f, -0.00501969f, 0.03704042f, -0.00094731f, 0.03457019f, 
    -0.03697608f, -0.03866283f, 0.03665672f, -0.04939395f, -0.00775472f, -0.01677377f, 0.01659089f, -0.06397870f, 
    -0.06208569f, 0.04458468f, -0.03969384f, 0.01201728f, 0.02757978f, -0.05562578f, -0.01698857f, -0.03845133f, 
    -0.01301515f, 0.03138562f, -0.02352736f, 0.00566286f, 0.04074954f, 0.05258969f, 0.02069083f, 0.00929031f, 
    0.00288922f, -0.00222659f, -0.00486781f, 0.02997810f, -0.00269867f, 0.01270380f, -0.05204385f, 0.01283087f, 
    -0.01695603f, 0.02526169f, -0.01348209f, 0.03669716f, 0.03545979f, 0.03377982f, -0.04395714f, -0.02122874f, 
    -0.00008536f, -0.00587789f, 0.02974845f, 0.04395877f, -0.02510539f, 0.02733134f, 0.05139978f, -0.02775013f, 
    0.00456179f, -0.02122258f, -0.05376982f, 0.04990197f, -0.05988034f, -0.02442102f, 0.02718582f, -0.02769632f, 
    -0.03775065f, 0.02829457f, 0.01114378f, -0.00903743f, -0.04083773f, -0.02018926f, -0.02387107f, 0.03038172f, 
    0.01805025f, -0.02184097f, 0.01511345f, -0.02897880f, -0.00645314f, -0.05569967f, -0.04598336f, -0.00390452f, 
    -0.00243974f, 0.00408157f, 0.04652996f, -0.00788905f, 0.04107548f, -0.02527881f, -0.00200473f, -0.03259526f, 
    0.00439110f, -0.00567845f, -0.04386785f, 0.00247818f, -0.03082422f, -0.03286981f, -0.00741594f, -0.02593176f, 
    -0.05665687f, -0.02785049f, -0.03693531f, 0.01050841f, 0.00837120f, 0.00948382f, -0.00735839f, 0.04848131f, 
    0.02701329f, -0.02621680f, 0.01929094f, 0.00815780f, -0.00581596f, 0.03243656f, 0.01661706f, -0.02473238f, 
    -0.04346029f, -0.05109939f, -0.05496262f, -0.04369518f, -0.00308917f, -0.05835608f, -0.03702387f, -0.02538374f, 
    -0.05714757f, -0.00689734f, 0.02159817f, 0.01093434f, 0.03689669f, -0.03770142f, -0.03521280f, -0.03715181f, 
    0.04814334f, 0.01015698f, -0.00305735f, 0.03164480f, 0.02367027f, -0.00745061f, 0.04896744f, 0.00751727f, 
    -0.02482006f, -0.03242389f, -0.05047278f, 0.01594583f, -0.05007271f, -0.01651519f, -0.03791742f, -0.02522288f, 
    -0.00266104f, -0.02997029f, -0.00177498f, 0.00352163f, -0.02310763f, -0.00500390f, 0.00713999f, 0.03384752f, 
    -0.02221884f, 0.01055393f, 0.00022719f, -0.02475099f, -0.00692681f, -0.02311380f, -0.05203710f, -0.03663439f, 
    0.00020637f, 0.00560360f, 0.04907691f, 0.01693614f, -0.05722875f, -0.05684032f, 0.00012662f, -0.04942914f, 
    -0.03154120f, -0.04712431f, -0.05525579f, -0.04553882f, -0.04283712f, -0.04258293f, -0.00252720f, -0.03930511f, 
    -0.00961525f, 0.04466230f, -0.00457294f, -0.03790796f, 0.00904960f, -0.01788642f, -0.02262170f, 0.01894808f, 
    0.01653744f, 0.03337775f, 0.02595673f, 0.04155653f, 0.03287102f, -0.01005217f, -0.01527529f, -0.04367890f, 
    -0.04707314f, 0.04495778f, 0.03614581f, 0.06011655f, -0.04023077f, -0.04226240f, -0.03941880f, 0.03326667f, 
    0.00716835f, -0.05524610f, -0.05005649f, 0.02836111f, -0.02171632f, -0.00280563f, -0.02991693f, -0.05590160f, 
    0.01951825f, -0.05349650f, 0.02780128f, -0.02160854f, -0.03900931f, -0.00087777f, -0.04976919f, -0.03702707f, 
    0.00228489f, 0.04575846f, -0.01105014f, -0.04380237f, 0.02927500f, -0.03034664f, 0.00482093f, -0.02898869f, 
    0.02537912f, -0.02987642f, -0.02380329f, 0.05105952f, -0.06213365f, 0.01060863f, 0.04983206f, -0.00130885f, 
    0.03833138f, -0.02890384f, -0.03626652f, 0.00951930f, 0.00048001f, 0.02726303f, 0.04279454f, -0.05690093f, 
    -0.03488535f, -0.06061263f, -0.03712770f, 0.04129259f, -0.05370637f, 0.00196097f, -0.00740678f, 0.03155105f, 
    -0.01183830f, 0.05307528f, -0.06191656f, 0.02710777f, -0.00897800f, -0.00902562f, 0.03867860f, -0.02116440f, 
    -0.02648694f, 0.00580918f, 0.05537495f, 0.03090821f, -0.04041244f, -0.02993226f, -0.03035845f, -0.02370974f, 
    0.01117309f, -0.01849252f, 0.01834129f, -0.02036031f, 0.04365868f, 0.04493927f, -0.05228078f, 0.02832137f, 
    -0.00646100f, 0.02745889f, -0.06179222f, -0.02172735f, -0.01931010f, -0.01942950f, 0.03152787f, -0.03851233f, 
    0.01716012f, 0.03416530f, -0.04134832f, 0.03690294f, -0.00032825f, -0.03979538f, -0.01281624f, 0.03426871f, 
    -0.05549543f, 0.01662619f, -0.05445794f, -0.02224277f, -0.03907182f, -0.02919827f, 0.04050276f, -0.02665025f, 
    -0.00053854f, 0.01475711f, 0.00052599f, 0.04726051f, -0.05463714f, -0.02699013f, -0.02813555f, 0.02045553f, 
    -0.00195730f, -0.03159139f, 0.02667653f, -0.04871441f, 0.02909280f, -0.05449227f, -0.03053312f, -0.01376556f, 
    -0.05907296f, -0.03243723f, -0.01743914f, -0.02703509f, -0.05517923f, 0.00228271f, -0.06703664f, -0.00123155f, 
    0.01824635f, 0.04458401f, -0.04762049f, -0.05428239f, 0.03863402f, 0.02853270f, -0.00787934f, 0.03694968f, 
    -0.04068404f, 0.00473200f, 0.03769784f, -0.05114006f, -0.02458013f, -0.00603992f, -0.01044639f, -0.01285469f, 
    -0.04254800f, -0.00660232f, -0.06582464f, -0.01693184f, 0.02882129f, -0.02438745f, -0.02889439f, -0.01078973f, 
    0.00068940f, 0.01295204f, -0.02236378f, 0.03086580f, 0.02259231f, -0.01482999f, -0.05543799f, -0.05451429f, 
    -0.02171656f, -0.01666333f, 0.02498864f, 0.00787678f, -0.00354357f, 0.04942904f, -0.04509692f, -0.01642468f, 
    -0.00886033f, 0.01745187f, 0.02620392f, 0.04804851f, -0.04117447f, -0.04133961f, 0.04729811f, -0.01044174f, 
    0.00914680f, 0.02824980f, 0.01190064f, -0.05937742f, 0.01870717f, -0.01029677f, 0.00303528f, 0.01897990f, 
    0.01213298f, -0.05535628f, 0.01533907f, 0.03797248f, -0.04015343f, 0.01441143f, -0.05206167f, -0.00809909f, 
    0.02241780f, -0.04455508f, 0.04658134f, 0.05207652f, 0.01668040f, 0.04041490f, -0.01009157f, 0.03245914f, 
    -0.04539041f, -0.03000148f, 0.00476025f, 0.03123173f, 0.05004988f, 0.01721308f, -0.05726264f, 0.03592460f, 
    -0.02532076f, 0.02167344f, -0.02225696f, -0.01589489f, -0.00832715f, -0.01931704f, 0.01515694f, -0.06310151f, 
    -0.01070929f, -0.04360767f, 0.01618582f, -0.02067501f, -0.05203134f, 0.00777139f, 0.00803084f, -0.06405728f, 
    -0.05209735f, -0.02821064f, 0.01180383f, -0.01518501f, -0.04281293f, -0.02214553f, -0.06692894f, -0.02618733f, 
    -0.21477273f, 0.07775015f, 0.21671538f, -0.18265171f, 0.00634984f, -0.15307087f, -0.01421755f, 0.10160317f, 
    -0.06281467f, 0.08392191f, 0.08369448f, -0.02618609f, 0.08819883f, 0.08281450f, -0.04471852f, -0.01261771f, 
    -0.14767590f, -0.02672681f, -0.03297005f, -0.11668310f, 0.34665662f, -0.07031464f, 0.12452692f, 0.38801351f, 
    0.26193964f, 0.08825036f, 0.20866483f, 0.02460778f, 0.04444894f, -0.05447060f, 0.05302076f, 0.01705007f, 
    -0.13154273f, -0.03025624f, -0.01051866f, -0.05197066f, 0.03168570f, -0.08699497f, 0.10794864f, 0.10097037f, 
    -0.07653246f, 0.01806675f, -0.19107775f, -0.05139062f, 0.00595057f, 0.01499309f, -0.08506308f, -0.14696370f, 
    -0.19612370f, -0.05015795f, 0.07185353f, 0.05285625f, 0.07083685f, -0.05021900f, 0.00499436f, -0.09162691f, 
    -0.03693586f, 0.06457805f, 0.19943392f, 0.13985941f, -0.08119482f, 0.14502577f, -0.24068181f, 0.42099160f, 
    0.16277440f, 0.17095311f, -0.17142117f, 0.09035533f, 0.19468902f, -0.00669469f, -0.06249399f, -0.00500361f, 
    -0.08620712f, -0.08403927f, 0.06807459f, 0.04309944f, 0.04765194f, 0.17025366f, 0.11177408f, 0.02003877f, 
    -0.01300004f, -0.07012056f, 0.12173999f, 0.38684943f, 0.02377397f, 0.06418970f, 0.08915632f, 0.03406198f, 
    0.05081382f, 0.03706071f, 0.16261441f, 0.02115901f, -0.06370335f, -0.04593613f, -0.03987500f, -0.22348356f, 
    0.12858567f, 0.09616505f, 0.04464178f, -0.01601156f, -0.18490995f, 0.02396765f, 0.19503826f, -0.21095110f, 
    -0.12047654f, 0.12203299f, -0.12154783f, -0.02702862f, -0.12737422f, 0.03488897f, 0.17935485f, 0.01362999f, 
    0.00185403f, 0.05278338f, -0.06259605f, -0.25520507f, -0.02754061f, 0.20095086f, 0.08876249f, -0.01362891f, 
    -0.32738140f, 0.12542607f, 0.21378393f, -0.22612180f, 0.30020317f, 0.02508718f, 0.12971169f, 0.07572365f, 
    0.12502658f, -0.11494432f, 0.02025328f, 0.05805003f, 0.14053564f, -0.01145920f, 0.05810118f, -0.02459591f, 
    0.10082836f, 0.00728952f, 0.18430661f, -0.00748776f, 0.09915987f, 0.03420053f, -0.20477542f, -0.05036639f, 
    -0.10464324f, 0.02293663f, 0.34380475f, 0.07964210f, -0.14204782f, 0.31113911f, -0.04116273f, 0.07324506f, 
    0.02316706f, -0.09839508f, 0.10285319f, -0.08134326f, 0.04826937f, 0.17132522f, -0.11275928f, 0.03475904f, 
    0.37145486f, 0.04629082f, 0.02687158f, -0.19284667f, 0.02256424f, -0.11518930f, -0.04202737f, -0.16249454f, 
    -0.01969565f, 0.19640043f, 0.07623097f, -0.10711522f, -0.04319139f, -0.10732424f, 0.03968135f, 0.10304981f, 
    0.00119297f, -0.03698002f, 0.10846388f, 0.00113374f, -0.19151369f, 0.22023050f, 0.25828186f, -0.11194319f, 
    0.10693453f, 0.05932362f, -0.03484507f, 0.15370175f, 0.12170429f, -0.07792312f, -0.02350863f, 0.01044629f, 
    0.11399122f, 0.14074934f, 0.00428776f, 0.12780878f, -0.08416602f, 0.31808060f, -0.31833124f, 0.13206942f, 
    0.56397146f, -0.04823830f, -0.24289623f, 0.04953092f, 0.07596404f, 0.06490621f, -0.15100951f, 0.07142425f, 
    0.08309549f, 0.05826692f, 0.06550136f, -0.04797486f, -0.07567898f, -0.07146308f, -0.00677221f, 0.12339700f, 
    -0.10074382f, 0.22086561f, 0.02054603f, -0.11188481f, -0.28120857f, -0.43210709f, -0.26592845f, 0.38535669f, 
    0.00695651f, 0.03444630f, -0.00945750f, 0.07283147f, 0.02964244f, 0.00978074f, 0.00233567f, -0.01176879f, 
    -0.06357144f, 0.00471241f, -0.01514959f, -0.05893575f, -0.02213211f, 0.09748895f, -0.09940759f, -0.12076227f, 
    -0.01908047f, 0.05613990f, -0.12396755f, 0.07077908f, -0.14202374f, -0.03549384f, -0.06435067f, -0.08025767f, 
    -0.14591374f, 0.07488120f, 0.04107526f, -0.00980567f, -0.06111976f, -0.00067431f, -0.03742647f, -0.04859251f, 
    0.04397412f, 0.08934949f, 0.11723346f, -0.02298279f, -0.25116229f, -0.17618968f, 0.37976500f, 0.06760000f, 
    0.18939717f, 0.07091716f, 0.04541070f, -0.00454126f, -0.15768537f, -0.17079008f, -0.00790656f, -0.04706496f, 
    -0.01987330f, -0.13374150f, -0.07429396f, 0.01841331f, 0.05238434f, -0.06766319f, -0.16583660f, -0.25673562f, 
    -0.16818650f, -0.21033816f, 0.20822014f, 0.05397144f, 0.06620868f, 0.03916335f, -0.10348545f, -0.12126185f, 
    -0.06220264f, 0.00439256f, -0.04422029f, -0.07343248f, -0.04835434f, 0.00829894f, 0.03932370f, 0.14231125f, 
    0.19018942f, -0.14523110f, 0.07641046f, 0.00717041f, -0.25738567f, -0.23871732f, 0.12921400f, 0.05374109f, 
    0.02120602f, 0.13169804f, -0.05438598f, -0.06961851f, 0.05568088f, 0.05723167f, 0.04381583f, -0.04041436f, 
    -0.01569712f, -0.04413255f, -0.05683555f, -0.06379195f, 0.04721192f, -0.02233062f, -0.00836615f, 0.13540509f, 
    0.07512958f, 0.05185973f, -0.04633978f, 0.06728575f, 0.02271210f, 0.00986028f, -0.09552328f, -0.05020485f, 
    -0.00518246f, 0.08507054f, 0.20952664f, 0.15440327f, 0.21638301f, -0.02544851f, -0.11636770f, -0.05922299f, 
    -0.02477802f, 0.02776909f, -0.06571554f, -0.02604291f, 0.05886137f, 0.45901841f, -0.60511065f, -0.33878741f, 
    -0.18399143f, -0.24097279f, 0.16977176f, 0.07320187f, 0.25787905f, 0.11407637f, -0.09902083f, -0.04701860f, 
    -0.08971671f, -0.03210776f, -0.03791690f, -0.10982133f, 0.00247625f, -0.11891150f, -0.14641419f, 0.11721766f, 
    0.19909832f, 0.20582506f, 0.14345317f, -0.13472989f, 0.25828236f, -0.06577358f, -0.04687996f, -0.05749047f, 
    0.06373562f, 0.03102454f, 0.04245196f, 0.07388038f, -0.03237712f, -0.02461761f, -0.07292629f, 0.08908477f, 
    0.03967345f, 0.01480399f, -0.02560244f, -0.05393139f, -0.60686469f, -0.01925652f, 0.13853799f, -0.71001649f, 
    0.16684534f, -0.13568118f, 0.04735928f, -0.01419013f, 0.02877643f, -0.04592279f, 0.12963134f, 0.01537339f, 
    0.05360750f, 0.01039105f, 0.09072538f, 0.02539531f, 0.13896781f, -0.03992125f, 0.05255125f, -0.00458686f, 
    -0.92308903f, 0.16904561f, 0.08343333f, -0.48526070f, -0.28650618f, -0.09385637f, 0.10627266f, -0.04337232f, 
    -0.07496662f, 0.03575828f, -0.04683940f, 0.05228574f, -0.05066572f, 0.06555763f, 0.00298807f, -0.04190959f, 
    -0.02542782f, 0.02208679f, 0.06375942f, 0.21861722f, 0.04631224f, -0.07408541f, 0.05429389f, 0.11968083f, 
    -0.00814203f, 0.02559994f, -0.03833057f, -0.07562648f, -0.05932632f, 0.00664541f, 0.02264519f, 0.00406264f, 
    -0.06380735f, 0.13450368f, -0.03476127f, -0.11267372f, -0.06785197f, -0.12170202f, -0.00788772f, -0.03559379f, 
    0.29335088f, 0.14424133f, -0.51049954f, -0.39620426f, 0.08787292f, 0.03945279f, 0.07653590f, -0.19903663f, 
    0.01785666f, -0.00509846f, 0.16512428f, -0.14569145f, 0.02964007f, -0.12616439f, -0.15528263f, 0.07924680f, 
    0.04238630f, 0.02515681f, 0.01708631f, 0.01246117f, -0.05533101f, 0.22219999f, 0.40239474f, -0.09315133f, 
    0.32383201f, -0.05012228f, -0.12087137f, 0.01185154f, -0.13727917f, 0.00056839f, -0.05278996f, -0.04551223f, 
    -0.01380434f, -0.06666123f, 0.06806835f, 0.08162924f, 0.07181779f, -0.02723312f, 0.07049954f, 0.03687903f, 
    0.25687104f, 0.20296720f, 0.14605294f, 0.04965704f, 0.27764317f, -0.08754425f, -0.01766767f, -0.06660512f, 
    0.08699632f, -0.01067914f, 0.06553853f, -0.02716743f, 0.00991866f, 0.04807916f, 0.09801317f, 0.04377986f, 
    0.04356661f, 0.02557254f, 0.01259663f, -0.10968075f, 0.33309969f, -0.01524158f, 0.03379567f, 0.02460196f, 
    0.01249270f, 0.05843429f, -0.08790137f, 0.04384180f, -0.19549142f, 0.05220797f, 0.15766549f, 0.17987555f, 
    -0.03829683f, 0.16622914f, -0.14951897f, -0.06910186f, -0.01036249f, -0.01754880f, -0.00816746f, -0.02767521f, 
    0.30232179f, 0.17113896f, 0.11795472f, 0.07782851f, 0.29809758f, -0.05065333f, -0.07099104f, 0.04089085f, 
    0.02747709f, 0.00994856f, 0.01854719f, -0.06870943f, -0.08219191f, 0.07228111f, 0.03338480f, 0.02998099f, 
    0.14236210f, -0.02914141f, 0.07422400f, 0.00516740f, 0.05343385f, 0.02803884f, 0.05600316f, 0.02156118f, 
    0.31543347f, -0.12548162f, 0.02939839f, -0.04214360f, -0.07815599f, 0.15248311f, -0.04929126f, -0.09676684f, 
    0.01592848f, 0.02142825f, 0.00813273f, 0.04231832f, 0.03996540f, -0.07018338f, -0.09682523f, -0.06206817f, 
    0.21991621f, 0.02488693f, 0.08544153f, 0.13500601f, 0.12568367f, -0.01627888f, 0.00944034f, 0.00391047f, 
    -0.03197123f, 0.06670471f, 0.16885893f, 0.07664701f, -0.04687641f, 0.01412112f, 0.04359293f, -0.16383885f, 
    -0.10161781f, -0.09163070f, -0.07758569f, -0.10440976f, -0.18759818f, 0.13756445f, -0.14196819f, -0.46280205f, 
    -0.27722606f, 0.06711861f, 0.14391229f, 0.02000700f, 0.10547943f, -0.02423426f, 0.24920101f, 0.12829645f, 
    -0.08637235f, -0.02964995f, -0.01956222f, -0.06545999f, -0.06324059f, -0.05455062f, -0.09815674f, -0.13419996f, 
    -0.23001762f, 0.03959229f, -0.65686512f, -0.40151072f, 0.21997066f, 0.06059904f, 0.13898079f, 0.06995307f, 
    -0.11120953f, 0.06744699f, -0.09148797f, 0.03272902f, 0.09218960f, 0.17517070f, 0.10580850f, -0.09263472f, 
    0.14008179f, -0.05987399f, 0.14079162f, 0.17299224f, -0.56239319f, -0.35642630f, -0.70932120f, -0.68340665f, 
    0.12524827f, -0.15096098f, -0.07650982f, -0.19886681f, -0.30806151f, 0.05430483f, -0.08753340f, -0.03553892f, 
    -0.00863659f, 0.04338377f, 0.03654367f, 0.09187675f, 0.04012978f, 0.03003955f, 0.14364502f, 0.07309590f, 
    0.01626711f, 0.02980039f, 0.15892258f, 0.20464733f, -0.12911895f, -0.03053830f, -0.12617065f, 0.05329690f, 
    0.08962562f, 0.00899262f, 0.06720946f, -0.04053112f, 0.00077360f, 0.14369595f, 0.11190645f, 0.03485171f, 
    -0.02046478f, -0.11224868f, -0.10245843f, -0.06716707f, 0.12841812f, -0.36478680f, -0.30968040f, 0.03707540f, 
    0.41552934f, 0.16842519f, 0.06819100f, 0.23120308f, 0.03921391f, -0.25663403f, -0.00631726f, -0.06001048f, 
    -0.03118182f, 0.01567369f, 0.04826785f, 0.15783669f, 0.10786622f, 0.11601841f, 0.12353321f, 0.05017491f, 
    -0.42732564f, 0.10803864f, 0.05984077f, -0.17471944f, -0.01361819f, -0.05126796f, 0.02561382f, -0.11158378f, 
    -0.03639881f, -0.04357110f, 0.00971171f, -0.17485906f, -0.08889394f, -0.08448883f, -0.10756235f, 0.04017503f, 
    0.14307117f, 0.04419113f, -0.22391154f, 0.30524924f, 0.23640916f, -0.16273323f, -0.37467650f, 0.03994123f, 
    0.25623760f, -0.13434930f, 0.01060114f, 0.14082465f, -0.13335326f, -0.08806881f, 0.01638091f, 0.05063790f, 
    0.06691814f, -0.01586464f, 0.15406907f, 0.10989253f, 0.08982635f, 0.17167218f, 0.06984607f, 0.12538511f, 
    -0.06782912f, -0.24488109f, -0.00988226f, 0.12940799f, -0.00090367f, -0.10802715f, -0.07382184f, -0.08672631f, 
    -0.03064544f, -0.07078879f, 0.03397399f, -0.00618880f, 0.11056834f, -0.01736555f, 0.02387113f, 0.06999820f, 
    0.05197630f, -0.00463771f, 0.34127635f, -0.06705005f, -0.21307869f, -0.01631608f, 0.16781315f, -0.03649144f, 
    -0.10693302f, -0.05230730f, -0.06446542f, -0.05544127f, -0.13627185f, 0.09224450f, 0.15358999f, 0.07559705f, 
    0.12911348f, -0.00942920f, 0.03534276f, -0.00246604f, -0.02169855f, -0.02724837f, -0.01507440f, 0.12301259f, 
    -0.50427175f, -0.24656755f, -0.07603021f, 0.10842903f, 0.20483440f, 0.00475557f, 0.13207260f, -0.22344360f, 
    0.26957878f, -0.18274958f, -0.02459281f, 0.00940165f, 0.17538416f, 0.14213152f, -0.10409867f, 0.09908728f, 
    0.09299538f, 0.10894480f, 0.04711886f, 0.04720761f, 0.37242019f, 0.09393800f, -0.04761286f, -0.36789277f, 
    0.22137392f, -0.00836804f, 0.13640116f, 0.26113144f, 0.25975519f, 0.00123481f, -0.08390518f, -0.04744761f, 
    -0.04745702f, 0.00243534f, 0.04496739f, 0.04351157f, 0.15355153f, -0.21389884f, 0.36128917f, 0.06799269f, 
    0.23071988f, -0.00765572f, 0.11139261f, 0.16707212f, -0.02834414f, 0.00303104f, -0.00660798f, 0.10600635f, 
    -0.03721462f, 0.02559066f, 0.04150948f, -0.05736795f, -0.08940611f, -0.07790919f, -0.04029133f, 0.05418166f, 
    0.14193679f, 0.12474417f, -0.02731965f, 0.19382763f, -0.31519672f, 0.34403253f, 0.32346287f, -0.06969629f, 
    0.18936312f, -0.04749156f, -0.11595108f, -0.04356644f, 0.05288376f, 0.10879382f, 0.00366752f, 0.04076007f, 
    -0.04078576f, 0.12209032f, 0.08784695f, 0.05097021f, -0.08866762f, -0.08775567f, -0.11116487f, -0.03017395f, 
    0.30685470f, 0.07501751f, -0.03862707f, 0.04835075f, 0.02250087f, 0.06979956f, 0.10977091f, 0.24595238f, 
    0.15731429f, -0.06429978f, -0.03821883f, -0.00262297f, -0.07683342f, -0.06517833f, -0.03252484f, -0.01878184f, 
    -0.00847189f, 0.19145803f, 0.07375884f, 0.12267146f, 0.36069182f, -0.10285820f, -0.26966721f, -0.05549005f, 
    0.14760098f, 0.11604387f, 0.11607893f, 0.14672318f, 0.12180705f, -0.17299026f, 0.02641526f, 0.04612744f, 
    -0.02439805f, 0.01399520f, 0.02157485f, -0.07586015f, 0.03164782f, -0.00125383f, 0.26178184f, 0.14305080f, 
    -0.21523023f, 0.16581294f, 0.10123701f, -0.02674739f, -0.15707655f, -0.00347604f, -0.03730711f, -0.01346675f, 
    -0.02931312f, 0.06188478f, 0.05821986f, 0.03789216f, 0.05581824f, 0.06195641f, 0.03811584f, 0.07061691f, 
    0.09392657f, -0.09441242f, -0.11635034f, 0.05248934f, -0.06523809f, -0.08889229f, 0.15187562f, 0.13059205f, 
    -0.01500379f, -0.03164693f, -0.12372813f, -0.12902771f, 0.00242519f, -0.02384374f, -0.08624815f, -0.02163752f, 
    -0.03169318f, -0.04840283f, 0.07675980f, -0.06215712f, -0.06622839f, 0.13466297f, -0.15211491f, -0.33554566f, 
    -0.03932577f, -0.21861443f, -0.42704147f, -0.06347532f, 0.12719171f, -0.09588835f, -0.02692245f, 0.02789664f, 
    -0.05676439f, 0.05007721f, -0.07237614f, 0.01541850f, -0.07835533f, 0.08880633f, 0.11423254f, 0.17273378f, 
    0.03054938f, 0.11087921f, 0.22739804f, 0.04203731f, -0.18130217f, -0.21673907f, -0.34635061f, 0.11430731f, 
    0.20110285f, 0.00822198f, 0.03263553f, -0.05483160f, -0.14546715f, 0.11947529f, -0.15655600f, 0.02229754f, 
    -0.00569044f, 0.12169156f, -0.02209151f, 0.16745797f, 0.09768324f, 0.11020973f, 0.12804961f, 0.14187887f, 
    0.02934001f, -0.05291006f, -0.00423179f, 0.03837581f, 0.03788117f, 0.04350319f, 0.03240123f, -0.00957765f, 
    0.00971906f, 0.03228142f, -0.06009697f, -0.03246078f, 0.02884173f, -0.00861613f, -0.06113252f, -0.03806878f, 
    0.01966321f, -0.03235919f, -0.02102624f, -0.01517544f, -0.05180866f, -0.00433666f, -0.03673417f, 0.00086642f, 
    -0.02456107f, 0.01319092f, -0.00648045f, 0.01260968f, -0.02664110f, 0.03264067f, -0.02001711f, 0.00735189f, 
    -0.05313376f, -0.01202638f, -0.02776125f, -0.02388681f, 0.03223027f, -0.01436506f, 0.01416251f, -0.02298548f, 
    0.02904709f, -0.03024681f, 0.04006140f, 0.01922263f, -0.01935093f, -0.02167927f, 0.03384906f, 0.01866421f, 
    0.01561952f, -0.00052266f, -0.00200259f, 0.01561016f, -0.05785424f, -0.04391900f, 0.02368306f, 0.00882076f, 
    -0.04479912f, -0.01442623f, 0.00769755f, -0.04901206f, -0.03672333f, 0.04860979f, -0.00269391f, -0.03540592f, 
    0.00333212f, 0.01583595f, -0.03666025f, 0.03039148f, 0.02443001f, 0.00071322f, -0.05058042f, -0.05115413f, 
    0.01963643f, -0.01922941f, -0.03222833f, -0.00934790f, 0.03952123f, -0.05443630f, 0.00658699f, -0.05612716f, 
    0.01148213f, 0.02622012f, -0.00564354f, 0.03390347f, -0.05508887f, 0.00230516f, 0.03256894f, -0.02901571f, 
    -0.00502011f, -0.06032893f, -0.04570508f, -0.00228734f, 0.00134940f, 0.02961031f, 0.03067215f, 0.03200316f, 
    0.03434404f, -0.03454794f, -0.02302307f, -0.02505647f, 0.04381317f, 0.04654757f, 0.02808314f, -0.01065558f, 
    0.00776835f, -0.01111908f, 0.00826492f, -0.04528610f, -0.02335397f, -0.00226339f, 0.03037234f, 0.02795368f, 
    0.04147259f, -0.03595766f, 0.04072462f, -0.00992731f, -0.01244218f, 0.00281035f, -0.00588913f, 0.03336309f, 
    -0.04589753f, 0.00317465f, 0.04406786f, 0.03908260f, -0.05712436f, -0.04539937f, 0.03290371f, -0.00105533f, 
    -0.00466621f, -0.03785351f, -0.03836291f, -0.00719180f, -0.03198148f, -0.03426103f, -0.03821485f, 0.01493809f, 
    -0.00617155f, -0.06187513f, -0.01622695f, 0.00120773f, -0.02334854f, 0.01815437f, -0.05804257f, -0.04449190f, 
    0.03859218f, 0.01105267f, 0.00801792f, -0.00064506f, 0.02250048f, 0.02099012f, -0.00231152f, 0.00062760f, 
    0.03476535f, -0.00046340f, 0.03769987f, 0.00589208f, -0.00281040f, -0.00410752f, 0.03230715f, 0.00337569f, 
    -0.04593736f, -0.03787125f, 0.03682902f, -0.01213728f, -0.01903414f, 0.02021033f, -0.02444966f, -0.02735464f, 
    0.02285135f, 0.02147018f, 0.00248354f, -0.02415537f, 0.00419727f, 0.00759750f, 0.00561869f, -0.01581936f, 
    -0.00863346f, -0.01370694f, -0.02840749f, -0.03239516f, 0.02405287f, -0.01760908f, -0.05537675f, 0.00520680f, 
    -0.01354606f, -0.03557186f, -0.05215573f, 0.03560029f, 0.03594750f, -0.05683338f, -0.00690208f, -0.04059849f, 
    -0.02932556f, 0.00751035f, -0.04444847f, -0.05790419f, 0.04418884f, 0.01452726f, -0.05338741f, -0.02060744f, 
    0.00073567f, -0.01737871f, 0.02148086f, 0.04673161f, -0.03892456f, -0.05891108f, 0.01934930f, -0.01732239f, 
    -0.04210163f, 0.02710623f, 0.01318800f, -0.03683993f, -0.03170772f, -0.00178673f, -0.01206969f, 0.01766446f, 
    -0.01415652f, -0.00002580f, -0.05109771f, -0.00630700f, 0.00177008f, 0.02441800f, -0.04104990f, -0.02984436f, 
    -0.01045224f, -0.05560487f, 0.03649700f, -0.04053861f, -0.01335241f, -0.02140363f, -0.03705711f, 0.03145346f, 
    -0.02471236f, -0.04015077f, -0.02969188f, -0.00216820f, 0.03770083f, 0.03451663f, -0.00694458f, -0.00880331f, 
    0.01628111f, -0.00994240f, -0.03685914f, 0.04399791f, -0.03514639f, -0.05005200f, -0.04571467f, 0.00264291f, 
    0.04516774f, -0.01244348f, -0.01887306f, 0.00417676f, -0.03369820f, 0.02490816f, -0.00506537f, -0.02560267f, 
    0.02099375f, 0.04864568f, 0.03753716f, -0.04032350f, -0.04534659f, 0.00147079f, -0.00087624f, -0.00371398f, 
    -0.02392719f, 0.03082594f, -0.01788829f, 0.02042673f, -0.02935458f, 0.02393020f, -0.05787163f, -0.01836659f, 
    -0.04444657f, -0.01594151f, 0.01288904f, -0.01092017f, 0.03261312f, -0.04072845f, -0.01302553f, 0.01791123f, 
    0.00337656f, 0.04562061f, 0.01496352f, 0.03686834f, 0.01125856f, -0.04536343f, -0.04694640f, -0.05013962f, 
    0.00734488f, 0.02223035f, -0.01151074f, 0.03211581f, 0.01742070f, -0.02364910f, 0.02782289f, -0.01430853f, 
    0.01146428f, -0.00880060f, -0.05021807f, 0.02517209f, -0.01906111f, -0.01764527f, 0.00110961f, -0.03110383f, 
    0.04712589f, -0.00124872f, -0.01107561f, -0.03781843f, 0.03160948f, -0.06003864f, 0.01801097f, -0.03411856f, 
    0.04933054f, -0.00303628f, -0.00912626f, -0.05154687f, -0.00270637f, -0.00460098f, 0.03896840f, -0.00622206f, 
    -0.15422936f, -0.07306825f, 0.17819676f, -0.34529412f, -0.05941006f, -0.07605475f, 0.08424141f, -0.19133520f, 
    -0.17487070f, -0.03767106f, -0.02463987f, 0.08045783f, -0.09172123f, 0.10544256f, 0.04676931f, -0.00856934f, 
    0.01049684f, 0.09874057f, -0.08523984f, -0.16356282f, -0.13163652f, -0.56707346f, 0.20409113f, 0.28984177f, 
    0.35482809f, 0.10888541f, 0.08796820f, 0.14682654f, 0.07046318f, 0.28007218f, 0.14910634f, 0.03724640f, 
    -0.06373067f, 0.00170657f, -0.00147827f, -0.01458703f, 0.00789314f, 0.04262365f, 0.08894342f, 0.01939827f, 
    -0.01676780f, 0.16105479f, 0.01007156f, 0.22464629f, -0.10445214f, 0.05625043f, 0.07093540f, 0.14669605f, 
    -0.01918860f, 0.05885156f, -0.09836044f, -0.00378782f, -0.00379765f, -0.10203474f, 0.06538574f, 0.07116178f, 
    -0.00060851f, -0.07570544f, 0.10875815f, 0.15319411f, 0.60510588f, 0.10542105f, -0.37206334f, -0.03271797f, 
    -0.04418988f, 0.04120994f, 0.01168015f, 0.02408651f, -0.08136881f, 0.10206142f, -0.13039133f, -0.07217457f, 
    0.02577529f, -0.06825262f, -0.08986436f, 0.04205418f, 0.01598851f, 0.02943413f, 0.10062385f, 0.00067593f, 
    0.41165781f, -0.26214305f, -0.37561837f, 0.16049466f, -0.07707319f, 0.20059130f, 0.06241577f, 0.08255646f, 
    0.09489883f, 0.02269770f, 0.11723637f, -0.02636505f, 0.00989246f, -0.04110966f, 0.05650624f, -0.09602666f, 
    0.07234272f, 0.22196837f, -0.16379245f, 0.02323474f, 0.22038133f, 0.24300617f, 0.15348265f, -0.46643376f, 
    -0.23390113f, -0.12487894f, -0.05896692f, -0.07900456f, 0.01699102f, -0.18408565f, 0.04615000f, -0.17470683f, 
    0.02518578f, -0.03659425f, 0.12461686f, -0.16320160f, -0.08102197f, -0.12329648f, 0.22506492f, 0.13299790f, 
    -0.25419217f, -0.02478480f, 0.24178483f, -0.14234944f, 0.38401622f, -0.02501503f, -0.09738083f, 0.21578671f, 
    0.02058469f, -0.03980447f, -0.17293230f, 0.09239192f, 0.17808066f, 0.09490055f, 0.11712421f, 0.18815723f, 
    0.11959488f, 0.08451557f, 0.17809299f, 0.04745815f, 0.46842480f, 0.47116733f, -0.25867754f, 0.05442156f, 
    -0.27350205f, 0.04139415f, 0.13146655f, 0.10485616f, -0.15135299f, 0.09920914f, 0.00093134f, 0.18605855f, 
    0.07335037f, 0.04460299f, 0.00473337f, -0.09971529f, 0.01824863f, 0.27112925f, -0.05833165f, 0.10614037f, 
    -0.32682514f, 0.05742514f, 0.15261397f, -0.08782951f, -0.09412949f, 0.06832165f, -0.00552307f, -0.08732625f, 
    -0.09827898f, -0.03257707f, -0.03284935f, -0.03972054f, -0.08351497f, 0.01646896f, 0.07637757f, 0.10077269f, 
    -0.04621573f, 0.09327764f, -0.07932559f, 0.05290565f, -0.11715737f, 0.06337664f, 0.12143612f, 0.02862570f, 
    0.11931194f, -0.23573051f, -0.08121441f, 0.18091902f, 0.03777716f, -0.03512154f, -0.04767310f, 0.02279202f, 
    0.07037207f, 0.07218672f, 0.08579975f, -0.01837636f, -0.17317393f, 0.04499771f, 0.02863812f, 0.17111312f, 
    -0.30489218f, 0.16398774f, 0.27970350f, 0.05168987f, -0.06122923f, 0.06685169f, -0.10060240f, -0.05846661f, 
    -0.08670246f, -0.05262847f, 0.07468469f, -0.00027798f, -0.05242049f, 0.12497211f, -0.03528574f, 0.08848966f, 
    -0.06680832f, 0.06894323f, 0.01798918f, -0.01916274f, -0.03858412f, 0.09292644f, -0.05791132f, 0.08240338f, 
    -0.22737646f, 0.17016198f, 0.00394840f, 0.01791226f, -0.00017566f, -0.10550297f, 0.05274997f, -0.02217476f, 
    0.01946452f, 0.02491899f, -0.02350051f, -0.02833252f, 0.02585576f, 0.12557237f, -0.09739325f, -0.14048748f, 
    -0.02759483f, 0.06371592f, 0.22321138f, 0.07261149f, -0.10547742f, -0.15982634f, -0.09542153f, -0.03498194f, 
    -0.09430925f, -0.12131678f, -0.08982514f, -0.04142155f, 0.03588681f, 0.00040264f, -0.02887391f, 0.01142134f, 
    -0.07720704f, -0.00236645f, 0.03711263f, -0.00478398f, -0.40694785f, -0.65676320f, -0.24556334f, 0.04790772f, 
    0.10712643f, 0.03136941f, -0.00605518f, 0.18178095f, 0.21555303f, 0.18356410f, 0.03837788f, 0.01421365f, 
    0.04721564f, 0.04651695f, -0.09242111f, 0.04343336f, 0.09205621f, 0.06793937f, 0.01070820f, 0.07059238f, 
    -0.02459933f, -0.08446533f, -0.08240557f, -0.04022915f, -0.11511800f, 0.01917534f, 0.00509861f, -0.14197417f, 
    0.12384629f, 0.10092299f, 0.01215181f, 0.03664820f, -0.10128576f, 0.04356678f, -0.02754461f, 0.06872352f, 
    0.12198830f, 0.03035825f, -0.07812323f, -0.10708237f, -0.10720013f, -0.04825571f, -0.18950930f, -0.09337828f, 
    0.05123045f, 0.11642104f, 0.06810026f, 0.03036483f, 0.16835672f, 0.04579303f, 0.03055181f, -0.03332514f, 
    -0.01796607f, 0.07415642f, 0.10336406f, 0.01617490f, 0.10494492f, 0.13792889f, 0.01099594f, 0.09410585f, 
    0.02693343f, 0.01348090f, 0.01666638f, -0.04529629f, -0.03969315f, -0.01118609f, 0.04640676f, -0.04968099f, 
    -0.02549887f, -0.00856911f, 0.03129448f, 0.01478563f, 0.03303640f, 0.01382559f, -0.03453863f, -0.00309654f, 
    0.03236018f, 0.04146844f, 0.02836906f, -0.00498354f, -0.06208052f, 0.00915307f, -0.02184005f, 0.01970871f, 
    -0.04114553f, -0.01851235f, -0.05801944f, -0.01976384f, 0.02178879f, -0.00463885f, 0.04493643f, -0.04668396f, 
    0.02127594f, -0.06105357f, 0.01422655f, 0.00306638f, -0.00475205f, 0.02882068f, 0.00308716f, -0.04980281f, 
    -0.04966095f, -0.06733193f, 0.02636935f, -0.02918859f, -0.03028266f, 0.00114463f, -0.02118896f, -0.06048158f, 
    0.02028199f, 0.02229390f, -0.02361933f, 0.02047054f, 0.01980833f, -0.00489835f, 0.03419266f, -0.04129722f, 
    0.01406374f, -0.03751417f, 0.01382401f, -0.02109723f, 0.02627620f, -0.04427808f, 0.03445920f, 0.02897027f, 
    -0.04994767f, -0.00009203f, 0.00777646f, 0.02540032f, -0.01216215f, -0.04896964f, -0.04714732f, 0.03790516f, 
    -0.05075114f, 0.02455512f, -0.02429163f, -0.02781003f, 0.02072148f, 0.02718247f, -0.00566260f, 0.00192475f, 
    -0.03524499f, 0.06390701f, -0.02571597f, -0.05682330f, -0.03666215f, -0.03686121f, 0.03124033f, 0.04473563f, 
    0.03774087f, 0.01093330f, 0.04186333f, 0.03874026f, -0.00656516f, -0.01678208f, 0.00618487f, -0.00492433f, 
    -0.05465902f, 0.04407311f, 0.03416690f, -0.00374740f, -0.01784756f, 0.03233629f, 0.01879915f, -0.03973182f, 
    -0.02458772f, -0.05384909f, 0.01236366f, 0.01306332f, -0.00058284f, 0.01501168f, -0.01370197f, -0.05977779f, 
    -0.05993786f, 0.00525745f, -0.05018994f, 0.02701053f, 0.00332664f, 0.01599066f, 0.02876003f, -0.00280578f, 
    0.01452345f, -0.04605701f, -0.01739066f, -0.00006959f, -0.03851977f, -0.03456128f, -0.02331305f, 0.01049374f, 
    0.01375325f, -0.00180271f, -0.02280975f, -0.03445120f, 0.01881522f, 0.03625062f, -0.04964031f, 0.02885036f, 
    -0.00659246f, -0.05921741f, -0.00499038f, -0.03367103f, 0.04266784f, -0.03462816f, -0.03467616f, 0.00160247f, 
    -0.04552026f, 0.01183587f, -0.00998197f, 0.04638438f, -0.00347629f, 0.01355313f, 0.02508057f, -0.00607308f, 
    0.00809141f, -0.04364610f, -0.05395509f, 0.00872951f, 0.00142974f, -0.03522485f, 0.04395118f, -0.03029733f, 
    -0.04556253f, -0.00085970f, 0.03135567f, 0.03533840f, 0.00339287f, 0.03229075f, -0.04577960f, -0.06282405f, 
    0.01498537f, -0.03651109f, 0.04332133f, -0.06075969f, 0.01132488f, -0.01287650f, -0.02451735f, 0.02228040f, 
    -0.05704009f, -0.01986400f, -0.06183725f, -0.02309042f, -0.05179286f, -0.02688075f, -0.02375685f, 0.03020758f, 
    0.01988167f, 0.00240864f, -0.00167093f, 0.03698473f, -0.03477576f, 0.00711158f, 0.03208046f, 0.00096180f, 
    -0.05651896f, -0.03838280f, 0.00550206f, -0.02556517f, -0.03517300f, 0.04167027f, -0.00488706f, 0.03087754f, 
    -0.00354640f, -0.03386674f, -0.04190895f, 0.02284868f, 0.00428531f, 0.02998085f, 0.01637448f, -0.00022071f, 
    0.03397064f, -0.02486545f, 0.01571430f, 0.03008060f, 0.01474044f, 0.02597057f, -0.05199279f, 0.03616862f, 
    -0.00404896f, 0.04341079f, 0.00266080f, -0.06041656f, 0.02638083f, -0.00074349f, -0.00627643f, -0.01427273f, 
    -0.06422745f, 0.01854091f, -0.00273696f, -0.05811277f, 0.00641977f, 0.02477046f, -0.05927920f, 0.02808647f, 
    -0.00109196f, 0.03314675f, -0.02925817f, -0.06015956f, -0.03972296f, -0.03703427f, 0.00357635f, -0.01383119f, 
    0.01268109f, -0.05686422f, -0.04342277f, -0.00891786f, 0.04039666f, -0.02127323f, 0.01331902f, 0.01704525f, 
    0.02925090f, -0.05616219f, -0.00968964f, 0.03388376f, 0.04492457f, 0.03263387f, 0.02304542f, 0.00222985f, 
    -0.05712995f, 0.02849596f, -0.05070365f, -0.02503945f, -0.04040254f, -0.00842302f, -0.04416807f, 0.03832668f, 
    0.03517400f, -0.06665868f, 0.03196798f, 0.04545707f, -0.03984394f, -0.00225193f, -0.06356526f, -0.06261278f, 
    -0.02420896f, 0.01589043f, -0.05798779f, 0.03484152f, -0.00093866f, 0.02414567f, -0.05043034f, -0.04926589f, 
    0.00582253f, 0.03274130f, -0.02866185f, 0.01709873f, -0.01364104f, -0.02829743f, 0.04425419f, 0.03437185f, 
    0.03803863f, 0.04392827f, 0.03542094f, -0.01929365f, 0.04248826f, -0.03942227f, 0.04036382f, -0.03681892f, 
    0.03297751f, 0.00728227f, 0.04148866f, -0.01960565f, -0.01517839f, -0.00875215f, 0.03654922f, -0.01938242f, 
    0.03957462f, -0.06459489f, -0.04225055f, 0.03510049f, -0.05736547f, 0.03543599f, -0.05959493f, 0.00464355f, 
    0.02603692f, 0.01763735f, 0.01953740f, -0.03019740f, -0.03025829f, -0.00440446f, -0.06011949f, -0.03654227f, 
    -0.08258655f, -0.19772811f, 0.11655980f, 0.14014275f, -0.12129749f, -0.07212490f, 0.16968271f, 0.13135961f, 
    -0.14115298f, -0.09018390f, 0.09070341f, -0.09306662f, -0.07444830f, -0.12607381f, -0.00963324f, 0.07465004f, 
    0.04384850f, -0.04202675f, 0.05788536f, -0.08512504f, 0.59041810f, 0.47182742f, 0.49252513f, 0.34523538f, 
    0.13004547f, 0.08315482f, -0.06848241f, 0.04473953f, 0.22878253f, 0.30614418f, 0.05449028f, 0.05234006f, 
    -0.01587667f, 0.02242494f, -0.09781134f, 0.02891148f, 0.01661629f, -0.13018416f, 0.09470008f, 0.16112266f, 
    0.05732069f, -0.20439848f, -0.21291175f, 0.26787499f, 0.13325702f, 0.10410944f, 0.01580208f, -0.02122548f, 
    0.01731439f, -0.16730843f, 0.09971033f, 0.00753958f, -0.02602108f, -0.03440004f, -0.03633855f, -0.12113032f, 
    0.02257983f, 0.24464501f, 0.00697838f, -0.19080535f, -0.52192920f, 0.54547685f, 0.21600935f, 0.47444293f, 
    -0.07355934f, 0.11417204f, -0.08412909f, 0.24986452f, 0.11810061f, 0.16144422f, -0.07502243f, 0.06609742f, 
    -0.28879628f, -0.03367729f, -0.04531073f, -0.05878494f, -0.02349152f, 0.21134511f, -0.09034040f, 0.00695696f, 
    0.46884313f, 0.20283702f, 0.54699492f, -0.01970289f, -0.06559509f, 0.13333379f, -0.11576675f, 0.00974432f, 
    0.03686737f, -0.03345956f, 0.12853035f, -0.01172035f, 0.05088802f, 0.05070078f, -0.04372352f, -0.11944071f, 
    -0.00066552f, -0.04126037f, 0.03915011f, 0.14575495f, 0.01012854f, 0.14488292f, -0.23383835f, -0.10398143f, 
    -0.03120615f, 0.11424298f, 0.15621948f, -0.00137740f, -0.05755402f, -0.04538066f, -0.00068737f, -0.05313578f, 
    -0.00186806f, 0.13077070f, 0.05849139f, 0.10972771f, 0.07547664f, 0.09137724f, -0.07141297f, -0.06880089f, 
    -0.05998195f, -0.10384613f, -0.55847615f, -0.09830851f, -0.41814855f, 0.06085018f, 0.31946456f, -0.00159602f, 
    0.17973305f, 0.13061070f, -0.33263800f, 0.13518620f, -0.17642941f, 0.03375188f, 0.00652411f, -0.07137778f, 
    -0.05719940f, 0.25435749f, 0.07495549f, 0.04768075f, 0.00544624f, -0.39802906f, 0.62867212f, 0.31239843f, 
    -0.26909447f, 0.03685432f, -0.26113918f, -0.15747759f, 0.07623972f, 0.23762010f, 0.02219557f, -0.01722352f, 
    0.01696648f, -0.06524824f, 0.07755674f, 0.00153847f, -0.22452314f, 0.19949909f, -0.27585325f, 0.11928266f, 
    0.27997497f, 0.00968948f, -0.16815394f, 0.37419546f, -0.03197848f, -0.00587865f, 0.05853488f, -0.07370111f, 
    -0.01883253f, -0.06272640f, 0.05671982f, 0.11724549f, -0.05094516f, -0.15782514f, -0.09282930f, 0.02390237f, 
    -0.05152429f, 0.13535286f, -0.07496963f, -0.06758774f, -0.13912341f, -0.25425434f, -0.29158348f, -0.07246751f, 
    -0.20853308f, 0.04578763f, -0.03675460f, -0.23688880f, 0.25401363f, -0.12309048f, -0.19186409f, -0.09145397f, 
    0.09175441f, -0.21119063f, 0.05153171f, 0.09156454f, 0.00573856f, 0.03288149f, -0.11443077f, 0.00261894f, 
    0.15048046f, 0.15973935f, 0.04845487f, 0.39242774f, 0.07239938f, -0.00201218f, -0.05502043f, -0.15406629f, 
    -0.00701915f, 0.00693207f, 0.00643590f, 0.11761875f, 0.02055687f, -0.06846507f, -0.04632355f, 0.03878851f, 
    -0.00749158f, 0.21555705f, -0.14938879f, -0.01637843f, -0.20360956f, 0.40513372f, 0.34553969f, 0.22665912f, 
    -0.24052863f, 0.19122277f, 0.02694973f, 0.23593915f, -0.01164019f, 0.04840482f, 0.03664026f, 0.05948228f, 
    -0.01626804f, 0.07193494f, 0.06547450f, 0.07643890f, 0.07149579f, -0.02631777f, -0.14799842f, 0.08828226f, 
    0.02028945f, -0.08383050f, -0.11160541f, -0.04239011f, 0.09963153f, 0.12185863f, 0.05456441f, -0.01454279f, 
    0.00873700f, -0.18137439f, -0.03508251f, -0.03229628f, -0.05615395f, -0.06552535f, -0.03284068f, 0.16973975f, 
    0.07083310f, 0.10301260f, -0.05663300f, -0.03151839f, 0.33044365f, 0.01403875f, 0.06807212f, -0.09479696f, 
    0.08385517f, -0.06236948f, 0.02852307f, 0.14578800f, 0.04277472f, 0.34729218f, 0.01102025f, 0.01521499f, 
    0.20135303f, -0.06424751f, -0.18873638f, 0.04048147f, -0.01082257f, -0.23048547f, 0.05138670f, 0.02407135f, 
    0.17847578f, 0.08791564f, 0.29366532f, 0.02214934f, -0.24336742f, -0.00962101f, 0.05075965f, 0.13290025f, 
    0.07013311f, -0.07968000f, 0.02432305f, -0.06056341f, -0.01224923f, 0.18152264f, -0.01991920f, 0.35876584f, 
    0.02091182f, -0.11949173f, -0.19183615f, 0.05673406f, 0.13344064f, 0.26396188f, -0.12574287f, -0.10438058f, 
    -0.56217283f, 0.08403087f, 0.01613726f, 0.10658555f, -0.05969528f, -0.07933051f, -0.06122170f, -0.02294081f, 
    0.01885871f, 0.20885970f, 0.19325830f, -0.17964967f, 0.03462339f, 0.03922473f, -0.03957677f, 0.16872047f, 
    -0.02311607f, 0.04440646f, 0.01166571f, 0.04424558f, -0.01479607f, -0.01565357f, -0.05860223f, 0.03673985f, 
    -0.01199725f, 0.02752060f, -0.03159479f, -0.01814609f, -0.04060060f, 0.00511202f, 0.03027425f, 0.03810325f, 
    -0.01195238f, 0.00443730f, -0.01887326f, 0.00024174f, -0.04221567f, 0.02495671f, -0.03929573f, 0.00987349f, 
    -0.03807950f, -0.05179836f, -0.03803333f, 0.01286476f, 0.01479883f, -0.05698993f, -0.01672774f, -0.01025498f, 
    0.02114809f, -0.05502985f, -0.02626683f, -0.00882623f, 0.04256110f, 0.01262787f, -0.03495779f, -0.02780464f, 
    -0.04855979f, 0.04920713f, -0.05285214f, -0.05035086f, -0.04604460f, -0.02761338f, 0.04791588f, 0.04435754f, 
    -0.02096276f, -0.04957253f, -0.04480584f, -0.06048124f, -0.01832130f, 0.00226498f, 0.00667170f, -0.00594306f, 
    0.00535678f, -0.04720634f, 0.00871875f, 0.01779614f, -0.02227589f, -0.04734917f, 0.01245538f, 0.00548954f, 
    -0.03414701f, 0.05041103f, -0.03103299f, 0.04382583f, 0.00140966f, 0.01927180f, -0.05464154f, -0.00747419f, 
    -0.02045251f, 0.01675178f, -0.01950173f, -0.05601628f, -0.01497173f, -0.00608728f, -0.02658557f, 0.03588658f, 
    -0.01135650f, -0.01122792f, -0.04151462f, 0.03700865f, 0.01407343f, -0.02720191f, 0.04953216f, 0.02707543f, 
    -0.04631338f, -0.03923782f, 0.03744934f, -0.03352264f, 0.00138202f, -0.02629500f, 0.00595558f, -0.04804800f, 
    0.01491215f, 0.01404684f, 0.03654022f, 0.02206933f, 0.02530790f, -0.01301148f, -0.03798103f, -0.02687189f, 
    -0.05456824f, -0.00797446f, 0.02410636f, -0.04579570f, -0.04255067f, 0.01053026f, 0.00601146f, 0.02737282f, 
    -0.01108522f, -0.02894910f, -0.04840508f, -0.04894184f, 0.03076110f, -0.05673801f, -0.01485515f, 0.04976184f, 
    0.04959085f, -0.02322109f, -0.01341771f, -0.01427676f, 0.05448294f, -0.02253393f, -0.00545580f, 0.01792034f, 
    0.02970853f, 0.02316917f, -0.03675327f, 0.04178451f, 0.04440970f, 0.02380565f, 0.03055517f, -0.05428897f, 
    0.02485952f, -0.03654766f, -0.01998727f, 0.03354728f, -0.03816055f, -0.00403534f, -0.05396392f, -0.01097935f, 
    -0.00067757f, 0.01272667f, -0.01083992f, 0.01769517f, -0.01898991f, 0.03773220f, 0.03308017f, -0.02413442f, 
    -0.03726161f, -0.00000346f, -0.00886396f, 0.04755393f, -0.02552711f, -0.05226691f, 0.03694669f, -0.02551804f, 
    -0.00582059f, -0.06412906f, -0.04086434f, 0.00339855f, -0.05025861f, 0.03127904f, -0.01881174f, -0.02804512f, 
    0.02900207f, 0.01750324f, -0.00172101f, 0.02270856f, 0.03541458f, 0.00680035f, -0.00456166f, 0.02875483f, 
    0.04450031f, 0.00953250f, 0.00995395f, -0.01609428f, 0.01509766f, 0.02334540f, 0.01497615f, -0.02716500f, 
    0.03889590f, -0.03364590f, 0.04422537f, -0.02820960f, -0.05560211f, 0.01392625f, 0.05402324f, -0.00324786f, 
    -0.01183239f, 0.04631476f, 0.01244879f, 0.01131930f, -0.02794681f, 0.02459796f, 0.00194397f, -0.00417447f, 
    0.01151645f, 0.02128326f, 0.00584109f, -0.03965946f, -0.02804613f, -0.00017524f, -0.03372434f, -0.00602718f, 
    0.03976007f, -0.00290041f, 0.02904687f, -0.00372200f, -0.00202139f, 0.00590327f, -0.05508088f, -0.05851185f, 
    0.00265401f, -0.01544493f, 0.01655928f, -0.02153894f, -0.05112768f, -0.03608239f, 0.02346099f, -0.02077512f, 
    -0.00121009f, 0.03198594f, 0.04985418f, 0.03292170f, 0.03897911f, -0.01423370f, -0.00931035f, -0.03287604f, 
    0.04129950f, -0.03953486f, 0.00015604f, -0.05713079f, 0.03940440f, -0.00449428f, -0.02413023f, -0.04615061f, 
    0.03931402f, -0.04032350f, -0.01977563f, 0.01274185f, -0.02906986f, 0.00725641f, -0.02439651f, 0.04066218f, 
    0.03531395f, 0.04307246f, 0.04612230f, 0.05398336f, -0.02739056f, 0.02139515f, -0.04203119f, -0.03999222f, 
    0.02480376f, 0.04009595f, -0.02443990f, -0.02172773f, -0.01874371f, -0.05185943f, -0.03026689f, -0.01401842f, 
    0.03054976f, -0.06517698f, -0.00876503f, -0.04904231f, -0.00710943f, -0.04473259f, 0.01704067f, -0.00225416f, 
    0.01458925f, -0.04354246f, 0.00873545f, -0.01895772f, 0.01159918f, -0.02531629f, -0.04083850f, 0.02080183f, 
    -0.05100181f, -0.02027242f, -0.02471256f, 0.00386078f, -0.00386613f, 0.01809026f, -0.01361835f, -0.04456674f, 
    0.02968103f, -0.03690472f, 0.00256331f, -0.01572107f, -0.04380736f, -0.05822929f, 0.02142214f, -0.05598328f, 
    0.03794914f, 0.00590019f, 0.04992002f, 0.02891715f, -0.01013160f, 0.03207437f, 0.05311477f, 0.03820654f, 
    -0.03591210f, -0.02826422f, -0.04770978f, -0.03380126f, -0.02971557f, -0.00104644f, 0.02217806f, -0.05617559f, 
    -0.02177461f, 0.02021042f, 0.04044519f, -0.05109636f, -0.04213356f, 0.02281332f, 0.00240666f, 0.01276478f, 
    0.13246247f, -0.12991731f, -0.01049927f, 0.24299119f, 0.18413487f, 0.09301177f, -0.08687153f, -0.20252261f, 
    -0.13482684f, -0.02529431f, 0.29651970f, -0.01727032f, 0.03674196f, 0.13532548f, 0.07930183f, -0.10442773f, 
    0.07526539f, -0.13247363f, -0.02244931f, 0.31061149f, 0.09284447f, 0.29882547f, -0.08672933f, -0.03590621f, 
    -0.17838447f, 0.15114604f, 0.13467421f, 0.18094547f, 0.02304913f, 0.01404768f, 0.11039890f, 0.11127986f, 
    0.01060447f, 0.06560603f, -0.00241202f, 0.14723194f, -0.15385954f, 0.03094384f, -0.06042683f, -0.16186902f, 
    -0.35946658f, 0.21046731f, 0.47651210f, 0.03142789f, 0.13943057f, -0.09985434f, -0.10421485f, -0.20943592f, 
    -0.09841336f, -0.01026438f, 0.08297408f, -0.06680024f, -0.06130858f, -0.01949584f, -0.08955690f, -0.21770202f, 
    0.01659641f, 0.06323509f, -0.22947209f, -0.11431367f, -0.04276778f, 0.36592686f, 0.36377916f, 0.14376414f, 
    -0.03841434f, -0.11715147f, 0.12569922f, 0.31622946f, 0.24739498f, -0.37606406f, 0.05849519f, 0.10156591f, 
    0.03151201f, 0.09625769f, 0.09879045f, 0.06686565f, -0.06906637f, 0.15039276f, 0.00136299f, -0.13130367f, 
    0.06932117f, -0.03451618f, -0.09146450f, -0.07771979f, -0.09793440f, 0.10984059f, 0.02645472f, 0.11031666f, 
    0.11669428f, 0.11908147f, 0.07285649f, -0.10129515f, 0.03764829f, 0.10779738f, 0.13062066f, -0.02465598f, 
    -0.01075367f, -0.11091323f, 0.19465518f, 0.01608142f, -0.00258902f, -0.09699792f, -0.04198393f, -0.02239078f, 
    -0.03496678f, -0.09248030f, 0.03838925f, -0.20188126f, -0.02317825f, 0.04462057f, 0.25956747f, 0.07252502f, 
    0.09313177f, 0.07346549f, 0.10781515f, -0.07209631f, 0.07018678f, 0.07504122f, 0.01651092f, 0.12241432f, 
    -0.01875306f, -0.36763942f, 0.00189459f, -0.19567442f, 0.36118031f, -0.01163667f, 0.00262163f, -0.07572582f, 
    -0.05620171f, 0.12312489f, 0.20141821f, 0.10392570f, -0.00171585f, -0.02667384f, -0.00439108f, -0.07894193f, 
    -0.08979501f, 0.01535764f, -0.09147999f, -0.08704045f, 0.00167617f, -0.00072858f, -0.02515377f, 0.51186007f, 
    -0.21186814f, 0.11661120f, -0.03133144f, 0.11909993f, 0.33684042f, -0.00394814f, -0.13714007f, -0.13197504f, 
    -0.12385603f, 0.07182458f, 0.08456425f, 0.10849850f, -0.23314936f, -0.12387773f, -0.03544135f, 0.07078561f, 
    -0.45282280f, 0.14523868f, 0.14763790f, 0.25734434f, 0.32319194f, 0.00693708f, -0.01634583f, 0.03597422f, 
    0.00238684f, 0.00815726f, -0.00991187f, -0.12902845f, -0.00591986f, -0.02650366f, 0.02079379f, 0.05890511f, 
    -0.04193418f, -0.13541569f, -0.05382122f, 0.03283741f, -0.32295904f, -0.23670477f, -0.12716602f, -0.14932026f, 
    0.05961194f, 0.14962649f, -0.02974522f, 0.00952345f, 0.06221658f, 0.21059050f, 0.17770317f, 0.23364805f, 
    0.04475397f, -0.00936281f, -0.05805965f, -0.06236444f, 0.11382121f, -0.02813934f, 0.21684654f, 0.06451885f, 
    -0.19486675f, 0.23956421f, -0.16521166f, 0.07196458f, 0.10835724f, 0.14275883f, 0.06874460f, 0.20297353f, 
    0.09216081f, -0.01661860f, 0.00007673f, -0.05298828f, 0.07111070f, -0.13307780f, -0.09483521f, 0.06262416f, 
    -0.00445316f, 0.12394335f, 0.02107628f, -0.07059539f, -0.07044841f, 0.04648425f, -0.18188551f, 0.21369985f, 
    -0.07402968f, -0.01513702f, -0.09016749f, 0.01847085f, 0.04205325f, -0.12036882f, -0.15678826f, 0.11086145f, 
    -0.02449005f, -0.01829498f, 0.01734746f, 0.06395844f, 0.15573430f, 0.15592909f, 0.07867581f, 0.05173607f, 
    -0.28749058f, 0.19857869f, 0.15716554f, 0.06703409f, -0.10608541f, -0.01256931f, -0.07873569f, -0.13414438f, 
    -0.10872822f, -0.02446377f, 0.04003131f, 0.07635838f, 0.03378528f, 0.15634190f, 0.15060639f, -0.07689428f, 
    -0.01394881f, -0.02870323f, 0.13636976f, -0.02201154f, 0.24721578f, 0.06547792f, 0.07985904f, -0.26539883f, 
    -0.10287313f, -0.05090567f, -0.05126958f, -0.11777966f, -0.00036978f, 0.13468094f, -0.18758795f, 0.03206938f, 
    -0.01494949f, -0.09007949f, -0.01190416f, -0.17119686f, 0.15063517f, 0.02880100f, 0.28924635f, 0.23640090f, 
    0.07599010f, 0.10864976f, 0.02330793f, -0.19653770f, -0.06038089f, -0.05263909f, 0.04011133f, 0.10763913f, 
    0.02778169f, -0.07846645f, 0.11633845f, 0.07161945f, -0.07066794f, 0.14619054f, -0.05547744f, 0.19778062f, 
    0.01868295f, -0.02865215f, 0.04803434f, -0.15819474f, 0.06373265f, -0.01191539f, -0.25814268f, -0.44155169f, 
    -0.09758705f, -0.01510052f, 0.07174763f, 0.04436890f, -0.03054218f, 0.12835751f, -0.08531807f, 0.01480190f, 
    -0.10878497f, 0.09795567f, 0.00563095f, 0.06668865f, -0.06077059f, -0.00272087f, 0.02459503f, -0.00298720f, 
    -0.34399542f, -0.04467241f, -0.17940727f, -0.04944943f, -0.00665885f, -0.05863238f, -0.00889467f, -0.19524854f, 
    -0.03648304f, -0.00175283f, -0.13515940f, 0.09637841f, 0.05136112f, 0.06523297f, -0.02781397f, 0.02240576f, 
    0.00301121f, 0.20074387f, 0.14347489f, 0.07914557f, -0.35569030f, -0.33989596f, 0.18697608f, -0.10144320f, 
    0.14371465f, -0.10938372f, 0.13964690f, -0.02653724f, 0.06467667f, 0.20862854f, -0.04551336f, 0.00382448f, 
    -0.02696023f, -0.07513306f, -0.00390317f, 0.06659822f, -0.07611959f, 0.02900692f, -0.00621692f, -0.08222836f, 
    0.17716788f, 0.07731179f, 0.16129762f, 0.26576018f, -0.15353976f, -0.03346588f, -0.06022595f, 0.07099462f, 
    -0.13761896f, -0.12188523f, -0.06148877f, 0.08942165f, -0.05033281f, 0.01597826f, 0.07291329f, -0.01674007f, 
    -0.06286784f, -0.08656404f, 0.16762233f, -0.09166572f, 0.61868113f, 0.03620865f, 0.22282046f, -0.25439087f, 
    -0.00803355f, 0.10028903f, 0.16765685f, 0.08211756f, -0.00660457f, 0.04777342f, 0.04385957f, -0.03833225f, 
    0.12325673f, -0.00950992f, -0.04893525f, 0.00213205f, 0.01801301f, -0.03526911f, 0.17790657f, 0.15745889f, 
    0.18082042f, 0.10155597f, -0.32264212f, -0.10600434f, 0.24405965f, 0.10117198f, 0.18781739f, 0.05018258f, 
    0.12641422f, 0.04771597f, -0.06730916f, -0.00065798f, -0.00642256f, 0.03999787f, 0.02077959f, 0.07608645f, 
    0.02229567f, 0.14493562f, -0.13662547f, 0.22647116f, 0.06339440f, -0.08398763f, -0.16000250f, -0.18384987f, 
    -0.05706155f, -0.00797431f, 0.05182608f, 0.14187953f, 0.11984624f, -0.09549373f, -0.13494851f, 0.08634494f, 
    -0.06227951f, -0.09126127f, 0.18847568f, -0.01806319f, -0.00792791f, 0.07494238f, 0.05526678f, -0.03742634f, 
    0.28492609f, 0.53231543f, 0.26848641f, 0.23550247f, 0.27086347f, 0.16307235f, -0.25383320f, 0.24947001f, 
    -0.17381449f, 0.31530607f, 0.10838658f, -0.03002935f, 0.08381362f, -0.04636713f, 0.12402405f, 0.04493153f, 
    0.00419476f, 0.09558409f, 0.10583514f, 0.02764570f, 0.29802260f, 0.09254379f, 0.29335284f, -0.03702584f, 
    0.02467309f, -0.01894830f, 0.14281744f, -0.10343291f, -0.11923417f, -0.21711729f, 0.08409533f, 0.07568467f, 
    0.07936239f, -0.07133189f, -0.04562982f, 0.05973193f, 0.01886565f, 0.02175328f, -0.08441488f, -0.10675324f, 
    -0.56349736f, -0.11867094f, 0.18381134f, -0.04712807f, -0.04273864f, -0.05947281f, -0.11124849f, -0.08503402f, 
    -0.05642116f, -0.07765032f, -0.05194619f, 0.05504185f, 0.07355206f, 0.05419760f, -0.01129818f, 0.02400834f, 
    0.02273331f, 0.22952059f, 0.02566110f, -0.07843064f, 0.03504480f, 0.00092871f, -0.09084223f, 0.16385248f, 
    0.06305729f, -0.03161623f, 0.12310356f, 0.16517299f, 0.03216804f, 0.05582610f, 0.10598349f, 0.06400423f, 
    0.01430216f, 0.00871642f, 0.06174633f, -0.00965598f, 0.06481890f, 0.08597115f, 0.25577691f, -0.14358284f, 
    -0.60902780f, -0.21616569f, 0.66058236f, -0.15754633f, -0.10557957f, -0.09852827f, -0.00788706f, -0.04316849f, 
    -0.08164865f, -0.00258631f, 0.01911487f, -0.03042780f, 0.11575339f, 0.11070143f, 0.02012724f, -0.01935780f, 
    0.05748698f, 0.07686614f, 0.03291777f, -0.01977864f, -0.13169210f, -0.03442985f, 0.50771296f, -0.20177518f, 
    -0.15103677f, 0.02461416f, 0.06486806f, -0.05523812f, -0.13896045f, 0.04189755f, -0.00783749f, -0.09683993f, 
    0.09752454f, 0.13424559f, 0.04913277f, -0.03870798f, 0.04829810f, 0.12963204f, 0.04417830f, -0.04153772f, 
    -0.01459208f, -0.15462817f, 0.13769722f, -0.03109734f, -0.13165793f, -0.07230295f, -0.11052575f, -0.00465695f, 
    -0.07767431f, -0.12629734f, -0.04192619f, 0.12058210f, 0.10296827f, 0.12478211f, 0.11855170f, 0.07877649f, 
    0.07032055f, 0.11629847f, 0.13004006f, -0.00961970f, -0.23300575f, -0.11875227f, -0.40642986f, 0.21877502f, 
    0.16259751f, 0.14714909f, 0.06751302f, 0.08269766f, 0.10339953f, 0.15618990f, 0.17675942f, 0.03485212f, 
    0.04327434f, 0.05029010f, -0.12295262f, 0.03412125f, -0.07972352f, 0.12827691f, 0.20273258f, 0.31319314f, 
    0.07337146f, 0.17830403f, -0.04463518f, 0.04358390f, 0.15112124f, 0.10129790f, 0.05619677f, 0.03205764f, 
    0.12732731f, 0.14459968f, -0.04706861f, -0.06940538f, -0.04842800f, -0.11444703f, 0.04949372f, -0.10973073f, 
    0.01310440f, 0.13623947f, -0.10495867f, -0.06702964f, 0.10448344f, 0.28893891f, 0.23932950f, 0.00627670f, 
    0.23279545f, 0.21068327f, 0.11648728f, 0.24041896f, 0.16487968f, 0.10319156f, -0.01277034f, 0.06989794f, 
    -0.00184850f, -0.09073410f, 0.09954148f, 0.02214993f, -0.01103375f, 0.07497967f, 0.00185018f, -0.03671109f, 
    -0.37912387f, -0.01256360f, -0.22833046f, 0.17926706f, -0.19073793f, 0.07185009f, -0.15754271f, 0.05117046f, 
    0.10666317f, -0.07262633f, -0.04167895f, 0.10762827f, -0.01011924f, 0.09448823f, 0.05125065f, 0.12750283f, 
    -0.08038791f, -0.04157263f, 0.15786399f, 0.02967178f, 0.14828464f, 0.18851942f, -0.21694928f, 0.21250263f, 
    0.33213493f, 0.05254864f, 0.26846895f, 0.26312676f, 0.23371889f, 0.33109462f, -0.07335208f, 0.02218302f, 
    -0.01088645f, 0.02223963f, -0.06377859f, 0.09797788f, 0.15839081f, 0.01180389f, -0.05879828f, 0.16831885f, 
    -0.14601630f, -0.03731207f, -0.23700729f, -0.20464520f, 0.00647731f, -0.02927656f, -0.18366295f, -0.07658761f, 
    -0.03060687f, -0.08675030f, 0.04847855f, 0.15251543f, -0.07455437f, 0.00956941f, -0.03607420f, -0.01956412f, 
    0.09941845f, 0.09542237f, 0.17505509f, 0.18287715f, 0.10095004f, -0.11313509f, 0.23739709f, 0.31025639f, 
    0.03391190f, 0.13741222f, -0.01497268f, 0.29401878f, -0.01299958f, 0.16940546f, 0.03825875f, -0.08113117f, 
    -0.08137456f, 0.07893026f, 0.02138321f, 0.09801751f, 0.12189806f, 0.14037713f, 0.18415575f, 0.12855642f, 
    -0.16138497f, 0.26680717f, 0.28996551f, 0.27086768f, 0.20024854f, -0.00924039f, -0.08793548f, 0.05543292f, 
    0.04103222f, 0.22169572f, 0.02679413f, 0.06740174f, -0.00878496f, 0.03990704f, 0.10404289f, 0.06116823f, 
    -0.05076783f, -0.00791391f, 0.09829772f, 0.25466397f, 0.00103675f, -0.10679599f, 0.04672540f, 0.16947094f, 
    0.07447420f, 0.05706748f, -0.13722882f, -0.17887995f, -0.19409655f, 0.01023186f, -0.05127358f, 0.18473469f, 
    0.04400871f, 0.08952124f, -0.05423757f, 0.07326730f, -0.09468420f, 0.00074866f, -0.00606967f, -0.14567499f, 
    -0.03686989f, 0.47416157f, 0.39150658f, 0.19493261f, -0.08717766f, 0.11261407f, 0.08152843f, -0.26315987f, 
    0.28014168f, 0.14499140f, -0.00571308f, 0.02705765f, 0.12015735f, 0.11738859f, 0.05464576f, -0.09345768f, 
    0.18605796f, 0.15797672f, 0.09371419f, 0.00542883f, -0.40740636f, -0.33971635f, 0.01751912f, -0.11201809f, 
    0.01520996f, -0.30077747f, -0.11059377f, 0.03578368f, -0.15360729f, -0.01708644f, 0.01325338f, -0.17432842f, 
    -0.08985069f, -0.08166312f, 0.00627139f, 0.09640604f, -0.11106682f, 0.19167069f, 0.15200286f, -0.13007197f, 
    -0.08630085f, -0.33345202f, -0.52388585f, 0.16109613f, -0.04048203f, -0.20004851f, 0.01146680f, 0.05306581f, 
    -0.16264430f, -0.14118198f, 0.06246848f, 0.01883852f, 0.05716658f, -0.08463716f, -0.00859886f, 0.09986862f, 
    0.12889236f, 0.17112714f, 0.16334073f, 0.05353432f, 0.11131207f, 0.14850223f, 0.46215415f, -0.31044337f, 
    -0.16867501f, 0.02403315f, -0.13492890f, -0.30320016f, 0.11266036f, -0.05593681f, 0.11476479f, 0.03332156f, 
    0.03990048f, 0.20098005f, -0.00766717f, -0.00758059f, 0.12419206f, 0.06045793f, 0.00630669f, -0.12235574f, 
    -0.10224680f, -0.10928306f, -0.23826659f, -0.12894051f, 0.07777049f, 0.08624982f, 0.14520842f, 0.24261650f, 
    -0.02711638f, -0.10800672f, 0.12074692f, -0.06378322f, 0.09228709f, -0.08995837f, 0.05388999f, 0.09713470f, 
    0.05937711f, 0.13129021f, 0.05678094f, -0.13229527f, -0.44746292f, 0.03656347f, -0.09551149f, 0.12965916f, 
    -0.02933025f, 0.13682653f, 0.27653039f, 0.32064092f, -0.08578495f, 0.07705630f, 0.09891351f, -0.04652712f, 
    -0.05562166f, -0.02320952f, 0.06682390f, 0.10331496f, -0.02475689f, 0.04525624f, 0.03955682f, -0.07854925f, 
    -0.03873405f, -0.22108643f, -0.22381932f, -0.22203186f, -0.07236683f, -0.08786123f, -0.23247859f, -0.05993401f, 
    -0.02319664f, -0.13635969f, 0.14813162f, 0.26764491f, 0.18797858f, 0.00507362f, 0.13053785f, 0.19804133f, 
    0.13530895f, 0.05698274f, 0.16908301f, 0.00538609f, 0.09866353f, 0.26231351f, 0.32126400f, -0.01295546f, 
    -0.00982908f, 0.22916901f, 0.06305639f, 0.07749040f, 0.05481933f, 0.34478751f, 0.09627637f, 0.08313350f, 
    0.22482921f, 0.04998937f, -0.11790742f, 0.07923429f, -0.00628185f, -0.06132650f, -0.00531539f, 0.18872492f, 
    -0.21378717f, -0.12577707f, -0.10895067f, 0.36708444f, 0.28334534f, -0.15500018f, 0.22810347f, 0.07551650f, 
    0.08359026f, 0.22750714f, -0.00994499f, 0.06048291f, 0.07129437f, 0.17493875f, 0.22256339f, 0.11756151f, 
    0.23514190f, -0.02638095f, 0.12326259f, 0.35296109f, -0.02386342f, 0.21284947f, 0.47474796f, 0.34165516f, 
    0.22001155f, -0.06338438f, 0.04492459f, -0.10774856f, -0.05090680f, 0.15511063f, 0.04721631f, 0.03303754f, 
    0.18200065f, -0.14640582f, 0.14345081f, 0.01487870f, 0.12219680f, 0.13285458f, 0.05806752f, 0.04859684f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03283732f, -0.06134405f, 0.13128135f, -0.05448237f, 0.02875270f, -0.03909576f, 0.17490751f, 0.15132155f, 
    0.08332133f, 0.08418961f, 0.12280571f, -0.18485673f, -0.03376393f, 0.13769265f, 0.08487312f, -0.14251010f, 
    0.07748965f, -0.03194684f, 0.27258548f, 0.03249201f, -0.01410572f, 0.12129617f, 0.26406360f, 0.03495472f, 
    -0.00278948f, -0.06787865f, -0.05975056f, -0.07596576f, 0.01378732f, 0.08861251f, 0.03485344f, 0.11718738f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17723699f, -0.06100918f, -0.20694205f, -0.10432678f, -0.31704143f, 0.16902123f, -0.09996192f, 0.33331606f, 
    -0.16844591f, 0.09779505f, 0.18901780f, -0.14058521f, -0.17143585f, 0.50592363f, 0.06879164f, -0.10095029f, 
    0.21397167f, -0.02668826f, -0.01921774f, -0.02457108f, 0.14182383f, 0.10152373f, 0.08217289f, -0.15593666f, 
    -0.03212970f, -0.06656333f, 0.07165145f, 0.10071065f, 0.00633661f, 0.09415018f, 0.30152628f, 0.07212518f, 
    -0.29823688f, -0.25250891f, 0.31903648f, -0.14874506f, 0.03762017f, -0.06397254f, -0.33076310f, 0.00021188f, 
    -0.08889875f, 0.27776179f, -0.08898278f, 0.37515643f, 0.29754889f, 0.02238753f, -0.10033636f, 0.41226348f, 
    0.47753757f, -0.39739129f, -0.23259617f, -0.05450682f, -0.02790049f, -0.02163032f, -0.27227050f, 0.29160455f, 
    -0.02963043f, 0.24571185f, -0.07092162f, -0.00180584f, 0.05484253f, -0.25625429f, 0.18865237f, -0.09672256f, 
    0.14373513f, 0.36797604f, 0.31490284f, 0.01697005f, -0.12283178f, -0.04169036f, 0.20813705f, -0.08343956f, 
    -0.47142026f, -0.03895650f, -0.08482036f, 0.23301603f, 0.20244363f, 0.28445673f, 0.13266663f, 0.11794144f, 
    -0.30234125f, -0.19160892f, 0.12788917f, 0.06455614f, 0.06977542f, 0.04474109f, 0.30198476f, -0.10749195f, 
    -0.10331998f, -0.42050523f, 0.16597427f, 0.14965084f, 0.05667387f, -0.23980522f, 0.12887046f, 0.28625375f, 
    -0.00700593f, 0.33262593f, -0.23436159f, -0.12836608f, 0.23935002f, 0.03114315f, -0.35059884f, -0.04840127f, 
    0.04020005f, -0.35032728f, -0.46922699f, -0.06675470f, 0.39200485f, -0.57289737f, 0.19791763f, 0.31131607f, 
    0.01394876f, 0.07834224f, -0.11199387f, -0.01205536f, 0.07456247f, -0.19614244f, -0.17657524f, 0.04501154f, 
    0.05494537f, -0.43037555f, 0.01338617f, 0.28662711f, -0.12259509f, 0.30935889f, -0.12613505f, 0.08645723f, 
    -0.12027013f, -0.07876001f, -0.18677233f, 0.03599307f, 0.07278803f, 0.10043136f, 0.19828559f, 0.12521087f, 
    0.05659109f, -0.02379869f, -0.13349456f, -0.09717119f, 0.23779555f, -0.09921616f, -0.13044752f, 0.01058588f, 
    0.19929020f, -0.05273836f, -0.32854944f, 0.05635951f, -0.11841513f, -0.22290684f, 0.10706269f, 0.08393165f, 
    0.14892018f, -0.13951382f, -0.05570167f, -0.20061208f, 0.14582154f, -0.16583695f, 0.08841874f, -0.40508962f, 
    -0.15733759f, -0.00528857f, -0.21233614f, -0.17098397f, -0.11792208f, -0.03628784f, -0.12707868f, -0.22597924f, 
    -0.21800025f, -0.16406381f, 0.18162416f, 0.03589848f, -0.31217796f, -0.15756366f, -0.22077642f, 0.16874093f, 
    0.32125524f, 0.22207826f, -0.11182859f, -0.15500781f, 0.10565241f, -0.15202011f, -0.31798771f, 0.11924250f, 
    0.02344119f, -0.18448487f, -0.13170768f, -0.29945594f, -0.15538238f, -0.14444986f, 0.12109572f, -0.41586995f, 
    0.09455535f, -0.41026324f, 0.27138016f, 0.10884634f, 0.07034817f, -0.12990518f, 0.09486348f, -0.15268016f, 
    0.39893964f, -0.08473900f, -0.19025980f, 0.02161760f, 0.17007795f, -0.33388114f, -0.08293257f, 0.05248672f, 
    0.02895580f, -0.10127460f, 0.18953767f, 0.11409098f, -0.05259068f, 0.23623000f, 0.19370644f, 0.25478944f, 
    -0.07257156f, 0.27041748f, -0.10297165f, -0.28180572f, -0.12294208f, 0.14274594f, -0.27516350f, 0.02130288f, 
    -0.03944330f, 0.34460136f, 0.01698948f, 0.10983635f, -0.53890789f, 0.01971490f, 0.07018779f, 0.15078291f, 
    -0.21253100f, 0.20072034f, 0.01162876f, -0.14236368f, 0.04004718f, 0.26403031f, -0.02438674f, -0.51484233f, 
    -0.61375880f, -0.21138947f, -0.00554802f, -0.04613220f, -0.08910587f, 0.08206584f, 0.28984976f, -0.20883027f, 
    0.02053786f, -0.09844577f, -0.07633241f, 0.07487459f, 0.04525053f, 0.08941073f, 0.09079810f, 0.30432543f, 
    -0.02466225f, -0.05661406f, -0.30664247f, -0.08680008f, -0.00349959f, -0.15305729f, -0.31947225f, 0.08267377f, 
    0.24160986f, 0.17836806f, -0.17496711f, -0.10009680f, -0.12408747f, -0.27778000f, -0.13136353f, 0.17338206f, 
    0.02212495f, 0.08917850f, 0.23353897f, -0.14218168f, 0.15356427f, -0.19277537f, -0.29643491f, 0.23545150f, 
    0.15312292f, 0.13387883f, 0.12875137f, -0.11418079f, -0.15786240f, 0.50296181f, 0.07623927f, 0.21652684f, 
    0.12230951f, -0.24529220f, -0.15489858f, 0.02522038f, -0.33512139f, 0.14894439f, -0.06768584f, 0.25171036f, 
    -0.20825534f, 0.16145992f, 0.05623437f, 0.16521965f, 0.26284465f, 0.27426067f, -0.34778911f, 0.03738680f, 
    0.01026929f, -0.23490636f, 0.19014566f, 0.17075671f, -0.12809414f, 0.06069768f, -0.42365643f, 0.10161576f, 
    -0.15364254f, 0.28029916f, -0.09667957f, 0.04673201f, -0.04636763f, 0.23925205f, 0.39676598f, 0.05099731f, 
    -0.05894250f, 0.20216951f, -0.19390483f, 0.03090622f, 0.34481332f, 0.08929656f, -0.06982013f, -0.20137222f, 
    0.32415095f, -0.17915937f, -0.23765732f, 0.25526357f, 0.23438749f, -0.40645877f, 0.00172122f, 0.35226959f, 
    -0.38085169f, -0.07254647f, 0.07592170f, 0.05786638f, -0.10132602f, 0.03013938f, 0.04987255f, -0.07389059f, 
    -0.03693118f, -0.08587687f, 0.16852525f, 0.37023488f, 0.00264471f, 0.28249872f, -0.15982682f, 0.20125431f, 
    0.17061564f, 0.22708677f, 0.27772874f, -0.03748867f, 0.34983486f, 0.09221877f, -0.18005110f, -0.18972646f, 
    0.49554616f, -0.03865406f, -0.13591669f, -0.17377968f, -0.28795761f, -0.18808518f, -0.05454545f, -0.21055061f, 
    -0.02482935f, 0.17102467f, 0.28601938f, -0.11017249f, -0.03133200f, 0.22322877f, 0.03361820f, 0.03692687f, 
    -0.09930891f, -0.13885704f, -0.10501829f, 0.16729638f, 0.03586550f, 0.19042221f, -0.25203413f, 0.06955820f, 
    0.47576332f, -0.10898579f, 0.59655660f, 0.02007348f, 0.33204862f, -0.16995989f, 0.17020576f, -0.05625696f, 
    0.12551457f, 0.03133576f, -0.00803012f, -0.13388421f, -0.15564501f, 0.14215054f, 0.25330406f, 0.11662021f, 
    0.44127735f, 0.13085710f, 0.25130597f, 0.01570096f, -0.11397628f, 0.01579945f, 0.39949256f, 0.11332653f, 
    -0.04517952f, -0.17135787f, 0.01577075f, -0.36922517f, 0.09778856f, -0.28441691f, -0.15513328f, 0.18539509f, 
    -0.01869598f, -0.18308021f, -0.25885981f, 0.16387957f, -0.33059421f, 0.16894689f, 0.21634682f, 0.03214888f, 
    0.08088411f, -0.04404458f, -0.20059440f, 0.01733113f, 0.26474804f, 0.18855444f, -0.08380131f, -0.14648548f, 
    -0.04309126f, 0.10568997f, -0.07379792f, 0.16518854f, -0.09757832f, -0.00205989f, 0.20296939f, -0.05208845f, 
    0.13187951f, -0.14275713f, 0.08763549f, 0.03370892f, -0.18199465f, 0.07603280f, 0.00003478f, -0.39937907f, 
    0.34707204f, 0.26845729f, 0.28853226f, -0.09869339f, 0.24155894f, -0.12658511f, -0.10516097f, 0.10412934f, 
    -0.02474429f, -0.17748982f, -0.04152793f, -0.28873605f, -0.16286048f, 0.39677548f, 0.06774642f, 0.09460861f, 
    -0.01345478f, 0.20694821f, -0.34034759f, 0.04459215f, 0.09810375f, -0.25211778f, 0.17993876f, -0.24165744f, 
    -0.07686956f, -0.07882317f, -0.07179964f, -0.30177435f, 0.06777459f, -0.02136422f, 0.31673011f, 0.30308685f, 
    -0.44530791f, 0.12979831f, 0.23531234f, -0.09510417f, -0.30441284f, 0.08109052f, -0.36784118f, 0.32527736f, 
    0.27801159f, 0.21130539f, 0.08060177f, -0.51250023f, -0.30986863f, 0.11154007f, -0.07287941f, -0.31017351f, 
    -0.00592222f, -0.27262425f, 0.45050856f, -0.12123004f, 0.15535709f, 0.30486256f, 0.22944443f, 0.21801366f, 
    0.04128508f, -0.26410773f, 0.08015260f, 0.05536417f, 0.09117139f, 0.27323046f, -0.01798673f, 0.33242542f, 
    -0.35979035f, -0.25427443f, 0.04983012f, 0.07356178f, -0.06941044f, -0.12486088f, 0.12321279f, -0.10408266f, 
    -0.02099274f, -0.12872335f, 0.22185859f, 0.13874263f, -0.10115180f, -0.07880043f, 0.23433237f, 0.14694887f, 
    -0.26089257f, 0.10498191f, -0.23587978f, -0.02197631f, 0.13284893f, -0.05767354f, 0.14256468f, -0.03574404f, 
    -0.06131169f, -0.35977590f, 0.14223245f, 0.20987278f, -0.13427025f, -0.13616723f, -0.10936094f, -0.04710823f, 
    0.46724108f, 0.10974047f, 0.31504279f, -0.14156525f, 0.40515122f, 0.03418302f, -0.04666150f, -0.17880285f, 
    -0.39540118f, -0.03275515f, -0.00744696f, 0.07821817f, -0.34239185f, 0.09329395f, 0.22700508f, 0.07054214f, 
    0.06445104f, -0.30887690f, 0.24065837f, -0.01462167f, -0.04728434f, -0.36347404f, -0.12991972f, -0.21710554f, 
    -0.11187941f, 0.09495332f, 0.12109271f, 0.27430585f, -0.13039941f, 0.05620220f, 0.25614914f, 0.13818893f, 
    0.13733533f, -0.09529601f, 0.27897567f, 0.10172120f, 0.30035797f, 0.03794217f, 0.05243671f, 0.05774394f, 
    0.39097020f, 0.03807752f, -0.08154170f, -0.33405995f, -0.10611744f, -0.10229921f, 0.09578265f, 0.07397585f, 
    0.41479117f, 0.08034910f, 0.33375898f, -0.14818448f, -0.18636034f, 0.59206551f, -0.35326955f, -0.12644008f, 
    0.05414296f, 0.43246394f, 0.03654742f, 0.01999500f, 0.15519841f, -0.46198416f, 0.07754581f, -0.06887606f, 
    -0.49678975f, 0.31076902f, -0.45373297f, -0.15331362f, 0.08504257f, -0.10841079f, -0.30704284f, -0.05421679f, 
    -0.19803548f, 0.03923231f, -0.54825342f, 0.39417529f, -0.15182628f, -0.57770789f, 0.29675362f, 0.30468050f, 
    0.41168904f, -0.21425875f, -0.27753258f, 0.16563264f, 0.01761195f, 0.15322758f, 0.03303700f, 0.06363471f, 
    -0.01945147f, 0.01801245f, -0.07562813f, 0.10209336f, 0.08122174f, -0.19135454f, 0.10824305f, 0.16385062f, 
    -0.36150581f, 0.04707513f, -0.12216754f, 0.16435355f, -0.30002156f, -0.11917062f, -0.23614879f, 0.06135904f, 
    -0.02694973f, -0.18209693f, 0.28169602f, -0.08740218f, -0.12892199f, -0.37350234f, 0.37275091f, 0.07760699f, 
    0.31900430f, -0.21446070f, 0.28468311f, -0.08303458f, -0.12236217f, 0.32992381f, -0.26498610f, -0.15477404f, 
    -0.13411683f, 0.00948091f, -0.04732973f, 0.11270952f, -0.05001764f, -0.45018750f, 0.10006922f, 0.18869796f, 
    -0.26514205f, -0.32968426f, -0.16893339f, 0.15270737f, 0.29108083f, 0.05291598f, -0.23386750f, 0.22650045f, 
    -0.13596579f, 0.13300328f, 0.00870963f, -0.19425808f, 0.21721613f, -0.09819290f, -0.07680429f, 0.23887148f, 
    0.10289078f, -0.15720138f, 0.41940990f, -0.14603262f, 0.13772294f, 0.11473989f, -0.44126931f, 0.30913550f, 
    -0.10482561f, 0.39480707f, -0.05587935f, 0.29689980f, 0.16251479f, -0.07817542f, -0.00963410f, 0.08292373f, 
    0.04756666f, -0.66807950f, 0.11136299f, -0.02946424f, -0.36459097f, -0.09215219f, 0.09873410f, 0.28891248f, 
    0.28965685f, 0.07606412f, -0.02524056f, 0.42863342f, 0.34001860f, -0.01599517f, 0.05070797f, -0.12218068f, 
    0.04908186f, -0.03002222f, -0.16542651f, 0.12756291f, -0.09808811f, 0.25200197f, 0.14761126f, 0.24351503f, 
    0.06358927f, -0.15073846f, 0.01004907f, 0.00854685f, -0.01576335f, 0.05938691f, -0.13578035f, -0.18244465f, 
    -0.32046100f, 0.23816061f, -0.15463327f, -0.16514926f, 0.31907102f, 0.06944261f, -0.08745644f, 0.08501931f, 
    -0.35101718f, -0.26619056f, -0.19624758f, 0.12315910f, -0.34705746f, 0.10694475f, -0.00574639f, 0.45713121f, 
    0.35486650f, 0.35764593f, -0.37048665f, -0.04328001f, 0.15220788f, -0.26513934f, -0.24280071f, 0.07542641f, 
    0.16526195f, -0.01214458f, 0.11669306f, 0.17508700f, 0.13346191f, -0.44421780f, 0.24665068f, 0.34450746f, 
    -0.18403818f, -0.07531865f, -0.47795939f, 0.16557513f, -0.11554006f, -0.09001023f, -0.01997130f, -0.02939857f, 
    0.24992147f, -0.12521836f, -0.33305699f, 0.27850622f, -0.04848875f, -0.58526397f, 0.35717076f, 0.28196120f, 
    0.30833927f, -0.31000468f, 0.06159768f, -0.09049775f, 0.07625465f, 0.30457324f, -0.16375040f, -0.03217750f, 
    0.02898708f, 0.56860715f, 0.00767103f, -0.20680234f, 0.13105015f, 0.17083700f, 0.23203431f, 0.16496819f, 
    0.31433678f, 0.11141875f, -0.11264577f, 0.03189307f, -0.00743036f, -0.06354227f, 0.08662487f, 0.07699727f, 
    0.14177467f, 0.06884050f, 0.10092910f, 0.12464492f, -0.26832259f, -0.11388475f, 0.08484165f, -0.19433334f, 
    -0.05762915f, -0.13122661f, 0.23949695f, 0.12865248f, -0.16734220f, -0.11372039f, 0.10420103f, 0.16485856f, 
    0.08944638f, -0.00239748f, 0.01700621f, -0.26983124f, 0.12634908f, 0.43345493f, 0.09405585f, 0.03098546f, 
    -0.56583911f, 0.06277003f, -0.03240465f, -0.02112378f, 0.17387769f, -0.10198888f, -0.27574876f, 0.12825480f, 
    0.48770919f, -0.05861476f, -0.01717821f, -0.44198176f, 0.13875230f, 0.03829930f, -0.17664897f, 0.23965557f, 
    -0.06346353f, -0.08123958f, -0.06639998f, 0.11488783f, 0.09227142f, 0.36628473f, -0.32433078f, 0.22308612f, 
    0.14829333f, -0.04870419f, -0.05188523f, 0.26873067f, -0.17139763f, -0.26666367f, 0.05372014f, 0.31962484f, 
    0.35755178f, 0.41979483f, -0.14177269f, 0.07700533f, 0.49904653f, -0.17041476f, 0.27749497f, -0.29249656f, 
    0.19992176f, -0.15105164f, -0.09723416f, -0.08061191f, 0.23553540f, -0.23992229f, 0.34777308f, 0.16788195f, 
    -0.43651658f, 0.33127546f, 0.27219769f, 0.01855409f, 0.13680859f, 0.25007796f, -0.06192473f, -0.34674597f, 
    0.14100468f, 0.07314003f, -0.09092886f, 0.28177854f, 0.13628440f, -0.05152000f, -0.03108464f, 0.03908132f, 
    0.44646364f, 0.09534135f, 0.03624311f, 0.06004111f, 0.02002013f, 0.10602006f, 0.24746332f, -0.00534232f, 
    -0.20427732f, -0.09555206f, -0.04455164f, 0.57321966f, 0.30151573f, 0.11096491f, 0.25774422f, -0.12714370f, 
    -0.31798843f, -0.44366181f, 0.23001719f, -0.15687539f, 0.15689060f, -0.05515252f, 0.33152619f, -0.35259721f, 
    0.09083360f, 0.07303350f, -0.16083574f, 0.21292195f, 0.15563340f, 0.36983860f, 0.18516929f, -0.17044094f, 
    0.17735232f, -0.01682688f, -0.21284531f, -0.09699733f, -0.34432554f, -0.08437534f, 0.09508855f, 0.30758095f, 
    -0.18604596f, 0.04372707f, 0.00740603f, 0.26676828f, 0.28532234f, 0.44077036f, -0.04466195f, -0.17142433f, 
    0.12387710f, -0.01550668f, -0.09062181f, -0.05348606f, 0.17646345f, 0.13217790f, -0.00907822f, -0.02382215f, 
    0.03418740f, 0.26614720f, 0.03702978f, -0.02107089f, 0.09580739f, -0.21883297f, 0.19340490f, 0.03822953f, 
    -0.19989845f, -0.42154869f, -0.09982177f, 0.08776960f, 0.35012242f, 0.05723097f, 0.24763207f, 0.21331766f, 
    -0.21962127f, 0.23897852f, 0.06654625f, 0.04390052f, 0.34126085f, 0.19572863f, -0.53078717f, -0.18853858f, 
    0.12279929f, -0.03436710f, -0.06456156f, 0.04839410f, -0.16342604f, -0.19004793f, 0.06179127f, 0.05794213f, 
    0.00250858f, 0.15208313f, 0.10933538f, 0.10905365f, 0.15817609f, -0.06959454f, -0.12126583f, -0.11838749f, 
    -0.09548674f, -0.32651937f, 0.43694904f, -0.05328905f, 0.50699991f, -0.14978425f, 0.07887781f, -0.03908935f, 
    -0.11418064f, 0.26358926f, -0.20557509f, -0.01078037f, 0.30512863f, 0.14542587f, -0.10990714f, 0.07801115f, 
    -0.04816185f, -0.04766935f, 0.31360775f, 0.09874275f, -0.06937110f, 0.00493087f, 0.31129506f, 0.16148458f, 
    -0.15511119f, -0.07842070f, -0.04799965f, 0.02895446f, 0.05578111f, -0.18219264f, -0.26161864f, 0.12641414f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.25621712f, 0.02078272f, -0.19689079f, 0.10159936f, 0.07446582f, -0.02877010f, 0.19993584f, 0.06736805f, 
    0.26184607f, -0.05494192f, -0.22468610f, 0.08336338f, 0.15757100f, 0.20443518f, 0.13905451f, 0.35767365f, 
    -0.17994052f, 0.15910231f, 0.07909747f, 0.06834147f, 0.09801032f, 0.06264896f, 0.20317364f, -0.06308211f, 
    0.15386499f, 0.01453350f, 0.15125467f, -0.17055058f, -0.16363873f, -0.03045407f, -0.28176680f, 0.01732956f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11254685f, -0.07327417f, 0.17609292f, 0.34495300f, -0.05274623f, 0.16477647f, -0.16476017f, -0.16709855f, 
    -0.25164866f, -0.22474198f, 0.28705996f, 0.01181573f, -0.19139834f, -0.29322881f, 0.20188497f, -0.53988135f, 
    0.11661864f, 0.23661898f, -0.41856536f, 0.19783780f, -0.25683492f, -0.52656907f, -0.29874662f, 0.22482978f, 
    -0.05178124f, -0.23758936f, -0.15103838f, 0.18642026f, 0.39516038f, -0.17438279f, -0.15980287f, 0.11915009f, 
    0.04596058f, -0.37939620f, 0.41905013f, -0.21685828f, 0.31081364f, 0.02164953f, 0.23285706f, 0.19469655f, 
    -0.43705559f, -0.16364895f, -0.55449438f, -0.17227238f, 0.19358158f, 0.19268705f, 0.32639822f, -0.04299279f, 
    -0.07313314f, 0.20013808f, -0.02275220f, -0.86718398f, 0.00224216f, -0.36760297f, 0.11967496f, 0.04465087f, 
    -0.63346541f, -0.06528590f, -0.48552027f, 0.17818826f, 0.17229497f, 0.18378527f, 0.03399128f, 0.28183863f, 
    0.19577572f, -0.11398456f, -0.92827171f, -0.61384028f, -0.26042819f, -0.03600990f, -0.27378291f, -0.55610961f, 
    -0.08296826f, -0.07470214f, -0.84270203f, 0.05121519f, 0.29083803f, 0.29093826f, 0.31333226f, -0.06099161f, 
    -0.20703615f, 0.13989650f, 0.40254605f, -0.55338997f, 0.15055646f, 0.05859843f, -0.52570516f, 0.07385393f, 
    0.21266975f, 0.07049491f, 0.14270896f, 0.01222166f, -0.46753722f, -0.00809187f, -0.17890362f, -0.30471402f, 
    0.11340766f, 0.35875219f, -0.00125873f, -0.18562616f, -0.15104832f, -0.53933221f, -0.25445959f, -0.17809522f, 
    -0.04645841f, 0.07121643f, -0.18372178f, -0.69997150f, -0.01638967f, -0.80614579f, -0.00185496f, -0.36603266f, 
    0.04344455f, 0.17217876f, -0.08939029f, 0.26255485f, 0.18179524f, 0.04215686f, -0.40897158f, 0.29476267f, 
    0.31015804f, -0.18201621f, -0.12426915f, -0.14804204f, 0.01980660f, 0.11869559f, -0.06783089f, -0.19080791f, 
    -0.15677842f, -0.42677298f, -0.01122391f, 0.30785561f, -0.22256495f, -0.54496479f, -0.32653099f, -0.20506480f, 
    0.08086959f, -0.48947316f, 0.10407194f, 0.12098183f, -0.06562577f, 0.03576766f, -0.02157271f, 0.06412248f, 
    0.20665568f, -0.19493470f, -0.03340378f, 0.24852686f, 0.13341568f, -0.05726393f, 0.10219005f, 0.18525393f, 
    0.15255825f, -0.03732435f, 0.15094027f, 0.18788779f, -0.50010020f, -0.18731184f, 0.10408387f, -0.43221098f, 
    0.15165594f, -0.61204517f, 0.01863633f, -0.08611809f, -0.21730262f, -0.00516871f, -0.09438103f, 0.19460586f, 
    -0.08048860f, -0.07930692f, 0.21041140f, 0.21053867f, -0.13910803f, -0.53365535f, -0.28487200f, 0.23844066f, 
    0.07591017f, 0.03600070f, -0.02818967f, -0.32511955f, 0.21672022f, 0.08334713f, -0.01009958f, -0.54101437f, 
    0.01793478f, 0.00534073f, -0.05524232f, 0.19600067f, 0.23686883f, -0.13473755f, 0.11069673f, -0.23120466f, 
    -0.25681645f, 0.14790791f, -0.44537482f, -0.38194484f, -0.12777317f, -0.10423210f, 0.31880108f, 0.02641802f, 
    0.08071254f, -0.14242466f, -0.43963104f, 0.14596730f, 0.36796224f, -0.08589165f, -0.06008345f, 0.41050452f, 
    0.10785887f, -0.81761169f, 0.20056750f, 0.09041075f, -0.54237556f, -0.18524857f, 0.28575009f, -0.49120173f, 
    -0.04896483f, 0.04680736f, 0.06042994f, -0.32632160f, -0.86372930f, -0.15752272f, -0.62587583f, 0.01607021f, 
    -0.32150450f, 0.07588033f, -0.39266899f, -0.30225056f, -0.28968498f, -0.22964160f, 0.22843325f, 0.07493141f, 
    0.06363445f, 0.04315237f, 0.04189849f, -0.04778811f, -0.21073438f, 0.02560910f, -0.20461752f, -0.63314831f, 
    0.03454241f, -0.60033476f, 0.31942528f, 0.07265652f, -0.67802775f, 0.17085046f, 0.06363942f, 0.01718605f, 
    0.54933983f, -0.23053920f, -0.00206528f, 0.38746488f, -0.02565557f, 0.18729226f, -0.15376417f, -0.17165746f, 
    0.05488266f, 0.01793433f, -0.48233020f, -0.08910178f, -0.04502784f, -0.18481608f, -0.07158680f, -0.06356648f, 
    0.39567071f, 0.38871706f, -0.50131005f, -0.54725182f, -0.25686851f, 0.10662632f, -0.21544558f, 0.00668421f, 
    -0.10985712f, 0.13492523f, -0.32534906f, -0.13243437f, -0.36545017f, 0.22008345f, 0.09170183f, -0.42379007f, 
    0.11702827f, 0.35943854f, -0.82293028f, -0.45517233f, 0.01635287f, 0.21393280f, -0.04781144f, -0.15505756f, 
    -0.53402859f, -0.21138532f, -0.03157899f, -0.11600783f, -0.13362306f, -0.76515275f, 0.19926211f, -0.57447129f, 
    0.10830984f, -0.22744913f, 0.18257542f, 0.27201667f, 0.30089423f, -0.32438216f, -0.02897811f, -0.04908089f, 
    -0.21986824f, 0.19527572f, 0.18512534f, -0.47895205f, -0.16021766f, 0.17812160f, -0.46875173f, -0.16344930f, 
    -0.17350630f, -0.05001448f, -0.02492433f, 0.29011604f, -0.68330437f, -0.44656870f, -0.01102142f, 0.36970666f, 
    0.26291066f, -0.34999907f, 0.09158799f, -0.32285202f, 0.06745320f, -0.30364791f, -0.21598682f, 0.42404613f, 
    0.17066866f, 0.20553406f, -0.03052470f, -0.19418387f, -0.48006901f, -0.38493711f, 0.33443922f, 0.22820409f, 
    -0.17173104f, -0.15657283f, -0.43338895f, -0.35331622f, -0.48816881f, -0.04157409f, -0.22448450f, 0.14273508f, 
    -0.38995469f, -0.10434060f, 0.27471951f, -0.23682949f, -0.55942774f, 0.15742481f, -0.55415261f, -0.29065987f, 
    0.05323738f, 0.42745644f, 0.29216367f, 0.06420262f, -0.17549197f, -0.32067052f, -0.00573295f, -0.17054617f, 
    -0.23783220f, 0.15797885f, -0.17305820f, -0.35644302f, -0.00376515f, -0.34080249f, -0.60725856f, -0.00131263f, 
    -0.33164704f, -0.10549104f, 0.11585245f, -0.16799104f, 0.15975931f, 0.41848704f, 0.04834157f, 0.01300599f, 
    -0.60303628f, -0.34966418f, 0.16682582f, -0.33292758f, -0.42156166f, 0.05716990f, 0.46008557f, 0.27776986f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.24224633f, 0.02631716f, -0.03703493f, -0.08647958f, -0.06909800f, 0.13457105f, 0.01029671f, -0.03474300f, 
    0.22797239f, -0.15562336f, 0.12916940f, -0.02502333f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
