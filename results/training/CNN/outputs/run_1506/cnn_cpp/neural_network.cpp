#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06359216f, 0.29649320f, 0.25878400f, 0.23396362f, -0.04522227f, 0.00051818f, 0.08841069f, 0.22575298f, 
    -0.11719184f, 0.14477140f, 0.28566527f, 0.03432027f, -0.23016797f, -0.25889561f, -0.04049856f, -0.16649833f, 
    0.14650606f, 0.15954578f, -0.08044274f, -0.17082219f, -0.06853054f, -0.13577761f, -0.05153554f, -0.15081738f, 
    -0.17032868f, 0.18752182f, 0.54520506f, -0.37649506f, -0.64210570f, 0.07351658f, 0.14507347f, 0.23924088f, 
    0.40390790f, -0.47964120f, -0.28087676f, -0.01765130f, 0.27832171f, 0.05682644f, 0.33258939f, -0.40812162f, 
    0.16052501f, -0.12933166f, -0.49903265f, -0.27405173f, 0.08505334f, 0.28293568f, 0.03077997f, 0.06483011f, 
    0.35813162f, 0.06474619f, 0.12327446f, -0.88066697f, -0.10182695f, -0.08616348f, -0.58033115f, 0.80890936f, 
    0.52764601f, 0.01145289f, -0.32090208f, 0.06028285f, -0.33191615f, -0.35345632f, -0.09521410f, 0.20685147f, 
    0.04376105f, 0.17613548f, 0.26582554f, -0.05533794f, -0.34466559f, -0.03622149f, -0.06077797f, 0.13496421f, 
    0.12251508f, 0.11568895f, -0.03091545f, -0.34996000f, 0.02084196f, 0.01216298f, 0.10291007f, 0.50171143f, 
    0.25770894f, -0.14538740f, -0.35744828f, -0.41487610f, 0.04357766f, -0.51615560f, 0.61862928f, -0.20336719f, 
    -0.33347982f, -0.04131862f, 0.14382266f, 0.16392848f, 0.06336450f, 0.27825323f, -0.08454244f, 0.24144293f, 
    -0.39744997f, -0.11510655f, 0.38721097f, -0.13841054f, 0.16419832f, -0.12249020f, -0.24397883f, -0.23559931f, 
    0.08161991f, 0.12516357f, -0.26008490f, -0.01346823f, 0.13839896f, 0.25042650f, -0.05469038f, -0.33519620f, 
    0.25447509f, 0.16940075f, 0.05344388f, -0.38375118f, -0.01035452f, 0.34905881f, -0.28463060f, -0.20426430f, 
    0.13856776f, 0.24931853f, -0.02962063f, 0.10725934f, 0.05586917f, -0.69614094f, -0.23660924f, -0.03326311f, 
    -0.30576095f, -0.57582569f, 0.25370190f, -0.23915799f, -0.06632328f, 0.28708035f, 0.23926768f, 0.04722458f, 
    0.08063500f, -0.23319671f, -0.10253683f, -0.14599407f, 0.11426907f, -0.45302036f, -0.09447226f, -0.13670896f, 
    -0.09211860f, -0.09280540f, 0.32330051f, 0.15717168f, 0.04653829f, 0.19799103f, 0.54328758f, 0.10406859f, 
    0.26775301f, -0.33680770f, -0.43094623f, 0.02571037f, 0.08639614f, -0.07283905f, 0.06925470f, -0.04045844f, 
    0.27162248f, 0.09183313f, -0.39756864f, -0.30672047f, 0.39685875f, 0.05342700f, 0.23644519f, -0.32817635f, 
    0.13269688f, 0.04935675f, -0.11493701f, 0.29179382f, 0.29547518f, -0.25391293f, -0.13243145f, 0.05843780f, 
    0.03708052f, -0.48735419f, -0.36391929f, -0.39974898f, -0.13038157f, -0.47831035f, -0.45070475f, -0.12115976f, 
    -0.09884811f, 0.44471622f, 0.33615345f, 0.57522416f, 0.03071659f, -0.04514394f, 0.16403931f, 0.08460739f, 
    -0.17321038f, -0.36511195f, -0.24012825f, -0.08615935f, 0.23636883f, 0.06712041f, -0.13263848f, 0.21727522f, 
    -0.54803830f, -0.59130752f, -0.21194768f, 0.22773069f, 0.23278689f, -0.46851185f, -0.24662922f, -0.10455878f, 
    0.29317230f, 0.10203519f, -0.15112230f, -0.40545401f, -0.38133657f, 0.13350095f, 0.28821182f, 0.11316966f, 
    -0.11766270f, 0.17152126f, -0.12093927f, -0.29108322f, -0.10113344f, 0.09264544f, -0.08276045f, -0.39522809f, 
    -0.06345391f, 0.53692830f, -0.05140721f, -0.12960732f, -0.18451473f, 0.38426921f, 0.67065167f, 0.05785181f, 
    -0.17550020f, 0.34051359f, -0.13858570f, 0.09166277f, -0.11166324f, -0.03363513f, 0.13020051f, 0.14455302f, 
    -0.07380017f, 0.06856430f, -0.09980334f, -0.12023696f, -0.23513442f, 0.14436963f, -0.09026979f, -0.37570202f, 
    0.20805861f, 0.08292593f, -0.12313042f, 0.64934433f, -0.06396335f, -0.28093037f, -0.21558388f, -0.18268274f, 
    0.20473556f, 0.08704913f, -0.11991742f, -0.36006907f, -0.29645801f, 0.27962163f, 0.57003611f, -0.28024170f, 
    0.07723771f, -0.43350536f, 0.12950616f, -0.16456012f, -0.11136518f, 0.22920434f, 0.45720229f, 0.24593519f, 
    -0.45449725f, -0.07838883f, -0.22325402f, -0.45204556f, -0.22015384f, 0.09266938f, 0.15597700f, -0.07577915f, 
    0.06997485f, -0.27814516f, -0.53921920f, -0.55427635f, -0.28283998f, -0.07685824f, -0.24524654f, -0.06612033f, 
    -0.40687120f, -0.32508862f, -0.18458608f, -0.29839855f, -0.06569768f, -0.14387593f, -0.06011463f, 0.08756806f, 
    -0.16180642f, -0.08234021f, -0.03404073f, 0.01958138f, 0.31394303f, -0.10373999f, 0.19438715f, -0.00206177f, 
    0.23149145f, -0.10408176f, 0.14628941f, 0.13123043f, 0.21312651f, 0.42172042f, -0.04678814f, 0.26326743f, 
    -0.03060364f, -0.29344815f, -0.09707012f, 0.01352348f, -0.09216709f, 0.04158120f, -0.16312724f, 0.07472233f, 
    0.19611585f, 0.29259580f, 0.14571413f, -0.17853534f, 0.03765620f, 0.57316524f, -0.69005311f, -0.35189423f, 
    0.36308596f, 0.50287515f, -0.07322808f, 0.51549870f, 0.29880664f, -0.46556500f, -0.61650515f, -0.03657385f, 
    -0.02820795f, 0.16586044f, -0.14519174f, 0.05098666f, -0.00402202f, 0.14810471f, -0.15790071f, -0.24198866f, 
    0.21522525f, -0.08588030f, -0.09594559f, -0.00122341f, 0.09343849f, 0.01262429f, 0.30450007f, -0.60043389f, 
    0.09920463f, 0.39657989f, -0.30561098f, -0.18622716f, -0.14655209f, -0.44943905f, -0.23525421f, 0.38453183f, 
    -0.29806682f, 0.16888511f, -0.18485303f, 0.06007408f, 0.29591998f, -0.31568480f, -0.16658041f, 0.05197015f, 
    0.16803436f, -0.47310594f, -0.28679234f, -0.27837986f, -0.03080575f, 0.28577214f, 0.34641242f, 0.34192502f, 
    -0.08093178f, 0.02968868f, 0.33034870f, -0.12217827f, -0.30961663f, -0.14888833f, -0.10133533f, -0.00943622f, 
    0.20139298f, 0.02889474f, -0.12388054f, 0.10958539f, -0.16440053f, -0.23383340f, 0.20045295f, -0.02192544f, 
    -0.28743184f, 0.25836152f, -0.33637539f, -0.35821730f, 0.03896906f, -0.15032578f, -0.24284804f, -0.59044141f, 
    0.13928948f, 0.20680732f, 0.36314148f, -0.52122551f, -0.47531584f, 0.10572722f, -0.13119911f, 0.08496571f, 
    0.12338194f, -0.35046473f, 0.08207144f, 0.48996416f, -0.19946596f, 0.28648347f, -0.22701554f, -0.23066930f, 
    -0.20043401f, 0.00598359f, -0.31469718f, -0.32640380f, 0.22789916f, 0.13883622f, 0.05994327f, 0.14627630f, 
    0.13390349f, -0.39658844f, -0.38598391f, 0.08740204f, 0.26437044f, 0.10363427f, -0.03692752f, 0.18054472f, 
    0.36329666f, -0.06036000f, 0.22357225f, 0.05967630f, 0.07041591f, 0.28999004f, 0.06159617f, -0.22978166f, 
    -0.19723147f, 0.04951652f, -0.09292755f, -0.34252572f, 0.28269124f, 0.21086481f, 0.11158113f, -0.18701927f, 
    -0.09377997f, 0.10272314f, -0.12832026f, -0.32039371f, -0.18029509f, 0.14247113f, -0.10532955f, 0.01025492f, 
    -0.27046055f, -0.15271494f, 0.01444057f, 0.31287995f, -0.11722839f, -0.11812036f, -0.03313156f, 0.22547746f, 
    -0.29681215f, -0.12251762f, 0.08986214f, -0.24003878f, -0.11890659f, -0.28872269f, -0.14553671f, -0.39101136f, 
    0.20098379f, -0.12447306f, -0.20698282f, 0.04381425f, 0.74775237f, 0.74313504f, -0.52726442f, 0.44328025f, 
    -0.22997038f, -0.17454214f, 0.21856803f, -0.21033901f, -0.26375005f, -0.09732033f, 0.03178686f, 0.33378607f, 
    -0.29989985f, -0.00126544f, 0.11214076f, -0.09075887f, -0.22775583f, -0.06543557f, 0.25085756f, -0.10136325f, 
    0.19544469f, -0.03385475f, -0.06176461f, -0.03207336f, -0.41293067f, -0.11382646f, -0.00945191f, 0.06699295f, 
    -0.04926315f, -0.21721742f, -0.20621407f, -0.34720322f, -0.11615076f, -0.40212265f, 0.29600450f, -0.29141086f, 
    0.09237426f, -0.29550824f, -0.15406770f, -0.01642829f, -0.25167722f, 0.03333816f, -0.10122529f, 0.08725467f, 
    -0.00153208f, 0.22113268f, 0.02479645f, 0.01318885f, 0.14272866f, -0.35845891f, 0.21245208f, 0.14032608f, 
    0.12759687f, 0.06484214f, -0.22013085f, -0.19155979f, -0.04558332f, 0.10733563f, 0.37758604f, 0.23045924f, 
    -0.26918882f, 0.58351636f, -0.58818156f, 0.01433074f, 0.18453087f, -0.23912986f, 0.01441315f, -0.11628033f, 
    -0.04879148f, -0.20133486f, -0.21369442f, 0.12726836f, 0.16758275f, 0.23535825f, 0.02750794f, 0.59996873f, 
    0.49646610f, -0.56633550f, -0.06911030f, -0.72957379f, -0.20689283f, 0.09759556f, -0.02825216f, 0.16251594f, 
    0.11154135f, 0.00629607f, 0.00448420f, 0.22244404f, -0.10870314f, 0.32832295f, -0.15841569f, -0.10363861f, 
    -0.06555936f, -0.21063150f, -0.26758346f, 0.13938867f, 0.02116457f, -0.01203813f, 0.15080532f, -0.87083435f, 
    -0.55831641f, -0.05953348f, -0.18129547f, 0.33707634f, -0.20478357f, -0.19356611f, 0.20194021f, 0.49935311f, 
    0.50823075f, -0.07845498f, -0.28263924f, 0.23637670f, 0.19963147f, -0.35663995f, -0.07624824f, 0.20375009f, 
    0.07731503f, 0.28916910f, 0.23248084f, -0.04393652f, 0.01115603f, -0.11722378f, -0.22242308f, -0.26850954f, 
    0.10834924f, 1.01815438f, 1.05006421f, -0.60581768f, -0.37154678f, -0.25733441f, -0.58571064f, -0.13328867f, 
    0.07296560f, -0.12590310f, -0.20361334f, -0.28904974f, -0.29735747f, 0.39111537f, -0.04227469f, 0.37033808f, 
    0.02245953f, 0.19218972f, 0.02729275f, -0.21245153f, 0.06144245f, -0.01538135f, 0.00480609f, -0.08902901f, 
    -0.18307483f, -0.73703986f, -0.27545530f, 0.00773896f, -0.64817053f, -0.54779333f, 0.70732915f, 0.39369908f, 
    -0.33477116f, 0.24694359f, -0.08684942f, -0.29947305f, -0.22673540f, 0.16494004f, -0.26900479f, 0.19398530f, 
    -0.10563166f, 0.10190710f, 0.11262157f, -0.12842168f, 0.00525224f, 0.02304009f, 0.03718170f, 0.06005216f, 
    0.04046892f, 0.20417230f, 0.09364249f, 0.16275369f, -0.01564151f, -0.04391210f, -0.18437529f, 0.29021347f, 
    0.13259619f, -0.01459967f, 0.13436215f, -0.09630367f, -0.15940362f, 0.11286052f, 0.23539543f, -0.42898870f, 
    0.23286143f, -0.16530068f, 0.13941865f, -0.24827284f, 0.15162295f, -0.09996674f, -0.14405234f, 0.20685872f, 
    -0.35063797f, 0.20093286f, 0.31802353f, -0.17802486f, 0.02306230f, -0.54322958f, -0.36335817f, -0.14087228f, 
    -0.28895023f, -0.28002754f, 0.25015154f, 0.21494947f, -0.20739938f, 0.39929900f, 0.14491417f, 0.30830863f, 
    0.27894020f, 0.21480983f, -0.06417008f, -0.24027108f, 0.00919668f, 0.22340792f, 0.00104559f, -0.02789591f, 
    -0.04262039f, 0.11631809f, -0.06448235f, -0.18709628f, -0.06065537f, -0.59432417f, 0.05854490f, 0.52809805f, 
    -0.17280711f, 0.40159461f, 0.41995272f, -0.32559142f, -0.17895959f, -0.25705549f, 0.06917617f, -0.32849211f, 
    -0.17236112f, -0.03175295f, -0.07471117f, 0.14461835f, 0.30758336f, -0.03833768f, 0.06181953f, -0.10485283f, 
    -0.30514774f, -0.36681375f, -0.33693969f, -0.15780558f, -0.21037215f, 0.15359035f, 0.53227204f, 0.17512578f, 
    0.20360094f, 0.05248375f, -0.28120238f, -0.54970169f, -0.08448053f, 0.41846192f, 0.02697283f, 0.49977791f, 
    0.00454208f, -0.29430473f, -0.21494332f, 0.25004452f, -0.01390192f, 0.10123259f, 0.04369896f, 0.00354508f, 
    0.09887019f, 0.02695807f, 0.02493429f, -0.03546256f, 0.16314815f, -0.02864312f, -0.06277804f, -0.10362832f, 
    0.11111085f, 0.10072511f, -0.05956560f, 0.27905494f, -0.05786271f, 0.02043983f, 0.31799328f, -0.05573421f, 
    -0.11860283f, 0.27998179f, 0.18333697f, 0.17690186f, -0.44083512f, -0.14055757f, 0.21558644f, 0.28377554f, 
    -0.04205529f, -0.22929882f, -0.08815265f, 0.15137030f, -0.22357500f, 0.08157568f, 0.28729925f, 0.22037680f, 
    0.11538131f, 0.06582195f, -0.38404256f, 0.07686076f, -0.23818596f, 0.03359746f, 0.09678662f, -0.00479625f, 
    0.32426533f, -0.21264903f, -0.14616895f, 0.60009331f, -0.43187642f, 0.33543384f, -0.32140899f, -0.03084907f, 
    -0.06965550f, -0.02568501f, 0.31782949f, 0.13690136f, 0.26463291f, 0.04081736f, -0.17718795f, -0.08946786f, 
    -0.46851519f, -0.42293456f, -0.62482411f, -0.00734435f, -0.44079703f, 0.48506978f, 0.37028301f, 0.17348656f, 
    0.11049680f, 0.33973691f, -0.05760996f, 0.01009249f, -0.18474039f, 0.25365886f, -0.02025974f, 0.03269345f, 
    -0.09961764f, -0.13077913f, -0.06621181f, -0.25853282f, 0.11129203f, 0.09789319f, 0.07717385f, 0.24024992f, 
    -0.00510254f, 0.29585287f, 0.32905036f, 0.17240585f, 0.29111221f, 0.24229091f, -0.03490776f, -0.06479467f, 
    0.23747836f, 0.07330466f, 0.10003570f, 0.17570421f, 0.04037872f, 0.10655227f, -0.10789546f, 0.04048123f, 
    -0.04660124f, 0.27684844f, -0.17988907f, -0.09246545f, -0.11637768f, -0.13261861f, 0.01018522f, 0.15345149f, 
    -0.00969497f, 0.00199401f, 0.26685709f, 0.07657490f, 0.16242176f, 0.13920648f, 0.26641446f, 0.08690266f, 
    0.12842283f, 0.17925450f, -0.03470242f, 0.18743625f, -0.10631680f, -0.09701464f, -0.01188282f, -0.20025104f, 
    0.14481090f, 0.24572857f, -0.05423728f, -0.20350941f, -0.08368529f, -0.23576756f, 0.06665579f, -0.07735687f, 
    -0.19037968f, -0.27163008f, -0.31322178f, -0.05269887f, -0.27215245f, -0.37443456f, -0.44268075f, -0.08750111f, 
    0.19452442f, -0.23349953f, -0.21230896f, -0.28206745f, -0.20830430f, 0.22542398f, 0.43493119f, -0.14146283f, 
    0.28081664f, -0.41003716f, 0.01715472f, 0.04304047f, -0.15711002f, 0.11096177f, -0.05434027f, -0.40308839f, 
    0.15642533f, 0.08083189f, -0.30139920f, -0.30722797f, -0.43313751f, 0.28461781f, -0.05531871f, -0.41301766f, 
    0.04229074f, -0.14326422f, -0.19773875f, -0.08632077f, 0.33862194f, -0.08864719f, 0.06285134f, -0.13114749f, 
    -0.00533881f, 0.00209838f, -0.25726461f, -0.07749122f, 0.04086407f, -0.20995612f, 0.25925392f, -0.12526329f, 
    0.14780256f, 0.43709794f, 0.17752807f, 0.00070555f, 0.16542552f, 0.01703732f, -0.32952094f, -0.00681431f, 
    0.52730662f, -0.02619130f, -0.19917832f, 0.39198789f, -0.42834485f, -0.04477372f, 0.30274883f, -0.32580194f, 
    0.07698289f, -0.24138521f, -0.10443351f, 0.45918152f, -0.08255389f, 0.17921750f, -0.06081810f, -0.05045581f, 
    0.05095604f, 0.35823819f, -0.32618240f, 0.28192127f, -0.15478693f, -0.25113147f, 0.00550259f, 0.38524622f, 
    -0.34600225f, -0.53246224f, -0.56383991f, 0.06057636f, 0.11944011f, 0.05981231f, 0.36517301f, 0.04422699f, 
    0.15082549f, -0.07503562f, -0.01273889f, 0.20458613f, -0.12688076f, -0.22758670f, -0.28077352f, 0.04643111f, 
    0.18067479f, 0.23669913f, 0.10419492f, 0.03435740f, -0.01483983f, -0.35851416f, 0.44205916f, 0.07110451f, 
    -0.02757346f, -0.05540038f, 0.55468524f, 0.07567523f, -0.29828790f, -0.15417384f, -0.08571440f, 0.20899190f, 
    0.04109379f, 0.57033056f, -0.44241887f, 0.02578557f, -0.00537256f, 0.36944452f, -0.22375529f, 0.20296009f, 
    -0.22782683f, -0.04451844f, -0.06805590f, -0.13677093f, -0.07173201f, 0.23850682f, 0.10612205f, -0.07270533f, 
    0.03272029f, 0.30595556f, 0.19897315f, -0.01781301f, 0.18441144f, -0.17486255f, 0.18300149f, 0.34647924f, 
    -0.04211571f, 0.14696489f, 0.27671075f, -0.22192359f, -0.07713892f, 0.27944860f, -0.29045156f, 0.07580540f, 
    -0.02591250f, -0.19653521f, -0.12580107f, -0.10690862f, 0.16720222f, -0.07912578f, -0.26582912f, -0.18882854f, 
    -0.07923818f, -1.02423632f, 0.14889424f, -0.29728305f, -0.92443025f, 0.01619532f, -0.21097730f, 0.18007523f, 
    0.50417024f, 0.74176192f, 0.51064599f, -0.33272627f, -0.30364621f, -0.18655372f, -0.29403359f, -0.11634931f, 
    0.20162010f, 0.15568057f, 0.04652731f, 0.17733581f, 0.24500795f, -0.29508147f, -0.06463811f, 0.06856455f, 
    -0.11690307f, -0.24757978f, -0.30589786f, -0.20584507f, -0.43530482f, 0.08372624f, 0.19992031f, 0.30985931f, 
    0.37926292f, -0.05535623f, -0.35212967f, -0.30907369f, 0.33670849f, 0.13583274f, 0.21206436f, -0.00666338f, 
    0.04301073f, 0.07280269f, -0.19955766f, 0.10146161f, -0.12203887f, 0.30622965f, -0.33125213f, -0.13979641f, 
    0.03844528f, 0.26223829f, 0.14422339f, -0.32487041f, -0.72586691f, -0.59628677f, -0.50894636f, -0.40757650f, 
    0.64045453f, 0.44939330f, 0.11110534f, -0.11485437f, 0.40428969f, 0.26949888f, -0.17444858f, 0.12769215f, 
    0.14759243f, 0.25714111f, -0.24498399f, 0.04624743f, 0.05860145f, -0.11570378f, -0.17858334f, -0.25663096f, 
    -0.16566692f, 0.09587484f, 0.16847038f, -0.12895611f, -0.79849410f, 0.00402842f, 0.06451556f, 0.30647835f, 
    0.01645923f, 0.33323351f, 0.05566993f, -0.07944167f, 0.16177391f, 0.52617538f, 0.19417964f, 0.06061885f, 
    -0.03471659f, -0.11411023f, -0.07081768f, -0.08070203f, 0.06351024f, -0.17603983f, 0.09457638f, 0.23049830f, 
    -0.13389391f, -0.11873934f, 0.09230727f, 0.05577730f, 0.08923840f, 0.78146285f, -0.54756993f, -0.41612768f, 
    0.43987992f, -0.83099490f, 0.13196065f, -0.17406581f, 0.07224654f, 0.12747885f, 0.15763071f, 0.05306566f, 
    0.19038102f, -0.18753712f, -0.28058723f, -0.32771391f, -0.15852940f, -0.08350956f, 0.28223911f, -0.02033321f, 
    -0.04199674f, -0.14825644f, -0.25261608f, -0.13089515f, 0.10516200f, -0.24669205f, -0.44879934f, -0.10716639f, 
    -0.11732747f, -0.29338521f, -0.70736808f, 0.04755210f, 0.30485782f, 0.30416816f, -0.28223160f, 0.03232366f, 
    -0.17661330f, -0.16966900f, 0.07139662f, -0.07330623f, -0.09228420f, 0.33461893f, -0.24855967f, 0.09815111f, 
    -0.05830953f, -0.22431801f, -0.21942535f, -0.21879913f, -0.16245976f, -0.02343846f, 0.02804130f, 0.46131283f, 
    -0.06035262f, 0.29185647f, -0.44258714f, -0.05195580f, 0.08684047f, 0.47994363f, -0.14588292f, -0.34290704f, 
    -0.12992631f, 0.15204644f, 0.06162314f, -0.28823972f, -0.05238090f, -0.11626650f, -0.03942912f, 0.06819028f, 
    0.14796054f, 0.08545961f, -0.02633611f, -0.00158113f, 0.06621257f, -0.21150129f, 0.06523648f, -0.42096299f, 
    -0.18199073f, -0.16805986f, -0.36303830f, -0.08904446f, -0.00114206f, 0.45618105f, 0.58775288f, 0.41482273f, 
    0.13144447f, 0.10646466f, 0.08779698f, 0.10456980f, -0.02957710f, 0.04664529f, 0.02282287f, 0.08264413f, 
    -0.01242599f, 0.11942872f, -0.05562118f, -0.21348460f, -0.10085039f, 0.13581547f, -0.00993268f, -0.09161226f, 
    0.07639882f, -0.19177343f, 0.02441652f, -0.28822604f, 0.49611789f, 0.20846230f, -0.10793868f, -0.04607042f, 
    0.01911253f, 0.07218766f, 0.31230992f, 0.13773404f, -0.13224950f, -0.26063478f, -0.01536829f, -0.01621714f, 
    -0.22534131f, 0.05672239f, 0.30629703f, -0.07060549f, -0.41549471f, -0.16503654f, -0.14957996f, 0.15249853f, 
    -0.33520201f, 0.41481519f, -0.59594738f, -0.52739012f, -0.05227411f, 0.36628938f, 0.46523181f, -0.49963096f, 
    -0.47432971f, -0.47110322f, -0.00510478f, 0.37901586f, 0.04680668f, 0.28473300f, 0.53348315f, -0.03056062f, 
    -0.11512658f, -0.21954231f, 0.05977886f, -0.09899037f, -0.33111089f, -0.32659262f, 0.30065373f, -0.24369611f, 
    -0.12161744f, 0.02052082f, 0.12538332f, 0.37026316f, -0.46992362f, -0.21035646f, -0.28993952f, 0.10820229f, 
    0.24425554f, -0.10291178f, 0.00041106f, 0.09341288f, -0.22955015f, 0.11491197f, -0.08209793f, 0.12475081f, 
    -0.01093129f, 0.11151730f, -0.06656965f, 0.12998492f, 0.18821791f, -0.10593150f, -0.09179583f, 0.02122427f, 
    -0.14827244f, 0.17873898f, -0.29325256f, -0.38512880f, 0.25836381f, 0.20629795f, 0.09220658f, 0.10576236f, 
    0.15422408f, -0.13234656f, 0.08175505f, -0.25632325f, -0.13694766f, 0.03720142f, -0.17411295f, 0.13644499f, 
    -0.13233435f, 0.05456133f, 0.16331890f, -0.06612577f, -0.13266328f, -0.05335306f, 0.23177724f, 0.08809803f, 
    -0.12821701f, 0.15299451f, -0.16231978f, 0.14046523f, 0.24184898f, -0.30380926f, 0.07286860f, -0.22446144f, 
    -0.19949158f, -0.41064870f, -0.20900649f, 0.05733389f, -0.33270398f, -0.24968497f, -0.29614496f, 0.07958443f, 
    0.05914642f, 0.14111669f, -0.31562123f, 0.37350777f, -0.09150511f, -0.06514529f, 0.02523998f, 0.00418064f, 
    -0.05567748f, 0.24935867f, 0.23920606f, 0.29474244f, 0.16659172f, 0.05862210f, -0.96398348f, 0.35912573f, 
    0.46850088f, 0.25385356f, 0.07862657f, 0.54089838f, 0.51887012f, -0.74851519f, -0.34105814f, -0.12642837f, 
    -0.24257147f, 0.04011962f, 0.08068097f, -0.21114050f, 0.11852679f, -0.06612633f, -0.00312235f, -0.09783585f, 
    0.15663250f, 0.25894910f, 0.14032266f, -0.05891797f, 0.03792375f, -0.13451555f, -0.20075524f, 0.16269541f, 
    -0.06050266f, 0.27430236f, 0.48796150f, -0.01987985f, 0.03001050f, -0.01785422f, -0.24842234f, -0.42595041f, 
    -0.39075989f, -0.21123992f, 0.18510945f, -0.12951422f, 0.21139126f, -0.02857713f, 0.27160969f, 0.05208725f, 
    0.05260894f, -0.27259639f, 0.19577873f, -0.37687421f, -0.35618243f, 0.22351047f, 0.24790566f, 0.15193462f, 
    0.56456375f, -0.39498305f, -0.32407051f, -0.46275800f, -0.18339019f, -0.07352854f, 0.48177496f, 0.38119066f, 
    -0.29198515f, -0.14853130f, -0.33513716f, -0.38912165f, 0.02776396f, 0.16379833f, -0.22581534f, -0.14464770f, 
    -0.32358247f, -0.05431230f, -0.49235657f, -0.02598477f, 0.16540243f, -0.07966907f, -0.09403545f, -0.06279571f, 
    -0.43268946f, 0.29219997f, 0.20423651f, -0.02076288f, 0.13043481f, 0.39912209f, 0.18205395f, 0.13919953f, 
    -0.22578503f, -0.16351570f, -0.06293632f, 0.15432410f, 0.18804193f, -0.06957845f, -0.22880940f, -0.04271372f, 
    -0.25984377f, 0.04830712f, 0.02898757f, 0.07381707f, 0.15029173f, 0.00155923f, -0.15969145f, -0.03396223f, 
    -0.30432302f, -0.41051894f, -0.02687362f, 0.48318675f, 0.09332740f, -0.32136914f, 0.10667153f, -0.27980307f, 
    -0.14979403f, 0.36836618f, -0.48171520f, -0.32680973f, -0.17991596f, 0.06486171f, -0.19511858f, -0.09663860f, 
    -0.14232287f, -0.00788796f, 0.19762127f, 0.02295346f, -0.16232572f, 0.17445478f, -0.04893498f, -0.05373567f, 
    -0.19873556f, 0.15801454f, 0.34422666f, 0.75345498f, -1.02025938f, 0.09186982f, 0.02807454f, 0.58888847f, 
    -0.29250699f, 0.41332158f, -0.15801673f, -0.29521224f, -0.02069020f, 0.25777811f, -0.15044017f, -0.17898628f, 
    -0.24151407f, 0.19227137f, -0.06598259f, 0.06280033f, 0.18684988f, 0.16233917f, -0.19753070f, -0.06293052f, 
    0.09331272f, 0.10074737f, -0.17844458f, -0.09096554f, -0.48542359f, -0.32564750f, -0.18180783f, -0.31750858f, 
    -0.03480453f, 0.39394239f, -0.04547450f, -0.40032363f, 0.09492088f, 0.34404573f, 0.10700005f, -0.27289054f, 
    -0.08322795f, 0.08160885f, -0.23860925f, 0.01013957f, 0.08768018f, 0.10829148f, 0.08327862f, -0.31304497f, 
    0.09756679f, 0.06454141f, 0.16991058f, 0.33446452f, 0.36559746f, 0.07691913f, 0.50432301f, 0.17138879f, 
    -0.34919864f, -0.33399409f, -0.11964548f, -0.36216176f, -0.39871821f, -0.34942257f, -0.63699067f, 0.19549665f, 
    0.22347184f, -0.22229259f, 0.03835506f, -0.13226843f, 0.11056257f, -0.24654339f, -0.09363397f, -0.29801357f, 
    0.13735320f, -0.17100286f, -0.29345411f, 0.08095207f, 0.01474025f, -0.22253594f, -0.64754832f, -0.15564457f, 
    -0.53514379f, 0.12537822f, -0.08589048f, 0.27378908f, -0.13283046f, -0.25867999f, -0.56884778f, -0.38271067f, 
    -0.37961546f, 0.06504683f, -0.21938673f, -0.38678551f, -0.10138360f, 0.00713359f, -0.14520527f, 0.07168525f, 
    0.04467092f, -0.29122612f, -0.12826191f, 0.22519007f, 0.07256686f, -0.04610293f, 0.05160876f, -0.02023259f, 
    -0.38038847f, 0.09200749f, 0.07498644f, -0.09660718f, -0.03781622f, -0.45493636f, -0.52162462f, -0.19418249f, 
    -0.19302231f, 0.44430637f, 0.27161530f, 0.13360867f, 0.05302678f, -0.08364008f, -0.09267542f, 0.12395777f, 
    0.12244559f, -0.10829034f, 0.14233559f, 0.11807439f, 0.10640490f, 0.00844900f, -0.47747281f, -0.34381297f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04983704f, 0.04675626f, -0.03550778f, -0.13433298f, 0.19462726f, -0.06234266f, 0.14349674f, -0.15438716f, 
    -0.18876816f, 0.03187285f, 0.13046166f, -0.24737999f, -0.21963315f, 0.17019947f, 0.06834404f, -0.23734388f, 
    -0.09800646f, -0.00639471f, 0.07366810f, 0.25432077f, 0.07117019f, 0.27187806f, 0.11838497f, -0.06525511f, 
    0.00226732f, 0.09216591f, 0.16500664f, 0.08113350f, -0.26478714f, 0.00985966f, 0.07776587f, 0.07655362f, 
    0.23355778f, -0.43458924f, -0.19756319f, -0.02661665f, -0.19783472f, -0.05261750f, 0.15839738f, 0.18786347f, 
    -0.33012170f, 0.07074287f, -0.19802214f, 0.10310609f, -0.19664285f, 0.05104715f, -0.18054126f, 0.13867052f, 
    -0.14873296f, 0.13819762f, 0.00819189f, -0.12706220f, -0.01267235f, -0.06668197f, 0.03513685f, -0.18243216f, 
    -0.23927888f, -0.23546180f, 0.10388934f, 0.06944337f, -0.38287351f, -0.08353385f, -0.23582254f, -0.10377418f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08212055f, 0.00320216f, -0.16312072f, -0.11534222f, -0.07216175f, -0.06712878f, 0.00065341f, -0.05050243f, 
    0.09247883f, 0.17961971f, 0.02362403f, 0.08464321f, 0.12589607f, -0.08682624f, 0.05980613f, -0.16981800f, 
    0.06625316f, 0.10887869f, -0.23137625f, 0.10937833f, -0.08491527f, 0.05813194f, -0.03585766f, -0.17477198f, 
    -0.47608745f, 0.21057917f, 0.19102505f, 0.00754351f, 0.05222525f, 0.08875382f, 0.17853317f, -0.17353770f, 
    -0.06967542f, -0.05871669f, -0.11615948f, 0.16313127f, 0.04448150f, -0.02456645f, 0.09249972f, 0.24258037f, 
    0.02519140f, 0.03742183f, 0.16761048f, -0.03578920f, -0.14342138f, -0.06473352f, -0.16498917f, 0.09164176f, 
    -0.05185536f, -0.01742997f, 0.06365408f, -0.06828421f, -0.01500709f, -0.09016458f, 0.01280264f, 0.06937619f, 
    -0.05512983f, -0.04693828f, -0.11493907f, -0.05995926f, 0.06209949f, 0.02584453f, 0.07119913f, 0.25478846f, 
    0.04949328f, -0.19297349f, -0.07608839f, -0.07076675f, -0.00336118f, -0.04512931f, -0.00321013f, -0.09288179f, 
    -0.06298274f, 0.06476797f, -0.04584368f, 0.12497423f, -0.01230924f, 0.14465459f, 0.11011407f, -0.19269441f, 
    0.05127168f, -0.12735982f, 0.00895634f, 0.04966959f, -0.06176772f, -0.05539300f, 0.02002848f, 0.12857741f, 
    -0.06068200f, -0.02604128f, 0.05031291f, -0.04562634f, 0.14460768f, 0.10988895f, -0.05335225f, -0.04047677f, 
    -0.07332367f, -0.11859595f, -0.20558730f, -0.06445074f, -0.09078390f, 0.11848198f, -0.12428977f, 0.02487340f, 
    0.02149724f, 0.05599983f, 0.24923494f, 0.28292125f, -0.05945959f, -0.05776444f, 0.00980675f, -0.02319273f, 
    0.23916776f, 0.03958251f, -0.02443534f, 0.06381986f, -0.21522708f, -0.00109175f, -0.05089306f, 0.02250142f, 
    0.04595644f, -0.18620166f, 0.07522853f, -0.17361291f, 0.09441852f, -0.00461342f, 0.06140199f, -0.04380957f, 
    -0.09000182f, 0.04802154f, 0.00480260f, 0.06323227f, -0.18299842f, -0.17557701f, -0.04992402f, 0.25705734f, 
    0.11277239f, 0.07334211f, 0.10267147f, -0.02784721f, -0.07349655f, -0.01586381f, -0.06443783f, 0.01661333f, 
    -0.02103754f, -0.00431455f, -0.05684109f, 0.01088613f, 0.11441407f, 0.11188541f, -0.03175259f, 0.10364477f, 
    -0.09115560f, -0.03827628f, -0.20698631f, -0.11405158f, -0.27384001f, 0.35483253f, -0.07857207f, 0.17689824f, 
    0.08825406f, -0.09072667f, -0.10688455f, 0.07538140f, -0.02478479f, -0.04162998f, -0.12831965f, -0.01549733f, 
    -0.15520146f, -0.04027553f, -0.16619055f, 0.31445581f, -0.00855771f, -0.03390099f, 0.20222384f, 0.05952773f, 
    -0.17486691f, 0.11091525f, -0.02669329f, -0.07919867f, 0.11850984f, 0.03055646f, -0.09495473f, -0.04083885f, 
    -0.08516067f, -0.07419161f, -0.00120939f, 0.07984427f, 0.21802168f, 0.21063043f, 0.10403167f, 0.26741052f, 
    0.05438468f, -0.08996838f, 0.13891961f, -0.04551602f, 0.12175253f, -0.04917580f, 0.25716883f, -0.19680725f, 
    -0.13732919f, -0.00280081f, -0.03112491f, -0.11874931f, -0.04337938f, 0.01781440f, 0.07245304f, -0.22669397f, 
    0.02794850f, 0.02222499f, -0.07874142f, 0.01149532f, 0.09448928f, 0.07678624f, -0.06222324f, -0.05424977f, 
    -0.06413835f, 0.00362606f, 0.11714657f, 0.06443169f, -0.13169231f, -0.09235448f, -0.06586894f, -0.00912553f, 
    0.04610337f, 0.10312641f, 0.13231303f, 0.30491391f, 0.35116670f, 0.12346900f, 0.39963508f, -0.19020484f, 
    -0.02473107f, 0.14184354f, -0.14397521f, -0.07647620f, 0.06649319f, -0.07109626f, -0.01592509f, -0.05208994f, 
    -0.02166533f, -0.20287314f, -0.00784729f, 0.05004631f, 0.01868122f, 0.02991232f, -0.00823573f, -0.02595941f, 
    -0.01857048f, -0.08188477f, 0.01330487f, -0.13402925f, 0.18272452f, -0.04764231f, 0.04777285f, -0.13576123f, 
    -0.04641467f, -0.09334214f, -0.10510611f, -0.01361965f, -0.04998561f, 0.05975275f, 0.05301321f, -0.26751441f, 
    0.35156709f, -0.12257548f, 0.01726791f, -0.12451969f, 0.04710924f, 0.10919229f, -0.10653652f, -0.08146552f, 
    -0.12677391f, -0.04919889f, 0.03707865f, -0.24487203f, 0.17254178f, -0.12284925f, 0.04982879f, 0.00520581f, 
    0.09646263f, 0.08218144f, 0.08906235f, 0.03023929f, -0.01302259f, 0.10914997f, 0.17601995f, 0.16510603f, 
    0.35070330f, -0.32805380f, 0.28120169f, 0.08093466f, -0.01343178f, 0.04429443f, 0.00236090f, -0.14131348f, 
    0.13969168f, 0.07590041f, 0.04431639f, 0.07090139f, -0.02788221f, -0.14974576f, 0.13294324f, 0.18519472f, 
    0.02874576f, -0.01640062f, 0.03675682f, -0.10598911f, -0.04962035f, -0.05287585f, -0.11632090f, 0.00806660f, 
    -0.06789739f, 0.07214999f, 0.08937629f, -0.13264547f, 0.17091800f, -0.05312961f, -0.10707153f, -0.03414388f, 
    -0.26453322f, 0.06243591f, 0.04965759f, -0.20964795f, 0.00685076f, 0.06076707f, 0.08884010f, 0.10443886f, 
    -0.01614854f, 0.03968821f, -0.10053415f, -0.01477308f, 0.12794271f, -0.08390205f, 0.03045228f, -0.11518111f, 
    -0.27285025f, 0.21391684f, -0.01871395f, 0.04341305f, 0.07518449f, -0.09300270f, 0.01955066f, 0.01651354f, 
    0.04355093f, 0.36289224f, 0.15052605f, 0.14631347f, 0.22053254f, -0.11398694f, 0.01585267f, 0.07677604f, 
    -0.05902144f, -0.02052232f, 0.06666518f, 0.06307897f, 0.06821427f, -0.07653016f, -0.18210441f, -0.17895141f, 
    0.00125756f, -0.04575973f, 0.07004651f, -0.06003419f, 0.10330369f, 0.02510630f, 0.02217566f, 0.02098855f, 
    -0.22014849f, 0.15172027f, -0.15271412f, -0.11942446f, 0.15731874f, 0.05936823f, 0.03000714f, -0.19378296f, 
    -0.02285367f, 0.00999094f, -0.00513662f, -0.00563556f, 0.01149841f, 0.00107148f, -0.09093552f, 0.03473026f, 
    -0.07671259f, 0.11833378f, 0.19034155f, 0.15795937f, 0.11160474f, -0.07265131f, 0.11431152f, 0.12118335f, 
    0.02065447f, 0.03175647f, -0.05935015f, 0.06358648f, 0.13131100f, -0.02900412f, -0.05494759f, -0.20913969f, 
    -0.07095051f, 0.00118023f, -0.00182325f, 0.22357568f, 0.02620861f, 0.11421902f, -0.07880700f, -0.02945388f, 
    -0.07841912f, 0.01904225f, -0.18434343f, -0.18436080f, 0.01770846f, -0.11781214f, 0.05223626f, 0.00692897f, 
    0.08937910f, 0.11530758f, 0.15428427f, 0.16499531f, -0.13782147f, -0.07290404f, 0.11667224f, 0.07315119f, 
    0.10612365f, 0.01286918f, -0.06479651f, -0.06779464f, 0.12968111f, 0.08225869f, 0.11917914f, 0.16634183f, 
    0.14604236f, -0.17874117f, -0.01914535f, -0.03693921f, -0.04623405f, -0.05792255f, -0.04613543f, 0.00115183f, 
    -0.04243315f, -0.26710308f, -0.02711533f, -0.22434120f, -0.27927276f, -0.15838525f, -0.34561887f, 0.25020790f, 
    0.13838781f, -0.09270491f, 0.16024628f, -0.06785382f, 0.21444263f, 0.11163121f, -0.22254449f, 0.27673385f, 
    0.26671410f, 0.08407334f, 0.06529918f, 0.33229297f, 0.09809152f, 0.06451818f, -0.17511734f, 0.05462741f, 
    0.00856649f, -0.06907588f, -0.02918137f, -0.25392643f, 0.13652095f, -0.00231864f, -0.07967354f, 0.08522334f, 
    -0.13817155f, -0.12290119f, -0.00431091f, 0.04637199f, -0.05875942f, -0.11660280f, -0.05758489f, 0.04276762f, 
    0.00923268f, -0.12356791f, -0.01746900f, -0.34862438f, 0.04116886f, -0.09254329f, -0.11434246f, 0.02715499f, 
    -0.00459756f, -0.00537371f, 0.07033984f, 0.08363846f, 0.43794063f, -0.12032163f, -0.01535648f, 0.19948855f, 
    0.14210089f, -0.04096742f, 0.00333612f, 0.12571703f, -0.04682688f, 0.11259257f, 0.14192478f, 0.13883652f, 
    -0.25685766f, 0.12878035f, 0.10942000f, 0.09792708f, 0.04405626f, -0.07691374f, -0.01647481f, 0.00374989f, 
    -0.15967736f, 0.06956760f, -0.00143847f, -0.12987632f, -0.35312673f, 0.29739064f, 0.25142834f, 0.22749925f, 
    0.08280721f, -0.04923829f, 0.03663252f, 0.07893927f, 0.05531452f, -0.00444353f, 0.07328535f, 0.09089704f, 
    0.03162962f, 0.02707827f, -0.02755856f, 0.05525874f, 0.15437327f, 0.04988390f, 0.15893412f, 0.10801768f, 
    0.00021811f, 0.02671892f, -0.03473427f, -0.04669398f, -0.30120090f, -0.05497575f, -0.05179970f, 0.25472900f, 
    -0.01126051f, -0.00224794f, 0.19655481f, -0.01487844f, 0.02858046f, 0.16385093f, 0.06700787f, 0.07678607f, 
    0.01806420f, -0.01096661f, -0.01042798f, 0.09012420f, -0.06405170f, -0.09652483f, 0.09080958f, -0.00612936f, 
    0.00076789f, 0.07385749f, 0.13398314f, 0.09491065f, -0.07385000f, 0.26518369f, -0.08779432f, 0.11538745f, 
    0.03386827f, 0.10506555f, 0.11003845f, -0.00287402f, 0.07769432f, 0.08204303f, 0.10740932f, 0.07846168f, 
    -0.19472544f, 0.06304859f, -0.05696233f, -0.15100090f, 0.13339189f, 0.04495697f, 0.09197105f, 0.18821374f, 
    -0.09067375f, -0.00510205f, 0.04092119f, -0.03315715f, -0.04111643f, 0.07162480f, -0.21700124f, -0.05984918f, 
    0.02725645f, -0.03529661f, -0.00178178f, 0.09608889f, -0.02052670f, 0.15902258f, 0.01537430f, 0.00098605f, 
    -0.02300679f, -0.15444724f, -0.28673577f, 0.07188182f, 0.09964015f, -0.09324645f, -0.09518659f, -0.07947252f, 
    -0.14007354f, 0.10228516f, -0.01814022f, -0.04503051f, -0.28022382f, 0.15308760f, -0.02430209f, -0.05861643f, 
    0.09997238f, 0.01825280f, -0.01160468f, -0.16848572f, 0.11627129f, 0.02301913f, -0.02155873f, 0.20412083f, 
    0.03048665f, 0.02183338f, -0.07021774f, 0.05305283f, 0.06749912f, 0.09108819f, 0.04376695f, -0.00856915f, 
    -0.17192748f, -0.12897095f, -0.09020080f, -0.27039182f, -0.05176309f, -0.10648793f, -0.01963490f, 0.05824208f, 
    -0.01688944f, -0.10016460f, -0.02763796f, -0.06697451f, 0.03493918f, -0.06414510f, -0.11319919f, -0.16869003f, 
    -0.13178124f, -0.08715907f, -0.09151740f, 0.21687244f, 0.14235468f, 0.03034304f, 0.03589474f, -0.20514132f, 
    -0.07920007f, 0.05653122f, -0.01134386f, 0.13920006f, -0.14106639f, 0.29110539f, 0.13138857f, 0.32631341f, 
    0.03853884f, 0.10956009f, -0.00976663f, 0.06381913f, -0.21575730f, 0.16438828f, -0.15723820f, -0.02770439f, 
    -0.29995552f, 0.08269770f, 0.04023492f, 0.02302986f, -0.11185893f, 0.07131090f, 0.00639391f, -0.03229011f, 
    -0.03477373f, 0.14025666f, 0.06321006f, 0.13684218f, -0.02473109f, -0.11849451f, -0.27360943f, 0.06908507f, 
    -0.07409330f, 0.02905306f, 0.01354347f, -0.07649609f, 0.14620070f, 0.14052901f, 0.10568228f, 0.36826310f, 
    0.09653324f, 0.06241721f, 0.17687610f, -0.13096406f, 0.00810831f, 0.05852007f, -0.05768902f, 0.04735551f, 
    -0.02768497f, -0.14543985f, -0.21375367f, -0.22228627f, -0.43731162f, 0.19103333f, -0.19212413f, 0.43099973f, 
    0.01945247f, 0.07449660f, 0.00320604f, -0.01282801f, 0.27903399f, -0.01733955f, 0.00855206f, 0.02497874f, 
    -0.05206213f, -0.07724816f, -0.08431589f, 0.09339026f, 0.11062072f, -0.00868647f, 0.05723707f, -0.02255751f, 
    -0.17936985f, -0.00615992f, -0.29190326f, -0.18703142f, -0.04959864f, -0.02836656f, 0.20102479f, 0.07347968f, 
    0.20854992f, 0.05237859f, 0.05325503f, -0.13593096f, 0.04051126f, 0.00903595f, 0.05383716f, 0.07357941f, 
    -0.10031863f, -0.30116439f, -0.03388768f, 0.10647287f, 0.04561984f, -0.07782500f, -0.03250082f, -0.07559443f, 
    -0.03078952f, -0.02420876f, 0.00059681f, -0.03623668f, -0.27568269f, -0.12604304f, 0.01541637f, 0.15471141f, 
    0.07771765f, 0.16055952f, -0.07311116f, -0.19441055f, 0.12527144f, 0.02979017f, -0.03784692f, 0.16985941f, 
    0.00505724f, 0.02910138f, 0.01550796f, -0.00007068f, -0.00961613f, -0.03733843f, -0.01952418f, 0.03036284f, 
    -0.02011408f, 0.02574374f, 0.00069697f, 0.00966198f, 0.02862920f, 0.02927572f, 0.02689118f, -0.01730964f, 
    -0.00741988f, 0.01154115f, -0.00960295f, -0.00086498f, -0.03466586f, 0.01208205f, 0.00826495f, 0.03026041f, 
    0.01750321f, -0.01152842f, 0.03723072f, -0.03922782f, -0.00530520f, -0.01520466f, -0.01469503f, -0.00824456f, 
    0.00274857f, 0.00166004f, -0.00245315f, -0.03374219f, -0.02559510f, 0.00215844f, 0.00106490f, -0.00973195f, 
    0.00271454f, -0.02298384f, -0.03886124f, 0.00494699f, 0.01831038f, -0.00389925f, 0.03911243f, -0.02399904f, 
    0.02711851f, 0.02454767f, -0.02148205f, 0.01589254f, -0.01588357f, -0.01964427f, -0.01714997f, 0.02284816f, 
    0.02816498f, 0.00909221f, -0.02492349f, -0.02690050f, -0.00487264f, 0.02883575f, 0.03201023f, 0.03190278f, 
    -0.02971767f, 0.02884474f, -0.01273190f, 0.01925197f, -0.03016925f, -0.01265476f, 0.02882393f, 0.01891172f, 
    -0.00957055f, -0.01506751f, -0.02648053f, 0.03726752f, -0.02716846f, 0.01278674f, 0.02922944f, -0.00179512f, 
    0.01648656f, -0.02626698f, -0.00606504f, 0.03403075f, 0.01476462f, -0.00804013f, -0.00239110f, 0.02934493f, 
    -0.03598587f, -0.00924546f, 0.03553525f, 0.02148993f, 0.00305617f, 0.02707377f, -0.03040049f, -0.01775586f, 
    0.00252278f, 0.00922878f, -0.03657445f, -0.00389884f, -0.00979942f, -0.02549073f, -0.00274356f, 0.02452930f, 
    0.02147485f, -0.01301195f, -0.00711495f, 0.00037358f, -0.03296015f, 0.02271073f, 0.01476683f, -0.00466490f, 
    -0.02152918f, -0.00873894f, 0.03212639f, 0.00369133f, -0.00199675f, -0.03193219f, -0.01741693f, -0.02824047f, 
    0.00514724f, -0.00052088f, -0.00708760f, -0.00341378f, 0.03141445f, -0.02260585f, 0.02786870f, -0.02186680f, 
    0.02271439f, -0.02926775f, -0.03864214f, -0.03541718f, -0.01535749f, -0.00287228f, -0.01665302f, 0.00631368f, 
    0.00380604f, -0.00995407f, -0.00151668f, -0.00871676f, -0.00238395f, 0.00880091f, -0.03666915f, -0.02140997f, 
    0.03022008f, 0.03991684f, 0.02082764f, -0.01750053f, -0.01739757f, -0.00148318f, -0.00423833f, -0.01277138f, 
    0.04090041f, -0.03096513f, 0.00678807f, 0.02275244f, -0.02632868f, 0.02639403f, -0.00902476f, 0.03809242f, 
    -0.04106060f, 0.01317666f, -0.00807921f, -0.02442344f, -0.00365889f, 0.02230540f, -0.01973208f, 0.03811365f, 
    0.00653936f, -0.00950728f, 0.00269525f, -0.03194404f, -0.02841540f, -0.02539540f, -0.03037478f, -0.01562846f, 
    -0.01289192f, -0.01559697f, 0.03086375f, 0.03498938f, -0.01325979f, 0.00774621f, -0.02924032f, 0.00437164f, 
    0.01368885f, -0.01063777f, 0.02768173f, 0.03279564f, -0.02534894f, -0.00685599f, -0.01525015f, -0.01745492f, 
    0.00404002f, 0.02962556f, -0.03856342f, -0.02543982f, -0.02901527f, 0.01865735f, 0.01335873f, -0.01028477f, 
    -0.02055689f, -0.02465920f, -0.02479424f, -0.02495117f, -0.02638398f, -0.02207805f, 0.00061737f, 0.02207730f, 
    0.02232098f, -0.01738158f, 0.03397891f, -0.03248444f, 0.00439871f, -0.02362048f, -0.02708390f, -0.03707183f, 
    0.02575603f, -0.00604438f, 0.01568217f, -0.00106085f, 0.00370319f, -0.01298141f, -0.02249765f, 0.01014761f, 
    -0.01763168f, -0.03138105f, -0.03281153f, 0.00085613f, -0.00784991f, -0.01060167f, -0.02689473f, -0.01099634f, 
    0.00134704f, -0.01753642f, 0.02291166f, -0.00889662f, -0.00922695f, 0.00823303f, 0.02834779f, -0.01945137f, 
    -0.01780945f, 0.01277475f, 0.00836857f, -0.03307637f, -0.02487240f, 0.03124228f, 0.02454264f, 0.02747423f, 
    0.01468160f, -0.02216482f, 0.01896292f, -0.01186574f, 0.02284150f, -0.00377560f, 0.00792462f, -0.03425488f, 
    0.02309275f, 0.01488615f, 0.02074217f, -0.01896882f, 0.02300473f, -0.02368490f, -0.03694200f, 0.00055962f, 
    -0.01744018f, -0.02412207f, 0.00450950f, -0.02248397f, 0.04215408f, -0.03355670f, 0.02659540f, -0.02260152f, 
    0.00836758f, 0.01625619f, -0.03807966f, -0.01904679f, 0.00925133f, -0.00884655f, -0.03292258f, 0.02830342f, 
    -0.03890060f, 0.00439813f, -0.00503031f, 0.01954011f, -0.03455612f, 0.02482624f, 0.00163660f, 0.00170782f, 
    -0.01795032f, 0.01474892f, 0.03550595f, -0.02741832f, -0.02165088f, 0.01210254f, -0.03295080f, -0.02097272f, 
    0.01141741f, 0.02835613f, -0.01203032f, 0.01352099f, -0.02127562f, -0.02064345f, -0.02019652f, 0.01431717f, 
    -0.00893198f, 0.02828320f, 0.02955762f, 0.01483186f, 0.01209837f, -0.00169929f, -0.03900200f, -0.02177456f, 
    0.02942583f, 0.01852037f, 0.01272992f, -0.01645412f, -0.02639608f, -0.02359391f, -0.02638371f, -0.03528990f, 
    0.00346560f, -0.03248377f, -0.01242458f, -0.00932228f, 0.02299856f, 0.02092693f, -0.02603186f, -0.02237093f, 
    0.01617243f, -0.02875084f, -0.01141604f, -0.01042464f, 0.02493929f, 0.00290541f, -0.01022089f, -0.02064599f, 
    0.02843326f, -0.01086837f, -0.02045736f, 0.01777610f, 0.01591486f, 0.00130544f, 0.02061989f, -0.03165257f, 
    -0.02443856f, -0.01150811f, -0.01254895f, -0.03860630f, -0.01577234f, 0.03779779f, 0.00038274f, 0.00321628f, 
    0.02569250f, -0.01064431f, 0.02824947f, -0.01463602f, -0.00357907f, -0.02034502f, -0.02317138f, 0.01520938f, 
    -0.01917074f, -0.02681032f, -0.03677735f, -0.01430360f, 0.02527573f, 0.01115395f, -0.02582926f, 0.01311076f, 
    0.01218318f, 0.03443997f, -0.03245860f, 0.00821172f, -0.02380110f, -0.02258908f, -0.02014247f, -0.02082990f, 
    0.00355938f, -0.01288247f, 0.02583121f, -0.00243621f, 0.03591087f, -0.01766903f, 0.00209530f, -0.02356963f, 
    -0.04035923f, -0.03553132f, -0.00693382f, 0.02348412f, 0.02839610f, -0.03916264f, -0.01003715f, -0.02993052f, 
    -0.01641559f, 0.02347198f, 0.02544755f, -0.00352366f, -0.02796394f, 0.01207618f, -0.00363808f, 0.02834663f, 
    0.01692967f, 0.00276529f, 0.00416630f, -0.01172435f, -0.00769183f, 0.00269751f, 0.00025307f, 0.01491276f, 
    -0.03146106f, -0.00246166f, -0.00813943f, -0.03211085f, -0.00538353f, 0.03574181f, -0.03534937f, -0.00610299f, 
    -0.00116240f, -0.01303802f, -0.00288525f, 0.02296983f, -0.03063080f, 0.02079950f, -0.00352716f, -0.01673532f, 
    -0.00916940f, 0.02675337f, -0.00578401f, -0.02467133f, -0.03146460f, -0.01908235f, 0.02572698f, 0.01205123f, 
    -0.00652561f, 0.01822028f, -0.01640513f, -0.00829685f, 0.02187191f, -0.01540225f, -0.00996427f, 0.02675288f, 
    0.00918359f, 0.00440591f, 0.02996271f, -0.02221851f, -0.02087369f, 0.02722763f, -0.02699204f, 0.03436916f, 
    0.03880724f, -0.03692605f, 0.02713853f, -0.00966242f, -0.02228535f, 0.02306478f, -0.01049087f, -0.03076408f, 
    -0.03056908f, -0.02628517f, 0.00417138f, 0.02894196f, -0.01776009f, -0.02092150f, 0.02357754f, 0.01670954f, 
    0.00007088f, -0.03358195f, -0.03942143f, 0.01989551f, 0.01345663f, 0.01778611f, -0.03433228f, -0.00445838f, 
    -0.01168967f, -0.01891566f, -0.02901764f, 0.02527737f, 0.01293870f, -0.02735912f, -0.00042325f, 0.02126099f, 
    -0.03177308f, 0.00722334f, 0.00922288f, 0.02924160f, 0.00111051f, -0.00005471f, -0.00507050f, 0.02997505f, 
    0.03399943f, -0.02466294f, -0.00722807f, 0.02023936f, -0.02757613f, -0.02289733f, 0.00929354f, -0.00808577f, 
    0.01471508f, 0.00425575f, -0.02714674f, 0.03136023f, -0.03578864f, -0.00413642f, 0.00300703f, 0.00142956f, 
    0.02864587f, -0.03850136f, -0.00835949f, -0.02959274f, 0.03143122f, -0.00998791f, -0.01554382f, -0.01517037f, 
    -0.00940963f, -0.01480060f, 0.01391919f, -0.00191789f, 0.01258376f, -0.00216845f, -0.03029381f, 0.00374129f, 
    0.02526897f, 0.01461754f, -0.02235636f, 0.01709752f, 0.02427537f, -0.03336231f, -0.00795424f, -0.00821934f, 
    -0.01161909f, 0.00666101f, -0.02874406f, -0.01341034f, 0.00589969f, -0.03251497f, 0.01249184f, -0.00491340f, 
    -0.03079499f, 0.02374005f, -0.01787096f, -0.03900359f, -0.04052543f, 0.01855179f, -0.02449805f, -0.00781208f, 
    -0.01994206f, 0.01606234f, -0.00463084f, -0.03044756f, -0.00059913f, 0.02014587f, 0.01630440f, 0.02753172f, 
    -0.01392991f, 0.01035852f, -0.03687005f, -0.00593195f, 0.01916182f, -0.00316576f, -0.00581558f, 0.02949297f, 
    -0.02243096f, -0.01685918f, 0.00856359f, -0.03270756f, 0.00740631f, -0.02941993f, -0.00458070f, -0.01273522f, 
    -0.00315363f, -0.00297905f, 0.02198263f, 0.01320565f, 0.02002637f, -0.03793500f, 0.03369315f, 0.01712635f, 
    0.00067763f, 0.04022394f, 0.01827777f, -0.01416723f, -0.02240776f, -0.02865483f, 0.02376680f, 0.01486703f, 
    -0.02490749f, -0.00691955f, -0.00396874f, -0.01163283f, 0.02197193f, -0.00605285f, -0.03715984f, 0.01225564f, 
    0.02192044f, -0.04064209f, 0.00537852f, 0.00611115f, -0.00562052f, -0.02273626f, -0.03892893f, 0.02300372f, 
    0.02665158f, 0.00447642f, -0.00948010f, -0.01880669f, 0.00464189f, 0.03147300f, 0.00749894f, -0.02623012f, 
    -0.03015170f, -0.00246964f, 0.02187602f, -0.01248685f, 0.01223824f, 0.01478927f, -0.02781479f, 0.01259291f, 
    0.01337273f, 0.01965472f, -0.01729222f, -0.00166871f, -0.03414815f, -0.01356470f, -0.00095234f, -0.03541846f, 
    -0.00260927f, 0.02099441f, 0.00569142f, 0.00832474f, -0.02350846f, -0.02190631f, -0.04047276f, 0.02117436f, 
    -0.02963977f, -0.02460526f, 0.03869868f, 0.03893360f, 0.03521478f, -0.00062447f, 0.02613761f, 0.00860781f, 
    0.00497264f, -0.01177524f, 0.02767862f, -0.00623771f, -0.03575990f, 0.01617581f, 0.01544247f, -0.00979794f, 
    -0.04324194f, -0.00256173f, -0.03833387f, -0.00510700f, -0.02674578f, 0.00599291f, 0.00208850f, 0.01731749f, 
    -0.00480103f, -0.01322769f, -0.04023074f, 0.00390451f, -0.02509786f, -0.03532334f, 0.01199739f, 0.00850425f, 
    0.01727686f, 0.00852077f, 0.02709491f, -0.00695653f, 0.01314248f, -0.01623660f, -0.02375917f, 0.03815930f, 
    -0.03546260f, 0.01894239f, -0.00918115f, 0.02206640f, 0.02745270f, -0.00587825f, -0.01972164f, -0.01402323f, 
    -0.02436086f, 0.02357404f, -0.03133918f, -0.00715050f, -0.03780429f, -0.01775124f, -0.01074409f, 0.03688145f, 
    0.00924832f, 0.01992350f, 0.00713155f, -0.01721747f, -0.02875509f, 0.00121567f, -0.01050281f, 0.03113477f, 
    0.01140078f, 0.01808874f, -0.02447937f, -0.01137567f, 0.01760773f, 0.01047362f, 0.02957745f, 0.00690889f, 
    -0.02750674f, 0.00613739f, 0.00954968f, -0.02995436f, 0.01697280f, -0.00783408f, 0.00128377f, 0.02343590f, 
    0.02775763f, -0.03266212f, -0.02487277f, -0.03097108f, 0.01591344f, -0.02034061f, -0.00606441f, -0.00052096f, 
    0.03829317f, 0.00625606f, 0.03301888f, -0.03483830f, -0.01996425f, -0.02831693f, 0.03168763f, 0.01405711f, 
    0.01788640f, -0.01947870f, 0.02707102f, 0.03047944f, 0.03129437f, 0.03221760f, 0.00017410f, -0.03321948f, 
    -0.03818022f, -0.01533551f, 0.02459997f, -0.02791898f, -0.03810631f, -0.03913184f, -0.03914250f, -0.00965709f, 
    -0.02499636f, 0.04184011f, -0.02436838f, -0.03593440f, 0.00502091f, -0.01918443f, 0.01344477f, -0.00702027f, 
    -0.01467226f, -0.00719264f, 0.02523881f, -0.02469457f, -0.03790521f, 0.03502143f, -0.01628417f, 0.02753335f, 
    -0.01859160f, 0.00013780f, 0.01082853f, -0.00804701f, -0.00903379f, 0.00790603f, -0.03947981f, -0.03609203f, 
    0.02492132f, 0.00341950f, 0.02333685f, -0.01773456f, -0.04057596f, -0.00534408f, 0.00574459f, -0.01794660f, 
    -0.00149257f, -0.00477525f, 0.02795978f, 0.01709926f, -0.00167383f, -0.01247804f, -0.01602310f, 0.02133845f, 
    0.01078109f, -0.00068798f, -0.00866021f, 0.01577807f, 0.02394127f, 0.01148679f, 0.00293359f, 0.01986465f, 
    -0.04098830f, -0.01064892f, -0.01873555f, -0.00125426f, -0.01850254f, 0.01611540f, -0.00278683f, 0.01846869f, 
    -0.03408920f, -0.00044421f, -0.00745264f, -0.01719609f, 0.00960925f, -0.00555865f, -0.03955902f, -0.03170500f, 
    0.00815856f, 0.01777846f, -0.03766301f, -0.00109887f, -0.02479056f, -0.01157404f, -0.03612135f, -0.01465942f, 
    -0.02774285f, -0.02032102f, -0.01212965f, 0.00495521f, -0.03305969f, 0.01094225f, -0.00733052f, -0.01624599f, 
    -0.02445379f, 0.01203225f, -0.01766593f, 0.01844759f, 0.00338772f, -0.02571817f, -0.04183189f, 0.02630515f, 
    0.02049943f, 0.02782530f, -0.01911485f, 0.00365885f, 0.00299264f, 0.02670202f, -0.01254771f, 0.02283402f, 
    -0.00399700f, -0.02367319f, 0.00891524f, -0.04153226f, -0.02931630f, 0.00435015f, 0.00097297f, -0.03191983f, 
    -0.01264359f, 0.01494129f, -0.03832373f, 0.00258352f, -0.00608225f, 0.01750644f, -0.02356143f, 0.02523660f, 
    0.00333097f, -0.01567600f, -0.01973203f, -0.03950901f, -0.01179732f, -0.04021250f, -0.00937699f, -0.02120625f, 
    0.02111341f, 0.02439666f, 0.02941946f, 0.01664999f, 0.00077602f, -0.00537186f, 0.02591511f, 0.02735948f, 
    -0.01248248f, 0.01186193f, -0.01736956f, -0.00532040f, -0.01143642f, -0.01604922f, -0.02850617f, -0.02336683f, 
    0.01685963f, -0.01007375f, 0.02372433f, -0.02565054f, -0.00176605f, -0.02102276f, -0.03164203f, 0.00345567f, 
    -0.02186370f, 0.02460753f, 0.01847269f, 0.00329095f, -0.01077807f, 0.01974234f, -0.04130583f, 0.02574309f, 
    0.01548695f, -0.01533068f, -0.03523549f, 0.02765186f, -0.01879218f, -0.00030777f, 0.02514438f, -0.04027459f, 
    -0.02340360f, -0.02685297f, 0.03661676f, 0.03866535f, 0.03118891f, 0.01165608f, -0.01108759f, 0.02786707f, 
    0.02320776f, -0.01310512f, 0.02932834f, -0.04268423f, -0.01552905f, -0.02394335f, -0.04260240f, -0.00932415f, 
    0.01828698f, -0.00999023f, 0.02074548f, -0.01217640f, -0.00545949f, 0.01015848f, -0.00148408f, 0.02335976f, 
    0.01522880f, -0.01427037f, -0.00833712f, -0.02983649f, -0.01641785f, -0.02931348f, 0.02063166f, -0.00257340f, 
    -0.02239465f, 0.02599606f, -0.02478872f, 0.01352237f, -0.01710040f, 0.02122808f, -0.03891575f, -0.01749552f, 
    0.00113436f, -0.03788453f, -0.00000102f, 0.02666490f, -0.02513999f, 0.00041316f, -0.01946551f, -0.01800624f, 
    -0.04365527f, -0.02288976f, 0.01506606f, -0.03544242f, 0.01891079f, -0.03528218f, -0.00632036f, 0.03198894f, 
    -0.01670889f, -0.00860209f, -0.04297550f, 0.02460338f, 0.01388168f, 0.01036233f, 0.00264178f, -0.01775062f, 
    0.02175069f, 0.00577615f, -0.02799866f, 0.01064269f, -0.03316801f, -0.03870031f, -0.01245274f, 0.00203557f, 
    -0.02851714f, 0.01095324f, 0.00561975f, -0.02698860f, 0.03045294f, 0.02422154f, 0.02892503f, 0.01767263f, 
    -0.01276538f, 0.02495941f, 0.01476920f, -0.02055766f, -0.04012970f, 0.02542404f, -0.01835242f, -0.02987671f, 
    0.01230059f, -0.02341525f, -0.04132576f, 0.00549255f, 0.02497347f, -0.02826911f, -0.00109813f, -0.01071259f, 
    0.01633328f, -0.01382013f, 0.01696671f, 0.00455233f, -0.00697205f, -0.00935377f, -0.00679624f, -0.00133637f, 
    -0.01586862f, -0.00393440f, 0.01971411f, 0.02863145f, 0.00209200f, -0.00677458f, -0.00245995f, -0.02291956f, 
    0.02699327f, -0.03703953f, -0.01461502f, -0.01445927f, 0.01918900f, 0.00021588f, 0.00128932f, 0.01375516f, 
    -0.03663402f, -0.02785782f, -0.02118493f, -0.03908519f, -0.00732770f, 0.00943754f, -0.04077220f, -0.02587310f, 
    -0.04079227f, 0.01000199f, -0.02460440f, 0.00503177f, -0.02575622f, -0.01829198f, -0.00345865f, -0.00855413f, 
    -0.03341791f, 0.00174595f, -0.03471363f, -0.01551425f, -0.04238753f, -0.01055050f, 0.00295293f, 0.01794184f, 
    -0.03626661f, -0.00892396f, -0.01574418f, 0.00656739f, -0.03648981f, -0.01993018f, 0.01794481f, -0.02331300f, 
    0.03574223f, 0.00620583f, 0.02405828f, -0.02944547f, -0.02011387f, 0.03632094f, -0.03615517f, -0.02680646f, 
    -0.00614050f, 0.02475064f, -0.01840130f, -0.03041561f, -0.02319231f, -0.03089366f, -0.03965340f, 0.01462490f, 
    -0.01868562f, 0.02128788f, 0.00469412f, 0.01727215f, 0.01851617f, -0.02870387f, 0.02377257f, 0.00812879f, 
    -0.01079561f, -0.04359296f, 0.02683720f, 0.01456601f, 0.00300486f, -0.01703206f, -0.02476522f, -0.03738853f, 
    0.00999050f, 0.02807006f, -0.03454839f, -0.03753003f, 0.02632278f, 0.00953697f, -0.01461504f, 0.01992747f, 
    -0.01619491f, -0.01000323f, -0.00051297f, 0.00919837f, -0.03659071f, 0.01107415f, -0.03059623f, -0.03070711f, 
    0.03273727f, 0.02047693f, -0.01627710f, -0.01116948f, -0.02749101f, 0.00321230f, 0.01606780f, -0.02377925f, 
    0.00702763f, 0.01958002f, -0.02902219f, -0.03552216f, -0.03674917f, 0.02279786f, -0.02756024f, -0.01614556f, 
    -0.01817426f, -0.04054258f, -0.02530752f, 0.00521390f, 0.02025185f, -0.02661251f, 0.00149604f, 0.00017400f, 
    -0.01704126f, -0.01365008f, -0.00221088f, -0.00371923f, -0.01788831f, -0.03960497f, 0.02679090f, -0.04045275f, 
    0.00513863f, -0.01452903f, 0.02579539f, -0.00853654f, 0.00249267f, -0.01114563f, 0.02050614f, -0.03044900f, 
    -0.03630219f, -0.01036982f, -0.01440867f, -0.00313218f, 0.01182043f, -0.03249136f, -0.00561911f, 0.00949563f, 
    -0.03784362f, 0.02357185f, -0.02476311f, -0.02004474f, -0.00086663f, -0.00346874f, 0.01919999f, -0.02234116f, 
    -0.03077660f, -0.01520107f, -0.00662855f, -0.00818711f, 0.00468069f, 0.00792075f, -0.03840745f, -0.01890385f, 
    0.00814425f, -0.00264110f, 0.01508915f, 0.01131742f, 0.01942166f, 0.02497841f, 0.02826607f, 0.02412208f, 
    -0.01219727f, -0.03468836f, -0.03897160f, -0.03249850f, -0.01748928f, -0.02957464f, 0.00124323f, 0.02930417f, 
    -0.03569877f, -0.01444337f, -0.02144389f, -0.00556178f, 0.01377803f, -0.00640401f, 0.03191665f, -0.01038317f, 
    0.03032613f, -0.00343240f, -0.03356858f, -0.01325840f, 0.00619324f, 0.00567810f, 0.00480017f, 0.02161840f, 
    -0.00904504f, 0.00373107f, -0.00992013f, -0.04287989f, -0.03127936f, 0.03015493f, 0.02266195f, 0.02552859f, 
    -0.02328316f, -0.00957380f, -0.02944928f, -0.03390515f, 0.00281956f, -0.01935827f, 0.00376681f, -0.02373963f, 
    -0.03800684f, -0.00180542f, -0.04149678f, -0.01928926f, -0.02631655f, -0.03634131f, -0.00861421f, -0.00798785f, 
    0.01750133f, 0.01333438f, -0.01412255f, -0.00886865f, -0.03949788f, -0.00587048f, -0.01297630f, -0.03462391f, 
    -0.00345141f, -0.00527899f, -0.03098717f, 0.00836103f, 0.00964664f, 0.00871306f, 0.01548426f, -0.04179725f, 
    -0.02225641f, -0.02466211f, 0.01368316f, -0.01304724f, -0.03467306f, -0.04082029f, 0.01821507f, -0.00377359f, 
    -0.04237391f, -0.03467963f, 0.01287174f, 0.02275030f, -0.00479797f, 0.00494010f, -0.01788742f, 0.00676997f, 
    -0.01074498f, -0.02204924f, 0.01669380f, 0.00673724f, -0.01280560f, 0.00662285f, 0.02882406f, -0.03104857f, 
    0.02035435f, 0.01357274f, -0.03616894f, -0.03693386f, -0.03167611f, -0.00426943f, -0.02330541f, 0.03079513f, 
    0.02307711f, -0.01731661f, 0.01247839f, 0.00127700f, 0.01883788f, -0.02872162f, -0.01425425f, 0.02469807f, 
    0.02540436f, 0.01513129f, 0.02336691f, 0.01471447f, -0.00792778f, 0.02297336f, -0.02156256f, 0.01225782f, 
    0.00965876f, -0.03850966f, -0.01352010f, -0.01341012f, 0.00422924f, 0.02378010f, -0.02548920f, 0.02641496f, 
    0.01365036f, -0.04347074f, 0.01496546f, -0.00353676f, 0.01006695f, -0.02273916f, 0.00839104f, -0.03179176f, 
    -0.03213466f, -0.02627729f, 0.01174168f, -0.03660818f, -0.00188533f, -0.03395471f, -0.02682348f, -0.00305001f, 
    0.00307453f, 0.01489539f, -0.01973672f, 0.01288937f, 0.00880903f, -0.00268155f, 0.02452012f, -0.01157461f, 
    0.01337619f, -0.01247174f, -0.03936993f, -0.02762175f, -0.03478112f, 0.02441703f, -0.02192217f, -0.01160002f, 
    -0.00264268f, -0.03504290f, -0.02313082f, -0.01048419f, 0.02183655f, 0.01677196f, -0.03087726f, -0.01036400f, 
    -0.02909403f, -0.00537683f, 0.00492048f, 0.01105324f, -0.00057493f, -0.03683127f, 0.01598513f, -0.01803842f, 
    -0.02130952f, -0.02632255f, -0.02221250f, 0.02233631f, 0.02639730f, 0.00698953f, -0.02757861f, -0.01556266f, 
    0.02047209f, 0.02473789f, 0.02502386f, -0.02784495f, 0.00885030f, -0.01102895f, -0.02976181f, -0.04297428f, 
    -0.03897716f, -0.02236196f, -0.00096893f, -0.03428234f, -0.03643296f, -0.03365701f, 0.02371828f, -0.02476635f, 
    0.01395397f, -0.01525202f, -0.00890274f, 0.01350736f, 0.01733219f, -0.00461266f, 0.01657302f, -0.02466895f, 
    -0.01512345f, -0.00227299f, 0.01442931f, -0.00441214f, -0.02784664f, 0.02276178f, -0.01135942f, -0.02877589f, 
    0.00960913f, -0.00118016f, -0.04071577f, 0.00947052f, -0.00357784f, 0.02662075f, -0.03452571f, -0.00327727f, 
    -0.03642687f, -0.02176659f, -0.02657691f, 0.02335859f, -0.01945766f, -0.01686747f, 0.01307674f, 0.02883084f, 
    -0.01504017f, -0.04007806f, -0.02222059f, 0.00802963f, 0.00907163f, 0.00961289f, -0.03123652f, 0.02109647f, 
    -0.02087148f, 0.02743386f, 0.01500459f, 0.02606933f, -0.00152179f, -0.01045266f, -0.00382171f, -0.00566730f, 
    -0.01944419f, -0.02978382f, -0.00739417f, 0.00857157f, -0.01104934f, -0.01748278f, 0.00395318f, -0.02708505f, 
    0.00820911f, 0.02398967f, -0.01739105f, -0.00715940f, -0.02562453f, 0.02214104f, 0.02235573f, -0.03561652f, 
    -0.04319898f, -0.04330455f, -0.00280915f, -0.01950092f, 0.02379049f, 0.02848074f, 0.01938509f, 0.00691065f, 
    -0.04193781f, 0.03492042f, 0.00950141f, 0.02422396f, 0.01187852f, -0.03040782f, -0.01508627f, 0.01944015f, 
    -0.03915260f, 0.01627214f, -0.02324253f, -0.02953351f, 0.00073032f, -0.04031891f, 0.00302698f, -0.00620453f, 
    0.00782058f, -0.03491651f, -0.02545418f, 0.01029478f, -0.03069251f, -0.02520691f, 0.01594789f, -0.02925927f, 
    0.01253064f, -0.01706184f, 0.02184557f, 0.01118309f, -0.02053107f, -0.02797719f, -0.00755358f, -0.02926286f, 
    -0.00578129f, 0.00515797f, 0.00809384f, 0.02451674f, 0.04391402f, 0.01738437f, 0.01802934f, -0.01009149f, 
    0.00634756f, -0.01659756f, -0.03793366f, -0.03333670f, 0.00650915f, 0.02715150f, 0.01832313f, 0.00420015f, 
    -0.03589633f, -0.03593474f, -0.02213283f, 0.01794105f, 0.01880118f, -0.02879280f, 0.02364585f, 0.01995493f, 
    -0.02744863f, 0.00711396f, 0.02915727f, -0.00850534f, 0.00487770f, -0.00851979f, -0.01855226f, 0.02237732f, 
    -0.02108755f, -0.03529462f, 0.01206497f, -0.04110886f, 0.02502194f, -0.03054130f, 0.02601249f, -0.00361253f, 
    -0.03260269f, -0.00173775f, -0.04073061f, 0.01943035f, -0.03707697f, 0.01662399f, -0.03826269f, -0.03534793f, 
    -0.01693855f, 0.02220343f, 0.00071264f, 0.00969692f, 0.02233131f, -0.03413006f, -0.01620684f, -0.00908382f, 
    -0.02280880f, 0.01950941f, -0.03070761f, -0.00013938f, -0.04048591f, 0.02910745f, -0.00181951f, 0.02535438f, 
    0.00313697f, -0.07774045f, 0.01456153f, 0.02172763f, -0.02041137f, 0.02017182f, -0.01889169f, -0.03859863f, 
    0.11278290f, 0.03142733f, 0.02632752f, 0.09259522f, 0.00129053f, 0.05125863f, -0.01065687f, -0.08672517f, 
    0.00981289f, 0.08727913f, -0.06929149f, -0.06431285f, 0.05924451f, -0.08709563f, -0.09017894f, -0.06761103f, 
    0.30352068f, 0.00618225f, 0.20050992f, -0.10595887f, -0.04683230f, 0.06395789f, 0.03430783f, -0.05759794f, 
    -0.01949444f, -0.05508104f, 0.13394448f, -0.03025800f, 0.12583783f, -0.08060604f, -0.26332447f, 0.18528143f, 
    0.09199242f, 0.01799292f, 0.08518427f, 0.25361347f, 0.16182549f, -0.02755691f, 0.02995682f, -0.07395522f, 
    0.05743751f, 0.09545945f, 0.10524285f, 0.05936466f, 0.00954747f, 0.04549310f, -0.08992314f, 0.02765967f, 
    -0.11484516f, -0.08775434f, -0.00027624f, -0.31312042f, 0.04826496f, 0.19685316f, 0.11517265f, -0.01582629f, 
    0.00526856f, -0.00621624f, -0.00196632f, 0.09349710f, -0.03263376f, -0.15478934f, -0.15652026f, -0.01225270f, 
    0.08470982f, 0.08333468f, -0.17731975f, -0.16099899f, -0.00020178f, -0.00316010f, 0.15270285f, -0.04060096f, 
    -0.02356658f, 0.14070763f, -0.18669504f, 0.15911312f, 0.13506219f, 0.16909111f, -0.00450185f, -0.09132798f, 
    -0.15125504f, -0.07517451f, -0.09502954f, -0.08480908f, 0.05707869f, -0.07911000f, -0.00121296f, -0.03408104f, 
    0.05384553f, -0.00690539f, 0.15049410f, 0.13325058f, 0.11202708f, -0.03763977f, 0.14986850f, 0.02640859f, 
    0.05596785f, 0.03823232f, -0.02367971f, 0.12757222f, 0.00950787f, -0.16279763f, -0.00165856f, 0.07287537f, 
    -0.03355477f, -0.00738363f, -0.05373532f, 0.06875128f, 0.02122196f, 0.22426614f, -0.11017116f, -0.14518878f, 
    -0.22677666f, 0.25973076f, -0.11329586f, -0.07750695f, 0.03366607f, -0.09939468f, 0.04961949f, 0.09547276f, 
    0.19320866f, -0.03036598f, -0.06017092f, -0.12873478f, 0.20745035f, 0.12476495f, 0.04126656f, -0.08889747f, 
    0.00572902f, 0.09046755f, 0.09470124f, 0.10128675f, -0.11880582f, -0.05673319f, -0.01585679f, -0.09074882f, 
    0.06833772f, -0.11957593f, -0.13827839f, -0.16554286f, 0.10716063f, 0.05028556f, 0.04741995f, 0.09845550f, 
    0.10016717f, 0.00128381f, -0.08509371f, 0.00248209f, 0.32321140f, -0.36755729f, 0.23136422f, -0.21649112f, 
    -0.00529413f, 0.01037460f, 0.09906946f, -0.00190983f, 0.10045976f, 0.10235422f, -0.04544166f, 0.00380908f, 
    0.00152112f, 0.02240105f, 0.16893043f, -0.17373504f, -0.00277831f, 0.01390015f, -0.15435794f, -0.09530943f, 
    -0.11818584f, -0.12212881f, -0.10987943f, -0.09436078f, -0.07492743f, -0.11128142f, -0.09025659f, 0.02282863f, 
    0.07391594f, 0.05522651f, -0.01566992f, -0.20189191f, -0.12863840f, -0.10584930f, 0.28934813f, 0.15519951f, 
    0.00458135f, 0.05649748f, -0.24331005f, -0.09199942f, -0.01387777f, 0.04741602f, -0.20471695f, -0.12266376f, 
    0.02909621f, -0.15276691f, -0.14674985f, -0.14748593f, -0.09893076f, 0.07258378f, 0.06213456f, 0.14078110f, 
    0.04164814f, 0.01155731f, 0.01835568f, 0.00608604f, -0.05096441f, -0.08340393f, -0.07990362f, -0.06800910f, 
    0.18601210f, -0.01023319f, 0.09033076f, 0.15943125f, -0.05837940f, -0.04656893f, 0.02208938f, -0.14016910f, 
    -0.00001668f, 0.08524287f, 0.13024448f, 0.13603209f, -0.15152130f, 0.01291475f, -0.42848799f, -0.00898536f, 
    0.01490145f, -0.01828884f, -0.01339865f, 0.03823283f, 0.02566701f, 0.00734395f, 0.02832063f, 0.03185875f, 
    -0.04401502f, 0.13179487f, -0.08803717f, -0.06751923f, 0.03438820f, 0.01191532f, 0.01694708f, 0.16901015f, 
    -0.01352584f, -0.05796775f, -0.08251502f, -0.09836783f, -0.12955664f, 0.12687589f, -0.24722093f, 0.02542971f, 
    0.07193348f, 0.05944970f, 0.04627957f, 0.02655908f, 0.00859517f, 0.02655801f, -0.00199442f, 0.19706962f, 
    -0.22664040f, -0.06334256f, -0.02268827f, 0.07557295f, 0.08004758f, 0.12902047f, -0.07711983f, -0.06091880f, 
    0.03541274f, -0.06260635f, 0.00634707f, -0.01770001f, 0.05457327f, 0.43283558f, 0.11137576f, 0.34414339f, 
    -0.03006349f, 0.04357931f, -0.09325358f, -0.05970130f, 0.13222632f, -0.06144842f, 0.14701898f, 0.07846518f, 
    -0.07104340f, 0.30397579f, -0.43827060f, -0.12549657f, 0.11705411f, -0.06441247f, -0.06734634f, -0.02506625f, 
    0.09271216f, -0.05299078f, 0.02485955f, 0.04937769f, 0.01911519f, -0.03953509f, -0.00374105f, 0.00921355f, 
    -0.09716773f, 0.04138731f, -0.03085442f, 0.07283449f, 0.02449067f, -0.04763261f, -0.04885509f, 0.01139545f, 
    0.12776843f, -0.02321902f, -0.16961254f, -0.01541386f, 0.00396939f, 0.06112980f, -0.06565517f, -0.00397313f, 
    -0.08145325f, 0.05428106f, 0.00634053f, -0.03610421f, 0.13736464f, 0.10722483f, 0.13196927f, 0.04647085f, 
    0.12557420f, -0.01443027f, -0.01296180f, -0.06416050f, 0.02586139f, 0.14345327f, 0.07260255f, 0.09216120f, 
    0.14648020f, -0.24093626f, -0.00500130f, -0.08747751f, -0.02150239f, 0.02117850f, -0.20034562f, -0.16299534f, 
    0.27601665f, 0.17544717f, 0.08835448f, 0.23249356f, -0.17903815f, -0.07637210f, -0.02308180f, 0.03822315f, 
    -0.02534411f, 0.09804124f, 0.05555366f, 0.00989682f, 0.02626280f, -0.02148851f, 0.01286626f, 0.09141478f, 
    0.00458352f, -0.03186135f, -0.08035804f, 0.02031201f, -0.02412241f, 0.13612987f, -0.01277635f, 0.07854714f, 
    -0.05051056f, -0.11425378f, 0.07000863f, -0.13268174f, -0.04729430f, 0.04401349f, -0.01864214f, -0.01137464f, 
    0.15193523f, -0.11963459f, 0.06837157f, 0.10074318f, 0.16157778f, 0.03628322f, -0.00149474f, -0.13017702f, 
    0.29879609f, 0.09039055f, 0.11702713f, 0.23842219f, -0.00424556f, 0.00752069f, 0.03886382f, -0.02739808f, 
    -0.03173011f, -0.00978767f, 0.04102210f, 0.00622104f, -0.10227747f, -0.09022766f, 0.01316294f, 0.02246376f, 
    0.03049085f, 0.03089155f, -0.00219377f, 0.04466351f, 0.01873270f, 0.06427406f, 0.03409281f, 0.05644978f, 
    -0.11169861f, -0.14249484f, 0.04995415f, 0.08031293f, -0.01828760f, 0.02069206f, -0.02779794f, -0.04760104f, 
    0.13122757f, 0.13601343f, 0.09525409f, 0.11734239f, 0.12149274f, 0.03550348f, -0.11345296f, -0.05587954f, 
    -0.08513354f, -0.03431724f, 0.16143787f, 0.07343797f, 0.08971822f, -0.10164081f, -0.02298738f, 0.02795718f, 
    -0.08763497f, 0.13255280f, 0.15652047f, 0.06625293f, 0.05613746f, -0.05120392f, -0.01412851f, 0.01523951f, 
    -0.03165303f, -0.13872316f, -0.10827199f, -0.11233754f, 0.13475581f, 0.01244363f, 0.07164745f, -0.05951721f, 
    -0.00765857f, -0.08801094f, -0.06328992f, 0.02411174f, 0.07245995f, -0.03165417f, -0.12313133f, 0.10188918f, 
    -0.10784513f, 0.20829807f, 0.06484343f, -0.09896234f, 0.12184265f, -0.06636510f, -0.01043918f, -0.04265825f, 
    -0.07864694f, 0.09203318f, -0.00575723f, 0.05342415f, -0.15793972f, -0.07846352f, 0.13825741f, 0.05365262f, 
    0.03369632f, -0.03237564f, 0.01420571f, -0.00012948f, -0.00647009f, 0.00328321f, -0.04259779f, 0.17087755f, 
    -0.20999493f, -0.11354119f, -0.02033909f, 0.10636079f, -0.00752763f, 0.02658197f, -0.02761478f, 0.00011085f, 
    0.17901446f, 0.06333817f, -0.08348579f, 0.07175672f, -0.35162368f, 0.22799277f, 0.24280639f, 0.15012482f, 
    -0.00348737f, -0.06534898f, -0.02461160f, 0.09832785f, 0.12015153f, 0.05785230f, 0.17131883f, 0.14719826f, 
    0.27150989f, -0.13199769f, -0.06232975f, 0.05680761f, 0.01650695f, 0.14358965f, -0.00060403f, -0.13364643f, 
    0.02444390f, -0.11362882f, 0.15323156f, 0.11246370f, 0.47144386f, 0.14502959f, 0.18443215f, 0.17919537f, 
    0.05441196f, -0.02581497f, 0.01160100f, -0.11582773f, -0.07906058f, 0.00908955f, 0.12509596f, 0.05024948f, 
    0.06269986f, 0.05111526f, 0.10208292f, 0.11319864f, -0.11860020f, 0.04408121f, 0.07655555f, 0.03942356f, 
    -0.15126982f, -0.05846713f, -0.04447112f, 0.10824665f, 0.16195145f, 0.01542183f, 0.15006897f, -0.26579031f, 
    -0.07609243f, 0.06232920f, 0.00266266f, 0.07575824f, 0.08877342f, 0.04967764f, 0.12138701f, 0.18083283f, 
    0.00718811f, 0.15106955f, 0.07989062f, -0.02527736f, -0.03982007f, -0.00962669f, 0.10012628f, 0.09324370f, 
    0.11596847f, -0.05383148f, 0.02394746f, 0.06792770f, 0.03827482f, -0.07483238f, -0.19537894f, -0.25743777f, 
    0.01169313f, -0.03969383f, 0.01532276f, 0.01254858f, 0.03137537f, 0.01535278f, 0.06976403f, 0.01572263f, 
    0.08317982f, 0.00755627f, 0.20498472f, 0.07839835f, -0.07028411f, -0.02711498f, -0.06533098f, 0.02315939f, 
    -0.07572255f, -0.12231782f, -0.04396646f, -0.07366417f, 0.07856277f, -0.01424889f, 0.26020840f, -0.04879134f, 
    0.03306736f, 0.01303826f, 0.01616004f, 0.09070214f, -0.02726135f, 0.13073885f, 0.08182018f, -0.16366793f, 
    -0.07293944f, 0.17089677f, 0.08258573f, 0.18352078f, -0.01295496f, 0.08183445f, 0.03287590f, -0.05686931f, 
    -0.01287646f, -0.12840588f, -0.07991356f, -0.18450782f, 0.11209305f, -0.08471406f, 0.14703679f, 0.06044156f, 
    0.01753038f, -0.04598555f, -0.09589788f, -0.02117698f, 0.07340466f, 0.07589158f, 0.16304748f, 0.18995002f, 
    -0.00709520f, -0.04838341f, -0.02730836f, 0.02206780f, -0.03361623f, 0.00360041f, -0.01280019f, 0.11328503f, 
    -0.12915434f, 0.00229088f, -0.04893845f, 0.01535631f, 0.18581527f, 0.28964394f, 0.12159536f, 0.04327785f, 
    -0.07617124f, 0.04188222f, 0.00645648f, 0.09476489f, -0.06465508f, -0.09189684f, -0.13833587f, -0.05424849f, 
    0.14423491f, -0.10779686f, -0.11821639f, 0.02147272f, 0.05347190f, 0.05353700f, -0.05960169f, 0.03725559f, 
    -0.02119760f, 0.11660290f, 0.02252141f, 0.10223059f, 0.07798026f, -0.16317338f, -0.02375157f, -0.08196132f, 
    -0.01744816f, 0.10676449f, 0.10805724f, 0.05523393f, -0.07418703f, -0.00946412f, -0.11232176f, -0.03216346f, 
    0.04398188f, -0.08623030f, 0.12882146f, -0.02933015f, 0.06760430f, -0.17383809f, 0.04918415f, -0.20066221f, 
    0.02836018f, 0.05504977f, 0.03135581f, 0.15854289f, 0.00382151f, -0.04241077f, 0.02297502f, -0.07966042f, 
    0.01911045f, -0.03255605f, -0.02224476f, 0.06616192f, -0.05126113f, 0.02992688f, 0.13925412f, 0.11096396f, 
    -0.00371944f, 0.20563900f, -0.32644919f, 0.02891038f, 0.16194840f, -0.03178112f, 0.05970956f, 0.02170786f, 
    -0.06101836f, 0.04934249f, -0.06641804f, -0.06800030f, 0.14332730f, -0.35856026f, 0.01187559f, -0.22207491f, 
    0.05271365f, -0.10513205f, 0.01782491f, 0.02417499f, 0.06585007f, -0.11856783f, -0.00390934f, -0.01284565f, 
    0.15970439f, 0.16975667f, 0.20767246f, 0.16339903f, -0.09869599f, -0.00649274f, -0.04286522f, -0.01260606f, 
    -0.01272848f, -0.11096057f, 0.00182950f, -0.11832852f, 0.05105849f, 0.16587815f, -0.13619477f, 0.10035285f, 
    0.04004601f, 0.10688836f, 0.03765332f, 0.10853177f, -0.05086394f, -0.01514385f, -0.04445106f, -0.10169046f, 
    0.01177539f, 0.04786036f, 0.02481781f, -0.03139893f, -0.01977320f, 0.02351383f, 0.07294285f, 0.09171874f, 
    0.02476048f, -0.05417077f, -0.12717497f, -0.11846367f, 0.15187006f, 0.26258573f, 0.10603728f, -0.12634173f, 
    0.00879237f, -0.09376416f, 0.02671467f, 0.08396858f, 0.21336815f, 0.05926600f, 0.01255953f, -0.00240068f, 
    0.02322197f, 0.01632294f, -0.02291404f, 0.00815899f, 0.01483368f, -0.02710466f, -0.03231294f, -0.03638848f, 
    0.00301367f, -0.00896005f, -0.04136584f, 0.02594388f, 0.01977810f, -0.01742968f, -0.03872734f, -0.03435490f, 
    -0.02591942f, 0.01151001f, -0.02000737f, -0.00686391f, -0.02924349f, -0.03599618f, 0.00373200f, 0.02448075f, 
    -0.02466601f, -0.03102161f, 0.03577155f, -0.01708611f, -0.01518233f, 0.02063477f, 0.02062972f, -0.00338495f, 
    0.00013218f, -0.00264834f, -0.00294507f, 0.01276316f, -0.03221929f, -0.01980669f, -0.03831162f, -0.04004876f, 
    0.00365688f, 0.01630590f, 0.01034577f, 0.02147219f, 0.02383060f, -0.00589855f, -0.03388068f, 0.02596920f, 
    0.01939404f, 0.02535862f, 0.01166642f, -0.02379521f, -0.00746988f, -0.01843011f, -0.00704315f, -0.02180600f, 
    -0.00903189f, -0.03086330f, -0.00416033f, -0.00943287f, 0.02520029f, 0.00185490f, -0.00388166f, 0.01031941f, 
    0.01455088f, 0.01948316f, 0.00386184f, -0.00062169f, -0.01113045f, -0.00225702f, 0.00768650f, -0.00040085f, 
    -0.01139005f, 0.00027059f, -0.03586933f, 0.01488193f, -0.04070630f, -0.01699187f, 0.00081357f, -0.00258865f, 
    0.01272501f, 0.02564577f, 0.00001669f, -0.03279539f, 0.01855718f, 0.02311306f, 0.02399058f, 0.00402875f, 
    -0.03464134f, 0.00859094f, 0.00976728f, 0.00227252f, 0.01857202f, -0.01440805f, -0.02308065f, -0.02293020f, 
    -0.04057520f, -0.02260706f, -0.03279214f, -0.00649502f, 0.02236144f, 0.01590363f, -0.00137050f, -0.02454107f, 
    -0.03465533f, -0.04224846f, -0.00391647f, -0.00459502f, 0.00536563f, 0.02135953f, -0.03026721f, -0.00240291f, 
    0.01132017f, -0.01097665f, 0.00055749f, -0.02407253f, 0.02855219f, -0.00768075f, -0.04030128f, 0.00900528f, 
    0.00885085f, -0.03562407f, -0.03137986f, -0.00052396f, -0.03325065f, -0.00069601f, 0.01863996f, 0.01130008f, 
    -0.02887377f, 0.02242714f, -0.00611997f, -0.01944851f, -0.00549168f, -0.02232373f, 0.01335166f, -0.00355907f, 
    -0.03200682f, -0.01217465f, 0.02705925f, -0.01123681f, -0.01279577f, 0.02336187f, -0.02392901f, 0.02084153f, 
    -0.00092015f, -0.03530245f, 0.00226672f, 0.02841430f, 0.00724397f, -0.00095177f, -0.01646952f, 0.00097450f, 
    -0.01375384f, 0.00889006f, 0.02415763f, -0.03826349f, -0.02842322f, -0.01334334f, -0.00527244f, -0.02813922f, 
    0.02050589f, -0.03330096f, 0.02612930f, -0.03044996f, -0.03779607f, 0.00291991f, -0.01102785f, -0.04077071f, 
    -0.00061382f, -0.00288332f, 0.00178522f, -0.02678540f, -0.04185865f, -0.01467655f, -0.00581998f, 0.01033936f, 
    -0.00396660f, 0.00746759f, 0.00479090f, 0.02742464f, 0.01430803f, -0.02018099f, -0.03257899f, -0.00402985f, 
    -0.01735137f, -0.00028524f, -0.02359565f, -0.00985234f, 0.01644929f, 0.00086771f, -0.00828816f, -0.03443422f, 
    -0.03991875f, -0.01446484f, -0.02474629f, 0.00276169f, -0.01062397f, 0.00909809f, -0.03340170f, -0.03789968f, 
    0.00110713f, 0.01495660f, 0.02158121f, -0.01961889f, -0.00221326f, -0.02483472f, -0.01278052f, -0.00671482f, 
    0.02078150f, -0.01482025f, -0.02206955f, -0.01255292f, -0.00535823f, -0.02314105f, 0.00855199f, 0.00478809f, 
    -0.02943911f, -0.04130294f, -0.00750010f, -0.02800189f, 0.00273395f, -0.04314776f, -0.02637010f, 0.02524663f, 
    0.01722568f, -0.00161605f, -0.00870668f, -0.02986865f, -0.01788234f, -0.02996389f, 0.00155751f, 0.00190680f, 
    0.02386572f, -0.02672497f, -0.03682493f, 0.01334531f, -0.04142433f, -0.03804806f, 0.02265869f, -0.03971102f, 
    -0.02217635f, -0.02595677f, -0.04231460f, -0.00356602f, 0.01270159f, -0.00915918f, 0.00513155f, 0.01019702f, 
    -0.00835717f, 0.01886334f, 0.02437211f, -0.01199551f, 0.00390334f, -0.00617497f, -0.02866033f, 0.02580786f, 
    0.00183951f, -0.03937662f, -0.00582978f, -0.01452556f, -0.00705855f, 0.01813488f, 0.01076933f, -0.01218321f, 
    -0.01787071f, 0.01479420f, -0.01140374f, 0.02120518f, 0.02552400f, 0.00854413f, 0.01517076f, -0.03436808f, 
    -0.01342209f, -0.02792403f, 0.02564577f, -0.00042453f, -0.01734655f, -0.00901704f, -0.02103845f, 0.02482071f, 
    0.00095821f, -0.01563494f, -0.03852492f, 0.01670563f, 0.02174523f, -0.02451430f, -0.01833187f, 0.00100686f, 
    -0.00843838f, -0.02177147f, -0.00097036f, 0.00715778f, -0.04255951f, 0.02590844f, 0.00597184f, -0.02608462f, 
    0.02616282f, 0.01166709f, 0.00465024f, 0.00615779f, -0.02586803f, 0.00621129f, 0.00040716f, -0.04094077f, 
    -0.01197116f, -0.01988698f, -0.02560234f, 0.00677465f, -0.01431805f, -0.02454085f, 0.00691805f, -0.00483383f, 
    -0.00664853f, 0.00022795f, 0.00045653f, -0.00364643f, -0.04192540f, -0.01497197f, -0.01177696f, 0.02067054f, 
    -0.01995428f, -0.03928820f, -0.01112404f, -0.02134335f, -0.04091036f, -0.04254417f, -0.02405868f, 0.01393362f, 
    0.00299502f, 0.01152258f, 0.00955216f, -0.01850267f, 0.00265627f, 0.00808127f, 0.01693797f, -0.04239043f, 
    -0.00604826f, -0.02599804f, -0.02915186f, 0.00818664f, -0.01921065f, 0.00168957f, -0.03212807f, -0.00413629f, 
    -0.00930469f, 0.01429050f, -0.03091078f, -0.00646537f, -0.01663790f, -0.01687361f, 0.02602338f, -0.02358102f, 
    0.00393454f, -0.01702298f, -0.04272952f, 0.01366670f, 0.01388409f, -0.00813263f, 0.00587583f, 0.00072078f, 
    0.01116859f, -0.02815186f, -0.03396519f, 0.00880938f, -0.01681250f, -0.03589243f, 0.01647728f, -0.03917561f, 
    -0.03265489f, -0.01640346f, -0.00561643f, 0.01391099f, 0.00999380f, -0.03209462f, -0.03268147f, 0.00125070f, 
    0.00270818f, 0.01305526f, -0.04282715f, -0.02391048f, 0.01662703f, -0.01717474f, 0.01469387f, 0.00662838f, 
    0.01761122f, 0.02846521f, 0.00150648f, 0.02765772f, 0.00842551f, 0.00504463f, -0.00768800f, -0.04325315f, 
    -0.02389766f, 0.00560354f, -0.04199163f, 0.01040601f, -0.04093670f, -0.02183206f, -0.01411080f, 0.01537675f, 
    -0.01634541f, 0.00718908f, 0.02698927f, -0.03261437f, -0.00094282f, -0.02424631f, -0.02959206f, -0.03997498f, 
    -0.01524496f, 0.00204564f, -0.02290684f, -0.00811850f, 0.01425046f, -0.02481165f, -0.02485905f, 0.01339500f, 
    -0.00338897f, 0.00905901f, -0.01618589f, 0.01364294f, -0.00432420f, -0.01001557f, -0.00495958f, 0.01353797f, 
    0.00237542f, 0.00339262f, 0.02488246f, 0.01392623f, 0.01722590f, 0.01238751f, 0.01343180f, 0.01493167f, 
    -0.00392065f, -0.00359370f, -0.00940922f, 0.00062981f, 0.00160464f, -0.03025348f, -0.00497082f, -0.02872971f, 
    0.02193698f, -0.02159329f, 0.02977395f, -0.01455194f, 0.00860954f, 0.01119651f, -0.00306491f, 0.00934823f, 
    -0.01864262f, -0.01389013f, 0.01346254f, -0.04225742f, -0.03782929f, 0.01473971f, -0.04333790f, -0.00377401f, 
    0.01225680f, -0.03449126f, -0.03158700f, 0.01615922f, 0.02768905f, -0.01537701f, -0.02831092f, -0.00484055f, 
    -0.01616884f, -0.02563855f, -0.00324953f, -0.02801028f, 0.00790448f, -0.01690087f, 0.01263628f, -0.02071862f, 
    -0.00836659f, -0.00295257f, -0.01830955f, -0.01113695f, -0.01069060f, -0.01492725f, 0.00277186f, -0.00200625f, 
    -0.00893839f, -0.03325654f, 0.00648282f, -0.00095405f, -0.01117418f, -0.03584896f, 0.01547771f, -0.01400024f, 
    -0.03588410f, -0.02802526f, -0.00202332f, -0.00719028f, -0.03591221f, 0.00100489f, -0.03997827f, -0.03137421f, 
    -0.00381424f, -0.04290140f, -0.03642226f, -0.03441675f, 0.00857050f, -0.03896968f, -0.03684034f, 0.00065894f, 
    -0.03666900f, -0.02340362f, 0.00160350f, -0.00183117f, -0.04169603f, 0.00691329f, -0.01314396f, -0.01697928f, 
    -0.02642018f, -0.03315606f, -0.01160571f, -0.02275961f, -0.02530984f, -0.01181418f, -0.02329128f, -0.00860547f, 
    0.02539138f, 0.01051378f, 0.01023596f, 0.02697485f, 0.01200996f, -0.00390506f, 0.02064042f, 0.01457875f, 
    0.00207934f, -0.02546248f, 0.00147762f, -0.03522002f, -0.00829308f, -0.01755434f, -0.02790728f, -0.03893817f, 
    -0.01979660f, 0.00527909f, -0.01735455f, 0.00497245f, 0.01988482f, 0.02098709f, 0.01985682f, 0.02333911f, 
    0.02532496f, 0.01122974f, -0.02506214f, -0.03654175f, -0.00638815f, 0.01931824f, 0.01483766f, -0.01359901f, 
    0.00738320f, -0.02233185f, -0.02988634f, 0.01967633f, 0.01091752f, 0.02475643f, -0.02560710f, 0.02749040f, 
    -0.01771902f, 0.00740763f, 0.00918445f, 0.02447002f, 0.01927947f, -0.04298824f, -0.03079225f, -0.02497395f, 
    -0.00275634f, 0.01376127f, 0.00164952f, -0.03267087f, -0.03754034f, -0.00897340f, 0.01510544f, 0.00823095f, 
    -0.03752445f, 0.02909154f, -0.01647581f, -0.01824418f, -0.02795160f, -0.04073473f, 0.01966328f, 0.00794151f, 
    0.00533567f, 0.01693035f, -0.04265285f, -0.02660450f, -0.00393365f, 0.02026017f, 0.00387429f, 0.01101885f, 
    -0.04097763f, 0.00121883f, 0.01565424f, -0.03874256f, 0.02759288f, 0.01200096f, -0.03046785f, 0.00380842f, 
    -0.04229102f, -0.01699462f, 0.01379160f, 0.01830147f, 0.02243700f, 0.00683099f, -0.00687697f, 0.00785086f, 
    0.02005222f, 0.01614223f, 0.01353514f, 0.01966378f, 0.02579354f, -0.02214985f, -0.02226444f, 0.00503459f, 
    0.01354948f, -0.00332255f, -0.02582538f, -0.02044301f, -0.02550341f, -0.04326118f, -0.03761447f, 0.02555137f, 
    -0.00332193f, -0.00613215f, -0.00310751f, 0.00655727f, -0.01299287f, 0.00695971f, 0.00879492f, 0.02250839f, 
    -0.02879965f, -0.02686114f, -0.01483447f, 0.01935072f, -0.00150341f, 0.01158185f, 0.01356405f, -0.03287574f, 
    -0.03411870f, -0.02289124f, -0.00821052f, -0.02346783f, -0.00610990f, -0.04112688f, 0.01143680f, -0.01594779f, 
    -0.03943750f, -0.03733300f, -0.01174614f, -0.03175973f, -0.02283281f, -0.02135508f, -0.04025281f, -0.01549646f, 
    -0.00172321f, -0.00146060f, -0.00626142f, 0.02045568f, -0.01850930f, -0.01571067f, -0.00901834f, 0.00092281f, 
    -0.03791798f, -0.02884906f, -0.03327548f, -0.02656323f, -0.03503869f, 0.02017061f, 0.01688332f, -0.01856444f, 
    -0.03333160f, -0.01851934f, -0.01217953f, -0.00716700f, -0.02586167f, -0.03364623f, 0.02564854f, -0.02389904f, 
    -0.00994626f, -0.02613328f, -0.04428219f, 0.00922983f, -0.03336915f, 0.00752346f, 0.02594198f, -0.03636063f, 
    0.02707623f, -0.00897847f, -0.01412931f, 0.00735011f, -0.01918975f, -0.01228099f, 0.00278679f, -0.02650193f, 
    0.02855362f, 0.00098690f, -0.02106242f, -0.02498496f, -0.00360196f, -0.03705877f, -0.03821263f, 0.00617836f, 
    -0.03259098f, -0.01894169f, -0.02146692f, 0.02589643f, 0.00789546f, -0.03007051f, 0.01181379f, -0.00003002f, 
    0.00034125f, -0.03799849f, -0.03390762f, -0.01746477f, 0.00703733f, -0.00756121f, -0.02959829f, -0.00307399f, 
    0.02045830f, 0.02359948f, -0.02106019f, -0.02488706f, 0.00523813f, 0.02264784f, -0.03914525f, 0.01907053f, 
    -0.01383672f, 0.00478620f, -0.02521221f, -0.02755854f, 0.01077151f, -0.03910701f, 0.00701010f, 0.02742559f, 
    -0.00987476f, -0.00208791f, -0.01782630f, 0.01872134f, -0.00946182f, -0.01553457f, -0.00655687f, -0.02760407f, 
    -0.03927943f, -0.03602649f, -0.00030151f, 0.02825305f, -0.01968972f, -0.00060536f, 0.00374150f, -0.00774884f, 
    0.00846611f, -0.00358573f, 0.01125376f, 0.00610249f, 0.00196981f, -0.02787052f, 0.01449078f, 0.02061133f, 
    0.00361790f, 0.00727601f, -0.02795140f, 0.01977825f, 0.01183278f, -0.00072045f, 0.01505501f, 0.00317307f, 
    -0.03790161f, 0.00239780f, 0.00972634f, 0.00452179f, -0.03578410f, -0.01717426f, -0.00464977f, -0.03647229f, 
    -0.00575031f, -0.00328167f, -0.02067163f, -0.00665026f, -0.01971646f, -0.02763579f, -0.04080721f, -0.00674167f, 
    -0.03255989f, -0.03782891f, -0.02232055f, 0.02350935f, -0.03770266f, 0.01557725f, 0.01448394f, 0.00762808f, 
    -0.01267284f, -0.01147319f, -0.03651880f, 0.02741471f, -0.00402645f, -0.01336130f, 0.02849993f, 0.02536842f, 
    -0.02428911f, -0.00382348f, 0.02356976f, -0.03509530f, 0.01356317f, -0.01182714f, 0.01193143f, 0.02871978f, 
    -0.01061321f, -0.02197076f, 0.02201498f, 0.02608416f, 0.02782004f, -0.00942488f, 0.00221756f, -0.02719633f, 
    -0.01092601f, 0.00669571f, 0.01029158f, -0.03850181f, 0.00346520f, -0.04163229f, 0.02335569f, -0.00198403f, 
    -0.01063157f, 0.01698011f, -0.00746632f, -0.00470771f, 0.02406432f, -0.00090039f, 0.02908913f, -0.02387980f, 
    -0.01826657f, 0.03001010f, 0.00077411f, -0.03861173f, -0.01866177f, 0.01399615f, -0.03552466f, -0.01829877f, 
    -0.02055734f, -0.00415807f, -0.02189227f, -0.03983603f, -0.03097097f, -0.03784665f, -0.01659410f, 0.00371565f, 
    -0.03737879f, -0.01985370f, -0.01294613f, 0.00009630f, -0.02697172f, -0.02137012f, -0.00808086f, 0.02433145f, 
    0.01675749f, -0.02432051f, 0.01049775f, 0.02543911f, -0.03419744f, -0.01729293f, -0.04085076f, -0.02078053f, 
    -0.03935195f, 0.01355883f, 0.02721642f, 0.00435366f, 0.00042264f, 0.01022418f, 0.02924648f, 0.00289301f, 
    -0.00952022f, 0.01535358f, -0.03648432f, -0.03712074f, 0.00982758f, 0.00984066f, 0.00597081f, -0.01508793f, 
    0.01783594f, -0.00611354f, -0.03139641f, 0.01435169f, -0.02024161f, -0.03163747f, 0.01025874f, 0.02287091f, 
    0.00110999f, -0.04018163f, 0.02240182f, 0.01706846f, -0.01801038f, -0.03967901f, 0.01665884f, -0.02912340f, 
    -0.00926811f, -0.02382752f, 0.01893406f, 0.00441075f, -0.03985529f, -0.01205079f, -0.02172813f, -0.03247629f, 
    0.01923193f, 0.01658685f, 0.01340909f, -0.00257877f, 0.02600145f, 0.02942500f, 0.00565280f, 0.03007611f, 
    -0.01230290f, -0.01975855f, -0.03497321f, -0.04206362f, 0.00639379f, 0.01121883f, -0.03058863f, -0.03896657f, 
    -0.02028846f, 0.00990334f, 0.00911857f, -0.00588564f, 0.00916445f, -0.01918419f, 0.02110466f, 0.00196533f, 
    0.00191154f, -0.01138831f, -0.00075043f, 0.00422045f, 0.01901054f, -0.02540557f, 0.02595239f, 0.00411462f, 
    -0.00980950f, -0.03438161f, -0.02398147f, 0.01616760f, -0.03553637f, -0.00894637f, 0.02376510f, 0.01485148f, 
    -0.04199842f, 0.00751863f, -0.03062274f, -0.02398562f, -0.01874075f, -0.01315713f, -0.02823784f, 0.01982153f, 
    -0.02279662f, 0.00388341f, 0.00242760f, 0.01562219f, -0.03586985f, 0.02941899f, -0.03512967f, 0.01972157f, 
    0.00854079f, -0.03832320f, 0.00587048f, 0.02227740f, -0.01572585f, -0.01454795f, 0.00192575f, 0.02062201f, 
    0.01865672f, -0.00470240f, -0.04123272f, -0.03716643f, -0.03887659f, -0.03139820f, 0.01960418f, -0.03220035f, 
    -0.00307548f, -0.03415144f, -0.03835374f, -0.03680457f, 0.02607052f, 0.00355128f, -0.02230839f, 0.02021981f, 
    -0.03488936f, 0.01522378f, -0.02834482f, 0.01997155f, 0.01604452f, -0.02840791f, -0.01567926f, 0.01681993f, 
    0.02426604f, -0.01205867f, -0.00899431f, -0.02152203f, -0.03910932f, -0.02173430f, 0.02151200f, -0.02977811f, 
    -0.00854224f, 0.00134671f, -0.03418445f, -0.04035273f, 0.00839455f, -0.02117902f, -0.04071791f, -0.00857545f, 
    -0.02499232f, -0.02633617f, -0.02743015f, 0.01978524f, 0.01818766f, 0.00809567f, -0.03525534f, -0.02870084f, 
    -0.02378568f, -0.03023583f, 0.00790759f, -0.03913935f, -0.02846419f, 0.02060246f, 0.00175681f, -0.00146308f, 
    0.00732806f, -0.00423812f, -0.00108065f, -0.03800873f, -0.03178478f, -0.03719802f, -0.03311371f, -0.00013010f, 
    0.02137504f, 0.00649784f, 0.01076219f, -0.03788499f, -0.01991270f, -0.03127164f, 0.01184271f, -0.01889182f, 
    -0.03341148f, -0.02179947f, 0.02843204f, -0.02762003f, 0.02315670f, -0.00370901f, -0.00318305f, -0.04070778f, 
    0.01263427f, -0.01280386f, 0.00579910f, 0.00953084f, -0.01512133f, 0.02743229f, -0.01870456f, 0.01773920f, 
    -0.01323456f, -0.04140096f, 0.01871227f, 0.00257286f, 0.01801899f, -0.04145893f, -0.00745183f, -0.00180247f, 
    0.00057218f, -0.01347189f, 0.01032818f, -0.00350431f, 0.01781120f, 0.01552764f, -0.02126272f, -0.02973241f, 
    0.02157419f, -0.00769133f, 0.02906985f, -0.00352795f, 0.01147343f, -0.03583621f, 0.02296346f, -0.00884783f, 
    -0.03174176f, -0.00937162f, -0.00903919f, -0.02146202f, 0.00298242f, 0.00098818f, -0.03227639f, -0.03835679f, 
    -0.00884034f, 0.01178108f, 0.02506418f, 0.00245696f, 0.00883694f, 0.01755881f, 0.01294847f, -0.02923379f, 
    -0.03833291f, 0.01573984f, -0.02708846f, 0.02024978f, -0.02941653f, 0.01120432f, 0.02948690f, 0.01285271f, 
    0.00814143f, 0.02959674f, -0.02931002f, -0.02180449f, -0.03549445f, -0.01946391f, 0.00838407f, 0.01479378f, 
    -0.01447345f, 0.00046487f, -0.01388534f, 0.02890743f, -0.01547679f, -0.02383266f, -0.02019017f, 0.00187994f, 
    -0.02061510f, -0.02487683f, 0.01039319f, -0.03554818f, -0.03136730f, 0.01629112f, 0.00415273f, -0.01886484f, 
    -0.01290560f, -0.01792675f, -0.03580791f, 0.00292242f, -0.03309704f, 0.01589892f, -0.01873945f, -0.00781337f, 
    0.02026941f, 0.02729121f, -0.03880306f, 0.00671283f, 0.01429791f, -0.01289582f, 0.01217055f, 0.02229323f, 
    0.00129277f, -0.00689355f, -0.00000045f, -0.01888530f, 0.00002359f, -0.04028528f, 0.01599230f, -0.03016004f, 
    0.00818201f, -0.00166209f, -0.02673909f, 0.01614329f, 0.02154123f, -0.03128809f, 0.01295906f, -0.02739611f, 
    0.02121267f, 0.00436988f, 0.02800286f, -0.02266331f, -0.02572665f, 0.01508036f, -0.02947098f, -0.03168652f, 
    -0.02703073f, 0.02412618f, 0.00624943f, 0.00007642f, -0.02133379f, -0.04195304f, 0.02002759f, -0.00829642f, 
    -0.04004500f, 0.00698227f, -0.03745413f, 0.02229653f, 0.01490794f, 0.02687935f, -0.02147669f, -0.00446384f, 
    0.01675993f, -0.03039286f, 0.00926885f, 0.02186314f, -0.01794931f, -0.00383795f, 0.00261181f, 0.00391263f, 
    -0.00979301f, -0.03412527f, 0.01951244f, 0.00969932f, 0.02966860f, -0.01132062f, -0.04018313f, -0.02963483f, 
    -0.02235750f, -0.01607090f, -0.00802216f, 0.00119480f, -0.01284268f, 0.00115949f, -0.04163183f, 0.02796432f, 
    -0.00857498f, -0.00871005f, -0.01555205f, -0.00102358f, 0.00543736f, -0.01572771f, -0.03511669f, -0.02404905f, 
    0.02165180f, -0.02131593f, -0.03978211f, 0.00561797f, -0.01693064f, 0.00782039f, -0.00799168f, 0.02007815f, 
    0.00313324f, -0.03060378f, 0.02187159f, -0.03576304f, -0.01448131f, -0.02720577f, 0.00529551f, -0.02256883f, 
    -0.04105408f, 0.02735153f, 0.01802516f, -0.01851170f, 0.00882630f, -0.02315211f, -0.03794255f, 0.00113962f, 
    -0.03660220f, -0.03131760f, -0.00373014f, -0.01578315f, 0.01995420f, 0.01352086f, 0.02557120f, 0.00039712f, 
    0.00234707f, 0.00919152f, 0.00478233f, 0.01728123f, -0.00898168f, -0.02179221f, -0.01150553f, 0.03311456f, 
    -0.01035750f, -0.01485882f, -0.00189965f, 0.00031121f, -0.00161141f, -0.02997762f, -0.03386085f, 0.01958528f, 
    -0.00160062f, -0.02905802f, 0.01942708f, -0.02020507f, 0.00091388f, 0.00249607f, 0.02735967f, -0.02348981f, 
    -0.01150736f, -0.00886624f, 0.02713893f, -0.01693605f, 0.02399828f, -0.03413942f, -0.03421671f, 0.01376587f, 
    -0.01828451f, -0.03161224f, 0.00333895f, 0.00138114f, 0.01402976f, -0.00449397f, -0.02265912f, -0.03523014f, 
    -0.03968078f, 0.01629559f, -0.01511349f, 0.02024356f, -0.02715654f, 0.02860568f, -0.00101585f, 0.02241182f, 
    0.00112448f, 0.00082027f, -0.02006046f, -0.00604998f, -0.01305725f, 0.02941351f, 0.00207013f, 0.01891296f, 
    0.00778095f, -0.02666573f, 0.00408954f, 0.00886268f, -0.04041272f, -0.02104320f, -0.03582776f, -0.01275556f, 
    -0.02833334f, 0.00797433f, 0.01496368f, 0.02503079f, 0.01924380f, -0.02401609f, 0.02706446f, -0.00021504f, 
    -0.01689435f, -0.01161719f, -0.00700096f, -0.03931170f, 0.00732964f, -0.01225630f, 0.02685203f, -0.04046034f, 
    0.02091551f, -0.01729151f, -0.00527357f, 0.00825053f, -0.03271812f, 0.00690290f, 0.00902905f, -0.00011641f, 
    0.03118607f, -0.01708750f, -0.02362646f, -0.01214039f, 0.00576244f, 0.02666033f, -0.00061800f, -0.01324144f, 
    0.00743644f, -0.00385586f, 0.01712272f, -0.00599206f, 0.02266760f, 0.01320680f, 0.02884474f, -0.03556962f, 
    -0.03303022f, -0.03302159f, -0.03119376f, -0.04106269f, -0.01229522f, 0.02457129f, -0.00976227f, 0.02556347f, 
    0.00506265f, -0.01588441f, 0.01197388f, 0.00569895f, -0.00723183f, -0.02714373f, -0.03279789f, -0.04192910f, 
    -0.03997271f, -0.03334269f, 0.02608689f, 0.02729312f, -0.01757094f, 0.00733830f, -0.01501619f, -0.02018280f, 
    0.01199797f, -0.03878217f, 0.00558373f, 0.01604151f, 0.00522134f, 0.02765250f, -0.00998842f, -0.00986318f, 
    0.01239498f, 0.02398929f, -0.01024988f, -0.00587575f, -0.03237572f, 0.02300189f, 0.00835221f, 0.02336888f, 
    -0.03264256f, -0.03533346f, -0.04039172f, -0.00313889f, 0.01943896f, -0.03716218f, 0.01145537f, -0.03471077f, 
    -0.03108028f, -0.03901922f, 0.01219064f, -0.01476732f, -0.00159652f, -0.03708879f, -0.01075145f, 0.01433260f, 
    0.02525297f, 0.02152642f, -0.01365184f, -0.01319234f, 0.00915764f, -0.03887191f, 0.00136987f, -0.01339232f, 
    -0.01732849f, -0.04007854f, -0.00843599f, 0.02783693f, -0.03083901f, -0.02866803f, 0.02910874f, 0.02518297f, 
    -0.01789611f, -0.03914521f, 0.01015362f, 0.02373904f, 0.02486550f, -0.01573993f, 0.02969018f, -0.02792021f, 
    -0.03657028f, 0.00625889f, -0.02661985f, -0.01465630f, -0.03163561f, 0.00948837f, -0.03148909f, -0.01879592f, 
    -0.01041438f, -0.01215654f, 0.00024281f, -0.02309482f, -0.03865523f, -0.01664184f, -0.02716498f, 0.02091811f, 
    -0.01918943f, 0.01599611f, 0.02275625f, 0.01577777f, 0.02595421f, -0.03972226f, -0.01843413f, 0.01082151f, 
    0.01754219f, -0.00570565f, -0.00589807f, -0.02559911f, -0.02048477f, 0.02408773f, 0.02927256f, 0.01229074f, 
    -0.02072520f, -0.01609797f, -0.03688077f, -0.03479220f, -0.01443127f, -0.00854040f, -0.01996784f, 0.02502090f, 
    0.02792861f, -0.03191619f, -0.03335093f, 0.01036347f, -0.00761998f, 0.00476483f, -0.03185641f, 0.00566591f, 
    -0.02087855f, -0.02361204f, 0.01117592f, -0.03368219f, 0.00593473f, 0.00283120f, 0.02921222f, -0.04044921f, 
    0.01933322f, 0.01941776f, 0.02422988f, -0.01164169f, 0.00367999f, 0.02056123f, -0.02820502f, 0.00658284f, 
    0.02774500f, 0.00171050f, -0.02573491f, 0.00789253f, -0.03928291f, -0.00182037f, -0.01777956f, 0.00088672f, 
    -0.02740173f, 0.02791801f, -0.01551251f, 0.01438902f, 0.01565725f, -0.01394458f, 0.00031587f, 0.02302025f, 
    -0.03401570f, 0.01203187f, -0.02396081f, -0.00555017f, -0.02524205f, -0.00754002f, 0.00547325f, -0.02332484f, 
    -0.03923617f, 0.00566246f, -0.02428192f, 0.01818970f, -0.03606711f, -0.00870730f, -0.02968054f, -0.01996639f, 
    -0.01066481f, -0.03247087f, -0.01784112f, -0.01998745f, 0.02894522f, -0.03407881f, 0.01123114f, -0.02726566f, 
    -0.09309271f, 0.00602484f, -0.13139434f, -0.09713234f, -0.03273020f, -0.09898454f, 0.02962612f, -0.04073985f, 
    0.00732317f, -0.06770223f, -0.03055691f, -0.03726581f, 0.05711425f, -0.22936580f, 0.08432692f, -0.14931706f, 
    0.00332344f, 0.04405776f, -0.10843299f, 0.10445797f, -0.06552740f, 0.13347648f, 0.02319746f, -0.02919759f, 
    -0.27585706f, 0.23264211f, -0.13369146f, 0.09562703f, 0.08503480f, 0.05842177f, 0.00559981f, -0.05838967f, 
    -0.07811835f, -0.09484386f, -0.14658292f, 0.06870072f, -0.01365460f, -0.02453641f, 0.26902208f, 0.00544926f, 
    -0.09912964f, 0.06589291f, 0.02282759f, -0.07900932f, -0.08117237f, -0.00700854f, 0.05991309f, 0.16222221f, 
    -0.01060791f, 0.08619038f, -0.04475877f, -0.01772898f, 0.08632880f, -0.01469563f, -0.03249973f, -0.07211365f, 
    0.01858829f, 0.08700123f, -0.02991717f, 0.21515740f, 0.05876586f, -0.11279718f, -0.06009307f, 0.11025386f, 
    -0.01848914f, -0.08422212f, 0.06783038f, -0.02618824f, -0.01384221f, 0.05321126f, 0.04718171f, -0.06655898f, 
    -0.08929494f, 0.10852230f, 0.05750626f, 0.22880524f, 0.02976077f, -0.00325350f, 0.03363124f, 0.00617357f, 
    0.03655314f, 0.01155567f, 0.19925486f, 0.04518627f, -0.13627398f, -0.24049647f, 0.08755474f, 0.14532502f, 
    0.04562630f, 0.00816146f, 0.11613051f, 0.07042214f, -0.00817525f, 0.04204777f, -0.06268335f, -0.00985001f, 
    -0.13317025f, -0.02842151f, -0.13744387f, -0.04493906f, -0.10088931f, 0.05025161f, -0.07792167f, 0.09232409f, 
    -0.05831531f, 0.06460977f, 0.11241116f, -0.00734855f, -0.22457294f, -0.02146713f, -0.21387821f, 0.07286894f, 
    0.01117764f, 0.13211972f, 0.00185259f, 0.11177073f, -0.06203276f, -0.00588256f, 0.12032193f, 0.14279263f, 
    0.14669359f, -0.17675103f, 0.12775822f, -0.05621914f, 0.02668040f, 0.02063047f, 0.04624029f, 0.08022836f, 
    -0.07026845f, -0.01826767f, 0.11519674f, 0.00887082f, -0.29103267f, -0.26138437f, 0.00010610f, 0.11953243f, 
    0.01401739f, -0.00433469f, -0.01507018f, -0.07174587f, 0.09174774f, 0.00075378f, 0.02039394f, 0.06392034f, 
    -0.17926276f, 0.04477900f, -0.02348817f, 0.10151400f, -0.09057590f, -0.03397033f, 0.00289851f, -0.02673533f, 
    -0.03760591f, 0.01060460f, 0.06793547f, -0.00448087f, -0.24907881f, 0.35540774f, -0.17709741f, 0.22597860f, 
    0.09621682f, 0.09581201f, -0.13712113f, 0.06701813f, -0.08298716f, -0.01015253f, -0.03335520f, 0.10305218f, 
    -0.09684262f, 0.05169415f, -0.13102221f, 0.28865737f, 0.04449453f, 0.04622173f, 0.09864015f, 0.17327777f, 
    0.02981128f, 0.11586948f, 0.09953794f, 0.06432711f, 0.13753159f, 0.16611122f, -0.00899926f, -0.08102544f, 
    -0.11003586f, -0.05236348f, -0.00220473f, 0.10078064f, 0.06087605f, 0.13462974f, -0.17019479f, -0.07561520f, 
    0.04304812f, -0.04915063f, 0.34410155f, 0.01803578f, -0.01182977f, -0.03474934f, 0.12390241f, -0.07071243f, 
    -0.10374435f, 0.10376055f, 0.07813984f, -0.04473958f, -0.16612278f, -0.11212564f, 0.13027978f, -0.11789006f, 
    0.09302723f, -0.04209777f, -0.01746578f, 0.00651414f, 0.15626775f, 0.07954728f, 0.11195066f, 0.02464858f, 
    -0.19313323f, 0.09497729f, -0.05658609f, -0.06052765f, -0.03203763f, -0.02198090f, 0.04345945f, 0.08513824f, 
    0.00894969f, 0.00787614f, 0.04115049f, 0.00816489f, 0.22512057f, -0.03827740f, 0.50373292f, -0.17324789f, 
    0.02120816f, 0.03985269f, 0.01462477f, 0.06255472f, -0.05987177f, 0.02929511f, 0.00569581f, 0.03142973f, 
    -0.09284065f, -0.12995900f, 0.08334989f, 0.13085593f, 0.01157892f, -0.01047548f, -0.03229034f, 0.00006454f, 
    -0.01854290f, 0.00756681f, 0.00385564f, 0.02475842f, 0.19096684f, -0.13941768f, 0.34306705f, -0.03298207f, 
    -0.08504709f, -0.10577566f, -0.08089124f, 0.02384553f, 0.05867201f, -0.08735465f, 0.14106245f, -0.01821863f, 
    0.35064259f, -0.05913603f, 0.14974973f, -0.14466678f, 0.11626699f, -0.06488577f, 0.06773899f, 0.01640596f, 
    -0.02573858f, 0.03728272f, 0.05507910f, 0.10509526f, -0.05338706f, -0.14394322f, -0.12778476f, -0.23968339f, 
    0.09008060f, -0.06154955f, 0.04685120f, -0.02585333f, -0.10437705f, 0.06791306f, 0.12254377f, -0.05942756f, 
    0.15895998f, -0.29057372f, 0.31978938f, 0.07602916f, 0.19709320f, -0.07734281f, 0.14930186f, 0.02190084f, 
    -0.07488192f, -0.02041860f, -0.02704043f, -0.04066729f, 0.03115060f, 0.00051546f, 0.11295334f, 0.14396891f, 
    0.11257195f, -0.02793491f, 0.05168470f, -0.04478196f, -0.09247033f, -0.01341282f, 0.00893973f, -0.01862627f, 
    -0.15738228f, -0.07311502f, 0.16919896f, 0.02897726f, 0.03086261f, -0.03457959f, 0.01048474f, 0.05537504f, 
    0.08618490f, 0.02098546f, 0.10810483f, 0.00250711f, -0.05120919f, -0.07796332f, -0.00354569f, 0.07316612f, 
    -0.01740699f, 0.00109047f, -0.06693800f, 0.12589689f, 0.08605986f, 0.08045854f, -0.04416105f, -0.13506910f, 
    -0.24042797f, 0.20785472f, -0.04127983f, 0.07597411f, 0.02694135f, -0.04463756f, -0.00677156f, -0.03586059f, 
    -0.10368084f, -0.09573241f, 0.04484926f, -0.15176253f, 0.12912118f, 0.11437542f, -0.01427507f, 0.01173897f, 
    0.04565680f, 0.00052161f, 0.04033276f, 0.01560942f, 0.00201601f, 0.01157067f, -0.05714332f, -0.02254616f, 
    -0.11686093f, -0.01560585f, 0.12885462f, 0.17930101f, 0.01466486f, -0.05258308f, 0.02075417f, -0.06130146f, 
    0.04139237f, 0.19208190f, 0.12087741f, 0.05276240f, 0.06101991f, 0.05148458f, 0.32467794f, -0.09031806f, 
    0.00524615f, -0.05985909f, 0.02925543f, -0.00592982f, -0.11649405f, 0.02267702f, 0.09884288f, 0.14543259f, 
    -0.21851198f, 0.03824664f, -0.07352552f, -0.11772597f, 0.04430947f, 0.05391093f, 0.06624575f, 0.07581725f, 
    0.11662653f, 0.04752772f, -0.01103323f, 0.01133792f, 0.05258084f, -0.01668864f, -0.02934843f, -0.10225371f, 
    -0.07498113f, 0.02705108f, -0.03964195f, 0.01669149f, 0.02150767f, 0.01187028f, -0.02326213f, 0.02476607f, 
    -0.19418187f, 0.05629646f, -0.11863761f, -0.21616225f, -0.03233395f, -0.03412130f, 0.03932438f, 0.00939017f, 
    -0.03127124f, -0.02521260f, -0.07664201f, -0.09501434f, -0.11145763f, -0.02958488f, 0.13154964f, 0.05269263f, 
    0.08235467f, -0.09896918f, -0.09263265f, -0.03667875f, 0.06317113f, 0.08323079f, 0.06399908f, -0.01988010f, 
    0.12645534f, -0.02257883f, 0.05812107f, 0.07565106f, -0.03010320f, -0.01477022f, -0.03205989f, -0.16822711f, 
    -0.11067992f, 0.01286076f, 0.04930887f, -0.02289941f, -0.29011020f, 0.17498569f, -0.15535912f, 0.14917669f, 
    0.04228069f, 0.02135355f, 0.19062929f, 0.12933421f, -0.05795214f, 0.06078766f, 0.02117972f, 0.10976158f, 
    0.19929942f, -0.03520380f, 0.09726949f, 0.17108503f, 0.04556413f, 0.02317289f, 0.02544460f, 0.14493278f, 
    -0.00810664f, 0.07158238f, -0.02815399f, -0.12648812f, 0.21875705f, 0.21691218f, -0.14368679f, 0.17785546f, 
    -0.08852849f, 0.01710088f, 0.00488281f, 0.03084285f, -0.01273554f, -0.02641776f, 0.09655828f, 0.13863629f, 
    -0.02907312f, -0.12086884f, 0.15688089f, -0.15633689f, -0.00569581f, -0.02403449f, 0.00903702f, 0.01343706f, 
    -0.07334933f, -0.01718673f, -0.02107171f, 0.01259709f, 0.33314249f, -0.08470450f, -0.07415271f, -0.09092869f, 
    0.11451436f, -0.03177804f, -0.00797030f, -0.02643711f, -0.07015577f, -0.01244771f, 0.01440980f, -0.06262707f, 
    -0.14655508f, 0.09095076f, -0.00931281f, 0.13449004f, 0.00946333f, 0.00676113f, -0.08073211f, -0.01298229f, 
    0.07825834f, 0.10921659f, -0.01790981f, -0.04587594f, -0.31518465f, 0.12966113f, -0.02503568f, 0.07996204f, 
    0.02460350f, -0.00682164f, 0.00576684f, 0.11563551f, 0.13621289f, 0.09864685f, -0.00920830f, 0.01206449f, 
    -0.26296607f, 0.02990709f, -0.27043197f, -0.09746001f, 0.20359571f, 0.03149810f, 0.01553104f, -0.05656026f, 
    0.09038829f, 0.06581703f, -0.01124224f, 0.00129204f, -0.09355790f, -0.07133448f, -0.13763021f, 0.22436681f, 
    0.01365159f, 0.04958005f, 0.05822640f, 0.10511383f, -0.04303674f, 0.09016363f, -0.07724727f, -0.12891549f, 
    0.07838285f, -0.10391558f, 0.01008294f, 0.06165015f, -0.01922022f, -0.05536121f, -0.03301243f, 0.05640962f, 
    0.01384006f, -0.03983916f, 0.11851109f, -0.00181865f, -0.03258135f, 0.11796727f, -0.01446875f, -0.00382275f, 
    -0.07270491f, 0.03775895f, 0.16802521f, 0.00841638f, 0.08183399f, -0.02707536f, -0.10186551f, -0.10371680f, 
    -0.26306635f, -0.13022825f, -0.12815642f, -0.08245064f, 0.10000189f, -0.01328125f, 0.08170695f, 0.04717190f, 
    -0.00108154f, 0.10416184f, 0.08250833f, -0.00318554f, -0.01827987f, 0.08370610f, -0.22619255f, 0.04864804f, 
    -0.11925729f, -0.09601947f, 0.04963785f, 0.01934017f, 0.07623083f, -0.01474702f, 0.07421172f, 0.06647380f, 
    0.05673719f, -0.17522311f, -0.07915389f, -0.07504045f, 0.11699606f, -0.03598974f, -0.08002064f, -0.09030674f, 
    0.00746026f, 0.03201524f, 0.04519225f, 0.06675877f, -0.18568352f, 0.12139872f, -0.11800364f, -0.05420820f, 
    -0.01475618f, -0.04971584f, -0.05762947f, -0.00999227f, 0.04074062f, -0.06963407f, -0.07055417f, -0.11725972f, 
    -0.01052716f, 0.09205192f, -0.01947897f, -0.00879025f, 0.05029293f, 0.00530504f, 0.00143251f, -0.02851927f, 
    0.09768688f, 0.03870895f, 0.06415643f, 0.05959912f, -0.05717398f, -0.06828927f, 0.07644913f, 0.09979916f, 
    -0.02618401f, -0.03604651f, -0.00028415f, 0.01527552f, -0.00248155f, -0.00547643f, 0.03866965f, -0.05238838f, 
    -0.20033431f, 0.03277183f, 0.04455648f, 0.03978113f, 0.02872372f, -0.02384490f, 0.05864463f, -0.11550245f, 
    0.07065587f, 0.00472087f, 0.01853261f, -0.09241614f, -0.08488714f, 0.15100186f, 0.15463698f, 0.23103350f, 
    -0.01223595f, -0.06035637f, -0.09359012f, -0.02906670f, -0.00948378f, 0.06066719f, 0.13873143f, -0.01053854f, 
    -0.11836225f, -0.01667172f, -0.13972653f, 0.03230091f, -0.09520799f, 0.15335050f, -0.06153450f, 0.10658952f, 
    0.00207848f, 0.07682596f, -0.01705882f, -0.09000190f, -0.06264007f, -0.03984940f, -0.18377224f, -0.03904393f, 
    -0.15642010f, 0.13616014f, -0.09234919f, -0.12600361f, 0.02237699f, -0.03653564f, -0.22122386f, -0.05230720f, 
    0.09540424f, -0.18370619f, 0.25173283f, 0.00866804f, -0.00666205f, 0.08758122f, 0.01396700f, 0.13811240f, 
    -0.02118544f, -0.11728062f, -0.00986886f, 0.04317803f, -0.24119446f, 0.43765542f, -0.11656585f, 0.33638570f, 
    -0.00372431f, 0.27228662f, -0.00370931f, 0.12554669f, -0.06419884f, 0.02407668f, -0.01285649f, -0.05753360f, 
    -0.19613141f, -0.04794124f, -0.06593073f, 0.09312637f, 0.05453654f, -0.01710778f, 0.03639645f, -0.12066173f, 
    -0.12764367f, -0.03202241f, -0.13397640f, 0.03430244f, -0.07405976f, -0.17000033f, 0.22276090f, -0.06132194f, 
    0.03867133f, -0.04405772f, -0.00855550f, -0.10193919f, 0.04555292f, -0.01129672f, 0.00752241f, 0.03721287f, 
    -0.14357704f, -0.22269452f, -0.00794581f, 0.07321481f, 0.02305922f, 0.05142469f, 0.07547898f, 0.02413151f, 
    0.05212586f, -0.02905589f, 0.04085637f, 0.01299053f, -0.12375955f, -0.20989348f, -0.13195485f, 0.10839824f, 
    0.05559341f, 0.00824168f, -0.02443061f, -0.11077211f, -0.11096544f, -0.06274693f, -0.06573085f, -0.01664668f, 
    -0.03731767f, 0.00328228f, -0.14603144f, -0.00529937f, 0.14218862f, -0.01473441f, 0.00843325f, 0.02232632f, 
    -0.05420030f, -0.02088357f, 0.04035186f, -0.03976799f, -0.15268049f, 0.08815198f, -0.10603354f, 0.07266327f, 
    0.07352372f, -0.08955148f, -0.07427309f, -0.10607249f, 0.01081270f, 0.14480343f, 0.01089159f, -0.02788417f, 
    -0.18176933f, 0.18151131f, -0.17403841f, 0.10384926f, -0.05648665f, -0.03037969f, -0.06381253f, 0.02906524f, 
    -0.03234050f, -0.00348366f, -0.15920569f, -0.00548970f, 0.01542690f, 0.17640683f, 0.20230761f, -0.21910718f, 
    -0.00148156f, 0.08127018f, -0.10769795f, -0.08826389f, -0.13030544f, -0.02899831f, 0.20259084f, 0.12873694f, 
    0.04147647f, -0.00777867f, -0.04835845f, -0.08535606f, 0.14218239f, -0.09640227f, -0.00936053f, -0.11247931f, 
    0.05600162f, 0.13199046f, -0.01884018f, 0.28715780f, -0.04545861f, -0.22212501f, -0.11113959f, 0.06108821f, 
    0.00106470f, 0.07893814f, 0.14732292f, 0.01592040f, 0.07766410f, 0.11077154f, 0.04170384f, 0.07884048f, 
    -0.23224808f, 0.16361207f, 0.02858756f, 0.08558917f, 0.08665866f, 0.02064751f, -0.09894651f, 0.14479795f, 
    0.13047279f, -0.00132595f, 0.09907431f, 0.12465063f, -0.11917818f, -0.20121382f, -0.06150028f, 0.09029861f, 
    0.09570740f, 0.01371991f, 0.14265959f, 0.12928781f, -0.18154816f, -0.09739008f, -0.14183182f, 0.04509849f, 
    0.00997971f, -0.04707498f, 0.00627224f, 0.12819004f, -0.10201295f, -0.03415150f, -0.08064818f, 0.05043017f, 
    -0.01424000f, -0.10560606f, -0.11969465f, -0.12531763f, -0.35102361f, 0.07857753f, -0.07586067f, -0.12697288f, 
    -0.07450814f, -0.02067959f, 0.06802525f, 0.04183799f, 0.09198845f, -0.08736945f, 0.10194792f, 0.17387260f, 
    0.11424305f, -0.01439864f, 0.06336742f, 0.20840068f, 0.05624204f, 0.13392936f, -0.02302912f, 0.12068449f, 
    -0.12874369f, -0.03454813f, 0.21881920f, 0.00135237f, -0.19810787f, -0.01815745f, 0.07598611f, -0.02121928f, 
    -0.04318561f, 0.05982543f, -0.07068948f, 0.04714389f, 0.06696089f, 0.02480909f, 0.04112118f, 0.04002455f, 
    -0.28776425f, -0.02163765f, -0.05033308f, 0.02422846f, -0.21250190f, -0.12078739f, -0.06141794f, -0.15768045f, 
    -0.03689667f, -0.00081964f, 0.08373199f, 0.08279816f, -0.28587562f, 0.25293133f, -0.29387861f, 0.27358180f, 
    0.05145777f, 0.00190506f, -0.14121498f, 0.00845784f, -0.05245860f, 0.04204936f, -0.00453195f, 0.11951605f, 
    0.15611412f, -0.00734526f, 0.07691517f, 0.19014278f, 0.07921977f, -0.01380134f, 0.05240360f, 0.10384147f, 
    0.16592406f, 0.07115110f, 0.03096871f, 0.07927154f, -0.03670575f, -0.00319909f, -0.04237697f, -0.05862426f, 
    -0.03159275f, -0.05142271f, 0.03083979f, 0.00567310f, 0.00891781f, -0.08663666f, -0.25127676f, -0.31992987f, 
    -0.17356411f, 0.22917747f, 0.00485450f, 0.04808298f, 0.01678109f, -0.15719952f, -0.19636095f, 0.00842215f, 
    -0.03607972f, 0.09934041f, 0.14551659f, -0.02831539f, -0.02040453f, -0.17279688f, 0.07733012f, 0.04373898f, 
    -0.01169731f, -0.04422402f, -0.06524669f, 0.05369122f, 0.18002023f, 0.13924132f, 0.19277911f, 0.00778359f, 
    -0.08001510f, 0.01497753f, 0.08779690f, -0.08677237f, 0.00142123f, -0.00279258f, 0.06049761f, 0.00764005f, 
    0.02457298f, -0.06035892f, 0.01894692f, -0.17104147f, -0.24951635f, -0.09748156f, 0.23781545f, 0.09200338f, 
    0.11084857f, 0.05619253f, 0.00632872f, 0.01276321f, -0.05448084f, 0.00925557f, 0.03606382f, 0.01976858f, 
    -0.00144817f, -0.01263529f, 0.05019470f, 0.07412300f, 0.09653430f, 0.11535294f, 0.13169128f, 0.04988897f, 
    0.10192180f, 0.04538684f, 0.00025833f, 0.10927341f, 0.35837901f, -0.10712086f, 0.11395337f, 0.18160619f, 
    -0.07066684f, -0.06521762f, -0.05922957f, 0.05779305f, 0.08505313f, -0.00623786f, 0.15256910f, 0.09237636f, 
    -0.03082918f, 0.21804915f, -0.15407638f, -0.00279135f, 0.02773231f, -0.20695575f, -0.01958997f, -0.00874352f, 
    0.09871893f, 0.05283218f, 0.04995329f, 0.16087203f, -0.05551947f, -0.23004466f, -0.07621137f, -0.18105568f, 
    0.22736436f, -0.05234203f, -0.02870938f, 0.08432259f, -0.01350216f, 0.02232735f, 0.09664077f, -0.09397980f, 
    -0.24530359f, -0.15558766f, 0.20897497f, -0.00827603f, 0.05793901f, -0.01264134f, -0.06791104f, 0.11453463f, 
    -0.14091155f, 0.03059379f, -0.02642270f, -0.11168829f, -0.01007799f, 0.02626725f, 0.00377745f, 0.07660036f, 
    0.11576956f, 0.00086781f, 0.11688211f, 0.03333134f, -0.07104964f, 0.00130061f, 0.01601780f, 0.11194390f, 
    -0.22698633f, -0.04389333f, -0.00105703f, 0.07570285f, -0.09923164f, 0.03061139f, 0.03552347f, 0.08009528f, 
    0.28663450f, -0.02120967f, 0.12432464f, 0.25878143f, -0.03883303f, -0.02503215f, -0.08623897f, 0.01852588f, 
    -0.00433049f, -0.08498115f, 0.07483829f, 0.12938555f, -0.07269372f, -0.03007466f, 0.00180540f, -0.12349850f, 
    -0.13785933f, 0.20253897f, -0.04580840f, 0.04539643f, -0.00378724f, -0.05674362f, 0.02449995f, -0.15165943f, 
    -0.22501782f, -0.13639145f, -0.10073067f, -0.23169120f, -0.06918328f, 0.04342267f, -0.16609628f, -0.18846641f, 
    -0.07251142f, -0.01988020f, -0.11823938f, 0.01132745f, -0.03696593f, 0.05533508f, -0.02390756f, 0.00712207f, 
    -0.07160780f, 0.01295507f, 0.06220813f, 0.07893895f, -0.00072875f, -0.08541895f, -0.03933295f, -0.11014328f, 
    0.16481616f, 0.03392158f, 0.12551866f, 0.15813109f, -0.12474014f, 0.10716350f, -0.00271735f, -0.00462825f, 
    0.03128978f, -0.09091504f, -0.00222512f, -0.01113388f, -0.13675247f, 0.10411100f, 0.16426770f, 0.05380281f, 
    -0.25657535f, -0.09339784f, 0.09263518f, -0.03872817f, -0.01522299f, 0.00710374f, -0.06003156f, 0.04228770f, 
    0.09088087f, 0.08849827f, 0.01466891f, -0.02565570f, -0.19376583f, -0.04800459f, -0.04572576f, -0.04623463f, 
    -0.01705575f, -0.06796515f, -0.04409486f, -0.06901543f, -0.01949740f, -0.07691463f, 0.00096368f, -0.02239698f, 
    -0.13473837f, 0.01143855f, -0.00858651f, -0.17718782f, -0.00165260f, 0.01087544f, 0.01613764f, -0.05099252f, 
    -0.05889530f, -0.05652204f, -0.16644824f, -0.18006471f, -0.09163824f, -0.00271950f, 0.09481575f, -0.01390437f, 
    0.05561975f, 0.02535659f, -0.06705815f, 0.02052923f, -0.05018465f, -0.08612101f, 0.04336911f, -0.02910931f, 
    0.04179524f, -0.04667617f, -0.07692063f, 0.04683439f, -0.04201204f, 0.04561153f, 0.11822804f, -0.14437446f, 
    -0.02402748f, 0.15275002f, 0.13108912f, 0.10544587f, 0.10532964f, 0.07508013f, 0.16096881f, -0.05610157f, 
    0.08995124f, 0.05156503f, 0.00581964f, -0.00798685f, -0.07365252f, 0.16383401f, 0.14116099f, -0.07483923f, 
    0.01749111f, 0.07156248f, -0.11022031f, 0.25437856f, 0.01761304f, 0.10409760f, 0.08944697f, 0.15170272f, 
    -0.01912932f, 0.05599436f, 0.08062848f, 0.11394403f, 0.27423593f, 0.15781149f, -0.14180794f, -0.08355160f, 
    0.08675405f, 0.02772216f, 0.05163025f, 0.01388171f, 0.02576206f, 0.11629850f, 0.13829820f, 0.11530785f, 
    -0.05157143f, 0.03141002f, 0.01431145f, -0.20356299f, 0.03202974f, 0.01415951f, -0.01220226f, -0.06916636f, 
    -0.12368343f, 0.00869975f, 0.00628687f, -0.05920658f, 0.30711398f, -0.02607479f, -0.01296555f, 0.02280976f, 
    0.01857908f, -0.02619061f, 0.02190837f, 0.05051359f, -0.14072607f, -0.10426681f, 0.06447130f, -0.02995227f, 
    0.00178061f, 0.04695363f, -0.08240367f, -0.09277267f, -0.03420550f, 0.03584668f, -0.14959502f, 0.04146371f, 
    0.14079973f, -0.12231228f, -0.09854624f, 0.00763580f, -0.32910174f, -0.14825149f, 0.04245942f, 0.01503401f, 
    0.00946400f, 0.11437321f, -0.06217586f, 0.09003751f, 0.07596163f, 0.05766556f, -0.07984703f, 0.04539345f, 
    -0.13266161f, -0.07397379f, -0.18721105f, 0.00248822f, 0.01880437f, -0.01239208f, -0.12203097f, -0.11707281f, 
    0.06072104f, 0.00363357f, 0.11387276f, 0.01717344f, -0.13187832f, 0.01155634f, -0.14305429f, 0.24123737f, 
    0.05877944f, 0.05091669f, 0.04255850f, 0.03235457f, -0.16891558f, -0.00817825f, -0.08360615f, -0.18046285f, 
    0.05207388f, 0.02085862f, 0.01465390f, 0.07661723f, 0.03378112f, -0.03065288f, -0.08207395f, 0.13606554f, 
    -0.06354041f, -0.13650629f, -0.01618982f, -0.04211750f, -0.12894748f, 0.05713103f, 0.05859253f, 0.03847798f, 
    -0.04463210f, 0.05567553f, 0.00196669f, 0.05151779f, 0.06831231f, -0.00118347f, -0.12028980f, -0.18868105f, 
    -0.24718049f, -0.09786125f, -0.02989727f, -0.10852265f, 0.00161463f, -0.09235236f, -0.03051823f, -0.07414726f, 
    0.10166144f, 0.12433466f, -0.00200286f, 0.03526739f, 0.23704672f, 0.05225665f, -0.10600731f, 0.11727084f, 
    -0.05346528f, -0.06217650f, 0.07735695f, 0.07137011f, 0.04782314f, -0.08969060f, 0.21603276f, 0.16301535f, 
    0.30168176f, -0.21546462f, -0.03362071f, -0.14543459f, -0.00753179f, 0.05616998f, 0.08633004f, 0.07415090f, 
    0.08888036f, 0.01744967f, -0.00215828f, -0.00864679f, -0.14439318f, 0.03349336f, -0.12443476f, -0.16637743f, 
    0.05525370f, 0.03138408f, 0.01485431f, 0.03461097f, -0.07047512f, -0.07548566f, -0.04831915f, -0.06656289f, 
    -0.23414396f, -0.01754113f, 0.09006380f, -0.06530792f, 0.04040658f, -0.02347207f, 0.03911265f, -0.05319940f, 
    0.10110948f, 0.01920724f, 0.08433873f, 0.10104504f, -0.05001246f, -0.05695735f, -0.00001392f, 0.04900357f, 
    0.06255212f, 0.07215367f, 0.19033884f, 0.05379457f, 0.05076435f, 0.04722721f, 0.12256597f, 0.02295762f, 
    -0.13924234f, 0.13377702f, 0.14782645f, -0.06128023f, -0.02987620f, -0.12706870f, 0.06552160f, 0.06747998f, 
    0.00394520f, 0.00598001f, 0.00831358f, -0.10885298f, -0.22331613f, -0.00224206f, -0.05092437f, 0.12052944f, 
    -0.00250013f, -0.27049837f, -0.05252829f, -0.08610014f, 0.04129368f, -0.18078586f, 0.21571445f, 0.05034703f, 
    0.02462659f, 0.09955204f, -0.17957178f, 0.03016752f, 0.00427204f, 0.04918346f, -0.14427431f, 0.16357091f, 
    -0.04074537f, 0.00950114f, 0.06568754f, -0.17101742f, -0.18239918f, -0.11594968f, -0.04493572f, -0.07347162f, 
    0.02170846f, 0.10116232f, 0.02683583f, -0.08797610f, -0.06104236f, -0.09143809f, -0.22755904f, -0.31442451f, 
    0.00938579f, -0.02686920f, 0.15001450f, 0.19076364f, -0.06767087f, 0.13441223f, -0.05852848f, 0.07171332f, 
    0.05079859f, -0.03209322f, 0.04890576f, 0.08493849f, 0.06155727f, 0.24073020f, 0.05141566f, 0.10401200f, 
    0.06425198f, 0.20289773f, 0.12123299f, 0.04753713f, -0.13174027f, 0.07384189f, 0.03449152f, 0.03293938f, 
    -0.15896361f, -0.24705735f, -0.04497662f, 0.00861616f, -0.01669994f, -0.03279695f, 0.02243612f, -0.02750935f, 
    -0.06541414f, -0.02209991f, -0.05522802f, 0.17967935f, -0.05166943f, -0.10005279f, 0.16460691f, -0.04528383f, 
    0.01753475f, 0.04684234f, -0.05399813f, 0.02106903f, 0.05795902f, -0.04001015f, -0.02719616f, 0.00770352f, 
    -0.02523901f, 0.01272754f, -0.01386472f, -0.04497956f, 0.06075775f, 0.09724278f, 0.07668398f, 0.00898869f, 
    0.09676834f, 0.00655677f, 0.00387648f, 0.16537802f, 0.04448247f, -0.13299319f, -0.05066322f, 0.04365024f, 
    0.05419577f, 0.11555184f, 0.04211611f, 0.03254037f, -0.12786800f, -0.12240434f, -0.02888950f, -0.04994163f, 
    -0.04978288f, -0.00657638f, 0.09757466f, -0.19459668f, -0.15901212f, 0.01496625f, -0.02734319f, -0.06925683f, 
    0.04734696f, 0.02614270f, -0.04592755f, -0.07929060f, 0.01870127f, -0.17224880f, 0.07631982f, 0.10077761f, 
    -0.06865247f, -0.17465864f, 0.31845227f, 0.16538319f, -0.06996623f, 0.08577591f, 0.03305518f, -0.01244303f, 
    -0.19855118f, 0.01793584f, 0.32192317f, 0.22758502f, 0.01211045f, 0.05883032f, 0.09853049f, 0.06241938f, 
    -0.04781519f, 0.01563604f, -0.02195322f, 0.09140678f, -0.04272034f, 0.27208143f, 0.08875385f, -0.04903571f, 
    -0.14130771f, -0.02930879f, 0.06912953f, -0.07887516f, 0.02801405f, -0.06518452f, -0.01652943f, 0.13881844f, 
    -0.00018587f, -0.09880234f, -0.00538426f, -0.00763624f, -0.04632401f, -0.03452346f, -0.03553095f, -0.02787260f, 
    0.06455789f, 0.00579199f, 0.01489716f, 0.04363189f, 0.21500781f, 0.01185224f, 0.00001052f, 0.17499749f, 
    -0.03183352f, 0.01468455f, -0.08677156f, 0.04338338f, -0.09578990f, 0.08487391f, 0.11091376f, 0.09382699f, 
    -0.42118117f, -0.03104958f, 0.23356839f, 0.15400527f, -0.08985691f, 0.00575473f, 0.01530778f, 0.07425924f, 
    -0.03666391f, -0.00519252f, -0.12985593f, -0.01709784f, -0.13349637f, -0.33195251f, -0.15200101f, 0.19283803f, 
    0.08710508f, 0.05315391f, 0.03131256f, 0.05778728f, 0.11678340f, 0.11221697f, 0.00071193f, 0.05500263f, 
    -0.00689104f, 0.01611480f, -0.22219761f, -0.02220107f, 0.16882418f, 0.09520127f, -0.11897267f, 0.05000794f, 
    0.02391262f, 0.20152585f, 0.09021301f, -0.02331103f, -0.08024237f, -0.14592846f, -0.14565727f, 0.01143902f, 
    0.03538432f, 0.05880315f, 0.03296194f, -0.07717092f, -0.13313317f, 0.01100888f, -0.05822159f, 0.04332442f, 
    0.09816559f, -0.05939740f, 0.07388703f, 0.08233523f, 0.14661746f, -0.10470169f, 0.03033496f, 0.10686542f, 
    -0.15330257f, 0.11369602f, -0.04511974f, 0.16679882f, -0.19517732f, -0.07815180f, -0.02296467f, 0.15547313f, 
    0.07081050f, 0.09808605f, 0.01608395f, -0.02082938f, -0.00963899f, 0.02882847f, -0.01578520f, -0.01960824f, 
    -0.13291468f, -0.08053991f, 0.03725839f, -0.17652188f, -0.11721431f, -0.04746713f, -0.05801152f, -0.07637960f, 
    -0.09075034f, 0.06773621f, -0.15533787f, -0.26913437f, 0.14902247f, 0.38946339f, -0.19342165f, 0.27997646f, 
    0.04580647f, -0.09048875f, 0.12736396f, 0.00540427f, -0.10043026f, -0.00824551f, -0.06435296f, -0.02326470f, 
    -0.26502630f, -0.01936292f, 0.06739642f, 0.29894781f, 0.02797149f, 0.20050761f, -0.00365146f, -0.00081596f, 
    -0.08218206f, 0.07234402f, 0.13317178f, 0.00646087f, -0.15613483f, 0.29899609f, 0.15404154f, 0.07671282f, 
    -0.02918556f, 0.02061760f, -0.06593411f, 0.03341502f, -0.01862416f, -0.05838868f, -0.00418690f, 0.03296019f, 
    -0.08539786f, 0.00987204f, 0.21280901f, 0.38478824f, -0.08674647f, -0.02195102f, 0.25248668f, 0.18510567f, 
    -0.06944802f, 0.05055596f, 0.01808921f, 0.12833686f, 0.00997664f, 0.12760305f, -0.18705989f, -0.25167069f, 
    0.05249386f, -0.05479912f, -0.01996627f, -0.01528660f, 0.03582281f, 0.05013014f, -0.06136942f, 0.01299550f, 
    -0.00947523f, -0.10846368f, -0.06785928f, 0.04216869f, 0.00440878f, 0.00391522f, -0.01284690f, -0.02816318f, 
    -0.00300643f, 0.03671938f, 0.00568239f, 0.02347468f, 0.31756926f, 0.07475621f, 0.31764060f, -0.33659858f, 
    -0.06738178f, -0.20911409f, -0.05068611f, 0.05714365f, 0.04011147f, 0.09904114f, -0.00788628f, -0.04974390f, 
    0.00173104f, -0.16843337f, 0.00090575f, 0.14034277f, 0.02295445f, 0.00193557f, -0.01038545f, 0.09366937f, 
    -0.03067107f, 0.04990938f, 0.04383741f, -0.07568392f, 0.12519790f, 0.04213038f, 0.13499169f, -0.29988915f, 
    -0.05313184f, 0.02284750f, -0.02707737f, -0.19489640f, 0.05650182f, -0.04160860f, 0.03911699f, -0.15148218f, 
    0.09471642f, -0.12744989f, 0.49070871f, -0.07569543f, -0.12993485f, 0.08077451f, 0.01035610f, -0.03090671f, 
    0.00061432f, -0.00174374f, 0.11514953f, -0.02602893f, 0.49734309f, 0.04048160f, -0.24238852f, -0.07168378f, 
    0.12386329f, 0.03108193f, 0.03167424f, -0.01612640f, 0.00067035f, 0.01051652f, 0.01480871f, 0.05837966f, 
    0.02201955f, -0.14583449f, 0.38483530f, -0.00348860f, -0.00915322f, 0.04580791f, 0.13077475f, 0.01507162f, 
    0.04857739f, 0.04963061f, 0.08010536f, 0.05234884f, 0.27065414f, -0.05309276f, 0.09214547f, 0.15035775f, 
    0.04557301f, 0.06784607f, -0.07359134f, 0.15801908f, -0.04952727f, 0.01237736f, 0.05106140f, -0.07737392f, 
    -0.17454334f, 0.09393266f, 0.13077006f, -0.12410830f, 0.07260926f, 0.00590286f, -0.10990976f, 0.01806170f, 
    -0.07794857f, 0.07719854f, -0.07675923f, -0.16713034f, -0.00388668f, -0.33868903f, -0.14863758f, 0.08949921f, 
    0.00981723f, 0.07102782f, 0.06783630f, 0.05711997f, 0.02879087f, -0.01099414f, 0.08780673f, 0.02921140f, 
    -0.15142290f, 0.27992859f, 0.04433880f, 0.18393312f, 0.03303675f, 0.03139526f, 0.06137236f, 0.05270955f, 
    -0.01317887f, 0.11209626f, 0.10867300f, -0.05902303f, 0.00768347f, -0.02383453f, 0.28380865f, -0.14449009f, 
    -0.16398947f, -0.03742354f, 0.00142610f, -0.04859361f, 0.00373355f, -0.12767564f, -0.14681277f, 0.06246742f, 
    -0.10493537f, -0.08672259f, 0.00116829f, -0.18639013f, 0.00975833f, 0.00418330f, -0.02415423f, -0.11652693f, 
    -0.08021194f, 0.14781806f, -0.02835308f, -0.05331220f, 0.08487557f, -0.12797946f, 0.05269856f, -0.11897181f, 
    -0.05402970f, -0.06345145f, -0.14283811f, -0.05433251f, -0.00433239f, 0.06501653f, -0.07933263f, -0.04953399f, 
    0.25401762f, -0.05083052f, 0.00502487f, -0.00393136f, 0.05648409f, 0.00548005f, 0.16257182f, 0.04012974f, 
    -0.03428340f, -0.01802694f, 0.07743115f, 0.19159642f, -0.01721464f, -0.01805069f, 0.03518161f, -0.18853182f, 
    -0.29667875f, -0.14538689f, -0.07575170f, -0.08372229f, -0.04218931f, -0.00612655f, -0.18401383f, -0.23155263f, 
    -0.11107119f, 0.06334990f, -0.04876684f, -0.05009861f, -0.00753569f, -0.02003432f, -0.05403118f, -0.07722224f, 
    -0.11197436f, 0.09614713f, 0.07299327f, 0.04915315f, -0.17996444f, -0.13036171f, -0.11984251f, 0.19107415f, 
    0.08913888f, -0.14272770f, 0.01878398f, 0.05546089f, 0.02963810f, 0.03975372f, 0.04659504f, 0.04528932f, 
    0.26869920f, -0.09897026f, 0.02827540f, 0.16138317f, 0.04022492f, 0.12131411f, -0.02400507f, 0.10632567f, 
    -0.02461302f, -0.10190652f, 0.00068461f, 0.05727040f, -0.04682129f, 0.19656616f, -0.02703150f, -0.28731474f, 
    0.03733224f, -0.00199211f, 0.05453967f, -0.16337784f, -0.01309007f, 0.08908644f, -0.11574741f, 0.14920993f, 
    0.05306436f, -0.14375684f, -0.01695382f, 0.25558504f, -0.03206849f, 0.03268391f, -0.12703569f, 0.10849749f, 
    -0.09142098f, -0.00946013f, 0.05611670f, -0.09923437f, 0.17703018f, 0.12182048f, 0.06285858f, -0.07313709f, 
    -0.26337823f, -0.06799731f, 0.02093098f, -0.05045016f, 0.03508466f, -0.01671328f, -0.04459389f, 0.07247643f, 
    0.02907909f, 0.11070144f, 0.10603734f, -0.05117753f, -0.04298916f, -0.06458829f, -0.00119966f, -0.02950726f, 
    -0.03655433f, -0.04046799f, -0.00573049f, -0.00502514f, 0.77483553f, 0.05501533f, -0.04069676f, 0.03759208f, 
    0.13917390f, 0.05120191f, -0.00224210f, -0.05148716f, -0.03132566f, 0.15452443f, 0.07365368f, 0.11737938f, 
    -0.17602842f, -0.05364437f, -0.26609167f, 0.06859057f, -0.00443122f, 0.00414099f, 0.01010885f, 0.11781954f, 
    0.02497309f, 0.09240108f, 0.01141832f, -0.08634911f, 0.04624876f, -0.22185268f, 0.03078085f, 0.09940362f, 
    0.05871011f, -0.05724342f, 0.15671372f, 0.02633330f, 0.14188465f, 0.00960081f, 0.05182396f, 0.03540642f, 
    0.10846236f, 0.11011075f, -0.26090091f, -0.33251324f, 0.07927284f, 0.11148246f, -0.10178263f, -0.06723620f, 
    0.08321713f, -0.10959898f, 0.01044504f, -0.01004699f, -0.27684641f, -0.02569099f, 0.09949109f, 0.20025809f, 
    -0.03054054f, -0.00065775f, 0.06801634f, 0.04586734f, 0.04571826f, 0.06213553f, 0.02628190f, 0.05884806f, 
    0.11149575f, -0.09717657f, 0.00916399f, 0.18584400f, 0.05259489f, 0.00802606f, -0.10269471f, -0.04862598f, 
    0.07455720f, 0.15757254f, 0.12582657f, -0.04445846f, -0.15587933f, 0.12502578f, 0.10006605f, 0.05328460f, 
    -0.11745205f, -0.11384186f, 0.01756067f, 0.06630952f, 0.12480086f, 0.04253185f, 0.06937496f, 0.02321590f, 
    -0.17330743f, -0.15842757f, -0.22306682f, -0.12131490f, 0.10111867f, -0.03533108f, 0.02754905f, 0.05246846f, 
    0.04745874f, -0.00147415f, 0.04095022f, -0.02472593f, -0.09329097f, 0.06356686f, -0.09487475f, -0.14639302f, 
    -0.02004082f, 0.06354591f, -0.02604710f, -0.16490588f, 0.15254204f, 0.09686168f, 0.04770996f, -0.02176645f, 
    0.07739207f, -0.08744115f, -0.27323022f, 0.09638215f, 0.25274855f, 0.02350843f, -0.08496154f, 0.06185199f, 
    -0.07344975f, 0.09281953f, 0.01679660f, 0.02435781f, -0.10105170f, 0.04130776f, -0.07367335f, 0.12191688f, 
    -0.06179226f, 0.04150466f, 0.01980936f, -0.06032057f, -0.10560244f, 0.18905683f, -0.18799691f, 0.08965706f, 
    -0.09675965f, 0.08701883f, -0.06376459f, -0.13926077f, -0.13995354f, -0.11343008f, -0.07265546f, -0.02600796f, 
    -0.02726530f, -0.01258603f, 0.04568917f, -0.11247641f, 0.06076631f, -0.14843875f, -0.02415737f, 0.22445382f, 
    0.02774342f, 0.01226108f, -0.07334999f, 0.01044189f, 0.02882018f, 0.02343686f, -0.00788835f, 0.00718468f, 
    0.14816965f, 0.32645231f, -0.03334489f, -0.21846685f, 0.16559823f, 0.06652156f, -0.00551211f, -0.15538014f, 
    -0.14967272f, -0.05404000f, 0.20434035f, 0.09791519f, 0.00320738f, 0.40690973f, 0.08520157f, 0.03403603f, 
    -0.18393779f, -0.08900847f, 0.10348860f, 0.00656777f, -0.16713981f, 0.08265799f, -0.05643395f, 0.07147945f, 
    -0.06517678f, 0.11406976f, 0.12174603f, 0.33779353f, -0.09724475f, 0.07211828f, 0.08357339f, -0.03960260f, 
    -0.11086603f, 0.14791821f, -0.03967033f, -0.18739241f, -0.06081656f, 0.19293399f, 0.01779203f, -0.02544047f, 
    -0.18309173f, 0.05898171f, -0.11193959f, -0.05554160f, 0.05922652f, 0.01631035f, -0.05683978f, 0.05911403f, 
    0.06005032f, -0.00569703f, 0.23987862f, 0.13710016f, -0.07426205f, 0.05144719f, 0.13637887f, 0.09789390f, 
    -0.01894837f, 0.00942399f, -0.07596903f, -0.03221139f, -0.35707206f, 0.37621689f, -0.11822407f, 0.26240483f, 
    -0.15862177f, 0.15319107f, -0.18800698f, -0.07377031f, -0.00528215f, 0.07570802f, 0.10729729f, -0.00549600f, 
    0.12022173f, -0.07967202f, -0.08024455f, 0.09343436f, 0.21174014f, 0.10427440f, -0.13679878f, 0.09756996f, 
    -0.06703712f, 0.07054988f, 0.03523219f, 0.02967978f, -0.14482839f, -0.15360437f, 0.14735234f, 0.02246734f, 
    0.03072310f, -0.03911431f, 0.00505538f, 0.07088609f, -0.04093405f, -0.02733950f, -0.04095985f, 0.09347502f, 
    -0.05294937f, -0.21001926f, -0.05482723f, 0.04909849f, 0.02333322f, 0.00476638f, -0.07976855f, 0.12613147f, 
    0.00961231f, -0.03544644f, -0.01651457f, 0.04837434f, -0.32525128f, -0.10607071f, -0.12922803f, 0.26023209f, 
    0.07017807f, 0.14058815f, 0.08041390f, 0.00669263f, 0.11432052f, 0.01415143f, -0.07297649f, 0.08829913f, 
    0.08125418f, 0.03370998f, 0.10531602f, -0.01371463f, -0.10428247f, -0.01254729f, 0.03952265f, 0.00055670f, 
    0.27563077f, 0.19679321f, -0.05209349f, 0.24939488f, 0.14739303f, -0.11758550f, 0.02999082f, -0.02363176f, 
    0.01163089f, -0.12024475f, 0.11347007f, -0.01969548f, 0.00349193f, -0.00179652f, -0.16508870f, 0.03350833f, 
    0.13811022f, -0.59290057f, 0.50024080f, -0.00307277f, -0.04379326f, 0.09431091f, -0.07210705f, -0.02550017f, 
    -0.03815644f, -0.25012279f, 0.07529242f, 0.18738848f, 0.16188446f, 0.24367031f, 0.08316161f, 0.13781571f, 
    -0.01159472f, -0.03986290f, 0.04225485f, 0.18277557f, 0.22016817f, -0.15614809f, -0.02846017f, -0.03863867f, 
    -0.03659467f, 0.04394396f, 0.06029522f, 0.01597850f, 0.03482873f, -0.01679002f, -0.08789231f, 0.01536531f, 
    -0.12318948f, 0.00307161f, -0.02384341f, -0.03643481f, -0.15211739f, -0.00625913f, -0.03666636f, 0.13439721f, 
    -0.06964745f, 0.07548220f, -0.01721077f, 0.18547677f, -0.21278670f, -0.08003139f, -0.12454186f, -0.08975729f, 
    0.19980724f, 0.10227738f, 0.15034352f, 0.09699932f, 0.05800385f, 0.17027627f, -0.12283659f, 0.03222729f, 
    0.06853686f, -0.00338089f, -0.00283558f, -0.03547780f, -0.28130528f, -0.24763702f, -0.49889287f, -0.25699392f, 
    0.21024089f, 0.05712625f, -0.06711909f, -0.08290506f, 0.26860884f, -0.06854250f, -0.07528351f, -0.09663645f, 
    0.04991786f, -0.06310239f, -0.10112279f, -0.13299754f, 0.09359160f, -0.08599789f, 0.01398838f, 0.14690602f, 
    -0.13847376f, 0.11878138f, 0.14288677f, 0.05009724f, 0.15922441f, 0.12081867f, 0.18245184f, 0.11638533f, 
    -0.00192113f, -0.09579772f, -0.01719054f, 0.00403006f, 0.14930297f, 0.31951728f, -0.16787086f, -0.05930514f, 
    0.05808133f, -0.04390928f, -0.02332376f, 0.01455589f, 0.12046796f, 0.04774537f, 0.08562405f, 0.03894103f, 
    -0.02951152f, -0.02970961f, 0.01229698f, 0.36823496f, -0.26153213f, -0.25403565f, -0.25403720f, -0.22079051f, 
    0.13516709f, -0.11479145f, -0.08673432f, 0.01142806f, -0.13494168f, -0.01479917f, 0.04603782f, 0.03042976f, 
    0.08774809f, 0.10586696f, 0.04717451f, 0.05077459f, -0.03033959f, -0.02335898f, -0.06098853f, -0.02162984f, 
    -0.00958599f, -0.02504721f, -0.11690888f, 0.02299580f, 0.42619261f, 0.03450924f, 0.07582919f, 0.25871098f, 
    -0.03471902f, -0.09931201f, 0.23631513f, -0.05789654f, 0.06626074f, 0.10110608f, -0.02842765f, 0.01570958f, 
    -0.16117245f, -0.18400981f, -0.04714296f, -0.10088706f, -0.11754845f, 0.18781786f, 0.18927327f, -0.08440398f, 
    0.16432211f, 0.09844863f, 0.13618176f, -0.00752718f, -0.26266205f, 0.02149059f, -0.09930208f, 0.00712043f, 
    -0.13942851f, 0.10831602f, 0.02899139f, -0.00586751f, -0.03177572f, -0.18216842f, -0.05517464f, 0.01501825f, 
    0.10103012f, -0.16159549f, -0.35604566f, -0.34166980f, -0.07094940f, -0.05082154f, -0.15303479f, -0.02135185f, 
    -0.00574687f, -0.12711090f, -0.13777718f, -0.02948785f, 0.13035594f, 0.20557851f, -0.06556218f, 0.05333888f, 
    -0.07160958f, -0.07766986f, 0.03624525f, 0.04812199f, 0.04073710f, -0.12425981f, 0.05240549f, -0.04127656f, 
    0.14449218f, 0.11726824f, 0.11856502f, 0.01294462f, 0.01415178f, 0.22242318f, 0.01387011f, 0.03200732f, 
    -0.00212062f, 0.09616863f, 0.08277186f, -0.00755219f, 0.27051914f, 0.20312706f, 0.19745924f, 0.12845649f, 
    -0.08395562f, -0.11691362f, -0.08410572f, 0.01443019f, -0.03866962f, 0.01283105f, 0.07395246f, 0.07344143f, 
    -0.19168153f, -0.23897626f, -0.38335052f, -0.33528921f, 0.08882513f, 0.06205762f, -0.01659350f, 0.05701063f, 
    -0.07779539f, 0.02907110f, 0.06411833f, 0.02956518f, 0.35479289f, 0.27930534f, 0.06289499f, 0.13223432f, 
    -0.04815640f, -0.01136986f, 0.05379599f, 0.02818762f, 0.04951787f, 0.15458222f, 0.05737551f, -0.10692932f, 
    0.29767659f, -0.05943950f, -0.00041212f, 0.07696439f, -0.04924309f, 0.04550309f, -0.04695551f, 0.10482924f, 
    -0.06399851f, -0.03637921f, 0.14362927f, -0.09369140f, 0.15659297f, 0.15300480f, -0.15974694f, 0.02252346f, 
    -0.20724709f, 0.01759423f, -0.09900827f, 0.00748093f, -0.20364636f, -0.10775881f, -0.05925331f, -0.02287301f, 
    -0.02707673f, -0.22469719f, 0.24745491f, -0.25036672f, 0.05193521f, 0.13786371f, -0.00835657f, -0.02981959f, 
    0.00756314f, -0.00670842f, 0.05305800f, 0.02446617f, -0.10386065f, -0.17540474f, 0.04650278f, 0.27979326f, 
    -0.03315855f, 0.04632697f, 0.03405853f, 0.23979275f, -0.09270926f, -0.05475658f, -0.15178928f, 0.03117850f, 
    0.08888510f, 0.20783110f, 0.05393607f, 0.09192485f, 0.08680139f, -0.06991600f, -0.01769549f, -0.02226933f, 
    0.09853706f, 0.04902289f, -0.03408126f, 0.04950807f, -0.12084977f, -0.07124970f, -0.00492350f, -0.03124389f, 
    0.06513461f, 0.19768366f, 0.04936849f, 0.03984911f, 0.03679416f, -0.05391883f, -0.04502524f, -0.09595323f, 
    -0.07145576f, -0.17840280f, -0.01650094f, -0.05785322f, -0.13321359f, 0.06063223f, 0.11267143f, -0.02328669f, 
    0.19846568f, 0.02853958f, 0.09111614f, 0.03387317f, 0.07077920f, 0.09807597f, 0.17110862f, 0.04647848f, 
    -0.07281715f, -0.02162158f, 0.00675438f, -0.06337397f, -0.09932836f, -0.10548653f, -0.08284746f, -0.02328891f, 
    -0.02447832f, 0.04231462f, 0.13549469f, 0.04055437f, -0.01156510f, -0.02489356f, 0.02653701f, -0.01567448f, 
    0.05931105f, 0.12476268f, -0.13114262f, 0.00604566f, 0.13972433f, 0.02784899f, -0.07697181f, 0.19646828f, 
    0.03123763f, 0.12306435f, -0.01574827f, 0.27000269f, -0.04517742f, -0.02526892f, -0.21193530f, 0.25700226f, 
    0.03446796f, -0.29507968f, 0.25598010f, 0.05133924f, -0.07080941f, 0.02719170f, 0.04779576f, 0.04118310f, 
    -0.04331516f, -0.13971896f, 0.03012426f, 0.10622263f, 0.00856518f, 0.06388163f, 0.07861438f, 0.00600398f, 
    -0.09028243f, -0.07812471f, -0.00788646f, 0.00627829f, -0.03491750f, 0.03908876f, -0.11343576f, 0.03763993f, 
    0.14951992f, 0.08715023f, -0.01595032f, -0.01075314f, -0.08748825f, -0.02787255f, -0.00851236f, 0.06478257f, 
    0.22386813f, 0.22596163f, 0.13678478f, 0.05998726f, -0.07988550f, -0.10349626f, 0.01369291f, 0.05291776f, 
    0.01725356f, 0.16052468f, 0.19973496f, 0.04477446f, 0.06076686f, -0.02557629f, -0.11530058f, 0.08740837f, 
    -0.11910261f, 0.00122989f, -0.05870938f, -0.05477992f, 0.10464114f, 0.06635901f, -0.21115208f, -0.09150679f, 
    -0.18728228f, -0.08585063f, -0.03771081f, 0.01140410f, 0.06245204f, 0.05132709f, 0.14825536f, 0.03585146f, 
    -0.10730183f, 0.15531957f, 0.06574593f, -0.06728817f, 0.14612518f, -0.00278363f, 0.06274524f, 0.17446204f, 
    -0.08841373f, 0.16967432f, 0.18383729f, 0.12580183f, 0.03699997f, -0.04122211f, -0.14341669f, -0.06571826f, 
    -0.12153821f, -0.01829254f, 0.01389579f, -0.13747089f, 0.05461662f, 0.08816031f, 0.16503821f, 0.05235588f, 
    -0.19052137f, -0.05113294f, 0.00441289f, 0.00401261f, 0.01388990f, 0.08723992f, -0.03522403f, 0.04003469f, 
    0.10422458f, 0.09289718f, 0.02675241f, 0.02595650f, -0.05964191f, -0.02519403f, 0.01274803f, 0.02838872f, 
    0.09634440f, 0.08464900f, 0.07899129f, 0.14225982f, -0.01061100f, 0.02220625f, -0.06630124f, 0.24443045f, 
    -0.08788177f, -0.05705947f, 0.02666206f, 0.07326906f, -0.12267227f, 0.00087647f, 0.07153418f, 0.09923673f, 
    -0.11566705f, -0.14008248f, -0.11743423f, 0.04922939f, 0.01089616f, -0.06485090f, 0.01201424f, 0.09184127f, 
    -0.07623415f, 0.02572049f, -0.08195752f, -0.08059891f, 0.02314294f, -0.10942693f, 0.31338739f, -0.00398730f, 
    -0.13401493f, -0.00618360f, 0.08341964f, 0.07478891f, 0.11802214f, 0.04636125f, 0.06372308f, -0.08333288f, 
    0.12854233f, 0.05929381f, 0.03955408f, 0.05031458f, -0.08037692f, 0.03309120f, -0.00205293f, -0.00813083f, 
    -0.06070952f, -0.09904542f, -0.01220460f, 0.07493222f, -0.08104943f, 0.24000208f, 0.07021217f, 0.11226553f, 
    0.01416398f, 0.11158384f, 0.29603741f, -0.14385873f, 0.15028496f, 0.03523230f, 0.08423731f, 0.22198364f, 
    0.06033293f, 0.02699308f, 0.16876124f, 0.04964242f, -0.14415348f, 0.07491632f, 0.15584275f, -0.04805299f, 
    0.03969048f, 0.10962646f, 0.00084493f, -0.08147276f, 0.18972053f, -0.04052390f, 0.08605605f, -0.02837536f, 
    -0.00716709f, 0.02416168f, -0.01440049f, -0.04032856f, 0.26282805f, -0.03666610f, 0.15578385f, 0.08751177f, 
    0.04503717f, -0.06900433f, 0.06822260f, 0.02015614f, -0.08349789f, -0.03546308f, -0.05837446f, 0.00889089f, 
    -0.05541056f, -0.12209588f, -0.17861399f, 0.00424929f, -0.00172858f, 0.25109226f, 0.24607778f, 0.06963132f, 
    -0.02151173f, -0.00178009f, 0.05617400f, 0.01748730f, 0.14795284f, 0.54028004f, -0.01637982f, 0.15026863f, 
    -0.19981100f, -0.27614418f, -0.47589490f, -0.19466290f, -0.00691176f, -0.16207072f, -0.01266202f, -0.01446340f, 
    -0.02993409f, 0.06654633f, -0.10198627f, -0.00304330f, 0.04608546f, 0.02068439f, -0.00580139f, 0.03409249f, 
    0.01069279f, 0.03727625f, 0.07925716f, -0.03436777f, 0.00351898f, 0.20941852f, -0.18992746f, 0.01098861f, 
    0.10341603f, 0.11870841f, 0.10431919f, 0.05523564f, -0.06334671f, -0.14607905f, -0.09157617f, -0.04385768f, 
    -0.08334085f, -0.06584726f, 0.03941910f, 0.00460219f, -0.14849479f, -0.30834967f, -0.23516600f, -0.18436456f, 
    -0.08645172f, 0.08482456f, -0.07104644f, -0.08321727f, -0.21181500f, -0.08111340f, -0.08395077f, -0.05211549f, 
    0.22824191f, 0.18250741f, 0.02200321f, -0.03099792f, -0.17606704f, 0.17117584f, -0.22700897f, 0.16017066f, 
    0.04476980f, -0.09703039f, 0.31726855f, 0.07460371f, -0.02446917f, 0.04923199f, -0.10398018f, 0.09221452f, 
    -0.10985185f, -0.20564888f, -0.13369977f, -0.22088420f, -0.08728811f, 0.04452884f, -0.06422717f, 0.00452613f, 
    -0.04622062f, 0.02059632f, 0.33912164f, 0.31072286f, -0.00430688f, 0.12235393f, 0.17582354f, -0.00508251f, 
    -0.11438498f, -0.06060258f, 0.00786103f, -0.02772792f, -0.05515618f, 0.05034008f, 0.08346318f, 0.09040923f, 
    -0.07498869f, 0.00403865f, -0.09161963f, 0.01367646f, 0.22501917f, -0.02902148f, 0.04217980f, 0.29105133f, 
    -0.02746459f, 0.14585705f, -0.11785738f, -0.07826519f, -0.02313583f, -0.02024487f, 0.13737389f, -0.06300624f, 
    -0.01504747f, -0.00245550f, -0.00883097f, 0.03495045f, 0.29898876f, 0.05794878f, 0.06886342f, 0.17811413f, 
    0.13969155f, 0.02062967f, 0.02804838f, -0.11639386f, 0.00154719f, 0.02729445f, -0.00376605f, 0.11809012f, 
    -0.20091033f, -0.15266146f, 0.00793275f, -0.03980711f, 0.02826470f, -0.07255915f, -0.01203548f, 0.01494803f, 
    -0.22732148f, -0.16418801f, -0.05984029f, -0.11168749f, -0.38128266f, -0.28010675f, -0.00396916f, -0.23279634f, 
    0.07689133f, 0.04903238f, -0.01289884f, 0.06065022f, -0.03152608f, -0.09561037f, -0.01819146f, 0.06231903f, 
    -0.01281544f, -0.19753239f, -0.03565834f, -0.16651963f, 0.08063389f, -0.16745144f, -0.04294899f, 0.10719660f, 
    -0.11922245f, -0.03489960f, 0.03025610f, 0.02187481f, -0.30215517f, -0.14723383f, 0.04213116f, -0.01061509f, 
    0.10086976f, 0.15941744f, 0.01194561f, -0.04398362f, 0.19853853f, -0.04799697f, -0.02052339f, 0.01845425f, 
    0.00406399f, -0.00711331f, 0.03605545f, 0.01055131f, -0.02184963f, -0.01605090f, -0.01808641f, 0.01185465f, 
    0.01466694f, -0.01015988f, -0.03460200f, -0.03908362f, 0.02658453f, 0.01645928f, -0.03441840f, 0.00325631f, 
    0.00430592f, -0.02022934f, -0.01910726f, -0.04173803f, 0.00191762f, 0.01415750f, -0.01799709f, -0.03854492f, 
    -0.03695840f, -0.01239111f, -0.01423090f, -0.03018578f, 0.01805253f, -0.01738920f, 0.01261356f, -0.01022085f, 
    0.00274236f, 0.01243525f, -0.03365459f, 0.01675511f, 0.00854471f, -0.02651291f, 0.00382554f, -0.04288143f, 
    -0.04058239f, 0.01510881f, 0.02258251f, -0.00512440f, -0.03675257f, -0.03678802f, -0.01654535f, 0.02718774f, 
    -0.00049760f, -0.00547217f, 0.00973346f, 0.01938543f, -0.01776871f, -0.01429660f, -0.03880008f, -0.02761341f, 
    -0.00859964f, -0.00096165f, -0.00786386f, 0.02338231f, -0.00082410f, -0.02978968f, 0.00726973f, -0.01461779f, 
    0.01750523f, -0.02572666f, -0.00840139f, 0.01275856f, -0.01867587f, -0.01826511f, -0.01767018f, -0.02265629f, 
    -0.02366698f, -0.02086878f, -0.00050651f, -0.04308928f, -0.03861725f, -0.04406283f, 0.01693653f, -0.03200719f, 
    0.01070500f, -0.02253842f, 0.00636417f, -0.02762842f, -0.02980838f, -0.03775834f, -0.03822227f, -0.03704270f, 
    0.01844551f, 0.02080959f, -0.00395133f, -0.02447601f, 0.02570484f, -0.02808125f, 0.00819984f, 0.00265815f, 
    0.01874443f, -0.01842025f, -0.00038742f, 0.00771213f, -0.01283966f, 0.00802631f, 0.02719349f, 0.01496679f, 
    -0.01249893f, -0.04288587f, -0.02902048f, 0.00946328f, -0.03287926f, -0.03072805f, 0.01612422f, -0.00449248f, 
    -0.00869082f, 0.00571535f, -0.02060142f, 0.00958454f, 0.01267701f, -0.01978196f, -0.04177329f, -0.03618800f, 
    -0.02544038f, 0.01998645f, -0.01699792f, 0.00235288f, -0.00629945f, 0.02140842f, -0.03747015f, 0.00990692f, 
    -0.00069715f, -0.02599026f, -0.01783929f, -0.02326988f, -0.00790158f, -0.01469188f, -0.01256822f, 0.00918847f, 
    0.00047437f, 0.01979088f, -0.00553165f, 0.00433921f, -0.04339516f, -0.02193366f, -0.02931610f, -0.00044539f, 
    -0.03429031f, -0.01832980f, 0.00886755f, 0.03451473f, 0.02562856f, -0.04359856f, 0.00610285f, 0.00857841f, 
    0.01168207f, -0.02096372f, -0.02388190f, -0.03603646f, -0.01343212f, 0.01394726f, 0.01381903f, -0.02235551f, 
    -0.03106369f, -0.01578324f, 0.01442557f, 0.02220115f, 0.02718638f, -0.04277335f, 0.01256476f, 0.02319112f, 
    0.00931662f, -0.03661687f, -0.02096238f, -0.03748775f, -0.02885717f, -0.01108678f, 0.02429434f, 0.00116888f, 
    -0.00598784f, -0.03350452f, -0.03360785f, 0.02216864f, 0.01160255f, -0.01150030f, 0.02787257f, -0.00798327f, 
    0.01871122f, -0.01443778f, 0.02370711f, -0.02126315f, -0.00323216f, -0.01093448f, 0.00169801f, 0.02225513f, 
    0.00186366f, 0.00676707f, 0.01289654f, -0.00700541f, 0.01383218f, 0.01143109f, 0.00448766f, -0.03133415f, 
    -0.04096390f, -0.03374898f, -0.01760236f, -0.03971530f, 0.02280403f, 0.02147730f, 0.00455570f, 0.00815324f, 
    -0.03175684f, -0.03191917f, 0.01302140f, -0.02564972f, 0.02503439f, -0.01708280f, 0.01943295f, -0.01679893f, 
    -0.00416574f, -0.03945095f, -0.01057852f, -0.01904184f, -0.02719231f, 0.02274872f, -0.00729402f, 0.00214287f, 
    -0.03101436f, -0.00800610f, 0.02325207f, -0.02935690f, -0.03491392f, -0.01293493f, 0.00286759f, 0.03308303f, 
    -0.03246683f, 0.00016538f, 0.01386837f, -0.00954066f, -0.02625307f, -0.01073856f, 0.01112481f, -0.03612849f, 
    -0.03973536f, -0.02154599f, -0.00734776f, -0.00827853f, 0.02370425f, 0.00130143f, 0.01226260f, 0.01083669f, 
    -0.03689739f, -0.00030423f, 0.00183551f, -0.04211460f, -0.02928992f, -0.00699782f, -0.03557007f, 0.02592740f, 
    0.01251274f, -0.00131730f, 0.00995770f, -0.00353858f, -0.03290458f, -0.02600379f, -0.02007532f, 0.00663750f, 
    -0.02963590f, -0.01111666f, -0.02278214f, -0.02373100f, -0.02854083f, -0.03291190f, -0.03487076f, -0.00368784f, 
    -0.01644378f, -0.03844304f, 0.01246955f, -0.04016452f, 0.02664855f, 0.02732324f, 0.02023083f, -0.01785096f, 
    -0.02521149f, -0.01546491f, -0.00012659f, -0.02697781f, -0.04077034f, 0.00114606f, -0.04053229f, -0.01081596f, 
    0.00416372f, -0.02485960f, 0.01528101f, 0.02457259f, -0.00299320f, -0.00914361f, -0.00438105f, -0.02028134f, 
    -0.03130921f, 0.02200365f, -0.02085541f, 0.01687980f, -0.00984505f, -0.00490694f, 0.00829188f, -0.02000346f, 
    0.01628274f, -0.03277479f, -0.02636969f, -0.02927499f, -0.02136389f, 0.01363864f, 0.00738494f, 0.02153587f, 
    0.01816120f, -0.00305235f, -0.02147179f, -0.01542435f, -0.01876455f, 0.00270334f, -0.00664608f, -0.02214779f, 
    0.01289862f, -0.00319103f, -0.03653244f, -0.01022703f, -0.01394606f, -0.03742318f, 0.00921147f, 0.00145306f, 
    -0.01912461f, 0.01404218f, -0.03793350f, -0.01975696f, -0.03525711f, 0.02702587f, 0.02704842f, 0.02333565f, 
    -0.00240410f, 0.00447115f, 0.00262014f, -0.04029234f, -0.01994183f, -0.03924290f, 0.01852191f, -0.00059696f, 
    0.01347064f, -0.00619600f, -0.03798958f, 0.00968622f, -0.03303381f, -0.02611659f, 0.02163260f, -0.03340442f, 
    0.00087277f, -0.01922842f, 0.02008902f, 0.03526329f, -0.00255509f, -0.03989270f, 0.01891184f, -0.00385115f, 
    0.02843156f, 0.03513130f, 0.00864858f, -0.01877905f, -0.03464213f, 0.02693642f, -0.01713286f, 0.00058347f, 
    -0.00900259f, 0.00048119f, -0.03269144f, 0.00330859f, 0.00156953f, -0.04299497f, -0.00827937f, -0.00108817f, 
    -0.00937446f, -0.01863566f, 0.02235459f, 0.00874188f, 0.00349851f, 0.02190032f, 0.00077257f, -0.01179351f, 
    -0.01558482f, 0.00725282f, -0.02576988f, 0.00217008f, 0.02747239f, -0.00257737f, 0.01923206f, -0.01597006f, 
    -0.01332067f, 0.00794697f, 0.02215276f, 0.01612526f, 0.02169974f, 0.02124558f, 0.01180042f, -0.02800385f, 
    -0.03968504f, -0.01882093f, -0.02454556f, 0.01763582f, 0.00749558f, -0.00395375f, -0.02519180f, 0.01432249f, 
    -0.00458590f, 0.01104404f, 0.01285082f, -0.00902555f, 0.01454351f, -0.00445595f, -0.01064265f, 0.02343898f, 
    0.01999218f, 0.01852689f, 0.00231547f, -0.00040238f, -0.02575545f, 0.02194032f, -0.04133510f, -0.00181307f, 
    -0.02375906f, -0.03625735f, 0.00807669f, -0.02693579f, -0.02747495f, -0.00251503f, -0.03827128f, -0.03117723f, 
    -0.00344227f, -0.04073513f, -0.01891301f, -0.03300400f, -0.01434731f, 0.00509890f, -0.02350955f, -0.03432222f, 
    0.00601474f, 0.00702578f, 0.00416319f, -0.00922530f, -0.02234012f, 0.01062252f, 0.00077550f, 0.02596310f, 
    -0.03457903f, -0.02425735f, -0.03160646f, 0.01622454f, -0.01540980f, -0.01012452f, -0.01029879f, -0.04256186f, 
    -0.01501623f, -0.03286471f, 0.02656625f, -0.00462182f, -0.00631308f, -0.01214317f, -0.00164179f, -0.02843664f, 
    -0.04353546f, -0.04011546f, 0.02300644f, -0.02039602f, 0.01012501f, 0.02165645f, -0.00304210f, -0.03572436f, 
    0.02514130f, -0.01029686f, -0.00763340f, -0.02363081f, 0.01213372f, -0.03320442f, -0.02083899f, 0.00558914f, 
    -0.00377407f, -0.03282102f, 0.02244481f, -0.00245503f, -0.01871642f, 0.00800789f, -0.00306913f, -0.02081920f, 
    -0.01170245f, -0.01566406f, 0.00076393f, -0.03376634f, -0.03674068f, 0.01656065f, -0.03884424f, 0.01027138f, 
    -0.03050403f, -0.01652634f, -0.01093233f, -0.02001230f, -0.00860386f, -0.02783447f, -0.01654809f, -0.01052413f, 
    0.01107315f, 0.01071488f, -0.01191286f, -0.03513187f, 0.02008421f, 0.00916782f, -0.03170376f, 0.01717508f, 
    -0.00721234f, 0.02338369f, 0.01674223f, 0.00461072f, 0.01047441f, 0.01691451f, 0.02321894f, -0.04268351f, 
    -0.03753572f, -0.02417357f, -0.02717988f, 0.01286115f, -0.04253259f, -0.03353680f, -0.02428441f, 0.02776268f, 
    -0.03421440f, -0.00693901f, 0.02255175f, -0.03406457f, 0.02170045f, -0.02698187f, -0.04068209f, 0.03071089f, 
    -0.00353498f, -0.00520597f, 0.02740949f, -0.03205800f, -0.00661059f, 0.00993908f, -0.01352393f, -0.04302927f, 
    -0.02180347f, -0.01947828f, -0.01435892f, -0.03371057f, -0.01683673f, -0.00850462f, -0.02420588f, -0.03090615f, 
    0.00982437f, -0.01031985f, -0.00598997f, 0.00416640f, 0.01901848f, 0.00995573f, -0.02018279f, 0.01746238f, 
    -0.04117795f, 0.01533251f, 0.00581276f, -0.01410628f, -0.02353780f, -0.02017502f, -0.01178369f, -0.01071407f, 
    0.02255274f, -0.04060144f, -0.00968516f, -0.01916948f, -0.04008229f, 0.00712070f, -0.02820183f, -0.02571184f, 
    -0.03131932f, -0.01642336f, -0.00943593f, -0.02923502f, -0.01041740f, -0.01061528f, -0.01449710f, -0.02189458f, 
    0.01496148f, -0.01988410f, 0.01687789f, -0.00234192f, 0.00588688f, -0.00223140f, 0.00962182f, -0.03720048f, 
    -0.00659637f, -0.03395058f, -0.02362529f, 0.00535082f, 0.00193808f, 0.02588710f, 0.00126349f, -0.01173004f, 
    0.01083553f, 0.00579205f, -0.01469429f, 0.01644098f, -0.02301118f, -0.00491014f, 0.01428942f, -0.03987753f, 
    0.01652978f, 0.00445810f, -0.03860110f, -0.03491527f, -0.03087247f, -0.00198432f, 0.02639646f, -0.02291102f, 
    0.01940943f, 0.00387205f, -0.03374485f, -0.02161179f, 0.00215318f, 0.01714621f, -0.03269718f, -0.03747180f, 
    -0.01384345f, 0.01379889f, -0.02693009f, -0.00593051f, -0.02724364f, 0.02246636f, -0.03157359f, -0.03748310f, 
    0.00042472f, 0.00336144f, 0.01283342f, -0.02330459f, -0.02677320f, 0.01091908f, 0.02629994f, -0.02950155f, 
    -0.03186277f, -0.04318823f, 0.02032957f, 0.00959019f, 0.01932692f, -0.01112083f, -0.03343928f, -0.02922019f, 
    -0.01124661f, 0.02499282f, 0.00483645f, -0.01564762f, -0.02971571f, 0.01304280f, -0.00696627f, -0.00376571f, 
    -0.00494415f, 0.00656533f, -0.01060179f, 0.01288503f, -0.01930818f, -0.00079168f, 0.00737602f, -0.00299881f, 
    0.01925579f, -0.01392428f, -0.03238602f, 0.00160326f, -0.00974682f, 0.00919251f, -0.02191681f, 0.00943431f, 
    -0.00304224f, -0.01615151f, -0.02999168f, -0.00011791f, -0.02010800f, -0.04270106f, 0.01264154f, -0.04409928f, 
    -0.04217144f, -0.03372711f, 0.00960204f, 0.00518135f, -0.03526868f, -0.01415903f, 0.00976649f, -0.03499969f, 
    -0.00956319f, 0.01346479f, -0.00705837f, -0.02505833f, -0.03539881f, -0.02953768f, -0.04273650f, 0.02579273f, 
    -0.03637756f, -0.01610595f, -0.03146214f, 0.00326555f, 0.01399751f, -0.02292844f, -0.02035589f, -0.01967347f, 
    0.02021333f, -0.03564665f, -0.03648590f, -0.00856593f, -0.03310170f, -0.03205330f, 0.02772677f, -0.03594287f, 
    0.01552674f, -0.02977923f, -0.00601204f, 0.00190811f, 0.00810080f, -0.04186205f, 0.02792687f, -0.01031682f, 
    0.01699430f, -0.01975385f, -0.01560174f, -0.00045362f, 0.01097823f, 0.00137622f, -0.03860401f, 0.02050153f, 
    -0.01442435f, -0.02234970f, 0.00439946f, -0.02807232f, -0.03424217f, -0.01126238f, -0.00370409f, 0.02462992f, 
    -0.03921147f, -0.00483633f, 0.00138035f, -0.04355322f, -0.03535508f, -0.01291948f, -0.01444874f, 0.00683366f, 
    -0.00876741f, 0.02126035f, 0.01069478f, 0.01569610f, -0.03367619f, 0.01435656f, -0.01042301f, 0.02305285f, 
    -0.00299494f, -0.02673716f, -0.03469283f, -0.03304852f, 0.01235168f, 0.00692176f, -0.02279970f, 0.00623151f, 
    -0.00033409f, -0.02707370f, -0.01085427f, -0.03671430f, 0.00453987f, -0.01921368f, 0.02771381f, 0.01618325f, 
    -0.00970737f, 0.11453325f, -0.07513619f, 0.04209441f, 0.00101128f, -0.09340284f, -0.06035355f, -0.04458743f, 
    -0.01965881f, -0.08788881f, 0.05681186f, -0.08134850f, 0.06561607f, -0.16847417f, 0.16003892f, -0.09312044f, 
    0.00146116f, -0.00935793f, -0.14855450f, -0.07997224f, -0.00888997f, 0.14761890f, 0.03185836f, -0.01000158f, 
    -0.05993373f, 0.26711020f, -0.13393837f, 0.05263585f, 0.08914930f, 0.06972062f, -0.07627697f, 0.02701719f, 
    -0.13896176f, 0.02871806f, -0.08964226f, -0.00090335f, -0.00835396f, -0.07973596f, 0.29105261f, -0.04428579f, 
    0.10153531f, 0.09833780f, 0.03952961f, -0.01656498f, -0.00872603f, 0.03520540f, 0.16979879f, 0.07713013f, 
    0.09289438f, 0.11427672f, -0.06527520f, 0.05363810f, 0.09462756f, -0.05631092f, 0.01183153f, -0.05311910f, 
    -0.01382410f, 0.21638872f, -0.01769357f, 0.25056106f, -0.13028751f, -0.13739495f, -0.09345378f, 0.01527130f, 
    -0.02583491f, -0.01106616f, 0.11125503f, 0.00950840f, 0.04822238f, 0.05376513f, 0.05073533f, -0.03879219f, 
    0.13046706f, 0.04215100f, 0.01812541f, 0.08811088f, -0.00275266f, -0.05286438f, -0.04029037f, 0.02986957f, 
    0.08311072f, 0.03011727f, 0.23176603f, -0.01258961f, -0.18960568f, -0.15245157f, -0.01293870f, 0.06703097f, 
    0.09857760f, 0.01409716f, 0.09796035f, 0.06277324f, -0.14065419f, -0.03058065f, -0.07672571f, -0.03203188f, 
    -0.11415543f, -0.07852779f, -0.07854533f, -0.03132291f, -0.06134774f, 0.03469655f, -0.07860983f, 0.10457358f, 
    0.01099219f, -0.03210966f, 0.02493844f, -0.03683915f, -0.10464918f, 0.14464426f, -0.05273934f, 0.09478885f, 
    -0.08555983f, -0.05816250f, -0.03841040f, 0.03841237f, -0.03721261f, -0.05504298f, 0.09640481f, 0.11895639f, 
    0.10040503f, -0.14733528f, 0.10946201f, 0.03942823f, 0.03262660f, 0.17311078f, 0.06164128f, 0.03700937f, 
    -0.08558623f, -0.07672058f, 0.17708528f, 0.01524278f, -0.27791783f, -0.16938920f, -0.08425674f, -0.03058728f, 
    0.04663157f, -0.01218495f, -0.11572678f, -0.08361688f, 0.08469385f, 0.04816908f, 0.06726577f, 0.03129485f, 
    -0.13636269f, 0.08941773f, -0.05381699f, -0.00704046f, -0.21952257f, -0.21100733f, -0.08774613f, -0.14285691f, 
    -0.15904362f, -0.16043299f, 0.02696557f, -0.01482584f, -0.35380146f, 0.28147468f, -0.02138435f, 0.23077342f, 
    0.07996699f, 0.08271530f, -0.16255571f, 0.08019984f, 0.07176004f, 0.01310520f, 0.08613755f, 0.19574898f, 
    0.03540049f, -0.01199240f, -0.09053231f, 0.06977067f, 0.06922663f, 0.00987518f, 0.12930726f, 0.16665171f, 
    0.21568713f, 0.06988563f, 0.04133808f, 0.06419110f, 0.09506924f, 0.00862380f, -0.15278834f, -0.07606382f, 
    -0.03884461f, -0.05479184f, 0.01464544f, 0.10729177f, 0.06380414f, 0.16850537f, -0.24722660f, -0.08866266f, 
    0.13222785f, 0.10572433f, 0.14954770f, -0.12773818f, 0.02646065f, -0.09316699f, -0.09436167f, -0.09221800f, 
    0.03030402f, 0.03435974f, 0.13784546f, 0.12465145f, -0.03631983f, -0.12133154f, 0.24851407f, 0.02782148f, 
    -0.05248605f, -0.01942221f, -0.09620748f, 0.00423560f, 0.09791034f, 0.03790148f, 0.19016013f, 0.13033490f, 
    -0.14663799f, 0.15338962f, 0.04480136f, -0.08091513f, -0.00218969f, 0.00424259f, 0.06179736f, 0.15950587f, 
    0.03601279f, 0.01194775f, 0.01403089f, -0.04271615f, 0.04737312f, -0.16992207f, 0.36108205f, 0.02109757f, 
    0.07440178f, 0.08318090f, 0.03727640f, -0.03218919f, -0.04962128f, 0.03704499f, 0.02133195f, 0.05675275f, 
    -0.10719602f, -0.12785411f, -0.04176982f, -0.00571581f, 0.07523364f, 0.04674019f, 0.02351929f, -0.07727347f, 
    -0.00404966f, -0.01335630f, 0.01334686f, 0.11122975f, 0.39137721f, -0.03165227f, 0.35743248f, 0.24863331f, 
    -0.02266215f, -0.03859908f, 0.03713818f, 0.08535785f, 0.05794255f, 0.00690010f, 0.16751245f, 0.07508092f, 
    0.32371965f, 0.04283198f, -0.19316925f, -0.18492769f, 0.07489584f, -0.05745213f, 0.09379281f, 0.08447637f, 
    -0.01022439f, 0.10074927f, 0.00238238f, 0.10292623f, -0.23322028f, -0.12885684f, -0.02127375f, -0.08452112f, 
    0.16866980f, 0.01727683f, 0.08851592f, 0.05773864f, -0.10505278f, 0.14665927f, 0.05424239f, -0.06169549f, 
    -0.03259571f, -0.36884400f, 0.08481015f, -0.09529361f, 0.02001906f, 0.02650591f, 0.07756414f, 0.15882452f, 
    -0.14317068f, 0.03878881f, -0.09278254f, -0.01925233f, -0.04754826f, -0.03282699f, 0.16476126f, 0.09453067f, 
    0.15665522f, -0.01820404f, 0.11528827f, -0.01790899f, -0.06886011f, -0.02195181f, 0.02063713f, 0.06492754f, 
    0.00876858f, 0.05817079f, 0.23318106f, 0.18705209f, -0.04395323f, -0.00462602f, 0.01807672f, 0.00999639f, 
    0.16381919f, -0.00227847f, 0.14537576f, 0.18277754f, -0.19521432f, -0.00591796f, -0.04112505f, 0.02197730f, 
    -0.08685362f, -0.00756208f, -0.02234567f, 0.07939047f, -0.02040249f, -0.04541010f, -0.06222232f, -0.12339911f, 
    -0.11181251f, 0.13433896f, -0.00112894f, -0.02965674f, 0.00151385f, -0.00518444f, -0.07330240f, -0.06316486f, 
    -0.10851855f, -0.12777978f, 0.03788375f, -0.17539014f, -0.02999254f, 0.06089118f, -0.24671821f, -0.17629243f, 
    0.04850179f, -0.05133842f, -0.09170661f, -0.14492361f, -0.15174985f, 0.03118056f, -0.07363204f, -0.09741385f, 
    -0.11319327f, 0.02582388f, 0.08000728f, 0.18639487f, -0.01420843f, -0.14971252f, -0.07808308f, -0.10707802f, 
    0.09001841f, 0.11374349f, 0.09646806f, 0.18416707f, 0.18363649f, 0.03489764f, 0.29053542f, 0.14854451f, 
    0.01708762f, -0.01289452f, 0.02580032f, 0.13412775f, -0.15065992f, 0.06203296f, 0.11741606f, 0.13111515f, 
    -0.21236706f, 0.14297801f, 0.06438234f, -0.07306267f, -0.04388866f, 0.05691846f, -0.06231521f, 0.02551962f, 
    0.06449379f, 0.13418625f, 0.04709486f, 0.01303539f, -0.05560078f, -0.03139304f, -0.06496654f, -0.08635054f, 
    -0.08334360f, -0.11901786f, -0.10228309f, -0.10137457f, -0.19129641f, -0.11947376f, -0.09498355f, -0.13238809f, 
    0.10062208f, 0.20857933f, 0.06226618f, -0.17268957f, -0.03813482f, -0.01986302f, -0.01481338f, 0.00343912f, 
    -0.06358751f, -0.02845566f, -0.06721334f, -0.12223235f, -0.10380432f, -0.03584721f, 0.18232481f, -0.05289475f, 
    0.05509383f, 0.06264038f, -0.00535247f, -0.03386527f, -0.01412006f, 0.01423899f, 0.07530179f, -0.02982991f, 
    -0.06992177f, -0.11980804f, -0.12010981f, -0.07442941f, -0.04375732f, -0.00510440f, 0.04206106f, -0.10723815f, 
    -0.10914325f, 0.10739037f, 0.04080985f, 0.02114834f, -0.11224810f, 0.17072311f, 0.04081211f, 0.15953538f, 
    -0.03494143f, 0.09630206f, 0.04358531f, 0.11538530f, -0.00918115f, 0.12788737f, 0.16398494f, 0.01260042f, 
    0.12859118f, 0.09218960f, 0.03475125f, 0.12717390f, -0.01681207f, -0.00838841f, 0.13012920f, 0.08419062f, 
    0.10106444f, 0.04861315f, -0.01036454f, 0.04763387f, 0.24365626f, 0.24405046f, -0.18734431f, 0.17263624f, 
    0.04631208f, 0.06619153f, 0.01066423f, 0.09500986f, -0.01012538f, 0.06083983f, 0.14021239f, 0.07492267f, 
    0.19608805f, 0.13450819f, 0.12488771f, -0.19274090f, -0.04223017f, -0.05405398f, -0.04100233f, -0.04968964f, 
    -0.13702245f, -0.05754188f, 0.04950591f, -0.07185037f, 0.15841866f, -0.08619484f, -0.02347643f, 0.02277265f, 
    -0.00794839f, 0.04279267f, -0.02488842f, 0.02376840f, -0.00437214f, -0.03816136f, 0.02528463f, -0.12716036f, 
    -0.26909137f, -0.03889381f, 0.00945015f, -0.02929985f, -0.07577989f, -0.01070238f, -0.15090767f, -0.08605687f, 
    0.09684766f, -0.04235205f, -0.05593256f, -0.04705074f, -0.30739358f, 0.10588832f, 0.06070065f, -0.07520305f, 
    -0.06686004f, 0.07157943f, -0.05111991f, 0.17165953f, 0.07679950f, 0.14307447f, -0.00870106f, 0.06918608f, 
    -0.21732526f, -0.05632998f, -0.08859682f, 0.04834415f, 0.00238266f, -0.08162587f, -0.12192324f, -0.10630765f, 
    -0.01737075f, 0.04709913f, -0.01735458f, 0.02140023f, -0.08679294f, 0.11131959f, -0.18672901f, 0.15441947f, 
    0.08935980f, 0.08566798f, 0.04221147f, 0.03333229f, 0.02122846f, 0.10007059f, -0.03314257f, -0.13442451f, 
    0.01896423f, -0.01828655f, 0.00368072f, -0.04587851f, 0.01745594f, 0.00959696f, -0.03756178f, 0.07062522f, 
    -0.00100418f, -0.04773018f, 0.03888382f, -0.02499768f, 0.08854943f, 0.03601598f, 0.16838135f, -0.05917322f, 
    -0.03933966f, 0.17418453f, 0.12006651f, 0.04399747f, 0.04887780f, 0.03929096f, -0.03302073f, -0.07028677f, 
    -0.26948428f, -0.12799495f, 0.00165874f, -0.10352834f, -0.06739184f, -0.13240978f, -0.07919421f, -0.10612310f, 
    0.00996530f, 0.11308491f, 0.01386174f, 0.01961688f, 0.14197220f, 0.14202137f, 0.01763141f, 0.14088209f, 
    -0.00609420f, -0.01900121f, 0.02131528f, 0.07076598f, 0.05379513f, -0.06656330f, 0.08095970f, 0.10689643f, 
    -0.00114649f, -0.17666511f, -0.05163671f, -0.06379379f, 0.06111203f, -0.00579019f, 0.04035589f, -0.04200856f, 
    0.04440139f, 0.05213904f, 0.10593497f, 0.06223411f, -0.15325166f, 0.16081731f, -0.15648843f, -0.07257832f, 
    0.00266754f, -0.02824406f, -0.06929153f, 0.06201579f, -0.00057928f, 0.00753263f, -0.00368618f, -0.19271892f, 
    -0.06071316f, -0.01826320f, -0.00328189f, -0.05249395f, -0.03787114f, -0.00405812f, 0.02035033f, -0.13330121f, 
    0.07013765f, -0.05340850f, 0.03229122f, 0.07004189f, -0.15417455f, -0.05058543f, 0.00389897f, -0.06240583f, 
    0.03962787f, 0.05269786f, 0.12116728f, -0.02622955f, -0.01079768f, 0.02061074f, 0.08916897f, -0.02912528f, 
    -0.11680865f, -0.04465777f, 0.11770722f, 0.05637646f, -0.00289046f, 0.06378628f, 0.06632338f, -0.00685302f, 
    0.14061798f, 0.02832406f, -0.04410495f, -0.14625172f, -0.27314728f, -0.13540193f, -0.08189099f, 0.08991570f, 
    0.13549383f, 0.00458216f, -0.14246222f, -0.13760254f, 0.07941986f, -0.05654338f, 0.16517392f, 0.08404644f, 
    -0.03504476f, -0.01634096f, -0.16687746f, -0.13472182f, -0.03568508f, 0.11257308f, -0.05865639f, 0.16952313f, 
    -0.00957438f, 0.04489753f, 0.08042850f, -0.02363262f, -0.02979461f, -0.10834847f, -0.02061867f, 0.02761120f, 
    -0.05915588f, 0.14346351f, -0.01873076f, -0.13900879f, 0.00307492f, -0.04066401f, -0.12298467f, -0.17281905f, 
    -0.05595557f, -0.16693519f, 0.20703948f, -0.03402105f, -0.05402496f, 0.11907888f, 0.04790805f, 0.04205506f, 
    0.00537917f, -0.03245408f, 0.11454501f, 0.13966823f, -0.05289643f, 0.17601612f, -0.03030181f, 0.21150990f, 
    0.08371925f, 0.24093308f, 0.06377612f, 0.20818366f, -0.01991863f, 0.07723298f, 0.06203987f, 0.02143706f, 
    -0.22395818f, -0.18144298f, -0.11859666f, -0.07206029f, -0.02889459f, -0.01211674f, 0.09885944f, 0.00149613f, 
    -0.15716714f, -0.03519557f, -0.13492124f, 0.08542393f, -0.08626430f, -0.26393631f, 0.13190530f, -0.13073076f, 
    0.06485880f, 0.02621859f, -0.02228648f, -0.15409873f, 0.12547079f, 0.00631364f, 0.06498325f, 0.05882637f, 
    -0.09124124f, -0.08471307f, 0.02466987f, -0.00137100f, 0.05750783f, -0.05894745f, 0.06520740f, -0.05360040f, 
    0.00627659f, 0.06764254f, 0.00998378f, 0.03992414f, -0.06007284f, -0.20327984f, -0.14007489f, 0.03742727f, 
    0.06917914f, 0.16293825f, -0.00325620f, -0.02355777f, -0.17345358f, -0.00908109f, 0.02360775f, -0.06143700f, 
    -0.00789558f, 0.02149837f, 0.01684412f, 0.02953674f, -0.01418358f, -0.00776151f, -0.03700967f, 0.02984114f, 
    -0.00478752f, -0.01895795f, 0.03503269f, 0.01941104f, -0.02631222f, -0.01725006f, -0.03737525f, -0.04107063f, 
    0.02909533f, 0.01146818f, -0.03868819f, 0.01832311f, 0.01842308f, 0.01772759f, -0.01115564f, -0.01438284f, 
    0.00136205f, 0.01105794f, -0.02238306f, -0.01803658f, -0.02658172f, 0.02570111f, -0.03396010f, 0.02148814f, 
    -0.01729937f, -0.03434822f, -0.01102823f, -0.03553690f, -0.00541286f, -0.00546362f, 0.00291489f, -0.01305820f, 
    0.02801382f, 0.01210914f, -0.00395330f, -0.01816416f, 0.01696749f, -0.03532720f, 0.02620314f, -0.00328276f, 
    -0.02398748f, 0.00127120f, 0.02892659f, -0.01294818f, 0.02081887f, 0.00809829f, -0.02576253f, -0.01322206f, 
    0.03934983f, -0.01268012f, -0.00772159f, -0.00424611f, 0.02320874f, -0.03574349f, 0.00265055f, -0.02341356f, 
    0.02535490f, 0.00708284f, -0.01764761f, 0.02812713f, -0.02901125f, -0.00507391f, 0.01507215f, 0.02619121f, 
    0.01640957f, 0.01586546f, -0.04168975f, -0.03197056f, 0.00871238f, -0.01427748f, -0.03047077f, -0.00322508f, 
    -0.00680559f, 0.02564066f, 0.01847940f, -0.01872981f, -0.01580317f, 0.02837780f, 0.01649531f, 0.00075400f, 
    0.00117302f, -0.01982859f, 0.03183867f, 0.02509334f, -0.02941831f, 0.02409386f, 0.00693222f, 0.02067945f, 
    -0.02910596f, -0.04748460f, -0.02539395f, -0.02419533f, -0.03833919f, -0.04232496f, -0.03406417f, -0.01036120f, 
    -0.00904088f, -0.03817843f, -0.01931924f, 0.00737819f, -0.00333583f, -0.00107675f, 0.01728774f, -0.04901311f, 
    0.01563937f, -0.00262587f, -0.03016166f, 0.01091536f, 0.03939823f, -0.00103591f, 0.03786424f, -0.03558348f, 
    0.02171855f, -0.02861598f, -0.00853488f, -0.02996138f, 0.00423344f, -0.00665334f, 0.02570903f, 0.00889607f, 
    -0.04130144f, 0.02115597f, -0.02738696f, 0.01969752f, -0.02061686f, -0.00412356f, -0.03388899f, 0.00364754f, 
    -0.02782748f, -0.02197449f, -0.03068457f, -0.04015284f, 0.02014285f, -0.02513218f, -0.03399951f, -0.00962999f, 
    0.00476283f, -0.02764571f, -0.00568585f, -0.00719822f, -0.03388525f, -0.00750212f, -0.01347616f, 0.02583353f, 
    -0.01866434f, 0.03948644f, 0.01401272f, -0.02376102f, -0.02643573f, -0.03176927f, 0.02390974f, -0.02844036f, 
    0.02686974f, -0.03030408f, -0.00770689f, -0.00638693f, 0.02918346f, -0.03947537f, -0.01370515f, -0.00669656f, 
    -0.01314865f, -0.00542889f, 0.01209601f, 0.01830157f, 0.02590027f, -0.03855035f, -0.02519382f, -0.00539930f, 
    0.02950139f, 0.00797200f, 0.02565507f, -0.03732603f, 0.00357545f, -0.00719364f, 0.03010093f, 0.01035299f, 
    -0.03646856f, -0.02457523f, -0.02302456f, -0.00807069f, -0.02094398f, 0.02715481f, 0.00231146f, -0.02556349f, 
    -0.01554436f, -0.00692450f, 0.01512789f, 0.00202876f, 0.01139654f, 0.01228493f, -0.01323330f, -0.02030571f, 
    0.01605195f, -0.02880005f, -0.03954644f, 0.00791038f, 0.02389580f, 0.02375259f, -0.04362323f, -0.03134838f, 
    -0.01895458f, -0.00999600f, 0.00334760f, 0.01946309f, -0.02157515f, 0.01642135f, 0.00089844f, -0.03480039f, 
    -0.04163834f, 0.00648718f, -0.02387171f, -0.01336113f, -0.01753484f, -0.01958613f, 0.00143300f, -0.00451898f, 
    -0.00327769f, 0.02609951f, 0.03283680f, 0.00314154f, -0.04083632f, -0.00391941f, 0.00812066f, 0.02083989f, 
    0.01561145f, -0.03110687f, -0.04112085f, -0.00535661f, -0.01273989f, 0.00200211f, -0.01851526f, -0.04086654f, 
    -0.01881800f, 0.00792602f, -0.03991668f, -0.01968786f, 0.01840063f, 0.03000686f, -0.01603151f, 0.01833752f, 
    0.02816361f, -0.03406349f, 0.00685244f, 0.02760164f, 0.00050299f, 0.00402918f, 0.00891463f, -0.02278133f, 
    -0.01411817f, -0.02128830f, -0.04705188f, 0.00158396f, 0.01287150f, 0.01183733f, 0.00340113f, -0.00534453f, 
    0.00485402f, -0.02814794f, 0.00981808f, 0.03014928f, 0.02280253f, 0.01721293f, -0.01684930f, 0.01506334f, 
    -0.03686513f, -0.00555892f, 0.02465612f, -0.02812911f, -0.01660706f, 0.02459196f, -0.00725461f, 0.01226044f, 
    -0.01612228f, -0.00671707f, 0.01486117f, 0.03356591f, 0.00595109f, -0.00682958f, -0.02782240f, 0.01643866f, 
    0.00881010f, 0.00110372f, 0.01229563f, 0.00266780f, -0.04042023f, 0.02957748f, -0.00349948f, -0.04268670f, 
    -0.04512502f, -0.01391983f, 0.02292395f, -0.03870294f, -0.03317573f, -0.03868841f, 0.02072100f, -0.03665764f, 
    0.02356608f, 0.00005556f, -0.00461426f, 0.02331787f, -0.02350768f, -0.01443225f, -0.00213881f, -0.02652917f, 
    -0.03718678f, 0.00303207f, -0.00653727f, 0.00184529f, -0.02373510f, -0.02668818f, -0.00377566f, -0.03780214f, 
    0.02285332f, 0.00076183f, 0.00067467f, -0.01844678f, -0.00878315f, -0.02241297f, -0.03787206f, 0.01840693f, 
    0.00671988f, -0.02609617f, -0.01147618f, -0.03125484f, -0.00076409f, 0.02055078f, -0.01308508f, -0.03233469f, 
    -0.01664465f, -0.02352660f, -0.02787250f, -0.03717825f, -0.01779268f, 0.01976714f, -0.02246374f, -0.02860869f, 
    -0.00432240f, 0.01488591f, -0.01317060f, -0.00175274f, -0.02182758f, -0.03015473f, -0.01122384f, 0.00061347f, 
    -0.00004570f, -0.01122030f, -0.02637912f, -0.02883879f, -0.00233978f, -0.00445484f, -0.02210532f, -0.01839906f, 
    0.02177861f, 0.00024240f, -0.01672174f, 0.00433775f, -0.02029637f, 0.00805517f, 0.02328452f, -0.01395972f, 
    0.01520420f, -0.01123632f, 0.03077381f, 0.00869842f, -0.00321241f, -0.00225138f, -0.02244944f, -0.00260567f, 
    0.01650077f, -0.01210570f, -0.01428481f, 0.00415734f, 0.03032552f, 0.01107436f, 0.00063512f, 0.00277401f, 
    0.00362490f, 0.00354515f, 0.02181003f, -0.03866914f, 0.01089328f, -0.00640880f, 0.02203832f, 0.02714894f, 
    -0.03609838f, 0.02735680f, -0.00218753f, -0.02623710f, 0.02063469f, -0.02486763f, 0.00365081f, 0.02475903f, 
    0.02845239f, -0.03427223f, -0.01597804f, 0.02470066f, 0.00461022f, 0.02592216f, -0.02224639f, 0.02973311f, 
    0.00340676f, -0.02934565f, -0.00058289f, -0.01470586f, -0.00221847f, 0.00002678f, 0.02426292f, -0.03153142f, 
    0.02975319f, 0.01172999f, 0.01101175f, -0.01303468f, -0.02303492f, -0.03147035f, 0.01060012f, -0.02879540f, 
    0.00835006f, 0.01848145f, -0.00265386f, -0.02906396f, 0.02834174f, 0.02811949f, -0.00228809f, -0.03720866f, 
    -0.03792252f, 0.00982435f, -0.00676581f, 0.04477535f, -0.00467463f, -0.02663199f, 0.00201998f, -0.02959402f, 
    -0.00381065f, -0.01107385f, 0.01959517f, -0.00253594f, 0.00175525f, 0.00759031f, -0.00200987f, 0.02144329f, 
    0.03011062f, 0.00345166f, 0.00721405f, 0.01506859f, 0.03054674f, 0.02847063f, -0.00178622f, -0.02365836f, 
    -0.03924037f, -0.01574353f, 0.02047856f, 0.00588200f, 0.01029507f, -0.03190193f, 0.00436688f, 0.00769221f, 
    0.02688782f, -0.01404503f, -0.00399164f, -0.02299206f, 0.02913067f, -0.00262617f, 0.01516547f, 0.00971668f, 
    0.02652850f, 0.01689700f, 0.00064063f, -0.03772590f, 0.00578448f, -0.04527749f, -0.02748244f, -0.00068259f, 
    -0.03251321f, 0.00385156f, 0.01207391f, 0.02664033f, -0.00697786f, -0.00619345f, -0.02214430f, -0.00613793f, 
    0.02695352f, -0.02236235f, 0.00688882f, 0.01574126f, 0.00175792f, -0.04131316f, -0.01149754f, 0.00636190f, 
    -0.00680149f, -0.03063299f, 0.00968682f, -0.03796950f, 0.01077337f, 0.02695789f, -0.01263939f, 0.02055481f, 
    -0.02075632f, -0.02933877f, -0.02883240f, 0.00372483f, 0.02302449f, -0.03019413f, 0.01930190f, 0.02836584f, 
    -0.00390351f, 0.00999029f, 0.02733735f, 0.02320731f, 0.03024085f, 0.01854764f, 0.00226853f, -0.03399344f, 
    -0.03154153f, -0.02995218f, 0.02434945f, -0.03925157f, -0.02408543f, 0.03111214f, 0.00740600f, -0.01110690f, 
    -0.01264054f, 0.02582970f, -0.03012028f, 0.00813870f, 0.01802202f, 0.00524212f, -0.02778284f, -0.00793723f, 
    -0.03404298f, -0.00609299f, -0.02933152f, -0.02623168f, -0.02380198f, -0.02933442f, 0.01669074f, 0.00625125f, 
    -0.00408001f, -0.01484363f, 0.00835246f, 0.02514445f, 0.00254970f, -0.03774366f, 0.03132057f, 0.01686567f, 
    0.00831652f, -0.02569583f, -0.04502489f, -0.01628201f, -0.03203963f, 0.00201531f, -0.03457008f, -0.00290815f, 
    -0.00689754f, 0.01437188f, 0.01854396f, -0.00087845f, -0.02673371f, -0.01184498f, 0.01940997f, 0.01518380f, 
    -0.00449048f, -0.03049961f, 0.00028137f, 0.02286745f, -0.03953294f, -0.01110460f, -0.00524239f, 0.01354356f, 
    -0.03845226f, -0.03015151f, -0.02599200f, -0.03720903f, 0.00348650f, 0.02566618f, 0.03330566f, -0.02788194f, 
    0.00388089f, 0.00570776f, 0.02345954f, -0.02133817f, 0.01084870f, -0.04757928f, -0.03245173f, -0.02437010f, 
    -0.00776976f, -0.02361774f, -0.02706518f, -0.03811397f, -0.02962032f, -0.01022503f, -0.03546476f, 0.02139076f, 
    -0.02321672f, 0.01590670f, -0.02640778f, -0.02054834f, 0.02665527f, 0.02102973f, -0.01464647f, 0.00849515f, 
    0.01643943f, -0.01895219f, -0.04229504f, 0.01908913f, 0.02485584f, -0.02468171f, -0.03019292f, -0.04170527f, 
    -0.02859499f, 0.02390176f, -0.02662485f, -0.01251904f, -0.01961755f, 0.00214750f, -0.03031997f, 0.00629988f, 
    0.00055759f, -0.01614745f, 0.01065211f, -0.01522140f, -0.03442442f, -0.01389102f, -0.01229121f, -0.02842971f, 
    0.00623169f, 0.02420045f, 0.00200809f, -0.00122461f, -0.02604247f, 0.01951999f, 0.02210647f, -0.00937689f, 
    -0.00055579f, -0.00701981f, 0.02750338f, 0.00139725f, 0.01010907f, -0.01082081f, 0.02647911f, -0.00782225f, 
    -0.03249738f, -0.00429197f, 0.01410602f, 0.00147162f, 0.01274208f, 0.01557024f, -0.02464420f, -0.03476966f, 
    -0.00573565f, 0.01995918f, -0.03555726f, -0.02605300f, 0.03863817f, 0.01846906f, 0.01650524f, 0.02529598f, 
    0.00227249f, -0.03271037f, -0.01911565f, 0.01924151f, -0.01808873f, 0.01214845f, -0.03170262f, -0.02900353f, 
    0.01587930f, 0.00466013f, 0.00524974f, -0.03967870f, -0.02804762f, 0.01452131f, -0.02907516f, -0.03014930f, 
    -0.01973262f, 0.01076384f, 0.00767375f, -0.02189194f, 0.00530800f, 0.00382153f, -0.02045570f, -0.04252249f, 
    0.02574206f, 0.01808822f, -0.02198044f, 0.02139344f, 0.02708210f, 0.02988744f, -0.00885349f, -0.02299874f, 
    -0.03798184f, -0.02663639f, 0.01449876f, -0.03869991f, 0.03451320f, 0.00563783f, -0.03585618f, -0.03229047f, 
    0.00250134f, 0.02516616f, -0.01492958f, 0.02784952f, -0.03035238f, -0.02390730f, -0.02003108f, 0.00988948f, 
    -0.02886167f, -0.01401967f, 0.01999202f, 0.00828707f, 0.00672788f, 0.00391174f, -0.03071070f, -0.00482391f, 
    0.00010193f, -0.01057560f, -0.00604824f, -0.01295353f, -0.00399829f, 0.00880039f, 0.00854136f, 0.02101674f, 
    0.00387932f, -0.02252151f, 0.00902822f, -0.00194679f, 0.02174894f, 0.02164437f, -0.00039829f, 0.03032048f, 
    0.02722323f, -0.03205686f, -0.01401293f, -0.02592067f, -0.04220286f, -0.02448767f, -0.00091578f, -0.02442630f, 
    0.01714346f, 0.01610951f, -0.01898512f, 0.00031959f, 0.01382036f, 0.01553945f, -0.02504604f, 0.00913278f, 
    0.01654245f, 0.01193364f, -0.03122945f, -0.00731085f, 0.01824444f, -0.02594149f, 0.01450740f, 0.00623411f, 
    0.02810650f, 0.01477987f, 0.01342696f, -0.02148038f, -0.01066824f, 0.01801587f, -0.00467167f, 0.02467675f, 
    0.08146356f, -0.05345022f, 0.08971527f, -0.01423895f, 0.04172192f, 0.04679102f, 0.06213908f, 0.04057854f, 
    0.04669153f, 0.09755699f, -0.03589832f, 0.11577534f, -0.20135668f, 0.40114456f, -0.27889135f, 0.23357803f, 
    0.06818860f, -0.10784772f, 0.04857230f, -0.07535024f, 0.01115062f, -0.04947677f, -0.09852604f, -0.03863436f, 
    -0.04673585f, -0.11965771f, -0.34378842f, -0.06386142f, -0.02761503f, -0.11546975f, 0.06904070f, 0.02781829f, 
    0.02696515f, -0.06372532f, -0.08311065f, -0.06286830f, 0.04939102f, 0.52405119f, -0.05081530f, -0.01943491f, 
    0.16148563f, 0.04989633f, -0.05330480f, -0.01178009f, -0.20443949f, -0.01015081f, 0.00404492f, 0.02119700f, 
    0.04214907f, -0.18683557f, -0.02319893f, -0.13249105f, -0.04424142f, -0.00986796f, -0.08820923f, -0.07003333f, 
    -0.01080112f, -0.15710220f, -0.10982946f, -0.17309591f, 0.09720949f, -0.11969022f, 0.07192819f, -0.09802475f, 
    0.16149913f, 0.10141435f, -0.00637866f, -0.02636465f, 0.08877930f, -0.06460135f, -0.13797975f, 0.09212760f, 
    -0.42229033f, 0.13447751f, -0.04698238f, -0.03659357f, 0.15731643f, -0.04974078f, 0.03048857f, -0.06308235f, 
    0.05906038f, -0.09543486f, -0.13811490f, 0.08884592f, 0.28322518f, 0.16544397f, -0.00144529f, 0.00469709f, 
    0.07144637f, 0.14375518f, 0.06520937f, 0.07426120f, 0.01882061f, 0.00614892f, -0.00385449f, -0.07232764f, 
    0.29273549f, 0.10676129f, 0.15274994f, 0.01404134f, 0.11311057f, -0.00570873f, 0.12869219f, -0.09399860f, 
    0.04922337f, 0.04244960f, -0.03933118f, 0.03574516f, -0.16768157f, -0.12435120f, 0.07426259f, -0.23228452f, 
    -0.09113091f, -0.07860568f, -0.10596485f, -0.11928582f, 0.05076526f, -0.09582371f, 0.01336931f, 0.00381868f, 
    0.05589274f, 0.22179508f, 0.02634639f, 0.17185362f, 0.00399072f, 0.02663819f, 0.00467780f, 0.08447585f, 
    0.07962397f, 0.01288024f, -0.02118162f, -0.06520250f, 0.34294364f, 0.38760880f, 0.22497888f, 0.04866904f, 
    -0.09300053f, 0.10284290f, 0.10672256f, 0.19588976f, -0.05330728f, -0.09746785f, -0.01155157f, 0.00213102f, 
    -0.00963303f, -0.08601414f, -0.00467981f, -0.02340207f, 0.06840991f, 0.02840314f, -0.10935511f, -0.12019023f, 
    0.02301520f, -0.17660753f, 0.04545850f, -0.04667829f, 0.19957125f, 0.04084292f, -0.07754539f, -0.10070506f, 
    0.06170496f, -0.18728361f, 0.16034873f, -0.01163975f, -0.20386046f, 0.04691257f, -0.09487097f, -0.14750537f, 
    0.06640843f, 0.09062742f, 0.22965521f, 0.17710111f, 0.10703642f, -0.00285462f, 0.01695320f, 0.02974552f, 
    -0.00329352f, 0.05308857f, -0.04357439f, 0.12530218f, -0.10719726f, 0.07863265f, 0.18722215f, 0.12589236f, 
    0.02465606f, -0.02283084f, 0.07325020f, 0.04106095f, -0.07656940f, -0.07031449f, 0.20716022f, 0.07255188f, 
    -0.11275415f, 0.14663944f, -0.11721209f, 0.27653962f, 0.05705106f, 0.19506194f, -0.04962441f, 0.05177319f, 
    -0.11847725f, -0.04255282f, -0.11274169f, -0.14214881f, 0.16952524f, 0.08659033f, -0.20813385f, -0.13318492f, 
    -0.01989196f, 0.01708750f, 0.02348500f, 0.03203432f, -0.02026799f, 0.16448466f, 0.04127803f, -0.11862109f, 
    0.11480340f, -0.15152107f, 0.00298107f, 0.03504907f, 0.06190804f, 0.04484516f, -0.00957297f, -0.04976001f, 
    0.00224424f, 0.04145444f, 0.09394839f, 0.04648412f, -0.29230085f, 0.19267285f, -0.05318510f, 0.09079232f, 
    0.06155809f, -0.06828806f, -0.12565105f, 0.01033065f, -0.04961114f, -0.04644815f, -0.06014701f, -0.01779704f, 
    0.23688164f, 0.25460252f, 0.16582713f, 0.10462300f, 0.06492468f, 0.02480590f, 0.17809448f, 0.16710205f, 
    0.01392040f, -0.07150208f, -0.03081715f, -0.05439138f, -0.03573008f, 0.12345015f, -0.12666015f, -0.14817096f, 
    -0.01466936f, -0.10145426f, -0.16560449f, 0.03051083f, -0.00553777f, -0.02097028f, -0.10123732f, 0.02240652f, 
    -0.37580457f, 0.25596949f, 0.13651459f, 0.29115385f, -0.02779148f, 0.00994638f, -0.08461823f, -0.08398675f, 
    -0.05780535f, -0.05937003f, 0.01962597f, 0.04358388f, 0.48997894f, -0.04091119f, 0.06976727f, -0.09642215f, 
    0.13917786f, 0.15141530f, 0.05878850f, 0.15554790f, 0.04953612f, 0.07957572f, 0.13772222f, 0.05314891f, 
    -0.06689847f, 0.42098343f, 0.21729346f, 0.22937739f, -0.16928257f, 0.05471256f, 0.06646866f, -0.01348885f, 
    -0.01734406f, 0.09186943f, 0.16513695f, -0.05237069f, 0.05818466f, 0.00620767f, -0.26548332f, -0.16402124f, 
    0.00744228f, 0.09589942f, 0.01886172f, 0.04357143f, -0.06848706f, -0.07447106f, -0.10072026f, 0.09270437f, 
    -0.03195100f, 0.08915295f, -0.13914903f, -0.12619345f, -0.07289540f, 0.01104350f, -0.15107709f, 0.00949895f, 
    -0.02194770f, -0.02303498f, -0.03250107f, 0.08375552f, 0.36014396f, -0.10380989f, -0.14222758f, -0.02157651f, 
    0.07580853f, -0.07323805f, 0.02228776f, -0.01932992f, 0.03026570f, 0.04961537f, -0.02430633f, -0.07197246f, 
    0.03367866f, 0.12040850f, -0.01160255f, 0.02170937f, -0.08330385f, -0.01253421f, 0.14455649f, 0.10353739f, 
    -0.03117561f, 0.07060789f, 0.01871910f, 0.15790176f, -0.04506056f, -0.08728244f, 0.15941255f, -0.08540174f, 
    -0.09512007f, -0.09926219f, -0.23685351f, 0.08581740f, 0.08029291f, -0.05630516f, -0.10417584f, 0.02389609f, 
    0.07758975f, -0.03732146f, -0.13891308f, -0.26850533f, -0.22652863f, 0.00939037f, -0.16834992f, 0.03736363f, 
    -0.04915228f, -0.10762901f, 0.06971949f, -0.09417579f, -0.26196256f, 0.09851578f, -0.17980765f, -0.14285010f, 
    -0.00953977f, -0.05358803f, 0.07848131f, -0.11470072f, 0.10191543f, -0.13028200f, 0.00933069f, -0.14419810f, 
    0.02112191f, -0.32147115f, -0.25866690f, -0.04811738f, 0.08344626f, -0.04313281f, 0.00914291f, -0.03857216f, 
    0.02512559f, -0.06129457f, -0.03652802f, -0.04826988f, 0.04646488f, 0.07975311f, 0.04871057f, 0.01386249f, 
    0.04173867f, 0.02626904f, -0.16086708f, -0.03473800f, -0.03205880f, -0.10227770f, -0.04115002f, 0.04591606f, 
    -0.04784983f, -0.06726479f, 0.01797965f, 0.11302719f, -0.02166510f, -0.04113134f, 0.06957563f, 0.01078786f, 
    0.01472437f, 0.07000743f, 0.02664441f, 0.09301390f, 0.11017301f, 0.12241352f, -0.11876412f, 0.04805231f, 
    0.13216403f, -0.00165684f, 0.00192835f, 0.04318507f, 0.01978484f, 0.01019784f, 0.09835438f, 0.00260719f, 
    0.07292245f, -0.05782997f, 0.03933451f, 0.00578057f, 0.04690890f, 0.16425730f, 0.17261861f, 0.03595791f, 
    0.09948467f, -0.08080074f, 0.02422691f, -0.08322110f, 0.20808360f, -0.07430507f, -0.14447704f, -0.16722462f, 
    0.18373868f, -0.08884340f, 0.08210140f, -0.19368495f, 0.04036947f, 0.03568479f, -0.00165339f, 0.06548991f, 
    -0.07988760f, -0.26947710f, -0.27396944f, 0.06962803f, 0.04023351f, 0.04293685f, -0.04449628f, -0.00907008f, 
    -0.04427284f, -0.04614900f, 0.09218465f, 0.05212815f, 0.10768487f, -0.13154995f, 0.38922697f, -0.20548679f, 
    0.03671457f, -0.05046857f, -0.08925923f, -0.13701524f, -0.04452643f, -0.02690577f, -0.14405532f, -0.00098540f, 
    0.04860789f, 0.13866751f, 0.09527845f, 0.19673282f, 0.07839590f, 0.01561758f, -0.06655534f, -0.10689296f, 
    0.00117310f, 0.04538091f, 0.05125046f, 0.12070525f, 0.14454757f, -0.11299631f, -0.06182795f, -0.11789218f, 
    0.06403720f, 0.11140929f, 0.18360302f, 0.20360011f, -0.07213708f, -0.00787173f, 0.07812984f, 0.16095547f, 
    0.14528783f, 0.08539030f, -0.15416785f, -0.16781488f, 0.03637683f, -0.00807140f, 0.04974955f, -0.03864840f, 
    -0.01584737f, -0.12009422f, 0.02589702f, 0.00757664f, 0.00623234f, -0.30058566f, -0.30834791f, 0.00225665f, 
    0.15971479f, 0.12118610f, 0.05180211f, -0.10002541f, 0.12205117f, -0.03179433f, -0.07073690f, -0.02554242f, 
    0.12388146f, -0.01853863f, -0.05641975f, -0.20714667f, -0.04079694f, -0.10547008f, 0.09771745f, 0.11244766f, 
    0.03098091f, -0.06866111f, 0.14983159f, -0.00493924f, -0.09208976f, -0.09420058f, 0.12160271f, 0.11440630f, 
    0.01869757f, 0.08719141f, 0.06157272f, 0.12395632f, -0.10142406f, 0.03425378f, 0.00417254f, -0.00266728f, 
    0.02673767f, 0.05013832f, -0.08461558f, 0.05607608f, 0.12617162f, 0.11412767f, 0.02172092f, 0.10018121f, 
    -0.03599028f, -0.06018061f, 0.02161962f, 0.12074194f, -0.18897256f, 0.14384478f, -0.13212061f, 0.17302629f, 
    -0.00190355f, -0.03604671f, -0.00628231f, 0.04266805f, 0.10869953f, 0.11545010f, 0.04601240f, -0.01558000f, 
    0.14307587f, 0.00331656f, -0.37501967f, -0.08333391f, 0.01482178f, 0.04209805f, 0.10692174f, 0.03994069f, 
    0.04817781f, -0.08429713f, 0.05527911f, 0.00167615f, 0.17875984f, -0.05769478f, 0.14884189f, 0.13425508f, 
    -0.10364645f, -0.02562119f, -0.07227529f, 0.02610809f, -0.06204525f, 0.04814110f, 0.07375506f, -0.07503130f, 
    0.46908599f, 0.29722208f, 0.23329759f, -0.04624221f, 0.12280121f, 0.11099660f, 0.11693285f, 0.15334159f, 
    0.05295263f, -0.05107392f, -0.12712994f, -0.09722380f, 0.08907140f, -0.14338258f, -0.03343153f, 0.02093403f, 
    0.04289399f, 0.10258601f, 0.08660615f, -0.03584092f, -0.00062278f, 0.08916310f, 0.05404259f, 0.18795551f, 
    -0.12555255f, -0.02717718f, 0.04622746f, -0.06961352f, 0.00952497f, -0.09131695f, -0.00631289f, -0.05740124f, 
    -0.10655845f, -0.07190929f, -0.16599803f, -0.01844991f, 0.22857362f, 0.07910524f, -0.16602530f, 0.02491582f, 
    0.15401669f, 0.06855916f, 0.20978844f, 0.04946966f, 0.04221536f, -0.02141594f, -0.03956535f, -0.09816021f, 
    -0.10815778f, 0.34721011f, -0.10594299f, -0.08144373f, 0.03810235f, -0.19640230f, 0.07901744f, 0.04669765f, 
    0.01969226f, -0.03735487f, -0.10461073f, 0.08431882f, 0.12954509f, 0.21501251f, 0.15712799f, -0.00581466f, 
    0.09705723f, -0.15191935f, 0.18069425f, 0.09980136f, -0.16628955f, 0.00064591f, -0.00823956f, -0.06454212f, 
    0.11996722f, 0.31258219f, -0.04886755f, 0.30175322f, 0.01480256f, -0.02899717f, 0.21065322f, -0.06215297f, 
    0.04330075f, 0.07431148f, 0.10863784f, -0.05500972f, -0.10634673f, 0.14598295f, 0.01989562f, -0.07774367f, 
    0.13473755f, -0.13788298f, 0.03748749f, 0.08534390f, 0.19308582f, 0.06000852f, 0.10488883f, 0.12909441f, 
    0.14749599f, 0.19832914f, -0.00486464f, 0.23749883f, 0.11942444f, -0.12388320f, -0.02041605f, 0.07252660f, 
    0.00639708f, 0.05506140f, -0.07972844f, -0.08188077f, 0.05448708f, -0.04303636f, 0.09951110f, -0.04376208f, 
    0.10640783f, -0.12404576f, 0.20324135f, -0.07350474f, 0.08833030f, -0.00185890f, -0.06796782f, 0.02279689f, 
    0.03431060f, -0.00121249f, -0.04958144f, -0.03576380f, 0.04302619f, 0.04635855f, -0.14234221f, 0.04404983f, 
    0.01842422f, -0.02331433f, 0.01492180f, 0.09882570f, 0.17034911f, 0.29543039f, 0.08352725f, 0.28553417f, 
    -0.05568860f, -0.06927783f, 0.09620050f, 0.14974326f, -0.02582373f, 0.05999857f, 0.03101150f, 0.01730956f, 
    0.26982856f, 0.32419774f, -0.10149579f, -0.13436630f, 0.04698121f, 0.09814998f, 0.01837611f, 0.01076852f, 
    -0.08779683f, -0.13068040f, 0.03113251f, 0.02782930f, 0.26006919f, 0.15654483f, 0.19290484f, 0.10987275f, 
    0.08993626f, 0.00937773f, 0.04524246f, 0.11199844f, 0.19011068f, 0.10074638f, 0.11401971f, -0.00582058f, 
    0.03826539f, 0.02184803f, 0.07281343f, 0.00426985f, -0.11844217f, 0.12334388f, 0.07793662f, -0.00059230f, 
    0.11008468f, 0.13154620f, 0.18291530f, -0.01229926f, -0.24946344f, 0.19913590f, 0.17609794f, -0.09697194f, 
    -0.13970688f, -0.00299013f, 0.08028328f, -0.00113946f, -0.02618280f, 0.04088144f, 0.01504554f, 0.00810958f, 
    -0.07415458f, -0.00004575f, -0.51774764f, -0.02483284f, -0.10275660f, 0.02815610f, -0.02987124f, 0.17423484f, 
    -0.09851815f, -0.11814146f, -0.11661322f, 0.03306664f, -0.09230338f, -0.09425079f, 0.01365223f, -0.12241835f, 
    0.01923567f, 0.10822975f, -0.01416134f, -0.06901198f, -0.10344081f, -0.17730695f, -0.12164069f, 0.03578447f, 
    0.17090739f, -0.01115474f, 0.05050729f, -0.00780079f, 0.04830121f, 0.00652945f, 0.04848314f, -0.08223715f, 
    -0.07565687f, -0.01174485f, -0.10884853f, -0.06038298f, -0.18676214f, -0.22669737f, 0.08312145f, -0.23808628f, 
    -0.12762907f, -0.04433013f, 0.01810293f, 0.04824688f, 0.05697472f, 0.03332591f, 0.07936718f, -0.06537851f, 
    0.07817739f, 0.22885455f, 0.03667888f, -0.05674903f, 0.10568324f, 0.17332496f, -0.05975107f, -0.00495527f, 
    -0.14012870f, -0.01189310f, 0.08862966f, -0.08619655f, -0.11487161f, 0.07066101f, 0.27828282f, -0.14514123f, 
    -0.07812296f, -0.06596073f, 0.09201508f, 0.27750331f, -0.11197536f, -0.01470082f, 0.06152962f, -0.18578573f, 
    0.17549863f, -0.00335402f, -0.03679207f, 0.33628014f, 0.10313786f, -0.06038991f, 0.05014626f, -0.00062146f, 
    0.07148249f, 0.21326722f, 0.26405627f, 0.06363064f, 0.17472111f, -0.12756094f, 0.05134722f, 0.01500183f, 
    -0.06646890f, 0.04711942f, 0.03007326f, -0.16776069f, -0.04940227f, 0.09495658f, 0.06127943f, -0.02110646f, 
    -0.26965004f, 0.30773044f, 0.18482377f, -0.15667695f, -0.02165270f, -0.01081905f, -0.00133039f, 0.00326786f, 
    0.08698624f, 0.10686815f, -0.08570027f, 0.08726246f, -0.21406573f, -0.37461746f, 0.18939775f, 0.20163642f, 
    -0.09845681f, -0.06222984f, -0.02863238f, 0.00357319f, 0.11644896f, 0.10094701f, 0.05224285f, -0.00258627f, 
    0.01705869f, 0.12924993f, 0.08602786f, 0.07283506f, 0.03826847f, 0.12202202f, 0.04124516f, -0.09084443f, 
    0.00173382f, 0.02369762f, 0.03303369f, -0.03922930f, 0.06207772f, 0.13832453f, 0.13653123f, -0.26149505f, 
    0.15087177f, 0.01981429f, 0.00852053f, 0.10664225f, -0.03227400f, 0.07613434f, -0.18553360f, -0.06945599f, 
    0.06991164f, -0.05780250f, 0.03512111f, 0.06385452f, -0.10298084f, 0.00898437f, 0.20495644f, 0.10615677f, 
    -0.09738806f, 0.11168553f, 0.02289954f, 0.15617836f, 0.10373475f, 0.19379713f, 0.04386161f, 0.06281145f, 
    0.08327278f, 0.13122292f, 0.09824540f, 0.05617511f, 0.05124782f, 0.20271535f, 0.05880284f, 0.18405125f, 
    -0.13063052f, 0.19174562f, 0.06660751f, 0.20320161f, -0.10707273f, 0.02715614f, 0.14754820f, 0.00720478f, 
    -0.01555729f, 0.03945796f, -0.15271747f, 0.06609498f, -0.05057798f, 0.17086627f, -0.07247040f, 0.05944300f, 
    -0.04105033f, 0.01028040f, -0.01849229f, -0.03793054f, 0.04066611f, 0.03197367f, -0.01594918f, 0.04841663f, 
    0.04572433f, -0.13335367f, -0.17729522f, 0.07093804f, 0.01574617f, -0.01322910f, -0.03544251f, -0.02383364f, 
    -0.01052720f, 0.06554939f, 0.08070809f, 0.08666950f, 0.25566512f, 0.15956253f, -0.03054433f, -0.14091289f, 
    0.04177522f, 0.00487590f, 0.07451937f, 0.03998388f, -0.05198289f, 0.06843971f, 0.00600083f, 0.12204196f, 
    -0.03780075f, -0.28500691f, -0.00417133f, 0.15944126f, -0.03413045f, -0.15127967f, -0.02528365f, 0.14542237f, 
    0.01534708f, -0.01415377f, 0.01621070f, -0.05368875f, -0.04398481f, 0.10928975f, 0.02589013f, -0.11258074f, 
    0.04646441f, -0.02382759f, -0.11129449f, -0.07489437f, 0.03993780f, 0.11359201f, -0.03005622f, -0.20134121f, 
    0.02684049f, 0.22333601f, 0.09632946f, -0.00879149f, 0.01988426f, -0.01733328f, 0.17335655f, 0.09713257f, 
    -0.02216785f, -0.01148882f, 0.13643716f, -0.08237147f, 0.31082264f, -0.21260394f, -0.14114407f, -0.04083752f, 
    0.06447309f, -0.08992533f, 0.02065247f, -0.05214418f, -0.02196557f, 0.00485319f, 0.01058847f, 0.11841436f, 
    0.10982140f, 0.32311332f, 0.07495511f, 0.00593661f, -0.05995734f, 0.00981434f, 0.31439686f, -0.03512178f, 
    -0.01488739f, -0.10449439f, 0.02080289f, 0.01010310f, -0.03740049f, -0.04847927f, -0.42499444f, -0.25853693f, 
    -0.13003057f, 0.16882023f, -0.03767042f, 0.21621804f, 0.10613286f, -0.02555724f, -0.12965955f, 0.00137703f, 
    0.14443913f, 0.17986748f, 0.03335041f, -0.09181199f, -0.06943817f, 0.08242153f, -0.01870984f, 0.00207773f, 
    0.03386155f, 0.11881282f, -0.08788938f, -0.09749138f, 0.12280831f, -0.14021765f, 0.21411738f, -0.14550628f, 
    0.08229914f, 0.02009413f, -0.00912195f, 0.04529431f, 0.01098019f, -0.07457256f, -0.10641446f, 0.00059429f, 
    -0.20636515f, 0.04279348f, -0.01159518f, 0.28858039f, -0.07881761f, 0.01077087f, 0.04014765f, 0.20014998f, 
    0.13662773f, 0.05897492f, 0.04431099f, 0.05763468f, 0.34878913f, 0.17967620f, 0.02353721f, 0.10279623f, 
    0.05150804f, 0.10593957f, 0.05007016f, -0.10754958f, -0.08126608f, -0.12677923f, -0.09125672f, -0.08464751f, 
    0.08019552f, 0.01561353f, 0.07734283f, 0.08050635f, -0.03012813f, 0.04191680f, -0.03816986f, 0.03092071f, 
    0.09160006f, 0.14939444f, -0.05033425f, -0.11814926f, 0.07792130f, 0.15896811f, 0.15988527f, -0.26026818f, 
    0.07626912f, 0.03491228f, 0.10430474f, -0.18521155f, -0.07450739f, -0.14686634f, -0.06257158f, 0.07682087f, 
    0.17193906f, 0.01975392f, -0.35007781f, 0.08308493f, -0.09171011f, -0.18645224f, -0.04467763f, -0.01625889f, 
    -0.15481448f, -0.10824231f, -0.01417392f, -0.08173585f, 0.28270355f, 0.19908218f, 0.04745333f, -0.06520784f, 
    -0.02192470f, 0.03336464f, -0.06450573f, 0.01231711f, 0.11510016f, 0.10550617f, 0.08651705f, 0.00586778f, 
    0.01759529f, 0.12524423f, 0.05651916f, 0.00156656f, -0.03272332f, 0.04706669f, 0.02607827f, 0.01461465f, 
    0.04526200f, 0.14448309f, 0.13311382f, 0.15562496f, -0.21948552f, -0.10281119f, 0.03557439f, -0.11106654f, 
    -0.13186432f, 0.00658783f, 0.03465798f, 0.08017132f, 0.09056266f, 0.08176479f, 0.09215208f, 0.01396880f, 
    0.00831742f, -0.09605996f, 0.11733275f, 0.13311833f, 0.09203476f, -0.02879548f, 0.21656811f, -0.07743109f, 
    -0.11105872f, -0.15712662f, -0.14711848f, -0.16389397f, 0.14858098f, 0.00963246f, -0.32145092f, -0.00089884f, 
    0.07285383f, -0.03899781f, -0.01596678f, -0.04564471f, 0.01303254f, -0.08436116f, 0.06172948f, 0.19916947f, 
    0.05875151f, -0.06419501f, 0.13796230f, -0.43739000f, 0.14709496f, -0.09582463f, 0.10563447f, -0.10868808f, 
    -0.11750879f, -0.08416627f, -0.06252579f, 0.02780844f, 0.33138806f, 0.03687067f, 0.12557814f, -0.02338754f, 
    0.04192560f, 0.00775029f, -0.05784462f, -0.04222795f, 0.06667558f, -0.03852648f, 0.07716690f, -0.22104892f, 
    0.06617149f, 0.08313353f, 0.09783047f, 0.13316967f, -0.04634718f, -0.02953674f, 0.04154208f, -0.04568249f, 
    0.10344168f, 0.14999917f, 0.18069831f, 0.12551801f, 0.13940813f, -0.22632122f, -0.01361215f, -0.28942475f, 
    0.00851213f, -0.00814704f, 0.03571248f, -0.22170274f, -0.12297752f, -0.05672237f, 0.16452870f, 0.20327488f, 
    -0.08470205f, 0.02330083f, 0.09032809f, 0.00965401f, 0.06817430f, 0.17439136f, 0.08305658f, 0.03021791f, 
    0.08760595f, 0.02996782f, -0.11327339f, -0.05625245f, 0.19316073f, -0.15862828f, -0.30569211f, -0.11751583f, 
    -0.13205005f, -0.15543190f, -0.06468870f, -0.05254367f, -0.05865300f, 0.09004693f, 0.00196700f, 0.06477913f, 
    -0.01603496f, 0.09896177f, -0.06020022f, -0.10504407f, -0.03727549f, 0.02734034f, -0.04691736f, -0.09717043f, 
    0.19821706f, -0.07428796f, 0.10498815f, -0.02607847f, 0.00867708f, -0.26095915f, 0.22273473f, -0.00322875f, 
    -0.10619300f, -0.04049574f, 0.03580412f, 0.24503326f, -0.08492874f, 0.03879739f, 0.07485574f, 0.03644451f, 
    -0.31839246f, -0.08994578f, -0.23217376f, -0.10946922f, -0.08041463f, -0.11071961f, -0.04446973f, 0.18503042f, 
    0.11577482f, 0.20111224f, -0.00126573f, -0.05148851f, -0.05870172f, 0.09236852f, 0.07426881f, 0.08998746f, 
    -0.18826430f, 0.10322290f, 0.09977414f, 0.05320505f, 0.13105893f, 0.01143327f, 0.09077593f, 0.09697348f, 
    0.12099525f, -0.01047686f, -0.21161664f, 0.05694943f, -0.05997070f, -0.04217969f, -0.02434896f, -0.00595494f, 
    0.09345376f, 0.06938819f, 0.10820491f, 0.04288863f, 0.17212285f, -0.10482477f, 0.00243512f, 0.06864920f, 
    -0.03403233f, -0.00709845f, -0.04050549f, -0.11439199f, 0.11552636f, 0.17218961f, 0.06045040f, -0.01535288f, 
    -0.22434184f, -0.22920437f, 0.04363728f, 0.20865913f, 0.24693948f, -0.15956768f, -0.04290056f, 0.00905002f, 
    0.00249541f, 0.03811511f, 0.01034708f, -0.05092987f, 0.06995846f, -0.13660556f, 0.23089321f, 0.05905034f, 
    -0.13510886f, -0.00764903f, 0.01842728f, 0.01707810f, 0.11465172f, 0.10614866f, -0.04547829f, -0.00860616f, 
    0.34656543f, 0.14312841f, -0.01361620f, -0.14787056f, -0.02810591f, 0.00806805f, -0.02747669f, -0.10338253f, 
    -0.06740197f, -0.09763298f, -0.10153057f, -0.04273742f, 0.01573604f, 0.02571893f, -0.03703550f, 0.05925573f, 
    0.08100041f, -0.07830763f, 0.03563026f, 0.16878825f, -0.08340468f, -0.10673533f, -0.11666129f, 0.00732647f, 
    -0.28971213f, 0.15608111f, -0.03860698f, -0.06765825f, -0.20830034f, 0.19601145f, -0.11311162f, -0.02229709f, 
    0.00108588f, -0.10291683f, -0.02622481f, 0.00895329f, 0.38112804f, 0.14763707f, 0.24795403f, -0.15414158f, 
    0.09588082f, 0.03535334f, 0.09032035f, 0.17031078f, -0.06746294f, -0.08232126f, -0.13370511f, -0.04328385f, 
    -0.22593726f, 0.07329236f, -0.01539200f, 0.15325285f, -0.00648003f, 0.11834836f, 0.07579920f, 0.00314357f, 
    0.02076948f, 0.08226034f, 0.01264189f, 0.05775548f, 0.11762106f, 0.11610056f, 0.08482807f, -0.04330635f, 
    -0.12683806f, 0.17916153f, -0.00442500f, 0.04400104f, 0.18996835f, 0.14158508f, 0.09152082f, 0.10741211f, 
    -0.00299242f, 0.02786617f, 0.08965638f, -0.01772456f, 0.12761246f, -0.08792613f, 0.08399872f, -0.00853978f, 
    -0.10343498f, -0.07211164f, -0.12619291f, 0.03888723f, 0.14115937f, -0.21973720f, -0.12313145f, -0.22371615f, 
    0.07539727f, 0.19956405f, 0.09014060f, -0.06729074f, -0.00257463f, -0.02376347f, 0.07364347f, -0.06350916f, 
    0.02663543f, 0.10164702f, -0.00596949f, 0.02629340f, 0.08166995f, 0.07499783f, 0.06891856f, 0.10915931f, 
    -0.04925109f, 0.00107335f, -0.14114960f, -0.06647319f, 0.14696233f, -0.02601426f, 0.01287375f, 0.17231628f, 
    -0.15291020f, -0.05074507f, 0.15384851f, 0.08635746f, 0.01213751f, 0.08622652f, 0.07908785f, 0.01133668f, 
    0.04508030f, -0.11745971f, 0.05217147f, -0.08354675f, 0.02320103f, -0.04355362f, -0.15185039f, 0.03604360f, 
    0.07900670f, 0.02513960f, 0.05087610f, -0.03579586f, 0.05416494f, -0.11335760f, 0.24227297f, 0.01788022f, 
    -0.06781225f, -0.08460441f, 0.00593396f, 0.07586508f, -0.01207441f, -0.01974787f, -0.13166013f, -0.18196967f, 
    0.02644455f, -0.00110044f, -0.00409788f, -0.02521569f, 0.03090479f, -0.02834942f, 0.02122550f, -0.03487925f, 
    -0.00962515f, 0.02260725f, 0.01736052f, 0.00726759f, -0.03404301f, 0.00295714f, 0.02871434f, -0.00684529f, 
    -0.00126613f, -0.02056780f, -0.02938254f, 0.01671527f, -0.02103576f, -0.03274003f, -0.02390498f, 0.01797051f, 
    -0.02275573f, 0.00969337f, 0.02617734f, -0.03034634f, 0.02964815f, -0.01553588f, -0.00224624f, -0.02126983f, 
    0.00367463f, 0.02774169f, -0.02851813f, 0.01679657f, -0.01405866f, -0.00705144f, -0.00582639f, -0.04138280f, 
    0.00905270f, -0.01930596f, -0.02125475f, 0.00659185f, 0.02690741f, -0.02094547f, 0.02127239f, 0.00790462f, 
    0.00165767f, 0.01574403f, 0.01755277f, -0.00496051f, -0.02716716f, -0.02779521f, -0.00589415f, 0.00812887f, 
    0.00118757f, -0.01350451f, 0.02015772f, 0.00053290f, -0.02229497f, -0.00970605f, -0.01009815f, -0.01252898f, 
    0.00492666f, -0.01577596f, 0.02505371f, -0.03539322f, -0.04100189f, 0.00673208f, -0.03888253f, 0.02040011f, 
    0.00944794f, -0.01662111f, -0.03735668f, 0.01474429f, -0.03715530f, 0.02385509f, 0.00124683f, -0.00673943f, 
    -0.01636562f, -0.01890511f, -0.02462337f, -0.01939785f, 0.01575692f, 0.00555484f, -0.02279731f, 0.02875120f, 
    -0.01947821f, 0.01579428f, -0.02052685f, -0.02932660f, -0.02991946f, -0.04065366f, 0.01916184f, 0.00803599f, 
    -0.00906873f, 0.01421501f, 0.00536399f, -0.01403400f, 0.02384879f, -0.00473454f, 0.00029300f, 0.00033072f, 
    0.02360847f, -0.01879066f, -0.00654848f, 0.01815904f, -0.01866851f, -0.00742540f, 0.01014434f, -0.02222542f, 
    -0.02507344f, -0.03571227f, 0.00709390f, 0.01382611f, 0.01266990f, -0.02826991f, 0.02560131f, 0.01056164f, 
    -0.01844794f, 0.01878582f, -0.03715503f, -0.02515502f, -0.00737784f, 0.01531223f, 0.02127063f, 0.02259866f, 
    0.00430260f, 0.01771839f, -0.01033225f, 0.02475186f, -0.04088528f, 0.01939324f, 0.02736141f, 0.01825890f, 
    -0.00276373f, -0.01748569f, 0.00478241f, -0.01556748f, 0.00993856f, -0.03167174f, -0.00424362f, -0.02989550f, 
    0.04089565f, 0.00493912f, 0.03080687f, -0.02089211f, -0.00739788f, 0.01950267f, -0.00364930f, -0.01575613f, 
    0.03928388f, -0.01798705f, -0.02064229f, -0.02831670f, 0.01339841f, 0.01578742f, -0.00979709f, 0.00972281f, 
    0.02574401f, 0.00005991f, 0.00603875f, -0.02369702f, -0.01079478f, -0.00008378f, -0.00678574f, -0.02062507f, 
    -0.04025761f, 0.01002774f, 0.00963380f, -0.02398774f, 0.00150093f, 0.01395612f, 0.01635722f, -0.01201080f, 
    0.01158680f, 0.00002202f, -0.00627898f, -0.01617324f, 0.00671502f, 0.00256222f, -0.01060263f, 0.00361368f, 
    0.02201451f, -0.03452314f, 0.01262903f, 0.02417274f, -0.01467887f, -0.01778435f, 0.02323743f, 0.02556411f, 
    0.03183318f, -0.01770293f, 0.01861000f, -0.00910473f, -0.01160725f, 0.00226083f, -0.00224909f, -0.00788022f, 
    0.02784286f, 0.02918452f, -0.00197410f, 0.02699140f, 0.01693391f, -0.02610078f, -0.01549730f, 0.02322300f, 
    -0.00913326f, 0.00000212f, -0.03341475f, 0.02744800f, 0.00606246f, 0.00931501f, -0.01659245f, 0.01417161f, 
    0.02050211f, -0.01258296f, -0.03019379f, -0.02394153f, -0.01318676f, -0.00057815f, -0.00118630f, -0.00943872f, 
    0.02423195f, -0.00317730f, -0.03831757f, 0.01558230f, 0.02535786f, 0.01529020f, -0.03193927f, -0.02097551f, 
    -0.03356313f, 0.02183895f, -0.00096218f, -0.03559386f, -0.03083889f, 0.00260174f, -0.01322028f, -0.02328699f, 
    -0.04172242f, -0.00626047f, 0.01613300f, 0.00369627f, 0.01266027f, 0.02940864f, -0.00185032f, 0.00172740f, 
    0.00808317f, -0.01897733f, 0.00269270f, -0.01015712f, -0.03502449f, 0.00764769f, -0.02750581f, 0.02292233f, 
    -0.01636369f, -0.02595488f, 0.01650116f, -0.01112576f, 0.01982091f, -0.02771263f, -0.03863290f, -0.02176286f, 
    -0.01390223f, -0.00594489f, 0.02873738f, -0.01054388f, -0.00534545f, -0.00122977f, -0.02990225f, -0.02158131f, 
    0.01671800f, 0.02108946f, -0.03897761f, -0.00686785f, 0.00964139f, -0.03250741f, -0.01469029f, -0.03371306f, 
    0.02102902f, -0.01517243f, 0.00734700f, -0.01007080f, -0.02975916f, -0.00235983f, 0.01091415f, -0.01459610f, 
    -0.00001304f, -0.04029228f, 0.01223474f, -0.02945970f, -0.01727310f, 0.02723784f, -0.01987620f, -0.02338436f, 
    -0.03142088f, 0.00798098f, 0.01267288f, 0.00514743f, -0.00754168f, -0.03370027f, -0.03153506f, -0.00739197f, 
    -0.01953093f, 0.00503925f, 0.00868334f, -0.02694035f, 0.01300821f, -0.00086450f, -0.02586470f, -0.02755489f, 
    0.02696443f, 0.00507459f, 0.01686245f, 0.01860173f, 0.00787639f, 0.01293051f, 0.00169419f, -0.02642397f, 
    -0.02055790f, -0.00370296f, 0.02441374f, 0.02904230f, -0.01178213f, 0.00518112f, -0.02464636f, -0.01444682f, 
    0.01620182f, 0.03414690f, 0.02210850f, 0.02403838f, 0.01683195f, 0.03115165f, -0.03649788f, -0.01425052f, 
    -0.01353028f, 0.00261219f, 0.02931125f, -0.01742278f, -0.03042544f, 0.03947362f, 0.01387921f, -0.03317707f, 
    -0.03694322f, 0.02732979f, -0.00137785f, -0.02243795f, 0.02248506f, -0.03744515f, 0.02807478f, -0.03971889f, 
    0.00422918f, -0.01394093f, -0.00796712f, 0.02379423f, 0.02265712f, 0.02005821f, -0.00836684f, -0.02134904f, 
    -0.00797293f, -0.01519956f, 0.01556003f, -0.01016195f, -0.00305738f, -0.03969750f, -0.01128404f, -0.03121816f, 
    -0.03489207f, 0.00556751f, -0.03765458f, -0.02794609f, 0.01434918f, 0.02903547f, -0.00383379f, 0.01978654f, 
    -0.01755527f, -0.03779459f, -0.00907359f, -0.02884038f, 0.01521098f, 0.00231140f, -0.03351454f, 0.02228949f, 
    -0.02301133f, -0.02833217f, 0.01562988f, -0.03434728f, -0.04069145f, -0.03162880f, 0.02185235f, -0.02486941f, 
    0.00984461f, -0.00169103f, 0.02547034f, 0.00008727f, 0.01030464f, 0.00416933f, -0.01576299f, 0.01480566f, 
    -0.02606898f, -0.02273160f, -0.00303638f, -0.01175979f, -0.02730557f, -0.03053697f, 0.01522986f, -0.03224200f, 
    -0.02539293f, 0.00553335f, -0.02221141f, 0.01443177f, -0.03560667f, -0.03436935f, -0.00597284f, -0.02668850f, 
    -0.01729221f, -0.03941456f, -0.00401394f, -0.03769637f, 0.02793638f, -0.01417871f, -0.00575146f, 0.01610593f, 
    0.00714614f, -0.03958225f, 0.02680931f, 0.02392839f, -0.03654128f, -0.03745982f, -0.01493463f, 0.01366113f, 
    -0.01138361f, -0.01605977f, -0.04107010f, 0.02661176f, 0.02762542f, 0.00151533f, -0.00493602f, -0.00733711f, 
    -0.00045765f, -0.01438579f, 0.01128162f, -0.03734384f, 0.01888327f, -0.03159192f, 0.02172450f, -0.03538521f, 
    0.01379307f, -0.00709342f, 0.02060497f, -0.00125982f, 0.00647099f, -0.03152781f, 0.02375876f, -0.03203333f, 
    -0.03173530f, -0.00639076f, 0.02494889f, -0.03577031f, 0.02258296f, -0.00521581f, -0.02138497f, 0.00205778f, 
    0.00588891f, -0.02616736f, 0.01749269f, 0.03094600f, -0.01336801f, 0.00584221f, -0.02288449f, -0.00746804f, 
    -0.00767254f, -0.03122535f, -0.00093747f, -0.02426689f, -0.00972975f, 0.00120555f, -0.01817651f, -0.01485344f, 
    -0.00226879f, 0.00058528f, -0.03941186f, -0.01100350f, 0.02124420f, 0.00987950f, -0.02616600f, 0.00525334f, 
    -0.02758687f, 0.02051515f, 0.02891301f, -0.02910605f, 0.02437103f, -0.04122103f, 0.01119805f, -0.01989770f, 
    0.00829596f, 0.00856821f, -0.03658354f, -0.03469550f, -0.00791084f, 0.01901357f, -0.02604820f, 0.00835780f, 
    -0.03374105f, 0.01458673f, 0.02902366f, 0.02038347f, 0.02698457f, 0.02007464f, 0.03072482f, 0.01037459f, 
    -0.00596413f, -0.02830169f, -0.01955009f, -0.00090692f, -0.01856768f, 0.01704258f, 0.00039986f, 0.01403617f, 
    0.01158368f, 0.00980982f, 0.01047025f, -0.00113676f, 0.00970368f, -0.01983603f, 0.03208326f, -0.00121682f, 
    0.01997376f, 0.00858965f, 0.00816266f, 0.00369591f, 0.01693316f, 0.01068937f, 0.01097505f, -0.00200412f, 
    0.00128784f, 0.01268620f, 0.02210246f, -0.01494150f, 0.01579458f, -0.03813440f, 0.00742384f, -0.03656690f, 
    -0.03889631f, -0.01374164f, -0.03691048f, -0.03195694f, -0.01421110f, -0.02059181f, 0.00855714f, -0.00946560f, 
    -0.02459678f, 0.01016767f, -0.01030639f, -0.03599489f, -0.00993342f, -0.01483752f, 0.00996547f, -0.01705223f, 
    -0.00477140f, -0.01403676f, 0.01926627f, 0.03678760f, -0.00598922f, -0.01537001f, -0.03892414f, -0.03395757f, 
    0.00007285f, -0.01862417f, 0.01588408f, -0.01479120f, -0.00212114f, -0.02127231f, 0.01871551f, -0.03305499f, 
    0.02113936f, -0.03893020f, -0.01046555f, -0.01236882f, -0.00782666f, 0.01933083f, -0.00803975f, -0.00155242f, 
    -0.01233650f, -0.00062235f, -0.03300380f, 0.00871185f, 0.00685373f, -0.01880115f, -0.02447390f, -0.02521862f, 
    -0.03653095f, 0.02832982f, -0.01927624f, -0.01774848f, -0.01108413f, 0.00896325f, 0.02965856f, -0.01660515f, 
    -0.00610278f, -0.03875796f, -0.01855673f, -0.00879520f, -0.00948962f, -0.00380096f, -0.02665170f, -0.02197382f, 
    0.02223174f, 0.01685559f, -0.01414265f, -0.01854355f, 0.01176859f, 0.00447120f, 0.00698551f, -0.03621992f, 
    0.02485264f, -0.01631225f, 0.02581710f, 0.00409919f, -0.02713092f, -0.00206685f, 0.02793595f, -0.03002111f, 
    -0.01728594f, -0.02405832f, -0.01889788f, -0.01347798f, -0.00542937f, -0.02851631f, 0.00650590f, -0.00757077f, 
    -0.02962789f, -0.02670327f, 0.02948687f, -0.03390400f, -0.04023151f, -0.00758079f, -0.00683936f, 0.00379846f, 
    -0.03134095f, 0.02079891f, -0.00991699f, 0.02084047f, -0.02164140f, 0.02858852f, 0.01914013f, -0.03411101f, 
    -0.02748233f, -0.02777229f, -0.03684009f, -0.03424857f, 0.02765475f, -0.01775870f, -0.02785943f, -0.04066116f, 
    -0.03725423f, -0.03773720f, 0.02238264f, -0.04006954f, 0.00649046f, 0.03750883f, -0.00683010f, 0.01625956f, 
    -0.03076934f, 0.01420228f, -0.01374998f, -0.04118964f, -0.01651446f, -0.01176690f, -0.03134150f, -0.02142180f, 
    -0.00859543f, 0.00636616f, 0.01353177f, 0.01215389f, 0.01517845f, 0.02419729f, -0.00877902f, 0.02867188f, 
    -0.00774079f, -0.02238726f, -0.03170118f, 0.00075363f, -0.00047852f, 0.02195367f, -0.02092537f, 0.01541692f, 
    -0.00009422f, -0.00684397f, -0.00761257f, 0.00602767f, -0.00354527f, -0.03688031f, -0.02180536f, 0.00798921f, 
    -0.01221016f, 0.02939500f, 0.00514272f, 0.00664847f, -0.01073719f, 0.02184511f, -0.04102908f, -0.00332107f, 
    0.01581043f, -0.00409854f, 0.01182175f, -0.00099573f, 0.00490655f, 0.02691150f, 0.00474217f, -0.02315278f, 
    -0.00934178f, -0.01273620f, 0.02215107f, 0.02534031f, -0.01551538f, -0.02610609f, -0.01942965f, 0.00848863f, 
    0.01924886f, -0.02725982f, -0.02490459f, 0.01502136f, 0.02430578f, 0.02720530f, 0.00909887f, 0.01751810f, 
    0.01946669f, -0.02293825f, -0.03719660f, 0.02491499f, -0.01227202f, 0.01644412f, 0.02037957f, -0.03100856f, 
    0.00346419f, 0.00123726f, -0.00370658f, 0.01621804f, 0.01944296f, 0.02181989f, -0.00945416f, 0.01016050f, 
    -0.00616740f, 0.01700929f, -0.00656928f, -0.00916993f, -0.00411805f, -0.00976636f, 0.02620781f, -0.01799143f, 
    -0.03030950f, -0.03623825f, -0.01356902f, -0.01537795f, -0.00496299f, 0.02570122f, 0.00872164f, 0.00070501f, 
    0.01401076f, -0.02773127f, 0.01548685f, -0.01463950f, -0.03007468f, 0.00347614f, -0.00290625f, -0.00235656f, 
    0.10874715f, 0.07446848f, 0.02185250f, 0.02542218f, -0.09527830f, 0.07420538f, 0.04136780f, 0.03269220f, 
    0.01207020f, 0.15949702f, 0.06695510f, 0.10685656f, -0.14261417f, 0.11829479f, 0.19522068f, -0.18613128f, 
    0.09275545f, 0.08905705f, -0.07393292f, 0.06038953f, 0.01384625f, 0.13587210f, 0.04499699f, -0.02030533f, 
    -0.06303425f, -0.06699658f, -0.41322696f, -0.15319608f, 0.09599984f, 0.11775991f, -0.08572514f, 0.14091812f, 
    0.03043776f, 0.02158145f, 0.02332106f, 0.10454945f, -0.07832810f, -0.10914608f, -0.05365117f, -0.02317460f, 
    0.20759887f, 0.22918759f, 0.15313362f, 0.01185238f, -0.00786503f, -0.07043557f, -0.04380730f, 0.09746364f, 
    0.08626680f, 0.10939942f, 0.02748234f, -0.08077247f, 0.13319851f, -0.08292657f, 0.12951702f, -0.02046166f, 
    -0.00794381f, 0.05215675f, -0.11753488f, -0.07702892f, -0.25570050f, -0.30049336f, 0.11110324f, -0.21174723f, 
    -0.08795860f, -0.14905477f, 0.03217656f, 0.02985936f, 0.08591840f, 0.02031013f, 0.01455012f, -0.10418328f, 
    0.37772146f, 0.11120627f, -0.02355422f, 0.00937287f, -0.00435333f, 0.15621530f, -0.03590545f, -0.01034077f, 
    0.00621487f, 0.00652277f, 0.06002297f, -0.04614265f, -0.21327260f, -0.03380556f, -0.06510197f, -0.42763346f, 
    -0.02246514f, -0.12420566f, 0.11922227f, 0.15213089f, -0.06812190f, -0.05675241f, 0.02433768f, -0.07112071f, 
    0.17620172f, -0.09380291f, -0.05061287f, 0.18631463f, 0.03044403f, -0.02868412f, 0.14349340f, 0.10510446f, 
    0.12559740f, 0.12078723f, 0.30666065f, 0.09279390f, 0.17449683f, -0.05536800f, 0.15660107f, 0.06843115f, 
    -0.03760265f, -0.04171193f, 0.05138870f, -0.00723161f, -0.12275866f, 0.14766286f, -0.02091135f, -0.02961971f, 
    -0.34031323f, 0.17439471f, 0.16260847f, -0.19741087f, 0.00560812f, 0.16336535f, 0.12366645f, 0.06583320f, 
    0.31717277f, 0.10143825f, 0.05843240f, 0.16954046f, -0.17658997f, -0.40795505f, -0.13408482f, -0.10916308f, 
    -0.07579079f, 0.05136694f, 0.03006938f, -0.15988930f, 0.01708248f, 0.10528492f, 0.06943344f, -0.02176847f, 
    0.01851506f, 0.08564469f, -0.05182820f, 0.15402733f, -0.03003567f, -0.00753659f, -0.01356073f, -0.00896994f, 
    -0.07688094f, -0.12999246f, -0.10546349f, -0.03096463f, -0.02475113f, 0.03951905f, 0.08000904f, -0.03654793f, 
    0.22977988f, 0.01218734f, 0.05734206f, 0.09089078f, -0.01010436f, 0.03436755f, -0.12666947f, -0.06160351f, 
    0.15619971f, -0.11118726f, -0.15466386f, -0.02806715f, 0.06908737f, -0.04500195f, 0.36898136f, 0.14272077f, 
    0.07793870f, 0.05714621f, 0.14723632f, 0.13040712f, 0.10759277f, 0.09785684f, -0.05140952f, -0.04344515f, 
    0.00607861f, 0.04185755f, 0.07860588f, 0.09519184f, 0.15370928f, 0.26422891f, 0.15405560f, 0.12136012f, 
    -0.00171518f, 0.06186279f, -0.03182162f, -0.16516364f, 0.10635116f, 0.09207822f, 0.13800760f, -0.05969138f, 
    0.07605273f, 0.11335558f, -0.20681526f, -0.05861771f, -0.12435415f, 0.13042441f, 0.10714567f, 0.09256277f, 
    -0.01020978f, 0.02422835f, -0.07462043f, -0.02398554f, 0.14246273f, 0.02493372f, 0.15075745f, 0.05571480f, 
    -0.08379003f, -0.12878549f, -0.04506162f, -0.00505902f, -0.03724301f, -0.01902028f, -0.10806096f, 0.02846369f, 
    -0.00834520f, 0.10476485f, 0.15771702f, 0.12835416f, 0.09353356f, 0.15143195f, 0.09876051f, -0.06834486f, 
    0.09168147f, 0.04992357f, 0.02460566f, 0.12724029f, -0.00986632f, -0.02482269f, 0.01755269f, 0.03102014f, 
    -0.02427233f, -0.32186535f, -0.14123270f, -0.15277870f, -0.03393012f, -0.20140618f, -0.04773914f, -0.02767893f, 
    0.00099294f, -0.04008877f, 0.05470678f, -0.04031929f, 0.10302038f, 0.09857347f, 0.05759890f, 0.10869369f, 
    0.03752929f, 0.01665748f, -0.00950039f, 0.06819053f, -0.06436223f, 0.13679133f, -0.16090086f, -0.11450308f, 
    0.30191758f, 0.19212107f, -0.05304428f, -0.18260950f, -0.07144452f, -0.00765644f, 0.22148177f, 0.17271830f, 
    -0.03970034f, -0.03927686f, 0.06218290f, -0.11334506f, 0.04119318f, -0.07217553f, 0.04987327f, -0.06188544f, 
    0.00778254f, -0.01317094f, -0.01590436f, 0.01016413f, 0.06800734f, 0.07168237f, 0.14317730f, 0.23179020f, 
    0.07962763f, 0.06191785f, -0.08175012f, -0.17361197f, -0.18822592f, 0.11900795f, 0.22141947f, -0.07954853f, 
    0.07042317f, -0.04321480f, 0.04752858f, 0.09320816f, -0.16021407f, -0.08318615f, -0.27300724f, -0.20493093f, 
    -0.03249357f, 0.08237167f, 0.08597308f, 0.17417602f, 0.09583782f, 0.00442157f, -0.05566112f, 0.08636893f, 
    0.07119345f, 0.15739325f, 0.06677879f, -0.00024773f, 0.04958766f, -0.01891072f, -0.06026419f, 0.02869378f, 
    0.00675542f, 0.11315012f, -0.04601393f, -0.05508310f, 0.03369338f, 0.00953172f, 0.14803642f, -0.13887036f, 
    0.01402671f, -0.05026938f, -0.18548366f, -0.02324703f, 0.07740977f, -0.02828655f, 0.01288620f, 0.00620756f, 
    -0.04466814f, -0.00421518f, -0.00542257f, 0.16666782f, 0.01811749f, 0.12230398f, 0.05794109f, 0.12506658f, 
    0.11225936f, 0.18543722f, 0.06774011f, 0.05191930f, 0.33787438f, 0.02316566f, -0.07659014f, 0.09640044f, 
    -0.12797885f, 0.04560019f, 0.03848480f, 0.00684008f, -0.05403769f, -0.10168818f, -0.11548494f, -0.12379057f, 
    -0.04285785f, -0.00494975f, 0.08412597f, 0.08733590f, 0.05728514f, -0.02684702f, -0.04099691f, 0.05057425f, 
    0.04934368f, 0.21789397f, -0.10458678f, -0.07003480f, 0.18675734f, 0.23611382f, 0.08698127f, -0.07525553f, 
    0.18267296f, 0.01575229f, 0.13503318f, 0.03618733f, 0.12755014f, -0.06878744f, -0.01515872f, 0.21141967f, 
    -0.04465874f, 0.07199720f, -0.13882130f, 0.11613928f, -0.06201616f, -0.13644946f, -0.06904066f, -0.01521481f, 
    0.02491483f, 0.10209689f, 0.05610623f, -0.01551157f, 0.20305227f, 0.11017299f, -0.06162975f, -0.07850241f, 
    -0.09457494f, -0.01829109f, -0.06943183f, 0.01495742f, -0.05512923f, -0.07744727f, -0.12280659f, -0.10077409f, 
    0.13039251f, 0.20762448f, 0.09389675f, -0.02305273f, -0.06789171f, -0.05496705f, 0.06047779f, -0.00028720f, 
    0.03101174f, 0.20168935f, 0.19878106f, 0.15951701f, -0.15564363f, -0.17857713f, 0.01587480f, -0.27931225f, 
    -0.04229834f, 0.11098030f, 0.00642225f, 0.07655169f, 0.03852446f, 0.01653735f, -0.01019036f, 0.10018618f, 
    -0.15335590f, -0.21773499f, -0.11580089f, -0.15422550f, 0.02867876f, -0.00917937f, 0.05637732f, 0.10861897f, 
    -0.10525483f, -0.18190931f, -0.09045018f, -0.11951727f, 0.08175609f, 0.07265365f, -0.24994241f, 0.29351529f, 
    0.05309238f, -0.07166367f, 0.07425621f, -0.02468487f, 0.18684372f, 0.12425759f, 0.03771761f, 0.21662532f, 
    0.06100425f, 0.05336350f, 0.15258896f, -0.26267126f, 0.10826817f, -0.12728582f, 0.10960934f, -0.07928020f, 
    -0.01050049f, -0.02888988f, 0.06461643f, 0.02122033f, 0.39657578f, -0.03343572f, -0.01251848f, 0.03468876f, 
    0.00519278f, 0.11219660f, 0.00477982f, -0.00084866f, -0.01658577f, -0.03079762f, 0.03032870f, -0.25057998f, 
    0.12215514f, 0.13544042f, 0.07302739f, 0.03426996f, -0.07723372f, -0.00180369f, 0.02099675f, -0.01896831f, 
    0.01512418f, 0.05967863f, 0.17567250f, 0.15230513f, 0.03215861f, -0.06697061f, 0.04417939f, -0.07061580f, 
    0.11915008f, -0.08200789f, 0.05044812f, -0.03581357f, 0.12454376f, 0.04157335f, 0.22177960f, 0.09649740f, 
    -0.22415036f, -0.05857880f, 0.21718635f, 0.05448927f, 0.01820312f, -0.10810425f, -0.03343134f, -0.09584938f, 
    -0.04101828f, -0.01086017f, 0.05437273f, 0.00543493f, 0.04477768f, 0.12785956f, -0.08263231f, -0.04164543f, 
    -0.06239666f, -0.13838583f, -0.12202434f, -0.00449946f, 0.02895392f, 0.20772126f, 0.15800381f, 0.15335110f, 
    -0.10926773f, -0.01611865f, 0.07692759f, 0.00895610f, -0.03089554f, -0.04484297f, -0.11398546f, -0.08062056f, 
    0.14166884f, -0.00528672f, 0.13667953f, 0.03161145f, 0.04652037f, -0.07172792f, 0.13347755f, 0.07805688f, 
    0.01722978f, -0.01671739f, 0.08929477f, 0.09884977f, -0.09360036f, 0.14638720f, 0.06391732f, 0.08543137f, 
    -0.29241765f, 0.00376816f, -0.14706786f, -0.18041880f, -0.17241767f, -0.02685618f, -0.03923925f, 0.13900054f, 
    0.11409159f, 0.15650755f, 0.03779938f, -0.00419983f, 0.07621146f, -0.01787201f, 0.02862559f, 0.04990903f, 
    0.00202476f, 0.18057150f, 0.11459002f, 0.01247234f, 0.13343552f, 0.08653297f, 0.02660988f, 0.06070845f, 
    -0.00099936f, 0.03037582f, -0.09508938f, 0.03318111f, -0.11514249f, -0.13187233f, -0.05884228f, -0.00678164f, 
    -0.06721511f, 0.09255955f, 0.03795094f, 0.10865000f, 0.20953025f, -0.00772523f, 0.03235535f, 0.23775706f, 
    -0.00239364f, -0.06530368f, -0.03385886f, 0.02684429f, -0.05110461f, 0.16152821f, 0.09522656f, 0.05824896f, 
    -0.21285535f, -0.30394098f, -0.17843767f, -0.00417040f, 0.24000844f, -0.10814574f, 0.00778141f, 0.04864410f, 
    0.14232077f, 0.11645029f, 0.06164818f, -0.02623563f, 0.05221920f, 0.02598657f, 0.06755297f, 0.00656778f, 
    -0.03508532f, -0.01996963f, -0.06433078f, -0.10032826f, -0.02766010f, 0.18434884f, -0.00238971f, 0.02634315f, 
    0.22696440f, 0.06791762f, -0.02353954f, -0.06201788f, 0.03417102f, 0.03973426f, 0.05875045f, -0.07036801f, 
    -0.04493329f, -0.09807988f, -0.13106744f, -0.07158579f, -0.12167748f, -0.13219577f, -0.28803775f, -0.31922549f, 
    0.08373536f, -0.03432305f, 0.05324662f, -0.00272126f, -0.04235942f, -0.13943478f, -0.10324364f, 0.00084005f, 
    -0.20312421f, 0.01547169f, -0.04694085f, 0.07498534f, -0.08446009f, 0.16065791f, 0.04492940f, 0.09978959f, 
    0.16708423f, -0.07641252f, 0.02944183f, 0.17691313f, 0.12244693f, -0.08939367f, 0.04797532f, -0.02234218f, 
    0.09588701f, 0.19737132f, 0.17577228f, -0.01386694f, -0.12671302f, -0.10818759f, -0.12825568f, -0.02122279f, 
    -0.26114601f, 0.04173753f, -0.04566321f, -0.01703417f, 0.01005038f, 0.06809311f, 0.06731514f, -0.14661603f, 
    0.18508497f, 0.09134433f, 0.13510868f, 0.10641306f, 0.02429807f, -0.02149061f, 0.06422327f, 0.05520678f, 
    -0.06137636f, 0.10711844f, -0.01245499f, 0.00585645f, 0.13525403f, 0.10487264f, 0.08623874f, 0.22419219f, 
    -0.21066342f, -0.14998555f, 0.04932944f, -0.18507290f, 0.02568610f, 0.19839308f, 0.17218634f, 0.03609883f, 
    -0.00737724f, -0.06776337f, -0.01061684f, 0.03485522f, 0.11659021f, -0.23207094f, -0.17368805f, -0.01036104f, 
    0.20669372f, 0.19640400f, 0.20771283f, -0.00609426f, 0.04182727f, -0.05261068f, 0.11203243f, 0.01917847f, 
    -0.19226561f, -0.14766856f, -0.13983907f, -0.19268060f, 0.07248092f, 0.03552909f, 0.20893873f, 0.13723166f, 
    -0.05468982f, -0.00991151f, -0.14857109f, -0.13572598f, -0.07501096f, -0.23749572f, -0.16948882f, -0.13913837f, 
    -0.04495272f, -0.07710416f, 0.05629690f, -0.10668401f, 0.06709817f, 0.09455363f, 0.11293952f, 0.01933351f, 
    0.11748993f, -0.06294282f, -0.07496268f, -0.18682571f, -0.02770010f, -0.12489027f, -0.21090178f, -0.10566490f, 
    -0.00186361f, 0.01300355f, 0.02347355f, -0.09212542f, 0.03738961f, -0.21653435f, 0.02310665f, -0.12523097f, 
    -0.08578476f, 0.10579237f, 0.01119747f, 0.01431044f, -0.09880530f, -0.04387735f, -0.02654363f, -0.01446201f, 
    0.02195804f, -0.12945333f, 0.03484312f, 0.08962880f, 0.04031962f, -0.09127338f, -0.07924812f, -0.09723673f, 
    0.02419818f, -0.04359232f, 0.06151189f, 0.04710318f, 0.09931535f, 0.17956637f, -0.17786741f, 0.00050038f, 
    0.09027884f, 0.03416997f, 0.06804067f, -0.15593199f, 0.11813066f, -0.14528567f, 0.10395189f, 0.14480175f, 
    0.33291054f, -0.05444009f, -0.08020544f, -0.09252264f, 0.12739994f, 0.00658604f, 0.00651427f, 0.12519568f, 
    0.06677546f, -0.03646124f, 0.05666633f, -0.07843264f, 0.00372655f, -0.08472781f, 0.01873709f, -0.03954268f, 
    0.08162783f, -0.00365090f, 0.01437698f, 0.09745495f, 0.06169397f, 0.09593825f, 0.11756790f, -0.14044140f, 
    0.03817416f, -0.00109624f, -0.02053940f, 0.04051711f, -0.06366194f, 0.15002950f, 0.02814674f, -0.02617827f, 
    0.01193973f, -0.02176592f, 0.13556139f, -0.05093146f, -0.03226122f, 0.08985069f, -0.01512105f, -0.14538743f, 
    0.04304958f, 0.17395635f, 0.11945158f, 0.11466257f, -0.04905352f, -0.06679824f, -0.10178760f, 0.04040143f, 
    0.05651645f, -0.04791149f, -0.10155448f, -0.12372303f, 0.15471628f, -0.02298866f, 0.07001829f, 0.19997676f, 
    0.05820710f, 0.09485088f, -0.03483489f, 0.05031663f, 0.20773308f, 0.20832109f, 0.22919682f, 0.00159526f, 
    0.00167161f, 0.08238593f, 0.09808633f, -0.02210775f, -0.02904244f, -0.07021677f, 0.02514773f, 0.00672697f, 
    0.00782659f, 0.13495180f, 0.32459506f, 0.14723244f, 0.05203060f, -0.03535497f, 0.13218579f, 0.05277561f, 
    0.07749586f, -0.09236376f, -0.22180003f, -0.01587792f, 0.05039647f, 0.13266635f, 0.01588208f, -0.00155105f, 
    -0.16018881f, -0.05343101f, -0.11294115f, -0.13961621f, 0.20336850f, 0.01098167f, 0.12327787f, -0.00326157f, 
    0.08056547f, 0.16281050f, -0.09149046f, 0.15864612f, -0.00539094f, 0.11525485f, 0.04921299f, 0.15326153f, 
    0.14585291f, -0.05841632f, 0.08319271f, -0.05227209f, 0.30949500f, 0.28935423f, 0.19612963f, -0.10052830f, 
    0.02698810f, 0.07697269f, 0.10745337f, 0.16184294f, -0.00859264f, -0.05666409f, 0.01426018f, 0.05567655f, 
    -0.00828981f, -0.11603117f, -0.02355843f, 0.00843874f, 0.03691989f, -0.04849592f, -0.06119175f, -0.08310509f, 
    0.12840630f, -0.00990703f, 0.05561917f, 0.07992665f, 0.18010499f, -0.26098058f, 0.10811631f, -0.13165568f, 
    0.01528689f, 0.11141676f, 0.00946558f, 0.00065800f, 0.03864231f, -0.02980972f, 0.16438955f, 0.00436256f, 
    0.16077679f, 0.13967071f, 0.19425887f, -0.18698294f, 0.05901235f, 0.03324624f, -0.13986991f, 0.03639989f, 
    0.04642644f, -0.02011282f, -0.04052392f, 0.10234040f, -0.01145467f, -0.20939697f, 0.06368056f, 0.07350801f, 
    -0.02836809f, 0.04095172f, 0.07837046f, -0.08436444f, -0.02908942f, -0.05506213f, 0.09166502f, -0.05665356f, 
    0.11965546f, 0.18935739f, -0.03329864f, -0.07210619f, -0.00317357f, 0.09582277f, -0.10498216f, 0.01002258f, 
    0.02156966f, -0.01548900f, 0.04753992f, -0.01857446f, 0.13017656f, -0.03722480f, -0.01538941f, 0.20506300f, 
    -0.05592734f, -0.01063339f, -0.06797145f, -0.08003306f, 0.03008034f, 0.09134673f, 0.05158580f, 0.05686001f, 
    0.11418182f, 0.10540255f, 0.04985889f, 0.03696910f, 0.03728405f, 0.01301562f, 0.04142030f, 0.04422252f, 
    0.09831557f, -0.02154807f, 0.04201626f, -0.07838411f, -0.18275507f, -0.04577231f, -0.24006869f, 0.36409721f, 
    0.08793059f, -0.01904130f, 0.08001714f, 0.02433952f, -0.08218471f, -0.06551903f, -0.05485621f, -0.01128555f, 
    0.08920163f, 0.30756843f, 0.15012474f, 0.05202913f, 0.10097918f, 0.10926874f, 0.15153041f, 0.15110460f, 
    -0.01684531f, 0.00699239f, -0.01903685f, 0.13455367f, -0.19295992f, 0.06506089f, -0.05605474f, 0.26343989f, 
    -0.00353540f, 0.00553551f, -0.05434524f, -0.07263364f, -0.00752626f, 0.00606942f, 0.03008386f, 0.33371282f, 
    -0.26017871f, 0.15228705f, -0.12216870f, 0.24529493f, 0.20438661f, -0.02274664f, 0.00929316f, 0.00269401f, 
    0.01031799f, 0.07754905f, -0.05705433f, 0.15448491f, -0.33209592f, 0.01121562f, 0.05115402f, 0.05544285f, 
    -0.01696431f, -0.02664712f, -0.05752056f, 0.03894889f, 0.04340732f, -0.05860100f, -0.07363321f, -0.08920439f, 
    -0.04956679f, 0.33116972f, -0.21768603f, 0.19125843f, 0.13420455f, 0.07467873f, 0.03771304f, 0.15497568f, 
    -0.00261980f, 0.03223883f, -0.02453646f, -0.10731049f, 0.02618215f, 0.16370079f, 0.04030326f, -0.07730816f, 
    0.06763871f, 0.00010481f, 0.02765275f, 0.04756683f, -0.02669778f, -0.08267455f, 0.03163428f, 0.00234807f, 
    0.22821538f, -0.01429186f, -0.14630914f, 0.15060700f, -0.04089660f, -0.05394257f, 0.03815227f, -0.09685106f, 
    0.05950733f, 0.03718770f, -0.00995797f, 0.23382181f, -0.04912772f, 0.07188862f, -0.03945570f, -0.09664989f, 
    -0.01940808f, -0.06191736f, 0.10112788f, 0.01066713f, 0.02758696f, 0.09037866f, 0.00966976f, -0.05134666f, 
    0.20239748f, -0.16985300f, 0.04409720f, -0.15118925f, -0.11014724f, 0.02114573f, 0.02761960f, 0.00025094f, 
    0.06830685f, -0.11511377f, -0.05011886f, 0.06917819f, -0.28598401f, 0.00245064f, -0.04279564f, 0.00453791f, 
    0.18065445f, 0.05171457f, 0.01423209f, -0.02847878f, -0.04194174f, 0.11201382f, 0.04809224f, 0.05782734f, 
    0.03244151f, 0.03336285f, -0.09631360f, -0.03205564f, -0.07425375f, -0.02601796f, -0.01552583f, -0.05579320f, 
    0.15268512f, -0.06513818f, 0.15996666f, 0.15426116f, -0.08987649f, -0.00423845f, -0.02813939f, 0.11838154f, 
    0.04630306f, -0.00363259f, 0.01255729f, -0.02998558f, 0.12110410f, 0.02821998f, 0.09687500f, -0.04340397f, 
    0.10386348f, 0.03532019f, -0.05305035f, -0.11438943f, 0.01006492f, 0.00449101f, -0.04209074f, -0.01887919f, 
    0.06918894f, -0.03417790f, 0.09801510f, 0.02743020f, -0.14285943f, -0.17997105f, -0.01567634f, 0.15483856f, 
    0.05802961f, -0.07730819f, -0.05786654f, -0.15443709f, -0.08067721f, -0.03078749f, 0.14821033f, 0.04619508f, 
    0.07916446f, -0.05544965f, 0.10364730f, 0.13350217f, -0.10111438f, -0.07944289f, -0.12266977f, -0.07455432f, 
    0.10598156f, -0.05756456f, -0.04759204f, -0.03198425f, 0.15367110f, 0.16751210f, 0.06729767f, -0.02056551f, 
    -0.06515285f, 0.10710846f, 0.15149242f, 0.12638195f, 0.04369419f, -0.03326307f, 0.04651811f, -0.01081673f, 
    -0.25062829f, 0.11938909f, -0.00767322f, -0.04583006f, 0.11459595f, 0.10383373f, 0.15757068f, 0.04075050f, 
    -0.05549094f, 0.04311248f, -0.05082002f, -0.02851496f, 0.09493338f, -0.04992208f, 0.20626979f, -0.08838998f, 
    -0.09563910f, -0.01521806f, -0.04531758f, 0.08980054f, -0.01655086f, -0.01796754f, 0.22474593f, -0.07981972f, 
    -0.23556204f, -0.00436302f, -0.15212296f, -0.31321195f, -0.02668609f, 0.07345958f, 0.19764233f, 0.04136892f, 
    0.01864184f, 0.06355812f, 0.06739910f, 0.13390288f, -0.21899271f, -0.01542655f, 0.14373717f, 0.14623210f, 
    0.18422048f, -0.00799940f, -0.04855703f, -0.06685945f, -0.03577193f, 0.02857193f, -0.01577426f, 0.03754540f, 
    -0.06224990f, 0.05435884f, -0.01109670f, 0.23330480f, -0.04901275f, -0.07261673f, -0.06304639f, -0.15731484f, 
    0.03598704f, 0.01715555f, -0.07508899f, -0.05268969f, -0.47840577f, 0.11640766f, 0.05108654f, -0.08648620f, 
    -0.11539225f, -0.00033210f, 0.01639985f, 0.09506287f, 0.07211545f, -0.10592077f, -0.09259222f, 0.02707248f, 
    0.22658393f, 0.01982813f, -0.17213641f, -0.16675274f, 0.02565789f, -0.02865182f, 0.01342215f, 0.03536287f, 
    0.17783715f, -0.01224031f, -0.03372471f, 0.08819026f, 0.33709511f, 0.05599485f, -0.10649439f, -0.17506291f, 
    -0.00094618f, -0.00327404f, -0.05238009f, -0.05361798f, 0.02688899f, 0.04982596f, -0.01286930f, -0.04273532f, 
    -0.04493735f, -0.08453441f, 0.04066612f, -0.01646590f, -0.16433614f, -0.08447085f, -0.07194939f, 0.01427845f, 
    -0.04036336f, 0.11704179f, 0.06221847f, 0.09862268f, 0.29735711f, 0.07740620f, -0.03080840f, -0.22600828f, 
    0.04278101f, 0.11859267f, -0.02533227f, 0.13366537f, 0.07773989f, -0.10745106f, 0.13431931f, 0.01135809f, 
    0.07565985f, 0.14813380f, 0.05376867f, -0.08324442f, 0.16762212f, 0.10892648f, 0.02958411f, 0.11572377f, 
    0.01035552f, -0.12809449f, -0.05637095f, 0.10088110f, 0.11800671f, -0.10086974f, -0.01411959f, -0.10749171f, 
    0.03671737f, 0.03122301f, 0.10227674f, 0.07802559f, 0.07507209f, 0.06396391f, 0.02230468f, 0.03521346f, 
    0.24278973f, 0.02484429f, 0.01207349f, -0.05175745f, -0.03272548f, -0.05105577f, -0.03264168f, -0.15337455f, 
    0.07482539f, 0.03966929f, 0.06841239f, 0.06745905f, 0.08988068f, -0.06804840f, 0.22728114f, 0.13857368f, 
    -0.05620275f, -0.00438078f, -0.04071510f, -0.04550242f, -0.02440784f, 0.00792033f, 0.05780678f, 0.05029336f, 
    0.04943815f, 0.26712590f, 0.41830298f, 0.04184610f, -0.18242991f, 0.13050540f, 0.04868791f, 0.13116270f, 
    0.15188536f, -0.07565746f, -0.00707271f, 0.03179267f, 0.04853984f, -0.17083167f, -0.03008639f, -0.16798000f, 
    -0.10333038f, -0.06104161f, 0.02823417f, 0.04534688f, 0.04774203f, -0.08867069f, 0.19982743f, -0.04500378f, 
    -0.10307844f, -0.14258052f, 0.01175563f, -0.02477082f, 0.10941851f, 0.00229418f, -0.04951477f, -0.01933885f, 
    -0.01557588f, -0.08400706f, -0.07229582f, 0.00555569f, 0.02548603f, 0.17950688f, 0.09517261f, -0.05642371f, 
    0.06979474f, 0.12029704f, 0.14808969f, 0.16671693f, -0.04159805f, -0.00062316f, -0.06110572f, 0.02045425f, 
    0.00013798f, -0.08308363f, 0.12474496f, -0.08212550f, -0.00319192f, -0.00446926f, 0.00023932f, 0.26577196f, 
    0.19785321f, 0.09754795f, 0.05896987f, -0.00877160f, 0.05705826f, -0.18522795f, -0.09852561f, -0.13952336f, 
    0.13136563f, 0.02737812f, -0.04124920f, 0.02902486f, 0.05739820f, -0.08625810f, 0.08523206f, -0.06580347f, 
    0.31672129f, -0.00813110f, -0.01718558f, -0.12209554f, 0.11999376f, -0.04350927f, 0.04451253f, 0.18126203f, 
    0.08345778f, -0.00442092f, 0.16777778f, 0.04626937f, -0.06009195f, -0.06570221f, 0.03578471f, -0.06811851f, 
    0.05363218f, -0.13971260f, -0.00252650f, -0.00467652f, 0.03295807f, -0.07575194f, 0.04689078f, -0.17319399f, 
    -0.01395668f, 0.08876850f, -0.16425246f, 0.09660188f, 0.17616005f, -0.06663343f, 0.03859782f, -0.01764888f, 
    -0.05117722f, 0.03629070f, -0.01994124f, -0.04293698f, 0.27592015f, -0.14928198f, 0.21420801f, -0.21243060f, 
    0.14125514f, -0.02174497f, 0.15925725f, 0.13927810f, -0.02254379f, -0.03391371f, -0.07665065f, -0.10545097f, 
    -0.09479351f, -0.03594676f, 0.08433330f, -0.08617147f, -0.08367222f, 0.02295256f, 0.05965094f, -0.02696695f, 
    -0.03597132f, -0.18300773f, 0.00685043f, -0.03478469f, 0.17653899f, 0.24515542f, -0.05501067f, 0.10784148f, 
    0.00037342f, 0.09906580f, 0.08055116f, 0.13687147f, -0.01023608f, 0.00361604f, 0.01344952f, 0.00167249f, 
    0.08607486f, 0.32435086f, 0.18223196f, 0.09100042f, 0.01844615f, 0.21784563f, 0.17487545f, 0.08379764f, 
    -0.04603351f, -0.01027834f, -0.00224077f, 0.08115388f, 0.23833309f, 0.18073733f, 0.14590240f, -0.11221059f, 
    -0.00496231f, -0.11734515f, 0.06924164f, 0.23030446f, -0.00319489f, 0.07795340f, 0.08840804f, -0.03335360f, 
    0.00702755f, -0.13677061f, -0.05956835f, 0.08782149f, -0.06685223f, 0.06061319f, -0.01558136f, -0.02375508f, 
    0.13759787f, 0.16417515f, 0.04791482f, 0.05461470f, 0.07409599f, 0.34545928f, 0.04616598f, 0.03593601f, 
    0.10177599f, 0.00689205f, -0.15747581f, -0.06328217f, 0.17737564f, -0.09423964f, -0.03234850f, -0.21610944f, 
    -0.19666244f, 0.19059746f, -0.38974339f, 0.03710623f, -0.08231331f, -0.00229241f, -0.06050019f, 0.10647535f, 
    -0.03068672f, 0.00890640f, -0.08993161f, 0.00746647f, -0.21004623f, -0.35735494f, 0.16269401f, 0.01074867f, 
    0.15382630f, 0.02048870f, -0.02872137f, -0.06320186f, -0.19218256f, 0.04610575f, 0.11183586f, -0.00094015f, 
    0.21914883f, 0.05899987f, 0.06196876f, 0.00907783f, -0.06773815f, -0.04818258f, 0.02385686f, -0.10463287f, 
    -0.09372186f, -0.15246131f, -0.06218932f, -0.08401415f, -0.00143930f, -0.06777897f, 0.02995826f, -0.09277190f, 
    -0.10609168f, -0.05222863f, -0.02833979f, 0.02573529f, 0.08529912f, -0.08711781f, -0.12299868f, -0.03595793f, 
    -0.13060342f, 0.03602203f, -0.22963493f, -0.24510713f, 0.03148206f, -0.00109980f, 0.10428784f, 0.20932636f, 
    0.08466473f, -0.15413135f, -0.01992693f, 0.20494762f, 0.06832282f, 0.18054724f, 0.22914918f, -0.05126093f, 
    -0.00906884f, -0.07805101f, 0.09363841f, 0.17287494f, -0.04115334f, 0.05246967f, -0.05024698f, 0.06851539f, 
    0.01498372f, -0.04162200f, -0.00307274f, 0.34130770f, -0.01920350f, 0.02194472f, 0.05370457f, -0.06823029f, 
    0.08945630f, -0.02761861f, 0.06926894f, 0.14102094f, 0.10636272f, 0.11638063f, 0.01111718f, -0.13970529f, 
    -0.03886895f, -0.20256199f, -0.03165556f, 0.01393960f, -0.01504546f, 0.00909276f, 0.08431302f, -0.00784695f, 
    -0.11917733f, 0.11905021f, 0.00945054f, -0.04132667f, 0.06200466f, -0.00018655f, 0.11762140f, 0.24224271f, 
    0.14043577f, -0.08808163f, -0.06363185f, -0.02626622f, -0.09603834f, -0.05668943f, 0.11952446f, 0.07860980f, 
    0.05271643f, 0.20853932f, 0.10383806f, 0.21023546f, 0.04204961f, 0.02914754f, 0.04355836f, 0.00238382f, 
    -0.07458285f, -0.10666531f, -0.13016051f, -0.04561057f, -0.00210699f, 0.02595349f, -0.01970503f, -0.07917202f, 
    0.05629943f, -0.17007811f, 0.03728240f, 0.09696564f, -0.28482294f, 0.03668145f, 0.13918668f, -0.19463192f, 
    0.16727594f, -0.07473028f, -0.22968064f, 0.09203991f, -0.10234646f, -0.03807000f, -0.02492340f, -0.07989609f, 
    -0.05534497f, -0.04701938f, 0.05204697f, -0.02703718f, -0.06435577f, -0.02365622f, -0.01029945f, 0.10075979f, 
    -0.04887773f, 0.11789549f, -0.15954168f, 0.06169078f, 0.07125685f, -0.27252936f, -0.18202715f, 0.12108626f, 
    0.00043359f, 0.10658041f, 0.12231655f, -0.07347548f, 0.21958208f, 0.14214727f, 0.21814980f, 0.25103772f, 
    0.04772023f, 0.43887457f, 0.15448174f, 0.05124363f, -0.03520967f, -0.08174216f, 0.09518150f, -0.12145881f, 
    -0.00891178f, 0.00110942f, -0.03179418f, -0.12601607f, -0.00172852f, 0.07887388f, 0.29136840f, 0.16011153f, 
    0.01225362f, -0.01972270f, -0.22634661f, 0.04368313f, 0.05959447f, 0.00191792f, -0.03534782f, -0.00274753f, 
    0.00567727f, 0.03888860f, 0.10933049f, 0.14705227f, -0.00429968f, 0.04605914f, 0.02210511f, 0.05400595f, 
    0.06797069f, 0.04272843f, 0.01088316f, 0.21970925f, -0.38964304f, -0.01180355f, -0.03682523f, 0.29761621f, 
    0.00827164f, 0.17191094f, 0.09082526f, -0.07609160f, 0.07580598f, -0.14826077f, -0.01636783f, -0.05306315f, 
    -0.11919799f, -0.03102910f, 0.10622919f, 0.08672898f, 0.08747777f, 0.14744684f, 0.11855152f, 0.19889241f, 
    -0.00258592f, -0.02638980f, 0.01723651f, 0.07958290f, -0.12680808f, 0.00526155f, -0.00655129f, 0.18304475f, 
    -0.09322821f, 0.00405801f, -0.13269131f, -0.05788704f, 0.04501687f, 0.00282020f, 0.05944062f, 0.01349651f, 
    -0.37593621f, 0.25766104f, -0.38398021f, 0.21217957f, -0.00620642f, -0.01857966f, 0.07744098f, -0.12586634f, 
    -0.06135653f, -0.00553379f, -0.08259857f, -0.17017548f, -0.28508016f, -0.03393511f, 0.21330135f, 0.14004782f, 
    0.13450465f, -0.16791998f, -0.06875911f, -0.00967422f, 0.13019837f, 0.10788538f, 0.08888928f, 0.05395338f, 
    -0.01592702f, 0.32382080f, -0.45148480f, 0.25659415f, -0.15406109f, -0.03266488f, 0.08461238f, -0.06786603f, 
    -0.01355349f, -0.01818259f, -0.05133415f, 0.02522492f, -0.05209352f, -0.17338708f, -0.07379787f, 0.00749446f, 
    -0.09198931f, -0.08012557f, -0.01086970f, 0.00979319f, -0.04084575f, -0.03500915f, -0.04733368f, 0.09951872f, 
    0.04097229f, 0.11394101f, 0.04439567f, -0.01149369f, -0.14624286f, -0.07929394f, 0.04331209f, 0.04284923f, 
    -0.00629289f, 0.00752746f, 0.07324530f, 0.05562950f, -0.21047834f, 0.25865632f, 0.09055168f, -0.02368017f, 
    -0.11934778f, -0.24043623f, 0.03331778f, -0.02663293f, -0.00996655f, -0.00143842f, 0.14151762f, -0.06203850f, 
    0.04461019f, 0.03583674f, 0.11772853f, 0.02791774f, -0.02620540f, 0.08361948f, -0.09304762f, 0.14828005f, 
    0.09572796f, 0.23547222f, -0.01414924f, 0.14981836f, -0.25901672f, -0.25268826f, -0.50307685f, -0.00431213f, 
    0.06261885f, 0.13927567f, 0.04453893f, -0.06740694f, 0.10308933f, 0.02552951f, 0.00740158f, -0.11548875f, 
    0.07778374f, 0.13744408f, -0.03739359f, 0.06971972f, 0.02569932f, 0.00200144f, -0.15043929f, -0.10440960f, 
    0.04704136f, -0.02215314f, 0.02107450f, 0.02392332f, -0.21877344f, 0.18465108f, -0.04555823f, -0.23093973f, 
    0.06269892f, -0.08044672f, 0.15848796f, -0.10762575f, 0.11725039f, 0.03438393f, 0.14178741f, 0.00984100f, 
    0.29244769f, 0.32321697f, 0.24317957f, 0.15424336f, -0.07339022f, -0.10839070f, -0.09752601f, -0.04181180f, 
    0.06580696f, 0.03715402f, -0.04942854f, -0.00124310f, -0.21713693f, -0.28307289f, -0.27770624f, -0.01966856f, 
    0.07418238f, 0.05660862f, -0.02596762f, -0.07032242f, 0.00217973f, 0.02394966f, 0.15957980f, 0.12925377f, 
    0.05638982f, 0.09731986f, 0.00572548f, -0.01440431f, -0.07503008f, -0.03107483f, 0.04385515f, -0.04815035f, 
    0.09287444f, 0.10290112f, -0.03976745f, 0.21307524f, -0.12760252f, -0.00446410f, 0.24591711f, -0.11666018f, 
    0.04532347f, -0.02512441f, -0.02016217f, 0.11661579f, 0.25049782f, 0.01477616f, 0.18468702f, 0.06902426f, 
    -0.19565162f, -0.08202417f, -0.13756213f, -0.06465205f, -0.05385678f, -0.06467287f, 0.15974614f, 0.06371782f, 
    -0.10198366f, -0.05187421f, -0.06117823f, -0.06116278f, 0.17790908f, -0.11015685f, 0.09921826f, -0.10973741f, 
    0.06767355f, 0.03291971f, -0.11476571f, 0.02963592f, -0.01273294f, -0.01621835f, 0.00448759f, 0.10659704f, 
    -0.00807964f, 0.30480203f, -0.22216630f, -0.23322284f, -0.05247620f, -0.03453450f, 0.14482407f, -0.02212810f, 
    0.11936238f, 0.02874558f, 0.10453539f, 0.08203553f, 0.07434122f, -0.19516087f, 0.01912830f, 0.23237495f, 
    0.24833274f, 0.04920333f, -0.08658081f, -0.16688938f, -0.09635127f, 0.01904302f, 0.02587567f, 0.04171694f, 
    -0.06588549f, -0.03626600f, -0.14628242f, 0.09659193f, -0.04046174f, -0.01364367f, -0.09044233f, -0.22807509f, 
    0.14430921f, 0.09515791f, -0.01569527f, 0.03609644f, -0.10821708f, 0.01267480f, 0.11119304f, 0.10689046f, 
    0.00961230f, -0.02253680f, -0.02383781f, 0.05060406f, -0.00450481f, 0.02464272f, 0.03985074f, 0.08528548f, 
    0.20410024f, -0.03903029f, 0.14468537f, -0.26464710f, 0.05827734f, -0.11458799f, -0.14804754f, -0.02649423f, 
    0.05710581f, -0.02514995f, 0.05355806f, -0.06461936f, 0.17528465f, 0.19472106f, 0.17646316f, 0.12021625f, 
    -0.16632350f, -0.10018349f, -0.22527649f, -0.06694420f, -0.04873699f, 0.07937481f, -0.02798416f, 0.08406468f, 
    -0.06563340f, -0.09563468f, 0.12933038f, 0.06653628f, -0.04037872f, -0.11042541f, -0.12451068f, 0.04418039f, 
    0.02548374f, 0.01116484f, 0.06487298f, -0.07261296f, -0.12219467f, -0.08259066f, 0.17789820f, -0.04704840f, 
    -0.01656849f, 0.12637506f, -0.04012447f, 0.13192829f, 0.04461720f, 0.10199081f, 0.01462693f, -0.05161382f, 
    -0.06752209f, -0.00383147f, -0.06024475f, -0.01852229f, 0.03708792f, -0.01993352f, 0.05359627f, 0.23224448f, 
    0.01433123f, -0.05179840f, 0.03814739f, 0.16016386f, -0.02561784f, -0.02955330f, 0.11047847f, 0.00650151f, 
    0.01583591f, 0.12588041f, 0.10418949f, 0.07987466f, 0.21463884f, 0.12469697f, -0.00510578f, 0.13713163f, 
    0.32137525f, 0.23082055f, 0.28096047f, -0.00837489f, -0.02369865f, -0.23048903f, -0.07495171f, -0.05528458f, 
    -0.02742952f, -0.02113464f, 0.06391820f, 0.03071337f, 0.31255186f, -0.04590521f, 0.08746208f, 0.20312612f, 
    -0.08589124f, 0.06983951f, -0.04486065f, 0.17752649f, -0.08900363f, 0.08338532f, 0.07320174f, -0.07342740f, 
    0.14385684f, 0.03680988f, 0.12948270f, 0.03819106f, -0.02928184f, 0.06940854f, -0.07509742f, 0.03765729f, 
    -0.03103663f, 0.02304710f, -0.07605261f, -0.03039566f, -0.10611917f, 0.00542280f, 0.12690517f, -0.14109252f, 
    0.06162919f, -0.04245714f, -0.08669334f, 0.11534449f, 0.16680776f, -0.07334507f, 0.11962218f, 0.22569658f, 
    -0.12909551f, -0.23606521f, 0.06462065f, -0.11774020f, 0.06371676f, 0.00320279f, 0.11037502f, -0.07676345f, 
    -0.17021431f, -0.13567962f, -0.19914609f, -0.11832994f, -0.09518977f, -0.01600247f, -0.01459661f, -0.13945808f, 
    0.01612501f, -0.08684352f, 0.07882877f, 0.19270122f, -0.00514378f, -0.02464506f, 0.01495172f, -0.02772038f, 
    -0.12697807f, -0.25874579f, 0.32729018f, 0.15490247f, 0.01484390f, -0.05507791f, -0.08325185f, 0.04899260f, 
    0.17926714f, -0.00182719f, -0.03233929f, 0.03590614f, -0.21552114f, -0.13818349f, 0.03065039f, 0.04787521f, 
    0.18275133f, 0.04368107f, -0.00403668f, 0.10507597f, -0.17572805f, -0.03308698f, 0.05621343f, -0.22356233f, 
    -0.12992914f, -0.00542846f, -0.28634250f, -0.15485625f, 0.08902133f, -0.06175554f, 0.06525982f, 0.13939460f, 
    0.20207112f, 0.11677740f, 0.02996588f, 0.20320861f, -0.06576075f, -0.27295807f, 0.01050327f, -0.06175779f, 
    0.05270962f, 0.00739525f, -0.02274098f, -0.03508315f, 0.35028070f, 0.15672007f, 0.02002566f, 0.10008552f, 
    -0.22273822f, -0.10880817f, -0.08520824f, 0.25246894f, 0.08909914f, 0.06790172f, 0.08227414f, 0.16213304f, 
    -0.10951436f, -0.08308554f, -0.13713443f, -0.16210492f, -0.17339820f, -0.36227041f, 0.04985737f, -0.01723360f, 
    0.23212703f, 0.09785197f, 0.15364107f, 0.22348820f, 0.07717057f, -0.06951103f, -0.05055483f, 0.01553574f, 
    -0.07920694f, -0.15000221f, -0.01657839f, 0.05651655f, -0.07996297f, 0.03222748f, -0.09426171f, -0.13513124f, 
    -0.05092803f, -0.12769809f, -0.17777976f, 0.03840247f, 0.06086849f, 0.17091633f, 0.04345995f, 0.21655925f, 
    0.07396033f, 0.11335996f, 0.19912685f, -0.00615119f, 0.13965777f, 0.04269294f, 0.08435342f, -0.08255702f, 
    -0.15201341f, -0.19715974f, -0.06039181f, 0.00071761f, -0.06012442f, 0.06181137f, 0.03933719f, 0.07996402f, 
    0.09584882f, -0.01770067f, 0.08874349f, 0.09844603f, 0.08991172f, -0.06670234f, 0.08929340f, -0.07831676f, 
    0.12547377f, 0.01583243f, 0.06050246f, 0.08659039f, 0.06115169f, 0.15066428f, 0.07388867f, 0.06876820f, 
    -0.00124141f, 0.02066539f, -0.03234348f, -0.00697573f, 0.00132173f, -0.02274912f, -0.03547687f, 0.01671073f, 
    0.00496118f, 0.01748963f, -0.03624783f, -0.03446328f, -0.00914997f, -0.00437383f, -0.01870066f, 0.01563492f, 
    0.03238236f, -0.03696785f, -0.01204360f, -0.03728919f, -0.02747903f, -0.03045154f, -0.02764698f, -0.03972477f, 
    -0.03279217f, -0.00997301f, -0.02777705f, -0.02111512f, 0.02108518f, -0.03204622f, -0.01758468f, 0.02283782f, 
    0.01319603f, -0.02437199f, -0.02573223f, 0.01539142f, -0.02872633f, 0.01340843f, -0.00344597f, -0.01322506f, 
    -0.00108896f, -0.01405287f, -0.02740061f, -0.00161227f, -0.03157162f, -0.01705016f, -0.01771826f, 0.00972519f, 
    -0.01581303f, -0.00022078f, -0.01512947f, 0.02898647f, -0.03763614f, -0.02509230f, 0.01668956f, 0.00561027f, 
    0.02606318f, -0.00194366f, 0.02443881f, 0.02402109f, -0.02310475f, 0.00710330f, -0.01364675f, -0.03308843f, 
    -0.01953460f, -0.00686312f, 0.02398091f, 0.00629525f, -0.00369427f, -0.02139951f, 0.01083403f, 0.02490836f, 
    -0.01029223f, -0.01945413f, 0.00854323f, -0.00590558f, 0.02795854f, -0.00218202f, -0.02003456f, -0.03517389f, 
    -0.00013726f, 0.02363897f, -0.02174099f, -0.00344786f, -0.00636999f, -0.00464273f, 0.00187290f, -0.00694619f, 
    -0.03377079f, 0.01816091f, -0.03298577f, -0.01741463f, 0.00919180f, 0.03157603f, -0.00897252f, 0.02009060f, 
    -0.01489234f, -0.01434066f, 0.02829493f, 0.01559801f, -0.00373688f, 0.01700347f, -0.02118528f, 0.03247831f, 
    -0.00865116f, -0.03560546f, 0.01356035f, -0.01768150f, 0.01773417f, -0.02230179f, -0.00863409f, 0.00012185f, 
    -0.04006684f, -0.00083412f, 0.00942888f, 0.00533473f, -0.02262986f, 0.00897842f, -0.02182065f, -0.00388311f, 
    -0.03307884f, -0.02298402f, -0.01417187f, 0.02789268f, 0.00938517f, -0.00944768f, -0.00625289f, 0.00524851f, 
    -0.02110919f, 0.01447126f, -0.03482009f, 0.00522115f, -0.00327261f, 0.00033911f, -0.01131651f, 0.03113651f, 
    0.01869617f, -0.03381411f, 0.00258235f, -0.03347257f, -0.02654733f, -0.02190433f, 0.01863637f, 0.02631498f, 
    -0.04075753f, 0.02671479f, 0.01884756f, -0.00243375f, 0.00117964f, -0.03134196f, -0.00069845f, -0.02251068f, 
    -0.01421410f, -0.02223229f, 0.01694532f, -0.00355247f, 0.00836070f, -0.02051877f, 0.01304844f, 0.02538139f, 
    0.02906590f, 0.00047191f, -0.03587291f, -0.00881482f, -0.00118260f, 0.02433232f, 0.00988914f, 0.00506737f, 
    -0.03081546f, 0.00739805f, -0.03540574f, -0.02878802f, 0.00147743f, -0.03560869f, -0.02770737f, -0.02546582f, 
    -0.03311760f, 0.01957999f, -0.03180275f, 0.02013530f, -0.01079162f, -0.03137565f, 0.00926840f, 0.02008487f, 
    0.00528619f, 0.00082431f, -0.02793013f, -0.00182949f, -0.03515453f, -0.00094941f, 0.01294317f, 0.01732850f, 
    0.03006876f, 0.00707964f, 0.02539774f, -0.04181431f, -0.02861310f, -0.02823302f, 0.01183751f, -0.03792928f, 
    -0.02695852f, -0.00979932f, 0.00878896f, 0.02428206f, 0.02911216f, -0.00065767f, 0.01338514f, 0.01117185f, 
    0.02627514f, -0.00241618f, -0.03247895f, 0.01847729f, -0.00812936f, -0.02084354f, 0.01516292f, 0.02967885f, 
    -0.02212319f, -0.00315713f, -0.00374767f, 0.01107653f, 0.01492438f, -0.02567961f, -0.01574430f, -0.00157438f, 
    0.02311141f, -0.00506900f, 0.03154944f, -0.02087901f, 0.00250562f, -0.02951458f, 0.03143285f, 0.01960119f, 
    -0.02190888f, 0.02444344f, -0.02162894f, -0.00081117f, -0.01315311f, -0.00916976f, 0.02772629f, 0.02950093f, 
    -0.00543088f, 0.00313540f, 0.00146620f, 0.00566729f, 0.00832068f, 0.03227466f, 0.00939789f, -0.02947430f, 
    0.02082656f, 0.02330942f, -0.03672861f, 0.01448934f, -0.03069054f, 0.00129909f, -0.00937691f, -0.01987894f, 
    0.01412537f, 0.01338814f, -0.03153674f, -0.04161040f, -0.00080883f, -0.01253972f, 0.01190959f, -0.00486422f, 
    -0.00811521f, 0.02504919f, -0.03850961f, -0.02194575f, -0.01126298f, -0.01443280f, 0.01798020f, -0.00281131f, 
    -0.00457275f, -0.01394166f, 0.02372127f, 0.02784683f, -0.00131779f, 0.01519253f, -0.01640257f, -0.00848265f, 
    0.01495258f, 0.01935234f, 0.01777876f, 0.01983539f, -0.00821684f, 0.02463475f, -0.01068548f, 0.01752929f, 
    -0.02033786f, -0.02782755f, -0.02318031f, -0.03108769f, -0.00571418f, -0.02700062f, -0.02085513f, 0.01293590f, 
    0.02127312f, -0.02970824f, -0.02612866f, -0.02557315f, -0.03483884f, -0.01804719f, -0.02247149f, -0.02007486f, 
    0.01953581f, 0.03009186f, -0.03027241f, 0.00806670f, -0.01876773f, -0.02634771f, 0.02191360f, -0.02445533f, 
    0.00730826f, -0.03014820f, 0.02500740f, -0.03174534f, 0.01345818f, 0.00247823f, -0.00229936f, 0.01228244f, 
    0.01266343f, -0.01680391f, -0.03280334f, 0.00493913f, -0.02196108f, -0.04032390f, 0.00404924f, -0.01214770f, 
    -0.03129356f, 0.02958653f, -0.01184998f, -0.02728240f, -0.01515847f, -0.00418262f, -0.02686456f, 0.00114715f, 
    0.02728084f, 0.01800288f, 0.02070069f, -0.00018160f, -0.01575940f, 0.00593559f, 0.02765209f, 0.01288350f, 
    -0.02145287f, 0.02318875f, 0.00897694f, -0.03277100f, 0.01418637f, -0.03779940f, 0.00673321f, -0.01857412f, 
    -0.01881493f, -0.02648240f, -0.04035312f, -0.01542550f, -0.03625929f, 0.02210698f, 0.00491221f, -0.04205986f, 
    -0.01628222f, -0.01592499f, -0.03207534f, 0.02227288f, -0.01239348f, -0.01426115f, -0.00388007f, 0.02839792f, 
    -0.01523996f, 0.01140415f, -0.01451856f, -0.03131041f, 0.02909107f, -0.03351589f, -0.00224723f, -0.01921536f, 
    0.02164750f, -0.02950153f, -0.01646799f, 0.00588886f, -0.00823076f, -0.01489484f, 0.00600612f, -0.00736794f, 
    -0.00561561f, -0.03939817f, -0.01470339f, 0.02692570f, -0.01711934f, 0.01256209f, 0.02384654f, -0.01793239f, 
    0.00333152f, 0.00164452f, -0.03254795f, 0.01158514f, 0.00089765f, 0.02957031f, -0.03133454f, -0.00578547f, 
    -0.01532616f, 0.02347730f, -0.02015449f, 0.01279536f, 0.01983930f, 0.00230770f, 0.00907471f, -0.02116320f, 
    0.02910957f, 0.00095087f, -0.02334262f, -0.01852078f, 0.00771297f, 0.02409865f, -0.00751545f, 0.02817739f, 
    0.02824655f, -0.02982897f, -0.03343845f, -0.02517817f, 0.02019337f, -0.01547999f, 0.02139511f, -0.01285839f, 
    0.01132764f, 0.00250957f, -0.02769307f, 0.01979548f, 0.01439509f, 0.02010883f, -0.03535291f, -0.02524416f, 
    0.01745630f, 0.02746438f, -0.00103905f, -0.01495192f, -0.00421154f, 0.01240569f, -0.02466160f, -0.01460611f, 
    0.01691555f, 0.02568112f, -0.00942187f, 0.02775314f, -0.03126720f, -0.03027475f, -0.03942395f, -0.01507477f, 
    -0.02363408f, 0.02751110f, 0.02833848f, 0.01103575f, -0.01719530f, -0.03787812f, -0.02316825f, -0.01716015f, 
    0.01149726f, 0.02923697f, 0.00479101f, -0.00938188f, 0.00619701f, 0.01764039f, 0.02933150f, -0.02636889f, 
    -0.03922928f, -0.01355180f, -0.00245051f, 0.00028623f, -0.03255413f, -0.03423718f, -0.02425271f, -0.04196684f, 
    -0.00501597f, -0.03992214f, -0.00160411f, -0.01912318f, 0.02476465f, 0.01981090f, -0.02502331f, -0.02241368f, 
    0.02133640f, 0.03002008f, -0.00613826f, -0.00097420f, -0.03604542f, 0.01942889f, 0.02474616f, 0.01743171f, 
    -0.02462963f, -0.01156493f, -0.04116456f, 0.00435844f, -0.03253072f, 0.00409428f, 0.03301180f, 0.00974116f, 
    -0.03255735f, 0.01867473f, 0.01399171f, 0.01881868f, -0.03592177f, 0.00535066f, 0.02236308f, -0.02006577f, 
    0.00859491f, -0.02135334f, -0.00253236f, 0.02517352f, -0.00795776f, -0.00437262f, -0.00805253f, 0.00694306f, 
    0.00202528f, -0.01718088f, -0.02398472f, -0.00596911f, -0.02739846f, 0.00186046f, -0.03583367f, -0.02540891f, 
    -0.00040894f, -0.03833391f, 0.01759711f, 0.02640258f, -0.00718759f, 0.01908034f, -0.03094532f, 0.00626755f, 
    0.01269273f, -0.00889504f, -0.02075293f, -0.00519224f, -0.00475982f, -0.01930171f, -0.03271197f, -0.03027025f, 
    -0.02940809f, 0.00158589f, -0.02174017f, -0.00760441f, -0.03932975f, 0.00767431f, 0.02777111f, -0.00233014f, 
    -0.00628778f, 0.01667089f, -0.00472871f, 0.00231658f, -0.04113846f, -0.02569016f, -0.03350201f, 0.01777825f, 
    0.00363575f, 0.02014451f, -0.00862526f, 0.02103571f, 0.00832466f, 0.02624623f, -0.03528726f, 0.03439932f, 
    -0.02753932f, 0.01278988f, -0.02326929f, -0.01067368f, -0.01672152f, -0.01795636f, -0.04155926f, -0.03607915f, 
    -0.01773443f, -0.02663634f, 0.02746142f, -0.02996846f, 0.00710426f, 0.02143794f, -0.01778885f, -0.03232651f, 
    0.01392512f, -0.00234160f, -0.03016537f, -0.00554173f, 0.00994152f, -0.03330654f, -0.02674805f, -0.01747095f, 
    -0.01195694f, 0.01166005f, -0.03823467f, -0.01854794f, 0.01789395f, 0.02974490f, 0.02856524f, -0.00542656f, 
    0.00172813f, -0.02820875f, -0.03490157f, -0.02085902f, 0.01203428f, -0.04074107f, -0.00387706f, 0.02939137f, 
    0.02755724f, -0.00577933f, 0.03218963f, -0.02112435f, -0.01848809f, -0.01512323f, -0.03293332f, -0.02214587f, 
    -0.02864446f, 0.01199879f, -0.00662052f, -0.00465908f, 0.01160078f, -0.01749354f, -0.00001476f, 0.02381482f, 
    -0.03481827f, -0.00791077f, -0.03766756f, 0.02472504f, 0.03303218f, 0.00596529f, -0.00738207f, 0.02433382f, 
    -0.02577853f, 0.01865048f, 0.01211185f, 0.02859022f, 0.00155505f, -0.03985535f, -0.01295254f, -0.00961048f, 
    0.00215323f, -0.01784953f, -0.01934963f, -0.03847318f, 0.01977605f, 0.00283788f, -0.02651351f, -0.03932169f, 
    -0.02949459f, -0.03329074f, -0.02078195f, -0.01421408f, -0.01377366f, -0.03834101f, -0.03500564f, -0.03471443f, 
    0.02215026f, 0.00522715f, 0.02522356f, -0.03560958f, -0.00133649f, 0.01550769f, -0.03106549f, -0.02681367f, 
    0.03116800f, -0.01769209f, 0.00498812f, -0.00522707f, -0.02834474f, -0.00581536f, -0.00346418f, -0.02274953f, 
    -0.00087551f, 0.01308744f, 0.02257192f, -0.02513767f, -0.01733809f, -0.04129375f, 0.02512149f, -0.03554569f, 
    -0.02802474f, -0.01987749f, -0.02009680f, 0.01867997f, -0.01748184f, -0.00197672f, -0.03538177f, 0.01475498f, 
    -0.02026651f, -0.03132118f, -0.00001143f, -0.04165137f, 0.01684765f, -0.03524698f, -0.01902992f, -0.01152120f, 
    -0.03241095f, -0.00522750f, 0.01225106f, 0.02347542f, -0.03573140f, -0.01262577f, -0.03467641f, -0.02304905f, 
    -0.01313638f, -0.02104556f, 0.02562247f, 0.00871276f, 0.02317966f, 0.02182085f, 0.01200776f, -0.02291954f, 
    -0.03161761f, 0.00543531f, -0.02926940f, 0.00410409f, -0.01187194f, 0.00304659f, -0.03649729f, 0.02746744f, 
    0.02686942f, -0.00368434f, 0.02230931f, -0.02089123f, 0.01148822f, -0.01728624f, 0.02276159f, -0.02338942f, 
    -0.00467611f, 0.00156927f, -0.04098695f, 0.01132517f, 0.02643832f, 0.01359813f, 0.01910591f, -0.02732756f, 
    0.01395919f, 0.00304836f, -0.03682387f, -0.03137392f, -0.00369770f, 0.00242606f, 0.01138911f, -0.01709198f, 
    -0.00801635f, 0.00229901f, -0.02115484f, 0.01997662f, -0.00491275f, -0.00451493f, 0.01699657f, -0.04131108f, 
    0.01535862f, 0.02579638f, -0.02653020f, -0.02617139f, 0.03240257f, -0.01347600f, -0.00204633f, -0.02787066f, 
    -0.03807322f, -0.03869380f, 0.02981128f, -0.02881398f, -0.00247766f, -0.04093108f, -0.04018907f, -0.03017930f, 
    -0.02502966f, -0.01175482f, 0.01082218f, -0.03079545f, -0.01068794f, 0.01310986f, -0.01600926f, 0.02050788f, 
    0.02133759f, -0.03078309f, -0.02164673f, 0.01916808f, -0.00951808f, -0.00986354f, 0.00161958f, -0.03023795f, 
    -0.01032377f, -0.02228536f, -0.01379181f, 0.00703192f, -0.01730380f, -0.02625234f, 0.01393704f, -0.00825151f, 
    -0.00262161f, 0.01909747f, 0.00268005f, -0.00098285f, 0.01260876f, -0.01780852f, -0.00189720f, -0.02936988f, 
    0.00340963f, -0.00225033f, -0.01068469f, -0.02695874f, -0.03503307f, 0.02572119f, 0.01132962f, 0.00439241f, 
    0.01539256f, -0.03577326f, 0.00122786f, 0.02368909f, -0.03785045f, -0.01876959f, -0.01322997f, -0.00121199f, 
    0.02834039f, -0.04068954f, 0.00420347f, 0.02044546f, -0.03309799f, -0.04141727f, 0.02862533f, 0.01403661f, 
    0.00609500f, -0.02731988f, 0.01542756f, 0.01235672f, -0.00601381f, -0.03458853f, 0.01593949f, -0.00765753f, 
    -0.03140741f, -0.00327241f, 0.01702140f, 0.02319597f, 0.02409653f, 0.00904975f, -0.00664321f, -0.01934098f, 
    0.00450897f, -0.01705970f, -0.03514920f, 0.00296185f, -0.03951488f, 0.02648506f, 0.01143966f, -0.02934600f, 
    0.00934083f, 0.00975395f, 0.01334306f, -0.01232208f, -0.03362958f, -0.01783998f, -0.02857557f, -0.02688760f, 
    -0.03894842f, -0.03116933f, -0.00069259f, -0.01576682f, 0.02866210f, -0.01340949f, -0.01536882f, 0.00765381f, 
    0.02048145f, -0.02456512f, 0.01584667f, 0.01638086f, -0.03872027f, 0.01492609f, 0.03212494f, 0.03405900f, 
    -0.01959642f, -0.02597184f, 0.00113623f, 0.00837061f, -0.02181918f, -0.03474450f, 0.02036753f, -0.01644823f, 
    0.00571528f, 0.01906133f, 0.02670613f, -0.03103404f, -0.01745266f, -0.00208697f, -0.00270848f, -0.02564751f, 
    0.01737694f, 0.00501366f, -0.01038438f, 0.00738032f, -0.00130724f, 0.00577725f, -0.03151308f, -0.02939322f, 
    0.00831889f, 0.01591458f, 0.03415461f, -0.02005953f, 0.02247675f, 0.02349213f, -0.01767885f, -0.02668184f, 
    0.02292795f, -0.00825081f, -0.01788378f, 0.00772401f, 0.00251648f, -0.01733235f, 0.00612089f, -0.00092361f, 
    0.02242843f, -0.02605734f, 0.02467925f, -0.03593509f, -0.02515481f, 0.01113891f, 0.01762892f, -0.03192730f, 
    0.01354343f, -0.02561108f, 0.02883843f, 0.02413541f, 0.02534924f, 0.00683147f, 0.02157884f, -0.03864276f, 
    -0.00771981f, 0.01981296f, -0.02486858f, -0.01198721f, -0.04203997f, 0.01140441f, -0.01839122f, -0.01174273f, 
    0.00311942f, -0.00800969f, 0.02855665f, 0.01132314f, 0.02534299f, -0.01475149f, -0.00257341f, -0.02172855f, 
    -0.00778599f, -0.00718484f, -0.02921479f, -0.01914475f, 0.02341033f, 0.01449571f, -0.02071626f, 0.02952308f, 
    -0.00715909f, 0.01227247f, 0.00604521f, 0.00219119f, -0.01019884f, 0.01843310f, 0.01879361f, -0.00910853f, 
    -0.03138908f, -0.00868577f, -0.00881170f, -0.02111859f, -0.03865951f, -0.03128829f, -0.02908475f, 0.00519799f, 
    -0.03678776f, 0.00224620f, 0.02144555f, 0.01417617f, -0.02607054f, -0.02528554f, -0.00747783f, 0.02418410f, 
    -0.04196332f, -0.02146862f, -0.00594367f, 0.02274177f, 0.02933368f, -0.03040277f, 0.00844876f, -0.03272618f, 
    0.01247078f, 0.02555557f, 0.02794785f, -0.03986861f, 0.01608490f, -0.01528734f, -0.02547457f, -0.04006783f, 
    -0.01829145f, -0.02257305f, -0.00710524f, -0.03792486f, 0.02990844f, -0.03605291f, 0.00590878f, -0.03101579f, 
    -0.01087057f, -0.03704323f, -0.00382808f, -0.03015290f, -0.01957810f, 0.01467771f, 0.01953487f, -0.03256311f, 
    0.02959108f, 0.02910106f, -0.01976169f, 0.01460528f, 0.01618722f, -0.02113309f, -0.03984782f, 0.01731989f, 
    0.03538550f, -0.03399152f, 0.01565954f, -0.01116565f, 0.02951594f, -0.03783436f, -0.03678476f, -0.02819406f, 
    0.00349619f, 0.02952498f, 0.01730164f, -0.00420846f, 0.00217690f, -0.02114308f, -0.00288318f, 0.02766834f, 
    -0.02652199f, -0.02050304f, 0.01942929f, -0.02333585f, -0.00681340f, 0.00127030f, -0.02633109f, -0.03370715f, 
    -0.01077711f, -0.02192618f, -0.03215726f, -0.00169440f, -0.01502652f, 0.02652310f, -0.03476613f, -0.02053308f, 
    0.00880933f, 0.01336921f, 0.00397418f, 0.00783611f, 0.02735608f, -0.01877734f, 0.01552134f, 0.02292048f, 
    0.02880623f, -0.00562878f, 0.00802019f, -0.03031288f, -0.03319222f, -0.01722698f, -0.00680884f, -0.01456835f, 
    -0.02185359f, -0.00538889f, -0.02027361f, -0.02229887f, -0.00162324f, -0.02956217f, -0.03803264f, -0.03644800f, 
    0.01479352f, 0.02609154f, -0.02835652f, -0.01881330f, -0.01166985f, 0.03189325f, -0.01671592f, 0.02168056f, 
    0.00123391f, 0.02802625f, 0.02119984f, -0.00856454f, 0.01148127f, -0.03002077f, -0.00631970f, -0.03447847f, 
    -0.01699399f, 0.00315956f, 0.01959804f, -0.03156749f, -0.01651982f, 0.00375895f, 0.00290188f, -0.02892190f, 
    -0.01705223f, 0.00756860f, 0.01391045f, -0.01454566f, -0.00959461f, -0.02013174f, 0.01356548f, -0.02568544f, 
    0.01487734f, -0.03834488f, -0.01319235f, -0.02266085f, -0.02285999f, -0.00606307f, 0.01721532f, -0.02108081f, 
    0.00772087f, -0.03227612f, -0.02504154f, -0.02768220f, -0.01471799f, 0.00760717f, -0.00883825f, 0.01787858f, 
    -0.00675000f, -0.03539863f, 0.01119843f, 0.02165931f, -0.02461563f, -0.00532341f, -0.00805769f, 0.00072172f, 
    0.01717827f, 0.02015422f, -0.00918903f, -0.02094427f, -0.03386584f, 0.02081986f, -0.01569768f, -0.00380987f, 
    -0.01159023f, -0.01457187f, -0.02775567f, -0.02749556f, -0.02412700f, 0.02314431f, -0.03430129f, 0.01298260f, 
    0.00744601f, -0.00369927f, -0.01267031f, 0.02545320f, -0.00132183f, -0.02862030f, -0.03110272f, -0.00940201f, 
    -0.03788388f, -0.02878027f, -0.02666908f, -0.03635176f, 0.01496714f, -0.00271024f, -0.01355646f, -0.01490324f, 
    0.00079678f, 0.02709852f, -0.03940986f, 0.01701052f, -0.02699330f, 0.02894795f, -0.03447131f, -0.00568757f, 
    0.02939950f, 0.02192759f, 0.01446605f, -0.00339774f, 0.00666226f, 0.00140585f, -0.01607450f, -0.01557222f, 
    -0.02193602f, 0.01602684f, -0.02672375f, -0.01075443f, -0.04108364f, -0.01070782f, -0.02106923f, -0.02894292f, 
    0.01670569f, 0.00681648f, 0.00832611f, 0.02858304f, -0.03557455f, 0.00386981f, 0.01828001f, -0.00387954f, 
    -0.02969898f, -0.03408456f, -0.00464249f, 0.01674163f, -0.03311330f, -0.04177006f, 0.00481983f, 0.01293545f, 
    -0.01856640f, -0.00483068f, -0.01206664f, 0.00053649f, -0.01446435f, -0.00150640f, 0.00008319f, -0.03684542f, 
    0.02402848f, -0.00962444f, -0.03457023f, -0.02887496f, -0.02068006f, -0.03869735f, -0.03462800f, 0.01543319f, 
    -0.00267955f, 0.02542221f, 0.00960231f, 0.00596606f, 0.00035585f, -0.02625829f, -0.01060518f, -0.00685788f, 
    -0.02670388f, -0.04203662f, 0.02432154f, -0.03050955f, -0.01567226f, 0.00537738f, -0.02126747f, -0.02861818f, 
    -0.00697947f, 0.01631580f, 0.03184346f, -0.03450790f, -0.00775030f, -0.04018001f, -0.03502733f, -0.00171978f, 
    -0.03450026f, -0.03136439f, -0.00322423f, 0.00149947f, 0.00250072f, -0.01898459f, -0.00946171f, -0.00522933f, 
    0.00122672f, 0.00359968f, -0.03498394f, -0.03781322f, 0.02593828f, 0.02611677f, -0.03354033f, 0.00308941f, 
    -0.03060286f, 0.02025768f, -0.03548027f, 0.02971811f, -0.00273736f, -0.01026012f, 0.00361988f, 0.00295726f, 
    -0.02930512f, -0.03731716f, 0.02728644f, -0.02541904f, -0.00721442f, 0.02731773f, -0.03932999f, -0.03632661f, 
    -0.02510109f, 0.01725385f, -0.01537950f, -0.02657741f, 0.01746393f, -0.02173712f, 0.01192565f, 0.00305074f, 
    0.01367171f, -0.03874382f, 0.00182222f, 0.02566284f, -0.02047188f, -0.00110379f, -0.00838860f, -0.02291487f, 
    -0.04082494f, -0.02396535f, 0.02163125f, -0.01930392f, 0.02491748f, -0.03267397f, -0.00969011f, 0.02211644f, 
    0.02987568f, 0.02552638f, -0.02114606f, -0.03891553f, 0.00939013f, -0.02799864f, 0.00859130f, 0.01917003f, 
    -0.02211202f, 0.01043647f, -0.03934446f, -0.03588754f, -0.02838141f, -0.03267616f, -0.00532959f, 0.01789472f, 
    -0.03771181f, 0.00276349f, -0.00408565f, 0.00108181f, 0.00421738f, -0.03072993f, 0.02009614f, 0.01891468f, 
    0.01559067f, 0.02897185f, -0.02690331f, -0.01621475f, 0.00291406f, -0.01686439f, 0.01128359f, 0.02707776f, 
    0.00603584f, 0.01309754f, 0.00206300f, 0.01552820f, 0.00809759f, -0.00677438f, 0.00474551f, -0.03717626f, 
    -0.03090965f, -0.04106440f, -0.03802248f, -0.02626864f, -0.03403495f, 0.02702143f, 0.02929313f, -0.01421516f, 
    0.02324686f, -0.01036992f, -0.01058305f, -0.00675252f, 0.02788841f, -0.01747891f, -0.02004868f, 0.00547331f, 
    -0.00767987f, 0.02941612f, 0.01954296f, 0.02842993f, 0.02706463f, -0.00547575f, -0.01143431f, -0.00346630f, 
    0.00154640f, -0.01314088f, 0.01702803f, 0.02466657f, 0.00895404f, -0.03893512f, 0.01554904f, -0.02471872f, 
    0.00177975f, -0.02812059f, 0.02452486f, 0.01274664f, -0.01414026f, -0.02768499f, 0.00506845f, -0.01044419f, 
    -0.00779348f, 0.01871487f, -0.03893246f, -0.03253567f, -0.04202154f, -0.02470773f, -0.00289660f, -0.03980046f, 
    -0.00344656f, -0.03453634f, -0.01947751f, -0.01550197f, -0.02097449f, -0.01277962f, -0.00835292f, -0.02331770f, 
    0.02887559f, 0.00926685f, 0.00732927f, -0.02229137f, 0.02523298f, -0.00856323f, -0.02801029f, -0.01400495f, 
    0.02398732f, -0.03328774f, -0.00860368f, -0.01309509f, 0.00816065f, -0.02371226f, -0.02503098f, -0.02969540f, 
    -0.03869465f, 0.00487276f, 0.00020542f, 0.02650926f, 0.01611780f, -0.02816714f, 0.00782508f, -0.02791999f, 
    -0.01843239f, -0.00068596f, -0.02788499f, 0.01665612f, -0.00266245f, 0.00849727f, -0.03539361f, -0.01497687f, 
    -0.02528173f, 0.00257007f, 0.02154744f, -0.00925637f, 0.02756718f, -0.04122530f, 0.00793854f, -0.02467858f, 
    0.01709136f, -0.01106072f, -0.03348217f, -0.00083448f, -0.03246044f, 0.01891225f, 0.02122749f, 0.02222031f, 
    0.02947399f, -0.01263984f, -0.00628614f, -0.00172531f, -0.00379832f, -0.04001665f, 0.01948272f, -0.01676986f, 
    -0.02849701f, -0.02751940f, 0.01931905f, -0.00489068f, -0.02294229f, 0.02026840f, -0.01990451f, 0.01320379f, 
    -0.02466559f, 0.00346359f, -0.00800760f, -0.02119116f, -0.03104710f, 0.02363285f, 0.02057719f, 0.02318887f, 
    0.00843803f, 0.00442317f, -0.03953086f, -0.01753721f, -0.00136155f, -0.02128337f, -0.00126725f, -0.01353195f, 
    -0.03973843f, -0.03413595f, -0.02641116f, -0.04123002f, -0.01453574f, 0.00506737f, -0.03855877f, 0.01041432f, 
    0.02954558f, 0.02222693f, 0.01396350f, -0.03470753f, 0.01843949f, -0.00589152f, -0.03552540f, 0.01866292f, 
    0.00199751f, 0.00796014f, -0.00462576f, -0.02885844f, -0.01101568f, 0.03451808f, -0.00536530f, -0.00307332f, 
    -0.03273255f, -0.01523668f, -0.02479484f, 0.00333216f, -0.00575634f, 0.01029863f, -0.03312533f, 0.01617368f, 
    -0.01393985f, 0.02767604f, -0.02473566f, -0.00981187f, -0.00195011f, -0.03527212f, 0.02531764f, 0.01282703f, 
    -0.00597361f, -0.01822014f, -0.02214072f, 0.00771449f, -0.03442146f, 0.01353864f, -0.01875306f, -0.01048489f, 
    0.03436683f, -0.02332199f, -0.02486756f, 0.01071875f, 0.02292839f, -0.01241955f, -0.01250876f, 0.00017893f, 
    0.01044330f, 0.03412043f, -0.02623383f, 0.01031848f, 0.02198784f, -0.03500937f, -0.02324155f, 0.01310322f, 
    -0.00893933f, 0.01280767f, -0.00645196f, 0.00527010f, 0.01663363f, 0.00396110f, 0.02835108f, 0.01787710f, 
    0.05502750f, 0.04761463f, 0.01770563f, -0.09699526f, 0.00802100f, 0.02156822f, 0.01131254f, 0.08355210f, 
    -0.07946125f, 0.00639947f, -0.00944493f, -0.03257830f, -0.33684534f, 0.29995298f, -0.12697925f, 0.20854673f, 
    0.10996085f, -0.16430472f, 0.18263781f, -0.04143716f, 0.01345189f, 0.04486097f, 0.06608529f, 0.08141040f, 
    0.03828226f, -0.17847081f, -0.13253713f, 0.09574617f, -0.11575207f, -0.04791274f, 0.07534704f, 0.08553943f, 
    0.04837283f, 0.03708502f, -0.17830332f, 0.00871414f, 0.11903657f, 0.59039098f, 0.01179461f, -0.24255311f, 
    0.12540932f, 0.02736975f, -0.15793180f, -0.00314247f, -0.12375582f, 0.00213897f, 0.06338651f, -0.00565630f, 
    -0.00485674f, -0.14446996f, -0.01616677f, -0.19769800f, 0.10657769f, -0.02696585f, 0.02011125f, -0.06117930f, 
    0.04993850f, 0.04222000f, -0.09610832f, 0.11224490f, -0.01558599f, -0.28768775f, -0.03804366f, -0.04581184f, 
    0.11359689f, 0.10451568f, 0.05637522f, 0.00494552f, 0.15531509f, 0.00155735f, -0.08562336f, 0.06219545f, 
    -0.39923409f, 0.14002946f, 0.09905952f, 0.08215289f, 0.11275660f, 0.07151371f, -0.02905877f, 0.03161912f, 
    0.16520305f, -0.04400328f, 0.02211535f, 0.12719022f, 0.10375899f, -0.11826601f, -0.27371007f, -0.08811375f, 
    0.08491297f, 0.03690793f, 0.07928751f, 0.04001510f, -0.15095659f, -0.07408401f, -0.10806445f, -0.10940531f, 
    0.27715161f, 0.00431314f, 0.16039805f, -0.08290618f, 0.05241919f, -0.08008204f, 0.05202093f, -0.02730971f, 
    0.07050335f, -0.11579955f, -0.20720960f, -0.14873689f, -0.28302121f, -0.08833749f, 0.08281304f, -0.25622123f, 
    -0.07330592f, -0.05103719f, 0.01495221f, -0.02249603f, 0.16292359f, -0.08753391f, 0.06855396f, 0.14581473f, 
    0.00723184f, 0.22379367f, 0.01189286f, 0.24694775f, 0.04471122f, 0.10313870f, -0.03093016f, 0.13109916f, 
    -0.04355787f, 0.11103982f, 0.11359643f, 0.00856379f, 0.11447155f, 0.28351760f, 0.08713327f, -0.18956526f, 
    -0.09619150f, -0.06040623f, -0.05047869f, 0.10941786f, -0.07202068f, -0.06203395f, -0.01261437f, -0.10603412f, 
    -0.12467884f, -0.00283252f, 0.01233688f, -0.00173763f, -0.01292172f, -0.02908213f, -0.10194163f, -0.14130574f, 
    -0.02419141f, 0.04309115f, 0.08779532f, 0.06389629f, 0.02672884f, 0.07392428f, -0.15243016f, 0.10052333f, 
    0.04448626f, -0.05950519f, 0.18287939f, -0.06240200f, -0.09211358f, 0.04868171f, -0.05056620f, -0.04468801f, 
    0.20586790f, -0.06106716f, 0.27218321f, 0.04688397f, 0.12201098f, 0.04394573f, -0.05441310f, 0.02641974f, 
    0.16922154f, 0.03353608f, 0.06460178f, 0.06929316f, -0.25685537f, 0.04769047f, 0.05923590f, -0.11044753f, 
    0.01697386f, -0.05991614f, 0.07680400f, 0.00328538f, -0.05421326f, -0.22132868f, -0.03282711f, -0.11732253f, 
    -0.25685257f, 0.18406145f, -0.27960917f, 0.15121786f, 0.14830153f, 0.04957141f, -0.19241180f, 0.02806341f, 
    0.01425383f, -0.00172307f, 0.09882021f, 0.04217912f, 0.16824748f, 0.07997966f, -0.20135230f, -0.07305406f, 
    0.04390514f, -0.05321043f, 0.03271393f, -0.00978244f, 0.06663417f, 0.20992969f, 0.19020008f, -0.05072122f, 
    0.12997442f, -0.22030273f, -0.00409808f, -0.07513175f, 0.06713786f, 0.10195795f, -0.02320882f, -0.09147503f, 
    0.06328169f, 0.02149971f, 0.07522518f, -0.15749052f, -0.34305730f, 0.13607289f, -0.07229441f, 0.10670725f, 
    0.10220022f, -0.11352764f, -0.02390439f, 0.12583517f, -0.07632474f, 0.05166307f, 0.03672951f, -0.02463643f, 
    0.16918327f, 0.15004969f, 0.03245759f, -0.05498299f, 0.08027895f, -0.00068681f, 0.10735618f, 0.12957589f, 
    0.03710944f, 0.01211763f, -0.01611834f, -0.04338851f, 0.22975066f, 0.06797656f, -0.15073715f, -0.01459495f, 
    0.04884521f, -0.07766666f, -0.05191172f, 0.01033802f, 0.03010003f, 0.04156909f, 0.01811136f, 0.04225186f, 
    -0.33215517f, 0.28963259f, 0.01162953f, 0.20223789f, 0.02318020f, -0.10839940f, -0.13846064f, -0.02848485f, 
    0.02360763f, -0.01636623f, 0.12180255f, 0.11251423f, 0.54442447f, -0.04361925f, -0.14398111f, -0.30312344f, 
    0.22965324f, 0.15183617f, 0.03983653f, 0.20523041f, 0.05814971f, -0.06452792f, 0.13199849f, -0.05456055f, 
    -0.38347772f, 0.19242707f, 0.22081356f, -0.02384627f, -0.09031107f, 0.06381061f, 0.01890591f, 0.15293245f, 
    -0.10849887f, 0.03545206f, 0.11575954f, -0.09788712f, 0.07301617f, 0.04359809f, -0.29569262f, -0.03329023f, 
    0.11038266f, 0.13402428f, 0.03691119f, 0.14331579f, -0.03685402f, -0.10316626f, -0.11458666f, 0.09394497f, 
    -0.17799512f, 0.11614901f, -0.06391262f, -0.07393931f, -0.05789347f, 0.00921504f, -0.09627697f, 0.01348355f, 
    0.19571231f, 0.02665609f, 0.08350448f, 0.18498892f, 0.28765821f, -0.12702057f, -0.14204325f, -0.06680339f, 
    0.09718196f, -0.03660825f, 0.00347614f, 0.03730460f, -0.06106609f, -0.01060868f, -0.04433040f, -0.10040823f, 
    -0.04969872f, 0.07593367f, -0.08813229f, -0.07923766f, -0.05672356f, -0.05291011f, 0.15634350f, -0.05488687f, 
    -0.09662815f, -0.05197909f, 0.00071269f, -0.03512563f, -0.01868942f, -0.03751320f, 0.09245300f, -0.12320743f, 
    -0.07266632f, 0.00109917f, -0.10884756f, 0.13416833f, 0.05667262f, 0.00957171f, 0.01507855f, 0.06899115f, 
    0.04952982f, -0.01425688f, 0.02534497f, -0.13110819f, -0.07038409f, -0.01076169f, -0.05205987f, 0.06939783f, 
    0.09452356f, -0.07221208f, 0.08611643f, 0.10354140f, -0.14843366f, 0.05753036f, -0.15897676f, 0.04010194f, 
    0.03711505f, -0.03970361f, 0.08336924f, 0.01081787f, -0.07827242f, 0.05005090f, 0.04901986f, -0.03087725f, 
    -0.00305627f, -0.37389916f, -0.15077551f, -0.01911399f, 0.04099672f, -0.01207641f, 0.05093810f, 0.05202964f, 
    0.10742150f, 0.06960873f, 0.02490872f, -0.07233921f, -0.06921387f, 0.06723426f, 0.00144049f, -0.04861012f, 
    -0.00416141f, -0.03858628f, -0.08373395f, -0.08858996f, 0.01907873f, -0.13474189f, 0.00118203f, 0.05222507f, 
    -0.06413058f, -0.09860200f, -0.00286876f, -0.02119002f, -0.01139117f, -0.07006791f, 0.00631623f, -0.06798685f, 
    0.00279691f, -0.00354490f, -0.05132219f, -0.13713156f, 0.02801454f, -0.01609177f, -0.13664958f, -0.02632593f, 
    0.11340061f, 0.06814601f, -0.00574092f, 0.03421672f, -0.10084780f, -0.08209390f, 0.01388563f, -0.05138122f, 
    0.09775218f, -0.13903281f, -0.03549110f, 0.01660262f, 0.05648131f, 0.14434445f, 0.12229650f, -0.00198643f, 
    0.02616750f, 0.05570678f, 0.16949055f, 0.03456842f, 0.24443004f, -0.04161413f, -0.00136551f, -0.18802480f, 
    0.13419230f, 0.07393369f, 0.07777134f, -0.14154594f, 0.02375567f, 0.11689305f, 0.08023888f, -0.06503243f, 
    -0.04926684f, -0.08049827f, -0.20515911f, 0.24404575f, 0.01269114f, 0.08864348f, 0.04999423f, 0.03249842f, 
    -0.07089307f, -0.01298977f, 0.05455298f, 0.10962018f, 0.22023192f, -0.03631870f, 0.20104532f, -0.27948797f, 
    0.10031465f, 0.06639273f, -0.03674081f, -0.12368073f, 0.06286272f, 0.01559742f, -0.02612601f, -0.04424947f, 
    0.06062421f, 0.18477435f, 0.00283737f, -0.06380127f, -0.01295171f, 0.01146185f, 0.04757600f, -0.08955237f, 
    -0.08535217f, -0.03461608f, 0.03080641f, -0.00875428f, 0.35905710f, -0.07252604f, -0.12198944f, -0.00633353f, 
    0.02641280f, 0.09014372f, 0.19242437f, 0.10636836f, -0.04812917f, -0.07904360f, 0.04851874f, 0.10518041f, 
    0.10264774f, 0.11334048f, -0.03074805f, -0.13467067f, -0.08610521f, -0.00228056f, -0.00223749f, 0.04246741f, 
    0.14977236f, -0.08642549f, -0.00432034f, -0.04250228f, -0.07611349f, -0.48720178f, -0.25676906f, -0.06770712f, 
    0.06531493f, 0.16656652f, 0.06808672f, 0.01512842f, 0.18498962f, 0.02905089f, -0.07134378f, 0.02833872f, 
    0.12190074f, 0.03531549f, -0.10045803f, -0.20108323f, -0.01721470f, -0.00237821f, -0.02027913f, -0.00032875f, 
    0.12532759f, -0.00222051f, 0.18088716f, 0.01229975f, -0.07850948f, -0.01693154f, 0.04471809f, 0.11669257f, 
    0.03784148f, 0.03589269f, 0.15011163f, -0.02798760f, -0.11832435f, 0.00806239f, 0.03056114f, -0.02006284f, 
    0.07228114f, 0.03943583f, -0.16194096f, 0.03081664f, 0.02499808f, 0.10558626f, -0.03735761f, 0.13909529f, 
    -0.12004930f, -0.10153691f, -0.10719602f, 0.00632440f, -0.21471380f, 0.02566086f, 0.02827431f, 0.10975170f, 
    -0.02381745f, -0.03120616f, -0.08240426f, 0.06489978f, 0.03111695f, 0.12361625f, -0.02894003f, -0.08327185f, 
    -0.03450257f, -0.06103589f, -0.14365119f, -0.08994754f, -0.05170941f, -0.02080315f, 0.05852562f, 0.02651326f, 
    0.17250818f, 0.04076789f, 0.01368236f, 0.05359399f, 0.20494515f, -0.03254858f, 0.15123379f, 0.04430829f, 
    -0.11747281f, -0.04571157f, -0.07293203f, -0.04981021f, 0.06911705f, 0.04293868f, 0.20619717f, 0.01585000f, 
    0.60863000f, 0.02896436f, 0.08899775f, -0.17050816f, 0.11684053f, 0.10832179f, 0.14879380f, 0.17184839f, 
    0.12860736f, -0.03039701f, -0.04523508f, -0.05233493f, 0.02012057f, -0.17477490f, -0.12689680f, -0.05060072f, 
    0.01544482f, 0.05681505f, 0.05832282f, -0.01907291f, -0.05707752f, 0.04983592f, -0.03481513f, 0.00955153f, 
    -0.15488617f, 0.01200846f, 0.04834259f, -0.13271876f, 0.07231865f, -0.05151387f, -0.01831211f, -0.06018375f, 
    0.08450625f, -0.01075664f, -0.02018863f, 0.04966797f, 0.10821255f, -0.06977986f, -0.22218743f, 0.00971520f, 
    0.09329782f, 0.04963211f, 0.16255249f, -0.02556680f, 0.00724832f, -0.00188017f, -0.00791268f, -0.06404394f, 
    -0.02904429f, 0.40106714f, -0.10700783f, -0.10495819f, -0.03371814f, -0.08898474f, 0.13145015f, 0.07651223f, 
    0.00111945f, 0.04792748f, -0.01603699f, -0.01899339f, 0.01863038f, 0.19004443f, 0.02737843f, -0.09692436f, 
    -0.01959193f, -0.25810143f, 0.10407694f, 0.02187560f, -0.02956607f, -0.11536419f, 0.07127613f, -0.02879202f, 
    0.10325711f, 0.21531470f, -0.08806239f, 0.28693685f, -0.03723554f, -0.05132454f, 0.10449018f, -0.03982259f, 
    0.01768315f, 0.06858409f, 0.10337261f, -0.14277992f, -0.18295126f, 0.05087214f, 0.00865112f, -0.17628627f, 
    0.01504205f, -0.02744848f, 0.05914530f, 0.02099732f, -0.03196926f, -0.08488577f, -0.04345396f, -0.13860931f, 
    0.02259048f, 0.25117502f, -0.03743539f, 0.21248798f, -0.01208761f, -0.09193119f, -0.03117871f, 0.03063494f, 
    0.10097241f, 0.08186550f, 0.02412878f, 0.06762927f, 0.26609117f, -0.00804604f, 0.20592442f, -0.07036033f, 
    0.01593529f, 0.00897788f, 0.15146187f, -0.15263845f, 0.08475578f, 0.11971463f, 0.06761950f, 0.03315144f, 
    -0.02461767f, -0.12765522f, -0.03937814f, -0.09161238f, 0.06033761f, 0.09424885f, -0.06431668f, 0.12320632f, 
    0.06118975f, -0.02374286f, -0.00151077f, 0.12836941f, -0.03629904f, 0.04391072f, 0.01496701f, 0.11963683f, 
    -0.09208092f, -0.09091339f, 0.01641042f, 0.15959863f, -0.00535045f, -0.06500410f, -0.03771129f, -0.01490795f, 
    0.19432043f, 0.30461979f, -0.16671367f, -0.28733203f, 0.05555705f, 0.03038152f, -0.02947317f, -0.00834292f, 
    -0.03490253f, -0.12597446f, -0.04264503f, 0.09088438f, 0.22252575f, -0.00858863f, -0.00113988f, -0.01473543f, 
    0.09603134f, 0.10393106f, 0.02562361f, 0.01993889f, 0.09729020f, -0.07504936f, 0.09159458f, -0.04097694f, 
    -0.02627640f, 0.14653736f, 0.10913083f, -0.12718031f, -0.09462243f, -0.11690297f, -0.13396069f, -0.09591273f, 
    0.06733133f, -0.09982323f, -0.03179510f, 0.01096752f, 0.20544229f, -0.33646786f, -0.00917257f, 0.01825423f, 
    -0.10928312f, 0.07103594f, 0.42954329f, 0.17296728f, 0.00132859f, -0.03722240f, 0.04959046f, 0.21850808f, 
    0.15703639f, -0.16837373f, 0.63523984f, 0.19741271f, 0.13126375f, 0.08833190f, 0.12849060f, 0.03349296f, 
    0.02342873f, 0.02209715f, 0.02179902f, 0.01137664f, 0.04763257f, 0.09619754f, 0.00381548f, 0.01031073f, 
    -0.21712536f, -0.13702157f, 0.05117385f, 0.06972773f, 0.20679827f, 0.03308338f, -0.09610564f, -0.06958274f, 
    -0.12979770f, 0.01027161f, -0.01952027f, 0.13128683f, -0.00117854f, 0.11766748f, 0.07403721f, 0.03861864f, 
    0.01562761f, 0.04881648f, 0.29567263f, 0.04562189f, 0.16613334f, 0.32718831f, -0.02807257f, 0.25637096f, 
    0.06411396f, 0.16364470f, 0.09811137f, 0.11393532f, -0.25512397f, 0.01082061f, 0.01087909f, -0.02686406f, 
    -0.09336194f, -0.28830859f, 0.31353819f, 0.11935607f, -0.05455251f, 0.09137119f, -0.01324019f, -0.02517353f, 
    -0.03079868f, 0.18295926f, -0.10091310f, 0.00876561f, -0.12528977f, -0.22809492f, -0.20875536f, 0.20503518f, 
    0.04865209f, 0.16127057f, -0.08371259f, -0.15589483f, 0.18598402f, 0.10339691f, 0.05131800f, 0.11927622f, 
    -0.12485605f, 0.16885905f, -0.01235551f, -0.14802182f, 0.15697259f, 0.09697922f, -0.06374986f, 0.14524725f, 
    -0.07919193f, 0.11330748f, -0.09091195f, -0.10769609f, 0.15284117f, 0.15180552f, -0.04590956f, 0.15774797f, 
    0.05567875f, 0.08584439f, -0.03881097f, -0.07161158f, 0.07164291f, 0.06969847f, -0.00671371f, -0.03130225f, 
    0.20107186f, -0.16212279f, -0.06113281f, 0.18295062f, 0.07875858f, 0.03647535f, 0.03005733f, -0.03137468f, 
    -0.16528372f, 0.07083473f, -0.00269584f, 0.20115437f, -0.02770805f, -0.00275582f, -0.13318041f, -0.01936916f, 
    0.14302255f, -0.01202555f, 0.01924170f, -0.00537825f, -0.04816438f, 0.03518231f, -0.09599952f, 0.01497671f, 
    0.10163907f, 0.05164228f, 0.19586527f, -0.04337111f, -0.03398236f, -0.08343878f, -0.04307679f, 0.01170732f, 
    -0.03018709f, 0.12168175f, -0.06203448f, -0.03522049f, 0.33915299f, 0.13981363f, -0.04179129f, 0.28864557f, 
    -0.17412601f, 0.02883112f, 0.15878797f, -0.08605511f, 0.14488009f, -0.02026079f, 0.08833347f, 0.14068034f, 
    -0.16176824f, 0.12413184f, 0.08794013f, 0.01674548f, 0.10162342f, 0.12608235f, -0.26434720f, -0.11481696f, 
    -0.03929747f, -0.05281461f, 0.21071477f, -0.04811493f, -0.23193547f, 0.10679831f, 0.11711644f, 0.01728582f, 
    -0.07605995f, -0.10991469f, -0.17009810f, -0.02659334f, -0.08163155f, -0.20825602f, -0.08435316f, -0.10284067f, 
    -0.02250512f, -0.28220820f, 0.05738634f, -0.00829358f, -0.07065830f, 0.15936597f, 0.13192461f, 0.15728046f, 
    -0.01460844f, -0.09831158f, 0.11291617f, 0.15647647f, 0.15751897f, 0.03571939f, -0.23631415f, -0.13720123f, 
    -0.08156676f, -0.06426159f, -0.04879018f, -0.00857909f, -0.03740287f, 0.04089778f, -0.02368950f, 0.08103602f, 
    0.14212619f, 0.16247265f, -0.00246122f, 0.05947280f, 0.05287731f, -0.03246343f, 0.07982817f, -0.05373064f, 
    0.09690960f, -0.00292975f, -0.06554080f, -0.08172221f, 0.52711689f, 0.10510136f, 0.16935167f, -0.05906333f, 
    -0.17230092f, -0.31054735f, -0.14911672f, -0.04396821f, -0.02902122f, 0.13595681f, -0.03157739f, -0.03199369f, 
    -0.06720719f, 0.07614563f, -0.10416517f, -0.00977429f, 0.06746202f, 0.04953146f, 0.02506929f, 0.04468333f, 
    -0.07024651f, 0.04702301f, -0.01478220f, -0.02378234f, 0.07837445f, 0.06846397f, 0.13434349f, -0.08018605f, 
    -0.00374302f, 0.09501904f, 0.02480866f, -0.18493937f, 0.01901054f, -0.02681861f, 0.05079254f, 0.11774704f, 
    0.14663902f, -0.29027310f, 0.40874848f, 0.01111629f, 0.07503032f, 0.09657246f, -0.11805707f, -0.06312192f, 
    0.02032098f, -0.06931574f, 0.05705041f, 0.10555770f, 0.07250727f, 0.17353807f, -0.37052196f, 0.03180122f, 
    -0.20898169f, -0.02352760f, -0.09722294f, -0.05697224f, -0.13381402f, -0.18707451f, -0.09522657f, -0.16008720f, 
    0.08506082f, -0.26282081f, 0.38739949f, -0.06487811f, 0.20229478f, 0.04555394f, -0.19576499f, 0.04796438f, 
    -0.09590320f, -0.00079439f, 0.05563344f, -0.06114669f, 0.27105376f, 0.20469680f, 0.31897435f, 0.27472320f, 
    0.02291624f, 0.06459811f, -0.03469821f, 0.06627531f, -0.02192125f, 0.03827738f, 0.10929214f, -0.22866672f, 
    0.10015181f, 0.05244372f, 0.10990459f, 0.13756579f, 0.11865822f, 0.04701296f, 0.00044193f, -0.11960206f, 
    -0.01734994f, 0.09353137f, -0.01904641f, -0.00087227f, -0.23617288f, -0.36337507f, -0.34566438f, -0.06019443f, 
    -0.10112448f, 0.13461933f, 0.14691243f, 0.11773594f, 0.08019041f, 0.07856210f, 0.03177386f, 0.02817608f, 
    0.01644518f, 0.07519035f, 0.04947806f, -0.14906606f, 0.11236894f, -0.02681743f, -0.02485112f, -0.13690279f, 
    0.05719413f, -0.09559264f, 0.04528284f, -0.02647183f, -0.08567441f, 0.06750911f, 0.35987401f, 0.00010584f, 
    0.07722814f, -0.07220186f, -0.02207704f, -0.09104940f, -0.10084831f, 0.06544614f, 0.03871392f, 0.09783912f, 
    -0.06286550f, 0.04295913f, 0.00937666f, -0.10958667f, 0.08002444f, -0.01789480f, 0.07768004f, -0.01952640f, 
    0.00894378f, -0.01236342f, 0.12645212f, 0.11557200f, 0.23990388f, -0.29165152f, -0.10602099f, 0.24596548f, 
    -0.10318302f, 0.07411411f, -0.11742877f, 0.08160277f, 0.02936041f, 0.17859669f, -0.07241104f, -0.04696248f, 
    0.21719414f, -0.00215339f, 0.19143881f, -0.06686897f, -0.08088526f, 0.05008700f, 0.07690067f, 0.07089718f, 
    0.05016028f, -0.00040612f, 0.07343354f, 0.12875056f, -0.02386092f, 0.05133497f, 0.12236153f, 0.06781641f, 
    -0.16995785f, -0.17596664f, -0.00868609f, -0.20596433f, -0.01706238f, 0.09935026f, -0.02644696f, 0.03403281f, 
    0.07791612f, -0.02500598f, 0.02664820f, 0.03214440f, -0.00272925f, -0.05232793f, -0.18337989f, -0.09751680f, 
    0.09908315f, -0.05404918f, -0.09055553f, -0.05939912f, 0.08975778f, -0.01648824f, -0.13620293f, 0.26708546f, 
    -0.00088898f, -0.04446340f, 0.13489489f, 0.00818419f, -0.11553594f, 0.14948101f, -0.09183482f, 0.10811973f, 
    0.05697449f, 0.06198892f, 0.02928381f, 0.13250001f, 0.11294597f, 0.12489432f, -0.10716143f, 0.11865305f, 
    -0.02142100f, 0.02860393f, 0.02944788f, 0.06262905f, -0.04442073f, 0.10038135f, 0.14820838f, -0.17450432f, 
    -0.10959551f, 0.01695667f, -0.04877000f, -0.00592425f, -0.02565875f, 0.09590516f, -0.00850916f, -0.14016631f, 
    0.00078519f, -0.08831789f, 0.06521127f, 0.08486839f, -0.15990980f, 0.13535340f, -0.06227768f, 0.08158343f, 
    -0.00785310f, 0.04975896f, -0.03618525f, -0.17012598f, -0.18839371f, 0.15599443f, 0.00124220f, 0.02633976f, 
    -0.23506364f, -0.07900725f, 0.04004730f, -0.04419172f, 0.03664738f, 0.02463930f, 0.06563299f, 0.13842438f, 
    0.14397542f, 0.01168343f, 0.02050377f, -0.07839549f, -0.05457234f, -0.04690380f, -0.08066721f, -0.05152620f, 
    0.06267417f, -0.07979317f, -0.06135631f, 0.03680032f, 0.25482160f, 0.27773747f, 0.02615099f, 0.07063945f, 
    0.04264715f, -0.03165641f, -0.10126944f, -0.15838760f, 0.05719687f, 0.00376027f, -0.16211133f, -0.03395933f, 
    -0.16183585f, -0.14666037f, -0.15754874f, -0.06499870f, -0.04929249f, -0.05995115f, 0.16065678f, 0.12421630f, 
    0.05483088f, 0.18989074f, -0.01732302f, 0.05328851f, 0.17222169f, -0.09624227f, 0.27514806f, 0.03269327f, 
    -0.13008849f, -0.12102753f, 0.20212667f, 0.05281946f, 0.05310098f, 0.01364719f, 0.10668956f, -0.12673678f, 
    0.19642070f, 0.10840677f, -0.09683121f, -0.17370109f, 0.01281641f, 0.08483633f, -0.01606928f, -0.07737914f, 
    -0.05868749f, 0.00463464f, -0.01003792f, 0.14027078f, 0.07615844f, 0.16489899f, -0.03405629f, -0.12304041f, 
    0.08591256f, -0.11208494f, 0.00479012f, -0.12056475f, 0.08342986f, -0.07536595f, 0.09118838f, 0.17784816f, 
    0.29139885f, 0.07921254f, 0.25462589f, 0.17541926f, 0.03172024f, 0.16527143f, 0.04456406f, -0.19731767f, 
    0.04445938f, 0.03799773f, 0.03493985f, -0.10310240f, 0.11610402f, 0.02132229f, 0.16427805f, -0.16989602f, 
    -0.01481887f, -0.19147861f, -0.07291704f, 0.06057956f, -0.02924747f, 0.02469372f, 0.08793271f, 0.02538928f, 
    0.01444557f, -0.01619454f, 0.05399643f, -0.08482782f, -0.01656508f, -0.01103565f, -0.03436095f, -0.08822744f, 
    0.03800644f, -0.03452528f, -0.00378753f, 0.05076719f, -0.24214610f, 0.21244864f, 0.02980988f, -0.13669915f, 
    0.05521025f, 0.06640308f, -0.08307335f, -0.20654610f, 0.14227116f, 0.01075180f, -0.02089469f, 0.09367193f, 
    -0.16607182f, -0.00822031f, -0.25511855f, 0.11531600f, -0.02615372f, 0.05869292f, -0.01438470f, 0.04084849f, 
    -0.04277809f, 0.02738114f, 0.12917945f, 0.07262591f, -0.10666363f, 0.00532526f, -0.13991672f, -0.01507066f, 
    -0.09083497f, -0.14070474f, 0.01445021f, 0.02004688f, -0.14776151f, 0.10306726f, -0.08140304f, -0.06433162f, 
    -0.01935058f, 0.09273168f, -0.00802903f, 0.09811850f, -0.11868986f, -0.09361901f, -0.16418400f, 0.00854553f, 
    -0.01752211f, 0.07789155f, 0.09064908f, -0.01680658f, -0.04351960f, -0.07386068f, 0.09706637f, 0.13447148f, 
    -0.08317412f, 0.10697845f, -0.11213550f, 0.02625814f, -0.05928266f, 0.03727790f, 0.00421399f, -0.00585717f, 
    0.37606364f, 0.15412860f, -0.01294143f, -0.23380180f, 0.17962871f, -0.01812269f, -0.07883279f, -0.07582162f, 
    -0.14131525f, 0.21211466f, 0.22215809f, -0.03841480f, -0.04592221f, 0.20805664f, -0.00823362f, -0.06934009f, 
    -0.17184696f, -0.10632806f, -0.20096169f, -0.18512918f, 0.11712730f, 0.09729353f, -0.01744201f, 0.04393631f, 
    0.24113171f, -0.04777664f, 0.35875636f, 0.29062146f, -0.07975845f, -0.00062086f, -0.00148915f, -0.04383129f, 
    -0.06415033f, -0.03304034f, -0.02877223f, -0.16237782f, 0.03161756f, 0.18969239f, -0.04318513f, -0.02354033f, 
    -0.07904602f, -0.19861116f, -0.14470580f, -0.10983849f, -0.08663212f, -0.03978154f, -0.03542593f, -0.08895723f, 
    0.15519017f, 0.01895250f, 0.04838764f, -0.05830703f, -0.05070114f, -0.04690535f, 0.00530067f, -0.02169862f, 
    0.06778318f, 0.07842844f, 0.01697663f, 0.03323229f, -0.15421626f, 0.41243425f, 0.06326310f, 0.20863485f, 
    -0.20706728f, -0.00111100f, -0.18987884f, -0.03339357f, -0.04059286f, 0.12890401f, -0.02446664f, 0.01167429f, 
    0.05654068f, 0.01556615f, 0.01403776f, 0.05154267f, 0.09923398f, 0.00105870f, 0.05358715f, 0.13353041f, 
    -0.04172375f, -0.00317174f, 0.14907295f, -0.06449518f, -0.04674591f, -0.04213223f, 0.07308476f, -0.21189946f, 
    0.12656222f, 0.12021190f, -0.05336559f, 0.12140596f, -0.03629538f, -0.04241595f, -0.06599408f, 0.13616742f, 
    -0.01634021f, 0.03109542f, 0.09232448f, 0.17824735f, 0.00719625f, 0.08124689f, 0.06778072f, 0.16254984f, 
    -0.00306212f, 0.03246289f, -0.03751988f, 0.06110772f, -0.36851686f, -0.01795975f, -0.34563899f, 0.16512123f, 
    0.01001691f, -0.04185289f, 0.09924744f, 0.05907808f, -0.02744561f, 0.05874625f, 0.03292337f, 0.11336383f, 
    -0.14834221f, -0.03429275f, -0.11649596f, -0.05401239f, -0.07066741f, -0.14365566f, -0.04298472f, -0.11395536f, 
    0.09697422f, -0.12221596f, 0.03256444f, -0.08696100f, 0.24750137f, -0.29337168f, 0.09632275f, -0.21786579f, 
    -0.08942048f, 0.17094243f, -0.00738937f, 0.11073508f, 0.05120589f, 0.05679960f, -0.03084907f, 0.00103854f, 
    -0.11063686f, 0.22719260f, 0.16775267f, 0.09501001f, 0.15600547f, 0.13390034f, 0.07928369f, 0.05733885f, 
    -0.02503417f, -0.06014064f, -0.04111722f, 0.03147252f, -0.03151985f, -0.39577258f, 0.33858591f, 0.11595511f, 
    -0.21008074f, -0.02776524f, 0.06117508f, 0.16860667f, 0.08064297f, 0.05818052f, -0.02628749f, -0.00991104f, 
    0.06807636f, 0.14013861f, 0.11213130f, 0.12746723f, -0.00343041f, 0.06224678f, -0.04693345f, -0.01140890f, 
    0.06180908f, 0.11895781f, 0.24048647f, 0.08597817f, 0.00894629f, 0.11996948f, -0.01696579f, 0.01504047f, 
    -0.11496472f, 0.01184614f, 0.07638910f, 0.04313214f, -0.02508083f, 0.04038764f, 0.07688444f, -0.09115239f, 
    0.05395977f, 0.08522521f, -0.02195072f, 0.05172683f, 0.01398732f, -0.03744259f, 0.05329680f, 0.08783465f, 
    -0.05628630f, 0.11817264f, 0.13859360f, 0.01313021f, -0.19239485f, -0.14250949f, 0.27452928f, 0.15343083f, 
    -0.03388241f, 0.08128033f, 0.13267517f, 0.02365642f, 0.00190581f, 0.01803812f, 0.01568216f, 0.05903957f, 
    -0.19691385f, -0.10084792f, -0.07970282f, 0.19196163f, -0.04657822f, 0.00642977f, -0.04624833f, 0.15993243f, 
    -0.03813955f, 0.06125840f, 0.13609968f, -0.01294716f, 0.01980835f, -0.01585611f, -0.26493794f, 0.27910265f, 
    -0.09405323f, 0.09153584f, -0.10631950f, -0.00155660f, -0.07243640f, 0.05796329f, 0.08037362f, 0.07542268f, 
    0.06357317f, -0.10678339f, 0.03692975f, -0.08312269f, 0.08948787f, -0.03652532f, 0.05097964f, 0.08635022f, 
    0.04708164f, -0.07045615f, 0.04784194f, -0.04958788f, -0.32979438f, -0.32566574f, 0.05536336f, 0.10111535f, 
    0.05078189f, 0.00294377f, 0.03956900f, 0.03208125f, 0.13115714f, 0.03889186f, 0.02066064f, 0.01550737f, 
    -0.09363838f, -0.03460144f, -0.06493845f, -0.01566000f, -0.12227343f, -0.04450796f, -0.04484940f, -0.02820371f, 
    0.08717243f, 0.01917196f, 0.00741969f, -0.05420341f, 0.02506210f, 0.15458183f, 0.14055988f, -0.06491222f, 
    -0.04724737f, 0.23765102f, -0.11773778f, 0.14432620f, 0.04414613f, 0.00300533f, 0.09749492f, 0.17499259f, 
    -0.19151828f, 0.08322130f, 0.03623905f, 0.10020873f, -0.01387145f, 0.12061611f, -0.06453366f, 0.11795726f, 
    -0.13160878f, 0.06968373f, 0.00885897f, 0.02671915f, 0.22208935f, -0.00926008f, -0.12678199f, -0.04748190f, 
    -0.03922261f, 0.02858682f, -0.02725230f, 0.08773166f, 0.13667440f, 0.11369111f, -0.06093691f, -0.00868550f, 
    0.13315248f, 0.00747826f, 0.34654343f, -0.03985668f, -0.10089722f, -0.07028495f, 0.22826964f, -0.05388127f, 
    0.02075300f, -0.01157024f, 0.04719235f, 0.06720169f, -0.14025542f, -0.23186253f, 0.03071191f, 0.08084421f, 
    0.01000204f, -0.10696495f, -0.09979719f, -0.02763834f, 0.06794180f, -0.00156783f, 0.02912527f, 0.15186748f, 
    -0.08766185f, 0.14071648f, -0.05620963f, 0.03843408f, -0.03626962f, -0.05938517f, 0.09500249f, 0.09544307f, 
    0.02391245f, -0.08528817f, -0.02629671f, 0.08734091f, 0.50684774f, -0.01734305f, 0.23163711f, -0.10766403f, 
    -0.09495992f, -0.04810726f, 0.05771838f, 0.05743262f, -0.00870773f, 0.04427208f, -0.04079507f, -0.02902812f, 
    -0.15060329f, -0.05590780f, 0.05389293f, 0.19613673f, -0.02556070f, -0.05264945f, -0.00682600f, 0.06573849f, 
    0.00113764f, 0.06043968f, 0.01130874f, 0.07310572f, -0.08812416f, -0.11682605f, 0.35001811f, 0.01019371f, 
    -0.04902998f, 0.02015826f, -0.12020770f, -0.04762523f, -0.01618793f, -0.03588570f, 0.18459973f, 0.05746548f, 
    0.31987977f, -0.14471956f, 0.22204418f, -0.03425443f, 0.16030039f, -0.00133495f, 0.06519549f, -0.01814247f, 
    0.09210102f, 0.04872200f, -0.08556487f, 0.12180549f, -0.34695294f, -0.11506788f, -0.12058695f, 0.14916012f, 
    -0.01628775f, -0.18533926f, 0.04608796f, -0.07289559f, -0.08450240f, 0.03228467f, 0.05855294f, -0.06709916f, 
    0.27262676f, -0.10916923f, 0.05111705f, 0.06492421f, 0.35108685f, -0.08396327f, 0.02075965f, 0.07936005f, 
    0.06018649f, -0.03088501f, -0.17306969f, 0.04427298f, -0.01463224f, 0.05180007f, 0.29241461f, 0.16796678f, 
    0.00665862f, -0.01250922f, 0.08429194f, 0.01408048f, -0.00513052f, 0.03090501f, 0.06380177f, -0.15324338f, 
    0.08378277f, -0.14297038f, 0.11283656f, 0.04013656f, -0.00508828f, -0.01706282f, 0.08111175f, -0.00920307f, 
    0.00910266f, 0.04670728f, 0.03232196f, 0.00696470f, -0.30910993f, -0.10431218f, 0.01393591f, 0.08521259f, 
    -0.02074965f, 0.00264246f, 0.07049670f, 0.08967566f, 0.04675736f, 0.12068444f, -0.03947086f, 0.00000978f, 
    -0.08820152f, 0.01516004f, 0.04450750f, 0.02623200f, -0.03057647f, 0.05110681f, -0.07158076f, 0.07092994f, 
    0.03517583f, -0.15242481f, -0.06701537f, -0.07830349f, -0.04336778f, 0.16705768f, -0.06618687f, 0.10183875f, 
    0.14665566f, -0.04262222f, 0.02989656f, -0.11293454f, -0.11782459f, 0.05949749f, -0.04656396f, -0.03177388f, 
    -0.10849096f, -0.04479753f, -0.06364841f, 0.18291196f, 0.06884046f, 0.01586562f, -0.04599594f, -0.11190525f, 
    0.09288019f, 0.15430240f, 0.15655634f, 0.04274520f, 0.18246479f, -0.05913475f, 0.35586271f, -0.01834979f, 
    -0.06286353f, 0.00906397f, -0.04324729f, -0.04953323f, -0.00139107f, 0.14388037f, 0.05034843f, -0.04649478f, 
    -0.01697310f, 0.25035661f, 0.03787471f, -0.07908184f, 0.00065979f, 0.01529377f, 0.02086095f, 0.05463512f, 
    0.01835410f, 0.01312258f, 0.09878476f, 0.10272862f, -0.04942186f, -0.13925113f, -0.09584567f, -0.09537238f, 
    -0.11084618f, -0.12683225f, -0.09133685f, -0.10595942f, -0.02012747f, 0.08984695f, 0.03422014f, -0.05747782f, 
    -0.07099627f, 0.04662642f, -0.08759134f, -0.16509430f, -0.08461542f, -0.02947733f, -0.17207736f, -0.03238973f, 
    0.03287328f, -0.07177044f, -0.10863600f, -0.01922961f, -0.01498113f, 0.02872666f, 0.19523025f, 0.05694441f, 
    -0.02654403f, -0.08227014f, 0.13643685f, 0.01760007f, 0.06022993f, 0.03431666f, 0.02636149f, 0.01328171f, 
    -0.04934913f, 0.05396011f, 0.08561206f, 0.05683684f, 0.01769377f, -0.09895069f, 0.02266383f, -0.00409304f, 
    -0.05760865f, 0.15737318f, -0.11392277f, 0.02552894f, -0.25580022f, 0.05871019f, -0.05922449f, 0.16355939f, 
    -0.02122483f, -0.04073126f, 0.10318495f, 0.28517804f, -0.06949490f, 0.02622150f, 0.09246021f, 0.10492265f, 
    0.04712672f, 0.08241420f, 0.18461815f, -0.19900319f, -0.03891592f, 0.10853392f, 0.13370821f, 0.14821297f, 
    0.01287798f, 0.17644435f, -0.07765900f, 0.03285505f, -0.03873995f, 0.31304577f, -0.22902612f, 0.44407645f, 
    -0.11821555f, -0.09915885f, 0.07137220f, -0.02290243f, -0.01512960f, -0.05230415f, 0.06141963f, 0.15425825f, 
    -0.05653664f, -0.15703671f, 0.12619905f, 0.05328508f, -0.08987676f, -0.15113664f, -0.14549264f, -0.11313930f, 
    -0.02678831f, -0.09641365f, 0.02437923f, 0.03430672f, -0.23393460f, 0.06370579f, 0.11718372f, -0.03240516f, 
    0.02238738f, -0.07951818f, -0.07942735f, -0.06935790f, 0.05784526f, -0.03090159f, -0.07823842f, -0.10247906f, 
    -0.11942231f, -0.06079054f, -0.06251345f, 0.08009911f, 0.04214958f, 0.13225091f, 0.02441862f, -0.02429585f, 
    -0.01592732f, 0.17174196f, -0.10434478f, -0.02483216f, -0.05988246f, 0.21433805f, 0.11839139f, 0.01338753f, 
    -0.08357078f, -0.10185379f, -0.00469889f, 0.02406403f, -0.02934936f, 0.05762706f, 0.02710876f, 0.01230206f, 
    -0.33756402f, -0.05225893f, -0.28657699f, -0.02160184f, 0.10409342f, 0.01623314f, -0.13310707f, -0.12569073f, 
    -0.00751473f, 0.07541581f, -0.08948117f, 0.14871982f, 0.12492459f, 0.02285462f, -0.00745263f, -0.08042712f, 
    -0.03481788f, 0.05839209f, -0.07116450f, 0.17649996f, 0.01269173f, -0.02252253f, 0.01649494f, -0.11579910f, 
    0.01754990f, -0.06547885f, 0.08813111f, -0.01299981f, 0.00478595f, -0.07254499f, 0.01168470f, 0.05395329f, 
    0.14439081f, -0.04238887f, 0.07037562f, -0.06154527f, 0.16751543f, 0.15510868f, 0.04606097f, -0.21457429f, 
    0.01468004f, 0.07103668f, 0.26337588f, 0.10280168f, 0.05674984f, -0.05167487f, -0.01446590f, -0.03023080f, 
    -0.23014976f, -0.25872746f, -0.04710053f, -0.08965933f, 0.07369687f, -0.04691928f, -0.11238465f, -0.10943920f, 
    -0.02169496f, 0.03507765f, 0.08081506f, 0.09147518f, -0.08736901f, 0.00370916f, -0.06146230f, 0.01298219f, 
    -0.04726856f, -0.10487121f, -0.00303641f, -0.04615091f, 0.06677421f, -0.05146877f, -0.04260950f, 0.01723133f, 
    -0.30029589f, -0.23608647f, 0.06333685f, 0.28815782f, 0.03870109f, -0.05445334f, -0.13663541f, -0.14314555f, 
    -0.04094157f, 0.05633916f, 0.09472859f, 0.05940134f, -0.07573845f, 0.03501705f, 0.06858267f, -0.12818263f, 
    -0.04317896f, -0.12621410f, -0.04781413f, 0.04283478f, 0.07591870f, -0.14953314f, 0.01549595f, -0.13040604f, 
    0.13171400f, 0.04517334f, -0.09768418f, 0.02988602f, -0.08250679f, -0.11351677f, -0.13603193f, 0.02784570f, 
    0.05462110f, 0.08565570f, 0.01486766f, 0.05866312f, -0.08191938f, 0.08720607f, 0.21982594f, 0.05767377f, 
    -0.16226669f, -0.00372317f, 0.00005644f, 0.15556443f, -0.01003609f, 0.06317534f, 0.02876588f, -0.00853921f, 
    -0.03529535f, -0.28679660f, 0.02956001f, -0.01767594f, 0.08906885f, 0.09033192f, -0.00464840f, 0.06839206f, 
    0.07369036f, 0.08371250f, 0.05709136f, -0.12726250f, 0.09310579f, 0.05002007f, 0.10387509f, 0.05887894f, 
    0.00772434f, 0.05013488f, -0.13790812f, 0.12529331f, 0.11684185f, 0.02573987f, 0.04397300f, -0.05357736f, 
    -0.10151070f, -0.16015200f, 0.03792217f, -0.20929158f, 0.01107366f, 0.08375537f, -0.00441704f, 0.09878822f, 
    -0.12941776f, -0.03820619f, -0.00376356f, 0.05524669f, 0.05597475f, -0.03751935f, -0.18159543f, -0.12443362f, 
    -0.16616891f, 0.06436910f, -0.09495683f, -0.09974981f, 0.01135902f, -0.03656134f, -0.15220661f, -0.16980067f, 
    0.08025800f, -0.10826244f, 0.16277468f, -0.04374981f, 0.05735302f, 0.05930354f, 0.01207941f, 0.18497269f, 
    -0.06135283f, -0.06227419f, -0.00081180f, 0.01590673f, -0.01995145f, 0.27088827f, -0.01147184f, 0.08866488f, 
    -0.01063441f, 0.18820605f, 0.03469193f, 0.24989387f, -0.15083002f, -0.04954342f, -0.00501057f, -0.15815105f, 
    -0.14685090f, 0.08332054f, 0.13278182f, 0.05848316f, -0.08505823f, 0.01766879f, 0.13723443f, 0.01320900f, 
    -0.06158600f, -0.02471991f, -0.04225867f, -0.08090585f, -0.03215967f, -0.01520045f, 0.16097115f, -0.09010071f, 
    0.11206011f, 0.05196458f, 0.01099689f, -0.07225772f, 0.01019657f, -0.02226941f, -0.02785090f, -0.00507562f, 
    -0.27734020f, -0.22095142f, 0.23118605f, 0.18085596f, -0.09513873f, 0.04130388f, 0.17040250f, 0.12207564f, 
    0.09701283f, 0.02705559f, 0.05054045f, -0.03570757f, -0.15793221f, -0.14237875f, -0.02779131f, 0.04200713f, 
    0.04038351f, -0.14008167f, 0.02461122f, 0.03326441f, -0.18810798f, -0.02939196f, -0.04732294f, -0.07327845f, 
    -0.02817788f, 0.02144718f, 0.01667920f, -0.02372605f, 0.03318109f, 0.02973297f, -0.01895324f, 0.02261173f, 
    0.00189594f, -0.00851333f, -0.02710632f, -0.03597115f, 0.02385748f, -0.01551901f, -0.00155647f, -0.02462609f, 
    -0.00949171f, 0.01464474f, 0.00881317f, 0.02509868f, -0.03372493f, -0.03067802f, -0.01981573f, 0.01708475f, 
    -0.01890986f, -0.03099248f, 0.00867084f, -0.01939832f, 0.02039009f, -0.01169516f, 0.02194490f, -0.01486858f, 
    0.01869903f, -0.01530536f, 0.02897673f, -0.02010766f, -0.01221860f, 0.00616686f, -0.00575346f, 0.02064056f, 
    0.02892995f, 0.00112558f, -0.03866886f, 0.01446265f, 0.01545582f, 0.01355513f, -0.02583366f, -0.01749767f, 
    -0.02353405f, 0.01061632f, 0.03052568f, -0.01544410f, 0.00777911f, 0.00675983f, 0.01002569f, 0.02110493f, 
    -0.04088439f, -0.01018323f, -0.03523571f, 0.02325025f, 0.03008595f, -0.00206552f, 0.02277310f, -0.01683915f, 
    -0.01693040f, 0.02148494f, -0.04037749f, -0.02117337f, -0.00753971f, -0.01290557f, 0.02907540f, 0.03492594f, 
    -0.00370617f, -0.03933249f, -0.00049366f, -0.03786655f, -0.01906619f, -0.03903185f, 0.02439842f, -0.03116637f, 
    -0.02371782f, -0.02264489f, 0.03439464f, 0.02529426f, 0.01478181f, -0.03618588f, 0.01920687f, -0.02370393f, 
    -0.01384238f, -0.01816267f, -0.03302568f, -0.02005621f, 0.00578731f, 0.01814828f, -0.00319827f, -0.03256965f, 
    0.00726601f, -0.02360345f, 0.00121628f, 0.00445974f, -0.03186940f, -0.03490021f, -0.03135671f, 0.02704784f, 
    -0.01729970f, 0.01678056f, -0.02825128f, -0.03010894f, 0.02689175f, -0.03553714f, 0.00063742f, -0.01874964f, 
    0.00309883f, 0.00695863f, 0.00554694f, 0.02682707f, -0.03187798f, -0.01674947f, 0.01703023f, -0.03361545f, 
    0.02553928f, -0.00001566f, 0.02187128f, -0.00745677f, -0.02799223f, -0.00041905f, 0.01413488f, -0.02955377f, 
    0.01241417f, 0.01844595f, -0.00365839f, -0.03771885f, 0.01949576f, 0.00290250f, 0.01419288f, -0.00112669f, 
    0.02112656f, -0.01428233f, 0.02472776f, 0.01323275f, 0.00372706f, 0.00933653f, -0.00783374f, 0.01513287f, 
    -0.02379729f, -0.02497274f, 0.02466369f, -0.00211355f, 0.02867021f, -0.01250638f, 0.02811956f, 0.02457604f, 
    -0.01006223f, -0.02204812f, -0.03637554f, -0.00019680f, -0.00666649f, 0.02001330f, 0.02530554f, 0.02463145f, 
    -0.00715597f, 0.01216830f, -0.00109741f, 0.00256760f, 0.00095698f, -0.00490627f, -0.00367991f, -0.00291703f, 
    -0.02814519f, 0.00943697f, -0.01389795f, -0.01451192f, 0.00898223f, -0.01679122f, -0.00443710f, -0.02503527f, 
    0.01681407f, 0.01494749f, -0.02580510f, -0.01659221f, -0.01092459f, -0.01645723f, -0.01220967f, 0.00640336f, 
    -0.03312246f, -0.02864293f, 0.02743807f, -0.02600592f, 0.01222743f, 0.00078583f, -0.03291700f, -0.03182184f, 
    0.00582618f, -0.01800588f, -0.01277911f, 0.01338806f, -0.00287049f, 0.00686404f, -0.02522055f, 0.03458748f, 
    -0.02215593f, -0.01720482f, 0.01066778f, -0.03911098f, -0.01727324f, -0.02407208f, 0.02389284f, 0.03034035f, 
    0.00334266f, -0.02418464f, -0.01368395f, -0.03648892f, -0.03166424f, -0.02358218f, -0.03323897f, -0.02869171f, 
    -0.01517089f, 0.01156068f, 0.00255085f, -0.01073804f, 0.01582853f, -0.01633795f, -0.00836390f, -0.01608935f, 
    -0.02423416f, -0.02343939f, -0.00382210f, -0.03666489f, -0.03422830f, -0.00655743f, 0.01726274f, 0.02495831f, 
    0.00567000f, 0.02158208f, 0.02784579f, -0.02255823f, 0.00861789f, -0.00792691f, -0.01021369f, -0.01091183f, 
    0.02204145f, -0.00286353f, 0.01915687f, -0.02488874f, 0.00371657f, 0.02277885f, -0.03976616f, 0.02818241f, 
    0.01960126f, -0.04005559f, -0.03942108f, -0.01529150f, 0.00792130f, -0.03642098f, 0.01941159f, -0.02610430f, 
    0.00122151f, -0.03461776f, 0.00021573f, 0.03385795f, 0.00909277f, -0.01330645f, 0.00061608f, -0.01384958f, 
    -0.00255797f, -0.02676167f, 0.01145428f, -0.02588290f, 0.01152698f, 0.00067447f, -0.03900724f, -0.03097510f, 
    -0.02043472f, 0.02773322f, -0.02293573f, -0.01903197f, -0.00638366f, -0.00495633f, -0.02228466f, -0.01685854f, 
    -0.00407119f, 0.00031556f, -0.04133846f, -0.02935034f, -0.03690052f, 0.00671767f, -0.02346966f, 0.01454545f, 
    -0.00748498f, -0.00942485f, 0.01810686f, -0.03878903f, 0.01008089f, -0.02674871f, -0.03384231f, 0.01273786f, 
    0.02049794f, 0.01477761f, 0.01872969f, -0.02759857f, -0.02508460f, -0.03111527f, -0.03069062f, -0.01850699f, 
    0.02909683f, -0.02176311f, -0.03833127f, 0.00479529f, -0.01548848f, -0.01278077f, 0.02113356f, 0.02380896f, 
    -0.02168348f, -0.02145749f, -0.02119938f, 0.02937404f, -0.00411131f, 0.00578757f, -0.02660447f, -0.00680770f, 
    0.00342022f, 0.01163144f, 0.00810234f, -0.02761594f, -0.00459880f, -0.03911114f, 0.00375206f, 0.00992740f, 
    0.02320651f, 0.02279928f, 0.02149538f, -0.01626064f, 0.01909658f, -0.02388501f, 0.00648628f, -0.03046260f, 
    -0.02624639f, -0.01163249f, 0.02036649f, -0.02323652f, 0.01879479f, -0.00223005f, -0.02123714f, 0.01488228f, 
    0.01953487f, 0.02172798f, 0.01485682f, 0.01751649f, -0.01008955f, 0.01313054f, -0.04083681f, -0.03324223f, 
    0.01178719f, -0.04109706f, -0.02962150f, 0.02120605f, -0.01233612f, 0.00877579f, -0.02310618f, 0.01259315f, 
    0.00464361f, -0.00223722f, -0.04064978f, 0.01839280f, -0.03412595f, -0.03592781f, -0.01656332f, -0.00608106f, 
    -0.00270996f, 0.01026105f, -0.03005579f, -0.02704910f, 0.02584055f, 0.02650805f, -0.03623055f, -0.03326625f, 
    -0.02420024f, -0.01553377f, 0.00360652f, 0.00036527f, -0.00868861f, 0.02366275f, 0.02254972f, -0.00011972f, 
    -0.01614100f, -0.00820010f, 0.02802928f, 0.02961966f, -0.02504474f, 0.01103225f, 0.00385531f, -0.01741534f, 
    -0.01945776f, -0.02847829f, -0.02893613f, -0.02369621f, -0.02548881f, 0.01479715f, 0.01602899f, -0.00035040f, 
    0.00092485f, -0.02335445f, -0.01947536f, -0.02860618f, -0.00129293f, -0.00942171f, -0.00163987f, 0.01875482f, 
    -0.02621615f, -0.01291991f, -0.00659827f, 0.02723515f, -0.00989473f, -0.00325934f, -0.03012187f, -0.01423416f, 
    0.00561403f, 0.02285221f, 0.01854813f, 0.01506303f, 0.01258711f, 0.00646209f, -0.01694517f, -0.02630278f, 
    0.02491655f, -0.01408305f, -0.02747072f, 0.01564112f, 0.00125757f, -0.01757114f, -0.03912719f, -0.01050402f, 
    -0.04130952f, -0.01462725f, 0.00676062f, 0.00225683f, -0.04107524f, -0.01127793f, 0.01386224f, -0.03158966f, 
    -0.02195331f, 0.02336024f, -0.03224736f, 0.01343879f, -0.01493890f, -0.01586828f, 0.00252439f, 0.02279276f, 
    -0.03921944f, -0.00835366f, -0.03631188f, 0.02914273f, 0.03551563f, 0.00575959f, -0.02436980f, -0.00429761f, 
    0.02078727f, 0.01756072f, 0.02283916f, -0.04135715f, -0.03560853f, -0.02122838f, -0.03062658f, -0.00744038f, 
    0.02707847f, 0.02100716f, 0.02128822f, -0.04125404f, -0.01043416f, -0.00280785f, 0.00277102f, -0.01064610f, 
    0.00403764f, 0.01547270f, 0.01401199f, 0.00029159f, -0.01444039f, -0.00306724f, -0.00322454f, 0.00613489f, 
    0.00102257f, -0.02096804f, -0.02336715f, -0.02374008f, -0.03366526f, -0.00760392f, 0.01734735f, 0.01703905f, 
    0.02842932f, -0.03793561f, -0.01222222f, -0.04147746f, 0.02251856f, -0.03872030f, 0.01322015f, -0.01896471f, 
    0.02726038f, 0.01612622f, -0.00696567f, -0.03579013f, -0.01509587f, 0.00032342f, 0.01169170f, -0.03403298f, 
    -0.00383958f, 0.01175716f, 0.01861614f, -0.03443268f, 0.00380707f, 0.02279310f, -0.03675872f, 0.02554059f, 
    0.01708267f, 0.02986809f, 0.00717556f, -0.02749640f, -0.02954368f, -0.02284643f, -0.01521186f, -0.02858722f, 
    -0.01388932f, -0.01387939f, 0.00477873f, 0.01725625f, -0.02118504f, -0.00471263f, 0.02732230f, -0.00746770f, 
    0.02124160f, -0.00027150f, -0.00995792f, -0.01827743f, -0.02647942f, 0.02383815f, -0.00412972f, 0.01659531f, 
    -0.02432798f, 0.00999576f, -0.03980602f, 0.02783897f, 0.01420940f, -0.01731100f, -0.03182373f, 0.00304920f, 
    -0.03932275f, -0.00013309f, 0.02057631f, 0.02328139f, 0.02027287f, 0.00193273f, 0.01272661f, -0.02654725f, 
    0.02784871f, -0.01408344f, -0.02833951f, 0.01677623f, -0.03142215f, 0.01008771f, 0.00920136f, -0.04119254f, 
    -0.02769225f, -0.02873606f, -0.03327478f, -0.03688733f, 0.02819822f, 0.00101654f, -0.02215650f, -0.03128563f, 
    -0.02866923f, -0.00874031f, -0.02255077f, 0.00122442f, -0.01263112f, -0.00849275f, 0.01097051f, -0.02597541f, 
    -0.01304690f, -0.03546999f, -0.02411954f, 0.00005014f, 0.03106179f, -0.00540591f, -0.02507893f, -0.01264542f, 
    -0.03707530f, 0.01715645f, -0.01533528f, 0.01829194f, -0.02054682f, -0.02098192f, 0.01305892f, -0.01556144f, 
    -0.00815249f, -0.03519504f, -0.02542333f, 0.00275613f, 0.01774107f, -0.00345923f, -0.03139152f, -0.01710008f, 
    0.02913130f, -0.02500543f, -0.00059032f, 0.02297393f, -0.01379133f, -0.03133712f, -0.01583425f, -0.02501300f, 
    -0.03445373f, -0.02112752f, 0.00975298f, -0.00184526f, -0.03053687f, -0.03040528f, 0.00030113f, -0.01092212f, 
    -0.03255528f, -0.03884931f, 0.00092624f, 0.02842981f, 0.01086481f, 0.00936057f, -0.02562654f, -0.02842919f, 
    -0.02104445f, 0.00426033f, -0.00715906f, -0.00271262f, 0.02116688f, -0.03153515f, -0.03451617f, -0.03983342f, 
    -0.02816066f, -0.00419386f, -0.04036876f, 0.00381285f, 0.01951393f, 0.00144731f, -0.00686669f, 0.00607688f, 
    0.01962231f, 0.02750867f, 0.01232293f, -0.00351035f, 0.02347495f, -0.03136433f, -0.02493197f, 0.02241034f, 
    0.01260771f, -0.00349688f, -0.02684910f, -0.00957150f, 0.02841116f, 0.01135337f, 0.00350241f, 0.02638186f, 
    -0.01392915f, -0.02094431f, -0.03817313f, -0.03888069f, 0.02901515f, 0.00231200f, 0.02334984f, -0.02412824f, 
    -0.03594564f, 0.03112392f, 0.01294241f, -0.03137840f, 0.01632709f, -0.02194178f, 0.00042566f, -0.00863903f, 
    0.00704170f, 0.01917544f, -0.00659116f, -0.02686069f, -0.00447752f, 0.00314392f, 0.00719366f, -0.02774063f, 
    -0.00126571f, 0.01977183f, -0.03169011f, -0.02837424f, -0.03351999f, -0.01710864f, -0.03195847f, 0.00166211f, 
    -0.01742898f, 0.02727967f, 0.02107991f, -0.02322260f, -0.04027465f, 0.01534313f, 0.00078366f, 0.02758378f, 
    -0.00702213f, -0.00861411f, -0.00302045f, -0.00142745f, -0.03023542f, 0.01832229f, 0.00125567f, -0.01753721f, 
    -0.02678064f, -0.02994773f, 0.00640780f, -0.04076875f, 0.02781251f, -0.02519708f, -0.03410663f, 0.01526272f, 
    0.00799874f, -0.01138848f, 0.00092002f, -0.02693160f, 0.00467332f, -0.00881952f, -0.03596221f, 0.01419813f, 
    0.00631387f, -0.01268646f, -0.01485706f, -0.00333730f, 0.02129017f, 0.00801017f, -0.03131052f, 0.01671658f, 
    0.01028069f, 0.01136698f, 0.02297319f, -0.02691030f, 0.00269464f, 0.01761123f, -0.01865130f, -0.02252140f, 
    -0.00750159f, 0.01916262f, 0.01807989f, -0.02633915f, -0.03488994f, -0.01657332f, 0.03180925f, -0.03422235f, 
    0.02642377f, 0.01309747f, 0.02473646f, -0.01360033f, 0.02207612f, -0.01445294f, -0.00644675f, -0.01930944f, 
    -0.01003888f, -0.00922490f, 0.02160671f, -0.01025077f, -0.03241315f, 0.02750546f, -0.02846706f, -0.03470534f, 
    0.00342274f, 0.00989805f, 0.00127152f, -0.03164947f, 0.00398237f, -0.03497842f, -0.03337630f, -0.01877295f, 
    -0.21701922f, -0.29880920f, -0.22353849f, -0.04375070f, -0.04261802f, -0.02263842f, 0.02059545f, 0.00300054f, 
    0.04274271f, 0.14709635f, 0.05536702f, 0.07899154f, 0.20095453f, 0.17385645f, 0.02726174f, -0.03633285f, 
    0.04008275f, 0.16730788f, -0.19383781f, 0.03340177f, 0.10004636f, -0.05210341f, 0.06745204f, -0.03454422f, 
    -0.07059417f, 0.45582396f, -0.14287540f, 0.00414025f, 0.01741543f, 0.11721782f, 0.14014870f, -0.06895841f, 
    -0.04012557f, -0.08195477f, -0.02715413f, 0.05121212f, -0.03573187f, -0.23624228f, 0.18392746f, 0.33004111f, 
    -0.04377373f, 0.07552560f, 0.06016324f, 0.11379213f, -0.14615650f, 0.02755296f, -0.06115007f, -0.01503897f, 
    0.14871015f, 0.04767942f, 0.03153586f, -0.04264158f, -0.10044375f, -0.03540934f, 0.00677374f, 0.02204393f, 
    0.04192099f, -0.04206181f, 0.02467416f, 0.05759666f, 0.30432844f, 0.18899342f, 0.09254773f, 0.09052752f, 
    0.10391784f, -0.11092402f, -0.09821462f, 0.01596947f, 0.03248525f, -0.06506050f, -0.02282704f, -0.07252615f, 
    -0.09457013f, -0.08690722f, -0.20690987f, -0.03070420f, -0.03784985f, 0.07396863f, 0.06492911f, -0.02696917f, 
    0.00983523f, -0.10847624f, 0.17568380f, -0.02544617f, 0.22559190f, 0.36220890f, 0.38933638f, 0.18555820f, 
    0.05531880f, 0.08087988f, 0.08096197f, 0.13375117f, 0.18528414f, 0.04408364f, -0.00473855f, -0.00894276f, 
    0.03442366f, 0.03102732f, -0.06174082f, 0.15061510f, -0.03157232f, 0.21172592f, 0.05320115f, -0.03864894f, 
    -0.05314786f, -0.04379870f, 0.06739338f, 0.22480503f, -0.21860808f, -0.06933487f, -0.24368559f, -0.17417391f, 
    0.13062067f, -0.02466186f, -0.03609230f, -0.02642618f, -0.08886430f, -0.03006513f, 0.14316246f, 0.10393614f, 
    0.03731306f, 0.06449545f, -0.00788221f, -0.02202121f, 0.17745745f, 0.02198871f, 0.13219860f, -0.05027772f, 
    0.13043778f, -0.11919377f, -0.10413470f, -0.03442723f, 0.09180585f, -0.00424925f, 0.16851601f, 0.26872814f, 
    0.17440133f, 0.24817383f, 0.18777695f, 0.13678317f, -0.04957861f, 0.00833442f, -0.00152025f, 0.06659793f, 
    -0.07993167f, -0.20448978f, -0.22703457f, -0.16366021f, 0.10032663f, -0.00139072f, 0.01002640f, -0.01770585f, 
    0.07391306f, 0.01129660f, 0.03070273f, 0.07539932f, -0.23281422f, -0.03096129f, 0.04590537f, -0.11487643f, 
    0.05629393f, -0.04017894f, -0.19548653f, 0.15956607f, 0.01163641f, -0.08677728f, 0.06616154f, -0.08248440f, 
    -0.00000122f, 0.02988402f, -0.00837090f, 0.12023623f, 0.01024084f, -0.09205328f, 0.05710376f, 0.20841330f, 
    -0.18395466f, 0.04785515f, -0.16737799f, -0.10448501f, 0.15717556f, -0.21477416f, -0.07531318f, -0.04687253f, 
    -0.04939890f, -0.01218767f, 0.02314563f, -0.08952938f, 0.25679961f, 0.15984580f, 0.22383964f, 0.09641647f, 
    0.12751441f, 0.25032485f, 0.29448867f, 0.16049416f, 0.01951526f, -0.17067179f, 0.23553060f, -0.08176905f, 
    -0.00030969f, 0.03954902f, 0.13151114f, -0.18874522f, -0.13257660f, -0.16375570f, 0.15738197f, -0.07213723f, 
    0.01254030f, 0.08462701f, -0.01170824f, -0.03997929f, 0.00033511f, 0.09172159f, -0.12615545f, -0.01316489f, 
    -0.02153315f, 0.01526246f, 0.15823874f, 0.19688608f, -0.00406520f, -0.03255477f, -0.02786691f, 0.04731650f, 
    -0.00881777f, -0.01034441f, 0.02399064f, 0.16536465f, -0.23846275f, -0.12027297f, -0.01508259f, 0.16850042f, 
    -0.06505535f, 0.08780040f, 0.01214392f, -0.05838963f, 0.08246753f, -0.05969755f, -0.00319874f, -0.02475844f, 
    0.07913107f, 0.11465664f, 0.25867850f, 0.26212522f, -0.06131561f, 0.05178107f, -0.01361021f, -0.00941376f, 
    -0.01350143f, -0.00186772f, 0.00434857f, -0.04147170f, -0.30409220f, -0.12686701f, -0.08483572f, -0.12568037f, 
    -0.06468545f, -0.01778138f, -0.06708229f, -0.02356242f, 0.04073721f, 0.07147428f, -0.01635748f, -0.01490496f, 
    -0.17267799f, 0.12605366f, -0.19116718f, 0.16437803f, -0.00483829f, 0.05304210f, -0.00295955f, -0.02788554f, 
    0.00835038f, 0.01596874f, -0.05931632f, -0.11754753f, -0.04896794f, 0.01973236f, 0.22071619f, 0.14616510f, 
    0.13940926f, 0.11130559f, 0.12608239f, 0.13388826f, 0.01253854f, 0.09871000f, -0.08322959f, 0.05618973f, 
    0.29544982f, 0.29518086f, -0.14914000f, 0.45565644f, -0.07858665f, 0.02237093f, -0.02271793f, -0.13359369f, 
    0.10402442f, -0.01409484f, 0.00149711f, -0.02937390f, 0.20014426f, 0.02243133f, 0.15472543f, 0.03268569f, 
    -0.01893862f, -0.02421806f, 0.07755805f, -0.17714091f, -0.08330245f, -0.01761173f, -0.00051402f, 0.05323242f, 
    -0.07939794f, -0.16691300f, -0.05491902f, -0.10550295f, -0.00847564f, -0.07232168f, 0.01719266f, 0.01942925f, 
    -0.10726238f, 0.06988958f, 0.06571572f, 0.05228520f, 0.06936396f, 0.19836643f, 0.08319668f, 0.08580753f, 
    0.08621196f, 0.01906859f, 0.06708591f, 0.02662459f, 0.11344542f, -0.08989889f, -0.00357880f, -0.00325490f, 
    0.04093892f, 0.04854221f, 0.11719146f, 0.02138520f, 0.00057455f, 0.05592721f, -0.02910028f, 0.11023104f, 
    0.02912279f, 0.24251696f, -0.00708406f, 0.15512817f, -0.20242684f, -0.26607063f, -0.27425644f, 0.00950941f, 
    -0.06380921f, 0.01149916f, 0.05496421f, 0.07799081f, 0.08335333f, 0.04692698f, 0.03277700f, -0.04372340f, 
    -0.02316734f, -0.10562995f, -0.16682634f, -0.13158381f, 0.02724295f, 0.01492194f, 0.01584837f, -0.01938476f, 
    -0.06562585f, 0.04106487f, 0.00354545f, 0.08471586f, -0.03803675f, 0.06936292f, -0.13540924f, -0.21202920f, 
    0.03221281f, -0.00200584f, 0.09377310f, -0.20846087f, 0.17945242f, -0.13401107f, 0.08421790f, 0.04187312f, 
    0.28881162f, 0.41605702f, 0.15647513f, 0.19865808f, 0.05649231f, -0.01552136f, 0.04067715f, 0.08453452f, 
    0.10994779f, 0.12424693f, 0.06875886f, 0.11695923f, -0.25852025f, -0.32146364f, -0.27473354f, -0.15829720f, 
    0.06470661f, 0.01403744f, 0.00869504f, 0.01780206f, 0.02939063f, 0.07435952f, 0.06328903f, -0.01216375f, 
    -0.20060243f, -0.20540018f, -0.23393682f, -0.14503160f, -0.02728303f, -0.03925801f, -0.07271014f, 0.00277103f, 
    0.14141792f, 0.18355392f, 0.13405050f, 0.26979417f, 0.02523207f, 0.10291372f, 0.28130797f, 0.19285987f, 
    0.17265402f, 0.01616064f, -0.02741979f, 0.07227810f, 0.09476788f, -0.00423218f, 0.02725045f, -0.01039949f, 
    0.11340762f, 0.09437667f, 0.05759723f, 0.03590614f, -0.02284148f, -0.11662357f, 0.02994434f, 0.02014296f, 
    0.14737754f, -0.01559661f, -0.02543593f, -0.06097371f, -0.05799228f, -0.21158196f, 0.00959216f, -0.03138123f, 
    0.04892274f, 0.02347569f, -0.10874193f, -0.00110788f, 0.01633533f, 0.04518371f, 0.07201593f, 0.19597018f, 
    0.07412130f, 0.09907027f, -0.02161122f, -0.02076793f, 0.04852665f, 0.02545546f, 0.09032889f, 0.17898335f, 
    0.12671134f, 0.06490681f, -0.00028695f, -0.03228915f, -0.28406960f, -0.18786584f, -0.04148415f, 0.07635723f, 
    0.04451583f, -0.00689957f, -0.00785724f, -0.00204908f, -0.11950377f, -0.05394236f, -0.00209596f, -0.08811826f, 
    -0.38000238f, -0.37393555f, -0.24238123f, -0.07793302f, -0.01535070f, -0.04049552f, -0.05216534f, -0.11674473f, 
    0.13787310f, 0.00139208f, 0.00008642f, 0.08586718f, 0.13286275f, 0.11337712f, 0.18026955f, 0.06714172f, 
    0.20072801f, 0.06613079f, 0.21350132f, 0.36550292f, -0.02625615f, 0.05653647f, -0.01173431f, 0.13520485f, 
    0.05424250f, 0.02945701f, 0.06110998f, -0.05401663f, 0.08848833f, -0.02018523f, -0.05310939f, -0.01011568f, 
    -0.02331041f, -0.00847672f, -0.08631883f, -0.09435738f, 0.15274911f, 0.39188570f, 0.23848158f, 0.22548632f, 
    0.08013245f, -0.01180182f, -0.05356781f, 0.05939446f, -0.05498886f, 0.02734780f, 0.03494500f, 0.02855385f, 
    -0.19396871f, -0.18404053f, -0.05249286f, -0.06273491f, 0.02891399f, -0.02465064f, 0.08660016f, 0.09999886f, 
    -0.00458169f, 0.07496520f, 0.00427681f, -0.00171863f, 0.06184505f, -0.03581230f, 0.16031791f, -0.00328076f, 
    -0.02097181f, 0.09095535f, 0.02608269f, 0.07654095f, -0.05993923f, 0.11715243f, -0.10763551f, -0.07579482f, 
    0.03321405f, 0.13882026f, 0.03804807f, 0.17734519f, 0.08892377f, 0.06858431f, 0.24560863f, 0.10165244f, 
    -0.05254311f, -0.05125140f, -0.02921171f, 0.14061183f, -0.09023898f, 0.06872285f, -0.04062213f, 0.14089324f, 
    0.05017897f, 0.11382250f, 0.11136159f, -0.04373520f, 0.01937224f, 0.07489032f, 0.02347529f, 0.01991926f, 
    -0.00077215f, 0.06227924f, -0.01478297f, -0.08452932f, 0.06994333f, 0.00770430f, -0.01223062f, 0.09981076f, 
    -0.02903840f, 0.04614922f, 0.13919824f, 0.00497177f, 0.00030090f, -0.13510072f, -0.18619254f, 0.02607591f, 
    -0.05395428f, -0.01981669f, -0.05025879f, 0.12026685f, -0.15249708f, 0.23457922f, -0.16111159f, -0.12883127f, 
    0.13034636f, 0.25412032f, 0.23862198f, 0.26269573f, 0.04086244f, 0.08246396f, -0.10431348f, 0.07745785f, 
    -0.15161565f, 0.07566863f, -0.12510979f, -0.07834994f, -0.13841458f, -0.03262835f, 0.01392142f, -0.04422089f, 
    0.05251726f, 0.01230493f, -0.05538066f, 0.05563731f, 0.09322982f, -0.21927361f, 0.01908061f, 0.18067576f, 
    -0.16319467f, -0.24710542f, -0.05920039f, -0.00144809f, 0.05756341f, 0.04243072f, 0.07404815f, 0.08090390f, 
    -0.04288860f, -0.00212378f, -0.02935476f, 0.03826064f, 0.18470256f, 0.24474654f, 0.21988490f, 0.16423638f, 
    -0.03309947f, -0.16590163f, -0.05003742f, 0.05879383f, 0.08348997f, 0.00101554f, -0.04470907f, -0.05709165f, 
    -0.02903212f, -0.36635217f, 0.11369833f, 0.27629647f, 0.20982803f, 0.05371781f, -0.03541319f, -0.06964163f, 
    0.08543252f, 0.03152290f, -0.06503114f, 0.11770596f, -0.11158600f, -0.02348712f, 0.08284139f, 0.13578697f, 
    0.16572447f, 0.11217083f, 0.04865560f, 0.26386437f, -0.03449862f, 0.03242886f, -0.04226099f, -0.11012387f, 
    -0.07718309f, -0.02956601f, -0.07035884f, -0.13481501f, 0.05361889f, -0.04673727f, -0.02537323f, 0.04150020f, 
    0.18182054f, 0.03791533f, 0.00631069f, 0.26481265f, -0.12829618f, -0.25073233f, -0.18256994f, -0.08554900f, 
    0.10256623f, -0.01417488f, -0.02987394f, -0.04623307f, 0.10478901f, -0.01131494f, 0.12133005f, 0.15060651f, 
    0.09238021f, 0.07625854f, 0.09378796f, 0.26190931f, 0.07596173f, -0.08285645f, 0.02515716f, 0.21440762f, 
    -0.00948977f, -0.08461878f, -0.08378879f, -0.09855718f, -0.21907642f, -0.12471499f, 0.04788984f, 0.18067512f, 
    0.03583625f, -0.02073751f, 0.05873842f, 0.18469922f, 0.01755085f, -0.12846103f, -0.16141535f, -0.00425452f, 
    0.14944361f, 0.10708787f, 0.07946065f, 0.06096167f, 0.01875750f, -0.01892070f, -0.05080432f, -0.11068014f, 
    0.04971617f, 0.00699688f, -0.03891015f, -0.04170751f, 0.26207903f, 0.40117753f, 0.10205730f, 0.29925138f, 
    0.10357749f, 0.08757493f, 0.10042837f, -0.02877053f, 0.03862054f, -0.01927359f, 0.02904614f, -0.13300267f, 
    -0.02280159f, -0.13705558f, 0.07094868f, 0.23953602f, -0.05215698f, 0.10033845f, -0.05011809f, -0.00249610f, 
    0.03014783f, -0.04570395f, 0.06867058f, -0.07263675f, 0.17061770f, 0.15965535f, 0.11513760f, 0.13509931f, 
    0.12169223f, 0.09320658f, 0.02180119f, -0.00930519f, 0.03884373f, 0.07628114f, -0.08412110f, 0.02001616f, 
    0.01788322f, -0.03180326f, 0.01866214f, -0.02995187f, -0.02084403f, -0.03959307f, -0.03993435f, 0.01633420f, 
    -0.00100191f, -0.02094333f, -0.03888668f, -0.03713744f, -0.01577181f, 0.01713318f, -0.03509765f, -0.00216884f, 
    0.01931353f, -0.00857813f, 0.02451397f, -0.00233562f, 0.00112358f, 0.02506646f, 0.00512922f, -0.01890077f, 
    -0.01819235f, -0.01915672f, -0.01491941f, 0.02491890f, 0.02862955f, 0.00299132f, 0.02206757f, 0.01176196f, 
    -0.03117011f, -0.01230700f, -0.01650636f, -0.04020565f, -0.01411814f, -0.03757719f, 0.00131511f, -0.00329892f, 
    0.02386249f, 0.00473505f, 0.01110345f, 0.01315764f, -0.02955291f, 0.02979176f, -0.03711114f, -0.03686548f, 
    0.00662219f, -0.01900144f, -0.00675835f, -0.03944374f, 0.02196453f, 0.02144806f, 0.01228489f, -0.01595790f, 
    -0.00213370f, -0.00898466f, -0.02532905f, 0.02628535f, -0.03049356f, -0.02208629f, -0.03498344f, -0.03751196f, 
    -0.00179635f, -0.00444600f, -0.01721407f, -0.01014294f, -0.00044963f, -0.00244013f, -0.03301137f, 0.01962771f, 
    -0.01546060f, -0.00349004f, -0.02299280f, 0.01427440f, -0.01499547f, -0.00259923f, -0.00200016f, 0.02705029f, 
    0.01531258f, -0.03016282f, -0.03030594f, 0.01623735f, 0.01086100f, 0.00710845f, -0.00189720f, -0.00300486f, 
    -0.00604538f, -0.03391996f, 0.00036932f, 0.02050992f, 0.02622368f, -0.01169974f, -0.02972756f, -0.00478722f, 
    0.00944897f, -0.02046076f, -0.03280907f, 0.00334890f, -0.03360235f, 0.03493309f, 0.01493667f, 0.01339891f, 
    0.01518004f, -0.01850417f, -0.00438689f, -0.01216203f, 0.02127837f, -0.02224556f, -0.02853804f, 0.01903641f, 
    -0.03693476f, 0.02315514f, -0.03596841f, 0.00329154f, -0.01492548f, 0.01010811f, 0.00162809f, 0.00966458f, 
    0.02813857f, 0.01400354f, 0.01031943f, -0.01296738f, -0.01602647f, -0.03679785f, -0.01566513f, 0.02290230f, 
    0.01293591f, -0.02746209f, -0.03145207f, 0.00801061f, -0.00840156f, -0.02632533f, -0.02975112f, -0.02927925f, 
    -0.03379680f, 0.01399162f, -0.01483000f, 0.02862466f, -0.03084491f, 0.01797004f, 0.02238213f, 0.02020036f, 
    -0.04202674f, -0.01163545f, 0.02635106f, 0.01952279f, -0.03678691f, -0.01698029f, 0.00977897f, -0.01740230f, 
    -0.04167848f, -0.03989078f, -0.03029456f, -0.03095488f, 0.02244367f, 0.00182540f, 0.00878652f, 0.02064612f, 
    -0.00282978f, 0.01089755f, -0.00919499f, 0.02441847f, -0.00307375f, 0.01595326f, -0.03655513f, -0.03403800f, 
    -0.01684974f, 0.01076923f, 0.02695670f, -0.01753536f, -0.00850762f, 0.02991803f, -0.02923641f, 0.01951678f, 
    -0.04198658f, 0.00466988f, 0.01032936f, 0.00753556f, -0.01634213f, 0.00409003f, -0.00480740f, 0.00240729f, 
    -0.00699794f, 0.02253473f, -0.01779754f, -0.02474108f, -0.01449652f, 0.00830840f, -0.01398269f, 0.02206259f, 
    0.00212531f, -0.01042888f, -0.00711522f, 0.01591233f, 0.01048978f, 0.00004004f, 0.00488232f, -0.01305256f, 
    -0.01215465f, -0.02380084f, -0.01498277f, -0.02807259f, 0.01572955f, -0.01929202f, -0.00905966f, -0.02687030f, 
    0.00614400f, 0.00329667f, -0.02386913f, -0.01580458f, -0.00036305f, -0.02335928f, -0.03458344f, 0.02488510f, 
    0.02553913f, -0.03108908f, -0.00578396f, -0.01975057f, 0.02472827f, 0.00677275f, -0.01311522f, -0.00696237f, 
    0.01747617f, -0.03348472f, -0.00994466f, -0.00411765f, 0.00929511f, 0.02025290f, -0.02065411f, 0.00147356f, 
    -0.03751134f, 0.00158875f, 0.00754406f, 0.01170787f, 0.00488920f, -0.02372740f, 0.01272849f, -0.02971428f, 
    -0.01932226f, 0.02877835f, 0.00213536f, 0.01255280f, -0.02220065f, -0.03417751f, -0.02823409f, -0.00662218f, 
    0.01815660f, -0.00148167f, -0.03399492f, 0.02290426f, -0.04151674f, -0.02370682f, -0.02566189f, -0.03278092f, 
    -0.03505426f, -0.00926323f, -0.01603166f, -0.00439466f, -0.02282147f, 0.01292826f, 0.01656313f, -0.03354153f, 
    -0.02598695f, -0.02101016f, -0.02403669f, 0.01559392f, -0.01955825f, -0.01561726f, 0.00011923f, -0.00262934f, 
    -0.02609666f, -0.02903613f, 0.00629149f, 0.02518936f, 0.02328094f, -0.03911756f, -0.03314880f, 0.03089694f, 
    0.02921132f, -0.03806898f, 0.02136864f, 0.01537722f, -0.01457787f, 0.00053690f, -0.02480716f, -0.02857427f, 
    -0.00465076f, -0.01131038f, 0.00786444f, -0.03765223f, 0.00685025f, -0.04071227f, -0.02079624f, 0.00751743f, 
    0.02850101f, -0.02226674f, -0.03604482f, 0.01949126f, -0.00488381f, -0.02373881f, -0.03742074f, -0.03541083f, 
    -0.03601133f, 0.00624672f, 0.01614984f, 0.00953702f, -0.04118835f, 0.02178399f, -0.00821317f, 0.02066571f, 
    -0.04072520f, 0.02937390f, 0.01163561f, -0.01399448f, -0.02362818f, -0.02736089f, 0.00374153f, -0.00228467f, 
    -0.01679409f, 0.01603737f, 0.02340474f, -0.01615498f, -0.02898404f, 0.02188641f, -0.00497623f, -0.00265968f, 
    0.01521996f, 0.01209877f, 0.01467642f, -0.00375751f, 0.03005834f, -0.03488231f, -0.01217526f, 0.00437613f, 
    -0.00533375f, 0.01959591f, 0.00158504f, -0.00023423f, 0.01440874f, 0.01704472f, 0.01421979f, -0.03262592f, 
    0.00322263f, 0.01191407f, -0.03637299f, 0.01290172f, 0.00952296f, -0.02380499f, -0.00338078f, 0.01548147f, 
    -0.04081039f, -0.00983949f, -0.02768281f, -0.01168908f, -0.02798528f, 0.00605467f, 0.01699219f, -0.03718529f, 
    -0.00058415f, -0.04182525f, -0.01587085f, 0.02244992f, -0.01325399f, -0.03641367f, 0.01512639f, -0.00530421f, 
    -0.02492071f, -0.04088124f, -0.02340561f, 0.00449917f, -0.02989842f, 0.01803080f, -0.00721205f, -0.02994842f, 
    -0.00594478f, -0.03262193f, -0.03795191f, 0.01433546f, 0.01702861f, 0.00962396f, -0.03570558f, 0.01083803f, 
    -0.00069027f, -0.02676227f, -0.02552976f, -0.04091903f, 0.01307294f, 0.02510866f, 0.01856832f, -0.00746024f, 
    0.00236956f, -0.04106635f, -0.00383075f, 0.01828670f, 0.02293525f, -0.01949388f, 0.01504246f, -0.03275734f, 
    0.00242247f, -0.03896767f, -0.03661827f, 0.00459856f, -0.02678310f, -0.03446238f, -0.01562798f, -0.03206169f, 
    -0.00644333f, 0.02561000f, 0.03201666f, -0.04087278f, -0.02188314f, 0.02598991f, 0.02658696f, 0.00159379f, 
    -0.02317558f, 0.02717775f, 0.00730587f, 0.00627393f, 0.02929130f, 0.00318831f, -0.01323042f, -0.00108982f, 
    0.02862707f, -0.01411946f, 0.01920615f, -0.02294713f, -0.02715042f, 0.01943571f, 0.00092396f, 0.02791908f, 
    -0.03865099f, -0.01770981f, 0.00339987f, -0.02422255f, -0.02669064f, 0.00152303f, -0.00590069f, 0.01351896f, 
    -0.00285541f, -0.02464250f, -0.02465809f, -0.00884911f, 0.02645162f, 0.02539895f, -0.01651831f, 0.02581264f, 
    -0.02533904f, -0.01569342f, 0.01826043f, -0.00993930f, 0.01974575f, -0.02700985f, -0.02746594f, -0.03228560f, 
    -0.01142114f, -0.01990570f, -0.01819178f, 0.01314662f, 0.00535907f, -0.03176690f, -0.01871026f, -0.01133155f, 
    -0.03828246f, -0.02883532f, -0.03850807f, -0.00319464f, 0.00037568f, -0.02607710f, 0.01562122f, -0.03553076f, 
    -0.03764012f, 0.00356443f, -0.01462043f, -0.00774122f, -0.03157449f, 0.02568645f, 0.01722041f, 0.02732199f, 
    0.03149105f, 0.01153617f, -0.03433679f, -0.01207713f, -0.01299734f, 0.01988319f, 0.03279809f, -0.03426762f, 
    -0.03679865f, -0.02732279f, -0.01289506f, -0.03628957f, -0.03636768f, 0.02626362f, 0.00633083f, -0.00944202f, 
    -0.03903766f, -0.03582760f, -0.02966534f, 0.02327102f, 0.00149516f, -0.03788834f, 0.01005567f, 0.01946071f, 
    0.01017498f, -0.01140603f, -0.00385778f, 0.00583741f, -0.00285886f, -0.01423177f, -0.00120356f, 0.01048320f, 
    -0.02566568f, 0.02214606f, -0.00739146f, -0.02872326f, -0.02596190f, -0.01415654f, 0.00024946f, -0.00609888f, 
    -0.02135236f, -0.03731164f, 0.00903659f, 0.02734894f, -0.03653870f, -0.03895414f, 0.01777935f, -0.01669338f, 
    -0.02913283f, 0.01351052f, -0.03562684f, 0.01852588f, 0.02277848f, 0.00506441f, 0.02882739f, -0.02189122f, 
    0.02009593f, -0.01092677f, 0.01217928f, 0.01420690f, -0.03127086f, 0.00299213f, -0.04032320f, -0.02639971f, 
    -0.00617284f, -0.02265162f, 0.02507088f, -0.00557307f, -0.01564953f, -0.00013921f, 0.00015183f, -0.00534531f, 
    0.02346225f, -0.04060664f, -0.03672948f, -0.01492173f, -0.00194589f, -0.00246220f, 0.00323541f, -0.03375979f, 
    -0.02761825f, -0.03805208f, 0.02191737f, -0.04196743f, -0.03787778f, -0.00767217f, -0.02398190f, -0.01803372f, 
    0.01001100f, 0.02939215f, -0.01142596f, 0.01611365f, -0.01694579f, 0.01675676f, 0.02098511f, -0.00780802f, 
    0.02827044f, -0.01649810f, -0.02574064f, -0.01525755f, 0.00696258f, -0.03263048f, -0.02588191f, 0.02911577f, 
    0.01199731f, 0.01677293f, 0.01902139f, -0.03969947f, 0.01141842f, -0.01529641f, -0.00418405f, -0.02385234f, 
    -0.00405156f, -0.03002609f, 0.00908242f, 0.00208542f, -0.02744679f, -0.03792470f, -0.03039902f, -0.03282504f, 
    -0.00966271f, -0.01727333f, 0.00271257f, 0.00877128f, 0.00502837f, 0.00139860f, 0.02880883f, 0.02355659f, 
    -0.03885537f, -0.02750587f, 0.00836269f, -0.02953503f, 0.01619717f, -0.02844398f, 0.01347573f, 0.01247658f, 
    -0.04059159f, 0.02705007f, -0.01864964f, 0.00554502f, 0.01122145f, 0.02632943f, -0.03503503f, -0.01946611f, 
    -0.02393272f, -0.01299542f, -0.01751050f, -0.02522390f, 0.01145470f, -0.00691913f, -0.02788555f, -0.02854666f, 
    0.00846456f, 0.02827868f, 0.02427266f, 0.01306549f, 0.02091261f, 0.00436225f, 0.02944132f, -0.00356820f, 
    -0.00050654f, -0.02710768f, -0.03522082f, -0.02378418f, -0.01557289f, 0.03351779f, -0.02357163f, -0.02071622f, 
    -0.02980465f, -0.00741238f, 0.01639961f, -0.01242956f, -0.04054422f, 0.00213263f, 0.00042662f, -0.03072596f, 
    0.02421322f, -0.00726618f, 0.02836455f, 0.01331225f, -0.00130570f, 0.02828533f, 0.00939048f, 0.00939008f, 
    -0.00373624f, 0.01629002f, -0.01371715f, 0.01404595f, 0.01712651f, -0.01247518f, -0.01658412f, -0.02571377f, 
    0.00094124f, -0.01582475f, -0.03505066f, -0.01833081f, 0.00077255f, -0.02335448f, -0.03796845f, 0.01320143f, 
    -0.00355110f, 0.00308538f, -0.00177880f, -0.04002624f, -0.03647934f, -0.01487619f, 0.02923679f, -0.02809750f, 
    0.03195994f, -0.02367613f, -0.01783933f, -0.00890431f, -0.04022575f, -0.00388846f, 0.00510155f, -0.03909419f, 
    0.02569248f, 0.02531741f, -0.03229531f, -0.02859828f, 0.02031078f, 0.02158714f, 0.03276100f, -0.03904577f, 
    -0.00612621f, -0.01655468f, -0.00142454f, -0.00362536f, 0.00703519f, -0.02574074f, -0.01627856f, -0.00087966f, 
    0.01159525f, 0.00428186f, -0.03101853f, -0.03092948f, -0.01970938f, -0.02479915f, -0.02909224f, 0.02518284f, 
    0.02783605f, -0.01168776f, 0.00432131f, 0.02570938f, -0.00597935f, -0.02970967f, -0.02343127f, 0.00693002f, 
    -0.02162637f, 0.03286975f, 0.01407690f, -0.03298087f, -0.00371005f, -0.02533526f, 0.02741505f, 0.02453187f, 
    -0.01209365f, -0.03410998f, 0.00249115f, 0.01735236f, 0.01550465f, 0.02164926f, -0.00570335f, -0.03953271f, 
    -0.00697987f, -0.03495644f, 0.01786299f, 0.01531162f, -0.02441433f, 0.00126262f, -0.03064202f, 0.00317638f, 
    -0.01984284f, -0.00961312f, -0.01467662f, -0.03834700f, 0.00529702f, -0.00232538f, -0.00041329f, -0.03935215f, 
    0.00228867f, -0.02587789f, -0.01778374f, 0.01861444f, 0.01997060f, -0.04014989f, -0.04154398f, 0.01917527f, 
    0.02083952f, -0.00959877f, -0.00515593f, -0.02783646f, -0.02904654f, -0.02992868f, -0.03056758f, -0.01142990f, 
    0.01151881f, -0.00905229f, -0.01601002f, -0.00425082f, -0.04127274f, 0.02583116f, -0.02189497f, -0.01097395f, 
    -0.00465464f, -0.02323007f, 0.03390740f, 0.02595641f, -0.01062214f, -0.02342547f, 0.01192696f, -0.01035798f, 
    -0.03901265f, 0.01059831f, 0.01615557f, -0.02509432f, -0.03354648f, -0.03174911f, 0.02248520f, 0.02233863f, 
    -0.02918983f, -0.02290203f, -0.02541126f, -0.00691593f, -0.00486617f, -0.01809857f, -0.00952008f, 0.01662443f, 
    -0.02260213f, 0.02603848f, -0.01117158f, -0.00122580f, -0.03175966f, 0.02730147f, -0.03646735f, -0.01731633f, 
    -0.01209394f, 0.02992024f, 0.02085454f, -0.01243803f, -0.01100749f, 0.00985642f, -0.01493547f, -0.04073273f, 
    0.01961427f, -0.03783589f, 0.03356298f, 0.02603739f, -0.01525252f, 0.00665107f, -0.03523935f, 0.01644331f, 
    0.01205766f, -0.03351604f, 0.01193214f, -0.00757159f, -0.03552873f, -0.01400384f, -0.00847711f, 0.01657456f, 
    0.00285106f, 0.01864402f, -0.01178559f, 0.02492568f, -0.01727016f, -0.00520720f, -0.01673899f, 0.01576036f, 
    -0.03554245f, -0.01211039f, -0.02515546f, -0.03336579f, -0.03503032f, -0.00895702f, 0.00784536f, 0.02289578f, 
    -0.00740466f, -0.03585992f, 0.02113197f, 0.02176895f, 0.02467393f, 0.01382062f, -0.03331278f, -0.00916614f, 
    0.00748042f, 0.02388974f, 0.01944433f, -0.03697256f, -0.02312564f, 0.00678441f, -0.01841485f, 0.03595965f, 
    -0.00452045f, -0.02915698f, 0.02318874f, 0.01424720f, -0.03576613f, -0.01550756f, 0.03071667f, -0.03883130f, 
    -0.03853496f, 0.01406420f, 0.00967196f, -0.00818457f, -0.03424772f, -0.03263575f, 0.01493039f, -0.02870491f, 
    -0.01397897f, -0.03259237f, -0.03604070f, -0.02928807f, 0.00206434f, 0.00517949f, -0.02109432f, -0.02392813f, 
    -0.04534618f, 0.00442947f, 0.03128568f, -0.00082345f, -0.01410883f, 0.01566036f, -0.02642629f, -0.02848381f, 
    -0.02205954f, -0.00349273f, -0.00396104f, -0.02271276f, -0.01380368f, 0.00030543f, 0.00244310f, 0.01062191f, 
    -0.00704231f, 0.03023683f, -0.00938974f, 0.00809541f, -0.01284337f, -0.00981968f, -0.02467201f, 0.01963108f, 
    0.02516618f, -0.03645896f, 0.01765046f, 0.00616255f, 0.00743865f, 0.00712780f, -0.02263905f, -0.02477575f, 
    -0.01196347f, -0.01843942f, 0.01704912f, -0.01025373f, 0.00609802f, -0.02134684f, -0.01028025f, -0.04198116f, 
    -0.01226773f, 0.03116176f, 0.00590236f, 0.02129502f, 0.01110821f, 0.01576087f, -0.03013911f, -0.02051380f, 
    0.00160739f, -0.00599620f, -0.00270556f, -0.01491439f, 0.03161755f, -0.00914230f, 0.01391974f, -0.02079315f, 
    -0.03697934f, -0.01778112f, 0.00344656f, -0.02285198f, -0.03369986f, 0.02127028f, 0.01497032f, 0.02284068f, 
    -0.04612976f, 0.02566627f, 0.01514419f, -0.02489257f, -0.00122404f, 0.03124713f, -0.00467218f, -0.04145875f, 
    -0.03618184f, -0.01005894f, -0.01173703f, -0.01808499f, -0.00984200f, -0.02902092f, -0.01328505f, -0.02596217f, 
    -0.01198793f, -0.04560613f, 0.00625708f, -0.02805108f, -0.03210318f, -0.02639098f, 0.00157872f, 0.02506819f, 
    0.00309783f, 0.00224992f, -0.00279852f, 0.01917914f, -0.01061320f, 0.00108145f, 0.00548190f, 0.02055096f, 
    -0.02518107f, -0.00056057f, -0.02600309f, -0.01792245f, 0.00958028f, -0.02670013f, -0.01580929f, 0.03832131f, 
    -0.03217150f, 0.02712972f, 0.02172813f, -0.01703993f, -0.03931446f, -0.01911006f, 0.01920003f, -0.01138806f, 
    -0.03399561f, -0.03492082f, 0.03508223f, -0.00505426f, 0.01449663f, 0.00999347f, -0.02624564f, 0.02451845f, 
    -0.03981310f, -0.02054224f, 0.02592012f, -0.02651103f, 0.03701499f, -0.02415236f, -0.00300293f, -0.02561619f, 
    -0.00609626f, -0.03271068f, 0.01565322f, -0.02016521f, 0.02707127f, -0.00441884f, 0.00338470f, -0.03933876f, 
    -0.03853905f, -0.01731718f, 0.00673503f, -0.02968287f, -0.00333900f, 0.02455332f, -0.00453944f, -0.03538027f, 
    0.02027524f, -0.04073159f, 0.02467110f, -0.01297676f, -0.01625511f, -0.00898798f, -0.03487455f, -0.02954181f, 
    0.01186366f, 0.03104483f, -0.04011447f, 0.02881863f, 0.02172077f, -0.01970982f, 0.00508961f, 0.03462823f, 
    -0.02030249f, -0.03002873f, -0.00302645f, -0.01599136f, -0.00571346f, -0.02286415f, -0.00921788f, 0.03867181f, 
    -0.02906463f, -0.00001317f, -0.04168443f, 0.01261134f, -0.00097294f, -0.02989481f, 0.01572015f, -0.03308777f, 
    0.01661286f, -0.00402430f, -0.00387862f, -0.01026342f, -0.01817059f, -0.01051895f, 0.02544658f, 0.01514992f, 
    0.03078611f, -0.02530638f, -0.01632259f, 0.02353355f, 0.02284851f, -0.01747102f, 0.01703775f, -0.00704632f, 
    -0.01659191f, -0.01038182f, 0.01858550f, 0.01648342f, 0.02265657f, 0.00794036f, -0.03088560f, -0.03541083f, 
    -0.01075641f, -0.02080619f, 0.02196066f, -0.00072541f, 0.02451315f, -0.03057251f, -0.01699468f, 0.00727893f, 
    -0.02733889f, -0.01061932f, -0.00680664f, -0.00882013f, -0.02000062f, 0.02090140f, 0.00400094f, -0.02251592f, 
    0.04084784f, -0.03407773f, -0.00852274f, 0.02240473f, 0.01592381f, 0.03162342f, -0.03616752f, 0.01353757f, 
    -0.03258888f, -0.01879885f, 0.01006942f, -0.00945874f, 0.00121393f, 0.01375937f, -0.02275826f, 0.01196877f, 
    0.02532592f, -0.02913577f, 0.01962189f, 0.01299052f, 0.00437778f, 0.02212942f, -0.01018047f, -0.02397503f, 
    -0.02856019f, 0.01226377f, -0.03150351f, 0.01050038f, -0.03121373f, -0.04043776f, -0.01814812f, -0.01070977f, 
    0.02682057f, -0.01816099f, -0.02673336f, -0.04586656f, 0.00036285f, -0.02409286f, -0.01296950f, -0.01081252f, 
    -0.04262812f, -0.03527927f, 0.02000071f, -0.01584580f, 0.00840043f, -0.02123138f, 0.01400441f, -0.03682155f, 
    0.00385217f, 0.00250301f, 0.03249609f, 0.02922565f, 0.00690973f, -0.02544982f, -0.03260630f, -0.00056570f, 
    -0.00569213f, 0.00074145f, 0.00625284f, 0.02309502f, 0.02365730f, -0.00919902f, 0.00522687f, 0.02520779f, 
    0.03569418f, -0.01138243f, -0.01194238f, 0.02520018f, -0.02188498f, -0.02426763f, 0.00752590f, -0.01216022f, 
    0.00406224f, -0.02478016f, -0.03574438f, 0.00215970f, 0.00619426f, 0.02225343f, 0.02469691f, -0.02887146f, 
    0.01582474f, -0.03754593f, 0.00854687f, -0.01888597f, -0.02699102f, -0.00500398f, -0.01778261f, 0.01895496f, 
    -0.01155434f, -0.03486586f, -0.02375201f, -0.00384578f, 0.00569860f, 0.02728662f, -0.02884309f, 0.02657364f, 
    -0.02690811f, -0.02729346f, -0.02027204f, 0.00924629f, -0.01713215f, -0.01940207f, 0.00235941f, -0.02935771f, 
    0.01236792f, -0.04162023f, -0.00333943f, 0.02012803f, 0.01771012f, 0.03692950f, 0.01531911f, -0.00883282f, 
    -0.02269569f, -0.00113783f, -0.04168045f, -0.03075332f, 0.01370184f, 0.02456959f, 0.01540900f, 0.01184590f, 
    0.01680990f, -0.02757941f, -0.00147431f, 0.01095825f, -0.02602899f, 0.02095643f, -0.01945122f, 0.01024463f, 
    -0.02729395f, 0.01406789f, -0.02911005f, 0.00244197f, -0.02907438f, 0.02680511f, -0.04629147f, -0.00847461f, 
    0.04103479f, 0.00342667f, 0.03949448f, -0.02556233f, -0.01399229f, -0.02756429f, 0.02478529f, -0.03605238f, 
    -0.03882296f, 0.02272219f, 0.01898298f, -0.02004681f, -0.00132810f, 0.01896467f, 0.02886450f, -0.01979827f, 
    -0.01148354f, 0.01015937f, 0.02071012f, -0.02700468f, 0.01446535f, -0.00848064f, -0.00225391f, -0.03597682f, 
    -0.04066903f, -0.03674585f, 0.01603841f, 0.01561458f, 0.01246479f, -0.00331158f, 0.02736015f, -0.02971715f, 
    0.00364392f, 0.00488423f, -0.01824550f, -0.00050154f, 0.01575161f, 0.03179242f, 0.03926164f, -0.02064553f, 
    -0.01218197f, 0.00178740f, 0.00944853f, 0.02293303f, 0.03321489f, -0.02809422f, -0.02289557f, 0.03000300f, 
    -0.00749747f, 0.01724626f, 0.00232621f, 0.00678531f, -0.02832284f, 0.01461009f, 0.01610353f, -0.00363242f, 
    -0.03131795f, 0.01296297f, 0.02962584f, 0.02163569f, -0.02026143f, 0.00153084f, 0.00909430f, -0.00845024f, 
    -0.01323196f, 0.03823386f, 0.02523299f, 0.01992674f, 0.01194226f, -0.01557705f, -0.01292899f, 0.01968744f, 
    0.01311452f, 0.00424474f, 0.01520425f, -0.04137892f, -0.03305361f, -0.01201437f, -0.02082337f, 0.00296443f, 
    -0.00464150f, -0.00906278f, -0.01668407f, 0.03042756f, -0.03883607f, 0.02793179f, 0.00357947f, 0.02202565f, 
    -0.01764454f, 0.01495712f, -0.02345167f, -0.01307928f, -0.02435070f, -0.03514756f, -0.03599963f, 0.00273121f, 
    0.02858077f, -0.00785548f, 0.01755641f, 0.03054645f, -0.01480932f, -0.00622017f, -0.01393685f, 0.00352831f, 
    -0.03066569f, 0.01182786f, 0.02499778f, 0.02931024f, -0.01604058f, 0.01852737f, 0.00897537f, 0.03541452f, 
    -0.01372912f, 0.00186863f, -0.01773849f, -0.02063124f, -0.03518238f, -0.00728402f, -0.02707351f, 0.00477593f, 
    0.01422431f, -0.02754224f, -0.01441500f, -0.01801394f, 0.01725057f, -0.02804053f, 0.02635695f, 0.01465203f, 
    0.01071251f, 0.00232200f, 0.01230228f, 0.02298688f, 0.02009367f, -0.01112721f, -0.02385487f, -0.02880919f, 
    0.00281947f, 0.02178690f, 0.01985799f, 0.02194005f, 0.00591966f, -0.01716492f, 0.03222590f, -0.00068004f, 
    -0.00972574f, 0.02601671f, -0.02935535f, 0.02782124f, -0.01231382f, -0.02303076f, -0.00496487f, -0.02696411f, 
    0.00020082f, -0.01795734f, -0.00487201f, -0.01275491f, -0.00022365f, 0.02561589f, 0.01758976f, -0.02315489f, 
    0.01773812f, 0.00158131f, -0.03451885f, -0.01426813f, -0.00555782f, -0.00674176f, -0.02692890f, -0.00295694f, 
    0.01953281f, -0.00331276f, -0.03088355f, -0.01698990f, -0.01165462f, -0.01826313f, 0.00420550f, -0.00744723f, 
    -0.02331082f, -0.00230560f, 0.02865023f, -0.00106514f, -0.03493575f, 0.00787608f, 0.02940730f, -0.02033905f, 
    -0.00807178f, 0.02759681f, -0.00363325f, 0.01870312f, -0.00229231f, 0.01222820f, 0.00357829f, -0.00918714f, 
    0.01475424f, 0.02464580f, 0.00028703f, 0.03454012f, -0.01747276f, 0.00086406f, -0.00991475f, 0.01800509f, 
    0.01613749f, 0.02526804f, -0.01900966f, 0.02341812f, 0.02122637f, -0.02929435f, -0.00400035f, -0.03614760f, 
    -0.02280420f, -0.04093894f, -0.03540218f, 0.00687420f, -0.03236361f, -0.03070090f, -0.01228847f, 0.02482703f, 
    -0.03542817f, 0.00128601f, 0.02284561f, 0.01414807f, -0.02328121f, 0.03206176f, 0.02229925f, 0.03231120f, 
    0.00687004f, 0.01218199f, -0.03576618f, 0.02763554f, -0.01881086f, -0.03098314f, -0.02258041f, 0.00640392f, 
    0.00794019f, 0.01136646f, 0.01532994f, -0.01773399f, 0.00054680f, 0.00268895f, 0.00764367f, -0.01087077f, 
    -0.03582844f, 0.00488858f, -0.00320598f, 0.00103561f, -0.01851851f, 0.03033466f, 0.02994468f, -0.02955707f, 
    -0.00775187f, 0.00673968f, -0.02231282f, -0.02611495f, 0.02255621f, -0.02956692f, 0.02446986f, 0.02174575f, 
    0.01643412f, 0.01333246f, -0.00784687f, -0.03738417f, 0.00018342f, 0.00863603f, 0.01572361f, -0.03973233f, 
    -0.01659789f, -0.00381027f, 0.03782446f, 0.01053024f, -0.03056282f, 0.00642526f, -0.00161036f, -0.02733867f, 
    0.00805386f, 0.02759047f, 0.02991584f, 0.01558663f, -0.04100860f, -0.01149573f, 0.01246294f, -0.00203974f, 
    -0.03785728f, 0.01393889f, -0.00139809f, -0.00238065f, 0.03931040f, 0.01544759f, -0.02661083f, 0.01008788f, 
    -0.09963141f, -0.09875757f, -0.09583974f, -0.04991429f, -0.04536844f, 0.03258098f, -0.11026879f, -0.01357914f, 
    -0.16959469f, -0.00985003f, -0.00590592f, -0.21505174f, -0.18558732f, -0.03240830f, -0.01353487f, -0.31439421f, 
    0.12715149f, -0.01762148f, 0.10113064f, 0.02032010f, 0.07383721f, 0.12205058f, 0.03236217f, 0.06072689f, 
    0.15608111f, 0.02675509f, 0.46478868f, -0.00920787f, 0.07978168f, 0.16334777f, 0.09842182f, 0.19155616f, 
    0.24752915f, -0.15951616f, 0.08428057f, 0.14745224f, -0.10054868f, -0.20317112f, -0.24275708f, -0.25904503f, 
    -0.08083351f, -0.13457650f, 0.03351195f, 0.13495837f, 0.12489451f, 0.11608175f, -0.02045277f, -0.01075865f, 
    -0.09815552f, -0.08988741f, 0.02454954f, 0.05800974f, 0.09241416f, -0.09218460f, 0.11496504f, -0.00215870f, 
    0.14763294f, 0.10416396f, -0.07655094f, 0.23603903f, -0.14578940f, 0.13220397f, 0.28759515f, 0.27152765f, 
    -0.05628461f, -0.07487141f, -0.03156456f, 0.14883938f, -0.00631958f, 0.11140263f, 0.06868086f, -0.02384013f, 
    0.18684718f, -0.13202155f, 0.01615164f, -0.14810266f, -0.02168861f, 0.42519307f, -0.20511362f, -0.04147815f, 
    0.07651014f, -0.10499339f, 0.07202957f, -0.06233377f, -0.20863602f, 0.16358776f, 0.04465898f, -0.14637825f, 
    -0.27521947f, -0.19594933f, 0.11014708f, 0.18054803f, 0.03490125f, 0.20266297f, 0.04414153f, -0.04443352f, 
    -0.15741980f, -0.09048574f, 0.24310935f, 0.40466365f, 0.02131354f, -0.28211841f, 0.00578811f, 0.11203745f, 
    0.32103732f, 0.07877327f, 0.27247593f, -0.18739139f, 0.09278733f, -0.16865909f, -0.00704912f, -0.21424653f, 
    0.05556516f, -0.09687188f, 0.14186160f, -0.12530981f, -0.08818303f, 0.04868283f, 0.14448826f, 0.28872338f, 
    0.13607313f, 0.24565910f, -0.26167199f, -0.13679829f, 0.07707619f, 0.18286286f, -0.01459217f, -0.03250984f, 
    0.04108308f, 0.08588922f, -0.08693966f, 0.31690812f, -0.19662614f, -0.00984905f, 0.11017177f, -0.03963222f, 
    -0.12608495f, -0.17473441f, -0.14844458f, -0.13387102f, 0.09044620f, 0.11610834f, 0.14708740f, 0.12298714f, 
    -0.14565589f, -0.12406402f, -0.11508664f, 0.09295949f, -0.01714469f, 0.08583078f, -0.07581784f, -0.01870700f, 
    -0.05509495f, 0.09783526f, 0.00767836f, -0.04781481f, -0.09472803f, 0.09422420f, -0.18623963f, 0.00110713f, 
    0.15141267f, -0.13429482f, 0.04614848f, -0.14230835f, 0.07606889f, -0.05509515f, -0.05466601f, 0.10293405f, 
    0.26639664f, -0.24355315f, 0.09436461f, 0.00825572f, -0.02804387f, 0.01508166f, 0.26209658f, -0.05176232f, 
    0.11912814f, 0.00376011f, 0.15563528f, 0.12348194f, -0.02868035f, -0.04224993f, -0.00750605f, 0.06683170f, 
    0.00800404f, 0.02745659f, 0.03007031f, 0.17130424f, -0.11556302f, -0.06101554f, 0.13643669f, -0.26945424f, 
    0.01209972f, -0.03249608f, -0.39051470f, -0.48131502f, 0.02759194f, -0.05663418f, 0.03119999f, 0.14074594f, 
    0.10260201f, 0.14504437f, -0.21955404f, 0.24155205f, -0.20305498f, 0.00471160f, -0.23031288f, 0.19969171f, 
    0.00936997f, -0.01702132f, -0.05846900f, -0.04127831f, 0.39221346f, 0.17773919f, 0.26816007f, 0.29740876f, 
    0.02950062f, -0.15911436f, 0.20842756f, 0.16671185f, 0.03644350f, 0.07230014f, 0.05416137f, 0.06410588f, 
    0.00985577f, 0.04421059f, 0.25080585f, -0.09133975f, 0.01615074f, 0.09386627f, -0.15095651f, -0.07150491f, 
    0.12754466f, -0.01413474f, -0.07878861f, -0.03370357f, -0.09314282f, 0.01383139f, 0.04274100f, 0.02232948f, 
    -0.02607338f, 0.10765087f, 0.11167382f, -0.03515290f, -0.03470640f, -0.07237902f, -0.00339339f, -0.02890610f, 
    0.05913697f, 0.09371475f, 0.04722473f, -0.02949544f, 0.10154621f, -0.19106291f, -0.10928778f, 0.15766771f, 
    0.13479179f, -0.04915907f, -0.08043326f, 0.03113017f, 0.01887089f, 0.26204270f, -0.05689030f, -0.11758363f, 
    0.21974821f, -0.07641710f, -0.07320099f, -0.01500268f, 0.26152274f, -0.02416495f, 0.06994740f, 0.10344344f, 
    0.04980195f, -0.03530140f, 0.16088304f, -0.03267029f, -0.23104179f, -0.13697918f, -0.05166129f, 0.23509651f, 
    0.05384056f, 0.07112121f, 0.09213749f, 0.09304536f, 0.31996945f, -0.00748807f, 0.02946143f, 0.17188798f, 
    -0.12230659f, -0.25071701f, 0.07276323f, -0.27741548f, 0.19833429f, 0.09891521f, 0.02100875f, 0.10442153f, 
    -0.00354226f, -0.04125443f, 0.10083779f, -0.01176761f, 0.04792300f, 0.23199899f, 0.18649763f, 0.16411658f, 
    0.15157194f, 0.12814116f, 0.06497773f, 0.12606044f, 0.15092787f, -0.01581234f, -0.09503089f, 0.06495460f, 
    0.00148739f, -0.13452029f, -0.11857837f, 0.00877938f, 0.00529494f, -0.03532625f, -0.00006466f, 0.02921871f, 
    -0.00930279f, -0.01043391f, -0.02039995f, 0.21529037f, -0.06330413f, 0.05699320f, 0.04548756f, -0.06949421f, 
    -0.08109348f, 0.07550971f, 0.10281420f, 0.07518909f, 0.04272465f, -0.03539528f, 0.07717005f, 0.00040017f, 
    -0.08856788f, 0.09684827f, 0.09221822f, 0.06224519f, 0.08250806f, 0.01303186f, 0.21248546f, 0.09891790f, 
    0.15877658f, -0.00918135f, -0.02096894f, -0.13215199f, 0.01781728f, -0.16828728f, -0.06114713f, 0.02902116f, 
    0.09816736f, 0.11823800f, -0.07112666f, 0.04623074f, 0.12938659f, -0.05031605f, 0.05062792f, -0.04411967f, 
    -0.09028988f, -0.06169723f, -0.01404898f, -0.11621579f, 0.10972178f, -0.08592777f, 0.06450479f, 0.10198115f, 
    0.24938148f, 0.35702091f, -0.18640271f, 0.12528788f, 0.32700196f, -0.25446895f, -0.51821631f, 0.07903815f, 
    0.17556250f, 0.16498095f, -0.01414579f, -0.05731431f, 0.10168558f, 0.06242956f, -0.11619566f, 0.35386276f, 
    -0.20216355f, 0.12499966f, 0.52380311f, 0.21789187f, -0.05484094f, -0.04518423f, -0.03248451f, 0.02656198f, 
    0.07247166f, -0.02457529f, 0.20888208f, 0.07446253f, -0.03143178f, -0.06914548f, -0.11397068f, -0.01836398f, 
    -0.00373518f, -0.01141151f, -0.07874411f, -0.04017956f, -0.04258986f, -0.05458383f, -0.07789475f, -0.07253707f, 
    0.05816740f, -0.05310681f, -0.07008670f, 0.00720758f, -0.06505581f, -0.03888224f, -0.06250220f, -0.05325419f, 
    -0.25878266f, 0.02286732f, 0.29082847f, -0.10070302f, -0.03306476f, 0.16089195f, 0.04896379f, -0.03035006f, 
    -0.19026159f, 0.23215538f, 0.05242918f, 0.08345286f, 0.06409786f, 0.08891766f, -0.04886349f, 0.04410286f, 
    -0.11170000f, -0.03876326f, 0.05669922f, 0.09506706f, 0.16557518f, 0.05334973f, -0.18844374f, 0.12429949f, 
    -0.09450995f, -0.02268879f, 0.02015674f, -0.04586046f, 0.09606438f, -0.36718667f, -0.17115629f, 0.23840481f, 
    0.02958532f, 0.12265458f, -0.06798010f, -0.12633306f, 0.12475359f, -0.28583303f, 0.35595056f, 0.07296512f, 
    0.11735671f, 0.17617938f, 0.01041501f, -0.09330586f, 0.12654142f, 0.08797634f, 0.08474030f, 0.07747512f, 
    0.02857691f, 0.00713539f, -0.02891420f, 0.13245408f, 0.21479753f, -0.04577294f, -0.17314410f, 0.03176316f, 
    0.05730694f, -0.07858928f, -0.04169372f, 0.03725092f, 0.03512315f, -0.03240096f, 0.06670216f, -0.12017234f, 
    0.01449305f, -0.10498720f, -0.21658197f, -0.10204632f, 0.01026383f, -0.05452751f, -0.04631553f, -0.06563695f, 
    -0.23441215f, -0.10662173f, 0.23930220f, -0.07319397f, 0.22730950f, 0.29264978f, 0.20612530f, 0.40412089f, 
    -0.07842030f, -0.12513319f, -0.10562712f, -0.20391487f, 0.02092439f, 0.11252709f, 0.15076600f, 0.11754747f, 
    -0.04066735f, 0.02137348f, 0.06535339f, -0.22680166f, -0.16972877f, -0.06898256f, 0.15227509f, 0.20181774f, 
    0.20373507f, 0.19022192f, 0.04062163f, -0.09871189f, 0.03702494f, 0.10035516f, 0.52993077f, -0.15380026f, 
    -0.08466474f, 0.01213401f, 0.04188089f, 0.00779381f, -0.01771260f, 0.02000154f, 0.28345799f, -0.01923490f, 
    -0.19052872f, -0.14135478f, -0.02315715f, -0.02302288f, 0.02313812f, 0.01052679f, -0.11153476f, -0.01379702f, 
    0.23088780f, 0.16621652f, 0.26417565f, 0.28411847f, 0.25166267f, 0.28452250f, 0.27467501f, -0.11160800f, 
    -0.11344510f, 0.00132593f, 0.27390578f, -0.23783270f, 0.15978780f, 0.02633102f, 0.05557979f, 0.19740000f, 
    0.07128519f, 0.29565498f, 0.08011878f, 0.17678189f, 0.06319670f, 0.03052366f, -0.00952415f, -0.01788012f, 
    0.08239480f, 0.29788822f, -0.00680321f, -0.11688501f, -0.01421200f, -0.01181396f, 0.04338016f, -0.21008603f, 
    -0.01167785f, 0.09223673f, -0.05824361f, 0.04392068f, -0.08250111f, 0.09247836f, 0.06852315f, 0.06511408f, 
    -0.10879584f, 0.00241630f, -0.09209055f, -0.09986323f, 0.00664557f, 0.00224255f, -0.03381389f, -0.03538888f, 
    0.26469287f, 0.35345903f, 0.30610001f, 0.28850013f, -0.13841882f, -0.18660779f, -0.02194064f, 0.06289700f, 
    0.04098703f, -0.09519983f, -0.07869665f, -0.04586914f, -0.08761976f, 0.08515764f, 0.04837992f, -0.07781824f, 
    -0.00928135f, -0.38174403f, -0.19655304f, 0.24502864f, -0.34189522f, -0.45019171f, 0.04440957f, 0.41516986f, 
    0.20592554f, 0.23543361f, 0.00414567f, 0.10741236f, -0.03529749f, -0.08431691f, -0.02296144f, -0.07364804f, 
    -0.06804105f, 0.11035344f, 0.01466119f, -0.09430500f, 0.01552270f, 0.07332060f, -0.04427253f, -0.11439164f, 
    0.00755902f, -0.13718413f, -0.16943826f, -0.00905220f, 0.22294721f, -0.01089952f, 0.00662767f, -0.01904623f, 
    0.00008057f, -0.07875143f, 0.00038630f, 0.09679689f, -0.11547117f, -0.01266536f, 0.10657731f, -0.05385691f, 
    -0.09380762f, 0.06839808f, -0.10050509f, -0.09133346f, -0.05232558f, -0.04137841f, 0.00120884f, -0.00330362f, 
    -0.23622015f, -0.02452374f, -0.06806558f, -0.07591366f, -0.02702910f, 0.34817889f, 0.08849756f, 0.11110087f, 
    0.18897207f, 0.00812165f, 0.18524460f, 0.11802452f, 0.04322991f, -0.02128252f, -0.08620902f, -0.11365242f, 
    0.06227037f, -0.19906056f, 0.03000666f, 0.04986958f, 0.05558596f, -0.11290940f, -0.09071144f, 0.06955514f, 
    0.05491314f, 0.01189986f, 0.20921388f, -0.15620340f, -0.00712381f, 0.25886387f, 0.15951215f, -0.17882515f, 
    -0.11668189f, 0.15201697f, 0.20121858f, 0.15256730f, -0.03568576f, -0.08371426f, -0.00660342f, -0.10495129f, 
    -0.11134169f, 0.03685411f, 0.03088908f, -0.02558308f, -0.28138742f, -0.00507428f, -0.11633947f, -0.13633713f, 
    -0.04224472f, 0.09733074f, 0.04599591f, -0.26226351f, -0.06871745f, 0.06683569f, 0.12100950f, -0.09340225f, 
    0.03671934f, 0.03157515f, -0.04594877f, 0.04578850f, 0.14635828f, -0.16172278f, 0.04820308f, -0.10903592f, 
    0.08339949f, 0.21663442f, -0.07675470f, -0.16402380f, 0.01325023f, -0.00183110f, 0.01053165f, 0.00720307f, 
    -0.09520850f, -0.03394651f, 0.21101899f, -0.07184002f, 0.18543752f, 0.03847389f, 0.20986979f, 0.17453925f, 
    0.02792294f, 0.01448539f, -0.00786650f, -0.12330360f, -0.06366536f, -0.06356069f, 0.08951061f, -0.28111520f, 
    0.09496513f, 0.09536444f, -0.00546805f, 0.02371152f, 0.06298200f, 0.06280980f, 0.08944926f, 0.15416998f, 
    -0.12524371f, 0.24575192f, 0.27604961f, 0.15587497f, -0.10534520f, -0.07026585f, -0.11512451f, 0.06639113f, 
    0.10575889f, 0.09996359f, -0.00345149f, 0.06247802f, 0.09410515f, 0.00834488f, 0.09016393f, -0.14456601f, 
    -0.30991071f, 0.27126262f, 0.13127615f, -0.04995593f, 0.12039348f, -0.16219264f, 0.02485207f, 0.02597879f, 
    0.20989576f, 0.15130091f, 0.04843542f, 0.09498716f, 0.04179685f, -0.10552938f, -0.04194717f, -0.03867739f, 
    0.01308785f, -0.04024201f, 0.02301505f, -0.02784446f, 0.16004661f, -0.20516756f, -0.05654663f, 0.02655033f, 
    0.01579589f, 0.03047722f, 0.15106818f, 0.00623064f, -0.04601415f, -0.04810363f, -0.03276759f, 0.08195536f, 
    0.16810222f, -0.23224264f, 0.11188411f, -0.07959990f, 0.05610024f, 0.03710645f, 0.15068491f, 0.07687658f, 
    -0.01349611f, 0.00318881f, -0.01463597f, -0.08787943f, 0.10253146f, -0.04012605f, 0.27672073f, 0.04607284f, 
    0.01817641f, 0.07887983f, -0.07401029f, 0.10595126f, 0.03321407f, -0.05344696f, 0.05184346f, -0.07213888f, 
    -0.07711751f, 0.11799122f, -0.02062101f, 0.06320458f, 0.06571733f, 0.08459291f, 0.10722774f, 0.05184329f, 
    0.01480958f, 0.22310707f, 0.05702488f, 0.19503742f, -0.36346412f, -0.10379953f, -0.14392839f, -0.05094511f, 
    0.04187754f, 0.09216433f, 0.20717421f, 0.03804540f, 0.03245180f, 0.09650383f, 0.03643471f, -0.11847375f, 
    0.31297612f, -0.01056413f, 0.13847996f, 0.09062475f, 0.18018496f, 0.11241145f, 0.11258832f, 0.00730934f, 
    0.04923496f, 0.14304012f, 0.24049650f, -0.17109105f, -0.15066990f, -0.05749149f, 0.13177176f, 0.05814371f, 
    0.07178019f, -0.02584473f, -0.01794190f, -0.15516312f, -0.00251865f, 0.03701793f, -0.01489854f, -0.00431456f, 
    -0.12561648f, -0.07563044f, 0.02537470f, -0.13834278f, 0.04034855f, -0.08391403f, -0.01024633f, 0.17997308f, 
    0.04784428f, -0.08277732f, -0.08941229f, -0.09609966f, 0.21561636f, 0.29164562f, 0.19560134f, 0.06087384f, 
    -0.03734539f, 0.05074419f, 0.02872895f, 0.00024789f, 0.18325344f, 0.02341551f, 0.02595261f, 0.03825662f, 
    0.16812062f, -0.18284942f, 0.13143755f, 0.08399656f, -0.14361636f, 0.20078160f, -0.02822915f, 0.02776576f, 
    -0.09191811f, -0.02758906f, 0.11050616f, 0.03898519f, -0.05486111f, -0.08806840f, 0.04608152f, -0.04084272f, 
    0.03223199f, -0.21736169f, -0.13670129f, -0.04588204f, 0.02775867f, -0.04146390f, 0.03358994f, 0.02307818f, 
    0.14488827f, 0.23076066f, 0.16862358f, 0.19939937f, -0.07829168f, -0.08633681f, -0.10619675f, -0.04412356f, 
    -0.05086178f, -0.03249918f, 0.08179270f, 0.05210032f, 0.10999586f, 0.07125095f, 0.02721214f, 0.07697303f, 
    -0.01984464f, 0.16256109f, 0.04072957f, -0.00755172f, 0.15212424f, 0.11825089f, 0.10927676f, 0.19038045f, 
    0.16257298f, 0.01354393f, -0.09268945f, 0.03344794f, 0.01370558f, 0.01325843f, 0.01400313f, 0.01451038f, 
    0.20651971f, 0.01499379f, 0.10816913f, 0.11884820f, 0.12895662f, 0.03303989f, -0.08668268f, -0.01924055f, 
    -0.04462200f, -0.05828638f, 0.02341259f, 0.10978403f, -0.01176897f, 0.08693348f, -0.25636643f, -0.15446542f, 
    0.10189762f, -0.08180785f, 0.06199710f, -0.09533609f, -0.03871957f, 0.01829201f, 0.04747057f, 0.09073419f, 
    -0.05857183f, -0.11916473f, 0.12820870f, 0.25766456f, 0.19465345f, -0.08413149f, 0.04170640f, 0.03434413f, 
    -0.05972978f, -0.00429558f, 0.06897022f, -0.01308928f, 0.05879875f, 0.09211410f, 0.11527202f, 0.16931202f, 
    -0.11779957f, 0.14980140f, -0.08295013f, -0.17970169f, 0.08601348f, 0.00388410f, 0.03548584f, 0.13117579f, 
    0.07556132f, -0.06396656f, -0.06572758f, -0.12854110f, 0.40426153f, 0.16039138f, 0.13255687f, 0.13941389f, 
    -0.03065330f, 0.04633496f, 0.11939868f, 0.02376576f, -0.04308989f, 0.06207573f, -0.01419067f, 0.02927921f, 
    -0.03235647f, -0.04942441f, -0.00425032f, 0.01176553f, 0.01495580f, -0.03750308f, -0.05351583f, -0.16451007f, 
    -0.06646937f, -0.00591410f, -0.09331219f, 0.10711934f, 0.26037979f, 0.00700907f, 0.33522364f, 0.33478650f, 
    0.04864585f, 0.00812487f, 0.01484937f, 0.00373681f, 0.05605392f, 0.02556215f, 0.13805307f, 0.12846658f, 
    0.39167276f, -0.10383526f, 0.02378467f, 0.03461436f, 0.18256241f, 0.03583808f, 0.10443779f, 0.14661296f, 
    -0.01584328f, 0.10646428f, 0.00279229f, 0.13615116f, -0.30476001f, -0.18106873f, -0.11046719f, -0.14319722f, 
    -0.08519790f, 0.04006116f, 0.03299530f, 0.17026842f, -0.14580029f, 0.00476942f, -0.12088002f, -0.09483754f, 
    0.05660960f, -0.18757918f, 0.13539711f, -0.03528352f, 0.12455823f, 0.17999664f, 0.09042112f, 0.27678666f, 
    -0.10656270f, 0.03090866f, 0.03229508f, -0.07809908f, -0.35905829f, 0.03495670f, 0.11459712f, -0.01722279f, 
    0.15860447f, 0.08079454f, 0.12321499f, -0.02620503f, -0.08104662f, -0.00127526f, -0.00398676f, -0.03959143f, 
    0.20057002f, 0.06982007f, 0.10361937f, 0.22289720f, 0.04301852f, -0.01795082f, 0.09169795f, -0.02706074f, 
    0.13752413f, -0.04097755f, 0.11549760f, 0.15948424f, -0.18284406f, -0.06104601f, -0.06008033f, -0.08420175f, 
    -0.05413889f, 0.10399844f, 0.01878265f, 0.06129214f, 0.01169622f, -0.00310211f, -0.13629967f, -0.03459147f, 
    0.06117375f, -0.13679014f, -0.06325485f, -0.14941512f, -0.05851663f, -0.08527435f, 0.10308597f, 0.05249576f, 
    -0.16910200f, -0.24847987f, -0.04631611f, -0.17185940f, 0.18586557f, 0.22676347f, 0.19625676f, 0.05227540f, 
    0.15533948f, 0.02472466f, 0.03997288f, -0.00809517f, -0.11232667f, 0.05615016f, 0.02922327f, -0.09316009f, 
    0.05917678f, 0.17375328f, 0.13271782f, 0.12863472f, -0.02356953f, -0.05180512f, 0.03128783f, -0.03945122f, 
    0.11647015f, 0.06309555f, 0.05759583f, 0.18809740f, 0.27384827f, -0.13591237f, 0.24285814f, 0.36685479f, 
    -0.13199298f, 0.22559737f, -0.03493176f, 0.15699312f, -0.14421868f, 0.05057276f, 0.06521118f, 0.10310189f, 
    -0.32871911f, -0.19983283f, -0.09362026f, -0.26261693f, -0.06501296f, 0.07201917f, 0.01728152f, 0.07199665f, 
    0.07904831f, 0.11327147f, 0.05038090f, -0.07043396f, 0.18624966f, 0.19905259f, 0.11805861f, 0.11638072f, 
    0.03880838f, -0.00986035f, -0.00472027f, -0.03767176f, -0.08587910f, -0.05725528f, -0.00320565f, -0.03930967f, 
    0.24127758f, 0.12495395f, 0.07644822f, 0.04449154f, -0.07046437f, -0.03325498f, -0.07940423f, -0.03879770f, 
    0.02822188f, -0.28242975f, -0.06160882f, -0.15652412f, -0.00348039f, 0.07885238f, 0.21508850f, -0.00777296f, 
    -0.03309473f, 0.17780928f, 0.00510478f, -0.05504517f, -0.16567622f, 0.16783947f, 0.02783986f, -0.07614791f, 
    -0.14810652f, -0.02189635f, -0.13192935f, -0.15641198f, -0.01193930f, -0.05435225f, 0.00556356f, -0.00845129f, 
    -0.06081081f, 0.07612534f, 0.03146290f, 0.05810431f, 0.01501601f, -0.00501578f, -0.00646913f, 0.19138739f, 
    -0.07883884f, 0.08324062f, -0.00989122f, 0.15693805f, 0.10506027f, 0.04365333f, 0.23602411f, -0.08413773f, 
    0.16093563f, -0.00245291f, -0.02330851f, -0.02012554f, -0.03762458f, 0.10898002f, 0.04319306f, 0.07214659f, 
    0.11711223f, 0.03013517f, -0.13753973f, -0.01491706f, 0.15869240f, 0.24623251f, -0.04603967f, 0.18950681f, 
    0.08822031f, 0.00093640f, -0.02320295f, 0.05247144f, 0.08152294f, 0.01634735f, 0.02480454f, 0.01201667f, 
    0.32692504f, 0.11180924f, 0.12657985f, -0.00046273f, -0.03998104f, -0.06398436f, -0.04685023f, -0.02098934f, 
    -0.08145850f, -0.06038447f, 0.02373062f, -0.00626004f, -0.45756832f, -0.14024875f, -0.15278916f, -0.04103451f, 
    -0.14305894f, 0.08886445f, -0.00471155f, -0.05777271f, -0.01940599f, -0.15966211f, -0.16559295f, -0.19432445f, 
    -0.19650795f, 0.06036078f, 0.00588222f, 0.06351132f, -0.10078149f, -0.04464172f, 0.11525401f, 0.08363957f, 
    -0.03244797f, 0.20936584f, -0.09129985f, -0.04343172f, -0.46377710f, -0.09199778f, -0.18219276f, -0.31086087f, 
    -0.11857165f, -0.01624832f, 0.04432709f, 0.12259988f, 0.05080189f, 0.02097503f, -0.04427819f, -0.04982384f, 
    0.07390738f, -0.00776572f, 0.01854785f, 0.09844431f, 0.03132270f, -0.06698944f, 0.01979306f, -0.07769152f, 
    0.08029221f, 0.09221460f, -0.10667848f, 0.10428639f, 0.17068514f, 0.13921168f, -0.18749267f, 0.08766028f, 
    0.14498043f, -0.04997275f, 0.06168885f, -0.02607240f, 0.07359378f, -0.10631646f, 0.05025893f, -0.03914173f, 
    -0.02839640f, -0.00502587f, 0.00264221f, -0.16240864f, 0.11471917f, 0.10044631f, -0.05386366f, -0.05705037f, 
    -0.01823975f, 0.03269839f, -0.08990067f, -0.05944642f, 0.23985676f, 0.02725852f, 0.06181632f, -0.02212849f, 
    0.02707736f, 0.02213564f, 0.07426658f, 0.05649347f, -0.06768446f, 0.06618796f, 0.04241446f, 0.01253043f, 
    -0.02099814f, -0.04628758f, -0.02984431f, 0.00387328f, -0.10561638f, 0.01885664f, 0.00379368f, -0.08076578f, 
    0.08228677f, 0.08796527f, 0.00984900f, 0.05155321f, -0.07667746f, 0.13567536f, 0.14563464f, 0.05713670f, 
    0.02345053f, 0.02254331f, -0.00377537f, -0.07530437f, 0.13656509f, -0.16044636f, -0.09090436f, 0.36280939f, 
    -0.18823712f, -0.14388789f, 0.08238994f, -0.06271366f, -0.09876599f, -0.12264315f, -0.02012488f, -0.08222959f, 
    -0.02314056f, -0.02493097f, 0.19273753f, 0.17954491f, -0.01449881f, 0.00528754f, -0.11056727f, -0.15675978f, 
    -0.04333311f, 0.00435706f, -0.01157197f, 0.03396029f, -0.03204564f, -0.02115645f, 0.02012957f, -0.28075069f, 
    0.15726565f, 0.09947188f, 0.04798622f, 0.11618817f, 0.07990551f, 0.04553055f, -0.03555370f, -0.04483233f, 
    0.11976340f, -0.00766570f, 0.06104392f, 0.01975235f, -0.23136973f, -0.13413544f, -0.04541508f, -0.11422356f, 
    -0.02890809f, 0.09917859f, -0.01812020f, -0.10423522f, -0.02354849f, 0.06941213f, 0.02882231f, -0.02413464f, 
    0.01635537f, -0.00676212f, -0.02726980f, 0.00655695f, -0.03138653f, 0.07120418f, 0.17978126f, 0.25177187f, 
    0.09586456f, 0.15875219f, -0.03174854f, -0.08649062f, 0.11507149f, -0.01980050f, 0.02688328f, 0.03534865f, 
    0.08014729f, 0.04939481f, -0.14937852f, -0.01111212f, 0.11278524f, 0.01669779f, 0.07282069f, 0.04288709f, 
    0.07133928f, -0.08275578f, 0.03267723f, -0.15134390f, -0.03458178f, 0.09818605f, -0.02089725f, 0.23337160f, 
    -0.11276955f, -0.16108567f, 0.06126837f, -0.03006073f, 0.09131625f, 0.09548283f, 0.01421773f, 0.08499257f, 
    -0.02357367f, -0.00433913f, 0.08220446f, 0.01851939f, 0.06934204f, 0.08566872f, -0.05303632f, -0.09932770f, 
    -0.04502778f, -0.03179614f, 0.07674929f, -0.13810095f, -0.00410850f, 0.03198497f, -0.09073295f, -0.11636666f, 
    0.05688374f, -0.01818685f, 0.09038899f, 0.11736753f, 0.37667358f, 0.07913718f, 0.17543288f, 0.04199471f, 
    0.15983869f, 0.07281946f, 0.13009067f, 0.13814013f, 0.03237924f, 0.05624418f, -0.07545508f, -0.03620192f, 
    -0.27603820f, -0.07101107f, -0.09164191f, -0.17932667f, -0.09729913f, -0.02721588f, 0.25244433f, 0.19604334f, 
    -0.04776514f, 0.01489229f, -0.02921654f, -0.07213768f, -0.03796024f, -0.12339791f, 0.09158880f, -0.13671446f, 
    0.02740182f, 0.03448091f, -0.04280036f, -0.08025374f, 0.03026618f, -0.04081646f, 0.02916750f, 0.01024319f, 
    0.00964784f, 0.07789517f, 0.12938611f, 0.02419848f, 0.00895748f, -0.02888698f, 0.17542604f, -0.05835074f, 
    -0.09234047f, 0.02707701f, -0.02540517f, -0.00367750f, -0.08797095f, -0.07616100f, -0.03773463f, 0.01027390f, 
    0.02814865f, -0.00111148f, 0.00888930f, -0.04973244f, -0.17948695f, -0.01536708f, 0.10398749f, -0.04163526f, 
    0.02849263f, 0.01740590f, -0.01447093f, 0.02499916f, 0.01232504f, -0.01363738f, 0.02165247f, -0.02607581f, 
    0.01831149f, 0.00209496f, -0.00769924f, 0.02574816f, 0.01749048f, 0.01195374f, -0.01045286f, -0.00416463f, 
    0.00072851f, -0.01521585f, -0.03353611f, 0.00035557f, 0.00414369f, 0.01906449f, -0.03904023f, 0.00828112f, 
    0.02709733f, -0.03916226f, -0.00581847f, -0.02635248f, 0.01234776f, -0.02258734f, -0.01982002f, -0.00923716f, 
    -0.03817480f, -0.03278297f, 0.02342325f, -0.01695102f, -0.02932710f, -0.01408258f, 0.03061586f, -0.00775490f, 
    -0.04003728f, 0.00771469f, -0.01893439f, -0.02538475f, -0.00543678f, -0.01127904f, 0.00266313f, 0.00112070f, 
    -0.03446325f, -0.04093347f, -0.00369808f, -0.01091643f, -0.03535827f, -0.03209057f, -0.00143632f, 0.01046648f, 
    0.02104288f, 0.02172970f, -0.02418990f, -0.01356290f, 0.00620724f, 0.02588969f, -0.00786630f, -0.01670045f, 
    -0.03929714f, 0.00182454f, 0.02681936f, -0.03546998f, 0.00493339f, 0.02012162f, -0.03239428f, -0.03407403f, 
    0.00806798f, -0.01475756f, -0.03846406f, -0.02978132f, -0.01812299f, -0.00667308f, -0.04044987f, -0.02735288f, 
    -0.01846283f, 0.01708072f, -0.02412692f, 0.02208363f, 0.00624139f, 0.00957658f, -0.03560582f, 0.00867777f, 
    0.01414112f, -0.01746137f, 0.03073512f, -0.02901529f, -0.03362534f, 0.00014060f, 0.01206623f, -0.02293028f, 
    -0.03728451f, 0.00295592f, -0.01038608f, 0.02607988f, -0.03334886f, 0.01583703f, 0.01979335f, 0.00971291f, 
    0.02004445f, 0.00722750f, 0.02601361f, 0.01914703f, 0.02971306f, 0.02874829f, -0.03338792f, 0.01051493f, 
    -0.01709532f, 0.01851225f, 0.01264115f, -0.00183309f, -0.02927175f, 0.01894341f, 0.02338621f, -0.02880991f, 
    0.02219580f, -0.03562073f, -0.03339805f, 0.01947291f, -0.02883801f, -0.03192243f, 0.01064705f, -0.01964506f, 
    -0.02563237f, -0.02332565f, 0.02855326f, -0.03306044f, -0.03726310f, -0.01432656f, 0.00321007f, -0.00525854f, 
    0.02461439f, -0.02508093f, 0.02170559f, -0.04010326f, -0.02520226f, -0.03567127f, -0.01615928f, 0.02508781f, 
    -0.00244207f, 0.02487449f, 0.00962149f, -0.01579209f, -0.01313851f, -0.01256529f, 0.02064615f, 0.02104863f, 
    0.02079366f, 0.00944681f, -0.01354931f, -0.02895239f, -0.03733230f, -0.04027528f, -0.01657102f, -0.03486491f, 
    0.00675650f, 0.01743355f, 0.02746165f, -0.04100290f, -0.01865727f, -0.02523130f, 0.01762053f, -0.03397961f, 
    -0.00708394f, 0.00208513f, -0.03917453f, -0.01039850f, -0.01725369f, 0.01723244f, -0.02870411f, -0.00244034f, 
    -0.03292238f, -0.01237527f, 0.00360053f, -0.01903373f, -0.03649800f, 0.02946220f, -0.00945663f, -0.00107299f, 
    0.01183785f, 0.00406690f, 0.01164217f, -0.01461866f, -0.01562116f, -0.02187609f, -0.02913797f, -0.03583230f, 
    -0.00716660f, -0.01103560f, -0.00913889f, 0.01349312f, -0.01533980f, 0.01430579f, 0.00351239f, -0.00896989f, 
    -0.02224985f, -0.03661134f, -0.00790612f, 0.00278789f, -0.03288398f, -0.03831631f, -0.03729258f, 0.00823321f, 
    -0.03634563f, -0.02487092f, 0.02658526f, 0.01327973f, -0.03274502f, -0.02191427f, 0.00451317f, -0.02126584f, 
    -0.02701596f, 0.01961913f, 0.01936943f, 0.00315372f, -0.01246841f, -0.00120413f, -0.01024228f, -0.02742243f, 
    0.01141457f, 0.01640670f, -0.01124009f, 0.00533766f, -0.02151346f, 0.02132951f, -0.02879732f, -0.02908651f, 
    -0.02993484f, -0.00736494f, 0.02835551f, -0.00822154f, 0.00356235f, -0.02466368f, 0.01582232f, -0.02843879f, 
    0.01980316f, 0.00506240f, -0.03491689f, -0.01707115f, 0.00252242f, -0.02713869f, 0.01602511f, 0.03045257f, 
    -0.03270930f, -0.00515926f, 0.01948175f, -0.00202109f, 0.00364052f, -0.00131314f, 0.01958650f, -0.02762057f, 
    -0.02872379f, 0.02403366f, 0.00059188f, 0.01394044f, -0.01606695f, -0.01008265f, 0.01490411f, 0.02408907f, 
    -0.04069177f, -0.01441810f, 0.02901577f, -0.02670165f, 0.02090400f, -0.00851353f, -0.02259115f, 0.01850872f, 
    0.00084865f, 0.00038155f, 0.00222024f, 0.02274994f, -0.03386666f, 0.02131631f, -0.02297552f, 0.01190358f, 
    -0.01683152f, 0.02448535f, -0.03515349f, 0.01176503f, -0.01984099f, -0.00105521f, -0.00227852f, 0.02233864f, 
    0.00388245f, -0.03468873f, -0.02043335f, -0.03697855f, 0.00373677f, 0.02890722f, -0.03508287f, -0.01005729f, 
    -0.00155785f, -0.01206068f, -0.04103317f, -0.01887009f, -0.01057177f, -0.03205273f, -0.00035980f, -0.02702190f, 
    -0.01796858f, -0.01412527f, 0.00829900f, 0.00012317f, -0.01223987f, -0.01354012f, 0.00449836f, 0.00340215f, 
    0.01298235f, 0.00593846f, -0.00070093f, 0.02788671f, 0.00026967f, -0.02959998f, 0.02901980f, 0.00452863f, 
    0.01385359f, -0.02706479f, 0.00272204f, -0.01642250f, -0.00896722f, 0.01728861f, 0.00372205f, -0.03175171f, 
    0.03032002f, -0.01746775f, -0.01174893f, -0.02237983f, -0.01799024f, -0.00408389f, -0.03760511f, 0.00985409f, 
    -0.00086980f, -0.02601815f, -0.03768217f, 0.00305260f, -0.01745008f, -0.01887381f, -0.02757599f, -0.03070108f, 
    -0.02229132f, 0.00780153f, -0.00641529f, 0.01916906f, -0.01562514f, 0.01493072f, -0.01551279f, -0.00662539f, 
    -0.00282404f, -0.00751483f, -0.03957697f, 0.01512302f, -0.03627564f, 0.01650198f, -0.02323118f, 0.02204672f, 
    -0.00210575f, -0.00877098f, -0.04011950f, 0.01603239f, -0.03491478f, 0.02997783f, -0.03319503f, 0.01455066f, 
    0.02249537f, -0.02597005f, -0.02279173f, -0.01060637f, -0.01335630f, -0.03529229f, -0.02544023f, 0.00081073f, 
    -0.03252761f, -0.00627741f, -0.03023770f, -0.03202584f, 0.00456051f, -0.00668577f, -0.00601478f, -0.00936817f, 
    -0.00699590f, 0.01233210f, 0.01826880f, -0.03820245f, 0.01251578f, -0.02261239f, 0.00155914f, -0.03364861f, 
    -0.02147283f, 0.01366117f, 0.00363114f, 0.01233236f, 0.02003093f, 0.01840589f, -0.02851111f, 0.01600685f, 
    0.03291598f, -0.00339997f, -0.01874217f, -0.03884860f, -0.01440367f, -0.04039202f, 0.02268601f, -0.01396980f, 
    -0.02576815f, 0.02342509f, 0.02128536f, 0.00571492f, 0.02380496f, -0.03259626f, -0.00755626f, -0.01360031f, 
    0.02422720f, 0.02968002f, 0.00059695f, -0.00128952f, -0.03363745f, -0.00394199f, -0.03620188f, -0.01715318f, 
    0.02413540f, -0.03038774f, -0.03351129f, 0.01312423f, -0.01399459f, 0.00561697f, -0.02298954f, -0.02283702f, 
    -0.02164361f, -0.01556740f, 0.02184859f, -0.00452201f, 0.02877253f, 0.00150005f, 0.01110193f, -0.03581474f, 
    -0.01275564f, 0.00330769f, -0.02020049f, 0.01883461f, 0.01189687f, -0.02998113f, -0.01439195f, 0.02536992f, 
    0.02261965f, -0.00722289f, -0.00451751f, -0.00342413f, -0.02504745f, 0.01132660f, 0.02846557f, 0.01677278f, 
    0.00528681f, -0.00518258f, 0.02689066f, -0.02225931f, -0.03556104f, -0.03952014f, -0.00440476f, 0.02315229f, 
    0.01994923f, -0.01605313f, -0.00115254f, -0.01721186f, 0.00298433f, -0.01825876f, -0.02395979f, -0.00575420f, 
    0.01791776f, -0.02835686f, -0.02866987f, 0.02204238f, 0.02723368f, 0.00860050f, 0.00829629f, 0.01134226f, 
    -0.02699110f, 0.01098275f, -0.00267204f, 0.01148439f, -0.03785547f, -0.02926857f, -0.03035161f, 0.01084449f, 
    0.02686952f, 0.03380466f, -0.03049031f, 0.02750805f, 0.02184011f, -0.03588112f, 0.00899660f, 0.02694563f, 
    -0.02562484f, -0.01020864f, -0.01869018f, -0.02099810f, -0.03144490f, -0.02693695f, -0.03172756f, -0.02402119f, 
    -0.03469394f, -0.03485838f, 0.02427485f, -0.01046517f, -0.01471198f, 0.00489945f, -0.03427362f, -0.01203360f, 
    0.00038729f, 0.02672058f, 0.02988084f, -0.02979612f, 0.00305533f, -0.02278407f, 0.00068230f, 0.01549497f, 
    0.02897871f, -0.03259708f, 0.02381736f, 0.01398710f, 0.02538341f, 0.01963112f, 0.02973877f, -0.03894531f, 
    -0.03957890f, -0.03700114f, -0.00670917f, -0.00384909f, -0.03602800f, 0.00277303f, -0.02317066f, -0.01586263f, 
    0.02495095f, -0.03127632f, -0.02673709f, -0.00705421f, -0.03562967f, -0.03941704f, -0.00309556f, -0.03742401f, 
    -0.00367891f, -0.01653677f, -0.00613788f, -0.00170980f, 0.01098851f, 0.00351804f, -0.01375401f, -0.01677415f, 
    -0.01399674f, -0.00452048f, 0.03009073f, -0.03607396f, 0.00299053f, 0.00526539f, 0.02804305f, -0.03123518f, 
    0.02048017f, 0.00440800f, -0.01075147f, -0.03077171f, -0.00287174f, 0.02437772f, -0.02114827f, -0.02283709f, 
    -0.01095253f, -0.03977311f, 0.00826893f, 0.00482300f, -0.00138878f, -0.01888341f, 0.01622396f, 0.02705727f, 
    -0.03317787f, -0.00156553f, 0.03040830f, -0.01767573f, 0.02054845f, -0.02922342f, -0.03969330f, 0.00889054f, 
    -0.01870357f, 0.01217904f, -0.00827151f, -0.00239163f, 0.00192750f, -0.03725135f, 0.02720990f, -0.01490755f, 
    -0.02733499f, -0.02064689f, -0.00046344f, -0.00251041f, -0.01288859f, -0.00493011f, -0.02223733f, -0.03362555f, 
    0.00983253f, 0.00360207f, 0.02088356f, -0.02346985f, -0.00494560f, -0.00222265f, -0.00284698f, -0.02002168f, 
    0.02859249f, 0.02971302f, 0.00401646f, -0.02387823f, -0.02450179f, -0.00301407f, 0.01986774f, -0.02752136f, 
    0.00332261f, -0.00568142f, 0.01968828f, 0.03450819f, -0.03743018f, -0.00757636f, -0.03291957f, 0.00240416f, 
    -0.01016686f, 0.02084482f, 0.01753723f, -0.00525921f, -0.01834989f, 0.00147271f, -0.02549497f, -0.03656295f, 
    -0.00092660f, 0.01761932f, 0.01719087f, -0.03421241f, 0.02852037f, 0.02099803f, 0.00192735f, 0.01582246f, 
    -0.03110945f, 0.01615601f, -0.00589817f, 0.00715683f, 0.03039985f, 0.01568276f, 0.00494401f, 0.02901699f, 
    -0.00867485f, -0.03049063f, -0.03140194f, -0.02705390f, -0.04033339f, -0.02781788f, 0.00615381f, 0.00801683f, 
    -0.01920452f, 0.01808915f, 0.02863391f, -0.01481781f, -0.00673681f, -0.01221113f, 0.01936281f, -0.02515666f, 
    0.00768272f, -0.03720319f, 0.00034040f, -0.02831781f, -0.03524253f, -0.03032853f, -0.00209452f, -0.00934938f, 
    -0.02716129f, 0.01453514f, -0.01227034f, -0.03253174f, 0.02865180f, 0.02080585f, -0.02381053f, 0.00548783f, 
    -0.02687090f, -0.01406748f, 0.02855924f, -0.01121958f, -0.04117075f, -0.02169912f, -0.03040224f, 0.00130840f, 
    -0.00751739f, -0.02783233f, 0.00805068f, 0.01452007f, 0.02080248f, -0.01600523f, -0.01714341f, -0.01076849f, 
    -0.00417959f, -0.02219546f, -0.03189983f, -0.03369852f, -0.01705177f, 0.01321669f, -0.01326751f, -0.00541277f, 
    -0.02713228f, 0.01346507f, -0.00512119f, 0.02138086f, 0.02925823f, 0.01838623f, -0.01407678f, 0.01982345f, 
    -0.01532326f, -0.02880597f, 0.02995062f, 0.02130504f, -0.03297349f, -0.03922092f, -0.02364749f, 0.02369545f, 
    -0.01888049f, 0.03245760f, -0.03493276f, -0.01475872f, -0.01782842f, 0.01440461f, -0.00997678f, -0.04032445f, 
    0.02712955f, 0.01238456f, 0.02462863f, 0.03017941f, -0.01334834f, -0.04011143f, -0.02812007f, -0.00046455f, 
    0.02970241f, -0.03596263f, -0.01952884f, -0.02078389f, -0.03792003f, -0.03221907f, 0.01503474f, 0.03058753f, 
    0.00239371f, 0.02506516f, 0.00652404f, 0.02707099f, -0.03863275f, -0.04038774f, 0.02788176f, 0.01656773f, 
    0.01166678f, 0.00483088f, -0.01397300f, 0.01766754f, 0.01232975f, -0.02984043f, -0.02379270f, 0.00829045f, 
    -0.03089408f, 0.03349108f, 0.03361196f, 0.02540737f, -0.01583073f, -0.03955419f, -0.00685971f, -0.02958160f, 
    0.12180831f, 0.07464830f, -0.01385613f, -0.03155421f, 0.02069929f, -0.07064444f, -0.02601790f, 0.03597466f, 
    0.09291253f, 0.12892438f, 0.04897310f, 0.18122862f, 0.01204277f, 0.17094567f, 0.06020019f, -0.09115013f, 
    0.12203839f, -0.02315395f, -0.18396209f, -0.10450106f, 0.02314762f, 0.25153920f, -0.10484792f, -0.13885383f, 
    -0.36174896f, -0.07596533f, 0.38224512f, 0.00181767f, -0.15389246f, 0.08606565f, 0.18687209f, -0.10450529f, 
    0.07604976f, 0.05322612f, -0.00373527f, 0.11502241f, 0.23694047f, -0.26487023f, 0.17324257f, 0.04822871f, 
    0.20251873f, 0.13166140f, -0.05514013f, 0.15047753f, -0.09147926f, 0.05411704f, -0.02429662f, -0.09606638f, 
    0.09769075f, -0.07973275f, 0.06920297f, -0.13933586f, 0.07055875f, -0.05921784f, -0.00693874f, 0.06660925f, 
    -0.02305112f, -0.03821175f, -0.06572640f, -0.01140838f, -0.16275677f, -0.10291079f, 0.00853904f, 0.24111564f, 
    -0.01661495f, -0.16386728f, 0.04035722f, 0.08489769f, 0.17590719f, 0.01664044f, -0.05970290f, -0.03412145f, 
    0.05415853f, 0.24925859f, -0.11057944f, -0.03499355f, 0.04291021f, 0.10262544f, 0.19616905f, -0.12129484f, 
    0.27456856f, -0.19597584f, 0.03563845f, 0.13728277f, -0.04379489f, 0.11843071f, -0.00093813f, -0.09063797f, 
    -0.10044396f, -0.07446680f, 0.01324731f, 0.02125128f, 0.08100770f, -0.06327824f, -0.06325959f, -0.07609816f, 
    -0.03369469f, -0.27146056f, -0.04751984f, 0.05062065f, -0.12106134f, 0.04405588f, -0.05717600f, -0.07196679f, 
    0.10436669f, -0.14415714f, -0.01821480f, 0.11324596f, -0.10067444f, 0.15950458f, 0.31202528f, -0.26292166f, 
    -0.02305189f, -0.23942290f, -0.06787591f, 0.25315723f, 0.16480091f, 0.04842253f, 0.01275044f, 0.05230024f, 
    -0.01895751f, 0.02188544f, 0.04008429f, 0.02748852f, 0.13211113f, 0.01976893f, 0.14670721f, -0.05498030f, 
    -0.02163360f, 0.04034266f, 0.10856557f, -0.05961759f, -0.06042949f, -0.01895609f, 0.19404462f, 0.00416326f, 
    0.14141752f, -0.01414318f, -0.05948076f, 0.14050545f, 0.00021423f, -0.04840885f, 0.04025447f, -0.02105044f, 
    0.12908037f, 0.00215090f, -0.15870994f, -0.07313870f, -0.04470536f, -0.21511196f, -0.15670790f, -0.02575782f, 
    -0.01224539f, -0.12946382f, -0.03803836f, 0.10243361f, -0.28195730f, -0.14770213f, 0.09471465f, -0.13088919f, 
    0.01905700f, -0.01648773f, -0.07548436f, 0.04889759f, 0.09192986f, 0.05563129f, -0.00592748f, -0.03850638f, 
    0.25804561f, -0.13900621f, 0.03388886f, -0.00709459f, 0.03205539f, 0.04107108f, 0.08392064f, 0.05689719f, 
    0.13556421f, 0.01951740f, -0.11659254f, -0.04307863f, 0.23978838f, -0.20455180f, -0.21833801f, -0.06149296f, 
    -0.03381871f, 0.04157710f, 0.07809709f, -0.20519182f, 0.25292116f, 0.04926507f, -0.02657224f, 0.10260378f, 
    -0.00073561f, 0.25288162f, -0.12676805f, -0.21373177f, 0.14015503f, -0.19058403f, -0.06039554f, -0.17642502f, 
    0.09375838f, -0.13540001f, 0.08352485f, -0.11936328f, 0.19344725f, 0.07750608f, 0.07160042f, -0.02661540f, 
    -0.02592360f, -0.02407459f, -0.04871083f, -0.04195062f, 0.09296622f, 0.10277985f, 0.09240428f, 0.00476662f, 
    0.04900680f, -0.02879093f, 0.20625311f, 0.02653894f, -0.10065094f, -0.00991075f, -0.02469921f, 0.10126680f, 
    0.11123920f, 0.12007354f, 0.02386527f, 0.17388724f, -0.17164585f, 0.18554217f, -0.16456096f, 0.18755132f, 
    0.05666463f, 0.09741654f, 0.02535755f, -0.17461969f, 0.02397235f, -0.08954541f, 0.05048367f, -0.03024631f, 
    -0.16805199f, -0.01812972f, 0.04210026f, 0.07017039f, 0.02275735f, -0.00327819f, 0.02353452f, -0.12772162f, 
    0.00814540f, -0.06396378f, -0.05846830f, 0.03548556f, 0.39470714f, 0.03444926f, -0.26473796f, 0.14983349f, 
    -0.07696067f, -0.06910018f, 0.00448118f, 0.16280180f, -0.03245834f, 0.02928604f, 0.06045311f, -0.06705805f, 
    -0.21276982f, 0.02000838f, -0.56534660f, 0.21069928f, 0.09498750f, 0.08154479f, -0.00993514f, -0.01675212f, 
    -0.00290730f, 0.00215998f, -0.04798754f, -0.05758527f, -0.09201440f, -0.04110714f, 0.04246732f, 0.09736998f, 
    -0.00481807f, 0.11957666f, 0.03284849f, 0.23328249f, 0.12390721f, 0.08211575f, 0.04359526f, 0.16941671f, 
    -0.08398008f, -0.06211666f, -0.27082604f, 0.06462442f, 0.06613687f, 0.07493771f, 0.01576808f, -0.10365190f, 
    0.09553511f, 0.05419951f, 0.02736169f, 0.05308105f, -0.44313568f, -0.23557203f, 0.10644239f, 0.16670696f, 
    0.01680521f, -0.04162800f, 0.10735151f, -0.08590441f, 0.00664819f, -0.01975618f, -0.03939861f, 0.15319869f, 
    -0.02486791f, 0.14532249f, 0.01039866f, -0.17420945f, -0.02570760f, -0.11230997f, -0.02047445f, -0.00832012f, 
    -0.01919251f, 0.02715927f, 0.15050574f, 0.10362413f, -0.08629764f, 0.36897448f, 0.09095360f, 0.01705784f, 
    -0.06183153f, -0.06939887f, -0.06196977f, -0.04661585f, 0.11761400f, -0.00430044f, 0.00606647f, 0.03035256f, 
    0.08606693f, -0.17104220f, 0.11029579f, -0.16087912f, -0.02604243f, -0.07224023f, -0.03307063f, -0.04464572f, 
    0.08081315f, 0.16981967f, 0.00931128f, 0.02973762f, -0.06757604f, -0.27074313f, -0.16909777f, -0.09355842f, 
    -0.00279340f, 0.04311351f, 0.06152952f, 0.04604205f, 0.05303886f, -0.01999282f, 0.00559953f, -0.08052928f, 
    -0.00260482f, 0.01821921f, 0.10908175f, -0.23216836f, 0.03404257f, 0.03440949f, -0.03836692f, 0.06646726f, 
    -0.01895498f, -0.09066550f, -0.06133911f, 0.12291647f, 0.00636300f, 0.05014029f, -0.20062207f, 0.02948573f, 
    0.09255353f, 0.03477198f, 0.14854388f, 0.14464152f, -0.04940695f, 0.02624841f, 0.05939776f, 0.08282994f, 
    -0.02200969f, 0.02609810f, 0.38363218f, 0.14423573f, -0.20340167f, -0.02291940f, 0.02422836f, 0.06876969f, 
    0.23958068f, 0.22916162f, 0.02593473f, 0.07607621f, -0.09730106f, -0.11953815f, -0.12457851f, -0.12157595f, 
    -0.03700894f, -0.09635731f, 0.00426238f, 0.05457782f, -0.09577801f, -0.10034887f, -0.07513733f, 0.12030832f, 
    0.16369413f, -0.00768830f, -0.00708439f, -0.06863709f, -0.11857905f, -0.21242779f, 0.06279235f, -0.02725881f, 
    0.18501103f, 0.14744754f, 0.09379782f, 0.06359106f, -0.07019990f, 0.00434238f, 0.27670008f, -0.04064530f, 
    0.06382776f, 0.06169279f, 0.01268752f, -0.02342252f, 0.09032667f, -0.12038225f, 0.07157575f, 0.08647761f, 
    -0.44736606f, -0.09078241f, -0.23210123f, -0.07176863f, 0.03405033f, -0.10017708f, 0.03713325f, 0.00200623f, 
    -0.10654197f, -0.01071511f, 0.07204805f, 0.06856448f, 0.19721320f, -0.38853526f, -0.09820933f, 0.09882669f, 
    -0.05465853f, 0.13798678f, -0.01104651f, -0.06693032f, 0.07133868f, 0.09694358f, -0.01303412f, 0.10127867f, 
    0.04374582f, 0.56145626f, -0.04918741f, 0.28784189f, 0.02410382f, 0.03294498f, 0.04663097f, -0.02056914f, 
    0.08675125f, 0.04857162f, 0.03921883f, 0.11550879f, 0.02242048f, -0.11133625f, -0.12776949f, 0.02009433f, 
    0.07818516f, 0.01150565f, -0.04001756f, 0.02892983f, -0.03985047f, -0.02980967f, -0.02262837f, 0.07011738f, 
    0.07356311f, 0.12055738f, -0.11649332f, -0.31514034f, -0.10267798f, -0.12715431f, -0.03585829f, -0.02033107f, 
    0.03030569f, 0.05944894f, 0.09701340f, 0.06216848f, -0.37225083f, -0.07574403f, -0.05969343f, 0.36806747f, 
    -0.12273514f, 0.03716313f, 0.07427922f, 0.29963627f, 0.03025978f, 0.00797592f, 0.06357457f, 0.09605588f, 
    -0.11410697f, -0.04667203f, 0.27824795f, -0.19340552f, -0.15550376f, -0.19796729f, -0.05567794f, 0.08064403f, 
    0.01100426f, -0.09146398f, -0.02856152f, -0.04627902f, -0.14939831f, 0.21583946f, 0.40065143f, 0.07275145f, 
    -0.15994652f, -0.02445867f, -0.03497595f, 0.19665280f, 0.17374875f, 0.04068175f, 0.06104184f, 0.13998112f, 
    0.25966853f, -0.04629243f, 0.24931675f, 0.18847962f, -0.07006542f, -0.14934377f, -0.01364986f, 0.18752630f, 
    0.00763351f, 0.11872857f, 0.06539315f, 0.01874945f, -0.07227675f, 0.16024707f, 0.03979360f, 0.13317013f, 
    0.05356891f, 0.17651460f, 0.18230377f, -0.15351002f, 0.12717868f, 0.12754765f, -0.05125109f, -0.00315229f, 
    -0.18580937f, 0.00693397f, -0.02497688f, -0.08588805f, -0.13871314f, 0.02382733f, 0.26041627f, -0.01360900f, 
    0.00926001f, -0.06873163f, -0.03421202f, 0.14299338f, -0.01984669f, 0.13041224f, 0.07734472f, -0.05059301f, 
    0.19002526f, 0.06924927f, -0.04180919f, 0.03603902f, 0.05252862f, 0.13882194f, 0.05488206f, 0.00627017f, 
    -0.06636922f, 0.07097597f, 0.37610134f, -0.18850274f, -0.21470045f, -0.07008157f, -0.08623145f, 0.05507775f, 
    0.10976622f, 0.00646595f, 0.01943176f, 0.06592957f, 0.21612118f, 0.01511289f, 0.10071240f, -0.00341004f, 
    -0.03457656f, -0.02140466f, -0.01802531f, 0.14677818f, -0.06827308f, -0.00278014f, 0.01869106f, 0.06143462f, 
    0.33633703f, -0.30370569f, -0.06742853f, 0.02531989f, -0.13067015f, 0.02652487f, -0.03376178f, 0.03510168f, 
    0.04323208f, 0.05002436f, 0.00611897f, -0.09729946f, -0.02079898f, 0.01873357f, 0.05989983f, -0.15821013f, 
    0.08765609f, 0.05228330f, -0.14680764f, -0.05432819f, 0.17748196f, -0.10826179f, 0.03461067f, 0.05028579f, 
    -0.12590693f, -0.12758544f, 0.05023971f, 0.00149598f, 0.05984546f, 0.05089200f, 0.07999613f, 0.02426025f, 
    -0.06620836f, -0.08505080f, -0.06602529f, -0.03980109f, -0.26683769f, -0.09797525f, -0.04000502f, -0.09115528f, 
    0.06017557f, 0.01817139f, 0.09861528f, -0.13712730f, 0.00275189f, -0.02061713f, -0.04687897f, 0.00686624f, 
    0.12228967f, -0.32016411f, -0.10342003f, 0.26591384f, 0.04319094f, -0.07885135f, 0.03629983f, -0.00586907f, 
    0.02940891f, 0.10773052f, -0.01533707f, 0.01423180f, -0.40164194f, -0.15154301f, -0.09337839f, -0.04023210f, 
    0.01026526f, 0.11793119f, 0.01004329f, -0.04545003f, -0.15321079f, -0.01278034f, -0.08395585f, -0.01404229f, 
    -0.33745539f, 0.09674118f, 0.10646565f, -0.10364499f, 0.02186062f, -0.13405088f, 0.04163123f, 0.04977370f, 
    0.03206785f, 0.01553191f, 0.08381147f, 0.19577825f, -0.05172852f, -0.08157311f, -0.05373579f, -0.06010761f, 
    0.14671643f, -0.07296383f, 0.01949145f, -0.09183954f, 0.02955886f, 0.05687410f, 0.16051972f, 0.10335766f, 
    -0.17169715f, 0.41061234f, -0.14595860f, 0.09196997f, 0.06306124f, 0.01528959f, 0.06088425f, 0.00979716f, 
    0.01822291f, -0.02703086f, -0.02205309f, -0.08038980f, 0.08326569f, -0.50219953f, 0.29614085f, 0.09575385f, 
    0.22004861f, 0.13010854f, 0.10664941f, 0.09874469f, 0.22671647f, -0.04623022f, -0.04668523f, 0.04170450f, 
    -0.31741396f, -0.33568949f, -0.03654488f, 0.05336374f, -0.03531485f, 0.03406283f, 0.01237837f, 0.12144984f, 
    -0.01164714f, -0.05614306f, -0.06587645f, -0.07501223f, -0.16172235f, 0.13631225f, 0.02383156f, 0.13587524f, 
    0.17419717f, 0.10809197f, 0.02255273f, -0.15611202f, 0.06728534f, -0.02518487f, 0.09863601f, -0.02124205f, 
    -0.16504782f, -0.16539426f, 0.10198909f, -0.01181117f, -0.09330794f, -0.19457977f, -0.03372474f, -0.03424240f, 
    -0.01499456f, -0.01705787f, 0.05492444f, -0.12523770f, -0.09400125f, -0.13991125f, 0.26402512f, 0.04368066f, 
    0.14848882f, 0.18995461f, -0.07388902f, -0.12582642f, 0.15160233f, -0.04539999f, 0.10269923f, 0.01670531f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06500152f, 0.02647420f, -0.01189175f, 0.01877931f, 0.00829840f, 0.01260631f, 0.01023054f, 0.13553852f, 
    -0.01511781f, 0.19500345f, -0.03474843f, 0.15936361f, -0.02854368f, -0.06460273f, -0.03367504f, 0.01531351f, 
    0.05507204f, 0.14581190f, 0.02326532f, -0.02806593f, -0.03969944f, -0.01984966f, 0.04808523f, 0.12886102f, 
    -0.03300657f, 0.04040423f, 0.02699450f, -0.02814985f, 0.16121447f, 0.18304782f, 0.02047402f, 0.07735080f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04125987f, 0.08255174f, 0.16436093f, 0.16092128f, 0.02953239f, 0.08984622f, 0.11337472f, -0.18023412f, 
    -0.04049511f, -0.08287612f, -0.00319152f, -0.19294237f, -0.07602973f, 0.03587450f, -0.35443932f, 0.15894872f, 
    -0.38807514f, 0.15656570f, -0.12458066f, -0.08674044f, 0.09815925f, 0.03326701f, 0.32863033f, 0.40082651f, 
    -0.05981403f, 0.24684830f, -0.02487363f, 0.10558479f, 0.22649068f, -0.24116410f, 0.01471545f, 0.17740254f, 
    0.07363194f, -0.07693136f, 0.12104028f, 0.14211479f, -0.14452867f, 0.10172217f, -0.35233995f, -0.38931125f, 
    -0.07460064f, 0.10467248f, -0.15516636f, -0.10421415f, 0.04113476f, 0.08575287f, 0.22912206f, 0.04340480f, 
    0.18472804f, 0.10665235f, 0.33207735f, 0.14289951f, -0.09897181f, -0.02331043f, -0.19069105f, -0.27406111f, 
    0.09894851f, 0.13088647f, 0.13718957f, 0.13072558f, 0.01676149f, -0.32087812f, -0.15608618f, 0.42202809f, 
    0.55063832f, -0.02207976f, -0.10122520f, -0.10703364f, -0.11984203f, 0.17038599f, 0.32455340f, 0.08741219f, 
    0.34660330f, 0.04082092f, -0.13105874f, 0.11518392f, -0.08625687f, -0.32981810f, 0.26098365f, 0.00955517f, 
    0.31984815f, -0.25047028f, -0.06239747f, -0.17810817f, 0.13067393f, -0.07345029f, 0.11990328f, 0.32156736f, 
    -0.13621426f, 0.14073388f, -0.03933676f, -0.01176301f, 0.16683313f, -0.12519087f, -0.06120297f, -0.02461448f, 
    -0.15612343f, -0.01318596f, -0.10588118f, -0.02876052f, 0.10229640f, 0.07589261f, -0.24926730f, -0.14387926f, 
    0.16477813f, -0.22765732f, 0.03717963f, 0.07474358f, 0.17085882f, -0.08089500f, -0.29857054f, 0.12831999f, 
    -0.07661306f, -0.16637021f, -0.06694070f, 0.01109194f, 0.07119269f, 0.03748359f, 0.34427449f, 0.09924342f, 
    -0.04297832f, -0.11597699f, 0.14771952f, 0.09850073f, -0.06593208f, 0.07244631f, 0.05991756f, -0.33106226f, 
    0.31396770f, 0.01953417f, 0.10630798f, -0.32508639f, 0.02337035f, 0.14529404f, 0.27189058f, 0.33849072f, 
    -0.20707108f, -0.14260228f, -0.16629593f, 0.31489080f, -0.03314720f, -0.16033289f, -0.27203068f, 0.04953620f, 
    0.08305857f, 0.10325398f, 0.21124116f, 0.15092468f, -0.17234728f, -0.17265721f, -0.28260249f, 0.08240882f, 
    0.10140070f, 0.19286638f, -0.05616862f, -0.05666472f, 0.14424987f, 0.14437139f, 0.15980658f, 0.31169853f, 
    -0.70296544f, 0.14570676f, 0.16728100f, 0.09160142f, -0.08681957f, 0.01767857f, -0.17406766f, 0.37326255f, 
    -0.19157395f, 0.07032319f, 0.15368557f, 0.04754755f, 0.12811723f, -0.14871463f, 0.01945026f, 0.02817237f, 
    -0.10550874f, 0.29238459f, 0.21760562f, 0.01714589f, -0.11260197f, 0.04340813f, -0.01343758f, 0.08081280f, 
    0.06845705f, 0.02357017f, 0.07060736f, -0.12519346f, 0.14496015f, 0.15391447f, -0.10475733f, 0.02361079f, 
    -0.24346380f, -0.03579867f, -0.14289625f, -0.10437678f, 0.05237492f, 0.17047544f, -0.13189249f, 0.04811590f, 
    0.33021963f, 0.29124624f, 0.14999540f, 0.01905431f, 0.06732272f, 0.29717770f, 0.00053639f, 0.17384057f, 
    0.10909231f, 0.04045614f, -0.00468035f, 0.07355030f, 0.08479604f, 0.49416187f, 0.12540182f, -0.27846235f, 
    0.08079985f, -0.11875763f, -0.01665492f, 0.11013701f, 0.01402879f, -0.12256420f, -0.11742369f, -0.30681399f, 
    -0.00273029f, 0.10519533f, 0.13448796f, 0.18776354f, 0.05312657f, 0.07621573f, -0.15846071f, -0.01648384f, 
    0.12504634f, -0.24324490f, 0.18236971f, -0.26840302f, -0.06677486f, 0.31732252f, 0.21693355f, -0.14877804f, 
    -0.11534128f, 0.18749467f, 0.32770878f, -0.11327314f, -0.01724694f, 0.06500824f, 0.00900051f, 0.03761729f, 
    0.15095067f, 0.24646875f, 0.08243553f, -0.06349283f, 0.02487121f, -0.29240063f, -0.11761761f, -0.11714219f, 
    0.10143882f, -0.15413211f, -0.17477900f, -0.04406959f, 0.15227866f, 0.13561299f, 0.04357189f, 0.10890124f, 
    0.00705184f, -0.04617218f, 0.07883141f, 0.30274367f, -0.12972677f, -0.34365049f, -0.06405445f, 0.02880840f, 
    0.18323839f, -0.00517063f, 0.41595986f, 0.08802021f, 0.09841202f, -0.34531784f, 0.00631669f, 0.30120581f, 
    -0.05589258f, 0.10835674f, 0.16345182f, -0.10058546f, 0.14362274f, -0.09918282f, 0.13330135f, 0.08113898f, 
    0.69162208f, 0.13507274f, -0.10108431f, -0.07906286f, -0.02380527f, -0.13683586f, 0.04247830f, -0.11115675f, 
    0.22417201f, 0.06311739f, -0.03015887f, -0.18524887f, 0.13678026f, 0.20390971f, 0.31419262f, -0.04669651f, 
    0.13067952f, -0.20072372f, -0.05266592f, -0.13780618f, 0.00150910f, -0.00624380f, 0.18406928f, -0.20832880f, 
    -0.15597343f, 0.04771326f, 0.05945806f, 0.01303130f, 0.01939330f, 0.02242383f, 0.14286181f, 0.01691680f, 
    -0.24540535f, -0.05152456f, 0.06351121f, -0.17658302f, -0.05448901f, -0.04265773f, -0.14232393f, 0.12748964f, 
    -0.05250763f, -0.10013852f, 0.08636622f, -0.10485837f, -0.17155969f, -0.30212846f, -0.03019794f, 0.01354067f, 
    -0.03393431f, -0.15895599f, -0.23637569f, 0.13395134f, -0.02927147f, -0.05487657f, 0.37192443f, 0.12563391f, 
    0.06894143f, -0.16420873f, 0.03379454f, 0.05006133f, -0.25762939f, 0.16688065f, -0.11758444f, -0.30840474f, 
    -0.32702127f, -0.05258892f, 0.10934593f, -0.23904371f, 0.01564250f, 0.05653737f, 0.05647853f, 0.44268575f, 
    0.03769669f, 0.11155627f, -0.04456738f, 0.09451514f, 0.12827614f, 0.00729251f, -0.12723443f, -0.06514496f, 
    -0.00320061f, 0.18187617f, -0.14408040f, -0.11632789f, 0.01550269f, 0.37579313f, 0.17775303f, -0.20147075f, 
    0.08409832f, -0.11277244f, 0.11821092f, -0.05982317f, 0.11345626f, -0.00263434f, -0.00312643f, 0.21621150f, 
    -0.02993431f, -0.07237044f, -0.08130658f, 0.06503196f, -0.12153067f, -0.15173896f, -0.20243031f, -0.15756866f, 
    0.00987003f, -0.05926066f, 0.11192469f, 0.01744989f, -0.15303497f, -0.15284103f, 0.04362191f, -0.14251222f, 
    0.13408953f, -0.27846447f, 0.06128392f, 0.10912713f, 0.15532717f, -0.22148560f, -0.15477741f, -0.09185810f, 
    -0.13963291f, -0.04242156f, -0.10798971f, 0.16571026f, -0.09019598f, -0.03913141f, -0.01636781f, -0.07690716f, 
    -0.20899890f, -0.14621629f, -0.05250229f, 0.15414539f, -0.05220755f, 0.12087248f, -0.00238241f, 0.31759134f, 
    -0.03967322f, -0.09224669f, 0.10178949f, 0.07089568f, -0.03867042f, 0.23938723f, -0.00581412f, 0.10125997f, 
    0.06940576f, 0.06032019f, 0.27222881f, -0.14680052f, 0.03121480f, 0.39894649f, -0.17833483f, -0.05278146f, 
    -0.03743698f, 0.02818004f, -0.17675118f, 0.13279232f, -0.20610479f, -0.10319901f, -0.00990052f, 0.24537326f, 
    -0.10956933f, -0.15126763f, 0.07488336f, 0.17638510f, -0.16929705f, 0.00530629f, -0.23984563f, -0.23288797f, 
    -0.05084570f, 0.19492830f, -0.10681714f, -0.08591221f, -0.08304264f, -0.07204998f, 0.54238641f, -0.07876523f, 
    0.25076774f, -0.02882845f, 0.24937814f, -0.08118668f, -0.09960835f, 0.03317945f, -0.21769001f, 0.13350594f, 
    0.09211852f, -0.13126723f, 0.15628535f, -0.00126451f, 0.03803534f, -0.22061419f, 0.14586972f, 0.07731199f, 
    -0.35298890f, -0.13999236f, 0.09447040f, 0.29225236f, -0.08308537f, -0.11685473f, -0.35288456f, -0.19249606f, 
    -0.34008974f, -0.00628116f, -0.09436167f, -0.07290956f, -0.07846957f, 0.19136183f, 0.17381400f, -0.09512720f, 
    0.20663606f, 0.33363843f, -0.22951514f, -0.11753844f, -0.03803704f, 0.20424478f, -0.06603332f, -0.05111876f, 
    0.05432814f, -0.03792389f, 0.11138730f, 0.03038849f, 0.27528745f, 0.15957788f, -0.16402000f, 0.17233363f, 
    -0.28342697f, -0.07757336f, 0.15218520f, 0.21317439f, -0.10240835f, 0.14835465f, 0.10635265f, -0.17616402f, 
    -0.05400049f, 0.25714636f, -0.07374816f, 0.07553781f, 0.04578718f, -0.23398298f, -0.07275727f, 0.08872306f, 
    -0.04606624f, 0.32336840f, 0.31368443f, -0.10597157f, 0.03958978f, -0.40349379f, 0.27516076f, 0.15250321f, 
    -0.10314752f, 0.04881998f, -0.04619777f, 0.01936848f, -0.02195602f, -0.08296165f, 0.00979328f, -0.13575166f, 
    0.24481861f, 0.17665854f, 0.07349989f, -0.16809271f, 0.03959521f, 0.14010505f, -0.05439153f, 0.11790346f, 
    0.04706436f, -0.24690200f, 0.14140233f, -0.06747225f, -0.06772048f, -0.12722537f, -0.10208236f, 0.14246020f, 
    -0.15060392f, -0.15585731f, 0.17168023f, -0.10518853f, 0.17160797f, -0.01307548f, -0.25440985f, 0.14819419f, 
    -0.07939838f, 0.16677694f, -0.06220078f, 0.16077667f, 0.14538598f, 0.05210575f, -0.16203368f, 0.33222109f, 
    0.04752740f, 0.00066397f, 0.04415309f, -0.03671790f, -0.13254391f, -0.07943828f, 0.11668767f, -0.08645710f, 
    0.09506273f, 0.23294772f, 0.14380208f, 0.09599268f, 0.04271173f, 0.27117434f, 0.06855198f, -0.16686988f, 
    0.12008384f, -0.09398653f, -0.19016837f, 0.04026914f, 0.12827344f, -0.08368447f, -0.04596262f, 0.20087384f, 
    -0.04259576f, -0.38796476f, -0.03169572f, 0.07575248f, -0.13129075f, 0.11850413f, -0.14575934f, 0.01174188f, 
    0.27814296f, 0.13400708f, -0.16983566f, 0.03478997f, -0.10320546f, -0.03414185f, -0.35856858f, -0.26060352f, 
    0.29222465f, 0.13183104f, -0.07065544f, -0.36040586f, -0.14212802f, 0.38878307f, 0.05543160f, 0.11959469f, 
    0.05196970f, 0.06994098f, 0.35945934f, 0.03412963f, -0.01378022f, 0.14615819f, 0.03841732f, -0.22006780f, 
    -0.15620069f, 0.18510559f, 0.11470454f, -0.15477161f, -0.05695419f, -0.42517677f, 0.02029482f, 0.28853232f, 
    -0.13097475f, -0.00948378f, -0.05615177f, -0.07077365f, 0.16112925f, 0.05333568f, 0.46929914f, 0.50209892f, 
    0.28682169f, 0.17542471f, -0.11289885f, 0.33220127f, -0.06509198f, -0.28173622f, -0.19363564f, -0.15289709f, 
    0.02942369f, 0.04548610f, 0.03082606f, 0.06342952f, -0.17786986f, -0.08269848f, 0.21205615f, 0.49681762f, 
    -0.09851661f, -0.02148606f, -0.00096746f, 0.17053455f, 0.05452522f, 0.11740089f, 0.15578027f, 0.08005235f, 
    -0.12658687f, 0.02733234f, -0.15929313f, -0.37726560f, -0.11036226f, -0.17520808f, 0.03008009f, -0.15871519f, 
    0.31268778f, -0.28814542f, 0.00003722f, -0.06693554f, -0.01987287f, -0.01824667f, 0.06105924f, 0.10586022f, 
    0.03324232f, -0.21183960f, -0.12931745f, 0.10883338f, -0.08004635f, -0.27937263f, -0.22749315f, 0.09878829f, 
    0.07112150f, -0.13974620f, -0.15878937f, -0.05614020f, 0.08584657f, -0.08414649f, -0.05589475f, -0.02579793f, 
    0.30113399f, 0.04273477f, 0.18344879f, -0.13202608f, 0.09132660f, 0.08585470f, 0.27646628f, -0.11643125f, 
    -0.01416385f, 0.19210322f, -0.15383755f, 0.05506858f, -0.11393581f, -0.13651109f, 0.15418160f, -0.06318849f, 
    0.16467564f, -0.30657127f, -0.25565666f, 0.04610591f, -0.00099013f, 0.16009019f, -0.03874237f, 0.04142370f, 
    -0.03460421f, -0.07838571f, -0.03081731f, -0.00102525f, -0.05599546f, 0.18445003f, 0.02846162f, 0.22969317f, 
    0.65541828f, 0.06806515f, -0.05945859f, -0.07522118f, -0.07777391f, -0.00359479f, 0.13311531f, 0.26786444f, 
    -0.04136343f, 0.12391463f, -0.01747386f, 0.05682546f, 0.12023911f, 0.17242071f, -0.25450864f, -0.04021760f, 
    0.19320762f, -0.12535262f, 0.34308073f, -0.01944807f, 0.07862005f, 0.31250775f, -0.29890817f, -0.23336646f, 
    0.11219901f, 0.03504971f, -0.09590691f, -0.13496177f, 0.15934360f, -0.16102484f, -0.15618055f, 0.28410915f, 
    0.27823332f, 0.04903202f, 0.12288200f, 0.18427359f, -0.00633920f, -0.15606084f, -0.12599380f, -0.13474140f, 
    0.25483966f, 0.28386873f, -0.02794519f, 0.09411196f, -0.08366346f, -0.24711551f, -0.47547072f, 0.00934200f, 
    -0.12626129f, -0.05490268f, -0.08737276f, -0.14091025f, -0.10464386f, -0.23987423f, 0.40084717f, -0.04034207f, 
    0.03876869f, -0.07483700f, 0.06836895f, -0.00783396f, 0.08465027f, 0.04936635f, -0.06489428f, 0.24063241f, 
    -0.14459133f, 0.13976489f, 0.04429639f, -0.00565242f, 0.07092189f, 0.03547063f, 0.24548744f, 0.18545784f, 
    0.08211169f, -0.17981529f, -0.09942646f, -0.06286398f, 0.06731724f, 0.14482328f, -0.09607594f, -0.04691299f, 
    0.00177815f, 0.28993797f, -0.01177180f, -0.15086558f, -0.00552551f, 0.22061385f, 0.15581027f, 0.06124349f, 
    0.15384984f, 0.28431034f, -0.02200974f, -0.01189092f, 0.19919312f, -0.24008171f, 0.03946370f, -0.41711301f, 
    -0.10664438f, 0.17351460f, -0.12120099f, -0.09534951f, 0.01440307f, -0.06280751f, 0.02252682f, -0.02268222f, 
    -0.14868183f, 0.02544528f, -0.17613234f, 0.09238085f, -0.11004253f, -0.06439969f, 0.04531581f, -0.02166316f, 
    0.01864918f, -0.17160328f, -0.11059923f, 0.04670231f, -0.06816427f, -0.17393711f, 0.07347573f, 0.00651453f, 
    -0.09700558f, -0.11572829f, 0.15511964f, -0.11630733f, -0.03553956f, -0.16981201f, 0.08503299f, -0.15075679f, 
    -0.06084644f, -0.13124545f, 0.05794637f, -0.11306483f, 0.02543511f, -0.09522042f, 0.09262816f, -0.16322282f, 
    -0.00948471f, 0.37888208f, 0.00327921f, 0.05431940f, -0.15323696f, 0.07664112f, 0.26976687f, -0.15163951f, 
    0.15900929f, 0.09463859f, -0.04664325f, 0.14105342f, 0.16217023f, -0.02390157f, -0.15217990f, 0.09491722f, 
    -0.04188238f, -0.16892180f, 0.15089722f, 0.10025614f, -0.08967571f, 0.16745041f, 0.08260814f, -0.12338061f, 
    0.13763851f, -0.13913873f, -0.06740441f, 0.03483643f, 0.15738636f, -0.09600824f, -0.07772610f, 0.18986154f, 
    0.26253501f, 0.36193767f, -0.12028204f, 0.16455396f, -0.07569142f, -0.27073538f, 0.03109250f, 0.14190415f, 
    -0.03834881f, -0.11098740f, -0.17397965f, 0.05631620f, -0.13137978f, 0.08003435f, 0.31706455f, 0.14964868f, 
    -0.16447267f, -0.20124482f, 0.07006521f, -0.06140824f, 0.23159321f, 0.14023046f, 0.00024393f, 0.29468995f, 
    0.09164870f, 0.08449107f, -0.15793325f, 0.22209918f, -0.13277319f, 0.05803899f, -0.13400146f, -0.15335481f, 
    -0.10965371f, 0.11595007f, 0.13609153f, -0.06260225f, 0.01036410f, -0.16433932f, -0.35180521f, 0.04224307f, 
    -0.11368365f, 0.17384677f, 0.16169517f, 0.04236656f, -0.10121140f, -0.22005178f, 0.06978489f, 0.09729440f, 
    -0.08321482f, 0.03857814f, 0.04322513f, 0.01775159f, -0.21690343f, 0.22518323f, 0.13299780f, 0.22362801f, 
    -0.12088818f, -0.09076431f, 0.10195927f, -0.19282910f, -0.06021802f, -0.03569541f, 0.33358222f, 0.38801685f, 
    0.21148962f, -0.38132355f, 0.17408130f, 0.28744060f, 0.04627085f, 0.20131180f, 0.18839633f, -0.02521234f, 
    -0.04732574f, 0.16467366f, 0.14420080f, 0.14537084f, -0.05480449f, 0.23764691f, -0.05057581f, 0.26253930f, 
    0.06937373f, -0.01471264f, 0.02398586f, 0.13426037f, -0.03522589f, 0.20470363f, 0.09147774f, 0.00282205f, 
    -0.00199889f, -0.17721580f, -0.08696327f, 0.18601288f, -0.13656981f, -0.10622022f, -0.19555154f, -0.19916953f, 
    -0.37071875f, 0.00981923f, -0.04635002f, 0.06689828f, -0.16544893f, -0.19228275f, -0.07908297f, -0.16578528f, 
    0.27881664f, 0.13802405f, 0.27140763f, -0.12007907f, 0.14065598f, -0.29403082f, -0.26518068f, 0.12437881f, 
    -0.08127471f, 0.17100438f, -0.09416521f, 0.12794863f, 0.11226520f, 0.08800039f, 0.00803921f, 0.26369989f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.19867592f, -0.05967641f, 0.12004793f, 0.14455833f, 0.27996749f, 0.22701769f, -0.17168236f, 0.10995835f, 
    0.19998772f, 0.01732248f, -0.18670915f, 0.22519323f, -0.08210876f, 0.00140698f, -0.07143601f, 0.12827639f, 
    0.05916968f, 0.00458309f, 0.04283946f, -0.07711758f, 0.05079948f, -0.12680517f, -0.18167128f, 0.16107205f, 
    -0.08345275f, 0.00612258f, -0.15297937f, 0.19927500f, 0.14208768f, 0.05052293f, 0.18350030f, 0.02848025f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.10702203f, 0.14279139f, -0.54896986f, 0.11409096f, -0.49200460f, 0.01293741f, 0.28357750f, 0.10102149f, 
    -0.44855401f, -0.01523487f, -0.16235694f, -0.18308716f, -0.05576424f, 0.14606038f, 0.18068649f, 0.23399697f, 
    0.08333938f, -0.46871501f, -0.24671628f, 0.20076858f, -0.31720570f, -0.00575458f, 0.00580180f, 0.01270964f, 
    -0.00954125f, 0.23376936f, 0.02762949f, -0.31867799f, -0.27789107f, 0.24320513f, -0.23990355f, 0.08131548f, 
    0.28369096f, -0.20434500f, -0.09165715f, -0.22505069f, -0.30789834f, 0.14505894f, 0.04779496f, 0.05198256f, 
    -0.07292267f, -0.05173272f, -0.14327645f, 0.03394950f, -0.25447690f, -0.49172062f, 0.14104074f, 0.18353863f, 
    0.22579113f, -0.23175023f, 0.27873090f, -0.24263391f, 0.10710852f, -0.07712881f, 0.06299263f, -0.67842305f, 
    0.10963599f, 0.27715522f, -0.16737366f, 0.22124954f, 0.15739088f, -0.01844840f, -0.12654655f, -0.03228690f, 
    0.14649116f, -0.11784703f, -0.02753329f, -0.17339210f, -0.15324366f, -0.05897417f, -0.19585519f, -0.19503340f, 
    0.10717694f, -0.04418079f, -0.38568693f, -0.02503987f, -0.14973558f, 0.03252642f, -0.06439354f, -0.01438857f, 
    0.13839756f, -0.02841374f, -0.19561401f, 0.08467022f, 0.09391058f, -0.14540230f, -0.09789515f, 0.26649800f, 
    0.59504610f, -0.25195068f, -0.00285396f, -0.68118560f, 0.22302489f, 0.23640157f, -0.24936028f, 0.09195194f, 
    -0.08697639f, -0.03501874f, 0.06886358f, -0.15857874f, -0.14850433f, -0.38181955f, 0.10936370f, 0.21833916f, 
    -0.09595386f, 0.26985472f, -0.27286601f, 0.00350422f, -0.23812975f, -0.02007540f, -0.21368819f, -0.45697027f, 
    -0.06634522f, 0.05970250f, -0.14151013f, 0.14574541f, 0.04744611f, -0.41755179f, -0.20353074f, 0.21096331f, 
    0.10663915f, 0.24418257f, -0.12889829f, -0.32377425f, -0.04687422f, -0.33956850f, 0.04888998f, -0.42414576f, 
    0.26009095f, 0.27499700f, -0.20202287f, 0.00863350f, 0.01782600f, -0.13398439f, -0.56088388f, 0.18329959f, 
    -0.05220938f, 0.09335805f, 0.32654619f, -0.62233877f, -0.19252363f, 0.04490409f, -0.60623431f, -0.04519466f, 
    0.06981197f, 0.17268269f, 0.05812108f, 0.15433022f, -0.07648963f, 0.07027423f, 0.06615563f, 0.03616184f, 
    -0.04931074f, -0.00719560f, 0.07125214f, 0.11255668f, -0.22630312f, 0.28822234f, -0.01649101f, 0.12411858f, 
    0.05196867f, -0.09498178f, -0.51327926f, -0.00763718f, 0.17312928f, 0.27645087f, -0.10593717f, 0.04456181f, 
    -0.07849554f, -0.29205325f, -0.04478699f, 0.16223618f, -0.04774730f, 0.27929869f, -0.25461987f, 0.21337821f, 
    -0.02630431f, 0.13414556f, -0.07087590f, -0.19826049f, 0.04650181f, -0.09494450f, -0.31973690f, -0.00637271f, 
    -0.46992278f, 0.13943961f, -0.13221897f, 0.02867305f, -0.10914242f, -0.10789261f, 0.18126801f, 0.12972531f, 
    -0.69173914f, 0.22198325f, 0.05666311f, -0.05995789f, 0.32504079f, -0.30114695f, -0.50363034f, -0.68064290f, 
    0.17799252f, 0.10025814f, -0.22782244f, -0.18508714f, -0.23312545f, -0.15185657f, -0.07132074f, 0.06805747f, 
    -0.04544819f, 0.16000105f, -0.26981351f, -0.21139760f, -0.00883895f, 0.12788273f, 0.18385789f, 0.28734508f, 
    0.04118251f, -0.62761384f, 0.07703038f, -0.21225215f, 0.10297388f, 0.02304753f, -0.21605664f, 0.28316832f, 
    -0.59693837f, 0.38254964f, -0.23019277f, 0.27522227f, -0.39968410f, -0.10979305f, 0.13633211f, 0.00122622f, 
    -0.42504644f, 0.09036448f, 0.17342879f, 0.00229878f, -0.00262619f, 0.35891777f, 0.30489781f, 0.21498936f, 
    -0.26538703f, -0.55898315f, -0.04327002f, 0.31249472f, -0.01984451f, -0.04797367f, 0.07412749f, -0.02951614f, 
    0.22646526f, -0.52991706f, 0.12608232f, -0.07199318f, 0.09083757f, 0.10376827f, 0.12131546f, -0.16419312f, 
    -0.21476182f, -0.26484063f, 0.03151487f, -0.36825499f, 0.02699653f, 0.01166860f, 0.21295813f, -0.54161108f, 
    -0.34697700f, -0.00297786f, -0.24054211f, 0.44770041f, -0.27102116f, 0.14115620f, -0.20298088f, 0.02292546f, 
    -0.57207602f, -0.00775599f, -0.15106858f, -0.28050622f, 0.10096901f, 0.32562193f, 0.22666572f, 0.08220662f, 
    0.01891161f, 0.01933921f, -0.12958287f, -0.16988619f, 0.15683538f, -0.46906996f, 0.06704171f, -0.47880375f, 
    -0.32171372f, 0.35828090f, -0.01596521f, -0.14091726f, -0.12047805f, 0.19789430f, -0.37429607f, 0.13123867f, 
    0.26423839f, -0.06053267f, -0.35078245f, -0.38824177f, 0.00173630f, 0.02880732f, 0.36408517f, 0.09504227f, 
    0.15893513f, -0.11381710f, -0.12820098f, 0.03694559f, -0.11298196f, -0.07884561f, -0.21206035f, 0.18698022f, 
    -0.50578135f, -0.05676655f, -0.02691585f, -0.20481135f, -0.16534558f, -0.15563995f, -0.08727477f, 0.25711295f, 
    0.01954808f, -0.42454308f, 0.14322962f, -0.17781658f, 0.17349792f, 0.08303836f, -0.08840228f, -0.23136745f, 
    0.27943486f, -0.25728828f, -0.07374407f, -0.23685762f, -0.05678017f, 0.00963588f, -0.32930854f, -0.81574327f, 
    0.35839525f, -0.18222991f, -0.55950511f, -0.41974011f, 0.24865180f, -0.30050412f, -0.22367258f, -0.48011577f, 
    -0.06832295f, 0.10144059f, -0.11950140f, -0.50693941f, -0.04100819f, 0.08461248f, 0.19547938f, -0.05593872f, 
    -0.11544292f, -0.43791205f, 0.39603099f, -0.42226082f, -0.02481970f, -0.56076443f, -0.23803258f, -0.01521341f, 
    0.03670815f, 0.32615885f, -0.37381652f, -0.45177162f, 0.13625057f, -0.38233969f, 0.05095483f, -0.07198881f, 
    -0.16558762f, -0.12145687f, 0.17326838f, -0.31227556f, 0.11479519f, -0.16464895f, 0.21541891f, 0.05455161f, 
    -0.36253184f, 0.04866932f, -0.10213587f, -0.05349914f, 0.01963685f, -0.48309061f, 0.14899020f, -0.03871800f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12481458f, 0.02260891f, 0.22587173f, 0.00511340f, -0.00535245f, -0.07113682f, -0.10774940f, -0.23066829f, 
    0.10604425f, -0.10067837f, 0.17765789f, 0.12477978f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
