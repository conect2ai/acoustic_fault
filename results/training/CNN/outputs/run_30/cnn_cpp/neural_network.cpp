#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.85746115f, 0.39044639f, 0.57832181f, -0.48455444f, 0.15109374f, -0.36946487f, 0.08528052f, -0.18284868f, 
    -0.43638179f, -0.24174258f, -0.05180590f, -0.00733357f, 0.44553471f, 0.06991907f, -0.20822905f, -0.13321239f, 
    -0.63391954f, -0.18735582f, -0.26468498f, 0.06487050f, -0.12734410f, 0.15420204f, -0.11039459f, -0.00277132f, 
    0.01992954f, -1.04188788f, -0.27996284f, 0.19753747f, 0.57487434f, 0.22648789f, -0.49933282f, 1.08865345f, 
    -0.12434828f, 0.03526165f, 0.32050195f, -0.17778702f, -0.15482165f, 0.17564820f, -0.01976379f, 0.06274325f, 
    -0.07365292f, -0.07541765f, -0.05303807f, -0.05367173f, -0.10823652f, 0.27310437f, 0.07708253f, 0.14060208f, 
    0.13450934f, -0.14452419f, -0.20386548f, -0.77540982f, -0.86602086f, -0.60180163f, 0.05018563f, 0.16987857f, 
    0.83537048f, 0.52954704f, 0.38479957f, 0.36184737f, -0.26553181f, -0.07628962f, -0.00230200f, -0.16641352f, 
    -0.19057602f, -0.32303748f, -0.01469012f, 0.05394874f, 0.16965283f, -0.06907407f, 0.07720697f, 0.12063806f, 
    -0.07809979f, -0.17282516f, 0.11775972f, -0.83319145f, 0.06269832f, 0.14760557f, -0.09412718f, 0.25590897f, 
    1.08626986f, 0.08289317f, -0.60771269f, 0.24172275f, 0.13896358f, 0.06622322f, 0.19873933f, 0.33555821f, 
    0.24486592f, 0.13319598f, -0.13767825f, -0.16387287f, -0.17898922f, -0.10725679f, 0.09125696f, -0.04912828f, 
    -0.24107790f, -0.15689723f, -0.01543339f, -0.17158593f, 0.00283410f, -0.55375630f, -0.28644162f, -0.54543281f, 
    0.64560544f, -0.48728377f, -0.40084401f, -0.21595144f, -0.35678837f, 0.29476985f, -0.17598945f, 0.27212429f, 
    -0.21212023f, 0.06208135f, -0.15476030f, 0.02297429f, -0.26863092f, -0.03659052f, -0.07489549f, 0.29433244f, 
    0.24182934f, 0.17045796f, 0.18025321f, 0.16285564f, 0.04299654f, 0.69759995f, 0.49935830f, 0.60460562f, 
    0.65100735f, 0.90478009f, 0.18459180f, -0.68881398f, -0.86495894f, -0.46051583f, -0.19521865f, 0.15781440f, 
    0.30789229f, -0.06105921f, 0.17381625f, 0.14079098f, 0.25418806f, -0.00076123f, -0.13938101f, 0.13259268f, 
    0.08571283f, 0.07995512f, 0.05137031f, 0.25498578f, 0.07023603f, 0.08867215f, 0.50715375f, 0.40365019f, 
    0.47255233f, 0.63190907f, 0.16536438f, -0.02573414f, 0.46874741f, -0.19641367f, 0.27927455f, 0.04111218f, 
    0.16050346f, -0.01450771f, -0.15471089f, -0.29916027f, -0.15484825f, -0.36734688f, -0.39600474f, 0.04039441f, 
    -0.16734597f, -0.21013546f, 0.27331743f, 0.36469197f, -0.09715165f, 0.20892808f, -0.08995237f, -0.50323832f, 
    -1.00799286f, -0.62165821f, -0.17701468f, -0.48650974f, -0.57085836f, -0.09807482f, -0.05018125f, -0.44767523f, 
    0.27843016f, 0.27833384f, 0.42729574f, 0.33429047f, 0.04930417f, 0.08763612f, -0.14566852f, 0.09014744f, 
    0.20979024f, 0.03946853f, -0.15849407f, -0.00477887f, -0.28855577f, -0.02996344f, -0.10683575f, 0.05403299f, 
    -0.44048703f, 1.28074682f, -0.41248995f, -0.89153808f, -0.42212594f, 0.57470262f, 0.39111096f, -0.25087491f, 
    -0.01326740f, 0.27607203f, 0.01344287f, 0.10464787f, 0.46450251f, -0.09812035f, -0.15638427f, 0.10195642f, 
    0.05679547f, 0.28370434f, 0.11183525f, -0.37223187f, -0.04082783f, -0.13812605f, 0.13944675f, -0.13593780f, 
    0.22357774f, 0.99789739f, 0.62529647f, -0.26206183f, 0.00500371f, -0.30306390f, 0.26227251f, 0.54698211f, 
    0.16473746f, 0.55427575f, 0.45975062f, -0.21279410f, 0.23351797f, -0.20311788f, -0.33067495f, -0.20469809f, 
    -0.08655877f, -0.06412286f, -0.17582013f, 0.03327706f, 0.03152886f, -0.25880334f, -0.13655646f, -0.09812257f, 
    -0.24919334f, -0.10273549f, 0.15841100f, -0.27391714f, 0.07446985f, 0.81690627f, 0.72339344f, 0.64023209f, 
    0.27151740f, 0.32942295f, 0.30383199f, 0.43104619f, -0.15720789f, 0.11463225f, -0.00836800f, -0.10456611f, 
    -0.25420296f, -0.02425525f, 0.21135773f, -0.10133028f, -0.03361912f, -0.01715525f, 0.10031078f, 0.09734260f, 
    0.04529875f, 0.08481551f, 0.06419801f, -0.40123552f, -0.46058911f, -0.56361341f, -0.04569592f, 0.16992021f, 
    -0.66231537f, -0.08563686f, 0.43919632f, -0.05872045f, -0.39778215f, -0.19271319f, -0.18958662f, 0.40857714f, 
    -0.18989833f, -0.21480799f, 0.27108929f, 0.01358419f, -0.00090730f, -0.03205915f, -0.02762915f, -0.34647959f, 
    -0.10013736f, -0.07632218f, 0.20491283f, -0.03940702f, -0.63322967f, 0.15167585f, -0.17419161f, 0.16676517f, 
    -0.43189481f, 0.46044371f, -0.16198875f, 0.06716587f, 0.01271335f, -0.36847693f, -0.52821273f, -0.14925286f, 
    -0.42667550f, -0.43547630f, -0.31132546f, -0.22232033f, 0.33607742f, -0.27944303f, -0.33664006f, -0.50139189f, 
    0.03762883f, -0.18074062f, -0.27117348f, -0.39230537f, -0.18875605f, -0.52536881f, -0.50555921f, 0.45627311f, 
    0.11476914f, -0.64975810f, -0.11241272f, -0.37258866f, 0.26634115f, -0.25347707f, -0.51497686f, -0.15839811f, 
    -0.09734973f, -0.07227679f, 0.31667209f, 0.07061028f, -0.10107026f, 0.04801666f, -0.05381903f, -0.13625753f, 
    -0.29559857f, 0.21383238f, 0.27222449f, 0.28443435f, 0.14096241f, 0.08371819f, 0.48892489f, 0.12713507f, 
    0.41152412f, 0.89369309f, 0.54478920f, -0.18186395f, 0.30939081f, 0.43203506f, 0.04172580f, -0.30202687f, 
    -0.30517384f, -0.40196922f, -0.30511621f, 0.26309493f, 0.16261370f, -0.09516481f, -0.17989840f, 0.22183958f, 
    0.33037946f, 0.01229821f, -0.09328669f, -0.06337760f, -0.22856437f, 0.20387001f, -0.12874728f, 1.13095760f, 
    0.48990476f, 0.44441658f, -0.12191659f, -0.03351653f, -0.01351742f, -0.59125572f, 0.07992184f, -0.02213398f, 
    0.39378318f, -0.01985965f, 0.27710861f, 0.20679611f, 0.42417741f, 0.04260442f, -0.33411545f, 0.10179885f, 
    0.17806406f, 0.04134576f, -0.01244753f, -0.04814972f, 0.27806127f, -0.21017897f, -0.01168370f, 0.24324901f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16975257f, 0.20524572f, 0.05636364f, 0.20903583f, 0.20611069f, 0.23890759f, 0.33573368f, -0.00090882f, 
    0.14476877f, 0.10812955f, 0.28314275f, -0.03706944f, 0.17687848f, 0.31117439f, -0.00336399f, 0.16214176f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02115938f, -0.02061485f, 0.02405625f, -0.05367446f, -0.01378129f, 0.05694935f, -0.02873854f, 0.06135109f, 
    0.06183555f, -0.02177991f, -0.06117661f, -0.07304800f, 0.00434219f, -0.04708183f, -0.06140215f, -0.01367513f, 
    -0.00648494f, -0.00637594f, -0.02627260f, -0.03857497f, -0.02055486f, -0.00223306f, 0.00042620f, -0.02926908f, 
    -0.02376771f, -0.07609883f, -0.02183158f, 0.01781068f, -0.06808387f, -0.02032800f, 0.03653596f, -0.03050910f, 
    -0.06156228f, -0.00767007f, 0.00774332f, 0.01216246f, -0.04978424f, 0.02779717f, -0.02886111f, -0.01832694f, 
    -0.02981662f, -0.07297067f, 0.00450138f, -0.03143970f, -0.00419290f, -0.01596498f, -0.03423050f, 0.01775951f, 
    -0.01615490f, 0.02609521f, 0.01828645f, -0.03563400f, -0.00851664f, 0.01802085f, -0.01045349f, 0.03634165f, 
    -0.00190272f, 0.01781438f, 0.05296476f, 0.04348192f, 0.01572298f, 0.00655775f, -0.01550970f, 0.00512434f, 
    0.01230201f, 0.02960384f, 0.05307334f, -0.06186103f, 0.01443469f, 0.05396547f, -0.01318735f, 0.01585717f, 
    -0.05852424f, -0.06474163f, 0.03316617f, 0.03149578f, -0.04453160f, 0.02947925f, 0.03597923f, 0.04337512f, 
    0.00971113f, 0.06366520f, 0.01084948f, -0.00695394f, -0.03022534f, -0.00341238f, -0.03673712f, 0.02410055f, 
    -0.05199409f, 0.04906898f, 0.06250353f, -0.01004327f, -0.02108259f, -0.05561151f, -0.00870371f, 0.05716683f, 
    0.01140572f, -0.05910838f, -0.07480348f, -0.04961108f, -0.02057691f, -0.07341938f, -0.06391860f, 0.05496844f, 
    -0.05993182f, -0.00336275f, -0.00707307f, 0.05092001f, 0.00741970f, -0.07754350f, -0.05564465f, -0.03666740f, 
    0.03320115f, -0.07472801f, -0.02495985f, -0.04967237f, -0.06347270f, -0.07658549f, 0.02314053f, 0.06403106f, 
    -0.00637332f, -0.06166670f, 0.00847214f, -0.04555406f, 0.04901557f, 0.01551883f, 0.01694732f, -0.05580155f, 
    -0.05368466f, 0.05676784f, 0.02499927f, -0.03712853f, -0.06270147f, -0.06766203f, -0.00725660f, -0.05664405f, 
    -0.00977901f, 0.06324050f, -0.06607026f, -0.04128252f, -0.02551183f, 0.03705128f, 0.04402487f, -0.01285774f, 
    -0.03639818f, 0.05091557f, 0.02294151f, 0.06224470f, -0.02811267f, -0.06381458f, 0.03610506f, -0.07169295f, 
    0.05527606f, -0.07648978f, -0.00826746f, -0.04009563f, -0.07029793f, -0.01136719f, -0.06519000f, -0.07604418f, 
    -0.06111372f, -0.04377207f, -0.03535751f, 0.00659389f, 0.01276085f, 0.03681114f, 0.05605022f, 0.04726398f, 
    -0.03042997f, 0.02418982f, -0.01874400f, 0.03644400f, 0.02880560f, 0.05131299f, -0.06542874f, -0.05524364f, 
    0.03824472f, 0.04276254f, -0.07597633f, -0.01872437f, 0.01862394f, 0.00501057f, -0.00848483f, 0.02405949f, 
    -0.07194237f, 0.04675134f, -0.07515359f, -0.01348305f, -0.01683907f, -0.06991703f, 0.00414373f, 0.06447603f, 
    0.33182737f, 0.07020593f, -0.00058840f, 0.11071622f, -0.10208391f, 0.09417108f, -0.02464160f, 0.00651999f, 
    0.23582496f, 0.02609083f, 0.06961311f, 0.22012761f, 0.54242909f, -0.00550530f, 0.01689596f, 0.10681265f, 
    0.12557250f, 0.01557286f, 0.07567273f, 0.13752490f, -0.01531520f, 0.06787064f, 0.01995779f, 0.09183640f, 
    0.02635403f, 0.21100056f, -0.01650515f, -0.15514834f, -0.14828779f, -0.02667833f, 0.17586274f, 0.14095545f, 
    -0.01415685f, -0.01479906f, -0.10979322f, -0.02801671f, 0.43736258f, -0.28269780f, 0.02570245f, 0.06911241f, 
    -0.02490116f, 0.07430671f, 0.13291235f, 0.31789112f, 0.12086310f, -0.02692015f, 0.09997280f, 0.02868749f, 
    0.30105785f, 0.28938484f, -0.27228731f, 0.13280801f, -0.06461003f, -0.16350760f, -0.10514961f, 0.03169011f, 
    0.04096683f, 0.09314948f, 0.09738495f, 0.22166538f, 0.35016897f, 0.10441022f, -0.24886900f, -0.07552005f, 
    0.33157626f, -0.05839977f, -0.01319277f, -0.05219895f, 0.10103294f, -0.05751570f, 0.20942225f, 0.07660998f, 
    0.17978214f, -0.03431896f, -0.07352086f, -0.29126784f, 0.20400745f, 0.10896253f, -0.13787797f, -0.04455242f, 
    -0.07637698f, 0.13220957f, 0.21339300f, 0.11010785f, -0.17876975f, 0.21355900f, -0.15051048f, -0.29363608f, 
    -0.06355376f, 0.05464109f, 0.12412579f, -0.07763449f, 0.12972046f, 0.13662525f, 0.01035624f, -0.13185897f, 
    -0.05905834f, 0.11553453f, -0.35449192f, 0.27556628f, -0.02227076f, 0.09966458f, 0.08349366f, -0.04716351f, 
    -0.05144030f, 0.00244092f, 0.01265314f, 0.11353020f, -0.81068456f, 0.06035186f, -0.10222440f, -0.14490640f, 
    -0.00488442f, 0.17424673f, 0.20348115f, -0.02098243f, 0.17397499f, -0.00708513f, 0.11212772f, 0.12006614f, 
    -0.08776260f, -0.33207029f, 0.29921237f, -0.41387051f, 0.13111535f, -0.01689919f, 0.00971972f, 0.12515815f, 
    -0.00750043f, -0.05677339f, -0.00970958f, 0.03382365f, -0.28900826f, 0.35734272f, -0.02292521f, 0.12298313f, 
    -0.05705514f, -0.02850204f, 0.13614175f, 0.13988192f, 0.11756110f, 0.13110642f, 0.03272097f, 0.12099050f, 
    0.13741954f, -0.21306282f, 0.04070029f, -0.24291474f, -0.13607341f, -0.05500115f, -0.03943181f, 0.04776824f, 
    -0.02859719f, -0.12168922f, 0.12505764f, 0.09987585f, -0.07775132f, -0.01764761f, 0.15017630f, 0.02216643f, 
    -0.03476616f, 0.02657479f, 0.02555632f, 0.13637429f, 0.01656473f, 0.15392724f, 0.07850346f, 0.05165757f, 
    -0.23682059f, -0.17973042f, 0.10498618f, -0.51951051f, 0.16080518f, -0.11144833f, -0.09195342f, 0.02131309f, 
    -0.09429244f, -0.02944523f, 0.08406606f, 0.05057090f, -0.06768777f, 0.08085604f, -0.09921809f, 0.10957663f, 
    0.17718507f, 0.04982824f, 0.09807228f, -0.03481678f, 0.16871507f, 0.07209361f, 0.06447181f, 0.14586787f, 
    0.05785935f, 0.13665119f, 0.11302411f, -0.37374550f, 0.04438623f, 0.01016518f, 0.03922027f, 0.06090896f, 
    0.18422568f, -0.12926398f, -0.04027532f, 0.02748211f, 0.14637746f, 0.11958694f, -0.04464706f, 0.30930722f, 
    0.02430099f, 0.08278910f, -0.07530035f, -0.09827013f, -0.06192645f, -0.05006213f, 0.05349823f, 0.13628471f, 
    -0.21182704f, 0.19273049f, 0.15382215f, 0.24655405f, -0.04692749f, -0.13997966f, 0.27109611f, 0.06037410f, 
    -0.09174388f, -0.01516463f, -0.03384300f, 0.20033146f, 0.54722309f, -0.05030814f, -0.08912505f, -0.01704758f, 
    0.05881055f, -0.01577125f, -0.00109077f, 0.04648160f, 0.15569030f, -0.02334366f, -0.02214893f, -0.01821572f, 
    0.02457076f, 0.16263478f, -0.13507646f, 0.07808359f, 0.04402347f, -0.04104354f, 0.01405620f, 0.01060584f, 
    0.15652603f, 0.12810750f, -0.00792381f, -0.00585237f, 0.16813259f, -0.10608540f, 0.07479572f, 0.09315271f, 
    -0.02533413f, 0.07854275f, -0.07701614f, 0.14653793f, 0.20172077f, 0.03061763f, -0.01442276f, -0.22233173f, 
    0.21454768f, 0.04403955f, -0.14342079f, -0.08969405f, 0.05721806f, -0.02605405f, -0.09615026f, -0.23371264f, 
    -0.08169430f, 0.11358055f, 0.17362131f, 0.18293357f, 0.16219297f, 0.01325271f, 0.16659197f, -0.10081401f, 
    -0.02567773f, 0.02182137f, 0.09083211f, 0.00340849f, -0.15448837f, 0.16243483f, -0.12623964f, -0.01352394f, 
    0.36274871f, 0.32177249f, -0.11101356f, 0.02301564f, 0.03790059f, 0.11230031f, 0.06421160f, 0.10813125f, 
    -0.11664973f, 0.10438690f, -0.18653134f, 0.11222231f, -0.48667681f, -0.06017026f, -0.18172044f, 0.22155994f, 
    0.02038676f, 0.17977096f, 0.08039708f, 0.08279777f, 0.07161012f, 0.10302543f, 0.13062958f, 0.12549737f, 
    0.16753513f, -0.25345105f, -0.07783759f, 0.10155565f, -0.11101311f, -0.10532732f, -0.06263410f, 0.02918673f, 
    0.03816676f, -0.00544916f, 0.04498764f, -0.02063702f, -0.17528120f, 0.09276032f, -0.02281969f, 0.22308257f, 
    -0.04443349f, -0.21185236f, 0.06999703f, 0.06273495f, 0.12467122f, 0.19024034f, 0.11221940f, -0.03568641f, 
    0.10276276f, -0.24409193f, -0.18011095f, -0.28617200f, -0.17257461f, -0.08473759f, 0.06171956f, 0.10239644f, 
    0.03386084f, 0.06308873f, 0.18237931f, 0.11957359f, 0.03804078f, -0.01976390f, 0.15243113f, -0.33373439f, 
    -0.04955504f, -0.07122009f, -0.08702480f, 0.00926630f, -0.10369003f, -0.09709579f, -0.09991968f, 0.21438047f, 
    0.00609253f, -0.15414472f, -0.18703756f, 0.25077519f, -0.04797370f, -0.19665430f, -0.00325734f, 0.14056472f, 
    -0.00033149f, 0.00829437f, 0.13951604f, 0.07304981f, -0.09892721f, -0.39579856f, -0.17253405f, -0.13701133f, 
    0.05873064f, -0.03420883f, -0.21768662f, -0.00826597f, 0.15746896f, 0.13587913f, -0.13450101f, 0.16306807f, 
    -0.07134864f, 0.03299205f, 0.02760739f, -0.01854235f, -0.00308659f, -0.07118524f, -0.08131475f, 0.00207113f, 
    -0.01175594f, -0.03904538f, -0.00538569f, -0.02362466f, 0.01456428f, -0.06707019f, -0.04849736f, -0.07317217f, 
    0.01395414f, -0.07575001f, 0.06502169f, 0.04332126f, -0.00155128f, 0.03540286f, 0.03273825f, 0.06160000f, 
    0.04993566f, 0.01106794f, 0.00787426f, -0.06581385f, -0.02955179f, -0.05631514f, 0.05144931f, 0.02148671f, 
    0.03135816f, 0.04624831f, 0.00937867f, -0.00387251f, -0.05303910f, -0.07463750f, 0.01844734f, 0.00113935f, 
    -0.02677022f, 0.02574184f, -0.04033239f, 0.00475038f, 0.04997747f, 0.01990314f, -0.03046141f, 0.06455037f, 
    -0.03068561f, 0.06382053f, -0.02802530f, -0.07776383f, 0.01052213f, 0.00836007f, -0.06283036f, -0.07012700f, 
    -0.03769292f, -0.08523232f, -0.00273250f, 0.02689066f, 0.00749903f, -0.00137287f, 0.05590140f, -0.02017988f, 
    -0.01858409f, -0.07499619f, 0.03115428f, -0.06601971f, -0.06763881f, -0.04507758f, 0.03740007f, -0.02334647f, 
    -0.00004866f, -0.06681776f, -0.03429519f, -0.06092256f, -0.04390597f, -0.05064104f, -0.05711607f, 0.00693864f, 
    -0.04966465f, 0.05429221f, -0.08471390f, -0.01472755f, -0.05797532f, -0.05090261f, -0.03565285f, -0.01808663f, 
    -0.05474835f, -0.02511363f, 0.01828537f, 0.00596034f, -0.06603835f, -0.03297476f, -0.05434208f, 0.02592214f, 
    -0.03768576f, -0.04778868f, 0.00073190f, 0.05269782f, 0.03387713f, -0.03693742f, 0.04672880f, 0.03068310f, 
    -0.00493861f, -0.00209461f, -0.01349517f, -0.04462313f, 0.04430737f, -0.02478736f, 0.04392170f, 0.05652263f, 
    -0.04571474f, -0.07551163f, -0.04768320f, 0.00811522f, -0.05770904f, 0.06321751f, 0.02547173f, -0.01476603f, 
    -0.06375132f, 0.06685359f, -0.00972636f, -0.02755920f, -0.07065256f, -0.07738016f, -0.00433291f, 0.00192849f, 
    0.04447854f, 0.03041345f, -0.04719921f, -0.05073617f, -0.08388786f, -0.06994463f, 0.02168116f, -0.00141339f, 
    -0.00044956f, -0.03176610f, -0.04691506f, -0.06886921f, 0.05353713f, 0.03392259f, 0.01532204f, -0.03026430f, 
    0.02956670f, -0.04816227f, -0.04941208f, -0.02723774f, -0.04177278f, 0.02343977f, 0.04584147f, -0.02297924f, 
    0.00028056f, -0.02652297f, -0.01953547f, -0.02343878f, -0.03707773f, -0.06681539f, -0.09510759f, -0.03455297f, 
    -0.07506938f, -0.03110261f, -0.02679734f, 0.06191976f, -0.07161361f, 0.02389193f, 0.03008583f, -0.00876793f, 
    0.02380785f, -0.01847945f, 0.05179058f, -0.03380657f, -0.03275408f, -0.05055166f, 0.00134502f, 0.03339978f, 
    0.06528439f, -0.01384614f, -0.00494035f, -0.06979775f, -0.00462316f, -0.05081227f, 0.03285553f, 0.01743611f, 
    -0.07304604f, -0.05206317f, -0.04651160f, -0.07014335f, -0.03876446f, 0.04431606f, -0.07298964f, 0.04318180f, 
    -0.19204694f, 0.20747924f, -0.26494092f, -0.09871165f, 0.02480673f, 0.20882604f, -0.05878619f, -0.04458748f, 
    0.31202582f, 0.14681511f, 0.07916599f, 0.05277646f, 0.01810266f, 0.17021467f, -0.11392588f, -0.02628716f, 
    -0.06883832f, 0.01832803f, -0.10517725f, 0.20370121f, -0.02901886f, 0.15332808f, -0.01226438f, 0.06113467f, 
    0.68303955f, 0.10562728f, 0.19610780f, 0.21019037f, -0.02572945f, -0.03617623f, 0.15154138f, 0.17718028f, 
    0.06457970f, 0.11160950f, 0.03274078f, -0.06863090f, -0.04772934f, 0.46983370f, -0.10027494f, 0.10460743f, 
    0.11946137f, -0.05531532f, 0.01805349f, 0.01724294f, 0.03284048f, -0.12791762f, 0.05892697f, 0.01341039f, 
    0.34052473f, -0.21399531f, -0.01411201f, 0.13230304f, 0.21094732f, 0.03171612f, 0.21655153f, 0.14244935f, 
    -0.02638747f, 0.17465521f, 0.15064220f, 0.03366316f, 0.12194492f, -0.16543317f, -0.20073967f, -0.14547065f, 
    0.18141450f, -0.17019156f, -0.06930935f, -0.01480886f, 0.12107211f, 0.12993686f, 0.07184678f, 0.08081725f, 
    -0.24114366f, -0.16968088f, -0.10343727f, -0.10262248f, -0.03892913f, 0.20278455f, -0.07928932f, -0.10076649f, 
    0.13724478f, 0.06617407f, 0.01088247f, 0.17595682f, 0.47167963f, 0.20013939f, -0.11931456f, 0.16345501f, 
    -0.02926342f, 0.08868212f, 0.12217010f, -0.06303984f, -0.18985869f, -0.01846514f, 0.01466217f, -0.15245950f, 
    -0.19460006f, -0.26555267f, 0.21329603f, -0.26555210f, 0.04677979f, 0.02096094f, -0.12534407f, 0.05855531f, 
    0.06004165f, 0.06670235f, 0.17700273f, 0.06682047f, -0.03600932f, -0.10941221f, -0.03708004f, -0.28687808f, 
    -0.00031596f, 0.04239684f, 0.00458006f, -0.09425374f, 0.08093377f, -0.05206523f, 0.06619505f, 0.00608633f, 
    -0.08436842f, 0.07146751f, -0.45403624f, -0.03879613f, 0.23453318f, 0.05220981f, -0.16110851f, 0.12928784f, 
    0.02332808f, 0.11544703f, 0.34656093f, -0.00970935f, 0.32106516f, 0.09968375f, -0.01038922f, 0.27594778f, 
    0.12039270f, 0.09524649f, 0.00462649f, 0.18573657f, -0.13922511f, 0.08311470f, 0.08746003f, -0.06703068f, 
    -0.08299528f, 0.08575153f, 0.05207426f, 0.29376850f, -0.08093831f, 0.06077474f, 0.16821198f, -0.10672130f, 
    -0.20568563f, -0.26932216f, -0.00165802f, -0.13308506f, 0.21527825f, 0.33305216f, -0.07689426f, 0.38642469f, 
    0.05515662f, 0.13143532f, -0.12969770f, 0.20378329f, 0.09933583f, -0.06734978f, 0.04993329f, 0.17988576f, 
    -0.27824029f, -0.20834886f, -0.32322097f, 0.01996784f, -0.09150718f, -0.10670222f, -0.16609511f, 0.04927190f, 
    -0.00206521f, -0.03273449f, 0.02229720f, 0.01202934f, -0.24023838f, -0.31852195f, -0.09052999f, -0.14908659f, 
    0.16194114f, -0.04425014f, 0.12457284f, 0.05678793f, 0.16752429f, 0.10633952f, -0.08936868f, -0.03394091f, 
    0.00905783f, 0.05080248f, 0.06591678f, -0.05696287f, -0.07967487f, -0.01157569f, -0.07107473f, 0.06079447f, 
    0.05282968f, -0.03808143f, -0.06140449f, 0.00052114f, -0.05389399f, -0.04848848f, -0.03885728f, -0.06015223f, 
    -0.02024475f, -0.05923951f, -0.05392606f, -0.08081184f, 0.00343459f, -0.08114022f, -0.04068361f, 0.02071582f, 
    0.02573323f, -0.05444810f, 0.01158541f, -0.06683288f, -0.04149663f, -0.00103255f, -0.03409792f, 0.01366353f, 
    0.02673267f, 0.05672837f, -0.03590640f, 0.03488111f, 0.01458387f, -0.06959323f, -0.05286340f, -0.05283658f, 
    -0.02174785f, -0.02405007f, -0.07363401f, -0.01176345f, 0.01563666f, -0.05482991f, 0.05563706f, -0.03170294f, 
    0.01112802f, 0.06279069f, -0.06676189f, 0.04669138f, -0.01630649f, 0.06299053f, -0.00320384f, -0.00151740f, 
    0.03974220f, 0.05603835f, -0.03070159f, -0.00754558f, -0.00694870f, -0.01281365f, -0.06907570f, -0.07232861f, 
    -0.01613495f, 0.02821171f, 0.01084203f, 0.01644771f, 0.05406198f, -0.02342122f, 0.01961636f, 0.04339943f, 
    -0.08234530f, -0.00305108f, -0.00793013f, 0.04758199f, -0.02608705f, 0.05716656f, 0.04015414f, 0.04324166f, 
    0.05985951f, 0.02607447f, 0.05873162f, -0.00346371f, -0.01104517f, -0.06673829f, -0.02540527f, 0.03236654f, 
    0.05899492f, -0.04444118f, 0.01241685f, 0.05317948f, -0.00184536f, 0.01690608f, 0.03093981f, -0.00799922f, 
    0.04009049f, -0.04299232f, -0.06432506f, -0.07098544f, 0.04272372f, 0.00683040f, -0.04559781f, 0.04669597f, 
    0.01576584f, -0.05958500f, -0.08228362f, -0.02750189f, 0.01161536f, -0.05704663f, 0.01997474f, 0.01448621f, 
    -0.06683195f, -0.02306410f, 0.01878510f, -0.02352448f, 0.05036236f, 0.01841094f, -0.00583375f, 0.00145777f, 
    0.04183191f, -0.07834717f, -0.05252587f, -0.05690527f, 0.02061075f, -0.00195157f, 0.05688769f, 0.03449486f, 
    -0.04273136f, 0.05702636f, -0.02064798f, -0.01637909f, -0.06319286f, 0.05068009f, -0.00166197f, -0.01328732f, 
    0.04488578f, -0.04272788f, 0.02795143f, -0.03368969f, -0.04664794f, -0.02436498f, -0.05384054f, -0.01902745f, 
    -0.00354426f, 0.00197487f, 0.04159696f, -0.06128740f, -0.07688873f, -0.02405928f, 0.05532410f, -0.06001564f, 
    0.05428717f, -0.04015831f, 0.01933648f, -0.01098439f, -0.02218924f, 0.04324392f, 0.01503267f, 0.02539415f, 
    -0.03748411f, -0.05146218f, 0.06094956f, -0.03371105f, 0.06436359f, 0.06317995f, -0.05399143f, -0.01339241f, 
    0.00715707f, 0.06054676f, -0.01678498f, 0.01273546f, 0.03387309f, 0.03747372f, 0.01108329f, -0.02488543f, 
    -0.01143160f, -0.06854548f, -0.03160279f, 0.06029704f, 0.02377534f, -0.03652340f, -0.03193567f, 0.02439150f, 
    -0.03759332f, 0.05007733f, -0.00022769f, -0.05839859f, -0.06579298f, 0.02457269f, -0.02169917f, 0.01446563f, 
    0.17372791f, -0.05006412f, 0.15523741f, 0.50396782f, 0.01879466f, -0.04962697f, 0.02255555f, 0.00325913f, 
    -0.08090376f, -0.05815149f, -0.09012605f, 0.06824047f, -0.38205609f, 0.25502861f, 0.12645805f, -0.18925792f, 
    0.18146467f, -0.07193995f, 0.13683137f, 0.06043448f, 0.04992826f, 0.03007612f, 0.08319692f, 0.03561590f, 
    -0.22715995f, 0.16179572f, -0.03370744f, -0.06304421f, -0.02393153f, 0.12457655f, -0.07170640f, -0.08490489f, 
    0.00428779f, 0.00307505f, 0.03580128f, -0.25034803f, -0.03837353f, -0.19863220f, 0.08671116f, 0.04598120f, 
    0.01790820f, 0.25100589f, 0.08678034f, 0.06022452f, 0.05008902f, -0.03020753f, -0.01285233f, 0.06449706f, 
    0.02163858f, 0.15832767f, -0.20273438f, 0.22188686f, -0.03110853f, -0.18487456f, 0.00720926f, -0.02727067f, 
    -0.02534941f, 0.08295645f, -0.01217222f, -0.12639020f, 0.18323091f, 0.01303953f, -0.11269883f, 0.22505012f, 
    -0.02925723f, -0.03111249f, -0.01510940f, -0.12250207f, -0.05700311f, 0.00212561f, 0.06099793f, 0.24763113f, 
    0.15903357f, 0.05010621f, 0.11526348f, -0.23906973f, -0.01689781f, -0.04079451f, -0.09906911f, 0.11977022f, 
    0.03162390f, -0.08920378f, 0.08019237f, -0.13152254f, -0.25065541f, 0.38133070f, 0.11690100f, -0.07139744f, 
    0.16776973f, 0.02614103f, 0.01168649f, 0.04457229f, 0.13141458f, 0.02060544f, 0.09254695f, 0.15370969f, 
    -0.39852238f, 0.01464846f, -0.28051499f, 0.39604145f, 0.19121544f, 0.03372052f, -0.08886176f, -0.04159045f, 
    -0.04959586f, -0.04641052f, -0.03009468f, 0.06685463f, -0.33489147f, 0.02448465f, -0.02850303f, -0.19072238f, 
    -0.08431437f, 0.00117788f, -0.02680316f, -0.05289273f, -0.00549230f, -0.05804567f, -0.01030114f, 0.08122984f, 
    -0.15678674f, -0.20091684f, 0.24093258f, -0.45485425f, -0.01838067f, 0.05847131f, 0.10419939f, 0.06714594f, 
    -0.07852481f, -0.02238125f, -0.10765222f, -0.01650116f, -0.14057690f, 0.15444949f, 0.15955342f, -0.07403823f, 
    0.11782874f, 0.02890643f, -0.03328002f, -0.12997229f, 0.18682240f, 0.04878359f, -0.05287417f, 0.02432973f, 
    0.11415911f, -0.11809706f, 0.24137598f, -0.20716879f, 0.12894928f, 0.08346434f, -0.06150135f, 0.04182775f, 
    -0.03522874f, 0.00818079f, 0.07517651f, 0.11296853f, 0.00500198f, -0.07947673f, 0.23136155f, 0.20359662f, 
    0.08183043f, 0.06385332f, 0.11864593f, 0.10347064f, -0.06404544f, 0.00590816f, -0.00154001f, -0.09142342f, 
    0.00563068f, -0.03597478f, 0.26390478f, -0.62257075f, 0.15979087f, 0.00736214f, -0.06958364f, -0.10552045f, 
    -0.04261953f, -0.00330709f, 0.09315874f, -0.14684869f, 0.13817403f, 0.05096991f, -0.24616869f, 0.07942698f, 
    0.07086471f, 0.02390125f, -0.00740191f, 0.10187742f, 0.07489733f, -0.05175972f, 0.17233802f, -0.05016712f, 
    0.05785858f, -0.04608904f, -0.02607593f, -0.04709973f, -0.02576556f, 0.00204168f, -0.03141097f, -0.03599549f, 
    -0.05109503f, -0.07805757f, -0.02788598f, -0.02527894f, -0.08118974f, -0.01460082f, 0.00597757f, -0.02003536f, 
    -0.03162034f, -0.02886202f, -0.02727671f, 0.04642218f, 0.05647666f, -0.04474024f, 0.00432839f, 0.04584936f, 
    0.00977077f, 0.02407602f, 0.01832671f, -0.06360200f, 0.06137888f, -0.00550499f, 0.03273698f, 0.03044820f, 
    -0.05185150f, 0.02872487f, 0.05080526f, -0.07592522f, 0.00074176f, -0.05037333f, 0.02489923f, 0.05013760f, 
    0.01449147f, -0.07030004f, 0.00746955f, -0.06459007f, -0.00531799f, 0.03607771f, 0.01449373f, -0.06217924f, 
    -0.03308567f, 0.01898639f, -0.01669984f, 0.03791651f, 0.03813048f, -0.00619929f, 0.04901040f, -0.05959723f, 
    -0.03267112f, 0.01464360f, -0.02589579f, -0.02816506f, 0.02712800f, -0.00264400f, 0.02206653f, -0.05794029f, 
    0.01456115f, -0.06330772f, 0.02850946f, -0.04571267f, -0.06166674f, 0.04797031f, -0.01636101f, 0.04664433f, 
    -0.04098929f, -0.01470523f, -0.07082044f, 0.00642162f, -0.05196903f, -0.05884293f, -0.00716731f, -0.04461136f, 
    -0.06843989f, 0.02139592f, 0.05156824f, 0.04977984f, 0.01415305f, 0.03359075f, 0.03413690f, -0.03500846f, 
    -0.02214056f, 0.04103298f, -0.01583598f, -0.06826874f, 0.02314111f, 0.01282631f, 0.02440115f, -0.00815799f, 
    0.02167926f, 0.06196191f, -0.02446585f, 0.03231607f, -0.06942700f, -0.06970175f, 0.00482333f, 0.00663625f, 
    -0.00981889f, 0.04881726f, 0.03934737f, -0.04644810f, 0.06214868f, -0.01906896f, 0.05573407f, -0.00563675f, 
    0.05083455f, 0.01030326f, 0.02025910f, 0.05849260f, 0.00680318f, 0.00292227f, 0.03569401f, -0.00608477f, 
    -0.04374057f, -0.04880138f, -0.05108386f, 0.05024949f, -0.05968573f, 0.00030551f, 0.02549118f, 0.02272888f, 
    0.00030830f, -0.03469476f, -0.04550673f, -0.02121595f, 0.02082323f, 0.02209750f, 0.00777582f, -0.07020446f, 
    0.06026679f, -0.06088389f, 0.03335137f, -0.01757199f, -0.02560260f, -0.07878432f, 0.05251028f, 0.00785922f, 
    -0.07898111f, -0.04381043f, 0.05543928f, -0.03038866f, 0.04694680f, -0.03265608f, -0.06538466f, 0.03080226f, 
    0.00422356f, -0.04058186f, -0.06290324f, -0.03627775f, -0.01898707f, -0.05064432f, -0.04387415f, 0.05802757f, 
    -0.04517866f, 0.01845308f, 0.01823050f, 0.04831982f, -0.00777905f, -0.01117234f, 0.03378303f, -0.07714037f, 
    -0.02174566f, 0.04635090f, -0.02504930f, 0.01250275f, 0.06541051f, -0.03096615f, -0.07806806f, -0.03192412f, 
    -0.00605939f, -0.07779399f, -0.00146771f, 0.05370256f, -0.02783087f, -0.05735181f, 0.02806709f, -0.05287862f, 
    -0.04971620f, -0.05003706f, -0.04470669f, -0.00613074f, 0.03749753f, 0.01572472f, 0.02349426f, -0.04373268f, 
    -0.19680312f, -0.03870331f, -0.25495443f, -0.01912666f, 0.07134742f, -0.08003922f, 0.14256839f, -0.12118992f, 
    0.15214568f, -0.01106386f, 0.22269543f, 0.17199826f, 0.04350202f, -0.23459040f, 0.01633713f, -0.02203220f, 
    0.01708126f, -0.00220922f, -0.04507470f, 0.08484785f, -0.04858242f, 0.04928224f, -0.03494999f, -0.02954744f, 
    -0.52529937f, -0.08556915f, 0.04820515f, 0.41198134f, 0.19413765f, -0.11813497f, 0.09430901f, 0.11029342f, 
    0.04270703f, -0.03286733f, -0.03864574f, 0.10726930f, -0.08099429f, 0.40217477f, -0.03413291f, -0.15232027f, 
    0.08309980f, 0.11290574f, -0.07320353f, 0.20791391f, -0.03359052f, 0.06725261f, 0.03908927f, 0.23121260f, 
    -0.38611931f, -0.14079122f, -0.23248705f, 0.14977241f, 0.07452008f, -0.02555719f, 0.07139648f, -0.02676052f, 
    0.10793755f, 0.03501231f, 0.08138387f, 0.01265127f, 0.10208012f, 0.32359505f, -0.02451307f, -0.14649448f, 
    0.05871346f, 0.04387754f, -0.05901077f, 0.05895892f, 0.04114442f, -0.13028906f, -0.01446685f, -0.19043194f, 
    0.10740223f, 0.11530734f, 0.06787669f, -0.12354027f, 0.09508177f, 0.03277759f, -0.12099796f, -0.05980674f, 
    0.12402949f, 0.07357591f, 0.11207254f, 0.15749906f, -0.35125491f, -0.27623096f, -0.21537685f, 0.05006887f, 
    0.09548375f, 0.10303736f, 0.32693583f, -0.05407096f, -0.01934022f, 0.14619863f, -0.24905321f, -0.24082284f, 
    0.38251099f, -0.41897857f, 0.25187692f, -0.08490961f, -0.05778043f, 0.12954308f, 0.20556033f, 0.00849169f, 
    -0.05466650f, 0.11792761f, -0.04188311f, -0.01127614f, -0.10907029f, 0.24789925f, 0.27174339f, 0.14029700f, 
    -0.02071214f, 0.07544205f, 0.16292618f, 0.19377889f, 0.03780669f, 0.19198564f, 0.26058832f, -0.05976734f, 
    -0.11747908f, 0.25149986f, -0.18732706f, -0.09878551f, 0.35955775f, -0.15016000f, 0.08589800f, 0.03846439f, 
    -0.03344722f, 0.02810112f, 0.05387960f, 0.05112715f, 0.16591503f, 0.15778822f, -0.34297386f, 0.22391756f, 
    -0.10133452f, 0.00116274f, -0.04354826f, 0.16950117f, 0.06273751f, 0.04020787f, 0.13791089f, 0.09943666f, 
    0.00479195f, -0.26222271f, -0.05223863f, 0.00234566f, 0.04771585f, -0.01510136f, 0.12752900f, 0.03423865f, 
    -0.13256256f, 0.13093191f, 0.22837447f, 0.20080107f, 0.32165292f, 0.11547365f, -0.17868932f, -0.32629019f, 
    -0.16265002f, 0.01802227f, -0.12375586f, 0.14193659f, -0.17836659f, -0.07128176f, 0.02599028f, 0.10793778f, 
    -0.03682486f, -0.02863474f, -0.26885745f, -0.23929358f, 0.17347458f, 0.06122788f, -0.04891654f, 0.13609891f, 
    0.01885182f, 0.02084629f, -0.15608096f, 0.06971023f, 0.21071509f, 0.08673115f, 0.15993796f, -0.08609844f, 
    -0.01007964f, 0.16296273f, 0.22355993f, -0.04280556f, -0.07965136f, -0.00198429f, -0.14897959f, -0.05816596f, 
    0.22162434f, 0.15196215f, 0.15883981f, -0.04895929f, 0.09775601f, -0.16799223f, -0.05805974f, 0.01488701f, 
    -0.02118077f, 0.05038261f, -0.08668355f, 0.10280760f, -0.19803025f, 0.08351061f, 0.04861138f, -0.04554982f, 
    0.09248091f, 0.08230376f, 0.07801290f, 0.20823035f, 0.07912156f, -0.08389253f, -0.11257962f, -0.00525488f, 
    -0.12400773f, 0.15681921f, 0.15719607f, 0.02127004f, -0.25313565f, -0.07027217f, 0.27539366f, 0.01326119f, 
    -0.12107687f, 0.04611423f, 0.01906247f, 0.23367143f, 0.25871539f, 0.38519314f, -0.31285566f, -0.30601516f, 
    0.20672627f, -0.07771979f, 0.15319791f, 0.09436804f, -0.06771267f, 0.00377850f, 0.08057266f, -0.01349901f, 
    -0.08879624f, -0.18740766f, 0.06467451f, 0.42619413f, 0.13878635f, -0.01568778f, -0.10199731f, -0.17742832f, 
    0.10428951f, 0.03698250f, 0.00441529f, 0.10088719f, -0.37216178f, 0.08001498f, 0.42910928f, -0.04265781f, 
    -0.07731691f, 0.05257820f, -0.17042921f, -0.11076715f, 0.08725036f, -0.15111396f, 0.04908785f, -0.07065519f, 
    -0.40175518f, 0.17541881f, 0.10169445f, -0.15837368f, -0.10898525f, 0.02875576f, -0.07895488f, -0.03898509f, 
    -0.11834865f, -0.05377791f, 0.04159037f, -0.00018342f, 0.35792273f, -0.13250113f, 0.15273058f, 0.08043507f, 
    -0.03032232f, -0.02129744f, -0.01907335f, 0.04302161f, -0.15945610f, 0.13468559f, -0.20066211f, -0.03418639f, 
    0.08054585f, 0.05331341f, 0.12903561f, 0.02872549f, -0.01702349f, -0.19281510f, 0.20579630f, 0.06106997f, 
    -0.04306673f, 0.05497838f, -0.11566895f, -0.01202812f, -0.25429299f, -0.19623587f, -0.03522526f, 0.05911556f, 
    -0.25873125f, 0.04538759f, 0.03573941f, 0.04737115f, 0.03432007f, 0.08558802f, 0.10652868f, -0.10710955f, 
    -0.11973432f, 0.33082432f, -0.13725761f, 0.00969446f, 0.11845903f, -0.03208195f, -0.03571218f, 0.01215799f, 
    0.13125981f, 0.00939888f, 0.12906066f, -0.03809947f, 0.42615303f, -0.18840815f, -0.09736510f, 0.17589143f, 
    0.17055622f, 0.06602111f, 0.01601301f, 0.08177635f, 0.02383523f, 0.16463761f, 0.07728900f, -0.01369740f, 
    0.13001275f, 0.00853121f, 0.07276471f, 0.19705860f, 0.04860449f, 0.00825227f, 0.22724904f, 0.21024702f, 
    -0.09558765f, 0.01008319f, 0.21748134f, 0.05350082f, 0.59440130f, -0.14048666f, -0.04652061f, -0.17120375f, 
    0.02688477f, 0.14298084f, -0.17756060f, 0.09588255f, -0.08256879f, 0.13216762f, -0.00802476f, 0.02472454f, 
    0.29824188f, 0.21117499f, -0.05753585f, 0.01223062f, -0.18616655f, -0.05891261f, 0.03694621f, 0.06325068f, 
    -0.06093172f, -0.16875201f, 0.14133446f, 0.03283428f, -0.62405151f, -0.27506068f, 0.06872280f, 0.07959486f, 
    -0.12586753f, 0.24061479f, 0.14237027f, -0.19082190f, -0.07708429f, 0.07940947f, -0.01914310f, 0.09221078f, 
    -0.18434934f, -0.06729202f, 0.23637174f, 0.29314402f, -0.09989365f, -0.14307065f, 0.00152624f, 0.17449026f, 
    -0.29915845f, 0.01044362f, -0.03217699f, -0.09026957f, -0.51757026f, 0.38640863f, -0.00500547f, -0.11527089f, 
    -0.03035854f, -0.07356979f, 0.03539208f, 0.22909988f, 0.07069926f, 0.03715336f, 0.01649517f, 0.01757575f, 
    -0.04581599f, 0.00736907f, -0.17509013f, -0.35237491f, 0.18275635f, 0.10075969f, -0.12286331f, 0.03597162f, 
    0.07012661f, 0.03040728f, 0.04789981f, -0.25268960f, -0.55422217f, -0.15795861f, 0.11519956f, -0.01994475f, 
    0.02545867f, -0.02210947f, 0.11714371f, -0.10208035f, 0.08846975f, 0.07466514f, -0.00544553f, -0.02880884f, 
    -0.07608342f, -0.26747841f, 0.27776027f, 0.03716444f, -0.08042064f, -0.08563044f, 0.03387259f, 0.19271538f, 
    -0.08039296f, -0.05269617f, 0.01340427f, -0.06462030f, -0.11525391f, -0.00325805f, 0.13273036f, 0.18764783f, 
    -0.07610394f, 0.05053101f, 0.01319299f, -0.01564874f, -0.00813645f, 0.04358544f, 0.10746194f, 0.42163450f, 
    -0.12905018f, -0.05960730f, 0.16696618f, 0.21109711f, -0.11046702f, 0.03775746f, 0.03843663f, 0.11064953f, 
    0.12416659f, -0.06949043f, -0.15506208f, -0.19768757f, -0.31714508f, 0.13025264f, 0.06216489f, 0.26253244f, 
    0.14732833f, 0.03712601f, -0.15969519f, 0.15247568f, 0.15576771f, -0.13977088f, 0.12905388f, 0.14201863f, 
    -0.23131891f, -0.04671868f, 0.08279210f, 0.02790517f, 0.12701595f, 0.07072552f, -0.06003927f, 0.00110262f, 
    0.23113532f, -0.14993395f, 0.12268575f, 0.04882456f, 0.45826530f, 0.02558735f, -0.08344124f, -0.20890921f, 
    0.08575879f, 0.17474620f, -0.17297108f, -0.11320165f, -0.05239938f, -0.07315305f, -0.16083246f, 0.05151995f, 
    -0.03835862f, 0.17830755f, -0.01248693f, 0.07128355f, 0.08615456f, 0.11722445f, 0.00593995f, 0.04427682f, 
    0.08261409f, 0.03061364f, 0.02119031f, 0.03777429f, -0.10871757f, 0.02963017f, 0.14055137f, -0.13837619f, 
    0.00921891f, 0.02557113f, -0.10758836f, -0.13752988f, 0.03775697f, -0.04328709f, -0.16867007f, -0.00412337f, 
    0.06300491f, 0.11834412f, 0.24343407f, 0.15155959f, 0.31233960f, 0.13605061f, -0.07782266f, -0.01001200f, 
    -0.00673710f, -0.05804808f, -0.23041372f, -0.15818514f, 0.13418752f, -0.08453547f, 0.06796125f, 0.43968332f, 
    0.15331404f, -0.01965553f, 0.07806835f, 0.05030940f, 0.11633784f, 0.18554246f, -0.02788893f, 0.03112652f, 
    0.26724011f, 0.21185155f, 0.02961553f, 0.08903790f, 0.04006669f, 0.06208748f, -0.04590140f, -0.09567972f, 
    0.08851886f, 0.01567893f, 0.08029149f, -0.08484033f, 0.27469704f, 0.01463142f, -0.02290298f, 0.00334983f, 
    0.05564728f, 0.01140397f, 0.04485608f, 0.09201448f, 0.08675390f, -0.04610806f, 0.19813944f, -0.03859583f, 
    0.31708214f, -0.24311957f, 0.00575412f, 0.26060516f, -0.11810867f, 0.14702845f, -0.01544156f, -0.11067959f, 
    0.11073862f, 0.15203349f, -0.11152319f, 0.09937926f, 0.36458662f, -0.37956151f, 0.05598631f, -0.00157375f, 
    0.16126150f, -0.12173102f, 0.08134545f, 0.13902722f, 0.06726767f, 0.00960457f, 0.08599015f, 0.01040359f, 
    0.39333954f, -0.31179851f, -0.11050650f, -0.12612982f, 0.07490038f, 0.12226444f, -0.04960658f, 0.12806082f, 
    0.10136978f, 0.04532457f, -0.07364303f, -0.02568079f, -0.24506374f, 0.14359678f, -0.14236000f, 0.03761837f, 
    -0.05254683f, -0.11162645f, -0.01889283f, 0.05822306f, -0.05120285f, 0.00982640f, 0.04201373f, 0.07742737f, 
    0.11357986f, 0.08167301f, 0.17092448f, 0.26247445f, -0.09892693f, 0.21152875f, -0.20099422f, -0.13353272f, 
    -0.12060296f, -0.02055100f, 0.01344006f, 0.16035858f, -0.24800187f, 0.31606758f, -0.19293813f, -0.38270321f, 
    0.10020451f, 0.05057385f, 0.03282943f, -0.07434723f, -0.08700991f, 0.14914438f, 0.20234001f, 0.04237479f, 
    -0.34220576f, -0.07841323f, 0.05379153f, -0.17264265f, 0.21036497f, 0.05953632f, 0.00367891f, -0.00868762f, 
    0.05805660f, 0.01382561f, -0.01595952f, 0.08121996f, -0.04640576f, -0.06428944f, -0.17282249f, -0.03263093f, 
    -0.07824046f, 0.14324926f, -0.05612305f, -0.16288160f, -0.07054567f, -0.00501896f, -0.07939532f, -0.10919181f, 
    -0.24407041f, -0.21245500f, -0.04559046f, 0.08183127f, 0.10064551f, -0.12609160f, -0.01045486f, 0.22509126f, 
    -0.03820143f, 0.02512115f, 0.08916448f, 0.11050306f, -0.26139554f, 0.09889152f, 0.04577218f, -0.02677677f, 
    0.03315843f, -0.01423290f, 0.00504981f, -0.03972958f, 0.03064621f, -0.09057479f, 0.00399954f, -0.03501476f, 
    -0.06250791f, 0.09219841f, 0.12061722f, -0.34816074f, 0.24298275f, -0.01971124f, 0.03184439f, -0.05107186f, 
    0.03041445f, -0.03206326f, 0.17130421f, 0.03907209f, 0.23629664f, -0.00857220f, -0.00332251f, -0.02434313f, 
    0.05855513f, 0.15194699f, 0.04599790f, 0.16209398f, -0.13005118f, 0.03398064f, -0.06058823f, -0.02179154f, 
    0.14833958f, 0.27708417f, 0.05397940f, 0.31751236f, 0.07654726f, -0.08525160f, 0.02911817f, -0.00004953f, 
    -0.02324021f, 0.07437145f, -0.03579839f, 0.09307949f, 0.25457329f, 0.09224883f, 0.10921317f, 0.32521838f, 
    0.16242836f, 0.03838016f, 0.08809809f, -0.08702572f, -0.06839786f, 0.12160634f, 0.17023422f, -0.10151555f, 
    -0.04054477f, -0.08394621f, 0.11941411f, -0.20082316f, 0.04642619f, -0.07129830f, 0.07158067f, -0.00455018f, 
    -0.07820632f, 0.01331571f, -0.05209029f, 0.06150546f, -0.27162018f, 0.24077559f, 0.04374318f, 0.23827456f, 
    0.12677161f, -0.01078749f, 0.23358278f, -0.03910212f, -0.14640494f, -0.01283749f, 0.04920624f, -0.04843831f, 
    -0.13596116f, 0.24054688f, -0.30638707f, 0.03812413f, 0.06927279f, 0.00305375f, 0.19401601f, -0.04116850f, 
    0.05432311f, 0.04159435f, 0.05842828f, -0.07935047f, -0.15130280f, -0.13608244f, -0.20055373f, -0.02780618f, 
    -0.11068481f, 0.09259509f, 0.01660797f, -0.01605907f, 0.01145060f, 0.13520227f, 0.14783554f, -0.04466343f, 
    0.05873400f, -0.02371470f, 0.02523750f, 0.24713735f, 0.11613691f, -0.19879447f, -0.21117771f, 0.02806363f, 
    0.03738682f, -0.07238314f, 0.05604298f, -0.17864916f, -0.06692858f, 0.11767336f, 0.17897080f, 0.14644909f, 
    0.06019795f, 0.23628654f, -0.04919339f, 0.05797576f, -0.19116321f, -0.00528223f, -0.15629162f, 0.02641937f, 
    -0.08752221f, 0.06203271f, -0.02966460f, -0.34244829f, 0.16864038f, -0.16900906f, 0.12361697f, 0.04772760f, 
    0.08912131f, 0.21394253f, 0.06393186f, 0.03823441f, 0.15347469f, -0.03636990f, 0.10182315f, 0.21665882f, 
    0.08721361f, 0.02144776f, 0.05790990f, -0.04849142f, 0.04737764f, -0.03741375f, 0.00152999f, 0.16578177f, 
    0.40589771f, -0.04818450f, 0.21154973f, 0.18414739f, 0.02777600f, 0.12665316f, 0.11648881f, 0.15302470f, 
    0.19982769f, 0.02762530f, 0.20943862f, 0.10905576f, -0.02993486f, 0.15313885f, -0.04303285f, -0.02748426f, 
    0.08782118f, 0.02840064f, 0.00064836f, 0.09784065f, 0.01945857f, -0.13155228f, 0.22392775f, 0.09510518f, 
    -0.07594040f, 0.07214510f, -0.00031350f, 0.01317874f, -0.05804009f, 0.14244957f, 0.06498418f, -0.02649531f, 
    0.11377300f, -0.09567189f, 0.25676730f, -0.05287739f, 0.49972013f, 0.21451470f, 0.21024232f, 0.03859791f, 
    0.07570823f, -0.02822527f, 0.11874905f, 0.03942068f, -0.15168905f, -0.03633725f, -0.11851884f, -0.03613213f, 
    0.19474466f, -0.12581594f, 0.13337953f, 0.18998262f, 0.10579390f, 0.08859199f, 0.06864462f, 0.12134579f, 
    -0.04687888f, 0.04673779f, 0.12297140f, 0.10599748f, -0.13479377f, -0.12981965f, -0.01953779f, -0.16633758f, 
    0.02240336f, -0.02355645f, -0.14352627f, -0.11098496f, -0.00532473f, -0.15114915f, 0.06838737f, 0.02455579f, 
    -0.18212996f, -0.10368651f, -0.00424241f, -0.15870669f, -0.02940294f, 0.13355894f, -0.10483471f, -0.03330280f, 
    0.15620308f, -0.04167333f, -0.06202536f, -0.00026562f, -0.50332499f, 0.15403974f, -0.14493807f, -0.19974495f, 
    -0.23150688f, 0.04030075f, 0.07749401f, 0.16303287f, 0.17166938f, -0.20835966f, -0.09135528f, 0.08359858f, 
    -0.12249895f, 0.02452057f, 0.11967346f, -0.07060554f, 0.19243951f, 0.09018790f, -0.11160622f, 0.07754346f, 
    -0.03603065f, 0.19870049f, -0.06108756f, 0.07938131f, 0.24199659f, 0.26680741f, 0.18859246f, 0.16712141f, 
    0.03594480f, 0.09644239f, -0.05415126f, 0.05573149f, 0.28997582f, -0.04098294f, 0.13359255f, -0.02505971f, 
    -0.06345969f, 0.19645166f, 0.24763975f, 0.33936417f, -0.01796011f, -0.15970469f, -0.04125861f, 0.20219775f, 
    -0.00396980f, -0.09767429f, -0.09337487f, 0.17468460f, -0.66993070f, 0.49598399f, 0.25811842f, 0.07369069f, 
    0.16174529f, -0.01494112f, 0.19244300f, 0.12614600f, -0.08594054f, -0.15252160f, 0.00018032f, 0.10399713f, 
    -0.26701772f, -0.01465171f, -0.05024298f, -0.09135945f, 0.03987812f, 0.06747060f, 0.23349610f, -0.09907010f, 
    -0.05178080f, 0.14424999f, 0.11083799f, 0.06006178f, -0.02434239f, -0.05370644f, -0.09113393f, -0.09850032f, 
    0.07557324f, 0.05599521f, 0.12830471f, 0.11133847f, 0.07140312f, 0.05906451f, -0.03249014f, 0.01811632f, 
    -0.05812868f, 0.15978080f, -0.07757965f, 0.33299649f, -0.00001000f, -0.13172249f, 0.07433294f, -0.03730306f, 
    -0.01714663f, 0.02557588f, -0.00223872f, -0.08289299f, 0.21854535f, -0.04585911f, 0.22667296f, 0.13849533f, 
    -0.11910410f, 0.11243943f, -0.11501104f, 0.05592724f, 0.02028704f, -0.14901033f, -0.06775741f, -0.06056158f, 
    0.03490881f, 0.02431921f, -0.01553114f, -0.15161908f, -0.20284796f, 0.00953685f, -0.03672021f, 0.00234717f, 
    -0.03910428f, 0.08893289f, 0.17031235f, 0.11665671f, -0.21365620f, 0.21036291f, 0.01734009f, 0.12471748f, 
    0.21792898f, -0.00353478f, 0.06012157f, 0.00705662f, 0.06277021f, 0.20360978f, -0.01885519f, 0.09548570f, 
    -0.03603027f, -0.19792785f, -0.00278477f, 0.20349300f, 0.05392878f, 0.04982925f, 0.14469822f, 0.13671668f, 
    0.00746474f, 0.16241048f, -0.30167511f, 0.11984344f, -0.56907386f, -0.22364379f, 0.11377639f, 0.02963428f, 
    -0.21369478f, 0.11799917f, -0.07761526f, 0.08792369f, 0.11558333f, 0.01673281f, 0.12573792f, -0.06440874f, 
    -0.20421505f, 0.00446077f, 0.05739138f, -0.21222909f, -0.09062888f, 0.07451124f, -0.02246733f, 0.02825951f, 
    0.02832409f, 0.07874242f, 0.05262595f, 0.01354046f, -0.11787139f, 0.31926051f, 0.15669030f, 0.18384533f, 
    0.10915368f, -0.01486493f, 0.07734782f, 0.13271549f, 0.13003403f, 0.20367986f, -0.04459970f, 0.00002711f, 
    0.25932330f, -0.09917374f, 0.24151190f, -0.01656624f, 0.00613857f, 0.07171131f, 0.11109607f, 0.10289624f, 
    -0.09167167f, 0.10096446f, 0.20732071f, 0.25147450f, 0.22932214f, 0.08750521f, 0.28869703f, 0.06416135f, 
    0.04394290f, 0.00568134f, -0.11545604f, 0.07826924f, -0.21846806f, 0.00438349f, 0.06533460f, 0.07944339f, 
    0.18233018f, -0.05609125f, 0.12820649f, -0.33466384f, -0.02158631f, 0.03673121f, 0.20440707f, 0.00710130f, 
    -0.02741616f, -0.11445242f, 0.03095243f, 0.02459135f, 0.08598837f, -0.37751481f, -0.14235416f, 0.03576119f, 
    -0.11237180f, -0.14299418f, -0.07673827f, -0.02631995f, 0.03438656f, 0.04415121f, 0.02133462f, 0.13463601f, 
    0.04842113f, 0.04378118f, -0.00306343f, -0.05347063f, -0.02474502f, -0.06590144f, 0.04766709f, -0.01027761f, 
    -0.01195608f, -0.07677981f, 0.00613399f, -0.05605214f, -0.00886823f, 0.02774261f, -0.04559406f, 0.01281535f, 
    0.04084545f, 0.05520781f, -0.02184056f, -0.01464751f, 0.00768479f, -0.02928633f, -0.05019845f, 0.04845962f, 
    -0.04185931f, 0.02854167f, 0.02543142f, -0.06574988f, -0.07074460f, 0.00388100f, -0.00423871f, -0.06729431f, 
    0.00437428f, -0.07470555f, -0.00275305f, -0.01845548f, 0.03671842f, 0.01657079f, -0.06394142f, -0.05688599f, 
    -0.03618715f, 0.05491729f, -0.01135662f, -0.03300764f, 0.01138260f, -0.06927433f, -0.02772418f, 0.05681309f, 
    -0.02942744f, 0.06373098f, 0.01417245f, 0.00345905f, -0.03820949f, 0.02482129f, 0.02005249f, -0.04825384f, 
    -0.00185622f, 0.04919366f, 0.02443167f, -0.06398916f, -0.02116431f, 0.03713521f, -0.07846636f, 0.03167707f, 
    -0.06734206f, 0.03124772f, 0.07278035f, 0.01672012f, 0.04121264f, -0.02329734f, -0.07104293f, -0.07187201f, 
    0.02562453f, 0.02844850f, 0.03831873f, -0.05274393f, -0.07092453f, 0.04370560f, -0.04326170f, 0.04818182f, 
    -0.05877952f, -0.01495969f, 0.03525253f, -0.06954763f, 0.00334355f, -0.00209013f, -0.00890803f, -0.06328677f, 
    -0.03637154f, 0.00359365f, -0.05597601f, 0.03841529f, 0.00939781f, -0.00861431f, 0.00932032f, 0.01220129f, 
    0.05960471f, -0.07013810f, -0.00874549f, -0.07111729f, 0.05810429f, 0.00155434f, -0.07475026f, 0.04480704f, 
    -0.02373633f, -0.02523334f, 0.04124148f, -0.07081457f, -0.02622262f, -0.05555433f, 0.04799474f, -0.07712044f, 
    -0.01465078f, 0.02068329f, -0.01350297f, 0.01448739f, -0.01291741f, 0.02412078f, -0.05989100f, -0.00128553f, 
    0.01262974f, -0.02536428f, 0.02586669f, -0.00610069f, 0.04828995f, -0.05064144f, 0.01476333f, 0.01986525f, 
    -0.05170830f, 0.00578180f, -0.07280999f, 0.04291232f, -0.06886524f, 0.06307134f, 0.00505865f, 0.03061907f, 
    0.00004729f, -0.02595513f, -0.02067450f, 0.00940377f, -0.02941567f, -0.04852647f, 0.02187149f, 0.05317030f, 
    -0.02587979f, -0.02708830f, -0.06635968f, -0.04037066f, -0.08382275f, -0.01948007f, 0.02997355f, -0.02885676f, 
    0.00683107f, -0.00085593f, -0.03112691f, 0.02440856f, 0.01077342f, 0.03825856f, 0.05694146f, 0.00362541f, 
    -0.01030008f, -0.03644189f, -0.06807316f, -0.05661657f, -0.07262005f, -0.00338598f, 0.04356590f, 0.06186765f, 
    -0.00163225f, 0.07112596f, 0.06225448f, 0.06424594f, -0.03771032f, 0.03232640f, 0.00601293f, -0.03900135f, 
    0.04363246f, 0.01608039f, 0.00751222f, -0.02201580f, 0.06318894f, 0.05484820f, -0.06158899f, -0.05738392f, 
    0.03874447f, 0.01305743f, 0.02728773f, -0.06476285f, -0.00324476f, 0.04069507f, -0.06543583f, 0.03217033f, 
    -0.04592412f, 0.05592825f, 0.06138185f, 0.04690254f, 0.03442950f, -0.05639964f, 0.02877369f, -0.05291765f, 
    -0.02408265f, -0.07545555f, -0.03695454f, -0.06661705f, 0.00806830f, 0.01574163f, -0.04960032f, -0.04628316f, 
    0.05409254f, -0.06698817f, -0.03965275f, -0.07744272f, -0.01543107f, 0.02231123f, -0.05423445f, 0.03133490f, 
    -0.01356463f, -0.01930913f, 0.02400811f, -0.06618454f, -0.00743276f, -0.00077041f, -0.03352128f, -0.00244210f, 
    0.03086354f, -0.05748279f, 0.03818896f, 0.02309887f, 0.01851995f, 0.04008866f, 0.06257054f, 0.05987126f, 
    0.00685022f, 0.04272882f, 0.03382249f, -0.06626135f, 0.05839023f, -0.05681460f, 0.04065080f, -0.03227347f, 
    0.05785426f, 0.06152762f, 0.02125895f, -0.04122875f, 0.03378372f, 0.05877717f, 0.00992266f, 0.02254069f, 
    0.06214913f, 0.01870199f, 0.03598034f, -0.03828764f, -0.04208459f, -0.07365269f, -0.02347867f, -0.01332605f, 
    -0.01237753f, -0.00697848f, -0.06328177f, -0.02025991f, -0.04293992f, -0.01017209f, -0.00861483f, 0.02997866f, 
    0.03775227f, -0.06221488f, -0.05025763f, 0.03567592f, 0.00715471f, -0.02901738f, 0.02223110f, -0.07949872f, 
    -0.00122805f, -0.03409386f, 0.05200842f, -0.03857273f, 0.01091156f, -0.06777148f, 0.05297964f, -0.06971632f, 
    0.03468753f, -0.03728987f, 0.00198320f, -0.00794001f, 0.02771239f, 0.02267076f, -0.03514122f, 0.03163993f, 
    0.04540320f, 0.01461357f, -0.05118587f, -0.02037013f, 0.00420280f, -0.04523298f, 0.02620716f, -0.05557293f, 
    0.02690100f, -0.04815359f, -0.07897756f, 0.04049255f, -0.04378829f, 0.01278705f, 0.01940944f, 0.02630512f, 
    0.05257761f, 0.04176684f, -0.00835140f, -0.03528240f, 0.03602323f, -0.03726925f, 0.05292029f, 0.02460838f, 
    -0.00671752f, -0.05349533f, -0.01228753f, -0.03594972f, 0.01454087f, -0.03902394f, -0.03497136f, -0.07965666f, 
    -0.06239190f, -0.03056214f, -0.00995350f, -0.07309411f, 0.01590222f, -0.01731222f, 0.05526637f, -0.07881036f, 
    -0.01304657f, 0.02700691f, 0.02118465f, -0.01795609f, -0.07967333f, 0.02254086f, 0.03498110f, -0.05948669f, 
    -0.00727652f, -0.01149401f, -0.05724537f, 0.05952477f, -0.04699503f, 0.00664107f, 0.05207646f, 0.00505908f, 
    0.03131356f, -0.07243399f, 0.00428109f, -0.01396335f, 0.04715477f, -0.07953609f, -0.01909128f, -0.04070219f, 
    -0.03010758f, -0.04423737f, -0.05596553f, -0.05518520f, -0.06814333f, 0.03709634f, 0.01993216f, -0.01414057f, 
    -0.00521707f, -0.00800550f, -0.03262361f, -0.05113701f, 0.00256064f, -0.06270318f, 0.02706915f, 0.03574513f, 
    -0.01569467f, 0.04835128f, -0.05149086f, -0.06115018f, 0.04883485f, 0.01100397f, -0.04468047f, -0.06939797f, 
    0.05917305f, 0.04881851f, 0.01226969f, 0.02180585f, -0.02288582f, 0.00651479f, -0.03462039f, 0.03004562f, 
    -0.29052630f, 0.16690107f, 0.23416662f, 0.11870020f, 0.07940006f, -0.13204792f, -0.04318972f, 0.12772846f, 
    -0.27037030f, -0.01278341f, -0.12129508f, -0.14252724f, -0.60459656f, 0.31667778f, -0.01294850f, 0.15329099f, 
    0.05431867f, 0.07021891f, -0.00312849f, -0.12187875f, 0.08180512f, -0.03363869f, 0.00004773f, -0.00095774f, 
    -0.36785641f, -0.07323587f, -0.29322439f, -0.33497328f, 0.19579916f, 0.09564310f, 0.08264875f, -0.00207267f, 
    -0.01795775f, 0.07306161f, 0.07336601f, 0.09074301f, -0.22879048f, -0.18669884f, 0.05092882f, -0.20674624f, 
    0.06686652f, 0.12404712f, 0.00216545f, -0.14749490f, 0.11152435f, 0.10613368f, 0.07265218f, -0.03157157f, 
    -0.12469843f, -0.04875907f, 0.08918188f, 0.00738659f, 0.02924248f, 0.01826962f, 0.03155959f, 0.12880394f, 
    -0.05275203f, -0.05077350f, -0.01374497f, -0.10585546f, 0.12125573f, -0.05511291f, 0.52132285f, 0.42829594f, 
    -0.19033405f, 0.12452450f, 0.01975319f, -0.00990589f, 0.10074826f, -0.03009649f, 0.00296984f, 0.13076323f, 
    0.04874812f, 0.13050534f, 0.08218847f, 0.24511607f, -0.11823305f, -0.02140142f, 0.07065370f, 0.08219187f, 
    -0.05482429f, -0.04437971f, -0.06200087f, -0.11700354f, -0.42421404f, -0.12627447f, 0.04471991f, 0.03701230f, 
    0.26505268f, -0.06231377f, -0.05172265f, 0.15981661f, 0.06341340f, -0.03116193f, 0.11774562f, 0.10699560f, 
    0.04106738f, 0.12328876f, -0.00656537f, -0.01072469f, 0.03090748f, -0.02097600f, 0.08396311f, -0.06327111f, 
    0.05954521f, -0.09155042f, -0.19256736f, 0.06839979f, 0.39658794f, -0.16802947f, -0.03678395f, 0.07312960f, 
    -0.05512731f, 0.10103338f, -0.11065847f, -0.06503457f, -0.05274802f, 0.08433762f, 0.04001379f, 0.08241017f, 
    0.20429975f, 0.19167627f, 0.07800635f, 0.17768660f, -0.10078771f, 0.13893799f, -0.02557136f, -0.02540244f, 
    0.02664261f, 0.21318455f, -0.05638636f, 0.04835410f, -0.28238609f, -0.17058314f, -0.01605231f, -0.10613544f, 
    0.01401559f, -0.11049785f, 0.01439615f, -0.14682885f, 0.13403201f, 0.02621091f, -0.06186347f, 0.04284633f, 
    0.08247240f, -0.05412667f, 0.01014340f, 0.04045658f, 0.16529766f, 0.15762837f, 0.00050571f, 0.16329065f, 
    0.08747897f, 0.18587260f, -0.06807674f, 0.06415815f, -0.06213824f, -0.18297312f, 0.01815584f, -0.10216819f, 
    -0.02721682f, 0.04196525f, 0.02058812f, -0.01154491f, 0.03404425f, -0.02856780f, 0.00276732f, 0.06178506f, 
    0.46360597f, 0.31389499f, 0.03105243f, 0.31792307f, 0.04947438f, 0.07960253f, 0.09558897f, -0.09992487f, 
    0.05394150f, 0.06913206f, 0.07007009f, 0.05209168f, 0.36089662f, -0.16149534f, -0.00649599f, -0.00215660f, 
    -0.07229630f, 0.02915361f, -0.15269288f, 0.07828596f, 0.01217417f, -0.10466731f, 0.14110683f, 0.04775638f, 
    -0.05604278f, -0.16152246f, -0.04894752f, -0.10008770f, 0.18458836f, -0.01295086f, 0.06290070f, -0.13988334f, 
    -0.08894143f, 0.23066796f, 0.10457068f, -0.03323882f, 0.25619599f, -0.34700531f, 0.06555547f, -0.19752355f, 
    -0.05512244f, 0.07471918f, 0.00694503f, -0.04704491f, 0.05211311f, 0.09060676f, -0.09185392f, -0.09636085f, 
    0.07438605f, -0.10237032f, -0.06143280f, -0.06739287f, 0.17077126f, -0.04725119f, -0.10830022f, 0.21290593f, 
    0.02764403f, -0.05802439f, -0.08919764f, 0.18391061f, -0.01456943f, 0.13142879f, -0.04012236f, -0.16886634f, 
    0.03188698f, -0.11858686f, 0.00837583f, 0.09642605f, -0.14331163f, -0.00975164f, 0.06383868f, -0.09872496f, 
    -0.25598970f, -0.18313023f, 0.32880798f, -0.13974726f, 0.13262494f, 0.21407697f, -0.19194390f, -0.04044298f, 
    -0.07175561f, -0.08595156f, -0.00074445f, 0.13798611f, -0.23455609f, 0.13380215f, 0.13474695f, 0.03006021f, 
    -0.00464748f, -0.04844095f, -0.16188778f, -0.14320411f, -0.09888715f, -0.06213083f, 0.05606557f, -0.00565258f, 
    -0.24625225f, -0.07488665f, 0.10622229f, 0.29253075f, 0.03901727f, 0.00423990f, -0.02202228f, -0.00748588f, 
    0.03749983f, 0.01586124f, -0.09272416f, 0.02388580f, 0.35889786f, -0.38129869f, 0.01255035f, 0.13719925f, 
    -0.05832065f, -0.04567910f, -0.12162820f, 0.06251365f, -0.08418005f, 0.05752406f, -0.11987974f, -0.13981624f, 
    0.20315370f, 0.10595059f, 0.39229324f, -0.38295966f, -0.03834497f, -0.05198984f, -0.00540762f, 0.16450128f, 
    0.14524667f, 0.06840929f, 0.07363603f, 0.01924822f, 0.75639105f, 0.05243398f, -0.06326608f, -0.02790837f, 
    0.04495684f, -0.05268919f, 0.09337093f, 0.01470528f, -0.02402223f, 0.26491505f, 0.04978680f, 0.10830068f, 
    0.10256507f, 0.32864395f, -0.19638930f, 0.16582438f, 0.22688571f, 0.06860511f, -0.01191100f, -0.04967974f, 
    0.07349591f, 0.02144682f, 0.19161627f, -0.00217951f, 0.52324432f, -0.06996947f, -0.02330074f, 0.00736958f, 
    0.08779352f, 0.03590047f, 0.04315433f, 0.07769693f, -0.20195018f, 0.10457535f, -0.06895402f, 0.16342147f, 
    -0.07446145f, 0.21262245f, -0.25515682f, 0.34104854f, 0.06134256f, 0.06440160f, 0.04810596f, -0.05060357f, 
    -0.04656087f, 0.12276907f, 0.04310874f, 0.00167174f, 0.19173057f, 0.06281303f, -0.18612012f, 0.16237904f, 
    -0.05236122f, 0.04119490f, -0.08051556f, -0.10453999f, 0.05751212f, 0.08714917f, 0.06309947f, 0.12813176f, 
    0.11377127f, 0.19567961f, -0.00410197f, 0.32555968f, -0.00435089f, -0.09618091f, -0.01087254f, -0.07921722f, 
    0.05047734f, 0.08417480f, 0.00632565f, 0.24297430f, 0.20181601f, 0.17342527f, 0.12656358f, -0.13246429f, 
    -0.09651467f, 0.03125212f, 0.27306229f, -0.00963340f, -0.19467795f, -0.09563882f, 0.01577866f, -0.04855178f, 
    -0.06055882f, 0.04131418f, -0.04932728f, 0.00412201f, -0.02554778f, 0.03341760f, 0.03789245f, -0.08101813f, 
    -0.03081144f, -0.04318758f, -0.00485528f, 0.01564131f, -0.07213952f, -0.02724689f, 0.03639367f, 0.06164918f, 
    -0.03148822f, 0.04879995f, 0.02253932f, -0.02882874f, 0.03160652f, 0.06206306f, -0.00990782f, -0.07861772f, 
    -0.01481664f, 0.01553475f, -0.07578392f, -0.08133665f, -0.06371164f, -0.01093998f, 0.01794739f, -0.06037626f, 
    -0.00375019f, 0.01632315f, -0.04086385f, 0.03338952f, 0.05683663f, 0.02394180f, -0.00614976f, 0.03242393f, 
    0.04067714f, 0.00529821f, -0.02647564f, 0.03938003f, -0.07785020f, -0.01966820f, -0.03338192f, -0.01732289f, 
    -0.02345036f, -0.00846356f, -0.06508699f, -0.07363061f, 0.01722445f, 0.03429677f, 0.04023699f, -0.01822102f, 
    0.00473678f, 0.05240127f, -0.05368866f, 0.01193475f, -0.05007266f, -0.00005811f, 0.03816704f, 0.05448345f, 
    -0.03340247f, -0.04493073f, -0.00250569f, -0.07987561f, 0.04978760f, -0.01427229f, -0.02196896f, -0.04254862f, 
    0.00523322f, -0.07191764f, 0.04865946f, -0.02076007f, -0.06738231f, 0.04328408f, -0.03340518f, 0.02328246f, 
    -0.07352065f, 0.05408399f, -0.07184199f, 0.03985678f, -0.04217999f, -0.02981723f, 0.01330918f, -0.04596011f, 
    -0.05338920f, -0.02888498f, -0.06608331f, 0.05744705f, -0.03051938f, 0.05580802f, 0.01710282f, 0.00612755f, 
    -0.03734351f, 0.03676990f, -0.02648711f, 0.04397551f, -0.01538626f, -0.01401532f, -0.06616464f, 0.05996798f, 
    -0.06088126f, -0.00275848f, -0.06310148f, -0.04233557f, -0.07536090f, -0.02284099f, -0.05968108f, 0.02205294f, 
    -0.06622829f, -0.02975231f, 0.01403794f, 0.01605460f, 0.06137580f, -0.03383653f, -0.07515892f, -0.00774281f, 
    -0.01503480f, 0.05697762f, -0.06852993f, -0.03537757f, -0.05787427f, -0.03456526f, -0.00092860f, -0.06880978f, 
    -0.06990191f, -0.02430764f, 0.01405611f, 0.04180869f, 0.04610844f, 0.03732143f, 0.05151520f, -0.00311961f, 
    0.01995528f, -0.02302545f, -0.00534325f, 0.01677426f, -0.03247569f, -0.07584725f, 0.02403214f, -0.03483441f, 
    0.02167205f, 0.06358252f, 0.04257826f, -0.01823983f, 0.00238850f, -0.01043851f, 0.03593815f, 0.01044833f, 
    0.00403299f, 0.05204692f, -0.01463530f, -0.07290828f, -0.03043994f, -0.03557533f, 0.00466276f, 0.03425108f, 
    0.01903197f, -0.04239516f, 0.02382512f, -0.04736386f, -0.03939311f, -0.04800649f, -0.06412615f, -0.00095706f, 
    0.00796812f, -0.06927045f, 0.04336429f, -0.01223971f, 0.04525270f, 0.02838941f, -0.01030896f, 0.04472268f, 
    0.00998233f, -0.04702373f, -0.04123304f, -0.03547113f, 0.03346860f, -0.04628640f, 0.01105048f, -0.01855008f, 
    -0.05392716f, -0.02140966f, 0.01402211f, 0.03427666f, 0.05617595f, -0.07032225f, -0.06881716f, -0.02897463f, 
    0.04492837f, -0.06667557f, -0.01408477f, 0.01366660f, 0.04511448f, -0.02140130f, 0.01056828f, -0.02190563f, 
    0.02957778f, -0.03865677f, 0.03093684f, 0.00007115f, -0.03530203f, 0.02852349f, 0.03664986f, -0.01644198f, 
    0.05221216f, -0.01517632f, 0.03130597f, -0.04647963f, 0.03473343f, -0.06997210f, 0.03700189f, 0.02758640f, 
    -0.05715590f, -0.02602888f, -0.05861441f, 0.05264420f, -0.00753915f, 0.01832456f, -0.08191093f, 0.03406753f, 
    0.04137268f, -0.03659851f, -0.00111238f, 0.01086812f, -0.03972385f, -0.00890642f, -0.05682303f, -0.02892638f, 
    0.02120699f, 0.06652693f, -0.05858633f, -0.01894017f, -0.07822181f, 0.00573154f, -0.01642739f, -0.06304625f, 
    0.04914737f, 0.04282068f, 0.02792197f, 0.01314162f, -0.00308900f, -0.01645782f, -0.04222710f, 0.00074229f, 
    -0.03606797f, -0.04898328f, 0.05857498f, 0.04927709f, 0.01503210f, 0.02877897f, 0.05881081f, -0.06604691f, 
    -0.03738361f, -0.06223534f, 0.00779015f, 0.05411113f, 0.04939527f, -0.06894360f, -0.07953887f, -0.05451610f, 
    0.03543774f, -0.02892925f, 0.04546874f, 0.01565928f, -0.03807234f, 0.03127930f, -0.00219501f, 0.04755448f, 
    -0.06478716f, 0.05463351f, -0.08005293f, -0.05208569f, -0.04040541f, 0.02740598f, 0.03016679f, -0.06974296f, 
    -0.04056517f, -0.00630747f, -0.06418345f, 0.05314254f, -0.06151264f, -0.01938947f, 0.05614889f, -0.01081742f, 
    -0.05169742f, 0.00380234f, -0.05965825f, -0.00383853f, -0.00855074f, -0.04066782f, -0.02468380f, 0.00344311f, 
    -0.00310651f, -0.05683468f, -0.04670847f, 0.03688558f, 0.04554521f, -0.02025603f, -0.01731516f, -0.00852323f, 
    0.00747485f, 0.04476468f, -0.06165536f, -0.05164065f, 0.04717395f, -0.04775277f, -0.05323336f, -0.02445951f, 
    0.04632961f, 0.03185607f, -0.05505544f, -0.05548017f, -0.07324599f, -0.07085487f, -0.07406186f, -0.06761039f, 
    0.03262739f, -0.05052230f, 0.00582298f, -0.01044012f, 0.04730891f, 0.01811655f, -0.00753573f, -0.04076628f, 
    -0.01674837f, 0.05634870f, 0.00343706f, 0.02854617f, 0.04142717f, -0.02367888f, 0.01404788f, 0.02343290f, 
    0.01811771f, 0.05821051f, -0.01649509f, -0.04610492f, 0.01964214f, -0.02409960f, -0.00834656f, 0.01835921f, 
    0.02370519f, 0.05635099f, -0.07794461f, 0.04391690f, 0.03269074f, 0.00124427f, -0.05180046f, 0.04640505f, 
    0.04038240f, -0.05785102f, -0.05954986f, -0.00603162f, -0.02637931f, 0.03432063f, -0.02167719f, -0.03655195f, 
    -0.03105330f, 0.05099796f, -0.02166063f, -0.02631590f, -0.05735004f, -0.07296289f, -0.04308692f, -0.04491207f, 
    0.01264675f, -0.05158136f, -0.07357556f, -0.01933913f, 0.00889395f, -0.02381594f, -0.04054479f, 0.01357756f, 
    -0.02448168f, -0.00448578f, -0.07100979f, 0.00687054f, -0.00364562f, 0.04243890f, -0.07782973f, -0.01548849f, 
    0.14489849f, -0.48330975f, 0.04590841f, -0.04323968f, 0.01612522f, 0.02607884f, -0.04838859f, -0.05495889f, 
    -0.06810802f, -0.03781894f, -0.04017298f, 0.14311846f, 0.69922864f, -0.46732533f, 0.41026717f, 0.01151317f, 
    0.21702625f, 0.03355737f, -0.08050022f, -0.08154531f, 0.06681058f, -0.08404969f, 0.06870117f, -0.00668015f, 
    0.03384884f, 0.15887170f, 0.18661733f, -0.16239084f, 0.17321938f, 0.27070889f, 0.09128466f, -0.00547155f, 
    0.02372815f, 0.08112720f, 0.00623432f, 0.16764607f, -0.15563208f, -0.19577514f, -0.13460124f, 0.06381448f, 
    0.00930263f, -0.14992017f, 0.05566267f, -0.05148889f, 0.04376277f, 0.11613841f, 0.15654187f, 0.07918023f, 
    -0.13200365f, -0.22863656f, 0.18743758f, 0.18673651f, -0.07461315f, 0.14163072f, -0.20746580f, 0.01906594f, 
    -0.12782663f, -0.19398052f, 0.06047694f, 0.03697769f, -0.26061735f, 0.51799768f, -0.20619179f, -0.48562405f, 
    -0.11445482f, 0.00807530f, -0.04462575f, 0.02249240f, -0.01384606f, 0.10216304f, 0.02429634f, -0.15744163f, 
    -0.05743045f, 0.27339500f, -0.01742477f, -0.25790733f, 0.18012977f, -0.05803803f, -0.02198759f, -0.13266270f, 
    -0.22115055f, -0.01459388f, -0.09376461f, 0.02763009f, -0.03146489f, 0.00469866f, 0.22116135f, 0.18982776f, 
    -0.13759626f, -0.04484813f, -0.07479719f, -0.13858685f, 0.05173014f, 0.17325771f, -0.20665994f, -0.14025235f, 
    0.33332101f, -0.03494270f, 0.01702392f, 0.20303145f, 0.11487111f, -0.07007226f, 0.15947407f, 0.05784092f, 
    0.00827034f, 0.03670534f, -0.18063161f, -0.02878740f, -0.22501330f, 0.13718717f, 0.07002704f, 0.09297552f, 
    0.03764551f, 0.00397544f, 0.03839101f, 0.10087857f, 0.18472746f, 0.09103544f, 0.04568522f, -0.09741013f, 
    0.05074642f, 0.06032103f, 0.12834473f, -0.07550386f, 0.11392394f, -0.06164745f, 0.06172662f, 0.02880768f, 
    -0.04863328f, 0.00506037f, -0.04771042f, 0.04264446f, -0.10806675f, 0.20162919f, 0.05987547f, 0.06976400f, 
    0.07319357f, 0.03805066f, -0.03069736f, 0.12445436f, 0.13657844f, 0.08850710f, 0.02041916f, 0.00093777f, 
    0.30213502f, 0.32048291f, 0.07303571f, 0.08739666f, -0.00630483f, -0.25260201f, -0.05661542f, 0.00059615f, 
    0.05245902f, 0.20208107f, 0.04779121f, 0.16296928f, 0.24378692f, -0.09580597f, 0.08495604f, 0.20374681f, 
    0.16208149f, -0.00067213f, -0.08254522f, -0.26296836f, -0.11302652f, 0.07059404f, -0.00384848f, -0.14281775f, 
    0.30693316f, 0.11569287f, 0.10721636f, 0.04945652f, -0.05772335f, 0.02201445f, 0.05747245f, -0.04922972f, 
    -0.01255084f, -0.02538771f, -0.14895630f, 0.02401663f, 0.17360745f, 0.27139023f, -0.00544081f, -0.05768421f, 
    0.07586522f, 0.03154660f, 0.03276988f, -0.05751248f, -0.17748359f, 0.15603875f, -0.00896538f, 0.01995822f, 
    0.22666240f, 0.25811973f, -0.04848447f, -0.38796213f, -0.02284896f, 0.01182057f, -0.01332549f, 0.03802125f, 
    -0.11810281f, 0.07998037f, -0.09285806f, -0.00115505f, 0.12111949f, -0.42371598f, -0.33528256f, -0.14423920f, 
    -0.09581693f, 0.13629869f, -0.11168534f, -0.03076565f, 0.08714358f, 0.11423997f, 0.09057304f, 0.02953019f, 
    0.31785846f, -0.21355475f, 0.31282604f, 0.24869533f, -0.29791528f, 0.02452286f, -0.18178041f, 0.03967963f, 
    0.09137085f, -0.00888745f, 0.03674351f, -0.13174500f, -0.14677872f, 0.12119183f, -0.17865647f, 0.00578143f, 
    0.04333181f, 0.04216712f, -0.07789981f, 0.04134247f, 0.02179451f, 0.05830437f, -0.08546150f, -0.10085018f, 
    0.21322155f, -0.10971883f, 0.17960189f, -0.01161373f, 0.06867091f, 0.15791595f, 0.10348509f, 0.10633914f, 
    0.13282949f, 0.12208768f, -0.01154767f, 0.10595994f, -0.47449243f, -0.08520387f, 0.06979449f, -0.05842611f, 
    -0.01704815f, 0.09688595f, 0.06125616f, 0.11064629f, 0.10396113f, 0.19927828f, -0.00853816f, 0.19639014f, 
    0.08767442f, 0.00312930f, 0.31459025f, 0.18035516f, 0.26681733f, 0.18183163f, 0.18401909f, 0.11733646f, 
    0.08749423f, -0.07535308f, 0.13070366f, 0.08791331f, 0.26744300f, 0.38772884f, 0.47126997f, 0.02880450f, 
    -0.03698668f, 0.11434253f, 0.07432085f, 0.23872246f, -0.08479980f, -0.17984559f, 0.31943521f, 0.12588027f, 
    -0.47572336f, 0.35448596f, -0.18908334f, 0.41571763f, -0.04791760f, 0.07785314f, 0.00259765f, 0.14008684f, 
    -0.04732480f, 0.02910434f, 0.33381352f, -0.04260426f, 0.04734386f, -0.05738836f, 0.07970735f, 0.23051691f, 
    0.21674031f, -0.02872437f, 0.04711064f, -0.11355861f, -0.09470407f, -0.20574723f, -0.17664497f, 0.07809655f, 
    0.44277012f, -0.16339241f, 0.19451056f, 0.01159654f, -0.13708456f, 0.04383897f, -0.06131022f, 0.05991640f, 
    0.14073946f, -0.13108706f, 0.01888617f, -0.00833558f, -0.00263437f, -0.41474754f, 0.03668261f, -0.46211448f, 
    -0.03659155f, 0.10685464f, 0.02726142f, 0.01020656f, 0.01765303f, 0.03150490f, 0.07537095f, 0.11002108f, 
    -0.11164049f, -0.09343839f, 0.23719317f, -0.04882387f, -0.11860345f, -0.04676441f, -0.18988338f, -0.04480290f, 
    0.34518924f, -0.08757061f, -0.04012683f, -0.06876493f, -0.16736254f, -0.21222696f, 0.05993975f, -0.31969926f, 
    0.11181163f, -0.02736770f, 0.30868098f, -0.02017787f, 0.03856325f, -0.08949283f, -0.03894387f, -0.00726677f, 
    0.12850463f, -0.06215374f, 0.17862171f, 0.12592931f, 0.01510352f, -0.23167412f, -0.16502912f, 0.07977787f, 
    0.02702434f, 0.29751056f, -0.03909609f, 0.02098485f, -0.54291379f, -0.18254651f, 0.15826946f, 0.21094003f, 
    0.09210303f, 0.16909595f, -0.21096414f, 0.02677909f, 0.18560451f, -0.04915644f, 0.24544087f, -0.11832938f, 
    0.00339840f, -0.01945465f, 0.20918663f, 0.04729274f, 0.09504876f, 0.14239199f, -0.14673297f, 0.10154361f, 
    0.04843133f, 0.02994764f, 0.11623497f, -0.07785287f, 0.16061126f, 0.39345497f, 0.12219242f, 0.03559102f, 
    0.04428531f, -0.06628460f, -0.02013650f, 0.11764471f, 0.12244309f, -0.02344318f, -0.08991738f, 0.10812179f, 
    0.12886389f, 0.44606835f, 0.03742884f, -0.08024300f, -0.10785849f, 0.08730996f, 0.17724246f, 0.05657936f, 
    -0.13251792f, -0.01833025f, -0.10907409f, -0.00948804f, 0.44679722f, -0.20870064f, 0.01631276f, 0.01947307f, 
    0.01281277f, 0.04070189f, 0.08287107f, -0.03893235f, 0.08865645f, 0.06276472f, 0.06964038f, -0.09020366f, 
    0.12955549f, -0.12444974f, -0.08702026f, 0.10446472f, 0.01172643f, -0.01622478f, 0.07574711f, 0.02196900f, 
    0.13162066f, 0.01123565f, 0.07635794f, -0.00790591f, 0.14766073f, -0.28665102f, 0.03496877f, 0.25272951f, 
    0.12563933f, -0.09849809f, -0.09061030f, -0.10905360f, 0.02549488f, -0.01772458f, 0.02491354f, 0.03423315f, 
    -0.01149791f, -0.04471612f, -0.26618719f, -0.08306363f, 0.01966855f, 0.02014720f, -0.15871175f, -0.18138041f, 
    -0.11289012f, -0.00522836f, -0.09235556f, -0.07448761f, 0.29573545f, -0.14220718f, 0.19273837f, 0.04178753f, 
    0.06216126f, -0.06958649f, 0.01298277f, -0.03326335f, 0.01783923f, 0.14870337f, 0.09725873f, 0.09893272f, 
    0.24472024f, 0.49581313f, 0.05804785f, -0.18397015f, 0.10887907f, -0.06320493f, -0.03766881f, -0.01750184f, 
    0.12269889f, -0.07217236f, 0.02536003f, 0.09226681f, 0.11423668f, -0.04110247f, -0.38571775f, -0.23024724f, 
    -0.05585852f, 0.01591123f, 0.01959074f, -0.04827007f, 0.05156623f, 0.06941544f, 0.04120180f, 0.00694305f, 
    0.03819423f, 0.05682781f, -0.05956512f, 0.09698845f, -0.00498257f, 0.00676180f, -0.00801068f, -0.01529231f, 
    0.05983525f, 0.05905816f, 0.03552236f, 0.00620505f, -0.03468923f, 0.01897043f, 0.25533083f, 0.12575601f, 
    -0.02251858f, -0.12179971f, 0.13462351f, -0.13560800f, -0.05853974f, 0.03737057f, 0.09148338f, 0.00299431f, 
    0.11143522f, -0.08058719f, -0.06991209f, -0.11464459f, 0.11524808f, 0.09013392f, 0.09658130f, 0.18013404f, 
    -0.00406195f, -0.12494853f, 0.03444071f, -0.05393656f, 0.25563782f, -0.12963399f, 0.07376727f, 0.19197427f, 
    0.15405327f, 0.09477737f, -0.12386172f, -0.04753307f, 0.16462781f, 0.17544004f, -0.00074668f, 0.11504561f, 
    -0.01467598f, 0.00040774f, -0.22239520f, 0.23520325f, -0.15630689f, -0.08559635f, -0.00420584f, -0.08763372f, 
    0.03127924f, -0.06827763f, 0.24157286f, -0.08702425f, 0.10543145f, -0.20362818f, -0.29421666f, -0.33333090f, 
    0.08950382f, 0.15505464f, 0.03262562f, -0.05712778f, -0.06905311f, 0.07428902f, 0.01408507f, 0.08202993f, 
    0.04329173f, -0.01962723f, 0.03733900f, -0.03027647f, 0.02905503f, 0.03862971f, 0.07061547f, -0.05814362f, 
    -0.03328661f, -0.04428450f, -0.00923503f, 0.05189607f, -0.05548504f, 0.01303683f, -0.06604336f, 0.03278686f, 
    0.01786023f, 0.02813331f, 0.01871212f, -0.07798290f, -0.07714314f, -0.04280277f, 0.01508927f, -0.07439175f, 
    -0.00040538f, 0.00624951f, -0.05208597f, -0.03901252f, 0.03979373f, -0.07963070f, -0.08050244f, -0.00555431f, 
    -0.06574773f, -0.02845864f, -0.04115058f, 0.00875303f, 0.04185025f, -0.02021155f, 0.02187575f, 0.00997487f, 
    0.06260878f, -0.01741706f, -0.04656131f, 0.01904350f, -0.06263488f, -0.05178482f, 0.02203670f, -0.03335958f, 
    0.00977638f, 0.02647470f, -0.06773900f, 0.01896473f, -0.05831281f, 0.07155284f, -0.02970281f, -0.00511134f, 
    0.02449350f, 0.02341797f, -0.04872358f, -0.05402168f, 0.01945139f, 0.02429593f, 0.02194716f, 0.04458363f, 
    -0.02883091f, -0.07024116f, -0.06218816f, -0.06349774f, 0.03268459f, -0.07449168f, -0.00461842f, -0.09132693f, 
    -0.06291155f, -0.04692829f, -0.03240957f, -0.03826043f, -0.02720384f, -0.06249071f, -0.02146630f, 0.00413270f, 
    -0.04578242f, -0.00613190f, -0.08579563f, 0.02201359f, -0.03003441f, -0.02205965f, 0.07173966f, -0.01389510f, 
    0.04878052f, 0.02474351f, 0.03521575f, 0.06212716f, -0.05465608f, -0.00558304f, -0.01891599f, 0.02776448f, 
    -0.11055771f, -0.02010502f, 0.05530253f, -0.08751152f, 0.02115367f, -0.08328383f, 0.03675862f, -0.02305351f, 
    -0.08458365f, -0.05678390f, -0.09182698f, -0.02365359f, -0.07903270f, 0.00871091f, 0.00172863f, -0.04139879f, 
    0.02050285f, -0.01891566f, -0.01955440f, -0.00401116f, -0.03170142f, 0.03546158f, 0.04336477f, 0.02431518f, 
    -0.06194326f, 0.00018806f, 0.00911098f, 0.01571849f, -0.04817323f, -0.04202724f, 0.02888275f, -0.00435218f, 
    -0.05247867f, 0.04063948f, -0.07980628f, -0.04129924f, -0.02641146f, -0.03221668f, 0.06270225f, -0.02266262f, 
    0.03273435f, -0.05563399f, 0.00952784f, 0.03386215f, -0.07960144f, 0.04275441f, -0.00702754f, -0.05477297f, 
    0.06270187f, 0.01547628f, -0.04888860f, 0.06740975f, -0.03172318f, -0.00145891f, -0.02772026f, 0.06377386f, 
    0.03650762f, -0.01305095f, -0.02165507f, -0.04590326f, 0.03694215f, -0.07932086f, 0.06381018f, 0.03574316f, 
    -0.06008958f, -0.04912876f, -0.04891242f, 0.05389944f, 0.02364713f, 0.02509663f, 0.02476098f, -0.04732150f, 
    0.06837729f, -0.02133597f, -0.06142307f, 0.03548620f, -0.01677062f, -0.05585896f, -0.06631213f, -0.01595008f, 
    0.04589637f, -0.06378971f, 0.04396677f, -0.04806236f, -0.01093846f, 0.03131251f, 0.02668525f, -0.07146353f, 
    -0.02489148f, -0.06461331f, 0.03129654f, 0.04092872f, -0.00897312f, -0.01007751f, 0.00966573f, -0.09286904f, 
    -0.25384998f, 0.08302948f, 0.02173520f, -0.23761414f, 0.04747088f, 0.07439619f, 0.05589387f, 0.04500183f, 
    -0.04592402f, 0.10830145f, 0.03450255f, -0.07502957f, 0.29419774f, -0.08900104f, -0.16357462f, 0.16419116f, 
    -0.07082726f, 0.09418549f, -0.03521734f, -0.06572011f, 0.10645784f, -0.01026595f, -0.03661595f, 0.04933034f, 
    0.27571607f, -0.02340665f, -0.27327830f, -0.29488868f, 0.20671801f, 0.03594591f, -0.01282483f, 0.14002374f, 
    0.04520984f, -0.07182433f, -0.00717122f, 0.10634890f, -0.07914005f, -0.26624772f, 0.11406013f, 0.00753640f, 
    -0.11107039f, -0.11509760f, -0.02644887f, -0.12768330f, -0.03270594f, 0.06083178f, 0.05266083f, -0.09900688f, 
    0.22517398f, 0.06315975f, 0.37612906f, -0.45343494f, 0.00123217f, 0.10929632f, 0.01750506f, 0.23320113f, 
    -0.04174056f, -0.06636531f, 0.08912043f, 0.11952339f, 0.32335794f, 0.06878666f, 0.11152443f, 0.09632785f, 
    -0.13809769f, -0.04121763f, 0.14776781f, -0.03866180f, 0.05280844f, 0.09386326f, 0.02276901f, -0.04034295f, 
    0.14804274f, 0.08929835f, -0.07099468f, 0.27465877f, -0.11209853f, -0.07235432f, 0.03252769f, 0.06011835f, 
    -0.12857823f, 0.02898885f, -0.10833412f, 0.04322997f, -0.05466570f, -0.24848054f, -0.00226267f, -0.07840440f, 
    -0.03767017f, 0.03360912f, -0.01946187f, 0.03666668f, -0.02917041f, -0.10584804f, 0.13870808f, -0.08112000f, 
    0.14425275f, 0.16368870f, -0.06155866f, -0.34566775f, -0.06755740f, 0.18653475f, -0.07106236f, 0.01603870f, 
    0.12019957f, 0.03228955f, 0.12862597f, -0.02599165f, 0.46042293f, -0.03885058f, 0.02113068f, 0.02291024f, 
    0.21959680f, -0.19616681f, -0.07860669f, -0.01589101f, 0.05803555f, 0.07230446f, -0.00339322f, 0.07036059f, 
    0.22369374f, -0.00152818f, -0.05812037f, 0.35071594f, -0.06515574f, 0.05917039f, -0.10742955f, 0.02844712f, 
    -0.00529076f, 0.06400076f, 0.02075830f, 0.02227728f, -0.04917252f, 0.04475471f, -0.00602945f, -0.03251173f, 
    0.02508822f, 0.05411989f, -0.00615525f, -0.08718225f, -0.04461648f, -0.00337769f, -0.00935180f, 0.03108459f, 
    -0.06399415f, 0.15311398f, -0.12188896f, 0.09953526f, 0.06941658f, 0.07780614f, -0.11471502f, 0.01931721f, 
    0.04195425f, 0.09943528f, -0.19422463f, -0.10510055f, -0.33282599f, 0.05241419f, -0.08260629f, 0.08374926f, 
    0.08356287f, 0.01249616f, 0.16224924f, -0.06756216f, 0.18578456f, 0.08736610f, 0.11898180f, 0.00590260f, 
    0.09922847f, 0.13973954f, -0.04537367f, 0.40146461f, -0.00453782f, 0.02557809f, -0.04117247f, -0.01184550f, 
    0.01448079f, 0.10290913f, -0.00498329f, 0.07383689f, 0.29517439f, 0.16513431f, 0.12356692f, -0.12894338f, 
    -0.01561058f, -0.23108609f, -0.09538518f, 0.01347641f, -0.07639237f, 0.01019413f, -0.05869710f, 0.08092125f, 
    -0.03741938f, 0.03125364f, 0.04351953f, -0.03509180f, -0.07913468f, -0.03474589f, 0.04128935f, 0.05333798f, 
    -0.02940920f, -0.05624539f, -0.05057892f, 0.00520938f, -0.01798328f, -0.06543801f, 0.03564296f, -0.06412523f, 
    0.02139215f, -0.05592983f, -0.06128789f, 0.04946046f, -0.04951512f, -0.00198797f, -0.03695161f, -0.00540029f, 
    0.04383506f, -0.04014646f, 0.01920595f, -0.03283627f, 0.06443758f, 0.02339340f, -0.03808995f, -0.01154575f, 
    -0.00896549f, -0.03111762f, 0.02562682f, -0.07507490f, -0.04039503f, 0.04499715f, -0.05554076f, 0.04592465f, 
    -0.04071747f, -0.03786057f, 0.06484425f, 0.03809309f, 0.05661349f, -0.05364906f, 0.00735247f, -0.07709515f, 
    -0.03961332f, -0.06629897f, -0.02225472f, -0.01401161f, -0.06427913f, 0.05600524f, -0.07304968f, 0.05231312f, 
    0.02564534f, -0.05260123f, 0.05312693f, -0.01114745f, -0.03565663f, 0.03789442f, -0.05003899f, 0.01929317f, 
    0.05634328f, 0.01347402f, -0.01555217f, -0.02303247f, -0.07101338f, -0.02561229f, 0.05613940f, 0.04224467f, 
    0.03303204f, 0.01673429f, -0.02221597f, -0.04695653f, -0.07438882f, -0.00730971f, -0.02875507f, 0.02956628f, 
    -0.06715623f, -0.00945330f, 0.04160445f, 0.03758078f, -0.05948756f, 0.03960574f, 0.06077001f, -0.04594402f, 
    0.04439167f, -0.03733642f, -0.05231694f, -0.05136836f, -0.05907080f, 0.00265333f, 0.04345313f, 0.04283260f, 
    -0.00959283f, -0.03448000f, -0.04932345f, 0.03160010f, -0.05402071f, -0.06941701f, -0.05902750f, -0.03519922f, 
    -0.02970925f, -0.00260878f, -0.04965838f, -0.02299848f, -0.03435962f, -0.06872702f, -0.00441470f, 0.02001044f, 
    -0.03046818f, -0.07504797f, 0.01215650f, -0.05363428f, 0.02042635f, -0.02702574f, -0.07566342f, 0.06032171f, 
    0.01949120f, 0.05620379f, 0.03831106f, -0.07462943f, 0.02109231f, -0.06911139f, 0.03676540f, 0.00082833f, 
    -0.06305652f, -0.00381857f, -0.07362837f, 0.02429007f, 0.00313243f, 0.03978624f, -0.02343239f, 0.02989962f, 
    0.04608641f, 0.04677282f, 0.02660230f, -0.00637500f, 0.06340287f, -0.05527670f, -0.00534651f, -0.03007414f, 
    0.01645125f, 0.04621636f, -0.03702769f, 0.03534089f, -0.05670810f, -0.03935394f, -0.02609271f, 0.00696948f, 
    -0.01952218f, -0.02075722f, 0.02397073f, 0.05208208f, -0.07461581f, 0.05462716f, -0.00644528f, 0.06299115f, 
    -0.02422216f, 0.02063775f, 0.01127955f, -0.05461531f, -0.01309845f, 0.04123307f, -0.00397387f, 0.06210438f, 
    0.01823343f, -0.01874706f, -0.01244970f, -0.06988715f, -0.02034264f, -0.06094421f, -0.04342884f, 0.05013416f, 
    -0.04247561f, -0.07949843f, -0.07874837f, 0.00852950f, -0.02062380f, 0.00263050f, 0.03426951f, 0.05066064f, 
    -0.01178232f, -0.00016552f, 0.00410753f, -0.02398051f, -0.03149194f, 0.02169419f, 0.01155531f, -0.05580449f, 
    0.09198917f, -0.01814595f, -0.10696679f, 0.31431800f, 0.06185405f, -0.13996202f, 0.04629144f, -0.00455281f, 
    -0.00578270f, 0.04584136f, -0.05187484f, 0.12701482f, -0.39117312f, -0.02269011f, 0.22893953f, -0.08018755f, 
    0.10660741f, -0.05915960f, 0.11696564f, 0.10574061f, -0.15064211f, -0.09035944f, -0.00368738f, 0.03946434f, 
    -0.41755378f, -0.23577507f, 0.09815105f, 0.24860682f, 0.15521806f, -0.00892841f, -0.05211411f, 0.02161782f, 
    0.00167853f, 0.02880438f, 0.04371889f, -0.07340435f, -0.30042002f, 0.38085246f, -0.11440294f, -0.17163296f, 
    0.14926392f, 0.13543652f, -0.00826222f, 0.12031130f, 0.02163151f, -0.02914346f, 0.01374132f, 0.13220046f, 
    -0.27376872f, -0.04242573f, -0.16927016f, 0.48181704f, -0.08210293f, -0.08876372f, -0.02582932f, -0.02426417f, 
    -0.01210862f, 0.08523257f, 0.11351111f, -0.05204547f, -0.27060017f, 0.24907939f, -0.07935229f, -0.09660567f, 
    -0.02641269f, 0.02216963f, -0.11179802f, 0.11483736f, -0.06819298f, -0.01133642f, 0.10990638f, 0.02754422f, 
    -0.18759748f, 0.15203081f, 0.10324794f, -0.09608043f, 0.05046901f, -0.03824867f, 0.03341208f, 0.12570566f, 
    0.12726270f, -0.03061380f, 0.07729466f, -0.00198042f, -0.22432306f, 0.33460322f, -0.06340863f, 0.23142274f, 
    0.08431166f, 0.04614070f, 0.11601758f, -0.02592146f, 0.05479775f, 0.13412842f, -0.17043088f, -0.05690354f, 
    -0.08326156f, -0.39151862f, 0.15719438f, 0.22452778f, 0.09881180f, -0.03577709f, 0.05144911f, 0.04771468f, 
    -0.03915432f, 0.09069155f, -0.07650451f, 0.03705521f, -0.18329661f, 0.12013689f, 0.18565187f, 0.05753388f, 
    -0.04444341f, 0.26413250f, 0.01070797f, 0.03504089f, 0.07669887f, 0.06202098f, -0.01971030f, -0.10462473f, 
    -0.15959728f, 0.21320812f, -0.08667634f, -0.23429076f, 0.20208539f, -0.05329950f, 0.07448684f, 0.03809323f, 
    -0.00034608f, -0.02586046f, 0.03165461f, 0.02195232f, 0.25187525f, 0.21918564f, -0.15399598f, 0.11941087f, 
    0.05865384f, 0.07593321f, -0.02576659f, 0.20133078f, -0.02080486f, 0.09516387f, -0.06524002f, 0.06677545f, 
    0.13571474f, -0.06457538f, 0.18864109f, 0.03904682f, 0.00914876f, 0.09664588f, 0.14150384f, 0.02110811f, 
    -0.18020375f, 0.17323852f, 0.13443428f, 0.12842755f, 0.47558513f, -0.00229601f, 0.11655007f, -0.01474671f, 
    -0.03320859f, 0.04692522f, -0.03969774f, 0.10747327f, -0.27330023f, -0.11120002f, -0.07317120f, 0.08088751f, 
    0.07736030f, 0.01979443f, -0.02936058f, -0.37909877f, 0.15613453f, -0.03429686f, 0.06753296f, 0.05431600f, 
    -0.09326667f, -0.07150596f, -0.01742042f, 0.00104146f, 0.09107497f, -0.08181547f, -0.03620186f, -0.00755645f, 
    -0.03452936f, 0.00046902f, 0.15741064f, -0.05010848f, -0.01825462f, -0.05357663f, 0.18837768f, -0.11319571f, 
    0.21867189f, -0.11311758f, 0.12267050f, 0.02230656f, 0.12156720f, 0.10542596f, 0.03487168f, -0.02676424f, 
    0.22932069f, 0.07583459f, 0.10022403f, -0.09224278f, 0.17086452f, 0.15207905f, 0.30362543f, -0.06689864f, 
    0.08570395f, -0.03015352f, 0.12055605f, -0.01484010f, 0.05422153f, 0.18062633f, -0.11829829f, -0.02529082f, 
    -0.04373706f, 0.22862822f, 0.24474885f, 0.17436005f, -0.12302346f, -0.04063306f, 0.00776246f, -0.01821089f, 
    -0.13953781f, 0.10075711f, 0.02286734f, 0.01079184f, 0.60718101f, 0.06116518f, 0.17004365f, 0.21677494f, 
    0.05491751f, 0.17635472f, -0.02105043f, 0.01893911f, -0.00709885f, 0.00479256f, 0.05195833f, -0.11725596f, 
    -0.18129000f, 0.29113013f, -0.27165490f, 0.04507425f, 0.05701637f, 0.16840369f, -0.06603145f, -0.19350870f, 
    0.06980144f, 0.05349348f, -0.07083321f, -0.11558878f, 0.12578584f, -0.39977610f, -0.17951918f, 0.19710241f, 
    0.21579053f, 0.18203877f, 0.01160940f, -0.08404841f, -0.13789193f, -0.08335993f, 0.11095697f, -0.17856732f, 
    -0.05558109f, -0.14118947f, -0.07168975f, -0.02694066f, 0.00580053f, 0.09521992f, -0.04492637f, -0.06470296f, 
    0.02455610f, 0.12065282f, 0.00346330f, -0.00569772f, 0.53998357f, -0.19623908f, 0.08291143f, -0.15982522f, 
    -0.22829007f, -0.08318995f, -0.13011293f, -0.03161417f, -0.01306653f, -0.03450185f, 0.07249437f, 0.17496406f, 
    0.10458070f, 0.42968524f, 0.06638715f, -0.02033513f, 0.11431824f, -0.01899233f, -0.12016858f, 0.05909229f, 
    -0.04657149f, -0.10960904f, 0.03117816f, 0.04460854f, -0.00437968f, -0.03399016f, -0.16801119f, -0.06500466f, 
    -0.16807432f, -0.15602839f, -0.03700172f, 0.01133701f, -0.05907394f, 0.17582123f, 0.09962457f, 0.01105286f, 
    -0.22993670f, -0.01615036f, 0.13707581f, -0.01070092f, -0.00953742f, 0.05213235f, 0.01802309f, -0.04763288f, 
    0.06580231f, 0.04634682f, 0.13558888f, -0.00596610f, 0.28892404f, -0.24230047f, 0.25291294f, -0.03633229f, 
    0.05790010f, 0.01274370f, 0.11210385f, -0.03560808f, -0.09101509f, -0.03590240f, -0.09038167f, -0.06235083f, 
    -0.24476410f, -0.03037766f, -0.23222965f, 0.08631390f, -0.02763388f, 0.01779599f, 0.08894292f, 0.15431844f, 
    -0.06259661f, -0.02707420f, 0.17403515f, 0.01607104f, 0.29571769f, 0.09302379f, 0.13069947f, -0.08529571f, 
    0.00820919f, -0.05506154f, -0.08629715f, 0.10612492f, 0.10539522f, 0.01250116f, -0.04259999f, 0.09829619f, 
    -0.41582057f, -0.18282218f, 0.38966429f, 0.01412044f, -0.04039857f, 0.03996098f, 0.11873423f, -0.05704368f, 
    0.00771721f, -0.01346553f, 0.18060526f, -0.04017256f, -0.34222019f, 0.11236430f, -0.22307721f, 0.00780166f, 
    0.01614115f, 0.04225209f, 0.28572267f, 0.12633587f, -0.06814855f, 0.04423291f, -0.01367076f, 0.00787904f, 
    -0.06584912f, 0.01441642f, -0.04903624f, -0.08259825f, -0.02675863f, -0.04797227f, -0.01463221f, -0.01844946f, 
    0.02734502f, -0.03422590f, -0.03653169f, 0.05003349f, 0.05269006f, 0.03296121f, -0.02053478f, 0.06086050f, 
    0.06372425f, -0.05085489f, -0.04496408f, -0.02201207f, -0.05717973f, -0.00196265f, -0.03043133f, 0.00855802f, 
    -0.00106354f, 0.05374908f, -0.02982851f, -0.00736336f, -0.04083215f, 0.05183383f, -0.03422421f, -0.06757063f, 
    -0.01320693f, -0.07048923f, -0.03172422f, 0.02229621f, -0.07911423f, -0.00369411f, 0.04506982f, -0.02288838f, 
    -0.03001189f, -0.01503785f, 0.02574221f, -0.00319254f, 0.04865248f, -0.06834737f, -0.04620135f, -0.03344705f, 
    0.04622605f, 0.02507444f, -0.00921474f, 0.03899134f, 0.01883950f, -0.02015192f, -0.06970396f, -0.06066364f, 
    -0.06865595f, -0.02767359f, 0.04377615f, 0.04297347f, 0.00141371f, 0.03819314f, 0.05904920f, -0.00306904f, 
    0.04687363f, 0.04860667f, 0.01951417f, 0.04816120f, -0.03427533f, -0.07409967f, -0.06151712f, -0.04393531f, 
    -0.00202564f, 0.00470326f, -0.00217945f, -0.07385616f, 0.03025758f, -0.05580172f, 0.00883189f, 0.03164986f, 
    0.02206925f, -0.06897060f, 0.06672455f, -0.03786889f, 0.06578963f, -0.03745989f, 0.04068412f, 0.03085773f, 
    -0.06399841f, 0.03649916f, -0.07486017f, 0.01304441f, -0.04110013f, 0.04157448f, -0.04772374f, 0.01185811f, 
    0.02310978f, -0.01078401f, -0.04643961f, 0.00090043f, 0.05622081f, -0.05826735f, 0.05766372f, -0.05353710f, 
    -0.05591170f, 0.01148781f, -0.00758458f, -0.06194311f, 0.07236955f, -0.05756089f, 0.05656079f, 0.05792890f, 
    -0.05765112f, -0.06963617f, 0.05150053f, -0.03485055f, -0.05354583f, -0.04965309f, 0.02134657f, -0.06238145f, 
    0.03591402f, 0.03949897f, -0.04702695f, 0.03695633f, -0.04651610f, -0.06485991f, -0.00965950f, -0.04680729f, 
    0.06530028f, -0.00016005f, 0.05311097f, 0.03804064f, -0.06835756f, -0.00243179f, -0.06503854f, -0.05783195f, 
    -0.07159084f, -0.06093521f, -0.06405985f, -0.00269015f, 0.00251503f, 0.02018538f, 0.04874748f, 0.02417362f, 
    -0.06650157f, -0.03698486f, -0.06443319f, -0.03360999f, 0.04624455f, 0.00265650f, -0.01558533f, 0.01477687f, 
    0.04656149f, -0.01983344f, 0.01070046f, 0.01394223f, -0.01898414f, 0.03587825f, -0.06679202f, -0.06904999f, 
    -0.04622128f, -0.05088287f, 0.06215267f, -0.06475220f, -0.01208263f, -0.04583709f, 0.03279965f, 0.05718632f, 
    -0.03430976f, -0.02890461f, -0.07734077f, -0.01044308f, -0.04770670f, 0.04532030f, 0.00424967f, 0.06378853f, 
    0.02133821f, -0.03888931f, 0.00877626f, 0.01724257f, -0.03534865f, -0.02883735f, -0.04877151f, -0.00983980f, 
    -0.05766492f, -0.03223216f, -0.01260595f, 0.04676704f, 0.04412813f, -0.04858102f, 0.03317329f, 0.06474307f, 
    0.01563087f, 0.02112544f, -0.07030734f, -0.01799221f, -0.03270518f, -0.01145327f, 0.02023088f, -0.07366292f, 
    0.08438159f, -0.09360836f, 0.05330224f, 0.03048358f, 0.05037400f, -0.04903859f, 0.03499452f, -0.11324618f, 
    -0.09629437f, -0.04366637f, -0.02368604f, 0.04980656f, -0.05963204f, -0.01298244f, 0.00114916f, -0.06163689f, 
    0.03766798f, 0.04353308f, 0.02342781f, -0.05671659f, 0.01579319f, -0.05119897f, -0.06543474f, -0.05305135f, 
    0.02106251f, 0.01901219f, 0.02860190f, -0.06990616f, 0.04228058f, -0.03864576f, -0.05326660f, -0.10563070f, 
    -0.10421651f, -0.02199842f, 0.01512551f, 0.04199527f, -0.02386411f, -0.07252263f, 0.04911274f, -0.00692943f, 
    0.01829600f, 0.00681551f, -0.02518978f, -0.02935306f, -0.04999461f, -0.06311423f, -0.06227111f, -0.03730529f, 
    -0.06255955f, -0.00336039f, -0.05580601f, -0.03065195f, 0.04769960f, 0.04049245f, 0.01507125f, -0.09325696f, 
    -0.07374527f, -0.02805572f, -0.07223273f, -0.08162557f, -0.00756795f, 0.01983602f, -0.01774767f, 0.05058017f, 
    0.00560017f, -0.01905597f, -0.04467912f, 0.02682034f, -0.06253935f, -0.09026426f, -0.07971654f, 0.02834326f, 
    0.06064230f, -0.04811399f, -0.04532769f, -0.05795972f, -0.03774136f, 0.05136763f, 0.02659623f, 0.06707993f, 
    0.01848765f, -0.00768784f, -0.01373796f, 0.02008216f, -0.07011866f, -0.02389749f, 0.07310680f, -0.05928667f, 
    0.06412889f, -0.06090622f, 0.04561815f, 0.03607406f, -0.06772424f, -0.02889385f, -0.03657031f, 0.00987530f, 
    -0.06420865f, -0.03287825f, 0.03136858f, -0.07511345f, -0.05789657f, -0.03640935f, 0.03503595f, -0.03822127f, 
    -0.00999111f, -0.08769234f, 0.03736653f, -0.06789200f, -0.04227742f, 0.06290925f, 0.02398768f, -0.05465571f, 
    -0.01155958f, 0.01904556f, -0.00328229f, 0.02592386f, -0.10395662f, -0.09644368f, -0.04032275f, -0.06982794f, 
    -0.09531090f, -0.04511442f, -0.04021522f, 0.03313571f, 0.02690425f, -0.00530609f, -0.02278044f, 0.02640076f, 
    0.01173075f, 0.01333741f, -0.03807458f, 0.02977832f, 0.01291901f, 0.00943372f, -0.03641887f, -0.05151645f, 
    -0.00044835f, -0.06846809f, -0.04268957f, -0.07611188f, -0.05273902f, -0.03632584f, 0.00373812f, -0.08873145f, 
    -0.06181417f, -0.00091543f, -0.04133960f, 0.05142292f, 0.03538131f, -0.04442740f, -0.00010657f, -0.01689689f, 
    -0.01510871f, 0.04862626f, 0.00916027f, 0.05918097f, -0.07621446f, -0.04031131f, 0.01370821f, 0.01250163f, 
    -0.06201686f, 0.02258237f, -0.04774237f, -0.01627224f, -0.08544673f, -0.02183887f, -0.04933462f, -0.01596935f, 
    -0.04743610f, -0.07642487f, -0.08010200f, -0.04456545f, -0.07701588f, 0.03637873f, -0.01480592f, -0.03700090f, 
    0.03679616f, -0.04245798f, -0.00428247f, -0.04723120f, 0.01013547f, -0.04200292f, -0.02075210f, 0.05749599f, 
    0.03340645f, 0.31345192f, -0.02977881f, 0.01684831f, -0.00289228f, 0.17494154f, 0.17508265f, 0.04472799f, 
    -0.01096521f, 0.04144596f, 0.09918321f, 0.12565151f, 0.49002895f, -0.08624266f, -0.19845665f, 0.45800203f, 
    0.14264899f, -0.04968499f, -0.04112529f, -0.05371981f, -0.00250715f, -0.09479588f, 0.12404475f, 0.12328184f, 
    -0.00906274f, -0.14218135f, -0.45223671f, -0.43072325f, 0.08547997f, -0.00114771f, 0.11425477f, 0.29479557f, 
    0.03652569f, 0.00668894f, 0.04656537f, 0.27828240f, 0.33322197f, -0.26429111f, 0.17019548f, -0.06349130f, 
    -0.23252322f, -0.02466529f, -0.00017033f, 0.19228588f, 0.03740176f, 0.14924023f, 0.13655126f, 0.04868824f, 
    0.30132776f, 0.22475243f, 0.08433161f, -0.33069634f, 0.14066789f, 0.10121329f, 0.01376211f, 0.12155383f, 
    0.11734903f, 0.01833960f, 0.26144028f, 0.37481737f, 0.70371687f, 0.29016453f, 0.35256469f, 0.04046087f, 
    0.15325823f, 0.05544218f, 0.18425333f, -0.00351964f, -0.01717918f, -0.14459419f, 0.05896537f, -0.09145031f, 
    0.37190768f, 0.14031336f, -0.00665390f, 0.16856740f, -0.01095330f, -0.07215444f, -0.01890200f, 0.10386588f, 
    -0.02892437f, 0.21578921f, 0.15732858f, 0.21810588f, -0.41101205f, -0.21679765f, -0.40605989f, -0.32439351f, 
    -0.02760957f, 0.01093910f, 0.07331466f, 0.07425563f, 0.02024962f, 0.05942712f, 0.04917455f, -0.10181636f, 
    0.22246708f, -0.05452157f, -0.16117953f, -0.05561646f, -0.11703852f, 0.23979279f, 0.13418838f, 0.15951957f, 
    0.09230562f, 0.11933368f, -0.06581882f, 0.06812137f, -0.01711798f, -0.00368045f, 0.22863053f, 0.15529129f, 
    0.09017663f, -0.04104691f, 0.11097974f, -0.00766183f, 0.18755047f, 0.07025376f, 0.20898409f, 0.14833505f, 
    0.17298225f, -0.20657293f, 0.32054374f, 0.02926505f, 0.06972463f, -0.01168088f, 0.01171098f, -0.00551941f, 
    -0.01717368f, 0.02805493f, 0.04980507f, 0.13392378f, -0.24248764f, 0.20529562f, -0.26138163f, 0.09337060f, 
    -0.04397482f, -0.03910655f, 0.05859168f, 0.19433936f, 0.02604328f, 0.06729457f, -0.03155606f, 0.18667111f, 
    0.03163347f, -0.03233977f, -0.00720440f, -0.03231226f, -0.03082991f, 0.05112994f, -0.01834786f, 0.24910027f, 
    0.18892065f, 0.29673612f, 0.09108727f, 0.32660303f, -0.45962551f, 0.14186111f, 0.02321051f, 0.10409193f, 
    0.05094830f, -0.09871060f, 0.09399352f, -0.06801607f, 0.01661531f, 0.11638515f, 0.21882063f, 0.12754689f, 
    -0.11197584f, 0.29220369f, 0.14798553f, 0.17159796f, 0.16142066f, 0.00154245f, 0.06726404f, 0.09057293f, 
    -0.01459858f, 0.07086225f, 0.04696603f, 0.18496548f, 0.48158899f, 0.39337945f, 0.27978048f, 0.23926206f, 
    -0.00533314f, -0.12778096f, -0.01109017f, -0.07312143f, -0.01243531f, -0.06520487f, -0.03345476f, 0.17011838f, 
    -0.02983133f, -0.07130330f, -0.00600388f, -0.01798766f, -0.00962862f, -0.04807630f, -0.02420218f, 0.04969072f, 
    0.06186041f, -0.06286971f, -0.03535612f, -0.06000658f, -0.00982531f, 0.03422782f, 0.02026506f, -0.06743556f, 
    0.01698649f, 0.05928954f, 0.02433765f, -0.08321740f, 0.02333469f, -0.01544794f, -0.05535619f, 0.04875686f, 
    -0.00659537f, -0.07151207f, -0.01332951f, -0.02917398f, -0.03705825f, -0.06590679f, -0.07285693f, 0.03142845f, 
    0.03464137f, 0.02788007f, 0.00603732f, -0.02647159f, -0.05202116f, -0.01732280f, -0.01842009f, 0.00972952f, 
    -0.05020590f, -0.06489673f, 0.01922172f, 0.03302784f, 0.02386113f, -0.00233262f, 0.06391259f, 0.01349774f, 
    0.06679441f, 0.03622326f, -0.03268937f, 0.00412758f, 0.00601418f, 0.04432628f, -0.01201910f, 0.04177417f, 
    0.01880371f, -0.04642129f, 0.01938787f, 0.03657232f, -0.01870763f, -0.05723994f, -0.05910215f, -0.01098657f, 
    0.03531094f, -0.06304721f, -0.03865665f, -0.05577375f, 0.04447319f, -0.01857348f, -0.05271710f, -0.01517972f, 
    -0.03395632f, 0.04717151f, 0.01234995f, -0.03179174f, 0.03816827f, -0.06558795f, 0.05992901f, 0.02449771f, 
    0.00717709f, -0.02000883f, -0.07827337f, -0.01345728f, 0.00628293f, -0.04250753f, -0.03880586f, -0.06843095f, 
    -0.03781041f, -0.05567629f, -0.05111304f, -0.03583375f, -0.00745728f, 0.05750073f, -0.06637429f, -0.06825862f, 
    0.03185235f, -0.00895145f, -0.05862803f, -0.06535849f, 0.05883277f, 0.02164238f, -0.03862629f, -0.01565370f, 
    -0.01676206f, -0.01076374f, 0.02065604f, -0.04302155f, 0.02605433f, -0.04927025f, 0.00965930f, -0.08048011f, 
    0.04571234f, 0.05696145f, 0.00840693f, -0.00004854f, 0.03281900f, -0.01418852f, 0.05215150f, 0.00274313f, 
    0.03378875f, -0.07412756f, -0.01287362f, 0.00783271f, -0.02362880f, -0.01489938f, -0.00268164f, -0.02280364f, 
    -0.04492104f, 0.00644796f, -0.02440636f, 0.01780401f, -0.04817183f, 0.00808864f, 0.00322899f, 0.02023910f, 
    0.00934831f, -0.02905624f, -0.06998017f, 0.01914776f, 0.01211192f, -0.06626023f, -0.03901137f, -0.04478443f, 
    -0.04096060f, -0.02096805f, 0.05305395f, -0.07476438f, -0.05200522f, 0.02199945f, 0.02115637f, 0.01630791f, 
    -0.01545127f, -0.02183169f, -0.00015663f, 0.01397860f, 0.06189488f, -0.06918684f, 0.05055872f, 0.01783230f, 
    0.03472581f, 0.03371888f, -0.03257011f, -0.01574656f, 0.01412543f, 0.05251601f, -0.06580245f, -0.05889121f, 
    0.03463862f, 0.05032662f, -0.07052389f, -0.00807111f, 0.02947393f, 0.02161654f, -0.00002132f, 0.05649637f, 
    -0.01523721f, -0.06711981f, 0.05158760f, 0.06023070f, -0.01542437f, -0.06017476f, 0.05487498f, 0.05068856f, 
    -0.06894936f, -0.00240898f, 0.01424576f, -0.05181993f, 0.04492447f, -0.00471192f, 0.01884561f, -0.04851861f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05907374f, 0.17706302f, -0.07961635f, -0.00047495f, 0.14652099f, -0.04754023f, 0.06368431f, -0.03936084f, 
    0.00832814f, -0.01727492f, 0.08060817f, 0.13865271f, 0.14765039f, 0.05256508f, -0.06634626f, -0.02264123f, 
    0.04954512f, 0.05277800f, -0.01507067f, -0.03517711f, -0.09021216f, 0.11176310f, -0.08083350f, 0.03348010f, 
    -0.08451790f, -0.02390635f, 0.01318207f, -0.11436120f, -0.06558102f, 0.01078220f, 0.09390662f, 0.05884855f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01206333f, 0.03899071f, -0.18653862f, -0.02248266f, -0.34744072f, -0.14439128f, 0.57612824f, 0.11972389f, 
    0.05967051f, -0.36667946f, 0.65124404f, -0.09742711f, 0.14468198f, 0.49470019f, 0.02811764f, 0.07689788f, 
    0.69161552f, 0.09635864f, -0.15517519f, 0.03981973f, 0.00679085f, 0.01131016f, -0.15982111f, -0.15572652f, 
    0.15355608f, 0.09650218f, 0.22065307f, -0.37709576f, 0.08544575f, -0.04235690f, 0.23817678f, -0.03516280f, 
    -0.12825328f, 0.25424230f, 0.00801302f, 0.10516202f, 0.45448276f, 0.14778973f, 0.24933112f, -0.14116937f, 
    0.04415057f, 0.17028208f, -0.38417420f, 0.13593554f, -0.04888811f, 0.03017534f, 0.06692141f, 0.07687417f, 
    -0.54201686f, 0.09184596f, 0.05415891f, -0.06745812f, -0.15519328f, -0.14880624f, 0.17634089f, -0.06408704f, 
    -0.11624187f, 0.07091092f, -0.08453777f, 0.59304446f, -0.07742078f, -0.07919966f, 0.01677504f, 0.14414577f, 
    -0.05247493f, 0.02530777f, 0.15890037f, 0.03056546f, 0.24672061f, 0.10231096f, -0.41023201f, -0.13359684f, 
    0.17225242f, 0.26652867f, -0.29932058f, 0.04903251f, 0.21532607f, -0.19440114f, 0.07795313f, 0.11922516f, 
    -0.05075109f, 0.14720584f, 0.04715930f, 0.05876165f, -0.25293681f, 0.35612094f, -0.02997716f, 0.00500417f, 
    0.23140436f, 0.16923328f, -0.28107578f, -0.07737122f, 0.11515258f, 0.10676950f, 0.07968917f, 0.02529866f, 
    0.15554671f, 0.02896130f, -0.37461552f, -0.13317296f, -0.36124247f, -0.08983909f, -0.12752312f, -0.11411072f, 
    -0.20227811f, 0.09434672f, 0.44816551f, -0.32468298f, 0.33795899f, -0.44509372f, -0.00119232f, 0.13647848f, 
    0.40419090f, 0.39176086f, 0.06206779f, -0.07084358f, -0.23297502f, 0.10706453f, 0.38017574f, 0.13433681f, 
    0.40571380f, -0.05039873f, -0.49960542f, 0.01490799f, 0.09098826f, -0.03220147f, 0.17831965f, -0.16591763f, 
    -0.05665541f, -0.07073822f, 0.12236543f, -0.03773498f, 0.01063277f, 0.05882062f, -0.07202850f, 0.07394514f, 
    -0.13945007f, -0.13246559f, 0.13870303f, -0.16539919f, -0.20420484f, -0.16498855f, -0.13653198f, -0.05293123f, 
    -0.11024666f, -0.16603470f, 0.13952006f, -0.11872958f, 0.09640887f, -0.03355279f, -0.18039392f, -0.04979998f, 
    0.09794919f, -0.10077124f, 0.01477961f, 0.00504182f, -0.10726196f, 0.04188448f, 0.02688210f, 0.06774524f, 
    -0.06351334f, 0.25623718f, 0.72277087f, -0.00565399f, 0.23771417f, 0.04857844f, -0.05152506f, 0.12567115f, 
    0.19324349f, 0.40769008f, -0.35544264f, -0.38762552f, -0.00381732f, 0.00545223f, -0.00847787f, -0.09024862f, 
    -0.21800597f, -0.13068931f, -0.02863425f, 0.15076654f, 0.14675327f, 0.16405185f, 0.44141221f, -0.03087004f, 
    -0.04856535f, -0.05299164f, 0.00497637f, 0.40152147f, -0.13228630f, 0.09946866f, -0.08140629f, 0.01474151f, 
    0.14813364f, -0.10824034f, 0.10829464f, 0.09108029f, 0.24820383f, 0.06807999f, -0.00425438f, 0.11896523f, 
    0.16046251f, 0.31670776f, 0.23686296f, -0.33370560f, -0.21943255f, 0.35592121f, 0.13316157f, 0.06177224f, 
    0.39705440f, 0.02783249f, 0.12506667f, 0.11221930f, -0.13207190f, -0.80055821f, 0.48594052f, -0.07369374f, 
    0.11059632f, -0.06691354f, 0.09854268f, -0.23471034f, -0.09504293f, 0.15274751f, 0.04184627f, -0.14099160f, 
    -0.11972823f, 0.06083474f, 0.22008206f, -0.15415959f, 0.53695107f, 0.01881797f, -0.10970566f, -0.16620851f, 
    0.16729689f, 0.53347343f, 0.12358379f, 0.29474011f, -0.37815195f, 0.32561728f, -0.01731959f, -0.12038619f, 
    -0.33268318f, 0.12975405f, 0.12537827f, 0.02637493f, 0.00106852f, 0.24901383f, 0.06818303f, 0.03179444f, 
    -0.49057436f, -0.15985553f, 0.42322677f, -0.05069161f, -0.08817065f, -0.08074930f, -0.31220925f, 0.12646730f, 
    -0.12309565f, 0.25733188f, -0.06487910f, -0.03285584f, 0.70333540f, 0.04350157f, 0.33074233f, 0.15016457f, 
    -0.12421604f, -0.26095918f, -0.04256978f, 0.31186679f, 0.25463426f, 0.18651831f, -0.15645501f, -0.07096190f, 
    -0.34874672f, -0.10545800f, 0.02930602f, -0.12202941f, -0.59657615f, -0.21437114f, 0.21863872f, 0.03015448f, 
    -0.15776733f, -0.17048749f, -0.06124687f, 0.30933589f, -0.16901459f, 0.05614937f, -0.03231905f, -0.15822814f, 
    0.10946368f, 0.41563675f, -0.15322848f, 0.00080247f, -0.03394258f, 0.18175593f, 0.63512081f, -0.04990456f, 
    -0.18531431f, 0.07878698f, 0.26697487f, 0.22464204f, -0.09174784f, 0.27093065f, 0.09532574f, 0.15251234f, 
    -0.02440548f, -0.44003969f, -0.12756060f, 0.07329399f, 0.34802336f, -0.10920244f, 0.10621828f, -0.02991727f, 
    -0.03290333f, 0.06146866f, 0.19556800f, -0.14940721f, -0.02599939f, -0.07702797f, 0.08510288f, 0.06611768f, 
    0.01361973f, 0.05582668f, 0.53186452f, -0.13927194f, 0.07220357f, -0.10472091f, 0.06665908f, 0.14843202f, 
    -0.09706126f, 0.16641466f, -0.28058851f, -0.54525054f, 0.29186937f, 0.23057069f, -0.01933679f, -0.05530347f, 
    0.13671668f, -0.03652437f, -0.13942102f, -0.12637629f, -0.50227123f, 0.27738824f, 0.24068153f, 0.13076618f, 
    -0.05837708f, -0.17394099f, -0.15370077f, 0.19003080f, 0.17422129f, 0.09664883f, 0.19481540f, 0.01063621f, 
    -0.14717351f, 0.30030835f, 0.38672996f, -0.00585323f, -0.39661950f, 0.08053996f, -0.07431245f, -0.15729761f, 
    0.45636210f, 0.35831317f, -0.44963503f, 0.08940279f, -0.22024733f, 0.20743623f, -0.07266320f, -0.10884232f, 
    -0.21556310f, 0.10807046f, -0.02166908f, -0.07729202f, 0.73370302f, -0.51951766f, 0.11166696f, 0.11171986f, 
    -0.19149189f, 0.14509669f, 0.25386035f, 0.07774577f, 0.01750056f, 0.08772331f, 0.18854405f, 0.17810886f, 
    -0.16779326f, -0.17014301f, -0.43486643f, 0.05118375f, 0.33995321f, 0.01302188f, -0.22230864f, -0.12955230f, 
    0.30656600f, 0.21286726f, 0.00108779f, 0.48421302f, 0.11213408f, -0.32782429f, -0.10069343f, -0.07438117f, 
    -0.12163053f, 0.47279873f, 0.16215010f, -0.07211490f, 0.41260368f, -0.05089365f, -0.01559717f, -0.00574364f, 
    0.17930305f, 0.05182746f, 0.21586940f, -0.25422394f, 0.14345533f, 0.01934800f, 0.02891494f, -0.16376455f, 
    0.11959220f, 0.38628826f, -0.06903575f, 0.04656256f, 0.07565971f, -0.07866984f, 0.11989806f, -0.07812755f, 
    0.20694064f, -0.32127845f, -0.10933365f, 0.33306938f, -0.14410196f, -0.04051659f, 0.15079503f, -0.12510601f, 
    -0.39786932f, 0.10365617f, 0.08510976f, 0.16057044f, 0.02767544f, -0.41349858f, 0.34126070f, -0.16108251f, 
    -0.19231665f, -0.15393083f, 0.02244106f, 0.36521444f, 0.03166912f, -0.03627132f, 0.18646814f, -0.08938875f, 
    -0.08938538f, -0.09891494f, -0.14008787f, -0.09103381f, 0.22429028f, -0.08795440f, -0.57151324f, -0.02135897f, 
    0.18201470f, 0.36810923f, -0.16880894f, 0.36828995f, -0.11876891f, -0.17988960f, -0.03708776f, 0.02331527f, 
    -0.29393363f, 0.44994098f, -0.05700991f, -0.06223009f, 0.16223876f, -0.12568127f, -0.09317419f, 0.06376076f, 
    0.13739021f, 0.09716859f, 0.08195563f, 0.49144930f, 0.00328729f, -0.09653527f, 0.18768969f, 0.09055290f, 
    0.07852490f, 0.20098351f, 0.26165393f, 0.07028205f, -0.08918544f, -0.06231116f, 0.04176073f, -0.07319820f, 
    -0.24070601f, -0.20077227f, -0.13345791f, 0.16331421f, -0.20433319f, 0.04561161f, 0.02952731f, -0.07772194f, 
    -0.10254167f, -0.07306828f, -0.14097525f, -0.16398296f, -0.13237147f, -0.32455406f, 0.26765788f, -0.13941510f, 
    0.35520700f, 0.13910851f, -0.39956009f, 0.15462114f, -0.09974565f, -0.13245912f, 0.30020419f, -0.07218757f, 
    0.07033573f, -0.00821032f, -0.10754375f, 0.07645939f, 0.39283893f, -0.15419021f, 0.19136918f, 0.12402400f, 
    -0.44609842f, -0.01049051f, -0.04647725f, 0.14347042f, -0.16560140f, -0.09438298f, 0.10340539f, -0.08354150f, 
    -0.49332538f, 0.16369212f, 0.14065185f, -0.02177578f, 0.57072830f, 0.34046501f, 0.29172686f, 0.08652227f, 
    -0.16487992f, 0.12964569f, 0.02634608f, -0.03741537f, 0.08692074f, 0.04565249f, -0.23296897f, -0.02536742f, 
    -0.02861611f, -0.24391265f, -0.00756686f, -0.13108808f, 0.18424433f, -0.01047358f, -0.71584886f, -0.06498448f, 
    0.05705873f, -0.09651827f, 0.08616359f, -0.00797935f, -0.03651416f, -0.19664831f, -0.16221899f, -0.16078742f, 
    0.19839592f, 0.13383973f, 0.07105467f, -0.07078034f, -0.02518648f, -0.16607378f, 0.03682945f, 0.05780733f, 
    0.01289838f, 0.09236602f, -0.27567980f, -0.05646627f, 0.03326935f, 0.08088078f, 0.20916767f, -0.12800373f, 
    -0.04532997f, 0.18023662f, -0.06587815f, -0.14233905f, -0.08980496f, -0.00460359f, -0.00419801f, -0.00334950f, 
    -0.56713957f, 0.31111631f, -0.05281319f, 0.44610265f, -0.20557018f, 0.15597980f, 0.11091518f, -0.17245600f, 
    0.04020463f, -0.12749948f, 0.15172902f, 0.14954518f, 0.07441215f, 0.48709473f, 0.11127161f, 0.01585026f, 
    0.00540965f, 0.03575490f, -0.14551857f, 0.19772014f, 0.05095512f, -0.15346272f, 0.17172782f, -0.12196743f, 
    -0.14442424f, 0.04829747f, 0.26111090f, 0.18582727f, -0.01289928f, 0.11330226f, -0.70922762f, 0.02967018f, 
    0.15573549f, -0.15204318f, -0.40448400f, 0.20230041f, -0.15985242f, 0.09957634f, 0.07469301f, -0.06636424f, 
    0.09456588f, 0.41190276f, -0.04122223f, 0.16876559f, 0.45034719f, -0.59100842f, -0.15696114f, 0.01748726f, 
    0.45016369f, 0.06160111f, -0.20707081f, -0.38912246f, -0.00512236f, -0.03199196f, 0.37159342f, 0.01737714f, 
    0.14862455f, 0.24754280f, 0.71010119f, -0.13454621f, -0.24914318f, 0.08448548f, 0.17439710f, 0.01903183f, 
    0.10038980f, -0.25215968f, -0.46178710f, -0.12589237f, -0.02559263f, -0.05191979f, -0.02705082f, 0.09272879f, 
    -0.09751647f, -0.19314748f, 0.06109398f, 0.14384240f, 0.52057207f, 0.17077862f, 0.31572255f, -0.04802597f, 
    0.08774056f, 0.02716978f, -0.13402107f, 0.19542255f, 0.10018785f, 0.03770280f, 0.08166250f, 0.11039697f, 
    -0.09615384f, 0.18252073f, 0.13799974f, 0.10174033f, 0.07543024f, 0.08488844f, 0.12224147f, 0.04702976f, 
    0.35044751f, 0.53119773f, -0.34850258f, 0.17922927f, 0.12357111f, -0.06490675f, 0.15611587f, 0.03992855f, 
    -0.25118965f, -0.17978221f, 0.12112792f, 0.05419768f, -0.12462927f, 0.28437606f, -0.28057522f, -0.16026492f, 
    -0.25728258f, -0.11970688f, 0.32273200f, -0.24393512f, 0.11416346f, -0.05607321f, 0.13872489f, 0.01218515f, 
    0.08367163f, -0.04793119f, 0.06120479f, 0.10455979f, -0.02065964f, 0.16484094f, -0.13297309f, 0.05598005f, 
    0.06133933f, 0.07702126f, -0.11522681f, -0.15159866f, -0.04167439f, -0.06587772f, -0.13036442f, 0.01841809f, 
    -0.11057962f, -0.17701218f, 0.04482214f, -0.02878221f, -0.13782957f, -0.02090812f, 0.11609905f, 0.12968330f, 
    0.06930956f, 0.16358604f, -0.09717000f, 0.10703526f, -0.05674154f, -0.01311174f, -0.04637698f, -0.12954704f, 
    -0.13523394f, 0.19034156f, -0.42107382f, -0.13083629f, -0.44405973f, 0.14048082f, 0.39031908f, -0.14879768f, 
    0.16976929f, 0.31153220f, 0.03693586f, 0.45173180f, -0.10512143f, 0.23549008f, -0.08944125f, -0.08087628f, 
    0.05979865f, 0.15192533f, 0.12245813f, 0.13875760f, 0.28949875f, -0.15699904f, -0.19960512f, 0.16864567f, 
    -0.24772251f, 0.15010199f, 0.41300711f, 0.24365282f, -0.13440116f, 0.01246312f, 0.04738268f, 0.12814860f, 
    0.11503434f, -0.16960087f, -0.11775545f, 0.04133531f, 0.04212438f, -0.06746616f, -0.11155779f, 0.01008733f, 
    0.22319888f, 0.00280600f, 0.17491600f, -0.41199484f, 0.25887665f, -0.07237489f, -0.07521161f, 0.11833605f, 
    0.37821129f, 0.40709400f, -0.07502615f, 0.01114536f, -0.55351144f, -0.23700686f, 0.30236837f, 0.07773052f, 
    0.36327159f, -0.12718149f, 0.09420800f, 0.45408371f, 0.09519510f, 0.13951370f, 0.11459503f, 0.00714870f, 
    0.01302802f, -0.19615681f, -0.02279534f, -0.02964053f, -0.06536050f, 0.16828871f, 0.03538148f, -0.08047944f, 
    -0.18883106f, 0.55529833f, 0.37646174f, 0.26034009f, -0.30416927f, 0.28030783f, 0.12448192f, 0.14635628f, 
    0.47525463f, 0.32413259f, 0.09834533f, -0.12453443f, 0.07037518f, 0.00782829f, 0.26676667f, 0.05709296f, 
    -0.14275487f, -0.07875744f, 0.19134939f, 0.13336615f, 0.13082014f, -0.15107207f, -0.24612555f, -0.07191309f, 
    -0.00778423f, -0.30724171f, -0.13657486f, -0.15471087f, 0.03365983f, -0.04813917f, 0.10552426f, 0.09841027f, 
    0.13477811f, -0.38451630f, 0.14757384f, -0.06255981f, 0.26452211f, 0.19140804f, 0.01073506f, 0.05474747f, 
    0.17322730f, -0.46816453f, -0.16349964f, -0.16521688f, 0.40794218f, 0.33369905f, -0.59921169f, 0.05995138f, 
    -0.00915544f, 0.08049057f, 0.05966846f, 0.08479482f, 0.13219932f, 0.18871149f, -0.15725671f, 0.13883364f, 
    0.07782883f, 0.21304645f, -0.27727434f, -0.00054843f, 0.34077799f, -0.07743324f, -0.14102051f, -0.03672615f, 
    0.25692111f, -0.41083118f, 0.44449693f, 0.21991464f, 0.12214292f, -0.19641173f, 0.04644382f, -0.03594769f, 
    -0.07351635f, -0.08658013f, 0.11310825f, -0.00984903f, 0.24070333f, 0.06642725f, -0.10217027f, 0.11707749f, 
    0.48205453f, 0.09270704f, 0.12307087f, -0.44913393f, -0.07125958f, 0.01694199f, 0.31538698f, 0.16119713f, 
    0.09273250f, 0.05425198f, 0.11626059f, 0.15551774f, 0.09811758f, -0.04158982f, 0.23422204f, -0.10008761f, 
    0.43385151f, 0.01690305f, -0.06260018f, -0.23928304f, 0.12828718f, 0.51840961f, 0.00674038f, 0.02602402f, 
    0.19899680f, -0.33439004f, -0.03116283f, -0.00115224f, -0.16097365f, -0.32337981f, -0.07350645f, 0.16187854f, 
    -0.21785359f, -0.05302334f, 0.46976820f, 0.01113400f, 0.16367365f, 0.03138146f, 0.12188446f, -0.12662330f, 
    -0.02562545f, 0.10148796f, 0.20457542f, 0.01200372f, 0.15507972f, -0.04550456f, -0.09416932f, -0.05542751f, 
    -0.20162307f, 0.44504252f, 0.06425332f, -0.06880022f, -0.44926724f, 0.18889955f, 0.04125430f, 0.04807970f, 
    0.11226974f, -0.03879339f, 0.16756028f, 0.01329610f, 0.06183651f, -0.31157964f, 0.35679528f, 0.20864923f, 
    0.15536444f, -0.04143259f, -0.27789265f, 0.02302193f, -0.14556426f, -0.06496145f, 0.07312912f, 0.01619918f, 
    -0.17118186f, 0.33987528f, 0.21423839f, 0.17306121f, -0.13350300f, -0.12050600f, 0.03206948f, 0.04148684f, 
    0.21909301f, 0.02134240f, -0.19907646f, 0.14372784f, 0.15416695f, 0.31879789f, -0.18055566f, 0.03958498f, 
    0.05733618f, -0.04786674f, 0.10844840f, -0.01399543f, -0.46911925f, 0.23261501f, -0.45810175f, -0.00562479f, 
    0.10494151f, -0.07405093f, 0.17867914f, -0.48804033f, 0.12283391f, 0.04575830f, 0.37370071f, -0.11430341f, 
    0.14856260f, -0.01669309f, 0.10416262f, 0.06906823f, 0.00525824f, -0.09995838f, -0.04889841f, -0.15411364f, 
    -0.12491052f, -0.01345983f, -0.16479838f, -0.05886790f, 0.07906944f, -0.13196512f, -0.07987671f, 0.14324941f, 
    -0.17531595f, 0.06982817f, -0.05911336f, -0.14041039f, 0.02619432f, -0.06085291f, -0.12451883f, 0.10226172f, 
    -0.18311913f, -0.11042177f, -0.01439145f, -0.11632071f, -0.11676238f, -0.17557944f, 0.01727635f, 0.03332117f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00790960f, 0.13845034f, 0.02088389f, 0.15591808f, 0.02915456f, -0.01737724f, 0.17051099f, 0.11551790f, 
    0.27178207f, 0.20621273f, 0.05353297f, -0.00939605f, 0.02019879f, 0.25427055f, 0.06099782f, 0.19494317f, 
    -0.07436409f, 0.01551804f, 0.19334581f, -0.05786180f, -0.23980011f, -0.04703322f, -0.15785863f, 0.07070258f, 
    -0.05480075f, -0.03171728f, 0.03805554f, 0.23959266f, 0.19655104f, -0.03698613f, 0.23069935f, -0.17344980f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06276418f, -0.62022924f, 0.02320512f, 0.15743342f, -0.16605224f, -0.14395073f, 0.61112267f, -0.36838630f, 
    -0.71485275f, 0.11030782f, -0.11231239f, 0.03660166f, -0.13257344f, -0.03529539f, -0.16766655f, 0.24840197f, 
    -0.17320083f, 0.10964824f, -0.12396658f, 0.38082686f, -0.09437891f, -0.62724996f, 0.00521314f, -0.29117480f, 
    -0.00207187f, 0.12790488f, 0.56212759f, 0.08307935f, -0.11173926f, 0.52373904f, -0.29603747f, -0.01813107f, 
    0.15138032f, -0.10287284f, 0.12064669f, 0.19528469f, 0.11427785f, -0.43018913f, -0.23433502f, 0.14549805f, 
    0.31327274f, -0.49264288f, 0.10489881f, -0.98991233f, 0.29715320f, -0.66286021f, 0.07450601f, 0.01560558f, 
    0.47521105f, 0.10041757f, 0.03181022f, 0.25365847f, -0.40534636f, -0.45066875f, 0.11162799f, -0.17551717f, 
    0.25850916f, -0.11962017f, -0.00118063f, 0.16486126f, -0.22433943f, -0.34614271f, 0.23486826f, -0.17681466f, 
    -0.63641107f, 0.30150074f, 0.22257376f, 0.05939662f, 0.07067320f, 0.14993373f, -0.64274210f, -0.21494396f, 
    0.08257800f, -0.70275033f, 0.02640456f, 0.20647281f, 0.22993173f, 0.19071442f, 0.44589689f, -0.04658986f, 
    -0.52886176f, 0.09550056f, -0.47021052f, 0.13827847f, 0.10933825f, 0.14553568f, 0.14171322f, 0.06402483f, 
    0.19828843f, -0.50150174f, -0.06144383f, -0.22353849f, -0.38474217f, -0.30460346f, -0.18339442f, -0.19130498f, 
    -0.21272604f, 0.18595324f, -0.13440333f, -0.46772438f, -0.08239435f, 0.11394393f, 0.25503883f, 0.18305689f, 
    0.15781701f, -0.05422474f, 0.28714231f, 0.03400628f, -0.84265274f, 0.16176726f, 0.12110075f, 0.09624513f, 
    -0.65086585f, -0.00305959f, 0.22863543f, -0.43053207f, -0.12690754f, -0.19254805f, -0.03987838f, 0.06541597f, 
    0.26499844f, 0.29727361f, -0.03690987f, -0.64839244f, 0.09041966f, 0.36137533f, -0.23516093f, -0.19659881f, 
    0.09609254f, -0.37724188f, 0.07923790f, -0.04460159f, -0.07606156f, 0.03379541f, 0.36856678f, 0.37391654f, 
    -0.36909208f, -0.11882197f, 0.24994859f, 0.17479263f, -0.22715339f, -0.42589548f, -0.27077094f, -0.57362020f, 
    -0.21453175f, -0.15618385f, -0.34933805f, -0.28728312f, -0.13848731f, 0.39573222f, -0.19263282f, 0.04241499f, 
    0.05038271f, 0.28098050f, -0.03902573f, -0.18950389f, 0.39006063f, 0.05607337f, 0.20472887f, 0.16150150f, 
    0.38484874f, -0.45742968f, -0.15087873f, 0.19576721f, -0.07083723f, -0.66406882f, -0.10116601f, -0.91642392f, 
    0.26181400f, 0.25216541f, -0.30989230f, -0.36172214f, 0.12760092f, 0.17741302f, -0.18794538f, -0.23722976f, 
    -0.29955831f, -0.56533015f, 0.05956338f, -0.35686579f, -0.56467038f, -0.03230995f, -0.14891370f, 0.39631474f, 
    0.10951620f, 0.33590928f, -0.29393312f, 0.10816864f, 0.12060115f, -0.11892752f, 0.16007327f, -0.13447328f, 
    0.16561179f, -0.23839238f, -0.00827795f, -0.38566646f, -0.11023751f, -0.27036288f, -0.76267445f, -0.65419841f, 
    -0.60839605f, 0.26188862f, -0.11308908f, 0.43663099f, -0.26256263f, -0.05885069f, -0.24013238f, 0.01655213f, 
    -0.15669912f, -0.61938244f, 0.52890885f, 0.22342099f, 0.29149345f, 0.19985907f, 0.01865811f, 0.27674246f, 
    -0.47092229f, -0.32179865f, 0.22925065f, -0.07612031f, -0.00562134f, -0.12447302f, 0.28383034f, -0.04861347f, 
    -0.28163642f, 0.15906131f, -0.33441624f, 0.16624737f, 0.06998897f, 0.01329273f, -0.02333088f, 0.32073724f, 
    -0.03188451f, 0.17538625f, -0.20615911f, -0.06952016f, 0.21338765f, -0.05936755f, 0.04118651f, -0.70811230f, 
    0.29893875f, 0.18942022f, 0.21850887f, -0.09123746f, -0.01950653f, -0.05445775f, 0.00086426f, 0.20964244f, 
    -0.40016145f, 0.42061776f, -0.09548780f, -0.53252560f, -0.16318166f, 0.21915071f, -0.72070396f, -0.09934228f, 
    0.09991909f, -0.33389062f, 0.15157266f, 0.38781846f, 0.00849514f, 0.26241654f, -0.82819718f, -0.39241388f, 
    -0.30564752f, 0.04848770f, 0.42937902f, -0.27872527f, -0.37511659f, -0.37866834f, -0.62685615f, 0.04666679f, 
    0.40045100f, -0.15085039f, 0.30949414f, -0.53101355f, 0.59371698f, -0.32267302f, 0.00577274f, -0.48556802f, 
    0.10327517f, 0.03649084f, -0.35457867f, -0.02946020f, -0.78784072f, -0.17418729f, -0.08557871f, -0.03054099f, 
    -0.13675244f, -0.20615098f, -0.01817804f, -0.52279454f, -0.08950087f, -0.12207253f, -0.11115399f, 0.27359769f, 
    -0.19320022f, -0.28063461f, -0.51140100f, 0.39078522f, 0.39887801f, 0.21314541f, 0.28441644f, -0.47341222f, 
    -0.02394520f, 0.21801513f, -0.42901126f, 0.25096741f, 0.09032835f, 0.05611134f, -0.13076439f, 0.10723204f, 
    -0.10009014f, 0.04896411f, -0.40495357f, 0.15344860f, 0.02274430f, -0.40358573f, -0.00072798f, 0.01028150f, 
    -0.56783378f, 0.22163728f, 0.29502627f, -0.19818866f, 0.04491167f, 0.07342358f, -0.41424850f, 0.26149619f, 
    0.37694052f, 0.19335690f, 0.05610053f, -0.61133599f, -0.08607401f, 0.18216687f, -0.02299652f, 0.02143779f, 
    0.00140492f, 0.13148336f, 0.31291014f, -1.05812418f, -0.09868057f, 0.39997295f, -0.02084309f, -0.32155553f, 
    -0.41820297f, -0.43488443f, -0.39506790f, 0.18624726f, -0.19945462f, 0.22840977f, 0.12498821f, -0.14167455f, 
    0.15544628f, 0.12064272f, -0.30582833f, -0.51995325f, -0.10125084f, 0.01059431f, 0.02199266f, -0.31233066f, 
    0.44147280f, 0.35406306f, 0.19961981f, -0.03355461f, -0.54702562f, 0.43280512f, -0.66434550f, 0.14075592f, 
    -0.76826894f, -0.31559220f, -0.47211373f, -0.40427068f, 0.25655812f, -0.13093245f, 0.08580361f, -0.00762693f, 
    -0.05207537f, -0.69723219f, 0.19475128f, 0.05145076f, 0.46052194f, -0.24840117f, 0.09122652f, -0.09378813f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03347529f, 0.17141658f, -0.26128078f, -0.11634780f, -0.20056465f, 0.05713473f, -0.00622203f, -0.14694095f, 
    -0.09297433f, -0.02794316f, 0.30317914f, 0.00891339f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
