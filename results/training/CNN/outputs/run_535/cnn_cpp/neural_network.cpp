#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16864163f, -0.00703577f, -0.26168555f, -0.62566304f, 0.07739109f, 0.20510139f, 0.58877397f, -0.26289245f, 
    -0.20475151f, -0.15724975f, 0.32604250f, -0.31023619f, -0.13003337f, -0.16327804f, -0.19883162f, 0.15401886f, 
    -0.25720790f, -0.13953704f, 0.01444787f, -0.17297268f, -0.16258310f, 0.24666503f, -0.14706825f, 0.18183385f, 
    0.06361683f, 0.21968074f, -0.26527736f, 0.50053090f, -0.27818957f, 0.14247411f, -0.43315634f, -0.15950754f, 
    -0.42387536f, -0.14128803f, -0.53948659f, 0.13226989f, -0.21510772f, 0.06980816f, -0.06693313f, 0.22270268f, 
    0.05915698f, 0.30355549f, -0.03804836f, 0.04604968f, 0.14387551f, -0.20006867f, 0.06321400f, 0.02512604f, 
    -0.04052194f, 0.16131273f, 0.77056366f, 0.28276059f, -0.06717326f, 0.80348760f, 0.50530684f, 0.14977172f, 
    0.06099325f, 0.03681488f, 0.29520059f, 0.02889796f, -0.22923405f, -0.24910857f, -0.19928789f, -0.00458018f, 
    -0.05321003f, 0.04154976f, 0.05152307f, -0.04181940f, 0.14574225f, 0.28558049f, 0.09317061f, -0.04748535f, 
    -0.19624683f, -0.20559490f, -0.01406248f, 0.22030984f, 0.78673011f, -0.35318875f, -0.64770347f, -0.80156106f, 
    0.46960917f, -0.12549397f, 0.06172843f, 0.02163549f, 0.11934458f, 0.15149902f, 0.14439125f, 0.02263870f, 
    0.06117724f, 0.01926926f, -0.15856953f, 0.02353506f, -0.00291709f, -0.21334782f, -0.25982794f, -0.24470250f, 
    -0.03000122f, 0.11135910f, -0.05573842f, 0.30564076f, 0.62102580f, 0.01494988f, 0.01891781f, -0.41099665f, 
    -0.18110697f, 0.42080599f, 0.52118814f, 0.41688624f, 0.11683968f, 0.23540878f, -0.42316997f, 0.08668313f, 
    -0.21712562f, 0.08691086f, -0.16936958f, -0.24189287f, -0.21193494f, -0.21673211f, 0.13240856f, 0.21768390f, 
    0.19861668f, -0.33785850f, 0.29741615f, -0.00823151f, -0.36931333f, -0.30810151f, 0.34619597f, -0.00621902f, 
    -0.66591108f, -0.41947567f, -0.03962856f, 0.07907191f, -0.23850420f, -0.71629524f, -0.27432507f, -0.07421185f, 
    0.24551941f, 0.01595850f, 0.22822005f, 0.16531581f, 0.00305980f, 0.13223220f, 0.25385934f, 0.10826969f, 
    -0.04537010f, 0.18743570f, 0.13683221f, -0.27927110f, 0.11349265f, 0.20880860f, -0.19926396f, -0.13325195f, 
    0.44854674f, 0.55333602f, 0.48732105f, 0.53136837f, -0.18763709f, -0.41215366f, 0.28013799f, 0.05225039f, 
    0.16371867f, 0.02872794f, 0.15119456f, 0.08045251f, 0.05606364f, 0.13961899f, -0.34627005f, 0.04752654f, 
    0.18578169f, 0.26073673f, -0.05121284f, 0.03401714f, -0.46286279f, 0.08923648f, -0.00705728f, 0.67099857f, 
    0.21489754f, 0.50901109f, 0.17135988f, 0.67778188f, -0.27458513f, -0.01794856f, -0.18327099f, 0.45623541f, 
    -0.10037330f, -0.37806427f, -0.26578110f, -0.05906880f, -0.06646310f, 0.28983039f, -0.18292826f, 0.00432410f, 
    -0.32125700f, -0.35970980f, 0.14950532f, 0.23791835f, 0.00983134f, 0.07197383f, 0.17108250f, -0.14206052f, 
    0.48306850f, 0.92857850f, -0.06662848f, -0.09516466f, -0.14279440f, -0.50733960f, -0.39964807f, 0.32384145f, 
    0.14753911f, 0.27811503f, -0.07309912f, 0.18394867f, -0.34023297f, 0.14669487f, 0.04721439f, -0.10562605f, 
    -0.12331256f, 0.25954250f, -0.13507067f, 0.23672765f, 0.24485968f, 0.15819934f, -0.12248612f, -0.02784315f, 
    0.13940121f, -0.19843116f, 0.18143831f, -0.26754749f, -0.13838924f, -0.33035657f, 0.19666652f, -0.29004836f, 
    0.05615089f, 0.06723660f, -0.49816367f, -0.32102731f, -0.21575285f, -0.26826054f, -0.32828316f, -0.34335116f, 
    0.04846696f, 0.23905462f, -0.10053769f, 0.14747818f, -0.05128865f, -0.30097082f, 0.04159499f, -0.00014355f, 
    -0.36873749f, -0.28261793f, -0.74088866f, 0.36211890f, -0.17857726f, -0.02739297f, -0.18598875f, -0.20612386f, 
    0.50481528f, 0.19364098f, -0.31995866f, 0.27073640f, -0.42951024f, 0.25483796f, 0.40539652f, -0.04080047f, 
    0.06283890f, -0.20747684f, -0.11218604f, -0.21288402f, -0.25912175f, -0.33968285f, 0.13472795f, 0.24236301f, 
    0.04981652f, 0.01418646f, 0.18583801f, 0.27349383f, -0.65181476f, 0.79098904f, 0.39228398f, 0.16569814f, 
    0.29726717f, -0.47101784f, 0.32374692f, 0.28901523f, -0.31278145f, 0.19223402f, -0.22857744f, -0.07363997f, 
    0.02510647f, -0.17124246f, -0.16156515f, 0.09325802f, 0.17358728f, -0.12703665f, -0.09175515f, 0.00381616f, 
    0.01478190f, -0.20401257f, -0.04728946f, -0.00675847f, 0.61039829f, 0.61782789f, 0.60839683f, 0.51267499f, 
    0.30539632f, -0.23606113f, -0.21534172f, -0.34181666f, -0.46235883f, -0.23824824f, -0.01318270f, 0.20266266f, 
    0.14504737f, 0.21928130f, 0.00911802f, 0.13443604f, -0.18650277f, 0.19115762f, 0.18804656f, -0.00746296f, 
    -0.05867876f, 0.10128970f, 0.07699936f, 0.24896190f, 0.00275830f, -0.18552393f, 0.02785295f, 0.17525673f, 
    0.13871503f, 0.45329365f, -0.08333662f, -0.44418421f, -0.55138737f, -0.34576544f, -0.40521511f, 0.46950236f, 
    -0.35908508f, -0.08330320f, 0.18455476f, -0.21520863f, 0.13078462f, -0.23103838f, -0.19154844f, -0.12525542f, 
    0.18078250f, -0.11644886f, 0.07037313f, 0.38829383f, -0.19079646f, 0.04644244f, -0.07566292f, 0.44890201f, 
    0.56249994f, 0.33051026f, -0.31387284f, -0.18326296f, -0.28623915f, 0.08477757f, -0.09227534f, -0.23049144f, 
    0.36896101f, -0.51709384f, 0.15090178f, -0.10588027f, -0.26879597f, 0.08877971f, 0.07393637f, -0.01806900f, 
    -0.16280815f, 0.15902595f, -0.04249985f, -0.15023620f, 0.25414652f, -0.11791965f, 0.01757968f, -0.69908267f, 
    0.04871485f, 0.16090891f, 0.22458211f, 0.54580575f, 0.43282548f, -0.04401142f, -0.59269840f, 0.20591937f, 
    -0.09642079f, -0.40808040f, 0.06046117f, -0.39978859f, 0.30905831f, -0.15114717f, -0.42961994f, -0.13252930f, 
    -0.27876046f, 0.18641911f, 0.03440582f, -0.00974922f, -0.02327393f, -0.11720834f, -0.12877172f, 0.14350224f, 
    -0.67991763f, 0.49017844f, -0.17950474f, -0.13254587f, 0.11872109f, 0.34295857f, 0.14468172f, 0.26051804f, 
    0.50247949f, 0.47503620f, 0.16250663f, -0.26858920f, 0.10007241f, -0.30812165f, -0.19568217f, 0.08789744f, 
    -0.21795043f, 0.07892522f, 0.22465575f, -0.12350900f, -0.17816842f, -0.22270952f, 0.04219135f, -0.06972706f, 
    -0.16317908f, -0.38475811f, -0.08308974f, -0.37071308f, -0.34147471f, -0.31089047f, -0.20969485f, 0.03396056f, 
    0.00370504f, 0.08717470f, 0.31849170f, -0.11256643f, 0.27610627f, -0.10753055f, 0.12724291f, -0.30693048f, 
    0.18747748f, 0.24322486f, 0.18052390f, 0.23794539f, 0.04112921f, -0.13544571f, -0.01423814f, 0.14357822f, 
    -0.28350496f, 0.27643469f, -0.28457665f, 0.06665429f, 0.47525090f, 0.32954463f, -0.10404596f, -0.62210155f, 
    0.11163454f, -0.36398357f, 0.02547287f, 0.02135450f, -0.12201925f, 0.10088972f, 0.11255974f, -0.13561548f, 
    -0.15141205f, 0.19202051f, 0.20077433f, 0.13750407f, 0.12075892f, 0.22901797f, -0.13720763f, -0.13540922f, 
    -0.32386127f, -0.23286970f, 0.21736124f, -0.90547138f, 0.39627784f, -0.11687737f, -0.06065012f, -0.11091026f, 
    0.14140996f, 0.74349892f, -0.38683057f, 0.32651326f, 0.31787074f, 0.00364033f, 0.10671251f, 0.00963374f, 
    0.02153650f, 0.20634571f, -0.08665710f, -0.13798440f, -0.22667824f, -0.01460114f, 0.02885377f, 0.27191606f, 
    0.25332880f, 0.15727623f, 0.08173671f, 0.07844634f, 0.75551909f, -0.01419206f, -0.57255292f, -0.38961095f, 
    -0.12090432f, 0.45152313f, 0.40278250f, -0.08231292f, -0.04207655f, 0.21009530f, 0.00273259f, 0.29866666f, 
    -0.32681060f, 0.10985172f, 0.06025966f, 0.09301293f, 0.00710753f, 0.00018122f, 0.01637308f, -0.08558290f, 
    -0.13896310f, 0.30880165f, 0.04101871f, -0.10970261f, 0.09308231f, 0.23291914f, -0.34234184f, -0.37001124f, 
    -0.66979218f, -0.45846197f, 0.18605298f, 0.40189260f, -0.33481315f, -0.19471727f, -0.16521692f, -0.41998541f, 
    -0.34180307f, 0.09625564f, 0.24834526f, -0.08437305f, -0.25156990f, 0.11065980f, -0.17906646f, 0.19584565f, 
    0.26207352f, 0.08768389f, 0.02631557f, -0.18653952f, 0.04342270f, -0.05759387f, 0.23087876f, 0.19120915f, 
    0.49738145f, 0.68621105f, 0.27787921f, 0.53716731f, 0.26271611f, -0.14944492f, 0.26699686f, -0.29827046f, 
    -0.02666810f, 0.27733472f, 0.04036712f, 0.07783170f, -0.11642092f, 0.23783842f, 0.03312112f, -0.26986954f, 
    -0.23415653f, -0.18316314f, 0.21603523f, 0.20488299f, 0.11625624f, 0.07804386f, 0.31463447f, 0.09431411f, 
    -0.25319365f, -0.37997970f, -0.34800184f, -0.38228655f, -0.11990573f, 0.45102027f, 0.64320481f, -0.26872256f, 
    0.32188693f, -0.06370004f, 0.19453052f, -0.26716059f, -0.26595047f, -0.23649576f, -0.07076339f, -0.09058888f, 
    -0.00770123f, 0.19800538f, -0.26232871f, 0.00549198f, -0.01394877f, -0.30398586f, -0.11828089f, -0.06875831f, 
    -0.41328335f, -0.46374035f, 0.10928564f, 0.12177926f, -0.26484516f, 0.10396323f, 0.51261485f, -0.25006381f, 
    0.32764751f, 0.03071776f, 0.11839875f, -0.29479891f, -0.05368683f, -0.25957674f, -0.19360776f, 0.24778791f, 
    0.36359632f, 0.32296214f, 0.28883812f, -0.36480144f, 0.13613997f, -0.10546964f, 0.11308428f, 0.20999743f, 
    0.25962454f, -0.00483037f, -0.03258532f, -0.50180501f, -0.40360796f, 0.36521351f, 0.41978109f, 0.31853470f, 
    -0.49799702f, -0.28147900f, -0.36217394f, -0.14053948f, 0.25340447f, -0.01457041f, 0.19982365f, 0.44044396f, 
    -0.09186342f, -0.03239864f, 0.19061911f, -0.19913708f, 0.15607055f, -0.08335031f, 0.22806576f, 0.02766402f, 
    0.06512888f, 0.21708700f, -0.03647871f, -0.44314727f, -0.15975933f, -0.18310460f, 0.00090141f, -0.52133226f, 
    -0.32314634f, 0.18653533f, -0.20827690f, -0.48792738f, -0.01152000f, 0.15969539f, 0.23660745f, -0.01725990f, 
    -0.07797520f, 0.22881593f, -0.31238210f, -0.34245685f, -0.42917097f, 0.17261910f, -0.35956395f, 0.04496074f, 
    0.12656891f, 0.23935826f, -0.12469184f, -0.47035640f, -0.65209991f, -0.21162376f, -0.29195675f, -0.19219139f, 
    -0.39305902f, -0.29766843f, -0.28417668f, -0.10071024f, 0.24802810f, 0.22754405f, 0.19437256f, -0.24616969f, 
    0.16718741f, 0.04088218f, 0.11757541f, -0.08189267f, 0.32681122f, -0.14354259f, -0.17536493f, 0.13655695f, 
    -0.08242729f, -0.06641033f, 0.30505094f, -0.00576551f, -0.05414679f, -0.19268689f, -0.60023683f, -0.46901914f, 
    -0.20518094f, 0.58710438f, 0.34919021f, 0.13098709f, 0.36768246f, 0.44261602f, -0.29010689f, 0.04590643f, 
    0.18465123f, -0.29325938f, -0.18519726f, -0.06005264f, 0.14880498f, 0.17105810f, 0.26648456f, -0.31024560f, 
    -0.17857131f, 0.01064560f, -0.37618253f, -0.01546631f, 0.23247893f, -0.40174833f, -0.37090811f, -0.40227571f, 
    0.08208258f, 0.26525697f, 0.21963736f, -0.06249923f, -0.04653833f, 0.02997143f, -0.35248151f, -0.15646078f, 
    0.29989555f, -0.06961889f, 0.00094190f, 0.08782375f, 0.22345437f, -0.11228128f, -0.33686918f, 0.31615406f, 
    0.26325545f, -0.19537166f, -0.02250990f, -0.00748327f, -0.14053975f, -0.31097144f, -0.37319499f, -0.71205926f, 
    -0.65400064f, -0.10597855f, -0.01245195f, -0.70506620f, 0.41575113f, 0.52148128f, -0.45553392f, 0.17522216f, 
    0.09860799f, -0.14224495f, 0.10825785f, 0.03487932f, 0.40176949f, 0.18305930f, 0.02422489f, -0.16719618f, 
    0.12320424f, 0.10943671f, 0.06327917f, 0.13836098f, -0.11751976f, -0.17647068f, 0.16345954f, 0.48606497f, 
    -0.00172018f, 0.22402284f, -0.21446112f, -0.42630634f, -0.47792748f, -0.04601956f, 0.03089560f, 0.38792837f, 
    -0.05637621f, -0.26726687f, 0.19087747f, -0.02413989f, -0.30042541f, -0.25435817f, 0.05635836f, 0.14849374f, 
    -0.20409055f, 0.29033703f, -0.23946884f, -0.12937775f, -0.08855239f, -0.16269179f, -0.21657707f, -0.31801957f, 
    0.08207011f, -0.01043982f, -0.57804495f, -0.37911040f, 0.11841704f, 0.10319873f, -0.51182115f, 0.16221522f, 
    0.48988760f, -0.31996211f, -0.52047366f, -0.15564522f, 0.23752871f, 0.19936022f, -0.07189711f, -0.00575092f, 
    -0.35797146f, -0.04375711f, 0.00858977f, 0.22478536f, 0.29822099f, 0.31942767f, -0.26543853f, -0.03982488f, 
    -0.13506237f, 0.53689355f, -0.25463822f, 0.02925235f, 0.24245642f, 0.29700074f, 0.55382258f, -0.08486000f, 
    0.20276527f, -0.18563721f, 0.07407997f, 0.03024458f, 0.13888894f, 0.23327661f, -0.31022686f, -0.24747142f, 
    -0.14249374f, -0.16907980f, 0.17068277f, -0.16436492f, 0.06568854f, -0.04262474f, 0.14842264f, 0.18447055f, 
    0.02002419f, 0.08641794f, 0.45169345f, 0.36161190f, 0.35378265f, 0.80747575f, 0.43808976f, 0.10869381f, 
    0.01923417f, -0.24090438f, -0.31336603f, 0.39095163f, 0.41834676f, 0.05616814f, 0.11614134f, -0.13539174f, 
    -0.18434702f, -0.24545716f, 0.00150243f, 0.08041149f, 0.02675829f, -0.14877507f, 0.05426971f, -0.02654817f, 
    0.05971132f, 0.00723333f, -0.14083022f, 0.05676439f, -0.27524719f, -0.50509721f, 0.21260488f, -0.23492108f, 
    0.30817616f, -0.61323243f, -0.29156965f, -0.01023016f, 0.13790843f, 0.05274890f, 0.01072059f, 0.11166184f, 
    0.15912797f, 0.32189888f, -0.31905055f, -0.32090342f, 0.08666620f, -0.02475174f, 0.20170526f, -0.19938120f, 
    -0.02447234f, -0.02255879f, -0.33661771f, -0.45691577f, 0.17199312f, -0.31299967f, 0.33055362f, 0.08330077f, 
    0.63917160f, -0.67882341f, -0.31427231f, 0.11193685f, -0.28151575f, -0.31447992f, -0.01784469f, -0.19439480f, 
    0.02290576f, 0.15731482f, 0.32064998f, 0.21167694f, -0.07260719f, 0.17750579f, -0.15874323f, -0.04898652f, 
    0.01947827f, -0.05272397f, -0.24803141f, -0.00851425f, 0.03869034f, -0.13355519f, -0.51028281f, -0.35687876f, 
    -0.25217992f, -0.29496405f, -0.41457132f, 0.00616132f, 0.23011240f, -0.11633871f, 0.20610474f, -0.20380239f, 
    0.10831095f, 0.25524959f, 0.09846745f, -0.15285961f, -0.15473600f, 0.25842491f, 0.35152715f, -0.11368839f, 
    0.11476336f, 0.07929341f, 0.44446266f, -0.38607821f, 0.14113137f, -0.01270746f, 0.50233024f, 0.58759540f, 
    0.51034880f, -0.10536211f, 0.33541566f, -0.52666199f, 0.14705952f, 0.15585716f, -0.22696950f, -0.49354219f, 
    0.17245783f, -0.27003220f, -0.16830213f, -0.02298211f, 0.28574100f, 0.09497941f, -0.16887058f, 0.24943550f, 
    -0.00683803f, 0.15865068f, 0.01021560f, -0.10193111f, 0.08720849f, 0.03420203f, 0.19142155f, 0.23822185f, 
    0.49403948f, 0.30771747f, 0.62861258f, 0.31906220f, 0.40149501f, 0.22063710f, 0.40792131f, 0.18029684f, 
    0.18963876f, -0.34223318f, -0.21091172f, -0.23724468f, -0.21749306f, -0.40353224f, -0.11199673f, 0.11855336f, 
    0.06177366f, -0.15356234f, 0.01285111f, 0.03739440f, -0.12382895f, -0.11437866f, -0.16864493f, 0.18886994f, 
    0.25529844f, 0.22001423f, 0.28400174f, 0.06341285f, 0.57408279f, 0.26722232f, -0.31093583f, 0.03957219f, 
    -0.18292955f, 0.01446719f, 0.29910243f, 0.19222501f, 0.13940492f, 0.12092835f, -0.11756556f, 0.23276216f, 
    -0.21214692f, -0.29118133f, -0.02338832f, -0.41645956f, 0.25832886f, -0.17274834f, 0.07040606f, 0.29399860f, 
    0.31623083f, -0.45608708f, 0.13698819f, 0.38787305f, -0.37259582f, 0.24018049f, -0.23215392f, 0.08147989f, 
    -0.05813447f, 0.04824644f, -0.52817756f, 0.30676439f, 0.07045408f, -0.17657667f, 0.30256382f, -0.07283928f, 
    -0.46574011f, -0.42374915f, 0.03145813f, -0.46510085f, 0.25500277f, -0.24815059f, -0.02902313f, 0.16034307f, 
    -0.14697346f, 0.30781984f, -0.76851147f, -0.69010752f, 0.42419222f, 0.22950910f, -0.10913718f, 0.49035949f, 
    0.38809797f, 0.29669327f, 0.17368993f, 0.04263131f, -0.19329053f, -0.09311792f, 0.22741915f, 0.31565553f, 
    0.27498364f, 0.00523762f, 0.22335891f, 0.09388666f, 0.00996822f, 0.20075743f, -0.16698417f, 0.15038428f, 
    -0.02493541f, -0.03235126f, 0.00561297f, 0.60188299f, 0.36517331f, 0.42640194f, 0.02736439f, 0.71705651f, 
    -0.25418711f, -0.18608913f, -0.08984773f, 0.05683061f, 0.37365255f, 0.13639913f, -0.22143053f, -0.23957616f, 
    0.10268214f, -0.29072306f, 0.16400233f, -0.26866531f, 0.04115422f, 0.23992862f, 0.04865524f, 0.40146828f, 
    0.21706341f, 0.12872216f, -0.00902909f, 0.13040414f, -0.21317434f, -0.43759236f, 0.32757810f, 0.75413722f, 
    0.01878087f, 0.10032157f, 0.53207505f, 0.40264022f, -0.16500665f, -0.00275497f, -0.15629496f, -0.14549558f, 
    0.09279391f, 0.28159094f, 0.05387360f, -0.21947530f, -0.11019531f, 0.17809655f, 0.20979960f, -0.11036457f, 
    0.05882828f, -0.06499243f, -0.37847906f, 0.01946601f, -0.47623822f, -0.50674081f, 0.73683470f, 0.11205836f, 
    -0.61006594f, 0.16643298f, 0.11066635f, -0.41852042f, -0.37175378f, -0.03836302f, -0.62295312f, -0.01829684f, 
    0.12911288f, -0.30014247f, -0.19014829f, -0.23318119f, -0.18384045f, 0.25100985f, -0.24323891f, -0.08980955f, 
    -0.02630921f, 0.03211891f, 0.09363716f, 0.06896544f, 0.31751239f, -0.16976468f, -0.48288357f, -0.84369695f, 
    -0.02572485f, 0.17736977f, -0.24893492f, 0.15645394f, 0.54115295f, 0.47044268f, 0.08330771f, 0.39567542f, 
    0.01774574f, -0.05395448f, -0.15052740f, 0.37371913f, 0.01755642f, -0.27047074f, -0.07675574f, -0.08458004f, 
    -0.16076723f, 0.00057297f, -0.15882064f, -0.11418267f, 0.00565022f, -0.17157499f, -0.12302057f, -0.02367237f, 
    0.37013462f, 0.41403049f, 0.14908591f, 0.36490080f, 0.03735924f, -0.06222257f, 0.29737869f, -0.24142100f, 
    0.43787774f, -0.22767234f, -0.11080191f, 0.09915151f, 0.19399160f, 0.20126370f, 0.14596541f, 0.16220298f, 
    -0.10373961f, 0.30267081f, -0.12391804f, -0.21730305f, -0.21592236f, 0.17487876f, -0.30036673f, 0.31983885f, 
    -0.53894395f, -0.20197918f, -0.07818348f, 0.04366232f, 0.61374938f, -0.34398824f, -0.30871731f, -0.32250783f, 
    -0.31047457f, 0.17886281f, -0.14167200f, 0.37994087f, 0.08890628f, -0.35256770f, -0.30044571f, 0.16684231f, 
    -0.19551684f, 0.20034921f, -0.00680427f, -0.15952350f, -0.19655780f, -0.24402185f, -0.02405050f, -0.03698403f, 
    -0.06556943f, -0.11459093f, -0.20373943f, 0.09284953f, 0.14939803f, -0.56047368f, -0.24992771f, -0.18295902f, 
    -0.21344455f, -0.40302345f, 0.41172883f, 0.30350545f, 0.27704841f, -0.52988642f, -0.22672743f, -0.01008905f, 
    0.03024442f, -0.38969240f, -0.01043277f, 0.19091533f, 0.24644631f, -0.00932419f, -0.29509386f, -0.09789844f, 
    -0.22070186f, 0.07774209f, -0.42117527f, -0.35064384f, 0.03295500f, -0.41667005f, -0.49411753f, 0.23024952f, 
    -0.12781999f, -0.21256925f, 0.10134235f, 0.27905625f, 0.17985031f, 0.14464937f, -0.26457134f, 0.18685177f, 
    0.26362124f, -0.29685423f, 0.19110231f, 0.18541792f, 0.04845141f, 0.17080326f, 0.24078530f, 0.18902288f, 
    0.01620269f, 0.01565845f, 0.01244333f, -0.48227748f, 0.17221676f, -0.32038245f, -0.28969532f, 0.27462599f, 
    0.19815297f, 0.57181048f, -0.42762423f, 0.21929574f, 0.57290733f, -0.00459166f, 0.11218630f, 0.26501572f, 
    -0.30186057f, 0.11644532f, 0.13928388f, 0.20684479f, 0.27781931f, -0.03421163f, -0.15679637f, -0.00572914f, 
    -0.26287016f, -0.27727348f, -0.09582005f, -0.01409681f, 0.29001561f, -0.07137302f, -0.06394800f, 0.45047018f, 
    0.00110225f, 0.47564647f, 0.80992484f, -0.20210764f, 0.17091502f, 0.40034294f, -0.17463346f, 0.04399269f, 
    -0.13749093f, 0.17437984f, 0.06644089f, -0.07317559f, -0.13457690f, -0.09094099f, -0.19189245f, -0.31372172f, 
    0.04308386f, -0.08265011f, 0.19366784f, -0.06461827f, -0.05299066f, -0.49479851f, -0.31397682f, -0.55680424f, 
    -0.25849071f, -0.13696049f, 0.26169062f, -0.16255701f, -0.27296558f, 0.21640807f, 0.34407851f, 0.04109440f, 
    -0.11261587f, -0.18638663f, -0.23321009f, -0.17623197f, 0.18647689f, 0.23264869f, 0.33514604f, -0.20214041f, 
    0.31393287f, -0.03733629f, 0.05196020f, -0.21916084f, -0.29622644f, 0.15007818f, -0.50997204f, 0.51691288f, 
    0.58640122f, -0.06741228f, 0.23903476f, 0.45278499f, 0.11841904f, 0.17197500f, 0.09584484f, 0.07301989f, 
    0.14452583f, 0.04759051f, 0.20733836f, -0.23836510f, -0.30594590f, -0.17608792f, 0.07215589f, 0.13316749f, 
    -0.27438930f, -0.17634754f, -0.05095590f, -0.07033978f, -0.12211035f, -0.10404572f, -0.29114562f, -0.22626953f, 
    -0.30542684f, -0.14332187f, -0.33802113f, -0.42794251f, -0.02345876f, 0.06080941f, -0.04215044f, -0.38558105f, 
    0.34069219f, 0.05018139f, -0.00926484f, 0.20383729f, 0.10343453f, -0.34598237f, 0.18769050f, -0.04997307f, 
    -0.00622263f, 0.14008994f, -0.41465634f, -0.25575045f, -0.25726447f, 0.24659204f, 0.20829722f, 0.21459594f, 
    -0.17356990f, -0.25830954f, -0.18288147f, 0.39437816f, -0.36908627f, 0.29687157f, -0.51533335f, 0.19847992f, 
    -0.27359709f, -0.58895028f, -0.23011909f, -0.17955129f, 0.29587060f, -0.15181535f, 0.22891739f, -0.16864485f, 
    -0.06145770f, -0.39787334f, -0.04259646f, 0.07152800f, -0.04208223f, 0.15737878f, 0.11202412f, -0.13808821f, 
    0.10612012f, 0.60764104f, 0.31932780f, -0.54791105f, 0.28672642f, -0.45696947f, -0.15561563f, -0.26039109f, 
    0.21550347f, -0.18227619f, -0.38289371f, -0.48625991f, -0.14813486f, 0.12867533f, 0.19981003f, -0.01660877f, 
    -0.26334414f, -0.13393563f, -0.04870174f, -0.08304166f, -0.13330513f, 0.16293110f, 0.00233403f, -0.19411629f, 
    -0.27822542f, -0.15937293f, -0.07831060f, -0.50867033f, -0.51965052f, 0.10674679f, 0.20222817f, 0.42254773f, 
    0.41682392f, -0.41707730f, 0.28107616f, -0.19168909f, -0.31541800f, 0.37284416f, -0.21004851f, 0.17225042f, 
    0.10220401f, -0.13061742f, 0.15477109f, -0.21202727f, -0.07728656f, -0.33640724f, 0.05211886f, -0.05790173f, 
    0.17815696f, 0.12457043f, 0.17016213f, -0.02573765f, -0.48636815f, -0.46333659f, -0.12638561f, -0.39133281f, 
    0.45286924f, 0.64730573f, -0.07403545f, 0.62857455f, 0.53937453f, -0.20241341f, -0.04631780f, 0.05404932f, 
    -0.15691765f, -0.22803611f, -0.11988336f, -0.21417575f, 0.18580504f, -0.18470053f, 0.13048325f, -0.12614462f, 
    -0.21429963f, 0.12436068f, -0.00874951f, 0.08957162f, 0.06718899f, 0.20981494f, 0.18834740f, 0.35421577f, 
    0.69760758f, 0.23138675f, -0.01924100f, -0.38420260f, 0.07961772f, 0.00095483f, -0.23219608f, -0.23261626f, 
    0.22436725f, 0.02373337f, 0.24874708f, 0.13428538f, 0.16991262f, 0.16840780f, 0.27635089f, 0.24935773f, 
    -0.03923243f, 0.08044404f, 0.01914450f, -0.30837503f, -0.38321173f, -0.70686591f, -0.50454926f, -0.03950606f, 
    0.18135536f, 0.42377236f, -0.29052991f, -0.16001572f, -0.22313203f, -0.41843334f, 0.05034425f, 0.17573565f, 
    0.15861034f, -0.29986235f, -0.19139211f, -0.09758766f, -0.22056948f, 0.05752407f, 0.39515832f, 0.27713495f, 
    0.03583606f, -0.10834266f, -0.18528950f, -0.11285053f, 0.00523667f, -0.04889201f, 0.97327238f, -0.14514412f, 
    -0.25874537f, 0.70282948f, 0.34614232f, -0.34282899f, -0.04293959f, 0.06786519f, -0.19753814f, -0.22551107f, 
    -0.14765222f, -0.27019966f, -0.11057176f, -0.12178549f, 0.20382561f, 0.13654473f, 0.08615968f, -0.03931106f, 
    0.11910008f, 0.33103168f, -0.18497334f, 0.05175653f, 0.02520697f, -0.05156301f, -0.05681813f, -0.37191364f, 
    -0.39176041f, -0.46413428f, -0.16087148f, 0.17889065f, 0.15408206f, 0.01592411f, -0.03133478f, -0.04249027f, 
    -0.69272661f, -0.26768422f, 0.01526488f, -0.25512022f, 0.08197406f, 0.33205950f, 0.22951220f, 0.06736848f, 
    0.23450981f, 0.04531626f, 0.07094379f, 0.16652536f, -0.17813247f, -0.10995784f, 0.23985228f, 0.13812989f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15812437f, 0.10658725f, 0.06028021f, -0.02421304f, 0.09435687f, 0.17774653f, 0.21147706f, 0.05433627f, 
    0.08960152f, 0.12008253f, 0.01189485f, -0.00930651f, 0.05919570f, 0.28543723f, -0.00788164f, -0.03428154f, 
    -0.00931434f, 0.13487391f, 0.03609581f, 0.04386560f, 0.16435154f, 0.05127760f, 0.29323113f, -0.15859240f, 
    -0.06639373f, 0.24633530f, 0.20809025f, -0.02240374f, 0.07430692f, -0.19432731f, 0.07365425f, -0.11128571f, 
    0.22347729f, -0.04841196f, 0.04691670f, 0.23255153f, 0.21409890f, 0.17613475f, -0.13276601f, 0.00567862f, 
    0.05010550f, -0.03108914f, 0.25898820f, 0.03727371f, 0.16279951f, 0.21941407f, 0.01405559f, -0.07055053f, 
    0.00976906f, -0.06522896f, 0.19593745f, 0.08135315f, -0.01793264f, -0.03926902f, 0.08075029f, -0.04862264f, 
    0.22099747f, 0.07724333f, 0.04882815f, 0.01723202f, 0.18963198f, 0.26709825f, -0.20579913f, -0.05107114f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00183900f, 0.01505558f, -0.03859233f, 0.02000266f, -0.02207876f, -0.00792557f, 0.02381991f, -0.04113188f, 
    -0.02720869f, 0.01603895f, -0.00504198f, -0.04084020f, 0.00447161f, -0.00317735f, -0.00022535f, -0.03523030f, 
    0.00310755f, 0.01407766f, -0.03795448f, -0.02196817f, -0.02242142f, 0.02368285f, 0.01194164f, 0.00640117f, 
    -0.02631607f, -0.01979377f, 0.02629676f, -0.03808886f, 0.00791193f, 0.00458874f, 0.00061356f, -0.00695994f, 
    -0.02812026f, 0.02426906f, -0.04045674f, 0.02566150f, 0.02790648f, -0.00364011f, 0.02563015f, 0.02943094f, 
    -0.02678055f, -0.03935065f, 0.00260629f, -0.02200473f, 0.02583680f, -0.03064169f, -0.01668765f, 0.01335054f, 
    0.02249387f, -0.01757560f, -0.04206661f, -0.02442143f, -0.03827500f, -0.01575398f, 0.00582964f, -0.01918047f, 
    0.02867289f, -0.02261652f, 0.04052301f, -0.04022655f, 0.01985888f, 0.01796527f, -0.03449181f, 0.02830118f, 
    -0.00364651f, 0.02965950f, -0.00443401f, -0.01648979f, -0.03674769f, -0.00159956f, 0.02315148f, -0.02058346f, 
    0.02796803f, 0.01130673f, 0.02755677f, -0.04160144f, -0.02143886f, 0.00088459f, 0.00441400f, -0.01084349f, 
    0.02797802f, -0.01230666f, -0.01569268f, -0.01808894f, 0.01774881f, 0.02999908f, -0.04055931f, -0.02392431f, 
    0.01069062f, 0.02254196f, -0.00178751f, 0.02333541f, 0.03205241f, 0.00247396f, -0.04037086f, -0.03484976f, 
    0.02553876f, -0.00131805f, 0.01091213f, -0.00277265f, 0.02266088f, 0.01435959f, 0.02764731f, -0.02973465f, 
    -0.00986105f, 0.01768499f, 0.01357054f, 0.00558311f, -0.01140349f, 0.02549810f, 0.01813983f, 0.02758292f, 
    -0.00847141f, 0.02085695f, -0.03652896f, 0.00706589f, -0.00420245f, 0.00977532f, -0.00825747f, 0.02880382f, 
    0.00356438f, 0.01538049f, -0.03581776f, -0.02026911f, -0.00782567f, -0.00323833f, 0.00534245f, -0.03563956f, 
    -0.02298881f, 0.02028835f, -0.03125795f, 0.00489379f, -0.00538960f, -0.01446632f, -0.03880306f, -0.01512904f, 
    0.02021643f, -0.01417567f, -0.00898709f, -0.00221832f, 0.02995164f, 0.01130651f, 0.01133613f, -0.03842634f, 
    -0.02305251f, 0.02823361f, -0.01601190f, -0.00004599f, -0.02264620f, 0.01160545f, -0.01276653f, -0.02291466f, 
    -0.01022303f, -0.00055191f, -0.02667552f, 0.02543424f, -0.00369556f, -0.02542499f, -0.02493169f, -0.02658896f, 
    -0.01233487f, 0.02237868f, -0.02553692f, 0.01250891f, -0.00359988f, -0.01840089f, -0.01931014f, -0.03159848f, 
    0.02138186f, 0.02876301f, 0.00736258f, -0.01271778f, -0.02435475f, -0.04093121f, -0.01815221f, -0.00272770f, 
    0.00420284f, -0.01207908f, -0.02777622f, 0.00576073f, -0.01651846f, 0.01239923f, -0.02399465f, 0.01190685f, 
    0.01697378f, -0.02132831f, -0.00055563f, -0.02254988f, -0.01346026f, 0.00510577f, -0.00518285f, 0.00944256f, 
    0.02172818f, -0.02817387f, 0.00270621f, 0.02729934f, -0.01507462f, 0.02530721f, -0.00069934f, -0.03107987f, 
    -0.02407306f, -0.02590332f, -0.00400871f, 0.00690763f, -0.02591117f, 0.02348291f, 0.00140071f, 0.01909675f, 
    0.00842232f, 0.01297214f, -0.02011216f, 0.02664146f, -0.03461266f, 0.01819742f, 0.02729025f, -0.01339553f, 
    -0.03747738f, -0.03468562f, -0.02805113f, 0.00094025f, 0.02708980f, -0.03589946f, -0.01562657f, 0.00030273f, 
    -0.03031580f, -0.03929703f, 0.01233322f, -0.00133350f, 0.02321755f, -0.00143926f, -0.00253077f, -0.01457375f, 
    -0.03603958f, 0.02021745f, -0.00448635f, 0.02126656f, 0.02496425f, 0.01614374f, -0.01418728f, -0.02602654f, 
    -0.03001228f, -0.03471850f, -0.02330855f, -0.03020198f, -0.01623180f, 0.02121104f, -0.00192459f, 0.01549952f, 
    0.02592521f, -0.00108865f, -0.00678431f, -0.03532496f, 0.01492514f, -0.02024126f, -0.00073635f, -0.03831976f, 
    0.00053689f, -0.01537852f, -0.03315667f, 0.01090110f, 0.00297954f, -0.04053875f, 0.00001030f, 0.02957957f, 
    0.01155226f, 0.00128840f, 0.00540311f, 0.02250435f, -0.01826971f, -0.03696459f, 0.02089305f, -0.02513012f, 
    0.00519661f, -0.01444767f, -0.02118857f, 0.01337436f, -0.04016247f, 0.01123438f, 0.00745774f, 0.02325430f, 
    -0.03765306f, 0.02373599f, -0.00814255f, -0.02616046f, -0.00047743f, -0.00893856f, -0.03957826f, -0.00815971f, 
    -0.03310633f, 0.00717806f, -0.01335882f, 0.00222905f, 0.02237015f, -0.00002928f, -0.02905579f, 0.01208374f, 
    -0.00057308f, 0.01269561f, -0.02440056f, 0.02721267f, 0.01702683f, -0.00613241f, 0.01524423f, 0.00544701f, 
    0.02955162f, -0.02134978f, 0.00311513f, -0.03549310f, -0.01336165f, 0.01999634f, -0.02668508f, -0.02925456f, 
    -0.03282421f, -0.03970713f, 0.01596513f, 0.00921923f, -0.03590582f, -0.02628400f, -0.02247457f, -0.00122146f, 
    0.01523678f, -0.02339254f, 0.02094475f, -0.02094716f, -0.00926429f, -0.02121766f, -0.00806223f, -0.03975645f, 
    0.02075799f, -0.03609939f, -0.02354719f, 0.03544979f, 0.00373213f, -0.03818544f, 0.01196717f, -0.00813761f, 
    -0.01146624f, -0.00551893f, -0.00523431f, -0.02780931f, 0.00557491f, -0.00314447f, -0.01825706f, -0.03931522f, 
    0.03003491f, 0.00326353f, 0.02254716f, 0.03008498f, -0.03222936f, -0.02775372f, -0.02965157f, 0.01383352f, 
    -0.02389219f, -0.01749824f, -0.00118392f, -0.03866310f, 0.02483634f, -0.03995063f, 0.00785033f, 0.01926429f, 
    -0.03753294f, 0.00091769f, -0.02090991f, -0.03503390f, -0.02463791f, -0.02669092f, 0.02015177f, -0.03017550f, 
    -0.02017954f, 0.02085328f, -0.01743819f, -0.01279532f, 0.02744102f, 0.00609659f, 0.02091928f, 0.01281571f, 
    -0.02856760f, -0.00554193f, -0.01137187f, -0.02307904f, 0.01060353f, -0.04085467f, -0.02691983f, 0.02554563f, 
    -0.02302889f, -0.01428234f, -0.03417988f, -0.03506577f, -0.02228079f, -0.03573046f, -0.00919802f, -0.02848700f, 
    -0.02898204f, -0.03719359f, 0.00603923f, -0.01182651f, -0.01434212f, 0.01070983f, -0.00770907f, -0.02352130f, 
    -0.02750243f, 0.02806948f, -0.00746797f, -0.01391802f, 0.01419982f, 0.01810990f, -0.03688883f, 0.00876288f, 
    -0.02486438f, -0.03279601f, -0.02504586f, -0.02936256f, 0.02234693f, -0.01447622f, -0.02159089f, -0.02367747f, 
    -0.00141068f, -0.03810521f, -0.03296763f, -0.03425899f, -0.02408942f, 0.02731713f, -0.00971666f, 0.00699348f, 
    -0.01451756f, 0.00582895f, -0.01764092f, -0.01086300f, -0.00812577f, 0.02621182f, -0.03030376f, -0.00992907f, 
    -0.02663643f, 0.02564576f, -0.01501621f, -0.03982814f, -0.03765516f, -0.00339190f, 0.01884638f, -0.03506148f, 
    -0.03876622f, 0.02947887f, 0.00276559f, -0.03947809f, 0.02245231f, -0.01107238f, -0.01443578f, 0.00190823f, 
    -0.01561902f, -0.01414680f, -0.02621163f, -0.01626891f, 0.00596607f, -0.01303000f, 0.01762617f, -0.01338845f, 
    0.00076562f, -0.03537521f, -0.02327277f, 0.01343376f, 0.01249857f, -0.02186068f, 0.00849356f, 0.02597710f, 
    -0.00834381f, -0.00699026f, 0.00166029f, -0.00182430f, -0.00260218f, 0.00629647f, -0.01986141f, 0.00519780f, 
    0.00028302f, -0.03880746f, -0.02259742f, 0.01105890f, 0.02289795f, -0.02193984f, -0.00776490f, -0.00942516f, 
    -0.02019807f, -0.00925415f, -0.02398390f, -0.04139224f, -0.03797534f, 0.00091109f, 0.01029229f, 0.00515349f, 
    -0.01985428f, -0.00291124f, -0.03251927f, -0.01276467f, 0.02343380f, -0.03549627f, -0.01746630f, 0.00224284f, 
    0.00017268f, -0.03000152f, 0.01555736f, -0.03058443f, -0.01004389f, -0.04046445f, 0.02354136f, -0.00020808f, 
    0.01437235f, -0.00610444f, -0.01040896f, 0.02931898f, 0.01213920f, 0.02063867f, 0.00664872f, -0.01241860f, 
    0.02543695f, -0.01668205f, -0.02783295f, 0.00108232f, 0.02191620f, -0.01455728f, -0.03639840f, -0.03321552f, 
    -0.02660735f, -0.01317826f, -0.03701027f, 0.02091585f, -0.03555992f, -0.03944850f, -0.01289047f, 0.00452406f, 
    -0.03790878f, -0.03055338f, -0.03529631f, -0.01830070f, 0.01231628f, -0.00894491f, 0.02119425f, -0.03671483f, 
    -0.00561044f, 0.00658879f, -0.03371035f, -0.02509472f, 0.01151782f, 0.02781138f, -0.02524215f, 0.00326656f, 
    0.00288057f, 0.01297786f, -0.02725670f, -0.01661741f, 0.02803373f, 0.02971699f, 0.00863000f, -0.01463176f, 
    -0.03333163f, -0.04061828f, -0.01092023f, 0.02209986f, -0.03509153f, 0.02997445f, 0.02886186f, 0.00724041f, 
    -0.01677390f, -0.00146119f, 0.02896460f, 0.00037862f, 0.00675067f, -0.00151635f, -0.00037552f, -0.01448607f, 
    -0.02316617f, 0.01658237f, -0.00423248f, 0.01436612f, -0.01875073f, 0.00097352f, 0.02441684f, -0.04108124f, 
    -0.01809397f, 0.01598310f, 0.02821412f, 0.01124395f, 0.02501652f, -0.02013953f, 0.01069927f, -0.01376905f, 
    -0.03532348f, -0.01385986f, 0.02117656f, 0.00751707f, 0.02157066f, -0.01928033f, -0.01644636f, -0.03758853f, 
    0.00204517f, -0.01452659f, -0.03427808f, -0.04123194f, 0.02294327f, -0.00645415f, 0.00047060f, 0.00150760f, 
    -0.00118935f, -0.01705522f, -0.01830444f, 0.00434142f, -0.00562340f, -0.00983621f, 0.00389362f, 0.00866838f, 
    0.01614618f, -0.01837733f, -0.02548276f, -0.00705376f, 0.02388505f, 0.02912116f, 0.01401282f, 0.01578776f, 
    0.00939088f, -0.01564023f, -0.01748307f, 0.02196084f, -0.01481114f, -0.01845967f, 0.00670733f, -0.00119940f, 
    0.02076541f, 0.00006801f, -0.00777322f, -0.00338690f, -0.01651099f, 0.00685252f, -0.02975735f, -0.00144862f, 
    -0.00808582f, 0.02485224f, 0.02774020f, 0.01570781f, -0.01687049f, -0.04100940f, -0.03382503f, -0.00535345f, 
    -0.00895727f, -0.03045805f, -0.03334378f, 0.01253846f, 0.01998524f, -0.00077053f, 0.02514443f, -0.02311291f, 
    -0.00789477f, 0.00040032f, -0.02079899f, -0.03195538f, -0.03594552f, 0.00401041f, 0.02931711f, -0.03451765f, 
    -0.03081686f, -0.03463841f, 0.01057440f, -0.04125486f, 0.02714995f, -0.00879505f, 0.02136547f, -0.00785669f, 
    0.01988598f, -0.00086796f, -0.01229166f, 0.00835382f, -0.02733495f, -0.02701492f, -0.02887773f, 0.00462803f, 
    0.02360468f, 0.00656106f, -0.02046878f, -0.02582866f, -0.00607812f, -0.02076557f, 0.00812975f, 0.01548870f, 
    -0.02727508f, -0.02421575f, 0.01032994f, -0.00504044f, 0.00956031f, -0.01512527f, -0.01059871f, -0.00259636f, 
    -0.01842209f, -0.00645282f, -0.03919367f, -0.01797586f, -0.02792513f, -0.00321197f, -0.02703248f, -0.04082623f, 
    0.01512828f, -0.04178830f, -0.03150047f, 0.01452508f, -0.02750052f, 0.02596463f, -0.01199269f, 0.00538008f, 
    0.00401162f, -0.00401123f, 0.01544533f, -0.03704209f, -0.01120094f, 0.00966047f, 0.01633480f, -0.03045683f, 
    -0.00753999f, -0.00730365f, -0.03694803f, 0.00184562f, -0.03938835f, -0.01569041f, 0.01330679f, -0.03823839f, 
    -0.02375254f, 0.00668097f, 0.01197443f, 0.00609597f, -0.04038408f, -0.04031619f, 0.02734478f, 0.01445823f, 
    -0.01095814f, -0.01097686f, 0.00248147f, 0.00935033f, -0.00343071f, -0.00446125f, 0.00153462f, -0.02949001f, 
    0.00896298f, -0.02573234f, -0.00074941f, -0.00089287f, -0.01430029f, -0.00143709f, -0.00467837f, 0.01866075f, 
    -0.02455379f, -0.00732082f, -0.01857635f, 0.01832831f, -0.01460404f, -0.00852012f, -0.02686467f, -0.01078495f, 
    0.01422287f, -0.00534681f, -0.03199901f, -0.01002185f, 0.02638540f, 0.00202906f, -0.02191326f, -0.02282728f, 
    -0.00952650f, 0.00351865f, 0.00871803f, -0.02381810f, -0.03262655f, -0.00749540f, -0.01066245f, -0.00851358f, 
    0.04217602f, -0.07972579f, 0.10166927f, -0.11954738f, -0.01162941f, 0.05354971f, 0.04961160f, -0.09024070f, 
    0.00266478f, 0.07395808f, 0.01247384f, -0.02487645f, 0.07521294f, 0.03259122f, -0.08099383f, -0.14327429f, 
    0.00077160f, -0.02343722f, -0.02344416f, 0.03282405f, -0.04101898f, -0.03094142f, 0.04808708f, 0.04484970f, 
    -0.00925663f, 0.07814085f, 0.11545187f, 0.26745322f, 0.07461079f, 0.02260634f, -0.07177933f, 0.04016943f, 
    -0.00524365f, 0.10162076f, -0.07237978f, 0.05133124f, 0.25879806f, 0.19074751f, 0.06190717f, -0.26475784f, 
    0.01362144f, 0.08651888f, 0.05368265f, -0.15880063f, -0.01175453f, -0.06647765f, 0.04552994f, 0.07166854f, 
    0.26060778f, 0.08094412f, -0.01903730f, -0.04884337f, -0.04278395f, -0.00534023f, -0.06448879f, -0.11479069f, 
    0.03880476f, 0.05665693f, -0.04402683f, 0.09306631f, -0.32560667f, 0.13687102f, -0.08116389f, -0.00683584f, 
    -0.04093739f, 0.05422688f, 0.09283213f, -0.00373824f, -0.02263601f, -0.04016056f, 0.02653178f, -0.00019980f, 
    0.03963676f, -0.08092171f, 0.06766595f, 0.04520366f, -0.09185234f, -0.07709478f, -0.01880292f, 0.00003674f, 
    0.04667639f, 0.06581748f, 0.01266681f, 0.07165917f, 0.25793698f, 0.09308636f, -0.10948439f, 0.18941712f, 
    0.04770285f, 0.08083986f, -0.06473737f, 0.05644221f, 0.13322355f, -0.04786579f, -0.08330918f, -0.01668164f, 
    0.27608904f, 0.10710865f, 0.14394769f, -0.17678286f, 0.09351464f, -0.02297843f, -0.05211700f, 0.03132374f, 
    -0.07674883f, 0.00490457f, 0.02839452f, -0.06293815f, -0.02022627f, 0.07747737f, 0.00077908f, -0.12052390f, 
    0.02400379f, -0.02669140f, -0.03873702f, -0.01403765f, -0.07549215f, 0.01069631f, 0.00430838f, -0.19998266f, 
    0.14016978f, -0.02129942f, -0.00810770f, 0.05346171f, 0.05623876f, 0.13477311f, -0.03847926f, 0.09031788f, 
    0.08078890f, -0.03575610f, 0.08453955f, 0.00707307f, 0.15425444f, 0.06705434f, -0.03503164f, 0.12852563f, 
    -0.00280040f, -0.06518213f, 0.00163198f, -0.08263481f, -0.01540403f, -0.04851204f, 0.09175453f, 0.04454048f, 
    0.35271984f, 0.22774823f, -0.14665717f, -0.02152507f, -0.04100834f, 0.03394192f, -0.00637510f, 0.00978625f, 
    -0.15106308f, 0.00726367f, 0.01215331f, 0.06643922f, -0.07920991f, -0.14825426f, -0.08161665f, -0.00850726f, 
    -0.01475232f, 0.01304657f, -0.03970141f, 0.06151917f, 0.07641689f, -0.03096711f, 0.03010937f, 0.13614464f, 
    0.13553338f, 0.14630684f, 0.07849525f, -0.03271760f, -0.05617044f, -0.08611886f, -0.02571243f, 0.00616973f, 
    -0.01895407f, -0.06567773f, -0.03483893f, 0.00896597f, -0.46066794f, -0.12267298f, 0.16021506f, 0.03010544f, 
    -0.00430807f, 0.01686607f, 0.13837819f, -0.02996622f, -0.10623686f, 0.09304178f, -0.00356082f, 0.04119204f, 
    0.28177571f, -0.08078187f, 0.04486577f, 0.10745101f, 0.04828898f, -0.04358102f, 0.12387290f, -0.08241013f, 
    0.01538966f, -0.02417863f, 0.07976793f, -0.02201444f, 0.11084969f, -0.03204714f, 0.01187628f, -0.05227239f, 
    0.10139506f, 0.03562254f, 0.02028432f, 0.02153944f, 0.01826409f, -0.07241763f, -0.02910495f, -0.00955871f, 
    0.27995208f, -0.11867136f, 0.06199729f, -0.04798007f, -0.07048347f, -0.05687151f, -0.08520164f, -0.00251412f, 
    0.09592411f, 0.16392460f, 0.03015155f, 0.10246306f, 0.25784680f, -0.20694108f, 0.06828079f, 0.07358852f, 
    0.03026363f, 0.02927521f, 0.04528170f, -0.02994894f, 0.12609434f, 0.09390691f, 0.00132229f, 0.08437137f, 
    0.22926439f, 0.25531405f, 0.04285347f, -0.06787252f, 0.02179422f, 0.02936166f, 0.04955970f, -0.02041959f, 
    -0.00180535f, 0.07590596f, 0.05736892f, 0.01317933f, -0.01712866f, 0.13195260f, 0.01207675f, -0.23330964f, 
    0.05344699f, 0.09437850f, -0.11554223f, 0.00703529f, 0.03318862f, 0.03676232f, 0.05696123f, 0.01088672f, 
    0.14332487f, 0.02363208f, 0.16974407f, 0.13436864f, 0.04501968f, 0.04702859f, -0.04981854f, -0.01948333f, 
    -0.00433494f, 0.00625731f, -0.02011123f, -0.00849682f, -0.03525471f, 0.20305352f, -0.21432731f, -0.07240880f, 
    0.02817988f, -0.00707953f, 0.07546531f, 0.08769692f, 0.02777687f, 0.01507367f, -0.00820403f, -0.04630973f, 
    0.20285650f, 0.05665044f, 0.12733567f, 0.07788631f, 0.08874539f, 0.02972863f, 0.00160565f, -0.11467484f, 
    0.09237406f, -0.00370407f, -0.05774064f, 0.03498453f, -0.22370502f, 0.01602178f, 0.03645007f, -0.00703265f, 
    0.02813262f, 0.00898469f, 0.13600014f, -0.00854315f, 0.09473249f, 0.08015665f, 0.02662455f, 0.04321070f, 
    -0.20628542f, 0.00764984f, 0.01127972f, -0.02944333f, -0.05919846f, 0.06877509f, -0.02467748f, 0.02753972f, 
    0.04825382f, -0.01338696f, 0.00447123f, -0.00762178f, -0.23432696f, -0.21978940f, 0.04027652f, 0.02184774f, 
    0.05845617f, 0.06118678f, 0.08791077f, 0.04635103f, 0.06585746f, 0.01645180f, -0.06481831f, -0.12553857f, 
    0.32860056f, 0.06726623f, -0.03694547f, -0.05801782f, 0.18224947f, 0.08689418f, 0.04297458f, 0.03744120f, 
    0.12169784f, 0.02144284f, -0.05441083f, 0.00213158f, -0.02484919f, 0.02883931f, 0.16945614f, 0.08306315f, 
    0.10109033f, -0.05329822f, 0.13806194f, -0.09038126f, -0.04395900f, 0.03425274f, 0.08603344f, -0.01183243f, 
    -0.19740766f, 0.18369727f, -0.01100652f, 0.03223700f, 0.05369916f, 0.07484008f, -0.03742877f, 0.01071083f, 
    0.03177577f, 0.04884560f, 0.05853951f, 0.10444782f, 0.16398805f, -0.06359959f, -0.16438438f, -0.00025331f, 
    0.08720105f, -0.08470872f, -0.03097588f, -0.01265883f, 0.07399631f, -0.06070877f, 0.04552312f, -0.07733183f, 
    -0.13023356f, 0.03274499f, 0.06014157f, -0.01779062f, 0.05236641f, 0.02332408f, 0.00953364f, -0.01338650f, 
    0.07970327f, 0.03552351f, -0.00196965f, 0.06951320f, 0.10450036f, -0.02661311f, 0.09031681f, 0.09513602f, 
    -0.06938999f, -0.03681003f, 0.02949726f, 0.04838084f, -0.09089453f, 0.08984680f, -0.07625601f, -0.03695873f, 
    0.20678411f, 0.18149541f, -0.02314201f, 0.02107007f, 0.07750255f, -0.05445325f, -0.00110367f, 0.02314031f, 
    -0.01874073f, 0.01198662f, 0.04714411f, -0.01104215f, -0.15039881f, -0.13712527f, 0.18015468f, 0.00568281f, 
    -0.03351378f, -0.03202918f, 0.04237699f, 0.04069460f, -0.00766536f, 0.05020678f, 0.06516368f, 0.06919863f, 
    0.11210599f, -0.06570852f, -0.28328869f, -0.25817752f, -0.12357615f, -0.06142021f, -0.07038996f, -0.05783535f, 
    0.02382092f, -0.09590828f, 0.06977803f, 0.06594060f, -0.12867913f, 0.02638474f, 0.01385448f, 0.00363039f, 
    0.17823525f, 0.09395768f, 0.06277458f, -0.02514054f, 0.07185520f, -0.00767644f, -0.05062825f, -0.02127546f, 
    0.36408022f, 0.12526424f, -0.06225124f, -0.00621421f, -0.07364392f, 0.02778802f, -0.01866166f, 0.00863356f, 
    0.03813405f, 0.01251431f, -0.05318860f, 0.05692973f, 0.02900379f, 0.05520632f, 0.14778137f, 0.16112395f, 
    0.10788842f, 0.00397132f, -0.06311486f, -0.01022107f, 0.03563734f, -0.02178212f, -0.09061161f, -0.02506832f, 
    0.14279561f, 0.08435582f, 0.11756141f, -0.02210098f, 0.00482394f, -0.06316216f, -0.06636462f, 0.00944164f, 
    -0.05500594f, -0.05753000f, 0.13901553f, 0.01073380f, -0.18443309f, -0.29604277f, 0.00037371f, 0.10229331f, 
    -0.07323729f, 0.18853629f, 0.00621364f, 0.18332258f, -0.01243297f, -0.08096796f, -0.00087638f, 0.00778286f, 
    -0.14481601f, 0.07100777f, 0.22229210f, 0.16126482f, 0.06187847f, 0.07864874f, 0.04467382f, -0.01182294f, 
    0.08675731f, 0.06886390f, -0.01263849f, -0.00761889f, 0.36144957f, 0.10107884f, 0.14683847f, -0.04190932f, 
    -0.00517342f, -0.08604014f, -0.03069730f, 0.05533447f, 0.00110411f, 0.05288878f, 0.01542142f, 0.04118367f, 
    0.01503850f, 0.16340065f, -0.02570861f, 0.08100561f, 0.06808490f, -0.01057677f, -0.04034109f, -0.00252129f, 
    0.06455148f, -0.09907936f, 0.15025790f, 0.02001686f, -0.46379066f, -0.07468735f, 0.04955327f, 0.06994958f, 
    0.04703064f, -0.06304732f, 0.00921263f, 0.02049475f, 0.04824627f, -0.07791735f, -0.02402010f, 0.01017384f, 
    -0.23111469f, 0.12610197f, 0.05596795f, 0.05286927f, 0.10117639f, 0.03259277f, 0.01867806f, 0.00427474f, 
    -0.02219420f, 0.02611399f, 0.10388948f, -0.04015986f, 0.08139852f, 0.11974788f, 0.10647314f, 0.00562742f, 
    0.03737342f, 0.05057685f, 0.02886916f, -0.05780319f, 0.03103318f, -0.00066234f, 0.05793730f, 0.02528148f, 
    -0.04317772f, -0.13956682f, -0.10839401f, -0.08990426f, 0.00874950f, 0.01221768f, 0.03315652f, -0.03733154f, 
    0.03023146f, 0.03231877f, 0.05327894f, -0.05584528f, 0.13363804f, -0.06348095f, -0.12225787f, -0.06426094f, 
    0.01752742f, -0.07779229f, 0.13242133f, -0.04913482f, 0.19163956f, 0.01924825f, -0.00678065f, 0.10996345f, 
    -0.06796861f, -0.10815309f, 0.05382262f, 0.13063338f, 0.15908937f, 0.00101011f, 0.06368130f, -0.03846170f, 
    -0.01015194f, 0.06186497f, -0.07490904f, -0.04593442f, 0.32568544f, -0.07480488f, 0.12371195f, -0.02290864f, 
    0.02070982f, 0.05079238f, -0.02600767f, 0.02040527f, 0.07078733f, 0.14539154f, 0.00551664f, 0.06209183f, 
    0.06511672f, 0.10937715f, 0.11870032f, 0.02406084f, -0.06735260f, 0.02585707f, 0.03291955f, 0.02151726f, 
    0.09283487f, 0.03369686f, -0.00672617f, -0.03400073f, 0.13867764f, -0.07508498f, 0.09690771f, 0.05277823f, 
    0.10659404f, 0.02772603f, -0.02916753f, -0.00703850f, 0.13758370f, 0.07569310f, -0.06007566f, -0.01762068f, 
    -0.01072715f, -0.16319023f, 0.16208243f, 0.10596439f, -0.02025962f, 0.07147530f, -0.01211419f, -0.05395542f, 
    -0.05639720f, -0.00346790f, 0.03844514f, -0.08728313f, -0.09991308f, 0.05524440f, 0.03431605f, 0.04108317f, 
    0.04829193f, 0.03515501f, 0.11163636f, 0.02039314f, 0.01114144f, 0.06471746f, -0.01853453f, 0.00682489f, 
    -0.31220868f, -0.06024876f, -0.03345045f, 0.00664230f, -0.05852721f, 0.03175096f, 0.07978631f, 0.06797962f, 
    -0.04877761f, 0.02496464f, -0.06453362f, 0.07190751f, -0.15886565f, 0.29598421f, -0.03530910f, -0.10269117f, 
    -0.03032698f, -0.05087785f, -0.13038214f, 0.06193468f, -0.02912034f, -0.00175534f, -0.00361777f, -0.04432907f, 
    -0.28285635f, -0.02918261f, 0.16472977f, 0.00974390f, 0.13911572f, 0.02402891f, 0.05058675f, 0.00997164f, 
    0.10144319f, -0.01182612f, 0.01898020f, -0.01968974f, 0.29621840f, 0.11989259f, -0.03905954f, 0.00272088f, 
    0.11136108f, 0.00775148f, 0.06351773f, 0.02908416f, 0.03502784f, 0.02831383f, -0.04188767f, -0.00291815f, 
    -0.02063708f, 0.00066626f, -0.02666679f, 0.00455309f, -0.07132306f, -0.00629869f, -0.02979641f, -0.02292439f, 
    -0.00757895f, 0.11450655f, -0.05078549f, 0.05198004f, -0.05848099f, -0.05790637f, -0.07203066f, -0.01775923f, 
    0.03817507f, 0.01242353f, 0.02961873f, -0.04852607f, 0.09163892f, 0.02227090f, 0.03369053f, 0.00644585f, 
    -0.05440518f, 0.03959567f, -0.18977574f, 0.16424294f, -0.08733803f, -0.07992484f, -0.12674975f, 0.05345891f, 
    -0.04878316f, 0.04508750f, -0.13563250f, 0.02495243f, -0.12706849f, -0.00103029f, 0.11397132f, 0.01326957f, 
    0.06821416f, -0.00139720f, 0.13813958f, 0.10988397f, 0.19733343f, 0.04874408f, 0.07423899f, 0.06501761f, 
    0.17341584f, -0.01954375f, -0.13902386f, 0.15401937f, 0.04198053f, 0.09177715f, 0.06488114f, -0.02216361f, 
    -0.00634625f, 0.03423962f, -0.02372004f, 0.02367475f, 0.17452820f, 0.10199095f, 0.00098157f, 0.14382617f, 
    -0.06303928f, 0.05392777f, -0.00056282f, 0.06348880f, -0.08811223f, 0.07415332f, 0.08718552f, 0.05635174f, 
    -0.10153596f, 0.18398280f, 0.15519270f, -0.30837044f, -0.08086883f, 0.06061405f, -0.04830523f, -0.02395643f, 
    -0.03436958f, -0.03046761f, -0.11966658f, 0.00574190f, 0.07694013f, 0.03167156f, -0.04194143f, 0.38696745f, 
    0.00603352f, 0.04993601f, 0.01091478f, 0.02640867f, -0.01983526f, -0.01820341f, -0.07709261f, 0.04615087f, 
    0.08240937f, -0.07678635f, 0.03737166f, 0.09046654f, -0.04406481f, -0.13627242f, -0.12323587f, -0.04425918f, 
    0.13945144f, 0.03061336f, 0.00942267f, 0.02615305f, 0.06582215f, -0.09249327f, 0.07066038f, 0.32402799f, 
    0.04021038f, 0.03143857f, -0.05246590f, 0.06981226f, 0.06450769f, 0.06048058f, 0.02078687f, -0.02518871f, 
    0.03125934f, -0.04532949f, -0.10877191f, -0.22338153f, -0.01114403f, 0.07552895f, -0.00798903f, 0.02022533f, 
    -0.00779912f, 0.08279432f, -0.01054956f, 0.00071220f, -0.00742465f, 0.12581255f, 0.19324020f, -0.13308536f, 
    -0.02671385f, 0.08520419f, 0.03490793f, 0.03067044f, -0.11058065f, -0.06209864f, 0.06616362f, -0.03090709f, 
    -0.10333704f, 0.19550377f, 0.02511520f, 0.12722543f, 0.02459664f, -0.03192661f, -0.07394473f, 0.10145015f, 
    -0.01648986f, -0.02447774f, -0.00109701f, -0.05390533f, 0.18389226f, 0.15769324f, 0.12247274f, 0.22207183f, 
    0.01358952f, 0.06230086f, 0.00081067f, 0.00049413f, -0.01121369f, 0.06582963f, -0.03262274f, 0.04483824f, 
    -0.22045217f, -0.14098474f, -0.07034997f, 0.11352408f, -0.02743964f, 0.06949282f, 0.02861339f, 0.03197759f, 
    -0.08469723f, 0.06356052f, 0.03643570f, -0.01152766f, 0.10079834f, -0.16065241f, 0.07037753f, 0.07004677f, 
    -0.01177097f, 0.05543177f, 0.03262705f, -0.12912062f, -0.05077086f, -0.02351563f, 0.08647600f, 0.04281154f, 
    0.11926445f, 0.04938705f, 0.08065946f, -0.19327070f, 0.01497857f, -0.00639562f, 0.04836860f, 0.03280842f, 
    -0.16447617f, -0.02080985f, 0.03531035f, 0.14215295f, 0.09441433f, -0.02271351f, 0.04776864f, -0.08095848f, 
    -0.06560381f, 0.02393895f, 0.14282271f, 0.01233662f, 0.03199685f, -0.05232247f, 0.05261109f, 0.07305641f, 
    0.07089438f, -0.07957348f, 0.15366405f, 0.06642714f, 0.04731906f, -0.06612382f, 0.11676293f, -0.02623796f, 
    0.04813809f, -0.05507799f, 0.00190595f, 0.07709476f, -0.03217442f, 0.01748653f, 0.01354037f, -0.12684144f, 
    0.04145306f, -0.01358076f, 0.23746197f, 0.08815777f, -0.10001626f, 0.03230484f, -0.04114844f, -0.09082974f, 
    -0.18080993f, -0.13682605f, 0.02697212f, -0.09945098f, 0.08808997f, -0.08028652f, 0.03770889f, -0.04646124f, 
    0.02684039f, -0.03613749f, 0.07872684f, 0.09452260f, 0.01931305f, -0.06916650f, -0.17937326f, -0.05340333f, 
    0.11931410f, 0.05652924f, -0.00025580f, 0.03507554f, 0.04268456f, -0.00509483f, -0.05975714f, -0.02450626f, 
    0.15462226f, -0.10213502f, 0.07310981f, -0.19055010f, 0.05697622f, -0.05780918f, -0.00030411f, -0.01270237f, 
    0.03981173f, -0.00395326f, 0.06905830f, -0.00117793f, -0.29338747f, -0.18748574f, 0.01652785f, 0.06535178f, 
    -0.03990372f, -0.08379523f, 0.12972392f, 0.00967009f, 0.02651168f, 0.04240293f, 0.01921064f, 0.04324464f, 
    -0.03442178f, -0.01844892f, -0.14142604f, 0.15887311f, -0.06171664f, 0.06002023f, -0.06931341f, 0.01184704f, 
    0.00963399f, 0.03751642f, -0.09451605f, -0.01161765f, 0.27063763f, 0.06370762f, -0.12077368f, 0.08504998f, 
    0.01292441f, 0.10905246f, 0.00483755f, 0.01655906f, 0.04080281f, 0.06822691f, 0.10200129f, 0.10083925f, 
    -0.12419952f, 0.13423054f, 0.08305634f, 0.04613289f, -0.00010914f, 0.02456132f, 0.06397351f, 0.05262353f, 
    -0.10419384f, -0.00778405f, -0.00195924f, 0.04548993f, 0.12575606f, -0.10181060f, -0.10890352f, -0.12265223f, 
    0.03414666f, -0.02828968f, -0.06119680f, 0.01103847f, 0.11153734f, -0.05348909f, -0.10712542f, 0.04878807f, 
    -0.03435942f, 0.15151380f, -0.07574721f, -0.04104943f, 0.12191166f, 0.08765382f, -0.03440419f, -0.00625302f, 
    0.01310297f, -0.12331706f, 0.01579149f, -0.01933928f, 0.00174484f, 0.01795075f, -0.00990310f, 0.21420127f, 
    -0.02008106f, -0.00120098f, -0.04998057f, 0.12201732f, 0.00070366f, 0.04588021f, 0.09470794f, 0.00061062f, 
    0.04102452f, -0.05943071f, 0.10763966f, 0.16342258f, -0.08640282f, 0.00447792f, 0.02480920f, 0.00347172f, 
    -0.00097918f, -0.03631684f, -0.11907332f, 0.10261214f, -0.00058650f, 0.22942702f, -0.09307673f, 0.00364992f, 
    0.05717216f, 0.00968259f, 0.04829818f, -0.01725263f, -0.08042840f, -0.00488834f, -0.02589923f, -0.02214855f, 
    -0.03104731f, -0.09922511f, -0.22258013f, -0.23931734f, 0.04960601f, 0.10570583f, -0.07060298f, -0.12322768f, 
    0.05942789f, 0.01201236f, 0.09986985f, 0.02736585f, 0.04930356f, 0.14541090f, -0.00904697f, -0.03190749f, 
    -0.01636402f, 0.03421657f, -0.01690253f, -0.02832264f, -0.01887259f, 0.11367593f, 0.03051502f, 0.06749979f, 
    -0.34858602f, -0.13410302f, -0.01677609f, -0.03917687f, 0.16205382f, -0.01108629f, 0.00282366f, 0.01311591f, 
    0.00742221f, 0.02057379f, 0.02496100f, 0.06558126f, 0.28783005f, -0.19412085f, -0.08565846f, 0.29877478f, 
    0.03810752f, -0.06204188f, 0.04252660f, 0.02055103f, 0.00936285f, -0.09895813f, -0.04249655f, 0.00997260f, 
    0.13149548f, -0.05974528f, 0.13330975f, 0.00443315f, 0.01905954f, 0.04291733f, -0.03071445f, 0.03499448f, 
    0.03744553f, 0.06831360f, 0.02481493f, 0.00144578f, 0.03205962f, -0.14110775f, 0.14235111f, 0.04159240f, 
    -0.06253607f, 0.09669768f, 0.08865809f, -0.00363015f, 0.03332409f, -0.01199548f, 0.16358933f, -0.02917887f, 
    0.06442907f, 0.08594200f, 0.14385581f, -0.27321309f, -0.00354614f, 0.02210802f, 0.05650586f, 0.06413513f, 
    -0.00653421f, -0.04343423f, 0.04828648f, -0.05932642f, -0.06026027f, 0.13242561f, 0.08420444f, 0.05546422f, 
    0.00389302f, -0.03765196f, -0.01888377f, 0.01251645f, 0.07268010f, -0.06775959f, 0.09024009f, 0.03185046f, 
    0.11775716f, 0.09490508f, 0.15595526f, -0.10084728f, -0.01103141f, 0.10235914f, -0.03646691f, 0.05089858f, 
    -0.03023182f, 0.01192166f, 0.10642823f, 0.05311891f, -0.15090610f, -0.10917120f, -0.17183608f, -0.00087653f, 
    0.09626305f, 0.06978508f, -0.06538497f, 0.02706341f, -0.00292484f, 0.07150982f, -0.01543956f, 0.03265049f, 
    0.13768058f, 0.00033894f, 0.12681954f, 0.10027188f, -0.02055706f, 0.09142806f, 0.07323850f, 0.02519188f, 
    0.08749381f, 0.06708236f, 0.01642912f, 0.03361365f, 0.00100130f, 0.19589143f, 0.22444126f, 0.01357454f, 
    -0.10077643f, 0.03416882f, 0.00782410f, 0.08101289f, -0.04270828f, -0.08760830f, -0.03588287f, 0.06415476f, 
    -0.03795857f, 0.08587362f, 0.08644567f, -0.00325815f, -0.10225643f, 0.09841821f, 0.03880310f, 0.05692635f, 
    -0.15883754f, -0.10061955f, 0.01962560f, 0.08504242f, 0.05393139f, -0.19666195f, 0.22346869f, 0.25582042f, 
    -0.12652661f, -0.03351774f, 0.08415698f, 0.00240863f, -0.07383337f, 0.00737233f, -0.06533781f, -0.04641163f, 
    -0.20051636f, -0.03918355f, -0.04802692f, 0.11861923f, 0.13205466f, 0.04698851f, -0.01598650f, -0.06210956f, 
    -0.00937728f, 0.07030139f, 0.02500296f, 0.01525266f, -0.03974133f, 0.16340370f, 0.21045928f, -0.20471638f, 
    -0.08048403f, 0.10721188f, 0.01525261f, 0.08161736f, -0.05642457f, -0.06112646f, 0.04172597f, 0.06783503f, 
    0.14120807f, 0.03557365f, 0.11008199f, -0.06146330f, 0.09086528f, -0.04165917f, -0.13408613f, 0.03644844f, 
    0.08202054f, -0.03711723f, 0.02384491f, -0.08071408f, -0.02479905f, -0.09562664f, 0.12579308f, 0.30909646f, 
    0.02838147f, -0.03527777f, 0.08384170f, 0.06816071f, 0.05329270f, 0.04322660f, -0.04598348f, 0.09777582f, 
    -0.14473040f, -0.03435386f, -0.22226387f, -0.00975012f, 0.10146241f, -0.07487005f, 0.04228523f, -0.20406544f, 
    -0.05937713f, -0.05366184f, 0.07419689f, -0.04484141f, -0.09661539f, 0.19204295f, 0.13017549f, -0.07828714f, 
    0.04369692f, 0.04771242f, 0.11229742f, -0.04596083f, 0.01727006f, -0.03622702f, -0.11658371f, 0.02525425f, 
    0.08724888f, 0.10221204f, -0.08126549f, -0.15973751f, 0.04707498f, 0.05937331f, 0.10306173f, -0.07561622f, 
    0.04101929f, -0.00497607f, 0.04568809f, 0.03443402f, 0.17699088f, 0.20888095f, -0.24615970f, 0.11881582f, 
    -0.03737637f, -0.10646764f, -0.02762841f, 0.08772127f, -0.02964835f, 0.00805972f, 0.11671826f, 0.01011963f, 
    -0.21648072f, 0.14145064f, -0.17861333f, 0.17476612f, 0.15168414f, -0.08816339f, 0.00000306f, -0.08801065f, 
    -0.03195953f, 0.03742979f, -0.03192038f, -0.04390306f, -0.28524098f, 0.01023936f, 0.02077287f, -0.15502094f, 
    0.08405355f, 0.04652374f, -0.01352795f, -0.07918157f, -0.06319319f, 0.03163145f, 0.00323834f, 0.01285138f, 
    -0.13564588f, -0.01738091f, 0.07401841f, -0.08821379f, -0.03968671f, 0.05705523f, -0.02561606f, 0.02700878f, 
    0.03804941f, -0.03684084f, -0.01244894f, 0.03897393f, -0.03799147f, 0.21362008f, -0.11631805f, -0.11408917f, 
    -0.00367563f, 0.08435810f, 0.03418707f, -0.01916983f, 0.11896900f, 0.05023155f, -0.05346049f, -0.09760382f, 
    -0.06792847f, -0.05918055f, 0.09780001f, 0.15654132f, 0.06022814f, -0.04359104f, -0.03436041f, -0.07197767f, 
    0.05344614f, -0.04728259f, 0.02965395f, -0.01543049f, 0.01231497f, 0.06071139f, -0.12336561f, 0.15662798f, 
    -0.00770056f, 0.08308104f, 0.04653652f, -0.07826521f, 0.10919186f, -0.04131084f, 0.04752499f, 0.02286886f, 
    0.04404562f, -0.00559009f, 0.22989210f, 0.19987448f, -0.08561449f, 0.07269043f, 0.02943177f, -0.00363676f, 
    -0.06598227f, 0.02851163f, -0.08009747f, -0.07336592f, 0.11204485f, 0.09596333f, 0.15556356f, 0.27523205f, 
    -0.08133493f, 0.01159933f, 0.09600683f, 0.09097442f, -0.14890526f, -0.08449332f, 0.06063684f, -0.00569370f, 
    -0.21802042f, -0.00430413f, -0.02462162f, -0.06954296f, 0.00861684f, 0.18115562f, 0.05540253f, -0.00822195f, 
    0.06491838f, 0.05960680f, 0.01443967f, -0.02076464f, -0.00655305f, -0.07777681f, -0.13648199f, -0.19572373f, 
    -0.03454873f, -0.01639787f, -0.03545963f, -0.14911214f, 0.01451231f, -0.03817696f, 0.11032798f, 0.02107272f, 
    0.02973644f, 0.23718119f, 0.00554796f, -0.24969292f, -0.04394123f, 0.09149519f, 0.10519513f, 0.03979867f, 
    -0.08339208f, 0.09816005f, 0.06993360f, 0.02259290f, 0.24659313f, 0.19935343f, -0.03563975f, -0.18131483f, 
    0.11991838f, 0.03077988f, 0.05445689f, -0.03752469f, 0.02387636f, 0.02816266f, -0.00688664f, 0.04090634f, 
    0.10145703f, 0.04305145f, 0.10832102f, -0.25232172f, -0.12806758f, 0.04146286f, 0.01119504f, -0.03077493f, 
    -0.06550183f, 0.01841843f, -0.08718126f, 0.07437280f, 0.15951823f, 0.09071913f, -0.01263316f, 0.07067019f, 
    0.02179696f, 0.04294085f, 0.04949591f, -0.04268207f, 0.09630834f, 0.11784625f, 0.04031984f, -0.02661989f, 
    0.01054286f, 0.02693524f, 0.11250493f, 0.21224137f, 0.05933540f, -0.01216215f, 0.01360594f, 0.01779426f, 
    0.02606164f, 0.01072962f, 0.09829127f, 0.12066215f, 0.06699736f, 0.03614381f, 0.07254306f, 0.10332862f, 
    -0.03752493f, -0.03844017f, 0.06090807f, 0.01845646f, -0.01268694f, -0.08298612f, -0.04398490f, -0.03879556f, 
    -0.06629836f, 0.03591742f, -0.02436623f, -0.09644131f, 0.09732471f, 0.01510914f, 0.08341487f, -0.01329785f, 
    0.00460298f, -0.03063096f, 0.03130125f, 0.00683847f, -0.11593886f, -0.15991624f, 0.18319450f, 0.07113710f, 
    0.01229204f, -0.01939298f, -0.00448390f, 0.02074992f, 0.00213236f, 0.05918003f, 0.06381523f, -0.04102652f, 
    -0.28898001f, -0.05236274f, -0.04248630f, 0.00963667f, 0.05641244f, 0.08393624f, 0.06283575f, 0.02653916f, 
    0.00365949f, -0.03710002f, 0.08780747f, -0.04080749f, 0.07749526f, -0.08102958f, 0.06134712f, 0.04715568f, 
    0.03794692f, -0.02836229f, -0.03060039f, -0.00672985f, 0.05560073f, -0.05917782f, -0.10076635f, 0.07633794f, 
    -0.07612146f, 0.12179226f, -0.06188028f, 0.05565191f, 0.05536476f, -0.01578654f, -0.00856892f, 0.03289140f, 
    -0.00005710f, -0.01805027f, 0.00895023f, 0.06521610f, 0.05869475f, -0.00313799f, -0.19166380f, -0.14638619f, 
    0.07638388f, 0.10280661f, 0.01266669f, 0.00925236f, 0.10140911f, -0.01366666f, 0.03822455f, 0.12553751f, 
    0.16156532f, 0.01981263f, 0.11639415f, 0.02385781f, 0.00836088f, 0.06576887f, 0.08881965f, -0.06799155f, 
    0.03449695f, 0.08207004f, 0.00034045f, 0.00178637f, 0.13313073f, 0.06828353f, 0.05739611f, 0.12910564f, 
    0.05229223f, 0.05268946f, 0.05505934f, 0.00270845f, 0.00398235f, 0.01879951f, 0.13564938f, 0.00892460f, 
    0.19757351f, -0.04352948f, 0.03819818f, 0.04769953f, -0.07507750f, -0.03687961f, 0.04789455f, -0.00184152f, 
    0.11129554f, 0.05616400f, 0.00794695f, 0.03132163f, 0.06849637f, 0.02670405f, -0.13691634f, -0.21534027f, 
    0.06106391f, 0.00733401f, -0.00043907f, 0.04848618f, -0.01293006f, 0.05754228f, -0.06916130f, 0.02435872f, 
    0.03210092f, -0.00535840f, -0.06811576f, -0.12229367f, 0.07745065f, 0.02031861f, -0.05426864f, 0.00103357f, 
    0.05940150f, -0.04456647f, -0.02288757f, -0.09093422f, 0.02249645f, 0.01341624f, -0.00348057f, 0.13644494f, 
    -0.05227090f, 0.00863236f, -0.08307656f, 0.08756984f, 0.11032969f, -0.03251331f, 0.07821993f, -0.08652542f, 
    -0.00158997f, -0.03268835f, -0.02828773f, 0.08358078f, -0.14974515f, 0.06765769f, -0.05459158f, 0.05044435f, 
    0.12369181f, 0.03538262f, 0.03537603f, -0.07990895f, -0.02669206f, 0.20178191f, 0.03601798f, 0.06987007f, 
    -0.07418930f, -0.06224649f, -0.00407130f, 0.02802272f, 0.05067197f, -0.00176374f, 0.00149472f, 0.12842445f, 
    -0.01372198f, 0.04514455f, 0.01590984f, -0.04288881f, -0.01245416f, 0.07329465f, 0.05285484f, 0.11866692f, 
    0.01592311f, 0.07098888f, -0.05756992f, -0.03310652f, 0.17654209f, 0.01999239f, 0.07770886f, 0.05831743f, 
    0.02381588f, 0.04740198f, -0.00162964f, -0.02368381f, -0.09549733f, 0.04286458f, -0.01339842f, -0.01826157f, 
    0.01263866f, 0.09739567f, 0.10314912f, 0.09592257f, -0.03352775f, 0.04353139f, 0.05049635f, 0.14171016f, 
    -0.02544993f, 0.03680075f, -0.11584400f, 0.05991255f, 0.18262801f, 0.08971568f, 0.10795679f, -0.06922010f, 
    -0.06234613f, 0.04707595f, -0.06334499f, -0.00126497f, -0.05131585f, -0.02237890f, 0.03679506f, 0.03226742f, 
    -0.25473079f, 0.04635334f, 0.07038561f, 0.12463687f, 0.03450514f, 0.01454895f, 0.09314117f, 0.06172269f, 
    0.04124239f, 0.06789796f, 0.01389006f, -0.04481354f, 0.00975961f, 0.06230269f, 0.01990995f, 0.19810659f, 
    -0.05296123f, 0.07392024f, 0.02052787f, -0.03269292f, -0.00103962f, -0.07106581f, -0.05263439f, 0.02001788f, 
    -0.03450013f, -0.01624244f, -0.14514500f, -0.13673006f, 0.10669031f, -0.00658759f, -0.02061577f, 0.06373446f, 
    -0.01216809f, 0.07729591f, 0.04959147f, -0.00997296f, 0.05947897f, 0.07772021f, 0.14282128f, 0.13698979f, 
    -0.04633988f, 0.07896169f, 0.10221550f, 0.06423674f, -0.04287273f, 0.08696996f, 0.03327924f, -0.07074741f, 
    -0.00282455f, 0.05234907f, 0.19346313f, 0.03428911f, -0.00576061f, -0.05942787f, 0.06925901f, 0.08588880f, 
    -0.13109064f, 0.10271093f, 0.04039076f, -0.01636979f, 0.08811565f, 0.01326610f, 0.09041746f, 0.13577062f, 
    0.03644872f, 0.04094116f, -0.03022067f, 0.00992430f, -0.01975009f, -0.02006129f, 0.01178977f, -0.00236419f, 
    0.14733161f, 0.12505272f, -0.00508399f, 0.11115967f, 0.07229875f, 0.09271149f, 0.00848200f, 0.03283204f, 
    0.01943710f, 0.08746767f, 0.08831491f, -0.08787178f, 0.18007325f, 0.06426321f, -0.03242991f, 0.01765035f, 
    0.05176699f, 0.01942492f, -0.02908280f, -0.00651816f, 0.11779314f, 0.00813921f, -0.01831377f, -0.03153735f, 
    0.00096985f, 0.05917766f, 0.14811513f, 0.11774100f, -0.04632831f, -0.01288504f, 0.17708257f, 0.04883492f, 
    0.04220147f, 0.08108498f, -0.04735781f, 0.01256020f, 0.11874589f, -0.02217845f, 0.06175900f, 0.06616136f, 
    0.01350843f, 0.00751578f, -0.03260997f, 0.01530184f, 0.09893672f, -0.08803571f, -0.00313671f, -0.03601484f, 
    0.18288143f, 0.09966820f, -0.03943257f, 0.01115965f, 0.07727455f, 0.03902433f, 0.00353048f, -0.02809238f, 
    -0.00689264f, -0.00587408f, -0.04178204f, -0.00577353f, -0.07269865f, 0.17875139f, 0.13496956f, -0.06917987f, 
    -0.09816295f, 0.17678675f, 0.08437463f, 0.03521382f, 0.04067208f, 0.10821460f, 0.11019699f, 0.03712700f, 
    0.27638325f, 0.20638838f, -0.02502682f, 0.14862636f, 0.05097247f, 0.04267450f, 0.02559059f, -0.02861068f, 
    -0.05300663f, -0.00244723f, 0.02863036f, 0.08313718f, -0.16280313f, 0.00392188f, -0.05897399f, -0.11390879f, 
    0.07756288f, -0.07050963f, -0.03280858f, 0.01983175f, -0.08625862f, -0.01877225f, -0.09016366f, -0.01269884f, 
    -0.11979039f, -0.01235289f, -0.13456392f, -0.14144893f, 0.11631227f, 0.03927792f, -0.02842428f, -0.03671233f, 
    0.01246944f, 0.05120211f, -0.02190655f, 0.02859806f, 0.16084450f, 0.02442388f, -0.06601554f, -0.03391277f, 
    0.03813316f, 0.11943659f, 0.05150260f, 0.07373752f, -0.01336768f, -0.06800155f, -0.00226418f, 0.00337183f, 
    0.04114100f, 0.03677271f, -0.01739499f, 0.07157350f, 0.02207200f, -0.07550988f, 0.11816079f, 0.01956919f, 
    0.00755166f, 0.01407335f, -0.07490274f, -0.00656450f, 0.17958245f, 0.16175871f, -0.00132602f, 0.08322830f, 
    -0.03551963f, -0.01118848f, 0.09823969f, -0.01147381f, -0.04384383f, 0.07472558f, -0.04503986f, -0.00278584f, 
    -0.00389530f, -0.21432263f, -0.06292611f, -0.11959769f, 0.01501057f, -0.02172617f, -0.03013941f, 0.02637068f, 
    -0.00311121f, -0.05324453f, 0.04014415f, -0.05686222f, -0.21665506f, -0.10542809f, -0.13068910f, -0.21891536f, 
    0.08769910f, 0.03591463f, 0.03333367f, 0.02480591f, 0.04764624f, 0.10436022f, -0.06230740f, 0.06966733f, 
    0.00241740f, -0.04151178f, -0.12695363f, -0.01949195f, 0.10356308f, -0.05844238f, -0.02750674f, -0.02530111f, 
    -0.02550647f, 0.00862863f, 0.07469358f, 0.00594768f, 0.10060363f, 0.09265664f, -0.00319441f, 0.02367095f, 
    0.05768159f, -0.01302297f, 0.03232723f, -0.02599876f, 0.00613859f, 0.02017431f, 0.07174694f, 0.00125718f, 
    0.16116951f, 0.02167040f, 0.03011469f, 0.01706216f, 0.06877423f, -0.06893446f, 0.05264625f, 0.07409678f, 
    0.07590859f, -0.07403137f, 0.03348018f, 0.05617905f, -0.00359895f, 0.04599585f, -0.27820382f, -0.00368790f, 
    0.00954728f, 0.03577473f, -0.04632943f, -0.09729549f, -0.05113873f, -0.02545943f, 0.00341404f, 0.00386192f, 
    -0.07456340f, 0.00058249f, 0.11023735f, -0.09568258f, 0.02453726f, 0.05869764f, 0.11544909f, -0.08827836f, 
    0.02045464f, 0.05163586f, -0.01415553f, 0.08966283f, 0.15502222f, 0.11387692f, 0.03716574f, 0.13902013f, 
    -0.01262634f, 0.08860836f, -0.00251268f, 0.02682274f, -0.06779765f, -0.06199471f, 0.09896025f, 0.01232148f, 
    0.09102641f, 0.08763146f, 0.03814486f, 0.01501644f, 0.03716832f, 0.04687933f, 0.02189795f, 0.12738352f, 
    0.16299707f, 0.03641638f, -0.01844809f, 0.03623140f, -0.08199459f, -0.18063161f, -0.05805475f, -0.10300925f, 
    0.00009530f, -0.02401772f, -0.01729556f, 0.05536815f, 0.04563788f, 0.04399868f, 0.09783936f, 0.08506579f, 
    0.00651623f, -0.01159430f, 0.12068648f, 0.22723824f, -0.04836756f, -0.00495698f, 0.05186442f, 0.10431634f, 
    0.03704581f, 0.07903846f, 0.08284524f, 0.07374459f, 0.25262696f, -0.01706264f, 0.24431810f, 0.02827443f, 
    0.01775419f, 0.14467999f, 0.03150234f, 0.08296210f, 0.10697749f, 0.06890261f, 0.04069417f, -0.00271905f, 
    0.23952384f, 0.01236879f, 0.08024316f, 0.01743711f, -0.00842230f, 0.05560827f, 0.04014080f, 0.01296426f, 
    0.03813067f, -0.01783052f, 0.03847775f, 0.03434603f, 0.18343772f, 0.03100126f, 0.10979351f, 0.09741569f, 
    0.05476217f, -0.02744612f, 0.14982200f, 0.05488766f, -0.05308273f, -0.00586259f, -0.06569060f, -0.00197161f, 
    -0.23965278f, 0.00420911f, -0.05409286f, 0.02251055f, 0.07476893f, 0.00256651f, 0.02299342f, -0.00664951f, 
    0.01623407f, 0.03627371f, -0.09125933f, -0.01127422f, 0.15601517f, -0.03521642f, 0.07733673f, 0.17726958f, 
    0.04476450f, -0.05423258f, 0.09755881f, 0.02476046f, -0.12892231f, 0.00473588f, -0.06497819f, 0.03266362f, 
    -0.09663740f, 0.02100306f, -0.05736051f, -0.09644677f, 0.01299605f, 0.09955911f, 0.05429038f, 0.08589268f, 
    0.07552561f, 0.02973239f, -0.00565764f, 0.07294404f, 0.09767295f, 0.01127014f, 0.07506146f, 0.05069000f, 
    0.09098152f, -0.01858772f, -0.02063009f, 0.00548443f, 0.01161299f, 0.12684679f, -0.05366328f, -0.07846503f, 
    0.17352420f, 0.01251138f, 0.01496276f, 0.00875473f, 0.12685965f, 0.00036535f, -0.02926575f, 0.06235199f, 
    -0.00175532f, 0.02458598f, 0.11175398f, 0.17285849f, -0.07905620f, 0.16968006f, 0.04484039f, -0.08412613f, 
    0.06102122f, 0.07597207f, 0.14819527f, -0.07513802f, 0.02905000f, 0.07666837f, 0.04199831f, 0.07439135f, 
    -0.03555301f, 0.06924804f, 0.11338395f, 0.15937075f, 0.01287135f, -0.10278190f, -0.02936492f, -0.00792892f, 
    0.02345305f, -0.00271154f, 0.00654210f, -0.03471499f, -0.13335672f, 0.13641374f, 0.08879878f, 0.03726764f, 
    0.07187130f, 0.01390627f, -0.02365310f, 0.17292926f, -0.00029663f, 0.04547400f, -0.04463701f, -0.01279073f, 
    -0.03854223f, 0.05427528f, 0.00956509f, 0.12508819f, 0.02856496f, 0.05362268f, 0.02374098f, 0.04363169f, 
    0.04191872f, -0.08965348f, 0.00528864f, 0.03138177f, -0.01931832f, 0.03280888f, 0.06230963f, 0.12177906f, 
    -0.00266188f, -0.03580484f, 0.00548182f, -0.05189116f, 0.01437837f, 0.04695394f, 0.03826414f, 0.02759892f, 
    -0.12606484f, 0.16250518f, 0.05005450f, -0.05098844f, 0.12888676f, 0.02299906f, 0.11001249f, 0.06401833f, 
    0.07005975f, -0.14398500f, 0.03263615f, -0.05789473f, 0.08170255f, 0.01073870f, 0.07138882f, 0.14386068f, 
    0.07059397f, -0.13545622f, -0.02337472f, -0.01311539f, -0.07639706f, -0.14045916f, 0.06959606f, -0.00215282f, 
    -0.01889078f, -0.03204532f, 0.04013496f, 0.18247393f, 0.12670967f, -0.00339501f, 0.01110715f, 0.04755647f, 
    -0.01625037f, 0.02118617f, -0.00994981f, 0.10311023f, 0.10670121f, 0.05872963f, -0.07755166f, -0.06372143f, 
    -0.07669912f, -0.03842546f, 0.02631719f, 0.04883707f, -0.04112831f, -0.06189081f, 0.07172230f, 0.03897520f, 
    -0.34912482f, 0.09563255f, -0.06529137f, -0.07566949f, 0.03546669f, -0.00528415f, 0.06080408f, -0.12481350f, 
    -0.02806429f, 0.00489197f, 0.01672343f, -0.03399320f, -0.03947135f, 0.04756027f, 0.33068717f, 0.08702050f, 
    -0.08488224f, 0.06141794f, -0.06553012f, -0.05151296f, -0.01229963f, 0.02667185f, -0.02285670f, 0.07277090f, 
    -0.19794658f, -0.04658820f, -0.09517836f, 0.11327265f, 0.04539586f, 0.08172729f, 0.00405119f, -0.00541790f, 
    0.04682236f, -0.00470424f, 0.12943737f, 0.01868661f, 0.13881421f, -0.11868576f, 0.10035057f, 0.02747632f, 
    0.11723283f, -0.05110403f, 0.02279732f, -0.04652685f, -0.03343304f, -0.06439730f, -0.09210993f, 0.02036059f, 
    -0.09908248f, 0.09935290f, -0.08866175f, -0.06648964f, 0.05257871f, -0.11662017f, -0.01742453f, -0.05560919f, 
    0.02995908f, 0.04594201f, 0.03852172f, 0.07328376f, -0.18697350f, 0.00096633f, -0.08513330f, -0.16386060f, 
    0.07029349f, 0.12626605f, -0.11502767f, -0.02249593f, -0.03189417f, -0.00588942f, 0.06473812f, 0.07562733f, 
    -0.04870054f, 0.00021263f, 0.15021370f, 0.12512134f, 0.02931560f, 0.09793793f, 0.00425608f, -0.06020411f, 
    -0.05104872f, 0.10473245f, 0.03146132f, -0.05216884f, 0.02910079f, 0.04456292f, 0.07868306f, 0.17182603f, 
    -0.03457009f, 0.00825485f, -0.02592385f, 0.11308118f, 0.03167983f, 0.05072744f, 0.03612436f, 0.00336468f, 
    0.39471021f, -0.18958767f, 0.09284811f, 0.08871592f, -0.03394418f, -0.04458465f, -0.01040460f, 0.00385332f, 
    0.03039147f, 0.08965307f, 0.07117216f, 0.06518043f, 0.39549911f, 0.00285104f, -0.09288815f, -0.13925737f, 
    0.00028034f, -0.06346826f, 0.05955255f, -0.00781174f, -0.03550066f, 0.02400860f, 0.00683854f, 0.04401044f, 
    -0.06787140f, -0.05092653f, -0.12359283f, -0.26429304f, 0.13384262f, 0.11552597f, 0.00843997f, -0.02940214f, 
    -0.05619755f, 0.01614553f, -0.02010272f, -0.10231361f, 0.02890359f, 0.15026169f, -0.00625401f, 0.04388030f, 
    -0.02483520f, -0.02334520f, 0.00280738f, 0.06966017f, 0.13161707f, 0.00679555f, 0.00638850f, -0.07063652f, 
    0.08942792f, 0.08157898f, 0.04083120f, 0.03967007f, -0.13963258f, 0.04225374f, 0.06240373f, 0.06361859f, 
    0.18571699f, 0.08508467f, 0.01966587f, -0.01949723f, -0.16258371f, 0.00988949f, 0.06624740f, 0.18804002f, 
    0.03732616f, -0.06430174f, 0.01795533f, -0.12943757f, 0.07411590f, -0.04681023f, 0.06769414f, 0.09394559f, 
    0.01677236f, -0.17007618f, -0.04637901f, -0.04239385f, -0.05365590f, -0.00457815f, 0.01862989f, 0.03847308f, 
    0.01363976f, -0.06143248f, 0.01850407f, 0.03102426f, 0.01344855f, -0.13552898f, 0.06564700f, -0.05198441f, 
    0.03422232f, 0.07190584f, -0.01370792f, 0.06244049f, -0.07593922f, 0.04151345f, -0.04062599f, 0.06455681f, 
    0.00973478f, 0.09914543f, 0.14982662f, 0.06156843f, -0.01905595f, -0.06491788f, 0.00119373f, 0.12847723f, 
    0.00579693f, 0.09908475f, -0.01511054f, 0.08130401f, 0.21479669f, -0.10077935f, 0.16838063f, 0.04668827f, 
    -0.03751669f, -0.03934985f, -0.00891607f, -0.08489574f, -0.00384429f, -0.02920183f, 0.12471969f, -0.00496258f, 
    -0.31189489f, 0.34256443f, 0.03757517f, 0.18006070f, 0.06348018f, 0.06168405f, -0.02046940f, 0.10151106f, 
    0.13953726f, 0.01041728f, 0.03298401f, 0.01818003f, -0.14814663f, 0.06533407f, 0.04033533f, 0.03255529f, 
    -0.03472994f, 0.06856466f, -0.03750305f, 0.00392682f, -0.00655789f, -0.03894383f, -0.00150297f, -0.04685784f, 
    -0.04659664f, 0.10013116f, -0.16638477f, -0.14930817f, 0.16595681f, 0.03111964f, -0.03094274f, 0.01780554f, 
    -0.00584998f, -0.02545905f, 0.03167547f, 0.00378316f, -0.02676079f, -0.13185188f, -0.05562290f, -0.04194433f, 
    -0.01657366f, 0.09975574f, -0.00102833f, 0.03164815f, -0.04835868f, -0.00095086f, 0.04227128f, 0.01921507f, 
    0.10851954f, -0.20160100f, 0.18062943f, -0.00284060f, 0.11181709f, -0.01671151f, -0.02938959f, 0.07234825f, 
    -0.14447522f, 0.08967149f, 0.08748730f, -0.00247609f, 0.03749128f, 0.10989378f, -0.03908310f, 0.17557131f, 
    0.10157593f, 0.05800891f, 0.02060196f, 0.07554907f, 0.06101636f, -0.00221422f, -0.02460425f, -0.05118292f, 
    0.18822832f, 0.02829391f, -0.02511461f, 0.21267428f, 0.03064015f, 0.06907883f, -0.02786651f, 0.04931056f, 
    0.10600924f, 0.01741705f, 0.00237478f, 0.04019855f, -0.01731767f, 0.02050598f, -0.04835523f, -0.00693553f, 
    0.03432580f, 0.02217711f, 0.02619080f, -0.13448630f, 0.07051267f, 0.04278068f, 0.03346811f, -0.04901082f, 
    -0.18806520f, 0.05516826f, 0.09524179f, 0.04507183f, 0.01234719f, 0.07154685f, 0.06639528f, 0.10816333f, 
    -0.00219201f, 0.08939519f, -0.06139589f, 0.10627852f, -0.04230245f, -0.09181830f, -0.05581901f, 0.25391853f, 
    0.05585292f, -0.01707439f, 0.09075762f, -0.01719129f, 0.17366648f, -0.03420800f, 0.04289994f, 0.04591725f, 
    -0.02838136f, -0.06642000f, -0.10450561f, -0.12966946f, 0.04044605f, 0.04686499f, -0.00908522f, 0.00280429f, 
    -0.02713415f, -0.00029696f, 0.01742394f, -0.00254935f, -0.06804698f, 0.10368083f, 0.11998425f, 0.02370834f, 
    -0.06317583f, 0.18030217f, 0.06253186f, 0.14295425f, 0.08797882f, 0.08181654f, 0.05216458f, 0.12887347f, 
    0.00997224f, 0.13352028f, 0.10121875f, 0.14963849f, 0.05409541f, -0.01649277f, 0.06111361f, -0.00649445f, 
    -0.00959082f, -0.00460087f, -0.00695994f, 0.06074493f, -0.02966751f, 0.14143951f, -0.12717241f, -0.02822812f, 
    0.07576596f, -0.04428162f, -0.02727035f, 0.08506733f, -0.07923038f, -0.05040984f, -0.04087961f, -0.04970107f, 
    -0.19016708f, 0.06930062f, -0.18929233f, -0.21923137f, 0.11824409f, 0.03086426f, -0.05606869f, -0.05073267f, 
    0.01326119f, 0.05818108f, -0.01766584f, -0.02977578f, 0.09302558f, 0.02764028f, 0.00971393f, -0.04187107f, 
    0.03620018f, 0.03733404f, 0.02026465f, 0.09547541f, -0.03435526f, -0.04870784f, 0.04843441f, -0.00815853f, 
    0.12481485f, 0.01334014f, -0.01863366f, 0.01618709f, -0.06288645f, -0.03114491f, 0.07570088f, 0.02294712f, 
    0.12325113f, 0.08674597f, 0.01173981f, -0.08394466f, 0.00583048f, -0.13329099f, -0.02162232f, -0.01993592f, 
    0.01793559f, -0.03579681f, 0.06774189f, 0.03657615f, -0.06498636f, 0.05018704f, -0.13876113f, 0.00551180f, 
    -0.08732083f, -0.24568738f, 0.04293549f, -0.14429809f, 0.01159386f, 0.01230792f, -0.08011182f, 0.03524407f, 
    0.02315232f, 0.00380269f, 0.07844009f, -0.02833111f, -0.27683547f, 0.01840542f, -0.17965983f, -0.07266030f, 
    0.02317249f, -0.09129714f, -0.02802572f, -0.11098877f, -0.04151389f, 0.07386686f, -0.03421656f, 0.03866734f, 
    -0.00194868f, 0.00563785f, -0.16851445f, -0.22478084f, 0.09546538f, -0.07434069f, -0.06841914f, -0.04007057f, 
    -0.02486997f, -0.08599340f, 0.15876061f, 0.00930524f, 0.21350673f, -0.12217310f, -0.02146263f, 0.06307860f, 
    -0.03069106f, -0.01831659f, 0.04865601f, -0.08910180f, 0.15146972f, 0.18358190f, 0.07859714f, 0.04033788f, 
    0.28890023f, -0.20738846f, -0.02507327f, -0.05625764f, 0.07231970f, -0.15997271f, 0.05038198f, -0.01638583f, 
    0.02257707f, -0.07238829f, 0.02513254f, 0.06517299f, -0.21002242f, 0.09081400f, -0.04907576f, -0.09541756f, 
    -0.01795787f, 0.07143372f, -0.09535296f, -0.14351237f, -0.12567846f, 0.01110922f, -0.02513347f, -0.05762159f, 
    0.15773070f, -0.13213600f, 0.00341759f, -0.08790007f, -0.00484660f, -0.00484391f, 0.05083275f, -0.03488435f, 
    0.07135803f, -0.04551916f, -0.06388650f, 0.15517457f, 0.15461548f, 0.00066118f, 0.10891356f, -0.02408307f, 
    0.02883322f, 0.07771315f, -0.07417179f, 0.09860828f, 0.02811933f, -0.04571433f, 0.12823501f, 0.03472831f, 
    0.21170118f, -0.12756313f, 0.12740682f, -0.12531590f, 0.03183117f, -0.05044058f, -0.00071757f, -0.06646101f, 
    0.02678500f, 0.02791299f, 0.03873480f, 0.00689168f, -0.06606988f, -0.09786222f, 0.00496520f, -0.10948183f, 
    0.06857965f, 0.04284248f, -0.02232257f, -0.07109866f, 0.10690014f, 0.02790608f, 0.08980782f, 0.11964350f, 
    -0.04497829f, 0.03277799f, 0.11668777f, 0.10832441f, -0.03234680f, 0.05961917f, -0.00519663f, -0.03258897f, 
    0.06096692f, 0.08287074f, 0.03011357f, 0.05706217f, 0.03536757f, 0.14034607f, 0.15807293f, 0.00100297f, 
    0.04012415f, 0.08856990f, 0.10715390f, 0.05896050f, 0.08826998f, 0.06958159f, 0.15085782f, 0.09552862f, 
    0.05844020f, -0.18610929f, -0.00835938f, -0.13026094f, 0.03910958f, -0.06225796f, 0.06534775f, 0.01273447f, 
    -0.01426628f, -0.01110340f, 0.01075633f, -0.01253759f, 0.03498367f, 0.03652851f, 0.00522345f, 0.06022425f, 
    -0.01330973f, 0.04976990f, 0.09281026f, -0.01131413f, -0.03760515f, 0.06855901f, -0.05445258f, 0.09310264f, 
    -0.30628896f, 0.10602722f, -0.03959397f, 0.01155656f, 0.01072265f, 0.01104871f, -0.07019971f, -0.16237609f, 
    0.12647098f, 0.03332993f, -0.00042823f, 0.01394987f, -0.03151638f, -0.13394816f, 0.00685000f, 0.01416451f, 
    0.06061919f, 0.00521257f, 0.07514609f, 0.08795485f, -0.17251061f, 0.02265250f, -0.05986284f, 0.03884917f, 
    0.03183293f, -0.04180868f, -0.03400961f, -0.17015968f, 0.02980309f, 0.01764505f, 0.01230012f, 0.02391651f, 
    0.06783429f, -0.02423381f, 0.01862413f, 0.05791540f, -0.01571951f, -0.06969685f, -0.00972789f, -0.06608840f, 
    -0.04696356f, 0.03280444f, -0.03947218f, 0.01727504f, 0.08811253f, 0.13348532f, -0.07984655f, -0.03981221f, 
    0.28703338f, 0.00483750f, -0.00279963f, 0.06918886f, 0.02259800f, -0.02979818f, 0.03815420f, -0.01658551f, 
    -0.12817800f, 0.06646404f, 0.07438073f, 0.09557575f, -0.09753320f, 0.10282633f, 0.11540929f, -0.01141314f, 
    0.14293995f, 0.00744491f, 0.03994937f, -0.04645286f, 0.07065550f, 0.08878505f, 0.07236528f, 0.04909258f, 
    -0.29443896f, 0.19687539f, 0.09104161f, 0.29153413f, 0.04476572f, 0.05292477f, 0.02961782f, -0.03102739f, 
    -0.01367519f, -0.02249889f, -0.00422639f, -0.00653357f, -0.17638451f, 0.11800096f, 0.11428405f, -0.06011695f, 
    0.04578648f, -0.01988355f, -0.01016615f, 0.06976257f, 0.05914807f, 0.07875052f, -0.05124277f, 0.05232848f, 
    -0.05281312f, 0.03221722f, 0.00712709f, -0.04179420f, 0.04409692f, 0.01138936f, -0.00881699f, 0.02060656f, 
    0.08186243f, 0.01162291f, 0.01878053f, -0.05010219f, -0.03434680f, 0.01968499f, 0.16546419f, 0.09163282f, 
    -0.03434190f, 0.00579830f, 0.04977673f, -0.02524251f, 0.09613467f, 0.02737013f, 0.06828636f, 0.02935274f, 
    -0.22500089f, 0.05518278f, -0.04595026f, -0.10517588f, -0.01185009f, -0.05236685f, 0.09409880f, 0.01781857f, 
    -0.00950135f, -0.02526114f, 0.14220995f, 0.05907997f, 0.05412887f, -0.02173194f, -0.09975831f, 0.24817209f, 
    0.03476974f, -0.04953242f, 0.11416857f, -0.04770244f, 0.02038254f, -0.06589519f, -0.07221256f, -0.05702922f, 
    0.02977274f, 0.01521644f, -0.01316996f, 0.00318267f, 0.02620851f, -0.03828898f, 0.01385066f, -0.03692913f, 
    0.00239492f, -0.01914498f, -0.00939136f, 0.02362778f, 0.01565603f, -0.00867076f, -0.02426430f, -0.01242367f, 
    0.00411562f, 0.03390231f, -0.01271307f, 0.03132084f, -0.01626447f, -0.03652462f, -0.01021892f, -0.01012972f, 
    -0.01696440f, -0.03434302f, -0.02872500f, 0.01710609f, 0.02793922f, 0.01261277f, -0.01002928f, 0.03058058f, 
    -0.02008820f, 0.03093682f, -0.01807980f, 0.00235877f, 0.02657252f, 0.00662767f, -0.01216727f, 0.01730120f, 
    -0.03619475f, -0.02157963f, 0.02396423f, 0.00869396f, -0.03536474f, -0.03498109f, -0.00452986f, -0.01060576f, 
    0.00574589f, -0.00065811f, -0.00119675f, 0.02236537f, -0.01441080f, -0.03999103f, 0.00292882f, 0.00770785f, 
    0.03306289f, 0.00503382f, 0.00820258f, 0.02994428f, 0.01191637f, 0.00115886f, 0.02068325f, -0.04366057f, 
    0.00119078f, -0.03699687f, -0.03953919f, -0.02852149f, -0.04334193f, -0.03369878f, 0.02554173f, -0.00639389f, 
    -0.03034567f, -0.01758158f, 0.02264493f, -0.02573007f, -0.02872955f, -0.01275067f, 0.00190776f, 0.01881546f, 
    0.01308189f, -0.00716513f, 0.01536811f, -0.01028202f, 0.00158332f, 0.00069187f, -0.02019780f, 0.00778291f, 
    0.00868637f, 0.01990986f, 0.02955901f, -0.03318364f, -0.03612279f, -0.00686619f, -0.01108735f, -0.00360260f, 
    0.01420197f, -0.03351138f, -0.00636727f, -0.02401114f, 0.02364383f, 0.02359610f, -0.01695095f, -0.01260278f, 
    0.02284332f, -0.02428773f, 0.01019117f, 0.01056810f, 0.00644369f, -0.01262384f, -0.02008261f, 0.03208753f, 
    0.00379932f, 0.01863066f, 0.01506803f, 0.02585871f, 0.00672398f, -0.01592562f, -0.02073549f, 0.02133356f, 
    -0.02494287f, 0.01986216f, -0.00617792f, -0.00030176f, -0.04477402f, -0.04143351f, -0.02345517f, 0.03217004f, 
    0.02387575f, -0.02727514f, -0.01396190f, -0.00467117f, 0.01050570f, -0.03885535f, -0.00068712f, -0.01018961f, 
    -0.03360961f, 0.00928209f, -0.03134378f, -0.00378709f, 0.01547597f, 0.02308611f, -0.00127842f, -0.00667920f, 
    -0.00823487f, -0.03070071f, 0.03318796f, -0.03260946f, -0.02663808f, 0.00843914f, 0.02442270f, -0.01484579f, 
    -0.01724336f, -0.00826539f, 0.00685468f, -0.01596886f, -0.01291903f, -0.01594787f, 0.00783693f, -0.03595440f, 
    -0.03740839f, -0.00677082f, 0.00465950f, -0.02024291f, 0.01780502f, -0.03387590f, -0.03089857f, 0.02772016f, 
    0.01929737f, -0.00322010f, -0.00423328f, -0.04026185f, 0.00180893f, -0.02014706f, 0.02500954f, 0.00513169f, 
    -0.02009603f, -0.03784009f, -0.02000823f, 0.01805854f, -0.00969315f, 0.02798424f, -0.01277331f, 0.01321474f, 
    -0.01218537f, 0.02976256f, -0.02687699f, 0.01215756f, -0.03249142f, 0.01948100f, -0.03461514f, -0.02376704f, 
    -0.03012282f, -0.00544648f, -0.04013366f, 0.01800477f, -0.03701998f, -0.01579904f, 0.01614910f, -0.02630148f, 
    -0.02489340f, 0.00254671f, -0.03459609f, 0.00706675f, -0.03543376f, -0.01063904f, -0.04102193f, -0.01736554f, 
    -0.03620920f, 0.00197891f, -0.00553848f, -0.01414079f, -0.00945272f, 0.00702328f, 0.00956251f, -0.02129857f, 
    -0.00303842f, -0.01347968f, -0.00682405f, -0.01596115f, -0.03128907f, 0.01538005f, -0.03780813f, -0.03174101f, 
    0.01673506f, -0.02104888f, -0.01912328f, -0.03947049f, -0.00812189f, -0.00934558f, 0.01249553f, -0.04453694f, 
    -0.04378444f, 0.01140314f, -0.00650582f, 0.00786361f, 0.02865526f, -0.00294238f, -0.02289019f, -0.02237689f, 
    -0.01801356f, -0.04208732f, -0.00864278f, -0.00275723f, -0.00178334f, -0.01871745f, -0.01277242f, -0.02405846f, 
    0.01495630f, -0.00023731f, 0.00982950f, 0.01247007f, 0.00445482f, 0.01847389f, 0.01808050f, -0.01832739f, 
    -0.02333247f, -0.03370780f, 0.03131357f, 0.00529958f, -0.02912942f, -0.00391968f, 0.00710054f, -0.00496591f, 
    -0.00176810f, -0.02241508f, 0.00458743f, -0.01656590f, -0.03210779f, -0.00436983f, -0.02722559f, 0.01352238f, 
    0.02440438f, -0.03942841f, -0.04005969f, 0.02402471f, 0.03292277f, 0.01481770f, -0.02878580f, -0.02871246f, 
    0.00892856f, -0.00090752f, 0.02023162f, 0.02972715f, -0.03469554f, -0.04046103f, 0.01218797f, -0.02113668f, 
    -0.03976501f, 0.03030193f, 0.01393664f, 0.02180574f, -0.04167702f, -0.00198653f, -0.02466182f, -0.00172634f, 
    0.01098224f, -0.01394006f, -0.01774894f, 0.03036792f, 0.01547835f, -0.01504870f, -0.03690417f, 0.02273845f, 
    0.02694324f, 0.02206002f, -0.01136457f, -0.00340290f, -0.00232306f, 0.01591863f, -0.02034885f, -0.01496353f, 
    -0.00641038f, -0.01778343f, -0.02095988f, 0.02265565f, 0.00936603f, -0.04094271f, 0.01560467f, -0.01528375f, 
    -0.00989909f, -0.03925935f, -0.03026889f, -0.00903896f, 0.01295793f, -0.01659420f, 0.02624781f, 0.02192569f, 
    0.01849404f, 0.02989008f, -0.01925728f, 0.02366405f, 0.01047918f, 0.02212383f, -0.03520029f, -0.01431564f, 
    -0.04620487f, 0.01877739f, -0.02780659f, -0.03447378f, -0.03983588f, -0.01587301f, 0.01687974f, -0.01031799f, 
    0.02732122f, 0.02558155f, -0.00403584f, -0.03031373f, -0.00562507f, -0.00148221f, 0.02134678f, -0.03633734f, 
    -0.00493377f, 0.01934643f, -0.03140393f, -0.02901844f, -0.01836095f, -0.03218914f, -0.02163297f, -0.02090903f, 
    -0.00842038f, -0.01641404f, -0.04706667f, -0.01798949f, 0.01351001f, -0.01625882f, 0.02059443f, 0.01050871f, 
    0.02317599f, -0.01637694f, -0.02025015f, -0.02559400f, -0.04294620f, -0.02150874f, 0.00421659f, 0.00191882f, 
    -0.01687175f, -0.01219377f, -0.00843655f, -0.03249983f, 0.03054298f, 0.00645075f, -0.03111606f, -0.02538407f, 
    -0.04265039f, -0.01770595f, -0.01022907f, -0.03960310f, -0.00582149f, 0.01280994f, 0.03289743f, -0.00235486f, 
    0.00074622f, -0.02807008f, -0.03806214f, -0.03501169f, 0.02033441f, 0.02399059f, 0.02386268f, -0.00513981f, 
    0.01840768f, -0.02702632f, -0.02316801f, 0.00230088f, 0.00600107f, -0.00973941f, 0.01786845f, 0.01832530f, 
    0.02463152f, -0.01071139f, -0.01154384f, 0.02776933f, -0.00361903f, -0.04091459f, -0.01217704f, -0.00491679f, 
    -0.02220592f, -0.01613187f, -0.03671902f, -0.01819474f, -0.00850810f, -0.01491374f, -0.01141793f, 0.00814942f, 
    -0.03325570f, -0.02359017f, -0.00853927f, -0.01819662f, 0.03050517f, 0.02335642f, -0.00133719f, 0.02704954f, 
    0.01129514f, 0.01033614f, 0.03989320f, 0.01846169f, -0.03596525f, 0.02313198f, -0.03339795f, 0.02726977f, 
    0.02435482f, -0.01577482f, -0.03974438f, -0.03883014f, 0.00196949f, 0.00836431f, 0.00920467f, 0.02587969f, 
    -0.04097801f, -0.00351795f, 0.00570003f, -0.02403330f, -0.00577973f, 0.02815785f, 0.00218854f, -0.03359728f, 
    -0.03238080f, 0.02387757f, -0.03708120f, 0.01025729f, -0.04458897f, -0.02261760f, -0.00551638f, 0.02685728f, 
    0.01592383f, 0.01922354f, 0.02453718f, -0.02170756f, -0.01999131f, 0.01506790f, -0.02664866f, 0.00817763f, 
    0.01225862f, -0.02101324f, -0.02781485f, 0.01637504f, 0.02846051f, -0.03668282f, -0.00977736f, -0.04110249f, 
    -0.00137727f, 0.02320591f, -0.00333266f, -0.00923906f, 0.00320449f, 0.02269186f, -0.02046755f, 0.01133411f, 
    -0.03019280f, 0.01475940f, -0.03171980f, -0.01893198f, -0.00913309f, 0.00055027f, 0.00556787f, 0.02663253f, 
    -0.01651424f, -0.00257024f, 0.02378602f, 0.01669952f, -0.02062013f, -0.02864601f, 0.02194651f, 0.01971965f, 
    0.02582792f, 0.01916750f, -0.00296141f, -0.01174150f, -0.01168977f, 0.01233105f, -0.00062878f, 0.01194085f, 
    0.03026248f, 0.00376021f, 0.01656052f, 0.02018471f, -0.01568473f, -0.03374916f, -0.00842558f, 0.01075478f, 
    -0.01781379f, 0.01102489f, 0.01119881f, -0.02944507f, -0.04665921f, 0.01989079f, -0.00719005f, 0.00874141f, 
    -0.02242627f, -0.00953612f, 0.01635635f, -0.02333702f, -0.02932453f, -0.03173963f, -0.00693583f, -0.03531332f, 
    0.01574904f, 0.02057888f, -0.04081301f, -0.00867212f, -0.02783730f, 0.01680097f, -0.01407363f, 0.02547167f, 
    -0.03522189f, 0.02355992f, -0.03081029f, -0.02360048f, -0.02621634f, -0.02182338f, 0.02349532f, -0.00145778f, 
    0.00799981f, -0.03841640f, -0.03436135f, -0.02061989f, -0.04361073f, 0.02036747f, -0.01486976f, -0.01404106f, 
    0.03359844f, 0.01925859f, -0.01201484f, 0.00122050f, 0.00882030f, -0.02868664f, -0.00664928f, -0.04247534f, 
    -0.04369074f, 0.02908852f, 0.01358324f, 0.01574748f, -0.02479749f, 0.00679675f, -0.02583498f, 0.02314779f, 
    0.00360277f, 0.00490866f, -0.01107500f, -0.01968393f, -0.01141188f, -0.03498468f, -0.00252607f, -0.02945475f, 
    0.00798731f, 0.01859056f, 0.01288777f, -0.00575222f, 0.00318236f, -0.00587646f, 0.01617508f, 0.03166233f, 
    0.01209234f, -0.00112182f, 0.01302097f, -0.01434842f, 0.00922830f, -0.00017678f, -0.01770370f, 0.00344239f, 
    -0.01292513f, -0.04131549f, 0.01393754f, 0.00133303f, -0.00866585f, -0.02790653f, -0.03976989f, -0.01905595f, 
    0.02635200f, 0.02490180f, -0.02794432f, 0.01170649f, -0.00279036f, -0.02721958f, 0.00081210f, -0.00232101f, 
    0.00812037f, -0.00187257f, 0.01628605f, -0.04222655f, 0.01239635f, 0.01866218f, -0.00989477f, 0.02266431f, 
    -0.03031421f, -0.01833907f, -0.00319980f, 0.00526188f, -0.00499763f, 0.01620282f, 0.02493075f, -0.02794372f, 
    -0.01519526f, -0.00030234f, 0.01159759f, 0.02614630f, -0.02511413f, 0.01889054f, 0.00942214f, 0.01780432f, 
    -0.01712541f, -0.01857240f, 0.01258546f, 0.01126127f, -0.01982081f, -0.01188295f, -0.00760277f, -0.01999002f, 
    0.00357377f, 0.02055547f, -0.02384027f, -0.00114998f, 0.02680147f, -0.00226039f, -0.03569667f, 0.02358560f, 
    -0.02878123f, 0.01698776f, -0.02689332f, -0.02013670f, 0.01243154f, 0.00792634f, -0.02684194f, 0.02994804f, 
    -0.01063744f, -0.01702912f, -0.03576382f, 0.00653635f, -0.03724978f, -0.00468659f, 0.00124752f, -0.01964157f, 
    -0.03234535f, 0.01552529f, -0.00264359f, 0.01709571f, -0.00335746f, 0.01235789f, 0.00566238f, 0.01793984f, 
    0.02097741f, -0.02275174f, -0.03377444f, 0.00190447f, -0.00908423f, -0.00547331f, -0.01927678f, -0.00582251f, 
    0.00936083f, -0.00369384f, 0.02299910f, -0.02577038f, -0.04086239f, 0.01565382f, 0.02002491f, -0.03500837f, 
    0.01997257f, 0.02292466f, -0.03186502f, -0.03121807f, -0.02975469f, 0.01276983f, -0.00636059f, -0.01636979f, 
    -0.01028270f, -0.00188337f, -0.03524794f, -0.02739660f, -0.01161537f, 0.01441069f, 0.02310176f, -0.01719968f, 
    -0.03384477f, -0.01492687f, -0.01710929f, -0.00539684f, -0.01149269f, 0.01306539f, -0.01369557f, 0.00530363f, 
    -0.04002289f, 0.02650564f, -0.02152539f, 0.00079329f, -0.01637138f, -0.02521079f, -0.01013345f, 0.02055138f, 
    0.02776180f, -0.03240670f, -0.00867815f, -0.04143476f, -0.02950804f, 0.02070232f, 0.02146289f, -0.02412394f, 
    -0.02715041f, -0.00693833f, -0.00739256f, -0.02529473f, 0.01213181f, -0.03412122f, -0.02684619f, -0.02426914f, 
    0.03725750f, -0.02552604f, -0.00933723f, 0.01740943f, -0.02893005f, -0.01320049f, -0.04143171f, 0.01458472f, 
    0.01254320f, -0.02175001f, 0.01111405f, 0.01387911f, 0.01239796f, -0.00670799f, -0.02615927f, -0.01253015f, 
    0.01937143f, 0.01445932f, -0.02095254f, 0.02226762f, -0.02708454f, 0.01961170f, 0.00439034f, 0.02789038f, 
    -0.23487496f, 0.15812439f, 0.05000621f, 0.02281605f, 0.03928808f, 0.01546056f, -0.00669515f, 0.00751276f, 
    -0.03563865f, -0.02351382f, -0.06060206f, 0.00011745f, 0.12671061f, -0.11430065f, -0.01360067f, -0.04074172f, 
    -0.03991017f, -0.05558890f, -0.08682793f, -0.09948353f, 0.09775157f, -0.05058987f, 0.04661227f, -0.07454481f, 
    0.14252637f, 0.16600685f, -0.06552284f, 0.20406350f, 0.00577651f, 0.02302852f, 0.14016874f, -0.02480181f, 
    -0.03914467f, -0.08990087f, 0.09029809f, -0.08641215f, 0.16211960f, 0.11265159f, 0.09228111f, 0.02553094f, 
    -0.01962483f, 0.00300699f, -0.05020177f, 0.02246007f, -0.04318506f, -0.05905440f, -0.01499803f, -0.06291433f, 
    0.05870742f, -0.02192884f, 0.00305680f, 0.08983248f, 0.10319010f, 0.12150548f, 0.03494800f, 0.03256666f, 
    0.02679016f, -0.02217919f, 0.04277729f, -0.03147191f, 0.06907707f, 0.05968824f, 0.26056179f, -0.01214376f, 
    0.16178383f, -0.10613928f, 0.01272949f, -0.04809459f, -0.04568860f, -0.02218191f, -0.06836914f, 0.00298115f, 
    -0.15273023f, 0.09840528f, -0.05751180f, 0.00163576f, 0.04917158f, -0.05506327f, 0.11535533f, -0.04504425f, 
    0.01526416f, -0.00244808f, -0.05306982f, -0.07134142f, 0.00937303f, -0.10082302f, -0.01183585f, 0.03357219f, 
    0.03080258f, 0.08694292f, -0.11164796f, -0.01172513f, -0.06694925f, -0.00146972f, 0.04206585f, 0.02982231f, 
    -0.05922065f, -0.31586662f, -0.00859092f, -0.14049603f, -0.09193175f, 0.01232995f, -0.01741170f, -0.06567602f, 
    -0.02744647f, -0.07294904f, 0.00971767f, -0.07089695f, 0.14907908f, 0.02943357f, -0.04572729f, 0.12917541f, 
    -0.02098876f, -0.02860465f, 0.00928961f, 0.14611438f, 0.02060905f, 0.04071926f, 0.17035335f, 0.14761540f, 
    0.23205997f, -0.00108755f, 0.21411075f, -0.00443315f, 0.00572375f, -0.00639071f, -0.03667850f, -0.04180541f, 
    -0.03683007f, 0.03973483f, -0.00867629f, 0.16161768f, 0.40760449f, 0.23406015f, 0.04295465f, 0.03079648f, 
    -0.04314210f, -0.01429126f, 0.12737098f, -0.04825249f, 0.06024610f, -0.06830855f, -0.05096696f, 0.01204493f, 
    -0.23320086f, -0.10763622f, 0.01176220f, 0.06890446f, 0.01819447f, 0.03837284f, 0.04799533f, 0.05964709f, 
    -0.01350128f, -0.06214724f, -0.11562060f, -0.05680089f, -0.32564068f, -0.03332712f, 0.05046475f, 0.00417211f, 
    -0.02119538f, 0.02694865f, -0.11340152f, -0.14306657f, 0.01217795f, -0.05152940f, -0.04183875f, 0.00892141f, 
    0.11882660f, 0.02118703f, 0.00378963f, 0.12000956f, -0.09224520f, 0.08338886f, 0.02326513f, -0.00713273f, 
    0.02762948f, 0.07596260f, -0.11396830f, -0.16801383f, -0.00679554f, 0.03898393f, -0.09652532f, -0.05558800f, 
    0.02752646f, -0.04008256f, -0.06554133f, -0.06507821f, 0.00507490f, -0.08299875f, 0.06000491f, 0.01129751f, 
    0.15940200f, 0.17298371f, 0.05859423f, 0.12867165f, 0.03503242f, 0.02777179f, -0.01745888f, 0.03942256f, 
    0.03418299f, -0.01058068f, -0.05413884f, -0.06569988f, 0.03396427f, -0.00454842f, 0.13190405f, 0.09737777f, 
    0.02462486f, 0.06238709f, 0.01830862f, 0.06128769f, 0.01504018f, 0.02323169f, -0.02210436f, 0.11958919f, 
    -0.04612453f, -0.12514456f, -0.05992356f, 0.00319589f, 0.02375285f, -0.01216493f, 0.11760420f, 0.04103241f, 
    0.00277491f, -0.03743162f, -0.02318723f, -0.04451887f, 0.18301399f, 0.12164172f, 0.05873348f, -0.00771789f, 
    0.13901891f, 0.03676981f, -0.03589385f, -0.05086957f, 0.03758878f, -0.13364232f, -0.03135962f, -0.02631357f, 
    0.04980903f, 0.19789621f, 0.09998865f, 0.04588442f, 0.03374985f, 0.04813724f, -0.12259343f, -0.01494605f, 
    0.02602092f, 0.02400842f, -0.09181878f, 0.01590269f, -0.13922854f, 0.11401495f, 0.26082838f, 0.09717056f, 
    0.02800683f, 0.02135097f, -0.00886787f, -0.00824627f, 0.03415847f, -0.00796025f, -0.05328650f, 0.07246383f, 
    -0.08477662f, 0.19382925f, -0.05009340f, 0.13481210f, -0.02508124f, -0.05907504f, -0.02931603f, 0.00676172f, 
    -0.07444998f, -0.06744748f, 0.04121729f, -0.05493765f, 0.10952967f, -0.02109594f, 0.24299845f, 0.18356197f, 
    0.04437688f, 0.01226511f, 0.03138163f, -0.02047284f, -0.02088984f, 0.16377896f, 0.18597047f, 0.14601032f, 
    -0.02837374f, -0.02095168f, 0.06960715f, -0.01648788f, 0.11024589f, -0.05806752f, -0.06670522f, 0.06096124f, 
    -0.06716989f, 0.06855220f, 0.02202179f, 0.12288646f, -0.16481632f, 0.09493697f, 0.02151585f, -0.05597292f, 
    0.01773270f, -0.01196550f, -0.07217676f, -0.07114124f, 0.00665448f, -0.14700994f, -0.13813032f, -0.01744842f, 
    -0.01509512f, -0.04959933f, -0.02298694f, 0.08866692f, -0.04291967f, -0.03248026f, -0.02765710f, -0.05814271f, 
    -0.01504605f, -0.03114832f, 0.03947153f, -0.01317484f, -0.03682508f, 0.06595439f, 0.18970828f, 0.19492991f, 
    -0.00163691f, -0.02791648f, -0.04324804f, 0.04050330f, 0.14426164f, 0.05767512f, 0.01034908f, 0.03566744f, 
    -0.06441865f, 0.07980090f, 0.17299290f, 0.14743860f, -0.00542737f, -0.04774121f, 0.03844664f, 0.02769521f, 
    -0.06400970f, 0.11227625f, 0.00829942f, 0.03134555f, -0.15474413f, -0.02574075f, -0.03666979f, 0.10393362f, 
    0.18889879f, 0.05238976f, 0.02178707f, 0.06493368f, 0.17758891f, 0.08796813f, 0.13758224f, -0.01791453f, 
    -0.00679491f, 0.04055484f, 0.08702184f, 0.06486155f, -0.05378269f, -0.00273630f, -0.04676307f, -0.00898796f, 
    0.02948677f, -0.07861276f, 0.03328314f, -0.06043245f, 0.29155552f, 0.02166205f, -0.02770912f, -0.08927024f, 
    -0.03528068f, 0.11681162f, 0.02043772f, 0.12858023f, -0.05256063f, 0.17590255f, 0.09899446f, 0.09387260f, 
    0.00914383f, 0.08067957f, -0.12255593f, -0.05641032f, -0.02702536f, -0.04504244f, -0.02209335f, -0.00135681f, 
    -0.09372406f, -0.12793736f, -0.01916183f, -0.05621096f, 0.05821171f, 0.31260055f, -0.16924813f, 0.02773757f, 
    -0.02835908f, 0.06921490f, -0.11051033f, -0.00027521f, -0.01147568f, 0.01895695f, -0.11841049f, -0.06714500f, 
    -0.24100740f, 0.09306984f, 0.08566383f, 0.16793306f, -0.04968428f, 0.06666980f, -0.06567971f, 0.05315583f, 
    0.00999601f, 0.01179439f, -0.11216629f, -0.05046006f, -0.10296483f, 0.19995530f, -0.00508623f, -0.07707635f, 
    -0.13707365f, 0.03645053f, -0.02546460f, 0.00240618f, -0.07332040f, -0.06330891f, -0.00259793f, -0.04406338f, 
    0.11212525f, -0.12201875f, 0.00486883f, 0.07348632f, 0.01911604f, -0.06383841f, 0.01732258f, -0.17279288f, 
    0.06816781f, -0.01420230f, -0.08044617f, -0.11682518f, 0.09737756f, 0.04471573f, 0.22739826f, 0.06899600f, 
    -0.02586516f, -0.08686226f, 0.06087888f, 0.15532763f, 0.00263083f, 0.02066324f, -0.07817717f, 0.10189483f, 
    0.03238242f, -0.15119088f, 0.19054157f, 0.03863411f, 0.03819833f, 0.05060319f, 0.04072064f, -0.00020884f, 
    0.00562429f, -0.01985745f, 0.10033593f, -0.07477900f, 0.02592716f, 0.08514997f, 0.05120498f, 0.29825017f, 
    -0.03001877f, -0.08951437f, 0.13799407f, 0.00934165f, 0.02208162f, 0.04251792f, 0.04712015f, 0.06342886f, 
    -0.18490328f, 0.14290832f, -0.15311280f, -0.00662950f, -0.07620185f, -0.10685040f, -0.08195010f, -0.03075700f, 
    -0.01491109f, -0.00963335f, 0.12973335f, -0.12335595f, -0.04937401f, -0.11342068f, -0.05282877f, -0.09627268f, 
    0.03856665f, 0.00738156f, -0.08531132f, -0.20006236f, -0.03418168f, -0.07273993f, 0.04559547f, 0.10027032f, 
    -0.00424531f, -0.06608420f, 0.07291716f, -0.03998077f, 0.04581137f, -0.10462390f, -0.06532412f, -0.06204025f, 
    -0.04518538f, -0.03397159f, -0.04077476f, 0.00206471f, -0.17122351f, 0.02045850f, -0.06896456f, 0.16297889f, 
    0.04573475f, 0.00706746f, -0.05326551f, -0.02312005f, -0.02863832f, 0.01015687f, -0.06460574f, -0.12138028f, 
    0.00700312f, 0.00541070f, -0.01336837f, -0.02153648f, -0.04455907f, 0.10268280f, 0.22688778f, 0.06893512f, 
    0.04568659f, -0.08045514f, -0.08888502f, 0.02430512f, 0.15177591f, 0.05445194f, -0.05995147f, -0.24171981f, 
    -0.01630031f, -0.02607292f, -0.01058023f, -0.05623104f, 0.00111126f, -0.01506754f, 0.10281476f, 0.03036496f, 
    -0.04553155f, -0.05503360f, 0.25046235f, 0.06924041f, 0.04529979f, 0.07532026f, -0.07784231f, 0.01238955f, 
    0.02422631f, 0.07006347f, 0.04865896f, 0.07623270f, 0.10990430f, -0.09010007f, -0.07154300f, 0.04428003f, 
    -0.04779810f, 0.01520113f, -0.06856760f, 0.04951018f, -0.01437332f, -0.06760929f, -0.04931322f, -0.05952897f, 
    -0.26778686f, -0.21049267f, 0.18812807f, -0.00658774f, -0.02420360f, 0.12831780f, 0.01557761f, 0.00588031f, 
    0.08549304f, 0.03130176f, -0.11298035f, 0.10568196f, -0.02640355f, -0.01296580f, 0.03356582f, 0.01115463f, 
    -0.01591356f, 0.06973823f, 0.06944462f, -0.08004944f, 0.04352552f, 0.04061113f, 0.05725322f, -0.10860130f, 
    0.09320650f, 0.09459602f, 0.11628864f, -0.03771688f, -0.03895073f, -0.06380130f, 0.01946221f, -0.02565536f, 
    0.00355399f, -0.13021107f, 0.05172454f, -0.00665411f, -0.21376374f, 0.13710514f, 0.14531177f, 0.06145667f, 
    -0.02253090f, 0.03665770f, -0.02586217f, 0.00207665f, 0.08235383f, -0.02399485f, -0.06189960f, 0.04068097f, 
    -0.20953719f, 0.10842222f, -0.01058449f, 0.00638025f, 0.02423479f, 0.09998479f, -0.12240724f, -0.01408334f, 
    0.00485673f, 0.10336821f, -0.05197176f, -0.02085391f, -0.14422968f, 0.02048895f, 0.15784228f, 0.10339164f, 
    0.06653382f, 0.03908136f, -0.06071132f, 0.06207298f, -0.04999255f, 0.03945941f, 0.16280949f, 0.10556824f, 
    0.30871978f, 0.20551206f, -0.02544858f, 0.03004729f, -0.01719759f, 0.03658336f, 0.08427836f, 0.01821946f, 
    -0.00704457f, -0.00870421f, -0.03992643f, -0.01710106f, 0.04408396f, 0.02807505f, 0.20947148f, -0.02046619f, 
    0.04441399f, 0.02469414f, 0.00875495f, -0.03324998f, -0.01127887f, 0.17490640f, -0.08726466f, -0.00361237f, 
    0.01582136f, 0.04691268f, -0.06984013f, -0.04576447f, -0.01312024f, -0.10091285f, -0.10105250f, -0.02315590f, 
    -0.07014122f, 0.01247813f, 0.12558921f, -0.02198958f, 0.25205863f, -0.07823089f, -0.04233315f, -0.02314312f, 
    0.01479819f, 0.00800817f, 0.10499753f, -0.03916541f, -0.02941726f, 0.08203648f, 0.06891661f, -0.01131686f, 
    -0.12599267f, 0.14906904f, 0.07102221f, -0.09282908f, -0.01446035f, 0.00068507f, 0.04914848f, 0.02282278f, 
    -0.02229618f, -0.00105892f, -0.03548260f, 0.05556772f, -0.14672650f, 0.07780305f, 0.26837608f, 0.12019730f, 
    0.05327057f, 0.08847616f, -0.09524907f, -0.01785370f, 0.00089749f, 0.12817878f, -0.03224282f, 0.03067091f, 
    -0.00187846f, -0.01774926f, -0.00154060f, 0.10649162f, 0.02494359f, 0.06445306f, -0.01387553f, -0.04988765f, 
    0.03644643f, -0.03629009f, -0.04355431f, -0.06724577f, -0.19963637f, -0.13070697f, 0.02334339f, 0.02225731f, 
    0.00011547f, 0.06615361f, -0.00454095f, -0.00906941f, 0.06557867f, 0.01515791f, 0.07139609f, 0.01172075f, 
    0.40387988f, 0.27390295f, -0.02206443f, 0.05823698f, 0.11342434f, 0.15680929f, 0.13357885f, -0.00213956f, 
    0.09152322f, -0.03731451f, 0.13362034f, -0.03676794f, -0.23034604f, 0.21439831f, -0.07071883f, -0.00881248f, 
    -0.00780047f, -0.06183580f, 0.06562247f, -0.06224018f, -0.00387136f, -0.03240027f, -0.06264873f, 0.03977723f, 
    -0.05352278f, -0.11675415f, 0.05907743f, 0.06031848f, 0.02065992f, 0.10428747f, 0.06890744f, 0.16296488f, 
    0.02255845f, 0.05768538f, 0.05591359f, 0.04807577f, 0.16666514f, 0.07196597f, 0.10094191f, 0.17617200f, 
    -0.06216492f, 0.04053201f, 0.04536062f, -0.01202297f, 0.06995302f, -0.01514457f, 0.05305178f, -0.01503856f, 
    -0.00090693f, 0.10285784f, -0.02414497f, -0.14885299f, 0.00292554f, 0.03656126f, 0.12209595f, 0.01430418f, 
    0.03170917f, -0.16722776f, 0.02921610f, 0.00220180f, 0.18457328f, -0.36019894f, 0.13978004f, 0.28131399f, 
    0.00333378f, 0.11941731f, -0.03204760f, 0.08713132f, 0.07018927f, 0.06320646f, 0.00392139f, -0.11552521f, 
    -0.23567475f, -0.10385674f, 0.07530893f, 0.06760661f, 0.09757382f, 0.03135848f, -0.15256503f, 0.07437350f, 
    0.09425490f, -0.09004086f, 0.11064056f, 0.02229175f, 0.04585937f, -0.15380451f, 0.23598573f, 0.15100437f, 
    0.08111002f, 0.01341204f, 0.06172639f, 0.08920725f, -0.00162976f, -0.02737177f, -0.08630692f, 0.11785617f, 
    0.02381754f, 0.06499007f, -0.06382032f, -0.06744918f, 0.06667511f, -0.00543794f, 0.04675895f, 0.03209958f, 
    0.05679797f, -0.01870401f, -0.02005740f, -0.03185898f, 0.23056029f, 0.16545537f, 0.04313336f, -0.06067142f, 
    -0.06185990f, 0.05558852f, 0.02471649f, -0.02175822f, -0.08012288f, -0.05142029f, 0.18981671f, 0.16478281f, 
    0.13151494f, -0.03849634f, 0.18039222f, 0.13967177f, -0.14635326f, 0.06589076f, 0.10649827f, -0.01272362f, 
    0.09425008f, -0.04235459f, -0.00764410f, -0.11035846f, 0.20941377f, 0.01728512f, 0.11609054f, 0.23601907f, 
    -0.03367405f, 0.09322225f, 0.04504811f, 0.09056494f, 0.00324360f, 0.07592864f, 0.09552734f, 0.23365717f, 
    -0.10590251f, -0.06255788f, 0.06163058f, -0.05810380f, -0.01267051f, -0.04844214f, 0.08139581f, 0.02352894f, 
    -0.02571474f, 0.01905511f, 0.05242055f, 0.19258600f, 0.42220291f, -0.12395071f, -0.09605686f, -0.09938966f, 
    0.04822243f, 0.00058773f, 0.11838315f, 0.00411628f, 0.02865771f, 0.05115334f, -0.11137325f, 0.07014836f, 
    0.11058298f, 0.06927198f, 0.16819039f, -0.04855900f, 0.01753902f, 0.00463336f, 0.00091504f, 0.10520333f, 
    0.01222169f, -0.13942502f, -0.00045506f, 0.07354952f, 0.00012397f, 0.03854926f, 0.21760675f, 0.08723420f, 
    0.04372602f, 0.01028384f, 0.01090848f, 0.01953594f, 0.09689869f, -0.11621933f, 0.15367813f, -0.06426744f, 
    0.21174105f, -0.01535913f, 0.01724938f, 0.10995171f, -0.06072366f, 0.02571927f, 0.10233726f, 0.07409658f, 
    0.10320852f, 0.07286239f, -0.00541607f, -0.04069477f, 0.11949544f, 0.10902280f, 0.02622568f, 0.04251808f, 
    0.02230795f, -0.01252157f, -0.03441579f, 0.01453218f, 0.03555542f, -0.03347080f, 0.08541285f, 0.11142094f, 
    0.00706375f, -0.06084740f, 0.00958093f, -0.11471521f, -0.02113467f, 0.03524813f, 0.02830771f, 0.11156300f, 
    0.02149788f, 0.05083808f, -0.08847039f, 0.02364312f, 0.01768206f, -0.07751187f, -0.01197349f, 0.00199905f, 
    0.01391496f, 0.08023688f, 0.06462453f, -0.00002286f, -0.02653191f, 0.10251930f, -0.02632085f, -0.01436912f, 
    -0.12066688f, 0.09711083f, 0.09185608f, 0.04689128f, 0.03903534f, -0.00536241f, 0.18740788f, 0.06288889f, 
    0.05843108f, -0.03305190f, -0.04651747f, -0.03606366f, -0.02454210f, 0.02174077f, 0.09632110f, -0.05828920f, 
    -0.01213966f, 0.09158779f, 0.00671166f, -0.05642050f, -0.13483439f, -0.05417775f, 0.01731449f, -0.01276986f, 
    -0.08482242f, -0.12391365f, 0.07771397f, 0.13718916f, -0.02960638f, -0.00920782f, 0.02824093f, 0.04529598f, 
    -0.01760080f, 0.08966887f, -0.04508372f, -0.08338811f, 0.03111718f, -0.14095980f, 0.07424060f, 0.20024030f, 
    -0.03546764f, 0.15672188f, 0.07039252f, 0.00364378f, 0.04285328f, -0.02846858f, -0.01692078f, 0.22372490f, 
    -0.01040817f, 0.20880248f, 0.02826292f, 0.04216281f, -0.02289696f, -0.03989311f, 0.01393433f, 0.06401663f, 
    -0.08277518f, -0.04082235f, 0.07113865f, 0.06099812f, -0.27191243f, -0.14943315f, -0.00143527f, -0.12207319f, 
    0.02907756f, 0.09555414f, 0.04152545f, 0.03875730f, 0.01004709f, 0.12961291f, 0.08644444f, 0.04512770f, 
    -0.03238772f, 0.04644966f, -0.11007512f, -0.05937167f, 0.04268375f, -0.00419014f, 0.01239061f, 0.12567559f, 
    -0.10194373f, 0.05484694f, 0.04835793f, 0.01263292f, 0.02082130f, -0.03633536f, 0.05155485f, 0.14586154f, 
    0.08940694f, 0.05050842f, -0.00154273f, 0.05115392f, -0.00598699f, -0.09653916f, 0.03418910f, -0.08288433f, 
    -0.02374767f, 0.09549683f, 0.02248780f, 0.17975029f, -0.00748747f, -0.07372583f, -0.03601581f, 0.09021501f, 
    0.05623335f, -0.01558039f, 0.05890422f, -0.02858268f, -0.00377833f, 0.13700378f, -0.18233956f, 0.02879893f, 
    -0.01473448f, -0.07067008f, 0.04530699f, -0.02279384f, -0.02864026f, 0.01703215f, -0.07249965f, 0.00035723f, 
    -0.10667743f, -0.14340150f, -0.02011977f, -0.10802814f, 0.02532538f, -0.03923223f, 0.10685597f, -0.03735229f, 
    0.01024783f, 0.19023471f, -0.00899986f, 0.05647673f, -0.05809094f, 0.09680784f, -0.09273746f, 0.09854808f, 
    0.06872065f, 0.07687523f, -0.07156263f, 0.11018182f, 0.16655102f, 0.05282162f, 0.03183675f, -0.07202783f, 
    -0.31932250f, 0.02344752f, -0.20755382f, 0.01698171f, 0.10351413f, -0.04192783f, 0.10858965f, 0.00511924f, 
    0.02849652f, -0.11275647f, 0.03043632f, -0.07432991f, 0.10508354f, 0.12737747f, 0.09016737f, 0.04538059f, 
    -0.02357977f, 0.14187381f, 0.10076568f, 0.02632482f, 0.05426418f, 0.09043704f, 0.12567297f, 0.11210220f, 
    0.19716619f, -0.06289319f, -0.05288406f, 0.08302034f, 0.00319954f, -0.01457187f, 0.06702838f, -0.07845011f, 
    0.02785628f, -0.00179368f, 0.01366117f, 0.06242137f, 0.04630115f, -0.03133303f, -0.05386769f, 0.01487287f, 
    0.09111532f, 0.06719761f, -0.04923590f, 0.03933414f, 0.01168944f, -0.05314985f, -0.04496156f, 0.04293379f, 
    0.06613648f, 0.06669662f, 0.05682770f, -0.00963185f, -0.07096664f, 0.03209944f, 0.00356937f, 0.02698239f, 
    0.09002795f, 0.06216946f, 0.02645394f, 0.11466672f, 0.15256272f, 0.06334542f, -0.08910092f, -0.02652987f, 
    0.04127799f, 0.07180234f, 0.07478211f, 0.03438069f, 0.04221121f, -0.19391215f, 0.09409261f, 0.10748947f, 
    0.01373506f, 0.06252753f, 0.15883006f, 0.10426685f, 0.06087219f, 0.05460965f, 0.09431947f, -0.03430484f, 
    0.07361350f, -0.01356606f, -0.04891682f, -0.02193952f, -0.02184948f, -0.06394657f, -0.19242166f, -0.06130145f, 
    -0.07156532f, -0.04237143f, 0.10407240f, 0.10434406f, -0.13412531f, 0.03905031f, -0.08292240f, 0.03952997f, 
    0.15329424f, 0.01529994f, 0.18074404f, -0.07339456f, 0.01329141f, 0.01005971f, 0.04499545f, 0.00220530f, 
    0.06823840f, -0.03082679f, 0.11286201f, -0.10538034f, -0.19062951f, 0.05702388f, -0.02982545f, -0.01389032f, 
    -0.12256740f, -0.01091167f, 0.05242806f, 0.04514416f, 0.00867810f, 0.04782817f, 0.06409801f, 0.11534292f, 
    -0.02094166f, -0.00925525f, -0.00038459f, -0.05638814f, -0.16192535f, -0.09453899f, 0.03306077f, 0.02369332f, 
    -0.02484947f, 0.01014684f, 0.12727731f, -0.01202709f, -0.10713215f, 0.01898176f, 0.12738380f, 0.07351036f, 
    -0.02202846f, -0.09787297f, -0.01573635f, -0.05194632f, 0.08812180f, 0.01966746f, 0.12590647f, -0.01828061f, 
    -0.10807429f, -0.01170147f, -0.08945837f, -0.04193727f, 0.16197236f, -0.02402686f, -0.03731719f, 0.08487349f, 
    -0.00957924f, -0.01258623f, -0.00609837f, 0.08935893f, 0.01669532f, 0.14139552f, 0.02363579f, -0.01676801f, 
    -0.01644141f, 0.09296590f, -0.04311019f, -0.07591408f, -0.02824879f, -0.04721868f, 0.02926604f, -0.11487795f, 
    -0.17204390f, 0.07085167f, 0.09722814f, -0.00741143f, 0.07291404f, 0.13621488f, 0.12928176f, 0.04521145f, 
    0.04854520f, 0.00980221f, -0.04708568f, 0.12328042f, 0.28633758f, -0.02394713f, 0.12500638f, 0.14676718f, 
    -0.07093012f, 0.10341780f, 0.04053599f, 0.03688283f, -0.01689420f, 0.00943220f, 0.05149996f, 0.11619606f, 
    -0.19441116f, 0.01464397f, -0.16918191f, -0.07931535f, 0.13326181f, 0.02814131f, 0.04878819f, 0.02377608f, 
    0.10634151f, 0.03353098f, 0.09110206f, 0.07903403f, -0.16440871f, -0.06748511f, -0.02708213f, -0.08913305f, 
    -0.02437532f, -0.01547464f, 0.01891120f, 0.07996397f, 0.05112935f, -0.00395088f, 0.00216461f, 0.01088538f, 
    -0.32301563f, -0.02914958f, 0.20017938f, 0.11165635f, 0.07413205f, 0.05298913f, 0.09810919f, 0.17990077f, 
    0.12297492f, 0.10644563f, 0.00235990f, 0.14962004f, 0.02974826f, 0.03263225f, 0.05589889f, 0.17052631f, 
    -0.04399112f, 0.08170724f, 0.07729141f, 0.03508340f, 0.16199237f, 0.10753885f, 0.12796292f, -0.12697949f, 
    0.05592524f, 0.00490466f, -0.07497878f, -0.16904698f, -0.08394377f, -0.05242603f, -0.00465400f, 0.01725782f, 
    0.06794753f, -0.01388429f, 0.00681370f, -0.04341256f, -0.05398481f, -0.01140803f, 0.09230141f, -0.03768596f, 
    -0.01505545f, 0.06647734f, 0.09054656f, -0.02198354f, 0.04214992f, 0.00560099f, -0.06771789f, -0.04119170f, 
    -0.30282176f, -0.07049064f, -0.03391749f, 0.06305020f, 0.04629445f, 0.02104146f, -0.00419435f, -0.06717577f, 
    -0.01719551f, 0.07208570f, -0.07594464f, 0.06375085f, 0.06498274f, -0.02047946f, -0.04679912f, 0.01906011f, 
    -0.01991316f, -0.06914999f, 0.09796637f, 0.01756551f, -0.03330993f, -0.00813229f, 0.02788997f, 0.01860551f, 
    -0.05485987f, 0.07042436f, -0.05382029f, 0.02105418f, -0.01241821f, 0.06472311f, 0.15344162f, 0.08846851f, 
    0.13872860f, 0.14706671f, -0.04991136f, 0.10745122f, 0.02768993f, -0.13365558f, -0.06602420f, 0.00509148f, 
    -0.02311458f, 0.00273895f, -0.03928869f, 0.02628753f, 0.05083873f, 0.15435243f, -0.08334928f, -0.00965426f, 
    0.18714683f, 0.06126294f, 0.11286526f, 0.04041401f, 0.10568906f, 0.01039938f, -0.07367559f, 0.10236688f, 
    -0.05011860f, -0.03588666f, 0.17255294f, 0.09270368f, 0.31195721f, 0.14140524f, 0.15586659f, 0.15203850f, 
    0.04194288f, -0.01327984f, 0.11915517f, -0.05986318f, -0.03756581f, 0.03956216f, 0.14104067f, 0.13050632f, 
    -0.05177441f, 0.03344768f, -0.03646668f, 0.07940586f, 0.03674275f, -0.00414442f, 0.06180494f, -0.10579380f, 
    0.02230480f, 0.02438782f, 0.08083456f, 0.05231164f, -0.27935812f, -0.05303866f, -0.04544784f, -0.07564466f, 
    0.04077177f, 0.08178288f, -0.09450881f, -0.01569696f, 0.02252606f, 0.07546258f, 0.07494351f, 0.00468825f, 
    0.12035594f, 0.09338351f, 0.03406581f, 0.00354958f, -0.03261970f, 0.14907438f, 0.09418304f, 0.05347570f, 
    -0.06244495f, -0.01790726f, -0.00732948f, 0.02073821f, -0.18223506f, 0.10693934f, 0.03592460f, 0.04891481f, 
    0.05860023f, 0.06391437f, 0.05437914f, 0.10668755f, 0.02241269f, 0.03768301f, -0.02859228f, 0.02882280f, 
    0.24703519f, 0.21244532f, 0.09973777f, -0.04042011f, 0.14558275f, 0.12006095f, 0.04051092f, -0.00454535f, 
    0.11236531f, -0.11249168f, 0.05615079f, 0.02392046f, 0.04874606f, 0.15151425f, 0.03859231f, 0.17982420f, 
    0.05163948f, -0.10709865f, -0.00013521f, 0.01415488f, -0.07857339f, -0.06006256f, 0.04848168f, -0.03043805f, 
    -0.03713204f, 0.05069244f, 0.09431013f, -0.24062261f, -0.06428748f, 0.05837032f, 0.01744123f, -0.03123348f, 
    0.06132929f, 0.01669727f, -0.01916589f, -0.08326568f, -0.13329844f, -0.06389493f, 0.05911444f, -0.10309555f, 
    0.13134767f, 0.09314171f, 0.01355526f, -0.03750271f, 0.08408212f, 0.10094447f, -0.07792591f, 0.05107974f, 
    0.29450846f, -0.08699746f, -0.00722504f, 0.31917754f, -0.02276937f, -0.05184700f, -0.06357285f, 0.01440653f, 
    0.06093913f, 0.13122098f, 0.02867743f, 0.03832880f, -0.13856003f, 0.11801002f, -0.13028210f, -0.41065019f, 
    0.07612219f, -0.04272011f, 0.10979678f, 0.00612906f, -0.07391248f, 0.00101410f, 0.05422833f, 0.08386136f, 
    0.34694362f, 0.03075906f, 0.06862175f, -0.10748672f, -0.04109000f, -0.01484533f, 0.05639053f, -0.04190878f, 
    -0.00843825f, 0.07344638f, -0.05851850f, 0.01348683f, -0.23110098f, 0.22711983f, -0.05531755f, -0.14772604f, 
    -0.02608938f, 0.06363344f, 0.03284807f, 0.05136978f, 0.05294653f, 0.12221013f, 0.11970390f, -0.05332723f, 
    0.01881561f, -0.00869374f, 0.05929329f, 0.05349338f, 0.02192671f, 0.04611171f, 0.01498234f, 0.01185363f, 
    -0.06125273f, -0.00679163f, 0.03163473f, -0.04063305f, 0.10061904f, -0.09851112f, 0.00338844f, 0.23459783f, 
    -0.04157138f, -0.08003635f, 0.07485560f, -0.01167359f, 0.09085788f, -0.01030532f, -0.08814546f, -0.02528995f, 
    -0.04709724f, -0.18298367f, -0.06999344f, -0.28107110f, 0.04755213f, -0.06599522f, 0.00665895f, 0.05631110f, 
    -0.05167909f, -0.01670180f, -0.02308272f, 0.14557752f, -0.09056729f, 0.04666076f, -0.03647295f, -0.16673781f, 
    0.09335015f, 0.02335043f, 0.09419122f, -0.01333382f, 0.02241762f, 0.03989691f, -0.02522078f, -0.04316039f, 
    -0.11504760f, 0.15560639f, -0.05059209f, -0.06399281f, 0.10916504f, 0.10532175f, -0.04182557f, 0.04012195f, 
    0.00864813f, -0.01388485f, -0.01963316f, -0.03367421f, -0.34192318f, 0.17062873f, 0.09256534f, 0.17360249f, 
    -0.03902309f, -0.00322867f, -0.02164057f, 0.00365446f, 0.11663833f, -0.02037852f, 0.05433068f, -0.07940748f, 
    -0.04192293f, -0.00172526f, -0.01785031f, 0.24835034f, -0.09370881f, -0.03315658f, -0.02067981f, -0.02114790f, 
    0.00967120f, 0.05965611f, 0.03042483f, 0.04658514f, -0.06567273f, -0.04444735f, -0.04679279f, -0.02120689f, 
    0.10938228f, -0.00576283f, -0.03451483f, -0.05944516f, -0.07813381f, 0.03082036f, -0.06878550f, 0.04496143f, 
    -0.16777249f, 0.14509301f, -0.06812198f, -0.06545701f, 0.09343614f, 0.00633638f, -0.05923827f, -0.04371754f, 
    -0.14969924f, -0.06374627f, -0.02737844f, -0.00455587f, 0.09919484f, -0.02749386f, -0.14053857f, -0.08104894f, 
    0.01922902f, 0.03255693f, -0.00947101f, 0.04860876f, -0.03975540f, 0.00363407f, -0.02907521f, -0.06624536f, 
    0.13188231f, 0.22184119f, 0.00774086f, 0.03414271f, 0.09914327f, 0.01277085f, -0.02780214f, -0.02522612f, 
    0.06624427f, 0.06542235f, 0.03637386f, -0.02991304f, 0.00672220f, 0.09911462f, 0.05224852f, -0.03846594f, 
    0.09565879f, 0.00512667f, 0.00890300f, 0.09784197f, 0.05848373f, -0.05545332f, 0.07667549f, 0.01188515f, 
    -0.01874334f, -0.13258764f, -0.16343693f, -0.04891905f, -0.00440664f, 0.11132926f, -0.10222801f, -0.06293966f, 
    0.00885691f, 0.02436249f, 0.08969343f, -0.02193639f, -0.05099032f, 0.05278380f, -0.15965657f, -0.09676215f, 
    0.11053686f, -0.02461504f, 0.01051971f, 0.01759692f, 0.11483715f, 0.01595353f, -0.03955301f, 0.02741680f, 
    0.30802259f, -0.19569445f, 0.08854598f, -0.26690000f, -0.04786564f, -0.03676774f, -0.02173094f, -0.07087153f, 
    -0.09732682f, 0.00762032f, 0.03598150f, 0.04852694f, -0.03194411f, 0.01076678f, 0.16958828f, -0.14344753f, 
    0.07232707f, -0.05154668f, 0.03883170f, 0.14164294f, 0.00980829f, 0.11639671f, 0.01610711f, -0.06634431f, 
    -0.02079086f, -0.05082597f, 0.11046773f, 0.06506738f, -0.13594234f, 0.00994136f, 0.01134726f, -0.04997997f, 
    0.09063984f, 0.01050192f, -0.04562983f, 0.01866665f, 0.17158070f, 0.16281697f, 0.13834046f, 0.08624662f, 
    0.06620875f, -0.03263061f, 0.06500580f, 0.05401859f, -0.00502543f, -0.03068977f, 0.04672236f, 0.00502841f, 
    -0.02659603f, 0.11061114f, -0.06508237f, 0.08562545f, -0.02877645f, 0.04596273f, 0.00696823f, -0.01183994f, 
    0.19449808f, -0.00099457f, -0.03809744f, 0.03086932f, -0.11810128f, -0.03586804f, 0.04671979f, -0.23976809f, 
    -0.07395419f, -0.01789190f, 0.04926887f, -0.04892617f, -0.04835498f, 0.09359702f, -0.00076122f, 0.05145492f, 
    -0.05614529f, -0.12047829f, 0.04842278f, -0.08082550f, 0.04656551f, 0.00210458f, 0.07219321f, -0.03244334f, 
    -0.03781852f, 0.00573490f, 0.02857230f, 0.05169076f, 0.04038716f, -0.11734559f, 0.15322530f, 0.17550613f, 
    0.03351352f, 0.08144715f, 0.03078374f, 0.20174976f, 0.05403329f, -0.05822315f, 0.06119955f, 0.01673065f, 
    0.20826231f, 0.03332117f, 0.05600481f, 0.05044189f, 0.08166807f, -0.01121838f, -0.04194750f, 0.06353189f, 
    -0.01919704f, -0.07439726f, 0.06081573f, -0.03136740f, 0.06679139f, -0.03331864f, 0.03591321f, -0.03944217f, 
    0.07764798f, 0.07181042f, 0.10891566f, -0.05043723f, -0.13472691f, 0.03341301f, 0.05670891f, 0.01777211f, 
    0.26604679f, 0.00149221f, 0.09518136f, 0.12108517f, -0.11677708f, 0.01795548f, -0.00981151f, 0.13915344f, 
    0.03352180f, 0.03627081f, -0.02625386f, 0.03137208f, 0.10581934f, -0.07662372f, -0.10172923f, 0.00413373f, 
    0.08510609f, -0.14021809f, -0.01119224f, -0.04704522f, -0.06474178f, -0.04890750f, -0.07030048f, -0.08396129f, 
    -0.10828481f, -0.13120092f, -0.07208824f, -0.05264435f, -0.00476791f, -0.02204377f, -0.00474878f, 0.06326603f, 
    0.00263975f, 0.02478338f, -0.01640781f, -0.07188100f, 0.11869939f, 0.09520804f, 0.00119425f, 0.05221222f, 
    -0.07016557f, 0.02157196f, -0.01873638f, -0.04439328f, 0.01361450f, 0.08090585f, 0.08005650f, 0.04513039f, 
    0.04152585f, -0.00165290f, 0.08263905f, 0.32132450f, -0.06341541f, -0.04770004f, -0.05547344f, 0.02148975f, 
    -0.03524685f, -0.07174004f, 0.05314986f, -0.00617046f, -0.16410111f, -0.02416797f, 0.06032971f, 0.14308845f, 
    0.03252377f, -0.04000720f, 0.01201812f, -0.02250753f, -0.02204792f, 0.12646526f, -0.04182673f, 0.04794115f, 
    -0.05426772f, -0.09157147f, -0.15894622f, -0.00831562f, -0.03496266f, -0.05330967f, -0.11749932f, 0.00785374f, 
    -0.09601375f, -0.03364484f, -0.00599305f, 0.04523474f, 0.08749452f, -0.01620707f, 0.20888753f, 0.06131736f, 
    0.07396322f, 0.02236910f, -0.01386849f, 0.13701265f, 0.12072383f, 0.00680935f, 0.13949923f, 0.02664900f, 
    -0.00238975f, 0.15537427f, -0.03047035f, 0.03659344f, -0.03730826f, -0.01887271f, 0.04594589f, -0.01856925f, 
    -0.06563262f, 0.00432064f, -0.04316118f, 0.13753653f, 0.30809832f, 0.03336027f, 0.05445929f, 0.16239858f, 
    0.03006501f, 0.07388044f, -0.05006140f, 0.02631536f, -0.01972623f, 0.00633289f, 0.09318081f, -0.05262889f, 
    0.00900494f, 0.06652554f, 0.08591983f, 0.10846250f, -0.03832719f, 0.01946628f, -0.06420038f, -0.04891754f, 
    0.09924296f, 0.08879737f, -0.11772208f, 0.02765258f, -0.13713939f, 0.17805152f, -0.11211688f, -0.17195252f, 
    0.08180264f, 0.07645067f, -0.02130362f, 0.10840164f, -0.09348403f, -0.17653739f, -0.06702736f, 0.09388850f, 
    -0.07988109f, 0.29612699f, 0.00594797f, 0.01572792f, -0.06682275f, 0.05635601f, -0.01206387f, -0.04179730f, 
    0.00173092f, 0.02899209f, -0.04501072f, 0.02339354f, 0.15804505f, -0.15000829f, 0.02716970f, 0.12278271f, 
    0.02493682f, -0.12224836f, 0.10881161f, 0.05664988f, 0.12952784f, 0.03319432f, -0.03680826f, 0.10287584f, 
    -0.08614004f, 0.12531248f, -0.14914520f, 0.17147501f, -0.01751997f, 0.00305063f, -0.02756660f, -0.00189301f, 
    -0.00334765f, 0.00500577f, 0.12526070f, -0.09655616f, -0.23223065f, 0.07096443f, -0.03890323f, -0.24623689f, 
    0.02504828f, -0.01505779f, 0.07517763f, -0.07060779f, 0.01748869f, 0.02616949f, -0.02331890f, -0.09570534f, 
    -0.00934812f, 0.13020188f, -0.01699484f, 0.15471417f, -0.01696112f, 0.08047663f, 0.01143079f, 0.09085159f, 
    -0.07514160f, 0.02540804f, -0.01263598f, 0.00253700f, 0.19966966f, 0.08924653f, -0.07727626f, 0.05643702f, 
    -0.03144844f, -0.09368800f, -0.09094144f, 0.00663457f, -0.09838422f, 0.01758098f, 0.00164577f, 0.01722021f, 
    0.21508363f, -0.11225715f, -0.06945021f, -0.00726170f, 0.00333106f, -0.02774796f, 0.01321778f, 0.00799758f, 
    -0.05073234f, -0.05045684f, -0.02421090f, -0.13007219f, -0.17521200f, -0.10206682f, -0.01649423f, 0.01670095f, 
    0.01786306f, -0.01965835f, -0.01771447f, -0.02849474f, -0.11394482f, -0.07393661f, -0.09302434f, 0.08238476f, 
    -0.04273421f, 0.07052046f, 0.07727222f, 0.08191469f, 0.08572474f, 0.08282422f, 0.05848333f, 0.07646159f, 
    0.01885596f, -0.02339860f, -0.02004167f, 0.11711027f, 0.02450567f, -0.02344351f, 0.00744861f, -0.05915407f, 
    0.02144907f, -0.02569276f, -0.11595669f, 0.02882092f, 0.05297660f, 0.00226830f, 0.17265250f, -0.02904444f, 
    0.26542303f, 0.05293489f, -0.00528500f, -0.02940303f, -0.03860196f, -0.01952774f, 0.00893999f, 0.06826400f, 
    0.01608930f, 0.01152479f, 0.07134341f, 0.00387783f, 0.01601822f, 0.10431746f, 0.08259851f, 0.14711323f, 
    0.13061330f, 0.09280799f, 0.00509521f, 0.04400403f, 0.10250048f, 0.03102203f, 0.12866163f, 0.02621404f, 
    -0.03669316f, 0.08275282f, 0.04180506f, 0.03980777f, -0.00840554f, -0.02390558f, -0.04703391f, -0.03372237f, 
    -0.14894477f, -0.01359638f, -0.03022486f, -0.06724706f, 0.03552508f, 0.04713288f, 0.16856830f, 0.02994639f, 
    0.11956390f, 0.00056055f, 0.09167513f, 0.08862996f, -0.08561113f, -0.09746046f, 0.12646641f, 0.02822531f, 
    -0.26393643f, 0.02479923f, -0.14762454f, 0.02524541f, -0.01062943f, 0.06908511f, 0.03355481f, 0.01208843f, 
    0.08316177f, 0.06460313f, -0.11763258f, -0.06859753f, -0.02658323f, -0.16032147f, -0.13545068f, -0.11361507f, 
    -0.11344439f, 0.01789222f, -0.07252524f, 0.08484202f, -0.03686401f, -0.02641094f, -0.14038673f, -0.05550751f, 
    0.18123882f, -0.08652958f, -0.05689532f, -0.18052137f, 0.05566045f, -0.02466996f, -0.00492056f, 0.11232898f, 
    0.05221944f, 0.02612263f, 0.01888041f, -0.00138512f, 0.25973326f, -0.05334172f, -0.04176528f, 0.07480019f, 
    0.07399805f, -0.03216297f, 0.09856415f, 0.06391376f, 0.01718741f, 0.04674223f, -0.01296033f, -0.00716460f, 
    -0.00927280f, -0.10964105f, -0.09434732f, 0.07105783f, 0.02075250f, -0.04541504f, -0.02904367f, -0.06786454f, 
    0.05650355f, -0.01028592f, -0.04233999f, 0.05514339f, 0.13171828f, -0.14370964f, -0.10547061f, 0.08052848f, 
    0.06235871f, 0.02307951f, -0.00524594f, 0.05815168f, -0.00695948f, -0.00904569f, 0.02834662f, -0.03017047f, 
    0.19616877f, -0.12980436f, -0.08948080f, 0.33929324f, -0.08625069f, 0.04289233f, -0.12362587f, 0.01301850f, 
    -0.01053267f, 0.04677342f, -0.02077102f, 0.00367815f, -0.06414278f, -0.00163388f, 0.00667605f, -0.14411384f, 
    0.06183605f, 0.12149046f, 0.05051367f, 0.10695887f, 0.02413177f, 0.05327987f, 0.07228544f, 0.04830296f, 
    -0.06831088f, 0.12425903f, -0.05517802f, 0.01294458f, 0.06998809f, -0.09484827f, -0.09664866f, 0.02328118f, 
    0.03012000f, 0.05683475f, 0.02706658f, 0.03711191f, -0.17637685f, -0.00584909f, -0.09287661f, -0.21568857f, 
    0.12422684f, 0.05407080f, 0.07742206f, 0.03102555f, 0.01981455f, 0.06640537f, 0.03270562f, 0.09798100f, 
    -0.13089621f, 0.03777587f, -0.09254469f, -0.04009857f, 0.07502691f, -0.08089932f, -0.00414177f, -0.02735044f, 
    0.00062117f, 0.07339459f, 0.04325954f, 0.01463927f, -0.26956323f, 0.19134863f, 0.16302377f, -0.02672525f, 
    -0.04321102f, -0.02791471f, 0.06976523f, 0.06451046f, 0.06456278f, 0.00821200f, -0.01253881f, 0.01460637f, 
    -0.00268205f, 0.11413455f, 0.04305691f, 0.19973645f, -0.00877132f, 0.12712371f, 0.14081445f, 0.08905741f, 
    -0.02519230f, 0.09385704f, 0.09527522f, 0.01689837f, 0.18530165f, -0.00045669f, -0.05600991f, -0.24320865f, 
    0.10709094f, -0.03096590f, 0.02538633f, 0.01841776f, 0.01015142f, 0.08267350f, 0.02010436f, 0.01338159f, 
    0.03236160f, 0.18401329f, -0.03288038f, 0.01520279f, 0.06793317f, -0.04420711f, -0.06157307f, 0.00123706f, 
    -0.04499354f, 0.05406317f, 0.02859432f, 0.05585411f, -0.43907991f, -0.10407925f, 0.05393164f, -0.01616114f, 
    0.18655393f, 0.05256845f, -0.07227441f, -0.03034789f, -0.00356811f, 0.04335218f, 0.02889824f, -0.03565582f, 
    -0.21924901f, -0.19028197f, -0.00652110f, 0.14080121f, 0.06776156f, 0.03792601f, 0.09964970f, -0.00908682f, 
    -0.04272752f, 0.09006058f, 0.02622619f, 0.08626422f, -0.16783035f, -0.09605365f, -0.06246275f, 0.01139906f, 
    0.04584228f, -0.01023327f, 0.06361259f, 0.05249422f, 0.14543103f, -0.01070581f, 0.00122850f, 0.05112310f, 
    0.32709426f, -0.03451119f, -0.01442430f, 0.05843700f, -0.06949520f, -0.07656518f, 0.01144448f, 0.00129082f, 
    0.03027586f, 0.07469822f, -0.04913749f, -0.10856180f, -0.03673029f, 0.21937735f, 0.02474354f, -0.13784063f, 
    0.05132926f, -0.02331223f, -0.07182947f, 0.05205356f, 0.04104426f, 0.09307111f, 0.08891059f, 0.03992244f, 
    -0.41767603f, -0.06761424f, 0.04416127f, -0.05905231f, 0.14170390f, 0.10021440f, 0.02492538f, -0.07033370f, 
    0.03562156f, 0.07839156f, -0.02459176f, -0.10189672f, 0.06486780f, 0.28245091f, -0.10075045f, -0.05050291f, 
    0.10327774f, 0.02800141f, 0.05433018f, -0.02354451f, 0.01470199f, 0.15497424f, -0.07294296f, -0.02268457f, 
    -0.22740209f, 0.08153579f, 0.00672174f, 0.04140773f, 0.04807858f, 0.09150545f, -0.00404987f, 0.01501469f, 
    0.04312541f, 0.10425398f, -0.00274938f, 0.05979086f, 0.18335384f, 0.10035457f, -0.07873610f, 0.08153348f, 
    -0.01645191f, 0.06707259f, -0.08079422f, -0.00268920f, 0.08709428f, 0.01619413f, 0.05665728f, 0.01780274f, 
    -0.05575953f, 0.01407198f, -0.07314818f, 0.10701945f, -0.04614184f, 0.03685464f, -0.02703789f, 0.15000162f, 
    0.01853142f, -0.00372543f, 0.02391316f, 0.00235696f, -0.13092223f, -0.04924898f, 0.06087774f, 0.02830882f, 
    -0.00131598f, 0.01119720f, -0.05757726f, 0.10527653f, -0.01831488f, 0.01854865f, 0.08357547f, 0.13317518f, 
    -0.09496397f, 0.01989535f, 0.03833957f, 0.06933067f, 0.04379706f, 0.02043761f, -0.04019215f, 0.02591394f, 
    -0.08671714f, -0.00868051f, 0.04604855f, -0.01217244f, 0.07650633f, -0.00650471f, -0.06972288f, 0.02738793f, 
    -0.01895979f, -0.05976532f, -0.00048014f, -0.01195977f, 0.02970328f, -0.00342457f, 0.04578252f, 0.00371096f, 
    -0.15348026f, 0.27445248f, 0.12338074f, 0.07175345f, 0.03773309f, 0.04242115f, 0.01868805f, 0.09637565f, 
    0.13622460f, -0.13323493f, 0.03569565f, 0.04725011f, -0.26198703f, 0.08355015f, 0.02102125f, 0.01370181f, 
    0.04049523f, -0.07758822f, 0.00383544f, 0.08046143f, -0.01006562f, 0.01269921f, 0.02183042f, -0.16096348f, 
    0.05020370f, 0.07726521f, -0.11204121f, -0.10104834f, 0.18047914f, 0.09833533f, 0.05510883f, -0.04644180f, 
    0.16354539f, -0.00465121f, 0.10363987f, 0.07476594f, 0.21909806f, -0.11810399f, 0.12494452f, 0.26871052f, 
    -0.07690735f, 0.10350378f, 0.00168476f, 0.05651176f, -0.09717733f, -0.08646960f, -0.01897388f, -0.04533505f, 
    0.00002156f, -0.24169873f, -0.02520648f, 0.07820695f, -0.02602196f, -0.00458244f, 0.00371596f, -0.04420932f, 
    -0.03332015f, 0.08582546f, 0.08671650f, 0.04106292f, 0.14629965f, 0.11496099f, -0.10128888f, -0.09715936f, 
    0.01454049f, 0.05036991f, 0.02512249f, 0.05775465f, 0.02033609f, 0.04646356f, 0.01127052f, -0.02085303f, 
    0.34466401f, -0.02689530f, -0.08212402f, -0.02782921f, 0.00736766f, 0.06912080f, 0.04721438f, 0.07589348f, 
    -0.00115419f, 0.04596215f, 0.05271157f, 0.04909043f, 0.16608357f, -0.02274980f, 0.08185448f, -0.01480433f, 
    0.10034486f, 0.05745077f, -0.06461990f, 0.00105806f, 0.01183171f, 0.05003855f, 0.05431498f, 0.08952998f, 
    -0.16862983f, 0.09695008f, 0.30125821f, 0.21209419f, -0.08005964f, -0.01078337f, 0.03516104f, 0.12235563f, 
    -0.06115425f, -0.05831958f, 0.02172950f, 0.08154232f, 0.04083854f, -0.11515120f, -0.14779378f, 0.13667610f, 
    -0.03307693f, -0.02874441f, 0.12746626f, 0.02638317f, 0.04656603f, -0.02780515f, -0.05611861f, 0.06033444f, 
    0.56440681f, -0.21451384f, 0.01681579f, 0.03320171f, -0.17997314f, 0.03617430f, -0.05015163f, 0.08162139f, 
    -0.05186202f, 0.07609058f, -0.00692334f, -0.03035337f, -0.21805763f, 0.01453954f, 0.11533604f, 0.00734755f, 
    0.01945999f, 0.09308497f, 0.11800039f, 0.14746116f, 0.01161834f, 0.10192574f, -0.09250184f, 0.07593343f, 
    -0.15453887f, -0.04509090f, -0.01905941f, 0.02540638f, -0.07063130f, -0.03219949f, -0.01073914f, 0.13176535f, 
    -0.00494437f, 0.01705420f, -0.01263462f, -0.09755433f, -0.07904097f, 0.15691444f, -0.05328659f, -0.01627006f, 
    -0.00457969f, -0.01172276f, 0.00440728f, 0.02928355f, 0.07634860f, -0.06580584f, 0.09724050f, -0.02143103f, 
    -0.26191810f, 0.04758021f, -0.01556172f, -0.02727098f, 0.16028069f, 0.05857268f, -0.08214623f, -0.03065808f, 
    -0.04666469f, 0.01423001f, -0.00543564f, -0.00092503f, -0.10248191f, 0.06508014f, 0.00985292f, -0.04873645f, 
    0.02451056f, -0.01831537f, 0.02282475f, -0.00552621f, 0.01146688f, 0.08021190f, -0.06644033f, -0.02715234f, 
    0.04090947f, -0.04129064f, 0.02726997f, 0.11068588f, 0.03779784f, -0.00625189f, 0.06175825f, 0.07191391f, 
    0.09186751f, 0.18994774f, 0.02461379f, -0.01089238f, 0.20798703f, -0.06543953f, 0.09017279f, 0.01950100f, 
    -0.00924841f, 0.00564072f, -0.01088165f, 0.02694348f, -0.00423816f, 0.03234255f, 0.04084081f, 0.03989864f, 
    -0.31675136f, -0.12212340f, -0.08306561f, 0.05590222f, 0.15986262f, -0.01668277f, -0.07415985f, -0.00095704f, 
    -0.02775781f, -0.00603793f, -0.04170306f, 0.10232656f, 0.01919033f, -0.00265821f, -0.13248207f, -0.02802443f, 
    0.11201797f, -0.00774495f, -0.01770798f, -0.06866091f, 0.06114283f, 0.02583006f, 0.03985078f, -0.01573543f, 
    0.04342277f, 0.19350943f, -0.08628262f, -0.08363415f, 0.20127037f, 0.05895075f, 0.01820327f, -0.04183892f, 
    0.06263816f, 0.05889310f, -0.05660349f, -0.00395074f, 0.36179820f, 0.22698006f, -0.26629132f, -0.17394404f, 
    0.08932089f, -0.02962748f, -0.03664199f, -0.05123343f, 0.13990243f, 0.20490421f, 0.07174830f, 0.01140971f, 
    0.50424421f, -0.01211517f, -0.16548958f, -0.09113968f, -0.10073252f, -0.11517452f, 0.03033587f, -0.04585684f, 
    0.04177003f, 0.01244561f, -0.02490190f, 0.03988452f, -0.35873458f, -0.04573318f, 0.02491986f, 0.05249343f, 
    0.07459830f, 0.01072261f, -0.01990512f, -0.06377110f, 0.03082237f, 0.04359654f, -0.00934107f, -0.00660257f, 
    0.27146915f, -0.12558007f, -0.10567217f, 0.06004689f, -0.01522500f, 0.01032801f, -0.04943420f, -0.03342579f, 
    -0.03259618f, 0.10224715f, -0.05388885f, 0.04496088f, 0.21324794f, 0.00817381f, -0.19159761f, -0.31790864f, 
    0.06442582f, 0.01813194f, -0.04718490f, 0.07719626f, 0.01091509f, 0.11536402f, 0.17360067f, 0.00298918f, 
    0.49768052f, -0.12536912f, 0.16659097f, 0.03739705f, -0.19633210f, -0.03807377f, -0.00857695f, 0.04596356f, 
    0.03848592f, 0.00819751f, -0.04790091f, 0.01329731f, 0.17462045f, -0.01050693f, -0.03360685f, 0.06707578f, 
    0.11489763f, -0.00103128f, -0.07139049f, -0.02337124f, 0.04572015f, 0.03375030f, 0.09224517f, 0.10163200f, 
    0.31763202f, 0.11609384f, 0.04139490f, 0.01389786f, -0.02085804f, 0.03237441f, -0.08261585f, -0.08672158f, 
    -0.04528573f, -0.03153947f, -0.01465933f, -0.14948486f, -0.27120650f, -0.01630289f, 0.13228092f, -0.09701752f, 
    0.06242732f, 0.09720802f, 0.00678681f, 0.02893896f, -0.12937939f, -0.01557876f, 0.06373740f, 0.11527415f, 
    0.05824386f, 0.00163376f, 0.03012436f, -0.03987360f, -0.01144950f, 0.06387710f, 0.11970939f, 0.08657432f, 
    -0.01235895f, 0.00082617f, 0.02871214f, 0.04043853f, -0.03974132f, -0.00572660f, -0.05570867f, 0.06679034f, 
    0.02254928f, 0.01572420f, -0.02558154f, 0.09520357f, -0.08767722f, 0.02870720f, 0.05469081f, 0.05174224f, 
    0.06931080f, 0.13296452f, -0.02072063f, -0.01593499f, 0.11585864f, 0.00226716f, 0.00385677f, -0.01436660f, 
    0.07291197f, 0.00260094f, 0.04004706f, 0.03209661f, -0.28106913f, -0.11915711f, 0.06460520f, -0.04589685f, 
    0.02902055f, 0.08058363f, 0.02715819f, 0.06087045f, -0.15373516f, 0.03820875f, 0.08677376f, 0.08894093f, 
    0.26157475f, 0.20866780f, -0.12814020f, -0.18835835f, 0.00027545f, -0.01448833f, -0.05840434f, 0.02629593f, 
    -0.01447253f, -0.06401469f, 0.14030708f, 0.06813402f, 0.02439293f, 0.01209503f, -0.00761242f, -0.11769059f, 
    0.00182297f, -0.04026918f, -0.00486506f, 0.08251783f, -0.07286794f, -0.08505078f, 0.12440594f, 0.04567888f, 
    0.22636245f, 0.02120303f, -0.12960473f, -0.01468880f, 0.10176806f, -0.03560923f, 0.07499027f, -0.01481508f, 
    -0.00448477f, 0.13474998f, 0.01570528f, -0.02558712f, -0.23815499f, -0.28122213f, 0.01727374f, -0.06142814f, 
    0.16318786f, 0.04025421f, 0.11262122f, -0.03690157f, 0.10669514f, 0.06749184f, -0.06059621f, 0.00410640f, 
    0.12855574f, 0.12958404f, -0.02396496f, 0.06555051f, 0.01264868f, 0.02738053f, -0.01781578f, 0.07612319f, 
    -0.05675267f, -0.03657156f, -0.06784632f, -0.01007616f, -0.05751850f, -0.07774339f, 0.20631284f, 0.08200123f, 
    0.04219555f, -0.08940950f, -0.02113983f, 0.10417496f, 0.11719987f, 0.03104394f, -0.01814641f, 0.03595620f, 
    -0.06529459f, -0.06505007f, 0.00219458f, -0.02583318f, 0.15994194f, -0.05758478f, -0.03539829f, -0.01374542f, 
    0.05901550f, 0.00834345f, -0.01556669f, 0.02629951f, 0.17358541f, -0.11104386f, 0.08290283f, 0.12031424f, 
    -0.10135374f, -0.00190682f, -0.04757972f, 0.02924728f, 0.03077300f, -0.02831825f, 0.05282182f, 0.03932470f, 
    -0.23928781f, -0.08717727f, -0.04890446f, -0.12801090f, 0.01010763f, -0.03463848f, 0.07362314f, 0.02138998f, 
    0.02768517f, 0.07518674f, 0.11820339f, 0.07205400f, 0.04763282f, -0.15537743f, -0.19887382f, 0.00491274f, 
    -0.04823266f, 0.04620230f, 0.07203995f, 0.00884496f, -0.06792328f, -0.02632575f, -0.11486749f, -0.01490819f, 
    0.02451670f, -0.04201484f, -0.01848346f, -0.03144052f, 0.02792002f, -0.00685374f, -0.01102497f, 0.00180826f, 
    0.01926675f, -0.00282021f, -0.02402350f, 0.01017075f, 0.01016107f, 0.03106878f, 0.02806076f, -0.00317922f, 
    -0.00666337f, -0.03999479f, 0.01346714f, 0.01840271f, -0.02543581f, 0.00121697f, -0.02595540f, 0.02292323f, 
    0.00209624f, -0.02224650f, -0.00947430f, -0.04074005f, -0.00205940f, -0.00207097f, -0.00767034f, -0.01911089f, 
    -0.04153465f, 0.01826478f, 0.01004619f, -0.01845351f, -0.00021602f, 0.01372381f, -0.03575531f, 0.01860802f, 
    -0.03492902f, -0.03478231f, 0.00068506f, -0.01581443f, 0.00057450f, 0.00081844f, -0.02094167f, -0.01235878f, 
    -0.01772717f, 0.01342284f, -0.01798370f, -0.00560061f, -0.01251802f, -0.02985537f, 0.01794226f, -0.03143655f, 
    0.00888222f, 0.00009531f, -0.03493499f, -0.00713378f, 0.00511678f, 0.00360750f, -0.02482382f, 0.01400642f, 
    -0.00137787f, -0.00293194f, -0.02771675f, -0.02689238f, -0.02262614f, -0.01289474f, 0.00606851f, -0.00752804f, 
    -0.01502921f, 0.02269554f, -0.02522046f, -0.04000822f, -0.00145189f, -0.02151334f, -0.02395409f, -0.00883272f, 
    -0.03025386f, -0.01794519f, 0.00356073f, 0.02476385f, -0.01666246f, 0.01121381f, -0.02420592f, -0.00258623f, 
    -0.03017654f, -0.01060067f, -0.00064997f, 0.01956629f, 0.01281985f, -0.02508289f, 0.01042058f, -0.02854184f, 
    0.02427403f, 0.03137157f, -0.03219076f, -0.02733522f, 0.01523328f, 0.01927517f, 0.01612609f, 0.01455355f, 
    0.02294441f, -0.01775420f, -0.01832348f, -0.00862005f, -0.03785175f, -0.03285190f, 0.02272334f, 0.01323448f, 
    -0.00723109f, 0.00913412f, 0.01986993f, -0.00798137f, -0.02723481f, -0.03093983f, -0.02525974f, 0.01138799f, 
    0.01239697f, -0.00879687f, 0.00791979f, -0.00869705f, 0.01464452f, 0.00381465f, -0.03752907f, 0.01944432f, 
    0.02325387f, -0.03580437f, 0.01345378f, -0.01999264f, -0.01190556f, 0.01768186f, 0.01950680f, 0.02064450f, 
    -0.03115978f, 0.02366889f, -0.01488441f, -0.04341340f, 0.01004684f, -0.00008780f, -0.01435415f, 0.00028223f, 
    0.00200974f, 0.02093155f, -0.04234355f, -0.04367107f, -0.04358390f, -0.02975638f, -0.02662911f, 0.00944992f, 
    -0.03850231f, -0.03740527f, 0.00861246f, -0.03726482f, 0.00305176f, -0.00936739f, -0.04272075f, 0.01111552f, 
    -0.04088532f, 0.02662617f, -0.01187891f, 0.00283369f, -0.04227372f, 0.00580580f, 0.01716158f, 0.02563799f, 
    -0.00128189f, -0.02273321f, -0.00411116f, 0.02183273f, 0.02130539f, 0.01431309f, 0.01142360f, -0.01825038f, 
    -0.00845611f, -0.02700334f, 0.00570491f, -0.02607258f, -0.00448450f, -0.01380609f, -0.02288927f, -0.01236170f, 
    -0.02716278f, 0.02891743f, -0.03038387f, 0.00259813f, -0.00105221f, -0.02429283f, 0.00494850f, 0.03262411f, 
    -0.00678976f, 0.02181359f, 0.01297094f, 0.00179190f, -0.01669388f, -0.01765965f, -0.00336909f, 0.01934944f, 
    -0.01807967f, 0.01141070f, 0.00305901f, -0.01045228f, -0.02823911f, 0.00569055f, 0.00141772f, 0.01017630f, 
    0.00304850f, 0.02031771f, 0.00766125f, 0.02476584f, -0.03557085f, -0.04306904f, -0.01437400f, -0.03852422f, 
    -0.02116573f, -0.01303584f, 0.02026537f, -0.03405760f, 0.00517321f, 0.01239744f, -0.01033526f, -0.01877720f, 
    -0.01630379f, 0.00985564f, -0.02026119f, 0.02125825f, -0.01123751f, 0.01925633f, -0.03145426f, 0.00400067f, 
    -0.03438959f, 0.00197345f, -0.00846737f, 0.00010640f, 0.00108613f, -0.03050190f, -0.00132530f, 0.02074719f, 
    -0.00712183f, 0.01775335f, -0.02760758f, -0.01294964f, -0.01950947f, 0.02701392f, 0.00370006f, 0.02713978f, 
    -0.02039843f, -0.00331774f, -0.02097238f, 0.01635381f, -0.00676696f, -0.03596265f, 0.01936030f, 0.01135226f, 
    -0.00626588f, -0.01216347f, -0.02150858f, -0.02677342f, -0.02049444f, 0.00399631f, -0.00053399f, 0.01749706f, 
    0.01022150f, -0.02883769f, 0.01666066f, -0.03472780f, 0.00304856f, -0.03709109f, 0.02295587f, 0.02059372f, 
    -0.02842903f, -0.00664415f, -0.00728742f, 0.00537291f, -0.02582165f, 0.00435313f, 0.02775624f, -0.02163992f, 
    -0.02207910f, 0.00329100f, -0.01630996f, 0.01634485f, -0.02465007f, 0.01937170f, -0.01186506f, -0.03515521f, 
    -0.02068609f, 0.02562274f, 0.00637167f, -0.01750093f, -0.03111847f, -0.02068903f, 0.03191845f, -0.03955254f, 
    -0.01060807f, -0.01690930f, -0.00283404f, 0.02238131f, -0.01082624f, 0.00889250f, -0.02560532f, -0.02553622f, 
    0.01309988f, -0.03575980f, -0.00314975f, -0.03198569f, -0.01116599f, 0.01118289f, -0.00155065f, 0.01403826f, 
    0.01587331f, -0.01620990f, 0.01160403f, -0.02175128f, -0.03495222f, -0.00366294f, 0.02686546f, 0.02436978f, 
    -0.03610388f, 0.00785208f, -0.00863795f, -0.03758806f, 0.01977128f, -0.02943438f, 0.02717778f, -0.01480568f, 
    0.02458178f, -0.00649365f, 0.02618473f, 0.02006585f, -0.00898867f, -0.02168579f, 0.02735689f, -0.01497804f, 
    -0.02450548f, 0.02595568f, -0.04295850f, 0.01992621f, -0.01080193f, 0.02730377f, 0.02373107f, 0.01299627f, 
    0.00810322f, -0.04043157f, -0.03218758f, -0.03589361f, -0.00986341f, 0.01048698f, -0.01827969f, -0.01733560f, 
    -0.02610854f, 0.00687436f, -0.01565216f, -0.00815186f, -0.00835965f, 0.01771374f, -0.01374091f, -0.02290550f, 
    -0.02593058f, 0.01774067f, -0.01315958f, -0.03739304f, -0.03729150f, -0.03545693f, 0.01583011f, -0.03619954f, 
    -0.02273784f, 0.00905757f, 0.02632944f, -0.04327263f, 0.00054018f, 0.02635140f, -0.02806988f, 0.02590312f, 
    0.02633843f, -0.01079878f, 0.00255909f, -0.00141683f, -0.03106388f, 0.00766067f, -0.00716160f, 0.00430119f, 
    0.00096352f, 0.01995334f, -0.01182562f, -0.04033753f, -0.04256048f, 0.00344452f, -0.01254173f, -0.02462805f, 
    0.00447547f, 0.00057448f, -0.03188240f, 0.02696651f, -0.00141965f, 0.02751824f, -0.02980025f, 0.00538945f, 
    -0.00123948f, 0.00679371f, -0.00011155f, 0.01980835f, 0.00455234f, 0.00215600f, 0.00122726f, 0.01787024f, 
    -0.02408901f, 0.00153972f, -0.00609789f, 0.02030972f, 0.00578232f, 0.01867669f, -0.03440092f, -0.02491758f, 
    0.02017458f, -0.04358420f, -0.03464086f, -0.01917774f, -0.02872885f, -0.03285445f, -0.03312272f, -0.01066631f, 
    -0.02193594f, 0.00733078f, -0.01987617f, -0.01202871f, -0.00884234f, 0.02753551f, -0.03710146f, -0.02448432f, 
    -0.00785265f, -0.00392919f, -0.01800011f, -0.01664728f, -0.01733563f, 0.01442718f, -0.00575059f, -0.00176887f, 
    -0.00080452f, 0.00735288f, -0.00654445f, -0.02818453f, -0.03636073f, -0.00867677f, -0.01683908f, -0.02689167f, 
    -0.00911254f, -0.03429327f, 0.01993251f, -0.03890434f, 0.01753373f, 0.01299880f, -0.01352318f, -0.00064910f, 
    -0.03704398f, -0.03841576f, -0.03843848f, 0.02526680f, -0.02720247f, 0.02052025f, -0.01960914f, -0.01807863f, 
    -0.01657472f, -0.01802062f, 0.00079606f, -0.01109481f, -0.04109716f, -0.02997380f, 0.00414538f, -0.03397285f, 
    -0.01350325f, 0.00204037f, -0.02020846f, 0.02011382f, 0.02869609f, 0.02046387f, 0.01689551f, -0.01455935f, 
    -0.01316074f, -0.00899409f, 0.00350525f, 0.02777273f, 0.01683595f, -0.01409492f, -0.01196516f, 0.01725038f, 
    -0.02459629f, 0.00684154f, -0.00946859f, -0.02811262f, 0.02319971f, -0.01584906f, 0.01688440f, -0.01998784f, 
    0.01212021f, -0.04060314f, 0.01848453f, -0.00836904f, -0.01866750f, -0.02506033f, 0.02425122f, 0.02576710f, 
    -0.00337058f, -0.02471607f, 0.01909636f, -0.00830714f, 0.01530116f, -0.00411894f, 0.02455694f, -0.02624454f, 
    -0.01184610f, 0.02618970f, -0.02387584f, 0.01106235f, -0.02351067f, -0.02595992f, -0.02369661f, 0.00872196f, 
    -0.01098626f, 0.00909058f, -0.02933133f, -0.03056897f, 0.02082239f, -0.01591349f, 0.01523908f, -0.03822399f, 
    -0.03666421f, 0.02774691f, 0.02226440f, -0.03121184f, -0.00174536f, -0.02695804f, 0.02488185f, -0.03610341f, 
    -0.01183970f, -0.04153537f, 0.00267378f, 0.01861711f, 0.00817773f, 0.00517748f, -0.01186150f, -0.02769973f, 
    -0.02644630f, -0.02739163f, -0.02869147f, 0.00193995f, -0.00992653f, 0.00992281f, -0.02628107f, 0.02146933f, 
    0.02509914f, 0.02791642f, -0.03563486f, -0.02798956f, -0.00199026f, 0.01030772f, -0.02132165f, -0.01132505f, 
    0.00006892f, 0.01682912f, 0.00192808f, -0.00223655f, 0.01389593f, -0.02552670f, 0.02562562f, 0.02141571f, 
    -0.01654819f, -0.03867706f, -0.03627922f, -0.03493736f, 0.02317481f, 0.02833258f, 0.02790472f, 0.01852472f, 
    0.01991034f, 0.00721142f, 0.01289866f, 0.00201099f, -0.00666744f, -0.02915328f, 0.01000611f, -0.02168199f, 
    -0.00357870f, -0.01920997f, -0.01204312f, 0.03240234f, -0.01469276f, -0.01040853f, -0.03575921f, 0.01036030f, 
    0.02660445f, -0.04021802f, 0.02849161f, -0.00275942f, 0.02067686f, -0.02056841f, 0.03133321f, -0.01039447f, 
    -0.01580418f, -0.02210008f, 0.00064465f, -0.02038206f, -0.03023777f, -0.03942432f, -0.04101333f, 0.00943530f, 
    -0.01826151f, -0.02148835f, 0.00248482f, 0.01693691f, 0.01326616f, 0.00584865f, -0.01150427f, 0.01466434f, 
    -0.02666485f, 0.00707345f, -0.02912134f, -0.03380696f, 0.01121987f, -0.03378503f, 0.00161896f, 0.01513579f, 
    0.02623631f, 0.02332656f, 0.01063008f, 0.01285040f, -0.02120150f, -0.01307898f, -0.02239777f, 0.01323555f, 
    0.00610008f, 0.03985025f, -0.02518820f, 0.02783516f, -0.01370417f, -0.00821906f, 0.00952358f, -0.04241874f, 
    -0.03131998f, 0.00818834f, -0.00109344f, 0.02209295f, -0.03275926f, 0.00287077f, -0.01407328f, 0.00747898f, 
    0.00880966f, 0.01318813f, 0.03452915f, -0.00461383f, -0.03888765f, -0.00812751f, 0.01895269f, -0.03294873f, 
    0.02126725f, -0.02806911f, -0.01258442f, 0.02350596f, 0.01494263f, -0.01229158f, 0.02309136f, 0.00170062f, 
    -0.00534971f, -0.03291089f, -0.01974930f, -0.01605194f, 0.00429113f, -0.04215690f, 0.02981060f, -0.02037510f, 
    0.02768119f, -0.02253266f, 0.02287554f, -0.03476044f, -0.00994040f, -0.00140292f, -0.00688786f, 0.00865489f, 
    -0.01322404f, 0.01537242f, -0.00742231f, -0.02321385f, -0.01418207f, -0.02180095f, -0.02281744f, -0.03645482f, 
    -0.02134783f, -0.01622355f, 0.01797295f, -0.03562853f, -0.02610010f, -0.01043625f, 0.00348179f, -0.01622882f, 
    0.00221212f, 0.01180164f, 0.00557729f, 0.00670076f, -0.02229607f, -0.00163435f, -0.02810164f, -0.04198925f, 
    -0.03064328f, -0.04124730f, 0.00051834f, -0.01348588f, -0.01501614f, -0.02864374f, -0.03194319f, -0.00057215f, 
    -0.02502021f, -0.02707450f, 0.00261990f, 0.00779894f, -0.01352620f, -0.02445367f, 0.01696656f, -0.03533344f, 
    -0.00893056f, -0.03950369f, -0.01672611f, -0.03062782f, 0.00440055f, 0.01366370f, -0.02026968f, 0.01809382f, 
    0.01755778f, 0.01859867f, -0.03123205f, -0.02185312f, 0.01410893f, -0.00159496f, 0.00646426f, -0.00971437f, 
    -0.00674118f, 0.00999846f, -0.01084941f, -0.01395091f, -0.03714321f, -0.01977790f, -0.01096170f, -0.01307316f, 
    -0.03093604f, -0.02692706f, 0.01007447f, 0.02853130f, 0.01860849f, 0.00797030f, 0.02718727f, -0.00772535f, 
    0.02294979f, 0.01516795f, -0.03132370f, 0.02792223f, 0.01168540f, 0.01022663f, -0.01714046f, -0.02971006f, 
    -0.01871903f, -0.01482669f, -0.03938336f, -0.00261257f, -0.01604830f, -0.00887793f, 0.01403756f, -0.01620196f, 
    0.05954562f, 0.11762221f, -0.16088726f, -0.03850803f, 0.04644420f, -0.02438396f, -0.02922781f, -0.06941339f, 
    0.00212463f, 0.03137818f, 0.14353266f, 0.04179511f, -0.09282592f, -0.02175155f, -0.05005438f, -0.06465915f, 
    0.08816992f, 0.03640420f, 0.04318028f, -0.00637811f, 0.02572145f, 0.06956045f, 0.04744440f, 0.11020596f, 
    0.09570587f, 0.09667945f, 0.10914490f, -0.04882507f, 0.03816701f, 0.04035064f, -0.05007493f, 0.07487013f, 
    0.03838069f, 0.01958363f, -0.07119740f, 0.02125366f, 0.03757199f, 0.19085851f, -0.13380109f, 0.23883773f, 
    0.09374190f, 0.03983292f, 0.01355736f, 0.02827685f, 0.15582916f, -0.02232668f, 0.14773215f, 0.02351717f, 
    0.07047758f, 0.18169895f, 0.07160521f, 0.24560671f, 0.05299735f, 0.10963237f, 0.01242409f, -0.02283588f, 
    0.09151123f, -0.02067529f, 0.01608144f, 0.13163906f, 0.10735825f, -0.02476073f, -0.27031603f, 0.06331943f, 
    -0.03318003f, 0.02329116f, 0.01652579f, 0.08024636f, 0.15249395f, 0.01224346f, 0.09372725f, -0.03711413f, 
    0.11241346f, 0.01873948f, 0.15067837f, -0.09206618f, -0.02244519f, 0.10162291f, 0.00423109f, 0.16925390f, 
    0.00670393f, 0.00001536f, -0.02084925f, 0.09836729f, -0.05803894f, 0.16397902f, 0.30701074f, 0.05888944f, 
    0.06280790f, -0.04314873f, 0.03584746f, 0.11311930f, -0.04845317f, 0.11335858f, 0.09901187f, 0.09447469f, 
    0.01722662f, 0.10551216f, -0.08128274f, 0.30392998f, 0.08560190f, 0.02066666f, 0.05143669f, 0.10658321f, 
    0.12833133f, -0.05537798f, 0.00818474f, 0.04178950f, -0.07142954f, -0.09420527f, -0.05947997f, -0.20475519f, 
    0.01147610f, -0.02562563f, 0.08157652f, -0.03096177f, 0.05686759f, -0.01895074f, 0.00034242f, 0.06646311f, 
    -0.04029107f, 0.02162779f, 0.01885704f, 0.12806123f, 0.04042158f, -0.09012735f, 0.12246853f, -0.04348389f, 
    0.01050925f, -0.07106805f, -0.03063126f, -0.02821518f, -0.02535478f, 0.13579747f, 0.17597157f, -0.16841891f, 
    0.13193956f, 0.03486346f, -0.11120347f, 0.07473916f, 0.03261917f, 0.00869038f, 0.11337629f, 0.06178851f, 
    -0.03995466f, 0.12258327f, 0.15465485f, -0.03138218f, 0.11873633f, -0.01527851f, 0.00147062f, -0.02238304f, 
    0.03606586f, 0.10616361f, 0.14430936f, 0.04155608f, -0.02625407f, 0.06684276f, -0.03918571f, -0.10822759f, 
    0.10868944f, -0.00651916f, 0.09019870f, 0.05972746f, -0.08724798f, 0.16231875f, 0.04679752f, 0.11510850f, 
    0.11627785f, -0.06143484f, 0.17369200f, -0.17124559f, 0.22406562f, -0.03799919f, 0.03282763f, -0.01181521f, 
    -0.00326537f, 0.08588686f, 0.04969082f, 0.07441516f, -0.02887388f, 0.09326242f, -0.01255165f, -0.06975143f, 
    -0.05061324f, 0.09419048f, -0.00555854f, 0.20638558f, 0.12263047f, 0.09469560f, -0.06432973f, 0.01329028f, 
    -0.13791077f, -0.04624078f, 0.10746238f, 0.23870227f, 0.02926309f, 0.03757773f, 0.02612492f, 0.06483091f, 
    -0.02193146f, 0.11523254f, 0.01562056f, 0.11870977f, -0.05154953f, 0.09082976f, 0.05487832f, 0.22320509f, 
    -0.04177848f, -0.06026698f, -0.02478242f, -0.06321026f, 0.08285418f, -0.00758091f, 0.10298953f, -0.08947413f, 
    0.15607348f, -0.13884705f, 0.10399830f, -0.17206354f, 0.00071525f, 0.05285389f, -0.04879928f, -0.13075797f, 
    0.02682056f, 0.02924081f, 0.00809281f, -0.08013743f, -0.11479858f, -0.06175256f, -0.13924432f, 0.23210400f, 
    0.01648377f, -0.04817378f, 0.04858924f, 0.02799220f, -0.00537774f, 0.02509687f, -0.05159504f, -0.03853392f, 
    0.08140511f, 0.24638201f, -0.09476456f, 0.12326980f, 0.16045070f, 0.00537338f, 0.02039931f, 0.04090818f, 
    0.15821922f, -0.04660187f, 0.10209117f, -0.03318055f, 0.09005619f, 0.16953199f, -0.11253607f, 0.11355329f, 
    0.08555652f, -0.02491369f, 0.01981428f, -0.03057753f, 0.08248992f, 0.04811009f, 0.02104466f, -0.10515429f, 
    0.25622931f, 0.05153416f, 0.17119548f, -0.05543162f, 0.06014589f, 0.06082604f, 0.03071863f, 0.05781528f, 
    0.07649442f, -0.00478577f, 0.09967086f, 0.14904575f, 0.01896486f, 0.14662100f, 0.00715549f, 0.27768081f, 
    -0.05430765f, 0.01506326f, 0.02939246f, -0.03008979f, 0.05661147f, 0.00829223f, 0.09089343f, 0.04523677f, 
    0.01143738f, -0.11889199f, -0.06591798f, -0.01294306f, -0.09144691f, 0.06552238f, 0.08767087f, -0.13205366f, 
    0.02966436f, 0.03577083f, -0.02155764f, -0.06727889f, 0.10621194f, 0.04689739f, -0.15658350f, 0.10530220f, 
    0.05502412f, 0.04763659f, 0.02498107f, 0.01062946f, -0.00303588f, 0.09631130f, 0.02693455f, 0.04693698f, 
    -0.06755444f, 0.08638504f, -0.11016316f, -0.19404086f, 0.04877325f, 0.03565382f, 0.12927848f, 0.01212126f, 
    -0.02572663f, 0.10620423f, -0.00512978f, 0.20022257f, 0.03501089f, 0.09596696f, 0.09765414f, -0.22841962f, 
    0.01587931f, 0.04567431f, 0.00055029f, 0.06297670f, -0.04598587f, 0.03778409f, 0.00929534f, 0.09645878f, 
    -0.14601536f, 0.02035926f, 0.11968861f, 0.19729432f, 0.00282718f, -0.03753626f, -0.03245649f, -0.02741397f, 
    0.04297605f, 0.01127592f, 0.15114282f, -0.03050624f, 0.12097604f, 0.04549329f, -0.00154988f, -0.08780570f, 
    -0.09374437f, -0.01239784f, 0.03073869f, 0.12565519f, 0.01312430f, 0.06928308f, -0.11840646f, 0.10862311f, 
    0.10936029f, 0.04167997f, 0.14079538f, 0.08702266f, -0.00868014f, 0.12388700f, 0.00794544f, 0.02438209f, 
    0.05438930f, 0.07866988f, 0.08843912f, -0.00681753f, -0.01980332f, -0.13029645f, 0.11223428f, -0.07053062f, 
    0.07241651f, 0.08654827f, 0.00747304f, -0.06683215f, 0.04581597f, -0.01791621f, -0.04904123f, 0.01513664f, 
    -0.08409752f, 0.03671571f, 0.03654268f, 0.02190577f, -0.05593952f, 0.11284158f, -0.05101766f, 0.13686800f, 
    0.08993710f, -0.04817694f, 0.08490974f, 0.02631542f, -0.00224558f, -0.02608230f, 0.05946975f, -0.03846478f, 
    0.03527136f, -0.00488759f, 0.15822390f, -0.07481802f, 0.13227141f, -0.00850378f, 0.14189640f, 0.11043815f, 
    0.17241685f, 0.13976309f, 0.04046085f, -0.08205931f, 0.10801490f, 0.00560159f, 0.01366563f, 0.07426170f, 
    0.00158447f, -0.04278139f, 0.11205036f, 0.09677139f, -0.09343527f, 0.02186147f, 0.09119616f, 0.04271884f, 
    0.05811890f, 0.04436047f, 0.01216850f, -0.01556934f, 0.10396412f, 0.10362815f, 0.00852144f, 0.04374967f, 
    -0.12404419f, 0.05007095f, 0.12460324f, -0.00206057f, 0.09845206f, -0.00045281f, -0.06383415f, 0.07973570f, 
    0.05295066f, 0.03173951f, 0.06967128f, 0.12624454f, -0.02650013f, 0.09708993f, 0.10676778f, 0.10105662f, 
    -0.05640288f, 0.03397959f, -0.02401276f, -0.06460549f, 0.10736843f, 0.07157665f, 0.11720997f, -0.11641497f, 
    0.15295893f, 0.04800982f, -0.03380272f, 0.28310919f, 0.19046153f, 0.05074054f, 0.02874796f, -0.04907782f, 
    0.03187153f, 0.08878192f, -0.06528115f, 0.07918548f, 0.22608608f, 0.18128595f, 0.07359502f, 0.02741497f, 
    0.14068405f, 0.10301666f, -0.05165284f, 0.05500600f, 0.06185011f, -0.00460094f, 0.09301857f, -0.01026846f, 
    0.21292908f, 0.18767639f, 0.07518525f, 0.12746839f, 0.09401761f, 0.01812971f, -0.00139620f, 0.15059124f, 
    0.02002888f, 0.05050122f, -0.05977033f, 0.14897634f, 0.20506479f, -0.07714964f, -0.01561643f, 0.08794428f, 
    0.07881848f, -0.00069120f, -0.09854273f, 0.02610515f, 0.06164807f, 0.12641604f, 0.05800722f, -0.08591983f, 
    0.07098119f, -0.05682045f, 0.10553770f, 0.03363742f, -0.03640110f, 0.09858044f, -0.00257946f, 0.01199120f, 
    0.02641132f, 0.19012164f, 0.02341388f, -0.02638231f, 0.11824601f, 0.18078187f, 0.11345955f, 0.08167083f, 
    0.10287046f, -0.01701477f, 0.08362164f, 0.10508355f, 0.05198174f, 0.01979925f, 0.08392569f, 0.05955763f, 
    0.24128725f, -0.11251458f, 0.06723136f, -0.12337011f, -0.01701752f, -0.02952220f, -0.12618785f, 0.04120559f, 
    0.02767073f, 0.09935389f, 0.03393952f, -0.07959359f, -0.07158136f, -0.07847387f, -0.22856928f, 0.09408469f, 
    0.09064033f, -0.04313677f, 0.00562045f, 0.01973910f, 0.06623390f, 0.16766453f, 0.09929593f, 0.05087015f, 
    0.03792200f, -0.04443292f, 0.11145326f, 0.11950348f, -0.05439495f, 0.00468529f, 0.02775887f, 0.02393492f, 
    0.10721587f, 0.03414716f, 0.03616584f, 0.05301231f, 0.23439874f, 0.15433177f, 0.11472738f, 0.12325723f, 
    0.09023695f, -0.06889603f, 0.03901309f, 0.05994366f, -0.09050755f, 0.05277750f, 0.06389381f, -0.14410736f, 
    0.10792345f, 0.18828259f, -0.12351021f, -0.11868064f, -0.01020303f, 0.03830777f, 0.03154059f, -0.02470883f, 
    -0.06632140f, -0.02823970f, 0.05721002f, 0.07160207f, 0.06265233f, -0.09842324f, -0.12484518f, -0.17500046f, 
    0.05895707f, 0.00451003f, 0.02516513f, 0.06898908f, -0.10326090f, 0.06474750f, -0.16270846f, 0.08214167f, 
    0.00845789f, 0.12488060f, 0.03371247f, 0.11316350f, 0.00872326f, 0.01624664f, -0.02069225f, -0.02376189f, 
    -0.00162831f, 0.10494630f, 0.02173514f, -0.08538835f, -0.05125988f, 0.03441049f, -0.04821233f, 0.15719062f, 
    0.03499787f, 0.00733385f, 0.11794709f, 0.06916605f, 0.01264381f, 0.09128159f, 0.03646523f, 0.03623024f, 
    0.22426358f, 0.03183226f, 0.06764491f, 0.08040658f, 0.13717726f, 0.00640746f, 0.07628645f, 0.17577891f, 
    0.07901330f, -0.03246212f, 0.07436258f, 0.14678860f, -0.14941531f, 0.00846826f, 0.08688781f, 0.01818506f, 
    -0.08346134f, 0.06693126f, 0.00998530f, -0.00205731f, 0.02041970f, 0.05803015f, 0.00397765f, -0.03200853f, 
    0.25963503f, 0.11670723f, 0.03515705f, 0.06602312f, 0.05720123f, -0.04380675f, -0.07800283f, 0.05850141f, 
    -0.00354344f, 0.01968801f, 0.14171410f, 0.08181071f, -0.04954235f, 0.05747876f, -0.08063701f, 0.15763463f, 
    0.01924867f, -0.04098517f, 0.05438850f, -0.14629230f, -0.03334636f, -0.10714007f, 0.15497434f, 0.13708344f, 
    -0.21247783f, -0.07514545f, 0.07872963f, -0.25179595f, 0.06188581f, -0.01261493f, 0.02353624f, 0.06905294f, 
    0.15403222f, 0.04168115f, 0.06235698f, 0.01130610f, -0.15834232f, 0.09643027f, -0.01389327f, 0.02240443f, 
    0.07284784f, 0.04189935f, 0.06320043f, -0.02738013f, 0.13301887f, -0.00263657f, 0.05652916f, 0.00016197f, 
    0.14089952f, -0.02555128f, -0.01059454f, -0.01266423f, -0.00138500f, 0.03846269f, 0.05905144f, 0.03394977f, 
    0.03804333f, 0.08501873f, -0.10988825f, 0.05491404f, -0.09672693f, -0.12685475f, 0.15722880f, 0.20197031f, 
    0.05051139f, -0.01773101f, 0.05161945f, 0.03008746f, 0.07071183f, -0.02426026f, 0.06715097f, 0.02739533f, 
    -0.02420366f, 0.14911464f, 0.02484336f, -0.03170577f, 0.07958581f, -0.00618696f, 0.01900272f, 0.12444106f, 
    0.06811148f, 0.03845286f, 0.04252584f, -0.00014060f, 0.11166364f, 0.03383368f, -0.08290780f, -0.06982550f, 
    -0.02686016f, 0.07049610f, -0.00534736f, 0.01021845f, 0.05331030f, 0.03524696f, -0.07408632f, 0.11696365f, 
    -0.19417101f, 0.22683056f, 0.06714328f, -0.21727979f, 0.07975540f, 0.00134329f, 0.01484075f, -0.08613008f, 
    0.00653715f, 0.16272281f, -0.13658689f, 0.06476986f, 0.05741743f, -0.03994530f, -0.03180820f, -0.13140997f, 
    -0.05028894f, 0.09673394f, -0.03364216f, -0.01018615f, -0.04690061f, 0.03369703f, -0.02451110f, 0.05946904f, 
    -0.00774010f, 0.02347896f, 0.00523618f, -0.03354064f, 0.03400394f, -0.01857761f, -0.01018369f, 0.01673469f, 
    -0.03866607f, -0.03381029f, 0.03384683f, 0.01137334f, -0.03844706f, -0.01148431f, -0.03060138f, -0.00427199f, 
    -0.01641387f, 0.00790413f, -0.01741606f, 0.02416850f, -0.04125784f, -0.00598849f, -0.03377729f, -0.01731707f, 
    -0.01230402f, 0.02259268f, 0.03159090f, 0.03263579f, 0.02441461f, 0.02812254f, -0.00879929f, -0.02583424f, 
    0.00784063f, 0.00191036f, -0.03580711f, 0.02992800f, -0.03846661f, 0.01712483f, 0.02351184f, -0.03659369f, 
    -0.03543714f, 0.01196859f, -0.03557387f, -0.00380016f, 0.00466918f, 0.00658242f, -0.02121799f, -0.03457050f, 
    0.00316174f, 0.02480854f, -0.00210230f, -0.00479624f, -0.02058104f, -0.02876129f, -0.02093625f, -0.01701054f, 
    0.02410292f, -0.04040927f, 0.01161394f, 0.03456973f, 0.01491625f, -0.02879078f, -0.01894876f, -0.00685045f, 
    -0.01165039f, 0.01918308f, -0.01616562f, 0.01814632f, -0.00076777f, -0.02056433f, 0.00624800f, 0.01512225f, 
    -0.02509256f, -0.00846499f, -0.00713740f, -0.01151667f, 0.00983615f, 0.01509224f, 0.00225596f, 0.02221547f, 
    -0.03054105f, -0.00323105f, -0.02140911f, -0.03655402f, 0.02132718f, -0.02247315f, 0.01418281f, -0.02773047f, 
    -0.01380393f, -0.01305386f, 0.01058332f, -0.00229825f, 0.01938781f, -0.00689460f, 0.01233181f, -0.01379225f, 
    0.01086454f, -0.01336225f, 0.00898365f, 0.00624174f, 0.00765790f, 0.00951978f, 0.02081567f, -0.01945976f, 
    -0.00003290f, 0.00932900f, 0.00852880f, 0.00115149f, -0.01334018f, -0.01622538f, -0.03701356f, 0.01868095f, 
    -0.02898710f, -0.03407419f, 0.02567534f, -0.03275054f, -0.01450701f, -0.00344224f, -0.01379592f, 0.02186376f, 
    0.00188125f, 0.02328328f, -0.02738151f, 0.01758461f, -0.01673328f, -0.00043974f, -0.03046415f, -0.01587580f, 
    0.00106252f, -0.03259163f, -0.03352360f, 0.00577478f, -0.00873357f, 0.02655496f, -0.02792694f, 0.02003567f, 
    -0.00510554f, 0.02738630f, 0.01999410f, -0.02727051f, 0.01797703f, -0.00033574f, -0.03300481f, -0.03001949f, 
    -0.00874182f, 0.01449677f, -0.03281913f, -0.03626730f, -0.03549330f, -0.03134095f, -0.02313874f, 0.02370777f, 
    0.01958204f, -0.01846812f, 0.00859867f, 0.00158648f, -0.00780224f, -0.00749334f, -0.02160052f, 0.00285309f, 
    0.01015897f, -0.04099513f, 0.02343280f, -0.02537018f, -0.03497517f, 0.00225430f, -0.03022644f, 0.00480455f, 
    0.00046186f, 0.02982038f, 0.03134524f, -0.02485441f, -0.01357338f, -0.02213826f, -0.00516217f, 0.00572614f, 
    0.01466234f, -0.02885763f, 0.00220999f, 0.01917227f, -0.02757438f, 0.00588270f, -0.01643120f, -0.01203086f, 
    -0.00522894f, 0.02320297f, -0.03381865f, -0.02799955f, 0.00849999f, 0.02828394f, -0.01899793f, -0.03390193f, 
    -0.00516176f, -0.01509024f, -0.00410019f, -0.01128884f, 0.01359053f, 0.02189426f, 0.00444949f, 0.01087941f, 
    -0.00784802f, 0.02468709f, 0.01650043f, -0.01256480f, 0.01552753f, 0.03206193f, 0.02919577f, -0.02752176f, 
    0.01925137f, -0.01041463f, 0.00836919f, -0.03034403f, -0.01016529f, -0.01182484f, 0.00140187f, -0.00102779f, 
    -0.01546005f, 0.02072063f, 0.03086443f, -0.00964140f, -0.00411198f, -0.02537461f, -0.01624886f, 0.01598447f, 
    -0.00882784f, -0.03709821f, -0.02650255f, 0.01921083f, -0.00758623f, 0.00590223f, 0.01519182f, -0.00384968f, 
    -0.03060148f, 0.01106959f, 0.02403754f, -0.03616327f, 0.01860567f, -0.01842328f, -0.00818746f, -0.01877386f, 
    -0.01989332f, -0.01851153f, 0.01288075f, 0.01226282f, -0.00606486f, 0.00943548f, 0.02179336f, 0.02537213f, 
    -0.00954744f, -0.00135733f, 0.02644016f, 0.01762247f, 0.03047090f, -0.02246854f, -0.03685171f, -0.03657813f, 
    -0.01927357f, 0.00016694f, 0.03060126f, -0.01991922f, 0.01916499f, -0.02033970f, -0.04062241f, -0.03596377f, 
    -0.02379063f, 0.01472443f, 0.02472661f, 0.02753173f, -0.03635076f, 0.00528375f, 0.02324882f, 0.03091316f, 
    -0.01915851f, -0.00794049f, -0.01283546f, -0.01838197f, 0.00839451f, 0.02916860f, 0.00808658f, -0.01894756f, 
    -0.01182389f, -0.02127126f, 0.02456671f, 0.01121982f, 0.02922148f, 0.00441411f, -0.03059934f, 0.00752805f, 
    0.02730256f, -0.03666412f, -0.03827551f, -0.02220819f, 0.01657241f, 0.01055585f, 0.03104429f, -0.04016506f, 
    0.00763957f, 0.01715997f, -0.02832676f, -0.01417802f, -0.00339129f, 0.02114333f, 0.02003320f, -0.01620559f, 
    -0.00090385f, 0.00416776f, -0.03406509f, -0.02903507f, 0.02837314f, 0.01819662f, 0.02902505f, -0.01945145f, 
    0.02021694f, 0.02849853f, -0.00130965f, -0.01344481f, -0.00188101f, 0.02260861f, 0.00331959f, -0.03542479f, 
    0.02252482f, -0.03616454f, -0.00294714f, 0.01846946f, 0.00690554f, -0.02562966f, -0.03242955f, 0.00995894f, 
    -0.04040501f, -0.00845233f, 0.01205404f, 0.01714039f, 0.02982255f, -0.03102810f, -0.03859460f, 0.00281278f, 
    -0.03943286f, 0.01006651f, -0.01947901f, -0.00175437f, 0.01111086f, -0.03700352f, -0.01811343f, -0.02798676f, 
    -0.01981774f, 0.01183907f, -0.00124244f, -0.03873961f, 0.02573046f, -0.01324004f, -0.01195842f, -0.03423062f, 
    -0.00596283f, -0.01743782f, 0.01389787f, -0.02568121f, -0.01409137f, -0.00904740f, -0.02231197f, -0.00820434f, 
    -0.00815106f, -0.00844671f, -0.01139798f, -0.00238637f, 0.00688694f, 0.03237034f, -0.00871489f, 0.03214084f, 
    0.02178570f, 0.00231829f, 0.01919330f, -0.03441811f, -0.02268534f, -0.00760337f, -0.02516982f, -0.01753118f, 
    -0.01972669f, -0.03574090f, -0.03689566f, 0.00544086f, -0.01801759f, -0.02675078f, 0.01392636f, -0.02262215f, 
    -0.03297009f, 0.00312187f, 0.00879379f, -0.02840363f, 0.02561166f, -0.02503059f, -0.01160903f, -0.01387122f, 
    -0.01002381f, 0.02954860f, -0.01504892f, 0.01523151f, 0.00047806f, -0.02548852f, 0.00333253f, -0.01455498f, 
    0.01022918f, -0.01773480f, -0.00688746f, -0.03757607f, 0.00302767f, 0.01147437f, -0.02189087f, -0.00125024f, 
    -0.02936674f, 0.00946094f, -0.03377942f, -0.01212484f, -0.01623627f, 0.01294325f, -0.01897189f, 0.01103711f, 
    0.00669727f, -0.02812366f, 0.00377281f, 0.01759676f, -0.02158841f, 0.00580193f, -0.01828772f, -0.01223147f, 
    -0.00466439f, 0.00053951f, 0.00294035f, 0.02364038f, -0.00048174f, -0.01882434f, -0.01359057f, 0.02053645f, 
    0.01515213f, -0.00211417f, 0.02156833f, -0.00171878f, -0.03814274f, 0.00462960f, 0.01071601f, -0.03090239f, 
    -0.01459737f, 0.00163074f, 0.01329566f, 0.01682541f, -0.03028326f, -0.00478340f, 0.00848318f, 0.03118299f, 
    -0.01060830f, -0.03078691f, 0.03218523f, -0.02658550f, -0.02659681f, 0.01781110f, 0.02359934f, 0.00897902f, 
    -0.00075682f, -0.00044403f, -0.03067321f, -0.00292344f, 0.01547296f, 0.01062231f, -0.02941199f, 0.01943103f, 
    -0.01929910f, -0.01681009f, 0.02060274f, -0.03353585f, -0.02588254f, -0.00302999f, -0.03266372f, -0.04186828f, 
    0.01096242f, 0.01707402f, -0.00040357f, 0.01108280f, 0.02194566f, 0.01217809f, 0.01902797f, 0.02435335f, 
    -0.03492676f, -0.01079724f, -0.02109710f, -0.03999592f, -0.03954101f, -0.02138567f, -0.03100410f, -0.01068765f, 
    -0.02756292f, 0.00477783f, 0.01067075f, 0.02017486f, 0.03124838f, 0.00516770f, 0.00753740f, -0.00707356f, 
    0.02880637f, 0.00707400f, -0.03446657f, 0.03115139f, -0.02127827f, -0.00202345f, -0.02945487f, 0.01127142f, 
    -0.02187046f, 0.02993977f, -0.00624868f, 0.01452697f, -0.01593478f, 0.02450565f, 0.00011171f, -0.01510522f, 
    0.00716909f, -0.00186269f, -0.00201558f, -0.01841048f, 0.00613594f, 0.00618474f, 0.00084213f, -0.02689255f, 
    0.01893738f, -0.00454673f, -0.02809687f, 0.00174095f, -0.00631274f, -0.01161628f, -0.01769739f, -0.00197162f, 
    -0.00194742f, -0.02420399f, 0.01084805f, 0.01782520f, 0.00920923f, -0.03586667f, -0.03036956f, -0.00825690f, 
    -0.00500198f, -0.01632941f, 0.02402326f, -0.01243055f, -0.00439921f, 0.01449007f, 0.00304129f, 0.00905898f, 
    -0.02421347f, 0.01452955f, -0.00113687f, -0.03725959f, -0.01887015f, 0.01028872f, -0.03843211f, -0.03310204f, 
    -0.02862333f, -0.01568519f, -0.04034998f, 0.00603319f, 0.02132340f, -0.00356766f, 0.01573822f, -0.01016336f, 
    0.01783740f, 0.01065160f, -0.01498282f, 0.00028378f, -0.01041752f, -0.02964325f, -0.00283154f, -0.02532977f, 
    -0.03820636f, -0.01538613f, 0.00705586f, -0.02359865f, -0.02311183f, -0.03593065f, 0.00148684f, 0.00528202f, 
    0.02466533f, 0.03047414f, -0.02285398f, -0.00762179f, -0.01238951f, 0.01452594f, -0.00338798f, 0.03030322f, 
    0.00933939f, -0.01780525f, 0.02997014f, -0.01054126f, -0.01451102f, 0.02585523f, -0.02568260f, 0.00952786f, 
    -0.02837149f, 0.00880984f, 0.00122855f, 0.02402125f, -0.03867110f, -0.03889234f, -0.02709736f, -0.01821071f, 
    -0.01912260f, -0.02066369f, -0.01447936f, -0.01007022f, -0.00099974f, -0.00877019f, -0.00927636f, 0.01780855f, 
    -0.02001279f, -0.01334631f, 0.01735581f, -0.03879589f, 0.02794940f, 0.02801301f, -0.00344272f, 0.00204949f, 
    -0.04069171f, -0.01999571f, -0.01958649f, -0.02094311f, 0.01848027f, -0.02850164f, 0.01716948f, -0.01053706f, 
    0.01174915f, -0.01916365f, -0.00075834f, 0.02969939f, 0.02157885f, -0.03307908f, 0.00694139f, 0.01427530f, 
    -0.02737660f, 0.00360465f, -0.02597894f, -0.00734192f, -0.02538350f, 0.01289201f, -0.02474518f, -0.01617185f, 
    0.01342286f, 0.01381041f, -0.03376243f, 0.02157119f, 0.01739539f, 0.01481956f, 0.01435891f, 0.00405466f, 
    0.00967026f, 0.01303871f, -0.03366892f, -0.00263224f, 0.03028196f, -0.02409469f, -0.02995379f, 0.00024682f, 
    -0.00861071f, 0.01418012f, -0.01170809f, -0.03894262f, -0.01416575f, -0.00181405f, 0.01983746f, 0.03015023f, 
    -0.03766901f, -0.02027962f, -0.03122213f, -0.04158748f, 0.02778021f, 0.02154279f, 0.01342789f, 0.03370976f, 
    0.03020464f, 0.01264832f, 0.02993000f, 0.00872001f, -0.00611596f, -0.02250220f, -0.00734529f, -0.02074961f, 
    0.00811558f, -0.02001895f, 0.03088643f, 0.00495229f, -0.01289947f, 0.00556810f, -0.02240830f, -0.02389837f, 
    -0.02050981f, 0.03354079f, -0.00788698f, -0.01288710f, 0.01749983f, 0.02963899f, 0.02295262f, -0.00145485f, 
    -0.03475744f, 0.00514392f, -0.03578319f, -0.03021196f, 0.01442796f, 0.01536127f, 0.01471450f, 0.02181180f, 
    -0.00022962f, 0.02813368f, 0.02222341f, -0.01209039f, -0.01007820f, -0.03917962f, 0.02869055f, 0.02745998f, 
    0.00152545f, -0.00943904f, -0.01589565f, 0.00548392f, 0.01998157f, 0.01939624f, -0.02923396f, 0.00776182f, 
    -0.00087444f, 0.01266467f, 0.00636137f, 0.02530911f, 0.00223405f, 0.00993699f, 0.02808789f, 0.02949340f, 
    0.02080417f, 0.01766774f, -0.01250960f, -0.02245287f, -0.02606225f, -0.02684228f, 0.01395316f, -0.03327880f, 
    0.02649206f, -0.00236964f, -0.00406043f, 0.02857097f, 0.00267985f, 0.02252020f, -0.03957235f, 0.01282676f, 
    -0.01583367f, 0.00713354f, 0.00246482f, 0.02500859f, -0.01411543f, -0.03717106f, -0.03644637f, -0.04104048f, 
    0.01726017f, -0.03180704f, -0.02437084f, 0.02304457f, -0.01182809f, 0.02948982f, -0.02055106f, 0.02673677f, 
    -0.01605287f, -0.01150162f, 0.00333840f, -0.00969963f, -0.01615735f, 0.00134744f, -0.03666677f, -0.00733543f, 
    -0.13550328f, -0.11788491f, 0.06203088f, 0.00861152f, 0.07410812f, 0.14642128f, 0.11907827f, 0.02591198f, 
    -0.02454531f, -0.00841793f, 0.00413992f, 0.01881433f, 0.00797492f, -0.01181547f, 0.17632835f, 0.21982177f, 
    -0.04514422f, 0.04108131f, 0.04088615f, -0.01476053f, 0.01671778f, -0.01402183f, 0.09084326f, 0.03265647f, 
    0.26857626f, 0.24277861f, 0.10699799f, -0.10629243f, 0.03991267f, 0.00183497f, 0.03459781f, 0.00332690f, 
    -0.00174216f, -0.04854922f, 0.02193333f, -0.02102445f, 0.08485652f, -0.29729095f, -0.12862720f, 0.15966959f, 
    0.05460886f, 0.09843802f, 0.02727895f, 0.05331274f, -0.00058365f, -0.04340501f, 0.10925934f, 0.02590630f, 
    -0.05982617f, -0.03702309f, 0.12045684f, -0.02955728f, 0.09328507f, 0.02543516f, -0.11421704f, -0.00862709f, 
    0.11875954f, -0.05309886f, 0.03788468f, -0.04224110f, -0.12647951f, -0.12258635f, 0.23821561f, 0.24004629f, 
    0.03188634f, -0.01556638f, 0.00827614f, 0.02674934f, 0.11029162f, -0.00294979f, 0.05448958f, 0.02467033f, 
    -0.08799162f, 0.12079884f, -0.09125345f, -0.11319977f, 0.13165529f, 0.12548092f, 0.08219963f, 0.19709741f, 
    0.03605677f, -0.01894583f, 0.01611476f, -0.04689649f, 0.34494951f, 0.10869844f, 0.15692532f, 0.12652671f, 
    -0.05861278f, -0.03326977f, -0.01659106f, -0.05958591f, 0.01521770f, 0.05829389f, 0.01863357f, 0.12854032f, 
    0.18016769f, -0.12475171f, 0.08663283f, 0.11843909f, -0.15440208f, -0.04452879f, 0.04608091f, -0.02743501f, 
    0.08022910f, -0.13143526f, 0.00726856f, -0.09200438f, 0.15647809f, 0.00863117f, 0.10129420f, 0.10130795f, 
    -0.05956455f, 0.01401606f, 0.09835298f, 0.11834659f, -0.00960699f, 0.06339125f, 0.06522509f, 0.15066111f, 
    -0.35670093f, -0.10438546f, -0.04261716f, -0.06428780f, 0.03481298f, -0.03491719f, 0.12872417f, 0.06223998f, 
    -0.03573297f, -0.06220618f, 0.04798155f, 0.15081035f, 0.17851736f, 0.04895770f, -0.00379195f, -0.10813560f, 
    -0.00008127f, 0.00360168f, 0.07856534f, -0.01361977f, 0.04503359f, -0.06987690f, -0.00548409f, 0.03382681f, 
    0.05495835f, 0.12211468f, 0.31657410f, 0.20026134f, -0.12122178f, -0.05823488f, 0.00318576f, 0.02384150f, 
    0.00374954f, -0.11357766f, 0.07440043f, 0.12662509f, -0.17401645f, -0.01077747f, 0.23325753f, 0.03977297f, 
    -0.01037299f, 0.01706338f, -0.06184698f, -0.02208586f, 0.00794941f, -0.01973532f, 0.15617883f, 0.11473367f, 
    0.10532951f, -0.05353759f, 0.10248550f, 0.11516169f, -0.01644294f, 0.02095824f, 0.01766104f, -0.02070948f, 
    0.10356067f, 0.02249780f, -0.02773515f, -0.12064190f, 0.09184724f, 0.13356072f, -0.12386948f, -0.26994842f, 
    0.00816764f, 0.00573802f, 0.02972460f, 0.10161828f, -0.04086992f, 0.06411345f, -0.07445950f, 0.05099739f, 
    0.00057514f, 0.00192867f, 0.10431292f, -0.00966410f, 0.08667158f, -0.00150520f, 0.01119686f, 0.08714624f, 
    0.02347362f, 0.11819949f, 0.01508808f, 0.00566614f, 0.17576364f, -0.05830629f, -0.01963303f, 0.07856669f, 
    0.12260372f, 0.06657475f, 0.04062803f, -0.02430161f, 0.04544950f, 0.03786297f, 0.04194544f, 0.04097134f, 
    -0.02354243f, -0.06370486f, 0.07327953f, -0.03952677f, 0.07594255f, 0.00398967f, 0.05807569f, 0.06240803f, 
    0.10597710f, -0.03347661f, 0.09712582f, -0.02690761f, -0.28162912f, -0.05925105f, -0.07983606f, -0.11783486f, 
    -0.00595024f, 0.09601459f, 0.06540814f, 0.02895634f, -0.03333303f, -0.04161875f, -0.06859551f, -0.04323835f, 
    -0.09221266f, -0.12484855f, 0.05444061f, 0.10723110f, 0.01249779f, 0.04005214f, 0.02959122f, 0.00314076f, 
    -0.03046617f, 0.04785217f, -0.06090688f, 0.00427943f, -0.06582629f, -0.06579641f, 0.02440505f, 0.23049897f, 
    0.00440894f, 0.14404643f, 0.10561206f, 0.08974788f, 0.06623142f, -0.00589748f, -0.01352364f, 0.12131408f, 
    -0.09215993f, 0.29102057f, 0.14970382f, 0.05176077f, -0.06877626f, 0.02097373f, 0.01961388f, 0.11964393f, 
    -0.03242103f, 0.02176841f, -0.01980801f, 0.11201123f, -0.25824028f, -0.09447411f, 0.08876415f, 0.08413278f, 
    0.07673973f, 0.07970504f, 0.03656729f, 0.01030408f, 0.04557211f, 0.08358460f, 0.04892984f, 0.00721797f, 
    -0.16742603f, 0.15142356f, -0.07793119f, 0.00159972f, 0.09392779f, 0.03667324f, -0.03498690f, 0.09658600f, 
    -0.02434747f, 0.00279866f, 0.00022776f, 0.03041541f, -0.18333824f, -0.07979524f, 0.05449152f, 0.07404210f, 
    0.07246929f, 0.06657369f, 0.00418562f, 0.01684143f, -0.07292983f, 0.01540290f, 0.03309927f, 0.04904690f, 
    -0.16026306f, 0.00499497f, -0.00844519f, 0.15965594f, -0.04409836f, -0.07018674f, 0.04464672f, 0.03758506f, 
    -0.04170226f, -0.00189166f, -0.05325058f, 0.02705012f, 0.00304095f, 0.00562544f, -0.05792101f, 0.08309406f, 
    0.04317496f, 0.00622930f, 0.07756325f, 0.15189327f, 0.00585484f, -0.00011799f, -0.00829536f, -0.05908661f, 
    -0.16256957f, -0.21248405f, -0.05554705f, 0.01990703f, 0.08917014f, 0.05121383f, 0.04979529f, -0.07021854f, 
    0.05833764f, 0.08656865f, 0.07634633f, 0.01108705f, -0.07229736f, 0.09659276f, -0.03672621f, -0.05300636f, 
    0.09182868f, 0.03187050f, -0.04831788f, 0.11136355f, 0.05428642f, 0.05391711f, 0.03174351f, 0.02364807f, 
    -0.47341555f, -0.07653657f, -0.13720231f, 0.10810200f, 0.15186615f, 0.01679830f, 0.07004649f, 0.00005318f, 
    -0.01406359f, -0.11072058f, 0.02198468f, 0.00002481f, 0.12973797f, -0.18820743f, 0.12933527f, 0.09896284f, 
    -0.05781879f, 0.09024202f, 0.04995109f, -0.02174851f, -0.02601151f, 0.05902195f, 0.16679880f, 0.00221088f, 
    0.30271980f, -0.12779269f, -0.20356035f, 0.08802818f, 0.09571103f, 0.07427603f, -0.12469365f, -0.01810910f, 
    0.00157706f, -0.04259850f, 0.04884749f, -0.00152265f, -0.01809991f, -0.02398731f, 0.02689013f, -0.14389656f, 
    0.07043691f, 0.05879229f, -0.02014912f, -0.06473031f, 0.00169067f, -0.07813879f, 0.03965185f, 0.04007822f, 
    0.02032398f, 0.09512185f, 0.20396256f, 0.01070629f, -0.10782855f, 0.01474732f, -0.02195845f, 0.04061417f, 
    0.03995256f, -0.13383836f, 0.06516308f, 0.07663762f, -0.09615819f, -0.00266189f, 0.01174023f, -0.03591624f, 
    0.03948273f, 0.09674428f, 0.04544695f, -0.01268447f, 0.08320678f, -0.12275945f, 0.07099736f, 0.13168105f, 
    -0.00261335f, -0.02741061f, 0.12854594f, 0.09826441f, 0.06215874f, -0.01327483f, -0.04230445f, -0.10240445f, 
    -0.02066588f, 0.00461345f, 0.00775230f, 0.02697980f, -0.15162438f, -0.07886533f, -0.05260593f, 0.13972054f, 
    0.07008132f, 0.04060452f, 0.01423921f, 0.14397717f, 0.02147866f, 0.00678366f, 0.01157902f, -0.02058171f, 
    0.28635606f, -0.00198959f, 0.21436125f, 0.17204073f, -0.08841331f, 0.02826774f, 0.02447355f, -0.04977269f, 
    0.06507465f, -0.02278247f, 0.07390889f, -0.04255783f, 0.11866850f, 0.11479996f, 0.14868098f, 0.08960548f, 
    -0.05723061f, -0.02449308f, 0.02191428f, 0.09662755f, 0.00402366f, -0.01680106f, 0.03295041f, 0.02477958f, 
    -0.02809441f, 0.09471826f, 0.04607605f, 0.07452345f, -0.23899482f, -0.04929775f, 0.02320412f, 0.03474581f, 
    -0.11848376f, -0.06708989f, 0.03859809f, 0.02108985f, -0.18321590f, -0.02727468f, 0.05821308f, -0.01844130f, 
    0.05708707f, -0.07467806f, -0.02309030f, -0.05705526f, -0.12937936f, -0.09657770f, -0.02991680f, 0.02649506f, 
    -0.41643459f, 0.08009799f, -0.11543194f, -0.05939349f, 0.15005808f, 0.10883708f, -0.00034957f, 0.02756650f, 
    0.03303827f, 0.00832938f, -0.00032281f, 0.10474949f, 0.07860489f, 0.08386289f, -0.00422797f, 0.05937174f, 
    -0.03468478f, -0.02600867f, -0.01617902f, 0.04507370f, 0.09370472f, -0.00794742f, 0.01088376f, -0.04756194f, 
    -0.21424900f, 0.22594860f, 0.04891590f, -0.16723391f, 0.11929097f, 0.10490191f, 0.01823287f, 0.12612182f, 
    -0.03100745f, 0.02715808f, 0.02173472f, -0.05742968f, 0.17971459f, 0.05006185f, 0.09205737f, 0.21604855f, 
    -0.03459531f, -0.05888940f, -0.00204861f, 0.02427863f, 0.02558563f, -0.01458976f, -0.01902050f, 0.09566863f, 
    -0.48223582f, 0.05054385f, -0.23104370f, 0.04000925f, 0.25187480f, 0.08184094f, 0.07954662f, 0.08231547f, 
    0.02651852f, -0.00306257f, 0.01483195f, 0.07631150f, 0.02938371f, 0.03592799f, 0.03484336f, -0.06838956f, 
    0.05407207f, 0.01138364f, -0.02899636f, 0.10434042f, -0.06458712f, -0.02586709f, 0.10840725f, -0.00320339f, 
    -0.22887717f, -0.04467256f, 0.08162532f, 0.04003147f, 0.05856841f, -0.00071210f, 0.12946244f, 0.14557885f, 
    0.07929251f, 0.06579403f, 0.03050847f, 0.16391425f, 0.11443318f, -0.11654454f, -0.05352617f, 0.11152782f, 
    -0.07934079f, 0.01231225f, 0.04200301f, 0.08944141f, 0.09544045f, 0.07020213f, 0.03297924f, -0.05501477f, 
    -0.04069196f, 0.08209373f, -0.06687316f, 0.01056628f, 0.03167599f, 0.00875731f, -0.09041166f, 0.00959727f, 
    0.06637320f, -0.05232549f, -0.02786103f, 0.04074580f, -0.27530617f, 0.00651006f, 0.06481081f, -0.02675087f, 
    0.06707994f, 0.07990447f, 0.14757486f, -0.05670267f, 0.02793242f, 0.06158494f, 0.01412140f, 0.00630604f, 
    -0.26227850f, 0.02686105f, -0.09592039f, -0.00759979f, 0.09955943f, 0.01832299f, 0.01279937f, 0.07857276f, 
    -0.02846690f, 0.01100584f, -0.08033073f, 0.05842359f, -0.01166913f, 0.04111070f, 0.05418861f, 0.18940257f, 
    0.07364366f, -0.01410464f, 0.03645744f, 0.01685505f, 0.04116883f, -0.00487477f, 0.03651549f, 0.03491888f, 
    -0.06436704f, 0.19263309f, 0.00174780f, 0.06496930f, 0.04464486f, 0.02651055f, 0.09926694f, 0.08546465f, 
    0.07445389f, 0.07502417f, -0.11824022f, 0.03329924f, -0.04674816f, -0.13067958f, -0.03199318f, 0.12891418f, 
    0.13595392f, -0.00202445f, 0.11351676f, -0.01981725f, 0.14361931f, -0.04087060f, -0.03876169f, 0.00716899f, 
    -0.07226893f, 0.02106248f, 0.09583442f, -0.09445518f, 0.10651387f, 0.01252397f, -0.08569762f, 0.11277052f, 
    -0.04728433f, -0.01540641f, 0.05979743f, 0.00841835f, 0.30097637f, 0.14604890f, 0.10265101f, 0.16362248f, 
    0.03815700f, 0.03599908f, 0.12913746f, -0.10596196f, -0.12296306f, 0.00726951f, 0.11702592f, -0.02130966f, 
    -0.23168035f, 0.06295366f, -0.03270163f, -0.12863156f, 0.07533703f, -0.00400326f, 0.11624302f, -0.02658798f, 
    -0.00086083f, 0.03214712f, 0.03892910f, 0.04156196f, -0.31769803f, -0.07592934f, -0.07517659f, 0.09383624f, 
    0.08625501f, 0.04952261f, -0.08205581f, -0.00830606f, -0.06951397f, 0.02848222f, 0.07250101f, -0.00752252f, 
    0.13647690f, 0.21075457f, -0.02004069f, -0.02900022f, -0.00406205f, 0.11012306f, 0.16683018f, 0.03432707f, 
    -0.02348993f, 0.00984521f, 0.11526814f, 0.08349649f, -0.15821470f, 0.10603077f, -0.03607434f, -0.07933454f, 
    0.12875064f, 0.01578748f, 0.04723942f, 0.08413948f, 0.07119368f, 0.09776230f, -0.01661208f, 0.03556663f, 
    0.17466049f, 0.33015224f, 0.13295887f, 0.05949917f, 0.13067263f, -0.00841386f, -0.01699966f, -0.14526713f, 
    0.11588427f, 0.01133116f, 0.00584905f, 0.04412856f, -0.06633703f, 0.16364041f, 0.08978572f, -0.05959767f, 
    0.12910001f, -0.00788483f, 0.02817826f, 0.01288810f, 0.02213258f, 0.00768023f, 0.11264441f, 0.02607268f, 
    -0.01317747f, -0.02696222f, 0.01681327f, 0.00752330f, -0.01773282f, -0.00589868f, -0.03707849f, -0.01547504f, 
    -0.01667319f, 0.01919821f, -0.00201401f, -0.02203736f, -0.03350561f, 0.02682255f, -0.02476859f, -0.01009077f, 
    0.03270121f, -0.03713664f, -0.02087289f, -0.00656915f, -0.01145689f, 0.01993093f, -0.02358376f, 0.00924774f, 
    -0.01734518f, -0.01164413f, -0.02312689f, 0.00263024f, -0.00000162f, -0.02485926f, -0.04085723f, -0.04374631f, 
    0.01380474f, -0.03794011f, -0.02451197f, -0.02537646f, 0.01770990f, -0.02891774f, 0.01981235f, 0.00299124f, 
    -0.00733051f, -0.01556084f, -0.00629628f, 0.01398629f, 0.02426901f, -0.03847515f, -0.00375130f, 0.01231663f, 
    -0.01751439f, -0.03264334f, -0.01484515f, 0.02511641f, 0.01288650f, -0.00750066f, 0.02406790f, 0.02714637f, 
    -0.03659848f, 0.02324157f, -0.02357133f, -0.03723419f, 0.02087640f, -0.02269860f, -0.01676550f, 0.02882617f, 
    -0.01546883f, 0.00825561f, -0.00090976f, 0.02091904f, 0.00024728f, -0.04213808f, 0.01086697f, 0.00022851f, 
    0.00879283f, -0.00354415f, -0.02478619f, -0.00278218f, 0.02300620f, 0.00531301f, 0.02446956f, 0.00554480f, 
    0.02558908f, -0.01785194f, -0.03204095f, 0.00764310f, -0.01580989f, 0.02104461f, 0.01885410f, -0.03597675f, 
    -0.01293983f, 0.02402822f, 0.00713014f, 0.00825618f, -0.01070001f, -0.03464971f, -0.02760245f, 0.00733385f, 
    -0.01609045f, 0.01809864f, -0.00153551f, 0.02379502f, -0.03195903f, 0.01612297f, 0.00170924f, 0.02014602f, 
    -0.01203450f, -0.01927714f, 0.02018718f, -0.01086643f, -0.00131198f, 0.00237015f, -0.01897808f, -0.03365892f, 
    -0.02987164f, 0.00425990f, 0.00362956f, -0.00716320f, -0.03017953f, 0.02481240f, 0.02327960f, 0.02771881f, 
    -0.01958222f, 0.01982474f, -0.00165573f, 0.01263387f, -0.03564402f, -0.02805580f, 0.03700088f, 0.00108909f, 
    -0.02454535f, 0.00452478f, -0.00086789f, -0.01690923f, -0.02356820f, 0.02171607f, 0.01743227f, 0.02396786f, 
    -0.00234706f, -0.03083752f, -0.00386368f, -0.01483364f, -0.01573313f, -0.02648739f, -0.00803977f, -0.03566084f, 
    -0.00051260f, -0.00893437f, -0.00057102f, -0.01777647f, -0.03197739f, -0.00537059f, 0.02640336f, 0.01143725f, 
    -0.03505389f, 0.01068732f, -0.01169644f, -0.00277834f, 0.01956993f, 0.00272800f, -0.00830428f, -0.00896361f, 
    -0.02703496f, 0.02983261f, 0.01380503f, 0.02200520f, 0.02086817f, -0.00585741f, 0.01131273f, 0.01651703f, 
    0.01669359f, 0.00682852f, 0.01149885f, 0.00255067f, -0.00491239f, -0.02285380f, 0.00593874f, 0.01869971f, 
    -0.03181126f, 0.01258722f, 0.02594205f, -0.02611498f, 0.04324806f, -0.02744438f, -0.01984015f, -0.00392854f, 
    -0.02514292f, 0.01340487f, 0.00404366f, 0.01880117f, -0.00829868f, -0.00790940f, -0.01792517f, -0.02863839f, 
    0.01344354f, -0.01951294f, -0.04245104f, -0.02295358f, -0.01915310f, -0.01851152f, -0.03487624f, -0.03826557f, 
    -0.00149958f, -0.02466904f, -0.01748196f, 0.02211007f, 0.02063824f, -0.03595911f, -0.02139767f, -0.03551074f, 
    0.01694812f, -0.00633951f, -0.03490845f, -0.03496865f, -0.00012100f, -0.03211998f, 0.00383727f, -0.00483360f, 
    -0.02050382f, -0.00010574f, 0.02044211f, -0.00878848f, -0.04284883f, 0.00689995f, 0.01327150f, -0.03650820f, 
    -0.02069156f, 0.01705807f, -0.03896197f, 0.00618128f, -0.04028073f, -0.03171948f, -0.00543928f, -0.00539951f, 
    0.00364345f, 0.02494595f, 0.03001658f, 0.01192241f, -0.02635254f, 0.00715461f, -0.01621956f, -0.00375161f, 
    -0.03399451f, -0.02810271f, 0.03596983f, 0.00257786f, -0.00129495f, 0.00184431f, 0.01609162f, -0.02611286f, 
    -0.00268853f, -0.01792989f, -0.00295457f, 0.00984696f, 0.01504436f, -0.01907703f, 0.02733835f, 0.00649902f, 
    0.03081531f, 0.01430794f, 0.00890424f, -0.03761436f, -0.03149452f, 0.01112240f, 0.00610053f, -0.02137886f, 
    0.01259130f, 0.01570334f, 0.01121572f, -0.00505672f, -0.00385540f, -0.00585617f, 0.01729785f, -0.02985981f, 
    -0.00498575f, -0.03045608f, 0.00581685f, 0.00221669f, -0.02439861f, -0.03218881f, -0.02847503f, 0.00161680f, 
    0.02426821f, -0.02104698f, 0.02239350f, 0.01780129f, 0.02712285f, -0.02164018f, -0.03111269f, -0.02021473f, 
    -0.04045219f, -0.01241638f, 0.02238979f, 0.01352807f, -0.00277914f, -0.00661451f, -0.01890816f, -0.03507744f, 
    0.00606767f, 0.00928030f, 0.01179601f, -0.02591778f, -0.02631679f, -0.03635791f, 0.00436899f, 0.02584275f, 
    -0.01109913f, -0.02698299f, -0.00698948f, 0.00005687f, -0.02736573f, -0.02479968f, 0.02715705f, 0.02213671f, 
    -0.02974782f, 0.01148328f, 0.00617826f, 0.01895488f, -0.04076780f, 0.01349956f, -0.00359907f, -0.02459610f, 
    0.00086615f, -0.03307120f, -0.03544174f, 0.02103471f, -0.01586294f, 0.00748883f, -0.01576261f, 0.02221134f, 
    -0.04060894f, -0.00046394f, 0.00222714f, 0.00062643f, 0.00864646f, -0.03924941f, 0.00788026f, -0.01903374f, 
    -0.00230910f, 0.00239331f, 0.02081260f, -0.03691076f, -0.00510953f, -0.04221752f, 0.02102352f, 0.00134523f, 
    0.02589793f, 0.02038087f, -0.00789375f, -0.03393994f, -0.02156913f, 0.02459143f, 0.02958084f, -0.01131567f, 
    -0.02472291f, -0.02300027f, -0.01677058f, -0.02940177f, -0.01707924f, 0.02940498f, -0.01188605f, -0.00801506f, 
    0.00204508f, 0.00144626f, -0.01804023f, -0.02565877f, -0.02088167f, -0.00375145f, -0.02738163f, 0.00052482f, 
    -0.01047704f, -0.02630023f, -0.03809230f, 0.01517820f, -0.02524170f, -0.01870215f, -0.02577685f, -0.02583887f, 
    -0.01601532f, 0.00785082f, -0.02858297f, 0.00908009f, -0.01543927f, -0.01059559f, -0.03472816f, -0.03814271f, 
    -0.01968777f, 0.02365387f, 0.01505196f, -0.02647701f, 0.02741383f, -0.02900116f, 0.01317650f, -0.02850944f, 
    -0.02524398f, 0.02650567f, 0.01350333f, -0.02691520f, 0.00805824f, 0.01341625f, -0.00596256f, -0.01659083f, 
    -0.03673115f, -0.01829029f, 0.02117634f, 0.02507104f, 0.03798820f, 0.00564416f, -0.00197218f, 0.01061127f, 
    -0.02550367f, -0.02911838f, 0.01210957f, -0.03943193f, -0.03340826f, -0.03081193f, 0.02593303f, 0.01113942f, 
    -0.03887838f, -0.00653059f, -0.00148431f, -0.01956659f, -0.03770922f, -0.02875496f, 0.01895543f, -0.03355888f, 
    0.01319924f, -0.03401696f, 0.01788268f, -0.04166841f, 0.02442939f, -0.00886176f, -0.02678733f, 0.02632958f, 
    -0.02101642f, 0.00594364f, -0.03251080f, 0.01012486f, -0.00368992f, -0.00346995f, -0.01809433f, 0.02155881f, 
    -0.00872013f, -0.01418539f, 0.00561655f, -0.01544752f, 0.02353577f, 0.00883157f, 0.00107701f, -0.01984818f, 
    0.00750907f, -0.01848527f, 0.01620663f, 0.02051254f, -0.01813144f, 0.02584393f, 0.00201928f, 0.01937378f, 
    0.02102440f, 0.02128058f, -0.03264547f, 0.02833555f, 0.01151781f, 0.01108717f, -0.03606806f, -0.02661118f, 
    -0.03870063f, 0.01587253f, 0.01979635f, -0.00483727f, -0.02644404f, -0.00273741f, 0.03473468f, -0.02276227f, 
    -0.01066319f, -0.03961284f, 0.00772568f, -0.04106578f, 0.02667551f, 0.00657678f, -0.02766112f, 0.02316814f, 
    0.03359507f, -0.01750705f, -0.02657494f, -0.01265503f, 0.02428621f, -0.02339073f, -0.03050311f, -0.03429646f, 
    -0.02570998f, 0.00346097f, 0.03628974f, -0.02514485f, -0.01661002f, -0.03869565f, -0.03719248f, 0.01442192f, 
    0.01221827f, 0.00413025f, -0.03458016f, -0.01649977f, -0.02296938f, 0.01046772f, 0.00775799f, -0.01027460f, 
    -0.03616704f, 0.01484810f, 0.00023585f, 0.01542288f, -0.02180072f, -0.03188556f, 0.00906833f, 0.00788711f, 
    0.01388725f, 0.02850357f, -0.00201419f, 0.00268432f, 0.02227108f, -0.02073750f, 0.02365607f, 0.00193084f, 
    0.01648837f, -0.03953417f, 0.01025235f, 0.02133125f, 0.00103746f, -0.00991385f, -0.03400862f, -0.01425674f, 
    -0.03963025f, -0.00335942f, 0.00751258f, -0.01177258f, -0.01956564f, 0.02642308f, -0.02165696f, -0.00174097f, 
    0.00686051f, -0.01494047f, 0.00809433f, -0.01627825f, 0.01963224f, 0.01769966f, -0.03464387f, -0.03371873f, 
    -0.04191795f, -0.03447555f, -0.03531135f, -0.03256352f, -0.02427688f, -0.00556401f, -0.02793236f, -0.00234673f, 
    -0.00207066f, -0.00708301f, 0.02009912f, 0.02297212f, 0.00788327f, 0.02653192f, 0.02697983f, 0.00587600f, 
    -0.01133976f, 0.02027144f, -0.02992495f, -0.01280877f, -0.00121589f, 0.03218792f, -0.00999001f, 0.01764851f, 
    0.00728965f, 0.02695024f, 0.01583942f, -0.01209851f, -0.03353319f, -0.02175296f, -0.00052824f, -0.01890121f, 
    0.02420291f, -0.02340548f, -0.00917518f, -0.00066882f, -0.02268784f, 0.00872187f, -0.04277999f, -0.02903140f, 
    -0.02600868f, -0.02960084f, -0.02793067f, 0.00343853f, -0.02352458f, 0.00473118f, -0.02182334f, 0.01029003f, 
    0.00474617f, 0.02506847f, 0.01360245f, -0.03353823f, -0.02287429f, -0.01690253f, -0.01499973f, -0.00983377f, 
    -0.00386507f, 0.01051142f, 0.01718725f, -0.03791080f, -0.00185971f, -0.00645232f, -0.01621518f, 0.00527658f, 
    0.01242307f, -0.03879257f, -0.03522301f, 0.03257990f, -0.02686513f, 0.01138416f, 0.01672135f, 0.01212814f, 
    0.00968916f, -0.02282831f, 0.02418283f, -0.01290728f, 0.02509573f, -0.01753534f, -0.00918954f, 0.02267839f, 
    -0.01798700f, 0.02642284f, -0.01223718f, -0.00713089f, 0.02445324f, -0.02269553f, -0.02560763f, 0.00320271f, 
    0.01916006f, -0.00533932f, 0.02933346f, 0.01396970f, -0.00340402f, 0.00657154f, -0.01819441f, -0.03727756f, 
    0.03819939f, 0.01720594f, 0.01684149f, 0.01115258f, -0.00063847f, 0.01860435f, -0.00785509f, -0.03226097f, 
    -0.03154381f, -0.00858572f, -0.01273044f, -0.03248200f, 0.01651416f, -0.02924688f, -0.02896115f, 0.01755166f, 
    -0.04232178f, -0.03888621f, 0.04070112f, 0.00817974f, -0.01208070f, 0.00178378f, -0.04140672f, -0.00147810f, 
    0.01145180f, -0.03934394f, 0.00762423f, -0.03573253f, -0.01056381f, -0.03528967f, -0.01627004f, 0.01837555f, 
    -0.00322386f, -0.03614022f, -0.01341070f, -0.02872462f, 0.03189152f, -0.00726607f, -0.00420711f, -0.01166722f, 
    -0.02525569f, 0.00124553f, -0.00192919f, 0.01419694f, 0.02786284f, 0.00878708f, -0.00686499f, -0.02007865f, 
    0.00777469f, -0.03913722f, -0.00486433f, 0.00531490f, -0.01397008f, -0.02436331f, 0.02657003f, -0.00212090f, 
    -0.04066862f, -0.02500586f, -0.02726519f, -0.01242613f, -0.00790948f, -0.01942210f, -0.02607546f, 0.01992959f, 
    0.02773429f, -0.02219160f, -0.00357422f, -0.03504544f, -0.02501665f, -0.02556095f, -0.02953793f, 0.02381338f, 
    -0.02393534f, 0.00279531f, 0.02568343f, -0.01226054f, 0.01642680f, 0.02176751f, -0.02548164f, 0.01373273f, 
    -0.02094525f, -0.01279976f, 0.01994986f, 0.02382802f, -0.01444514f, -0.02942284f, -0.01555248f, 0.01988037f, 
    0.03457831f, 0.03092933f, 0.01510002f, 0.01248734f, -0.02903501f, -0.00730214f, -0.00115818f, 0.02495837f, 
    0.02221733f, -0.01909227f, -0.01230159f, -0.01853551f, -0.01443882f, -0.02991511f, -0.00866878f, -0.02045001f, 
    -0.00997647f, -0.02080377f, -0.03527385f, -0.02967658f, -0.01696128f, -0.03902978f, 0.03630862f, -0.00789077f, 
    0.01124871f, -0.02327560f, 0.01295869f, -0.00030204f, -0.02087605f, 0.00329833f, 0.01281723f, -0.00761767f, 
    -0.00973204f, -0.01088493f, -0.03219713f, -0.01254711f, 0.02796056f, 0.00238334f, 0.00007005f, -0.02949047f, 
    0.03611525f, 0.14596665f, 0.02950296f, 0.08836681f, 0.08596160f, 0.05285085f, 0.09089770f, -0.04248911f, 
    -0.05459074f, -0.07214175f, -0.11049452f, 0.05736580f, -0.23837014f, -0.01190449f, 0.14087041f, 0.04337021f, 
    0.10705116f, 0.07349207f, -0.00696703f, 0.05506040f, -0.08186215f, 0.07665757f, 0.01455834f, 0.10111948f, 
    0.06899478f, 0.02166571f, 0.10478176f, -0.01447509f, -0.04578737f, -0.05375726f, -0.13015831f, -0.11120947f, 
    -0.06673546f, 0.17281002f, 0.01967013f, 0.03214677f, -0.18200274f, 0.06679656f, -0.19330683f, -0.09802671f, 
    0.10241729f, -0.01180102f, 0.04594620f, 0.02309910f, 0.01285792f, -0.11831311f, -0.01763947f, 0.19274513f, 
    0.11632433f, -0.00557617f, -0.05744623f, -0.20542385f, 0.00475008f, -0.09692822f, 0.07875644f, -0.08713001f, 
    0.02010110f, 0.07951115f, 0.07219164f, -0.04941522f, 0.04463071f, 0.03006149f, 0.14480560f, 0.12434050f, 
    0.03069774f, 0.04018953f, -0.07496671f, -0.03005974f, 0.15243840f, 0.13212131f, 0.19935043f, 0.00277347f, 
    -0.21871120f, 0.04638243f, 0.00649005f, -0.01060477f, 0.07608437f, 0.03605607f, -0.08640759f, 0.07591506f, 
    -0.01100335f, 0.13245758f, 0.05457272f, 0.03559600f, 0.00457981f, -0.27302027f, 0.08701434f, 0.06454231f, 
    -0.04438961f, 0.02802894f, -0.02450274f, -0.02032893f, 0.11195342f, 0.09356558f, -0.16438018f, -0.12836725f, 
    -0.10749841f, 0.00928909f, -0.22285655f, -0.09364803f, 0.01029317f, 0.00341987f, -0.12695199f, 0.08767128f, 
    0.07511880f, 0.03985771f, 0.08746546f, 0.01341405f, 0.04565141f, 0.08229988f, 0.13616052f, 0.08864650f, 
    0.01583418f, -0.01148947f, -0.01527355f, 0.06729940f, 0.01221124f, -0.01274140f, -0.13793010f, -0.04693900f, 
    -0.25597149f, -0.04860445f, -0.09243582f, 0.03116560f, 0.01081601f, 0.11897943f, 0.00178131f, 0.08288091f, 
    0.06707577f, 0.02948972f, 0.05079962f, -0.03691228f, -0.30435839f, 0.02841106f, 0.11302952f, 0.27662742f, 
    0.02762609f, -0.03295413f, -0.11490940f, -0.02593201f, -0.03351508f, -0.06484441f, 0.06946629f, -0.03180523f, 
    -0.20852317f, -0.28716490f, 0.08215380f, 0.20714757f, -0.00699319f, -0.04186627f, 0.05036668f, -0.07116546f, 
    0.02599235f, -0.00366045f, 0.20606360f, 0.08083200f, -0.13728572f, -0.04373303f, 0.04458661f, 0.07282580f, 
    -0.00959789f, 0.00465284f, -0.01020139f, 0.01433216f, -0.02365487f, 0.11792190f, 0.04071235f, 0.14148122f, 
    -0.28810415f, -0.16373830f, 0.04976727f, 0.05278155f, 0.07250599f, -0.02784684f, -0.05260339f, -0.01806989f, 
    0.03969130f, 0.06294246f, 0.02248026f, 0.13727891f, -0.03752598f, 0.12530592f, -0.04051761f, -0.29786652f, 
    0.03694943f, -0.04564332f, 0.09062448f, 0.03051326f, -0.05667467f, 0.04937636f, -0.05586316f, -0.19388056f, 
    -0.03367809f, 0.11003921f, 0.01511524f, -0.07677516f, 0.03993426f, -0.07203683f, -0.00135346f, -0.08995884f, 
    0.06122960f, -0.06007158f, 0.10517140f, -0.01696499f, 0.13015378f, 0.09482658f, 0.02016824f, -0.00235425f, 
    0.10019101f, 0.09987099f, -0.05984246f, 0.09937380f, 0.08255443f, -0.03252725f, 0.03003017f, 0.10620717f, 
    -0.15849692f, -0.09319191f, 0.01412626f, 0.05106194f, 0.09378428f, -0.03143334f, -0.12937032f, 0.05037873f, 
    -0.00614386f, 0.15576205f, 0.15096891f, 0.16685158f, -0.30874604f, 0.14178422f, -0.07091530f, -0.07577505f, 
    0.00898130f, -0.08873325f, 0.16908459f, 0.18180658f, 0.12127372f, 0.13764903f, 0.05328701f, 0.08000339f, 
    -0.15503165f, -0.04058355f, -0.09925440f, -0.06258044f, -0.05280957f, 0.11403909f, -0.03178326f, -0.02136400f, 
    0.09586480f, -0.01730157f, 0.04791147f, 0.17340146f, 0.06561504f, 0.14266466f, -0.13068002f, 0.03076749f, 
    -0.00738918f, -0.01594591f, 0.07338714f, 0.14204282f, 0.02039645f, 0.04935362f, 0.06558076f, -0.07941983f, 
    -0.25154233f, -0.05856914f, 0.02835492f, -0.02730250f, 0.06469338f, 0.03036973f, 0.03138209f, 0.05343360f, 
    0.08858357f, 0.04650790f, -0.05483017f, 0.09175740f, 0.17349149f, 0.02798063f, 0.12760925f, 0.00641174f, 
    0.00197704f, -0.01609727f, -0.10751004f, 0.06874185f, 0.03520320f, -0.08575477f, -0.16084440f, 0.03583995f, 
    -0.21080384f, 0.36693171f, 0.09485055f, 0.11446024f, 0.04187401f, 0.10558105f, -0.02789460f, -0.01952715f, 
    0.08584855f, -0.12072794f, 0.10049304f, 0.11949307f, -0.02297252f, 0.10837713f, -0.00602516f, -0.01818774f, 
    -0.10187992f, 0.07469158f, -0.04349101f, 0.04636131f, 0.01971293f, 0.21640387f, 0.04306262f, 0.06674891f, 
    0.08521875f, -0.12311709f, 0.10694380f, 0.11345070f, -0.01811860f, -0.06479903f, 0.14738588f, -0.08650935f, 
    -0.10595036f, 0.02114685f, -0.04023070f, 0.15969402f, -0.01391293f, 0.15701604f, 0.05076442f, 0.08049411f, 
    0.11827444f, 0.04569885f, 0.02077536f, 0.12580848f, 0.05473206f, -0.02914972f, 0.10855334f, 0.01372097f, 
    0.04027032f, 0.16849279f, -0.17082784f, -0.08321861f, -0.02363138f, 0.06756072f, -0.07617442f, -0.05984689f, 
    0.03407526f, -0.24028459f, 0.14977898f, -0.01576232f, 0.00076748f, -0.09978767f, -0.03782148f, -0.08452919f, 
    0.03060773f, -0.05879557f, 0.01504646f, -0.07785726f, -0.06997539f, 0.04884014f, 0.03019325f, 0.13066250f, 
    -0.20066613f, -0.12580524f, 0.11872628f, -0.09519485f, 0.05041584f, 0.04773097f, -0.10029389f, 0.03386823f, 
    0.01330163f, 0.10918430f, -0.02915417f, 0.14224780f, 0.05173096f, -0.25280929f, -0.01556894f, 0.13051635f, 
    0.06491204f, -0.01679478f, 0.01578788f, -0.05521204f, -0.00607038f, -0.08233186f, -0.04970355f, -0.07090975f, 
    0.33576617f, -0.01839847f, -0.04324772f, 0.01558390f, 0.05112592f, 0.09597543f, -0.18579595f, 0.17465755f, 
    -0.03489146f, 0.08720206f, 0.12745939f, -0.12660438f, -0.00105159f, 0.00411957f, 0.10464644f, -0.02839030f, 
    -0.04017895f, -0.02436827f, 0.09314009f, -0.09207536f, 0.08616779f, -0.06941575f, 0.13682541f, 0.01597448f, 
    -0.18397041f, -0.17346586f, 0.03227290f, 0.04265901f, 0.05116000f, 0.04054314f, 0.01723928f, -0.01175534f, 
    0.03376026f, -0.18272202f, 0.04273625f, -0.05291152f, -0.03301683f, -0.08319382f, 0.00946071f, 0.09527782f, 
    0.01271977f, -0.00111282f, -0.06067024f, 0.03895728f, 0.06649471f, 0.16367595f, 0.06057081f, -0.05308885f, 
    -0.10834207f, -0.13129197f, 0.03427487f, 0.12707859f, 0.04804189f, -0.06364828f, -0.07518284f, -0.00170352f, 
    -0.07048942f, 0.07889546f, 0.16483298f, 0.00598256f, -0.04286763f, -0.01276222f, 0.10342658f, 0.01587264f, 
    0.09795663f, 0.11788408f, -0.13373929f, 0.07838717f, 0.17534937f, 0.01047158f, 0.15840578f, -0.01062148f, 
    -0.17010692f, -0.14394964f, 0.11139498f, 0.09604029f, -0.14273670f, 0.00495112f, -0.03141312f, -0.09379452f, 
    0.03296857f, 0.04205978f, 0.01080498f, 0.12050366f, 0.14179923f, -0.02990739f, 0.09219209f, -0.01760641f, 
    -0.04672160f, -0.03308249f, -0.15571073f, 0.02983297f, -0.00462325f, -0.02876963f, -0.00821558f, -0.09448184f, 
    -0.20352760f, -0.05771970f, 0.07826064f, 0.07540564f, 0.02011441f, 0.12859145f, -0.06171510f, -0.01738708f, 
    -0.03362945f, -0.08853246f, -0.08842435f, 0.11733626f, -0.03245980f, 0.12179060f, 0.10123547f, -0.11082725f, 
    0.07331536f, -0.04914992f, 0.05885718f, -0.06073289f, -0.20715494f, 0.03650055f, -0.16638345f, 0.01517070f, 
    -0.25833768f, 0.11732528f, 0.01019593f, 0.09373768f, 0.05733489f, 0.01754227f, 0.06678644f, -0.08264605f, 
    0.01095839f, 0.06325646f, 0.05875985f, 0.08714241f, -0.07682279f, -0.19985485f, -0.05671014f, 0.04555841f, 
    -0.01551339f, -0.07764769f, 0.08839396f, 0.06269997f, 0.16692775f, 0.10129692f, 0.01825232f, 0.11260251f, 
    -0.03026972f, 0.16629712f, 0.05571558f, -0.02896955f, 0.13862422f, -0.11806331f, -0.14784464f, 0.09638342f, 
    -0.03456921f, -0.02970571f, 0.14764079f, -0.22946519f, 0.04971418f, 0.11642093f, 0.16057603f, 0.17568992f, 
    0.09536586f, -0.10489164f, 0.02152350f, 0.10389747f, 0.04462634f, -0.02497046f, -0.14217839f, 0.02235950f, 
    -0.19305107f, 0.09505093f, -0.05964042f, 0.08617989f, 0.14342353f, -0.13677996f, 0.03450786f, -0.12221919f, 
    -0.10496458f, -0.09483656f, -0.04637168f, -0.12890616f, -0.03061573f, 0.03557345f, 0.12544699f, 0.03982275f, 
    0.02559667f, -0.01476805f, -0.02033260f, -0.05766012f, -0.01054060f, 0.04626664f, 0.16003938f, 0.09062655f, 
    0.19762082f, 0.15485999f, -0.08501637f, 0.17105554f, 0.04167927f, -0.11467471f, 0.03588976f, -0.00828021f, 
    0.05132142f, -0.00766372f, 0.03461543f, 0.01012212f, 0.12574123f, 0.04140493f, -0.10732561f, 0.08797574f, 
    0.05146293f, -0.04717225f, -0.10764007f, 0.11535383f, -0.06273673f, -0.02698687f, 0.00261080f, 0.14267579f, 
    0.01923518f, 0.09451125f, -0.01579080f, 0.20655143f, 0.11653198f, 0.10915268f, -0.03230685f, 0.01996769f, 
    0.03319985f, 0.09728453f, 0.01350444f, 0.15858428f, -0.17381647f, 0.18344195f, -0.02606674f, -0.03299512f, 
    0.04835645f, -0.02481704f, -0.06904540f, -0.13993201f, 0.01940036f, -0.05471599f, 0.12744121f, 0.06509729f, 
    -0.01110689f, 0.18844126f, -0.12991907f, -0.08628210f, -0.01829266f, -0.05847960f, 0.00375000f, 0.07255758f, 
    0.08081008f, -0.15663850f, 0.07361095f, -0.11530484f, -0.08125386f, 0.19203123f, 0.07800605f, 0.14793356f, 
    -0.03517490f, 0.11442260f, -0.04638131f, -0.04903498f, 0.11944416f, -0.06981147f, -0.02506670f, -0.01281326f, 
    -0.24794540f, 0.09825239f, 0.13599724f, -0.03126048f, 0.18319649f, -0.03021656f, -0.12034991f, 0.01459039f, 
    0.04998378f, -0.09979437f, -0.07501639f, -0.09713682f, 0.11544631f, 0.07082559f, 0.02087470f, 0.07743158f, 
    0.06810568f, 0.04227342f, 0.16143849f, 0.02431684f, 0.12957679f, -0.29627553f, 0.13955784f, 0.06676774f, 
    0.08119139f, 0.02028116f, -0.03808874f, 0.07303862f, 0.00903891f, 0.05001191f, 0.07061134f, 0.10342418f, 
    0.00513265f, 0.10514010f, -0.14032367f, -0.02776986f, 0.01071521f, -0.06552532f, 0.10847285f, 0.15415955f, 
    -0.04822108f, 0.16578694f, -0.00443920f, 0.08753330f, -0.07779136f, -0.05970706f, -0.00926587f, -0.10981329f, 
    -0.03090459f, 0.10840961f, -0.08441802f, -0.06675984f, 0.01787304f, 0.05252934f, 0.14958856f, 0.11004517f, 
    0.05957779f, -0.01604249f, 0.07278749f, -0.03365179f, 0.01815334f, 0.23342684f, -0.17629753f, -0.01201748f, 
    -0.03962867f, -0.01210807f, 0.01381784f, -0.08270022f, -0.02055121f, -0.10800257f, 0.01234594f, -0.07507177f, 
    -0.12970923f, 0.06450259f, -0.03225426f, -0.00252149f, 0.12602840f, -0.03883092f, 0.05693794f, 0.01814331f, 
    0.02183379f, 0.24019006f, 0.25291166f, 0.08454396f, -0.00425045f, 0.17164341f, 0.08260245f, -0.12970029f, 
    0.07306885f, -0.00996812f, -0.04894799f, 0.01151595f, 0.13469221f, 0.10405927f, 0.09761903f, -0.01064498f, 
    -0.17600669f, -0.13878334f, 0.06782851f, 0.15706395f, -0.14660829f, -0.11420958f, 0.04471959f, -0.13414256f, 
    0.06337684f, 0.14849898f, 0.03012375f, 0.08007266f, 0.13830647f, -0.04561542f, 0.10192042f, -0.23809044f, 
    -0.00059457f, 0.10930009f, 0.02284952f, -0.10585382f, 0.11594327f, 0.15434049f, 0.13454513f, 0.05160261f, 
    -0.04121426f, 0.02771158f, -0.01460679f, -0.00743479f, -0.01834390f, 0.02679404f, 0.01738610f, 0.00094180f, 
    0.01783593f, 0.01066436f, -0.01889532f, 0.00494293f, 0.03585679f, 0.03185472f, 0.00459600f, -0.02841976f, 
    -0.04093825f, -0.02119349f, -0.03270619f, -0.04095954f, -0.00814732f, -0.02605927f, -0.00401771f, 0.00508675f, 
    -0.00569830f, 0.01628929f, 0.00561554f, -0.04070013f, 0.00800773f, 0.00988914f, 0.01999708f, -0.02048122f, 
    -0.02261352f, 0.03255740f, 0.00275437f, 0.03465769f, -0.01194820f, 0.01264024f, 0.02117279f, -0.01783491f, 
    -0.00925622f, 0.02481265f, 0.02926857f, -0.00288248f, 0.02315052f, -0.01232741f, -0.01997602f, -0.00965601f, 
    0.02502033f, 0.00107315f, -0.00747930f, 0.00424200f, 0.02024189f, 0.02034293f, -0.01983068f, 0.02839594f, 
    0.00627917f, -0.01201152f, 0.01567925f, -0.03012122f, 0.02089019f, 0.00988387f, 0.01335322f, 0.00027453f, 
    -0.03357404f, -0.02219966f, -0.01500063f, 0.02994686f, 0.02509417f, -0.02483032f, -0.02467952f, 0.01031917f, 
    0.02907117f, -0.02642841f, -0.01211917f, -0.01421726f, 0.03001000f, 0.00801970f, 0.02349397f, 0.04218093f, 
    0.01239087f, -0.01886211f, 0.01447108f, -0.02423879f, -0.00450569f, 0.01641898f, -0.01808662f, 0.00285848f, 
    0.01282395f, 0.03276537f, -0.02790689f, -0.02122652f, 0.01086059f, -0.00180559f, 0.00116630f, 0.00395439f, 
    0.03130575f, 0.03925169f, 0.01084025f, -0.01354451f, -0.04218505f, -0.01778980f, -0.00837924f, -0.02030494f, 
    0.03958412f, 0.00223640f, -0.03607112f, -0.01545939f, 0.01077581f, -0.00885852f, 0.01604583f, 0.00085519f, 
    0.02448912f, -0.00359111f, 0.01919304f, -0.03266614f, -0.00864182f, 0.02575495f, -0.01215762f, -0.03559706f, 
    0.00179506f, 0.01500129f, 0.02332025f, 0.03735444f, -0.00695479f, 0.02461091f, 0.00071978f, -0.02555174f, 
    0.01114236f, -0.01544601f, -0.02070050f, -0.02031165f, -0.00401138f, 0.02187853f, -0.02876082f, -0.01817869f, 
    0.03946670f, -0.00166734f, -0.00878601f, -0.00921186f, -0.00703142f, -0.02455270f, -0.00899556f, -0.01300229f, 
    0.01988369f, -0.00180950f, 0.00948275f, 0.00418794f, 0.00672853f, -0.02751631f, -0.01451221f, -0.01629156f, 
    -0.03485839f, -0.01225956f, -0.02321566f, -0.00947413f, -0.02909105f, 0.03616730f, -0.03005762f, 0.01871112f, 
    0.02863914f, -0.04036330f, 0.01389662f, -0.01044986f, -0.00707477f, -0.02349954f, 0.01434326f, -0.02823657f, 
    0.00931541f, 0.01921408f, -0.00319450f, 0.01564209f, 0.03031072f, -0.01043417f, 0.00071470f, -0.00306045f, 
    -0.00661480f, -0.01116389f, -0.00360085f, 0.02508929f, -0.00033216f, -0.01043002f, -0.03334983f, -0.00875570f, 
    0.02847880f, -0.02613117f, -0.02102371f, -0.00687625f, -0.00778549f, 0.03645116f, 0.02156434f, -0.00519227f, 
    0.00420160f, 0.01458583f, -0.00029979f, 0.02098029f, -0.00231585f, -0.00423361f, -0.01017864f, -0.03173105f, 
    0.03157166f, -0.03391015f, -0.00740136f, -0.00763522f, -0.01830708f, 0.03680942f, 0.00231326f, 0.02117831f, 
    0.01861191f, -0.01108079f, 0.00783354f, 0.02006532f, 0.03012349f, 0.00665571f, -0.02387419f, -0.03614173f, 
    -0.03336638f, -0.02463114f, 0.02076989f, -0.01879618f, 0.03524215f, 0.01722398f, -0.03301276f, -0.01170187f, 
    0.02339439f, -0.02309438f, -0.00013792f, 0.02941712f, -0.02969582f, -0.00698314f, 0.00583662f, 0.00544048f, 
    0.02404932f, -0.00130553f, 0.01916089f, 0.01796695f, -0.00460151f, 0.02631535f, -0.02918183f, -0.01365650f, 
    -0.03746334f, 0.02303357f, -0.03519728f, -0.00035068f, 0.03318414f, 0.02056152f, 0.01945612f, 0.00373686f, 
    -0.03011786f, 0.01063971f, -0.02600388f, 0.01796474f, 0.02067019f, -0.01947177f, -0.01287781f, -0.01353892f, 
    -0.00540728f, -0.01932598f, -0.01633066f, -0.01348528f, 0.01722959f, -0.01935257f, 0.02422911f, -0.01865489f, 
    0.00842734f, -0.01853414f, -0.00458852f, -0.02549050f, -0.03692162f, -0.02671108f, -0.01792593f, -0.01246980f, 
    -0.02624376f, -0.03535315f, 0.00455969f, -0.02529535f, -0.03195224f, 0.02183654f, -0.02754507f, 0.01736387f, 
    0.00796628f, -0.02657374f, 0.01530191f, -0.03772561f, 0.01881600f, -0.03130028f, 0.00681944f, 0.02669314f, 
    0.02883775f, -0.03942774f, -0.02275828f, -0.00237625f, 0.00271348f, 0.04081926f, 0.01409299f, 0.00743972f, 
    0.00508966f, -0.02724189f, 0.00027787f, -0.01371109f, -0.01549843f, -0.01503527f, 0.01304777f, -0.02579213f, 
    -0.02163900f, -0.01762377f, 0.03087544f, -0.02042775f, 0.02956538f, 0.00372467f, 0.01911541f, 0.01900133f, 
    0.02796042f, -0.02793979f, -0.01865847f, 0.02149541f, -0.02509220f, 0.02462962f, 0.01395917f, -0.00814236f, 
    0.01942530f, 0.00018871f, -0.00799485f, -0.01649470f, 0.00071777f, 0.01643002f, -0.00335042f, -0.01782839f, 
    0.01472051f, 0.03928203f, -0.01676413f, 0.02946907f, -0.03624306f, -0.00080639f, -0.00404276f, 0.01100113f, 
    -0.01565810f, 0.01717082f, 0.02431255f, -0.04157396f, 0.01784931f, -0.02297246f, 0.02027807f, -0.02410440f, 
    -0.03127413f, 0.01052264f, -0.00090170f, -0.01363174f, 0.01747595f, -0.03018918f, 0.00096208f, -0.00253186f, 
    -0.02278718f, -0.03873329f, 0.02360623f, -0.00255724f, 0.00118811f, -0.01544983f, -0.00429300f, 0.02086546f, 
    -0.00544130f, 0.01367695f, -0.00096873f, -0.00511215f, 0.00239951f, -0.00420213f, -0.03015386f, -0.01156749f, 
    0.02960591f, 0.00611228f, 0.00182933f, -0.03186876f, 0.02002342f, -0.01153665f, 0.01626329f, 0.03120590f, 
    -0.01940913f, -0.01872065f, -0.00092550f, 0.02655545f, 0.00619624f, -0.01154746f, -0.01003352f, -0.01188242f, 
    0.03862350f, -0.03949658f, 0.02664884f, 0.02594159f, -0.03262866f, -0.02960482f, 0.02469652f, -0.00866579f, 
    -0.01544888f, -0.02510314f, -0.02763264f, -0.01191718f, -0.01992863f, -0.01096244f, 0.00660693f, -0.02832810f, 
    0.01599347f, 0.01401437f, 0.01474697f, -0.04099726f, -0.01690412f, 0.02682791f, -0.00144469f, -0.03461739f, 
    -0.01388256f, -0.01256963f, 0.03009496f, 0.01537449f, -0.01809299f, 0.01672685f, 0.00599879f, 0.00534438f, 
    0.02836420f, 0.02781600f, 0.01222414f, 0.02473510f, 0.02180553f, 0.01886623f, 0.02474781f, -0.01450269f, 
    0.00119241f, 0.01128063f, 0.01504583f, 0.03033431f, 0.02679905f, -0.04053238f, -0.03598870f, 0.01915937f, 
    0.01341187f, -0.02334849f, -0.00864594f, 0.02770754f, -0.02426350f, 0.01446083f, 0.02408171f, 0.00521692f, 
    -0.01661324f, 0.01549062f, 0.00130213f, -0.03315569f, 0.00275186f, 0.03161614f, -0.00234268f, 0.04140818f, 
    -0.01211240f, -0.00680114f, 0.03923154f, -0.00056791f, -0.01279165f, -0.03586642f, 0.02877425f, -0.03208866f, 
    0.01006723f, -0.02972402f, -0.01612928f, -0.00333171f, -0.01394977f, 0.04027680f, -0.03150422f, -0.00995658f, 
    0.01537543f, 0.01645869f, -0.00954410f, -0.02457446f, 0.01840018f, -0.03413107f, -0.00914615f, -0.02608964f, 
    -0.01778333f, -0.03770920f, -0.00755791f, -0.02755680f, 0.03357315f, 0.02302392f, -0.03819319f, 0.02725789f, 
    -0.01024025f, -0.02296360f, -0.03247248f, -0.02708653f, -0.01798183f, -0.03462203f, 0.01392543f, -0.00793834f, 
    0.00607876f, -0.01456957f, -0.00341556f, -0.01540109f, -0.00082584f, 0.00522005f, -0.03857764f, -0.03934213f, 
    0.02292314f, -0.02847926f, 0.02054049f, -0.03704096f, 0.02106652f, 0.00227861f, 0.01949479f, -0.00952685f, 
    0.01611326f, -0.01206706f, -0.02841056f, 0.01277189f, 0.02418456f, -0.01690331f, 0.02153466f, -0.01871321f, 
    -0.03282169f, -0.00205318f, -0.02111907f, 0.00909050f, -0.02595090f, 0.02434962f, 0.01142640f, -0.03656601f, 
    0.00382226f, -0.03029496f, -0.02776778f, 0.01394246f, -0.03965328f, 0.02954370f, -0.00623415f, 0.01049738f, 
    -0.02422857f, 0.01686341f, -0.02223015f, 0.00627873f, -0.02223759f, 0.01534400f, -0.00942156f, 0.03281097f, 
    -0.03924107f, 0.00222792f, -0.03337875f, -0.01814876f, -0.00108295f, -0.01474141f, 0.03950223f, -0.02584592f, 
    0.00224985f, -0.00773203f, 0.01717621f, 0.01804620f, 0.00389454f, -0.00055572f, 0.00138507f, 0.02809912f, 
    -0.00678523f, 0.01669484f, -0.03651050f, 0.01426938f, 0.00619150f, 0.03097536f, -0.01765255f, 0.01459228f, 
    0.03815253f, -0.03240314f, -0.00498074f, 0.00174659f, -0.01575546f, 0.01780215f, -0.00959159f, 0.02985423f, 
    -0.00594582f, 0.01458573f, -0.01962085f, 0.01464846f, -0.02791331f, 0.00170716f, 0.02459539f, -0.01462210f, 
    -0.02095568f, -0.02238474f, -0.04035560f, -0.00199061f, -0.01755792f, -0.01530227f, -0.01618746f, -0.02457023f, 
    -0.03864118f, 0.02869434f, -0.00180289f, -0.01405480f, 0.00337564f, -0.03459352f, -0.02132853f, -0.03778024f, 
    0.03951884f, 0.01615859f, 0.01583069f, -0.00351024f, -0.01136221f, 0.00953613f, 0.02940461f, 0.00476480f, 
    -0.01777860f, -0.01318031f, 0.01187559f, -0.01989907f, -0.04021567f, -0.02481160f, -0.01518834f, 0.01194871f, 
    -0.01425557f, -0.02242285f, -0.01531682f, -0.01005904f, -0.03299509f, -0.02059324f, -0.01848281f, -0.00706757f, 
    0.00583362f, 0.01668603f, -0.00861516f, -0.02697827f, 0.01323844f, -0.02549819f, 0.00896228f, -0.01001099f, 
    -0.00343993f, 0.01348147f, -0.03031703f, -0.02446186f, -0.02950321f, -0.00177451f, -0.00879903f, -0.00501642f, 
    -0.02075991f, -0.02569325f, -0.00326219f, 0.00090100f, -0.02682795f, 0.00138292f, 0.01813007f, -0.01622326f, 
    0.01967294f, -0.00193985f, 0.01806588f, -0.02823799f, -0.00724647f, 0.01066091f, 0.01191537f, 0.01940263f, 
    -0.00304513f, 0.00019962f, -0.03907234f, -0.02605355f, 0.01600983f, -0.03760728f, 0.01149808f, -0.01695232f, 
    -0.00908243f, -0.02143357f, -0.02839271f, -0.02376396f, 0.02991355f, 0.00603030f, -0.00612817f, -0.00207787f, 
    -0.02505995f, 0.02955642f, 0.02583413f, 0.01852970f, -0.02896909f, -0.01349568f, -0.01099159f, -0.00878180f, 
    0.02075766f, -0.00321269f, -0.02034926f, -0.02425487f, -0.02169321f, -0.02113901f, 0.01631760f, -0.01824028f, 
    -0.02128920f, 0.01762960f, -0.01859978f, -0.00664716f, -0.00611543f, -0.01585039f, -0.02014538f, 0.02579114f, 
    -0.01865741f, -0.03840952f, 0.00046748f, -0.00634457f, -0.00397716f, 0.00141391f, -0.00243750f, -0.01585426f, 
    -0.01444388f, -0.03446702f, -0.03651823f, -0.02056188f, -0.01242050f, 0.01744094f, -0.03530045f, 0.01258874f, 
    -0.00375981f, 0.03217757f, -0.03529246f, 0.00707467f, -0.03643883f, 0.00101080f, -0.03016682f, -0.00417547f, 
    -0.03279397f, 0.02419139f, -0.02471678f, 0.02318783f, 0.02544931f, 0.02315079f, -0.00397385f, 0.02200857f, 
    -0.02922647f, -0.01457593f, -0.02873772f, 0.00404467f, 0.02901078f, 0.01452032f, 0.02904512f, 0.03697399f, 
    0.00351867f, 0.01082980f, -0.03186148f, -0.03596147f, 0.00645816f, -0.00708357f, -0.00686062f, -0.00039449f, 
    -0.02539328f, 0.02617492f, -0.03648839f, 0.00509627f, 0.02920138f, 0.02820758f, -0.03898467f, -0.02441861f, 
    -0.01411356f, 0.01192167f, 0.03728623f, 0.04260269f, -0.00842220f, -0.01867867f, 0.00071030f, 0.01040147f, 
    0.00513251f, 0.01913573f, -0.00487077f, 0.00273037f, 0.02437461f, -0.00789414f, 0.00905863f, -0.00419993f, 
    -0.03143415f, -0.02277270f, -0.03880253f, 0.02787185f, 0.02491509f, 0.01848485f, 0.02411458f, -0.03634680f, 
    0.09739313f, -0.04247484f, 0.25238824f, 0.13336661f, 0.02766750f, 0.00561626f, 0.09617452f, 0.03959378f, 
    0.02013134f, 0.02852581f, 0.00003406f, 0.03804558f, 0.08643445f, 0.07767913f, 0.01662432f, 0.12350288f, 
    -0.06308216f, -0.07835796f, 0.02845298f, 0.06506206f, -0.09742809f, -0.13535237f, -0.00862569f, -0.05746960f, 
    -0.12409714f, -0.03168308f, 0.00116634f, 0.00901336f, 0.07003669f, -0.01206351f, 0.07982513f, -0.03764648f, 
    0.01491494f, 0.01249253f, 0.00957998f, 0.09144590f, -0.07009141f, -0.16897088f, 0.14636235f, -0.06901001f, 
    0.03173643f, 0.04602919f, -0.01479383f, -0.07225462f, -0.00944049f, 0.04589188f, 0.01671655f, -0.00668328f, 
    -0.21501186f, -0.07088474f, -0.11065489f, -0.07678542f, 0.03102865f, 0.01270162f, 0.00324485f, -0.06145668f, 
    -0.06646208f, 0.01952416f, 0.07413574f, -0.00041429f, -0.02359595f, 0.01019655f, 0.11013563f, 0.03111124f, 
    0.04917951f, 0.03442968f, 0.00784884f, -0.05851619f, -0.04487084f, -0.03786219f, -0.06410021f, 0.05418474f, 
    -0.05557827f, 0.05787684f, -0.01134551f, 0.14077787f, -0.01698249f, -0.03377631f, 0.00136852f, -0.00434642f, 
    0.00504214f, 0.04128394f, 0.03781729f, -0.00739991f, 0.17533109f, -0.00883423f, -0.25814316f, -0.10486418f, 
    0.07015515f, 0.04918108f, -0.02238672f, -0.05714214f, 0.10833738f, -0.06270752f, 0.00235194f, 0.05200565f, 
    0.14105463f, 0.07809008f, 0.09590599f, -0.09261142f, -0.00389881f, 0.08837350f, 0.00950520f, -0.04810866f, 
    -0.08440389f, 0.06249623f, 0.08815750f, -0.04549824f, 0.09806541f, 0.07243388f, 0.04119467f, 0.12378696f, 
    0.01401334f, 0.07907832f, -0.03302264f, 0.03067827f, -0.08495092f, -0.00975731f, 0.08297340f, -0.11578268f, 
    0.22225977f, 0.01109819f, 0.01561585f, 0.06622919f, -0.01089597f, 0.02420100f, -0.00378845f, 0.05723333f, 
    0.12355008f, 0.04971446f, 0.04246831f, 0.06239098f, 0.08204267f, -0.05309996f, -0.12248263f, -0.04105952f, 
    -0.00023744f, -0.01052910f, 0.04689066f, 0.03337840f, -0.08326443f, 0.05174584f, -0.11536791f, 0.04759798f, 
    0.16354266f, 0.06980267f, -0.15492699f, -0.03842405f, -0.01995028f, 0.06824548f, -0.04834712f, 0.00220706f, 
    -0.05006619f, -0.05851308f, -0.04305271f, -0.02173107f, 0.10501251f, -0.04894779f, 0.03580700f, 0.23113751f, 
    -0.01517679f, 0.00881825f, -0.10720766f, 0.09516147f, 0.09861784f, -0.05910166f, 0.07851537f, -0.07768606f, 
    0.01483939f, 0.04735912f, -0.09057277f, 0.13985036f, -0.21108809f, 0.05529425f, -0.07254005f, -0.00466488f, 
    0.02422696f, 0.03461893f, 0.05822267f, -0.04641012f, -0.10350236f, 0.07460081f, 0.19364306f, 0.02889786f, 
    -0.00601386f, -0.01397780f, -0.00645041f, -0.06328358f, 0.03336857f, 0.00316131f, 0.00949516f, 0.16090645f, 
    0.16028535f, 0.04526799f, -0.00570695f, -0.04128513f, -0.05769634f, -0.02155380f, 0.06631559f, 0.05676544f, 
    0.03154401f, 0.06005164f, 0.01522684f, -0.11663122f, 0.22308201f, 0.03533099f, 0.06748994f, 0.00575094f, 
    0.06791886f, 0.13204211f, 0.03597056f, -0.01074390f, -0.08285449f, 0.05578764f, -0.07146146f, -0.04183080f, 
    0.02015390f, 0.10680208f, 0.04996662f, 0.20846033f, -0.06570279f, 0.02062173f, 0.06906274f, 0.14237826f, 
    -0.03518481f, 0.11152468f, -0.12443166f, 0.10244708f, 0.30386516f, 0.04790897f, 0.14330007f, -0.10658838f, 
    -0.02811752f, 0.10029426f, -0.02319196f, 0.04544555f, -0.02551237f, 0.07226931f, 0.05770344f, 0.01270308f, 
    -0.25883093f, -0.03369669f, 0.05152337f, 0.05913049f, -0.01103152f, 0.02397648f, 0.14209819f, 0.01931057f, 
    -0.05168824f, 0.07682202f, 0.04110214f, 0.02230212f, 0.00945756f, -0.01333204f, 0.02437887f, 0.06207698f, 
    -0.09840946f, 0.07929581f, -0.04652620f, -0.01689797f, 0.00843476f, -0.09071349f, 0.01275130f, 0.04061190f, 
    -0.14730294f, -0.06371959f, -0.05752340f, -0.01304542f, 0.07891189f, 0.00004004f, -0.04273620f, 0.00072569f, 
    -0.05100100f, 0.10040549f, -0.01521761f, -0.03701465f, 0.04726500f, 0.11793631f, 0.05536602f, -0.05115196f, 
    0.01249449f, 0.02316542f, 0.09543951f, 0.01736165f, -0.01269413f, 0.06923018f, -0.02910954f, -0.02997494f, 
    0.05631669f, 0.19695430f, 0.26126561f, 0.04014353f, 0.05520099f, -0.05299236f, 0.03561782f, 0.10623982f, 
    -0.04717591f, 0.10757087f, 0.07496218f, 0.02053750f, 0.01576159f, -0.08985625f, 0.14927787f, 0.03825355f, 
    0.05711866f, 0.04198776f, -0.00232270f, -0.01628143f, 0.06614631f, 0.00200398f, 0.02408618f, 0.05878939f, 
    0.12559400f, 0.08803729f, 0.02469178f, 0.09270024f, 0.03216347f, 0.10225859f, -0.07884666f, 0.03999259f, 
    0.05354093f, 0.03635077f, 0.04143471f, -0.10541545f, 0.01016007f, -0.03935682f, -0.07083312f, 0.00140890f, 
    0.04222946f, 0.08556408f, 0.01772971f, -0.01990167f, 0.14570689f, -0.00394313f, -0.01310393f, -0.16443436f, 
    0.17675693f, 0.09402574f, -0.00721437f, -0.00808163f, -0.00510420f, -0.00507729f, 0.15471932f, 0.05731769f, 
    0.05379864f, 0.08119699f, -0.09024317f, 0.00794295f, 0.02795851f, -0.04639871f, 0.12222773f, 0.06589594f, 
    0.03802297f, 0.06080456f, 0.01059445f, -0.01410434f, 0.04246186f, -0.08375338f, 0.04264887f, -0.08551733f, 
    0.01805146f, 0.13418986f, -0.06689841f, -0.07252207f, 0.09682667f, 0.03515716f, 0.02250105f, -0.03467657f, 
    0.01927494f, 0.04024058f, -0.03454486f, 0.01787751f, -0.07637408f, 0.19319725f, 0.00177798f, -0.07812250f, 
    -0.06886107f, 0.11078954f, 0.08273713f, -0.00242984f, 0.02726513f, 0.05099985f, 0.12172882f, -0.02995462f, 
    0.31190622f, 0.19459720f, 0.01849919f, 0.17019773f, 0.14560074f, 0.04976181f, 0.10137425f, -0.06193329f, 
    -0.03618385f, 0.03673702f, 0.01011462f, 0.14155379f, -0.09177871f, -0.03574863f, 0.00667046f, -0.04138001f, 
    0.08712615f, -0.09504497f, -0.03430485f, 0.07767481f, -0.16320407f, 0.05351797f, -0.17976466f, -0.00613526f, 
    -0.08523818f, -0.03052094f, -0.16359663f, -0.02017039f, 0.06639222f, -0.04399423f, -0.03980613f, -0.00333618f, 
    0.00091805f, 0.02438020f, -0.03158547f, -0.00484153f, 0.20455961f, -0.06610801f, -0.10241069f, -0.04154034f, 
    0.00635630f, 0.08563807f, 0.08079635f, 0.05899680f, -0.06191481f, -0.06134172f, -0.00641761f, -0.00385066f, 
    0.14536877f, 0.01359197f, -0.15062414f, 0.01087515f, -0.06325481f, -0.05069596f, 0.04289887f, 0.01642492f, 
    -0.01062183f, -0.01703154f, -0.02593608f, 0.00758367f, 0.09046260f, 0.10750457f, -0.03725924f, 0.06161091f, 
    0.02653942f, 0.00136834f, 0.07469580f, -0.01167540f, -0.01977225f, 0.00287792f, -0.07515545f, 0.02641436f, 
    0.08844259f, -0.10543153f, -0.06442608f, -0.14535394f, -0.06997198f, -0.03899341f, -0.01037747f, 0.04389626f, 
    -0.00252303f, -0.06856634f, 0.02442269f, -0.08869653f, -0.24513306f, -0.11866813f, -0.09277162f, -0.10516812f, 
    0.04363334f, 0.02013889f, 0.01270202f, -0.03042005f, 0.00202513f, 0.07569776f, -0.11603061f, 0.06301523f, 
    -0.05345384f, -0.14237815f, -0.09380691f, -0.09182595f, 0.03866951f, -0.07305502f, -0.03466040f, -0.03634131f, 
    -0.00622643f, -0.05307133f, 0.12780216f, 0.01455772f, 0.02141348f, 0.04217730f, 0.03075012f, 0.06133220f, 
    0.05002746f, 0.07825911f, 0.07060634f, 0.01302374f, 0.00058613f, 0.00841463f, -0.01403562f, 0.02744748f, 
    0.00093621f, 0.06684548f, 0.08989824f, 0.07504698f, 0.00656650f, -0.02693702f, 0.09545568f, 0.05300671f, 
    0.08312778f, -0.06202792f, -0.02540985f, 0.01697497f, 0.10773695f, -0.02096909f, -0.21737006f, -0.05952685f, 
    -0.00856616f, -0.03546873f, -0.03356098f, -0.06138948f, -0.05390998f, 0.01903203f, -0.04586682f, 0.02276523f, 
    -0.18779911f, 0.12871219f, 0.12725800f, 0.03008806f, 0.03686361f, 0.05497291f, 0.09100293f, -0.08183929f, 
    -0.01798324f, -0.02560176f, 0.02628826f, 0.11200172f, -0.02133389f, 0.15123391f, 0.12827897f, 0.25793949f, 
    0.05705385f, 0.03649846f, -0.00654511f, -0.00085153f, -0.06486233f, -0.11021738f, 0.03102445f, 0.01998077f, 
    -0.01118200f, 0.18611589f, -0.00921395f, -0.07061068f, 0.06570201f, 0.01207360f, 0.01668139f, 0.09029042f, 
    0.09049037f, -0.01189657f, -0.04013904f, 0.01981172f, -0.15752248f, -0.16353612f, 0.00173919f, -0.03170711f, 
    -0.01331706f, 0.03063369f, -0.00374545f, -0.00478852f, 0.06031643f, 0.09013186f, 0.09824220f, 0.06934305f, 
    0.01815409f, -0.06392167f, 0.04653633f, 0.20312789f, -0.04060636f, -0.03196061f, -0.01778067f, 0.10167731f, 
    0.07892389f, 0.13436843f, 0.05129436f, 0.04671544f, 0.34574500f, 0.02475377f, 0.20297033f, 0.09218244f, 
    0.05503591f, 0.09202547f, 0.04414859f, 0.00059013f, 0.19992681f, -0.04523158f, 0.03361384f, 0.02963042f, 
    0.20904978f, -0.06426883f, 0.08069081f, 0.05558886f, 0.01839352f, 0.05012826f, 0.04707115f, -0.00443969f, 
    0.02334796f, -0.03179522f, 0.00030707f, 0.00386002f, 0.27597308f, -0.01318397f, 0.11990658f, 0.08119015f, 
    0.02808158f, 0.02720735f, 0.10566153f, 0.01877949f, 0.01951949f, 0.00894703f, -0.04061447f, 0.01408412f, 
    -0.17540458f, 0.03799957f, 0.02298367f, -0.03482197f, -0.09626652f, -0.05538156f, 0.01332420f, -0.05651740f, 
    0.01419977f, 0.09512851f, -0.03196242f, -0.06451492f, 0.28305623f, -0.00514700f, 0.00814169f, 0.20017213f, 
    0.02958453f, 0.00110919f, 0.10161355f, -0.03134871f, -0.00082579f, 0.00331379f, -0.06736398f, 0.02421779f, 
    -0.18007454f, -0.06596304f, 0.02190837f, -0.06153153f, 0.05475918f, 0.08955190f, 0.06304665f, -0.04333442f, 
    -0.01954251f, 0.01496801f, -0.05938711f, 0.06602335f, 0.03703415f, 0.06670022f, 0.12271158f, -0.01886057f, 
    0.07889051f, 0.06998812f, 0.02925282f, 0.04335202f, 0.06937698f, 0.17480646f, -0.13295215f, -0.05019375f, 
    0.19979742f, 0.04113290f, -0.04792980f, 0.10914838f, 0.02001613f, 0.02813593f, -0.01011528f, 0.05000861f, 
    -0.07685693f, -0.02334410f, 0.05707807f, 0.10860056f, -0.09812124f, 0.27873576f, -0.01697547f, -0.06613120f, 
    0.00902423f, 0.05334580f, 0.06208701f, -0.04059791f, -0.01664281f, 0.08439592f, 0.06084781f, 0.04152686f, 
    -0.07560076f, 0.02187697f, 0.15397426f, 0.09745452f, -0.02600965f, -0.04793675f, -0.00484375f, -0.03713231f, 
    0.04750871f, 0.00847492f, 0.08017164f, -0.02776611f, 0.10877805f, 0.22185922f, -0.02051041f, -0.03091910f, 
    0.02815839f, 0.06357957f, 0.03477872f, 0.16991422f, -0.03199204f, 0.07643285f, -0.10741593f, -0.05943763f, 
    -0.08405980f, 0.05080185f, 0.06337767f, 0.10110745f, 0.02902662f, 0.05342101f, 0.01878444f, -0.01224251f, 
    0.04416115f, -0.01867773f, 0.00699645f, 0.02909264f, -0.08962309f, 0.07016253f, 0.09121186f, 0.05465938f, 
    0.01210162f, 0.00624336f, 0.03972956f, -0.07024300f, 0.06091416f, -0.00294853f, 0.03464082f, -0.02119942f, 
    -0.07813989f, 0.08222640f, -0.03787418f, 0.10759397f, 0.04007158f, -0.04924794f, 0.04239056f, 0.07905915f, 
    -0.01839060f, -0.12449704f, 0.00782096f, -0.08163577f, 0.11162192f, -0.06414945f, 0.17112392f, 0.11864104f, 
    0.05692051f, -0.12335663f, -0.02293851f, 0.07875250f, 0.03950739f, -0.13023061f, 0.14493757f, -0.02673160f, 
    0.21848653f, -0.13870072f, -0.07106286f, -0.09613869f, -0.07085511f, -0.06229922f, -0.04604037f, 0.07799389f, 
    0.07951723f, 0.10112950f, 0.11716036f, -0.01936708f, -0.03182601f, 0.10079104f, 0.04694407f, 0.03672242f, 
    0.10733446f, 0.05465637f, 0.06158669f, 0.08575501f, 0.03098308f, 0.05359468f, 0.00712618f, 0.04823151f, 
    0.02488139f, -0.28613704f, -0.12576674f, -0.05224767f, 0.07924744f, 0.03276036f, -0.01790629f, 0.12924443f, 
    0.10320032f, 0.02234521f, -0.00341867f, 0.10151028f, 0.06316218f, -0.11705741f, 0.09760536f, -0.05392082f, 
    -0.01500887f, 0.06402332f, -0.02054912f, 0.01178410f, 0.13063002f, 0.13304350f, 0.02590341f, -0.04238677f, 
    -0.04463264f, 0.04603722f, 0.11315162f, 0.06724828f, 0.06412140f, -0.01718222f, 0.01352832f, 0.10292066f, 
    0.00577666f, -0.05247653f, -0.05957818f, 0.07764187f, -0.02407278f, -0.05520160f, -0.14232786f, -0.05253943f, 
    -0.19044387f, 0.04939520f, 0.06118558f, 0.07759169f, -0.00110114f, 0.03748851f, 0.03595321f, 0.07010588f, 
    0.36571950f, -0.17887761f, 0.13285781f, 0.14160271f, -0.01275702f, 0.03159422f, -0.00925262f, 0.05939090f, 
    0.03707260f, 0.04230765f, 0.02412269f, 0.10337385f, 0.10509936f, 0.19635326f, -0.04420481f, 0.04450246f, 
    0.04180921f, -0.06577375f, 0.13928449f, 0.11314941f, 0.06335638f, -0.02076367f, 0.04860959f, 0.00848575f, 
    0.24232030f, 0.25020897f, 0.00331043f, 0.15956824f, 0.05738247f, 0.07748849f, 0.07285667f, 0.11089663f, 
    0.10374829f, -0.00828017f, -0.05149033f, 0.12937948f, -0.16610783f, -0.13424608f, -0.03092641f, -0.15101342f, 
    -0.01197493f, 0.01750202f, 0.03481979f, -0.15583779f, 0.06768086f, -0.04078145f, -0.02337394f, 0.01686375f, 
    -0.16702376f, 0.21328399f, -0.09520376f, -0.01291947f, -0.01470196f, 0.02767170f, -0.00079669f, 0.06080680f, 
    -0.00264566f, -0.12235782f, 0.03125164f, -0.02818846f, -0.25733128f, -0.29578817f, -0.08853317f, -0.09452774f, 
    0.14773446f, 0.07227421f, -0.08246396f, 0.13796310f, 0.07972184f, 0.09479040f, 0.05925058f, 0.06235786f, 
    0.36949891f, 0.17745034f, 0.03256781f, -0.04599558f, 0.09840659f, 0.01764167f, 0.02374928f, 0.06325229f, 
    0.14254044f, 0.08782996f, 0.04212372f, 0.03596650f, 0.28525826f, 0.01049271f, -0.00447964f, 0.00956559f, 
    0.11730901f, 0.01015731f, 0.08914933f, 0.12886180f, 0.03518639f, 0.05063004f, -0.02627461f, -0.05341340f, 
    0.09320021f, 0.06888395f, -0.07354234f, -0.13691691f, 0.14524458f, -0.01297032f, 0.05188849f, 0.07795952f, 
    -0.01182266f, -0.03147660f, 0.10118210f, 0.16089654f, 0.22019446f, -0.04733921f, 0.11264975f, 0.28410348f, 
    -0.04093641f, 0.07610282f, 0.01710417f, 0.05637490f, 0.10017073f, 0.09001473f, 0.00748488f, 0.02519723f, 
    -0.17714050f, -0.10272467f, 0.00019334f, -0.00033315f, -0.02180057f, 0.13327344f, 0.04041874f, 0.03077652f, 
    0.01018792f, 0.01928751f, -0.05736950f, 0.10361683f, -0.11922105f, 0.05019589f, -0.06988074f, -0.05114583f, 
    -0.15493584f, -0.15922391f, -0.00842083f, -0.02300310f, -0.01063891f, -0.04222202f, 0.03800914f, -0.00036146f, 
    0.05890730f, 0.25931722f, -0.08625299f, -0.02291713f, -0.01118211f, 0.06342946f, -0.05185876f, -0.09622949f, 
    0.06374003f, -0.01991893f, 0.00404428f, -0.06174600f, 0.10402577f, -0.04896098f, 0.00575332f, 0.03041141f, 
    -0.05885612f, 0.08268558f, -0.10952021f, 0.00643745f, -0.07338273f, 0.00852975f, -0.01102709f, 0.01709353f, 
    0.29174936f, -0.19567153f, 0.02864550f, -0.07526603f, 0.07863562f, -0.10955551f, 0.15824305f, 0.00712766f, 
    -0.08822146f, 0.06273584f, 0.05693915f, 0.00316475f, 0.20285715f, -0.13493197f, -0.07598914f, -0.00783531f, 
    -0.02477572f, -0.11473948f, 0.04460096f, -0.07246353f, 0.00988905f, 0.03095485f, 0.04208582f, 0.03926409f, 
    0.41518205f, -0.16359204f, 0.05401047f, 0.04371728f, 0.00571322f, 0.08954681f, 0.06271450f, 0.07014294f, 
    0.09773825f, 0.06899007f, 0.04952504f, 0.00755314f, -0.18117496f, 0.02613188f, -0.24722034f, -0.08982535f, 
    -0.02389374f, -0.03271112f, 0.01823770f, 0.00547642f, 0.05028031f, -0.02607753f, -0.02577474f, -0.03845054f, 
    0.13852562f, -0.16342442f, -0.13288246f, -0.02695049f, -0.15275876f, -0.00909955f, 0.10157154f, -0.00066405f, 
    0.05761651f, -0.02737380f, -0.10667512f, -0.14337540f, 0.28359523f, -0.08978020f, 0.06101160f, 0.07971267f, 
    0.05615807f, -0.00782842f, 0.07725491f, 0.11301903f, -0.04930838f, 0.04308410f, 0.16819263f, 0.06552067f, 
    -0.06416353f, 0.11029030f, 0.02646984f, -0.14140159f, 0.14210437f, -0.06206198f, 0.03218930f, 0.12231389f, 
    0.12424707f, 0.08512368f, 0.06139294f, -0.02709357f, 0.10610808f, -0.05367937f, -0.12162004f, -0.19984758f, 
    -0.13738285f, -0.01795822f, -0.02131912f, 0.00422283f, -0.15146577f, -0.08823043f, 0.01936276f, 0.08243151f, 
    0.05339333f, -0.08917166f, 0.02711619f, -0.10208447f, -0.02344655f, 0.00200444f, -0.03882334f, 0.03418637f, 
    0.03907865f, -0.01728788f, 0.01128252f, -0.01211289f, 0.13675521f, 0.12946258f, -0.00584829f, 0.07294384f, 
    -0.14799277f, -0.07155831f, -0.06741113f, 0.03106167f, -0.04520947f, -0.05577588f, -0.03476066f, -0.05035971f, 
    0.08152918f, 0.15977769f, -0.09004517f, 0.10036275f, 0.01463422f, -0.10575780f, 0.08044420f, 0.00044768f, 
    -0.01180538f, 0.09848500f, 0.02928573f, -0.01185691f, -0.24021675f, 0.15335043f, 0.01490943f, -0.07550681f, 
    0.03620543f, -0.03782606f, -0.03758576f, -0.03246598f, 0.07816315f, -0.04246085f, 0.02014512f, 0.03465463f, 
    -0.23118000f, -0.07797860f, 0.13970040f, 0.04894478f, -0.07571429f, -0.00520469f, 0.16806631f, -0.01589751f, 
    0.09778507f, 0.10456249f, -0.03315770f, 0.12627901f, 0.01558864f, -0.21484716f, 0.09570009f, 0.09827519f, 
    0.08397546f, 0.06040127f, 0.04872569f, 0.10304546f, 0.15762141f, 0.02779583f, 0.01228741f, 0.16131353f, 
    0.47817475f, -0.04021341f, -0.02663106f, 0.01850460f, -0.01665363f, 0.03554304f, 0.12110401f, 0.05662913f, 
    0.09293564f, 0.17476565f, 0.10388970f, 0.13309924f, 0.23930280f, -0.05549337f, 0.04081801f, 0.16663383f, 
    0.14874858f, 0.02554718f, -0.01163387f, 0.01131104f, 0.09800945f, 0.06159713f, 0.07616424f, 0.09925532f, 
    -0.22507626f, 0.17994960f, 0.09280921f, -0.09390686f, 0.04878565f, 0.18132693f, 0.03681790f, 0.13263412f, 
    -0.03435531f, -0.02845222f, 0.01581659f, 0.16757697f, 0.01216920f, 0.02792849f, -0.17547092f, -0.12100313f, 
    -0.09920297f, -0.04387157f, 0.02290697f, -0.15153714f, -0.00472577f, -0.00352058f, 0.07685059f, -0.01419506f, 
    0.02129258f, 0.32976308f, -0.11660507f, -0.05802502f, 0.10931177f, 0.05861839f, 0.07072544f, 0.04072972f, 
    -0.00773103f, 0.06296375f, -0.10212895f, 0.00728080f, -0.05012554f, -0.18476333f, -0.13262966f, -0.14660782f, 
    0.17197506f, 0.15656081f, 0.01839621f, 0.09566718f, 0.08555392f, 0.04814563f, 0.04654649f, 0.05615844f, 
    0.37450022f, -0.15056090f, 0.14944138f, 0.12692645f, 0.06132280f, 0.08558166f, 0.15341416f, 0.10387649f, 
    0.14127924f, 0.15404634f, -0.11520725f, 0.09381385f, -0.07641461f, 0.14602952f, 0.04288305f, 0.11817168f, 
    -0.04375751f, 0.02892719f, 0.01004360f, 0.14601159f, 0.13718934f, 0.03268756f, 0.13853905f, -0.05209155f, 
    0.07971137f, 0.09604989f, 0.00830245f, 0.02367133f, -0.07874259f, 0.10156629f, -0.01805083f, 0.14981396f, 
    0.00804370f, 0.07828659f, 0.06040079f, 0.00609940f, 0.35327664f, 0.09653194f, 0.08606376f, -0.04102068f, 
    0.02242161f, 0.10129842f, 0.09350123f, 0.07452489f, 0.03367537f, -0.02939828f, 0.05538372f, 0.04232971f, 
    -0.03556372f, -0.04128480f, -0.10397827f, 0.05861181f, 0.04226895f, 0.02065211f, -0.04444685f, -0.00453289f, 
    0.04298779f, 0.11569355f, 0.08537466f, 0.12992933f, -0.06625174f, -0.08889401f, 0.00317486f, 0.10405686f, 
    -0.02446900f, 0.12876791f, 0.03404328f, 0.07223947f, -0.00781767f, 0.04701438f, -0.06250985f, 0.01455892f, 
    0.13312754f, 0.00877372f, -0.07413912f, -0.04337712f, -0.02557085f, 0.04449404f, 0.05081655f, 0.14669359f, 
    0.06324723f, 0.00983745f, 0.06298105f, -0.01151690f, 0.00172242f, 0.11605141f, -0.01676740f, -0.04869319f, 
    -0.03560245f, 0.01092098f, 0.10360303f, 0.00500813f, -0.00209659f, 0.01455319f, -0.06634952f, 0.00210301f, 
    0.13576297f, 0.17606504f, -0.17140438f, -0.03999868f, 0.04424482f, -0.04021908f, 0.01767143f, 0.04060964f, 
    -0.00727565f, -0.01582024f, 0.03231143f, 0.00057230f, -0.11912575f, -0.00431113f, -0.01104962f, -0.03538757f, 
    -0.00569447f, -0.01781568f, -0.05671231f, 0.02614438f, 0.00193548f, 0.05594484f, -0.04251849f, 0.00885224f, 
    -0.01243655f, -0.11403615f, -0.00069403f, -0.09692226f, -0.13066752f, 0.01817668f, -0.03467917f, 0.07789571f, 
    -0.00617516f, 0.10360795f, -0.06147738f, -0.09518267f, 0.35900646f, -0.10493390f, -0.05271921f, 0.04912971f, 
    0.05542194f, 0.00636555f, 0.04119369f, 0.14208022f, 0.03414082f, 0.02041646f, 0.04408544f, -0.02580714f, 
    0.34987336f, -0.24673530f, 0.00348220f, 0.03744711f, 0.06568936f, 0.00636969f, 0.17196503f, 0.04040562f, 
    -0.01149696f, -0.02963283f, 0.11764695f, 0.07097486f, 0.20728651f, -0.11474711f, -0.06256893f, -0.15874740f, 
    -0.11382538f, -0.16477412f, 0.01958608f, -0.05010131f, 0.06016022f, 0.00454309f, -0.04718009f, -0.04589283f, 
    0.01132285f, -0.19195525f, -0.04330147f, -0.00197112f, -0.01239599f, -0.01210385f, 0.01328203f, 0.10683674f, 
    0.11860576f, 0.09983811f, 0.13986234f, 0.08953645f, -0.03603278f, -0.11129524f, -0.14300589f, -0.05190397f, 
    -0.13897020f, -0.03312343f, -0.07329822f, -0.02226870f, -0.02561925f, -0.00829336f, 0.07331921f, 0.04060838f, 
    -0.13758585f, -0.02978460f, 0.09917998f, 0.00249400f, 0.03179741f, 0.05428371f, 0.02634734f, -0.04456355f, 
    0.17173676f, -0.02330472f, 0.00446108f, 0.06729358f, -0.08852997f, 0.00495531f, -0.02586132f, -0.01679021f, 
    0.09937195f, -0.10805831f, -0.09911662f, 0.12728781f, 0.18471228f, -0.01325505f, 0.05127279f, 0.11297488f, 
    0.33329847f, -0.15684706f, -0.10003231f, 0.07556592f, 0.01824415f, -0.04554764f, -0.09714496f, -0.01018738f, 
    0.04320545f, -0.00751955f, 0.10910746f, 0.01272054f, 0.16411772f, -0.22273099f, -0.05994737f, -0.08421059f, 
    -0.02166473f, -0.02530381f, 0.11511167f, 0.10123408f, 0.02184312f, -0.01192026f, 0.01786370f, 0.01195220f, 
    0.15304495f, -0.13079353f, -0.02320724f, 0.00942650f, 0.03000379f, -0.03030967f, -0.02217226f, 0.02549360f, 
    0.06687625f, -0.07877237f, -0.04318968f, 0.00357974f, 0.08979560f, 0.09143017f, -0.06722084f, 0.09871996f, 
    -0.01142097f, -0.03250479f, -0.01271561f, 0.05269308f, -0.08230551f, 0.02751525f, -0.00629939f, 0.10683832f, 
    -0.06213200f, -0.18750294f, 0.02022508f, -0.08172344f, 0.05257404f, 0.00312263f, -0.03871025f, 0.07589573f, 
    0.02618896f, 0.03706224f, -0.09614892f, -0.00866622f, 0.19480953f, -0.10847510f, 0.02579919f, 0.12557484f, 
    0.00404752f, 0.04423727f, -0.11559091f, 0.04096685f, -0.11387198f, -0.06309992f, -0.01740688f, 0.05509382f, 
    0.00094680f, 0.00594175f, -0.16848932f, -0.13903092f, -0.02063517f, -0.01012879f, -0.01086610f, 0.16511850f, 
    0.05914998f, 0.04955611f, 0.03287150f, -0.00922024f, 0.06201393f, 0.04820635f, 0.02037883f, 0.00527769f, 
    0.08554332f, 0.04095096f, 0.03582167f, 0.00511518f, 0.10637207f, 0.04895698f, 0.03355225f, -0.05113216f, 
    0.09010841f, -0.04879786f, 0.03593572f, 0.06371862f, -0.08589186f, 0.00188340f, 0.01713107f, 0.11712943f, 
    0.11820626f, -0.10599497f, 0.09889107f, 0.02811915f, 0.15352346f, -0.05610285f, -0.06601115f, 0.16218187f, 
    -0.08944805f, 0.03816980f, 0.02054084f, 0.11986988f, 0.06176228f, 0.04774671f, -0.10647591f, -0.05532975f, 
    0.00870348f, 0.02548892f, 0.05960528f, 0.08289999f, -0.02510615f, 0.01507355f, 0.05362343f, 0.14486806f, 
    -0.00393128f, -0.06602693f, 0.07121548f, 0.09937877f, 0.08247290f, -0.01766069f, -0.06280668f, -0.08041321f, 
    -0.00086362f, 0.02923162f, 0.13510509f, 0.09428637f, -0.02415364f, 0.03602173f, 0.00061846f, 0.11295918f, 
    0.15369597f, -0.12783173f, 0.12431904f, 0.06803524f, 0.03351134f, 0.05065448f, 0.03654767f, -0.08560017f, 
    0.08554886f, -0.01928900f, -0.03384598f, -0.06967228f, -0.14635760f, 0.09435453f, 0.25722355f, 0.17678864f, 
    -0.04035518f, -0.09751400f, 0.06929164f, 0.01987237f, -0.08842308f, 0.04986579f, 0.13561477f, -0.02563051f, 
    -0.19493388f, -0.00817730f, -0.00271242f, 0.12770340f, -0.04519468f, 0.04910566f, 0.01657848f, 0.09632912f, 
    0.09187279f, -0.01919605f, -0.03820328f, 0.12521173f, -0.04483713f, -0.11857892f, 0.05616754f, -0.05633209f, 
    -0.05808160f, 0.02241431f, 0.04627735f, 0.02262659f, 0.09210945f, 0.04973632f, 0.06981918f, 0.17492226f, 
    -0.08988854f, 0.21455576f, 0.05236074f, -0.13891627f, 0.08625899f, 0.03087969f, -0.03713183f, -0.04978234f, 
    -0.06971755f, 0.01382855f, -0.01447283f, 0.06074280f, 0.06483052f, -0.09866863f, 0.09051927f, 0.15614362f, 
    -0.05939384f, 0.07007781f, 0.10638838f, 0.03080345f, 0.04851844f, 0.10181288f, -0.05881871f, -0.02359158f, 
    -0.02752411f, 0.03740273f, 0.21708548f, 0.13102631f, 0.00062503f, -0.03953082f, 0.02904878f, 0.05457739f, 
    0.13204990f, 0.04489448f, -0.05209998f, -0.02213637f, 0.21221502f, 0.15289572f, 0.21832174f, -0.04451868f, 
    0.06903727f, 0.06394021f, 0.09902790f, 0.02359525f, 0.04673347f, -0.02859348f, -0.01260983f, -0.04834041f, 
    0.10905828f, 0.11963097f, 0.07675033f, 0.05123836f, 0.15225282f, -0.01502797f, 0.15169010f, 0.04168606f, 
    0.00492963f, 0.02747213f, 0.02987857f, 0.02953977f, 0.34371683f, -0.07849556f, 0.03923979f, 0.17130743f, 
    0.13598791f, 0.05161618f, -0.06937134f, 0.04447003f, 0.10280229f, 0.02115616f, 0.06398808f, 0.07065628f, 
    0.03893146f, 0.03071049f, -0.03712821f, 0.04795158f, -0.02694190f, 0.06712093f, -0.06703676f, 0.03439941f, 
    0.02839581f, -0.00764992f, -0.00916329f, 0.08119847f, -0.23035891f, 0.03378368f, -0.06294461f, -0.03415947f, 
    -0.14592405f, -0.08976112f, 0.10359590f, 0.02165525f, 0.04211410f, 0.01547712f, 0.00210637f, 0.01653404f, 
    -0.10366411f, 0.18872280f, -0.06414180f, 0.04285621f, 0.07692141f, 0.06252193f, 0.10956316f, -0.13572338f, 
    0.06481049f, -0.07333404f, 0.04934638f, -0.09752580f, 0.04866490f, 0.15409607f, -0.05360672f, 0.11397018f, 
    0.02114826f, 0.05275148f, -0.02281590f, -0.03777859f, -0.08601768f, -0.02251810f, -0.00329136f, -0.05071256f, 
    0.24930486f, -0.18582910f, -0.01948944f, 0.00878016f, -0.00614540f, -0.07686106f, -0.10210449f, 0.04735498f, 
    -0.05219929f, -0.09063506f, -0.00660759f, 0.01147442f, 0.02895661f, -0.10628351f, 0.03661031f, -0.06593183f, 
    0.02984213f, -0.00956020f, 0.10370383f, 0.00217792f, 0.01256587f, -0.00755532f, 0.04508882f, 0.09348659f, 
    0.20365965f, -0.03502113f, 0.05752239f, 0.19302157f, -0.12188983f, -0.05737250f, 0.00375278f, -0.02626714f, 
    0.03953291f, -0.04351564f, 0.05883618f, -0.02794086f, -0.22309060f, -0.16074605f, -0.14774078f, -0.13282745f, 
    0.05344569f, 0.05623528f, 0.02901352f, -0.04952912f, 0.04649616f, 0.00152053f, 0.14527525f, 0.16016281f, 
    0.14337008f, -0.24252146f, -0.22236440f, -0.14053641f, -0.07023008f, 0.03053760f, 0.05463607f, 0.10362912f, 
    0.11475889f, 0.00447550f, -0.04622526f, 0.01239052f, 0.16342957f, 0.05503588f, -0.05592170f, -0.03903854f, 
    0.06680799f, -0.04591445f, 0.01506771f, 0.08660733f, 0.01443447f, -0.09983471f, 0.02226960f, 0.04370617f, 
    -0.02642738f, 0.07066412f, 0.03043633f, -0.15789154f, 0.06498415f, -0.01729303f, -0.00830283f, 0.05567300f, 
    0.08932505f, 0.02867601f, 0.08410753f, 0.00592818f, -0.03984192f, -0.00406332f, -0.00717730f, -0.03993821f, 
    -0.03947053f, -0.05922441f, -0.06747556f, -0.05594937f, -0.11050526f, 0.04988835f, 0.03435680f, 0.16444372f, 
    -0.10957655f, -0.06382371f, -0.11318032f, -0.02103884f, -0.07794848f, -0.03626864f, -0.04590201f, 0.02672782f, 
    -0.01657950f, 0.08244735f, 0.05432094f, 0.06240012f, -0.10283202f, 0.10135478f, -0.11361174f, -0.10396478f, 
    0.01874524f, 0.05049901f, -0.01056389f, 0.18993826f, 0.04932508f, -0.02175779f, 0.10298423f, 0.05381996f, 
    -0.06525706f, -0.00041663f, -0.07108667f, 0.01153908f, -0.00966580f, -0.06612936f, 0.15627089f, 0.11896566f, 
    0.06321973f, -0.10088208f, 0.11798982f, -0.02842505f, 0.02504041f, 0.14529589f, 0.06070553f, 0.01272912f, 
    0.09483092f, -0.00969272f, 0.02734433f, 0.04707647f, 0.01611624f, 0.04977002f, 0.09467637f, 0.07774885f, 
    -0.23442774f, -0.15548995f, 0.01152293f, -0.13807286f, -0.02307596f, -0.01828782f, 0.14054342f, 0.03408129f, 
    0.02268075f, -0.03452030f, 0.02723565f, 0.02968999f, 0.22216596f, 0.05002882f, 0.06286711f, 0.13277741f, 
    -0.02829713f, 0.12438630f, -0.00362936f, 0.02703112f, 0.14528240f, -0.00098298f, 0.03903387f, 0.05588003f, 
    0.23208162f, 0.06596319f, 0.20989741f, 0.30682564f, -0.15391161f, 0.00657526f, 0.01309318f, 0.03562858f, 
    0.02492237f, 0.14606041f, 0.05233571f, 0.09966104f, 0.16936007f, 0.09877636f, -0.00687642f, 0.01529595f, 
    0.05948352f, 0.00812471f, 0.02151579f, -0.07868496f, 0.11700754f, 0.02176259f, -0.03084049f, 0.01232698f, 
    0.03264894f, 0.15999888f, 0.21773076f, 0.11051434f, 0.07444201f, 0.11342053f, 0.04135543f, 0.05145009f, 
    0.06355450f, 0.05288281f, -0.02303939f, -0.00101020f, -0.05820775f, -0.08610083f, -0.07206135f, -0.15314013f, 
    -0.05977237f, -0.05864080f, 0.08604275f, 0.04023570f, -0.07622340f, -0.02065317f, 0.05382696f, 0.09582383f, 
    -0.20878620f, 0.34190467f, 0.23225798f, 0.10542623f, 0.07005208f, -0.00601388f, 0.01581293f, 0.04332294f, 
    0.03599147f, 0.05258213f, 0.06515554f, -0.07121707f, 0.07252239f, 0.04682823f, 0.07650698f, 0.16388752f, 
    -0.11407394f, -0.02032058f, 0.05627641f, 0.02552598f, -0.00237156f, 0.04682022f, 0.10979301f, 0.11372998f, 
    0.07514226f, 0.00970619f, 0.14657076f, 0.05555579f, -0.11126907f, 0.03655517f, 0.10482536f, 0.09219929f, 
    0.05734370f, 0.12426081f, 0.05486209f, -0.09783396f, 0.05327332f, 0.21485673f, -0.03696516f, -0.05504816f, 
    0.03360929f, 0.03426841f, -0.02663105f, -0.01209792f, 0.15267394f, 0.04267807f, 0.10743638f, 0.01639182f, 
    0.03051827f, -0.14544469f, -0.04817918f, -0.15329084f, -0.07678715f, 0.02311906f, -0.07135218f, 0.09950662f, 
    -0.07015101f, 0.04480418f, 0.04811375f, -0.06585557f, -0.13604262f, 0.04603160f, 0.28236696f, 0.10889110f, 
    0.00119046f, 0.11679573f, -0.04681230f, 0.03776841f, -0.00490599f, -0.02186140f, 0.08919308f, -0.04292370f, 
    0.11559180f, -0.19746700f, 0.00280039f, 0.14320982f, -0.11211002f, -0.00576962f, 0.06602375f, 0.04438625f, 
    0.04049657f, 0.07315396f, 0.00843154f, 0.08168717f, 0.21207663f, -0.03255242f, -0.02617508f, -0.23661335f, 
    -0.00228753f, 0.11215536f, 0.07104663f, -0.00297791f, 0.08285329f, 0.09548678f, -0.02496420f, 0.02345000f, 
    0.11411021f, -0.25881231f, 0.01755316f, -0.12546426f, -0.08416624f, 0.04351096f, 0.01820085f, 0.01112358f, 
    -0.07183874f, 0.06844769f, 0.08716418f, 0.10275785f, 0.05167004f, 0.19053803f, 0.03536541f, 0.10002743f, 
    -0.04538552f, 0.01281483f, -0.00199038f, 0.03273518f, 0.08357894f, -0.04265292f, -0.11434022f, -0.07741215f, 
    -0.03519070f, 0.12871635f, 0.10467898f, -0.06788860f, 0.06737303f, 0.07045874f, -0.04092596f, -0.01723676f, 
    0.01736584f, -0.05478358f, -0.05559535f, 0.13403654f, -0.34673136f, 0.05269044f, 0.03051039f, -0.00783997f, 
    0.05448568f, 0.02682655f, -0.01451658f, -0.04142633f, -0.01113363f, 0.05938051f, 0.09964971f, -0.10967720f, 
    -0.06480434f, -0.08701669f, -0.04453759f, -0.16883868f, -0.10927285f, -0.04921066f, 0.07802200f, 0.02651600f, 
    -0.00529532f, 0.04671618f, 0.03710206f, -0.05020539f, -0.15124306f, -0.00523053f, -0.18355377f, -0.07739853f, 
    -0.09424482f, 0.03658987f, -0.01300466f, 0.02087147f, 0.05580885f, 0.05565291f, 0.02555388f, 0.03157202f, 
    0.23328280f, -0.19640414f, 0.00452723f, 0.06306894f, -0.03720682f, 0.02442330f, -0.00832851f, -0.00497828f, 
    -0.02594604f, 0.02607637f, 0.08027757f, 0.10676559f, 0.01533757f, -0.06238713f, -0.08572333f, -0.19633015f, 
    -0.07155836f, -0.00432761f, 0.02080074f, 0.10977823f, 0.08468627f, 0.06725413f, 0.15211289f, 0.09013262f, 
    0.27097756f, 0.05359204f, -0.09989573f, 0.08142118f, -0.15672618f, -0.10048541f, 0.03901580f, 0.05667164f, 
    0.08150935f, 0.15346785f, 0.06932951f, 0.07766590f, 0.00683411f, -0.12039737f, -0.11094682f, -0.13522232f, 
    -0.05867226f, 0.08528145f, -0.13416421f, 0.02385666f, -0.05178050f, 0.12682527f, -0.02932966f, 0.08171889f, 
    0.12022442f, -0.01988146f, 0.03754008f, -0.02922521f, 0.05826633f, 0.07162446f, -0.01589205f, -0.06957603f, 
    0.09544448f, -0.04109491f, 0.10146759f, -0.04350456f, 0.26664895f, -0.25885063f, -0.02819862f, 0.16973977f, 
    0.07748844f, -0.06902625f, -0.01371194f, 0.05836864f, 0.05935698f, 0.00462203f, 0.08473717f, 0.15481760f, 
    0.31792185f, -0.09815119f, -0.16848007f, -0.14240561f, -0.00297003f, 0.00535295f, 0.00291607f, 0.03350918f, 
    -0.04725812f, 0.04984129f, 0.02086369f, 0.09195214f, 0.00783525f, -0.23379657f, -0.04491634f, -0.01788431f, 
    -0.07434290f, 0.07162713f, 0.05057402f, -0.05524245f, 0.03327285f, 0.00800272f, 0.12597685f, 0.17337386f, 
    0.11121082f, -0.14160384f, 0.11375907f, 0.05317235f, -0.04584824f, 0.07689824f, -0.04503089f, 0.02070669f, 
    0.04609146f, -0.04164548f, -0.09246954f, -0.09537203f, 0.01380495f, 0.04741379f, 0.02339453f, -0.00578048f, 
    0.03193641f, 0.04181610f, 0.03011468f, 0.15585582f, -0.02318667f, -0.01294939f, -0.09513008f, 0.09070347f, 
    0.40961781f, -0.10000500f, 0.13734806f, 0.04936537f, -0.01192024f, 0.15747958f, -0.06468566f, 0.08081949f, 
    0.04108677f, 0.03818157f, 0.13813058f, 0.00421102f, -0.13416147f, 0.08588928f, -0.11346974f, -0.03588868f, 
    0.02746370f, 0.06193917f, 0.01839122f, 0.07212126f, -0.05118779f, 0.08067524f, -0.05858435f, -0.01736053f, 
    0.09589595f, -0.07176425f, 0.04382524f, -0.08595581f, -0.04196263f, 0.02077658f, 0.00509618f, 0.00163691f, 
    0.04917150f, 0.08055971f, -0.08056136f, -0.10421944f, -0.13279034f, 0.03337511f, 0.04012611f, 0.08685588f, 
    0.06953865f, 0.13646193f, 0.03318725f, 0.06813478f, -0.03829104f, 0.04929044f, -0.02482136f, 0.09708080f, 
    0.14744514f, 0.05073828f, -0.02662316f, -0.20248923f, 0.02140841f, 0.03471831f, -0.13648753f, -0.02110039f, 
    0.02294118f, 0.02820676f, -0.02189776f, 0.06404500f, -0.15282889f, -0.12349634f, -0.04082629f, -0.18276769f, 
    -0.03066209f, 0.08887924f, 0.16936669f, -0.00279798f, -0.00111833f, 0.00516252f, 0.09422364f, 0.02372687f, 
    0.21404061f, 0.11388398f, 0.12007570f, -0.07914845f, -0.02734773f, -0.17811070f, -0.06758287f, 0.04266952f, 
    0.01133641f, 0.04254401f, -0.09186612f, -0.08771224f, -0.32340676f, 0.06326520f, 0.00392551f, 0.02143754f, 
    -0.01283110f, 0.04947399f, -0.01728331f, 0.05678928f, 0.07041986f, 0.10366403f, 0.05302499f, -0.11244034f, 
    0.22751132f, 0.02730841f, -0.10354696f, -0.08294827f, 0.03842970f, 0.08509027f, -0.01766720f, 0.00023990f, 
    -0.06171311f, 0.05295074f, 0.09013860f, -0.00149519f, 0.04483989f, 0.08912182f, -0.00845011f, 0.04139498f, 
    0.03736736f, 0.03167014f, 0.10638894f, 0.01769098f, 0.09545562f, -0.01891733f, -0.05364381f, -0.01483393f, 
    0.02837686f, -0.07339354f, -0.01325672f, -0.10222749f, 0.02487433f, -0.04795820f, 0.15969615f, 0.04325548f, 
    -0.01119799f, -0.06402989f, 0.00846343f, 0.09832062f, -0.06489389f, 0.04815639f, 0.02903178f, 0.04686950f, 
    0.06955568f, 0.12652898f, 0.09143957f, -0.00654514f, -0.01518139f, 0.08225255f, -0.13576156f, -0.00516881f, 
    -0.28234586f, 0.00012832f, -0.10168297f, -0.07084953f, 0.01064076f, 0.01517442f, 0.01297522f, 0.14734975f, 
    0.00244635f, -0.06492488f, 0.05108583f, -0.03899239f, -0.37489802f, 0.03589334f, 0.01292991f, 0.08964387f, 
    0.02120315f, 0.09320418f, 0.02046590f, -0.05482455f, 0.06466290f, 0.00260622f, 0.08245242f, -0.01316620f, 
    0.01533355f, 0.09248688f, 0.07053324f, 0.02210101f, -0.00879235f, 0.10893402f, 0.03269045f, 0.02156586f, 
    -0.15783395f, 0.02456211f, 0.03121387f, 0.03757825f, 0.08275783f, 0.00114393f, -0.01477809f, -0.07864306f, 
    0.08299184f, 0.02080901f, 0.03591383f, -0.02826188f, -0.03982738f, 0.00076735f, 0.03531452f, 0.09392780f, 
    -0.16054162f, 0.11330150f, -0.06270722f, 0.05147117f, 0.10933544f, 0.03720711f, 0.11253344f, 0.00349619f, 
    -0.03880642f, -0.05124517f, 0.05516437f, 0.07840278f, 0.13325745f, -0.04944496f, -0.09163969f, -0.17535089f, 
    0.02662187f, 0.03431587f, 0.18563026f, 0.03195794f, -0.17195776f, 0.16660346f, -0.00345403f, -0.20843571f, 
    -0.04701428f, 0.11092246f, -0.01547795f, -0.11305495f, 0.07991649f, -0.01167179f, 0.06961042f, -0.06869562f, 
    0.05469704f, -0.01009561f, 0.02767563f, 0.06497733f, -0.00873009f, -0.07529256f, -0.05747519f, -0.04729573f, 
    0.05638312f, -0.01561823f, -0.01090220f, 0.12425311f, 0.05209643f, -0.03581687f, 0.02794772f, 0.04907872f, 
    0.00047114f, -0.05555683f, -0.10155581f, -0.11098257f, 0.08500110f, 0.08163484f, 0.00239823f, -0.03743844f, 
    -0.03734524f, -0.01644010f, 0.14181449f, -0.02023437f, -0.32387564f, -0.07636660f, -0.08879771f, -0.18677014f, 
    -0.07032136f, -0.02943657f, 0.12928803f, -0.05925334f, 0.01450829f, 0.04355706f, -0.05608791f, 0.01535738f, 
    0.14377777f, -0.23242286f, 0.06873158f, -0.24383628f, -0.02664985f, -0.04887224f, 0.08861879f, -0.01881967f, 
    -0.12371669f, -0.03316979f, -0.00191739f, 0.06179627f, 0.07453371f, -0.13438511f, 0.09368698f, 0.01231475f, 
    0.07448522f, -0.03939901f, 0.05135624f, 0.19089590f, -0.00968061f, 0.08270735f, 0.07506675f, -0.03817454f, 
    0.02566944f, 0.06299265f, 0.06614576f, 0.03126876f, -0.03895244f, 0.11387145f, 0.10795216f, 0.00596807f, 
    -0.02292940f, -0.00377538f, 0.00387883f, 0.09756046f, 0.19472122f, -0.02363466f, 0.00869109f, -0.02348110f, 
    0.02753397f, -0.02282482f, 0.01054202f, 0.13140209f, 0.04546341f, -0.02631021f, -0.11165979f, -0.09815697f, 
    -0.03644828f, 0.17304522f, -0.10673627f, 0.15577073f, 0.05128608f, 0.03201587f, -0.04578884f, -0.01568323f, 
    0.13071804f, -0.09343126f, 0.00209852f, -0.08058006f, -0.09231417f, -0.05077171f, 0.12370787f, -0.16436845f, 
    -0.01434500f, -0.02152227f, 0.06036140f, 0.06526513f, 0.00885546f, 0.14997654f, 0.06288844f, -0.03051742f, 
    0.11001702f, -0.13761796f, 0.06777363f, 0.14762764f, -0.04842474f, -0.01409215f, 0.03968858f, -0.00218795f, 
    -0.07006331f, 0.00473840f, -0.07133044f, -0.01877609f, 0.13319603f, -0.07974480f, -0.09779532f, 0.08681224f, 
    0.00758420f, 0.07557920f, 0.03503907f, 0.15943168f, -0.04495871f, -0.05113732f, 0.01938893f, 0.02812243f, 
    0.10148118f, -0.09905287f, -0.00819371f, -0.10330547f, 0.07630751f, 0.02365224f, -0.07158277f, -0.11106913f, 
    0.11596998f, -0.09740338f, -0.00501178f, 0.00134714f, 0.12435764f, 0.11071157f, 0.03426161f, -0.05796916f, 
    -0.02002133f, 0.06956097f, 0.05864555f, -0.07463833f, -0.11591766f, 0.02135668f, -0.00835119f, -0.00326881f, 
    0.14645435f, -0.14590248f, -0.01263274f, 0.17292731f, -0.03515135f, -0.05412343f, 0.08870494f, 0.06749394f, 
    -0.07506276f, 0.11146875f, -0.00030350f, 0.02244956f, 0.11479222f, -0.15694384f, -0.06221720f, 0.17847972f, 
    0.02300842f, -0.19815439f, 0.05985729f, 0.02472130f, 0.01567825f, -0.12452576f, -0.10366288f, -0.12870550f, 
    -0.03417470f, -0.21315753f, 0.01752588f, -0.00613511f, 0.03616258f, 0.02399216f, 0.07048244f, -0.04499221f, 
    0.03360401f, 0.12586802f, -0.01321047f, 0.01603618f, 0.00471902f, -0.02239045f, 0.10452386f, -0.00091285f, 
    -0.05856762f, 0.03630492f, 0.06632501f, 0.03552238f, 0.03168193f, 0.00097304f, 0.15961087f, 0.02122773f, 
    0.05019710f, 0.09782483f, 0.14074667f, 0.00088836f, 0.01532543f, 0.06231632f, 0.06628086f, -0.00539353f, 
    -0.01715880f, -0.06027928f, 0.00144416f, 0.00271357f, -0.13212006f, 0.04027037f, 0.06298187f, 0.09529454f, 
    0.02218090f, -0.06141801f, -0.11110697f, 0.02936048f, 0.01963813f, 0.03054854f, 0.06197291f, 0.01356488f, 
    0.04590663f, -0.04760375f, -0.09212326f, -0.13110173f, 0.10272805f, 0.10423651f, -0.04695114f, -0.02690346f, 
    -0.14060484f, 0.02565841f, 0.05331239f, 0.12711535f, 0.05733398f, -0.20460397f, -0.07435986f, 0.14114936f, 
    0.04058487f, 0.02702623f, -0.01264379f, 0.09381984f, 0.07983723f, 0.02914017f, 0.08400285f, 0.04998981f, 
    -0.02380695f, 0.12625705f, -0.05783049f, 0.01786819f, -0.01157605f, -0.03447947f, 0.11624561f, 0.03998578f, 
    -0.02993738f, 0.01376265f, -0.10627215f, 0.14460851f, 0.17348284f, 0.09041803f, 0.06195105f, 0.03786806f, 
    -0.03633555f, 0.11640400f, -0.03121756f, 0.06952514f, 0.01950338f, 0.00346973f, 0.03958244f, -0.06201184f, 
    0.09463561f, 0.10061826f, 0.17637482f, -0.00387006f, -0.03547597f, 0.10490899f, 0.04323722f, 0.01263392f, 
    -0.00743107f, -0.00225119f, -0.17980206f, 0.08794184f, -0.01806591f, 0.12854989f, 0.03262833f, 0.10125621f, 
    -0.04297565f, -0.06273528f, 0.04436353f, 0.11878015f, -0.13643581f, -0.11861878f, -0.11003264f, 0.08516511f, 
    -0.05112634f, 0.24795301f, -0.07932466f, -0.00731963f, -0.05768799f, 0.07209709f, 0.00546248f, -0.06614265f, 
    0.02468582f, 0.02448143f, -0.01591091f, -0.01198461f, 0.02951746f, -0.05062536f, 0.13584206f, -0.07819106f, 
    -0.00914576f, -0.02500017f, 0.08455753f, 0.09355319f, 0.03443377f, -0.00217771f, 0.01407176f, 0.09553313f, 
    0.01613163f, 0.22600739f, -0.08142024f, 0.04340466f, 0.05404790f, -0.00048885f, -0.17914428f, 0.06027447f, 
    -0.03429341f, 0.04451269f, 0.06041615f, -0.13729545f, -0.21861620f, -0.11534559f, 0.04287972f, 0.09618314f, 
    0.04344436f, -0.01799421f, 0.10373499f, -0.02535237f, 0.00943198f, 0.10058195f, -0.06566089f, -0.00200311f, 
    0.06497194f, 0.19149829f, -0.27072591f, 0.06035161f, -0.02808016f, -0.00761076f, -0.01059929f, 0.04203084f, 
    -0.02771169f, -0.01410111f, -0.03341353f, -0.05993736f, 0.08775413f, 0.13255851f, 0.04948471f, -0.04092580f, 
    0.04841559f, 0.04643416f, 0.06988405f, -0.07128109f, -0.03824572f, -0.01819677f, -0.03533010f, 0.05150088f, 
    0.28432575f, -0.16696827f, -0.13324003f, -0.10443199f, 0.06196394f, 0.05610074f, 0.07393631f, -0.00060425f, 
    -0.07906823f, 0.07434990f, 0.04336827f, -0.10625047f, -0.11150387f, -0.07278664f, -0.06325120f, 0.04218557f, 
    -0.05048595f, -0.04311726f, -0.04722640f, 0.13915449f, -0.04772801f, -0.03668294f, 0.04371802f, -0.01411258f, 
    -0.20053153f, 0.05814432f, -0.11382977f, 0.16197084f, 0.11810066f, 0.02576810f, -0.02170160f, 0.03270119f, 
    0.03083535f, 0.00862885f, -0.03439748f, 0.06061719f, -0.12150579f, -0.13554837f, 0.01856822f, -0.21729483f, 
    0.13463895f, -0.01924803f, -0.06510182f, -0.04575448f, 0.03319326f, -0.00351200f, 0.13043372f, -0.01760411f, 
    0.08680579f, 0.01648529f, 0.06875131f, -0.03931257f, -0.04461394f, 0.00676238f, 0.03656038f, 0.10236285f, 
    -0.01698008f, -0.00910174f, 0.06953233f, -0.00613487f, 0.03851011f, 0.10491972f, -0.06114457f, 0.11322418f, 
    0.07669472f, 0.04897998f, 0.04867166f, -0.00599017f, 0.08443413f, -0.04241115f, 0.03096461f, -0.07230041f, 
    -0.07387328f, 0.00385806f, -0.00087603f, 0.01346085f, -0.04275325f, -0.06033521f, 0.01101052f, -0.01937902f, 
    -0.06109772f, -0.00291431f, 0.01514442f, -0.07804540f, -0.05992104f, -0.01830248f, -0.03245749f, 0.07577511f, 
    0.01967605f, -0.02204878f, 0.06347384f, 0.07585887f, -0.00295053f, -0.08775819f, 0.12541537f, -0.00660019f, 
    -0.14566331f, 0.05380833f, 0.01560005f, 0.17379862f, -0.03326985f, 0.08649372f, 0.05183401f, 0.03804358f, 
    -0.01057562f, 0.04686982f, -0.12146477f, -0.06905561f, 0.02712505f, -0.11497106f, -0.04563740f, 0.02271924f, 
    -0.06680786f, -0.00796724f, -0.00965337f, 0.09102058f, -0.12623169f, -0.02144406f, -0.09535396f, -0.04438496f, 
    -0.00920786f, -0.07926904f, -0.04935298f, -0.06175486f, -0.00431787f, 0.05669314f, 0.00593462f, 0.08233690f, 
    0.09279674f, 0.00422848f, 0.05185601f, -0.06518661f, 0.16409437f, -0.05578955f, -0.10261765f, -0.02088117f, 
    0.01874051f, -0.06509397f, 0.03409210f, 0.02208547f, -0.01859941f, -0.02068271f, -0.00119162f, -0.07445241f, 
    0.07564954f, 0.08527063f, -0.09004394f, -0.18681057f, 0.10069277f, 0.05321365f, 0.02678662f, -0.02365508f, 
    -0.06867601f, 0.06036032f, 0.06610949f, 0.09716149f, 0.31939158f, -0.06309097f, -0.18620256f, 0.09601000f, 
    0.05245050f, 0.00290278f, -0.07065810f, 0.07433449f, -0.02109993f, -0.04811009f, 0.04486645f, -0.01160093f, 
    0.01230681f, -0.10599965f, -0.01185576f, 0.02568332f, 0.02674794f, 0.02637646f, -0.09221306f, -0.01270085f, 
    -0.03356300f, -0.01036340f, -0.13765991f, 0.03938041f, 0.16312233f, -0.03523260f, 0.07328837f, -0.04066106f, 
    0.04374379f, 0.08613493f, -0.02130330f, -0.01198236f, 0.06494253f, 0.06404435f, 0.02131493f, 0.01231298f, 
    -0.03690400f, 0.03804874f, 0.02495689f, 0.00325578f, 0.02467442f, 0.02072941f, -0.02931818f, 0.01962543f, 
    0.03737533f, 0.01581731f, 0.01408298f, 0.02505893f, -0.02394436f, -0.03306757f, 0.02780608f, -0.00746737f, 
    -0.02410012f, -0.01591266f, 0.01985421f, -0.03800190f, -0.03738293f, 0.00250103f, 0.02514228f, 0.02722754f, 
    0.02863915f, 0.02416487f, -0.02583592f, -0.02798514f, -0.00837521f, 0.02446860f, -0.01445075f, -0.02555949f, 
    -0.00109371f, -0.01610506f, -0.00980552f, 0.01502127f, 0.01375132f, -0.01601484f, 0.00228019f, 0.01023846f, 
    -0.00037855f, -0.00409842f, -0.02067490f, -0.01325717f, 0.03048328f, 0.02304518f, 0.01712308f, 0.02855637f, 
    0.01840386f, -0.03600075f, 0.00110743f, -0.02463824f, -0.02694991f, 0.01107467f, -0.00551998f, -0.01910772f, 
    0.01418204f, -0.03002180f, -0.01985130f, 0.00984209f, -0.03859815f, 0.02800237f, 0.02217118f, -0.03208637f, 
    -0.00112442f, -0.03506817f, -0.03095246f, 0.01541384f, 0.00807334f, 0.01795501f, -0.02234589f, -0.01024259f, 
    -0.01782105f, -0.01974646f, -0.01601789f, -0.03910036f, -0.00723235f, 0.01064249f, 0.00572458f, -0.00319210f, 
    0.00410564f, 0.03159851f, -0.03049359f, 0.01586565f, 0.00338079f, -0.00647306f, 0.00773659f, 0.02549522f, 
    0.01359391f, -0.03415389f, 0.01531306f, 0.02909548f, 0.01633240f, -0.01023422f, 0.02281458f, 0.00680487f, 
    -0.00217932f, 0.00144800f, 0.01544011f, 0.01133057f, -0.00785079f, 0.01492588f, -0.03676876f, 0.02614784f, 
    0.03789975f, 0.02943299f, 0.02331854f, 0.01574301f, -0.01663274f, 0.01777316f, -0.00732589f, -0.00912827f, 
    -0.01710443f, 0.01559140f, -0.02587174f, 0.03795377f, 0.04032231f, -0.00248924f, 0.02897719f, 0.03248353f, 
    0.01697440f, -0.03504278f, 0.01233936f, -0.01024832f, -0.02750014f, 0.02693663f, -0.03252895f, -0.00911572f, 
    -0.01644910f, -0.02994962f, -0.00267459f, -0.01892188f, 0.01163354f, -0.01088229f, 0.01237044f, 0.00559911f, 
    0.02028370f, -0.02885529f, 0.01631272f, 0.01091043f, -0.00917404f, -0.01090334f, 0.00114271f, -0.00646465f, 
    -0.03797337f, 0.01972462f, -0.00828729f, 0.03477689f, -0.00030272f, -0.03532815f, -0.00581378f, -0.01704572f, 
    -0.03932016f, -0.02918253f, -0.02889102f, -0.01535576f, 0.02743501f, -0.00613947f, 0.00838383f, -0.00239346f, 
    -0.01884103f, 0.03067194f, -0.01138804f, -0.00070158f, -0.02541855f, -0.00531889f, -0.00473418f, 0.00140970f, 
    0.01347093f, 0.01832686f, -0.03154857f, -0.01191971f, 0.02151015f, -0.00478981f, -0.01551452f, -0.00020091f, 
    -0.04222456f, 0.02566510f, -0.02672277f, -0.02504068f, 0.00214874f, 0.01561777f, 0.03785779f, -0.02512435f, 
    0.04333610f, -0.03559095f, -0.00536031f, -0.02163525f, -0.03672286f, -0.01073403f, -0.02938339f, 0.01519047f, 
    0.02635213f, 0.00614605f, -0.01517531f, 0.02368304f, 0.01191935f, 0.00576649f, 0.02715721f, -0.01671434f, 
    0.02357335f, 0.02870991f, -0.01389527f, 0.01189213f, 0.01513474f, -0.02411879f, 0.02304515f, -0.00984433f, 
    0.01536977f, 0.01870920f, -0.02458045f, -0.01590776f, 0.01343555f, 0.01960866f, -0.03237947f, -0.03699290f, 
    -0.03749104f, 0.01206052f, 0.00186558f, 0.02489693f, -0.00012427f, 0.01059046f, -0.03099925f, 0.02831721f, 
    -0.01100835f, 0.01756149f, -0.02456538f, 0.02026702f, -0.01050444f, -0.03697065f, 0.01965526f, -0.02952085f, 
    -0.02067185f, 0.01523952f, 0.01880975f, -0.01634719f, -0.02196449f, 0.02778943f, 0.00029016f, -0.01460600f, 
    0.01117064f, -0.01810664f, 0.01539606f, 0.00157810f, 0.02314044f, -0.02567695f, -0.00375980f, 0.02776296f, 
    0.01977806f, -0.00881912f, 0.03220190f, -0.01277678f, 0.00918705f, 0.00660763f, -0.01095844f, -0.02173536f, 
    -0.03776837f, 0.02987826f, 0.01819142f, 0.00733678f, -0.02846285f, 0.01465460f, -0.01724107f, 0.01135958f, 
    -0.02415561f, 0.00408071f, 0.02833387f, -0.01592920f, 0.00856710f, 0.01739844f, 0.02167794f, -0.01246270f, 
    -0.02691023f, -0.02083571f, -0.00057515f, -0.04064822f, 0.01421268f, -0.01746774f, -0.00390828f, -0.01201282f, 
    -0.03762966f, -0.02770268f, 0.00567315f, 0.01224736f, 0.01286685f, 0.00797635f, -0.03643214f, -0.00059757f, 
    0.01689083f, 0.01558787f, -0.00781766f, 0.03575440f, -0.03786995f, 0.00984233f, 0.01980085f, 0.00167328f, 
    -0.02114731f, -0.03961971f, 0.00454918f, -0.01202994f, 0.01469138f, -0.02910397f, -0.04050089f, -0.03413036f, 
    -0.01560814f, -0.02609481f, -0.02551347f, 0.02317298f, 0.02893298f, 0.01262734f, -0.03286992f, -0.03824697f, 
    -0.03380150f, -0.02052778f, 0.00429841f, -0.01716947f, -0.03683328f, 0.00262869f, 0.00926831f, 0.03683755f, 
    -0.01871868f, 0.02423483f, -0.01023774f, 0.02773814f, 0.01665167f, 0.04091586f, 0.00635021f, 0.04217750f, 
    0.02802131f, -0.01136616f, 0.02414013f, -0.01233248f, 0.00492906f, -0.02202032f, -0.03904713f, -0.00009026f, 
    -0.00063946f, -0.01587421f, -0.04035631f, -0.02091713f, 0.01369114f, -0.01130339f, -0.01516106f, 0.02562414f, 
    -0.00008093f, -0.01405663f, 0.00184559f, -0.01586074f, 0.01038086f, -0.00412674f, -0.01975463f, -0.00631070f, 
    -0.00690804f, 0.03317808f, 0.02671250f, 0.02485743f, 0.02863743f, 0.00709662f, 0.01129317f, 0.00176055f, 
    -0.02808059f, -0.00248444f, -0.01597485f, -0.02525529f, -0.03396419f, 0.00506990f, -0.01800299f, 0.02627036f, 
    0.01202785f, -0.01812754f, 0.01977021f, 0.01170953f, -0.02213954f, -0.03479987f, -0.02640364f, 0.02068703f, 
    0.00479045f, -0.01978505f, 0.00553633f, -0.00233042f, 0.02838496f, 0.01857393f, 0.00097930f, 0.01369729f, 
    0.03365196f, 0.01732707f, 0.00435408f, 0.02099328f, -0.03275135f, -0.03213688f, 0.01714878f, -0.03390096f, 
    -0.01483480f, -0.01509893f, -0.01719086f, 0.02996337f, -0.01017380f, -0.01357636f, 0.01484753f, -0.02623121f, 
    0.01413960f, 0.01669147f, -0.00022257f, -0.03633657f, -0.01945748f, -0.00515935f, -0.00822419f, -0.02341256f, 
    0.00380068f, -0.03372327f, 0.02740308f, -0.00786832f, -0.02436142f, -0.02110381f, -0.02516460f, 0.00091054f, 
    -0.03740776f, -0.03784902f, 0.02946373f, 0.00189988f, -0.03243021f, -0.01960622f, -0.03732274f, -0.03874135f, 
    0.00650691f, 0.02193967f, 0.01492009f, 0.02634641f, -0.02004992f, 0.02074717f, -0.02179481f, 0.03365667f, 
    -0.02459306f, -0.02348845f, -0.01788402f, -0.00004271f, 0.02668986f, -0.01023018f, -0.03366043f, 0.03074737f, 
    -0.02317229f, -0.02265616f, -0.02036010f, -0.02668056f, 0.02369258f, -0.00752213f, -0.01316251f, -0.00029196f, 
    -0.03891564f, 0.03053277f, 0.02362032f, -0.02890166f, -0.03020000f, 0.00197550f, -0.00539212f, 0.00001911f, 
    0.02259336f, -0.01754773f, 0.01083789f, 0.00963967f, 0.01743411f, 0.01465490f, 0.02427322f, 0.01836578f, 
    -0.00879717f, 0.00115802f, 0.01823004f, 0.00307413f, -0.03643076f, -0.01901306f, 0.02975773f, -0.00820305f, 
    -0.00791231f, 0.02411619f, -0.01186415f, 0.00965018f, 0.01095801f, 0.00467686f, -0.00770728f, -0.03164669f, 
    -0.01358213f, 0.00472544f, -0.01647804f, -0.01520547f, 0.01561985f, 0.01192558f, 0.01634058f, 0.00680652f, 
    -0.01098376f, 0.01211533f, 0.01459424f, 0.02737549f, 0.01779287f, -0.00513114f, -0.00102894f, 0.00942859f, 
    -0.03311565f, 0.00302574f, -0.01744468f, -0.02725456f, -0.00940816f, 0.01819539f, -0.01649567f, -0.03311345f, 
    0.00573764f, -0.03723175f, -0.01881616f, -0.03137250f, -0.01225788f, -0.01965695f, -0.03073844f, 0.00216761f, 
    0.02533518f, -0.01860350f, 0.00999184f, -0.03625190f, 0.02063311f, 0.02431493f, -0.01075704f, 0.00504553f, 
    0.02725063f, -0.00436272f, -0.00537710f, -0.00590886f, -0.01838530f, -0.03623920f, 0.00338191f, 0.00796491f, 
    -0.01523877f, 0.01546990f, -0.00643275f, 0.00243104f, -0.03821031f, -0.02030902f, -0.01991926f, 0.02334902f, 
    0.03137181f, -0.02860818f, -0.02923117f, 0.02593985f, -0.00249624f, -0.03919312f, -0.01012641f, -0.00444347f, 
    0.00519992f, -0.00727177f, 0.03246528f, 0.02538637f, -0.03431593f, 0.02057978f, 0.01501215f, 0.02550166f, 
    -0.02435248f, 0.01091618f, -0.02573150f, 0.01046941f, -0.01639211f, 0.00640373f, -0.03693290f, 0.00110116f, 
    -0.01410391f, 0.02842617f, 0.02953922f, -0.00064064f, -0.02835694f, -0.03279883f, 0.01283262f, -0.01431735f, 
    -0.03359401f, 0.00303453f, -0.01472512f, -0.02889868f, -0.02808725f, 0.02777945f, -0.00826116f, -0.04037543f, 
    -0.01554860f, 0.02895577f, -0.01588321f, -0.02263879f, 0.02371689f, -0.01568212f, -0.00170276f, -0.02610834f, 
    0.02941698f, 0.02879637f, -0.01678406f, 0.01445353f, -0.01389999f, -0.01059199f, -0.00776242f, -0.01014508f, 
    0.03144051f, 0.01926467f, -0.00964887f, 0.03505683f, 0.00579719f, -0.01096364f, 0.03281147f, -0.01559692f, 
    -0.01631133f, -0.03058906f, -0.03291889f, -0.02505553f, -0.03559617f, -0.03491335f, 0.01200462f, 0.01962839f, 
    0.02512725f, 0.02561707f, 0.01284569f, -0.03926997f, -0.03352911f, -0.01669778f, -0.01394724f, -0.02011829f, 
    0.00154659f, 0.02602153f, 0.01577521f, 0.00281427f, 0.03652276f, 0.02120256f, 0.01613537f, -0.02736499f, 
    -0.00031050f, 0.01952847f, -0.03719572f, -0.00021360f, 0.01170912f, 0.02602658f, 0.03271275f, -0.03032583f, 
    -0.02534866f, 0.00222803f, -0.02646558f, -0.00804222f, -0.00689443f, -0.02164465f, -0.03192267f, -0.00348489f, 
    0.03248159f, -0.01137186f, 0.03761301f, -0.03693582f, 0.03547925f, -0.02938862f, 0.02124752f, -0.00483138f, 
    -0.00022905f, -0.03832462f, -0.02918605f, -0.02438029f, -0.03203089f, 0.00959477f, -0.00642026f, 0.01346431f, 
    0.03794209f, -0.01492890f, 0.00572415f, 0.02676737f, -0.00844417f, 0.03597302f, 0.00581947f, -0.01627606f, 
    -0.03929944f, -0.00313355f, 0.00453666f, -0.01622150f, 0.02122602f, 0.00339767f, 0.00328317f, 0.00954608f, 
    -0.02814480f, 0.00232418f, -0.01286574f, -0.02277057f, 0.03064786f, -0.00391505f, -0.00066005f, -0.01032619f, 
    -0.02207713f, -0.00619010f, 0.02633093f, 0.01242943f, -0.01997492f, -0.03210550f, 0.00143586f, -0.00448948f, 
    0.01716987f, 0.01116761f, 0.03729000f, -0.00024664f, -0.02079600f, -0.02770912f, -0.02917618f, 0.01208383f, 
    0.00252553f, -0.01964968f, -0.00503539f, -0.00967900f, -0.00438797f, -0.02885765f, 0.01452257f, -0.00033518f, 
    -0.00463979f, 0.00505828f, -0.02506155f, -0.02221481f, 0.01529197f, 0.00659169f, -0.00831649f, -0.02935141f, 
    0.01513384f, 0.01596148f, 0.00365652f, 0.00901045f, -0.00184307f, -0.02519034f, -0.01647174f, -0.00451060f, 
    0.03203926f, 0.02853460f, -0.02144409f, -0.00509791f, -0.02095021f, 0.00407122f, 0.01378863f, -0.03305807f, 
    -0.03164488f, -0.03029957f, 0.02516158f, -0.00785404f, -0.01325645f, 0.01690460f, -0.02120276f, -0.00952073f, 
    0.02808343f, 0.00320478f, -0.02190396f, -0.01660963f, 0.00742535f, 0.00911762f, -0.03046083f, 0.00916334f, 
    -0.01313801f, -0.03315347f, -0.02216323f, 0.03934119f, 0.00393136f, 0.01530992f, 0.02626360f, -0.03155758f, 
    -0.01601213f, 0.02512971f, 0.00621699f, -0.02571824f, -0.04138567f, -0.01450134f, -0.02397757f, -0.03854081f, 
    0.03032806f, -0.01952338f, 0.00468541f, 0.02985896f, 0.01475878f, -0.00767991f, -0.01224747f, 0.00443987f, 
    -0.17333731f, 0.10874904f, 0.10458621f, -0.14472233f, -0.02989631f, 0.01720973f, 0.06263287f, 0.11891017f, 
    0.03264746f, -0.00399622f, -0.05697149f, -0.02130868f, 0.12845458f, -0.03251065f, -0.03816014f, -0.09713300f, 
    -0.00932377f, -0.00325296f, -0.07966356f, -0.04398742f, 0.14379777f, 0.01673073f, 0.01491213f, -0.05735052f, 
    0.24180351f, 0.02415255f, -0.03246392f, 0.35199195f, -0.01624329f, -0.00926957f, 0.12518157f, 0.01398127f, 
    0.04489162f, -0.03474556f, 0.13503380f, -0.02390507f, 0.15679900f, 0.08603018f, 0.05133079f, -0.14165679f, 
    -0.04378155f, 0.05278558f, 0.02474401f, 0.01644514f, -0.04028448f, 0.03072485f, -0.04553787f, -0.05527001f, 
    0.14597173f, 0.00516487f, 0.00822179f, -0.03265502f, 0.00805009f, 0.06626999f, 0.08466492f, 0.05027625f, 
    -0.06235346f, 0.03642047f, 0.09341758f, -0.00505410f, 0.00378666f, 0.15332162f, 0.14466128f, -0.23055311f, 
    0.10423385f, -0.04153983f, 0.12852031f, 0.01781151f, -0.06000172f, 0.01840732f, -0.07770437f, 0.05952818f, 
    -0.00586899f, -0.03928467f, 0.11339412f, 0.14810035f, 0.00756824f, 0.00153183f, 0.03049370f, -0.11969624f, 
    0.07124766f, 0.00451611f, -0.03962633f, -0.13500199f, 0.09750549f, -0.03069866f, -0.00700045f, 0.22135475f, 
    -0.00949673f, -0.02848838f, -0.05540842f, -0.04867420f, -0.00638212f, 0.03453786f, 0.03781669f, 0.06233968f, 
    -0.08774544f, -0.23976398f, 0.06075327f, -0.24608959f, -0.03349346f, 0.00547599f, 0.02463151f, -0.01009978f, 
    -0.02881899f, -0.04760391f, 0.04089801f, 0.00587234f, 0.02430158f, 0.03314939f, -0.02999441f, 0.01422563f, 
    0.01701680f, 0.03724687f, 0.02995864f, 0.12404931f, 0.00080923f, 0.06444331f, 0.07305178f, 0.09943488f, 
    0.20155157f, 0.19108376f, 0.11346694f, -0.15347441f, 0.09247794f, 0.06761280f, -0.01375795f, 0.03479756f, 
    -0.01737339f, 0.09326993f, -0.03879797f, 0.16387133f, 0.22903928f, 0.11251399f, 0.01004031f, 0.19273610f, 
    -0.08018864f, 0.01091433f, 0.13970545f, -0.00461118f, 0.09946777f, 0.04119850f, -0.10736416f, -0.01538556f, 
    -0.08373678f, 0.01375640f, 0.00181376f, 0.24168597f, -0.04235443f, 0.00304458f, -0.00929106f, 0.05336127f, 
    0.03214693f, -0.02089540f, -0.09378208f, -0.06947083f, -0.09758556f, -0.02143827f, 0.14328462f, 0.07450444f, 
    0.05865584f, 0.04878025f, -0.11407869f, -0.09777111f, -0.00230985f, -0.03266464f, -0.01959210f, -0.05969941f, 
    0.06594771f, 0.14017756f, -0.05611279f, 0.10718698f, -0.05262454f, 0.07792763f, 0.06727001f, -0.03419825f, 
    -0.03637610f, 0.02164653f, -0.02956495f, -0.07075626f, 0.05316615f, -0.10005494f, 0.06930043f, 0.10344133f, 
    0.08555897f, 0.01989619f, -0.12045157f, -0.11090729f, 0.03300606f, -0.04370896f, 0.09701035f, 0.03748558f, 
    0.33944097f, 0.21715601f, 0.05014325f, 0.08779451f, -0.02850590f, 0.04543878f, -0.05463380f, 0.05445371f, 
    0.00175196f, 0.01156082f, 0.00799490f, -0.04697726f, -0.05610956f, -0.04719555f, 0.12866187f, 0.01865152f, 
    -0.00947783f, 0.01648751f, 0.08952541f, 0.08061850f, 0.06366616f, 0.00279465f, 0.03038588f, 0.03695142f, 
    -0.06062363f, -0.03306459f, -0.10617854f, 0.18708311f, 0.02821134f, 0.02817283f, 0.11027525f, -0.01940760f, 
    0.04424728f, 0.00279641f, -0.06454308f, -0.02502083f, 0.33183947f, 0.17437410f, 0.04325799f, -0.01844041f, 
    0.08988543f, 0.07292213f, -0.00311765f, -0.05463160f, 0.05621044f, -0.02606758f, 0.04370178f, 0.00647816f, 
    0.22446586f, -0.07702775f, 0.09003437f, -0.06149566f, -0.03438132f, 0.01628479f, -0.01872484f, -0.03597940f, 
    -0.04106004f, 0.00737976f, -0.00802160f, 0.01084514f, -0.21743079f, 0.01768100f, 0.24425760f, -0.17737678f, 
    0.06423935f, -0.00447365f, 0.02557425f, 0.01723177f, 0.02233589f, -0.02537606f, 0.01415302f, 0.09163587f, 
    0.06671675f, 0.07313786f, 0.02168647f, 0.24141064f, -0.06433678f, -0.04625337f, -0.06062140f, -0.04970603f, 
    -0.02988203f, -0.03727197f, 0.00912579f, -0.04831307f, -0.04193508f, -0.00983292f, 0.13103779f, -0.02020729f, 
    0.11241909f, 0.06911032f, 0.10302221f, 0.03897493f, 0.00209311f, 0.09429394f, 0.19054167f, 0.13099325f, 
    0.03839711f, -0.05811374f, 0.01876348f, 0.00442903f, 0.07877973f, -0.05372272f, 0.02470875f, 0.08860250f, 
    0.05650279f, 0.12063154f, -0.00832526f, 0.13581844f, -0.18667191f, 0.04572264f, 0.01960042f, -0.20659405f, 
    0.01225179f, -0.01345830f, -0.01725297f, 0.00001636f, 0.02956041f, -0.11879509f, -0.08288074f, 0.05005496f, 
    -0.08107938f, -0.01322323f, 0.01288800f, -0.01099797f, 0.01401770f, 0.00643862f, -0.01989232f, 0.03668193f, 
    0.11317608f, -0.00901543f, 0.14347883f, -0.06856973f, -0.15493259f, -0.10649598f, 0.18022257f, 0.25240573f, 
    -0.00756615f, -0.01454551f, 0.02846807f, 0.09655144f, 0.10204974f, 0.08091582f, 0.00447412f, -0.00051945f, 
    0.12930456f, 0.08936235f, 0.06975353f, 0.09655255f, -0.00647428f, -0.05447620f, 0.04770106f, 0.09634610f, 
    -0.05727011f, 0.12987572f, 0.00804806f, 0.05968730f, -0.19328083f, -0.02652277f, 0.02386000f, 0.00132945f, 
    0.16728690f, 0.13306269f, 0.07391979f, 0.13542497f, 0.09488390f, 0.04710561f, 0.09829798f, -0.04653753f, 
    0.10501876f, 0.09949699f, 0.00195168f, -0.00397189f, -0.09505301f, 0.01463409f, 0.08362618f, 0.08206150f, 
    0.04171722f, -0.08060470f, 0.02767331f, -0.02746625f, 0.18424031f, 0.17412072f, -0.03891115f, -0.04595135f, 
    0.06221080f, 0.06684741f, -0.02880773f, 0.03859283f, -0.01250889f, 0.13301711f, 0.10702148f, 0.04913159f, 
    -0.14108968f, -0.03682419f, -0.12012288f, -0.11526080f, 0.02807074f, 0.02071156f, 0.11016603f, -0.03669733f, 
    0.03692955f, -0.05933125f, -0.05274587f, -0.03515130f, 0.25414801f, 0.22673988f, -0.01756578f, 0.12874444f, 
    -0.04828232f, 0.06837022f, -0.09542991f, 0.04345568f, -0.00432633f, 0.08556525f, -0.11537023f, -0.01723726f, 
    -0.05843271f, 0.03883296f, 0.10310303f, 0.38936585f, -0.10030127f, -0.02687476f, -0.04336135f, 0.02162099f, 
    -0.06251380f, 0.08810752f, -0.04437358f, 0.03871328f, -0.02468108f, 0.09792089f, -0.03745243f, -0.11422756f, 
    -0.03757298f, -0.01568061f, 0.08223112f, 0.00154976f, -0.02761141f, -0.01707575f, -0.01326177f, -0.00178160f, 
    0.17974751f, -0.02946998f, -0.02569343f, 0.11837919f, 0.01790793f, 0.01833060f, 0.03467976f, -0.15463319f, 
    0.10083646f, -0.02933400f, -0.11118778f, -0.12535207f, 0.01724535f, 0.00983223f, 0.11907098f, -0.04743893f, 
    -0.04432939f, -0.02472239f, 0.10101208f, 0.17413777f, -0.03034707f, -0.04619795f, -0.08379196f, 0.11420114f, 
    -0.02920929f, 0.17788780f, 0.13329938f, -0.01048935f, -0.04281857f, 0.00689917f, -0.02239140f, 0.08262713f, 
    -0.04436733f, 0.00848066f, 0.12290201f, -0.06782345f, 0.06985168f, -0.01360354f, 0.09310380f, 0.29168957f, 
    -0.01495140f, -0.04715674f, 0.10157897f, -0.03125396f, 0.01795350f, 0.10818437f, 0.06604683f, 0.10476796f, 
    -0.09401856f, 0.05641483f, 0.04279539f, 0.01914849f, -0.09878995f, -0.08415063f, 0.00333965f, -0.06795090f, 
    0.09134952f, 0.05087350f, 0.12928686f, -0.11512743f, -0.09647531f, 0.00892156f, -0.14222993f, -0.19993977f, 
    0.00462279f, 0.07609868f, -0.03008067f, -0.03086902f, 0.08864890f, -0.07596166f, 0.06825713f, 0.08374058f, 
    0.04988614f, -0.01981934f, 0.05348008f, -0.09014082f, -0.01398796f, 0.00717133f, -0.05033587f, 0.04139999f, 
    0.03285462f, -0.03836087f, -0.05729270f, -0.00715691f, -0.05986528f, -0.04527193f, 0.08843248f, 0.15011114f, 
    0.02265853f, 0.00512081f, -0.05120541f, 0.00380699f, 0.03691023f, -0.02583064f, 0.01167819f, -0.05211401f, 
    -0.00761103f, -0.00262897f, -0.04474734f, 0.16360883f, -0.08379559f, 0.09881562f, 0.27630135f, -0.00352442f, 
    0.04445491f, -0.05995727f, 0.00376739f, 0.10895149f, 0.08139257f, 0.02113510f, -0.00879430f, -0.31111684f, 
    -0.00752711f, 0.04503402f, 0.02774171f, -0.10536354f, 0.00839017f, -0.02305798f, 0.08745611f, 0.00826608f, 
    0.09412231f, -0.03884442f, 0.13167273f, -0.03407910f, -0.02014929f, 0.12448485f, 0.01400870f, 0.05380305f, 
    -0.04726863f, 0.07178044f, 0.01822839f, 0.11920633f, 0.11434886f, 0.00707343f, -0.06155914f, 0.11692750f, 
    -0.02353222f, -0.00366925f, -0.04467637f, 0.04855656f, 0.07135799f, -0.08301216f, -0.03450229f, -0.01809523f, 
    -0.23236969f, -0.19399481f, 0.21498473f, 0.01437218f, 0.01154129f, 0.10990006f, -0.08090872f, 0.03854069f, 
    0.08303048f, -0.00188041f, -0.04569437f, 0.06809513f, -0.27317417f, 0.01020150f, 0.07179049f, 0.01571469f, 
    0.05739909f, 0.07390612f, 0.03826341f, -0.07427961f, 0.06484497f, -0.00671507f, 0.08192981f, -0.05431290f, 
    0.06105776f, -0.06995216f, 0.14420667f, -0.08531146f, -0.00993394f, 0.00167309f, 0.09655208f, 0.09671467f, 
    0.05857140f, -0.07047838f, 0.04879674f, 0.05280038f, 0.04980810f, 0.04805125f, 0.09990889f, -0.02674389f, 
    -0.12331884f, 0.00518365f, -0.02284922f, 0.01798224f, 0.12454212f, 0.03925432f, -0.02166747f, 0.04953068f, 
    0.12054110f, 0.04693420f, 0.02729291f, 0.09711283f, -0.08146270f, 0.05570241f, -0.02876968f, -0.07714333f, 
    -0.01853652f, 0.14937568f, 0.00723559f, 0.04007199f, 0.00177446f, -0.03254664f, 0.06525002f, 0.06230033f, 
    0.09149510f, 0.02651337f, -0.00558241f, 0.12775923f, 0.03813956f, 0.02692050f, 0.08926344f, 0.14674829f, 
    0.23076946f, 0.13538633f, -0.00275339f, 0.07892697f, -0.08795268f, 0.01706135f, 0.13304208f, 0.01176324f, 
    -0.03119845f, 0.14415987f, -0.00983036f, 0.02488534f, -0.00779089f, 0.00134511f, 0.13603923f, -0.14649238f, 
    0.07406566f, 0.03687986f, -0.00113717f, 0.12088924f, -0.04308236f, 0.18794122f, -0.04972570f, -0.03038821f, 
    -0.04447678f, 0.03549511f, -0.13944358f, -0.06753045f, -0.02471489f, -0.00307080f, -0.09206019f, -0.01426998f, 
    0.03213293f, -0.02830247f, 0.08122909f, -0.03241871f, 0.28098720f, -0.07723165f, -0.11150388f, -0.04153521f, 
    0.01447440f, -0.04395290f, -0.03567522f, 0.03764685f, 0.01220996f, 0.11416756f, 0.04285361f, 0.02942078f, 
    0.01433369f, 0.00574762f, 0.01054923f, -0.10085530f, 0.03757012f, -0.05491495f, 0.01186399f, 0.05346540f, 
    0.00110559f, -0.02996411f, 0.05741249f, 0.10650874f, 0.11292709f, 0.02444816f, 0.10528105f, 0.05197844f, 
    0.01720246f, 0.04817389f, 0.00330367f, 0.00830423f, 0.00161988f, 0.11909670f, 0.05676367f, 0.06254997f, 
    0.07718613f, -0.16192204f, 0.08307837f, 0.19268623f, -0.10014822f, 0.09355615f, -0.00347224f, -0.05175358f, 
    0.02256719f, -0.06076203f, -0.13401201f, 0.03134913f, -0.19961295f, -0.23028228f, 0.06105362f, 0.12646036f, 
    -0.01541733f, 0.08053441f, 0.00868718f, 0.09769535f, 0.02606825f, -0.02899447f, 0.05586448f, -0.00014242f, 
    0.50491673f, 0.07142842f, -0.01818211f, 0.27095893f, 0.02120693f, 0.15603274f, -0.06073249f, 0.13264535f, 
    0.04545020f, -0.04058384f, 0.17799260f, -0.00328013f, -0.32349977f, 0.17623259f, -0.02750481f, -0.08460139f, 
    0.03447221f, 0.01136397f, 0.08603923f, 0.17168368f, 0.02895184f, 0.04114665f, 0.03204552f, 0.03125726f, 
    -0.04221046f, -0.01295439f, -0.03055234f, -0.01172217f, 0.01455371f, 0.02060365f, 0.00236560f, -0.02272527f, 
    0.01823611f, -0.00608125f, 0.01292044f, 0.01196254f, -0.00876033f, -0.01030312f, 0.00245177f, -0.03796252f, 
    0.02300187f, -0.00013342f, -0.01655523f, 0.00085419f, -0.03309578f, -0.03686133f, 0.01592612f, 0.00478805f, 
    0.01429627f, -0.00321683f, -0.03738147f, -0.04360978f, 0.00856920f, -0.01217229f, 0.01513916f, -0.01183033f, 
    -0.02702425f, 0.00937456f, -0.01437451f, -0.02762206f, 0.00030079f, -0.02127578f, 0.02347924f, 0.02000069f, 
    0.00078539f, -0.04144488f, -0.03822896f, -0.00761445f, 0.01304026f, -0.03401193f, 0.01914663f, -0.03417516f, 
    -0.04259048f, -0.02425521f, 0.02344966f, 0.00418778f, -0.02409591f, -0.03912458f, -0.01180196f, -0.03683975f, 
    -0.01729853f, 0.02332506f, 0.01971146f, 0.01746217f, 0.02679109f, -0.03684179f, 0.00935368f, -0.02502868f, 
    -0.02604258f, -0.00341657f, -0.02221461f, 0.02320607f, 0.01320395f, 0.01042433f, 0.02203722f, -0.02400829f, 
    0.01050330f, 0.01523872f, -0.04124114f, -0.01511749f, -0.00663295f, 0.01314769f, -0.00436334f, 0.02200517f, 
    0.01025649f, -0.02369048f, 0.01333852f, -0.03567724f, -0.04009833f, -0.00171724f, -0.00453653f, 0.00870298f, 
    0.01256905f, -0.00468998f, -0.03260721f, -0.03355329f, -0.00265727f, 0.01179976f, -0.00581941f, 0.01104074f, 
    0.01377366f, -0.01142785f, -0.02267004f, -0.02781862f, 0.02574884f, 0.02267432f, 0.02387958f, 0.02491424f, 
    -0.02063591f, 0.00798294f, 0.01571395f, -0.02574687f, -0.03107986f, 0.00801018f, 0.02593589f, -0.00702520f, 
    -0.01120277f, 0.00397374f, -0.03939081f, 0.00488948f, -0.02306056f, 0.02708150f, -0.01635026f, -0.03285111f, 
    -0.03099812f, -0.02389551f, -0.00136970f, -0.00667374f, -0.03823288f, -0.00332738f, -0.00752298f, -0.04447269f, 
    -0.02890820f, -0.00481128f, -0.03503883f, -0.00283331f, 0.00625934f, -0.03462953f, -0.01043961f, 0.01303493f, 
    0.00934353f, 0.02761079f, -0.02223682f, 0.00015268f, -0.03062242f, 0.01334766f, -0.01579602f, -0.01706065f, 
    0.02095106f, 0.02177393f, 0.01066476f, 0.00197225f, -0.02100229f, -0.04535935f, -0.01838929f, -0.00642249f, 
    0.00902484f, -0.02450357f, -0.03726711f, -0.03732582f, 0.01486845f, 0.02222279f, 0.00564983f, 0.02147353f, 
    -0.03545191f, -0.00380614f, -0.00974067f, 0.02247623f, 0.01013540f, 0.02317484f, -0.04134074f, -0.01664225f, 
    -0.02875969f, 0.01374283f, -0.01021557f, -0.01785008f, -0.02583123f, 0.00877754f, -0.00378194f, -0.01306554f, 
    0.00451371f, -0.01149053f, 0.00385689f, 0.01922181f, -0.02439728f, -0.03602746f, 0.02772412f, -0.00383979f, 
    0.00131870f, 0.02254636f, -0.01299216f, -0.03850831f, 0.00566933f, 0.01080539f, 0.01552969f, 0.02570502f, 
    -0.01361028f, -0.00800488f, -0.02494500f, -0.01601704f, -0.04312373f, 0.00680598f, -0.03831865f, 0.02340053f, 
    -0.01575651f, 0.02330333f, -0.04422513f, 0.01760314f, -0.03045388f, 0.02305084f, 0.02229736f, -0.01249185f, 
    0.01991901f, 0.00168348f, 0.02543125f, 0.01039456f, -0.01874203f, 0.01572391f, 0.02657154f, -0.01394035f, 
    0.02084379f, -0.03295892f, -0.00690036f, -0.01213310f, -0.01418178f, 0.01082464f, 0.00289564f, -0.01279791f, 
    -0.04514430f, 0.01259861f, -0.02612708f, 0.02561437f, -0.03481307f, -0.04151117f, -0.03062141f, -0.02812248f, 
    0.01216427f, 0.01604638f, -0.02646957f, 0.01343214f, 0.00778784f, -0.04040300f, -0.00797789f, 0.02026892f, 
    -0.01348797f, -0.04179677f, 0.01348047f, -0.02055867f, -0.01149677f, -0.01935124f, -0.03099643f, 0.02475244f, 
    0.00758680f, -0.02282074f, 0.00636401f, -0.03228218f, 0.02971059f, 0.01954896f, -0.01701892f, 0.00814071f, 
    -0.00117822f, -0.00609015f, 0.00384418f, -0.01311016f, -0.01593277f, 0.01230820f, -0.01251907f, 0.02831592f, 
    -0.01154418f, -0.03023211f, 0.02341213f, 0.02380841f, 0.01697781f, -0.01787209f, 0.01831459f, 0.02627714f, 
    -0.03665821f, 0.02285903f, -0.02675697f, -0.02662012f, -0.03439384f, 0.01465800f, -0.02343869f, 0.00183062f, 
    -0.01067141f, 0.01962930f, 0.02170113f, 0.01746207f, 0.00037667f, -0.00082198f, 0.01987362f, -0.01179562f, 
    -0.02438883f, -0.01083471f, 0.00547916f, 0.02668266f, 0.01202373f, 0.02609436f, -0.00820799f, -0.04221592f, 
    0.02523476f, 0.01055152f, -0.01641961f, 0.02494357f, -0.04218486f, -0.00265756f, 0.00039975f, -0.00048819f, 
    0.02175873f, -0.00997640f, 0.01534760f, -0.03500900f, -0.02805145f, 0.02599321f, -0.01544360f, 0.00800678f, 
    0.01209885f, 0.02750054f, -0.01869347f, -0.03093094f, -0.04325439f, 0.01276993f, 0.02056067f, -0.00615409f, 
    -0.03982186f, 0.00736269f, -0.01698126f, -0.02028698f, 0.01765849f, 0.01410626f, -0.02965563f, 0.01749897f, 
    0.01810473f, 0.01039024f, 0.02563706f, -0.01562877f, -0.03193796f, -0.04139820f, -0.04419923f, -0.04450141f, 
    0.00552041f, -0.02507243f, 0.02171741f, -0.04058535f, 0.02917298f, 0.02708832f, 0.02286991f, 0.02497883f, 
    0.03430273f, -0.03753956f, -0.00214264f, 0.01879799f, -0.01434080f, -0.01018335f, -0.01599578f, -0.01420069f, 
    -0.03492407f, -0.02233830f, -0.01506349f, -0.01531346f, 0.00170067f, -0.04217295f, 0.02362972f, -0.03905281f, 
    0.02404365f, 0.00602534f, -0.00258869f, 0.02586279f, -0.00417763f, -0.03461670f, -0.01221722f, -0.02213188f, 
    -0.01075845f, -0.04412223f, -0.00509828f, 0.02346218f, 0.00997726f, 0.00669387f, 0.00072947f, -0.03759176f, 
    -0.01762694f, -0.04022259f, -0.00729038f, 0.00100410f, -0.03906262f, -0.00700772f, -0.03276683f, 0.02081683f, 
    -0.01283836f, -0.02887671f, -0.00053665f, -0.01614081f, 0.02511788f, 0.01255894f, 0.02739258f, 0.00075332f, 
    -0.00294063f, -0.01470229f, -0.01390212f, -0.01066972f, -0.02258940f, -0.00785877f, -0.02344098f, 0.01208843f, 
    0.01929062f, 0.01476870f, -0.04025880f, -0.04155279f, 0.00897170f, -0.00048512f, -0.02808191f, -0.01055767f, 
    -0.02938470f, -0.02167871f, 0.01742187f, 0.00391675f, 0.01331524f, -0.00825605f, 0.02215086f, -0.03326144f, 
    0.01172117f, -0.02767268f, -0.03907393f, -0.00579534f, 0.01702518f, -0.01693888f, 0.02586849f, -0.01623989f, 
    -0.02460279f, 0.02341701f, 0.01958660f, 0.01775235f, 0.01583449f, 0.00638556f, -0.01589186f, -0.02590853f, 
    0.00282821f, -0.02730191f, -0.00925257f, 0.01274227f, -0.04451477f, 0.03386983f, -0.01750042f, 0.02435274f, 
    0.01134194f, 0.02387620f, -0.03186796f, 0.01937694f, -0.03158563f, 0.00266042f, 0.02228553f, 0.00295676f, 
    -0.04227750f, -0.02450923f, -0.03976366f, -0.00309621f, -0.01100525f, 0.01822872f, 0.01895991f, -0.00740126f, 
    0.00526903f, 0.02290371f, -0.02795012f, -0.02254283f, -0.03831448f, 0.02457979f, 0.00919965f, -0.02636353f, 
    -0.03159057f, -0.02155161f, -0.03845167f, -0.02929834f, -0.04594795f, -0.02065595f, -0.03403040f, 0.01330725f, 
    0.00499791f, -0.00089243f, -0.03106783f, 0.00729619f, -0.03238985f, 0.02164858f, 0.00633324f, 0.02308898f, 
    -0.03402260f, -0.01591079f, -0.04332231f, -0.03770886f, -0.01389659f, -0.01478900f, -0.01785705f, 0.02699003f, 
    -0.00706173f, -0.03583442f, 0.00275285f, -0.01391105f, 0.00705081f, 0.02829382f, -0.01595127f, -0.03943494f, 
    0.02446052f, 0.01113884f, -0.01938866f, -0.00537298f, 0.02651636f, 0.00540161f, -0.02925612f, -0.03035984f, 
    -0.01218163f, 0.00566762f, -0.02667040f, -0.01679778f, 0.01365007f, -0.03867927f, 0.01549657f, -0.04107873f, 
    0.00135801f, 0.00231017f, -0.04449987f, 0.01985916f, -0.03934526f, -0.04251447f, 0.02429969f, 0.02108759f, 
    -0.00096314f, -0.01650937f, -0.01412642f, 0.01190783f, -0.01714994f, 0.01514918f, -0.01715616f, -0.03192819f, 
    -0.02968930f, 0.00380464f, -0.01062117f, 0.01385596f, 0.02770974f, -0.02451330f, -0.02416823f, 0.00577053f, 
    0.01760556f, -0.03917960f, 0.01787411f, -0.00773080f, 0.01760138f, -0.03885305f, 0.01355440f, 0.01346374f, 
    0.02670926f, -0.03247674f, -0.04200536f, 0.02609634f, -0.02614606f, -0.04002284f, 0.01802715f, -0.01928861f, 
    0.00457838f, 0.00679374f, 0.02912889f, -0.03170819f, 0.01704454f, 0.00722109f, 0.01564129f, 0.00866482f, 
    -0.00329734f, -0.02101653f, -0.00086897f, 0.00365936f, -0.02309760f, 0.00310927f, -0.02793661f, -0.01361416f, 
    0.01964775f, -0.00892281f, -0.02062359f, 0.02599616f, -0.03850771f, -0.00427226f, -0.00859969f, 0.02678428f, 
    0.01280681f, 0.03088443f, 0.01624963f, 0.00264430f, -0.01972510f, 0.02229433f, -0.01642654f, -0.03223662f, 
    -0.03039205f, 0.02481135f, -0.02826974f, 0.01812196f, -0.02535040f, 0.02094544f, -0.02591369f, 0.02135630f, 
    0.02494985f, 0.00744703f, -0.01022681f, 0.00144829f, -0.00497389f, -0.02140688f, -0.02073779f, -0.00188853f, 
    -0.02283270f, -0.02647395f, 0.02559259f, 0.01628452f, 0.02529722f, 0.02487779f, -0.03543879f, -0.03175487f, 
    -0.03683078f, 0.00363683f, -0.01547088f, -0.02833950f, 0.00198996f, -0.00403605f, -0.04588573f, -0.02452024f, 
    0.02579227f, 0.00616850f, 0.02248315f, -0.02191967f, -0.03474451f, -0.00878638f, 0.01304796f, -0.01506019f, 
    0.01839944f, -0.01156437f, -0.03284202f, -0.01575421f, -0.00343126f, -0.03342183f, -0.02246896f, -0.02454828f, 
    -0.00985037f, -0.00150746f, -0.03936303f, -0.00790667f, -0.03230234f, -0.01539035f, -0.03632651f, -0.00880060f, 
    0.01285779f, 0.02500373f, 0.00864270f, -0.01467391f, 0.00556195f, -0.02250923f, 0.01446903f, 0.01562964f, 
    0.01454235f, -0.02837582f, 0.01945834f, 0.01670864f, 0.02246731f, -0.03739131f, -0.02533721f, -0.02909121f, 
    -0.00195925f, -0.03619336f, -0.03820841f, 0.01718145f, 0.02387589f, 0.03753209f, 0.01001304f, -0.01631411f, 
    0.01036347f, 0.01520638f, 0.02010821f, 0.01422581f, -0.01291192f, 0.02120942f, -0.01717050f, 0.00591687f, 
    0.00774847f, -0.03421901f, 0.00742624f, -0.00114149f, -0.02125288f, 0.00774124f, -0.03161113f, 0.00388851f, 
    0.02298805f, -0.01746565f, -0.02801450f, -0.03159090f, 0.01014463f, -0.01552255f, 0.00076732f, -0.01579794f, 
    0.02306796f, -0.01061646f, 0.02269570f, -0.04017096f, 0.00831169f, -0.00882199f, -0.02929243f, -0.01071819f, 
    -0.01636827f, 0.02311560f, 0.01769236f, 0.00288610f, 0.02366396f, 0.01307711f, -0.02975137f, 0.01125250f, 
    -0.00503156f, -0.03929579f, 0.00164620f, -0.00655832f, -0.02430218f, 0.00061721f, 0.00246161f, -0.01468021f, 
    -0.01956054f, 0.00681150f, 0.02731553f, -0.04053168f, -0.02099292f, -0.01227785f, 0.01646544f, 0.00313040f, 
    0.00203459f, -0.02125925f, -0.03478109f, 0.02318234f, -0.00961081f, -0.02999543f, 0.00424091f, -0.00529330f, 
    -0.01651714f, 0.00824481f, -0.03617278f, -0.03284219f, 0.02610688f, 0.01207915f, -0.02904666f, 0.02601693f, 
    0.02969832f, -0.00043823f, 0.02562706f, -0.00763441f, 0.01876502f, -0.02983491f, -0.03294545f, -0.00166076f, 
    0.02047889f, -0.00898961f, 0.02428269f, -0.04191102f, 0.01672742f, -0.03279456f, -0.04529960f, -0.00745003f, 
    -0.01378729f, 0.01467224f, 0.00881649f, -0.02789260f, -0.03098910f, 0.02381748f, -0.02288900f, -0.02079096f, 
    0.00554974f, -0.03644225f, 0.01615692f, -0.03543282f, -0.00809541f, -0.00036060f, 0.02874646f, -0.04352743f, 
    0.19822158f, 0.22571157f, -0.07071212f, 0.09104335f, -0.02473222f, -0.03858991f, 0.05528770f, 0.00013686f, 
    0.01729812f, 0.04735487f, -0.03541174f, -0.03492500f, 0.11563715f, 0.10129704f, 0.06570887f, 0.19653478f, 
    0.04156642f, 0.02544799f, -0.06118787f, 0.12119685f, -0.01167389f, 0.03787536f, -0.09640334f, -0.12323888f, 
    0.05490293f, -0.12234003f, 0.03682359f, -0.20177598f, -0.08354629f, -0.02014039f, -0.05996124f, 0.02435320f, 
    0.05667639f, 0.02591393f, 0.08365382f, 0.04484618f, -0.16732517f, 0.15061921f, -0.18980268f, 0.17575851f, 
    0.01938079f, -0.10846717f, 0.05345955f, 0.09639230f, -0.05093074f, 0.01746156f, -0.10094655f, -0.04971109f, 
    0.15988055f, -0.01845390f, -0.08254163f, -0.12713748f, -0.11814564f, -0.12779604f, 0.18307182f, 0.07503802f, 
    -0.08635166f, 0.05236867f, -0.03828621f, 0.01214821f, 0.24314897f, 0.12080580f, -0.08810737f, 0.06909610f, 
    0.01417653f, 0.03554984f, -0.06716064f, -0.01835798f, -0.01649342f, 0.14257114f, 0.07089648f, 0.02712436f, 
    0.13953796f, -0.20616603f, 0.05851392f, 0.01663422f, -0.03553210f, 0.03054099f, -0.03601085f, -0.07583298f, 
    -0.00771331f, 0.01506109f, -0.03282383f, -0.01656278f, -0.15432531f, -0.02416159f, 0.08620565f, -0.05513160f, 
    0.02059566f, -0.12102631f, 0.08107620f, 0.02601485f, -0.04281900f, 0.04961273f, 0.02902719f, -0.07974549f, 
    -0.32595047f, 0.15189205f, -0.12746480f, -0.05705703f, 0.15876338f, -0.06663084f, -0.05458141f, 0.06099932f, 
    0.00127770f, 0.00406086f, 0.03820164f, 0.17181709f, 0.08714949f, 0.17334700f, 0.09315922f, 0.13091132f, 
    0.13604373f, 0.09765921f, 0.04026092f, 0.00516884f, 0.07849560f, -0.03572418f, -0.02503491f, 0.01615793f, 
    -0.06271825f, 0.19792630f, -0.06658100f, -0.02449258f, -0.01558898f, 0.15857618f, -0.12866230f, -0.07066596f, 
    0.03051942f, 0.07515441f, -0.02498572f, -0.07832637f, -0.47088018f, -0.13947177f, 0.01847948f, 0.24864098f, 
    -0.10577478f, 0.13735661f, -0.00085138f, 0.01974376f, 0.02244757f, 0.06531425f, 0.02449828f, -0.03579904f, 
    -0.02751324f, -0.07853574f, 0.03649090f, 0.11711322f, -0.05705322f, -0.01678381f, 0.09209078f, -0.01643544f, 
    0.05764711f, 0.02221035f, -0.00420242f, 0.00777839f, 0.27447861f, 0.04720814f, -0.04948639f, 0.05640585f, 
    -0.06411881f, 0.05288693f, 0.08298609f, -0.04572652f, -0.05672319f, -0.03505335f, -0.00543295f, -0.01885639f, 
    -0.07868816f, -0.07668383f, 0.00524946f, 0.04786862f, 0.08480141f, -0.02392725f, 0.00674646f, -0.05539773f, 
    -0.03547811f, -0.04717481f, 0.06747077f, 0.10616356f, 0.37060517f, -0.07813191f, 0.02206428f, 0.02048161f, 
    0.07717814f, 0.10178179f, 0.06539971f, 0.07291164f, 0.03516169f, 0.03203441f, -0.03786334f, -0.05711339f, 
    -0.06821983f, 0.25177488f, -0.06516506f, -0.07746515f, 0.04922354f, -0.04987122f, 0.05742306f, -0.01443999f, 
    0.05025209f, -0.03217836f, 0.08122746f, 0.05307969f, -0.05417185f, 0.17792125f, -0.02102566f, 0.01954791f, 
    -0.02793428f, -0.04872964f, 0.03731717f, 0.03912463f, 0.08060315f, -0.05376032f, -0.01599181f, 0.04325321f, 
    0.04468114f, 0.07415272f, -0.10799280f, 0.09285404f, 0.04080749f, 0.05405997f, 0.06317271f, -0.05873743f, 
    -0.06572374f, -0.04687583f, 0.02292247f, -0.01385730f, -0.09120255f, 0.28476921f, 0.00743589f, -0.01812625f, 
    0.07178037f, -0.04663843f, 0.02290663f, 0.05639693f, 0.04090046f, 0.03051483f, 0.00597250f, 0.06836341f, 
    0.13290125f, -0.33856937f, -0.13795273f, -0.12595327f, -0.07094027f, -0.03357276f, -0.00173545f, -0.12885222f, 
    -0.12330593f, -0.06279353f, -0.06463874f, 0.03470588f, 0.23904195f, 0.09517682f, -0.02391463f, 0.01579335f, 
    0.00209837f, -0.14164810f, 0.08355803f, 0.06528603f, 0.00252607f, 0.03024375f, 0.13293162f, 0.01608918f, 
    -0.15354228f, -0.21583524f, -0.04298209f, 0.04935993f, -0.16662796f, -0.04115224f, -0.02552589f, -0.04716963f, 
    0.06158727f, 0.05799685f, -0.01567161f, -0.07403594f, 0.48311809f, 0.04062678f, 0.12152898f, 0.05145452f, 
    0.06886034f, 0.02349708f, 0.01437117f, 0.02148166f, 0.04750216f, -0.08277403f, -0.09963930f, 0.06433848f, 
    -0.00328892f, 0.14149617f, 0.02139039f, -0.04908390f, -0.04602757f, 0.11687541f, -0.01154406f, 0.06083116f, 
    0.08114023f, -0.13147897f, -0.05064699f, -0.00824028f, 0.16216588f, -0.02223914f, -0.00454847f, -0.07615054f, 
    -0.11912990f, -0.03301503f, -0.04359105f, 0.02441346f, -0.02767130f, 0.06182940f, 0.03153220f, 0.02676448f, 
    0.28822264f, 0.04706046f, 0.14990495f, -0.05496732f, 0.08161448f, 0.06599513f, 0.04276376f, -0.10274676f, 
    -0.00404564f, -0.00237757f, 0.01659413f, -0.05332666f, 0.17909355f, 0.20737949f, 0.18579698f, 0.14941500f, 
    0.02282587f, 0.03496648f, -0.06720898f, -0.05532194f, -0.06685796f, -0.04957126f, 0.07797922f, 0.10326459f, 
    0.15707216f, 0.09484780f, -0.16751860f, -0.08398903f, -0.08951249f, 0.04275242f, -0.02241053f, 0.02045889f, 
    -0.07580223f, -0.05788881f, -0.00791338f, 0.03624700f, 0.12671335f, 0.00268249f, 0.05769470f, -0.19443625f, 
    -0.00067012f, 0.05568364f, -0.04565093f, 0.03698375f, -0.13174768f, -0.07490136f, 0.02036249f, -0.00070807f, 
    0.35928774f, 0.02060950f, 0.19468278f, 0.00356978f, -0.05271530f, -0.00382888f, 0.09466586f, 0.04954003f, 
    0.06485154f, 0.01332175f, -0.03094607f, 0.04499539f, 0.03796452f, 0.12335479f, -0.03216306f, 0.19405015f, 
    0.02621728f, -0.06532357f, -0.01892012f, 0.03138911f, 0.01380943f, -0.11441397f, -0.07997030f, -0.02849680f, 
    0.09534061f, 0.08744141f, 0.09592957f, -0.03784694f, -0.00669774f, 0.01492775f, 0.07481688f, 0.03997858f, 
    0.00244101f, 0.06346480f, -0.00063971f, 0.00583046f, 0.08265083f, -0.10146365f, 0.18205485f, 0.07766480f, 
    -0.07792888f, 0.08048710f, -0.05722769f, 0.06941637f, 0.02883078f, 0.07021756f, 0.10216799f, 0.00579087f, 
    0.07579578f, -0.08720789f, 0.12122077f, 0.06568396f, -0.02146962f, 0.06331271f, 0.01918879f, 0.00165372f, 
    -0.02447340f, 0.02921020f, 0.04139265f, -0.03209346f, 0.14210671f, 0.11216139f, -0.01577833f, 0.12718830f, 
    0.01056609f, -0.03157421f, -0.01971211f, -0.00653019f, -0.02071649f, 0.09087389f, -0.09739548f, -0.07428379f, 
    0.17706867f, 0.11216403f, 0.12182537f, 0.07611826f, 0.06663081f, 0.10283279f, 0.05079094f, 0.11020877f, 
    -0.02745705f, 0.00455911f, -0.00451370f, 0.01644592f, 0.21197774f, 0.05494246f, 0.12045489f, 0.05921982f, 
    0.01084203f, 0.06657620f, 0.01202219f, -0.03840875f, 0.04911871f, -0.06369678f, 0.08765011f, 0.10969247f, 
    -0.16699144f, 0.19112147f, 0.05455374f, 0.02623122f, -0.00538595f, -0.02875449f, 0.06471754f, 0.02840181f, 
    -0.06044121f, 0.05887893f, -0.03161298f, 0.07612526f, 0.18730788f, -0.00208271f, 0.10987224f, -0.12888189f, 
    -0.13866952f, 0.00065788f, 0.02151459f, 0.01241950f, -0.04630492f, 0.01406044f, 0.10424274f, -0.02378173f, 
    -0.15740512f, -0.09874639f, 0.06374197f, 0.07293929f, -0.01084411f, 0.06136692f, 0.04173120f, -0.02725250f, 
    0.04550016f, 0.06162062f, -0.13642640f, -0.02277706f, 0.23033929f, 0.28146827f, 0.07207907f, 0.08440971f, 
    0.00390135f, -0.00498066f, 0.07247512f, 0.02374126f, -0.04614113f, -0.00814861f, -0.13927023f, 0.07898905f, 
    0.03982683f, -0.02702228f, -0.05399779f, 0.02137299f, -0.05562644f, 0.05965446f, -0.01431995f, -0.02809506f, 
    -0.02009580f, -0.01602638f, 0.02732159f, -0.01945815f, -0.06726889f, -0.08648900f, 0.03999512f, -0.05638115f, 
    -0.04409906f, 0.04955472f, 0.02645717f, 0.07354724f, -0.01009567f, -0.03823184f, 0.05433414f, 0.11971658f, 
    0.15151745f, -0.11545888f, 0.04041268f, 0.03186338f, -0.04748676f, -0.01614476f, 0.00649144f, -0.03254314f, 
    0.09596626f, 0.04157423f, -0.04400592f, -0.10599787f, 0.17544907f, 0.14298588f, 0.04247954f, 0.04968237f, 
    0.15037231f, 0.00427980f, 0.09720296f, -0.06932469f, 0.01980934f, 0.05230699f, -0.09844299f, 0.01252282f, 
    0.41163760f, -0.00712938f, 0.04260984f, -0.02156133f, -0.05853941f, -0.04241843f, 0.03906093f, -0.06597485f, 
    0.00036990f, -0.03255250f, -0.03171243f, -0.05672235f, -0.06221173f, 0.16055432f, 0.02317599f, 0.04727815f, 
    -0.13349804f, 0.02846253f, 0.02422659f, -0.06420458f, 0.02630217f, -0.01729082f, -0.13414830f, 0.05130635f, 
    0.35321197f, 0.18761237f, -0.05289042f, -0.02497037f, 0.04056113f, -0.05777258f, 0.04838364f, -0.08311484f, 
    0.01046008f, -0.09827772f, -0.03235268f, -0.01363586f, 0.06860308f, 0.25315690f, 0.06426077f, 0.14773852f, 
    0.06356251f, 0.03273496f, -0.06004718f, -0.03121514f, -0.15203291f, -0.07055978f, -0.02975833f, -0.05633126f, 
    0.00074008f, 0.20514360f, 0.08022982f, 0.17771098f, 0.04971241f, 0.05058394f, 0.03728680f, 0.04200517f, 
    0.00937966f, 0.04681261f, 0.02624067f, 0.06153885f, -0.17914960f, 0.01778482f, -0.12437491f, -0.16015232f, 
    -0.00369620f, 0.01083746f, -0.09488412f, 0.01554731f, -0.02485563f, -0.08128992f, -0.03211994f, -0.02751640f, 
    0.32279456f, -0.15012845f, 0.05116097f, -0.10026398f, -0.10846870f, -0.03352669f, 0.02721677f, 0.01558172f, 
    -0.07390587f, -0.03720250f, 0.13252239f, -0.00755180f, 0.03737479f, 0.31639841f, 0.02606055f, -0.05377162f, 
    0.01023262f, 0.07675729f, 0.03136339f, 0.01522490f, 0.12027606f, -0.03852309f, 0.05151682f, -0.03434291f, 
    -0.00790692f, -0.07471791f, -0.03379113f, 0.01348741f, -0.06684861f, -0.08929843f, 0.04246566f, -0.09300550f, 
    -0.00112780f, 0.06089196f, -0.00435116f, -0.06673558f, 0.30635881f, 0.19353993f, 0.09394725f, 0.09681848f, 
    -0.00405424f, 0.12304766f, -0.08240613f, -0.02399870f, -0.05232047f, -0.03569151f, 0.08820496f, 0.04869842f, 
    0.24533017f, 0.07549047f, 0.12186129f, 0.21888511f, -0.04501263f, 0.11883877f, 0.04437409f, -0.06443933f, 
    0.14949229f, 0.00797408f, -0.02239818f, -0.07533205f, 0.19419709f, -0.18003112f, 0.02243522f, 0.18152404f, 
    -0.12758388f, 0.02833457f, 0.07010338f, 0.17079882f, -0.00457965f, -0.03324721f, 0.00881640f, 0.07062075f, 
    0.41657916f, -0.17787153f, -0.04580481f, -0.13691005f, -0.17201178f, 0.12911744f, -0.02139498f, 0.14132391f, 
    -0.03821525f, -0.02914484f, 0.00548614f, 0.02382397f, 0.37033224f, -0.04779233f, -0.13295034f, -0.08892322f, 
    -0.15866432f, 0.07620690f, 0.14384760f, -0.10913435f, -0.01275442f, -0.06014020f, 0.06741869f, 0.03337855f, 
    -0.00492934f, -0.06261852f, 0.04978515f, -0.06226532f, -0.02912738f, 0.04206223f, -0.00788933f, -0.01559196f, 
    0.00935221f, -0.03035904f, -0.00130494f, -0.03118696f, 0.36048934f, 0.03918300f, 0.07841838f, 0.00738208f, 
    -0.00743502f, 0.05847634f, -0.03524946f, 0.06210377f, -0.05839660f, -0.03227828f, -0.02859082f, 0.04578694f, 
    0.37063608f, -0.21698229f, 0.17893341f, -0.04747735f, -0.10388326f, 0.11939555f, -0.01729648f, 0.06925526f, 
    -0.07396051f, 0.00280022f, 0.07722860f, -0.08072092f, 0.18444796f, 0.02657959f, 0.10971666f, 0.00702250f, 
    -0.02123464f, 0.12743571f, -0.09366832f, 0.06001114f, -0.00300242f, 0.12866350f, 0.01515380f, -0.02739757f, 
    0.12923987f, 0.13353832f, -0.13593781f, -0.05787523f, -0.00049758f, -0.04679790f, 0.00359720f, 0.03409784f, 
    -0.01034388f, -0.02788896f, 0.04436379f, 0.01350807f, -0.09145832f, 0.05006677f, -0.06837094f, -0.11246798f, 
    0.05107814f, 0.04602500f, -0.02836989f, 0.04184654f, 0.01095129f, 0.03986616f, 0.03767554f, 0.06333000f, 
    -0.05380343f, -0.14636385f, 0.12140710f, 0.19635873f, -0.03260303f, -0.02707829f, -0.09765060f, 0.02964816f, 
    0.00668642f, 0.11598361f, 0.04675311f, 0.02046127f, 0.20345585f, 0.20248741f, -0.13829339f, -0.05844861f, 
    0.04306353f, -0.01378565f, 0.03096854f, 0.09101509f, 0.02666952f, -0.11768218f, -0.07664135f, 0.13834709f, 
    0.17771062f, 0.14844023f, -0.10448226f, -0.09441759f, -0.09390003f, 0.00788433f, 0.10979912f, 0.03743288f, 
    0.02079097f, 0.02765237f, 0.01125568f, 0.04208517f, 0.10565380f, 0.10427883f, -0.12508512f, -0.06173823f, 
    -0.06553010f, 0.05231304f, -0.01567103f, 0.02210331f, 0.01972445f, 0.02802915f, 0.12929113f, 0.03638920f, 
    0.02922956f, -0.14298922f, 0.21620955f, 0.12169429f, -0.02814972f, 0.06425531f, -0.06854308f, -0.05853266f, 
    0.03501441f, 0.05836060f, 0.04523826f, 0.06046877f, -0.11091575f, -0.11865997f, 0.10974292f, 0.15179281f, 
    0.00358870f, -0.05931734f, 0.04635216f, 0.01979879f, 0.02338790f, 0.07818170f, -0.05020244f, -0.16877781f, 
    -0.12171329f, 0.25451320f, -0.16844749f, -0.01057942f, 0.10445851f, 0.06022239f, -0.17859420f, 0.15218416f, 
    0.05016924f, 0.08656087f, 0.03511637f, 0.06472389f, -0.16152263f, -0.01698035f, 0.06348454f, -0.14433664f, 
    0.02253579f, -0.09961323f, -0.07986790f, -0.03203670f, 0.02930268f, -0.02373356f, -0.09590360f, -0.03496711f, 
    -0.05504653f, 0.18112564f, 0.02045903f, 0.03645273f, 0.06729434f, 0.10938121f, -0.00859218f, -0.01557732f, 
    -0.06297664f, 0.02755302f, -0.00599222f, -0.02438943f, -0.03107561f, -0.08671995f, 0.16213596f, 0.35664785f, 
    0.07139670f, 0.06055825f, -0.06662317f, 0.01406185f, -0.04014204f, 0.02641372f, 0.08315093f, 0.00941449f, 
    0.06130040f, -0.14670658f, -0.04614098f, 0.10861780f, 0.00225281f, -0.01892402f, -0.00611559f, -0.00244411f, 
    0.06410225f, 0.13842086f, 0.05504562f, 0.08383762f, 0.09614608f, -0.06322432f, -0.01535236f, 0.05098516f, 
    0.11550304f, 0.07405186f, 0.09611149f, 0.03431671f, -0.00761450f, 0.13148838f, -0.01054231f, 0.06810196f, 
    -0.00313343f, -0.04981148f, 0.03053200f, -0.03318806f, 0.18233976f, -0.04945967f, -0.02948288f, 0.06682181f, 
    -0.05232063f, -0.03273713f, 0.08356392f, 0.18498780f, -0.06427453f, -0.18065156f, 0.21686019f, 0.19881651f, 
    0.05593601f, 0.09514306f, -0.01184491f, -0.06400891f, 0.04347825f, 0.00736234f, -0.04357848f, -0.14949377f, 
    0.03488918f, -0.00339545f, -0.02159852f, 0.02421742f, -0.04182105f, -0.02220289f, -0.02253320f, -0.10946194f, 
    0.01671057f, -0.06510655f, 0.05420233f, 0.07143604f, -0.10848014f, 0.03479892f, -0.02021797f, -0.08153241f, 
    -0.02011657f, -0.07719693f, -0.00409011f, -0.00783645f, 0.10233743f, -0.10275697f, 0.03736926f, -0.01289988f, 
    -0.01502516f, 0.06065398f, -0.03188199f, 0.02842771f, 0.03606956f, -0.01349976f, -0.06977214f, -0.04484618f, 
    0.03358557f, 0.11703100f, 0.05680511f, 0.04710276f, -0.00411674f, 0.06510433f, -0.04404882f, 0.13866197f, 
    0.02516608f, -0.01171443f, 0.04489192f, 0.05926614f, 0.07517567f, 0.05397896f, 0.02993099f, 0.08270066f, 
    0.21191052f, 0.10147884f, -0.14476945f, -0.06715944f, 0.03208102f, 0.06123367f, -0.00708010f, 0.04113502f, 
    0.06256712f, -0.00923121f, 0.06046182f, 0.06165253f, 0.13989146f, 0.07612257f, -0.12475894f, -0.26946834f, 
    -0.05199662f, -0.06260123f, 0.01749182f, -0.00190745f, -0.00034229f, 0.02541527f, 0.06309588f, -0.06405226f, 
    0.15711853f, -0.23085077f, 0.09231920f, 0.15618339f, 0.07132971f, 0.04324280f, 0.04675348f, 0.01320343f, 
    0.10636792f, 0.02392122f, -0.01686897f, 0.02001978f, -0.06982294f, 0.11261688f, -0.26421493f, -0.14502113f, 
    0.00399349f, -0.06262808f, -0.05687948f, -0.01953624f, 0.05411168f, -0.11472255f, -0.04268162f, 0.12760730f, 
    0.14041319f, -0.00604923f, -0.03343356f, -0.01663175f, -0.04286691f, 0.04762113f, 0.04896057f, -0.07373033f, 
    0.15055731f, -0.04752072f, -0.00897840f, 0.00953273f, 0.16050033f, 0.13776889f, -0.11583684f, -0.02855334f, 
    -0.00254440f, -0.02029773f, 0.01307750f, 0.06611016f, 0.12622209f, 0.07977098f, 0.11653714f, 0.05812601f, 
    -0.11093616f, 0.04260297f, 0.11427139f, -0.13262215f, 0.02956817f, -0.03175282f, 0.05416310f, -0.02860053f, 
    0.07119787f, -0.02347658f, 0.04764629f, 0.09740035f, -0.21536675f, -0.01101407f, 0.07570541f, -0.14464562f, 
    -0.03030244f, -0.08614314f, -0.04909115f, -0.11336312f, -0.05942106f, 0.04473827f, 0.06236729f, 0.06693596f, 
    0.10988649f, 0.14201678f, -0.12756866f, -0.13134485f, -0.04620507f, 0.04702260f, -0.13130434f, 0.02718192f, 
    0.05114925f, -0.12379582f, 0.06768472f, 0.06146641f, -0.10628271f, -0.02389454f, -0.01384101f, -0.09466677f, 
    -0.04756886f, -0.12586917f, -0.04352200f, -0.06922641f, -0.09579695f, -0.03658530f, 0.04193343f, 0.07107249f, 
    -0.21062027f, 0.08628965f, 0.05958242f, -0.15315065f, -0.01400525f, -0.01571499f, 0.01217242f, 0.03211264f, 
    0.05218393f, 0.06365810f, 0.05567861f, 0.04808034f, -0.05283907f, 0.01830660f, -0.10835432f, 0.03282742f, 
    0.12322382f, -0.08984778f, -0.04876294f, -0.06290647f, 0.04761382f, -0.09980799f, -0.02646262f, 0.04684079f, 
    -0.20334181f, 0.03586307f, 0.10820945f, -0.10017980f, 0.01637568f, 0.07233196f, 0.00531745f, 0.11199507f, 
    0.08964305f, 0.06293233f, 0.09714215f, -0.02821059f, 0.13872550f, -0.02816406f, 0.12998636f, 0.14827920f, 
    -0.01233204f, 0.05263777f, 0.10445707f, 0.00655666f, 0.17573279f, 0.06256953f, 0.11846729f, 0.02746477f, 
    0.14491279f, -0.09481560f, 0.07772068f, 0.16122256f, 0.03779911f, -0.03594729f, 0.03033444f, 0.01469804f, 
    0.03547139f, 0.07346456f, 0.06744283f, -0.05448237f, 0.05198804f, -0.09577302f, 0.05676423f, 0.02286592f, 
    0.08470482f, -0.02177724f, -0.06392181f, -0.02198763f, 0.11305230f, 0.17073192f, 0.04265427f, -0.09554776f, 
    -0.18784511f, 0.05059390f, 0.12569542f, 0.06942803f, 0.00888716f, 0.06129497f, -0.05238591f, 0.06112249f, 
    -0.01768807f, 0.03163311f, 0.11655752f, -0.00064093f, -0.14347067f, 0.01900596f, -0.04025059f, -0.16080762f, 
    0.06313781f, 0.06337484f, -0.09712514f, -0.03789410f, 0.07946003f, -0.07208069f, 0.03529309f, 0.01150502f, 
    -0.10079902f, 0.16066739f, -0.04457916f, 0.09095687f, 0.00136663f, 0.03855295f, 0.03377739f, 0.03349259f, 
    0.04478999f, -0.00112481f, 0.05150316f, 0.03608859f, 0.13096878f, -0.02680013f, 0.09919626f, 0.06347931f, 
    0.01491613f, -0.02912125f, -0.11036821f, 0.00266667f, 0.06787428f, -0.03183748f, -0.01413543f, -0.03944763f, 
    0.07482772f, -0.12606101f, 0.15684466f, 0.14179596f, 0.07745413f, 0.15805376f, 0.02897079f, -0.01777296f, 
    0.09654184f, 0.09468830f, 0.01289606f, 0.06684893f, 0.00173994f, 0.01761204f, 0.15642230f, -0.01889089f, 
    0.00956588f, 0.09279960f, 0.07331591f, 0.06261223f, 0.06865811f, 0.06905270f, -0.04003380f, -0.01704593f, 
    -0.08728235f, -0.10732868f, 0.16202311f, 0.05343515f, -0.06366482f, 0.04412348f, -0.00170093f, 0.00406486f, 
    -0.04142271f, 0.06796741f, 0.04145565f, -0.06875889f, 0.01646085f, -0.10015058f, 0.18342806f, 0.08870442f, 
    0.06235487f, 0.04346296f, 0.05316252f, 0.11683001f, 0.05280775f, 0.08560351f, 0.09724609f, 0.09309098f, 
    0.17632346f, -0.12064067f, 0.04902562f, 0.12819853f, -0.03288897f, -0.11524737f, -0.08362927f, 0.03860975f, 
    0.03437536f, 0.02624919f, 0.08702485f, -0.11350691f, -0.14053895f, -0.00375143f, 0.11019851f, 0.09141288f, 
    0.07906747f, -0.01792459f, 0.04957371f, 0.08248985f, 0.11848113f, 0.01362287f, -0.06326696f, 0.00196479f, 
    0.00322456f, -0.16626848f, 0.11530532f, -0.02446680f, 0.00031676f, -0.03752078f, 0.07244362f, -0.09547365f, 
    -0.10496423f, -0.03871486f, 0.05642745f, -0.05643361f, 0.03601393f, 0.13825348f, 0.16068175f, 0.17155002f, 
    0.00958474f, 0.02377886f, 0.03973928f, -0.07896250f, 0.06442168f, 0.02544401f, -0.05486690f, -0.02192087f, 
    0.03728604f, 0.21229422f, -0.04747909f, 0.07400076f, 0.02527614f, -0.02410282f, -0.07790245f, -0.10243749f, 
    -0.01852494f, -0.07556318f, -0.06552607f, 0.00758774f, -0.06582352f, 0.14975318f, -0.18656825f, -0.07216320f, 
    0.16639812f, -0.13472888f, -0.10730604f, -0.01117793f, -0.06619290f, -0.00039904f, -0.02530424f, 0.08489408f, 
    -0.08336145f, -0.11562964f, 0.06034091f, -0.03185425f, 0.03125395f, 0.01655683f, 0.00536142f, 0.00144101f, 
    -0.01946121f, 0.16062425f, 0.00164873f, 0.02013150f, 0.11110876f, 0.08956275f, -0.14136006f, 0.01357686f, 
    -0.02737209f, 0.02326653f, -0.09149208f, -0.01893256f, 0.07935007f, 0.07673462f, 0.09591924f, 0.04246771f, 
    0.36167297f, 0.04468984f, -0.01046650f, 0.02457342f, -0.03071865f, -0.00050707f, 0.03774589f, 0.02947200f, 
    0.02106068f, -0.10558985f, 0.17954163f, -0.04945920f, -0.00873294f, 0.01530533f, -0.01936032f, -0.12225620f, 
    -0.14461213f, 0.02136439f, -0.07095122f, -0.06140166f, 0.13896225f, 0.01476274f, -0.04919286f, -0.00279963f, 
    -0.01617773f, -0.12229958f, 0.18855546f, 0.13271016f, 0.10957263f, -0.12609310f, -0.13552772f, 0.02425233f, 
    0.07764865f, 0.00467317f, 0.07112829f, 0.00086343f, -0.01236511f, 0.08136637f, -0.07062022f, -0.03628506f, 
    -0.06771828f, 0.03950099f, 0.01664702f, -0.01939280f, 0.04728616f, -0.15751000f, 0.15536748f, 0.10628070f, 
    -0.01916438f, -0.03024814f, 0.00639572f, 0.01658639f, -0.02698163f, 0.08080324f, 0.09870649f, 0.01926384f, 
    0.09862926f, 0.03266564f, -0.01549479f, -0.03298776f, -0.01461200f, -0.05831651f, -0.01954967f, 0.07737666f, 
    -0.04985237f, -0.03105923f, -0.16644096f, 0.12323897f, 0.11504371f, -0.06231195f, 0.01489867f, 0.05434645f, 
    0.18779571f, 0.04815239f, 0.02880093f, -0.01985815f, 0.02619524f, 0.09868331f, 0.00524063f, 0.03070762f, 
    0.02513040f, 0.04203507f, 0.06295006f, 0.03503969f, 0.30171794f, -0.00607503f, -0.05905047f, -0.12559758f, 
    -0.08548500f, 0.03089948f, 0.13871594f, -0.10725306f, -0.01457023f, -0.07637416f, 0.08317734f, 0.00981952f, 
    -0.05010900f, -0.10509491f, 0.08953572f, 0.08135948f, 0.03632030f, -0.09460443f, -0.08217929f, 0.02072378f, 
    0.07548477f, 0.11643006f, 0.03139831f, -0.01581276f, -0.01983413f, 0.08992583f, 0.10122158f, -0.05632772f, 
    0.03582677f, 0.00905746f, -0.01132894f, 0.00114122f, 0.02056119f, 0.00752836f, -0.03784249f, 0.03987815f, 
    -0.12787677f, -0.25639114f, 0.08033619f, 0.17888573f, -0.12204012f, 0.00746009f, -0.01329153f, -0.02480520f, 
    -0.01240867f, 0.15182948f, -0.01313008f, 0.06143367f, -0.02551048f, -0.01288475f, 0.04679849f, -0.12984449f, 
    0.00693370f, 0.09537475f, -0.01385183f, 0.02986934f, 0.03813263f, 0.15636563f, 0.02153507f, -0.01607285f, 
    0.02261654f, 0.17837171f, -0.04545751f, 0.14722021f, -0.04780973f, 0.02261365f, -0.05407489f, -0.04865848f, 
    0.01425577f, -0.05585172f, 0.13891749f, 0.06719019f, -0.07396299f, -0.00850295f, 0.09260230f, 0.10411155f, 
    0.12531966f, 0.01156324f, 0.05603328f, -0.01293546f, 0.04448126f, -0.05950862f, -0.15112169f, -0.03169814f, 
    0.10263120f, -0.18150574f, -0.06060726f, -0.00627292f, -0.03350755f, -0.02925592f, -0.04035088f, 0.04822695f, 
    0.01598044f, 0.01554210f, 0.05554803f, 0.02653112f, -0.07865075f, -0.06344113f, -0.15307024f, 0.06089368f, 
    0.12797268f, -0.05989590f, -0.07307450f, 0.06524006f, 0.04831145f, 0.07349005f, 0.02187175f, 0.04229787f, 
    -0.09738030f, -0.06129210f, -0.01496693f, 0.02346903f, 0.09823649f, 0.03767802f, 0.03284933f, -0.06282073f, 
    0.04974331f, -0.02062614f, -0.01208841f, -0.01158527f, 0.25069794f, -0.03146085f, -0.06316223f, 0.10269718f, 
    -0.02857901f, 0.12643075f, -0.03980918f, 0.03946445f, 0.12546428f, 0.03354517f, -0.00668414f, -0.02174573f, 
    -0.14638534f, -0.00102509f, 0.03464231f, -0.01634446f, -0.00831285f, 0.00352546f, 0.00530630f, 0.06945159f, 
    -0.05242690f, -0.12151655f, 0.05741462f, 0.02552024f, 0.05969016f, -0.13917190f, -0.04517142f, -0.04141291f, 
    -0.08554069f, -0.18073110f, 0.06515940f, 0.01407175f, 0.07781842f, 0.13075925f, 0.04993206f, 0.08360089f, 
    0.00179685f, 0.12479670f, -0.28378454f, 0.02917173f, 0.05963342f, -0.01372810f, -0.10144732f, 0.02454344f, 
    0.11878242f, 0.02167055f, -0.05430740f, 0.04867386f, 0.12123776f, -0.02680037f, -0.02957725f, -0.04074825f, 
    0.03771205f, -0.01234293f, 0.06514271f, -0.09591911f, -0.00795789f, -0.03867270f, -0.02804318f, 0.07448267f, 
    -0.13875598f, 0.12329342f, 0.07725281f, 0.02969771f, 0.05810817f, -0.04158821f, -0.07867644f, -0.05189376f, 
    0.06022946f, -0.03054859f, -0.02671182f, 0.02161701f, -0.29985756f, -0.11438424f, 0.04927398f, -0.15935817f, 
    0.08933863f, -0.03596198f, -0.16989565f, 0.12501714f, 0.03039854f, 0.04558440f, 0.02205757f, -0.00551584f, 
    0.00738920f, -0.20572427f, -0.07286672f, 0.08732834f, 0.02727240f, -0.18609457f, -0.00585600f, -0.02758989f, 
    0.24282527f, -0.03950053f, 0.05398147f, -0.04666827f, -0.02148394f, -0.06063967f, 0.00705935f, 0.14049993f, 
    0.01507904f, -0.02209464f, 0.01067412f, 0.02988101f, -0.07416029f, 0.02849479f, 0.04299169f, -0.10131066f, 
    0.03336956f, -0.32962576f, 0.02908537f, -0.20053850f, 0.10610624f, 0.01905518f, -0.10796193f, 0.00677475f, 
    -0.05056712f, 0.01901880f, 0.00422509f, 0.09900363f, 0.01566989f, 0.22860339f, -0.05238743f, -0.08673259f, 
    -0.16113393f, -0.03786770f, -0.10503026f, 0.07964929f, 0.13173877f, -0.09695859f, -0.03508409f, 0.07565005f, 
    -0.23530111f, 0.11468318f, 0.02517337f, 0.01639479f, 0.03703632f, 0.05208889f, -0.09761027f, 0.04362883f, 
    0.05310796f, 0.07256404f, 0.03151963f, 0.03157758f, 0.12209608f, 0.17872752f, 0.08426160f, 0.11216851f, 
    -0.10706725f, -0.05882959f, 0.03449653f, -0.09576266f, 0.05360971f, 0.08084390f, 0.11959378f, -0.09052160f, 
    -0.11221819f, 0.07388794f, -0.04972883f, -0.12347278f, 0.03355359f, -0.03421062f, -0.02405603f, 0.02030265f, 
    -0.11919162f, 0.03212803f, -0.04971644f, -0.00393200f, -0.20012361f, 0.28388554f, -0.07443567f, 0.02813939f, 
    0.09649396f, 0.05933538f, -0.06354045f, 0.09640977f, 0.03300263f, -0.00887671f, 0.01646277f, 0.06867704f, 
    -0.04521587f, -0.16411740f, -0.13824135f, 0.12799044f, 0.05744977f, 0.08169732f, -0.03395240f, -0.07376285f, 
    -0.00681667f, 0.05393905f, 0.02001155f, -0.00172275f, 0.24073955f, 0.10411230f, -0.08207201f, 0.27967495f, 
    -0.10680477f, -0.04856205f, 0.10164711f, 0.04742692f, 0.02105375f, 0.05713903f, -0.12895902f, -0.00949103f, 
    -0.00495791f, -0.27363396f, -0.10299256f, -0.18212546f, -0.05148509f, -0.06103218f, -0.00113069f, 0.06621549f, 
    -0.01400112f, 0.11297006f, 0.00392335f, 0.00246192f, 0.11361729f, 0.10186298f, 0.22214267f, 0.17865779f, 
    -0.02898706f, -0.02101102f, 0.01714882f, -0.02735535f, -0.05753826f, 0.07473043f, 0.04542869f, 0.10988659f, 
    -0.11270664f, 0.14384758f, 0.08044958f, -0.07601096f, -0.15239449f, -0.02374573f, 0.09741955f, 0.03159864f, 
    -0.12634860f, 0.03293676f, 0.02331139f, -0.11362462f, 0.28910542f, -0.00265874f, -0.09302851f, 0.16250141f, 
    -0.08536564f, 0.07432918f, -0.08950957f, -0.06565920f, -0.13415003f, -0.01690699f, 0.02420745f, 0.05852259f, 
    0.05655469f, 0.14984773f, 0.10609453f, -0.06073398f, 0.12030463f, -0.04093326f, 0.11662012f, 0.02323852f, 
    -0.10727868f, 0.06014983f, 0.06453817f, 0.04556961f, 0.20937382f, 0.30541867f, 0.08214137f, -0.06942183f, 
    -0.07624331f, 0.05225649f, 0.04221518f, 0.06346659f, 0.03616683f, -0.01271271f, 0.01222666f, 0.04077967f, 
    0.02885767f, 0.13601470f, 0.01325689f, 0.16105446f, -0.03671056f, -0.06318915f, -0.02420399f, 0.06519568f, 
    -0.04400384f, -0.08210712f, 0.05467479f, -0.03492327f, 0.24239452f, -0.04027316f, 0.06634780f, -0.06646888f, 
    -0.06790554f, -0.10859182f, -0.03229164f, 0.04488039f, -0.07564115f, -0.14715940f, -0.15180126f, 0.01622046f, 
    0.08745466f, 0.12819117f, 0.20440845f, 0.06554615f, -0.11231989f, -0.02435695f, -0.04392158f, -0.00920999f, 
    0.00525298f, -0.00072183f, -0.00077749f, -0.02294310f, -0.15228172f, 0.07048181f, 0.17951976f, -0.20191197f, 
    -0.02211172f, 0.04124667f, -0.00658530f, -0.11805153f, -0.02068458f, 0.04856823f, -0.04462698f, -0.00073178f, 
    0.37009689f, 0.21125713f, -0.01624165f, 0.06928077f, -0.03928240f, 0.09036861f, -0.02490569f, 0.09018257f, 
    -0.05770713f, 0.00339789f, 0.00528381f, 0.04781729f, -0.12938118f, -0.11798485f, -0.09941266f, -0.03032380f, 
    0.06131523f, -0.00728698f, 0.00728301f, -0.15434374f, 0.02362164f, -0.04062913f, -0.00980959f, 0.04539409f, 
    0.01300585f, -0.21915141f, -0.24644710f, 0.01743832f, 0.00430631f, -0.05703021f, -0.06881349f, 0.01486867f, 
    0.01507130f, -0.07830134f, 0.01926368f, -0.03967123f, 0.20249586f, 0.00374708f, -0.08258461f, 0.11721358f, 
    0.04101694f, 0.07538918f, 0.10499560f, -0.02139009f, 0.14647661f, 0.05041550f, 0.04162562f, 0.00115085f, 
    -0.35167882f, -0.00911657f, 0.08706037f, 0.11954153f, 0.00104600f, -0.06739061f, 0.07151792f, 0.13819744f, 
    -0.02243229f, -0.00653460f, -0.04933245f, 0.05895505f, 0.15847400f, 0.22865321f, 0.12699977f, 0.09189119f, 
    -0.15228809f, 0.06156498f, -0.04875443f, -0.02629597f, 0.00924230f, 0.05920346f, 0.15894055f, -0.10730397f, 
    0.00465237f, -0.10049883f, -0.07619015f, 0.02439309f, 0.08866804f, 0.00830370f, 0.05908631f, -0.01582658f, 
    -0.01016679f, -0.13181658f, -0.09294624f, -0.00222852f, 0.15794183f, -0.10931060f, -0.11277375f, -0.24929537f, 
    0.00128086f, 0.07232544f, -0.06079270f, -0.01587711f, 0.04127269f, 0.04382008f, 0.05865193f, -0.07716256f, 
    -0.01069026f, -0.24200185f, -0.18289992f, 0.15187488f, 0.06462102f, 0.03893443f, 0.01764839f, -0.01408812f, 
    0.05829492f, 0.09396360f, -0.11684401f, 0.02151554f, 0.01701830f, 0.21186878f, 0.16360015f, -0.03397363f, 
    0.11955725f, -0.09445211f, 0.01704988f, -0.03685751f, -0.00462717f, 0.01859276f, 0.01614230f, -0.02919610f, 
    -0.21436866f, 0.05692977f, 0.05193303f, -0.01772510f, 0.00579698f, -0.00241192f, -0.01629939f, 0.08104860f, 
    -0.04685105f, 0.04557594f, 0.00585921f, 0.03571092f, 0.15506333f, -0.10595205f, -0.37436098f, 0.14706111f, 
    0.05854350f, -0.07232161f, 0.11253462f, 0.01912076f, 0.06716104f, -0.03395437f, 0.08515212f, -0.00314766f, 
    -0.17136458f, -0.08267218f, 0.10756800f, -0.06548594f, -0.00874007f, -0.12223428f, 0.00674449f, -0.10270806f, 
    -0.06064501f, 0.12928414f, 0.07561553f, -0.05337183f, 0.09845209f, 0.14590764f, -0.00916167f, 0.16618957f, 
    0.04993600f, 0.06938783f, -0.00883070f, 0.02901643f, -0.05281294f, -0.01341378f, -0.07475650f, -0.02948171f, 
    -0.06395714f, 0.08694648f, 0.18024001f, 0.13520940f, 0.01913333f, -0.11612091f, 0.01742634f, 0.07260430f, 
    0.09271094f, 0.03317237f, 0.01862746f, 0.10859828f, 0.01591356f, -0.17647630f, -0.14475550f, -0.03750148f, 
    -0.09104396f, -0.18412557f, -0.02815544f, 0.02753791f, -0.12738977f, 0.08745620f, 0.09664982f, -0.05243005f, 
    -0.02128275f, 0.25490391f, -0.02252062f, 0.13844697f, -0.11239263f, -0.11544000f, 0.08546083f, 0.20050868f, 
    -0.05031724f, 0.00889081f, 0.06835169f, 0.07947877f, 0.24333782f, -0.01242771f, 0.11938164f, -0.03954023f, 
    0.06525695f, 0.04771465f, -0.08626165f, 0.02148088f, -0.14615878f, 0.02958127f, -0.15955237f, 0.04787175f, 
    0.23029242f, 0.21571401f, 0.14166357f, 0.13669722f, -0.06858306f, 0.19441845f, -0.03366397f, -0.02049786f, 
    -0.05230187f, 0.08779346f, 0.01600984f, -0.02686301f, 0.03335024f, 0.21785034f, -0.09399570f, 0.22882168f, 
    -0.01731903f, -0.12537600f, -0.03738175f, 0.13579330f, -0.05332068f, -0.05773805f, 0.05470866f, -0.06031333f, 
    0.17647606f, 0.02272345f, -0.14567533f, 0.09370968f, 0.13031827f, -0.07752405f, -0.04267443f, -0.02045092f, 
    -0.08870999f, -0.07043115f, 0.06428830f, 0.01864125f, 0.07680106f, 0.24968654f, 0.03027411f, 0.08986423f, 
    -0.12852030f, -0.00364340f, 0.06274269f, -0.03469347f, -0.02029819f, -0.01769749f, 0.01973289f, -0.03439117f, 
    -0.16463664f, 0.08385679f, 0.03097458f, -0.12270160f, 0.15922803f, 0.04517222f, -0.08598053f, -0.02207454f, 
    -0.03943933f, 0.08825221f, 0.01817448f, 0.02993303f, 0.16734402f, 0.14392060f, 0.17204159f, 0.16807662f, 
    0.10759095f, -0.03879882f, 0.05280423f, 0.05246027f, -0.02880167f, -0.14219287f, 0.11665917f, 0.06445865f, 
    0.10527090f, 0.02548105f, 0.07234648f, 0.02381494f, 0.10874830f, -0.00962748f, 0.04934581f, 0.08133450f, 
    0.16617161f, -0.05160927f, 0.00469537f, 0.08067810f, -0.01008489f, -0.05909490f, 0.01440217f, 0.01528266f, 
    -0.06716180f, 0.14618687f, 0.06013450f, 0.03141734f, 0.11014724f, -0.04606979f, -0.01280209f, 0.04238437f, 
    0.37840855f, 0.00887159f, -0.06841756f, 0.03579992f, -0.08580141f, -0.11953326f, -0.10853235f, 0.01932287f, 
    0.00273738f, 0.04448999f, 0.03027355f, -0.08779792f, -0.07452944f, 0.10062732f, 0.06801508f, 0.17779073f, 
    0.03647764f, 0.00249788f, 0.03584287f, 0.11074103f, 0.00874149f, -0.00075188f, -0.00094878f, -0.01580093f, 
    -0.08392923f, -0.00371167f, -0.14318438f, 0.15465662f, 0.05365670f, -0.12331973f, -0.00892282f, 0.03782604f, 
    0.01612745f, -0.13596384f, 0.08570255f, -0.07101063f, -0.10201325f, 0.16579053f, 0.08041024f, -0.09080005f, 
    -0.03878588f, -0.01329844f, -0.02339611f, 0.06894428f, -0.14050998f, 0.06855682f, 0.03354215f, 0.03093674f, 
    -0.19504543f, -0.10039239f, 0.10097697f, 0.04619558f, 0.07791005f, 0.02852865f, 0.08452667f, -0.08644232f, 
    0.07450086f, -0.06421401f, -0.02812895f, -0.07402951f, 0.22459196f, -0.02890035f, 0.08650305f, -0.08844058f, 
    -0.04247427f, 0.07168590f, -0.06744877f, -0.00551291f, -0.19473916f, -0.10707965f, 0.06513677f, -0.00902299f, 
    -0.00773825f, 0.01359893f, -0.04220961f, 0.01274126f, 0.02800218f, 0.03290869f, -0.03279993f, -0.04003236f, 
    -0.01067566f, -0.02018489f, 0.03475270f, -0.00410427f, 0.02091967f, 0.01470623f, 0.00967189f, 0.03430146f, 
    0.01477524f, -0.00067064f, 0.02206929f, -0.03451371f, -0.01152182f, 0.02092493f, -0.02813681f, -0.02815575f, 
    0.02495101f, -0.04462131f, 0.02875360f, 0.00558767f, -0.02905268f, 0.01151139f, 0.02156177f, -0.02732112f, 
    -0.01794771f, -0.00306348f, -0.02855892f, 0.02559529f, -0.00124628f, -0.01695729f, -0.02414797f, -0.02954290f, 
    0.02003016f, 0.01605936f, 0.00289496f, 0.01737672f, 0.00794190f, -0.01835615f, 0.01429416f, -0.01970144f, 
    -0.02159110f, -0.02570070f, 0.01328358f, -0.01208412f, -0.01587030f, -0.01176928f, -0.02135077f, -0.03880568f, 
    0.00275019f, -0.01812903f, -0.04027636f, 0.01884035f, -0.04025000f, -0.00483898f, -0.00984084f, -0.04642158f, 
    0.02946672f, -0.03035035f, -0.01178069f, -0.00452152f, 0.00297681f, -0.01499738f, -0.01473240f, 0.00089083f, 
    -0.01566395f, -0.03698875f, 0.02768919f, -0.01470119f, -0.03422926f, -0.01499781f, 0.01633041f, -0.00771476f, 
    -0.01766837f, -0.01072161f, 0.00020835f, -0.02063518f, 0.00221938f, 0.03730269f, 0.00563746f, 0.02153286f, 
    -0.01556992f, -0.01504759f, 0.00970273f, -0.03880150f, -0.04250415f, 0.03319579f, 0.02742077f, 0.01954549f, 
    -0.03283200f, 0.02235615f, 0.02015871f, -0.04065906f, -0.00010654f, -0.00396663f, -0.01302993f, 0.00544695f, 
    0.02009838f, 0.02450149f, 0.01538760f, -0.00445493f, -0.00441248f, 0.00939711f, -0.01651467f, 0.00661681f, 
    -0.00010660f, -0.00837880f, 0.00718232f, -0.01911407f, -0.04487600f, -0.01836321f, -0.02282701f, 0.02518423f, 
    0.01622115f, 0.03533123f, -0.03879827f, -0.02693657f, 0.02457216f, 0.00466342f, 0.02603951f, 0.00577016f, 
    -0.03166384f, 0.01663621f, 0.02826964f, 0.01826151f, 0.01564594f, -0.02673879f, -0.02144156f, -0.00896805f, 
    0.01860363f, 0.01377713f, -0.00566731f, -0.03702934f, -0.02252056f, -0.00497345f, -0.00434255f, 0.00772175f, 
    0.01147587f, -0.01741694f, 0.01513382f, 0.01965900f, -0.00431540f, -0.00923165f, -0.00810420f, 0.00444320f, 
    0.00132872f, -0.03949023f, 0.02903150f, -0.02449596f, -0.00382011f, 0.01973650f, -0.00344185f, -0.00978799f, 
    0.00613047f, -0.03076616f, -0.01322332f, 0.00757990f, -0.00166006f, -0.02334954f, -0.03386927f, -0.02952164f, 
    -0.04502613f, -0.03883746f, -0.00282997f, -0.01534854f, 0.02979228f, 0.00150823f, 0.00084386f, 0.01505468f, 
    -0.01024351f, -0.02418933f, -0.00856818f, 0.01422840f, -0.02933625f, -0.03527087f, 0.00229124f, -0.02230135f, 
    -0.01224013f, -0.00327762f, -0.03413690f, 0.02609773f, 0.02036754f, -0.02503364f, -0.04113369f, -0.01784620f, 
    0.02189820f, -0.02354106f, -0.03292019f, -0.01638785f, -0.03178855f, -0.00941820f, -0.01280163f, -0.01680176f, 
    -0.02461926f, 0.00858042f, -0.01141188f, -0.03594882f, -0.01478980f, 0.01889547f, 0.01482137f, 0.01611453f, 
    0.02971217f, -0.01043948f, 0.02190295f, 0.00330762f, 0.01562949f, -0.02590732f, -0.02350602f, -0.00379741f, 
    -0.00655499f, -0.00233373f, -0.02827268f, -0.00661395f, 0.01442947f, -0.00048861f, -0.00673339f, -0.00703630f, 
    -0.00192483f, -0.02474465f, 0.02371360f, 0.00071839f, 0.00429352f, -0.01949237f, 0.01796189f, -0.02784428f, 
    0.02400523f, -0.00365769f, -0.03965297f, 0.00491478f, 0.00342238f, -0.04390938f, -0.01747148f, 0.01116596f, 
    -0.03966879f, -0.01949323f, 0.00874824f, 0.01428206f, 0.01086695f, 0.01919214f, 0.01255868f, -0.01988909f, 
    -0.01138717f, -0.03055747f, -0.02523453f, -0.00811357f, 0.02561547f, -0.04633008f, 0.01279329f, 0.02174275f, 
    -0.02996169f, -0.01871628f, 0.01256313f, 0.00579038f, -0.02606820f, -0.01846167f, 0.02773966f, 0.00315407f, 
    0.00866757f, -0.02284425f, 0.02770506f, 0.03299504f, 0.01865405f, 0.01603452f, 0.00221835f, -0.00899551f, 
    -0.01254354f, 0.01044391f, 0.00614580f, 0.00047929f, -0.01675597f, -0.02214865f, -0.01280978f, -0.01645188f, 
    -0.01302224f, -0.03450683f, 0.02931529f, -0.00251895f, -0.00353308f, 0.01916983f, -0.03169943f, 0.00001826f, 
    -0.02813509f, 0.01718130f, 0.00450961f, -0.03557464f, 0.01719777f, 0.02828842f, 0.01558876f, 0.00785702f, 
    -0.02340221f, 0.00061104f, 0.00562259f, 0.02231831f, -0.02140396f, 0.00865995f, 0.01987800f, -0.00418662f, 
    -0.02349690f, 0.00617192f, -0.00260490f, 0.01558483f, 0.00958924f, 0.00594098f, -0.01496635f, -0.02617304f, 
    -0.00544839f, -0.02834310f, 0.01812148f, 0.01658841f, -0.02423287f, -0.03444588f, 0.00744077f, -0.02042292f, 
    -0.03402369f, -0.01912659f, 0.01969118f, -0.02877781f, -0.02892861f, 0.03908871f, -0.03071970f, 0.01976039f, 
    -0.02250839f, -0.00663185f, 0.00477975f, 0.01554528f, -0.02203312f, -0.02823925f, 0.01722676f, 0.02020252f, 
    -0.02733427f, -0.01107415f, 0.00726066f, -0.01229160f, 0.02025940f, 0.02840394f, 0.00625899f, 0.02852353f, 
    -0.01021908f, -0.03657801f, 0.00074545f, 0.00646795f, -0.00320348f, -0.02400732f, 0.00573461f, -0.00634761f, 
    -0.01581124f, -0.01423923f, -0.00295765f, 0.03148148f, -0.00733906f, -0.03102420f, -0.03548508f, -0.00605887f, 
    0.00535225f, -0.02547912f, 0.02662243f, -0.00621040f, -0.00716129f, 0.00259565f, 0.00426612f, -0.01348451f, 
    -0.01757062f, 0.02639372f, 0.00303567f, 0.01116019f, 0.02437972f, -0.00630487f, 0.00543583f, -0.02393647f, 
    0.01241380f, -0.03691264f, -0.02098869f, 0.02733959f, 0.01504213f, -0.02785963f, 0.03037222f, 0.01355358f, 
    0.01407562f, 0.01429343f, -0.01367097f, 0.02636124f, 0.00193195f, 0.00470253f, -0.00308858f, 0.01439729f, 
    0.00354890f, 0.02526049f, 0.00015584f, 0.02567492f, 0.03512925f, -0.02400733f, 0.01086615f, -0.01501551f, 
    -0.03098907f, 0.02655877f, -0.02559689f, -0.00005020f, 0.01547825f, 0.01232883f, -0.01117226f, -0.00206867f, 
    -0.01295002f, -0.03760365f, 0.01209618f, 0.02529460f, -0.01466240f, -0.02708055f, 0.03222553f, -0.00795446f, 
    -0.02893629f, 0.01098167f, 0.00925240f, 0.00405388f, 0.00499495f, 0.00184703f, 0.03287201f, 0.03090309f, 
    -0.04129063f, -0.02496320f, 0.01510196f, 0.00752258f, -0.02973730f, 0.02938791f, -0.02099958f, 0.02803879f, 
    0.00138386f, -0.02203869f, 0.00091649f, -0.00608051f, -0.02959044f, -0.03856454f, -0.03275847f, -0.03136845f, 
    -0.02166791f, 0.01962114f, 0.00184378f, 0.00238034f, -0.03313958f, 0.01401553f, -0.04126279f, -0.03442218f, 
    -0.01025933f, 0.01913503f, 0.03187571f, -0.00131543f, 0.01602428f, 0.00463820f, -0.02071651f, 0.02238011f, 
    -0.00727001f, 0.00528220f, 0.01643565f, -0.01873805f, -0.00081836f, -0.02162449f, 0.02556264f, 0.01481295f, 
    -0.00890485f, -0.01820621f, 0.03223812f, 0.01646580f, -0.03842058f, 0.01948518f, 0.00312942f, 0.01798827f, 
    -0.02264675f, 0.00336656f, 0.02617243f, -0.03296420f, 0.03201762f, 0.00536337f, 0.02727369f, -0.00428904f, 
    0.01195787f, -0.00800168f, -0.03514819f, 0.00846332f, -0.00899035f, -0.02052276f, 0.01372721f, -0.02878336f, 
    -0.02602240f, 0.00128535f, 0.01018265f, -0.00284446f, -0.03363245f, 0.02133449f, -0.02491780f, -0.03816473f, 
    -0.02168246f, -0.00044316f, 0.01363227f, -0.00901688f, -0.02167606f, -0.02105482f, 0.00165333f, -0.03470168f, 
    -0.03411015f, 0.02480426f, -0.02826916f, -0.00598337f, 0.02011236f, 0.01716189f, -0.03535882f, -0.02322468f, 
    -0.00836852f, -0.01392245f, -0.00148021f, -0.00908659f, -0.01029532f, 0.02937343f, 0.00990186f, -0.03467488f, 
    -0.03184464f, 0.01874495f, -0.03176031f, -0.01455550f, 0.00476121f, -0.00427933f, 0.01863656f, -0.00073886f, 
    -0.00735232f, -0.00631978f, 0.00002021f, -0.00937719f, 0.01674157f, -0.01207785f, -0.02021779f, -0.02612313f, 
    -0.00793929f, -0.02114611f, 0.02362466f, -0.03911531f, 0.02210884f, -0.00728373f, -0.01344451f, 0.02500678f, 
    -0.00640264f, 0.00797300f, -0.00938321f, 0.01277027f, -0.02239397f, 0.02543435f, -0.01741700f, -0.01616141f, 
    0.01327431f, 0.03526944f, 0.01392306f, -0.03408348f, 0.00877072f, 0.02378626f, -0.00110593f, -0.01488211f, 
    -0.02477509f, 0.01030676f, 0.01235709f, 0.00545345f, -0.00377983f, -0.01813791f, 0.02212605f, -0.01840867f, 
    -0.02544410f, -0.03589100f, 0.01964007f, -0.04798013f, 0.00984624f, -0.02322518f, -0.03070252f, -0.04273072f, 
    0.03490356f, 0.02034323f, 0.00681213f, 0.01609597f, 0.01983547f, 0.01638151f, -0.03563933f, -0.03832734f, 
    0.01136350f, -0.03052359f, -0.02205214f, 0.00151467f, -0.00232748f, -0.03205314f, -0.01714317f, -0.01529390f, 
    -0.01443005f, 0.00426077f, -0.01534776f, 0.01023294f, -0.00114347f, -0.02376102f, -0.03022040f, -0.02546429f, 
    0.02622973f, 0.00987751f, -0.03439608f, 0.02829001f, -0.03324056f, -0.03674128f, 0.02297833f, -0.03104241f, 
    -0.02895376f, 0.00228222f, 0.02284115f, 0.00881936f, -0.04023042f, 0.00588076f, -0.03829914f, -0.01341193f, 
    0.01504243f, -0.03320499f, 0.01868888f, 0.02538138f, -0.00552734f, -0.04030564f, -0.01827214f, -0.04078241f, 
    -0.01078872f, 0.00672597f, -0.00648236f, -0.00708782f, -0.03614040f, 0.02069150f, 0.00034022f, 0.03216824f, 
    0.02734106f, -0.03660163f, 0.02948793f, -0.03085719f, -0.01525834f, 0.00582542f, -0.03837031f, 0.02829680f, 
    0.02903607f, -0.03515088f, 0.01335803f, -0.03368753f, -0.01845775f, -0.02240985f, 0.01769902f, -0.00434575f, 
    0.00482693f, -0.04052613f, -0.02750833f, -0.01846022f, -0.04028741f, 0.03575491f, 0.02027318f, -0.02677720f, 
    -0.03247161f, 0.00322632f, 0.02784230f, -0.04336403f, -0.00097111f, -0.01965329f, -0.01967999f, -0.00434455f, 
    -0.01681822f, 0.00962930f, 0.01574625f, 0.02757432f, -0.03341414f, -0.02299301f, 0.00214681f, 0.01027488f, 
    0.02221547f, -0.01907615f, 0.02038602f, 0.00713035f, -0.01422837f, 0.00195331f, -0.03784298f, -0.03981709f, 
    -0.01408540f, 0.02771373f, -0.03910563f, -0.02007872f, -0.00006040f, 0.02036961f, 0.01327730f, 0.00308462f, 
    -0.01315171f, -0.00889036f, -0.01434871f, 0.02165859f, 0.01024825f, -0.00098936f, -0.01015359f, -0.00590927f, 
    -0.01955205f, 0.00536613f, 0.01895623f, 0.00982327f, 0.01271995f, 0.00842919f, -0.03784811f, -0.01177824f, 
    0.03192286f, -0.00766106f, 0.00031818f, -0.02755927f, -0.03106752f, -0.03135017f, 0.02522883f, -0.03081770f, 
    -0.01789067f, 0.02393904f, 0.00879588f, 0.03013794f, -0.02534585f, -0.01901178f, 0.00867680f, -0.01356474f, 
    -0.04326533f, 0.00656839f, -0.03081837f, -0.02175882f, 0.02311890f, -0.00327298f, 0.01142889f, -0.00557039f, 
    0.00916507f, 0.00678711f, -0.02608149f, 0.03113743f, -0.02684327f, 0.02381193f, -0.00842035f, 0.02260073f, 
    -0.00434983f, -0.01583899f, 0.02969338f, 0.00880118f, -0.02610209f, -0.02392118f, 0.00342862f, -0.00853382f, 
    0.00288763f, 0.00675737f, 0.03398804f, 0.03308623f, -0.02170900f, -0.00824141f, 0.00714526f, 0.03292770f, 
    -0.01388901f, 0.02504025f, -0.01444475f, 0.00914814f, -0.00789273f, -0.03751913f, -0.02724505f, -0.03439750f, 
    -0.02142801f, -0.01280942f, 0.01978273f, 0.02864206f, 0.01675514f, 0.00165236f, -0.02492738f, -0.02568018f, 
    -0.01950218f, -0.01469700f, -0.01553771f, 0.02267013f, 0.02975687f, -0.00058426f, -0.02914792f, -0.01681070f, 
    -0.03754916f, 0.02571605f, 0.01827824f, -0.03111743f, 0.00204664f, -0.02111768f, 0.02166955f, -0.03786260f, 
    0.00397968f, 0.03120935f, 0.02997079f, 0.00099895f, -0.00019285f, -0.00794779f, -0.02673296f, 0.01326358f, 
    -0.00553477f, 0.00802750f, 0.00935680f, 0.02313868f, -0.00102632f, -0.03250512f, -0.03396681f, -0.02447662f, 
    -0.01721867f, -0.02339843f, 0.01958442f, -0.03703734f, 0.02151420f, 0.01485828f, -0.03021995f, 0.00959031f, 
    0.01172067f, 0.02576424f, -0.00410508f, -0.04187365f, -0.01323645f, -0.03195347f, -0.03732932f, -0.01987527f, 
    0.00683985f, -0.03311034f, 0.02507356f, -0.01300902f, -0.00827401f, 0.02081013f, -0.00348823f, 0.01253339f, 
    0.02996658f, -0.01871907f, -0.02579181f, -0.00381913f, 0.00065756f, 0.00646348f, 0.01183702f, -0.00260689f, 
    -0.03112700f, -0.02286304f, 0.00101924f, -0.04157089f, -0.02233982f, 0.00664792f, 0.02445955f, 0.02519752f, 
    -0.02338411f, 0.00418629f, 0.00365878f, -0.02812077f, 0.00239423f, 0.01557464f, -0.03864549f, -0.01091661f, 
    -0.00316008f, -0.02499608f, -0.02628930f, -0.04137081f, 0.02468966f, -0.03969261f, 0.02319987f, -0.02840084f, 
    0.00970227f, 0.02249957f, 0.02819873f, -0.00416045f, -0.02941781f, -0.03266548f, 0.00624059f, -0.03452531f, 
    0.02506725f, -0.01419332f, -0.03621025f, -0.03080633f, -0.03738580f, 0.00481514f, -0.01094746f, 0.00707076f, 
    0.01533074f, -0.01216514f, -0.01223012f, -0.00495663f, -0.02977688f, -0.03297726f, -0.01793029f, 0.01757015f, 
    0.02568024f, 0.00280905f, -0.01147508f, 0.00985984f, 0.01042453f, -0.02364176f, -0.03049359f, 0.03062495f, 
    0.01607775f, -0.03196788f, -0.03940342f, -0.01119905f, 0.02172772f, -0.01049347f, -0.03561909f, 0.01401247f, 
    -0.03536236f, 0.00537916f, 0.01480036f, 0.02697200f, -0.00076171f, -0.01795590f, -0.01449922f, 0.01035211f, 
    -0.02356732f, -0.01856456f, -0.03115547f, 0.02503615f, 0.02080654f, -0.03870958f, 0.00530835f, 0.01762424f, 
    -0.02876763f, -0.03413379f, -0.02227858f, -0.01066499f, -0.02833764f, 0.00134547f, -0.03598691f, -0.00536290f, 
    0.02479304f, -0.02531967f, -0.04156462f, 0.01488482f, -0.03591424f, -0.00632487f, -0.01062680f, 0.02102058f, 
    -0.00388213f, 0.02985062f, -0.00131592f, -0.00412947f, -0.03839440f, -0.00736445f, -0.02088991f, -0.00432010f, 
    -0.02693773f, -0.00528795f, -0.02813501f, 0.01056113f, -0.01018741f, 0.00187024f, -0.02435015f, 0.01088071f, 
    -0.02361880f, -0.01541458f, -0.02155491f, -0.01376183f, 0.01600654f, 0.00247306f, 0.00572571f, 0.02692605f, 
    -0.01401499f, 0.01256668f, -0.03114983f, -0.01859660f, 0.01676580f, -0.04113270f, -0.02101229f, -0.02604304f, 
    -0.01168333f, -0.03104595f, 0.02612793f, 0.00831064f, -0.00306813f, -0.03435833f, -0.02431823f, 0.02895716f, 
    -0.00618685f, 0.02828127f, -0.02493342f, 0.00043239f, -0.03181450f, -0.01181785f, -0.03955644f, 0.02331915f, 
    -0.01126331f, -0.00269698f, -0.02608656f, -0.02896404f, 0.00053894f, -0.00172702f, -0.04018301f, 0.02815935f, 
    0.02137063f, 0.01811783f, -0.01001952f, 0.02235926f, -0.03625961f, -0.01998965f, -0.03179978f, -0.03468116f, 
    -0.01950637f, 0.02040405f, -0.01384249f, 0.02366352f, -0.03527844f, -0.03838863f, -0.01327765f, 0.02956776f, 
    0.02538222f, -0.00712282f, 0.02807610f, 0.01802181f, 0.01251035f, -0.03412133f, -0.03851607f, -0.03204171f, 
    0.02973211f, -0.02607534f, -0.03672144f, -0.04062745f, 0.01190442f, 0.02136255f, -0.04105484f, -0.02064507f, 
    -0.03858909f, 0.00129384f, -0.00076018f, 0.01099748f, -0.00506058f, -0.03804049f, 0.01098967f, -0.02449057f, 
    -0.02400598f, -0.02014409f, -0.00293004f, 0.02859958f, -0.00447087f, -0.03436581f, -0.01738033f, -0.02681744f, 
    -0.03078634f, -0.02466573f, -0.01101317f, -0.02565464f, 0.00380381f, -0.03725604f, 0.01555851f, 0.02190555f, 
    -0.00919912f, -0.01689532f, -0.02023469f, 0.00727705f, 0.02982289f, -0.02811457f, 0.02034147f, -0.00491173f, 
    -0.00789563f, -0.02563913f, -0.00197470f, 0.01939131f, -0.02904828f, -0.03916168f, 0.02741838f, -0.02103599f, 
    0.01546275f, -0.03603914f, -0.03695925f, -0.01435560f, -0.04000446f, -0.03219072f, 0.01247245f, -0.02214554f, 
    -0.03700896f, -0.01247391f, -0.03427107f, 0.02796568f, 0.01589452f, -0.01533308f, 0.01320022f, -0.01270912f, 
    -0.03672104f, -0.00887699f, 0.02508374f, 0.02054167f, -0.02725842f, 0.02025096f, 0.02719262f, -0.01735193f, 
    0.02295140f, -0.01726971f, -0.00171270f, 0.02051355f, -0.01177564f, 0.00727924f, 0.00762005f, 0.00653772f, 
    0.02300731f, -0.02123834f, -0.01490030f, -0.00753709f, -0.01039123f, 0.02921076f, 0.01208516f, 0.00981863f, 
    -0.00907891f, -0.00220544f, -0.02897893f, -0.00508878f, 0.00404410f, -0.03836771f, -0.00560890f, -0.01853205f, 
    0.00445102f, -0.01651693f, 0.01959837f, -0.02891806f, -0.03079596f, 0.00787411f, -0.00722826f, -0.03538574f, 
    0.02274123f, -0.03988746f, -0.00993697f, -0.01386872f, -0.00230117f, 0.02806181f, -0.02491718f, -0.02796239f, 
    0.02591922f, 0.02775587f, 0.02042075f, -0.00172537f, -0.01408984f, -0.01220953f, -0.02628546f, -0.00326507f, 
    0.02799081f, 0.01825461f, -0.00525643f, 0.02444253f, 0.02883663f, -0.02139980f, -0.02706628f, 0.00424748f, 
    0.02809213f, -0.02070623f, 0.01234455f, -0.02273136f, -0.01490999f, -0.02569331f, 0.02301485f, 0.00361043f, 
    0.01271577f, 0.02993826f, 0.01703680f, -0.03117521f, -0.00281472f, -0.02712619f, -0.00974243f, 0.01884373f, 
    0.01247133f, -0.03094730f, 0.01355565f, -0.01386703f, -0.01449498f, 0.00409504f, 0.01956923f, 0.01851984f, 
    -0.00964562f, -0.01089838f, 0.00373972f, -0.03491603f, 0.00390769f, -0.02033971f, -0.01859067f, -0.02740081f, 
    -0.03485512f, -0.01019518f, -0.01119965f, 0.00972211f, 0.00584615f, 0.00802233f, -0.01440217f, -0.02919191f, 
    -0.00836052f, -0.02597965f, -0.03401598f, 0.01279721f, 0.01541854f, 0.02628900f, -0.01324370f, -0.01362931f, 
    0.01175303f, 0.01092591f, 0.01168996f, -0.04195778f, -0.02624653f, -0.02304834f, 0.00240611f, 0.03004036f, 
    -0.01264849f, 0.02152381f, 0.02884671f, 0.01753462f, -0.02523073f, 0.02869185f, 0.02624994f, -0.00710390f, 
    0.00667085f, -0.00471378f, -0.03722069f, -0.00125787f, 0.01835939f, -0.04153097f, 0.00486768f, -0.03869615f, 
    -0.02377573f, 0.00346536f, -0.01447329f, 0.00781113f, 0.02637632f, -0.01342838f, 0.01173076f, 0.01556050f, 
    -0.00212052f, -0.02437029f, -0.01225863f, -0.01610379f, -0.02601517f, -0.03643827f, -0.02148516f, -0.03428444f, 
    -0.01513169f, 0.00943701f, -0.03176223f, 0.00488111f, -0.01843050f, 0.02018916f, -0.03830635f, -0.00112712f, 
    -0.02590972f, 0.02437644f, -0.01314734f, 0.01344697f, -0.03387248f, -0.02944980f, -0.00394367f, 0.01103710f, 
    0.00795123f, 0.02090430f, 0.01663396f, -0.00052135f, -0.01058104f, 0.02550334f, 0.02522098f, -0.02072560f, 
    0.00178527f, 0.01288173f, 0.02796291f, 0.01668938f, 0.00723590f, -0.02917073f, -0.01579215f, -0.00648643f, 
    0.02631131f, -0.01226926f, 0.02007754f, 0.02965314f, -0.04039019f, -0.04105892f, -0.00840687f, -0.04161850f, 
    -0.00048375f, 0.00137792f, -0.02246406f, -0.02113193f, -0.00756560f, 0.02397544f, 0.02236854f, -0.02864883f, 
    -0.00832070f, -0.01887645f, -0.00558251f, -0.01272148f, 0.02310868f, -0.00025506f, 0.00433009f, -0.03742205f, 
    0.01290770f, -0.02602788f, -0.03812518f, 0.02786832f, 0.00757096f, -0.01918052f, 0.02578648f, 0.01177426f, 
    -0.01160960f, -0.02886282f, 0.00262605f, -0.02211979f, -0.03308931f, 0.00327685f, -0.02333749f, -0.02631235f, 
    -0.00757027f, 0.02359687f, 0.02385911f, -0.00404966f, -0.01777277f, -0.01861624f, -0.02523526f, 0.02776077f, 
    -0.01106958f, -0.03450949f, -0.01919532f, -0.03682303f, 0.02491978f, -0.02957878f, 0.01046825f, 0.02179158f, 
    -0.01178178f, 0.01353909f, 0.00680020f, 0.00719757f, 0.02139935f, 0.00233893f, -0.03536413f, -0.01660788f, 
    0.02706623f, -0.02179218f, 0.00434718f, 0.01317868f, 0.01281772f, 0.02546480f, -0.02017797f, 0.00430526f, 
    -0.02064501f, -0.03420034f, -0.03940134f, 0.02505066f, -0.00079967f, -0.00028884f, -0.00298896f, -0.00076452f, 
    -0.03190947f, -0.00373034f, 0.01364257f, -0.02879224f, 0.02730605f, 0.02238449f, -0.01853272f, -0.03139106f, 
    0.01900645f, -0.02337007f, 0.01140823f, -0.01674582f, 0.02148630f, 0.01197996f, -0.02303168f, 0.02915543f, 
    0.03352208f, -0.00652123f, -0.03300632f, -0.03326117f, -0.00246055f, -0.01474120f, -0.03373986f, 0.00110424f, 
    -0.03421579f, 0.00754239f, -0.02169584f, -0.01402856f, -0.00532501f, -0.00556753f, 0.02043974f, -0.01281323f, 
    0.01540214f, -0.03832074f, -0.02327405f, 0.01381772f, -0.02705513f, -0.01460899f, -0.00386241f, 0.00964773f, 
    -0.04093758f, 0.02386412f, -0.00029312f, 0.01947352f, -0.03114511f, -0.01817992f, 0.01675356f, -0.02778042f, 
    -0.02073715f, -0.02036108f, -0.01479963f, -0.00934642f, -0.04088771f, -0.02663751f, -0.02072097f, -0.00009793f, 
    0.01996514f, -0.00495925f, -0.01474087f, -0.01119653f, -0.01399540f, 0.01657447f, -0.03435980f, -0.02126713f, 
    0.01069142f, -0.01046291f, -0.01465905f, -0.00531398f, -0.03012577f, -0.02072680f, -0.01033739f, 0.00485773f, 
    -0.00273985f, 0.01778346f, -0.03174123f, 0.02307612f, -0.01032986f, 0.01445790f, 0.00264661f, -0.00984911f, 
    -0.03303527f, 0.00591514f, -0.00405963f, 0.01083348f, 0.02619408f, -0.03405961f, -0.03965572f, -0.01632666f, 
    0.02371256f, -0.03291776f, -0.03500385f, -0.00494378f, 0.02222076f, 0.01346521f, -0.00267379f, -0.02130658f, 
    0.03489786f, -0.00694641f, 0.01458188f, -0.00628859f, 0.01155981f, -0.02139503f, -0.00853764f, 0.00777191f, 
    0.01163290f, -0.03551025f, 0.01442114f, -0.04099083f, -0.02024605f, 0.02467776f, 0.02929544f, 0.01756858f, 
    0.03005235f, -0.01445062f, -0.03632689f, -0.00790993f, 0.02387499f, -0.03013426f, 0.01404775f, 0.02497450f, 
    -0.02844105f, 0.01806913f, 0.02177614f, 0.02489840f, -0.01644002f, -0.03136507f, -0.03069547f, -0.03354825f, 
    -0.02240019f, -0.02001769f, 0.02513593f, -0.00784877f, -0.03024198f, -0.01427332f, -0.01977754f, -0.00289660f, 
    -0.02071188f, 0.02629604f, -0.04105132f, -0.01171251f, -0.00606277f, 0.02057436f, 0.00260838f, 0.02200682f, 
    -0.01611945f, -0.00359381f, -0.03422604f, -0.02626763f, 0.01026886f, 0.03326643f, -0.03726077f, -0.02600760f, 
    -0.02274819f, -0.01473697f, 0.02358869f, 0.02664791f, -0.03387511f, -0.00721074f, -0.00479879f, -0.03577451f, 
    -0.02767208f, 0.01662408f, 0.01770790f, -0.02588951f, -0.02507807f, -0.00986164f, -0.02441608f, 0.00258004f, 
    0.00002149f, 0.00366322f, -0.01397958f, 0.02009556f, -0.02852801f, 0.00831702f, 0.01151707f, 0.02180264f, 
    0.01208751f, -0.01105683f, -0.03854986f, -0.00207785f, -0.02129009f, -0.03931429f, -0.01826418f, -0.00529087f, 
    -0.00540013f, 0.02032601f, -0.02270958f, -0.00890076f, 0.01317883f, -0.00506027f, -0.03083468f, -0.03149717f, 
    -0.02850946f, 0.02731434f, -0.01891156f, -0.01117031f, -0.02749751f, -0.01932445f, -0.03204449f, -0.00275036f, 
    -0.02291010f, -0.00339145f, -0.01930232f, -0.03818782f, -0.00092852f, -0.01446787f, -0.02427117f, 0.01657105f, 
    0.00013001f, 0.00344638f, -0.02439214f, 0.03440488f, -0.01344428f, -0.00341154f, -0.02783053f, 0.00728630f, 
    0.00389376f, 0.02407607f, -0.02033561f, 0.01461964f, 0.01260915f, -0.02575061f, -0.03464857f, -0.02685996f, 
    -0.00584632f, -0.03126089f, -0.02439133f, -0.01800089f, 0.03180763f, 0.02573476f, 0.02560239f, -0.02633568f, 
    0.03457901f, 0.02121620f, -0.02043452f, 0.00768407f, 0.02904675f, -0.03086529f, -0.00552075f, -0.03217744f, 
    0.01928017f, 0.00428325f, 0.02953019f, -0.03226183f, 0.03183803f, -0.00864531f, 0.00620541f, 0.01933879f, 
    -0.00766626f, -0.01002507f, -0.00108088f, -0.02114256f, 0.00013685f, 0.00387156f, 0.01804041f, -0.04189553f, 
    0.00097485f, -0.00155718f, -0.02228443f, 0.03396305f, -0.03165674f, 0.03468025f, 0.00982384f, -0.00819713f, 
    0.00537727f, 0.02084415f, 0.02485259f, 0.00399730f, 0.01297469f, 0.01127504f, 0.00104345f, -0.02956404f, 
    -0.02205637f, -0.01718375f, 0.01364896f, 0.01532866f, -0.03374626f, -0.00132328f, -0.01759635f, -0.04229788f, 
    0.01393770f, 0.01499238f, -0.00871665f, 0.01484223f, 0.00879515f, 0.00606865f, -0.02576626f, -0.01029573f, 
    0.01718605f, -0.01246722f, -0.02591558f, -0.00838063f, 0.01415876f, -0.01261165f, 0.02839828f, -0.01831393f, 
    -0.01336716f, 0.00510995f, -0.03671117f, -0.02104053f, 0.01145178f, 0.00215645f, 0.01770641f, 0.00623148f, 
    0.00831355f, 0.02878051f, 0.01307269f, 0.02602912f, 0.01536679f, 0.01766937f, -0.03968184f, -0.00803563f, 
    0.00949040f, -0.00839742f, -0.03279359f, 0.01377580f, 0.00403993f, 0.01428477f, -0.02663716f, -0.00865425f, 
    0.00976888f, 0.00782162f, 0.00663332f, -0.04025103f, -0.03476539f, -0.02985753f, -0.01392822f, -0.03413153f, 
    -0.01644434f, -0.00537541f, -0.02245184f, 0.03981318f, 0.01872201f, -0.02500290f, -0.01527597f, 0.04229211f, 
    -0.03594267f, -0.02579222f, 0.02238506f, -0.02435065f, -0.03619207f, -0.01774752f, 0.01557148f, -0.02522239f, 
    0.02369011f, 0.00628430f, -0.02843834f, 0.03256634f, -0.03161256f, 0.02372554f, -0.00953607f, 0.03003319f, 
    -0.03802315f, 0.01585876f, -0.03312219f, 0.00727610f, -0.03664123f, -0.00902851f, -0.02927552f, 0.00809643f, 
    0.00691957f, 0.01549605f, -0.00827612f, -0.00092188f, -0.00830280f, 0.02964126f, -0.03118758f, 0.00877775f, 
    -0.03467291f, 0.02157711f, -0.02022867f, 0.00911482f, 0.01299244f, -0.02127328f, -0.02701295f, -0.01197235f, 
    -0.00312456f, -0.01644371f, 0.01495905f, -0.01481745f, -0.02891685f, -0.02022566f, -0.01574559f, 0.02536087f, 
    -0.03201746f, -0.00796669f, -0.00068571f, 0.01239557f, -0.00742259f, 0.01825299f, -0.00679289f, 0.02789570f, 
    -0.00426608f, 0.01711532f, 0.03065917f, 0.02442929f, -0.00126654f, -0.01604190f, -0.00481747f, -0.03718943f, 
    -0.03327750f, -0.00332640f, 0.02654650f, -0.03830835f, -0.00817008f, 0.01010962f, -0.03767600f, 0.01032146f, 
    -0.00660413f, -0.01290602f, 0.02906253f, 0.01877715f, 0.02271781f, 0.01697885f, 0.01375070f, -0.00836170f, 
    0.00753521f, -0.01703959f, -0.00217166f, -0.03508640f, -0.02476903f, 0.01363350f, 0.01901053f, 0.00012744f, 
    0.01548630f, 0.02872658f, 0.00390724f, 0.00261964f, 0.00740009f, -0.00839684f, 0.00563433f, 0.01719317f, 
    -0.02197639f, -0.01177182f, -0.00270553f, 0.00203898f, -0.00531152f, 0.00529857f, 0.01999689f, -0.01244579f, 
    -0.00426217f, -0.02171240f, -0.02144896f, -0.01750360f, -0.04164740f, -0.01062639f, -0.03280173f, 0.00772280f, 
    0.02182865f, 0.02834997f, -0.00261002f, -0.00343932f, -0.00583081f, 0.00386272f, -0.00052134f, 0.01038355f, 
    0.02974686f, -0.00084212f, 0.02708838f, 0.00488698f, 0.00166418f, 0.01412230f, -0.02294971f, 0.02672374f, 
    -0.00912956f, -0.03918720f, 0.02922111f, 0.03578614f, 0.01366417f, 0.02065961f, 0.01733903f, -0.02953230f, 
    0.00980650f, -0.00022537f, 0.00616503f, -0.01657225f, -0.01254252f, 0.03593866f, 0.01331983f, 0.01331231f, 
    -0.02532772f, -0.01125937f, 0.02047086f, -0.00425882f, 0.00023825f, 0.00540042f, 0.00460647f, -0.00843463f, 
    0.00575077f, 0.02256375f, -0.02356406f, -0.02175177f, 0.02389145f, 0.00385159f, 0.00547566f, -0.03117048f, 
    -0.02400577f, -0.01542327f, 0.00716682f, -0.00663284f, -0.02929217f, 0.00366242f, 0.02148309f, -0.01852698f, 
    -0.02868690f, -0.00270592f, 0.02717276f, 0.01641887f, -0.03107962f, -0.03669783f, -0.03341293f, -0.02900331f, 
    -0.01579037f, 0.02950614f, -0.03130320f, -0.00548027f, -0.00277349f, -0.00026573f, -0.02969169f, -0.01959966f, 
    0.01027826f, -0.01316073f, 0.01349151f, 0.02023855f, -0.03493163f, 0.01503508f, 0.01975565f, -0.01705569f, 
    -0.01252028f, -0.00580831f, -0.00228005f, 0.02354746f, -0.00345029f, 0.01249627f, -0.03529837f, -0.00399779f, 
    0.01902821f, 0.01710859f, -0.00924721f, -0.01950833f, -0.01319238f, -0.02261944f, -0.02496454f, -0.02255658f, 
    0.01194926f, 0.00314857f, -0.00520026f, 0.01064035f, -0.02769375f, -0.02641634f, 0.00986805f, 0.02299833f, 
    0.01077667f, -0.00194447f, -0.01627075f, -0.04074782f, 0.02794422f, 0.02517642f, 0.01394516f, -0.02645912f, 
    0.00224029f, 0.03485284f, -0.00997039f, 0.02219746f, -0.02371191f, -0.02187703f, 0.01429711f, -0.03531075f, 
    -0.03022950f, -0.01941149f, 0.01233692f, -0.01394778f, 0.02004715f, 0.02250444f, -0.00053004f, -0.00263629f, 
    0.02380551f, -0.01732263f, -0.03697263f, 0.03634692f, 0.01090182f, 0.03073479f, 0.01571037f, 0.01894889f, 
    0.00399288f, -0.01956727f, -0.01054760f, -0.03549318f, 0.00669812f, 0.01796571f, -0.03951984f, 0.02771444f, 
    0.02194032f, 0.00830783f, -0.00442757f, -0.03953860f, 0.00005314f, 0.02634824f, -0.02181562f, -0.00657241f, 
    0.02232436f, -0.01266675f, 0.03080853f, -0.00359458f, 0.00337307f, 0.02022626f, -0.00646923f, -0.02890533f, 
    -0.03609899f, -0.02748062f, -0.03407564f, 0.03513179f, 0.01016982f, -0.02612037f, 0.02523179f, 0.00390102f, 
    -0.00806737f, -0.01600090f, 0.00516491f, 0.02527449f, -0.01978936f, 0.01468278f, -0.03869517f, -0.00275642f, 
    -0.01312996f, -0.02039433f, 0.01141637f, -0.02243518f, 0.00451851f, 0.03657957f, -0.00003236f, 0.02744575f, 
    0.01665961f, 0.03067259f, -0.00029016f, 0.00343452f, -0.01649225f, 0.01712818f, -0.00536402f, 0.03152950f, 
    0.00504326f, -0.03161518f, 0.00011822f, -0.02278593f, -0.01426378f, -0.01785632f, -0.00601423f, 0.01306293f, 
    -0.04039974f, -0.00030338f, 0.02689521f, -0.00275340f, 0.01569247f, -0.03564065f, -0.03333002f, 0.00513992f, 
    -0.02179718f, 0.03191954f, 0.03352330f, -0.01960307f, 0.01354027f, 0.01766902f, -0.02355617f, -0.00753118f, 
    -0.00866609f, 0.01056589f, 0.03032751f, -0.00859633f, 0.00844171f, -0.02295876f, -0.02078382f, 0.02867497f, 
    -0.00806700f, -0.01471955f, -0.01941800f, -0.00948945f, 0.00125437f, 0.02801407f, -0.00458985f, -0.03364339f, 
    -0.02793080f, -0.02612667f, -0.02051619f, -0.00353689f, -0.00183729f, -0.03637032f, -0.03155743f, 0.00234665f, 
    -0.02768366f, 0.00374216f, -0.02307453f, 0.00139292f, -0.02342526f, 0.00914032f, -0.02101256f, 0.00046426f, 
    -0.01183430f, -0.00706610f, -0.02201089f, 0.00442142f, -0.03110969f, -0.01376171f, 0.00651067f, -0.02991012f, 
    0.03228983f, 0.00536466f, 0.00801136f, -0.01020761f, -0.01129394f, -0.02318818f, -0.01330031f, -0.01580689f, 
    -0.02760646f, -0.00105131f, 0.00129322f, -0.02304900f, -0.04190741f, 0.01033451f, -0.02213944f, 0.00614726f, 
    -0.01345407f, -0.01811825f, -0.00276978f, 0.01097384f, -0.01495831f, 0.01331752f, -0.02789988f, -0.02502437f, 
    0.01139628f, -0.00162851f, 0.03528503f, -0.02874049f, 0.01009298f, -0.03471368f, -0.00388031f, 0.00865899f, 
    -0.01499792f, 0.02340763f, -0.01628671f, 0.00775629f, -0.02728853f, -0.00056853f, -0.00513653f, 0.00661092f, 
    -0.00794018f, -0.02967347f, -0.03227242f, 0.00688850f, -0.03298020f, 0.00918688f, -0.02878888f, 0.00626746f, 
    0.03779466f, 0.03310151f, 0.00745267f, -0.00023426f, 0.02873794f, 0.00446587f, 0.01554866f, 0.01616105f, 
    0.01628534f, -0.02421300f, -0.02723622f, 0.01762736f, -0.02498912f, -0.02922992f, -0.03010059f, -0.02444963f, 
    0.01274089f, 0.02172511f, -0.03555457f, -0.01834180f, -0.03194453f, -0.04044749f, 0.02876128f, 0.00636698f, 
    -0.00125553f, -0.01399066f, -0.02769397f, 0.03307473f, -0.03871903f, -0.01976747f, -0.03747823f, -0.01383479f, 
    -0.03052908f, 0.00662292f, 0.01439731f, -0.00066126f, 0.01170083f, -0.01871841f, -0.04008149f, 0.02088167f, 
    0.03082287f, -0.03126576f, 0.03010531f, 0.02179347f, -0.03454871f, -0.01200850f, -0.02427584f, -0.03747341f, 
    0.02284323f, 0.00461404f, -0.02613961f, -0.01940832f, -0.03174607f, 0.02804681f, -0.00618003f, -0.00543125f, 
    -0.02996123f, -0.01693916f, 0.03095015f, 0.02231847f, 0.00752562f, -0.01829151f, -0.02489398f, -0.01763614f, 
    0.02682159f, -0.00735434f, 0.02277841f, 0.02458418f, -0.00747685f, 0.01696290f, 0.03019494f, 0.02035046f, 
    0.02248017f, 0.02988569f, -0.01047296f, 0.02421013f, -0.00717236f, -0.00800157f, 0.02306024f, -0.02414550f, 
    -0.01647146f, -0.00449732f, -0.01213908f, -0.02346264f, 0.00267654f, 0.02471018f, -0.02162020f, -0.03078162f, 
    -0.02418524f, 0.00423224f, -0.04118625f, -0.01546050f, -0.02070267f, -0.03989465f, 0.01430315f, -0.01635032f, 
    0.03475846f, 0.01920615f, 0.01522724f, 0.01299624f, -0.00049877f, 0.00618085f, -0.01854364f, 0.01130310f, 
    -0.01545046f, -0.02592984f, 0.00902944f, -0.03069725f, -0.00879056f, 0.00036700f, 0.00474485f, -0.00595978f, 
    0.01771630f, 0.00968246f, -0.01739394f, -0.02442325f, -0.00689902f, 0.01106376f, -0.00073130f, -0.00119852f, 
    0.00213295f, 0.02442711f, 0.03464045f, -0.01066194f, 0.00306313f, 0.00211039f, -0.02935236f, -0.02596327f, 
    -0.03402366f, 0.00694706f, -0.01916821f, -0.02840600f, 0.01666338f, 0.02232624f, 0.00521615f, 0.01205500f, 
    0.00678861f, 0.03178811f, -0.02475206f, 0.00708710f, -0.00796310f, -0.01259340f, 0.03327307f, -0.03557498f, 
    -0.01754368f, -0.00297518f, 0.03564482f, 0.00331186f, 0.00633537f, -0.01633736f, 0.03405884f, -0.01704497f, 
    -0.00108118f, 0.02908055f, -0.01086695f, 0.00280680f, -0.01653048f, -0.01808443f, -0.03658827f, -0.00924330f, 
    -0.01290025f, -0.03229164f, 0.01310139f, -0.01901552f, -0.00181323f, 0.03063128f, -0.01346816f, -0.01053266f, 
    0.00223664f, 0.00044909f, -0.02045352f, -0.02195350f, -0.00385757f, -0.02103092f, 0.02891993f, -0.04010516f, 
    -0.01010524f, -0.01863137f, -0.01832132f, 0.02462990f, -0.01526100f, -0.02779268f, 0.03171583f, -0.01706262f, 
    0.02376286f, -0.02501511f, -0.00172556f, -0.01811870f, 0.02019410f, -0.04320382f, -0.01678479f, -0.02101840f, 
    -0.02407193f, -0.00937563f, -0.02422320f, 0.04030452f, 0.02573848f, -0.00709504f, -0.01772457f, 0.01128760f, 
    0.01461421f, -0.02093536f, 0.00156502f, 0.01812254f, -0.00539950f, -0.01804103f, 0.01237131f, -0.00751401f, 
    0.02847665f, -0.01300490f, 0.00897523f, -0.01807757f, 0.01877557f, -0.02696791f, -0.00152024f, -0.00147155f, 
    0.10148536f, -0.15895651f, 0.01110886f, -0.10327265f, 0.02125750f, -0.02035641f, -0.01710922f, -0.00698967f, 
    0.03143021f, 0.07596969f, 0.00526251f, -0.00808465f, -0.03662083f, 0.04286560f, -0.02178130f, -0.14498329f, 
    0.13010839f, 0.07016978f, 0.03566287f, 0.04892984f, -0.03249095f, 0.04828551f, 0.04312091f, 0.19815236f, 
    -0.09217335f, -0.01638099f, -0.00839776f, 0.03281252f, 0.04791606f, 0.02157474f, -0.14695850f, 0.03275444f, 
    -0.00687788f, 0.12608665f, -0.02831000f, -0.00151779f, 0.02462532f, 0.12871207f, 0.20669422f, -0.23902671f, 
    -0.02054921f, 0.07564927f, 0.02010123f, -0.03326794f, 0.05163409f, -0.00393039f, 0.10921336f, 0.09073573f, 
    0.19411111f, 0.17665091f, 0.10290585f, 0.01131652f, -0.02120677f, 0.01025194f, -0.00662986f, 0.01698862f, 
    0.00065623f, 0.08726467f, -0.03154385f, 0.03094110f, -0.21820621f, 0.01464382f, -0.09244205f, -0.05171337f, 
    -0.07461307f, 0.08507861f, -0.01974593f, 0.07038502f, -0.01879521f, 0.02969136f, 0.13329877f, 0.00200168f, 
    0.15536042f, 0.03795195f, -0.02788434f, 0.00937923f, 0.00076897f, 0.00924453f, -0.03770994f, 0.01793911f, 
    -0.07297273f, 0.08984394f, 0.05777669f, 0.10078017f, -0.00189463f, 0.09454683f, 0.01964009f, 0.14023791f, 
    0.07607154f, 0.07921151f, 0.02235445f, 0.07569391f, 0.07440691f, -0.06593390f, -0.02865516f, -0.13188769f, 
    0.24906152f, 0.04394494f, 0.13378564f, 0.03902443f, 0.02154266f, 0.03636989f, 0.02143712f, 0.12456901f, 
    -0.08200846f, 0.01394623f, -0.05667474f, 0.06603488f, -0.12272634f, 0.01077076f, 0.04875436f, -0.15146902f, 
    -0.01968074f, -0.00316366f, 0.02262669f, -0.03768054f, 0.03330310f, 0.05281979f, -0.09570075f, -0.08548348f, 
    -0.00084235f, -0.04446723f, -0.09628730f, 0.00050686f, -0.03308241f, 0.05119691f, -0.00611527f, 0.16624734f, 
    0.05797275f, -0.01171754f, 0.05199504f, -0.06978866f, -0.08278904f, 0.07367430f, -0.03321301f, 0.07963271f, 
    0.11416438f, -0.02794608f, -0.10978869f, -0.02526726f, 0.00163631f, -0.03332338f, 0.20601608f, 0.02337415f, 
    0.14363916f, 0.14732234f, 0.02094932f, -0.08521873f, 0.06951450f, 0.10983486f, -0.00878010f, -0.01357072f, 
    -0.13044794f, 0.00258594f, 0.00177389f, 0.04597641f, 0.05475518f, 0.01618980f, -0.11136440f, -0.08109397f, 
    0.09134805f, 0.00898623f, 0.10014743f, 0.08835611f, -0.03845605f, 0.08155162f, -0.02741252f, 0.14657609f, 
    -0.01066353f, 0.22771248f, 0.08599976f, -0.01625392f, 0.12695557f, -0.04474518f, 0.02319670f, 0.04827797f, 
    -0.04473078f, 0.00545289f, 0.01910532f, 0.15615012f, -0.20470148f, -0.10915291f, 0.05478378f, 0.09604639f, 
    0.04068621f, 0.02759190f, 0.11621384f, 0.03860880f, -0.14247096f, 0.14734501f, 0.02861175f, -0.04835134f, 
    0.04757389f, -0.17459396f, -0.01687047f, 0.00810747f, 0.08542087f, -0.01036562f, 0.12006469f, -0.02720021f, 
    0.02697346f, -0.01277269f, 0.04891290f, 0.04496173f, -0.09881566f, -0.06213688f, -0.06158197f, -0.01477647f, 
    0.06917889f, 0.01318480f, -0.04218199f, 0.09856904f, 0.02817013f, -0.08643824f, 0.01762714f, 0.03934563f, 
    0.18679774f, 0.02435579f, 0.09842774f, -0.06129957f, -0.03987271f, -0.01339237f, -0.11894722f, -0.02865691f, 
    0.09194249f, 0.05212145f, 0.11247367f, 0.11383749f, -0.05862340f, -0.30103552f, -0.04829341f, -0.01202958f, 
    -0.03980355f, -0.03837708f, 0.04025587f, -0.03835697f, 0.04926244f, 0.07066439f, -0.02772764f, 0.02801480f, 
    0.20393254f, 0.24625516f, -0.00513188f, -0.11759084f, 0.08657112f, -0.00301810f, 0.02159055f, 0.06833146f, 
    0.02987661f, -0.02026369f, 0.02436591f, 0.05974892f, 0.03430116f, -0.02574698f, 0.05132918f, -0.12210763f, 
    0.13228986f, 0.05722723f, -0.09677782f, 0.07066721f, 0.03329518f, 0.11558123f, 0.07441298f, -0.06232724f, 
    0.19093342f, 0.06592942f, 0.07448772f, 0.07423755f, 0.18428849f, 0.13916494f, 0.02175451f, -0.00185386f, 
    0.06682191f, 0.03549719f, -0.04541805f, 0.08647407f, -0.08649828f, 0.05715967f, -0.21620649f, 0.02875925f, 
    -0.04040065f, -0.01300598f, 0.00124089f, 0.15083796f, 0.03088674f, -0.03022462f, -0.07046352f, -0.06048747f, 
    0.15469778f, -0.18281503f, -0.04220046f, 0.14986043f, 0.06410278f, 0.05848411f, -0.00688799f, -0.08374321f, 
    0.17551911f, -0.13001339f, -0.09162300f, -0.02426989f, -0.06764383f, 0.05184712f, 0.03875655f, -0.00603657f, 
    0.06985586f, -0.04145750f, 0.08617932f, 0.09457856f, 0.02070953f, 0.13337266f, 0.07355236f, 0.07381482f, 
    -0.14078556f, -0.04579984f, -0.01971416f, 0.05634272f, -0.00270471f, -0.02890782f, 0.05890519f, 0.11600104f, 
    -0.02299757f, 0.05330339f, -0.07312943f, 0.08757623f, -0.05751286f, -0.16043220f, -0.02466793f, -0.03287815f, 
    0.04800150f, 0.03052987f, 0.11624495f, 0.05711321f, -0.03983956f, -0.04476631f, 0.05820767f, 0.02296211f, 
    0.02873753f, -0.03678931f, 0.06981344f, -0.05287706f, 0.09286910f, 0.12297201f, -0.04324899f, 0.09439404f, 
    0.10103291f, -0.10516661f, 0.02635702f, 0.00946211f, 0.01410839f, 0.04129762f, 0.00705306f, 0.19373950f, 
    -0.02126765f, -0.07915058f, 0.08622105f, -0.12357359f, -0.12066168f, 0.04303892f, 0.04284947f, 0.06896105f, 
    -0.06584559f, -0.01905272f, -0.06845049f, 0.08248804f, -0.00714704f, 0.05065425f, 0.01617464f, 0.02161341f, 
    -0.00838901f, 0.15704173f, 0.03370016f, 0.04626393f, 0.05901450f, -0.12066737f, -0.02976792f, 0.09483133f, 
    0.06300273f, -0.12851311f, 0.05589365f, 0.04146312f, 0.10867968f, -0.07780259f, -0.09995914f, 0.03224817f, 
    -0.33293176f, -0.09781606f, 0.12350294f, 0.01603213f, -0.05039646f, -0.04173410f, 0.00247767f, 0.05604125f, 
    0.10569603f, 0.11146912f, -0.01485512f, 0.04070830f, -0.01673421f, 0.04868841f, 0.06797890f, 0.11218964f, 
    -0.04617020f, 0.00142688f, 0.06783076f, 0.04124568f, 0.10813002f, -0.01061686f, 0.14208812f, 0.00563099f, 
    0.12012468f, 0.15396090f, 0.01180029f, -0.04688452f, 0.14389203f, 0.00288690f, -0.01597674f, 0.00687233f, 
    0.00961471f, -0.00583223f, 0.06079340f, -0.01248705f, -0.12063702f, -0.06894021f, 0.20238046f, 0.08377215f, 
    0.08410682f, -0.02966085f, -0.05763268f, 0.06327610f, 0.03482194f, 0.13727851f, 0.08996253f, 0.03077884f, 
    -0.08471297f, -0.02312644f, -0.08555930f, -0.23293529f, 0.00755227f, 0.02810810f, -0.06617606f, 0.03145062f, 
    -0.02934179f, -0.00073400f, 0.13933189f, 0.12265069f, -0.09003640f, -0.11687191f, -0.10198542f, -0.01212034f, 
    0.18642975f, 0.04140405f, -0.03278095f, -0.03896524f, 0.11007868f, 0.03834190f, -0.03993954f, 0.04107011f, 
    0.08863270f, 0.07458352f, -0.08647488f, 0.01532714f, 0.02728091f, 0.06042273f, -0.02094383f, -0.01627256f, 
    0.01870317f, 0.03778186f, -0.10651310f, 0.12346998f, 0.07290857f, 0.04874131f, 0.00308971f, 0.02547682f, 
    0.17960542f, 0.07538561f, -0.10721400f, 0.04308381f, 0.04458640f, -0.02662760f, -0.02172081f, -0.03153180f, 
    0.27765772f, 0.20862199f, 0.14582136f, -0.02529618f, 0.09549880f, 0.10767638f, 0.02371258f, 0.03439866f, 
    -0.03714966f, -0.00627711f, -0.09989325f, 0.06803135f, -0.03070447f, -0.09115028f, 0.04008510f, 0.09036902f, 
    -0.01433522f, 0.03742819f, 0.00644323f, 0.12726396f, 0.05621957f, 0.04605419f, 0.08110525f, 0.02931081f, 
    0.14371845f, 0.04933525f, 0.07459623f, 0.08085254f, -0.00269837f, 0.05031113f, 0.02282906f, -0.05720525f, 
    0.00623901f, 0.07074594f, -0.00443297f, 0.01348029f, 0.14986153f, 0.06757601f, 0.26296723f, -0.07506607f, 
    0.03919990f, 0.03506917f, 0.02973156f, 0.02148085f, 0.02654361f, 0.04004027f, -0.08880194f, 0.02898745f, 
    0.15582959f, 0.12033858f, -0.11039894f, 0.08907846f, 0.07280505f, -0.02502978f, -0.18454149f, 0.08104534f, 
    0.06519903f, 0.01495721f, 0.09566961f, 0.01990099f, -0.27343592f, -0.18505192f, 0.01681748f, 0.03165871f, 
    0.03789564f, -0.06022191f, 0.02603307f, 0.11685527f, 0.07619932f, 0.07892294f, 0.05935607f, 0.06594419f, 
    0.00296333f, 0.02610250f, -0.02598437f, 0.02255857f, 0.02655719f, -0.05255020f, 0.06657118f, 0.01058941f, 
    -0.04797585f, -0.00526476f, 0.04650351f, -0.07247401f, 0.15618405f, 0.15897498f, 0.08517984f, -0.05492952f, 
    0.05976281f, 0.06118480f, 0.00057041f, -0.11927389f, 0.06164311f, 0.02766274f, 0.01916214f, 0.05390549f, 
    0.23035605f, 0.02141596f, -0.12880129f, -0.06983619f, 0.01490810f, 0.00780036f, -0.00605970f, -0.06719874f, 
    -0.11084163f, 0.02668573f, 0.08715058f, -0.08807574f, -0.09119752f, -0.08256631f, -0.07269437f, -0.11831867f, 
    0.00612203f, -0.08418638f, -0.01056366f, 0.07832803f, -0.00515419f, 0.05774453f, 0.04572278f, 0.15926032f, 
    -0.21030641f, -0.18032622f, -0.03777028f, -0.02724453f, 0.11084170f, 0.02184535f, 0.05329584f, 0.00146176f, 
    0.02170829f, 0.02831111f, -0.05214108f, -0.02622123f, 0.15860830f, -0.12088337f, -0.03445337f, -0.06865802f, 
    0.11262574f, 0.02891325f, -0.02311989f, 0.03802513f, 0.02900380f, 0.11956768f, 0.11951612f, 0.03039003f, 
    0.08443642f, 0.08009250f, -0.02769583f, -0.00688809f, 0.08245414f, -0.00578314f, 0.09618801f, 0.04109728f, 
    0.16660263f, -0.03405911f, 0.09424438f, -0.02445965f, -0.04742239f, -0.12513924f, 0.04040297f, 0.04463373f, 
    0.05687819f, 0.01163304f, -0.05347770f, -0.02763259f, 0.03742654f, 0.03646950f, -0.05714850f, -0.03842050f, 
    0.04831466f, -0.20168129f, 0.09171206f, 0.02440830f, -0.00078971f, 0.02709902f, -0.09178052f, 0.01849377f, 
    -0.04248386f, -0.05113714f, 0.12730490f, -0.04174446f, -0.13505992f, -0.04248865f, -0.06728401f, 0.02122470f, 
    -0.05259364f, -0.04067156f, 0.10557717f, 0.05451994f, 0.03023154f, -0.13550153f, 0.18368779f, 0.03748244f, 
    -0.21646951f, -0.01470096f, 0.04604289f, -0.02544165f, -0.06378689f, -0.00378755f, 0.13053463f, -0.00405516f, 
    -0.01461821f, 0.05359301f, -0.10866089f, 0.01523055f, -0.15585145f, 0.00284559f, 0.02744711f, -0.00123540f, 
    0.05462228f, -0.08845375f, -0.10449441f, 0.09871160f, 0.05967532f, -0.01138843f, -0.03111046f, -0.06763054f, 
    -0.21291335f, -0.00933876f, 0.00628598f, 0.06089976f, 0.15881497f, 0.02919126f, 0.02192102f, 0.04159506f, 
    0.04449555f, -0.01773582f, 0.02747848f, -0.02120992f, 0.09317395f, -0.12237990f, 0.00873270f, -0.08035620f, 
    0.09408730f, -0.05500445f, -0.00519878f, 0.10112204f, 0.04582309f, -0.02818614f, -0.00244433f, -0.02391643f, 
    0.09386094f, 0.02683461f, -0.07893947f, -0.12059285f, 0.09765820f, -0.07729911f, 0.01617134f, 0.01973012f, 
    0.02114636f, 0.07496891f, 0.01529245f, 0.03631914f, 0.08809386f, 0.00175705f, -0.04284136f, 0.10927004f, 
    -0.00001752f, -0.04668847f, -0.00263801f, 0.01602086f, 0.04895542f, 0.01528230f, 0.09229015f, 0.08344067f, 
    -0.24952768f, -0.04908210f, -0.13362953f, 0.03966980f, -0.04360732f, -0.12367951f, -0.06837159f, 0.02081499f, 
    -0.10271084f, 0.09915149f, -0.09443841f, 0.08406264f, 0.03396090f, -0.09692183f, -0.03394832f, 0.10684511f, 
    0.05078289f, 0.01028360f, 0.11874986f, 0.00835471f, 0.11001411f, 0.08876602f, -0.06226308f, 0.02596129f, 
    -0.01733533f, -0.00790804f, -0.01623016f, -0.01485275f, -0.03481217f, -0.04002349f, -0.03606033f, 0.00700287f, 
    -0.02283069f, -0.02436486f, -0.00140420f, 0.02532970f, -0.04084920f, -0.01185056f, -0.03981543f, -0.01295101f, 
    -0.02024111f, -0.02330981f, 0.02405739f, -0.01721759f, 0.01017199f, -0.02796257f, 0.01401485f, -0.02581926f, 
    0.01084942f, -0.00277098f, -0.00763569f, -0.00226415f, -0.01838790f, -0.03596909f, -0.03867739f, -0.03819859f, 
    -0.01664240f, 0.00356794f, 0.02991631f, 0.02129911f, 0.02571271f, 0.00729892f, -0.03021325f, -0.02244829f, 
    -0.01537052f, 0.00843450f, -0.00362453f, -0.03902085f, 0.01145581f, -0.01592565f, 0.01940083f, -0.02388345f, 
    0.01023233f, 0.01114987f, -0.02989402f, 0.02877275f, 0.00031699f, 0.02006097f, -0.02180608f, -0.00396445f, 
    -0.03521169f, -0.01997769f, 0.00444781f, 0.00664404f, 0.00873285f, 0.00376262f, 0.00756683f, 0.02256540f, 
    -0.01947000f, 0.00918518f, 0.01439698f, 0.01871440f, -0.01230269f, -0.04123153f, 0.01255353f, -0.04142310f, 
    -0.01700703f, 0.00374130f, 0.01940026f, 0.00957257f, -0.03428602f, 0.02778767f, 0.02920356f, 0.00872373f, 
    0.02700697f, -0.00062843f, -0.00422810f, 0.02456734f, -0.00880925f, -0.04160370f, 0.02888144f, -0.01381961f, 
    -0.01734540f, 0.02581607f, -0.02842534f, -0.00315045f, 0.02859715f, -0.02789511f, 0.00596143f, -0.00952848f, 
    0.01125620f, -0.02296901f, -0.03881793f, -0.03703590f, 0.01203053f, 0.00294960f, 0.02767795f, 0.01589556f, 
    0.02977842f, 0.01957539f, -0.01084548f, 0.02174681f, -0.03823584f, -0.02233260f, 0.00084084f, -0.00433291f, 
    -0.00397093f, 0.02930816f, -0.02023978f, 0.02566366f, 0.02264865f, 0.01983402f, -0.02745916f, -0.02536659f, 
    0.01674378f, -0.00875745f, 0.01366383f, 0.00908316f, -0.00904831f, 0.00277339f, -0.01749098f, -0.00144964f, 
    0.01045518f, 0.01739417f, -0.01682521f, 0.02178100f, -0.00809009f, 0.01695848f, -0.01489433f, -0.00254151f, 
    -0.00790582f, -0.03539222f, -0.02805667f, -0.00633434f, -0.00808449f, 0.00821784f, 0.00704519f, -0.01084149f, 
    -0.00003421f, 0.01620113f, -0.01124677f, -0.02543696f, 0.01290916f, 0.00273455f, -0.03603127f, -0.01795640f, 
    -0.02388565f, -0.03117616f, -0.00602640f, -0.03386873f, -0.03574307f, 0.00023701f, 0.02707621f, 0.00591851f, 
    -0.01812723f, -0.01585795f, -0.00549454f, -0.00175598f, -0.01711729f, -0.03385996f, 0.02859397f, -0.00280603f, 
    -0.02314635f, -0.04196799f, -0.01150330f, -0.02756353f, 0.02775379f, -0.03649811f, -0.01803794f, -0.01290440f, 
    -0.02418901f, -0.03366806f, 0.00911652f, -0.00037248f, 0.02201702f, -0.02178097f, 0.00080298f, 0.01237189f, 
    0.00858596f, -0.01234684f, 0.00638798f, 0.02329092f, -0.01719243f, -0.00711972f, 0.02726377f, 0.02955607f, 
    -0.03833944f, -0.00045997f, -0.01959010f, 0.00122094f, -0.03818366f, -0.00442485f, 0.02555197f, -0.01387220f, 
    -0.00985884f, -0.02179579f, -0.00524194f, -0.00520280f, -0.00579917f, -0.03911139f, -0.03015648f, -0.02508736f, 
    -0.01529231f, -0.01222513f, 0.01253219f, -0.03839648f, -0.03925303f, -0.02958349f, -0.03322968f, 0.01722065f, 
    -0.02703319f, -0.01523156f, 0.00350949f, 0.02860040f, 0.01571199f, -0.03657525f, 0.00521770f, -0.00943534f, 
    0.00238502f, -0.00474264f, -0.00156050f, -0.00866738f, 0.00722583f, 0.02730981f, -0.00342543f, 0.01678349f, 
    -0.02407865f, 0.00383512f, 0.02517068f, -0.01107962f, 0.02618502f, 0.00634531f, 0.01112267f, -0.03329563f, 
    -0.00916283f, -0.03189244f, -0.00561322f, -0.00046509f, 0.01077564f, -0.02261214f, -0.02686600f, -0.02277503f, 
    -0.00789211f, 0.02019912f, 0.00446963f, -0.02797359f, -0.01600290f, 0.02598452f, 0.01949358f, -0.02280982f, 
    0.01525870f, 0.02997135f, -0.01100188f, -0.03047562f, -0.03357075f, -0.02845772f, -0.03948427f, 0.02047975f, 
    0.02009521f, 0.02218639f, -0.03855617f, -0.01790798f, -0.00664085f, -0.03452838f, 0.00775617f, 0.02188603f, 
    -0.01076059f, -0.01322498f, 0.00612699f, 0.00244125f, 0.01072252f, -0.01309265f, 0.00475069f, -0.02300798f, 
    0.01066206f, 0.01097455f, -0.03866306f, -0.02378433f, 0.00003652f, -0.00628289f, -0.02871316f, 0.01132224f, 
    0.00616145f, -0.01867303f, -0.02448689f, 0.01311480f, 0.00381015f, 0.01174846f, -0.03720577f, 0.01653660f, 
    -0.02612487f, 0.01434056f, -0.00354204f, 0.01797262f, 0.02753028f, 0.01131214f, 0.00773676f, 0.02354506f, 
    0.01570000f, -0.01598853f, 0.02616102f, -0.03805487f, -0.01432887f, 0.00904501f, -0.01718666f, -0.02127450f, 
    0.01651185f, -0.00801401f, -0.03754357f, -0.02513312f, -0.04194740f, -0.01338050f, -0.00371678f, -0.00538942f, 
    -0.03922872f, 0.02989702f, -0.01064862f, -0.02521388f, -0.01358170f, -0.03365789f, -0.00454805f, 0.00135525f, 
    0.01655455f, -0.03376459f, 0.02809880f, 0.01598079f, 0.01369866f, -0.02735501f, 0.02621767f, 0.00827909f, 
    0.01254406f, -0.03950938f, 0.02986008f, 0.01682843f, 0.01058945f, 0.00657081f, -0.03082261f, -0.03900560f, 
    0.01411771f, -0.00307268f, 0.02225484f, 0.00578761f, -0.03915474f, 0.01393317f, -0.00219627f, -0.02356148f, 
    0.01997166f, -0.00752879f, 0.00222699f, 0.02476376f, -0.02765511f, 0.01779058f, -0.03858982f, -0.01025858f, 
    -0.00216384f, 0.00949462f, -0.03993920f, 0.00676366f, -0.03247956f, -0.04045429f, -0.00342676f, -0.04069018f, 
    0.02060487f, -0.01703921f, -0.03428574f, -0.03334402f, -0.02494971f, -0.02590326f, 0.00332888f, -0.00441017f, 
    -0.02730147f, -0.01757376f, -0.01117933f, 0.02284654f, -0.00606286f, -0.01017143f, -0.03463791f, -0.03520568f, 
    -0.01810440f, -0.01221082f, 0.00159098f, -0.01493637f, -0.02610243f, -0.03161480f, -0.01691169f, 0.02301744f, 
    -0.03883656f, 0.02889026f, 0.01443141f, 0.00239070f, -0.03550721f, -0.03379464f, -0.02053275f, 0.01303252f, 
    0.02425310f, -0.02105921f, -0.03508215f, 0.01404575f, -0.00125873f, -0.00644768f, -0.03538106f, -0.00410286f, 
    -0.03762560f, -0.02410116f, 0.01513945f, -0.03482204f, 0.01371358f, -0.00719964f, -0.03085798f, -0.01593856f, 
    -0.00869901f, -0.00105415f, -0.03848718f, -0.00829929f, 0.00129564f, 0.00808983f, 0.00945253f, -0.00513470f, 
    -0.01829977f, 0.00468159f, -0.00696028f, 0.01985827f, -0.01013977f, -0.03731339f, -0.03050111f, 0.01807202f, 
    0.02268846f, 0.00432922f, -0.03742104f, 0.02380839f, -0.03032207f, 0.02460997f, -0.03840867f, -0.03648435f, 
    0.01830032f, 0.01487295f, 0.02241602f, -0.02419573f, -0.03429429f, -0.00005807f, 0.02189251f, 0.01412471f, 
    -0.00655713f, -0.02458802f, -0.00991147f, 0.00980345f, -0.00935889f, -0.02393450f, 0.00449951f, -0.00857079f, 
    -0.03812168f, 0.00701974f, -0.02293419f, -0.04061579f, 0.00062901f, 0.00627176f, -0.03548212f, -0.02905670f, 
    -0.01591390f, 0.00470675f, 0.00963860f, -0.00956892f, -0.02638663f, 0.02422633f, -0.03046916f, 0.02924897f, 
    0.00358249f, -0.00303463f, -0.04054129f, -0.04188207f, -0.01420220f, -0.02167165f, -0.01883181f, 0.01986372f, 
    0.02812152f, -0.03732204f, 0.02403112f, -0.00153654f, 0.01335702f, 0.00850658f, -0.02395849f, 0.00212162f, 
    0.00667506f, -0.04020317f, -0.02426283f, 0.00292379f, 0.02026185f, 0.00878975f, 0.00879880f, -0.03297684f, 
    0.02156255f, -0.03316014f, -0.03259793f, -0.02471408f, -0.01263471f, 0.01519337f, -0.03368873f, 0.00904637f, 
    -0.00226595f, 0.00116398f, -0.03254005f, -0.00761368f, -0.00246642f, -0.02831953f, -0.02494522f, -0.03882485f, 
    0.01844424f, -0.00992677f, -0.01983942f, 0.02401989f, 0.00691880f, -0.00332553f, 0.02218406f, -0.04055516f, 
    0.02815270f, -0.00760870f, -0.03988836f, 0.00200393f, -0.00922854f, 0.02408652f, -0.01071996f, -0.02731762f, 
    -0.01656676f, -0.02327661f, 0.01107727f, 0.00118422f, 0.02677850f, -0.01219251f, 0.01307602f, -0.01419987f, 
    -0.02901631f, -0.00417534f, -0.02419627f, -0.00397178f, 0.01164683f, -0.01095360f, -0.02181317f, -0.03514294f, 
    -0.03848447f, 0.02667202f, -0.04047211f, 0.02587879f, -0.03232059f, 0.00237472f, 0.02303708f, -0.04112513f, 
    -0.00462326f, 0.01069794f, -0.02093357f, -0.01185007f, 0.02435742f, 0.00425074f, -0.03209659f, -0.02492017f, 
    -0.03851754f, -0.03780762f, 0.00278015f, -0.03981386f, 0.01094004f, 0.01477526f, -0.02756833f, 0.01597440f, 
    -0.02698773f, 0.01335945f, -0.01724400f, 0.00383402f, 0.02609196f, -0.00004501f, -0.03945954f, 0.00991337f, 
    -0.02676511f, 0.00717832f, 0.02946032f, 0.01078160f, 0.03003531f, 0.01512287f, 0.01159127f, -0.03683909f, 
    -0.02739920f, 0.00900221f, -0.02131472f, -0.02610206f, 0.01638496f, 0.02306022f, 0.01779559f, -0.00664716f, 
    -0.00869312f, 0.01001391f, -0.01324366f, -0.01290493f, -0.00071230f, -0.00228627f, 0.00235197f, 0.02645501f, 
    0.00279760f, -0.01751800f, -0.03765444f, -0.00361571f, -0.02002971f, -0.03774223f, 0.01030480f, -0.03731240f, 
    -0.01167749f, 0.02889231f, -0.04014524f, -0.00838973f, -0.01795238f, 0.01929403f, 0.01042948f, 0.00264327f, 
    0.01440752f, -0.02338748f, 0.02847150f, -0.02250938f, -0.03727559f, -0.02093453f, -0.02255305f, -0.00529051f, 
    0.01109465f, -0.03085314f, -0.00692961f, -0.03936980f, -0.02703590f, -0.00905820f, 0.01235752f, -0.03607339f, 
    -0.02910820f, 0.02624310f, -0.02181684f, -0.00507528f, 0.02430821f, 0.01671970f, -0.01922255f, -0.00189510f, 
    -0.00099262f, -0.00266832f, -0.02948959f, 0.00272820f, 0.00356826f, -0.02613389f, 0.01259032f, 0.02267470f, 
    0.02506466f, 0.01224390f, -0.02775328f, -0.01689607f, 0.02599506f, 0.00321856f, -0.04040866f, -0.00607026f, 
    -0.00900637f, 0.02670499f, -0.03993066f, 0.01796933f, 0.02112304f, -0.03386060f, 0.02450208f, -0.03392581f, 
    -0.02233174f, 0.02635880f, -0.02561503f, 0.00911633f, -0.03032462f, -0.03002604f, 0.02100325f, -0.03292000f, 
    -0.00220136f, -0.00210490f, 0.01870078f, -0.02563609f, -0.00465442f, -0.01566508f, 0.02241047f, 0.02993932f, 
    -0.03244480f, -0.00202154f, -0.00805908f, -0.03003560f, 0.01147630f, -0.01469184f, -0.00396684f, -0.00547035f, 
    0.00373637f, -0.00619875f, -0.03995809f, 0.01693647f, 0.02057554f, -0.02158768f, 0.02507395f, -0.01184530f, 
    0.00101653f, 0.01291414f, -0.01594786f, -0.04087146f, 0.01326977f, -0.01976451f, -0.00725299f, 0.00497445f, 
    0.01851045f, -0.00914541f, 0.02677249f, -0.02212527f, -0.02389002f, 0.02065902f, -0.04073507f, -0.01457602f, 
    0.00206600f, -0.01864006f, -0.02561019f, 0.00990823f, 0.00531175f, -0.00330886f, -0.03908123f, -0.01896959f, 
    -0.00690400f, -0.03846684f, 0.01022702f, -0.01875844f, 0.02728830f, -0.03982703f, -0.02854463f, -0.00718789f, 
    -0.03904737f, -0.03109948f, -0.02492684f, -0.01701399f, 0.00388841f, 0.00244976f, 0.00436930f, -0.02748633f, 
    -0.04146540f, -0.00110671f, -0.02126723f, 0.00689287f, 0.02872764f, -0.00539023f, 0.00318086f, -0.02466948f, 
    0.01350231f, -0.01517203f, 0.02182129f, -0.03995384f, -0.00747874f, -0.00831131f, 0.00076840f, -0.00156984f, 
    0.00923704f, 0.01099997f, 0.02388982f, 0.02234646f, -0.00613046f, -0.03471806f, -0.00963211f, -0.02182391f, 
    -0.01250754f, -0.01287394f, 0.00912034f, 0.02728986f, -0.01618755f, -0.04061720f, -0.01878401f, -0.00211275f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04108120f, 0.00492483f, 0.01220246f, 0.03762756f, -0.00989452f, -0.03283224f, -0.10586697f, 0.01896758f, 
    -0.03212245f, 0.06236289f, -0.00279226f, 0.08907605f, 0.00634036f, -0.01142208f, 0.02217557f, 0.02634476f, 
    0.01478360f, -0.01864188f, 0.10520332f, -0.00929095f, 0.03843485f, -0.00778034f, -0.06038241f, 0.01019648f, 
    0.03580906f, 0.06239139f, 0.09412225f, -0.00197128f, -0.00433885f, -0.02515158f, 0.04679576f, -0.01124743f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05805993f, 0.18288040f, 0.22518785f, 0.00787667f, -0.21935448f, 0.02370360f, -0.40137535f, -0.07360698f, 
    0.00376794f, -0.37176791f, 0.12566163f, 0.16947435f, 0.09269343f, -0.19415382f, -0.08216495f, 0.10644438f, 
    0.07871009f, 0.04064332f, 0.29128104f, 0.00441409f, 0.16157967f, -0.08131099f, -0.14767486f, -0.10101841f, 
    0.32975644f, 0.35551625f, 0.44667494f, 0.16503480f, -0.04243435f, -0.12165388f, 0.05761155f, -0.11365739f, 
    -0.11274330f, -0.07944707f, 0.12541936f, -0.04253011f, 0.12194121f, -0.00286442f, -0.08731627f, 0.09725113f, 
    -0.17012344f, -0.07958549f, -0.11616182f, 0.00457091f, 0.13906507f, -0.09985156f, -0.02373195f, -0.14665920f, 
    -0.00830298f, -0.07806329f, -0.16232415f, -0.12046364f, 0.00912236f, -0.04410941f, -0.11007924f, 0.03400140f, 
    -0.09066309f, -0.12639065f, 0.08711034f, 0.07839549f, -0.08465521f, -0.10218905f, -0.03990084f, -0.13627712f, 
    0.05904108f, 0.04267758f, -0.17321110f, 0.00037591f, -0.09744877f, 0.12305265f, -0.05557076f, 0.13453859f, 
    0.15859385f, 0.07958698f, -0.12355380f, -0.14390017f, 0.07077111f, -0.07457872f, -0.13507298f, 0.03850660f, 
    -0.01899215f, 0.10005059f, -0.13788311f, -0.10582193f, 0.04353201f, 0.07575151f, -0.02904156f, -0.01077404f, 
    0.01924839f, -0.13262117f, -0.12822819f, 0.12728809f, -0.12613508f, -0.03665210f, -0.09585977f, 0.11829486f, 
    -0.06308224f, -0.14652859f, -0.02946477f, 0.07548179f, -0.14369364f, 0.07568441f, -0.11130243f, -0.12411340f, 
    0.06862152f, -0.13874632f, -0.00884667f, -0.18760723f, -0.14719012f, -0.05724780f, 0.06939892f, 0.14745896f, 
    0.03213624f, 0.09282699f, 0.10860968f, 0.10050298f, -0.09689865f, 0.01138117f, -0.14189114f, -0.07311343f, 
    -0.06524564f, -0.07630784f, 0.04917216f, 0.14617164f, -0.12841390f, -0.02847705f, 0.14845096f, 0.17373200f, 
    0.15814592f, -0.05113363f, 0.34687856f, -0.23771250f, -0.31563297f, -0.07552147f, 0.21948896f, -0.11487938f, 
    0.32342738f, 0.04392122f, -0.04833505f, 0.17976390f, -0.03096779f, 0.22437042f, 0.09476414f, 0.29093206f, 
    0.02822088f, -0.30356786f, -0.11029632f, 0.10402581f, 0.44374806f, 0.08469896f, 0.16809063f, -0.12923059f, 
    0.34544387f, 0.02412461f, -0.19615054f, -0.08468050f, -0.06526367f, -0.00923135f, 0.04905037f, -0.10587694f, 
    0.11221081f, -0.11336312f, 0.09688857f, 0.09886608f, -0.02753809f, 0.02451991f, -0.10086375f, -0.07686587f, 
    0.04259996f, -0.18350576f, 0.01685272f, -0.06617433f, 0.12005952f, -0.10966394f, -0.00522395f, 0.00715307f, 
    -0.11667777f, -0.16365936f, -0.12219524f, -0.11938339f, 0.00453435f, -0.01785561f, 0.13892742f, 0.15946089f, 
    -0.01788740f, 0.03859636f, 0.10439140f, 0.15921995f, 0.12591538f, -0.02245067f, 0.11194360f, 0.12127454f, 
    0.12303063f, -0.23022756f, 0.16684325f, 0.28316459f, 0.31277815f, -0.00581461f, 0.25438213f, 0.28548434f, 
    -0.48599464f, 0.06841702f, 0.11342596f, 0.22631417f, 0.11833102f, 0.11920095f, 0.12818374f, -0.28839180f, 
    -0.01489676f, -0.02262735f, 0.04520576f, -0.00980083f, -0.34040460f, -0.02797657f, -0.10247516f, 0.03033918f, 
    -0.15558457f, -0.22864336f, 0.32007301f, -0.17667635f, 0.01351568f, -0.02845559f, -0.22231111f, -0.16720705f, 
    -0.04837976f, 0.20274796f, -0.43091691f, -0.12920099f, -0.27256340f, -0.10229316f, 0.18777913f, -0.26251486f, 
    0.45982873f, 0.25717315f, -0.06746402f, 0.24749339f, -0.07297456f, -0.21776229f, -0.06552413f, 0.01314104f, 
    -0.10713290f, -0.15204562f, -0.02507235f, 0.12537980f, -0.15779656f, 0.05158413f, 0.20274469f, 0.04922706f, 
    -0.15853743f, 0.23307210f, 0.22171257f, -0.01769076f, 0.12911704f, 0.07908932f, 0.15800796f, 0.09780704f, 
    -0.16593090f, -0.06496325f, 0.06325367f, 0.04521439f, -0.08747958f, -0.13010274f, -0.30420205f, -0.02431392f, 
    0.09995200f, -0.18051849f, 0.03445124f, -0.03811595f, -0.05289951f, 0.22618449f, -0.05642907f, 0.49205291f, 
    -0.15482901f, 0.19917247f, 0.11627688f, -0.12456840f, 0.06607389f, -0.14879741f, -0.16178983f, -0.03321107f, 
    -0.17772911f, 0.26370457f, 0.41115636f, -0.10912685f, -0.00499202f, 0.09837518f, 0.09914384f, 0.09317773f, 
    -0.12846835f, -0.12249772f, -0.10888034f, 0.23930979f, 0.44094527f, -0.06204039f, 0.26379743f, 0.02718922f, 
    -0.15062600f, 0.39942905f, 0.05471882f, -0.06448839f, 0.01690046f, -0.08657021f, -0.09275557f, -0.14276682f, 
    0.13665242f, 0.09075917f, -0.08818913f, 0.10604684f, -0.17341971f, 0.09365488f, 0.16505633f, 0.01259860f, 
    -0.07316322f, -0.11555494f, -0.05062604f, -0.16931172f, 0.14296255f, -0.12813453f, 0.05540647f, -0.15791336f, 
    -0.01314691f, -0.08873735f, -0.09716533f, -0.22980645f, 0.21096276f, 0.08339568f, 0.04999460f, -0.04180295f, 
    0.01279669f, 0.19643682f, -0.09578904f, 0.08510467f, 0.07529037f, -0.11546345f, -0.00941464f, 0.12839523f, 
    -0.15459484f, -0.25618422f, 0.02083986f, 0.35919517f, -0.40479574f, -0.11504976f, 0.25332931f, 0.16068712f, 
    0.03019000f, 0.30924743f, 0.09555714f, 0.08811580f, 0.08204013f, 0.16409507f, -0.18279636f, 0.10051212f, 
    -0.16916750f, 0.28342891f, -0.20202723f, 0.25060955f, 0.03828985f, -0.05035363f, -0.16361274f, 0.17479344f, 
    -0.08978580f, -0.20964985f, -0.00350567f, 0.12787473f, -0.05478352f, 0.18262547f, 0.10063400f, -0.19986068f, 
    0.12240957f, 0.24668601f, 0.24779996f, -0.08573724f, 0.23982778f, -0.13071060f, -0.01239164f, 0.15259993f, 
    -0.31618083f, -0.15704057f, -0.28107148f, 0.16322221f, 0.14737304f, -0.07776970f, 0.11338688f, -0.10452441f, 
    0.04795621f, 0.44333258f, -0.07649084f, -0.05856552f, 0.06890409f, -0.10617661f, 0.34989935f, 0.03401923f, 
    0.29417947f, -0.21624540f, 0.04162522f, 0.10367516f, -0.16116038f, 0.28586385f, -0.00490058f, 0.01641888f, 
    -0.06760053f, -0.05260211f, -0.05606966f, -0.09646813f, -0.12912336f, -0.17442878f, 0.24505907f, -0.10666208f, 
    -0.32052144f, -0.02586256f, -0.06365880f, -0.12855701f, 0.00278493f, -0.04734867f, 0.27403060f, -0.04915522f, 
    0.06018835f, 0.02869242f, -0.08446419f, -0.12602419f, -0.08668856f, -0.00374229f, -0.06756543f, 0.00687735f, 
    0.02486427f, 0.08982306f, 0.15335670f, -0.06502885f, -0.04986901f, -0.04707735f, 0.03696245f, 0.13483208f, 
    -0.05661051f, 0.06831330f, -0.04808105f, -0.07272594f, -0.01849129f, 0.17735109f, -0.16635717f, -0.16748694f, 
    0.03099078f, 0.11832819f, 0.05266449f, -0.01894018f, 0.03940732f, 0.05720444f, -0.07416444f, -0.04743208f, 
    0.11717660f, 0.27124104f, 0.32119149f, -0.05523584f, 0.23335855f, 0.07489011f, -0.11636937f, -0.04253507f, 
    -0.08127362f, -0.01932091f, 0.10814888f, 0.10713810f, -0.11944293f, 0.16277297f, -0.10137877f, 0.28852782f, 
    0.12994328f, 0.06443401f, -0.25992808f, -0.16559105f, -0.05100569f, 0.07310926f, -0.15960497f, 0.09003022f, 
    -0.08808882f, 0.12711701f, 0.05181203f, 0.03396424f, 0.03020812f, -0.07449751f, 0.02754865f, 0.04412553f, 
    -0.03412248f, 0.17351392f, 0.27252606f, 0.05911741f, 0.13084111f, 0.10680462f, 0.00012332f, 0.35328984f, 
    -0.41002464f, -0.24744147f, 0.05351971f, -0.03175966f, -0.08887845f, 0.34790668f, 0.05865015f, -0.09967957f, 
    -0.05606876f, 0.24016732f, -0.05230548f, 0.20482466f, -0.10805061f, 0.16001704f, 0.21899801f, 0.04679555f, 
    -0.22276556f, 0.03327772f, -0.34149936f, -0.10167404f, 0.15272234f, -0.03722984f, -0.14451431f, 0.03128538f, 
    -0.00650827f, -0.16234772f, 0.10373932f, -0.16433349f, -0.02731109f, 0.14458853f, 0.06070792f, -0.04199900f, 
    -0.11239150f, -0.11736871f, -0.11462221f, -0.15670243f, 0.09218243f, 0.02683610f, 0.13473479f, 0.13107446f, 
    0.01715356f, 0.04657718f, -0.14946093f, -0.08934426f, 0.02494059f, 0.06131378f, 0.05462217f, -0.17252755f, 
    -0.05947108f, -0.04675253f, -0.15477473f, -0.01470316f, -0.15798254f, 0.11512776f, 0.12521604f, 0.05677252f, 
    -0.07309155f, 0.08261249f, -0.21617192f, -0.05409852f, 0.01676512f, 0.07035394f, -0.04222757f, -0.05169453f, 
    -0.10493768f, 0.05759339f, -0.02966438f, 0.21160060f, 0.11219016f, -0.12227575f, 0.04723108f, -0.44856799f, 
    0.15563425f, -0.02723711f, 0.25726262f, 0.33327326f, -0.34233129f, -0.06284337f, 0.24716090f, 0.10950173f, 
    0.23434713f, 0.32158124f, -0.12322994f, -0.06812054f, 0.11420118f, 0.12546039f, 0.08588507f, 0.10407020f, 
    -0.03907038f, -0.22156166f, -0.04484661f, 0.27107409f, 0.28405160f, 0.09114482f, -0.20080511f, -0.07719834f, 
    -0.29996416f, 0.41421175f, 0.14184506f, 0.22114687f, -0.02760012f, 0.01959277f, -0.14171536f, 0.23443204f, 
    -0.14096096f, 0.26400387f, -0.04156111f, -0.14076732f, -0.09454028f, -0.06730182f, -0.14820085f, -0.14144339f, 
    0.15968555f, -0.07728577f, 0.17799266f, -0.15892214f, -0.14423841f, -0.00838948f, 0.03953762f, -0.08013245f, 
    -0.15775269f, 0.12199087f, 0.25496665f, 0.03183050f, 0.11482054f, -0.10766490f, -0.38038513f, -0.00943418f, 
    -0.14251816f, 0.22847092f, 0.16099229f, 0.23658468f, 0.16499528f, -0.03374024f, 0.04476890f, -0.18540390f, 
    -0.14878641f, -0.11043104f, 0.24028164f, 0.02154988f, 0.11303160f, -0.05482949f, -0.28355730f, 0.01396640f, 
    0.01510560f, 0.01841547f, -0.00267590f, -0.12750909f, -0.14685902f, -0.00981410f, 0.27234977f, -0.16117780f, 
    -0.13174821f, 0.09762076f, 0.02604463f, -0.12432579f, 0.06008299f, -0.02351000f, -0.14819804f, -0.05124830f, 
    0.00664517f, -0.06162137f, -0.01254067f, 0.04420523f, 0.04014716f, -0.11720892f, -0.07566072f, -0.11441784f, 
    -0.07631648f, 0.00191532f, -0.01898567f, -0.02515261f, -0.11314721f, 0.16827059f, 0.12265264f, 0.09199952f, 
    -0.15505558f, -0.15604798f, -0.06440113f, -0.02579968f, 0.05591451f, 0.16879068f, -0.06977221f, 0.17948793f, 
    -0.13312447f, -0.18610293f, -0.26921031f, -0.12421046f, -0.26645458f, -0.17554225f, -0.06333666f, 0.11278760f, 
    0.29545540f, 0.39810207f, 0.07256531f, 0.10938371f, 0.17614920f, 0.18579581f, 0.11673778f, -0.15833697f, 
    -0.04557881f, -0.30350414f, 0.08286605f, 0.10710113f, 0.33050337f, 0.02592310f, 0.16599926f, 0.11828559f, 
    -0.24423099f, -0.05165905f, 0.09485728f, -0.11855996f, -0.10212468f, 0.04354836f, -0.02730992f, 0.04591898f, 
    0.15073618f, 0.06272324f, 0.19864888f, -0.18408087f, -0.11945738f, -0.08551766f, -0.38591939f, 0.01333811f, 
    0.23306884f, -0.01600213f, 0.11212861f, 0.03443085f, 0.13133730f, -0.06948399f, -0.06658102f, 0.22874720f, 
    -0.13476671f, -0.17459294f, 0.15097119f, 0.23904094f, 0.27823818f, 0.16256560f, -0.07749312f, 0.10574006f, 
    0.27046710f, 0.25937751f, -0.03052042f, -0.12352191f, 0.16623372f, -0.09596128f, 0.21217659f, -0.15009518f, 
    -0.12416428f, -0.02164574f, 0.33878219f, -0.13457009f, 0.15531062f, -0.09247693f, 0.06241884f, 0.35713926f, 
    -0.20441012f, -0.15090275f, -0.04526786f, -0.06702167f, -0.11477161f, 0.23574160f, -0.14204858f, -0.14769737f, 
    0.16604768f, -0.06454938f, 0.12130541f, 0.31499082f, 0.04880367f, 0.00235618f, 0.12054712f, -0.15024100f, 
    0.01086315f, 0.06731880f, -0.31698418f, 0.15907155f, -0.08817364f, -0.02066896f, 0.25256345f, 0.08471202f, 
    -0.02733071f, 0.04185444f, -0.18244117f, 0.23439632f, 0.29681349f, -0.07982521f, 0.18577000f, 0.07463033f, 
    0.00740096f, 0.13698041f, 0.03744735f, -0.05136465f, 0.13649067f, -0.19689009f, -0.15704603f, 0.06898368f, 
    0.04089965f, 0.30894688f, -0.12684579f, -0.12405241f, -0.09180067f, 0.16033728f, 0.28716472f, 0.02716449f, 
    0.21485867f, 0.12157834f, -0.10896650f, -0.15294951f, -0.04210551f, 0.14500186f, -0.16162866f, -0.14043427f, 
    -0.09913678f, 0.10236649f, 0.06636024f, 0.09070006f, -0.10672501f, 0.07314294f, 0.03738504f, -0.11574461f, 
    0.12212510f, -0.16513868f, -0.17211317f, -0.14308831f, 0.03660950f, 0.08052562f, 0.13082124f, 0.11530973f, 
    -0.00728919f, -0.17215085f, 0.03310867f, -0.05550735f, 0.05145208f, 0.07644009f, -0.11189469f, 0.10352852f, 
    -0.07357978f, -0.05057554f, 0.12768966f, -0.15266821f, -0.14429365f, -0.08093595f, 0.00395093f, 0.14577669f, 
    0.15748081f, 0.00102337f, -0.10627352f, 0.07780277f, 0.31690073f, -0.04942088f, -0.12431535f, -0.12597328f, 
    0.03746937f, 0.49342322f, 0.03088588f, -0.02616789f, 0.06970342f, -0.26247320f, 0.16638459f, 0.22984277f, 
    0.01787511f, -0.01103326f, 0.18221685f, -0.13653727f, 0.08344316f, 0.15928443f, -0.17141196f, -0.11256870f, 
    0.03159811f, 0.07950955f, -0.07945406f, -0.10567435f, -0.11208497f, -0.06830801f, 0.21387050f, -0.04002025f, 
    -0.06165038f, 0.04633597f, 0.12987126f, 0.13964473f, -0.07501741f, 0.16838099f, 0.11513641f, 0.07766668f, 
    0.24413575f, -0.25642660f, -0.05652314f, -0.09904193f, 0.16357695f, 0.28528744f, -0.03537106f, 0.21480788f, 
    -0.10138224f, 0.25016436f, -0.33218929f, -0.13818325f, -0.03587463f, -0.09483699f, 0.07471198f, 0.13465746f, 
    0.26452690f, -0.21263126f, 0.13650213f, -0.07901499f, -0.01719876f, 0.09597857f, -0.21252617f, 0.06628148f, 
    0.06828980f, -0.11299704f, -0.00177421f, -0.11054235f, -0.07689396f, 0.10626445f, -0.15391175f, 0.14118165f, 
    0.15411520f, -0.14600405f, -0.13002664f, 0.05300495f, -0.12017039f, 0.04898975f, 0.11523373f, -0.05189474f, 
    -0.07853631f, -0.11818261f, -0.17586994f, -0.12527856f, 0.07048429f, -0.13095343f, 0.14378037f, -0.05108722f, 
    0.04944697f, -0.07267261f, 0.11707682f, -0.07132212f, -0.17001078f, -0.05793160f, -0.13188970f, -0.05064085f, 
    0.09228878f, -0.36464706f, -0.07787516f, 0.14087944f, -0.13004436f, -0.07592257f, 0.05687023f, 0.24546543f, 
    -0.21525860f, -0.05737230f, -0.01346558f, 0.09595392f, -0.03562507f, 0.30834591f, 0.01578987f, 0.23468092f, 
    -0.13514775f, -0.14488301f, 0.06846713f, 0.11272852f, -0.11911337f, 0.07712268f, -0.13089126f, -0.05984688f, 
    0.13823372f, 0.05607365f, 0.34644902f, 0.04196768f, 0.14753586f, 0.05841096f, -0.18595482f, -0.05137024f, 
    -0.04875025f, 0.05387400f, -0.03652408f, -0.15700674f, -0.12079225f, -0.15919372f, -0.05523960f, -0.15298481f, 
    0.09230611f, 0.12371632f, 0.06046783f, -0.07422304f, -0.16346586f, 0.15733340f, -0.01109082f, 0.15194114f, 
    -0.13152520f, -0.09930916f, -0.09588932f, -0.15500741f, -0.02538764f, -0.11079572f, -0.16187668f, -0.16395733f, 
    0.03831435f, -0.05150960f, 0.01460930f, -0.06172290f, 0.12086538f, 0.08287992f, -0.04242057f, 0.09778174f, 
    0.00805225f, -0.08466969f, -0.32967642f, 0.14271504f, -0.23304307f, 0.11282219f, -0.05921827f, 0.04940725f, 
    0.52957064f, 0.04688533f, 0.16535227f, -0.13981485f, -0.13395078f, -0.06995273f, 0.04376694f, -0.16713458f, 
    -0.04921268f, 0.27793694f, 0.18646474f, 0.23932201f, 0.06163207f, 0.06485919f, 0.27604812f, 0.07945369f, 
    0.34961373f, -0.16277866f, 0.54668927f, 0.10607196f, -0.11418428f, -0.10222370f, -0.16983481f, 0.09048321f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12916869f, 0.07959826f, -0.01020457f, 0.03701969f, 0.09341376f, 0.04327140f, -0.10274195f, -0.05326957f, 
    0.04094933f, 0.14390258f, 0.17528923f, 0.00251556f, 0.11337154f, -0.03824218f, -0.02496758f, 0.16902471f, 
    -0.14840028f, 0.08549389f, 0.04595409f, 0.13214682f, 0.12430452f, -0.04730249f, -0.00956296f, 0.06896486f, 
    0.02520204f, -0.13200875f, -0.02449667f, -0.07418059f, -0.14145270f, 0.04500993f, 0.12767784f, -0.01963181f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.03670489f, -0.10554609f, 0.04956616f, 0.14647540f, -0.10660588f, 0.11495765f, -0.48931724f, -0.13731650f, 
    -0.00187897f, -0.20622182f, -0.05337961f, 0.24332403f, 0.22781149f, 0.13732740f, -0.25780296f, 0.18311401f, 
    -0.14997829f, 0.09681448f, -0.48569587f, -0.23061471f, -0.07883872f, -0.42199370f, -0.02725804f, 0.07097323f, 
    0.24322802f, -0.07445987f, -0.52387959f, 0.00122658f, -0.11444485f, -0.54346472f, -0.16508088f, 0.21544474f, 
    0.20895422f, -0.07189260f, 0.08732104f, -0.01811826f, 0.30877379f, 0.00532242f, -0.03700414f, 0.03518865f, 
    -0.04064865f, -0.40665901f, -0.08393137f, -0.21958949f, 0.05841213f, 0.06078473f, -0.43111828f, -0.32180765f, 
    -0.02693458f, -0.09802794f, -0.27827007f, 0.14454992f, -0.06414199f, 0.45405948f, 0.18369883f, -0.02674573f, 
    -0.23957080f, -0.14206925f, -0.17649896f, 0.04201517f, 0.02725884f, -0.12724763f, -0.03329612f, 0.19486326f, 
    -0.05532640f, -0.02096199f, -0.17181368f, -0.12674420f, 0.02965854f, -0.15194264f, -0.32144466f, 0.04528260f, 
    -0.68890566f, 0.20601042f, -0.23873347f, 0.17181920f, -0.09167421f, -0.15358140f, -1.01660466f, -0.34751251f, 
    -0.06320015f, 0.27814823f, 0.11021134f, 0.07896904f, 0.11765693f, 0.17016792f, -0.16910361f, -0.22075139f, 
    0.13543847f, -0.17812207f, 0.17655918f, -0.35078102f, -0.00377059f, -0.57254815f, 0.06247893f, 0.34923059f, 
    -0.04476144f, 0.15509224f, -0.02967846f, -0.16953345f, -0.10346565f, -0.01248865f, 0.08487196f, -0.43622369f, 
    -0.05404661f, 0.30632737f, 0.31589624f, -0.43919921f, -0.55749196f, 0.13769561f, -0.52786869f, 0.01956152f, 
    0.00963355f, -0.03556215f, 0.19316739f, -0.29208565f, -0.00804090f, -0.60932386f, -0.10848202f, 0.07266179f, 
    0.15918639f, 0.05665388f, -0.05444092f, -0.06704541f, 0.11964760f, 0.27877569f, -0.09493849f, 0.22318792f, 
    -0.39574501f, 0.05639071f, 0.13175464f, 0.06594480f, 0.04886252f, 0.00310082f, 0.14894500f, 0.14179334f, 
    0.07329158f, 0.03719343f, 0.06098289f, 0.08971728f, 0.14811359f, -0.03096496f, -0.10863738f, 0.10675479f, 
    0.07330331f, -0.23584750f, 0.08826746f, -0.09471283f, 0.06081790f, 0.44842517f, -0.27986121f, -0.04758354f, 
    -0.19158414f, 0.13809191f, -0.40938070f, 0.24034801f, -0.11785990f, 0.31937397f, -0.06507096f, 0.02082659f, 
    0.16896337f, -0.05173518f, 0.13824664f, -0.14197783f, 0.29666719f, -0.09600086f, -0.39405316f, -0.35544887f, 
    0.19444923f, -0.52812481f, -0.36921009f, 0.04601648f, 0.00159315f, -0.06302477f, 0.32373604f, 0.07467026f, 
    -0.12524888f, -0.22571979f, -0.05228734f, 0.10481715f, 0.00970209f, -0.14717522f, 0.06615317f, 0.09970941f, 
    -0.24740824f, -0.01170086f, 0.16546246f, 0.18972766f, -0.15664455f, -0.04515147f, -0.08520401f, -0.42207122f, 
    0.04273817f, 0.12173498f, 0.11002188f, -0.15886810f, 0.04625322f, 0.07142510f, 0.23748314f, -0.58274645f, 
    -0.45173737f, -0.01556859f, 0.23260035f, -0.15325634f, -0.21972156f, 0.13384949f, -0.23369661f, 0.22844671f, 
    -0.15246053f, 0.23200136f, -0.05788800f, 0.24414767f, -0.08872835f, -0.23348998f, 0.00530179f, 0.24222568f, 
    -0.21042900f, -0.01485607f, -0.44982094f, -0.75641066f, -0.02969369f, -0.04466749f, 0.01466217f, -0.22174744f, 
    -0.03916267f, -0.04904915f, -0.07687210f, 0.10621501f, 0.07768729f, 0.03674204f, 0.20867321f, 0.19421507f, 
    -0.02943382f, 0.07780486f, -0.22672328f, -0.39736080f, -0.08834714f, 0.06108128f, 0.47669342f, -0.09198940f, 
    0.01661519f, -0.39480501f, 0.20641398f, -0.36664930f, 0.07953630f, -0.41118845f, -0.42303693f, -0.42561200f, 
    0.24122293f, -0.07242762f, -0.08407246f, 0.47865409f, 0.09434437f, 0.02256654f, -0.03345391f, 0.05203019f, 
    0.04546364f, 0.16058764f, 0.06604133f, -0.00128376f, 0.06770240f, 0.09640496f, -0.35829481f, 0.40654668f, 
    -0.05602794f, -0.03522119f, 0.47852957f, -0.55271691f, 0.14690714f, 0.09881610f, 0.17254248f, -0.43867892f, 
    -0.10922088f, 0.21080512f, -0.13245949f, -0.05594857f, 0.05423444f, -0.13942868f, -0.01943139f, -0.30707580f, 
    -0.02619975f, 0.11177843f, 0.16178007f, -0.28156364f, -0.01541467f, -0.10214344f, -0.15736027f, -0.18464179f, 
    -0.44692433f, -0.16492812f, -0.03025016f, 0.07155915f, -0.35760236f, -0.09963222f, 0.15917751f, -0.24811666f, 
    -0.26821336f, 0.38892794f, -0.17253989f, 0.12940519f, 0.15379646f, 0.02166039f, 0.24964871f, 0.10841814f, 
    -0.13049899f, -0.07996890f, 0.12729819f, 0.14268802f, 0.01071175f, -0.07638859f, -0.26811543f, 0.11949977f, 
    0.13653669f, -0.00657232f, 0.42257741f, -0.20344317f, -0.16392660f, -0.43485937f, -0.17288016f, -0.38782483f, 
    0.16175179f, -0.11261282f, -0.00618707f, -0.07644474f, -0.25268781f, -0.07709528f, -0.07596379f, -0.10368846f, 
    0.19268948f, -0.00070078f, 0.00629697f, -0.18519802f, -0.66131330f, -0.11608067f, 0.31917766f, -0.37895566f, 
    0.00800954f, -0.08850510f, 0.36810270f, 0.25730097f, 0.13235955f, 0.11352421f, 0.18299927f, -0.38096538f, 
    0.00272343f, 0.09019338f, 0.47405842f, -0.05114380f, -0.12576845f, -0.12518752f, 0.10741341f, 0.05184555f, 
    0.41277498f, -0.05962900f, -0.13053055f, 0.11681461f, -0.57400644f, 0.08293279f, 0.23822647f, -0.14073931f, 
    0.28978419f, -0.31246871f, -0.26303157f, 0.23585887f, -0.03206013f, -0.03744284f, -0.10528267f, -0.03891198f, 
    0.03753223f, 0.10265233f, 0.05117693f, 0.16170384f, -0.01625646f, -0.58439428f, -0.17505753f, -0.13079315f, 
    -0.16625944f, 0.12209595f, -0.25526619f, -0.32219830f, -0.17981148f, 0.04956212f, 0.15151690f, 0.13591185f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.17910488f, -0.05981518f, 0.06417812f, -0.02567020f, -0.10923765f, 0.00150915f, 0.11238700f, -0.16871162f, 
    -0.05046233f, -0.03716938f, 0.10374508f, -0.00552543f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
