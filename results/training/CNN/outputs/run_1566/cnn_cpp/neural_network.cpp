#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49168906f, 0.05088049f, -0.80738664f, -0.19175795f, 0.47914866f, -0.08202728f, 0.78306961f, -0.11582018f, 
    -0.45538232f, -0.73018748f, -0.09463026f, -0.09507041f, 0.07161684f, -0.47113198f, -0.06595591f, -0.11577010f, 
    -0.12707435f, 0.04821723f, -0.14873953f, 0.00401841f, 0.13760558f, 0.04862392f, -0.03556511f, 0.01434381f, 
    -0.40156659f, -0.21736941f, -0.04985342f, -0.00689439f, 0.52445006f, -0.05072862f, 0.02665239f, -0.16719754f, 
    0.18612029f, 0.16938733f, 0.41437742f, 0.11372367f, 0.52327210f, 0.19385794f, -0.62555921f, -0.20216055f, 
    -0.20565836f, -0.00577438f, 0.40533143f, -0.44197488f, -0.32502297f, 0.12862234f, 0.21547623f, 0.10412082f, 
    0.11249174f, -0.01819666f, 0.81155914f, 0.46957150f, 0.44207868f, -0.34368545f, -0.48700911f, 0.03367945f, 
    -0.00266053f, -0.40080768f, 0.20968825f, -0.50780356f, 0.07564601f, 0.30845645f, -0.27619332f, -0.25560981f, 
    -0.22353052f, 0.15417197f, -0.06191349f, 0.22505347f, 0.04553106f, -0.03995863f, -0.15244372f, 0.15929766f, 
    0.11302011f, -0.09111542f, 0.17565289f, -0.00116952f, 0.11419488f, 0.42044410f, 1.05834448f, -0.53237998f, 
    0.13660564f, 0.31990007f, -0.33522373f, -0.77618712f, -0.50255710f, 0.03186582f, 0.00425960f, 0.05227719f, 
    0.05943492f, 0.07333526f, -0.04563703f, 0.16008009f, -0.09016492f, -0.21938542f, 0.30610040f, 0.31046087f, 
    -0.00803940f, 0.02982143f, -0.03511282f, -0.46352163f, 0.51587570f, -0.22334743f, -0.13114330f, -0.11857225f, 
    0.23883441f, -0.62506330f, -0.32729915f, 0.06414934f, 0.40950060f, 0.09607278f, 0.34391382f, -0.05375672f, 
    -0.19604599f, -0.37690854f, 0.55264062f, 0.15446831f, 0.16723293f, -0.54469949f, -0.13430360f, 0.15787603f, 
    -0.37843591f, -0.12294009f, 0.16856903f, 0.03271255f, 0.26701695f, -1.09076726f, -0.65830731f, -0.99328512f, 
    -0.68369526f, -0.29400602f, -0.40898028f, 0.20211805f, 0.02518266f, -0.64514178f, -0.43513367f, 0.16964625f, 
    0.06053121f, -0.35402581f, -0.18237484f, -0.06550144f, 0.03535611f, -0.15965766f, -0.12576891f, -0.16430278f, 
    -0.57987761f, -0.35338500f, -0.32362723f, 0.24766538f, -0.01692423f, -0.04923783f, -0.95473075f, -0.05682267f, 
    -0.69065362f, 0.07738352f, 1.12724054f, 0.48031417f, -0.76670367f, -0.38285995f, -0.42803919f, -0.39420763f, 
    0.70911437f, -0.62706286f, 0.00172301f, -0.41012409f, -0.16531965f, 0.30634859f, -0.33018011f, -0.08819712f, 
    -0.17168909f, -0.04025262f, -0.38283738f, -0.04305803f, 0.09335156f, -0.23900697f, 0.27075428f, -1.08173788f, 
    0.35586733f, 0.75038487f, -0.00086818f, -0.53112358f, 0.23480190f, -0.04779840f, -0.25956127f, 0.23416424f, 
    -0.39157483f, 0.41549066f, -0.13245852f, -0.17039603f, 0.26360163f, -0.14330928f, -0.01863577f, -0.08626095f, 
    0.10024312f, 0.16922429f, -0.23428991f, 0.15892699f, -0.10485055f, -0.04085676f, -0.27019167f, -0.27240354f, 
    -1.47086704f, -1.31395364f, -0.40785006f, 0.55637068f, 0.12302650f, 0.39417285f, 0.61894447f, 0.49724257f, 
    -0.33018866f, -0.61878455f, -0.36582899f, -0.12103190f, 0.00355414f, 0.10132416f, -0.26615429f, 0.20876683f, 
    0.14668176f, -0.56411207f, -0.32385784f, -0.04143447f, -0.03226066f, 0.06689932f, 0.03988733f, 0.01300744f, 
    -0.23184334f, -0.57971710f, 0.54465753f, -0.11853679f, -0.50322121f, -0.11116643f, 0.16013762f, 0.49520379f, 
    0.19671373f, -0.52787584f, -0.39029074f, -0.27948025f, 0.01992890f, -0.04063548f, 0.46496177f, 0.16141562f, 
    -0.06813123f, -0.52774864f, -0.08423219f, -0.25062075f, -0.30433381f, 0.33161739f, 0.30788499f, -0.16006397f, 
    0.26396924f, 0.21027108f, -0.71281642f, 0.53236085f, 0.33419508f, 0.38107657f, 0.20914981f, -0.32963377f, 
    -0.62004483f, -0.19869442f, 0.26220956f, 0.37390697f, 0.29507107f, -0.07422197f, -0.10372715f, -0.01700268f, 
    -0.09999233f, -0.20284897f, -0.21354392f, 0.02232399f, 0.26186076f, -0.05297349f, 0.00216216f, 0.12240158f, 
    0.25407249f, -0.11169244f, -0.24452607f, -0.76895338f, -0.23487441f, -0.67700911f, -0.09159911f, 0.23435223f, 
    -0.11094975f, 0.35158414f, 0.66805029f, 0.42029589f, 0.23248933f, 0.02253641f, 0.16865210f, 0.12528946f, 
    0.11078516f, -0.46802959f, 0.06088303f, -0.12684837f, 0.28088206f, -0.09021978f, 0.02222722f, 0.02350230f, 
    -0.16167173f, 0.07894380f, -0.16251262f, -0.19525985f, 0.89373946f, -0.02878671f, -0.83536553f, -0.99498075f, 
    -1.28832734f, 0.80492187f, 0.78743488f, 0.00927099f, 0.00626818f, -0.14749873f, 0.07629257f, -0.12676717f, 
    -0.29739782f, -0.07896311f, -0.12800102f, -0.25393972f, -0.56987792f, -0.09338494f, 0.39975479f, -0.44500437f, 
    -0.40050316f, 0.00418069f, 0.35872251f, 0.00191653f, 0.11751299f, -0.12511683f, -0.59455568f, -0.40690249f, 
    -0.74978369f, -0.67907989f, 0.19373858f, -0.01103676f, 0.08481959f, 0.04452137f, -0.14031780f, -0.47777215f, 
    -0.40374944f, -0.17019451f, 0.59768480f, 0.57198626f, -0.00212798f, -0.31899115f, -0.34653386f, -0.38777500f, 
    -0.10123493f, -0.19854812f, -0.27824596f, -0.22922581f, -0.41561574f, -0.70028526f, -1.37884462f, -0.94166422f, 
    0.60802197f, -0.43036559f, -0.92955804f, 0.92001683f, 0.16670898f, 0.08498307f, -0.14161180f, 0.72465086f, 
    0.13248177f, -0.10197486f, 0.07860353f, 0.16768403f, -0.36379686f, 0.02239943f, 0.08602708f, -0.29694989f, 
    -0.13102221f, -0.03848284f, -0.02179110f, -0.08609222f, 0.04824927f, 0.14350262f, -0.08155387f, -0.02731023f, 
    -0.97988272f, 0.06620333f, 0.59157318f, 0.64916116f, 0.79624456f, 0.51130533f, -0.34800619f, -0.52329558f, 
    0.17767540f, -0.03668882f, -0.14182718f, -0.09794261f, -0.20526442f, -0.17396042f, -0.02350322f, -0.21455036f, 
    -0.12885426f, -0.14830588f, 0.04121021f, -0.00065132f, -0.42748588f, 0.10558355f, 0.31093201f, -0.15472348f, 
    -0.48977906f, -0.96144170f, -0.46396115f, 0.05518688f, -0.32935441f, 0.27257723f, -0.15159273f, 0.30390343f, 
    0.37567037f, 0.36800390f, -0.18694679f, 0.04474561f, 0.00539534f, 0.31464514f, 0.18136500f, -0.10228997f, 
    0.10348517f, -0.15118568f, 0.25949553f, 0.08005273f, 0.41368604f, -0.21786790f, 0.21959195f, -0.13963418f, 
    0.19059698f, -1.51381516f, 0.06705178f, -0.34879744f, -0.22881834f, -0.03681023f, -0.33390099f, 0.10987397f, 
    0.62701058f, 0.70442969f, 0.78442228f, 0.10203521f, 0.03417755f, 0.16293253f, -0.27012417f, 0.01172093f, 
    0.04934466f, -0.21934576f, -0.36094868f, -0.20854631f, 0.15025036f, -0.05262266f, 0.04002161f, 0.44637609f, 
    -0.10783010f, 0.14031053f, 0.56274843f, 0.75622022f, -0.56684452f, -0.14747196f, -0.44225547f, -0.28652894f, 
    0.19464621f, -0.07369003f, 0.04496815f, -0.05284978f, 0.08361547f, -0.34032074f, 0.25659996f, -0.05762987f, 
    0.17543902f, -0.20960006f, 0.18077576f, 0.13076015f, 0.16549850f, -0.20999812f, -0.14782400f, 0.04791043f, 
    0.12469900f, -0.13309826f, 0.18674310f, 0.86789340f, -0.26602846f, -0.11776786f, 0.18044569f, -0.17524031f, 
    0.34296194f, 0.06617529f, -0.12361621f, -0.59058726f, 0.37532932f, -0.32504410f, 0.38583508f, -0.20130132f, 
    -0.29424775f, -0.11983707f, 0.19827263f, 0.23364668f, 0.23700804f, -0.08498001f, -0.20911996f, 0.18802249f, 
    -0.30574679f, -0.01451826f, -0.22936837f, -0.22004989f, 0.65435922f, 0.57983035f, 0.37190253f, 0.04901728f, 
    0.49565274f, 0.07617390f, 0.05043345f, -0.03947753f, 0.05698866f, -0.11552744f, 0.11324491f, 0.01455803f, 
    0.05099170f, 0.01245395f, 0.05198903f, 0.07664851f, 0.01983389f, 0.13415855f, -0.22800390f, 0.00806338f, 
    -0.17458482f, 0.13247350f, 0.03921426f, 0.18650787f, -0.14404944f, 0.83760643f, 0.95622981f, 0.39946419f, 
    -0.43985441f, -0.28508639f, -0.71021986f, -0.09679892f, 0.44461703f, 0.15596259f, -0.38804978f, -0.45236993f, 
    0.40809271f, -0.16880955f, 0.07509708f, -0.38501671f, 0.24053597f, -0.16478835f, -0.19774540f, -0.33875528f, 
    -0.01012455f, 0.03482712f, 0.29151204f, -0.20552544f, -0.42355195f, -0.25545365f, -0.11528274f, 0.75673902f, 
    -0.16896050f, -0.79372430f, 0.78409255f, -0.44427493f, -0.27808672f, 0.15668944f, -0.94519371f, 0.04989021f, 
    -0.47038084f, -0.39912906f, 0.41480660f, -0.37639657f, -0.08205741f, 0.25230420f, 0.09641675f, 0.17978491f, 
    -0.14529543f, 0.12267471f, -0.17385375f, 0.09849380f, -0.03403558f, -0.09241077f, -0.18397155f, -0.53938508f, 
    -0.68469483f, -0.19248770f, -0.10032591f, -0.76532835f, -0.94342631f, -0.65352190f, -0.76512778f, -0.72222096f, 
    -0.53624558f, 0.12294909f, -0.34006971f, -0.20723632f, -0.39613438f, -0.14142597f, 0.00308006f, -0.29619870f, 
    -0.19641536f, -0.33349839f, -0.22407156f, 0.05977500f, -0.40508336f, -0.23114672f, -0.14162724f, 0.35665330f, 
    -0.04492726f, -0.49361864f, -0.47239277f, 0.09450965f, 0.05395975f, 0.26362160f, 0.58280522f, 0.10894449f, 
    -0.07861691f, -0.01316161f, -0.33288035f, -0.44311386f, -0.17669258f, 0.06370820f, 0.25222224f, -0.03576629f, 
    0.00172047f, 0.14965381f, 0.24859880f, -0.36612734f, -0.24128899f, 0.11402531f, 0.19972935f, -0.20868015f, 
    -0.52993959f, -0.66928363f, 0.70938152f, 0.64437389f, -0.65762687f, -0.00726346f, -0.12620288f, 0.00448193f, 
    -0.16567220f, 0.40930188f, 0.10251863f, 0.22575672f, -0.43944752f, 0.12781873f, -0.27104038f, -0.15849617f, 
    -0.02629984f, -0.04167888f, -0.23181060f, -0.12873815f, -0.08793586f, -0.38123667f, -0.50196666f, -0.64118427f, 
    -0.45753959f, -0.99569798f, -0.64989972f, -0.59527636f, -0.51701474f, -0.41670698f, -0.16682622f, -0.56252414f, 
    -0.82791078f, -0.03526532f, -0.49207249f, -0.96034992f, 0.42732126f, 0.53894162f, -0.24636920f, 0.05432989f, 
    0.04142013f, -0.10476631f, 0.07148504f, 0.02507812f, -0.17741378f, 0.10480079f, 0.34033346f, 0.44624293f, 
    0.19503339f, 0.20313488f, 0.44606152f, 0.49607241f, 0.49737087f, 0.10600567f, 0.12738299f, 0.19909173f, 
    -0.88465750f, -0.73112696f, -1.16214931f, -1.09508550f, -0.08055142f, 0.19443779f, 0.05765551f, -0.00632195f, 
    0.38476014f, 0.43598890f, -0.04502439f, -0.34881914f, -0.06348800f, 0.32730570f, -0.70892966f, -0.13354293f, 
    0.09947958f, 0.16090159f, 0.18874454f, -0.09538892f, 0.43843630f, -0.08999527f, -0.75357777f, -0.45786393f, 
    0.44533333f, 0.76266247f, 0.14234298f, 0.14309652f, 0.28040725f, -0.07038104f, 0.06332155f, 0.09331534f, 
    -0.12636453f, -0.06500814f, -0.04114576f, -0.21233527f, -0.11756285f, -0.09484633f, 0.02953387f, 0.03808700f, 
    0.32956797f, -0.02455902f, -0.45135489f, -0.07038689f, 0.30440140f, -0.41230184f, -0.78471839f, -0.43966797f, 
    0.26028568f, 0.20658484f, -0.08091499f, 0.27415735f, 0.10479995f, -0.13231383f, 0.25698790f, 0.23299792f, 
    -0.20201787f, 0.09495302f, 0.00324760f, 0.27832049f, 0.25840238f, -0.33760059f, -0.00019438f, -0.16427062f, 
    -0.52819896f, 0.12949470f, 0.45797017f, 0.53613698f, -0.01232868f, -0.19321440f, 0.16856731f, -0.71462125f, 
    0.04043430f, 0.25897324f, 0.67833400f, -0.02095586f, 0.40262127f, 0.43709806f, 0.02360493f, -0.14009477f, 
    -0.26889783f, -0.73992324f, 0.39070067f, 0.02448548f, -0.04628503f, -0.12918684f, -0.05488298f, -0.29308939f, 
    0.04688896f, -0.30288479f, 0.29875839f, -0.07682092f, -0.22902909f, 0.13088958f, -0.05196573f, -0.34821382f, 
    -0.22911817f, -0.18397793f, -0.78580409f, -0.38912910f, -0.07583418f, -0.24069718f, -0.03520209f, 0.03480940f, 
    0.75410068f, -0.14635180f, -0.04820323f, -0.14421782f, -0.00280615f, -0.02562748f, -0.10644239f, -0.00261492f, 
    0.01422150f, -0.24027222f, 0.15599203f, -0.47782388f, -0.34920004f, -0.56878901f, -0.27120739f, -0.58474946f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19683406f, 0.41935816f, 0.42312029f, 0.19539955f, 0.45808789f, -0.23098145f, 0.32776985f, 0.01559373f, 
    -0.00777436f, 0.26490951f, 0.55896467f, 0.05760259f, 0.37071258f, -0.29100958f, -0.05285180f, 0.51397449f, 
    0.15902925f, 0.35691303f, 0.26498345f, 0.43707186f, -0.16758348f, 0.38384971f, 0.04588193f, -0.00991223f, 
    0.01242992f, -0.11383560f, -0.13663658f, 0.26149791f, 0.48866630f, 0.43944293f, 0.61458361f, 0.14306274f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18256754f, -0.54959387f, -0.55218953f, 0.25474763f, -0.11440908f, -0.05287070f, 0.13505851f, 0.01573539f, 
    -0.04088748f, 0.03073211f, -0.00364636f, -0.02711227f, -0.48150352f, -0.23693994f, -0.13315129f, -0.18764628f, 
    0.06014969f, 0.07356589f, 0.00681099f, -0.02684597f, -0.04781878f, -0.08084776f, -0.20029142f, 0.00183037f, 
    -0.10194881f, -0.09343941f, -0.18741864f, 0.14403231f, -0.08041242f, 0.02291983f, -0.04087195f, 0.02989740f, 
    -0.04052195f, -0.06635000f, 0.00403145f, 0.00303651f, -0.06818099f, -0.44710094f, -0.03777375f, -0.12471192f, 
    -0.04478885f, -0.10022786f, -0.14625928f, -0.14059003f, -0.05560648f, 0.01122882f, 0.01882689f, 0.07291977f, 
    -0.19378898f, 0.07701301f, -0.10417935f, -0.24874072f, -0.26282841f, -0.14264283f, -0.07972518f, -0.09257476f, 
    -0.08631702f, -0.17793398f, -0.38871065f, -0.12675500f, 0.41619977f, 0.24280982f, -0.08808674f, -0.07815121f, 
    0.15635616f, 0.31918532f, 0.11159420f, 0.13028167f, -0.08407401f, -0.07809217f, -0.02777378f, 0.00846001f, 
    0.39152023f, 0.32224596f, -0.22712643f, -0.21895441f, -0.04733457f, 0.15217917f, -0.20117284f, 0.01414692f, 
    -0.07782322f, -0.03137235f, -0.14726660f, -0.14204389f, 0.09124333f, 0.12803739f, -0.05590796f, -0.12744598f, 
    -0.18005596f, 0.18343496f, -0.11286128f, 0.05204764f, 0.08053049f, -0.04831221f, -0.14392243f, 0.00398697f, 
    0.57836014f, 0.13966520f, -0.19829291f, -0.27141628f, 0.08419786f, 0.07314033f, 0.19718070f, -0.04592348f, 
    -0.15374666f, -0.11286087f, -0.06655847f, 0.01760159f, 0.15351711f, -0.08617562f, -0.12216413f, 0.07581340f, 
    0.09262471f, 0.13409574f, -0.38958549f, -0.13840123f, -0.08016766f, -0.20107546f, -0.12833102f, -0.21422373f, 
    -1.11617768f, 0.14865576f, 0.26308861f, -0.12997510f, 0.02984122f, -0.04276693f, 0.05184279f, 0.04478534f, 
    0.04111229f, -0.03902243f, 0.00182215f, 0.00851997f, 0.15437895f, 0.09991622f, -0.02599202f, 0.05668998f, 
    0.08852115f, 0.03403246f, 0.02292031f, 0.10607854f, 0.01359282f, 0.13256282f, 0.01376483f, -0.00346591f, 
    0.07454524f, -0.34430575f, -0.58657277f, 0.13662592f, 0.18251164f, -0.04596608f, -0.25634453f, -0.23189251f, 
    -0.04033557f, -0.29213363f, -0.30430883f, 0.10267587f, 0.27496657f, -0.00146742f, -0.06482818f, -0.09200434f, 
    0.09594396f, 0.06064749f, -0.31624976f, -0.20607333f, 0.09445439f, -0.04402686f, 0.08566051f, 0.25225857f, 
    0.44728571f, 0.02411940f, 0.12331397f, -0.27750179f, 0.07727309f, 0.14885099f, 0.10630553f, 0.10183836f, 
    0.04800334f, 0.09949641f, -0.07231265f, -0.02496309f, 0.59086037f, -0.04975849f, 0.25261551f, -0.01182282f, 
    0.04582143f, -0.02642029f, 0.16671041f, -0.03549967f, 0.07355929f, -0.04610538f, 0.19179402f, 0.05114774f, 
    0.03313101f, 0.11419158f, 0.09479177f, -0.08678349f, 0.12895206f, 0.05385345f, 0.11143386f, -0.25725189f, 
    -0.10973866f, 0.04157376f, -0.03605991f, 0.00515995f, -0.34740630f, -0.15325297f, 0.19507101f, -0.04487228f, 
    0.03507775f, 0.06328128f, 0.05252755f, 0.10470424f, -0.06338086f, -0.14867261f, -0.08988376f, 0.03743007f, 
    -0.11903475f, -0.17753841f, 0.04948688f, 0.00413076f, -0.04714689f, -0.02400746f, -0.03787325f, -0.18788430f, 
    -0.09401701f, -0.00440636f, -0.05237255f, 0.01288705f, -0.32247999f, -0.09166757f, -0.03270132f, 0.08035182f, 
    0.04536333f, 0.05699082f, -0.11066859f, -0.14571099f, -0.15965745f, -0.02101787f, 0.01573537f, -0.16543177f, 
    -0.17145923f, -0.12688325f, -0.06149353f, 0.10960785f, 0.07877409f, 0.00681340f, 0.08383680f, 0.04352143f, 
    -0.01818204f, 0.08260122f, 0.01121061f, 0.09031693f, -0.71129793f, -0.77202207f, -0.10722753f, 0.28180811f, 
    0.04925119f, 0.11474683f, -0.05369731f, 0.02464270f, 0.08428019f, 0.06000318f, -0.09624341f, -0.01015066f, 
    -0.20571738f, 0.35862648f, -0.19071019f, 0.20442276f, 0.05206463f, 0.12159918f, -0.07435575f, 0.03862021f, 
    -0.04694534f, -0.08160055f, -0.02689820f, -0.00114339f, 0.40817210f, 0.24414380f, -0.04765259f, -0.34436384f, 
    0.19881608f, 0.01321438f, 0.27081335f, 0.10171942f, -0.03758902f, -0.06740005f, -0.02350510f, -0.12896982f, 
    0.07201912f, -0.38485965f, -0.30441573f, 0.08912718f, 0.03894393f, -0.02360704f, 0.07775300f, 0.05443689f, 
    0.05197341f, 0.15883684f, -0.07643795f, 0.26402500f, -0.37112549f, -0.04125148f, 0.09147925f, 0.14103691f, 
    0.01419912f, 0.01739808f, -0.02700309f, 0.07725630f, -0.09143982f, -0.12831068f, 0.03137566f, 0.29200035f, 
    0.46987677f, 0.31429055f, -0.12148158f, -0.14532863f, -0.04008552f, 0.12329598f, -0.03540635f, -0.03735559f, 
    0.01054250f, -0.01562487f, 0.01996888f, -0.03201517f, 0.10085380f, 0.21823338f, -0.34207064f, -0.32003394f, 
    0.14688623f, 0.01452954f, 0.00996991f, -0.14933454f, -0.00720146f, 0.04424917f, 0.09171635f, 0.00974334f, 
    -0.57427984f, -0.40318963f, -0.94011790f, 0.04682530f, 0.04874447f, 0.06424216f, -0.04491158f, 0.04231927f, 
    -0.26566803f, -0.00006020f, -0.23332748f, -0.40929982f, 0.06620552f, 0.38853955f, -0.14882062f, -0.10342718f, 
    0.01125424f, 0.09230303f, 0.12545145f, -0.36414674f, -0.14054649f, -0.11859393f, -0.18527585f, 0.01356018f, 
    0.06570093f, -0.50228918f, -0.04060185f, -0.01753237f, 0.02487730f, -0.00253062f, 0.06036401f, 0.07446196f, 
    0.10302258f, -0.04844702f, -0.02880322f, 0.03860506f, -0.05980979f, 0.18996231f, 0.05637059f, 0.08516560f, 
    0.04855556f, 0.16058360f, -0.02577548f, -0.13827233f, -0.02245172f, 0.15493655f, -0.00657004f, 0.11226537f, 
    0.45001650f, -0.41361865f, -0.01403451f, 0.08601730f, -0.04656400f, -0.04455192f, -0.11364056f, -0.04247561f, 
    -0.11889137f, 0.07955397f, -0.17876066f, 0.15679111f, -0.19003434f, 0.14841062f, 0.20613937f, -0.05274818f, 
    -0.03083334f, 0.04486706f, -0.10521542f, 0.19886908f, -0.13847233f, 0.01415520f, -0.20419933f, 0.09458423f, 
    0.34322280f, -0.18265218f, 0.12057987f, -0.19045798f, -0.00755435f, -0.14037681f, 0.00754719f, -0.11235051f, 
    -0.05190312f, 0.02383434f, -0.01262932f, 0.05482663f, -0.01103045f, 0.31588495f, -0.01243070f, -0.49140504f, 
    -0.22594652f, -0.08539198f, -0.08407554f, 0.06836282f, -0.03508155f, -0.10464518f, 0.13729729f, 0.01458987f, 
    -0.01219324f, 0.02475195f, 0.01139572f, 0.19895694f, 0.02242111f, 0.20638517f, 0.06929857f, -0.22606684f, 
    0.12731062f, 0.13826661f, 0.07768726f, 0.18142535f, 0.11793415f, 0.09426416f, 0.33805248f, 0.05258206f, 
    0.14679329f, 0.23825504f, -0.01892099f, -0.21687619f, 0.09777786f, 0.10035837f, -0.11998867f, -0.04792431f, 
    -0.45218879f, -0.11761790f, -0.76204479f, -0.09588242f, 0.18898389f, -0.13632487f, 0.15921623f, -0.09372063f, 
    0.05295780f, 0.15021595f, -0.11704166f, 0.05450970f, -0.23398460f, -0.19676991f, -0.09547304f, -0.36516383f, 
    0.08165437f, -0.10292764f, 0.15464476f, 0.23149751f, -0.18358652f, 0.10722896f, 0.16387898f, 0.06461602f, 
    -0.03654496f, -0.13172759f, 0.51769149f, 0.07822563f, 0.04739175f, -0.03549509f, 0.19064379f, 0.07972812f, 
    0.15497303f, -0.04159911f, -0.04185664f, -0.04859748f, -0.12662469f, -0.56553203f, 0.37078449f, 0.04152189f, 
    -0.17227595f, 0.07295657f, -0.01876251f, 0.09273443f, -0.04260346f, -0.09213091f, 0.12898076f, 0.02518789f, 
    -0.09889443f, 0.16925199f, 0.06678599f, -0.03306292f, 0.03602383f, -0.06061242f, 0.04890984f, 0.07366068f, 
    -0.01036839f, 0.01550721f, -0.01366036f, -0.09661403f, -0.20649952f, -0.21662463f, -0.03260518f, -0.02135998f, 
    -0.13508168f, 0.07475163f, 0.03194833f, -0.04947178f, 0.05636790f, 0.06723334f, -0.12380606f, 0.15029748f, 
    0.44037095f, 0.03767265f, -0.32448718f, -0.30230340f, -0.06009011f, -0.01719297f, 0.11072365f, 0.15828320f, 
    0.03489078f, -0.02456022f, -0.06391627f, -0.17539869f, -0.06680138f, -0.17895085f, 0.25597131f, -0.04762204f, 
    0.12747042f, 0.11396305f, -0.04987883f, -0.04275702f, -0.35858691f, 0.13171814f, 0.21658331f, -0.36671191f, 
    0.54841322f, 0.01815640f, -0.29678255f, -0.43931502f, 0.05990845f, 0.13002543f, 0.04443528f, -0.26872817f, 
    -0.10074541f, -0.03138010f, -0.08839685f, -0.21649303f, 0.64686888f, -0.12256414f, 0.23304075f, 0.33798137f, 
    -0.05952318f, -0.07991760f, -0.02179959f, -0.01339346f, -0.01462667f, 0.11027848f, -0.00793108f, -0.04903306f, 
    -0.22135463f, 0.07226237f, -0.10467196f, -0.00081202f, -0.04824615f, 0.13299929f, 0.07980688f, -0.11091125f, 
    -0.06565992f, -0.13412333f, 0.03108414f, -0.10215569f, -0.67702240f, 0.08855376f, -0.25991559f, -0.25227711f, 
    0.09336243f, 0.08074395f, 0.04471526f, 0.01554012f, 0.09467817f, 0.24192218f, -0.02885919f, 0.14973329f, 
    0.05064909f, -0.06744953f, 0.06740601f, -0.14140102f, -0.04676497f, -0.07870246f, 0.00538895f, -0.11565398f, 
    -0.15459116f, 0.12258139f, 0.05444895f, -0.00065086f, 0.43580467f, 0.12397587f, 0.02936086f, -0.09078569f, 
    -0.03862089f, 0.02808376f, -0.07553519f, 0.00300897f, 0.13156176f, 0.05341375f, -0.03748662f, 0.12300036f, 
    0.15819621f, 0.11261681f, 0.11195505f, 0.24857479f, -0.06132685f, -0.10253594f, -0.01472058f, -0.01556218f, 
    -0.02863792f, 0.09850400f, 0.02091691f, 0.04807935f, 0.41931102f, 0.21005452f, 0.37486076f, -0.06046698f, 
    0.03195907f, -0.05417041f, -0.02447805f, 0.05618138f, 0.04936181f, 0.05173889f, -0.12740661f, 0.06022360f, 
    -0.02754349f, -0.63696474f, -0.64682639f, 0.03820099f, 0.11437995f, -0.24465722f, 0.07237698f, -0.15601885f, 
    -0.10478401f, 0.24327782f, -0.13545661f, -0.05881177f, -0.04151557f, 0.21160543f, 0.18929373f, -0.06162841f, 
    -0.10173969f, 0.06445521f, -0.04766930f, 0.02180929f, 0.05491693f, -0.03150004f, 0.03479277f, 0.02630384f, 
    0.02624620f, -0.05566374f, 0.11603268f, 0.09794293f, 0.02599600f, 0.00314770f, -0.07960687f, 0.01566023f, 
    0.13402085f, -0.16664395f, 0.00417002f, -0.05777037f, 0.10412942f, -0.03120392f, 0.02826380f, -0.11407299f, 
    -0.04286290f, -0.02685430f, -0.16398181f, 0.04838876f, -0.76780802f, -0.22684473f, -0.30877525f, -0.36586910f, 
    -0.18261744f, 0.30454412f, 0.12286397f, 0.24687496f, -0.00174849f, 0.01194838f, 0.10176028f, -0.01171873f, 
    -0.16602471f, -0.00812680f, -0.00179657f, 0.06223423f, -0.05127964f, -0.14769627f, -0.42473915f, -0.10662083f, 
    -0.35715407f, -0.17461303f, -0.17303042f, 0.12656274f, -0.08710673f, 0.02474015f, 0.08498141f, 0.00706825f, 
    0.51231390f, 0.02769566f, -0.22975993f, 0.17588384f, -0.03216352f, -0.08961917f, -0.04710259f, 0.05432510f, 
    0.09468900f, 0.17006350f, -0.02385337f, -0.21948485f, -0.16462009f, -0.01860199f, 0.07963613f, -0.06632046f, 
    -0.12866625f, 0.01552968f, 0.13137184f, 0.18669088f, -0.13935681f, -0.00648402f, 0.25419882f, -0.05967352f, 
    -0.05166380f, 0.09248225f, 0.42532247f, 0.56702137f, -0.03093532f, -0.01294944f, 0.09277419f, 0.05583996f, 
    0.06608249f, -0.07792082f, 0.04262583f, -0.07744443f, 0.14833309f, 0.01439978f, -0.07383697f, -0.02504663f, 
    0.14318889f, 0.10597825f, -0.26859212f, -0.05463757f, -0.07152539f, -0.16530856f, -0.18912680f, -0.44984087f, 
    0.41537029f, 0.10545802f, -0.05300926f, -0.11897902f, 0.04024356f, 0.02314565f, 0.06468310f, -0.05379111f, 
    0.01409480f, 0.06242151f, -0.02326461f, -0.09274087f, -0.28730544f, -0.42363980f, -0.20281175f, -0.00536327f, 
    0.11126334f, -0.05146642f, -0.04143093f, 0.03035290f, 0.03802711f, -0.03932263f, 0.21941736f, -0.00443348f, 
    -0.19763328f, 0.07150129f, 0.22120401f, -0.62127125f, -0.05821651f, 0.00976142f, -0.07330691f, 0.14219411f, 
    0.03474692f, -0.00902842f, -0.00557569f, -0.00911668f, 0.04321142f, 0.42539313f, -0.09353859f, -0.26445058f, 
    0.30243170f, -0.68188637f, -0.22289845f, 0.10399225f, 0.03081414f, 0.13893722f, -0.06233407f, 0.07378180f, 
    -0.08489842f, 0.05147165f, -0.00740867f, 0.20822378f, 0.00293843f, 0.04833101f, 0.02614515f, -0.24587628f, 
    0.12426630f, 0.22032574f, -0.39055556f, 0.27321085f, -0.86134320f, 0.25037396f, 0.56659603f, -0.24787597f, 
    -0.23287113f, -0.15237160f, 0.06515674f, 0.07964498f, -0.07033984f, -0.02767223f, 0.00456276f, 0.05384480f, 
    0.01259971f, -0.02097496f, -0.28909338f, -0.12611079f, 0.04318359f, -0.23539802f, -0.03693493f, 0.04881960f, 
    -0.12887667f, 0.05348020f, -0.14606224f, 0.05247701f, 0.33036026f, 0.09137029f, -0.06784611f, -0.11021873f, 
    0.11981640f, -0.12539677f, -0.35638198f, -0.07228973f, -0.20542552f, -0.04110132f, 0.09434952f, 0.08270597f, 
    -0.01983473f, -0.34400380f, 0.63391906f, 0.36611727f, -0.14730528f, 0.00336773f, 0.11626735f, 0.09219607f, 
    0.05850870f, -0.06369627f, 0.09220349f, -0.14391607f, 0.07471357f, -0.39720145f, -0.07042988f, -0.10654160f, 
    0.10501599f, -0.14578480f, -0.18202616f, 0.04704669f, -0.06212634f, -0.00356173f, -0.13309413f, -0.14699844f, 
    0.05401953f, 0.21175842f, 0.03397306f, -0.04935326f, -0.00574312f, 0.06248598f, 0.06006410f, 0.00790176f, 
    0.03477620f, -0.07594740f, 0.00352789f, 0.01296478f, -0.04451764f, 0.17194444f, 0.08263128f, 0.14945106f, 
    0.00364172f, -0.02382290f, 0.09198492f, 0.03305225f, 0.02190210f, -0.04971742f, 0.09690613f, -0.10556673f, 
    -0.42593458f, 0.66555107f, 0.62086844f, -0.43233511f, -0.05212018f, -0.07406246f, -0.02947944f, -0.12995628f, 
    -0.03090438f, -0.06608316f, -0.03260603f, -0.14324693f, -0.16635987f, 0.02146184f, 0.27476844f, 0.30029637f, 
    -0.10583035f, -0.02296417f, 0.14203629f, -0.13592494f, -0.03699389f, 0.00877748f, -0.00028506f, -0.10488371f, 
    0.66751307f, 0.17987247f, 0.62440920f, 0.59552175f, -0.01200550f, 0.03803529f, -0.01724182f, 0.11571965f, 
    0.11760075f, -0.14314964f, 0.08251027f, 0.14724678f, -0.14553019f, 0.19177899f, -0.28390068f, -0.18421589f, 
    0.04911107f, -0.07690863f, -0.01327007f, 0.03230243f, -0.08262873f, 0.03436285f, 0.00402514f, -0.30158970f, 
    -0.03597841f, 0.09513269f, 0.15606660f, 0.26149285f, -0.02823572f, 0.09128174f, 0.00445890f, -0.08463282f, 
    0.06190031f, 0.05822611f, 0.06684711f, 0.04364237f, 0.09623653f, 0.28217465f, -0.05910766f, 0.33089858f, 
    0.02824061f, 0.11938886f, 0.11371149f, -0.09008916f, -0.15932217f, -0.08839789f, -0.17846374f, 0.10523994f, 
    -0.20406172f, 0.02736590f, 0.11151613f, 0.02768583f, 0.16862625f, 0.03508667f, 0.04680001f, -0.07378006f, 
    0.12466101f, 0.00817565f, -0.02020122f, -0.09518795f, -0.11589477f, -0.00151738f, 0.05695943f, -0.07547448f, 
    0.06883129f, -0.01143004f, -0.09670765f, -0.02691055f, 0.08055644f, 0.00415766f, -0.03210047f, 0.06414752f, 
    -0.26740947f, -0.24070521f, 0.09809485f, -0.17392883f, -0.05558580f, -0.10081536f, -0.01691460f, 0.03776787f, 
    -0.08793716f, -0.06948660f, -0.02146867f, 0.02652789f, 0.08641366f, -0.36601853f, 0.03220132f, -0.22306019f, 
    -0.01201126f, 0.01454525f, -0.04939490f, -0.00672568f, 0.03268124f, -0.05839343f, -0.16756073f, 0.16366029f, 
    0.33979753f, -0.56037170f, 0.03494973f, -0.05030132f, -0.05598943f, -0.20091678f, -0.17254098f, -0.10791200f, 
    -0.05683554f, 0.04930232f, 0.03107495f, -0.01338609f, -0.78400308f, -0.39555478f, -0.30050862f, -0.19814625f, 
    -0.10047789f, 0.08184166f, 0.03950042f, -0.07705873f, 0.00257246f, -0.03968781f, -0.03902153f, 0.04421743f, 
    -0.12404320f, -0.06170490f, 0.40644592f, -0.01456833f, 0.01431589f, 0.06910197f, 0.11753439f, 0.01293062f, 
    0.21209987f, 0.04599170f, 0.25264299f, -0.19048321f, 0.11376136f, 0.00953872f, -0.09838729f, 0.01361937f, 
    -0.06204424f, -0.05637809f, 0.00501457f, -0.06872407f, 0.09179650f, 0.17156722f, 0.25167593f, 0.24040647f, 
    -0.51180476f, -0.18883206f, -0.34667847f, -0.23584592f, -0.05628406f, 0.03876043f, 0.04043075f, 0.08138666f, 
    0.02425211f, 0.03538143f, -0.07798586f, 0.00577414f, -1.07643330f, -0.46546754f, 0.44122207f, -0.17613101f, 
    0.12939368f, -0.12759204f, -0.27687714f, -0.33703396f, 0.06832855f, -0.04368436f, 0.09856136f, -0.02609094f, 
    -0.03989951f, -0.15100910f, 0.19740544f, -0.00862142f, 0.02492402f, 0.00134343f, 0.04419083f, 0.13334404f, 
    0.13450195f, -0.07455993f, -0.08272482f, 0.10449746f, -0.08636375f, -0.31766844f, 0.14576997f, 0.24841486f, 
    0.15863483f, -0.02193365f, 0.07888445f, -0.17877302f, 0.07693855f, -0.12923288f, 0.00002321f, 0.05290571f, 
    0.14240472f, 0.23766069f, -0.25931731f, 0.22072186f, -0.02218626f, -0.08151878f, 0.06200706f, -0.06708668f, 
    -0.01442009f, 0.00995409f, 0.12152670f, -0.19225016f, 0.08601616f, 0.09252309f, 0.04822557f, 0.27105820f, 
    0.01302200f, 0.03726950f, 0.02940457f, -0.02273617f, -0.08167576f, 0.07358643f, -0.02222892f, 0.14112626f, 
    0.20187275f, 0.48972383f, -0.02266897f, 0.36718413f, 0.00034974f, -0.07961372f, -0.11508765f, 0.06142196f, 
    -0.04807140f, 0.05919098f, -0.02734491f, -0.07844917f, 0.26197168f, -0.22878462f, -0.16029878f, -0.31094307f, 
    0.14342646f, -0.10486037f, 0.11887844f, 0.05030534f, -0.01215366f, 0.24324104f, -0.37460774f, -0.07287368f, 
    -0.45395970f, -0.25395852f, 0.17234248f, 0.00896797f, -0.23521140f, -0.03713247f, -0.12945336f, -0.03937221f, 
    -0.18049072f, 0.08165430f, -0.06778717f, 0.01876469f, -0.08204770f, 0.42284867f, 0.05854604f, 0.72612971f, 
    0.04993047f, -0.15324274f, -0.10459089f, 0.01338502f, -0.02400533f, -0.09216799f, -0.02326694f, 0.21675217f, 
    -0.37988934f, -0.23121759f, -0.09283860f, -0.42103100f, -0.16366398f, -0.07349993f, -0.18578885f, -0.28984654f, 
    -0.22745374f, 0.16498591f, -0.26236108f, -0.20478179f, 0.07229020f, -0.23670892f, -0.18202245f, 0.20868859f, 
    0.13526919f, -0.02508073f, 0.02029882f, -0.12302272f, -0.05045360f, -0.02722055f, 0.14391845f, 0.08023115f, 
    0.02483576f, -0.08071423f, -0.37569669f, -0.09244279f, 0.01395092f, -0.05253144f, -0.21738732f, -0.07269323f, 
    -0.08081800f, -0.04320323f, 0.12536205f, 0.10362278f, 0.38870427f, 0.33219075f, 0.46075267f, 0.18448003f, 
    -0.02425897f, 0.11263799f, -0.05735070f, -0.21187788f, -0.08438555f, 0.03354719f, 0.11032233f, -0.13615130f, 
    -0.26202145f, 0.39740315f, -0.18162628f, -0.11566471f, 0.14413607f, -0.05399907f, -0.17199163f, 0.08833156f, 
    -0.29836750f, -0.03206794f, 0.01043933f, -0.00265784f, 0.21870558f, 0.01147818f, 0.05946821f, 0.31236529f, 
    -0.05821537f, -0.19891734f, 0.17795764f, -0.04272333f, -0.05043054f, -0.06614067f, 0.15721484f, 0.02802318f, 
    0.10187073f, 0.17485096f, 0.08690921f, -0.57498401f, -0.20341833f, -0.03454482f, -0.08186570f, -0.06549220f, 
    0.09686531f, -0.11537929f, -0.13060793f, 0.01227412f, 0.43406045f, -0.23509832f, -0.20364384f, -0.12937964f, 
    0.26211005f, 0.20671788f, 0.20705399f, -0.04296596f, -0.10697985f, 0.08142687f, -0.20140682f, -0.07367224f, 
    -0.31772661f, -0.16376279f, 0.01836143f, 0.48532379f, -0.06118500f, 0.10389007f, -0.04784100f, -0.13044846f, 
    0.13245831f, 0.04619532f, 0.15872762f, 0.03783735f, -0.06483802f, -0.18756285f, 0.00888346f, 0.36927053f, 
    -0.01571872f, 0.03065906f, 0.01889894f, 0.10512469f, 0.05691013f, 0.06540747f, 0.03813355f, 0.05711304f, 
    -0.10605451f, 0.00878224f, 0.20560396f, 0.08562295f, 0.24625328f, 0.11737057f, -0.08461217f, 0.05651676f, 
    -0.19717745f, 0.10054408f, 0.00012103f, -0.03667427f, -1.02628458f, 1.08521390f, -0.59088248f, -0.65047938f, 
    0.23518403f, 0.26651871f, 0.07228544f, -0.22716501f, -0.26568946f, -0.00561793f, 0.03629065f, 0.00350638f, 
    -0.43393916f, -0.10010704f, -0.03684572f, -0.08182725f, 0.18352200f, 0.07951945f, 0.05199702f, -0.20814569f, 
    -0.09225416f, -0.07612727f, 0.00462709f, -0.11742681f, 0.96749365f, -0.01795087f, -0.10935762f, -0.07043465f, 
    0.17068876f, 0.08528576f, 0.01078593f, -0.20692688f, -0.12713023f, 0.10460971f, -0.03399286f, 0.11100488f, 
    -0.65403616f, 0.05136774f, -0.23996195f, 0.17330272f, -0.31387356f, -0.00024988f, -0.35298550f, -0.11039822f, 
    -0.08312985f, -0.10118795f, -0.16694528f, -0.19869684f, -0.59383273f, 0.03451954f, -0.42687547f, 0.11671367f, 
    -0.12420718f, 0.01459880f, 0.46223128f, 0.01147783f, 0.10096204f, 0.18871704f, -0.08979357f, 0.02789426f, 
    -0.73260939f, -0.48487371f, -0.29851639f, -0.20998013f, -0.14173982f, -0.41437411f, -0.41815630f, 0.00700008f, 
    0.01706018f, 0.27911499f, 0.11457273f, 0.01810393f, -0.21084379f, -0.05356337f, 0.73320323f, -0.64137816f, 
    -0.28480709f, -0.06066641f, -0.21748702f, 0.16665763f, -0.01411176f, -0.03040275f, 0.07586788f, 0.04857780f, 
    0.29035303f, -0.14793544f, 0.02137206f, 0.13146679f, -0.16255325f, -0.11802316f, 0.00402441f, -0.03766662f, 
    0.13195749f, 0.03246597f, 0.11826900f, 0.13402702f, -0.03705844f, -0.18632053f, 0.00460321f, 0.21025935f, 
    -0.01117721f, 0.03768985f, -0.02101504f, 0.01313628f, -0.16066106f, 0.04344538f, -0.09389940f, -0.07184453f, 
    0.00435566f, 0.37132153f, -0.25179556f, -0.03291099f, 0.20308928f, 0.05867195f, 0.10299760f, -0.06640661f, 
    0.07421302f, -0.03967049f, -0.13821226f, 0.03147899f, 0.47864825f, -0.08902145f, 0.19240861f, -0.19402567f, 
    -0.10306612f, 0.09215811f, 0.06799771f, -0.02247957f, 0.14046931f, 0.07310398f, 0.14617421f, -0.15116397f, 
    0.03150678f, -0.17344537f, -0.03418089f, 0.15642393f, 0.08038959f, 0.13314159f, -0.01308128f, 0.23911871f, 
    0.17991011f, 0.03671322f, -0.05754112f, -0.19076346f, 0.08178463f, -0.17511225f, 0.17194420f, 0.22233306f, 
    -0.01119869f, 0.13759832f, 0.07561535f, 0.10712060f, -0.05651476f, -0.12144768f, 0.08744555f, 0.16217515f, 
    0.52404463f, 0.19516364f, -0.17597826f, 0.18451089f, 0.48574197f, 0.07170798f, 0.07994584f, -0.15641846f, 
    -0.14420016f, -0.16733275f, -0.16049342f, -0.14614056f, 0.09585413f, 0.07343820f, -0.01384382f, -0.15538600f, 
    -0.03494363f, -0.12699327f, -0.10900722f, -0.19751129f, 0.02357269f, -0.12817664f, 0.05209057f, -0.09743929f, 
    -0.33553427f, 1.00948274f, -0.61535776f, -0.49244907f, 0.15050292f, 0.07614110f, -0.05656287f, -0.13566926f, 
    0.01910458f, -0.15861149f, 0.12706609f, -0.20624883f, 0.16558452f, -0.27546060f, -0.06950559f, 0.12133013f, 
    0.10058175f, -0.09032337f, 0.05823592f, -0.07994805f, 0.00762560f, -0.03142340f, -0.01217794f, 0.19242954f, 
    -0.35084903f, -0.24820624f, 0.00810487f, -0.40646917f, 0.12637535f, 0.01146161f, -0.05290456f, 0.01447009f, 
    0.07443659f, -0.13807383f, 0.11902677f, -0.06401076f, 0.26170126f, 0.02131635f, -0.24738260f, -0.16259226f, 
    0.04652741f, -0.06777969f, 0.08710660f, -0.07834259f, -0.07402463f, -0.16565968f, -0.27694321f, -0.28491572f, 
    0.16615304f, -0.06054188f, -0.09869995f, 0.28644848f, 0.18277507f, -0.01466817f, 0.12112155f, 0.01868038f, 
    0.11521470f, 0.00556627f, -0.02515847f, -0.14522362f, 0.18475959f, -0.11410035f, 0.07174086f, 0.40434861f, 
    0.05374203f, 0.09249671f, -0.07106355f, -0.11859248f, 0.06037919f, -0.01104275f, -0.05928435f, -0.02942467f, 
    -0.03325385f, -0.14265856f, -0.01864533f, -0.14889276f, -0.22051801f, -0.00543975f, -0.06399291f, 0.08021444f, 
    -0.10866042f, -0.09810521f, 0.00853690f, -0.16047154f, 0.01356603f, 0.02735506f, 0.17535974f, 0.19095685f, 
    -0.11204696f, -0.14214680f, -0.00362253f, -0.01239121f, 0.04715574f, -0.03411455f, 0.08894388f, 0.01311554f, 
    -0.17912672f, -0.12644641f, 0.26978263f, 0.01350856f, 0.16653028f, -0.06583644f, -0.29316336f, 0.01669467f, 
    -0.20658557f, -0.09162192f, 0.02779390f, -0.06799848f, 0.00275725f, -0.15129352f, -0.18075544f, 0.19891939f, 
    0.18190448f, -0.14756541f, -0.07463647f, -0.30335048f, 0.00682525f, 0.08577966f, -0.01521834f, 0.09682459f, 
    0.05640548f, -0.42760882f, 0.06381536f, -0.00790624f, -0.20373252f, -0.06019150f, 0.00765727f, -0.21441121f, 
    -0.02252221f, 0.01778702f, 0.03945557f, -0.05008010f, 0.12131938f, 0.04028996f, -0.18657775f, 0.08060673f, 
    0.03334071f, -0.04062013f, -0.14939894f, 0.05125864f, -0.01952084f, -0.05613469f, 0.00165879f, -0.17554988f, 
    0.21525797f, -0.41452634f, -0.17996743f, 0.30859637f, -0.00334962f, -0.21612130f, 0.04751964f, -0.15114871f, 
    -0.04946034f, 0.02970150f, -0.00841807f, 0.13594356f, -0.24649897f, -0.14031415f, 0.14051645f, -0.00198168f, 
    -0.10333909f, -0.02961406f, 0.04961473f, 0.12987994f, -0.02460450f, -0.04159116f, 0.00189400f, -0.18323629f, 
    -0.17378186f, 0.21819928f, 0.15628237f, 0.18578617f, -0.05775380f, -0.12421428f, -0.18738547f, -0.10691503f, 
    -0.09061670f, -0.17049044f, 0.05407379f, 0.01847399f, -0.08912335f, 0.24305142f, 0.14375855f, -0.02514238f, 
    -0.12447410f, -0.00483158f, 0.05321094f, 0.02612951f, 0.17892940f, 0.15361184f, -0.05230681f, 0.37998658f, 
    0.10539959f, 0.27105135f, 0.07213638f, 0.31473377f, -0.13868648f, -0.19645061f, 0.20475447f, -0.30045158f, 
    -0.10346396f, -0.11135508f, 0.04815699f, 0.05525991f, 0.09969730f, -0.60642529f, -0.13392088f, -0.22456709f, 
    0.02622488f, 0.16067949f, -0.01123844f, 0.09538417f, -0.15319137f, -0.05832333f, -0.15053678f, 0.03718045f, 
    0.09741815f, 0.00034587f, -0.01565602f, 0.01254995f, -0.27347460f, -0.06529922f, -0.08649907f, 0.01461353f, 
    0.03352260f, 0.07722553f, -0.14421919f, 0.01787199f, -0.05468218f, 0.05598100f, -0.19675265f, -0.10346632f, 
    -0.10275074f, 0.01542337f, 0.04506564f, 0.13710068f, 0.07491758f, -0.18716823f, -0.16485448f, -0.07513497f, 
    -0.05745516f, 0.09035440f, -0.00543966f, 0.04565253f, 0.07481565f, -0.10052095f, -0.20055421f, 0.02102975f, 
    -0.01058035f, -0.06331618f, -0.02259632f, -0.12445658f, 0.15914401f, -0.18486817f, -0.13253184f, -0.02906211f, 
    0.12014350f, -0.01953579f, 0.04400473f, -0.24858965f, 0.00687953f, -0.08507143f, -0.16025780f, 0.19100904f, 
    0.03609685f, 0.04051505f, 0.03081250f, 0.12951313f, 0.12705618f, 0.16652369f, 0.05719311f, -0.00377841f, 
    0.13668880f, 0.00194315f, -0.00320508f, 0.02807276f, -0.13404652f, -0.29002213f, -0.91957235f, 0.23754920f, 
    0.07679388f, 0.04942818f, 0.09673871f, -0.08156661f, 0.13176639f, 0.03987664f, 0.05481747f, -0.04721517f, 
    0.29392248f, 0.25733942f, 0.26797956f, -0.01021103f, -0.00114665f, 0.13976131f, 0.01220644f, -0.11935065f, 
    0.10994399f, -0.23060393f, 0.02096917f, -0.09793597f, 0.03743434f, 0.11947056f, 0.15564848f, 0.17503475f, 
    -0.10827316f, -0.05462027f, 0.00722372f, -0.01749348f, -0.00758517f, -0.03640942f, 0.04269482f, 0.09617502f, 
    -0.50304741f, 0.01962443f, -0.25302574f, -0.26384357f, -0.03518052f, -0.04066643f, 0.03482869f, 0.06754842f, 
    0.09660666f, -0.06782999f, 0.03400404f, 0.26428929f, 0.09698641f, -0.01759014f, -0.12508781f, 0.09375253f, 
    0.05830423f, -0.05767640f, 0.03877749f, -0.08064256f, 0.18330573f, -0.02230685f, 0.24939243f, 0.49106428f, 
    0.14747435f, 0.13311878f, 0.35296327f, 0.13231991f, -0.04204481f, -0.22096513f, -0.04687178f, -0.01397909f, 
    0.16988198f, -0.01660431f, 0.06878488f, -0.00238155f, -0.04845278f, 0.40880165f, 0.37736654f, 0.61767048f, 
    0.03765969f, 0.04379886f, 0.11688709f, 0.20125623f, 0.03672099f, -0.00950579f, -0.05721959f, -0.12401313f, 
    -0.10541234f, -0.01849345f, -0.03257811f, -0.01962373f, -0.04577103f, 0.07578264f, -0.04213005f, 0.09652016f, 
    -0.07205533f, -0.13550201f, -0.10548607f, -0.00554734f, 0.11431243f, -0.26604396f, -0.07153591f, -0.08289722f, 
    0.00241964f, 0.05906162f, -0.09055027f, -0.04336803f, 0.15341659f, 0.03984746f, -0.15194875f, 0.00395839f, 
    -0.21088742f, -0.73463047f, 0.07437322f, -0.38804144f, 0.02460970f, 0.09365037f, 0.01405253f, 0.08301982f, 
    -0.05638009f, -0.11074089f, -0.19584432f, -0.11673070f, -0.25265339f, -0.01863259f, -0.00442134f, -0.00394901f, 
    -0.04412397f, -0.05995763f, 0.08819680f, 0.08737554f, 0.00711003f, 0.06640229f, 0.07259455f, 0.25358331f, 
    -0.11214162f, 0.60207695f, -0.32740894f, -0.43046901f, -0.02255275f, 0.02092160f, 0.11222330f, 0.11378092f, 
    -0.02202026f, -0.06393605f, 0.06759369f, -0.14418508f, 0.20603003f, -0.16432774f, -0.30973187f, 0.21315475f, 
    -0.05370655f, -0.02644063f, -0.02338763f, -0.07806151f, 0.10853656f, 0.02559804f, 0.55851823f, 0.15472800f, 
    -0.07081319f, 0.19252041f, -0.40193886f, 0.16946469f, 0.05707322f, 0.11200739f, -0.10165989f, -0.01465469f, 
    0.15845503f, 0.00934165f, 0.00127501f, 0.13492560f, 0.28438172f, -0.50708938f, -0.29491886f, 0.32655790f, 
    0.03029963f, 0.10622222f, -0.00743545f, 0.23134863f, 0.12608331f, 0.01260782f, -0.01140346f, -0.24638332f, 
    -0.11954428f, 0.01199928f, 0.09118668f, -0.00307831f, 0.31612459f, -0.09424932f, -0.13145112f, 0.29117963f, 
    0.00402005f, -0.10294197f, -0.00314349f, 0.06643958f, -0.10278081f, 0.28685501f, -0.15734744f, -0.07370799f, 
    0.04875075f, -0.09122121f, 0.02967298f, -0.10707756f, 0.08370473f, -0.09001029f, -0.07580829f, 0.04155334f, 
    0.01449226f, 0.36947486f, 0.55697036f, -0.16711596f, -0.28505838f, 0.18912514f, 0.39250305f, -0.06444132f, 
    0.18194458f, -0.07600209f, -0.12412404f, 0.32365912f, -0.22973722f, 0.21133804f, -0.05948275f, 0.04340446f, 
    -0.04852362f, 0.05032398f, -0.16868952f, 0.03989554f, 0.19498755f, -0.31227693f, -0.22345527f, -0.21282426f, 
    -0.23942623f, 0.25622675f, -0.20153213f, -0.01420500f, 0.10814077f, -0.04562672f, -0.05062994f, -0.09988643f, 
    0.03971917f, 0.09400519f, -0.09301855f, 0.05941309f, -0.04627759f, 0.39615566f, -0.25213766f, -0.16737752f, 
    0.15665016f, -0.01195417f, 0.03024550f, -0.20735638f, 0.07187149f, 0.14734429f, -0.14287272f, 0.07144629f, 
    -0.50786841f, -0.27323094f, 0.14024037f, 0.28369203f, 0.07793232f, -0.14325875f, -0.11702465f, 0.16485341f, 
    -0.00667412f, 0.02302556f, 0.03067068f, 0.09328888f, -0.10563209f, -0.18476397f, -0.17894766f, -0.04019941f, 
    0.02046120f, -0.04230685f, -0.09413903f, 0.00262665f, -0.08940814f, -0.19813640f, 0.23587866f, 0.06507222f, 
    0.15590549f, -0.02665685f, -0.56531572f, -0.58484095f, 0.03375390f, 0.16216849f, 0.07102542f, 0.03314635f, 
    0.16251101f, 0.13027303f, -0.04420701f, -0.00748517f, 0.10517688f, 0.01741310f, -0.12814157f, -0.06738873f, 
    0.12143518f, 0.00356761f, -0.00252233f, -0.04877422f, 0.12636800f, -0.14939578f, -0.21515658f, -0.25865859f, 
    -0.85285336f, -0.25073037f, -0.20398594f, -0.07683591f, 0.01580345f, -0.03916110f, -0.17643300f, 0.24850066f, 
    0.18869171f, -0.05337020f, -0.11472572f, -0.13713682f, -0.33069637f, -0.20741418f, 0.05096147f, 0.05188738f, 
    -0.05133251f, -0.01788574f, -0.01644215f, 0.15682821f, 0.15471849f, -0.11686463f, -0.03251798f, -0.05601887f, 
    0.08173474f, -0.57230914f, -0.08625937f, -0.06219456f, 0.21785341f, 0.02960253f, -0.10726805f, 0.06324349f, 
    0.11799382f, 0.03488610f, -0.00342105f, 0.06526759f, -0.73463231f, -0.48617890f, 0.01808163f, 0.26065266f, 
    -0.08713625f, -0.13211048f, -0.06095351f, 0.10436884f, 0.06390715f, -0.06160185f, 0.04771632f, 0.00245500f, 
    0.37615415f, -0.07764041f, -0.26955536f, 0.06056194f, 0.10857911f, 0.27977306f, -0.02862214f, 0.05476726f, 
    0.20614623f, -0.13749635f, 0.06715585f, 0.08924085f, -0.18220502f, -0.10072172f, 0.02069516f, -0.02659242f, 
    -0.08551279f, -0.08343010f, -0.06073747f, 0.32905832f, 0.01427984f, -0.07322016f, 0.34738174f, -0.43350154f, 
    -0.23940749f, -0.21569642f, -0.15561016f, 0.07482446f, 0.01494613f, 0.09347526f, -0.01512219f, -0.07907753f, 
    0.00993610f, -0.15917419f, -0.00189057f, -0.00924457f, 0.03859265f, -0.39049447f, -0.48752403f, 0.48427281f, 
    0.02409473f, 0.07270140f, 0.08732163f, -0.02654948f, 0.04743496f, 0.07815322f, 0.09629722f, -0.07789631f, 
    -0.26326013f, 0.42589483f, 0.16770294f, -0.21411663f, -0.05969288f, 0.15169120f, -0.03246018f, 0.12067064f, 
    -0.00375942f, -0.15278046f, 0.13226551f, -0.10374261f, 0.21588130f, 0.18816377f, 0.15125757f, 0.16554870f, 
    0.32846928f, 0.09199781f, -0.00123827f, 0.08079548f, 0.04607296f, -0.01841580f, 0.04305255f, 0.08681467f, 
    0.08054218f, -0.01336169f, -0.10492896f, -0.22160211f, -0.06226430f, 0.02308322f, 0.02915099f, -0.02539738f, 
    -0.24640237f, -0.04896879f, -0.20670901f, -0.61111856f, -0.33418089f, 0.04793430f, -0.08600697f, 0.04008424f, 
    0.01833715f, 0.11223308f, 0.04910364f, 0.06164986f, -0.01600509f, -0.37574628f, -0.77672631f, -0.51272410f, 
    0.03879718f, -0.06225390f, -0.04586205f, -0.12744392f, 0.14966807f, 0.27075335f, 0.24234039f, 0.07446408f, 
    0.12121120f, 0.10606443f, 0.06857280f, 0.05597984f, -0.03615182f, 0.11967667f, 0.19792801f, -0.39463630f, 
    0.17690483f, -0.10770137f, 0.20211005f, 0.04020377f, -0.03228827f, -0.06074136f, -0.07800599f, 0.03727305f, 
    -0.64350420f, -0.04259026f, 0.09394411f, -0.45383886f, -0.05958747f, 0.05535047f, 0.04419650f, -0.00846861f, 
    0.13191849f, -0.13874058f, 0.15004225f, 0.36579895f, 0.00499997f, 0.07448592f, 0.09768023f, -0.09669243f, 
    0.10290059f, -0.11961424f, -0.02750847f, -0.06897028f, 0.21680403f, 0.09681996f, -0.08699615f, -0.03859146f, 
    0.24459553f, -0.19056703f, 0.06796440f, -0.23948184f, -0.01891180f, -0.03214889f, 0.02126513f, -0.02066941f, 
    -0.05535327f, 0.16519296f, 0.09989151f, 0.07921731f, -0.13523427f, -0.13956884f, 0.04464103f, 0.02414272f, 
    -0.14165105f, -0.01739106f, 0.06716148f, 0.10247438f, -0.05812509f, -0.06232733f, 0.07477071f, -0.07088000f, 
    -0.66134334f, -0.09621979f, -0.00884394f, 0.32998109f, 0.13988477f, -0.00105083f, -0.12708960f, -0.13781694f, 
    0.02183538f, 0.10559639f, 0.14439066f, -0.04128905f, 0.15656762f, -0.06490976f, -0.04039869f, 0.29058537f, 
    -0.06516793f, -0.03057169f, 0.03867696f, -0.00558213f, -0.02712476f, 0.10801829f, -0.24974413f, -0.09470084f, 
    0.30026245f, -0.20233572f, -0.01945405f, -0.30234766f, 0.04386137f, 0.04241862f, 0.15061790f, -0.15737931f, 
    -0.00316893f, 0.02710924f, -0.07902483f, -0.01319876f, 0.01737840f, -0.41103461f, -0.12014628f, 0.13179931f, 
    0.22202688f, 0.38100952f, 0.38445160f, -0.42336634f, 0.08771518f, -0.06820029f, 0.05597543f, -0.02630152f, 
    0.20013264f, 0.08019145f, -0.17950420f, 0.18882710f, 0.05824661f, -0.10716294f, 0.15030406f, 0.28084174f, 
    -0.06602035f, 0.04058850f, 0.24743564f, -0.37335485f, -1.16740072f, -0.95621705f, 0.30326530f, -0.35424364f, 
    -0.42259410f, -0.24965937f, -0.17546354f, -0.23657140f, -0.05794193f, 0.04123821f, 0.11648801f, -0.05905667f, 
    0.08151884f, -0.62728256f, 0.52799147f, 0.32949108f, 0.14008658f, -0.23336218f, -0.05490756f, 0.03385943f, 
    -0.14032514f, 0.03014906f, 0.21825530f, -0.17647487f, -0.20065206f, -0.25505915f, 0.24429585f, -0.20579080f, 
    -0.03941214f, 0.06950571f, 0.04152221f, -0.13159083f, 0.20521519f, 0.05356462f, 0.02876168f, -0.01708021f, 
    -0.45029643f, -0.61030215f, 0.14313906f, -0.77791035f, -0.27139816f, -0.27963740f, 0.06407827f, -0.35313514f, 
    -0.10631754f, 0.15334427f, 0.06979202f, -0.00206049f, -0.13362367f, -0.15380979f, 0.12157622f, -0.23471452f, 
    0.05901662f, -0.41049853f, 0.12183274f, -0.06048689f, 0.04404610f, 0.00276819f, -0.01810582f, 0.09873013f, 
    -0.00375023f, -0.22144821f, -0.20166387f, 0.18097888f, 0.01633776f, 0.12002125f, -0.00287591f, 0.09671718f, 
    -0.11395548f, -0.02524922f, 0.06542739f, -0.00225700f, -0.19757433f, 0.25396058f, 0.35519013f, -0.02053569f, 
    -0.13511997f, 0.10216165f, 0.02591148f, 0.04277217f, -0.03228306f, 0.20858593f, -0.13547507f, -0.02330645f, 
    -0.00958850f, 0.42468759f, 0.19583504f, 0.34792700f, 0.07410067f, -0.03530964f, 0.12930898f, 0.10719414f, 
    0.09372284f, 0.04562115f, 0.14790864f, 0.15057513f, 0.07246962f, 0.00269187f, -0.37763157f, -0.26735163f, 
    -0.06594358f, 0.14664561f, -0.01597181f, -0.06335082f, -0.04524315f, -0.14728177f, 0.08056328f, 0.10233881f, 
    -0.62429446f, -0.00592289f, 0.96872455f, -0.10290377f, 0.01312619f, 0.07404957f, -0.06262299f, -0.13687590f, 
    -0.22663856f, 0.10598274f, 0.09922105f, 0.00777660f, -0.04491606f, -0.19016229f, 0.00970481f, -0.02155354f, 
    0.09939143f, 0.05130525f, -0.11943808f, 0.10454478f, 0.02661790f, 0.04544191f, -0.16226815f, -0.00578367f, 
    -0.36942124f, 0.22044469f, 0.15387002f, 0.13792187f, -0.11463831f, -0.08573402f, -0.15309520f, 0.09616208f, 
    0.01919360f, -0.02119928f, -0.02855653f, 0.04309461f, -0.15235648f, 0.25254467f, 0.28597736f, 0.44168201f, 
    -0.05486921f, -0.05520342f, -0.19348928f, 0.17600209f, -0.09905706f, 0.12364607f, 0.21740364f, -0.03187319f, 
    0.44140744f, 0.05863410f, -0.17180012f, -0.00483702f, -0.15768059f, 0.05805467f, 0.31668279f, 0.09727028f, 
    0.09359199f, -0.08230844f, -0.09361983f, 0.04820366f, 0.17742649f, -0.06377901f, -0.01654833f, 0.06802298f, 
    0.02780364f, 0.08237901f, 0.11991363f, -0.05988853f, 0.01057431f, 0.18989775f, -0.17601223f, -0.01065080f, 
    -0.05668337f, -0.12128032f, -0.04531425f, -0.06880402f, 0.09622612f, 0.04438063f, -0.03440680f, 0.00414008f, 
    -0.13184321f, -0.14240155f, -0.14490254f, -0.13115647f, 0.27119347f, 0.07645299f, -0.28147867f, -0.53667980f, 
    0.02262767f, -0.02730106f, 0.16358986f, -0.08020439f, -0.07363877f, -0.00637563f, 0.02545745f, -0.21173802f, 
    -0.18386270f, -0.65507847f, -0.14837435f, 0.16975586f, 0.08276092f, 0.07036706f, 0.03826790f, 0.09918913f, 
    0.05988515f, 0.10777225f, 0.09898809f, 0.13328914f, -0.73643631f, -0.81906927f, -0.50307220f, -0.56852573f, 
    -0.27145380f, -0.16429451f, 0.04347862f, -0.43080756f, -0.06475408f, -0.00793905f, 0.02676935f, -0.01462389f, 
    -0.10208012f, 0.08106454f, 0.04590239f, -0.03502588f, -0.07942545f, 0.05755883f, 0.02389625f, 0.02769815f, 
    0.14865215f, 0.10976455f, 0.14551982f, 0.13405035f, 0.11229671f, 0.04331718f, 0.08032717f, 0.00040578f, 
    0.00147053f, 0.01123063f, 0.02839085f, 0.03481498f, 0.09117710f, 0.35647920f, 0.29190242f, 0.05567065f, 
    -1.03624451f, -0.79122943f, -0.45530486f, -0.56064516f, -0.17552204f, -0.30369425f, -0.57238817f, -0.67507935f, 
    -0.06462414f, -0.08800712f, 0.02908458f, -0.03042793f, 0.12700121f, -1.29061222f, -0.75684363f, -0.03984481f, 
    0.07763203f, 0.07901422f, 0.29347274f, -0.13289446f, 0.01939707f, 0.01355130f, -0.03158447f, -0.02434518f, 
    -0.07895212f, 0.17435899f, 0.15761517f, -0.21791732f, 0.12198980f, -0.08048995f, 0.01614439f, -0.05883470f, 
    0.07401606f, 0.05314039f, 0.02069919f, 0.14387524f, -0.16717187f, 0.25282669f, 0.08935518f, -0.17325437f, 
    -0.03493460f, -0.00683155f, -0.23589116f, 0.33170128f, -0.05077225f, 0.18563153f, 0.10405359f, -0.04033944f, 
    -0.08125024f, 0.14923956f, -0.16521814f, -0.31228805f, 0.01966835f, 0.00064701f, -0.12322251f, 0.06121581f, 
    -0.01754412f, 0.09464538f, -0.01482986f, 0.06295262f, 0.19387929f, 0.15067439f, 0.00404200f, 0.07339558f, 
    -0.14274551f, 0.02007426f, 0.01562619f, 0.13185237f, -0.10510060f, 0.20939516f, 0.06637514f, 0.02233671f, 
    0.05553671f, 0.18672906f, 0.31819674f, 0.13526352f, 0.07412618f, -0.21036263f, 0.08652797f, -0.00872894f, 
    0.08125112f, -0.01170680f, 0.03957467f, -0.12359907f, 0.20063215f, -0.00427263f, 0.18305290f, -0.11517062f, 
    -0.01913636f, 0.00095591f, -0.04512189f, -0.01924795f, 0.01022399f, -0.08682227f, -0.23989378f, -0.29901227f, 
    -0.27347127f, 0.15261838f, 0.05479345f, -0.06895766f, 0.01307047f, -0.00800205f, -0.03758143f, -0.05836793f, 
    0.07587022f, 0.02478776f, 0.06581324f, 0.01973652f, -0.02555386f, 0.04082868f, -0.10097574f, -0.11130421f, 
    -0.04908947f, 0.01247736f, 0.24301419f, 0.26659155f, 0.00591834f, 0.14254248f, -0.02943264f, 0.02842408f, 
    0.06311911f, -0.22479104f, 0.02775579f, -0.00759642f, 0.12822111f, -0.11195070f, -0.08699835f, -0.22905916f, 
    -0.04005337f, 0.05676092f, -0.17441694f, -0.05007154f, 0.05295046f, -0.25868082f, -0.49621105f, -0.41775429f, 
    0.19543242f, -0.28468949f, 0.05321499f, 0.20079660f, -0.03706352f, 0.01851765f, -0.06272781f, 0.03625533f, 
    0.22786897f, -0.42117885f, 0.69529963f, -0.24323870f, -0.33599228f, -0.03499539f, -0.02507635f, 0.10296094f, 
    -0.05682980f, -0.14227362f, -0.18571191f, -0.24216393f, 0.20340630f, 0.03714060f, -0.05271876f, 0.01740903f, 
    0.00429149f, -0.03414259f, 0.23983754f, 0.07982298f, 0.01325381f, 0.01716806f, 0.03440406f, 0.08537348f, 
    0.64051163f, -0.67780513f, -0.40814248f, -0.66456795f, -0.00546231f, -0.02456547f, 0.14165814f, 0.27346292f, 
    -0.07431583f, 0.12430026f, -0.03528522f, 0.02081071f, 0.05993993f, 0.61140829f, -0.02357065f, 0.18887413f, 
    0.04528749f, 0.05108811f, 0.27762693f, 0.07857172f, -0.11510164f, 0.06741759f, 0.00067558f, 0.11024032f, 
    0.12032813f, -0.14836034f, 0.01891636f, -0.09362621f, -0.04335967f, 0.03844207f, -0.07100423f, -0.00001511f, 
    0.02022634f, 0.04004172f, 0.03475914f, -0.08021919f, 0.32443535f, 0.14556906f, -0.33365083f, -0.13220991f, 
    -0.03234790f, -0.06792834f, -0.03699954f, -0.15754849f, 0.00176737f, 0.06323160f, -0.18419126f, -0.20437363f, 
    -0.31080028f, 0.27685326f, 0.19977103f, 0.06081156f, 0.05923485f, -0.01786286f, 0.17978859f, -0.00368744f, 
    -0.14049923f, -0.04754018f, 0.16485937f, 0.06005202f, -0.29570881f, 0.02450139f, -0.52034205f, -0.27544406f, 
    -0.16637596f, -0.11665418f, 0.02611833f, 0.05507199f, 0.00794069f, 0.03140976f, -0.04877915f, 0.11388976f, 
    0.57317340f, -1.05490923f, -0.72367173f, -0.54281276f, -0.15179190f, -0.01589761f, -0.47896343f, 0.44469813f, 
    0.06252853f, 0.21143126f, 0.15292025f, 0.13791472f, 0.12654819f, 0.03501444f, 0.07573316f, -0.26661295f, 
    0.02871162f, -0.00902606f, 0.06849850f, -0.00188724f, 0.06648622f, 0.06167348f, -0.04507871f, -0.27697045f, 
    0.29715306f, -0.07462266f, -0.16112715f, -0.18693665f, -0.15839018f, -0.13439955f, -0.13684028f, -0.02713635f, 
    -0.00092041f, 0.08202329f, 0.06862672f, -0.02794918f, 0.74710643f, -0.32580024f, -0.28914618f, -0.19562021f, 
    0.01509628f, -0.12176970f, -0.03417156f, -0.13715491f, -0.21734132f, -0.12659897f, 0.09868712f, -0.04395202f, 
    -0.13147990f, 0.10488372f, 0.03867777f, -0.03290678f, -0.14000189f, 0.05287746f, -0.06219190f, -0.02929995f, 
    -0.03032948f, -0.01399675f, 0.10338462f, -0.00163663f, 0.03196166f, 0.00021329f, 0.18982249f, 0.02343753f, 
    0.01660266f, -0.09986338f, -0.07496503f, -0.12922058f, -0.10805406f, -0.43330124f, 0.06433894f, 0.23116501f, 
    0.04971813f, 0.04005992f, 0.09751980f, -0.00185929f, 0.02378226f, -0.01852925f, -0.02778713f, 0.02010239f, 
    0.11683533f, -0.05897179f, 0.08007941f, 0.03608127f, -0.18454728f, 0.17620754f, -0.36389276f, 0.05144368f, 
    -0.00905508f, -0.03981239f, -0.01608750f, -0.07767566f, 0.11488140f, 0.05382996f, -0.01709730f, 0.01808727f, 
    -0.52488893f, 0.66123545f, -0.31069565f, 0.19875214f, 0.20253724f, -0.05662121f, 0.10142335f, -0.24422993f, 
    0.01018141f, -0.04883547f, 0.08160901f, 0.07234174f, -0.53449541f, -0.40310872f, 0.01957775f, 0.68595821f, 
    0.11163217f, -0.22216506f, 0.04576383f, 0.17467326f, -0.03815423f, -0.06836814f, -0.17149267f, -0.06424153f, 
    0.11863817f, -0.07694728f, -0.05739344f, 0.03168881f, -0.03129791f, -0.10649920f, -0.06865483f, -0.07721347f, 
    -0.10045063f, -0.16557664f, 0.18623465f, 0.02435191f, 0.16700010f, 0.10634647f, 0.03373223f, -0.02270805f, 
    0.00635679f, 0.00828295f, -0.03639850f, -0.04494487f, 0.11903733f, 0.06319098f, 0.05150697f, 0.17288797f, 
    -0.67896587f, -0.44990000f, -0.40922499f, 0.43378109f, 0.22678840f, -0.01763166f, 0.04937302f, -0.06397225f, 
    0.07572310f, 0.03214463f, 0.00853708f, -0.02560025f, -1.06976175f, 0.28878826f, 0.06867528f, 0.07564624f, 
    -0.14527723f, -0.14188448f, -0.33251545f, 0.02542652f, 0.06952065f, -0.04143427f, 0.01452735f, -0.00900153f, 
    0.13600200f, -0.05029793f, 0.02076281f, -0.17158853f, 0.07673045f, 0.07442023f, 0.05173967f, -0.01726236f, 
    -0.16807488f, -0.08272397f, -0.14305446f, -0.29504248f, 0.30768374f, -0.05441187f, -0.06011532f, -0.10218460f, 
    -0.13891053f, -0.09270369f, 0.05265307f, -0.02570225f, -0.01591202f, 0.11850154f, 0.11084547f, 0.04928826f, 
    0.10171165f, -0.17489395f, -0.15977556f, -0.08057207f, 0.01882583f, -0.02996095f, 0.06338789f, -0.07887051f, 
    -0.00438490f, 0.04368741f, -0.17948961f, -0.24579485f, 0.12316087f, -0.44502085f, -0.26231566f, -0.22636154f, 
    -0.05139025f, -0.08852011f, -0.03960726f, 0.05762976f, 0.18703373f, -0.05563159f, -0.08554625f, -0.11352568f, 
    -0.23300032f, -0.04252615f, 0.17725039f, 0.14839979f, -0.21828519f, 0.01154971f, 0.03258282f, -0.05945404f, 
    -0.08923516f, 0.04704733f, -0.00920488f, 0.11571907f, 0.06985735f, 0.10161614f, -0.05661032f, 0.11933286f, 
    0.03758341f, -0.13413790f, 0.02366972f, -0.04674263f, 0.11256217f, 0.09611870f, -0.00165920f, 0.37918106f, 
    -0.55798090f, 0.23301744f, 0.15337977f, 0.20424303f, 0.05020306f, -0.10096838f, -0.17439140f, 0.08510976f, 
    0.04525988f, 0.02168155f, -0.00025153f, 0.11756556f, -0.33693236f, 0.13333796f, 0.04971440f, -0.07312515f, 
    -0.21816549f, -0.13270843f, -0.12100957f, -0.27986863f, -0.11164168f, 0.06604358f, 0.01141990f, 0.08796336f, 
    0.30560490f, 0.14069000f, -0.03238074f, -0.06828657f, 0.12732597f, -0.08277726f, 0.01771025f, 0.12218715f, 
    0.25120372f, -0.06007500f, 0.24726665f, 0.26061279f, -0.25566003f, -0.59768230f, -0.79540128f, -0.63330364f, 
    0.09256101f, 0.07312816f, 0.07802936f, 0.11741509f, 0.05376431f, -0.11667119f, -0.10125919f, -0.02798930f, 
    0.77507615f, 0.80184180f, -0.32843077f, -0.24713995f, 0.29428244f, -0.27480018f, 0.19255878f, -0.11022834f, 
    0.08831358f, 0.26920238f, 0.12041277f, 0.07141238f, 0.05759614f, 0.06272474f, -0.09576855f, 0.10031874f, 
    0.10450651f, -0.12553480f, 0.12136617f, 0.11120724f, -0.18744336f, 0.12691194f, -0.29964572f, -0.16050039f, 
    0.42253003f, -0.41253567f, -1.12793505f, -0.57519746f, 0.02291506f, 0.27033290f, 0.22070844f, 0.13304579f, 
    0.06114874f, -0.07412402f, -0.06927960f, 0.09997547f, -0.35219550f, -0.08258786f, -0.07768394f, -0.16394056f, 
    -0.07494840f, 0.01818879f, -0.06198712f, 0.15558501f, 0.01811267f, 0.17773087f, 0.07402049f, 0.10399873f, 
    0.65098667f, 0.24517049f, 0.03299050f, -0.24276415f, -0.02487143f, -0.05188984f, 0.07790347f, -0.09296285f, 
    -0.08170897f, 0.02320366f, 0.05762321f, 0.03683539f, -0.00807043f, -0.33276519f, -0.20127933f, -0.22726819f, 
    -0.13269950f, 0.00359615f, 0.00353219f, -0.00268362f, 0.20146720f, -0.01271605f, -0.14635521f, -0.19792446f, 
    -0.30317152f, -0.40193388f, 0.53583533f, 0.73016673f, -0.05656048f, 0.18307833f, -0.00358196f, 0.03696785f, 
    -0.01341869f, 0.22168466f, -0.04061116f, 0.12875822f, 0.40502372f, -0.34735176f, 0.04623631f, 0.19214740f, 
    0.10214416f, 0.08510158f, 0.01174767f, 0.22205834f, -0.21621266f, -0.18855815f, -0.00885727f, -0.52945155f, 
    -0.52848983f, -0.57639772f, -0.69020241f, -0.06936458f, 0.04019980f, 0.09462047f, 0.20149198f, 0.25784835f, 
    0.15691759f, 0.00371756f, -0.07035032f, -0.08050290f, 0.13971429f, -0.11757088f, 0.10699935f, -0.37334082f, 
    -0.18515325f, -0.06546303f, -0.06833387f, -0.10605561f, 0.04116554f, -0.24351260f, 0.16183208f, 0.09873766f, 
    0.12331018f, -0.15528366f, -0.11904080f, 0.01111182f, 0.01927733f, 0.00235588f, 0.22245288f, 0.15974374f, 
    0.01968192f, 0.00378801f, 0.04269774f, 0.04568340f, 0.19434021f, -0.20587175f, -0.46491411f, -0.22144955f, 
    -0.00610096f, 0.14522845f, 0.10015114f, 0.05664392f, 0.17671718f, -0.02689492f, 0.10601902f, 0.02049593f, 
    -0.40122396f, 0.02982486f, 0.02258407f, 0.14517289f, 0.08283613f, 0.14138602f, 0.05845248f, 0.18070009f, 
    0.09131424f, 0.03197306f, 0.02380721f, 0.15332386f, -0.43690598f, -0.08208825f, 0.08889398f, 0.07782888f, 
    -0.08667789f, 0.01197353f, -0.12930287f, -0.19041222f, -0.26833948f, 0.00773771f, -0.23563266f, 0.11973325f, 
    -0.31783605f, 0.16006194f, 0.11796619f, -0.11013433f, -0.08507320f, -0.14846930f, 0.01737841f, -0.00433030f, 
    -0.00271877f, 0.03400344f, -0.00505436f, 0.05663455f, -0.77295667f, 0.43907812f, 0.34227395f, 0.03936287f, 
    0.04617514f, -0.05706830f, -0.19806251f, -0.06170676f, -0.31743431f, -0.13272187f, -0.09474443f, 0.08168382f, 
    0.13697284f, -0.07795780f, 0.11727782f, 0.14496955f, 0.01437621f, 0.07231111f, -0.07272322f, -0.07377105f, 
    0.00521198f, -0.05961816f, -0.21503031f, -0.04846457f, 0.14309901f, -0.38989154f, -0.58740598f, -0.61770320f, 
    0.03362867f, -0.08748772f, -0.02915058f, -0.11702555f, 0.01564601f, 0.04389038f, 0.00046641f, -0.00298942f, 
    0.14313601f, -0.07637382f, 0.25868887f, -0.12558615f, -0.07067625f, -0.02559838f, -0.00392185f, 0.10599562f, 
    -0.11220177f, 0.05138763f, -0.12098581f, -0.02879576f, -0.15573873f, -0.00982756f, -0.06251329f, -0.06997189f, 
    0.07375202f, -0.04930654f, -0.05769291f, 0.02918772f, -0.31239402f, -0.05728136f, -0.25963998f, -0.61634296f, 
    -0.22360303f, -0.57805324f, -0.48034981f, 0.32011613f, -0.01118189f, 0.02625698f, -0.00395876f, -0.08607320f, 
    -0.09527543f, 0.08162377f, 0.06083300f, 0.10115703f, -0.02796740f, 0.03071143f, 0.00999545f, -0.25883070f, 
    -0.01084905f, -0.00055851f, -0.10875434f, 0.07603130f, 0.04501640f, 0.12006920f, 0.00479662f, -0.02203208f, 
    -0.26260805f, -0.16559008f, 0.24643150f, -0.18355656f, -0.04749572f, -0.10545361f, 0.09420291f, -0.07137653f, 
    0.06272870f, 0.19228821f, 0.08381949f, 0.10157821f, -0.07359785f, -0.34734452f, -0.15755899f, -0.20379005f, 
    -0.04096237f, 0.23468816f, 0.00004667f, 0.22296609f, 0.00878582f, 0.02483230f, -0.11379506f, 0.05546604f, 
    0.13819721f, 0.01131058f, -0.01733872f, -0.40223715f, -0.09810279f, -0.10100305f, 0.05306222f, -0.15044756f, 
    0.09275583f, 0.13131958f, 0.05420969f, 0.10226749f, -0.03289793f, -0.13855842f, 0.01010694f, 0.15011141f, 
    0.22238213f, 0.14177464f, 0.04393472f, 0.10698449f, -0.28739864f, -0.23851430f, -0.16260056f, -0.74856704f, 
    -0.11746052f, -0.48811758f, 0.35657334f, -0.59819549f, 0.15637156f, 0.10065533f, 0.12998882f, 0.14659829f, 
    0.09590083f, 0.03514025f, 0.06381258f, 0.05247266f, 0.06088944f, -0.20633639f, 0.24875109f, 0.25717735f, 
    -0.03023332f, 0.02942136f, -0.08021694f, -0.18300642f, 0.16729572f, 0.18287769f, -0.15327674f, -0.18085219f, 
    -0.24508570f, -0.31074613f, -0.70931017f, 0.27655733f, 0.04530043f, 0.18994671f, 0.13993496f, 0.12300348f, 
    -0.02797460f, 0.01725067f, -0.07988629f, -0.15936346f, 0.15972054f, -0.35549149f, 0.09186970f, -0.19673693f, 
    -0.00119660f, 0.10441868f, -0.16849981f, 0.17867988f, 0.00191570f, -0.03594559f, -0.19133420f, 0.08133352f, 
    0.02041207f, -0.20165400f, 0.26142102f, -0.35630679f, 0.07874530f, -0.24369815f, -0.06363109f, 0.01226500f, 
    -0.05649217f, -0.21698757f, 0.08471973f, -0.25602508f, -0.52344406f, -0.01158176f, 0.21893448f, 0.00433459f, 
    0.08617641f, -0.00744126f, 0.01303836f, 0.22741225f, 0.03523787f, -0.02793817f, 0.04192195f, -0.00221495f, 
    -0.45066103f, -0.38058838f, 0.15258312f, -0.14336507f, -0.07977665f, -0.03257624f, -0.01648137f, -0.19918080f, 
    0.10419251f, 0.06811880f, -0.00654159f, -0.21798833f, -0.21694046f, 0.29847601f, -0.30802286f, 0.37651929f, 
    -0.43918782f, 0.01877302f, -0.03315533f, -0.12567486f, 0.05443203f, -0.02316182f, -0.00870245f, -0.11613955f, 
    -0.72798824f, 0.42609230f, -0.44444948f, 0.76431894f, 0.02582178f, 0.05184026f, -0.54514194f, 0.30054784f, 
    0.12296032f, -0.20001599f, 0.06373647f, 0.17179388f, -0.26912177f, 0.05639663f, -0.01470028f, -0.21852420f, 
    -0.14647730f, 0.26204070f, -0.11498685f, -0.19916897f, 0.10928131f, -0.13143516f, -0.04303117f, -0.13917582f, 
    -0.02518506f, -0.42741612f, -0.33488688f, 0.21799651f, -0.05046675f, 0.33908430f, 0.10165638f, -0.12942177f, 
    0.05626037f, -0.06763642f, -0.02179992f, -0.04178081f, 0.19845517f, 0.10729773f, 0.32960665f, 0.36992273f, 
    0.13184772f, -0.29347390f, -0.21061030f, -0.14551973f, 0.03126442f, 0.06152500f, -0.05625962f, 0.14415070f, 
    0.02059287f, -0.11856566f, 0.13114694f, -1.13183618f, -0.05699338f, -0.07918198f, 0.00846684f, -0.03538376f, 
    -0.05698544f, 0.01326479f, 0.02160308f, 0.01664098f, 0.06946332f, 0.27445972f, 0.05405986f, 0.02183455f, 
    -0.20651463f, -0.08516108f, -0.01040011f, 0.04686724f, 0.05942913f, 0.07742553f, 0.18015078f, 0.09475587f, 
    -0.46336946f, -0.07201929f, -0.69105870f, 0.00011156f, -0.38878414f, -0.07906140f, -0.23439994f, -0.12088448f, 
    0.16606267f, -0.11645454f, -0.00209208f, -0.00604647f, -0.13919428f, -0.48864868f, 0.36335102f, 0.15713219f, 
    0.02726700f, 0.12259395f, -0.23895587f, -0.02263178f, -0.25999260f, 0.01467173f, 0.09001081f, -0.02613869f, 
    0.49005347f, 0.11998822f, 0.04256975f, 0.12091114f, -0.00355502f, -0.12741436f, -0.14934623f, -0.05234904f, 
    0.16741988f, 0.01745191f, 0.00470797f, 0.12962723f, -0.17485631f, 0.51559335f, 0.51920897f, 0.26810214f, 
    -0.08113933f, -0.18141857f, -0.23046352f, -0.35631707f, 0.01179443f, -0.06247057f, -0.06378540f, -0.02671426f, 
    -0.37030330f, 0.29244524f, -0.18436219f, -0.35788491f, 0.02655075f, -0.24092409f, 0.01029571f, -0.02351960f, 
    -0.03380292f, 0.08907796f, -0.14232278f, 0.18038137f, 0.07489137f, -0.27104220f, 0.11968818f, -0.30528754f, 
    0.07480763f, 0.08981574f, 0.11701602f, -0.04483517f, 0.17162144f, 0.04973447f, -0.04834443f, 0.09839319f, 
    -0.04407711f, -0.22065698f, -0.26343340f, -0.05222727f, 0.16854887f, 0.15631297f, 0.29700261f, 0.01555499f, 
    0.12322588f, -0.00855940f, 0.02632567f, 0.05600761f, -0.59500408f, 0.14406396f, -0.50764596f, 0.10076800f, 
    0.27748314f, -0.01094552f, 0.19004826f, 0.01858151f, 0.16903208f, -0.02008879f, -0.07952699f, 0.08845048f, 
    -0.52348047f, -0.20355101f, -0.53924191f, -0.34102973f, 0.20554543f, -0.32825097f, 0.17371434f, -0.04493321f, 
    0.05293095f, 0.03180785f, -0.01726843f, 0.07811042f, -0.31434333f, 0.10506763f, 0.02909857f, -0.01156880f, 
    -0.13099185f, -0.19027203f, 0.03726377f, 0.28403497f, 0.07847219f, 0.08303429f, 0.17366190f, -0.01976236f, 
    0.20079963f, -0.03333664f, 0.14126346f, 0.34722918f, 0.06535845f, -0.07391699f, -0.04605487f, 0.11113178f, 
    -0.09421791f, -0.09091962f, 0.12683484f, 0.18737891f, -0.20189723f, 0.11752043f, -0.03523248f, 0.12537682f, 
    0.02971667f, 0.04400893f, 0.10478532f, -0.00714441f, 0.11767241f, 0.04999939f, 0.09269462f, 0.27632308f, 
    -0.23450574f, 0.20329042f, -0.03206354f, -0.20924757f, 0.12220313f, -0.35954115f, 0.05312026f, 0.22002293f, 
    -0.01070139f, -0.11808867f, -0.03392031f, -0.01932182f, 0.48782903f, -0.15890938f, -0.28143814f, -0.16425127f, 
    -0.12996441f, 0.12588079f, -0.00098473f, -0.02072629f, 0.11434679f, -0.12222899f, -0.12979065f, -0.07126321f, 
    0.23753759f, 0.05657448f, 0.45152009f, -0.03545181f, 0.06483815f, -0.25068060f, 0.05108520f, -0.06454688f, 
    -0.16519368f, 0.05822603f, 0.01787025f, -0.03380615f, 0.23122193f, -0.15064628f, 0.20386253f, 0.28131187f, 
    0.22016971f, -0.06203746f, -0.15373416f, -0.19179559f, 0.01445825f, 0.02220598f, -0.12345516f, -0.03528613f, 
    -0.04143182f, -0.00152084f, 0.16438153f, 0.29982167f, 0.13992141f, 0.00033073f, 0.01813355f, 0.00284184f, 
    -0.04335150f, 0.06458621f, -0.09460589f, 0.09770046f, 0.00537566f, 0.16930887f, 0.27282679f, -0.08007731f, 
    -0.15796895f, -0.09372731f, 0.04415154f, -0.17303620f, 0.07221656f, -0.05127520f, 0.03370985f, 0.25832158f, 
    -0.12663864f, 0.18904723f, 0.24674113f, 0.24743612f, -0.04238559f, 0.10398111f, -0.08202026f, 0.01864113f, 
    -0.01750439f, -0.12468101f, -0.10398604f, 0.10779854f, -0.28298387f, 0.15417144f, 0.08073460f, -0.17708212f, 
    -0.12229628f, 0.20117229f, -0.07146872f, -0.02587242f, 0.19542146f, -0.40274453f, 0.27400687f, 0.14999568f, 
    0.19485576f, 0.27768838f, 0.39484641f, -0.01153535f, -0.09725478f, -0.15509260f, 0.03930663f, 0.12505300f, 
    0.01985325f, 0.09408879f, 0.18158713f, 0.11741553f, 0.02804966f, -0.75871474f, 0.30163890f, -0.18301322f, 
    -0.25709552f, 0.55481648f, -0.10027312f, -0.04240926f, -0.08576785f, 0.03677304f, -0.06146638f, -0.03566414f, 
    -0.34339643f, 0.39395225f, -0.19357777f, 0.19367445f, -0.07835450f, -0.01708897f, 0.21200529f, 0.25187975f, 
    -0.08145123f, 0.10299993f, 0.30233011f, 0.09634425f, 0.06378538f, -0.34347755f, -0.18337105f, 0.13830049f, 
    -0.16147277f, -0.08120874f, -0.15440862f, 0.33396736f, 0.09713915f, 0.11135071f, -0.06068586f, -0.16040082f, 
    0.01077569f, -0.34078541f, -0.75218379f, 0.54713297f, -0.08657105f, 0.30481371f, 0.28059423f, 0.12095344f, 
    0.11810432f, -0.04102303f, 0.05912038f, 0.07238854f, 0.68792427f, 0.13556315f, 0.17482381f, -0.31506911f, 
    0.00977531f, -0.07752817f, 0.15989137f, 0.16301563f, -0.29513404f, 0.02510067f, -0.36160836f, 0.05371111f, 
    0.03608689f, 0.08551273f, -0.07216813f, 0.10521942f, 0.01306147f, 0.08335861f, -0.32055956f, 0.25088090f, 
    -0.15113324f, 0.03914489f, -0.00614619f, 0.09697551f, 0.42799532f, -0.05074941f, 0.12554282f, -0.04748365f, 
    -0.22851525f, 0.21498419f, 0.20750542f, 0.09562688f, 0.11344745f, 0.14801143f, 0.16708258f, 0.11236229f, 
    -0.30501938f, 0.03132221f, -0.22320995f, -0.14746803f, -0.23405033f, -0.09969845f, 0.20821302f, 0.01411643f, 
    -0.00539685f, 0.18464120f, -0.15641062f, 0.14789824f, -0.01152313f, 0.03995543f, -0.04097756f, -0.33812496f, 
    0.06277631f, -0.11846472f, -0.08985654f, 0.07264392f, -0.07630298f, -0.15847003f, -0.08869901f, -0.08017917f, 
    0.31381640f, -0.55802578f, 0.22058198f, 0.31675479f, -0.00187566f, -0.14595225f, -0.09060097f, -0.00787299f, 
    -0.03608603f, 0.09118330f, -0.81980360f, -0.19891262f, -0.10325505f, 0.08015760f, -0.19325353f, -0.22552568f, 
    0.04235667f, -0.21179500f, -0.07899210f, 0.06157809f, -0.05282229f, -0.14617117f, -0.42509544f, -0.59095615f, 
    0.28347427f, 0.15752760f, 0.37191612f, 0.06567135f, 0.27223128f, -0.16953334f, -0.01569839f, 0.01618938f, 
    -0.28181788f, 0.04678763f, -0.22749853f, -0.01102432f, -0.64661813f, 0.38932368f, -0.14602637f, -0.07518905f, 
    -0.00125049f, 0.16091888f, -0.22049420f, -0.04871485f, 0.03836103f, 0.03631627f, -0.08503813f, 0.07723550f, 
    -0.59519404f, 0.28890616f, 0.00554487f, -0.00525939f, 0.00732045f, -0.04291641f, -0.01868061f, 0.28093785f, 
    -0.13321745f, 0.16543023f, -0.00348717f, -0.17156021f, 0.25620794f, -0.04289036f, 0.36691058f, -0.56645131f, 
    -0.19047965f, -0.09897245f, 0.20173496f, 0.12863022f, -0.06400890f, -0.03423243f, -0.03762404f, -0.17507729f, 
    -0.01246986f, 0.11540183f, 0.29005283f, 0.40357143f, -0.10832751f, 0.00592808f, 0.38129339f, -0.07680990f, 
    0.00647310f, 0.12403935f, 0.07131567f, 0.15923733f, -0.35233226f, 0.43928865f, -0.02040680f, 0.24623598f, 
    -0.07751284f, -0.14309263f, -0.18219407f, 0.09744922f, -0.18840253f, -0.22454002f, -0.02598536f, -0.16247135f, 
    0.02948439f, -0.50787115f, -0.79163724f, -0.61049312f, -0.40789622f, -0.14113039f, -0.02730377f, 0.06519096f, 
    -0.10859478f, 0.05676628f, 0.01979626f, -0.10778662f, 0.01786896f, -0.27211550f, 0.26407319f, 0.24302320f, 
    -0.18611203f, -0.47454885f, 0.21471417f, 0.04674711f, -0.30353719f, -0.06718585f, -0.06106256f, 0.00576707f, 
    0.25360879f, 0.25110638f, 0.17114386f, 0.04039882f, -0.25172222f, 0.32199383f, 0.18304941f, 0.06392910f, 
    -0.04267053f, -0.19682162f, -0.00173604f, 0.04787440f, -0.22065951f, -0.38980660f, -0.31416410f, -0.00598133f, 
    -0.03877158f, 0.14738481f, -0.09170635f, 0.05494967f, 0.02958865f, 0.08588310f, 0.02430492f, 0.01070824f, 
    -0.38479787f, 0.10540741f, 0.02535042f, -0.12330731f, -0.04534395f, 0.00436107f, -0.02357620f, 0.00880822f, 
    -0.08399377f, 0.26525754f, -0.18987171f, -0.09272519f, 0.20883474f, 0.02063442f, 0.13282885f, 0.00585341f, 
    0.06958804f, -0.04752569f, 0.01101112f, -0.04382719f, -0.06615376f, -0.16235681f, -0.63937980f, -0.59125614f, 
    -0.26946145f, -0.13673171f, 0.16523449f, 0.11714370f, -0.19811103f, 0.04327397f, -0.08723131f, 0.03932580f, 
    -0.04893572f, 0.05582607f, 0.13099729f, 0.13878781f, -0.41857049f, -0.12698784f, -0.17996517f, 0.14258592f, 
    0.00340294f, 0.07357057f, 0.06887772f, -0.15968640f, -0.01699842f, 0.17608126f, 0.01946660f, -0.00367479f, 
    0.24471559f, 0.24103481f, -0.36781755f, 0.19705719f, -0.15132691f, -0.01760667f, 0.16147263f, -0.10356527f, 
    -0.00705611f, -0.03662531f, 0.12643628f, -0.01805504f, -0.24645768f, 0.19404233f, -0.16534276f, 0.20332061f, 
    0.02620565f, -0.15973221f, -0.01534079f, -0.16140182f, 0.03691564f, 0.17301431f, -0.06785238f, 0.29873019f, 
    -0.30927649f, 0.01702272f, 0.05619100f, -0.15590453f, -0.20525648f, 0.04491736f, -0.14242835f, 0.12278330f, 
    0.14140277f, -0.01956170f, 0.02312787f, 0.27752241f, -0.09468545f, 0.18990190f, 0.07340717f, -0.12687375f, 
    0.05545787f, -0.21492910f, 0.02661531f, 0.03852018f, 0.08154093f, -0.12256974f, -0.33055583f, -0.45681801f, 
    -0.23351690f, 0.19340271f, -0.20517495f, 0.06757177f, -0.10194250f, 0.29075441f, -0.13556945f, 0.03492184f, 
    0.03694847f, 0.17582881f, 0.10151422f, -0.01076952f, -0.15114947f, 0.24528778f, -0.22460504f, -0.01884607f, 
    -0.00315457f, -0.02591585f, 0.12039336f, 0.02147488f, 0.09888120f, 0.05863224f, 0.21097569f, -0.25663450f, 
    0.13348487f, 0.00716026f, 0.38032258f, 0.24066338f, -0.22294515f, -0.00518190f, -0.03954035f, -0.08408803f, 
    -0.25291210f, -0.09265442f, -0.01451701f, -0.09678914f, -0.40190995f, 0.51751280f, 0.15534429f, -0.08505818f, 
    0.01929331f, -0.22427507f, 0.35316652f, -0.00564014f, -0.02897716f, -0.10308803f, 0.00044209f, 0.08416703f, 
    0.39945352f, 0.00154733f, 0.06083497f, 0.13252853f, -0.00627837f, 0.12449965f, -0.02601991f, -0.00511985f, 
    -0.09396917f, -0.06476329f, 0.06767669f, -0.15602757f, -0.37720457f, -0.31221285f, -0.07106560f, 0.01107173f, 
    -0.22563326f, 0.07088588f, -0.34644437f, -0.08240403f, -0.00900219f, 0.09785396f, 0.05000605f, -0.00157853f, 
    -0.61147809f, -0.42373988f, 0.22840326f, 0.10710946f, -0.11439671f, 0.24550796f, -0.45412144f, 0.11613265f, 
    0.07135741f, 0.01493206f, 0.30710489f, -0.01825490f, -0.15077011f, -0.28132641f, 0.37435448f, 0.30422276f, 
    -0.02153837f, 0.16931377f, 0.30167311f, -0.09073500f, -0.00133068f, 0.08451102f, 0.24211122f, 0.20271316f, 
    -0.55500853f, -0.30929002f, 0.53641170f, 0.25906023f, 0.13196936f, 0.12336552f, -0.11283682f, -0.17446823f, 
    0.05844706f, -0.13682145f, 0.09499058f, -0.06948148f, -0.25779369f, 0.01113024f, -0.10203903f, 0.09524828f, 
    0.13517596f, 0.03134436f, 0.11051702f, 0.00318150f, -0.00681696f, -0.11127367f, -0.15604992f, -0.01279192f, 
    0.23636347f, 0.27993569f, 0.04554145f, -0.11846325f, -0.01141264f, 0.00336822f, 0.03133414f, -0.04213906f, 
    -0.02131234f, 0.00211012f, -0.03226709f, -0.03873066f, -0.12105668f, -0.10960123f, -0.40537688f, -0.11578041f, 
    0.05704949f, 0.15764427f, -0.09215546f, -0.00302500f, 0.04952810f, 0.15547821f, 0.24591364f, 0.02213314f, 
    -0.68144202f, 0.01874576f, -0.17813860f, -0.12453454f, -0.08481739f, 0.19532117f, 0.00042032f, 0.18787497f, 
    -0.22672398f, 0.04226000f, 0.10842114f, 0.12884971f, -0.25264132f, -0.12423535f, 0.08095199f, -0.43808368f, 
    -0.17476551f, -0.18276016f, 0.04298806f, 0.03323329f, -0.03326184f, -0.00277804f, -0.06356452f, 0.09941750f, 
    -0.54715341f, 0.35323581f, -0.64948434f, 0.36812985f, 0.06114653f, -0.33473438f, 0.15786152f, -0.11128166f, 
    0.05470733f, -0.03420857f, 0.11371075f, 0.11194041f, -0.74895865f, 0.39089644f, -0.72892863f, 0.14428915f, 
    0.15136752f, -0.15608418f, 0.14788753f, -0.00273946f, -0.05375940f, 0.01742930f, 0.04812714f, 0.18506895f, 
    -0.11428589f, 0.00507957f, -0.00995233f, 0.19272836f, 0.13613677f, -0.03236759f, 0.11300948f, -0.02472091f, 
    0.01084583f, -0.03276579f, -0.15738040f, -0.09097337f, -0.15995614f, -0.29624468f, -0.03066023f, -0.53223729f, 
    0.07335606f, 0.12302630f, -0.06648859f, 0.01588226f, -0.01016029f, 0.02354492f, 0.05645893f, -0.26406038f, 
    0.31253216f, 0.07816579f, 0.33002672f, 0.07483575f, 0.12896314f, 0.04234011f, -0.06115473f, 0.23209731f, 
    -0.06613964f, -0.04921203f, -0.06743812f, -0.16805460f, -0.22751570f, 0.27862442f, -0.29993340f, 0.24174526f, 
    -0.09785095f, -0.03067054f, 0.17845447f, 0.23734824f, -0.15432039f, 0.06276288f, -0.05034640f, -0.16969711f, 
    0.52091622f, 0.35096908f, -0.06590320f, -0.29566005f, -0.10025344f, 0.16288185f, -0.04505344f, 0.11092196f, 
    -0.19686627f, 0.06274547f, -0.10427865f, -0.10178313f, 0.55460781f, -0.10277972f, 0.36172512f, -0.15834638f, 
    -0.09915617f, 0.11802546f, -0.28928384f, 0.12967619f, -0.16453969f, -0.01679172f, 0.06225925f, -0.02150386f, 
    0.16317649f, 0.02849643f, 0.63799071f, -0.36873278f, -0.38049769f, 0.16442817f, -0.32671082f, 0.10321220f, 
    0.04691847f, 0.16422835f, -0.04394684f, -0.05912765f, -0.27104914f, -0.53746128f, -0.10080673f, -0.00082019f, 
    -0.20286934f, -0.19343470f, 0.04948813f, -0.29039857f, 0.03450533f, 0.08653420f, 0.06439289f, -0.08114477f, 
    -0.00530066f, 0.27685457f, -0.50862938f, 0.34425744f, 0.07552867f, -0.09418723f, 0.08225533f, 0.08403212f, 
    -0.05609772f, 0.11646273f, 0.07485047f, 0.07007869f, 0.11754593f, -0.04428876f, 0.06115482f, -0.17264326f, 
    0.14917901f, -0.00659187f, 0.07181768f, 0.00667947f, 0.21594909f, 0.02117144f, 0.13295645f, -0.05300039f, 
    0.27077651f, -0.27043080f, 0.19474611f, -0.33195698f, -0.10276364f, -0.12264018f, -0.38490310f, -0.03188398f, 
    -0.03630546f, -0.05420660f, -0.19861750f, -0.22034556f, 0.60585070f, 0.29102454f, 0.17448162f, -0.12735248f, 
    0.13015756f, -0.04376333f, -0.17332110f, 0.01117733f, 0.00392801f, 0.07002797f, 0.20053126f, 0.04293246f, 
    -0.55166596f, -0.10365477f, -0.07481829f, 0.35420328f, -0.14549388f, 0.23476510f, -0.10703616f, 0.17444324f, 
    -0.10529392f, -0.02255431f, 0.04036470f, 0.07959257f, -0.59306908f, 0.11439060f, -0.51988351f, 0.37071699f, 
    -0.02057950f, 0.05756475f, 0.01329546f, 0.07377274f, -0.10589203f, -0.16031268f, 0.11623047f, -0.23778668f, 
    -0.04622136f, -0.11155032f, -0.23301367f, 0.02942615f, 0.12791033f, 0.01294084f, -0.02209963f, 0.03551125f, 
    0.07995479f, -0.09820710f, -0.01450133f, 0.10689033f, 0.08095652f, 0.13922146f, -0.09756622f, -0.33242086f, 
    -0.04949388f, -0.10546313f, 0.10589406f, 0.05475510f, 0.05261559f, 0.12519866f, 0.08786461f, -0.06386626f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15718774f, 0.09690582f, 0.09120268f, -0.15975368f, -0.09545663f, 0.08367220f, 0.01378331f, -0.14498597f, 
    0.11556394f, 0.04169739f, 0.02331095f, -0.07149273f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
