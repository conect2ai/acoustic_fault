#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57718122f, -0.47758639f, 0.96652466f, 0.54621768f, -0.25768682f, 0.05023582f, 0.27368879f, 0.15967149f, 
    0.37401482f, 0.77805758f, 0.48742068f, 0.37028539f, -0.61035341f, 0.45165354f, 0.17131224f, -0.40331155f, 
    -0.85041761f, -0.66394717f, -1.40403330f, -0.96443224f, 0.06554309f, 1.59092510f, 1.16324043f, -0.59049702f, 
    0.17890427f, -0.05056269f, -0.05349251f, 0.62280285f, 0.77662277f, -1.05515099f, 0.22120887f, 0.35713655f, 
    -0.16371508f, -0.08605957f, -0.42368564f, 0.44725940f, 0.46201876f, 0.42690921f, 0.09579499f, 0.69280124f, 
    1.05634952f, 0.39525661f, -0.26467294f, 0.00428470f, -0.36926258f, -0.46536025f, -1.27807617f, -0.38981974f, 
    0.00495059f, -0.76995462f, -0.11788618f, 0.65742660f, 0.93095374f, 0.27421394f, -0.80449140f, 0.65718573f, 
    0.67945677f, -0.45263302f, 0.50800347f, 0.97921026f, 0.11586925f, 0.32298613f, -0.26405299f, -0.76614928f, 
    -0.96019912f, -1.08762920f, 0.10772563f, 0.53389895f, 0.41905832f, 0.52226132f, 0.63700140f, 0.41603714f, 
    -0.93557894f, -0.10575517f, 0.56913298f, -0.08090946f, 0.34049603f, 0.06666160f, -0.15776423f, -0.00910722f, 
    0.50818670f, 0.21219231f, -1.11770332f, -1.74792969f, 0.39071536f, 0.23990823f, 0.52512217f, -0.77250433f, 
    -0.47314730f, -0.66237587f, -1.09788299f, 0.22084017f, 1.09421921f, 0.32088703f, -0.47072059f, 0.39448845f, 
    -0.12390722f, -0.49667951f, 0.53978652f, -0.33561039f, 0.25830230f, -1.07165229f, -1.46452558f, -1.51077068f, 
    -0.91439301f, -0.16675469f, -1.05475819f, -0.76593435f, 1.16608739f, 0.43589744f, 0.12151124f, -0.32470214f, 
    0.64182562f, -0.63338178f, -0.49732304f, 0.46980831f, -0.32214144f, -1.18334138f, -1.39359879f, -0.75585055f, 
    -1.51717365f, -0.53910381f, 0.84394640f, 0.18150969f, 0.10046151f, -0.30809850f, -1.46102750f, 1.45551789f, 
    1.14802349f, -1.05114567f, -0.53027368f, -0.09505011f, -0.59522146f, -0.07670309f, -0.50822383f, 1.15799177f, 
    -0.93118495f, 0.94885480f, -0.18453962f, -0.39717925f, -0.58211190f, 0.65237981f, -0.33193162f, 0.20905587f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10618668f, 0.30851254f, 0.39263722f, 0.51315808f, -0.30249017f, 0.77285826f, 0.22891577f, 0.22693786f, 
    0.48770073f, -0.21314664f, 0.53730941f, -0.13805738f, 0.62352288f, 0.46895826f, 0.26882398f, 0.14563514f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10275643f, -0.02660347f, 0.23400344f, -0.11816081f, 0.11036178f, -0.04537579f, 0.00984889f, 0.06414054f, 
    -0.03476206f, 0.01146529f, 0.14492737f, -0.21552250f, -0.25228563f, -0.11540725f, -0.10046069f, -0.04393987f, 
    0.02330118f, -0.02571733f, -0.02973546f, 0.00019702f, -0.43460390f, 0.20930785f, 0.34209132f, 0.19133994f, 
    0.18634269f, 0.06147073f, -0.00779787f, -0.11268934f, 0.04216811f, 0.02475226f, 0.02597544f, -0.03300717f, 
    0.02881569f, 0.08481571f, 0.10622879f, 0.14439262f, -0.00692798f, 0.07556208f, 0.06933098f, -0.12968853f, 
    0.72123390f, -0.03111048f, -0.89187384f, -0.13109779f, 0.02600369f, 0.00868062f, 0.07479973f, 0.04434631f, 
    0.02445827f, 0.13109288f, -0.08226898f, -0.02768072f, -0.08883481f, 0.07997994f, 0.04972018f, -0.01501159f, 
    0.05222236f, 0.11135054f, -0.06224784f, -0.04267409f, -0.99166733f, -0.51515424f, -0.34651434f, 0.33872527f, 
    -0.13458174f, 0.00600764f, -0.06511539f, -0.09868049f, 0.04073553f, -0.02910887f, 0.00555346f, -0.15077558f, 
    -0.32259083f, 0.02137669f, 0.07226074f, -0.08603527f, -0.00004492f, -0.24015936f, -0.04950730f, -0.15744239f, 
    -0.05966590f, -0.13781179f, -0.20867603f, -0.02369431f, 0.00676437f, 0.04809524f, 0.04467714f, 0.07774234f, 
    0.14292234f, 0.13227268f, 0.14013575f, -0.09246702f, 0.10706064f, 0.05465847f, 0.02591150f, -0.20618269f, 
    -0.05986220f, 0.16343233f, -0.01395569f, 0.06776349f, 0.47653395f, 0.34148046f, 0.02074566f, -0.37689081f, 
    -0.03744735f, 0.17617686f, 0.09266432f, 0.17432934f, -0.28249851f, -0.01494770f, 0.05615940f, 0.02143917f, 
    0.01386990f, -0.00987325f, 0.04957362f, -0.05421502f, -0.18122748f, -0.12291691f, 0.01322090f, 0.09174351f, 
    -0.17028351f, -0.12585779f, 0.13840543f, 0.06923481f, 0.02957577f, -0.06974572f, 0.09515029f, 0.05757060f, 
    0.03989387f, -0.04768942f, -0.29198003f, -0.02309518f, -0.04653569f, 0.01157637f, -0.11353503f, 0.04145409f, 
    -0.13555743f, 0.02290870f, -0.11140857f, 0.03802484f, 0.29278731f, 0.37356505f, -0.07906851f, -0.01383038f, 
    0.02263421f, 0.28666615f, 0.06842107f, 0.10686491f, -0.15701932f, -0.22039393f, -0.09716453f, -0.06798290f, 
    -0.09627755f, 0.05685069f, 0.08565803f, 0.05164485f, 0.02818419f, -0.03886294f, -0.01111525f, -0.03813608f, 
    -0.07082648f, -0.06733568f, 0.12627451f, -0.14661245f, 0.05513505f, -0.13380952f, -0.00026189f, 0.10365831f, 
    0.15207230f, -0.13106935f, -0.11847649f, -0.29217881f, -0.30205548f, -0.11990172f, -0.13511671f, -0.06745044f, 
    -0.03417861f, 0.04479446f, -0.08459503f, -0.04058501f, 0.53733599f, -0.05346395f, -0.10442732f, -0.12955599f, 
    -0.10142892f, 0.37813282f, 0.13940389f, 0.32236648f, -0.10382915f, 0.22582006f, -0.03717883f, 0.00924353f, 
    0.00844551f, 0.13699521f, -0.17653367f, 0.12228353f, 0.04128301f, -0.03862201f, 0.06597470f, 0.05474629f, 
    -0.50754416f, -0.40921625f, 0.16191381f, -0.60652500f, 0.06151508f, -0.00453007f, -0.17511675f, -0.01284798f, 
    0.08409414f, -0.21057911f, 0.15896086f, 0.04911714f, -0.26587057f, -0.17950194f, -0.14895809f, -0.10201362f, 
    -0.26719317f, -0.07715894f, -0.07827911f, -0.03731525f, 0.29826584f, 0.49482882f, 0.38869467f, -0.44565162f, 
    -0.19696416f, 0.19180851f, 0.27365679f, 0.15798141f, -0.02920409f, 0.08036400f, -0.00940623f, -0.11421075f, 
    -0.07658563f, -0.16012760f, -0.07472996f, -0.08073149f, -0.10529187f, -0.00627728f, -0.04345817f, 0.15007067f, 
    -0.64947176f, -0.45929718f, -0.27773365f, 0.17885149f, -0.20741786f, -0.01009165f, 0.03201537f, -0.09460799f, 
    0.02370929f, 0.07102774f, -0.13887650f, 0.01816377f, -0.03867090f, -0.01007885f, -0.00837420f, -0.18783598f, 
    0.16701114f, -0.18461312f, -0.26745260f, 0.08398340f, 0.54435492f, 0.37784040f, 0.15943266f, -0.44803178f, 
    -0.19973616f, 0.27454218f, 0.13152610f, 0.08772043f, -0.08174987f, -0.21966724f, -0.05540998f, -0.05308857f, 
    -0.07867961f, 0.04160891f, 0.03480341f, 0.03680558f, -0.06692360f, -0.06424078f, -0.06807894f, -0.10657286f, 
    -0.50568986f, 0.41222262f, 0.09139457f, -0.09601060f, 0.05043941f, -0.34228826f, -0.44620126f, -0.11385641f, 
    -0.04224476f, -0.29281178f, 0.09156080f, -0.08454841f, -0.05615801f, 0.04017527f, 0.03636714f, 0.00223983f, 
    0.19005132f, -0.04532286f, -0.01797407f, 0.01688373f, -0.31635788f, -0.07678262f, 0.06228050f, -0.62084562f, 
    0.09923227f, -0.48147216f, -0.01312642f, -0.19187485f, -0.19544707f, -0.06117221f, 0.03816462f, 0.03613071f, 
    0.01815774f, 0.11283244f, 0.08767550f, -0.20998143f, 0.00271491f, -0.35545599f, -0.31661418f, -0.09242754f, 
    0.00972024f, -0.02023469f, -0.03780940f, 0.01330605f, 0.09898305f, -0.11058263f, -0.12068492f, 0.09353954f, 
    0.02206415f, -0.02211427f, -0.13661225f, 0.14619176f, -0.01702423f, 0.22654387f, -0.12908480f, -0.13237648f, 
    -0.05404202f, 0.01289263f, -0.01067333f, 0.01745443f, 0.71355599f, 0.12199864f, 0.28386256f, 0.22078848f, 
    0.36206284f, -0.08583996f, 0.00132263f, 0.04148993f, -0.05301771f, -0.02860979f, -0.06887151f, 0.01306135f, 
    -0.07023943f, -0.04658286f, 0.02346075f, 0.02353976f, -0.17393786f, -0.09170873f, 0.14376806f, -0.10903267f, 
    0.60519832f, -0.04805956f, -0.33448821f, -0.00026552f, -0.01233017f, 0.00896632f, -0.03425892f, 0.04022074f, 
    0.15582962f, -0.36599892f, 0.09131279f, -0.05881376f, -0.11410014f, -0.04736245f, -0.12795623f, 0.09240665f, 
    -0.09983917f, -0.01817022f, 0.03051178f, -0.14260206f, 0.07742053f, -0.13765417f, 0.12189271f, 0.20167880f, 
    0.05156955f, 0.09201568f, -0.07188734f, -0.00835056f, 0.10741176f, -0.22003186f, -0.03329170f, 0.15700501f, 
    0.01230482f, 0.07413964f, -0.10121262f, 0.18386246f, 0.08754378f, 0.06735176f, 0.10235540f, 0.01824070f, 
    0.24909830f, -0.06218124f, 0.05169126f, 0.23280378f, 0.10202283f, -0.08283176f, -0.10421338f, -0.01260970f, 
    -0.05274137f, -0.07944303f, 0.01311069f, 0.02249884f, -0.08322302f, -0.08196022f, -0.01031726f, -0.05879059f, 
    -0.07893138f, -0.23191820f, 0.06723676f, -0.10515703f, -0.32204515f, -0.02074012f, -0.37560675f, 0.09991972f, 
    0.23972565f, 0.07834825f, 0.23626570f, 0.11581609f, 0.29795328f, 0.09724339f, -0.05814348f, 0.04698458f, 
    0.03264363f, 0.08164673f, 0.03403467f, 0.02219983f, 0.08747203f, 0.12389023f, -0.10256877f, 0.03253303f, 
    -0.00983250f, -0.18645583f, 0.16602917f, 0.17327185f, 0.19238579f, -0.02013701f, 0.01857439f, -0.03474011f, 
    -0.03265335f, 0.01051624f, 0.20182866f, -0.07935046f, -0.12503827f, 0.04486415f, 0.16276893f, -0.04055553f, 
    -0.14242490f, -0.06546814f, 0.05197128f, 0.01008656f, -0.21966739f, -0.25995472f, -0.38733977f, 0.00463253f, 
    -0.11010328f, -0.08959871f, 0.09516104f, 0.16855767f, 0.04721071f, -0.10282047f, -0.07915302f, 0.10972384f, 
    -0.05976048f, 0.04640668f, -0.04796009f, -0.12677516f, 0.00672152f, 0.00975278f, -0.00592669f, 0.07730986f, 
    -0.13993381f, 0.07184421f, 0.08389989f, 0.07259984f, -0.00289955f, -0.05898676f, 0.10701577f, 0.11232163f, 
    0.03702985f, 0.13013636f, 0.00298692f, 0.09574399f, 0.21725421f, 0.17859900f, -0.09865552f, -0.02166583f, 
    0.07422360f, 0.02972765f, -0.01078969f, -0.07679049f, 0.55011046f, 0.41839206f, 0.38332590f, 0.10202875f, 
    -0.73428077f, -0.09573074f, -0.14972745f, 0.15713921f, 0.05509014f, -0.03422648f, 0.11069885f, -0.19133449f, 
    0.07849065f, -0.21611813f, -0.00205319f, 0.11610950f, 0.02973502f, -0.15258601f, -0.12958230f, 0.05366471f, 
    -0.57952279f, 0.03632175f, -0.06910582f, 0.07108674f, 0.26936206f, 0.00213265f, 0.01649718f, 0.03311832f, 
    -0.03878198f, 0.08478375f, -0.02586998f, 0.09517640f, 0.07716350f, -0.15180044f, 0.10703251f, 0.27831784f, 
    0.18391161f, 0.14975460f, 0.09640425f, 0.07538206f, -0.23672076f, 0.33393353f, -0.00398357f, 0.03800232f, 
    -0.12131442f, 0.28230876f, -0.19366616f, -0.16130345f, -0.32296956f, 0.17559728f, -0.11162703f, 0.03156712f, 
    0.09944842f, 0.00680763f, 0.15939045f, -0.09819188f, -0.05416131f, 0.15551339f, -0.36090499f, -0.32701424f, 
    0.65900367f, -0.04112917f, -0.09860171f, -0.15506978f, -0.15987495f, -0.11747959f, -0.05958918f, -0.05430453f, 
    -0.06251656f, 0.01616142f, 0.01904496f, -0.00562067f, -0.07884311f, 0.02630153f, -0.03474473f, -0.05258909f, 
    0.20824660f, -0.14884710f, 0.31253880f, 0.06535430f, -0.38675103f, 0.48954624f, -0.00271608f, 0.01961716f, 
    0.37590045f, -0.14548346f, 0.03001203f, -0.01475231f, -0.26349431f, -0.04462006f, -0.02915673f, 0.02303164f, 
    -0.06510154f, 0.01278508f, 0.02802498f, 0.13940649f, -0.00691591f, 0.02548386f, 0.01336856f, 0.07643706f, 
    -0.59544033f, -0.65919471f, -0.27081475f, -0.66880250f, -0.29187697f, 0.13873629f, -0.05616546f, -0.19452016f, 
    0.01996892f, -0.23173147f, -0.04724560f, 0.05076418f, 0.02842456f, -0.01615034f, -0.01820157f, -0.11555322f, 
    0.01639888f, -0.21888286f, -0.09122524f, -0.27540749f, -0.15186989f, 0.47651336f, -0.22042787f, -0.47537592f, 
    0.08015846f, -0.19506660f, -0.03067047f, -0.40709147f, -0.02761464f, -0.09915055f, -0.12548371f, -0.14995319f, 
    0.06132017f, 0.10872290f, -0.04065670f, -0.04066847f, -0.08061358f, 0.05810888f, 0.11055487f, -0.21465261f, 
    0.37251040f, 0.04836588f, -0.05002151f, 0.08224487f, 0.10378364f, 0.05476807f, -0.06622906f, -0.08158049f, 
    0.07214669f, 0.06414356f, -0.36118361f, -0.33674699f, -0.08415341f, -0.08722458f, -0.07057671f, 0.03568178f, 
    -0.10236917f, -0.07240789f, -0.02965213f, -0.06404997f, -0.26734293f, -0.51693934f, 0.04220232f, -0.06248412f, 
    -0.32226005f, -0.01136185f, -0.02958497f, -0.02482814f, -0.04629624f, 0.05267948f, 0.05130290f, 0.03594953f, 
    -0.05857009f, 0.00151290f, -0.03497882f, 0.20990518f, 0.13605635f, 0.28152534f, -0.02002561f, -0.30541897f, 
    -0.06235916f, -0.64650625f, 0.89680511f, 0.11755642f, 0.33158380f, 0.04144471f, -0.17347424f, -0.01422975f, 
    0.25841889f, -0.41230261f, 0.17856762f, 0.14670736f, -0.01600937f, -0.06693973f, -0.04605865f, 0.11028747f, 
    -0.07215579f, -0.06941000f, 0.05626868f, -0.11213836f, 0.10579623f, -0.03369169f, -0.00199790f, -0.25414202f, 
    -0.05350637f, 0.01810163f, -0.14101514f, -0.07268444f, 0.01672608f, 0.07023771f, -0.07739299f, -0.04035694f, 
    -0.01959336f, -0.28925651f, 0.06297067f, -0.10456564f, 0.11511824f, -0.29731548f, 0.24068438f, -0.07883354f, 
    -0.22649778f, -0.32821280f, -0.49814680f, -0.27272400f, 0.03297210f, -0.05022517f, -0.08629686f, 0.00173483f, 
    0.01125213f, -0.00997930f, -0.18273410f, -0.15260829f, 0.03829700f, -0.10101309f, 0.06411914f, 0.10622148f, 
    0.06358031f, -0.06022497f, 0.10197974f, -0.06583635f, -0.11463090f, 0.04449720f, -0.04724853f, 0.04369701f, 
    0.11282492f, -0.02243155f, -0.10300521f, -0.22935426f, 0.19510563f, -0.16558281f, 0.00996868f, 0.17900759f, 
    -0.09693979f, 0.06520443f, 0.02006297f, -0.02972560f, -0.00328683f, 0.01837773f, -0.03388358f, -0.05196951f, 
    0.27281174f, -0.09594001f, -0.16302003f, -0.09290103f, 0.11462726f, -0.01736611f, -0.02604474f, -0.02709856f, 
    0.03042524f, 0.06052620f, -0.09677175f, 0.15033647f, -0.15143444f, 0.23203611f, -0.08280373f, 0.14051922f, 
    0.04033929f, 0.11627679f, 0.01103169f, -0.08206715f, -0.06662691f, 0.18385629f, 0.32925534f, 0.01139178f, 
    0.20451941f, -0.16079745f, -0.11799359f, 0.05214254f, 0.01672208f, -0.32883868f, -0.00792188f, -0.04770571f, 
    0.04789535f, 0.02857730f, 0.05862875f, 0.01200921f, -0.13514215f, 0.00989715f, -0.01270725f, -0.12807770f, 
    0.38076377f, 0.07856806f, -0.02777915f, 0.19787829f, 0.16166799f, -0.02826020f, 0.07235363f, -0.03369161f, 
    0.03318392f, 0.00431066f, -0.28433853f, 0.06466494f, 0.10856771f, -0.04274473f, 0.04027768f, 0.00938469f, 
    -0.05146874f, 0.05651497f, 0.00137408f, -0.04418892f, -0.48600337f, -0.11870112f, 1.16362786f, 0.29745638f, 
    0.10071801f, 0.00478633f, -0.27950528f, -0.12455101f, -0.19996308f, 0.13127552f, 0.08494731f, 0.06224953f, 
    0.08463211f, -0.22350438f, -0.02267950f, -0.09027518f, 0.12710957f, -0.14523265f, 0.12773204f, -0.19173382f, 
    0.72001803f, 0.20982815f, -0.41224787f, 0.19405878f, 0.21938808f, 0.00261466f, 0.00597489f, -0.10523158f, 
    0.02258051f, -0.01339219f, 0.08143800f, 0.07588098f, -0.01402771f, -0.22731449f, -0.10114152f, -0.15920624f, 
    0.03055101f, 0.15643768f, -0.09443787f, 0.11577895f, -1.12461054f, -1.31587291f, -0.78497100f, -0.03455407f, 
    -0.92979598f, 0.02217559f, 0.03150498f, 0.11587454f, -0.02814450f, -0.00994977f, -0.15164720f, 0.01337505f, 
    0.04440509f, -0.00867514f, -0.07548271f, -0.07822771f, -0.03315894f, -0.04138462f, 0.08732141f, 0.32891291f, 
    -0.36721846f, 0.08674837f, 0.25083286f, -0.46497697f, -0.08032996f, -0.02103265f, -0.09216969f, -0.02624820f, 
    0.02361087f, 0.11756274f, 0.01075382f, 0.00794694f, -0.04281034f, 0.08160549f, -0.00701796f, 0.22436658f, 
    -0.29678193f, -0.18215577f, 0.15902422f, -0.02825765f, -0.42913041f, 0.57433176f, -0.08653168f, 0.10569195f, 
    0.41816831f, 0.12743373f, -0.02800194f, 0.28047800f, 0.17594612f, 0.27690509f, -0.04961849f, 0.04891661f, 
    0.06988531f, 0.05148336f, -0.03613144f, 0.03880626f, 0.01563086f, -0.02315057f, -0.15479162f, 0.07772887f, 
    0.22702901f, 0.33658203f, 0.34958452f, -0.16067460f, 0.39641163f, -0.12563431f, 0.21570982f, -0.08282167f, 
    0.08345396f, 0.07021105f, -0.04635874f, 0.00158354f, 0.08009886f, -0.07902513f, 0.03431695f, -0.00190324f, 
    0.17510270f, -0.00098935f, 0.34729835f, 0.08075993f, -0.91458374f, 0.31027347f, -0.00582596f, -0.32954311f, 
    -0.30664003f, -0.09416409f, -0.13743013f, -0.35528928f, -0.31119716f, 0.13710761f, 0.12218932f, -0.00162496f, 
    0.06064785f, 0.11607774f, -0.22962756f, -0.08340161f, 0.05418362f, -0.16493058f, -0.16099824f, 0.00448617f, 
    -0.48897532f, 0.35859507f, -0.12639596f, -0.48583192f, 0.12422235f, -0.03740130f, 0.06896275f, -0.39157370f, 
    0.27350292f, -0.18467054f, -0.08053970f, 0.01690489f, -0.17551278f, -0.25918457f, 0.08701045f, 0.17622542f, 
    0.18382059f, -0.20675954f, 0.03198931f, -0.27371514f, -0.09552493f, -0.33449638f, 0.43456247f, 0.10311256f, 
    -0.44979486f, -0.09152620f, -0.11909775f, 0.11827589f, 0.16664180f, 0.01163947f, 0.12771823f, 0.08508699f, 
    0.31956556f, -0.04912753f, -0.07077464f, -0.01703270f, -0.02238245f, -0.15601064f, 0.09981959f, -0.02078583f, 
    -0.86250091f, 0.99014807f, -0.15165381f, -0.23643836f, 0.21740127f, 0.56778055f, 0.10060772f, 0.04903793f, 
    -0.07984155f, -0.06531936f, -0.36433616f, -0.13034552f, -0.01523603f, -0.14633584f, 0.07334457f, -0.16052562f, 
    -0.01742896f, 0.02007632f, 0.29888245f, -0.05911271f, -0.25252995f, 0.08537628f, -0.02180769f, 0.13519980f, 
    -0.08929978f, 0.09569627f, -0.05638764f, -0.28229478f, -0.13530953f, 0.07089806f, 0.14498907f, -0.04615219f, 
    0.10012379f, -0.18243220f, -0.24781007f, -0.05691359f, -0.01734657f, 0.22616196f, 0.05338354f, -0.27003410f, 
    -0.50533479f, -0.37475598f, -0.74768621f, 0.04987777f, -0.31173018f, 0.49838677f, 0.13070029f, 0.31209359f, 
    0.38115451f, 0.17748630f, -0.19568552f, -0.24339440f, 0.13474572f, -0.12568152f, -0.07474037f, -0.06255644f, 
    0.03556998f, -0.24913432f, 0.07778474f, -0.00146915f, -0.31704381f, -0.24398737f, -0.35818636f, -0.20167027f, 
    0.37221530f, 0.08564173f, 0.11661495f, 0.11941110f, 0.12216748f, 0.11147273f, -0.03726890f, -0.00623598f, 
    0.04990486f, -0.08884423f, -0.11636247f, 0.09368746f, -0.06493092f, 0.23500733f, -0.15854041f, 0.03771284f, 
    0.30579180f, -0.12908696f, 0.04044630f, -0.10801302f, -0.68081731f, 0.11032545f, -0.31715760f, 0.01563126f, 
    -0.03891516f, -0.25312892f, -0.04154684f, -0.23930214f, 0.13901067f, 0.02375980f, 0.01583820f, 0.05547420f, 
    0.16164169f, -0.35222265f, -0.02875174f, 0.01181474f, -0.31524500f, -0.14957981f, -0.15265352f, 0.00287112f, 
    0.52620351f, 0.15848604f, -0.03280006f, 0.03472896f, -0.12581114f, 0.08012689f, -0.03050217f, 0.14152069f, 
    0.17543198f, 0.00500252f, 0.04778202f, 0.03625903f, -0.17554805f, -0.16845533f, 0.08539039f, 0.04361199f, 
    0.09331274f, 0.28818315f, 0.04612509f, -0.06537512f, 0.07359938f, 0.17581415f, -0.11425979f, -0.26511815f, 
    -0.06091340f, -0.20895445f, -0.20870274f, -0.00082466f, 0.07023896f, -0.02201516f, 0.13405807f, -0.07221259f, 
    0.16730152f, -0.27904895f, -0.02573717f, -0.07436299f, 0.14755580f, 0.33853367f, -0.10386825f, 0.15288539f, 
    0.59101743f, 0.20438772f, 0.02818990f, -0.13636518f, 0.14913262f, 0.06264523f, -0.13808765f, 0.07130829f, 
    0.04216503f, 0.04416262f, 0.13275568f, 0.00695774f, 0.17860092f, 0.00849319f, 0.06237752f, 0.06178115f, 
    0.62081170f, 0.81314719f, 0.57744825f, -0.59942275f, 0.17176135f, -0.12916797f, 0.08300990f, -0.39222011f, 
    -0.09771430f, -0.31113797f, 0.02278905f, -0.01279567f, -0.03545730f, -0.08481927f, 0.09915091f, 0.17816763f, 
    -0.09728483f, 0.02276494f, -0.21305349f, -0.26110438f, 0.11431872f, -0.31986466f, -0.30025542f, -0.06559422f, 
    0.46844769f, -0.10117412f, 0.11747654f, 0.07091402f, 0.07745057f, 0.08006006f, -0.03592046f, -0.03403254f, 
    -0.20946358f, -0.19850770f, -0.03662223f, -0.02285738f, -0.08615602f, 0.04846327f, -0.11483264f, -0.07970060f, 
    -0.96322948f, 0.12882225f, 0.52906525f, 0.17626938f, -0.31504175f, -0.15950237f, -0.36244896f, 0.08335131f, 
    0.01263739f, -0.25152564f, -0.14005969f, -0.00042159f, -0.04343719f, 0.12425546f, -0.01634711f, 0.07229266f, 
    0.17696536f, -0.13000254f, 0.09425420f, -0.24908632f, 0.02567966f, -0.19232994f, -0.25544533f, -0.24116457f, 
    0.32873508f, 0.00698636f, -0.08360817f, -0.08786044f, -0.09636522f, -0.35707080f, -0.03092025f, -0.02827313f, 
    0.03922207f, -0.00274077f, 0.12364389f, -0.07296623f, 0.03379727f, 0.06189158f, -0.04442761f, 0.04960410f, 
    0.66151524f, 0.47403088f, 0.49910104f, -0.65252131f, 0.53646356f, -0.34476840f, 0.08283181f, -0.01942862f, 
    -0.15020530f, 0.17844273f, -0.07882249f, -0.01831925f, 0.07506100f, 0.04129133f, -0.01007776f, -0.02975350f, 
    -0.03911668f, -0.04944025f, 0.14859802f, 0.12077705f, -1.06016445f, -0.28159496f, 0.32968047f, 0.52600199f, 
    0.10087788f, 0.43511346f, 0.22666156f, -0.20649016f, -0.30869091f, -0.07094837f, -0.04903037f, 0.23192124f, 
    -0.08019112f, -0.12159991f, 0.15091708f, 0.09089711f, 0.20273057f, 0.24177316f, -0.20635343f, -0.48862782f, 
    -0.04216699f, 0.03466830f, -0.05881653f, -0.02328656f, -0.07198651f, 0.08660895f, 0.01387753f, 0.00334707f, 
    -0.06926639f, 0.01391248f, -0.26537400f, 0.11761353f, -0.12857625f, 0.00695292f, 0.00245728f, 0.16782176f, 
    -0.09386344f, -0.01893113f, -0.08610861f, -0.14650391f, -0.21509698f, 0.40272316f, -0.44459113f, -0.13818790f, 
    -0.27352977f, -0.01723556f, 0.00133495f, -0.00112452f, 0.07052445f, 0.07683448f, 0.07291327f, 0.04347321f, 
    0.00171162f, 0.05514945f, 0.03355723f, 0.03276006f, 0.14116943f, 0.27505475f, -0.15849110f, 0.45223019f, 
    0.33966976f, -0.80197924f, 0.13614188f, 0.06987980f, -0.05357634f, -0.16689695f, -0.24433000f, -0.07610130f, 
    -0.13651021f, 0.34710172f, 0.10918284f, -0.02083118f, 0.06539421f, -0.20086439f, -0.06519257f, 0.09074605f, 
    0.11598992f, 0.08649510f, -0.24407429f, -0.00450343f, -0.13260578f, -0.15185745f, -0.13757756f, -0.37232125f, 
    -0.37051639f, 0.02156227f, 0.03981947f, -0.16143519f, 0.00993193f, 0.03990731f, 0.04449769f, -0.19398184f, 
    0.21008232f, -0.03144656f, 0.00533188f, -0.21567628f, -0.26246750f, -0.07742261f, -0.17249893f, -0.13817021f, 
    0.32805705f, 0.35010478f, 0.17138539f, -0.31432965f, -0.23085131f, 0.18057479f, 0.01076396f, 0.00527865f, 
    0.07052857f, 0.12463071f, 0.20984383f, 0.18302283f, 0.12182733f, -0.10657422f, -0.07694256f, -0.00299495f, 
    0.08215169f, -0.00566724f, -0.09953003f, 0.13892514f, 0.17700489f, 0.06093009f, 0.28169692f, 0.18520378f, 
    -0.06484091f, -0.00188222f, -0.07966230f, -0.16527608f, -0.13479565f, 0.06113519f, 0.13798869f, -0.03666841f, 
    0.01199029f, -0.00231605f, -0.02490532f, 0.04556521f, -0.11147121f, -0.10717986f, -0.04035660f, -0.21862359f, 
    0.10779578f, -0.03559945f, -0.34384447f, -0.17908078f, -0.05791562f, 0.15468009f, -0.03625513f, -0.02354579f, 
    0.01893971f, 0.04791893f, 0.03435317f, -0.22892235f, 0.18958387f, -0.06492789f, -0.05243283f, 0.08907047f, 
    -0.09847143f, -0.04666200f, -0.14205022f, 0.19040766f, 0.24675426f, 0.03195628f, 0.13779005f, 0.16801220f, 
    0.15792057f, -0.04934450f, -0.11271013f, -0.14079471f, 0.04938953f, -0.00864918f, 0.16820703f, -0.10177287f, 
    0.03004798f, 0.01268854f, 0.05830142f, 0.09861874f, 0.04210855f, 0.07981544f, -0.07944718f, -0.10437316f, 
    -0.08002038f, 0.05941388f, -0.16453873f, -0.01718233f, -0.10289122f, -0.04060967f, -0.15026230f, -0.01771616f, 
    -0.07354739f, -0.00485146f, 0.01487241f, -0.05051714f, -0.12492412f, 0.00275793f, 0.09178798f, -0.07161386f, 
    -0.01499168f, 0.00712852f, -0.11821708f, -0.10825516f, -0.46509075f, -0.09626754f, 0.04060170f, 0.09188522f, 
    0.15718344f, -0.30074361f, 0.36722472f, -0.21490686f, -0.23775713f, -0.20211984f, -0.05998299f, 0.01122854f, 
    -0.16263431f, 0.22639467f, 0.11797991f, -0.11600392f, 0.00930092f, 0.00008686f, 0.05955308f, 0.10337356f, 
    -0.02743965f, -0.37178189f, -0.49187151f, 0.01848583f, -0.42962426f, -0.12840651f, -0.06641889f, 0.07512543f, 
    -0.26428223f, -0.09162883f, -0.09181926f, -0.21725464f, -0.06060230f, 0.16223826f, 0.05720167f, -0.26492596f, 
    -0.42204985f, -0.05671066f, -0.12205339f, -0.09076677f, -0.01533166f, 0.18511774f, 0.37016603f, 0.25395513f, 
    0.07781158f, -0.09783720f, 0.10086783f, -0.02645817f, 0.31940418f, 0.06997760f, -0.00934245f, 0.01021755f, 
    -0.02819627f, 0.07722909f, -0.05837360f, 0.01203805f, 0.14415753f, -0.18325216f, 0.13289888f, 0.25498441f, 
    0.10724721f, 0.01203370f, -0.43368185f, 0.12048221f, 0.26645291f, 0.09509494f, -0.02118782f, 0.03675925f, 
    -0.03514364f, 0.01378660f, 0.11393110f, 0.07917942f, 0.03228249f, -0.04590982f, 0.02169222f, 0.08162942f, 
    -0.04131909f, -0.01383449f, -0.19084874f, -0.01012953f, -0.10696255f, 0.01553694f, 0.36152491f, 0.21668965f, 
    0.18032447f, -0.27948296f, -0.19024548f, -0.04821409f, -0.15116999f, -0.05866298f, 0.00793042f, 0.00538014f, 
    -0.01484495f, 0.03703469f, -0.00175269f, -0.06913962f, -0.12797619f, -0.05478269f, -0.06389084f, 0.03457991f, 
    0.46004492f, -0.32669848f, -0.23841721f, 0.74607372f, 0.01360589f, 0.15915997f, -0.04994057f, 0.12697187f, 
    0.00524647f, 0.03101278f, 0.05743500f, -0.19751833f, -0.05891009f, 0.01149773f, 0.01458379f, -0.15468626f, 
    0.08758303f, 0.13766809f, -0.21934441f, -0.02554313f, 0.18619251f, -0.17039970f, 0.13002139f, 0.35555169f, 
    0.28516814f, 0.08989429f, -0.05317417f, 0.12440483f, 0.03076717f, -0.14870659f, 0.03321014f, 0.13374439f, 
    -0.14418520f, -0.02128997f, 0.01026797f, 0.05459055f, -0.16924520f, -0.44808054f, -0.28090543f, -0.08273199f, 
    0.07989963f, -0.06767636f, -0.03282331f, 0.11376971f, -0.16228932f, -0.01120486f, 0.03826612f, -0.14416736f, 
    0.02280727f, 0.03188665f, 0.29388505f, -0.16350333f, 0.06706350f, -0.30166820f, 0.16647883f, -0.01653485f, 
    0.05002235f, -0.01252907f, 0.08230161f, 0.03303551f, 0.04746957f, -0.11138268f, -0.40045556f, -0.10506487f, 
    0.10453207f, 0.16659203f, 0.03579782f, -0.06854851f, 0.00700770f, 0.00347999f, 0.00872856f, 0.01810696f, 
    -0.03363404f, 0.04118307f, 0.10657845f, -0.43255416f, -0.05639382f, -0.00666680f, 0.03060295f, -0.13344145f, 
    -1.07907903f, 0.26455179f, -0.36828849f, -0.57176304f, -0.30401066f, -0.06102540f, 0.13503335f, -0.00918945f, 
    -0.08746674f, -0.05933338f, 0.05728787f, 0.15107721f, -0.10177910f, 0.21325590f, 0.03356657f, -0.08315106f, 
    -0.12934749f, 0.06180402f, -0.01752351f, 0.07310621f, 0.69593674f, 0.39258710f, -0.41686982f, -0.24437366f, 
    0.23046991f, -0.15934666f, 0.28906557f, 0.04670487f, -0.23784585f, 0.14068471f, 0.16081908f, -0.17449702f, 
    0.04798618f, -0.01135328f, -0.02170563f, 0.08120075f, -0.10335939f, -0.03489652f, 0.02548350f, 0.30525112f, 
    -0.12656039f, 0.01918709f, -0.18259124f, 0.01672641f, 0.08965732f, 0.00376846f, 0.03008053f, -0.04466958f, 
    -0.06657426f, -0.01239583f, 0.15736146f, -0.07768673f, -0.29094324f, 0.06654794f, 0.13960840f, -0.08913571f, 
    0.05765933f, 0.26692766f, 0.07038554f, -0.09050273f, 0.38250455f, -0.08714557f, 0.26582122f, -0.05591991f, 
    -0.39956707f, -0.02690877f, 0.11221582f, 0.21813588f, -0.29833555f, -0.17762169f, 0.17131467f, -0.01327067f, 
    -0.00783070f, -0.12560503f, -0.06539628f, -0.05829730f, 0.12378189f, -0.01353183f, 0.11148352f, 0.11520531f, 
    -0.31177565f, -0.10673503f, -0.45031828f, 0.19995126f, 0.06067834f, 0.13160108f, -0.22303650f, -0.13213712f, 
    -0.02037823f, 0.10810523f, 0.07227255f, -0.02211711f, -0.02854841f, -0.02769110f, -0.10354841f, -0.11229371f, 
    0.08529235f, 0.21999374f, 0.01875950f, -0.15644260f, -0.11790613f, -0.18336833f, -0.05327668f, -0.04952935f, 
    -0.23654674f, 0.08811111f, 0.01149660f, 0.03805875f, 0.06811416f, 0.17077138f, 0.00630930f, -0.04239735f, 
    -0.04530665f, -0.02007249f, -0.17589119f, -0.06176591f, 0.10059047f, 0.09547459f, -0.09712962f, 0.09471873f, 
    -0.04754736f, -0.25354114f, -0.08946927f, 0.04742894f, -0.09284902f, 0.13057272f, -0.13824040f, -0.11599343f, 
    0.20213310f, -0.02841571f, 0.21798936f, 0.07139812f, -0.10542060f, -0.14533193f, 0.01754829f, 0.02391303f, 
    0.04456578f, 0.08273980f, 0.12951027f, 0.27308184f, -0.20816571f, 0.08356498f, -0.15336244f, -0.33037642f, 
    -0.14606220f, -0.04601015f, -0.16403553f, -0.13020067f, -0.06365727f, 0.10438354f, -0.09643801f, -0.01065084f, 
    -0.11620842f, -0.06509385f, 0.02564106f, -0.24351139f, -0.21920018f, 0.00041668f, -0.01711249f, -0.17280532f, 
    0.17552835f, -0.28031385f, 0.29272786f, 0.33362383f, -0.19605832f, 0.08825649f, -0.21770266f, -0.10709310f, 
    0.11906231f, 0.17430139f, -0.04349857f, -0.22182435f, -0.10180011f, -0.01125899f, 0.13244383f, 0.04370247f, 
    0.15373150f, -0.21977405f, -0.03607310f, 0.08508872f, 0.23075119f, 0.16702807f, 0.36872000f, 0.33127323f, 
    -0.18074168f, -0.02436926f, 0.07964078f, 0.08198409f, 0.01183169f, -0.00747411f, 0.12162222f, -0.01400345f, 
    0.04601474f, 0.08354938f, -0.01804131f, 0.07129223f, 0.03898530f, -0.10330114f, -0.26790211f, -0.23573332f, 
    -0.17266020f, -0.03141665f, -0.36215720f, 0.09254424f, 0.41489962f, -0.00185277f, 0.04607746f, -0.02634601f, 
    0.05079836f, -0.03970748f, 0.16389248f, -0.18340281f, 0.07590693f, 0.00450273f, -0.08084727f, -0.12246537f, 
    -0.30041975f, 0.28170457f, -0.10674935f, -0.30907178f, 0.15491006f, -0.25025398f, -0.03473143f, 0.32576787f, 
    -0.38896710f, 0.13651484f, 0.25015649f, 0.14217950f, 0.12062018f, 0.18005116f, -0.04579049f, -0.03640719f, 
    -0.07969338f, 0.02774428f, -0.03920998f, -0.12374277f, 0.16564448f, -0.00048816f, -0.04468045f, 0.14644341f, 
    -0.77320254f, 0.00053531f, 0.35029614f, 0.29727691f, -0.62800300f, 0.15958411f, -0.17733604f, -0.05998490f, 
    0.23511867f, 0.20204313f, -0.03519280f, 0.14093849f, -0.08411244f, 0.00653946f, -0.04095127f, 0.10449703f, 
    -0.16803284f, 0.30369729f, -0.08695265f, -0.10481508f, 0.19445542f, -0.45119232f, -0.22954631f, -0.08582023f, 
    -0.19688873f, 0.29649708f, 0.09689884f, 0.20081246f, -0.22909549f, 0.11775232f, 0.01834801f, -0.05928065f, 
    -0.04958643f, -0.03562405f, 0.08445286f, -0.01615924f, 0.15188870f, 0.16048183f, 0.21962595f, 0.25085950f, 
    -0.34899142f, 0.02872536f, 0.32990235f, 0.02161259f, -0.06189890f, -0.05848933f, -0.03149686f, -0.17040554f, 
    -0.05610680f, 0.21157478f, 0.25658163f, -0.13123654f, -0.04244193f, 0.15258311f, -0.04802792f, -0.01482839f, 
    -0.07947747f, -0.11980485f, -0.01174326f, 0.03432377f, -0.39964360f, 0.11591860f, -0.05185096f, -0.44087777f, 
    -0.28815302f, 0.05557751f, 0.04215859f, 0.02436988f, -0.05166243f, 0.06046019f, -0.02547791f, -0.06408981f, 
    0.04944884f, -0.03972941f, -0.09123991f, 0.20356901f, 0.19365282f, -0.03241687f, -0.07164641f, 0.19111750f, 
    -0.47773734f, -0.26060364f, 0.64880741f, 0.08251490f, 0.18683565f, -0.00106134f, -0.12129410f, -0.00355772f, 
    -0.16141909f, 0.21981712f, 0.00449785f, 0.22143361f, 0.08422857f, 0.13292581f, -0.06939016f, 0.10977761f, 
    0.16170487f, -0.03130718f, -0.17590170f, 0.01039668f, 0.28623876f, 0.11729933f, -0.08641184f, -0.04732752f, 
    0.28434524f, -0.01737461f, -0.08160587f, -0.04850563f, 0.08618315f, -0.17975770f, 0.11140083f, 0.03931857f, 
    0.15286937f, 0.15832001f, 0.00670756f, 0.07895304f, 0.01388314f, -0.22086428f, -0.22777522f, -0.07214522f, 
    -0.13628800f, 0.06816836f, 0.19752754f, -0.18548881f, -0.00913232f, -0.04237599f, -0.07590022f, -0.12243244f, 
    -0.18219008f, -0.03871825f, -0.06333294f, -0.02475773f, 0.00716481f, -0.00998849f, -0.14646110f, -0.04679961f, 
    -0.19888738f, 0.00760012f, -0.13260317f, 0.03420843f, -0.75916821f, 0.47553378f, 0.45345587f, 0.23894763f, 
    -0.27602354f, -0.16702148f, -0.07614422f, -0.34122923f, -0.17105201f, -0.16988352f, -0.16526683f, -0.11816829f, 
    0.01025467f, -0.02936803f, 0.06601846f, -0.03175230f, 0.00913755f, 0.05179292f, 0.03326890f, -0.09334581f, 
    0.05765622f, -0.01405886f, -0.21984556f, -0.02384009f, 0.07872297f, 0.05828157f, -0.14419010f, -0.15301678f, 
    -0.07319575f, 0.21126325f, -0.01218399f, 0.07512282f, 0.23951451f, -0.05028279f, -0.16220565f, -0.13609701f, 
    0.14294715f, -0.24470221f, 0.06014151f, 0.01224319f, -0.81242681f, 0.71795487f, 0.62177426f, -0.10376386f, 
    -0.04760333f, -0.26957366f, -0.05889008f, -0.20892023f, -0.22310488f, 0.18084012f, -0.20071736f, 0.08391317f, 
    0.02540147f, 0.06204909f, -0.01426423f, 0.02001909f, -0.02936845f, -0.07727841f, 0.02549739f, -0.05232296f, 
    -0.18339439f, 0.11673185f, 0.34310973f, -0.04242719f, -0.03670838f, -0.02549387f, 0.09798314f, 0.04707815f, 
    -0.11349157f, 0.08081163f, 0.01284789f, 0.04655607f, -0.00813360f, 0.15366271f, 0.06246997f, -0.00955428f, 
    -0.03659464f, -0.13043052f, 0.00460254f, 0.02736653f, -0.68890727f, -0.71870035f, -0.30705473f, -0.15755430f, 
    1.18096852f, -0.02964146f, 0.09158112f, -0.03293809f, 0.00411877f, -0.22771016f, 0.04552514f, 0.02197146f, 
    0.03740417f, -0.07390166f, -0.12109391f, -0.00927779f, 0.06272577f, 0.23934446f, 0.19875427f, 0.05440570f, 
    0.06116313f, 0.20753802f, -0.03692829f, 0.18093152f, 0.24470487f, -0.09180263f, 0.13174896f, -0.13740437f, 
    0.09683383f, 0.30894661f, 0.06564261f, 0.23457332f, 0.01077968f, 0.11129192f, -0.19987389f, -0.09721429f, 
    -0.00175940f, -0.17223760f, 0.12319930f, -0.05570688f, -1.23133767f, -1.25410473f, -1.20780134f, -0.69716215f, 
    -0.12633508f, -0.26259473f, 0.11126829f, -0.15177040f, -0.05031892f, -0.62893736f, -0.01842251f, -0.06256953f, 
    -0.02390456f, -0.03581959f, 0.10324928f, -0.06638639f, -0.02149145f, -0.09075451f, 0.40454695f, 0.14203505f, 
    0.14765336f, 0.01507498f, 0.18077943f, 0.16712916f, -0.12910460f, 0.04525272f, 0.07112134f, 0.08159689f, 
    -0.08312602f, -0.15170409f, -0.03986550f, -0.03289619f, -0.01020908f, 0.01417154f, -0.01141323f, 0.11816211f, 
    -0.00716047f, 0.06762820f, -0.09568334f, 0.01915025f, -0.88753039f, -0.60559160f, -0.29087570f, -0.02592990f, 
    -0.10093709f, -0.19972964f, 0.09582819f, 0.11653874f, 0.04835777f, -0.03459071f, 0.09374064f, 0.03280480f, 
    0.03773376f, -0.03876192f, -0.02001555f, 0.03218871f, -0.04081437f, 0.02640310f, 0.23113459f, -0.21879885f, 
    -0.37174234f, -0.65622139f, -1.07364130f, -0.26802030f, 0.60362989f, -0.18486296f, 0.33126739f, 0.17764178f, 
    -0.07622629f, 0.12326156f, -0.02417208f, 0.03128838f, 0.05827636f, 0.08768159f, 0.05372905f, -0.04366861f, 
    -0.04198249f, -0.03699668f, 0.36111134f, -0.03422523f, 0.34873003f, -0.43123582f, -0.55050606f, -0.39092058f, 
    0.11535264f, -0.00917739f, 0.32681185f, 0.22647619f, 0.17222045f, 0.15618186f, 0.04521437f, 0.05680424f, 
    -0.13424769f, -0.10164491f, 0.15908599f, -0.03999924f, 0.15852615f, 0.10476552f, -0.23861334f, 0.19563073f, 
    0.03235700f, 0.07647765f, -0.02812378f, -0.20526041f, -0.07259903f, 0.03900850f, 0.07430375f, -0.04153685f, 
    -0.01835933f, -0.22183906f, 0.06580140f, 0.07177586f, 0.13023061f, -0.02310207f, 0.03268430f, -0.01247630f, 
    -0.02850300f, 0.00310164f, -0.05389144f, -0.01415330f, -0.20074601f, 0.15840057f, -0.07646628f, 0.21925917f, 
    -0.40698764f, 0.08353026f, 0.11635675f, 0.01474725f, -0.14642352f, -0.02363796f, 0.04281609f, -0.03827609f, 
    0.03821890f, 0.00329755f, -0.03891886f, 0.13506053f, 0.06175981f, -0.24435683f, -0.22665711f, -0.07535271f, 
    0.56376737f, 0.09827951f, 0.01875379f, -0.30595124f, 0.04957690f, -0.11485408f, 0.14428841f, -0.07631712f, 
    0.29430076f, 0.04015705f, 0.05873073f, -0.16169639f, 0.00887506f, -0.06714529f, 0.05838850f, -0.04774641f, 
    0.05238028f, -0.11801399f, 0.05876578f, 0.07136860f, -0.03229210f, 0.08590637f, 0.02120417f, 0.05923215f, 
    0.00518683f, 0.08556958f, 0.04366259f, 0.11185956f, -0.07847063f, 0.01999988f, 0.09411272f, -0.00550857f, 
    0.16671517f, -0.00218885f, -0.01357312f, -0.23181769f, -0.05916397f, 0.00436567f, -0.07874563f, 0.05060361f, 
    0.07965212f, 0.05545248f, -0.09931444f, 0.16018413f, -0.18758564f, -0.02964491f, 0.04741225f, 0.06287198f, 
    0.02605037f, -0.04882070f, 0.04243662f, -0.10519364f, 0.01023821f, -0.09726670f, -0.04824194f, -0.00972238f, 
    0.06943331f, -0.07085725f, 0.09946007f, 0.05555431f, 0.21674131f, -0.69440234f, -0.22733335f, 0.07360229f, 
    0.14391446f, 0.13569660f, 0.04118988f, 0.17777717f, 0.11535951f, 0.06373373f, -0.07586803f, -0.12933765f, 
    0.09517953f, 0.00492325f, 0.00898845f, -0.00930680f, -0.03042420f, -0.01061091f, 0.07622045f, -0.13474511f, 
    0.17872454f, 0.25558940f, -0.01108047f, -0.07928618f, -0.34829423f, -0.05761041f, 0.06309028f, 0.13147545f, 
    0.00541947f, -0.11480840f, -0.27866057f, -0.02359239f, -0.13768649f, -0.40881586f, -0.06544100f, -0.03361856f, 
    -0.19079813f, 0.09960795f, 0.02215768f, 0.00623242f, 0.59199709f, -0.38104722f, -0.28992972f, -0.04443158f, 
    -0.21993744f, 0.19225164f, -0.02161445f, 0.01920930f, -0.08766502f, 0.17696777f, 0.11668789f, -0.08606718f, 
    0.12355366f, 0.07147043f, 0.08608830f, -0.03497303f, -0.07740958f, 0.06132645f, 0.09779605f, -0.02243279f, 
    0.18506698f, 0.08504084f, -0.41325954f, -0.21383417f, -0.25017408f, 0.11601210f, 0.09323235f, -0.05844884f, 
    -0.13247076f, -0.18301493f, -0.06922375f, 0.01051959f, 0.13941310f, 0.02443105f, -0.08204243f, 0.01479882f, 
    -0.05055698f, 0.05228122f, -0.03619744f, 0.00649983f, -0.97075552f, -0.79549640f, -1.03981733f, -1.05088282f, 
    -0.30147070f, 0.11207426f, -0.15606935f, 0.49874270f, 0.19386339f, 0.11298763f, 0.01785393f, 0.15439969f, 
    -0.03950929f, 0.13754688f, 0.26828912f, -0.05945829f, -0.20549731f, 0.02844130f, 0.04625179f, 0.23186402f, 
    0.12587678f, 0.22583893f, -0.19470011f, -0.20129637f, -0.22023666f, -0.02986295f, 0.23585273f, -0.06323420f, 
    0.05286374f, -0.24370962f, -0.30306098f, 0.37285417f, 0.16153312f, -0.15797067f, -0.24354559f, -0.30542877f, 
    -0.07917870f, -0.01788836f, -0.17567787f, -0.23325391f, -0.39065686f, -0.66182524f, -0.23958214f, 1.13926041f, 
    -0.05775120f, 0.19089240f, -0.01428887f, -0.09698759f, -0.12394246f, 0.21996255f, 0.01347209f, -0.09026743f, 
    -0.13724327f, -0.10539853f, -0.09737588f, 0.08025976f, 0.14182131f, -0.02495307f, 0.11029600f, -0.01172844f, 
    -0.14329591f, 0.07079986f, -0.08227937f, -0.03892503f, -0.20918711f, 0.03814527f, 0.00177721f, -0.00098604f, 
    -0.03113978f, -0.04877875f, 0.00237666f, -0.04303084f, 0.11644985f, 0.01013861f, -0.09074321f, 0.11176461f, 
    -0.31956881f, -0.12493079f, -0.01373063f, -0.07505029f, 0.81337166f, -1.30425966f, -0.95263016f, -0.26282826f, 
    -0.25476277f, 0.10234342f, 0.00887951f, 0.00997063f, 0.16250437f, 0.02759339f, 0.00686713f, -0.03114277f, 
    0.00324300f, -0.03097351f, -0.12229382f, -0.09069473f, 0.01996569f, 0.02631444f, -0.03285377f, -0.25989437f, 
    -0.31787550f, 0.35008568f, -0.61724049f, 0.88166100f, -0.64113116f, -0.00178504f, 0.26545069f, -0.10716999f, 
    -0.06449696f, -0.07184348f, -0.10268750f, 0.07665587f, 0.04251453f, -0.03297871f, -0.03654408f, -0.03155645f, 
    -0.06635734f, -0.03328823f, -0.12625222f, 0.13376603f, 0.14450742f, -0.33490515f, 0.34083098f, 0.06222935f, 
    0.18543826f, 0.10616527f, 0.06838034f, -0.09609281f, 0.02511116f, -0.02484922f, 0.15422611f, 0.03251684f, 
    -0.01731743f, 0.05830411f, -0.14496313f, -0.02294198f, -0.11352337f, -0.04413197f, 0.19550052f, -0.11288748f, 
    -0.00865741f, -0.13908210f, -0.17025581f, -0.11592310f, -0.15155984f, -0.03273421f, -0.07277801f, 0.01355867f, 
    0.04851403f, -0.01523382f, 0.19561809f, 0.07157493f, 0.31445751f, -0.01383482f, 0.12358689f, 0.08215910f, 
    0.17088930f, 0.02688811f, 0.15741029f, 0.20710842f, -0.82428151f, 0.03364753f, 0.39732102f, 0.12615627f, 
    -0.16907400f, -0.11291072f, -0.05102090f, -0.12122918f, -0.08478075f, -0.06691090f, -0.12208461f, -0.10067137f, 
    -0.03199117f, -0.15924776f, -0.09142203f, -0.26943901f, -0.19083510f, -0.06163592f, -0.29848561f, -0.33406419f, 
    -0.22442910f, -0.31094989f, -0.46342018f, 0.24111329f, 0.04516405f, -0.25313345f, -0.04129078f, 0.43407893f, 
    0.23132959f, -0.10137613f, 0.14864051f, 0.00701051f, 0.12167501f, -0.06149381f, -0.01595194f, -0.07803326f, 
    -0.02713414f, 0.06113907f, -0.00950309f, 0.13968568f, -0.74089450f, -0.10852801f, 0.08219267f, 0.18607312f, 
    0.16275993f, -0.08853602f, 0.03946036f, 0.04850962f, 0.03067011f, 0.04286280f, -0.26518419f, 0.12010238f, 
    0.02304463f, 0.21236828f, 0.02317808f, -0.03243880f, -0.09645578f, 0.03357753f, 0.05113193f, 0.14398362f, 
    -0.64117622f, -0.09243990f, 0.24677248f, -0.04726475f, -0.34452882f, -0.20185092f, -0.00076845f, -0.09085813f, 
    -0.03023631f, -0.08836112f, -0.18209299f, 0.02062300f, 0.10945477f, 0.08231566f, 0.17209823f, 0.07857175f, 
    -0.03490154f, 0.05258202f, -0.03489362f, -0.02637275f, 0.24521755f, -0.44025129f, -0.58517891f, 0.05047663f, 
    0.14701515f, -0.15446751f, -0.18818761f, -0.05845161f, 0.11891481f, 0.05514928f, -0.09838241f, -0.23441248f, 
    -0.17975326f, -0.09174554f, 0.03090956f, -0.10469866f, 0.19391350f, 0.09163641f, 0.05804647f, -0.01982439f, 
    0.02480480f, 0.11475784f, 0.05384916f, -0.13952304f, -0.32937980f, -0.07587686f, 0.10111918f, -0.04116646f, 
    0.10132378f, -0.14671081f, -0.00654430f, 0.03218940f, 0.11363530f, 0.18458895f, 0.14049593f, 0.08443558f, 
    0.05493548f, -0.08863723f, 0.15022738f, 0.00580161f, -0.13495752f, -0.47033030f, -0.38558006f, -0.20978163f, 
    0.03589650f, -0.04439599f, 0.18446875f, 0.17100520f, 0.08951815f, 0.06177609f, 0.10955139f, -0.03299426f, 
    0.01879608f, -0.17260298f, -0.11511520f, 0.00368080f, 0.03191215f, 0.08454141f, 0.06242229f, -0.05276537f, 
    0.17154258f, -0.05055013f, -0.17529060f, -0.02283977f, -0.12849906f, -0.06435209f, 0.12928055f, 0.12460295f, 
    0.08668651f, 0.06942674f, 0.11173125f, -0.01802920f, -0.02134552f, -0.04831096f, 0.03341192f, 0.08010036f, 
    0.20369986f, 0.09627590f, 0.18644081f, 0.10811046f, 0.24663529f, -0.92401344f, -0.75093311f, -0.18910879f, 
    0.64242256f, -0.23908198f, 0.22479559f, 0.22135070f, 0.07277755f, 0.05323294f, 0.01584754f, -0.04465974f, 
    0.07401448f, 0.13102086f, 0.08463271f, 0.01681363f, 0.05744084f, -0.10848989f, -0.22191073f, -0.31743452f, 
    0.40737474f, 0.06351466f, -0.15501024f, -0.08764597f, -0.19861685f, 0.23079634f, -0.19713023f, 0.15352415f, 
    0.08625574f, -0.10144997f, -0.04135028f, 0.09458385f, 0.12877183f, 0.15048510f, -0.02858690f, 0.07775029f, 
    0.02687450f, 0.01222452f, 0.04178385f, 0.20225197f, 0.26755059f, -0.43070313f, -0.32345107f, -0.37237406f, 
    -0.11245217f, -0.08043154f, -0.29206347f, -0.11757118f, -0.18811885f, -0.27583331f, 0.07707955f, -0.03313456f, 
    0.04746641f, 0.11310352f, 0.13766909f, 0.07790753f, 0.08433370f, 0.17604667f, -0.08911069f, -0.31109080f, 
    -0.71159321f, 0.05522719f, 0.27850211f, 0.10168562f, -0.19812055f, -0.07775705f, 0.06943496f, -0.09222913f, 
    0.06904362f, 0.00436269f, -0.06916773f, 0.05497432f, -0.06277965f, -0.09892645f, -0.08221930f, 0.00078551f, 
    0.11060853f, 0.10925816f, -0.05534758f, 0.04476221f, -0.34026057f, -0.80334121f, -1.39210975f, -0.66628909f, 
    0.17218953f, 0.08664374f, 0.18809579f, 0.02129509f, 0.16358615f, 0.14099428f, 0.05176938f, -0.11947428f, 
    0.02302501f, 0.07492012f, 0.02387263f, 0.08033235f, 0.04003750f, 0.01748428f, 0.02433435f, -0.05522235f, 
    1.04146147f, 0.36501086f, 0.20772080f, -0.06412608f, -0.19716507f, 0.32760158f, 0.01337244f, -0.06484586f, 
    0.02150796f, -0.38393885f, 0.00835063f, 0.01385931f, 0.01920313f, -0.02548720f, 0.00763320f, 0.17026919f, 
    -0.15717715f, -0.31852394f, -0.03080105f, -0.23318663f, 0.62432164f, -0.01958820f, 0.03262824f, -0.04056924f, 
    -0.28516066f, 0.00162726f, -0.29067683f, -0.26035526f, -0.03037412f, -0.14318576f, 0.10336088f, 0.03910224f, 
    0.08411179f, -0.14418221f, 0.05439031f, -0.02643973f, 0.14751518f, 0.19607422f, -0.02100613f, 0.29650405f, 
    0.02645849f, 0.01767810f, -0.05769457f, 0.20926623f, 0.30798495f, -0.19202136f, -0.01082703f, -0.21212493f, 
    -0.09004387f, -0.33068848f, -0.26161188f, -0.03330005f, 0.04014804f, -0.08636052f, 0.07618450f, 0.07435235f, 
    -0.08448241f, -0.16574034f, -0.16924982f, 0.00060041f, -0.33783630f, -0.28229952f, -0.66153955f, -0.09297953f, 
    0.44256720f, 0.08536430f, 0.16343027f, 0.24512596f, 0.04602941f, -0.02215417f, -0.08636434f, -0.01087783f, 
    0.00608751f, 0.12818129f, -0.00768043f, -0.15182833f, 0.20755592f, -0.00609020f, 0.03879336f, 0.18435743f, 
    -0.04712004f, 0.05677849f, 0.06122598f, 0.50796729f, -0.18897872f, -0.27217647f, 0.33836114f, -0.73388791f, 
    -0.20878853f, -0.19779585f, 0.07137871f, -0.13499658f, 0.10343739f, 0.09701841f, 0.13048880f, 0.22944723f, 
    0.10689547f, -0.08253432f, -0.04944832f, -0.02166909f, -0.22779024f, 0.21706042f, -0.13476452f, -0.37534940f, 
    0.03171556f, 0.05351970f, -0.18037689f, 0.21519011f, -0.38636139f, 0.17422125f, -0.13531445f, 0.20246859f, 
    -0.33482581f, -0.04930438f, 0.01793093f, 0.03553578f, 0.13787062f, 0.01375995f, -0.04033395f, 0.18863431f, 
    -0.17203501f, 0.08685549f, 0.17326552f, -0.00312992f, 0.49684134f, 0.00056704f, -0.01962643f, 0.09561023f, 
    -0.00482370f, -0.15023348f, 0.14032139f, 0.23499750f, 0.21472661f, 0.03191860f, -0.20679702f, 0.23643287f, 
    -0.01961167f, -0.00758245f, -0.08463068f, 0.17597276f, -0.06137408f, -0.26129919f, 0.39441091f, 0.04966542f, 
    -0.48968127f, -0.01244207f, -0.21338171f, -0.04581707f, 0.04956568f, 0.14362365f, 0.05238961f, 0.03029310f, 
    0.07795063f, -0.01316568f, -0.08473832f, 0.11186734f, -0.07945820f, -0.11144351f, -0.02539123f, -0.00138991f, 
    -0.72395259f, 0.20827568f, -0.22202004f, 0.44850194f, 0.35007745f, -0.12381396f, 0.22924930f, -0.03512640f, 
    -0.25638360f, -0.34107506f, 0.16917577f, 0.20546006f, -0.04710102f, -0.40254876f, 0.08868855f, 0.01701803f, 
    -0.06813426f, -0.12973922f, 0.05047104f, 0.15372139f, 0.18915243f, -0.07777347f, 0.51249117f, 0.18323646f, 
    -0.51441413f, 0.16844425f, -0.20504589f, -0.32055998f, -0.17470802f, -0.01673066f, 0.08685595f, 0.14493798f, 
    0.05376134f, 0.08713076f, -0.00276117f, -0.05467239f, -0.09722167f, -0.00848913f, -0.02958168f, -0.06779106f, 
    -0.36646247f, 0.21717191f, -0.11874099f, 0.49705252f, 0.15742786f, -0.07686229f, -0.01003361f, -0.27639604f, 
    -0.03892744f, -0.06919692f, 0.06550267f, -0.07204399f, -0.15059838f, -0.03439031f, -0.01170903f, 0.04820409f, 
    -0.08499456f, -0.10757154f, -0.06310593f, -0.07905970f, 0.43952385f, -0.20545715f, -0.03757821f, 0.58250022f, 
    -1.37380624f, 0.01281456f, -0.25929919f, -0.25925523f, 0.42847925f, -0.22001353f, -0.05674168f, 0.01366477f, 
    -0.02545600f, 0.03277730f, -0.11097119f, 0.11901713f, 0.18651713f, 0.18498604f, -0.01426800f, 0.21350637f, 
    -0.42812219f, 0.01131805f, -0.38920182f, 0.17156351f, -0.16974886f, -0.17206924f, -0.01579934f, -0.01667118f, 
    -0.05502356f, -0.04614776f, -0.00412652f, -0.06147832f, 0.03075553f, 0.05172211f, -0.12891078f, -0.06918837f, 
    0.07905498f, -0.09679478f, 0.06702289f, -0.04564432f, -0.21708283f, -0.29792896f, -0.13484086f, 0.19466576f, 
    -0.19093330f, -0.06740736f, -0.30586296f, 0.11982229f, -0.09171832f, 0.18929054f, 0.02956567f, 0.06660151f, 
    0.06557249f, 0.08661491f, -0.07922003f, -0.08177928f, 0.07115802f, 0.25896502f, 0.21869271f, 0.23998937f, 
    -0.01062832f, -0.13337657f, -0.27114019f, -0.52003103f, 0.32199633f, 0.18380806f, 0.11704704f, 0.23333640f, 
    -0.04654843f, 0.17932265f, 0.05400259f, 0.02204253f, 0.00824893f, 0.12710574f, 0.07699169f, 0.00483859f, 
    0.02311474f, 0.02494285f, -0.08088186f, 0.09263904f, -0.50700498f, -0.01934838f, 0.54725289f, 0.55300856f, 
    -0.85446101f, 0.35806242f, -0.64205807f, 0.02155102f, 0.04852450f, 0.23988783f, -0.01208943f, -0.05862850f, 
    -0.04227060f, -0.02691354f, 0.05025953f, -0.07585385f, -0.04215965f, 0.02378282f, -0.03066084f, -0.05307914f, 
    -0.38290337f, 0.22432713f, -1.38845456f, 0.16771908f, -0.24628417f, 0.17474520f, -0.05903101f, 0.14831789f, 
    -0.21754581f, 0.09507027f, 0.08367214f, -0.14498787f, 0.03388607f, -0.00744165f, -0.15868063f, 0.08899335f, 
    -0.11094288f, 0.11161478f, 0.17884988f, 0.07333667f, 0.33362576f, -0.49060076f, -0.47845283f, -0.06960505f, 
    -0.20753354f, 0.15497114f, 0.24439770f, 0.03396866f, -0.14869311f, 0.12418114f, -0.02601054f, -0.10414408f, 
    -0.14379655f, -0.18227035f, -0.26145703f, 0.23608255f, 0.04238876f, -0.34931493f, -0.28500417f, -0.13576724f, 
    0.07200777f, -0.27717757f, 0.40831038f, 0.07022566f, -0.05976761f, 0.13968468f, 0.07377422f, 0.17895840f, 
    -0.17727439f, 0.12140331f, -0.14546588f, 0.11810032f, -0.10551360f, 0.21373747f, 0.11409066f, -0.13999075f, 
    0.02173241f, 0.14391454f, 0.12776864f, 0.38072330f, -0.04004752f, -0.38572884f, 0.10771587f, -0.32319057f, 
    -0.03862299f, -0.31506568f, 0.01172650f, -0.04608198f, -0.01079202f, -0.27213281f, -0.12015229f, 0.08030451f, 
    -0.13214776f, 0.00535849f, 0.03735543f, 0.01898688f, -0.32465270f, -0.16390862f, -0.37756848f, -0.18904877f, 
    0.40590677f, 0.30873534f, 0.37570933f, -0.06508888f, 0.09473550f, 0.35402161f, -0.24779254f, 0.01702712f, 
    -0.00283466f, -0.03575001f, -0.38579622f, 0.16804166f, -0.10190053f, -0.03901208f, -0.03436477f, -0.07796565f, 
    -0.11324183f, -0.03404472f, -0.03434163f, -0.12274378f, 0.25494725f, -0.10321243f, 0.10776798f, 0.60668093f, 
    -0.37236649f, -0.15694992f, -0.01749476f, 0.36523297f, -0.11091699f, 0.00483366f, 0.04613962f, -0.08889553f, 
    0.01188885f, 0.15730517f, 0.04623661f, 0.02878188f, 0.08116544f, 0.21774444f, -0.04486430f, 0.12307672f, 
    -0.13240568f, -0.73565674f, 0.14026682f, -0.39814249f, -0.82332140f, 0.11483938f, -0.23073468f, -0.19680607f, 
    -0.12668425f, -0.18642564f, -0.02212952f, 0.06670374f, -0.31697318f, 0.08533583f, -0.03603732f, 0.08401883f, 
    0.02756141f, 0.03245603f, -0.12802033f, -0.42445296f, -0.67700940f, 0.17401525f, -0.20480809f, 0.06402084f, 
    0.33362764f, -0.05705962f, 0.24569938f, 0.00106763f, 0.01237172f, 0.08073391f, -0.15632756f, -0.02214800f, 
    0.12086326f, 0.02616240f, -0.01598513f, 0.12513806f, 0.19192332f, -0.09299419f, 0.10082167f, 0.30814302f, 
    0.54986453f, -1.00606883f, 0.48124585f, -0.75859833f, -0.46017915f, -0.25455940f, -0.12928592f, 0.24012983f, 
    0.05316165f, -0.10188545f, 0.21194626f, 0.04008838f, -0.02981636f, 0.04601149f, 0.08434091f, 0.00899305f, 
    -0.11496980f, 0.22283801f, 0.00875027f, -0.35149249f, -0.14537804f, -0.09461337f, 0.01577117f, -0.00934009f, 
    -0.08124737f, 0.00054366f, 0.16860344f, -0.34659380f, 0.15730421f, 0.05944372f, -0.00152200f, 0.14929895f, 
    -0.02486737f, -0.03421620f, -0.20792712f, -0.04697023f, 0.02636208f, -0.00134784f, 0.14887357f, 0.16600731f, 
    0.52845401f, -0.20685713f, 0.48575309f, -0.35670170f, -0.02255072f, 0.08035026f, 0.02428617f, -0.07853060f, 
    0.02026549f, 0.11742296f, -0.22702774f, 0.17464857f, 0.06978513f, 0.12180033f, -0.04475808f, -0.17250887f, 
    0.13393521f, 0.07141709f, 0.09154840f, 0.05491509f, -0.54411060f, 0.14736135f, -0.51536536f, 0.12745047f, 
    -0.09288274f, 0.07627367f, -0.04283043f, 0.03698621f, 0.01469334f, 0.07740813f, -0.05470044f, 0.10261473f, 
    -0.17671265f, -0.11098729f, -0.39676198f, -0.00052508f, -0.27731627f, -0.12848100f, -0.20509662f, -0.25238180f, 
    0.50959164f, -0.35938448f, 0.62054557f, 0.35279807f, 0.20386492f, -0.19826342f, -0.16537197f, 0.10852114f, 
    0.03851088f, 0.05684399f, -0.15767211f, -0.01757254f, -0.10294645f, 0.15134484f, 0.23321979f, 0.03804295f, 
    -0.25415358f, 0.12563972f, 0.10377554f, 0.16124520f, -0.27326983f, -0.16175084f, -0.81467235f, -0.22688954f, 
    0.18905182f, -0.02393476f, 0.08668736f, 0.33500558f, -0.13915133f, -0.14934775f, -0.03060297f, 0.17400436f, 
    -0.06862416f, 0.16356790f, 0.02227322f, 0.20501898f, -0.04070563f, -0.05516073f, -0.24933267f, -0.29641718f, 
    -0.07311834f, -0.17388369f, 0.54723525f, -0.11630290f, -0.27008009f, -0.08667835f, -0.13304323f, -0.26299378f, 
    -0.00961821f, -0.07305507f, -0.19085047f, 0.00213290f, 0.16918451f, -0.01837080f, 0.02587132f, -0.08165185f, 
    0.08098016f, 0.16092062f, -0.02782781f, 0.04220840f, -0.46027440f, 0.09732035f, 0.07597697f, 0.11126371f, 
    0.13810073f, -0.19135432f, -0.05952850f, -0.40270558f, 0.18444839f, -0.10644305f, 0.07826158f, -0.01803888f, 
    -0.09578113f, -0.02037359f, 0.18119554f, 0.04650582f, 0.01089256f, 0.10617615f, -0.00753535f, -0.10629299f, 
    0.13503508f, -0.18904382f, -0.01967366f, -0.09570572f, 0.41615316f, -0.30659834f, 0.07929489f, 0.11515446f, 
    -0.09181549f, -0.24112995f, -0.12749943f, 0.09365320f, -0.03516103f, -0.07428266f, 0.04071538f, 0.20522800f, 
    -0.28698435f, -0.19538583f, -0.24977145f, -0.22156557f, -0.93000424f, -0.09867467f, -0.93749785f, 0.59148008f, 
    -0.36121053f, -0.00464142f, -0.16820264f, 0.46388257f, 0.50723439f, 0.37619695f, -0.44931793f, 0.14310099f, 
    -0.08037557f, -0.07060460f, 0.01050747f, 0.12624267f, -0.16363634f, 0.13664557f, 0.47881570f, 0.40458283f, 
    -0.51803339f, -0.06606499f, -0.25794804f, 0.09756029f, -0.09656945f, 0.09577853f, 0.01998583f, 0.25523105f, 
    -0.11978050f, 0.12098116f, -0.05734713f, 0.06305450f, 0.04015917f, -0.02022736f, -0.06902887f, 0.12848420f, 
    -0.18382353f, -0.22035009f, -0.19020426f, -0.27364692f, 0.50371474f, -0.17474218f, 0.18041389f, 0.17308483f, 
    0.04149387f, -0.04262421f, -0.03719381f, 0.00689787f, -0.13903438f, -0.23170510f, -0.01234481f, -0.07121461f, 
    -0.04318063f, -0.11280411f, -0.01473571f, 0.31398824f, -0.10874711f, -0.00783804f, 0.10860550f, -0.03263041f, 
    -1.42634082f, 0.33863148f, -0.66454881f, 0.51560646f, -0.34856260f, -0.07659127f, 0.16741557f, 0.14323618f, 
    -0.32635626f, 0.42550749f, -0.12451777f, -0.11045064f, 0.00361435f, 0.15410778f, -0.00258059f, 0.01228251f, 
    -0.08796886f, 0.19276407f, 0.11587618f, 0.00530642f, 0.21080902f, -0.07824828f, 0.52785194f, 0.06178471f, 
    0.02970029f, -0.04077155f, 0.34599587f, -0.07738742f, 0.44065723f, 0.06178152f, -0.24879120f, 0.30660063f, 
    -0.18312453f, -0.09097442f, 0.17038029f, 0.15758966f, 0.13878241f, 0.05625772f, 0.12583844f, -0.25014448f, 
    -0.52690059f, -0.15671554f, -0.46066079f, -0.11650668f, 0.19857191f, 0.01764001f, 0.15853779f, -0.03626808f, 
    -0.05023677f, 0.00871896f, -0.38139376f, -0.01611021f, -0.07568038f, 0.25037333f, 0.05865751f, 0.13554864f, 
    0.16658598f, -0.08136912f, -0.23684551f, -0.04393620f, -0.12723492f, -0.49149063f, -0.35007867f, 0.28901204f, 
    0.01468223f, -0.14374156f, -0.25455990f, -0.03306611f, -0.06997254f, 0.00675511f, -0.08447021f, 0.04350159f, 
    -0.10790870f, -0.16573657f, -0.03960355f, -0.00386056f, -0.14464396f, 0.05091192f, -0.10904630f, -0.32112548f, 
    -0.20535122f, 0.02486948f, 0.20843078f, -0.42648754f, 0.26536429f, 0.08324959f, 0.27591681f, 0.18189263f, 
    0.20522924f, 0.14300312f, -0.10251981f, 0.13924800f, 0.07018054f, -0.06029031f, -0.11701424f, 0.04347422f, 
    0.08717342f, 0.02734579f, -0.30283904f, 0.02172191f, -0.44844320f, -0.46778843f, -0.39376390f, 0.24863587f, 
    -0.09033784f, -0.09383044f, -0.19410715f, -0.02382401f, -0.07233071f, -0.01806644f, -0.04992342f, -0.07753818f, 
    -0.01711210f, -0.30930197f, 0.02844916f, 0.07037715f, -0.08240587f, -0.13172406f, -0.04053733f, -0.01183944f, 
    -0.20957538f, -0.24310879f, -0.20178662f, -0.04372416f, 0.31048220f, 0.08594770f, 0.12305063f, -0.06835420f, 
    -0.11075144f, 0.15816130f, -0.09055556f, -0.08785299f, 0.01102250f, -0.06638051f, -0.03450011f, -0.06994916f, 
    -0.20157824f, -0.10808836f, 0.00543981f, -0.04810534f, -0.42899969f, -0.35942560f, 0.22729598f, -0.03327356f, 
    -0.50610614f, 0.09921049f, 0.02958537f, -0.10430835f, -0.02483855f, -0.10190828f, -0.10321345f, -0.04851358f, 
    0.30042562f, 0.14487445f, 0.16799194f, 0.09476463f, -0.06487529f, 0.09269783f, 0.07871369f, 0.11701754f, 
    -0.17050758f, -0.47183114f, 0.30220842f, -0.44054210f, 0.22502472f, 0.48120087f, 0.13788237f, 0.29854575f, 
    0.22850868f, 0.01864273f, -0.01693358f, 0.00352836f, 0.16126467f, 0.15602554f, 0.13868511f, -0.03731396f, 
    0.23167866f, -0.31461221f, -0.01551878f, -0.17514905f, 0.33253986f, -0.74932390f, -0.15533248f, -0.58706617f, 
    0.48133227f, -0.35970080f, -0.58311051f, -0.20493048f, 0.20571572f, -0.48243493f, -0.03858211f, -0.00343425f, 
    0.15993083f, -0.16553387f, -0.12626080f, 0.16024150f, 0.00237332f, 0.01431682f, 0.23417875f, -0.18781787f, 
    0.43141410f, 0.25646824f, 0.11026292f, 0.35657784f, 0.01294268f, -0.05948596f, 0.15288657f, -0.05180543f, 
    0.16072083f, 0.03082906f, -0.13082710f, 0.09056938f, -0.09974335f, -0.04744355f, 0.03552914f, 0.11472515f, 
    0.07511970f, 0.08782738f, 0.03011324f, 0.18738936f, 0.52919990f, -0.45132384f, 0.32244706f, -0.33657432f, 
    -0.23390017f, 0.03395710f, -0.09413186f, -0.15252496f, 0.07092168f, 0.00951956f, 0.07377274f, 0.15692820f, 
    0.22928432f, -0.13801824f, 0.00445235f, 0.11321948f, 0.05153689f, 0.07828295f, 0.17465208f, 0.02391194f, 
    0.26674679f, -0.62799537f, 0.46127874f, -0.41843116f, 0.18781112f, 0.17400567f, -0.00223670f, 0.16821411f, 
    0.10641378f, -0.01804031f, -0.09398163f, 0.12952188f, 0.00311856f, -0.00087417f, 0.01511124f, -0.07158658f, 
    0.23534313f, 0.08221956f, -0.18137020f, 0.32233793f, 0.09933455f, 0.68883097f, 0.87748158f, 0.76120460f, 
    -0.69474036f, -0.18424699f, -0.35419309f, 0.40018243f, -0.11383680f, -0.10533297f, -0.19013487f, -0.10460685f, 
    0.08020581f, 0.00816876f, -0.00039025f, -0.11207821f, -0.23835465f, -0.05852672f, 0.15674645f, -0.27041620f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.29713815f, 0.17539513f, 0.04175233f, -0.12213357f, -0.13276625f, 0.06791739f, 0.01963685f, -0.21391329f, 
    0.08532440f, 0.02096352f, -0.00090797f, -0.07399938f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
