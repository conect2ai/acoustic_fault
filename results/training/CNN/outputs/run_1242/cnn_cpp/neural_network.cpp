#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18873228f, -0.03841210f, 0.40813649f, 0.05712564f, -0.29719433f, 0.10466862f, -0.22948283f, 0.39174387f, 
    -0.19916309f, 0.01940807f, 0.52396637f, -0.29947412f, -0.32149795f, 0.56706309f, -0.58843952f, -0.08560252f, 
    -0.26952016f, 0.17754546f, -0.22153254f, 0.35358870f, 0.05552416f, -0.12978886f, 0.23391472f, -0.07223975f, 
    0.01244330f, -0.47639257f, -0.18971235f, -0.77004272f, -0.75463021f, -0.44303799f, 0.03215634f, -0.18174456f, 
    -0.18158372f, 0.08454098f, 0.27775091f, 0.39480194f, 0.26341602f, 0.10944788f, 0.05434936f, 0.45957488f, 
    -0.17387363f, 0.00640368f, -0.33094972f, -0.49022505f, 0.11734340f, 0.13504367f, -0.38413402f, 0.12876478f, 
    0.31726882f, 0.42342797f, -0.52248639f, -0.37395796f, 0.08316754f, 0.05479192f, 0.03551963f, -0.01192208f, 
    0.31961143f, 0.19141024f, -0.19944803f, -0.02428408f, 0.12722671f, -0.28984708f, -0.08922672f, 0.42553324f, 
    0.14104041f, -0.42669666f, 0.00970635f, -0.42734888f, 0.02131471f, -0.01873818f, 0.28990185f, 0.19670229f, 
    0.43565348f, 0.26824242f, 0.06605314f, -0.36699361f, -0.47787037f, 0.16249838f, 0.30972862f, 0.55494493f, 
    0.75560963f, 0.32881361f, 0.13725658f, 0.23359922f, 0.44883052f, -0.14568575f, -0.10092760f, -0.33825168f, 
    -0.15917411f, 0.20455347f, -0.21984155f, -0.05908096f, -0.30000693f, 0.16601303f, -0.21732639f, -0.20434807f, 
    -0.11731087f, 0.32959405f, 0.25376865f, -0.11730643f, 0.04191866f, 1.11360765f, 0.74573594f, -0.21054870f, 
    -0.60798943f, -0.70601869f, -0.51021749f, -0.26122490f, -0.24206215f, 0.11974218f, 0.01448114f, -0.24535219f, 
    -0.20012093f, 0.68842083f, -0.07940922f, -0.18461363f, -0.16900390f, -0.16998388f, 0.10085149f, 0.05332008f, 
    0.33286020f, -0.04692385f, -0.13691182f, -0.47749752f, -0.26039484f, -0.36020344f, 0.13538612f, -0.19044808f, 
    0.22010081f, -0.41349849f, -0.03725355f, -0.32646450f, 0.26477677f, -0.20649867f, -0.09542702f, 0.29641023f, 
    0.09295015f, 0.22088091f, -0.20294456f, 0.12510133f, 0.01606344f, 0.03405241f, -0.14577426f, -0.34265086f, 
    -0.02436750f, 0.48904309f, 0.53066510f, 0.30222347f, 0.27132100f, 0.25846854f, -0.13724853f, 0.19578320f, 
    0.36546761f, 0.39770755f, 0.22115779f, 0.33751354f, 0.36824596f, 0.04201732f, -0.08855481f, 0.02199555f, 
    0.04275891f, 0.31071994f, -0.05108478f, -0.39027902f, -0.06665015f, -0.15122126f, -0.10498259f, -0.01044243f, 
    0.03849513f, 0.07049847f, 0.10271242f, -0.16855800f, -0.28187591f, -0.25616571f, -0.22287233f, -1.25371945f, 
    -0.24416161f, -0.75287133f, -1.34012151f, -1.02903545f, 0.64817160f, 0.33124226f, -0.08239724f, 0.02385919f, 
    0.50151569f, -0.07361399f, -0.02143066f, -0.53167087f, -0.49577239f, -0.34307143f, -0.05541879f, 0.25665861f, 
    0.15417659f, 0.06949475f, 0.21153727f, 0.05588612f, -0.02758750f, -0.06882237f, 0.27679816f, -0.04200929f, 
    -1.37067938f, -0.95875400f, -0.55571240f, -0.18845713f, 0.27628222f, -0.11408397f, -0.57879293f, -0.74972236f, 
    -0.73561299f, -0.56117022f, -0.40021071f, -0.25725210f, -0.27487916f, 0.67521054f, -0.58889079f, 0.09035132f, 
    -0.20367429f, -0.10586698f, -0.05035618f, -0.10044728f, -0.13014784f, -0.00420499f, -0.13207121f, -0.20075345f, 
    -0.24099474f, 0.55356890f, -0.08192610f, 0.27383372f, 0.12154740f, 0.60331184f, 0.06735607f, -0.31546986f, 
    -0.51195163f, -0.19629344f, -0.10454015f, -0.21909431f, -0.02399497f, 0.01200129f, -0.27976507f, -0.19372116f, 
    -0.12692961f, 0.10755604f, 0.19535461f, 0.29773900f, -0.03950442f, 0.19313779f, -0.23746173f, -0.21657917f, 
    -0.06155918f, 0.41123557f, -0.10755336f, -0.18734919f, 0.14461386f, 0.14406919f, -0.00648705f, 0.44006738f, 
    0.28252313f, -0.17307936f, 0.46796593f, 0.18392493f, 0.55207378f, -0.20408511f, -0.11357749f, 0.20181569f, 
    -0.35635576f, -0.03932790f, 0.02838344f, 0.06392182f, -0.18428299f, -0.18421863f, 0.26638275f, 0.33056659f, 
    0.10099336f, -0.01884276f, -0.00595773f, -0.72108388f, 0.34525958f, 0.47600529f, 0.91401899f, 0.04299121f, 
    0.55844808f, -0.85054153f, -0.47749150f, -0.13812119f, 0.06379855f, -0.25325388f, -0.07237802f, -0.29063505f, 
    0.18232739f, 0.23856589f, -0.28774929f, 0.10684634f, 0.04854748f, 0.21692619f, 0.02805184f, -0.03448723f, 
    0.07737671f, 0.00366605f, -0.11669250f, -0.04423900f, 0.89019513f, 0.73498714f, 0.22212879f, -0.69773322f, 
    -0.65748787f, 0.35407129f, 0.29877141f, 0.13374789f, -0.55568868f, -0.08266923f, 0.14215225f, -0.06976960f, 
    -0.15234828f, -0.33806276f, 0.09789993f, -0.14953342f, -0.23309638f, 0.06767288f, 0.14036717f, 0.18037137f, 
    0.34638542f, 0.22692139f, -0.23438659f, -0.40146345f, -0.04770296f, 0.84577852f, -0.26943269f, -0.14451091f, 
    0.36070094f, -0.45210943f, 0.07795592f, 0.01788051f, -0.28213102f, 0.09830586f, -0.08524629f, -0.04683030f, 
    -0.10289849f, -0.12596150f, 0.23324192f, -0.12726903f, 0.04315783f, 0.06769985f, -0.13307667f, -0.07559333f, 
    -0.40783495f, -0.28075600f, -0.48009729f, -0.43433779f, -0.53643847f, -0.72648346f, 0.93177921f, -0.24336626f, 
    -0.22395159f, 0.17364211f, -0.64737856f, 0.30235073f, 0.13518406f, -0.00482295f, 0.06629283f, 0.03122415f, 
    0.11581106f, -0.28737414f, -0.19733058f, 0.24082546f, 0.24533977f, -0.26913530f, 0.04682902f, -0.12194133f, 
    -0.27132308f, -0.01226844f, 0.40914270f, -0.32408950f, -0.10673768f, 0.24058479f, -0.00862201f, 0.78527963f, 
    -0.13717729f, -0.14227711f, 0.37609774f, 0.03805790f, 0.00033250f, 0.93150622f, -0.47043064f, -0.83357602f, 
    -0.80214876f, 0.02377979f, 0.34692192f, -0.14153923f, 0.06412403f, 0.28029627f, -0.13467872f, -0.49588510f, 
    0.15099639f, -0.02214714f, 0.19617915f, -0.14055012f, -0.27318698f, 0.01033145f, 0.39703861f, -0.16578439f, 
    0.39335689f, 0.80521727f, -0.01331078f, -0.13924880f, -0.68931621f, -0.58836967f, -0.56006837f, 0.23729850f, 
    -0.18532434f, -0.68390566f, 0.06135105f, 0.18115652f, -0.31171665f, 0.22308020f, -0.47853211f, 0.06501392f, 
    -0.28949958f, -0.44871312f, -0.60537893f, -0.27160442f, 0.08469956f, -0.02250860f, -0.20902567f, -0.01167218f, 
    0.34721425f, 0.04065765f, 0.08065914f, 0.29306707f, 0.17904772f, -0.21902092f, -0.39837676f, 0.40335575f, 
    -0.12949213f, 0.27866542f, 0.21434073f, 0.04284049f, -0.01749644f, 0.11290789f, 0.01268710f, 0.13028452f, 
    -0.17654790f, -0.04043218f, -0.35028434f, -0.18450968f, 0.28351381f, -0.21899803f, -0.08352222f, 0.36434188f, 
    0.13887489f, -0.12086254f, -1.11076021f, -0.87611920f, -0.77317291f, 0.13959025f, 0.41610298f, 0.21953563f, 
    0.58335161f, 0.41660118f, 0.41542968f, 0.10119332f, 0.37826091f, 0.26474723f, 0.16006279f, 0.30617803f, 
    -0.23302178f, -0.24153882f, -0.13265534f, 0.01178497f, -0.24004784f, 0.13610235f, -0.27010170f, -0.32809716f, 
    -0.11048931f, 0.20875673f, -0.23298599f, -0.13560121f, 0.32090065f, 0.20645845f, 0.03141391f, 0.35233980f, 
    -0.67014605f, -0.36055496f, 0.02268551f, 0.46881124f, 0.34190631f, 0.34963757f, -0.17080377f, -0.28139162f, 
    -0.29482323f, 0.35157686f, 0.16440830f, -0.04905962f, -0.06663605f, -0.10460407f, -0.10167349f, -0.02074175f, 
    -0.14819932f, 0.17222209f, 0.33668295f, -0.41629446f, -1.08267546f, -0.86211461f, -0.10025387f, -0.10970210f, 
    0.21739337f, -0.70961964f, -0.85991096f, 0.01325077f, -0.64630842f, -0.27144045f, 0.00920975f, -0.42250049f, 
    0.13266405f, -0.24433704f, -0.29599884f, -0.34399134f, -0.46419781f, -0.49539429f, 0.02952587f, -0.09548913f, 
    0.07542413f, -0.14750816f, -0.36832580f, 0.21971658f, -0.00024143f, 0.10444575f, -0.88188344f, -0.37200415f, 
    0.15017641f, -0.42906001f, -0.32837853f, -0.24093464f, 0.24852730f, 0.35240334f, 0.33526975f, 0.25094149f, 
    -0.17648469f, -0.21543449f, -0.30496535f, 0.27917841f, -0.44019783f, -0.18891442f, -0.16921701f, 0.19761349f, 
    -0.31952536f, -0.62102360f, -0.48011801f, -0.45310000f, -0.61584723f, -0.45950091f, 0.52682030f, 0.57893360f, 
    -0.48295903f, -0.34193763f, -1.15100384f, -0.04205645f, -0.38181865f, 0.24493057f, 0.52408034f, 0.47647572f, 
    -0.01295269f, 0.13936526f, 0.38839579f, -0.21198130f, -0.39659089f, -0.27701578f, -0.18596971f, 0.36537856f, 
    0.18234387f, 0.00261409f, -0.04400159f, -0.03308784f, -0.23608401f, 0.11271147f, 0.40386143f, 0.26387137f, 
    0.23104447f, 0.45829186f, 0.32451701f, 0.52852142f, 0.00366893f, -0.27487725f, -0.11333780f, -0.05680512f, 
    0.25699091f, -0.08257145f, -0.11992167f, 0.19303694f, 0.09198388f, 0.03878129f, 0.07352384f, -0.19849785f, 
    0.15031560f, 0.03789598f, -0.21588340f, 0.13188644f, -0.08928922f, 0.03199317f, 0.11982993f, -0.18517244f, 
    -1.88961399f, 0.36576292f, 0.16171582f, 0.04370571f, 0.31467387f, -1.13971114f, -0.33946249f, 0.46977207f, 
    0.41306210f, 0.46055472f, 0.31116611f, 0.17610569f, 0.04942486f, 0.11632050f, -0.04888219f, -0.02832903f, 
    -0.44332722f, -0.17836313f, -0.08698130f, -0.46651390f, -0.09406448f, 0.03579101f, 0.11275115f, 0.07498708f, 
    -0.07941081f, 0.17246465f, 0.48288298f, -0.24174887f, -0.54513717f, -0.99126881f, -0.13746554f, -0.25632501f, 
    -0.31838104f, -0.79144651f, -0.53385341f, 0.71679646f, -0.65617818f, -0.04933459f, 0.01482130f, -0.04355348f, 
    0.03925127f, 0.46048251f, 0.14915836f, -0.28042176f, -0.39659986f, -0.22010040f, -0.40317896f, 0.05291099f, 
    -0.09034523f, -0.43944961f, 0.20415215f, -0.54840785f, -1.03967738f, -0.79985261f, -0.10171616f, -0.77969754f, 
    -0.84727067f, 0.06277588f, -0.87775409f, -0.75795293f, 0.17825073f, 0.49022678f, 0.62206358f, -0.20371993f, 
    -0.09323675f, 0.33700764f, 0.13197255f, -0.18189363f, -0.00992416f, 0.23460019f, 0.13488480f, -0.33473590f, 
    0.02380902f, 0.10623659f, 0.10845783f, 0.49529701f, 0.12959091f, 0.09328470f, -0.25027296f, -0.09994826f, 
    0.60701627f, -0.14162725f, -0.49406114f, -0.11397702f, 0.38959333f, 0.36195722f, -0.13932472f, -0.30428886f, 
    -0.26945636f, -0.04245012f, 0.14510395f, -0.12001758f, 0.25088364f, -0.11945088f, -0.41442642f, 0.01256428f, 
    0.28860602f, 0.15845698f, 0.10931435f, -0.48058224f, -1.16459668f, 0.80433965f, 0.74919295f, -1.04422104f, 
    -0.42447799f, -0.44430375f, 0.02708346f, 0.03231586f, 0.07506363f, 0.09231385f, -0.06620654f, -0.33553848f, 
    -0.54018801f, -0.59932148f, -0.54328400f, 0.19299473f, 0.32158741f, 0.27963209f, 0.34402898f, -0.20792465f, 
    0.02483879f, -0.07623696f, -0.32064074f, -0.44258410f, -0.43555269f, -1.35248625f, -0.18125163f, 0.15358466f, 
    -0.94602901f, -1.00540721f, 0.82147038f, 0.50420010f, 0.14276339f, 0.44424069f, 0.81295979f, -0.03517285f, 
    0.04855409f, 0.24184887f, -0.08701511f, 0.13092142f, 0.02610636f, -0.02444992f, -0.23851900f, -0.07029470f, 
    0.16168754f, -0.12771507f, 0.08365827f, 0.17979823f, -0.06537785f, -0.03984656f, 0.88863468f, -0.12096585f, 
    -0.48079616f, -0.35176861f, 0.59034669f, 0.10352418f, -0.41647243f, -0.16279076f, -0.59543061f, -0.48018932f, 
    -0.02925441f, 0.23958236f, -0.04278452f, 0.10665248f, 0.18968841f, -0.24196088f, 0.43114468f, 0.03993516f, 
    -0.19227199f, -0.02962451f, -0.22558135f, 0.20810208f, 0.22607434f, 0.20558831f, 0.23222579f, -0.65811652f, 
    0.02839680f, 0.10815256f, 0.35143983f, 0.31226063f, -0.50422317f, 0.21767712f, -0.18103050f, 0.55749077f, 
    0.19506495f, 0.09988859f, -0.17521878f, -0.35832462f, 0.19433446f, 0.16989458f, -0.27733392f, 0.14222571f, 
    0.11136778f, -0.43200433f, 0.10163260f, -0.10812610f, -0.09654290f, -0.18344837f, -0.03305233f, 0.33540562f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14260830f, 0.58594012f, 0.15553170f, 0.41743815f, 0.15570278f, -0.15995339f, 0.06124002f, -0.25686261f, 
    -0.70655900f, 0.22367379f, -0.25246716f, 0.30159050f, 0.56855977f, -0.06348550f, 0.45043436f, 0.18044388f, 
    0.20103002f, 0.52819544f, 0.04924179f, 0.49095717f, 0.15782565f, -0.06106936f, 0.35966253f, 0.04031834f, 
    0.16205743f, 0.15158284f, -0.02256121f, 0.61751842f, 0.09677187f, 0.18612523f, 0.12843986f, 0.51138395f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23056355f, -0.06633093f, 0.05391677f, 0.05438417f, -0.01033227f, -0.02587055f, -0.17075342f, 0.17293011f, 
    -0.03112903f, -0.13054027f, -0.17944166f, 0.04655125f, 0.36619404f, 0.02859810f, -0.02333890f, -0.23282644f, 
    0.02982478f, 0.17086926f, -0.20607212f, -0.19699228f, -0.10868473f, -0.10516237f, 0.03116832f, -0.05888241f, 
    -0.05797845f, -0.00736283f, 0.08228890f, 0.00052248f, 0.15327932f, 0.06507111f, -0.08132961f, -0.03475815f, 
    -0.14969042f, -0.09452395f, -0.14453734f, -0.17743452f, 0.05389715f, -0.30237937f, -0.18143876f, -0.00847891f, 
    0.04834608f, 0.04922624f, 0.11901175f, -0.02578267f, 0.09827369f, -0.07958384f, -0.03465996f, -0.11350336f, 
    -0.12363738f, 0.06998751f, -0.01359382f, 0.09565806f, 0.08006644f, 0.01649506f, 0.01126039f, -0.21151061f, 
    0.01717238f, 0.01059086f, -0.00465596f, 0.00659840f, 0.15529005f, 0.02431797f, 0.05329902f, 0.05381207f, 
    -0.14093706f, 0.23290424f, 0.00229047f, -0.21260214f, -0.01106766f, -0.07627048f, -0.05246212f, -0.13068484f, 
    -0.11902031f, -0.09429811f, -0.08055515f, 0.05125557f, 0.08053218f, 0.07620633f, 0.00961082f, 0.04131494f, 
    -0.08518174f, -0.05125201f, 0.18375063f, 0.13817841f, 0.34405562f, 0.11709262f, -0.25263572f, -0.21372481f, 
    0.10111015f, 0.38708973f, -0.04562339f, 0.14999995f, 0.04494138f, 0.04015753f, 0.04173622f, 0.03785888f, 
    0.72943157f, 0.24933285f, -0.12253174f, -0.34433964f, 0.07935866f, 0.34755191f, 0.21098731f, 0.09719415f, 
    -0.06263462f, -0.09581457f, -0.04761017f, -0.07239016f, -0.03053011f, 0.11784364f, -0.40358672f, 0.09306163f, 
    0.00791921f, -0.05672265f, -0.01566279f, 0.06669106f, -0.05940577f, -0.05799443f, 0.01784719f, -0.01150081f, 
    -0.02603792f, -0.06682039f, -0.09213489f, 0.04762226f, 0.00296114f, -0.00456792f, 0.06091152f, 0.02029879f, 
    0.01533593f, -0.03193462f, -0.19004510f, -0.33066401f, -0.24172939f, 0.20393923f, -0.07831369f, -0.32849500f, 
    0.02512575f, -0.09964152f, -0.01587028f, -0.09554193f, -0.04550439f, -0.08672498f, 0.04364803f, -0.02722099f, 
    -0.53553605f, -0.86662972f, -1.08994091f, 0.22668415f, 0.14769952f, 0.03327716f, 0.09917301f, -0.01473122f, 
    -0.09570550f, 0.00214876f, -0.06079564f, -0.13555206f, -0.15450124f, -0.22090073f, 0.00369697f, 0.05240866f, 
    -0.00458318f, -0.00662695f, -0.03597336f, -0.01073167f, 0.04747016f, 0.13691457f, 0.00379994f, 0.32007390f, 
    -0.47423452f, -0.46320555f, -0.37096879f, -0.14980404f, 0.07133735f, 0.02280299f, -0.04454117f, -0.03338535f, 
    -0.02973246f, -0.03610596f, -0.11412814f, -0.00799826f, 0.15891947f, -0.28073850f, -0.18549167f, -0.13347052f, 
    -0.19034867f, -0.55546349f, -0.13711305f, -0.16710086f, -0.07859551f, 0.04250036f, 0.14106047f, -0.00379085f, 
    0.03835194f, -0.05735991f, -0.12825413f, -0.19463974f, -0.20265517f, -0.06093827f, -0.08513362f, -0.20410624f, 
    -0.01796453f, -0.01964551f, -0.09636989f, -0.01892736f, -0.29176965f, -0.44651943f, 0.17967387f, -0.11098779f, 
    -0.01214075f, -0.05069526f, -0.01554626f, 0.08695295f, -0.08363683f, -0.05877481f, -0.10751612f, -0.19431892f, 
    0.42156744f, 0.15799943f, -0.01283011f, 0.06306633f, 0.09777695f, 0.09636904f, 0.09115264f, 0.05966202f, 
    -0.09471844f, -0.03095172f, -0.10409202f, 0.04338830f, -0.73153466f, 0.22855803f, 0.25022706f, -0.19272672f, 
    -0.03647481f, 0.06582991f, -0.04582680f, -0.04748163f, -0.00256121f, -0.16999161f, -0.10693512f, 0.03369671f, 
    0.49066949f, 0.28839213f, 0.06570899f, -0.33994710f, 0.15007204f, 0.11519694f, 0.02100493f, -0.02737786f, 
    -0.06544174f, -0.21003352f, -0.12073278f, -0.26902282f, -0.00660916f, 0.04024258f, 0.02124198f, -0.04191793f, 
    0.10391031f, -0.03769129f, 0.02251140f, -0.11080460f, -0.08438357f, 0.01767130f, 0.12244012f, 0.27791977f, 
    -0.03287747f, -0.53457671f, -0.09907155f, -0.07057697f, 0.03377701f, 0.05968174f, -0.15587151f, -0.40990463f, 
    0.01692171f, -0.24823919f, 0.18578392f, -0.07022471f, -0.22731265f, -0.07138707f, 0.12841319f, 0.03382586f, 
    0.04171288f, 0.02714894f, 0.03179999f, 0.02470252f, 0.01161391f, -0.03414691f, 0.02877186f, 0.10589473f, 
    -0.28954935f, 0.29857448f, 0.53089684f, -0.18787758f, -0.04105323f, 0.05119710f, 0.12560096f, 0.07896140f, 
    -0.08501526f, -0.08369422f, -0.10123599f, -0.00075882f, 0.13945970f, -0.08583128f, -0.25294027f, -0.17240778f, 
    0.20057093f, 0.12061068f, -0.29125240f, 0.00297435f, -0.03405379f, 0.11516973f, -0.00763616f, 0.01658281f, 
    0.45126894f, 0.30301493f, -0.35615221f, -0.20902984f, 0.06986803f, -0.16163084f, -0.07956501f, -0.00473876f, 
    0.03096523f, 0.00215169f, -0.01210610f, 0.03169810f, -0.31945527f, -0.19665115f, -0.31251964f, 0.07449528f, 
    0.00519534f, -0.08173684f, -0.02984085f, -0.05380402f, -0.13259794f, -0.02555007f, -0.02421570f, 0.06585416f, 
    -0.15985209f, 0.42117500f, -0.00569774f, 0.06898636f, -0.09066043f, 0.33144820f, -0.07539888f, 0.14885777f, 
    0.07950541f, 0.02177206f, -0.00452372f, -0.04104602f, -0.18189885f, -0.40263781f, 0.10191704f, -0.02603817f, 
    0.08223201f, 0.16424090f, 0.01368873f, 0.05842816f, 0.06470448f, 0.01223103f, -0.11249422f, -0.06692135f, 
    0.27048546f, 0.13871856f, -0.21933784f, 0.02542822f, -0.04618786f, -0.16116133f, -0.08814739f, -0.06074751f, 
    -0.03681660f, 0.03124784f, 0.00310745f, -0.11483852f, -0.20990047f, 0.04150881f, 0.24519983f, -0.28449991f, 
    0.01439766f, -0.02041837f, 0.09917882f, 0.01877144f, 0.04274882f, -0.04566518f, -0.13425018f, -0.27287850f, 
    0.07972308f, -0.01521388f, -0.27966839f, -0.35462525f, -0.04232014f, -0.09055015f, 0.17492685f, 0.05588183f, 
    -0.01238209f, -0.04328457f, 0.02184372f, 0.03464341f, -0.35916710f, -0.20914330f, -0.18631932f, -0.05667058f, 
    0.25761437f, 0.25113609f, 0.25164276f, 0.19813275f, 0.08513036f, 0.05458944f, 0.04509375f, -0.02181066f, 
    -0.07721231f, -0.04454627f, 0.04875781f, 0.03197231f, -0.08640190f, 0.02928157f, 0.15370224f, 0.13324365f, 
    -0.03985854f, -0.08889090f, 0.27389535f, -0.05421134f, 0.11328802f, 0.11886470f, 0.16398737f, 0.23070191f, 
    -0.12375166f, 0.03178929f, 0.03844639f, 0.02730157f, -0.02794820f, -0.04033395f, 0.10322306f, -0.21959490f, 
    0.14702716f, -0.18472819f, -0.17159928f, -0.40872428f, 0.23346375f, -0.22920245f, -0.04941344f, 0.18711859f, 
    0.11070593f, -0.12393091f, 0.19083753f, -0.14934382f, -0.13251112f, 0.01805698f, 0.05227824f, -0.04751847f, 
    0.16434626f, -0.05557585f, -0.09820041f, 0.14646898f, -0.24927363f, -0.04301817f, 0.04766007f, 0.05534053f, 
    0.17618050f, 0.12228123f, 0.16921446f, 0.19026408f, -0.01885751f, -0.03333179f, -0.09974095f, -0.01524993f, 
    0.09758046f, -0.15122676f, 0.09473093f, -0.10761347f, 0.57026488f, 0.34997869f, 0.10410827f, -0.29194841f, 
    -0.01945358f, 0.02241418f, -0.09111305f, -0.06463283f, -0.05904833f, 0.00679016f, -0.13180684f, -0.00959774f, 
    0.11326700f, 0.03502048f, 0.22437306f, 0.45056060f, 0.04290015f, -0.17169993f, 0.14372972f, -0.06518307f, 
    0.02735228f, -0.05754603f, 0.08423620f, -0.04071357f, 0.29524767f, 0.25146639f, -0.29954994f, -0.18369848f, 
    -0.17516826f, -0.06079119f, -0.14879578f, -0.14738233f, 0.01278121f, 0.01960892f, 0.05007619f, 0.01710163f, 
    0.08274263f, -0.00192966f, -0.00050529f, 0.08774681f, -0.10566752f, -0.02154512f, -0.03282561f, 0.05823524f, 
    0.01235877f, -0.00142249f, -0.00962986f, 0.05665959f, -0.20471828f, 0.09153067f, -0.26493451f, -0.16234687f, 
    -0.01970258f, -0.08662401f, -0.00453634f, 0.17336358f, -0.04560562f, -0.02268121f, 0.08927528f, -0.02136397f, 
    0.76236337f, -0.23367116f, 0.17434491f, -0.16852227f, 0.03221451f, -0.11489121f, -0.11919107f, 0.03485894f, 
    -0.08160004f, 0.00663325f, 0.04659870f, -0.10331757f, 0.08158598f, -0.01526394f, -0.00192146f, -0.05440120f, 
    -0.00418593f, -0.05770393f, -0.02589287f, -0.04820556f, -0.27884254f, -0.37982079f, -0.18327513f, -0.23948871f, 
    0.64828962f, 0.11241160f, 0.13631879f, 0.00375997f, -0.13775867f, -0.00673661f, 0.11471725f, -0.03748147f, 
    0.10319926f, -0.29029974f, 0.18100521f, -0.20608729f, 0.39118105f, -0.10721782f, 0.06283778f, 0.05495473f, 
    -0.20870700f, -0.11669853f, -0.08376332f, -0.09611738f, -0.02391982f, -0.05623119f, 0.09240596f, 0.11528827f, 
    0.05949537f, -0.46055105f, -0.02399321f, -0.37005407f, 0.04655031f, 0.01771698f, 0.00569733f, 0.00625685f, 
    -0.01458503f, -0.14962940f, -0.06147030f, 0.04635992f, 0.20010240f, 0.07298224f, 0.12431829f, -0.04255811f, 
    -0.14591035f, 0.01264458f, 0.00736924f, -0.01586760f, 0.11873946f, 0.07642519f, -0.02055127f, -0.08680145f, 
    0.14848259f, -0.34541991f, -0.18325759f, -0.02590788f, -0.14561802f, -0.02181461f, 0.08359973f, -0.05266262f, 
    0.09259667f, -0.08331093f, -0.09323783f, 0.06192129f, 0.00896171f, 0.06715961f, 0.35541397f, 0.15278453f, 
    0.04381831f, -0.00129155f, -0.00862776f, -0.00157413f, 0.01199285f, 0.09754743f, 0.05331983f, -0.12766342f, 
    -0.13018575f, 0.10902964f, -0.08639348f, 0.26203361f, 0.05967796f, 0.04155288f, 0.20860450f, 0.05897130f, 
    0.03574943f, 0.06219424f, -0.05506614f, 0.05370848f, -0.12440817f, 0.11630460f, -0.07470880f, 0.00569931f, 
    -0.03560666f, 0.08977251f, -0.04730573f, -0.08028182f, -0.27805743f, -0.29819039f, -0.05218347f, -0.15265031f, 
    -0.19829074f, -0.02840979f, 0.28127214f, -0.48719805f, 0.13440403f, 0.14797153f, -0.15916331f, -0.10834544f, 
    -0.05786463f, 0.13047090f, 0.15434761f, -0.01801132f, 0.12483577f, 0.23055345f, 0.04994638f, 0.16552810f, 
    -0.03800695f, -0.02996756f, -0.03111109f, -0.07120626f, 0.02544550f, 0.04675453f, 0.09883278f, -0.01711445f, 
    -1.37235820f, -0.66131675f, -0.47307232f, -0.45189863f, -0.11119508f, -0.00466041f, 0.04110001f, 0.12513718f, 
    0.02655100f, 0.07739428f, -0.18990673f, 0.00681455f, 0.04012943f, -0.09172531f, 0.18728304f, -0.35320583f, 
    0.20050365f, -0.42271301f, -0.04361732f, 0.02998015f, -0.05931598f, 0.10092328f, -0.27661610f, 0.14919844f, 
    0.06156595f, 0.07639207f, -0.07144819f, 0.22709984f, -0.20343271f, 0.21972872f, 0.04582885f, -0.32417819f, 
    0.04218775f, -0.02652294f, 0.00078654f, 0.08957029f, 0.42963171f, -0.01001872f, 0.26702067f, 0.25400081f, 
    -0.05236562f, 0.02736500f, -0.00092103f, 0.12521242f, -0.02161996f, 0.05411821f, -0.02403006f, 0.04161441f, 
    -0.03354222f, -0.13452986f, 0.30951968f, -0.28450823f, 0.24149974f, -0.05143774f, -0.43747407f, -0.10370694f, 
    0.02431637f, -0.03671776f, -0.28333572f, 0.01456791f, 0.05949397f, 0.32400191f, -0.19485311f, -0.20372075f, 
    -0.03678969f, 0.06245037f, -0.09598465f, -0.09358750f, -0.17559065f, 0.05080698f, 0.09591799f, -0.12115461f, 
    0.28710863f, 0.03265892f, -0.20181109f, 0.08903379f, -0.11013357f, 0.06209577f, 0.21136063f, 0.08133024f, 
    -0.13631037f, 0.07904997f, -0.02468686f, 0.05238380f, -0.13044313f, 0.40502483f, 0.12239026f, -0.09681764f, 
    -0.08319340f, 0.00365295f, -0.03554022f, -0.10846912f, 0.23581849f, 0.12138176f, -0.16088179f, 0.23284252f, 
    0.08395166f, 0.09510127f, -0.12083270f, -0.52486938f, 0.03076218f, -0.02361804f, 0.14469799f, 0.08923446f, 
    -0.02198160f, -0.03366687f, 0.12985370f, -0.02513062f, 0.17869322f, -0.04344450f, -0.03791075f, 0.08380290f, 
    -0.07685203f, 0.07863667f, -0.12837315f, -0.08093677f, -0.03053849f, 0.03659908f, -0.10792106f, 0.12110092f, 
    0.04946113f, -0.02401992f, -0.04665400f, 0.06929406f, 0.08828810f, 0.02891271f, 0.04390887f, 0.02000494f, 
    -0.09129196f, -0.05552191f, -0.03572568f, -0.14080229f, -0.27558064f, -0.31817651f, 0.04362247f, 0.11645750f, 
    0.00082604f, -0.04643304f, -0.02116903f, -0.04701607f, -0.04941462f, -0.04543878f, 0.03118177f, -0.04883949f, 
    -0.04696357f, -0.06735056f, 0.19969364f, -0.37861621f, -0.03050853f, -0.09103650f, -0.59559864f, -0.29302937f, 
    0.14098737f, -0.08978668f, -0.00255136f, 0.05082475f, -0.04489155f, -0.10114689f, -0.08312696f, -0.00063550f, 
    -0.00473769f, 0.00460191f, 0.09725301f, -0.02740878f, -0.00662236f, -0.09482643f, -0.18438748f, -0.00116845f, 
    0.11879326f, -0.00429289f, -0.12492342f, -0.06209915f, -0.05300279f, -0.08259438f, -0.02700948f, 0.12858494f, 
    -0.07261087f, 0.00712747f, -0.08423604f, 0.16586526f, -0.18042517f, 0.44775996f, 0.67644483f, 0.67298752f, 
    0.02102822f, -0.08050074f, 0.01678683f, 0.16385122f, 0.03976070f, 0.00909813f, -0.06569681f, -0.03871497f, 
    -1.27867818f, -0.82602739f, 0.18353191f, -0.28653452f, 0.06216122f, -0.13069169f, -0.04905061f, 0.12900369f, 
    -0.03340746f, -0.03105216f, -0.00487683f, -0.07484703f, -0.23585896f, 0.18039961f, 0.17959636f, -0.35745987f, 
    -0.00131354f, 0.06544030f, 0.04911270f, 0.13936102f, 0.01026012f, 0.01030840f, 0.08360597f, -0.12376758f, 
    -0.20439380f, -0.11429554f, -0.18878713f, -0.08114278f, 0.12018596f, -0.00140670f, 0.02645016f, 0.05271295f, 
    -0.08954932f, -0.33919731f, 0.12853223f, -0.00705876f, -0.16992493f, 0.49702433f, -0.42146146f, -0.13160843f, 
    0.06726692f, 0.04350401f, -0.18740748f, 0.10228851f, -0.00405956f, 0.00096331f, 0.10784893f, -0.02829933f, 
    -0.04580174f, 0.01544430f, 0.18335208f, -0.76404297f, 0.01787400f, -0.02839450f, -0.21459603f, 0.25040096f, 
    0.10285738f, -0.00603328f, -0.08750381f, 0.06458618f, -0.05174890f, 0.11831696f, 0.02721217f, -0.00577839f, 
    -0.03528079f, 0.00312961f, -0.05299659f, -0.09420769f, 0.22144367f, 0.16738278f, 0.23833755f, 0.30449319f, 
    -0.59084463f, 0.31973341f, -0.16403960f, -0.10521681f, -0.06312963f, 0.05077080f, 0.02083785f, -0.01464431f, 
    -0.14175311f, 0.19245674f, -0.20569552f, 0.09840952f, -0.43235251f, -0.01936509f, -0.20035529f, -0.55052584f, 
    -0.19582202f, -0.35310274f, -0.16741131f, 0.20030119f, -0.08865520f, 0.09412351f, -0.07193740f, -0.02539884f, 
    -0.44928366f, 0.11688662f, 0.07512130f, -0.46516261f, 0.20710582f, 0.10806189f, -0.16850668f, -0.06435115f, 
    0.06239198f, -0.06459446f, -0.13201807f, 0.12881158f, -0.21500303f, 0.04657602f, -0.02382918f, 0.03101223f, 
    0.04148185f, 0.07509831f, -0.05834091f, -0.08474518f, -0.05411869f, 0.05106783f, -0.14128959f, 0.17496204f, 
    -0.04320857f, 0.12428553f, 0.21054964f, 0.17042905f, -0.09269301f, -0.05664686f, 0.04964611f, 0.05707381f, 
    -0.03789718f, 0.07878011f, 0.12770499f, -0.19759724f, 0.05353135f, -0.24955074f, 0.01761623f, 0.21231267f, 
    0.02487121f, 0.02684539f, 0.11330183f, -0.06494241f, -0.00601731f, 0.02433163f, -0.13763507f, 0.08697378f, 
    -0.21254104f, -0.10227440f, -0.48595351f, 0.17011878f, 0.14414997f, -0.03562161f, -0.01065011f, 0.09420187f, 
    -0.06599534f, -0.03402385f, 0.04332739f, -0.10339317f, -0.07888000f, 0.09730431f, 0.06928948f, 0.16981456f, 
    -0.06831115f, 0.00519506f, -0.00484703f, 0.00824907f, 0.06636056f, 0.12626567f, 0.15548548f, 0.24375230f, 
    0.07700764f, 0.56527925f, -0.11606450f, 0.07871797f, 0.07020304f, 0.02519762f, -0.03097139f, 0.11269781f, 
    -0.04816698f, 0.11133835f, 0.09117216f, 0.07870380f, -0.25816464f, 0.03579309f, 0.04026579f, 0.03773687f, 
    -0.09996807f, -0.00384032f, 0.06659826f, 0.07603925f, -0.03919483f, -0.02243255f, 0.02698808f, -0.02864767f, 
    0.44581687f, 0.36074838f, -0.75797057f, 0.33544180f, 0.01483834f, 0.01573479f, -0.08747797f, -0.04480844f, 
    -0.15839297f, -0.03723723f, -0.15148371f, 0.14319685f, -0.12837814f, -0.09925165f, 0.09508342f, -0.61880869f, 
    0.00921160f, -0.06479849f, 0.09476002f, -0.27977324f, 0.01551041f, 0.00708016f, 0.04262125f, 0.22107163f, 
    -0.58169270f, -0.27851182f, -0.31249726f, -0.17045118f, 0.04119918f, 0.12490535f, 0.38002968f, -0.12087450f, 
    -0.01097388f, -0.01146766f, -0.03790721f, -0.00466626f, -0.25224945f, -0.04225422f, 0.32345030f, -0.14473245f, 
    0.09051841f, -0.06379560f, 0.01757680f, 0.03882890f, -0.08960108f, 0.07081806f, 0.09369453f, 0.06853516f, 
    0.46527284f, 0.29770976f, 0.08154834f, 0.03120749f, 0.10278124f, -0.11093900f, -0.19216885f, -0.10277764f, 
    -0.02431398f, 0.01953158f, -0.05035206f, -0.04386892f, 0.45809773f, 0.42278504f, 0.36889151f, 0.42815802f, 
    -0.03200881f, -0.03115441f, 0.01451396f, -0.11292611f, 0.04925723f, -0.01171830f, 0.01058021f, 0.16884167f, 
    -0.36140573f, -0.12875213f, 0.01029771f, 0.02542338f, -0.53748739f, -0.06551999f, -0.09169931f, -0.21519504f, 
    0.02775567f, -0.00880877f, -0.08744635f, -0.03263531f, -0.03461088f, -0.10427024f, -0.19995254f, 0.14998092f, 
    0.11114174f, 0.02926200f, -0.02592373f, 0.08192831f, -0.01285825f, 0.11854777f, 0.12439934f, 0.08484983f, 
    -0.05821599f, -0.06690720f, -0.12481946f, -0.39576688f, 0.04526610f, -0.02802498f, -0.09388365f, -0.35759082f, 
    -0.11828722f, 0.20762038f, -0.21032389f, 0.02665288f, -0.05215562f, -0.12788153f, -0.00694867f, 0.19426695f, 
    0.14269723f, -0.03142880f, 0.12810177f, -0.00043814f, 0.07719582f, 0.28256121f, -0.11320251f, 0.10648708f, 
    0.03473591f, 0.05322838f, 0.08349473f, 0.05930077f, -0.13396010f, -0.14521797f, -0.14172128f, -0.09867431f, 
    -0.13641854f, 0.01000217f, 0.05585910f, -0.05005440f, -0.21313134f, 0.46666753f, -0.35767859f, -0.51520580f, 
    0.42963135f, 0.27120161f, 0.06086793f, 0.06871073f, -0.25071576f, -0.05927898f, 0.10008374f, 0.08419292f, 
    -0.10706830f, 0.01173933f, 0.33730167f, -0.19080932f, -0.33908722f, 0.20081645f, 0.06401265f, -0.04036792f, 
    -0.00099916f, -0.09809310f, 0.00682001f, 0.05517184f, 0.13418604f, 0.14445880f, 0.01318632f, 0.13481633f, 
    0.08874404f, -0.19963188f, -0.02635771f, 0.02063093f, 0.11370876f, 0.14764756f, -0.06131827f, -0.15414591f, 
    -0.33252564f, 0.11210506f, -0.25663406f, -0.21837915f, 0.04898229f, 0.11048626f, -0.01950287f, -0.04881278f, 
    -0.01347413f, 0.07754633f, -0.03063302f, 0.00010813f, 0.41206348f, -0.27696034f, 0.00956113f, 0.38672566f, 
    0.08492179f, -0.09294204f, -0.07478242f, -0.15504976f, 0.01640723f, 0.01941968f, 0.04373500f, 0.26475427f, 
    -0.23022708f, -0.00089228f, -0.31930122f, 0.20271847f, 0.09053797f, 0.04381190f, 0.03274724f, 0.05136282f, 
    -0.05997461f, 0.01761082f, 0.05661730f, 0.05044784f, -0.22207056f, 0.41200948f, 0.28284714f, 0.50497484f, 
    -0.08097277f, -0.08404908f, 0.05590510f, -0.25734401f, 0.11213619f, 0.04237704f, 0.02872166f, -0.15710120f, 
    -0.16539815f, -0.31611502f, -0.35772410f, -0.24070574f, 0.21570006f, 0.31218383f, 0.08790753f, -0.09460747f, 
    -0.11446773f, 0.09379637f, -0.04862302f, -0.00340193f, 0.01202828f, 0.89001924f, 0.36589870f, 0.14155728f, 
    -0.30024993f, -0.02380450f, -0.03437160f, -0.00982214f, -0.00340258f, -0.07272331f, -0.16405247f, 0.00708350f, 
    -0.46216562f, -0.02591656f, 0.17764828f, 0.30493957f, -0.33576578f, -0.05248848f, -0.42374277f, 0.06322359f, 
    -0.01420552f, 0.04151179f, -0.05575320f, -0.21901232f, -0.15797712f, 0.00621504f, -0.03326587f, 0.30150774f, 
    -0.14760800f, 0.12706290f, 0.00806672f, -0.02903808f, -0.01750853f, 0.10283247f, 0.14504056f, 0.14771257f, 
    -0.77881569f, -0.31758222f, -0.09292491f, 0.33788401f, -0.06700867f, -0.32110670f, 0.24338762f, -0.17823692f, 
    -0.07064376f, -0.08175825f, -0.23717088f, 0.02788605f, -0.29802176f, 0.29757220f, -0.20744628f, 0.76908207f, 
    0.11127271f, -0.11470027f, 0.20542890f, 0.07679485f, 0.00289816f, -0.09022830f, 0.07503758f, -0.01570885f, 
    0.10746326f, 0.02636348f, 0.33273375f, -0.03925270f, 0.12855184f, 0.08166903f, -0.09511180f, 0.10959809f, 
    -0.08008008f, 0.04627017f, 0.08994082f, -0.09265422f, 0.23092632f, -0.13508406f, -0.06856313f, -0.26016244f, 
    -0.11653303f, -0.15254186f, -0.08190361f, -0.10938572f, -0.11045241f, -0.14358334f, -0.00816520f, -0.22223511f, 
    -0.37337697f, -0.07822958f, -0.21541354f, -0.21035573f, 0.37641796f, 0.12284092f, 0.12934542f, -0.01325989f, 
    -0.25036314f, 0.00831080f, -0.15050727f, -0.19620037f, 0.59987807f, -0.28328335f, 0.06397814f, -0.55020779f, 
    -0.11000110f, -0.29124761f, -0.04817617f, -0.13138282f, 0.04450035f, 0.10212013f, 0.03608336f, -0.09368565f, 
    -0.17219162f, 0.05255245f, -0.18324156f, -0.08281875f, 0.00566521f, 0.06832393f, -0.00537877f, 0.01153113f, 
    -0.14433022f, 0.04747497f, -0.03618475f, -0.15769565f, -0.18961230f, -0.04767647f, -0.05738759f, 0.13227934f, 
    -0.00587775f, 0.00608230f, -0.15487175f, -0.21940616f, 0.08724538f, 0.15714170f, 0.06074944f, 0.03734517f, 
    -0.20314464f, -0.15334886f, -0.17135832f, 0.39296824f, 0.04615255f, 0.03039809f, -0.40795571f, -0.16789211f, 
    -0.06121670f, 0.05348409f, 0.00385862f, -0.09896353f, -0.38518748f, -0.30279532f, -0.47440591f, -0.34993750f, 
    -0.36191249f, -0.11992701f, -0.23261774f, -0.25579098f, 0.01404572f, 0.20046300f, -0.00111855f, -0.01575151f, 
    0.85659194f, 0.10528607f, -0.11686262f, -0.12674129f, -0.03904743f, -0.05035083f, 0.08942340f, -0.29121369f, 
    0.02274552f, -0.05147254f, 0.00424433f, -0.00695195f, -0.00325926f, -0.33470273f, 0.20400238f, 0.05248966f, 
    -0.15293086f, 0.05101124f, 0.02329050f, -0.06637744f, 0.11306327f, 0.02383255f, -0.02963535f, 0.00442130f, 
    -0.19236310f, -0.13023746f, -0.17794940f, 0.21351825f, 0.11341769f, 0.15893212f, 0.14266469f, 0.01204582f, 
    0.00067152f, -0.01482630f, -0.00872020f, -0.11854158f, -0.35263333f, -0.05575298f, 0.10341173f, -0.14991577f, 
    -0.23290989f, 0.10637324f, 0.01447602f, -0.24401250f, -0.04052718f, -0.00627293f, 0.04232409f, -0.03551495f, 
    0.71326143f, -0.30574062f, 0.26626319f, 0.03300151f, 0.01811472f, 0.08738032f, -0.02557615f, 0.03192043f, 
    -0.03144864f, 0.11220912f, 0.11949455f, 0.15197967f, 0.84685439f, -0.30085510f, 0.19686462f, 0.19700602f, 
    0.16778062f, 0.08434443f, -0.08792103f, 0.10209627f, -0.01025740f, 0.01395960f, -0.01227211f, 0.02867810f, 
    -0.15571919f, -0.24673551f, 0.30899644f, 0.55576158f, -0.04639316f, -0.21271017f, 0.08585869f, -0.22674470f, 
    -0.01227013f, -0.14914653f, -0.15758714f, -0.02109209f, 0.02075719f, 0.08958261f, -0.44396937f, -0.78378993f, 
    0.07644841f, -0.03093915f, -0.11526684f, -0.06993727f, -0.20801242f, 0.04112995f, 0.03852683f, -0.19013439f, 
    0.12302977f, 0.06822822f, 0.15413858f, 0.02172315f, -0.15957308f, 0.02098512f, 0.05390090f, -0.10377662f, 
    -0.13485837f, -0.17663482f, -0.03403480f, -0.11523150f, 0.16274673f, 0.31696141f, 0.11079346f, 0.24282597f, 
    -0.07111634f, -0.17618425f, -0.15138370f, -0.12192355f, -0.13209803f, -0.13396983f, -0.03635190f, 0.04154137f, 
    0.21655296f, 0.03228894f, 0.00776169f, -0.00468462f, 0.00713855f, -0.13235894f, 0.02712462f, -0.03601192f, 
    -0.07384861f, -0.20331500f, -0.14848728f, -0.02194802f, 0.28343713f, -0.08443114f, 0.02788591f, -0.15810642f, 
    0.08347433f, 0.01200106f, 0.01158802f, 0.09904913f, -0.10210468f, -0.07715559f, -0.39906490f, -0.14920391f, 
    0.10208308f, -0.06862900f, -0.22947216f, 0.45062155f, -0.13790767f, -0.05706056f, -0.25444117f, -0.36337090f, 
    0.11764129f, 0.03565912f, -0.05571172f, 0.00526095f, 0.17726056f, 0.14327389f, 0.11517400f, 0.01051844f, 
    0.01359901f, -0.11462943f, 0.02912494f, -0.13408369f, 0.15840894f, -0.04682355f, -0.08499858f, 0.03096923f, 
    0.02805843f, -0.08295859f, -0.07347891f, 0.00019334f, 0.07398355f, 0.03815093f, 0.03223779f, 0.01960646f, 
    -0.09431773f, 0.12871188f, -0.03670762f, 0.20001735f, -0.25211078f, -0.04142953f, 0.22083367f, 0.21252589f, 
    -0.08611871f, -0.20384502f, -0.02722809f, -0.03512079f, 0.06790964f, -0.04791356f, -0.03166842f, 0.03619204f, 
    -0.16134574f, -0.17645469f, 0.27249658f, -0.02573094f, -0.05831068f, 0.04568017f, -0.09200772f, 0.05195817f, 
    0.02914438f, -0.04325467f, -0.06826210f, 0.11412343f, 0.32678413f, -0.20067519f, 0.34886020f, 0.11165489f, 
    0.03458015f, 0.04507073f, 0.05934097f, 0.21049075f, 0.04375371f, 0.01979482f, -0.06682155f, 0.01931726f, 
    0.27191210f, 0.08616548f, 0.14668448f, -0.06424926f, 0.12002870f, 0.05970684f, 0.19734719f, 0.10564766f, 
    0.15307108f, -0.02130264f, -0.28273281f, -0.22824803f, 0.32881990f, -0.70752889f, -0.15418279f, 0.42644745f, 
    -0.02742380f, -0.13653438f, 0.09130413f, -0.22940947f, -0.07862315f, 0.00633171f, -0.07790113f, 0.07798923f, 
    -0.00894919f, 0.31389025f, -0.47549847f, -0.12213952f, 0.22863846f, 0.15610901f, 0.08919634f, -0.23514634f, 
    0.04577194f, 0.07364408f, 0.04476495f, 0.01606932f, 0.09711509f, 0.05871627f, 0.02798015f, -0.10404325f, 
    -0.00145498f, -0.07826378f, -0.03236982f, -0.04562315f, 0.17577882f, 0.09254476f, -0.09117951f, 0.39305088f, 
    -0.24855831f, -0.41781089f, 0.08774556f, -0.05386555f, 0.01782392f, 0.06525286f, -0.17225365f, 0.07151893f, 
    -0.17433165f, 0.17488691f, -0.12863100f, 0.00438684f, 0.02656428f, 0.12616041f, -0.18564335f, -0.11458334f, 
    0.18445607f, 0.02146633f, -0.04305715f, -0.05050904f, -0.13388844f, 0.09047856f, -0.08930876f, -0.09408577f, 
    -0.04554843f, 0.15683971f, 0.07743102f, 0.26477137f, -0.01794955f, -0.03794803f, -0.15375954f, 0.10360942f, 
    -0.06961918f, -0.08490434f, 0.03552948f, -0.36012194f, -0.40710083f, -0.04661591f, -0.00147862f, -0.05073470f, 
    0.08330534f, 0.05175504f, -0.06935751f, -0.01992222f, -0.04266502f, -0.08875247f, -0.34672406f, -0.04555977f, 
    -0.07581770f, -0.14154187f, 0.06992856f, 0.11621258f, -0.10153312f, -0.03014893f, -0.04648010f, 0.01291153f, 
    0.06090111f, 0.21624659f, 0.01773163f, -0.08285908f, -0.50639349f, -0.09186443f, -0.24343726f, -0.21273473f, 
    -0.07844912f, -0.09487350f, 0.01530481f, 0.09141692f, -0.02499740f, -0.11154111f, 0.03795479f, 0.07730479f, 
    -0.07161178f, 0.02295581f, 0.15813372f, 0.16070822f, -0.12108845f, -0.09717058f, -0.03621142f, -0.05100926f, 
    0.00889929f, -0.02009556f, 0.01808135f, 0.25034049f, -0.01907926f, -0.08397944f, -0.02706658f, -0.02601163f, 
    -0.08736575f, -0.00616643f, 0.05693644f, -0.00576468f, 0.32599396f, 0.25488520f, 0.13700248f, 0.33664215f, 
    -0.68203217f, -0.04219675f, -0.08348172f, -0.08084439f, -0.07889614f, -0.18254018f, -0.01708209f, 0.24119364f, 
    -0.02620405f, -0.24130897f, 0.02971161f, -0.17165247f, -0.05069358f, -0.08455130f, 0.02815671f, 0.16905746f, 
    0.05038449f, 0.12423646f, 0.09801846f, 0.02527639f, 0.05295558f, 0.00792298f, -0.05498015f, 0.10659476f, 
    -0.25839162f, 0.21408883f, 0.02043880f, 0.23674239f, 0.07595324f, -0.01570839f, -0.03047661f, -0.00317002f, 
    -0.04352452f, -0.06819899f, 0.06777057f, -0.06159803f, 0.11430200f, 0.38688758f, 0.15465730f, 0.25886604f, 
    0.18879442f, -0.22719096f, -0.14286035f, 0.06934288f, -0.04483064f, -0.08987317f, 0.11038454f, -0.05999709f, 
    0.18700005f, 0.15609860f, 0.31525445f, 0.09472685f, -0.10231580f, -0.12026802f, -0.05501606f, 0.09934474f, 
    0.04604542f, 0.05197963f, 0.04375307f, -0.05504844f, 0.22146942f, -0.01791106f, -0.79356271f, -0.17578018f, 
    0.19676977f, -0.11232813f, 0.05602788f, -0.04374241f, 0.01924702f, -0.13838695f, -0.20260881f, -0.09402370f, 
    0.03883115f, -0.16645022f, -0.39061779f, 0.14261356f, -0.05230302f, -0.17327610f, 0.11492174f, -0.25692412f, 
    0.07702272f, -0.11155595f, 0.21195838f, 0.08483095f, -0.05694953f, 0.35582066f, -0.04323745f, 0.05441433f, 
    -0.05095595f, -0.18202023f, 0.09262761f, -0.02441599f, 0.05529141f, -0.30499509f, 0.09557922f, 0.02743131f, 
    0.32991940f, 0.08494578f, 0.18904588f, -0.01522167f, -0.01267940f, 0.03098758f, 0.16266550f, 0.25691828f, 
    0.03014563f, -0.08187708f, -0.00754873f, -0.13997936f, -0.13653025f, -0.37732112f, -0.34815535f, -0.04190640f, 
    0.02072894f, -0.01322909f, 0.02226186f, -0.09663232f, -0.15641131f, -0.16181740f, -0.21699561f, 0.07969011f, 
    -0.02085855f, -0.11136718f, -0.17266329f, 0.62977630f, 0.21074782f, 0.07849865f, -0.12034919f, -0.02921983f, 
    0.13773757f, 0.17600299f, 0.02500604f, 0.06774886f, -0.05548542f, 0.02642847f, -0.01627686f, -0.17513563f, 
    -0.16835633f, 0.04641841f, -0.01067457f, 0.11921012f, 0.11087756f, 0.06188660f, -0.00081829f, -0.08741421f, 
    0.01817859f, -0.04728352f, -0.10478313f, 0.07654210f, -0.05100104f, -0.09927174f, -0.08838765f, -0.04603423f, 
    0.07326694f, 0.33816943f, -0.17712620f, -0.07812509f, -0.11133666f, -0.26580802f, 0.18180202f, -0.00489246f, 
    -0.07101092f, -0.01981189f, -0.08444458f, 0.00312834f, 0.14571433f, 0.07725498f, -0.20787863f, 0.07575779f, 
    -0.14508757f, 0.03763089f, 0.03472022f, 0.27279127f, 0.08400465f, 0.08807795f, 0.23548423f, 0.13412485f, 
    -0.16978680f, 0.12196518f, -0.22810876f, -0.07244961f, 0.04603950f, -0.05466148f, -0.16606982f, -0.07479083f, 
    -0.01461738f, 0.10390522f, 0.16486496f, -0.04462495f, 0.19499600f, 0.05129621f, -0.00089291f, 0.00229928f, 
    -0.01476274f, -0.08464010f, -0.08678100f, 0.07221052f, 0.09357649f, -0.02784862f, -0.01262234f, 0.06528945f, 
    0.11992233f, -0.12494181f, 0.10684297f, -0.15506266f, -0.55831099f, 0.04152807f, -0.27461568f, -0.25627533f, 
    0.02577635f, 0.03727024f, -0.00720196f, 0.04067706f, 0.01573038f, -0.01536503f, 0.09147894f, -0.01642007f, 
    -0.12624957f, 0.14600486f, 0.19276685f, -0.12574257f, 0.19592914f, -0.15014501f, -0.07440155f, -0.06231808f, 
    0.05472958f, -0.00733007f, -0.01280150f, 0.02557985f, -0.02712417f, -0.27339274f, -0.07398568f, 0.02731724f, 
    0.16014376f, 0.03382025f, -0.02766752f, 0.05286326f, -0.06039784f, 0.05547219f, 0.02092149f, 0.08882887f, 
    -0.02410237f, -0.08317880f, -0.04657190f, 0.02840254f, 0.01852265f, -0.11113345f, -0.16257001f, -0.19369562f, 
    -0.00642639f, 0.04702836f, 0.23821820f, 0.16242798f, -0.14957358f, -0.54332340f, 0.41793662f, -0.02572688f, 
    -0.03627441f, 0.05192226f, -0.25665140f, 0.12128563f, 0.08465842f, 0.00007206f, -0.03862970f, 0.06237253f, 
    -0.20129955f, -0.01211120f, -0.54861259f, 0.03567732f, 0.03623730f, -0.07471249f, 0.10263415f, 0.00856127f, 
    0.16213533f, -0.05312129f, -0.12631273f, -0.00960007f, 0.11383855f, -0.10694231f, -0.09601533f, -0.16343912f, 
    -0.04796654f, 0.07397146f, 0.04459177f, -0.03304897f, -0.16446887f, -0.22413047f, -0.23916040f, -0.79256356f, 
    0.01825939f, -0.04866753f, -0.18423317f, -0.10169502f, 0.12560719f, 0.00048594f, -0.12963985f, 0.18941405f, 
    0.09885644f, 0.31180048f, 0.10631945f, -0.07101931f, -0.04499213f, 0.14816953f, -0.45652294f, -0.33207306f, 
    0.39614308f, 0.34136960f, 0.16624615f, -0.09982843f, 0.15581352f, -0.00122976f, -0.19564229f, 0.02278648f, 
    0.27018338f, 0.18091886f, -0.27444011f, 0.34440386f, 0.00692157f, 0.03532599f, -0.06024032f, -0.03869189f, 
    0.06199378f, 0.02672029f, -0.03571124f, 0.13552661f, -0.29566875f, -0.18886980f, -0.21526437f, 0.44831625f, 
    0.11268481f, -0.05459888f, 0.05193665f, 0.09629081f, 0.01517043f, 0.01227953f, 0.22057149f, 0.16542792f, 
    -0.07603521f, 0.01981025f, -0.15865695f, 0.03456467f, 0.06839012f, 0.00116801f, -0.05398712f, 0.12478298f, 
    -0.00511517f, -0.11520333f, 0.09044922f, 0.05104315f, -0.41143680f, 0.07253163f, 0.02613681f, 0.16238816f, 
    0.02571700f, 0.02175799f, -0.05055897f, 0.08407812f, -0.00215831f, 0.15300305f, 0.02368633f, 0.08491505f, 
    0.16876735f, 0.17262347f, 0.35035017f, 0.01369819f, 0.12315302f, 0.18788391f, -0.09813749f, 0.00873676f, 
    0.16527736f, -0.00971724f, 0.03380134f, 0.06207896f, 0.25188288f, -0.28462270f, 0.04812641f, -0.09444202f, 
    0.07619458f, -0.04052412f, 0.07902447f, 0.16209605f, -0.05436575f, -0.22692306f, -0.33156273f, -0.43786862f, 
    0.51363432f, -0.07921499f, -0.30837983f, 0.26639464f, -0.28842819f, 0.00441546f, -0.16197132f, 0.15750006f, 
    0.07033329f, -0.12557837f, -0.16803375f, 0.17745152f, -0.27446005f, -0.22838828f, 0.24659452f, -0.09030949f, 
    -0.02896056f, 0.05343262f, -0.03466862f, 0.08599787f, -0.07700544f, -0.05707680f, -0.15803954f, -0.03897987f, 
    -0.41098580f, -0.01933925f, 0.40905869f, 0.40784973f, -0.06566967f, -0.08724601f, 0.00722722f, 0.03179000f, 
    0.03111820f, -0.09646490f, -0.07770848f, -0.15753865f, -0.00095953f, 0.32122338f, -0.09439997f, -0.05632546f, 
    -0.16301785f, 0.24565187f, -0.00243429f, -0.07206409f, -0.07542769f, -0.13042684f, 0.15285365f, -0.09995700f, 
    0.13725415f, 0.13653234f, 0.18501946f, -0.08620759f, 0.33570832f, 0.22781378f, -0.21687582f, -0.01387938f, 
    -0.00727590f, -0.03799536f, -0.05079800f, 0.01101110f, -0.13999167f, 0.17127456f, -0.34049499f, -0.35712260f, 
    -0.02189296f, 0.09347625f, 0.00690156f, 0.07126582f, 0.08374315f, -0.00810995f, 0.11923375f, 0.05434377f, 
    -0.63326210f, 0.33752951f, -0.01625213f, 0.05624081f, -0.06032914f, -0.23654185f, 0.26276967f, 0.25347081f, 
    -0.15209593f, -0.00929427f, -0.11934511f, -0.33140096f, -1.07012773f, -0.66108596f, -0.60780162f, -0.29553258f, 
    0.09440370f, -0.01519457f, 0.01567441f, 0.13579564f, 0.23382463f, 0.02491093f, -0.12156352f, -0.06729718f, 
    -0.28669780f, -0.07367350f, -0.06422310f, -0.26120222f, 0.21925749f, 0.25875863f, 0.04900935f, -0.12525475f, 
    0.07319812f, -0.02242573f, 0.06493097f, 0.09959336f, -0.05946908f, -0.45927656f, 0.16600014f, 0.54346216f, 
    0.02490019f, -0.11368434f, 0.01962764f, 0.11451092f, -0.10688300f, -0.03123002f, 0.17480378f, 0.10655740f, 
    -0.05980182f, -0.19685206f, 0.15002918f, 0.07609640f, 0.18438779f, 0.11093979f, -0.37527016f, -0.07051387f, 
    -0.06209696f, 0.05046751f, 0.01885324f, 0.02987836f, 0.06918211f, 0.31691939f, 0.29046634f, 0.19719501f, 
    -0.04331397f, -0.16227339f, -0.27700022f, 0.25577655f, 0.02395223f, -0.08373035f, 0.14705244f, -0.11929774f, 
    -0.16054229f, -0.00932232f, 0.02110023f, -0.03970937f, -0.07528695f, -0.06477015f, -0.27151540f, -0.00837811f, 
    0.01986099f, -0.01728035f, 0.03765417f, 0.12526540f, -0.02726648f, -0.03579802f, -0.02520252f, 0.10409255f, 
    -0.02828843f, -0.01576764f, -0.12037625f, 0.13704021f, -0.02218061f, 0.07965858f, 0.24808520f, 0.22697423f, 
    0.23756273f, -0.66470450f, -0.80967319f, -0.21900098f, -0.14026746f, 0.21044587f, 0.18248333f, 0.07279409f, 
    -0.02826904f, 0.00399312f, 0.03493053f, -0.02004361f, -0.05949979f, -0.05858347f, -0.10747811f, -0.10446243f, 
    -0.21113771f, -0.43880093f, -0.09886545f, 0.05586228f, -0.03312778f, -0.05244406f, -0.03272499f, -0.12691690f, 
    -0.00213230f, 0.01113639f, -0.00451819f, -0.01559405f, 0.07407861f, 0.04884778f, 0.02610339f, -0.02622998f, 
    -0.00015927f, -0.06455038f, -0.08477098f, -0.08856167f, -1.01186514f, -0.63835269f, 0.22311825f, 0.43109918f, 
    -0.05973503f, -0.01083975f, 0.02194601f, 0.00934392f, -0.07254323f, 0.03341168f, -0.10474294f, -0.00471541f, 
    -0.75723726f, -0.64663118f, -0.88776547f, 0.06210063f, -0.42142665f, -0.17791787f, -0.03867422f, -0.37183946f, 
    0.00869779f, -0.02107745f, -0.02674012f, 0.04118369f, -0.38007119f, -0.37980005f, -0.38800266f, 0.06893432f, 
    0.12198234f, 0.13810137f, 0.05026262f, -0.00470702f, -0.00134991f, 0.02858515f, 0.02039751f, 0.09315259f, 
    0.00008146f, 0.00220838f, 0.04568875f, -0.21757899f, 0.01986277f, 0.01136000f, -0.09551685f, -0.01042983f, 
    0.02957680f, 0.06812125f, -0.04822473f, -0.15549268f, -0.32770938f, -0.47447386f, -0.29784957f, 0.51983398f, 
    -0.03000629f, 0.25911829f, 0.04162510f, -0.08158612f, 0.08755171f, -0.04201009f, 0.02103502f, 0.05448486f, 
    0.48489380f, 0.06130140f, 0.24060650f, -0.26806602f, 0.11282904f, -0.02531366f, 0.10229278f, -0.16007115f, 
    -0.04672280f, -0.03913152f, 0.14990078f, 0.03696499f, 0.13493980f, 0.09904984f, -0.02782850f, 0.01484620f, 
    -0.04832657f, 0.08451686f, 0.06505173f, -0.00394523f, 0.14158612f, 0.17707577f, 0.18491942f, 0.15785205f, 
    0.42485607f, 0.30874756f, -0.00232517f, -0.22934538f, 0.17485116f, 0.04372530f, 0.10252161f, -0.07889330f, 
    0.10789899f, -0.06633707f, 0.17929056f, 0.15196063f, -0.55198967f, -0.39186272f, 0.08468112f, 0.41478524f, 
    0.03879765f, 0.06442794f, 0.21814232f, -0.29968259f, -0.00321067f, -0.01577777f, 0.02690391f, 0.08761179f, 
    0.35155115f, -0.12763315f, -0.24603964f, -1.28368449f, -0.12658563f, -0.15674512f, 0.28763422f, 0.05829489f, 
    0.02142245f, 0.09238571f, 0.10929281f, -0.19364858f, 0.12758879f, 0.04319979f, -0.05481040f, 0.16786753f, 
    0.03066185f, 0.02041895f, -0.02442898f, 0.08455197f, 0.01064686f, -0.08734248f, 0.12785703f, -0.06876628f, 
    -0.57581294f, 0.42770892f, 0.40728673f, -0.10820927f, -0.10503571f, -0.05784990f, -0.01390409f, 0.07256505f, 
    0.08588542f, -0.00250364f, -0.05097070f, 0.07873225f, 0.15729432f, -0.16932169f, -0.40368813f, 0.11951497f, 
    -0.04650269f, -0.00712188f, 0.02180383f, 0.15626886f, -0.07109261f, 0.00625593f, 0.12428050f, -0.37798265f, 
    -1.02497983f, -0.90873754f, -0.69052505f, -0.08391445f, -0.41861114f, -0.06976175f, -0.08350198f, -0.28446895f, 
    -0.12438402f, -0.05973873f, -0.06185924f, 0.01088921f, -0.05844382f, 0.25841975f, 0.00526986f, 0.08897036f, 
    -0.07667158f, 0.05636587f, 0.01219907f, 0.09744125f, 0.11991131f, 0.04907227f, 0.29768124f, 0.20792276f, 
    0.52059639f, 0.07904862f, -0.16921861f, 0.32384565f, -0.03501457f, -0.27440852f, 0.29277411f, 0.04325821f, 
    0.01413759f, 0.14379697f, -0.31781098f, -0.05631000f, 0.03809091f, -0.19977775f, -0.26372492f, 0.16460618f, 
    -0.02616893f, 0.11055774f, -0.02186057f, 0.03778966f, -0.03011171f, 0.02690910f, -0.20922047f, -0.05509776f, 
    -0.15807632f, -0.23085341f, 0.15172264f, -0.14993499f, -0.08455171f, -0.11623464f, 0.00666980f, 0.07965667f, 
    0.06457613f, 0.27436060f, 0.26873106f, -0.05617647f, -0.24164642f, -0.62397200f, 0.06988791f, -0.08717900f, 
    0.06584869f, 0.17340606f, 0.04051924f, -0.14784306f, 0.01602972f, -0.02188929f, 0.10319047f, -0.07071818f, 
    -1.02337825f, -0.10249233f, -0.39702597f, -0.59330893f, -0.41395304f, -0.16054083f, -0.23520716f, -0.10226420f, 
    -0.00122840f, -0.02060576f, 0.00221848f, 0.02446469f, 0.02766285f, 0.11766652f, 0.04328277f, -0.10958316f, 
    0.05053902f, 0.19418846f, -0.04536176f, 0.03665347f, 0.03222840f, 0.13924006f, -0.01920251f, -0.24104665f, 
    -0.46221080f, -0.35000837f, -0.21454035f, 0.14337569f, -0.04795716f, 0.25661826f, 0.09954812f, 0.08363685f, 
    -0.02144350f, 0.17371802f, 0.12079677f, 0.04207632f, -0.18579940f, 0.16100574f, 0.48485044f, 0.29456979f, 
    -0.00862078f, -0.12386893f, -0.08395845f, 0.05372065f, -0.10192510f, 0.02533754f, 0.07455520f, 0.17937094f, 
    -0.27931812f, -0.14083116f, 0.23937915f, -0.14522530f, 0.11851636f, 0.10222364f, -0.10089269f, -0.14041325f, 
    -0.04162458f, -0.11229416f, -0.06851987f, -0.03591247f, -0.04143852f, 0.12274212f, -0.13880827f, 0.15150173f, 
    0.12030169f, -0.02061243f, 0.02095491f, 0.09880044f, -0.11838841f, -0.25808418f, 0.11083756f, 0.11156756f, 
    -0.03649973f, 0.13837764f, -0.05939173f, 0.00310646f, 0.00508196f, 0.04078040f, -0.14285180f, -0.02658352f, 
    0.07902794f, -0.03402160f, 0.00986704f, -0.13176547f, -0.00457086f, -0.64097059f, -0.45604315f, -0.19229141f, 
    -0.11194375f, -0.14874671f, 0.00947395f, -0.16218247f, -0.00971804f, 0.08761591f, 0.03672844f, 0.00880601f, 
    0.09209973f, 0.12155607f, -0.07616150f, -0.07107399f, -0.06229153f, 0.04143115f, 0.08499692f, 0.07200953f, 
    -0.12034351f, 0.09619983f, -0.01447791f, 0.12008393f, 0.16023336f, -0.01380595f, 0.00910439f, -0.21358308f, 
    0.05141579f, 0.04024238f, 0.00134240f, -0.01565824f, 0.07325369f, -0.07005788f, 0.10258853f, -0.36179858f, 
    -0.40421143f, 0.27056521f, -0.28408590f, 0.09680273f, -0.39036915f, -0.05593578f, -0.05581252f, 0.26895690f, 
    0.03712720f, 0.13698228f, 0.02988029f, 0.01759499f, 0.03740444f, 0.15187490f, 0.09525552f, 0.11784270f, 
    -0.16441353f, -0.23624119f, 0.12737837f, 0.08974873f, -0.01456482f, 0.07696544f, 0.03455274f, 0.03410505f, 
    0.14159122f, 0.19878194f, 0.09001239f, -0.05705913f, 0.01819204f, -0.01640138f, 0.04352034f, 0.00943157f, 
    -0.03976187f, 0.04594317f, 0.00577802f, -0.19340371f, -0.53443760f, -0.83443874f, -0.73038381f, -0.67869163f, 
    -0.07540181f, -0.03105387f, 0.02158634f, 0.09858892f, 0.10767598f, -0.01632652f, -0.03623747f, -0.00831906f, 
    0.07567954f, -0.55339307f, 0.23996216f, -0.19759205f, 0.10903573f, 0.23064683f, -0.14777508f, 0.25970730f, 
    -0.00207747f, -0.01046011f, -0.05210926f, -0.02544341f, 0.03337390f, -0.07721071f, 0.08894138f, -0.38005504f, 
    0.02584336f, -0.03212121f, -0.09893419f, -0.05940168f, 0.03732700f, 0.06310598f, 0.00826864f, -0.01154227f, 
    0.15766247f, -0.04833303f, 0.06383272f, -0.21181624f, -0.03166425f, 0.08646567f, 0.02139485f, 0.04360738f, 
    0.06539666f, -0.04633158f, -0.25084248f, 0.01358438f, 0.08558013f, -0.35749444f, 0.12857233f, -0.40975028f, 
    -0.10714416f, -0.12663876f, 0.04848170f, -0.01042486f, -0.00960287f, 0.03843632f, 0.02623991f, -0.09738493f, 
    -0.19129184f, 0.32144704f, -0.01576889f, 0.13714890f, 0.09100780f, 0.01141797f, 0.12200832f, 0.03366841f, 
    -0.04556075f, 0.10771574f, 0.11851970f, 0.04196028f, 0.05089137f, -0.10175675f, 0.10024636f, -0.11166207f, 
    -0.01852710f, -0.04951395f, -0.01763557f, -0.01087622f, -0.04806323f, -0.01693016f, 0.14957771f, -0.02308992f, 
    0.01459907f, 0.04289645f, 0.14671084f, 0.05863133f, 0.07557803f, 0.11475834f, -0.09069590f, -0.08861832f, 
    0.03549423f, -0.12017904f, -0.22755365f, -0.03875567f, -0.13504142f, 0.28436476f, 0.24115780f, -0.10625023f, 
    -0.02965943f, -0.16934396f, 0.06796968f, 0.31384048f, 0.02401698f, 0.03527854f, 0.04206876f, -0.01678412f, 
    -0.84821731f, 0.66935825f, -0.52506393f, 0.27313972f, -0.06816002f, -0.24414603f, 0.06648404f, -0.21907544f, 
    -0.01148282f, -0.04761927f, -0.12179021f, -0.04389505f, -0.02190964f, -0.03440075f, -0.08149645f, -0.15605396f, 
    -0.00827860f, -0.05619590f, 0.03148355f, -0.06786563f, -0.01943385f, -0.09049613f, -0.09640855f, -0.24899715f, 
    0.45912573f, 0.10704801f, -0.36733049f, -0.41177031f, 0.01815306f, -0.00581975f, -0.00091891f, -0.01732400f, 
    0.15526828f, 0.07321972f, -0.13158906f, -0.00433995f, -0.00887164f, -0.09483340f, 0.10539852f, -0.14806210f, 
    -0.01326941f, 0.06365816f, -0.07845125f, -0.05550287f, 0.07446833f, -0.12343342f, -0.08414147f, -0.09480787f, 
    0.28963640f, -0.31555951f, 0.13312282f, 0.82708734f, -0.09489889f, -0.11152133f, -0.11948431f, 0.11523446f, 
    -0.05014338f, -0.10809998f, -0.10407187f, 0.07894313f, 0.20836782f, -0.55051023f, -0.25678271f, -0.22795226f, 
    -0.01018000f, 0.01093483f, 0.01139129f, 0.04699543f, 0.12619716f, 0.02370643f, 0.06336888f, 0.09151067f, 
    -0.03177534f, -0.03957438f, -0.16310024f, -0.14878897f, -0.25475895f, 0.04916255f, 0.00008250f, 0.09444841f, 
    0.03819122f, 0.02894265f, 0.04553238f, -0.02280998f, 0.06449204f, -0.03849196f, 0.00505922f, -0.08709396f, 
    0.01274532f, -0.06239357f, -0.05548992f, -0.02133240f, 0.06463605f, -0.03039892f, 0.03261606f, 0.03365777f, 
    0.86546761f, -0.17684384f, -0.75269055f, 0.60981721f, 0.09951033f, -0.10655988f, 0.00209070f, -0.10052988f, 
    -0.12833734f, 0.01901679f, 0.13904080f, -0.06079936f, -0.38943246f, -0.01942030f, -0.09868152f, 0.41948840f, 
    0.04969011f, 0.30991402f, 0.13215889f, -0.13778907f, 0.05105830f, -0.04459777f, -0.13844644f, -0.11063213f, 
    -0.71462083f, -0.11619279f, -0.56645209f, 0.25172168f, 0.06191067f, -0.10438089f, 0.16673785f, 0.12125434f, 
    0.02573240f, -0.00009012f, 0.00675248f, 0.03316107f, -0.05573202f, -0.07059362f, 0.31671286f, -0.27067479f, 
    0.07519817f, -0.03532457f, -0.12650713f, 0.05433382f, 0.11113031f, -0.19123489f, 0.05648998f, -0.01033657f, 
    -0.50584108f, 0.08434041f, -0.06732917f, 0.36331171f, -0.10030928f, 0.15233995f, -0.04502086f, -0.02899401f, 
    0.04806591f, -0.02595414f, 0.08523498f, 0.18810704f, 0.51641291f, -0.49907863f, -0.19220799f, -0.22511680f, 
    -0.09669730f, 0.11972358f, -0.09403540f, -0.01455750f, 0.04025399f, -0.11091492f, 0.08461982f, 0.19192870f, 
    -0.21328449f, 0.20454200f, 0.24073990f, -0.03185887f, -0.06132074f, -0.33474562f, -0.10016893f, -0.02279452f, 
    0.07392808f, -0.01280019f, 0.06460644f, -0.04241771f, 0.23139994f, -0.04454273f, -0.01839473f, -0.25148129f, 
    -0.07950328f, 0.06338932f, -0.01892963f, -0.11368080f, -0.18287706f, 0.02114920f, -0.06055383f, -0.31121877f, 
    0.16624741f, 0.03928531f, -0.04761687f, 0.05807053f, 0.07593821f, 0.16922916f, 0.12600137f, 0.17067678f, 
    -0.11408111f, 0.06319780f, 0.12524197f, -0.01395833f, -0.11172774f, -0.48965096f, -0.19194578f, 0.13342351f, 
    0.14304784f, 0.17626534f, 0.16896577f, 0.00382811f, -0.10818132f, -0.11288291f, 0.08222418f, -0.04251003f, 
    -0.06981824f, -0.12229709f, -0.07528275f, -0.15710270f, -0.08370547f, 0.13791013f, 0.07296256f, 0.07509975f, 
    0.03881020f, 0.05206985f, 0.15438393f, 0.20041515f, -0.03652096f, -0.05750503f, -0.02318777f, -0.22502349f, 
    -0.20498262f, -0.07788841f, -0.03314806f, 0.01436268f, 0.17545390f, 0.06561632f, 0.17048579f, 0.21014915f, 
    -0.12338980f, 0.16542193f, 0.10865352f, 0.15445605f, 0.11713500f, -0.00042389f, -0.09502848f, 0.15810657f, 
    -0.35188892f, -0.02794314f, 0.09438197f, -0.07187974f, -0.14483972f, -0.12719868f, -0.12209104f, -0.05124991f, 
    0.04658931f, 0.05129807f, -0.03358229f, -0.06601050f, -0.01388311f, 0.13847592f, 0.11317001f, 0.13302493f, 
    -0.10806843f, -0.03977726f, -0.06708466f, -0.33798170f, -0.03793536f, -0.02093981f, 0.00760482f, -0.04226872f, 
    -0.37539378f, -0.05070196f, -0.08567464f, -0.07434095f, -0.12527022f, -0.85536808f, -0.66458601f, 0.39707577f, 
    0.13712187f, 0.24263096f, 0.09312315f, -0.13630018f, -0.07341347f, -0.05433083f, 0.05874176f, 0.05232720f, 
    0.47605845f, 0.06176072f, -0.58464319f, -0.40341622f, -0.33704630f, -0.22445571f, 0.02157686f, -0.06206797f, 
    0.06546052f, -0.06951206f, -0.08335098f, 0.02735934f, -0.01501913f, 0.17167181f, 0.19651984f, 0.12419941f, 
    -0.03322502f, -0.13430890f, -0.01751314f, -0.19038448f, 0.00249374f, -0.08707450f, -0.00569647f, 0.01195569f, 
    -0.16223936f, -0.03849646f, -0.13221811f, -0.08919461f, -0.02614161f, -0.04103347f, -0.04727165f, -0.09442212f, 
    -0.03647493f, 0.05798177f, 0.04910596f, 0.12683541f, 0.39331266f, 0.28000516f, 0.19629842f, -0.31480625f, 
    -0.02177659f, -0.16338070f, 0.00956858f, -0.08767384f, -0.06480362f, 0.03932506f, 0.01714517f, 0.08179227f, 
    -0.79608423f, -0.35146734f, 0.15838073f, 0.20671418f, -0.15333427f, -0.02468695f, -0.10627476f, 0.05284879f, 
    -0.21386284f, 0.03484011f, 0.07780853f, 0.05733960f, -0.22378892f, -0.08225633f, -0.00898539f, -0.02335806f, 
    0.05333883f, -0.02359511f, 0.00686900f, -0.09342237f, -0.03675678f, -0.24582139f, -0.28369126f, -0.63418573f, 
    -0.60501832f, -0.09765093f, 0.08679760f, -0.09553689f, 0.08954628f, 0.06743269f, -0.01987234f, -0.08348082f, 
    0.04611577f, -0.06937768f, 0.26880330f, 0.04877992f, -0.28440106f, -0.10371242f, 0.05941679f, -0.19172737f, 
    -0.23239864f, 0.03348177f, -0.00330968f, -0.20219928f, 0.02099814f, -0.13005760f, -0.03370644f, 0.03642414f, 
    -0.47334257f, 0.18351811f, 0.01381575f, 0.33805609f, 0.25584561f, 0.06003062f, -0.09649394f, 0.03775401f, 
    0.02009574f, 0.07233872f, 0.11460702f, 0.17247120f, 0.06070570f, 0.25172654f, 0.03115466f, -0.03937248f, 
    0.00885899f, 0.13124065f, 0.06521133f, 0.04092527f, 0.21984181f, 0.01461924f, 0.19701844f, 0.12546057f, 
    -0.09536736f, -0.36771134f, -0.27537194f, -0.21511987f, -0.14044167f, 0.06986637f, 0.10182489f, 0.01728736f, 
    0.10938274f, -0.22046627f, 0.06822859f, -0.24603920f, 0.48543271f, 0.15069287f, -0.01810932f, -0.16815351f, 
    0.12530944f, 0.00355353f, -0.02649428f, 0.01683369f, 0.11606669f, -0.02107377f, 0.09064473f, 0.13812979f, 
    -0.04830460f, -0.33196506f, -0.67337310f, -0.41238251f, -0.12909742f, -0.26712480f, 0.09794171f, 0.06926180f, 
    0.15399757f, 0.17142412f, 0.00121733f, 0.03757961f, 0.18001643f, 0.04781893f, -0.02985061f, -0.05618530f, 
    0.15160793f, 0.10827273f, 0.07988808f, 0.16445646f, -0.15225224f, -0.25939670f, -0.40349984f, -0.48669267f, 
    -0.35678607f, 0.04744549f, -0.18532442f, 0.35411531f, 0.15623017f, 0.11029595f, 0.17030840f, 0.00133987f, 
    -0.02118208f, -0.08165289f, -0.01518121f, 0.18033309f, 0.09828887f, 0.10895404f, 0.18046914f, -0.09092966f, 
    -0.01921497f, -0.04338787f, 0.01856555f, -0.02280098f, -0.08699249f, 0.00488495f, 0.01329010f, 0.07889491f, 
    0.79173470f, -0.23701239f, -1.18381608f, -0.41121149f, 0.17263423f, 0.06626549f, 0.10605516f, -0.13269149f, 
    0.16484420f, 0.06625127f, 0.27896753f, 0.23729457f, -0.25431743f, 0.17984262f, -0.10776231f, -0.04867618f, 
    0.32151616f, 0.12404065f, -0.02234914f, 0.20575272f, -0.09696177f, -0.03201017f, -0.01486131f, -0.24782892f, 
    -0.05823812f, -0.51264924f, -0.37827596f, 0.05464655f, -0.26627299f, -0.00350657f, 0.17386501f, -0.11016326f, 
    -0.07732650f, 0.00084786f, -0.03472022f, 0.02041515f, -0.28015938f, 0.07511419f, 0.23965243f, 0.04094857f, 
    0.00998711f, -0.11030948f, -0.11450553f, 0.03216307f, 0.08892941f, 0.08072002f, -0.08683418f, -0.06904037f, 
    -0.16479582f, 0.14179587f, -0.02852966f, -0.02144305f, -0.07521569f, 0.20718369f, -0.16284335f, 0.09348757f, 
    -0.12559748f, 0.05725816f, -0.22459631f, -0.18937178f, -0.63908768f, -0.51945537f, -0.28014389f, 0.44118968f, 
    -0.05325385f, 0.14755903f, 0.10845038f, 0.16331057f, 0.09034928f, 0.20502262f, -0.05286166f, -0.26923648f, 
    -0.37782526f, -0.17237505f, -0.10910802f, -0.03413966f, 0.16150145f, -0.08912333f, -0.13889657f, 0.03028113f, 
    0.19681792f, 0.16803801f, 0.05925807f, 0.12232786f, 0.32839146f, 0.24791279f, -0.04290472f, -0.30795097f, 
    0.11087114f, -0.08052427f, 0.00857649f, -0.06194271f, 0.12309252f, -0.05004228f, 0.16146478f, 0.13088715f, 
    -0.16455013f, -0.13311604f, -0.49112236f, -0.00314749f, -0.27948883f, 0.15644577f, 0.01922293f, 0.00751094f, 
    -0.04181920f, -0.11487726f, -0.13256156f, -0.07854711f, 0.20685311f, 0.22061613f, 0.32951379f, -0.44215107f, 
    -0.08467545f, -0.46638134f, -0.13240123f, -0.12133442f, -0.20673080f, -0.09459025f, 0.10541929f, 0.01811069f, 
    0.19001307f, 0.18427469f, 0.19587456f, 0.09038579f, 0.22301456f, 0.03444467f, -0.31595817f, 0.01016406f, 
    -0.02668987f, -0.27679104f, 0.17506734f, -0.12361135f, 0.07253501f, 0.18956946f, 0.23632912f, 0.21401094f, 
    -0.01469655f, -0.00130303f, -0.13421939f, -0.02044427f, -0.13527556f, 0.01670314f, 0.10072620f, -0.06489353f, 
    -0.20144199f, 0.79433089f, -0.66329288f, -0.10945537f, 0.14394702f, -0.05017041f, 0.20009281f, 0.09200215f, 
    0.11038145f, -0.00620274f, 0.09563656f, 0.16710362f, 0.00120244f, 0.08328445f, 0.01990805f, -0.02420892f, 
    0.10957680f, 0.04428417f, -0.16501383f, -0.00596166f, 0.18782254f, -0.11821065f, 0.05506279f, -0.15503788f, 
    -0.24365485f, -0.26097926f, 0.14123310f, 0.03325864f, -0.00940834f, 0.27322483f, 0.05149411f, 0.10572314f, 
    0.22140445f, 0.34736261f, 0.06858971f, 0.05854289f, -0.09158380f, -0.13525696f, 0.10087981f, -0.79837543f, 
    -0.00886374f, -0.00695463f, 0.15403911f, -0.06391843f, 0.02929338f, 0.06468996f, 0.07631007f, 0.03314075f, 
    -0.36977059f, -0.23164560f, -0.17121094f, 0.43026221f, -0.27416641f, 0.23172791f, -0.05106100f, 0.21190096f, 
    0.00977880f, 0.03403521f, 0.06609096f, 0.02613321f, 0.16720830f, -0.81369716f, -0.08877584f, -0.09815604f, 
    0.14643465f, 0.05122386f, 0.22912142f, -0.13593656f, -0.07279210f, 0.06532865f, -0.04240111f, -0.01128104f, 
    0.24780314f, -0.11651326f, 0.03203988f, 0.27251741f, -0.00932774f, 0.20609896f, -0.01383739f, 0.03986831f, 
    -0.00032264f, 0.01120384f, -0.02205940f, -0.18987225f, 0.45164064f, -0.76264822f, 0.04679221f, -0.17066699f, 
    0.06802964f, 0.19872741f, 0.12434912f, -0.07488560f, -0.02836690f, -0.08743048f, -0.05474404f, -0.03088885f, 
    -0.12362983f, 0.06586146f, -0.13991039f, -0.38767943f, -0.14183813f, 0.10075498f, 0.13548186f, -0.06223446f, 
    0.03215840f, 0.01173319f, 0.02650708f, 0.14644656f, 0.07501107f, -0.02770279f, 0.13803574f, 0.05342535f, 
    0.04936351f, -0.02801593f, 0.09037878f, 0.10191493f, 0.10885514f, 0.19828813f, 0.24734172f, 0.23816465f, 
    0.05596260f, -0.28210914f, -0.03727512f, -0.21338364f, -0.11399198f, -0.02721324f, -0.12803143f, -0.14416325f, 
    0.01092896f, -0.17429256f, 0.09740491f, 0.10141983f, 0.50072098f, -0.55172282f, 0.21184032f, -0.73381847f, 
    0.16853157f, 0.03359792f, -0.28430796f, 0.06480086f, 0.12406664f, -0.09246594f, -0.20498551f, -0.08319654f, 
    -0.57719445f, 0.16191161f, -0.64934927f, 0.38264793f, -0.23761906f, 0.00585711f, 0.06989461f, -0.04573353f, 
    0.06705205f, 0.05546711f, 0.00418156f, -0.14719333f, 0.15359502f, 0.24822855f, -0.16998552f, -0.05782183f, 
    0.13220672f, -0.08295333f, -0.09989601f, -0.00262986f, 0.06733559f, -0.09689630f, 0.07481893f, 0.03721645f, 
    0.36363518f, 0.11158670f, 0.36387649f, 0.54587406f, 0.22386135f, -0.20779094f, -0.30734652f, -0.14331010f, 
    -0.08985171f, -0.01369673f, -0.00539509f, 0.20491923f, -0.27089393f, -0.10317796f, -0.29240277f, 0.12795992f, 
    0.08747399f, 0.09657464f, 0.10410984f, -0.16123496f, 0.20329311f, -0.15445925f, 0.01547442f, 0.02235116f, 
    -0.41635793f, -0.09342314f, -0.05241764f, 0.06109049f, -0.01202833f, -0.16349632f, 0.12785099f, 0.12361625f, 
    -0.07565700f, 0.04966589f, 0.15156758f, -0.03109217f, 0.21290734f, -0.10329031f, 0.37159976f, 0.14167315f, 
    0.02701390f, -0.12367880f, -0.06280991f, -0.06280199f, 0.09349758f, 0.17039189f, 0.13641998f, 0.05135634f, 
    -0.09106634f, 0.39572585f, 0.41509408f, -0.67037016f, -0.09163810f, -0.19798978f, 0.23770289f, -0.09894941f, 
    -0.15538102f, 0.16388294f, -0.11559474f, 0.01175022f, 0.00367681f, -0.44224086f, -0.04736901f, -0.03168249f, 
    0.25544873f, 0.21615127f, 0.18358198f, -0.04941505f, 0.03204883f, -0.08561508f, 0.00695213f, -0.02140344f, 
    -0.75097090f, 0.06504121f, 0.04316263f, 0.60813367f, 0.09394232f, -0.13089064f, -0.15679553f, -0.35168916f, 
    0.17767358f, -0.05929402f, -0.11708640f, 0.06815658f, 0.21218957f, 0.41530833f, -0.23428069f, -0.43143678f, 
    -0.17391151f, -0.05697925f, 0.07967912f, 0.34748322f, -0.06687818f, 0.18555935f, -0.03759087f, -0.19135970f, 
    -0.56037891f, 0.31576547f, 0.35568818f, -0.55170119f, -0.18636465f, -0.29538313f, 0.08999889f, 0.14271584f, 
    -0.09946323f, 0.01477764f, 0.02114871f, -0.07258776f, 0.12353538f, -0.62950373f, -0.08758496f, -0.00543023f, 
    -0.11482999f, 0.01065097f, 0.03044112f, -0.09617387f, 0.17586654f, 0.08500993f, -0.14265284f, -0.02786930f, 
    -0.61269325f, -0.03302170f, -0.19174422f, 0.11284911f, -0.11503316f, -0.12943460f, 0.02329254f, -0.17640094f, 
    0.09763924f, 0.15976179f, -0.02032082f, 0.15976833f, -0.08754167f, 0.42998433f, -0.03740432f, -0.18419781f, 
    -0.25811392f, -0.03524584f, -0.21389504f, -0.14547271f, -0.00482394f, -0.01434870f, 0.01178519f, 0.08994257f, 
    0.21615082f, -0.32174388f, -0.10608365f, -0.20142955f, 0.13544564f, -0.39572862f, -0.05882948f, 0.00398160f, 
    -0.01662860f, -0.19816023f, -0.12821378f, -0.08727534f, -0.06543320f, -0.02484985f, 0.02254033f, 0.29773930f, 
    -0.09771965f, 0.01333367f, -0.00690845f, -0.14254518f, -0.12215248f, -0.01727272f, 0.08958887f, -0.09499013f, 
    0.04710397f, 0.60615379f, 0.31560051f, 0.07058784f, -0.21724388f, -0.19425009f, 0.07030394f, 0.22548142f, 
    0.02605988f, 0.15770516f, -0.15125158f, 0.02901933f, -0.10617249f, 0.06173976f, 0.01742243f, 0.00343729f, 
    -0.01086166f, -0.02578329f, 0.07257410f, 0.00274864f, 0.05763346f, -0.04878130f, 0.11572924f, -0.04983946f, 
    -0.01244114f, 0.10576276f, 0.11560302f, -0.09728683f, -0.24156979f, -0.00365811f, 0.00094442f, 0.09729396f, 
    0.19282828f, 0.21557924f, 0.21209444f, 0.21816087f, -0.32058173f, 0.22389355f, 0.02227990f, -0.04275406f, 
    -0.01029231f, -0.00581608f, -0.00660838f, -0.19837481f, 0.08260797f, 0.27730781f, -0.07911883f, 0.07547673f, 
    0.15578252f, -0.06239546f, -0.06769216f, -0.05704007f, -0.27744919f, -0.15770413f, 0.30481988f, 0.05837401f, 
    -0.12039728f, 0.13347207f, -0.27738529f, -0.22488579f, 0.05108887f, -0.17672420f, 0.36911482f, -0.02307762f, 
    -0.20149907f, 0.16254283f, 0.12105901f, 0.07887249f, 0.00623101f, -0.08379114f, 0.34612763f, 0.26650587f, 
    -0.19456844f, -0.37121502f, -0.08405921f, -0.31634247f, -0.10933053f, -0.14601853f, -0.14620602f, -0.07100590f, 
    0.02454501f, -0.23298804f, -0.19292998f, -0.17257912f, 0.02178043f, -0.41018143f, 0.23703834f, 0.16538279f, 
    -0.01236341f, 0.01761583f, 0.02029798f, -0.05363109f, -0.01884951f, 0.11377207f, -0.06296956f, -0.32793337f, 
    -0.25220597f, 0.42523423f, -0.68778992f, 0.10730190f, -0.02758217f, -0.07531708f, -0.21028472f, 0.00388059f, 
    -0.02825618f, 0.18741013f, -0.04627088f, -0.02726537f, -0.46102089f, -0.19439095f, -0.46002597f, 0.10376777f, 
    -0.05089810f, 0.05876635f, 0.16787443f, 0.07911739f, 0.09059060f, -0.01099509f, 0.03163167f, -0.00788077f, 
    -0.27365565f, 0.28770208f, 0.03584216f, -0.14677432f, -0.16494532f, -0.31731164f, -0.04657725f, -0.18654042f, 
    -0.05131486f, 0.04826089f, 0.00406852f, 0.13237689f, -0.57399982f, -0.24409334f, -0.47748721f, 0.03502925f, 
    -0.13975815f, 0.15046598f, 0.08988021f, -0.03552173f, -0.04813009f, 0.09490198f, -0.08077246f, -0.08508709f, 
    0.24318475f, -0.03628715f, 0.40329424f, 0.42232227f, -0.15851307f, -0.26858637f, 0.13007806f, 0.03002126f, 
    -0.11716820f, -0.03992086f, -0.14532602f, -0.07092756f, -0.09659030f, 0.26370099f, -0.14742328f, -0.18035538f, 
    0.08143681f, 0.03720524f, -0.11844201f, 0.15673772f, -0.41751778f, -0.35843933f, -0.29987347f, -0.69505751f, 
    -0.03534024f, 0.32968870f, -0.07334946f, -0.05384887f, 0.21563296f, 0.11887661f, -0.16778626f, 0.08396198f, 
    0.03359353f, 0.07182258f, -0.06249101f, -0.19447811f, 0.05584309f, 0.09092042f, 0.48428550f, 0.15062457f, 
    -0.08977294f, 0.24490760f, -0.46161398f, -0.06936953f, 0.08437242f, -0.07322703f, 0.09883481f, -0.08998902f, 
    0.11687951f, -0.11862514f, 0.22309692f, -0.19871610f, 0.03337791f, 0.09819548f, 0.07861895f, 0.11398935f, 
    0.02212727f, -0.02072876f, 0.18668143f, 0.13701597f, -0.25302085f, 0.08380762f, 0.41194430f, -0.03457306f, 
    -0.02492955f, 0.11919224f, 0.02233613f, 0.10845223f, -0.07365914f, 0.18204997f, 0.17344466f, 0.04675124f, 
    -0.55722129f, 0.26580089f, -0.09212955f, -0.20741710f, 0.15245473f, 0.08794647f, -0.25224712f, 0.08775923f, 
    -0.00843879f, -0.11293088f, -0.03244857f, -0.19457048f, -0.28155449f, -0.05469886f, -0.20749468f, 0.10610561f, 
    -0.04483578f, 0.03361012f, 0.03644809f, 0.01761454f, -0.07748271f, -0.13113610f, -0.13040952f, 0.08651432f, 
    -0.30993277f, -0.33421186f, 0.11233819f, 0.09398070f, -0.12804759f, 0.14191182f, -0.03030087f, 0.08878995f, 
    0.07021730f, 0.14417380f, 0.13513693f, -0.04883725f, -0.28416941f, 0.27858406f, -0.07613093f, 0.03928557f, 
    0.03389242f, 0.00930499f, -0.03933991f, 0.10397199f, -0.03486692f, -0.28888330f, -0.31473580f, -0.53554916f, 
    -0.07288700f, 0.04146567f, 0.10188188f, 0.23616502f, -0.16731037f, 0.02277992f, 0.10078157f, -0.22649767f, 
    0.21439040f, -0.10067004f, 0.15502517f, 0.04849769f, -0.60333228f, -0.10928415f, -0.64680099f, -0.35109648f, 
    -0.35300475f, 0.09341813f, -0.05475625f, 0.00798305f, 0.17156531f, 0.10622894f, -0.08108893f, 0.04717930f, 
    0.17882757f, 0.18500301f, 0.35043469f, -0.82597643f, -0.19450991f, 0.06302316f, -0.08825149f, 0.11300116f, 
    -0.20620950f, -0.19125357f, -0.17912899f, -0.05351951f, 0.16658743f, -0.45945486f, -0.22845683f, 0.46409515f, 
    -0.05069738f, -0.03442688f, 0.23735887f, -0.04356218f, -0.00138585f, -0.24851967f, -0.23667611f, -0.01142773f, 
    -0.37431806f, -0.55382943f, 0.03859092f, 0.13139524f, 0.03560147f, 0.08804698f, -0.19588046f, 0.12830624f, 
    0.02695070f, 0.06923781f, 0.05010594f, 0.01406326f, 0.21410672f, 0.14990118f, -0.17803077f, 0.31805155f, 
    0.01746737f, 0.04243800f, 0.00680517f, -0.08288308f, -0.06831714f, 0.05999888f, -0.21027429f, 0.05347133f, 
    0.34155321f, -0.44956952f, 0.07652474f, -0.17507185f, -0.05017324f, 0.12590612f, -0.16945520f, -0.06745545f, 
    -0.15350543f, 0.02060936f, -0.29855275f, -0.07330339f, 0.51314873f, -0.06804087f, 0.36224762f, -0.15060149f, 
    0.04932230f, -0.19807294f, -0.04337838f, 0.07673167f, -0.22527459f, 0.23754601f, -0.01706174f, -0.24630912f, 
    -0.36901402f, 0.25797454f, 0.12693207f, 0.29533178f, -0.09364132f, -0.00459344f, -0.08574236f, 0.33571112f, 
    -0.09399192f, 0.07724492f, 0.20131682f, 0.27267605f, -0.11366171f, 0.18159541f, 0.23611803f, -0.00963325f, 
    -0.10517590f, 0.06547662f, 0.11799775f, 0.15780018f, 0.07198255f, -0.08101930f, 0.21523219f, -0.02193642f, 
    -0.08035351f, -0.23345453f, 0.79805911f, 0.45046696f, 0.01803471f, -0.23180005f, 0.15457213f, -0.11296511f, 
    0.09636907f, -0.24046765f, 0.11945872f, 0.07099766f, -0.30116239f, -0.02262651f, 0.08842270f, 0.00709362f, 
    -0.08149558f, -0.24560128f, 0.03764725f, -0.00267680f, -0.01840606f, -0.03723626f, -0.28744006f, -0.04609348f, 
    -0.37744603f, 0.05324848f, -0.14464107f, 0.06324841f, 0.10168447f, 0.04358589f, 0.07369979f, -0.10968097f, 
    0.03831465f, -0.14038897f, -0.37061226f, -0.00641180f, -0.50096834f, -0.11871178f, -0.55180460f, 0.10111181f, 
    0.21408527f, 0.02526971f, -0.01544173f, -0.10344511f, -0.09044805f, -0.00476106f, 0.08558190f, 0.21878892f, 
    0.26689637f, -0.43903434f, 0.91978645f, -0.21629128f, 0.20480455f, 0.02476504f, -0.13274936f, 0.00798290f, 
    0.03172013f, -0.02797255f, 0.07246712f, 0.16308171f, -0.11303636f, 0.06310342f, -0.01141937f, -0.20117044f, 
    -0.15783153f, 0.09609392f, 0.18700860f, 0.19678873f, 0.04847375f, -0.05138059f, -0.37479416f, -0.41350931f, 
    -0.15415339f, 0.14265537f, -0.34370077f, -0.11420248f, -0.13654366f, 0.11782576f, 0.07055841f, 0.07642631f, 
    -0.06199376f, 0.11614294f, -0.14818965f, 0.07650617f, -0.16558552f, 0.49151713f, -0.14015119f, -0.39971241f, 
    -0.10054313f, -0.01731074f, 0.07549427f, 0.05051416f, -0.03572498f, 0.11170375f, -0.00057143f, -0.16619109f, 
    -0.03366502f, -0.35106915f, -0.05975407f, 0.00452878f, -0.27251202f, -0.04234990f, 0.19866005f, -0.30301532f, 
    0.01316149f, 0.02558757f, 0.06776044f, -0.07234982f, 0.12045471f, 0.17854153f, 0.26454020f, 0.09101032f, 
    -0.01489407f, -0.04919737f, -0.00093996f, -0.15932664f, -0.25896209f, 0.00392719f, -0.08120487f, -0.10707803f, 
    -0.37058261f, -0.12667456f, 0.19599530f, 0.36437175f, 0.05527385f, 0.02924323f, 0.10319882f, 0.07085063f, 
    0.02726352f, -0.03743484f, 0.05368260f, -0.01678090f, -0.04557241f, 0.42946541f, 0.08430623f, 0.11954056f, 
    0.32873493f, -0.13170028f, 0.17403853f, 0.03054664f, 0.08657669f, 0.14926590f, -0.10817309f, -0.08261652f, 
    -0.16269125f, 0.14771721f, 0.33361891f, -0.18937489f, -0.10807569f, 0.21956034f, -0.19299646f, -0.15399237f, 
    -0.02555509f, -0.02593215f, 0.07881478f, 0.09462704f, -0.17847666f, -0.01700776f, 0.14795502f, 0.16951041f, 
    0.17913769f, -0.00518830f, 0.05303732f, 0.22483993f, -0.01585059f, 0.15310498f, 0.04717785f, 0.14147106f, 
    -0.17921051f, 0.10783561f, -0.01157475f, 0.37576309f, 0.10429259f, -0.04550478f, 0.18840915f, 0.12853375f, 
    -0.17219053f, 0.04341849f, -0.22069168f, 0.31389970f, 0.12584846f, 0.49931148f, -0.21743937f, 0.38072422f, 
    -0.16604988f, 0.04697670f, 0.02350315f, 0.25011986f, 0.06470190f, 0.05301006f, 0.03354330f, 0.05508180f, 
    0.27318996f, -0.35684469f, 0.57085973f, -0.15010068f, 0.08006556f, 0.11240389f, -0.13404445f, 0.13983585f, 
    -0.01836421f, 0.10076722f, 0.18320225f, 0.05679434f, 0.14360616f, 0.03989236f, -0.05000989f, -0.00611779f, 
    0.04552320f, 0.03983024f, 0.14512904f, 0.02220397f, 0.01738866f, 0.11504722f, -0.11449858f, 0.04149937f, 
    -0.48702228f, -0.40895000f, -0.20701979f, 0.04971695f, 0.10078186f, -0.08126784f, -0.05534675f, -0.10644884f, 
    -0.05111666f, 0.13221984f, 0.13448708f, 0.03669144f, 0.40505883f, 0.15031312f, -0.00863001f, 0.02400149f, 
    -0.07294464f, 0.11031969f, -0.00937919f, -0.00983346f, -0.18277499f, -0.11094420f, -0.03688340f, 0.02878304f, 
    0.04968303f, -1.09275866f, 0.37853909f, -0.08438553f, -0.22060108f, -0.29327035f, -0.09542603f, -0.17120458f, 
    0.03858343f, -0.01656938f, 0.04203092f, -0.07858750f, -0.04012199f, -0.17303090f, -0.18323945f, -0.06046395f, 
    -0.01041256f, -0.22338253f, 0.05642457f, 0.04919410f, -0.09008190f, 0.10685256f, 0.01080904f, 0.04062238f, 
    0.31588987f, -0.42784077f, 0.56956381f, -0.13307852f, 0.15936905f, -0.04773263f, 0.19709989f, 0.15668738f, 
    -0.10555116f, 0.19544643f, -0.07821968f, -0.18352562f, 0.53697580f, 0.13866875f, -0.00007665f, -0.32348382f, 
    0.16166823f, -0.03628549f, 0.11892297f, 0.05186874f, -0.00138703f, 0.09074007f, -0.00199243f, -0.12886487f, 
    -0.40776664f, -0.84816176f, -0.35491511f, -0.49212739f, 0.17975284f, 0.15074201f, -0.06154766f, 0.11310618f, 
    -0.04824565f, 0.13880892f, 0.25376406f, 0.03496346f, -0.36588138f, -0.00929889f, -0.09742605f, 0.20598300f, 
    -0.59061569f, -0.05271179f, -0.24526283f, 0.05467469f, 0.15187632f, 0.10294718f, 0.11554717f, 0.04729658f, 
    -0.35302877f, -0.46267360f, 0.44472554f, -0.17238307f, -0.09603771f, -0.36353481f, -0.11963280f, -0.06132833f, 
    -0.01844583f, 0.08712913f, -0.07685983f, -0.19611393f, -0.14637597f, 0.25608614f, -0.09829528f, 0.30429235f, 
    -0.11985753f, 0.00160966f, 0.15798280f, -0.27112710f, -0.15789464f, 0.05237962f, 0.12331004f, -0.01881550f, 
    0.27090329f, -0.04691045f, 0.05905234f, -0.30984408f, -0.00389630f, 0.00860712f, 0.20946869f, 0.02099622f, 
    0.02648779f, 0.00995276f, 0.12776336f, 0.09092207f, -0.49884799f, 0.01406867f, -0.03782849f, -0.28701496f, 
    -0.01284916f, -0.06353642f, 0.17542976f, -0.10984845f, -0.03157793f, -0.03498555f, -0.15030488f, -0.02706819f, 
    0.12512542f, 0.14324160f, 0.10719334f, -0.09698568f, -0.13593037f, 0.22161077f, -0.42144898f, 0.01111873f, 
    -0.10638058f, -0.10158770f, -0.15504782f, 0.00104757f, -0.21036558f, -0.25924423f, -0.06795363f, 0.08256412f, 
    0.01224333f, 0.02289030f, 0.10885095f, 0.07365810f, 0.22211644f, 0.08337605f, -0.06195105f, -0.16618763f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20442145f, 0.12675305f, 0.14600401f, -0.11221213f, -0.13348489f, 0.10798088f, 0.06579380f, -0.20193054f, 
    0.11128981f, 0.04844087f, 0.08689467f, -0.05423742f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
