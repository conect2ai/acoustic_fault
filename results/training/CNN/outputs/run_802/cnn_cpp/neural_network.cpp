#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.29075527f, -0.74679583f, -0.41243047f, -0.39462140f, 0.61075824f, 0.70588958f, -0.07701877f, 0.10051162f, 
    -0.45341328f, 0.85884327f, -0.68460631f, -0.08585843f, 0.24232896f, -0.53764760f, 0.14850920f, 0.22975661f, 
    0.10529184f, 0.16017030f, -0.70166326f, -0.39859304f, -0.55267942f, 0.28076962f, -0.59566271f, 0.07565657f, 
    0.20094411f, 0.12575136f, 0.00420990f, -0.18984044f, 0.05360089f, -0.15434486f, 0.38936630f, 0.20555624f, 
    0.68191874f, 0.17834683f, 0.27310061f, 0.59704781f, -0.09961966f, -0.02540813f, 0.26798224f, 0.02415847f, 
    -0.18540314f, -0.26347780f, 0.67528218f, 0.54153419f, -0.14788896f, -0.45145455f, -0.48203862f, 0.10118173f, 
    0.57578671f, 0.50490516f, 0.46123111f, 0.14318128f, -0.24667609f, 0.27045351f, -0.08780390f, 0.26599789f, 
    0.36092505f, -0.58628589f, 0.79287064f, -0.41307974f, -0.01681273f, 0.27310187f, -0.10338605f, 0.33715320f, 
    0.26763543f, -0.06081070f, 0.36542082f, 0.37477219f, 0.43575168f, -0.69218493f, 0.25668335f, 0.17514805f, 
    0.20216176f, -0.03555423f, 0.41705745f, 0.36404169f, 0.44735131f, 0.00223897f, -0.41815901f, -0.44169223f, 
    -0.46079990f, -0.53535914f, -0.51657683f, -0.27994829f, 0.42340350f, 0.77344567f, -0.40537554f, -0.08431488f, 
    0.06758061f, -0.05698806f, 0.23028101f, 0.54492915f, 0.31614494f, -0.65540373f, -0.55286556f, 0.20114064f, 
    -0.38838464f, -0.01326891f, -0.50143367f, 0.65563661f, 0.25840876f, 0.64579695f, -0.09868455f, -0.62163705f, 
    0.18499099f, -0.07815981f, 0.25742310f, 0.13196076f, 0.67795318f, 0.55886561f, -0.51912391f, 0.50122064f, 
    0.27887526f, -0.01511803f, 0.35474178f, 0.43007281f, 0.17714894f, 0.58745468f, -0.17377678f, -0.55579269f, 
    -0.78453964f, -0.05344979f, 0.17162159f, -0.51280642f, -0.45141226f, 0.16288191f, 0.62169039f, 0.44071883f, 
    0.47568762f, 0.29664022f, -0.07292487f, -0.55026710f, -0.35392407f, -0.12188358f, 0.26299128f, -0.77428257f, 
    -0.01596885f, 0.19422387f, 0.42878819f, 0.60647583f, 0.44410220f, -0.33230907f, 0.36362135f, 0.07343394f, 
    0.77262324f, -0.46186334f, 0.40094069f, 0.72712576f, 0.12593305f, 0.16221842f, -0.02806688f, 0.27372470f, 
    -0.31637412f, -0.02577456f, -0.51491296f, -0.65548950f, 0.41924381f, 0.07825245f, 0.05549622f, -0.33562335f, 
    -0.20336057f, -0.24587174f, -0.17345139f, 0.46778730f, -0.09264942f, 0.40934828f, -0.37958056f, -0.06608578f, 
    -0.55221969f, -0.43818477f, -0.64317745f, -0.43420124f, -0.81457978f, -0.36044887f, -0.43846589f, -0.22496229f, 
    -0.12289768f, 0.44531870f, 0.42876557f, 0.46517670f, 0.61463189f, -0.16989394f, 0.13212916f, -0.98358107f, 
    -0.44713894f, -0.75131202f, 0.15149803f, 0.24988890f, 0.08457571f, -0.33126923f, 0.00127807f, 0.60716015f, 
    -0.73335683f, 0.35460651f, 0.06913054f, -0.15188856f, 0.18430547f, 0.46561155f, -0.82810920f, -0.45878947f, 
    -0.31444451f, -0.27958766f, 0.32505503f, 0.74196076f, 0.37074441f, -0.12133804f, 0.09383141f, -0.00662246f, 
    -0.59080011f, -0.44196123f, -0.44464841f, -0.03246200f, -0.56315470f, -0.34599155f, 0.31839207f, -0.33209017f, 
    0.52972311f, -0.62873101f, -0.49942973f, -0.17822945f, -0.45053580f, -0.07964302f, -0.26367423f, -0.06844860f, 
    0.44362935f, -0.68464178f, 0.28348792f, 0.73041981f, 0.72199470f, 0.05837914f, -0.83027881f, -0.02160133f, 
    0.24711859f, 0.10792094f, -0.74679965f, -0.50167245f, -0.54254436f, -0.53227848f, -0.38431251f, -0.15655211f, 
    -0.45267895f, 0.03136625f, -0.25171918f, 0.47086188f, 0.39653879f, 0.20531982f, 0.40796024f, 0.61758429f, 
    -0.02505174f, 0.10402821f, -0.17975479f, -0.01130051f, 0.38767800f, -0.51053131f, -0.43494639f, -0.54355311f, 
    0.52264726f, -0.59200877f, 0.18676287f, 0.36004487f, 0.14283048f, -0.10188750f, 0.61795431f, -0.69175136f, 
    -0.06957196f, -0.02639936f, -0.51770854f, 0.20666797f, -0.18834434f, 0.32640228f, 0.54507411f, 0.48475915f, 
    0.60909694f, 0.21269727f, -0.30231988f, 0.29609442f, 0.35344398f, 0.09037891f, -0.07445299f, 0.68796599f, 
    0.06615248f, -0.49661705f, 0.26858374f, 0.52298051f, -0.19081920f, -0.24648827f, 0.25248054f, -0.12491517f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.34496787f, -0.07569686f, 0.02061336f, -0.18754445f, 0.00578731f, 0.30134064f, -0.17257245f, -0.03871695f, 
    -0.04050201f, -0.03558534f, 0.12245076f, 0.13454047f, -0.14544895f, -0.10868727f, -0.04317379f, -0.20152511f, 
    -0.11859679f, -0.07515715f, 0.02258828f, 0.09132920f, 0.15274027f, 0.02909660f, 0.00969648f, 0.09841170f, 
    -0.03709962f, -0.25122827f, 0.18070902f, 0.22084908f, 0.19646902f, 0.09281228f, 0.20308736f, -0.24362636f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.29315263f, -0.03827948f, 0.28700015f, 0.00456763f, 0.13693644f, 0.00152516f, -0.04943449f, 0.15779310f, 
    0.17795125f, 0.13293432f, 0.14804970f, -0.24173187f, -0.03829348f, -0.10840289f, -0.06227847f, -0.05726881f, 
    0.00070084f, -0.03987671f, -0.08879386f, 0.05314979f, 0.13174866f, 0.13614061f, 0.03158356f, 0.01657290f, 
    0.04073213f, 0.10570272f, -0.01417311f, 0.01027297f, -0.01402342f, -0.04022935f, -0.00616973f, -0.01863126f, 
    -0.06098716f, -0.04016054f, 0.10124498f, -0.06159910f, -0.06948197f, -0.07068332f, -0.14404149f, -0.00302963f, 
    0.08249294f, 0.05775727f, 0.05841416f, -0.12119842f, -0.09989303f, -0.11561487f, -0.02153183f, 0.04045702f, 
    0.07082418f, 0.01393148f, -0.10579605f, -0.01948718f, 0.03186492f, 0.00234156f, 0.23033687f, -0.18115796f, 
    0.12418815f, -0.00181582f, 0.13448150f, -0.02025182f, -0.03057107f, 0.03922021f, -0.06241971f, 0.01459986f, 
    -0.09996698f, 0.10587741f, -0.01491194f, 0.14306730f, 0.08462328f, -0.01373110f, -0.05700484f, 0.03625137f, 
    0.11522882f, 0.05099909f, 0.04262524f, -0.05944534f, 0.00513457f, 0.09941125f, -0.00353086f, -0.01283310f, 
    -0.08892832f, -0.11727167f, 0.07556574f, 0.27365127f, 0.01739144f, 0.08173634f, 0.01247861f, -0.01666681f, 
    0.13261911f, -0.10071204f, 0.03824031f, -0.05223073f, -0.12635909f, -0.19628796f, -0.06340553f, -0.06408742f, 
    -0.24085896f, -0.02061168f, -0.07027161f, -0.00187639f, 0.10362835f, -0.15043297f, -0.05818580f, -0.06064416f, 
    -0.14938377f, -0.10658403f, -0.02265325f, 0.07728743f, -0.15685931f, 0.20046508f, 0.27317366f, -0.07626132f, 
    -0.00195031f, -0.27946183f, -0.02464928f, -0.08620290f, -0.03865441f, 0.28008690f, 0.04948452f, 0.05340947f, 
    -0.01891810f, -0.07316345f, -0.03279696f, -0.11416491f, 0.08040688f, -0.01189554f, -0.13737693f, 0.18828459f, 
    -0.08362581f, -0.10266075f, 0.07972004f, 0.00596031f, 0.07045774f, 0.08816981f, -0.04109800f, 0.10738257f, 
    -0.13501668f, 0.00819559f, 0.01600202f, 0.07494731f, -0.06803180f, -0.06496406f, -0.04184596f, 0.03115071f, 
    -0.17257620f, 0.05022955f, 0.02160784f, -0.04606807f, 0.05628470f, 0.06031337f, 0.06869877f, -0.06477184f, 
    -0.03323510f, 0.16531497f, 0.18077461f, 0.26544604f, -0.00160416f, 0.02371354f, 0.04986672f, -0.05396217f, 
    -0.05295043f, 0.02970959f, 0.09909116f, 0.10630126f, -0.06038709f, -0.08911566f, -0.03547993f, 0.01803958f, 
    -0.13952687f, -0.07609877f, 0.04548667f, 0.14245729f, -0.03310914f, 0.17940521f, -0.10110725f, 0.01857616f, 
    0.00679229f, -0.03671871f, 0.07587960f, -0.11498027f, 0.24047582f, -0.00840637f, -0.24415722f, -0.13730828f, 
    -0.07624701f, -0.04467197f, 0.02619783f, -0.11572181f, 0.05825217f, 0.04928703f, -0.36563420f, -0.02977427f, 
    -0.09346557f, -0.08041671f, -0.08858147f, -0.09022447f, -0.01709866f, 0.07290661f, 0.02946024f, -0.06848181f, 
    0.07057235f, 0.01095506f, 0.05834247f, -0.13490245f, 0.03250388f, -0.00519260f, 0.02915783f, 0.17708860f, 
    -0.02063300f, 0.15232001f, -0.00290140f, -0.04317035f, 0.02462411f, -0.02875004f, 0.10536285f, -0.19089647f, 
    0.26355386f, 0.10832296f, 0.02656895f, -0.10785479f, 0.00759795f, -0.02617974f, -0.13086447f, 0.14859502f, 
    -0.09031624f, 0.02050239f, 0.08599886f, -0.31146592f, 0.05926182f, -0.05885582f, 0.05834037f, -0.09794145f, 
    0.03515503f, -0.02370784f, 0.11595391f, -0.03111899f, 0.18219008f, 0.05710249f, -0.01219095f, -0.02288777f, 
    0.00723428f, -0.06244500f, -0.06133766f, -0.09853469f, -0.00750450f, 0.14493503f, -0.08563950f, -0.12191046f, 
    -0.05985184f, 0.01572053f, -0.11655948f, 0.00917746f, 0.14271283f, -0.08497149f, 0.16589037f, -0.08630504f, 
    0.01441688f, -0.02302672f, -0.08050050f, 0.02493881f, -0.05920847f, -0.26512989f, 0.04656983f, 0.17600495f, 
    0.11068390f, -0.13632259f, -0.03224010f, 0.04285133f, 0.01065716f, 0.01554754f, -0.12945376f, -0.09869151f, 
    0.02336186f, 0.05669960f, -0.03581852f, -0.03146666f, -0.10215788f, 0.03508614f, 0.02493409f, -0.18412863f, 
    0.12460732f, 0.01437152f, -0.05440383f, 0.05917555f, -0.00835111f, 0.00404039f, 0.17124070f, 0.04074594f, 
    0.10555366f, -0.12232817f, -0.34490001f, 0.11641853f, 0.05381171f, -0.12729266f, 0.00760531f, 0.01238242f, 
    -0.10391493f, -0.22294199f, -0.12949200f, 0.03367201f, 0.05143012f, -0.08116227f, 0.05150590f, 0.08336312f, 
    -0.04925971f, 0.00664746f, -0.40729523f, 0.04165774f, -0.06771001f, 0.01567078f, -0.01418079f, -0.04938627f, 
    0.13843273f, 0.11007001f, -0.02402870f, -0.17444769f, -0.06633560f, 0.00431977f, -0.01559396f, 0.09786145f, 
    0.02897722f, 0.12121806f, -0.10051067f, 0.04154605f, -0.02310218f, -0.02766223f, 0.00019221f, -0.15301336f, 
    0.07308819f, 0.08945958f, 0.02749157f, 0.12631613f, -0.01180206f, -0.09717445f, -0.00799047f, 0.02804475f, 
    0.06126409f, 0.10603473f, -0.00355874f, 0.07237940f, -0.07560854f, -0.01579618f, -0.09829894f, 0.02176381f, 
    -0.07996616f, 0.11184506f, 0.13174380f, 0.02365966f, -0.07065029f, -0.14652658f, 0.01732197f, 0.08774053f, 
    0.05876282f, -0.04165584f, -0.03469860f, 0.01903690f, -0.03349228f, 0.01348375f, 0.08123996f, 0.03371206f, 
    0.14733130f, -0.03640792f, 0.02964199f, -0.01698536f, 0.11755333f, -0.06615619f, 0.18774222f, 0.12452306f, 
    0.07105287f, -0.24335995f, -0.05467954f, -0.24081440f, 0.06019369f, 0.09543911f, 0.06136415f, -0.02432246f, 
    0.01923536f, -0.08792512f, 0.01148198f, 0.04920745f, 0.03822042f, 0.11508069f, -0.04714611f, 0.03260379f, 
    0.03668156f, 0.05902287f, 0.12081032f, 0.15657870f, 0.09377035f, 0.16927323f, 0.03370496f, -0.05873770f, 
    0.14194843f, -0.01065976f, 0.07741591f, 0.14533061f, 0.00581932f, -0.02938319f, 0.13137743f, -0.07168960f, 
    0.07136389f, -0.03817915f, -0.10069603f, 0.03121625f, 0.03862513f, -0.14174832f, -0.22708137f, 0.08574525f, 
    0.08086461f, 0.16824032f, 0.08970734f, -0.03168097f, 0.02390353f, -0.02289697f, 0.25096086f, 0.09859302f, 
    0.17782661f, -0.13145806f, 0.10201159f, 0.13067302f, -0.08389392f, 0.15939973f, 0.15666510f, -0.31680456f, 
    -0.10436412f, -0.03419993f, -0.07019192f, 0.09443075f, -0.00769562f, 0.04712588f, -0.05206050f, 0.09446335f, 
    -0.03880486f, -0.05471217f, 0.00119932f, -0.14426592f, 0.06358683f, 0.00312467f, -0.03290464f, 0.02576701f, 
    0.08055608f, 0.06082868f, 0.16745582f, -0.32345176f, -0.03257455f, 0.02680138f, -0.10282581f, 0.09517200f, 
    0.17343281f, -0.17182900f, -0.12448678f, 0.13312596f, 0.15418041f, 0.10811745f, 0.14245446f, -0.15676153f, 
    0.24086125f, 0.00077197f, 0.01686841f, -0.14362966f, -0.04753859f, -0.06143021f, -0.05625777f, -0.02364155f, 
    0.01378609f, 0.13687193f, 0.10260409f, 0.04038942f, 0.14536858f, 0.02076548f, 0.01486340f, -0.12097038f, 
    0.03189125f, 0.10975482f, -0.01541420f, -0.00232895f, 0.23750913f, -0.05479723f, -0.03164652f, -0.07770547f, 
    -0.06024006f, 0.00710712f, -0.00766725f, 0.14527181f, -0.01966305f, 0.09124524f, -0.32478157f, -0.20940045f, 
    -0.08085524f, 0.03518904f, -0.02936364f, 0.09369536f, 0.02381553f, 0.08150125f, 0.00980889f, -0.13714521f, 
    -0.03716738f, -0.00834189f, 0.04989809f, 0.07227378f, 0.10690556f, -0.04536179f, 0.04961121f, -0.12726671f, 
    -0.22887039f, -0.25084311f, 0.04368620f, -0.06744144f, 0.05150642f, -0.06170070f, -0.01633649f, -0.18504189f, 
    0.01078083f, -0.23070632f, -0.19765750f, 0.27988973f, -0.00042105f, 0.13215587f, 0.02932308f, -0.03044674f, 
    0.09060480f, -0.06933905f, -0.27696770f, 0.15685260f, -0.04110801f, 0.06638113f, 0.17462994f, -0.05456065f, 
    0.09283256f, 0.15468358f, -0.10689599f, 0.19739585f, 0.05549731f, 0.08876183f, -0.09138587f, 0.04073994f, 
    0.01118642f, 0.11406564f, 0.03256659f, 0.06296190f, -0.15320741f, -0.08256999f, 0.09807676f, 0.03236399f, 
    -0.00794006f, -0.09338146f, -0.01975856f, -0.12579025f, -0.00703284f, -0.00749531f, -0.07099131f, 0.25009054f, 
    0.00229046f, 0.05187869f, 0.01318623f, 0.01549273f, 0.02197626f, -0.06023497f, 0.15282030f, 0.11850163f, 
    0.21210636f, 0.12077934f, 0.05866227f, 0.11805849f, -0.08341078f, 0.07340296f, 0.07596909f, -0.11903997f, 
    -0.27389604f, 0.06128233f, -0.00663024f, 0.05974108f, 0.01820102f, 0.01754183f, 0.13108975f, 0.08596464f, 
    -0.25122339f, -0.12551604f, -0.15299995f, -0.11996282f, 0.03989840f, -0.02599251f, 0.08683715f, -0.05351935f, 
    0.23462042f, -0.09326506f, -0.13181293f, -0.18602063f, -0.07363882f, -0.09215751f, -0.01572660f, -0.00076031f, 
    0.02309468f, -0.08090248f, 0.07844499f, 0.06815529f, 0.11883359f, 0.03418080f, 0.02568073f, -0.04838394f, 
    0.09329034f, 0.02383542f, -0.05598305f, -0.23522004f, -0.06505401f, -0.00032025f, 0.19403392f, 0.27080151f, 
    0.09511055f, -0.08555249f, -0.00777981f, -0.25283259f, 0.12781590f, 0.05944578f, -0.02376443f, 0.02778832f, 
    -0.00306287f, -0.01912552f, -0.06535507f, 0.07763483f, -0.09087869f, -0.18259411f, -0.00403688f, -0.00518685f, 
    0.21642730f, 0.11401933f, 0.11792044f, -0.01477472f, -0.06427333f, 0.05365998f, 0.11690520f, 0.10674120f, 
    -0.02723434f, -0.07827883f, -0.12559940f, -0.05074282f, -0.06582828f, 0.00681773f, 0.23454331f, -0.18863299f, 
    -0.16316031f, -0.01944153f, 0.16722193f, 0.11662917f, 0.07744500f, -0.03880461f, -0.01220753f, -0.13218252f, 
    -0.10034950f, -0.04411971f, -0.02632955f, 0.00044992f, -0.02584280f, 0.23136692f, 0.09163739f, 0.14549506f, 
    0.00036855f, -0.24307421f, 0.02561261f, 0.06584585f, 0.07378206f, 0.02130788f, 0.02402801f, -0.13877305f, 
    0.08861839f, 0.02968089f, 0.03670616f, 0.16405639f, -0.06833736f, -0.07448680f, -0.05779503f, -0.09083323f, 
    0.09003640f, 0.09939511f, 0.14294389f, 0.14627580f, -0.07002795f, 0.02024087f, 0.10019603f, -0.00548781f, 
    -0.01719259f, 0.14525342f, 0.15648124f, 0.16702488f, -0.03046242f, -0.17855133f, -0.07227154f, 0.13951683f, 
    0.10239572f, 0.12635420f, -0.01847012f, -0.07560576f, -0.19067636f, 0.09563007f, 0.10155328f, -0.19012430f, 
    -0.21354374f, 0.09151759f, 0.00249984f, 0.26697651f, 0.08300832f, 0.06630169f, 0.25394094f, 0.06116888f, 
    0.19746058f, 0.07452992f, -0.07669777f, 0.06569310f, 0.09785855f, 0.03578818f, 0.20707993f, -0.27347502f, 
    0.01655547f, -0.00654235f, 0.17650130f, 0.17274658f, 0.26131195f, -0.04307934f, -0.01190948f, -0.04699217f, 
    -0.22527973f, -0.06086602f, -0.21965070f, 0.12518841f, 0.03914527f, -0.00296292f, 0.02915868f, 0.01389229f, 
    -0.17905426f, 0.01855707f, -0.01198979f, 0.19498134f, -0.04805343f, -0.10605012f, 0.08467406f, -0.07991003f, 
    0.02604856f, 0.17515713f, 0.13635634f, 0.05677613f, 0.09182440f, 0.01622454f, 0.03913659f, 0.23523724f, 
    -0.01553364f, 0.18189362f, -0.08820858f, -0.21435584f, 0.00922539f, 0.09848959f, 0.17325045f, 0.10475927f, 
    0.04317095f, 0.08275209f, -0.05226816f, -0.21252398f, -0.02304564f, 0.04673308f, -0.06697594f, -0.04132175f, 
    -0.14828481f, -0.06979599f, 0.01280328f, 0.16596733f, 0.09142594f, -0.05618547f, 0.09604117f, 0.01257461f, 
    -0.08114297f, 0.00321498f, 0.05196643f, 0.01618710f, -0.10014732f, -0.11234475f, -0.21742034f, 0.03230410f, 
    0.02255859f, 0.08993726f, 0.09082837f, 0.00630502f, -0.00521034f, 0.03612621f, 0.03581388f, 0.04952497f, 
    0.08915206f, 0.10960922f, -0.09523651f, -0.19139840f, -0.04866346f, 0.07659433f, 0.08501492f, 0.16874583f, 
    0.18998395f, 0.10737937f, -0.03123702f, -0.06330934f, -0.05375847f, 0.03844819f, 0.06638821f, 0.11205754f, 
    0.01734509f, 0.04536847f, 0.01070115f, -0.09239846f, -0.08985672f, -0.00941081f, 0.09123822f, 0.12201496f, 
    -0.07207976f, 0.00785528f, 0.08104704f, 0.07282248f, 0.17884898f, -0.10790098f, -0.01917977f, 0.01054124f, 
    0.10006081f, 0.09812607f, 0.18175919f, -0.08709806f, -0.03884187f, 0.03260477f, 0.18665631f, 0.07270794f, 
    0.17426656f, -0.01326851f, 0.15190387f, -0.05019728f, -0.04730817f, 0.10195657f, 0.06473310f, 0.03166803f, 
    0.06080860f, -0.01700387f, -0.04673705f, 0.04656165f, -0.01030089f, 0.16879289f, -0.10681628f, 0.18600926f, 
    0.04841833f, 0.10441346f, -0.00471339f, -0.01504271f, -0.04205673f, 0.00136116f, 0.17843910f, -0.07738566f, 
    -0.08523656f, 0.03897476f, 0.06471846f, 0.06660820f, 0.05899505f, 0.09456116f, 0.08797584f, 0.03998065f, 
    -0.07578023f, -0.05352633f, 0.04576677f, -0.00973682f, -0.00948286f, 0.00357692f, 0.09392191f, -0.09510965f, 
    -0.04263210f, 0.03132949f, 0.00650668f, 0.00299882f, 0.01433514f, -0.01688903f, -0.05743483f, 0.01757451f, 
    0.03768616f, -0.05450349f, 0.03848093f, 0.01015432f, 0.02680647f, -0.02879487f, 0.04992572f, -0.01641236f, 
    -0.01618725f, -0.03423506f, 0.03960690f, 0.02005686f, 0.05194189f, 0.00822765f, 0.02245934f, 0.01441451f, 
    -0.03852907f, -0.04864737f, 0.00136254f, -0.05539579f, 0.00655730f, -0.03778880f, -0.04145294f, 0.04572925f, 
    -0.00177734f, -0.02096788f, 0.03523549f, 0.02667071f, -0.04834428f, -0.00819784f, -0.03952053f, -0.01544651f, 
    -0.05094092f, -0.02952472f, -0.00985807f, -0.05305108f, -0.00197715f, 0.03852846f, 0.03380682f, -0.02700633f, 
    0.01525939f, -0.04059691f, -0.05177505f, 0.01854510f, 0.02703976f, -0.05606722f, 0.05415534f, 0.01231067f, 
    -0.03977626f, 0.03940653f, 0.00732365f, -0.03752277f, 0.03149383f, 0.01906690f, -0.05344329f, 0.04234452f, 
    0.01058589f, 0.03367497f, 0.05425130f, -0.01883082f, 0.04634883f, -0.04677562f, -0.06289777f, 0.03117994f, 
    -0.04513608f, 0.01058091f, -0.02579379f, 0.04803422f, 0.02961198f, -0.06185494f, 0.04501142f, -0.06078581f, 
    -0.03865136f, -0.03846218f, -0.05749338f, 0.03099057f, -0.00492342f, 0.00623637f, 0.00936794f, -0.05416193f, 
    0.01975830f, 0.02583909f, 0.02296715f, -0.01243708f, -0.01922434f, -0.01960237f, 0.02258657f, 0.03976320f, 
    -0.05641568f, 0.01256912f, -0.06182875f, 0.02622273f, -0.01122453f, 0.02244988f, -0.05627165f, 0.02045261f, 
    -0.00458054f, 0.05158092f, 0.04149532f, -0.03620992f, 0.02625876f, -0.02141331f, -0.05323644f, 0.04540338f, 
    0.01435397f, -0.06092649f, 0.01732729f, 0.04880885f, 0.02223794f, 0.03157375f, 0.04173517f, 0.01683196f, 
    -0.01359288f, 0.04102698f, -0.02221134f, -0.00591854f, 0.01732323f, -0.04341137f, 0.03040160f, 0.00222639f, 
    0.02605595f, 0.00149062f, 0.05027439f, 0.01408375f, 0.03395111f, -0.02469859f, -0.01472368f, 0.01319835f, 
    -0.02496446f, 0.03573065f, -0.01430747f, 0.04177287f, -0.04539856f, 0.01980984f, -0.02039696f, -0.03115655f, 
    -0.02512732f, -0.05059053f, 0.04953661f, 0.00676761f, -0.03074072f, 0.04026842f, 0.04480654f, 0.00340361f, 
    -0.04240271f, -0.02986028f, -0.01585013f, -0.03516364f, 0.03738501f, -0.00536667f, -0.02110711f, -0.05899573f, 
    -0.05865270f, -0.03869941f, -0.00433483f, -0.06247170f, 0.00002593f, 0.01816666f, 0.01100831f, -0.03574659f, 
    -0.05538669f, -0.03313483f, 0.01208250f, -0.01509420f, -0.03321592f, 0.02554348f, -0.04119737f, -0.04923300f, 
    -0.06830114f, 0.01806870f, -0.03491357f, -0.03026689f, -0.01884143f, 0.00698435f, 0.00455896f, -0.06186060f, 
    -0.03239051f, -0.06221569f, 0.04130581f, -0.03157352f, -0.04554848f, -0.01819770f, 0.01691643f, -0.05468273f, 
    0.04471119f, -0.02259937f, -0.05768060f, -0.00116938f, 0.02354325f, -0.01289430f, 0.02045112f, -0.00299323f, 
    -0.00037516f, 0.02624759f, 0.04882384f, -0.02050528f, 0.01933562f, -0.00442823f, -0.02446189f, -0.02914099f, 
    -0.02879383f, -0.01011659f, 0.02281066f, -0.02798034f, 0.02062909f, 0.02864329f, -0.04599512f, -0.02284064f, 
    0.03479650f, -0.02842874f, -0.02051447f, -0.05596637f, -0.02442759f, -0.03907683f, -0.03652864f, 0.01031829f, 
    -0.02613193f, -0.06119415f, -0.02036142f, -0.05547000f, 0.02657125f, -0.04977379f, 0.04461471f, -0.01622369f, 
    -0.00357349f, 0.04278491f, 0.04754903f, -0.05304459f, -0.06146730f, -0.02261945f, -0.03170012f, 0.04023654f, 
    0.04877986f, -0.03209654f, -0.01542914f, -0.02111297f, -0.06127761f, -0.02896167f, -0.04161058f, -0.04636695f, 
    -0.03683692f, 0.04378993f, 0.01135022f, -0.02921108f, 0.03521071f, 0.01878630f, 0.04693312f, -0.04072268f, 
    -0.06312405f, 0.04982628f, -0.03047445f, -0.01678835f, 0.03390786f, 0.01499799f, -0.03467328f, -0.02880128f, 
    -0.04671402f, -0.04094150f, -0.01518336f, 0.02735361f, -0.03219904f, -0.02236244f, -0.05084430f, -0.03879524f, 
    -0.03454158f, -0.02158968f, 0.00287361f, -0.01000414f, 0.00464966f, 0.00072493f, -0.02387633f, -0.00680259f, 
    0.00415993f, -0.00790847f, -0.01085433f, -0.03769547f, -0.06346262f, -0.01473776f, 0.00327742f, -0.04654876f, 
    0.01291577f, 0.06911932f, 0.08471720f, -0.08036865f, 0.00324349f, -0.07125399f, 0.03847035f, -0.04462915f, 
    -0.09324162f, -0.15296842f, 0.05635604f, 0.06281519f, -0.13373098f, -0.02918488f, -0.08505667f, -0.02452048f, 
    0.18220541f, -0.14815368f, -0.21374609f, 0.09529281f, 0.14872764f, -0.01803929f, -0.02160135f, 0.06747467f, 
    0.03821069f, 0.10240091f, -0.06897055f, 0.13409789f, 0.02246521f, 0.15529121f, 0.01233569f, -0.07896782f, 
    0.10441598f, -0.05568668f, -0.05579287f, 0.17201769f, 0.19559903f, 0.09142495f, 0.06554011f, -0.08809002f, 
    -0.00655025f, -0.06613160f, 0.00927487f, 0.11262257f, 0.14342326f, 0.15075132f, 0.05456547f, 0.02245675f, 
    0.02439050f, -0.08889681f, -0.10393598f, -0.02100541f, 0.00220272f, 0.08798509f, -0.11047287f, -0.10742462f, 
    -0.43318969f, -0.08713973f, -0.05088316f, 0.21608733f, 0.01165039f, 0.12435884f, -0.08293776f, 0.02140789f, 
    -0.10868200f, -0.07597479f, -0.00295787f, -0.04469670f, 0.10629872f, 0.09098666f, 0.13130684f, 0.08890602f, 
    -0.09117764f, 0.07275004f, -0.04665044f, 0.02789284f, 0.01667420f, 0.09863106f, 0.13377374f, 0.01196469f, 
    0.04083696f, -0.00650802f, 0.01071446f, -0.00923838f, -0.24351451f, 0.03889981f, 0.08321477f, 0.12037457f, 
    -0.01537440f, -0.02048852f, -0.08434843f, -0.10423280f, -0.07613038f, 0.25544801f, 0.08572666f, 0.15037784f, 
    0.05517088f, 0.01164795f, 0.07115587f, -0.05849423f, -0.07398990f, -0.09324925f, 0.02759559f, 0.08865572f, 
    0.02841487f, -0.07115036f, 0.00546868f, 0.04639831f, -0.02982438f, 0.10803167f, -0.09304628f, -0.06655365f, 
    -0.08774491f, -0.05257126f, -0.06313032f, 0.04111995f, 0.10087333f, -0.19845402f, 0.00240254f, 0.10282095f, 
    0.25790635f, 0.01252274f, 0.08217394f, 0.13573712f, -0.04670852f, -0.12704320f, -0.24462318f, -0.10147122f, 
    -0.07443807f, 0.13293828f, 0.04628458f, 0.05946726f, 0.02478910f, -0.08412210f, -0.02378197f, 0.09232033f, 
    -0.00964841f, 0.05874785f, -0.02924901f, -0.04971490f, 0.14271377f, 0.06835008f, -0.03591655f, 0.10597570f, 
    -0.22377127f, 0.02661742f, 0.01645613f, -0.09829288f, 0.09182953f, -0.14262961f, 0.05044285f, 0.02088854f, 
    0.05074575f, 0.02385758f, 0.06165985f, 0.17100573f, 0.03968331f, -0.02764936f, -0.13448040f, -0.04114408f, 
    0.11793476f, -0.03640267f, -0.21052226f, -0.17566177f, -0.13883713f, 0.04479493f, -0.01840001f, -0.00919913f, 
    -0.07547033f, -0.12181555f, -0.12648763f, -0.05255647f, 0.13878304f, 0.07481188f, 0.00735740f, -0.02030781f, 
    -0.00602159f, -0.06420233f, 0.10201929f, -0.03457766f, 0.18043397f, 0.10473348f, -0.09764682f, 0.10714246f, 
    0.12969904f, 0.05624559f, -0.06350263f, 0.12700053f, -0.02680575f, -0.01588236f, -0.12196854f, -0.10638062f, 
    -0.06647202f, -0.04323069f, 0.04376584f, 0.09146851f, -0.03340066f, -0.00698646f, 0.04768209f, -0.03143810f, 
    0.10252271f, 0.11018421f, 0.08216649f, 0.05017399f, 0.06152549f, 0.04379793f, 0.03711905f, -0.15387183f, 
    0.08151196f, -0.06422467f, 0.04041439f, -0.04983724f, 0.17078695f, 0.08315216f, -0.01229359f, -0.05968879f, 
    -0.15652353f, 0.04944861f, -0.06398789f, 0.10045258f, -0.10325439f, 0.04005779f, -0.09019139f, 0.03934121f, 
    0.05498671f, -0.04097126f, -0.03366550f, -0.04215130f, -0.12663314f, 0.00542431f, -0.09638019f, 0.06300297f, 
    -0.03880295f, 0.12032622f, -0.19213890f, 0.01050865f, -0.13615581f, 0.09394948f, 0.08514922f, 0.07125436f, 
    0.07393163f, -0.00910967f, 0.01595858f, -0.06237531f, -0.12491324f, -0.10826929f, 0.05359253f, -0.06945314f, 
    -0.05358458f, 0.11846723f, -0.11865209f, 0.07380810f, -0.06812426f, 0.09969345f, -0.05691819f, 0.00407001f, 
    0.06398198f, 0.03154488f, 0.03844201f, -0.05081370f, -0.04526095f, -0.05037704f, -0.09473341f, -0.30885452f, 
    -0.09665719f, -0.09337855f, 0.02749041f, -0.02778776f, -0.05272391f, 0.01704199f, -0.22868982f, 0.07050322f, 
    0.08208636f, 0.17444393f, 0.07540157f, -0.03158230f, -0.09884682f, -0.04057014f, 0.02269627f, -0.09033540f, 
    0.07374293f, -0.22565465f, -0.15060242f, -0.02168237f, -0.00610562f, 0.00276545f, 0.11049164f, -0.03124668f, 
    -0.04984099f, -0.06245149f, 0.03778741f, -0.03691804f, -0.05495420f, 0.00156070f, 0.02756068f, 0.03900267f, 
    -0.01005311f, -0.04060557f, -0.01089005f, -0.01827493f, -0.05334168f, 0.03240107f, 0.03543860f, -0.06875902f, 
    -0.06086595f, -0.02522693f, -0.03577609f, 0.04543278f, -0.06151243f, -0.01344382f, -0.00202277f, 0.04662472f, 
    0.03242856f, -0.03220059f, -0.01146758f, -0.05285905f, 0.02019885f, 0.04634189f, -0.03243099f, -0.01522562f, 
    0.03797171f, -0.06600846f, 0.01428126f, -0.02808040f, -0.01249423f, 0.03337745f, -0.02217731f, 0.02323237f, 
    0.00029839f, -0.06053820f, 0.01661649f, -0.03785865f, 0.01386981f, -0.05069510f, 0.03517060f, 0.01518440f, 
    0.04306471f, 0.00784048f, -0.05745813f, -0.01807779f, -0.00068208f, -0.03749087f, 0.04687628f, -0.00242797f, 
    0.02208252f, -0.00277987f, -0.02308196f, 0.00610274f, -0.02742834f, -0.06567447f, -0.05391745f, 0.02240920f, 
    -0.00369592f, -0.00247310f, -0.03173061f, -0.00125478f, 0.01351439f, -0.04997160f, -0.06123761f, -0.01724920f, 
    -0.05581475f, 0.02567833f, 0.01220972f, -0.00624388f, -0.06069619f, -0.01873654f, -0.04098709f, -0.00431981f, 
    -0.00319576f, -0.01064627f, -0.01364177f, -0.06890929f, -0.00011011f, -0.02619240f, -0.01679605f, -0.06876431f, 
    0.04424725f, -0.00425715f, -0.06217217f, -0.02653162f, -0.03067709f, 0.03912908f, 0.01729084f, -0.02381309f, 
    -0.04400131f, 0.03409350f, -0.04201223f, -0.06126078f, 0.02156994f, 0.01509081f, 0.01154658f, -0.04585922f, 
    0.01479252f, -0.05393828f, -0.06947235f, -0.00280175f, 0.04132544f, -0.01969193f, -0.04587837f, 0.01425924f, 
    0.02617270f, 0.00423340f, 0.02559131f, 0.03174981f, 0.02676715f, 0.03630917f, -0.01482107f, 0.00270074f, 
    -0.00909002f, -0.00694555f, -0.04755335f, 0.02660650f, 0.02464045f, 0.02549648f, -0.04869894f, -0.04539185f, 
    -0.01976774f, 0.01416671f, -0.02901205f, -0.00745588f, 0.00651333f, 0.00414811f, 0.01534803f, -0.05053896f, 
    0.00259861f, -0.04713992f, -0.02925321f, -0.04094331f, 0.03387221f, -0.06286845f, 0.03233644f, -0.06840360f, 
    -0.02865690f, -0.01315200f, 0.00430643f, -0.02957697f, -0.04236432f, -0.06258276f, 0.04468393f, 0.02340388f, 
    0.01385084f, -0.03514966f, -0.00658194f, -0.05490934f, -0.01396766f, 0.02078920f, -0.01586984f, -0.06568870f, 
    -0.03345048f, 0.00679675f, 0.03008327f, -0.03352940f, -0.06661616f, -0.04105332f, -0.03385445f, -0.03636356f, 
    -0.02057509f, -0.05268735f, -0.00010934f, -0.05379135f, 0.04052424f, -0.03401900f, -0.02131512f, -0.05764630f, 
    -0.02821479f, 0.04874265f, 0.04350739f, 0.01416482f, 0.02506342f, -0.06136249f, 0.00566769f, 0.02058482f, 
    -0.06955668f, 0.04427697f, 0.01203403f, 0.01131623f, -0.01452703f, -0.06453344f, 0.02071036f, -0.01591256f, 
    0.00167725f, -0.05935196f, -0.05240020f, -0.02869251f, 0.01236950f, -0.01046546f, -0.04407874f, -0.04416821f, 
    -0.03756654f, -0.03023333f, -0.05605339f, -0.02796341f, -0.03388314f, 0.04142168f, -0.01301985f, -0.04671787f, 
    -0.06139467f, 0.02008229f, 0.03313471f, -0.01901463f, 0.03778148f, -0.06940548f, -0.05132214f, 0.00908747f, 
    -0.06212487f, 0.02827722f, -0.05871020f, -0.03478007f, -0.04954934f, -0.03400847f, -0.02910583f, -0.06073566f, 
    0.03104970f, 0.01113807f, -0.00643538f, -0.05998232f, 0.01955936f, -0.02403281f, -0.02388116f, 0.03493341f, 
    0.00406161f, -0.05003204f, 0.03804014f, -0.01685709f, 0.02524752f, 0.04420049f, 0.02318530f, 0.03350841f, 
    0.02414815f, 0.02495018f, 0.02798097f, 0.02087265f, 0.00176130f, 0.02499846f, 0.03527671f, 0.00320288f, 
    0.03734212f, 0.02584533f, 0.02377425f, 0.02837117f, -0.02445955f, -0.06038302f, -0.03535423f, -0.02367090f, 
    -0.00797829f, -0.03101902f, -0.03937163f, 0.00659931f, 0.03960739f, -0.00684677f, -0.00101070f, -0.00168550f, 
    0.03009196f, 0.03527369f, -0.00439687f, 0.00202717f, -0.00436102f, 0.01128722f, 0.01841323f, -0.05483048f, 
    0.00561253f, 0.01081577f, 0.03016504f, 0.02007494f, 0.02050201f, 0.04235087f, -0.00544661f, -0.02884631f, 
    0.04016773f, -0.03725316f, -0.01163414f, 0.03972558f, 0.02281103f, -0.01817706f, 0.02087756f, 0.01933740f, 
    -0.22598845f, -0.00586570f, -0.10326593f, 0.08705723f, 0.08360185f, -0.01472688f, 0.04200467f, -0.14270730f, 
    0.05012445f, 0.06922993f, -0.22093399f, -0.27592856f, 0.00095544f, 0.00770207f, -0.06696849f, -0.03862655f, 
    -0.05252373f, 0.01092467f, -0.54803532f, -0.05535557f, -0.04429689f, 0.22462586f, 0.04079144f, 0.02029866f, 
    -0.02525596f, -0.07588080f, 0.01706436f, 0.11696053f, 0.17824006f, -0.16143399f, 0.09204662f, 0.05310526f, 
    0.09954934f, -0.08890638f, -0.07288563f, -0.18906477f, 0.02955950f, -0.02673190f, -0.08857519f, -0.09290241f, 
    -0.12707047f, -0.02080251f, 0.11428523f, -0.00151738f, -0.02284878f, 0.02195406f, 0.02696789f, -0.09804064f, 
    0.09143170f, 0.07671602f, -0.07186033f, 0.00300442f, 0.05892182f, -0.04888635f, -0.40223542f, 0.07799707f, 
    0.04426618f, 0.02626890f, -0.02378772f, 0.05140792f, 0.06233323f, -0.08799740f, -0.00073763f, -0.16727678f, 
    0.09769711f, 0.16058034f, 0.05785762f, 0.05449913f, 0.01819265f, 0.08101147f, 0.07725421f, -0.05596536f, 
    0.15788524f, 0.05104299f, -0.01354986f, 0.02279111f, -0.01811618f, -0.18940815f, 0.19258364f, 0.06220704f, 
    0.09516250f, -0.42769989f, -0.23937364f, -0.13265191f, 0.13451390f, 0.10580159f, -0.09491739f, -0.01210305f, 
    -0.10929923f, -0.06200907f, 0.12636372f, -0.00879749f, 0.15059708f, -0.05515410f, 0.07988086f, -0.00819958f, 
    0.01278821f, 0.17497210f, 0.11403412f, -0.02567893f, 0.05140968f, 0.19653881f, 0.08042386f, 0.00180822f, 
    -0.12133739f, 0.05873901f, 0.03446761f, -0.05022354f, -0.23843248f, 0.09150700f, -0.04744507f, -0.12217975f, 
    -0.11218432f, -0.08209548f, -0.03891796f, -0.12461813f, -0.11613399f, 0.00686182f, -0.08619460f, -0.01907151f, 
    -0.07095263f, -0.04187949f, -0.06902421f, 0.10103938f, -0.01803864f, 0.04337160f, -0.11053432f, 0.03120519f, 
    0.23749025f, 0.04068485f, 0.05524143f, -0.14220098f, 0.04118551f, 0.05620269f, 0.04939944f, 0.11507650f, 
    0.18242213f, -0.03310068f, 0.00278556f, 0.06684760f, 0.09681508f, -0.06807951f, -0.18821861f, -0.07228819f, 
    -0.08834007f, 0.19018783f, -0.04336986f, 0.07429183f, 0.03649985f, 0.00095354f, -0.03803491f, -0.01959175f, 
    -0.00849896f, -0.04233491f, 0.02515013f, 0.08487532f, 0.19999309f, -0.16451713f, 0.02165152f, -0.20402576f, 
    0.05373980f, -0.01546122f, 0.12164257f, 0.03849629f, 0.16917607f, -0.06362193f, 0.13111456f, -0.04643007f, 
    0.15758619f, 0.07510323f, -0.03832833f, -0.15632658f, -0.12098522f, 0.02833175f, 0.33087331f, 0.07288094f, 
    -0.03725103f, -0.00999444f, -0.03252498f, -0.04641558f, 0.12258317f, 0.12024873f, -0.00629569f, -0.22223915f, 
    -0.01468853f, 0.04812072f, 0.03284269f, 0.12059455f, 0.08008264f, -0.09933847f, -0.10666344f, -0.00505912f, 
    -0.00399620f, 0.08056810f, 0.02412893f, 0.07121300f, -0.03714267f, 0.11752731f, -0.26642799f, -0.13573061f, 
    -0.10375848f, 0.10262634f, 0.03745487f, 0.07986128f, 0.04790604f, -0.09284254f, -0.04034682f, 0.01658301f, 
    0.10311653f, 0.00225917f, 0.09823760f, 0.07174406f, 0.08435282f, -0.02549567f, 0.04231176f, 0.01191991f, 
    -0.02064749f, -0.13628152f, -0.09326416f, 0.02737462f, -0.14480522f, -0.03171482f, -0.05587695f, 0.01022959f, 
    0.01446227f, -0.27824661f, -0.07625318f, -0.03135059f, 0.09936590f, -0.11612195f, -0.09840521f, -0.07576960f, 
    0.06565624f, 0.16246988f, -0.12074925f, -0.00064220f, 0.11379056f, 0.16845651f, 0.10406990f, 0.04211803f, 
    0.06196358f, 0.04101488f, 0.01812378f, 0.00291294f, 0.21202563f, 0.14464191f, 0.01711654f, -0.04962062f, 
    -0.09916705f, 0.06812895f, 0.05925102f, -0.04509326f, -0.26665872f, 0.08986872f, -0.14317273f, 0.02211386f, 
    0.04961762f, 0.04988683f, 0.00021066f, 0.04442327f, 0.02789102f, -0.03983612f, -0.02592810f, 0.10995468f, 
    -0.00599310f, 0.00391540f, 0.07741490f, 0.04307653f, -0.07576561f, 0.01930075f, -0.02423231f, 0.12605020f, 
    0.20214254f, 0.12454769f, -0.00156521f, -0.01672386f, 0.03240440f, -0.05584823f, -0.04294383f, -0.12740913f, 
    -0.01807990f, 0.02754105f, -0.15503317f, -0.21456607f, 0.03370975f, 0.10695553f, 0.09708317f, -0.09883069f, 
    -0.02784618f, 0.08364268f, 0.21692137f, 0.04124829f, 0.07656927f, -0.14580405f, -0.15979554f, 0.07359096f, 
    -0.14457218f, 0.10579468f, 0.04471963f, -0.00991084f, -0.13951348f, 0.04693992f, -0.05143898f, 0.07728079f, 
    0.04992809f, -0.01326065f, 0.18889536f, -0.06264938f, -0.02904141f, -0.03618361f, 0.05212224f, 0.04510060f, 
    -0.07549117f, -0.02954456f, 0.08583010f, 0.09059728f, -0.00146715f, 0.02939203f, 0.03642466f, -0.02571525f, 
    -0.10518265f, 0.02845595f, 0.03921032f, -0.25021821f, 0.01972922f, 0.07180886f, -0.00202283f, 0.13767330f, 
    0.02121070f, -0.02026206f, -0.10122643f, -0.04046052f, 0.03859953f, 0.05993729f, 0.02887271f, -0.07059371f, 
    0.04298358f, 0.04966585f, -0.10877144f, 0.09747994f, 0.07303359f, -0.17100440f, 0.01156075f, 0.27196631f, 
    0.14203840f, 0.04770422f, -0.03554706f, 0.02810451f, -0.05595164f, 0.03563205f, -0.10645787f, -0.14734468f, 
    0.03499472f, -0.03971111f, 0.02546379f, 0.03599878f, 0.03405885f, 0.07168940f, 0.00923760f, -0.24994001f, 
    -0.02941002f, 0.04103979f, -0.07626121f, -0.02142245f, -0.00887893f, 0.18440391f, 0.13625111f, 0.00568627f, 
    -0.20499739f, -0.05598311f, 0.05090740f, 0.08913307f, 0.17415547f, 0.03052022f, -0.02892534f, 0.03825570f, 
    0.03086154f, 0.16980006f, 0.00103961f, -0.05145609f, -0.06443091f, -0.01848987f, 0.09959630f, -0.02606726f, 
    0.12290165f, 0.05396324f, -0.12949739f, -0.00389220f, -0.02292753f, -0.16027842f, -0.00582039f, 0.09248515f, 
    -0.08430921f, -0.00187355f, 0.03065131f, -0.15393119f, -0.07959340f, -0.07268333f, 0.08762448f, -0.04361045f, 
    0.03626511f, 0.05007590f, 0.02657761f, 0.00487850f, -0.13906375f, -0.01834554f, -0.01986226f, -0.07325884f, 
    -0.07452626f, 0.04433390f, -0.00822052f, 0.17093757f, 0.06315851f, -0.12944065f, -0.10535542f, -0.13718259f, 
    -0.12525818f, -0.03791256f, -0.06701715f, -0.02603416f, -0.05346505f, 0.11074435f, -0.06742969f, 0.10220276f, 
    0.06140878f, -0.01266295f, 0.08437325f, 0.00143482f, 0.09356113f, 0.14974183f, 0.00970758f, -0.18078393f, 
    -0.12565140f, 0.01138920f, -0.04872423f, -0.07436866f, 0.08688424f, -0.04899942f, 0.00650496f, 0.04365107f, 
    -0.23810822f, -0.08449246f, -0.01788380f, 0.15727136f, -0.04330590f, -0.05883070f, 0.09493249f, -0.00733502f, 
    -0.03677007f, 0.14136399f, 0.01193880f, 0.12792531f, -0.02451554f, -0.09097555f, -0.04846312f, 0.16299708f, 
    0.15017781f, 0.04913792f, -0.12102839f, 0.06194153f, -0.09891476f, -0.07411318f, 0.10050923f, 0.13597478f, 
    -0.04142471f, -0.01444993f, -0.10272913f, -0.06975729f, -0.00189538f, -0.05368480f, -0.09370641f, 0.05759862f, 
    -0.00073327f, -0.24680288f, 0.01567572f, -0.03425156f, 0.05562852f, -0.00173220f, -0.00133283f, 0.00158520f, 
    0.00002544f, -0.00951937f, -0.00094013f, 0.11636994f, 0.05284442f, -0.14143418f, 0.13577996f, 0.02974072f, 
    -0.09709530f, 0.00844592f, 0.04065878f, -0.04771643f, 0.05125836f, 0.02324615f, -0.11044234f, 0.06157815f, 
    0.14068240f, 0.05282797f, -0.01626495f, 0.04459167f, -0.15903273f, 0.03105024f, -0.08532459f, 0.16750003f, 
    0.16750744f, 0.06793686f, 0.00003487f, 0.02986719f, 0.14737271f, 0.01195824f, 0.04857607f, 0.05772678f, 
    -0.06176567f, 0.04700656f, 0.09393524f, 0.00469876f, 0.05532741f, -0.05230184f, 0.06919879f, -0.07198890f, 
    0.08396708f, -0.04531571f, 0.11259206f, -0.03284377f, 0.02781276f, -0.00273363f, 0.00361057f, -0.06854307f, 
    -0.02977899f, -0.13960764f, 0.18744530f, -0.19244929f, 0.09815782f, -0.05105207f, -0.01017744f, -0.10097709f, 
    0.18623239f, -0.01424162f, 0.00441910f, -0.24921887f, 0.03878329f, -0.00320274f, 0.04155926f, 0.01199795f, 
    0.03455376f, -0.08286487f, -0.10429347f, -0.00999253f, 0.00028694f, -0.01600590f, 0.11858919f, 0.15521052f, 
    0.01780372f, 0.01439110f, -0.10692361f, 0.15519457f, 0.04597245f, 0.09444016f, -0.18262596f, -0.11695153f, 
    -0.06732134f, -0.03756223f, 0.00989293f, 0.00168318f, 0.02766749f, -0.00846982f, -0.07687194f, -0.01054460f, 
    0.07536628f, 0.03753140f, -0.03581017f, -0.05419650f, 0.00684071f, 0.13571885f, 0.12256776f, -0.06912830f, 
    0.26319301f, 0.06577785f, -0.06602355f, -0.12110077f, -0.09093520f, 0.07482745f, -0.16516967f, -0.05115386f, 
    0.17877875f, -0.18845709f, -0.00877408f, -0.05185250f, 0.00379251f, 0.07222714f, 0.06285781f, -0.10172664f, 
    0.08380321f, -0.03971391f, -0.15663345f, -0.01805906f, 0.06537664f, 0.03075494f, -0.08627173f, -0.09006429f, 
    0.05603883f, -0.00017255f, 0.07241917f, 0.20683643f, 0.13438183f, 0.20716871f, -0.12719795f, 0.02176490f, 
    -0.00378916f, 0.12225090f, -0.00740246f, -0.08395614f, 0.12277254f, -0.03949058f, 0.10415775f, -0.12219422f, 
    -0.03619389f, 0.02953790f, 0.03224298f, 0.07462695f, -0.01718356f, 0.20683545f, 0.06990775f, 0.14336051f, 
    -0.08489314f, -0.06508438f, -0.03255083f, 0.03518244f, 0.08472361f, -0.00449121f, 0.14827570f, 0.18827382f, 
    -0.13335200f, 0.00061081f, 0.03756541f, 0.04414742f, -0.11187223f, 0.02172740f, 0.06645510f, -0.00713152f, 
    -0.02751635f, 0.13001199f, 0.08739549f, -0.03335423f, -0.04493879f, 0.05171956f, 0.07007565f, 0.06293079f, 
    -0.12658913f, -0.00301130f, -0.10395421f, 0.02638475f, -0.06610177f, 0.04826751f, 0.13839093f, 0.17458552f, 
    0.07698753f, 0.22301717f, -0.13060448f, 0.09859370f, -0.02654370f, -0.04611585f, -0.07939043f, 0.03078353f, 
    -0.01183874f, -0.02685087f, -0.10787963f, 0.11464013f, -0.11297133f, -0.00186607f, 0.08531103f, 0.07381012f, 
    0.01658301f, -0.02871899f, -0.02588826f, -0.23738301f, 0.16420764f, -0.02372357f, 0.04409463f, 0.17693509f, 
    0.06348271f, -0.10089549f, 0.15435427f, -0.04217794f, 0.28467563f, -0.06744460f, 0.08222511f, -0.04293353f, 
    -0.00744406f, 0.01787990f, -0.20585378f, 0.03551908f, -0.15290792f, 0.10342029f, -0.14341049f, -0.40236780f, 
    -0.07642024f, 0.01797306f, 0.10125861f, 0.00265678f, 0.02158274f, -0.12577926f, -0.06367388f, -0.16584055f, 
    0.16034177f, 0.07726549f, 0.14515544f, -0.00056197f, -0.02405169f, 0.05628793f, 0.04485869f, 0.41049203f, 
    -0.00247043f, -0.01156765f, -0.21566451f, -0.04306611f, 0.08071349f, -0.00342208f, 0.07000785f, -0.15299900f, 
    -0.33900666f, -0.02203666f, 0.03568909f, 0.08657865f, -0.03173108f, 0.01749884f, -0.02581800f, -0.04778460f, 
    -0.08154671f, -0.19740881f, -0.06670705f, 0.14742358f, -0.04728959f, -0.03693282f, -0.04545432f, -0.07709917f, 
    -0.06917600f, 0.12726329f, 0.01694622f, -0.18964884f, 0.05122605f, 0.00429271f, 0.02072043f, -0.03171697f, 
    0.00650879f, -0.08902243f, -0.02046023f, 0.36135361f, 0.02438345f, 0.07456343f, 0.01650763f, -0.13079551f, 
    -0.12016536f, -0.06545186f, -0.05219159f, -0.05746176f, 0.24966148f, 0.29546547f, -0.02898352f, 0.12598495f, 
    0.06297227f, -0.01157045f, -0.03866884f, 0.05068395f, -0.00682770f, 0.29495451f, 0.13585098f, -0.04452417f, 
    -0.23308861f, 0.02208460f, 0.06911585f, -0.06229191f, -0.04365641f, -0.06456861f, 0.21924278f, 0.12370270f, 
    0.05755204f, -0.29757860f, 0.18740578f, 0.13730772f, -0.08529248f, 0.08349047f, 0.03102963f, -0.04268869f, 
    -0.10778044f, -0.06406686f, 0.03194714f, 0.02548273f, -0.04129323f, -0.00026084f, -0.05970570f, -0.01858705f, 
    -0.00714497f, -0.18602659f, -0.06320520f, 0.10267076f, 0.11749756f, -0.05288647f, -0.03470235f, 0.05720028f, 
    -0.02193696f, 0.33262011f, -0.25084433f, -0.15918234f, -0.14823318f, 0.04654082f, -0.02011735f, -0.02861342f, 
    0.10845134f, -0.08919287f, -0.01496711f, -0.18437894f, -0.15402956f, -0.05982044f, 0.10870293f, 0.04043809f, 
    0.02262451f, 0.02329687f, 0.10374548f, 0.06324197f, -0.07066132f, -0.01383105f, -0.08410268f, -0.10552423f, 
    0.06141831f, -0.00268859f, 0.13155180f, 0.02556655f, 0.13288644f, 0.06486737f, -0.08555891f, 0.03765951f, 
    0.12085556f, 0.10658956f, -0.03508358f, -0.08807772f, 0.03038359f, 0.05021871f, -0.01345033f, -0.09511656f, 
    -0.00779412f, 0.14310238f, 0.00502286f, 0.00621655f, -0.00800540f, -0.04648741f, -0.17739244f, 0.17850670f, 
    -0.01010257f, 0.04864911f, 0.14674726f, 0.01071717f, -0.04549452f, -0.06194194f, -0.00233764f, -0.00275154f, 
    -0.02562166f, 0.00473420f, -0.19785985f, -0.16957600f, 0.01815635f, 0.01402532f, -0.04449795f, -0.09826913f, 
    0.00859157f, 0.09974913f, -0.40478289f, -0.03354492f, 0.10283750f, -0.03006632f, -0.14003000f, 0.00378383f, 
    -0.06186156f, 0.27300099f, -0.20025875f, 0.05299924f, 0.02071157f, 0.06393232f, 0.07513079f, -0.04914859f, 
    0.14690994f, -0.01537655f, -0.20673963f, -0.02991282f, -0.16236542f, 0.12188281f, 0.03589519f, 0.20744881f, 
    -0.00971344f, -0.08489615f, 0.17137322f, -0.20447983f, 0.06519876f, -0.29179406f, 0.11301048f, 0.07373906f, 
    0.10867285f, -0.03425019f, -0.08887094f, -0.08333140f, -0.29270330f, 0.07731341f, -0.08227443f, -0.03293033f, 
    -0.02118792f, -0.01739341f, -0.15846831f, 0.00784835f, -0.09698523f, -0.00782347f, 0.17546245f, -0.01140302f, 
    0.02906571f, 0.14531636f, -0.07445049f, 0.02745809f, -0.05336771f, -0.01336314f, -0.06892985f, -0.10336385f, 
    -0.24560085f, -0.02191154f, 0.02746545f, 0.04534367f, -0.11376897f, 0.04195684f, 0.00025583f, -0.01753135f, 
    0.12227623f, -0.12392676f, 0.05656037f, 0.02516144f, -0.03253322f, 0.08987270f, -0.04979829f, 0.00160398f, 
    0.10846188f, 0.09261993f, 0.07801329f, -0.04470842f, 0.00130958f, -0.00395893f, 0.18761697f, 0.08135480f, 
    -0.00654025f, 0.24181820f, 0.11589348f, -0.07567612f, 0.07910324f, 0.06843691f, 0.02949208f, -0.08569084f, 
    -0.05810434f, -0.08743860f, -0.04781688f, 0.07760005f, -0.01443372f, -0.14545228f, -0.05746195f, -0.04705584f, 
    0.08226413f, 0.05458625f, 0.15732905f, 0.19281659f, 0.13493107f, -0.01942195f, -0.05378306f, -0.13505471f, 
    -0.05707690f, -0.15343885f, 0.03137526f, 0.01046272f, 0.00908353f, -0.12120903f, 0.19517295f, 0.02051621f, 
    0.09789331f, -0.01746364f, 0.04700115f, -0.14731163f, -0.14231117f, -0.10897349f, -0.17303646f, 0.05162500f, 
    -0.26681253f, -0.05584219f, 0.01732463f, -0.05092131f, 0.03588304f, 0.11388821f, 0.04336519f, -0.00198078f, 
    0.01900514f, -0.10391805f, -0.12469719f, -0.02972702f, -0.00455075f, 0.08608180f, -0.07737966f, 0.08184171f, 
    0.22760171f, 0.13211060f, 0.14514843f, 0.01991658f, 0.04172134f, 0.03305930f, -0.12149318f, 0.02786398f, 
    0.47698423f, -0.07770227f, -0.05244909f, -0.10800558f, 0.01125495f, 0.09235956f, 0.06407566f, 0.03175392f, 
    0.08902148f, 0.22689845f, -0.02160950f, -0.27350885f, 0.03087967f, 0.02759998f, 0.02878546f, 0.01539181f, 
    0.08337424f, -0.17070311f, 0.05266199f, -0.01615007f, 0.16160648f, 0.00666810f, -0.04047809f, 0.12447092f, 
    0.14530788f, 0.03399524f, -0.10234665f, -0.21315493f, -0.12184682f, -0.13053608f, 0.03831154f, 0.03997745f, 
    -0.01733535f, -0.00100894f, 0.03708792f, -0.00101438f, 0.33492458f, -0.05347409f, 0.01193292f, -0.02698266f, 
    0.03807445f, -0.03417924f, -0.03931502f, -0.00853204f, 0.05173270f, -0.14730594f, 0.04114331f, -0.11081298f, 
    0.02614982f, 0.03539300f, 0.04988137f, 0.00338182f, 0.12306491f, 0.00080164f, -0.12978993f, 0.19512379f, 
    0.00432537f, 0.01515201f, -0.03106510f, 0.08966550f, -0.05240218f, -0.04363373f, -0.14624116f, -0.08740389f, 
    -0.05523232f, 0.00422678f, 0.04968690f, -0.00173040f, -0.09185098f, 0.01570371f, 0.02267829f, -0.01397065f, 
    0.06921808f, -0.18958265f, 0.17982449f, -0.01726952f, 0.01318163f, 0.00152184f, -0.04219867f, 0.10934424f, 
    -0.07822572f, -0.18603680f, 0.02279613f, 0.46086246f, -0.19109114f, -0.09768048f, -0.04950437f, -0.10856848f, 
    0.04550780f, 0.05759485f, -0.20378259f, 0.08912065f, -0.14155805f, 0.12259166f, -0.00133640f, -0.05578456f, 
    0.10330042f, 0.05570229f, 0.06920722f, 0.04178444f, -0.01777568f, 0.12396117f, -0.04449832f, -0.07170729f, 
    0.05400790f, 0.07880796f, 0.05516324f, -0.00207933f, 0.02115755f, -0.26792145f, -0.03449190f, 0.00064169f, 
    0.07169069f, 0.04294122f, -0.02535095f, -0.02769650f, -0.14203346f, 0.10524286f, 0.06201796f, 0.02390077f, 
    -0.07894203f, -0.02201741f, 0.03106061f, -0.07862854f, -0.09741128f, -0.04567814f, 0.06898043f, 0.08971814f, 
    0.09976085f, 0.04530641f, -0.04746376f, 0.07629042f, 0.02564492f, -0.05010534f, -0.00738958f, -0.06625704f, 
    -0.26984847f, 0.02426468f, -0.03158250f, -0.07742586f, -0.00228399f, -0.09033085f, -0.00896034f, 0.16576399f, 
    -0.22071378f, -0.17806242f, -0.00159741f, 0.04079530f, 0.03848857f, 0.00952545f, 0.13135199f, 0.01675610f, 
    -0.03173421f, -0.48194197f, -0.07230066f, 0.09697676f, 0.05684409f, 0.05834254f, 0.04043513f, 0.02814280f, 
    0.00742320f, -0.09898386f, 0.05833083f, 0.05912569f, -0.23870219f, 0.10037726f, 0.02402506f, 0.06674931f, 
    -0.03981531f, 0.02350947f, -0.03896179f, -0.09615307f, 0.12996843f, -0.12830661f, 0.20081303f, -0.02889132f, 
    0.11849454f, -0.03169012f, -0.03550166f, -0.07653776f, -0.19700648f, -0.05198612f, 0.16154464f, -0.04191694f, 
    -0.09651267f, -0.16647227f, 0.12092344f, 0.11959983f, -0.06100217f, 0.08934934f, 0.21806076f, 0.02102512f, 
    0.03115956f, 0.03565798f, -0.03451201f, 0.11116106f, 0.03186277f, -0.06567886f, -0.00039954f, 0.06460850f, 
    -0.27697557f, -0.01765800f, 0.16266353f, 0.17164749f, 0.06820180f, 0.00315223f, -0.12021503f, -0.01297384f, 
    0.24070436f, 0.16824727f, -0.02112286f, 0.02465688f, -0.07126427f, 0.08951290f, -0.00345689f, 0.04558561f, 
    0.12266596f, 0.07764856f, 0.02043440f, 0.01468662f, 0.11357076f, -0.07424583f, -0.00753483f, 0.16643481f, 
    -0.09182185f, 0.25815877f, -0.23706746f, -0.05459941f, 0.06017254f, 0.02305556f, 0.01333658f, 0.09279382f, 
    0.12388011f, -0.01097907f, -0.08965296f, 0.08135864f, -0.17434829f, 0.07891209f, 0.01664973f, 0.03604404f, 
    0.01717085f, 0.05059480f, -0.05164194f, -0.17661653f, 0.12449926f, -0.05834034f, 0.09166942f, 0.06960362f, 
    -0.03620067f, -0.00948597f, -0.10987699f, 0.04457232f, -0.06030397f, -0.32437360f, 0.17002015f, 0.04707671f, 
    -0.08422857f, -0.02542885f, -0.05947521f, -0.08128688f, -0.02768589f, -0.05360870f, -0.29999274f, -0.25341815f, 
    -0.02053677f, -0.07722113f, -0.06110407f, 0.02625530f, 0.01423072f, 0.04155169f, -0.00147767f, -0.13795629f, 
    0.07888717f, -0.09593195f, 0.00218236f, 0.05329142f, -0.10413950f, -0.05456546f, 0.06062910f, 0.01613869f, 
    0.16955240f, -0.07353646f, 0.01070525f, -0.00970449f, -0.02367899f, 0.00371637f, 0.05676100f, 0.07794853f, 
    0.11462752f, -0.19255601f, 0.07898044f, -0.01265794f, 0.18272078f, 0.02207529f, -0.05359679f, 0.04508674f, 
    -0.06484417f, 0.09990164f, -0.21438318f, -0.10528081f, -0.04134517f, 0.01914931f, -0.02985351f, 0.11237448f, 
    -0.00742662f, 0.05425171f, 0.06734972f, -0.05934809f, -0.18747267f, -0.01384924f, 0.03049454f, -0.02358990f, 
    0.01096622f, 0.03589177f, -0.16524558f, 0.05024830f, -0.13157579f, 0.10325103f, -0.10535610f, 0.05758739f, 
    0.04907129f, 0.05163078f, -0.01985742f, 0.06681914f, -0.06221744f, 0.01546967f, -0.14027169f, -0.02334512f, 
    -0.08035350f, 0.04001583f, 0.11400764f, 0.13630739f, 0.10215704f, -0.12421413f, 0.06029159f, -0.33378306f, 
    -0.03956906f, -0.07948947f, 0.05456448f, 0.00254135f, 0.04766986f, -0.06947521f, 0.39575329f, 0.20142567f, 
    -0.06892228f, 0.07489324f, -0.05532977f, -0.03317327f, -0.02791164f, -0.08822145f, 0.09679185f, -0.17612062f, 
    -0.07365754f, 0.14687434f, 0.05186219f, 0.13249268f, 0.07949737f, -0.02462501f, -0.11662105f, 0.04851177f, 
    -0.43223199f, -0.14713386f, 0.06560288f, -0.04284980f, 0.08165567f, -0.03590448f, 0.01709956f, -0.01822859f, 
    -0.04312345f, -0.16913193f, -0.23857653f, 0.01209061f, -0.07911997f, 0.08152532f, 0.01091032f, 0.12190671f, 
    0.00206799f, 0.01453466f, 0.01863565f, -0.49017060f, -0.05699258f, 0.03193893f, 0.06759404f, 0.14453308f, 
    -0.02000260f, -0.02235465f, 0.06113328f, -0.12383374f, 0.09857754f, 0.18978442f, -0.12836072f, 0.01444067f, 
    0.07577932f, 0.03786864f, 0.05825311f, -0.02053307f, 0.09050781f, -0.32360497f, -0.05235062f, -0.11630964f, 
    0.06149955f, 0.08746950f, 0.20039421f, 0.00228770f, -0.06867874f, 0.25140032f, -0.18840630f, -0.21982923f, 
    0.11188728f, 0.02904174f, 0.06560045f, -0.05216538f, -0.02370169f, -0.02549697f, -0.16940421f, 0.00690798f, 
    0.07160400f, -0.07114625f, 0.01115651f, 0.02522816f, -0.06678349f, 0.00732151f, 0.02934162f, -0.00695997f, 
    -0.25589186f, 0.00594063f, 0.02915558f, -0.02200268f, 0.01945020f, -0.07035846f, -0.03412230f, -0.01058841f, 
    -0.23927686f, 0.12804665f, 0.07864051f, -0.04874771f, -0.15949959f, -0.24678332f, -0.00098837f, 0.05814255f, 
    -0.03976254f, 0.04927362f, -0.15214036f, -0.02174040f, -0.12001580f, -0.12293819f, -0.04244299f, 0.11283544f, 
    0.01794193f, -0.08698314f, 0.00353156f, -0.14672764f, -0.04304364f, 0.04770671f, 0.18025260f, -0.09959605f, 
    0.06066388f, -0.00795627f, -0.20756727f, 0.05636332f, 0.02334139f, -0.03369448f, 0.01976740f, 0.02080147f, 
    0.05498264f, -0.13836996f, -0.06059349f, -0.11044445f, 0.08064570f, -0.02285570f, 0.10277671f, -0.00340289f, 
    -0.13304432f, 0.00753605f, -0.01994509f, 0.02116711f, -0.01875855f, 0.14205779f, 0.09158778f, 0.05017817f, 
    0.10483802f, 0.03314845f, 0.11522125f, -0.09810771f, 0.04846871f, 0.08091489f, -0.11665665f, -0.00599265f, 
    -0.03644945f, 0.14301920f, -0.00525518f, 0.02099223f, -0.09477910f, 0.08503903f, -0.22438847f, -0.26440442f, 
    0.17420539f, 0.07412677f, -0.08986365f, 0.01657932f, -0.01106430f, 0.14207143f, -0.03372785f, 0.01374636f, 
    0.12337194f, 0.11033063f, -0.01220939f, 0.00920791f, 0.06654860f, 0.05289524f, 0.12940545f, -0.06119609f, 
    0.02153309f, -0.01128773f, 0.14187972f, 0.11890953f, 0.10093818f, -0.01142174f, 0.03352847f, -0.15073855f, 
    0.08930431f, 0.01759583f, -0.06541508f, 0.00240251f, -0.06140964f, -0.08828786f, -0.00678377f, 0.03673537f, 
    -0.08973030f, 0.08124756f, -0.13358016f, 0.02169491f, -0.00104430f, -0.11340223f, 0.02081602f, 0.13675852f, 
    0.05557768f, 0.06270208f, 0.07395691f, -0.02617753f, -0.01827886f, 0.07818160f, 0.03082973f, 0.06601240f, 
    -0.13704470f, 0.07678735f, 0.17708930f, -0.14696562f, 0.16186731f, 0.07918907f, -0.02831323f, -0.12548095f, 
    -0.04609099f, 0.00863353f, -0.08604389f, 0.10334557f, 0.00331136f, 0.06351189f, 0.05554833f, 0.04953287f, 
    0.02098038f, 0.06305329f, 0.03283452f, 0.04128805f, -0.00556746f, -0.10138750f, 0.01133159f, 0.15941663f, 
    0.09982037f, 0.19439882f, 0.12755004f, 0.01785741f, 0.09996884f, -0.18935014f, 0.03134918f, 0.08420689f, 
    0.01305587f, 0.10830867f, -0.05262715f, 0.03902398f, 0.07149409f, 0.06628939f, 0.00373915f, -0.04382518f, 
    0.02866924f, 0.22475329f, -0.05078553f, 0.28454095f, 0.03171324f, 0.08335995f, -0.14214779f, -0.05009516f, 
    -0.08836817f, 0.24357951f, -0.03790292f, 0.01860727f, -0.04032560f, -0.07467063f, -0.04997070f, 0.15975147f, 
    0.20483282f, 0.08608174f, -0.04572029f, -0.12365536f, -0.02063215f, -0.01763221f, 0.08944162f, -0.18615548f, 
    -0.00967931f, -0.04923628f, -0.05330531f, -0.06560858f, 0.00365236f, -0.02710412f, 0.04966201f, -0.05712583f, 
    0.05493948f, -0.05980612f, 0.00611643f, 0.02824895f, 0.03104174f, 0.00400390f, -0.05690870f, 0.05574187f, 
    -0.10561780f, 0.06113537f, -0.01273156f, -0.08509460f, 0.09556366f, 0.08268296f, 0.01884066f, 0.12855892f, 
    -0.12244330f, 0.11507429f, -0.02174076f, 0.16052049f, 0.09754352f, -0.02743073f, 0.01409606f, -0.03286812f, 
    -0.23745005f, 0.07306872f, 0.02729043f, -0.06721912f, -0.00792444f, -0.02458509f, -0.05731808f, -0.16776714f, 
    0.38442588f, -0.20968106f, -0.06429990f, -0.06593408f, -0.01992578f, -0.04895272f, -0.04795856f, -0.01750791f, 
    -0.07877738f, -0.02722751f, -0.01515092f, -0.22350866f, -0.02737557f, -0.06331282f, 0.02666536f, 0.07772212f, 
    0.03337084f, -0.01631830f, -0.05464494f, -0.22400814f, -0.01432584f, 0.02942542f, 0.11262856f, -0.13082744f, 
    -0.00173142f, 0.06183591f, -0.17809795f, -0.04601857f, 0.06253557f, 0.04479679f, -0.05535825f, 0.08659701f, 
    0.03765539f, 0.00102660f, -0.02689817f, -0.04695575f, -0.22299613f, -0.00167101f, 0.06026339f, 0.13545319f, 
    -0.07592968f, 0.08451370f, 0.03904305f, -0.04895272f, -0.04362597f, 0.02194262f, 0.04905141f, 0.07318030f, 
    0.01390861f, -0.04629541f, -0.20555091f, 0.04026787f, 0.01041330f, 0.11725944f, -0.04470007f, 0.00819283f, 
    -0.14703181f, 0.03570887f, 0.03141154f, 0.07669008f, 0.07234357f, -0.23712394f, -0.01671648f, -0.18380021f, 
    0.07376558f, 0.08056366f, 0.00079997f, -0.03948423f, 0.04777172f, 0.12647827f, -0.05555087f, 0.06239673f, 
    0.05818177f, -0.09664971f, 0.27373827f, -0.19614759f, 0.05626478f, 0.05862664f, 0.00752331f, -0.00256439f, 
    0.05245390f, 0.03230085f, 0.05581774f, -0.18357907f, -0.06416821f, -0.09607523f, -0.18744737f, -0.13463543f, 
    -0.00238253f, 0.09264261f, -0.01002065f, -0.10606632f, -0.00641097f, 0.10967483f, -0.15817091f, -0.02469750f, 
    0.07150783f, 0.02021425f, 0.03802811f, 0.15737531f, -0.14079702f, 0.01884530f, -0.00290928f, -0.02877579f, 
    0.00357188f, -0.01729331f, -0.00002871f, 0.05645247f, 0.11794320f, 0.02317188f, 0.09631234f, -0.18567760f, 
    0.03070323f, -0.11604995f, 0.02656821f, 0.02322202f, -0.09362138f, 0.08602142f, -0.08696739f, 0.12454037f, 
    -0.04431503f, 0.07031318f, 0.09074906f, 0.07229985f, -0.15704040f, 0.10125651f, 0.12923679f, 0.10865235f, 
    -0.00236086f, 0.00202717f, 0.04030267f, -0.03922119f, 0.06286849f, -0.09981375f, 0.05815107f, -0.05808089f, 
    0.10703535f, 0.05754269f, 0.11978716f, 0.02472122f, 0.04892758f, -0.06581052f, -0.18867244f, -0.00515926f, 
    0.13750970f, -0.12514643f, -0.21900269f, 0.10570314f, 0.02655214f, 0.03641569f, -0.12818219f, 0.05426119f, 
    -0.10805503f, -0.11094916f, 0.05724890f, 0.17999354f, 0.07454066f, -0.02014667f, -0.03860923f, -0.02147307f, 
    -0.04944643f, -0.00533719f, -0.07056962f, 0.02999967f, -0.10265531f, 0.09112100f, 0.09883311f, 0.03453735f, 
    -0.03448401f, -0.18405052f, -0.05930568f, -0.07824516f, 0.00167599f, 0.12266089f, 0.09732820f, 0.04539367f, 
    0.06826487f, -0.02571004f, 0.01576011f, -0.00240392f, -0.15347828f, 0.10881703f, 0.14981690f, -0.04363421f, 
    -0.18975142f, 0.05103619f, -0.09294138f, 0.04034739f, 0.02234381f, 0.04977483f, -0.12275749f, 0.01040426f, 
    -0.03325277f, 0.11893902f, -0.05251931f, 0.06713902f, -0.24349943f, 0.00635785f, -0.04932127f, -0.04299938f, 
    -0.05725269f, 0.12814488f, -0.04161750f, 0.19798616f, -0.09584069f, -0.07603590f, -0.05021658f, 0.13481413f, 
    -0.18376902f, 0.03770562f, -0.07410509f, -0.11031675f, 0.04365823f, -0.01096268f, 0.01931235f, 0.08262559f, 
    -0.12550679f, 0.01681219f, -0.43486795f, 0.06124008f, -0.11502898f, 0.08683456f, -0.12874269f, -0.12202663f, 
    -0.09263398f, 0.06391572f, -0.00914099f, 0.39882761f, -0.10111769f, 0.00889958f, -0.03010214f, -0.06301489f, 
    0.11052474f, 0.06300870f, 0.07351189f, 0.11734896f, -0.03338984f, -0.01347626f, 0.08423606f, 0.12690681f, 
    -0.08635665f, -0.06792299f, 0.05188346f, 0.05715667f, -0.02435559f, 0.08620590f, -0.03780105f, -0.05438884f, 
    0.00329971f, -0.00243569f, 0.08580210f, 0.03769255f, 0.06321818f, -0.02123086f, 0.12594220f, -0.01691059f, 
    0.08562584f, -0.05102263f, 0.11483616f, -0.03419733f, -0.08347432f, 0.06728327f, 0.10973532f, 0.05218796f, 
    -0.14266978f, -0.03624452f, 0.08783193f, 0.14990962f, -0.11628478f, 0.08202925f, 0.10856451f, 0.01498990f, 
    0.13127163f, -0.08166681f, -0.02914900f, -0.08013882f, 0.07101221f, 0.17325276f, 0.02265948f, 0.03233593f, 
    -0.05891972f, 0.17528205f, -0.03060053f, 0.09899747f, 0.11062661f, 0.13985765f, -0.01381481f, -0.06859010f, 
    0.20844102f, -0.01773008f, 0.17797890f, -0.01891267f, 0.11313578f, -0.24290454f, 0.08099832f, -0.00169605f, 
    0.03784607f, 0.09420907f, 0.02150304f, 0.08990826f, 0.00476729f, -0.08658336f, 0.08058921f, -0.07536089f, 
    0.00077835f, -0.07594325f, 0.06821668f, -0.21138556f, 0.14776658f, 0.06269898f, 0.00753454f, -0.04635195f, 
    -0.02587620f, 0.07078775f, -0.00592799f, 0.02421037f, 0.09135313f, -0.05968925f, 0.09073678f, -0.07412514f, 
    0.11170024f, 0.02680805f, 0.01870719f, -0.03445078f, 0.08148838f, -0.12794675f, 0.17834297f, 0.03763320f, 
    -0.01775942f, 0.13836178f, 0.02481629f, -0.01444037f, -0.00396620f, 0.07763112f, 0.05102922f, 0.06053707f, 
    -0.00606359f, -0.04244801f, -0.17766674f, 0.02662195f, -0.15239294f, 0.18935095f, -0.10354033f, -0.13557464f, 
    -0.08291189f, -0.03986346f, 0.01272263f, 0.12810151f, -0.11861183f, -0.00029909f, -0.20070983f, -0.02350093f, 
    -0.02448385f, 0.01287772f, -0.08764703f, -0.05963594f, -0.03227581f, 0.00544072f, -0.11755441f, -0.10734759f, 
    0.12293227f, 0.04352190f, -0.11904049f, 0.00486064f, 0.05826911f, -0.09573479f, -0.18520950f, 0.10344553f, 
    0.13533393f, -0.07460187f, -0.07596891f, -0.10508694f, 0.12029286f, 0.01767918f, -0.07382001f, -0.14603628f, 
    -0.08269105f, 0.05273085f, -0.12738557f, -0.12126097f, -0.02573942f, 0.02562513f, 0.08080348f, 0.12620577f, 
    -0.01739310f, 0.14247559f, -0.15739234f, 0.10169342f, -0.02893477f, -0.13259347f, 0.18748480f, 0.07533231f, 
    -0.03904508f, -0.06652069f, -0.03527340f, 0.00749467f, -0.05852766f, -0.00849289f, 0.03971880f, 0.02839115f, 
    0.17424333f, 0.02440480f, 0.02521567f, 0.05751282f, 0.04996844f, 0.17223065f, 0.19672003f, -0.12879750f, 
    0.05003275f, -0.00389458f, 0.01608323f, 0.04937492f, 0.00694918f, 0.11614504f, -0.05084215f, 0.01251392f, 
    -0.11797628f, 0.00955258f, -0.10173795f, 0.04639346f, 0.02244200f, 0.02301770f, -0.09378231f, 0.12836668f, 
    -0.05952488f, -0.16196129f, 0.07477172f, 0.11316755f, 0.02610041f, 0.00624442f, 0.00585608f, 0.07250910f, 
    -0.04365211f, 0.06830861f, 0.10620090f, 0.04343764f, -0.02974981f, 0.01296033f, -0.03637001f, 0.16759829f, 
    0.07167928f, 0.24347420f, 0.02893888f, 0.14455740f, 0.02629973f, 0.00281284f, 0.05717807f, 0.06873016f, 
    -0.04297392f, 0.03915821f, -0.01083292f, -0.04860784f, 0.06665824f, -0.04002699f, -0.02518863f, -0.03016432f, 
    0.01776446f, 0.02221326f, 0.14039892f, -0.03311559f, 0.05130842f, 0.09454215f, -0.09220167f, -0.05977304f, 
    0.10520851f, -0.05988794f, -0.05556617f, -0.06904402f, -0.16564718f, 0.24973884f, 0.02205033f, 0.03764785f, 
    -0.06585361f, 0.04795400f, 0.02760289f, 0.06386425f, 0.02357459f, -0.04633012f, -0.14051236f, 0.02749279f, 
    0.04709142f, 0.05592759f, -0.14983478f, -0.00386962f, 0.02695891f, 0.15110961f, -0.07359441f, 0.18303986f, 
    0.03672127f, -0.00217224f, -0.10254964f, 0.05853374f, 0.01650700f, 0.01882279f, 0.02716894f, 0.35256818f, 
    0.23542419f, -0.17546301f, -0.10611298f, 0.07832174f, -0.18353404f, -0.01272152f, -0.02895101f, 0.04678094f, 
    0.20442507f, 0.02487036f, -0.11779549f, 0.08667381f, 0.02726578f, 0.08179645f, 0.08459026f, 0.01212790f, 
    0.06206191f, 0.19066986f, 0.09239237f, 0.10263277f, 0.01152046f, -0.07632269f, 0.01417520f, -0.12540621f, 
    -0.16801906f, 0.04671348f, -0.07475989f, 0.12123014f, 0.00908011f, 0.03183372f, -0.10069382f, 0.00695962f, 
    0.00177531f, -0.01652966f, 0.08636519f, -0.21077263f, -0.25344530f, 0.05327279f, 0.03955820f, -0.01771893f, 
    0.01574155f, 0.02615877f, 0.11629942f, 0.06248061f, -0.35880819f, 0.03467721f, 0.11010212f, -0.12727425f, 
    0.10747325f, -0.06932466f, -0.11376806f, -0.13224107f, 0.02063473f, -0.02303230f, -0.14135739f, -0.03743243f, 
    -0.01034546f, -0.02631175f, -0.00712447f, -0.06091071f, 0.07280961f, 0.11419690f, 0.15238078f, 0.13284925f, 
    -0.00676140f, -0.03078896f, -0.01794994f, -0.06200457f, 0.06669382f, -0.04176790f, 0.04900654f, -0.16913176f, 
    -0.01761806f, 0.09052506f, -0.10508021f, -0.04730890f, -0.06342349f, -0.00438514f, -0.10986889f, -0.11500944f, 
    -0.15297095f, 0.00594646f, -0.05466034f, -0.04872198f, 0.04380757f, -0.08812992f, -0.09157299f, 0.03096700f, 
    -0.01544452f, -0.27713919f, 0.25957820f, -0.00438775f, -0.03099954f, -0.09051330f, -0.02571077f, -0.00337099f, 
    0.05387083f, 0.03909916f, 0.03373034f, -0.20146507f, 0.03304733f, -0.02841387f, -0.02362464f, -0.03938965f, 
    -0.03655455f, 0.17232469f, -0.03032459f, 0.05634182f, 0.12058821f, -0.11383726f, 0.02461732f, -0.08510119f, 
    0.02583268f, 0.05963823f, 0.19904381f, 0.18614098f, -0.40418911f, -0.14752823f, 0.10648446f, 0.04111531f, 
    0.08284740f, 0.05555881f, 0.07180755f, -0.15073597f, -0.04408365f, -0.14304560f, -0.04646149f, -0.06968065f, 
    -0.00196250f, 0.10668655f, -0.01899431f, -0.03868445f, 0.04166210f, -0.13230506f, 0.04067955f, 0.07260788f, 
    0.03886539f, -0.16124979f, -0.02036315f, 0.08249757f, -0.02802995f, -0.09142113f, -0.00944225f, -0.04959868f, 
    0.01023454f, -0.12247349f, 0.00369900f, -0.03252310f, 0.09036301f, 0.17321487f, 0.18557389f, -0.01037368f, 
    0.33237723f, -0.16411120f, -0.21033028f, 0.00688258f, -0.15407012f, -0.03029603f, 0.04218343f, 0.09833110f, 
    0.10557176f, 0.06609029f, 0.02748555f, -0.11344712f, 0.01362007f, 0.07897978f, 0.05025635f, 0.08489297f, 
    -0.02998113f, 0.02257434f, -0.03883031f, 0.19211771f, -0.12950324f, 0.06927045f, 0.00518854f, 0.03422312f, 
    0.05108492f, 0.01955545f, 0.07978901f, -0.04575946f, -0.04808676f, 0.38423586f, 0.08580438f, 0.04037489f, 
    -0.06209078f, 0.00164197f, -0.05291532f, -0.09903480f, 0.13987842f, 0.01354664f, 0.03790659f, -0.00339095f, 
    -0.10336146f, 0.05312133f, -0.08123096f, -0.05482824f, 0.16065566f, 0.04517677f, -0.20481154f, 0.00047198f, 
    0.02237874f, 0.03940707f, 0.12834369f, -0.02902651f, 0.01498404f, -0.01294576f, 0.18722707f, -0.08968351f, 
    -0.05429702f, -0.09865812f, 0.12112979f, 0.03399701f, -0.04896474f, 0.00418652f, -0.03185456f, -0.21405485f, 
    0.10924575f, 0.10816424f, 0.06686447f, 0.01664745f, -0.02384282f, -0.01840064f, -0.10216734f, 0.03010250f, 
    -0.03485558f, -0.11038103f, -0.03185541f, 0.10712829f, -0.02814465f, 0.00405290f, -0.02156009f, -0.01469175f, 
    -0.05649843f, 0.08947375f, -0.30066729f, -0.26707077f, 0.01677325f, 0.02585517f, 0.06647534f, 0.02483840f, 
    -0.02715842f, -0.12529778f, 0.12655260f, 0.20042115f, -0.08409597f, 0.07047020f, -0.02521453f, 0.06335223f, 
    0.00928973f, 0.02657917f, 0.14552410f, 0.15026854f, 0.37559441f, 0.11379421f, -0.08084507f, -0.07513150f, 
    0.14744405f, 0.04364656f, -0.06931033f, 0.00888648f, -0.01162127f, 0.08556854f, 0.28299621f, -0.07490025f, 
    0.02957675f, -0.11814493f, 0.10852244f, 0.01531760f, 0.04010974f, 0.03703697f, 0.07021752f, 0.07769141f, 
    0.03648251f, 0.00518579f, 0.08048698f, -0.09692424f, 0.07013606f, 0.08296759f, 0.03873479f, 0.25445625f, 
    0.00220756f, 0.06894178f, 0.05312688f, 0.05320653f, 0.02648441f, 0.09097768f, -0.03528663f, 0.02230992f, 
    -0.32048869f, 0.02426199f, 0.02592394f, 0.01080219f, 0.01813542f, -0.06687346f, -0.07399594f, -0.06411708f, 
    -0.12286313f, -0.16334581f, 0.05363365f, 0.04141733f, -0.01125656f, 0.01938847f, -0.04303777f, 0.14931695f, 
    -0.15959419f, -0.09133038f, -0.08216733f, -0.15979858f, 0.16421114f, -0.05671087f, -0.07488415f, -0.06278235f, 
    0.04610163f, -0.15045404f, 0.00929630f, -0.01115540f, 0.09851310f, 0.00606234f, 0.11392429f, -0.04718225f, 
    -0.02518421f, -0.05376941f, 0.04959060f, 0.05344869f, 0.13184659f, -0.24681701f, -0.04324438f, 0.14076728f, 
    -0.00640102f, -0.04142135f, -0.07756568f, -0.00143467f, 0.17300406f, 0.22769170f, -0.25060603f, 0.13071083f, 
    -0.11383229f, 0.13743466f, -0.06212065f, 0.02838072f, -0.09352501f, 0.13733260f, 0.00378740f, -0.07358013f, 
    0.01423091f, 0.11953145f, 0.04294168f, 0.09230139f, -0.16996336f, -0.00635880f, 0.02038153f, -0.03684578f, 
    -0.17453092f, 0.09817533f, 0.01048141f, -0.00488909f, -0.06195063f, -0.05544954f, -0.01639354f, -0.22284615f, 
    0.03466971f, -0.34943643f, 0.01984643f, 0.00526056f, 0.08404399f, -0.07743120f, 0.00758783f, -0.07298537f, 
    -0.01590238f, -0.17792609f, -0.21449976f, 0.02859139f, 0.02002245f, -0.05831324f, -0.04457505f, -0.03637826f, 
    -0.01208822f, 0.12868479f, -0.26460624f, 0.05764494f, -0.18016942f, 0.01453806f, 0.05328428f, 0.14160192f, 
    -0.11526706f, 0.10904387f, -0.01014092f, 0.14489372f, -0.21623455f, -0.02751037f, 0.08028808f, -0.02576411f, 
    -0.16623500f, 0.03314739f, -0.09114331f, 0.02951457f, 0.10954058f, 0.01753702f, 0.06810659f, 0.00853359f, 
    0.02485558f, -0.03173072f, -0.02339247f, -0.08466290f, -0.07634630f, 0.03333584f, -0.20999335f, -0.00669389f, 
    0.01663215f, 0.09446998f, -0.01283386f, -0.00575076f, -0.10944828f, 0.03448852f, -0.12556829f, 0.02577457f, 
    0.10759444f, -0.18708079f, -0.00262722f, -0.02201045f, 0.05124778f, 0.06370125f, 0.17649597f, 0.27839231f, 
    0.26623377f, -0.09896000f, 0.10385982f, 0.12591220f, 0.03717580f, 0.09201657f, 0.05970816f, -0.30863234f, 
    0.04263384f, 0.18739453f, 0.01429583f, 0.02960953f, 0.12365865f, 0.06656633f, -0.07656833f, 0.10745366f, 
    -0.04306829f, -0.07472815f, 0.16564652f, -0.02033250f, -0.04826617f, 0.01785499f, 0.06570812f, 0.04478373f, 
    0.13711710f, 0.23255344f, 0.13905525f, -0.17423181f, -0.01586756f, 0.01304051f, -0.21159583f, -0.03051629f, 
    0.06775502f, 0.10223483f, 0.03000246f, 0.03100523f, 0.05167963f, -0.12725376f, 0.04837223f, 0.05751322f, 
    0.02127700f, -0.00606249f, 0.02894125f, 0.18371336f, 0.00780463f, -0.05060928f, -0.11028045f, -0.04138493f, 
    0.02783181f, 0.16027151f, 0.03347206f, 0.04785996f, -0.07003877f, 0.00772841f, 0.10890941f, 0.17490196f, 
    -0.06982876f, -0.08138511f, 0.04012088f, -0.00774191f, -0.03006209f, 0.12639372f, -0.03394464f, -0.16557953f, 
    -0.02700550f, -0.01111397f, 0.12423645f, -0.01229584f, -0.00322982f, -0.01002431f, -0.28203976f, 0.40834284f, 
    0.02133539f, 0.05827349f, 0.20886613f, 0.01684456f, 0.09257066f, -0.08060752f, -0.03382635f, -0.11246539f, 
    -0.15237857f, -0.18115699f, -0.00672451f, -0.05549414f, 0.14892685f, -0.00057404f, 0.03607496f, 0.08492258f, 
    -0.08361400f, 0.20578006f, 0.14407173f, -0.05584913f, -0.04582930f, -0.11440714f, -0.05246447f, 0.04071173f, 
    0.04527635f, -0.16418602f, 0.06736287f, -0.13615324f, -0.11804610f, -0.03296442f, 0.05034381f, 0.19320826f, 
    0.01996784f, 0.15530299f, -0.29075429f, -0.00129705f, 0.17032988f, -0.04008877f, 0.04949538f, -0.00720018f, 
    0.00238343f, -0.08509047f, -0.03908771f, -0.12717248f, -0.09440163f, 0.20437527f, 0.17153925f, 0.00191440f, 
    0.07725794f, 0.00260787f, 0.04377752f, 0.01501298f, -0.31750837f, 0.02326785f, -0.20428126f, -0.04990500f, 
    -0.16216654f, -0.00702784f, 0.11727872f, -0.10889824f, 0.09662815f, -0.02996907f, -0.17848668f, -0.17302303f, 
    -0.02119884f, 0.16041528f, -0.09120031f, 0.00299742f, 0.00582537f, -0.07409453f, -0.50174534f, -0.01689770f, 
    0.16440798f, -0.06034211f, -0.00271102f, 0.05340627f, 0.06949829f, 0.17999892f, -0.00699897f, -0.06939805f, 
    -0.01233887f, -0.04680213f, -0.06227254f, 0.05751395f, -0.03623516f, -0.05033338f, -0.06082087f, -0.12707435f, 
    -0.08832179f, 0.00659352f, -0.22580197f, -0.00081278f, -0.01934507f, -0.13436830f, -0.01912561f, 0.06958026f, 
    0.04603239f, 0.01513262f, -0.01694485f, -0.11903451f, 0.17885983f, 0.09331831f, 0.14325987f, 0.03579981f, 
    -0.06633047f, -0.05310907f, 0.15357129f, 0.00835039f, -0.01834398f, 0.08138519f, 0.08249808f, 0.09342322f, 
    -0.12982674f, -0.17182298f, -0.07353402f, 0.06836474f, 0.18331866f, 0.09965212f, 0.07068966f, -0.06796592f, 
    -0.02834011f, -0.01071399f, -0.04221377f, 0.12626795f, 0.04801587f, 0.07551602f, 0.05396175f, 0.10829249f, 
    0.01769115f, 0.08463766f, -0.06457848f, -0.01507609f, -0.00315068f, -0.02638892f, 0.12755424f, 0.00051991f, 
    0.15591103f, -0.00373023f, 0.07959983f, -0.14282648f, -0.07448974f, -0.00755327f, 0.17186996f, -0.06055200f, 
    0.08398738f, -0.09695079f, -0.02909984f, 0.01817630f, 0.04516653f, 0.02578896f, 0.06550524f, 0.13627495f, 
    0.21902162f, 0.12542683f, -0.03933976f, 0.01858911f, -0.01636992f, 0.05402897f, -0.08330670f, 0.05246530f, 
    0.19000784f, 0.18558532f, 0.02377645f, 0.02414868f, 0.06465558f, -0.08274445f, -0.05072432f, 0.07169373f, 
    0.06657553f, 0.31636187f, -0.04412505f, -0.04975164f, 0.09191529f, -0.14218308f, -0.12200307f, 0.04973785f, 
    0.08172191f, -0.01617656f, 0.13139811f, -0.00844427f, 0.15700425f, 0.01279666f, -0.01300719f, 0.07733660f, 
    0.04400864f, 0.04353911f, -0.05265297f, -0.38809869f, 0.07205383f, 0.03613848f, -0.16942583f, -0.08367567f, 
    0.06998678f, -0.00209606f, 0.07288837f, 0.13077922f, -0.10601630f, 0.11411423f, 0.12886561f, 0.13536295f, 
    -0.12100487f, -0.06818108f, -0.01183857f, 0.01463551f, 0.04321404f, 0.17979380f, 0.11294932f, -0.17952508f, 
    -0.10076393f, 0.00663228f, 0.07132569f, -0.10769394f, -0.01111884f, -0.00692215f, -0.37776321f, -0.12181209f, 
    0.09442175f, 0.09558831f, 0.10630881f, -0.01366904f, -0.00341560f, -0.05415607f, 0.04336996f, -0.11862972f, 
    -0.17162608f, -0.20241317f, -0.10060692f, 0.06696701f, -0.04937998f, -0.07134447f, 0.03520652f, -0.05733456f, 
    -0.22858734f, -0.43274763f, 0.03395385f, -0.10419624f, -0.06357060f, 0.06767795f, -0.04187540f, 0.04726079f, 
    0.03675870f, -0.00332227f, 0.08065886f, 0.10095695f, -0.08163153f, 0.09489290f, 0.03481353f, 0.03147191f, 
    0.20487276f, 0.03052295f, -0.20679839f, -0.06395935f, 0.21288827f, -0.05949274f, 0.12338179f, 0.03970302f, 
    0.04093890f, -0.02165556f, -0.04403612f, 0.07616929f, -0.21911658f, 0.10865128f, 0.03279213f, -0.05538520f, 
    0.07561425f, -0.12155745f, -0.14931466f, 0.14014076f, 0.03989641f, -0.06132355f, -0.22423723f, -0.10750867f, 
    -0.06839008f, -0.14919175f, 0.06126301f, 0.02525418f, -0.13347784f, -0.07320765f, -0.20490670f, 0.14454633f, 
    -0.03843861f, -0.04487660f, -0.00846199f, -0.07148697f, 0.02616776f, 0.01670669f, -0.40745726f, 0.27518880f, 
    -0.32254013f, -0.04391327f, 0.04212636f, 0.09177610f, -0.09020795f, -0.04826188f, 0.08512879f, 0.16258781f, 
    -0.10152969f, -0.05144979f, -0.03281239f, 0.00505143f, 0.07647752f, 0.16884646f, -0.04527694f, -0.06423370f, 
    0.03756264f, -0.02566662f, -0.12877415f, -0.04754819f, 0.01628650f, -0.05842475f, -0.03663743f, 0.11602037f, 
    0.19426924f, -0.31471294f, -0.41414937f, 0.16549262f, -0.00655241f, -0.31882820f, -0.07373173f, 0.01991938f, 
    -0.02879601f, 0.04983579f, -0.16210924f, 0.17215247f, 0.05218048f, 0.12327956f, 0.07993739f, -0.10093150f, 
    0.15880345f, 0.14199175f, -0.06274846f, 0.03884348f, 0.18685113f, -0.13104656f, 0.07967868f, 0.03217692f, 
    0.00910815f, -0.01759776f, 0.04378943f, -0.07423931f, 0.27301124f, 0.32324031f, -0.05955029f, -0.03367838f, 
    -0.09811950f, -0.09132724f, 0.09241068f, 0.12747736f, 0.04692814f, 0.15656678f, -0.15039906f, 0.24987116f, 
    -0.08653662f, 0.05341202f, 0.12185045f, 0.13898878f, -0.14071791f, 0.10585451f, 0.06629977f, 0.13119452f, 
    -0.26531935f, 0.12560506f, -0.33285850f, -0.03071323f, -0.01597252f, -0.09597632f, 0.06344084f, -0.05622516f, 
    -0.02892533f, 0.08800595f, 0.02264969f, 0.01524949f, -0.05921814f, -0.01692122f, -0.06620028f, 0.01038134f, 
    0.35907516f, -0.23338675f, 0.04583696f, -0.06772899f, 0.19067557f, -0.02277634f, 0.08493410f, 0.20174566f, 
    0.19509956f, -0.09104893f, -0.00203560f, 0.07254060f, -0.01282730f, 0.04962583f, 0.19389288f, -0.05405926f, 
    0.03665133f, 0.04491284f, -0.01155282f, -0.01297812f, -0.17116961f, 0.09657900f, -0.05409005f, 0.04945822f, 
    0.00342328f, -0.02804819f, -0.00237411f, 0.04129048f, 0.01557932f, 0.07749628f, -0.01337007f, -0.01437361f, 
    -0.08758566f, -0.01370767f, -0.16025762f, -0.03082652f, 0.05835146f, 0.06305866f, -0.32470772f, 0.18890446f, 
    -0.04430442f, -0.12492709f, 0.08884208f, 0.04028565f, -0.00944137f, -0.06479353f, 0.22939228f, 0.03166867f, 
    0.07627169f, -0.10117242f, 0.13119912f, 0.04918129f, -0.00402036f, 0.12840237f, -0.03981868f, -0.24402377f, 
    0.23128507f, -0.01371143f, -0.03006791f, -0.04035827f, -0.03480994f, 0.06704284f, 0.01362973f, 0.09585229f, 
    0.08121546f, 0.05552157f, -0.01318505f, -0.00971217f, -0.01511911f, -0.13558762f, 0.00975656f, 0.12632948f, 
    -0.05860866f, 0.17711453f, 0.13010442f, 0.03669091f, 0.02408907f, -0.02746521f, 0.09710582f, -0.11921076f, 
    -0.04256440f, 0.00276624f, -0.09499009f, -0.36753497f, -0.06244024f, -0.08034591f, 0.05557751f, -0.05263495f, 
    -0.00089179f, 0.00116136f, -0.08190808f, -0.01655833f, 0.23504877f, 0.00523015f, -0.07472722f, 0.06839050f, 
    0.03197126f, 0.08824699f, 0.14599429f, 0.04547382f, 0.15983710f, 0.05850501f, -0.06888732f, -0.11039212f, 
    -0.11818784f, 0.00613199f, 0.01869507f, 0.09873513f, 0.20427686f, -0.06442837f, -0.02628188f, 0.00697859f, 
    -0.04378810f, -0.06474264f, -0.05733966f, 0.02754557f, 0.00901256f, -0.15135437f, 0.10151266f, -0.15141246f, 
    0.01593490f, -0.05073755f, 0.17461567f, 0.05652751f, -0.05595464f, 0.06426376f, 0.08870607f, 0.15904960f, 
    -0.13179721f, -0.01451444f, 0.02665340f, -0.02029015f, -0.07226579f, 0.06831497f, -0.03338069f, 0.54688823f, 
    0.14589156f, 0.05305545f, -0.07684682f, 0.01158744f, 0.04934588f, 0.15987182f, -0.06343146f, -0.01895165f, 
    0.00273635f, -0.01812628f, -0.04872753f, -0.04490442f, -0.01930045f, -0.04235585f, 0.02152248f, 0.01080345f, 
    -0.04696402f, 0.04815892f, -0.02941611f, 0.02725183f, -0.02482368f, -0.03536125f, -0.01389356f, 0.03136429f, 
    -0.03232352f, -0.05097820f, -0.04695154f, 0.03688544f, 0.03179368f, -0.02611586f, 0.02419364f, 0.03044383f, 
    -0.03570164f, -0.02214813f, 0.00037324f, 0.03680221f, -0.01772612f, -0.04152377f, -0.00131332f, 0.00018954f, 
    0.01406091f, -0.04235780f, 0.00796288f, -0.04624875f, 0.04670853f, 0.00438184f, 0.00666938f, -0.02916685f, 
    0.04034367f, -0.03955169f, 0.02914271f, -0.04353737f, 0.02803726f, -0.03721259f, -0.06484058f, -0.05831531f, 
    -0.03492607f, 0.04044858f, -0.05199058f, 0.01182070f, -0.03984142f, -0.05314250f, -0.03222372f, -0.03456828f, 
    -0.00087686f, 0.01899322f, 0.01912368f, 0.04481996f, 0.05043701f, -0.06562563f, -0.03504493f, 0.02241040f, 
    -0.02323456f, -0.05570213f, 0.01883626f, -0.04592058f, -0.03262530f, 0.00907174f, 0.00826149f, -0.00554644f, 
    -0.05942819f, -0.04642555f, -0.01150354f, 0.00281974f, 0.01005885f, -0.03062651f, -0.06564596f, 0.03766115f, 
    0.02759679f, 0.00241486f, 0.04090223f, -0.03909849f, -0.00315854f, 0.01704956f, -0.06169092f, 0.02370900f, 
    -0.05208968f, 0.03067661f, -0.03743565f, -0.02963097f, -0.02778313f, -0.01559198f, 0.03277240f, -0.05102056f, 
    -0.02393912f, 0.01214493f, -0.02867798f, -0.03749463f, 0.03327489f, 0.00898052f, -0.01025399f, -0.00547134f, 
    -0.03231591f, -0.06129727f, 0.04765126f, -0.02043956f, 0.00058341f, -0.02386982f, -0.05238015f, 0.00783782f, 
    -0.03624384f, -0.00356094f, -0.04155780f, -0.06112182f, -0.05169953f, 0.02853181f, 0.05027603f, -0.06617658f, 
    -0.01484078f, -0.00905878f, -0.06188477f, 0.04140217f, -0.05668539f, -0.05661052f, -0.04334302f, -0.01579231f, 
    0.04575984f, 0.03886132f, -0.02209008f, -0.04201388f, 0.02343506f, -0.04864750f, -0.02327397f, -0.05470806f, 
    -0.00149597f, -0.04417435f, 0.00106384f, -0.00031458f, -0.06020795f, -0.02529082f, -0.04069827f, -0.00450048f, 
    -0.05788555f, 0.02831562f, 0.00482105f, 0.04540131f, 0.03401110f, 0.01320311f, -0.00898433f, 0.03883747f, 
    0.01960918f, -0.03769000f, -0.00123823f, -0.01296122f, -0.04005156f, -0.01192759f, -0.01551011f, -0.02367372f, 
    -0.01699886f, 0.03078338f, 0.03075159f, 0.00408963f, 0.00080328f, -0.00228925f, -0.00289190f, 0.04260254f, 
    -0.03340947f, 0.02512816f, 0.03055048f, -0.03012460f, -0.03330456f, -0.03380252f, -0.03808745f, -0.06325505f, 
    0.03379063f, -0.01758197f, 0.04786166f, -0.03422449f, 0.01380128f, -0.03600539f, 0.02699132f, 0.02900006f, 
    -0.05451895f, -0.03757282f, -0.02726811f, -0.02048872f, -0.05107326f, 0.02195321f, 0.03144609f, -0.00377492f, 
    -0.02790620f, 0.04239757f, -0.00560940f, 0.01846261f, 0.00752461f, 0.04592503f, -0.04383770f, -0.01632443f, 
    0.03131737f, -0.01227267f, 0.02637177f, -0.01147873f, 0.05023956f, -0.01336347f, -0.00748422f, -0.06174686f, 
    -0.03589323f, 0.00380420f, -0.01664353f, -0.00229594f, -0.06269842f, -0.04015507f, -0.00715765f, -0.05828565f, 
    -0.00982179f, 0.03740807f, 0.00845072f, -0.06666023f, 0.01069950f, 0.05002297f, 0.03066336f, -0.04279516f, 
    -0.03114566f, -0.00486645f, -0.00663727f, -0.02892924f, -0.04780982f, 0.01141126f, 0.04017226f, 0.03720722f, 
    -0.00719433f, -0.06618806f, -0.04119604f, 0.00712436f, -0.00148384f, -0.02313849f, 0.02272717f, -0.03924362f, 
    -0.00119815f, 0.00289669f, -0.05725342f, -0.00259217f, 0.01695334f, 0.01503181f, 0.03335641f, 0.00065319f, 
    0.04295810f, 0.04683774f, -0.03274813f, 0.00946013f, -0.01445994f, -0.02030313f, -0.06447054f, 0.02750115f, 
    0.05015473f, 0.02602887f, -0.06487018f, -0.04175476f, -0.04941479f, -0.05301339f, 0.02833384f, 0.00314121f, 
    -0.04483930f, -0.01820550f, 0.01759618f, -0.00891957f, -0.00429581f, -0.04907384f, 0.02171708f, 0.00901610f, 
    0.01287890f, 0.03766223f, -0.02817855f, -0.04726288f, -0.02031166f, 0.03714788f, -0.02476978f, -0.02794196f, 
    -0.05589817f, 0.02022573f, 0.01330803f, -0.02560235f, 0.04753563f, -0.06375029f, -0.02582643f, -0.00157067f, 
    0.04274771f, 0.02423299f, -0.04219432f, 0.03965537f, 0.06396791f, -0.00777921f, 0.12667973f, 0.03728776f, 
    -0.02515095f, 0.25799820f, -0.03475669f, -0.26000983f, 0.00219389f, -0.09600502f, 0.05751733f, -0.06708612f, 
    0.07902535f, -0.07418922f, 0.02686606f, 0.04371594f, -0.08463121f, -0.03349980f, -0.05073408f, 0.08014444f, 
    0.03155500f, 0.01420497f, 0.10534699f, 0.05167243f, 0.10812593f, 0.05123306f, 0.11788213f, -0.17094781f, 
    -0.04053412f, -0.12750049f, 0.12778947f, 0.03835188f, 0.21030536f, 0.06479318f, 0.02523712f, 0.08707684f, 
    0.05469497f, -0.08366459f, -0.09475752f, -0.08638785f, -0.16749993f, 0.10535832f, 0.09046233f, -0.00744221f, 
    -0.09537587f, 0.03718674f, 0.03988995f, 0.02298593f, 0.15424520f, 0.10246194f, 0.20216955f, -0.16431949f, 
    0.01616376f, -0.11454124f, -0.04567893f, -0.02635752f, -0.10108424f, -0.04212472f, 0.02860224f, -0.15886673f, 
    -0.09482493f, 0.13351226f, -0.07661880f, -0.02053379f, -0.05370732f, 0.05122588f, 0.05257357f, 0.01895638f, 
    -0.21099752f, -0.18884440f, 0.01074933f, -0.02967254f, 0.07711373f, -0.01437751f, 0.06447338f, 0.10566297f, 
    0.16175489f, -0.04995177f, 0.03606825f, 0.00921196f, -0.08352656f, 0.10199384f, 0.04509839f, -0.01324465f, 
    0.20807268f, 0.01966791f, -0.10330836f, -0.16561158f, 0.10100522f, 0.16236278f, 0.01849461f, 0.05997984f, 
    0.01681304f, -0.12689595f, -0.04993219f, -0.00299655f, -0.21601790f, 0.02424111f, 0.10402131f, 0.13758448f, 
    0.05682630f, 0.04959866f, 0.01371195f, 0.07223888f, 0.11417194f, 0.00129844f, -0.01025079f, -0.05035335f, 
    0.02650359f, 0.09733810f, 0.07105901f, 0.11962432f, 0.06102198f, -0.00358746f, 0.16624337f, -0.13281871f, 
    -0.05345244f, 0.09595170f, -0.04505818f, 0.09871046f, 0.04091270f, -0.15081848f, -0.30388385f, -0.37513986f, 
    -0.12816176f, -0.09900307f, 0.05692584f, 0.14852868f, 0.09283291f, 0.16756460f, 0.07307868f, -0.13379934f, 
    0.11936124f, 0.03374098f, -0.11838610f, -0.19915134f, 0.03235627f, -0.03244888f, 0.03385263f, 0.08295935f, 
    -0.39826947f, -0.16605619f, -0.24227625f, -0.01445184f, 0.09418508f, -0.06581655f, -0.04282312f, -0.02157705f, 
    -0.03286390f, 0.17964429f, -0.03532913f, -0.17278074f, -0.12803078f, 0.14647390f, 0.00325781f, 0.05415672f, 
    0.02984912f, -0.01494215f, 0.26641715f, -0.13948207f, 0.06266224f, 0.06486306f, 0.01562147f, 0.07256297f, 
    -0.04132541f, -0.14449282f, 0.15222493f, -0.02270500f, 0.16677880f, -0.08577964f, -0.09778986f, -0.10241258f, 
    -0.15386069f, -0.05291496f, -0.04178972f, 0.02347076f, 0.23395985f, 0.24849549f, -0.05199564f, 0.05297926f, 
    0.07758381f, -0.00283764f, 0.01133105f, -0.17450194f, 0.02068131f, -0.02734886f, 0.13013645f, 0.10873183f, 
    -0.08839586f, -0.11614961f, 0.02956666f, 0.10486113f, 0.01789852f, 0.07013316f, 0.10144664f, 0.09278694f, 
    -0.00577683f, -0.05326891f, -0.06875397f, -0.14514315f, 0.05138246f, 0.02777576f, 0.12193748f, 0.12217367f, 
    0.32334709f, -0.07941772f, -0.04290239f, -0.07619818f, -0.04428329f, 0.09636767f, -0.01297004f, -0.03690617f, 
    0.32555968f, 0.12981679f, -0.19737178f, 0.00770209f, -0.02643333f, -0.14160632f, 0.14430831f, 0.08309497f, 
    -0.06897770f, 0.32668707f, -0.11449116f, 0.04083498f, -0.07732940f, -0.02832053f, -0.01408086f, 0.00306759f, 
    -0.00607358f, -0.00218614f, -0.13769022f, 0.19290139f, -0.08111460f, -0.10564838f, -0.02786919f, -0.02123914f, 
    -0.04801699f, -0.02473279f, -0.05742864f, -0.19005904f, -0.03865266f, -0.08086304f, 0.04333665f, -0.05042231f, 
    -0.00357186f, 0.02341516f, 0.12047999f, 0.08490436f, 0.08649516f, 0.20157850f, -0.12644076f, -0.11486610f, 
    -0.10713906f, -0.06702396f, -0.00305688f, -0.01465878f, 0.04431090f, 0.14041182f, 0.10248731f, 0.01675535f, 
    0.05460064f, -0.10414410f, 0.01228399f, -0.05380582f, 0.04105857f, 0.03299486f, -0.20611444f, -0.32876930f, 
    -0.06848378f, 0.03909909f, 0.09050511f, 0.06671503f, -0.00613551f, 0.02179804f, -0.12235998f, 0.21447675f, 
    0.04152939f, -0.11733060f, -0.01441958f, 0.01597838f, -0.05030698f, 0.00469619f, 0.02114661f, -0.09866467f, 
    0.23513162f, 0.14635861f, 0.08201270f, 0.11565413f, -0.02407544f, -0.11234698f, 0.09720746f, 0.14782216f, 
    0.14907201f, -0.05665139f, 0.05549921f, 0.08581622f, -0.02649497f, 0.09769145f, 0.01852126f, 0.06278404f, 
    -0.06280071f, -0.03628470f, -0.05159939f, 0.12996709f, 0.12394245f, 0.09178957f, -0.06696973f, 0.03969687f, 
    0.08179510f, 0.10112891f, 0.03385047f, 0.10815547f, -0.11025201f, -0.07417990f, -0.00761571f, -0.06616067f, 
    0.00958624f, 0.06110543f, 0.04242948f, 0.09098311f, 0.01220111f, -0.04095055f, 0.02151265f, -0.08215251f, 
    0.03529424f, 0.05646846f, 0.02912284f, -0.09516858f, -0.08587854f, -0.11454802f, 0.05587237f, -0.11307955f, 
    -0.00018777f, -0.04762343f, 0.03121847f, 0.15026899f, -0.01132763f, 0.07526296f, -0.29738358f, -0.03131163f, 
    0.10237443f, 0.03295628f, 0.09306961f, -0.03883870f, -0.09883455f, -0.12325343f, 0.00692464f, 0.18540195f, 
    -0.18360877f, -0.00455834f, 0.05651135f, 0.07077166f, -0.08559062f, -0.00406660f, 0.14193194f, 0.11878645f, 
    0.07112641f, 0.03297461f, 0.01573101f, -0.19692683f, 0.06105572f, 0.00339936f, -0.00696515f, -0.00409721f, 
    -0.10340293f, 0.06877057f, 0.12927692f, 0.12645209f, -0.01126791f, -0.03784489f, 0.00408934f, 0.02727313f, 
    0.03296610f, 0.05811897f, -0.08983102f, -0.15994200f, 0.11666390f, -0.15435715f, 0.01061229f, -0.03833361f, 
    -0.08952069f, -0.05581155f, 0.13768512f, -0.17578593f, 0.03935599f, 0.04807037f, 0.04059995f, -0.06867753f, 
    -0.09990989f, 0.04430189f, 0.05436951f, 0.05779667f, -0.03295447f, -0.01498614f, 0.01890869f, 0.01262072f, 
    -0.02141888f, 0.01587821f, -0.07022248f, -0.05538738f, 0.02164783f, 0.01146191f, -0.01396783f, 0.15303436f, 
    -0.07529169f, -0.06492127f, 0.00044801f, 0.01491033f, -0.03596168f, 0.01467065f, -0.24125552f, -0.00599200f, 
    -0.06123805f, 0.04504060f, -0.01122985f, 0.08017508f, -0.03702091f, 0.08174980f, -0.03547083f, 0.01743605f, 
    -0.06159278f, -0.01030415f, -0.05985925f, 0.09743223f, 0.04736831f, 0.05081952f, 0.06842983f, 0.00012657f, 
    -0.16328776f, 0.05852672f, -0.11716265f, -0.17954312f, 0.07802586f, 0.02198505f, 0.05299339f, -0.01379678f, 
    -0.01899462f, 0.24774326f, 0.23657256f, 0.09168137f, 0.11111670f, -0.03297517f, -0.01055850f, 0.12278527f, 
    0.02180211f, 0.10044355f, 0.11936899f, -0.02472134f, 0.12914620f, 0.00396243f, 0.09060974f, -0.00512158f, 
    -0.03442224f, -0.13946737f, -0.17228137f, 0.05671620f, 0.04874079f, 0.16394369f, -0.04678454f, 0.04007595f, 
    0.20162040f, 0.02228207f, -0.01943553f, -0.04989289f, -0.04041959f, -0.02944429f, 0.08252285f, -0.12020255f, 
    -0.11533999f, 0.01153840f, -0.02487443f, -0.04652746f, -0.14310448f, -0.07969935f, -0.01730889f, -0.10166635f, 
    0.03264839f, 0.03499237f, -0.13894890f, -0.04158719f, -0.01053279f, 0.02043424f, -0.01009652f, -0.05232489f, 
    0.01076920f, 0.05023389f, 0.09177493f, 0.06708687f, 0.02798634f, -0.08192761f, 0.00438325f, 0.02753659f, 
    0.03096336f, 0.06977705f, -0.04109010f, 0.03350248f, 0.00353508f, -0.12826030f, 0.06497979f, -0.09265479f, 
    0.11556374f, 0.15219437f, 0.06451896f, -0.09717816f, -0.03476058f, -0.00499872f, 0.09448507f, -0.09673100f, 
    -0.08116507f, -0.06967634f, -0.08406888f, -0.20695421f, 0.09752031f, 0.00983568f, 0.07538422f, 0.07491633f, 
    0.01222439f, -0.19575757f, 0.02165326f, 0.16169548f, 0.20630930f, 0.14227872f, 0.08755054f, -0.04313412f, 
    -0.08400284f, -0.01086435f, -0.02645926f, 0.02601838f, -0.17550287f, -0.08963385f, -0.10119227f, -0.07126613f, 
    -0.04596119f, 0.01241050f, 0.05481802f, 0.00642255f, -0.04826420f, -0.11681282f, 0.10198011f, -0.04350467f, 
    0.06489962f, 0.02993133f, -0.13604483f, -0.09300907f, -0.28801805f, -0.05558793f, 0.08700742f, 0.05817805f, 
    -0.03597447f, -0.01293957f, 0.03105185f, -0.00017858f, -0.21393017f, -0.22016120f, -0.22528647f, 0.03884295f, 
    -0.02986127f, -0.04427108f, 0.07919905f, 0.00422024f, -0.02347518f, 0.05376013f, 0.10246608f, -0.07428923f, 
    -0.04225354f, 0.06066487f, -0.13353996f, 0.05290085f, 0.03237247f, -0.06899196f, 0.14684770f, -0.00320030f, 
    -0.04243169f, -0.03133003f, 0.00066387f, 0.03456517f, 0.00443006f, -0.04323222f, -0.05126643f, 0.03388961f, 
    0.02750384f, -0.06170904f, -0.01482942f, 0.04649018f, -0.01779774f, 0.00241735f, -0.03490588f, -0.01752676f, 
    -0.00099604f, 0.01028550f, -0.05968379f, -0.00375826f, -0.02023190f, -0.05847121f, 0.02070882f, -0.00754755f, 
    0.00652908f, 0.05573360f, -0.01556943f, -0.02592438f, 0.01866766f, 0.04195091f, -0.03954455f, -0.00561735f, 
    -0.06130048f, -0.00539404f, 0.03264219f, -0.03197116f, -0.02110952f, -0.02276246f, -0.01713821f, 0.01055057f, 
    -0.06012291f, -0.05822830f, -0.03072285f, -0.03350894f, -0.03274267f, -0.05782987f, 0.03932936f, -0.03457909f, 
    0.00159973f, 0.04711347f, -0.02305892f, 0.03835816f, 0.03164638f, -0.01823797f, -0.04045641f, -0.03268834f, 
    0.03705417f, -0.01366014f, -0.02334388f, 0.02732835f, -0.01224115f, 0.02434203f, -0.01900886f, -0.02648159f, 
    -0.03076913f, -0.03893785f, -0.02307282f, 0.01585794f, -0.00583438f, -0.01185204f, -0.03329862f, -0.04778138f, 
    -0.00932951f, -0.03824107f, 0.03225730f, 0.05029181f, -0.02484940f, 0.04095492f, -0.03079809f, -0.02300985f, 
    -0.03626748f, 0.00781624f, -0.06653761f, -0.03927433f, -0.06377440f, 0.04294781f, 0.02203167f, 0.05185498f, 
    -0.04935598f, -0.04532262f, -0.02017589f, -0.04763078f, 0.04174340f, -0.06588356f, -0.04197951f, 0.04963749f, 
    -0.01491173f, -0.02681635f, -0.04510400f, -0.05494088f, -0.03372362f, -0.02458713f, -0.04817448f, 0.03043170f, 
    0.00432984f, 0.01596014f, -0.06564287f, -0.01768350f, 0.04301243f, 0.00302318f, 0.04581400f, 0.03046324f, 
    -0.00885049f, -0.00199739f, 0.03709026f, -0.02695969f, -0.04798838f, -0.02490402f, 0.04855528f, 0.04885969f, 
    -0.05780848f, -0.01994022f, -0.04139408f, 0.04470462f, -0.02379167f, -0.05685268f, 0.04423664f, 0.01080671f, 
    0.03820477f, 0.01776742f, -0.04933138f, -0.00513602f, 0.01177965f, -0.05794941f, -0.00738318f, 0.01536549f, 
    -0.01505185f, -0.03923295f, 0.03408973f, 0.04853351f, 0.04196837f, -0.00186546f, -0.03182884f, -0.00809038f, 
    -0.06413861f, 0.00268934f, 0.04830911f, 0.02590834f, -0.04139495f, 0.00373676f, 0.03358710f, -0.05538754f, 
    -0.05683322f, 0.00360591f, 0.04252783f, -0.03195620f, -0.00032238f, -0.06607506f, 0.00492694f, -0.04127393f, 
    -0.03395584f, 0.04705968f, -0.03471093f, 0.00000125f, 0.03070051f, -0.03773756f, -0.04573925f, -0.05984136f, 
    -0.05236010f, -0.02144942f, -0.00882394f, -0.05310146f, 0.05450951f, 0.03426681f, 0.00781489f, 0.03156905f, 
    -0.02319200f, -0.04106785f, 0.03003927f, 0.04889753f, -0.02033781f, -0.06190591f, -0.02714680f, 0.04455228f, 
    0.03737173f, -0.02646349f, -0.05871695f, -0.06463926f, -0.02023366f, -0.05983777f, 0.01535123f, -0.00919152f, 
    -0.04624289f, -0.01744377f, 0.00005883f, -0.05566730f, 0.02761363f, -0.01895244f, 0.03727063f, -0.03667658f, 
    0.00097419f, -0.00505503f, 0.00232107f, -0.00857244f, 0.05163361f, 0.02562224f, -0.00931778f, -0.00326951f, 
    -0.04630246f, 0.00351931f, -0.02367534f, 0.04043304f, 0.03882279f, 0.03959319f, -0.00170576f, 0.02917881f, 
    0.02625808f, -0.01875036f, -0.03415868f, -0.06344373f, 0.03260895f, -0.02574146f, -0.01250484f, 0.03266884f, 
    -0.05576058f, 0.02187623f, -0.01718993f, 0.03967769f, 0.00374748f, -0.00806454f, -0.06302865f, -0.05658240f, 
    -0.05669113f, 0.04270113f, 0.03205768f, -0.01309645f, -0.06422861f, 0.04503069f, -0.00294885f, 0.04862991f, 
    0.00936045f, -0.04836352f, -0.04930774f, -0.04154870f, -0.00126092f, -0.01994137f, -0.02945985f, 0.04247179f, 
    -0.04159232f, -0.00881474f, 0.02786344f, 0.00152218f, 0.03509077f, 0.04188006f, 0.03637809f, 0.02830434f, 
    -0.00000851f, -0.04813389f, 0.04959120f, 0.02604512f, -0.02867281f, -0.00297841f, -0.06614578f, 0.01893675f, 
    -0.04061700f, -0.01815054f, -0.06361095f, -0.04348679f, 0.01733304f, 0.00929404f, 0.00477753f, 0.04338916f, 
    -0.05144944f, 0.04318161f, -0.00167217f, 0.01789579f, -0.00206914f, -0.04166542f, 0.03203506f, 0.02341566f, 
    -0.04575957f, -0.03719625f, -0.01431224f, -0.04772239f, -0.02766914f, 0.01594988f, -0.00336977f, 0.00161035f, 
    -0.03728941f, 0.04209901f, -0.04588848f, -0.02727905f, 0.02648186f, -0.04623258f, -0.01953359f, -0.05050582f, 
    -0.03457350f, -0.01423949f, -0.02302132f, -0.04263715f, 0.03298751f, 0.01531135f, 0.01496053f, 0.00958107f, 
    -0.04208594f, 0.02988275f, -0.06507259f, 0.02142460f, -0.04934926f, 0.02577444f, -0.00670962f, 0.02402432f, 
    -0.03225613f, -0.02156078f, 0.00963078f, -0.05238301f, -0.05270068f, 0.02265413f, -0.06022858f, -0.02937884f, 
    0.04315327f, -0.04306635f, 0.02369799f, -0.00968781f, -0.02273051f, 0.02783613f, 0.03058536f, 0.02128723f, 
    0.01070183f, -0.04585895f, 0.00997860f, -0.03894985f, 0.03485958f, -0.00510717f, -0.02688452f, -0.03537104f, 
    -0.02807995f, 0.02824769f, -0.01271955f, 0.02348845f, -0.01810293f, 0.00409538f, -0.04474588f, -0.05600672f, 
    0.03044661f, -0.05865770f, -0.02459427f, -0.02190433f, 0.04762249f, 0.01801990f, -0.03752288f, 0.02196631f, 
    -0.01241598f, 0.01283093f, 0.03421230f, -0.02490609f, -0.06086987f, -0.01421983f, -0.04863497f, 0.04934266f, 
    0.03222851f, -0.04562538f, 0.04510442f, 0.00148766f, 0.04369023f, 0.00685302f, -0.00069366f, 0.03211536f, 
    -0.02417032f, -0.02881368f, -0.05220557f, -0.00773771f, 0.03619552f, -0.05305633f, -0.01354165f, 0.04142884f, 
    0.01547292f, -0.05896197f, -0.02527267f, -0.05785559f, 0.04800807f, 0.01274491f, 0.01635970f, -0.05748005f, 
    -0.06076572f, 0.02343561f, -0.00592734f, -0.04810952f, -0.02984758f, 0.00932988f, 0.00064600f, 0.03917315f, 
    -0.06216585f, -0.04819729f, -0.00832666f, -0.04527396f, -0.05039664f, -0.00821235f, -0.00656288f, -0.00838521f, 
    -0.03730311f, -0.04519792f, -0.03319611f, 0.00133601f, -0.06049598f, -0.03800279f, -0.06288294f, -0.03326174f, 
    0.00777658f, 0.03706439f, -0.00316689f, 0.02750006f, -0.04917172f, -0.04879549f, -0.04591555f, -0.06227693f, 
    0.02056751f, -0.02658195f, 0.02822151f, 0.00234441f, 0.03681967f, -0.02953372f, -0.04088890f, 0.03568457f, 
    -0.02966987f, -0.01169061f, -0.04521186f, 0.01425876f, 0.04294503f, -0.00162579f, 0.00258008f, -0.02304615f, 
    -0.05500657f, 0.00105946f, 0.02904094f, -0.05505256f, -0.04869324f, -0.02510377f, -0.03514332f, 0.02428740f, 
    -0.05098935f, -0.05005526f, -0.05783373f, 0.03349222f, -0.06522980f, -0.03577745f, -0.01479350f, 0.03365783f, 
    0.04841210f, 0.02991140f, 0.01356229f, -0.04218928f, 0.03865766f, 0.04956241f, -0.01149149f, -0.06627906f, 
    0.00825823f, 0.04996243f, -0.02536522f, -0.03336282f, -0.03579720f, -0.05444209f, 0.03607005f, 0.03779379f, 
    0.01145385f, -0.01009393f, -0.00043171f, 0.01026045f, -0.06224965f, 0.03421455f, -0.05259087f, 0.02367618f, 
    -0.00892552f, 0.03912251f, -0.05926756f, -0.01170540f, -0.01393571f, -0.01771270f, -0.00622402f, -0.02696331f, 
    -0.06364636f, 0.00712151f, -0.06328021f, 0.02971948f, -0.00825565f, -0.00511608f, -0.03486772f, -0.04134800f, 
    0.03121841f, -0.06030039f, 0.02707955f, -0.04389973f, 0.04566696f, -0.05147726f, -0.03192531f, 0.02113685f, 
    0.00997767f, 0.00283085f, -0.01183692f, 0.02694473f, -0.03186457f, 0.00290919f, 0.04046024f, -0.01844499f, 
    -0.06397127f, 0.02037328f, -0.01363014f, 0.02803553f, -0.03544104f, 0.00136368f, -0.01802680f, 0.02255744f, 
    -0.01855472f, -0.02319513f, 0.01169193f, -0.05410314f, -0.04785219f, 0.03441105f, -0.04196222f, -0.04346234f, 
    0.03317898f, 0.03951564f, 0.03019908f, 0.04825920f, 0.04458072f, -0.03801103f, -0.03179269f, -0.05042282f, 
    0.01904412f, 0.03330133f, 0.02320610f, 0.01846510f, -0.02120889f, 0.02645476f, -0.02105768f, -0.05915517f, 
    -0.04592867f, 0.01528124f, -0.00001844f, -0.05670355f, 0.04620255f, -0.03177009f, -0.02417923f, -0.05914849f, 
    0.01441545f, -0.05553042f, -0.03146214f, -0.03621149f, -0.02545949f, -0.03005756f, 0.00106939f, -0.04655694f, 
    0.04677029f, 0.01565600f, -0.01204058f, -0.06449664f, 0.01048919f, -0.04787258f, -0.03050686f, -0.02140257f, 
    -0.00798175f, -0.03842585f, -0.02355720f, -0.01699704f, -0.00660302f, -0.04725805f, 0.01100835f, 0.03641238f, 
    -0.03262501f, -0.04297237f, 0.01165793f, -0.01342930f, 0.04418024f, 0.04718709f, 0.01180701f, 0.03942868f, 
    0.03851137f, -0.05018609f, -0.00450735f, 0.01932581f, 0.01480146f, -0.04372396f, -0.05498626f, -0.05895500f, 
    0.00494879f, -0.04115457f, 0.00313507f, 0.03130634f, -0.05439436f, -0.03551913f, 0.03564379f, -0.00270700f, 
    0.00584270f, -0.00039010f, 0.00542700f, -0.03559093f, -0.04410447f, 0.03879407f, 0.00847488f, 0.04765308f, 
    0.04271778f, 0.01410445f, 0.00458573f, -0.02896678f, 0.02640781f, -0.02749192f, -0.02515543f, -0.00699856f, 
    -0.05191718f, 0.00465789f, 0.00541483f, -0.03728062f, -0.04956502f, 0.00161059f, 0.01805031f, 0.04332895f, 
    -0.03856280f, -0.06474485f, -0.00188290f, -0.03192921f, 0.04602214f, -0.04347866f, 0.01589981f, -0.01393659f, 
    -0.01419000f, -0.03877497f, -0.03502213f, 0.00826944f, -0.03423561f, -0.03653290f, -0.03738070f, 0.04098380f, 
    -0.00768212f, -0.04099669f, 0.01301021f, 0.02495637f, 0.00483005f, 0.01070770f, 0.00052595f, -0.03756146f, 
    0.04176544f, -0.00978069f, 0.02270802f, -0.05393320f, 0.04112251f, 0.02635853f, -0.05268031f, -0.02540621f, 
    -0.02590360f, -0.00461656f, 0.01079125f, 0.01933252f, -0.00798645f, -0.01282694f, -0.06580878f, 0.04181218f, 
    -0.02303118f, 0.02368241f, 0.03331496f, -0.01773139f, -0.06082128f, -0.05522726f, -0.02639133f, -0.05097319f, 
    0.04230907f, -0.03072155f, 0.03659131f, -0.04745864f, -0.03443636f, -0.04633870f, -0.01427645f, -0.03062745f, 
    -0.02548158f, -0.01156532f, -0.06044215f, 0.04907048f, 0.04100120f, 0.01549408f, 0.00420320f, 0.01464869f, 
    -0.05092233f, -0.03852198f, -0.00551725f, -0.02208444f, -0.01064728f, 0.04659897f, -0.06104649f, -0.00585968f, 
    -0.00910277f, -0.06671450f, 0.02993597f, -0.06841712f, 0.04207106f, -0.02888585f, 0.04919854f, -0.06130801f, 
    -0.03243402f, -0.02237715f, 0.04441976f, -0.06601238f, -0.01244921f, -0.02186049f, -0.03409898f, -0.00396705f, 
    0.01179398f, -0.01562209f, 0.00996903f, -0.02761869f, 0.00610338f, -0.03245502f, -0.06281719f, -0.04902114f, 
    0.02136593f, -0.02961645f, -0.05902850f, -0.00572285f, -0.03766945f, 0.04043064f, 0.00451018f, -0.05158540f, 
    0.03713699f, -0.03028275f, -0.04907302f, -0.00252536f, -0.05426666f, 0.02908624f, 0.02385860f, 0.00107653f, 
    0.01162433f, 0.01142293f, -0.05903279f, 0.04991430f, -0.00164423f, 0.01559880f, 0.05057108f, -0.04642637f, 
    -0.01119590f, -0.05963185f, -0.00551943f, 0.03737968f, -0.00006888f, -0.00188928f, -0.05986638f, -0.02362124f, 
    -0.03489508f, -0.00293527f, 0.00292637f, -0.03694763f, -0.01324812f, -0.02254511f, -0.04906331f, -0.01049405f, 
    0.01370994f, -0.04680718f, 0.01177394f, -0.00137883f, -0.00930985f, 0.03516328f, 0.00572529f, -0.03334820f, 
    -0.06560140f, -0.02726956f, -0.04891438f, -0.01807468f, 0.04362203f, -0.03438008f, -0.02861891f, 0.00388931f, 
    0.03269016f, 0.04848266f, -0.05367847f, 0.02355132f, 0.00295725f, -0.04490658f, -0.00393143f, -0.00680798f, 
    -0.05579015f, -0.03792678f, 0.03527195f, -0.02874327f, 0.00004316f, -0.01209820f, 0.01575113f, -0.02174563f, 
    -0.04827946f, 0.03618200f, -0.05106075f, 0.05243982f, 0.02690782f, 0.03809753f, 0.04006812f, -0.05221675f, 
    -0.04977662f, -0.03736495f, 0.00270453f, 0.04964954f, -0.05528054f, -0.05852424f, -0.01570215f, -0.00923507f, 
    0.01318270f, -0.03457683f, 0.00958792f, 0.04519537f, 0.04334726f, -0.05049546f, 0.05120707f, -0.06062507f, 
    -0.05081667f, 0.03596788f, 0.04723139f, 0.02156381f, 0.00875770f, -0.06515588f, 0.01865556f, 0.00953555f, 
    0.03414696f, -0.01944852f, -0.04337636f, 0.04577570f, 0.04409514f, 0.00057638f, 0.00230387f, 0.04372723f, 
    -0.00441786f, -0.00406927f, 0.03972058f, 0.04361289f, -0.05940497f, -0.06052684f, -0.02575682f, -0.02379592f, 
    0.00542928f, -0.00908581f, -0.06101025f, -0.00707937f, 0.02519621f, -0.02239875f, 0.05008000f, 0.05027082f, 
    -0.03920918f, 0.03997288f, 0.03570255f, 0.02218316f, -0.02731699f, 0.02864235f, 0.02743554f, 0.01816548f, 
    0.04803704f, 0.03733637f, -0.02732467f, 0.02458502f, -0.02123548f, 0.01091959f, -0.01517787f, 0.01376784f, 
    -0.04195907f, -0.03072249f, -0.03105142f, 0.03743289f, -0.00802507f, -0.02433668f, 0.00689317f, 0.01215807f, 
    -0.04929924f, -0.05975048f, -0.05163801f, -0.05779843f, 0.03532425f, 0.00854860f, -0.01683624f, -0.02818575f, 
    0.01907574f, -0.01127604f, 0.00536507f, -0.04539771f, 0.03152880f, 0.00240043f, -0.03694367f, 0.02310903f, 
    0.04322369f, -0.03457173f, -0.01348327f, -0.02595260f, -0.06085809f, -0.06313067f, -0.04320231f, 0.03610193f, 
    0.01764753f, 0.02304060f, 0.01822805f, -0.03832496f, -0.01266169f, -0.06424032f, -0.03253687f, -0.02590546f, 
    -0.04400245f, -0.01291642f, -0.05383203f, 0.02640533f, -0.01148468f, -0.05971581f, -0.02117856f, 0.02731187f, 
    0.03940882f, -0.00105746f, 0.02467290f, 0.01052997f, -0.04418516f, -0.01136183f, -0.03173611f, 0.00557860f, 
    0.00632002f, 0.02139438f, 0.01686066f, -0.03882068f, 0.04317696f, -0.03842812f, -0.02094708f, -0.00274003f, 
    -0.05801163f, -0.00767066f, 0.01954626f, 0.04560476f, 0.05077606f, -0.01398305f, -0.03693584f, 0.02305278f, 
    0.03039698f, -0.04951887f, 0.01441703f, -0.00394207f, 0.01009494f, 0.00100767f, -0.03925310f, -0.06103238f, 
    -0.05553055f, 0.03008244f, -0.06435616f, 0.03546289f, -0.04010664f, -0.05459870f, 0.00619233f, -0.06005122f, 
    0.03680056f, -0.00411997f, -0.02402256f, 0.02428963f, 0.01378866f, 0.00500280f, 0.04113611f, 0.05149772f, 
    0.01266523f, -0.01971933f, -0.01791281f, -0.05869097f, -0.04108625f, 0.02907939f, -0.02841629f, 0.01996674f, 
    0.00455079f, 0.00025828f, -0.03713651f, -0.05339076f, 0.00412889f, 0.00869552f, -0.02486082f, 0.01812947f, 
    0.00687026f, -0.04856067f, -0.01050478f, -0.02568500f, -0.03500894f, 0.04259115f, 0.00270695f, -0.05126793f, 
    0.00471473f, 0.01214376f, -0.00669127f, 0.00850615f, -0.04331915f, -0.00544895f, -0.00149521f, 0.04325725f, 
    -0.03017518f, -0.05375868f, -0.05123642f, -0.02609544f, -0.05787629f, 0.00812914f, -0.05635875f, -0.00956084f, 
    -0.06158360f, 0.03783709f, 0.01282561f, 0.00988966f, -0.02125586f, -0.00137407f, -0.01292515f, 0.00647942f, 
    -0.00800594f, 0.04541384f, 0.05052288f, 0.00223512f, -0.00498723f, -0.06037552f, -0.04063161f, 0.05135536f, 
    0.01787939f, -0.05607104f, 0.00434698f, -0.01717828f, -0.04380547f, 0.03575104f, -0.04325280f, -0.03877392f, 
    -0.05802797f, 0.00576942f, 0.01103377f, 0.04943436f, 0.04223165f, -0.02035603f, -0.04636513f, -0.03117120f, 
    -0.01353611f, 0.04521640f, -0.00109248f, -0.05018530f, 0.00360979f, -0.06485687f, 0.02132933f, 0.03959021f, 
    0.01470945f, -0.04304398f, -0.05048097f, -0.00797562f, -0.01638797f, -0.06499987f, 0.02216032f, 0.00613289f, 
    -0.04905349f, 0.04466474f, 0.04250167f, -0.03573718f, -0.00437104f, 0.02735470f, -0.03770867f, -0.02100802f, 
    0.00351316f, -0.04153590f, -0.05281380f, -0.05305959f, 0.00797759f, -0.03982360f, -0.01637761f, -0.00233183f, 
    0.04090091f, 0.00526951f, 0.01172591f, -0.04026695f, 0.03674193f, 0.01025401f, -0.03946915f, 0.00812783f, 
    0.04919707f, -0.01859009f, -0.00819558f, 0.02682650f, -0.02207303f, -0.00998775f, 0.03362807f, -0.06288990f, 
    0.05060632f, -0.02674537f, -0.04442756f, -0.03196140f, 0.01862195f, -0.03544378f, 0.00539657f, 0.02042590f, 
    0.04305404f, -0.04778507f, 0.05074933f, -0.03972833f, 0.01333224f, 0.04067107f, -0.03202075f, 0.00767024f, 
    -0.00352359f, -0.04807599f, -0.03945334f, 0.03712862f, -0.00399738f, 0.02763937f, -0.05105427f, 0.01823037f, 
    -0.04685922f, -0.00703861f, -0.01867815f, 0.01560278f, -0.06070625f, 0.01733820f, -0.01773655f, -0.04469299f, 
    -0.02211288f, -0.04233427f, 0.04830602f, -0.03235338f, -0.01238035f, -0.02619342f, 0.02605494f, -0.00554759f, 
    0.04429682f, -0.02996098f, -0.00697436f, -0.03958433f, 0.00836069f, -0.05308762f, -0.03779265f, 0.01435681f, 
    -0.05293044f, -0.02468211f, -0.05208809f, 0.00581422f, -0.05421763f, 0.02864899f, 0.00336819f, 0.04873491f, 
    0.04269411f, -0.02505332f, 0.04722962f, 0.02037185f, -0.02540761f, -0.04708411f, 0.03389941f, -0.04057158f, 
    -0.00702101f, -0.02439288f, -0.01528738f, -0.06402964f, -0.02637408f, 0.02274716f, 0.03803891f, -0.00750520f, 
    -0.02616220f, -0.00902333f, -0.06552336f, 0.02913656f, 0.01907234f, -0.05469823f, -0.05862579f, -0.00339509f, 
    -0.01231563f, 0.01002823f, 0.00853833f, 0.01203256f, 0.02831848f, -0.04110204f, 0.00176898f, -0.01562763f, 
    0.03368074f, -0.06512555f, 0.05057393f, -0.05035612f, 0.04911605f, 0.00432085f, 0.04588721f, 0.02332967f, 
    0.04311208f, 0.02177085f, -0.03142722f, -0.04494676f, 0.03605437f, 0.03721131f, 0.04915142f, -0.02733054f, 
    0.02447616f, 0.04365017f, 0.01571727f, 0.00704498f, 0.04882164f, -0.01249943f, 0.01681010f, 0.00027366f, 
    0.04822304f, 0.01596404f, -0.01208284f, -0.01920938f, -0.05380648f, -0.02046273f, -0.03243690f, -0.00349280f, 
    0.00269201f, 0.03745496f, -0.05776549f, -0.04102711f, -0.02491631f, -0.04312680f, 0.02659033f, -0.07044152f, 
    -0.02720980f, -0.02818543f, 0.03944048f, 0.02548429f, -0.01183389f, 0.00732316f, -0.02863491f, 0.04607525f, 
    -0.00935934f, -0.05397439f, 0.04065692f, 0.01761811f, 0.05023896f, 0.01841960f, -0.03677050f, -0.05756891f, 
    0.02461848f, 0.02008349f, -0.01116296f, 0.05237582f, -0.02854300f, -0.06386986f, -0.00130543f, 0.03116921f, 
    -0.03429615f, -0.03142980f, -0.05280526f, 0.02325597f, 0.03260483f, 0.02753742f, -0.05741387f, 0.01112012f, 
    -0.06398440f, -0.02272586f, -0.00713856f, 0.00845669f, 0.00317194f, 0.03127698f, -0.00410193f, -0.06399849f, 
    -0.04144645f, -0.07860595f, 0.01067772f, -0.01837296f, -0.03345429f, -0.05864630f, 0.02943499f, 0.01702682f, 
    -0.00583375f, 0.00029334f, 0.03334943f, -0.05894556f, -0.02595752f, 0.02721155f, 0.02739233f, 0.02131871f, 
    -0.01426403f, 0.03989364f, -0.04450802f, -0.01877720f, -0.01014073f, -0.04944530f, -0.03396585f, 0.05988930f, 
    0.02095420f, 0.01541325f, 0.04479680f, -0.02433060f, 0.00235622f, 0.01109194f, 0.04494752f, -0.03422260f, 
    0.00388338f, 0.02357991f, -0.03616414f, 0.05131685f, -0.02703395f, 0.02936148f, -0.02344347f, 0.01551172f, 
    0.02407243f, 0.03165314f, 0.03459164f, 0.00224216f, -0.00445022f, -0.00161712f, 0.00486384f, -0.01548215f, 
    0.01185943f, -0.04535080f, -0.05306812f, 0.02437799f, 0.01225769f, -0.02262990f, -0.03520723f, 0.00703413f, 
    -0.05406241f, -0.00740547f, 0.02417500f, -0.01727922f, -0.03681976f, -0.02503987f, 0.02877127f, -0.03743305f, 
    -0.04113951f, 0.02822161f, 0.03728757f, -0.04357418f, -0.02729391f, -0.00962874f, 0.00523370f, -0.02188289f, 
    -0.02458009f, -0.04684396f, -0.00574034f, -0.04407295f, -0.03694434f, 0.02105739f, -0.06072858f, 0.00257760f, 
    -0.05304255f, 0.00573974f, 0.03967610f, 0.03267678f, -0.04452263f, 0.00243709f, -0.03445062f, 0.02219638f, 
    0.01283074f, -0.03777813f, 0.04003992f, -0.06141993f, -0.04420910f, -0.02523221f, -0.00718217f, -0.00026028f, 
    0.02441224f, 0.01959323f, 0.02421353f, -0.03191316f, 0.00284411f, 0.02876888f, -0.02047857f, 0.02802964f, 
    0.03447756f, -0.05405127f, -0.01993379f, 0.02691263f, 0.04838727f, 0.04711630f, -0.04851197f, 0.05132617f, 
    -0.00505426f, -0.06026170f, -0.04437312f, -0.02090282f, 0.00931025f, -0.00852506f, 0.00002454f, 0.00071026f, 
    0.05043225f, 0.01762325f, 0.03475340f, 0.00090921f, -0.04920796f, 0.00563891f, 0.00299722f, 0.04896145f, 
    0.02036980f, -0.05808292f, -0.04727222f, -0.05488924f, 0.05408470f, 0.00380898f, -0.05795490f, 0.00004676f, 
    -0.05454582f, 0.04323407f, 0.03417510f, -0.00084242f, -0.03246940f, 0.04058303f, 0.01626041f, 0.03449567f, 
    0.02850960f, -0.02061326f, -0.01298861f, 0.03526988f, -0.02603237f, -0.06045185f, 0.03704339f, -0.02439522f, 
    -0.04761917f, -0.03615169f, 0.00043167f, -0.04025570f, -0.06444712f, -0.02302763f, 0.03210351f, -0.05279328f, 
    0.04664213f, -0.03780502f, 0.03735257f, -0.00361452f, -0.01104637f, 0.00361375f, -0.04927565f, -0.03086810f, 
    -0.01739378f, -0.03090144f, -0.01203473f, 0.02909583f, 0.03910353f, 0.00547852f, 0.03434231f, -0.03663750f, 
    0.01973876f, -0.06243610f, -0.03399263f, 0.02932630f, 0.00418014f, 0.03055578f, -0.06073759f, -0.00707065f, 
    -0.05513459f, -0.04412919f, -0.05683176f, -0.04826042f, -0.05974090f, 0.01222910f, -0.03836715f, 0.02535636f, 
    -0.01963913f, 0.03887733f, 0.00031403f, -0.05898556f, -0.05448267f, -0.00457168f, -0.03165269f, -0.01380252f, 
    -0.34905002f, 0.19569369f, 0.05804017f, -0.02951446f, 0.09206844f, 0.00008331f, -0.04611282f, -0.00532006f, 
    -0.18854783f, 0.00038982f, 0.09950466f, -0.00628831f, -0.00067300f, -0.04251498f, 0.01415126f, 0.11068428f, 
    0.06733496f, -0.01635764f, -0.16729164f, -0.03737679f, 0.05684951f, 0.11061426f, -0.03631265f, -0.01849368f, 
    -0.00560925f, 0.10760819f, -0.00030980f, 0.15369733f, 0.10427245f, 0.15924200f, 0.00151623f, 0.24845648f, 
    -0.08147740f, 0.02016483f, 0.06605390f, 0.18603376f, 0.29396826f, -0.00668842f, -0.08640194f, 0.00042860f, 
    -0.15952072f, 0.03149058f, -0.17063729f, 0.09824536f, -0.02901081f, 0.09202051f, 0.00716355f, 0.16696359f, 
    -0.13525249f, 0.08242651f, 0.06323954f, 0.01891861f, -0.03430161f, 0.00282489f, 0.06637064f, -0.04335831f, 
    -0.34238875f, -0.02412051f, 0.12506884f, 0.10100400f, 0.17339545f, 0.14450960f, -0.07675433f, 0.17573689f, 
    0.08802877f, 0.13322595f, 0.01718697f, -0.13449651f, -0.05585631f, 0.02778294f, 0.06169870f, 0.11429847f, 
    0.15608612f, -0.04439354f, -0.05955926f, 0.07167982f, 0.01049402f, -0.12769502f, 0.04738582f, -0.01028291f, 
    -0.05003497f, -0.11918719f, -0.25703257f, 0.11534476f, -0.17320670f, 0.06126293f, 0.01895801f, -0.07246583f, 
    -0.10331342f, -0.04393898f, -0.40390891f, -0.10387926f, -0.03905251f, 0.04861012f, 0.11124609f, -0.04334284f, 
    0.09004851f, 0.12350401f, 0.08102602f, -0.10846701f, -0.06205685f, 0.06742445f, 0.17738329f, 0.04580096f, 
    -0.11986177f, 0.07904290f, 0.00500957f, -0.03922929f, 0.06122113f, 0.08183092f, -0.06059559f, 0.16596632f, 
    -0.12155250f, -0.11233974f, 0.04770418f, 0.13763253f, 0.05876049f, -0.11896005f, 0.05125444f, -0.06631923f, 
    0.09964338f, 0.00517802f, -0.10387309f, -0.07286477f, -0.02540983f, 0.02904721f, 0.04437713f, -0.09976690f, 
    -0.12737274f, 0.09834058f, 0.01610707f, -0.00338292f, -0.00777795f, -0.08452591f, 0.06644464f, 0.00842230f, 
    -0.13684918f, 0.11370263f, 0.00453917f, -0.07512140f, 0.01499686f, 0.03533983f, 0.04441574f, -0.04022567f, 
    0.09384213f, 0.22304954f, 0.18454261f, 0.12691528f, -0.03042553f, -0.14205079f, 0.13119850f, 0.10821326f, 
    -0.00691050f, -0.11277360f, 0.03963720f, 0.13662578f, -0.03717917f, 0.02807997f, -0.09287383f, 0.04049187f, 
    -0.13080843f, 0.05928805f, -0.08656570f, -0.07378423f, -0.12880823f, -0.02939928f, 0.04833665f, -0.04428290f, 
    -0.00447207f, 0.07977888f, -0.08844320f, 0.07196179f, -0.10794346f, 0.03049702f, -0.08086979f, -0.04044801f, 
    0.01143613f, -0.03848476f, 0.14388357f, 0.19253162f, -0.17371826f, -0.15104045f, -0.16531810f, 0.00231230f, 
    0.01654340f, 0.01340926f, 0.05674706f, 0.06825103f, -0.04608969f, -0.03180330f, -0.01005391f, -0.06205717f, 
    -0.20981003f, 0.13761891f, 0.07013594f, 0.02265160f, 0.03196054f, 0.03875294f, -0.03617733f, -0.18830538f, 
    0.15990432f, -0.16536203f, 0.15929264f, -0.05283996f, -0.03037920f, 0.05742767f, 0.00601728f, -0.15140557f, 
    0.12145433f, -0.00289823f, -0.14107138f, -0.08159730f, 0.00968632f, 0.01723673f, -0.02756653f, -0.08219623f, 
    -0.21179247f, 0.09585830f, -0.05354859f, 0.01844056f, -0.01627268f, 0.03250666f, 0.08591624f, -0.05844783f, 
    0.00552406f, 0.02922722f, -0.19824907f, -0.11371105f, -0.02995825f, -0.22281064f, 0.13920005f, 0.07152779f, 
    -0.15615286f, 0.21628685f, 0.00713857f, -0.07891873f, 0.16084461f, 0.03111095f, -0.07777686f, 0.00238592f, 
    -0.00768706f, 0.06890088f, -0.06487548f, 0.14715619f, 0.03584754f, -0.05594309f, 0.12063795f, -0.04499212f, 
    -0.03571012f, 0.02774864f, -0.01227943f, -0.02720693f, 0.07732262f, 0.11763807f, -0.13375480f, -0.04131604f, 
    0.01822112f, 0.07543401f, -0.15073007f, -0.04456700f, 0.03231243f, -0.08603518f, 0.05813290f, -0.24127768f, 
    0.08837318f, -0.02776235f, 0.00859170f, 0.12343484f, -0.04390299f, 0.04482551f, 0.09565905f, 0.03052776f, 
    0.18529579f, 0.23619305f, -0.01339886f, -0.11032376f, 0.08189379f, -0.00905847f, 0.11477532f, 0.12912598f, 
    0.14261882f, -0.00000734f, -0.02127328f, -0.05426905f, -0.17501181f, -0.00805458f, 0.01131068f, -0.04352311f, 
    -0.06612229f, -0.07822072f, 0.10268461f, -0.04089550f, 0.05657457f, 0.04377010f, 0.06608998f, 0.14535271f, 
    0.06231304f, 0.03186103f, -0.08564758f, 0.01805833f, -0.03012254f, 0.08238192f, -0.05133625f, 0.06355709f, 
    -0.00927407f, -0.04069711f, -0.13724032f, 0.11658563f, 0.11252017f, 0.13177074f, -0.00777816f, 0.10566566f, 
    0.00644814f, -0.05310255f, 0.02188769f, 0.09360210f, 0.00553892f, -0.12106279f, -0.00192141f, 0.01551889f, 
    0.03867995f, 0.04687059f, -0.03064512f, 0.05163487f, -0.28134856f, -0.04685088f, -0.06170002f, -0.02198428f, 
    0.09432714f, -0.02876037f, 0.03522972f, -0.04595718f, -0.10183336f, 0.14117022f, 0.03356538f, 0.05097710f, 
    0.06160994f, 0.03213613f, -0.06914148f, 0.00528387f, 0.05495588f, 0.04418555f, -0.12120581f, -0.09352037f, 
    -0.22870547f, 0.11826698f, 0.03499100f, 0.07039501f, -0.04900267f, -0.04607394f, -0.01447537f, 0.06282626f, 
    0.16370086f, -0.14684632f, 0.04542318f, -0.06550385f, 0.17288408f, 0.05564165f, -0.09530841f, 0.02164435f, 
    -0.00976342f, -0.15003780f, 0.09067398f, -0.03085758f, 0.05298322f, -0.05601889f, 0.10671011f, -0.03362441f, 
    0.13145114f, 0.10695542f, 0.00155948f, 0.18259704f, -0.03890530f, -0.02506461f, -0.09151709f, -0.10599783f, 
    0.09510650f, 0.09918473f, -0.11303812f, 0.06817494f, -0.05820102f, -0.12858990f, 0.14323625f, 0.00536985f, 
    0.03968638f, -0.03522401f, 0.02207453f, 0.00667893f, 0.14298126f, -0.13389333f, 0.03865782f, 0.09793972f, 
    -0.06981915f, 0.05304211f, 0.08785977f, -0.04607000f, 0.22306955f, 0.07609149f, -0.04049060f, -0.03286904f, 
    -0.01396670f, -0.09536027f, -0.04011656f, -0.10497959f, -0.01009988f, 0.26788768f, -0.03760048f, -0.14615780f, 
    -0.01056841f, -0.01972485f, -0.06970312f, 0.01085932f, -0.07593327f, 0.07139380f, 0.14057569f, -0.00411396f, 
    -0.11536244f, -0.09330037f, -0.03242129f, -0.00346828f, -0.05331801f, 0.04358400f, -0.02498440f, 0.05639873f, 
    0.08487032f, 0.08620860f, -0.04884691f, -0.00865964f, -0.08767705f, 0.00842997f, 0.08808990f, 0.15439683f, 
    0.25229156f, -0.06746874f, -0.12273841f, -0.01492267f, 0.04612254f, -0.01768932f, 0.03798851f, -0.10666944f, 
    0.04827717f, 0.10063589f, 0.21889755f, 0.07807773f, -0.00597676f, -0.16566132f, -0.00499059f, 0.11864405f, 
    0.18054813f, -0.05693220f, 0.00613600f, -0.20201269f, -0.10232524f, -0.06007392f, 0.04160243f, 0.05987806f, 
    0.11634251f, -0.02463607f, -0.05142882f, -0.09937391f, -0.10829151f, 0.14929940f, 0.11306054f, 0.01718550f, 
    -0.01954325f, -0.06202079f, -0.15274291f, -0.03994417f, 0.10732493f, -0.15978600f, -0.44969642f, 0.09723963f, 
    0.10572303f, 0.01634105f, 0.08118579f, 0.05421035f, 0.00540173f, -0.29016718f, -0.01106028f, -0.14480330f, 
    0.06369070f, -0.02132449f, -0.04541426f, -0.10717427f, -0.04615742f, 0.07774036f, 0.05204311f, 0.08823044f, 
    0.01918690f, -0.04282239f, -0.00269206f, -0.03022936f, 0.03248157f, 0.13784571f, -0.01195343f, 0.16175838f, 
    -0.10852829f, 0.07285400f, 0.10732645f, -0.05205149f, 0.03020824f, -0.07186650f, 0.04482232f, 0.06503162f, 
    0.06816392f, -0.01533998f, 0.24387661f, 0.03852019f, 0.12336973f, -0.21548848f, -0.08080699f, 0.08453508f, 
    -0.04568029f, -0.17422153f, -0.38225475f, -0.04461526f, -0.03837889f, -0.08772884f, -0.02339235f, 0.01743939f, 
    0.02189388f, 0.13977060f, 0.01302689f, 0.10320063f, 0.11850487f, 0.01411239f, -0.08356992f, 0.02136141f, 
    0.03741255f, 0.01953098f, 0.02288303f, -0.02198141f, 0.03407439f, 0.03648953f, -0.07674701f, 0.00423963f, 
    -0.08173239f, -0.03900268f, -0.05237092f, 0.11219858f, 0.13297157f, -0.25808758f, -0.06222144f, 0.02124459f, 
    -0.02913955f, -0.05774917f, -0.01000585f, -0.07036191f, -0.07399634f, -0.06975292f, -0.14526115f, -0.13925463f, 
    0.07453476f, -0.00371548f, -0.00887653f, -0.14092758f, -0.03501899f, 0.00179305f, 0.09933992f, 0.20489079f, 
    0.08705989f, -0.06264172f, -0.06047861f, -0.04771417f, -0.02392392f, 0.11885151f, -0.08691564f, 0.29038978f, 
    -0.04799405f, -0.16863459f, -0.06641608f, -0.08791851f, -0.14464442f, -0.22748265f, -0.01557448f, 0.18571408f, 
    0.04814047f, -0.02619173f, 0.01926543f, 0.00485726f, 0.04828550f, 0.02013455f, -0.07349662f, 0.04857269f, 
    0.02206837f, 0.04476351f, 0.00500226f, -0.04792089f, 0.04551430f, 0.01625127f, -0.01101102f, 0.00755968f, 
    -0.00102725f, -0.01802224f, -0.00118822f, 0.02754802f, 0.00793079f, 0.02344597f, -0.02197988f, 0.04149713f, 
    0.01431989f, 0.04047117f, -0.02935045f, -0.06356462f, -0.00004746f, -0.04592347f, -0.03265776f, 0.04845199f, 
    -0.03382007f, -0.00354363f, -0.05849124f, 0.01167127f, -0.05744369f, -0.05004692f, 0.00792067f, 0.02485139f, 
    0.02807444f, -0.02334879f, 0.03506120f, -0.01639999f, -0.00283622f, 0.00070534f, -0.05798608f, -0.00817722f, 
    0.03415234f, 0.01187806f, -0.00619277f, 0.02789765f, -0.04988038f, -0.00217226f, 0.00426466f, 0.01843520f, 
    0.03376064f, 0.01518372f, 0.01740301f, -0.01070559f, -0.05672586f, 0.04101106f, 0.02088603f, 0.01253629f, 
    -0.04152336f, 0.03743821f, 0.03963483f, 0.03474190f, 0.00025646f, -0.06179404f, -0.05273534f, -0.01119416f, 
    -0.02990405f, -0.03637992f, -0.02661803f, -0.05141142f, -0.03885870f, -0.01451818f, -0.03226746f, 0.02660236f, 
    -0.03322085f, -0.00834622f, 0.00169844f, -0.02380952f, -0.00130474f, 0.04434487f, 0.00879227f, -0.05588932f, 
    -0.03542239f, -0.01545243f, 0.04283177f, 0.03489705f, 0.03570695f, 0.02101415f, 0.00525782f, 0.00375558f, 
    0.01104893f, -0.03501998f, -0.04391995f, -0.06551506f, 0.02779915f, -0.01091369f, 0.02139139f, -0.00075252f, 
    -0.00902124f, -0.01015843f, -0.02424713f, -0.06981559f, -0.00134676f, 0.01906291f, -0.07009827f, -0.05771884f, 
    -0.05779711f, 0.01565966f, -0.01247724f, 0.02503726f, -0.06759513f, -0.01786121f, -0.00413286f, -0.05433245f, 
    -0.03161163f, -0.04359300f, -0.01634340f, -0.04468920f, 0.02857884f, 0.01719068f, -0.00057923f, -0.01532505f, 
    0.00898727f, 0.00701565f, 0.03215668f, 0.01742299f, -0.03182766f, 0.02637433f, -0.05008564f, 0.02977682f, 
    -0.05636071f, -0.00222312f, 0.04056121f, 0.01713098f, 0.01600257f, -0.04711870f, -0.05752916f, -0.03884435f, 
    -0.03677087f, -0.07126050f, 0.00322791f, -0.05924047f, 0.02337479f, -0.02132823f, 0.04174222f, -0.03889973f, 
    0.01038387f, -0.03394342f, 0.01434809f, -0.07370608f, 0.03693284f, 0.03161381f, -0.00599623f, -0.00897367f, 
    -0.00874497f, 0.04669087f, 0.03213014f, -0.00802334f, 0.03193846f, 0.00588332f, -0.03106012f, -0.03980054f, 
    -0.02071105f, -0.02720687f, 0.03312854f, 0.01895751f, -0.05099004f, -0.01890694f, 0.02489811f, 0.01132738f, 
    0.00179162f, -0.01636701f, -0.01068410f, -0.04095491f, -0.06686248f, -0.02414846f, -0.01924219f, 0.05419151f, 
    -0.05716847f, -0.00634858f, 0.04635284f, 0.04431802f, 0.03740497f, -0.03203400f, -0.01606160f, -0.03375435f, 
    0.05335240f, 0.04836040f, -0.05470724f, -0.00110524f, 0.04600006f, 0.00159593f, 0.00324653f, -0.03128947f, 
    0.03280920f, -0.05040221f, -0.04104226f, 0.02371696f, -0.01737330f, 0.02855672f, -0.03299860f, -0.00791008f, 
    -0.00579465f, -0.00765109f, -0.00190769f, -0.02006955f, -0.04876012f, 0.00716992f, 0.04842770f, 0.00040037f, 
    0.02033794f, -0.01672860f, -0.00568826f, -0.03570182f, 0.04528978f, -0.03605513f, 0.03052647f, 0.00980807f, 
    -0.02249776f, -0.01045824f, -0.04383218f, -0.01371254f, 0.03251350f, -0.06841365f, 0.04367183f, -0.03474553f, 
    0.02652458f, 0.03494235f, 0.02210405f, 0.00129363f, -0.04728017f, -0.04981022f, -0.02868245f, -0.03235965f, 
    -0.05857028f, 0.01292021f, -0.00515296f, 0.01220801f, 0.02245448f, 0.02672543f, 0.01393480f, -0.06270450f, 
    -0.00802908f, -0.01374752f, 0.05147438f, 0.00637748f, 0.04694496f, 0.02994900f, 0.01938920f, -0.00681068f, 
    -0.02989521f, -0.05348687f, 0.04412978f, -0.04805453f, -0.01091983f, 0.02985132f, 0.02827511f, -0.01006663f, 
    0.05001634f, -0.05670163f, -0.02906822f, -0.04650794f, -0.02482825f, 0.03832615f, -0.04380432f, -0.04943570f, 
    -0.00640809f, -0.03922170f, -0.03909012f, 0.02766123f, 0.02200010f, -0.05197976f, -0.04768456f, -0.00734687f, 
    -0.03631853f, -0.02310801f, 0.03752120f, 0.03663367f, 0.01176835f, 0.00290791f, 0.01071556f, -0.01082307f, 
    0.01474346f, -0.01628847f, -0.07099758f, 0.09175754f, -0.00937714f, 0.01021750f, 0.02206769f, -0.13944884f, 
    -0.14346261f, -0.01525176f, 0.05729879f, 0.09965590f, 0.15124322f, -0.00126206f, 0.03334704f, 0.06712044f, 
    0.10065718f, 0.02942587f, -0.05641043f, 0.11512383f, 0.04399807f, 0.04873622f, 0.08138270f, 0.17516452f, 
    0.15234756f, 0.09431937f, -0.04772305f, 0.04862764f, 0.00086132f, -0.07510184f, -0.04601769f, -0.05902009f, 
    -0.02087868f, 0.02784539f, -0.14101084f, -0.01173761f, 0.07924531f, 0.08672520f, 0.01579286f, -0.01523249f, 
    0.06015504f, 0.11622474f, 0.08770446f, -0.18034433f, 0.09394221f, 0.07589984f, 0.20786913f, 0.00234688f, 
    -0.01477654f, -0.08652499f, -0.00670683f, -0.01874144f, -0.02968397f, -0.01648374f, 0.09365793f, -0.30201244f, 
    -0.18229185f, 0.00916978f, -0.00153391f, 0.13538615f, 0.19767377f, -0.04722289f, 0.00870697f, 0.22826156f, 
    -0.05220664f, -0.07134217f, -0.07517470f, -0.16525777f, -0.04609293f, 0.05425017f, 0.08263538f, 0.03061493f, 
    -0.04395314f, 0.10368885f, -0.04350954f, -0.06760997f, -0.04147970f, -0.23275453f, 0.04694998f, 0.06120702f, 
    -0.02012265f, 0.11204123f, -0.02085205f, -0.14464338f, -0.18216093f, 0.08112752f, -0.03300497f, 0.04467295f, 
    -0.10170068f, -0.06325633f, 0.16097544f, 0.06242289f, -0.14165866f, 0.08359373f, -0.15029210f, 0.11547256f, 
    0.04151841f, -0.07271648f, -0.09713700f, 0.22358747f, 0.00342340f, -0.07722604f, 0.08162790f, 0.11367685f, 
    0.06715735f, -0.02403764f, 0.00421384f, 0.11673687f, 0.29946309f, -0.10894155f, -0.06678572f, 0.08493769f, 
    0.00338526f, 0.07240073f, 0.02017765f, 0.11023578f, 0.16186479f, 0.00785037f, 0.08874646f, -0.02194511f, 
    0.14540139f, 0.01558925f, 0.07610080f, -0.11339702f, -0.03563993f, -0.05692356f, 0.10672159f, 0.02825645f, 
    -0.01425800f, -0.09793036f, 0.10374173f, -0.04234949f, -0.09877031f, 0.13978598f, -0.08154164f, -0.04034829f, 
    -0.03681644f, -0.01900958f, 0.05494896f, -0.06258065f, -0.17196213f, -0.01098392f, -0.00832129f, -0.01833738f, 
    0.02620228f, 0.09806910f, -0.00834086f, -0.01723046f, -0.00787268f, -0.17336462f, 0.03249120f, 0.07430059f, 
    0.06946013f, 0.08640310f, 0.02074976f, -0.12842998f, -0.13146251f, -0.02487690f, -0.10809125f, 0.10982610f, 
    0.00186141f, -0.28699404f, -0.07414725f, -0.03847191f, -0.01272449f, 0.06998151f, -0.03848628f, -0.10318282f, 
    0.06915586f, -0.02580212f, -0.02384851f, -0.13010183f, 0.08200783f, -0.00264410f, 0.01152206f, 0.04281424f, 
    0.08453903f, 0.03048573f, -0.02302056f, 0.07018497f, 0.13031359f, -0.10396676f, 0.02783984f, 0.09167209f, 
    0.00794234f, 0.18040496f, 0.01272016f, -0.07527964f, -0.07275666f, 0.13929832f, -0.12709808f, -0.17545685f, 
    0.16882914f, -0.13474433f, -0.02460458f, 0.10164952f, 0.15006399f, -0.07623556f, -0.11039119f, 0.10599171f, 
    -0.00966537f, 0.01345079f, -0.04996052f, 0.09434155f, -0.02070837f, -0.04224709f, 0.04191545f, -0.02479705f, 
    0.00612912f, 0.00199453f, 0.04200812f, 0.05421603f, 0.09322286f, -0.01025310f, -0.03632560f, -0.12641735f, 
    -0.03435395f, 0.01122370f, 0.09157526f, 0.03028188f, -0.04933451f, -0.01792956f, -0.11971458f, -0.02109810f, 
    -0.05873719f, -0.26157415f, 0.09175450f, 0.13945603f, -0.03152568f, 0.19893508f, -0.05888488f, -0.06417731f, 
    -0.05448382f, 0.26123452f, -0.05996346f, 0.01230469f, -0.12805755f, 0.07209960f, 0.10081217f, 0.12108725f, 
    0.03139605f, -0.06868906f, -0.05299958f, 0.20380175f, 0.07565122f, -0.05178592f, -0.02501837f, -0.11255965f, 
    -0.09047259f, 0.08102068f, 0.02116307f, 0.03967684f, 0.06628507f, -0.10306394f, 0.09501939f, 0.12038180f, 
    0.09723447f, 0.01469584f, 0.09671019f, -0.03995053f, -0.02851027f, -0.08313889f, -0.12738962f, -0.05055676f, 
    -0.03000287f, 0.25507778f, -0.03896606f, 0.10337642f, -0.06246097f, -0.03708919f, 0.23920998f, 0.11743385f, 
    -0.02693865f, 0.06902833f, -0.05085865f, 0.02381053f, 0.14257473f, 0.07687374f, 0.16341238f, 0.08865587f, 
    -0.02866668f, -0.18530205f, 0.06819643f, -0.17542937f, -0.10823759f, 0.15041682f, 0.04770316f, 0.11503945f, 
    -0.05148001f, -0.04403585f, 0.01265161f, -0.04015881f, -0.05429419f, 0.00711330f, -0.00809567f, -0.01670372f, 
    0.01471105f, -0.02957085f, 0.00566027f, 0.01688698f, 0.04386869f, -0.03364722f, -0.01164508f, -0.04938526f, 
    -0.03807648f, -0.01775213f, 0.04347434f, -0.00531654f, -0.02890744f, -0.00164400f, 0.03278527f, -0.06220884f, 
    0.02049411f, -0.01944527f, 0.03904037f, 0.03913113f, 0.00985925f, 0.05197565f, -0.03486925f, -0.00404498f, 
    -0.04225677f, 0.01229639f, -0.03977459f, 0.02113192f, -0.05567464f, -0.00244206f, 0.04537528f, 0.03849921f, 
    -0.01428715f, 0.02531593f, 0.03661762f, -0.01981524f, 0.04515342f, 0.01342263f, 0.02025829f, -0.05822159f, 
    0.04303870f, -0.03570603f, -0.00154906f, 0.03999998f, 0.01309594f, -0.06283488f, -0.01094524f, 0.03393400f, 
    0.04763255f, 0.04336423f, -0.01845614f, 0.00403301f, 0.00929102f, -0.03846512f, 0.03791616f, 0.00945427f, 
    -0.00408692f, 0.05077470f, -0.05668631f, -0.05319437f, -0.04606215f, 0.01357873f, -0.05851426f, -0.03696795f, 
    -0.04511504f, -0.01860422f, 0.04123437f, 0.01879775f, -0.04766702f, -0.03240639f, 0.00697164f, -0.02316863f, 
    -0.02498577f, 0.00760474f, -0.04934855f, -0.01662030f, 0.02770026f, -0.03506986f, -0.03167253f, 0.02659684f, 
    -0.01120571f, 0.02704409f, 0.01359581f, -0.00604940f, -0.04516245f, 0.00739417f, 0.00715799f, 0.01016158f, 
    -0.03399473f, -0.06159542f, 0.02383765f, -0.06763250f, 0.02324069f, -0.03013968f, -0.06135005f, -0.02695524f, 
    -0.03464643f, -0.02141754f, -0.01691749f, -0.06357820f, 0.03364770f, -0.06714268f, -0.01054638f, -0.04820340f, 
    0.00801609f, 0.03380983f, -0.02551814f, 0.01853597f, -0.04652090f, -0.01024126f, -0.04452246f, -0.01118376f, 
    -0.05521401f, -0.06154035f, 0.03881006f, -0.03428815f, -0.03191863f, 0.01371447f, -0.04053827f, 0.01325535f, 
    -0.05654224f, -0.05397388f, -0.06145919f, 0.03289765f, -0.03568332f, 0.04496653f, -0.02904275f, 0.00490507f, 
    -0.01898467f, -0.03549158f, 0.00700125f, -0.03197219f, 0.02531270f, 0.04822185f, 0.02645720f, 0.00407393f, 
    0.01043570f, -0.04891452f, 0.03215596f, -0.04082536f, -0.03720486f, 0.04931560f, -0.05555453f, -0.00236115f, 
    -0.06181595f, 0.01287865f, -0.00209155f, -0.01923141f, 0.04687477f, 0.02250365f, -0.01267096f, -0.02975513f, 
    -0.05670756f, -0.02647571f, 0.02846480f, -0.05681779f, 0.00318170f, -0.04845740f, 0.04624973f, -0.01303096f, 
    0.03303048f, -0.05751662f, 0.04844519f, 0.04083925f, -0.05199060f, -0.03676674f, 0.00130101f, 0.04221573f, 
    0.03230952f, -0.01529364f, -0.01421757f, 0.04292724f, -0.06474333f, -0.00042421f, -0.00659731f, -0.01171558f, 
    0.01574323f, 0.00791342f, 0.04786758f, 0.00131557f, 0.00499173f, 0.00972833f, -0.00111554f, -0.00970764f, 
    -0.01589897f, -0.05052486f, 0.05009196f, -0.04475089f, 0.03349470f, -0.05483607f, 0.03538724f, 0.00276722f, 
    0.01354866f, 0.01997190f, 0.00295175f, -0.00718632f, -0.01669989f, -0.01768598f, 0.04211442f, -0.00787549f, 
    -0.04105968f, 0.00616359f, -0.00740984f, 0.01554575f, -0.06655288f, 0.00192372f, -0.01448082f, -0.05181592f, 
    -0.06552291f, -0.00155981f, 0.04227413f, -0.02887311f, 0.03958144f, -0.06249060f, -0.06686612f, -0.06343458f, 
    0.02058387f, 0.04260540f, -0.02649766f, 0.04463608f, -0.05041890f, 0.03163307f, 0.03883751f, 0.03015964f, 
    -0.00400180f, -0.01324102f, 0.04643605f, 0.01445061f, -0.01457277f, -0.03414814f, 0.01743883f, -0.01337328f, 
    0.03782169f, -0.05665355f, -0.01510928f, 0.02130566f, -0.01131900f, -0.03457449f, 0.04639396f, 0.03579991f, 
    0.04061621f, -0.03522969f, 0.02822367f, -0.00281371f, -0.01596883f, -0.00943420f, -0.04462635f, -0.05934735f, 
    0.04414333f, -0.01041413f, 0.02082691f, -0.01161620f, -0.05042707f, -0.00134515f, 0.01654650f, -0.05215804f, 
    -0.03104053f, -0.02971281f, -0.04221210f, -0.04884975f, 0.02940870f, 0.04391886f, 0.00396386f, -0.05183773f, 
    -0.04294553f, -0.01349391f, -0.03914682f, -0.05089422f, -0.04551442f, -0.00940798f, 0.04404471f, -0.02759050f, 
    -0.00622208f, -0.05089499f, -0.04443961f, -0.06502758f, 0.03768479f, -0.01132501f, -0.00820562f, 0.04840382f, 
    0.06765803f, -0.07946417f, -0.04732449f, 0.03048024f, -0.08703601f, -0.12290859f, -0.00573042f, 0.08267616f, 
    -0.11170243f, -0.12925544f, -0.21501163f, 0.03829720f, -0.00941520f, -0.13558175f, 0.14048803f, 0.07489060f, 
    0.00754933f, -0.00880414f, 0.03306530f, 0.11582728f, 0.03497725f, 0.03994396f, 0.11953806f, 0.09995186f, 
    -0.00309920f, 0.06301071f, 0.02176056f, 0.02396522f, 0.00208438f, -0.06873064f, 0.00957911f, 0.03433783f, 
    0.01709682f, 0.01097171f, -0.00908989f, -0.02688381f, 0.13651864f, 0.17578721f, -0.04520271f, -0.07767736f, 
    -0.01346798f, 0.04615673f, 0.00950771f, 0.00759536f, -0.01663031f, 0.28562829f, 0.16666697f, 0.06437949f, 
    0.13182229f, 0.00598772f, 0.00998616f, -0.02748577f, -0.00406763f, 0.03350629f, -0.16935664f, -0.03123930f, 
    -0.18439791f, 0.05044973f, 0.04602940f, 0.02288462f, -0.04690276f, 0.01451912f, 0.08671080f, -0.17899027f, 
    -0.04028722f, 0.06339086f, -0.02840697f, 0.08644229f, -0.07850382f, -0.05448423f, -0.04033898f, 0.19172128f, 
    -0.13281554f, -0.08950763f, -0.23713255f, 0.11124952f, 0.17308696f, 0.08417594f, -0.05202996f, -0.03072011f, 
    0.08134315f, 0.24944101f, 0.08593511f, 0.00042612f, -0.05533556f, -0.10101756f, 0.06871306f, 0.07325210f, 
    0.11282106f, 0.08374316f, 0.02242352f, 0.00675896f, -0.06684814f, 0.04748190f, -0.07962409f, 0.04979007f, 
    -0.02922628f, 0.05672923f, 0.02926360f, 0.00467014f, -0.14799266f, 0.03204816f, 0.01178532f, -0.01293661f, 
    0.00953609f, 0.04512152f, 0.11973775f, 0.09126435f, -0.23927759f, -0.38809130f, 0.00406965f, -0.07162522f, 
    -0.06075781f, -0.01078809f, -0.01062567f, -0.00316275f, 0.10572425f, -0.13582876f, 0.09810928f, -0.06071035f, 
    0.07806483f, 0.08696169f, 0.12689836f, -0.08634415f, -0.07395694f, -0.04155529f, -0.30365604f, -0.27949116f, 
    -0.02886056f, 0.09541288f, 0.04248797f, -0.04363032f, 0.01219116f, -0.03144021f, 0.08624427f, 0.01957669f, 
    0.07127582f, -0.06872344f, 0.02269387f, -0.02583194f, -0.04227491f, 0.11618526f, -0.01640895f, -0.01877190f, 
    -0.43673867f, -0.18278077f, -0.01772926f, 0.05442880f, 0.10746551f, 0.04868168f, 0.14155218f, -0.12349092f, 
    0.09528030f, 0.20236760f, 0.22725280f, 0.09693018f, 0.02072801f, 0.04416707f, 0.06304174f, -0.07169423f, 
    0.15823445f, -0.05064927f, -0.05127341f, 0.04433728f, 0.01672272f, 0.21301951f, 0.15147394f, -0.02455905f, 
    -0.13701802f, -0.02998416f, -0.18026339f, 0.12992036f, 0.07904947f, -0.03154389f, 0.10305121f, -0.02919714f, 
    -0.01005872f, -0.02516988f, -0.01235541f, 0.02843190f, 0.13659424f, 0.08562670f, 0.14244036f, 0.05169878f, 
    -0.03894366f, 0.11028288f, -0.01103202f, -0.10760436f, -0.01451196f, -0.15461099f, 0.05730398f, -0.07810640f, 
    -0.02372647f, -0.05762066f, -0.09598234f, 0.07899838f, 0.03663750f, 0.04764717f, 0.09241410f, 0.05345899f, 
    -0.06871408f, 0.07695816f, 0.17249697f, -0.13432971f, -0.11340059f, 0.18232945f, 0.05032761f, -0.07180408f, 
    -0.00654121f, 0.07742552f, 0.02989452f, -0.06202367f, 0.06322855f, -0.07080264f, 0.11809168f, -0.03211622f, 
    0.07565948f, -0.11301826f, -0.01303675f, -0.13125820f, -0.12476595f, 0.07104263f, 0.02845042f, 0.05153158f, 
    -0.02341697f, -0.18511911f, -0.01577243f, -0.38216400f, 0.01628809f, -0.12245701f, 0.00041327f, -0.07473558f, 
    -0.02283955f, 0.07076566f, 0.12372220f, 0.07229352f, 0.04697471f, 0.12891366f, 0.01139669f, 0.08690660f, 
    -0.07775614f, -0.01715894f, 0.04032807f, -0.06736716f, -0.23212400f, -0.33094186f, 0.08494622f, 0.11497387f, 
    -0.06129140f, 0.08854491f, 0.00728717f, 0.00218503f, -0.13172410f, -0.04093421f, 0.03323868f, 0.07929722f, 
    -0.00656689f, -0.00765747f, 0.13309547f, 0.00001443f, -0.00388364f, 0.14303619f, 0.07734767f, 0.00905619f, 
    0.06234775f, 0.09167960f, 0.08298086f, -0.01573649f, 0.02686031f, 0.02593601f, -0.43063727f, -0.27056363f, 
    -0.13036884f, 0.16724226f, -0.06015778f, 0.08410450f, 0.00309786f, 0.05226698f, -0.06427632f, -0.03674644f, 
    -0.20793547f, -0.13749728f, -0.06144401f, 0.02109021f, 0.09263715f, -0.01567388f, -0.03396553f, 0.02518886f, 
    -0.03554711f, -0.08819264f, 0.24592990f, 0.15215090f, -0.06270500f, -0.07096888f, -0.05312528f, -0.09997866f, 
    -0.07039399f, 0.15490316f, 0.07665634f, 0.07056679f, 0.04038924f, -0.01118042f, 0.10051374f, 0.15491453f, 
    -0.06302325f, 0.09584316f, 0.05105879f, 0.32418376f, -0.02609744f, 0.00573742f, -0.13464814f, 0.14057523f, 
    0.08831626f, 0.00912392f, -0.02037400f, 0.10088754f, 0.19451787f, 0.03760548f, -0.23348393f, -0.11480612f, 
    0.00798925f, -0.07018238f, -0.05640256f, -0.10416546f, 0.05625511f, -0.00647668f, 0.02412321f, 0.02213165f, 
    -0.06179653f, -0.08944514f, 0.09789951f, -0.05734820f, 0.01386442f, -0.00050830f, 0.16342083f, 0.02146387f, 
    -0.04577764f, 0.02495171f, -0.05076803f, 0.03115174f, -0.03879610f, -0.09551896f, -0.22874078f, -0.17823651f, 
    -0.04805006f, -0.03315953f, 0.08500139f, 0.04143231f, -0.06887718f, -0.11063320f, 0.22497080f, 0.09068844f, 
    0.00589375f, 0.11576016f, -0.04735886f, -0.11886095f, -0.11472661f, 0.05723108f, 0.09769595f, 0.07710021f, 
    0.16521341f, 0.00961377f, 0.01370871f, 0.07218932f, -0.10270333f, -0.06837533f, 0.00733402f, -0.06987327f, 
    -0.10603577f, -0.01001242f, 0.01758506f, -0.04905280f, -0.10948216f, 0.05960740f, 0.01255932f, -0.04922952f, 
    -0.00129572f, -0.12257547f, -0.14220984f, -0.00594522f, -0.06524733f, -0.04402589f, -0.07519983f, 0.05156136f, 
    0.08800964f, -0.00939114f, -0.08926995f, -0.12280779f, -0.01317038f, 0.04823273f, 0.14442439f, 0.07987422f, 
    0.01588854f, 0.03987836f, -0.04942341f, -0.00084458f, 0.14061648f, -0.16762409f, 0.07395048f, 0.08803628f, 
    -0.12921460f, -0.08877619f, 0.00543015f, 0.01160199f, 0.10855778f, -0.00097353f, -0.18421945f, -0.05140941f, 
    0.04739200f, 0.01235196f, -0.11150368f, -0.09851938f, -0.04905329f, 0.15079945f, -0.09924680f, 0.03983299f, 
    0.17878479f, 0.04075168f, 0.05718438f, -0.09744798f, -0.11215363f, -0.07314690f, 0.01068719f, -0.13296433f, 
    0.04460334f, 0.05754525f, -0.00563664f, -0.00241206f, -0.17181803f, -0.00783360f, 0.06336846f, 0.03270318f, 
    0.18234056f, 0.00668172f, 0.09974687f, -0.06883510f, 0.04223510f, -0.10401977f, 0.07824966f, 0.04481823f, 
    0.01097691f, 0.09063192f, 0.18965870f, -0.00737165f, -0.05244840f, 0.03932990f, 0.05807887f, 0.05841879f, 
    0.06499543f, -0.21642882f, -0.07496887f, -0.08790338f, -0.22335942f, 0.08687393f, 0.01573881f, 0.05749859f, 
    -0.10672584f, 0.02930351f, -0.03817672f, 0.08361636f, 0.24812774f, -0.09013195f, -0.00878172f, -0.22324777f, 
    0.07728484f, 0.06255311f, -0.01896709f, 0.03527377f, 0.10447254f, -0.25679168f, -0.05200016f, 0.13530885f, 
    0.06500437f, 0.05394339f, 0.04696108f, -0.07930356f, -0.10022102f, -0.19752765f, 0.04745794f, -0.00628539f, 
    -0.01092071f, 0.01259610f, 0.03686507f, 0.02494927f, -0.00910904f, -0.00255779f, -0.13334955f, 0.26212171f, 
    0.06982595f, 0.08623501f, -0.08428442f, -0.08071589f, -0.12548669f, 0.09308277f, -0.00368362f, 0.21170147f, 
    -0.05009159f, -0.21966644f, 0.06775836f, -0.03721238f, 0.06168753f, -0.15444019f, 0.04930019f, -0.04949825f, 
    0.15041785f, 0.04397605f, -0.15759686f, -0.05117605f, -0.00165212f, 0.19583951f, -0.04033222f, -0.07774607f, 
    0.02670568f, -0.45847273f, -0.08330594f, 0.05011736f, -0.01502545f, -0.03205265f, -0.01370861f, -0.03956778f, 
    -0.01608892f, 0.09874120f, 0.13401723f, 0.09800857f, -0.20092835f, 0.02913416f, -0.02574302f, -0.04685647f, 
    -0.03093594f, 0.07122467f, 0.05413369f, 0.06847081f, -0.02929625f, 0.04578716f, -0.00682450f, -0.08240355f, 
    -0.15769087f, 0.01609971f, 0.10654987f, 0.01853443f, 0.30016896f, -0.17876966f, -0.03619854f, 0.13751580f, 
    -0.09125081f, -0.02770434f, -0.01031973f, -0.12181944f, -0.05817952f, 0.06975559f, -0.18190083f, -0.13625540f, 
    -0.08647816f, 0.02358416f, -0.08042488f, 0.01327998f, -0.02224658f, -0.10697293f, 0.01662970f, -0.00450270f, 
    0.09970680f, 0.08920348f, -0.05437012f, -0.00839354f, 0.05223006f, 0.01795870f, 0.13721764f, 0.17267644f, 
    0.06233826f, -0.03974743f, -0.02106138f, -0.12986235f, -0.08682002f, -0.02874696f, -0.11498535f, 0.02268074f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.11118497f, 0.05198669f, 0.07482252f, -0.02852522f, 0.04870747f, -0.07025618f, 0.14442451f, 0.00505174f, 
    0.06635602f, -0.04452302f, 0.11894529f, 0.07196444f, 0.00016373f, 0.03685013f, 0.04029308f, 0.06097454f, 
    0.06415686f, -0.04055576f, -0.01571973f, -0.00536566f, -0.05330535f, 0.02791790f, 0.03536156f, 0.02335085f, 
    -0.01546388f, 0.09587260f, -0.05267252f, -0.03906692f, 0.10099121f, -0.05489303f, 0.04037141f, 0.01126321f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24165903f, -0.14272623f, -0.19403377f, -0.02925690f, 0.17787358f, 0.13644971f, -0.18007718f, -0.06284650f, 
    0.22150056f, 0.04053921f, 0.30185032f, -0.44254780f, 0.14290728f, 0.05181596f, 0.19669157f, 0.37824759f, 
    0.27914223f, 0.14368770f, 0.23969825f, -0.03518183f, 0.02782992f, 0.14496663f, 0.15615168f, 0.04606002f, 
    -0.06238177f, -0.11041242f, 0.03767829f, -0.01100064f, 0.18232444f, -0.13467939f, -0.13668108f, 0.04950140f, 
    -0.26483312f, -0.20959032f, 0.20047301f, 0.12007057f, -0.04617996f, 0.01238111f, -0.15867811f, 0.24018185f, 
    0.18742019f, 0.13583672f, -0.20015579f, 0.14824153f, 0.23382553f, -0.27026302f, 0.13448404f, -0.07120860f, 
    0.20528108f, -0.08190110f, 0.17302015f, -0.20314844f, -0.16897260f, -0.15795806f, 0.03270894f, -0.02770095f, 
    0.10057691f, -0.12090405f, -0.13996665f, 0.01690988f, 0.09787425f, 0.07311612f, -0.13116884f, -0.25476864f, 
    0.47593880f, 0.25035954f, -0.02147433f, 0.04454596f, -0.23283057f, 0.00514153f, 0.37494257f, 0.04401419f, 
    -0.20787622f, 0.43300149f, 0.15455724f, 0.04786556f, -0.01730937f, 0.38975894f, -0.02139476f, 0.05926644f, 
    -0.21732773f, 0.11408071f, 0.00050437f, 0.27941403f, 0.08815657f, 0.00314382f, 0.12584908f, 0.04569996f, 
    0.08920790f, 0.05856844f, 0.24592012f, 0.15538822f, 0.02539888f, -0.00763082f, -0.23492306f, -0.12923139f, 
    -0.12683043f, 0.06912560f, -0.11453173f, 0.06707321f, -0.21627001f, 0.09146320f, -0.19903435f, 0.07840575f, 
    0.09788871f, 0.13806401f, -0.19524492f, -0.06586243f, -0.12493152f, -0.04410738f, 0.06983692f, 0.00905073f, 
    -0.19806671f, 0.00010374f, -0.00662166f, -0.08633666f, 0.00761488f, -0.06070189f, -0.15983039f, 0.06486429f, 
    -0.15465109f, -0.02640797f, -0.12812337f, 0.14812368f, -0.07569137f, -0.08785357f, -0.18676835f, 0.06020344f, 
    0.21935599f, -0.01378592f, 0.27013522f, -0.14551145f, -0.12379008f, 0.03007737f, 0.24098293f, 0.07770286f, 
    -0.20886582f, 0.14875731f, 0.03533924f, -0.33359268f, 0.18057762f, -0.14813809f, -0.29968277f, 0.03210455f, 
    -0.13274115f, 0.03690055f, 0.16214186f, 0.31941009f, -0.04075938f, -0.12886935f, 0.07183921f, -0.10630984f, 
    -0.03800605f, -0.22612500f, -0.21433012f, 0.02396840f, -0.26240227f, 0.09036694f, -0.00776550f, -0.27181080f, 
    0.15883060f, 0.34816653f, -0.19094574f, 0.05774512f, 0.24847105f, 0.16017523f, 0.16675948f, -0.32916945f, 
    0.09225113f, -0.22489581f, -0.11299200f, -0.02334808f, -0.11263467f, 0.00926897f, 0.15794820f, 0.13285750f, 
    0.05559408f, -0.12243278f, -0.20455647f, 0.44584969f, -0.14543986f, 0.17187203f, 0.08408282f, -0.09831306f, 
    -0.03595773f, 0.43271002f, -0.19245216f, 0.06809405f, 0.04305264f, -0.03706547f, 0.16019222f, 0.21886581f, 
    0.23062453f, -0.19829494f, 0.12200806f, 0.00093415f, -0.01090340f, -0.01398697f, -0.10514317f, 0.08930741f, 
    0.29528809f, -0.36764312f, 0.00578677f, 0.00886592f, -0.00329092f, -0.01322129f, 0.16604866f, -0.20330751f, 
    0.14200696f, -0.13963649f, 0.15699355f, 0.05828738f, -0.17269477f, -0.05248462f, 0.05288658f, -0.09111170f, 
    0.07580445f, 0.34785059f, -0.15048075f, 0.14134957f, 0.02607274f, -0.10525862f, 0.27416372f, -0.10942779f, 
    0.26536810f, -0.06750652f, 0.05133212f, -0.00607576f, 0.14795382f, 0.15088433f, -0.22124028f, 0.21843730f, 
    -0.19790944f, 0.37936267f, -0.51504487f, -0.03664647f, -0.01800932f, -0.20725466f, 0.44468465f, -0.25932124f, 
    0.30435106f, -0.10986339f, 0.31991643f, -0.21192127f, -0.07082219f, -0.11783093f, -0.05345150f, -0.00773178f, 
    -0.11663634f, -0.24325535f, 0.42240450f, 0.14935087f, 0.19855995f, -0.01172447f, -0.08396248f, 0.17765275f, 
    -0.18398754f, 0.28274918f, 0.01429592f, -0.16375783f, -0.07527839f, 0.14292820f, 0.32674676f, -0.09396495f, 
    -0.03968399f, 0.00186165f, -0.51969278f, 0.04878848f, -0.00546687f, 0.08205740f, 0.06967297f, 0.16632664f, 
    0.36184394f, 0.13702729f, 0.03834456f, -0.07280859f, -0.01903673f, -0.07425331f, 0.09001352f, 0.14340174f, 
    -0.01689641f, -0.33154950f, 0.07826737f, -0.15232146f, 0.05906948f, -0.16896196f, -0.19140586f, -0.32613051f, 
    -0.39507037f, -0.18230870f, 0.26200363f, 0.16817218f, -0.03150367f, 0.12014757f, -0.29426807f, 0.16866606f, 
    0.20427261f, -0.01215321f, 0.05811203f, 0.00787980f, 0.27319413f, 0.00678644f, 0.09446845f, 0.08565303f, 
    -0.13214168f, -0.07746563f, 0.25106147f, -0.39555737f, 0.06864048f, -0.00309515f, 0.16721928f, -0.12517422f, 
    0.16881648f, -0.20066184f, 0.19482350f, 0.14159751f, -0.02801523f, -0.12449653f, 0.04357634f, -0.15560406f, 
    -0.43321115f, -0.07884116f, 0.05382458f, -0.05446403f, -0.14501040f, -0.01977554f, -0.24563122f, 0.37524596f, 
    0.02726562f, 0.35118747f, 0.23855041f, 0.17439117f, 0.30392864f, -0.03519150f, -0.07498507f, 0.12208968f, 
    -0.30968207f, 0.15105070f, 0.10197052f, -0.33152500f, -0.04983367f, -0.09908273f, -0.09930384f, -0.00217693f, 
    -0.07683231f, -0.23015442f, -0.24279805f, -0.09162023f, 0.29975909f, -0.12008142f, 0.35013548f, 0.00937570f, 
    0.17503670f, 0.02316715f, 0.21816374f, 0.13078378f, -0.24902357f, 0.13171855f, 0.00288484f, 0.11194508f, 
    0.10525466f, -0.25761363f, -0.40591481f, -0.07592814f, 0.18061543f, -0.30149069f, 0.35808828f, 0.13708688f, 
    0.07231763f, 0.16165847f, 0.01731082f, -0.17751500f, 0.14515349f, -0.08331356f, -0.09573054f, -0.11323307f, 
    0.01974825f, 0.36651510f, -0.25909990f, 0.09512234f, -0.01861198f, -0.03610580f, -0.13841063f, -0.01818056f, 
    -0.27233809f, 0.02706498f, 0.04246755f, 0.01836515f, -0.15930846f, -0.06242812f, -0.13801384f, 0.24091063f, 
    0.35652232f, 0.11873063f, -0.02711511f, 0.03975596f, 0.29271710f, -0.07553843f, -0.12095256f, 0.25778607f, 
    0.25937387f, 0.10953107f, 0.18832244f, -0.11320043f, -0.01194099f, -0.06779395f, -0.08568392f, -0.00840912f, 
    -0.15528806f, -0.06563532f, 0.16071662f, 0.08326086f, -0.17927121f, -0.04920322f, -0.32707939f, 0.01375100f, 
    -0.51886278f, -0.02112436f, 0.13997310f, 0.12007252f, -0.17307681f, 0.10642070f, 0.11971252f, 0.01241006f, 
    -0.11246397f, 0.07753213f, -0.15296221f, 0.06431096f, 0.21677813f, 0.15837936f, -0.18330796f, 0.19335577f, 
    0.07796484f, 0.00399769f, 0.28978249f, 0.02676044f, -0.05743693f, -0.16243549f, -0.10541204f, -0.13766839f, 
    0.03527002f, 0.16567269f, -0.08369555f, 0.15889700f, -0.12446108f, -0.07462448f, 0.19054841f, 0.03589530f, 
    0.44775459f, 0.08623150f, 0.24554180f, -0.15777610f, -0.33715436f, 0.04098442f, 0.34007362f, 0.15373477f, 
    0.11971372f, 0.26425308f, -0.06960522f, 0.31901824f, 0.24711388f, 0.25556049f, 0.07829299f, 0.14554299f, 
    -0.11107316f, -0.13358621f, -0.04412905f, -0.05838105f, -0.09468503f, -0.05140226f, 0.09782122f, -0.01757431f, 
    -0.12070856f, -0.29530549f, 0.15603337f, -0.01825349f, -0.25681093f, 0.04061736f, -0.29784808f, -0.32020384f, 
    -0.17998901f, -0.00094689f, -0.09818470f, 0.10963881f, 0.20427440f, -0.09963191f, 0.04097997f, 0.30254611f, 
    0.29802686f, 0.05709881f, 0.44448736f, -0.07518368f, 0.07681216f, -0.00004917f, -0.05757719f, 0.25799635f, 
    0.15332580f, -0.05355713f, -0.36885086f, -0.09182602f, 0.11736766f, 0.04519765f, 0.11540014f, -0.12664834f, 
    -0.11776276f, 0.06987529f, 0.14366189f, -0.15619792f, -0.01963354f, -0.01362586f, 0.02735284f, -0.08187769f, 
    0.05113614f, 0.03369673f, 0.35460097f, -0.07831398f, -0.19344074f, 0.08486938f, 0.05086026f, 0.10573959f, 
    0.09271156f, 0.21459465f, -0.21120508f, 0.04430939f, -0.10489459f, -0.01497638f, 0.32432628f, -0.34153402f, 
    0.17266494f, -0.05424992f, -0.12523355f, -0.28296345f, 0.05738579f, 0.06449777f, -0.12181583f, -0.11531775f, 
    0.03276870f, -0.30840981f, 0.27873355f, -0.14630881f, 0.18864720f, 0.11531002f, -0.16720828f, -0.20969529f, 
    0.03754864f, -0.18880725f, 0.09235254f, -0.00592860f, 0.32980037f, 0.07768337f, -0.16232368f, 0.15283500f, 
    0.20520502f, -0.33443886f, -0.22031739f, -0.03632925f, 0.30565435f, -0.25994751f, 0.10434734f, 0.06831670f, 
    0.37520674f, -0.11108270f, 0.38577890f, -0.05314951f, 0.01552361f, -0.07851955f, 0.11491488f, -0.12648302f, 
    -0.09259509f, 0.19464074f, 0.09516817f, 0.11244227f, -0.14852172f, 0.08611134f, 0.10709856f, 0.19320026f, 
    0.20925154f, 0.04530808f, 0.18547645f, 0.06687381f, -0.36063102f, 0.02127862f, 0.26165536f, 0.17116573f, 
    -0.31125188f, -0.01905727f, 0.32896161f, 0.18617213f, 0.02852033f, 0.33500168f, -0.22946882f, 0.08067541f, 
    -0.06964994f, -0.04546278f, -0.09353458f, 0.14378393f, 0.12440942f, 0.07416243f, 0.16279410f, -0.10001633f, 
    -0.15258525f, 0.03836832f, 0.20452516f, -0.08133268f, 0.08306352f, 0.08584307f, 0.21517220f, -0.13282973f, 
    -0.22386101f, 0.23017706f, 0.02052114f, 0.05959151f, 0.20927916f, 0.11352629f, -0.32909548f, 0.01231824f, 
    0.26641271f, 0.31790569f, -0.40392962f, -0.01772247f, -0.05881896f, -0.20762838f, 0.24940132f, 0.23870361f, 
    -0.19360670f, 0.04460976f, 0.00344025f, -0.23970187f, 0.00627672f, 0.01018704f, 0.16828479f, -0.03224733f, 
    -0.12782632f, -0.28312758f, -0.22103858f, 0.13383269f, 0.09446441f, 0.01335241f, 0.31795728f, -0.16971207f, 
    -0.44984964f, 0.26002795f, 0.11936241f, 0.09672127f, -0.10601543f, -0.06876511f, -0.21213177f, -0.09110981f, 
    0.07732148f, -0.04767762f, 0.23643610f, -0.22119480f, -0.03540683f, -0.33031827f, -0.06665120f, 0.29697803f, 
    -0.17555121f, -0.06585698f, 0.35287011f, -0.08676974f, -0.01281791f, 0.02799281f, -0.16152209f, -0.04621081f, 
    0.11661798f, 0.14711487f, -0.03225894f, -0.14205183f, 0.12003486f, 0.16717522f, 0.08938444f, 0.32953265f, 
    0.18078622f, 0.08842088f, -0.25006548f, -0.01439627f, 0.19057372f, -0.15153736f, -0.08946573f, -0.13965182f, 
    0.29251593f, 0.07736520f, -0.00925574f, -0.28591377f, -0.07611316f, -0.00082427f, 0.32348174f, 0.16866286f, 
    0.20440882f, 0.16697763f, 0.06221442f, -0.13864356f, -0.16960783f, -0.12042050f, 0.05434101f, 0.14456782f, 
    -0.16272332f, -0.05237526f, 0.19125244f, 0.13489696f, -0.07833654f, -0.11138927f, 0.17780133f, 0.17108032f, 
    0.12793116f, 0.05011154f, -0.09242579f, 0.04900059f, -0.08706569f, -0.13244735f, 0.29880118f, -0.27959886f, 
    0.08753570f, -0.33832157f, -0.30545059f, 0.04853931f, 0.08688337f, 0.03046048f, 0.17421496f, -0.05939832f, 
    -0.06068846f, -0.15719007f, 0.10342456f, 0.34469089f, 0.04897073f, 0.06976249f, -0.07767208f, 0.06117463f, 
    0.08212201f, 0.51113516f, -0.26983237f, 0.10999574f, 0.11720181f, -0.12848663f, 0.28961548f, 0.21755975f, 
    0.10565576f, -0.13474350f, -0.05247196f, 0.14671567f, 0.05228708f, -0.02399321f, -0.14460301f, -0.06129289f, 
    -0.02311281f, 0.07465451f, 0.02917484f, -0.03572445f, -0.07943209f, -0.11530806f, -0.11092725f, 0.09243698f, 
    -0.09979549f, 0.02410964f, -0.08321498f, -0.11131996f, -0.12212199f, -0.11333947f, 0.11722684f, -0.02465156f, 
    -0.05437047f, 0.11545156f, -0.01849760f, 0.04807845f, -0.11988967f, 0.07877627f, -0.06700870f, 0.12672986f, 
    -0.25107101f, 0.27439791f, -0.20257638f, 0.12124836f, 0.25885099f, 0.12214676f, -0.03934581f, -0.13488126f, 
    -0.15450878f, -0.08803201f, 0.11349478f, -0.16189957f, -0.21252216f, -0.13378839f, 0.15481196f, 0.03651644f, 
    0.09882155f, 0.13170262f, 0.03914025f, 0.10865021f, -0.06582429f, -0.05435453f, -0.05667386f, 0.06141049f, 
    0.11443668f, 0.26270843f, -0.03107530f, 0.10826798f, 0.24965921f, -0.17678536f, 0.27782407f, 0.35624674f, 
    0.20049712f, 0.13493268f, 0.07492106f, -0.07926276f, -0.22657131f, 0.03910389f, 0.18424959f, 0.29202050f, 
    -0.11533378f, 0.50493830f, -0.34833291f, -0.00785330f, -0.10326657f, 0.32438108f, 0.18374375f, 0.07415266f, 
    0.33272478f, 0.16636463f, 0.06509744f, -0.11546557f, -0.08689912f, 0.11307160f, 0.11245545f, -0.08597256f, 
    -0.06369922f, -0.11909757f, 0.22994526f, 0.13182926f, -0.01652575f, -0.04927116f, -0.36845118f, -0.20710884f, 
    -0.04558357f, -0.06736185f, 0.39489338f, -0.04165936f, -0.27377298f, -0.13785201f, 0.10383334f, 0.32085451f, 
    0.16958536f, -0.21123646f, -0.07858510f, -0.13495381f, -0.10862811f, -0.05103954f, 0.21938944f, -0.16651736f, 
    0.36834458f, -0.00271782f, 0.02623374f, -0.29029834f, -0.09804678f, 0.16612063f, 0.10229100f, 0.13121855f, 
    -0.13021100f, -0.25400403f, 0.12174185f, 0.11783360f, -0.18277588f, -0.02223869f, -0.11667838f, -0.19536941f, 
    0.21225737f, 0.02182638f, 0.07150733f, -0.07613906f, -0.44617584f, -0.11049329f, 0.31444651f, 0.09162715f, 
    -0.21887565f, 0.08962382f, -0.27849770f, 0.24296761f, 0.19081847f, 0.31956682f, 0.06883469f, 0.31424201f, 
    0.16687091f, -0.01138881f, 0.27408049f, 0.18467829f, 0.07519694f, 0.06857022f, 0.08904314f, 0.00806991f, 
    0.04202167f, 0.11819660f, -0.29316208f, -0.03968186f, -0.29816273f, 0.08655453f, 0.07383231f, -0.21639273f, 
    -0.14087521f, -0.01896121f, -0.05566847f, -0.14710291f, -0.08487262f, 0.15054050f, 0.36093739f, 0.26264220f, 
    -0.11145089f, 0.16642600f, -0.09090944f, 0.38195688f, 0.16591866f, 0.23286358f, -0.26640078f, 0.02655274f, 
    0.19629943f, -0.06246409f, -0.13253029f, 0.13783254f, 0.11464293f, 0.15077634f, -0.12411761f, 0.03155711f, 
    -0.07355870f, 0.04597524f, 0.10848517f, 0.11597938f, -0.16887492f, 0.11188263f, 0.14284201f, -0.30710852f, 
    0.46230674f, -0.27316368f, 0.13756283f, -0.11195914f, -0.10856134f, 0.17507492f, -0.01374990f, 0.02114587f, 
    0.29063141f, -0.34340584f, 0.18543085f, 0.30800915f, 0.32863989f, 0.00105811f, -0.22618163f, -0.18645966f, 
    0.00176983f, 0.11129925f, 0.00140890f, 0.11415644f, -0.08496982f, 0.06985368f, -0.07679739f, 0.03395129f, 
    -0.10720146f, 0.42080542f, -0.11186498f, -0.16675045f, 0.11595975f, 0.16151841f, 0.28492388f, -0.18120052f, 
    -0.44679153f, -0.01526846f, 0.33637071f, -0.09379039f, -0.29490721f, 0.01176444f, -0.06234516f, -0.03026591f, 
    0.23695210f, -0.23115611f, -0.03779255f, -0.10770158f, 0.27653405f, -0.45687762f, 0.19365487f, 0.10574581f, 
    0.23512205f, 0.10948461f, 0.27994525f, -0.17068344f, 0.08098549f, 0.11174608f, 0.03988840f, -0.17265114f, 
    0.04709017f, -0.04255097f, -0.13988110f, 0.11308445f, -0.11661959f, -0.13856328f, -0.14233719f, 0.13571903f, 
    -0.21670783f, 0.26192242f, -0.06783448f, -0.10180843f, 0.30691260f, 0.00931515f, -0.05289307f, 0.03859973f, 
    0.06772798f, 0.24957518f, 0.09557628f, -0.19429128f, -0.15234940f, 0.17939022f, 0.17309339f, 0.26894608f, 
    0.36189216f, 0.01316189f, -0.27184251f, -0.03036510f, 0.12451424f, -0.04678222f, -0.16399224f, -0.17443952f, 
    -0.16471663f, -0.25196409f, -0.15741445f, -0.13890685f, 0.05961510f, 0.10088830f, -0.23189323f, -0.21909803f, 
    0.23094225f, 0.17532577f, 0.03065979f, -0.05178115f, -0.05373266f, -0.09628645f, 0.22078879f, -0.12388945f, 
    -0.07383808f, 0.27179864f, 0.34852344f, 0.00230917f, -0.20998569f, 0.14346084f, 0.05963756f, 0.10626462f, 
    -0.08837363f, 0.16113418f, -0.05293723f, 0.05474508f, -0.01123679f, 0.15885754f, -0.11653113f, -0.02449335f, 
    -0.06617202f, 0.11733089f, 0.29365042f, 0.11034265f, 0.16748489f, 0.17592353f, -0.36663482f, 0.33301315f, 
    -0.08699340f, 0.11595853f, 0.31818527f, -0.03309866f, -0.00498052f, 0.09263901f, 0.32617837f, 0.08808269f, 
    0.06259898f, -0.07205096f, -0.20341013f, 0.22536084f, 0.02071839f, 0.11894140f, 0.09850004f, 0.14293833f, 
    -0.14220701f, -0.10150198f, -0.34872678f, -0.14611480f, 0.02416033f, 0.01568001f, 0.15076573f, -0.17224833f, 
    -0.10535862f, -0.14064042f, -0.25163376f, 0.13389041f, 0.02240058f, 0.07355284f, -0.14432037f, -0.20258288f, 
    -0.14845835f, -0.09200176f, -0.10151203f, -0.08722223f, 0.01450931f, 0.01466261f, 0.09307040f, -0.02216190f, 
    -0.08917679f, -0.03561731f, -0.07433736f, -0.14408922f, -0.18138477f, 0.04791821f, 0.13753216f, 0.04524427f, 
    -0.17464465f, 0.10934854f, -0.16117054f, 0.05516141f, -0.03031176f, -0.15981740f, -0.10345232f, -0.12861562f, 
    -0.08147550f, -0.05501877f, 0.11132968f, -0.03276382f, -0.13298172f, -0.16374613f, -0.00594775f, -0.17884043f, 
    0.23293898f, -0.10369137f, 0.11036705f, 0.04589051f, -0.09909411f, 0.14032364f, -0.32124594f, -0.02386277f, 
    0.28420120f, -0.38035187f, 0.32610834f, 0.10521249f, 0.34127906f, -0.04928369f, -0.19607352f, -0.07491177f, 
    -0.24080198f, -0.10627628f, 0.12943816f, -0.02821034f, -0.03097497f, 0.17016613f, 0.15677013f, -0.03188198f, 
    -0.10864966f, 0.42098916f, -0.20129041f, 0.06634291f, 0.20255524f, 0.12727514f, 0.11153659f, 0.06075382f, 
    -0.08498815f, -0.14593305f, -0.05876930f, -0.11643014f, 0.01346187f, -0.06992766f, -0.13428934f, 0.02239392f, 
    -0.11553471f, -0.06201151f, 0.09010640f, 0.14284159f, -0.13176441f, 0.02959147f, 0.05533378f, 0.01898012f, 
    -0.11843406f, -0.05924352f, -0.08982080f, 0.13326156f, -0.05710297f, -0.03577083f, 0.11156723f, 0.08509246f, 
    -0.07081801f, -0.06538931f, 0.13307695f, 0.15740356f, -0.18362708f, 0.08340440f, 0.04929573f, -0.04077536f, 
    -0.02318040f, 0.33095855f, 0.01453740f, -0.15997486f, -0.21416795f, 0.00181801f, 0.47557399f, -0.10725840f, 
    -0.11910230f, 0.09523023f, -0.51653880f, 0.14509684f, 0.09482773f, -0.08545619f, -0.04145955f, 0.04971368f, 
    0.39970461f, 0.16006652f, -0.14041167f, 0.05614787f, 0.16756096f, -0.12758607f, 0.03769973f, 0.14035794f, 
    0.09451313f, 0.24970227f, -0.13288133f, 0.10220824f, -0.08120567f, -0.07236537f, -0.23395364f, 0.04650545f, 
    0.03784944f, -0.17462741f, 0.05793163f, -0.07629351f, -0.01534057f, 0.03820140f, -0.12702933f, 0.01595779f, 
    0.00964274f, -0.13924642f, -0.06241827f, -0.15924078f, -0.12315819f, 0.07351558f, -0.01045106f, -0.16908357f, 
    -0.12211496f, -0.01477858f, -0.03059380f, -0.16898982f, 0.16299114f, -0.06925964f, 0.16018310f, -0.09641913f, 
    -0.07603487f, 0.06656975f, -0.00191676f, -0.09683904f, -0.17611058f, 0.08685979f, -0.01712587f, 0.07234668f, 
    -0.16530852f, 0.34007931f, -0.05857198f, -0.11737225f, 0.15633380f, 0.17301030f, 0.07017987f, -0.15592217f, 
    0.19482778f, 0.27937651f, -0.29861671f, -0.17331898f, -0.22793065f, 0.07919709f, 0.27851200f, -0.14200081f, 
    0.29074943f, 0.09946302f, -0.30811915f, 0.12526900f, 0.15776519f, 0.12515286f, -0.13422289f, -0.10109202f, 
    0.11438219f, -0.11543697f, -0.05086038f, -0.01919571f, 0.09274640f, 0.00840701f, -0.10611203f, -0.09391662f, 
    0.08449107f, -0.09206825f, 0.10297474f, 0.16175576f, 0.10306258f, 0.00291255f, -0.04027466f, -0.15267776f, 
    0.28623968f, -0.39091378f, 0.37108794f, 0.03117911f, 0.19930840f, -0.29756081f, 0.04665674f, -0.01548279f, 
    -0.27358705f, -0.00484907f, 0.13026856f, -0.14614229f, 0.05870226f, -0.02873624f, 0.16817565f, 0.13854152f, 
    -0.16697814f, 0.36317244f, -0.17096560f, 0.02465237f, 0.27044603f, 0.12780948f, 0.29315647f, 0.07646977f, 
    -0.09063388f, -0.03453943f, 0.31329668f, 0.03001758f, -0.36020264f, -0.15860249f, 0.13057010f, 0.09698774f, 
    -0.00679490f, -0.18644106f, 0.12232506f, -0.05962503f, 0.12490617f, -0.30639920f, 0.01844255f, 0.31760347f, 
    0.08395793f, 0.03180664f, 0.28129748f, -0.02917029f, 0.11996596f, -0.00669863f, -0.03385746f, -0.04206036f, 
    -0.04081888f, 0.02342591f, -0.03660693f, -0.06523628f, -0.24344264f, 0.00412002f, -0.14773722f, 0.07840908f, 
    0.35880882f, -0.21555823f, -0.09787390f, 0.07718926f, 0.20442802f, -0.13334116f, -0.21175547f, 0.06295460f, 
    0.11847425f, -0.10829026f, -0.18322268f, 0.33204177f, 0.37767750f, -0.06767876f, -0.08706539f, -0.08654048f, 
    0.31414402f, 0.07449706f, 0.23575190f, 0.07221516f, 0.04439556f, -0.08414312f, -0.05508868f, 0.02158856f, 
    0.01588693f, 0.15362920f, -0.09302098f, -0.12003924f, 0.01631377f, 0.13290475f, 0.27936497f, -0.09256987f, 
    -0.19084215f, 0.24332070f, -0.07317517f, -0.00540215f, -0.05561103f, -0.11888798f, -0.05574577f, 0.15526292f, 
    0.43094364f, -0.16123898f, -0.12177681f, 0.09021442f, 0.03680034f, -0.15982094f, -0.03551393f, 0.17342153f, 
    -0.30311090f, -0.01730735f, 0.07886019f, 0.12913133f, 0.17560916f, -0.15818357f, -0.16669728f, -0.08638629f, 
    -0.14127176f, -0.10618130f, -0.36970663f, -0.16535895f, 0.06679620f, 0.05036911f, 0.24519300f, -0.23027386f, 
    0.16488871f, -0.11788123f, -0.26208535f, -0.07794239f, 0.30218261f, -0.16116098f, -0.07599968f, 0.06555152f, 
    -0.13826965f, 0.13860406f, -0.24876274f, 0.15705502f, -0.20405537f, 0.18613923f, 0.07521530f, 0.14884084f, 
    0.31615871f, 0.16854168f, 0.24729466f, 0.19140269f, -0.15398858f, 0.02442128f, 0.15831837f, -0.01528136f, 
    -0.01188966f, -0.05145075f, 0.18327400f, -0.08629636f, 0.09505687f, 0.06521787f, 0.22537361f, 0.32043678f, 
    0.25126678f, 0.10406028f, 0.00507571f, 0.18001336f, -0.03580372f, 0.02173427f, 0.06092672f, -0.29934853f, 
    -0.27866229f, 0.29985315f, 0.34259203f, 0.00318417f, 0.03144411f, -0.06747444f, 0.04890838f, 0.09028868f, 
    -0.17658766f, 0.00834717f, -0.16456082f, -0.08070482f, -0.09883804f, 0.12814303f, 0.07250763f, 0.11842217f, 
    -0.16291016f, 0.01936042f, 0.09462104f, -0.00837986f, 0.35654292f, 0.06191845f, 0.28546953f, 0.49521706f, 
    0.12159096f, 0.11905524f, 0.13530435f, -0.12204707f, -0.09071068f, -0.17576939f, 0.25608340f, -0.16376927f, 
    -0.19823714f, -0.28842264f, 0.02279880f, 0.11709446f, -0.23705973f, 0.01940079f, 0.38837934f, -0.04878997f, 
    0.08859851f, -0.03735239f, -0.19172905f, 0.07187377f, 0.11106821f, -0.05254381f, 0.06480973f, 0.08120060f, 
    0.01997316f, -0.03548972f, -0.09478182f, 0.10210415f, 0.03542152f, -0.07656188f, 0.32964113f, -0.01623519f, 
    0.05798677f, 0.19578190f, -0.06832207f, -0.06618503f, 0.34391588f, 0.14774176f, -0.19424184f, -0.31651351f, 
    0.12409251f, 0.01593543f, 0.14185666f, -0.33434913f, -0.14333770f, -0.23623489f, 0.19330609f, -0.12652861f, 
    -0.17194408f, -0.02483360f, 0.12757279f, 0.02905309f, 0.16461979f, -0.10802857f, -0.15069777f, 0.01855144f, 
    0.01853271f, 0.35394797f, 0.08433455f, 0.10295074f, 0.22340681f, -0.02797033f, 0.22303395f, 0.48890084f, 
    -0.18412527f, 0.23987406f, 0.14390095f, 0.02880594f, -0.38267204f, 0.11500981f, -0.09975071f, -0.14609188f, 
    -0.16822986f, 0.21602197f, 0.40579841f, -0.08164103f, 0.06857005f, 0.08028426f, 0.25736022f, 0.24552733f, 
    -0.07448632f, -0.14476606f, -0.29315597f, -0.23617317f, 0.11653240f, -0.16144297f, -0.02660747f, 0.11608066f, 
    0.00205733f, -0.25255549f, 0.03571253f, 0.04473143f, 0.13932849f, -0.02254904f, -0.15871541f, -0.01613586f, 
    -0.18099028f, 0.32000697f, 0.18015702f, -0.07887723f, -0.03812860f, -0.08570827f, 0.09822859f, -0.17756836f, 
    -0.19305499f, 0.31160378f, 0.08948604f, -0.26536047f, -0.26394808f, -0.25026530f, 0.24024332f, -0.05896204f, 
    0.11265469f, 0.02849824f, -0.20442313f, -0.11382120f, 0.05513838f, 0.16364565f, 0.14719214f, -0.13729316f, 
    -0.11226078f, -0.13570593f, -0.19687654f, -0.03930875f, 0.31780100f, -0.02861210f, 0.18926930f, 0.08446363f, 
    -0.37940106f, 0.12601581f, 0.22191456f, -0.10517914f, -0.25177979f, -0.11651757f, -0.15927359f, 0.15704904f, 
    -0.16089924f, 0.06749515f, -0.43120244f, 0.32927057f, 0.23121345f, -0.19099085f, 0.10342830f, 0.04335063f, 
    0.16752718f, 0.11494583f, 0.38653469f, 0.18593183f, 0.01303878f, 0.00586829f, -0.06606431f, -0.13798326f, 
    0.07415286f, -0.03118118f, -0.18132596f, 0.17375784f, 0.02989698f, -0.05335413f, 0.27304900f, -0.13617767f, 
    0.35470822f, -0.23338963f, 0.10730249f, 0.17076726f, 0.25547519f, -0.06505356f, -0.28573358f, 0.15423128f, 
    0.16508296f, 0.15707888f, 0.43909761f, 0.24847570f, 0.28395334f, 0.12557794f, -0.19870056f, -0.11297856f, 
    -0.32951257f, 0.05149729f, -0.08549254f, -0.17901020f, -0.09926142f, 0.02932056f, 0.06473427f, -0.16936924f, 
    -0.05563024f, 0.43820551f, 0.29229340f, -0.15171137f, 0.08852230f, -0.15375417f, 0.13067847f, 0.28242949f, 
    -0.36455494f, 0.26251882f, -0.09162514f, 0.02526867f, -0.19335930f, -0.01762769f, 0.11985952f, 0.22650808f, 
    -0.00904936f, 0.04459210f, -0.25789165f, 0.03732215f, -0.10513657f, 0.02141394f, 0.12526393f, 0.30453426f, 
    0.20610048f, 0.03243081f, -0.26234534f, 0.01572967f, 0.11964955f, 0.02294874f, -0.18015672f, 0.00180905f, 
    0.01303422f, -0.05010595f, -0.36543426f, 0.12174713f, 0.13620628f, 0.12215532f, 0.35108566f, -0.02787569f, 
    -0.35862109f, 0.18395206f, 0.26649243f, 0.07026815f, 0.02063039f, 0.14463404f, 0.12419641f, 0.28954741f, 
    -0.28767282f, 0.27852574f, -0.19249690f, 0.26872733f, -0.20857799f, 0.04643790f, -0.07086433f, -0.02736367f, 
    0.40738854f, -0.01147836f, -0.23424986f, 0.05670064f, 0.04650814f, 0.03265563f, -0.11597722f, -0.05283906f, 
    -0.15960920f, -0.20532079f, 0.00175600f, -0.07550694f, 0.08753708f, 0.00889050f, 0.22176035f, 0.12706318f, 
    0.03956516f, -0.08001719f, -0.09907538f, 0.17196126f, -0.02133681f, -0.10488648f, 0.00179075f, -0.08169224f, 
    -0.03048152f, -0.18510661f, -0.14239219f, -0.09070577f, -0.10188630f, -0.07867571f, 0.13172030f, -0.10250324f, 
    -0.05203100f, -0.08742643f, -0.14721744f, 0.12858737f, 0.14608413f, 0.17241634f, 0.05571062f, 0.07194781f, 
    -0.15117942f, -0.09535143f, -0.06748232f, -0.17602016f, 0.11106965f, -0.14274697f, 0.05119743f, -0.05437172f, 
    -0.12094161f, 0.02479823f, -0.00015315f, -0.01989211f, 0.14985503f, 0.13586670f, -0.13525854f, 0.08449622f, 
    0.23660627f, 0.21212210f, 0.45943967f, 0.07057035f, 0.04081152f, 0.24552013f, -0.21461649f, -0.08001844f, 
    -0.43672007f, -0.09889853f, -0.02509176f, -0.48607937f, 0.00219501f, 0.17612675f, 0.08429947f, -0.08124369f, 
    0.04157085f, 0.10812701f, -0.12986498f, 0.02523884f, 0.21676767f, -0.00389829f, 0.14826840f, 0.08378377f, 
    0.17059399f, 0.13053575f, 0.08422140f, 0.17225856f, -0.01932348f, 0.07253365f, -0.02287164f, -0.00446425f, 
    -0.12882769f, 0.27463561f, 0.13614960f, -0.03570150f, -0.11213133f, 0.08890251f, 0.13906366f, -0.17022106f, 
    0.09183414f, 0.04546560f, -0.26116279f, -0.02552368f, 0.13288267f, -0.06612188f, 0.02431257f, 0.13234279f, 
    0.16898322f, 0.23867850f, 0.47846434f, 0.09699658f, 0.32504153f, 0.15610741f, -0.05927494f, 0.37074396f, 
    -0.48459932f, 0.30714971f, 0.17903091f, -0.17102376f, -0.22953019f, -0.07593834f, -0.08972076f, 0.00601601f, 
    0.31512883f, -0.06392276f, -0.38608742f, -0.14629875f, -0.00237598f, -0.19033116f, 0.17281604f, 0.33093998f, 
    -0.22246021f, 0.08028570f, 0.14572676f, 0.07952631f, 0.12810814f, 0.00722312f, -0.04056452f, -0.07172980f, 
    0.11125129f, -0.13521247f, -0.42467189f, -0.16746071f, 0.14086673f, 0.15079254f, 0.08590488f, -0.34744617f, 
    0.27287403f, -0.10105707f, 0.14756760f, 0.09943217f, -0.00077024f, -0.13911401f, 0.18676558f, 0.23066287f, 
    -0.11998240f, -0.18505415f, -0.04479257f, 0.21348315f, -0.00823422f, 0.04851634f, -0.21989988f, 0.14891788f, 
    -0.05206376f, 0.16237965f, 0.18720795f, 0.40392226f, 0.08556670f, 0.03597202f, 0.05447728f, 0.12539701f, 
    0.10970213f, -0.06350834f, -0.01666182f, -0.16220120f, -0.38245231f, -0.12594207f, 0.23334883f, -0.10338345f, 
    -0.09301623f, -0.08570809f, -0.07056422f, 0.10902284f, 0.04767442f, 0.00408587f, -0.01985286f, 0.02104343f, 
    0.10331372f, -0.04518161f, -0.11798914f, -0.04457648f, -0.16215339f, -0.12852304f, 0.00604248f, -0.17824750f, 
    -0.08000170f, -0.11281384f, -0.02398285f, 0.04160846f, -0.15548569f, 0.10771622f, -0.10406009f, 0.12618457f, 
    0.11017391f, -0.02261341f, 0.03678543f, 0.05821261f, -0.06017102f, -0.05830549f, -0.12311585f, 0.09037514f, 
    0.30679917f, -0.13660651f, 0.22244547f, -0.00561121f, 0.04375419f, -0.08440416f, 0.06867159f, 0.09827664f, 
    0.07626028f, -0.29696152f, -0.05169348f, -0.01513780f, 0.01137512f, -0.12510268f, -0.18774405f, -0.32691336f, 
    0.30040196f, -0.15601537f, 0.15500997f, -0.11899243f, -0.16493826f, 0.05212574f, -0.00962279f, -0.01675415f, 
    0.03843754f, 0.28351891f, 0.39718929f, 0.03743695f, -0.04144252f, -0.04467627f, 0.29637849f, 0.08313828f, 
    0.25730968f, 0.06527180f, 0.03698449f, -0.03731920f, -0.19871044f, 0.14631657f, 0.39867875f, 0.13562672f, 
    0.29682794f, -0.07123034f, 0.04783111f, 0.12440726f, -0.05777506f, 0.03143790f, 0.25470689f, 0.09921198f, 
    0.03794140f, -0.05158728f, -0.36141229f, 0.04009480f, -0.12744069f, 0.04482054f, 0.02649326f, -0.10365410f, 
    -0.08617410f, -0.28744575f, -0.16850241f, -0.06749492f, 0.22447301f, -0.12576674f, -0.04728412f, -0.25498456f, 
    -0.33223462f, 0.18483366f, 0.19349279f, 0.15090939f, -0.05824246f, 0.11127740f, 0.06216661f, -0.05137395f, 
    0.08005378f, -0.19479950f, -0.21270742f, -0.18987805f, -0.12099217f, -0.16974041f, 0.10865251f, -0.28329948f, 
    0.06361522f, -0.15783992f, 0.10403968f, -0.00210940f, -0.01631129f, 0.16463538f, -0.17879738f, 0.14785105f, 
    0.03450416f, 0.40895921f, 0.12838201f, -0.13306670f, 0.17155692f, -0.10695950f, 0.19338539f, 0.26309204f, 
    -0.19524339f, 0.02926586f, 0.05656315f, 0.13431831f, 0.32221344f, 0.04413591f, -0.01050249f, -0.09324443f, 
    0.06963556f, 0.46940467f, -0.15014407f, -0.17752801f, -0.19600070f, -0.20261112f, 0.32565340f, -0.09474914f, 
    0.09410869f, -0.10726082f, 0.29050753f, -0.03787860f, -0.16650723f, 0.09638238f, -0.04321223f, 0.10726992f, 
    -0.14271571f, -0.18979785f, 0.26681888f, -0.12767072f, 0.19083291f, -0.11886047f, -0.17910491f, 0.13112794f, 
    -0.10393119f, 0.31587139f, -0.02596841f, 0.02251999f, -0.10713600f, 0.06031867f, 0.02823830f, -0.11445538f, 
    -0.18609765f, 0.36958030f, -0.39086369f, -0.11319046f, -0.08215643f, 0.12094148f, 0.08075830f, 0.22142501f, 
    0.29190165f, -0.08944006f, 0.24946491f, 0.07447288f, 0.14005925f, 0.04713010f, -0.12123115f, -0.13978818f, 
    -0.00744316f, 0.05047289f, -0.12438247f, -0.13719453f, -0.11207289f, 0.08009022f, -0.14909503f, 0.29360384f, 
    0.29375613f, 0.29270509f, -0.01977099f, 0.03490834f, -0.17627674f, -0.06665682f, 0.28808948f, -0.17162861f, 
    -0.15209498f, -0.23658736f, 0.17493060f, -0.03363566f, -0.05034094f, -0.10307403f, 0.37241444f, -0.04690733f, 
    -0.27381974f, 0.03024536f, -0.07866413f, 0.27577525f, -0.12240058f, 0.07359648f, 0.04246592f, 0.03844926f, 
    -0.04710059f, -0.05975145f, -0.22017832f, -0.04103212f, 0.07512955f, -0.14540996f, 0.25792262f, 0.26261821f, 
    0.12342322f, -0.15293132f, -0.12103771f, -0.02155435f, 0.10540710f, 0.17944756f, -0.00947665f, 0.16075723f, 
    0.36793539f, -0.33784673f, 0.41455486f, -0.12862574f, 0.34493458f, -0.12167992f, 0.20288259f, 0.34557912f, 
    0.18396488f, -0.08483682f, 0.15553507f, -0.11271677f, 0.06274682f, -0.06689192f, 0.02916767f, 0.04394465f, 
    -0.07380859f, 0.12399919f, 0.16794598f, -0.04357267f, -0.24726795f, -0.07477425f, 0.00137859f, -0.24080828f, 
    0.05432824f, -0.25174162f, 0.18769322f, -0.06704393f, 0.08054710f, -0.15610093f, -0.09585019f, 0.28295121f, 
    -0.08620270f, -0.14088751f, 0.18504803f, -0.08930101f, 0.28556454f, 0.12873176f, -0.39669934f, 0.35223511f, 
    -0.02402924f, -0.08462458f, 0.03166722f, 0.11507215f, -0.08232450f, -0.00420335f, 0.14821360f, 0.13209118f, 
    0.06565904f, -0.02292475f, 0.30646327f, -0.11952463f, 0.10086310f, 0.13803913f, -0.06927761f, -0.04232257f, 
    0.10477500f, -0.08825079f, 0.27026406f, 0.14205649f, -0.20958225f, 0.08380426f, 0.16352220f, -0.01867214f, 
    -0.02042193f, -0.27451548f, -0.21433634f, 0.26844451f, 0.11547990f, -0.18683787f, 0.17787184f, -0.11121424f, 
    -0.31340906f, 0.00810610f, -0.08183471f, -0.08419090f, 0.02425905f, 0.13482939f, 0.13905682f, -0.13731699f, 
    0.06524891f, 0.29182839f, -0.18760966f, 0.03604792f, 0.11775038f, -0.17066742f, 0.13462509f, -0.05384396f, 
    0.03640682f, -0.08352649f, 0.00154342f, 0.14903556f, -0.02462194f, -0.00428041f, -0.10135788f, -0.26561323f, 
    0.06395792f, -0.07775553f, -0.01367901f, -0.12105890f, -0.17631204f, -0.05084315f, -0.16829486f, 0.04428299f, 
    0.03359718f, -0.05020554f, -0.03656211f, -0.12545142f, -0.10325038f, 0.01478223f, -0.07185256f, -0.10047144f, 
    -0.14316410f, 0.08489580f, -0.14143635f, 0.09209266f, -0.01661273f, 0.14493366f, -0.07597219f, 0.03760279f, 
    0.11689673f, 0.09138428f, 0.14097969f, 0.04916902f, 0.05641555f, -0.06578189f, 0.20119426f, -0.10299990f, 
    0.04635974f, 0.26076531f, 0.30396861f, -0.27245024f, 0.00849928f, -0.11782464f, 0.03022631f, -0.20510323f, 
    -0.08698120f, 0.16306861f, -0.09483726f, 0.12949415f, 0.17149302f, 0.10609517f, -0.06325117f, 0.07155029f, 
    -0.12900585f, -0.06467952f, 0.31587860f, 0.17005551f, 0.27397430f, -0.06249876f, -0.26954165f, 0.17331751f, 
    0.22441380f, 0.00679143f, 0.21486990f, 0.00929540f, 0.11491955f, 0.17982739f, -0.44343081f, -0.19773978f, 
    0.02176825f, -0.11786869f, -0.09066591f, -0.16677615f, -0.12873431f, 0.10607691f, -0.25628248f, 0.15339141f, 
    -0.02282309f, -0.12754266f, -0.21026874f, 0.23399600f, -0.11128032f, -0.17060751f, 0.13734615f, 0.09305464f, 
    0.11183157f, 0.18274647f, -0.23131455f, 0.09934821f, 0.07049686f, -0.04271399f, 0.35834494f, -0.07840944f, 
    0.13520992f, -0.19211686f, 0.00239190f, 0.13000491f, 0.37165257f, -0.12683794f, -0.04292266f, -0.07517293f, 
    0.20262554f, -0.37044293f, 0.08922157f, 0.02321467f, 0.27998403f, -0.23752867f, 0.22850002f, -0.13730791f, 
    0.18894590f, -0.14684099f, 0.33053401f, 0.06115987f, 0.10572731f, -0.08550617f, 0.00258841f, 0.00284801f, 
    0.06285225f, 0.34204480f, 0.13196932f, -0.13649403f, 0.12485860f, -0.16608535f, 0.05162929f, 0.26448745f, 
    0.06943676f, 0.09881712f, 0.03776896f, 0.12071780f, 0.11301598f, -0.07600399f, -0.26962125f, -0.29119006f, 
    -0.21796001f, 0.11995491f, 0.33815873f, -0.20190367f, -0.15226859f, -0.27353886f, 0.24024403f, 0.12575421f, 
    -0.15545702f, 0.01957599f, 0.08326407f, 0.16635020f, -0.17047188f, -0.01159327f, -0.05193456f, -0.02928736f, 
    0.06014401f, 0.29619512f, -0.27052945f, -0.02548967f, 0.27213210f, -0.12217560f, 0.23708856f, 0.17857343f, 
    -0.25349703f, -0.09381282f, 0.06270152f, -0.02039494f, -0.07873458f, -0.07680479f, -0.18408298f, -0.04168474f, 
    0.10119519f, -0.14768358f, -0.09189486f, -0.15348168f, 0.08035476f, -0.06362397f, -0.34806204f, 0.39820746f, 
    0.14040190f, -0.03817141f, 0.43960664f, 0.25085607f, -0.09644882f, -0.02445230f, 0.07515525f, 0.13437429f, 
    -0.00274330f, 0.07403745f, -0.45491955f, -0.04316502f, -0.03465001f, -0.04954398f, 0.26001078f, -0.32972857f, 
    -0.31392312f, 0.12534390f, 0.35358745f, 0.10898997f, -0.33825299f, -0.01124875f, 0.33965772f, 0.04258354f, 
    0.12430158f, 0.14922604f, -0.04769469f, -0.13858214f, -0.17234047f, -0.14509152f, 0.26887017f, 0.15529287f, 
    -0.15953305f, -0.12994073f, 0.03990631f, 0.00121100f, -0.01349009f, 0.16746938f, -0.02755903f, 0.00860366f, 
    0.10401816f, -0.24754494f, -0.14227779f, 0.15938240f, 0.05487404f, 0.06494381f, -0.20279834f, 0.02965051f, 
    -0.05426062f, 0.16630314f, 0.37574536f, -0.12883735f, -0.25026658f, -0.06563924f, -0.02511411f, 0.38275024f, 
    -0.01829278f, 0.08197795f, -0.18189257f, 0.12565014f, 0.11492328f, 0.05461103f, -0.07685070f, -0.06247593f, 
    -0.18485858f, 0.15410663f, 0.28678960f, 0.15869814f, 0.03774373f, 0.14911504f, 0.17469896f, 0.14804511f, 
    0.14244334f, -0.30411741f, -0.12896085f, 0.04586889f, -0.15121022f, 0.03878937f, 0.24283086f, -0.26706547f, 
    -0.06859922f, -0.17838351f, -0.17936598f, -0.02045191f, -0.02194181f, 0.08268491f, -0.10723355f, -0.06704654f, 
    -0.07671136f, -0.17243129f, -0.09448000f, -0.05965402f, 0.11670370f, -0.15269767f, -0.11746404f, 0.10269931f, 
    0.09477313f, -0.02020109f, 0.14959349f, -0.19583583f, -0.09343699f, -0.04870212f, -0.15565185f, 0.14501651f, 
    0.08997376f, 0.03571522f, 0.05970575f, -0.06724431f, -0.16942532f, -0.09883014f, -0.19717509f, -0.19142644f, 
    -0.23882595f, -0.21271278f, 0.26673350f, 0.11963500f, -0.16678071f, -0.10953150f, -0.11810219f, 0.32916456f, 
    -0.03316825f, -0.16201049f, -0.06491624f, 0.05243944f, 0.29455599f, 0.05717843f, -0.25951639f, 0.34499109f, 
    0.43834844f, -0.01966312f, 0.28060183f, -0.10259187f, -0.04876317f, 0.02979878f, -0.13536359f, -0.16794860f, 
    0.06676896f, 0.17367843f, -0.17690384f, -0.06340089f, -0.19906890f, 0.14418156f, 0.10509430f, -0.29908371f, 
    -0.01252060f, 0.19632785f, -0.13324101f, 0.01352978f, -0.04217516f, -0.02785954f, 0.04696327f, 0.20432656f, 
    -0.20274030f, 0.47193879f, 0.20523533f, 0.03082182f, 0.15920584f, -0.27589554f, 0.21040490f, 0.06883755f, 
    -0.01536912f, -0.01147099f, 0.32358107f, -0.09230115f, 0.14066097f, -0.00697964f, 0.03613621f, 0.14981416f, 
    0.00961423f, -0.31922564f, 0.21876301f, 0.02028540f, -0.05526605f, -0.14826664f, -0.08061684f, -0.02911810f, 
    -0.13562478f, -0.14485098f, -0.11963176f, -0.10244508f, 0.49429822f, -0.07008623f, -0.23331793f, 0.05920460f, 
    0.10291129f, 0.47747925f, 0.06126981f, -0.05817688f, 0.02375627f, 0.32749566f, -0.20307736f, -0.17973413f, 
    0.32791138f, 0.13043460f, 0.26850891f, 0.00677060f, -0.14684156f, -0.03334842f, 0.17240000f, -0.08424097f, 
    0.16112949f, 0.08919262f, 0.32936203f, -0.13180360f, 0.16510619f, 0.05756608f, 0.12533101f, -0.02109791f, 
    0.37573087f, -0.03505099f, 0.03280532f, -0.12866127f, 0.04469962f, -0.16073933f, 0.26061881f, -0.15881640f, 
    0.27748746f, -0.38621113f, -0.26915249f, -0.15879135f, 0.12289192f, -0.06050465f, 0.33540249f, -0.19590540f, 
    0.11965106f, -0.11098924f, 0.11071437f, -0.01751014f, -0.16268201f, 0.06202349f, 0.13247241f, 0.00145249f, 
    -0.11281943f, 0.48162064f, 0.03566687f, -0.13870651f, -0.05774626f, 0.13272126f, 0.21936922f, 0.25637782f, 
    0.04389512f, 0.15741810f, 0.02583711f, -0.03745247f, -0.11993301f, 0.04912606f, 0.36146101f, -0.02623345f, 
    -0.43243626f, 0.18447112f, -0.06624831f, 0.21596806f, -0.25223458f, 0.19728222f, 0.14908054f, 0.11392224f, 
    -0.01693760f, -0.09505817f, 0.02287790f, 0.30748087f, -0.12149176f, -0.00126159f, -0.03124821f, -0.12083732f, 
    -0.04724271f, 0.11312371f, 0.31496841f, 0.14333437f, 0.15305434f, 0.13041489f, -0.21255691f, 0.19952816f, 
    -0.27302530f, 0.02651180f, 0.10554752f, -0.07562753f, 0.05963244f, 0.04691745f, 0.33338317f, -0.16623721f, 
    0.00742948f, -0.21992214f, -0.29632255f, 0.24711159f, -0.00548551f, 0.04091585f, -0.26730081f, -0.00938112f, 
    0.01756649f, -0.01607774f, -0.14123400f, 0.39992404f, 0.08660744f, 0.02919332f, 0.11656624f, 0.00478145f, 
    0.13298832f, 0.29712540f, -0.05725875f, -0.01159725f, 0.18181834f, 0.17396642f, 0.34002411f, 0.27615687f, 
    0.20256796f, 0.11292422f, -0.01784606f, 0.13459706f, 0.02526704f, -0.14480698f, -0.20495448f, 0.10175035f, 
    0.23279616f, 0.32270500f, -0.32787400f, 0.24822615f, 0.12652190f, 0.17815983f, -0.12588419f, 0.24362659f, 
    -0.11886077f, 0.01591529f, 0.07937300f, 0.06068671f, 0.02876815f, 0.03059898f, -0.15450469f, -0.16932663f, 
    0.15329093f, -0.28945017f, -0.20681514f, -0.02498762f, 0.04345491f, 0.04539812f, 0.10042483f, -0.53339559f, 
    0.14103749f, 0.09114453f, -0.07524987f, 0.11787274f, 0.00063439f, -0.07052603f, -0.22554819f, 0.07757650f, 
    -0.31170559f, 0.34362575f, 0.13438773f, 0.21896787f, 0.16246547f, 0.33828649f, -0.02951236f, -0.08833771f, 
    0.01255730f, 0.15983577f, -0.02772996f, 0.11130650f, 0.14201590f, 0.04601166f, -0.03159899f, -0.00399228f, 
    -0.11047106f, -0.17986977f, 0.06616931f, -0.08587544f, 0.22040075f, 0.10659838f, 0.29683849f, 0.12960783f, 
    -0.10747658f, 0.15262543f, 0.16079897f, -0.11051462f, -0.01793551f, 0.15990606f, 0.26304036f, 0.29101405f, 
    0.19506638f, 0.16369523f, 0.03869892f, -0.02524664f, -0.09110538f, -0.01786315f, 0.16811639f, -0.10474437f, 
    0.34065521f, 0.01414373f, -0.39053091f, -0.29208052f, 0.02990614f, 0.08478548f, -0.15496622f, 0.12958924f, 
    -0.16927749f, -0.26088718f, 0.13746132f, -0.01853624f, 0.19140668f, -0.07144818f, -0.27476534f, -0.35682121f, 
    0.57902139f, -0.12301555f, -0.05479395f, -0.08560573f, -0.19423625f, 0.14442520f, -0.01236890f, -0.01513041f, 
    -0.10012881f, 0.20995441f, -0.00834423f, 0.17791256f, 0.26168197f, 0.15789114f, -0.24464010f, 0.12445918f, 
    -0.25765857f, -0.12342291f, 0.23805034f, 0.27145833f, 0.04209510f, -0.04654771f, -0.15800537f, 0.15920913f, 
    0.17389140f, -0.26963180f, 0.41594997f, -0.01243365f, 0.11511331f, 0.02846091f, 0.17317879f, 0.32941690f, 
    0.23366997f, 0.02996051f, -0.12237014f, -0.03201053f, 0.34648368f, 0.11865311f, 0.23756662f, -0.27676916f, 
    0.09263357f, 0.09338909f, 0.49985561f, -0.16846217f, 0.00635176f, 0.25357512f, -0.29183245f, 0.05895945f, 
    -0.17646325f, 0.01253664f, -0.23521566f, 0.12649244f, 0.10641192f, -0.00099629f, 0.09393729f, 0.07935480f, 
    -0.11843648f, 0.31884968f, 0.07272764f, -0.08873677f, 0.28979376f, -0.15100788f, 0.10728957f, 0.43319237f, 
    -0.12982467f, 0.23433489f, -0.02602550f, -0.02334219f, 0.03786890f, -0.07461672f, 0.05196578f, -0.04753939f, 
    -0.16556887f, -0.00484750f, 0.41514090f, 0.06983326f, 0.13921419f, 0.35070002f, -0.28204712f, 0.25038463f, 
    -0.17132308f, -0.16227567f, 0.08024945f, 0.21810463f, 0.12914863f, 0.10366285f, 0.00422938f, -0.04466232f, 
    0.07267381f, -0.21085283f, 0.00430878f, 0.03950100f, -0.01902520f, 0.10430311f, 0.16123807f, 0.11639652f, 
    -0.38782740f, -0.02158881f, 0.11110455f, 0.07304753f, 0.21337701f, 0.13633576f, 0.04006163f, -0.16405125f, 
    0.29971215f, -0.31713590f, -0.36130497f, -0.03910626f, 0.20374374f, -0.20767127f, -0.02598058f, -0.10329020f, 
    0.26052493f, -0.16388533f, 0.09963208f, -0.16389714f, 0.11267115f, 0.10502589f, 0.08615544f, -0.10033356f, 
    0.16231048f, 0.23752753f, -0.24220231f, -0.01836576f, 0.09683811f, -0.15071259f, 0.37545708f, -0.15375872f, 
    -0.18493627f, 0.26299381f, 0.00868574f, 0.06890144f, 0.02281585f, 0.08239503f, 0.32962525f, -0.01308379f, 
    0.12444071f, 0.32299083f, -0.07558379f, -0.20392476f, -0.11687999f, 0.04166504f, -0.06239705f, 0.12810494f, 
    -0.06138995f, -0.15426472f, -0.08728661f, 0.10974757f, -0.09156702f, 0.16865399f, -0.03338381f, 0.06109522f, 
    0.13044682f, 0.04731447f, 0.28217077f, 0.06937125f, 0.17690146f, 0.01466292f, -0.33322790f, -0.10707816f, 
    0.46493438f, -0.19916685f, 0.05187951f, -0.13445088f, 0.38220242f, -0.05000757f, -0.14104576f, 0.23545218f, 
    0.21891141f, 0.18647742f, 0.21598324f, 0.24882749f, 0.24656309f, 0.39746165f, -0.17249487f, -0.06957774f, 
    -0.13650705f, -0.08503415f, -0.08276707f, -0.12697259f, -0.17192850f, -0.02251508f, -0.15368271f, -0.00072366f, 
    -0.13351673f, -0.00123540f, 0.29026064f, 0.08193539f, 0.18350913f, -0.09675795f, 0.04916438f, -0.32162011f, 
    -0.19875486f, -0.17044827f, 0.23054314f, 0.06882539f, 0.17729592f, -0.13655372f, -0.19911388f, 0.05093795f, 
    0.04302425f, -0.51399249f, 0.05065488f, -0.14864665f, 0.17206959f, -0.19666553f, -0.17927884f, 0.43894443f, 
    0.18790127f, -0.07856787f, 0.16918303f, 0.38667911f, -0.03867780f, 0.02349694f, -0.12770438f, 0.03348895f, 
    0.15407385f, -0.20089036f, -0.30536541f, 0.15539409f, -0.23850028f, 0.03503471f, 0.27276722f, -0.20906894f, 
    0.09074896f, 0.30449849f, 0.19830139f, 0.13980006f, -0.07932760f, -0.07009446f, 0.42892697f, -0.12095699f, 
    -0.31115255f, -0.26442716f, -0.46920136f, 0.15256900f, -0.10973443f, -0.12862943f, 0.28067061f, 0.01512072f, 
    -0.00449739f, -0.03835280f, 0.01100387f, 0.32600832f, -0.10251295f, -0.07921062f, 0.05666725f, -0.07159660f, 
    -0.03109175f, 0.34700575f, 0.03619710f, 0.10353793f, -0.13583422f, -0.11223547f, -0.16050684f, 0.20837742f, 
    -0.29412028f, -0.13946120f, 0.34767008f, -0.15142024f, -0.26481441f, -0.00945865f, -0.32013366f, 0.37480199f, 
    -0.07051536f, 0.16057874f, -0.37370607f, 0.01275337f, 0.32688957f, -0.44126031f, 0.31594300f, 0.03362314f, 
    0.21895969f, 0.05414698f, 0.32346162f, -0.25962186f, 0.07676488f, -0.03582996f, 0.06825732f, 0.14634190f, 
    -0.04374966f, -0.18654090f, -0.16548134f, 0.07061043f, 0.06050593f, -0.12313695f, -0.12739831f, -0.15894648f, 
    -0.40121245f, 0.08469550f, 0.02857171f, -0.13880019f, -0.28511775f, 0.02715602f, 0.42376530f, 0.12366215f, 
    0.14575338f, 0.37671104f, -0.14615645f, 0.09145554f, -0.07112262f, 0.18385506f, 0.13195612f, 0.40153480f, 
    0.03541122f, -0.03876718f, -0.15486111f, 0.17753799f, -0.06124120f, -0.08397496f, -0.13823374f, 0.06691886f, 
    -0.16203628f, -0.07748222f, -0.11641655f, -0.05798473f, -0.09561253f, -0.11637322f, -0.27260330f, -0.18825790f, 
    -0.22150432f, 0.28495994f, 0.00883843f, 0.12933698f, -0.03752497f, -0.05230000f, 0.16872352f, -0.32265383f, 
    -0.20294745f, 0.08481928f, 0.18653747f, -0.20211948f, -0.06297363f, -0.01537052f, 0.37589365f, 0.13513318f, 
    -0.30967516f, 0.01880542f, 0.12043542f, -0.00205192f, -0.07401176f, 0.11476444f, -0.12903595f, -0.09102546f, 
    0.03092538f, -0.12327302f, -0.24349317f, -0.13678670f, 0.17372887f, -0.15348211f, -0.19393201f, -0.02166471f, 
    0.00884838f, 0.05768161f, 0.08785003f, -0.05987244f, 0.08162641f, -0.10145670f, -0.29454339f, -0.03142578f, 
    -0.10759532f, 0.17629969f, 0.63922423f, 0.00006624f, 0.08858669f, 0.32870683f, -0.16872431f, 0.28046778f, 
    -0.19291088f, 0.14477508f, -0.15959321f, 0.16122715f, 0.08684150f, 0.10868697f, 0.04575066f, -0.06211473f, 
    -0.15133898f, -0.04619620f, 0.18288644f, 0.11865789f, 0.03893009f, 0.16736278f, 0.10853281f, 0.09441572f, 
    0.45184535f, -0.05904188f, -0.09805905f, 0.09303360f, -0.08370477f, -0.00274896f, -0.07998778f, 0.07836771f, 
    -0.12821990f, 0.11379627f, -0.31527105f, 0.17005943f, 0.20053391f, -0.06417616f, 0.05094317f, -0.19162586f, 
    -0.22552136f, 0.05564189f, 0.12392324f, 0.14143947f, -0.13125455f, -0.16287483f, 0.03743822f, -0.08880204f, 
    -0.00118726f, 0.03315179f, 0.17240041f, 0.03179272f, 0.17668235f, 0.05639771f, 0.33235511f, -0.03488713f, 
    0.29228517f, 0.11111105f, -0.12997444f, -0.09413396f, 0.08453715f, 0.08202367f, 0.35651824f, -0.11714883f, 
    0.30686307f, -0.24948123f, 0.25956333f, 0.06639189f, -0.19241770f, -0.13633893f, 0.11883423f, 0.21267565f, 
    0.18237594f, 0.03806658f, -0.33883274f, 0.12511718f, 0.08317678f, -0.04078408f, -0.11174903f, -0.06674267f, 
    0.08077081f, 0.19284919f, -0.23291776f, 0.02034584f, 0.21686544f, 0.08496942f, 0.05242010f, -0.11872523f, 
    0.44714397f, -0.22711363f, 0.00715566f, 0.14494476f, 0.34157360f, 0.01019353f, -0.11763079f, 0.16342960f, 
    0.39596033f, 0.08565519f, 0.43205830f, 0.13969027f, 0.24007535f, 0.11415102f, -0.10496605f, -0.12714069f, 
    0.30855268f, -0.07825837f, 0.04998009f, -0.23266418f, -0.16152333f, -0.08275657f, -0.06492865f, -0.15750007f, 
    0.10951122f, -0.11435083f, 0.33524767f, 0.14639586f, -0.10359567f, -0.10131487f, 0.14059781f, -0.22598593f, 
    -0.04490640f, 0.00299350f, 0.16275796f, 0.14406908f, 0.35149756f, -0.07535399f, 0.14925686f, -0.29936454f, 
    -0.02755790f, -0.03919540f, -0.21560527f, -0.02522107f, -0.00699237f, 0.31307009f, -0.00715972f, -0.41962752f, 
    0.39943221f, -0.14424723f, -0.38110971f, -0.25034809f, 0.04396354f, -0.08181315f, 0.01171194f, -0.17149569f, 
    0.08939272f, -0.05174470f, 0.28210592f, 0.14423414f, 0.10204740f, -0.15034166f, -0.04944588f, -0.76120996f, 
    0.03774055f, 0.19543840f, 0.27746475f, -0.07813213f, -0.28297415f, -0.00932298f, 0.02349295f, 0.04874238f, 
    -0.03400983f, -0.16188642f, -0.43919423f, 0.16508101f, 0.11715842f, -0.13209207f, 0.29253936f, -0.05122015f, 
    0.07395718f, 0.08849590f, 0.25759092f, 0.04074747f, 0.09684644f, 0.09077130f, 0.06812152f, 0.09860072f, 
    -0.10783452f, -0.11648124f, -0.51878542f, 0.08864120f, -0.14230061f, 0.12839755f, 0.26350304f, -0.11892252f, 
    0.37004009f, 0.22028157f, -0.22768442f, -0.01011387f, 0.07119077f, -0.15195656f, 0.15093957f, -0.07076216f, 
    -0.24482943f, -0.12599015f, 0.14804231f, -0.05690990f, -0.00821012f, 0.07658481f, 0.20290004f, 0.17836116f, 
    0.12691185f, 0.06531285f, 0.11587272f, 0.14965394f, -0.01252928f, 0.12854195f, -0.17294063f, -0.01760979f, 
    0.10271589f, -0.02572617f, -0.23774986f, 0.10573395f, 0.04644136f, 0.00132933f, 0.14676993f, 0.04487763f, 
    0.40608129f, 0.17642456f, -0.01003707f, 0.11518897f, 0.08593637f, 0.11985693f, 0.07764238f, -0.36365500f, 
    0.13154207f, 0.02578324f, 0.15859036f, -0.12603711f, -0.28539202f, -0.09084754f, 0.28911322f, -0.07165752f, 
    0.14682773f, 0.16920781f, -0.22157228f, -0.10547127f, -0.10982211f, 0.01716560f, -0.17365165f, -0.00000510f, 
    -0.01999455f, -0.00808881f, -0.05576314f, -0.12146632f, 0.23524649f, -0.10683400f, 0.24222651f, 0.39961097f, 
    -0.25467563f, -0.20141827f, -0.09191937f, -0.05364879f, 0.30026811f, -0.06248981f, -0.10514656f, 0.18674496f, 
    0.36607304f, -0.09617163f, 0.43992275f, -0.33427590f, 0.23417908f, -0.26296771f, 0.20184211f, 0.22742818f, 
    0.25711238f, 0.12894098f, 0.00772688f, -0.24821734f, -0.03195905f, -0.00163087f, 0.02983473f, -0.06627787f, 
    0.15199682f, -0.17330655f, -0.02254210f, -0.08202581f, 0.12598675f, -0.01599036f, 0.12695229f, 0.06632292f, 
    -0.01717282f, 0.25684181f, 0.02983938f, -0.15981390f, -0.13323542f, 0.08223552f, 0.54247206f, -0.05036121f, 
    -0.16419716f, 0.05519338f, -0.29651138f, 0.06252865f, -0.25345570f, 0.41052988f, -0.06270525f, 0.10932463f, 
    0.16672049f, 0.13669926f, -0.13462943f, 0.27926305f, 0.03329827f, 0.07236584f, -0.05112522f, 0.12583548f, 
    -0.10444947f, 0.27729625f, 0.24054562f, -0.13566828f, -0.02237596f, 0.12659343f, -0.26796860f, 0.27006021f, 
    0.30351359f, -0.38053176f, -0.02836526f, -0.13902155f, -0.17405120f, 0.15695238f, -0.31746402f, 0.25544721f, 
    -0.18190995f, 0.13401099f, -0.27244341f, 0.05325108f, 0.11019586f, -0.46689633f, -0.04916367f, 0.33571342f, 
    0.11141142f, 0.09336014f, 0.29617834f, -0.02112157f, 0.17942952f, -0.06363970f, -0.09532569f, 0.02185842f, 
    -0.05495955f, 0.01619884f, 0.16292231f, 0.12922828f, -0.07386286f, 0.15094537f, 0.17583655f, 0.16642070f, 
    0.45804891f, 0.14100869f, 0.11134223f, -0.01193181f, -0.35507429f, 0.09698005f, 0.21325874f, 0.13166551f, 
    -0.22580844f, -0.24236897f, 0.06271062f, 0.37721062f, 0.18671742f, 0.10284872f, -0.00457462f, 0.21882412f, 
    -0.12103070f, -0.12262565f, -0.28471717f, 0.12854207f, 0.16595687f, 0.11898036f, 0.12086162f, 0.03519091f, 
    0.07989686f, 0.05534686f, -0.21840136f, 0.15068111f, -0.01697372f, 0.15737851f, 0.18997841f, -0.06151995f, 
    0.24917954f, -0.24235362f, -0.03311974f, 0.10117230f, -0.04751236f, 0.00465391f, -0.00521444f, 0.27153131f, 
    -0.05217692f, 0.14759038f, -0.12475496f, 0.30488366f, 0.28710318f, 0.47359651f, -0.08854910f, 0.09159617f, 
    0.11881094f, -0.16033047f, 0.25460124f, 0.20767955f, 0.01569571f, -0.14592355f, -0.09630340f, -0.16934565f, 
    0.09324807f, -0.00511904f, 0.08056451f, 0.15021695f, -0.03416950f, -0.14961180f, -0.09909947f, -0.34197098f, 
    -0.11739680f, 0.19057964f, -0.10296141f, -0.16546711f, 0.43034458f, -0.02731937f, -0.01794979f, -0.16207920f, 
    0.16412078f, -0.30464923f, 0.28138581f, -0.33385766f, -0.07030348f, -0.05595312f, 0.26085675f, -0.27790323f, 
    -0.16633256f, 0.10398853f, 0.07465076f, -0.09780473f, -0.03545142f, -0.16091926f, -0.03001095f, 0.06827131f, 
    0.02807378f, 0.18046913f, -0.14554167f, -0.17052431f, 0.29627451f, -0.05335541f, 0.29483527f, 0.35846934f, 
    -0.03584844f, -0.07782118f, -0.14644639f, 0.05498981f, -0.17471179f, -0.03237144f, -0.20111732f, -0.08932408f, 
    0.13004105f, 0.06429367f, -0.10222770f, 0.01189094f, 0.02743902f, 0.05401957f, -0.02371542f, -0.15810980f, 
    0.10316183f, -0.01474927f, 0.11539917f, -0.13571595f, -0.13248825f, 0.10739339f, -0.08554249f, 0.09688686f, 
    0.05609550f, -0.09689407f, -0.24300258f, -0.05544612f, -0.07607912f, -0.15474500f, 0.04144783f, -0.13166347f, 
    -0.08826109f, -0.06560463f, 0.11412911f, 0.09616347f, 0.28515449f, -0.13594596f, -0.02033901f, 0.01661441f, 
    -0.08805820f, -0.05750445f, -0.23857383f, 0.12559460f, -0.16329916f, 0.13525590f, 0.14628358f, -0.35582742f, 
    0.47172275f, -0.09541446f, -0.08202871f, -0.18188120f, -0.09630390f, 0.10592791f, 0.13344216f, -0.06175584f, 
    -0.10075815f, -0.35129181f, 0.18387625f, -0.17155518f, 0.16185693f, 0.10081829f, -0.01567356f, -0.31719220f, 
    -0.05428090f, -0.16416685f, -0.06738485f, -0.12323453f, 0.11968734f, 0.06854399f, 0.00776831f, 0.10761800f, 
    0.10312136f, -0.10322351f, -0.04873318f, -0.14416638f, -0.02220945f, -0.11625586f, 0.09261397f, 0.03506775f, 
    -0.10615751f, -0.12162942f, -0.02954557f, 0.00326489f, -0.05950749f, 0.14652580f, -0.02445604f, -0.01971368f, 
    0.14519474f, -0.05145638f, 0.01084192f, 0.00921476f, -0.15922560f, 0.05488787f, -0.03985886f, -0.13379395f, 
    -0.19008233f, 0.06083275f, -0.03133209f, -0.09264779f, 0.34890029f, 0.10514913f, -0.21397182f, 0.03583027f, 
    0.20564601f, 0.24803990f, 0.46979672f, -0.13124330f, -0.23029973f, 0.03829926f, -0.01502046f, 0.22163045f, 
    -0.28711703f, 0.00958135f, -0.20091094f, -0.04829191f, -0.05726973f, 0.14256808f, 0.03907412f, 0.02383645f, 
    0.11463983f, -0.19586569f, 0.12969837f, -0.05553927f, 0.36482596f, 0.16994993f, 0.26364541f, 0.14110963f, 
    0.10054945f, -0.10581724f, 0.13727313f, -0.03090572f, 0.14527069f, -0.16599125f, -0.02882068f, 0.01785552f, 
    -0.28386617f, 0.37981528f, 0.16886580f, 0.19068219f, -0.18299013f, 0.08407434f, -0.22601621f, -0.08102836f, 
    0.24309647f, 0.00281600f, 0.30343845f, -0.01999433f, -0.02132313f, -0.09834986f, -0.03213352f, 0.15002578f, 
    0.05357252f, 0.08702208f, 0.33285749f, 0.13838401f, 0.13999924f, 0.06687731f, 0.04639573f, 0.11690101f, 
    0.49874821f, 0.20842661f, 0.13439351f, -0.03810060f, -0.22948085f, 0.01518539f, -0.09760786f, -0.01662420f, 
    -0.33192235f, -0.23004244f, 0.05438767f, 0.19953839f, 0.20593718f, -0.09392601f, -0.01951877f, 0.11575663f, 
    0.01003153f, -0.06422926f, 0.10765414f, 0.17238136f, 0.09289264f, -0.13471289f, 0.00254790f, 0.05880812f, 
    -0.14524387f, 0.14640971f, 0.12172183f, -0.08807480f, 0.13187735f, -0.04297425f, -0.06110743f, 0.11591753f, 
    -0.39112279f, 0.26580781f, -0.04229903f, 0.16528697f, 0.26711616f, 0.03873767f, -0.19073899f, -0.19911274f, 
    0.21578355f, 0.09292741f, 0.12477846f, -0.27313370f, 0.01993080f, -0.44811690f, 0.22528088f, 0.12218698f, 
    -0.30423251f, -0.10690883f, 0.31204423f, 0.12086684f, -0.10592128f, 0.08042493f, 0.13069956f, 0.05097178f, 
    0.15465322f, 0.16619836f, -0.30075794f, 0.16258611f, 0.28705442f, -0.13189629f, 0.24932674f, -0.02484331f, 
    -0.07631650f, -0.09278820f, -0.13658220f, 0.12288811f, 0.43427095f, -0.12438995f, 0.26929215f, 0.15268826f, 
    0.35876918f, -0.07267882f, -0.34074017f, 0.21784580f, -0.07323299f, 0.14739574f, -0.06875315f, -0.11682424f, 
    0.44083545f, -0.08545678f, -0.07812826f, -0.03245635f, -0.02904278f, 0.02223269f, 0.09942289f, -0.07093886f, 
    0.03619942f, 0.35815656f, 0.21125279f, -0.01281972f, -0.11693273f, -0.04282006f, 0.16566484f, -0.07422768f, 
    0.43774951f, 0.11691586f, 0.22314341f, -0.08664868f, 0.10573644f, 0.07907359f, 0.46642992f, -0.03798524f, 
    0.06992070f, 0.13612123f, -0.33039677f, -0.19179879f, -0.27781358f, 0.02966307f, 0.23500022f, -0.29747203f, 
    0.15860578f, 0.09687193f, -0.12848625f, 0.03431299f, 0.15930390f, -0.02605602f, 0.04563676f, 0.03069577f, 
    0.10282307f, 0.00558699f, 0.48965842f, -0.13687155f, 0.08497975f, -0.02127348f, -0.22372732f, 0.08193287f, 
    0.43314007f, 0.16537203f, 0.04429958f, 0.04025346f, -0.09092372f, 0.14284617f, 0.29746467f, -0.08030191f, 
    0.16131757f, 0.10266786f, 0.16483060f, -0.16915971f, 0.06561716f, -0.02345794f, -0.09805419f, 0.02101645f, 
    0.35159162f, 0.14875874f, -0.21635790f, 0.00092569f, 0.10064058f, -0.11748607f, 0.06719361f, 0.10143655f, 
    0.08595685f, 0.27527407f, 0.25746727f, -0.09689657f, 0.08657470f, -0.09960622f, -0.39108449f, 0.08504640f, 
    0.04005163f, 0.15775205f, -0.04997580f, -0.02707986f, 0.27074480f, 0.01944132f, -0.01564429f, 0.04927111f, 
    0.26060984f, 0.11027247f, 0.04560560f, -0.12598087f, -0.37015083f, 0.02733513f, 0.37443456f, -0.05819167f, 
    0.16651735f, -0.11136086f, -0.28196910f, 0.16360405f, 0.05603508f, 0.14345936f, -0.05321015f, -0.10971420f, 
    0.10889155f, -0.30450183f, 0.15323061f, 0.07872888f, 0.19752906f, -0.08985469f, 0.09934396f, -0.15715314f, 
    0.30362266f, 0.16380022f, -0.18244734f, 0.08869947f, 0.30056891f, -0.09029652f, -0.16007580f, -0.25945032f, 
    0.13193184f, 0.03667365f, 0.56224889f, -0.00794334f, -0.12434033f, 0.26514962f, -0.15825376f, 0.14795271f, 
    -0.06064545f, -0.02827525f, -0.08888382f, 0.09013267f, 0.06048507f, 0.10122676f, 0.11048729f, -0.15078180f, 
    -0.11206792f, -0.05731227f, -0.02177947f, 0.10000035f, 0.22249635f, 0.10063626f, 0.17268059f, 0.00015488f, 
    0.08059925f, -0.15271373f, 0.22203928f, 0.06558840f, 0.03655828f, 0.05855807f, 0.01179492f, 0.16878012f, 
    0.17311852f, 0.13353837f, -0.26680034f, -0.04167300f, -0.07877592f, 0.10983409f, 0.31071475f, -0.30145651f, 
    -0.01215467f, 0.01983247f, -0.03985567f, -0.32735980f, 0.15585013f, 0.00565257f, -0.08646137f, 0.10137738f, 
    -0.12040726f, -0.24677765f, 0.36220312f, 0.01034545f, 0.22422607f, 0.16437578f, -0.05172550f, -0.41719681f, 
    -0.30963117f, 0.03077779f, -0.32165098f, 0.13663816f, 0.08649433f, 0.08711639f, 0.12425805f, -0.09264437f, 
    0.06017832f, 0.12172601f, 0.30056053f, 0.01345256f, -0.17409457f, 0.37585390f, -0.08958941f, 0.19599025f, 
    0.34982497f, 0.07101054f, -0.00923028f, 0.26435497f, 0.08980332f, 0.06328924f, -0.05449353f, 0.01381747f, 
    -0.13880481f, -0.02458675f, -0.03110075f, -0.03858075f, 0.19118308f, -0.11302572f, 0.30902362f, 0.35355607f, 
    -0.34227979f, 0.23126838f, 0.16210225f, 0.00677047f, -0.17654777f, 0.12243982f, 0.02524262f, 0.02706375f, 
    0.19564858f, -0.10027996f, -0.30876487f, 0.09218514f, 0.24542971f, -0.06125561f, 0.12467221f, 0.18828474f, 
    0.15152831f, -0.14886361f, 0.19021051f, -0.06086263f, -0.04155992f, 0.08611559f, 0.12723954f, -0.01045345f, 
    0.17464599f, -0.22328825f, -0.15670182f, 0.06437305f, -0.15075447f, 0.08929656f, -0.00687774f, -0.35856307f, 
    -0.20254809f, -0.02991817f, 0.17550427f, 0.05529649f, 0.20947891f, 0.03908218f, 0.02272219f, 0.12586476f, 
    0.22791024f, -0.11764521f, -0.41776952f, 0.16206756f, -0.07098923f, 0.02908298f, 0.00992967f, -0.15051423f, 
    0.34124351f, 0.12665290f, 0.03781278f, 0.21588393f, 0.14988121f, -0.05530873f, -0.08885053f, 0.09529887f, 
    0.14426930f, 0.27478221f, 0.03648380f, 0.08082544f, -0.15829951f, 0.00352266f, 0.01877490f, -0.17123292f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15664995f, 0.12856701f, -0.16341853f, -0.16695026f, 0.13652547f, 0.11848509f, -0.04252370f, -0.10489865f, 
    0.00006243f, -0.04942989f, 0.16767007f, 0.06894484f, 0.05656743f, -0.05812920f, 0.13469376f, 0.09844061f, 
    0.19250366f, -0.17296654f, 0.28266853f, 0.16030207f, 0.13434747f, -0.07146503f, 0.21497706f, -0.08622324f, 
    -0.04487998f, 0.14514485f, 0.13265529f, 0.10297461f, 0.23487163f, 0.20537151f, 0.20956586f, 0.19373302f, 
    0.07708728f, 0.16438447f, -0.15433484f, -0.02746438f, 0.08947097f, 0.16736636f, 0.06130878f, -0.14616783f, 
    -0.04437944f, -0.11882244f, 0.05456589f, 0.22348419f, -0.00695835f, -0.03146487f, -0.01113664f, -0.11661669f, 
    -0.07172081f, 0.08905736f, -0.00137907f, 0.01888902f, 0.21836498f, 0.10002702f, 0.02831215f, 0.00437076f, 
    -0.07935734f, 0.14958590f, -0.02088586f, 0.09672350f, 0.00958064f, 0.01255392f, 0.12837477f, 0.07231884f, 
    -0.06547920f, 0.05665442f, -0.13182075f, 0.26820600f, 0.18694168f, 0.11546145f, 0.02228154f, 0.08761648f, 
    0.13011986f, 0.21434405f, -0.09804204f, 0.07905992f, 0.33845201f, -0.19219327f, 0.30231196f, 0.03529949f, 
    0.10325610f, 0.12093536f, -0.05274089f, -0.00632136f, -0.08530584f, -0.03690351f, 0.21877269f, 0.00675144f, 
    0.20882846f, 0.08199576f, -0.12702096f, -0.08462729f, -0.08935203f, 0.22919621f, 0.08191944f, 0.23521514f, 
    0.07079096f, -0.03041700f, -0.10777412f, -0.03107205f, 0.08624891f, 0.04590857f, 0.19735053f, 0.18232714f, 
    0.07030895f, 0.13415210f, -0.04425493f, -0.00032201f, -0.26322177f, 0.16537467f, -0.00432180f, 0.14792486f, 
    -0.10557600f, -0.03837025f, 0.03969055f, 0.04482634f, -0.17953685f, -0.08029325f, -0.14966248f, -0.15670857f, 
    0.09461871f, -0.07596451f, 0.05273893f, -0.11516969f, 0.11733803f, 0.08162090f, 0.16546437f, -0.04350645f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09624443f, 0.04964735f, 0.22695179f, -0.05320239f, 0.30141956f, -0.34005702f, -0.45099717f, 0.02406595f, 
    0.03290999f, 0.09240407f, 0.27037713f, -0.69226599f, 0.01984128f, 0.04564258f, 0.13117371f, 0.11101066f, 
    0.08268507f, -0.39857200f, 0.17482804f, 0.12835030f, -0.21541700f, -0.15643023f, -0.40521833f, -0.04993552f, 
    -0.38825962f, 0.18499719f, -0.14057848f, -0.01597980f, 0.33749351f, -0.16194016f, -0.53937989f, 0.07982641f, 
    0.08544050f, 0.11991203f, 0.01258404f, -0.45086256f, -0.00041876f, -0.05911387f, -0.06183569f, -0.06540836f, 
    -0.43726531f, -0.24001306f, -0.18160413f, -0.07293765f, 0.05706064f, 0.11947774f, -0.23658583f, -0.37406129f, 
    0.10040795f, -0.02175358f, 0.01124995f, 0.07020552f, 0.10074846f, 0.23066220f, -0.07898175f, 0.12562875f, 
    0.03696124f, -0.08141588f, -0.18641445f, 0.00904741f, -0.24757132f, 0.01392068f, -0.16618739f, 0.06852058f, 
    0.03317587f, -0.33432695f, -0.30132273f, 0.17327753f, -0.27616358f, 0.03835877f, -0.00533759f, 0.04374264f, 
    -0.47070172f, -0.25644571f, 0.11110926f, 0.04215947f, 0.16804005f, -0.01860230f, 0.01236399f, 0.12155298f, 
    0.24722731f, -0.68634266f, 0.15613218f, 0.00302505f, 0.26623836f, 0.24982733f, 0.05928060f, 0.14675643f, 
    0.02336884f, 0.18412897f, -0.19322075f, 0.12745002f, 0.21170148f, -0.09724976f, -0.27977887f, -0.01909899f, 
    0.22119559f, -0.26091215f, 0.22345145f, -0.01402141f, -0.31129515f, 0.00685020f, 0.17893137f, -0.22627856f, 
    -0.14273603f, -0.15874536f, -0.20755784f, 0.07744379f, 0.05104326f, 0.01673158f, 0.23831499f, -0.31571397f, 
    -0.06174919f, 0.21838474f, -0.06554179f, 0.25400501f, 0.18053928f, -0.16280381f, -0.24595442f, -0.03669216f, 
    0.00778881f, -0.12419754f, 0.03060319f, 0.09945340f, 0.10400497f, 0.12753178f, -0.04783488f, -0.09656959f, 
    0.26792562f, -0.22595294f, 0.08699054f, -0.01312041f, -0.29137775f, 0.03054465f, -0.23490985f, 0.06288528f, 
    -0.17812064f, -0.04095287f, -0.01056692f, -0.57436538f, -0.08339688f, -0.26190281f, -0.09621920f, 0.12274060f, 
    0.03346319f, -0.04729587f, 0.04919539f, -0.25153688f, 0.11781162f, 0.16836947f, -0.20228460f, -0.05980153f, 
    0.11966961f, -0.07161118f, -0.07996150f, -0.40458170f, -0.31481200f, -0.15475048f, -0.20212893f, 0.14818445f, 
    0.23105146f, -0.09973572f, -0.00159155f, 0.04675453f, 0.02787156f, -0.21463692f, -0.08321099f, 0.01659130f, 
    -0.00917900f, 0.04076698f, -0.13822788f, -0.26460353f, 0.01796131f, 0.32030991f, 0.03593244f, 0.17924407f, 
    0.27028823f, 0.22641996f, -0.33629993f, 0.10474092f, -0.08270395f, -0.04890583f, 0.02803413f, 0.13554370f, 
    0.18978119f, -0.24340262f, -0.05949041f, -0.04225362f, -0.03522520f, 0.03267964f, -0.04929894f, 0.04960668f, 
    -0.15227671f, 0.05295816f, 0.12588735f, 0.29974577f, -0.31094724f, 0.06296723f, 0.24758106f, 0.17847481f, 
    -0.05612677f, 0.20648609f, -0.32028645f, -0.02913899f, -0.23388331f, -0.05522494f, -0.22701313f, 0.12736888f, 
    0.03756028f, -0.20261174f, 0.11394254f, -0.22427011f, -0.35255095f, 0.08284113f, 0.10585329f, 0.13370845f, 
    0.27249628f, 0.12210339f, -0.47917598f, 0.06055982f, -0.01087010f, -0.10237741f, -0.20080534f, -0.29672202f, 
    -0.05867181f, 0.20124081f, 0.24748726f, -0.12587520f, 0.15829714f, 0.07805998f, -0.31521180f, -0.55160320f, 
    0.13438682f, 0.16383317f, 0.24721378f, -0.02018253f, 0.14725316f, -0.05630168f, -0.19321303f, 0.10371430f, 
    -0.05178393f, -0.36627072f, 0.03250951f, 0.26723397f, 0.12208967f, 0.02740549f, -0.04159828f, -0.24741399f, 
    0.06362318f, 0.17718869f, 0.07683960f, 0.24452914f, -0.12692042f, 0.13214506f, -0.36534840f, -0.41275206f, 
    0.30601576f, 0.10510112f, -0.10212708f, -0.02207488f, -0.22737885f, 0.04737021f, 0.17872354f, -0.28244072f, 
    -0.02006741f, 0.11910003f, -0.15963537f, -0.08164656f, 0.16110773f, -0.35880056f, 0.07528662f, 0.18871531f, 
    0.09544875f, 0.10723462f, -0.36608112f, 0.12221168f, -0.23682018f, 0.36478293f, -0.03878566f, -0.02628063f, 
    -0.25100243f, -0.07476369f, 0.16389331f, -0.37108853f, -0.11684924f, 0.15635160f, 0.00017855f, 0.08434836f, 
    0.00246436f, 0.08275465f, 0.02311405f, 0.02764631f, -0.07368081f, -0.16819820f, -0.04268308f, 0.07997289f, 
    0.13280949f, -0.22772944f, -0.00336841f, 0.24866270f, -0.22599630f, -0.49559870f, -0.22089162f, 0.03423766f, 
    -0.22626777f, -0.34237733f, -0.32635930f, 0.03720749f, -0.09983638f, -0.38413030f, -0.05806288f, 0.12060470f, 
    -0.09821150f, 0.14599445f, -0.37034923f, 0.06128772f, -0.01093726f, 0.27082565f, -0.04248143f, 0.11838380f, 
    -0.45369121f, -0.43537721f, 0.33104232f, -0.17394684f, -0.11883106f, -0.04548828f, 0.07782694f, -0.23075427f, 
    0.09676102f, -0.45171043f, -0.09874149f, 0.04142108f, -0.13612807f, 0.01659335f, -0.24604587f, -0.42267528f, 
    0.11754803f, 0.12228186f, -0.44908330f, -0.17460442f, 0.16508748f, -0.42003328f, 0.18858039f, -0.32407278f, 
    -0.04323025f, -0.29454762f, 0.19231093f, 0.08033559f, 0.24335088f, 0.01472402f, -0.40434879f, -0.10723418f, 
    0.04917804f, -0.32423338f, -0.17277272f, -0.30992892f, 0.31707141f, 0.34438244f, -0.04068650f, -0.20629448f, 
    -0.43283114f, 0.02442538f, 0.38569874f, -0.13927342f, -0.44171456f, -0.33799314f, -0.00653852f, 0.11541171f, 
    -0.05576420f, -0.12644187f, -0.01691843f, 0.12683804f, -0.37403232f, -0.57324064f, 0.05555797f, 0.28002918f, 
    0.08403838f, 0.04884726f, 0.18578336f, 0.08187124f, 0.26119190f, -0.06616156f, 0.07603294f, 0.11876672f, 
    0.36673316f, 0.14248709f, -0.18538512f, -0.00852265f, 0.14985190f, -0.27664986f, -0.06625432f, -0.08310746f, 
    -0.01580782f, 0.28417948f, 0.12190479f, -0.06857677f, 0.29715493f, 0.27481455f, -0.02340869f, -0.10489997f, 
    -0.29191831f, 0.20109612f, -0.12194437f, 0.10910082f, 0.29688892f, 0.10482378f, -0.08888432f, -0.10108875f, 
    -0.01488568f, -0.10851578f, -0.05294485f, 0.15646267f, -0.14541472f, -0.02854045f, 0.30866987f, -0.08928189f, 
    -0.20315680f, -0.36162323f, -0.04383819f, 0.06674957f, 0.04796390f, -0.11220626f, -0.06803955f, -0.05483312f, 
    -0.02641401f, 0.22545934f, 0.12748741f, 0.05312721f, 0.07649194f, -0.25376707f, -0.49653488f, -0.02226501f, 
    0.02226711f, -0.44448310f, 0.20786572f, -0.09022860f, -0.15935224f, -0.15006790f, 0.03695143f, 0.01570569f, 
    -0.34761065f, 0.21007374f, 0.09303425f, -0.00227265f, -0.10734180f, -0.61981779f, -0.11999822f, 0.04346594f, 
    0.18690507f, -0.36117414f, 0.26158178f, 0.16638102f, -0.40798739f, -0.07875911f, -0.31197551f, -0.14399499f, 
    0.05040736f, 0.03701975f, 0.32257849f, -0.05314589f, 0.13060214f, -0.04501734f, 0.30750018f, 0.22048943f, 
    0.12213890f, -0.18135805f, -0.11952532f, -0.19768371f, 0.09147867f, -0.01308582f, -0.57148868f, -0.02437315f, 
    -0.38072848f, 0.12498726f, 0.02651011f, -0.19018169f, -0.12158415f, 0.35932189f, -0.22808059f, 0.20636480f, 
    -0.09068440f, 0.34285909f, 0.08614147f, -0.25750721f, -0.64258373f, 0.01121115f, -0.23920819f, 0.04834793f, 
    -0.03724086f, -0.26729205f, 0.17332691f, -0.34513351f, 0.27806312f, -0.18907927f, 0.15486591f, -0.12984462f, 
    -0.07734784f, 0.02570361f, -0.07790404f, -0.15836364f, 0.12419358f, 0.01605541f, 0.18777326f, -0.22243451f, 
    -0.56514120f, -0.35899425f, -0.35528690f, -0.09205081f, -0.43700588f, 0.02697936f, 0.24369130f, -0.11943668f, 
    -0.25555241f, 0.05368724f, 0.04684905f, -0.03236654f, 0.25590706f, 0.01618666f, 0.01170973f, -0.59193403f, 
    0.01067179f, -0.01434521f, -0.07145914f, 0.09846498f, 0.15828164f, 0.16618094f, 0.14969712f, 0.13679959f, 
    -0.00353678f, -0.01545614f, 0.17842211f, -0.45984831f, -0.04219582f, -0.41901723f, 0.11445399f, 0.01097549f, 
    -0.46019706f, -0.02730259f, 0.06831080f, 0.20384851f, 0.30955538f, 0.22459209f, 0.15666237f, -0.21705601f, 
    0.01034175f, 0.19806291f, 0.03340221f, 0.03222816f, -0.07251952f, 0.24439140f, 0.02517007f, -0.42076963f, 
    -0.00007061f, 0.28021550f, -0.10065404f, -0.01773960f, -0.35934290f, -0.14403288f, -0.02168270f, -0.28375968f, 
    -0.08060641f, -0.35647398f, 0.01111962f, 0.08249716f, 0.04846882f, 0.05632697f, -0.01943572f, -0.11357435f, 
    -0.06493594f, -0.03334413f, 0.19985999f, -0.03880661f, 0.06700385f, 0.10512546f, 0.02630281f, -0.26695001f, 
    -0.15351944f, -0.11279279f, 0.13757291f, 0.17501909f, 0.13560274f, 0.03396701f, -0.06452978f, -0.32847631f, 
    -0.05719016f, -0.35176635f, -0.00280602f, 0.10346165f, 0.08437101f, -0.06050159f, 0.30337784f, -0.28609243f, 
    -0.26885957f, 0.05630020f, 0.05435823f, 0.20318319f, -0.11124381f, -0.17708908f, -0.01405892f, -0.12910856f, 
    0.01108900f, 0.04304120f, -0.03005409f, -0.00204090f, -0.07760394f, 0.09130969f, 0.15759206f, -0.04235857f, 
    0.17345951f, -0.56254768f, -0.01963732f, -0.35837540f, 0.14857695f, -0.03971866f, -0.39041087f, -0.00446435f, 
    -0.15797022f, -0.16224663f, -0.14946885f, 0.18472986f, -0.75300735f, 0.24380137f, 0.12388247f, -0.29280630f, 
    0.04505580f, -0.85372156f, 0.03469011f, -0.35752138f, -0.09038645f, 0.03339739f, -0.30817741f, 0.04945709f, 
    0.00590891f, 0.16374648f, -0.19634728f, -0.21608794f, -0.19809133f, -0.06229356f, 0.09665292f, 0.05278782f, 
    -0.40453935f, -0.43426821f, 0.23345570f, 0.03728100f, 0.13254634f, 0.33907217f, -0.19969608f, -0.27126101f, 
    0.09858183f, -0.40841940f, -0.18594864f, -0.16988893f, -0.38204977f, -0.04879714f, 0.06705840f, -0.21476796f, 
    -0.00904263f, -0.46347952f, 0.04712158f, -0.02098176f, -0.01930916f, -0.05260245f, 0.28783190f, 0.02571488f, 
    0.15072100f, -0.05415770f, -0.22670296f, 0.14655386f, 0.01996453f, -0.13525093f, -0.36590827f, -0.05740247f, 
    0.13284795f, 0.11873686f, -0.06695646f, -0.00403717f, -0.03225940f, 0.20206133f, 0.01467536f, 0.10511799f, 
    -0.05560903f, -0.15884832f, -0.36323997f, 0.03226863f, -0.09764033f, 0.21464458f, 0.25564882f, 0.11463287f, 
    0.05906885f, 0.22071816f, 0.01923660f, -0.20973524f, 0.07093411f, -0.01939619f, 0.04586658f, -0.20696038f, 
    0.02280703f, 0.16999888f, 0.03258496f, -0.05833199f, -0.34839830f, 0.06521990f, 0.01550083f, 0.01713655f, 
    0.13268325f, 0.27755481f, -0.52477682f, -0.40827319f, 0.12783413f, -0.02241378f, 0.04274580f, -0.10376445f, 
    -0.20156562f, 0.20860264f, -0.25192031f, 0.10806844f, 0.07311529f, 0.05436802f, -0.54320443f, 0.02018913f, 
    -0.32137990f, 0.02359050f, 0.26022285f, 0.16796716f, 0.03224158f, 0.04229778f, -0.06458338f, 0.21668416f, 
    0.04841638f, 0.13763811f, -0.27834040f, 0.07085005f, -0.27415073f, -0.35588065f, 0.29021227f, -0.50834465f, 
    0.03178242f, 0.26095846f, -0.04888496f, 0.07735225f, 0.11559375f, -0.50894582f, 0.27750394f, 0.12360620f, 
    0.24875149f, 0.09005051f, -0.73618418f, 0.20514238f, -0.20625401f, 0.13745543f, -0.15153578f, 0.07693701f, 
    0.04983485f, 0.03603317f, -0.06406989f, -0.00699367f, -0.11581720f, 0.12192203f, 0.10758140f, -0.26753724f, 
    0.12310984f, -0.06230036f, 0.04344609f, -0.00154915f, -0.11157534f, -0.02259247f, -0.02914886f, -0.21390951f, 
    0.10513410f, 0.18951327f, -0.09524141f, -0.04661900f, -0.13773623f, -0.05674511f, -0.22441888f, 0.21922331f, 
    0.22441052f, 0.00686678f, 0.02235089f, 0.28109396f, 0.12125061f, -0.06203251f, 0.02940187f, 0.00512089f, 
    0.15579097f, -0.04501234f, -0.22179449f, 0.32456541f, 0.15821043f, 0.17109442f, -0.15657793f, -0.00627478f, 
    -0.01685260f, 0.11509661f, 0.18858649f, -0.02664081f, -0.24975270f, -0.52763718f, 0.32491827f, 0.22434913f, 
    0.02416925f, 0.12190391f, -0.06068271f, -0.49846590f, -0.01528567f, 0.18457955f, -0.05641190f, 0.21791624f, 
    -0.12954512f, 0.18325336f, -0.56126767f, 0.13941714f, -0.14477171f, -0.10091627f, 0.08339614f, -0.04756807f, 
    0.23366421f, 0.30339530f, 0.11107889f, -0.50173771f, 0.21732566f, 0.05749963f, 0.02526747f, -0.29782966f, 
    -0.10176745f, 0.30342036f, -0.58172750f, -0.02153350f, -0.33335674f, 0.14052285f, 0.02012972f, 0.12630615f, 
    0.18224980f, 0.07305518f, -0.03973066f, -0.45668364f, -0.04314915f, -0.06355897f, -0.00174086f, 0.35397711f, 
    -0.20194742f, 0.02028974f, -0.03973939f, 0.21328796f, 0.05941750f, -0.07018077f, -0.07892229f, 0.24391612f, 
    -0.44488606f, -0.11959681f, -0.02259722f, -0.22959420f, 0.03533648f, -0.21663423f, 0.17836052f, -0.68101799f, 
    -0.54632491f, -0.23387341f, 0.01950091f, 0.10556840f, -0.48795232f, -0.04139241f, 0.15443683f, 0.33651754f, 
    0.16684377f, 0.25480741f, -0.28613529f, -0.60135311f, 0.03605782f, -0.35920709f, -0.52581269f, 0.27290583f, 
    0.02246431f, -0.01195033f, 0.14414093f, -0.05634283f, -0.41696212f, -0.04864627f, -0.34738436f, -0.06281102f, 
    0.00813048f, -0.27664700f, 0.07857790f, -0.05546961f, -0.26749900f, -0.06846785f, 0.19190817f, -0.22748005f, 
    0.09752019f, -0.04308252f, 0.08443198f, -0.50973797f, 0.04050905f, -0.21908396f, 0.25990644f, -0.06742804f, 
    -0.21065655f, -0.10603024f, 0.18326186f, -0.05390251f, 0.33682495f, 0.00703871f, 0.01971247f, 0.00341952f, 
    -0.27621129f, -0.07871740f, -0.01891955f, 0.23177287f, -0.04534428f, -0.18697089f, 0.17876598f, -0.12500426f, 
    -0.19797997f, 0.07681169f, -0.00755993f, -0.23752940f, -0.40037018f, -0.00717266f, -0.03221834f, -0.06543592f, 
    -0.29357845f, -0.01574799f, -0.28162941f, 0.15743388f, 0.00750936f, 0.22253214f, -0.33444405f, -0.22813961f, 
    -0.12636521f, -0.28216797f, -0.07479862f, 0.16346999f, -0.03685322f, -0.13218072f, 0.00535763f, -0.04065779f, 
    0.03381563f, 0.02425875f, 0.27454779f, 0.01367028f, 0.04443807f, -0.02389729f, -0.15615477f, -0.14202161f, 
    -0.08363564f, -0.54843599f, -0.01573003f, 0.19554001f, -0.51541984f, -0.45883346f, 0.07398835f, -0.01658622f, 
    -0.13546591f, -0.59449553f, 0.15140834f, 0.03923067f, 0.05469551f, -0.01101766f, -0.32794788f, -0.32029709f, 
    -0.16399674f, 0.08305749f, 0.17374462f, 0.12027980f, -0.00263471f, -0.01796301f, -0.09953265f, 0.18365754f, 
    0.00076134f, 0.02494428f, 0.02277017f, -0.38929504f, 0.05481016f, -0.03055973f, 0.03395715f, -0.00848337f, 
    -0.06552697f, 0.05847889f, -0.12306996f, -0.22979429f, 0.20152202f, 0.12556520f, -0.08713154f, 0.25059533f, 
    -0.08046486f, -0.04923561f, -0.23365964f, -0.22250202f, 0.26189837f, 0.07298385f, -0.08668075f, -0.07269333f, 
    -0.32252911f, -0.20243219f, 0.10254364f, 0.26400107f, 0.11958944f, 0.22136207f, -0.02911938f, 0.06634644f, 
    0.15957049f, -0.05261348f, -0.24804685f, -0.24130046f, 0.31298280f, 0.19776799f, 0.22531419f, -0.16563107f, 
    -0.02283467f, -0.24083346f, -0.00908532f, -0.38899431f, -0.02695284f, 0.16994576f, -0.14438990f, -0.05531009f, 
    -0.06794101f, 0.02179883f, -0.22001190f, 0.09343451f, -0.12322792f, -0.32086784f, -0.15491129f, -0.19798104f, 
    -0.04585823f, -0.15866742f, -0.08028986f, -0.06389255f, -0.11351133f, 0.28669429f, -0.02685869f, 0.10062171f, 
    -0.15091418f, -0.43671545f, -0.41945615f, 0.07374530f, -0.05101150f, 0.02591611f, -0.43162352f, -0.09525292f, 
    -0.15755889f, 0.17047638f, -0.29078847f, -0.16439158f, 0.08912701f, 0.09900025f, 0.21220358f, -0.04254456f, 
    0.39167884f, -0.07521455f, -0.26813433f, -0.26532406f, -0.03646358f, -0.07826712f, -0.03748591f, -0.20691076f, 
    0.14334285f, -0.31853828f, -0.00638986f, -0.17972580f, 0.05207768f, 0.24231544f, -0.10015597f, 0.09200816f, 
    -0.00137524f, -0.24283920f, -0.00730957f, -0.34096342f, 0.21466365f, 0.10061765f, -0.10544541f, 0.28275591f, 
    -0.53894740f, 0.08767690f, -0.12901169f, 0.13174820f, -0.08275126f, -0.00314356f, -0.01170118f, -0.26001692f, 
    0.15287890f, -0.33235195f, -0.32928768f, -0.07444018f, 0.20309703f, -0.49623364f, 0.20666915f, 0.16641250f, 
    0.21518691f, -0.08887889f, -0.17983697f, -0.35952374f, -0.07377254f, -0.02616851f, 0.10257065f, -0.33935392f, 
    0.17291859f, 0.12376354f, -0.36630133f, -0.13289465f, -0.47270435f, -0.07219854f, -0.40213335f, -0.19317092f, 
    0.20044422f, 0.17869854f, 0.14182360f, 0.26234299f, -0.41292763f, -0.11895778f, -0.17683302f, -0.15794265f, 
    0.26333603f, -0.22524360f, 0.14914453f, 0.09772653f, -0.21503726f, -0.33409885f, 0.22197424f, -0.28281462f, 
    -0.18051834f, 0.03950886f, -0.16321008f, -0.25200668f, -0.07428957f, -0.16027780f, -0.26774308f, -0.43355170f, 
    -0.11402612f, 0.06593106f, -0.21255250f, 0.25294307f, -0.07975335f, -0.35808703f, -0.17301559f, 0.11456620f, 
    -0.10114091f, -0.16104834f, 0.03154511f, -0.23308127f, 0.18344431f, -0.09731811f, 0.08956058f, 0.28837502f, 
    0.17002439f, 0.16898449f, -0.09450550f, -0.11490573f, -0.35226464f, 0.11595381f, -0.45724091f, 0.16039765f, 
    -0.11881746f, 0.02744363f, -0.03305032f, 0.03575624f, -0.27186033f, -0.02562863f, 0.01781448f, 0.33174923f, 
    0.24502976f, -0.13569567f, -0.35125279f, -0.07964133f, -0.08973614f, -0.06241903f, 0.08374514f, -0.10110976f, 
    0.19465312f, 0.05230606f, 0.04167353f, -0.23022296f, -0.50573796f, 0.12361614f, 0.01518351f, -0.08412969f, 
    -0.09957775f, 0.18624568f, 0.25069565f, 0.13371296f, 0.19808419f, -0.07135039f, -0.12281388f, 0.21648800f, 
    -0.09275530f, 0.02132633f, -0.04473783f, -0.68641847f, -0.03365519f, 0.21551153f, -0.05313098f, 0.22960742f, 
    -0.50829238f, -0.08468191f, 0.07504352f, -0.45099938f, 0.30812505f, -0.20079824f, 0.20598538f, -0.40127671f, 
    -0.13860539f, 0.04382590f, 0.08251121f, -0.34036043f, 0.03944922f, 0.24704133f, -0.01042564f, -0.88992333f, 
    -0.00922734f, -0.24979195f, 0.06371421f, 0.07344457f, 0.16961731f, 0.01043040f, 0.00480069f, 0.07815339f, 
    0.13713565f, -0.20533110f, -0.13064508f, -0.36990210f, -0.29811999f, 0.02083887f, -0.07079481f, -0.67244768f, 
    -0.03314283f, -0.46463174f, -0.66595078f, -0.03428020f, 0.04771874f, -0.05541772f, 0.06584672f, -0.06064069f, 
    0.08671715f, 0.07294212f, 0.17066148f, -0.02918033f, -0.04897909f, 0.02010864f, 0.17925963f, 0.00976662f, 
    -0.45308718f, -0.12748067f, -0.03246764f, -0.08349086f, -0.10929792f, -0.69629318f, 0.17208444f, 0.00483894f, 
    0.00069700f, -0.50193983f, -0.31080440f, 0.06732890f, -0.00139528f, 0.05387634f, 0.61961210f, 0.06099651f, 
    0.12908357f, 0.04248129f, -0.15361883f, 0.11189935f, 0.11420637f, 0.01680167f, 0.14286046f, -0.15474409f, 
    -0.04482542f, 0.53812355f, 0.08157290f, -0.49899206f, 0.18502073f, -0.02260854f, -0.60102105f, 0.24953306f, 
    0.21717075f, 0.04137262f, 0.11487444f, -0.39980033f, 0.15045421f, 0.06850091f, 0.02420303f, 0.18963249f, 
    -0.01762315f, -0.17175655f, -0.52095389f, 0.04049362f, -0.19325916f, 0.29945663f, 0.11897693f, -0.49941021f, 
    -0.31515172f, -0.02139177f, 0.15935992f, -0.11973264f, -0.21674959f, 0.04191068f, -0.41855797f, 0.07913087f, 
    -0.28965235f, 0.07005995f, -0.03652516f, 0.20654257f, 0.11400068f, 0.17763563f, 0.23156768f, -0.01347741f, 
    0.33478868f, -0.62908798f, -0.46837655f, -0.16090332f, -0.01263239f, 0.13376702f, -0.13303338f, -0.12602313f, 
    -0.35992509f, -0.14500844f, -0.08731382f, 0.15222299f, 0.02071763f, -0.42573488f, -0.05390600f, -0.15805778f, 
    0.23323819f, -0.17219788f, 0.17860934f, 0.31292844f, 0.14884552f, 0.08122084f, 0.16565424f, 0.13223635f, 
    -0.33793393f, -0.03076338f, 0.01801612f, -0.02456285f, 0.27235731f, 0.05102798f, -0.06513132f, 0.23317686f, 
    -0.23547833f, 0.08149704f, -0.01722357f, -0.02584609f, 0.00582371f, -0.12877822f, 0.04413742f, -0.21996287f, 
    -0.23683837f, 0.01585975f, 0.06362383f, -0.08713161f, -0.08535036f, 0.06699116f, -0.41129544f, 0.42162639f, 
    0.02232790f, 0.20616531f, 0.14014696f, -0.19408540f, 0.00428235f, 0.01918847f, 0.04957753f, -0.35804537f, 
    0.03050219f, 0.07567947f, -0.32827285f, 0.24800287f, 0.02572460f, 0.09417602f, -0.36497313f, -0.20784260f, 
    0.10621814f, 0.08535924f, 0.22858967f, -0.31151840f, -0.09586592f, 0.26562369f, -0.20340478f, -0.23443535f, 
    -0.30031785f, -0.53429097f, 0.04176394f, 0.02692069f, 0.19894165f, 0.01869237f, -0.39934814f, 0.08754106f, 
    0.10601122f, 0.08972174f, 0.26423511f, -0.32174054f, -0.12348518f, 0.10570744f, -0.12419485f, 0.20415886f, 
    0.04484969f, -0.14326794f, -0.01733397f, 0.20103964f, -0.11749922f, -0.09314341f, 0.20822197f, 0.10590283f, 
    -0.45554477f, -0.50515026f, 0.05395677f, 0.23413616f, -0.45415109f, 0.27897868f, -0.03560898f, -0.03551665f, 
    -0.33528233f, 0.29872450f, -0.25394765f, 0.04286513f, -0.36657006f, -0.42894655f, 0.20299326f, 0.29616770f, 
    -0.27325258f, 0.31188890f, 0.23314902f, 0.10586874f, -0.09217429f, -0.04804876f, -0.05966628f, -0.11825714f, 
    0.26288453f, 0.07531212f, -0.01220243f, 0.10968900f, 0.02067515f, -0.34000325f, -0.04019187f, -0.02668346f, 
    -0.23110871f, -0.15346824f, 0.23049445f, -0.23646866f, -0.33583614f, 0.21453263f, 0.23411830f, -0.59562379f, 
    -0.15668432f, 0.07426716f, -0.04071245f, 0.16842905f, 0.00699764f, -0.36230788f, -0.02217025f, -0.58727020f, 
    0.21645564f, 0.01762183f, 0.00039873f, -0.02154808f, -0.27037916f, 0.06563018f, 0.04888417f, 0.10771951f, 
    -0.05202653f, 0.06802101f, 0.14458345f, 0.23640409f, -0.17828962f, 0.02247945f, 0.04473479f, 0.12792842f, 
    0.06953900f, 0.04396478f, -0.26408496f, -0.00163204f, 0.27451825f, -0.15529417f, 0.14767256f, 0.12664056f, 
    -0.35455528f, -0.03295921f, -0.17100823f, -0.04787735f, 0.29911411f, -0.03751724f, 0.06484012f, -0.00808868f, 
    0.12079325f, 0.12439006f, -0.36109474f, 0.10460085f, 0.21824864f, -0.03958498f, -0.02840320f, -0.00726462f, 
    -0.00927063f, 0.08653911f, -0.13295531f, -0.04988636f, -0.11281846f, -0.00956042f, -0.06711270f, -0.12656976f, 
    -0.32051226f, -0.23756315f, 0.14108001f, -0.23327702f, 0.07712686f, -0.22180833f, -0.05271142f, 0.37068096f, 
    -0.38941890f, 0.13392100f, -0.05338877f, 0.19625159f, -0.49041745f, 0.04484718f, -0.23955932f, 0.16752857f, 
    -0.38922426f, 0.01755027f, -0.04439919f, -0.33268398f, -0.09929600f, -0.05827436f, -0.02963194f, 0.10785774f, 
    -0.04761831f, -0.04528736f, -0.04173363f, -0.08795809f, 0.08815884f, 0.04554204f, 0.06567386f, -0.23741502f, 
    0.08034974f, -0.30967388f, -0.06323693f, -0.35865393f, 0.35165924f, -0.51044708f, -0.05210243f, -0.00619752f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03954186f, -0.01715150f, -0.06503837f, -0.08562534f, 0.12687641f, 0.03963101f, -0.03995553f, -0.17535055f, 
    -0.18488012f, 0.09577147f, 0.07047155f, 0.07783147f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
