#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.07838767f, 0.45135030f, -0.39966914f, -1.04188442f, -0.85373282f, -0.34869194f, 0.59358037f, -0.66870070f, 
    0.32991233f, -0.60863948f, -0.58867061f, -0.32113731f, -0.47131753f, -0.26206833f, -0.69067758f, -0.18919192f, 
    -0.37259924f, -0.31379935f, -0.95276213f, 0.87115419f, 0.34732434f, -1.10142636f, -0.43378398f, -1.05542660f, 
    -0.25213230f, -0.71826237f, -1.00568664f, 1.02372658f, 0.74186981f, 0.63016135f, 0.09057882f, -0.88693839f, 
    -0.28293681f, 0.29409823f, 0.31236288f, 0.37319046f, -0.69310737f, 0.44985980f, -0.24293789f, -0.81052673f, 
    -0.29358432f, -0.98684818f, 0.34686488f, -0.18600695f, 0.69195735f, 0.10036063f, -0.37420449f, -1.43694139f, 
    -0.43078849f, -0.18146953f, 0.03415353f, -0.48618895f, -0.60014468f, -0.39278883f, -1.31885576f, -0.70632243f, 
    0.18482430f, 0.86208981f, -0.34960613f, -0.50477558f, 0.53484726f, 0.18416055f, 0.06827924f, 0.54149914f, 
    0.55194616f, -0.19736776f, -0.52111387f, 0.25122929f, 0.09351379f, -0.34651694f, 0.02517371f, 0.70663106f, 
    0.87827009f, -0.23995791f, -0.38561642f, 0.60133511f, -0.52687019f, 0.29412949f, -0.27522731f, 0.24417606f, 
    0.07408521f, -1.37475693f, 0.09118449f, 0.93087488f, -0.61692727f, -0.87243950f, 1.43747783f, -0.06380620f, 
    0.04707239f, -0.07562366f, 0.40343216f, 0.68590575f, 0.82184494f, -0.25329188f, 0.30240399f, -0.21951270f, 
    0.25500283f, -0.41909245f, 0.20237154f, -0.93319577f, -0.56945652f, -0.02413355f, -0.55386204f, -1.15418875f, 
    -0.85847265f, -0.19539247f, 0.10995196f, -0.01195425f, 0.39023224f, 0.51408309f, 0.54350799f, 0.65050673f, 
    -0.21767415f, -0.60779905f, -0.49789894f, -0.24282104f, -0.12529404f, -0.43261626f, 0.26955885f, 0.22982207f, 
    0.41306010f, -0.49426579f, -0.33491164f, -0.13148126f, -0.78641647f, -0.49305189f, -0.50463229f, 0.49524808f, 
    -0.19067708f, -0.52887213f, -0.03753548f, -0.47686034f, 0.62421310f, 0.61240697f, 0.55725026f, -1.05702353f, 
    -0.68604529f, -0.74716794f, 1.05121350f, 0.76585054f, 0.51349896f, -0.14185584f, 0.43318588f, -0.02385372f, 
    0.33846882f, -0.30171853f, 0.42487568f, -0.28650346f, 0.03334452f, 0.23651627f, 0.31373799f, 0.33558103f, 
    0.45564845f, -0.32790175f, -0.44528946f, -0.43954957f, -0.43748233f, -0.45442438f, 0.78453183f, 0.45273405f, 
    0.47593433f, 0.70866168f, 0.32801625f, -0.54801428f, 0.30811343f, 0.19522913f, -0.30352560f, 0.56344026f, 
    -0.37245667f, -0.68102890f, -0.45267773f, -0.75554460f, -0.09178653f, 0.40662092f, 0.69602233f, 0.93724531f, 
    0.22955897f, 0.34899884f, 0.73911875f, 0.23305826f, 0.52630305f, -0.47467163f, -0.64849049f, 0.35751078f, 
    0.02452653f, -0.00925814f, -0.49517015f, -0.54534531f, 0.62843740f, 0.70084035f, -0.35945007f, -0.25080127f, 
    0.85776377f, -0.48777696f, -0.21543925f, 0.39439580f, 0.51629746f, -0.19196087f, -0.25108323f, -0.61062706f, 
    0.29658088f, 0.85944217f, -0.05121671f, 0.84376478f, -0.34374514f, -0.85200036f, -0.48338085f, 0.04224386f, 
    -0.72774172f, 0.66518700f, 1.27624965f, -0.89477199f, -0.34806371f, -0.03830453f, 0.10974489f, 0.03550662f, 
    -1.14675701f, -0.83886510f, -0.29955581f, 1.27630055f, 0.22890909f, -0.94589293f, -0.52765185f, -0.75726891f, 
    -0.13689275f, 0.90740919f, 0.05196078f, 0.98607546f, -0.72716564f, 0.14550890f, -0.13163322f, 0.22557004f, 
    0.35128528f, -0.16585901f, 1.20687509f, -0.91387701f, -1.05243361f, 0.92800122f, 0.14756984f, 0.68442887f, 
    -0.30857447f, -0.19444248f, -0.49007666f, 0.16490521f, 1.73764074f, -1.25284851f, -0.58379078f, -0.04180313f, 
    0.01356363f, -0.12267476f, 0.54373652f, 0.12180137f, 0.77952200f, -1.06392503f, -0.82541043f, -0.38825798f, 
    0.66981101f, -0.59759820f, -0.01088277f, -0.12479080f, -0.65215826f, 0.69393420f, -0.90323961f, -0.27780581f, 
    -0.71778923f, -0.87130809f, -1.20356643f, 0.67227179f, 0.65998834f, -0.03705913f, -0.58769274f, 0.70815593f, 
    0.09906372f, 0.53220081f, -0.07958963f, 0.70550001f, 0.29290989f, -0.44396481f, 0.06499141f, -0.38483348f, 
    -1.24931347f, -0.70259249f, -0.71120006f, -0.05593133f, -0.18785247f, 0.67849004f, -0.43781409f, -0.40880382f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48170671f, -0.43846720f, -0.32225564f, 0.26651406f, 0.38102949f, 0.24790664f, 0.34257248f, 0.63018054f, 
    0.66647124f, 0.21918912f, 0.70922011f, -0.65333235f, 0.07684169f, 0.38123560f, 0.21711344f, -0.08595473f, 
    0.30717602f, 0.42946029f, -0.30807590f, -0.05422952f, 0.60342896f, 0.15237111f, 0.23660710f, -0.00337682f, 
    0.03356564f, 0.56902194f, -0.08863491f, 0.22098495f, 0.04062963f, -0.03654287f, 0.36923844f, 0.70164180f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.38802916f, 0.04656911f, 0.54780740f, 0.08323440f, 0.21020120f, -0.22609545f, -0.03795289f, 0.14752430f, 
    0.10384043f, 0.00374413f, 0.28405756f, 0.00337551f, -0.03923980f, 0.01303451f, 0.06063981f, 0.11058494f, 
    -0.03499749f, 0.18730836f, 0.11737168f, 0.45247072f, 0.57624680f, -0.00593507f, 0.05284556f, -0.02282956f, 
    0.14763686f, 0.18506835f, 0.21954189f, -0.23638275f, 0.04015984f, 0.11379813f, 0.00971150f, -0.02103147f, 
    -0.18100226f, -0.06170962f, 0.10975775f, 0.13213374f, -0.12775803f, 0.34798592f, 0.37174892f, -0.09584200f, 
    -0.01115889f, -0.00687392f, -0.02334926f, 0.16496180f, 0.04323611f, -0.09764697f, -0.62200308f, -0.44257894f, 
    0.11872979f, 0.21620296f, -0.01343938f, 0.18540415f, -0.20720345f, -0.03808435f, -0.10970785f, 0.24194270f, 
    -0.36103213f, 0.12806433f, 0.13842846f, -0.01021073f, 0.14017670f, -0.05695511f, -0.16453378f, -0.36256406f, 
    0.11490099f, 0.16854361f, -0.19485144f, 0.08965989f, 0.09268712f, 0.13208136f, 0.00603899f, -0.15993714f, 
    -0.35501954f, -0.27072841f, 0.13611491f, -0.07209102f, -0.02477040f, 0.07856707f, -0.00833294f, 0.06855270f, 
    -0.00055444f, 0.72394633f, 0.23046999f, 0.31284747f, -0.40172493f, 0.19178413f, 0.11139596f, 0.03137373f, 
    -0.36569938f, 0.08861171f, -0.12567498f, 0.08277817f, 0.15875839f, 0.09762708f, 0.02410971f, -0.12182226f, 
    -0.01010212f, -0.05834602f, -0.01915360f, -0.15541576f, 0.74118572f, 0.20503092f, -0.15408391f, -0.12085962f, 
    0.01363309f, 0.06792846f, -0.05513594f, 0.00351181f, -0.20532538f, 0.13854657f, 0.17151339f, -0.03187536f, 
    -0.24091549f, -0.10402776f, -0.08340069f, -0.06082278f, -0.24924694f, -0.01300204f, 0.21909779f, 0.09431418f, 
    -0.02568983f, -0.23603781f, 0.04326789f, -0.00841021f, -0.04953039f, -0.02772196f, 0.10714088f, 0.06530132f, 
    0.20324039f, -0.15282637f, 0.12105318f, -0.10156998f, -0.04102008f, 0.13299841f, 0.09028284f, 0.13766265f, 
    -0.16727407f, -0.37643203f, -0.04628745f, 0.16220513f, -0.04877825f, -0.03804973f, 0.16961524f, -0.01288952f, 
    0.04010401f, -0.00267022f, -0.00088643f, -0.01276380f, 0.01769121f, -0.12933132f, 0.03997497f, 0.02078620f, 
    0.09189276f, 0.10310385f, -0.07124102f, 0.01673742f, -0.13041125f, -0.08221864f, -0.13016866f, -0.00426499f, 
    0.00735139f, -0.02487326f, 0.00790376f, -0.03510596f, 0.07987162f, -0.04770517f, -0.05752969f, 0.15798701f, 
    0.07200146f, -0.09211440f, -0.05533931f, 0.10206215f, 0.02567790f, -0.21112056f, -0.07731897f, 0.24576944f, 
    -0.10402209f, 0.02141241f, 0.15030898f, 0.04510239f, -0.03412252f, -0.19208778f, -0.10820869f, 0.13587545f, 
    0.10548855f, 0.13332286f, 0.07595427f, -0.06164442f, 0.13207243f, -0.22507586f, 0.10590138f, -0.01029238f, 
    0.03282072f, -0.06811230f, -0.09583192f, 0.03980298f, 0.01693967f, -0.08286081f, -0.01034862f, -0.09571850f, 
    -0.02216680f, -0.29642743f, -0.01917212f, -0.06888661f, 0.00149884f, -0.18696833f, 0.04860141f, -0.14918746f, 
    0.05495863f, 0.07715693f, 0.11529583f, -0.11541283f, -0.15372923f, 0.02649640f, 0.02168016f, -0.04106262f, 
    0.05746587f, -0.06884108f, -0.91930366f, 0.01591427f, -0.16686662f, -0.07083856f, -0.03200262f, 0.05100332f, 
    -0.00392360f, -0.12143448f, 0.18766755f, 0.05692813f, -0.00678415f, 0.16710158f, -0.08193951f, -0.08181515f, 
    0.11116112f, 0.01519924f, -0.19079797f, -0.24426863f, 0.06093289f, -0.05504447f, 0.08303015f, -0.13105631f, 
    0.19178621f, 0.06425279f, -0.22876635f, -0.11685717f, 0.14490932f, 0.16957298f, -0.17027119f, 0.63232601f, 
    -0.16421610f, -0.15009278f, 0.10775000f, 0.02977718f, -0.05636277f, -0.05384530f, -0.18141799f, -0.07830895f, 
    0.26196492f, -0.18080600f, 0.06931370f, -0.06079195f, 0.09067535f, 0.00851400f, -0.16894680f, -0.01471911f, 
    0.03525795f, 0.05135873f, 0.01527798f, -0.08801480f, -0.02702734f, -0.02880916f, 0.17168322f, 0.25408900f, 
    0.22446038f, -0.17838764f, -0.02788859f, 0.11315157f, -0.01793341f, -0.08416456f, 0.03244454f, 0.04401651f, 
    -0.15576430f, -0.16918531f, 0.05719617f, 0.08374643f, -0.06276827f, -0.08086400f, -0.10884794f, 0.13616674f, 
    0.28303045f, -0.05766375f, 0.02755873f, -0.22870934f, 0.04802094f, -0.01493448f, -0.03638690f, -0.08382975f, 
    -0.16985859f, 0.26433665f, 0.20048530f, 0.09244401f, 0.31535989f, 0.21254845f, 0.22754163f, -0.01368517f, 
    0.02703463f, -0.19937216f, 0.23457599f, 0.27039257f, 0.50390333f, -0.18520385f, -0.05928696f, 0.04044659f, 
    -0.08460607f, -0.13185914f, 0.07708512f, 0.17901190f, -0.09978473f, 0.01592433f, -0.05052977f, -0.03811720f, 
    0.01117740f, 0.02533302f, 0.09042410f, -0.08369472f, 0.12140937f, 0.03200732f, 0.03003218f, -0.20191191f, 
    -0.14009720f, -0.07254676f, -0.03443066f, -0.14326653f, -0.11276594f, 0.28782538f, 0.11224190f, 0.16249794f, 
    0.19427586f, 0.18096195f, 0.19684109f, 0.04238486f, 0.05598957f, 0.05598863f, -0.22851145f, -0.13678092f, 
    0.04738972f, 0.20596364f, -0.03182318f, -0.15689106f, 0.27370110f, -0.09394950f, -0.06588203f, 0.01153770f, 
    0.00507589f, -0.08888260f, 0.15910587f, -0.04851438f, 0.09601098f, 0.00583777f, 0.09348033f, -0.27310741f, 
    -0.31710327f, 0.38289237f, -0.24464859f, 0.03581006f, 0.07270587f, -0.08305538f, 0.13147396f, 0.11734795f, 
    0.04835144f, 0.41609383f, 0.35082096f, 0.25655302f, -0.13829845f, -0.09974980f, -0.40847892f, -0.01023572f, 
    0.23567651f, -0.11117416f, 0.02905962f, -0.32016391f, -0.02123290f, 0.02293673f, 0.05722889f, 0.00702746f, 
    0.09922694f, 0.07630196f, 0.09323979f, 0.44702125f, 0.28374854f, 0.26680908f, 0.31938240f, -0.09116003f, 
    0.09034202f, 0.00568379f, -0.06112839f, -0.17968138f, -0.03543914f, -0.24886180f, -0.25995222f, 0.22214216f, 
    0.04678418f, 0.09057654f, 0.09735609f, 0.08557523f, 0.16213058f, 0.00597343f, 0.36695877f, 0.15157412f, 
    0.05929888f, 0.08533230f, -0.13603787f, 0.02683241f, 0.06779650f, 0.00663436f, 0.12316159f, 0.01370969f, 
    0.09811851f, -0.05168902f, -0.01321232f, 0.00649276f, -0.18803790f, -0.41587242f, -0.29166073f, -0.50424665f, 
    -0.48374945f, -0.48192376f, 0.36264372f, 0.12877974f, 0.14660254f, 0.00640955f, 0.09917077f, 0.01406991f, 
    0.02820931f, 0.09239890f, -0.03862433f, 0.04277847f, 0.06890623f, 0.11546718f, -0.37368011f, -0.18329552f, 
    -0.33863765f, 0.09761998f, 0.01805601f, -0.04349988f, 0.07528192f, 0.01243190f, -0.06261115f, -0.08680089f, 
    -0.09267031f, -0.20000480f, 0.33373874f, 0.18974774f, 0.00455400f, 0.24135451f, 0.04150687f, 0.06625427f, 
    -0.03871248f, 0.15569904f, -0.11561889f, 0.02431642f, 0.05696470f, 0.13759300f, 0.20794530f, 0.12102181f, 
    0.07785459f, -0.09629630f, -0.28069440f, -0.23856091f, -0.07098819f, 0.10068525f, -0.15976250f, 0.09408481f, 
    -0.04947764f, 0.02956359f, -0.04762015f, 0.01746434f, -0.16427445f, -0.03964143f, -0.01625046f, -0.00999016f, 
    -0.00603099f, 0.04703768f, 0.01871102f, -0.28254411f, -0.27604839f, 0.21641871f, 0.23621853f, -0.04625196f, 
    -0.07278033f, 0.01633161f, 0.14406306f, 0.15915270f, -0.10420083f, 0.34828305f, 0.04227529f, -0.22867081f, 
    0.54635680f, -0.31317037f, -0.16717273f, 0.01211575f, 0.05972303f, -0.16062450f, -0.10585791f, 0.35165870f, 
    -0.04251386f, 0.21543986f, -0.25750887f, 0.10820296f, 0.17286117f, -0.03725319f, -0.00489384f, 0.18482226f, 
    -0.07192898f, -0.11938724f, -0.12939414f, -0.13934886f, 0.09075337f, 0.06604423f, -0.11922660f, 0.13959105f, 
    -0.09671305f, 0.15880674f, -0.00073431f, 0.15134104f, -0.01975830f, 0.01837192f, 0.19947129f, 0.16839463f, 
    0.16065328f, 0.21837187f, -0.03609059f, 0.12523516f, 0.17879266f, -0.36282870f, -0.20935696f, -0.19911784f, 
    0.09820375f, 0.29321510f, -0.24004099f, -0.07190049f, 0.18378215f, 0.24127413f, -0.01588434f, -0.06977510f, 
    0.15197274f, 0.21692298f, 0.02123401f, 0.20636216f, -0.01190423f, 0.13783261f, 0.22656783f, -0.21408218f, 
    0.05685093f, 0.07476240f, -0.08219727f, 0.05141931f, 0.15444627f, -0.16701137f, -0.06526577f, 0.06405877f, 
    -0.06809254f, 0.20549758f, 0.09114162f, 0.04650570f, -0.06903985f, 0.06214631f, 0.21983604f, 0.16711411f, 
    0.13341914f, -0.07464674f, 0.20852189f, 0.27215791f, 0.04024556f, 0.04152193f, 0.16818337f, 0.00597241f, 
    -0.02419044f, -0.03021836f, 0.02333463f, -0.00832775f, -0.01403831f, 0.01674573f, -0.04587748f, -0.05927546f, 
    -0.03168566f, -0.04853590f, 0.04165190f, -0.04105877f, 0.04914059f, -0.04185365f, 0.02533869f, -0.05307387f, 
    0.03801642f, -0.00129642f, -0.00309402f, 0.02554956f, -0.04853328f, 0.04908204f, 0.03291769f, 0.00248325f, 
    -0.04066237f, 0.03350701f, -0.05546655f, -0.01340115f, -0.01212880f, 0.00687007f, -0.05256484f, 0.00582183f, 
    -0.04141670f, -0.01231301f, 0.04085164f, -0.06293914f, -0.03573604f, -0.04009389f, -0.02136260f, -0.00416133f, 
    0.01865776f, -0.00041999f, -0.05621244f, 0.02448577f, -0.00027248f, 0.00773357f, -0.05521749f, 0.05091103f, 
    -0.02406518f, -0.06216927f, -0.00705273f, 0.00630498f, -0.04741583f, 0.04819220f, 0.04206519f, 0.00515355f, 
    -0.04795593f, -0.04626910f, -0.02796791f, 0.01163945f, -0.04506215f, 0.01490668f, 0.02219922f, -0.00326826f, 
    -0.02395168f, 0.04744565f, -0.05720503f, 0.04323308f, 0.03248902f, -0.05463033f, -0.00570806f, -0.05685445f, 
    0.00199184f, 0.00217545f, 0.00107361f, -0.05114844f, -0.02468647f, -0.00053898f, 0.02328777f, -0.05766852f, 
    0.00758703f, -0.00679456f, 0.02763416f, 0.03415322f, -0.05681820f, -0.05977071f, -0.03785729f, 0.02830224f, 
    -0.01236942f, -0.01814872f, -0.05673850f, -0.01223441f, -0.04042092f, -0.05849054f, 0.02655623f, 0.02660494f, 
    -0.03094306f, -0.02875300f, -0.03944259f, 0.00573570f, -0.03529828f, -0.03796199f, -0.03677772f, -0.05076593f, 
    -0.05002473f, 0.03449542f, -0.03221730f, -0.01824214f, -0.00597442f, 0.02831656f, -0.02550375f, 0.02627512f, 
    -0.01113192f, -0.03086736f, 0.00213356f, 0.04097973f, -0.00424382f, -0.04072461f, -0.01405895f, -0.00460641f, 
    -0.01866689f, -0.06371896f, 0.03188816f, -0.01414781f, 0.00285789f, -0.00438002f, -0.02774512f, -0.05109357f, 
    -0.00523104f, -0.02208782f, 0.02616512f, -0.02573166f, 0.01580658f, -0.00648454f, -0.05579863f, -0.00819744f, 
    -0.01341318f, -0.01438472f, 0.04315764f, 0.03561477f, 0.03555800f, -0.02403793f, 0.02123256f, -0.02064021f, 
    0.03432486f, -0.03205951f, -0.01005969f, -0.00050609f, -0.05917228f, -0.03814282f, 0.02148900f, 0.03617200f, 
    -0.03200664f, 0.02415012f, 0.03223605f, 0.00903966f, 0.00542141f, 0.03831572f, 0.04403867f, 0.00416092f, 
    -0.05010767f, 0.02651114f, -0.06206981f, 0.02204751f, 0.00751312f, -0.00739724f, 0.02324266f, 0.00773024f, 
    -0.02814471f, -0.01222457f, 0.03688469f, -0.04624177f, -0.05662986f, -0.01841505f, -0.05218540f, 0.00687546f, 
    0.03333369f, -0.01496378f, -0.00975864f, -0.06088439f, 0.04700582f, 0.00321911f, -0.00426808f, 0.01951179f, 
    -0.03342574f, -0.04681943f, 0.03941532f, 0.01817722f, -0.05287350f, -0.01917425f, -0.01521397f, -0.02734253f, 
    -0.00521459f, 0.02312467f, -0.02125791f, -0.00070673f, -0.01942603f, -0.03563183f, -0.02850687f, 0.04889690f, 
    -0.03798866f, -0.05061621f, 0.02224210f, -0.03197148f, 0.00151806f, 0.04115795f, 0.04128521f, -0.05795545f, 
    0.00850949f, -0.05841808f, -0.01904773f, 0.03596675f, 0.02279039f, -0.03923002f, -0.03341572f, -0.05969496f, 
    0.02993286f, 0.00921061f, -0.00926934f, 0.02182137f, 0.03642889f, -0.00179777f, -0.03440114f, -0.03840927f, 
    0.01742082f, 0.01838070f, 0.00682178f, -0.02042700f, 0.04458461f, -0.06186662f, 0.01339730f, 0.04151928f, 
    0.01457412f, -0.03350841f, -0.01919373f, -0.06041089f, -0.02145487f, -0.05843034f, 0.04609945f, 0.03256920f, 
    -0.05560314f, 0.04226102f, -0.02115886f, 0.00112453f, 0.03563784f, -0.00727794f, -0.06411093f, -0.01792549f, 
    0.04495273f, 0.05248095f, 0.02558544f, -0.00169845f, 0.02677530f, -0.05668209f, 0.01150759f, 0.03917846f, 
    0.01039524f, -0.04874673f, -0.02442163f, 0.05049382f, -0.01106508f, 0.03310889f, -0.05946045f, -0.06172916f, 
    -0.03898683f, -0.06290037f, -0.05859711f, -0.02098949f, 0.01871353f, -0.04326121f, -0.05467027f, 0.05609235f, 
    -0.05855151f, -0.01475798f, -0.01041519f, -0.02830573f, -0.05237296f, 0.05240759f, -0.01986863f, 0.01472492f, 
    0.00357415f, 0.03189265f, 0.01288388f, -0.05483381f, -0.02154618f, -0.05164588f, -0.05414826f, -0.00564484f, 
    0.00496962f, 0.04126756f, -0.04174810f, 0.00189666f, 0.01945900f, -0.05796343f, -0.02297236f, 0.03618034f, 
    -0.04993072f, 0.03626030f, -0.04927964f, -0.02435463f, 0.03609008f, -0.01847383f, 0.02843376f, -0.02362169f, 
    0.01623242f, -0.01613790f, 0.03630995f, -0.06344805f, 0.02065735f, -0.01148758f, -0.02984722f, -0.02093104f, 
    -0.02352979f, -0.04842105f, -0.04525902f, -0.05692540f, 0.00279988f, 0.03795797f, -0.04238173f, -0.06257936f, 
    -0.00666660f, -0.02127721f, -0.04591230f, -0.01497930f, 0.02768453f, 0.01174982f, 0.02928818f, 0.04789006f, 
    0.03597457f, 0.05244748f, -0.04521763f, -0.01504521f, -0.04084248f, -0.01930058f, -0.05199346f, 0.01037744f, 
    0.00114152f, -0.00444554f, -0.03096319f, -0.03563122f, 0.05537034f, -0.03479830f, 0.04410619f, 0.01375215f, 
    -0.00373213f, 0.02195351f, 0.02652943f, -0.03920882f, 0.00992160f, -0.04630824f, -0.01845602f, -0.01978213f, 
    -0.05625471f, -0.00450421f, -0.05124966f, 0.03144853f, 0.03048974f, -0.06214491f, 0.01034501f, -0.02638581f, 
    0.02434199f, 0.04217964f, -0.02757930f, -0.00315413f, -0.02212517f, 0.00873231f, 0.05137613f, 0.00584447f, 
    -0.04395745f, -0.04034103f, -0.06625048f, -0.04906246f, -0.05521803f, -0.03480669f, 0.01387442f, -0.06745515f, 
    -0.02744385f, 0.01920731f, -0.01492500f, -0.02693200f, 0.02539113f, 0.04493299f, 0.04597075f, 0.02482464f, 
    0.03225445f, 0.00280433f, -0.06268471f, 0.05370648f, 0.00646545f, 0.04813481f, 0.02516418f, -0.01380439f, 
    -0.00809237f, -0.03419963f, 0.02512488f, -0.02866175f, -0.03625640f, -0.01074197f, -0.00454951f, -0.04724973f, 
    -0.02612213f, -0.05299157f, 0.03190185f, 0.00415474f, -0.01847852f, -0.04330749f, -0.04613162f, 0.05770418f, 
    -0.01275093f, -0.06161745f, 0.02061178f, -0.04189333f, -0.02287723f, -0.00621299f, 0.02404762f, 0.02972818f, 
    -0.06446499f, 0.02685118f, -0.04807697f, -0.01888462f, 0.04975791f, 0.00386214f, -0.03447916f, -0.01399019f, 
    -0.03713873f, 0.04001360f, 0.02772732f, -0.04611743f, -0.05004017f, -0.02355029f, 0.02203045f, -0.00035614f, 
    -0.00325323f, 0.01759735f, -0.03189502f, -0.02334704f, -0.01603090f, -0.04269838f, 0.05321589f, 0.02335031f, 
    0.05037569f, -0.03401074f, 0.04232340f, -0.02784521f, 0.02162478f, -0.02560912f, -0.01343250f, 0.00646704f, 
    -0.04784735f, 0.02702644f, -0.04190102f, 0.03988030f, 0.01475974f, -0.03406320f, -0.05685388f, -0.02952015f, 
    -0.01340448f, 0.06454027f, -0.04560392f, -0.03804888f, -0.00844117f, -0.02920451f, -0.04826585f, -0.02782708f, 
    -0.02813260f, 0.02643458f, -0.00720752f, 0.01926840f, -0.05720597f, -0.00239970f, -0.03916819f, -0.03484045f, 
    -0.01065894f, -0.06071195f, 0.05666430f, 0.02685448f, 0.00593244f, 0.05022432f, 0.00874393f, -0.05852631f, 
    0.01740181f, -0.02927588f, 0.01250092f, -0.04079733f, -0.05908662f, 0.04604070f, 0.01298644f, -0.02397279f, 
    -0.04864679f, -0.02015897f, 0.01155086f, 0.00958253f, -0.01629704f, 0.02344652f, -0.00115970f, 0.02893883f, 
    0.05869341f, 0.05609588f, -0.03747477f, 0.04334336f, -0.01686493f, 0.02281287f, -0.03899911f, 0.00448836f, 
    0.03966394f, -0.04565877f, -0.01608275f, -0.05909839f, 0.00546264f, -0.01156792f, 0.05689488f, -0.03206249f, 
    -0.05059229f, 0.02960743f, 0.03271120f, -0.05893776f, -0.03802974f, -0.05837261f, -0.01748910f, 0.03830118f, 
    0.02620429f, -0.00824719f, 0.04021146f, 0.02249794f, -0.03080850f, -0.03740637f, 0.03361356f, 0.06695259f, 
    -0.04701927f, -0.01567594f, 0.00396566f, -0.03908270f, -0.02379853f, 0.02226160f, 0.02884376f, -0.01388661f, 
    -0.04193259f, -0.00868296f, 0.00120357f, 0.03724524f, -0.04235874f, 0.01075251f, -0.01671754f, -0.05180176f, 
    0.04942646f, 0.02678121f, 0.05048093f, -0.03652921f, 0.01791054f, -0.04719425f, 0.01462842f, 0.03424241f, 
    -0.04695885f, -0.03980624f, -0.05660440f, 0.01885252f, 0.05060740f, 0.03592234f, 0.03561353f, -0.00431090f, 
    0.01973671f, 0.01488128f, -0.02914866f, -0.01527986f, 0.05765984f, -0.05896653f, -0.03152790f, -0.01814642f, 
    -0.03708754f, -0.00625192f, -0.05544134f, 0.00581026f, 0.02403163f, -0.05545548f, 0.02129438f, -0.04377094f, 
    -0.04910596f, -0.01896135f, 0.00676691f, 0.00412598f, 0.04562717f, 0.04473953f, -0.05559025f, 0.02964247f, 
    0.02022858f, -0.03430434f, 0.04800619f, -0.03897955f, -0.05015203f, -0.02695366f, -0.02009500f, -0.05888464f, 
    -0.00114132f, 0.01496932f, 0.02707534f, -0.01606876f, -0.05186859f, 0.04181996f, 0.00508383f, -0.03922580f, 
    0.00087634f, 0.03061444f, -0.05644009f, -0.05153116f, 0.01968894f, -0.00695137f, 0.03271378f, -0.01080452f, 
    -0.02565289f, -0.00603473f, -0.04099079f, 0.03339484f, 0.00030383f, -0.06040159f, 0.01744191f, -0.00220334f, 
    -0.04089487f, 0.00705501f, 0.01977235f, -0.03689568f, -0.01585076f, 0.01735643f, -0.04424175f, -0.06048904f, 
    -0.06102038f, -0.02582793f, 0.05550219f, -0.05029661f, -0.02125850f, -0.00030820f, -0.01623639f, 0.04616251f, 
    -0.00063370f, -0.02775902f, -0.03654407f, -0.01694044f, -0.00077295f, -0.01977696f, 0.01532555f, -0.02877745f, 
    0.04888645f, -0.05511162f, -0.01362747f, -0.02249288f, -0.00305302f, 0.04503146f, -0.06331314f, -0.04334667f, 
    -0.01893320f, -0.01892809f, -0.01160547f, -0.03508117f, 0.04491187f, -0.00618310f, -0.03937585f, 0.04154485f, 
    -0.05062706f, 0.00190128f, 0.02207411f, 0.02644543f, 0.00194823f, 0.02466380f, -0.02969123f, 0.00038237f, 
    0.00528369f, -0.05523350f, -0.04995243f, 0.03447473f, -0.02375865f, 0.03930104f, -0.05721534f, -0.05523320f, 
    -0.02139571f, -0.02234915f, -0.01425861f, 0.02579865f, 0.01754003f, -0.00426469f, 0.05362979f, 0.01225934f, 
    0.05219119f, -0.05441818f, -0.01927207f, -0.05911536f, -0.01957236f, 0.04342988f, -0.04262643f, 0.00415302f, 
    -0.01469822f, -0.01391630f, 0.04713444f, -0.03363427f, 0.01841486f, 0.00920822f, -0.01334379f, -0.05250339f, 
    -0.01836344f, -0.03005814f, 0.03217297f, -0.00581633f, 0.03636044f, -0.00512693f, 0.02398833f, 0.04094902f, 
    -0.01008690f, -0.01018037f, -0.03934992f, -0.03744260f, -0.04412073f, -0.00014545f, 0.04905885f, -0.00940787f, 
    -0.00817828f, 0.04132999f, -0.03495298f, 0.06357963f, 0.02377744f, -0.04077880f, -0.06140192f, 0.02150938f, 
    -0.05747426f, -0.05485881f, 0.00825702f, -0.05528696f, 0.00601471f, 0.01392433f, -0.06425478f, -0.05580710f, 
    -0.05344615f, -0.01403396f, -0.05705292f, -0.03853644f, -0.03908630f, 0.03280109f, 0.00807808f, 0.01735014f, 
    0.01878853f, -0.04242123f, 0.04318945f, -0.02539039f, -0.04994900f, -0.02674324f, -0.05651220f, 0.03160527f, 
    0.00295180f, 0.02708365f, 0.04696527f, 0.03920171f, 0.05270980f, 0.03808994f, -0.00952408f, -0.03556034f, 
    0.01716461f, -0.05997783f, -0.06011438f, -0.05705523f, -0.03111316f, -0.01227408f, 0.00690606f, 0.00891703f, 
    -0.05155404f, 0.00430021f, 0.00613383f, 0.02024809f, -0.03390526f, -0.04335057f, 0.02293608f, -0.02585635f, 
    -0.01763316f, -0.04414139f, -0.01797461f, 0.03554541f, -0.00533931f, -0.05424039f, -0.02124736f, 0.04378435f, 
    0.02770540f, -0.01800660f, 0.00390561f, 0.01443829f, 0.04711521f, 0.03680727f, 0.02301970f, 0.03465090f, 
    -0.00086962f, -0.02109193f, -0.00133842f, 0.05128811f, -0.05119980f, 0.01438929f, 0.01396827f, -0.03407326f, 
    0.03489248f, -0.00353746f, 0.01205653f, 0.00719066f, 0.01857316f, 0.01818698f, 0.01438657f, 0.05076604f, 
    -0.01739249f, -0.00613215f, -0.01235617f, 0.03252921f, -0.06199000f, 0.04493482f, 0.03648452f, -0.03048544f, 
    -0.01008707f, 0.00780885f, -0.03632088f, -0.03695757f, 0.04890513f, 0.01905245f, -0.05902187f, -0.02388782f, 
    0.03257888f, 0.01409357f, -0.02767273f, 0.00685862f, 0.03035782f, -0.00459196f, 0.00999689f, -0.05931723f, 
    -0.03277968f, 0.00863877f, 0.02805117f, 0.03319971f, 0.03674317f, 0.00666662f, -0.03009108f, 0.02467135f, 
    0.00396218f, 0.04701406f, -0.00035476f, -0.04290291f, 0.03642917f, -0.01560164f, -0.00042222f, -0.01997050f, 
    0.01802501f, 0.03977457f, -0.01064510f, 0.02815919f, -0.02463502f, 0.03834186f, -0.02486601f, 0.00440381f, 
    0.01607081f, 0.03964563f, -0.00745545f, 0.03554824f, 0.01345112f, -0.03047904f, -0.01181342f, -0.03602393f, 
    0.01455680f, 0.01692888f, 0.00888227f, -0.06194137f, -0.01013096f, -0.04318535f, -0.04846525f, 0.04069735f, 
    -0.08652820f, -0.11250822f, -0.31408089f, -0.03263409f, 0.27948928f, 0.25674057f, 0.10780127f, 0.29420987f, 
    0.11744025f, 0.23591630f, -0.19074580f, 0.02398027f, -0.20285659f, -0.15096897f, -0.16615447f, -0.00856464f, 
    0.01510213f, -0.14523938f, -0.29287857f, -0.34259090f, 0.01947901f, -0.05838127f, -0.14790608f, -0.01969321f, 
    -0.05269307f, -0.08250874f, -0.18885601f, -0.15397286f, -0.00103846f, 0.05122353f, 0.03513877f, 0.13338614f, 
    -0.00483130f, -0.11008578f, 0.26118347f, 0.10801601f, 0.13394982f, -0.04564440f, -0.00495010f, 0.11970730f, 
    -0.00659497f, 0.15420339f, 0.20428655f, 0.32571498f, 0.13072464f, 0.07656024f, 0.14156453f, 0.30167648f, 
    -0.18548435f, 0.03082702f, -0.24765958f, -0.02271035f, -0.03538622f, 0.01342870f, 0.13978849f, 0.06683093f, 
    0.16774294f, 0.13798465f, -0.05023339f, 0.10253836f, -0.15726537f, -0.12696587f, 0.02563544f, 0.19367738f, 
    0.24607240f, 0.14186430f, 0.15092719f, 0.27108592f, 0.17576951f, 0.07869889f, 0.21460439f, 0.12864581f, 
    0.12801895f, 0.02668432f, 0.22985204f, 0.16080891f, 0.22690429f, 0.24835183f, 0.19041066f, 0.07841088f, 
    0.26293629f, 0.40734500f, 0.33956051f, 0.28691471f, 0.05529423f, -0.19455676f, -0.22108577f, 0.10512710f, 
    0.11652180f, 0.25189358f, -0.13149147f, 0.02816872f, 0.35485756f, 0.10165628f, 0.03525497f, 0.04613937f, 
    -0.00732447f, 0.18249919f, 0.01695467f, 0.28233740f, -0.41088873f, -0.44186494f, -0.11106617f, -0.09776992f, 
    -0.09543723f, 0.08239857f, 0.08537820f, 0.00590663f, -0.46862057f, -0.09230773f, 0.24242246f, 0.13376868f, 
    0.09210075f, -0.08303675f, 0.12451869f, 0.00617131f, -0.03134694f, 0.05910479f, 0.06379150f, 0.07913284f, 
    0.11303142f, -0.08574906f, -0.00297752f, 0.08696983f, -0.16311075f, -0.04193742f, 0.04097712f, 0.02198412f, 
    -0.00330466f, -0.05794454f, -0.00009265f, -0.06128121f, 0.22132939f, 0.26008901f, 0.26828256f, -0.38129795f, 
    -0.41984954f, -0.08928590f, 0.04396748f, 0.04424404f, -0.05100878f, -0.23818152f, -0.25225186f, -0.26518852f, 
    0.15035313f, 0.05860988f, 0.09978186f, 0.00842822f, 0.17014484f, 0.09594940f, 0.03585208f, 0.21143295f, 
    0.13006446f, 0.23427403f, 0.08273555f, 0.07760192f, -0.00232962f, 0.11941403f, -0.21376468f, 0.27228606f, 
    0.30033109f, 0.04845797f, -0.19920152f, -0.04650459f, 0.03391934f, -0.09641943f, -0.10485255f, -0.20503178f, 
    -0.10212079f, -0.28177685f, -0.21108791f, 0.02805713f, -0.00515149f, 0.02274251f, -0.08649877f, 0.09135333f, 
    0.06323905f, 0.02500702f, -0.04989137f, 0.14129812f, 0.08270196f, 0.22482041f, 0.11294208f, -0.08896863f, 
    0.05998258f, -0.01389466f, 0.21197374f, 0.00066478f, 0.04981476f, -0.04367808f, 0.05477542f, -0.04073630f, 
    -0.07818848f, 0.09294739f, 0.15929885f, -0.05115416f, -0.15702178f, 0.32983109f, -0.18695046f, -0.12683210f, 
    0.00505278f, 0.03758169f, -0.07551654f, -0.19756484f, -0.24780065f, 0.14484908f, -0.23368283f, 0.23221558f, 
    0.01231818f, 0.23216952f, -0.04174574f, 0.32333824f, 0.12600340f, -0.05329761f, 0.01281771f, 0.31295279f, 
    0.00173903f, 0.16100305f, 0.15684442f, -0.16285612f, -0.08726316f, -0.09580166f, -0.20290421f, -0.08601900f, 
    -0.17389131f, -0.13252513f, 0.15284677f, 0.37806123f, -0.03664635f, 0.15222798f, 0.07172588f, -0.03185854f, 
    0.13888191f, 0.14680150f, -0.06413049f, -0.23552468f, 0.07228587f, -0.16245754f, -0.15944622f, -0.24097471f, 
    -0.14480920f, -0.09688748f, 0.02358537f, -0.12024385f, 0.21416298f, 0.33061200f, -0.03080377f, 0.05819713f, 
    -0.05256226f, 0.11686235f, 0.15343419f, 0.35599998f, 0.07509594f, 0.01690670f, 0.21226297f, 0.03584078f, 
    0.05900884f, -0.00739484f, -0.05926235f, 0.02573295f, 0.09531008f, -0.13123608f, -0.40292791f, -0.45169622f, 
    0.12838125f, -0.08887316f, 0.01877323f, 0.18022570f, 0.15576367f, 0.16487552f, -0.13752806f, 0.12822609f, 
    0.01209494f, 0.03110798f, 0.06071381f, 0.07890741f, 0.05925837f, 0.13367635f, 0.28002274f, 0.16264229f, 
    0.01166238f, 0.37515002f, 0.04018819f, 0.04165954f, 0.08387031f, 0.02687811f, 0.07906383f, 0.03026506f, 
    0.03857531f, -0.02193361f, -0.02846278f, 0.02016961f, -0.02220012f, 0.02367171f, -0.00396304f, -0.05655941f, 
    -0.03790069f, -0.02681823f, -0.05127062f, 0.05303323f, -0.04250215f, 0.00961676f, -0.05936644f, -0.01205368f, 
    0.02662977f, 0.00634289f, 0.02353944f, -0.05047082f, 0.02557036f, 0.01792835f, -0.00382353f, -0.06347345f, 
    -0.00199146f, -0.00780439f, -0.05646818f, -0.01032642f, 0.04255490f, 0.03908928f, -0.05990306f, 0.00457825f, 
    -0.05184862f, -0.00394179f, -0.03168875f, -0.05742900f, -0.04629675f, -0.01459268f, -0.01668245f, -0.01348415f, 
    0.03776308f, 0.00503387f, 0.00556533f, -0.06551551f, 0.00151218f, 0.00360650f, -0.00885018f, 0.01100137f, 
    -0.00473645f, -0.01043751f, 0.01271063f, 0.01399050f, -0.03783451f, -0.00103168f, -0.02488823f, -0.03792475f, 
    -0.05415319f, 0.02667356f, -0.06026002f, -0.04491255f, -0.01212747f, -0.03992964f, 0.03963660f, -0.02732130f, 
    -0.05190343f, -0.00858666f, 0.01075365f, 0.04003650f, 0.02137496f, -0.07421651f, -0.01904276f, -0.06712678f, 
    -0.05820466f, 0.03650509f, -0.01262842f, -0.04229425f, -0.04434514f, 0.02532919f, -0.05882816f, 0.04716587f, 
    0.01709914f, -0.00946810f, -0.01071377f, 0.01401440f, 0.02230041f, -0.06086544f, 0.02140966f, -0.06900897f, 
    -0.04201165f, -0.02930784f, -0.05697130f, -0.02749078f, -0.02634677f, -0.00427736f, -0.02613934f, 0.00390872f, 
    -0.00068276f, -0.04883733f, -0.07265708f, -0.07137398f, -0.00317680f, -0.04084064f, 0.01443142f, 0.00344758f, 
    0.02112988f, 0.02494758f, 0.04911359f, -0.04091153f, -0.01513220f, 0.02908909f, 0.02025724f, -0.04629416f, 
    0.00946471f, -0.03506471f, -0.07030009f, -0.01773860f, -0.03028340f, -0.03905550f, -0.06767154f, -0.05671097f, 
    -0.06219688f, -0.02756229f, 0.03254559f, -0.05234554f, -0.02712888f, -0.05976458f, -0.02322618f, -0.05444706f, 
    0.01162943f, -0.07320186f, -0.06183671f, -0.03862049f, -0.00718368f, 0.03423132f, -0.00464912f, -0.04508809f, 
    -0.01667242f, 0.02408268f, -0.00525788f, -0.01567415f, -0.01445328f, 0.03594770f, 0.04621541f, -0.05896789f, 
    0.04063091f, -0.05539549f, 0.04111828f, 0.03706050f, -0.02053762f, -0.01730265f, -0.04813961f, 0.04196110f, 
    -0.05804717f, 0.01578361f, -0.05987418f, -0.00687062f, 0.00761273f, 0.01680810f, 0.04216993f, -0.05399405f, 
    -0.02800763f, 0.00093490f, -0.03104415f, -0.02596666f, 0.03966543f, 0.04808888f, -0.00814536f, -0.03669149f, 
    -0.02499421f, -0.05107600f, 0.03643526f, 0.01518647f, -0.06043809f, -0.03469449f, -0.06844223f, -0.00486850f, 
    -0.00377898f, -0.05696566f, -0.02892950f, -0.03765555f, 0.03281361f, 0.02236413f, -0.03530282f, -0.00322601f, 
    0.00885249f, 0.04502868f, 0.01039296f, 0.04348738f, 0.00416563f, -0.01909975f, 0.03670766f, -0.04553106f, 
    0.01229392f, -0.04082857f, -0.06775747f, 0.03206973f, -0.01729108f, -0.06276798f, -0.02048932f, -0.04734150f, 
    0.04780477f, 0.03215994f, -0.03079494f, 0.03065167f, 0.03251709f, -0.04907186f, 0.00056924f, -0.00641310f, 
    -0.06257794f, 0.03003305f, -0.04607849f, 0.01288725f, 0.00322497f, -0.07477698f, -0.01740322f, -0.05256945f, 
    -0.03486144f, 0.01467409f, -0.00759738f, -0.02959740f, -0.06957107f, 0.02584763f, -0.00487789f, -0.00764986f, 
    -0.05423515f, 0.02221464f, -0.06352582f, -0.01248848f, 0.00444086f, 0.00087214f, -0.03483438f, 0.01544413f, 
    -0.02863090f, -0.02797368f, 0.00854950f, 0.02007668f, -0.06457519f, 0.02646152f, 0.04671394f, -0.03756421f, 
    -0.02552206f, -0.04362596f, -0.02794262f, -0.01091263f, 0.03205149f, -0.06343441f, -0.04298499f, 0.01010091f, 
    -0.04488409f, -0.01974067f, -0.04618008f, 0.03368869f, -0.05831928f, -0.03531338f, -0.01439708f, -0.03052969f, 
    -0.04261867f, -0.03931909f, -0.02764494f, -0.00569640f, 0.04628214f, -0.05688205f, 0.05306640f, 0.03961470f, 
    0.03129300f, -0.04013001f, 0.03293033f, -0.04997742f, -0.03518285f, -0.03175283f, -0.02772149f, 0.01844314f, 
    -0.01498104f, -0.01475408f, -0.04686273f, 0.03394567f, 0.03957406f, 0.04172399f, -0.04112675f, -0.03849158f, 
    0.02797031f, -0.02714776f, 0.02090557f, 0.03682890f, 0.01310628f, 0.03980554f, -0.01114049f, -0.06019453f, 
    -0.19350161f, -0.10710271f, -0.35414344f, 0.03669725f, 0.04579680f, 0.10057925f, 0.19679902f, 0.26063746f, 
    0.12934561f, 0.03185450f, -0.49887276f, -0.01652911f, -0.08681338f, 0.04653489f, 0.10228071f, -0.06499128f, 
    0.11589798f, 0.27643797f, -0.62700260f, -0.73850560f, -0.65417033f, 0.11375131f, 0.04660464f, 0.03366859f, 
    -0.04846467f, 0.09475662f, 0.04008463f, 0.05854706f, -0.41218621f, -0.35983956f, -0.05416013f, -0.07987010f, 
    0.12949461f, -0.03291941f, 0.04931632f, -0.03514747f, -0.09505845f, 0.13310309f, -0.03047659f, 0.06457155f, 
    0.08336836f, 0.10519045f, 0.18712637f, 0.17263372f, 0.12716660f, -0.09159781f, -0.47414124f, 0.10834139f, 
    0.05458689f, 0.07558288f, 0.11671656f, -0.08066712f, -0.05601031f, -0.00835499f, -0.39349106f, -0.14679258f, 
    0.31207463f, -0.06600700f, 0.16650049f, 0.06107826f, 0.01254253f, -0.00055129f, -0.00556174f, 0.06503022f, 
    -0.11339200f, -0.14852504f, -0.12750201f, 0.09352872f, 0.10164174f, -0.02918369f, 0.23192519f, -0.15826704f, 
    0.32869351f, 0.05386962f, 0.14558385f, 0.11263221f, 0.12451418f, 0.21697260f, 0.17267497f, 0.22445564f, 
    -0.03458080f, -0.01033956f, -0.08425795f, -0.13091452f, -0.20337625f, 0.11265978f, 0.09533244f, -0.02901303f, 
    0.09004088f, 0.19483969f, -0.09126787f, -0.24270412f, -0.08911342f, -0.09990656f, 0.07595250f, 0.01850395f, 
    0.18728480f, 0.12765612f, -0.00305981f, -0.32935026f, -0.20801637f, -0.19345172f, -0.11815553f, -0.05527481f, 
    -0.05123738f, 0.08618423f, 0.08468971f, 0.20571880f, -0.35789540f, -0.28008854f, -0.00070864f, -0.08860166f, 
    -0.12929122f, -0.01291801f, -0.04818093f, 0.02762409f, 0.05518482f, 0.27153984f, -0.03108558f, -0.04673123f, 
    0.01613137f, 0.11612984f, 0.12769458f, -0.03804782f, 0.12577967f, 0.19568248f, -0.14653212f, -0.01857514f, 
    -0.03375778f, -0.06974564f, 0.07949495f, -0.02143490f, 0.02735975f, 0.20061430f, 0.14393760f, -0.29287469f, 
    -0.02681096f, 0.29345542f, -0.00305969f, -0.12606780f, -0.17942069f, -0.04553680f, -0.13598245f, 0.18260528f, 
    -0.05654833f, -0.08631647f, -0.09533850f, -0.04432179f, 0.02502193f, -0.11162155f, -0.03845006f, 0.16582187f, 
    0.25705343f, -0.12230347f, 0.11400340f, 0.17984316f, 0.15695225f, -0.01026524f, 0.07827268f, 0.08101677f, 
    0.23263529f, 0.11468207f, -0.01592772f, -0.02507138f, -0.07538613f, -0.02677415f, -0.26089051f, -0.06575639f, 
    -0.07478107f, -0.10983652f, 0.13366577f, -0.32735953f, -0.17133950f, -0.02030678f, 0.02590324f, -0.01575074f, 
    -0.24249361f, 0.03584371f, -0.09446573f, 0.21214385f, 0.36052683f, -0.08099584f, 0.12946749f, 0.18352683f, 
    0.11789527f, 0.23628342f, 0.24330670f, -0.06021065f, 0.20374860f, 0.07883307f, -0.21118146f, -0.06456356f, 
    -0.13084145f, -0.13023724f, -0.05489454f, 0.08838302f, 0.25954059f, 0.14472754f, 0.05777217f, 0.03952800f, 
    0.07380193f, 0.00503893f, -0.03925886f, -0.01997585f, 0.15757306f, 0.16626848f, 0.17920472f, -0.30151054f, 
    -0.56173193f, 0.07770950f, 0.02488858f, 0.04398938f, 0.29056847f, 0.16541772f, -0.05347080f, -0.14933744f, 
    0.11657210f, -0.00158646f, 0.08740898f, 0.15819857f, -0.00565549f, -0.02639156f, -0.01762314f, -0.01280969f, 
    0.15777551f, 0.12729754f, -0.29326278f, -0.29207107f, 0.01794422f, 0.07112105f, 0.01563459f, 0.05172731f, 
    0.11735789f, 0.16906548f, 0.11946815f, -0.35713816f, -0.08420909f, -0.05390336f, -0.11869681f, 0.02375506f, 
    -0.00491663f, 0.24639322f, -0.14309126f, -0.15791830f, 0.10386924f, -0.36227384f, 0.10667704f, 0.03915035f, 
    0.14559089f, 0.10976034f, 0.13478950f, -0.12912953f, 0.12638257f, -0.27618414f, 0.37060380f, 0.19824047f, 
    0.01737968f, 0.06909160f, -0.02833404f, 0.02920071f, -0.32241842f, -0.18043388f, 0.01192694f, -0.10390766f, 
    -0.12377905f, -0.30920437f, -0.06444658f, -0.00161618f, 0.01640965f, 0.22249281f, -0.18269496f, 0.02504743f, 
    -0.05900433f, 0.04828653f, -0.09739983f, 0.00051055f, -0.03234372f, 0.05934322f, -0.19389607f, -0.14999966f, 
    -0.04562508f, 0.33313179f, 0.22257796f, 0.02993710f, 0.15542990f, 0.08200696f, 0.06398560f, 0.03695147f, 
    -0.29996809f, -0.00895945f, 0.12776047f, -0.01203394f, 0.07840070f, 0.00506901f, -0.05100873f, 0.17794497f, 
    -0.14928934f, -0.01350887f, 0.19761196f, -0.16747095f, -0.01330106f, -0.16355641f, -0.04613920f, -0.01606733f, 
    -0.02782257f, -0.16421670f, 0.02470113f, -0.22769527f, 0.07049970f, 0.21194369f, -0.13713627f, -0.10744540f, 
    0.06182288f, -0.10171740f, -0.07965914f, -0.32397583f, -0.19694433f, 0.10309987f, 0.10799285f, -0.03139542f, 
    -0.04436082f, -0.06190715f, -0.18047388f, 0.14696011f, -0.00289094f, -0.08116068f, 0.23923032f, 0.22375274f, 
    0.08909237f, -0.01745488f, -0.08646356f, 0.15171966f, -0.06614211f, -0.13502373f, 0.12794791f, 0.02398195f, 
    0.07726004f, 0.02778292f, -0.11450227f, -0.05357681f, 0.06629384f, 0.18520674f, 0.12652954f, 0.29231867f, 
    0.40454820f, 0.09763945f, 0.04255886f, 0.12819833f, 0.05664676f, -0.01959451f, 0.01073737f, -0.00909659f, 
    -0.23000459f, -0.11902723f, 0.03823337f, -0.07568049f, 0.03864822f, 0.09119345f, -0.09373759f, 0.10588052f, 
    0.45018420f, 0.24132754f, 0.17040607f, 0.23107167f, -0.12619835f, -0.09444308f, -0.02673936f, 0.23345426f, 
    0.08561849f, -0.56355125f, -0.32282409f, -0.06204744f, -0.12625615f, -0.01808693f, -0.23194118f, -0.07381596f, 
    0.25350383f, 0.00843774f, 0.09385389f, -0.09986839f, 0.15785444f, 0.02899235f, -0.11134626f, -0.00788705f, 
    0.00737354f, -0.02860057f, 0.02673817f, -0.19531155f, 0.26877993f, -0.11375311f, -0.10612877f, 0.00725572f, 
    -0.00050525f, -0.02571806f, 0.06010166f, -0.20436102f, 0.00769967f, 0.04069752f, 0.04784649f, -0.04065500f, 
    -0.15392214f, -0.07020123f, 0.31233609f, -0.08779339f, -0.06374022f, 0.00719450f, -0.10620874f, -0.01526986f, 
    0.13960010f, -0.04355636f, 0.05252493f, 0.11596530f, 0.02080473f, -0.05533579f, 0.03628934f, -0.35230407f, 
    -0.00463901f, 0.35341883f, -0.01718737f, 0.01631455f, 0.02682409f, -0.06749734f, 0.11943542f, -0.44982156f, 
    0.40224200f, 0.57139772f, -0.06549240f, -0.15959820f, -0.05351656f, 0.04173896f, 0.01758546f, 0.04382863f, 
    -0.06709804f, 0.03302504f, -0.04175296f, 0.10285341f, 0.00019658f, -0.01833939f, 0.03446906f, -0.00119577f, 
    0.06936190f, 0.00542767f, 0.10294200f, 0.14417034f, 0.16171053f, 0.04762938f, 0.10153498f, -0.00132602f, 
    -0.03339100f, -0.02817101f, -0.15016079f, -0.12533006f, 0.09830363f, 0.00762121f, 0.05897430f, -0.01066565f, 
    -0.13419142f, -0.35009253f, -0.16618764f, -0.03712693f, 0.15957905f, 0.13127635f, -0.32608071f, -0.19953893f, 
    -0.14477158f, -0.05413715f, 0.09457053f, 0.08275983f, 0.08477981f, 0.32608035f, 0.08619313f, -0.01080783f, 
    0.11741810f, -0.06465624f, 0.15364748f, 0.07383939f, 0.34410235f, 0.10669611f, -0.12722564f, 0.04875540f, 
    0.02867191f, -0.31735495f, 0.20598929f, -0.08423214f, 0.03023696f, -0.08101162f, -0.28807059f, -0.06221308f, 
    0.28209317f, 0.22180560f, 0.15513729f, -0.26674503f, 0.16018173f, 0.10977343f, -0.10279693f, -0.60226220f, 
    -0.33401743f, -0.16875313f, 0.17796290f, -0.01314211f, -0.14569888f, -0.26802698f, -0.17005284f, 0.00251204f, 
    -0.40920165f, 0.14263466f, 0.44199145f, 0.16118744f, -0.00832262f, 0.04255571f, -0.03975415f, 0.07660576f, 
    0.06003539f, -0.15467480f, -0.14745955f, 0.00624755f, 0.05857590f, 0.02425692f, 0.05971047f, -0.05586223f, 
    0.02186137f, 0.14406739f, 0.02134974f, -0.09661590f, 0.14606267f, 0.07855999f, -0.35213876f, -0.26368845f, 
    -0.01646757f, -0.01909757f, 0.16097195f, -0.01072862f, -0.80442351f, -0.34220847f, 0.19354008f, 0.01421081f, 
    -0.02191650f, -0.09480467f, 0.14377047f, 0.15228485f, -0.01233593f, -0.00531882f, 0.13232012f, 0.10860027f, 
    -0.10557859f, -0.11775576f, 0.00095813f, -0.32588878f, 0.10246307f, -0.34020641f, 0.16412221f, -0.35511079f, 
    0.11938744f, -0.06508259f, 0.02449049f, -0.05274475f, 0.05670285f, -0.18326329f, -0.11708829f, -0.10648762f, 
    0.17666003f, -0.27871701f, -0.38891622f, -0.13227209f, -0.13356404f, -0.05302110f, 0.12281865f, -0.13064909f, 
    0.16545102f, 0.00877675f, 0.01788020f, 0.00013229f, 0.05961443f, 0.17422661f, 0.01003110f, -0.04355584f, 
    -0.01888479f, -0.02787445f, -0.01667383f, 0.03038399f, -0.04166180f, -0.00466856f, 0.04332156f, 0.01196122f, 
    0.02232192f, -0.03308246f, -0.06154968f, -0.03535253f, 0.02994186f, -0.06654347f, 0.02330477f, 0.03106458f, 
    -0.00587773f, -0.00722161f, 0.03540362f, 0.03865356f, 0.01496771f, -0.05407031f, 0.02910380f, 0.03997996f, 
    0.01387892f, 0.03630935f, -0.01217178f, -0.02683959f, 0.02750392f, 0.02391755f, -0.01799255f, -0.03720472f, 
    -0.05772461f, -0.01594806f, -0.01066229f, 0.03531744f, 0.00671820f, 0.03381063f, 0.00339076f, 0.00950941f, 
    0.01496092f, -0.05220317f, -0.01424860f, -0.06181312f, -0.06161072f, -0.01010063f, -0.04392216f, -0.02117554f, 
    0.04376618f, -0.04237241f, -0.00088849f, -0.01234318f, -0.06176668f, 0.05526056f, -0.07181210f, 0.03597525f, 
    -0.04883051f, -0.01528002f, -0.00302666f, -0.01352149f, -0.01102796f, -0.05006129f, 0.01664787f, 0.05666770f, 
    -0.01941822f, 0.02984829f, -0.06233910f, 0.01681837f, -0.04380053f, -0.01857776f, -0.03966116f, 0.03299381f, 
    0.03874601f, 0.01310502f, 0.04168828f, 0.05676045f, -0.03366897f, 0.05180011f, -0.04234966f, -0.03558286f, 
    -0.04222518f, 0.01927972f, -0.00316348f, 0.02236388f, 0.03725881f, -0.03697312f, -0.00337402f, 0.04278311f, 
    -0.03360355f, 0.02838517f, 0.04175906f, 0.03384884f, -0.04153019f, -0.03823390f, -0.03096261f, -0.03620701f, 
    -0.05749433f, -0.01448900f, -0.04171454f, 0.02094665f, 0.01348404f, -0.03109911f, -0.03595752f, -0.05779255f, 
    0.02706111f, 0.00271532f, -0.03577637f, -0.01661904f, 0.03229368f, -0.03537975f, 0.02590436f, -0.06164292f, 
    -0.06015357f, -0.02869490f, -0.05179559f, 0.02496338f, -0.05279758f, -0.03662056f, 0.03202409f, 0.04745993f, 
    -0.03368004f, -0.04283066f, -0.05925266f, 0.03645182f, -0.02877439f, -0.03857655f, -0.02596838f, -0.03328651f, 
    0.03548992f, 0.03228807f, -0.02638502f, -0.01677702f, -0.02944816f, 0.01822104f, -0.01449179f, -0.02998219f, 
    0.05190612f, -0.02025961f, -0.04778298f, -0.00079549f, 0.00653465f, -0.06527451f, -0.00577734f, -0.04359831f, 
    0.02221358f, 0.03627620f, -0.06123291f, 0.01001680f, -0.02398561f, -0.01076925f, -0.04875057f, 0.02822032f, 
    0.04707542f, -0.06262437f, 0.04361762f, -0.05465176f, -0.06324695f, 0.00020793f, 0.05095438f, 0.01492648f, 
    -0.00022387f, 0.01231479f, -0.01817834f, -0.06523428f, -0.04885546f, -0.01905695f, -0.05361791f, -0.04042697f, 
    0.01333226f, -0.04910411f, 0.05226933f, 0.04340727f, -0.01237816f, -0.00039111f, 0.02302393f, 0.02365925f, 
    0.05109314f, -0.03610528f, -0.00481766f, -0.01955458f, 0.04890466f, -0.02144297f, 0.02130499f, -0.01898612f, 
    -0.04381291f, 0.04729794f, 0.01503597f, -0.03995906f, 0.05195985f, 0.03672232f, -0.03982097f, 0.04244043f, 
    0.02520767f, -0.05213619f, -0.00166268f, 0.03585113f, -0.02731137f, -0.01039080f, -0.03840251f, -0.01243719f, 
    0.00003152f, -0.05704595f, 0.02940407f, -0.02198081f, -0.02306592f, -0.04757601f, 0.00892037f, -0.04264650f, 
    -0.03416659f, -0.04969360f, 0.02140453f, 0.00944599f, 0.02725407f, -0.03617477f, -0.02296818f, 0.00129861f, 
    0.01162692f, 0.02489137f, 0.04151976f, -0.04664023f, -0.05494838f, -0.03878121f, 0.04311465f, -0.03461447f, 
    -0.00192317f, -0.03537660f, -0.01773541f, -0.05430054f, -0.06382251f, 0.02023594f, -0.06001623f, 0.04900813f, 
    0.00677390f, 0.03874417f, -0.00056346f, -0.00399457f, 0.05267664f, 0.04126111f, -0.02787868f, -0.05042833f, 
    -0.04403925f, 0.01978206f, -0.02119118f, -0.05673143f, 0.00880751f, 0.01377013f, -0.03326822f, 0.01614106f, 
    -0.02025595f, -0.01153660f, -0.01909702f, 0.03403380f, -0.01665751f, 0.02505864f, 0.01956113f, 0.02747076f, 
    -0.05672062f, 0.00695907f, -0.00231420f, -0.03070596f, 0.00860327f, -0.01286545f, -0.04051892f, 0.03260519f, 
    -0.00102480f, -0.04770469f, 0.03939079f, -0.01888825f, 0.03306906f, -0.00779796f, -0.03207652f, 0.02597067f, 
    -0.03351878f, -0.02127464f, 0.03998576f, 0.04535940f, -0.00436046f, 0.03091034f, 0.02404104f, 0.01412586f, 
    -0.01648044f, 0.04320809f, -0.00557290f, -0.02957962f, -0.05125203f, -0.03701262f, 0.04700331f, 0.03964147f, 
    0.22484766f, 0.22627734f, 0.16656311f, -0.13412474f, 0.01104689f, 0.03829692f, 0.02443002f, -0.06502232f, 
    -0.16293833f, 0.30885425f, 0.29741809f, 0.29637021f, 0.11811354f, 0.12286766f, 0.18753041f, 0.13342166f, 
    -0.04029767f, -0.06890208f, -0.38969457f, 0.13691893f, 0.23601970f, 0.05840647f, 0.06120816f, 0.06185211f, 
    0.16661587f, -0.11698098f, -0.51833165f, -0.27528125f, -0.45998424f, -0.02652755f, -0.03392316f, 0.02080883f, 
    0.06899492f, 0.18789703f, 0.11900553f, 0.07589516f, 0.34788835f, 0.46823561f, 0.43865481f, 0.02815147f, 
    0.05704328f, 0.06742205f, 0.04999573f, 0.02636714f, -0.04891825f, 0.09791669f, 0.26678839f, 0.10394118f, 
    0.04470211f, 0.08546791f, 0.08068339f, 0.26304343f, -0.03648684f, 0.00888035f, 0.39100587f, 0.40930694f, 
    0.38508859f, 0.19977394f, -0.16904320f, 0.07849501f, 0.12252993f, 0.03918950f, 0.12952770f, -0.01884456f, 
    -0.45009622f, -0.19291346f, -0.04565478f, 0.11025054f, 0.10408309f, 0.19666091f, -0.22284502f, 0.14915423f, 
    0.05365021f, -0.20445998f, -0.31454408f, -0.17291673f, 0.07391758f, -0.20508696f, 0.19346212f, -0.18710746f, 
    0.10335223f, -0.72150004f, -0.14761479f, 0.84457630f, 0.03991850f, -0.11881530f, -0.44074664f, -0.01790221f, 
    0.15539423f, -0.14308177f, -0.11896846f, -0.21978815f, -0.00188154f, 0.08378801f, 0.04260604f, 0.11433522f, 
    0.15871322f, -0.03224187f, -0.01854772f, 0.46976855f, 0.51882321f, 0.51221359f, 0.06154368f, 0.09758577f, 
    0.04292706f, 0.19865166f, 0.00891453f, -0.04745944f, -0.11870313f, -0.15455657f, 0.01830810f, 0.02769250f, 
    0.11268254f, 0.08325282f, 0.04339482f, -0.13654268f, -0.24736391f, -0.09549706f, 0.13328806f, 0.02190908f, 
    0.05101079f, 0.03896135f, 0.16325510f, -0.14349239f, -0.15508591f, -0.31696934f, 0.14627428f, 0.23874587f, 
    0.14944106f, -0.00216123f, 0.18331096f, 0.02026927f, -0.00588051f, -0.07174183f, -0.01362491f, 0.33957538f, 
    -0.04743346f, -0.27277422f, -0.01255744f, -0.19058128f, -0.30541873f, 0.07618543f, -0.01101101f, 0.10715151f, 
    -0.09545748f, -0.09016383f, -0.03473755f, 0.28731740f, 0.18824613f, -0.04434283f, -0.16715294f, 0.09155895f, 
    0.08504485f, 0.23398888f, 0.32432002f, 0.21420319f, 0.13303064f, -0.13167100f, -0.11269652f, -0.00814941f, 
    0.02658730f, 0.04156058f, 0.11519482f, -0.14488795f, -0.00323459f, 0.10793275f, 0.11473375f, 0.14777903f, 
    -0.28661194f, -0.08704998f, -0.42905250f, 0.03441961f, -0.02051193f, 0.05356136f, 0.06538723f, -0.35388884f, 
    -0.10559398f, 0.04066507f, 0.05237130f, 0.21857561f, 0.05498882f, -0.02960334f, -0.03529984f, 0.01282462f, 
    0.05376511f, 0.06438746f, 0.14156005f, 0.13610655f, 0.14654343f, -0.06887135f, 0.01669712f, -0.10291820f, 
    0.19704759f, 0.05737500f, 0.02786085f, 0.09742259f, -0.13265696f, 0.19240147f, 0.02853056f, -0.14529513f, 
    0.00772158f, -0.19617793f, -0.11900298f, -0.03066393f, -0.02285973f, -0.23415992f, -0.27921399f, -0.44834539f, 
    0.03135401f, -0.38460070f, -0.19875830f, -0.10917754f, -0.03838230f, 0.15097950f, 0.15787491f, -0.01525283f, 
    0.02783253f, 0.03129618f, -0.40545139f, 0.10249367f, -0.04767541f, 0.11047072f, 0.08778480f, -0.06537407f, 
    -0.06761356f, -0.29426464f, -0.34807989f, -0.02425520f, 0.09570435f, 0.00640495f, 0.09424666f, 0.10848025f, 
    0.18744063f, -0.02986907f, 0.17790174f, -0.27102444f, -0.29350585f, -0.16272238f, 0.07562838f, -0.07836638f, 
    0.11653797f, -0.45646206f, -0.12928598f, -0.05983611f, -0.49742231f, -0.75516289f, -0.25943947f, 0.08731026f, 
    0.10237282f, 0.16150509f, -0.13372484f, 0.11831986f, 0.13274392f, 0.06271667f, -0.12540711f, -0.01970813f, 
    -0.07373787f, 0.14805113f, 0.14009623f, 0.04905105f, 0.02542667f, 0.24614456f, 0.36177677f, 0.44481429f, 
    -0.00463395f, 0.15361294f, 0.14862017f, -0.03701245f, -0.05448050f, 0.02601650f, 0.02733286f, -0.03245231f, 
    0.03559993f, 0.01007563f, -0.22822879f, -0.42762700f, -0.19824730f, 0.10915978f, -0.13815823f, 0.21846694f, 
    -0.00322433f, -0.10076807f, 0.06901722f, -0.04365474f, 0.14360611f, 0.04708982f, 0.03796028f, -0.08877081f, 
    -0.13866159f, 0.21908359f, 0.08641294f, 0.09980196f, -0.20936878f, -0.10903754f, -0.17368582f, 0.04301473f, 
    -0.05096595f, 0.53920764f, 0.15151422f, 0.39008763f, 0.03269178f, 0.03910475f, 0.00723376f, 0.12269433f, 
    -0.05852859f, 0.12707391f, -0.27482510f, -0.09633649f, -0.19060317f, 0.21120352f, -0.09475233f, -0.21201818f, 
    0.04868809f, 0.07061445f, -0.02564000f, 0.13960436f, -0.26110741f, 0.04007377f, -0.11592715f, 0.04785711f, 
    0.14624274f, 0.09535081f, 0.15920727f, 0.18306205f, 0.02176806f, 0.23626004f, 0.19752687f, -0.02137013f, 
    -0.10035002f, -0.12827626f, -0.00516059f, 0.03246477f, 0.15550373f, 0.13187505f, 0.31033298f, 0.45652175f, 
    0.12082807f, 0.04068901f, 0.20354511f, 0.02550318f, -0.03034093f, 0.04081339f, 0.27029917f, 0.10129234f, 
    0.12621246f, -0.14615640f, 0.08760766f, 0.10012443f, -0.01755359f, 0.08266447f, -0.05227778f, 0.11032921f, 
    -0.55837005f, -0.39039236f, 0.16492447f, 0.06163019f, 0.10954089f, 0.06292633f, -0.00046774f, 0.10945330f, 
    0.75691742f, -0.27205071f, -0.31345284f, -0.22723638f, -0.06853994f, -0.14216249f, -0.05340673f, 0.05113615f, 
    -0.18822417f, -1.61663103f, -0.52372086f, 0.27517539f, 0.11492519f, -0.08566743f, 0.09771262f, 0.22506052f, 
    0.12176307f, 0.02446830f, 0.22953433f, -0.33131939f, -0.38176572f, 0.05086757f, -0.09819104f, -0.05956784f, 
    -0.00770090f, 0.02768811f, 0.01110376f, 0.37697122f, 0.44164854f, 0.23681901f, -0.32107508f, 0.26047581f, 
    -0.14759728f, 0.10756131f, 0.00437424f, 0.23760796f, 0.09852969f, -0.32569766f, -0.64424634f, -0.07814532f, 
    0.02000004f, -0.02922679f, -0.03594867f, 0.03206430f, -0.10768164f, -0.15094629f, 0.14956160f, -0.22813073f, 
    0.11179140f, -0.11733848f, -0.06479170f, -0.01949760f, 0.00684234f, -0.17980471f, 0.11049512f, 0.01488758f, 
    0.09785462f, -0.03460616f, 0.06515743f, -0.01394962f, 0.00336828f, 0.30645630f, 0.05664646f, 0.37537810f, 
    -0.45108169f, -0.45617834f, 0.09349225f, 0.13953087f, 0.23568140f, 0.02701103f, 0.07292566f, 0.06522588f, 
    0.03235053f, 0.06128244f, -0.14317420f, -0.11453334f, 0.12346838f, 0.05443803f, 0.07527861f, 0.10629448f, 
    0.04420191f, -0.09634037f, -0.11800551f, 0.15770708f, -0.09527196f, 0.09865396f, 0.09814571f, 0.09165122f, 
    -0.01801997f, 0.00137765f, 0.43555641f, -0.11433645f, 0.26800707f, -0.21844129f, 0.04918878f, 0.11717464f, 
    0.21330313f, 0.02339092f, -0.04773327f, -0.12468421f, -0.28795353f, -0.24468379f, 0.05225021f, 0.04083779f, 
    0.17809117f, 0.04389596f, 0.31010568f, 0.17577547f, 0.27782872f, -0.15587746f, 0.55399424f, -0.09069833f, 
    0.14498973f, 0.07302155f, 0.29338729f, -0.19496368f, 0.16872245f, 0.20918737f, -0.17420335f, -0.30430633f, 
    -0.02316953f, 0.01173364f, 0.17308655f, -0.06676514f, 0.15128933f, -0.07917086f, 0.04384827f, -0.50452387f, 
    0.18973118f, -0.22132638f, -0.08677188f, 0.08009364f, 0.21786939f, 0.13654627f, 0.14860752f, -0.45975259f, 
    -1.34139514f, -0.64181787f, -0.08345135f, -0.04847239f, 0.23091312f, 0.01982957f, 0.00310608f, -0.16625480f, 
    0.49276596f, 0.07260291f, 0.29033217f, -0.06586517f, -0.08715963f, -0.11063049f, 0.10156163f, 0.00542011f, 
    0.09711475f, 0.15102224f, -0.15905604f, -0.43940261f, -0.12580594f, -0.05720382f, -0.30846074f, -0.02058072f, 
    -0.07694719f, 0.00360090f, 1.27384412f, -0.66113400f, -0.59034944f, -0.15449220f, -0.17527296f, 0.03092060f, 
    0.13495836f, 0.09759846f, 0.02721418f, -0.34303859f, -1.17637110f, -1.17982399f, -0.17989440f, -0.33674437f, 
    0.12465679f, -0.09736761f, 0.14434004f, -0.20814143f, 0.38855144f, -0.31508765f, 0.12390750f, 0.09493088f, 
    -0.12911910f, 0.02850815f, 0.03916969f, 0.04072659f, -0.01172879f, 0.06936562f, 0.20970343f, 0.33433414f, 
    -0.19030701f, 0.00866993f, -0.07854047f, 0.07120776f, -0.02992450f, 0.24230655f, -0.83684468f, -0.19569346f, 
    -0.25642201f, -0.03789237f, -0.36671746f, 0.07223593f, 0.08493792f, -0.09501921f, 0.00525466f, 0.26312661f, 
    -0.01239886f, 0.00123641f, -0.08047593f, 0.01854529f, 0.26988965f, 0.06135593f, -0.05788310f, -0.13404237f, 
    0.03800294f, -0.05140585f, -0.06240508f, 0.02168433f, 0.04828687f, -0.05418644f, -0.05163237f, 0.03546740f, 
    -0.06719552f, 0.01243457f, -0.04918092f, -0.01880165f, 0.01002677f, -0.03068913f, -0.03552433f, -0.06166854f, 
    -0.00167876f, -0.01141689f, 0.01532057f, -0.05413801f, -0.03652244f, 0.04700192f, -0.03013692f, -0.03434947f, 
    -0.00790869f, 0.02715293f, -0.02623156f, 0.03362682f, 0.04675552f, 0.01147859f, -0.00048785f, -0.06587546f, 
    0.00921740f, 0.01132793f, -0.04504233f, 0.00368331f, -0.03335835f, -0.01739082f, -0.02719710f, 0.02073986f, 
    -0.02685545f, -0.02040096f, -0.03654116f, -0.01990783f, -0.04370851f, 0.02979141f, 0.04653455f, -0.01264141f, 
    0.03335353f, 0.03917656f, -0.00466762f, -0.04658665f, -0.02713458f, 0.03365337f, 0.02709266f, -0.00564551f, 
    -0.05251651f, -0.05109969f, -0.02535340f, -0.00875696f, -0.03277193f, -0.06846886f, -0.05037834f, -0.01796655f, 
    0.01501418f, -0.03550887f, 0.01261084f, -0.02643570f, -0.05210749f, -0.06816225f, -0.06827056f, 0.04562614f, 
    0.00849596f, -0.01489218f, -0.04013069f, -0.05445614f, 0.00480393f, 0.02323374f, 0.02346793f, 0.03145006f, 
    -0.02653963f, -0.04377167f, -0.04418986f, -0.05047253f, 0.03913544f, -0.00946398f, 0.02112028f, 0.04653686f, 
    0.03209145f, -0.05750199f, 0.04622129f, 0.04074031f, -0.05190545f, -0.02759259f, -0.02621777f, -0.05741337f, 
    -0.03076666f, -0.05303229f, 0.00586076f, 0.03287033f, -0.04190779f, -0.03996737f, -0.01052527f, -0.04301540f, 
    -0.02586840f, -0.06175756f, 0.03207021f, -0.03406756f, -0.00501220f, -0.02576317f, 0.04935227f, 0.03950204f, 
    0.04086154f, 0.04470253f, -0.05593388f, -0.05118296f, 0.03631728f, -0.04840738f, -0.04277055f, -0.04210499f, 
    -0.01569121f, -0.00780319f, 0.03415345f, -0.01591949f, -0.04452628f, -0.05141251f, -0.01811797f, -0.05472624f, 
    -0.00756766f, -0.03059174f, -0.04712513f, -0.04990648f, -0.05516472f, 0.04740606f, 0.01175872f, -0.03026795f, 
    -0.03593106f, -0.00744473f, -0.03401522f, 0.02355975f, -0.01621682f, -0.04000592f, -0.00829843f, -0.05577151f, 
    -0.03994485f, 0.02366325f, 0.04722049f, -0.00584376f, 0.01608196f, -0.03930281f, -0.05708599f, -0.05186409f, 
    0.04634399f, 0.00613864f, 0.02015825f, 0.00756311f, 0.00302624f, -0.03799065f, -0.00223389f, -0.04820414f, 
    -0.01285533f, -0.05956302f, 0.02812510f, -0.02980914f, -0.01523848f, -0.00055357f, 0.00413917f, 0.04534534f, 
    0.02695460f, -0.00370035f, -0.01567884f, 0.03078968f, 0.01143208f, 0.04274233f, 0.02373682f, 0.00337603f, 
    -0.05730139f, 0.04020156f, 0.02245657f, 0.05000832f, -0.01312826f, 0.00023778f, 0.04294570f, -0.02773568f, 
    -0.05903581f, 0.03856763f, -0.03591827f, -0.03873897f, 0.04222133f, -0.05589831f, -0.02755124f, -0.05957594f, 
    0.05072532f, -0.04564772f, -0.01238624f, -0.00382317f, -0.02548490f, -0.01600077f, 0.03330444f, -0.01892628f, 
    -0.06518544f, -0.03159299f, 0.01090652f, -0.06063488f, -0.03379566f, 0.00870982f, -0.03536032f, -0.03099637f, 
    0.03006623f, -0.04483151f, 0.02434698f, -0.03224815f, 0.04427337f, -0.06310557f, 0.00625169f, -0.04112956f, 
    -0.02440643f, -0.02411178f, -0.00139804f, -0.05047892f, -0.02419518f, -0.03002810f, 0.01021938f, -0.04605457f, 
    0.02522034f, 0.00794907f, -0.05100211f, -0.03358828f, 0.00352791f, -0.02435138f, 0.04490817f, 0.03057591f, 
    -0.02464688f, 0.04251927f, -0.03491067f, -0.00616410f, 0.00331589f, -0.01602207f, 0.00978931f, -0.05982218f, 
    -0.01198415f, 0.05422093f, -0.00906805f, -0.06418205f, 0.04272533f, -0.05991152f, 0.04467971f, -0.06178191f, 
    -0.00841299f, -0.06038847f, -0.02397178f, 0.00157461f, -0.00084102f, -0.03028410f, -0.02264853f, -0.03238996f, 
    -0.03303741f, 0.04820330f, 0.02887863f, 0.01148533f, 0.03490246f, -0.04240220f, -0.00709770f, 0.01251416f, 
    0.03810373f, 0.02497268f, -0.04279417f, 0.00017603f, -0.01552216f, 0.01280715f, -0.02862047f, -0.00052551f, 
    -0.02413197f, 0.02827192f, 0.01102145f, -0.06241672f, -0.01098634f, 0.00315452f, -0.06146812f, -0.05013341f, 
    0.04638970f, 0.05885227f, -0.03566550f, 0.04918698f, 0.02259388f, -0.01932224f, -0.02762101f, -0.00696860f, 
    -0.00777688f, -0.06891319f, 0.01987023f, -0.06411954f, 0.02252189f, -0.01347657f, -0.05444795f, -0.02424273f, 
    -0.01167568f, 0.02324330f, -0.00284297f, -0.05517681f, 0.01963522f, 0.03483932f, 0.00448011f, -0.05333931f, 
    0.02109074f, -0.04671447f, -0.01113193f, -0.03215227f, -0.02293381f, -0.05315591f, -0.05997589f, 0.04191101f, 
    0.02738365f, -0.02815088f, -0.02563758f, -0.03728892f, 0.01634659f, -0.02202891f, -0.03824198f, 0.03251436f, 
    0.01501069f, -0.03505400f, -0.02215084f, 0.04734325f, -0.02332464f, -0.00265058f, 0.01111074f, 0.03818190f, 
    -0.02987058f, -0.04694191f, 0.02069119f, 0.05170624f, -0.00546581f, -0.06735896f, -0.05655004f, 0.03420408f, 
    -0.01178535f, 0.03397564f, 0.01855867f, 0.05673432f, 0.03944111f, 0.01410350f, -0.05492643f, -0.03328182f, 
    -0.03597179f, -0.02770928f, -0.00908614f, -0.06325062f, -0.05372741f, -0.05268865f, -0.01431441f, -0.03014132f, 
    0.05220065f, 0.01070105f, 0.03411778f, -0.01632483f, -0.00366344f, 0.04006206f, 0.00601006f, -0.01858292f, 
    -0.02281948f, -0.01208532f, 0.02384877f, -0.01931959f, -0.05877721f, -0.03236272f, 0.02148916f, -0.01731016f, 
    -0.02149037f, -0.00021222f, 0.02758896f, -0.00878785f, -0.01697592f, -0.03450406f, -0.03045182f, -0.03041686f, 
    -0.05086685f, -0.05129549f, 0.03351513f, -0.00221150f, 0.00597872f, -0.05449886f, 0.00274714f, -0.00630417f, 
    0.00406452f, -0.03911792f, -0.00293797f, 0.02985851f, -0.04206885f, -0.03172468f, 0.00915164f, -0.02848221f, 
    -0.03342742f, 0.00670416f, -0.01637313f, -0.04622685f, -0.01932896f, -0.01135430f, 0.04032359f, -0.00308346f, 
    -0.03129371f, -0.05029392f, 0.00696493f, -0.04983868f, -0.01251676f, 0.04149178f, -0.02345254f, -0.04077956f, 
    -0.05268037f, -0.04434996f, 0.03099447f, 0.04780799f, 0.03000056f, 0.01052065f, -0.05478013f, -0.03414112f, 
    -0.06824881f, 0.02491384f, 0.03315830f, -0.06228122f, 0.04597282f, 0.02567152f, -0.02300586f, -0.02000172f, 
    0.03726183f, -0.01206452f, -0.00682945f, -0.04560159f, -0.01375990f, -0.01578551f, -0.02651292f, 0.00126146f, 
    0.05064774f, 0.04052949f, -0.02708615f, 0.00301304f, 0.03465248f, -0.04824117f, 0.03066291f, 0.04505010f, 
    0.03123384f, 0.02650334f, -0.04941182f, 0.03918052f, -0.04965154f, 0.04493425f, -0.00586839f, 0.04616823f, 
    0.02947515f, 0.03734706f, -0.03366427f, -0.06125626f, -0.04926382f, -0.01073075f, 0.02526644f, -0.04092078f, 
    0.02296257f, -0.04032869f, 0.00976344f, -0.01925506f, 0.00090232f, 0.02477956f, 0.01111364f, -0.03368417f, 
    -0.06206559f, 0.01659485f, 0.02281214f, -0.05046619f, 0.03693970f, -0.03367076f, 0.02537014f, -0.03937948f, 
    0.04889363f, -0.06446839f, 0.04973524f, 0.03490104f, -0.01753979f, -0.02073601f, -0.02526011f, -0.01844373f, 
    0.01384389f, -0.06824530f, -0.03438296f, 0.00175214f, -0.06199734f, -0.00959239f, -0.02870058f, 0.01172983f, 
    0.01505814f, -0.06069694f, 0.04826829f, 0.02767091f, -0.00458896f, 0.00021830f, -0.03768354f, 0.04405653f, 
    -0.04022786f, -0.03146391f, -0.04785316f, 0.04399217f, 0.03101658f, -0.04352017f, 0.02147241f, -0.04863184f, 
    -0.01821373f, -0.06736309f, 0.00754708f, 0.00167577f, 0.03954608f, 0.04458182f, -0.04365024f, 0.03769613f, 
    0.04124779f, -0.03929786f, -0.01634976f, 0.01761278f, 0.01966724f, 0.00517308f, 0.01848945f, 0.04943195f, 
    -0.03616942f, 0.00706960f, 0.00759086f, -0.04561764f, -0.03239324f, 0.02540381f, 0.00689534f, 0.01185049f, 
    0.05191550f, -0.02068885f, -0.03881915f, -0.02168329f, -0.00073862f, -0.05374540f, -0.02223935f, 0.03584931f, 
    0.00977205f, -0.06745671f, 0.03260491f, -0.05853903f, -0.01505271f, -0.06409261f, 0.03007019f, 0.03736719f, 
    -0.01650389f, -0.04201956f, 0.04803509f, 0.03092113f, -0.00878443f, -0.05963874f, -0.03837904f, 0.02262117f, 
    0.04935626f, 0.01586683f, 0.02849734f, -0.00774332f, -0.04753964f, 0.02330216f, -0.03382079f, -0.06515697f, 
    -0.00419452f, -0.05745916f, -0.03209532f, -0.02918976f, 0.01721833f, 0.02289871f, -0.05535275f, -0.05042271f, 
    -0.04545181f, -0.05165889f, 0.00287690f, -0.05950805f, -0.02291271f, -0.01106113f, 0.04606852f, -0.00068265f, 
    -0.01727735f, 0.10403108f, -0.23547406f, 0.26579052f, 0.10626173f, -0.12780036f, -0.18904589f, 0.17355914f, 
    0.14996827f, 0.12256508f, -0.36767757f, -0.12743884f, -0.01348689f, 0.02328154f, -0.08470605f, 0.13729869f, 
    -0.04885128f, 0.05791066f, -0.17465821f, 0.22837657f, -0.88193458f, -0.09317816f, 0.06142519f, 0.11390265f, 
    0.00144413f, 0.07287448f, 0.04640022f, 0.25838596f, 0.25949553f, -0.00725523f, 0.06985052f, -0.03084555f, 
    -0.08218358f, 0.00422659f, -0.03979046f, -0.04284814f, 0.11915136f, -0.04135627f, -0.46623617f, -0.01155443f, 
    0.06435254f, -0.02939651f, 0.06314399f, 0.06119062f, -0.05929329f, 0.12921433f, -0.55040455f, -0.37749779f, 
    0.08191434f, 0.09358431f, 0.11483385f, 0.02181011f, -0.07635169f, 0.07511292f, -0.11019879f, -0.90842479f, 
    -0.56416923f, -0.01128821f, 0.17278589f, 0.33479601f, 0.13029827f, 0.04426845f, -0.18140940f, 0.11251882f, 
    0.15556803f, 0.16323864f, -0.03389987f, 0.10994105f, 0.14788431f, 0.23582517f, -0.01005647f, 0.17892021f, 
    0.08296639f, 0.08710615f, 0.20121866f, 0.07225955f, 0.03163324f, 0.01713273f, 0.12903626f, 0.20214155f, 
    0.03555673f, -0.37296873f, 0.02136338f, -0.28151402f, 0.03808975f, -0.13147262f, 0.24688217f, 0.31800443f, 
    0.02355069f, -0.00327551f, 0.37217367f, 0.33400699f, 0.15713969f, -0.03041079f, 0.02059558f, 0.03649559f, 
    0.05451083f, 0.08927762f, 0.04322714f, -0.03094580f, -0.28856170f, 0.28173345f, -0.28699771f, -0.26819628f, 
    0.00643589f, -0.03673360f, -0.05473967f, 0.09769583f, 0.18970801f, 0.29795468f, 0.20876107f, -0.15442751f, 
    -0.21998280f, -0.04305424f, -0.01921623f, -0.06056014f, -0.04299615f, -0.04194243f, 0.28924474f, -0.03821751f, 
    -0.02265580f, 0.03758882f, 0.17151906f, 0.10825301f, 0.08246852f, 0.08983736f, -0.03987008f, -0.08311529f, 
    -0.11666515f, 0.10439833f, 0.08244949f, 0.07872133f, -0.00794721f, -0.08195081f, -0.08440080f, -0.47858122f, 
    -0.58685148f, -0.41603443f, -0.13642626f, 0.08007957f, 0.00006685f, -0.06281491f, -0.08806020f, 0.03222070f, 
    0.10443780f, 0.02205877f, 0.00376209f, -0.01700703f, 0.10846846f, -0.08339836f, 0.00232770f, -0.11823932f, 
    0.05971394f, -0.40593699f, -0.34773847f, -0.19728962f, 0.16359101f, 0.01482101f, 0.01970758f, 0.02153019f, 
    -0.10411594f, -0.11873645f, -0.10825298f, -0.11562362f, -0.11629692f, -0.13937850f, -0.25887498f, -0.09316344f, 
    -0.01104440f, 0.02474412f, -0.21433234f, -0.11552615f, -0.23604538f, -0.08802556f, -0.08033331f, -0.10088450f, 
    0.00778176f, 0.08482739f, -0.07858445f, 0.08725027f, 0.10797963f, -0.09930471f, 0.11731329f, 0.12517856f, 
    0.17449260f, 0.00368354f, -0.09496429f, -0.04737886f, 0.07952371f, -0.03660917f, -0.02847957f, 0.12922108f, 
    0.16291814f, 0.00153291f, -0.05871201f, 0.10515315f, 0.21238828f, -0.20733120f, -0.14422520f, 0.00293880f, 
    0.00817732f, 0.02131532f, -0.01190188f, -0.05553676f, 0.20440520f, 0.12010708f, 0.12930635f, -0.38054335f, 
    -0.62910539f, -0.27834615f, 0.07042855f, -0.25241166f, -0.06727756f, 0.14290111f, 0.35858688f, -0.08964726f, 
    0.27249709f, -0.38324109f, -0.50902796f, -0.16116089f, 0.31498620f, -0.03278477f, 0.00292334f, -0.14439411f, 
    0.12022600f, 0.36754856f, 0.26899654f, -0.01421543f, 0.00514701f, 0.02359563f, -0.07027785f, 0.10609237f, 
    0.07189263f, -0.06711561f, -0.02826654f, 0.11550949f, -0.30308175f, -0.09389585f, -0.08061246f, -0.19730529f, 
    -0.20902169f, 0.00443716f, -0.30332586f, -0.28256923f, 0.05333173f, -0.02738097f, 0.02160909f, 0.33860305f, 
    0.39807364f, 0.17720751f, -0.19244121f, 0.07469265f, -0.29043067f, -0.14045583f, -0.03384276f, 0.21183787f, 
    0.12624985f, 0.24258111f, -0.11243417f, -0.02463260f, 0.03383931f, 0.13533241f, 0.01403698f, 0.56162149f, 
    0.00021835f, -0.05984087f, -0.08154733f, -0.28441450f, 0.00883568f, -0.02990088f, 0.08282816f, 0.12796441f, 
    -0.00932650f, -0.04548340f, 0.12653142f, 0.08155462f, 0.01172306f, 0.02540527f, -0.06578658f, -0.15101962f, 
    -0.78960538f, -0.46163446f, 0.01426180f, 0.03050839f, 0.18587144f, -0.08705914f, 0.01620641f, 0.11410304f, 
    0.14616953f, -0.23104288f, 0.20644157f, -0.07171563f, -0.20338483f, -0.07175684f, -0.16867134f, 0.01433564f, 
    0.12023918f, 0.29648656f, 0.09878172f, 0.06399318f, -0.02628515f, -0.20318003f, 0.19104716f, 0.01889992f, 
    -0.02713572f, -0.03949069f, -0.07538488f, -0.18165551f, 0.04566720f, -0.04826864f, 0.06718613f, 0.04828141f, 
    -0.07398380f, -0.00725061f, 0.02460720f, 0.48069528f, 0.42154574f, 0.37511310f, -0.04423887f, -0.07384214f, 
    -0.10114039f, 0.07015348f, 0.11111168f, 0.05532307f, -0.20623913f, -0.35269085f, 0.17632437f, 0.08079133f, 
    -0.05321022f, -0.04416490f, 0.02736707f, -0.01302615f, 0.09259029f, 0.13980652f, -0.39982834f, -0.15829584f, 
    0.12460953f, 0.15163277f, -0.06075697f, 0.01800017f, 0.07836621f, -0.14800893f, -0.05689511f, -0.30181438f, 
    0.03380583f, -0.11170615f, -0.25307837f, 0.03645394f, 0.16130015f, -0.05993326f, 0.10213250f, 0.45821232f, 
    0.14089118f, 0.48788890f, 0.07948352f, 0.13540033f, 0.03664230f, 0.03393549f, 0.26825839f, 0.03746042f, 
    0.13997403f, -0.19533460f, 0.04974151f, 0.08871268f, 0.03864580f, 0.01969902f, -0.16960843f, 0.04018857f, 
    -0.02512838f, -0.08304597f, -0.02294722f, 0.88674510f, 0.18335578f, 0.01712051f, -0.06459901f, 0.05252596f, 
    -0.10387291f, 0.02017112f, 0.46463642f, 0.25073415f, 0.38392144f, 0.04483562f, -0.06662753f, -0.09381807f, 
    -0.00233431f, 0.15254302f, 0.16103777f, 0.39925849f, 0.31835935f, 0.26365268f, -0.24135143f, -0.08022218f, 
    -0.35891944f, 0.02386810f, 0.03976727f, 0.07173157f, 0.46416274f, 0.16176416f, 0.20634240f, -0.11024839f, 
    -0.10451194f, 0.00210665f, -0.12216188f, 0.00525531f, 0.10281429f, 0.14571504f, 0.22976443f, 0.15751375f, 
    0.09910116f, 0.00738208f, 0.03241657f, 0.03743738f, -0.03325788f, 0.18212119f, -0.05508630f, -0.17288393f, 
    -0.17558157f, 0.03246625f, 0.13371077f, -0.04065934f, 0.06794911f, 0.20783038f, 0.03012972f, -0.32631087f, 
    -0.43918911f, -0.50879121f, -0.15565817f, -0.23752984f, -0.09183208f, -0.16602924f, -0.25942993f, -0.07491259f, 
    0.07437586f, 0.11200766f, -0.08248941f, -0.05104404f, 0.12789130f, 0.02321447f, -0.04815818f, 0.07426804f, 
    -0.05954170f, -0.10302252f, -0.35538876f, 0.15921290f, 0.10619665f, 0.09528773f, -0.06891651f, -0.02581608f, 
    0.18431237f, -0.12457863f, -0.07040086f, -0.31882951f, 0.17752749f, 0.02428901f, -0.05455596f, -0.09972072f, 
    0.04346142f, -0.06321995f, -0.08052063f, -0.01886539f, -0.12391095f, -0.41501734f, -0.01581438f, -0.01514091f, 
    0.02115904f, -0.01301103f, 0.02502500f, 0.15995449f, -0.09989376f, 0.12574865f, 0.27250424f, -0.16440181f, 
    -0.03696300f, -0.06492217f, -0.07304250f, 0.02018967f, 0.02775107f, -0.10345224f, 0.03336157f, -0.12479036f, 
    -0.03958224f, 0.01763181f, 0.09181263f, 0.11686160f, 0.08990535f, -0.04553689f, -0.18384045f, -0.11799116f, 
    0.00965307f, -0.07209667f, -0.09242296f, -0.04446989f, 0.09727125f, -0.20309058f, 0.07748662f, -0.79562157f, 
    0.18064396f, -0.56514424f, 0.07849908f, -0.43155602f, 0.17274769f, -0.03515473f, 0.06098446f, -0.12108392f, 
    -0.16266477f, -0.31108120f, -0.25622654f, -0.16712083f, -0.19957080f, 0.07227959f, 0.03358947f, 0.01710286f, 
    0.07207758f, 0.25524017f, 0.37423563f, 0.39814162f, -0.13287193f, 0.05010019f, 0.04522805f, 0.10194688f, 
    -0.02210531f, 0.00548939f, -0.17778206f, -0.56652886f, -0.14655228f, -0.12246107f, -0.03242677f, -0.00644817f, 
    -0.31848395f, -0.20571099f, 0.13762303f, 0.44843844f, -0.43225467f, -0.15121403f, 0.16417544f, 0.27174777f, 
    -0.10568637f, -0.12009036f, 0.04148955f, -0.20926227f, -0.29024830f, -0.36829379f, -0.80432510f, 0.14199060f, 
    0.14730223f, 0.05990255f, 0.12047385f, -0.11883462f, -0.21687458f, -0.30384460f, -0.05031566f, 0.21546701f, 
    -0.25042263f, -0.04655521f, 0.08700524f, 0.03184890f, 0.08441123f, 0.03450541f, -0.03032549f, 0.02452317f, 
    -0.08705252f, -0.04684330f, -0.02965309f, -0.13077825f, -0.03414354f, -0.20803259f, 0.03683415f, 0.30146512f, 
    -0.16418447f, -0.03779342f, -0.00249003f, 0.09532396f, 0.24070242f, 0.03976737f, 0.03151384f, -0.11670828f, 
    0.02309249f, 0.11062998f, 0.23256080f, 0.17616610f, 0.07283743f, 0.08863469f, 0.02684758f, 0.16313601f, 
    -0.03130785f, -0.24614517f, 0.03236113f, -0.09266803f, 0.00023422f, 0.06671207f, 0.02868393f, -0.09544962f, 
    0.05268379f, -0.01781229f, -0.20963672f, 0.08194848f, 0.17468931f, 0.06612644f, -0.08632351f, -0.07532303f, 
    0.21504295f, 0.07653821f, -0.03541911f, -0.05264660f, 0.01292028f, 0.05075034f, -0.01405816f, 0.07166018f, 
    -0.11667916f, -0.21646096f, 0.01970542f, -0.06234417f, -0.08758065f, 0.31294724f, 0.23941439f, 0.18214741f, 
    -0.13883416f, -0.06247232f, 0.14086926f, 0.12852025f, 0.08111059f, -0.10700490f, 0.03620111f, 0.05047058f, 
    0.16218071f, -0.00289010f, 0.01236377f, -0.17969309f, 0.07747106f, -0.00434368f, -0.17223978f, -0.07488992f, 
    0.16619420f, 0.07720043f, 0.03274013f, -0.00455019f, 0.03325407f, 0.02014360f, 0.07905842f, 0.13652778f, 
    0.16189182f, 0.25757328f, 0.11951869f, 0.05242581f, 0.09242169f, 0.08597626f, -0.01608357f, -0.16665356f, 
    0.08505421f, -0.07688913f, 0.12333480f, -0.17779613f, 0.00676237f, 0.14999241f, 0.24331672f, -0.11675019f, 
    -0.13295145f, -0.38104424f, -0.00213534f, 0.63172770f, -0.07225040f, 0.31681776f, 0.40127355f, -0.01686879f, 
    -0.19015341f, -0.09814940f, 0.13197498f, -0.09017497f, -0.10328428f, 0.07318137f, 0.02851581f, 0.01539665f, 
    -0.12474423f, 0.00008880f, -0.35867593f, -0.21277812f, -0.10105580f, -0.13077952f, 0.05519079f, 0.18603610f, 
    0.01600359f, 0.03872440f, 0.02720204f, -0.09036944f, -0.03558327f, -0.21105123f, -0.15280069f, 0.05616961f, 
    -0.08364297f, 0.04665620f, -0.00267617f, -0.04680513f, -0.42543456f, 0.02337820f, 0.00623962f, 0.16332561f, 
    -0.11990350f, -0.10973434f, 0.03632641f, -0.01553480f, -0.14915606f, -0.10149567f, 0.04110621f, 0.04118023f, 
    -0.09520233f, 0.02720231f, -0.28939849f, -0.43630883f, 0.17228319f, 0.31228545f, 0.15257084f, -0.27750823f, 
    0.30425134f, -0.27813047f, 0.38126278f, -0.05307152f, -0.06610596f, 0.07079135f, 0.02851705f, -0.04877208f, 
    0.02729456f, 0.09975445f, -0.02192686f, 0.00647777f, 0.12949674f, 0.00948268f, 0.12872884f, 0.06932698f, 
    0.03446997f, 0.11599981f, 0.06798121f, -0.08244135f, -0.23983069f, -0.21983191f, -0.37776816f, 0.11993754f, 
    0.17686172f, 0.09329192f, 0.15112919f, 0.02598756f, 0.08611235f, -0.23677243f, -0.21394111f, 0.17161307f, 
    -0.73053771f, -0.30560079f, -0.26311320f, -0.12562762f, 0.05040249f, -0.08224370f, 0.28939134f, 0.00441194f, 
    0.28374505f, 0.17514655f, 0.20304130f, 0.16881581f, -0.14603025f, 0.01657693f, 0.09942541f, -0.05964507f, 
    -0.03991293f, 0.18156420f, -0.03394250f, -0.11613046f, 0.13208337f, 0.05754061f, -0.01214030f, -0.09484352f, 
    0.03705109f, -0.02851560f, 0.17010932f, -0.06502347f, 0.13509470f, 0.14059237f, -0.11183512f, -0.04365459f, 
    -0.01566829f, 0.02129549f, -0.01284804f, 0.00900454f, -0.46199125f, -0.32770252f, -0.18233603f, -0.01626906f, 
    -0.25987393f, 0.19880226f, 0.11317829f, -0.08205833f, 0.50752360f, 0.36356720f, 0.09530205f, -0.09013089f, 
    -0.54860985f, -0.33940876f, -0.02210134f, -0.06306051f, 0.02019454f, 0.03440735f, -0.08763125f, -0.05810138f, 
    -0.20835011f, 0.05387125f, 0.10866321f, -0.11479248f, 0.18179621f, 0.14463483f, -0.05472550f, -0.30414206f, 
    0.07465274f, 0.06710882f, -0.35009274f, -0.10416594f, -0.17041196f, 0.19997004f, 0.04109519f, 0.23991507f, 
    -0.08391614f, -0.01359872f, -0.46872342f, 0.38325188f, -0.03489513f, 0.36469796f, 0.05311890f, 0.10371225f, 
    0.24452180f, 0.04525979f, 0.12188297f, 0.09720422f, 0.05504130f, -0.02614793f, 0.24997231f, 0.25749052f, 
    -0.01771080f, 0.02173300f, -0.05616088f, 0.22896537f, 0.08781406f, 0.17658605f, -0.04404669f, -0.41712195f, 
    -0.03722450f, -0.12942202f, 0.02669337f, 0.10235763f, -0.01263483f, 0.04643299f, -0.05044370f, -0.07836704f, 
    0.03096486f, 0.25947833f, -0.18163674f, 0.24510823f, 0.16601476f, 0.13586660f, -0.11267988f, 0.05882829f, 
    0.07936656f, 0.04952944f, 0.06087510f, -0.11552233f, -0.11447163f, -0.09426552f, 0.02458674f, 0.01812162f, 
    0.27653942f, 0.28384683f, 0.44079494f, 0.20586753f, 0.03514353f, 0.06881766f, -0.24272661f, -0.05167814f, 
    -0.15498412f, 0.19349739f, 0.18637997f, 0.27537331f, 0.04233744f, -0.11778313f, 0.02718099f, 0.12035909f, 
    0.15534431f, 0.17106201f, 0.57703787f, 0.12703165f, 0.61233735f, 0.03743965f, 0.18792133f, -0.07623016f, 
    -0.02849632f, 0.10008809f, 0.02570710f, -0.23342872f, 0.14467937f, 0.27347162f, 0.26010814f, 0.17444636f, 
    -0.07387927f, 0.13001068f, 0.08224554f, -0.03978645f, 0.40693077f, 0.29419234f, 0.27648652f, 0.15181582f, 
    -0.10563371f, -0.13224210f, -0.08448333f, 0.00684265f, -0.12685333f, -0.13014743f, -0.06379244f, -0.09533000f, 
    0.17254652f, -0.04764627f, 0.10386101f, -0.01861125f, 0.03220782f, 0.17377722f, 0.49195218f, -0.34618816f, 
    0.10649763f, -0.14542484f, -0.07712957f, -0.16382000f, 0.06909195f, 0.01259119f, 0.03077853f, -0.46001059f, 
    0.09825111f, -0.24834248f, 0.08806601f, 0.13810736f, -0.07728795f, -0.11531847f, -0.16043210f, 0.00327360f, 
    -0.66971427f, -0.22247927f, 0.20211083f, 0.02673451f, -0.22394927f, -0.12749906f, -0.12102990f, 0.00141364f, 
    0.14516942f, 0.11170538f, 0.34422374f, -0.55338418f, -0.16354840f, -0.05675695f, -0.13401921f, 0.16580084f, 
    -0.07194286f, 0.09774485f, -0.34270704f, 0.06831484f, -0.01264625f, 0.13656655f, 0.09674551f, -0.13738509f, 
    -0.26141822f, -0.23656446f, 0.04474273f, 0.47916335f, 0.48000699f, 0.31834930f, 0.00904955f, -0.15945758f, 
    -0.14404352f, -0.03631116f, -0.13386935f, 0.10545687f, -0.14315164f, -0.03725809f, -0.05428481f, -0.00164624f, 
    0.05998133f, -0.05602701f, 0.05931015f, -0.25621021f, 0.00848811f, -0.32164183f, -0.27461216f, 0.00522125f, 
    0.01950480f, 0.05620808f, -0.16520567f, -0.10362548f, -0.19288433f, 0.09536503f, 0.38593772f, 0.18614902f, 
    0.02099744f, -0.12493311f, -0.08018850f, -0.03390035f, 0.11441106f, 0.08340879f, -0.02732614f, -0.13968967f, 
    0.14046493f, 0.46825430f, -0.08354018f, -0.28719136f, -0.25693044f, 0.16889761f, -0.00158725f, 0.11216028f, 
    -0.13191441f, 0.14758486f, -0.10881579f, -0.25995836f, 0.14277919f, 0.08475503f, 0.23798487f, 0.07367858f, 
    -0.05216834f, 0.22501770f, 0.22189149f, 0.03934238f, 0.02663329f, -0.29312477f, -0.00808305f, 0.15613616f, 
    -0.07521697f, 0.01831301f, -0.19483469f, -0.11183361f, -0.21587345f, 0.10661596f, -0.12565872f, 0.14090788f, 
    0.05128882f, 0.03283143f, 0.16181444f, 0.22406997f, 0.11076023f, -0.00104991f, -0.35141858f, -0.20612590f, 
    0.08493882f, 0.18537754f, 0.05935597f, 0.06029432f, -0.23252016f, 0.10895207f, -0.03194665f, -0.08375208f, 
    -0.14059584f, -0.01298055f, -0.22512396f, -0.09130800f, 0.17699572f, -0.04056777f, -0.01357321f, 0.21028183f, 
    -0.01105249f, -0.08557075f, -0.11571423f, 0.35908005f, 0.13388778f, 0.03541682f, -0.21472149f, 0.03331633f, 
    0.00505738f, -0.25964114f, -0.15182674f, -0.17862546f, -0.09986337f, -0.01063040f, 0.16055515f, -0.05839927f, 
    -0.46976864f, 0.05770351f, -0.31228492f, -0.17665583f, -0.60768038f, 0.08205621f, 0.09242473f, -0.09360704f, 
    -0.16323157f, -0.21161655f, 0.17026275f, -0.10611925f, 0.04665503f, -0.07996558f, 0.05732597f, 0.08578683f, 
    0.03645413f, -0.38351253f, 0.20442237f, 0.07834610f, -0.07129422f, 0.13698995f, 0.11923984f, 0.02168316f, 
    0.06552901f, -0.25814778f, -0.23029621f, 0.09541744f, 0.07301508f, -0.07449356f, -0.30290896f, -0.08665778f, 
    -0.19846019f, 0.01082051f, 0.34428754f, -0.07639772f, -0.20601493f, 0.17034701f, 0.00698949f, 0.19814934f, 
    0.10636432f, -0.26796973f, 0.20430973f, -0.15097788f, -0.08218373f, -0.11937366f, -0.09207553f, 0.01343883f, 
    -0.12450621f, 0.03546323f, -0.07333159f, 0.18776813f, 0.19693001f, 0.26359665f, 0.41640905f, 0.28351524f, 
    0.14220621f, -0.04842012f, 0.04648891f, 0.00144838f, 0.01120483f, -0.04037717f, 0.01491428f, 0.21589792f, 
    0.23399980f, -0.23092988f, -0.23014103f, 0.05980382f, -0.04094281f, 0.06571497f, 0.09906618f, 0.17946523f, 
    -0.09892358f, 0.08771162f, -0.10852694f, -0.12725222f, -0.08500434f, -0.00787713f, -0.09044575f, -0.03429629f, 
    0.00137206f, 0.01589610f, -0.01161083f, 0.01868257f, 0.01975490f, 0.01730008f, 0.01333265f, 0.02176089f, 
    0.00632016f, -0.01877849f, 0.04151311f, 0.01827987f, -0.02955890f, -0.02127580f, -0.05569717f, 0.01972994f, 
    -0.04712266f, -0.05275650f, -0.00125241f, -0.01116124f, -0.00319542f, 0.05159297f, 0.02840233f, 0.01442210f, 
    -0.03659606f, 0.03692020f, -0.03546114f, 0.03760399f, 0.00429329f, 0.02883523f, -0.03311026f, 0.01521911f, 
    -0.04260745f, 0.04253618f, 0.03303993f, 0.03777321f, 0.05056565f, -0.00441227f, 0.04739217f, 0.05526761f, 
    -0.01729079f, 0.01055410f, 0.04191200f, 0.03346723f, -0.03240866f, -0.00782766f, -0.03083397f, 0.01304166f, 
    -0.02602597f, -0.02021022f, -0.01653649f, 0.02699807f, 0.02073215f, -0.04207788f, -0.05331901f, 0.03104728f, 
    -0.05584039f, -0.00975497f, -0.03748838f, 0.03567374f, -0.05653464f, -0.02813837f, -0.03472331f, -0.05191491f, 
    0.00525442f, -0.01315160f, -0.03903024f, 0.03473407f, -0.00460278f, -0.00990239f, -0.04506962f, -0.02912559f, 
    -0.02314323f, -0.01957057f, -0.04122101f, -0.03311846f, -0.04318617f, -0.01717555f, 0.04012934f, -0.03593974f, 
    0.01956129f, -0.00595907f, -0.03724549f, 0.03328691f, -0.05835935f, -0.01619979f, 0.02978691f, -0.03317989f, 
    -0.01522926f, 0.03566565f, 0.00487646f, -0.03767415f, -0.04671555f, 0.03966548f, 0.00954337f, -0.01456635f, 
    0.02356950f, -0.02306230f, 0.01336322f, -0.02000813f, -0.02118339f, 0.02863165f, -0.00245653f, 0.02938651f, 
    -0.05532077f, 0.02523545f, -0.00204099f, 0.03181728f, 0.04104133f, -0.01487237f, -0.03276625f, -0.04350396f, 
    0.05118044f, 0.00514272f, -0.01164760f, -0.00338278f, -0.05042498f, -0.02781894f, 0.03033788f, 0.00740689f, 
    -0.00287687f, -0.04557594f, 0.02932568f, -0.04328523f, -0.04920617f, 0.00572727f, -0.01446548f, -0.04077899f, 
    0.02157828f, 0.00114151f, 0.04111110f, -0.03778476f, -0.00123099f, -0.00838409f, 0.03554602f, 0.02498340f, 
    -0.02255595f, 0.03450246f, -0.03608557f, -0.05262273f, 0.03082435f, -0.02263148f, 0.05237201f, -0.00075770f, 
    -0.02190954f, -0.01800809f, 0.04067546f, 0.01076420f, 0.02120922f, 0.04966165f, -0.04365613f, -0.03347871f, 
    0.00124642f, -0.05843669f, 0.01675842f, 0.02415855f, -0.02252297f, -0.06386638f, -0.02511236f, 0.02124833f, 
    -0.01893158f, -0.04799923f, 0.02079507f, -0.02340960f, -0.00772212f, 0.04188246f, -0.03422033f, -0.04434575f, 
    -0.02643707f, -0.02609834f, 0.02502013f, -0.00274414f, 0.01210256f, 0.03347389f, -0.03554681f, 0.04733300f, 
    0.00598520f, -0.04311958f, -0.02780654f, -0.02659047f, 0.04450762f, -0.04260926f, 0.01544136f, 0.01505734f, 
    -0.01518083f, -0.04436777f, 0.01898496f, 0.00765128f, 0.00559241f, -0.04178856f, -0.03969719f, -0.02052021f, 
    -0.05472185f, -0.02649073f, -0.05249278f, 0.01625812f, -0.03456792f, 0.03333127f, 0.02181365f, 0.05176336f, 
    -0.01247654f, -0.03940812f, -0.03834403f, -0.00248151f, 0.01143197f, 0.00312945f, -0.00437250f, -0.04900360f, 
    -0.03508726f, -0.00397749f, 0.01383100f, -0.05313893f, -0.00185112f, 0.03697790f, 0.02611502f, 0.01423032f, 
    -0.01284109f, 0.00741702f, -0.05716398f, -0.00143063f, 0.02744523f, 0.05808636f, -0.03868306f, 0.01026703f, 
    -0.05207574f, -0.06273597f, -0.04037932f, 0.02354642f, -0.04951020f, -0.05078229f, -0.00428954f, -0.02315000f, 
    0.05290275f, -0.01961604f, -0.05611477f, -0.03806770f, -0.02346113f, 0.01185617f, -0.00607535f, -0.00549888f, 
    0.01361455f, -0.01591668f, 0.01327460f, -0.04539159f, 0.02166466f, -0.03684826f, 0.01092914f, 0.03478052f, 
    -0.02131144f, -0.02797559f, -0.03578177f, 0.05169589f, -0.00966684f, 0.02738786f, -0.05507334f, -0.01343897f, 
    -0.04939496f, -0.04422066f, -0.05051493f, 0.01629372f, 0.03707523f, -0.00796252f, -0.05621535f, -0.04829123f, 
    0.03659093f, -0.00300149f, 0.02454507f, 0.04809025f, -0.03678377f, -0.05512894f, -0.06210963f, -0.01657118f, 
    0.00226296f, -0.01016079f, -0.05502904f, -0.04617181f, -0.04480368f, -0.01292742f, -0.02923511f, -0.05039329f, 
    -0.00763718f, -0.02341035f, -0.04750396f, 0.03220849f, 0.00832784f, 0.00834175f, -0.02709317f, -0.05065018f, 
    0.00344605f, 0.44747961f, -0.49661118f, 0.22631118f, -0.01786469f, 0.09389242f, -0.01984559f, 0.00412855f, 
    0.06887607f, 0.19332378f, -0.20813322f, 0.01413534f, -0.28677809f, -0.16091041f, -0.07377660f, 0.00192977f, 
    0.10291350f, 0.11470165f, -0.43640581f, 0.11890268f, -0.39119175f, -0.01478486f, 0.01262932f, 0.07800220f, 
    -0.03198096f, -0.00902529f, 0.02846348f, 0.09469838f, -0.10661878f, -0.06086877f, 0.05938111f, 0.08654242f, 
    0.22308406f, -0.09960091f, -0.04530418f, -0.03568484f, -0.08927804f, 0.43424675f, -0.22795282f, 0.17377043f, 
    0.17888376f, 0.12570463f, 0.00243225f, -0.03340069f, 0.04575220f, 0.20724188f, -0.06901708f, 0.05095197f, 
    -0.14265664f, -0.02897482f, 0.12814994f, 0.00046206f, 0.04008965f, -0.17176729f, -0.17514251f, -0.21142693f, 
    0.10335682f, -0.19416344f, 0.19134431f, -0.03699619f, 0.01002555f, 0.01665622f, 0.09416351f, 0.01946727f, 
    -0.04771828f, 0.14663228f, 0.15151754f, 0.23618694f, 0.14468862f, 0.23396908f, -0.08882540f, 0.15049237f, 
    0.33081749f, -0.00304458f, 0.09547850f, 0.22966321f, 0.02931887f, 0.07983229f, 0.15258126f, 0.08322832f, 
    0.07753196f, -1.34763050f, 0.13070485f, -0.06092894f, -0.20000276f, -0.34344557f, -0.09397069f, 0.33644733f, 
    0.00780218f, 0.07392651f, 0.03378981f, -0.05799983f, 0.11531463f, 0.15338297f, 0.13147557f, 0.12487619f, 
    0.05793468f, 0.12046584f, 0.03208424f, -0.23859538f, -0.01833221f, -0.19193086f, -0.50008309f, -0.24406807f, 
    -0.11841294f, 0.01016066f, 0.08020328f, 0.17594531f, -0.16848734f, -0.23119503f, 0.25647336f, 0.06534657f, 
    0.01159791f, 0.01521615f, -0.12889075f, -0.13236044f, 0.04077202f, -0.06562102f, 0.06009371f, -0.15119217f, 
    0.19290812f, 0.11756945f, 0.12895814f, -0.00352983f, 0.00857837f, 0.02337180f, -0.08435218f, 0.12805313f, 
    0.04256498f, 0.08118109f, -0.02436717f, 0.08574352f, 0.09744721f, 0.07221350f, 0.06888099f, 0.10706888f, 
    -0.15764856f, 0.02719593f, -0.25036409f, -0.21185052f, -0.40182680f, -0.12112302f, -0.14479059f, 0.02803670f, 
    0.02399740f, 0.03028449f, 0.10625298f, 0.14743011f, 0.10282774f, 0.10146564f, 0.08643203f, -0.00696263f, 
    0.07303479f, -0.22090024f, -0.00255277f, 0.10436006f, 0.00602986f, -0.02434776f, 0.05980437f, 0.15831496f, 
    0.12869081f, -0.00029655f, -0.16478296f, -0.10833837f, -0.29703760f, -0.07756263f, -0.05828612f, -0.12478921f, 
    0.04645215f, -0.02226731f, -0.14151572f, 0.05941325f, 0.01716849f, 0.17100932f, -0.14474835f, -0.16185884f, 
    -0.11161372f, -0.00714218f, -0.07694902f, -0.01243327f, 0.31781539f, -0.02135621f, -0.01648200f, -0.09090360f, 
    0.12265179f, 0.12340260f, 0.16508210f, 0.05590022f, 0.23007038f, 0.23787385f, 0.00176204f, 0.01819530f, 
    0.15362434f, 0.01127963f, -0.14520088f, -0.10633399f, 0.23298466f, 0.01653410f, 0.01160353f, 0.16601352f, 
    0.09643553f, -0.03978045f, 0.00873504f, -0.02793968f, 0.08546105f, -0.06430243f, 0.21649811f, -0.03498903f, 
    -0.63642704f, 0.01753585f, 0.02428610f, -0.09896900f, -0.01923663f, 0.04495539f, 0.07475915f, 0.11320914f, 
    -0.25430283f, -0.14288864f, -0.39797372f, -0.40757003f, -0.02624968f, -0.07222480f, 0.10608520f, 0.00537449f, 
    -0.06423108f, 0.02916343f, -0.08550173f, -0.01489988f, 0.19105476f, 0.21775207f, 0.10258310f, 0.07278969f, 
    0.10787497f, 0.07798576f, 0.29808107f, -0.49221766f, -0.10349626f, -0.27849242f, -0.12369825f, -0.26269135f, 
    -0.23077326f, -0.17006253f, -0.18087667f, -0.17836732f, 0.30980700f, -0.24421671f, -0.03438089f, 0.07576659f, 
    0.14113152f, 0.08867355f, -0.02136334f, -0.03213611f, 0.16312793f, -0.33549395f, -0.38148552f, -0.27166650f, 
    -0.04283006f, -0.02755200f, -0.00702807f, -0.15026931f, -0.19914524f, 0.24916357f, 0.12999161f, 0.11135997f, 
    -0.01884045f, -0.10134041f, -0.00766570f, -0.27050197f, 0.02752896f, 0.01171553f, -0.06219856f, 0.28186330f, 
    0.15126185f, -0.03616639f, 0.02797791f, -0.01899954f, 0.05615878f, -0.01947982f, 0.07574140f, -0.05066364f, 
    -0.01729029f, 0.52585608f, 0.14051880f, -0.04310138f, 0.07223954f, -0.09564937f, -0.00638934f, -0.03896546f, 
    -0.13060838f, 0.19265053f, -0.18798082f, 0.04336294f, -0.22880332f, 0.00097972f, 0.06067528f, 0.39418563f, 
    -0.05778106f, 0.21982402f, -0.08737430f, 0.16082220f, 0.06726485f, -0.02815630f, -0.13611157f, 0.12333415f, 
    0.07369145f, 0.05059586f, 0.32079512f, 0.32004353f, -0.32225946f, 0.13787754f, -0.02953414f, -0.07055607f, 
    0.02631633f, -0.06353453f, 0.18847124f, -0.07886314f, -0.08330563f, -0.12960327f, 0.03882659f, 0.02836117f, 
    0.09500819f, 0.17409593f, -0.08145706f, -0.08175013f, 0.00604289f, 0.11288310f, -0.13110483f, -0.03485261f, 
    0.01580559f, 0.00643757f, -0.07757954f, 0.03329546f, 0.04817138f, 0.06999359f, -0.37104872f, 0.04827108f, 
    0.11307538f, -0.10646280f, 0.13341974f, -0.02710858f, -0.07357134f, -0.18598522f, 0.02145146f, -0.42798984f, 
    -0.15305467f, -0.32260132f, 0.24174069f, 0.04430073f, 0.05406493f, 0.14058435f, -0.01709278f, -0.30118451f, 
    0.07753810f, -0.02145208f, -0.03107022f, -0.07221836f, 0.06895258f, 0.05175623f, 0.10410836f, 0.26896456f, 
    -0.08857163f, -0.13817270f, -0.12649722f, 0.03699540f, -0.07101541f, 0.20717587f, 0.20292783f, -0.14764220f, 
    0.03758413f, 0.12266612f, -0.23186575f, -0.74371707f, -0.12566763f, -0.15473449f, -0.03199833f, 0.06914534f, 
    0.10700830f, -0.05766756f, -0.29044482f, -0.04614384f, -0.10340016f, 0.05853684f, 0.13481283f, 0.06701704f, 
    0.11329542f, 0.22887169f, -0.05473490f, 0.12858680f, 0.02671172f, 0.17212574f, -0.13415872f, -0.07065114f, 
    -0.11870486f, 0.22839929f, -0.00049552f, 0.11880622f, -0.30714202f, -0.11395945f, 0.09982232f, -0.02678105f, 
    0.03645420f, 0.03612746f, 0.03682898f, -0.25689891f, -0.03160699f, 0.03352167f, 0.11523686f, -0.11101722f, 
    -0.02248233f, 0.02932454f, -0.07110782f, -0.15988618f, 0.09167142f, 0.20506576f, 0.08966023f, 0.24254973f, 
    0.03827387f, 0.15426919f, 0.10276398f, 0.03528885f, 0.15721069f, -0.02958489f, -0.04892603f, 0.32080388f, 
    -0.00855667f, 0.17930095f, -0.20572451f, 0.00418819f, -0.23448320f, 0.12369899f, -0.03433301f, 0.18204311f, 
    0.09822612f, 0.01623403f, 0.02008669f, 0.06546814f, -0.03939905f, 0.03611371f, 0.14415203f, 0.09832090f, 
    0.12508230f, -0.11312985f, 0.01922907f, 0.33373961f, 0.11187775f, 0.03718781f, 0.09891892f, 0.06822521f, 
    0.01737033f, -0.03476070f, 0.16190249f, -0.07976453f, -0.16495691f, -0.06768455f, -0.15179558f, -0.14704941f, 
    -0.05307933f, -0.04744653f, -0.03598293f, -0.00175014f, 0.13589741f, -0.02171806f, -0.14523548f, -0.21824673f, 
    -0.14642790f, 0.15221179f, 0.00066640f, 0.12396218f, 0.14851545f, -0.30752394f, 0.10040700f, 0.01595757f, 
    0.11686519f, 0.02983255f, 0.09814830f, -0.01808558f, -0.06665497f, 0.19620898f, -0.08823800f, 0.30347684f, 
    -0.17572607f, 0.35906571f, -0.06340384f, -0.00539093f, 0.03136002f, 0.01967080f, 0.31623966f, 0.00586091f, 
    0.10020038f, -0.40303519f, -0.34461108f, -0.19534647f, 0.04833829f, -0.13178252f, 0.24642166f, 0.30627099f, 
    -0.76764363f, -0.24567474f, -0.62092209f, 0.31215996f, -0.10827487f, 0.25822875f, 0.13715549f, -0.14259785f, 
    0.56670964f, -0.28096411f, -0.59474969f, -0.21317843f, -0.04313669f, -0.36313966f, 0.06273088f, 0.10718204f, 
    0.07316270f, 0.01892388f, -0.00527932f, -0.24483806f, 0.07432505f, 0.10447264f, 0.00399693f, 0.28209701f, 
    0.06318361f, 0.06682888f, 0.28290012f, -0.25746131f, 0.01747118f, -0.18903619f, -0.26693603f, 0.16585791f, 
    -0.14152116f, 0.13705242f, -0.00257601f, -0.28478765f, 0.76823688f, -0.42880046f, 0.01168199f, 0.04707901f, 
    0.12979509f, -0.02353005f, 0.03866975f, 0.01135571f, 0.22124808f, -0.43064260f, 0.00382554f, -0.07333583f, 
    -0.19719093f, 0.24795410f, -0.14783262f, -0.06048315f, 0.00353907f, 0.43300569f, -0.03514218f, 0.55688661f, 
    -0.21257505f, -0.15828733f, 0.03213695f, -0.05333615f, -0.07064372f, 0.14813764f, 0.17017058f, 0.25993589f, 
    0.11291000f, -0.19253209f, 0.14653517f, -0.41373855f, -0.02352539f, 0.05909079f, -0.00689583f, -0.02188506f, 
    -0.04740941f, 0.18247232f, 0.10022774f, -0.15345934f, 0.13514142f, -0.11366420f, 0.15832211f, -0.07682984f, 
    0.01315498f, 0.02887570f, -0.00933944f, 0.04367489f, 0.02543432f, -0.05704085f, -0.02151307f, 0.03323869f, 
    -0.04425307f, -0.04894161f, -0.03329336f, -0.06429609f, -0.06672443f, -0.02470042f, 0.03836565f, 0.02602460f, 
    0.05013552f, 0.00302300f, -0.01369608f, -0.04141099f, -0.01030839f, -0.05793058f, 0.00570738f, -0.02036739f, 
    -0.04188345f, -0.06441876f, -0.04510251f, 0.04415562f, -0.01305972f, -0.04728611f, 0.01567994f, 0.00222328f, 
    -0.04935312f, -0.04100226f, -0.02420437f, -0.02961631f, -0.00678406f, 0.00786058f, -0.01057118f, -0.00687084f, 
    -0.03632460f, 0.01423838f, -0.04660651f, -0.03713061f, -0.02741810f, -0.01145915f, -0.05678103f, 0.02568631f, 
    0.00470380f, -0.03346060f, 0.03597775f, -0.01673621f, -0.05486340f, -0.00947985f, 0.02442128f, 0.03423457f, 
    0.03724366f, -0.05185989f, -0.05745259f, -0.05629665f, -0.06774358f, 0.00405642f, 0.01893670f, -0.02298950f, 
    0.02233148f, -0.05764746f, -0.02275515f, 0.04612567f, 0.03440488f, -0.06354101f, -0.01936114f, -0.02848266f, 
    0.04306076f, 0.02084326f, -0.04295718f, -0.01406149f, -0.02929861f, -0.00519254f, 0.01784338f, -0.02809254f, 
    0.03174667f, -0.01626745f, 0.01392844f, -0.00770027f, -0.04650892f, -0.04773738f, -0.04551144f, 0.00164257f, 
    0.04440496f, -0.00997320f, 0.05706322f, -0.05426525f, 0.03740606f, -0.00433299f, -0.02252097f, -0.02908366f, 
    -0.02954202f, 0.01675268f, 0.02220684f, -0.00608853f, 0.00711071f, 0.02167368f, 0.04964011f, -0.01064922f, 
    0.03700292f, 0.00347441f, 0.05627820f, -0.01117261f, 0.03308157f, 0.01235154f, 0.02192186f, -0.04856282f, 
    -0.03863847f, -0.01702935f, -0.03612249f, -0.05868157f, -0.01276423f, -0.01471936f, 0.01615481f, -0.05446394f, 
    -0.03176048f, 0.03539258f, -0.06640979f, 0.01432750f, -0.06545664f, -0.02091921f, 0.02863118f, -0.02907543f, 
    -0.02105806f, -0.02442985f, 0.01848444f, -0.06549807f, 0.02809686f, 0.02089169f, 0.02704620f, -0.04049949f, 
    -0.05445443f, -0.03216569f, -0.03323470f, -0.00685338f, -0.02672496f, -0.05603254f, -0.06530047f, 0.02639969f, 
    0.02402095f, 0.04637710f, -0.04308524f, -0.00306650f, -0.01563470f, -0.06414033f, 0.02682095f, -0.05005765f, 
    -0.00600159f, 0.02098145f, -0.03509115f, -0.03019373f, 0.01097531f, 0.01500287f, 0.01562499f, -0.04362866f, 
    -0.02536584f, 0.00856197f, 0.01140961f, 0.02366705f, -0.01130195f, -0.03930067f, -0.04090732f, 0.02088487f, 
    0.03041915f, 0.00727250f, 0.02003689f, -0.02047981f, 0.04451056f, -0.04444940f, -0.04168786f, 0.03118411f, 
    0.02634665f, -0.04285441f, 0.00829459f, 0.02697115f, -0.00557569f, -0.00316655f, -0.05289599f, 0.00906060f, 
    0.05034905f, -0.03494062f, -0.04404695f, -0.01460388f, -0.01348852f, 0.03160847f, 0.01022361f, 0.04249790f, 
    0.00565868f, -0.02123730f, 0.02864400f, 0.00714340f, -0.03445235f, -0.00769976f, -0.02471837f, 0.00322997f, 
    -0.03021881f, 0.02661248f, -0.00458687f, -0.02715245f, 0.03341799f, 0.04264290f, -0.05947651f, -0.00698392f, 
    0.05083044f, 0.00685684f, -0.06666662f, -0.02848805f, -0.01720564f, -0.06259874f, -0.04330707f, 0.03244309f, 
    0.01783601f, 0.03755546f, 0.00693560f, -0.02835950f, -0.04640584f, -0.01095174f, 0.05136403f, -0.04739381f, 
    0.03905543f, 0.00040319f, 0.03034403f, 0.01461041f, -0.02387912f, -0.03240765f, -0.02285100f, -0.05046842f, 
    0.02800160f, -0.05999899f, -0.04757277f, 0.00003858f, -0.01377315f, 0.04479288f, -0.05461459f, 0.04039790f, 
    0.02407101f, 0.00472378f, -0.02949903f, 0.03673000f, -0.02663273f, -0.05240248f, 0.00993193f, -0.03443055f, 
    0.04238558f, -0.00925168f, -0.06609665f, -0.03115343f, 0.04552285f, 0.01677572f, -0.02401782f, 0.03639338f, 
    0.02656464f, 0.04982099f, -0.05264192f, -0.04911027f, -0.01360344f, -0.02277097f, -0.01345970f, -0.03069726f, 
    -0.06406676f, 0.04682384f, -0.01143345f, 0.02832866f, -0.01246065f, -0.04588235f, 0.06322793f, 0.00003522f, 
    0.02273960f, -0.00562096f, -0.03538474f, -0.00398247f, -0.05041528f, 0.00130346f, 0.01212181f, -0.01914955f, 
    0.00884649f, 0.02845607f, 0.03499498f, 0.00681292f, -0.04042204f, 0.05432639f, -0.05771390f, -0.01829701f, 
    0.04223153f, 0.30765232f, -0.11828049f, -0.14856322f, 0.04780076f, -0.03344030f, -0.06084195f, 0.19317926f, 
    0.01819137f, 0.48553282f, 0.24087313f, -0.46308151f, 0.05621579f, 0.08330800f, -0.01030670f, -0.07684159f, 
    0.05156339f, 0.06400941f, 0.50700814f, -0.05646699f, -0.35958517f, 0.12193193f, -0.05662771f, -0.06062336f, 
    -0.21612608f, -0.02762446f, -0.15177299f, -0.20067506f, -0.01277782f, 0.00482203f, -0.06380509f, 0.02151025f, 
    0.05160211f, 0.13302019f, -0.10127615f, 0.17942168f, 0.25848520f, -0.03028632f, -0.12103572f, -0.14175785f, 
    0.05281906f, 0.13999169f, 0.07707667f, 0.15006912f, 0.12071013f, 0.15023836f, 0.22206731f, -0.43465114f, 
    0.05801022f, 0.07956782f, -0.06513202f, -0.28333074f, -0.18722783f, -0.07535282f, 0.47402591f, 0.22822315f, 
    -0.44310990f, -0.05460581f, 0.12427595f, 0.07270453f, 0.09738830f, 0.10949026f, 0.00652782f, -0.23096816f, 
    0.02991651f, 0.10838582f, -0.14818834f, -0.03719391f, -0.03854772f, -0.08964682f, 0.03714057f, 0.26687217f, 
    -0.17871580f, -0.08352824f, -0.07013407f, 0.07366627f, 0.00188920f, 0.05804770f, 0.11597056f, -0.19394490f, 
    0.04960689f, 0.71891093f, 0.89129758f, -0.11460787f, 0.27413580f, -0.21466590f, 0.00599772f, 0.13370654f, 
    0.01936795f, 0.04824146f, -0.15450931f, -0.00850134f, 0.09577417f, -0.04126431f, 0.09244040f, -0.01122716f, 
    -0.15441063f, -0.07558966f, -0.02672897f, 0.84305561f, 0.30304572f, -0.37316585f, -0.01457819f, 0.07313218f, 
    0.05055940f, -0.02281662f, 0.04444244f, 0.08226453f, -0.09422468f, -0.13885127f, 0.04711093f, 0.07013781f, 
    0.05779501f, 0.05544826f, 0.05792432f, -0.01890157f, -0.27888358f, 0.05978599f, -0.26819640f, -0.19610114f, 
    0.07961041f, -0.09093901f, -0.02366147f, -0.01665756f, -0.08706763f, -0.22766806f, 0.17949167f, 0.06122887f, 
    0.25241655f, -0.13494115f, -0.10383652f, 0.12855735f, 0.11939153f, -0.00453137f, 0.13520597f, 0.22603120f, 
    -0.20238248f, 0.03491623f, 0.01326820f, 0.16439940f, -0.28287235f, -0.01654617f, -0.00449853f, -0.01226205f, 
    -0.00947340f, -0.03418805f, 0.07688139f, 0.03231440f, -0.15812337f, -0.02131665f, 0.00026870f, 0.06123974f, 
    0.15464556f, 0.00649350f, 0.14368407f, -0.22725503f, 0.05637611f, 0.00276719f, -0.01303568f, 0.04780956f, 
    -0.00278292f, 0.03643299f, -0.06330245f, 0.14759322f, -0.00592764f, 0.10679083f, 0.17422348f, -0.02441301f, 
    -0.27331305f, -0.21774454f, 0.09268840f, 0.11904893f, 0.09821319f, 0.13031593f, -0.15625665f, -0.16447745f, 
    -0.31637779f, -0.02785255f, -0.08344156f, 0.05238067f, 0.10372298f, 0.21042667f, -0.09385047f, 0.02950145f, 
    0.14006549f, -0.16260517f, -0.04456228f, -0.02226365f, 0.22325757f, -0.11771628f, 0.04915776f, 0.12680358f, 
    -0.12056245f, -0.18180661f, 0.06898271f, 0.05616636f, 0.07678577f, -0.03548309f, -0.12739176f, 0.05541067f, 
    0.14114720f, 0.00803461f, 0.10365730f, -0.18041553f, -0.05923693f, -0.05380832f, -0.24346705f, -0.00672075f, 
    -0.05088163f, -0.05730509f, -0.27304912f, 0.19813655f, 0.06381536f, 0.40403840f, 0.07225510f, -0.12902123f, 
    0.53883457f, -0.07430361f, -0.28241462f, -0.02043225f, 0.01971597f, -0.03930123f, 0.03417178f, 0.07469599f, 
    -0.02569175f, -0.06432742f, 0.05275992f, 0.10286580f, 0.01806651f, -0.01982878f, 0.08123700f, -0.05824654f, 
    0.07358456f, 0.19609764f, 0.03235842f, -0.08416652f, 0.14317013f, -0.13898687f, 0.24798940f, 0.06717122f, 
    -0.07666010f, -0.10889135f, -0.00899072f, -0.50000834f, -0.32811958f, 0.15432741f, -0.20000681f, 0.13258630f, 
    0.30804038f, 0.22328034f, -0.25510105f, 0.29627839f, -0.11125797f, 0.04323506f, -0.19975103f, -0.02203901f, 
    0.03058938f, 0.01455444f, -0.07211988f, -0.15766586f, -0.32649833f, 0.30812663f, -0.28743839f, -0.30114135f, 
    -0.00621791f, 0.03781491f, 0.19566369f, 0.03264752f, -0.01842635f, 0.32523310f, 0.17746893f, 0.16012375f, 
    0.21144193f, -0.03594683f, 0.12287974f, 0.02638372f, 0.00935612f, -0.27648616f, -0.16951364f, 0.01719127f, 
    0.02729681f, -0.68053895f, -0.01468372f, 0.00180003f, 0.03066369f, 0.06265602f, 0.07285774f, -0.13315944f, 
    0.03196598f, 0.18575956f, 0.30940214f, 0.24998288f, 0.16622829f, -0.05468545f, 0.05218758f, 0.19366775f, 
    -0.06242049f, -0.07491366f, 0.04324116f, 0.22425748f, 0.06322567f, 0.09926163f, -0.02069976f, -0.01605428f, 
    0.05889244f, 0.13360101f, 0.44683623f, 0.26864439f, 0.39742091f, 0.26272473f, -0.05291875f, -0.07032798f, 
    0.06613373f, -0.02271545f, 0.24466947f, 0.21864757f, 0.19467553f, -0.14052454f, -0.04604951f, -0.08896248f, 
    0.10743888f, 0.18012609f, 0.09123975f, -0.18531758f, -0.08465052f, 0.04746247f, 0.06734721f, 0.27726138f, 
    -0.05347940f, -0.13291764f, -0.08147714f, -0.06816757f, -0.07659309f, -0.03072616f, -0.14754041f, 0.44665459f, 
    0.17365175f, 0.04496974f, -0.05443314f, -0.06865397f, 0.21036519f, 0.22821398f, 0.01519588f, -0.46981928f, 
    -0.09778619f, 0.10571180f, -0.09709090f, 0.08297373f, 0.21689607f, 0.03066078f, 0.12410348f, -0.11345001f, 
    0.17477271f, -0.11556238f, 0.21911979f, -0.03346027f, -0.05093357f, 0.14610185f, 0.05528985f, 0.06671765f, 
    -0.03162559f, 0.23308513f, 0.07101668f, 0.18694150f, -0.04792056f, 0.13143902f, 0.17558548f, 0.39100504f, 
    0.03980998f, 0.59940839f, -0.27099267f, -0.70227540f, 0.03203045f, 0.15932430f, -0.04600328f, 0.19388340f, 
    0.11498799f, 0.05012609f, 0.12048385f, 0.21701288f, -0.09257983f, 0.04756679f, 0.09400605f, 0.03216734f, 
    0.16775036f, 0.11094547f, -0.06970026f, -0.02134519f, -0.04246772f, 0.31990245f, 0.32021379f, -0.07229000f, 
    0.08388713f, -0.01280936f, -0.01278441f, 0.04739887f, 0.16844253f, 0.29385126f, -0.11682881f, 0.10987571f, 
    0.00615193f, 0.11338769f, 0.17098111f, 0.10130984f, -0.13050470f, 0.26125064f, 0.29181516f, 0.42906383f, 
    0.06912465f, 0.17524712f, 0.12796657f, 0.21957269f, 0.19969364f, 0.04332421f, -0.00915473f, 0.08239672f, 
    -0.04088201f, 0.22376984f, 0.03072206f, -0.21505176f, -0.25699517f, -0.73224580f, -0.19841598f, -0.32185373f, 
    -0.28816274f, 0.54473191f, -0.02584178f, 0.07762989f, 0.29582512f, 0.09946092f, -0.31497499f, 0.02131876f, 
    0.05367458f, -0.04676808f, -0.00945755f, 0.07212179f, 0.06976364f, -0.11707288f, 0.18163237f, -0.07834886f, 
    -0.13945632f, -0.04164978f, -0.04685360f, 0.06891628f, 0.19672802f, 0.24048847f, -0.23669896f, 0.02415030f, 
    -0.26439548f, -0.18585590f, -0.07849371f, -0.04354480f, -0.38112247f, 0.14283881f, 0.05694889f, 0.10647621f, 
    0.03965179f, 0.27397600f, -0.02106689f, -0.08961814f, -0.07453503f, 0.07302879f, 0.06117930f, 0.01723184f, 
    0.04953463f, -0.02121876f, -0.32382411f, -0.14983968f, -0.08299759f, 0.09638338f, 0.08300015f, 0.18311383f, 
    0.17308767f, 0.20567903f, -0.09536812f, 0.25644073f, -0.17187916f, 0.10507669f, -0.03209570f, 0.00745570f, 
    0.19080107f, 0.01714975f, 0.12560025f, 0.09830763f, 0.34698111f, -0.21298729f, -0.08999015f, -0.09199768f, 
    -0.26383087f, 0.03343222f, 0.22988251f, 0.19973283f, 0.21150310f, 0.26127478f, 0.07215524f, 0.65061998f, 
    0.01089283f, -0.02650675f, 0.18044885f, 0.04677303f, 0.32975200f, 0.03455703f, 0.38317820f, -0.08591912f, 
    -0.12341451f, -0.12060368f, 0.13331909f, -0.05446216f, -0.02348423f, 0.23159868f, 0.06750835f, 0.21374716f, 
    0.27679798f, 0.30009586f, 0.07557709f, -0.18054704f, -0.08398016f, -0.11969856f, -0.00483687f, 0.13840276f, 
    0.13397035f, -0.06239629f, -0.47438416f, 0.31226075f, 0.14425680f, 0.12426247f, 0.11728869f, 0.26953337f, 
    0.04351044f, 0.21815616f, -0.03277544f, 0.07316916f, 0.12826657f, 0.09033249f, 0.17855844f, -0.22705655f, 
    -0.35933262f, 0.11614389f, 0.14037265f, 0.14002873f, -0.16885224f, 0.20779343f, 0.23357677f, 0.01455682f, 
    0.07548211f, 0.09538589f, -0.00709851f, 0.25294003f, 0.20337956f, -0.09961510f, 0.01743424f, 0.24269098f, 
    0.19723713f, 0.17198181f, -0.09769202f, -0.03127521f, 0.24286848f, -0.14672075f, 0.07382500f, -0.11015196f, 
    -0.26034650f, 0.11576351f, 0.31532505f, 0.00491578f, 0.27109724f, 0.30038646f, -0.27536646f, -0.03465897f, 
    0.01972416f, 0.37403992f, 0.08138158f, 0.12362381f, 0.00661020f, 0.13152158f, 0.13290632f, 0.09877849f, 
    -0.50809962f, -0.38960913f, -0.09214713f, 0.09302321f, 0.09422778f, 0.01286243f, -0.13004078f, 0.04394434f, 
    -0.06121626f, 0.43483108f, 0.63441378f, -0.46527693f, -0.04351687f, -0.05882230f, -0.16635887f, -0.00400555f, 
    0.05964327f, 0.00371722f, -0.56270576f, -0.37348050f, -0.62879056f, -0.08703248f, 0.11024767f, 0.00425525f, 
    -0.00745145f, -0.13044928f, 0.00852395f, 0.17266332f, -0.03011604f, 0.11092571f, 0.09498976f, 0.05128946f, 
    0.03824546f, 0.11934508f, 0.04096422f, 0.02513722f, -0.54943895f, -0.43363822f, -0.20100121f, 0.00433858f, 
    0.06435619f, 0.01351665f, -0.04981966f, -0.12522808f, -0.11253352f, -0.51654291f, -0.42386833f, -1.09111536f, 
    0.04645913f, 0.02345162f, -0.15834868f, -0.04978412f, 0.18065093f, 0.06790447f, 0.72675389f, -0.00671973f, 
    0.31794727f, -0.14303064f, 0.19801545f, -0.00432401f, 0.11127558f, 0.14939894f, 0.01613498f, 0.11568496f, 
    0.02748276f, -0.05297764f, 0.06129381f, -0.04817719f, 0.12863508f, 0.12076741f, 0.14954348f, -0.19721921f, 
    0.46150786f, 0.19374831f, 0.00305532f, -0.16011494f, -0.18612380f, 0.11115998f, -0.10140375f, 0.11204854f, 
    0.03438279f, -0.18986094f, 0.32150853f, -0.07420618f, 0.09731544f, -0.13478455f, -0.25655672f, 0.15767340f, 
    0.08452940f, 0.00889496f, 0.07268891f, -0.01408945f, 0.01863953f, 0.09563515f, 0.15920414f, -0.08899325f, 
    -0.01745319f, 0.05428776f, -0.03169365f, 0.71772021f, 0.85614055f, 1.08819592f, -0.16349354f, 0.00776320f, 
    -0.10324272f, -0.01217204f, 0.06194047f, 0.08221304f, 0.19304170f, 0.10687511f, -0.02457475f, 0.05232119f, 
    0.18211995f, 0.02754081f, 0.02843845f, 0.21458687f, 0.27990252f, -0.09879526f, -0.04019520f, 0.04786002f, 
    -0.13905723f, 0.02972426f, 0.03634304f, 0.17999917f, -0.09790406f, 0.30896690f, 0.11461424f, 0.20033275f, 
    0.04620169f, -0.00069253f, 0.12721390f, 0.12866059f, 0.02885698f, -0.04029777f, -0.04104728f, 0.48898438f, 
    -0.00471667f, -0.34200928f, -0.34155312f, -0.24001759f, -0.57967877f, 0.03217131f, 0.04517967f, -0.06554298f, 
    0.12852195f, 0.10682941f, 0.00371132f, 0.06604480f, -0.03147851f, -0.03802901f, -0.07132560f, 0.06050085f, 
    -0.08229665f, 0.15117161f, 0.01222180f, -0.31170198f, 0.16329320f, 0.14284451f, 0.03246687f, -0.02184394f, 
    0.02632855f, -0.11917430f, 0.04978302f, 0.05328751f, -0.01418792f, 0.09323832f, 0.04811301f, -0.02917797f, 
    0.07822271f, -0.05346677f, 0.39034268f, 0.33762309f, 0.26760414f, 0.07071272f, -0.19890779f, -0.12837583f, 
    -0.24775662f, 0.05499659f, -0.06600425f, -0.10076199f, 0.20689440f, -0.02370355f, 0.01607706f, -0.05601435f, 
    -0.02841416f, 0.14026886f, -0.07762892f, 0.13111657f, -0.01710671f, 0.18231341f, 0.06869163f, 0.18338317f, 
    0.16694154f, 0.05543415f, 0.13307786f, 0.05208638f, 0.06820752f, 0.10391197f, 0.18463701f, 0.09349649f, 
    0.14812125f, -0.17241356f, -0.17525494f, -0.36956632f, 0.12362599f, -0.02167982f, 0.41764134f, 0.01896563f, 
    0.15559542f, 0.43131202f, -0.00745849f, 0.19216403f, -0.07091853f, 0.23171003f, 0.23438561f, 0.01260863f, 
    0.48304632f, -0.51681381f, -0.28931159f, -0.07142720f, -0.00918671f, -0.25442418f, -0.09826791f, 0.04114020f, 
    0.09715525f, 0.10033890f, -0.30295125f, 0.03227645f, 0.10650925f, 0.08215111f, 0.01888973f, 0.08597300f, 
    0.01212198f, -0.00396238f, 0.29912648f, 0.14991923f, -0.09118999f, 0.19088474f, -0.34631702f, 0.12857990f, 
    -0.15945619f, -0.14392792f, 0.42708939f, 0.37980101f, 0.07772872f, -0.60374331f, -0.03595696f, 0.08208995f, 
    0.45573911f, 0.17873278f, -0.00410058f, -0.18857606f, -0.73436892f, -0.32566866f, -0.12458361f, -0.03438050f, 
    0.02803263f, 0.15838705f, 0.03811762f, -0.09030091f, 0.05680083f, -0.70563096f, -0.15643694f, -0.38458812f, 
    0.10885419f, 0.06351426f, 0.18542159f, 0.07461822f, -0.07147859f, -0.15155372f, 0.26476493f, 0.27954903f, 
    0.16323447f, -0.49674717f, -0.21169554f, -0.23552445f, -0.03664359f, -0.01448498f, -0.06311081f, -0.31075159f, 
    -0.10624257f, -1.06811106f, -0.12854467f, 0.01001891f, 0.07967677f, -0.06603894f, 0.02815208f, -0.08106434f, 
    -0.13480172f, -0.19422352f, 0.14857832f, 0.27347738f, 0.27384049f, 0.24521583f, 0.07527004f, 0.15493932f, 
    0.06981855f, -0.39706042f, -0.18597640f, 0.04526450f, -0.19131923f, -0.02984132f, -0.14937975f, 0.05483933f, 
    0.01243074f, 0.00906430f, -0.62311381f, -0.24554932f, 0.23830013f, -0.03102948f, -0.24113303f, -0.05145597f, 
    0.14360100f, 0.04979092f, -0.03148464f, -0.18202430f, -0.00850494f, -0.06040976f, -0.00897551f, -0.09271838f, 
    -0.18123460f, 0.08009971f, 0.20815925f, 0.08460125f, -0.12007656f, -0.15227334f, 0.21194772f, -0.04931858f, 
    0.13779788f, 0.09117548f, 0.13799988f, 0.09031466f, 0.27447364f, -0.08981711f, -0.21554023f, 0.03845630f, 
    -0.02633141f, 0.04161312f, 0.15295698f, 0.04853825f, 0.07963258f, -0.03480219f, -0.08984327f, -0.05365856f, 
    -0.05572136f, 0.07313558f, -0.04312529f, 0.10258136f, -0.01659022f, 0.17333834f, 0.20168622f, 0.09482463f, 
    -0.08876631f, 0.23817778f, -0.01641302f, 0.34414145f, -0.02682120f, 0.09434313f, 0.17613077f, 0.17466976f, 
    0.10311379f, 0.08488406f, 0.12679183f, 0.08993011f, 0.04181635f, 0.15431949f, 0.05170933f, 0.09932712f, 
    0.30779684f, 0.39413798f, -0.09592026f, 0.34419557f, 0.02021736f, 0.00864225f, 0.02570818f, 0.01221040f, 
    0.07901143f, 0.07417253f, -0.05282526f, -0.09958840f, 0.06864548f, 0.02075657f, -0.15331841f, -0.07712699f, 
    -0.08596369f, -0.01299393f, 0.12876628f, -0.30085537f, -0.01823815f, -0.01230807f, -0.04267166f, -0.08443441f, 
    -0.27054778f, 0.07114189f, 0.10882435f, 0.13575312f, -0.02564491f, -0.01189305f, -0.11830300f, -0.16592200f, 
    -0.11119805f, -0.08646353f, 0.17769252f, -0.08850592f, -0.20231386f, 0.02804997f, 0.00500999f, -0.26308215f, 
    -0.08639650f, -0.15386982f, 0.07734857f, 0.19113146f, -0.10790870f, -0.06139626f, -0.14851189f, -0.38474482f, 
    -0.00444162f, -0.02951485f, 0.08839409f, 0.08330365f, 0.03707923f, 0.17894091f, 0.20370315f, -0.39103904f, 
    -0.27260324f, -0.38249540f, -0.17271432f, -0.09727620f, -0.14739932f, -0.07898961f, 0.00233251f, -0.10515636f, 
    -0.02434186f, -0.10444074f, -0.07900755f, -0.02852185f, 0.01813401f, 0.13054815f, 0.05598965f, 0.25252137f, 
    0.21576169f, -0.18439691f, -0.44882211f, 0.12084683f, 0.11020333f, 0.16892727f, 0.13625816f, 0.11893518f, 
    0.14462262f, 0.07747629f, 0.09397629f, -0.10111464f, -0.09221907f, -0.07512099f, -0.01346989f, -0.10785255f, 
    0.06779900f, -0.24683405f, -0.10555270f, 0.18909030f, -0.10819834f, -0.39398795f, -0.14392178f, 0.01158780f, 
    0.05186919f, -0.04017505f, 0.15971287f, 0.03810238f, 0.04982483f, 0.24797429f, 0.16384371f, 0.07674272f, 
    0.00014322f, 0.06866241f, 0.08545545f, 0.05089539f, 0.04326438f, -0.30733305f, 0.12570430f, -0.37354234f, 
    -0.25071740f, 0.12870769f, -0.07132909f, 0.07323424f, -0.09767348f, 0.14268535f, -0.02225303f, -0.04159743f, 
    -0.08101331f, -0.03151587f, -0.00113665f, -0.07286725f, 0.03003694f, -0.45913920f, -0.34385675f, -0.15083206f, 
    0.31672257f, -0.40168449f, -0.19738604f, -0.07004479f, -0.34800234f, 0.35881007f, 0.07592943f, 0.33111563f, 
    -0.34805012f, 0.16492538f, 0.10357310f, -0.06108034f, -0.09862863f, -0.01955657f, 0.12581244f, -0.14981276f, 
    -0.04262337f, -0.09350913f, 0.04282372f, 0.15794465f, 0.05954203f, -0.21097954f, -0.03529271f, -0.07367545f, 
    0.28059995f, 0.21151838f, 0.03951254f, 0.13200185f, 0.05580198f, -0.13501669f, 0.10130801f, -0.22534865f, 
    -0.12292294f, -0.13486171f, -0.05811426f, 0.21314225f, -0.52284014f, 0.21734676f, -0.02942989f, 0.13677548f, 
    0.14917338f, 0.05989544f, 0.27947605f, 0.10527276f, 0.03347770f, 0.05283980f, 0.29072845f, -0.12520100f, 
    0.17327346f, -0.14929411f, -0.03881894f, 0.04676044f, -0.00113186f, -0.15981977f, -0.14104219f, -0.21719080f, 
    0.15768918f, 0.05465602f, -0.05772178f, 0.08486760f, 0.13013639f, 0.09700260f, 0.24294116f, -0.01672604f, 
    -0.05737382f, -0.05432848f, -0.06459367f, 0.07374102f, -0.24847089f, 0.04483284f, -0.02447190f, -0.09224429f, 
    -0.11330909f, 0.24089161f, -0.07280635f, 0.09874991f, 0.01862144f, -0.03241755f, -0.00099774f, 0.03121320f, 
    -0.18513711f, 0.01931371f, 0.17934227f, -0.01995171f, -0.04805412f, -0.23441961f, 0.00611853f, 0.02589664f, 
    -0.12515943f, 0.04058447f, -0.08460768f, 0.10215884f, 0.08939602f, -0.04381369f, -0.13393019f, 0.09156875f, 
    0.11570784f, 0.07122465f, 0.03185222f, -0.10455242f, -0.35877636f, 0.15509900f, 0.02701993f, 0.10979257f, 
    0.05011183f, 0.09706806f, -0.05624395f, 0.27260283f, -0.08935916f, -0.05576631f, 0.01619363f, 0.01563043f, 
    -0.03162187f, 0.00636310f, 0.08021671f, -0.02126270f, -0.30274445f, 0.18884401f, 0.05375075f, 0.02051729f, 
    0.14391458f, -0.08568521f, -0.13803838f, -0.06680971f, -0.04442593f, 0.16983464f, -0.13375866f, 0.00440446f, 
    0.07919098f, 0.15857409f, -0.08033360f, 0.00898609f, -0.02806403f, 0.06657668f, -0.04173918f, -0.27174872f, 
    0.05086037f, -0.22602323f, 0.04675672f, -0.05869560f, 0.02655042f, -0.10897612f, 0.10154451f, -0.14109683f, 
    0.25270709f, -0.16519992f, 0.04593896f, -0.03746708f, -0.04401989f, 0.18466248f, -0.11498991f, -0.02253770f, 
    0.18631674f, -0.39526752f, 0.47139886f, -0.00708289f, -0.04708496f, 0.20409270f, 0.12845606f, 0.07815070f, 
    -0.04381942f, -1.13456082f, 0.70568204f, -0.17898966f, -0.02011724f, 0.19886157f, 0.20519508f, -0.14699726f, 
    -0.10751334f, -0.20255592f, 0.10700865f, 0.30092973f, -0.25743255f, -0.02729600f, 0.01785165f, -0.14967208f, 
    0.14033373f, 0.00354756f, -0.04910528f, -0.09656423f, 0.18939276f, 0.21814676f, -0.09742681f, -0.20376270f, 
    -0.09316324f, -0.01227015f, 0.09964415f, 0.19211981f, -0.00681548f, 0.28685653f, 0.16464087f, -0.04267424f, 
    -0.09913173f, -0.14233918f, 0.07392308f, -0.02305190f, -0.01571570f, -0.00056036f, -0.28080323f, -0.18163610f, 
    -0.03751092f, 0.09605552f, -0.00098222f, -0.01534045f, -0.04863730f, -0.06630592f, -0.29034117f, -0.03967279f, 
    0.01868112f, 0.27806053f, 0.14645520f, 0.16404290f, -0.07778678f, -0.12750460f, -0.13188051f, 0.15317723f, 
    0.21410772f, 0.26591113f, -0.32136270f, -0.23166798f, -0.28910449f, 0.19947046f, 0.07463486f, -0.13039342f, 
    -0.06108095f, 0.00634476f, -0.05306771f, 0.19624186f, 0.06597443f, 0.00302484f, -0.06599518f, -0.30045748f, 
    -0.02309773f, -0.30196711f, 0.19257484f, 0.20377560f, 0.04734268f, -0.05406330f, -0.23769459f, -0.19800673f, 
    -0.04716732f, -0.10558701f, -0.24359152f, -0.02902246f, 0.27580276f, 0.13703330f, -0.06056520f, 0.08324295f, 
    0.05820775f, -0.02927990f, -0.09202240f, -0.05696398f, 0.00218813f, -0.12955846f, -0.06058121f, 0.01641120f, 
    0.01137292f, 0.14706869f, -0.15112677f, -0.09094869f, 0.21756448f, 0.08220825f, -0.00558304f, -0.01197913f, 
    0.18371086f, 0.14876987f, 0.06191604f, 0.24573895f, -0.10487429f, 0.12774506f, -0.19134736f, 0.26737756f, 
    0.16950752f, -0.01103282f, 0.05488925f, -0.04796410f, -0.03073554f, -0.15524110f, -0.27702135f, 0.13649499f, 
    0.40956831f, 0.04541071f, 0.00417430f, -0.10250435f, 0.09208100f, -0.05899540f, -0.08347386f, -0.51647604f, 
    -0.58888680f, 0.61574525f, -0.20143747f, 0.28140029f, -0.00477970f, 0.01794998f, -0.02179685f, -0.32008314f, 
    -0.19951211f, 0.05904196f, -0.05620008f, -0.16538014f, 0.20133407f, -0.01270739f, 0.10913137f, 0.19781505f, 
    0.04971154f, 0.11460220f, -0.05039068f, -0.17287888f, -0.12940742f, 0.03046632f, 0.01251472f, 0.14897609f, 
    0.23187809f, -0.14298739f, 0.28817955f, -0.76813161f, 0.44135329f, 0.17325008f, -0.00295727f, -0.03945296f, 
    -0.01575097f, 0.01722034f, 0.28863782f, -0.51142740f, 0.05480885f, 0.21276200f, 0.12602763f, 0.57571417f, 
    0.22220244f, 0.10664838f, 0.05986633f, -0.05757530f, 0.13102648f, -0.04176199f, 0.29171190f, 0.10903501f, 
    0.09865447f, 0.03369419f, 0.00476893f, -0.15379795f, -0.01759342f, -0.33013222f, -0.07063332f, 0.18874648f, 
    -0.05839624f, -0.22214989f, 0.05810960f, -0.10193329f, 0.08159377f, -0.13074595f, -0.28859055f, 0.37907782f, 
    0.35838121f, -0.05955220f, 0.05592763f, 0.07460160f, 0.04838100f, -0.21125953f, -0.08298521f, -0.20023759f, 
    -0.19002990f, 0.33608782f, 0.09350976f, -0.17259750f, 0.00851516f, 0.14071903f, -0.02615359f, 0.04444492f, 
    -0.13156706f, -0.40088972f, -0.36942098f, -0.08329871f, 0.03521139f, 0.24606232f, 0.00519129f, 0.25072992f, 
    -0.06166674f, -0.29765582f, 0.09255503f, -0.50816113f, -0.24998909f, -0.11952311f, -0.15961504f, -0.08649860f, 
    -0.08872337f, 0.02759456f, -0.29831359f, 0.06122490f, -0.86784750f, -0.09270030f, 0.10330120f, 0.08518205f, 
    0.01677513f, -0.03345113f, 0.03880037f, 0.42933267f, -0.04791461f, -0.01950770f, 0.10004234f, 0.06463597f, 
    -0.04391606f, 0.03374967f, 0.03461448f, -0.14191659f, -0.53393483f, -0.33051863f, -0.42494985f, 0.07367843f, 
    0.13435014f, -0.12379768f, 0.02232062f, 0.01168105f, -0.06754905f, -0.21322876f, -0.25791425f, -0.33553043f, 
    -0.18838285f, 0.11766027f, -0.26469636f, 0.10922098f, 0.02358881f, 0.09601987f, -0.60446900f, -0.02121041f, 
    0.72845399f, -0.04396771f, 0.09983148f, -0.03113746f, -0.07205206f, 0.13788606f, -0.04651684f, 0.34742466f, 
    0.07950830f, -0.07260215f, 0.17717502f, -0.15106151f, 0.29231051f, 0.07105133f, -0.01041959f, -0.15014434f, 
    0.08626559f, 0.53039414f, 0.26166177f, 0.03505558f, 0.01280431f, 0.23889740f, 0.21035919f, 0.05546031f, 
    0.02608799f, 0.02057639f, -0.24823824f, -0.31658748f, -0.15111245f, 0.04957208f, 0.17905608f, -0.02999577f, 
    0.21557395f, -0.00128243f, 0.31986925f, -0.03846898f, 0.06723875f, 0.01292419f, 0.07434148f, -0.02687233f, 
    -0.00453817f, 0.10709481f, -0.00767625f, -0.30231395f, -0.12010405f, 0.12197985f, -0.01220195f, -0.10593145f, 
    -0.54591978f, -0.04867788f, -0.04477975f, 0.01415769f, -0.20461474f, -0.09791131f, -0.04571458f, -0.05864403f, 
    0.08248230f, -0.08088233f, -0.13537335f, 0.10209490f, 0.09572534f, 0.02027016f, 0.20651369f, 0.23538028f, 
    -0.10310876f, -0.01501630f, 0.03101072f, 0.05480509f, 0.21987250f, 0.33860034f, 0.03234392f, -0.01479046f, 
    -0.04705586f, -0.08568063f, 0.14454193f, -0.02908091f, -0.04284642f, -0.31340244f, -0.17176926f, -0.95552093f, 
    0.05219048f, 0.81328160f, -0.02848518f, -0.00947160f, -0.09317347f, -0.27307591f, 0.03339007f, 0.00783785f, 
    0.27615425f, 0.07348776f, -0.23738015f, -0.07336178f, -0.03402658f, 0.07459797f, 0.04985374f, 0.08214074f, 
    0.06480439f, -0.07811889f, 0.47849834f, 0.03311887f, -0.31077942f, 0.21865954f, -0.08376687f, 0.06199521f, 
    -0.02732439f, -0.04828449f, -0.38024268f, 0.24867387f, -0.16619304f, -0.14855908f, 0.04374794f, 0.07108932f, 
    0.07110627f, -0.22736830f, 0.24692398f, -0.36966056f, -0.05508469f, 0.16881078f, -0.13378495f, -0.04491791f, 
    0.07226370f, 0.14550188f, -0.18735155f, 0.13497441f, -0.09407142f, 0.39693087f, 0.23024625f, 0.02660856f, 
    -0.01190593f, -0.08319305f, 0.18075711f, 0.11509094f, -0.01652517f, 0.07524680f, 0.14270112f, -0.02448535f, 
    0.11027500f, 0.01056752f, 0.06645148f, 0.08492117f, 0.15095620f, -0.11134291f, 0.05194724f, 0.14030428f, 
    -0.22367182f, -0.03909915f, 0.06390987f, 0.04056790f, -0.12183709f, 0.14131074f, 0.44011027f, 0.07032576f, 
    -0.55879819f, 0.25709683f, 0.08297561f, 0.09263869f, 0.15078031f, 0.39554185f, 0.13349259f, -0.21262211f, 
    0.00296066f, -0.08914576f, 0.17239223f, -0.10530382f, 0.05600809f, -0.07979367f, -0.16028319f, 0.03562760f, 
    0.12779519f, 0.57966691f, -0.17037851f, -0.28557324f, 0.13229409f, 0.24255742f, 0.03754480f, 0.08117841f, 
    0.11203276f, 0.08927143f, -0.67163062f, 0.26651984f, -0.14702930f, -0.20630771f, -0.05852884f, -0.03098863f, 
    0.08980009f, -0.03364100f, 0.16351791f, 0.76522994f, -0.42072737f, -0.26035282f, 0.12808266f, -0.29000023f, 
    0.41542092f, 0.13691446f, -0.18622726f, -0.09584226f, -0.46507752f, 0.26526198f, -0.19287796f, 0.17997898f, 
    0.14725538f, -0.11125155f, 0.10326806f, -0.02971014f, 0.31237856f, -0.53140891f, -0.21040837f, -0.59892881f, 
    -0.01534134f, 0.09578762f, -0.03657151f, 0.02921701f, -0.02048975f, -0.29753268f, -0.05085597f, -0.01911658f, 
    -0.01675565f, -0.08082369f, -0.25404528f, 0.05140047f, 0.26259404f, -0.02069500f, 0.20170586f, -0.24930596f, 
    0.16488580f, -0.00139700f, 0.03248017f, 0.21208422f, 0.15918328f, 0.10269728f, 0.10872301f, 0.15815197f, 
    0.02202767f, 0.03969125f, -0.04885005f, -0.01015166f, -0.05028387f, -0.03955204f, 0.02908292f, -0.05994854f, 
    -0.06428454f, -0.01676338f, 0.00698276f, 0.03143316f, -0.01586670f, -0.02160368f, 0.03310461f, -0.05259505f, 
    -0.04075740f, 0.01326015f, 0.05303665f, -0.04583120f, -0.02833740f, 0.01285536f, -0.03728821f, 0.04865161f, 
    -0.01346623f, 0.04061926f, -0.02034768f, 0.02090457f, 0.01691511f, -0.00918027f, -0.04707822f, 0.05111802f, 
    -0.04164657f, 0.02635558f, 0.00269925f, 0.03995388f, -0.04534213f, -0.00951448f, -0.05233635f, -0.02255480f, 
    -0.04880534f, -0.07024731f, -0.06118440f, -0.01691101f, -0.02286020f, 0.02723909f, -0.01122941f, 0.02733800f, 
    -0.05707804f, -0.01767881f, -0.00264627f, -0.03941738f, 0.02701722f, -0.04561530f, -0.04792272f, -0.02721890f, 
    -0.02004006f, -0.03610800f, 0.02287131f, 0.04946346f, 0.04576022f, 0.00963652f, -0.06159376f, 0.01736323f, 
    0.04771451f, 0.01165588f, -0.03731254f, 0.02952900f, -0.02963229f, -0.05228015f, -0.05949463f, 0.03627102f, 
    0.04604741f, 0.04021771f, -0.00578126f, 0.03634423f, -0.04747799f, 0.00062697f, 0.01969133f, 0.03018363f, 
    0.00898120f, 0.02939836f, -0.04614235f, 0.02234826f, -0.03155611f, -0.04489671f, 0.02274615f, 0.02502815f, 
    -0.00182276f, 0.04046836f, -0.04222932f, -0.00036487f, -0.03139181f, -0.05154379f, -0.03586363f, -0.03071471f, 
    -0.03586669f, 0.00126470f, -0.04456326f, -0.02217565f, 0.00718039f, -0.02316591f, 0.02377079f, 0.06474366f, 
    0.04256267f, 0.02369402f, -0.02392535f, 0.00348709f, -0.05219155f, -0.01043247f, -0.03098869f, 0.03346543f, 
    -0.02678453f, -0.03456492f, 0.04965317f, 0.02574539f, -0.06749085f, -0.03542604f, -0.04205098f, -0.05993377f, 
    0.04017717f, -0.06364396f, -0.05445541f, -0.03021010f, -0.01597039f, 0.04082831f, 0.03286459f, -0.05776142f, 
    -0.04938697f, -0.00080162f, 0.03525131f, -0.05111848f, -0.04534378f, -0.01092288f, 0.03042039f, -0.01129603f, 
    -0.01742088f, 0.03539619f, 0.03835488f, -0.01744084f, -0.02639567f, 0.00680724f, -0.05546952f, 0.00353093f, 
    -0.04092687f, -0.05503513f, 0.03710359f, -0.02211986f, -0.02536464f, 0.03982375f, -0.03036056f, -0.01002203f, 
    0.03796729f, 0.03031902f, -0.00728300f, 0.04256932f, -0.03162257f, 0.02459721f, -0.02611307f, -0.04351959f, 
    -0.05849937f, 0.01717932f, 0.01203781f, -0.01279242f, 0.01872044f, -0.04365368f, -0.05298780f, 0.04638607f, 
    0.01897104f, 0.03654666f, -0.04398493f, -0.05112587f, -0.05929053f, 0.00368190f, -0.04889367f, -0.06421657f, 
    -0.06233615f, -0.02991531f, -0.00275151f, -0.04366083f, 0.03197727f, 0.04066211f, 0.04461309f, -0.02435012f, 
    -0.01561105f, 0.04795240f, 0.02632123f, 0.03496395f, 0.02316674f, -0.02790919f, 0.02998392f, 0.03941636f, 
    -0.01121798f, 0.05032221f, 0.04246893f, 0.02012950f, -0.02729982f, 0.03515626f, 0.04083079f, 0.04512490f, 
    0.02905764f, -0.05355750f, 0.02593092f, -0.01416164f, 0.04261241f, -0.02440961f, -0.02553868f, 0.04552331f, 
    0.03965934f, -0.00536146f, -0.03916694f, 0.03872686f, -0.02837934f, 0.02572903f, -0.03571984f, 0.02206033f, 
    -0.04753566f, -0.00736361f, -0.02635017f, 0.02734234f, -0.04987257f, -0.03939152f, 0.01869678f, -0.06602311f, 
    -0.03959623f, 0.00526693f, -0.03353627f, -0.04914202f, -0.05170546f, 0.04090577f, -0.02908813f, 0.00402641f, 
    -0.02591769f, 0.02834722f, -0.05133743f, 0.00585396f, -0.02183672f, -0.04709814f, 0.00493357f, 0.03179400f, 
    0.06267863f, 0.03302665f, -0.05272801f, 0.04320974f, -0.00807931f, -0.05507113f, -0.00207121f, -0.06931061f, 
    -0.02700389f, 0.01357951f, 0.02584768f, -0.06028435f, -0.04434852f, -0.01302176f, 0.01404398f, -0.04030674f, 
    0.02110074f, 0.00685895f, 0.01113896f, -0.00731070f, -0.05664416f, 0.03633998f, -0.03504155f, -0.01885206f, 
    0.00572779f, -0.03357492f, -0.01692551f, -0.02468259f, 0.01357647f, 0.00443104f, -0.04647278f, 0.01963025f, 
    0.04260079f, 0.05222764f, -0.01673899f, -0.00046734f, 0.02469884f, -0.01871941f, -0.02330792f, -0.04232854f, 
    -0.02732331f, -0.03803164f, 0.01327585f, -0.02465180f, -0.00207714f, 0.02593498f, -0.02427279f, -0.01558898f, 
    -0.06550249f, 0.03676163f, -0.02475154f, 0.04794083f, -0.05361272f, -0.02787337f, -0.05741526f, -0.03750753f, 
    -0.06070820f, 0.00833049f, 0.01180149f, -0.04643261f, 0.02622257f, -0.02641725f, 0.00687877f, -0.02597680f, 
    -0.05448386f, -0.04066784f, 0.03494690f, -0.00136759f, 0.02637964f, -0.00948517f, -0.01785874f, -0.06653713f, 
    0.04363585f, 0.01791153f, 0.00120202f, -0.04366202f, -0.05412712f, -0.04453230f, -0.03623325f, -0.02942267f, 
    0.04151288f, -0.02642829f, -0.01604096f, -0.01276623f, 0.01855894f, 0.04850600f, 0.01511149f, 0.04695216f, 
    -0.05138185f, -0.00282408f, 0.00858294f, -0.01652934f, 0.05046793f, -0.05045546f, 0.03694014f, -0.04933234f, 
    0.02283412f, 0.03316621f, -0.00872767f, 0.04584198f, -0.06254805f, -0.05229153f, 0.03503833f, 0.02596115f, 
    0.03192348f, 0.01503789f, -0.06665509f, -0.02701601f, -0.04134158f, 0.04083748f, 0.00641677f, 0.00336329f, 
    -0.04580782f, -0.05492416f, -0.05431341f, -0.02988133f, -0.04296143f, -0.02807157f, -0.04066003f, -0.00138236f, 
    0.03536644f, -0.00914624f, 0.02414212f, -0.05036020f, 0.01628839f, -0.02466162f, 0.02496091f, -0.05031035f, 
    -0.05220814f, -0.01787459f, 0.02650867f, 0.00087641f, 0.05039512f, 0.04718665f, 0.00621339f, 0.02031898f, 
    -0.06365933f, -0.00771590f, -0.02217532f, -0.04319502f, 0.03946479f, -0.05665017f, -0.03994737f, -0.00838239f, 
    0.00933653f, 0.01282856f, 0.02470418f, 0.02600542f, 0.04281679f, -0.03070911f, -0.02044220f, -0.04543941f, 
    -0.00881254f, 0.01022532f, 0.03970157f, 0.00474852f, 0.03750800f, 0.03829349f, 0.04699782f, -0.01193894f, 
    -0.04226514f, -0.05694238f, 0.01683746f, -0.05981409f, 0.01391342f, -0.03182444f, -0.03465758f, -0.02105527f, 
    -0.03432393f, -0.01768967f, -0.03541125f, -0.01610802f, -0.03610755f, 0.01033201f, 0.01136370f, 0.04442790f, 
    0.00987201f, -0.03444553f, -0.04102202f, -0.06327547f, 0.04553176f, -0.01985215f, 0.01079928f, 0.00898024f, 
    -0.01941738f, -0.01174093f, 0.01436082f, -0.06751259f, -0.00096620f, 0.03298857f, -0.06116655f, 0.00815164f, 
    0.00058789f, 0.00534876f, -0.04255583f, 0.01670995f, -0.03330142f, -0.00215988f, -0.03885298f, 0.00556645f, 
    0.04795289f, -0.05569243f, 0.03903717f, -0.02024639f, -0.06292339f, -0.03759028f, -0.03512729f, -0.03331904f, 
    -0.02572046f, -0.05667062f, -0.01094875f, -0.06022865f, 0.03203938f, 0.03665153f, 0.01504633f, 0.00516532f, 
    0.00261685f, 0.00726305f, 0.00122521f, 0.00405547f, 0.04265464f, -0.02631368f, 0.00857590f, 0.02140651f, 
    -0.02481661f, -0.02864063f, -0.03838012f, -0.02180310f, 0.00621460f, 0.00696013f, 0.04178050f, -0.01072783f, 
    -0.02723817f, -0.01314752f, -0.06149494f, -0.00634189f, -0.06003011f, -0.05520413f, -0.03374042f, 0.03843657f, 
    0.01168231f, -0.02663401f, -0.00735623f, -0.04841202f, -0.03306266f, -0.03931295f, 0.00727744f, -0.00299410f, 
    0.03785937f, -0.04712801f, -0.02671109f, -0.01375865f, -0.00400402f, 0.01549113f, -0.02635306f, 0.03519367f, 
    0.02802503f, 0.03436484f, -0.04941742f, -0.05989168f, 0.04746136f, -0.04209950f, 0.04794455f, -0.06332120f, 
    -0.00287119f, -0.00084913f, -0.06243637f, 0.03082321f, -0.00895758f, 0.00279048f, 0.04767460f, 0.01419427f, 
    0.03621963f, -0.02701101f, -0.02108535f, -0.02676081f, -0.01800028f, 0.00202863f, -0.05491479f, -0.03913566f, 
    0.02681039f, 0.00118457f, 0.01617272f, 0.03212547f, 0.01078435f, 0.05305025f, -0.01691370f, -0.03880915f, 
    0.04319428f, -0.05918455f, -0.04441660f, -0.04105259f, -0.00200714f, 0.02479269f, 0.03644665f, 0.04707510f, 
    -0.06442717f, 0.01189996f, 0.02112908f, -0.00826129f, 0.00904077f, -0.04421638f, 0.00126096f, 0.02531768f, 
    -0.04161946f, 0.03600023f, 0.02138573f, -0.00172854f, -0.05657303f, -0.01458511f, -0.06148920f, 0.00543256f, 
    0.01001129f, 0.00337792f, -0.03462487f, -0.00455692f, 0.00699780f, -0.00172496f, 0.02528762f, -0.01785983f, 
    0.04710605f, -0.00101978f, -0.02706246f, -0.01795132f, -0.01100317f, -0.05322072f, 0.03855392f, 0.01956729f, 
    0.04012555f, -0.04124473f, -0.03117832f, -0.06615002f, -0.00746519f, -0.00050387f, 0.02404056f, 0.03236725f, 
    -0.07485229f, -0.55284148f, 0.05267955f, 0.05313304f, -0.04270649f, -0.00589245f, 0.10945097f, 0.20822665f, 
    0.02701856f, 0.04459600f, 0.30304718f, -0.05740727f, 0.03089999f, -0.07428615f, -0.00168104f, 0.03128230f, 
    -0.03334653f, 0.00523480f, 0.10983757f, -0.12270219f, 0.11487226f, -0.02591646f, -0.08123132f, 0.01138061f, 
    0.07633124f, 0.21273208f, -0.05558695f, 0.21096621f, 0.17062415f, 0.02163445f, -0.06672223f, 0.02707099f, 
    -0.11542489f, 0.01575131f, 0.23426741f, -0.03741670f, -0.09433036f, -0.46825674f, 0.30885491f, 0.07182951f, 
    -0.10010208f, 0.00497387f, 0.17724131f, 0.01191380f, -0.06308750f, 0.15763220f, -0.45098314f, -0.63883215f, 
    0.04694970f, 0.08541688f, 0.08604085f, -0.03622863f, 0.01049264f, 0.00234610f, -0.25666186f, -0.01239822f, 
    0.01839003f, 0.06911307f, -0.02098844f, -0.09474400f, 0.04254694f, 0.04397956f, -0.10467237f, 0.06651042f, 
    0.00958761f, 0.20352669f, -0.00414636f, 0.12940630f, -0.15438026f, 0.14233258f, 0.16877593f, -0.07876282f, 
    -0.32573578f, -0.20339349f, 0.06641910f, -0.11433984f, 0.02847137f, 0.04930989f, 0.13447326f, -0.11076264f, 
    0.00839032f, 0.70589679f, -0.30289611f, 0.22650315f, 0.05208295f, 0.01868482f, 0.18663314f, -0.07836750f, 
    0.12486566f, -0.01344688f, 0.05860094f, 0.08085823f, 0.13272920f, -0.01981653f, -0.04629507f, -0.09690253f, 
    0.04479809f, 0.15700154f, -0.06039571f, 0.00017274f, 0.08254451f, 0.46769944f, 0.02370125f, -0.10429775f, 
    -0.15009883f, 0.04316008f, 0.01969061f, 0.09178488f, -0.02349432f, 0.17676061f, 0.07818327f, -0.15047763f, 
    -0.00270656f, -0.01117810f, 0.02367254f, -0.07407862f, 0.02785589f, 0.12488525f, 0.35999370f, 0.27691704f, 
    0.01459360f, -0.19648348f, 0.15347092f, 0.00511259f, 0.09058879f, 0.17076226f, 0.04349162f, 0.01466905f, 
    -0.12273815f, -0.06535596f, 0.07071951f, 0.03198859f, 0.05910451f, 0.22595407f, -0.11619137f, 0.11004548f, 
    -0.22096965f, -0.33456284f, -0.27573431f, 0.30626535f, -0.00343838f, -0.06424617f, -0.03590370f, -0.03557447f, 
    0.12067952f, 0.04296877f, -0.16602123f, -0.14895424f, 0.13685963f, -0.09813612f, 0.14339618f, 0.06182776f, 
    -0.07790697f, 0.42826855f, -0.15238638f, -0.01304706f, 0.01323529f, 0.11409967f, 0.08966536f, 0.17630039f, 
    -0.02797046f, 0.01698871f, 0.17835626f, 0.03180510f, 0.11450394f, 0.01197840f, -0.17232135f, 0.03039763f, 
    -0.05777953f, -0.20591630f, 0.21522163f, -0.16163540f, -0.05165976f, -0.30313674f, -0.18783867f, 0.08503123f, 
    0.00373112f, 0.14838029f, 0.06071674f, 0.03018654f, -0.18565966f, -0.12098134f, -0.14170878f, 0.07421403f, 
    0.07335915f, 0.12129667f, 0.12617153f, -0.00663333f, 0.14084834f, -0.29341978f, -0.07922787f, -0.14076923f, 
    -0.18309236f, 0.04799238f, -0.18545209f, 0.06559238f, -0.02690265f, -0.00159595f, 0.02375972f, -0.04568090f, 
    0.03430445f, -0.09800798f, 0.00409004f, 0.10326367f, 0.06504720f, 0.05200002f, 0.40081164f, -0.96349108f, 
    -0.31479564f, 0.13215055f, 0.16248147f, -0.25636286f, -0.08716596f, 0.11550856f, -0.17453794f, -0.21566454f, 
    -0.22701132f, -0.15303543f, -0.52687389f, 0.06491178f, 0.12691028f, 0.18353650f, -0.02528726f, 0.04790901f, 
    0.10990497f, 0.43386313f, 0.04303917f, -0.04890822f, -0.02851194f, 0.20455538f, -0.04650526f, -0.04918135f, 
    0.06589703f, 0.02146051f, -0.65588951f, -0.32860050f, -0.03261996f, -0.03426165f, 0.10090883f, 0.10554434f, 
    -0.07564364f, 0.00602908f, 0.32512707f, -0.00863330f, -0.42596149f, -0.48215169f, 0.19983043f, 0.19648609f, 
    0.06416685f, 0.24291146f, 0.08420453f, -0.33446193f, -0.00729242f, -0.48024574f, -0.44317710f, 0.11943477f, 
    0.17620473f, 0.09294944f, 0.02126327f, 0.07910876f, -0.00374176f, 0.21605344f, -0.53800446f, 0.04633010f, 
    -0.21199745f, -0.12810743f, -0.05142947f, 0.20285001f, 0.08635660f, 0.01669773f, -0.04746182f, -0.08777692f, 
    -0.18959108f, -0.02018482f, 0.07519613f, -0.08703674f, 0.15929678f, 0.01740041f, 0.01683126f, 0.51472217f, 
    -0.03304908f, -0.29423213f, 0.09770449f, 0.06431781f, 0.16148289f, 0.08117053f, 0.02908524f, -0.06391541f, 
    0.33551300f, -0.17252609f, 0.18078908f, -0.08531653f, 0.13778399f, -0.03462768f, -0.06639200f, 0.00735173f, 
    -0.01225935f, -0.10885412f, 0.10138807f, 0.16274746f, 0.14404301f, 0.01832697f, -0.08145019f, 0.03178690f, 
    0.09019818f, -0.09986336f, 0.30828008f, -0.07282440f, 0.08657514f, 0.10666419f, -0.06086489f, 0.01295576f, 
    0.04800289f, 0.03591863f, -0.23436320f, -0.90600955f, -0.48201820f, -0.20936392f, -0.10552523f, 0.05781554f, 
    -0.10584365f, 0.01685369f, -0.13277233f, 0.29417965f, 0.36224708f, 0.25465938f, 0.37180978f, 0.02133571f, 
    -0.00172157f, 0.11394479f, 0.02554274f, 0.15181324f, 0.21647993f, 0.05565612f, 0.06780018f, 0.18518467f, 
    0.04144587f, -0.09631004f, -0.16412506f, -0.12088741f, -0.00187454f, -0.41659549f, -0.01209444f, 0.20473880f, 
    0.12147192f, 0.14231588f, 0.01832436f, 0.01339792f, 0.06872709f, 0.18174227f, 0.32250065f, -0.34220299f, 
    -0.07467007f, 0.01215294f, -0.32711619f, -0.03372201f, 0.15109926f, 0.16542484f, -0.03557163f, 0.05506000f, 
    0.26543429f, 0.15148464f, -0.12805733f, 0.14708266f, 0.09565416f, -0.08222362f, -0.03589796f, 0.01304424f, 
    -0.10401434f, 0.25810766f, -0.16897941f, -0.69116241f, 0.16598982f, -0.09647321f, -0.37320635f, 0.16762020f, 
    -0.07818042f, 0.16851948f, -0.52466005f, -0.27147076f, -0.31945640f, -0.18431339f, -0.07556064f, 0.02027052f, 
    -0.05239649f, 0.04652434f, -0.01139130f, -0.03341644f, -0.15874046f, 0.47175187f, 0.19677782f, 0.05767624f, 
    -0.00055194f, 0.09078494f, -0.06353373f, -0.01727036f, -0.32082352f, -0.35555831f, -0.03135946f, -0.02607901f, 
    0.09317795f, 0.10970253f, 0.00956792f, 0.05883983f, -0.22579980f, 0.10603791f, -0.02635246f, 0.11037284f, 
    0.09262531f, 0.05870364f, 0.03021303f, -0.04266728f, 0.14098166f, -0.27052662f, -0.04217125f, 0.07550784f, 
    0.23570168f, 0.02743136f, -0.01998359f, 0.15762080f, -0.13306355f, -0.04843116f, 0.37257671f, -0.41130337f, 
    -0.03503154f, 0.58307415f, 0.20644625f, 0.18780260f, 0.09571968f, 0.11897822f, 0.03680175f, 0.06497084f, 
    -0.25485185f, -0.04599064f, -0.27582279f, 0.13533299f, -0.14689472f, -0.01022755f, -0.05170989f, 0.01975171f, 
    0.05364095f, -0.07688601f, -0.05272571f, -0.08509619f, 0.13370924f, 0.01862884f, 0.03581400f, 0.11532626f, 
    0.17409089f, 0.03536934f, 0.07772432f, -0.06475095f, -0.38501415f, 0.24770196f, 0.22146979f, -0.02948523f, 
    -0.02913110f, -0.06196088f, -0.14277704f, -0.29896265f, -0.32823533f, -0.12686563f, 0.14632638f, 0.08564028f, 
    0.05005173f, -0.13062932f, 0.17134233f, 0.06591000f, 0.26530159f, 0.11791645f, 0.18625264f, 0.14337973f, 
    0.05764703f, 0.10796368f, -0.11243430f, -0.00180673f, -0.00498735f, -0.06104691f, -0.05776911f, -0.21659011f, 
    0.10128160f, 0.00449174f, 0.09241978f, 0.01250023f, -0.01035246f, 0.16997689f, 0.05208658f, 0.01234714f, 
    -0.01539369f, 0.23720503f, 0.24299857f, -0.05015117f, -0.01359083f, -0.33192694f, -0.15311976f, 0.28143317f, 
    0.27172196f, 0.01440473f, 0.20467989f, 0.06447755f, -0.15601406f, -0.31531510f, -0.11552563f, 0.19968379f, 
    0.01216047f, 0.06133910f, 0.28970298f, 0.16612306f, -0.06713519f, 0.04087408f, -0.11378291f, -0.27501395f, 
    -0.18364376f, -0.45664409f, -0.17300005f, -0.22342281f, 0.04302978f, -0.00092367f, -0.08217139f, 0.03219950f, 
    0.05219541f, -0.07832563f, 0.48742220f, 0.25691178f, 0.18891336f, 0.21928138f, 0.14162588f, -0.30161136f, 
    -0.12316498f, 0.02696965f, -0.24477664f, -0.07599470f, 0.42915973f, 0.37537545f, -0.18336324f, 0.26396534f, 
    -0.00499955f, 0.01366809f, 0.03471563f, -0.02246607f, -0.03820530f, 0.16655999f, 0.12676261f, -0.04740505f, 
    -0.09534339f, -0.00234747f, -0.17403115f, -0.01186620f, -0.15114248f, 0.06763726f, 0.13427286f, 0.33085567f, 
    0.11867261f, -0.05599599f, 0.28756875f, 0.04206795f, -0.01897749f, 0.13491544f, -0.09936533f, -0.17567623f, 
    -0.35440913f, 0.00149579f, -0.02923640f, 0.00179960f, -0.16906261f, -0.08937909f, 0.00180409f, -0.14544787f, 
    0.14566849f, 0.13204120f, -0.06727578f, -0.07129873f, 0.04098672f, -0.10854217f, 0.17449173f, 0.00020884f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06013950f, -0.08739147f, 0.02645219f, 0.03842509f, -0.05518509f, 0.18876112f, 0.00316810f, 0.39515436f, 
    0.25477079f, -0.00903443f, 0.08774529f, -0.00845350f, 0.01337844f, 0.04603463f, 0.42047814f, 0.15984833f, 
    0.08521975f, -0.07362498f, -0.01369748f, 0.45870325f, 0.02957824f, 0.04133279f, -0.12769870f, 0.18277185f, 
    0.01315759f, 0.20413387f, 0.02847135f, 0.32980102f, -0.06461609f, 0.02011227f, 0.16934483f, -0.01679840f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19176003f, 0.21407974f, -0.12497350f, -0.12694688f, -0.12778853f, -0.17220649f, 0.13982311f, -0.31350330f, 
    -0.27936995f, -0.02852488f, 0.40760773f, 0.56324100f, -0.09928520f, 0.07793354f, 0.28550562f, -0.41805908f, 
    -0.17479874f, 0.07282572f, 0.14956628f, -0.19738378f, 0.08015668f, 0.02400470f, 0.67684007f, -0.28664377f, 
    0.21963851f, -0.50501859f, -0.03114977f, 0.16101393f, -0.13994396f, -0.12100989f, -0.23792367f, -0.33099261f, 
    -0.51098758f, -0.14804491f, 0.09936024f, -0.08201813f, 0.05963934f, 0.05087920f, -0.04296948f, 0.15526409f, 
    0.30659202f, -0.12855819f, 0.12653720f, 0.73672837f, -0.12433004f, -0.06668632f, 0.65503520f, 0.24352467f, 
    -0.13687946f, -0.52966571f, -0.06499013f, 0.25699583f, -0.16493560f, 0.09433374f, 0.23473327f, -0.21520180f, 
    0.27115718f, -0.01434254f, 0.10243416f, -0.07076658f, -0.16557592f, -0.08777442f, -0.37895992f, 0.39736515f, 
    -0.59430534f, 0.23500925f, 0.03822118f, 0.00663176f, -0.12864755f, 0.27431729f, 0.15866421f, 0.05655275f, 
    0.58911431f, 0.01795965f, -0.24616733f, -0.55652827f, -0.11998050f, 0.16363776f, -0.75051039f, -0.71454132f, 
    -0.10012604f, -0.17072353f, 0.01429045f, -0.25754756f, -0.36663136f, -0.06620714f, -0.15495905f, 0.19065824f, 
    -0.19745056f, 0.35949960f, -0.36079636f, 0.32908636f, 0.09792590f, 0.02290182f, -0.28967863f, -0.18066357f, 
    -0.00881200f, 0.24705036f, 0.13558422f, -0.14000046f, 0.03519771f, -0.10336566f, 0.13842797f, -0.34823751f, 
    -0.65604341f, -0.14310783f, -0.03623166f, -0.55149955f, 0.05007992f, 0.10586657f, 0.10775206f, -0.70548773f, 
    -0.71667081f, 0.11497308f, -0.05680611f, 0.09402373f, 0.76304084f, 0.09921966f, 0.05024538f, 0.37087256f, 
    -0.20211764f, -0.01724159f, -0.51917982f, -0.96571600f, -0.02132706f, 0.12272500f, -0.06206595f, 0.42703581f, 
    -0.05791352f, -0.21306713f, 0.15541267f, -0.18004045f, -0.02746762f, -0.30375993f, -0.17650661f, -0.24215098f, 
    0.29517275f, -0.10414316f, 0.14615245f, 0.26686516f, 0.11074783f, -0.03641245f, -0.04207692f, 0.02226395f, 
    0.07314245f, 0.65139896f, 0.15267889f, 0.02253147f, -0.26358810f, -0.10676852f, -0.31841710f, 0.10748763f, 
    0.26129484f, -0.51638699f, 0.45999706f, -0.06216034f, 0.07918710f, -0.09985086f, -0.06783335f, 0.15199955f, 
    0.27231234f, 0.14059901f, -0.08918472f, 0.03746348f, -0.04153349f, 0.21831727f, 0.03665192f, -0.12094982f, 
    -0.28448179f, 0.08519777f, 0.41738135f, 0.10465848f, 0.16558778f, -0.14486976f, -0.44291353f, 0.22264466f, 
    0.45912638f, -0.24890569f, 0.10359415f, 0.19831564f, -0.35316563f, -0.03381820f, -0.22718737f, -0.09750903f, 
    -0.04112756f, 0.33107480f, -0.57596785f, -0.41984713f, 0.00312630f, -0.01615988f, 0.05765290f, 0.09140135f, 
    -0.13469383f, -0.04789644f, 0.13063522f, 0.14275971f, 0.06253269f, -0.32902062f, 0.09736641f, 0.26280364f, 
    0.10324696f, 0.15798864f, -0.63381582f, -0.81327951f, -0.09595060f, 0.04419196f, -0.25083658f, -0.75382847f, 
    0.02041268f, -0.59159482f, -0.09934603f, -0.02497235f, -0.07446551f, 0.05698887f, -0.16215394f, 0.27988923f, 
    0.14104071f, -0.26862004f, -0.12905614f, 1.01660109f, -0.08312082f, -0.01571638f, 0.20388633f, -0.52321380f, 
    0.37809962f, -0.07533574f, 0.14947319f, 0.04579711f, -0.07313267f, -0.20559257f, -0.13401583f, -0.34964007f, 
    -0.30298015f, 0.06406119f, -0.23744982f, -0.17768274f, 0.12679017f, 0.17591709f, -0.10654459f, 0.35122934f, 
    -0.28591719f, 0.14639097f, 0.10212287f, -0.56209791f, 0.28381476f, 0.08859111f, 0.23190410f, -0.05262587f, 
    0.43821976f, 0.47386491f, -0.06480481f, -0.03821840f, 0.01434689f, 0.08770274f, 0.21195282f, 0.42095920f, 
    0.48388711f, -0.61007881f, 0.08194482f, -0.04185045f, -0.07247259f, -0.02189708f, 0.14467198f, 0.15064630f, 
    -0.18517230f, 0.03302820f, 0.04750247f, -0.53086740f, -0.05553211f, -0.07951988f, 0.68725139f, -0.10931358f, 
    0.45192632f, -0.20154785f, -0.17795886f, -0.11290331f, 0.24082708f, 0.12086564f, 0.35543332f, -0.16096814f, 
    -0.42051256f, 0.16582859f, -0.65125579f, 0.18544260f, 0.01517568f, -0.11447242f, 0.60501754f, 0.27429760f, 
    -0.05756032f, 0.08118479f, 0.03761677f, 0.08915465f, 0.13054527f, -0.28351495f, 0.00786249f, 0.33760417f, 
    -0.20231274f, 0.03647515f, -0.04510780f, 0.13037334f, -0.14399379f, 0.03877019f, 0.02328268f, -0.12871270f, 
    -0.30768144f, -0.49085858f, 0.12666130f, 0.74685627f, 0.83237463f, -0.17825407f, -0.56384224f, 0.31101373f, 
    -0.23156904f, -0.63047212f, 0.43365121f, -0.24171376f, 0.12954500f, 0.13573548f, 0.14986348f, -0.53256822f, 
    0.56391442f, -0.31918395f, -0.09304421f, 0.06998773f, -0.02418428f, 0.37810671f, 0.09614216f, 0.31059206f, 
    0.08700032f, 0.04972244f, 0.02026041f, -0.67925954f, 0.01693000f, -0.07106537f, -0.86548638f, -0.53943473f, 
    0.09278711f, 0.11976761f, -0.01655374f, 0.23674950f, 0.12373532f, -0.17832585f, 0.09461129f, -0.34026778f, 
    -0.13125423f, 0.42755318f, 0.79040545f, -0.75932431f, -0.05847990f, -0.00724065f, -0.23554260f, 0.17367178f, 
    -0.63533401f, -0.06283716f, -0.16437921f, -0.09204334f, 0.08505889f, 0.34416083f, 0.08142504f, 0.12540884f, 
    -0.39164788f, -0.01821586f, -0.01406799f, -0.06974382f, -0.16614819f, -0.08035845f, -0.20754457f, 0.79947746f, 
    0.05189427f, -0.07623098f, 0.04138595f, -0.44366294f, -0.44057623f, 0.16079065f, -0.35830808f, 0.07363921f, 
    -0.31023750f, 0.00256989f, 0.46022099f, 0.04415087f, -0.08723954f, 0.02025864f, 0.61028218f, -0.75941682f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.34851357f, -0.16408588f, 0.50879061f, 0.17018460f, 0.05466659f, 0.00973229f, -0.00049836f, -0.48595479f, 
    0.06562246f, -0.03615978f, 0.10028016f, -0.02705195f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
