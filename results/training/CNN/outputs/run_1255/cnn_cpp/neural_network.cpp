#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.13694039f, -0.21617629f, -0.54758924f, -0.38639495f, -0.37389120f, -0.05672039f, -0.41689578f, -0.34141684f, 
    -0.45529318f, -0.63607782f, 0.21876548f, -0.00981192f, 0.15243603f, 0.18323478f, 0.00182016f, 0.30529043f, 
    -0.06617822f, 0.16727169f, 0.05021242f, 0.05080735f, -0.14964196f, 0.34714037f, 0.20840447f, 0.06008248f, 
    0.51933855f, -0.98971778f, -0.47449711f, -0.43133131f, -0.44538873f, -0.14626613f, 0.85768306f, 0.10851143f, 
    -0.40820667f, -0.18521304f, 0.30681124f, -0.36160570f, -0.32273030f, -0.33197737f, -0.30123278f, -0.31378540f, 
    0.18417510f, -0.17435022f, -0.19050187f, 0.26183420f, -0.21398166f, -0.04381540f, 0.08660833f, -0.02641706f, 
    -0.06559424f, 0.05335905f, -0.20458782f, 0.49757332f, 0.04919643f, 0.15750699f, 0.19375102f, 0.20538437f, 
    -0.45877984f, 0.20036656f, -0.06263906f, -0.16149256f, -0.30975524f, 0.13381504f, -0.14873859f, 0.01730778f, 
    0.02101913f, 0.13536721f, 0.40727848f, 0.19392936f, 0.12021758f, 0.05020096f, -0.20996827f, 0.24353899f, 
    -0.02203437f, -0.24922584f, -0.30862051f, 0.35928571f, 0.05572129f, 0.16704324f, 0.11665910f, 0.14520957f, 
    -0.41493306f, -0.18136074f, 0.55247104f, -0.34011659f, -0.28117198f, -0.19871901f, 0.01844278f, -0.01628068f, 
    0.01948221f, 0.12924543f, 0.03526242f, 0.16228178f, 0.08520787f, -0.15043710f, 0.10683491f, 0.11007080f, 
    -0.20784822f, -0.04634272f, 0.29677004f, -0.03181702f, 0.46909606f, 0.18024738f, 0.35787588f, -0.02999216f, 
    -0.54252148f, -0.36842832f, -0.15350029f, 0.20774662f, 0.45175046f, -0.07364424f, 0.37999487f, -0.18631032f, 
    -0.24219804f, 0.09085551f, -0.21404287f, 0.03810117f, 0.07198302f, -0.11308333f, 0.16573840f, -0.15533525f, 
    0.02102121f, -0.26212859f, -0.13170491f, -0.01839262f, 0.22833145f, 0.25509849f, 0.27760416f, 0.14128539f, 
    -0.76585311f, -1.05297065f, -0.20450665f, -0.13107355f, 0.17818034f, 0.72224486f, -0.10824890f, -0.02417419f, 
    0.14928909f, -0.08739774f, 0.17677924f, -0.17271537f, -0.04650164f, 0.20018148f, 0.09508348f, -0.37339219f, 
    0.17461036f, -0.08500024f, 0.19818439f, -0.12212124f, -0.04069012f, 0.08248420f, 0.17994732f, -0.12515193f, 
    0.10302685f, 0.36606446f, 0.20560688f, 0.27407542f, 0.21106654f, -0.21015573f, -0.03978325f, 0.34182563f, 
    0.26380077f, 0.36033702f, -0.17677559f, -0.43724582f, 0.22406708f, -0.25269729f, 0.13106352f, -0.06419034f, 
    0.02093177f, 0.00861616f, 0.41885057f, 0.04392751f, 0.00738887f, -0.07421415f, -0.33564880f, -0.72995269f, 
    -0.15563433f, -0.41714942f, -0.06403598f, -0.44871828f, 0.18785334f, -0.21090592f, 0.46487457f, 0.25220102f, 
    0.54038161f, 0.19873688f, 0.24870370f, 0.26619422f, 0.25307703f, 0.08646019f, -0.06355966f, -0.26381484f, 
    -0.22266681f, 0.10725672f, 0.08890615f, 0.06016869f, -0.01135079f, 0.15226865f, -0.03201905f, 0.25339553f, 
    0.14215608f, -0.89665437f, 0.11002187f, 0.29334679f, 0.48927328f, -0.39634439f, -0.33491260f, -0.09346481f, 
    -0.18655436f, 0.25804147f, -0.04605116f, -0.06090207f, 0.12264861f, -0.14152125f, 0.39311859f, -0.34135839f, 
    0.02908868f, 0.11397804f, -0.14887521f, -0.16449715f, -0.08043473f, 0.04698868f, 0.07727281f, 0.13213623f, 
    -0.16981155f, 0.36949098f, -0.40968397f, -0.53207958f, -0.51694691f, -0.63799226f, 0.14078647f, 0.31409624f, 
    0.12423575f, -0.06483860f, -0.02108524f, 0.01376010f, 0.30746162f, 0.10693108f, 0.13605154f, -0.32279384f, 
    -0.46419844f, -0.21106891f, -0.13594338f, -0.01631813f, 0.01637011f, -0.14484522f, -0.09126108f, -0.09780462f, 
    -0.35549250f, -0.57174677f, 0.49697143f, 0.43024531f, 0.28752017f, 0.23396626f, 0.03940881f, -0.10769025f, 
    -0.12406768f, 0.48158723f, 0.12623371f, -0.00433924f, -0.15277936f, -0.14393574f, -0.19915597f, 0.07494960f, 
    0.29931659f, 0.19179140f, 0.24570301f, -0.24901110f, -0.08721948f, 0.19195220f, -0.26023632f, 0.08668202f, 
    -0.07582453f, 0.06308478f, 0.00990139f, 0.06250732f, 0.68887055f, -0.17607979f, -0.32719386f, -0.15539633f, 
    -0.38456517f, -0.50545698f, -0.01274558f, 0.28170025f, 0.45704383f, 0.00820539f, -0.18732719f, -0.14995860f, 
    0.11365379f, 0.21142356f, 0.00382040f, 0.41622519f, 0.06388959f, -0.04053453f, -0.32868394f, -0.16819163f, 
    -0.21922654f, -0.52489907f, -0.26254082f, -0.30090037f, 0.00502507f, 0.01917563f, 0.12921126f, 0.29629841f, 
    -0.34440529f, 0.36935136f, 0.53221244f, -0.00642868f, -0.30272621f, 0.19443120f, 0.36434823f, -0.27977341f, 
    -0.18400469f, -0.08881610f, 0.24267197f, -0.00658628f, -0.18324782f, -0.43940458f, 0.34218213f, -0.35030916f, 
    0.35951841f, -0.12394476f, 0.36856705f, 0.37493154f, -0.10145139f, 0.82570696f, 0.36686385f, 0.04219578f, 
    -0.14821175f, -0.02627127f, 0.10175496f, -0.16511936f, -0.10021325f, 0.27327043f, -0.07272986f, -0.06892525f, 
    0.28708634f, -0.24141330f, -0.24755406f, -0.09427553f, -0.05757969f, -0.22179472f, 0.16213188f, -0.19150969f, 
    -0.15176216f, -0.19375521f, 0.13967386f, 0.28807023f, 0.03289682f, -0.22631258f, 0.09638892f, 0.02570506f, 
    0.21910143f, 0.28771874f, 0.41998094f, -0.22687954f, -0.34571746f, -1.01805580f, -0.37312436f, -0.11989337f, 
    -0.04902100f, 0.27780634f, -0.23127086f, 0.25294435f, -0.04563045f, 0.10988390f, 0.04592814f, -0.02535238f, 
    0.17049789f, 0.39259371f, -0.14558527f, -0.34274533f, -0.06706345f, -0.22121701f, -0.06391841f, 0.24839929f, 
    0.01371224f, 0.27746782f, 0.38075453f, 0.13534769f, -0.43186566f, 0.43868110f, -0.24048600f, -0.38463473f, 
    -0.30336207f, 0.18490309f, 0.09926242f, 0.15126708f, -0.34455255f, -0.09345819f, -0.05024530f, -0.09951301f, 
    -0.09238093f, 0.22299194f, 0.01341366f, -0.02826377f, -0.05660546f, 0.23735076f, -0.14830384f, 0.01425498f, 
    -1.22642422f, -0.13731465f, 0.22063778f, -0.72331828f, -0.41408619f, 0.10520056f, 0.66261292f, 0.13312629f, 
    0.51131827f, 0.42517087f, 0.21206449f, -0.09407104f, -0.06704355f, -0.04180368f, 0.09132613f, 0.03951251f, 
    0.01058928f, 0.08578394f, -0.04702925f, 0.03325086f, -0.03599739f, 0.07811066f, 0.06698248f, -0.02861721f, 
    -0.19793917f, -0.09240451f, -0.33097610f, 0.47633335f, -0.22138651f, -0.32380220f, -0.09968297f, -0.10514578f, 
    -0.41383806f, -0.54604405f, -0.66534489f, 0.35651752f, -0.42440173f, -0.42685720f, -0.34141934f, 0.59559077f, 
    0.15938902f, -0.04519201f, -0.45824617f, -0.30909279f, -0.24865821f, -0.27665806f, -0.25036019f, 0.45060965f, 
    -0.10880540f, 0.03880006f, 0.49338874f, 1.19300556f, -0.22548380f, -0.56107920f, -0.03734434f, -0.18275701f, 
    -0.53977269f, -0.17831025f, -0.04893067f, -0.73914641f, 0.03736505f, 0.07541280f, 0.42843094f, 0.38656005f, 
    -0.15907596f, 0.16459008f, 0.10709301f, 0.14946049f, -0.17085537f, -0.27160323f, -0.00592051f, 0.10220725f, 
    -0.06035524f, 0.12470386f, -0.01469541f, 0.06298456f, -0.18735206f, -0.38080245f, -0.25630856f, -0.32677916f, 
    0.45542631f, 0.09690343f, 0.14946461f, 0.24261820f, 0.43828449f, -0.24166831f, 0.50118780f, -0.39661041f, 
    -0.23069985f, 0.07768033f, -0.43387747f, 0.17659371f, -0.00341061f, 0.10058396f, -0.35629937f, 0.05791967f, 
    0.26508492f, 0.17580801f, 0.25273788f, 0.47230592f, -0.57508391f, 0.26780131f, 0.36744186f, 0.11505783f, 
    0.41243455f, -0.36762446f, -0.43825725f, -0.01375484f, 0.58016741f, 0.33444753f, -0.10685953f, -0.11957128f, 
    -0.25889552f, 0.43951097f, 0.08530159f, 0.22298782f, -0.13175993f, -0.07429174f, 0.16953999f, -0.43540299f, 
    -0.21410941f, 0.11654557f, 0.11472165f, -0.01210151f, -0.00905157f, 0.17805171f, -0.26442567f, -0.16572522f, 
    0.12455874f, 0.31145066f, 0.19819860f, -0.22096254f, -0.12518945f, 0.07850805f, -0.06831516f, 0.23679522f, 
    -0.28124011f, 0.16953182f, -0.22412618f, 0.30643535f, 0.18709974f, -0.13024072f, 0.13445276f, -0.09245002f, 
    -0.20756163f, -0.17849176f, 0.07323000f, 0.15866432f, -0.08042555f, 0.48429918f, -0.37019923f, -0.73911202f, 
    -0.39349082f, 0.07783146f, -0.48365632f, -0.38857564f, -0.32394233f, -0.56823373f, -0.26777127f, -0.23510602f, 
    -0.16355234f, 0.02202642f, -0.17662425f, -0.30838186f, -0.36370397f, -0.21455240f, 0.18011528f, 0.02767228f, 
    -0.03038242f, -0.12780547f, -0.45164171f, 0.16984904f, -0.10224336f, -0.29382256f, -0.19056131f, -0.44529662f, 
    -0.23335207f, 0.30488333f, 0.41528425f, 0.43675205f, -0.17655656f, 0.17345381f, -0.24985263f, -0.06089735f, 
    -0.02525286f, -0.14946209f, -0.18780875f, 0.04067160f, 0.31147614f, -0.25974658f, 0.10975085f, -0.11671162f, 
    0.34733450f, -0.28413016f, -0.11805624f, -0.49111173f, 0.14219220f, 0.31190920f, 0.28644690f, 0.35569310f, 
    -0.14752148f, -0.60830289f, -0.82171077f, -0.50597554f, -0.15763001f, 0.37946329f, 0.27205932f, -0.30536902f, 
    -0.51957160f, -0.18183428f, 0.38981450f, -0.01296788f, 0.39411110f, 0.01947898f, 0.37988278f, -0.07970208f, 
    -0.25438088f, 0.00490325f, -0.26462892f, -0.38049477f, -0.10271000f, -0.13942133f, 0.28569409f, -0.09337117f, 
    -0.12077034f, 0.52559602f, 0.28531489f, 0.26206899f, 0.21848777f, 0.29062065f, -0.10376306f, 0.16236462f, 
    0.09111794f, 0.06628900f, 0.06041702f, 0.03338246f, -0.09480932f, -0.19503768f, 0.09166695f, -0.07095054f, 
    0.02696899f, 0.04788996f, -0.07748266f, -0.01855227f, 0.03122878f, -0.30411211f, -0.07947975f, -0.22974290f, 
    -0.32852897f, -0.38695461f, -0.56047446f, 0.17646497f, 0.23428741f, 0.13980769f, 0.49089387f, 0.39135438f, 
    -0.14440934f, -0.19584174f, -0.37625709f, -0.27663830f, 0.28664640f, -0.24805012f, 0.09334129f, -0.27868339f, 
    -0.03614460f, -0.13984908f, -0.28966537f, 0.01086418f, -0.09953222f, -0.33890331f, -0.03522129f, 0.15874507f, 
    -0.12034810f, 0.05967066f, -0.41535085f, -1.02592158f, 0.66333491f, 0.10089508f, -0.59829950f, 0.17022896f, 
    0.04112533f, -0.06095139f, 0.19304562f, -0.04294952f, -0.41291350f, -0.15166032f, 0.19779634f, 0.32027107f, 
    -0.11867952f, 0.08097183f, 0.04495243f, -0.11297085f, -0.13735713f, -0.10174000f, -0.14808650f, 0.04584550f, 
    0.39568543f, 0.25133017f, -0.15450643f, 0.14815427f, 0.34325135f, -0.24391356f, 0.52925885f, -0.04144984f, 
    -0.45966873f, -0.53650844f, -0.21316750f, 0.51652646f, 0.07205796f, -0.04355897f, -0.29023755f, -0.14030944f, 
    0.29835114f, 0.19234186f, -0.17748854f, 0.02416489f, -0.29105851f, 0.22740346f, 0.25708595f, -0.35658360f, 
    -0.17023894f, -0.24714512f, -0.06334168f, -0.20352711f, 0.18753222f, 1.01640558f, -0.43058407f, -0.16962701f, 
    0.14142224f, 0.12618452f, -0.01812805f, 0.33021024f, 0.27565297f, -0.49029103f, -0.28667241f, -0.42251673f, 
    0.03415470f, 0.15322465f, -0.27844360f, -0.00658554f, -0.16817106f, -0.04956423f, 0.19888370f, -0.02416451f, 
    -0.18344495f, -0.04813724f, -0.29068312f, -0.24201463f, -0.15811659f, 0.11137855f, -0.09896787f, 0.82659370f, 
    -0.61888856f, -0.53004521f, 0.21853986f, -0.19953564f, 0.54363722f, 0.39764330f, -0.20728427f, -0.27363500f, 
    -0.32429731f, 0.12827559f, -0.08023547f, -0.06051656f, 0.02899239f, 0.01501193f, -0.37488028f, 0.05616494f, 
    -0.03183541f, 0.33150977f, -0.01296915f, 0.17876616f, -0.10265258f, 0.17070973f, 0.00574418f, 0.35820517f, 
    0.74731892f, 0.18083352f, -0.59578794f, -0.51161969f, -0.47803074f, 0.09068126f, 0.11778939f, 0.00474385f, 
    -0.03775017f, -0.10221808f, -0.30507511f, 0.64550656f, -0.38440585f, -0.05935123f, 0.03459918f, 0.14796013f, 
    0.11114793f, -0.11734404f, -0.01237330f, -0.09198611f, 0.23087180f, -0.10603064f, -0.21390530f, 0.27856779f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14294685f, -0.35252613f, 0.06765673f, 0.17390531f, 0.22887155f, 0.27537626f, -0.08265385f, 0.10790955f, 
    0.28027883f, -0.16030514f, -0.35815915f, 0.24042571f, 0.13223323f, 0.28325117f, 0.12435947f, 0.03691556f, 
    -0.01203908f, 0.11163232f, 0.04026241f, -0.06187484f, 0.25594577f, 0.26036635f, -0.25152263f, 0.22527944f, 
    -0.12673475f, -0.13894890f, 0.11881553f, 0.14045288f, 0.12215336f, -0.02985528f, 0.19091006f, 0.25580737f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08216554f, -0.25854540f, -0.06469129f, 0.12202861f, -0.13407896f, -0.09601777f, -0.09425574f, -0.03749437f, 
    -0.04214867f, -0.03548161f, -0.05016353f, -0.11846769f, 0.10935776f, -0.13835646f, -0.15859017f, 0.34651354f, 
    -0.09310446f, -0.03511532f, -0.04799765f, 0.09249079f, -0.10724621f, -0.05096137f, -0.07577349f, -0.15981728f, 
    0.07092148f, 0.01933501f, 0.12479121f, -0.00781061f, 0.00099596f, 0.11704617f, 0.05006582f, 0.01820739f, 
    -0.04347077f, -0.00230802f, -0.04158049f, 0.00161459f, 0.25956890f, 0.07301125f, 0.15856083f, -0.11792697f, 
    -0.17923172f, 0.10201052f, -0.03900618f, 0.11195182f, 0.04649243f, -0.02276028f, 0.06832509f, -0.02147719f, 
    0.28807160f, 0.19299513f, 0.16261145f, 0.01694787f, 0.08732668f, 0.00976752f, 0.10777347f, -0.07019725f, 
    0.07517320f, 0.05077113f, 0.10347572f, -0.01363344f, 0.14292893f, 0.02968498f, 0.30065262f, -0.10483856f, 
    0.02687699f, -0.01083384f, 0.04039721f, -0.01143082f, 0.00839242f, 0.13670421f, 0.15090270f, -0.14589193f, 
    0.11599959f, 0.28629389f, 0.00887554f, 0.10621829f, 0.00040390f, -0.01237012f, 0.08765033f, 0.00481134f, 
    -0.03787141f, 0.09227943f, -0.07481559f, 0.02949884f, -0.04696876f, 0.14052373f, 0.00080134f, -0.13508321f, 
    -0.07023144f, -0.06486367f, 0.01651514f, -0.03538284f, -0.00827872f, -0.01224458f, 0.05510631f, -0.05009011f, 
    -0.42393240f, 0.28031549f, -0.07668903f, 0.15306066f, -0.06128781f, 0.09786528f, 0.06942731f, 0.35014710f, 
    -0.07291398f, -0.06990759f, 0.12010757f, 0.06425437f, 0.11440305f, 0.07064005f, 0.22487658f, -0.04575011f, 
    -0.13313448f, -0.04181352f, -0.02105634f, 0.06642415f, -0.05143465f, -0.21447018f, -0.27446106f, -0.11570367f, 
    0.41677365f, 0.19586204f, 0.10622560f, -0.06878580f, -0.05687287f, -0.00630641f, -0.02529846f, 0.02697546f, 
    0.05821632f, 0.17661525f, 0.00176957f, -0.08793925f, 0.03667711f, 0.04485171f, -0.10183834f, -0.11179592f, 
    0.00754996f, -0.07538959f, -0.00773800f, -0.02080708f, 0.00808225f, 0.01112213f, -0.15479976f, -0.03713855f, 
    0.30285251f, 0.21756595f, 0.10107294f, 0.14368045f, 0.02190628f, 0.16703314f, 0.08048740f, 0.12702966f, 
    -0.03303087f, 0.03516571f, -0.20955640f, -0.02980913f, 0.52681422f, 0.19446321f, 0.21143374f, 0.20414311f, 
    -0.07191259f, -0.04087862f, 0.05366331f, 0.01182791f, 0.02937363f, 0.12612450f, 0.08141199f, -0.06256725f, 
    -0.03311589f, -0.06958126f, -0.18622543f, 0.16363525f, -0.13493405f, 0.02347023f, 0.03533223f, -0.15794006f, 
    -0.07460815f, 0.05457669f, -0.06950434f, 0.09467823f, 0.42695010f, 0.25057599f, 0.26645717f, 0.07917981f, 
    -0.23523487f, 0.01534472f, -0.11624885f, -0.08431938f, 0.02070000f, 0.05866510f, 0.01094761f, 0.04088232f, 
    0.13021854f, -0.13940069f, -0.00246600f, -0.30590922f, -0.07377029f, -0.16162337f, -0.02858520f, -0.12631446f, 
    -0.13325565f, -0.02311979f, 0.09911480f, -0.04360383f, -0.13009447f, 0.10650785f, 0.14145103f, 0.20663750f, 
    0.01884638f, 0.00799150f, -0.02721787f, -0.06028157f, -0.20557445f, -0.00933550f, -0.03110332f, 0.00930638f, 
    0.29359543f, -0.13613516f, 0.15469286f, -0.02863812f, 0.06119125f, -0.05176726f, 0.01813680f, 0.02173905f, 
    0.01001647f, 0.11365751f, 0.02738792f, 0.07186525f, 0.04907303f, 0.22772387f, -0.04391528f, 0.04567358f, 
    0.16352563f, -0.11931057f, 0.08599272f, 0.09885702f, -0.17968537f, -0.01076678f, -0.03632315f, -0.12340026f, 
    0.28798497f, 0.20195632f, -0.13862084f, -0.14559542f, -0.01012129f, 0.02405668f, 0.04216424f, 0.03003672f, 
    -0.09807584f, 0.12062947f, -0.01641422f, 0.23211643f, 0.09721244f, 0.09629190f, 0.10394159f, 0.06961948f, 
    0.07788131f, 0.01593821f, 0.03941432f, 0.05409892f, -0.02427310f, 0.04354749f, -0.02025678f, -0.09664875f, 
    -0.12804843f, -0.13727939f, -0.16608267f, 0.10887645f, 0.03980832f, -0.00946537f, -0.00880600f, 0.01213392f, 
    -0.05201481f, -0.03475346f, -0.07418523f, 0.04158113f, -0.01501552f, 0.15307097f, -0.04377434f, 0.03252285f, 
    -0.01178571f, 0.10082407f, 0.05893002f, -0.06573234f, -0.10860726f, 0.08694734f, -0.09469046f, -0.07655258f, 
    -0.11171153f, 0.22010739f, 0.08298202f, 0.25318173f, -0.02873822f, -0.22159186f, -0.14215876f, 0.24163915f, 
    0.00104759f, 0.26219842f, 0.05420333f, 0.13544874f, 0.21751806f, 0.08964472f, 0.10993982f, -0.03953858f, 
    -0.03637301f, -0.09645325f, -0.06696080f, -0.04290154f, 0.22413573f, 0.27783015f, 0.14600393f, 0.13778685f, 
    0.04700681f, -0.21263313f, -0.15066093f, 0.13315336f, -0.08276669f, -0.04343746f, -0.02299360f, 0.00132546f, 
    0.06634197f, 0.05121330f, -0.07097125f, -0.03339781f, -0.00581650f, -0.33401802f, 0.11951805f, -0.00056633f, 
    -0.03299370f, -0.02397821f, 0.00310975f, 0.07320915f, 0.00025986f, -0.03458139f, 0.04114292f, 0.04231556f, 
    0.12222502f, 0.15296045f, 0.04485969f, -0.11295833f, -0.02303804f, -0.02375909f, 0.06904196f, -0.13339086f, 
    0.09047378f, -0.08753311f, -0.00632947f, 0.13850176f, 0.19482371f, 0.15576948f, 0.02352636f, -0.07771534f, 
    0.00880341f, -0.10876111f, -0.04656764f, -0.11885312f, 0.16322683f, -0.07858444f, 0.00268065f, 0.18053643f, 
    0.16104858f, -0.19727859f, 0.20102109f, -0.04073245f, 0.04653421f, 0.21128155f, 0.09392265f, 0.10086220f, 
    -0.08285988f, 0.08963938f, -0.02214333f, 0.18686700f, 0.39031002f, -0.26124036f, 0.38765639f, 0.03792031f, 
    -0.04724555f, 0.16852340f, 0.17349839f, -0.25383228f, 0.04315221f, -0.00900208f, 0.06067841f, -0.04185371f, 
    0.04165654f, 0.06782517f, -0.33669010f, -0.31185380f, 0.03198608f, -0.02363872f, 0.23397729f, 0.08186211f, 
    0.00439203f, -0.00812881f, 0.07495974f, 0.02534416f, 0.14035426f, 0.07547911f, 0.11822630f, -0.24571608f, 
    0.06206277f, 0.00916011f, 0.04992659f, 0.08293767f, 0.00713840f, 0.02601923f, -0.02128471f, -0.08479442f, 
    -0.17240582f, -0.11527286f, -0.04722344f, 0.04140298f, 0.08550839f, 0.01904520f, 0.07412435f, 0.00938847f, 
    0.01348583f, 0.04649362f, 0.05826875f, 0.00958025f, -0.26970962f, -0.09493534f, -0.12098312f, 0.18921192f, 
    0.15572190f, -0.06847306f, -0.00069470f, 0.01389641f, 0.09295932f, 0.04409958f, 0.04008467f, 0.05493652f, 
    -0.13582532f, 0.16818395f, -0.25240079f, -0.02962912f, 0.10138801f, 0.02910409f, -0.19953731f, 0.06458795f, 
    0.02754354f, 0.13803044f, -0.03624991f, 0.05801625f, 0.02867290f, 0.44888598f, -0.34609759f, 0.19246972f, 
    -0.03770051f, 0.14428560f, -0.06034983f, 0.02716917f, 0.16351995f, -0.12331045f, -0.00351161f, -0.02041304f, 
    0.02666183f, -0.33112895f, 0.05494452f, -0.11189646f, 0.14871047f, 0.10109983f, -0.04521748f, -0.01199858f, 
    0.03416489f, 0.04145772f, 0.11724478f, 0.06487592f, 0.12622814f, 0.05591956f, 0.10646871f, 0.11628325f, 
    0.01918652f, -0.00848663f, 0.01831558f, 0.12001335f, 0.09962101f, -0.03014880f, 0.08734096f, 0.07085118f, 
    0.16224812f, -0.08046663f, 0.05872428f, -0.05057922f, 0.06443914f, 0.09198757f, 0.04681146f, -0.13260639f, 
    -0.00935356f, -0.02085353f, -0.07665788f, 0.04339606f, 0.18889460f, 0.16966490f, 0.02195728f, 0.03750781f, 
    0.14704874f, 0.13109881f, 0.01136229f, -0.15152742f, 0.07921132f, 0.11184628f, 0.07018606f, 0.10110288f, 
    -0.40815267f, -0.17759234f, -0.10172568f, 0.07126246f, 0.12181035f, 0.01990851f, -0.01288262f, -0.04374930f, 
    -0.04127299f, -0.10509343f, 0.09623341f, 0.09903137f, 0.00299110f, -0.02316419f, 0.07003380f, 0.14770436f, 
    0.02202366f, 0.01844754f, 0.20901932f, -0.03087077f, 0.05717506f, -0.03671178f, 0.16401593f, 0.06592920f, 
    0.10762455f, -0.20022196f, 0.25119948f, -0.08771335f, 0.08969802f, 0.00549283f, -0.12711340f, -0.02481501f, 
    0.09888072f, 0.09443516f, -0.01090135f, 0.05884726f, -0.31088313f, -0.07821550f, -0.18315932f, -0.18676138f, 
    0.05616969f, 0.07489590f, -0.01825342f, 0.02299982f, 0.05334682f, -0.08051062f, 0.01360777f, 0.11584397f, 
    0.06820292f, -0.03799742f, 0.03492583f, -0.14325057f, 0.33342385f, 0.12446530f, 0.07706934f, 0.17873444f, 
    0.18133770f, 0.01902989f, 0.07098582f, -0.06595313f, -0.34400767f, -0.20081469f, -0.14539279f, 0.09938464f, 
    0.09239643f, -0.02264153f, -0.04438053f, 0.10998036f, 0.04409184f, -0.03133133f, -0.06728003f, 0.03126059f, 
    -0.08025647f, 0.18511486f, 0.22871108f, 0.19318277f, 0.06702576f, 0.07487966f, -0.01225320f, 0.17218274f, 
    0.29282489f, -0.01888365f, 0.10411808f, 0.06749767f, 0.27353081f, 0.03304040f, -0.20008343f, -0.27002823f, 
    0.18003741f, 0.07127371f, 0.05503530f, 0.13442449f, -0.02892405f, 0.04416789f, 0.03337637f, -0.04128703f, 
    -0.01547281f, 0.35615382f, -0.51817137f, 0.01299022f, -0.00802796f, 0.10583825f, 0.07497769f, -0.07365769f, 
    0.05522697f, -0.06738373f, -0.05963812f, -0.10073742f, 0.12456561f, -0.14186960f, 0.15653729f, -0.01779091f, 
    0.04124184f, 0.01961876f, -0.06474890f, -0.13529973f, 0.35038978f, -0.02556145f, 0.20544808f, 0.06747761f, 
    -0.27915767f, -0.02224984f, 0.19904919f, 0.08837362f, -0.03388991f, 0.00093414f, -0.01164825f, 0.08952589f, 
    -0.05888686f, -0.04429979f, 0.05578438f, -0.00091021f, -0.01043485f, -0.05274513f, -0.00896281f, -0.00764089f, 
    0.01983508f, -0.10362698f, -0.00033787f, -0.01666686f, -0.00368700f, 0.00796431f, -0.05986167f, 0.17447279f, 
    0.23458484f, 0.12197392f, 0.15807025f, -0.20292342f, 0.09888447f, 0.19106756f, 0.12343723f, -0.04108756f, 
    0.00560527f, -0.05866703f, 0.04404808f, 0.04547035f, 0.09149436f, -0.06182957f, 0.12854584f, 0.02629718f, 
    -0.04658316f, -0.04723367f, -0.02742009f, 0.08146353f, 0.07155824f, -0.07691743f, 0.09972662f, 0.12180482f, 
    0.40144834f, 0.22872929f, -0.01967022f, -0.22666821f, 0.22054236f, 0.25501511f, 0.04176540f, -0.24326809f, 
    0.07593974f, -0.08196782f, -0.07480965f, -0.10912146f, -0.24101368f, -0.15920717f, -0.07928362f, -0.04748621f, 
    -0.00449737f, -0.01183472f, 0.04327030f, -0.01353906f, -0.10389879f, -0.12118883f, -0.09772144f, 0.00467738f, 
    0.22318418f, 0.17387927f, 0.19128108f, 0.05298718f, 0.06741539f, 0.05069321f, 0.08071495f, -0.06997555f, 
    -0.01441437f, 0.05382181f, -0.08319280f, 0.05357897f, 0.09504396f, 0.16887198f, -0.34651333f, 0.00645719f, 
    -0.03555623f, 0.15277240f, 0.04357688f, -0.01926627f, 0.08853807f, 0.07765771f, -0.02746771f, -0.01390531f, 
    -0.27046081f, 0.11645383f, -0.01864675f, 0.19995846f, -0.11968698f, 0.01261948f, -0.06733222f, 0.08374191f, 
    -0.11618375f, 0.20270513f, -0.05382164f, 0.15983130f, -0.33272591f, -0.26491183f, -0.09249883f, 0.09056769f, 
    -0.07219265f, 0.03648146f, -0.00972952f, -0.06662720f, 0.04230706f, 0.08079824f, 0.08759771f, 0.01617782f, 
    -0.22637700f, 0.09854303f, -0.14494960f, 0.07815214f, 0.00820897f, -0.07216836f, 0.07419534f, -0.07299362f, 
    0.23650867f, -0.10206360f, 0.00330616f, 0.00708433f, -0.11501583f, 0.20724554f, -0.52228206f, 0.18720956f, 
    0.08229883f, 0.04092544f, -0.03542281f, 0.08964071f, 0.01370200f, 0.08916190f, -0.03784677f, 0.16919884f, 
    0.07171467f, 0.11024685f, 0.00187702f, -0.05211101f, 0.03132626f, 0.13180895f, 0.13899620f, -0.06331731f, 
    -0.20061179f, -0.05621733f, -0.11159693f, -0.01109021f, 0.29364052f, 0.34973711f, -0.10685843f, -0.14182203f, 
    0.06165655f, 0.13807316f, 0.12464602f, -0.08771310f, -0.05769466f, 0.02183328f, -0.02359383f, 0.01635880f, 
    -0.23864570f, -0.07070989f, 0.02805617f, -0.11717319f, 0.13146515f, 0.11679450f, 0.14353116f, 0.15957643f, 
    0.00159199f, 0.12648328f, -0.07657421f, -0.06021520f, 0.07718772f, -0.11738089f, 0.05745067f, -0.12975459f, 
    0.30827901f, 0.23626909f, -0.00625190f, 0.18330969f, 0.04748529f, 0.07137961f, 0.16711655f, 0.02104643f, 
    0.08288527f, 0.00152062f, 0.03299050f, 0.26125973f, -0.00322808f, -0.12088009f, 0.05613451f, -0.08457543f, 
    0.02109219f, 0.00482202f, 0.01450626f, 0.08902796f, 0.23430121f, -0.05477820f, 0.22166047f, -0.14912619f, 
    0.12327722f, 0.10593189f, 0.10446401f, 0.21632345f, 0.09681081f, -0.04790959f, -0.01395540f, -0.05553949f, 
    -0.01682606f, 0.05137104f, -0.05476693f, 0.21036839f, -0.00717669f, -0.06205258f, -0.10603747f, -0.08139697f, 
    0.02070108f, 0.11466326f, 0.12833291f, 0.00148504f, -0.48189428f, -0.16466011f, 0.03832120f, -0.18789425f, 
    -0.00572006f, -0.02229005f, -0.05739507f, -0.05055939f, 0.01949574f, 0.22209455f, 0.03067752f, -0.07300137f, 
    0.23920614f, 0.25206351f, 0.07928827f, 0.01782764f, 0.11125550f, 0.17604384f, 0.02437494f, 0.29012403f, 
    0.01628792f, 0.09226069f, 0.19737166f, 0.15567082f, 0.34160522f, -0.10408957f, -0.01306708f, -0.14765808f, 
    0.01678843f, 0.09617842f, -0.02794369f, 0.24076936f, -0.10739423f, -0.04283309f, -0.03412865f, -0.23946406f, 
    -0.04701997f, -0.01769842f, 0.00680363f, -0.12713704f, -0.07262985f, -0.10908016f, -0.11974316f, -0.10005902f, 
    0.00395183f, -0.09127001f, -0.06893861f, -0.03052582f, -0.11446715f, 0.15042442f, 0.04363259f, -0.08510423f, 
    0.13909791f, -0.16697066f, 0.08312099f, 0.16693410f, -0.08377727f, -0.00011098f, -0.06548195f, -0.15114319f, 
    -0.20924357f, -0.03476197f, -0.06098150f, 0.14715399f, -0.16561425f, -0.12774220f, -0.12986112f, -0.05625339f, 
    0.21166743f, 0.14626813f, 0.16242437f, 0.10338446f, 0.20394033f, -0.00445018f, -0.23191907f, 0.12028921f, 
    -0.08851337f, -0.03948644f, 0.01367000f, 0.05297686f, 0.02912052f, 0.09644599f, -0.08331500f, -0.01259540f, 
    0.05297059f, 0.08269241f, -0.04683423f, -0.11515772f, 0.06969188f, -0.06320830f, 0.18322264f, -0.05297380f, 
    0.01912427f, -0.20160723f, -0.10001695f, -0.16083901f, 0.25953493f, -0.17411596f, 0.06013317f, 0.01251184f, 
    -0.03051859f, 0.03275871f, -0.05971320f, -0.13388310f, 0.00240746f, -0.02029226f, -0.10229589f, -0.04586298f, 
    -0.63342249f, -0.04468054f, -0.32925680f, -0.25235754f, -0.02179506f, -0.04493020f, -0.17029642f, 0.00389842f, 
    -0.02799071f, 0.00647046f, -0.02311505f, -0.11507916f, 0.18370126f, -0.08194972f, 0.04422598f, -0.18802381f, 
    0.04904324f, -0.06336863f, 0.12978990f, 0.17789482f, 0.09070388f, 0.13853592f, 0.11225349f, 0.10996287f, 
    0.39538807f, 0.14254221f, -0.25535884f, -0.19518238f, 0.15899841f, -0.06728348f, 0.21737832f, 0.17012125f, 
    -0.17212217f, 0.09761316f, -0.06640371f, 0.13937035f, -0.18994151f, -0.09332460f, -0.04969850f, 0.19098093f, 
    -0.08335264f, 0.02315206f, -0.03118319f, -0.09453407f, 0.16317806f, 0.21375051f, 0.12623645f, 0.03725380f, 
    -0.05442860f, 0.08405896f, 0.02847431f, -0.06403913f, 0.11621372f, -0.03825118f, 0.02516343f, 0.03699670f, 
    0.06136559f, 0.28845805f, -0.01419336f, 0.19160590f, -0.11102988f, -0.03396320f, -0.06008235f, 0.15977120f, 
    0.08527373f, 0.20847283f, 0.03870343f, -0.15467206f, 0.21412374f, 0.03722853f, 0.10235359f, 0.16567799f, 
    0.33938557f, 0.18975441f, -0.04013230f, 0.03362123f, 0.08385196f, -0.01530768f, -0.04327346f, -0.04210426f, 
    -0.04758305f, 0.05431681f, 0.09038597f, 0.15968722f, -0.05874273f, -0.08285618f, 0.05520725f, 0.10936122f, 
    -0.05485631f, -0.04154860f, 0.02035534f, -0.16010508f, 0.27166811f, 0.05861489f, 0.04389518f, 0.17877629f, 
    -0.05821726f, 0.23767349f, -0.17386775f, -0.08794113f, 0.05344322f, 0.14275147f, -0.06208516f, 0.03051987f, 
    -0.03014470f, 0.16346245f, 0.03000140f, 0.00886132f, -0.08062306f, 0.00374136f, -0.03000192f, -0.09086665f, 
    0.00388673f, 0.07585613f, -0.10243686f, -0.10843541f, -0.32743225f, -0.08951036f, -0.24832983f, -0.39481771f, 
    -0.09298809f, -0.07745831f, 0.05357961f, 0.05166674f, -0.06223154f, 0.05980889f, -0.04939430f, 0.05478106f, 
    0.02477964f, 0.01416145f, -0.07021063f, 0.17156433f, -0.22237375f, 0.14244063f, 0.22059362f, -0.15199794f, 
    0.05004093f, 0.01677996f, 0.07740519f, 0.16308472f, -0.05652418f, 0.12884338f, 0.10855613f, 0.04160108f, 
    0.20276511f, -0.02992185f, 0.27300873f, 0.09723834f, -0.04311509f, -0.04764120f, -0.01394913f, 0.14308889f, 
    0.17008609f, -0.04233394f, -0.13779101f, 0.03034251f, 0.33033031f, 0.00446466f, 0.02769326f, 0.05305818f, 
    -0.14894652f, 0.08502130f, -0.01972876f, -0.05842076f, -0.05319292f, -0.19668114f, 0.02499119f, -0.04878331f, 
    -0.20739534f, -0.22840755f, 0.04658479f, -0.27216795f, -0.04161729f, 0.26071537f, -0.03396397f, 0.16406304f, 
    0.20442474f, 0.12974706f, 0.09651297f, 0.08501701f, 0.25967932f, -0.12525597f, 0.30692059f, 0.15072367f, 
    0.10461687f, -0.01494851f, 0.27044606f, 0.24952160f, 0.01688568f, 0.04527514f, 0.01182810f, 0.10865706f, 
    -0.23105472f, 0.02261925f, 0.16055129f, 0.17521665f, 0.14553529f, 0.17279641f, 0.05397850f, 0.03408765f, 
    0.01893145f, -0.01858926f, 0.02087329f, 0.14983431f, -0.39349812f, -0.15905501f, 0.18888304f, -0.15671113f, 
    0.18621501f, 0.07247767f, 0.06791222f, 0.09175947f, -0.00512208f, -0.04511515f, -0.01578293f, 0.20642038f, 
    -0.00568210f, 0.07092537f, 0.00427807f, -0.42309368f, -0.13058248f, -0.02161120f, 0.00750096f, 0.04014730f, 
    0.01591621f, -0.03603318f, 0.11801730f, -0.11840132f, -0.05482871f, 0.05603394f, -0.10716632f, 0.03764918f, 
    0.10654562f, -0.06135459f, -0.17389704f, 0.00627471f, 0.01362249f, -0.00822727f, -0.07822455f, 0.12948969f, 
    0.01538504f, 0.09848846f, 0.08339009f, 0.13004220f, -0.00460287f, 0.02672875f, -0.19666474f, -0.08338155f, 
    -0.03839666f, 0.05714507f, -0.05582897f, 0.25058535f, -0.15528220f, 0.05278050f, -0.17169937f, 0.40248638f, 
    0.14774558f, 0.04048531f, 0.06085765f, -0.03656286f, -0.02135087f, 0.04830853f, 0.01942174f, 0.17212895f, 
    -0.20409347f, 0.12384032f, -0.01262384f, -0.38772812f, -0.20847593f, -0.09007829f, -0.13363431f, 0.00830086f, 
    0.07877373f, 0.00935367f, 0.11460971f, 0.01814534f, 0.25656512f, -0.51172870f, -0.30067784f, 0.19470109f, 
    0.14174064f, 0.08128287f, -0.14706382f, 0.07343782f, 0.04266436f, 0.19103506f, 0.00737984f, 0.01033003f, 
    0.43244267f, -0.15315931f, 0.14684258f, 0.20147875f, 0.13190120f, 0.05365275f, 0.02651079f, -0.09601306f, 
    0.20015241f, 0.24106660f, 0.01117509f, 0.18107012f, -0.29800054f, -0.16184823f, -0.08812715f, 0.18355453f, 
    -0.01092697f, 0.05409719f, -0.00386673f, 0.04975484f, -0.13210835f, 0.01016785f, -0.00793194f, -0.26282999f, 
    -0.33500963f, -0.03893988f, 0.09863859f, -0.09599840f, 0.03233162f, -0.04061446f, -0.12565792f, -0.15919223f, 
    -0.03058955f, -0.15686542f, -0.12662664f, 0.08105218f, -0.04974934f, -0.10895722f, 0.06150571f, 0.05747037f, 
    -0.07683642f, -0.00727803f, 0.05594770f, -0.00259334f, -0.10266861f, -0.17309791f, 0.00072298f, -0.17476915f, 
    -0.32422394f, 0.07752721f, -0.12653925f, -0.30346307f, -0.24059106f, -0.02919672f, -0.15483415f, -0.08976416f, 
    0.16500077f, 0.18279780f, 0.13850644f, 0.07809227f, -0.20649685f, 0.22371055f, 0.16400853f, -0.07260823f, 
    0.00052262f, -0.11805125f, -0.15726158f, 0.00335321f, 0.17919669f, -0.07239973f, 0.07254910f, 0.12158644f, 
    -0.07257142f, -0.08241857f, 0.25238460f, 0.07127867f, -0.06902933f, 0.00704199f, 0.04656762f, -0.06684026f, 
    -0.03879643f, -0.06794437f, 0.02772910f, -0.09314521f, -0.07086259f, 0.34782436f, -0.12615021f, 0.19230407f, 
    0.05378890f, -0.12546305f, 0.08853425f, 0.06190236f, 0.03954888f, 0.00814026f, -0.07482365f, -0.03759994f, 
    0.20963632f, -0.41384506f, -0.19998956f, 0.02164921f, 0.14770648f, 0.05506468f, 0.10626663f, 0.11757894f, 
    0.15393031f, 0.07519739f, -0.05640746f, 0.01258100f, -0.02240090f, 0.06778067f, 0.10368552f, 0.30242422f, 
    -0.02216529f, 0.05156995f, 0.08235610f, -0.00858751f, 0.18196225f, -0.01047439f, -0.03176562f, 0.06090095f, 
    -0.49557260f, -0.00666634f, 0.54208332f, 0.10775088f, 0.15785448f, 0.15236594f, 0.08287583f, 0.06565518f, 
    -0.11924916f, -0.17651716f, 0.12786704f, 0.01278611f, -0.40436369f, -0.31862220f, -0.12646025f, 0.02294176f, 
    -0.15748450f, 0.13291043f, -0.02400903f, -0.15467638f, 0.18298036f, 0.02753909f, 0.22414155f, 0.17357531f, 
    0.43594360f, -0.24829483f, 0.16809022f, -0.28138441f, -0.04914040f, 0.02885864f, 0.06727795f, -0.16518377f, 
    0.07013675f, -0.00606884f, 0.23952942f, 0.02346195f, -0.03157843f, -0.17535083f, -0.28781372f, -0.35781014f, 
    -0.03506595f, 0.12928626f, -0.00367947f, -0.03818806f, -0.00369743f, 0.00356862f, 0.09673724f, 0.10892353f, 
    -0.19777098f, 0.02382663f, 0.16125461f, 0.19251540f, -0.02731434f, -0.19333367f, 0.06483233f, 0.06872476f, 
    0.01638179f, -0.09818327f, -0.06106113f, -0.14889608f, 0.28258416f, 0.16779038f, -0.17198128f, -0.05955642f, 
    0.00386431f, -0.02063960f, -0.07414633f, -0.13375324f, 0.13594703f, -0.04653430f, 0.16737506f, 0.24065353f, 
    -0.28253528f, -0.16874567f, 0.05654927f, 0.09488993f, 0.02704329f, 0.06183064f, 0.02457867f, 0.01438542f, 
    0.00165811f, -0.15684211f, -0.12212276f, -0.07932590f, -0.19226964f, -0.02303958f, 0.04254998f, -0.16067983f, 
    -0.05233251f, -0.05988096f, -0.07635657f, -0.03885549f, 0.06633814f, -0.06279428f, -0.07236577f, -0.18237087f, 
    0.07951467f, 0.29862928f, 0.04476122f, -0.28933224f, -0.05001148f, 0.00718351f, 0.03685160f, -0.04879362f, 
    0.07785958f, -0.08204605f, 0.00699439f, 0.04517714f, 0.28990877f, 0.04496979f, 0.10571459f, 0.22643879f, 
    0.10708219f, 0.04725358f, 0.09075963f, 0.03670347f, 0.03272118f, 0.12979884f, 0.01112106f, 0.09144397f, 
    0.27717137f, -0.05802587f, -0.09352448f, 0.32151732f, 0.14088963f, 0.06838745f, -0.10480310f, 0.10285209f, 
    0.11972164f, 0.08574742f, 0.15451872f, -0.18819422f, -0.11948157f, 0.26108861f, -0.10536828f, 0.26586083f, 
    -0.01121881f, -0.01319300f, 0.05311334f, 0.02502967f, -0.01448168f, 0.09223872f, 0.10066114f, -0.12669036f, 
    0.16649087f, 0.35782877f, -0.04213572f, 0.22155923f, -0.06156223f, 0.00461426f, 0.04273201f, 0.00248858f, 
    -0.01556690f, 0.07126575f, 0.06354928f, 0.05458913f, -0.17741990f, 0.33963734f, 0.07593215f, 0.39629567f, 
    0.24453628f, 0.18187054f, 0.06188243f, 0.08539516f, 0.01884333f, -0.02004748f, 0.21039398f, 0.00964177f, 
    -0.11600573f, 0.16584669f, 0.15152411f, -0.28967378f, 0.05955377f, 0.02354739f, -0.01186369f, 0.12231706f, 
    0.09056142f, -0.02139596f, 0.01217393f, -0.06066174f, -0.47935465f, -0.27103129f, 0.22843778f, -0.15118308f, 
    -0.08739662f, -0.10502648f, -0.06822984f, -0.08242424f, 0.03034661f, 0.02136450f, 0.09340388f, 0.09823938f, 
    0.07775187f, -0.05583473f, -0.19659559f, 0.11367257f, 0.14970535f, 0.00676708f, 0.11611909f, -0.00784671f, 
    0.03421186f, -0.02987490f, 0.04219693f, -0.01915861f, -0.00033772f, -0.00018671f, -0.13617565f, -0.00172531f, 
    0.12422370f, 0.01638406f, 0.12937120f, 0.17040834f, -0.09480818f, -0.04667370f, -0.05633652f, 0.01861848f, 
    0.21149819f, -0.03242485f, -0.17524402f, 0.18719792f, 0.06590792f, -0.02388013f, 0.11266576f, 0.05579783f, 
    -0.02803158f, 0.10104805f, -0.06380206f, 0.01673549f, -0.14674340f, 0.27221388f, -0.12411949f, -0.10557248f, 
    -0.00853375f, 0.07759526f, 0.20183907f, 0.11699548f, 0.06461220f, 0.07250760f, 0.09464335f, -0.04195486f, 
    0.15132000f, 0.06359392f, -0.00610427f, 0.07829033f, 0.11730003f, 0.07329580f, 0.05421213f, 0.10313177f, 
    0.02463391f, -0.11049765f, 0.08357667f, -0.06797265f, -0.04943325f, 0.28828838f, 0.16033243f, 0.13765401f, 
    -0.01572525f, -0.09397441f, -0.07889841f, -0.06046881f, 0.02689022f, -0.03631748f, 0.00577112f, 0.20485127f, 
    0.06923094f, -0.24307829f, 0.09903962f, 0.06218704f, 0.05265573f, -0.04583511f, 0.08109307f, -0.03520263f, 
    0.00034575f, -0.01478554f, 0.09284907f, -0.03098318f, -0.13794665f, 0.13976116f, 0.08472727f, -0.31018531f, 
    -0.06189667f, -0.06810546f, 0.11919206f, -0.16077596f, 0.16604224f, 0.11123568f, 0.15381514f, 0.00852053f, 
    0.04783633f, 0.01846722f, -0.12116077f, 0.06865557f, 0.01285056f, -0.02823543f, 0.08375648f, 0.05849208f, 
    0.00017681f, -0.01749937f, -0.15950438f, 0.06558406f, 0.19908798f, 0.11741813f, -0.07566076f, 0.04597661f, 
    -0.09882148f, -0.07192466f, -0.01017292f, -0.09253875f, 0.20473558f, 0.08974962f, 0.19780460f, -0.00842057f, 
    0.17071985f, -0.13130596f, -0.11421842f, -0.06478327f, 0.08938081f, -0.02840464f, 0.04567010f, -0.02304791f, 
    0.04927244f, -0.05165879f, -0.10486387f, -0.14674309f, 0.28719905f, -0.14080620f, -0.12735131f, 0.01052574f, 
    0.01208743f, -0.01003378f, 0.08184214f, -0.04035578f, 0.05662959f, -0.03043135f, 0.04797630f, -0.12237810f, 
    0.01036953f, -0.16268215f, 0.07115021f, 0.01318321f, 0.09539560f, 0.06257903f, 0.03081635f, 0.16414440f, 
    -0.05765088f, 0.01067380f, 0.08103011f, 0.07468008f, 0.18001819f, -0.09484479f, -0.12700374f, 0.00000584f, 
    0.17510013f, 0.12351730f, 0.05969284f, 0.14703789f, 0.03232565f, 0.00264644f, 0.00931641f, -0.03203338f, 
    -0.55337435f, 0.27134904f, 0.01514497f, 0.27730992f, -0.11117088f, -0.13871187f, 0.08367515f, -0.04510119f, 
    0.11938323f, 0.07232326f, 0.06018664f, 0.17858140f, -0.03217999f, 0.22135957f, -0.06700650f, 0.07078417f, 
    -0.00157158f, 0.02786130f, 0.10921676f, -0.09632669f, 0.10554397f, -0.11140455f, -0.04631353f, 0.01078842f, 
    0.08908843f, 0.37441087f, -0.23794436f, -0.14349191f, 0.00748858f, 0.02466848f, -0.10150214f, 0.03866352f, 
    0.08839217f, 0.08163975f, -0.04470259f, -0.02142390f, -0.09400427f, -0.11905979f, -0.01516721f, -0.21937037f, 
    -0.06915481f, -0.10266533f, -0.09841615f, -0.00085852f, 0.00239074f, -0.13053720f, 0.02210196f, 0.04143647f, 
    -0.07831249f, -0.10287368f, 0.01317023f, 0.32645559f, -0.01031926f, 0.05927002f, 0.03946722f, -0.02733686f, 
    -0.04172343f, -0.02465202f, -0.01664622f, -0.00926576f, -0.01842331f, -0.06864116f, 0.14596370f, 0.01155163f, 
    -0.05064410f, 0.04627212f, 0.01292768f, 0.13590918f, 0.05012724f, -0.10749339f, 0.00182336f, -0.05124516f, 
    -0.05728067f, -0.03656629f, 0.31751135f, -0.11449791f, -0.06799011f, 0.06493106f, 0.16425030f, -0.02067937f, 
    0.03480241f, -0.00314855f, 0.16929723f, -0.06384662f, -0.06940509f, -0.26432148f, 0.08247536f, 0.05350380f, 
    0.06003613f, 0.17326488f, -0.01282651f, 0.14459251f, 0.01467556f, -0.09117821f, 0.01525207f, -0.04099766f, 
    0.03307642f, 0.05155745f, 0.17724146f, -0.21319281f, -0.04426039f, -0.21616693f, -0.05274000f, -0.10953747f, 
    -0.17659435f, 0.01314782f, -0.04036289f, -0.03767934f, 0.13186070f, -0.02915576f, 0.01581329f, 0.10384187f, 
    0.05989990f, -0.01990639f, 0.09970309f, 0.05103767f, 0.16480547f, -0.06973239f, -0.00902704f, 0.04024854f, 
    -0.08724020f, -0.00043139f, 0.25189126f, 0.10898568f, 0.03156381f, 0.08195096f, 0.04981680f, -0.00308944f, 
    0.05939949f, -0.13619636f, 0.06150522f, -0.06250367f, -0.24110322f, 0.13423562f, -0.02382386f, -0.02704019f, 
    -0.03207291f, 0.07889795f, 0.04154864f, 0.03816145f, 0.21121043f, -0.07898201f, 0.01537079f, -0.09678769f, 
    -0.01724249f, 0.25811636f, -0.17431325f, 0.09378950f, -0.03783752f, -0.04911245f, 0.00783514f, 0.16221054f, 
    -0.14028627f, 0.02991719f, 0.18092571f, 0.09239741f, -0.13867003f, -0.36929235f, 0.10391774f, -0.16591951f, 
    0.08046474f, -0.02137748f, -0.02932071f, 0.19691117f, 0.00417931f, -0.03372915f, -0.08996946f, -0.18125899f, 
    -0.11185291f, 0.27134809f, -0.03232586f, -0.24217643f, 0.29162785f, -0.15790766f, -0.09272484f, 0.09239249f, 
    0.07916135f, -0.01996028f, -0.05083288f, -0.03406705f, -0.03942879f, 0.22558871f, -0.24143857f, -0.09088965f, 
    0.10676987f, -0.13833311f, 0.12542929f, 0.25718236f, 0.22218759f, 0.03294133f, 0.02519850f, 0.07592735f, 
    0.02898076f, -0.03890442f, -0.03608958f, 0.02978162f, -0.02650866f, 0.04680489f, -0.05131570f, 0.01465998f, 
    -0.01572090f, -0.05255424f, 0.01690905f, 0.05063296f, -0.02477407f, -0.03066376f, -0.02520067f, -0.01704983f, 
    -0.04538764f, -0.02557949f, 0.04408351f, -0.02924983f, 0.03028917f, -0.04398169f, -0.03225529f, 0.04692882f, 
    0.03217630f, 0.01804177f, -0.01032499f, -0.04339194f, -0.03302751f, -0.02347443f, -0.04074670f, -0.03675022f, 
    0.00100806f, -0.03403378f, -0.02344089f, -0.04662111f, 0.01626584f, -0.00782419f, -0.04012556f, -0.05522555f, 
    -0.00234904f, -0.00285959f, 0.02673304f, -0.00954002f, 0.00394922f, -0.04148788f, -0.04537870f, -0.05103739f, 
    0.01457967f, 0.03843259f, 0.03437846f, -0.04420985f, -0.01212946f, 0.01536931f, 0.00471973f, -0.05138821f, 
    -0.03918791f, -0.02676907f, 0.01575692f, 0.03169557f, -0.05250878f, -0.05015382f, 0.03517977f, -0.01759492f, 
    0.00593081f, 0.01968308f, 0.00353943f, -0.02082262f, -0.04260654f, 0.03832679f, 0.01789841f, 0.02997704f, 
    -0.02582924f, -0.02983036f, -0.03374735f, -0.02647554f, 0.04182872f, -0.03036130f, -0.05547590f, -0.00525044f, 
    -0.01789015f, 0.00794353f, -0.01613193f, 0.04134640f, -0.04629162f, 0.04229503f, -0.04198408f, -0.03946321f, 
    -0.02408993f, -0.00702730f, 0.02376023f, 0.03471444f, -0.04289081f, 0.02514048f, -0.00430021f, 0.02303160f, 
    0.00260378f, -0.03574672f, -0.00018238f, -0.01090677f, -0.01145398f, 0.01730486f, -0.03484664f, -0.01791491f, 
    -0.02404208f, -0.01706108f, -0.04193186f, -0.01825625f, -0.03844962f, 0.00377801f, -0.01118870f, -0.03848594f, 
    0.03694351f, 0.04837768f, -0.03137260f, 0.03745517f, 0.02085354f, -0.01540017f, -0.04648492f, -0.01290082f, 
    0.01849533f, -0.03699546f, -0.03746278f, -0.05517982f, -0.05800487f, -0.01605756f, 0.03128049f, -0.05333066f, 
    -0.01635130f, -0.00270371f, 0.04132083f, 0.01828142f, -0.04678877f, -0.02973427f, -0.04180294f, 0.00069396f, 
    0.01072842f, -0.00809721f, -0.03853069f, -0.02676990f, 0.03774590f, -0.05266245f, -0.04225115f, -0.03902918f, 
    -0.01535515f, 0.03569424f, -0.03534631f, -0.03377984f, -0.00003191f, 0.00898097f, 0.00420350f, 0.00438696f, 
    -0.02736890f, 0.04530071f, -0.02229407f, -0.02720567f, -0.04196400f, 0.03695050f, 0.03375589f, -0.04220269f, 
    0.02290851f, -0.05325077f, -0.04916146f, -0.04042230f, -0.01775851f, 0.00801700f, 0.01199149f, -0.00472186f, 
    -0.04826304f, -0.02276078f, -0.00581068f, -0.05371133f, 0.01598860f, -0.05376706f, -0.00149271f, -0.02095275f, 
    0.04218488f, 0.04343289f, 0.02020213f, -0.01740782f, -0.02282017f, -0.01436262f, -0.06406813f, 0.00496408f, 
    0.03189022f, -0.03617506f, 0.03458468f, 0.00945676f, -0.00516036f, -0.00006742f, 0.03516755f, 0.03805176f, 
    -0.05815106f, 0.04333536f, -0.04398647f, 0.04743441f, -0.01119764f, -0.01127931f, -0.02294245f, 0.03812774f, 
    -0.04431624f, 0.04124420f, 0.02913496f, -0.00623681f, -0.03709322f, -0.04136014f, -0.02179885f, 0.01503762f, 
    -0.01604094f, -0.02865164f, 0.01487450f, 0.02171819f, 0.01992749f, -0.02174980f, 0.02442267f, -0.00247085f, 
    0.02343242f, -0.00691171f, 0.04198039f, -0.00505725f, -0.03793862f, -0.02401913f, -0.01890246f, -0.02033196f, 
    -0.04483832f, 0.02108968f, 0.03777991f, 0.04098274f, 0.03041753f, -0.03103415f, 0.03423217f, -0.04211815f, 
    -0.01928927f, 0.03154377f, -0.03333969f, -0.02849123f, -0.03145589f, 0.02308055f, 0.03400619f, 0.02941503f, 
    -0.00919421f, 0.01809710f, -0.03128507f, -0.00704589f, -0.00733060f, 0.04063473f, 0.02501803f, -0.02411124f, 
    0.01793209f, 0.04584765f, -0.03259432f, -0.04730811f, -0.05451874f, -0.03139373f, 0.03159688f, -0.02424841f, 
    0.00717984f, 0.02834811f, -0.02321218f, 0.00507399f, 0.03890580f, -0.02749726f, -0.01258942f, -0.03548993f, 
    0.03542480f, 0.04213569f, -0.02250982f, -0.00456014f, -0.00217506f, -0.03790874f, -0.02058929f, 0.00951241f, 
    -0.01285332f, 0.01453157f, -0.02329581f, 0.03905632f, 0.02734415f, -0.03411516f, 0.03534471f, -0.04554422f, 
    -0.05437651f, -0.02398008f, 0.01439303f, -0.02592566f, -0.03770915f, -0.01806623f, -0.02660558f, 0.04234591f, 
    0.00624963f, 0.04836800f, -0.03446747f, 0.02251354f, 0.02889566f, -0.01137541f, -0.01401538f, 0.03523789f, 
    -0.04757236f, -0.04241056f, -0.04628305f, -0.01863243f, -0.04355422f, 0.03735426f, -0.02933905f, -0.02378064f, 
    0.02970991f, -0.05247369f, -0.02288974f, 0.01998312f, 0.01150519f, 0.03155949f, 0.00209641f, 0.01013444f, 
    -0.04274942f, 0.00886117f, 0.00794456f, -0.02401548f, 0.02919576f, -0.03608404f, -0.01008282f, -0.01242871f, 
    -0.04935747f, -0.05160602f, 0.01313829f, -0.01705671f, 0.03889639f, -0.01627271f, 0.00390546f, 0.04545756f, 
    0.02687301f, 0.01380295f, -0.00735604f, 0.00333636f, -0.02042708f, 0.03425435f, -0.01595384f, 0.01540283f, 
    0.00698248f, -0.02601710f, 0.03068148f, -0.00393809f, 0.02157905f, 0.00450871f, 0.03970040f, 0.03532203f, 
    -0.03116090f, -0.05448657f, 0.00493726f, 0.02568253f, -0.02429068f, 0.00724785f, -0.01228447f, 0.02404560f, 
    0.00925398f, 0.03374692f, 0.03016055f, 0.04065752f, 0.04446753f, -0.00510575f, 0.03176159f, 0.00067251f, 
    -0.03796025f, -0.02760545f, 0.04332851f, 0.01537404f, 0.03835094f, 0.01085670f, 0.01945688f, -0.00880900f, 
    0.04291216f, 0.05080070f, -0.04815622f, 0.03545532f, -0.03854064f, -0.03569602f, 0.00825190f, 0.03110072f, 
    0.00322497f, -0.03856838f, -0.00868867f, 0.03815186f, -0.00245888f, -0.00364561f, -0.01014224f, 0.02145735f, 
    0.31500819f, 0.17339875f, 0.24523371f, 0.39616248f, -0.09793966f, 0.03549489f, 0.04566882f, -0.04165263f, 
    0.04913086f, -0.03435186f, 0.05263907f, -0.04185582f, 0.26677787f, 0.11175253f, -0.00173277f, 0.29322550f, 
    0.09871892f, 0.26679701f, 0.14962259f, 0.06406690f, -0.07744917f, 0.04582093f, 0.09391300f, 0.05190574f, 
    -0.00213201f, -0.05413149f, 0.00001747f, 0.04546561f, 0.02919833f, 0.08425570f, -0.11775641f, -0.01594029f, 
    0.16468760f, 0.19194312f, -0.03448627f, 0.00032954f, -0.12088555f, -0.14508595f, 0.07018814f, -0.00578715f, 
    -0.02690753f, 0.06627441f, -0.04998204f, 0.14226599f, 0.01447762f, 0.07935436f, 0.00858072f, -0.01639832f, 
    -0.35608807f, -0.23268896f, -0.06708041f, -0.39057535f, -0.09297230f, -0.02161772f, -0.04652869f, 0.02963058f, 
    0.02032407f, 0.08089501f, -0.08964971f, -0.04216263f, 0.17641157f, -0.01708291f, 0.27034330f, 0.19211075f, 
    0.17741038f, -0.15766890f, -0.11353104f, -0.03708233f, 0.00890719f, 0.13228889f, -0.04020064f, -0.01462517f, 
    -0.26504272f, -0.32149616f, -0.22046098f, -0.14766130f, 0.04012582f, 0.04651976f, -0.00710525f, -0.01930510f, 
    -0.07101463f, 0.02360092f, 0.01317435f, 0.19274127f, -0.06793238f, 0.22223648f, 0.12377702f, 0.14356329f, 
    0.04413000f, 0.08623537f, 0.13113873f, 0.08925049f, 0.01475125f, 0.02116175f, -0.08233579f, -0.01265223f, 
    -0.08571610f, 0.24835093f, 0.05793850f, 0.05382936f, 0.06781396f, -0.10359393f, 0.02023152f, 0.00669939f, 
    -0.05855504f, -0.06899336f, -0.02070735f, 0.01388494f, -0.03723915f, 0.11948992f, 0.16235411f, 0.25757819f, 
    0.08419468f, -0.06226999f, -0.07184026f, -0.17424601f, 0.02353549f, 0.13017337f, -0.03480199f, 0.22122413f, 
    -0.33495897f, -0.36216685f, -0.20180732f, -0.15558048f, -0.02250338f, -0.02426322f, 0.02011949f, 0.08228498f, 
    0.00889686f, 0.16920276f, 0.13630547f, 0.00744466f, 0.01943198f, 0.04291486f, 0.04019736f, 0.11098587f, 
    -0.00569580f, -0.06142107f, -0.12931465f, -0.01761532f, 0.00231782f, 0.15928906f, 0.03572057f, 0.34805429f, 
    -0.21326120f, -0.19604805f, -0.10142756f, 0.02546790f, 0.04996955f, 0.08684598f, 0.05780748f, 0.04798863f, 
    -0.00839307f, 0.04225294f, 0.26951730f, 0.11480610f, -0.39008299f, -0.18952329f, -0.17406599f, -0.06059273f, 
    -0.05134555f, -0.05385806f, 0.02870269f, -0.00328127f, -0.05957725f, 0.03638972f, 0.06416718f, 0.09779797f, 
    0.12492608f, 0.17708144f, -0.05662515f, 0.05656765f, 0.06474330f, 0.09225789f, 0.08566910f, 0.04941078f, 
    0.01485571f, 0.04997000f, 0.08690128f, 0.02111866f, -0.36835983f, -0.23332183f, 0.13921987f, 0.09735204f, 
    0.02863405f, 0.03768322f, 0.04145628f, 0.08987608f, 0.01297682f, -0.01041015f, 0.05314651f, 0.02449257f, 
    0.39712477f, 0.38371763f, 0.40331793f, 0.21829054f, 0.20685929f, 0.10497402f, 0.12592204f, 0.00838956f, 
    -0.02700780f, 0.07613464f, 0.06724240f, 0.09921972f, 0.12546542f, 0.01783353f, 0.16148140f, 0.05169375f, 
    0.02830827f, 0.06673460f, -0.01011017f, 0.26056474f, -0.07707173f, 0.00379380f, -0.11770261f, -0.00303703f, 
    0.05894085f, -0.05443901f, 0.23058523f, 0.10086910f, -0.17416874f, 0.16380370f, -0.03756179f, -0.06968505f, 
    0.03299101f, 0.09534028f, -0.04339323f, -0.00092626f, 0.38864118f, 0.33354712f, 0.18410552f, 0.06170511f, 
    0.23958810f, 0.01032661f, 0.03394137f, -0.12664096f, -0.13073999f, 0.06270137f, 0.05669056f, 0.02613838f, 
    -0.24619468f, 0.17857692f, -0.26424712f, -0.07460238f, -0.08670017f, 0.01051626f, 0.06112858f, 0.06142515f, 
    0.15335692f, -0.17670967f, -0.07193184f, 0.09378244f, -0.05765409f, -0.02185098f, -0.07464625f, 0.02374089f, 
    0.01214546f, -0.08284719f, 0.06712184f, 0.04616578f, 0.06281646f, 0.14361162f, 0.05180331f, -0.01599915f, 
    -0.16215211f, -0.02086358f, -0.08349197f, 0.14063451f, 0.08479510f, 0.09160055f, 0.09729981f, 0.24161930f, 
    -0.01673383f, 0.00680567f, -0.11773288f, -0.02666009f, 0.01207372f, 0.01239360f, -0.00618678f, 0.07722588f, 
    0.12092131f, 0.10741082f, 0.09963167f, 0.10648941f, -0.00000441f, 0.06169052f, 0.05342580f, -0.04105212f, 
    0.17407301f, 0.11312962f, 0.14521669f, 0.24807483f, 0.18899894f, 0.11360535f, 0.13221870f, 0.08079796f, 
    0.02503400f, -0.06694680f, 0.09405678f, 0.00755039f, -0.37248012f, -0.26259533f, -0.23384997f, -0.14399032f, 
    -0.01558745f, -0.00288617f, 0.01532567f, 0.06201405f, 0.02411163f, 0.15182956f, -0.05334475f, 0.00001813f, 
    -0.07295179f, 0.01459022f, 0.05777769f, 0.13527405f, -0.01466195f, 0.02148925f, -0.04010193f, -0.15209608f, 
    -0.05850675f, -0.03194572f, 0.02091863f, 0.17072827f, 0.48335877f, 0.12027504f, 0.15233770f, 0.20809226f, 
    0.15052789f, -0.02011698f, -0.04099482f, 0.12244608f, 0.05748564f, -0.04693871f, -0.00738455f, -0.02158177f, 
    -0.33656430f, -0.21290289f, 0.08700702f, -0.17975184f, 0.00915726f, 0.02782816f, -0.20028916f, 0.04980160f, 
    0.11264977f, 0.09584995f, 0.17629081f, -0.06129784f, -0.06645057f, 0.21020173f, -0.02705306f, -0.04348854f, 
    0.00340098f, 0.03115397f, -0.13077678f, -0.04745060f, 0.00686490f, 0.09176532f, -0.08778410f, -0.05531123f, 
    0.42564690f, -0.20132849f, 0.25677282f, 0.07973070f, 0.14713448f, -0.04080474f, -0.13828301f, 0.06206929f, 
    -0.00254153f, -0.04307673f, 0.19862634f, -0.12697269f, 0.20129132f, 0.16232017f, 0.09849440f, -0.19459234f, 
    -0.23713735f, -0.01646523f, -0.17968935f, 0.04250850f, -0.01364821f, 0.12094160f, -0.05875655f, 0.02288064f, 
    0.04371356f, -0.00349547f, -0.00381227f, -0.00016922f, 0.01580298f, 0.02926534f, 0.00228372f, -0.04262661f, 
    0.03463755f, 0.02966156f, -0.04962323f, 0.02647361f, 0.04030701f, 0.02663402f, 0.03404997f, 0.03125245f, 
    -0.00283764f, 0.01271788f, 0.03688416f, -0.01225899f, -0.01058117f, -0.02312422f, -0.04938468f, -0.05081175f, 
    -0.00465391f, -0.04443060f, 0.02813249f, -0.05579870f, -0.03511815f, -0.02979404f, 0.02378035f, -0.01171682f, 
    0.00057572f, 0.04443777f, -0.02498356f, 0.02305540f, -0.04249005f, -0.02456208f, -0.04974285f, 0.01462185f, 
    -0.04699652f, -0.00982439f, -0.03741403f, -0.05021726f, 0.04425689f, 0.02215024f, -0.04125172f, -0.00192687f, 
    -0.02470120f, 0.01193110f, -0.02157256f, 0.00334672f, -0.02977129f, -0.00022765f, 0.03640239f, 0.03005404f, 
    -0.02874776f, 0.03067430f, -0.02401285f, -0.05067505f, -0.03960487f, -0.04673732f, 0.00360526f, -0.00222955f, 
    0.01872747f, -0.02363904f, 0.04153673f, 0.03824878f, 0.03059800f, -0.01750348f, -0.05362344f, 0.02397824f, 
    -0.01367439f, 0.02700988f, 0.00237005f, -0.00539029f, -0.02196091f, -0.00376467f, -0.02128530f, -0.02517389f, 
    0.01989004f, -0.02828352f, -0.02517674f, 0.00670096f, 0.04422433f, -0.01420280f, -0.05184482f, -0.03380636f, 
    -0.04135776f, -0.05290309f, -0.05240270f, -0.04727346f, -0.03463968f, 0.00979513f, 0.03301813f, 0.02690578f, 
    0.03598845f, -0.02114619f, -0.03550752f, -0.02826613f, -0.03623254f, 0.04412498f, -0.01546595f, 0.02390914f, 
    0.00931211f, 0.00650639f, -0.04164936f, 0.02039145f, -0.00382520f, -0.05649874f, -0.00258114f, 0.03411023f, 
    -0.00698894f, 0.03695429f, 0.04354117f, 0.01324747f, 0.00809359f, 0.01126011f, -0.00501119f, -0.05339289f, 
    -0.00200279f, -0.00259979f, 0.02956795f, -0.02359628f, 0.01347972f, -0.04554470f, -0.04005573f, -0.01739528f, 
    -0.04812232f, 0.01980769f, 0.04155197f, -0.01008285f, 0.03890755f, 0.03835443f, 0.00995936f, 0.02459832f, 
    -0.02799457f, 0.04274030f, -0.03226895f, -0.04573037f, -0.01775659f, -0.02256971f, -0.01207992f, -0.04729042f, 
    0.03465042f, -0.00535229f, -0.03782811f, 0.02395746f, -0.01850398f, -0.05596948f, -0.03799972f, 0.00287938f, 
    -0.03135877f, 0.02221163f, -0.04974126f, -0.03776543f, -0.01711843f, 0.00376833f, 0.02000193f, 0.01662918f, 
    -0.05167898f, -0.01610794f, 0.02003037f, -0.05657545f, -0.04369443f, 0.00082110f, -0.03323258f, 0.02379471f, 
    -0.01678302f, -0.04075626f, 0.02828996f, -0.04481493f, -0.01743956f, 0.02911724f, 0.02333969f, -0.00680379f, 
    -0.03891538f, -0.01662152f, 0.00868074f, 0.02323591f, 0.00226674f, 0.00472783f, -0.05664440f, -0.02940815f, 
    -0.01987589f, 0.04233378f, -0.04459634f, 0.03373384f, 0.00427646f, -0.01013171f, -0.01788543f, -0.02271024f, 
    0.02620698f, -0.00487669f, -0.01902925f, -0.05137336f, -0.04324207f, -0.00947191f, -0.01102921f, 0.04082648f, 
    0.00031017f, -0.03123514f, -0.00520684f, 0.02734942f, 0.02337411f, -0.03445801f, -0.04984874f, -0.04797576f, 
    -0.01120951f, -0.00992549f, 0.01878501f, -0.05106803f, -0.05229396f, -0.02445962f, 0.00450557f, -0.02389586f, 
    0.01562857f, 0.01284440f, 0.02643983f, -0.01021860f, -0.03354182f, -0.03432663f, 0.00553389f, -0.02614291f, 
    -0.03030733f, 0.03167371f, -0.05635164f, -0.04105599f, -0.03893078f, 0.03260710f, 0.03227539f, -0.03718918f, 
    -0.01246047f, 0.03743933f, 0.02501761f, 0.01419253f, -0.00200551f, -0.01940012f, -0.04604546f, 0.04500832f, 
    -0.01742034f, -0.01978205f, 0.01717187f, 0.02400986f, -0.01489344f, -0.04963586f, -0.00252031f, -0.02170387f, 
    -0.03231516f, -0.04716966f, -0.04955285f, -0.03722190f, -0.00041565f, -0.00981682f, -0.01977048f, 0.02232174f, 
    0.02244065f, -0.01099454f, -0.02898540f, 0.04039654f, -0.01733588f, 0.00713640f, -0.00215518f, -0.02385384f, 
    0.02264205f, -0.00059715f, -0.01413462f, -0.03497608f, -0.01521133f, -0.03031301f, -0.00902727f, 0.01592400f, 
    -0.05445444f, -0.03832525f, -0.03672852f, -0.03603972f, -0.01032115f, 0.01668749f, 0.03396730f, -0.05473594f, 
    0.01729051f, 0.03461001f, -0.00737394f, -0.03997610f, 0.01239361f, 0.02605662f, 0.00066803f, -0.00370687f, 
    0.02638816f, 0.03766225f, 0.01880768f, 0.04455198f, -0.04268486f, 0.01621437f, 0.02771513f, 0.02620243f, 
    -0.02999699f, 0.02763426f, 0.00820803f, -0.00151986f, 0.01218022f, -0.01560540f, 0.03496261f, 0.01309887f, 
    0.04174611f, -0.01090104f, 0.00504019f, 0.01619198f, -0.03109018f, -0.00116991f, 0.02242083f, 0.03787802f, 
    0.02717834f, 0.00249773f, -0.04818188f, 0.00674626f, -0.01115640f, 0.02772012f, -0.04252558f, -0.02106267f, 
    -0.02745174f, 0.03620339f, -0.04466164f, 0.02374195f, -0.04878546f, 0.02184109f, 0.00762516f, -0.05432374f, 
    0.01917639f, 0.02075430f, 0.02958342f, 0.04069137f, 0.00669360f, 0.01652814f, -0.01193265f, -0.04753242f, 
    -0.03030212f, -0.04031143f, -0.01645736f, -0.00246104f, -0.02725064f, -0.02332141f, -0.02678100f, -0.04533340f, 
    -0.03329002f, -0.02518900f, -0.04254079f, 0.03308789f, -0.02909593f, -0.01448636f, -0.02025353f, -0.03888226f, 
    -0.01510640f, -0.05282545f, 0.00813050f, -0.01475857f, -0.01523945f, -0.02655561f, 0.00291699f, -0.01793999f, 
    0.02698810f, 0.03183183f, 0.00649438f, -0.04157646f, 0.03316027f, 0.02250984f, 0.03778922f, -0.05334462f, 
    -0.00106229f, 0.04210331f, -0.05171688f, -0.05677387f, -0.00431849f, -0.00845446f, -0.02443982f, -0.01399036f, 
    -0.02835354f, 0.04000982f, 0.01212148f, -0.02134508f, -0.00329283f, -0.00746702f, 0.03832310f, -0.00283942f, 
    0.16700502f, 0.11327171f, -0.06280864f, 0.12436961f, -0.12575167f, 0.15641476f, -0.05010027f, -0.04239139f, 
    -0.11220086f, 0.06160066f, -0.00067035f, -0.01274413f, 0.58466399f, 0.48924538f, 0.03957488f, 0.14098890f, 
    0.02215086f, 0.11006056f, 0.05388387f, 0.07820303f, 0.02240637f, -0.02786345f, -0.15137632f, -0.05161766f, 
    -0.05436552f, 0.13997555f, 0.12527372f, -0.05561325f, 0.05152036f, -0.10484913f, -0.08119226f, 0.09119031f, 
    -0.06074563f, -0.02628855f, -0.16589795f, 0.04467040f, 0.09354145f, 0.08776449f, 0.05911644f, 0.07538238f, 
    -0.07994390f, -0.13144901f, 0.07703193f, -0.15014462f, 0.06811126f, 0.06292554f, -0.02545895f, 0.06410678f, 
    -0.14915253f, -0.20568642f, 0.36401203f, -0.12915912f, 0.02889262f, 0.12062050f, 0.10607932f, -0.02173932f, 
    0.07193058f, -0.23101622f, 0.03225946f, -0.01876325f, -0.01235434f, -0.39978397f, 0.11463235f, -0.10802257f, 
    0.01721995f, 0.16563189f, -0.15704280f, -0.07726750f, -0.04285075f, 0.01735590f, 0.03066435f, 0.10081580f, 
    0.06299464f, 0.15715416f, 0.03421672f, 0.11199975f, -0.05986228f, -0.09945209f, 0.08002993f, 0.08930752f, 
    0.04128829f, 0.02080696f, -0.06978930f, 0.05819163f, -0.02376060f, -0.20947137f, -0.15324090f, -0.10219429f, 
    0.09096816f, 0.07029541f, 0.07944968f, -0.03456203f, -0.01741929f, -0.02916354f, -0.01258116f, -0.03067318f, 
    -0.07979036f, 0.11832266f, 0.03724132f, -0.06789856f, -0.06167449f, -0.02212843f, 0.04040058f, -0.06047198f, 
    0.07443058f, 0.06146520f, -0.00800466f, -0.08159095f, 0.23211372f, -0.19129243f, -0.22016674f, 0.07737821f, 
    0.00998834f, 0.00216508f, -0.08984201f, 0.07334501f, -0.05185033f, -0.03432617f, -0.00189364f, 0.04728201f, 
    0.07434470f, 0.11014333f, 0.12266751f, 0.06544142f, -0.04569650f, 0.01212915f, -0.05465040f, -0.00323015f, 
    0.03034659f, 0.08461644f, -0.06258680f, 0.00749617f, -0.23942213f, -0.05624373f, 0.28247124f, -0.11430867f, 
    0.21397284f, 0.18428154f, -0.25820646f, 0.01216953f, -0.12779462f, 0.07557505f, -0.13077165f, 0.07613751f, 
    -0.04158227f, 0.06213394f, 0.06615024f, 0.08443417f, -0.05011802f, 0.03364017f, 0.15272593f, 0.11390992f, 
    -0.04986361f, -0.06555962f, 0.17255081f, 0.05150294f, 0.19508636f, 0.21795107f, 0.25031731f, 0.12517224f, 
    0.04598078f, -0.09362172f, -0.00134055f, 0.07166133f, -0.02535114f, 0.12753464f, -0.04176739f, 0.11862081f, 
    0.04824294f, 0.24780023f, -0.07452337f, -0.30453581f, -0.03213876f, -0.23619187f, -0.04489671f, -0.12397689f, 
    0.01408363f, 0.08826894f, -0.03372377f, 0.02719834f, 0.24464245f, 0.15203975f, -0.02962666f, -0.12701140f, 
    -0.14045654f, -0.04592514f, -0.01231126f, -0.08458628f, -0.10110987f, 0.07531939f, 0.16479395f, 0.02191926f, 
    0.43721154f, -0.04135862f, -0.18182848f, -0.14787643f, 0.06463752f, 0.12883715f, -0.07801641f, 0.06553122f, 
    -0.15892477f, -0.05080713f, -0.08749469f, -0.10547905f, 0.08230381f, -0.15437894f, 0.24119431f, -0.32089832f, 
    -0.01559570f, 0.05380143f, -0.22497903f, 0.06456896f, -0.04410886f, 0.17079829f, -0.00210953f, 0.01779730f, 
    -0.11437511f, -0.36932167f, 0.06950288f, -0.10817555f, -0.00696098f, -0.07411763f, -0.07215495f, -0.08681028f, 
    -0.02389909f, 0.03239990f, 0.11636850f, 0.14713146f, 0.07408781f, 0.12853581f, -0.04006111f, 0.05640601f, 
    0.08815850f, 0.21540193f, 0.06719580f, 0.01970366f, -0.08476285f, 0.16495849f, -0.26352477f, -0.12774786f, 
    -0.01420807f, 0.04115951f, 0.14155462f, 0.06352379f, 0.07312604f, 0.01394644f, 0.07858445f, 0.02121775f, 
    0.11280148f, -0.06622783f, 0.02662095f, 0.04657054f, 0.08021791f, 0.09843397f, -0.00627759f, 0.00658752f, 
    0.06216738f, 0.11754344f, 0.09203660f, -0.13324703f, -0.03949828f, 0.07101084f, 0.10072512f, -0.01601266f, 
    0.21393120f, 0.17484792f, -0.17182109f, -0.11331294f, 0.11696208f, -0.04160495f, -0.12812394f, 0.12654312f, 
    -0.00935045f, 0.04046247f, -0.09637642f, 0.03676947f, 0.02084487f, 0.15392838f, 0.06306724f, 0.00305239f, 
    -0.01268704f, -0.15783860f, 0.14982624f, -0.03304658f, -0.02304538f, 0.08184214f, 0.03597888f, 0.01017680f, 
    -0.02398599f, -0.19019359f, -0.00399152f, 0.00543622f, -0.04624826f, 0.23948272f, 0.18627658f, 0.06875360f, 
    0.06461605f, -0.00577450f, 0.00455412f, -0.03551442f, 0.08133452f, 0.11608776f, 0.08609248f, 0.07690652f, 
    -0.01031843f, -0.00694575f, -0.07206588f, 0.07387612f, -0.08258153f, 0.10692526f, 0.03293173f, -0.00853665f, 
    0.02028537f, -0.02647424f, -0.29137298f, -0.06952504f, -0.02543629f, -0.10619442f, -0.08316905f, 0.16416363f, 
    -0.04483298f, 0.13517030f, 0.06087944f, -0.01943255f, -0.01205751f, -0.01884461f, 0.00294084f, 0.13408403f, 
    0.08723608f, 0.10463921f, -0.03377408f, -0.05914815f, -0.16407987f, 0.00931271f, 0.09140820f, 0.08779169f, 
    -0.02274524f, -0.10939712f, 0.25326526f, -0.13540317f, 0.08159655f, 0.11898485f, 0.01455200f, -0.27344531f, 
    0.09922967f, -0.20369205f, 0.00256148f, -0.12596133f, 0.57637852f, 0.13285369f, 0.02294780f, 0.11153243f, 
    0.01397060f, 0.05671263f, -0.04348040f, -0.13344236f, 0.03056153f, -0.05710789f, -0.00768035f, 0.06131415f, 
    0.03377040f, -0.17202862f, 0.07094109f, 0.17749707f, -0.16276883f, 0.02705158f, 0.07291989f, -0.12406126f, 
    -0.12379351f, 0.12600859f, -0.01129347f, -0.01015166f, 0.02615564f, -0.05714300f, 0.28154573f, -0.17063490f, 
    0.04699942f, 0.03740014f, -0.25411651f, -0.23243409f, -0.14508925f, 0.07790468f, 0.05834223f, 0.02442424f, 
    -0.01256742f, -0.03813935f, -0.01412581f, -0.00720826f, 0.03502733f, 0.01362838f, -0.00285202f, 0.04238739f, 
    -0.04952138f, -0.04864390f, 0.04147615f, -0.04390437f, 0.04117022f, 0.03009379f, -0.05627117f, -0.05439443f, 
    0.00529802f, 0.04038592f, -0.05288969f, 0.01495729f, 0.02718119f, 0.04254558f, -0.02275836f, -0.04287650f, 
    -0.02245738f, -0.00811220f, -0.02416404f, -0.03130308f, -0.03422393f, 0.01015668f, 0.03410885f, 0.03501696f, 
    -0.00872297f, -0.02424793f, 0.00476333f, 0.03658208f, -0.00220700f, -0.02485176f, 0.03986952f, -0.04557134f, 
    -0.02211365f, -0.03638579f, -0.03714010f, 0.02779167f, -0.00923487f, -0.04607951f, 0.04075985f, -0.05748856f, 
    0.02992914f, -0.00803803f, -0.03367153f, -0.05097740f, 0.03439971f, 0.00828109f, -0.04535411f, -0.00682633f, 
    0.02855352f, -0.01189354f, 0.00882618f, -0.00216229f, -0.01881744f, -0.00350308f, 0.04178159f, 0.00691695f, 
    0.03515969f, 0.01356968f, 0.00026803f, 0.04139304f, 0.01678471f, -0.03188894f, -0.02799051f, 0.02222412f, 
    -0.00683280f, 0.02070452f, 0.03299440f, -0.05078744f, 0.02415288f, 0.02646748f, -0.04636133f, -0.05107873f, 
    0.02314318f, 0.02515211f, -0.00859965f, -0.01470585f, 0.00315090f, -0.04145267f, -0.02202442f, -0.01547263f, 
    -0.00927771f, -0.03567936f, -0.01520735f, -0.01470526f, -0.00762798f, -0.05250502f, -0.05219673f, 0.03602527f, 
    -0.04239450f, -0.05740451f, -0.03222624f, -0.03561248f, 0.01660046f, 0.02086223f, -0.00349734f, -0.04711829f, 
    -0.03361132f, -0.05398446f, -0.00662915f, -0.04068456f, 0.00742776f, -0.04706463f, -0.02936354f, 0.03882625f, 
    0.02844119f, 0.02623498f, 0.01952388f, -0.05228849f, -0.03744679f, -0.03883661f, -0.03312754f, 0.02217587f, 
    -0.04845248f, -0.02907495f, 0.03973478f, -0.02179463f, -0.01827783f, -0.00716141f, -0.04089176f, -0.02549067f, 
    -0.05504592f, 0.00705884f, -0.00052468f, -0.04366865f, 0.02523147f, 0.04170663f, 0.00624856f, -0.02578064f, 
    0.01661909f, -0.04195449f, -0.05620724f, 0.04105789f, -0.05702550f, -0.02479293f, -0.05869957f, -0.00664473f, 
    -0.00837665f, 0.04241942f, -0.03594021f, -0.00716936f, 0.00057633f, 0.01630950f, 0.00015195f, -0.01056696f, 
    -0.05847102f, -0.00346883f, -0.05430175f, -0.00567236f, -0.05662654f, 0.04152992f, -0.03960203f, -0.01862292f, 
    0.00263161f, 0.03576171f, -0.03946697f, -0.03937924f, 0.02264317f, -0.02335899f, 0.00392667f, -0.05006832f, 
    -0.04714921f, -0.01997892f, 0.03406560f, -0.03631974f, -0.00295985f, 0.03510033f, 0.02966942f, -0.00812979f, 
    -0.03649757f, 0.00637252f, -0.04369781f, -0.00795556f, -0.00664670f, -0.02723926f, 0.02048909f, 0.02285829f, 
    0.03393933f, 0.02423305f, 0.00932193f, -0.04116955f, -0.05800105f, -0.02204705f, -0.03956310f, -0.01204831f, 
    0.02738499f, 0.03677589f, -0.04139096f, -0.00530825f, -0.04691113f, -0.00594727f, 0.02513741f, -0.01820180f, 
    -0.05467295f, 0.00877068f, 0.01479742f, -0.05038232f, -0.03416084f, 0.01895258f, 0.02608635f, -0.04801331f, 
    -0.01254824f, -0.00345560f, -0.01473801f, 0.02606565f, 0.01494104f, -0.02547793f, -0.01316550f, -0.01162772f, 
    0.02282315f, 0.04202846f, -0.00210125f, -0.04514853f, -0.03652318f, -0.01682256f, 0.01647373f, -0.02448468f, 
    -0.04995989f, -0.05163673f, -0.00600521f, -0.04598399f, -0.04379814f, -0.02420798f, -0.05154515f, 0.00948387f, 
    0.03236329f, 0.00894438f, -0.00124656f, 0.00178926f, -0.05659353f, 0.03690337f, -0.03532290f, -0.00645095f, 
    -0.03731162f, 0.01498061f, -0.03768664f, -0.05485533f, 0.02648567f, 0.02365210f, 0.04131082f, 0.00557133f, 
    -0.04445224f, 0.02128704f, 0.00516889f, 0.02140322f, -0.01903798f, 0.02010417f, 0.00962469f, -0.02177937f, 
    -0.04193361f, 0.00640964f, -0.05607365f, -0.02860301f, -0.03871676f, 0.02407594f, 0.01506004f, 0.03135230f, 
    0.03937392f, -0.01122774f, 0.02875535f, 0.04367372f, -0.03277702f, 0.03648531f, 0.00280092f, -0.03659209f, 
    0.00198766f, -0.00215773f, -0.01382514f, 0.03919237f, 0.02351159f, 0.03333671f, -0.05275865f, -0.03305895f, 
    -0.04305742f, -0.05234087f, 0.03308903f, -0.02757253f, -0.05673715f, 0.04011645f, 0.02430765f, 0.03645046f, 
    0.02129863f, 0.04053045f, -0.01966284f, -0.01094589f, 0.00858809f, -0.05354814f, -0.04584656f, -0.00158072f, 
    -0.02956177f, 0.00058668f, -0.04607486f, -0.02279383f, -0.04699274f, -0.05683068f, -0.03486665f, -0.03002355f, 
    -0.05300979f, -0.04576182f, -0.00146031f, -0.00528384f, 0.01602606f, 0.03268658f, -0.00384700f, -0.03595579f, 
    0.03874848f, 0.00134642f, 0.00187999f, -0.05169625f, -0.03374495f, -0.02490387f, 0.03557327f, 0.03492392f, 
    -0.03352937f, -0.05591835f, 0.00979482f, 0.01049918f, -0.00278945f, -0.00290740f, -0.00476029f, 0.02792745f, 
    0.03745323f, 0.04043616f, -0.00899618f, -0.02748204f, 0.01116877f, -0.00888038f, -0.04587222f, -0.03305693f, 
    -0.02089666f, -0.04282754f, -0.05507049f, -0.03490808f, -0.00671307f, 0.01078308f, 0.02244271f, 0.03602734f, 
    0.01888321f, 0.02828526f, -0.05743390f, 0.03659733f, -0.03820071f, 0.00808510f, 0.03821719f, -0.04045981f, 
    0.01667889f, 0.02778715f, 0.02560828f, -0.05531003f, 0.01232156f, -0.04399428f, -0.05037519f, -0.05425759f, 
    0.03650922f, 0.01020032f, 0.01945869f, 0.04166007f, 0.02585676f, -0.03577133f, -0.03234700f, 0.01232977f, 
    -0.05192371f, -0.01577396f, 0.03115556f, 0.01017980f, 0.04103436f, -0.04557469f, -0.03995065f, -0.05430612f, 
    0.01640035f, -0.02904660f, 0.01284534f, -0.03013528f, 0.02427683f, -0.02132829f, -0.03845059f, -0.05584609f, 
    -0.25139394f, -0.02044054f, -0.00226108f, -0.34720010f, 0.23129730f, 0.03691554f, 0.03404877f, -0.06771377f, 
    0.02135627f, -0.01905745f, -0.00250890f, 0.00353924f, -0.38705030f, -0.25796190f, 0.05774640f, -0.27368972f, 
    -0.01579188f, -0.04643851f, 0.01683543f, -0.11698412f, -0.04165145f, 0.00126220f, 0.01846516f, 0.16206399f, 
    0.01071931f, 0.02403375f, -0.06795649f, 0.05619478f, -0.08534633f, -0.01511045f, 0.06002466f, -0.00223020f, 
    -0.04442152f, -0.06009171f, 0.01758961f, -0.10124727f, -0.00051259f, -0.01506456f, -0.14947896f, 0.03010146f, 
    0.21735846f, -0.11626551f, -0.06422220f, 0.01227094f, -0.04600797f, -0.05434631f, -0.05074884f, -0.01282320f, 
    0.39066932f, 0.15469563f, -0.22993626f, 0.32721633f, 0.09783463f, -0.02346333f, -0.05907731f, -0.03348956f, 
    -0.03134191f, 0.27378631f, 0.07358826f, 0.10937941f, -0.01495270f, 0.18316342f, -0.22423346f, -0.01715888f, 
    0.03119138f, 0.10818638f, 0.13833745f, 0.08432898f, 0.14961599f, -0.09225666f, 0.03214404f, -0.04410014f, 
    0.20707648f, -0.02691545f, 0.10415433f, 0.01572912f, 0.02748349f, 0.13125566f, -0.09615742f, -0.00938825f, 
    0.08007773f, -0.03928515f, 0.13348170f, -0.10684536f, -0.08109216f, 0.00380011f, -0.04901082f, 0.00793269f, 
    -0.03081745f, -0.06609612f, -0.08380011f, 0.07356881f, 0.07652202f, -0.05077842f, -0.05736699f, -0.00218502f, 
    0.23883875f, -0.30398312f, 0.05218124f, 0.06882016f, 0.18063100f, 0.06205254f, 0.12443075f, 0.10210372f, 
    0.01699813f, -0.10247440f, 0.12950850f, 0.19628687f, -0.01599100f, 0.06059471f, 0.06488442f, -0.27884099f, 
    -0.07761457f, 0.08396360f, 0.12594117f, 0.03580164f, 0.00035108f, 0.08002111f, 0.14922889f, -0.03415883f, 
    -0.00617046f, 0.12122662f, 0.03828475f, 0.08987647f, 0.02610450f, 0.01766073f, 0.06538547f, -0.01004622f, 
    -0.06106807f, -0.07806803f, 0.09093294f, 0.03882672f, 0.00147693f, 0.02702553f, -0.06658288f, 0.02112013f, 
    -0.08813061f, -0.11979581f, 0.27765316f, 0.12049030f, 0.14504707f, 0.05238519f, 0.01087726f, -0.21821752f, 
    0.13487725f, -0.03370989f, 0.14519392f, -0.08993562f, -0.00361310f, -0.02138951f, -0.09563161f, -0.12414089f, 
    -0.00136950f, 0.02606820f, 0.08674223f, -0.07924723f, 0.26353824f, 0.16221645f, -0.25798953f, -0.12404217f, 
    0.03289356f, 0.10767253f, -0.00827238f, -0.06483344f, 0.10308357f, -0.03365465f, 0.06056587f, 0.09502393f, 
    -0.05068391f, -0.23086604f, 0.11753274f, 0.17187199f, 0.14889731f, 0.09045494f, 0.14094631f, 0.14583205f, 
    0.12107462f, -0.01574655f, -0.00118312f, 0.00427937f, 0.24459653f, -0.12202528f, -0.18058431f, 0.00491528f, 
    0.11962979f, 0.00082245f, -0.04722403f, -0.02258715f, 0.06086455f, 0.07093279f, 0.00663884f, 0.01984383f, 
    -0.70899075f, -0.18932620f, -0.28460380f, 0.02318332f, -0.10542613f, -0.06401927f, -0.01766231f, 0.11993463f, 
    0.10285323f, 0.04547082f, -0.11041996f, -0.05249026f, 0.03434193f, 0.01160606f, -0.07616406f, -0.01378738f, 
    0.22484596f, 0.03932419f, 0.13232581f, 0.03918103f, 0.05596510f, -0.04750939f, 0.11824182f, 0.01519686f, 
    0.06887665f, 0.44190547f, -0.49687108f, -0.14454049f, 0.17886460f, 0.05178327f, 0.01616593f, -0.11991671f, 
    -0.03105538f, -0.00768271f, -0.07700184f, -0.00554242f, -0.10000661f, -0.24545264f, 0.04077948f, -0.06961539f, 
    -0.13893390f, -0.12054582f, -0.07158723f, -0.01772188f, 0.21672736f, -0.00740298f, 0.14971441f, 0.08248701f, 
    -0.01098891f, -0.11962906f, 0.12026496f, 0.09247286f, 0.05846335f, 0.03239764f, -0.02169178f, 0.06277383f, 
    0.05450862f, 0.22567651f, 0.05488521f, 0.04438711f, 0.08277889f, -0.02086398f, 0.09668845f, 0.05845704f, 
    0.07795263f, 0.04125645f, -0.07720423f, -0.02127933f, 0.04571284f, -0.14368393f, 0.01691167f, 0.13892902f, 
    -0.01812090f, 0.04996099f, 0.24215697f, 0.01423828f, 0.06284257f, 0.05444772f, 0.17999999f, -0.10659081f, 
    -0.02823048f, 0.03070661f, 0.15833855f, -0.00150342f, 0.05339620f, -0.15486594f, 0.12304921f, 0.11180381f, 
    -0.02248288f, 0.02151993f, -0.16204268f, 0.01282683f, 0.11125807f, -0.06048933f, 0.00558308f, 0.09054601f, 
    -0.06600474f, 0.07651783f, 0.02048793f, -0.22910775f, 0.10691603f, 0.06421410f, -0.03381794f, -0.13728893f, 
    0.03964319f, 0.19797921f, -0.04609306f, -0.12262992f, 0.11856772f, 0.12337373f, -0.03785552f, 0.03881069f, 
    -0.05440437f, 0.03967251f, 0.03874056f, -0.03285963f, 0.20100649f, 0.05738037f, 0.08131194f, -0.08728473f, 
    -0.15224051f, -0.07457928f, 0.30330998f, 0.03871099f, 0.02199557f, 0.14283514f, -0.02715039f, -0.02809713f, 
    0.05603532f, -0.00216424f, 0.02073935f, 0.03642684f, -0.36249799f, 0.12040279f, -0.04483884f, -0.11347307f, 
    -0.02035974f, 0.06975430f, 0.11710294f, -0.00006391f, 0.13451147f, 0.13503104f, -0.04837607f, -0.01775742f, 
    0.26455736f, 0.19115309f, -0.26617450f, 0.10700618f, 0.01396023f, -0.02786956f, -0.05036807f, 0.10078537f, 
    0.00869541f, 0.24314612f, -0.10420456f, 0.14018202f, 0.05393540f, -0.18734334f, 0.04529855f, -0.07126381f, 
    0.00982437f, 0.01525804f, 0.08622812f, 0.07066762f, 0.06725864f, 0.08073272f, 0.07068679f, -0.01056250f, 
    -0.26873729f, 0.23831688f, -0.15184847f, -0.11555945f, 0.14992100f, 0.00876866f, -0.16823116f, -0.00221538f, 
    0.20743291f, 0.05799963f, -0.06907097f, 0.13979173f, 0.03429215f, 0.21616577f, -0.56746304f, 0.24266630f, 
    0.20346677f, -0.01053248f, 0.11740221f, 0.21246549f, 0.13117024f, 0.04436249f, -0.03800531f, 0.07849761f, 
    -0.22149208f, -0.19131912f, -0.08131333f, 0.02565371f, 0.09266010f, 0.12057967f, 0.27316183f, 0.17785650f, 
    0.04227160f, 0.09896980f, 0.08528973f, 0.21167256f, -0.41937566f, -0.42585635f, 0.05571033f, 0.08508630f, 
    -0.04213492f, -0.06175712f, -0.03837701f, -0.00758274f, -0.04686093f, 0.04806292f, -0.05770806f, -0.15018256f, 
    -0.00712473f, -0.11083361f, -0.09659497f, 0.10078873f, 0.02025535f, -0.02839507f, -0.05919791f, -0.25632936f, 
    -0.14225267f, -0.07989050f, 0.24652995f, 0.02692668f, -0.20480946f, -0.22038057f, 0.10553000f, -0.06792517f, 
    -0.05232338f, 0.16972391f, -0.20649551f, 0.11859141f, 0.04336596f, 0.07265155f, 0.20121852f, 0.06928190f, 
    0.02267577f, 0.42048255f, -0.25249901f, -0.07522798f, 0.01353199f, -0.03943174f, -0.16818376f, 0.01910998f, 
    -0.06963071f, 0.00132798f, 0.00311158f, 0.16633372f, -0.05235790f, 0.55393243f, -0.09386235f, 0.18917570f, 
    -0.04372857f, 0.11876085f, 0.10589804f, 0.00735845f, 0.09386795f, -0.13071984f, 0.24165221f, 0.04436174f, 
    -0.17912000f, -0.08940401f, 0.07403828f, -0.15320353f, 0.03076364f, -0.05227091f, -0.08434197f, 0.03592984f, 
    0.01693454f, 0.12783985f, 0.22300977f, -0.01917181f, 0.21955615f, 0.05949660f, 0.05270352f, -0.07592630f, 
    -0.01850563f, -0.00718456f, 0.12896727f, 0.02282043f, 0.11097502f, -0.07375260f, 0.19941957f, 0.06785963f, 
    -0.12369916f, 0.19432104f, 0.03786727f, 0.12539759f, 0.12933876f, 0.12676090f, 0.00682910f, 0.08049680f, 
    0.06787651f, 0.17833649f, 0.20579705f, 0.03403483f, -0.05096240f, 0.20457546f, 0.11328705f, -0.06008320f, 
    0.07250302f, -0.02845254f, 0.09749743f, 0.05354870f, -0.16757348f, -0.22939771f, -0.38217956f, -0.56097764f, 
    -0.14266531f, -0.14187667f, -0.00887905f, -0.08776154f, 0.04135774f, 0.11093532f, -0.06494015f, -0.16928424f, 
    0.01944462f, 0.00169295f, -0.01187421f, -0.08977129f, 0.12190231f, 0.16449501f, -0.30946818f, 0.07326311f, 
    -0.11147594f, -0.30770776f, 0.18271534f, -0.05158666f, -0.01412552f, -0.16243270f, 0.01689333f, -0.23871399f, 
    0.15140346f, 0.04277638f, 0.25843275f, -0.07171808f, -0.06505023f, 0.11475440f, -0.18971740f, 0.07729855f, 
    0.16760693f, 0.16316211f, -0.30023393f, 0.12608986f, -0.40395057f, -0.05439493f, -0.31727287f, -0.09525362f, 
    -0.02836924f, -0.00184140f, -0.00780191f, 0.02254254f, 0.11070774f, -0.04738202f, 0.21240693f, 0.00150187f, 
    -0.07035092f, -0.19536415f, 0.10305414f, -0.10385917f, 0.19004063f, 0.00888578f, -0.04773626f, -0.12460916f, 
    -0.06851615f, 0.05603058f, -0.07263272f, -0.12384258f, -0.34228250f, -0.23419541f, 0.31345838f, 0.09367055f, 
    0.00987270f, -0.02715844f, -0.01060927f, -0.00289987f, 0.12630002f, -0.03215795f, -0.17148671f, 0.09140747f, 
    0.12521341f, -0.09252504f, 0.18416364f, -0.02344516f, -0.04897414f, -0.24668446f, 0.08114827f, 0.06452575f, 
    0.11758060f, -0.05328392f, -0.05981921f, 0.00079910f, -0.00758857f, 0.44844031f, -0.13644995f, 0.36096254f, 
    0.10819147f, -0.11055215f, 0.22041439f, 0.05314496f, 0.08873970f, 0.02034045f, -0.10170259f, 0.09697671f, 
    -0.14429282f, 0.21334833f, -0.13106358f, 0.14334059f, 0.02796566f, 0.01110476f, 0.09981298f, -0.04652357f, 
    -0.04366061f, -0.00945399f, -0.00009194f, -0.04852642f, 0.06222341f, 0.03029344f, 0.17512111f, -0.06974559f, 
    -0.25626707f, 0.02549085f, 0.12214276f, -0.04832324f, 0.29386029f, 0.01673021f, 0.26073796f, 0.06028784f, 
    -0.07736048f, 0.07797789f, -0.09574976f, -0.11762003f, -0.07070616f, -0.06797726f, 0.10980147f, -0.09983773f, 
    -0.05259382f, 0.01236674f, -0.19941492f, 0.10127983f, 0.00213973f, 0.10937515f, -0.02253141f, 0.05514780f, 
    -0.03999861f, 0.02342821f, 0.05018925f, 0.08916829f, 0.06777865f, -0.01712080f, 0.08799654f, 0.25671336f, 
    -0.20670852f, -0.06958592f, 0.07801271f, 0.02788712f, 0.10629044f, 0.07775993f, -0.00023154f, -0.15592800f, 
    0.04989487f, -0.00085695f, 0.19187956f, -0.10015708f, 0.00415090f, 0.04403659f, 0.03428446f, 0.06264139f, 
    -0.06693227f, 0.14232682f, 0.06681105f, -0.06033819f, 0.10750813f, 0.02996149f, 0.06188909f, 0.12433473f, 
    0.07661665f, 0.33576071f, 0.03645743f, 0.29786372f, 0.05523658f, -0.08653292f, -0.15296176f, 0.06177952f, 
    -0.03137060f, -0.06672019f, -0.07912362f, 0.05845085f, -0.05077200f, 0.02952441f, 0.02457045f, -0.13849431f, 
    -0.01357855f, -0.06105117f, -0.01976275f, -0.04454798f, -0.14501461f, -0.16261435f, -0.17161244f, -0.13053697f, 
    0.21340229f, -0.19000617f, 0.02366006f, 0.10641959f, -0.01154500f, -0.05202661f, 0.14225335f, -0.11847921f, 
    0.13198651f, -0.14494695f, -0.30406976f, 0.04524762f, 0.39097625f, -0.04688163f, 0.13052794f, 0.03927326f, 
    -0.12261110f, -0.04065299f, 0.21453597f, 0.14476833f, 0.06398681f, 0.06516775f, 0.05041219f, 0.03425964f, 
    -0.02384052f, 0.03078165f, -0.02150171f, 0.18261003f, -0.09270168f, -0.03552929f, -0.13365264f, 0.14794442f, 
    -0.08961084f, 0.00089766f, -0.00321161f, -0.01494740f, -0.50544095f, -0.25685832f, 0.07021930f, -0.12342443f, 
    -0.03081522f, 0.08452868f, -0.12059740f, 0.09083424f, 0.01361912f, -0.19017169f, 0.12241147f, -0.15661223f, 
    0.09827588f, -0.07466355f, 0.04350020f, -0.21991986f, -0.10241497f, 0.25098145f, 0.22163273f, 0.21000345f, 
    -0.01428124f, -0.05266581f, 0.04720245f, 0.13312329f, -0.11424687f, 0.02576236f, -0.08124332f, 0.34009886f, 
    -0.01971444f, 0.08565477f, 0.09338591f, 0.03683814f, 0.02046107f, -0.17934893f, 0.14904347f, 0.11384250f, 
    -0.05667775f, -0.02313842f, 0.03423263f, -0.00353063f, -0.00643105f, -0.04598578f, -0.02579430f, -0.03061511f, 
    -0.02147176f, 0.01990765f, -0.02110107f, 0.02334575f, 0.01482626f, 0.02647136f, 0.03950518f, -0.02278171f, 
    0.02349002f, 0.00271282f, -0.00055357f, 0.01399238f, -0.04620412f, -0.01270918f, -0.05727046f, 0.03404146f, 
    0.01972001f, -0.03962303f, -0.00220412f, 0.03527226f, -0.02042843f, 0.01584223f, 0.01285972f, 0.00143759f, 
    -0.03121946f, -0.05105422f, 0.00542356f, -0.00163767f, -0.00569386f, -0.04648305f, 0.03149128f, -0.00142955f, 
    -0.01477040f, 0.04403100f, 0.02656876f, 0.03354895f, 0.02701375f, -0.05076959f, -0.04259439f, 0.00020365f, 
    -0.02464151f, 0.04201036f, -0.00040601f, -0.02488507f, 0.03810157f, -0.02034572f, -0.00132615f, 0.04282836f, 
    -0.04430237f, -0.04178753f, 0.00096914f, -0.04279946f, 0.02266212f, -0.03870074f, -0.04328884f, 0.02846975f, 
    0.04306547f, -0.00189779f, 0.00652052f, 0.03163227f, 0.03313142f, -0.02157213f, 0.02369602f, 0.01508234f, 
    0.00338237f, -0.05428104f, -0.02729286f, 0.03975270f, -0.02692121f, -0.00038218f, 0.01579842f, 0.03888075f, 
    -0.03508276f, -0.05610793f, 0.02022871f, 0.02874600f, 0.02507584f, 0.01743918f, -0.05402715f, -0.03861049f, 
    -0.00653891f, -0.00245202f, 0.01958944f, -0.01621986f, -0.03717574f, -0.03343116f, -0.05259765f, 0.00547841f, 
    -0.01682977f, -0.05599444f, -0.03412218f, 0.00710500f, -0.00901732f, -0.00104134f, -0.00292468f, -0.02561129f, 
    0.03642774f, 0.00595336f, 0.00832116f, 0.02982031f, -0.04529393f, -0.02345263f, -0.01501572f, -0.05153941f, 
    0.03180250f, -0.00660008f, 0.02982681f, -0.01932171f, 0.01545018f, -0.05556241f, -0.02279061f, -0.03884375f, 
    -0.01199496f, -0.00798648f, -0.00340306f, -0.03796649f, -0.02933151f, 0.03968134f, -0.04657654f, 0.01856626f, 
    -0.02068013f, 0.01508700f, 0.00740134f, -0.01277198f, 0.03194080f, 0.00596962f, -0.00082135f, -0.04539373f, 
    0.02684321f, 0.00235906f, -0.02147804f, 0.02269356f, -0.05411970f, -0.03909257f, -0.01779938f, -0.04113402f, 
    -0.05443554f, 0.03577244f, -0.00987665f, 0.03133114f, 0.00019063f, -0.01526824f, 0.03261783f, -0.00168511f, 
    -0.00733110f, 0.01769106f, -0.00343996f, 0.01967655f, 0.01792752f, -0.03744317f, -0.02943937f, 0.01196493f, 
    -0.05620591f, 0.03426239f, -0.03105398f, 0.01212663f, 0.01644566f, -0.00914496f, -0.01788322f, 0.00262079f, 
    0.02305432f, -0.05304611f, 0.03375593f, -0.05019514f, 0.00577955f, 0.01768071f, -0.01042672f, 0.00983216f, 
    -0.02950366f, -0.01771706f, -0.03910560f, -0.03534123f, -0.00734391f, 0.03805977f, 0.05188064f, 0.03004988f, 
    0.04237709f, 0.00024436f, 0.03462789f, -0.04647312f, 0.00601736f, -0.02078581f, -0.03184522f, 0.01109764f, 
    -0.05611438f, -0.04057372f, -0.04452180f, -0.05858892f, -0.03513100f, -0.01338211f, -0.05526319f, -0.02000254f, 
    0.00100977f, 0.00714916f, -0.00256396f, -0.02482301f, 0.01704472f, 0.01264531f, 0.03941569f, 0.01414500f, 
    0.03857477f, -0.05436052f, -0.00137856f, 0.00097878f, 0.03968240f, -0.00534663f, -0.00476459f, 0.01540847f, 
    0.01332710f, -0.04015785f, -0.04597159f, 0.00820528f, -0.02080988f, 0.00666937f, -0.05290515f, 0.01772626f, 
    -0.01042054f, 0.03080577f, 0.02148400f, 0.03579589f, -0.04312563f, -0.02721068f, -0.04964112f, 0.02768554f, 
    0.00797597f, -0.05625776f, -0.02601727f, 0.02093863f, 0.00956960f, -0.04567334f, -0.05001209f, 0.03981648f, 
    -0.00900607f, -0.01406271f, -0.02371530f, 0.02095625f, -0.01669944f, 0.00962667f, 0.03136256f, 0.00010030f, 
    -0.03468831f, -0.00911982f, 0.00805271f, -0.02626187f, 0.00666860f, -0.01031827f, -0.05567484f, 0.02324630f, 
    0.01804308f, -0.01988224f, -0.03513232f, -0.01035194f, -0.02991146f, 0.01339178f, 0.01090033f, -0.03372827f, 
    0.02433901f, 0.00265466f, -0.05480551f, 0.04322704f, -0.05421275f, -0.00735782f, -0.05557757f, -0.02958162f, 
    -0.00218469f, -0.03558205f, 0.04276136f, -0.01559944f, -0.02254424f, -0.02469606f, 0.01477116f, -0.05217567f, 
    0.01491569f, -0.03427446f, 0.02292964f, -0.01240545f, -0.03275246f, -0.00495407f, -0.03577498f, -0.02183413f, 
    0.00048091f, -0.01754146f, 0.03746358f, -0.01834200f, 0.02322348f, -0.00099914f, 0.03424659f, -0.01883419f, 
    0.00906754f, 0.01911546f, 0.02960415f, -0.03976288f, 0.00858917f, -0.04044217f, 0.02187962f, -0.02019906f, 
    0.03050797f, -0.00699039f, 0.01285120f, 0.00584031f, 0.04331422f, -0.03591602f, -0.05125011f, 0.03160601f, 
    0.02753940f, 0.01791473f, -0.03090598f, 0.00540145f, 0.02242905f, 0.01875499f, -0.05554217f, -0.05550009f, 
    -0.05463191f, 0.02812009f, 0.00793822f, -0.03055401f, 0.03359374f, 0.02604818f, -0.05498897f, -0.01770555f, 
    -0.02826988f, -0.00299587f, -0.03882189f, -0.05006856f, -0.04100134f, -0.05435705f, -0.05379340f, -0.00227389f, 
    0.02990707f, 0.03860284f, -0.04073838f, -0.02128266f, 0.02640877f, 0.00137924f, 0.00796574f, 0.03074223f, 
    0.00641055f, -0.00474759f, -0.00612334f, -0.03143481f, -0.01693938f, 0.02569161f, -0.04949998f, 0.04686245f, 
    -0.02459921f, 0.02147863f, -0.04486930f, 0.02929497f, -0.02345804f, 0.00684053f, -0.02254285f, 0.02702970f, 
    -0.03886474f, -0.04572146f, 0.00872193f, -0.04201974f, 0.03266955f, -0.04122869f, -0.02609906f, -0.01272424f, 
    0.00324060f, -0.02854666f, 0.01036584f, -0.02309848f, -0.03231994f, -0.02883478f, -0.00175459f, -0.00254472f, 
    0.01925266f, -0.05753659f, 0.01431778f, -0.01837548f, -0.00833331f, -0.05855370f, -0.01906510f, 0.01897530f, 
    -0.30570349f, -0.26314020f, 0.21052149f, 0.08141966f, -0.04358913f, -0.03239611f, -0.19711684f, -0.03399526f, 
    -0.00003301f, -0.04786048f, -0.00721128f, -0.09006696f, -0.20234132f, -0.22463539f, -0.03026815f, 0.06077491f, 
    -0.04114796f, -0.09821223f, -0.06451979f, 0.09259712f, 0.14997561f, 0.12572156f, 0.01170677f, 0.01083949f, 
    0.03031131f, 0.01625369f, -0.01896026f, -0.20783433f, 0.12123955f, 0.21536916f, 0.09948659f, 0.15422310f, 
    0.13739109f, 0.04067156f, -0.14973609f, 0.09010737f, -0.04711902f, 0.05262540f, -0.16724923f, 0.02771375f, 
    0.03157775f, 0.00586697f, 0.16114666f, -0.18582188f, 0.07088403f, -0.09656017f, -0.11244454f, 0.04378151f, 
    0.16678002f, 0.17267863f, 0.03220691f, -0.02659080f, 0.00443873f, 0.00394782f, 0.10083874f, -0.03212982f, 
    0.06037491f, 0.04986915f, -0.02057135f, -0.11551255f, -0.04498949f, 0.21254371f, -0.00978510f, 0.12133062f, 
    0.19649142f, -0.14978394f, 0.00715436f, 0.06256616f, 0.02231995f, 0.24315982f, -0.02363993f, 0.15340866f, 
    0.07204834f, -0.05730157f, 0.16352741f, -0.17300165f, -0.01473937f, 0.12753858f, -0.04464581f, -0.10040259f, 
    -0.03521487f, 0.02123756f, -0.10493220f, 0.07194977f, -0.04202584f, 0.12686113f, -0.13910896f, 0.14803208f, 
    0.01167222f, -0.05148058f, -0.17754707f, -0.13781410f, 0.16602446f, 0.05153957f, 0.09599530f, 0.16569208f, 
    0.11602940f, -0.26345032f, -0.13286158f, 0.23213682f, -0.01200774f, -0.03648886f, 0.11639711f, 0.12753095f, 
    0.03105152f, 0.02948642f, -0.05247678f, 0.18352513f, -0.18343286f, 0.05700913f, 0.23739012f, 0.18155357f, 
    -0.10165895f, 0.03647310f, 0.03430818f, 0.12309194f, -0.05629665f, -0.02138121f, -0.02565418f, -0.03779680f, 
    -0.04787005f, 0.17836021f, 0.05799628f, -0.15214361f, -0.13023965f, -0.07202376f, 0.04575766f, -0.01717639f, 
    -0.12996429f, -0.19937919f, 0.07548450f, -0.08879563f, 0.13960993f, -0.05309829f, -0.04385916f, 0.00768042f, 
    0.04787497f, 0.02573327f, 0.09377692f, -0.00130085f, -0.06260312f, 0.11932889f, -0.07410540f, -0.04883227f, 
    -0.04247949f, -0.07530656f, 0.10320183f, -0.11652260f, -0.03109988f, 0.02721705f, -0.01275543f, 0.01861255f, 
    0.05392073f, 0.02781843f, 0.18565384f, 0.02991661f, 0.02444272f, 0.16025518f, 0.40198198f, -0.17958066f, 
    0.02450457f, -0.10753799f, 0.05816493f, -0.09619059f, 0.02091148f, 0.02889348f, -0.01478949f, 0.02905924f, 
    0.00054704f, -0.14447504f, -0.07150903f, 0.28935477f, -0.14357901f, 0.04379671f, 0.18100484f, 0.10128054f, 
    0.03385823f, -0.02445161f, 0.01855305f, 0.17759615f, 0.14988016f, 0.01641756f, -0.20062202f, 0.09210681f, 
    -0.03824680f, 0.12550581f, -0.03227067f, -0.06128974f, 0.01696355f, -0.02634737f, 0.07404071f, -0.04755127f, 
    0.41822016f, -0.04241783f, 0.07263862f, 0.07843473f, 0.04831509f, 0.03792606f, -0.13411075f, -0.17578873f, 
    0.01365742f, 0.15465893f, 0.09441283f, 0.11005130f, -0.16860631f, -0.16390446f, 0.19653694f, 0.15003194f, 
    0.12651557f, 0.03439033f, -0.04319851f, -0.01962171f, 0.11812775f, 0.05330059f, 0.05443046f, -0.03478663f, 
    -0.29346475f, 0.16652352f, 0.32751197f, -0.01150738f, 0.17441815f, -0.07938142f, -0.07378693f, 0.04207524f, 
    0.07544029f, -0.09307715f, 0.09669485f, -0.05091419f, -0.04452837f, 0.01357066f, 0.09478202f, 0.17245644f, 
    0.17039068f, -0.20339002f, 0.14852528f, 0.22741875f, -0.07294060f, 0.18322545f, -0.06767595f, 0.27565584f, 
    0.60264927f, 0.17122199f, -0.24282993f, -0.15363117f, -0.03717114f, 0.01685054f, -0.06570314f, 0.03878218f, 
    0.06078405f, 0.07146279f, 0.26761210f, 0.05356659f, -0.00854971f, -0.09014759f, -0.04763014f, -0.15609685f, 
    0.10900115f, -0.06689044f, -0.02456865f, 0.13500433f, -0.01332970f, 0.15945864f, -0.00275139f, -0.04465789f, 
    -0.27656329f, -0.17907690f, -0.04986399f, 0.18530466f, -0.19084579f, -0.09490219f, -0.10350870f, -0.01113609f, 
    0.12836738f, 0.15814526f, 0.06499550f, 0.10743164f, -0.09613487f, 0.00470686f, -0.19344023f, -0.07197254f, 
    0.13364746f, 0.05267078f, -0.09606910f, 0.12409694f, 0.04877790f, 0.01565708f, -0.02375946f, -0.01543463f, 
    -0.26703209f, -0.18107875f, 0.28793129f, -0.03052879f, -0.04510157f, 0.03495760f, 0.13209128f, 0.19066915f, 
    0.06824248f, 0.07224254f, 0.19877566f, 0.04588034f, -0.03826684f, 0.04826600f, -0.01383252f, -0.13829337f, 
    -0.07873657f, -0.11811123f, -0.03609908f, -0.00708192f, -0.03207732f, -0.01557001f, 0.16797495f, -0.01159899f, 
    -0.11957812f, -0.25447404f, -0.01459658f, -0.02365254f, 0.09554851f, 0.06551426f, 0.02902142f, 0.03899948f, 
    0.02808410f, 0.07755160f, 0.08708392f, -0.16130209f, -0.14857846f, -0.11322033f, 0.08965010f, 0.15409955f, 
    0.02148313f, -0.07596960f, -0.01724888f, -0.09399679f, -0.01183328f, 0.14030752f, 0.02929975f, 0.00795346f, 
    0.27678338f, 0.29769069f, -0.35008010f, -0.09444920f, 0.02563067f, 0.08012576f, 0.22230199f, -0.00446194f, 
    -0.01708317f, 0.14403903f, 0.14724791f, -0.07317551f, 0.29096732f, 0.27644330f, -0.06289970f, 0.11196372f, 
    0.05400074f, -0.04528449f, -0.00004223f, -0.13812786f, -0.15609016f, 0.03398035f, 0.05415792f, 0.15430868f, 
    0.04722375f, 0.04807073f, 0.27812907f, -0.02683136f, 0.01843398f, -0.08001754f, 0.01523957f, 0.03545161f, 
    -0.11948436f, 0.15813862f, 0.09507819f, 0.13308065f, 0.12925771f, 0.24722809f, -0.29452515f, -0.08372091f, 
    0.04563275f, 0.02669123f, 0.09745371f, 0.14754795f, -0.08377706f, 0.07986845f, -0.14689562f, -0.17178567f, 
    -0.01789344f, 0.02713560f, -0.04876596f, 0.03738432f, -0.00516096f, -0.02336777f, -0.03573386f, 0.00754138f, 
    -0.01038509f, 0.04367192f, -0.05370796f, 0.00181259f, -0.01982062f, 0.01619147f, 0.00035183f, 0.04270685f, 
    -0.05099714f, -0.01797856f, -0.00365738f, -0.05718342f, -0.00936743f, 0.02114240f, 0.04868234f, -0.02868630f, 
    -0.03644068f, -0.04175435f, 0.03748916f, 0.03526692f, -0.04115848f, -0.03981913f, -0.03991273f, 0.02810243f, 
    0.03431692f, -0.04454469f, -0.00625227f, -0.03528734f, -0.00882105f, -0.02668294f, -0.05025494f, -0.01120283f, 
    0.03204613f, 0.00319328f, 0.01018214f, -0.03551203f, 0.01368564f, 0.00608734f, -0.02113193f, -0.01450395f, 
    -0.02032816f, -0.02126651f, -0.00274959f, -0.05910873f, -0.04706217f, 0.02395045f, -0.03224142f, -0.03317009f, 
    0.02471607f, -0.03155170f, 0.03872358f, 0.01974673f, 0.03763515f, -0.03595663f, -0.00042382f, 0.01973037f, 
    0.02596626f, 0.02770566f, 0.02942094f, -0.05862815f, -0.02499425f, -0.00341557f, 0.00894530f, -0.03592555f, 
    -0.05520977f, 0.03614274f, -0.01783444f, -0.05557547f, -0.03189254f, 0.02908109f, -0.03728286f, 0.02033858f, 
    -0.03740760f, 0.00964740f, 0.02566868f, 0.02068599f, 0.02306414f, 0.00129840f, -0.02748084f, 0.03667494f, 
    -0.05621546f, 0.02069927f, 0.00408184f, -0.02860187f, -0.04794223f, 0.02286758f, -0.05273334f, -0.00604859f, 
    -0.02228211f, -0.02148690f, -0.00489314f, -0.04678761f, 0.03386688f, 0.00916392f, 0.02506106f, 0.03213650f, 
    -0.06036447f, 0.02196633f, -0.04764533f, -0.05490594f, 0.01638859f, -0.05681575f, -0.05184973f, 0.01235612f, 
    0.03717276f, -0.00772131f, 0.02893945f, -0.01643920f, -0.03108185f, -0.05525966f, 0.00809271f, 0.00311350f, 
    0.03964260f, 0.00952910f, -0.01280134f, -0.02488899f, -0.01433895f, -0.05277936f, 0.00949712f, 0.03555565f, 
    -0.05401038f, 0.02847624f, -0.02777123f, -0.00639845f, -0.01378258f, 0.04673443f, 0.00289793f, -0.04917694f, 
    -0.02748345f, 0.02799169f, 0.01051337f, -0.03041305f, -0.01718772f, 0.01864013f, 0.01077174f, -0.03873584f, 
    -0.02408156f, 0.01270672f, 0.03316877f, -0.02200366f, 0.02155214f, 0.02909988f, 0.02680172f, 0.00123570f, 
    -0.00273675f, 0.02478334f, 0.00437523f, -0.04761548f, 0.00450195f, -0.01538841f, -0.02257144f, -0.04130334f, 
    -0.02297786f, -0.04374965f, 0.02774114f, -0.00412639f, -0.01672483f, -0.01153193f, 0.00494044f, -0.02351029f, 
    -0.04857720f, 0.01590187f, 0.02263809f, 0.02697864f, -0.05588866f, -0.01102653f, 0.00602422f, 0.03091704f, 
    0.01667274f, -0.04203538f, -0.04010932f, 0.02938491f, 0.00442086f, 0.00341169f, -0.01853622f, 0.01815090f, 
    0.02505481f, -0.03184751f, -0.03898042f, -0.04133010f, 0.02263450f, -0.00560366f, 0.01013102f, 0.02145878f, 
    -0.01294916f, -0.03370039f, 0.03946169f, -0.01805751f, 0.04145148f, 0.04297242f, -0.04566282f, -0.03050193f, 
    0.03579194f, -0.03668435f, 0.02039127f, -0.00055364f, 0.04764517f, -0.02203078f, -0.01007579f, -0.04500416f, 
    -0.00543073f, -0.04494641f, -0.04600441f, -0.02694168f, -0.04831759f, 0.03429664f, -0.01232559f, -0.00482780f, 
    -0.00577749f, 0.00098471f, -0.01235317f, -0.00835497f, -0.01832855f, -0.04751964f, -0.01522018f, -0.04307539f, 
    0.02804109f, -0.02399026f, -0.04314223f, 0.03389648f, 0.00811586f, 0.02095474f, -0.05247654f, 0.03949844f, 
    0.01443543f, -0.04604443f, -0.01822437f, 0.00654837f, 0.02773881f, 0.03618640f, -0.00695037f, -0.02728740f, 
    0.00298026f, -0.04167230f, 0.00830022f, -0.05719060f, -0.01506449f, 0.00131685f, -0.05526325f, -0.02704389f, 
    0.02524748f, 0.00785596f, -0.00838751f, -0.00240255f, 0.02528237f, 0.02121075f, -0.00605179f, 0.02097840f, 
    0.01691916f, -0.01444076f, -0.05129923f, -0.02032603f, -0.02015576f, 0.00104844f, 0.04084302f, -0.04610021f, 
    -0.02683712f, -0.04463614f, -0.04282951f, -0.03015938f, 0.03988232f, 0.00378905f, -0.00780723f, -0.03906195f, 
    -0.05626816f, 0.00949026f, 0.02860116f, -0.00411705f, -0.01217565f, 0.03450127f, -0.05625776f, 0.02127858f, 
    0.01430578f, -0.04887451f, -0.02190943f, -0.01824596f, -0.02022623f, 0.02719926f, -0.03424944f, -0.05193409f, 
    -0.01531970f, 0.01456490f, -0.04444391f, 0.00779274f, -0.00853141f, -0.01485474f, -0.03993315f, -0.04666709f, 
    0.00994624f, 0.02180691f, -0.00155679f, -0.04946601f, -0.01445047f, 0.02011698f, -0.04493926f, 0.00508087f, 
    0.03213121f, -0.01075211f, -0.05782580f, 0.01027858f, 0.00991235f, -0.02836194f, 0.02186197f, -0.02882757f, 
    0.04436560f, -0.05933801f, -0.04662167f, -0.01399588f, 0.02927236f, 0.00445076f, 0.02376084f, -0.02975104f, 
    0.04413969f, -0.04410408f, -0.05340077f, -0.02663361f, 0.02456256f, -0.04302091f, 0.00641367f, -0.03830421f, 
    0.02405023f, 0.00633284f, -0.04436063f, 0.03567930f, -0.02074018f, -0.02102097f, 0.03062378f, 0.01665907f, 
    -0.00738887f, -0.01212373f, -0.00815592f, -0.01640632f, -0.01514828f, 0.01127094f, 0.01552951f, 0.01803504f, 
    -0.03460908f, -0.04372943f, 0.00848209f, 0.01204266f, -0.03005502f, 0.01632401f, 0.00047829f, 0.03328854f, 
    0.01968271f, -0.00918615f, 0.02173643f, 0.03625844f, -0.04545471f, -0.03187463f, -0.00708165f, -0.04645602f, 
    0.03605718f, -0.00388466f, 0.00448090f, 0.01327142f, 0.00831999f, -0.04773026f, -0.05278056f, 0.02389713f, 
    0.03758967f, 0.02685149f, 0.01555153f, -0.05228994f, -0.01838594f, -0.03908436f, -0.02931666f, 0.01230301f, 
    -0.00967790f, -0.03410039f, -0.04604749f, -0.05287464f, -0.03090971f, -0.00247807f, -0.02940679f, 0.00865647f, 
    -0.05611690f, -0.03548665f, 0.00869238f, 0.00973521f, -0.00232917f, 0.01640467f, 0.01556543f, 0.03918267f, 
    -0.00033484f, 0.04021090f, 0.01324705f, -0.04625639f, -0.05016990f, -0.04782168f, 0.01032064f, 0.01503042f, 
    0.01795683f, -0.01359064f, -0.00609398f, 0.01930459f, -0.01353704f, -0.02126383f, -0.00110471f, -0.03036188f, 
    0.03315907f, -0.04705429f, 0.01357319f, -0.00671606f, -0.00672723f, 0.02023219f, 0.01712959f, -0.04250059f, 
    0.03897211f, 0.00049245f, -0.02216758f, 0.01898521f, 0.03887124f, -0.04967555f, -0.02341412f, -0.02084941f, 
    0.01565057f, -0.00537102f, 0.03162269f, 0.03466102f, 0.02063536f, 0.00190688f, 0.00276499f, 0.02670761f, 
    0.00307649f, -0.03939551f, 0.03179860f, -0.00546187f, 0.04174462f, -0.03934412f, -0.01947927f, -0.05495319f, 
    0.03722837f, -0.03491876f, -0.05366186f, 0.04190147f, 0.03753991f, -0.02794001f, 0.03865014f, -0.05579658f, 
    0.03736829f, -0.04901571f, 0.00888951f, -0.04869325f, -0.05684105f, -0.01536185f, 0.02836312f, -0.05133644f, 
    -0.04173440f, 0.01275506f, 0.00597239f, -0.05500393f, -0.01993738f, -0.03146077f, -0.04891098f, -0.00014120f, 
    -0.03524111f, -0.01972255f, 0.03513635f, 0.00731091f, 0.03516658f, -0.03685604f, -0.01103411f, 0.02167403f, 
    -0.04533846f, -0.01764143f, -0.04640619f, -0.03025488f, 0.03324325f, -0.03229228f, -0.03008785f, -0.02383501f, 
    -0.03960144f, 0.01285095f, 0.04140216f, -0.03036431f, 0.04250536f, 0.04162116f, 0.03026073f, -0.02748196f, 
    -0.02922301f, -0.05386239f, -0.00425994f, 0.03676892f, -0.00296630f, -0.01459650f, -0.01298267f, -0.05082997f, 
    0.01752228f, 0.01744151f, -0.00763234f, -0.00237668f, -0.04129985f, 0.00794540f, -0.01434125f, -0.00073343f, 
    0.00490998f, -0.03730026f, 0.02886858f, 0.00383649f, 0.02167780f, 0.01309210f, -0.03264289f, 0.03450964f, 
    0.01784194f, 0.04067046f, 0.00996220f, -0.03088515f, -0.03260739f, 0.00596633f, -0.05259253f, 0.00545025f, 
    -0.01291718f, 0.03499248f, 0.02874509f, -0.03219339f, 0.01870687f, -0.00331043f, -0.01719779f, -0.04398546f, 
    -0.02013770f, 0.02387848f, 0.01305138f, -0.04264324f, -0.00929744f, 0.00385850f, -0.05475222f, -0.01584248f, 
    -0.03402021f, -0.02690421f, -0.03849825f, -0.02110003f, -0.04669407f, 0.03944820f, 0.00496853f, -0.02379754f, 
    -0.01236548f, 0.03833681f, -0.01817155f, 0.01748905f, -0.01208176f, -0.02039048f, -0.03957130f, 0.02682796f, 
    -0.05127474f, 0.02320052f, 0.00806530f, -0.01615801f, -0.04385441f, 0.02018508f, -0.01216970f, -0.05248879f, 
    -0.02660554f, -0.00043029f, -0.01228997f, -0.01083235f, 0.02920909f, -0.02584070f, -0.03290483f, -0.01444840f, 
    -0.01943488f, 0.04368744f, -0.03357983f, -0.05558722f, -0.02912999f, 0.01438915f, -0.00603825f, -0.00811384f, 
    0.01147409f, -0.02522813f, 0.01895164f, -0.04429349f, -0.04225206f, -0.01022231f, 0.04141682f, -0.00641646f, 
    -0.00441152f, 0.01606041f, -0.05169683f, -0.02202469f, -0.05413216f, -0.04465755f, -0.02754280f, -0.04047995f, 
    -0.00919092f, -0.03977865f, -0.01115479f, 0.03156793f, -0.04255524f, -0.03346544f, -0.00032034f, 0.03237339f, 
    -0.03346578f, 0.02907229f, -0.04364529f, -0.03418981f, 0.02030373f, -0.03331042f, -0.04986081f, 0.02813227f, 
    0.00680045f, 0.02600103f, -0.05502336f, 0.02934451f, -0.05093417f, 0.02090439f, 0.00070572f, -0.05909338f, 
    -0.01267717f, 0.01603700f, 0.01892041f, -0.00732561f, 0.03441980f, -0.04246097f, 0.01826222f, -0.00214133f, 
    0.00629465f, -0.04217706f, -0.04385132f, -0.01071655f, -0.01920798f, 0.03268899f, -0.02239367f, -0.02460490f, 
    0.03835693f, 0.00116249f, -0.05545750f, -0.00536994f, -0.00839897f, 0.04056882f, -0.00173511f, -0.04380046f, 
    0.02756012f, 0.01888185f, -0.03805143f, 0.04014063f, -0.02486580f, -0.02463401f, 0.00415083f, -0.01017420f, 
    0.02830191f, 0.02246045f, 0.01995608f, -0.01422428f, -0.03772078f, -0.00134629f, -0.02203385f, -0.05102346f, 
    0.02000400f, -0.01847762f, 0.03038834f, -0.00228151f, -0.00620103f, 0.02286531f, -0.04356533f, -0.02612194f, 
    -0.02638352f, -0.01463946f, 0.01014324f, -0.02231451f, -0.00710995f, -0.00188586f, -0.03706203f, 0.02628771f, 
    -0.02874973f, 0.01403998f, -0.03298752f, 0.00007049f, 0.01266037f, 0.01282565f, -0.00638888f, 0.01843158f, 
    0.01949410f, -0.02138754f, -0.04301735f, 0.03433525f, 0.02468379f, -0.02214736f, -0.05012231f, -0.02714469f, 
    -0.05059616f, -0.05320309f, -0.02620967f, -0.01967992f, -0.03576031f, -0.00582149f, -0.02726957f, 0.03294984f, 
    -0.05349540f, -0.02420928f, 0.02202557f, -0.02760667f, -0.01021421f, 0.03730490f, -0.04898848f, -0.02626527f, 
    -0.02323093f, -0.03760643f, 0.03581543f, -0.02022198f, -0.00600399f, 0.01451372f, -0.00954354f, -0.04403450f, 
    -0.00582888f, 0.00553868f, -0.05444964f, 0.02912093f, -0.04644813f, 0.00938484f, -0.01955746f, -0.00554197f, 
    -0.03605967f, -0.01493784f, -0.03848888f, 0.04163028f, 0.01251095f, -0.02182635f, -0.01196488f, 0.03755770f, 
    -0.04266210f, -0.00483638f, 0.00893205f, 0.02007932f, -0.03277082f, 0.03062466f, 0.03527522f, -0.01528061f, 
    0.02658414f, 0.02348697f, -0.05420357f, 0.00490338f, 0.00198054f, 0.00965002f, -0.03649033f, -0.03176389f, 
    0.02696040f, 0.03797550f, -0.03532920f, 0.03411621f, -0.02780070f, 0.00719948f, -0.00260677f, -0.03994174f, 
    0.01780613f, -0.02051856f, -0.05094936f, 0.03401537f, -0.01063880f, 0.01587845f, 0.03243453f, -0.00289887f, 
    -0.00362503f, -0.02872238f, 0.03682437f, -0.05593150f, -0.00819649f, 0.03521701f, -0.04463347f, -0.01273415f, 
    0.10471187f, 0.09144643f, -0.00396583f, 0.18844567f, 0.14864783f, 0.01829793f, 0.03763376f, 0.25916240f, 
    0.11620018f, -0.15774550f, -0.11568965f, -0.26715621f, -0.07891855f, -0.18717986f, -0.05022665f, 0.06363722f, 
    0.19081603f, 0.06908402f, 0.05541072f, 0.12990060f, 0.07221173f, 0.03168489f, 0.20290972f, 0.23803364f, 
    0.29588136f, 0.03085796f, -0.02928095f, 0.34431955f, -0.22221839f, -0.07504841f, -0.03011279f, -0.06780708f, 
    -0.02054092f, 0.11287537f, 0.09548320f, -0.19623752f, -0.13297299f, -0.06061443f, -0.08854110f, -0.00399131f, 
    0.02241194f, -0.05909669f, -0.07581050f, -0.13847841f, -0.41236526f, -0.18619537f, -0.28163832f, -0.44733235f, 
    0.03704101f, -0.05607196f, -0.12452033f, 0.05819092f, 0.02049131f, 0.00349920f, -0.10741790f, 0.09841117f, 
    -0.08929840f, 0.03973379f, -0.00995107f, -0.08613756f, -0.04570710f, -0.09573007f, 0.01916042f, 0.04694452f, 
    -0.02340466f, 0.03474409f, 0.12691553f, -0.05671901f, -0.07848649f, 0.02993286f, 0.02461871f, -0.06619857f, 
    0.03207309f, 0.02999340f, -0.12836875f, -0.18320847f, 0.02843019f, -0.01619572f, -0.05892637f, -0.16682377f, 
    -0.03434195f, -0.13172324f, -0.17058592f, 0.20138520f, 0.55267447f, 0.13257034f, -0.05359046f, 0.02899177f, 
    -0.10060684f, -0.11377662f, -0.03385557f, 0.02976225f, -0.05323376f, -0.02967373f, -0.19156158f, -0.23857714f, 
    0.12794206f, -0.03853800f, 0.11109696f, -0.16282839f, 0.15109937f, -0.12105002f, -0.01862548f, -0.15923734f, 
    -0.00388723f, -0.10712412f, -0.21723330f, 0.05651567f, -0.21796833f, 0.03173808f, 0.03901939f, 0.26875317f, 
    0.04014810f, -0.08627572f, 0.11150296f, -0.06924641f, 0.23983061f, 0.19266698f, 0.16027775f, 0.29197252f, 
    -0.01532854f, -0.23372844f, -0.15405630f, 0.06577608f, 0.10837793f, 0.18615580f, 0.13663392f, 0.05603043f, 
    -0.04823585f, 0.09927742f, 0.06859221f, -0.07758980f, 0.33137092f, -0.08305514f, -0.06244606f, 0.20185800f, 
    -0.09450563f, 0.08955362f, 0.00992204f, 0.10666055f, 0.13127145f, 0.06840368f, 0.21106631f, 0.33249283f, 
    0.08624151f, 0.05382330f, -0.16757143f, -0.14000243f, 0.22216634f, 0.10671654f, 0.02334813f, -0.25876039f, 
    -0.26344755f, -0.17378446f, -0.11093466f, -0.08825698f, -0.14552896f, -0.11344562f, 0.02405758f, 0.01365018f, 
    0.03151783f, 0.21980603f, -0.21481812f, -0.31180266f, -0.17682746f, -0.35979584f, -0.00950230f, 0.06983973f, 
    0.13857868f, 0.23180339f, 0.25007007f, 0.31702268f, 0.00434985f, 0.11776463f, -0.15998751f, 0.12055826f, 
    0.13479564f, 0.17803536f, 0.08612967f, 0.03339621f, -0.18313755f, 0.25274426f, 0.28200063f, 0.18160369f, 
    0.15928394f, -0.01174277f, -0.03926628f, -0.10597993f, 0.06142647f, -0.14995392f, -0.06916194f, 0.11527891f, 
    0.21308380f, -0.01982770f, 0.10759896f, 0.19656739f, 0.09069981f, -0.01626807f, 0.19500823f, -0.14012860f, 
    0.07287051f, 0.09007152f, 0.11126334f, 0.23517092f, 0.08635961f, 0.20388165f, 0.00765622f, 0.36059856f, 
    -0.11388326f, 0.17231306f, 0.11038135f, 0.07597473f, -0.00393715f, -0.18981557f, -0.13166499f, 0.06755175f, 
    0.03444689f, 0.33647928f, 0.30418169f, 0.49045599f, -0.11224873f, 0.32438552f, 0.02547407f, 0.06100726f, 
    -0.12475565f, -0.01054058f, 0.04625455f, -0.28130984f, -0.00317552f, 0.05660306f, 0.00279110f, 0.00318702f, 
    0.06317447f, 0.03814034f, -0.06971544f, -0.17266953f, -0.17132556f, -0.14910927f, -0.19088371f, -0.16272856f, 
    0.05467777f, -0.13353258f, 0.03351085f, -0.03223834f, -0.23579098f, -0.01584337f, -0.12611677f, -0.30194247f, 
    -0.07401621f, -0.08497399f, 0.23225957f, 0.00336091f, -0.02230058f, -0.04974282f, -0.05917101f, -0.12328032f, 
    0.03307129f, -0.07564060f, -0.18455066f, -0.02658726f, -0.22114366f, -0.13175182f, -0.29892868f, -0.46226308f, 
    -0.02590765f, -0.07447124f, 0.10153519f, 0.11029212f, 0.10830289f, 0.09322409f, 0.19275050f, 0.12539740f, 
    0.14374325f, 0.08109000f, 0.11561450f, -0.04670765f, -0.04353841f, 0.08989019f, 0.05219639f, -0.09114905f, 
    0.33803087f, 0.05761866f, -0.22830729f, -0.28980222f, -0.43223685f, -0.24735054f, -0.14872044f, -0.51580030f, 
    0.36242855f, 0.18031652f, -0.02552392f, 0.21501574f, -0.02070258f, -0.00764624f, 0.07329173f, 0.11429367f, 
    0.15452984f, -0.09381510f, 0.10901091f, 0.11639102f, -0.12147769f, -0.35352513f, -0.23496263f, 0.00620312f, 
    0.05787745f, 0.12820147f, 0.05503269f, -0.15135409f, 0.31144792f, 0.22559768f, 0.25467560f, 0.46658653f, 
    0.21180113f, 0.35172692f, 0.32682911f, 0.22860402f, 0.02980785f, -0.03542273f, 0.00005967f, -0.17239565f, 
    -0.14778677f, -0.02058494f, 0.05497050f, 0.33601671f, 0.29645973f, 0.08369930f, -0.00411063f, 0.18694344f, 
    0.15157281f, -0.01975960f, 0.09436488f, 0.09404784f, 0.12454601f, -0.01734365f, -0.09102526f, -0.19242996f, 
    -0.08815321f, -0.11284172f, 0.01840740f, 0.06207645f, 0.07702737f, -0.07897927f, -0.10287248f, 0.15994379f, 
    -0.06160721f, 0.22353967f, 0.34122759f, -0.02324731f, -0.33094352f, -0.00259891f, 0.07940978f, -0.03947847f, 
    0.16734044f, -0.11701375f, 0.01937540f, 0.09804875f, 0.01091735f, 0.41865546f, 0.01803309f, 0.15582362f, 
    0.22767241f, 0.19273235f, -0.31444350f, 0.16950282f, 0.20609264f, -0.04177056f, -0.07682893f, -0.09705335f, 
    -0.02088439f, -0.11060848f, -0.05871427f, -0.17289288f, -0.07277853f, 0.26664960f, 0.02442632f, 0.10113160f, 
    0.09368721f, 0.10823826f, 0.03689643f, 0.06693044f, 0.00876873f, 0.03973065f, 0.08916851f, -0.19974002f, 
    -0.18575083f, 0.08932293f, 0.23660001f, -0.19533530f, -0.11743341f, -0.15190119f, -0.26562202f, -0.29666030f, 
    -0.03442229f, -0.24910080f, -0.21031024f, -0.12539060f, -0.42835048f, -0.15634140f, 0.46629894f, 0.22723506f, 
    -0.19275470f, -0.11219492f, -0.06021776f, -0.03154436f, 0.00026323f, -0.17647040f, 0.00148953f, 0.06332074f, 
    0.08085099f, -0.04784776f, -0.19286112f, -0.02986518f, 0.16198480f, -0.02385639f, -0.01521931f, 0.16039178f, 
    0.04775392f, 0.03807574f, 0.01649646f, 0.12996683f, 0.24294756f, 0.10422201f, -0.15328881f, -0.02352231f, 
    -0.01877125f, -0.04697630f, 0.04237464f, -0.07240199f, -0.08004013f, -0.11212507f, 0.01157159f, 0.03924531f, 
    0.19922437f, -0.08941136f, 0.04356164f, 0.11615571f, 0.07944904f, -0.03352732f, 0.10370766f, -0.03353118f, 
    0.16090657f, 0.03715901f, 0.14198755f, -0.06373827f, 0.12825345f, 0.35772863f, 0.16908322f, -0.04108332f, 
    0.21654563f, 0.11894820f, 0.15486394f, 0.15497293f, 0.10195216f, -0.00216174f, 0.05989941f, -0.14568321f, 
    0.05047695f, 0.19528948f, -0.23932207f, 0.04494257f, 0.05983206f, 0.01121778f, 0.14906467f, 0.13276333f, 
    0.17648862f, 0.08229593f, -0.04099727f, 0.07610324f, -0.01344294f, 0.39303562f, 0.12418821f, 0.28883123f, 
    -0.13750139f, -0.11766694f, 0.04163146f, 0.05951778f, 0.00872048f, 0.05056495f, -0.00467207f, 0.01269560f, 
    -0.01230044f, -0.21018368f, -0.10551598f, 0.17301175f, -0.00306856f, 0.05920102f, 0.13825473f, 0.14533022f, 
    0.01275109f, -0.06892089f, 0.01858498f, -0.04815625f, -0.08966254f, 0.31306463f, 0.22429231f, -0.11795978f, 
    -0.17761984f, 0.07774297f, 0.00305828f, 0.01593127f, 0.13636813f, 0.05145559f, 0.12882575f, 0.14109296f, 
    0.17415527f, 0.00875814f, -0.04357015f, -0.09996810f, -0.08476067f, 0.00841366f, -0.07999439f, 0.04110011f, 
    0.14933936f, 0.09061972f, -0.06899714f, -0.03633734f, 0.17769542f, 0.12331283f, -0.14518315f, -0.15508334f, 
    0.12811604f, 0.05041017f, 0.05400382f, 0.08634796f, 0.14702816f, 0.18916588f, 0.06192352f, 0.03453113f, 
    -0.00238512f, 0.02846902f, -0.24525997f, -0.02479396f, 0.22217570f, -0.09146831f, 0.28001910f, 0.04165318f, 
    -0.02475271f, 0.00068690f, 0.17803912f, -0.03033907f, 0.37163448f, -0.03558823f, 0.21489766f, 0.00010857f, 
    -0.06967723f, -0.00920266f, -0.00986014f, -0.05086601f, 0.04748143f, 0.07895908f, 0.04570534f, -0.04709350f, 
    -0.13956723f, -0.34329745f, -0.08578508f, 0.13376310f, -0.09367610f, 0.04687031f, -0.04928107f, -0.02092597f, 
    -0.03033674f, 0.10124771f, 0.10537664f, 0.11956169f, 0.28540000f, 0.05762599f, -0.25090194f, -0.08000655f, 
    -0.06641951f, -0.05131796f, 0.04422905f, -0.03817949f, 0.00023757f, -0.00987570f, -0.04976007f, 0.04480511f, 
    -0.43996161f, 0.30501139f, 0.14603998f, 0.30436075f, -0.18875571f, -0.08906612f, 0.06504312f, 0.10272478f, 
    -0.03514308f, 0.04002999f, 0.06037278f, -0.00344698f, -0.16450547f, 0.17414148f, 0.15742810f, 0.02126561f, 
    -0.03032134f, 0.09015557f, 0.10035980f, -0.23734279f, 0.06033916f, -0.11692484f, 0.04465222f, 0.03692188f, 
    0.32539403f, -0.10059675f, 0.13728598f, -0.49757284f, 0.24842808f, -0.06850562f, -0.20729470f, -0.01221049f, 
    -0.05288915f, -0.10327236f, 0.08208241f, 0.10478601f, -0.12892330f, 0.08282570f, 0.04713476f, 0.08161578f, 
    0.00420165f, 0.00092153f, -0.06551512f, 0.09232982f, -0.08199643f, -0.04665491f, -0.18910642f, -0.05728006f, 
    -0.02748040f, -0.33109254f, -0.23643856f, 0.21169275f, 0.15236448f, -0.02902531f, -0.00382597f, 0.08925669f, 
    0.06400336f, 0.21616791f, 0.19677125f, -0.02132811f, 0.03231164f, -0.11578998f, 0.07396441f, 0.17078264f, 
    0.09344990f, 0.16184458f, 0.00173607f, 0.19999890f, 0.04054452f, -0.02321409f, 0.10227584f, -0.14321403f, 
    -0.13280544f, -0.04158704f, 0.23502666f, -0.03268716f, -0.22985077f, 0.02666838f, 0.00805702f, -0.10924996f, 
    0.08690167f, -0.03419434f, -0.01563513f, 0.04543073f, -0.08554380f, 0.00223001f, -0.11650661f, 0.07799315f, 
    -0.01493056f, -0.01074275f, 0.00019052f, 0.02151381f, 0.00172807f, -0.03443994f, -0.07058055f, -0.17145205f, 
    -0.17271715f, -0.04429053f, 0.44424862f, -0.16808011f, -0.23213214f, -0.17215355f, -0.02956294f, 0.08651227f, 
    -0.10747229f, 0.12518544f, -0.14969392f, -0.06944439f, -0.03444109f, -0.11833958f, -0.18611306f, -0.16099933f, 
    -0.03124934f, -0.02855655f, -0.14027125f, -0.08953355f, 0.18519257f, 0.06524029f, 0.10333800f, 0.00738696f, 
    -0.17311923f, 0.03186161f, -0.13982029f, -0.07762410f, 0.08885399f, -0.11094449f, 0.01327449f, -0.00624532f, 
    0.01945925f, 0.03796368f, 0.14787522f, 0.09604319f, -0.33512527f, 0.08278677f, 0.14513913f, -0.05945233f, 
    0.07871393f, 0.05228684f, -0.00178252f, 0.09913367f, 0.00918080f, -0.04235650f, -0.02432863f, -0.13149071f, 
    0.27496180f, 0.14358415f, -0.13222915f, -0.17829731f, 0.03742710f, 0.02715807f, 0.14889380f, -0.03863632f, 
    -0.06972235f, -0.07276867f, 0.28290159f, 0.14167647f, -0.02796010f, -0.20313114f, -0.15426496f, -0.29749155f, 
    -0.13148984f, -0.01082272f, -0.01899455f, -0.04489780f, -0.05947519f, -0.02236480f, 0.06813173f, 0.06348509f, 
    0.11238900f, 0.11423327f, 0.27757487f, -0.08143657f, 0.12140429f, 0.06004391f, -0.27660871f, 0.21607286f, 
    -0.02780993f, 0.12308761f, 0.03213658f, -0.01169921f, 0.28700614f, -0.07340058f, 0.23750913f, -0.23600456f, 
    0.11050227f, -0.01516201f, -0.04324502f, 0.15196225f, 0.02881344f, 0.02851027f, 0.06923250f, -0.02193809f, 
    0.01336265f, 0.00783330f, 0.02984887f, -0.01717151f, -0.04446605f, -0.04235733f, 0.03904086f, 0.03444754f, 
    -0.03785343f, -0.01885791f, -0.03410474f, -0.00126185f, 0.02400330f, 0.00129898f, -0.02544875f, -0.03684465f, 
    0.00881409f, 0.00417024f, -0.02295742f, 0.02933136f, -0.04928415f, -0.03644346f, 0.02822583f, 0.02219436f, 
    -0.01989250f, 0.00855802f, -0.04113800f, 0.04148003f, -0.05507069f, 0.02328520f, -0.03768574f, 0.02857001f, 
    0.03065623f, -0.00071913f, -0.01030657f, -0.04306750f, -0.01256339f, 0.01552269f, -0.01075760f, -0.03881897f, 
    0.04097039f, 0.02942047f, 0.01852910f, -0.03676527f, 0.01128775f, 0.02079162f, 0.04255083f, 0.00599620f, 
    0.04395354f, 0.00162813f, -0.02748570f, -0.00458503f, -0.03370345f, -0.01706473f, 0.02976130f, -0.03882686f, 
    -0.00788393f, -0.04029873f, -0.03344887f, 0.01130483f, 0.00729551f, -0.04977343f, -0.00543998f, -0.03954731f, 
    0.02615448f, -0.00405812f, -0.01756382f, 0.04172070f, 0.04490422f, 0.02710037f, -0.03922976f, -0.02136170f, 
    -0.04903929f, 0.02221248f, -0.05026982f, -0.03218383f, -0.03097546f, 0.04325718f, -0.04012087f, -0.02302516f, 
    0.02986209f, -0.05143244f, 0.01827563f, -0.01733095f, -0.04944794f, 0.01454500f, -0.03466276f, -0.03637728f, 
    0.02809275f, -0.03910649f, -0.04174452f, -0.00774506f, -0.05061338f, -0.01869460f, 0.04547294f, 0.04679916f, 
    -0.05332146f, 0.00793257f, -0.01822215f, 0.03320261f, -0.01301457f, -0.02258888f, -0.05492432f, -0.00682926f, 
    -0.04410627f, 0.00735294f, -0.04477479f, -0.00999082f, -0.03953891f, -0.00533321f, -0.00960590f, 0.01577166f, 
    -0.01818705f, -0.01398269f, -0.05142270f, 0.01191291f, -0.03688014f, -0.02145753f, -0.04753859f, -0.05169423f, 
    0.02163895f, 0.00301613f, -0.02196557f, -0.02841998f, -0.00006138f, -0.04491265f, -0.00479757f, 0.01279428f, 
    -0.03714643f, -0.00166729f, 0.01930443f, 0.04150809f, 0.00050343f, 0.02296909f, -0.04327996f, -0.01411355f, 
    -0.02864418f, -0.04078240f, 0.03613789f, 0.04494303f, -0.01758894f, 0.00345443f, 0.02914780f, -0.03239046f, 
    -0.01149623f, 0.04825383f, -0.04290923f, -0.04797277f, 0.00721385f, -0.03625804f, -0.01547069f, -0.03843429f, 
    -0.00027153f, 0.00820364f, 0.02223521f, 0.04408396f, 0.00707911f, -0.01508068f, 0.00586054f, 0.00477086f, 
    0.01936946f, -0.00542478f, 0.03012749f, -0.05292443f, -0.02998881f, 0.01370309f, 0.01788615f, -0.01105802f, 
    -0.00107722f, 0.04144668f, 0.02689443f, -0.03966882f, -0.00194656f, -0.03795441f, -0.00334751f, 0.01702438f, 
    0.02543684f, 0.02429048f, 0.03309504f, -0.03379493f, 0.01069418f, 0.05407998f, -0.05128811f, -0.01535348f, 
    -0.02275479f, -0.03829197f, -0.04322623f, -0.00910227f, -0.01712348f, -0.01304811f, -0.05507981f, -0.00986612f, 
    0.01963763f, -0.00662794f, -0.02926235f, -0.05566992f, -0.03661594f, -0.04255518f, -0.00379486f, -0.03187695f, 
    0.01134660f, 0.03452671f, -0.02701298f, -0.02807338f, 0.01919898f, -0.01736304f, -0.04591842f, 0.04411175f, 
    0.04161735f, 0.01712200f, 0.04277446f, -0.04132424f, 0.01442614f, 0.02658714f, 0.04455043f, -0.02942184f, 
    -0.05335923f, 0.04437555f, 0.01455187f, 0.00512025f, -0.01374225f, 0.00259764f, 0.01795562f, -0.04133873f, 
    0.03551744f, 0.03910743f, 0.01237999f, -0.00353391f, -0.00627151f, -0.02331521f, -0.04123671f, 0.02965925f, 
    0.00338797f, -0.01099016f, -0.02743393f, -0.04481355f, 0.03149979f, -0.03866500f, -0.01066384f, 0.03431749f, 
    0.01070916f, 0.02883136f, -0.04390033f, 0.00141779f, 0.01883964f, -0.01964163f, 0.03641760f, 0.01921701f, 
    -0.00155631f, -0.01610063f, -0.03994259f, -0.01737909f, -0.03044665f, 0.02356221f, -0.05029800f, -0.05102043f, 
    0.02303033f, -0.01094988f, 0.04401851f, -0.05228259f, -0.04269785f, 0.02463661f, -0.05460060f, -0.04536065f, 
    0.00237010f, 0.01032607f, -0.04282046f, 0.01739962f, -0.00871229f, -0.05215975f, 0.03211045f, -0.01181636f, 
    -0.01110271f, 0.01381779f, -0.04598839f, 0.03990129f, 0.00191449f, 0.01989180f, 0.02433883f, -0.01547118f, 
    0.01797714f, -0.01992410f, -0.02185338f, -0.03641352f, -0.03203030f, -0.01750402f, 0.01313614f, 0.01493687f, 
    0.03688502f, 0.04557509f, -0.03151684f, 0.01417555f, 0.02611504f, 0.00805065f, -0.04249918f, -0.01411621f, 
    0.03691739f, -0.01978783f, -0.03019741f, 0.00017783f, 0.02295480f, 0.01745975f, 0.01508692f, 0.04725510f, 
    0.00806120f, -0.04698722f, -0.01765488f, -0.01827547f, 0.01524139f, 0.01334992f, 0.01384684f, -0.02568311f, 
    -0.01595332f, -0.05188410f, 0.02494519f, -0.04431791f, 0.00703958f, -0.03011341f, 0.03388014f, -0.01616609f, 
    -0.03660399f, -0.02274804f, -0.00191817f, -0.02910343f, -0.05612365f, 0.00150536f, 0.02565285f, -0.00518949f, 
    0.01898983f, -0.04055584f, -0.03594832f, -0.00321761f, -0.04029433f, -0.02206366f, -0.04031712f, 0.04321362f, 
    0.01315509f, 0.00564201f, 0.03594080f, 0.00243026f, -0.00181529f, -0.00403317f, 0.03376359f, 0.01415206f, 
    0.00129756f, 0.03563531f, -0.01827102f, -0.00536784f, -0.01276303f, 0.02041146f, 0.00676377f, -0.04469547f, 
    -0.05082889f, -0.04423132f, 0.02010379f, 0.00601202f, -0.00638101f, 0.04395169f, 0.02942766f, -0.02305472f, 
    -0.04367897f, 0.01235681f, 0.01848599f, -0.03309598f, 0.03716711f, 0.03315797f, -0.05336278f, -0.02889865f, 
    -0.01578649f, 0.02047204f, 0.03383662f, -0.00103500f, -0.04199963f, -0.02859916f, 0.01168199f, 0.02580002f, 
    0.00144613f, -0.02634699f, -0.01033517f, 0.01691008f, 0.02595825f, 0.03335511f, -0.01824626f, -0.00376751f, 
    -0.03675712f, -0.03154652f, -0.01329447f, -0.04976150f, -0.01902894f, -0.00405508f, -0.03789205f, 0.02555908f, 
    0.01134743f, -0.01242354f, 0.04323411f, -0.02733458f, -0.03130044f, -0.03003777f, -0.03131924f, 0.03980535f, 
    -0.03089744f, -0.02104040f, -0.01606114f, -0.02342993f, -0.02650478f, -0.02856732f, 0.02016244f, -0.00587409f, 
    -0.04586209f, -0.03954098f, 0.03062602f, 0.03645509f, -0.04093756f, 0.00019817f, 0.03453867f, 0.02252341f, 
    -0.00103639f, 0.04544898f, -0.00453858f, 0.03608234f, 0.02627288f, -0.03328517f, -0.00860273f, -0.03590487f, 
    0.00595361f, 0.00329489f, 0.03741446f, -0.00505749f, 0.01293117f, -0.02206055f, -0.00722351f, 0.02182218f, 
    0.03380519f, 0.00409878f, -0.02162642f, 0.01462623f, -0.03600661f, -0.00346186f, 0.00571681f, -0.03717982f, 
    -0.05529963f, 0.03183285f, -0.02087030f, -0.02890616f, 0.00633166f, -0.05022933f, -0.03070669f, -0.05355606f, 
    0.01581155f, 0.00773648f, -0.01101438f, -0.04936913f, 0.04471596f, -0.05440054f, -0.05175355f, 0.00382219f, 
    0.01041362f, -0.01439129f, -0.04471565f, -0.02761704f, -0.02156032f, -0.02004106f, -0.05281902f, -0.04983861f, 
    0.03329506f, -0.04926844f, -0.01773398f, -0.04575266f, -0.03331965f, -0.00952982f, -0.03300836f, 0.01707916f, 
    -0.04671341f, 0.00009471f, -0.03784256f, 0.03100879f, 0.04132212f, -0.04065917f, -0.02622781f, 0.00880690f, 
    -0.05445285f, -0.02787342f, -0.00793593f, -0.05137866f, -0.00431484f, -0.05324804f, 0.04322378f, -0.00932753f, 
    0.03322338f, -0.00712166f, 0.02874653f, 0.03356769f, 0.01471465f, 0.02004899f, 0.00156694f, 0.03106279f, 
    -0.00625536f, -0.01042750f, 0.01595078f, -0.05029338f, -0.04192210f, 0.02889045f, 0.04261846f, -0.03658589f, 
    -0.04109809f, 0.03123116f, 0.00084638f, -0.03015632f, 0.01762965f, 0.01220930f, -0.05387565f, -0.04619893f, 
    0.01453874f, -0.02910096f, -0.01926602f, 0.02471682f, -0.04262359f, -0.05651812f, -0.04475919f, 0.01399109f, 
    0.00552743f, -0.05603874f, -0.05138269f, -0.01728643f, -0.01508185f, -0.02772587f, -0.01610710f, -0.02245625f, 
    0.02514805f, 0.02961343f, 0.02034513f, -0.04473383f, -0.04393645f, 0.03217379f, 0.02313595f, -0.01434275f, 
    0.02252942f, -0.04768099f, 0.03357320f, -0.00774578f, -0.04110277f, 0.02122133f, 0.00760074f, -0.01524413f, 
    -0.00175427f, -0.00587938f, -0.00478672f, 0.03082161f, -0.01179976f, -0.01940959f, 0.04229251f, -0.03995833f, 
    -0.05471380f, 0.00419919f, -0.02615770f, 0.02581228f, 0.04086343f, 0.02355682f, 0.02675524f, -0.00048338f, 
    -0.01014593f, -0.03493064f, 0.04874551f, -0.03138556f, 0.03491595f, -0.02513879f, -0.04962869f, -0.04329504f, 
    -0.02069865f, 0.03928028f, -0.00595737f, -0.04873460f, 0.03869013f, -0.01729061f, 0.03396276f, -0.05499952f, 
    -0.00548682f, 0.01250786f, 0.00026400f, -0.00918425f, 0.04270703f, -0.01955012f, 0.03469121f, -0.03113118f, 
    -0.01925163f, -0.05160493f, -0.00890205f, -0.02492398f, -0.01810338f, 0.04171969f, -0.02733459f, -0.05108645f, 
    0.02272414f, -0.05360216f, -0.01784338f, 0.02903456f, 0.00494960f, -0.02074708f, -0.00145622f, -0.04004579f, 
    0.03068235f, -0.01602967f, 0.01303955f, 0.03625008f, -0.04622532f, 0.01124122f, -0.03183295f, -0.00707602f, 
    0.02810431f, -0.02845068f, 0.02945691f, 0.04516564f, -0.04529148f, -0.04316619f, -0.04289609f, -0.01403383f, 
    0.02593165f, 0.00030050f, -0.04220944f, -0.04269263f, -0.03747616f, 0.02590554f, -0.04061393f, 0.01295186f, 
    -0.02503319f, 0.02769517f, -0.00553656f, 0.04126603f, -0.01001073f, 0.03724374f, -0.03622093f, -0.01654021f, 
    -0.02177287f, -0.01263125f, -0.03766332f, 0.01233120f, 0.00597057f, -0.03949126f, 0.02091862f, -0.01037779f, 
    -0.01499897f, 0.04363761f, -0.01652630f, 0.00349622f, 0.01295018f, -0.01393355f, 0.04327203f, 0.00878249f, 
    -0.02474463f, 0.04834261f, -0.01986011f, 0.04442484f, 0.01600320f, -0.02830390f, 0.00204275f, -0.04267005f, 
    0.01539282f, 0.03843661f, -0.05037178f, -0.02882178f, 0.02863318f, 0.03167127f, 0.04198886f, 0.03314070f, 
    -0.02618890f, -0.05632535f, -0.01996952f, -0.01130454f, -0.00938991f, 0.03602232f, -0.02246739f, -0.04534423f, 
    -0.00702825f, -0.00576443f, -0.01666259f, 0.01183976f, -0.00691283f, -0.00613006f, 0.02596561f, 0.03953550f, 
    -0.01880324f, -0.00843203f, -0.00031679f, -0.01564563f, 0.04834702f, -0.02427014f, 0.01630680f, 0.04022885f, 
    -0.02083227f, 0.00608170f, 0.00625898f, -0.03091681f, -0.00906936f, -0.05310815f, -0.01824043f, -0.02532800f, 
    0.03445042f, -0.05605314f, -0.03751606f, -0.02974300f, 0.01408389f, 0.02898708f, -0.01321960f, -0.03911383f, 
    -0.02111888f, 0.03075089f, 0.00725804f, -0.04192184f, 0.02127854f, -0.02436967f, -0.04649264f, 0.01583018f, 
    0.03851967f, 0.03010549f, 0.02964178f, -0.03942404f, -0.01744357f, -0.00593211f, -0.02891732f, 0.02067908f, 
    0.01454080f, 0.00612100f, 0.02448855f, 0.00960655f, -0.03295567f, -0.02158836f, 0.03392153f, 0.02971166f, 
    0.03336423f, -0.04093528f, -0.01683577f, 0.03425422f, -0.03431233f, -0.00522682f, 0.04969433f, -0.05099585f, 
    0.00324344f, -0.03297012f, -0.02433605f, -0.04839230f, -0.02077736f, -0.00681433f, -0.04186291f, -0.04718981f, 
    0.01082917f, -0.04234590f, 0.00984349f, -0.01428442f, -0.04052380f, 0.03804060f, -0.00014812f, -0.04482448f, 
    -0.01260254f, 0.02668888f, -0.03708808f, -0.00163022f, -0.01323210f, 0.01706854f, -0.02288204f, 0.01382111f, 
    -0.04856566f, -0.01404084f, 0.03626388f, 0.00378335f, -0.03719393f, -0.04034209f, -0.03690059f, 0.00674935f, 
    -0.41754109f, -0.36376855f, 0.05798196f, 0.08740338f, -0.08497529f, 0.08072796f, -0.03854831f, -0.02244765f, 
    -0.00163638f, -0.01259898f, 0.08362773f, 0.02802274f, -0.26046437f, -0.24312007f, 0.00099580f, 0.11514749f, 
    0.03029641f, 0.00645419f, 0.03111395f, 0.11926249f, 0.07804539f, 0.03312310f, -0.03292556f, -0.07773243f, 
    -0.03482318f, -0.04739471f, 0.03963272f, -0.24920253f, 0.06180704f, 0.10727825f, 0.07512258f, 0.04530214f, 
    0.09530688f, -0.01277357f, -0.08091246f, 0.07825588f, -0.11632453f, -0.05163969f, -0.02477731f, 0.00276108f, 
    -0.11373231f, 0.01677720f, 0.12997057f, -0.07198130f, 0.10413879f, -0.02248365f, -0.07216988f, 0.10164860f, 
    0.19223778f, 0.37597284f, -0.05627083f, -0.17468813f, 0.00035723f, 0.01748429f, -0.06912664f, -0.10704634f, 
    0.16791616f, 0.17999816f, 0.03815512f, -0.03504326f, 0.10020769f, 0.33890453f, -0.04097445f, 0.27351037f, 
    0.21950124f, -0.10448247f, 0.02661796f, 0.04296988f, 0.13378365f, 0.23768091f, 0.01489115f, 0.07941303f, 
    0.07429431f, -0.22439164f, 0.16052714f, -0.16530950f, -0.07786150f, 0.04298411f, -0.03835417f, -0.10997808f, 
    -0.01773459f, 0.05001955f, -0.04954001f, 0.02066120f, -0.04054070f, 0.16164182f, 0.01518308f, 0.12669212f, 
    -0.03097853f, -0.00469176f, -0.05884065f, -0.19332530f, 0.14989807f, -0.03826438f, 0.11620011f, 0.07308047f, 
    -0.16982754f, -0.01406447f, -0.16637804f, 0.29042819f, 0.01658345f, 0.04500689f, 0.06429420f, 0.11127720f, 
    -0.02543452f, 0.03493519f, -0.00743788f, 0.17351955f, -0.17319502f, 0.10621630f, 0.20269673f, 0.10311688f, 
    -0.05635225f, 0.04541553f, 0.08415242f, 0.05790711f, -0.09838475f, -0.07707997f, -0.13921885f, -0.07886969f, 
    -0.23106371f, 0.06539859f, 0.04820563f, -0.15585779f, -0.20092277f, -0.16199565f, 0.04595627f, -0.10434067f, 
    -0.08350707f, -0.06706117f, -0.02487123f, -0.12432633f, 0.02369835f, -0.11624666f, -0.06931502f, 0.06101460f, 
    0.00949171f, 0.03782808f, 0.13029978f, 0.05537021f, -0.00723104f, 0.06115888f, -0.10569212f, 0.04827737f, 
    0.08434499f, -0.05668315f, 0.15017648f, -0.10940737f, -0.09088781f, 0.14027399f, -0.12169547f, 0.05777196f, 
    0.13333534f, 0.12444398f, 0.22420484f, 0.02339942f, 0.07281403f, 0.28875181f, 0.25509956f, -0.12772813f, 
    -0.07750024f, -0.12447746f, 0.02234398f, -0.03359849f, 0.02029610f, 0.02286620f, 0.02822278f, 0.00739647f, 
    -0.25101632f, -0.25893906f, -0.26649559f, -0.01893938f, -0.00777775f, 0.14433098f, 0.11844597f, 0.05545513f, 
    0.01287477f, -0.04099192f, -0.08369981f, 0.11114917f, 0.04702803f, 0.00462695f, 0.02654355f, 0.12281362f, 
    -0.07226579f, 0.06059091f, -0.08410423f, -0.06482053f, -0.03366016f, 0.02431739f, 0.05695993f, -0.05509595f, 
    0.64054400f, 0.01995913f, 0.30103979f, 0.06755129f, 0.00789552f, -0.02042463f, -0.08066002f, -0.08440270f, 
    -0.07518914f, 0.09248422f, -0.07162026f, 0.00892095f, -0.21588810f, -0.12610278f, 0.08018361f, 0.13297732f, 
    0.14503960f, -0.01553125f, 0.03659708f, 0.04117755f, 0.07952671f, -0.00833164f, 0.01166346f, -0.00753914f, 
    -0.19458757f, -0.14223690f, 0.11385339f, -0.12510550f, 0.19629513f, -0.05037576f, 0.02235895f, -0.09531585f, 
    0.04766086f, -0.10180987f, -0.05414635f, 0.01830251f, 0.05727567f, 0.05219509f, 0.24030115f, 0.06363003f, 
    0.16852805f, -0.16176718f, 0.09871142f, 0.05688039f, 0.07648405f, 0.27251065f, 0.01287866f, 0.13986140f, 
    0.30320799f, 0.37632033f, -0.17476663f, -0.11223856f, -0.19191818f, -0.04804384f, 0.03774371f, 0.01680576f, 
    0.03849424f, 0.01283595f, 0.10320985f, 0.09185127f, -0.00355318f, -0.03412853f, -0.08313368f, -0.06174332f, 
    0.03377767f, -0.04355789f, 0.07832463f, 0.15771472f, 0.06702086f, 0.18994804f, 0.06794468f, 0.05084484f, 
    -0.38107914f, -0.20424539f, -0.20987767f, 0.08565892f, -0.14914116f, -0.05563274f, -0.11604883f, -0.05603962f, 
    0.01549605f, 0.05082908f, -0.01435027f, 0.02851829f, -0.10360279f, 0.05177229f, -0.15250382f, -0.04954874f, 
    -0.09795019f, 0.09539078f, 0.10920797f, 0.13091817f, 0.06170981f, 0.05830704f, 0.04299153f, 0.04882300f, 
    -0.34333932f, -0.08408145f, 0.16722250f, 0.10401467f, 0.02865510f, 0.01325824f, 0.10699984f, 0.03939408f, 
    0.06386840f, 0.12818091f, 0.14798817f, 0.02238203f, -0.05855398f, 0.05769662f, -0.01194090f, -0.15155478f, 
    -0.14991856f, -0.18230057f, -0.04114340f, -0.07926808f, -0.06757160f, -0.04649064f, 0.07376311f, -0.18198240f, 
    -0.03999518f, -0.10938697f, -0.00559634f, 0.05757790f, -0.00301905f, 0.09901195f, 0.03505972f, 0.03417968f, 
    0.04255848f, 0.05684417f, 0.04984895f, -0.15438659f, 0.04211598f, -0.09296668f, 0.06997682f, 0.06392336f, 
    0.03645055f, -0.04695618f, -0.01218692f, 0.05572355f, -0.04314031f, 0.09549573f, 0.09764571f, 0.07247357f, 
    0.13589518f, 0.30760735f, -0.21076781f, -0.08647689f, -0.14200671f, 0.03657214f, 0.03766942f, -0.01958476f, 
    0.15016361f, 0.14331502f, 0.14988984f, -0.07491263f, 0.21850619f, 0.40440464f, 0.06443895f, 0.09525909f, 
    -0.01799539f, -0.08976685f, -0.02280944f, -0.12191969f, -0.06129864f, -0.10699989f, 0.07018571f, 0.13163623f, 
    0.34767023f, -0.13162729f, 0.51555675f, 0.00896623f, 0.02208789f, -0.15470411f, 0.17969237f, 0.05031758f, 
    -0.07320286f, 0.23664035f, 0.07987960f, 0.08436061f, 0.30674282f, 0.11670186f, -0.18751538f, -0.00620782f, 
    0.06709972f, -0.00037431f, 0.08107390f, 0.17652419f, 0.03069256f, 0.05846674f, -0.01105193f, 0.02215293f, 
    -0.01969374f, 0.03186949f, 0.04313691f, -0.04138728f, -0.00611678f, 0.01396268f, -0.02727315f, 0.03247646f, 
    -0.04084638f, -0.00197351f, -0.04792687f, -0.01858104f, -0.04016807f, -0.04277705f, 0.00706308f, -0.05601958f, 
    -0.05268226f, 0.01398942f, 0.02137947f, 0.04155266f, -0.01650401f, -0.02712087f, -0.02121020f, -0.07839587f, 
    -0.05490571f, -0.04622450f, 0.01826255f, -0.03743844f, -0.01911844f, -0.03927265f, 0.02709025f, -0.00671020f, 
    -0.01335330f, -0.00064093f, -0.05617104f, -0.03755895f, 0.03734471f, -0.00567606f, 0.02745312f, -0.04380400f, 
    -0.04543144f, -0.01571721f, -0.05249172f, -0.04936372f, 0.03378319f, -0.05391875f, -0.02235321f, 0.01575958f, 
    -0.05511658f, 0.01762350f, 0.02035205f, -0.01539914f, -0.01753368f, -0.05299623f, -0.03401394f, 0.01063402f, 
    -0.05140439f, -0.05350864f, 0.02636890f, 0.02107594f, -0.02848249f, -0.04707092f, -0.01520345f, 0.01039548f, 
    -0.05035624f, 0.04159114f, 0.03113315f, 0.02057423f, 0.01420424f, 0.00163188f, 0.01835232f, 0.02360004f, 
    -0.06310744f, -0.01709835f, 0.00660528f, -0.00434097f, -0.01335822f, -0.05470532f, 0.02089043f, 0.00903383f, 
    -0.04433079f, 0.00712315f, -0.06058910f, -0.05352715f, -0.01168001f, -0.05870880f, -0.05860287f, -0.01305132f, 
    -0.06363365f, -0.03155306f, -0.02611751f, 0.03206557f, 0.04560561f, 0.01035883f, 0.02946469f, -0.02100192f, 
    -0.00310983f, -0.01563689f, -0.05295438f, -0.05236191f, -0.03807982f, -0.01710035f, -0.00595697f, 0.03508078f, 
    -0.04449225f, -0.03154400f, 0.00471232f, 0.01149960f, -0.02417087f, -0.02638095f, 0.01109758f, 0.03568751f, 
    0.05665505f, -0.01827111f, -0.07797591f, -0.01669640f, 0.04195166f, 0.05253855f, 0.01853597f, -0.03374091f, 
    -0.07012907f, 0.02294815f, -0.01867859f, -0.05184666f, -0.03030276f, 0.01853774f, -0.04828282f, -0.00775252f, 
    -0.03871531f, -0.00951776f, -0.06346441f, 0.03063346f, -0.01806421f, 0.02825685f, -0.01261775f, 0.02208312f, 
    -0.05430380f, -0.01717149f, 0.03610738f, -0.03661207f, 0.00172937f, 0.00267178f, -0.04931761f, -0.02103949f, 
    0.01519930f, 0.00630626f, -0.06551604f, 0.01828369f, -0.02562426f, -0.03545672f, -0.04381507f, -0.03196384f, 
    -0.03785926f, -0.05280124f, -0.00329930f, 0.03694936f, -0.05283951f, 0.00427922f, -0.03199659f, -0.05956118f, 
    -0.05325480f, 0.01618734f, -0.07810267f, 0.01000268f, 0.02124730f, -0.04515100f, -0.00161291f, -0.03857040f, 
    -0.03260188f, -0.00132926f, 0.01437463f, 0.01701768f, -0.03830036f, 0.00465641f, -0.04360051f, 0.02475674f, 
    0.03362496f, 0.02977117f, -0.02402912f, -0.03533027f, -0.01932583f, -0.02991373f, 0.03676868f, -0.00704698f, 
    -0.05827294f, 0.01428365f, -0.06697290f, 0.01872805f, -0.02987696f, -0.06981321f, -0.03078221f, -0.02320286f, 
    -0.01731461f, 0.01673273f, -0.01704138f, 0.02066082f, -0.04898619f, -0.02720725f, -0.05479496f, -0.01937510f, 
    -0.02199310f, -0.04258017f, 0.04615285f, 0.00188568f, -0.02656621f, -0.02249575f, -0.05121976f, -0.00099768f, 
    -0.04085843f, -0.02802395f, -0.00738515f, -0.04211408f, -0.03147110f, -0.05411197f, -0.00980281f, -0.05170325f, 
    -0.06876199f, 0.03935827f, -0.05398211f, -0.03776766f, -0.01120689f, -0.03181973f, 0.03907456f, -0.00404185f, 
    0.02718479f, -0.01457457f, 0.01066430f, -0.03558010f, -0.02915343f, -0.03980716f, 0.02540900f, -0.05683834f, 
    -0.02510287f, -0.00474448f, 0.01315251f, -0.00612934f, 0.02388111f, -0.00186019f, 0.00114442f, 0.00450715f, 
    -0.00258275f, -0.01560378f, -0.03545283f, -0.00931998f, 0.00642359f, -0.02155282f, 0.02043919f, -0.03032094f, 
    -0.03040629f, 0.01535458f, 0.03164409f, -0.04273615f, 0.04165219f, -0.07121794f, 0.00816042f, -0.04915174f, 
    0.00950886f, -0.00032261f, 0.01989531f, -0.03086110f, -0.02106907f, -0.00206876f, -0.01525235f, -0.05450830f, 
    0.03565971f, 0.00170498f, 0.03231136f, -0.03947379f, -0.00618329f, 0.02578557f, -0.01643720f, 0.03102401f, 
    -0.02451908f, -0.03774863f, -0.06790084f, -0.03112812f, 0.02356082f, -0.03613716f, -0.06244255f, -0.00957322f, 
    0.04311020f, 0.02811592f, -0.05073434f, 0.00400272f, 0.00470129f, -0.02401786f, -0.01668139f, -0.00076580f, 
    0.03378830f, -0.05412268f, -0.05184800f, 0.02616984f, 0.03151017f, -0.02975164f, 0.01856373f, 0.00183897f, 
    0.01114297f, -0.02018089f, 0.01793627f, -0.05295994f, -0.01348450f, 0.01917538f, -0.01151683f, -0.03825256f, 
    0.00190406f, -0.05230656f, -0.02086576f, -0.02697802f, -0.00221751f, 0.01853191f, -0.02491799f, 0.00770438f, 
    -0.04145590f, 0.03921289f, 0.03827276f, -0.01788685f, -0.06479969f, -0.05430275f, -0.01936905f, -0.03025262f, 
    0.00914530f, 0.00297794f, -0.04344155f, -0.02529593f, -0.01572480f, -0.05524484f, 0.02793421f, -0.03029450f, 
    0.00152717f, -0.00813896f, 0.02163853f, 0.02664888f, 0.01556987f, -0.04104368f, 0.00173102f, -0.01422306f, 
    0.03054954f, -0.01020026f, -0.02037206f, 0.00842362f, -0.01975855f, -0.04903962f, -0.03929120f, -0.04317750f, 
    -0.04273998f, -0.03842690f, 0.04284820f, 0.00816271f, -0.01517277f, -0.03386690f, 0.01154641f, -0.04428270f, 
    -0.03498444f, -0.02847379f, -0.06086690f, 0.01083992f, 0.03431619f, 0.00187451f, -0.05531612f, -0.02382945f, 
    -0.03988896f, -0.02358781f, -0.05547367f, 0.02990460f, -0.00350744f, 0.01486024f, -0.04130714f, -0.05344302f, 
    -0.04810837f, 0.01954205f, -0.03964337f, 0.02691828f, 0.03838390f, 0.01082327f, -0.02703890f, -0.04152827f, 
    -0.04619596f, 0.03367937f, -0.03824512f, -0.04242711f, -0.01719077f, -0.00190291f, -0.02794721f, 0.02408303f, 
    0.27692068f, 0.28113064f, 0.25079364f, 0.21264206f, 0.05698433f, -0.04476335f, -0.03824756f, 0.08388228f, 
    0.07825045f, -0.09599084f, -0.05362829f, -0.08528797f, -0.20539337f, -0.15133105f, -0.05401329f, 0.17595433f, 
    0.00625902f, 0.09800572f, -0.09725917f, -0.12479635f, -0.10028095f, -0.02624660f, 0.12714516f, 0.11034148f, 
    0.16303582f, -0.13098066f, -0.07868820f, 0.19959375f, -0.00548213f, 0.16695614f, 0.13003835f, 0.11850546f, 
    0.16360554f, 0.16389126f, 0.12409370f, -0.08107652f, 0.13442510f, -0.20860124f, -0.02262235f, -0.06040174f, 
    0.10443819f, 0.19466507f, 0.01630842f, 0.31798592f, -0.13769701f, -0.07036915f, -0.06946463f, -0.20846952f, 
    0.13076057f, -0.09947447f, -0.20231496f, 0.04532041f, -0.08578333f, -0.06317918f, 0.01168698f, 0.14282721f, 
    0.07519522f, 0.06993741f, -0.02550104f, -0.08264719f, 0.11559394f, -0.11891909f, 0.30726090f, -0.16342291f, 
    0.05352074f, -0.00700291f, 0.17717135f, 0.10347960f, 0.03982935f, 0.01241155f, 0.09303582f, -0.06694744f, 
    -0.10348485f, -0.02005740f, -0.33512539f, 0.00558449f, 0.01799910f, -0.04474352f, -0.07556270f, -0.12364603f, 
    0.05967479f, -0.00364385f, -0.09317603f, 0.03577826f, -0.11789862f, 0.20421471f, -0.02604947f, -0.09614010f, 
    -0.04232523f, -0.11239748f, 0.02929350f, 0.10439546f, -0.02092688f, 0.04167463f, -0.04608169f, -0.00291373f, 
    0.01253878f, 0.17205660f, 0.20258763f, -0.05113349f, 0.22040163f, -0.06756027f, 0.14764304f, 0.24583118f, 
    -0.07965759f, 0.00844230f, -0.00880763f, 0.05063891f, 0.08149841f, 0.06035476f, 0.19621843f, 0.06028954f, 
    0.10722378f, -0.11387041f, 0.08961608f, 0.04451463f, 0.15597798f, 0.17725934f, 0.13918287f, 0.08830356f, 
    0.08793379f, -0.20134471f, -0.27669948f, -0.19532536f, -0.06876826f, -0.02011556f, -0.06824463f, 0.09895549f, 
    0.13951688f, 0.14525780f, -0.00511075f, -0.06559307f, 0.18942158f, 0.13719416f, -0.12018357f, 0.07947437f, 
    0.05545015f, 0.05245427f, -0.02778712f, 0.16843264f, 0.18675829f, 0.08749134f, 0.18229873f, 0.25387704f, 
    0.02399122f, 0.11892829f, -0.16692352f, 0.10020075f, 0.22938529f, -0.12921461f, -0.00514254f, -0.02221761f, 
    -0.04329119f, 0.00723173f, -0.08216013f, 0.07324478f, 0.16792697f, -0.17985313f, -0.19159578f, 0.18100560f, 
    -0.19776323f, 0.08029643f, -0.02457765f, -0.07319672f, -0.12489966f, -0.05018494f, -0.00157366f, -0.23044583f, 
    0.10958302f, 0.07367414f, 0.18452565f, 0.28024009f, 0.15247534f, 0.12001688f, 0.01401849f, 0.20603050f, 
    -0.00427563f, 0.05451554f, 0.05478677f, 0.09296764f, 0.06644487f, -0.00555173f, 0.23062393f, 0.08628745f, 
    0.03458007f, -0.04354730f, 0.03106952f, 0.02882306f, 0.04989877f, -0.14840223f, -0.06135956f, 0.07826451f, 
    -0.21327870f, 0.20268452f, 0.02256706f, 0.03686260f, 0.02298173f, -0.17328049f, 0.13112381f, 0.00043612f, 
    -0.06695316f, -0.01917504f, 0.22020113f, 0.17120850f, 0.06154136f, 0.19326329f, 0.03666789f, 0.23082593f, 
    -0.01484589f, 0.00542603f, 0.14184104f, 0.09852129f, 0.00072886f, -0.04674735f, 0.07394631f, 0.05502850f, 
    0.47604343f, 0.23030879f, 0.06998483f, 0.08095304f, -0.06529105f, 0.22857346f, -0.04486315f, 0.11682456f, 
    0.04928111f, 0.15965119f, 0.02718406f, -0.07566923f, 0.18008575f, 0.23045993f, -0.16680253f, -0.06791013f, 
    0.03920773f, -0.02396886f, -0.05455839f, 0.01939923f, -0.16910136f, -0.11965171f, 0.12213518f, 0.02632100f, 
    -0.16981705f, -0.05846356f, -0.20254569f, 0.13231754f, -0.12061007f, 0.03254338f, -0.04054340f, -0.05788608f, 
    0.01712682f, 0.02166433f, -0.00586339f, 0.12045985f, -0.11188711f, -0.01565125f, 0.10703394f, 0.13510661f, 
    0.10177018f, 0.04925615f, -0.11498530f, 0.11730918f, 0.06013716f, -0.01374253f, 0.00364710f, -0.06661949f, 
    -0.03688047f, -0.10400851f, 0.17999896f, 0.04241833f, 0.06214079f, 0.16764909f, 0.12540217f, 0.07877865f, 
    0.08067834f, 0.12918535f, 0.16083904f, 0.06299949f, -0.14911026f, -0.08090229f, 0.05410353f, 0.09151492f, 
    0.19705658f, 0.13819969f, -0.03825744f, 0.02930893f, -0.15933877f, -0.06644129f, -0.17330128f, -0.21584028f, 
    0.30007935f, 0.25756571f, -0.05587630f, 0.20340234f, 0.03059926f, -0.06460607f, 0.06542428f, 0.15983972f, 
    -0.01541851f, -0.02177192f, 0.04113477f, 0.07734505f, -0.04048974f, -0.17518632f, -0.13590217f, -0.07170872f, 
    -0.10631945f, -0.04155765f, -0.06149616f, -0.09268057f, 0.19663353f, 0.19307949f, 0.06163212f, 0.13163091f, 
    0.07062495f, 0.16741829f, 0.27751911f, 0.24960388f, 0.12610047f, 0.04876183f, -0.05491032f, -0.14075078f, 
    -0.03415357f, -0.07128897f, 0.06144971f, 0.25826430f, 0.18746755f, 0.07904598f, 0.15363863f, -0.01861375f, 
    0.02602052f, -0.03091352f, 0.00773588f, 0.17611618f, 0.22716513f, -0.13942961f, -0.02785372f, -0.15410760f, 
    0.00167457f, -0.04363232f, 0.17469931f, -0.03438371f, 0.03223637f, -0.09389872f, -0.03560705f, 0.11492390f, 
    0.06917627f, 0.12434329f, 0.15218353f, 0.16897811f, -0.08101747f, -0.14957646f, 0.09129532f, -0.36660632f, 
    -0.00086536f, 0.00641499f, 0.00487820f, 0.10885839f, 0.07467904f, 0.18382968f, -0.00223605f, 0.13264211f, 
    0.12076058f, -0.02147100f, -0.22186460f, -0.13420643f, 0.25043228f, 0.20370948f, -0.13793784f, 0.19000174f, 
    0.20893078f, -0.06871162f, 0.04337144f, 0.13547248f, 0.29001155f, 0.09370004f, 0.42167577f, -0.08666208f, 
    -0.08590029f, 0.00619216f, 0.08628501f, -0.02226159f, 0.21304113f, 0.03941873f, 0.11371247f, -0.08259595f, 
    0.01261535f, 0.02553720f, 0.00909887f, -0.04561196f, -0.03772923f, -0.05153998f, -0.01005681f, 0.00562361f, 
    -0.01100110f, 0.01170178f, -0.02937528f, -0.00320600f, -0.02746415f, 0.01498829f, 0.04299337f, -0.02028685f, 
    0.00870678f, -0.01450503f, 0.02710593f, 0.00398073f, 0.04544579f, -0.00116633f, 0.00385103f, 0.02155728f, 
    0.00171781f, -0.01771875f, -0.02921927f, -0.05332356f, 0.01853037f, -0.00648454f, -0.01048000f, 0.00915252f, 
    -0.03945463f, -0.01145428f, -0.05281224f, 0.03021355f, 0.04305328f, -0.05774440f, -0.02395419f, -0.00714333f, 
    -0.05701828f, 0.02495310f, -0.01490922f, 0.00768670f, 0.00079208f, 0.04051631f, 0.01726307f, -0.03235038f, 
    -0.04313863f, -0.02581498f, -0.03823412f, 0.02432158f, 0.00495157f, -0.00750507f, -0.01808870f, -0.03117496f, 
    0.02494979f, 0.00895089f, 0.03837819f, 0.00783795f, 0.02149676f, 0.00192629f, -0.00811549f, 0.03182724f, 
    0.01898858f, -0.00832464f, -0.00351598f, -0.04029491f, 0.01331963f, -0.05308414f, -0.00942625f, 0.00588664f, 
    -0.04144672f, -0.02922043f, -0.03470234f, -0.01157281f, 0.00355071f, 0.04138678f, -0.00106806f, -0.04489180f, 
    -0.00721610f, -0.00632001f, -0.00680195f, -0.05794575f, -0.00903230f, -0.04648722f, 0.02647475f, 0.05520840f, 
    -0.00351708f, -0.03362065f, -0.04589977f, 0.03963275f, 0.01414163f, -0.03212398f, 0.01312847f, 0.01240218f, 
    -0.04391560f, 0.03276789f, -0.03328210f, 0.01006125f, -0.04776845f, 0.04214774f, 0.01056823f, -0.01951566f, 
    -0.02703630f, -0.04918852f, -0.05351726f, -0.04616885f, 0.04029087f, -0.03671305f, -0.01271854f, -0.01429190f, 
    0.00414302f, -0.02325928f, 0.00138739f, 0.03283338f, -0.05221082f, -0.04993305f, -0.01723523f, 0.01555057f, 
    0.01848574f, -0.04502706f, 0.01196019f, -0.03093379f, 0.02747245f, -0.04222985f, -0.04860080f, -0.01467576f, 
    -0.00043731f, -0.05207712f, -0.04209994f, 0.01479673f, 0.01743077f, -0.04967599f, -0.02006765f, 0.03383915f, 
    0.00957957f, 0.03294353f, -0.02424361f, -0.04277118f, -0.03235751f, -0.05669440f, -0.01835930f, -0.00807892f, 
    -0.00476140f, 0.00584375f, -0.04749808f, 0.02339863f, -0.05735916f, -0.02733885f, -0.03185108f, 0.01614905f, 
    0.00953783f, -0.00701044f, -0.05309960f, -0.04340804f, 0.03091011f, -0.03305940f, 0.01966940f, 0.00475066f, 
    0.04675362f, 0.02798245f, 0.02528591f, -0.04103227f, 0.03842299f, 0.02563140f, -0.03684502f, -0.00154125f, 
    -0.02631015f, -0.01409710f, 0.04450298f, -0.02450581f, -0.02614778f, -0.00917737f, -0.02031747f, 0.04105592f, 
    0.00848021f, -0.00738965f, 0.04083240f, -0.00560685f, 0.04792782f, 0.01942705f, 0.01196983f, -0.01381649f, 
    0.03985468f, 0.02396332f, -0.00771659f, -0.03961078f, 0.00741448f, 0.03108869f, -0.03013294f, 0.00292449f, 
    -0.05593641f, -0.04008989f, -0.02320019f, 0.01890600f, 0.00844607f, -0.01548898f, 0.02548910f, -0.05425748f, 
    -0.05115904f, -0.02967369f, 0.02704181f, 0.02206550f, -0.02839918f, -0.01593179f, -0.05195717f, 0.00370282f, 
    0.02420614f, 0.00809787f, -0.03767117f, -0.01036521f, -0.01901629f, 0.01515148f, 0.03682547f, 0.01977123f, 
    -0.01248851f, 0.03580912f, -0.02066399f, -0.05344712f, -0.02465934f, 0.00819972f, -0.02173243f, 0.03336970f, 
    -0.03959505f, -0.04148041f, -0.03346020f, 0.00413549f, 0.01753029f, 0.00550659f, -0.02952087f, -0.02686159f, 
    -0.00779313f, -0.01726471f, -0.05626585f, 0.04188507f, 0.01713341f, 0.02875178f, -0.05429602f, 0.01194855f, 
    -0.02643946f, -0.00714434f, -0.03788958f, -0.02500943f, -0.04738238f, -0.00379934f, 0.04333794f, 0.00886370f, 
    -0.01491013f, -0.05129145f, 0.03725176f, 0.02652844f, 0.02559616f, -0.01384592f, 0.00761060f, -0.04208698f, 
    -0.03841129f, -0.03743555f, -0.04960288f, 0.00171702f, -0.05133444f, 0.02948750f, 0.02627373f, 0.03769449f, 
    -0.00862883f, -0.02487127f, -0.01527000f, -0.04308415f, -0.01161321f, 0.03353627f, 0.01508859f, -0.00979470f, 
    -0.01080998f, 0.01512758f, -0.03064859f, 0.01020469f, -0.00661570f, -0.03372133f, 0.03724208f, 0.04441236f, 
    -0.00431106f, 0.02105454f, -0.00665086f, -0.03161883f, 0.03472984f, -0.02183030f, -0.00970641f, 0.00942684f, 
    -0.02403198f, -0.05780762f, 0.00506022f, 0.00138091f, -0.01258702f, 0.01730632f, -0.05615242f, 0.02006768f, 
    -0.01019375f, 0.03297041f, 0.01286421f, -0.01486698f, 0.02716404f, -0.03443739f, 0.04485304f, 0.02582919f, 
    0.00746216f, -0.03892225f, -0.00952975f, -0.04977461f, -0.02808671f, -0.02269610f, -0.01372288f, 0.00506226f, 
    0.00740033f, -0.03813181f, -0.00658465f, -0.00442398f, -0.02183683f, 0.00629731f, 0.01941579f, -0.03495784f, 
    -0.01083579f, -0.03560222f, 0.02375601f, -0.00131601f, -0.05452242f, 0.02709460f, -0.05541599f, 0.02613221f, 
    0.03231402f, -0.04686631f, 0.02595446f, -0.00069973f, -0.05447545f, -0.00401497f, -0.02867184f, -0.01931076f, 
    0.01862943f, -0.02521333f, 0.01638697f, -0.04643494f, 0.01859612f, -0.05632558f, -0.03809713f, -0.00761130f, 
    -0.01452099f, 0.01516236f, -0.00194834f, -0.03765101f, 0.00644899f, 0.04209873f, 0.04311810f, -0.01763963f, 
    0.03678956f, -0.05146752f, 0.01311052f, -0.04150587f, -0.04064113f, 0.02835937f, -0.01604874f, -0.01390103f, 
    0.01724701f, 0.03056077f, 0.00773186f, -0.05206611f, -0.01889207f, 0.02127524f, 0.02510424f, -0.02382588f, 
    -0.04320600f, 0.00139293f, -0.00331509f, 0.03237201f, 0.00257576f, 0.01634572f, 0.03308237f, 0.01272661f, 
    0.04522042f, -0.04558028f, -0.04919349f, 0.02102971f, 0.01450421f, 0.00225665f, 0.02978801f, 0.02696638f, 
    -0.11555551f, -0.08312563f, 0.08971307f, 0.15123047f, -0.21951301f, -0.02405107f, -0.09684173f, -0.07764714f, 
    0.09514778f, 0.04615731f, -0.02187807f, -0.12713346f, -0.05727210f, -0.03942074f, 0.24851267f, 0.50737369f, 
    -0.06279803f, 0.04899628f, -0.07323260f, 0.06189479f, 0.08372357f, 0.02729020f, 0.11099011f, -0.12229186f, 
    0.22647893f, 0.05846100f, -0.06341628f, 0.02460239f, 0.09222632f, -0.02489072f, -0.07875484f, 0.07015452f, 
    -0.02985462f, -0.01740724f, -0.22259064f, 0.02928045f, 0.24608362f, 0.16472064f, 0.02689642f, -0.10515417f, 
    -0.23805775f, -0.05035998f, -0.12200294f, -0.10545288f, -0.11313254f, 0.00179212f, -0.00845758f, -0.03650790f, 
    -0.22284390f, -0.02326172f, 0.31728151f, -0.34699261f, -0.07958676f, 0.02453328f, 0.02784307f, 0.02460100f, 
    0.07668722f, 0.00124852f, -0.03931023f, 0.00686290f, -0.02224510f, 0.09687634f, 0.19257928f, -0.03450195f, 
    0.01920169f, 0.09350378f, 0.05955824f, -0.08744755f, 0.10212341f, 0.11071840f, -0.00396985f, 0.03156561f, 
    0.01868536f, 0.19539918f, 0.02404964f, -0.12037069f, -0.04888724f, -0.10269690f, 0.11421970f, 0.06133543f, 
    -0.09064710f, -0.02749016f, -0.23862325f, -0.03924292f, 0.40655497f, 0.11193762f, -0.09448402f, 0.01097800f, 
    -0.23951688f, -0.03769043f, 0.06887674f, -0.18490648f, 0.04555627f, -0.08550444f, -0.20474060f, -0.04787081f, 
    -0.34782562f, 0.18608689f, 0.06508444f, 0.23480874f, -0.06739104f, -0.08689383f, 0.03759804f, -0.08710290f, 
    0.00248035f, -0.08174565f, -0.05354402f, -0.07118992f, -0.09104276f, 0.12307526f, 0.10460184f, 0.08082759f, 
    -0.02386416f, -0.02349020f, 0.08303931f, -0.00604635f, 0.09027764f, -0.06893473f, -0.00953702f, 0.09927328f, 
    0.20584708f, -0.07225090f, -0.12652746f, -0.05688627f, -0.17832080f, -0.10393369f, -0.08415176f, 0.03004036f, 
    -0.13806987f, 0.21595711f, -0.08839698f, -0.15431233f, 0.05725175f, -0.05956640f, 0.06382032f, -0.09793639f, 
    0.25204319f, 0.10285023f, -0.06320393f, -0.01634751f, 0.12574175f, 0.10354429f, -0.01983212f, 0.38081902f, 
    -0.06045690f, 0.03876556f, -0.07491229f, -0.06966786f, 0.09329545f, 0.27839926f, 0.19059224f, 0.12159084f, 
    -0.14815120f, -0.12435517f, 0.05622021f, 0.18849929f, 0.17200464f, 0.02059506f, 0.29113927f, 0.01111156f, 
    -0.09998170f, -0.13984959f, -0.07778649f, -0.01163226f, -0.16129614f, -0.02119188f, -0.03171623f, -0.06331798f, 
    -0.20843758f, 0.10905966f, 0.03272921f, -0.04748911f, -0.01340790f, 0.06983414f, -0.06233463f, 0.07656301f, 
    0.08389816f, 0.22497278f, 0.02212297f, 0.05371706f, 0.05667573f, 0.32209471f, 0.10989008f, -0.11185495f, 
    -0.15587743f, 0.05181032f, 0.02560014f, 0.16010001f, -0.02724529f, -0.14953479f, 0.04833380f, -0.11573410f, 
    0.80523819f, 0.18864238f, 0.30756247f, 0.07061598f, -0.08536088f, -0.12396973f, 0.01585746f, -0.10594057f, 
    -0.03479067f, 0.05632477f, -0.05175091f, 0.12719186f, -0.15167914f, 0.21685934f, 0.24962805f, 0.06035220f, 
    -0.07336108f, 0.04220587f, -0.05933863f, -0.01428148f, 0.02521621f, -0.03544820f, -0.08531992f, 0.10097492f, 
    -0.16395450f, -0.38439909f, 0.54303771f, 0.04537887f, -0.00300303f, -0.03093605f, -0.20470391f, -0.06815609f, 
    -0.01226277f, 0.02954540f, -0.02481328f, -0.02711217f, 0.20145880f, 0.25303307f, 0.10496374f, -0.17342775f, 
    0.02806362f, 0.09375516f, 0.06502877f, -0.04116726f, -0.18140471f, -0.15959609f, -0.27243727f, -0.14715236f, 
    0.00635646f, -0.07781471f, -0.22737631f, 0.25629237f, 0.01807645f, -0.05187143f, 0.05219778f, -0.05801531f, 
    0.03875935f, -0.15920541f, -0.14070754f, 0.12918974f, -0.00684815f, 0.09097951f, -0.07641400f, -0.03922660f, 
    -0.12979272f, -0.16019489f, 0.03425988f, -0.10502025f, -0.12145264f, 0.09343162f, 0.04852179f, -0.17546721f, 
    -0.25413275f, -0.12134206f, -0.04610503f, 0.12348726f, -0.01746658f, 0.03570455f, -0.02955410f, 0.14370903f, 
    0.11130000f, 0.02739315f, -0.01348813f, 0.05189564f, -0.12287176f, 0.11506822f, -0.24234220f, -0.01095460f, 
    0.16817081f, 0.05955329f, 0.11650075f, 0.05164158f, -0.14668848f, 0.00919899f, 0.04360201f, -0.25644639f, 
    -0.00058683f, 0.03943614f, 0.36178571f, 0.28040802f, -0.08889993f, -0.15773155f, 0.16062188f, 0.10071420f, 
    0.04483396f, -0.02520813f, 0.05664581f, 0.01818688f, 0.12873696f, -0.04260042f, 0.05360463f, -0.08759583f, 
    -0.02985857f, -0.11359204f, -0.19759698f, 0.08168487f, -0.05421518f, -0.01050242f, 0.11647868f, 0.15315722f, 
    0.03393755f, 0.01035731f, -0.26181206f, -0.01165263f, 0.01683185f, -0.03509901f, 0.00340052f, 0.12109365f, 
    -0.09565095f, 0.03407425f, 0.05832459f, -0.00392572f, 0.22368486f, -0.11597476f, 0.19004296f, 0.32886031f, 
    0.09390522f, 0.02864548f, -0.02445671f, 0.03063144f, -0.01223807f, -0.04706534f, -0.06212357f, -0.05085727f, 
    -0.06455121f, 0.06941268f, 0.02321770f, -0.13245860f, 0.07515392f, 0.21071254f, -0.05423978f, -0.05518934f, 
    0.01307628f, 0.04057924f, 0.19905791f, -0.01202936f, 0.24919659f, 0.38952819f, 0.02950020f, -0.00847350f, 
    -0.01337193f, -0.06935501f, -0.17934780f, -0.01328614f, -0.03481818f, -0.01096516f, 0.01159349f, -0.12309346f, 
    0.50251126f, -0.08023648f, 0.32530025f, 0.15909420f, 0.12816393f, -0.07201281f, 0.17354459f, 0.04287598f, 
    -0.11445592f, 0.09376783f, 0.02822804f, -0.07950238f, 0.08622330f, 0.03994409f, 0.39982167f, -0.18283617f, 
    0.08587096f, 0.04742666f, -0.14521509f, -0.05929857f, 0.08044767f, 0.03112351f, 0.09362693f, -0.08917695f, 
    -0.26379424f, -0.25509793f, 0.01882304f, 0.02623032f, -0.02631458f, -0.00796223f, -0.15987818f, -0.04660058f, 
    -0.13533622f, -0.08127325f, -0.11731840f, -0.13347544f, -0.01997970f, -0.02868433f, -0.03435097f, 0.03605078f, 
    0.13472590f, -0.04897857f, 0.03393688f, -0.00793112f, -0.12792279f, -0.02393422f, 0.07076230f, 0.07981822f, 
    0.05514825f, 0.16257188f, 0.25565875f, -0.30914646f, -0.09574763f, 0.02926943f, 0.10105347f, 0.19189569f, 
    0.03545946f, -0.03335135f, -0.08565778f, -0.06031858f, 0.14323187f, 0.15502733f, 0.11066289f, 0.05106076f, 
    -0.07847452f, -0.13511463f, -0.06402445f, -0.11464284f, 0.14541346f, 0.01013937f, -0.08235002f, 0.10374130f, 
    0.02517164f, 0.13024408f, 0.30708948f, -0.00045187f, -0.05888997f, -0.06643579f, -0.03715938f, -0.14458907f, 
    0.03504451f, 0.01054943f, 0.03687071f, 0.04283972f, 0.07749723f, -0.02873191f, -0.06011999f, 0.30906478f, 
    0.08847668f, 0.00357921f, 0.06135033f, -0.05323000f, 0.08484899f, 0.12826745f, -0.08969598f, 0.10900208f, 
    0.02705517f, 0.19482841f, 0.13609840f, -0.03284165f, -0.10469070f, 0.03481520f, 0.03343081f, -0.04198666f, 
    0.03400383f, 0.00118751f, -0.03318044f, 0.05176076f, 0.04570092f, -0.31755972f, -0.25888103f, 0.10209563f, 
    0.05117179f, 0.00713336f, -0.02190538f, 0.03091576f, 0.08036140f, 0.08911466f, -0.02210721f, -0.07255559f, 
    0.03672618f, 0.04225996f, -0.11038125f, 0.14973296f, 0.00932446f, 0.11427703f, -0.00149097f, -0.01611576f, 
    0.06587312f, 0.08799457f, 0.02486741f, 0.11017501f, -0.14589868f, -0.10167746f, -0.03376089f, 0.25207153f, 
    -0.12132917f, 0.02928835f, -0.02726046f, 0.02950448f, -0.05767785f, 0.02833424f, 0.08229053f, 0.02023764f, 
    -0.00137182f, 0.22293399f, 0.25181982f, 0.00438892f, -0.15847866f, -0.09709487f, -0.00314681f, 0.03565274f, 
    0.02106319f, -0.04586526f, 0.05243254f, 0.00089565f, -0.08859435f, -0.13568509f, 0.14346668f, 0.00385396f, 
    0.07546398f, 0.18653774f, 0.08445851f, -0.00986503f, -0.09585919f, 0.05792228f, -0.13951163f, 0.02748297f, 
    -0.05954760f, 0.14959271f, -0.04969145f, -0.07082308f, -0.12381706f, 0.09036445f, -0.01475925f, -0.03543325f, 
    0.04735049f, 0.01372080f, 0.22821429f, 0.18205249f, -0.08037751f, 0.34905013f, 0.47299957f, -0.00870298f, 
    -0.00612043f, -0.23241243f, -0.11007046f, -0.00347149f, 0.05711857f, 0.04576527f, 0.00280880f, 0.11310399f, 
    -0.26208362f, -0.04687379f, -0.10084540f, 0.10516061f, -0.15661025f, 0.02290835f, 0.12732415f, -0.14599383f, 
    -0.07973048f, -0.11682511f, 0.00334041f, 0.03655096f, 0.10151692f, 0.40391424f, -0.12790090f, 0.12489999f, 
    -0.09411478f, -0.10732164f, -0.05739615f, -0.10372344f, -0.06357115f, 0.02322557f, 0.10066672f, -0.06465554f, 
    0.54080433f, -0.29450917f, -0.00729404f, -0.13056368f, -0.00795256f, 0.15813558f, -0.00813403f, -0.04016881f, 
    0.01847895f, 0.10105334f, 0.01457718f, -0.06436323f, -0.11521613f, -0.17687511f, 0.12235456f, 0.09225873f, 
    -0.01547769f, 0.05425516f, -0.08345857f, -0.07898913f, 0.09443723f, 0.08261149f, 0.07387494f, 0.03060750f, 
    -0.26718068f, -0.34925133f, 0.50963086f, -0.02895293f, 0.14903657f, 0.01790150f, 0.03079292f, -0.05543877f, 
    0.11686572f, -0.02973319f, -0.01008355f, 0.05296880f, -0.20505251f, -0.13662298f, 0.00717453f, 0.19715251f, 
    0.10487413f, 0.07098341f, 0.15005361f, -0.06339744f, 0.06398925f, 0.08474559f, -0.09437953f, -0.00047021f, 
    0.50408560f, 0.05878004f, 0.08094483f, -0.24711801f, -0.05865804f, -0.02700187f, 0.03819038f, -0.02153051f, 
    0.06446537f, 0.07762096f, 0.29424691f, 0.06494489f, -0.02122300f, -0.01806847f, -0.12593725f, -0.12100452f, 
    0.02558354f, 0.04591684f, 0.02770025f, -0.02801723f, 0.03369913f, 0.14252140f, 0.02849370f, -0.05191253f, 
    -0.19530141f, -0.09071106f, -0.08594625f, 0.08675566f, -0.01608104f, -0.10895113f, -0.11474760f, 0.03631261f, 
    -0.07391073f, -0.05028427f, -0.05586730f, 0.01906322f, 0.10864778f, 0.25888860f, -0.24674010f, -0.09004126f, 
    0.00330606f, -0.14097342f, -0.10684308f, -0.06415205f, 0.02801510f, 0.03777317f, 0.10952313f, 0.08972832f, 
    -0.37680781f, -0.19531749f, 0.08279694f, 0.05826272f, 0.07226122f, 0.06910327f, 0.20946503f, 0.10134003f, 
    0.02016369f, 0.04075281f, 0.08877961f, -0.08663221f, 0.00296987f, 0.09126907f, -0.00386991f, -0.18102361f, 
    -0.18444103f, -0.04548809f, -0.09124328f, -0.05147608f, -0.00760725f, 0.03493075f, 0.04823744f, -0.07536954f, 
    0.03739782f, 0.14287673f, -0.12077339f, -0.24565263f, 0.02148607f, 0.01081715f, -0.06640030f, -0.01400020f, 
    -0.00076081f, 0.11092183f, 0.26309821f, -0.00367219f, 0.14169055f, -0.14894983f, 0.09873378f, 0.11796991f, 
    0.11884513f, -0.07402695f, -0.02405277f, -0.07314632f, -0.08907239f, 0.06817962f, 0.00866967f, 0.06860956f, 
    0.21673395f, 0.04553020f, 0.01048915f, -0.00637433f, -0.01007260f, 0.10510100f, 0.06106955f, -0.07745252f, 
    0.18666075f, -0.00125060f, 0.21438614f, 0.00012113f, 0.20144978f, 0.53861034f, 0.01990833f, 0.27825031f, 
    -0.12350888f, -0.12022507f, 0.01989068f, -0.07813644f, 0.05196994f, 0.22440867f, 0.02515932f, 0.07298619f, 
    0.37525088f, 0.01898150f, 0.26584628f, 0.34256119f, -0.12994054f, -0.05705113f, 0.09891626f, 0.07646044f, 
    -0.19059274f, 0.17540707f, 0.03850611f, -0.01861355f, 0.07101004f, -0.01787862f, 0.11662292f, 0.12831436f, 
    0.02788430f, 0.09815177f, -0.00039492f, 0.03852452f, 0.00078666f, 0.01677035f, -0.03441059f, -0.08702535f, 
    -0.12764128f, -0.22630593f, -0.29501662f, -0.10088769f, 0.10444238f, 0.18061478f, 0.06775280f, -0.19426689f, 
    -0.04747269f, 0.02780959f, 0.02864596f, 0.08887260f, 0.07247767f, 0.21657573f, 0.09147249f, 0.04009419f, 
    0.27357438f, 0.02520234f, 0.14279357f, 0.11844590f, -0.16791531f, 0.01058170f, -0.05805771f, -0.08112340f, 
    -0.18022187f, -0.08417170f, 0.24379830f, -0.17174186f, 0.01403541f, -0.05274283f, 0.01504044f, -0.03243892f, 
    -0.08311706f, -0.07658270f, 0.05768580f, -0.00534630f, -0.17517316f, -0.08762926f, 0.20657407f, 0.02996715f, 
    -0.02182273f, 0.02429298f, 0.06980292f, -0.01172451f, 0.01855385f, 0.14554569f, 0.09585806f, 0.09285767f, 
    -0.01863098f, 0.28422970f, 0.17203052f, -0.10252606f, -0.05419941f, -0.01587959f, -0.13482712f, -0.11906920f, 
    0.03859477f, -0.03946620f, -0.07990801f, 0.01736313f, 0.29306307f, 0.17563707f, -0.24951427f, 0.24004513f, 
    -0.06555384f, 0.19931170f, -0.14984231f, -0.04135059f, 0.13664985f, 0.11650391f, -0.01693280f, 0.12721542f, 
    0.02777645f, -0.09378983f, 0.04077507f, 0.05382935f, -0.05552820f, -0.15295810f, -0.16390231f, 0.08600625f, 
    0.06946174f, 0.06248679f, 0.03998231f, -0.00086831f, -0.13881132f, -0.19444534f, -0.04963973f, 0.05185735f, 
    -0.03029251f, 0.04360253f, -0.03601857f, -0.03707784f, 0.02454901f, 0.00618445f, 0.14370394f, -0.09447149f, 
    -0.20704214f, 0.39559835f, 0.10496926f, 0.20462614f, -0.06859481f, 0.18780474f, -0.05027255f, -0.04030089f, 
    -0.02608734f, 0.15991332f, -0.03715252f, -0.03025582f, 0.22105907f, 0.02044720f, -0.05891781f, 0.16782156f, 
    0.05103213f, -0.09920842f, -0.06886617f, 0.01352079f, -0.06682450f, -0.14543049f, 0.04159112f, -0.12574339f, 
    -0.07141449f, -0.07764563f, 0.15213916f, 0.07761827f, -0.20042048f, -0.19460101f, -0.18510136f, -0.18278708f, 
    -0.02011704f, 0.05482047f, -0.19636524f, 0.06703167f, -0.12312294f, -0.08194121f, 0.15613696f, -0.05048342f, 
    -0.00530170f, 0.16251512f, 0.05999353f, -0.07560901f, 0.01574289f, 0.03194359f, -0.13725775f, 0.02189191f, 
    0.11362602f, 0.06933878f, 0.09253518f, 0.08535655f, -0.09931641f, 0.09716723f, -0.13031468f, 0.06487022f, 
    0.14340486f, 0.07588954f, 0.04139144f, 0.15566641f, -0.10434253f, 0.21123452f, 0.24741222f, -0.00551374f, 
    -0.14342049f, -0.16387472f, -0.18461016f, 0.10514471f, 0.01257915f, 0.00305027f, -0.06380469f, -0.00218539f, 
    -0.43070790f, 0.11787503f, -0.04686698f, -0.14609787f, 0.11366137f, 0.04812053f, -0.10687303f, -0.09383274f, 
    0.02582345f, -0.11262497f, 0.04330753f, -0.00043451f, -0.06061569f, 0.28893518f, 0.00043027f, 0.21917608f, 
    -0.05218443f, -0.16208863f, -0.04926243f, 0.17064528f, -0.13515607f, -0.10970555f, 0.05596622f, -0.04792315f, 
    0.55504185f, -0.10683931f, 0.20969146f, -0.18048398f, -0.05634033f, 0.04874105f, -0.03021525f, 0.21361881f, 
    0.05675178f, 0.04222275f, -0.02190341f, -0.01997511f, -0.03517259f, -0.03922383f, -0.11063369f, -0.06849463f, 
    0.03822265f, 0.12523419f, 0.06928170f, -0.07224861f, -0.07244693f, 0.08399132f, -0.05132674f, 0.02401530f, 
    0.02530065f, -0.58170837f, 0.06040955f, -0.09511614f, 0.08219218f, 0.04895694f, 0.09692775f, -0.10218231f, 
    0.04116079f, -0.05318373f, -0.05019442f, 0.09525885f, -0.22389197f, -0.06378622f, -0.05364184f, 0.06669234f, 
    0.03598157f, 0.33078012f, 0.08420587f, -0.06619637f, 0.31102529f, 0.03948915f, 0.08361528f, 0.16200106f, 
    -0.05926548f, 0.15729700f, 0.37763420f, 0.00203961f, -0.19913474f, -0.00873762f, 0.04200176f, 0.10700421f, 
    -0.06532800f, -0.01170852f, -0.02828586f, -0.00609580f, -0.08789869f, 0.13777961f, -0.09361509f, -0.00778929f, 
    -0.05162793f, 0.10817850f, 0.09081533f, -0.07458553f, 0.03781053f, 0.08568171f, 0.07160101f, 0.28628394f, 
    -0.03135182f, 0.07692391f, -0.24476227f, -0.02787130f, 0.15723012f, 0.05614891f, -0.06772421f, -0.10510144f, 
    -0.10443537f, -0.08418771f, -0.03959734f, 0.06525178f, -0.00978534f, 0.15149002f, 0.00120909f, 0.01116308f, 
    -0.19417335f, -0.02466076f, 0.17054757f, -0.04520008f, -0.11656393f, -0.02974340f, 0.13859357f, 0.17246513f, 
    -0.12059581f, 0.09220514f, 0.01976552f, 0.20102917f, 0.13144623f, 0.08033211f, 0.09364355f, 0.00398676f, 
    0.03618295f, 0.03568580f, -0.12159520f, -0.00874027f, -0.02461600f, 0.01187718f, 0.12312783f, -0.05046362f, 
    -0.11370601f, -0.17751272f, -0.13467343f, -0.01498794f, -0.11712544f, -0.13780318f, -0.16786571f, -0.17895044f, 
    0.21941470f, 0.34799248f, -0.20142594f, -0.15338643f, 0.02958762f, -0.04129869f, 0.01689206f, 0.08404669f, 
    -0.07624929f, -0.14341769f, -0.13249703f, -0.10598359f, 0.41293201f, -0.06164837f, 0.06617662f, 0.07446300f, 
    0.13967834f, 0.16893229f, 0.09891023f, 0.05501098f, 0.00963714f, 0.13622315f, -0.04633208f, 0.17268813f, 
    0.06985208f, 0.03651262f, 0.09546429f, 0.08275045f, -0.12780958f, 0.16348058f, -0.07277793f, -0.14225860f, 
    0.12833574f, 0.02403773f, 0.01962511f, -0.03721975f, 0.16840032f, 0.43134063f, -0.05163876f, 0.33962637f, 
    -0.01251225f, -0.10714614f, -0.05535784f, -0.01329849f, 0.04137927f, -0.09096690f, 0.05342882f, -0.17753713f, 
    0.50463229f, -0.04255757f, 0.15487412f, 0.22026353f, -0.12929372f, -0.09693795f, 0.27800068f, 0.09848458f, 
    -0.05099315f, 0.24361034f, 0.05457770f, -0.02807848f, 0.29103222f, -0.31810945f, 0.27676404f, 0.18133304f, 
    -0.01735255f, -0.01938219f, 0.02970925f, -0.04506345f, 0.14130352f, 0.04195599f, 0.12249332f, 0.10750281f, 
    0.35528892f, 0.37425300f, 0.20611374f, 0.04025471f, 0.11066313f, 0.08372235f, -0.00537519f, -0.11211205f, 
    -0.08829783f, -0.08406102f, -0.16011027f, -0.01236427f, 0.29577461f, 0.61718172f, 0.36597824f, 0.10733203f, 
    0.13803795f, 0.14298224f, 0.04087386f, -0.09662087f, 0.01972196f, -0.05433519f, 0.01556276f, 0.07327060f, 
    -0.12771767f, 0.01361922f, 0.02811776f, -0.15587124f, 0.07951706f, 0.07756128f, 0.12496688f, 0.21622086f, 
    -0.00685538f, 0.08484627f, -0.06611144f, -0.07584904f, 0.19135898f, -0.01268625f, 0.06310364f, -0.08776276f, 
    0.18619965f, 0.13642909f, 0.01185711f, 0.05508493f, -0.03026274f, 0.04427006f, 0.09670593f, -0.03255721f, 
    -0.03028790f, -0.24931429f, 0.25416082f, 0.17454641f, 0.02145530f, -0.02353865f, -0.02462076f, -0.02029507f, 
    -0.09190339f, -0.14504790f, -0.00149151f, 0.10198245f, 0.14531557f, -0.34139135f, 0.15914188f, -0.11860026f, 
    0.02930190f, 0.16566709f, -0.00716190f, 0.02350883f, 0.05092582f, -0.15856792f, 0.02292461f, 0.02716969f, 
    -0.03224792f, 0.22410420f, -0.12929259f, 0.12104376f, -0.06627953f, -0.07643517f, -0.04386220f, 0.06432562f, 
    0.10743912f, 0.00879100f, 0.00776283f, 0.10519781f, -0.13929515f, -0.33224666f, -0.14672153f, -0.06344292f, 
    0.04503364f, 0.02495717f, 0.02205648f, 0.04001303f, 0.06309690f, 0.17950875f, -0.02641710f, -0.00986677f, 
    0.20120791f, 0.16566189f, 0.19897300f, 0.03082739f, 0.02588785f, 0.02735847f, 0.06719916f, 0.07976083f, 
    0.07350033f, 0.10034642f, 0.09372386f, -0.07210866f, 0.35832918f, -0.12483689f, -0.18395902f, -0.01926107f, 
    0.02262993f, 0.06352390f, -0.08894835f, -0.00616132f, -0.14856096f, 0.01845790f, 0.10011982f, -0.10854594f, 
    0.13268943f, -0.00054328f, -0.06137055f, 0.00308823f, 0.01668286f, -0.01808245f, -0.16509871f, 0.01742806f, 
    0.11534762f, -0.02151054f, -0.04488202f, -0.05076513f, -0.10533050f, 0.01644720f, 0.23515163f, -0.04120035f, 
    0.17991818f, -0.04069445f, -0.09154857f, 0.04637078f, 0.00111893f, 0.00020659f, -0.03359396f, 0.02231268f, 
    -0.22943500f, 0.05523506f, -0.24014606f, 0.13228570f, -0.02496118f, -0.07841822f, 0.02369173f, 0.02314325f, 
    0.00092866f, -0.05754075f, 0.10615646f, 0.17426772f, 0.13706952f, 0.02424821f, 0.02883009f, 0.10257965f, 
    -0.02044564f, -0.02508832f, -0.12112163f, 0.03070585f, -0.07852381f, 0.04296643f, -0.09212493f, -0.06452490f, 
    0.09886288f, 0.22959775f, 0.20710620f, -0.11257601f, -0.01361885f, -0.11925693f, -0.05455310f, 0.00068690f, 
    0.03159827f, -0.00800335f, 0.01478132f, -0.03539338f, 0.33703089f, 0.21386778f, -0.06930492f, -0.08460329f, 
    -0.05892966f, -0.12893374f, 0.04290802f, -0.05802165f, -0.07214570f, -0.05228226f, -0.01404309f, -0.10782090f, 
    -0.39604890f, -0.13002634f, -0.30488479f, -0.11711750f, 0.02636419f, 0.02668983f, -0.03318454f, 0.00591465f, 
    0.02646173f, 0.02165723f, -0.00035622f, -0.08594468f, 0.10947183f, 0.15082778f, 0.25451279f, -0.05992012f, 
    -0.13033372f, 0.02515712f, -0.02354492f, -0.05609801f, 0.05412830f, 0.10738022f, 0.08416267f, 0.00115448f, 
    0.28639174f, -0.27482679f, 0.17440483f, -0.12474475f, 0.07723289f, -0.00980633f, -0.05108359f, 0.17564233f, 
    -0.06385508f, 0.04240095f, -0.00026234f, 0.21612312f, -0.16720411f, -0.04817169f, -0.28841943f, 0.08662035f, 
    0.01094744f, 0.30289400f, 0.05076421f, 0.05222099f, 0.10323817f, 0.01089432f, -0.07920938f, -0.08448297f, 
    -0.07686784f, -0.33876315f, 0.12918499f, 0.11400533f, 0.19249515f, -0.02594998f, -0.06608777f, 0.01162247f, 
    0.02646470f, 0.15823554f, 0.00987675f, 0.05320676f, -0.08342392f, 0.00026515f, -0.11084224f, -0.01571969f, 
    0.08446369f, 0.13924949f, 0.03308550f, -0.08079032f, 0.09492464f, -0.04664107f, 0.07335193f, 0.05686294f, 
    0.40620884f, 0.32251233f, 0.19263506f, 0.00888405f, 0.08210399f, -0.04527009f, -0.05577883f, -0.02182119f, 
    0.02958912f, 0.00870227f, 0.01724092f, -0.01001851f, -0.02411054f, 0.02606036f, -0.05969608f, 0.11527985f, 
    0.04512010f, -0.08476899f, 0.03395363f, -0.10997612f, 0.06931274f, -0.00578481f, -0.02524289f, 0.03592299f, 
    0.08672761f, -0.00240045f, 0.04248152f, 0.03489147f, -0.00655453f, 0.08540522f, 0.10992355f, -0.06306828f, 
    -0.05931081f, -0.01761656f, -0.03287514f, -0.04505957f, -0.03933316f, -0.04263102f, -0.08488968f, 0.04214682f, 
    0.00526474f, 0.02840507f, -0.13804685f, -0.01715273f, -0.14509264f, -0.03853180f, -0.06332733f, -0.14005113f, 
    -0.06048254f, 0.28854224f, -0.14628434f, -0.20999458f, -0.01060733f, -0.17068316f, -0.03263833f, 0.01246335f, 
    0.02948728f, 0.00163999f, 0.04195243f, 0.04739713f, 0.03037099f, 0.23498070f, 0.20888142f, 0.08045791f, 
    0.07610669f, 0.03662453f, 0.03347960f, 0.07542682f, -0.08887788f, 0.01239857f, 0.05579426f, 0.03083579f, 
    0.19068442f, -0.20190752f, 0.36501840f, -0.03349742f, 0.05975820f, 0.03884463f, -0.09608617f, -0.03012982f, 
    0.03913825f, -0.12241028f, 0.01351972f, -0.00724774f, 0.32852802f, 0.04952887f, -0.04044065f, 0.03268145f, 
    -0.14480074f, 0.03554776f, -0.11043994f, -0.02896824f, 0.00704295f, 0.02184638f, 0.02756452f, -0.13198981f, 
    0.04597371f, 0.00290053f, -0.11907003f, 0.00756547f, -0.15342905f, 0.28132766f, -0.13246864f, 0.11514966f, 
    0.07048526f, 0.01138066f, 0.01263083f, 0.04522902f, 0.13491124f, -0.11805059f, 0.59878409f, -0.05152079f, 
    0.16837211f, 0.00802234f, 0.03881001f, -0.10573433f, 0.00852890f, 0.02533522f, 0.06323110f, -0.04397329f, 
    -0.05741448f, 0.02455902f, -0.03442981f, -0.00780307f, 0.03492664f, -0.05127525f, 0.00177854f, -0.05144888f, 
    -0.02439052f, -0.01778634f, -0.00531455f, 0.02170120f, -0.00719303f, -0.03294600f, 0.02978375f, 0.02193804f, 
    -0.04109377f, 0.01591317f, -0.02013581f, 0.03056530f, -0.05255814f, -0.04104026f, -0.04576811f, -0.05301119f, 
    -0.05332289f, -0.05328316f, 0.03131737f, 0.01797130f, -0.00056493f, -0.03786455f, -0.05660155f, 0.03564490f, 
    0.01248346f, -0.01012455f, 0.00176137f, 0.04141843f, -0.04828130f, -0.01496673f, 0.01620717f, 0.00207623f, 
    -0.01460504f, -0.00360574f, 0.01350587f, 0.03074369f, 0.00758539f, 0.01098024f, -0.05346320f, -0.05346179f, 
    0.00139810f, 0.00631276f, 0.03679411f, -0.01276296f, -0.00008930f, -0.01674081f, 0.01683258f, -0.03507375f, 
    0.00926428f, 0.02988904f, -0.00744796f, -0.02871353f, -0.00998459f, 0.00655536f, 0.02538731f, 0.03698023f, 
    0.03077411f, 0.04241524f, -0.03599055f, -0.05575699f, 0.01634577f, -0.00954862f, -0.02183016f, -0.00118880f, 
    0.03812597f, 0.02665451f, -0.04994915f, -0.04429959f, 0.01754788f, -0.04060815f, -0.01500963f, -0.01269494f, 
    -0.04751660f, 0.02528042f, -0.01267593f, 0.04380836f, -0.02754032f, -0.05801697f, -0.03028022f, -0.02916974f, 
    -0.01680687f, -0.02223344f, 0.03501874f, -0.04614809f, 0.00614515f, -0.02941866f, -0.01700514f, 0.00663849f, 
    -0.00226373f, 0.03856221f, 0.00273497f, -0.00898607f, 0.01739235f, -0.02992072f, -0.05608728f, 0.01956918f, 
    0.01587644f, -0.02399441f, -0.00749072f, 0.01382548f, 0.00822723f, -0.00518886f, 0.03049145f, -0.04663003f, 
    0.03009168f, 0.02310321f, -0.00250986f, -0.04921140f, 0.03142918f, -0.00897325f, -0.00743475f, 0.01488335f, 
    -0.03050264f, 0.02474277f, 0.00885324f, 0.03108533f, -0.03976864f, -0.03903690f, -0.03270298f, -0.05149275f, 
    0.02849167f, -0.03943672f, -0.03294539f, 0.03231997f, 0.02995440f, -0.01656940f, -0.04088613f, 0.02345127f, 
    -0.03628479f, 0.03925125f, -0.05038880f, 0.03358981f, 0.00534320f, -0.04775122f, -0.04515640f, -0.03215815f, 
    0.01467926f, -0.00044591f, 0.00773800f, -0.00621041f, -0.01607028f, -0.03671129f, 0.04183582f, -0.02957065f, 
    -0.02528121f, 0.03997985f, -0.01606209f, 0.01932379f, -0.03454476f, -0.01946427f, 0.02134948f, -0.04604566f, 
    0.02533234f, -0.02626310f, 0.00701542f, -0.04198550f, 0.02101466f, 0.04011101f, -0.04409667f, -0.05136307f, 
    0.03408689f, 0.03756423f, 0.01121093f, 0.02109902f, 0.02761065f, -0.01368612f, -0.00860860f, -0.05449357f, 
    0.01997483f, -0.04793842f, 0.04126980f, 0.04011701f, 0.04149865f, 0.00721141f, -0.03398199f, 0.01722700f, 
    -0.01742356f, 0.00306445f, 0.02303945f, -0.05275175f, -0.03565771f, 0.02849919f, -0.04663922f, -0.00212279f, 
    0.01476291f, -0.03237978f, 0.03034565f, 0.02838095f, -0.02912230f, 0.02806060f, 0.04222995f, 0.01334850f, 
    -0.03010138f, 0.03945006f, -0.03492380f, 0.03165662f, -0.05429700f, 0.04437758f, 0.03535720f, -0.01816451f, 
    -0.05324619f, -0.03267327f, 0.03353237f, -0.00780527f, -0.01402588f, 0.03910408f, 0.04001654f, 0.00061547f, 
    0.00274032f, 0.01523256f, 0.00254334f, -0.03505218f, 0.04286129f, 0.01198019f, -0.00588459f, 0.00529459f, 
    -0.02489863f, -0.04202380f, 0.02180532f, -0.02353257f, 0.03085190f, 0.03113971f, 0.01263337f, 0.00248567f, 
    -0.01537078f, 0.00924612f, -0.05646097f, 0.03033043f, 0.02388266f, -0.02778567f, 0.00127237f, 0.03151606f, 
    0.01214201f, -0.02552175f, 0.02414998f, 0.01157258f, -0.04811137f, -0.03699175f, -0.03237136f, -0.01647635f, 
    0.03117983f, -0.04029502f, -0.02816535f, -0.05636007f, -0.03708442f, -0.04974306f, -0.04536842f, -0.05264885f, 
    -0.04927899f, 0.02956676f, 0.02948670f, 0.00198759f, -0.02885899f, -0.01722438f, -0.03116715f, -0.01113014f, 
    -0.00607304f, -0.02981753f, -0.00874154f, -0.03740469f, -0.01094129f, 0.01049268f, -0.00057091f, -0.01173739f, 
    -0.04814262f, 0.01410902f, -0.03839120f, 0.02032860f, 0.04346277f, 0.00389439f, -0.01434567f, -0.04356033f, 
    -0.02065589f, -0.05619309f, -0.01661259f, -0.03435127f, -0.02704133f, -0.05169959f, 0.02622669f, -0.02077214f, 
    -0.03551114f, -0.00990685f, 0.02224126f, -0.01164757f, -0.04766949f, 0.00775580f, 0.01004365f, 0.01043113f, 
    0.03115847f, -0.03924268f, -0.03692388f, -0.05155560f, 0.01669871f, -0.00361025f, -0.03254689f, 0.03243220f, 
    -0.05213743f, 0.04234131f, -0.04563237f, 0.00790466f, 0.00659598f, -0.00340914f, -0.00287602f, -0.03487766f, 
    -0.02534227f, -0.02650701f, -0.01413306f, -0.05522779f, -0.01741331f, -0.02850881f, -0.04286547f, 0.00447498f, 
    0.02870369f, -0.02984099f, 0.03065280f, -0.01833554f, 0.00824833f, -0.02652755f, -0.01858372f, -0.00726730f, 
    0.01998817f, 0.01429521f, 0.02211326f, 0.03461053f, -0.05710486f, -0.03314713f, -0.02220824f, 0.03558251f, 
    -0.02930960f, -0.00816109f, 0.03600014f, -0.04107802f, -0.00648181f, 0.04341073f, -0.00712381f, -0.03040831f, 
    0.02560183f, -0.01285803f, -0.01453763f, 0.03742802f, 0.03783947f, 0.01069447f, -0.03662919f, 0.04342816f, 
    0.04234033f, -0.01171667f, 0.01456441f, 0.03442700f, -0.04894361f, 0.04360643f, -0.02379315f, -0.00522491f, 
    0.03443122f, -0.00586172f, 0.00274184f, -0.05328410f, 0.02606407f, 0.00026739f, 0.00819635f, 0.01112946f, 
    0.02375389f, -0.04651453f, 0.02672644f, -0.01627825f, 0.03423654f, -0.04188932f, 0.01079940f, -0.04869921f, 
    -0.02208642f, 0.03719063f, 0.03528512f, -0.05031601f, -0.04627477f, -0.00762351f, -0.04093777f, -0.00401597f, 
    -0.17934205f, -0.29618797f, -0.17726977f, -0.18506093f, 0.08202428f, -0.14967757f, -0.14894629f, -0.19043043f, 
    0.04590707f, -0.05840055f, -0.10448071f, -0.02448650f, -0.24114276f, -0.28491172f, -0.01109648f, -0.03556143f, 
    -0.12318578f, -0.18449371f, 0.05848182f, -0.17927672f, -0.08314545f, 0.10615119f, 0.05095349f, 0.04819721f, 
    0.02941776f, -0.11135235f, 0.05609059f, 0.03112675f, 0.00258539f, 0.10370742f, 0.12135286f, 0.22181797f, 
    0.01852639f, 0.02482430f, -0.01980287f, 0.00769430f, 0.09295579f, -0.02916906f, 0.04833219f, -0.00139231f, 
    -0.03823997f, 0.07100480f, -0.00051183f, 0.05835406f, 0.00065155f, -0.03512260f, 0.02524219f, 0.10029707f, 
    0.07118925f, -0.11232305f, -0.02333701f, 0.23957780f, 0.10410827f, -0.01366192f, 0.06535337f, 0.06736200f, 
    -0.07544842f, 0.00703150f, 0.12032685f, -0.01532383f, 0.47934213f, -0.07256509f, 0.09622000f, 0.35289434f, 
    0.14827330f, 0.06880955f, 0.14324333f, 0.07678755f, 0.14210282f, -0.18598314f, 0.01497590f, 0.13987091f, 
    -0.07027479f, 0.12032817f, -0.19351478f, 0.14523846f, -0.06486193f, -0.01035796f, 0.10299566f, 0.01602639f, 
    -0.13565481f, -0.08569007f, 0.03219053f, 0.00133820f, -0.21793684f, 0.00845366f, 0.13779891f, 0.21997437f, 
    0.03616693f, -0.00155292f, -0.07522358f, 0.09713757f, 0.05529385f, 0.01882617f, -0.04373995f, 0.03471809f, 
    0.10050530f, 0.11284575f, -0.08393028f, 0.13766909f, -0.00747511f, 0.07423896f, -0.11370776f, 0.23205626f, 
    0.00371163f, 0.20865184f, -0.00575119f, 0.01874547f, -0.01927790f, 0.11262466f, 0.02081951f, 0.14755933f, 
    -0.10526100f, 0.08531155f, 0.17196220f, -0.13304991f, 0.03227542f, 0.06429894f, 0.08884221f, 0.15195112f, 
    0.08173783f, -0.01055673f, 0.09892885f, -0.04482294f, -0.06202075f, 0.16440304f, -0.01658601f, 0.02377564f, 
    0.02554130f, -0.25296864f, 0.07252327f, -0.05149923f, 0.26531193f, -0.06847798f, -0.10578698f, 0.02176957f, 
    -0.03750822f, 0.04919335f, 0.15096480f, 0.12456779f, 0.06574857f, 0.19752853f, 0.10699936f, -0.11575476f, 
    -0.22503795f, 0.05547199f, -0.22251444f, 0.01360507f, -0.01969960f, -0.12239309f, 0.01627212f, 0.03570146f, 
    -0.00159905f, -0.03769893f, 0.25295350f, 0.15360042f, -0.12428488f, -0.07741215f, 0.09775548f, -0.08165769f, 
    -0.05588314f, 0.12168366f, -0.04593372f, -0.01858952f, -0.04652457f, 0.07851865f, 0.00768231f, 0.04991746f, 
    -0.18591915f, -0.20658985f, -0.14587621f, 0.50420678f, 0.05028643f, 0.06667431f, 0.17545065f, -0.14110824f, 
    0.17124575f, -0.03562917f, -0.06133579f, 0.11728717f, -0.00085470f, 0.19361632f, -0.17879753f, -0.04101262f, 
    0.07784852f, 0.02274422f, 0.08437840f, -0.02031950f, 0.01377816f, 0.02143299f, -0.04220954f, -0.00194312f, 
    -0.62203181f, -0.28636515f, 0.03644134f, 0.07019767f, -0.02807404f, 0.21075478f, 0.14695139f, -0.01061574f, 
    -0.00007652f, 0.11107124f, 0.04096237f, -0.06198387f, -0.31791186f, -0.12248424f, -0.02686443f, -0.16339476f, 
    -0.17267402f, 0.12599686f, 0.02592289f, -0.31354848f, 0.05428459f, -0.04801947f, 0.18337214f, 0.00872063f, 
    0.41068026f, -0.34091836f, 0.22116154f, -0.45262870f, 0.26773196f, 0.01848549f, 0.00476491f, -0.09350390f, 
    -0.01308834f, -0.02541492f, -0.03220752f, 0.05830742f, -0.49584582f, -0.01821039f, -0.16848762f, 0.43408364f, 
    0.01222116f, 0.02529455f, 0.00257061f, 0.08404214f, 0.08107692f, 0.01093164f, -0.00996264f, -0.00437656f, 
    0.25404242f, -0.20537803f, -0.07730661f, -0.08181769f, 0.16812150f, 0.07099082f, -0.05225240f, 0.17871957f, 
    -0.04731359f, 0.29276469f, 0.15733857f, -0.00241221f, -0.16365752f, 0.00619900f, 0.07166960f, 0.08254297f, 
    -0.05923901f, -0.03997583f, -0.03043844f, 0.17442313f, 0.05079443f, 0.04015627f, 0.04292510f, -0.04012080f, 
    0.13171123f, -0.21795440f, -0.16916473f, -0.24862504f, -0.21035926f, 0.07854567f, 0.07676014f, -0.28142303f, 
    -0.00447614f, -0.01291959f, 0.06397534f, -0.02978504f, -0.00867955f, 0.07283020f, -0.12910339f, 0.03000034f, 
    -0.01378621f, 0.01510738f, -0.07194113f, 0.10490359f, 0.08986200f, 0.06246223f, -0.06400641f, 0.12714775f, 
    -0.55391705f, 0.41723865f, -0.01162372f, -0.25728464f, -0.12444757f, -0.02481422f, 0.03001726f, -0.18886518f, 
    -0.09579256f, 0.00132200f, 0.05661742f, 0.03200350f, -0.01151174f, 0.03793827f, -0.11100553f, -0.08859987f, 
    -0.00695100f, -0.01241852f, -0.05218561f, -0.00325962f, -0.16514899f, -0.14536048f, -0.10354146f, -0.17640938f, 
    -0.05214211f, 0.34517959f, -0.09218922f, -0.21999919f, 0.21003878f, -0.05484208f, -0.03608983f, 0.00449472f, 
    0.05665667f, 0.13197541f, 0.24012485f, 0.17231201f, -0.18004973f, -0.25068837f, 0.03172573f, -0.43761098f, 
    0.08639032f, -0.07369530f, -0.03848411f, -0.02866350f, 0.02997606f, 0.03730935f, -0.02060868f, -0.03720383f, 
    0.28120160f, 0.06974548f, -0.10683788f, -0.13935593f, -0.03523494f, 0.07946068f, 0.23033711f, 0.04351843f, 
    0.05893655f, 0.11611981f, 0.07325803f, 0.15607801f, -0.24870385f, 0.08448138f, -0.13084224f, 0.00876423f, 
    -0.03688104f, 0.00023550f, 0.06226484f, -0.00138033f, 0.04584983f, 0.12002012f, -0.03549291f, 0.05545152f, 
    0.23125729f, -0.18005852f, -0.00338475f, 0.09562131f, -0.06864951f, 0.22907816f, -0.28718224f, 0.24684805f, 
    0.10247475f, -0.10577268f, 0.12843175f, -0.08732363f, 0.18713330f, -0.41183147f, 0.24613376f, 0.03734163f, 
    0.00204105f, 0.06639457f, 0.13257855f, 0.01078124f, 0.00127166f, 0.00057588f, -0.07696077f, 0.06466933f, 
    -0.03628967f, -0.01843047f, -0.04652042f, -0.00118607f, -0.00228572f, 0.02744756f, -0.05761587f, 0.01616638f, 
    0.01042405f, 0.03087294f, -0.05188200f, -0.01208015f, 0.00745099f, -0.03223350f, -0.02552870f, -0.03283621f, 
    0.01836921f, 0.03889902f, 0.02267695f, 0.02542705f, 0.02375312f, 0.03959407f, -0.03828831f, -0.02898948f, 
    -0.00049472f, 0.03237971f, -0.05095961f, 0.02358164f, 0.03566591f, 0.03147045f, -0.00581955f, 0.03769312f, 
    0.03338055f, 0.01181008f, -0.02982073f, -0.00910801f, -0.04150512f, -0.02053106f, 0.02536940f, -0.05065068f, 
    -0.05333155f, -0.05918058f, 0.02937827f, 0.00050885f, -0.04642343f, -0.03038269f, -0.05627838f, 0.02617853f, 
    0.03434159f, -0.01405300f, -0.04912860f, 0.03684156f, -0.03914838f, 0.02248670f, 0.03923631f, 0.03856276f, 
    0.01019109f, -0.00448783f, -0.04712658f, -0.01788362f, 0.02336646f, 0.03744449f, -0.02690556f, -0.02924868f, 
    -0.04130007f, -0.05854632f, 0.01212738f, 0.02785225f, -0.04369267f, 0.01230833f, 0.01204463f, 0.01439049f, 
    0.01516410f, -0.04630081f, 0.01998402f, 0.03658865f, -0.04035354f, -0.00467647f, -0.00507208f, -0.04279167f, 
    0.02482343f, 0.03146442f, -0.01481216f, 0.00369173f, -0.00415751f, -0.04096126f, 0.03554839f, 0.00966241f, 
    -0.03276223f, -0.00173657f, 0.00131165f, 0.04309683f, -0.05835829f, -0.02563304f, 0.01711913f, -0.02994859f, 
    -0.00930958f, -0.00444895f, -0.02346452f, 0.00487657f, 0.02576273f, -0.03274614f, -0.03052158f, -0.02570781f, 
    0.03029343f, -0.01920711f, -0.02552794f, 0.00966005f, -0.00826898f, -0.02610231f, 0.00343976f, -0.04136939f, 
    0.02762124f, 0.02607734f, -0.03181740f, -0.04484165f, -0.02138280f, -0.04744348f, -0.02553741f, -0.01589428f, 
    -0.03798103f, -0.01478286f, -0.00086366f, -0.00926153f, -0.03988098f, -0.03760708f, 0.00294701f, -0.03336677f, 
    0.03182075f, 0.02033863f, 0.01875648f, -0.04465448f, -0.03357277f, -0.03363485f, -0.00705969f, 0.00410859f, 
    -0.00666474f, -0.02003985f, 0.01070962f, 0.00931959f, -0.02869468f, -0.05176462f, 0.02315716f, -0.04719755f, 
    -0.03334703f, -0.03236150f, -0.01452581f, 0.00780726f, 0.02126801f, 0.01135045f, 0.00798051f, 0.01944475f, 
    -0.01834282f, 0.03037022f, -0.00223811f, 0.01644151f, -0.00529985f, 0.03006045f, -0.03107129f, 0.02043409f, 
    0.02253506f, 0.01896293f, -0.01360142f, -0.02902741f, -0.03569993f, 0.03097917f, 0.01711740f, 0.01686254f, 
    -0.03431036f, 0.01800139f, -0.00860405f, -0.03430262f, 0.03118226f, 0.01670015f, -0.01023229f, 0.00707738f, 
    -0.03255412f, 0.00362177f, 0.03569277f, 0.00851088f, 0.02516298f, -0.01743832f, 0.02962632f, 0.04008377f, 
    0.04109522f, -0.04646282f, -0.05479727f, 0.00194489f, 0.00965352f, 0.01584364f, -0.05395906f, -0.03583765f, 
    0.01629739f, 0.00733188f, 0.01766823f, -0.03391350f, 0.01995661f, -0.04648340f, -0.04124840f, -0.01544115f, 
    0.02854250f, 0.00930741f, -0.04049575f, 0.00723229f, 0.00993432f, -0.01357353f, -0.00246629f, -0.01299861f, 
    0.00448704f, 0.02462124f, 0.03791566f, 0.01329202f, -0.02750782f, -0.03843766f, 0.00538188f, -0.04847117f, 
    -0.04328075f, 0.00710031f, -0.04804500f, -0.04076278f, -0.04404378f, 0.03083571f, -0.00496811f, 0.00697479f, 
    0.00088146f, -0.02792875f, -0.00547897f, -0.03165807f, -0.02082388f, 0.01671342f, -0.00343348f, 0.02842160f, 
    -0.03632595f, 0.00193238f, 0.04364106f, -0.01181154f, -0.02967325f, -0.00745708f, 0.02023360f, 0.00750731f, 
    -0.04052244f, 0.01418631f, 0.03898117f, 0.01535995f, 0.03801095f, -0.01597623f, 0.00859067f, -0.05049143f, 
    -0.04391646f, -0.02579277f, -0.03736830f, 0.01501870f, -0.00661172f, -0.04429395f, 0.01712721f, -0.03288988f, 
    -0.02603516f, 0.04148848f, -0.00951876f, -0.05673584f, -0.05207797f, -0.01196458f, 0.03095681f, -0.05932521f, 
    -0.02505036f, -0.00679287f, 0.02908923f, -0.00444690f, -0.01415582f, -0.04806762f, -0.02453591f, 0.01023910f, 
    0.01937381f, -0.03086263f, 0.03971588f, 0.03568961f, 0.00112445f, 0.01835929f, -0.01661991f, -0.04154632f, 
    0.00071792f, 0.01998502f, -0.04607748f, -0.04146637f, -0.02051654f, -0.01069091f, 0.02759540f, 0.02615143f, 
    -0.01931577f, -0.03930549f, -0.01866520f, 0.00038148f, 0.04089322f, -0.05380719f, 0.04366694f, -0.03007890f, 
    0.00545150f, -0.04939858f, -0.04625718f, -0.01815144f, -0.05086679f, -0.05671991f, 0.00062561f, -0.01503697f, 
    -0.02965311f, 0.02130784f, -0.02851977f, 0.00945461f, 0.00794131f, 0.03419667f, -0.04275488f, -0.05757685f, 
    -0.04108243f, -0.01010983f, -0.05380359f, -0.02771846f, -0.02205228f, 0.04290709f, -0.03878120f, -0.00116809f, 
    -0.01485823f, 0.03600378f, -0.04736169f, 0.03875604f, 0.00412827f, -0.02515244f, -0.03693929f, -0.05080223f, 
    -0.01055533f, 0.02485333f, 0.00359841f, -0.00836350f, -0.01075854f, -0.02714017f, -0.01432775f, 0.04426416f, 
    -0.04493254f, 0.01986895f, -0.01949702f, 0.01000440f, -0.04413659f, 0.03752488f, -0.00992394f, -0.00421070f, 
    0.01205190f, 0.01501302f, 0.01781724f, -0.05786316f, -0.05013803f, 0.01037248f, 0.00319695f, -0.03351801f, 
    -0.05349513f, 0.03927554f, 0.04085503f, 0.02927382f, -0.01652483f, 0.00502731f, 0.01504782f, -0.04029141f, 
    -0.01974932f, -0.01336763f, 0.01233291f, -0.00916714f, -0.01188744f, 0.01368563f, -0.02694936f, 0.03606600f, 
    0.02567826f, -0.04615196f, 0.00366094f, -0.05443711f, 0.01893299f, 0.00967323f, -0.00661974f, -0.02765108f, 
    -0.04181344f, -0.04066633f, 0.01613843f, 0.02938588f, -0.02935988f, -0.01499989f, -0.04698317f, -0.05655313f, 
    0.02146120f, 0.33040473f, 0.20293973f, -0.22401595f, 0.10822253f, 0.14343899f, 0.22398648f, 0.01789829f, 
    -0.06650230f, -0.03023537f, 0.04017939f, -0.01150054f, -0.06752923f, 0.13774459f, 0.30920109f, -0.04149253f, 
    -0.10078934f, -0.02868230f, -0.05092564f, 0.03403468f, 0.21921465f, -0.09139662f, -0.13436444f, -0.07727708f, 
    -0.15628423f, -0.04538246f, -0.19963835f, -0.02850202f, 0.15026937f, 0.02888500f, 0.07842781f, 0.03470606f, 
    0.08467234f, 0.05156656f, 0.10425952f, 0.14598003f, -0.09138999f, 0.04594203f, -0.33848497f, 0.02734597f, 
    0.03988414f, -0.08619536f, 0.22468576f, -0.04505784f, -0.13073328f, 0.04054746f, 0.01672008f, -0.04929890f, 
    0.00363659f, -0.03295708f, -0.03249815f, 0.00398902f, -0.00246412f, 0.10294420f, 0.06757464f, 0.04854866f, 
    0.11898657f, 0.06421579f, -0.02056217f, 0.05480707f, -0.34287846f, 0.30174899f, -0.20063917f, -0.36978203f, 
    -0.05223471f, 0.21731907f, 0.11251517f, 0.07216412f, -0.05486140f, 0.17339092f, 0.03787953f, -0.06539548f, 
    0.21797997f, -0.17892461f, 0.13364397f, -0.06689244f, 0.08688182f, -0.01582954f, -0.05371146f, 0.21045145f, 
    0.14682835f, 0.11022774f, 0.04943350f, 0.00892073f, 0.06974997f, 0.24527964f, -0.04065760f, -0.05554536f, 
    -0.14442620f, -0.07757404f, -0.02096986f, -0.17708321f, 0.08353381f, 0.03878726f, 0.04016576f, 0.20320021f, 
    0.11904097f, -0.28825137f, 0.14164804f, 0.02141155f, 0.05116236f, 0.04431277f, 0.18646242f, -0.11638557f, 
    0.04113709f, -0.15473700f, -0.02579097f, -0.12411354f, 0.13633785f, 0.10389469f, 0.03111473f, -0.35323253f, 
    0.07515809f, -0.07780877f, -0.08075476f, 0.06550132f, 0.07791561f, -0.02363809f, 0.16879471f, -0.01827647f, 
    -0.08810635f, -0.01611534f, -0.14687948f, 0.20643722f, -0.01032004f, -0.15937634f, 0.01783161f, -0.01924220f, 
    0.05989457f, 0.12510756f, -0.13470070f, 0.04953252f, -0.20064749f, 0.16576004f, 0.15414011f, -0.05260106f, 
    0.24093993f, 0.10847307f, -0.04824893f, -0.05237704f, 0.19209594f, 0.04471887f, 0.05035908f, 0.09639669f, 
    0.23676872f, -0.16842033f, 0.19243538f, -0.09439402f, 0.00672137f, -0.12011739f, 0.07579692f, -0.02502775f, 
    0.04206434f, 0.00625322f, -0.03535566f, -0.11420019f, 0.34764019f, -0.05429445f, -0.08096090f, 0.03340049f, 
    -0.01724218f, -0.07886517f, 0.10654239f, -0.04460403f, 0.12795238f, -0.05728682f, 0.01349941f, -0.04385999f, 
    0.06437083f, -0.07190958f, 0.06228778f, -0.27902317f, 0.10753763f, -0.00291409f, -0.06728067f, 0.24440944f, 
    -0.00752980f, 0.03409398f, -0.01413318f, -0.04511713f, 0.24171880f, -0.06882760f, -0.04326575f, -0.15830520f, 
    -0.02105454f, 0.02466458f, 0.06237723f, 0.06579288f, 0.01007212f, 0.00744373f, 0.01805583f, 0.03452282f, 
    -0.10312437f, 0.43195418f, -0.11691793f, 0.16964735f, -0.15185887f, -0.15920050f, -0.16148677f, 0.08402389f, 
    0.06975123f, -0.11746643f, 0.01424391f, 0.15688877f, 0.04489559f, 0.12108860f, 0.01305448f, -0.16229658f, 
    0.16086034f, 0.06182391f, -0.00343162f, 0.08202214f, -0.01933729f, 0.06331670f, -0.10277570f, -0.09507278f, 
    -0.07694983f, 0.37600219f, -0.38378826f, -0.14011630f, -0.01329842f, -0.08317435f, -0.03930174f, 0.04970750f, 
    0.07786340f, -0.06724105f, 0.06319138f, -0.05852707f, 0.21668255f, -0.10104322f, 0.20106269f, -0.42888027f, 
    -0.06458670f, 0.01684008f, -0.11449027f, 0.01265309f, -0.01296119f, -0.18788140f, -0.10025372f, 0.02482009f, 
    -0.44993496f, -0.03247848f, 0.12905915f, 0.41538024f, 0.10032449f, 0.08277492f, 0.08934147f, -0.04472416f, 
    0.08822840f, -0.07286966f, -0.08669993f, -0.04939945f, 0.11749043f, -0.14870162f, 0.02813278f, -0.01749440f, 
    0.08378607f, 0.16416577f, 0.22375739f, -0.11217581f, 0.02001127f, -0.02621279f, 0.06781190f, 0.08520532f, 
    0.09029950f, 0.20761284f, 0.37975213f, -0.12607950f, 0.03552809f, 0.05783064f, 0.05471838f, 0.13363694f, 
    0.09493990f, -0.07752644f, 0.05596727f, 0.02601286f, -0.18726103f, -0.28235254f, 0.29003048f, 0.04856623f, 
    0.07308897f, 0.13850467f, 0.15185949f, 0.07235171f, -0.02138812f, -0.07780482f, 0.11814251f, -0.19401239f, 
    0.17537698f, -0.15188946f, 0.33896708f, -0.29524988f, -0.05468391f, -0.02299480f, -0.02172197f, 0.02507217f, 
    0.03918975f, -0.01701569f, -0.11478364f, -0.02796620f, 0.03064672f, -0.07700410f, 0.09970926f, 0.23521401f, 
    -0.08334345f, -0.11959514f, 0.08595394f, -0.13894738f, 0.12547331f, 0.00731870f, 0.12547326f, 0.16240348f, 
    0.05190989f, -0.12656069f, 0.16689554f, 0.15598913f, -0.04851217f, 0.03099580f, 0.00502798f, 0.04375733f, 
    -0.10367591f, -0.09640954f, -0.11196195f, -0.08864777f, -0.30120566f, 0.27372125f, -0.07660131f, 0.24317975f, 
    -0.03863303f, 0.22693463f, 0.07997305f, -0.01554104f, 0.00157530f, -0.12209237f, -0.00624467f, -0.00866842f, 
    -0.02982805f, 0.23458226f, -0.15347582f, 0.11833373f, 0.02716028f, 0.02172429f, 0.01931279f, -0.06819931f, 
    -0.04960474f, 0.07397728f, 0.07561161f, 0.02109138f, 0.45253208f, -0.38860372f, 0.06591590f, -0.04157247f, 
    0.01914085f, 0.04421372f, -0.10123275f, 0.02576688f, -0.11202736f, -0.08511775f, 0.04674369f, 0.01332405f, 
    -0.42393792f, 0.34690151f, -0.05499407f, -0.24256726f, 0.13517271f, -0.22771601f, 0.20107055f, -0.15176685f, 
    0.14603612f, 0.05063195f, -0.10050110f, 0.07568698f, -0.01226338f, 0.34156802f, -0.18930505f, -0.18433654f, 
    0.20118621f, 0.00622960f, 0.02300963f, 0.14831620f, 0.04753947f, 0.12151280f, 0.11527152f, 0.08991738f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06379567f, 0.05150725f, 0.17587195f, 0.08108807f, 0.14810854f, -0.00231121f, -0.06395261f, 0.01467988f, 
    -0.03868689f, -0.01359446f, 0.16391180f, 0.08823980f, 0.01141968f, 0.08744720f, 0.00407350f, -0.04816079f, 
    -0.16776101f, 0.15942721f, -0.04681353f, 0.01418162f, 0.21405026f, 0.01725246f, 0.04741716f, 0.00216737f, 
    0.02073338f, 0.00750683f, 0.12882398f, 0.06181078f, -0.03554055f, 0.04254888f, 0.02119836f, 0.21805486f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15258533f, 0.35053450f, 0.09375231f, 0.24892437f, -0.04280848f, -0.09010889f, -0.22857188f, 0.13964784f, 
    -0.10522687f, -0.16538429f, 0.21765327f, 0.36202785f, -0.05719205f, -0.07597986f, 0.17223400f, -0.06944007f, 
    0.12481300f, 0.10306273f, 0.02013707f, -0.14663957f, 0.11757018f, 0.12137950f, -0.11786027f, 0.14680371f, 
    -0.58487344f, -0.03139354f, 0.03067166f, -0.02399982f, -0.15184988f, 0.06568567f, 0.16628602f, -0.09544629f, 
    -0.17277709f, 0.09249555f, -0.24068564f, 0.26591071f, 0.13742162f, 0.14538471f, -0.11915785f, 0.11249682f, 
    -0.11283577f, 0.11860251f, 0.03041928f, -0.05479578f, -0.01450744f, 0.31329963f, -0.15304220f, 0.09856202f, 
    0.40532991f, -0.04959011f, 0.06739111f, -0.02854912f, 0.28664017f, -0.11483751f, -0.07800452f, 0.12870935f, 
    0.21094102f, 0.24771331f, -0.06500069f, -0.27940720f, -0.08540374f, -0.49491450f, 0.16509333f, 0.46625718f, 
    -0.41142660f, 0.02130339f, 0.14637597f, -0.01713313f, -0.46528119f, -0.02571073f, 0.26993552f, 0.14081599f, 
    0.17521198f, 0.13727018f, -0.29225156f, -0.41637793f, -0.04074945f, 0.05531469f, -0.07158987f, -0.00002474f, 
    0.15692712f, -0.08411157f, -0.13156174f, 0.09324042f, 0.07743069f, -0.10804960f, 0.00781883f, -0.12893070f, 
    0.18278854f, 0.09190426f, -0.10732204f, 0.25704825f, 0.02382987f, -0.43543670f, -0.05451058f, 0.09671755f, 
    -0.17472392f, 0.20679383f, 0.19612347f, 0.37191844f, -0.24038601f, -0.06044418f, 0.13475308f, 0.15082115f, 
    0.32097477f, 0.05003658f, -0.08792786f, -0.28871101f, 0.11620450f, -0.00568866f, -0.11319234f, 0.14492513f, 
    -0.07345635f, 0.01470248f, 0.13101290f, -0.02810539f, 0.13611804f, 0.02368299f, -0.04801120f, -0.00798458f, 
    -0.14459111f, 0.44206625f, 0.39883316f, 0.33871806f, -0.08851426f, 0.26804158f, 0.15071957f, -0.19284576f, 
    -0.04501497f, -0.03306638f, 0.18737598f, 0.20673363f, 0.10323621f, -0.12068199f, 0.01936685f, 0.11937869f, 
    -0.13213718f, -0.03857915f, 0.10808170f, 0.01742171f, -0.12992293f, 0.12596375f, 0.04311460f, 0.09883462f, 
    -0.25079694f, 0.39150870f, 0.09690329f, 0.06903205f, 0.00998219f, -0.04406056f, -0.07003259f, -0.11659228f, 
    -0.41343373f, 0.32218307f, -0.21185671f, 0.31121391f, -0.11843713f, 0.44635794f, -0.03454139f, -0.24150059f, 
    -0.27365309f, 0.27913460f, 0.10310823f, 0.20501247f, 0.05305341f, -0.00096752f, -0.01340950f, 0.04643393f, 
    -0.17099279f, -0.06534428f, 0.20869568f, 0.14422229f, 0.07880220f, 0.36571607f, -0.17867303f, 0.11594183f, 
    -0.33549079f, 0.28435269f, 0.10940352f, -0.09046018f, 0.23070000f, 0.02150932f, -0.17696808f, 0.09498794f, 
    -0.30661473f, -0.03878389f, -0.13607126f, 0.14353019f, 0.04570730f, 0.12256111f, 0.16841973f, 0.31097835f, 
    -0.22370034f, 0.21828844f, 0.19532226f, 0.09645372f, 0.00395378f, 0.03085565f, 0.28853267f, 0.12782969f, 
    -0.31905735f, -0.03271580f, 0.22949463f, 0.41193271f, -0.10065717f, -0.27802956f, 0.12547849f, -0.09741418f, 
    0.23176256f, -0.22908905f, -0.09346405f, -0.16333579f, -0.04514033f, -0.08624324f, 0.04302923f, -0.00038400f, 
    -0.16618554f, -0.34647250f, 0.17303693f, -0.07060817f, -0.13276650f, -0.25130799f, -0.13336794f, 0.11447975f, 
    -0.30628979f, -0.09660482f, 0.25396684f, 0.21999939f, -0.05836636f, -0.01742061f, -0.15885027f, 0.05382572f, 
    0.07211831f, 0.13032454f, -0.05212449f, -0.05727858f, -0.17620900f, 0.14101502f, -0.15773557f, 0.03119745f, 
    0.01408589f, -0.15021224f, 0.12023088f, 0.01513830f, -0.04324282f, -0.14465597f, -0.17933221f, 0.04249068f, 
    0.12708706f, -0.20352495f, 0.09723464f, -0.18890810f, -0.12636308f, 0.02683362f, -0.09486450f, 0.01914371f, 
    0.21822168f, -0.11049709f, 0.28629246f, 0.01520252f, -0.24778971f, -0.05070182f, 0.04656553f, 0.14434956f, 
    -0.29184762f, -0.04932989f, 0.14746705f, 0.32021323f, 0.08080716f, -0.03599476f, 0.09731393f, -0.08884765f, 
    -0.08900114f, -0.06137215f, 0.16877687f, 0.11507461f, 0.39450437f, -0.00698384f, 0.09450668f, 0.10235076f, 
    -0.03766046f, 0.33478311f, 0.28994870f, -0.24679573f, -0.03119820f, 0.16164216f, -0.09223675f, -0.49829477f, 
    0.30630311f, -0.06861646f, -0.08997363f, -0.24521418f, -0.07427988f, -0.03815163f, -0.34043923f, 0.01428940f, 
    0.16549772f, 0.01308902f, 0.36269414f, -0.04072093f, 0.04804302f, -0.11126666f, -0.10474161f, -0.14240377f, 
    -0.03844529f, -0.27669182f, -0.14169893f, -0.11954656f, 0.06804595f, 0.18894102f, 0.09634516f, 0.04579652f, 
    -0.27381772f, -0.00025284f, 0.28939188f, -0.05144128f, 0.08341262f, 0.01400180f, -0.16021790f, 0.32503518f, 
    -0.02495114f, 0.04901033f, 0.21573158f, -0.00005363f, -0.34126511f, 0.12409499f, 0.21042126f, -0.10335027f, 
    -0.01857671f, -0.11988043f, 0.00884702f, -0.05796927f, 0.13113660f, 0.22390550f, -0.13572164f, 0.09228510f, 
    -0.05842381f, -0.37803638f, 0.06416144f, 0.14432637f, 0.14519671f, 0.02003055f, 0.29484197f, 0.05810908f, 
    -0.24024673f, -0.05736073f, -0.22043960f, -0.01854864f, -0.03516747f, -0.14830579f, -0.00961542f, -0.14112480f, 
    0.20183776f, -0.08997083f, -0.35183284f, 0.10973331f, 0.14000875f, 0.03693636f, 0.25138453f, 0.06776027f, 
    -0.26758626f, -0.17587410f, -0.19917598f, 0.19776794f, 0.15220979f, 0.29200664f, 0.01406714f, 0.14745225f, 
    0.35355601f, 0.18039499f, -0.08881971f, 0.01153050f, 0.29537407f, 0.10213226f, 0.18744004f, 0.05300470f, 
    0.44435528f, 0.06460350f, -0.29210648f, -0.24601091f, -0.06562995f, -0.14148474f, -0.02870088f, -0.14570503f, 
    -0.23927371f, -0.16863789f, 0.23894386f, 0.48311678f, -0.16518694f, -0.10957751f, 0.19766039f, 0.04614671f, 
    -0.26333141f, -0.02165826f, 0.05085512f, 0.43824902f, -0.09927222f, 0.17151627f, 0.08365273f, -0.02509855f, 
    -0.43401915f, 0.08373021f, -0.14980027f, -0.13212647f, 0.16863874f, -0.17009120f, 0.10996594f, -0.09324875f, 
    -0.17830828f, -0.13289796f, 0.17515041f, 0.02453442f, -0.03918047f, 0.13827100f, -0.06896637f, -0.13958460f, 
    -0.05518077f, 0.08461872f, 0.07391806f, -0.10457161f, 0.32519117f, 0.07563087f, -0.12942168f, -0.02528226f, 
    -0.23874670f, 0.05910096f, 0.34802330f, 0.07042368f, -0.12778313f, 0.09915733f, 0.09756191f, -0.16837409f, 
    0.08876330f, 0.44462413f, 0.02756638f, -0.11493184f, 0.02070899f, 0.07288029f, 0.27647179f, -0.00786117f, 
    -0.26556021f, -0.28536755f, -0.44941825f, -0.16061623f, -0.11537008f, 0.19162193f, 0.05994184f, 0.31040603f, 
    -0.24921414f, -0.04813810f, -0.24058436f, 0.50186503f, 0.18556836f, -0.12717913f, 0.09305755f, 0.07986644f, 
    -0.45589706f, 0.16037969f, 0.12799850f, -0.18641222f, 0.09009189f, 0.47179052f, 0.13207291f, -0.07175395f, 
    0.34681690f, 0.39216706f, 0.07439230f, 0.01202047f, 0.15975296f, 0.11985701f, 0.02173087f, -0.07412377f, 
    0.25779718f, 0.23236153f, -0.33801329f, -0.14669274f, -0.15742674f, -0.06717255f, -0.05385889f, -0.02133809f, 
    0.12614714f, 0.02475630f, -0.09621754f, -0.06691764f, -0.00356462f, 0.04012416f, -0.05927980f, 0.17142573f, 
    -0.28862619f, -0.06344248f, -0.17108001f, -0.03722058f, -0.02839758f, -0.13683324f, 0.09635033f, 0.12341742f, 
    0.40618607f, 0.07062900f, -0.10854736f, -0.04101365f, -0.01180878f, -0.05585351f, 0.32585502f, 0.05477655f, 
    0.18774962f, -0.13204513f, 0.21159208f, 0.09923283f, -0.09160300f, 0.53958207f, 0.11947124f, -0.38118866f, 
    0.01409294f, -0.13380681f, -0.28796327f, -0.00823432f, 0.29159683f, -0.16242878f, 0.11402613f, 0.06900126f, 
    -0.20070882f, 0.02572484f, -0.02247885f, -0.25998241f, 0.00820491f, -0.05332612f, -0.07692485f, 0.02665206f, 
    0.32542467f, 0.45003074f, -0.04286942f, 0.12708150f, -0.10404595f, -0.16668320f, 0.25225154f, 0.15938069f, 
    0.23391563f, 0.03090121f, -0.19197200f, 0.22314897f, -0.00644371f, 0.46889943f, -0.01133517f, -0.09089682f, 
    -0.10370019f, 0.18277110f, 0.01810408f, -0.28316966f, -0.02620852f, -0.05810870f, -0.10554720f, -0.16861598f, 
    -0.18769579f, -0.00636554f, -0.15146834f, 0.15768699f, 0.02524163f, -0.39304593f, 0.04423468f, -0.04875972f, 
    0.29216477f, 0.00773389f, 0.08189691f, 0.02946337f, -0.43238834f, 0.16855076f, 0.24081987f, 0.17701899f, 
    0.10650898f, -0.53335994f, 0.04657161f, 0.14231224f, 0.09920780f, -0.10601507f, -0.12053606f, 0.17489006f, 
    -0.25852165f, 0.27906930f, 0.17887327f, -0.46370506f, 0.27284983f, 0.02083650f, 0.32137012f, 0.13126567f, 
    0.00512106f, -0.15586068f, 0.12009744f, 0.05969612f, -0.10165225f, -0.21353810f, 0.06118824f, 0.11065050f, 
    0.06668822f, 0.23141021f, -0.13916995f, -0.00693689f, 0.03883224f, 0.04863042f, 0.27305871f, 0.04992200f, 
    0.29030153f, -0.36097112f, 0.14152128f, -0.07032511f, -0.15388235f, -0.08179151f, -0.03578906f, 0.48837712f, 
    -0.36277589f, 0.17165624f, -0.20747371f, 0.57419801f, -0.11166431f, 0.05901833f, 0.08708331f, 0.11289130f, 
    -0.20699202f, -0.09608764f, -0.03379303f, 0.36330426f, -0.12142383f, -0.06329890f, -0.09917752f, -0.17199382f, 
    0.22352794f, -0.25503880f, -0.06422837f, -0.12499379f, 0.13332412f, 0.14689045f, 0.09187526f, 0.17121041f, 
    -0.01480383f, 0.24284919f, 0.46718013f, -0.00754788f, 0.00788217f, -0.30840534f, -0.06317533f, -0.02498588f, 
    0.27105221f, -0.37639716f, 0.23794371f, 0.28559896f, -0.12426978f, -0.10577933f, -0.09639756f, -0.11679769f, 
    0.00832293f, 0.15580684f, -0.07609047f, -0.09314259f, -0.01108082f, 0.27211809f, 0.17091742f, 0.10013813f, 
    -0.35082763f, 0.22390793f, -0.05183748f, 0.03565755f, 0.23520628f, 0.16015247f, 0.03220474f, 0.12855373f, 
    0.33136523f, 0.01474411f, 0.12071832f, 0.28885418f, -0.03662035f, -0.39948305f, -0.11490080f, 0.11281303f, 
    -0.02501747f, 0.09932964f, 0.20381960f, -0.13790287f, -0.22422805f, -0.15157646f, 0.32845035f, -0.08384009f, 
    0.01544327f, -0.01926171f, -0.27531534f, 0.21610646f, 0.04690677f, -0.12699451f, 0.08836278f, 0.05672858f, 
    0.18339694f, -0.10891072f, -0.01420832f, -0.08326948f, -0.03437540f, -0.07068045f, 0.41073450f, -0.08459105f, 
    0.20486161f, -0.26611435f, -0.07304183f, 0.35955429f, 0.00091368f, -0.37016240f, 0.01986129f, 0.25028175f, 
    0.00613470f, -0.19979274f, 0.32427353f, 0.41183984f, 0.12943545f, 0.10201325f, -0.22161865f, 0.15686108f, 
    0.01083526f, 0.10540263f, 0.29340157f, -0.02327311f, -0.06789006f, -0.02396053f, 0.04985405f, 0.13668856f, 
    0.03750656f, -0.11310519f, 0.04435112f, -0.05742760f, -0.09428410f, 0.08064833f, 0.21848574f, -0.08373290f, 
    -0.27098227f, 0.11298800f, -0.39669368f, 0.26371175f, -0.01830379f, -0.22685546f, -0.00870464f, 0.13168459f, 
    0.17305070f, -0.18842767f, 0.17300157f, -0.03551910f, -0.45516664f, -0.09491470f, -0.01229923f, -0.00263002f, 
    -0.07045594f, 0.15211336f, -0.24000126f, 0.13801864f, -0.08548358f, 0.17228280f, -0.06093241f, 0.12718861f, 
    -0.16602726f, 0.25611308f, -0.10159551f, -0.08591923f, 0.37735045f, 0.02454643f, -0.04126043f, -0.07551792f, 
    0.57237899f, 0.46591318f, 0.32601482f, 0.07263105f, -0.17958479f, 0.12861398f, -0.12627585f, -0.38856754f, 
    -0.04259906f, -0.21136615f, 0.23732893f, 0.07022019f, 0.10147917f, -0.02202577f, -0.16372712f, 0.09242427f, 
    -0.08896831f, -0.01732816f, 0.14719449f, -0.17410600f, 0.03961284f, 0.17090724f, -0.13973087f, -0.09082457f, 
    0.05916798f, 0.37555146f, 0.04322389f, -0.05567409f, -0.13496098f, 0.06764188f, 0.25796893f, -0.03561221f, 
    -0.34769186f, -0.08549123f, -0.09353258f, 0.23868726f, 0.11054379f, 0.57195288f, 0.12763914f, -0.00857123f, 
    -0.14599992f, 0.13117415f, -0.22068565f, 0.00067704f, 0.15250185f, 0.12463102f, -0.07932841f, -0.17361023f, 
    -0.17123944f, -0.09194299f, -0.07604537f, 0.19906129f, -0.05569798f, 0.28914148f, -0.00023902f, 0.03452432f, 
    0.01985764f, 0.20713140f, -0.02183445f, 0.04429376f, 0.32509276f, 0.00925567f, -0.02290257f, 0.01462789f, 
    0.04552508f, 0.12528098f, 0.00539579f, -0.42563194f, 0.09502804f, -0.21388073f, -0.08963555f, 0.40947402f, 
    -0.04361040f, -0.15042649f, 0.04295278f, -0.05408047f, -0.10198945f, 0.02835928f, 0.14293081f, 0.05477746f, 
    -0.15125775f, -0.07633049f, 0.09774940f, 0.09626207f, -0.00595865f, 0.09531552f, -0.01279676f, 0.01516510f, 
    -0.24125563f, -0.10371039f, 0.09031474f, 0.04672677f, -0.01385529f, -0.01304512f, -0.12364041f, -0.02014490f, 
    0.17978355f, -0.08618892f, 0.16784549f, 0.06986326f, 0.08574703f, 0.02725854f, -0.04849587f, 0.00314214f, 
    0.13881655f, -0.06970031f, -0.10631290f, 0.41561055f, -0.30248228f, 0.10744978f, 0.02376214f, 0.05157603f, 
    0.32753873f, 0.17115887f, 0.02370695f, -0.03071032f, -0.02933045f, 0.20574135f, 0.18098587f, -0.09015718f, 
    0.00439606f, -0.20396653f, -0.06215538f, 0.04086571f, -0.06787388f, 0.07986197f, 0.01915485f, -0.09481790f, 
    0.04476241f, 0.49382752f, 0.42681891f, 0.01516341f, 0.05983622f, 0.16803676f, -0.04254914f, -0.06930654f, 
    0.24469721f, -0.07227331f, -0.04084905f, -0.13156156f, 0.20300385f, -0.02196351f, -0.21287328f, 0.05634593f, 
    0.11687054f, 0.05529405f, 0.04315958f, 0.16953680f, 0.01634174f, 0.10532978f, -0.05055122f, -0.08409163f, 
    -0.26103720f, 0.42647532f, 0.15612043f, 0.12685230f, 0.18557721f, -0.03589952f, -0.04180369f, -0.03939938f, 
    0.57148308f, -0.04063090f, 0.12800930f, 0.13831790f, 0.14813025f, 0.02681120f, 0.15982199f, 0.27418008f, 
    0.08217234f, 0.03101879f, 0.18563858f, -0.37319672f, 0.20746621f, 0.01046435f, -0.04755899f, 0.04196087f, 
    -0.04717774f, -0.15379883f, 0.21648484f, -0.46231997f, 0.16708170f, 0.14289747f, 0.15354997f, -0.06263224f, 
    -0.32000509f, 0.49439496f, -0.15519160f, 0.11353187f, 0.10400513f, 0.12005851f, 0.04841734f, 0.02173679f, 
    -0.03832528f, -0.02974431f, 0.00858716f, 0.14144608f, 0.06313046f, -0.21801266f, 0.12206909f, 0.62044138f, 
    0.31448328f, -0.03819953f, 0.24647984f, -0.24345870f, 0.01505929f, 0.11028663f, -0.13018325f, -0.06955069f, 
    -0.25185496f, 0.15393591f, 0.15601546f, -0.37278411f, 0.14918217f, 0.29702705f, -0.11831360f, -0.04510363f, 
    -0.13916719f, 0.03553805f, -0.07343302f, 0.16890764f, 0.33272210f, -0.07054730f, 0.01440841f, 0.10944238f, 
    -0.45236287f, 0.33251557f, 0.02340180f, -0.38358399f, -0.16317995f, 0.16379201f, -0.17635517f, -0.17470573f, 
    -0.15982521f, 0.09153717f, 0.23439120f, 0.47189638f, 0.04504661f, 0.06191823f, -0.28044701f, 0.01848780f, 
    -0.15471897f, 0.15806545f, 0.10662811f, 0.15025723f, 0.08962115f, -0.16548951f, 0.15087295f, 0.10756401f, 
    -0.19031034f, 0.08643088f, -0.16769265f, -0.04980370f, 0.00447152f, 0.10876896f, -0.07963917f, -0.03230935f, 
    0.01578191f, 0.04407156f, 0.26615703f, 0.23310831f, -0.03844004f, 0.04842138f, -0.00111490f, 0.31044781f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14283270f, 0.14832906f, -0.11900666f, 0.16126713f, -0.02667328f, 0.07357625f, 0.12717520f, -0.07432900f, 
    0.09468088f, 0.33489332f, 0.06934739f, -0.06715466f, 0.04478622f, 0.14569828f, 0.11284816f, 0.14876452f, 
    0.11792776f, -0.07466447f, 0.26128298f, 0.13393076f, 0.14530396f, 0.17869957f, 0.29243565f, 0.22508675f, 
    -0.03173581f, -0.01938366f, 0.00837340f, 0.14202110f, 0.15803708f, 0.19828551f, 0.31264356f, 0.20207757f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.01370055f, -0.53624761f, 0.28626785f, 0.20622991f, -0.13395923f, -0.36208048f, 0.16014960f, -0.11152931f, 
    -0.48488808f, -0.21402843f, 0.10529213f, -0.35119703f, -0.41123727f, -0.34043306f, -0.87495345f, 0.21608634f, 
    -0.05035120f, 0.45618278f, 0.25700912f, -0.07915424f, -0.42151880f, 0.26088953f, -0.23326336f, -0.41133019f, 
    -0.10950936f, -0.15842251f, -0.08153843f, 0.07634868f, -0.13813175f, -0.05763711f, -0.05905689f, -0.09888837f, 
    -0.24193147f, -0.19052941f, 0.30289105f, 0.10786855f, -0.01643129f, 0.09681492f, -0.26089212f, -0.15701674f, 
    -0.20802440f, 0.19845922f, 0.10900179f, -0.55272603f, 0.01183201f, -0.24836679f, -0.62332284f, -0.32034576f, 
    -0.23766153f, -0.64593923f, 0.12296011f, -0.25245997f, 0.26261583f, 0.25078735f, -0.01809933f, 0.14340734f, 
    -0.03922443f, -0.23739128f, -0.00350250f, 0.17072028f, 0.20952789f, 0.32489964f, 0.44950128f, -0.00028848f, 
    -0.20059255f, 0.08132701f, -0.64306736f, 0.03245011f, -0.11751612f, 0.09170786f, -0.12113725f, -0.20609845f, 
    -0.25175023f, -0.35772207f, -0.72619992f, 0.17666306f, -0.03973761f, -0.11421221f, 0.11359052f, 0.12771682f, 
    0.19111353f, -0.79543191f, 0.24009512f, 0.24688493f, -0.00828463f, -0.33456084f, -0.91558218f, 0.20952432f, 
    -0.25978631f, 0.05140017f, -0.01600965f, 0.02765107f, 0.18471356f, 0.08913911f, -0.57898450f, 0.21893556f, 
    -0.40742993f, 0.03944445f, 0.27406016f, 0.17510629f, -0.30675730f, -0.40815046f, -0.06096631f, 0.01727852f, 
    0.15006942f, -0.16712682f, 0.26477167f, 0.09111515f, -0.04934694f, -0.43492848f, 0.22958429f, 0.24541253f, 
    -0.02766921f, -0.42261288f, -0.04972603f, 0.30131057f, -0.13991171f, 0.06924355f, -0.38998431f, 0.11318754f, 
    -0.14103690f, -0.56780535f, -0.11190842f, 0.32969856f, -0.48147467f, -0.32588828f, -0.29213408f, -0.46254840f, 
    0.24769120f, -0.18621919f, -0.19109794f, -0.32551724f, -0.22959743f, -0.25137067f, 0.13403451f, -0.08434272f, 
    -0.40195140f, 0.26118070f, 0.20605180f, 0.24807374f, -0.07269219f, 0.18445912f, -0.06997272f, 0.21232723f, 
    0.23709838f, 0.23605409f, 0.12136975f, 0.07214030f, -0.16719753f, 0.19534737f, 0.15153340f, -0.28637034f, 
    -0.10102510f, -0.17148034f, -0.16002190f, -0.06947379f, 0.00560674f, -0.15709421f, -0.63384670f, -0.34281021f, 
    0.16485627f, -0.28788248f, -0.30341119f, 0.06174519f, 0.09748383f, 0.17488424f, 0.25456658f, -0.16887471f, 
    -0.14872883f, 0.08223843f, -0.12395577f, -0.47676194f, 0.22676791f, 0.15652914f, -0.23920760f, 0.05515144f, 
    -0.06335007f, 0.11428367f, 0.03568102f, 0.26791948f, -0.05012019f, -0.03277316f, 0.41874886f, -0.41393679f, 
    0.21967338f, -0.40358669f, -0.12143381f, -0.05706648f, -0.24098092f, 0.09083713f, -0.41304287f, 0.34670070f, 
    0.17424740f, -0.09748529f, -0.09729945f, -0.31433475f, 0.07576952f, 0.08855501f, -0.28256768f, 0.05524732f, 
    0.40142876f, -0.12754788f, -0.19209658f, 0.00867384f, -0.03083493f, 0.23478319f, 0.09450739f, 0.17750914f, 
    0.15502559f, -0.09508880f, 0.07590243f, -0.61862749f, -0.25160345f, -1.08396971f, -0.53933018f, 0.03823671f, 
    0.17213035f, 0.07242879f, -0.02947078f, -0.30871552f, 0.03206111f, 0.01855366f, 0.40018764f, -0.23778844f, 
    0.19758335f, 0.58931166f, -0.40567094f, -0.12442566f, -0.39052412f, -0.18052185f, -0.22782712f, -0.00683570f, 
    -0.01321228f, 0.09994455f, -0.29428640f, 0.01550671f, -0.55903959f, -0.24428889f, 0.28675789f, -0.48586822f, 
    -0.05990412f, 0.14394492f, -0.43295801f, 0.19058464f, 0.15350381f, -0.60407323f, 0.02463400f, -0.08954056f, 
    -0.27072936f, 0.25271568f, 0.02504722f, 0.26335132f, 0.24991173f, -0.31718269f, -0.17341910f, 0.27231553f, 
    0.22431292f, -0.07262195f, -0.35816580f, 0.29415333f, 0.28822824f, 0.30166280f, -0.41360962f, 0.13900878f, 
    0.07782743f, -0.37222973f, 0.30304262f, -0.38364989f, 0.31101745f, -0.21550915f, -0.09312548f, -0.43774611f, 
    -0.40517697f, -0.14572705f, -0.66672564f, 0.07664890f, -0.04347166f, -0.68198228f, 0.06688345f, 0.12906416f, 
    -0.13128856f, -0.04665869f, 0.05754642f, 0.23950912f, -0.11536248f, -0.44256052f, 0.15878530f, 0.15929697f, 
    -0.23200467f, 0.35305014f, -0.21332382f, -0.53258741f, -0.35270351f, 0.06972207f, 0.12702624f, -0.18883617f, 
    -0.23666373f, 0.02934117f, 0.21709976f, 0.22723514f, -0.34016797f, 0.21377073f, 0.12392955f, -0.24509384f, 
    -0.10795570f, -0.49116448f, 0.21732315f, -0.43765497f, -0.07475461f, -0.07608890f, 0.20888793f, -0.39276883f, 
    -0.12895836f, 0.22749586f, -0.08695611f, -0.58958817f, -0.05098384f, 0.32107943f, -0.13644493f, -0.11384202f, 
    0.10667120f, -0.32953522f, -0.76559073f, -0.25582266f, -0.23895693f, -0.27944064f, 0.30885726f, -0.07486336f, 
    0.44252363f, -0.59778565f, 0.04472763f, 0.19717960f, 0.29756588f, -0.33803031f, -0.58819002f, 0.14224255f, 
    -0.52064860f, -0.05457288f, -0.00354554f, 0.13392153f, 0.21472193f, 0.17056073f, -0.27392867f, 0.37276748f, 
    -0.47719377f, -0.01715748f, 0.20422678f, -0.12722036f, 0.13176435f, -0.41988236f, -0.35542962f, 0.14397100f, 
    -0.54624850f, -0.51891220f, -0.27533594f, 0.06519032f, 0.27809539f, -0.30059057f, -0.55176413f, -0.19602263f, 
    -0.02394572f, -0.17417824f, -0.29308400f, -0.04434930f, -0.11225498f, 0.00711063f, -0.07910759f, 0.20974641f, 
    0.46266165f, -0.27636030f, -0.27500132f, -0.63967675f, 0.25232488f, 0.01594946f, 0.43438494f, 0.14447843f, 
    0.39830035f, -0.82720429f, -0.03857724f, 0.08904384f, 0.09874850f, 0.00071233f, -0.05417547f, 0.08460026f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.20126542f, 0.31208301f, 0.17220487f, -0.19584556f, 0.01460654f, 0.06376648f, 0.06104197f, -0.02444995f, 
    0.10152845f, 0.10800761f, -0.00044536f, -0.07246434f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
