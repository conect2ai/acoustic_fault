#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.22805727f, -0.40055582f, -0.24455716f, 1.06425691f, 0.67726135f, -0.51882595f, 0.43693513f, -0.30047959f, 
    -0.50413442f, -1.29391873f, 0.58766800f, 0.64632398f, -0.53646898f, 0.16293697f, 0.39306301f, 0.31886390f, 
    0.10762270f, -0.37932774f, 0.80961853f, -1.43699050f, -0.60600984f, 0.46513739f, 0.88899827f, 0.17716065f, 
    -0.24542700f, -0.27479270f, -0.06393722f, -0.18660749f, 0.54234344f, -0.91189069f, -0.56669760f, -0.62666827f, 
    -0.70264107f, -0.28178105f, -0.42528027f, 0.51259184f, -0.30415556f, -0.95699918f, -0.92822826f, 0.51090449f, 
    0.16836928f, 0.55226243f, 0.44193310f, 0.35089937f, -0.21450034f, -0.71935648f, -0.53930682f, -0.39036101f, 
    -0.79647094f, -0.78289473f, -0.70875764f, -0.30332214f, -0.73550975f, -0.78809184f, 0.76170027f, 0.05357122f, 
    -0.04272595f, 0.43403468f, 0.41181716f, 0.19833386f, -0.36025518f, 0.00935293f, -0.21399340f, -0.12164906f, 
    0.07445312f, -0.00930171f, 0.07261965f, 0.48592499f, 0.00582652f, -0.11517008f, 0.21604596f, 0.31037980f, 
    0.40042922f, -1.10768533f, -0.10014138f, -0.88357490f, -0.69930226f, -0.42701656f, 0.67434150f, -0.09931464f, 
    0.19098030f, -0.28317031f, 0.08494494f, 0.31678241f, -0.52744329f, -0.33585671f, -0.38803530f, 0.57250720f, 
    0.33470222f, 0.09924571f, 1.11902881f, -0.84257531f, -1.06713378f, 0.07821459f, 0.33413190f, 0.53997552f, 
    0.01245502f, -0.04864081f, -0.07001694f, 0.22202729f, -0.28096566f, 0.49112880f, 0.00899055f, -0.55805117f, 
    -0.24617358f, -0.40815490f, -0.23489289f, -0.63364726f, -0.91299337f, 1.06403553f, -0.38019368f, -0.80828249f, 
    1.15010393f, -0.46164060f, 0.11370897f, 0.05147865f, -0.31521419f, -0.94302267f, -0.36383644f, -0.29435715f, 
    0.46145982f, -0.94434583f, -1.12110329f, -0.27477062f, 0.37206635f, 0.58584464f, 0.70099068f, -0.16517365f, 
    -1.16895843f, 0.01450158f, 0.58141202f, -1.13714826f, -0.32032466f, -0.17342868f, -0.28347307f, -0.89159280f, 
    -0.40097347f, -1.05651343f, -0.14242743f, 0.44849372f, 0.50614554f, -0.42592812f, -0.58211958f, -0.66879439f, 
    0.07434838f, -0.69785225f, 0.54729569f, -0.06248283f, 0.53313816f, 0.61960500f, -0.17450000f, -0.35788900f, 
    -0.51494497f, 1.06616604f, 0.05153106f, 0.12473080f, -0.41979551f, 0.22342078f, -0.56512767f, -0.05757756f, 
    -0.25993735f, 0.44504002f, -0.62441355f, -0.66728288f, -0.57524461f, 0.06232219f, 0.12781493f, -0.36442834f, 
    -0.28629965f, -0.52860820f, -0.46215761f, -1.40297914f, 0.39762080f, -0.19578984f, 0.09870108f, -0.05258831f, 
    0.89748055f, -0.54168403f, 0.39923707f, -0.20906575f, 0.32665998f, -0.40195900f, -0.28365806f, -0.57249731f, 
    0.60253620f, -0.30700141f, -0.05013376f, 0.44145340f, 0.39877534f, 0.55393660f, 1.08312607f, -0.00725874f, 
    -0.87554812f, -0.90385669f, -0.45125094f, -0.39994353f, -0.53039205f, -0.46630642f, -1.14419091f, -0.82940090f, 
    0.49818102f, -0.11129322f, -0.74468732f, 0.98442644f, 0.01233728f, -0.50297982f, -0.06215664f, 0.28446230f, 
    0.14882669f, 0.49974978f, -0.61858702f, -0.47344732f, 0.40656853f, 0.51083040f, 0.31053838f, -0.44971272f, 
    -0.42686847f, -0.53444129f, -0.30107743f, -0.58581096f, 0.83660132f, -0.70811749f, 0.19954744f, 0.02567446f, 
    0.32023942f, 1.09819758f, -0.30949640f, -0.59680063f, 0.84878242f, 0.27675253f, -0.16707151f, -0.25834036f, 
    -0.08256714f, -0.32906473f, -0.83204806f, 0.06040125f, -0.78792268f, 0.23515849f, -0.00923665f, -0.10792810f, 
    0.55768567f, 0.11647278f, 0.46503672f, 0.45070213f, -0.26701167f, 0.36667055f, 0.15892872f, 0.65587682f, 
    -0.29514527f, 0.15209398f, -0.34336823f, 0.26623687f, 0.26790044f, -0.45137262f, 0.14237371f, -0.02372872f, 
    0.58547008f, -0.25083637f, 0.15941893f, 0.57252157f, -0.47339597f, -0.33728454f, -1.11997628f, -0.36080989f, 
    0.13243724f, -0.36375850f, 0.27342564f, 0.14379591f, 0.39991626f, 0.43936059f, 0.27568433f, -0.97577959f, 
    0.80602008f, -0.96467268f, -0.43556622f, 0.12175231f, -0.21052769f, -0.08182583f, 0.41883597f, 0.28782442f, 
    0.74431211f, 0.28351408f, -0.44819334f, 0.28063053f, -0.61704564f, 0.24123584f, 0.17361598f, 0.40023881f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31446001f, 0.36747208f, 0.08161230f, -0.09618634f, 0.10168871f, -0.07000636f, 0.14650014f, 0.13054730f, 
    0.15309830f, 0.27964446f, 0.19722481f, -0.02522982f, 0.03783278f, -0.07216287f, -0.03575371f, -0.34635812f, 
    0.18729915f, 0.28799775f, 0.16013226f, 0.19076233f, 0.28500840f, -0.15482101f, -0.10441398f, 0.29848483f, 
    -0.21815984f, 0.28065217f, 0.15140405f, -0.18383002f, -0.01005619f, 0.46105313f, 0.34289354f, 0.18671279f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.34864789f, 0.15415481f, -0.29089233f, -0.24248852f, -0.05055598f, -0.12776010f, 0.14578323f, -0.02011192f, 
    0.02380878f, 0.05106906f, 0.02084205f, -0.11316191f, -0.09638581f, -0.01919535f, 0.10091624f, -0.01148148f, 
    0.09045877f, 0.00159635f, 0.00762398f, -0.03066538f, -0.55162758f, -0.10893729f, 0.21545914f, -0.01175734f, 
    -0.06496375f, -0.23150036f, -0.01761198f, 0.11045943f, 0.08556639f, -0.12372509f, -0.10657600f, -0.11800772f, 
    -0.21001428f, -0.03866463f, -0.07392249f, -0.03144537f, -0.11867259f, -0.00315435f, -0.19288203f, 0.00441345f, 
    0.36206576f, -0.53157109f, -0.92968440f, 0.10496372f, -0.07320645f, 0.14991352f, -0.10463080f, 0.14195082f, 
    -0.24917793f, 0.16242458f, 0.07040796f, 0.08432338f, -0.22138032f, 0.00489003f, 0.05420209f, 0.02187434f, 
    0.17361866f, 0.02803605f, -0.02229406f, 0.07411540f, 0.09113109f, 0.23179132f, -0.03464668f, -0.10971799f, 
    -0.29383451f, 0.01695256f, 0.06987553f, 0.07554116f, -0.02913897f, 0.06928890f, -0.01881464f, -0.08051882f, 
    0.03909105f, 0.06948324f, 0.02815835f, -0.03584957f, -0.01290967f, -0.02790912f, -0.04291199f, -0.13396451f, 
    0.35071841f, 0.10330848f, -0.23331444f, 0.10242707f, 0.12417801f, 0.13681100f, 0.13006130f, 0.09922230f, 
    -0.12385814f, -0.04933749f, -0.09841053f, -0.03496311f, -0.05164638f, 0.07861412f, 0.01570029f, 0.01246411f, 
    0.04710696f, 0.03053997f, 0.00431305f, 0.03753609f, 0.30367044f, 0.21726032f, 0.16178823f, -0.29782936f, 
    -0.05173021f, 0.07055555f, 0.16882958f, 0.11906118f, -0.05264197f, 0.06019090f, 0.02689258f, -0.07737751f, 
    -0.00066072f, -0.11809406f, -0.11035957f, -0.07123329f, -0.17792302f, -0.08447776f, 0.06541825f, 0.04563935f, 
    -0.20882559f, -0.12733161f, -0.19286387f, -0.01009478f, -0.05966279f, 0.02059178f, 0.04828406f, 0.03720123f, 
    0.07396349f, 0.06991115f, 0.01901637f, -0.02274027f, 0.00362377f, -0.00889835f, 0.01657233f, -0.11825173f, 
    0.00867523f, 0.01998246f, -0.00656706f, -0.01827037f, 0.07435860f, -0.01910741f, 0.00285973f, 0.07158906f, 
    0.04870971f, -0.00555835f, 0.00734332f, -0.00358443f, 0.01966155f, 0.06168473f, -0.11059804f, -0.15670322f, 
    -0.12303712f, -0.12248637f, -0.13391893f, 0.00624900f, -0.04394627f, 0.00317734f, -0.04248871f, -0.01111326f, 
    0.22390461f, 0.34804392f, 0.03661283f, -0.63305014f, -0.18296143f, 0.00352348f, 0.06860938f, -0.03584339f, 
    -0.10281087f, 0.04038046f, -0.02865041f, 0.08547837f, -0.04033169f, 0.00261843f, 0.02362810f, 0.03618097f, 
    -0.01519026f, 0.00010834f, 0.11490591f, 0.26493612f, 0.20408756f, 0.19676162f, 0.03881846f, -0.19077158f, 
    -0.09998978f, -0.13477997f, -0.01791835f, -0.23257905f, -0.09174041f, -0.01891762f, 0.04966015f, 0.06076186f, 
    -0.05405270f, -0.02731362f, -0.04676889f, 0.00576645f, -0.02868125f, -0.01579758f, -0.12035038f, -0.15315810f, 
    -0.06020804f, -0.13738567f, -0.49400187f, 0.18119098f, 0.00710430f, 0.06672384f, -0.05377542f, 0.01499944f, 
    -0.04984840f, 0.02204873f, -0.03997556f, -0.07784551f, -0.33383638f, -0.20091929f, -0.04660314f, 0.01698758f, 
    0.11492646f, 0.02489305f, 0.04061107f, -0.00016128f, -0.04503917f, 0.25927618f, 0.01757167f, -0.42899504f, 
    0.17493449f, 0.01780573f, -0.14826573f, -0.03327326f, -0.02314456f, 0.06409355f, 0.05120289f, -0.02010158f, 
    -0.00662235f, 0.03667183f, 0.02705184f, -0.04538858f, 0.01424334f, 0.09885586f, -0.01252670f, 0.04950591f, 
    -0.34711546f, -0.18372726f, 0.29387408f, 0.02115432f, -0.42617035f, -0.26238462f, -0.04539623f, -0.15008828f, 
    -0.07685181f, 0.02828916f, -0.03073088f, 0.06503024f, -0.08757992f, -0.11750083f, -0.19822758f, -0.35403076f, 
    -0.03961720f, -0.13709685f, -0.27265728f, -0.19947256f, 0.38864380f, 0.30859306f, -0.13266265f, -0.23409149f, 
    -0.16774011f, 0.00382252f, 0.01510580f, 0.07510844f, -0.01514819f, 0.09956433f, 0.04419534f, -0.06993734f, 
    0.01932850f, -0.02600805f, -0.00961347f, -0.02988302f, -0.03323565f, -0.00949482f, 0.01224150f, -0.02021678f, 
    0.18574834f, 0.05548181f, -0.01931146f, 0.09371597f, -0.23716010f, 0.08900769f, 0.09719770f, 0.15822127f, 
    -0.14557040f, 0.16633688f, -0.07275574f, -0.04331933f, -0.03467198f, -0.00861746f, -0.14828143f, -0.07144710f, 
    -0.07981507f, -0.11755921f, -0.05383151f, 0.14663658f, 0.36578074f, 0.13876034f, 0.02900006f, -0.05156122f, 
    -0.06038069f, 0.06735681f, 0.16122614f, 0.27972990f, 0.00606866f, 0.06188474f, 0.02675313f, 0.01539469f, 
    0.06014388f, 0.19994722f, 0.02024417f, 0.02936856f, 0.06997033f, -0.09354245f, 0.00534369f, -0.08054445f, 
    0.17564756f, -0.64463127f, -0.02565266f, 0.00585001f, -0.14395353f, 0.01869845f, -0.05332763f, 0.10421556f, 
    0.03064595f, 0.08642635f, 0.13623202f, 0.06011946f, 0.01032691f, 0.15092961f, 0.00093574f, -0.14397547f, 
    0.02191816f, 0.05929085f, 0.02689210f, 0.03841607f, -0.36677903f, -0.25163078f, -0.06353652f, -0.05534864f, 
    -0.23030683f, -0.02420180f, -0.08031818f, -0.09596875f, -0.12069301f, -0.00012282f, -0.05763596f, 0.02665381f, 
    0.00107111f, 0.08213250f, -0.00329026f, -0.15599032f, -0.13144939f, -0.20081095f, -0.23100425f, -0.13010740f, 
    0.24379353f, 0.12384325f, 0.06809256f, -0.15552509f, -0.12219804f, 0.05289657f, 0.12312367f, 0.10774603f, 
    -0.03217607f, 0.01297428f, 0.00775782f, -0.00968327f, -0.00821936f, -0.05165492f, -0.05147963f, 0.04774305f, 
    -0.13861890f, -0.05190239f, -0.01642277f, -0.05084633f, -0.14470600f, 0.01325711f, 0.17825235f, -0.10810362f, 
    -0.01525996f, -0.13444778f, 0.08596291f, 0.13998391f, -0.07104093f, -0.03732840f, -0.15662506f, -0.03419617f, 
    -0.00553575f, -0.03885393f, -0.04274058f, 0.03330633f, 0.02053870f, -0.01058784f, -0.06129517f, 0.02197633f, 
    0.16142927f, 0.18453661f, -0.08355863f, -0.05146857f, -0.10186642f, 0.00827222f, -0.08198783f, 0.04627321f, 
    -0.13109127f, -0.09021420f, -0.07185466f, 0.00504497f, -0.02565183f, -0.07668767f, -0.00835094f, -0.08551010f, 
    -0.08868928f, -0.02250306f, -0.08708880f, -0.04863898f, -0.32765296f, 0.43425208f, 0.25529453f, -0.24221747f, 
    -0.32134944f, -0.20236471f, -0.33795008f, -0.33484674f, 0.03569107f, 0.00320457f, 0.06662412f, -0.02506890f, 
    0.01176334f, 0.08312168f, 0.07562592f, 0.10220197f, 0.09862031f, 0.11848533f, 0.11724326f, 0.11909532f, 
    0.47829565f, 0.24724646f, 0.40427369f, -0.41208506f, 0.12866643f, -0.02403948f, 0.20495239f, 0.22675236f, 
    0.12476276f, -0.00742359f, 0.01484357f, -0.02761974f, -0.02782449f, -0.06754689f, -0.11570551f, 0.05376498f, 
    -0.09436684f, -0.00568473f, -0.01315691f, -0.12386886f, -0.23802756f, -0.09125057f, 0.04712848f, -0.12597279f, 
    0.01598103f, -0.09532706f, -0.04801932f, -0.07168639f, 0.01247571f, 0.03560826f, -0.03955292f, 0.02707441f, 
    -0.02206207f, 0.03298761f, -0.04228426f, -0.02228738f, -0.19273627f, -0.05223241f, -0.15354481f, -0.07130334f, 
    0.33134338f, 0.50073349f, -0.10299455f, -0.36246207f, -0.18023096f, 0.00593296f, -0.06164308f, 0.18301688f, 
    -0.13407527f, 0.12868157f, 0.09347473f, 0.08401857f, -0.01137494f, 0.05184624f, 0.06165648f, 0.01209619f, 
    -0.01676651f, -0.09580102f, -0.03156963f, 0.00109542f, -0.11332686f, -0.49666703f, -0.39191002f, 0.17096621f, 
    -0.11634878f, -0.00056625f, -0.04685902f, 0.00398725f, 0.02145208f, 0.06607670f, -0.09936904f, -0.00551905f, 
    -0.03346567f, 0.01192070f, 0.00868874f, -0.16794661f, 0.07108901f, 0.01304228f, -0.08160052f, -0.00851324f, 
    0.30137262f, 0.23400433f, -0.03090497f, -0.01214330f, 0.11563405f, 0.13358825f, 0.11794520f, 0.07627871f, 
    -0.10065374f, -0.08197568f, 0.01247437f, -0.14246148f, -0.04298430f, 0.01046280f, 0.03667402f, -0.10130989f, 
    0.00731984f, -0.06321575f, -0.01376484f, -0.01227078f, -0.10916697f, -0.12454613f, -0.09968333f, 0.01060761f, 
    0.03948336f, 0.01983302f, 0.02610779f, 0.05414056f, 0.03071254f, 0.05855304f, -0.06194361f, 0.03654164f, 
    0.06546621f, 0.08455458f, -0.04105028f, -0.20801918f, -0.04946573f, -0.06497349f, -0.03867236f, 0.02266831f, 
    0.00709022f, -0.00930841f, -0.08401909f, 0.05275818f, 0.04156547f, -0.04001700f, -0.00208379f, 0.01723061f, 
    -0.01253839f, 0.03864647f, -0.22059117f, -0.02361345f, -0.09032106f, -0.00421951f, -0.24556838f, 0.04190299f, 
    -0.05120873f, -0.05938878f, -0.07903647f, 0.08849759f, 0.32178873f, 0.26041344f, 0.00630999f, -0.09127232f, 
    0.08934616f, 0.11537019f, 0.15445288f, 0.14714901f, -0.26756722f, -0.14367607f, -0.11824743f, -0.09341689f, 
    0.01957594f, 0.00882926f, 0.05045593f, -0.02650862f, -0.07233094f, -0.02992630f, 0.04284745f, -0.02183616f, 
    -0.08123679f, 0.20516898f, 0.18894598f, -0.52935308f, -0.03917632f, -0.21803513f, 0.00115428f, -0.01698949f, 
    -0.22596096f, -0.14211696f, 0.01830038f, -0.10058321f, -0.01912770f, -0.02223127f, -0.12299800f, 0.01736949f, 
    -0.13250601f, -0.03922546f, 0.07391984f, -0.31811416f, -0.11669672f, -0.02940064f, -0.07218811f, 0.06075210f, 
    -0.06302191f, -0.08700811f, -0.14681149f, 0.01355717f, 0.05194157f, 0.05055128f, -0.03440106f, 0.08516227f, 
    -0.01312842f, 0.02850661f, -0.03603256f, -0.10378077f, -0.13949780f, -0.10773905f, -0.11976197f, -0.08804736f, 
    0.36134708f, -0.06574505f, -0.24545009f, -0.25797322f, -0.12766600f, 0.15838358f, -0.04823946f, 0.05438564f, 
    0.12522396f, -0.09853575f, 0.13485147f, -0.07675581f, 0.02954097f, -0.10677333f, -0.14756925f, 0.04392129f, 
    -0.08837553f, 0.01826128f, 0.00484763f, -0.05928439f, -0.17551367f, -0.39596081f, 0.06896168f, -0.01445883f, 
    0.14316948f, 0.01651506f, 0.00085026f, 0.09279189f, 0.07756193f, 0.07064723f, 0.01778951f, 0.03333306f, 
    0.13327044f, 0.06571145f, -0.10663407f, -0.00130424f, -0.00589469f, 0.06016426f, 0.18149398f, -0.01318535f, 
    0.88141191f, -0.34644416f, 0.03658797f, 0.16197951f, -0.37364456f, -0.01024046f, 0.01914178f, -0.04162478f, 
    -0.13165843f, -0.08855125f, 0.16012104f, -0.38897443f, 0.15800476f, -0.24866372f, -0.05093924f, 0.02618290f, 
    -0.06063413f, -0.14709121f, -0.04019628f, -0.05377863f, -0.21898493f, -0.05600203f, -0.03485469f, 0.27453870f, 
    -0.29270819f, 0.03094606f, -0.03149391f, -0.38223791f, -0.16969283f, 0.21039547f, -0.06824505f, 0.03855423f, 
    0.02382819f, 0.02595293f, 0.06834225f, -0.03533832f, 0.09617814f, 0.01145249f, -0.38192645f, -0.13244912f, 
    0.16517833f, -0.12804538f, -0.27759179f, -0.02133685f, -0.15051472f, -0.12609300f, 0.03277837f, 0.05972515f, 
    -0.07040533f, -0.05541092f, -0.01586491f, 0.06276460f, -0.08316356f, 0.04919550f, -0.04685790f, -0.05703721f, 
    0.04170606f, -0.02345706f, -0.03935468f, 0.08341217f, 0.06603923f, 0.19978045f, 0.06718651f, 0.07804912f, 
    0.17367366f, 0.14849371f, -0.10213844f, 0.00349791f, -0.02255488f, 0.03227932f, -0.01548766f, 0.03664211f, 
    0.02486892f, -0.03470828f, 0.13891993f, -0.09528310f, -0.05395733f, 0.17110343f, -0.18645151f, 0.04766069f, 
    0.43145344f, 0.10379263f, 0.04044039f, 0.12760609f, 0.10228980f, -0.05635596f, 0.02511727f, -0.02437825f, 
    -0.05129477f, -0.04604797f, -0.04438104f, 0.02543612f, -0.04369850f, -0.03353958f, 0.05880350f, 0.08442489f, 
    -0.12376771f, -0.12951055f, 0.03523936f, -0.04887464f, 0.02610906f, -0.01054778f, 0.04836006f, 0.07602480f, 
    0.05512576f, -0.00032292f, -0.00117607f, 0.00936291f, -0.03850174f, -0.02176073f, 0.07359470f, 0.09689935f, 
    -0.02824186f, 0.00922626f, -0.03127859f, -0.07304141f, -0.02676442f, -0.07420371f, -0.02690439f, -0.06076499f, 
    -0.49759740f, 0.22508243f, -0.11236017f, 0.08059721f, 0.22573562f, -0.21391068f, -0.02824662f, 0.06733267f, 
    -0.00633978f, -0.02150245f, 0.02170524f, -0.04205661f, 0.11212275f, 0.02859642f, 0.07727654f, 0.03345516f, 
    -0.04029413f, 0.07047322f, -0.15111138f, 0.01318401f, -0.21886241f, -0.05094218f, 0.03952388f, -0.09257281f, 
    0.02553371f, 0.09456521f, 0.10230229f, -0.12250876f, 0.18655625f, 0.05605914f, -0.00083547f, 0.04560258f, 
    0.03398160f, 0.15595670f, 0.04981500f, -0.02540045f, -0.02837659f, -0.03035058f, 0.15968636f, 0.05271711f, 
    0.87706840f, 0.13021371f, -0.02026567f, 0.07041246f, -0.25880128f, -0.09178372f, 0.08199904f, 0.01382257f, 
    -0.08491363f, 0.04988578f, 0.17215566f, -0.03526886f, -0.05808649f, -0.02627111f, -0.05335370f, -0.01633936f, 
    0.00130238f, 0.01855689f, -0.08574096f, 0.02669993f, 0.11623711f, -0.02600319f, -0.34035444f, -0.21941952f, 
    -0.12620583f, -0.00473285f, -0.03977124f, -0.10409671f, -0.00504151f, -0.14259878f, -0.03603637f, 0.00880416f, 
    0.01695273f, -0.02989485f, 0.03720678f, 0.01730600f, -0.33112115f, -0.34308523f, -0.12606914f, -0.27692670f, 
    -0.23777197f, -1.29443157f, -0.01959703f, -0.52747959f, -0.03778302f, -0.01596299f, -0.00576797f, -0.45266065f, 
    0.05927570f, 0.29712132f, -0.05473958f, 0.05329639f, 0.00284049f, 0.16664745f, -0.13966891f, 0.11005862f, 
    -0.01884286f, -0.16941434f, 0.11011589f, 0.08144805f, -0.31151929f, 0.18141349f, -0.04323715f, 0.44613200f, 
    0.10975825f, 0.02054970f, 0.00566701f, 0.06183000f, 0.02963295f, -0.12174886f, -0.05158404f, 0.01352159f, 
    0.01878879f, -0.00683636f, -0.01865125f, -0.06803762f, 0.05177559f, 0.04285202f, -0.17494908f, -0.06427258f, 
    0.22648570f, 0.01304335f, -0.25852200f, 0.01442363f, -0.33011705f, 0.02043568f, -0.14948259f, -0.12836336f, 
    0.05310923f, -0.02091080f, 0.05200851f, 0.01618549f, 0.05555756f, -0.04434181f, -0.03174206f, -0.07739723f, 
    -0.08823364f, -0.22788765f, 0.04655922f, 0.07916949f, 0.08672287f, 0.20323248f, 0.43727878f, 0.08376031f, 
    -0.24186906f, 0.07021315f, -0.16752292f, 0.16920508f, 0.01863872f, 0.09705872f, -0.01912427f, 0.00362013f, 
    -0.03083704f, -0.07188862f, 0.03391662f, 0.20135206f, -0.00023106f, -0.08323037f, -0.03296810f, 0.00634717f, 
    -0.00402189f, -0.06127074f, 0.25253138f, 0.19977555f, 0.21023519f, -0.06264310f, 0.00520701f, 0.01245138f, 
    -0.07020215f, -0.03079971f, 0.07802909f, 0.10499942f, -0.03615031f, 0.03181587f, -0.15856320f, 0.27740070f, 
    -0.12022058f, -0.13589354f, 0.12936729f, -0.18095079f, 0.23560862f, 0.12352750f, -0.10161961f, -0.07057758f, 
    -0.03878752f, -0.12149592f, -0.12517458f, -0.04518967f, -0.05983346f, -0.05713402f, -0.06251653f, -0.01227867f, 
    0.05788717f, 0.09922304f, -0.03837580f, 0.15138608f, 0.11899868f, 0.00840831f, 0.15541625f, 0.03858781f, 
    0.12386444f, 0.10839870f, 0.27657530f, -0.04082194f, -0.01381037f, 0.14633222f, -0.11213800f, 0.06548408f, 
    0.22278012f, 0.18467674f, 0.00275151f, -0.00349142f, 0.03132932f, -0.05768492f, 0.02312253f, -0.05540642f, 
    -0.01806078f, -0.10329618f, 0.00377484f, 0.01127013f, -1.07546926f, -0.43607220f, -0.02989852f, -0.19251530f, 
    -0.08632316f, -0.00997659f, 0.05953995f, 0.01639480f, 0.00266371f, -0.22782908f, 0.00076596f, 0.07643467f, 
    -0.13947283f, 0.08731893f, 0.05667429f, 0.00385432f, 0.03606595f, 0.02701791f, 0.00193671f, -0.07415191f, 
    -0.02006035f, -0.09917350f, -0.21554749f, -0.06518068f, -0.12937759f, -0.03458592f, 0.09283010f, 0.13729049f, 
    -0.08561632f, 0.16624692f, 0.19788739f, 0.18389878f, 0.08329140f, 0.09845446f, -0.00182757f, 0.00789946f, 
    0.00752462f, -0.02599028f, 0.04872650f, 0.09820185f, -0.28653726f, -0.07961711f, -0.29239419f, -0.33252177f, 
    -0.65395629f, 0.03545903f, -0.21915507f, -0.24693771f, -0.23408219f, -0.03129771f, -0.05794053f, 0.00789170f, 
    -0.02051548f, 0.02785728f, 0.03861753f, -0.13908964f, -0.10659207f, -0.28734288f, 0.01181507f, -0.19381031f, 
    -0.64387482f, 0.13286670f, -0.20840807f, 0.10937983f, 0.08842354f, -0.03020218f, -0.16381621f, 0.02182137f, 
    -0.10232008f, -0.05837913f, -0.02652430f, 0.07803308f, -0.02450380f, -0.12873590f, -0.12314988f, 0.15234251f, 
    -0.01123979f, -0.01057978f, -0.09513095f, 0.01370642f, 0.10730781f, 0.01581004f, 0.20692581f, -0.04240440f, 
    0.05840917f, 0.03119881f, 0.06114352f, -0.06415243f, 0.08383011f, -0.09238309f, 0.05946010f, -0.13114908f, 
    0.07333734f, 0.10349884f, -0.05199052f, 0.07889993f, -0.00256345f, 0.00793148f, 0.07435194f, -0.11783727f, 
    0.20967056f, -0.01735155f, -0.08144205f, -0.09255847f, 0.11022784f, -0.21921691f, 0.17649880f, 0.17527395f, 
    -0.20280318f, -0.09618533f, 0.02270370f, -0.02042428f, 0.02798987f, 0.01608122f, -0.00842495f, -0.01776188f, 
    0.01745896f, -0.11441786f, -0.05707910f, -0.01222437f, 1.13604999f, 0.13538647f, -0.11612104f, 0.25117931f, 
    -0.14088576f, -0.02098281f, -0.04809662f, -0.03128772f, 0.00830413f, -0.03167910f, -0.00884205f, 0.18499105f, 
    -0.06822816f, 0.07286544f, 0.07456963f, 0.15346456f, -0.12556738f, 0.03575705f, 0.17848246f, 0.09967123f, 
    -0.25424546f, -0.18548949f, -0.14894871f, 0.05608971f, -0.14339206f, 0.06423855f, 0.04327739f, 0.14368537f, 
    0.15664303f, -0.23186468f, -0.25596452f, 0.14174040f, 0.02351276f, 0.10571583f, 0.01034037f, 0.02406976f, 
    0.02004098f, 0.01168913f, -0.00132591f, 0.06486592f, 0.11611066f, 0.07563875f, 0.07812271f, 0.10756810f, 
    0.07296755f, -0.07808743f, 0.03188908f, -0.04318759f, -0.04223014f, -0.03431647f, -0.08979170f, 0.01149833f, 
    0.09505085f, -0.05532633f, -0.01888516f, -0.07561456f, -0.12609878f, 0.03737910f, -0.07892512f, -0.08183862f, 
    0.18950482f, -0.02095731f, -0.03409628f, 0.06123886f, -0.01132976f, -0.08792826f, 0.01250466f, -0.05041444f, 
    0.03231756f, 0.01628095f, -0.04954781f, 0.20519190f, 0.11048488f, 0.02079006f, 0.01143539f, -0.17019743f, 
    -0.04235585f, -0.00543948f, -0.03417199f, -0.00694406f, -0.21770512f, -0.01561491f, -0.21115521f, 0.02162455f, 
    -0.05265218f, 0.09762146f, 0.22054960f, 0.22909927f, -0.08149990f, 0.10486234f, -0.09592658f, 0.03575215f, 
    0.06665169f, 0.02735103f, -0.01910767f, -0.04721119f, 0.04388690f, 0.04024759f, -0.06552784f, 0.12058017f, 
    -0.38427535f, 0.29480395f, -0.35897604f, -0.26497489f, 0.02323169f, -0.15654172f, 0.06681176f, -0.00961551f, 
    -0.07020682f, 0.30716282f, -0.03832924f, 0.01644012f, 0.11754825f, -0.01195300f, 0.03284268f, 0.10470325f, 
    0.00420417f, 0.11640336f, -0.13295695f, -0.00946048f, 0.13118976f, 0.02255027f, 0.02194689f, -0.03911773f, 
    0.03186500f, -0.06897140f, -0.06557156f, -0.10934254f, -0.00675544f, -0.03894458f, 0.05396990f, -0.06340987f, 
    0.07469677f, 0.06402807f, 0.04031665f, -0.10934269f, 0.04230705f, -0.07091717f, 0.02090150f, -0.05450136f, 
    -0.09957380f, -0.23630758f, 0.54584998f, 0.13872114f, 0.32825443f, 0.00548085f, -0.10499340f, -0.07055847f, 
    0.29957265f, -0.36980921f, -0.02836904f, 0.08129834f, 0.02067148f, -0.02261416f, -0.05250602f, 0.07135788f, 
    -0.00916522f, -0.06377450f, 0.02788099f, 0.04542270f, 0.33594242f, 0.04624144f, -0.11802863f, -0.04109885f, 
    0.21397094f, 0.02850185f, 0.10655712f, -0.05335793f, -0.06686343f, 0.02453810f, -0.05350105f, 0.01075025f, 
    0.04479940f, 0.16303329f, -0.09976856f, 0.04846988f, 0.11036402f, 0.00524224f, 0.04964903f, 0.13588282f, 
    -0.17009391f, 0.05448238f, 0.95739639f, -0.12680155f, 0.16843764f, -0.15584619f, -0.04139025f, -0.07890645f, 
    -0.09486412f, 0.14261478f, 0.01072797f, 0.05597709f, 0.08085839f, -0.19199578f, 0.03911833f, 0.01304491f, 
    0.04590308f, 0.06745391f, 0.13258167f, -0.12844943f, -0.09553476f, -1.01687789f, -0.14356299f, -0.17020865f, 
    -0.23778582f, 0.14304209f, -0.01456298f, 0.01756422f, -0.02754421f, -0.09648237f, 0.01139910f, -0.00107916f, 
    -0.00169070f, -0.08518542f, -0.01354477f, 0.01593802f, -0.03835312f, -0.04565731f, 0.12373036f, 0.03116691f, 
    -0.04247670f, 0.08536324f, 0.35975969f, 0.05932716f, 0.21874528f, -0.04754448f, -0.00528217f, 0.04071195f, 
    0.19299209f, -0.21888392f, -0.00394963f, -0.02720367f, -0.17513038f, 0.05966189f, 0.07105739f, 0.01330227f, 
    -0.02513345f, 0.01403910f, 0.02368235f, -0.00988689f, -0.28696719f, -0.32640910f, -0.15393545f, 0.14565335f, 
    -0.35083312f, -0.02914903f, -0.01194935f, -0.05277077f, 0.07796259f, 0.01538256f, 0.02039837f, -0.04958028f, 
    0.01448939f, -0.02730429f, -0.02440256f, -0.05000263f, 0.01961323f, 0.04722892f, -0.09537336f, 0.12037298f, 
    -0.14388582f, -0.07629908f, -0.09856597f, -0.14400727f, -0.01418288f, 0.00411778f, -0.01394195f, 0.00007452f, 
    0.01756912f, 0.05895611f, 0.02605792f, -0.01527436f, -0.04361701f, 0.05398490f, -0.00403554f, 0.00659521f, 
    -0.04145718f, 0.02182881f, 0.08045252f, -0.02626781f, -0.02030495f, -0.09242754f, -0.02930071f, 0.02195065f, 
    0.04419279f, 0.04155868f, 0.00373329f, 0.04856614f, 0.05295769f, 0.02372479f, -0.27783704f, -0.08181323f, 
    -0.04513356f, -0.06293295f, 0.05128616f, 0.01894006f, -0.05133812f, -0.05287767f, 0.04504518f, -0.10600256f, 
    -0.52974617f, -0.24454695f, -0.74978620f, 0.05832979f, -0.38514987f, 0.18715526f, 0.18196608f, -0.12772487f, 
    0.00051646f, -0.16937537f, -0.02143749f, 0.05545383f, 0.03107427f, 0.03519103f, -0.00592544f, 0.02241790f, 
    0.01478881f, -0.03655454f, -0.05961229f, 0.02876325f, -0.04047874f, -0.02258320f, -0.09358494f, -0.04861454f, 
    -0.04020003f, 0.10644554f, 0.02123056f, -0.18402074f, 0.00678646f, -0.09992620f, 0.06817558f, -0.05048744f, 
    -0.07456157f, 0.06853372f, -0.06208158f, 0.03803229f, 0.03946948f, -0.04459452f, -0.05551615f, -0.17049146f, 
    -0.20133756f, 0.44720319f, 0.37068972f, 0.00482789f, 0.13728338f, -0.05011912f, -0.00018994f, 0.04986696f, 
    -0.11595877f, 0.11702149f, 0.02272796f, -0.06564721f, 0.04861956f, 0.09616932f, 0.02362845f, 0.02099115f, 
    -0.02592094f, -0.03430472f, 0.06335717f, -0.08213224f, -0.07227153f, 0.33599073f, -0.11496262f, -0.11183810f, 
    -0.21387030f, 0.04343291f, 0.02236363f, -0.06854384f, 0.05249369f, 0.02688072f, 0.01082030f, -0.03280880f, 
    -0.02283749f, 0.01221677f, -0.04292548f, 0.06222608f, 0.09232348f, 0.29003185f, 0.03618513f, 0.01432005f, 
    0.84613925f, -0.65525472f, -0.04505144f, -0.67017561f, -0.00087580f, 0.33056471f, 0.04073266f, -0.16787530f, 
    -0.16298614f, -0.05234941f, -0.00873753f, -0.05701281f, 0.01516504f, 0.06798303f, 0.00520265f, 0.24642579f, 
    -0.13516878f, -0.24824674f, 0.15634468f, 0.10568848f, 0.15723149f, -0.79858881f, -0.19127592f, 0.45794284f, 
    -0.34554580f, 0.11260107f, -0.08366660f, -0.14805566f, 0.09294062f, -0.10011384f, 0.01856575f, 0.10146406f, 
    -0.00193132f, -0.00688153f, -0.01897339f, 0.03936148f, 0.00713659f, 0.02812643f, 0.18044974f, -0.01471986f, 
    -0.07770993f, -0.21292531f, 0.12061656f, -0.12599108f, -0.50391138f, 0.13837437f, -0.06887534f, -0.04074850f, 
    0.04070770f, -0.16955452f, -0.00328692f, -0.08038978f, -0.02150083f, -0.05556983f, 0.03226868f, 0.10427830f, 
    0.09362623f, -0.09036122f, 0.13457277f, 0.07018518f, -0.32263839f, -0.03107013f, 0.61497259f, 0.11683049f, 
    0.27888694f, -0.06963449f, -0.19681394f, -0.12518612f, -0.13055786f, -0.05653572f, 0.01437907f, -0.00215523f, 
    0.01001294f, -0.08668309f, 0.02324497f, -0.04317981f, 0.05894864f, -0.05111913f, -0.01126313f, -0.03551531f, 
    -0.03024814f, -0.25930294f, -0.09579392f, -0.14407158f, 0.23874673f, -0.03908796f, -0.02575648f, -0.04736213f, 
    0.01737430f, 0.01467845f, -0.05021587f, -0.01814275f, 0.02305908f, -0.01659470f, -0.01679636f, 0.04221538f, 
    0.06925058f, 0.18914567f, -0.04558850f, 0.00847255f, -0.50550491f, 0.00191910f, 0.15185478f, -0.10275610f, 
    -0.03069379f, 0.02729383f, -0.09155414f, -0.04681386f, -0.07672946f, 0.05167131f, 0.01590588f, 0.01281319f, 
    0.06118385f, 0.00282242f, 0.00829685f, 0.06715330f, -0.18096994f, -0.22695501f, 0.05991392f, 0.05425939f, 
    -0.01251643f, -0.11166466f, 0.47372073f, 0.29162002f, 0.18056312f, 0.04849421f, 0.06158537f, -0.01051410f, 
    0.09024151f, -0.04003760f, 0.04497356f, -0.00281568f, 0.00274432f, 0.03782635f, -0.04162769f, -0.01203836f, 
    0.02901938f, -0.08934306f, -0.04823651f, 0.00801578f, -0.00235431f, 0.11724562f, 0.09287447f, 0.20965230f, 
    0.05972919f, 0.02647552f, -0.02128339f, 0.19824255f, -0.08742379f, 0.03975927f, -0.06606995f, 0.06898817f, 
    -0.08240348f, 0.12386700f, 0.05007594f, 0.02709133f, 0.01067396f, -0.00937836f, -0.05192730f, 0.07300573f, 
    0.09398071f, 0.01828262f, -0.02862596f, -0.00999888f, 0.09053487f, -0.03668299f, -0.04816866f, -0.01506569f, 
    0.00236811f, -0.16072366f, 0.02615153f, 0.06650421f, 0.04761558f, 0.00948625f, 0.01322661f, 0.04940458f, 
    -0.01014312f, -0.06494569f, 0.05258108f, -0.07907802f, -0.59762084f, -0.74193496f, 0.68467289f, -0.24381234f, 
    -0.23962486f, -0.19959742f, 0.14285515f, -0.15738449f, -0.03003963f, 0.04378930f, -0.04179254f, -0.05885340f, 
    0.00793225f, 0.01354062f, -0.06570930f, -0.05926241f, 0.03775242f, -0.01808440f, 0.04758597f, 0.12889722f, 
    0.01182449f, 0.11717392f, -0.55572885f, 0.29594594f, 0.36361042f, 0.05696068f, 0.03459925f, -0.15627010f, 
    -0.03435469f, 0.07053646f, -0.04235813f, -0.05637916f, 0.01941534f, -0.00862401f, -0.08737209f, -0.05469885f, 
    -0.01520059f, 0.03803267f, -0.33239639f, 0.06156423f, -0.15625943f, -0.03859743f, -0.07692472f, -0.01020629f, 
    -0.03395233f, -0.01156840f, -0.05290543f, -0.05917666f, 0.03940938f, 0.07259611f, 0.11438527f, 0.01843704f, 
    -0.01359075f, 0.08151074f, -0.07203040f, -0.09327254f, -0.05113352f, 0.10958438f, -0.11057181f, -0.11071628f, 
    -0.08354125f, -0.71207470f, -0.02647717f, -0.33702943f, -0.27024063f, 0.10707747f, -0.06732050f, -0.04671126f, 
    0.08686389f, -0.18080361f, -0.03346112f, -0.02062383f, 0.03304441f, 0.00522162f, 0.03631131f, -0.01575308f, 
    -0.00074235f, -0.06928936f, 0.08197426f, -0.09393026f, -0.47617862f, 0.22114678f, 0.20576994f, -0.30659205f, 
    -0.27218413f, 0.06064439f, -0.04507154f, -0.02727215f, 0.00460403f, 0.04873152f, 0.00052066f, 0.00609790f, 
    -0.13207370f, -0.11200497f, -0.08590422f, 0.05074514f, 0.06833515f, -0.03692413f, 0.22979487f, -0.00875026f, 
    0.10859931f, -0.01342177f, 0.16080220f, 0.15388368f, 0.09919675f, 0.00256910f, -0.09222310f, -0.02502171f, 
    0.05634208f, -0.26120204f, 0.03631781f, 0.02339480f, 0.01055968f, -0.00361429f, 0.04069610f, -0.01493915f, 
    -0.07525106f, -0.05918179f, 0.03634011f, -0.05829924f, -0.20559144f, -0.05366108f, -0.21758863f, -0.15112528f, 
    0.05520448f, 0.01319782f, -0.08507156f, 0.00574513f, 0.03249454f, 0.00755977f, -0.12701814f, -0.12174106f, 
    0.05602275f, -0.08649059f, 0.00668370f, -0.08985257f, -0.04643509f, -0.04445706f, 0.13351171f, 0.03893414f, 
    -0.01043460f, -0.06689989f, 0.00223329f, -0.09358292f, 0.15743963f, -0.02255972f, -0.03530066f, -0.02108531f, 
    0.12453065f, 0.06926733f, -0.01244657f, -0.08578957f, -0.16649824f, -0.00984853f, 0.08903935f, 0.04017447f, 
    -0.05903419f, -0.03808898f, 0.06005900f, -0.00545477f, 0.16015317f, 0.13101156f, 0.10172680f, 0.23638947f, 
    0.13287856f, -0.06712959f, -0.04444963f, 0.07365696f, 0.06891697f, -0.06196066f, 0.08541047f, 0.16096900f, 
    0.01602032f, 0.03162132f, 0.01020525f, -0.00068806f, -0.07104079f, 0.03639279f, -0.06323937f, -0.06152858f, 
    -0.06614693f, -0.03011718f, -0.68388849f, 0.18186383f, -0.16424127f, -0.17248249f, 0.09203134f, -0.02042246f, 
    -0.14530893f, 0.20122008f, -0.03875476f, 0.04121688f, -0.01559688f, 0.01568940f, -0.06160428f, -0.01391373f, 
    0.02887085f, -0.01391802f, -0.05301041f, 0.03147420f, -0.09235863f, -0.18384288f, 0.20651910f, -0.13460465f, 
    0.12841681f, 0.03805288f, -0.16945937f, -0.17603302f, 0.01895786f, 0.06699297f, 0.02013330f, -0.04663832f, 
    0.07885512f, -0.00707523f, -0.02229419f, 0.10969295f, -0.12585689f, -0.25448811f, 0.02813799f, -0.01412671f, 
    -0.00804956f, 0.19085336f, -0.20581290f, -0.10538778f, 0.18006742f, 0.24210703f, 0.06321369f, -0.09285375f, 
    -0.17919104f, -0.04584155f, -0.30402952f, -0.05258607f, -0.01145718f, -0.04183665f, 0.19491601f, -0.14509319f, 
    -0.03783296f, -0.18759097f, 0.19392061f, 0.08549533f, 0.66165411f, 0.48239928f, -0.11081364f, -0.70475739f, 
    -0.07878255f, 0.09975592f, -0.13057052f, 0.11245877f, -0.19498253f, -0.23959880f, -0.10686640f, -0.10817689f, 
    0.02913821f, -0.19901288f, 0.04566894f, -0.00613469f, 0.00998824f, -0.19318873f, 0.10320594f, 0.18491216f, 
    -0.60396016f, 1.31517863f, -0.11794300f, 0.05451610f, 0.33130872f, 0.16774262f, -0.02108972f, 0.13807584f, 
    -0.24516715f, 0.12340113f, -0.19172001f, -0.08888794f, 0.05974314f, -0.03201631f, 0.03825206f, 0.03368564f, 
    -0.05317804f, -0.04181980f, -0.07216001f, 0.02380214f, 0.09380555f, -0.16369207f, -0.19352239f, 0.06895324f, 
    0.43375325f, -0.04676128f, 0.04858967f, 0.05826931f, -0.16011651f, 0.10929818f, -0.02690714f, 0.00856607f, 
    -0.11591855f, -0.10399845f, -0.13853674f, -0.05999929f, -0.07677945f, 0.09474653f, 0.08969962f, -0.09258521f, 
    -0.16484757f, 0.07991213f, -0.03411993f, -0.04815193f, 0.33422938f, 0.24997492f, -0.05241124f, -0.06087067f, 
    -0.22247581f, -0.02127420f, -0.14956859f, 0.04475982f, 0.11269198f, 0.08356833f, 0.11256031f, 0.05444873f, 
    0.00521653f, 0.14823437f, -0.00290991f, 0.08934221f, 0.01371794f, -0.12198985f, -0.20823814f, -0.04944055f, 
    0.21978657f, -0.01535813f, 0.05088175f, -0.02140828f, -0.04826909f, 0.01048649f, -0.15694326f, -0.09074277f, 
    -0.08370756f, -0.11228951f, -0.06675569f, -0.06101928f, -0.06153479f, 0.02094749f, -0.04942061f, -0.04814513f, 
    -0.74589771f, -0.13422969f, -0.05295042f, 0.04710772f, -0.28384423f, 0.20901197f, 0.08566647f, 0.14196122f, 
    0.19915399f, -0.06182811f, 0.08563128f, -0.06967590f, 0.04119068f, -0.00885952f, -0.07412119f, -0.03555041f, 
    -0.05445658f, -0.13935812f, -0.06396727f, -0.03604246f, -0.42075163f, -0.06429889f, -0.15904194f, -0.16623057f, 
    -0.40342674f, 0.10702720f, -0.12635438f, -0.03614398f, -0.12926789f, -0.01989296f, -0.04730017f, -0.12794536f, 
    -0.09960817f, -0.09972222f, -0.11192366f, -0.10716435f, -0.01733556f, -0.25804943f, -0.07693481f, -0.19099540f, 
    -0.03760830f, -0.03414951f, -0.04763390f, 0.10684290f, 0.10178622f, -0.02612402f, 0.07204022f, 0.00608480f, 
    0.11700077f, 0.12917316f, -0.06166120f, 0.01454639f, -0.01151566f, -0.09791904f, 0.03878355f, -0.08913100f, 
    -0.02523834f, 0.13592190f, -0.15721811f, -0.11025550f, 0.19102335f, -0.15216547f, -0.18556064f, -0.14183588f, 
    0.20542319f, 0.06598374f, 0.13907143f, 0.00250300f, 0.13144948f, 0.04373688f, 0.14792964f, -0.06606035f, 
    -0.11029007f, -0.14969231f, -0.00059518f, -0.10970367f, -0.11611479f, -0.04802842f, -0.19663036f, 0.03942050f, 
    -0.14498298f, 0.47310176f, 0.24320357f, 0.24421658f, 0.34373689f, 0.07852424f, -0.07043976f, 0.01572010f, 
    -0.13945061f, -0.17756023f, -0.10540053f, 0.00737893f, -0.07551042f, 0.06762455f, 0.07849965f, 0.05694532f, 
    -0.03525218f, 0.10221645f, -0.13813893f, -0.15863773f, -0.42150003f, -0.09958556f, 0.37243336f, -0.00594904f, 
    0.00056427f, -0.23271237f, -0.06365705f, 0.10356890f, 0.03188816f, 0.08060379f, -0.04723543f, 0.02340658f, 
    0.14208591f, 0.08803446f, 0.01324488f, 0.22963940f, -0.00783612f, 0.19439505f, -0.13149439f, -0.04010214f, 
    0.73231894f, 0.05320371f, -0.27364388f, -0.52672404f, -0.15295665f, 0.04048167f, 0.04603899f, 0.04584144f, 
    -0.36561048f, -0.06184792f, -0.25948277f, -0.34043494f, 0.13832167f, -0.16081034f, -0.02065298f, -0.07196973f, 
    0.14018610f, -0.11015502f, 0.02542135f, 0.12705888f, -0.11945339f, -0.10770702f, -0.36712447f, -0.13648742f, 
    0.27708644f, 0.18811378f, 0.09180081f, 0.03814564f, 0.12854785f, 0.04574686f, -0.05767307f, 0.08769372f, 
    -0.33985636f, 0.18560371f, 0.02954285f, -0.14540291f, -0.04196429f, 0.22030155f, -0.02497920f, 0.03571328f, 
    -0.00642450f, -0.01559928f, -0.48813105f, 0.32677457f, 0.21144453f, -0.10230738f, -0.01695757f, -0.04998104f, 
    0.01962647f, -0.00596290f, 0.03788639f, -0.00369571f, -0.06192622f, -0.08684458f, -0.17238536f, 0.03040264f, 
    0.05932665f, 0.06351287f, 0.09970824f, -0.12116598f, 0.40027452f, -0.00253086f, -0.14379506f, 0.07413745f, 
    0.21730874f, 0.21053423f, 0.07263724f, 0.03192545f, 0.05174253f, -0.01958861f, -0.09535374f, 0.12417412f, 
    0.06804135f, 0.14602678f, 0.14509410f, -0.11283408f, 0.12534481f, 0.01967501f, 0.00136053f, 0.09958689f, 
    -0.63742745f, 0.93346888f, -0.02578345f, -0.50122851f, -0.63980132f, 0.28025389f, 0.24428686f, 0.05617445f, 
    0.11022826f, 0.12687218f, -0.04939248f, -0.12446316f, 0.03143172f, -0.03204744f, -0.05421674f, -0.04404138f, 
    0.08781821f, -0.21602172f, -0.02140879f, -0.04130937f, -0.74938309f, 0.10117629f, 0.17511702f, 0.36422908f, 
    -0.23148896f, 0.08012776f, -0.28759038f, 0.22995628f, 0.07410415f, -0.14729553f, 0.09324016f, 0.08233014f, 
    -0.02480663f, -0.09906904f, -0.03387485f, -0.15515859f, 0.06662513f, -0.06819137f, 0.07443038f, -0.26901594f, 
    0.00155611f, 0.00256379f, -0.25366944f, -0.01060906f, 0.20723803f, -0.00805639f, 0.02017035f, -0.08533435f, 
    -0.02967463f, 0.08129665f, 0.01457289f, 0.05799448f, -0.14043856f, 0.04767521f, 0.14072365f, -0.04050140f, 
    -0.03070350f, 0.03949974f, 0.02415534f, 0.04588863f, 0.59875864f, 0.13608837f, -0.27538458f, -0.02395576f, 
    0.02656007f, 0.26600966f, -0.04129698f, 0.10989159f, -0.03710338f, -0.24031268f, -0.13264756f, -0.05632512f, 
    -0.10641925f, 0.16801956f, -0.02671647f, 0.01038939f, 0.11186597f, 0.23289740f, -0.00032769f, 0.11274640f, 
    -0.18842579f, 0.13375363f, -0.16872074f, -0.08656613f, 0.03616059f, 0.05029905f, -0.20036030f, 0.16512442f, 
    0.07905040f, 0.06624335f, -0.06048055f, -0.02294406f, 0.05249311f, -0.08507566f, -0.03519148f, 0.06218855f, 
    0.01257927f, -0.02566494f, -0.08101911f, -0.07223037f, -0.00138170f, -0.50330526f, 0.61124480f, -0.00626729f, 
    0.55927360f, -0.26557052f, 0.18968211f, 0.05841231f, 0.21973093f, 0.06720244f, 0.16547394f, 0.02971827f, 
    -0.09120224f, -0.00582143f, 0.21598226f, -0.00152329f, 0.03754009f, -0.04293929f, 0.13149324f, -0.06053940f, 
    0.09820217f, 0.20371331f, -0.13242078f, -0.47677222f, 0.18356024f, 0.28425920f, 0.04397628f, -0.20608059f, 
    0.11557369f, -0.26156971f, -0.05778780f, 0.11816023f, -0.04215729f, 0.10834727f, 0.10914525f, -0.08645059f, 
    0.07627955f, -0.01875718f, -0.16604926f, -0.15321738f, -0.05827244f, -0.15691045f, 0.10713090f, -0.16714588f, 
    -0.33206758f, -0.01363763f, -0.08225169f, -0.15155180f, -0.05182206f, -0.05860743f, -0.01046539f, 0.17384398f, 
    -0.09814888f, -0.10277060f, -0.04684887f, -0.01954902f, -0.00225253f, 0.02394808f, -0.20282707f, -0.16164142f, 
    0.03317025f, 0.15043560f, -0.07457943f, -0.09726518f, 0.22991095f, 0.22863933f, -0.03057222f, 0.21266842f, 
    0.10049498f, 0.21558309f, 0.00501035f, 0.04591252f, -0.07402094f, -0.03690058f, -0.07311288f, 0.14295122f, 
    -0.11371835f, 0.06569143f, 0.12474944f, 0.07125995f, -0.19377434f, 0.43105039f, -0.00988901f, 0.26078013f, 
    0.01987504f, 0.12490186f, -0.00576610f, 0.04216715f, 0.15214492f, 0.00538019f, -0.08280279f, -0.04094494f, 
    -0.00049249f, -0.01073792f, -0.16117050f, -0.02993485f, -0.00785886f, -0.01019759f, -0.06185705f, -0.02205429f, 
    -0.01178748f, -0.26380557f, -0.22264008f, -0.02430479f, 0.34126762f, 0.11384044f, 0.16692731f, 0.07862457f, 
    -0.04626514f, -0.04182488f, -0.07485117f, 0.09974974f, 0.11428688f, 0.03860259f, -0.09756505f, -0.00506940f, 
    0.07546124f, 0.11348063f, 0.22697774f, -0.02501072f, -0.50915658f, -0.21735428f, -0.29844284f, 0.12773773f, 
    -0.48414314f, 0.34039879f, -0.12325227f, 0.12617470f, 0.03709604f, -0.07837819f, 0.19982323f, -0.10111453f, 
    0.26172662f, -0.15934852f, -0.12883709f, -0.05199992f, 0.22849678f, 0.04762769f, 0.01171558f, -0.12831691f, 
    -0.31464192f, 0.03892433f, -0.47003844f, -0.16582675f, -0.06473630f, -0.06273234f, -0.22648390f, 0.06550931f, 
    -0.14731164f, -0.08554681f, -0.10247100f, 0.04753520f, 0.02514417f, -0.08030497f, 0.02336582f, 0.09570449f, 
    0.09538139f, -0.05872025f, 0.04948247f, -0.10934290f, -0.28330347f, -0.03580564f, -0.12955366f, -0.17308669f, 
    0.45559520f, 0.17125827f, -0.05652710f, 0.00572062f, 0.00345911f, -0.04249381f, -0.08142979f, 0.01000705f, 
    -0.10463700f, 0.00877000f, 0.03126656f, 0.02496127f, 0.05252647f, 0.32284641f, -0.05350954f, 0.00505293f, 
    -0.06700473f, -0.01918953f, -0.09244424f, 0.03561513f, 0.10702203f, -0.00316028f, -0.14145793f, -0.04419550f, 
    -0.05536002f, -0.19529343f, 0.04599930f, 0.00330901f, -0.15262020f, -0.11770082f, 0.03520581f, 0.14220549f, 
    -0.04225491f, 0.12936009f, -0.20597275f, -0.23279698f, -0.43874148f, -0.13026781f, 0.57106334f, -0.27390149f, 
    -0.08452465f, -0.10848686f, -0.07599338f, -0.05412995f, 0.12815763f, -0.05882039f, 0.04190316f, -0.06176545f, 
    -0.04622521f, -0.14091419f, -0.11369734f, -0.06906176f, 0.05745213f, -0.09975337f, -0.02808015f, -0.13672584f, 
    0.17223230f, -0.23260315f, 0.14798178f, 0.22989976f, 0.01810757f, -0.16982499f, -0.18100262f, -0.07399540f, 
    -0.20013815f, 0.08854331f, -0.08677400f, 0.02862796f, -0.00659017f, -0.04663363f, -0.20447236f, -0.05121832f, 
    0.03228193f, -0.00104452f, -0.08599509f, 0.03590280f, 0.03100645f, -0.38260499f, -0.20704658f, 0.08269755f, 
    -0.19178462f, 0.00059405f, -0.04151834f, -0.18881240f, -0.16360520f, -0.03523624f, 0.12259800f, -0.14594796f, 
    0.05364661f, 0.07989062f, -0.13059980f, -0.00843276f, -0.06082540f, -0.04759153f, -0.22457299f, -0.13628769f, 
    -0.31998917f, -0.59095079f, 0.20589823f, -0.20851779f, -0.09974625f, -0.13917848f, 0.16077480f, -0.33347914f, 
    0.25216305f, -0.08227579f, -0.01380354f, 0.02128587f, -0.12784413f, 0.10823119f, 0.03304623f, -0.07090593f, 
    0.06074251f, -0.03151533f, 0.07495350f, -0.21267600f, -0.03982421f, 0.15184727f, 0.33338937f, 0.06650183f, 
    0.07510348f, -0.04064000f, 0.10486940f, 0.01903260f, 0.23410569f, 0.00373622f, -0.01684895f, -0.03141797f, 
    0.01101996f, -0.00559709f, -0.04000116f, -0.10270939f, -0.00602909f, -0.19601592f, 0.10907714f, 0.05522985f, 
    0.13761015f, -0.04880267f, 0.06767917f, 0.08983112f, -0.00154148f, -0.09047308f, -0.05384960f, -0.06334323f, 
    -0.05510470f, 0.01207984f, 0.10782747f, -0.12083592f, -0.21009444f, 0.03438962f, -0.01900422f, 0.12558195f, 
    0.07342093f, 0.06295524f, -0.00282922f, -0.04665199f, -0.11636046f, -0.00103218f, 0.11855785f, 0.08213739f, 
    0.03560717f, -0.09795208f, 0.08151199f, -0.00343872f, 0.02770551f, 0.02027346f, 0.04093704f, -0.01311988f, 
    0.04409260f, 0.08635219f, 0.04487279f, 0.06824191f, 0.10207635f, -0.08710757f, -0.00159545f, 0.22788896f, 
    0.07385406f, 0.09174985f, -0.02946092f, -0.15576275f, -0.16496429f, 0.06031684f, 0.01752652f, 0.03762718f, 
    0.08427814f, 0.06274275f, 0.10681869f, 0.10484707f, 0.02188657f, -0.01301677f, -0.00991768f, 0.00310657f, 
    0.13678293f, -0.04482314f, -0.03346613f, 0.11920842f, 0.08462599f, 0.07416131f, 0.03795865f, 0.01227334f, 
    -0.00762321f, 0.01385819f, 0.06259212f, 0.05275373f, 0.04826953f, 0.09648279f, -0.00613160f, -0.15615055f, 
    0.01500293f, -0.10869741f, 0.12108425f, 0.12808596f, 0.04902646f, 0.01464525f, -0.04304545f, -0.05976380f, 
    0.14209126f, 0.08149935f, 0.35396478f, 0.17964503f, 0.26091152f, -0.09106734f, -0.03434233f, 0.04419671f, 
    -0.02804064f, 0.01215011f, 0.07577874f, -0.04378163f, -0.04726535f, 0.02265120f, 0.04251667f, 0.01587133f, 
    -0.04818752f, -0.14380711f, -0.01865534f, -0.20983839f, -0.05328933f, 0.06367232f, 0.12769458f, 0.17048293f, 
    -0.06841718f, 0.02235758f, -0.05598060f, 0.08437450f, -0.08222831f, 0.23802024f, -0.02887033f, 0.00493366f, 
    0.07604871f, -0.04714457f, -0.03270731f, -0.02633615f, -0.03073799f, -0.18008001f, -0.29289111f, -0.29938143f, 
    -0.23303249f, -0.42362726f, 0.06374847f, -0.25302649f, 0.02652591f, -0.11658519f, 0.00057546f, 0.00328721f, 
    0.00829266f, -0.15186159f, -0.10429908f, -0.20883001f, -0.07334182f, 0.09374851f, -0.08968611f, -0.00709405f, 
    0.00849325f, -0.11874106f, -0.05655988f, -0.07915803f, 0.21560292f, -0.08218382f, -0.33946294f, -0.00331244f, 
    0.12566122f, -0.13594660f, 0.03048934f, 0.07183328f, 0.04209210f, 0.06045121f, 0.00675247f, -0.02752142f, 
    -0.03278501f, -0.01609773f, 0.00622432f, 0.08377348f, 0.27586779f, 0.01485191f, 0.22760516f, 0.40937975f, 
    0.18199685f, 0.00185309f, -0.38631085f, 0.19721964f, -0.23102385f, 0.20853941f, -0.34140638f, 0.04035791f, 
    -0.06353400f, 0.07603190f, 0.03028448f, -0.02926398f, -0.05870228f, -0.15701953f, 0.06939803f, -0.09795800f, 
    0.01008082f, 0.06231342f, -0.56514132f, 0.08366432f, 0.14598809f, 0.25690725f, 0.31014448f, 0.09438801f, 
    0.11402629f, -0.19410411f, -0.08921315f, 0.05122830f, 0.04973416f, 0.14710468f, 0.00676538f, -0.04991325f, 
    0.03795926f, 0.00010509f, 0.06437731f, 0.04351954f, -0.10181873f, -0.09683468f, -0.09936354f, -0.18108669f, 
    -0.16287281f, 0.05020989f, 0.29715547f, -0.12016597f, 0.06743290f, 0.01059098f, 0.07446948f, -0.21430869f, 
    -0.13865982f, -0.13450629f, -0.05391253f, 0.02660908f, 0.04043403f, 0.09528502f, -0.04703144f, -0.10085841f, 
    0.12901393f, -0.02054223f, -0.13848692f, 0.03017628f, -0.35868388f, -0.16108875f, 0.08354769f, 0.04399598f, 
    0.13525796f, -0.07744782f, 0.09889113f, -0.10705647f, -0.10642727f, 0.09973080f, 0.02463672f, 0.05320527f, 
    -0.04743510f, -0.03359759f, -0.01359725f, -0.00750350f, 0.00821374f, 0.06724294f, -0.01226195f, 0.11859505f, 
    -0.38963398f, -0.08258481f, -0.17967364f, -0.64552265f, -0.41893575f, 0.04890595f, 0.01173080f, 0.05669421f, 
    0.11456901f, 0.13274562f, 0.11725172f, 0.03356083f, -0.03104402f, -0.15651406f, 0.00315405f, -0.05829733f, 
    0.02900877f, 0.04134642f, 0.03984918f, 0.25285563f, 0.07118452f, -0.06589884f, 0.01639440f, -0.00210879f, 
    0.26334485f, -0.10870457f, 0.11721686f, 0.02248072f, -0.00543707f, 0.03053085f, 0.06228522f, -0.03932760f, 
    -0.04746112f, -0.02004530f, 0.03633190f, -0.10214645f, -0.15473245f, -0.05833011f, -0.14063583f, -0.17523094f, 
    -0.08977938f, -0.07054918f, 0.05575685f, 0.01923378f, 0.07795211f, -0.08555001f, 0.03250924f, -0.09737337f, 
    -0.16774903f, -0.16190764f, -0.04841141f, -0.01006157f, 0.02292850f, 0.01133524f, -0.05854940f, 0.01392471f, 
    0.22190939f, 0.01380769f, -0.04096394f, 0.09688018f, 0.13086975f, -0.30132368f, 0.09603532f, -0.01784575f, 
    -0.02822033f, -0.22897810f, -0.11977027f, -0.23621061f, 0.16001788f, 0.01704628f, 0.15437314f, 0.02392781f, 
    0.07564965f, -0.30009729f, 0.13540645f, -0.14601338f, -0.15569247f, -0.05641935f, 0.00332609f, -0.02543549f, 
    0.17950855f, -0.03942854f, 0.10458845f, 0.00021917f, 0.00617497f, 0.12974574f, -0.04959379f, -0.01156720f, 
    -0.04114495f, 0.03205119f, -0.06691922f, -0.05102994f, -0.00028013f, 0.00677066f, 0.04812634f, -0.04397268f, 
    -0.12410997f, 0.04433940f, -0.04872432f, -0.18496764f, 0.28007340f, 0.35573635f, -0.43879479f, 0.39908782f, 
    0.28573760f, 0.06155346f, 0.06176687f, 0.12644288f, 0.20705344f, 0.19971505f, 0.03277618f, -0.03744498f, 
    0.00286869f, 0.04106187f, 0.01624483f, 0.07674501f, 0.11848935f, 0.15223627f, 0.07630005f, 0.15442793f, 
    -0.16397063f, -0.31387022f, -0.05935877f, 0.20991914f, 0.04193727f, -0.32073599f, -0.05975821f, 0.15030202f, 
    -0.22028218f, -0.18140846f, -0.04168637f, 0.00730509f, -0.01563028f, 0.03318603f, -0.09898183f, -0.11338353f, 
    -0.10610148f, -0.01798078f, 0.13232003f, 0.10329100f, -0.05253889f, -0.10766109f, -0.05613545f, -0.02576687f, 
    0.10767613f, -0.01170426f, 0.02460812f, 0.09975265f, -0.03223037f, -0.03767719f, 0.10384229f, -0.03149905f, 
    0.08642554f, -0.08204322f, 0.05461147f, -0.02140831f, -0.03412201f, -0.19707435f, -0.04929327f, 0.13507351f, 
    0.28754631f, 0.06082572f, 0.07269303f, 0.40430894f, 0.18177585f, -0.03742744f, -0.03287423f, -0.03517336f, 
    -0.11650870f, -0.02137069f, -0.03684485f, -0.00458020f, -0.03626643f, 0.02233792f, 0.09039509f, -0.03443199f, 
    0.00836725f, 0.01851813f, -0.09061980f, -0.18347393f, -0.25971311f, 0.10878239f, 0.08992431f, -0.43160623f, 
    -0.41946465f, 0.09916010f, 0.13029334f, -0.06541212f, 0.04330197f, 0.09526823f, 0.09719512f, -0.01867261f, 
    0.00029645f, 0.05810016f, -0.07273428f, -0.25597635f, -0.11704632f, -0.08938872f, -0.10396780f, -0.03863899f, 
    0.12025637f, 0.14935388f, 0.04185076f, 0.07444663f, 0.01515664f, -0.02909738f, -0.06644629f, -0.17254755f, 
    -0.00377647f, 0.11046758f, 0.32317463f, 0.01223446f, 0.02255417f, 0.04595955f, 0.03219715f, 0.12994885f, 
    0.03970703f, -0.03084069f, -0.06206179f, -0.01000849f, 0.06648327f, 0.03842844f, 0.08161729f, -0.05968757f, 
    -0.05835256f, 0.10230307f, 0.13639189f, -0.02416072f, 0.02685225f, 0.03718067f, 0.11957189f, 0.11396942f, 
    -0.10465717f, 0.00906937f, 0.16586040f, 0.01631637f, -0.12117722f, -0.00484860f, -0.02914312f, -0.05316383f, 
    0.06773115f, 0.00607918f, 0.09816185f, 0.00517120f, -0.03534717f, 0.04573597f, -0.02287973f, 0.02766459f, 
    -0.05143941f, 0.00454029f, 0.03352651f, -0.17207466f, -0.18770346f, -0.10157508f, -0.03434857f, 0.10663421f, 
    0.02920093f, 0.05531043f, -0.10584814f, -0.08763039f, 0.15552592f, 0.00009217f, 0.11147948f, 0.09181114f, 
    0.00686436f, -0.12239896f, -0.11930723f, -0.20298396f, -0.01311220f, -0.02799631f, 0.05926841f, -0.04848053f, 
    0.03312024f, 0.06233174f, 0.01030012f, 0.05446786f, -0.01902650f, -0.00541636f, -0.00586543f, -0.04169612f, 
    -0.04410538f, -0.01934705f, 0.24873404f, 0.06959475f, 0.23571935f, -0.11036692f, 0.17601398f, -0.12904523f, 
    0.09255772f, -0.01248159f, -0.00428641f, -0.16959772f, -0.00380872f, -0.03617837f, 0.02492521f, -0.12627290f, 
    -0.09192158f, -0.09792970f, 0.06404027f, -0.05835980f, 0.02710457f, 0.05329452f, -0.11596885f, 0.04928437f, 
    0.04220121f, 0.17545694f, 0.23166952f, 0.05359575f, -0.01696617f, 0.09535689f, 0.07387804f, 0.04113226f, 
    0.04851868f, -0.01384011f, 0.04834579f, 0.01616027f, -0.00484293f, -0.03374568f, -0.09200265f, -0.03536490f, 
    -0.75397378f, 0.29284915f, -0.05545484f, -0.19868773f, -0.12010024f, -0.06875113f, 0.20033401f, 0.10302511f, 
    -0.00886154f, -0.06997732f, 0.13060814f, 0.01569175f, -0.09705352f, 0.13927053f, 0.10344942f, -0.12713276f, 
    -0.04094535f, 0.01967391f, -0.00825349f, -0.00824673f, -0.32003564f, 0.33471516f, -0.09217377f, 0.28764561f, 
    -0.17067006f, 0.03307324f, -0.21413934f, -0.08215994f, 0.09777313f, 0.07248489f, 0.06235019f, -0.00030926f, 
    -0.16431603f, -0.07704218f, 0.14401981f, 0.04960087f, 0.07589475f, 0.07960181f, -0.10841588f, -0.01824520f, 
    0.15297313f, -0.13855967f, -0.37976986f, -0.62889832f, -0.11224218f, -0.04211511f, -0.05368822f, 0.03422714f, 
    -0.01955312f, -0.03927615f, 0.00018743f, 0.27592582f, -0.15110369f, -0.05974908f, 0.09669015f, -0.04353458f, 
    -0.18921793f, 0.03148784f, -0.01661369f, 0.06478393f, 0.30889431f, 0.29656139f, 0.14155397f, 0.02793389f, 
    -0.01149619f, 0.10975810f, -0.07016113f, 0.06816225f, -0.02828677f, -0.01465631f, 0.04460377f, -0.00327890f, 
    0.05754868f, 0.04400463f, 0.08392200f, 0.14937519f, 0.01833670f, -0.02511506f, -0.10395606f, 0.13175753f, 
    -0.40723759f, -0.18328369f, -0.23205435f, -0.28337431f, -0.12837970f, 0.06937004f, 0.04577062f, -0.00494939f, 
    -0.08400647f, -0.05780529f, -0.01477264f, -0.07346102f, 0.12289165f, -0.12370868f, -0.06075626f, -0.03823847f, 
    -0.00952248f, 0.07423623f, 0.04535630f, -0.00930501f, 0.01867916f, 0.07197034f, 0.26199424f, 0.15769748f, 
    -0.17540435f, 0.01119461f, 0.05908838f, 0.09912954f, 0.09030806f, -0.14203715f, 0.02181524f, -0.00112838f, 
    0.00943205f, 0.03814305f, 0.00831690f, 0.02532690f, 0.02120730f, -0.20101932f, -0.08296126f, -0.37146103f, 
    -0.13522382f, -0.10532034f, -0.10734329f, 0.06099079f, 0.13664570f, 0.01782295f, 0.02787210f, -0.06063682f, 
    -0.02559070f, -0.01261646f, 0.11054468f, -0.04492101f, -0.02544389f, 0.01556063f, 0.01910521f, -0.10069851f, 
    0.00671346f, 0.23500350f, 0.00625796f, -0.04714842f, 0.03087087f, -0.03261688f, -0.19391775f, 0.03518020f, 
    0.04259293f, 0.03954001f, -0.03445532f, -0.08006771f, 0.03023251f, 0.01818055f, 0.13554445f, 0.07876463f, 
    0.09245784f, 0.09874579f, -0.00762516f, -0.01648314f, -0.00754639f, 0.13629857f, 0.00891541f, 0.13453819f, 
    0.37130412f, -0.11574104f, 0.17105275f, 0.03192178f, -0.23109111f, 0.20299289f, 0.13436604f, 0.00898138f, 
    -0.16443597f, -0.02158718f, 0.03506838f, -0.01650035f, -0.05863459f, -0.04395950f, -0.02473229f, -0.04707092f, 
    0.04918341f, -0.01241579f, 0.06927072f, 0.03232314f, 0.18692952f, 0.03429556f, 0.16860884f, 0.04568950f, 
    -0.18232957f, -0.10328604f, -0.05971819f, 0.12959458f, -0.06508268f, -0.14843521f, -0.07622235f, -0.05841237f, 
    -0.03885972f, -0.12076727f, 0.02363177f, 0.06122914f, 0.09018096f, 0.12793882f, 0.02172086f, 0.21599549f, 
    -0.36770326f, -0.36165544f, -0.32087043f, -0.26201332f, 0.07438166f, 0.14282507f, -0.08873811f, -0.03479331f, 
    0.01894805f, 0.05289620f, -0.02142487f, 0.10036606f, 0.15251057f, -0.06967302f, 0.00682129f, -0.01194156f, 
    -0.00760769f, 0.08912846f, 0.04150181f, 0.14015438f, 0.04891789f, -0.02293631f, 0.34243217f, 0.09331665f, 
    -0.06451449f, 0.01629066f, 0.11789501f, -0.10266095f, -0.03354732f, 0.02919738f, 0.00029249f, 0.03016385f, 
    0.02471914f, -0.04215015f, -0.04362664f, -0.39071548f, -0.08172277f, -0.12282719f, 0.00166819f, -0.37670776f, 
    -0.86845571f, 1.32530439f, -0.04512369f, 0.34419397f, 0.14568029f, -0.05900512f, -0.12086718f, 0.09123427f, 
    0.03201645f, -0.27574790f, 0.05888299f, -0.06993793f, -0.15126449f, 0.11241594f, -0.01195153f, 0.08827285f, 
    -0.20328304f, 0.23886605f, 0.15290420f, -0.24603912f, -0.02638927f, -0.09667474f, 0.36500001f, -0.13136894f, 
    -0.12066989f, 0.07500688f, 0.02969621f, -0.12212846f, -0.13480651f, -0.14908120f, 0.12327725f, 0.02866887f, 
    -0.01191692f, 0.01687026f, 0.03437926f, 0.06463706f, 0.04632887f, -0.08304349f, 0.12086003f, 0.33168519f, 
    0.01782748f, 0.32660103f, 0.20552903f, -0.32813758f, 0.15499084f, -0.00537216f, -0.10251062f, 0.15098171f, 
    0.03784128f, 0.26677617f, 0.02012173f, 0.01260983f, 0.01332851f, 0.04690741f, -0.05691688f, 0.05494312f, 
    0.00089684f, -0.02268423f, 0.04805531f, -0.15676190f, -0.38785234f, 0.17752276f, -0.30070353f, -0.04227415f, 
    -0.13722669f, -0.16735616f, -0.17902462f, -0.03818971f, -0.06408952f, -0.08678466f, 0.06552454f, -0.05703506f, 
    -0.05862568f, -0.03081087f, -0.03979625f, -0.29311445f, -0.16258653f, 0.09194648f, -0.07897929f, -0.15799016f, 
    0.62017024f, -0.35500240f, -0.03401971f, 0.00878469f, 0.23745856f, -0.02927231f, -0.08819475f, -0.02557274f, 
    -0.05002548f, -0.02491788f, -0.11119701f, -0.02074808f, -0.05192935f, -0.04126022f, 0.32166123f, -0.18940160f, 
    -0.07415872f, 0.05439973f, 0.01356375f, -0.12455054f, -0.01817816f, -0.24999976f, -0.23911090f, -0.00216911f, 
    0.28401077f, 0.05813841f, 0.17030360f, -0.00858973f, -0.03128209f, 0.11069723f, 0.08273598f, -0.07557301f, 
    -0.00676717f, -0.07015079f, 0.02739921f, -0.13722654f, 0.12870060f, 0.09830653f, -0.14709744f, 0.06628632f, 
    -0.10020278f, 0.11642053f, 0.06196334f, 0.04896601f, -0.07719480f, 0.00763411f, -0.09904348f, -0.03928012f, 
    -0.00066800f, 0.00424671f, 0.02051099f, -0.02600133f, -0.01240691f, 0.05642786f, -0.04242269f, -0.04061844f, 
    -0.07037457f, 0.00789741f, -0.07385061f, -0.14215301f, -0.44567481f, 0.46388951f, -0.17741677f, 0.07598678f, 
    -0.08091713f, 0.07310177f, -0.12865219f, -0.01072609f, 0.00819907f, 0.09102183f, 0.06559172f, -0.11806152f, 
    0.07770797f, -0.06582206f, -0.07691887f, 0.00333397f, -0.02117081f, 0.02150963f, -0.02476656f, 0.01821260f, 
    0.11934004f, -0.11881452f, 0.11467644f, 0.00382997f, 0.04228930f, 0.04643857f, -0.02081938f, -0.07364944f, 
    0.11485466f, -0.08853071f, -0.04472696f, -0.13006137f, 0.00266672f, -0.01718814f, -0.08232706f, 0.06488483f, 
    0.06271423f, 0.05331276f, -0.03844580f, 0.19086951f, 0.37385273f, -0.05710615f, -0.12664010f, 0.08205707f, 
    -0.23163885f, 0.23373051f, 0.08350170f, -0.05367453f, 0.01114017f, 0.08419389f, 0.09447680f, 0.10635711f, 
    -0.01070310f, -0.05134091f, -0.06070829f, -0.13066231f, -0.22580954f, 0.17883298f, -0.15580562f, -0.17304219f, 
    -0.22741757f, -0.15293446f, -0.00093847f, 0.05418229f, -0.40818194f, 0.07314146f, 0.06804024f, -0.02306346f, 
    -0.04140317f, 0.18132792f, 0.08200366f, -0.03048086f, -0.07609437f, -0.03245419f, 0.14572856f, -0.03243347f, 
    -0.02352528f, 0.02920891f, 0.07625787f, 0.03131919f, -0.03715572f, 0.00833899f, -0.16982937f, 0.22443135f, 
    -0.01592694f, 0.03609923f, -0.33536163f, -0.12407770f, -0.04193621f, 0.17144687f, -0.13184951f, 0.10983015f, 
    -0.12487746f, -0.00520605f, 0.09817216f, -0.12510803f, -0.05934705f, 0.16068092f, 0.06028248f, 0.10242973f, 
    -0.38638481f, -0.14747296f, 0.21199240f, -0.04932168f, -0.08221940f, 0.07404591f, -0.00972295f, -0.10049610f, 
    0.28992936f, 0.07117399f, 0.01326558f, -0.03992772f, -0.03120814f, 0.04645846f, -0.02049496f, 0.01287560f, 
    0.01921170f, 0.11385197f, 0.10172252f, 0.18033163f, -0.23733401f, 0.11561053f, -0.10152336f, -0.69061965f, 
    0.24009265f, -0.05623634f, 0.02995075f, -0.04001758f, -0.05115031f, -0.08172167f, 0.18058798f, -0.11294910f, 
    -0.06894034f, -0.10771634f, 0.09037844f, -0.00071381f, -0.05320723f, 0.06876238f, 0.04561790f, -0.21272370f, 
    -0.13636118f, 0.10159103f, -0.02607593f, -0.27786034f, -0.14363378f, -0.07887182f, 0.04014089f, 0.08415373f, 
    0.00854553f, 0.07415122f, 0.03749783f, -0.14277317f, -0.13170153f, -0.12457431f, -0.01947999f, -0.01962665f, 
    0.06445933f, 0.03427793f, -0.04381730f, 0.01975861f, -0.00497684f, -0.11364935f, -0.14500509f, -0.05952651f, 
    0.14200251f, 0.04293887f, -0.01861461f, -0.05647761f, -0.12642044f, -0.02894530f, 0.17177835f, -0.07559461f, 
    -0.16623318f, 0.15311044f, 0.14066646f, 0.10588758f, 0.07058752f, 0.01433949f, 0.03508334f, 0.11231558f, 
    0.12769149f, -0.04801000f, -0.07395725f, -0.03899849f, 0.03263058f, 0.14542831f, 0.04124155f, -0.00131481f, 
    -0.08425845f, -0.10706432f, 0.23040572f, -0.10879545f, -0.00304693f, 0.05035276f, 0.07055890f, -0.01889169f, 
    0.02113134f, 0.13699517f, 0.02484879f, -0.10686906f, 0.12707470f, -0.20781818f, 0.07301366f, -0.09405182f, 
    -0.22520033f, -0.03475256f, 0.00110555f, -0.07850372f, -0.04387441f, 0.04311470f, 0.12358189f, 0.00449156f, 
    0.00704179f, -0.03320176f, -0.03195186f, 0.03634923f, 0.03975276f, -0.02686060f, 0.03210930f, 0.02458859f, 
    0.27957797f, -0.19438761f, 0.29675987f, 0.26816857f, -0.52487308f, 0.25837499f, 0.05191872f, 0.04010518f, 
    0.11535140f, 0.06193758f, 0.09371383f, 0.08669542f, -0.06564792f, 0.07163203f, 0.08121497f, -0.06652408f, 
    0.03757666f, -0.03811623f, -0.10180172f, 0.31299037f, -0.12510747f, -0.08495323f, -0.19015828f, 0.03781953f, 
    0.20095180f, 0.11800166f, -0.10440692f, 0.02334254f, -0.01927956f, -0.02443053f, -0.01020987f, -0.06801678f, 
    -0.01204653f, 0.00559257f, 0.03670962f, 0.12317243f, 0.11094026f, 0.18637937f, -0.07294531f, 0.03734657f, 
    -0.15314244f, -0.04858243f, 0.47609267f, -0.01124428f, 0.06632993f, 0.00523286f, -0.20939399f, 0.08535817f, 
    0.00519216f, 0.11586711f, -0.08098628f, 0.12493616f, 0.06497207f, 0.00235245f, -0.01601504f, 0.06128899f, 
    0.07791312f, 0.04323217f, -0.00191303f, -0.01918801f, -0.18887153f, -0.01430990f, 0.10048954f, 0.08399868f, 
    0.05825405f, -0.18641357f, 0.03299172f, -0.04440765f, -0.01910474f, 0.23114172f, 0.03638101f, -0.01343620f, 
    0.18867502f, -0.12765437f, 0.18057127f, -0.11431368f, 0.09711044f, -0.13095140f, 0.05101577f, -0.13082327f, 
    -0.72705686f, 0.46317351f, 0.01644416f, 0.01608234f, 0.55227131f, -0.14227910f, 0.02872320f, -0.09072106f, 
    0.15941423f, 0.01812978f, 0.22794919f, 0.16108760f, 0.26275414f, 0.10580923f, 0.00376535f, 0.04069304f, 
    0.08404946f, 0.04271930f, 0.02228540f, 0.05986608f, -0.60778481f, -0.51922554f, -0.75665259f, -0.28068471f, 
    0.20638266f, -0.11158646f, 0.11713312f, -0.04023045f, 0.08245397f, -0.45144102f, 0.02322937f, -0.07644738f, 
    -0.09358354f, 0.04000641f, 0.01714751f, -0.05064269f, 0.03833085f, 0.07252595f, 0.16712445f, 0.05720046f, 
    -0.51287818f, 0.47649595f, 0.40750569f, 0.00560280f, 0.07672092f, -0.10657553f, 0.01015247f, -0.14829707f, 
    -0.12267210f, 0.21798083f, -0.11931725f, -0.00495859f, 0.09097642f, 0.02478042f, 0.05666703f, 0.04597086f, 
    0.00377086f, -0.02868967f, -0.01505068f, -0.03777421f, -0.46160227f, -0.32132611f, -0.59160072f, -0.13627228f, 
    0.11513761f, -0.22066899f, -0.09504078f, -0.07627158f, -0.25201267f, -0.28791693f, -0.00163068f, -0.05278212f, 
    0.00781514f, -0.02049593f, -0.08216827f, -0.06223366f, -0.04809060f, 0.01327770f, 0.22329992f, 0.03512141f, 
    -0.05773015f, 0.04016291f, 0.06919707f, -0.11919437f, 0.01646201f, -0.02270694f, 0.00559001f, 0.00823027f, 
    -0.04904674f, -0.03636156f, -0.02197057f, -0.10050189f, -0.06855487f, -0.10875499f, -0.05554288f, -0.08633269f, 
    -0.10218013f, -0.02911031f, -0.11365446f, 0.08906223f, -0.12416105f, 0.05558563f, 0.09105974f, -0.10039890f, 
    0.01088504f, -0.05812387f, -0.02370541f, -0.06112861f, -0.02349194f, 0.02926801f, -0.04691730f, 0.05852319f, 
    -0.06466682f, 0.07709160f, 0.00237284f, -0.02319368f, -0.08292929f, -0.10728760f, -0.09023649f, -0.01729844f, 
    -0.48628119f, -0.32966518f, -0.58631778f, -0.07308496f, -0.10191279f, -0.19829023f, 0.02524989f, -0.18486075f, 
    -0.14637809f, -0.17126718f, 0.05385686f, -0.06860345f, -0.04972698f, -0.06545103f, 0.05812229f, 0.01542778f, 
    0.02572723f, 0.10165706f, 0.03127836f, -0.03176164f, -0.09156624f, -0.31212816f, 0.05432934f, -0.11181868f, 
    0.20256028f, -0.08684132f, 0.01944617f, -0.08914680f, -0.10379510f, -0.22182670f, 0.03037001f, 0.04817726f, 
    -0.04765473f, -0.04003185f, 0.05721029f, -0.00940797f, -0.01083099f, 0.09148600f, 0.11707222f, -0.07819147f, 
    -0.02437346f, 0.54547071f, -0.06378197f, -0.04835292f, 0.22848149f, -0.06106285f, 0.02436961f, -0.09762099f, 
    0.18011847f, 0.03132934f, 0.20650284f, -0.00035031f, 0.14598770f, -0.12883878f, -0.03132234f, 0.04238027f, 
    -0.00210897f, -0.06480783f, 0.03622684f, 0.01040994f, -0.26491016f, -0.02158017f, -0.22530746f, 0.01267978f, 
    -0.12807742f, 0.06438075f, 0.13136947f, 0.09840772f, -0.05836644f, 0.00737707f, -0.00803934f, -0.04576487f, 
    0.05658320f, 0.02465390f, -0.00813943f, 0.13559943f, 0.00054684f, 0.09752974f, 0.17651647f, 0.11108123f, 
    -0.48430800f, -0.27820376f, 0.54337937f, -0.05993573f, 0.08022799f, -0.17633006f, -0.00676784f, 0.15722933f, 
    0.30462974f, 0.05970664f, 0.15191172f, 0.07599836f, 0.16100422f, -0.02507394f, 0.16658995f, 0.05597336f, 
    0.06130078f, -0.00439350f, 0.00692986f, -0.11699331f, -0.91111493f, -0.52546537f, -0.26097536f, -0.25767007f, 
    -0.14643039f, 0.09631787f, -0.07470760f, -0.12196293f, -0.14816438f, -0.33095992f, 0.01280515f, 0.00125552f, 
    -0.10096641f, 0.06276913f, 0.01775222f, -0.00920242f, -0.01799636f, 0.10043817f, -0.08392834f, -0.06455948f, 
    -0.39724505f, -0.33357054f, -0.26522967f, 0.67766726f, -0.68131512f, 0.06225229f, 0.23981436f, -0.17771977f, 
    -0.02075089f, -0.57038289f, 0.05229593f, 0.03829407f, 0.01216379f, 0.11478363f, 0.07561359f, -0.07563625f, 
    0.02137508f, 0.20354134f, -0.06000347f, -0.03166077f, -0.12772919f, -0.53270185f, -0.60136354f, -0.32722852f, 
    0.57294858f, -0.18044859f, 0.02261775f, -0.06624614f, 0.01169748f, 0.06943143f, 0.00932614f, 0.00983102f, 
    0.09990726f, 0.01231482f, -0.15432630f, -0.07755274f, 0.00613048f, -0.08682369f, 0.14017786f, -0.05856559f, 
    -0.09635199f, 0.10154356f, -0.07641150f, 0.02213430f, 0.02839665f, -0.06033461f, -0.02713427f, -0.07508358f, 
    -0.01505931f, 0.13192372f, -0.00794427f, 0.00049485f, 0.14454897f, 0.09713311f, -0.07647177f, 0.07708683f, 
    0.13360853f, -0.06217624f, 0.24064173f, 0.22254325f, 0.34239432f, -0.07031594f, -0.24846557f, 0.13458030f, 
    0.03054538f, 0.01403277f, -0.03935794f, 0.19536062f, -0.00048594f, -0.04027247f, 0.00699920f, 0.04072371f, 
    -0.14286906f, -0.00950948f, 0.03996504f, 0.03656401f, 0.08882022f, 0.06872904f, -0.12486736f, 0.02802011f, 
    -0.20298484f, -0.46268961f, -0.54252452f, -0.05160833f, 0.13364671f, -0.04004006f, -0.07685816f, -0.01441571f, 
    -0.09013267f, -0.07771770f, -0.00372067f, -0.00276683f, 0.00600000f, 0.00131612f, -0.16521196f, -0.06441201f, 
    -0.03112435f, 0.09715946f, 0.09505086f, -0.02502738f, -0.14384779f, -0.03022985f, 0.30786505f, 0.28930148f, 
    0.48519126f, -0.10195198f, -0.03398560f, 0.02164898f, 0.00446432f, 0.38195130f, 0.00911328f, 0.09277273f, 
    0.06939255f, 0.03945611f, -0.03013084f, 0.03736088f, 0.10748854f, 0.00404045f, 0.03452012f, 0.00329499f, 
    -0.17130099f, 0.27699062f, 0.15982147f, 0.02456347f, 0.08950134f, -0.07242826f, -0.07254168f, -0.21697512f, 
    -0.04979044f, -0.02389099f, 0.01301513f, 0.13161238f, -0.08200893f, 0.06010713f, 0.03554024f, 0.03482480f, 
    -0.08157784f, 0.01429311f, -0.06238457f, -0.07527535f, -0.42046091f, -0.79417926f, -1.12296402f, -0.46229157f, 
    0.02983119f, -0.17622493f, 0.17747162f, 0.31579673f, 0.10110718f, -0.20263816f, -0.01499274f, -0.04986355f, 
    0.05003388f, -0.03889118f, 0.03069521f, -0.01977891f, -0.00861852f, 0.06289060f, 0.13937576f, -0.03329838f, 
    -0.01585322f, -0.69092494f, -0.39147705f, 0.13656746f, -0.09461079f, -0.02216732f, -0.24614142f, 0.05353664f, 
    -0.14323358f, 0.36994252f, -0.15217429f, -0.03404568f, 0.07955126f, -0.09655824f, 0.03838794f, -0.07601064f, 
    0.06216380f, -0.18603426f, 0.26594716f, -0.08058749f, 0.20133828f, -0.06925544f, -0.23207711f, -0.07972211f, 
    0.03058010f, 0.05742525f, -0.01366029f, 0.10963341f, 0.02565877f, 0.10603940f, -0.02477936f, 0.04008447f, 
    0.01541071f, -0.07474705f, 0.01310632f, 0.02436404f, 0.00704607f, -0.24968718f, 0.08295722f, 0.06165640f, 
    -0.83688337f, -0.40318546f, -0.01603073f, -0.07407179f, -0.36186180f, -0.44819039f, 0.03999738f, -0.05402720f, 
    -0.06662302f, -0.10586338f, 0.11993413f, 0.10997880f, -0.07455766f, -0.00699298f, 0.03568837f, 0.00290945f, 
    -0.02313320f, 0.00313312f, -0.01839854f, -0.17432868f, -0.09525083f, -0.07197568f, 0.10346790f, -0.13267946f, 
    0.00692537f, 0.06602382f, 0.05627080f, -0.04156109f, 0.01204477f, -0.13320924f, 0.01402572f, -0.05863113f, 
    0.10321487f, 0.03134867f, 0.14248663f, 0.14359474f, 0.07279637f, 0.06209209f, -0.38101465f, 0.02163755f, 
    -0.53640020f, 0.25013176f, 0.41419673f, -0.19722424f, -0.14011012f, -0.10940554f, -0.06758457f, -0.12203282f, 
    -0.16409677f, 0.07077370f, -0.12428181f, 0.03110673f, -0.00507396f, -0.00661488f, 0.07523046f, 0.02055282f, 
    -0.06609369f, 0.04200708f, -0.02415342f, -0.02400375f, -0.00381398f, -0.05747870f, -0.08819271f, -0.09354082f, 
    -0.00991084f, 0.00815860f, 0.00881183f, -0.09542210f, -0.01231122f, 0.04714909f, -0.01045806f, -0.13851485f, 
    -0.10881985f, -0.11790853f, -0.10398152f, 0.08932763f, -0.00149144f, -0.04665684f, -0.09066572f, 0.03967947f, 
    -0.02629906f, 0.01413671f, 0.14698298f, -0.01837021f, -0.05596004f, -0.00549646f, -0.04511979f, -0.01004969f, 
    -0.08734834f, 0.07255704f, -0.02831716f, 0.03793579f, 0.09682715f, 0.07729039f, 0.04719466f, 0.05130431f, 
    -0.08306787f, -0.09627537f, -0.07720322f, -0.08305272f, -0.52487582f, 0.65954125f, 0.30555570f, -0.07244500f, 
    -0.04465206f, -0.20950596f, -0.03950876f, -0.21295834f, 0.02838075f, 0.12440147f, -0.12097973f, 0.06961891f, 
    -0.04217771f, 0.06627697f, 0.05629588f, 0.01825950f, -0.06899553f, 0.05410993f, 0.00388366f, -0.03093752f, 
    0.10682357f, -0.60560834f, -1.18048656f, -0.30850753f, 0.38835686f, -0.06748593f, 0.09784856f, 0.05463659f, 
    0.01144311f, -0.03894760f, -0.00044691f, -0.00057445f, -0.06219631f, -0.00532104f, 0.07083025f, 0.04226574f, 
    0.05812053f, 0.11273027f, 0.26581627f, 0.14109848f, 0.18527822f, -0.23122977f, -0.12001887f, 0.08254232f, 
    0.08881804f, 0.02668927f, 0.00725432f, 0.15422091f, 0.04365383f, -0.02223447f, -0.01719282f, -0.02728133f, 
    -0.15897922f, -0.07974774f, -0.00405941f, -0.14325124f, -0.07181498f, -0.02812489f, -0.05370025f, -0.01773502f, 
    0.49059662f, -0.62475872f, -0.16184539f, -0.30726996f, 0.04813584f, -0.05786086f, 0.04094807f, -0.15715247f, 
    0.07730616f, 0.04512224f, 0.00051170f, -0.01610083f, -0.09681538f, -0.00686419f, 0.06407531f, -0.11182843f, 
    -0.01019134f, -0.12572230f, 0.08627794f, 0.04174716f, 0.34190908f, 0.25213054f, -0.08896908f, 0.00772108f, 
    -0.32185403f, 0.11255568f, 0.02782006f, 0.03037568f, -0.04854706f, -0.12492031f, -0.13634811f, 0.00892025f, 
    -0.12945375f, -0.05254662f, -0.03435129f, -0.09315739f, -0.05410125f, -0.01357917f, -0.08292697f, -0.13329880f, 
    -0.60161811f, -0.89412761f, 0.08570942f, -0.07776909f, 0.00250555f, 0.03271266f, -0.03822391f, 0.33931211f, 
    -0.02907084f, 0.06652975f, -0.15483992f, 0.16759135f, 0.01948441f, 0.05234604f, -0.02441601f, -0.06012462f, 
    0.04261969f, -0.03610034f, 0.11774980f, 0.07701014f, -0.38336760f, -0.32221976f, 0.07197352f, 0.30503714f, 
    -0.05347343f, -0.01498695f, 0.18134917f, 0.16945094f, 0.09354793f, 0.10516748f, 0.03176673f, -0.01299950f, 
    0.02914693f, -0.07896588f, -0.08345462f, 0.01382400f, -0.00233799f, -0.13369498f, 0.01146272f, 0.12514693f, 
    0.33131787f, -0.13699245f, -0.22576867f, -0.20971927f, -0.18689069f, -0.02798170f, -0.08702799f, 0.09005482f, 
    0.11875714f, 0.18625882f, -0.02536955f, -0.02328001f, 0.11859098f, 0.00271439f, 0.09770489f, 0.01920369f, 
    -0.01758616f, -0.00010596f, 0.10727604f, 0.02295263f, -0.02785310f, -0.34474137f, -0.06269512f, 0.16690184f, 
    -0.17960218f, 0.06807028f, 0.03908477f, -0.15270934f, 0.14008106f, 0.12619589f, 0.00459493f, -0.01829443f, 
    -0.06833147f, -0.06588092f, 0.00014977f, 0.01563247f, 0.07200865f, -0.09350972f, 0.06366738f, -0.08617780f, 
    -0.00847103f, 0.06320927f, 0.02027031f, 0.02511089f, -0.07440975f, 0.01984465f, 0.03874722f, 0.05450271f, 
    -0.04840216f, -0.03035616f, 0.05645644f, -0.01965348f, 0.03898128f, 0.00761548f, -0.01476693f, 0.02713811f, 
    0.06703205f, -0.10498534f, 0.01764835f, -0.02597564f, 0.09733506f, 0.15155573f, -0.00221326f, -0.02022096f, 
    -0.10195758f, 0.02554032f, 0.04516035f, 0.01118661f, -0.04303449f, -0.05180600f, -0.12074944f, -0.21288908f, 
    0.02366129f, -0.02228510f, -0.03453715f, -0.02630212f, 0.00389979f, 0.04564407f, -0.01082292f, -0.02217693f, 
    -0.72561830f, -0.65760857f, -0.26900387f, 0.32284871f, 0.23691152f, -0.04910621f, 0.01199288f, 0.10551550f, 
    0.05432575f, -0.02292795f, -0.00422835f, 0.07118442f, -0.03841570f, 0.03287479f, 0.04019789f, -0.03226511f, 
    0.03474476f, 0.00671077f, 0.02961892f, -0.10018744f, -0.23484898f, -0.39990079f, -0.14662468f, 0.28482342f, 
    -0.11342507f, 0.16132130f, 0.05157615f, 0.08884430f, 0.02392741f, 0.04130049f, -0.09684041f, -0.00285405f, 
    0.07548471f, -0.03630914f, 0.02121411f, -0.02049685f, 0.01308341f, -0.06405798f, -0.04496227f, 0.00704053f, 
    -0.21492386f, 0.01801420f, -0.09869380f, -0.11028215f, -0.01246186f, 0.04505245f, -0.06309652f, 0.11655977f, 
    -0.07964803f, 0.05575886f, -0.26692066f, 0.10736526f, -0.00920187f, 0.07654347f, -0.00343785f, 0.03954299f, 
    0.03644136f, 0.00243676f, 0.01532309f, -0.01350996f, 0.07216749f, 0.15064771f, 0.04989125f, 0.05647595f, 
    0.05475642f, 0.10216682f, -0.02237272f, -0.08692026f, -0.04799647f, 0.00712736f, 0.05767610f, 0.00156339f, 
    0.04770309f, 0.01407411f, -0.00990609f, 0.12563801f, 0.06861029f, -0.04688331f, 0.01023358f, 0.00788244f, 
    0.68556201f, 0.30315223f, -0.36017904f, 0.24349880f, -0.27937648f, -0.07287662f, -0.13840285f, 0.10657115f, 
    -0.11835959f, 0.14548613f, -0.00218791f, -0.06062200f, 0.01082994f, -0.04730405f, -0.08131137f, 0.02631722f, 
    -0.06273565f, 0.09346443f, -0.16084166f, 0.03672665f, 0.33041513f, -0.27873367f, 0.62795198f, -0.22987860f, 
    -0.08852253f, -0.20217320f, 0.15597641f, 0.04039759f, 0.11163799f, -0.00170226f, -0.01206667f, -0.02136984f, 
    0.05122649f, -0.06846160f, 0.01967510f, 0.04317166f, -0.00965206f, -0.16846325f, -0.02234410f, 0.13188194f, 
    -0.40804106f, -0.97885215f, 0.92044634f, -0.36451906f, 0.44477808f, -0.03497029f, -0.25270855f, 0.11956953f, 
    0.13954480f, 0.03276770f, 0.02319239f, -0.00558965f, -0.03487847f, -0.06169387f, -0.04813953f, 0.01913647f, 
    -0.04270988f, 0.11970030f, -0.18398777f, -0.13027070f, 0.42762232f, -0.56339848f, -0.46947592f, -0.36155593f, 
    -0.18146920f, 0.15218638f, 0.02382482f, -0.08163403f, 0.14045988f, 0.01044283f, 0.02110058f, 0.05238322f, 
    -0.06041846f, 0.09504951f, 0.04125681f, -0.18409657f, -0.11093586f, 0.06091428f, -0.02202391f, 0.07591562f, 
    0.05640598f, 0.04416976f, -0.14784500f, 0.13198480f, -0.30788299f, 0.05000867f, 0.02709784f, 0.05067940f, 
    0.00557132f, 0.03395502f, -0.11163413f, -0.03639389f, -0.18261075f, -0.06896446f, -0.03483133f, 0.04334314f, 
    -0.01186192f, -0.16090286f, -0.00147093f, 0.01940794f, -0.08024243f, 0.09331702f, 0.13055658f, -0.03791028f, 
    -0.13455670f, -0.04102454f, 0.03781310f, -0.07804330f, -0.01529690f, 0.01167406f, 0.09863044f, 0.02322420f, 
    0.00651510f, 0.02701830f, -0.02224553f, 0.09286238f, -0.16960369f, -0.22662458f, -0.03653490f, -0.03870260f, 
    -0.00133621f, -0.42168629f, -0.32156244f, -0.34228894f, -0.10967059f, -0.08129724f, -0.04435305f, -0.03022729f, 
    0.09833215f, -0.02924863f, -0.01372855f, 0.05346372f, -0.06806258f, -0.08260518f, 0.04232588f, 0.06050585f, 
    0.10320678f, -0.06505176f, 0.05455037f, -0.10748745f, 0.81557268f, 0.12124465f, -0.43099678f, -0.25954178f, 
    -0.34825617f, 0.05446531f, 0.13797401f, -0.06127482f, -0.16944848f, -0.04486668f, 0.04986116f, -0.07444780f, 
    0.07407399f, -0.01490135f, 0.01524793f, -0.04732941f, -0.10229230f, -0.03383272f, 0.03450020f, -0.04876343f, 
    -0.16766584f, -0.16440380f, 0.01782385f, -0.11568064f, -0.01056789f, 0.00848452f, 0.03981225f, 0.06309172f, 
    0.00235094f, 0.02035631f, 0.00026693f, 0.02152106f, 0.06245469f, 0.00535615f, -0.04107780f, -0.02201864f, 
    -0.01547743f, 0.03702125f, -0.14864300f, -0.00979953f, -0.64786339f, 0.25122204f, -0.04303569f, 0.21746516f, 
    -0.09386037f, -0.01461150f, 0.01721435f, -0.07403331f, -0.13422121f, -0.04913067f, 0.05691503f, 0.03728897f, 
    0.06977369f, 0.03784098f, -0.00057395f, 0.07396600f, 0.10918231f, -0.09800159f, -0.09286998f, 0.01094340f, 
    0.75519907f, -0.54735792f, -0.66695559f, -0.25777122f, 0.11665299f, 0.15835451f, 0.26195407f, -0.30223700f, 
    0.30070585f, -0.07485884f, 0.07309382f, 0.05193520f, -0.01745531f, 0.00539368f, 0.06835351f, -0.04339496f, 
    -0.06011098f, 0.06509766f, -0.05022862f, -0.14533982f, 0.01205172f, 0.00092307f, -0.07200758f, -0.03619716f, 
    -0.06495186f, 0.02187826f, 0.12227318f, -0.02132267f, -0.05250048f, -0.02709010f, 0.00128849f, 0.00366905f, 
    0.02092771f, -0.00862909f, 0.01149026f, -0.22375154f, 0.06097453f, -0.02129194f, 0.04984435f, 0.03189468f, 
    0.43781260f, -0.56860048f, -0.02513607f, -0.33795425f, -0.00740199f, 0.21137184f, -0.22395757f, 0.21372670f, 
    0.06145773f, -0.03164995f, 0.01236664f, 0.04351257f, 0.06108422f, -0.01834214f, -0.01028307f, 0.02267369f, 
    -0.04524910f, 0.11429295f, -0.09318952f, 0.07131916f, -0.26949707f, -0.07675824f, 0.16481009f, 0.00061030f, 
    0.16184379f, -0.00512793f, 0.07944957f, 0.15424678f, -0.00046353f, 0.04680283f, 0.06205451f, -0.10872341f, 
    0.13898262f, 0.00533052f, -0.12802640f, -0.10021026f, 0.00711921f, -0.21126707f, 0.02608093f, 0.06652527f, 
    0.54900378f, -0.31739271f, -0.23069446f, -0.17358442f, -0.10622527f, 0.07927696f, -0.06067161f, 0.01162400f, 
    -0.00603061f, 0.08027653f, 0.07121108f, -0.00913876f, 0.08806331f, 0.03522825f, 0.01207286f, -0.00221746f, 
    0.01048950f, -0.03775315f, 0.00080902f, -0.03431931f, 0.07734963f, 0.16192663f, 0.04973727f, -0.04823874f, 
    -0.03763146f, -0.04383975f, 0.02291680f, -0.01047817f, -0.04767780f, -0.03522116f, 0.07367565f, -0.01687478f, 
    -0.08814584f, 0.00900340f, -0.08232369f, -0.05119081f, -0.02243442f, -0.02368670f, 0.10003515f, 0.00605050f, 
    -0.05356802f, 0.09523084f, 0.02259022f, -0.08540314f, 0.00016856f, 0.04927206f, 0.02432819f, 0.02404325f, 
    -0.03182410f, -0.05402635f, -0.06957258f, -0.17423940f, -0.13300690f, -0.06007385f, 0.06271036f, 0.06156842f, 
    -0.00016934f, -0.01061175f, -0.00257877f, -0.02916707f, 0.30159199f, -0.59525967f, -0.21008576f, -0.28336090f, 
    -0.14851502f, -0.02657626f, -0.08070042f, 0.00456163f, 0.17762996f, -0.22187826f, -0.01535045f, -0.05918943f, 
    0.07305987f, 0.00119290f, 0.06568990f, 0.03188015f, -0.03295603f, 0.00332602f, 0.06011818f, -0.04957888f, 
    -0.80018377f, -0.57187688f, -0.30271780f, 0.32025126f, 0.16867422f, 0.04793558f, -0.01944704f, -0.00192475f, 
    -0.21341382f, -0.05394175f, -0.01856245f, -0.00161242f, -0.07222552f, -0.00896682f, -0.07282371f, -0.00813360f, 
    -0.03663921f, 0.02090114f, -0.04774449f, -0.01939609f, -0.01031140f, 0.07998689f, 0.02908563f, 0.02967831f, 
    -0.08878747f, 0.03844057f, 0.05912152f, 0.01835780f, -0.00161059f, -0.03957177f, 0.01535829f, 0.01002812f, 
    0.01005100f, 0.00202826f, -0.07675377f, -0.05306028f, -0.12668584f, 0.11432666f, -0.00862145f, -0.01831795f, 
    0.04035194f, -0.17542836f, -0.59249389f, -0.05463368f, 0.11479890f, 0.10933071f, 0.03270214f, 0.26922098f, 
    0.18768346f, 0.02017291f, -0.00520782f, -0.04760802f, -0.02467171f, 0.06227022f, 0.16470744f, -0.01992862f, 
    -0.00379550f, 0.10310896f, -0.12357430f, 0.02589273f, 0.26043138f, 0.00038930f, -0.16435781f, -0.25998420f, 
    -0.00619732f, -0.00502773f, 0.20009969f, -0.01321482f, 0.01691309f, -0.18066913f, 0.09953256f, 0.11034464f, 
    0.10266767f, 0.06018993f, 0.12379075f, -0.01362364f, -0.08228365f, 0.02492707f, 0.21378490f, 0.06229720f, 
    0.05275869f, -1.01927960f, -0.04965889f, 0.05282997f, 0.42131513f, -0.14789829f, 0.09908539f, 0.00536931f, 
    -0.10420150f, 0.03884675f, 0.06692503f, -0.05863906f, -0.06368390f, 0.01031608f, -0.03720330f, -0.07922557f, 
    -0.04603149f, 0.00230932f, -0.18209666f, -0.16011080f, -0.12179141f, -0.35773900f, -0.24367678f, -0.14255993f, 
    -0.03634012f, 0.00361415f, -0.01115685f, 0.07543048f, 0.08061939f, -0.36710760f, 0.05627609f, 0.00575017f, 
    0.06084681f, 0.00701220f, 0.05494726f, 0.04730648f, 0.06387287f, 0.07959155f, -0.02556737f, -0.10419060f, 
    -0.19008212f, -0.49995294f, -0.41263789f, -0.13105072f, 0.03976206f, -0.09786417f, 0.12459593f, 0.15006103f, 
    0.10303550f, 0.14475623f, 0.11007287f, -0.07499897f, -0.04770222f, -0.04108403f, -0.07204652f, -0.02339222f, 
    0.03202008f, -0.02415270f, 0.02362101f, -0.02356614f, 0.09047160f, -0.14515346f, -0.31402215f, -0.34394470f, 
    -0.17822658f, -0.10056546f, -0.16705535f, -0.03724007f, -0.17806445f, -0.24143787f, 0.02398004f, -0.00961634f, 
    -0.02733313f, 0.07435025f, 0.05388108f, 0.08765150f, 0.06036129f, 0.12382501f, -0.13369852f, -0.25359845f, 
    -0.40445486f, 0.07594895f, 0.16623417f, 0.04019221f, -0.17108560f, -0.13071774f, -0.01756380f, -0.07815497f, 
    -0.02992187f, -0.02183935f, -0.11167729f, -0.06166396f, 0.02242761f, 0.01364593f, 0.02097844f, 0.00895335f, 
    0.00138764f, 0.03765357f, -0.02834064f, 0.06204338f, -0.13943179f, -0.12246238f, -0.05225289f, -0.07699034f, 
    -0.19040380f, -0.12212497f, 0.05031900f, 0.02825144f, -0.01971343f, -0.04338350f, 0.13955136f, 0.07393854f, 
    0.03624958f, 0.02101496f, 0.07097299f, -0.00381875f, 0.16683526f, 0.09009641f, 0.10606077f, 0.05041945f, 
    0.75043851f, -0.31487876f, -0.47978720f, -0.19132476f, 0.13718693f, 0.03928689f, -0.16170214f, -0.06867854f, 
    0.06443843f, 0.11759946f, -0.06630597f, 0.01073512f, 0.07299741f, -0.00723772f, 0.06665208f, -0.00407389f, 
    0.05016329f, 0.10569637f, -0.08290140f, 0.24764746f, 0.32533538f, 0.01935274f, -0.12545754f, -0.02392334f, 
    -0.01667989f, -0.03387945f, -0.12800372f, -0.07039708f, -0.02918677f, -0.17348623f, -0.08076733f, 0.11984257f, 
    0.14014970f, -0.05446859f, 0.02374577f, -0.07935092f, 0.10360377f, 0.15369436f, 0.18103738f, 0.19641821f, 
    -0.29306421f, -0.49854854f, 0.05350145f, -0.16026551f, 0.12526786f, 0.03287741f, 0.10119948f, 0.09167304f, 
    -0.05074105f, 0.08208089f, 0.12270575f, 0.15501282f, 0.02748119f, 0.09842028f, 0.02170420f, 0.01492837f, 
    0.06582056f, 0.02871678f, 0.10499012f, -0.01761148f, 0.20050009f, 0.18768902f, 0.30624041f, 0.06184064f, 
    -0.14409663f, 0.01718456f, -0.16092597f, -0.06106171f, 0.02307557f, -0.03849924f, -0.07380233f, -0.00917113f, 
    -0.04053397f, -0.07619084f, -0.01463973f, -0.22054483f, -0.08509939f, -0.21057335f, -0.23631050f, -0.50893134f, 
    0.44010240f, 0.01057161f, 0.05518084f, 0.01588813f, -0.00764550f, -0.07958319f, 0.28447083f, 0.21322815f, 
    0.29841688f, -0.39700276f, 0.01023220f, 0.14190942f, 0.01337776f, 0.02064455f, 0.26443794f, -0.03423491f, 
    -0.02261902f, -0.05444213f, 0.15429297f, -0.03149581f, 0.06759256f, -0.56907248f, -0.60800248f, -0.24134476f, 
    -0.15289624f, 0.01728033f, -0.01470120f, 0.07718153f, -0.02066970f, 0.02752989f, 0.02561992f, 0.07332654f, 
    0.00079991f, 0.02607802f, 0.05875945f, 0.04717460f, 0.11499628f, 0.08626047f, 0.08261560f, 0.04501334f, 
    -0.06354985f, -0.93397784f, -0.24496441f, 0.17825300f, 0.13128336f, -0.06195084f, 0.05293433f, 0.10072044f, 
    -0.16327572f, -0.01753418f, 0.00581571f, 0.05641955f, 0.08937395f, 0.11767615f, 0.15444656f, 0.07772797f, 
    -0.10810981f, -0.13556047f, -0.07888768f, -0.12937289f, 0.05033388f, -0.37771827f, -0.72782958f, -0.34627667f, 
    0.10711837f, -0.09656272f, 0.16681415f, 0.02757516f, 0.25236771f, -0.01155613f, -0.00380877f, -0.03953207f, 
    -0.02449013f, -0.05727948f, 0.00538692f, 0.15556146f, -0.06646712f, -0.07577103f, -0.01667205f, -0.12873335f, 
    0.05215131f, 0.26281562f, 0.17344430f, -0.10795023f, -0.40497530f, -0.06829085f, -0.10470766f, -0.17466909f, 
    -0.00228732f, -0.10278630f, -0.02208548f, -0.00280937f, 0.06787455f, -0.05760343f, -0.04372100f, -0.10681107f, 
    0.03841203f, -0.03184077f, -0.21099262f, -0.39014655f, -0.14557141f, 0.05347615f, 0.06722226f, 0.15066001f, 
    -0.14878175f, 0.04275347f, 0.07392529f, -0.05779174f, -0.08538796f, 0.06952486f, 0.00076870f, 0.03239038f, 
    0.03162306f, 0.03950806f, 0.00792921f, 0.09303690f, -0.00713215f, 0.09891415f, 0.01996438f, 0.14974740f, 
    0.17720997f, -0.13801230f, -0.56247211f, -0.28137931f, 0.01799664f, -0.08097613f, 0.02644968f, 0.08146599f, 
    -0.04332075f, -0.11499449f, 0.01648924f, -0.06417102f, -0.02292883f, 0.00958283f, 0.15755896f, 0.04754376f, 
    -0.03023210f, 0.05906940f, 0.00759714f, -0.05746817f, 0.32883203f, -0.24635217f, -0.42440045f, 0.05499150f, 
    0.02747777f, 0.05779518f, 0.19047889f, 0.16923358f, 0.10153229f, 0.00281021f, 0.07180072f, -0.04218822f, 
    -0.05680571f, -0.03810734f, -0.10025220f, 0.06181667f, 0.10619864f, -0.07978608f, -0.05712152f, -0.11032138f, 
    0.07135414f, -0.23536767f, -0.17888518f, 0.16425923f, -0.05269651f, -0.10003652f, 0.08903572f, -0.03348203f, 
    -0.06057299f, 0.06555535f, 0.10701369f, -0.01085839f, -0.10153804f, 0.00233751f, -0.02443570f, -0.01700397f, 
    0.19318260f, -0.01943182f, 0.19172366f, -0.01581328f, -0.44904453f, 0.19321537f, 0.36188397f, 0.18824421f, 
    -0.10904535f, 0.10925189f, -0.09791423f, -0.05522369f, -0.02020478f, -0.25192544f, -0.10573358f, -0.11335215f, 
    -0.02329767f, -0.10849604f, -0.02673264f, -0.10138725f, -0.09183303f, -0.17785645f, -0.25016466f, -0.29303721f, 
    -0.08165304f, -0.38964355f, -0.65300739f, -0.56408948f, -0.14059553f, 0.00568763f, -0.07834500f, 0.07259869f, 
    0.22371472f, 0.09752643f, 0.00518358f, -0.00735527f, -0.02582068f, 0.07135800f, 0.04204259f, 0.11646712f, 
    -0.07202905f, -0.04059324f, 0.00569199f, -0.12351567f, 0.01035413f, 0.19084190f, -0.04028848f, 0.01507885f, 
    -0.11524378f, -0.01069031f, -0.00780932f, 0.01232633f, -0.01676315f, -0.16384935f, 0.00228972f, -0.02254722f, 
    0.06870161f, -0.04085554f, 0.04921577f, -0.06265755f, 0.20912248f, 0.09220456f, 0.14908665f, 0.02742401f, 
    -0.19845378f, -0.58752000f, -0.54960150f, 0.03198558f, 0.03304441f, -0.01129856f, 0.19515680f, 0.04070113f, 
    -0.08358205f, -0.07867642f, 0.03258703f, -0.04724208f, -0.03964501f, -0.05633598f, 0.05082739f, 0.04757693f, 
    0.04063739f, -0.03446387f, 0.05356434f, 0.06671375f, -0.60943019f, -0.41339391f, 0.32295197f, 0.20295486f, 
    0.18746977f, -0.12797950f, -0.06876931f, -0.02744741f, -0.07961003f, -0.02830706f, 0.02036857f, -0.04632631f, 
    0.14503255f, 0.07576267f, 0.05351522f, -0.10518995f, -0.04935425f, -0.10560752f, -0.25711218f, 0.12469230f, 
    -0.02562940f, -0.37145337f, -0.34577784f, -0.21701618f, 0.08062892f, -0.08866489f, -0.06118149f, 0.05235637f, 
    0.04609748f, 0.19808990f, 0.06215202f, 0.01985308f, -0.12472364f, -0.06851352f, -0.05274320f, -0.02281705f, 
    0.05424203f, 0.06872259f, 0.03231445f, 0.04739437f, -0.19401598f, -0.03077132f, 0.05115053f, 0.02847597f, 
    -0.20033421f, -0.04422474f, -0.01477681f, -0.12535140f, -0.04408990f, -0.00454591f, -0.07753314f, -0.00398009f, 
    0.03696145f, 0.03488187f, 0.07555155f, 0.08577414f, 0.07434968f, 0.05506171f, -0.05351640f, 0.06350459f, 
    -0.03418920f, -0.05922325f, -0.09952907f, 0.03743742f, -0.16511571f, -0.07201947f, -0.02572957f, -0.00012989f, 
    0.00844608f, -0.00814493f, 0.12969933f, -0.03993198f, 0.09007005f, 0.09725121f, 0.13557571f, -0.04923474f, 
    0.10690474f, 0.07657203f, 0.12629203f, 0.06529095f, 0.20022428f, -0.49872085f, -0.59058565f, -0.02217106f, 
    0.14543849f, -0.02762873f, 0.07019807f, 0.05405882f, 0.01993979f, 0.12982862f, 0.04084542f, -0.09432039f, 
    -0.10697658f, -0.04132231f, -0.03822469f, -0.04133928f, 0.02849749f, 0.01600154f, -0.00526185f, 0.00941963f, 
    1.12955093f, 0.23720275f, 0.02965268f, 0.14344980f, -0.05337460f, 0.13604191f, -0.15336692f, -0.07866103f, 
    0.02720087f, -0.02515397f, 0.10667410f, 0.05216385f, 0.12797567f, 0.06620410f, 0.05211843f, -0.01885229f, 
    0.08842389f, 0.02416465f, -0.03109279f, -0.04913000f, -0.11626681f, 0.08033928f, 0.00080907f, 0.01252675f, 
    -0.17347251f, -0.09746815f, -0.11127799f, -0.02946676f, -0.01457461f, -0.13311061f, -0.06959985f, 0.05493636f, 
    0.00284060f, 0.05194764f, 0.03945323f, 0.02863884f, 0.14953387f, 0.09950747f, 0.16348936f, 0.10480209f, 
    -0.08060791f, -0.00887420f, 0.14226557f, 0.38793516f, -0.30561730f, -0.20100339f, 0.05774236f, -0.40226242f, 
    -0.07808392f, -0.02499969f, 0.10868894f, -0.16385815f, 0.05939759f, 0.01450614f, 0.01052627f, 0.13530852f, 
    0.06921320f, -0.07416712f, 0.01039660f, -0.00131693f, -0.70298779f, -0.05772080f, -0.08756720f, 0.43252796f, 
    0.02096586f, 0.05080039f, 0.10088771f, -0.17061266f, -0.18398546f, -0.04545006f, 0.10233648f, 0.05944578f, 
    0.02162374f, -0.11403458f, 0.01179017f, -0.00127617f, -0.00942506f, -0.11195046f, 0.11271081f, 0.04254134f, 
    -0.05000186f, -0.33339173f, 0.01890500f, 0.16479342f, -0.72215885f, 0.02241422f, -0.18531851f, -0.21232609f, 
    0.02093066f, -0.26530451f, -0.00202823f, -0.00997898f, 0.00820535f, 0.07186265f, -0.07804946f, 0.10438685f, 
    0.09649724f, -0.06570530f, 0.02999065f, 0.08970078f, -0.49376464f, 0.17508583f, -0.24136536f, 0.01142840f, 
    -0.22403406f, -0.12409374f, -0.06219043f, -0.07041429f, -0.11705358f, 0.13121097f, -0.02266471f, 0.04898672f, 
    -0.01095690f, -0.09034462f, -0.01687779f, -0.01830368f, -0.04052004f, 0.19710082f, -0.01466736f, -0.02539062f, 
    0.21225496f, 0.00997052f, 0.49730703f, 0.29728806f, -0.32896212f, 0.13018146f, -0.19262749f, -0.30394229f, 
    -0.06983107f, -0.19632646f, 0.01407728f, 0.10707984f, 0.05049910f, 0.08940455f, 0.04004903f, 0.05393351f, 
    -0.05507485f, -0.07772845f, -0.03711541f, 0.03020591f, -0.06502189f, -0.09726428f, 0.09183769f, 0.26969355f, 
    -0.18087846f, 0.01449495f, -0.17647785f, 0.04965297f, 0.13482739f, 0.20111637f, 0.05835591f, 0.04178166f, 
    0.06389582f, 0.06165226f, -0.00956717f, -0.03823301f, 0.05163113f, 0.16531816f, 0.18011402f, 0.15498909f, 
    -0.07226054f, -0.07865317f, -0.11274692f, -0.19629385f, 0.21870255f, 0.06693703f, -0.03021263f, 0.12770779f, 
    0.08512121f, -0.01305715f, 0.00681444f, 0.03631063f, 0.08960731f, -0.05537801f, -0.02729102f, 0.10314564f, 
    0.04239047f, 0.03514764f, -0.00477896f, 0.04336414f, -0.05443900f, 0.12623557f, 0.13990052f, 0.09516894f, 
    0.13935283f, 0.00456760f, 0.03573728f, -0.17045921f, -0.01414917f, -0.11017890f, 0.13085619f, 0.04032601f, 
    -0.00693323f, 0.06364480f, 0.08079088f, 0.08098278f, -0.01988898f, -0.05861200f, -0.08709007f, 0.02820029f, 
    0.02812787f, -0.06305417f, 0.45486197f, -0.16470021f, -0.23564303f, 0.10928498f, -0.35308856f, 0.10540425f, 
    0.15373461f, 0.17804591f, -0.02788291f, 0.01860761f, -0.04133380f, -0.04669423f, -0.05388510f, 0.05344942f, 
    0.04348201f, 0.01811749f, -0.02093006f, -0.14221413f, 0.13383918f, 0.16623390f, 0.00469100f, 0.09503949f, 
    -0.02275328f, -0.02304323f, -0.03036512f, 0.14361271f, 0.04740409f, 0.09661746f, 0.04914049f, 0.00028220f, 
    -0.06200407f, -0.05692601f, -0.08444813f, 0.04463526f, -0.13636638f, -0.01248236f, 0.07105298f, -0.24962711f, 
    0.01251080f, -0.24612869f, 0.42343068f, -0.12305580f, -0.34679407f, 0.13120529f, -0.36516863f, 0.03627067f, 
    -0.02810003f, -0.14948271f, -0.10452759f, 0.13480498f, 0.01515951f, 0.04675128f, 0.00770609f, 0.06966063f, 
    -0.06808938f, 0.04923458f, -0.11048980f, 0.07070766f, -0.14354670f, -0.51318830f, -0.44582680f, 0.08950125f, 
    -0.02558056f, -0.08817669f, 0.08671082f, 0.13108931f, -0.00283545f, 0.03531720f, -0.00104081f, -0.05640328f, 
    0.03212125f, -0.00144725f, -0.06457216f, -0.01007886f, 0.09455899f, 0.00744940f, 0.02768032f, 0.23915640f, 
    -1.34075642f, -0.27082998f, -0.41715148f, -0.42732394f, 0.12668411f, 0.04010259f, 0.09390258f, -0.05261553f, 
    -0.34448856f, 0.10022720f, 0.04802893f, -0.12359598f, 0.07242773f, -0.14605239f, 0.03341624f, 0.07690419f, 
    0.13555412f, -0.19264817f, 0.01902300f, -0.12038109f, -0.35810566f, -0.49531773f, -0.08985576f, -0.05920380f, 
    -0.05619498f, -0.47829211f, 0.13994256f, 0.14974210f, 0.00472164f, 0.14045368f, 0.02077713f, -0.02595327f, 
    0.02760158f, -0.02228578f, 0.02185049f, 0.04476545f, -0.01834024f, 0.10827943f, -0.06612645f, -0.29052863f, 
    0.30478364f, -0.72552669f, -0.04808269f, -0.71145058f, -0.01126950f, -0.49116799f, -0.05764463f, -0.08358348f, 
    0.15868250f, 0.22108173f, -0.04255123f, 0.01778271f, -0.03192667f, -0.06412628f, 0.02895370f, -0.11685254f, 
    0.20428844f, 0.06056728f, -0.11297484f, 0.13635853f, 0.12617567f, 0.14341083f, 0.09915389f, 0.66517061f, 
    -0.79515171f, 0.10842092f, -0.18705693f, -0.12418664f, 0.09450325f, -0.04288599f, -0.02340809f, -0.06539413f, 
    0.10842770f, 0.02306259f, 0.09800412f, 0.05027405f, 0.08077290f, 0.12587139f, 0.06351855f, 0.05297385f, 
    -0.08077651f, 0.11998391f, -0.14881518f, 0.21673480f, 0.22072928f, 0.00101263f, 0.05970313f, -0.11560407f, 
    0.15200885f, -0.23665969f, 0.03747369f, -0.08943598f, 0.13620792f, -0.19671500f, -0.07249496f, 0.11397309f, 
    0.06757916f, -0.11564616f, -0.05592601f, 0.14196159f, -0.00195938f, 0.16640253f, -0.34063798f, -0.41061997f, 
    0.07331436f, 0.20950729f, 0.03354511f, 0.19497579f, -0.00286588f, 0.00421422f, 0.11280123f, -0.02160869f, 
    -0.07566106f, -0.01716623f, 0.01638181f, -0.11835897f, -0.01748045f, -0.00790311f, 0.01678104f, -0.04983206f, 
    0.02304311f, 0.05500005f, 0.09425792f, 0.23119010f, -0.63378555f, -0.09830174f, -0.01511634f, -0.06225857f, 
    0.08826882f, 0.02912157f, 0.07832405f, 0.02887780f, 0.10860838f, -0.00278112f, 0.08007330f, -0.07177616f, 
    0.13094570f, 0.07233728f, 0.04854008f, 0.10539911f, -0.11128160f, 0.31364375f, -0.23951252f, 0.39288187f, 
    -0.15281966f, -0.09351604f, -0.19591433f, -0.16962755f, -0.15177165f, -0.08739657f, 0.15344557f, -0.06363764f, 
    0.00805960f, 0.00625731f, -0.03094474f, 0.02644665f, -0.07287196f, 0.03278761f, 0.07021569f, 0.09575491f, 
    -0.11860657f, 0.21359314f, 0.38362539f, -0.21938883f, -0.07594877f, -0.01541840f, -0.12951277f, -0.01108617f, 
    -0.04055584f, -0.14632910f, 0.05998718f, -0.05804152f, 0.08243051f, 0.01428011f, -0.01231544f, -0.09971401f, 
    -0.07197821f, -0.07097263f, -0.01205031f, -0.03805444f, -0.18074071f, 0.07669993f, -1.20769346f, 0.24839380f, 
    0.21936633f, 0.05230660f, 0.01433173f, 0.29716709f, -0.01512747f, 0.18930368f, 0.00363297f, -0.00543210f, 
    -0.00728630f, 0.03903154f, -0.05505906f, 0.06106304f, 0.12790625f, -0.04708580f, -0.07035267f, 0.10765117f, 
    -0.56088841f, 0.27537030f, -0.16726133f, 0.57199311f, -0.86874944f, -0.10911646f, -0.24430391f, -0.07209571f, 
    0.05853315f, -0.08815484f, 0.09864994f, -0.01786250f, 0.02594871f, 0.08511598f, 0.04864914f, -0.07009088f, 
    0.06635308f, -0.02687953f, 0.05522757f, 0.16011578f, -0.06989707f, -0.07870729f, -0.37285420f, 0.07861419f, 
    0.07399330f, -0.14668401f, 0.27741632f, 0.18398906f, 0.03102859f, -0.05607053f, 0.04109778f, -0.05409580f, 
    -0.02790019f, 0.00030311f, -0.07597604f, 0.10063380f, 0.10220778f, -0.24399199f, 0.00083476f, -0.00988233f, 
    -0.68380672f, 0.00866982f, 0.06391437f, -0.33168909f, -0.40140691f, -0.01517243f, -0.19973861f, -0.28705394f, 
    0.05673319f, -0.09759352f, -0.02704122f, -0.18278231f, -0.00568567f, -0.00645622f, -0.12896469f, -0.01364435f, 
    -0.01581789f, -0.03384067f, -0.13862281f, -0.01386982f, 0.16195665f, -0.48776293f, -0.02408081f, -0.52825892f, 
    0.18957292f, -0.14801486f, -0.11338381f, 0.09034587f, 0.12783749f, 0.05819682f, -0.15287654f, 0.04138564f, 
    0.15064056f, 0.01840251f, -0.02216095f, 0.08373141f, 0.14849725f, 0.19642225f, -0.02851243f, 0.07692473f, 
    0.05072921f, 0.09870828f, 0.33547840f, 0.02433703f, -0.16833445f, 0.02938667f, -0.01895138f, -0.30690080f, 
    -0.09948403f, -0.08709566f, 0.01971722f, -0.05985102f, 0.18451732f, 0.01730111f, -0.02347653f, 0.02388647f, 
    -0.13799517f, -0.02307162f, -0.05576441f, -0.10565713f, -0.09905928f, -0.24199563f, 0.06364612f, -0.20504449f, 
    0.05068962f, 0.04254598f, 0.04464108f, 0.06574894f, -0.04868528f, -0.04925966f, 0.17377469f, 0.08533949f, 
    -0.03372497f, 0.07147932f, -0.21724308f, 0.02092748f, 0.01866230f, 0.15837149f, -0.11555986f, 0.01685548f, 
    -0.06417994f, -0.06051379f, 0.20852086f, 0.01011720f, 0.14557758f, 0.08579351f, 0.07810177f, -0.21421260f, 
    -0.02544349f, -0.10673727f, 0.00673689f, 0.11086541f, -0.02411063f, 0.03169419f, -0.04491153f, 0.07264315f, 
    0.01353373f, -0.20007470f, -0.06753116f, 0.02790544f, -0.04132482f, -0.02283764f, 0.47248158f, 0.25018436f, 
    -0.33570111f, -0.01778439f, -0.16866477f, -0.27191582f, -0.02198996f, -0.10342751f, 0.09642229f, 0.01802383f, 
    0.05264206f, 0.07404537f, 0.05583598f, 0.03028035f, -0.09927289f, -0.02682042f, -0.00116004f, -0.00898110f, 
    0.03755574f, 0.29560882f, -0.79954135f, 0.03002014f, -0.10520265f, 0.22038451f, -0.22325562f, 0.00683145f, 
    -0.06460247f, -0.06015655f, 0.04692745f, -0.07889361f, 0.00689025f, -0.03756894f, -0.11997217f, -0.02565629f, 
    0.09564834f, -0.10227805f, 0.04000402f, 0.04498508f, 0.00030847f, 0.13188994f, -0.33265343f, -0.09736221f, 
    -0.00783153f, 0.13894786f, 0.25362620f, 0.28045946f, 0.04096895f, 0.02732279f, 0.11504657f, 0.06561544f, 
    -0.12715195f, 0.01009354f, -0.01467055f, 0.15112445f, -0.07923941f, -0.06468381f, -0.07421695f, 0.02756635f, 
    0.21826386f, 0.07290088f, 0.14292757f, 0.11395890f, 0.10285026f, 0.16764213f, -0.04343229f, 0.01567401f, 
    0.04706732f, 0.01609152f, -0.01901646f, 0.09439633f, -0.07783128f, -0.11054672f, -0.00306822f, -0.01063627f, 
    0.01302936f, 0.10663356f, -0.02034131f, -0.01127059f, 0.26888025f, -0.14930217f, 0.17717117f, -0.14017403f, 
    -0.03678184f, -0.20034005f, -0.02798435f, 0.11068092f, 0.00955701f, -0.07196138f, 0.05246530f, -0.06004718f, 
    -0.09080222f, -0.00183718f, 0.10089486f, 0.00642044f, -0.13156219f, 0.06574529f, -0.00318819f, 0.06041909f, 
    -0.63454646f, 0.56290102f, -0.03467533f, -0.00246783f, -0.00606449f, 0.12470698f, -0.07234806f, -0.06124957f, 
    0.17788725f, -0.12584573f, -0.09879986f, 0.04133127f, -0.08367687f, -0.04010542f, 0.03206569f, -0.14544883f, 
    -0.12179928f, -0.12380832f, -0.00121119f, -0.20443611f, -0.06172149f, -0.12998350f, -0.01047359f, -0.10342257f, 
    0.09654258f, -0.16161110f, -0.01314239f, 0.23059902f, -0.13092780f, -0.11264688f, 0.00875837f, 0.08980469f, 
    -0.02627640f, 0.04464903f, -0.02076637f, 0.02587921f, -0.08038511f, 0.07727971f, -0.11965010f, -0.02626768f, 
    -0.07306822f, 0.07006738f, -0.09485242f, 0.04322207f, -0.04546031f, -0.02356837f, -0.03994926f, -0.27642828f, 
    0.04723253f, 0.07126012f, -0.03213614f, 0.03052351f, 0.05267594f, -0.09922059f, -0.10853374f, -0.07161421f, 
    -0.02114040f, 0.00332994f, -0.00991680f, 0.03797849f, -0.28897476f, 0.06378850f, -0.50149530f, -0.09075066f, 
    0.01713842f, 0.00002445f, -0.00909975f, -0.09298031f, -0.08262033f, 0.04731613f, -0.02544775f, 0.04001406f, 
    -0.01931173f, 0.07663296f, -0.02063346f, 0.06697920f, -0.09323218f, -0.15308031f, -0.12947980f, -0.17139952f, 
    -0.15867589f, -0.15837997f, -0.01410323f, 0.05513351f, -0.21453808f, -0.11451415f, -0.09812327f, -0.13970321f, 
    -0.00353020f, -0.08067426f, -0.07527395f, -0.03549662f, -0.03019217f, -0.00076258f, -0.03689250f, 0.07186071f, 
    0.06153383f, 0.08977485f, 0.04205863f, -0.10381641f, 0.04486896f, -0.31384435f, 0.15375100f, -0.20966379f, 
    -0.21208160f, -0.03639453f, -0.01777598f, -0.17007188f, -0.04807826f, 0.02457297f, -0.00257194f, 0.01615470f, 
    -0.09473346f, 0.02342203f, -0.09420732f, -0.12580365f, 0.04049804f, 0.06893978f, 0.08533675f, 0.04386909f, 
    -0.50974858f, 0.15031455f, -0.38476551f, 0.10782553f, 0.03786404f, -0.07343946f, 0.02043996f, -0.20399465f, 
    0.11345466f, -0.01195896f, -0.08045121f, 0.05818532f, -0.01872673f, 0.07506648f, 0.02756218f, 0.07159718f, 
    -0.04976721f, -0.11890604f, 0.00184871f, 0.15538575f, -0.30936834f, -0.11349792f, -0.15445481f, -0.00010142f, 
    0.05771248f, -0.04700264f, 0.00230395f, 0.12107619f, -0.08701097f, 0.08246160f, 0.05734063f, 0.10503466f, 
    -0.00763136f, 0.06101465f, 0.04887972f, 0.14463229f, 0.09796758f, 0.16367701f, 0.12650266f, 0.21777810f, 
    -0.19520058f, 0.00591074f, -0.12796661f, 0.24300151f, -0.14000189f, 0.05516602f, -0.02090499f, -0.08594838f, 
    0.10555087f, 0.09558248f, 0.04269209f, -0.06327118f, -0.00434510f, 0.02829453f, 0.13707195f, -0.03022433f, 
    -0.07414814f, -0.01542732f, 0.11192552f, 0.05322776f, -0.15431227f, -0.08709205f, -0.21237287f, 0.19667545f, 
    0.23217168f, -0.02364760f, -0.04955667f, 0.10378556f, -0.06800737f, -0.18829910f, -0.00190234f, -0.04668586f, 
    -0.09272545f, -0.04687788f, 0.01562508f, 0.08271044f, -0.32276079f, -0.31828386f, -0.20485497f, -0.04408435f, 
    0.29517207f, -0.45415097f, 0.57286847f, 0.34331399f, 0.24840780f, 0.02575120f, -0.06677061f, 0.30127120f, 
    0.17570697f, -0.19634829f, 0.06230727f, -0.06029904f, -0.23693682f, -0.05245201f, 0.07263190f, -0.13567218f, 
    0.18100876f, 0.20847692f, -0.05941811f, 0.08662301f, -0.23460785f, 0.03082791f, -0.18907921f, -0.18621953f, 
    0.19125697f, 0.05346480f, -0.07444157f, 0.11694209f, -0.09387388f, -0.00401515f, -0.09125748f, 0.06349568f, 
    0.09666958f, 0.02498813f, -0.02718106f, 0.05481521f, -0.00458834f, -0.22749268f, 0.12416194f, 0.10025232f, 
    -0.10369106f, 0.23297687f, 0.24611259f, 0.23142339f, 0.08784141f, 0.04668918f, 0.05454258f, 0.12628096f, 
    -0.09256104f, -0.05609727f, 0.07046133f, 0.00331129f, -0.15114398f, 0.06758519f, 0.00415534f, -0.02287503f, 
    0.00121233f, 0.07377936f, -0.10320827f, -0.03358332f, -0.21915688f, -0.14245562f, -0.27479854f, -0.15667678f, 
    -0.09146397f, -0.07988797f, 0.06483790f, -0.03569682f, 0.07800172f, 0.02667360f, -0.02338761f, 0.03997442f, 
    -0.16435054f, -0.15535931f, -0.25375023f, 0.06052903f, -0.05558367f, 0.06258764f, -0.03797519f, -0.07881268f, 
    -0.07894070f, -0.05421229f, 0.25054193f, -0.02089808f, -0.21900602f, 0.04819947f, -0.01040041f, 0.05115125f, 
    0.13548742f, -0.15865009f, 0.00372263f, 0.02554412f, 0.01291389f, -0.03486848f, -0.04200355f, 0.00585366f, 
    -0.20270191f, 0.06789665f, -0.11522388f, -0.26595938f, -0.05652277f, -0.20460023f, 0.06797406f, 0.18887427f, 
    -0.09105042f, -0.05823284f, 0.06322501f, -0.16887799f, 0.24161212f, -0.10301435f, -0.22786519f, -0.02335334f, 
    0.09840386f, -0.06474587f, -0.09344034f, 0.15567845f, -0.00538367f, 0.06404535f, 0.15360658f, 0.09052994f, 
    -0.29595909f, -0.00173900f, -0.23754129f, 0.07028531f, 0.00267285f, -0.04305872f, -0.04562228f, 0.05139081f, 
    -0.04442636f, 0.01656141f, 0.01080799f, 0.06575976f, 0.00442926f, -0.09483661f, -0.03909430f, 0.01827167f, 
    0.00247106f, -0.00590089f, -0.03911794f, -0.11694586f, 0.38307986f, 0.02563011f, 0.29434210f, -0.05311925f, 
    0.04780236f, -0.03436324f, 0.12911849f, -0.11216770f, 0.11286586f, 0.03876028f, -0.07856925f, 0.10328123f, 
    -0.01316941f, -0.17623115f, -0.14469583f, 0.00693218f, -0.07706331f, 0.01763635f, 0.15345512f, -0.12424979f, 
    -0.28950325f, 0.01021582f, 0.09497562f, 0.05966607f, -0.02593915f, -0.00716279f, 0.16974044f, -0.16712272f, 
    0.05886066f, 0.00233365f, -0.01856671f, -0.09931815f, -0.02712104f, 0.00054984f, 0.01446274f, -0.01591818f, 
    0.07831040f, 0.02090663f, 0.11248641f, 0.12975718f, -0.17095083f, -0.38018751f, -0.47545409f, -0.21337661f, 
    0.08546409f, -0.12553596f, -0.09106605f, 0.25856039f, -0.42972589f, -0.20780344f, -0.04981531f, 0.11549793f, 
    -0.09075775f, -0.00052096f, -0.04585535f, 0.15408212f, -0.22721311f, -0.10668319f, -0.34419557f, -0.21346429f, 
    -0.16249767f, 0.14278318f, 0.42193460f, 0.18556708f, 0.23839964f, -0.21725051f, -0.12725280f, 0.07269079f, 
    0.07316097f, 0.09858559f, -0.14172304f, -0.00467377f, -0.16395774f, -0.02995662f, -0.12748548f, 0.11082244f, 
    -0.15538456f, 0.11208517f, 0.00219527f, 0.08558097f, -0.19781698f, -0.29470924f, 0.07091982f, -0.18419866f, 
    0.03069046f, 0.10056940f, -0.12121987f, 0.23499899f, 0.02227266f, -0.04014751f, -0.19898076f, 0.02249951f, 
    0.08897527f, -0.02756412f, 0.15476282f, 0.08617980f, -0.04190280f, 0.12626369f, 0.05925780f, 0.06088722f, 
    -0.50352466f, 0.04152593f, 0.40340450f, 0.24183522f, 0.15964516f, -0.08683317f, 0.17304912f, -0.35399920f, 
    -0.06332450f, -0.10329851f, -0.13538902f, -0.08388367f, 0.02484242f, 0.03530402f, -0.03863383f, -0.01336828f, 
    0.06071961f, 0.12862279f, -0.01993478f, 0.14259584f, -0.09135315f, 0.14971484f, -0.15549731f, 0.25714123f, 
    -0.06497651f, 0.00387772f, -0.07897470f, -0.06921065f, -0.04628116f, -0.01107923f, -0.06783931f, 0.11732206f, 
    -0.12050101f, -0.00029678f, -0.03743228f, -0.05002508f, 0.02406262f, -0.14675343f, 0.04679260f, -0.08059540f, 
    0.03433948f, -0.06722616f, 0.03648037f, 0.13683246f, 0.15834276f, -0.09263579f, 0.00554070f, 0.14561956f, 
    0.08158451f, 0.06766593f, -0.09663168f, -0.02168343f, 0.01707964f, 0.02889645f, -0.03168080f, 0.03522574f, 
    0.04211260f, 0.12224595f, 0.12372000f, 0.15076518f, -0.10602672f, -0.24135074f, 0.06507313f, -0.06975674f, 
    -0.26495641f, -0.09451190f, -0.16833858f, -0.03197420f, 0.20386693f, -0.10088532f, -0.18078215f, -0.03883217f, 
    0.01347042f, 0.04009529f, 0.03345659f, -0.06112804f, 0.09661871f, 0.00115507f, 0.14435880f, 0.05548061f, 
    -0.19043933f, -0.13372968f, 0.19028714f, 0.00188948f, -0.19701856f, -0.02343005f, -0.00845358f, 0.06005812f, 
    0.00098124f, 0.01508203f, -0.06259826f, -0.07155232f, 0.16052468f, -0.06834004f, -0.08311114f, -0.14862372f, 
    -0.09017774f, 0.09566513f, 0.07557224f, 0.19026625f, -0.37079883f, 0.12983523f, -0.09277283f, 0.00603624f, 
    0.00078493f, -0.00018522f, 0.04218195f, -0.11383741f, 0.10981393f, 0.01810814f, -0.01055373f, 0.03653502f, 
    -0.03309508f, 0.01123987f, -0.06556299f, 0.05061645f, 0.08908737f, -0.14210360f, 0.11140604f, 0.07047278f, 
    -0.64523917f, -0.06581809f, 0.28369060f, 0.07402633f, 0.10567623f, -0.11674703f, -0.10120444f, 0.10059993f, 
    0.37949637f, 0.10228419f, -0.06146941f, 0.06675670f, 0.05269654f, 0.18707713f, 0.01962760f, 0.10324375f, 
    0.03895766f, -0.13232049f, 0.13498260f, -0.12393070f, -0.24200207f, -0.45728096f, 0.09123658f, -0.02339606f, 
    -0.23330890f, -0.11274417f, 0.04199857f, 0.11044510f, -0.08145119f, -0.10224263f, -0.06920272f, -0.05632024f, 
    -0.01023687f, 0.02393174f, -0.12364119f, 0.00878443f, 0.06261180f, 0.15020394f, 0.10796203f, 0.04134599f, 
    -0.72549778f, 0.20540424f, -0.13594511f, 0.28303924f, -0.40561649f, 0.06663790f, 0.11676157f, 0.06234630f, 
    -0.19639273f, 0.18251498f, -0.08574609f, -0.05692578f, 0.14179081f, 0.03521445f, -0.05414638f, 0.03036080f, 
    0.07596192f, 0.06487622f, 0.06975571f, 0.03228269f, -0.07965554f, -0.03925597f, 0.08984327f, -0.25018197f, 
    0.22368453f, -0.00811323f, 0.08075122f, 0.08806560f, 0.00374478f, 0.19354737f, -0.04089472f, 0.22037794f, 
    -0.06919288f, 0.01624614f, -0.05021080f, 0.07805176f, 0.06555661f, 0.02377733f, -0.10725915f, 0.09808202f, 
    -1.16997147f, 0.07417115f, -0.79780453f, 0.59559852f, -0.52695262f, 0.22725743f, 0.17489795f, -0.05603653f, 
    0.14081028f, 0.00567191f, -0.25686407f, -0.12123986f, 0.06126030f, 0.11547618f, -0.07659272f, 0.15729094f, 
    -0.05366127f, 0.10425102f, -0.10477172f, 0.18773741f, 0.01513706f, -0.22065605f, 0.05096763f, -0.33136630f, 
    0.07187191f, -0.07552531f, -0.43323669f, -0.14313468f, 0.03951657f, -0.16918746f, 0.08053817f, -0.01749780f, 
    -0.03949427f, 0.03449824f, -0.02301114f, 0.04697496f, 0.04264686f, -0.10455046f, 0.20031896f, -0.10511063f, 
    -0.44393599f, -0.00916665f, -0.22604597f, 0.16975023f, -0.26868615f, 0.05919831f, 0.01434298f, -0.06840470f, 
    0.12503493f, 0.03643822f, -0.00014937f, -0.01668265f, 0.05109777f, -0.08240257f, -0.06600479f, -0.06077157f, 
    -0.04218774f, -0.01351953f, -0.01758555f, -0.02865277f, 0.10512520f, -0.26050946f, -0.21725720f, -0.26816618f, 
    0.04978801f, -0.03976779f, -0.30646768f, -0.00661561f, -0.07904933f, -0.08284684f, 0.02827654f, 0.04118183f, 
    0.02371764f, -0.08449522f, -0.08507606f, 0.05547829f, -0.11653402f, 0.00061056f, -0.01803879f, -0.00158555f, 
    0.06827843f, -0.02076202f, -0.08151098f, -0.02955129f, 0.02224440f, -0.07088570f, 0.06042701f, -0.05350100f, 
    0.10483130f, -0.02278920f, -0.18356001f, -0.05017547f, 0.04644523f, -0.04264680f, 0.03125354f, 0.12923020f, 
    0.02417089f, -0.01699597f, -0.12098086f, -0.11402538f, -0.17180833f, 0.01506069f, -0.05064292f, 0.02308684f, 
    0.01744383f, -0.01025074f, -0.00085154f, 0.00036750f, -0.01296401f, -0.03018144f, 0.00600660f, -0.00504319f, 
    0.12124806f, 0.04982106f, 0.11968648f, -0.06922738f, -0.16191059f, -0.10565349f, -0.11910396f, -0.10355517f, 
    -0.10410149f, -0.51877040f, -0.22996850f, 0.16302034f, -0.12418613f, -0.11308703f, -0.36367351f, 0.07104607f, 
    -0.13228323f, -0.20967977f, 0.06304672f, -0.01359485f, 0.03865654f, -0.04488220f, 0.03431267f, 0.05826158f, 
    -0.00967945f, 0.06848136f, 0.22469413f, -0.13798665f, 0.03096629f, -0.05003811f, -0.07502458f, 0.04958959f, 
    0.00428628f, -0.19007637f, -0.00685960f, 0.08696469f, -0.14881817f, -0.17483014f, 0.03304846f, 0.06931007f, 
    0.02207814f, -0.08929654f, -0.02551896f, 0.03619490f, -0.20240374f, -0.09904084f, -0.14262502f, -0.01025258f, 
    -0.38687450f, -0.21919708f, -0.07752191f, 0.34918913f, -0.21057197f, -0.05992859f, 0.25223112f, -0.01143192f, 
    0.28511512f, -0.15487964f, -0.14512646f, -0.03494211f, 0.03925908f, -0.00790231f, 0.11241607f, -0.07193653f, 
    -0.05886507f, 0.09201150f, -0.02651739f, 0.11163228f, 0.16759546f, -0.23641178f, 0.16492879f, 0.14880255f, 
    -0.09391224f, 0.17443870f, -0.22039065f, 0.19821632f, -0.11708792f, -0.03198428f, -0.05464301f, 0.03375915f, 
    -0.04159730f, -0.00494059f, 0.02851278f, -0.03887447f, 0.03422139f, 0.13246872f, 0.05030337f, 0.08037576f, 
    -0.57203579f, 0.04045302f, -0.72136122f, 0.47766340f, 0.44590679f, -0.03242382f, 0.23830703f, -0.05590766f, 
    0.15725446f, 0.15922779f, 0.01760221f, 0.15104896f, 0.06575482f, -0.08306295f, -0.11956204f, 0.07125489f, 
    0.05490239f, 0.06396700f, 0.18390478f, 0.10999294f, -0.26615769f, -0.15726572f, -0.13904606f, 0.19501108f, 
    -0.18265770f, 0.02070038f, -0.22487870f, -0.19518167f, -0.13981131f, -0.02046562f, -0.00180122f, -0.02467266f, 
    -0.07312348f, -0.05147926f, 0.01831816f, 0.10435409f, -0.05492535f, 0.04501914f, -0.01925019f, -0.13688684f, 
    -0.83356529f, -0.30055618f, -0.40050858f, 0.24497999f, 0.36896077f, 0.06641082f, 0.16006406f, -0.04640026f, 
    0.08489637f, -0.00601739f, -0.11120082f, 0.02157777f, -0.01278739f, 0.00099787f, 0.08693966f, 0.19649869f, 
    -0.03031037f, 0.05821961f, 0.06769042f, 0.14155585f, -0.15342490f, -0.31097269f, 0.08393182f, -0.28967911f, 
    -0.45736569f, 0.02957977f, 0.03711359f, -0.08464850f, -0.18871751f, -0.16138360f, -0.04868993f, -0.03632279f, 
    0.14759852f, 0.19450414f, 0.05619706f, 0.05306883f, 0.05088738f, 0.03729347f, 0.16162950f, 0.15369323f, 
    -0.18600985f, -0.17936294f, -0.09332947f, 0.05339327f, 0.09825247f, 0.05656714f, 0.03721210f, 0.07627833f, 
    -0.18540204f, -0.15110508f, -0.03142297f, -0.15896556f, -0.03022211f, 0.20730573f, 0.02153672f, 0.03585315f, 
    0.06177534f, 0.10149214f, -0.14180332f, 0.11327559f, 0.40381813f, 0.25464123f, 0.36139226f, 0.13874091f, 
    -0.04738577f, 0.06479459f, 0.09092899f, -0.01030989f, 0.20424405f, -0.04109531f, -0.16636121f, -0.00302931f, 
    0.00463210f, 0.02280510f, -0.03881757f, 0.01273070f, 0.00184774f, 0.09224246f, 0.20586821f, 0.05950795f, 
    -0.04758414f, -0.12048403f, -0.16520104f, -0.00643682f, -0.28800610f, -0.04687676f, -0.00502223f, 0.03382357f, 
    -0.04411973f, -0.02744856f, 0.01010967f, 0.02646186f, 0.08040116f, 0.04502762f, -0.04369158f, 0.06293824f, 
    0.03616089f, 0.03159543f, 0.06606025f, 0.13614368f, -0.08283943f, -0.17162374f, 0.30704793f, -0.31797823f, 
    -0.05271859f, 0.17281486f, 0.20646685f, -0.08477064f, -0.10171515f, 0.11842925f, -0.14009376f, -0.02543833f, 
    0.04769927f, 0.10326596f, 0.15438151f, 0.02834395f, -0.01100236f, 0.03379547f, 0.03149988f, 0.19443041f, 
    -0.02806502f, -0.04544510f, -0.36282048f, 0.29629585f, 0.12487480f, -0.11899576f, 0.03268125f, -0.03500097f, 
    0.09212100f, -0.13066028f, -0.07360139f, 0.01931682f, 0.02816969f, -0.11528464f, 0.09114984f, -0.09392316f, 
    -0.10859378f, -0.02443675f, -0.06166804f, -0.04638302f, 0.89929378f, -0.34203336f, 0.59795201f, -0.03442873f, 
    -0.02564759f, -0.01916939f, -0.12925565f, -0.35763955f, 0.14637132f, -0.09953625f, -0.07309414f, 0.06522525f, 
    -0.01112097f, -0.09233432f, -0.04885465f, 0.00001963f, 0.01584302f, -0.16457509f, 0.06935562f, 0.19235320f, 
    0.22944157f, -0.85208184f, 0.72231704f, -0.30313691f, 0.05907150f, 0.19474547f, 0.19153018f, -0.12380775f, 
    0.04503471f, -0.07132830f, 0.01153394f, -0.09373251f, 0.18466459f, 0.18514551f, -0.03247653f, -0.04413147f, 
    0.18898173f, 0.06332608f, -0.01472916f, -0.03450307f, 0.23566426f, 0.23522586f, 0.25879225f, 0.14016233f, 
    -0.06254864f, 0.04470497f, 0.08495433f, 0.01633658f, 0.08222727f, -0.10650931f, -0.12799248f, -0.02983736f, 
    -0.00908363f, -0.03772346f, -0.02734420f, 0.13017632f, -0.03504519f, 0.12723561f, -0.16686018f, 0.05588080f, 
    -0.07229706f, 0.01612313f, -0.55310708f, 0.48488179f, -0.31228721f, -0.05385011f, -0.07635108f, -0.11854438f, 
    -0.19023745f, 0.08914386f, -0.05496138f, 0.01650932f, 0.01948230f, -0.07404023f, -0.04010548f, 0.03707310f, 
    0.01008552f, -0.07952658f, 0.05132011f, 0.02360342f, -0.63239735f, 0.07656864f, -0.45194790f, 0.42123917f, 
    0.07364275f, -0.08651927f, 0.14347078f, -0.01257677f, 0.07509510f, -0.02095122f, -0.17610322f, -0.07170635f, 
    0.12565687f, 0.12107460f, -0.02438979f, 0.11814240f, 0.01326349f, 0.11592860f, 0.02650190f, -0.21276398f, 
    -0.37132657f, -0.24172466f, -0.12955102f, 0.27389547f, 0.01224589f, -0.14115193f, -0.12986121f, -0.06843454f, 
    -0.01579216f, 0.10651343f, 0.00106863f, -0.01884238f, -0.10221097f, -0.13344957f, -0.10209125f, -0.02627831f, 
    -0.11663463f, -0.13675553f, -0.10913683f, -0.16080470f, -0.10901310f, 0.07841338f, -0.00461240f, 0.06633851f, 
    -0.13458352f, 0.11456902f, 0.02095523f, 0.16603753f, 0.09655347f, -0.01766831f, -0.12492681f, -0.12172655f, 
    0.07052026f, -0.02583728f, -0.06340841f, 0.09415201f, 0.00300549f, -0.06274536f, 0.03063729f, -0.09306592f, 
    -0.17986429f, 0.18579742f, -0.34746096f, 0.26720160f, -0.08858969f, -0.04194374f, 0.11275295f, -0.03423517f, 
    0.15535960f, 0.11232303f, 0.04374838f, 0.16767812f, -0.06892767f, 0.16155982f, -0.05488944f, 0.09470502f, 
    -0.02434732f, -0.03539088f, -0.12586957f, -0.01621997f, -0.13710271f, -0.28342557f, -0.05746629f, 0.20544310f, 
    -0.26227820f, 0.02060301f, -0.12864877f, -0.01469448f, 0.01672738f, 0.00755503f, -0.04401914f, -0.03034965f, 
    0.04404523f, -0.25894454f, 0.05211326f, 0.01174913f, -0.07830937f, -0.02428829f, -0.07111797f, -0.18534569f, 
    0.07816704f, -0.13647234f, 0.42439914f, -0.10834804f, 0.09800564f, 0.06078662f, -0.27489275f, 0.08983600f, 
    0.08209528f, -0.27088556f, -0.02005875f, 0.01143803f, 0.13550223f, -0.01700675f, -0.00803013f, 0.06735936f, 
    -0.07208060f, 0.02752990f, 0.20259066f, -0.07389732f, 0.31022406f, 0.20403406f, 0.24177866f, 0.07173255f, 
    -0.11798020f, 0.08273400f, 0.12372717f, -0.07439656f, -0.04231289f, 0.06052903f, -0.19185436f, 0.03598594f, 
    0.02410884f, 0.09980666f, 0.01550508f, -0.04683057f, 0.02262669f, -0.02301081f, -0.09936886f, 0.09126687f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22001314f, 0.12116428f, 0.08363257f, -0.16300121f, -0.04052357f, 0.05945459f, 0.01657376f, -0.11653977f, 
    0.08931597f, 0.03563641f, 0.00923034f, -0.04677857f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
