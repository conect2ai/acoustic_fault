#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.99223423f, -0.16741492f, 0.35630971f, -0.08240434f, 0.41226503f, 0.67146158f, 0.47363523f, -0.36754614f, 
    0.26382929f, -0.14504632f, 0.14553992f, 0.42891386f, 0.49646851f, 0.31915164f, 0.42704526f, -0.01188276f, 
    0.24290264f, -0.19948368f, -0.37920550f, 0.50117218f, 0.10348924f, -0.24621114f, 0.33341444f, 0.65320909f, 
    -0.43153819f, -0.70385283f, -0.11817165f, 0.11700553f, 0.00745985f, -0.11459463f, 0.21709368f, -0.23413567f, 
    0.24814811f, 0.28355363f, -0.06719243f, 0.01056490f, -0.87409037f, 1.06538165f, -0.41371158f, 0.42305163f, 
    0.01892376f, 0.08196899f, 0.10269486f, 0.32978162f, -0.17526560f, -0.24980678f, 0.71259665f, -0.69588053f, 
    0.02637486f, -0.15970492f, -0.19980264f, 0.16903098f, 0.17212333f, 0.57366705f, -0.62819326f, 0.10955942f, 
    0.02612603f, -0.17493838f, -0.15410908f, -0.38197380f, 0.03690126f, -0.21481031f, -0.38961914f, 0.01523274f, 
    0.60674369f, 0.05241059f, -0.56678843f, 0.39082029f, 0.03469965f, 0.43584687f, -0.22425927f, 0.28618455f, 
    0.29479617f, 0.17877455f, -0.87632215f, -0.31467366f, -0.28812537f, -0.23882018f, -0.44766048f, -0.52266645f, 
    -0.13921770f, 0.61931032f, 0.06825326f, -0.10056002f, -0.18138114f, -0.36474243f, 0.60229707f, 0.18604083f, 
    -0.38216415f, -0.31172678f, -0.69783753f, -0.58931714f, -0.08674888f, 0.68497241f, 0.56241435f, 0.30861729f, 
    -0.33517390f, -0.27581596f, -0.35649109f, -0.38718349f, 0.16833656f, -0.29747322f, -0.01968765f, 0.48732802f, 
    -0.70460409f, 0.02356398f, -0.01595556f, -0.17339723f, -0.45506263f, 0.09344710f, 0.68323076f, 0.49779296f, 
    -0.25843921f, -0.24009299f, -0.46451059f, -0.42090163f, 0.61978108f, -0.70991355f, -0.30065775f, -0.21734415f, 
    0.78315639f, -0.39296925f, -0.49604550f, -0.37910590f, -0.13712713f, 0.00461224f, 0.57510018f, 0.11576446f, 
    0.07517109f, 0.12546663f, -0.51034772f, -0.33976769f, 0.01699811f, -0.04315627f, -0.01056893f, -0.48987558f, 
    -0.29593852f, -0.07069828f, -0.01997272f, -0.27780256f, -0.72245574f, -0.03127491f, 0.38620144f, 0.55151057f, 
    0.10379902f, -0.38061759f, 0.29868224f, 0.69724840f, 0.60461813f, -0.16236252f, -0.01200644f, 0.29073441f, 
    0.33675459f, 1.27315223f, -0.79900724f, -0.12592694f, -0.64101791f, -0.18084091f, -0.02228769f, -0.42721459f, 
    0.57640594f, 0.02251716f, 0.38836244f, -0.20348822f, 0.05407000f, -0.27186644f, 0.74636793f, -0.53603685f, 
    -0.12696373f, -0.23354439f, -0.13961385f, -0.17772394f, -0.49737230f, 0.53149492f, -0.12323487f, -0.76482731f, 
    -0.30503452f, 0.18741934f, 0.04489192f, -0.06620741f, -0.18554649f, 0.62147975f, -0.41598225f, 0.16064072f, 
    0.15567861f, 0.06414436f, 0.10288769f, 0.39413512f, -0.18073420f, -0.75701749f, -0.28525275f, -0.29751235f, 
    0.54098469f, -0.51411605f, 0.57944512f, -0.08631674f, -0.20320615f, 0.02353126f, 0.15273948f, -0.19982581f, 
    0.12982687f, -0.40300584f, -0.18364666f, -0.18421461f, -0.02480113f, 0.24441157f, 0.56072026f, -0.64704806f, 
    -0.45376211f, 0.01607865f, -0.03812009f, -0.20120810f, -0.34559169f, -0.15561686f, 0.26613629f, -0.28540972f, 
    -0.03134912f, 0.03778734f, 0.13501811f, -0.68749273f, -0.26780194f, 0.66684556f, 0.33654419f, 0.21870157f, 
    0.25089467f, -0.00652345f, -0.62452132f, -0.20546386f, -0.56526273f, 0.38437909f, -0.04091269f, 0.49774328f, 
    0.27333984f, 0.25498033f, -0.10064102f, -0.34071603f, 0.38385105f, -0.06299566f, -0.49003848f, -0.61994886f, 
    0.35277188f, 0.54402596f, 0.32569450f, 0.49358016f, -0.87714022f, 0.86091304f, 0.49304959f, -0.42377710f, 
    -0.48949349f, -0.09238737f, 0.01982118f, -0.05626523f, 0.46264338f, 0.53532887f, 0.74930155f, -0.54495531f, 
    -0.65844697f, -0.22463514f, 0.20878181f, 0.02537002f, 0.28999543f, 0.24362105f, -0.89383602f, 0.42774686f, 
    -0.38876915f, -0.08170213f, 0.49917531f, -0.31978601f, -0.08132412f, 0.51372987f, -0.27103636f, -0.46323815f, 
    -0.40065771f, -0.30347154f, -0.28805405f, -0.17960803f, 0.10455468f, -0.30567384f, 0.57036769f, 0.25747502f, 
    -0.28170288f, 0.64201564f, -0.05921659f, 0.50977284f, 0.38264233f, 0.20957176f, 0.10821950f, -0.36223707f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03832005f, 0.21351172f, -0.03743410f, -0.04417728f, -0.19377983f, -0.14528066f, -0.15101151f, -0.17039056f, 
    -0.32648668f, 0.00452053f, -0.12650612f, 0.43442956f, 0.03452348f, 0.13269384f, 0.18518098f, -0.21082878f, 
    -0.24554181f, 0.00097632f, 0.03139935f, 0.40591204f, 0.14168724f, -0.18938343f, 0.02127668f, -0.43882349f, 
    0.19282383f, 0.08045752f, 0.00926018f, -0.10456441f, -0.06135179f, -0.32608610f, -0.40804061f, -0.12179186f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.48207569f, 0.03545608f, 0.05844583f, -0.10891673f, -0.08335946f, -0.18078774f, 0.20267375f, -0.12688504f, 
    0.05300118f, -0.15188849f, -0.15765513f, -0.00215934f, 0.03015904f, 0.08372264f, -0.31132010f, 0.09785769f, 
    0.11087365f, 0.07115705f, -0.22132839f, -0.01675959f, -0.35702771f, 0.01822408f, -0.21616162f, -0.08182424f, 
    0.02936232f, -0.15757802f, 0.22153507f, -0.01644377f, -0.20300619f, 0.00922674f, -0.01325587f, -0.09556508f, 
    -0.04269921f, 0.15745012f, 0.04660889f, 0.15173890f, -0.28442931f, -0.45012406f, -0.44939706f, 0.07975005f, 
    0.02537899f, 0.10130434f, 0.12664177f, 0.14829448f, -0.01380095f, -0.08589268f, 0.22140482f, -0.29155287f, 
    -0.14991610f, 0.01465056f, 0.22165452f, 0.19081528f, -0.09151868f, -0.21215691f, -0.17004479f, 0.17627105f, 
    0.32880050f, -0.23685181f, -0.16934617f, -0.05729247f, -0.06001073f, 0.11016091f, 0.07542587f, -0.15730767f, 
    -0.00894090f, -0.07262392f, -0.10003029f, -0.32162878f, -0.08942046f, -0.00256154f, -0.06012512f, -0.17948413f, 
    0.25647700f, 0.07607173f, -0.19763118f, 0.00457375f, -0.13265966f, 0.13087395f, 0.13321467f, 0.02835536f, 
    0.03745933f, 0.32189599f, -0.63201058f, -0.33738968f, -0.00306370f, -0.31771377f, -0.09384518f, -0.16831732f, 
    0.05205606f, 0.20826878f, -0.75526834f, 0.05128961f, -0.18973948f, -0.06017845f, -0.10188009f, -0.18258403f, 
    -0.10701317f, -0.01393658f, 0.03268632f, -0.17425150f, 0.14021295f, 0.43797907f, -0.02268031f, 0.02226674f, 
    0.08173563f, 0.01807123f, 0.11383518f, 0.12851861f, -0.29923075f, -0.19910958f, 0.17433901f, -0.14883843f, 
    0.07261465f, 0.05048752f, 0.11303075f, -0.12451895f, 0.12313562f, -0.35833359f, 0.08587863f, 0.23729265f, 
    -0.01640550f, 0.00108271f, -0.14742708f, 0.14899513f, 0.08205407f, 0.00025218f, 0.41652340f, -0.00319440f, 
    0.10453299f, 0.08832774f, 0.03183424f, 0.08417549f, 0.13259202f, 0.08690871f, 0.07122712f, 0.08670041f, 
    -0.09818436f, 0.25387943f, -0.10508336f, 0.05610855f, -0.12000343f, 0.02052199f, -0.06252334f, 0.07555397f, 
    -0.04301363f, -0.55340683f, -0.14557922f, 0.00374799f, -0.13623397f, -0.25821826f, 0.25175554f, 0.05872051f, 
    0.27137148f, 0.08113808f, -0.14052536f, 0.38989630f, 0.13653426f, -0.12272553f, 0.21504429f, 0.07125595f, 
    -0.01356433f, 0.11011644f, 0.09787759f, 0.06125451f, 0.23457538f, 0.24732190f, 0.02939059f, 0.10827141f, 
    -0.05956817f, -0.05545923f, -0.00825678f, 0.01613094f, -0.02634092f, 0.35099602f, -0.13212821f, 0.08600936f, 
    0.04060621f, 0.11698701f, 0.11385877f, 0.06494036f, 0.18817332f, -0.18956883f, -0.13465019f, 0.04642219f, 
    -0.02046951f, -0.00424427f, 0.13269708f, 0.11744572f, 0.16288643f, -0.53268754f, 0.31358939f, 0.01250893f, 
    0.03690429f, -0.10138612f, -0.03707372f, -0.06554458f, -0.18038073f, -0.07995912f, -0.17849542f, 0.12729594f, 
    0.15876283f, -0.11691367f, 0.01203957f, 0.13613816f, 0.05019999f, 0.00132809f, -0.20664266f, -0.10214116f, 
    0.03462477f, 0.23351222f, -0.16904694f, -0.01858397f, -0.35457593f, -0.11630111f, 0.07433371f, 0.27861550f, 
    -0.29860404f, 0.12551859f, -0.18262129f, 0.00328252f, -0.08493324f, 0.05300877f, 0.16540346f, 0.29752532f, 
    0.19358560f, 0.16142280f, -0.10594344f, 0.49361148f, 0.02321314f, 0.18416038f, 0.07337466f, 0.11171608f, 
    -0.04943438f, -0.02645661f, 0.08892357f, -0.11808100f, 0.35167414f, -0.03989885f, 0.09507780f, 0.02319357f, 
    0.17701970f, -0.08588313f, 0.07010513f, 0.00528921f, -0.18232545f, 0.41658765f, -0.20747449f, 0.13604321f, 
    -0.16991010f, -0.12132326f, -0.01481257f, -0.08106276f, 0.06225881f, 0.13633719f, -0.37126863f, -0.13648775f, 
    0.08145438f, 0.16312310f, 0.09784674f, -0.12944052f, 0.01736077f, 0.05296640f, -0.50290447f, 0.18599634f, 
    -0.04106141f, -0.19063707f, -0.00747200f, -0.13018982f, 0.04374219f, -0.08193830f, 0.00702662f, 0.01333464f, 
    0.38866106f, -0.04840018f, -0.05098861f, -0.50732827f, -0.15289894f, -0.25399455f, -0.04808486f, 0.04276739f, 
    0.01415046f, 0.10633829f, 0.02781019f, -0.11230291f, -0.18945244f, -0.07095571f, 0.15027490f, 0.11367421f, 
    0.01957601f, 0.00576142f, -0.01867002f, 0.01811249f, -0.02079842f, -0.00631603f, 0.01084204f, -0.04946138f, 
    -0.00674933f, 0.04971488f, -0.02149159f, -0.06037984f, -0.06062082f, 0.04617701f, -0.05673400f, 0.00234322f, 
    -0.02826805f, -0.01650869f, -0.02107653f, 0.01120659f, 0.03911308f, -0.01362165f, 0.03455079f, -0.05772787f, 
    0.00364096f, -0.02902532f, 0.02465247f, -0.05524698f, -0.01421964f, 0.01484440f, -0.06426059f, -0.05747498f, 
    -0.01130049f, -0.00655530f, -0.00254853f, -0.02382615f, 0.04729946f, -0.05995846f, -0.01203028f, 0.05108129f, 
    0.03324113f, -0.03937151f, -0.03811522f, -0.02747664f, 0.00720172f, -0.02415765f, 0.00931275f, 0.04000101f, 
    0.03623337f, 0.02441889f, -0.00124196f, -0.04919393f, -0.02038970f, -0.01735853f, -0.04382087f, -0.04404777f, 
    0.03871858f, 0.00141392f, -0.02720914f, 0.04566648f, 0.02079497f, -0.00390233f, -0.03342559f, -0.03705093f, 
    0.02285011f, -0.02931985f, -0.03576814f, -0.04765453f, -0.03494192f, 0.01732770f, 0.05600069f, -0.05250804f, 
    -0.02118688f, -0.04100443f, 0.00902454f, 0.04028919f, -0.03560198f, -0.00616752f, -0.05589248f, 0.03659588f, 
    0.02474137f, 0.00368081f, -0.01929415f, 0.00147182f, 0.02305310f, -0.05610342f, 0.01655837f, 0.04130116f, 
    0.01343830f, -0.05577198f, -0.04128820f, -0.04412370f, -0.02471408f, -0.01840096f, 0.02351051f, 0.01026959f, 
    0.02479310f, 0.05060853f, 0.00237519f, -0.01344704f, -0.02474160f, -0.00164394f, 0.01451411f, 0.02743654f, 
    -0.00313500f, 0.03185785f, -0.00774241f, 0.02776247f, -0.02479047f, -0.00971350f, -0.04380115f, 0.01944570f, 
    0.01987321f, -0.00884347f, -0.00289028f, -0.02359235f, -0.00157724f, -0.02466358f, 0.03056736f, 0.01136374f, 
    0.02706866f, -0.06476563f, -0.01691419f, -0.02962375f, -0.02245339f, 0.02119981f, -0.04202076f, -0.04743695f, 
    0.01874581f, 0.02557771f, -0.00099212f, 0.00588062f, -0.05771454f, -0.06070404f, -0.05216996f, -0.00292375f, 
    0.03850566f, -0.05086285f, 0.02501741f, -0.00287587f, 0.03569474f, -0.01647385f, 0.03732010f, 0.04624563f, 
    -0.00232224f, 0.02774289f, 0.01012688f, -0.01207263f, -0.03734228f, -0.00480022f, -0.00943759f, -0.05126944f, 
    -0.01058977f, 0.03255295f, -0.04065988f, -0.03214841f, -0.05743926f, -0.01567241f, -0.06398018f, -0.02549079f, 
    -0.03198587f, -0.01533025f, -0.05960865f, -0.01660942f, -0.03736427f, 0.02207606f, 0.00576142f, -0.00778200f, 
    -0.00242637f, 0.00453096f, -0.05791227f, -0.03111950f, -0.03297722f, 0.04448844f, -0.05060458f, 0.04525806f, 
    0.04705683f, -0.01515713f, -0.04569166f, -0.02800616f, -0.06206954f, -0.06059433f, -0.00817652f, -0.01860726f, 
    0.02029558f, 0.01899846f, -0.04963915f, -0.06421236f, -0.02690519f, -0.06173452f, -0.01615117f, 0.01930179f, 
    -0.02128078f, -0.05343414f, -0.04266672f, -0.04730007f, -0.03725854f, -0.05659084f, 0.00961640f, 0.03633674f, 
    0.05202382f, 0.04822025f, -0.05540996f, 0.03947600f, 0.03629597f, -0.00675337f, -0.04182362f, -0.03918712f, 
    0.01415520f, -0.00632216f, -0.04235531f, 0.03779500f, -0.02644385f, -0.00760224f, 0.02374631f, 0.04237801f, 
    0.02273141f, 0.05040397f, -0.01051931f, -0.00832594f, -0.04783897f, -0.03531351f, -0.05737421f, -0.04855497f, 
    0.02035202f, 0.01831219f, -0.06351936f, 0.01568080f, -0.04275583f, 0.01111492f, -0.05566449f, 0.04745030f, 
    0.00176512f, -0.00762999f, 0.04492752f, -0.01872254f, 0.04220940f, -0.02779698f, 0.02962797f, -0.01822923f, 
    -0.03032630f, 0.02119149f, 0.02994091f, 0.03114665f, -0.02506563f, -0.06304459f, -0.02690774f, 0.01574676f, 
    -0.06414741f, -0.03260558f, 0.03053758f, -0.01540543f, -0.04271816f, 0.05102487f, 0.02983993f, 0.00185808f, 
    -0.05128030f, 0.02872271f, -0.06075240f, -0.00612397f, 0.02873139f, -0.05661410f, 0.00752833f, 0.03937525f, 
    0.02700482f, 0.00072668f, -0.03338031f, 0.02210094f, -0.01712172f, -0.02810152f, 0.03204739f, -0.04717855f, 
    -0.04860704f, -0.04967981f, 0.00133495f, -0.05703569f, -0.00872106f, -0.02043052f, 0.01466963f, -0.01418533f, 
    0.01782716f, 0.00273278f, 0.03384607f, 0.02355885f, -0.00234131f, 0.00903002f, 0.03865485f, 0.04542712f, 
    -0.03198890f, -0.04001538f, -0.04658967f, -0.02267757f, -0.00905154f, -0.04838277f, -0.02759345f, 0.02561791f, 
    0.01263057f, -0.06297930f, 0.01787698f, -0.01752056f, 0.02137075f, -0.02829442f, 0.03800597f, -0.05914304f, 
    0.01339675f, -0.02000290f, -0.00753361f, -0.02656937f, -0.05264201f, -0.04004104f, 0.04065884f, -0.03768244f, 
    0.02763822f, -0.04127727f, 0.01786937f, 0.02468404f, 0.04023053f, 0.04599391f, -0.03523743f, -0.02432449f, 
    -0.03404757f, -0.00439690f, -0.00739197f, 0.04994126f, -0.01014654f, -0.03561928f, 0.04602720f, -0.06310810f, 
    -0.04507831f, 0.01180185f, -0.01504304f, 0.04542169f, 0.01217546f, 0.01713082f, -0.03918135f, -0.05065919f, 
    -0.05778420f, -0.06033912f, -0.03584970f, -0.03713049f, 0.04892917f, -0.04987298f, -0.05821466f, -0.05467148f, 
    -0.02227388f, -0.06017101f, -0.01847401f, 0.02616857f, -0.01900128f, 0.02903510f, -0.02711862f, 0.02601518f, 
    0.03819493f, 0.02228922f, 0.02596072f, 0.04785781f, -0.03567626f, -0.02953527f, 0.04108818f, -0.05079062f, 
    0.04576484f, -0.02197983f, 0.04769651f, 0.00797887f, 0.01424307f, -0.01202112f, -0.02574839f, -0.02845395f, 
    0.00351896f, -0.01346888f, -0.03772151f, -0.05504514f, -0.00319823f, 0.04907648f, 0.02988113f, 0.04840881f, 
    0.04881242f, 0.01172367f, 0.01855857f, 0.01457790f, 0.03166357f, -0.00801537f, -0.05726991f, -0.01415656f, 
    0.01361291f, 0.02111601f, 0.03588862f, 0.01265167f, -0.04951415f, 0.00451330f, 0.00204283f, 0.00979091f, 
    -0.05986227f, 0.03876259f, 0.03849936f, -0.01624734f, 0.02269657f, 0.03997655f, 0.00760118f, -0.05362223f, 
    0.03082076f, -0.02461934f, -0.05109308f, -0.04001978f, -0.03655175f, -0.00635273f, 0.00949617f, -0.04316636f, 
    0.04646291f, 0.03079517f, -0.03074520f, -0.05129253f, 0.02543901f, -0.03593871f, 0.01451274f, -0.04539694f, 
    0.05027401f, 0.00615628f, -0.00828824f, 0.01321541f, -0.06299958f, -0.03732360f, -0.05053060f, 0.02631147f, 
    0.01343360f, -0.05739737f, -0.03470955f, -0.01568975f, -0.01793565f, -0.02105897f, -0.03791321f, -0.00235142f, 
    0.00715161f, -0.01483583f, 0.02314569f, 0.02423218f, 0.00598700f, -0.00536685f, -0.06035863f, 0.05011731f, 
    -0.06079841f, 0.00896877f, 0.04237358f, -0.03900240f, -0.06147002f, 0.03963351f, 0.03729995f, 0.04714569f, 
    -0.04293855f, -0.04185101f, -0.01724163f, -0.03113233f, 0.03079735f, -0.02027575f, -0.00746526f, -0.04009876f, 
    -0.01466441f, -0.04809657f, -0.04489441f, -0.02730324f, 0.04138803f, -0.04449491f, -0.04861091f, -0.02949322f, 
    -0.05793158f, -0.01592381f, -0.00916505f, 0.02930874f, -0.01374809f, -0.05263360f, -0.03352717f, -0.04909467f, 
    -0.06528649f, -0.00277177f, 0.04939139f, 0.01557685f, -0.03784960f, 0.03739562f, -0.02573300f, -0.02180751f, 
    -0.03463092f, 0.03388739f, 0.01251238f, 0.02538950f, -0.02215845f, -0.05252295f, -0.03220178f, -0.04028674f, 
    0.01784743f, 0.01568369f, -0.03859168f, -0.03895164f, 0.03057823f, -0.05142790f, -0.00209203f, -0.02183342f, 
    0.02818809f, 0.02434658f, 0.03284416f, 0.04421458f, -0.03879463f, -0.01786023f, -0.06241564f, -0.02324228f, 
    -0.02902028f, -0.03240591f, -0.01189164f, 0.00899958f, -0.05751151f, -0.01511241f, -0.03518999f, 0.00031456f, 
    -0.06045597f, -0.00258810f, 0.03699262f, 0.04086679f, 0.02310188f, 0.03350246f, -0.06222560f, -0.04780475f, 
    -0.01507146f, -0.01617933f, -0.01670500f, -0.03315639f, -0.00228799f, 0.01469030f, 0.04556223f, -0.00838288f, 
    -0.00024687f, 0.03549284f, 0.00032957f, 0.02629476f, -0.02909903f, 0.05083228f, 0.00494873f, -0.05387859f, 
    0.04168294f, 0.05028356f, -0.03368026f, -0.06589365f, -0.02691010f, -0.04333987f, 0.02462555f, 0.02661781f, 
    0.01112308f, -0.04100127f, 0.02616026f, -0.00222003f, 0.00727354f, -0.06241535f, -0.05048481f, 0.00584589f, 
    0.05002641f, 0.00229045f, -0.00691344f, 0.04242506f, -0.06530830f, 0.05074348f, 0.03651748f, -0.06512417f, 
    0.00066102f, 0.03826799f, -0.01858615f, -0.01514515f, -0.01469998f, -0.05633258f, 0.02388792f, 0.04382173f, 
    -0.00595337f, 0.03624533f, -0.05155053f, -0.02535082f, 0.04448899f, -0.00859082f, -0.05471176f, -0.02863878f, 
    -0.22901490f, 0.01126253f, -0.20749462f, 0.02698714f, 0.03006792f, -0.10121539f, 0.00836918f, 0.19155553f, 
    -0.02340569f, -0.34696341f, -0.12807150f, -0.18251556f, 0.00488562f, 0.05808965f, 0.03172951f, -0.13860708f, 
    -0.19768716f, -0.01408173f, 0.00945168f, -0.01611877f, -0.21602310f, 0.05597930f, 0.11374507f, 0.00725130f, 
    0.10031824f, 0.01431644f, -0.06733645f, -0.22430240f, 0.09945901f, -0.12666851f, 0.05594329f, 0.00194587f, 
    -0.00146197f, -0.02210983f, 0.11139720f, 0.00904106f, -0.32793635f, 0.03465970f, 0.07936997f, 0.20256838f, 
    0.09793171f, -0.20433848f, -0.05317871f, 0.03195123f, -0.02613228f, -0.27530915f, 0.09693050f, 0.09651733f, 
    0.16617392f, -0.06389331f, 0.03491411f, 0.02328141f, 0.21731842f, 0.16783154f, 0.34699389f, -0.04565179f, 
    0.09563658f, 0.01383287f, 0.12936521f, 0.04237138f, 0.04399161f, 0.02159692f, -0.11250474f, -0.14828466f, 
    0.13493109f, -0.27771705f, -0.15737598f, 0.01651811f, 0.04023834f, 0.00419380f, 0.19850326f, 0.08264092f, 
    0.14959213f, -0.28502691f, 0.12656164f, 0.00893120f, 0.00420906f, -0.05823168f, 0.16381273f, 0.03504432f, 
    -0.00000141f, -0.22886501f, -0.32425642f, -0.05590351f, -0.01925314f, -0.07761383f, 0.04510963f, -0.02878094f, 
    0.09465230f, -0.14605914f, 0.21189612f, -0.04057786f, -0.10005765f, -0.04891899f, -0.03356131f, 0.07453723f, 
    -0.00051752f, -0.04774956f, -0.19465348f, 0.25183672f, 0.21285039f, 0.16844128f, 0.14247130f, 0.05569907f, 
    0.08325188f, -0.07156277f, 0.14860216f, 0.13433950f, 0.09787301f, 0.25857443f, -0.16937901f, 0.11276462f, 
    0.34360942f, -0.12171264f, 0.06010866f, 0.00023751f, -0.10358620f, 0.40056336f, 0.07834799f, 0.03523513f, 
    0.15492116f, 0.11386718f, -0.20125510f, 0.13849856f, 0.04725984f, 0.04783614f, -0.31799030f, -0.03536541f, 
    0.21172705f, -0.04001690f, 0.07252121f, -0.00886565f, -0.00846047f, 0.07060351f, -0.07747781f, 0.17604578f, 
    -0.08757345f, 0.21595751f, -0.00202523f, 0.03434069f, 0.11660130f, 0.11596696f, -0.00988179f, 0.05777942f, 
    -0.20672780f, -0.05246494f, -0.08074103f, 0.11216886f, -0.12665851f, -0.09911773f, -0.05895576f, -0.08299567f, 
    0.02739139f, 0.24254818f, -0.05257665f, 0.33669806f, -0.05950007f, 0.25327745f, 0.06632981f, -0.01179542f, 
    0.11591120f, 0.10134196f, 0.04387487f, 0.20819612f, -0.07081273f, 0.00459109f, 0.12088590f, 0.21137087f, 
    0.13953124f, 0.00914235f, -0.06173157f, 0.19689511f, 0.08470471f, 0.10786067f, -0.06735035f, 0.11389834f, 
    0.03471888f, 0.05277742f, 0.07738651f, -0.09140550f, -0.30397686f, 0.06219630f, -0.03199719f, 0.11184647f, 
    0.05556124f, -0.00346930f, 0.01150291f, -0.02906669f, 0.09276190f, 0.16492395f, 0.07303289f, -0.02306471f, 
    0.14772429f, -0.12510206f, -0.09150544f, -0.00583091f, 0.12663165f, 0.02212176f, 0.27795672f, 0.09894351f, 
    0.25124547f, -0.02358939f, 0.10199427f, 0.24224550f, 0.20297542f, 0.10114766f, 0.07695847f, 0.33824378f, 
    -0.12006421f, -0.16548194f, -0.09501372f, 0.10462886f, 0.00520025f, 0.06903395f, -0.08348653f, -0.07854769f, 
    -0.13103488f, 0.04468032f, -0.09133316f, 0.05679406f, -0.15873902f, 0.10837997f, 0.13272363f, 0.16205573f, 
    0.19903159f, 0.06558039f, 0.21137643f, 0.22516122f, -0.08168979f, 0.11586645f, 0.02763806f, -0.01699932f, 
    0.12629233f, 0.07319089f, 0.10481826f, -0.13363965f, 0.24220134f, 0.13213034f, 0.09774886f, 0.01661517f, 
    -0.01561241f, 0.14773774f, 0.09076003f, 0.11064886f, 0.29583168f, 0.14629924f, -0.03018667f, 0.16710185f, 
    -0.14687803f, 0.11017117f, -0.07492624f, -0.19427383f, -0.41189858f, 0.27347717f, -0.21239133f, -0.11193287f, 
    -0.02263281f, 0.18622926f, 0.08980663f, 0.06552582f, 0.02542997f, 0.05080464f, 0.31433436f, 0.05258114f, 
    0.00113516f, -0.05754149f, -0.00358662f, 0.17974091f, 0.17819639f, -0.09485064f, 0.12425626f, -0.09774554f, 
    0.05446095f, 0.17806038f, 0.03046766f, 0.00070618f, 0.07226896f, -0.14648257f, -0.11434747f, -0.42307487f, 
    0.04329722f, -0.31495205f, -0.08640130f, 0.08958109f, 0.11730167f, -0.18041490f, -0.01753225f, -0.01413783f, 
    0.02416587f, -0.03960563f, 0.00277052f, -0.02849852f, 0.02867335f, 0.01119542f, -0.00619758f, -0.07596640f, 
    -0.06833253f, 0.01337286f, -0.07839852f, 0.03189423f, -0.05922619f, -0.01389126f, -0.07189787f, -0.00084083f, 
    -0.06602392f, 0.00142516f, -0.02473932f, -0.03475880f, 0.03666350f, -0.06308433f, 0.03433468f, -0.00882208f, 
    -0.01910396f, -0.03542505f, 0.03583419f, -0.06607635f, -0.07260554f, 0.03066833f, -0.08006979f, -0.00360004f, 
    0.03307816f, -0.07334642f, -0.06033392f, 0.02424317f, -0.00494164f, 0.00297276f, -0.05912609f, -0.02304023f, 
    -0.00644048f, -0.06770771f, -0.06206511f, -0.02628315f, -0.04286456f, -0.03637487f, -0.02557262f, -0.02524449f, 
    -0.01208946f, -0.07194051f, 0.00810968f, -0.02719613f, -0.07782368f, -0.04380820f, -0.04069993f, 0.01494300f, 
    -0.03390361f, 0.02717114f, 0.05281799f, -0.05423356f, -0.01434544f, -0.01747434f, 0.02575791f, 0.00996624f, 
    -0.02078170f, 0.00389530f, -0.06646743f, -0.07810478f, -0.04307979f, 0.00955092f, -0.06289888f, -0.05902763f, 
    0.00007206f, -0.01185788f, 0.00210905f, -0.01157247f, 0.00959947f, -0.05488157f, -0.03955254f, -0.04356032f, 
    0.00807560f, -0.05888826f, 0.00620299f, 0.01253452f, -0.03472870f, -0.05854212f, -0.06991650f, 0.00082976f, 
    -0.05554498f, 0.03014793f, 0.03635170f, 0.00620935f, -0.02462474f, -0.07680582f, -0.07005100f, 0.00093368f, 
    0.02551460f, 0.01753244f, -0.04327312f, -0.03075585f, -0.06421953f, -0.06553335f, -0.00934519f, -0.07793851f, 
    -0.01480216f, -0.07286038f, -0.07119459f, -0.03413333f, -0.02544927f, -0.04168897f, 0.00743339f, -0.04305316f, 
    -0.01088253f, -0.07700514f, -0.02966132f, 0.01126527f, -0.07735423f, -0.04422564f, -0.06636912f, 0.01347093f, 
    -0.04058862f, -0.03530407f, -0.07582060f, 0.02502117f, -0.05968628f, -0.01280088f, 0.01987652f, 0.01960793f, 
    -0.04564298f, -0.03661238f, -0.00025701f, -0.07348584f, 0.00609363f, -0.04035778f, 0.01230590f, -0.03257064f, 
    0.02614062f, 0.01833065f, -0.00437061f, -0.05033515f, 0.01679319f, 0.02393674f, 0.00145544f, 0.03512008f, 
    -0.06595773f, -0.02015644f, 0.00643530f, -0.06909785f, -0.07847953f, -0.05907613f, -0.02275259f, 0.01839794f, 
    -0.00712362f, -0.01522069f, 0.03594139f, -0.02402594f, -0.05474900f, -0.03822270f, -0.04189010f, -0.02641811f, 
    -0.01345066f, -0.06641973f, 0.00733707f, -0.05350054f, 0.02553171f, 0.02976508f, -0.03641188f, -0.04836242f, 
    -0.04389589f, -0.07361429f, -0.01017622f, -0.06190641f, 0.01292325f, 0.02654083f, -0.03735004f, -0.04268218f, 
    -0.01714652f, -0.06872881f, -0.00553306f, -0.00460005f, -0.02221878f, -0.06737241f, -0.02751136f, -0.03785829f, 
    -0.06660593f, -0.06860709f, -0.04555721f, 0.01359185f, -0.04116299f, 0.02500787f, -0.01528032f, 0.02709683f, 
    -0.04373989f, -0.02856114f, -0.02290531f, -0.07223142f, -0.05123792f, 0.02383244f, -0.01765105f, 0.03184943f, 
    -0.07036087f, -0.07762413f, -0.01179202f, 0.01023516f, -0.06527574f, -0.02086041f, -0.05060081f, 0.04332603f, 
    -0.00930675f, -0.04417997f, -0.01417446f, 0.00026665f, -0.04591739f, 0.00291203f, -0.01367008f, -0.03178553f, 
    -0.02058468f, -0.04257128f, -0.04725105f, -0.05362506f, 0.01062024f, 0.03001587f, 0.00420760f, -0.05317196f, 
    -0.01489358f, -0.01347040f, -0.05274394f, -0.05420401f, -0.05019322f, -0.00728554f, -0.07731159f, -0.04806629f, 
    -0.03480801f, -0.06711067f, 0.01369854f, -0.01176274f, 0.01397566f, -0.07872760f, -0.00707094f, 0.00851564f, 
    -0.03942887f, -0.02023677f, -0.07686648f, 0.01210157f, -0.07280053f, -0.00132804f, -0.01372039f, -0.07040382f, 
    -0.07630365f, -0.07924918f, 0.03241852f, -0.05462612f, -0.02877234f, 0.00888451f, -0.00573779f, 0.02557752f, 
    -0.07483787f, -0.02195644f, -0.01117138f, -0.06908059f, -0.00439686f, -0.02845856f, -0.06782960f, 0.00439496f, 
    0.03024165f, -0.05020178f, -0.00671308f, -0.04364033f, 0.03487198f, -0.01276943f, -0.00428076f, -0.04567102f, 
    0.05077388f, -0.03190220f, -0.05533043f, -0.04218476f, -0.01153875f, -0.03532828f, 0.04847717f, -0.02566840f, 
    -0.03335745f, 0.00292838f, -0.06060014f, 0.01431941f, -0.04961439f, -0.04387660f, 0.02593840f, 0.02766966f, 
    0.16853374f, 0.02768136f, 0.05582422f, 0.00253415f, 0.03080677f, -0.04986017f, 0.11588158f, 0.07054405f, 
    -0.07406463f, -0.13827968f, 0.02923561f, 0.03762813f, 0.18181787f, 0.11411820f, 0.02260337f, -0.10518039f, 
    0.02877342f, -0.15380302f, 0.06898177f, -0.03403940f, -0.03538072f, 0.02534004f, 0.01504579f, 0.10627095f, 
    -0.18309188f, -0.13435099f, -0.24972758f, 0.13658926f, -0.00383054f, -0.00329518f, 0.20445462f, 0.09726685f, 
    0.06225109f, -0.19461724f, 0.03611712f, 0.08919320f, 0.07097418f, 0.45796636f, 0.16425018f, 0.20803288f, 
    -0.10947132f, 0.01794096f, -0.16353045f, 0.18102148f, 0.06525267f, 0.13471757f, 0.27392772f, 0.12461916f, 
    -0.04452157f, -0.05639831f, -0.13965237f, 0.02169316f, 0.17861722f, 0.00031877f, -0.14591689f, -0.03447661f, 
    0.01948002f, 0.10802235f, 0.01169650f, -0.02563573f, -0.04482428f, 0.01697984f, -0.08960062f, 0.36900666f, 
    0.22956343f, -0.03126765f, -0.07489950f, -0.11754105f, 0.30069834f, 0.03007765f, 0.06044684f, 0.12092514f, 
    0.01983479f, 0.15911970f, -0.11795462f, 0.09006648f, 0.01883457f, -0.00091940f, -0.14411812f, 0.20220622f, 
    -0.01322886f, 0.06340706f, -0.13235684f, 0.13450946f, 0.09784799f, 0.05675084f, 0.06194153f, -0.32927617f, 
    -0.00332842f, -0.38679793f, 0.00878667f, -0.01790482f, -0.18451717f, 0.06591348f, -0.08416779f, 0.11859954f, 
    -0.13508497f, -0.14248958f, -0.11992215f, 0.10726112f, 0.10474031f, 0.08765996f, 0.01210588f, -0.03795970f, 
    -0.07454471f, -0.07613742f, 0.16752444f, 0.02154938f, -0.05748208f, -0.01376747f, -0.12944035f, 0.08617114f, 
    0.09567101f, 0.18211026f, 0.09286068f, -0.02752169f, -0.12053297f, 0.10203929f, -0.02778217f, -0.00372954f, 
    0.10642279f, -0.04668143f, -0.02476152f, -0.09569826f, -0.23054601f, -0.05012790f, -0.26381922f, -0.14706387f, 
    -0.03697485f, 0.01825436f, 0.04867193f, -0.02220938f, -0.08666067f, 0.10714837f, -0.05367253f, 0.00353168f, 
    -0.03869108f, 0.03379251f, -0.06536863f, 0.02623016f, -0.02847815f, 0.04357113f, -0.08065686f, 0.05874235f, 
    -0.04458537f, 0.09104423f, 0.04280115f, 0.29868284f, 0.07588842f, 0.21634626f, -0.20303713f, 0.03573646f, 
    0.04060148f, 0.03994936f, -0.02586128f, 0.43189022f, 0.14589670f, 0.07691963f, -0.04196044f, -0.01728781f, 
    -0.01121615f, 0.11641163f, -0.02777749f, -0.14069259f, 0.01073439f, 0.15187542f, 0.06453092f, 0.02009630f, 
    -0.22480223f, 0.08205257f, -0.01073096f, -0.08738483f, 0.10750740f, -0.33891475f, 0.00073869f, 0.03956294f, 
    0.05471241f, -0.06321844f, -0.01651921f, -0.14184289f, 0.14590989f, 0.19417779f, 0.05595600f, 0.11670318f, 
    -0.09974536f, -0.03146912f, -0.08876348f, 0.08065846f, -0.04946268f, 0.21223448f, 0.18625082f, 0.00328799f, 
    0.08658791f, -0.08693270f, -0.09850682f, -0.08085843f, 0.13607250f, 0.06212796f, 0.05003610f, 0.06511193f, 
    -0.02783882f, -0.07046293f, 0.01138687f, 0.05089975f, 0.03950928f, -0.04117345f, 0.15335360f, -0.26586658f, 
    0.03264771f, 0.10756547f, 0.09534031f, 0.12222093f, -0.07267229f, 0.08293341f, -0.08292845f, 0.07899775f, 
    0.18152002f, 0.04116313f, -0.01112782f, -0.02108926f, -0.11960378f, -0.06006520f, -0.13010982f, 0.07442465f, 
    0.06487004f, -0.01631930f, 0.02773402f, -0.05169751f, -0.18142720f, -0.04474181f, -0.01677375f, -0.03873747f, 
    -0.02237196f, 0.06902006f, -0.00020960f, 0.12697044f, -0.19798395f, -0.01597293f, -0.01232761f, 0.05926116f, 
    0.04750134f, 0.00606274f, 0.13450769f, -0.11031796f, 0.40237349f, 0.15947948f, 0.16028273f, 0.19470048f, 
    0.03595706f, 0.02333295f, -0.07228788f, 0.09459660f, -0.03234825f, 0.05735209f, -0.01798424f, 0.04258806f, 
    0.11223414f, 0.12802069f, -0.02706233f, 0.02737791f, 0.02479080f, 0.10901713f, 0.21334331f, 0.36958811f, 
    0.04180481f, 0.16127509f, 0.13634032f, 0.16431853f, -0.00843909f, 0.14801873f, -0.02562560f, -0.08703917f, 
    -0.15554021f, -0.00660983f, 0.12481639f, 0.06623041f, 0.07780249f, -0.13508619f, -0.00243418f, 0.05540471f, 
    0.15094842f, 0.13085362f, -0.06188081f, 0.12984441f, -0.03164958f, 0.02152098f, 0.04593203f, -0.08956763f, 
    0.06237707f, -0.12707090f, -0.20108037f, 0.11127235f, 0.12423610f, 0.22448519f, 0.02924563f, -0.06487527f, 
    0.01634319f, 0.07296654f, -0.13595916f, -0.08274262f, 0.13850009f, 0.08765899f, 0.15181091f, 0.07506850f, 
    0.06798019f, 0.03764494f, -0.01288808f, -0.04764429f, -0.25350934f, 0.11262857f, 0.00687431f, 0.15411733f, 
    0.12516403f, 0.06002697f, 0.03736220f, 0.06541931f, -0.10169640f, 0.03341299f, 0.06614453f, -0.04215603f, 
    0.05411056f, 0.05440112f, -0.09105741f, -0.23389848f, -0.00083653f, -0.09696758f, -0.34446150f, 0.12812141f, 
    -0.10210828f, 0.06369093f, 0.04914707f, -0.11415561f, -0.10946075f, 0.00630824f, -0.11644544f, -0.03246453f, 
    0.06685659f, -0.05186499f, -0.07069395f, 0.10974899f, -0.39190403f, -0.18736546f, 0.03523418f, -0.09433026f, 
    0.08915748f, -0.09044197f, 0.07496666f, -0.00067999f, -0.06796936f, -0.11962482f, 0.13657671f, 0.05787289f, 
    0.00152938f, -0.01100879f, -0.14502087f, -0.10756289f, -0.07617941f, -0.09899936f, -0.01622615f, -0.08295083f, 
    -0.01776464f, -0.05401469f, 0.05170768f, 0.06704648f, 0.03904789f, 0.07124308f, -0.24400909f, -0.00575893f, 
    0.03217634f, -0.08922394f, 0.28417596f, -0.03782604f, 0.17370515f, -0.04107439f, 0.11417360f, 0.11915000f, 
    0.17637853f, -0.04015182f, -0.20947935f, -0.07228626f, -0.00318060f, 0.11857154f, -0.08154200f, -0.00614116f, 
    -0.00160597f, 0.00455450f, 0.17717975f, 0.09803547f, -0.03420361f, 0.01615160f, -0.05531665f, 0.07521992f, 
    -0.09406199f, 0.08228873f, 0.01980820f, 0.13025990f, 0.29758495f, -0.07466383f, -0.03430088f, 0.05419738f, 
    0.10778170f, 0.14542557f, -0.00211116f, -0.00410367f, 0.03582811f, 0.00465545f, -0.23582016f, 0.01656505f, 
    0.10884913f, -0.11411747f, 0.02594554f, -0.00779166f, -0.10144100f, 0.09531202f, 0.31466985f, 0.33784869f, 
    0.05183370f, -0.02826374f, 0.11751533f, 0.03568434f, -0.01925798f, 0.10635834f, 0.02444597f, -0.01327564f, 
    -0.20640054f, -0.00778480f, 0.11344238f, 0.09682573f, 0.08197159f, 0.07021662f, 0.02703110f, -0.24183980f, 
    0.07481579f, -0.19591939f, -0.08748442f, -0.05279979f, 0.00374907f, 0.06678211f, -0.06861658f, -0.26777533f, 
    -0.02378459f, -0.09015872f, 0.32561326f, -0.20806183f, 0.26924175f, 0.23904325f, -0.01522613f, 0.12746482f, 
    -0.13961154f, 0.01523069f, 0.10546238f, 0.12468480f, 0.21245219f, 0.04069133f, -0.10015807f, -0.09749630f, 
    0.21385655f, -0.00136033f, 0.20464770f, 0.14094321f, 0.10250062f, 0.14750053f, 0.10232332f, 0.11040095f, 
    0.12807702f, -0.02626758f, 0.12652843f, 0.08512768f, 0.06789464f, -0.01494312f, -0.16169672f, 0.01893971f, 
    -0.00199214f, -0.07948674f, 0.10690929f, -0.01392149f, -0.10642035f, 0.12176829f, -0.17787085f, -0.13974071f, 
    0.20224556f, -0.07788728f, 0.08541505f, -0.04422234f, -0.00047524f, 0.06405696f, -0.04170031f, -0.02045717f, 
    0.07292643f, -0.05540128f, 0.10031372f, -0.00313739f, 0.01334507f, -0.19961840f, -0.06660015f, -0.04097410f, 
    -0.17134970f, -0.07056922f, -0.00110698f, -0.06507166f, 0.11579078f, -0.05962867f, -0.17769839f, -0.06066698f, 
    0.00352154f, 0.07261451f, 0.14812565f, 0.04112966f, -0.05656237f, 0.11606136f, -0.12014968f, -0.10109963f, 
    -0.13736960f, -0.03500972f, -0.04133726f, 0.07722834f, -0.03118026f, -0.01770900f, -0.00676045f, 0.02337821f, 
    -0.15119414f, -0.03389782f, 0.12318217f, 0.02417466f, 0.00406091f, -0.05595555f, -0.03541686f, 0.06662352f, 
    -0.17506093f, -0.17920332f, -0.16607687f, 0.27758542f, -0.09634471f, -0.07572487f, -0.08860187f, 0.01681772f, 
    0.11738490f, -0.00216235f, 0.00030447f, 0.01971390f, 0.23807511f, 0.23740628f, -0.11337214f, -0.04001690f, 
    -0.06736145f, 0.12236819f, -0.00832129f, -0.10214152f, -0.05051306f, -0.20938942f, 0.18969186f, -0.25181633f, 
    0.05603533f, 0.11344122f, 0.21335261f, -0.08099975f, -0.20622548f, -0.03601902f, 0.24575287f, -0.22435214f, 
    0.09765591f, 0.09510419f, 0.05837137f, 0.22278358f, 0.00483781f, 0.03334179f, -0.08828906f, 0.30259383f, 
    -0.26998127f, -0.19053154f, 0.09362575f, 0.03257624f, 0.16974655f, -0.02177801f, -0.02475756f, 0.16975461f, 
    -0.08221510f, 0.12535714f, 0.37918919f, 0.07506857f, 0.09988672f, 0.06481912f, -0.03718156f, -0.02120305f, 
    0.04575165f, 0.12235598f, 0.19211358f, 0.15390562f, 0.00286601f, 0.03875962f, 0.11391266f, 0.05708429f, 
    0.09799345f, -0.03295509f, 0.03796012f, 0.15325716f, -0.08252791f, -0.05097215f, -0.16816549f, 0.12130719f, 
    -0.02089821f, 0.11383209f, 0.03591505f, 0.18890771f, 0.08461078f, 0.04504608f, 0.03364789f, 0.08654621f, 
    0.09460895f, 0.00970154f, 0.14917363f, -0.10764936f, -0.01469785f, 0.02294633f, 0.17102647f, 0.05621077f, 
    -0.02772014f, 0.09361396f, 0.04837227f, -0.18351457f, 0.03224426f, -0.00759712f, 0.21553543f, 0.12321381f, 
    0.04305588f, -0.25319406f, 0.00115290f, 0.01836039f, -0.27854645f, -0.16111851f, -0.20541629f, 0.01314338f, 
    0.00719355f, 0.15164289f, 0.19248649f, -0.06059640f, -0.07199252f, 0.02937127f, 0.21418783f, -0.06511839f, 
    -0.03372065f, -0.04752697f, 0.11765857f, 0.04836652f, 0.10167051f, 0.03704741f, -0.01297689f, -0.00107781f, 
    -0.06479371f, 0.23953004f, -0.05099113f, 0.12306701f, -0.05796812f, -0.37594399f, -0.10833611f, 0.15241364f, 
    0.16201890f, 0.04812303f, -0.18428661f, -0.29391092f, 0.02728524f, 0.00215677f, 0.03794474f, 0.10701333f, 
    0.06364920f, 0.12926623f, -0.16251707f, 0.26221046f, 0.49897057f, -0.24333334f, 0.05555539f, -0.31118968f, 
    -0.00566187f, 0.03921558f, 0.29809797f, -0.27505466f, -0.35876614f, -0.22747217f, -0.12499008f, 0.21334164f, 
    -0.03144610f, 0.04536603f, 0.13054605f, 0.09799775f, -0.00002582f, -0.13342391f, -0.01506431f, -0.18461740f, 
    0.12790322f, 0.03877323f, 0.01694331f, 0.03527864f, -0.00742830f, -0.25521281f, -0.14045751f, -0.05306883f, 
    -0.29152229f, 0.01325093f, -0.21434700f, 0.04222861f, 0.13322148f, 0.08066972f, 0.06474754f, 0.19153750f, 
    -0.15568145f, 0.15048242f, 0.08482406f, 0.09997222f, -0.02515782f, 0.12971561f, 0.10448285f, -0.12540458f, 
    -0.01258933f, 0.28366467f, -0.09983070f, -0.04608248f, -0.23161428f, 0.07544193f, -0.00651124f, -0.09283152f, 
    0.22533692f, 0.01501492f, 0.28003705f, -0.04016874f, 0.06991214f, 0.02642920f, 0.06082617f, 0.00943186f, 
    0.09897358f, -0.15414502f, 0.04209130f, -0.01552828f, -0.02976101f, 0.00137613f, -0.12594040f, 0.07031211f, 
    -0.01186003f, 0.06425616f, -0.12723619f, -0.32375625f, -0.21597767f, 0.11838531f, -0.17322402f, -0.25114056f, 
    0.06938912f, 0.19857042f, 0.10024056f, 0.09041084f, 0.02341730f, -0.18746269f, 0.05801622f, -0.08864197f, 
    -0.21020469f, -0.04271727f, -0.01587125f, 0.10573158f, 0.10783278f, -0.01890989f, 0.12659049f, -0.02690300f, 
    -0.02638199f, 0.06030978f, 0.01452753f, -0.02464888f, 0.01298038f, -0.26815793f, 0.03785624f, 0.15601057f, 
    -0.21713476f, -0.05458415f, -0.08161218f, 0.10145691f, -0.08200040f, 0.16587009f, -0.01103204f, 0.06935257f, 
    0.07814811f, -0.13713410f, -0.19998266f, 0.03421721f, 0.07232417f, -0.18694077f, -0.17670943f, -0.17340787f, 
    -0.15954003f, 0.16430455f, 0.16293918f, -0.00823025f, -0.04661638f, 0.10873549f, -0.02126345f, 0.06483959f, 
    -0.02888824f, 0.06265297f, 0.03297093f, 0.02281731f, 0.02041535f, -0.02495168f, -0.07238463f, 0.15506454f, 
    -0.16593622f, 0.03238546f, 0.07477918f, 0.34151515f, 0.07122236f, -0.06168701f, -0.06145879f, -0.05436641f, 
    -0.08030846f, -0.16264905f, 0.17778479f, 0.09488097f, 0.02958612f, -0.01775024f, -0.17534260f, -0.23253123f, 
    -0.01301786f, -0.15751143f, -0.01002849f, 0.07319401f, -0.19278465f, -0.22517423f, 0.06495256f, 0.00181480f, 
    -0.09726273f, 0.02177327f, 0.04662227f, 0.10052759f, 0.00525972f, 0.03097314f, -0.21513475f, 0.15101385f, 
    0.08496051f, -0.07878606f, 0.01297748f, 0.06625421f, 0.05407751f, -0.18677768f, -0.04515466f, -0.17825703f, 
    -0.14048693f, 0.06966097f, -0.03961327f, 0.01668764f, 0.00731461f, -0.18352495f, 0.10382536f, 0.08548830f, 
    0.27950436f, 0.11489866f, 0.07137452f, -0.41139361f, 0.10482742f, 0.06682168f, -0.10398114f, 0.25560582f, 
    0.07377566f, 0.01677267f, -0.00292844f, 0.05096154f, 0.02499162f, 0.13299406f, 0.07614549f, -0.08302057f, 
    0.51126748f, -0.06403569f, 0.08851951f, 0.02828795f, -0.10914651f, -0.06958041f, -0.06234497f, 0.11222594f, 
    0.00979014f, 0.17393255f, 0.15931264f, 0.08116016f, -0.14539449f, -0.27462995f, -0.36624095f, -0.05176816f, 
    -0.08379878f, 0.04703261f, 0.09367238f, -0.17705260f, 0.31240529f, -0.10223941f, -0.12206352f, -0.15078220f, 
    0.03814445f, 0.11853892f, 0.02123149f, -0.15361457f, -0.00343006f, -0.12625988f, -0.16706264f, -0.02031563f, 
    -0.27038777f, 0.08776215f, 0.04416674f, 0.13702330f, -0.01577652f, -0.03948438f, -0.26680255f, 0.04891077f, 
    -0.04352099f, -0.00757117f, 0.08644597f, 0.06604621f, 0.02402700f, 0.09562830f, -0.02326735f, -0.22008759f, 
    0.06553674f, -0.07408450f, -0.01729064f, -0.12108400f, 0.19448660f, -0.01540923f, 0.29977825f, 0.30659229f, 
    0.03327988f, -0.07281590f, 0.10000206f, 0.00885774f, -0.07118697f, -0.10255091f, 0.22818549f, 0.01086369f, 
    0.09614775f, 0.07641066f, -0.00506583f, -0.09626173f, -0.02956784f, 0.06342954f, 0.11605265f, -0.14359532f, 
    0.17513369f, 0.03585751f, 0.08456751f, -0.00074827f, 0.09375829f, 0.13274847f, -0.04268812f, -0.12570758f, 
    0.09685200f, -0.35423261f, -0.28641611f, 0.07777882f, -0.04637651f, 0.03040361f, -0.10014378f, 0.10951093f, 
    0.24007165f, -0.06744688f, 0.49629688f, -0.02967535f, -0.24508370f, -0.11390468f, -0.06698831f, 0.35763404f, 
    -0.23006628f, 0.13875917f, 0.09175021f, 0.03448429f, 0.01441330f, -0.16849318f, 0.01656593f, -0.06673191f, 
    0.05816929f, -0.21748175f, -0.02443566f, -0.07377030f, 0.05287902f, 0.06551754f, 0.08368028f, 0.17732801f, 
    0.04772187f, -0.09622052f, 0.06419384f, 0.10581518f, 0.09021051f, 0.17488511f, 0.22084978f, -0.22515953f, 
    -0.06217423f, -0.05220217f, 0.11902561f, -0.09289241f, 0.06185692f, -0.00181400f, -0.18134803f, -0.14045455f, 
    -0.13933873f, -0.12492822f, 0.06471614f, -0.07868447f, 0.08303446f, 0.04281852f, -0.00539598f, 0.16206054f, 
    0.26662615f, -0.09172091f, 0.01342530f, -0.08777962f, -0.01541195f, 0.03276303f, 0.00237523f, -0.01090560f, 
    0.01893712f, 0.10206643f, -0.10314212f, 0.05008642f, -0.65191823f, -0.13587749f, 0.10140988f, 0.10382149f, 
    0.01146862f, -0.48559365f, 0.28851244f, 0.09093319f, -0.20563014f, -0.00047748f, 0.04738799f, 0.03699414f, 
    0.08541466f, -0.05798804f, -0.14717230f, 0.11381005f, 0.02322868f, -0.06422522f, -0.09208366f, 0.01325568f, 
    0.03729378f, 0.01892318f, 0.11115126f, 0.14968926f, 0.13246317f, 0.19633859f, -0.10244817f, -0.02136490f, 
    -0.14169386f, 0.13342601f, -0.04286532f, -0.03403247f, -0.06762497f, -0.01003338f, -0.33929428f, 0.08692557f, 
    -0.00027962f, 0.05630940f, 0.01823699f, -0.04561331f, 0.00405669f, 0.40119830f, -0.03302463f, -0.02767655f, 
    -0.10664596f, -0.00556838f, 0.25866082f, -0.02573520f, -0.07530018f, -0.06242881f, 0.00226317f, 0.31185368f, 
    0.07847574f, -0.11485075f, 0.01716595f, -0.02321143f, -0.12741975f, 0.04651390f, -0.10651361f, 0.40593937f, 
    0.19865943f, 0.08558273f, -0.04707609f, 0.07735118f, 0.17543304f, 0.09833109f, -0.13871199f, 0.05412560f, 
    0.15014437f, -0.21514706f, 0.05035706f, -0.18736081f, 0.05587645f, -0.05367649f, -0.01837624f, 0.12584004f, 
    0.02761274f, -0.06166967f, 0.18451649f, -0.07255195f, -0.01466229f, -0.05528866f, 0.07532831f, -0.15112424f, 
    0.08769720f, -0.05796574f, 0.05185463f, 0.25935337f, 0.07078210f, 0.02045138f, 0.03948753f, -0.00391705f, 
    0.10244002f, -0.01098786f, -0.01058471f, -0.51247185f, 0.14511636f, 0.13041924f, -0.06506886f, -0.10834598f, 
    -0.03933409f, 0.10244523f, 0.24524324f, 0.08086567f, 0.15726934f, -0.32011569f, 0.16860299f, -0.08350833f, 
    0.06507706f, -0.04146665f, 0.11504110f, 0.00199783f, -0.09056203f, -0.48281190f, -0.03664109f, 0.26895213f, 
    0.30183780f, 0.07048644f, 0.03098228f, 0.03381550f, 0.05874716f, -0.27644813f, 0.20483558f, 0.38685447f, 
    -0.07917085f, -0.04262403f, -0.07316340f, 0.05220621f, 0.18559836f, -0.07613777f, -0.02404559f, 0.06429839f, 
    0.08980820f, 0.12386003f, 0.02989027f, -0.29475665f, -0.10635196f, 0.02533514f, -0.12306135f, -0.00314451f, 
    -0.02984612f, 0.03613563f, -0.02661632f, 0.01586158f, -0.02200531f, -0.04668626f, 0.03524635f, 0.03991217f, 
    0.03906803f, 0.01566304f, -0.00411957f, -0.00651242f, -0.00422741f, -0.05028925f, -0.00164744f, -0.06240876f, 
    -0.02410088f, 0.02141061f, 0.00042155f, -0.03808561f, -0.04661850f, -0.04503464f, 0.03843917f, -0.04057976f, 
    -0.06046519f, 0.04611439f, -0.02450761f, -0.02021891f, 0.01342410f, 0.01720982f, -0.05119924f, 0.00940257f, 
    0.02464220f, -0.05697687f, 0.01125132f, 0.05020785f, 0.04347386f, -0.05422105f, -0.05354121f, -0.04286665f, 
    0.03230441f, -0.02008851f, 0.00118846f, 0.01993454f, -0.02054650f, -0.04565727f, -0.03609250f, 0.02229973f, 
    0.02820162f, 0.01964569f, -0.01802725f, -0.02836114f, -0.00352983f, 0.03459772f, -0.03466171f, 0.01125037f, 
    0.00027216f, -0.03594814f, 0.03562273f, -0.00469074f, -0.03595328f, 0.04922930f, -0.05258598f, 0.01483182f, 
    -0.00971719f, 0.04698689f, -0.05466570f, 0.02817906f, -0.06167610f, -0.04419407f, -0.00431857f, 0.03205806f, 
    -0.05082113f, 0.01597104f, -0.05199026f, -0.03559133f, 0.00541802f, -0.02928314f, 0.03746953f, -0.04668201f, 
    -0.01682838f, 0.00533839f, -0.00201414f, -0.00083008f, -0.05152449f, -0.00114439f, 0.04428473f, -0.00771043f, 
    0.04891975f, 0.02813081f, -0.05748915f, -0.04177817f, -0.01836184f, 0.04646819f, -0.00560684f, -0.03573985f, 
    0.04703605f, -0.04494493f, -0.00802514f, 0.01625554f, 0.01460853f, -0.01582741f, -0.03247685f, 0.01224068f, 
    -0.04683898f, 0.01171495f, 0.00937313f, 0.03609193f, -0.04647397f, 0.03070334f, 0.04858521f, 0.04041433f, 
    -0.06389850f, 0.04270007f, 0.02912275f, -0.03944661f, -0.00359886f, 0.00383075f, 0.01580737f, 0.02979490f, 
    -0.03482989f, -0.01208425f, -0.05960643f, 0.01955407f, -0.02885308f, 0.01033972f, -0.05344158f, -0.04410251f, 
    -0.04469286f, -0.04944130f, -0.01109639f, 0.03922608f, -0.01182043f, -0.06064083f, -0.02823094f, -0.03659459f, 
    0.00537899f, -0.02740707f, 0.01270357f, -0.02513322f, -0.00408148f, -0.02603912f, -0.00672066f, -0.02295707f, 
    0.04063584f, 0.00668961f, 0.04969793f, 0.05116877f, -0.01527132f, 0.01167176f, 0.05191524f, -0.03861356f, 
    -0.03055884f, 0.00550554f, 0.04844789f, -0.00140104f, 0.02932607f, -0.03358918f, 0.03975389f, -0.02212670f, 
    -0.02826270f, 0.00548837f, 0.02796005f, -0.04712172f, -0.02958286f, -0.01385817f, -0.06118146f, -0.05786758f, 
    -0.03664664f, -0.00174079f, -0.02286064f, 0.02117730f, -0.05516852f, 0.04342166f, 0.03988989f, -0.03621696f, 
    -0.04167573f, -0.05727499f, 0.00928334f, -0.03699169f, 0.02758710f, -0.00812840f, 0.03077856f, 0.04866430f, 
    0.00947061f, -0.04993816f, -0.04563229f, -0.02980586f, 0.03761767f, 0.03302605f, 0.02569721f, -0.03861916f, 
    -0.02113787f, -0.02116155f, 0.02340678f, -0.05182521f, -0.00404600f, -0.03619088f, 0.03863015f, 0.02330058f, 
    0.03498023f, 0.01287303f, -0.01324427f, 0.01362982f, -0.02164790f, -0.06385338f, 0.02058460f, -0.02416969f, 
    0.03150115f, -0.01020348f, 0.01091121f, -0.00484985f, 0.00808120f, 0.01105685f, 0.00178025f, -0.04049796f, 
    -0.06229889f, -0.02024423f, 0.00087641f, -0.04015166f, 0.04378383f, -0.06794046f, -0.06371858f, 0.00466817f, 
    0.04980829f, 0.02455935f, -0.02318951f, 0.01546184f, -0.06355566f, 0.03620775f, 0.04045696f, -0.01898271f, 
    -0.06157407f, -0.05123144f, -0.04611635f, 0.04142110f, -0.01277157f, -0.04537859f, -0.06049485f, -0.00086335f, 
    0.00607857f, 0.00361350f, 0.04506290f, 0.00395071f, -0.06261523f, -0.00822824f, 0.04390797f, 0.01267053f, 
    -0.02625676f, 0.03160363f, 0.04708986f, -0.04090886f, 0.03903130f, 0.01846404f, 0.01548557f, -0.04252713f, 
    0.04489676f, -0.03336158f, -0.04653703f, -0.04977245f, -0.01972345f, 0.02405847f, -0.03623925f, 0.03085277f, 
    -0.03390403f, -0.03294984f, -0.06112745f, 0.00537883f, 0.03239740f, 0.05105980f, -0.02377228f, 0.02052632f, 
    0.03056258f, 0.00984507f, -0.03235156f, 0.06145615f, -0.02900499f, -0.00374006f, -0.03844107f, 0.04077697f, 
    0.04258604f, -0.00466809f, 0.03003520f, 0.02461638f, -0.04362891f, 0.00213443f, 0.04720335f, -0.03071950f, 
    0.29481360f, -0.15151113f, -0.09088219f, 0.11606674f, 0.14496222f, 0.02537239f, 0.15276217f, -0.24938582f, 
    0.12901694f, -0.03735112f, 0.04990638f, -0.06391352f, 0.07302587f, 0.04230427f, -0.02611138f, -0.01845396f, 
    -0.07739630f, 0.06242066f, -0.14594398f, -0.01467299f, -0.06887823f, 0.21084593f, 0.19694071f, 0.08161041f, 
    0.11197890f, 0.11298376f, 0.07152821f, 0.05076962f, 0.01357885f, -0.14395274f, 0.03866531f, 0.00878076f, 
    -0.03800559f, -0.07436359f, -0.00666907f, -0.15821002f, 0.03027800f, 0.15845227f, -0.05522791f, 0.19107802f, 
    -0.07485410f, 0.13038398f, 0.12650071f, 0.00636454f, -0.11889393f, -0.00978592f, 0.16924657f, 0.13625877f, 
    0.14507262f, -0.11089035f, -0.01475243f, -0.29254958f, -0.03658018f, -0.13021749f, 0.08055472f, -0.06486098f, 
    -0.05880011f, 0.09465415f, 0.00965058f, 0.11472333f, 0.05144793f, -0.05159760f, 0.03263693f, -0.13853954f, 
    0.23286062f, 0.09007240f, 0.05585869f, 0.00526934f, -0.06287777f, -0.10036635f, -0.14545718f, 0.02573753f, 
    -0.10321482f, 0.03282794f, 0.14293782f, 0.12364865f, -0.00438021f, 0.01722032f, -0.20279343f, 0.06134085f, 
    -0.03430384f, -0.04959818f, 0.14738993f, 0.16597934f, 0.04291925f, 0.05724179f, -0.02670987f, 0.35427511f, 
    0.13353671f, 0.02450459f, -0.06514831f, -0.10167314f, -0.10980925f, 0.14767966f, 0.09023986f, -0.04888056f, 
    0.17424498f, 0.12245218f, 0.24236839f, 0.01547852f, -0.10495206f, -0.19231020f, 0.07843762f, 0.04979972f, 
    0.05637579f, 0.04509331f, 0.03293020f, 0.06624464f, 0.04097422f, -0.07836328f, -0.08560853f, 0.15562055f, 
    0.06942160f, 0.19859678f, -0.01442610f, 0.00851471f, -0.13348612f, -0.10224079f, -0.09821898f, -0.05041374f, 
    0.09079378f, -0.01798016f, 0.05799006f, 0.09061005f, 0.04644394f, -0.00035377f, 0.21558022f, 0.15731616f, 
    0.18109544f, -0.05880234f, 0.02737794f, 0.02600781f, 0.04015072f, 0.05256142f, -0.06077610f, -0.00756825f, 
    -0.07885323f, -0.11620358f, 0.21300867f, 0.03416446f, 0.18548541f, 0.01971225f, 0.19011831f, -0.19255649f, 
    -0.07059681f, 0.04704008f, 0.03061961f, 0.07268222f, -0.03318575f, 0.02139716f, -0.17856942f, -0.01040053f, 
    -0.07937024f, -0.29117468f, 0.13952067f, 0.10688173f, 0.04074356f, 0.15951908f, -0.03660459f, 0.22871616f, 
    0.02301348f, -0.15039057f, 0.02062890f, 0.01073984f, 0.21323064f, 0.12639530f, -0.02576318f, 0.06313924f, 
    0.20566811f, 0.15792909f, 0.05917594f, -0.03987713f, 0.04290785f, 0.02656204f, 0.03030573f, 0.08970290f, 
    0.05024913f, -0.06103215f, -0.02044803f, -0.03111391f, -0.06093344f, 0.09125738f, 0.08311400f, 0.13139731f, 
    0.04124336f, 0.05237980f, 0.12549075f, -0.10324505f, -0.18849209f, 0.08919620f, -0.25471726f, -0.08450619f, 
    0.06347826f, 0.00619927f, 0.11644258f, 0.24546836f, 0.09447657f, 0.15060095f, -0.01374444f, -0.03749469f, 
    0.03479157f, -0.06561895f, 0.02160235f, -0.15916793f, -0.13273709f, -0.08284505f, -0.11509516f, 0.12699135f, 
    -0.24738878f, -0.05250201f, 0.16160455f, 0.05491179f, 0.16959378f, -0.01185337f, 0.15380447f, -0.18872920f, 
    0.18561164f, -0.09974901f, -0.00370982f, -0.04382512f, 0.05782210f, -0.09668852f, -0.18936625f, 0.01724340f, 
    -0.13808127f, 0.07159932f, -0.03830665f, -0.01681003f, 0.20994122f, 0.03129155f, -0.03648371f, 0.10192329f, 
    0.00945033f, -0.05556598f, 0.10982767f, -0.09094891f, 0.00612678f, 0.11375885f, 0.03294454f, -0.04186878f, 
    -0.31158015f, -0.10230028f, -0.19486943f, 0.04301461f, 0.23627761f, 0.05437074f, 0.05171189f, -0.11105559f, 
    -0.07055791f, 0.09552737f, 0.09026420f, -0.02942654f, 0.02140662f, 0.09928961f, 0.02176837f, -0.08953603f, 
    0.04509925f, 0.02032048f, 0.02905924f, -0.08785562f, -0.05050880f, -0.03361040f, 0.34722009f, 0.01791041f, 
    -0.09280317f, 0.13242847f, 0.04059991f, 0.06654034f, 0.00000638f, -0.23462209f, 0.18846737f, -0.31438899f, 
    -0.16895200f, 0.11723290f, 0.09839910f, 0.01657081f, 0.10407825f, 0.13122895f, -0.12074771f, 0.07363471f, 
    -0.11343724f, 0.04457274f, 0.13016768f, -0.02511829f, -0.01561630f, -0.09467689f, -0.12530369f, 0.15876186f, 
    -0.18859062f, -0.50339741f, -0.27093270f, 0.02243260f, -0.09223392f, 0.11238053f, -0.09867113f, 0.04090216f, 
    0.16032247f, -0.04437992f, -0.27432713f, -0.21432246f, 0.00355032f, -0.09964451f, -0.08830763f, -0.11691141f, 
    0.00265993f, 0.17207032f, -0.00199605f, -0.05966295f, 0.14069061f, 0.18721388f, -0.06146452f, 0.03894629f, 
    0.08687536f, -0.09471721f, 0.06377173f, -0.07186680f, -0.17673810f, -0.28330922f, -0.05594055f, -0.01113913f, 
    0.03218516f, 0.02614159f, 0.05735498f, -0.03886028f, -0.17630616f, 0.03872524f, -0.34004796f, -0.26899108f, 
    0.01437476f, 0.11231899f, -0.01221113f, 0.14712957f, -0.12325858f, 0.10199159f, -0.13107893f, -0.29953936f, 
    -0.14304079f, -0.02906401f, 0.20516939f, 0.00643988f, 0.14087144f, -0.14519884f, 0.14935897f, 0.02319839f, 
    0.20598127f, 0.03541631f, -0.03766137f, 0.08883120f, 0.09197067f, -0.07985970f, 0.07573814f, 0.13719098f, 
    -0.03105604f, 0.04251913f, 0.11620951f, -0.02567567f, 0.05724131f, 0.13107310f, -0.07169264f, 0.07168426f, 
    0.12702011f, 0.25143853f, -0.03459046f, 0.05024355f, 0.08654546f, -0.06345446f, 0.08159724f, -0.08255480f, 
    -0.17673868f, 0.34618300f, 0.32478333f, -0.42742816f, 0.15095595f, -0.05817971f, -0.05918791f, 0.04436988f, 
    0.14917776f, 0.05112133f, 0.19850937f, -0.04343331f, 0.14001331f, 0.07796669f, 0.15805186f, -0.09135026f, 
    0.04727533f, -0.04585243f, 0.01074609f, 0.00119061f, 0.04555829f, 0.12899981f, -0.02288052f, 0.09534706f, 
    0.02434012f, 0.04963354f, 0.00871470f, -0.02752411f, -0.06684001f, -0.25432441f, -0.08908251f, -0.02234135f, 
    0.26270759f, -0.16700284f, 0.18525423f, 0.27742589f, -0.01269922f, 0.19879329f, 0.16275515f, 0.08991612f, 
    0.03454745f, 0.19065334f, -0.08179976f, 0.11103129f, -0.12770423f, -0.00978555f, 0.06726748f, -0.04030410f, 
    -0.20509127f, -0.01153647f, 0.14774126f, -0.09761868f, -0.05366798f, -0.01861312f, 0.11946282f, 0.13271210f, 
    0.28638163f, 0.23864876f, 0.01916221f, -0.19826999f, -0.04458473f, 0.07565979f, 0.07605045f, 0.12029801f, 
    -0.22311197f, -0.32595831f, -0.35604891f, 0.00586773f, -0.02927722f, 0.08262963f, -0.05238913f, 0.22242150f, 
    0.04751902f, 0.28134811f, 0.24059743f, -0.19043911f, -0.03113511f, 0.15832609f, -0.00203712f, 0.04676386f, 
    -0.04090047f, -0.06320056f, 0.22480114f, -0.11299315f, 0.01660241f, -0.07746425f, -0.12456005f, -0.07406701f, 
    0.09522864f, -0.00967643f, 0.01711001f, 0.10340670f, 0.06240334f, -0.05049022f, 0.04446446f, 0.00730030f, 
    -0.03334199f, -0.14147229f, 0.06265283f, 0.04699924f, -0.08789131f, -0.04423424f, -0.31340185f, -0.09355624f, 
    0.10584653f, 0.06820623f, -0.04699235f, 0.12850052f, -0.12149733f, 0.04897127f, -0.03416178f, 0.09492735f, 
    0.07259326f, 0.29260072f, 0.09668044f, -0.06674007f, 0.02118904f, -0.07163696f, 0.26062879f, 0.29342961f, 
    0.23474649f, -0.03247490f, 0.07761526f, -0.06401660f, 0.04889018f, -0.07116695f, -0.06833521f, 0.26240292f, 
    0.05627693f, 0.22568771f, -0.05597352f, -0.09479513f, -0.05559913f, 0.04704036f, -0.03136011f, 0.01431094f, 
    0.05485491f, -0.05825001f, 0.11794506f, 0.06406025f, -0.09164614f, -0.01865588f, 0.05066822f, 0.02085343f, 
    -0.02012768f, -0.07367298f, 0.00060042f, 0.08313348f, -0.00301011f, -0.13556293f, -0.00756418f, -0.00843425f, 
    -0.08781892f, 0.00834244f, 0.20522439f, 0.26593944f, 0.22853747f, -0.00786566f, -0.05429834f, 0.07273225f, 
    -0.11703449f, 0.00395399f, 0.15462971f, 0.06720199f, -0.50048649f, -0.55615216f, -0.00959125f, 0.23327889f, 
    -0.05472177f, 0.00463544f, 0.22228657f, -0.00937514f, 0.03745695f, -0.35907757f, -0.03405758f, -0.04252516f, 
    -0.04865912f, 0.01606303f, -0.03995656f, 0.12818305f, 0.17299709f, -0.14896892f, -0.16511285f, -0.20881993f, 
    0.21009043f, 0.17825513f, -0.06944409f, 0.23206651f, 0.10764582f, -0.02545700f, 0.04088408f, 0.29952389f, 
    0.11435624f, -0.14494225f, -0.09791066f, -0.01392945f, -0.00248350f, -0.04437962f, 0.01900666f, 0.11794702f, 
    -0.47265992f, -0.36288217f, -0.03946506f, -0.14691223f, -0.06433710f, -0.07463311f, -0.09541906f, 0.02956191f, 
    0.27581444f, 0.22972192f, 0.30195254f, -0.06073239f, 0.07103012f, -0.13825747f, 0.06156164f, 0.00283866f, 
    0.07502971f, -0.05858943f, 0.08022266f, -0.09035046f, 0.00143678f, 0.17130584f, -0.00223528f, -0.08575498f, 
    0.10466517f, -0.08275159f, -0.19224489f, -0.13304028f, -0.14342691f, 0.03534726f, 0.11646770f, 0.08611172f, 
    0.06184670f, 0.01534893f, 0.11742737f, 0.03075144f, -0.07425971f, -0.14829330f, 0.14389473f, 0.08609802f, 
    0.08719523f, -0.20083269f, 0.12064829f, -0.01977037f, -0.02162068f, -0.07449448f, 0.15989912f, 0.03162000f, 
    0.08435765f, 0.10975628f, 0.00605935f, -0.08208525f, 0.07512628f, -0.17341085f, 0.19659968f, -0.00736537f, 
    -0.07754215f, -0.02315544f, -0.05584488f, -0.06912234f, -0.33861747f, 0.16993167f, -0.11988418f, -0.10314185f, 
    0.05951767f, -0.05779535f, 0.03587595f, -0.00382520f, 0.06668092f, -0.01180042f, 0.16515969f, -0.15847313f, 
    -0.17670228f, 0.00815575f, -0.07581066f, 0.15894027f, -0.01645846f, 0.00637208f, 0.00262312f, 0.02729896f, 
    -0.27505720f, -0.04747950f, 0.05875619f, -0.05536758f, 0.09536271f, -0.07125370f, -0.01253541f, 0.23289528f, 
    -0.05996199f, -0.04970577f, -0.19473515f, -0.22505653f, -0.05060792f, -0.02212812f, -0.01769955f, -0.02489726f, 
    0.08943719f, 0.16582902f, 0.02616140f, 0.01790757f, -0.06581812f, -0.07254780f, -0.13552818f, 0.15656962f, 
    -0.04864092f, 0.08045377f, 0.29261371f, -0.11061142f, -0.06743328f, 0.00401793f, -0.05422856f, 0.11615577f, 
    0.05140808f, 0.01341095f, 0.19057623f, 0.30688795f, -0.10001959f, -0.21957502f, -0.06096711f, -0.02663372f, 
    0.11018208f, -0.12535888f, 0.17674130f, -0.04821020f, -0.11205576f, -0.09252162f, -0.09485199f, -0.15711601f, 
    -0.23118894f, -0.01128277f, 0.05545379f, 0.05903397f, 0.11115377f, 0.21781014f, 0.04056384f, -0.00739523f, 
    0.01571538f, 0.02409166f, 0.02685959f, 0.00520382f, 0.06423640f, 0.07089896f, 0.07850653f, -0.09589274f, 
    -0.12648733f, -0.22785220f, 0.01415927f, 0.12419254f, 0.04395721f, -0.17759004f, -0.21738210f, -0.09965175f, 
    -0.02515158f, -0.04952101f, -0.12138741f, -0.03483188f, 0.04657514f, -0.19867876f, -0.24861431f, -0.04824669f, 
    0.04167121f, -0.29660064f, -0.05919622f, 0.13423076f, 0.02510704f, 0.01153038f, 0.04215570f, 0.00242123f, 
    0.02729899f, 0.12993862f, -0.08060298f, -0.12383451f, 0.17469537f, 0.03131972f, 0.08752734f, 0.01272910f, 
    0.25074464f, 0.16834317f, 0.12878527f, 0.11631425f, -0.10778903f, 0.01234657f, 0.13266775f, 0.09183041f, 
    0.02750791f, 0.17703335f, 0.02676974f, -0.06673099f, -0.04793848f, -0.03155305f, 0.01774651f, -0.01290155f, 
    0.06894360f, 0.06892198f, 0.09684511f, 0.05087255f, 0.01775650f, 0.12156264f, -0.21876231f, 0.07770607f, 
    -0.17531246f, 0.04052174f, 0.15872817f, -0.21756628f, 0.07445194f, 0.30111286f, -0.25979114f, -0.12304540f, 
    -0.03695654f, -0.09959667f, 0.00466621f, -0.06643038f, 0.00820290f, -0.11643235f, -0.12298555f, 0.02551605f, 
    -0.11147825f, -0.13529801f, -0.10173912f, -0.02965801f, 0.03957659f, 0.00340724f, -0.06474341f, 0.02099672f, 
    -0.06226499f, 0.01857263f, -0.19824333f, 0.13882902f, 0.14301479f, -0.05809718f, 0.13792078f, 0.20222583f, 
    0.07964475f, 0.04749842f, 0.18718132f, 0.12730607f, 0.14254072f, -0.15187080f, -0.03871804f, 0.05891316f, 
    -0.05055859f, 0.00582361f, -0.06613784f, -0.15497471f, -0.01197761f, 0.01022919f, 0.04188109f, -0.15794720f, 
    0.02365469f, -0.19451571f, 0.00680153f, -0.27104574f, -0.50293660f, 0.25059879f, 0.01001394f, -0.00684772f, 
    -0.12317856f, 0.08782306f, 0.12737752f, -0.15491493f, -0.09986040f, -0.28585875f, -0.42159611f, -0.07484685f, 
    0.08134612f, 0.10142953f, -0.03501424f, -0.03337921f, 0.00960343f, -0.03458644f, -0.20267865f, -0.01624810f, 
    0.01386313f, 0.08145393f, -0.14409673f, 0.01864924f, 0.16186278f, -0.03801608f, 0.28455552f, -0.19155055f, 
    -0.03400359f, -0.08501169f, 0.03667914f, -0.00655054f, -0.08770815f, -0.01849276f, -0.16275148f, 0.00741378f, 
    -0.04772253f, -0.09689708f, 0.04383213f, 0.01305109f, 0.00452312f, -0.03335917f, 0.02981939f, 0.08117580f, 
    -0.02652613f, -0.03494868f, -0.00068964f, -0.01968781f, -0.02797002f, -0.00769205f, 0.02953750f, -0.05459641f, 
    -0.04530124f, 0.00672833f, 0.03641413f, -0.00568121f, -0.03642388f, 0.03507667f, 0.01589690f, -0.02602809f, 
    -0.00159302f, -0.05839407f, -0.02197630f, -0.02691958f, 0.01426285f, 0.03790576f, -0.04516231f, 0.04173173f, 
    -0.05200762f, 0.04574000f, 0.04042081f, -0.02228358f, 0.04641412f, -0.06097545f, -0.01504444f, 0.04761644f, 
    -0.01389224f, 0.03561515f, -0.03316238f, -0.02178618f, -0.00829935f, -0.00122611f, 0.03865094f, -0.01128262f, 
    -0.03819910f, 0.00010397f, -0.03450440f, 0.00978522f, -0.03941430f, 0.05342133f, -0.01464625f, 0.01691507f, 
    -0.04241130f, -0.06630091f, 0.00157989f, -0.04661638f, -0.01780012f, -0.05053175f, -0.00377518f, -0.05937476f, 
    -0.05813757f, -0.03635221f, -0.04154942f, -0.03920258f, 0.02794464f, -0.00375345f, 0.03288421f, -0.05918210f, 
    0.05366144f, -0.04027362f, 0.04025406f, -0.05379305f, 0.01479852f, 0.03785064f, 0.00989832f, 0.03804244f, 
    -0.04759254f, -0.00877508f, 0.02783752f, -0.03152611f, -0.05337497f, 0.02839848f, -0.00528130f, -0.03337269f, 
    0.04588571f, -0.01068253f, 0.03319275f, 0.03633985f, -0.05854747f, 0.02439347f, -0.03159352f, -0.03413519f, 
    -0.03091939f, 0.02316906f, 0.04613601f, -0.04256980f, 0.00964198f, -0.05579269f, 0.04481825f, 0.02794324f, 
    0.03813669f, 0.02208431f, 0.01747267f, -0.01962634f, 0.04131338f, -0.03141474f, 0.01451153f, 0.01455453f, 
    -0.04458917f, 0.03494262f, 0.05350930f, 0.04792749f, -0.03423502f, -0.06311873f, 0.00087354f, -0.03672485f, 
    -0.03986796f, -0.02492638f, 0.05247004f, -0.00158158f, -0.05655196f, 0.02152952f, 0.01035752f, -0.04646161f, 
    -0.03789705f, 0.03449206f, -0.02711801f, -0.04736106f, -0.03483046f, 0.02682485f, -0.01040077f, -0.00096505f, 
    0.00453805f, -0.03847219f, 0.00613265f, -0.00403120f, -0.01930232f, -0.04777996f, -0.03403506f, 0.02215078f, 
    0.00192604f, 0.02650167f, 0.04478020f, -0.00083757f, -0.00994485f, -0.04756870f, -0.02938617f, 0.01590697f, 
    -0.01769653f, 0.02587047f, -0.03728374f, -0.04570490f, -0.00975693f, 0.03204495f, -0.02876165f, -0.01336981f, 
    -0.04919299f, -0.04696026f, -0.05157570f, 0.02837607f, 0.03098831f, -0.05506971f, -0.00252315f, 0.04408750f, 
    0.00689752f, -0.06111384f, 0.03443585f, 0.04605329f, -0.02771878f, -0.02777525f, 0.00816099f, 0.02460785f, 
    -0.03250438f, -0.04554669f, 0.03963819f, -0.04378739f, 0.00038477f, -0.03134947f, -0.01311179f, -0.06039890f, 
    -0.00916802f, -0.01267714f, -0.00699853f, 0.05041173f, -0.00316432f, -0.03081360f, 0.04917828f, -0.00463763f, 
    -0.04994733f, -0.02300493f, -0.04210151f, -0.02019998f, 0.02410150f, -0.02254158f, 0.02954761f, 0.00928234f, 
    -0.05458976f, -0.03110615f, 0.00560384f, 0.01472310f, -0.04327801f, -0.02794963f, 0.03233917f, 0.00469317f, 
    0.03545541f, 0.03522260f, -0.03659246f, 0.05358920f, 0.00981294f, -0.05936374f, -0.02687194f, 0.00299907f, 
    0.05023197f, -0.03697798f, -0.01942457f, -0.04101893f, 0.03358624f, -0.05138044f, 0.03976262f, -0.02529785f, 
    -0.00056422f, -0.02014385f, -0.05740335f, -0.02507230f, -0.00135669f, 0.04640679f, 0.02069896f, -0.04968651f, 
    0.03462533f, 0.03275932f, -0.03414905f, -0.01325600f, -0.04274734f, 0.03870013f, -0.05724632f, -0.04357778f, 
    -0.00200339f, 0.03031672f, -0.06395244f, 0.04654805f, -0.01546760f, -0.01608261f, 0.00700796f, 0.04388658f, 
    -0.03450149f, -0.06161487f, -0.03269598f, 0.04242099f, -0.05391527f, -0.00595188f, -0.04619340f, -0.03562148f, 
    -0.03477499f, -0.00647856f, 0.03709677f, -0.00026264f, 0.02135088f, -0.03126318f, -0.05284081f, -0.03642163f, 
    -0.02630372f, 0.05304992f, -0.00460743f, -0.01626606f, 0.03411045f, -0.05482879f, 0.04812153f, -0.02703259f, 
    -0.00094156f, 0.03181502f, -0.05523520f, 0.00899590f, -0.05579225f, -0.00853858f, -0.02645857f, -0.02144055f, 
    0.05018564f, 0.03242238f, -0.04243794f, -0.03786372f, 0.04749494f, -0.00238180f, 0.03032585f, 0.03932492f, 
    -0.03029055f, -0.03555488f, -0.06494687f, -0.02826575f, 0.03050100f, -0.05768817f, -0.01486520f, -0.04939783f, 
    -0.29208598f, -0.30934548f, -0.15003568f, -0.27010509f, -0.05881152f, 0.01791392f, -0.12193226f, 0.03222239f, 
    0.05881967f, 0.12334871f, -0.19159313f, -0.31851479f, 0.01700954f, -0.17237075f, -0.02322291f, 0.09378172f, 
    0.05809705f, 0.05261333f, -0.49727115f, -0.37736854f, 0.07627685f, -0.03254699f, -0.09741712f, -0.07806055f, 
    0.22668214f, -0.02827270f, 0.18153632f, 0.00254736f, -0.02890965f, 0.00490856f, -0.11277697f, 0.01238074f, 
    -0.09413344f, 0.07496879f, 0.01441334f, -0.27499038f, -0.32807022f, -0.40666005f, -0.66053247f, -0.07222570f, 
    -0.23154825f, 0.14658976f, 0.05243117f, 0.09809475f, 0.13602439f, 0.10541750f, -0.17075559f, -0.36965209f, 
    0.08121584f, -0.09964000f, 0.12272225f, 0.29326206f, 0.02066622f, -0.12205900f, 0.08249315f, 0.07669929f, 
    0.09888292f, -0.08035571f, 0.05827462f, -0.04106751f, 0.04376949f, 0.12003120f, -0.03937228f, 0.30654216f, 
    -0.03192279f, -0.02271074f, 0.01934183f, -0.02151567f, -0.08302973f, 0.23020947f, -0.13071610f, 0.22801256f, 
    0.03948143f, 0.19171947f, 0.34224299f, -0.00295285f, -0.07346660f, 0.17142048f, 0.06731691f, 0.06550887f, 
    -0.01401384f, -0.10672718f, 0.11662719f, -0.16225971f, -0.09886211f, -0.13965282f, -0.01575682f, 0.07073789f, 
    -0.04884734f, 0.02689380f, 0.36529800f, 0.05859327f, 0.12079833f, -0.14288715f, -0.02840841f, 0.00040764f, 
    0.08730508f, 0.20299755f, -0.01104938f, -0.03801885f, 0.00051965f, 0.05169636f, -0.13945977f, 0.00885480f, 
    -0.04482133f, -0.03302388f, 0.01913308f, 0.04224189f, -0.35325783f, -0.09303267f, -0.29241931f, 0.07129074f, 
    0.00107841f, -0.04991302f, 0.07641882f, 0.04827078f, -0.15648849f, 0.14582145f, 0.14400525f, 0.03212574f, 
    -0.21587843f, 0.07387386f, 0.02199446f, 0.04563154f, -0.01965585f, 0.07108904f, 0.03976236f, -0.16321173f, 
    -0.16817355f, -0.10534191f, 0.11150702f, -0.09695826f, -0.03596845f, 0.04509684f, 0.11545958f, 0.19520614f, 
    0.28595671f, 0.17904471f, 0.13493633f, -0.09689654f, -0.03308820f, 0.04390769f, 0.03387633f, 0.14665687f, 
    -0.05592007f, 0.12299426f, -0.12197221f, -0.02710990f, -0.20743187f, 0.11849450f, 0.02712600f, 0.05631437f, 
    -0.06182719f, 0.09012046f, 0.08488137f, -0.20077050f, -0.11139636f, -0.02618095f, 0.11352805f, -0.16693126f, 
    0.06726103f, -0.12344963f, 0.00897614f, -0.31776285f, 0.08928550f, -0.07574816f, -0.16277587f, -0.07482073f, 
    -0.05373356f, 0.02810671f, 0.09508817f, 0.07641102f, 0.13312718f, -0.08713017f, -0.22246741f, 0.05243118f, 
    -0.17957857f, -0.05477927f, -0.05592334f, -0.00366915f, -0.06402989f, -0.33460182f, -0.34062195f, 0.01029907f, 
    -0.05032319f, 0.11583094f, -0.01256754f, 0.01617771f, 0.04859039f, 0.15996154f, 0.07635289f, 0.18187408f, 
    -0.26464099f, 0.14813793f, 0.12735704f, -0.05862526f, 0.09060439f, -0.07847826f, 0.06648223f, 0.19186737f, 
    0.09518511f, 0.05749511f, 0.01176063f, -0.19734196f, -0.03764989f, 0.02599578f, 0.11975876f, 0.34608731f, 
    0.16643625f, 0.29535577f, -0.18129186f, 0.00208022f, 0.10100408f, 0.12885231f, -0.01925106f, 0.02073686f, 
    -0.14460163f, -0.23291931f, 0.18094482f, -0.05795367f, 0.11030408f, -0.05484515f, 0.04626890f, -0.02957108f, 
    0.04349049f, 0.06210437f, 0.00561308f, -0.13347749f, -0.13621968f, -0.01437384f, -0.11516213f, 0.14912120f, 
    0.01300740f, 0.02973933f, 0.25647008f, 0.19990262f, 0.17301342f, -0.00803619f, 0.01197532f, -0.10531832f, 
    0.06177731f, 0.10688450f, 0.17108676f, 0.07776798f, -0.81804758f, -0.62909490f, 0.06742296f, 0.10421529f, 
    -0.21084505f, -0.00231090f, -0.01068723f, -0.07618807f, 0.07507211f, -0.49088725f, 0.10634101f, -0.03897558f, 
    0.02078466f, -0.12378371f, 0.07350124f, 0.02140967f, 0.13209344f, -0.50338912f, -0.01432402f, 0.01538178f, 
    0.15438198f, 0.31439337f, -0.09041740f, -0.01902829f, -0.13905850f, 0.11479370f, 0.15662239f, 0.38189626f, 
    0.18743651f, -0.11983918f, -0.05804953f, 0.02163859f, 0.08806823f, 0.11636548f, 0.06327067f, -0.06950220f, 
    -0.52287239f, -0.43878332f, -0.04709609f, 0.03801889f, -0.16345052f, 0.06982297f, -0.07050449f, 0.03756573f, 
    -0.04726918f, -0.19691065f, -0.03367311f, 0.02204425f, 0.08865561f, 0.16645083f, -0.00008758f, -0.24495603f, 
    -0.35671359f, -0.04889489f, -0.07262728f, -0.28554818f, 0.15515645f, 0.09577639f, 0.02579299f, 0.01520960f, 
    -0.05727181f, -0.18512294f, -0.12374926f, -0.19136469f, -0.04724071f, 0.00561197f, 0.07144350f, 0.00263456f, 
    0.06532253f, 0.08331959f, -0.09520383f, -0.02103022f, -0.19428490f, -0.11523730f, -0.00232057f, 0.04382014f, 
    0.02166419f, -0.08167990f, 0.00330752f, -0.01459069f, 0.02091324f, 0.05552703f, 0.03721990f, -0.00837646f, 
    0.18703015f, 0.01641942f, 0.05374252f, -0.09210739f, 0.19106255f, -0.10399137f, 0.03210214f, 0.03686987f, 
    -0.05298064f, -0.13385917f, -0.10667748f, -0.00134025f, -0.25017965f, -0.11075643f, -0.05181162f, 0.10848866f, 
    -0.02721444f, -0.05854055f, -0.05408324f, 0.09737264f, -0.01833831f, -0.09226228f, 0.13893813f, -0.02672382f, 
    0.18555924f, 0.11528395f, -0.00186327f, -0.12637149f, -0.07306893f, -0.06747882f, -0.00333902f, -0.24737021f, 
    0.03299958f, -0.15388946f, 0.36941490f, 0.02323302f, 0.07456813f, 0.12833352f, -0.00432516f, -0.01121345f, 
    0.06328005f, 0.11489816f, 0.22814569f, 0.19661650f, -0.01751922f, 0.00435309f, -0.03158969f, -0.02746833f, 
    0.06691668f, -0.03728643f, -0.23283276f, -0.16483399f, -0.16606006f, 0.14484082f, -0.01702555f, 0.11143900f, 
    0.04816969f, -0.05176312f, 0.14912966f, -0.00301566f, -0.00777071f, -0.15469404f, -0.17073284f, 0.04688824f, 
    0.04672062f, -0.03980049f, -0.03855960f, 0.21671958f, 0.21513510f, 0.03178135f, 0.02132856f, -0.06253505f, 
    0.15660143f, -0.07393800f, 0.10311202f, -0.04136117f, 0.03669610f, -0.04220409f, 0.01845564f, -0.03105963f, 
    0.03624805f, -0.06717131f, 0.14516875f, 0.02246836f, 0.10607556f, 0.10762554f, 0.36518463f, 0.16597231f, 
    0.19733784f, -0.01685617f, 0.05119662f, 0.10704540f, -0.17723420f, 0.08315735f, 0.07842670f, -0.00128892f, 
    -0.16400413f, -0.23484021f, 0.03370313f, 0.08827043f, 0.10853275f, 0.12150738f, -0.04022775f, -0.03624582f, 
    0.13362403f, -0.05165116f, -0.19185284f, 0.03438292f, -0.15051891f, 0.02081939f, 0.08236721f, -0.15294601f, 
    -0.15243120f, -0.05198391f, -0.02904364f, 0.33358616f, 0.09105480f, -0.03399356f, 0.09611687f, -0.09819540f, 
    -0.11969915f, 0.09400050f, 0.10103139f, 0.25552866f, 0.19773342f, 0.02372988f, 0.05813039f, -0.08135778f, 
    0.32113335f, -0.05971242f, 0.05887583f, 0.15730380f, 0.00764478f, 0.09419072f, 0.10253403f, -0.03043267f, 
    0.10518873f, 0.01677536f, -0.02058093f, 0.14964882f, 0.02165825f, -0.09832382f, 0.01454886f, -0.04329256f, 
    0.06275038f, -0.06438916f, 0.04285539f, 0.09434194f, 0.01667850f, 0.01895022f, -0.19108611f, -0.11565901f, 
    0.16022024f, -0.13583146f, 0.30438921f, 0.00005795f, 0.03201114f, 0.11823194f, -0.17738023f, -0.17060860f, 
    -0.06187648f, 0.00123323f, -0.01645025f, -0.05666368f, -0.02079519f, -0.02128097f, -0.11230825f, -0.00395749f, 
    -0.08496821f, -0.16056216f, 0.25566173f, -0.01216544f, 0.18337332f, 0.06244572f, -0.10193761f, 0.26925108f, 
    0.01338539f, 0.06859656f, -0.13689299f, -0.04423498f, 0.10790112f, -0.00206423f, 0.04268549f, 0.02586771f, 
    -0.07157785f, -0.01087475f, -0.12611860f, 0.02014194f, -0.06471297f, 0.13926066f, -0.21263963f, 0.00049328f, 
    0.02443854f, -0.04620793f, -0.04409844f, -0.14570448f, -0.09760720f, -0.10367483f, 0.01837834f, -0.01179721f, 
    -0.08220735f, -0.19144155f, -0.08098155f, 0.23487023f, 0.09023126f, 0.08722046f, -0.03097226f, -0.07700830f, 
    -0.13354230f, -0.04776037f, -0.01496442f, 0.13940515f, 0.39275396f, 0.27351451f, -0.07702789f, 0.01395130f, 
    -0.15366106f, 0.02682768f, -0.10124671f, -0.07288377f, -0.08355917f, 0.23635466f, 0.14115028f, 0.30460989f, 
    0.01712073f, 0.10224605f, -0.03711706f, 0.05215514f, -0.02992257f, -0.13592882f, 0.24389981f, -0.20011088f, 
    -0.09742796f, 0.14956705f, 0.06205227f, -0.00467103f, 0.11512449f, -0.02811361f, 0.02577996f, 0.07636443f, 
    -0.11930182f, -0.15529747f, 0.15508968f, 0.05619485f, 0.02110025f, -0.11369564f, -0.04446499f, -0.00682969f, 
    0.14153732f, 0.28731400f, 0.24572490f, -0.18165554f, 0.17687167f, 0.23488562f, 0.22401410f, 0.09044541f, 
    -0.04213750f, 0.03631430f, 0.03903489f, 0.01456723f, -0.37079012f, 0.12039977f, 0.01383235f, 0.14823835f, 
    0.06655250f, 0.03442954f, 0.13046603f, 0.02167838f, -0.15300557f, -0.18066528f, 0.00209579f, 0.15066005f, 
    -0.06889552f, 0.01440845f, 0.27740371f, 0.11001629f, 0.04702367f, -0.09709669f, -0.01509165f, 0.03833107f, 
    -0.02343702f, 0.08577764f, 0.03043163f, -0.10001229f, 0.02007823f, 0.09472042f, 0.13763170f, -0.28684601f, 
    0.00499945f, 0.03245047f, 0.43016937f, 0.01779788f, 0.00385204f, 0.18657240f, -0.03118093f, -0.22055419f, 
    0.03726733f, 0.19517793f, 0.33450377f, 0.02976089f, 0.08145564f, -0.14513557f, -0.16392450f, -0.53757751f, 
    -0.21046489f, -0.01144479f, 0.01073291f, -0.11789059f, -0.07387747f, -0.10213300f, 0.26770574f, 0.04788558f, 
    -0.12255236f, -0.14421208f, -0.10491517f, 0.03685204f, 0.01235053f, 0.17038050f, 0.08536059f, -0.03616762f, 
    -0.34214666f, -0.43818614f, -1.16488624f, 0.02572311f, 0.06157581f, -0.14514257f, 0.08879086f, -0.19677244f, 
    0.05290997f, 0.03728174f, -0.27303880f, -0.11349662f, 0.07873903f, 0.10973340f, -0.12219536f, -0.12019336f, 
    0.15117241f, 0.17177832f, 0.28595081f, -0.01800925f, -0.15261918f, 0.05224052f, 0.13593513f, -0.07646883f, 
    -0.04095956f, -0.03671111f, 0.19953801f, -0.43409830f, -0.39006943f, -0.15549147f, 0.05202293f, -0.04944427f, 
    0.01103723f, -0.09235176f, -0.03250356f, 0.18957327f, -0.06847368f, 0.05370123f, 0.17346323f, -0.00940038f, 
    0.24170922f, 0.04903942f, -0.08102839f, 0.21905878f, -0.04224495f, 0.00476124f, -0.41667119f, 0.04623416f, 
    -0.02447892f, 0.02795067f, -0.24811536f, -0.25234884f, 0.04667142f, 0.05823594f, 0.31934169f, -0.40141472f, 
    -0.14870849f, 0.09956238f, 0.15406656f, 0.06585192f, 0.13643374f, -0.06679579f, -0.09097512f, 0.20704553f, 
    0.16572115f, 0.12922043f, -0.01697258f, -0.16907384f, -0.22041443f, -0.08064334f, 0.00554666f, -0.10580679f, 
    -0.21919356f, -0.03788687f, -0.14278971f, -0.40867674f, 0.08523046f, -0.04452165f, 0.15127188f, 0.18325043f, 
    0.05204347f, -0.09636411f, -0.35981795f, -0.58969176f, -0.22123663f, 0.01521403f, 0.00468586f, 0.26927745f, 
    0.18179692f, 0.03011257f, -0.30481553f, -0.37602815f, 0.06756569f, 0.06317425f, 0.19036433f, -0.08984707f, 
    0.05581242f, 0.19383204f, 0.14141053f, -0.69867408f, -0.59705186f, 0.14160606f, 0.00065303f, -0.11582068f, 
    -0.10605711f, 0.13726448f, -0.14013705f, 0.03643771f, 0.05419898f, 0.12945104f, 0.08127789f, 0.03520950f, 
    0.09440376f, -0.07305097f, 0.14790417f, 0.04131630f, -0.00578639f, 0.27032745f, -0.32018754f, 0.03852912f, 
    0.01650937f, 0.12407404f, -0.46220216f, 0.07000051f, -0.03672976f, -0.08512641f, -0.06506763f, -0.05957826f, 
    -0.21300492f, 0.08540988f, -0.01644074f, 0.11079107f, -0.00969677f, 0.08207658f, -0.10310876f, -0.36939552f, 
    -0.10112114f, 0.41063771f, 0.05845064f, -0.13744503f, -0.12356744f, -0.16240366f, 0.01120201f, 0.13183716f, 
    0.09468695f, 0.09050701f, -0.06494673f, -0.01247866f, 0.06925387f, 0.09334061f, 0.04996964f, 0.12430751f, 
    0.03108807f, 0.10911339f, 0.28384119f, 0.11839958f, -0.01960296f, 0.02092053f, 0.06605949f, 0.13120405f, 
    0.12529081f, -0.12908092f, -0.20681939f, -0.11428144f, 0.24088378f, 0.03353194f, -0.09420023f, 0.09739915f, 
    -0.09780683f, -0.05087860f, -0.04479675f, 0.01174706f, -0.24726561f, 0.12111638f, 0.03705894f, 0.08445958f, 
    0.14153601f, 0.16491415f, 0.02402592f, 0.09668936f, -0.00708655f, -0.62846309f, -0.32042554f, 0.08913667f, 
    0.04690836f, 0.03697748f, 0.15958427f, -0.05816158f, -0.09628761f, -0.12728161f, 0.11521088f, -0.36030778f, 
    0.06042948f, 0.16516569f, 0.09078241f, 0.03024143f, 0.25343347f, -0.27429876f, -0.34505576f, 0.18409145f, 
    -0.17090395f, -0.00089013f, -0.15268028f, -0.15078926f, -0.09389233f, 0.18237559f, -0.21704207f, 0.03149334f, 
    -0.06181268f, -0.14913596f, -0.16975963f, 0.00496476f, 0.00589297f, 0.18122558f, 0.02603273f, 0.19007850f, 
    -0.33392584f, 0.06215132f, -0.11068673f, 0.14223693f, -0.02984960f, -0.14329612f, -0.18742937f, 0.06306987f, 
    0.03960231f, -0.01029895f, 0.12376527f, 0.05952260f, 0.07538657f, 0.05934986f, -0.18299794f, -0.10038486f, 
    0.03042449f, -0.09594281f, -0.10680170f, 0.14948323f, 0.10847498f, 0.14242892f, -0.04306699f, -0.03233915f, 
    -0.02402516f, -0.07055940f, -0.12722486f, 0.01571096f, 0.00923609f, 0.04508222f, -0.10864137f, 0.12131512f, 
    0.08464799f, -0.04587582f, -0.05124142f, 0.09456594f, 0.02063099f, 0.09736528f, 0.03635541f, 0.10730591f, 
    -0.04123190f, 0.24422370f, -0.00985096f, 0.11085577f, -0.00243364f, 0.05290572f, 0.22139554f, -0.02789107f, 
    -0.07828989f, -0.13764080f, 0.24226490f, 0.05447948f, 0.17501056f, -0.24658631f, -0.11621854f, -0.11082832f, 
    -0.00434669f, -0.19223842f, -0.13492334f, 0.08124585f, -0.05616626f, 0.05862744f, 0.05348294f, 0.31698462f, 
    0.41250345f, -0.01048660f, -0.09150808f, -0.26791146f, 0.06459305f, -0.07424313f, 0.11080458f, -0.02075262f, 
    0.00254854f, 0.06051015f, -0.29258850f, -0.08412531f, -0.17317361f, 0.09097359f, -0.00603191f, 0.12359386f, 
    -0.22233476f, 0.12147263f, -0.02220881f, 0.32878256f, -0.11536708f, -0.06598072f, 0.08530726f, -0.17355102f, 
    0.00966636f, -0.12106618f, -0.12841067f, -0.34739637f, -0.45204666f, 0.10166755f, -0.00312557f, -0.10122176f, 
    -0.07771390f, -0.22411637f, -0.07939579f, 0.00350354f, -0.02500168f, 0.28670883f, 0.05047872f, -0.09234107f, 
    0.09456175f, 0.06368422f, 0.20643373f, -0.11866071f, -0.24254175f, 0.24984537f, 0.02868308f, -0.09327334f, 
    0.03478355f, 0.01737283f, 0.09367809f, 0.01431390f, 0.05067331f, -0.10335100f, -0.15828811f, 0.10090776f, 
    -0.04981956f, 0.11399782f, -0.00276804f, 0.03420465f, -0.12603900f, -0.17059727f, 0.23665726f, 0.10623378f, 
    0.28437623f, -0.11307249f, -0.03428746f, -0.12860431f, 0.01249586f, 0.07030144f, 0.13808066f, -0.07255811f, 
    -0.16417684f, -0.06057265f, 0.02549529f, -0.04189800f, -0.25943181f, 0.02293697f, -0.07306746f, -0.03980661f, 
    0.06855717f, -0.07961001f, 0.05284803f, -0.07631563f, 0.01334868f, 0.10171464f, 0.06307817f, 0.00657305f, 
    0.03186847f, 0.26546219f, -0.28946772f, 0.55057019f, -0.07546272f, -0.01249298f, 0.32552162f, -0.00693550f, 
    0.02149358f, 0.14238924f, 0.27415159f, -0.28267419f, 0.33105505f, 0.03812251f, -0.15865777f, 0.11783055f, 
    -0.00620221f, 0.14406972f, -0.17527086f, -0.14173776f, 0.05918960f, 0.27391925f, -0.09264701f, 0.01261973f, 
    0.06789945f, -0.10577636f, -0.05393616f, -0.02765339f, 0.13577446f, -0.05078746f, 0.18662019f, 0.04007944f, 
    0.04581913f, 0.13723625f, 0.04698044f, 0.21708661f, 0.06481949f, -0.16369359f, 0.12064558f, -0.43493116f, 
    0.04789527f, -0.00863984f, -0.07783469f, -0.02098198f, -0.19287314f, -0.19446974f, 0.03072343f, -0.00381210f, 
    -0.05168440f, 0.17200349f, 0.06387305f, -0.15008442f, 0.21391781f, -0.08846097f, 0.17266065f, -0.22208358f, 
    -0.26964301f, 0.01586501f, 0.01542706f, 0.05462897f, -0.06823675f, -0.01921127f, 0.13265149f, -0.00539715f, 
    -0.11221752f, 0.08358231f, -0.07082054f, 0.07571847f, 0.11099448f, -0.03439595f, 0.06335367f, 0.11591171f, 
    0.08305842f, -0.20514368f, -0.04112926f, 0.04118127f, 0.00950756f, 0.03999338f, 0.09388448f, -0.05288362f, 
    0.12938453f, 0.04135807f, -0.04275044f, -0.12634763f, 0.05872231f, 0.17516074f, 0.04311297f, -0.13917555f, 
    0.06484015f, 0.08669250f, -0.02462341f, 0.23868324f, 0.29402983f, 0.52304447f, -0.16086923f, 0.25855550f, 
    -0.04113507f, 0.03987557f, -0.01222015f, -0.02509868f, 0.25352120f, 0.42909718f, 0.12486214f, 0.09849836f, 
    0.06550611f, -0.20052035f, 0.12482002f, -0.05350804f, 0.07128324f, -0.19444647f, 0.12851651f, 0.16365086f, 
    -0.09146336f, 0.23723741f, 0.05859404f, 0.26150143f, -0.07920462f, 0.05204746f, -0.19755439f, -0.00445010f, 
    -0.15106209f, -0.22769438f, 0.07160878f, -0.01846480f, 0.09763779f, -0.00999106f, -0.03197491f, 0.13233849f, 
    0.25921249f, 0.29869723f, -0.19152127f, 0.06126076f, -0.01199215f, 0.02553237f, 0.04898177f, -0.11706074f, 
    -0.21307272f, -0.14582111f, 0.05143782f, 0.07691129f, 0.09994112f, -0.01692075f, -0.07517515f, 0.00890003f, 
    -0.05938093f, -0.00438679f, -0.23505624f, 0.09415385f, 0.10172148f, -0.01922527f, 0.00266506f, -0.01272367f, 
    -0.09534261f, -0.12337331f, 0.12529220f, -0.06343878f, -0.22217745f, -0.15714796f, 0.03844151f, -0.01470129f, 
    0.20591281f, -0.03500393f, -0.14544983f, -0.06076038f, -0.14379311f, -0.02457675f, 0.14963141f, -0.10470899f, 
    -0.01035928f, -0.20623483f, 0.17861485f, -0.00209271f, 0.18616949f, -0.05535796f, 0.01038844f, -0.07008642f, 
    -0.17398657f, -0.06257701f, -0.03549890f, -0.04893780f, 0.04200639f, 0.39071247f, -0.13459939f, 0.05220786f, 
    0.11621145f, -0.13970743f, 0.07072326f, 0.12187397f, 0.02123486f, 0.08183909f, -0.02486245f, -0.03037983f, 
    -0.03016398f, -0.08080695f, -0.06128388f, -0.08103460f, -0.15478417f, 0.06401724f, -0.16132675f, 0.06477877f, 
    -0.35280693f, -0.04827435f, -0.14209995f, -0.04390927f, 0.14877197f, 0.00763871f, -0.03709427f, 0.23506805f, 
    -0.09040060f, -0.11123753f, 0.02592305f, -0.00920485f, -0.11010149f, 0.00056130f, -0.02519362f, -0.09702233f, 
    0.17032531f, 0.21184447f, 0.19885878f, -0.31333905f, -0.26089570f, 0.01452399f, 0.09474738f, 0.02927166f, 
    -0.05178187f, -0.00773571f, -0.19364622f, -0.03912161f, 0.13709231f, -0.07861974f, -0.16290557f, -0.19116324f, 
    -0.02039964f, -0.09553302f, -0.15665057f, 0.20597851f, 0.01154078f, 0.22575811f, 0.11810785f, 0.06294408f, 
    0.15986332f, -0.05779375f, -0.00580342f, 0.07452224f, 0.17140329f, 0.14578104f, 0.12794523f, 0.01937531f, 
    0.05238699f, -0.11674548f, -0.00471250f, 0.04728330f, 0.04296195f, 0.06669417f, 0.03338405f, 0.10585368f, 
    0.06530599f, -0.09522265f, -0.12128244f, -0.02900360f, -0.04019444f, 0.00523794f, 0.04462658f, 0.12773338f, 
    0.15772744f, -0.00612143f, 0.33547890f, 0.09775391f, 0.05893662f, 0.04642867f, 0.18956329f, -0.01229101f, 
    0.14038797f, 0.20461906f, 0.00309474f, 0.17834552f, -0.11623529f, 0.06959054f, -0.09368139f, 0.01827522f, 
    -0.08490484f, -0.11377426f, -0.02888033f, 0.14931166f, -0.03085161f, 0.02375854f, -0.06248471f, -0.25241250f, 
    0.06797300f, 0.21501665f, 0.07715637f, -0.16411169f, -0.04584878f, -0.03158822f, 0.07787149f, 0.10229089f, 
    -0.14988883f, 0.19628000f, 0.07224259f, -0.00291521f, 0.22545199f, -0.11892705f, 0.13006084f, 0.19292778f, 
    -0.00370059f, -0.12086350f, 0.14292032f, 0.05018901f, 0.12300399f, 0.22782126f, -0.01423872f, 0.21254364f, 
    0.07423942f, 0.12789522f, 0.17657517f, -0.01672271f, 0.07924115f, -0.03841898f, 0.05996977f, 0.06106400f, 
    -0.08501881f, -0.05486374f, -0.05838168f, -0.03881662f, 0.23606351f, -0.19733694f, -0.12820907f, 0.18315558f, 
    0.05739372f, -0.26112205f, -0.07731782f, -0.06359257f, 0.07099222f, -0.02426502f, 0.08919767f, -0.08406289f, 
    0.05887492f, -0.01719344f, 0.22749737f, 0.17034526f, 0.13740191f, 0.07697339f, 0.15871273f, -0.06298479f, 
    -0.11872055f, 0.09173741f, -0.16716518f, -0.10636064f, -0.15966679f, -0.10944565f, -0.13616209f, -0.25650051f, 
    0.11306315f, 0.05518207f, 0.01926352f, -0.06890084f, -0.11242910f, 0.13966638f, 0.03982143f, 0.03878802f, 
    0.02787981f, -0.19637041f, 0.30033210f, 0.01377437f, 0.10334768f, 0.07715855f, 0.08169372f, -0.02883641f, 
    0.24706672f, 0.14135459f, -0.01030006f, -0.01029598f, 0.08852865f, -0.03735139f, 0.17256585f, 0.10577573f, 
    -0.05088803f, 0.28347078f, 0.15050077f, 0.15593328f, 0.18628052f, -0.02009246f, -0.02407060f, 0.06133252f, 
    0.02113261f, -0.04110081f, 0.05112099f, 0.12926544f, 0.11402343f, -0.34193504f, 0.09784864f, -0.08632939f, 
    0.21280827f, 0.21030557f, -0.01004403f, 0.13895848f, 0.10250407f, 0.15987791f, -0.06656408f, -0.46281150f, 
    -0.13838504f, -0.04678106f, -0.17029911f, 0.04423600f, 0.05024349f, -0.12065126f, -0.14282507f, 0.03986579f, 
    0.17551355f, -0.04201737f, -0.03115633f, -0.16474020f, 0.01764310f, -0.14441410f, -0.05077434f, 0.08698113f, 
    -0.10573065f, -0.01210666f, 0.08822377f, -0.19034810f, 0.09487326f, 0.02358573f, -0.09598409f, -0.02443182f, 
    -0.13272418f, 0.05320477f, -0.07801066f, -0.08770787f, -0.10963341f, 0.10234413f, 0.08244304f, -0.15612838f, 
    -0.06030683f, 0.23582719f, 0.15512030f, 0.09220084f, 0.02861200f, -0.00233151f, -0.01299187f, 0.09140074f, 
    -0.05422340f, -0.02254653f, -0.16705731f, 0.21628013f, -0.06141604f, -0.00882488f, -0.12677912f, 0.18008181f, 
    -0.07594780f, 0.20981717f, 0.39672476f, 0.26675862f, 0.04428815f, -0.03540884f, 0.07500125f, 0.09079642f, 
    -0.07174079f, 0.11608925f, -0.06128021f, -0.02469751f, 0.09288958f, -0.05549284f, -0.09452381f, 0.01350362f, 
    0.15117976f, 0.25185734f, 0.03812853f, -0.19901973f, 0.05897555f, -0.04919158f, -0.18546824f, -0.39803049f, 
    0.06582151f, 0.10705520f, 0.24601527f, -0.12229311f, 0.10465071f, 0.03689249f, -0.35937041f, -0.08650413f, 
    -0.33528632f, -0.05085599f, 0.07394174f, 0.07981311f, -0.06342736f, 0.01516962f, 0.07674051f, 0.28178921f, 
    -0.11837841f, -0.25450137f, -0.05457782f, -0.14915167f, 0.14318560f, -0.06171056f, 0.09018432f, -0.20620668f, 
    -0.25129011f, -0.45616615f, -0.20038801f, 0.07509510f, 0.07244446f, -0.13610019f, 0.03776334f, 0.01304216f, 
    0.05029915f, 0.24179520f, 0.34586746f, -0.12981245f, 0.06826393f, 0.07102378f, -0.10217404f, 0.20540772f, 
    0.26647034f, 0.04979111f, -0.32340416f, -0.30250534f, -0.46020645f, 0.00161234f, -0.01878139f, 0.01882091f, 
    -0.04298868f, -0.05811346f, -0.06229464f, -0.26085186f, -0.38473764f, 0.12020885f, -0.05344168f, 0.31193605f, 
    0.12620193f, 0.03716179f, -0.00003479f, 0.21257310f, 0.03419555f, -0.02856408f, 0.08667821f, 0.02051408f, 
    -0.09550998f, 0.06483518f, 0.16696087f, -0.00921356f, 0.12375758f, 0.02610764f, -0.10787228f, -0.36004752f, 
    0.07531150f, -0.07175912f, -0.02591741f, 0.21811630f, 0.16969913f, 0.04812365f, 0.10460111f, 0.10987175f, 
    0.05159391f, 0.06467921f, 0.13943705f, -0.26146919f, 0.13894102f, -0.12592810f, 0.16041867f, -0.32975197f, 
    0.14069967f, -0.46713251f, 0.01021349f, -0.09449214f, -0.11257704f, -0.01560901f, -0.08676531f, 0.07126734f, 
    0.20874567f, -0.08296066f, -0.00682673f, -0.01844488f, -0.03503754f, 0.09741963f, 0.11272422f, -0.04670473f, 
    -0.14549108f, 0.02572644f, 0.10622188f, -0.74321508f, 0.01549081f, 0.09138376f, 0.13710754f, 0.13542356f, 
    -0.34125924f, 0.01588133f, -0.09889291f, 0.03380146f, 0.43845737f, 0.06642792f, 0.18198723f, 0.11192405f, 
    -0.18842982f, -0.06140447f, 0.25590742f, -0.83923680f, -0.02052248f, -0.09018245f, 0.10870574f, 0.15720598f, 
    0.00810986f, 0.05395246f, 0.00190355f, 0.12058705f, 0.02959947f, -0.04769789f, 0.01010275f, 0.11321451f, 
    -0.01351223f, 0.21663435f, -0.03231565f, -0.13071772f, 0.04346886f, -0.33847004f, -0.24139977f, -0.16078381f, 
    -0.15415715f, -0.12103783f, -0.22790009f, -0.06062060f, -0.13526873f, -0.08534864f, -0.66503376f, 0.05028241f, 
    -0.10521835f, 0.06659340f, -0.18980353f, 0.05840066f, 0.17425686f, -0.16279876f, 0.06924161f, -0.20014265f, 
    -0.09696762f, 0.13314600f, -0.19392893f, 0.07709609f, -0.02110913f, -0.01675072f, -0.05326050f, -0.03651697f, 
    -0.01916977f, -0.04104704f, 0.04834586f, 0.03776045f, 0.08284993f, 0.03368296f, 0.02325177f, 0.09792360f, 
    -0.09463706f, -0.27487925f, 0.27758297f, -0.03671959f, -0.00311242f, -0.08817224f, 0.22750039f, 0.07761907f, 
    0.10473055f, -0.08341572f, -0.69011730f, 0.05910186f, 0.14219238f, 0.16010423f, -0.05156172f, -0.00001110f, 
    -0.03080580f, 0.00802770f, 0.01391445f, 0.27103505f, -0.20090239f, -0.14795043f, 0.05740833f, -0.04517501f, 
    0.21234432f, 0.21203493f, -0.07199369f, 0.01371283f, 0.21518303f, -0.45853382f, -0.01636544f, -0.08591752f, 
    0.02142962f, -0.34502074f, -0.05730225f, -0.20299201f, -0.02735312f, 0.01230966f, -0.20456977f, -0.51107210f, 
    -0.12699877f, 0.06285863f, 0.13727596f, -0.01817307f, -0.12985876f, -0.12061915f, -0.49960342f, -0.01061871f, 
    -0.10776886f, -0.13184616f, -0.04308158f, 0.02218319f, -0.06999803f, -0.03337468f, 0.10134406f, 0.28357458f, 
    0.10560872f, -0.18628648f, 0.02655205f, -0.01812888f, 0.06619845f, -0.01711327f, -0.02624687f, 0.02397177f, 
    0.26807833f, 0.18953922f, 0.00056581f, 0.06416899f, -0.22646333f, -0.06558160f, -0.00537217f, 0.15223683f, 
    -0.05947207f, 0.15525489f, 0.18970674f, 0.25630361f, -0.10128378f, -0.11751823f, -0.24290738f, -0.04420151f, 
    0.04589747f, -0.03565621f, -0.08769439f, 0.12020742f, 0.21214488f, 0.03001017f, -0.11394747f, -0.07055080f, 
    0.11037146f, -0.06022678f, 0.16095115f, 0.09237440f, -0.04165496f, -0.02998920f, -0.02993607f, -0.00971117f, 
    -0.29697591f, 0.10567550f, 0.10073667f, 0.03125208f, 0.40205157f, 0.05846218f, -0.04641190f, -0.30981886f, 
    0.07489485f, 0.08714841f, 0.08137754f, -0.07914484f, -0.05722520f, 0.12023761f, 0.08259889f, -0.03212382f, 
    -0.11242143f, 0.24839704f, 0.13932309f, -0.06184155f, -0.08612145f, 0.05700264f, 0.42613527f, -0.02464101f, 
    -0.09591783f, 0.07502085f, 0.07240429f, -0.01497017f, 0.05224524f, 0.05176584f, 0.08196535f, -0.02894551f, 
    0.25807288f, 0.19419299f, 0.07103217f, 0.02330164f, -0.00674300f, 0.13431440f, 0.08658423f, 0.00589053f, 
    0.13506132f, 0.01208311f, -0.22207303f, 0.15748359f, -0.04925868f, 0.14178422f, -0.09761311f, 0.06811436f, 
    0.04809157f, 0.02926936f, -0.02230013f, 0.21836662f, 0.02346861f, -0.00821937f, -0.03948167f, 0.01846042f, 
    -0.06304523f, 0.09985100f, 0.20220311f, -0.15393916f, -0.35499358f, 0.00728707f, 0.14919198f, -0.13400616f, 
    -0.10578690f, -0.08565085f, 0.00253857f, 0.02301209f, -0.11508612f, -0.21070170f, 0.05110476f, 0.00285227f, 
    -0.09120894f, 0.01270307f, -0.08084907f, -0.10408099f, 0.21980584f, -0.01655869f, 0.03425959f, 0.09421621f, 
    0.04922570f, -0.11539143f, -0.02258244f, -0.06767225f, 0.04700172f, 0.31860352f, -0.07535337f, -0.30995744f, 
    -0.06623400f, 0.08033428f, -0.12331771f, -0.02960461f, 0.08169401f, -0.03269736f, -0.06555797f, -0.27076128f, 
    0.04128965f, -0.18357687f, -0.04330728f, 0.04117434f, 0.16865741f, -0.12096298f, 0.10911192f, 0.34419450f, 
    0.14031890f, -0.00273091f, -0.08686768f, -0.01858049f, -0.11690544f, -0.03284110f, 0.03461531f, 0.05598054f, 
    0.14425580f, 0.12485820f, 0.19171460f, -0.21792929f, -0.21988894f, -0.28299126f, 0.21760267f, 0.02158572f, 
    0.00528383f, -0.13195388f, -0.00673092f, 0.07527351f, 0.00870957f, -0.09262568f, -0.11454137f, 0.05574800f, 
    0.00191206f, -0.00760972f, -0.20383872f, -0.09667736f, 0.00293730f, -0.08232330f, -0.16522394f, -0.02141000f, 
    -0.06713191f, -0.17229518f, -0.12305701f, 0.11266530f, 0.10418159f, -0.11504690f, -0.01363400f, -0.02064976f, 
    -0.03733888f, -0.00840815f, 0.06468701f, -0.05255485f, 0.09412494f, 0.15210369f, 0.00030365f, -0.14567924f, 
    0.02108073f, 0.06765210f, 0.04543094f, 0.11951409f, -0.12689056f, 0.40977547f, -0.08675362f, -0.22470060f, 
    0.03163783f, 0.03889694f, -0.29022232f, 0.00992147f, 0.04443831f, -0.05201326f, -0.00013894f, 0.10677900f, 
    -0.10916811f, 0.00879572f, -0.07504652f, 0.02640255f, -0.09488962f, 0.13445289f, 0.08985790f, 0.41464686f, 
    0.16845012f, 0.02754957f, 0.11269675f, -0.12589858f, -0.06944168f, 0.13589934f, -0.03217847f, 0.00482793f, 
    -0.14521755f, 0.04060814f, 0.15792485f, 0.01361600f, 0.00981280f, -0.12451040f, 0.00736775f, -0.01118460f, 
    -0.04465681f, -0.08931746f, -0.14171301f, -0.15874624f, 0.06730121f, -0.12383919f, 0.11287779f, 0.11576468f, 
    0.03577734f, -0.03820279f, 0.04090977f, 0.07217572f, 0.08421288f, 0.05871141f, -0.05246324f, 0.04504196f, 
    0.06861125f, 0.16410895f, -0.01642012f, -0.15268181f, -0.15931608f, 0.08284362f, 0.00858345f, 0.08352169f, 
    -0.01801561f, 0.25021872f, -0.11375107f, -0.10479493f, -0.13951902f, -0.01036615f, 0.17888202f, -0.01717515f, 
    -0.01710327f, -0.00719585f, 0.00411537f, 0.05972991f, 0.01552814f, -0.18088700f, 0.07806709f, 0.07184936f, 
    0.23339275f, 0.09750384f, -0.19807176f, -0.02296213f, 0.00410549f, -0.15012392f, 0.32049188f, 0.14337528f, 
    -0.08328100f, 0.00053569f, -0.04295944f, -0.10924881f, 0.06133288f, -0.05765174f, -0.04374561f, 0.07643792f, 
    0.20741244f, 0.22565597f, -0.01055915f, -0.10824326f, -0.18944640f, -0.09518313f, 0.01438556f, -0.01816927f, 
    0.25009641f, 0.41053200f, 0.13250703f, 0.04966551f, -0.13252470f, 0.19968292f, -0.00952788f, 0.07609551f, 
    -0.20630343f, 0.01699863f, 0.19915719f, 0.08151881f, -0.10852483f, -0.06963526f, -0.03105860f, 0.04253180f, 
    0.00118397f, -0.03157326f, 0.06267916f, 0.26158515f, 0.13282312f, -0.11353770f, -0.12009960f, 0.16658437f, 
    -0.08499043f, 0.16626601f, 0.13829055f, 0.00920891f, 0.04867610f, 0.07883923f, 0.02491458f, 0.00568663f, 
    0.02390860f, -0.10414153f, -0.08632855f, -0.19986695f, 0.08492861f, 0.27037707f, 0.33016217f, -0.04729764f, 
    0.02660480f, 0.06303723f, 0.08475050f, -0.12489747f, -0.06838883f, 0.32500103f, 0.27391517f, 0.04954908f, 
    -0.01854792f, 0.18767968f, 0.25603646f, -0.14535041f, -0.16658758f, -0.18555593f, -0.03719991f, -0.11888324f, 
    -0.37083521f, 0.04351456f, 0.14248435f, -0.00789179f, 0.00315461f, -0.00609348f, 0.13083979f, -0.08557715f, 
    0.23375534f, 0.15883265f, -0.02672240f, -0.04347804f, -0.16924077f, -0.16116348f, -0.17663126f, -0.21274196f, 
    0.04545764f, -0.29172966f, -0.40130866f, 0.05482875f, 0.13977547f, -0.12003246f, 0.01176559f, -0.08404771f, 
    -0.18147328f, 0.08393040f, 0.01946213f, 0.15940300f, -0.09430813f, 0.03880401f, 0.10835766f, -0.01059671f, 
    0.04466667f, -0.00620882f, 0.14610486f, -0.12519886f, -0.28096119f, -0.05206036f, -0.15226854f, -0.15691194f, 
    -0.03948126f, 0.08365303f, 0.14204659f, -0.05526441f, -0.18133005f, -0.07236436f, 0.00223467f, -0.01889702f, 
    0.07310005f, 0.05625644f, -0.14538421f, -0.05951152f, -0.11589286f, 0.33765617f, 0.14283627f, 0.09972876f, 
    0.13198841f, -0.02468678f, 0.07632910f, 0.08808382f, -0.07653949f, 0.09947437f, -0.12507081f, 0.11165018f, 
    0.05803840f, 0.13904998f, -0.10261221f, -0.00478793f, -0.05241158f, 0.02277238f, 0.02759272f, -0.19443361f, 
    0.15762812f, 0.01044920f, 0.01732003f, 0.16533872f, -0.07011154f, -0.06234843f, 0.01861318f, 0.24902865f, 
    0.15160206f, -0.16857690f, -0.13420703f, 0.14391878f, -0.06179997f, 0.15290388f, -0.06673533f, -0.09049251f, 
    -0.24421112f, 0.21773383f, -0.05491675f, -0.03215305f, -0.07285643f, -0.05241127f, -0.03150389f, 0.06269608f, 
    -0.12441749f, 0.12040051f, -0.55804551f, 0.12896194f, -0.14601173f, 0.01287384f, 0.15767454f, 0.11193312f, 
    -0.01516574f, 0.08999331f, 0.13188750f, 0.01817759f, 0.47111252f, 0.01127216f, 0.07677765f, -0.02694054f, 
    -0.06720742f, -0.10470743f, -0.03410696f, -0.49773964f, -0.13811532f, 0.09990792f, 0.00244356f, 0.00658477f, 
    0.13536812f, 0.01605845f, -0.12153207f, -0.05336394f, 0.09056954f, 0.23279016f, 0.15178275f, -0.10073505f, 
    0.00635548f, 0.05244449f, 0.01695492f, -0.16500977f, -0.15543085f, 0.17007987f, -0.02526814f, -0.27280331f, 
    0.08988216f, 0.13505818f, -0.31379837f, 0.06546424f, -0.04566951f, -0.11005319f, -0.10096747f, 0.18118526f, 
    -0.01232948f, -0.16771881f, 0.07125387f, 0.05672659f, -0.05191653f, -0.07891769f, 0.09026972f, 0.00197727f, 
    -0.05916973f, -0.09648025f, 0.18446895f, 0.05842057f, 0.11378985f, 0.03653881f, -0.08296930f, 0.08565804f, 
    0.29683143f, 0.11958693f, 0.08536335f, -0.00863676f, -0.05021413f, -0.08526470f, -0.15835270f, -0.18289946f, 
    -0.05497590f, 0.16205153f, 0.05197947f, -0.19486319f, 0.10405261f, 0.02257843f, 0.19722840f, -0.16816828f, 
    0.10723642f, -0.14403722f, -0.32020351f, -0.02154547f, 0.28312740f, 0.06877231f, -0.07145329f, 0.04131681f, 
    0.04350324f, -0.05599356f, 0.10953167f, -0.23874639f, 0.38406107f, 0.06855463f, -0.03007301f, 0.02333780f, 
    0.22185697f, 0.18389145f, 0.09173080f, 0.06805635f, -0.38652939f, -0.06741424f, 0.08135346f, -0.04115712f, 
    0.12129218f, 0.01708054f, 0.08638570f, 0.04808662f, 0.04028780f, 0.20802504f, 0.31626636f, -0.10215951f, 
    -0.29095116f, 0.09354922f, 0.41027021f, 0.03537967f, 0.33259937f, -0.02881047f, -0.24492662f, 0.17192154f, 
    -0.26348734f, 0.15054780f, 0.14410774f, -0.05273325f, -0.00049436f, 0.05547711f, -0.29241347f, 0.17247191f, 
    0.18874875f, 0.00021754f, -0.12592126f, -0.05749996f, 0.00230525f, -0.02453757f, -0.15731290f, -0.26460516f, 
    0.04703060f, 0.02103409f, -0.04998711f, 0.03405675f, -0.04012517f, -0.04565473f, -0.09144653f, -0.00603237f, 
    -0.02220928f, -0.02860883f, -0.00207993f, -0.12611826f, 0.05948232f, 0.07467716f, 0.10029265f, -0.03055521f, 
    -0.15019009f, 0.02005938f, -0.03906781f, -0.02868868f, -0.16832413f, -0.09614056f, 0.04874301f, -0.24748483f, 
    -0.04269494f, -0.06765283f, -0.17603299f, -0.00852168f, -0.07849452f, 0.10761506f, 0.10525516f, -0.03047644f, 
    -0.02307526f, -0.07995619f, 0.10118124f, -0.01859070f, -0.01189074f, 0.02771035f, -0.03014777f, 0.00491827f, 
    0.00301005f, -0.08050151f, -0.12777710f, 0.08653846f, 0.04126629f, -0.07346817f, 0.00546725f, 0.03960475f, 
    -0.20368178f, -0.32908246f, -0.00465435f, 0.09066287f, 0.18107492f, -0.00020885f, -0.18618272f, -0.15145600f, 
    0.06337695f, -0.05311057f, -0.11531274f, -0.08860128f, 0.06605706f, 0.06245527f, -0.06966437f, 0.00939137f, 
    -0.26552474f, -0.05285379f, -0.16110089f, 0.01461462f, 0.16508436f, -0.09148096f, 0.06827302f, 0.09676097f, 
    0.10600358f, -0.05147101f, 0.03736195f, -0.01202238f, 0.06814640f, 0.19319139f, 0.10714140f, -0.06366114f, 
    -0.00267398f, 0.12710607f, 0.04130166f, 0.04489828f, 0.04962840f, -0.12559186f, 0.14385818f, -0.20141344f, 
    -0.11590993f, 0.06592433f, -0.33274224f, 0.05081889f, 0.28702083f, 0.09229908f, -0.16748601f, -0.13823427f, 
    -0.26346812f, -0.23034097f, -0.34498757f, 0.10070802f, 0.10301176f, 0.28038514f, 0.07658392f, 0.00281875f, 
    0.12700038f, -0.00953124f, 0.02888577f, 0.06096180f, -0.13671952f, 0.02997533f, 0.22342943f, -0.09114034f, 
    0.10304092f, 0.00233626f, 0.03486098f, 0.01751942f, -0.01309105f, -0.02813329f, 0.08725028f, 0.25974676f, 
    0.04289718f, -0.09340712f, -0.10151892f, 0.02596262f, -0.10159145f, -0.01709168f, 0.03288737f, 0.11800786f, 
    0.09421673f, 0.13770485f, 0.00332672f, 0.12908876f, 0.10746348f, 0.12420455f, 0.08758646f, -0.24887280f, 
    0.21485363f, -0.19158792f, 0.02365772f, -0.02701572f, 0.00499415f, 0.20621568f, 0.00408390f, -0.03413491f, 
    0.13709469f, -0.10999665f, -0.10006270f, 0.08263786f, 0.00443238f, 0.04061092f, 0.16873445f, -0.21186201f, 
    0.18367729f, 0.32145742f, -0.10632294f, -0.23026642f, 0.10497035f, -0.03837804f, 0.16804796f, -0.04076689f, 
    -0.09941006f, 0.01738495f, 0.02332620f, -0.18688641f, 0.05723017f, 0.05867589f, -0.01834168f, 0.06916720f, 
    -0.10114801f, -0.07265878f, 0.00647147f, -0.06269798f, 0.05394715f, -0.03802071f, 0.16528837f, 0.08866786f, 
    0.06726293f, 0.11141759f, 0.12188037f, 0.08567695f, 0.08193402f, -0.05098129f, 0.08373541f, 0.00823272f, 
    0.00933493f, 0.17228131f, -0.03289148f, 0.08660501f, 0.10205748f, -0.14775571f, 0.13385107f, 0.23096262f, 
    0.09014401f, -0.16283070f, -0.15248592f, -0.09198513f, -0.04225063f, -0.03667317f, -0.21071841f, 0.16886662f, 
    -0.03829065f, 0.05402122f, 0.18682456f, -0.08141821f, 0.16864787f, 0.07673981f, -0.04788895f, -0.35045323f, 
    -0.15299255f, -0.15885247f, -0.00335734f, -0.19235833f, -0.07163163f, 0.10342617f, 0.02727967f, -0.09582056f, 
    -0.01882537f, -0.07717547f, 0.24306211f, -0.00473558f, 0.00274210f, 0.01235825f, -0.14193767f, 0.14754190f, 
    0.09908200f, 0.07556016f, 0.02114900f, 0.17643043f, -0.04474299f, 0.08162827f, -0.14250232f, 0.10833380f, 
    0.30360582f, -0.10307226f, -0.26871562f, 0.21469444f, -0.02040209f, -0.03089950f, -0.10406207f, -0.03696105f, 
    0.23284990f, 0.16769254f, 0.02620271f, -0.14011571f, 0.09530419f, -0.20063153f, 0.15672950f, -0.03004547f, 
    0.14775835f, 0.07905088f, -0.02351280f, -0.01236634f, -0.20219554f, -0.15865627f, 0.06526276f, 0.01094063f, 
    0.04178659f, 0.01822791f, 0.00261804f, 0.02610733f, 0.05836247f, 0.01415721f, -0.09345246f, -0.10556358f, 
    -0.13335554f, 0.14052056f, -0.03272802f, -0.06671975f, -0.18672019f, -0.04046936f, -0.24203461f, 0.12004999f, 
    -0.00232452f, -0.02611884f, -0.11510124f, 0.02696234f, 0.08805954f, -0.00117709f, 0.04520172f, -0.08499051f, 
    0.02523055f, -0.05288206f, -0.02050773f, 0.11361616f, -0.00458640f, -0.10219763f, -0.06826201f, -0.04271601f, 
    -0.11923501f, -0.10674543f, 0.04945363f, -0.11559662f, 0.19670492f, 0.11199075f, 0.05942751f, -0.01012589f, 
    -0.01306319f, -0.06824221f, 0.12852605f, 0.09622126f, -0.08539414f, 0.06606173f, 0.07148086f, 0.00132864f, 
    -0.00238246f, 0.13767897f, -0.00987634f, 0.17222691f, 0.05195674f, 0.01941072f, 0.00617396f, 0.00907916f, 
    -0.09725045f, 0.10194747f, 0.30588472f, -0.19621463f, 0.05318190f, -0.00273027f, -0.10336562f, 0.01977400f, 
    0.01663255f, -0.01799652f, -0.09143806f, 0.03256282f, -0.25909671f, -0.34110028f, -0.11727456f, -0.07454067f, 
    -0.01304955f, -0.08542760f, 0.15710120f, -0.00844571f, -0.16867588f, -0.20554440f, -0.30189827f, -0.24808224f, 
    -0.13647927f, 0.06619202f, -0.09678295f, 0.08811715f, -0.16204707f, -0.27735925f, 0.15271816f, 0.06021110f, 
    -0.26923811f, -0.32025224f, -0.17251065f, -0.00035762f, 0.02175172f, 0.12397636f, 0.09155551f, 0.35436153f, 
    -0.15452914f, -0.06290836f, -0.28742456f, -0.25562108f, -0.15661179f, -0.12307897f, 0.11365313f, -0.02526160f, 
    -0.46821505f, -0.28974733f, -0.36869624f, -0.10356987f, -0.14370082f, -0.17008831f, 0.05592755f, 0.06511966f, 
    -0.00197207f, -0.09874767f, 0.10555072f, 0.06856624f, -0.02068782f, -0.01616768f, 0.12049012f, -0.01015827f, 
    -0.03508003f, 0.24950443f, -0.11383163f, -0.26372981f, -0.12009359f, -0.04319748f, 0.14253776f, 0.17180365f, 
    -0.02354886f, 0.02395220f, 0.25002080f, -0.05244721f, -0.22781378f, -0.17079176f, 0.07672823f, 0.18555626f, 
    0.02734189f, 0.13746734f, 0.01212593f, 0.16251189f, 0.15734826f, -0.25212204f, 0.07450917f, 0.03103215f, 
    0.00734513f, -0.08939224f, 0.10785478f, 0.00223041f, 0.16718374f, 0.06618406f, -0.38115305f, 0.07581818f, 
    0.06105588f, -0.06049065f, 0.15990247f, -0.04870703f, 0.13079026f, 0.01702269f, 0.24420325f, 0.05699787f, 
    0.20899884f, 0.05591083f, 0.13065763f, 0.13548835f, 0.14309824f, 0.00285259f, 0.07648209f, -0.08050921f, 
    -0.18590769f, -0.06657538f, 0.14400157f, 0.09730776f, -0.10360040f, -0.05822797f, 0.01110715f, 0.00737213f, 
    -0.14943168f, -0.11382863f, -0.11429270f, -0.39547893f, -0.00322371f, 0.16381396f, 0.08184271f, -0.01429018f, 
    -0.09307621f, 0.41233686f, -0.04071531f, -0.72573805f, -0.09292206f, -0.08258400f, -0.08099883f, 0.01017807f, 
    -0.03635046f, -0.12302758f, -0.10676076f, -0.20657428f, -0.10923807f, 0.02662760f, 0.10868800f, -0.11928180f, 
    0.19720130f, -0.06468291f, 0.14248143f, 0.06403122f, -0.54839337f, -0.11560655f, 0.03030110f, -0.06231331f, 
    -0.03878544f, 0.18313126f, 0.05150690f, 0.04342354f, -0.02196362f, -0.14230189f, 0.02839642f, -0.07629737f, 
    -0.01655128f, -0.07928998f, -0.02748673f, -0.02461832f, -0.01259231f, -0.54484892f, -0.39692140f, 0.15868005f, 
    0.12550899f, 0.02672433f, 0.11093378f, -0.14740805f, 0.03544076f, 0.04284138f, 0.29434204f, -0.26356781f, 
    -0.16654551f, 0.06039148f, 0.01039036f, 0.03395372f, 0.13683808f, 0.10379370f, -0.00557972f, 0.32153603f, 
    0.23989202f, 0.05129656f, 0.01242203f, -0.03408616f, -0.02226440f, -0.15457363f, 0.03028067f, -0.01296836f, 
    0.15967989f, 0.03669075f, -0.07583411f, -0.11704870f, 0.08443885f, 0.13114877f, 0.17729948f, 0.09157923f, 
    -0.03513097f, 0.03954824f, -0.05088153f, 0.07823657f, -0.04474720f, 0.19175789f, 0.03157423f, 0.12470478f, 
    -0.04964462f, -0.02862906f, 0.10162173f, -0.44479665f, -0.15885562f, -0.06222019f, 0.04904694f, -0.04256079f, 
    0.06462367f, -0.02880878f, -0.15600824f, 0.54830647f, -0.31875122f, -0.13837035f, 0.09389047f, 0.00482113f, 
    0.09788856f, 0.11650828f, -0.01986131f, -0.06548459f, 0.69956374f, -0.09576256f, 0.05400228f, -0.07535479f, 
    0.07426900f, 0.05475164f, 0.05074393f, 0.03003155f, -0.01899297f, 0.56973737f, -0.02500740f, -0.14351352f, 
    -0.09614597f, 0.03286700f, 0.00551517f, 0.08116348f, 0.25420776f, -0.00777269f, -0.05624525f, 0.01639841f, 
    -0.26822534f, -0.04593540f, 0.01262863f, -0.09519728f, -0.11764585f, -0.00615443f, -0.01437685f, 0.15356241f, 
    0.20894772f, 0.02014625f, -0.04200900f, -0.04288282f, 0.03124048f, -0.02236534f, 0.00200408f, 0.06017562f, 
    0.12509799f, 0.28139836f, 0.10430057f, -0.30980557f, 0.00598796f, -0.29041633f, -0.03124407f, -0.00083779f, 
    -0.05951169f, 0.08042013f, 0.04440608f, 0.10030471f, -0.30625197f, -0.20070544f, -0.08800675f, 0.09776235f, 
    0.08955593f, 0.01943582f, -0.03694882f, 0.02551880f, -0.16421074f, -0.05951092f, -0.06043842f, 0.02684771f, 
    0.11392961f, -0.01121519f, -0.10949183f, 0.02513784f, 0.08243202f, 0.05339334f, -0.14054869f, -0.19653071f, 
    -0.30757788f, 0.11884727f, 0.06736612f, 0.00499381f, 0.12719980f, 0.03745089f, 0.10434743f, -0.14067501f, 
    0.07440064f, 0.00081190f, 0.01679804f, 0.17799346f, -0.10136148f, 0.25287250f, 0.24717444f, -0.19972499f, 
    -0.14078210f, 0.15875521f, -0.06187122f, 0.05942158f, 0.16090401f, 0.17468289f, 0.24661142f, -0.18555258f, 
    0.19776917f, 0.09476110f, 0.01933828f, 0.02206357f, 0.01715300f, -0.09684409f, 0.07301547f, -0.12283040f, 
    0.27907813f, -0.08587159f, 0.26872879f, -0.02663214f, -0.04662955f, -0.14227797f, 0.28613353f, -0.18470627f, 
    -0.07094308f, 0.19647837f, 0.16759920f, 0.15235326f, -0.05887772f, 0.03993500f, 0.01066722f, 0.10043966f, 
    -0.02632716f, 0.01303999f, -0.08449616f, -0.11725724f, 0.15847927f, -0.02873359f, 0.27718028f, -0.04565081f, 
    0.09777307f, -0.04244956f, -0.02593304f, 0.03883354f, 0.13053618f, -0.07253727f, 0.08393706f, -0.17091858f, 
    0.01541325f, -0.09142267f, -0.05954000f, -0.13977402f, -0.05635640f, -0.01283762f, -0.08148350f, -0.05401286f, 
    -0.04185638f, -0.14733231f, -0.03494679f, 0.04735381f, -0.01956882f, 0.07976493f, -0.22762643f, -0.25052419f, 
    0.20362353f, -0.18411759f, -0.24199064f, -0.02025929f, 0.00215469f, -0.02823017f, -0.13088097f, 0.07463970f, 
    0.03585274f, 0.00432664f, -0.14971033f, -0.14274602f, -0.04857121f, 0.04267120f, -0.11059941f, -0.05976164f, 
    -0.00983385f, 0.04386939f, 0.09154207f, 0.07890267f, 0.19010703f, -0.30849618f, -0.00346357f, 0.19393755f, 
    0.21887660f, 0.17029850f, -0.05530804f, 0.02270030f, 0.08896505f, -0.02381384f, -0.06047975f, 0.11205062f, 
    0.21890815f, 0.11394425f, 0.11305273f, -0.15184322f, -0.25698280f, -0.01470235f, 0.13189065f, -0.02784039f, 
    0.00170656f, -0.34074187f, 0.45386741f, -0.01473763f, 0.08235796f, 0.07941438f, 0.12920992f, 0.07122795f, 
    -0.03290605f, -0.25505599f, 0.00590631f, 0.18853173f, -0.14062084f, -0.02781451f, -0.09202093f, 0.13939007f, 
    -0.26469469f, -0.04992747f, -0.07490324f, 0.28826666f, 0.16712543f, 0.08424692f, -0.03420213f, 0.09867176f, 
    0.01675490f, -0.05877620f, -0.12462790f, -0.17269692f, -0.03101192f, 0.09507745f, -0.08766647f, -0.21165848f, 
    0.09524766f, -0.12472313f, 0.04594171f, 0.13498525f, -0.00634277f, 0.16437091f, 0.21828468f, 0.31279337f, 
    -0.00181394f, -0.00470309f, -0.12120129f, -0.10198740f, 0.12735939f, -0.08760991f, -0.04125345f, 0.24099033f, 
    0.16309331f, -0.03793382f, -0.02758971f, 0.01109442f, 0.00928832f, -0.00248704f, -0.24868545f, 0.22907379f, 
    0.10613547f, 0.22432986f, 0.03915290f, -0.07064719f, 0.03683579f, -0.08120708f, -0.08630712f, -0.00274297f, 
    -0.11505735f, 0.13492544f, -0.05577434f, -0.04927121f, -0.05400299f, -0.13500850f, 0.11005113f, 0.06189065f, 
    -0.10279229f, 0.13715127f, 0.02701890f, 0.05893693f, -0.21815510f, -0.16947575f, 0.05354701f, 0.04232926f, 
    0.07440821f, -0.07628649f, 0.10145150f, 0.09309310f, 0.04788221f, 0.02442336f, 0.24409065f, 0.06612848f, 
    0.01987703f, -0.03540334f, -0.14794242f, -0.13839360f, -0.02378626f, 0.00714686f, 0.04974573f, 0.15384649f, 
    -0.00738307f, 0.00511568f, 0.01883486f, -0.08339242f, -0.31008238f, 0.21596766f, 0.06905115f, -0.01792319f, 
    0.11277083f, 0.03036423f, -0.03044198f, -0.16310194f, -0.15219964f, -0.40521732f, 0.11632839f, -0.29754075f, 
    -0.37657610f, 0.06462089f, -0.17347634f, -0.18944784f, 0.20328474f, -0.19448940f, 0.39313745f, 0.30097377f, 
    0.22953567f, -0.10652950f, -0.03633104f, -0.02505590f, 0.12357540f, 0.06085310f, -0.08795965f, -0.03782096f, 
    0.04859027f, 0.05631475f, -0.17665561f, -0.08190417f, -0.01512001f, 0.10081975f, 0.07831842f, 0.01698566f, 
    0.07335261f, -0.04462825f, 0.04447078f, 0.17567259f, 0.16517870f, 0.11460705f, -0.00437732f, -0.01694024f, 
    0.12521356f, -0.03604916f, -0.02660975f, 0.00236684f, 0.16657232f, 0.15204911f, 0.07908085f, -0.03076060f, 
    0.04631644f, -0.08838161f, -0.13471229f, -0.06456391f, -0.23156996f, 0.00206017f, -0.13691412f, 0.13915974f, 
    -0.12578772f, -0.39823347f, -0.14646463f, 0.02482385f, 0.04809919f, 0.04680587f, 0.10883053f, -0.05928638f, 
    0.11405504f, -0.04015367f, 0.14309466f, -0.05530266f, 0.01219622f, 0.17537062f, -0.04410164f, 0.14241420f, 
    -0.10174681f, -0.01530803f, -0.01326155f, -0.01705835f, 0.00667870f, -0.26820996f, -0.13250987f, -0.02550607f, 
    0.00550531f, -0.08410352f, -0.01069773f, 0.18295406f, 0.11542244f, -0.08921882f, -0.11645676f, -0.10810152f, 
    -0.01460676f, -0.08372490f, 0.00548886f, -0.07333561f, -0.09747564f, 0.04507369f, 0.07781398f, -0.08283343f, 
    -0.10252570f, 0.14431089f, -0.04344556f, 0.01444705f, 0.04357785f, -0.06926017f, 0.04303706f, 0.17397736f, 
    -0.22206643f, -0.15258057f, -0.15263623f, 0.01327761f, 0.08203172f, 0.01605491f, -0.14688674f, -0.10061603f, 
    0.08089960f, 0.02775042f, 0.07930920f, 0.03672174f, 0.04396412f, 0.02634277f, -0.00824812f, -0.14722517f, 
    0.01438818f, -0.18589380f, -0.32384536f, 0.12821095f, 0.10880927f, -0.09383852f, -0.06775082f, -0.21133511f, 
    -0.11066579f, -0.31244895f, -0.26522148f, 0.06780086f, 0.10093845f, 0.15365539f, 0.11141986f, -0.11226015f, 
    -0.06713933f, -0.00778133f, 0.09872478f, -0.02769915f, 0.15345363f, 0.13409881f, -0.07898157f, 0.06464817f, 
    -0.26624912f, 0.09537123f, 0.00759269f, 0.03593171f, -0.18847704f, 0.03925277f, 0.23311016f, 0.22342592f, 
    0.01306502f, -0.14054710f, -0.11625446f, -0.10509697f, -0.12970234f, -0.02298252f, -0.24323580f, 0.15552045f, 
    -0.00314055f, 0.18474962f, 0.07968807f, -0.01228862f, 0.13859989f, 0.11854409f, -0.01563181f, 0.03200674f, 
    -0.08924457f, 0.02357617f, 0.01515868f, 0.02440533f, 0.00165905f, 0.07655582f, 0.02748111f, 0.07067141f, 
    0.12289592f, -0.00015589f, 0.03506197f, 0.03437708f, 0.09127799f, 0.11269308f, -0.09023491f, 0.11207233f, 
    0.08119683f, 0.19108705f, -0.38517484f, 0.00215644f, 0.14792739f, 0.08984490f, -0.00639885f, 0.11259198f, 
    0.01861586f, -0.03905568f, -0.03856973f, -0.15880045f, -0.24097997f, -0.01164003f, 0.07544706f, -0.15992247f, 
    -0.02709859f, 0.09159734f, -0.02913382f, -0.05085698f, -0.16906866f, -0.10415740f, 0.19072837f, 0.08415019f, 
    -0.01200514f, 0.01250627f, 0.19925123f, 0.06597041f, 0.03344614f, 0.14522116f, -0.01175012f, 0.13661721f, 
    -0.00469356f, 0.01294234f, 0.03703545f, 0.06897605f, 0.07560859f, -0.06016537f, 0.16301736f, 0.11700162f, 
    -0.24400289f, -0.03262278f, 0.10719709f, -0.05730728f, 0.03085136f, -0.11885007f, -0.05496498f, -0.25650629f, 
    -0.06868125f, -0.00604968f, 0.09769030f, 0.09306769f, 0.27509493f, 0.12025188f, 0.12548748f, -0.09806477f, 
    -0.19829020f, -0.16678412f, -0.11399980f, 0.02730643f, -0.13837346f, -0.08298661f, -0.05230755f, 0.05393550f, 
    0.06214927f, -0.09050099f, 0.04100122f, 0.06934246f, 0.03174132f, 0.02743150f, 0.04818924f, 0.14025883f, 
    0.20629191f, -0.00664041f, -0.08725676f, -0.17020397f, -0.02145228f, 0.17524314f, 0.02388575f, 0.08930842f, 
    0.22118750f, 0.20832214f, -0.04342194f, -0.30551243f, -0.09624350f, 0.04693333f, -0.01935052f, 0.01627960f, 
    0.22207162f, 0.08465809f, 0.15985212f, 0.00430111f, 0.04158200f, -0.29093671f, 0.14013211f, -0.05064956f, 
    0.10213307f, 0.08704556f, 0.16587305f, -0.16158329f, -0.59578323f, 0.00147377f, 0.06307130f, 0.14677003f, 
    0.10654233f, 0.06663533f, 0.11026723f, 0.18997604f, 0.05794717f, 0.46174541f, -0.10508291f, -0.00785076f, 
    0.10273888f, -0.10531521f, -0.03244083f, 0.20265202f, -0.11954516f, 0.01673087f, -0.12995462f, -0.22032465f, 
    -0.19020791f, -0.02466610f, -0.07868019f, -0.00122943f, -0.01082791f, 0.08564876f, 0.06938825f, 0.02721224f, 
    -0.05544042f, -0.09993564f, 0.11780753f, -0.01485979f, 0.01430427f, 0.00646598f, -0.00457299f, 0.00552486f, 
    0.10990424f, 0.12944390f, -0.04593579f, -0.04080352f, 0.23442833f, 0.00311916f, -0.01267972f, 0.06475312f, 
    -0.08887898f, -0.00441802f, -0.12441936f, -0.06378753f, -0.15613969f, 0.12172687f, -0.04321583f, 0.01254331f, 
    -0.01513271f, -0.09516343f, -0.02236884f, -0.02062968f, 0.12323914f, -0.06255699f, 0.08271105f, -0.04679849f, 
    -0.05064341f, 0.22964215f, -0.09188087f, -0.07700593f, -0.11561655f, -0.09668151f, 0.03462191f, -0.00266173f, 
    0.05316884f, -0.14952958f, 0.04838026f, -0.06100954f, -0.20732097f, -0.08683617f, 0.04247718f, -0.13036336f, 
    0.03260336f, -0.01757321f, -0.04736228f, -0.20155533f, 0.14766783f, -0.18931264f, 0.11571893f, 0.05911767f, 
    0.03946599f, -0.06657977f, 0.03855936f, -0.42971936f, 0.17389309f, -0.10900639f, 0.40452364f, -0.02575851f, 
    0.06285580f, 0.05816297f, 0.02207194f, -0.09209238f, 0.00039550f, -0.05313975f, 0.01598672f, -0.39932540f, 
    -0.03881299f, -0.07094848f, -0.01926034f, 0.00356806f, -0.05727565f, -0.17019396f, -0.19589789f, -0.10669456f, 
    0.04120587f, -0.02074377f, 0.13131386f, 0.14276296f, -0.16169029f, -0.00018151f, -0.21842644f, -0.01490471f, 
    0.02506812f, -0.23797077f, 0.27683061f, -0.04315219f, -0.00910900f, -0.11592361f, -0.04422193f, 0.21359524f, 
    -0.02130117f, -0.04284777f, 0.23576868f, -0.20780694f, 0.09160864f, -0.07993957f, 0.16098514f, 0.15132703f, 
    -0.04524357f, 0.02112084f, 0.04507407f, 0.18785451f, -0.11070003f, -0.04231052f, 0.06182719f, 0.07916355f, 
    -0.02298663f, 0.05519789f, 0.02469351f, 0.08485433f, 0.17980401f, 0.27575859f, -0.20080206f, 0.03450379f, 
    0.02205083f, 0.18377449f, 0.07943995f, 0.21474577f, 0.01098122f, 0.26968974f, 0.04167951f, 0.04378375f, 
    0.03700390f, -0.08517606f, 0.08529491f, 0.16224438f, -0.03778005f, -0.01715058f, 0.10926040f, 0.14143063f, 
    0.10287166f, -0.11053726f, -0.21665454f, -0.06072620f, -0.10196950f, -0.05360740f, -0.07283988f, 0.20579466f, 
    -0.09288137f, 0.08291787f, 0.12217924f, -0.08291113f, 0.01600710f, 0.13860443f, 0.01622144f, -0.04789248f, 
    0.02419634f, -0.26402906f, -0.01893948f, -0.16639467f, -0.00467683f, -0.18410844f, -0.18136528f, -0.01809793f, 
    -0.08757196f, -0.00603800f, 0.15591444f, 0.14033575f, -0.10229126f, -0.03165557f, 0.18504441f, 0.20870563f, 
    0.04443327f, 0.07298919f, 0.14213875f, 0.05434880f, 0.20118026f, 0.11557082f, 0.10225329f, 0.19028604f, 
    0.06470630f, 0.16580176f, 0.01255517f, 0.11251190f, 0.16136417f, 0.13386866f, 0.02847434f, 0.10803020f, 
    -0.07505196f, 0.08259130f, -0.01425402f, -0.13735263f, -0.12413654f, -0.10900753f, 0.06467636f, -0.13323949f, 
    0.02010326f, -0.07618568f, -0.00632169f, -0.00244968f, -0.00786255f, 0.04249122f, -0.05827651f, -0.02712555f, 
    -0.02155435f, 0.13518630f, -0.02398334f, 0.12901655f, 0.09443156f, 0.14399089f, -0.02245528f, 0.02466754f, 
    0.07137828f, -0.04612328f, -0.01217495f, -0.00076916f, 0.03678479f, 0.02769826f, 0.10680961f, 0.29007053f, 
    -0.22197142f, 0.00994566f, 0.25802106f, 0.11665675f, -0.11895300f, 0.01691591f, -0.01360405f, -0.11577286f, 
    -0.02478707f, 0.01979724f, -0.07894032f, -0.00126269f, 0.09004097f, 0.06244720f, 0.06137170f, -0.33286911f, 
    -0.05984024f, 0.00787617f, -0.02184752f, 0.20397031f, 0.17801027f, 0.07511790f, -0.07131435f, 0.02636664f, 
    -0.10493704f, -0.06511340f, 0.17206700f, -0.10883883f, 0.20275421f, 0.04685022f, -0.07937197f, -0.06991286f, 
    -0.05549663f, -0.18773538f, -0.14720309f, 0.02250529f, 0.16712403f, 0.11050243f, -0.16261895f, 0.04238328f, 
    -0.05602461f, -0.04000369f, 0.04957522f, -0.05193373f, -0.00268173f, 0.24612629f, -0.05795764f, -0.07434797f, 
    -0.02421490f, -0.20857671f, -0.14437883f, 0.01004655f, -0.10968231f, -0.12923606f, 0.29636180f, -0.23456040f, 
    0.09020482f, 0.13130736f, -0.28735772f, -0.04722105f, 0.17504203f, -0.14257248f, 0.14541534f, -0.09621883f, 
    -0.08376396f, 0.26242954f, -0.05730391f, -0.07405899f, 0.16523950f, -0.01172017f, -0.13582781f, -0.08034717f, 
    -0.19072185f, 0.01480844f, -0.00698644f, 0.13415067f, -0.06027296f, -0.03489611f, -0.04702021f, -0.14111215f, 
    -0.20342503f, -0.01710350f, 0.23185451f, 0.22903255f, 0.02354215f, -0.22677132f, -0.12366799f, 0.07134980f, 
    0.14568391f, 0.05352552f, 0.09746747f, 0.07709328f, 0.11068441f, -0.04770942f, 0.02516733f, -0.07800383f, 
    0.01384601f, 0.09588157f, -0.00090065f, 0.33425799f, -0.03230935f, -0.08353090f, -0.13673270f, 0.06853098f, 
    -0.16526219f, -0.07201221f, -0.36664081f, 0.01675940f, 0.09774058f, 0.11842611f, 0.01042844f, -0.05663892f, 
    0.00717581f, -0.17431715f, -0.01883242f, 0.03538391f, -0.17435619f, -0.04628868f, -0.02526336f, 0.07766009f, 
    0.02680136f, -0.23411536f, 0.03252762f, 0.01502173f, 0.10314331f, -0.21928100f, -0.07384928f, -0.23873302f, 
    -0.02624016f, -0.08395971f, -0.14880691f, 0.02096675f, -0.06118103f, 0.03216216f, -0.28097695f, 0.01663028f, 
    -0.10175308f, 0.05547584f, -0.03723777f, 0.22501887f, 0.03389845f, -0.07444289f, 0.01163815f, 0.29267552f, 
    0.09060575f, -0.07047146f, -0.14192769f, -0.20936626f, -0.16445324f, -0.02957325f, 0.14918816f, 0.02241356f, 
    -0.08519547f, -0.00258287f, -0.11337949f, 0.11829364f, -0.08949153f, -0.03752445f, 0.09618335f, 0.13290371f, 
    0.00797633f, -0.05758438f, -0.01701371f, 0.01132796f, -0.00646255f, 0.03592267f, 0.08019555f, 0.18105577f, 
    -0.22426009f, -0.00691383f, -0.07229302f, 0.28824523f, 0.01264569f, -0.21164244f, 0.11186802f, 0.00620632f, 
    -0.01289703f, 0.08126127f, 0.08138593f, -0.08353002f, 0.00028187f, 0.13809203f, 0.18488266f, 0.01855656f, 
    0.10887957f, 0.06129950f, 0.08249740f, 0.13701226f, -0.22908843f, 0.06609076f, 0.15062146f, 0.07351132f, 
    -0.22277273f, -0.14349099f, 0.22900765f, 0.01574820f, -0.01974377f, -0.12723686f, 0.02240098f, 0.04513357f, 
    0.03640502f, 0.07552126f, 0.01261354f, 0.07219243f, 0.10480015f, -0.08963320f, -0.11326631f, -0.01273123f, 
    0.09029984f, 0.03066601f, 0.13173331f, -0.03686823f, 0.13732338f, -0.08572351f, 0.07857150f, -0.21824995f, 
    -0.16152881f, -0.12864979f, 0.09499171f, 0.23310171f, 0.05957472f, 0.07695280f, -0.02649386f, 0.05906843f, 
    -0.02234787f, -0.11846532f, 0.15479130f, 0.11918173f, -0.19336513f, 0.24102481f, -0.04891971f, -0.02142528f, 
    0.01774328f, 0.06007326f, -0.15272263f, -0.43615070f, 0.16124018f, -0.04563567f, -0.02580131f, -0.04002415f, 
    -0.01508913f, -0.00933081f, -0.13931635f, -0.13706324f, -0.00040757f, 0.09079096f, 0.07410904f, 0.07775315f, 
    0.38645393f, -0.10858710f, -0.02268453f, 0.09717497f, -0.28479263f, -0.24988338f, 0.03531046f, 0.15216815f, 
    -0.07062797f, 0.23606645f, 0.02731687f, -0.02485867f, 0.01402628f, -0.01367564f, 0.04627401f, 0.09782329f, 
    -0.07027768f, -0.09509213f, 0.02968591f, 0.05386513f, 0.18343626f, -0.37774026f, -0.05276947f, 0.16142747f, 
    -0.01047701f, 0.14619547f, 0.04724156f, -0.08670502f, 0.18275152f, -0.00769953f, 0.17132428f, -0.02858493f, 
    -0.38705328f, -0.16176669f, -0.02318625f, -0.11874314f, 0.11445778f, 0.06755864f, 0.06068868f, -0.17093503f, 
    -0.15028524f, -0.26596934f, 0.05719409f, 0.17335656f, 0.03941233f, 0.04371659f, -0.11871681f, -0.02285666f, 
    0.09712297f, 0.18253104f, -0.10168596f, -0.24094714f, -0.01968834f, -0.11212230f, -0.01914543f, 0.12164202f, 
    0.10299649f, -0.02548417f, -0.01834420f, 0.10997815f, -0.13458493f, -0.05983573f, -0.12391119f, -0.02698121f, 
    0.00668333f, 0.08082464f, 0.20013742f, -0.14099452f, -0.52015960f, -0.14584163f, -0.04121756f, -0.08602363f, 
    0.10010292f, -0.01398264f, 0.08953216f, 0.13487399f, -0.22417328f, -0.02632944f, 0.08811495f, 0.02833549f, 
    -0.06892937f, 0.19294867f, -0.22189297f, -0.09893748f, 0.19752339f, -0.23031525f, -0.20098677f, 0.00368540f, 
    0.15927389f, -0.13766387f, 0.15348269f, 0.17897287f, 0.05828114f, 0.49019912f, 0.09474772f, -0.09789043f, 
    -0.01039936f, 0.03061246f, -0.08567346f, 0.15800777f, 0.10563137f, -0.06368316f, -0.05736766f, -0.03850997f, 
    -0.11342912f, 0.08359671f, 0.23326524f, 0.09495573f, -0.03659453f, -0.12550312f, 0.03433031f, 0.14442080f, 
    0.22396125f, -0.05142098f, -0.16543157f, -0.13053985f, 0.09356371f, 0.00968869f, -0.03116989f, 0.03771080f, 
    0.02531723f, -0.33716840f, -0.21137956f, -0.09920439f, -0.05352085f, -0.01265052f, -0.13230093f, -0.04293244f, 
    -0.05597842f, 0.21113172f, 0.03740508f, 0.15936264f, 0.04201008f, -0.16734409f, -0.09022209f, 0.00427512f, 
    -0.05985257f, -0.01248327f, -0.35859537f, 0.03666345f, 0.18057552f, -0.06450535f, 0.00500182f, -0.05975267f, 
    0.17115329f, 0.12194903f, -0.02588361f, 0.08618317f, -0.05914852f, 0.20504600f, -0.12657778f, 0.08173344f, 
    -0.04720116f, 0.07617728f, 0.02675477f, 0.00050981f, 0.20740698f, -0.04518867f, -0.11698706f, -0.12247997f, 
    0.13436511f, 0.00598217f, 0.04936890f, -0.01497009f, -0.18933518f, 0.05074183f, -0.31561372f, -0.27006003f, 
    0.01891118f, 0.00389972f, 0.08607858f, -0.04207642f, 0.03709327f, -0.06779990f, -0.01162426f, 0.10865336f, 
    -0.14489183f, 0.11650249f, -0.03093840f, -0.01136098f, 0.08043448f, 0.05811219f, -0.03929093f, -0.02831892f, 
    0.15733892f, 0.34402508f, -0.05025721f, -0.05104150f, -0.00706291f, -0.01650157f, 0.00925866f, 0.03031226f, 
    0.00732550f, 0.04281382f, -0.15901788f, -0.08039767f, 0.17411515f, 0.08901303f, -0.01142118f, 0.02893851f, 
    -0.14071333f, 0.18891308f, 0.11163110f, 0.10904393f, -0.07095560f, -0.11326758f, -0.16972937f, 0.06626036f, 
    0.00905272f, -0.04569584f, 0.13043475f, 0.02089454f, -0.14434712f, 0.05384843f, 0.02149810f, -0.09519700f, 
    -0.02864513f, 0.00148016f, -0.07712869f, 0.01255055f, 0.10254233f, 0.35430473f, 0.07432209f, 0.02209949f, 
    0.13936962f, 0.21643947f, 0.05224359f, -0.01888649f, -0.07119475f, -0.09861054f, 0.21676040f, 0.16482688f, 
    0.02191337f, -0.01246707f, 0.01107547f, 0.05939263f, 0.15793808f, 0.20043208f, 0.09027344f, 0.04200104f, 
    0.04524587f, 0.03642919f, 0.07424351f, 0.11862694f, 0.05472936f, 0.09583325f, 0.07973877f, -0.02390266f, 
    -0.31710795f, 0.01160754f, -0.13352059f, -0.05261599f, 0.06479737f, 0.02817089f, 0.11628309f, 0.02105057f, 
    0.18840978f, 0.17765141f, -0.09367793f, -0.02433141f, -0.10536135f, -0.15894002f, -0.01734178f, 0.01372669f, 
    0.19521283f, 0.02632104f, 0.07598863f, -0.12988661f, -0.20321350f, -0.05924148f, -0.03805159f, 0.05341784f, 
    -0.05886492f, 0.14154048f, 0.09145773f, -0.07702658f, -0.02394470f, -0.05979479f, -0.05646261f, 0.07338139f, 
    0.00800315f, 0.02374297f, 0.11613198f, -0.05729315f, 0.34603658f, -0.00968952f, 0.01042210f, -0.13279217f, 
    -0.05717311f, -0.09367410f, -0.04577075f, -0.26188639f, 0.13320780f, -0.19400738f, -0.00817283f, -0.06860898f, 
    0.03113526f, -0.00358344f, 0.15549716f, 0.11351462f, 0.08625612f, -0.05984541f, 0.16361351f, -0.10358121f, 
    0.05075606f, 0.11908875f, -0.02734486f, -0.00444304f, -0.08138975f, -0.03973472f, 0.02705722f, 0.03425408f, 
    -0.21673244f, 0.02143553f, 0.08664019f, 0.00865678f, 0.00599330f, -0.18568687f, -0.23676117f, 0.19070083f, 
    0.17845178f, 0.10835351f, 0.04305625f, 0.10105870f, 0.04492111f, 0.05953553f, -0.01480181f, 0.20015432f, 
    0.35675314f, -0.09810255f, -0.19961204f, -0.08875412f, -0.34164828f, 0.07375417f, 0.01960349f, 0.00583983f, 
    -0.37336227f, 0.01705920f, 0.26677313f, 0.10750866f, 0.09117243f, -0.04308260f, 0.17275818f, 0.07396759f, 
    -0.02341410f, -0.48746178f, -0.27027643f, -0.25961530f, 0.04595525f, 0.08840278f, 0.08661168f, 0.18369231f, 
    -0.07629752f, 0.12176272f, -0.46671596f, 0.19268765f, 0.09986426f, 0.07918184f, 0.02801983f, 0.12561800f, 
    0.00004246f, 0.03682162f, 0.10431729f, 0.04960132f, -0.33365130f, -0.15487975f, -0.05144181f, -0.08453692f, 
    -0.00237487f, 0.09610685f, -0.03181388f, 0.02927107f, -0.22299092f, -0.17992079f, 0.04324370f, -0.02158236f, 
    -0.05782622f, -0.14454821f, -0.08134691f, 0.12272836f, 0.06211350f, -0.65616411f, -0.43794429f, 0.11882216f, 
    0.11344491f, -0.16463780f, -0.35730624f, -0.04683324f, 0.03115209f, -0.00051811f, -0.01032072f, 0.07455311f, 
    0.13882063f, -0.22496445f, -0.12898816f, -0.17364639f, -0.03683864f, -0.08011051f, 0.08942631f, 0.18232837f, 
    0.15592596f, 0.08062270f, -0.05171033f, -0.13646451f, 0.00110853f, -0.10612293f, 0.01708304f, 0.08705977f, 
    0.02436032f, -0.24445377f, -0.16635028f, 0.06715001f, -0.16099679f, -0.12121902f, -0.09055388f, 0.28366867f, 
    0.19349560f, -0.12465762f, -0.04494903f, 0.25438514f, 0.06580028f, 0.05663942f, -0.03744835f, 0.09380424f, 
    -0.03085660f, 0.06279712f, 0.03033230f, -0.08719927f, -0.06862434f, 0.17403923f, -0.00166977f, -0.26416343f, 
    0.05040379f, -0.11299790f, 0.07420579f, -0.09364024f, -0.05031369f, -0.27064353f, 0.21406811f, 0.04276189f, 
    -0.02385480f, 0.11811800f, 0.11844623f, -0.00640125f, 0.12786222f, -0.01249461f, 0.01470590f, -0.10130151f, 
    -0.12807761f, 0.00625089f, 0.03002182f, 0.02141462f, 0.00235627f, -0.18939489f, -0.17173654f, -0.04761108f, 
    0.10006607f, -0.06293549f, 0.05690811f, 0.10070324f, -0.01687018f, 0.09930043f, 0.08972578f, 0.04946924f, 
    0.04945146f, 0.02689661f, 0.00071253f, 0.01824973f, 0.03284683f, -0.03917840f, -0.18614876f, -0.27114528f, 
    -0.05618098f, 0.03291108f, 0.08726043f, -0.02838479f, 0.09690589f, 0.24310814f, -0.00771166f, 0.22106527f, 
    -0.07397357f, 0.05653889f, 0.15049693f, -0.01874905f, 0.03148584f, -0.04841889f, -0.02104241f, 0.06588533f, 
    -0.33040863f, -0.13992675f, 0.14399782f, 0.08636933f, -0.08494401f, -0.06803094f, -0.07107142f, 0.01665116f, 
    -0.08542318f, 0.04113270f, 0.02956940f, 0.07546752f, 0.16331342f, 0.00053920f, 0.05103575f, -0.08427488f, 
    0.01781829f, 0.02471205f, -0.13529071f, 0.23766126f, 0.14477660f, 0.00658708f, 0.11291061f, 0.16029811f, 
    0.09101478f, 0.09042581f, 0.09822577f, 0.10907540f, 0.07375325f, 0.15788651f, -0.27209461f, 0.10429048f, 
    0.16912359f, -0.08413227f, 0.08876175f, 0.31795296f, -0.09370369f, 0.17622152f, 0.14882925f, 0.10670292f, 
    -0.00489265f, 0.00184543f, 0.06776171f, -0.00827893f, 0.03026506f, 0.06353596f, -0.36956218f, -0.06829460f, 
    0.09629826f, -0.16372058f, 0.08455811f, 0.06282423f, 0.08178260f, -0.03542716f, 0.20310701f, -0.00538984f, 
    -0.05145250f, 0.16326737f, -0.06001588f, 0.01622261f, 0.10073220f, 0.03264892f, -0.16366565f, 0.05995185f, 
    -0.32694733f, -0.18331295f, -0.10498875f, 0.11006568f, 0.00924989f, -0.07725912f, 0.17041530f, 0.06212208f, 
    -0.19976884f, -0.06069338f, 0.25261462f, -0.42518124f, 0.02186313f, 0.05913211f, 0.12751594f, 0.02707279f, 
    0.07059702f, -0.14727908f, -0.02912384f, -0.03264319f, -0.02215088f, -0.06434702f, -0.02857990f, 0.03923083f, 
    0.18069211f, -0.10635798f, -0.15221600f, 0.27419013f, 0.14790785f, -0.21164457f, 0.00522478f, 0.00086629f, 
    0.06699540f, -0.06152312f, -0.06157850f, 0.04462610f, -0.10363569f, -0.02610015f, 0.10146180f, 0.13640462f, 
    -0.10277357f, -0.04482396f, 0.25791666f, 0.00283823f, 0.05969707f, 0.24657923f, 0.01174503f, -0.08688062f, 
    0.00974912f, 0.00244761f, -0.25416312f, 0.00747047f, 0.18627334f, 0.02877685f, -0.00060166f, -0.09383933f, 
    -0.17624035f, -0.03390555f, 0.02813714f, 0.10907082f, -0.16762279f, -0.01843903f, 0.00796696f, 0.07458029f, 
    -0.21044286f, 0.03897292f, 0.01804765f, -0.20770596f, 0.05890246f, -0.02448061f, -0.10002019f, -0.12130623f, 
    0.07282761f, -0.07489424f, -0.07110308f, 0.24042183f, 0.02605314f, -0.02232203f, 0.18654357f, 0.03258463f, 
    -0.01161467f, -0.25980937f, -0.12760955f, -0.08455296f, 0.17479037f, -0.04048424f, 0.10802942f, 0.08238877f, 
    -0.01712489f, 0.03088873f, -0.00216759f, -0.10395905f, -0.26376379f, 0.07688474f, -0.01329137f, 0.16223650f, 
    -0.12942971f, -0.14752786f, 0.22361191f, -0.05594140f, -0.07343552f, -0.44888717f, -0.28895819f, 0.08501543f, 
    -0.13256659f, 0.05348463f, 0.15180667f, 0.17691219f, -0.46952417f, -0.26499024f, -0.10890387f, -0.25612926f, 
    -0.02045359f, -0.03244771f, -0.07222894f, 0.02299801f, 0.04312227f, 0.07694268f, -0.08460674f, -0.50292033f, 
    0.01431411f, -0.03037139f, -0.03833695f, 0.36960959f, 0.12972611f, -0.21193813f, -0.28304410f, -0.23613249f, 
    0.09623482f, -0.00185047f, -0.03771171f, -0.04983335f, -0.00169465f, 0.11693855f, -0.21230158f, -0.17195581f, 
    -0.08973800f, 0.08496544f, 0.04813226f, -0.02051799f, -0.00103105f, 0.09896037f, 0.02008053f, 0.10322040f, 
    -0.05727359f, 0.02281721f, 0.13484068f, 0.09576097f, -0.07536118f, -0.10506739f, -0.02533973f, -0.00516354f, 
    0.07778466f, -0.10315453f, -0.06752574f, -0.09843224f, -0.03523203f, -0.00284370f, -0.05000675f, -0.03124186f, 
    -0.07164980f, 0.01915077f, -0.07933368f, 0.02249041f, 0.19728833f, 0.15292889f, 0.01017831f, 0.00115484f, 
    -0.07396402f, -0.15017092f, -0.15078312f, -0.02607601f, -0.02694496f, -0.00587054f, -0.08403968f, 0.06796370f, 
    0.02010015f, -0.08480242f, -0.09797121f, 0.09790245f, 0.10199641f, 0.19815952f, 0.07057327f, -0.17555930f, 
    -0.09756918f, 0.09321244f, -0.12802838f, 0.20944697f, -0.01836913f, 0.09194197f, 0.08655071f, 0.09873629f, 
    0.03887690f, 0.15635590f, 0.04302962f, -0.04488097f, -0.02996390f, 0.30217761f, 0.07143640f, 0.31783479f, 
    -0.19258091f, 0.03111421f, 0.04863792f, 0.08079672f, 0.07748419f, -0.01682043f, -0.14967586f, -0.27502817f, 
    0.04770198f, 0.20130081f, -0.14321569f, -0.00322982f, -0.09540946f, -0.10089483f, 0.15982153f, 0.14451799f, 
    0.15334831f, 0.15584823f, 0.20246688f, 0.08432109f, 0.23351067f, -0.04856924f, 0.09536672f, 0.02390190f, 
    -0.07248782f, 0.04228374f, 0.01630189f, 0.08012106f, 0.15652029f, 0.03650388f, 0.09612120f, -0.29928523f, 
    -0.13338915f, -0.10123276f, -0.11597177f, 0.03602243f, -0.29066798f, 0.07398891f, -0.05206003f, 0.05376884f, 
    -0.12951492f, -0.15436439f, -0.17035338f, 0.20748724f, 0.26883474f, 0.10863165f, 0.03029854f, 0.12695016f, 
    0.13878749f, -0.06604442f, -0.00317965f, 0.11404365f, -0.03081342f, -0.25003955f, 0.02117768f, 0.15245652f, 
    -0.00542362f, -0.09544014f, 0.02575994f, -0.04077675f, -0.15266746f, 0.16551155f, -0.01681585f, -0.17240766f, 
    -0.01464619f, -0.02179181f, 0.05560240f, 0.00692126f, 0.04330922f, 0.00764150f, -0.23379268f, 0.04321131f, 
    -0.10319492f, 0.02549134f, -0.05218779f, -0.02905163f, -0.04512567f, -0.05648904f, -0.07942549f, 0.06094917f, 
    0.15580241f, 0.07727008f, -0.10152620f, 0.07681966f, 0.02973228f, 0.10955491f, -0.11307571f, 0.08768597f, 
    0.03186054f, -0.04538077f, -0.09892323f, -0.07223893f, -0.24274622f, -0.12811260f, -0.02187570f, 0.04793234f, 
    0.04059625f, -0.24170762f, -0.03372582f, 0.02775652f, 0.06294359f, 0.21818325f, 0.09316991f, 0.01810931f, 
    -0.24864018f, -0.14232281f, 0.16426677f, 0.08559201f, 0.08894800f, 0.08238388f, 0.18065785f, -0.01068371f, 
    -0.06024804f, -0.14775066f, 0.02006415f, -0.03815159f, 0.11980209f, -0.05753853f, 0.05651390f, -0.07399552f, 
    0.12723902f, 0.07259068f, 0.03470461f, -0.27664685f, 0.02781374f, -0.04587181f, 0.05741572f, -0.04103775f, 
    -0.01790882f, 0.04638811f, -0.07256852f, 0.14684677f, 0.17551784f, -0.03590681f, -0.02626377f, -0.06452677f, 
    0.12840395f, 0.05358399f, 0.01965862f, 0.07263549f, 0.10718710f, 0.03450380f, 0.08137190f, 0.16466762f, 
    0.17981495f, -0.17742954f, 0.09916174f, -0.10289522f, 0.20662758f, -0.12146846f, 0.08867953f, 0.13318892f, 
    0.33270654f, -0.38579580f, -0.11432754f, -0.00886508f, 0.15582432f, 0.04265568f, -0.00619148f, -0.23235130f, 
    -0.06699363f, -0.01699363f, 0.13226703f, -0.13524657f, -0.30863649f, -0.11905199f, 0.01289133f, 0.10408553f, 
    -0.03757239f, 0.08915118f, 0.14290203f, 0.00807546f, -0.05410768f, -0.03161537f, 0.10011892f, -0.21001758f, 
    0.14180173f, -0.08013835f, 0.02616226f, 0.24942993f, -0.07712322f, -0.20149924f, 0.04248329f, -0.01714162f, 
    0.01176584f, 0.01218486f, 0.02093280f, 0.05077190f, 0.07664704f, -0.02605575f, -0.01331862f, -0.08655224f, 
    0.20653127f, 0.00870713f, -0.13573559f, -0.17964597f, -0.43187389f, -0.36822286f, -0.01570726f, 0.10675896f, 
    -0.01246482f, -0.06332246f, -0.08073993f, 0.04155395f, 0.01510888f, 0.07730031f, -0.18842188f, 0.24422434f, 
    0.06472328f, -0.05738887f, -0.17082657f, 0.08136936f, 0.06858192f, 0.10127255f, 0.19043274f, -0.12511562f, 
    0.04566944f, -0.02041963f, 0.03832612f, -0.00643201f, 0.07775347f, -0.05167825f, -0.07210627f, -0.06171516f, 
    -0.05347281f, -0.00276542f, -0.29875913f, 0.10015031f, 0.19267960f, -0.04382612f, -0.06090748f, 0.01005967f, 
    -0.09625920f, 0.07973780f, 0.20663053f, -0.18515778f, 0.04688202f, 0.09024048f, -0.00600742f, 0.04521494f, 
    -0.03470843f, 0.11756116f, 0.01355436f, -0.03775385f, -0.15878843f, 0.08214861f, -0.10322763f, -0.07364032f, 
    0.01205305f, 0.14738743f, -0.07218347f, 0.10998098f, -0.27569705f, 0.19543098f, -0.01770526f, -0.07079464f, 
    -0.04408173f, 0.06530118f, 0.14781083f, -0.10471295f, -0.03745228f, -0.08482419f, 0.12118104f, 0.07716391f, 
    -0.15414184f, -0.03797155f, 0.04248875f, -0.06358530f, 0.18675019f, 0.02844812f, -0.08520180f, -0.23167719f, 
    0.03900127f, -0.01170633f, -0.25407678f, 0.09690679f, 0.10352487f, 0.15124112f, -0.25000653f, -0.23651575f, 
    -0.04209746f, 0.07399295f, -0.22332734f, -0.18369758f, -0.17681925f, 0.08027720f, -0.13974901f, 0.03599633f, 
    0.11972199f, -0.01567476f, -0.17030524f, 0.18786167f, 0.09772612f, -0.03638337f, -0.04460397f, 0.04639494f, 
    -0.12162036f, -0.33560941f, -0.05529603f, -0.04336257f, 0.02267919f, -0.06042266f, -0.10470841f, -0.15382206f, 
    0.05009995f, 0.27945495f, -0.05918937f, 0.01739618f, -0.01976147f, -0.02648617f, 0.11230782f, 0.00208786f, 
    -0.04201879f, -0.03676739f, 0.03545780f, -0.24530035f, 0.21382633f, 0.07153946f, 0.12524787f, 0.05348364f, 
    0.24423456f, 0.08467594f, -0.65893823f, 0.18649383f, 0.41496393f, 0.02889900f, 0.05367862f, -0.14981444f, 
    0.14428324f, -0.08375110f, 0.06447174f, -0.10801423f, 0.03355575f, 0.07359043f, 0.02722521f, 0.04679969f, 
    0.10029011f, 0.15163253f, 0.04113535f, -0.08431828f, -0.08353458f, -0.05088203f, 0.08717487f, -0.01798910f, 
    0.29733157f, 0.06765750f, 0.09176597f, 0.15094759f, -0.08059040f, -0.23923375f, -0.02421468f, 0.28413147f, 
    -0.00947343f, 0.00324195f, 0.01707515f, 0.08274803f, 0.07909263f, -0.02929347f, 0.21280318f, 0.13219255f, 
    0.13854043f, 0.08135597f, 0.08659089f, 0.13181573f, 0.07621369f, -0.11881170f, 0.08357862f, -0.14419684f, 
    0.05009139f, 0.35208213f, 0.15844840f, 0.02303831f, -0.12995224f, -0.00753823f, -0.16584314f, 0.01329498f, 
    -0.12576404f, -0.15196677f, -0.18452643f, -0.15117487f, 0.04090600f, 0.09441853f, 0.18419005f, -0.17503802f, 
    0.01070254f, 0.13903987f, 0.27584064f, -0.27167976f, 0.20941827f, 0.09152133f, -0.05255590f, -0.04404654f, 
    0.17490041f, -0.09280971f, -0.10451573f, 0.05513370f, -0.04353245f, 0.15169087f, 0.10347626f, 0.10642442f, 
    0.10703558f, -0.18125115f, 0.10699148f, 0.10690677f, 0.12334031f, 0.16973841f, 0.16481714f, 0.11390974f, 
    0.15632246f, 0.04317281f, 0.07093502f, 0.01875637f, 0.02061940f, 0.07452403f, -0.09327514f, -0.17814839f, 
    -0.05504737f, -0.10673904f, -0.10762028f, 0.01460332f, 0.15399230f, -0.20582749f, -0.00599614f, 0.36009288f, 
    -0.03150735f, 0.07812818f, -0.02758030f, 0.10788002f, 0.19186158f, 0.05367751f, -0.06480406f, 0.06635136f, 
    -0.01115352f, -0.01498321f, 0.00560493f, -0.12309556f, -0.16189669f, -0.17448147f, -0.17849825f, -0.34091961f, 
    0.05987544f, 0.21124029f, -0.23816532f, -0.06092510f, -0.07278821f, -0.01344887f, -0.11322471f, -0.06913249f, 
    0.12635984f, 0.03016980f, 0.10960042f, 0.17084415f, -0.00744144f, -0.01721290f, 0.07503721f, -0.01088305f, 
    -0.16851349f, 0.05700066f, 0.10061446f, 0.05896397f, -0.02920355f, 0.04185940f, 0.03736051f, -0.05544424f, 
    -0.12441123f, -0.07351289f, -0.06754002f, -0.06091164f, 0.22382554f, 0.22204302f, 0.04029506f, -0.01475680f, 
    -0.27140957f, -0.21352173f, -0.03348989f, -0.34802645f, -0.35972318f, -0.27849197f, -0.01091012f, -0.02102027f, 
    0.06312386f, 0.18817744f, 0.08442024f, 0.01507435f, -0.24197100f, -0.44170055f, 0.02019249f, 0.01147760f, 
    -0.11608510f, -0.09353280f, -0.08751792f, -0.14102657f, -0.16174649f, -0.50814372f, 0.26618049f, -0.17515881f, 
    -0.06701583f, 0.31891623f, -0.30684116f, 0.00156285f, 0.27747834f, -0.00172115f, -0.01920078f, 0.28172502f, 
    0.23825322f, -0.17367919f, 0.10157746f, -0.07708112f, 0.11344679f, -0.20404923f, -0.01055345f, 0.04622804f, 
    -0.16258253f, -0.13847306f, -0.06053667f, -0.13902462f, -0.24155749f, -0.07986545f, -0.08073873f, 0.03113470f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.24950373f, -0.03878234f, 0.01708721f, 0.16687630f, -0.00348402f, -0.13195790f, 0.16738100f, -0.01130329f, 
    -0.08800227f, -0.04269391f, 0.04570857f, -0.03597325f, 0.07073845f, 0.03825582f, -0.08708513f, -0.01739729f, 
    0.05407340f, 0.11316805f, 0.28776458f, 0.19032681f, -0.04640280f, -0.03610948f, 0.19188428f, 0.18376425f, 
    0.02591089f, 0.03064400f, 0.00398060f, 0.00332651f, 0.14409344f, 0.19056757f, 0.00257687f, 0.09972385f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.29980356f, 0.11638123f, 0.04175290f, -0.00341702f, 0.05247371f, 0.21809265f, 0.04662935f, -0.24420141f, 
    -0.08363741f, 0.00414446f, -0.24372816f, 0.35184827f, -0.28953016f, 0.05552766f, 0.33554178f, -0.16643351f, 
    -0.20578445f, 0.10677854f, 0.13852382f, 0.21695513f, 0.32773280f, 0.06070055f, 0.18605421f, 0.20937052f, 
    -0.12142428f, 0.16378562f, -0.07718907f, 0.11764762f, 0.02233786f, 0.23932101f, 0.13339160f, 0.11798950f, 
    0.00306780f, -0.02366109f, 0.12109693f, -0.17171551f, -0.12416733f, 0.03458172f, -0.16478133f, -0.20825680f, 
    -0.15017228f, -0.10081187f, -0.01035511f, 0.05935302f, -0.07613195f, 0.15826157f, -0.11525276f, -0.16013592f, 
    0.10548715f, 0.06923274f, -0.20340218f, -0.07298198f, 0.06724561f, -0.00705554f, -0.17682835f, -0.04133434f, 
    -0.05348109f, -0.20310813f, -0.15799999f, -0.14164801f, -0.03374045f, 0.01055179f, -0.13492724f, 0.10644908f, 
    -0.17768200f, -0.00231963f, -0.08458231f, 0.02083165f, 0.08296382f, -0.22449797f, -0.21989173f, 0.06616443f, 
    -0.16582380f, 0.15583493f, -0.18286799f, -0.14320290f, 0.00855847f, -0.03804133f, 0.01295187f, 0.03575252f, 
    0.11088648f, -0.14627838f, -0.23172727f, 0.07288311f, 0.03703186f, -0.01557477f, -0.11483393f, -0.18615702f, 
    0.01171966f, -0.08245697f, 0.05923946f, -0.10921790f, 0.04944566f, -0.13522728f, 0.11228689f, 0.07201380f, 
    -0.22977994f, 0.09302939f, -0.04869628f, 0.16160575f, -0.05186842f, 0.03893110f, -0.15707076f, 0.18127267f, 
    -0.17687818f, 0.02119015f, -0.06362391f, -0.13155961f, 0.09004927f, 0.07454486f, -0.04488072f, 0.11398287f, 
    -0.08073166f, -0.15880074f, 0.04794344f, 0.17314783f, -0.07020791f, -0.16830945f, -0.03820065f, 0.18151776f, 
    -0.02720885f, -0.17818862f, 0.08930667f, 0.04078728f, 0.03895044f, -0.00176910f, 0.01490724f, 0.06464321f, 
    0.32979894f, -0.07096320f, 0.07392771f, -0.00142651f, 0.02214354f, -0.18790659f, 0.31577662f, 0.33594337f, 
    0.12857550f, -0.09196089f, 0.21580498f, -0.04303113f, 0.19687365f, 0.13949460f, -0.23383254f, 0.35763690f, 
    -0.32745305f, -0.10794503f, 0.11994512f, -0.28321812f, -0.37600106f, -0.15441732f, 0.07442172f, 0.12228160f, 
    -0.20075515f, -0.20044057f, 0.20789687f, 0.20988101f, -0.60708249f, -0.08822139f, -0.09960625f, 0.34824616f, 
    0.05567528f, 0.07854232f, -0.13463190f, 0.10099687f, -0.10615247f, 0.07391777f, 0.12360686f, -0.33048633f, 
    -0.30287954f, -0.01124277f, -0.18570384f, 0.21501324f, -0.21824913f, -0.15869227f, 0.19364396f, 0.03915330f, 
    0.26617631f, -0.15849248f, 0.07738882f, 0.30355880f, -0.32290176f, -0.08638776f, 0.22908264f, 0.57613248f, 
    -0.35193098f, 0.15419859f, -0.08596712f, 0.16145587f, 0.02680672f, 0.06216889f, 0.08902375f, 0.08403142f, 
    0.27928841f, -0.11962514f, 0.09774511f, 0.27609798f, 0.13355963f, -0.00418194f, 0.07039893f, -0.31114051f, 
    -0.03047943f, 0.02758256f, -0.05049121f, -0.06091119f, -0.03928833f, -0.03060512f, -0.50046694f, -0.15307307f, 
    -0.40921521f, 0.24569385f, 0.30685359f, -0.01385322f, -0.32588992f, -0.09953365f, 0.29103342f, 0.60171080f, 
    -0.19415109f, 0.03334792f, 0.22478370f, 0.04869876f, 0.07339080f, 0.02597317f, 0.02463383f, -0.03240002f, 
    0.21500687f, -0.00184038f, -0.04685462f, 0.18899834f, 0.03022753f, 0.02961048f, 0.26603135f, 0.18944179f, 
    -0.06941742f, -0.09433452f, 0.19578211f, 0.16548640f, 0.06288867f, -0.12465953f, -0.00369843f, 0.19750187f, 
    -0.42296055f, -0.00866295f, 0.07709951f, -0.57775563f, 0.21288171f, -0.50307149f, -0.08705301f, 0.23122358f, 
    0.24803142f, 0.10965188f, 0.02980363f, -0.19199421f, -0.78277254f, 0.18544598f, -0.15405005f, 0.02180181f, 
    0.33037686f, 0.13290757f, -0.03609227f, 0.16359499f, 0.02232142f, 0.00528842f, 0.11816777f, -0.16436546f, 
    -0.36677635f, -0.04279685f, -0.05706692f, 0.24144034f, -0.06580743f, 0.13223274f, -0.21637914f, -0.39181599f, 
    -0.11045706f, 0.11086382f, 0.24386860f, -0.40345651f, -0.21333691f, -0.08041044f, 0.28524429f, -0.24037062f, 
    0.07419920f, 0.20616926f, -0.12379923f, 0.03622194f, 0.11368597f, 0.11877026f, 0.07876233f, 0.39866927f, 
    -0.33671281f, -0.00170467f, 0.01469629f, -0.06910276f, -0.04563977f, 0.06120646f, 0.14682943f, 0.18565089f, 
    -0.05597663f, -0.03441236f, 0.13153228f, -0.01150665f, -0.25385869f, -0.12250708f, 0.17641723f, 0.19440210f, 
    -0.00557010f, 0.30482489f, -0.00670671f, -0.19470906f, 0.27166846f, 0.08727559f, -0.19206177f, -0.08090372f, 
    0.12804049f, -0.03164335f, -0.31711105f, -0.00768793f, -0.27010128f, -0.65033841f, 0.00896540f, -0.38736093f, 
    -0.11034672f, -0.12051497f, 0.13439421f, -0.18737580f, -0.03959588f, 0.09801225f, -0.15709561f, -0.24244700f, 
    -0.06883192f, -0.06428687f, 0.03454543f, 0.20813641f, -0.07172539f, -0.16412902f, 0.18895558f, 0.10180987f, 
    0.25575531f, 0.02612568f, 0.11041854f, 0.44026572f, 0.29102615f, 0.40989766f, -0.05875311f, -0.14883006f, 
    0.02137844f, -0.18215989f, 0.00837628f, -0.03284536f, 0.40852872f, -0.15264197f, 0.16153301f, 0.22181609f, 
    0.07990502f, -0.04761133f, 0.17277031f, -0.00807430f, -0.15727919f, -0.03403215f, 0.01613673f, 0.23521644f, 
    0.02572595f, 0.05038407f, 0.36097744f, -0.32768178f, 0.36796162f, -0.14160118f, -0.37402076f, 0.27615243f, 
    0.24147765f, -0.14203818f, 0.27263469f, -0.24848524f, 0.06622235f, 0.18848138f, -0.10298418f, 0.15907118f, 
    -0.01233179f, -0.11904769f, 0.35278547f, -0.17149715f, -0.03636092f, 0.13538872f, -0.30865723f, 0.03543086f, 
    0.00258577f, -0.00733189f, -0.01508577f, -0.16296773f, 0.15300784f, 0.04463994f, -0.13297465f, 0.08610953f, 
    0.12037609f, 0.03224041f, -0.21040729f, 0.37079528f, -0.52745444f, 0.10151698f, 0.52235919f, -0.27007902f, 
    -0.21088080f, 0.23671566f, 0.03153833f, 0.38439479f, 0.12106765f, 0.21767187f, 0.12420950f, 0.09922560f, 
    -0.28550640f, -0.07451309f, -0.21067616f, -0.09493253f, 0.53808212f, 0.21039827f, -0.15047882f, 0.27044725f, 
    -0.10222468f, 0.03968423f, 0.04576612f, 0.15146181f, 0.10839830f, -0.19215652f, -0.11641872f, -0.14417021f, 
    -0.06411428f, 0.01421409f, -0.11219478f, -0.15821387f, -0.00747169f, 0.04535666f, -0.14318995f, -0.20785491f, 
    -0.18058309f, -0.06503627f, 0.05510721f, -0.07316493f, 0.02750093f, 0.09818201f, -0.15800883f, 0.13329037f, 
    0.11797922f, -0.17389598f, -0.00193160f, 0.03113647f, -0.16349638f, -0.06378395f, 0.09828585f, -0.06378397f, 
    0.03801851f, 0.09662253f, 0.01104804f, 0.10992739f, -0.02099280f, 0.08854799f, -0.22791973f, 0.01254283f, 
    0.09452650f, 0.08719765f, 0.15167768f, 0.26723194f, -0.22270457f, -0.10702305f, 0.31181726f, -0.06921317f, 
    0.00631282f, 0.38031030f, -0.09811854f, -0.08681329f, 0.21911447f, 0.15967818f, -0.04577216f, -0.30930984f, 
    0.26374960f, -0.19534762f, 0.03306180f, -0.36375242f, 0.49649668f, -0.19827098f, 0.08147397f, 0.01239946f, 
    0.38280475f, -0.14343750f, -0.02440454f, 0.14573725f, 0.03285820f, 0.34369564f, -0.10926703f, -0.26706874f, 
    0.11284702f, -0.08169639f, -0.26301861f, 0.20972501f, 0.07662308f, 0.01272788f, -0.04251961f, 0.16151889f, 
    0.04458106f, 0.48048413f, -0.15933134f, 0.16574450f, -0.23116392f, 0.25751787f, 0.09989846f, 0.66488910f, 
    -0.45428041f, -0.09965570f, 0.00675880f, 0.02305727f, 0.42119661f, -0.27307928f, -0.12596929f, -0.38897374f, 
    -0.11763304f, -0.00134046f, 0.11179011f, 0.30670536f, -0.09221970f, 0.18886660f, -0.11815945f, 0.03619059f, 
    -0.34234816f, -0.02022597f, -0.13369210f, -0.00367132f, -0.09163564f, 0.14469872f, -0.24626145f, -0.19428836f, 
    0.13495328f, 0.08424306f, 0.28270105f, 0.19087665f, -0.32317758f, 0.09027852f, 0.21263427f, 0.46988964f, 
    -0.29132867f, 0.24958299f, 0.19880462f, 0.04713593f, 0.17893058f, 0.19762418f, -0.18358746f, -0.14508668f, 
    0.06282786f, 0.07078468f, -0.07136913f, -0.18384555f, 0.03623933f, -0.17910033f, 0.08953723f, 0.15430729f, 
    0.12500757f, 0.03870763f, -0.08140488f, -0.05227889f, -0.01134682f, -0.16409706f, 0.11805374f, -0.03559164f, 
    -0.12661195f, 0.14735161f, -0.10318626f, 0.04647179f, -0.16365704f, 0.08208761f, 0.15854882f, -0.06256883f, 
    -0.18369344f, -0.09979916f, -0.16088668f, 0.05105318f, -0.02176563f, 0.13324361f, -0.09674201f, -0.16470358f, 
    0.25771981f, 0.12501039f, 0.15796265f, -0.18094327f, 0.08710623f, 0.00508845f, -0.10798091f, 0.03327599f, 
    -0.17237705f, -0.12456410f, -0.08442746f, 0.05445937f, -0.25348794f, 0.09370205f, 0.34083283f, -0.07289906f, 
    -0.14188190f, 0.27496842f, 0.11524113f, 0.13260326f, -0.06734531f, 0.04499792f, 0.22780222f, -0.25669917f, 
    0.07612224f, 0.01713887f, -0.22435664f, -0.00770208f, 0.58686310f, 0.17502610f, 0.11711906f, 0.05562690f, 
    -0.19824405f, -0.09901553f, 0.09464204f, -0.11203340f, 0.11039263f, -0.25668219f, 0.18236625f, -0.06678502f, 
    -0.15161516f, 0.11250530f, -0.05320367f, 0.25870538f, -0.30098221f, -0.16907029f, 0.36457300f, -0.05799626f, 
    0.44943321f, -0.09301791f, 0.07887235f, 0.48821181f, -0.00388381f, 0.33516136f, 0.02640375f, 0.03136925f, 
    -0.00414650f, 0.07057963f, 0.01708368f, -0.21583673f, 0.13822524f, 0.11781844f, -0.19598840f, 0.24239050f, 
    0.20279193f, 0.14751844f, 0.01528127f, 0.06744376f, 0.13332042f, -0.13740747f, -0.02492269f, 0.03772256f, 
    0.08144995f, -0.14506328f, 0.08307389f, 0.06321274f, 0.15970407f, 0.10217745f, -0.14222889f, 0.35606930f, 
    0.21048762f, 0.11119670f, -0.02816828f, 0.25583023f, -0.15635343f, -0.23546562f, 0.18475050f, 0.51844901f, 
    -0.34296712f, 0.27937374f, 0.05040928f, 0.52412713f, -0.62778997f, -0.13652459f, -0.07680000f, 0.08673541f, 
    -0.40105563f, -0.13523552f, 0.11719288f, 0.14048655f, -0.06114949f, 0.00057672f, 0.00248013f, -0.01678302f, 
    0.43726191f, 0.05316921f, -0.08809561f, 0.15983649f, -0.08982468f, 0.12620673f, 0.11674622f, -0.42333168f, 
    -0.21966928f, -0.40933058f, 0.01617720f, -0.44218099f, 0.54051268f, -0.19516195f, -0.25398722f, -0.15854661f, 
    -0.20268387f, -0.05252339f, 0.14761607f, -0.14051136f, -0.24000737f, 0.20807220f, 0.15287381f, -0.13163005f, 
    -0.24668473f, -0.08979582f, -0.06246593f, 0.05701951f, -0.16073230f, -0.20535082f, 0.31432500f, 0.13734321f, 
    -0.39090204f, 0.04266504f, -0.05079666f, 0.24462134f, -0.18109548f, -0.12891670f, 0.31877509f, -0.13397531f, 
    -0.20895296f, -0.19836423f, -0.01727177f, 0.18984424f, 0.04130496f, 0.06024404f, 0.23077989f, -0.07289498f, 
    0.30711976f, 0.20865449f, -0.02060165f, -0.16154152f, 0.21804906f, 0.25680450f, 0.03755423f, 0.35782161f, 
    0.03001487f, 0.08580529f, 0.02978337f, -0.11287853f, 0.14973149f, -0.11820074f, -0.01352992f, -0.00644556f, 
    0.37388253f, -0.07585441f, -0.00708972f, -0.04060439f, 0.14428236f, -0.04380760f, 0.40755153f, 0.20058504f, 
    0.15996911f, 0.26220194f, -0.06618187f, 0.19556005f, 0.25488874f, 0.18245994f, -0.21890147f, 0.07311385f, 
    0.22650966f, -0.13765280f, 0.20789917f, -0.32841870f, -0.17832318f, -0.20850424f, -0.22629270f, 0.02999221f, 
    -0.07024213f, -0.11392156f, 0.06645938f, 0.21586522f, 0.04437037f, 0.19676125f, -0.01186311f, -0.27805963f, 
    0.45323196f, 0.08925521f, -0.04547496f, 0.23316213f, 0.00158387f, 0.11685072f, 0.26431370f, -0.30145180f, 
    0.03012776f, -0.15930812f, 0.10359798f, -0.06673329f, 0.39726424f, -0.19537795f, -0.01054757f, -0.30898967f, 
    0.05701377f, 0.01478564f, 0.17104062f, -0.18688931f, 0.56589419f, 0.46039951f, 0.35388333f, -0.11181552f, 
    -0.02383132f, -0.16794516f, 0.12190690f, 0.23289323f, -0.05553897f, -0.04300182f, -0.01062403f, -0.04740557f, 
    0.25345957f, -0.03232164f, 0.16154608f, 0.25728330f, -0.00273148f, -0.10041335f, 0.03513468f, -0.23835118f, 
    -0.16496100f, 0.08203857f, 0.24206281f, 0.04353578f, 0.02482133f, -0.07225677f, -0.15733591f, -0.54309881f, 
    -0.00002858f, 0.05605407f, 0.14255740f, -0.47220159f, 0.28651994f, 0.47526872f, 0.07013242f, 0.21945792f, 
    -0.24262679f, -0.11344732f, 0.06687714f, 0.11201018f, 0.10144675f, -0.42214236f, 0.30558780f, 0.08916783f, 
    -0.36435845f, 0.12497871f, 0.12843543f, 0.18245777f, -0.08608523f, -0.00988620f, 0.11477101f, 0.06610420f, 
    0.29773504f, -0.45144081f, 0.27415869f, 0.37124941f, -0.03732292f, -0.00918848f, 0.05626045f, -0.33427063f, 
    0.08440746f, 0.07350147f, 0.33745283f, -0.17528819f, -0.24172568f, 0.41385630f, -0.34074685f, 0.50761557f, 
    0.30067542f, 0.06694694f, -0.15324116f, -0.20606418f, 0.18713146f, -0.04183712f, 0.10213161f, 0.14936699f, 
    -0.20458314f, -0.15786593f, 0.10113845f, 0.28399265f, -0.01306874f, -0.04414214f, 0.25190350f, 0.32906565f, 
    0.14138274f, 0.28035069f, 0.10323514f, 0.26077682f, -0.40032229f, 0.14112897f, 0.20940100f, -0.31184825f, 
    0.29337493f, -0.19843556f, -0.08503038f, -0.16151661f, -0.07265379f, -0.15339562f, -0.21734779f, 0.29727712f, 
    0.02748167f, 0.00635527f, 0.14434917f, 0.11227737f, 0.03061692f, 0.02512608f, 0.15648696f, -0.02645609f, 
    0.25012499f, 0.16950811f, 0.15123628f, 0.16524017f, -0.01273755f, -0.15755725f, 0.53262168f, 0.13450772f, 
    0.18234338f, -0.24080263f, -0.17712951f, -0.48598072f, 0.24173018f, 0.12119451f, 0.04298868f, -0.58414865f, 
    0.06530783f, -0.17438386f, 0.01413146f, -0.26518580f, -0.68877333f, 0.04066261f, 0.04192885f, -0.11008049f, 
    0.27519396f, 0.11833219f, 0.00184055f, -0.01962645f, 0.04188253f, -0.19270454f, 0.29694131f, -0.05226275f, 
    0.46824124f, 0.13035332f, 0.30040523f, -0.00261454f, 0.31572056f, -0.10530908f, 0.19127075f, 0.31345171f, 
    0.14692917f, 0.20413160f, -0.18169582f, 0.00538625f, -0.07852206f, 0.10801909f, -0.12357671f, -0.29763886f, 
    -0.09915754f, -0.31005710f, 0.36920410f, -0.23158884f, -0.15269674f, 0.03469938f, -0.31771019f, 0.23722100f, 
    0.27074564f, -0.06137037f, 0.06134718f, -0.14649495f, 0.17852619f, -0.32285285f, 0.39477104f, 0.34369713f, 
    0.18799953f, 0.01906342f, 0.31631967f, 0.37130821f, 0.26356038f, 0.07517149f, 0.48173615f, 0.05051476f, 
    0.18867192f, 0.02138860f, 0.01314840f, -0.12737775f, -0.04014453f, -0.26008794f, 0.11249703f, -0.38785079f, 
    -0.04834223f, -0.11892502f, 0.01365120f, -0.04676636f, -0.06935583f, 0.17263381f, -0.08485802f, 0.48812973f, 
    0.33535120f, -0.14069206f, -0.00746095f, 0.33268160f, 0.01191346f, 0.28940737f, -0.08100379f, -0.25726038f, 
    0.05079800f, -0.08389801f, -0.14915778f, 0.01354469f, 0.19859874f, -0.10004932f, -0.23338962f, -0.08345080f, 
    -0.30596361f, 0.08966059f, 0.06385104f, -0.51532996f, -0.19088827f, -0.44522965f, 0.22819790f, -0.17179196f, 
    0.18990025f, 0.19352581f, -0.16600451f, -0.03864741f, 0.29236767f, 0.25758955f, 0.31528765f, 0.27925447f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19307041f, 0.05733202f, 0.06086369f, -0.15822360f, 0.24257311f, 0.25747195f, 0.07740410f, -0.04917623f, 
    0.37222618f, -0.07302384f, -0.33545199f, 0.11087713f, 0.00894270f, 0.06921486f, -0.04805626f, 0.15269753f, 
    0.25894067f, -0.09006628f, 0.24551448f, 0.04139399f, 0.26387578f, -0.26068404f, 0.23168203f, -0.02983386f, 
    0.24353394f, 0.06658694f, 0.23103221f, 0.02387336f, -0.15183777f, 0.05275865f, 0.15678938f, 0.35807431f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.65911597f, -0.07901657f, -0.01362819f, 0.16908962f, 0.51025712f, -0.06807848f, 0.12394008f, -0.01815137f, 
    0.04168953f, -0.25789768f, -0.43335587f, 0.54711461f, -0.65169120f, -0.03144557f, -0.37699354f, -0.13294777f, 
    -0.02255328f, 0.10100424f, -0.03828501f, -0.13355571f, 0.15059929f, -0.21859181f, -0.16845873f, -0.01640057f, 
    -0.31430370f, -0.03708755f, 0.12374008f, 0.29438984f, -0.13278048f, 0.44298714f, 0.13016701f, 0.20508669f, 
    -0.13417466f, 0.09593999f, 0.00972825f, 0.07707460f, -0.39451614f, -0.36356601f, -0.05101678f, -0.40676075f, 
    0.01262780f, -0.11583817f, 0.10084495f, 0.21310812f, 0.37504628f, 0.11111978f, 0.26646408f, 0.31039187f, 
    0.25012061f, 0.00883451f, 0.17801794f, 0.05415412f, -0.24619171f, 0.65110934f, 0.03578463f, 0.10148638f, 
    0.25321257f, 0.02319056f, -0.19338669f, -0.16147918f, -0.11554863f, 0.18409106f, -0.09394176f, 0.15470369f, 
    -0.10948162f, -0.05944638f, 0.10896366f, 0.12356213f, 0.08719460f, -0.00554457f, -0.06172914f, -0.09213619f, 
    -0.11004241f, -0.10257527f, -0.03076859f, -0.05519987f, 0.08045494f, 0.11723978f, -0.01730967f, 0.08529633f, 
    -0.12313975f, -0.14366542f, 0.08343196f, -0.14503247f, -0.09185195f, 0.13198645f, -0.07853798f, -0.10050207f, 
    -0.05858553f, 0.07702281f, 0.01814517f, -0.12865315f, 0.09425157f, -0.11315556f, -0.16528101f, -0.15995982f, 
    0.09542661f, 0.04212569f, -0.07251836f, -0.14353475f, -0.17371382f, -0.07489990f, -0.04221420f, -0.10620686f, 
    -0.14743285f, 0.00411958f, 0.01448826f, 0.08973259f, -0.19539717f, 0.01643521f, 0.08670510f, 0.15556173f, 
    -0.07747319f, -0.08114171f, 0.46735597f, 0.03737007f, -0.13646297f, -0.01301242f, -0.37194973f, 0.18343814f, 
    0.07755119f, -0.19264834f, -0.24995871f, 0.04157864f, -0.28915051f, -0.34749854f, -0.19069895f, -0.07244492f, 
    -0.09578244f, -0.11862757f, -0.09530378f, 0.00092740f, 0.11968223f, 0.01189416f, -0.01854546f, 0.04934996f, 
    -0.09867763f, -0.10182871f, 0.07792735f, -0.13421780f, -0.07769282f, 0.02357113f, 0.02915270f, -0.03213320f, 
    -0.09597392f, 0.01096046f, -0.10845394f, -0.05180475f, -0.14786553f, 0.04862741f, 0.08556422f, -0.07905615f, 
    -0.09427472f, -0.08209483f, -0.11680523f, -0.13178925f, -0.16262649f, 0.00441623f, -0.17210799f, 0.12790364f, 
    0.30507377f, -0.06452724f, -0.05991711f, -0.04636284f, 0.06121376f, 0.01234136f, -0.20126773f, -0.05563124f, 
    0.17937315f, -0.02721168f, 0.30335346f, -0.16903324f, 0.35565645f, -0.12849461f, 0.15241577f, -0.38282198f, 
    -0.12492734f, 0.05185245f, 0.39063689f, 0.68941182f, -0.01175769f, -0.58373290f, 0.51854193f, -0.04218949f, 
    0.20775281f, 0.06314679f, 0.33383986f, 0.17800853f, -0.18207894f, 0.08143561f, 0.43235725f, -0.02931173f, 
    -0.06627656f, -0.15859251f, -0.09626415f, 0.04865926f, 0.46650115f, -0.21248691f, -0.15015167f, 0.51431298f, 
    0.16041566f, 0.14651908f, -0.77247161f, -0.04666990f, -0.29392433f, 0.09738244f, -0.30819511f, -0.28781512f, 
    -0.26732284f, 0.12652442f, -0.20791563f, -0.66036618f, 0.20770429f, 0.85584235f, 0.01351842f, -0.32135153f, 
    0.26551044f, 0.19953050f, 0.16064909f, -0.12277429f, 0.28295231f, 0.17155181f, 0.52497309f, 0.27083805f, 
    -0.12050756f, -0.06646149f, 0.08925074f, -0.18069524f, 0.36100867f, -0.55789649f, -0.00565874f, 0.18312712f, 
    0.05450134f, 0.08685700f, -0.35496584f, 0.20626555f, -0.17492290f, 0.06120133f, -0.01268212f, -0.33042312f, 
    -0.07332559f, -0.01135736f, -0.06355481f, 0.10950705f, -0.35677695f, 0.07123774f, 0.19696470f, 0.18787284f, 
    0.15315229f, 0.23446564f, 0.39967492f, 0.24523160f, 0.59426087f, 0.34418157f, 0.39825943f, -0.02633659f, 
    0.44076034f, -0.07374190f, -0.17904188f, -0.08292069f, -0.22418687f, 0.30002013f, 0.42309836f, -0.10495764f, 
    0.15931617f, -0.55524361f, -0.11194143f, -0.14951232f, 0.46192688f, -0.12348191f, -0.18081823f, -0.13109031f, 
    0.35837039f, -0.12201492f, 0.12524302f, 0.34373772f, -0.22681625f, 0.55563945f, 0.06536575f, -0.49741521f, 
    0.36694780f, 0.27476341f, 0.26945943f, -0.15919554f, -0.06702600f, -0.11934554f, 0.06685729f, 0.11723216f, 
    -0.02927389f, -0.08398722f, -0.01423413f, 0.03527908f, -0.15004903f, 0.58009648f, -0.06321583f, -0.13555296f, 
    0.08898288f, -0.10896430f, 0.14573359f, -0.38086060f, 0.51583868f, -0.00115665f, -0.22011042f, -0.06935696f, 
    0.19741213f, 0.08361852f, 0.32586068f, 0.53390330f, -0.08462156f, -0.92583895f, 0.34546724f, -0.22009453f, 
    -0.26618204f, 0.16630718f, 0.43528512f, 0.39848787f, -0.08059959f, -0.16061738f, 0.19698168f, 0.01833671f, 
    -0.06465816f, -0.09789161f, 0.11096960f, 0.15676945f, -0.21384965f, 0.23762348f, -0.06015173f, -0.17655814f, 
    0.21404420f, 0.02843204f, -0.15741237f, -0.50416434f, 0.29348254f, 0.01190299f, 0.24096289f, 0.18936203f, 
    -0.16488725f, 0.12429799f, 0.49274683f, -0.09281342f, -0.22158244f, -0.73150927f, -0.01140225f, -0.06224451f, 
    0.08603735f, -0.02968275f, -0.25818092f, 0.34251875f, 0.00005859f, 0.04565180f, 0.11364289f, 0.36559132f, 
    0.13391703f, -0.15869829f, -0.08526511f, 0.04219158f, 0.05963543f, -0.06835568f, 0.30823243f, 0.33054617f, 
    0.01877089f, 0.06816483f, 0.12609445f, -0.06163610f, 0.69947809f, 0.16160922f, -0.09452087f, 0.36572334f, 
    -0.16733702f, 0.08648916f, 0.10070813f, 0.02627775f, -0.12785541f, -0.15451574f, -0.06579622f, 0.03238427f, 
    -0.50203270f, 0.07538453f, -0.42297980f, 0.12451960f, -0.27924961f, 0.16039211f, -0.28952423f, -0.06126182f, 
    -0.31172028f, 0.14515604f, -0.05533791f, -0.17288165f, 0.53351557f, -0.07703233f, 0.14667928f, 0.41722718f, 
    0.13483956f, 0.05005646f, -0.07105006f, 0.16393512f, -0.54266393f, 0.10624131f, 0.12899047f, -0.24902411f, 
    -0.19289507f, 0.06452864f, -0.01224910f, -0.06776024f, -0.05333625f, -0.51117438f, 0.05004439f, 0.25328484f, 
    -0.25479198f, 0.19120339f, 0.29395908f, 0.34403378f, -0.17664494f, 0.40853110f, 0.28273055f, -0.16888776f, 
    0.21222937f, 0.08358599f, -0.01801136f, -0.08151894f, 0.05689969f, 0.20476080f, 0.33858293f, 0.12862958f, 
    0.18071589f, -0.05785054f, 0.07859641f, -0.18496554f, -0.08308409f, 0.12391805f, 0.31247437f, 0.42905110f, 
    0.20185477f, 0.12326464f, 0.20638378f, -0.57087630f, 0.00702044f, -0.10057078f, -0.23673449f, -0.11556610f, 
    -0.01863075f, 0.00962488f, -0.68514991f, 0.11669230f, -0.60613972f, 0.00210414f, -0.09443134f, 0.39484957f, 
    0.24960832f, -0.03086725f, -0.05782630f, 0.20716602f, -0.10925971f, 0.11930218f, 0.46793655f, 0.36178386f, 
    0.17202936f, -0.05681797f, -0.31721652f, 0.00682729f, -0.07112554f, 0.10368498f, 0.17504603f, 0.28343073f, 
    0.03613353f, 0.09644587f, 0.14990276f, -0.71660507f, 0.12806921f, -0.16997898f, -0.23683429f, -0.20552227f, 
    0.22698183f, 0.17866109f, -0.23160364f, -0.06174677f, -0.08554377f, -0.11396515f, -0.33630607f, 0.51121384f, 
    0.01312268f, -0.04383429f, 0.01409676f, 0.08452100f, -0.12082752f, 0.16990528f, -0.16466781f, -0.22789337f, 
    0.01698542f, -0.31805471f, 0.16630152f, -0.08765520f, 0.33249900f, -0.02955977f, 0.25197753f, 0.23320886f, 
    -0.09421267f, -0.09752656f, 0.07963318f, 0.49885830f, 0.16570711f, 0.18081377f, -0.14379272f, 0.29619479f, 
    0.03984598f, 0.12633459f, 0.07113606f, 0.23117884f, 0.27179459f, 0.24223496f, 0.30385995f, -0.38375723f, 
    -0.39163694f, -0.07932836f, 0.14026462f, -0.16681996f, 0.24353214f, 0.00740512f, 0.21316181f, 0.08017919f, 
    0.16486089f, 0.13832174f, -0.09503345f, 0.03256248f, -0.15320641f, -0.07306885f, 0.00890370f, 0.09890199f, 
    -0.02115607f, 0.04730647f, 0.12311276f, -0.30038694f, 0.01576573f, -0.28126726f, 0.18596877f, -0.27318221f, 
    -0.19069158f, -0.10742259f, 0.15963215f, 0.41860703f, -0.25830564f, 0.00772458f, 0.24444328f, 0.48131889f, 
    -0.10206992f, 0.13836840f, 0.13478360f, 0.11203402f, 0.03081339f, -0.08521464f, -0.00043264f, 0.05399039f, 
    -0.14541753f, -0.15830187f, -0.14553210f, 0.01333487f, -0.02908266f, 0.09277231f, 0.06285853f, -0.09227366f, 
    0.01713975f, -0.03936815f, 0.03168043f, -0.04719289f, -0.07730924f, 0.07103521f, -0.09388733f, 0.03000916f, 
    -0.03552241f, -0.22168760f, -0.19694656f, 0.02522258f, 0.09664683f, -0.17821464f, 0.04385773f, -0.09770513f, 
    0.45369288f, 0.07088041f, -0.04769952f, 0.08022729f, -0.18552476f, 0.36226818f, -0.08288060f, -0.07911689f, 
    0.09449421f, 0.10073876f, 0.02204579f, -0.39913711f, 0.82380104f, -0.02864344f, 0.09077181f, 0.30919838f, 
    0.02982763f, 0.07445812f, 0.27547777f, 0.23638569f, 0.11234945f, 0.00697079f, 0.27634379f, -0.18623674f, 
    -0.00101444f, -0.02119122f, -0.09157835f, 0.20126557f, 0.08878444f, -0.25645497f, 0.16387823f, -0.07359585f, 
    -0.14348927f, 0.17340958f, 0.13918209f, -0.04758643f, 0.33908218f, 0.10236360f, 0.26607785f, 0.05299919f, 
    0.15185751f, 0.18578129f, 0.11591365f, 0.17041725f, -0.48816907f, -0.00910905f, -0.12907542f, 0.05985216f, 
    0.19361651f, 0.07535339f, -0.00787859f, -0.38846034f, 0.27242675f, -0.31823507f, -0.21789156f, 0.00426235f, 
    -0.07509391f, -0.11944251f, -0.16270936f, -0.06137769f, -0.35352060f, 0.11099707f, 0.17335118f, 0.25135151f, 
    -0.00019205f, -0.14095637f, -0.00546858f, 0.02121430f, 0.17457214f, 0.28068697f, 0.17651013f, 0.24218838f, 
    0.13023871f, 0.02337741f, -0.12951663f, 0.23315440f, -0.24988306f, 0.08948305f, -0.34105775f, -0.24304526f, 
    0.25493243f, 0.16329455f, -0.35576731f, 0.05266830f, 0.39309698f, 0.20809944f, 0.13895042f, -0.34353015f, 
    0.14374633f, 0.00927994f, 0.30646893f, -0.25575933f, -0.10684315f, -0.12091945f, 0.17209679f, 0.15506567f, 
    0.17433459f, 0.14998913f, -0.12356481f, 0.00782550f, -0.16462906f, 0.54786432f, 0.23135221f, -0.04559529f, 
    0.08677240f, -0.29369971f, 0.09104202f, -0.09153461f, 0.12149734f, -0.00014498f, -0.14780052f, 0.22503963f, 
    0.30778140f, -0.07789037f, -0.06268527f, 0.46467966f, 0.13739349f, -0.43494648f, -0.07729177f, 0.12025777f, 
    0.09486402f, 0.06418163f, 0.29064971f, 0.15354118f, -0.07827339f, 0.19725721f, -0.25919271f, -0.10381307f, 
    0.12951098f, 0.02797007f, 0.08809084f, 0.20188400f, 0.10271909f, 0.40725106f, 0.21486880f, 0.38865906f, 
    -0.23152763f, 0.22165023f, -0.01266686f, 0.12320878f, 0.48362580f, -0.12323800f, 0.05228061f, 0.25133887f, 
    0.00909643f, 0.14844115f, -0.19556813f, 0.14771336f, 0.20865558f, -0.14388888f, -0.17249042f, 0.08118122f, 
    -0.45507404f, -0.24134976f, -0.13225101f, -0.15105276f, 0.27084047f, -0.21883522f, -0.42688242f, 0.06052377f, 
    0.14976473f, -0.10948139f, 0.04201825f, 0.24134505f, 0.28230646f, 0.27223018f, 0.39605519f, -0.21925229f, 
    0.06619805f, -0.22961430f, -0.25320935f, -0.13224886f, 0.26482707f, -0.05792896f, -0.38913420f, 0.38541335f, 
    0.33379504f, 0.04841521f, 0.24337545f, -0.38394171f, 0.43544465f, 0.35479417f, -0.05151385f, -0.49972397f, 
    0.10221445f, 0.14685749f, -0.13338713f, -0.09333892f, -0.37155932f, -0.06215001f, -0.09243202f, 0.47765347f, 
    -0.14452046f, -0.09259386f, 0.17349978f, 0.08129606f, 0.19746809f, -0.20640472f, -0.11503245f, 0.24461710f, 
    -0.20024450f, -0.44231617f, 0.08934544f, -0.19600341f, -0.00247219f, 0.13171181f, 0.00511324f, 0.33105251f, 
    -0.36694202f, 0.13886753f, -0.29487392f, -0.11811204f, 0.16757433f, 0.47949561f, -0.23040313f, 0.45371360f, 
    0.19349977f, -0.08709627f, -0.18029758f, 0.07319687f, 0.22211017f, 0.43313029f, 0.29052120f, -0.04108870f, 
    -0.04601535f, 0.08970495f, -0.14708160f, -0.09779257f, -0.15922245f, -0.09065313f, 0.01084515f, -0.13830370f, 
    0.01333375f, -0.07990526f, 0.07005373f, -0.14274101f, 0.04954839f, 0.00359955f, -0.07197091f, 0.14809097f, 
    -0.06310531f, -0.11935619f, -0.14763220f, -0.13713761f, -0.11653585f, -0.09652850f, -0.02195504f, 0.05349853f, 
    0.10119935f, 0.01980374f, -0.14582674f, -0.03575737f, -0.02103024f, -0.13883118f, -0.07345984f, -0.13646039f, 
    0.13411008f, 0.10065371f, -0.16417192f, 0.15292864f, -0.42523521f, 0.06264040f, -0.28591177f, 0.16093373f, 
    0.06302210f, -0.06009860f, -0.22264197f, -0.45925486f, 0.12683995f, -0.15353458f, 0.19638459f, -0.04143612f, 
    -0.16762878f, -0.10468449f, 0.17248289f, -0.34489813f, -0.32533643f, 0.41228440f, -0.03230425f, -0.04776702f, 
    0.57617879f, 0.34431612f, -0.07525221f, 0.07419241f, 0.39382035f, 0.12650949f, 0.17793420f, 0.29259789f, 
    0.13530840f, 0.08599877f, 0.00699286f, -0.10433918f, -0.15558843f, 0.11947444f, -0.18672410f, -0.16818076f, 
    -0.11108112f, -0.15925525f, -0.16586418f, 0.07710133f, 0.06422339f, -0.01337773f, -0.05829591f, -0.04520897f, 
    -0.16070130f, 0.05043637f, -0.00799908f, -0.01285061f, 0.09800318f, -0.05928260f, -0.14896943f, 0.13876982f, 
    -0.20111804f, 0.03198371f, -0.02019064f, -0.04926688f, 0.00756455f, 0.12517993f, -0.18084939f, -0.09907770f, 
    -0.65553588f, -0.13152501f, 0.14967631f, -0.01427611f, 0.29909238f, 0.19475812f, 0.03729001f, 0.04111252f, 
    0.05269198f, 0.07546388f, -0.37064162f, 0.34114867f, -0.15512232f, -0.03729532f, -0.13168606f, 0.26734257f, 
    0.24189536f, 0.16593778f, 0.02650271f, 0.04809546f, 0.20548548f, -0.28885254f, -0.52889854f, -0.03083584f, 
    -0.51282054f, 0.02229474f, -0.18001735f, 0.41256353f, 0.00151482f, 0.21075889f, 0.19869137f, -0.14685009f, 
    -0.31782082f, -0.15958256f, -0.00611442f, -0.16177925f, 0.19457401f, 0.05067833f, -0.11347253f, -0.15689541f, 
    -0.25532436f, -0.35302851f, 0.02628791f, 0.39809868f, -0.25108993f, 0.16320507f, -0.19713758f, 0.44311681f, 
    0.16167749f, -0.14356993f, 0.05206618f, 0.24986142f, 0.27270582f, -0.28345633f, -0.56439316f, 0.13090456f, 
    -0.03328590f, 0.11049986f, 0.04971193f, 0.09868002f, 0.05614728f, 0.37937835f, 0.23767757f, -0.35948589f, 
    0.01816384f, -0.06199044f, -0.00728414f, -0.15372786f, 0.02183769f, -0.36540455f, 0.22909744f, 0.36220899f, 
    0.23920417f, -0.20939909f, -0.06339453f, 0.04372928f, -0.17771004f, -0.07087507f, 0.35112566f, -0.02050189f, 
    0.00606585f, -0.09650021f, 0.02874886f, -0.22466870f, -0.32854941f, -0.06850433f, 0.25602978f, -0.16237395f, 
    0.46670833f, 0.47674978f, 0.11993764f, 0.04513020f, 0.31355959f, 0.16259947f, 0.13954678f, 0.49057686f, 
    0.00581198f, 0.12392163f, -0.07338843f, 0.03971002f, 0.42102554f, 0.54103595f, 0.40741298f, 0.25218403f, 
    0.31497422f, 0.17724288f, -0.33081695f, -0.23966578f, 0.19162397f, 0.11464167f, -0.37868384f, 0.09946970f, 
    0.06275599f, 0.14433880f, 0.14559202f, 0.01755754f, 0.34780407f, -0.05495254f, -0.04410386f, -0.37745801f, 
    -0.03464465f, -0.14301789f, 0.07993842f, 0.00773815f, -0.29500943f, -0.13119541f, 0.03557534f, 0.34363231f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.26227698f, 0.33022299f, 0.03974311f, 0.17138225f, -0.19433016f, 0.05249797f, 0.15983073f, -0.01297355f, 
    0.24181652f, 0.14779647f, 0.13770953f, -0.03268756f, 0.11055737f, -0.06502917f, 0.04173656f, -0.15770769f, 
    0.22970508f, -0.21026640f, 0.00142487f, -0.12280832f, 0.33618623f, 0.07280891f, 0.09681686f, 0.33878711f, 
    -0.13740467f, 0.01230322f, 0.05419779f, -0.02302047f, -0.05077206f, 0.20935935f, 0.26054218f, 0.22451194f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.41437489f, 0.18786779f, 0.07888425f, -0.32569477f, 0.01145284f, 0.07742009f, 0.09799119f, 0.14488518f, 
    -0.03126568f, -0.36557731f, -0.06899134f, -0.54152811f, -0.18831080f, -0.49728402f, -0.44000876f, 0.19457367f, 
    -0.73748684f, -0.11347502f, 0.17604944f, -0.08666573f, -0.69239420f, -0.45501551f, -0.00549290f, -0.35126612f, 
    0.37074521f, -0.15872729f, 0.27606604f, -0.13077065f, -0.18942462f, 0.02464660f, 0.10608601f, -0.85659742f, 
    -0.69411200f, 0.12411989f, -0.04231044f, -0.13199164f, 0.09471122f, 0.13878991f, -0.37823302f, -0.15316099f, 
    0.34050006f, 0.49256212f, 0.08568347f, 0.15251015f, -0.31686386f, -0.30492911f, -0.13636608f, 0.08550394f, 
    -0.18670347f, -0.03789712f, 0.29490903f, -0.38004467f, -0.13470235f, 0.16806497f, 0.09833972f, 0.02813544f, 
    -1.02778828f, -0.12111326f, 0.19745269f, 0.01638433f, -0.17050733f, -0.08992268f, 0.06117970f, -0.09490140f, 
    0.34052175f, 0.03554052f, -0.02175037f, 0.05885530f, 0.14311503f, 0.15380174f, 0.18044932f, 0.12927662f, 
    0.19516602f, 0.15979707f, -0.31749707f, -0.37684521f, 0.15684688f, -0.27508330f, -0.40701321f, -0.39775714f, 
    0.30808255f, -0.19004126f, -0.09518361f, -0.02429068f, 0.17416798f, -0.16559605f, 0.08641101f, 0.15241973f, 
    -0.88630325f, -0.03807444f, -0.82473254f, -0.16627483f, -0.17502141f, -0.40325096f, -0.10859387f, 0.03122625f, 
    -0.11572598f, -0.15994786f, 0.08707463f, -0.21774299f, -0.15607145f, -0.13435528f, 0.24007764f, 0.25169203f, 
    0.04386543f, -0.71816939f, -0.52562368f, -0.51749992f, 0.24583288f, -0.47544020f, 0.06508861f, -0.24952863f, 
    -0.22131689f, -0.09344537f, -0.43927205f, -0.08216145f, 0.35414672f, -0.16193070f, -0.74215579f, -0.27625370f, 
    -0.00241188f, -0.12232736f, 0.10108990f, 0.00031329f, -0.69328827f, -0.23640212f, 0.26008686f, -0.28997779f, 
    -0.65004516f, -0.42643252f, 0.01321270f, 0.16526607f, -0.06456825f, 0.26165554f, -0.08621617f, 0.14292850f, 
    -0.31140307f, 0.24103408f, 0.11475382f, -0.21039084f, 0.29540220f, -0.28577495f, -0.26267970f, 0.11930986f, 
    0.26029667f, -0.01661950f, 0.16300127f, -0.24032387f, -0.19479649f, -0.04135606f, -0.07645868f, -0.89121842f, 
    0.02295046f, -0.08406935f, 0.04468052f, 0.04449714f, 0.02712658f, -0.60909200f, 0.12179197f, -0.21819144f, 
    -0.86563420f, -0.30264068f, -0.05002943f, -0.40416777f, 0.10402360f, 0.11411032f, 0.16731493f, -0.23344584f, 
    0.02858154f, 0.02147730f, 0.15298088f, 0.05863217f, -0.03376475f, 0.07848005f, 0.11228907f, -0.17340650f, 
    0.24291740f, -0.14021805f, 0.22097480f, 0.25704885f, -0.09236719f, -0.16978835f, -0.07770338f, 0.12444101f, 
    0.17758328f, -0.15456940f, 0.17313540f, 0.14017141f, -0.70785511f, -0.24018484f, -0.04793139f, 0.17098649f, 
    0.48959151f, -0.38013977f, 0.11618634f, -0.13226573f, -0.03797446f, -0.25627276f, -0.58212686f, -0.47733581f, 
    -0.39428970f, 0.15123640f, -0.32160303f, -0.81399912f, 0.05369531f, -0.28049543f, -1.18240774f, 0.07771230f, 
    0.04275215f, 0.09636100f, -0.21589915f, 0.29562432f, 0.17376396f, 0.11157976f, 0.14385958f, 0.27923438f, 
    -0.04118306f, -0.14019921f, -0.17749910f, -0.17944382f, 0.46200541f, 0.36521766f, -1.33623862f, 0.16208561f, 
    -0.26525104f, 0.14164148f, -0.17420517f, 0.06541935f, 0.08340556f, 0.19840567f, -0.67705441f, 0.04823379f, 
    -0.03442381f, 0.01211127f, -0.19702721f, -0.11271539f, 0.14973801f, 0.06910815f, -0.49894977f, 0.29411930f, 
    -0.62868887f, 0.02267667f, -0.00514842f, -0.25233459f, -0.77696466f, 0.38702020f, -0.37798801f, -0.63258916f, 
    0.50218642f, 0.10781340f, -0.31173581f, -0.10246044f, -0.27626160f, 0.21657965f, 0.11257490f, -0.48754340f, 
    -0.47638196f, -0.24566074f, 0.07807636f, -0.44257250f, -0.01179942f, -0.38455057f, -0.03451535f, -0.96336102f, 
    0.15063892f, -0.29296431f, -0.32748482f, -0.04763947f, -0.58849943f, 0.32682830f, 0.41627169f, -0.52174091f, 
    -0.08429501f, 0.02528361f, 0.26257801f, -0.07144420f, 0.32131872f, 0.23269470f, 0.24739698f, 0.35429361f, 
    -0.10544614f, -0.15456907f, -0.60416293f, -0.07758250f, -0.43190277f, -0.25317514f, -0.31747827f, 0.19040269f, 
    0.18988520f, 0.13042697f, 0.00052469f, -0.65482742f, -0.03420960f, 0.03527060f, 0.30125922f, 0.17814001f, 
    -0.66210043f, -0.32904238f, -0.23520823f, -0.37893915f, 0.15682040f, -0.37807256f, -0.52604920f, 0.10283212f, 
    0.05738067f, 0.02455570f, -0.22969873f, 0.24429980f, 0.05636008f, -0.07811211f, -0.18492970f, -0.28256595f, 
    0.29754892f, 0.10290445f, -0.63611519f, -0.00977448f, 0.18982233f, 0.28472331f, -0.33494556f, -0.17992800f, 
    -0.08413506f, 0.61221415f, 0.00428933f, -0.62492746f, -0.02890554f, -0.11474115f, -0.88100421f, -0.59944463f, 
    -0.02675409f, -0.32351869f, 0.34675637f, -0.53160232f, -0.42501581f, 0.32118425f, 0.36305162f, -0.27202255f, 
    0.29982179f, -0.05457604f, -0.12375923f, 0.16009770f, -0.52198803f, -0.14081107f, -1.09128654f, 0.19159201f, 
    -0.73804468f, -0.02978604f, 0.23629051f, 0.15093149f, 0.04452506f, -0.21010359f, 0.29423493f, -0.22422446f, 
    0.19399129f, 0.13354568f, -0.16994323f, -0.01431741f, -0.02056439f, -0.70400751f, -0.17372490f, -0.23283289f, 
    -0.34168193f, -0.36320078f, -0.23628958f, 0.34123152f, -0.01703467f, 0.44982943f, 0.15217045f, -0.12253173f, 
    0.24763045f, -0.12645458f, -0.07410326f, 0.20576213f, -0.34485683f, -0.06546424f, 0.10172106f, 0.26848400f, 
    -0.05992186f, 0.02799722f, -0.47361743f, 0.00549587f, 0.37248364f, 0.02201209f, -0.27492812f, 0.05855861f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.17948936f, 0.06808185f, -0.10473081f, 0.14331366f, 0.02695121f, 0.04646458f, -0.23585227f, 0.04606117f, 
    0.14600118f, 0.22095346f, 0.03393425f, 0.05796020f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
