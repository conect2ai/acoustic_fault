#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85741717f, -0.94846946f, -0.17895940f, -0.75174350f, -0.00296946f, 0.25482145f, 0.04211375f, 0.03616628f, 
    0.20451315f, -0.54665381f, -0.12281857f, -0.07444738f, 0.07795361f, 0.68420845f, -0.37015131f, 0.00535467f, 
    -0.21154749f, -0.22544253f, 0.41668034f, 0.39832982f, 0.13133456f, -0.71952158f, -0.32642049f, -0.32588869f, 
    0.25085884f, -0.46078312f, -0.31227151f, -0.49655476f, 0.50131804f, -0.52356362f, -0.30749154f, 0.00736664f, 
    0.49504721f, -0.49813423f, -0.32097742f, 0.33133492f, -0.55800480f, 0.48607433f, 0.59760195f, 0.49011314f, 
    0.54961479f, 0.68328625f, 0.01067179f, -0.21277358f, -0.14004326f, -0.55368704f, 0.24253909f, 0.67916632f, 
    0.88029748f, 0.03728837f, -0.36995929f, -0.09255403f, 0.12448374f, -0.24125016f, 0.68720472f, -0.67613155f, 
    0.23124081f, 0.01864138f, -0.72206348f, -0.17461137f, -0.58045125f, 0.36325601f, 0.04156106f, -0.15046977f, 
    -0.83655846f, -0.62259597f, -0.49120387f, -0.51891702f, -0.00904300f, -0.31919301f, 0.06572527f, -0.23372333f, 
    -0.30471420f, -0.81759256f, -0.14706962f, 0.58261198f, -0.19365053f, -0.13245304f, 0.47212252f, -0.18434414f, 
    -0.11485814f, 0.40163925f, 0.44436499f, 0.48147446f, 0.26413122f, -0.45554754f, -0.21586068f, 0.44375849f, 
    0.04133180f, 0.27327424f, 0.64121705f, 0.57491291f, 0.65129429f, -0.15978236f, 0.31245235f, 0.02639196f, 
    -0.17577715f, -0.05641212f, 0.27792004f, -0.28448692f, -0.48234734f, 0.86542118f, -0.37955189f, -0.03551808f, 
    0.21101640f, 0.40330586f, 0.08984954f, 0.17614324f, -0.03709757f, -0.43446243f, -0.12286367f, -0.58231658f, 
    0.27283326f, -0.57165182f, -0.41771403f, -0.12482613f, -0.51933706f, 0.46076334f, 0.33510512f, 0.32608289f, 
    -0.65537316f, -0.19410127f, 0.42744741f, 0.07743472f, 0.32118222f, 0.31352943f, -0.27971542f, -0.50645602f, 
    -0.54411501f, -0.14460441f, -0.59223264f, -0.41881919f, 0.33430332f, 0.28274262f, 0.28487235f, 0.61408830f, 
    0.69094086f, -0.55045837f, 0.41844556f, -0.08768804f, -0.55042315f, 0.40847230f, -0.26974207f, -0.36790696f, 
    -0.41129631f, -0.28101635f, -0.21137512f, -0.18302841f, 0.80120522f, 0.72310627f, -0.16292517f, 0.14761272f, 
    -0.44411442f, -0.15486473f, 0.39389685f, 0.80973244f, -0.75033480f, 0.51013458f, -0.41123053f, -0.07756016f, 
    0.14217636f, 0.17883827f, 0.66173345f, -0.05713299f, 0.02794058f, 0.38565394f, 0.45318639f, 0.09860634f, 
    -0.10563580f, 0.45946127f, -0.07835118f, 0.43387887f, -0.45593899f, 0.11457610f, 0.24810714f, 0.19163573f, 
    -0.73153776f, -0.47441036f, -0.46433306f, -0.01436572f, -0.62541479f, -0.47453937f, -0.56222087f, 0.36200267f, 
    0.23972575f, 0.33295995f, -0.25926524f, -0.03472321f, 0.14123677f, -0.41409579f, -0.18401937f, -0.48266584f, 
    0.45522499f, 0.64302063f, -0.34572768f, -0.27009657f, 0.18866614f, -0.49173808f, 0.35495490f, -0.35876396f, 
    -0.57095218f, 0.21192394f, 0.46122882f, -0.38033965f, 0.20939034f, 0.27831745f, -0.18809995f, -0.63066357f, 
    -0.56614423f, -0.54536206f, -0.13261048f, 0.42631719f, 0.40401441f, 0.36504284f, -0.27820182f, 0.13699909f, 
    -0.19624232f, 0.35048205f, 0.73648548f, 0.48580027f, -0.52125865f, 0.24605936f, -0.08771778f, -0.32371688f, 
    0.44515511f, 0.09275408f, -0.14314586f, 0.46184769f, -0.80962110f, -0.49069098f, -0.56042695f, 0.09518047f, 
    0.13690373f, -0.12681974f, 0.01239491f, 0.62260288f, -0.29720604f, -0.57525581f, -0.44125894f, -0.35558599f, 
    0.06926338f, 0.10607673f, 0.54112464f, -0.86335838f, -0.02466532f, 0.39660975f, -0.25083187f, 0.10175477f, 
    0.38511065f, 0.32001725f, 0.48812842f, -0.01830916f, 0.57792705f, 0.17977877f, 0.44491762f, 0.20394193f, 
    -0.61919397f, 0.33261955f, 0.10107914f, 0.55442798f, -0.32993162f, 0.51647824f, 0.74904495f, 0.69819432f, 
    -0.11993702f, 0.10127499f, -0.00800884f, 0.11293607f, -0.24242197f, -0.35546318f, 0.72408134f, 0.52803791f, 
    0.08171194f, 0.56536210f, -0.49545956f, -0.11888742f, -0.23089284f, 0.30566102f, 0.24639119f, -0.78922933f, 
    -0.27070138f, -0.21996351f, 0.26918483f, 0.28019571f, -0.40325069f, 0.29788721f, -0.08987013f, 0.08603105f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23271401f, 0.13842694f, 0.25340503f, -0.34848678f, 0.19021764f, -0.28534046f, -0.11942635f, 0.15562101f, 
    0.02383019f, 0.13915022f, 0.03221634f, 0.13008040f, -0.15492672f, -0.09283580f, 0.24239792f, -0.21193439f, 
    0.11127987f, 0.01818690f, 0.15196799f, -0.22995876f, -0.06558443f, 0.10466105f, 0.40270320f, -0.12047966f, 
    -0.18317480f, 0.09871262f, -0.04160183f, 0.10364951f, -0.10157920f, -0.10020305f, -0.24522538f, 0.20241833f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.31774092f, -0.08565353f, -0.01050892f, -0.08925705f, 0.20598993f, 0.11347766f, -0.09337519f, -0.06360673f, 
    -0.05025603f, 0.14147086f, -0.02286274f, -0.00986777f, -0.07633759f, -0.03455178f, 0.05650554f, 0.04368638f, 
    0.06480680f, 0.10372381f, 0.04181154f, 0.26990834f, -0.02695002f, -0.00308533f, 0.11417352f, -0.09934431f, 
    0.00514619f, 0.15115716f, 0.00454480f, 0.03470096f, -0.12862135f, -0.19886367f, 0.01976721f, 0.07262016f, 
    0.06424575f, 0.11511432f, 0.05375160f, 0.01456865f, 0.14139722f, 0.05589671f, -0.08933201f, -0.15456879f, 
    0.02127301f, 0.10862143f, 0.01691286f, -0.11981110f, -0.03631559f, 0.11044911f, -0.31600851f, 0.07542341f, 
    -0.13649058f, 0.08187985f, 0.04945265f, -0.15478843f, -0.00449633f, -0.25004095f, -0.24121092f, 0.01521919f, 
    0.05094501f, 0.00393789f, 0.04595562f, -0.20988975f, -0.05786785f, 0.10682599f, 0.04391226f, -0.01842885f, 
    -0.29953727f, -0.01386152f, -0.11085276f, 0.22542861f, -0.01507376f, 0.07626452f, -0.03954063f, 0.01563175f, 
    0.17181766f, -0.14931861f, -0.00460537f, -0.14224774f, 0.11508536f, 0.01929031f, -0.13133861f, 0.05472983f, 
    0.05366740f, 0.03138597f, 0.03959467f, -0.02348127f, 0.06006185f, 0.14272347f, -0.07026972f, -0.08551309f, 
    0.04399407f, -0.05247376f, -0.29377154f, -0.03234144f, 0.03909604f, -0.06070528f, 0.17835110f, 0.12654074f, 
    0.00710226f, -0.06880825f, 0.03905676f, 0.14629044f, -0.07529688f, 0.05706843f, 0.04300816f, 0.03450220f, 
    0.01910567f, -0.05813012f, 0.01087875f, 0.03085781f, -0.06190610f, 0.03874046f, -0.10953831f, 0.13731633f, 
    0.05938235f, -0.07766016f, 0.06450110f, -0.12008886f, 0.07338471f, -0.10140285f, 0.19856186f, -0.16428016f, 
    0.03984933f, 0.03597210f, 0.03369290f, -0.09655459f, -0.04109578f, -0.10809915f, 0.00449160f, -0.03096196f, 
    0.10021089f, -0.04182835f, 0.07008253f, -0.04669572f, -0.07709664f, 0.08828132f, 0.03503552f, 0.12690002f, 
    -0.34427062f, 0.07608135f, -0.06760868f, 0.08176085f, 0.06075082f, 0.08009997f, 0.01821441f, 0.06078748f, 
    0.13934472f, 0.11046761f, 0.00368933f, -0.11533206f, -0.05074440f, -0.02237397f, 0.00603618f, -0.00122844f, 
    0.08425502f, 0.20290782f, 0.14401434f, -0.14527710f, 0.04384669f, 0.06947090f, 0.05402207f, -0.05360421f, 
    -0.10590100f, -0.11885912f, -0.12033629f, -0.08900161f, 0.05084650f, -0.03782411f, -0.04326405f, 0.11737607f, 
    0.04656315f, 0.00969255f, -0.02456716f, -0.20764856f, -0.31971252f, 0.03168397f, -0.06616332f, 0.10737444f, 
    0.03853124f, -0.00280953f, 0.00750144f, 0.01829761f, 0.12994006f, -0.13566689f, -0.02483284f, -0.19229822f, 
    0.04765972f, 0.01719775f, 0.09672917f, -0.03803548f, 0.14105456f, 0.20502384f, 0.02158244f, 0.04095916f, 
    0.02786023f, -0.03005301f, -0.06307606f, 0.10918088f, 0.01066441f, 0.10522593f, 0.09118248f, -0.20525308f, 
    0.15630287f, -0.03134758f, 0.05678385f, -0.04446888f, -0.03053886f, 0.00459504f, 0.09572458f, 0.21627882f, 
    0.05881936f, -0.01160796f, -0.26891163f, 0.09055164f, -0.02443991f, -0.03759781f, -0.06915680f, 0.05990754f, 
    -0.14222261f, 0.20468219f, -0.00948338f, -0.04658804f, 0.17200653f, -0.09478734f, -0.07133947f, 0.02965840f, 
    -0.14506377f, 0.35861486f, 0.14022335f, 0.12528279f, 0.08065270f, 0.04490398f, -0.08905641f, 0.01520118f, 
    0.02415875f, 0.05820920f, 0.06448312f, 0.14876930f, -0.05901003f, 0.06890889f, 0.04682681f, 0.01849748f, 
    0.03762948f, 0.08712499f, -0.00226270f, 0.13840763f, -0.07468880f, -0.01569619f, -0.03872083f, -0.03454112f, 
    0.00933319f, 0.00767214f, -0.07678845f, -0.03227390f, -0.30737340f, 0.06075459f, 0.11815587f, 0.08185833f, 
    0.08413666f, 0.08213373f, 0.01037383f, -0.00075899f, -0.06106753f, -0.11262954f, -0.11592955f, -0.05830535f, 
    -0.02291694f, -0.00207501f, 0.09719193f, 0.09390067f, -0.03971002f, 0.00583306f, -0.23152228f, -0.19993185f, 
    0.06676757f, -0.02768425f, 0.02120653f, 0.01762663f, -0.23659018f, 0.00967305f, 0.02708009f, 0.31054801f, 
    0.04534306f, -0.01908517f, -0.04844656f, -0.06606744f, -0.06137255f, -0.00212713f, 0.05526559f, 0.03683660f, 
    0.01451923f, 0.00651581f, -0.04897614f, -0.02467696f, -0.01706101f, -0.01615204f, -0.00073689f, 0.03261660f, 
    -0.01156611f, 0.00795609f, 0.03863848f, -0.01689395f, -0.03578135f, -0.00643707f, 0.00248769f, 0.04669353f, 
    0.05634915f, 0.00591781f, -0.05035363f, -0.01213795f, 0.05615827f, 0.00863661f, -0.04911863f, -0.02905271f, 
    -0.03370792f, -0.03711862f, 0.03850718f, -0.02624759f, -0.04956359f, -0.04429289f, -0.00576654f, -0.00650713f, 
    0.04167487f, -0.03914319f, -0.02742351f, -0.03575927f, -0.00673871f, -0.01002365f, -0.00672257f, 0.03354025f, 
    -0.03040553f, -0.05643767f, -0.01635988f, 0.00848291f, 0.01956012f, -0.00769012f, -0.04492544f, 0.00696136f, 
    0.02786720f, 0.04481697f, -0.03674667f, -0.01913694f, 0.03748954f, -0.02465230f, 0.04439963f, -0.01073292f, 
    -0.03814608f, 0.03134570f, -0.03107772f, -0.03810208f, -0.00617822f, 0.01718911f, 0.00766955f, -0.02449599f, 
    -0.05425140f, -0.03009731f, -0.04617709f, -0.02380095f, -0.03036914f, 0.01657060f, 0.01408759f, -0.01432787f, 
    0.05332515f, -0.05828978f, -0.02237039f, 0.00289842f, -0.03929909f, -0.03020369f, 0.05685340f, -0.01256106f, 
    -0.00063430f, 0.00157534f, -0.05223747f, -0.05775625f, -0.04213116f, 0.03099003f, -0.03652876f, -0.03238102f, 
    0.04487366f, 0.04974629f, 0.04895888f, 0.04478667f, -0.02715297f, -0.04921697f, -0.00780798f, 0.04241256f, 
    -0.04684718f, -0.00909535f, 0.05161042f, 0.01373061f, 0.02884088f, -0.01273264f, 0.01430446f, 0.05291152f, 
    -0.01278530f, -0.02059178f, 0.02531628f, 0.02683931f, -0.05788915f, 0.05359799f, -0.03223275f, -0.04651165f, 
    0.00543672f, -0.05395991f, -0.02772146f, 0.04015211f, 0.00988229f, -0.04549140f, -0.03545529f, 0.03126919f, 
    -0.00126935f, -0.01740357f, -0.05923207f, -0.00568932f, 0.01265339f, -0.00528896f, 0.02886148f, -0.05713568f, 
    0.04415905f, 0.02345109f, 0.00104578f, 0.02512042f, -0.05823679f, -0.01482998f, -0.00647070f, 0.02889178f, 
    -0.03716189f, 0.03928874f, 0.00214246f, -0.00637840f, -0.04846372f, -0.03846203f, 0.01414729f, -0.02484716f, 
    0.01235935f, -0.04133727f, 0.00582909f, -0.03583864f, -0.05329712f, 0.01789312f, 0.03036489f, -0.05396647f, 
    -0.00832903f, -0.00361578f, 0.04417088f, 0.03825909f, 0.05087740f, 0.05006830f, -0.01548603f, 0.00475357f, 
    0.04301663f, -0.02996313f, 0.04673615f, -0.00036179f, -0.05804447f, -0.03734833f, -0.04740961f, 0.02048123f, 
    0.03922679f, -0.01177622f, -0.04065607f, -0.01857952f, 0.04376813f, -0.03940714f, 0.03400303f, 0.01899961f, 
    0.00724833f, 0.01694882f, -0.02700105f, 0.00699027f, -0.06155986f, -0.04522316f, 0.00881972f, 0.04978068f, 
    -0.01401470f, -0.01525483f, 0.02461590f, 0.03980191f, -0.01364786f, 0.04746542f, -0.03598288f, 0.01616095f, 
    -0.04128608f, 0.02401695f, -0.03689807f, -0.04055061f, -0.03724955f, -0.05399445f, -0.04940400f, 0.02853843f, 
    0.05465806f, -0.04331794f, -0.02023899f, -0.02558133f, -0.03578458f, 0.03790601f, 0.06114257f, -0.00166193f, 
    0.04926261f, -0.01013356f, -0.03483635f, -0.06364468f, -0.02799660f, -0.00921708f, 0.00427798f, 0.00875153f, 
    0.04607248f, -0.02193819f, -0.02778133f, 0.03377132f, -0.01895761f, -0.02145513f, -0.04968284f, -0.04764999f, 
    0.00330361f, 0.03630428f, -0.06164203f, 0.01544653f, -0.00579626f, 0.00431455f, -0.02236706f, 0.03432968f, 
    -0.03256043f, 0.04437885f, -0.03721833f, -0.05995810f, -0.02546787f, 0.00771031f, 0.00178093f, 0.03933051f, 
    -0.05582179f, 0.05358814f, -0.03992777f, -0.02802905f, -0.01148182f, -0.01607358f, -0.05446105f, 0.03701854f, 
    -0.01191880f, -0.01768300f, 0.01408607f, -0.02917136f, -0.04350131f, 0.02362259f, 0.04127328f, -0.04939488f, 
    0.03476964f, 0.02579456f, -0.04943551f, -0.00478216f, 0.03476062f, -0.00021037f, -0.05124319f, -0.02986368f, 
    -0.03014904f, -0.04530108f, -0.00602616f, -0.04694080f, 0.03305306f, 0.03366698f, -0.03706703f, -0.03600528f, 
    -0.03297277f, 0.02164968f, -0.01643144f, -0.06115250f, -0.06222412f, -0.03354116f, -0.03048245f, 0.05173783f, 
    -0.00230499f, 0.01470213f, -0.05423569f, 0.03389958f, -0.00149158f, -0.03754854f, -0.03711666f, -0.00629192f, 
    -0.47344753f, -0.29717714f, -0.06179882f, 0.05967133f, 0.13219599f, 0.21442465f, -0.03438851f, -0.00799691f, 
    -0.05928647f, -0.07576487f, -0.03910786f, 0.04721941f, 0.17405602f, -0.02002496f, 0.06084689f, -0.02481035f, 
    -0.06589571f, 0.06297812f, 0.10313807f, 0.01955903f, 0.29027271f, -0.00230144f, 0.09656118f, 0.12732188f, 
    0.02150552f, 0.09702970f, 0.10788134f, -0.26032767f, -0.22494245f, 0.01977814f, 0.07095698f, 0.12981488f, 
    -0.08300939f, -0.03527799f, -0.01967180f, -0.17397234f, 0.34145182f, -0.01586024f, -0.02210318f, 0.09437006f, 
    0.08691394f, 0.03770158f, 0.14012934f, 0.14425376f, 0.11258207f, 0.05712714f, -0.19575423f, -0.23005259f, 
    0.06437823f, 0.04078652f, -0.11859807f, 0.00698805f, 0.07393143f, 0.00308361f, -0.18688723f, -0.12310977f, 
    0.12371844f, 0.02681093f, -0.05516762f, -0.00312112f, -0.07390428f, 0.10909186f, -0.04711045f, -0.04967367f, 
    -0.01250554f, 0.16581932f, 0.18101054f, -0.01927954f, 0.07297760f, 0.18955064f, -0.05348869f, -0.07943245f, 
    -0.27780634f, 0.01357308f, 0.13615087f, 0.21324910f, -0.04753768f, 0.05904212f, -0.09580928f, 0.08371993f, 
    0.08810508f, -0.02730781f, -0.03975307f, 0.13565561f, -0.07387846f, 0.03589655f, 0.02847463f, -0.06651080f, 
    0.10231753f, 0.05790621f, 0.13380075f, 0.12041479f, 0.12457731f, 0.02550347f, 0.03516458f, -0.13221726f, 
    0.01501663f, 0.02976170f, 0.19360371f, -0.12775002f, -0.25581777f, 0.03126257f, 0.07030963f, 0.00543094f, 
    -0.04027179f, 0.19225720f, 0.05459847f, 0.01215454f, 0.04919457f, 0.17986847f, 0.17483327f, 0.10936282f, 
    0.10614518f, 0.00903416f, -0.10937987f, -0.03883403f, -0.10571131f, -0.13482460f, -0.05001332f, 0.00354336f, 
    -0.08745970f, 0.01878387f, -0.00838113f, 0.08822928f, 0.15471818f, 0.08518596f, 0.00211502f, 0.09051635f, 
    0.13430330f, 0.24712172f, 0.01342623f, 0.18578932f, 0.23251876f, 0.00399564f, -0.01817536f, 0.05200887f, 
    -0.05362866f, -0.02029121f, -0.00209920f, 0.06705991f, 0.01593449f, 0.03778861f, -0.00993321f, -0.00799576f, 
    -0.14972426f, -0.03857089f, -0.12977389f, 0.14904153f, 0.10708900f, -0.01690766f, 0.03282003f, -0.04832616f, 
    0.22217387f, -0.18705209f, 0.07635406f, 0.07726026f, 0.10861180f, 0.19836472f, 0.02446818f, 0.00829533f, 
    -0.06875783f, -0.00905176f, -0.05977108f, 0.09803976f, 0.08902420f, 0.12904717f, -0.09759931f, 0.03500238f, 
    0.17457694f, 0.12517676f, 0.01421334f, 0.09221078f, -0.03997161f, -0.10496738f, -0.15603320f, 0.07997908f, 
    0.11653228f, 0.20303418f, 0.18353753f, 0.22425444f, -0.37200299f, -0.00473804f, -0.02259895f, 0.15969396f, 
    0.01927106f, 0.02033370f, 0.04119144f, 0.06894503f, 0.08479593f, -0.05274902f, -0.01264651f, 0.13524276f, 
    0.21567336f, -0.08050472f, -0.01416175f, 0.05599427f, 0.05150649f, 0.00079299f, -0.07492283f, 0.10057716f, 
    0.15024368f, 0.14668277f, 0.07541256f, 0.06862438f, 0.01549490f, -0.00536763f, -0.00124910f, -0.49932039f, 
    -0.07542754f, -0.03488949f, 0.14610317f, 0.13441846f, 0.15527053f, 0.11741097f, -0.14887090f, -0.02371111f, 
    0.01908056f, -0.09627313f, -0.07273065f, 0.15023999f, -0.01556632f, -0.12210641f, -0.02511504f, 0.02325525f, 
    0.02573305f, -0.02734721f, 0.06010657f, 0.29132190f, 0.06260059f, 0.05856539f, -0.08777883f, 0.19597915f, 
    -0.08408584f, -0.02645006f, -0.09226049f, -0.03641902f, 0.15610424f, 0.14929879f, 0.02391029f, -0.03143862f, 
    0.09773380f, -0.03604188f, -0.00950037f, 0.00758338f, -0.33814156f, 0.02835682f, 0.10321786f, 0.15065725f, 
    0.11688522f, 0.02248038f, 0.10413581f, 0.07764511f, -0.21196826f, 0.02701686f, 0.05259297f, 0.14869483f, 
    -0.06392769f, -0.09271669f, 0.00203694f, 0.08917074f, 0.09906282f, 0.19364816f, 0.15559252f, 0.17406835f, 
    0.01430660f, 0.05200300f, -0.11008556f, 0.14487728f, 0.01712541f, 0.14022531f, -0.25994813f, 0.05153068f, 
    0.08211096f, 0.05349381f, 0.00934593f, 0.00255020f, -0.05774290f, 0.01646725f, -0.00874861f, -0.19872653f, 
    0.04229299f, 0.01387765f, 0.22822110f, 0.02826490f, 0.12218268f, 0.11394141f, 0.08609620f, -0.04039013f, 
    -0.14277910f, 0.01145092f, -0.08504771f, 0.12851751f, -0.02909273f, 0.09503651f, -0.15893684f, 0.07811949f, 
    -0.02096357f, -0.21327555f, -0.05425740f, -0.06104653f, -0.11114964f, 0.03879081f, 0.05614446f, 0.02221195f, 
    -0.04742610f, -0.18305455f, -0.08418675f, -0.07330931f, -0.09250676f, 0.12843661f, 0.08182380f, 0.04146298f, 
    0.07888351f, 0.05082812f, 0.01125623f, -0.01409074f, 0.03133774f, -0.22608852f, 0.07415034f, -0.16299473f, 
    -0.05915975f, -0.00591403f, 0.06985005f, 0.09166232f, 0.15163973f, 0.06760647f, 0.22486860f, -0.01261234f, 
    0.07123448f, -0.05847540f, -0.01588920f, 0.10178655f, -0.00020862f, 0.11381710f, -0.07991877f, 0.07166194f, 
    -0.13631949f, -0.03291075f, -0.00192980f, -0.00390054f, -0.04992497f, 0.05555622f, -0.04568752f, 0.01152473f, 
    -0.06107238f, 0.13104245f, 0.08117608f, -0.14735353f, 0.05721895f, -0.00080852f, -0.02183885f, -0.29519397f, 
    0.03816610f, 0.18516511f, 0.00233795f, 0.00276862f, 0.09800191f, -0.04362990f, 0.06158345f, -0.16791308f, 
    0.17486989f, 0.08249685f, 0.25449064f, -0.04065271f, -0.15955520f, -0.09101346f, 0.04407820f, -0.10800680f, 
    -0.05090397f, 0.18406093f, 0.17981906f, 0.01717476f, 0.02185929f, 0.02877119f, -0.06865097f, 0.08817225f, 
    -0.04694644f, 0.02581827f, 0.07986035f, -0.08860643f, 0.08853609f, 0.03833163f, 0.09634478f, -0.02289107f, 
    0.14191405f, 0.00192406f, 0.10827395f, 0.03991176f, -0.20801222f, 0.07150283f, -0.06174333f, -0.00295304f, 
    0.05059801f, -0.08994379f, 0.03468411f, 0.11519891f, -0.09406303f, -0.13524668f, -0.15024407f, 0.16134484f, 
    0.10103249f, 0.07735579f, 0.08623272f, 0.00719732f, -0.02280528f, 0.11401469f, -0.10525098f, 0.03961857f, 
    0.02996043f, 0.05202818f, 0.02563167f, -0.12475159f, -0.04540046f, 0.09071841f, -0.28049627f, -0.03352736f, 
    0.15930381f, -0.00810656f, -0.02334085f, 0.11931606f, 0.01677003f, 0.05869457f, -0.01354964f, -0.00416739f, 
    0.07364465f, -0.33432087f, 0.13045400f, -0.00191156f, -0.00435385f, -0.01132458f, -0.05902734f, 0.04992592f, 
    0.10440074f, 0.03416187f, 0.16337262f, -0.13650416f, 0.04036558f, -0.17592372f, 0.09612852f, 0.13868676f, 
    -0.19129635f, 0.01220400f, -0.31176990f, -0.00189971f, 0.10449158f, 0.15362845f, 0.04700816f, 0.08934511f, 
    0.00518589f, -0.08548058f, 0.15669484f, 0.13557573f, -0.15941924f, 0.10906623f, 0.01567144f, -0.00791773f, 
    0.04452022f, 0.04019056f, -0.10440233f, -0.22333971f, -0.07383893f, -0.03810975f, 0.10485782f, 0.04982570f, 
    0.00204104f, 0.07111070f, -0.13836324f, 0.11444286f, -0.17163180f, 0.06059044f, 0.17339256f, -0.07670263f, 
    0.03246560f, 0.04656504f, 0.01316705f, 0.03993894f, -0.01577803f, -0.03072898f, -0.12175238f, -0.18577437f, 
    -0.07333701f, 0.00713946f, 0.06044252f, 0.03850797f, 0.03828878f, 0.03946529f, -0.15822063f, -0.06851315f, 
    -0.16167787f, -0.06281031f, 0.10052181f, -0.11176668f, 0.03004850f, -0.12501138f, -0.01286721f, -0.14444880f, 
    0.00612594f, 0.19558905f, 0.02038401f, -0.00179177f, -0.08014283f, 0.03580089f, -0.02171090f, 0.02536548f, 
    0.13159429f, 0.00540146f, -0.02192174f, -0.01553129f, -0.06396721f, -0.07733496f, -0.13781928f, -0.02365482f, 
    -0.02363609f, -0.22407243f, -0.25703800f, -0.13213389f, 0.06069225f, 0.10620769f, -0.01675366f, 0.08001722f, 
    0.00168541f, 0.10659589f, -0.00010051f, -0.09072813f, -0.40478021f, 0.01216332f, 0.00905239f, -0.05019153f, 
    -0.05672813f, 0.09022121f, -0.05965720f, 0.07274614f, -0.18337691f, 0.03858452f, 0.01581089f, -0.00638952f, 
    -0.10754789f, -0.04522651f, 0.00639170f, 0.07305124f, 0.06570093f, -0.03337085f, 0.00392085f, 0.11443067f, 
    -0.01419487f, -0.00827921f, 0.01561267f, 0.07379324f, 0.07323952f, 0.10619570f, 0.06394174f, 0.18706059f, 
    0.11332352f, 0.13447313f, 0.03359242f, 0.08978343f, -0.03792904f, -0.02985300f, -0.03540820f, 0.08392684f, 
    -0.08816770f, -0.03512578f, 0.13348325f, -0.04515434f, 0.00684018f, 0.04896253f, -0.03619840f, -0.21847820f, 
    -0.08632366f, 0.18063296f, -0.17279686f, 0.01750019f, -0.05716020f, 0.01938138f, -0.04911355f, 0.00466759f, 
    0.03242353f, -0.07768866f, 0.02267175f, 0.05784314f, -0.01721229f, -0.02990364f, -0.07414829f, 0.05433426f, 
    -0.02406934f, 0.12988847f, 0.05893300f, 0.10609493f, 0.01092451f, -0.01804843f, 0.11950037f, 0.02960371f, 
    -0.00438100f, -0.08572129f, -0.12983383f, -0.12619998f, -0.05111397f, 0.05173706f, 0.09104486f, 0.01179277f, 
    -0.07476663f, -0.00702262f, -0.15838175f, 0.06047263f, -0.05415076f, 0.00325756f, -0.08849643f, -0.02339918f, 
    -0.15907155f, 0.00255015f, -0.15358654f, 0.23849007f, -0.10353790f, 0.08695401f, 0.01669324f, 0.08498926f, 
    0.03465172f, -0.08375075f, 0.02744141f, -0.01201576f, 0.06757804f, 0.01813778f, -0.01191118f, -0.06506067f, 
    0.10513197f, -0.00536149f, 0.00125030f, -0.07511707f, 0.06815402f, 0.06830202f, 0.21991071f, -0.11337295f, 
    0.24707705f, -0.05766526f, -0.19261274f, 0.00652420f, -0.27951199f, -0.08978260f, -0.09576112f, 0.05459712f, 
    0.07164598f, 0.07807333f, 0.07646159f, 0.02212980f, -0.02250039f, -0.09637729f, 0.12074877f, 0.03428836f, 
    0.06190704f, 0.03570009f, 0.04639755f, -0.07662089f, -0.16704738f, -0.03848978f, 0.07757857f, 0.27834111f, 
    -0.04270952f, -0.20514359f, -0.09493983f, -0.02841924f, -0.03249191f, -0.01038406f, 0.04692067f, 0.16336183f, 
    -0.02607848f, -0.01391301f, -0.12637186f, -0.06092561f, 0.05444290f, -0.06109922f, 0.02696181f, 0.09822577f, 
    0.07507218f, 0.12802850f, 0.11843752f, -0.04201361f, -0.10394626f, 0.11183542f, -0.09748246f, 0.03648695f, 
    -0.15056115f, 0.03213438f, 0.03594646f, 0.02814527f, 0.10235979f, 0.05973427f, 0.14681736f, -0.01237637f, 
    0.05898162f, 0.04665999f, -0.19022882f, -0.12184969f, -0.15434599f, -0.19741422f, -0.10718526f, -0.02324728f, 
    -0.08663875f, 0.03044964f, 0.01529808f, 0.09387770f, -0.04168944f, 0.14970060f, 0.07388076f, 0.00781603f, 
    0.10148796f, -0.08187478f, 0.02386364f, 0.17457318f, 0.10103160f, 0.08720868f, -0.16004778f, -0.18510193f, 
    -0.05533696f, -0.16616149f, -0.05755387f, -0.01044173f, -0.01342452f, -0.02370833f, 0.18765421f, -0.14253953f, 
    0.07716055f, 0.14220402f, 0.01485102f, 0.12947202f, 0.01745512f, -0.01101085f, -0.02332487f, -0.04724277f, 
    0.05277773f, -0.14420579f, 0.06476624f, -0.02751097f, 0.03125305f, 0.09968957f, 0.02070585f, -0.04817679f, 
    0.06238458f, -0.09650128f, -0.00778555f, -0.06214089f, 0.09227058f, 0.07346782f, -0.05334971f, -0.01872753f, 
    0.04934147f, 0.01728736f, 0.23415084f, 0.04014407f, 0.03112204f, 0.10153877f, 0.02765926f, -0.02881169f, 
    -0.01252199f, -0.04660469f, 0.05056506f, -0.13003163f, 0.16056272f, 0.11768689f, 0.14726390f, 0.01994667f, 
    0.05509333f, 0.09757783f, 0.00396836f, 0.01620982f, 0.10353229f, 0.11563311f, 0.04423161f, 0.00854328f, 
    0.09853395f, -0.02118632f, 0.10381790f, -0.03971651f, -0.00550293f, 0.03646656f, 0.01736696f, -0.01794110f, 
    0.02599865f, -0.06036408f, -0.12809910f, -0.08644161f, 0.10629051f, 0.04952827f, 0.04929451f, 0.16072649f, 
    -0.01317850f, 0.07825277f, -0.01524794f, -0.03215367f, 0.10535724f, 0.10876219f, -0.00909522f, 0.13124503f, 
    0.04014090f, -0.18911870f, -0.08731726f, -0.06056789f, 0.05103930f, -0.10625513f, 0.04517336f, 0.17088397f, 
    0.14526424f, -0.04885837f, -0.10423745f, 0.11994278f, 0.03948643f, 0.03759894f, -0.04758591f, -0.12307230f, 
    0.09399147f, -0.16261579f, -0.14573726f, -0.09529871f, -0.01705130f, -0.14235325f, 0.00947510f, 0.02303014f, 
    -0.02466510f, -0.06141650f, -0.19939896f, 0.05981027f, 0.03728922f, -0.01363034f, -0.02332103f, -0.10127177f, 
    -0.05041519f, 0.08382186f, 0.08153611f, 0.06181544f, -0.13951994f, -0.08712673f, 0.01138806f, -0.10580301f, 
    -0.09336425f, -0.01545453f, -0.12442576f, 0.01163698f, 0.01535918f, -0.00084955f, 0.10188886f, -0.03439666f, 
    -0.21182366f, 0.04514555f, 0.10547682f, 0.01319116f, 0.07091541f, 0.09065036f, -0.08386020f, 0.06184591f, 
    -0.00582754f, -0.16755572f, -0.14842263f, 0.12951303f, 0.07638248f, 0.02557403f, -0.01540124f, 0.18077685f, 
    0.12276005f, 0.15901971f, -0.01969852f, -0.04714314f, 0.05389909f, 0.01467591f, 0.01365673f, -0.07790232f, 
    0.02157743f, -0.05221340f, 0.03350176f, 0.03599277f, 0.01579746f, 0.03809614f, 0.02167960f, -0.04582942f, 
    0.04828158f, 0.04716245f, 0.02554483f, -0.01517389f, 0.01734233f, -0.04157481f, 0.02527215f, 0.01960767f, 
    -0.04592768f, -0.02948515f, -0.01731295f, 0.04983536f, -0.01989904f, 0.01646962f, 0.00011666f, -0.05605483f, 
    0.01386180f, 0.04880403f, -0.05401265f, -0.04872823f, -0.02612655f, 0.03045662f, -0.04918024f, -0.03333582f, 
    0.00293032f, 0.02004507f, -0.06259260f, -0.03192251f, -0.04979574f, 0.04423847f, -0.03170373f, 0.00095072f, 
    -0.05635866f, -0.04625745f, -0.00452678f, 0.04392755f, -0.00887948f, -0.01877717f, -0.06395540f, 0.02402188f, 
    0.00425834f, -0.00786209f, -0.04641217f, -0.01756808f, -0.03287886f, -0.00142795f, -0.05958919f, 0.06564825f, 
    0.04155392f, -0.00438170f, -0.01425152f, 0.00691545f, 0.04465950f, 0.00664721f, -0.05932150f, -0.03397634f, 
    0.00902119f, -0.00332903f, -0.05884944f, -0.05149941f, 0.04201924f, -0.01269187f, -0.00264803f, 0.00175451f, 
    -0.02219429f, -0.05754881f, -0.05389983f, -0.03381451f, 0.03319255f, -0.03579041f, -0.04671511f, -0.04269989f, 
    -0.00118241f, -0.02285987f, -0.03290577f, 0.05263746f, 0.03166962f, 0.01077583f, -0.00918392f, 0.02233387f, 
    0.02500026f, -0.04703812f, -0.01082447f, -0.05858181f, -0.06096005f, -0.03908589f, 0.00170386f, -0.06041458f, 
    0.01992280f, -0.00026433f, -0.06331573f, -0.03803750f, -0.05947376f, -0.00184594f, 0.00414584f, -0.02825798f, 
    -0.05186895f, 0.02348466f, 0.05236559f, -0.02212747f, -0.05864477f, 0.05618389f, -0.00032968f, -0.01896000f, 
    -0.00157792f, 0.03644304f, 0.04775462f, -0.00242659f, -0.05296809f, 0.05009887f, 0.02528538f, 0.03530350f, 
    0.00216165f, -0.00096276f, -0.03870941f, -0.06205531f, 0.04360070f, -0.03715315f, -0.04707441f, 0.04531943f, 
    0.01430199f, -0.00618909f, -0.01882816f, -0.02847824f, -0.01578491f, 0.02460200f, -0.00508233f, -0.01060833f, 
    -0.02288869f, -0.01135095f, -0.00423793f, -0.01766701f, 0.01351910f, 0.02348678f, -0.00850540f, 0.02878831f, 
    0.03882210f, 0.02754225f, 0.02632831f, -0.00207374f, 0.04883993f, -0.04311934f, -0.02581460f, 0.05218513f, 
    0.06255072f, -0.04124244f, -0.01191658f, -0.03422710f, 0.03421029f, 0.00596879f, -0.04842314f, -0.05599929f, 
    0.00677304f, -0.03263288f, -0.02258200f, -0.05058602f, -0.01016331f, 0.01755445f, -0.05264625f, 0.00460730f, 
    0.00060836f, -0.02686073f, -0.02147595f, 0.01750482f, 0.03653035f, 0.02943956f, 0.01960668f, -0.03736199f, 
    0.03744527f, -0.03908259f, 0.04667753f, 0.03422204f, -0.04876040f, -0.01732488f, 0.01211789f, 0.03988507f, 
    -0.01001136f, -0.05049220f, -0.06232063f, -0.04861589f, -0.05174576f, -0.05169277f, -0.00293297f, -0.01973825f, 
    -0.01621128f, 0.01941378f, -0.00388962f, -0.00948028f, -0.02702122f, -0.02499990f, -0.06332725f, -0.01265737f, 
    -0.04008909f, -0.01433713f, 0.01561705f, 0.03215855f, -0.04571800f, -0.04185076f, 0.04193569f, -0.05942832f, 
    -0.00475496f, 0.01335428f, -0.03802082f, -0.00760316f, -0.04377193f, -0.02073587f, -0.06561210f, 0.05315655f, 
    -0.06321914f, -0.03620689f, -0.03252559f, 0.02066796f, -0.04832269f, -0.05533231f, -0.05096177f, -0.00334910f, 
    -0.05632731f, -0.00807405f, 0.03135282f, -0.04892851f, -0.00312302f, -0.05548382f, -0.00169367f, -0.04346828f, 
    0.01167385f, -0.03693060f, -0.03593101f, 0.01233875f, 0.05112454f, -0.05265956f, -0.02868596f, 0.05150369f, 
    -0.01693826f, -0.00543246f, -0.04075669f, 0.00495653f, 0.00054143f, -0.04346229f, 0.02215324f, 0.03640096f, 
    0.01038795f, 0.01435851f, -0.03692505f, -0.01252913f, -0.06219639f, 0.02273707f, -0.01949817f, 0.05306583f, 
    -0.00194502f, -0.05643516f, -0.01151054f, -0.04771896f, -0.02571897f, -0.01560305f, -0.03077081f, -0.01973004f, 
    -0.05056405f, 0.04176066f, 0.03103201f, -0.03217889f, -0.04817147f, -0.05096168f, 0.01086158f, -0.06079740f, 
    -0.01990710f, 0.01746865f, 0.03363974f, -0.02637332f, 0.04955013f, 0.02138245f, 0.01464214f, 0.06253566f, 
    -0.03146546f, -0.04628539f, -0.05225746f, -0.03927608f, 0.03109497f, 0.04279356f, 0.00736666f, 0.04159280f, 
    -0.04928455f, 0.04864185f, -0.19370720f, -0.05329541f, 0.10313752f, -0.04460214f, 0.09120139f, 0.03044040f, 
    -0.00738856f, 0.04503469f, 0.15647629f, 0.03183379f, -0.02191452f, 0.05992817f, 0.01419981f, 0.01782770f, 
    0.12528738f, 0.09409417f, -0.03481485f, 0.08771186f, -0.14216566f, -0.01954588f, 0.03876370f, -0.08455817f, 
    0.10550177f, -0.07410579f, 0.07969754f, -0.06587400f, -0.10548247f, 0.02575334f, -0.09847058f, 0.03967409f, 
    0.01869912f, 0.07454634f, -0.04383473f, -0.06099006f, -0.12323701f, 0.12941647f, -0.01213614f, -0.07750958f, 
    0.02788915f, -0.03627250f, 0.05088712f, -0.09622058f, 0.06570631f, 0.50980747f, -0.01472519f, -0.15635087f, 
    -0.03070576f, -0.11312230f, -0.01419615f, -0.16651340f, 0.10087484f, 0.03121734f, 0.18796249f, 0.00651912f, 
    0.03638151f, 0.24348103f, -0.01744779f, -0.06903993f, 0.05108662f, 0.02209202f, 0.01274897f, -0.03862653f, 
    0.11912857f, -0.02677283f, 0.00793691f, -0.10213530f, -0.07730987f, 0.01331504f, 0.01546505f, -0.02920029f, 
    -0.00942578f, 0.07758444f, -0.34505928f, -0.02364898f, 0.01475879f, -0.00678102f, 0.04826872f, -0.02107861f, 
    0.05913678f, -0.07047787f, -0.07580304f, -0.09881665f, 0.06689095f, -0.03509300f, 0.04608975f, -0.05967094f, 
    -0.01783626f, -0.09326107f, -0.48303032f, -0.10298572f, 0.03879546f, -0.06457467f, 0.09685978f, 0.02952663f, 
    0.04410050f, 0.00419820f, -0.02998934f, 0.11970688f, 0.07293508f, 0.08730514f, 0.06567704f, -0.02152403f, 
    -0.04256641f, -0.07538275f, 0.16552395f, -0.01386100f, 0.07298841f, 0.17358083f, 0.10733797f, 0.07621584f, 
    0.01163132f, 0.02509040f, 0.03613535f, -0.18963224f, 0.00440953f, -0.17379937f, -0.14240676f, -0.04256182f, 
    0.00333299f, 0.01208533f, -0.02001206f, 0.10566956f, -0.01419549f, -0.06512700f, 0.15926926f, 0.09511191f, 
    -0.10597365f, 0.04370578f, 0.00055124f, -0.00767809f, -0.01906135f, 0.05861778f, 0.13361368f, -0.03379449f, 
    0.01616459f, -0.18712761f, 0.04768517f, -0.03808868f, 0.03844409f, -0.03175004f, 0.00567804f, -0.01509524f, 
    -0.00912051f, 0.10064347f, 0.07853203f, -0.01019318f, 0.04375919f, 0.02571017f, 0.06936511f, 0.02410942f, 
    -0.01108674f, -0.04071221f, 0.10489290f, 0.19129221f, 0.09473779f, 0.01584500f, 0.00632010f, 0.00073082f, 
    -0.03421795f, 0.04135924f, -0.06729859f, -0.07813869f, -0.16380422f, 0.02439453f, 0.12844031f, -0.06170101f, 
    -0.06454294f, -0.00703172f, -0.01644288f, -0.19480880f, 0.07954381f, -0.01684543f, 0.03122566f, -0.00452349f, 
    0.10420092f, 0.03025462f, 0.11565538f, 0.07676028f, 0.00415179f, -0.01578928f, -0.17195258f, -0.01116119f, 
    -0.06438700f, 0.04760178f, 0.05712499f, 0.07968899f, 0.00021578f, 0.01543037f, 0.10453205f, -0.11307496f, 
    -0.05506866f, 0.07208727f, 0.13740462f, -0.06669213f, 0.02848851f, -0.02228600f, 0.13479421f, 0.08145685f, 
    -0.03877708f, -0.09604365f, 0.01514245f, -0.00335739f, -0.18971485f, 0.11372153f, 0.06919920f, 0.01573640f, 
    0.03587959f, -0.01809384f, -0.06345472f, -0.11958876f, -0.07850289f, 0.06765422f, 0.11947720f, 0.11088192f, 
    -0.09918594f, -0.24499369f, -0.13420753f, 0.11868686f, 0.13006380f, 0.06649701f, 0.09077121f, -0.04450461f, 
    -0.02172029f, 0.24195443f, 0.18498397f, 0.13378759f, 0.05322391f, -0.11297287f, -0.02021606f, 0.13232522f, 
    0.03968520f, 0.03278284f, 0.19246484f, -0.05159111f, -0.13954394f, -0.03712598f, 0.06751470f, -0.04256637f, 
    -0.08460320f, -0.01517413f, 0.07044499f, 0.04349058f, 0.17041159f, -0.03845835f, 0.01463419f, -0.01624262f, 
    -0.10964544f, 0.05393755f, 0.09268814f, 0.11165611f, -0.26477084f, -0.53539902f, 0.00075513f, 0.07666497f, 
    0.04327397f, 0.06755144f, -0.23763219f, -0.01939030f, -0.13565661f, -0.48178446f, -0.24281985f, 0.06552526f, 
    -0.02168492f, 0.04597491f, -0.07237806f, 0.16291256f, -0.07211070f, 0.11215857f, -0.12796995f, -0.12565814f, 
    -0.16857329f, 0.00505881f, -0.06479183f, -0.02292303f, -0.04997493f, -0.01202666f, 0.10027079f, -0.02243197f, 
    0.03689507f, -0.05823231f, 0.07329186f, 0.01382226f, -0.02868188f, -0.01913230f, 0.01346745f, 0.01636495f, 
    0.00950907f, 0.01068115f, -0.05759375f, -0.05287554f, -0.03117345f, 0.00544456f, 0.04199858f, 0.02695137f, 
    0.03119202f, -0.04498063f, -0.05398248f, -0.00995071f, -0.00806906f, -0.04900109f, -0.03233479f, 0.00837223f, 
    -0.05480622f, -0.03253070f, 0.00881868f, -0.01255612f, -0.05471922f, -0.02850903f, -0.03312606f, -0.03543049f, 
    0.04893641f, -0.06391211f, -0.01425188f, -0.04578301f, -0.01716493f, 0.03822333f, -0.01170757f, -0.00332938f, 
    -0.05914667f, -0.00848712f, 0.05244501f, -0.02270287f, 0.03824809f, 0.01178166f, 0.03263553f, -0.01526803f, 
    -0.02610002f, -0.03607672f, -0.01818292f, -0.01407175f, 0.04691762f, -0.00780364f, -0.05090670f, -0.04000304f, 
    -0.05123964f, 0.03798435f, 0.02443322f, 0.03035966f, -0.06319965f, 0.04175699f, -0.03677168f, -0.03435805f, 
    0.04214743f, 0.00746309f, 0.03447586f, -0.05679189f, -0.02936603f, -0.03480917f, -0.03775456f, 0.00731400f, 
    0.00531013f, -0.03222464f, 0.01859900f, 0.03546421f, -0.04357560f, -0.04457315f, 0.04633673f, -0.00714763f, 
    0.01817612f, 0.01650307f, 0.02349633f, -0.04791193f, -0.02167575f, -0.02843777f, 0.01543443f, -0.06860964f, 
    0.05197976f, -0.00003031f, 0.04699140f, -0.05969838f, -0.00476579f, -0.02390487f, -0.04603252f, -0.00782268f, 
    0.01164812f, -0.04306158f, -0.04260898f, 0.01605999f, 0.00523341f, 0.00200212f, 0.04167882f, -0.01604977f, 
    -0.05190935f, -0.01469032f, -0.02292284f, -0.03388443f, 0.01056917f, -0.04486690f, 0.04013550f, -0.04575292f, 
    0.03075814f, 0.00512484f, -0.04679503f, 0.02980443f, 0.04482330f, 0.03363323f, -0.01462624f, -0.01594367f, 
    -0.03576495f, -0.05069795f, 0.03864969f, 0.02247682f, -0.05547205f, -0.04489337f, 0.03176110f, -0.00468645f, 
    0.00344350f, -0.01859295f, -0.05088776f, -0.00638863f, 0.03368474f, -0.00793258f, 0.03193678f, -0.00919347f, 
    0.02113697f, 0.04215070f, 0.01163201f, 0.00280377f, -0.06086723f, -0.04515418f, -0.05510970f, -0.02924723f, 
    -0.02105354f, 0.01913514f, -0.00641169f, -0.05739634f, 0.00185068f, -0.04178753f, 0.02872160f, 0.03662605f, 
    -0.04188890f, -0.01835806f, -0.01410821f, 0.00450963f, 0.04167007f, -0.04877036f, -0.02325683f, 0.03309566f, 
    -0.03769800f, -0.02102871f, -0.02607289f, -0.04657130f, -0.01609766f, 0.01780551f, 0.00063527f, -0.06310107f, 
    0.01679038f, -0.03591636f, -0.01001081f, 0.02478121f, -0.03651292f, 0.00385188f, 0.01961856f, -0.00636104f, 
    -0.04095289f, 0.03947855f, 0.00705620f, -0.02932193f, 0.03608844f, -0.02940413f, 0.01729528f, -0.03989115f, 
    -0.02175156f, -0.03654983f, 0.04820084f, -0.00683185f, -0.05355507f, -0.03177463f, 0.04050538f, 0.05398984f, 
    0.00691774f, -0.05557287f, -0.01351461f, -0.04609220f, -0.01270745f, 0.03645539f, 0.03830498f, 0.02502143f, 
    0.03743201f, 0.01246487f, 0.03732969f, 0.00415924f, -0.04626414f, -0.00550196f, 0.01656921f, -0.02467555f, 
    -0.02448172f, -0.02062580f, 0.04637995f, 0.02532524f, -0.00839081f, 0.04752171f, -0.03240609f, -0.04281015f, 
    -0.01686606f, 0.02171955f, 0.03930542f, 0.00075247f, 0.04406839f, 0.04815159f, -0.06622208f, -0.01202395f, 
    -0.05412727f, 0.02768522f, -0.06443132f, 0.03614306f, -0.04253583f, 0.03719087f, -0.06467675f, 0.02737687f, 
    0.04299450f, 0.03933604f, -0.02779640f, 0.02900713f, 0.00936323f, -0.03608795f, -0.05049770f, -0.03761959f, 
    -0.01730927f, 0.04252990f, 0.01103371f, 0.00070133f, 0.04319955f, -0.05222287f, 0.04322280f, -0.04679835f, 
    0.03501541f, 0.00688729f, -0.01228334f, -0.02102956f, -0.04269525f, -0.06277737f, 0.00977367f, -0.01043876f, 
    -0.00044798f, -0.05174721f, 0.04710880f, 0.03735439f, 0.02922944f, -0.02397928f, 0.01294936f, 0.04193179f, 
    -0.03711318f, -0.03151910f, -0.06454909f, -0.04534321f, 0.03447108f, 0.00194269f, -0.04289699f, -0.02913546f, 
    -0.02967381f, 0.00369110f, 0.01203252f, -0.01851645f, -0.04386326f, -0.04590687f, 0.04993979f, 0.04293384f, 
    -0.00401119f, -0.02688558f, -0.00572476f, -0.03726860f, -0.02596979f, 0.01444185f, -0.04016367f, 0.04570924f, 
    -0.02138833f, 0.04230306f, -0.02855034f, -0.00312549f, 0.00743713f, -0.05612113f, -0.01842115f, 0.00513252f, 
    -0.13022915f, 0.12038525f, -0.16589798f, 0.05590386f, -0.15241683f, 0.01018932f, 0.07979495f, 0.07576282f, 
    -0.07626691f, -0.17121936f, 0.09003682f, 0.03455100f, -0.08500272f, 0.07059763f, -0.05549798f, -0.17723213f, 
    0.13320850f, 0.05414686f, 0.28834182f, -0.02919777f, -0.02962171f, 0.18470562f, 0.03879808f, 0.00415165f, 
    0.00022786f, 0.04045905f, 0.07216430f, -0.10940478f, -0.05511207f, -0.10901994f, -0.09251198f, 0.04691673f, 
    -0.02390182f, -0.05472108f, -0.02223267f, -0.02261800f, -0.50116605f, -0.05664300f, -0.04965220f, 0.05253641f, 
    -0.01255983f, -0.06611968f, -0.12546138f, 0.13478474f, 0.08995797f, -0.23616597f, 0.10847484f, -0.13983643f, 
    -0.01065023f, -0.07251976f, -0.03212213f, -0.04697036f, -0.03088165f, -0.01071036f, 0.00927085f, -0.08244970f, 
    -0.14741746f, 0.06232044f, 0.11977219f, 0.11311486f, 0.08531484f, 0.01211676f, -0.13395813f, 0.11405753f, 
    0.22037700f, -0.12175780f, -0.07164025f, -0.07913060f, -0.02068422f, -0.03302733f, 0.10448404f, 0.11330457f, 
    -0.12302415f, 0.07171839f, -0.06229067f, -0.10298050f, 0.03145771f, 0.06008510f, -0.06908955f, 0.10863987f, 
    -0.00034587f, 0.27271393f, -0.16761146f, 0.12235153f, 0.16354468f, -0.03167082f, 0.09434003f, 0.06532910f, 
    0.11979139f, -0.02312855f, 0.21831784f, -0.01790569f, -0.04107103f, 0.06930733f, -0.00471421f, 0.08389867f, 
    0.06899980f, 0.00557605f, 0.07993583f, -0.05804465f, 0.10025120f, -0.11643902f, -0.05372193f, 0.01111573f, 
    -0.08876792f, 0.05117451f, 0.07903317f, -0.03003010f, 0.01372466f, 0.19039254f, -0.07704739f, 0.01166043f, 
    0.06007209f, 0.11413764f, -0.12728685f, -0.01032180f, -0.22325727f, 0.08584952f, -0.04522604f, 0.01177398f, 
    0.03014905f, -0.07307249f, 0.10042123f, 0.13079780f, 0.07980914f, -0.00998019f, 0.05067142f, 0.09456470f, 
    -0.20345497f, 0.02070593f, 0.01315119f, 0.07995132f, -0.01461579f, 0.03168151f, -0.10262246f, 0.46650651f, 
    -0.41515881f, 0.03641481f, 0.08629061f, -0.10013593f, 0.02344394f, 0.01919231f, 0.08950683f, 0.13504912f, 
    -0.17147246f, 0.09552212f, -0.06025453f, -0.06406803f, -0.13292974f, 0.01541945f, -0.01219436f, 0.03609855f, 
    -0.03050188f, 0.10804380f, -0.11300040f, 0.08621204f, -0.06620822f, -0.00754679f, -0.00301757f, -0.02691573f, 
    -0.05927487f, 0.04762390f, -0.17886436f, -0.03279720f, -0.12331989f, -0.05391838f, -0.04125739f, -0.01444647f, 
    0.00326901f, 0.02766347f, -0.01680867f, -0.17339113f, 0.03034605f, -0.27641565f, -0.14552779f, 0.11090008f, 
    0.14842886f, -0.01360717f, 0.06132699f, 0.07807826f, 0.15264210f, 0.16605410f, 0.01032895f, -0.07056334f, 
    -0.03120760f, 0.03109192f, 0.04384607f, 0.04161691f, 0.08498163f, -0.01524172f, -0.04559817f, -0.02296037f, 
    -0.01647045f, 0.13878977f, -0.04190890f, -0.21854295f, -0.03554796f, 0.03410463f, 0.13798396f, -0.10481023f, 
    -0.10450448f, 0.01797217f, 0.06926661f, -0.04299238f, -0.18322133f, 0.03924938f, -0.14674971f, -0.12582292f, 
    0.26630133f, -0.04784788f, 0.00614345f, 0.07606541f, -0.12425495f, 0.02225483f, 0.11119549f, 0.05784751f, 
    -0.12784404f, -0.23363274f, 0.00599850f, -0.02529310f, 0.12354612f, 0.09860859f, 0.03991437f, -0.08267817f, 
    -0.12168613f, 0.05079348f, 0.05991772f, 0.03166743f, 0.08714151f, -0.01939170f, 0.10494772f, -0.06794059f, 
    -0.06340446f, 0.03940198f, 0.17883132f, 0.06254114f, 0.03814628f, -0.02022574f, 0.08487846f, 0.07464129f, 
    0.07955485f, -0.08882283f, -0.11423615f, -0.01750300f, 0.08593047f, -0.07162245f, -0.00708197f, -0.01221382f, 
    -0.07017732f, 0.07199127f, -0.03174507f, -0.08508648f, -0.08983973f, -0.32741979f, -0.11940238f, 0.14871447f, 
    -0.12260331f, 0.01589143f, 0.05885174f, 0.06400315f, 0.01994584f, 0.49164802f, -0.19033405f, -0.07559336f, 
    0.05524634f, -0.01079630f, 0.01606847f, 0.01175199f, -0.00126140f, 0.13938755f, 0.14934573f, -0.18175715f, 
    0.04479862f, 0.04124682f, 0.13597102f, 0.04931182f, 0.08538724f, 0.03443138f, 0.11133252f, -0.28063196f, 
    0.11070186f, 0.01925967f, -0.05247356f, 0.00663143f, 0.01076061f, -0.02192314f, 0.11991544f, 0.02740498f, 
    0.15923387f, 0.03781914f, 0.02805988f, 0.00594215f, -0.08126274f, -0.07955758f, -0.00077573f, -0.00584574f, 
    0.10988577f, 0.11909981f, -0.00587844f, -0.00132514f, -0.02547574f, -0.04786658f, -0.00516559f, 0.05206185f, 
    0.06346644f, 0.05352434f, -0.18819754f, 0.13105673f, -0.04275737f, 0.18819204f, 0.02092088f, -0.16730019f, 
    -0.03628403f, 0.03744525f, -0.07857934f, -0.03152775f, -0.07759722f, -0.07824124f, -0.04954578f, -0.04854416f, 
    -0.00236071f, -0.12650612f, 0.04481106f, -0.01961959f, 0.08899757f, -0.12452225f, -0.07134628f, -0.00290317f, 
    -0.08244694f, 0.07300785f, 0.12786712f, 0.07032234f, -0.08226168f, 0.30760336f, -0.29286197f, -0.23352222f, 
    -0.10374404f, 0.01003932f, 0.05639971f, 0.00378899f, 0.00521362f, 0.03029547f, 0.23661952f, 0.01199318f, 
    0.15164083f, 0.11779601f, -0.07746900f, -0.01016746f, -0.04728732f, -0.13570383f, -0.08781331f, 0.05150829f, 
    -0.03767036f, 0.33231017f, -0.06091050f, -0.14080191f, 0.08891977f, 0.06158901f, 0.05091998f, -0.02965976f, 
    -0.11278467f, -0.06342921f, 0.00144984f, -0.02228938f, 0.00178028f, -0.17320928f, -0.12377466f, -0.05028069f, 
    -0.16345449f, -0.01920681f, -0.01170465f, 0.02789265f, 0.06744349f, 0.17077489f, 0.03280834f, -0.10277650f, 
    0.01021444f, -0.11070123f, -0.23970683f, 0.07622270f, 0.14996515f, 0.15421666f, 0.10781305f, 0.10678518f, 
    0.06234660f, -0.01535788f, -0.07979453f, 0.11665564f, -0.02272416f, 0.03767056f, -0.18105990f, -0.02920586f, 
    0.07906617f, -0.03923793f, -0.01416690f, -0.06838796f, 0.17422953f, 0.00594717f, 0.06429776f, -0.03240788f, 
    0.02579402f, 0.04254977f, -0.04124089f, -0.00942501f, -0.05116126f, -0.21406493f, 0.10946959f, 0.06721080f, 
    -0.04848584f, 0.16213213f, -0.02717772f, -0.04871747f, 0.00716326f, -0.06000934f, 0.07662965f, 0.05735119f, 
    0.12769273f, -0.02816179f, -0.20056199f, -0.04631142f, -0.02619403f, -0.00006473f, -0.00386269f, 0.00591932f, 
    -0.05243712f, -0.08118815f, 0.10124815f, -0.05328499f, 0.00506296f, -0.10669231f, 0.04606368f, -0.08326665f, 
    0.08659893f, -0.01686313f, 0.03433003f, -0.25183156f, -0.02812900f, 0.14799108f, 0.04579549f, 0.06791819f, 
    0.15538439f, 0.28675005f, 0.18125220f, 0.23710664f, 0.13045435f, -0.07083112f, 0.00520248f, 0.00568118f, 
    -0.05058957f, -0.02275096f, -0.09424496f, -0.06402043f, -0.07369638f, 0.03037899f, -0.09668714f, -0.00749515f, 
    -0.08044029f, -0.15224461f, -0.03984206f, 0.06488870f, -0.08647722f, 0.05512987f, 0.03427408f, -0.02335869f, 
    0.09015200f, 0.01100162f, 0.00303968f, 0.06420194f, 0.01847646f, -0.13036194f, 0.25825611f, -0.09361020f, 
    -0.02028970f, 0.13341749f, -0.01993202f, -0.00618313f, 0.08802285f, 0.01256881f, -0.09489051f, -0.00292346f, 
    -0.06997915f, 0.02795367f, 0.11822136f, -0.00457932f, -0.04549424f, 0.03497363f, 0.11326843f, 0.07476571f, 
    0.11435468f, -0.03950102f, -0.09319977f, -0.04431529f, -0.07482929f, -0.06706595f, 0.03453026f, 0.03006235f, 
    -0.05235298f, 0.21879511f, -0.02521747f, -0.09918479f, 0.06139559f, 0.02185510f, -0.02728107f, 0.02779110f, 
    0.19471122f, 0.00198292f, -0.10490602f, 0.06804993f, 0.09848114f, 0.07048259f, 0.12244432f, 0.07142285f, 
    -0.11992558f, 0.19978756f, 0.04458741f, 0.19445038f, 0.11688342f, -0.03291769f, -0.09702764f, -0.08235391f, 
    -0.03246964f, 0.01033423f, -0.05608621f, 0.04104852f, -0.11138174f, 0.06292205f, 0.09854652f, -0.18176739f, 
    -0.03119588f, 0.04815755f, 0.07228116f, 0.22387727f, -0.02791463f, -0.17741254f, -0.15220436f, -0.08804835f, 
    -0.00668490f, -0.04719337f, 0.02493042f, -0.03933987f, -0.24801753f, 0.02794291f, 0.15650181f, 0.04929909f, 
    0.11484785f, -0.00686023f, -0.21375313f, -0.04305058f, -0.15558167f, -0.08381514f, 0.13806145f, 0.33814499f, 
    0.04469329f, -0.08382842f, 0.13573465f, 0.11165969f, 0.06479406f, -0.06273763f, -0.03690146f, 0.13650768f, 
    0.11683024f, 0.05132156f, -0.11804673f, 0.02759914f, -0.02384050f, 0.03299969f, 0.02454315f, 0.09621821f, 
    0.17598541f, 0.00930349f, 0.07605468f, -0.06979104f, -0.03853606f, 0.06096926f, 0.04685735f, 0.03191922f, 
    0.15106347f, 0.00597491f, 0.19691890f, -0.09837035f, -0.01112116f, 0.01505868f, -0.06012621f, 0.06032391f, 
    -0.03532800f, -0.05459363f, 0.00044804f, -0.21192828f, -0.01327326f, 0.12909488f, 0.04823329f, 0.00031520f, 
    -0.06771790f, -0.00973823f, 0.08324911f, 0.01203917f, -0.04027914f, -0.06107773f, 0.04107181f, -0.03742387f, 
    0.24802966f, 0.10452937f, 0.01074309f, 0.01808316f, -0.05380247f, -0.06745533f, -0.02466181f, -0.11068040f, 
    0.08409408f, 0.04851687f, 0.02949764f, 0.17405096f, 0.12335648f, 0.07101057f, 0.08032133f, -0.02077601f, 
    0.11935496f, -0.01894818f, 0.05646919f, -0.10189116f, -0.10980252f, -0.12529954f, -0.05598226f, 0.00918825f, 
    -0.05294329f, -0.07919253f, -0.01933515f, -0.01706938f, 0.01442122f, -0.14992712f, 0.04536658f, 0.16944899f, 
    -0.26121736f, 0.04735260f, -0.24041909f, 0.07729393f, 0.10356931f, 0.08430661f, 0.05847216f, -0.06004157f, 
    0.05757724f, 0.05823367f, -0.00869035f, 0.06722600f, -0.09371293f, 0.01572302f, 0.00602063f, 0.08675165f, 
    0.08548716f, -0.00155655f, 0.01164056f, 0.05471151f, 0.08977097f, -0.09156927f, 0.02349878f, -0.16852197f, 
    -0.09954011f, 0.09731100f, 0.14634205f, -0.04550536f, -0.01594778f, 0.04761519f, -0.01260551f, 0.07144203f, 
    0.03917066f, -0.00095807f, 0.25638357f, 0.20586927f, 0.00758133f, -0.16520429f, -0.11079931f, -0.06795290f, 
    0.12010898f, 0.11490796f, -0.08891045f, -0.20926565f, -0.06936703f, 0.01261068f, 0.00918411f, 0.06903911f, 
    0.00586911f, -0.04630816f, -0.00345607f, 0.01697338f, -0.01778182f, 0.05937962f, -0.30072573f, -0.04968977f, 
    0.17663024f, 0.14532167f, 0.18368730f, -0.04447576f, 0.08533078f, 0.05712351f, 0.06329285f, 0.05039771f, 
    -0.08361277f, -0.07143184f, 0.01452755f, 0.04554545f, 0.04676896f, -0.07825615f, -0.21102619f, 0.00409223f, 
    0.06115057f, 0.21294133f, 0.14436013f, -0.02200415f, -0.18226048f, -0.04702037f, 0.05460365f, 0.07682554f, 
    -0.07731131f, -0.02875379f, -0.13377939f, -0.16598083f, 0.00439445f, -0.01990015f, 0.02624754f, 0.08002957f, 
    0.12169281f, 0.05108622f, -0.10543109f, -0.01659811f, 0.16175655f, 0.03494229f, -0.05636949f, -0.18144536f, 
    -0.01464116f, -0.11316336f, -0.03558642f, -0.00457047f, 0.03551533f, 0.04784950f, 0.03683021f, 0.16947676f, 
    0.00545631f, -0.04717666f, 0.11404319f, -0.07240348f, -0.09087896f, -0.00502180f, -0.11230436f, 0.06239889f, 
    -0.02687793f, -0.10705453f, 0.05828155f, -0.00698907f, 0.04541769f, -0.21507639f, -0.12314653f, -0.12990555f, 
    -0.00905003f, 0.00992091f, -0.05927288f, 0.08021889f, 0.16016670f, -0.08174336f, -0.00617543f, 0.10158800f, 
    0.11391385f, 0.07452624f, -0.02109315f, 0.01578358f, -0.10905211f, 0.00458009f, -0.06840362f, -0.12504344f, 
    0.10141984f, 0.06440549f, -0.00821071f, 0.07728413f, -0.08542762f, -0.24284495f, 0.08695913f, -0.15794155f, 
    -0.12666444f, 0.07791651f, 0.05114888f, 0.11289275f, -0.02408914f, -0.06117414f, -0.05640168f, 0.13223223f, 
    0.09616023f, 0.00009467f, -0.03904453f, 0.01347529f, 0.21768057f, -0.10778769f, -0.14559530f, -0.22064961f, 
    -0.00004356f, 0.04027679f, 0.07168202f, -0.08793090f, -0.05191756f, -0.06594858f, 0.03846335f, 0.02478312f, 
    -0.03420051f, -0.02126320f, -0.02181178f, -0.04476055f, 0.00200899f, 0.15705277f, 0.10633748f, 0.18625678f, 
    -0.01986818f, -0.03062037f, 0.02774024f, 0.02553224f, -0.06918976f, -0.01833832f, 0.15196007f, -0.13704610f, 
    -0.01172636f, 0.00915774f, -0.03850621f, -0.28538296f, -0.06858110f, 0.06181136f, -0.05699662f, 0.10244125f, 
    -0.00178764f, -0.16663747f, -0.01815076f, -0.03784781f, 0.22920617f, 0.12773041f, 0.16360672f, -0.22362827f, 
    -0.15864834f, 0.05762168f, 0.19008391f, 0.05312682f, 0.08566982f, 0.27658072f, 0.09823171f, 0.06962237f, 
    -0.18720450f, -0.16596536f, -0.02890494f, 0.17475413f, 0.05184668f, -0.01138984f, 0.12954520f, 0.06095266f, 
    -0.01804228f, -0.15402170f, -0.13154638f, 0.01678223f, 0.14843936f, 0.11654672f, 0.05159115f, -0.16217315f, 
    -0.09371899f, 0.02165163f, 0.02399283f, 0.10036300f, 0.04391468f, 0.02805139f, -0.15548834f, -0.05723431f, 
    -0.05506835f, 0.00144623f, -0.03964095f, 0.04246220f, -0.03419739f, -0.02149776f, -0.04556262f, -0.06022488f, 
    -0.02358253f, -0.03485788f, -0.00947230f, 0.01975091f, 0.01965514f, -0.02063578f, -0.00086125f, -0.00967813f, 
    -0.03230249f, 0.02618830f, -0.03599357f, -0.03362739f, 0.03542400f, 0.01192114f, -0.05606539f, 0.01064638f, 
    -0.03428500f, -0.03632475f, -0.05581795f, 0.05639505f, -0.02118932f, -0.04873938f, -0.00771382f, 0.02115997f, 
    0.03598938f, 0.04047537f, -0.03882851f, -0.01589901f, 0.00969066f, 0.02209708f, 0.03570653f, -0.02038634f, 
    0.00715841f, 0.04509235f, -0.00450012f, 0.02555545f, 0.00468579f, 0.02107870f, -0.06352055f, -0.02579999f, 
    -0.01669362f, -0.06190519f, 0.01607481f, 0.02667745f, 0.00567525f, 0.01403882f, -0.05355004f, 0.04499500f, 
    0.02966999f, 0.01361272f, -0.04444699f, -0.03538216f, -0.03483177f, 0.01949235f, 0.02302914f, -0.04764425f, 
    0.04907946f, -0.02673358f, 0.00502819f, 0.02350948f, 0.03832979f, 0.01770173f, 0.02490575f, 0.03121104f, 
    -0.01898701f, 0.04900263f, -0.05241227f, 0.00660843f, 0.00375224f, -0.01561128f, -0.01290905f, -0.04800093f, 
    0.01356175f, 0.04166503f, -0.05156080f, 0.01298284f, -0.04058116f, -0.02026264f, 0.01112862f, -0.02487614f, 
    -0.02536741f, 0.00158861f, 0.02657922f, -0.01709258f, -0.03673612f, 0.00575014f, 0.01642898f, -0.01836598f, 
    -0.03763504f, 0.01304687f, 0.03515448f, 0.02751150f, -0.03063541f, -0.03539818f, 0.04289068f, 0.04408590f, 
    -0.06699033f, 0.00860405f, -0.05903866f, -0.05308811f, -0.00610306f, -0.03314208f, 0.06129678f, -0.06270166f, 
    -0.03520329f, 0.01059060f, -0.02398992f, -0.02916377f, 0.01483651f, -0.02519445f, 0.00701488f, -0.05214522f, 
    -0.01855585f, 0.02494173f, -0.02109539f, -0.03488232f, 0.04542838f, -0.03789300f, 0.02901885f, 0.02762549f, 
    -0.02430855f, -0.01647751f, 0.01116698f, -0.01633197f, -0.01976060f, 0.03060841f, -0.05763979f, 0.01597273f, 
    -0.05917012f, -0.05315512f, -0.04284063f, -0.01300926f, 0.03793352f, 0.00783657f, -0.00289870f, -0.06429596f, 
    0.03426284f, -0.04149374f, -0.06570713f, 0.00271968f, 0.04286283f, 0.02631866f, -0.04323595f, -0.04109243f, 
    -0.00575194f, -0.06142821f, -0.00355412f, 0.00878906f, -0.05872022f, 0.03216558f, 0.03344665f, -0.00595711f, 
    -0.00786731f, 0.02234768f, 0.03531374f, -0.06030417f, 0.00840220f, 0.03012671f, 0.02070410f, 0.02877406f, 
    -0.00292651f, 0.04517467f, 0.00988947f, -0.02696582f, 0.04729118f, 0.00412939f, -0.02247741f, -0.04394438f, 
    0.01285471f, 0.02831044f, -0.02298568f, 0.04044990f, -0.01116677f, 0.04419265f, -0.02806273f, -0.00256714f, 
    -0.02399540f, 0.01270031f, 0.03090038f, 0.00389642f, 0.03562552f, -0.01749064f, -0.04833512f, -0.05574339f, 
    -0.03397997f, 0.03477223f, 0.05126813f, 0.04831306f, -0.00414657f, -0.03368953f, 0.03260808f, 0.02012982f, 
    0.04243615f, -0.03704942f, 0.00997063f, -0.05033186f, 0.02969763f, 0.00035932f, -0.02231647f, -0.01496084f, 
    -0.05082681f, 0.05531361f, 0.02246865f, 0.05267232f, 0.00686922f, -0.06018866f, 0.01103755f, 0.03485649f, 
    -0.03495193f, -0.04417784f, 0.01393992f, -0.03147493f, 0.03366528f, -0.04520915f, 0.03646098f, 0.01381474f, 
    0.02835672f, 0.00527794f, 0.03536967f, 0.00444183f, -0.01886245f, -0.00693076f, 0.01557404f, -0.03219293f, 
    -0.02723548f, 0.03318616f, -0.01486355f, -0.04829812f, -0.03780455f, 0.04750371f, -0.02650689f, -0.03197416f, 
    0.03650541f, -0.01131129f, 0.02781004f, -0.03862686f, 0.01025388f, 0.01289319f, -0.01995332f, -0.00388516f, 
    0.01022583f, 0.00657210f, 0.02142934f, 0.01833281f, -0.00728116f, -0.04528812f, -0.05287853f, -0.02507956f, 
    -0.04573814f, 0.01051801f, -0.02059715f, -0.02328669f, 0.00186543f, -0.02322986f, -0.02147705f, -0.06329105f, 
    -0.05673279f, 0.03363612f, -0.01831296f, 0.00939052f, -0.01185507f, 0.04555463f, 0.00360578f, -0.00140508f, 
    -0.05490286f, -0.00446703f, -0.03579039f, -0.06571309f, 0.02031998f, -0.02839638f, -0.05424114f, -0.04832551f, 
    -0.02603174f, 0.03328888f, -0.05337525f, -0.03768064f, 0.02515810f, -0.06903789f, 0.04029843f, -0.02509088f, 
    -0.24048123f, 0.02229393f, 0.11144760f, 0.27038512f, -0.15165482f, 0.11296565f, -0.04952779f, 0.07760796f, 
    -0.03276398f, 0.16484031f, 0.08312622f, -0.03614443f, -0.07428937f, 0.03818252f, -0.01737974f, 0.01629642f, 
    -0.05842937f, 0.00336811f, 0.29728845f, -0.05689627f, -0.03306950f, -0.07567063f, -0.02027329f, 0.21328402f, 
    0.00341079f, 0.01142874f, -0.09458812f, 0.01149542f, 0.13494462f, 0.11553472f, 0.10807884f, -0.01741428f, 
    -0.15833718f, -0.12373153f, 0.11234966f, 0.06634442f, -0.05264528f, -0.02754871f, -0.01422110f, 0.05978077f, 
    0.03061025f, -0.07775161f, 0.02119036f, 0.04837574f, 0.13925000f, -0.27316573f, -0.05793708f, 0.28206733f, 
    -0.16233726f, 0.05659494f, -0.13502133f, 0.00007139f, 0.00384035f, 0.12999710f, 0.10064024f, -0.09878571f, 
    0.04831319f, 0.05813322f, 0.13837785f, 0.12251448f, 0.01771059f, 0.01804709f, -0.04998150f, 0.09287041f, 
    0.17153081f, -0.01279730f, 0.07466976f, -0.05232212f, 0.01146570f, 0.01209161f, 0.02579588f, -0.18096164f, 
    0.03984692f, 0.04725084f, 0.07726913f, 0.08431888f, 0.05541947f, 0.05908062f, 0.14201571f, -0.05054208f, 
    0.20800230f, 0.20145777f, 0.01205629f, 0.01666489f, 0.05934359f, 0.01795460f, 0.04833883f, 0.18394396f, 
    0.14027525f, -0.05062726f, 0.16677307f, 0.11791790f, -0.02722812f, -0.02177680f, -0.17459455f, 0.00491218f, 
    -0.06208807f, -0.01148823f, 0.05404626f, -0.06975425f, 0.02839348f, -0.09288730f, -0.02936267f, 0.05205939f, 
    -0.06850337f, 0.06788655f, 0.13386501f, 0.05649596f, -0.07152805f, -0.12763965f, 0.07897834f, 0.15840831f, 
    -0.03198409f, 0.13220380f, 0.15356216f, -0.03038089f, -0.27590200f, 0.15156180f, 0.00931842f, -0.17366230f, 
    0.09216559f, -0.12159888f, 0.05489414f, -0.01453798f, 0.05778666f, 0.14862479f, -0.01360734f, -0.05637581f, 
    -0.02773347f, 0.02537385f, 0.06387178f, 0.10881802f, 0.09085813f, -0.10806028f, -0.01805281f, 0.05562635f, 
    0.02350251f, -0.00394932f, 0.01934986f, 0.00468914f, 0.06898503f, -0.02344621f, -0.00319354f, 0.06616659f, 
    0.06041243f, 0.03846636f, -0.07854339f, 0.11586073f, -0.11005926f, -0.04912948f, -0.03167699f, 0.06919827f, 
    -0.09491269f, 0.00781766f, 0.00534667f, -0.19541247f, 0.04887114f, 0.08856388f, -0.07122533f, 0.05451447f, 
    0.06713447f, 0.03444251f, 0.05796688f, -0.08670798f, -0.01053488f, -0.00630409f, 0.04906737f, 0.04458988f, 
    0.02299679f, 0.10851189f, 0.13561015f, -0.09899066f, 0.05486763f, 0.11350242f, 0.04903171f, -0.02832882f, 
    0.06210737f, -0.08334202f, -0.09713436f, 0.06910539f, 0.19940659f, 0.23509905f, -0.12541403f, -0.02378510f, 
    0.06441551f, -0.04650499f, -0.02801162f, 0.00462096f, -0.17810126f, -0.00301350f, 0.06752873f, -0.14914852f, 
    -0.00909796f, -0.00487820f, -0.01280514f, -0.04522407f, -0.13242279f, -0.06409843f, 0.03085461f, -0.10928686f, 
    0.00941565f, 0.04152922f, -0.04882783f, 0.10833230f, 0.10357194f, 0.05884907f, -0.03574302f, 0.04689277f, 
    0.23984008f, -0.04849219f, 0.08898291f, 0.05647838f, -0.07178765f, 0.11891340f, 0.03314992f, -0.28298485f, 
    -0.27804130f, 0.00551222f, -0.03556644f, 0.03909628f, -0.02514618f, -0.04579821f, 0.04184333f, 0.01408225f, 
    0.03726533f, 0.17767470f, -0.09238702f, -0.20840393f, -0.06777334f, 0.04157042f, 0.15268302f, -0.05499249f, 
    -0.06140709f, -0.18260957f, -0.06410754f, -0.03594077f, -0.03203729f, -0.06253497f, 0.12472745f, 0.13815993f, 
    -0.02684208f, -0.10278871f, -0.13055603f, -0.22603342f, 0.03373919f, 0.11060958f, 0.04815060f, -0.04233746f, 
    -0.00983637f, -0.01940734f, 0.03908764f, -0.04596718f, 0.27903342f, -0.02660951f, 0.17744710f, -0.09793963f, 
    0.03577977f, 0.00592797f, 0.00476396f, 0.07293102f, 0.11320280f, 0.32032588f, 0.07147677f, -0.09121164f, 
    -0.13589551f, -0.20363830f, 0.02521929f, -0.16898713f, 0.04900479f, 0.01776243f, 0.29546511f, -0.11664711f, 
    -0.04319146f, 0.07450475f, -0.09026405f, 0.01059046f, 0.02169728f, 0.00689975f, 0.04732418f, 0.03562885f, 
    -0.01088362f, 0.06687798f, -0.17572998f, -0.01025829f, 0.13022307f, 0.15069221f, -0.03885608f, -0.02711442f, 
    0.02206659f, -0.04000764f, -0.07652201f, -0.22120485f, 0.13821803f, -0.03741416f, 0.02468849f, 0.05624062f, 
    -0.02597709f, 0.09620979f, 0.29923391f, 0.00978965f, -0.03377552f, -0.06505373f, 0.04326878f, -0.00076659f, 
    0.06964818f, 0.05281595f, 0.00768091f, -0.10661895f, -0.02905934f, -0.00421080f, 0.07626391f, -0.11685287f, 
    0.03057879f, 0.00835136f, 0.08950371f, 0.03888611f, -0.04021970f, -0.01987731f, -0.05304030f, 0.08450484f, 
    -0.14371368f, -0.02519231f, 0.01038768f, -0.10354089f, 0.12905197f, 0.16578911f, 0.13135141f, -0.06744449f, 
    0.06479923f, 0.11627039f, 0.07916086f, 0.04118867f, -0.22377752f, -0.02730359f, -0.11240067f, 0.07531961f, 
    0.10375462f, 0.07811845f, 0.16966508f, -0.09202989f, 0.14195910f, -0.24325235f, 0.19738916f, 0.06162401f, 
    -0.17605400f, -0.11426279f, -0.00254237f, -0.02582726f, 0.04379243f, 0.03699904f, -0.04603051f, 0.09183269f, 
    -0.16535610f, 0.09149244f, 0.04343572f, 0.04026799f, 0.07821019f, 0.08686008f, -0.01432059f, 0.10630082f, 
    0.06777440f, -0.07747970f, -0.17689215f, 0.18374020f, 0.02979463f, -0.03812801f, -0.01306500f, 0.02088036f, 
    -0.07538623f, -0.13653328f, -0.03571315f, -0.00526473f, 0.04516100f, -0.06691237f, -0.02887095f, -0.09299479f, 
    0.05830299f, -0.12713161f, 0.05132331f, 0.09530031f, -0.06212079f, -0.08406948f, 0.06042929f, 0.07742511f, 
    0.14454898f, 0.01449731f, -0.06123300f, 0.04163862f, -0.00371751f, -0.11552770f, -0.06848349f, 0.04907819f, 
    0.20042892f, -0.03841374f, -0.03980279f, -0.10497847f, -0.07500540f, 0.03307500f, 0.10828556f, 0.00853461f, 
    -0.07817135f, -0.14166825f, 0.05628403f, -0.07915416f, 0.23206924f, -0.17785297f, -0.12901671f, -0.11001506f, 
    -0.15929249f, -0.07551773f, -0.08070482f, 0.02526857f, -0.00403588f, -0.07714827f, -0.20273146f, -0.23325974f, 
    0.06363299f, 0.23638637f, 0.16115983f, 0.02798792f, -0.04984922f, -0.02500740f, -0.01074127f, 0.23493850f, 
    0.07267487f, 0.00866829f, -0.07331377f, 0.13317730f, -0.05088983f, -0.01499433f, 0.07363521f, 0.02544671f, 
    0.04604518f, 0.16728280f, 0.13603969f, -0.02763541f, 0.05048633f, 0.03724746f, -0.07242218f, 0.03255631f, 
    -0.04167296f, -0.03035625f, 0.09626722f, 0.08218227f, -0.08136200f, -0.00570945f, 0.02683584f, -0.01018673f, 
    -0.01576456f, -0.09365515f, -0.06986090f, -0.00826759f, 0.01670220f, -0.05144170f, 0.13418499f, -0.03401834f, 
    0.03882648f, 0.08005594f, -0.19362503f, 0.12164476f, 0.03833565f, -0.05420113f, 0.02244873f, -0.08675829f, 
    0.01804723f, -0.08332817f, 0.09481962f, 0.04266141f, 0.20207584f, -0.10731511f, -0.03366550f, 0.07093127f, 
    -0.10582409f, 0.05226883f, 0.09200147f, -0.03685827f, 0.08551133f, 0.08406291f, 0.20705064f, 0.09926705f, 
    0.02213812f, -0.11090601f, 0.10170633f, -0.04494540f, 0.02214931f, 0.15902162f, 0.00949124f, 0.01684555f, 
    0.02550199f, 0.13649751f, 0.13883258f, -0.17291434f, -0.03098212f, -0.03763155f, -0.06114265f, 0.23727365f, 
    -0.01978026f, 0.00723064f, -0.00788337f, -0.01115502f, -0.04239598f, 0.01318910f, -0.03011357f, 0.06814059f, 
    -0.13480489f, 0.04567169f, -0.05195130f, 0.00279027f, -0.14251937f, -0.03971773f, -0.00545458f, 0.07841693f, 
    -0.10834529f, -0.08352254f, -0.16363890f, -0.08774687f, -0.04257663f, 0.04227907f, -0.16881323f, -0.03346219f, 
    0.02598234f, 0.09395552f, -0.18702599f, -0.03690145f, -0.01815570f, 0.02651697f, 0.06410092f, -0.20143463f, 
    0.03679009f, 0.19147466f, -0.04692799f, 0.20511706f, 0.15019581f, -0.05939227f, 0.02377119f, 0.06140266f, 
    0.06708031f, -0.11077522f, -0.03572559f, -0.09691034f, -0.12279195f, 0.02035677f, -0.04405500f, -0.07566815f, 
    0.03848633f, 0.01387962f, 0.00588680f, 0.06465564f, -0.14867547f, -0.03890341f, -0.00603711f, 0.02310729f, 
    0.04562674f, 0.03887815f, 0.05214916f, 0.20196083f, 0.03909785f, -0.02530946f, 0.03030149f, 0.18318468f, 
    -0.19256762f, -0.11824781f, -0.01682664f, 0.01536382f, -0.01644879f, -0.00099974f, -0.00642419f, 0.23655458f, 
    0.06326442f, -0.04563169f, -0.01749759f, -0.04563678f, -0.11248775f, -0.16116828f, 0.06784238f, 0.04874812f, 
    0.00105774f, 0.04102838f, -0.04979081f, 0.03874962f, 0.00816438f, -0.01271465f, 0.04427265f, 0.03963546f, 
    -0.06786062f, 0.01439632f, 0.01209382f, -0.02513760f, -0.02085798f, -0.02019985f, 0.02134013f, -0.05351356f, 
    0.04372902f, 0.04257234f, 0.02915723f, -0.06158236f, -0.00099897f, -0.03732688f, 0.03839985f, 0.01504118f, 
    -0.01073961f, -0.02641400f, 0.04731743f, -0.02383897f, -0.00763668f, 0.01643629f, 0.00220484f, -0.04228124f, 
    0.04769570f, 0.03013425f, -0.02225198f, 0.03393249f, -0.04183393f, 0.02568628f, -0.06166187f, -0.00889687f, 
    0.00627140f, -0.01905364f, -0.03854599f, -0.02141110f, -0.02977562f, -0.01874909f, 0.03381619f, -0.00648723f, 
    -0.04213902f, -0.02180171f, 0.03242480f, -0.00242799f, -0.06634814f, -0.02633950f, -0.02357216f, -0.05446323f, 
    -0.00959767f, -0.00001854f, 0.01936432f, -0.04119961f, -0.02284388f, 0.00176401f, -0.00563236f, 0.01710654f, 
    0.01689170f, -0.00317406f, -0.05550491f, -0.00707042f, -0.03001017f, 0.02996951f, 0.02692942f, -0.02544791f, 
    0.00443853f, -0.01453350f, -0.02456944f, -0.06416120f, -0.05752118f, -0.00503968f, 0.04329582f, 0.03120618f, 
    0.03832849f, 0.03605740f, 0.01023943f, -0.02805442f, 0.00906642f, 0.00774239f, 0.04037414f, -0.04941046f, 
    0.00955424f, -0.02097988f, -0.00439599f, 0.00538485f, -0.00851549f, -0.05563733f, -0.05800513f, 0.05385465f, 
    0.05023611f, -0.02121513f, -0.03485337f, -0.01480051f, -0.03367892f, -0.05205728f, -0.02365828f, 0.01589131f, 
    -0.00061526f, -0.02442324f, -0.02665292f, 0.04393847f, -0.00349001f, -0.00523692f, 0.02606519f, 0.02553845f, 
    -0.04615989f, 0.03269617f, -0.00500911f, 0.03861143f, -0.03240937f, -0.04545851f, -0.04752382f, 0.04149641f, 
    0.03118358f, 0.00098837f, -0.03160332f, -0.02112100f, -0.01603645f, -0.06259607f, -0.03105645f, -0.02289115f, 
    -0.05910656f, -0.05775859f, -0.06330774f, -0.06380229f, 0.02049362f, -0.05585238f, 0.02992228f, 0.00290545f, 
    -0.02768483f, -0.04241324f, -0.00259665f, -0.04505849f, -0.03896519f, 0.01008866f, 0.02912787f, -0.00048013f, 
    0.02714301f, 0.01672024f, 0.04352554f, 0.03589864f, 0.04848282f, 0.02318910f, -0.00707709f, -0.03454753f, 
    0.03859776f, 0.03166347f, -0.01767322f, 0.02365918f, -0.04175287f, -0.02881177f, 0.01631486f, 0.03649721f, 
    0.00589519f, 0.04152417f, -0.06603357f, 0.04353251f, 0.00447344f, 0.00346088f, -0.05818515f, -0.02428412f, 
    -0.02315299f, 0.03850441f, 0.04149511f, 0.04660882f, -0.04733432f, 0.04341269f, -0.00211337f, 0.04473777f, 
    0.03309667f, 0.00568456f, 0.05954595f, -0.02265558f, 0.00982707f, -0.04674047f, -0.03895550f, 0.03989759f, 
    0.02083456f, -0.00992147f, -0.00095329f, -0.02297286f, 0.03731815f, 0.00150151f, -0.02701215f, -0.01040577f, 
    -0.06500514f, 0.03913433f, -0.03491747f, 0.03642469f, -0.05698992f, -0.06607920f, -0.03881072f, 0.00618635f, 
    -0.04049961f, -0.05234006f, 0.02089206f, 0.01464611f, -0.03168442f, -0.01329075f, -0.02042541f, -0.01213281f, 
    0.00336645f, -0.03331099f, 0.05138238f, -0.01029268f, -0.00311906f, -0.00189880f, 0.01480624f, -0.01797346f, 
    -0.05673005f, -0.00781809f, 0.03876414f, -0.00971462f, -0.02045943f, 0.04116450f, -0.03777026f, -0.04089311f, 
    0.01599457f, -0.06084479f, 0.03241926f, 0.05131794f, 0.03452426f, 0.00537899f, 0.00321657f, -0.03330301f, 
    -0.02244923f, -0.01656442f, -0.05275016f, 0.02104963f, -0.01525796f, -0.00484888f, -0.01845778f, -0.04872828f, 
    -0.05054517f, -0.06316983f, -0.04857879f, 0.01804608f, 0.05039415f, 0.04698733f, -0.05048860f, 0.04459034f, 
    0.04451070f, -0.04978510f, -0.03307392f, -0.02940986f, -0.01520142f, -0.00024003f, -0.04823254f, -0.04345841f, 
    -0.03760789f, 0.04483218f, 0.04033964f, 0.01241214f, 0.02721166f, 0.03428026f, 0.00775642f, -0.02905601f, 
    -0.01956523f, -0.01739767f, -0.03306535f, -0.01172864f, -0.01637937f, 0.02457550f, 0.01913293f, -0.05052133f, 
    0.00318304f, -0.03791013f, -0.00391709f, 0.02512873f, 0.02301911f, -0.03736452f, -0.04322876f, -0.01095552f, 
    0.03524053f, 0.00479920f, 0.03494523f, -0.02300977f, -0.04213382f, 0.04239915f, 0.03168335f, 0.04490652f, 
    -0.13497737f, 0.05402543f, -0.10095136f, 0.05131044f, 0.07580708f, -0.09627423f, 0.08752814f, 0.01118646f, 
    -0.02977251f, 0.14320949f, 0.04454372f, -0.10286327f, -0.10516885f, 0.01996588f, 0.09327456f, -0.06221778f, 
    0.07549269f, 0.08787723f, 0.18816254f, 0.25047213f, -0.06482791f, -0.04909186f, -0.03997758f, -0.07147357f, 
    0.11452168f, 0.01911227f, -0.05449017f, 0.03760093f, 0.07543638f, -0.44429848f, -0.02949008f, -0.00031580f, 
    -0.06805266f, 0.03492717f, 0.02160082f, 0.00996070f, -0.03089427f, 0.13948448f, 0.02910246f, 0.04289311f, 
    0.09849386f, 0.10419642f, -0.06104110f, 0.08356766f, 0.04454223f, 0.15622863f, 0.01617266f, -0.05853234f, 
    0.02480948f, 0.09329943f, 0.14072439f, -0.01121287f, -0.06430622f, 0.04457527f, -0.04250451f, 0.01825669f, 
    -0.02831276f, -0.07127355f, -0.11294696f, -0.09537900f, -0.07078476f, -0.02403295f, 0.01111090f, 0.15332156f, 
    -0.05582950f, -0.04318615f, -0.08531378f, 0.04526359f, -0.07037091f, -0.00247815f, 0.11480562f, 0.04903175f, 
    -0.02197978f, -0.30418348f, 0.11777847f, 0.01255372f, 0.02503928f, 0.03163889f, -0.18697321f, -0.02625548f, 
    -0.00827623f, 0.20079736f, -0.08128159f, -0.05210182f, 0.00049582f, 0.00278531f, -0.08912758f, -0.12778580f, 
    -0.08217361f, -0.06540383f, 0.30904451f, 0.21929608f, 0.00706024f, -0.09659089f, -0.04987096f, 0.00975072f, 
    0.15328418f, -0.08617856f, -0.13411580f, -0.13888976f, -0.07305879f, 0.08625508f, 0.01628899f, 0.10457959f, 
    0.03453674f, 0.02305148f, -0.05805813f, 0.07907588f, -0.18269022f, -0.01477700f, -0.09041096f, 0.02012644f, 
    0.02376310f, 0.04442147f, 0.08149526f, -0.04806914f, 0.05076679f, 0.01021858f, 0.07432116f, -0.11557327f, 
    -0.05693449f, -0.17748453f, -0.00358409f, -0.02050492f, -0.03663947f, -0.02268575f, -0.04577206f, -0.14781858f, 
    -0.15536691f, 0.01533213f, 0.04011006f, 0.03649647f, -0.07327388f, 0.03320229f, -0.01361481f, 0.22411788f, 
    0.06188517f, -0.13922361f, -0.05939256f, -0.11097517f, 0.01593048f, -0.05078685f, 0.14335890f, -0.00491581f, 
    -0.31815988f, -0.00256129f, 0.00918013f, 0.07886121f, 0.07211874f, 0.09748799f, -0.10854040f, 0.00752335f, 
    0.07618734f, 0.21042660f, -0.20466077f, -0.05425612f, -0.00215875f, 0.08759623f, 0.10509539f, 0.06782616f, 
    -0.05192812f, -0.03273465f, -0.03953942f, -0.16509852f, -0.15129019f, -0.03703177f, 0.07643979f, 0.04512850f, 
    0.07354529f, 0.05593323f, -0.00637728f, -0.11513426f, -0.11365411f, -0.05851818f, -0.08086693f, 0.02494144f, 
    0.02409972f, -0.09473286f, -0.14066966f, 0.13638943f, 0.14749762f, -0.09512134f, -0.13392173f, -0.01973742f, 
    -0.04419333f, 0.16226886f, 0.07430355f, -0.02988144f, 0.02595755f, 0.02907819f, 0.00644812f, -0.11119135f, 
    0.08053112f, 0.04735702f, 0.13069293f, -0.17075373f, -0.14199926f, 0.16238704f, -0.03425378f, -0.05328988f, 
    -0.04183216f, -0.05926605f, 0.02638130f, 0.03831974f, -0.09322701f, -0.03159730f, -0.00053657f, 0.05744314f, 
    0.05079162f, -0.03529586f, 0.12104797f, -0.01351034f, 0.08551258f, 0.01270554f, -0.10002707f, 0.01316870f, 
    0.20252208f, -0.14678368f, 0.12047063f, -0.01304557f, 0.00910492f, -0.15479024f, -0.06921390f, -0.07456871f, 
    -0.10066771f, -0.00095892f, 0.05239240f, -0.08186970f, 0.12780276f, -0.19560003f, 0.01539859f, 0.03618602f, 
    0.04916571f, -0.03713020f, 0.03234214f, 0.15642114f, -0.13253242f, 0.04638894f, 0.04202680f, -0.08511664f, 
    -0.03055790f, 0.01732125f, -0.01505811f, -0.19278912f, 0.31269854f, 0.00973785f, -0.06842085f, 0.06729535f, 
    0.11304508f, -0.08022915f, -0.13079381f, 0.03211180f, 0.12956700f, 0.03045773f, -0.20290034f, 0.09751375f, 
    -0.10553297f, -0.08431122f, -0.03615517f, 0.00982473f, 0.03388812f, 0.30134410f, 0.17816179f, -0.16074719f, 
    -0.10788585f, -0.15047409f, -0.16799362f, 0.09234093f, 0.01211823f, 0.05347999f, 0.17098692f, 0.01388540f, 
    -0.19681211f, 0.13060352f, -0.03314062f, -0.05922775f, -0.03682913f, -0.09219520f, -0.00153950f, 0.11894167f, 
    0.02900712f, -0.08497340f, 0.00781066f, 0.02112765f, 0.14662407f, -0.03705310f, 0.07489391f, -0.03431579f, 
    0.04922505f, -0.11552099f, -0.02752519f, -0.02372263f, 0.01606178f, 0.00857317f, -0.02000317f, -0.01347173f, 
    0.02038728f, -0.06859770f, -0.24827787f, -0.25535789f, -0.02608536f, 0.13529535f, 0.03448692f, -0.07990267f, 
    -0.00308043f, -0.08450490f, 0.13637741f, 0.14198919f, -0.08971970f, -0.01897966f, 0.10300340f, 0.10609952f, 
    0.04024447f, 0.02572866f, 0.04446453f, -0.16310214f, -0.23301964f, 0.04851602f, 0.01148954f, -0.03933059f, 
    0.13345790f, -0.03126876f, -0.09774540f, 0.00039474f, -0.02587735f, -0.10774190f, 0.01214916f, -0.06705010f, 
    0.15106218f, -0.05978967f, 0.07162900f, -0.03403208f, -0.03801395f, -0.16110656f, -0.31781566f, -0.02620642f, 
    0.00074949f, 0.03785168f, 0.00598810f, 0.03934434f, -0.00117188f, -0.12451974f, -0.16928758f, 0.19122252f, 
    -0.01967010f, 0.01959870f, -0.00403801f, 0.02213787f, -0.09826625f, -0.04023920f, 0.02025885f, -0.24196646f, 
    -0.07786027f, -0.18645869f, 0.07817019f, 0.04154035f, -0.09225599f, -0.05429803f, 0.04753708f, -0.02045750f, 
    -0.07407550f, 0.07109240f, -0.28958589f, -0.10751806f, -0.01733274f, 0.00513054f, 0.08533423f, 0.02414180f, 
    0.01749251f, 0.11297695f, 0.10489407f, 0.13857034f, -0.04870202f, 0.02817821f, 0.00721130f, 0.14664495f, 
    0.05855896f, 0.00698994f, 0.17324445f, 0.17025051f, 0.14264292f, -0.00858140f, -0.04007856f, -0.09187215f, 
    -0.06825349f, 0.04180996f, 0.05703668f, -0.06444778f, 0.01939265f, -0.02224479f, -0.07226219f, -0.10479445f, 
    0.08708562f, -0.03750000f, 0.01026038f, 0.07807737f, -0.00435965f, -0.09446774f, -0.11065324f, 0.17739746f, 
    0.08058658f, -0.05624559f, 0.10422352f, -0.02562807f, -0.10841417f, 0.19672713f, 0.18325852f, 0.02814171f, 
    -0.05486777f, -0.06021573f, 0.01486970f, -0.04059462f, 0.00007890f, 0.06055216f, -0.10913900f, 0.03356576f, 
    -0.23669980f, 0.00452544f, 0.10377040f, -0.00413579f, -0.03115253f, -0.13385977f, 0.00837849f, -0.03964235f, 
    -0.17064068f, 0.09684870f, -0.06487757f, 0.01132335f, 0.01897131f, -0.06470297f, 0.02096464f, 0.11296261f, 
    -0.00474807f, -0.29021564f, -0.20332515f, 0.10056628f, 0.06248452f, 0.10348979f, 0.06486092f, 0.04566218f, 
    0.02220680f, -0.03393755f, 0.06308547f, -0.02575736f, -0.00750325f, 0.07515331f, 0.03714857f, 0.08088460f, 
    -0.07765948f, 0.04606105f, -0.06481076f, -0.13662790f, 0.02832586f, 0.01854431f, -0.03776331f, 0.09465534f, 
    -0.07259720f, -0.07136414f, 0.01226448f, -0.10833230f, -0.19484736f, -0.09396692f, -0.06022201f, 0.13690375f, 
    -0.01152843f, 0.01864678f, 0.06908968f, 0.03386222f, -0.03921892f, -0.25413507f, -0.10990753f, -0.04287366f, 
    0.00354259f, -0.05020531f, -0.02594904f, -0.05559555f, 0.05736902f, -0.09793893f, -0.21673331f, -0.12981729f, 
    0.03720218f, 0.06510721f, -0.12034660f, 0.09384214f, -0.03958308f, -0.07920972f, -0.02009878f, -0.24655016f, 
    -0.07667159f, -0.02370739f, 0.08273723f, 0.13961697f, 0.11417004f, 0.02948949f, 0.02276762f, 0.12369343f, 
    -0.16109516f, -0.03147659f, -0.05872548f, 0.13301423f, 0.08703454f, 0.05887794f, -0.01553297f, -0.12158285f, 
    0.22559752f, 0.11212681f, 0.13160010f, -0.04990349f, -0.12068323f, 0.11526925f, 0.01799948f, 0.09906636f, 
    0.02345079f, -0.05061841f, 0.10968774f, -0.00939748f, -0.01409242f, 0.01842773f, 0.13898420f, -0.06764019f, 
    -0.07995248f, 0.02341689f, 0.19856071f, -0.05943836f, -0.05310394f, 0.03693880f, -0.05989117f, -0.02345130f, 
    -0.15326878f, -0.10134912f, 0.07566743f, -0.27532518f, -0.09046286f, -0.23160811f, -0.00002955f, 0.06717426f, 
    0.05714376f, 0.06687498f, 0.09963095f, 0.03884429f, 0.12068829f, 0.28727567f, 0.22256215f, -0.14328015f, 
    0.01450515f, -0.02548637f, 0.19084892f, 0.06482894f, 0.01322514f, 0.26979196f, 0.18999258f, 0.15699083f, 
    -0.00064638f, -0.01379939f, 0.03489274f, 0.02252638f, 0.03188964f, -0.07157207f, 0.11353635f, 0.07119031f, 
    0.13326207f, -0.07913637f, 0.00233694f, -0.12642217f, -0.06446273f, -0.07869104f, 0.11221592f, -0.10041074f, 
    -0.13180520f, -0.17620690f, -0.08783181f, -0.01577770f, 0.03154721f, 0.03961569f, 0.02106654f, -0.00736639f, 
    0.16158538f, 0.12327281f, -0.10911336f, -0.23949601f, -0.02649428f, 0.00005212f, 0.01641621f, -0.11530440f, 
    0.00956212f, 0.05017925f, 0.07730752f, 0.04297805f, -0.03773962f, 0.08879648f, -0.03171772f, 0.06847287f, 
    -0.01370510f, 0.05421150f, 0.12999000f, -0.07896899f, -0.03785094f, -0.10569026f, -0.09965136f, -0.10020173f, 
    0.08961862f, 0.05518308f, -0.04476771f, -0.04283552f, -0.08986943f, -0.04340185f, -0.01785369f, 0.04651982f, 
    0.09242652f, 0.21394219f, 0.22442594f, -0.04700913f, -0.21265346f, 0.00904859f, -0.10446598f, 0.14789261f, 
    0.03109447f, 0.10666233f, -0.00253531f, 0.03090500f, 0.01860061f, -0.14777836f, 0.01109059f, 0.10226106f, 
    0.20681210f, 0.00079623f, 0.13017522f, 0.13510570f, -0.10964139f, -0.02464333f, 0.09610551f, -0.25455293f, 
    -0.10370333f, -0.08942701f, -0.05660179f, 0.01102222f, -0.05466143f, 0.08885336f, -0.01863886f, 0.15018368f, 
    0.01858750f, -0.02651537f, -0.11368274f, 0.03870398f, -0.18823937f, 0.05204127f, 0.01410513f, -0.07608564f, 
    -0.09246431f, 0.02088429f, 0.07712619f, 0.04030850f, 0.15881272f, -0.21946207f, 0.08926760f, -0.07415511f, 
    -0.02621554f, -0.16406827f, -0.00363719f, 0.00357941f, 0.00284736f, -0.09368803f, 0.00064715f, 0.03416166f, 
    -0.07333671f, 0.10199832f, 0.07224259f, 0.05270094f, -0.00100935f, 0.01806195f, 0.03777699f, 0.22705130f, 
    -0.01235754f, -0.08201431f, 0.08673884f, 0.15095378f, 0.01055233f, -0.06843772f, 0.08387078f, -0.03855075f, 
    0.09002633f, -0.09745454f, 0.16072027f, 0.11427108f, 0.03904304f, -0.09699690f, 0.10503262f, 0.04035427f, 
    0.01737102f, -0.06760045f, 0.02047491f, -0.09987552f, -0.22113256f, -0.01296461f, 0.10187273f, -0.04900577f, 
    0.00400345f, -0.03122796f, 0.09208766f, 0.02116719f, -0.06258230f, 0.08804363f, 0.01567461f, 0.00561230f, 
    0.07512262f, -0.06802102f, 0.00912442f, -0.10036063f, 0.04062774f, -0.08354738f, 0.03160545f, -0.13105880f, 
    0.02064430f, 0.16035356f, -0.01681864f, -0.09438816f, -0.00098267f, 0.12147979f, 0.06275318f, -0.02496250f, 
    0.10372185f, -0.04199190f, 0.04825561f, 0.05736690f, 0.03119464f, -0.00243476f, -0.04355630f, 0.09487156f, 
    0.02222509f, 0.21779573f, 0.02426867f, 0.08813060f, -0.11166386f, -0.03878843f, 0.09771868f, -0.05149112f, 
    -0.01991535f, 0.00763769f, -0.22094539f, -0.05310348f, -0.02451541f, 0.16608958f, 0.10219323f, 0.00139172f, 
    -0.02982054f, 0.02527023f, 0.02186255f, -0.09650014f, -0.19074371f, -0.00945076f, -0.08334062f, 0.00493525f, 
    -0.02634309f, 0.09804353f, 0.06726483f, 0.10959046f, 0.05215632f, 0.01257660f, 0.11328586f, 0.12125004f, 
    -0.02744650f, 0.03325843f, -0.03849822f, 0.07462511f, 0.11677956f, -0.07638136f, 0.13760881f, 0.10641289f, 
    -0.01773731f, -0.02359303f, -0.09190353f, -0.10172712f, 0.04639779f, 0.16070183f, -0.10741545f, -0.00438846f, 
    0.06900832f, 0.08448470f, -0.09065578f, -0.10535850f, -0.05294336f, 0.04711207f, -0.03035693f, 0.03587089f, 
    0.10866081f, 0.05008747f, 0.09618776f, 0.04960444f, -0.02295174f, 0.01179724f, 0.09708040f, 0.02959616f, 
    -0.35345361f, -0.15826020f, -0.08538587f, 0.15396163f, 0.02377726f, 0.03296435f, -0.14561872f, -0.14939809f, 
    -0.06096268f, 0.17655540f, -0.01818988f, -0.00142126f, -0.05630444f, -0.12051872f, -0.10317004f, 0.03797250f, 
    0.00261057f, -0.00384214f, 0.17580546f, -0.00789002f, 0.16249686f, -0.01459055f, -0.18014766f, -0.14373593f, 
    -0.01346904f, -0.11053404f, 0.08824788f, 0.06216067f, -0.14691125f, -0.07256149f, 0.01438208f, 0.15040828f, 
    0.11642267f, 0.05459772f, -0.05264696f, -0.10298333f, -0.02214677f, -0.25516185f, -0.07911469f, -0.02063709f, 
    0.05181713f, 0.21123697f, 0.12181725f, -0.09805015f, -0.12775137f, -0.06133721f, -0.22621481f, -0.07860950f, 
    0.00692838f, -0.01051756f, 0.23994270f, 0.18307561f, 0.05951921f, -0.06212398f, 0.20290236f, -0.03900363f, 
    0.11953874f, -0.12257814f, 0.03205154f, 0.08108031f, -0.04125319f, -0.05620566f, -0.01646220f, -0.02653999f, 
    0.14755629f, -0.00934680f, 0.02208578f, -0.07304946f, -0.08689298f, -0.03197064f, 0.07791224f, 0.06155030f, 
    0.25565994f, 0.05215871f, -0.04681941f, -0.25346732f, 0.03432143f, -0.01825573f, -0.04488894f, 0.10649047f, 
    0.03131667f, -0.02449223f, 0.15297136f, 0.17448232f, 0.00255144f, 0.10450076f, -0.00775091f, -0.04812746f, 
    -0.04299376f, -0.08937128f, -0.08779970f, -0.14803125f, 0.02805006f, -0.08783471f, 0.00372902f, -0.06145918f, 
    -0.14959356f, -0.06393012f, 0.07057314f, 0.02182566f, -0.15509856f, 0.13506481f, 0.08137446f, -0.02212301f, 
    -0.06083068f, -0.11022111f, 0.02828556f, 0.03334504f, 0.15515713f, -0.01062451f, 0.14361691f, -0.08020162f, 
    -0.01045774f, -0.10809495f, -0.01170125f, -0.04309391f, 0.02430087f, 0.02888064f, 0.19728664f, -0.27210903f, 
    0.06539477f, 0.01689356f, 0.11567766f, 0.04588766f, 0.13603310f, 0.02502354f, 0.17282380f, 0.00485405f, 
    -0.04631495f, -0.05718006f, 0.04851405f, -0.04850954f, -0.01188734f, -0.00627859f, -0.07425708f, 0.15953344f, 
    -0.11116305f, 0.25811061f, 0.12542436f, 0.03186426f, -0.06339833f, -0.08432765f, -0.02099176f, -0.14142951f, 
    -0.27930149f, -0.01932140f, 0.03887365f, -0.05862555f, 0.11476590f, -0.05461799f, 0.03338979f, 0.04382142f, 
    0.08119290f, -0.22363588f, 0.13330945f, -0.13100278f, 0.01802019f, -0.09585013f, -0.09411348f, -0.16341382f, 
    0.00397722f, -0.04535489f, -0.04415204f, -0.16858822f, -0.08780973f, -0.10946817f, 0.03784155f, 0.12820841f, 
    -0.05113628f, -0.01621785f, 0.08562362f, 0.01832079f, -0.18481365f, -0.09003957f, -0.23299430f, 0.04499846f, 
    0.07507635f, 0.03240711f, -0.08372132f, 0.00171445f, 0.17599975f, -0.09391337f, 0.27111211f, 0.04128893f, 
    -0.01463802f, 0.11156111f, -0.07999706f, 0.01801833f, -0.14578743f, -0.10092207f, 0.08033924f, -0.00196093f, 
    -0.15258415f, 0.00919178f, -0.09944364f, -0.03062950f, -0.10588536f, 0.12284809f, -0.14233907f, -0.10824283f, 
    0.04303000f, 0.04212527f, -0.00772215f, 0.07084273f, 0.06861302f, -0.04147189f, -0.01506564f, -0.33846113f, 
    0.16599183f, 0.11642554f, -0.03748658f, -0.03301218f, -0.03431210f, 0.11577754f, 0.00880084f, 0.01363874f, 
    0.19639175f, 0.04384378f, 0.17252246f, 0.09849729f, 0.04714431f, -0.02581948f, -0.09139578f, 0.03915624f, 
    0.00129726f, 0.08611757f, -0.24641113f, 0.02832351f, -0.01351446f, -0.01477727f, -0.00507470f, -0.00495536f, 
    -0.03135487f, -0.06225853f, -0.11645947f, -0.04946573f, 0.01650043f, -0.15735674f, -0.01905757f, -0.08019389f, 
    0.09660063f, 0.04133676f, -0.02420098f, 0.03041282f, 0.08740784f, -0.03318952f, -0.11876827f, 0.00012798f, 
    0.17697346f, -0.00428817f, 0.02045551f, 0.08196119f, -0.05819957f, -0.02693817f, 0.22169878f, 0.23614191f, 
    0.07486802f, 0.15255347f, -0.11932471f, 0.00936490f, 0.02540255f, -0.21836329f, 0.06547675f, 0.14796823f, 
    -0.04732699f, 0.00070095f, 0.05036373f, -0.03288854f, 0.10316408f, 0.04361926f, -0.13660486f, 0.01626239f, 
    0.07223076f, -0.17987753f, -0.03263516f, -0.02758150f, 0.03867944f, 0.01184220f, -0.06005055f, -0.03774592f, 
    0.02014896f, 0.21693186f, 0.10964505f, 0.12888026f, 0.02444804f, -0.00475911f, 0.06046071f, 0.11476026f, 
    0.01649615f, 0.01385782f, -0.18328983f, -0.06060314f, 0.00595613f, -0.04884583f, -0.07119798f, 0.02601181f, 
    0.08696597f, 0.14229336f, -0.10683273f, -0.09836623f, -0.04616584f, -0.01346572f, -0.09788270f, -0.01456379f, 
    0.00653955f, 0.08735337f, -0.11838820f, 0.08450366f, 0.03113393f, -0.03082174f, 0.01190996f, -0.27739924f, 
    -0.05556938f, -0.08769321f, 0.08033472f, 0.10404684f, -0.02975501f, -0.11490193f, 0.03888009f, -0.01330973f, 
    -0.05068927f, 0.02702877f, -0.08894889f, 0.07992650f, -0.17062028f, 0.01876315f, -0.04732028f, 0.06580226f, 
    -0.01006172f, -0.08658614f, -0.01225018f, -0.04983020f, -0.10094107f, 0.01962255f, -0.12548441f, -0.05655469f, 
    -0.06494451f, -0.06604102f, 0.07432468f, 0.04552117f, 0.12126251f, 0.10407026f, 0.06404693f, 0.12695128f, 
    0.17159557f, 0.04364783f, 0.03277271f, -0.00453808f, -0.05590632f, -0.00294166f, -0.01190929f, -0.07129811f, 
    0.09497669f, 0.10845079f, 0.09817614f, 0.04973412f, 0.10684469f, -0.04351266f, 0.00550002f, 0.06938014f, 
    0.04964642f, 0.10457014f, -0.09845760f, -0.00771354f, -0.20521899f, 0.02221763f, 0.08101921f, 0.06584693f, 
    0.03660781f, -0.21867047f, -0.22476804f, -0.14426129f, -0.01851909f, 0.08098377f, -0.01575040f, -0.04884354f, 
    0.03342681f, 0.03422460f, 0.07781879f, 0.13661309f, 0.12053825f, -0.07605250f, -0.01288956f, -0.01415337f, 
    0.00093413f, -0.05283818f, 0.08256053f, 0.06663254f, -0.38632840f, 0.30766994f, -0.01898920f, -0.01187510f, 
    -0.12905568f, -0.20860489f, 0.00379406f, 0.05115842f, 0.11149079f, -0.16256855f, 0.01484265f, 0.01991049f, 
    0.17912574f, 0.11560509f, 0.03754330f, -0.05932938f, -0.06227103f, -0.08413197f, -0.38957205f, -0.20373096f, 
    0.00246515f, -0.02985762f, -0.00129470f, 0.06916882f, -0.07261533f, -0.13108014f, 0.10916065f, -0.07830966f, 
    -0.25430578f, 0.03247543f, -0.11224168f, -0.08804592f, 0.05160758f, 0.05570730f, -0.02028798f, 0.00305588f, 
    0.08883083f, -0.18617439f, 0.04887016f, 0.10181187f, -0.02545505f, 0.12524900f, 0.06359999f, 0.06352233f, 
    0.16060153f, -0.15852103f, -0.09843968f, -0.05761104f, 0.00530717f, 0.01144165f, -0.00658965f, 0.10466016f, 
    -0.06068311f, 0.16589119f, 0.04244778f, -0.03618009f, 0.06599292f, -0.10237987f, 0.01346934f, -0.03700499f, 
    0.03832760f, -0.05837333f, 0.15286581f, 0.20893045f, 0.26798531f, 0.11059463f, 0.00957218f, -0.12277245f, 
    0.00375544f, 0.07323275f, -0.11379947f, 0.02322197f, -0.01826025f, 0.04793599f, 0.01086218f, -0.05804621f, 
    -0.03459472f, 0.16023156f, 0.04031583f, 0.03742288f, 0.04531624f, 0.05494705f, -0.06316674f, -0.03648090f, 
    0.01769415f, 0.01903833f, -0.17157310f, 0.07046571f, 0.04278667f, -0.15001956f, 0.23412727f, 0.19626345f, 
    0.00655587f, 0.07333758f, -0.00655664f, -0.07467595f, 0.03556903f, -0.10130566f, 0.13156880f, 0.01360301f, 
    -0.18134136f, 0.17479107f, 0.12150060f, 0.06359072f, 0.09693444f, -0.08291908f, -0.03583178f, -0.07116628f, 
    -0.05903804f, 0.11328987f, 0.05572341f, -0.01185060f, -0.05974825f, 0.09234427f, -0.09822726f, -0.00451723f, 
    0.01708789f, 0.02227374f, -0.06907704f, -0.01662726f, 0.03745897f, 0.04442677f, -0.13347580f, -0.00685119f, 
    -0.13529879f, 0.12955070f, 0.03745767f, 0.15905491f, -0.12278999f, 0.00999999f, -0.01317555f, -0.09746206f, 
    -0.01887701f, -0.07642441f, -0.19894135f, 0.11560694f, 0.15415968f, 0.09655569f, 0.01169527f, 0.02574635f, 
    -0.05351250f, -0.01956824f, 0.04109820f, -0.03922234f, 0.04685582f, -0.35628682f, 0.17945454f, 0.00376348f, 
    0.03428175f, -0.07034928f, -0.03346461f, 0.12275704f, -0.29308835f, -0.02723444f, -0.02206079f, 0.06935852f, 
    0.02968669f, 0.10544467f, -0.10003135f, -0.05059981f, -0.05946178f, -0.14410356f, 0.00895120f, 0.10659134f, 
    0.01549241f, 0.05789898f, 0.09618270f, -0.01936035f, -0.00861996f, -0.10642046f, 0.18479487f, -0.00951310f, 
    0.08237516f, 0.15838295f, 0.04964282f, -0.00632447f, 0.00520594f, -0.01318611f, 0.09940965f, -0.35947582f, 
    -0.16198525f, -0.13834749f, 0.11009656f, 0.18029073f, 0.07233384f, -0.18625885f, -0.06238574f, -0.06146078f, 
    0.11271939f, -0.08157246f, -0.09723575f, -0.02424938f, -0.08160978f, 0.05861839f, 0.12597686f, -0.08095939f, 
    -0.10494936f, 0.19370511f, 0.15515815f, -0.04213390f, -0.10491300f, 0.13273354f, -0.01430994f, 0.04215179f, 
    -0.04980319f, 0.04489207f, 0.11273056f, 0.03336691f, 0.05880676f, -0.08338828f, 0.02592738f, 0.01970333f, 
    -0.04311806f, -0.04053682f, 0.04075775f, -0.15950498f, -0.14463080f, -0.07186580f, 0.07021990f, 0.07545630f, 
    -0.04180765f, -0.01820039f, 0.07225318f, -0.17386793f, 0.05633204f, 0.09627192f, 0.07122811f, -0.02056332f, 
    0.09024951f, -0.01911498f, 0.03769561f, 0.00180704f, 0.04887760f, 0.25693208f, 0.19104584f, 0.15324387f, 
    0.12437121f, -0.03837941f, -0.13921654f, -0.05863859f, -0.06590864f, -0.01115715f, -0.08529302f, 0.18846571f, 
    0.04836887f, 0.02430387f, 0.11117803f, 0.02584106f, -0.00589592f, 0.09966699f, -0.08512125f, -0.22927107f, 
    -0.12101886f, -0.18432039f, 0.09742950f, 0.12882073f, 0.00612237f, 0.11297080f, 0.04383608f, -0.01052568f, 
    -0.58868384f, -0.44019023f, -0.05867691f, -0.01542133f, 0.05924301f, -0.04501228f, 0.05353650f, -0.04391347f, 
    -0.15302397f, 0.08508290f, -0.14931139f, -0.13278610f, -0.01130816f, 0.12168077f, -0.00205631f, 0.10385885f, 
    0.03123497f, -0.10113803f, 0.04934523f, 0.11496803f, -0.26127511f, 0.10710411f, -0.00839389f, 0.00230176f, 
    0.02429311f, 0.00201897f, 0.06209685f, 0.08491455f, -0.10331178f, -0.26033512f, 0.05415125f, 0.00204747f, 
    -0.01327934f, -0.08590746f, 0.00682616f, 0.12544112f, -0.03184153f, 0.23514420f, 0.06266019f, 0.11961399f, 
    0.14460726f, -0.05295220f, 0.09856591f, 0.18531375f, -0.01490051f, 0.01524252f, -0.15140142f, 0.15120482f, 
    -0.09389064f, -0.00130529f, -0.17591408f, 0.09677273f, 0.10281986f, 0.04233016f, -0.15083374f, 0.10938561f, 
    0.18167210f, 0.00622177f, 0.14901744f, -0.08914471f, 0.05877199f, -0.01737161f, 0.03563043f, -0.28457484f, 
    -0.27795845f, 0.14883605f, -0.00988865f, 0.13010900f, 0.05366182f, -0.02881537f, 0.02070148f, 0.03614629f, 
    -0.01921283f, -0.07923153f, 0.02376135f, 0.12278548f, 0.10889494f, -0.11398551f, -0.00613867f, -0.02164624f, 
    -0.06846844f, -0.16412982f, 0.06393940f, 0.12572740f, 0.02428778f, 0.00124201f, -0.08833289f, 0.00129903f, 
    -0.01109128f, 0.03642439f, 0.07369691f, 0.09491213f, 0.01042925f, -0.03991465f, -0.05904137f, 0.08169104f, 
    0.09935649f, -0.00649759f, 0.00774339f, -0.36510614f, -0.00082250f, -0.01693620f, -0.03136270f, -0.04883348f, 
    0.01359996f, -0.03415721f, -0.05765126f, 0.07168996f, -0.14727007f, -0.22164527f, -0.02255721f, 0.15423109f, 
    0.00749835f, 0.09633289f, 0.05182588f, -0.08115526f, -0.06029961f, 0.10136819f, -0.00405296f, -0.07174546f, 
    -0.07870584f, -0.15895663f, -0.03183452f, -0.02725077f, -0.03436911f, 0.04019887f, -0.07782943f, -0.07442676f, 
    -0.12117760f, -0.03307874f, 0.09574948f, 0.09268260f, -0.03010504f, 0.03014979f, 0.07571664f, -0.08548523f, 
    -0.29483625f, -0.08573972f, -0.13542138f, 0.01976574f, -0.00936101f, -0.08025207f, 0.11465939f, -0.07795679f, 
    0.12665506f, 0.12780580f, -0.09442262f, 0.06171370f, -0.00571208f, 0.01167398f, 0.10954925f, 0.04845643f, 
    -0.00117135f, -0.16222630f, 0.09546001f, -0.27525571f, 0.00413094f, 0.03893395f, -0.00497921f, -0.00387243f, 
    0.05086191f, 0.02269886f, 0.23644838f, -0.03668787f, -0.02403816f, -0.09493784f, 0.03926877f, -0.01631314f, 
    0.05536465f, 0.04388569f, 0.02953541f, 0.04656621f, -0.37398997f, -0.22540794f, 0.04472812f, 0.16527848f, 
    -0.01542616f, 0.10560283f, 0.09252362f, 0.06661282f, 0.31868190f, 0.14590865f, 0.03139544f, 0.05348535f, 
    -0.01563526f, 0.03938435f, -0.02104651f, -0.04748857f, 0.01165981f, 0.29997042f, -0.22198233f, -0.03409234f, 
    0.09810711f, 0.07269815f, -0.11519816f, 0.10300449f, 0.00181290f, -0.06258895f, -0.00059179f, -0.57986701f, 
    0.01147663f, 0.05101051f, 0.04690340f, 0.05618365f, -0.02620590f, -0.10762287f, 0.03372966f, 0.54335278f, 
    0.17675228f, 0.06622842f, 0.05132964f, 0.04453465f, 0.00577157f, -0.07552331f, -0.03311964f, -0.05153105f, 
    0.15108047f, 0.18012990f, 0.00836874f, -0.03163718f, 0.03438281f, 0.03074555f, -0.02287797f, 0.02613669f, 
    -0.00746606f, -0.20344265f, -0.04659794f, 0.11680147f, 0.00932692f, 0.05042088f, 0.03796424f, 0.03924110f, 
    0.03539525f, 0.08415458f, 0.03382188f, -0.15554969f, -0.10908742f, -0.04766695f, -0.05075433f, 0.05148002f, 
    -0.17341492f, -0.13209790f, 0.07599434f, -0.11295116f, -0.02039324f, -0.15284219f, -0.17450781f, 0.02754279f, 
    0.08576196f, 0.01674451f, 0.05434171f, -0.01261025f, -0.09056652f, 0.17519623f, 0.03897831f, 0.02324886f, 
    0.02450028f, 0.04219557f, 0.01910069f, -0.01098842f, -0.04318471f, -0.16730148f, -0.01228031f, -0.09038592f, 
    -0.06682274f, 0.00563280f, 0.10853164f, -0.07481196f, -0.01340457f, -0.03466932f, -0.31923851f, -0.06874399f, 
    0.01322252f, -0.09636811f, -0.01920456f, -0.01924558f, 0.05698800f, -0.17628284f, 0.07761206f, 0.07080018f, 
    0.09986455f, -0.12835230f, 0.09754428f, 0.01217288f, 0.16391061f, 0.01195052f, -0.01363944f, 0.00969179f, 
    0.04574541f, -0.11700059f, 0.18967606f, -0.03554277f, 0.10826164f, -0.00555348f, 0.02591281f, 0.03120790f, 
    0.00508111f, -0.35589102f, -0.06490289f, 0.03050742f, 0.00018072f, -0.07400396f, 0.00340931f, -0.05904902f, 
    -0.02216009f, -0.00529494f, -0.00521418f, 0.21402495f, -0.07297393f, -0.02966144f, 0.00530864f, -0.04285873f, 
    0.00699653f, 0.04896798f, -0.01006695f, -0.45909315f, 0.01899767f, 0.00158098f, -0.05907232f, 0.17568022f, 
    0.07999635f, 0.11157644f, 0.04179735f, 0.10598266f, -0.08424123f, 0.09131501f, -0.02631979f, 0.03831852f, 
    -0.02520225f, 0.10888546f, -0.00208921f, 0.04344152f, 0.05572795f, 0.02047827f, -0.13671137f, -0.45444664f, 
    -0.21404654f, -0.15266800f, 0.00143189f, -0.00992828f, -0.08885050f, 0.07315351f, -0.00834457f, -0.09801430f, 
    -0.13656051f, 0.08946715f, 0.01598801f, 0.07679009f, 0.03987219f, -0.03999444f, 0.04498645f, -0.11476561f, 
    -0.13183191f, 0.20455770f, 0.01290709f, -0.06365949f, 0.05222023f, 0.03162070f, 0.04144302f, 0.02852069f, 
    -0.01162783f, -0.11400588f, -0.02063059f, 0.02661874f, 0.03994349f, -0.11903599f, -0.04955693f, 0.15012470f, 
    0.01373850f, 0.20121579f, 0.05963804f, -0.25499284f, -0.02637926f, 0.02434575f, 0.03209138f, -0.13363490f, 
    -0.05299985f, -0.05456484f, -0.15204082f, 0.08926344f, -0.13046269f, 0.13180451f, -0.10502994f, 0.00920222f, 
    0.08022375f, -0.06984415f, 0.06558072f, 0.04384295f, 0.20289113f, -0.29808614f, -0.05210198f, -0.04124466f, 
    -0.05960852f, 0.08560592f, -0.02529702f, 0.01940366f, -0.01481742f, -0.04058680f, 0.06481237f, 0.08101851f, 
    -0.01063323f, 0.01872788f, -0.00672067f, 0.02830572f, 0.17763253f, -0.03578960f, 0.13767721f, -0.19079067f, 
    0.00892563f, 0.07883147f, 0.02402234f, 0.14700921f, -0.01495929f, -0.08838367f, -0.08044464f, -0.01935622f, 
    0.09768514f, 0.05774223f, 0.07442922f, 0.06774276f, -0.05387420f, -0.02088461f, -0.02117611f, 0.35111094f, 
    0.39288646f, -0.29664668f, -0.01855049f, -0.06676423f, -0.07493839f, -0.00259764f, 0.04320678f, 0.07511622f, 
    -0.08466495f, -0.09532128f, 0.19187190f, -0.03870078f, -0.02874224f, 0.00952559f, 0.00452076f, 0.10289386f, 
    0.01299896f, -0.27990794f, 0.34489554f, -0.33499846f, 0.06995931f, -0.03795148f, 0.14035861f, 0.06250096f, 
    -0.02738465f, -0.01298469f, 0.31549942f, 0.01426945f, 0.10907870f, -0.03616504f, 0.02854456f, -0.05673393f, 
    -0.08707619f, 0.00379581f, 0.04325589f, -0.00898626f, -0.18282966f, -0.25311497f, 0.03111231f, -0.15100661f, 
    0.09421563f, -0.04166710f, -0.05664082f, 0.09802227f, 0.00518281f, -0.26747391f, 0.31711024f, 0.03769212f, 
    -0.06974854f, 0.04041837f, -0.08444192f, -0.02148748f, 0.13095671f, 0.04751631f, -0.07174698f, 0.10259518f, 
    -0.04528308f, -0.11662628f, -0.01711898f, 0.03614540f, 0.07337848f, 0.01866804f, 0.18287753f, 0.02460819f, 
    0.00330273f, 0.03176776f, -0.03142991f, -0.08838441f, 0.07514813f, 0.01918244f, 0.01733404f, -0.07041233f, 
    -0.18441077f, 0.20942244f, -0.00978626f, -0.10434031f, 0.04458107f, -0.06835448f, 0.02515386f, 0.00315489f, 
    -0.12419202f, -0.06775168f, -0.37234303f, 0.08904557f, -0.06271503f, 0.02229959f, -0.01908653f, -0.03354946f, 
    0.03866724f, 0.02260561f, 0.03510971f, -0.20741314f, 0.15210964f, -0.01134206f, -0.02503620f, -0.02098465f, 
    0.13415003f, 0.02821391f, -0.00742039f, 0.02192725f, -0.08135818f, 0.03906389f, -0.00577216f, -0.03210466f, 
    -0.04748150f, 0.00349607f, -0.08142519f, -0.22060029f, 0.15250403f, 0.13842236f, 0.17263839f, -0.06259165f, 
    -0.10066321f, -0.05752004f, -0.00758530f, -0.13784252f, 0.09203982f, -0.01826625f, -0.11280428f, 0.01527785f, 
    0.14941376f, 0.00269488f, -0.02295634f, 0.20177726f, -0.01091437f, -0.09257369f, 0.14179248f, 0.13214183f, 
    0.05982033f, -0.11688580f, -0.03386267f, -0.00733914f, 0.04353232f, 0.03918273f, 0.21799277f, 0.07421623f, 
    -0.18531734f, -0.02198884f, 0.09223442f, 0.06243145f, -0.00566894f, -0.11709016f, -0.04383490f, -0.25989997f, 
    -0.18793064f, 0.18687512f, 0.06340884f, -0.04175781f, 0.05067001f, -0.06286085f, 0.02329233f, -0.01197744f, 
    0.02863329f, -0.02948707f, -0.03670751f, -0.01225999f, -0.20890851f, -0.04998744f, 0.10310998f, -0.07607353f, 
    -0.05044965f, 0.12957957f, 0.01625323f, -0.09550469f, -0.01323854f, -0.06404458f, 0.02259425f, 0.03331970f, 
    0.05030390f, -0.14492616f, 0.06833925f, 0.09371472f, 0.14194342f, 0.10474366f, 0.03637530f, 0.01478244f, 
    -0.16775717f, 0.07414435f, -0.08399317f, -0.09668645f, -0.18944117f, 0.03947338f, 0.01419827f, 0.14918591f, 
    0.09982985f, 0.05278420f, -0.10646439f, -0.00979207f, 0.09733355f, -0.06677766f, -0.07264971f, 0.07839119f, 
    0.08096509f, -0.01030690f, -0.07416796f, -0.10717331f, 0.05562518f, -0.26646021f, 0.00091055f, -0.37651870f, 
    0.00527340f, -0.01458876f, -0.02016717f, 0.03626477f, -0.07454896f, 0.16537623f, -0.29728568f, -0.12266849f, 
    -0.03231738f, 0.13649093f, 0.05395330f, 0.01426075f, -0.03721495f, -0.02623473f, -0.09919530f, 0.09621458f, 
    -0.04662698f, -0.00568192f, 0.05119318f, 0.03572403f, -0.08977112f, -0.00056702f, 0.01242264f, -0.02972017f, 
    0.00370973f, 0.21374197f, 0.12792139f, 0.05557083f, -0.13947174f, -0.04019695f, 0.07171904f, 0.08323985f, 
    -0.02847151f, -0.09243882f, -0.01933917f, -0.02751723f, 0.08510485f, 0.04259631f, -0.06526434f, 0.00161165f, 
    -0.04397957f, 0.11038779f, -0.38100964f, -0.20606273f, -0.25565663f, 0.14493994f, 0.13919960f, 0.08675984f, 
    -0.12169591f, 0.00073654f, 0.00531193f, -0.01607754f, 0.19038488f, 0.03097386f, 0.01649158f, -0.03585212f, 
    -0.04609562f, 0.04971714f, -0.03117746f, 0.08692135f, -0.16117926f, -0.18415192f, -0.01123781f, -0.06302403f, 
    0.04739774f, 0.07286457f, -0.23174505f, 0.01065870f, -0.15647776f, -0.06282064f, 0.10488387f, 0.05993224f, 
    -0.00612074f, -0.03935941f, 0.09603124f, -0.02729768f, 0.01294267f, 0.14086302f, 0.22269799f, 0.05762019f, 
    -0.07067618f, 0.03793967f, -0.03089997f, 0.12286037f, 0.00893788f, 0.04030017f, -0.08282929f, -0.21921948f, 
    -0.03821274f, 0.04781602f, 0.07910474f, -0.09643937f, -0.03268445f, 0.13335602f, 0.09881758f, -0.01558826f, 
    0.27696279f, 0.10420920f, 0.04465556f, -0.05068537f, -0.00678144f, -0.11085261f, 0.08085964f, 0.01685666f, 
    0.01219276f, -0.01659139f, 0.04716187f, -0.18107702f, -0.04308750f, 0.00190834f, 0.07399924f, -0.12926917f, 
    0.05964018f, 0.01588132f, 0.04813844f, -0.12261496f, -0.09112449f, 0.14147918f, -0.04493580f, -0.02279673f, 
    0.06173959f, -0.09373009f, 0.07710947f, -0.20356910f, 0.07934815f, 0.02020567f, 0.04234942f, -0.01016848f, 
    -0.00391269f, 0.11261708f, -0.13229334f, -0.05438448f, 0.20589995f, 0.12397906f, 0.23577484f, -0.08700642f, 
    -0.21183616f, -0.00044831f, -0.12474775f, 0.15923946f, -0.05813036f, 0.15058081f, 0.06340820f, 0.05793491f, 
    -0.11332235f, -0.00051493f, 0.03678817f, 0.04224696f, 0.02569986f, 0.02334317f, 0.05342042f, -0.08934064f, 
    -0.03531819f, -0.13469723f, 0.01670140f, 0.05624658f, 0.09554734f, 0.01504762f, 0.04913452f, 0.29228294f, 
    0.19039115f, -0.02421755f, -0.16005297f, 0.05836482f, -0.12307235f, -0.02567621f, 0.17310165f, 0.04760271f, 
    -0.23839118f, -0.10859532f, -0.14162973f, -0.01184088f, 0.03133599f, 0.04505828f, -0.14433043f, 0.00313280f, 
    0.08095183f, 0.30778590f, 0.20895295f, 0.06178075f, 0.11452136f, -0.04002385f, 0.03491125f, -0.02191052f, 
    0.06262025f, -0.01788349f, 0.26602051f, 0.01581007f, -0.00976187f, 0.09151356f, -0.02489474f, 0.00277513f, 
    -0.04252177f, -0.05392905f, -0.01262100f, -0.03139914f, 0.10972904f, -0.07364435f, -0.02228836f, -0.00974765f, 
    0.04925009f, 0.07867240f, 0.01954012f, 0.18540493f, -0.29870868f, -0.27997804f, -0.08569944f, 0.08797555f, 
    -0.00701845f, -0.05793208f, 0.18218388f, -0.05021951f, 0.10608979f, -0.25599843f, -0.04377098f, -0.13706058f, 
    0.22224006f, 0.00566473f, -0.03790583f, -0.18585467f, -0.03418940f, -0.12053797f, -0.19763520f, -0.26739559f, 
    -0.12809327f, 0.14207666f, 0.07359335f, -0.11282069f, 0.07597841f, 0.09174584f, 0.06367374f, 0.10080940f, 
    0.05007115f, -0.02134178f, -0.12656240f, -0.15392919f, 0.07886600f, 0.05222091f, 0.01198016f, 0.07413589f, 
    -0.01888424f, -0.03886197f, -0.01147214f, 0.01868811f, -0.04361280f, -0.05366271f, -0.03248950f, 0.04231155f, 
    -0.02656162f, -0.02455053f, 0.02317996f, -0.03253544f, 0.00186703f, 0.01931334f, -0.04473057f, -0.02877960f, 
    -0.00145243f, 0.01064323f, -0.01525045f, -0.00895541f, -0.00459699f, 0.01926922f, -0.03114630f, -0.00962009f, 
    0.02469431f, 0.04212933f, -0.02378014f, 0.00733533f, 0.01695584f, 0.04532603f, 0.03563929f, -0.01166981f, 
    0.03826628f, 0.02355095f, 0.04879074f, -0.06120427f, -0.03558701f, 0.03745935f, -0.03579174f, 0.00225830f, 
    -0.06065347f, 0.00955379f, -0.03715758f, 0.01652363f, -0.01378586f, 0.04561358f, 0.05227290f, -0.00056090f, 
    0.03533299f, -0.01298340f, 0.01790849f, -0.03816922f, -0.01954339f, -0.03982928f, -0.04201851f, 0.00848540f, 
    -0.04727149f, -0.05726921f, -0.03272131f, -0.00818443f, -0.04313034f, 0.03814371f, -0.03816982f, -0.06089677f, 
    -0.00956448f, -0.01280836f, -0.03241718f, 0.02202177f, -0.03571415f, -0.01662512f, 0.05528424f, 0.03238881f, 
    0.01384041f, 0.04749709f, -0.01186687f, 0.02505155f, 0.01086260f, -0.05311057f, -0.01235420f, 0.05046038f, 
    -0.05109946f, 0.05431718f, 0.05033848f, 0.02620278f, -0.06388759f, 0.04668166f, -0.02798387f, -0.00850904f, 
    -0.04071071f, 0.03470684f, -0.00225569f, -0.05098314f, -0.01995599f, 0.02880003f, -0.03197478f, -0.04063693f, 
    -0.01979507f, -0.04809830f, -0.02598665f, 0.01551489f, -0.05052096f, -0.00272983f, -0.03031878f, 0.01687939f, 
    0.01443443f, 0.04229148f, -0.04944253f, -0.04826549f, -0.01140517f, 0.01897687f, 0.04711149f, -0.05705317f, 
    0.01457653f, -0.04194817f, -0.02085608f, -0.02118281f, 0.04784754f, -0.00226989f, 0.00013823f, 0.00497691f, 
    0.03332769f, -0.04629114f, 0.01309596f, 0.05363077f, -0.01247250f, 0.01198758f, -0.01291297f, 0.01892953f, 
    -0.03819029f, 0.01493938f, -0.00584539f, 0.03750237f, -0.05233862f, -0.03440926f, 0.04088207f, 0.04285482f, 
    0.01029704f, 0.00090552f, -0.04103349f, -0.01436359f, -0.05328758f, 0.01485306f, 0.04563789f, -0.04198808f, 
    0.00686352f, -0.04337119f, -0.02840937f, -0.02704188f, -0.04095663f, 0.01518779f, -0.05527025f, 0.00960716f, 
    0.04486018f, 0.03889547f, 0.00288061f, -0.05217043f, -0.00872533f, -0.02373463f, -0.02687341f, 0.01139326f, 
    0.03517891f, 0.05260665f, 0.00972552f, -0.05525377f, -0.04419543f, 0.05010413f, -0.02181237f, -0.05269399f, 
    -0.04948339f, -0.00916217f, 0.02736261f, -0.04263400f, 0.00970980f, 0.00763463f, -0.02316903f, -0.05452040f, 
    0.03269468f, -0.03159118f, 0.01641645f, -0.05057513f, 0.03186047f, -0.02827017f, -0.04821295f, -0.03155219f, 
    0.02424837f, -0.01597707f, 0.00093343f, -0.03830862f, 0.03819532f, 0.03417627f, -0.04273430f, 0.00508238f, 
    -0.02178153f, 0.03788183f, -0.02010106f, -0.03133744f, 0.04044519f, -0.05722302f, -0.06517325f, 0.00742356f, 
    -0.02906700f, -0.02499553f, 0.04839907f, 0.01868251f, -0.04227275f, 0.02067794f, -0.01977881f, -0.04246739f, 
    -0.01467738f, -0.06270943f, -0.00981265f, -0.02566418f, 0.00861179f, -0.01789520f, -0.02399570f, -0.04555452f, 
    0.01129080f, -0.01464753f, 0.02378699f, 0.01520073f, -0.03472194f, -0.04309797f, 0.01245254f, 0.03852313f, 
    -0.04728430f, -0.01007868f, 0.00170918f, 0.01879620f, -0.04082454f, 0.02063403f, -0.01276115f, 0.01939412f, 
    0.05582958f, 0.03355631f, -0.05994143f, -0.04468110f, 0.03109086f, -0.03591786f, -0.03102046f, 0.03774676f, 
    0.01871413f, 0.02241225f, -0.03054696f, 0.05568368f, 0.04369389f, -0.03627357f, -0.02270607f, -0.03912011f, 
    -0.04367825f, -0.03763510f, 0.03221529f, -0.00955451f, -0.05824093f, 0.00255274f, 0.01894200f, 0.02271359f, 
    -0.02891204f, 0.04426132f, -0.04614338f, -0.02038676f, 0.02105160f, -0.01367277f, -0.02796135f, -0.03986339f, 
    -0.02082163f, -0.04997384f, 0.04536821f, -0.00419156f, -0.02102306f, -0.00152149f, -0.05147916f, -0.01005817f, 
    -0.02706365f, -0.00536195f, 0.00858284f, 0.05362748f, 0.02932246f, -0.05657500f, 0.03560067f, 0.02663037f, 
    -0.05146588f, -0.04941577f, -0.03599392f, -0.02354192f, -0.05490442f, -0.00662582f, 0.04769038f, -0.03472109f, 
    0.27096075f, 0.02580893f, -0.01117086f, -0.04468327f, 0.00214934f, -0.02552726f, -0.02702082f, -0.13620310f, 
    0.06004990f, 0.08661439f, 0.18241462f, 0.22675762f, 0.14098909f, 0.03668239f, 0.04639321f, -0.04368623f, 
    -0.06803986f, -0.00607612f, -0.12758431f, -0.13317375f, -0.06740563f, 0.04351372f, -0.00380488f, -0.04767115f, 
    -0.13083577f, 0.04920446f, -0.00210569f, 0.10464916f, 0.03247561f, -0.14771876f, 0.00816127f, 0.04974758f, 
    -0.07843441f, -0.10015407f, 0.17893031f, -0.03123921f, -0.23044008f, -0.09972580f, 0.03108526f, -0.04236140f, 
    -0.07136650f, -0.21589497f, -0.02367879f, 0.04607300f, 0.11508889f, 0.05285421f, -0.05003598f, 0.09276539f, 
    -0.15193003f, 0.11633241f, 0.05222817f, -0.06947815f, -0.05078652f, 0.10373922f, 0.02531612f, 0.06567089f, 
    0.14940132f, 0.05543446f, -0.08138677f, 0.02882429f, -0.08330735f, -0.07415777f, -0.12290500f, 0.15363823f, 
    0.31133074f, 0.04795628f, -0.01273415f, -0.03763918f, 0.01750167f, -0.07835215f, 0.02911753f, -0.13368215f, 
    0.04693857f, 0.10396571f, -0.05048098f, 0.09901857f, 0.00588348f, 0.01815091f, 0.17342833f, 0.17022881f, 
    0.01627248f, 0.09966177f, -0.20933075f, -0.11420340f, 0.05239205f, -0.01816489f, 0.03085915f, 0.04794472f, 
    0.01637662f, -0.13942583f, -0.19615445f, -0.17860097f, -0.02875549f, -0.02544033f, -0.04627127f, -0.02609119f, 
    0.04150838f, 0.04513168f, 0.11451669f, 0.01977601f, 0.14892361f, -0.01821966f, -0.10192661f, -0.07868569f, 
    -0.04275687f, -0.01552308f, 0.02697338f, 0.12077689f, 0.08983511f, 0.19382927f, 0.14344923f, 0.14753370f, 
    0.02074289f, 0.03149716f, -0.04667330f, -0.18569262f, -0.14924996f, 0.05670016f, -0.08766767f, 0.02954464f, 
    -0.07644539f, 0.04459520f, -0.04001047f, 0.03910759f, -0.00566128f, 0.07893102f, 0.02212461f, 0.10074389f, 
    -0.04597745f, -0.02836906f, -0.06009068f, -0.00710463f, 0.00052538f, 0.00198135f, -0.17689103f, 0.04253244f, 
    0.02739092f, -0.05395361f, -0.25705692f, -0.03250273f, -0.06797679f, -0.02771048f, 0.05191002f, 0.06833496f, 
    0.03041334f, -0.01808323f, 0.01517089f, 0.14907323f, 0.10863966f, -0.12856559f, 0.05896294f, -0.03674075f, 
    -0.03813460f, -0.20433138f, 0.04847933f, -0.04011296f, 0.10561999f, 0.01557098f, -0.00244081f, -0.18854760f, 
    -0.04160758f, -0.09688980f, -0.01090011f, 0.09032433f, 0.01509050f, -0.03448896f, -0.02502500f, -0.10955175f, 
    0.07997610f, 0.01222096f, 0.02846678f, -0.12691590f, 0.21230549f, 0.06739698f, -0.03972301f, 0.09818495f, 
    0.01956460f, -0.05012597f, -0.10752535f, -0.17010953f, 0.06498316f, 0.09034337f, 0.04648043f, 0.05269298f, 
    0.08573076f, 0.05542994f, 0.10464440f, 0.12850709f, 0.05910892f, 0.04898289f, 0.19658679f, -0.07278738f, 
    -0.00767519f, 0.14922422f, 0.08864086f, 0.09127608f, -0.04328222f, 0.04436181f, 0.02076445f, 0.11069573f, 
    0.00925584f, -0.06736071f, -0.00953605f, -0.11848244f, -0.02608941f, 0.00169585f, -0.11977112f, 0.10614605f, 
    0.10511259f, 0.06767886f, 0.04943615f, 0.15392746f, -0.08875262f, 0.11809611f, 0.03898905f, -0.06514525f, 
    0.09873372f, 0.05094210f, -0.10717098f, 0.02892218f, -0.01841307f, -0.02638563f, 0.09244933f, 0.01560621f, 
    0.04991932f, -0.03310980f, 0.13692853f, -0.01550462f, 0.01812973f, -0.06859637f, -0.01673406f, -0.07210456f, 
    0.03453701f, 0.03720797f, -0.05427138f, -0.08975795f, 0.00021652f, -0.05959262f, -0.03746199f, 0.03940653f, 
    0.00074460f, 0.02472167f, -0.13482489f, 0.02300064f, -0.02584264f, 0.09841954f, -0.00505425f, -0.08743878f, 
    -0.12122802f, -0.15126222f, -0.19408153f, 0.03762784f, 0.10432108f, -0.33966377f, -0.05607558f, -0.14275946f, 
    -0.09437934f, -0.01581928f, 0.10344318f, -0.03167778f, -0.01619825f, -0.18337584f, -0.17765634f, -0.10368042f, 
    -0.05826458f, -0.03318019f, -0.02433625f, -0.07715917f, 0.08532021f, 0.05581613f, 0.29133111f, -0.20458072f, 
    -0.04116162f, 0.03475944f, -0.09232007f, 0.18295129f, 0.04530194f, -0.05834009f, -0.07454669f, 0.04165661f, 
    0.15118526f, 0.14305200f, 0.01778526f, -0.02220160f, -0.06251062f, -0.05891161f, 0.08091725f, -0.04745065f, 
    -0.12240727f, -0.16611226f, -0.19319005f, -0.05057338f, 0.03988422f, 0.02812443f, -0.04935858f, 0.04333866f, 
    0.04545787f, 0.04058382f, 0.01885930f, -0.13434020f, 0.02902652f, 0.10811640f, -0.00303010f, -0.06171325f, 
    0.07847859f, -0.07558967f, -0.30186379f, -0.25294018f, -0.06724003f, 0.05012942f, -0.02988169f, 0.04474007f, 
    0.08261020f, -0.06699878f, 0.06792766f, 0.09033715f, -0.01080473f, -0.21846586f, -0.09680670f, -0.12718518f, 
    -0.11119617f, 0.00899725f, -0.09678803f, -0.04738233f, 0.14410490f, 0.04809672f, 0.21049321f, -0.07562468f, 
    0.04337334f, 0.07571924f, 0.03299051f, 0.03709318f, -0.04908073f, -0.08030506f, -0.07484603f, 0.04591758f, 
    -0.32649392f, -0.04560024f, -0.03571123f, -0.01772626f, -0.02969971f, -0.11290579f, 0.03736653f, 0.09211148f, 
    0.04413544f, 0.01528866f, 0.09603108f, -0.08777069f, 0.00412038f, 0.03601438f, 0.09111674f, 0.03871915f, 
    0.19886427f, 0.09877751f, 0.06802683f, -0.00715392f, 0.15190242f, -0.01436374f, 0.01767574f, 0.01562105f, 
    0.13309358f, 0.33313638f, 0.10465852f, 0.07997378f, -0.01247947f, 0.01268688f, -0.00028087f, 0.00849936f, 
    -0.10293368f, 0.09421781f, -0.00380324f, 0.14862289f, 0.06858124f, -0.11120410f, 0.00758603f, -0.06488274f, 
    -0.01535218f, -0.05336556f, -0.08710681f, -0.09702192f, 0.11179917f, 0.01390431f, -0.04079352f, -0.00649561f, 
    0.02601851f, 0.07030874f, 0.00201511f, -0.27166164f, 0.21885359f, -0.16295360f, 0.00614122f, -0.03956101f, 
    -0.11803903f, -0.05994273f, 0.08072692f, 0.04759491f, 0.20421644f, -0.06897077f, -0.18858233f, 0.03141540f, 
    0.12688501f, -0.03303854f, -0.02557481f, -0.05770212f, 0.08116728f, -0.22696261f, -0.07316967f, -0.13298364f, 
    0.06394636f, -0.13185710f, -0.03453668f, -0.00245210f, 0.00707708f, 0.05658421f, 0.06472074f, 0.08949556f, 
    -0.05664083f, 0.04227982f, 0.07569862f, 0.11131328f, 0.08300504f, 0.00819386f, 0.01674645f, -0.06606547f, 
    0.01848061f, 0.04905540f, 0.03438113f, -0.07253946f, -0.05177953f, -0.01384123f, -0.03655014f, 0.20024748f, 
    0.00126742f, 0.09676426f, 0.20349111f, 0.02784196f, -0.00682807f, -0.11886719f, 0.08191407f, -0.07598104f, 
    0.02406442f, -0.34588915f, -0.01756116f, -0.01898387f, 0.01623162f, -0.01255301f, -0.01480756f, -0.02901103f, 
    -0.03135986f, 0.07601512f, 0.13256852f, -0.03104993f, 0.10898054f, 0.15209442f, -0.01409041f, -0.10283653f, 
    0.06622931f, -0.08262410f, 0.11681800f, 0.04014380f, -0.17396626f, -0.05368836f, 0.08595691f, -0.05469706f, 
    -0.01080909f, -0.13831544f, 0.10090804f, 0.09685480f, 0.00004447f, 0.36433953f, 0.13654907f, 0.02223416f, 
    -0.05911295f, -0.04147214f, 0.03472307f, 0.06854136f, -0.03335072f, -0.00673574f, -0.17273465f, -0.03935606f, 
    0.11413111f, -0.00890037f, 0.05327605f, -0.05470296f, 0.04339096f, -0.05781689f, 0.10930207f, -0.05322566f, 
    0.01136983f, 0.15390283f, 0.04789053f, 0.04439723f, -0.07275707f, -0.03127304f, 0.06247503f, 0.08835975f, 
    0.34340647f, 0.06006228f, -0.05708572f, 0.07220320f, 0.08238257f, -0.03409702f, 0.05394480f, 0.01422195f, 
    0.08994742f, 0.00819734f, 0.06435598f, -0.12175808f, -0.08664039f, 0.07902580f, -0.00298594f, 0.02923757f, 
    -0.04157762f, -0.54594100f, -0.19297473f, -0.31860784f, 0.09551465f, -0.08726826f, -0.08810699f, -0.03861422f, 
    0.04908590f, 0.02673074f, -0.00711848f, -0.49155566f, -0.19344312f, -0.05708352f, -0.10672233f, 0.00109771f, 
    0.02720118f, -0.00450208f, -0.11585448f, -0.00894354f, 0.09257991f, -0.00808263f, -0.01168798f, -0.04115771f, 
    -0.04638474f, 0.05064546f, 0.03004396f, 0.21403320f, 0.06152609f, -0.03344057f, -0.03746529f, -0.05552775f, 
    -0.00480916f, -0.02130945f, -0.03883557f, -0.10343748f, 0.02914710f, -0.11817146f, 0.01506264f, 0.17264609f, 
    0.02714426f, -0.10509761f, -0.05773866f, 0.03537618f, 0.07793671f, 0.02351281f, -0.05406529f, 0.00730499f, 
    0.03297565f, 0.04741972f, -0.13509922f, 0.07358625f, 0.12690561f, 0.06373999f, 0.03855759f, -0.00075110f, 
    0.18618198f, -0.16338387f, 0.04533263f, 0.01224852f, 0.08533488f, -0.07004965f, 0.04277763f, 0.01914654f, 
    0.01260075f, -0.05200662f, -0.01307980f, 0.01703925f, -0.02570438f, -0.02307552f, -0.04877946f, -0.01971989f, 
    -0.03593094f, 0.04867526f, 0.02651470f, -0.06194587f, -0.02807384f, -0.00322902f, -0.01124639f, 0.01481445f, 
    -0.01594833f, 0.02640803f, 0.00561637f, 0.05032330f, -0.05622286f, -0.01430031f, -0.01802744f, 0.01796519f, 
    -0.05030798f, 0.02839006f, -0.04510755f, -0.04416711f, 0.01433591f, 0.01757345f, 0.05407210f, -0.01540631f, 
    0.02660831f, -0.03442125f, -0.04031835f, 0.03886030f, -0.04301036f, 0.01692478f, -0.03966265f, 0.01008942f, 
    -0.03937881f, 0.02911841f, 0.00787886f, -0.03657507f, -0.02116127f, -0.04736860f, -0.02465200f, -0.02148663f, 
    -0.04943062f, 0.01021436f, -0.00949457f, 0.00483006f, 0.00334250f, -0.03715434f, 0.02191560f, -0.04359949f, 
    0.00803202f, -0.04791807f, -0.04493506f, 0.03394034f, 0.01318635f, 0.03668218f, -0.01688939f, -0.02345331f, 
    0.00811848f, 0.02494676f, -0.04791545f, -0.01691530f, -0.04421534f, 0.02540020f, -0.06623934f, -0.01091280f, 
    -0.01191003f, -0.04851043f, 0.01812687f, 0.00123528f, 0.03838085f, -0.06378704f, -0.00165904f, 0.00142314f, 
    -0.03619649f, -0.05133974f, -0.05434456f, 0.01955028f, -0.02950193f, 0.03024382f, -0.03422719f, 0.01981348f, 
    -0.04748388f, 0.04647642f, -0.03115498f, 0.05224645f, 0.04167038f, -0.02368614f, -0.03751786f, 0.01476027f, 
    0.02707047f, -0.05140714f, -0.04066184f, 0.01497529f, 0.02360023f, 0.01871091f, -0.06322773f, 0.01482365f, 
    0.04337767f, -0.00306235f, 0.01859438f, 0.03653140f, 0.04881581f, -0.02900469f, 0.02663226f, 0.03281913f, 
    -0.05272936f, -0.04326390f, -0.00299036f, 0.01190375f, -0.00727526f, 0.04459106f, 0.04230610f, 0.04947733f, 
    0.03716530f, 0.01004312f, 0.04182689f, -0.02936509f, 0.00991351f, 0.04263765f, -0.05639733f, 0.02066605f, 
    0.04384185f, -0.04403111f, -0.04578020f, 0.05055064f, 0.00803981f, -0.02239669f, -0.05648001f, 0.00615593f, 
    -0.05012078f, -0.05032908f, 0.02414231f, -0.05052744f, 0.00758471f, -0.06753381f, -0.05190691f, -0.01942613f, 
    -0.01914716f, 0.00369146f, 0.00759161f, -0.03376213f, -0.04916448f, -0.02902573f, -0.05649063f, 0.01815932f, 
    -0.03289859f, -0.02502132f, -0.04568779f, -0.02776083f, 0.04912404f, -0.03927745f, 0.04777491f, -0.05534245f, 
    -0.03719280f, -0.01672806f, 0.02496839f, 0.02383141f, -0.04312982f, -0.03206952f, 0.02869144f, 0.03839429f, 
    0.00213522f, 0.04897002f, 0.05359048f, -0.03360428f, -0.00786700f, -0.01977808f, -0.05256676f, 0.04670878f, 
    0.02545421f, -0.00789618f, -0.03764087f, -0.04861711f, -0.03777527f, 0.02075223f, 0.02042201f, -0.04063285f, 
    0.02036567f, 0.05068127f, -0.04223552f, -0.06809081f, -0.03416060f, 0.01632022f, -0.00652232f, 0.02751040f, 
    -0.04250490f, -0.00591496f, 0.01994804f, -0.05031343f, -0.04588906f, -0.01805285f, 0.02147262f, -0.00097784f, 
    -0.05268063f, -0.04166837f, 0.03733168f, 0.04675444f, -0.05089129f, -0.02616495f, 0.00105067f, -0.04658936f, 
    0.00321742f, -0.02404794f, -0.00699998f, -0.00415589f, -0.01484896f, -0.04402127f, 0.00647095f, 0.00785212f, 
    -0.05385640f, 0.00787284f, -0.03274320f, 0.01493820f, -0.05391989f, -0.00946482f, 0.02999931f, -0.06692491f, 
    -0.06280524f, 0.02891211f, 0.03285808f, 0.02223367f, -0.00694541f, -0.03036361f, -0.04373115f, 0.05212469f, 
    -0.01740219f, 0.03491306f, 0.04154611f, -0.00682797f, -0.02882930f, 0.00270719f, -0.01668039f, 0.03051701f, 
    0.00236928f, -0.03618224f, 0.02041986f, 0.04463381f, 0.00359948f, 0.04337830f, 0.01032467f, 0.01644016f, 
    -0.01919080f, -0.01633935f, -0.00149933f, 0.01368525f, -0.05018839f, -0.01736365f, -0.05594474f, 0.02916192f, 
    -0.00002658f, -0.05752405f, -0.04359123f, -0.02502782f, 0.02578871f, 0.00604805f, 0.05766046f, -0.01582420f, 
    0.02567090f, -0.05508267f, 0.01461852f, 0.00960920f, 0.00567038f, -0.02743808f, -0.04431845f, 0.01951217f, 
    0.03680098f, 0.01727085f, -0.03119274f, -0.01377206f, 0.04708307f, -0.02403442f, -0.00722336f, 0.01301177f, 
    -0.03082860f, 0.00202328f, 0.00125544f, -0.00186110f, 0.00669979f, 0.00703816f, -0.02061712f, -0.01959502f, 
    -0.04031271f, -0.09942367f, -0.11340807f, -0.04221704f, 0.05439221f, -0.05628962f, -0.02370399f, 0.03943890f, 
    -0.08998206f, 0.02539139f, 0.08271033f, 0.08569894f, 0.05516696f, 0.04311800f, 0.03173828f, 0.05690313f, 
    0.14664592f, 0.08801059f, 0.05205072f, 0.09017739f, 0.03664768f, 0.03762382f, 0.02797249f, -0.06199444f, 
    -0.08648635f, -0.02880822f, -0.07143798f, -0.30751896f, -0.00817907f, -0.06884902f, -0.01042619f, 0.06527383f, 
    0.08075888f, 0.15017372f, -0.12585023f, -0.18334419f, -0.16174667f, 0.07851324f, -0.15145284f, 0.06011289f, 
    0.15210104f, 0.05652266f, 0.04682261f, -0.04685128f, -0.07407779f, -0.24552485f, -0.03155972f, -0.17311433f, 
    0.09167309f, 0.02530387f, 0.01356273f, 0.08848376f, -0.00848636f, -0.18444191f, 0.19331421f, 0.01496271f, 
    0.01811109f, 0.01778316f, -0.02496848f, 0.09684478f, -0.04986003f, 0.03804953f, 0.12841778f, 0.10802763f, 
    -0.14240384f, 0.07078256f, -0.00368251f, 0.04283062f, -0.03030462f, -0.05998812f, -0.05685034f, 0.00791196f, 
    -0.00455099f, -0.06830542f, 0.08356059f, 0.00642324f, -0.00936829f, -0.02174521f, -0.09099708f, -0.00394556f, 
    0.12594704f, -0.23645517f, -0.00860173f, -0.08092100f, 0.06120335f, 0.04405311f, -0.06116841f, -0.11412220f, 
    0.10562043f, 0.00139330f, -0.27451858f, -0.18724142f, -0.06731293f, 0.05584320f, -0.01583727f, -0.02528367f, 
    -0.01040804f, -0.02735364f, -0.03614141f, -0.09370610f, 0.10630896f, 0.02947590f, 0.07982677f, 0.10847857f, 
    0.01432079f, 0.05306235f, 0.03452051f, 0.00482801f, -0.07558059f, 0.00898579f, 0.13030066f, 0.10789545f, 
    0.06399813f, 0.08666018f, -0.08724475f, -0.12822992f, -0.14053364f, -0.41950592f, -0.10894008f, -0.03594548f, 
    -0.01137726f, 0.08594748f, -0.07134647f, 0.08937395f, -0.03448324f, -0.05943918f, 0.17676201f, -0.00192484f, 
    0.05369009f, 0.00618049f, -0.00822011f, 0.01709254f, -0.06584632f, 0.01001830f, 0.00612494f, -0.28508160f, 
    0.04474171f, -0.03916611f, 0.10615283f, 0.01039745f, -0.08115254f, -0.02209045f, 0.07839952f, 0.01497001f, 
    0.25291541f, 0.01963356f, 0.01873088f, 0.05123518f, 0.10958917f, -0.09961853f, -0.00750630f, 0.07549536f, 
    0.00243098f, -0.08406202f, 0.05090024f, 0.01545020f, 0.09986930f, 0.06117441f, -0.11608756f, -0.00365223f, 
    -0.09984718f, 0.01622644f, -0.01385266f, -0.02118317f, -0.02264890f, 0.16460598f, 0.11639846f, 0.03178384f, 
    0.16880172f, -0.15551832f, -0.05266976f, -0.09198592f, 0.04008481f, 0.07791197f, -0.06248344f, 0.02042398f, 
    0.01745856f, 0.11622337f, -0.03948315f, -0.12744215f, 0.09902891f, 0.09180761f, 0.18600580f, 0.04584801f, 
    0.03105019f, 0.04883756f, 0.02682659f, -0.01568995f, 0.07096586f, 0.03120207f, 0.03966315f, 0.08502385f, 
    -0.00384335f, -0.02218273f, 0.12496080f, 0.08503713f, 0.04998934f, 0.06048070f, 0.00778269f, 0.03640237f, 
    0.08399496f, 0.10613430f, -0.05417519f, -0.01361369f, 0.05879166f, 0.05911162f, -0.08425638f, 0.06927648f, 
    -0.00937350f, 0.11028012f, 0.12804452f, -0.03843798f, -0.07993385f, -0.04850683f, 0.12049924f, 0.00346563f, 
    -0.29827943f, -0.15860854f, -0.16216078f, 0.03506677f, -0.12185960f, 0.03248799f, -0.08194041f, 0.07774755f, 
    -0.16412696f, 0.17451087f, 0.18720572f, 0.02994961f, 0.05582426f, 0.06519321f, -0.04276092f, -0.13971198f, 
    0.03115636f, -0.08021876f, 0.05785289f, 0.09195986f, -0.04150794f, 0.04595678f, -0.02182831f, -0.03808173f, 
    -0.03517300f, 0.00873543f, 0.06184204f, -0.03041324f, 0.02738702f, -0.12303369f, 0.04612730f, 0.06554243f, 
    0.05578825f, 0.06338277f, 0.11509600f, 0.08162253f, -0.19055536f, 0.04492246f, -0.08928941f, -0.05669188f, 
    -0.19317666f, 0.00696610f, 0.07698791f, 0.09889060f, -0.14797223f, -0.22037953f, 0.04015065f, -0.03596129f, 
    -0.05290830f, 0.03280391f, -0.00703186f, -0.08366255f, -0.00261288f, -0.20207180f, -0.19890974f, -0.12495340f, 
    -0.08334912f, 0.01449467f, -0.14546435f, 0.04965511f, 0.10872823f, -0.01071401f, 0.04344103f, 0.10610944f, 
    0.04282047f, 0.09976559f, -0.05923128f, 0.05098322f, 0.04253453f, 0.08356233f, -0.05771396f, 0.05365514f, 
    -0.01104172f, -0.05200187f, 0.03692829f, -0.05701470f, 0.02984315f, -0.04787949f, -0.00869475f, -0.02714296f, 
    -0.02638646f, -0.06409734f, -0.05408890f, 0.00198731f, 0.05092270f, 0.01999379f, 0.02292960f, -0.00674960f, 
    -0.00825861f, -0.02123071f, -0.01832621f, 0.04047659f, -0.04521194f, 0.04403365f, 0.01693849f, 0.03986402f, 
    0.04836620f, -0.00227334f, -0.04438406f, 0.01908510f, -0.01600148f, -0.00396355f, -0.03279282f, -0.04833611f, 
    -0.00475380f, 0.01021521f, -0.03983448f, -0.06038713f, 0.00446256f, 0.02240810f, 0.03999979f, 0.00426249f, 
    0.00860022f, -0.04987221f, -0.01725402f, 0.05191697f, 0.04806629f, -0.03567620f, 0.00241683f, -0.00884846f, 
    -0.06232804f, 0.03347807f, -0.01341398f, -0.01687956f, 0.00561139f, 0.02117519f, -0.05507356f, 0.01688457f, 
    -0.01466142f, 0.00664322f, -0.01477278f, -0.06191492f, -0.02876758f, 0.02827398f, -0.06252693f, 0.04924086f, 
    0.01255215f, 0.05066769f, -0.00222888f, -0.03716662f, -0.03177663f, 0.00673784f, 0.00441687f, 0.00306063f, 
    0.00732051f, -0.05449919f, -0.06329005f, -0.04276551f, 0.04810235f, -0.00863848f, -0.04616748f, -0.02239998f, 
    -0.06473613f, 0.00377652f, 0.00935823f, -0.03388277f, -0.02285798f, -0.04922694f, -0.00151674f, 0.02498182f, 
    0.01682743f, -0.03017516f, -0.02364307f, -0.05361637f, 0.01398964f, -0.02929972f, 0.01854606f, -0.01995259f, 
    -0.05873318f, 0.00854567f, -0.06302756f, 0.00275511f, 0.00810806f, 0.02025804f, -0.03696758f, 0.05032703f, 
    0.02179787f, 0.01314594f, 0.04699382f, 0.02437364f, -0.06158353f, -0.00164462f, -0.06396277f, -0.03119279f, 
    -0.01974263f, -0.02044320f, 0.05168756f, 0.03138395f, 0.00960897f, -0.02606509f, 0.04617618f, -0.05882007f, 
    -0.02297216f, -0.03538177f, 0.04800984f, 0.04041517f, 0.02957124f, -0.00788833f, 0.04251304f, 0.03672600f, 
    -0.00995356f, 0.02834303f, -0.05439153f, -0.02056055f, -0.06110777f, -0.05329645f, -0.02162385f, -0.05393439f, 
    -0.02945499f, -0.00332302f, -0.00956375f, -0.01829702f, -0.05141057f, -0.02835332f, -0.06226521f, -0.01816864f, 
    0.01146059f, 0.03714501f, 0.00438714f, -0.06207832f, -0.02299393f, -0.06223649f, -0.05296623f, -0.02526774f, 
    0.02314566f, 0.02420580f, -0.06322943f, 0.02232726f, -0.02958004f, -0.03880579f, -0.02541165f, -0.01616649f, 
    -0.05689542f, -0.01757936f, -0.00730333f, 0.01076239f, -0.04940689f, 0.00417993f, -0.05007875f, -0.02615548f, 
    -0.02549142f, 0.00504944f, -0.03583572f, -0.02893975f, -0.03564531f, -0.05032684f, -0.01901719f, -0.02022218f, 
    -0.03609347f, -0.03529521f, 0.01662536f, -0.04876995f, 0.00463280f, -0.05077011f, -0.02007342f, 0.02120369f, 
    0.04727939f, 0.02674658f, 0.02965145f, 0.03074388f, 0.02638041f, 0.03983577f, -0.03657310f, 0.01309161f, 
    0.03031874f, 0.03663159f, -0.04001097f, 0.04117049f, -0.00096247f, -0.04297267f, -0.01619201f, -0.03138976f, 
    0.04643695f, -0.05976847f, 0.01720433f, 0.00749751f, 0.00724136f, -0.03566110f, -0.04153885f, -0.04792662f, 
    -0.05748617f, -0.06251542f, -0.02404441f, -0.03857385f, -0.04551576f, -0.01187432f, -0.04994050f, -0.04339109f, 
    -0.03614888f, 0.03019284f, -0.01171493f, 0.01261668f, 0.03578136f, 0.00143624f, -0.05536816f, -0.04959479f, 
    -0.05380544f, -0.04044472f, -0.02274868f, -0.02055148f, -0.02747303f, -0.02828134f, 0.04757247f, -0.05279247f, 
    0.04338967f, -0.03233000f, 0.00698366f, 0.04604056f, -0.01140401f, 0.04583695f, -0.05109282f, -0.03213777f, 
    -0.03518681f, -0.03024922f, -0.05860507f, 0.01037300f, -0.03470177f, -0.03943378f, 0.02534608f, 0.03910084f, 
    0.02737398f, -0.02302938f, -0.00227840f, -0.03444409f, -0.00187176f, -0.01433788f, -0.02561257f, 0.04026405f, 
    -0.02803369f, -0.01697319f, -0.02399723f, -0.04163704f, -0.01017207f, 0.00168977f, -0.03924860f, -0.06083426f, 
    0.03831716f, -0.01221920f, -0.02220437f, -0.05893441f, -0.05910015f, -0.03916960f, 0.00538214f, 0.01692154f, 
    -0.02379379f, -0.05245784f, -0.06288978f, -0.02111317f, 0.03498607f, 0.02513843f, 0.02544341f, 0.02202854f, 
    0.01949857f, -0.01195699f, -0.02171610f, -0.04032828f, -0.03245910f, -0.01842456f, -0.04027616f, -0.00606980f, 
    -0.03777938f, 0.00407903f, -0.00626758f, -0.05070611f, 0.03340908f, -0.04098310f, 0.00566359f, 0.04098974f, 
    0.03760735f, 0.03056477f, -0.04409032f, 0.00778937f, 0.03020100f, -0.04629876f, -0.05628196f, -0.00620664f, 
    -0.06175908f, 0.02112644f, -0.01068214f, 0.01648800f, -0.03294227f, 0.04321418f, -0.02491130f, -0.05362300f, 
    -0.01681748f, 0.03112927f, -0.03057988f, 0.02057434f, -0.03537553f, -0.00183527f, -0.01004572f, 0.02622190f, 
    0.01736475f, 0.02393015f, 0.01385314f, 0.04618881f, 0.00109742f, -0.00131884f, 0.03161658f, 0.00406698f, 
    -0.01506696f, -0.02502280f, -0.01699771f, -0.01828272f, -0.03352325f, -0.02398879f, -0.03035279f, -0.02423630f, 
    -0.00518490f, -0.04972736f, 0.00291698f, -0.03116441f, -0.02885613f, -0.04981899f, -0.02813167f, -0.05683605f, 
    0.02534110f, -0.02092129f, -0.05229898f, -0.03880860f, -0.05808314f, 0.02247814f, 0.01773043f, -0.03457592f, 
    0.03090272f, -0.05307914f, 0.02699829f, -0.00532586f, 0.00527219f, 0.03205969f, 0.04247337f, -0.03142232f, 
    -0.00018055f, -0.03001666f, -0.03620393f, -0.03294904f, -0.05884368f, -0.04000084f, 0.03857696f, -0.00841712f, 
    -0.00317006f, -0.05832502f, 0.00019855f, -0.03471036f, 0.00329195f, -0.02239657f, 0.00380524f, 0.05232147f, 
    -0.06032837f, 0.04759420f, -0.05615566f, 0.04538958f, 0.00574100f, -0.01841125f, -0.03133026f, -0.06375091f, 
    -0.04971300f, -0.04512882f, -0.02286335f, 0.03986336f, -0.05274590f, -0.05332343f, 0.02099833f, -0.01285568f, 
    -0.05732480f, -0.02228983f, -0.04029428f, -0.05786670f, -0.01770084f, 0.04400742f, -0.01788174f, 0.03596967f, 
    -0.01154526f, -0.02797317f, -0.00331111f, -0.03893964f, 0.01345125f, 0.04367336f, 0.04345883f, -0.05806491f, 
    -0.04391251f, -0.01935879f, -0.05014551f, -0.00804445f, -0.03705749f, 0.04520024f, 0.03295433f, -0.03791510f, 
    -0.06113632f, -0.00078692f, 0.01790300f, -0.01667028f, -0.05372006f, 0.01655924f, 0.02196491f, -0.00101292f, 
    0.02053945f, 0.00650421f, 0.03988325f, 0.03429862f, -0.03110618f, -0.03872684f, -0.05303364f, 0.03084844f, 
    -0.03504646f, -0.03900495f, -0.04284769f, 0.01662835f, -0.05082569f, -0.05890699f, -0.05344049f, -0.05295334f, 
    0.02769661f, -0.02149902f, 0.02101870f, 0.02758067f, -0.00425777f, -0.03200933f, -0.02133394f, 0.00196258f, 
    0.03731334f, -0.03293787f, 0.00838308f, 0.01138124f, 0.03846304f, 0.00612186f, -0.03535071f, 0.04862165f, 
    -0.06261773f, -0.04152600f, 0.01165256f, -0.01319196f, -0.00687052f, 0.03756734f, 0.02267947f, -0.04536798f, 
    0.03631215f, -0.01910546f, 0.00866180f, -0.01845112f, 0.00818222f, -0.00113123f, 0.01013697f, -0.04905727f, 
    -0.02302569f, -0.05515092f, -0.00996263f, 0.03337938f, 0.00422226f, -0.04404331f, -0.05480422f, 0.03702635f, 
    -0.03847939f, -0.04793018f, 0.02581834f, 0.01664448f, 0.03330272f, 0.00733551f, 0.03403883f, 0.04162456f, 
    0.00764218f, 0.03364187f, -0.04259562f, -0.03452021f, 0.01671331f, -0.03179284f, 0.01855082f, -0.04936224f, 
    0.04167228f, -0.02570958f, -0.02405147f, -0.00326156f, 0.02981623f, 0.05221677f, -0.00213516f, -0.05352112f, 
    -0.04167270f, 0.05082365f, -0.01073640f, -0.00296339f, 0.00917276f, 0.04495040f, 0.04955542f, -0.03758367f, 
    0.02097659f, -0.04219170f, 0.02213471f, 0.01404251f, -0.02198728f, 0.02615203f, 0.01205936f, -0.03487051f, 
    -0.04843078f, 0.01651166f, -0.04922781f, 0.03814396f, 0.02297900f, 0.00468104f, 0.03580818f, -0.01080830f, 
    -0.04023454f, 0.04973672f, -0.03115887f, 0.04457877f, -0.05618493f, 0.02348203f, 0.00246978f, -0.01851163f, 
    -0.00502527f, -0.02931903f, -0.00630280f, -0.02822196f, -0.03757555f, -0.04633242f, -0.05387023f, -0.02374100f, 
    0.02098718f, -0.04859586f, -0.02551354f, -0.03327533f, -0.05554612f, -0.00292606f, 0.03658643f, -0.00679849f, 
    -0.04889537f, 0.05271558f, -0.02434611f, -0.05651703f, 0.00045988f, -0.00295421f, 0.01598255f, 0.01556131f, 
    0.04848802f, -0.05184861f, -0.03374156f, -0.01938759f, -0.00978921f, -0.01755671f, 0.03768320f, 0.00786573f, 
    -0.04170448f, -0.00194897f, 0.01876206f, -0.02488332f, -0.01989379f, -0.05785450f, 0.03133579f, -0.03202943f, 
    0.37641928f, 0.10023927f, -0.10709619f, 0.07313783f, 0.01042972f, 0.11990574f, -0.07377266f, 0.05628954f, 
    -0.00359428f, 0.10947333f, -0.11210467f, -0.26017684f, -0.06088572f, -0.02164121f, -0.03539153f, -0.07223569f, 
    -0.03341541f, 0.03173329f, 0.02361751f, 0.02711065f, 0.03854392f, 0.08120988f, 0.08071573f, 0.07561989f, 
    -0.09407985f, 0.03773437f, 0.07582235f, -0.03924499f, 0.01329865f, -0.01661408f, -0.07332380f, 0.02789595f, 
    0.02978210f, 0.01028343f, -0.09316006f, 0.15623595f, 0.13043661f, 0.05388833f, -0.12778030f, 0.01680261f, 
    -0.13842644f, -0.11186242f, 0.06294432f, 0.09893575f, 0.08145041f, 0.40565756f, -0.14822423f, 0.01726543f, 
    -0.08168468f, -0.05029202f, -0.07450969f, -0.13405371f, 0.14911823f, -0.06172382f, -0.64614713f, -0.19199695f, 
    -0.25293770f, -0.00915612f, 0.08037225f, 0.05909917f, -0.03442544f, 0.05556061f, -0.02239060f, 0.27365181f, 
    -0.00955284f, -0.25786287f, 0.11560062f, 0.20145704f, 0.01729403f, -0.05925379f, -0.04980996f, -0.05395749f, 
    -0.09872068f, 0.09099909f, 0.13207461f, -0.12046770f, -0.09005729f, -0.01387046f, 0.05777510f, 0.06357063f, 
    0.02292067f, -0.00202982f, 0.13691263f, 0.03773421f, 0.00521999f, 0.05062523f, 0.02589639f, 0.07166156f, 
    0.09048715f, -0.03262333f, -0.10809424f, 0.01474805f, 0.02868405f, 0.11064961f, 0.07759153f, 0.13034634f, 
    -0.11193400f, -0.01495296f, 0.10226534f, 0.24788459f, -0.06212024f, -0.08901287f, 0.04897898f, 0.00701593f, 
    0.03708453f, 0.01664465f, -0.02472608f, 0.08562821f, -0.01417456f, -0.04033967f, -0.28284553f, 0.10356475f, 
    0.03395508f, 0.11919069f, -0.17076407f, 0.02186906f, -0.05291553f, -0.00827271f, 0.23509188f, 0.02887650f, 
    0.02589884f, -0.07480811f, 0.09086552f, -0.09103999f, 0.08508697f, -0.09467715f, -0.01263118f, -0.05820094f, 
    -0.12847480f, 0.11667833f, -0.02745648f, -0.05566514f, -0.00104572f, -0.03950530f, -0.11176532f, 0.20623788f, 
    -0.22183913f, -0.03774966f, 0.02232246f, 0.12884665f, -0.02836543f, -0.02818624f, -0.01555051f, 0.05944926f, 
    0.15170281f, -0.01367740f, -0.13735752f, -0.03442355f, -0.20602408f, -0.04682275f, 0.03031510f, -0.07301705f, 
    0.06968985f, 0.30843198f, 0.12915295f, -0.20981014f, -0.02064456f, -0.01353262f, -0.06162202f, -0.04764129f, 
    0.06365053f, -0.03328370f, 0.00135574f, 0.01701545f, 0.04104912f, 0.06066329f, -0.07205507f, -0.02847646f, 
    0.09013062f, -0.03870318f, 0.10477245f, -0.24072127f, 0.05416873f, -0.14821571f, -0.09858968f, 0.04556628f, 
    0.04052682f, 0.06959867f, 0.00236431f, 0.04712435f, -0.04965637f, 0.07254081f, -0.05907783f, -0.06045001f, 
    -0.10026760f, -0.04949334f, -0.11676121f, -0.07084391f, 0.03004996f, 0.08042154f, -0.31168836f, 0.02828730f, 
    -0.05757715f, -0.05606057f, -0.01003856f, -0.00244961f, 0.00308332f, -0.05558661f, 0.12879701f, -0.19438538f, 
    0.08779812f, -0.04971223f, 0.01562360f, 0.10884064f, 0.02064659f, -0.03726468f, 0.09707693f, 0.12019683f, 
    -0.08507700f, 0.07337449f, 0.02055981f, -0.11455154f, 0.02983261f, -0.11029653f, -0.00876375f, -0.00338705f, 
    0.21631719f, 0.10756309f, 0.03211616f, 0.00044531f, 0.05145046f, 0.06664628f, 0.03562520f, 0.11059548f, 
    0.01599854f, -0.09108021f, 0.11806136f, -0.11883219f, 0.17706077f, 0.07761437f, 0.11089620f, -0.17976522f, 
    0.03540300f, -0.04838273f, -0.06092107f, 0.04999537f, -0.07105605f, 0.09496926f, 0.01355733f, 0.06230446f, 
    0.07629647f, -0.04286592f, -0.18191539f, 0.15184036f, -0.04490938f, -0.18775235f, 0.05107825f, 0.08286094f, 
    0.09879845f, -0.10743047f, 0.08703958f, 0.09158558f, -0.16043487f, 0.18017291f, 0.09029996f, 0.00718044f, 
    0.16644190f, 0.05694966f, -0.04123072f, 0.16448922f, 0.08836097f, 0.08931591f, -0.06367554f, 0.03061117f, 
    0.08300522f, 0.06628681f, 0.09978296f, -0.06144210f, -0.00469968f, 0.02837843f, -0.22087300f, 0.12991619f, 
    0.04541854f, 0.05367375f, 0.04667209f, -0.03424988f, -0.02799991f, 0.08812782f, 0.04088946f, 0.12948449f, 
    -0.11593249f, 0.07027456f, -0.05648581f, 0.00243445f, -0.07492995f, -0.08102991f, 0.04998595f, -0.01485466f, 
    0.06727093f, -0.18535043f, 0.02488114f, -0.04918329f, -0.04621566f, -0.03336870f, 0.05954012f, -0.02114522f, 
    0.04875194f, 0.01209318f, 0.03824830f, 0.01704842f, 0.06706633f, 0.08049390f, 0.06601847f, 0.04639081f, 
    -0.05263472f, 0.03857411f, 0.05406897f, 0.19674630f, -0.01271277f, -0.05853720f, 0.06673983f, 0.03008388f, 
    0.02579539f, 0.07546683f, 0.12431777f, -0.15187941f, -0.14650060f, 0.01957290f, 0.09827365f, -0.09887891f, 
    0.03543200f, 0.19126517f, 0.02863147f, 0.09502592f, 0.20136940f, 0.13362505f, 0.16054873f, 0.01958287f, 
    -0.12135462f, -0.05659929f, 0.07160205f, -0.01225468f, 0.00664476f, -0.42865559f, -0.27829298f, 0.36423504f, 
    -0.08301175f, -0.04521089f, -0.04790565f, 0.04098471f, -0.01318514f, -0.00212523f, 0.17377807f, -0.25248682f, 
    -0.20135997f, 0.00509897f, -0.04299231f, -0.11733270f, -0.06017047f, 0.06094437f, -0.00228150f, -0.16975479f, 
    0.02594489f, -0.03865400f, 0.08364516f, 0.08877605f, -0.12897938f, 0.02067397f, 0.10685382f, 0.07917439f, 
    -0.23452663f, -0.17961313f, -0.22984359f, 0.08253551f, 0.04376790f, -0.00231959f, 0.10831358f, -0.02025210f, 
    0.02590772f, 0.03614152f, 0.09958404f, -0.02964788f, 0.06583276f, 0.06267000f, -0.00031723f, -0.05160474f, 
    -0.06212571f, -0.00079299f, -0.06646097f, 0.14586806f, 0.05939255f, 0.08035535f, 0.24429366f, 0.04185525f, 
    0.01386380f, -0.06065925f, -0.06669132f, -0.10965695f, -0.17665716f, -0.07838256f, -0.06857279f, 0.03638628f, 
    -0.02155734f, 0.00461181f, -0.03622206f, 0.06058793f, -0.09226618f, -0.04747076f, -0.19672033f, 0.10265764f, 
    0.11272633f, 0.15751232f, -0.01549112f, 0.11904516f, -0.04836727f, 0.10487494f, 0.23946042f, -0.10031461f, 
    0.01885995f, -0.07210695f, 0.12322646f, -0.15882930f, 0.01768155f, -0.00320680f, -0.32881111f, 0.02869353f, 
    0.19998470f, 0.03621073f, -0.00814953f, -0.12301788f, 0.09523948f, -0.01086598f, 0.08326842f, -0.11754602f, 
    -0.07090452f, 0.12373348f, -0.01986265f, -0.10519387f, -0.05979224f, 0.08431657f, 0.01084896f, 0.07228395f, 
    0.28912774f, 0.03412680f, -0.44578516f, 0.06361679f, 0.01380181f, 0.09782826f, -0.04299678f, -0.06431226f, 
    -0.01108899f, 0.17733078f, -0.10293013f, 0.01324152f, 0.00354739f, 0.06174707f, 0.02228689f, 0.09085388f, 
    0.03490487f, 0.04259083f, -0.06965309f, -0.01820802f, 0.04075992f, 0.06193128f, -0.01674311f, 0.03820876f, 
    0.02996478f, -0.09121580f, -0.10127312f, -0.05690706f, -0.08418800f, -0.04818324f, -0.08870206f, -0.04829459f, 
    -0.14095990f, -0.00199598f, 0.14758052f, 0.21642257f, 0.00112945f, -0.01300137f, -0.37751707f, 0.11810210f, 
    0.07668545f, 0.02868255f, -0.02560610f, -0.03600942f, 0.01058953f, 0.03277363f, 0.00175353f, -0.15718468f, 
    0.15416853f, 0.12012908f, 0.11530685f, 0.02288051f, -0.07496984f, 0.00238876f, -0.13845205f, -0.15050615f, 
    -0.03072968f, 0.06036233f, 0.08654758f, -0.04328836f, 0.06619988f, 0.11543655f, -0.01821842f, -0.35435802f, 
    0.02688244f, -0.27124140f, 0.07195715f, 0.12485751f, 0.04767293f, -0.03647984f, -0.02737929f, -0.07656589f, 
    -0.31950611f, -0.12146604f, -0.02205525f, -0.12880580f, 0.02051335f, -0.03289387f, -0.02634267f, 0.07095928f, 
    -0.08454391f, 0.10812213f, 0.04983449f, -0.07462097f, -0.05058477f, 0.17513658f, 0.06859244f, -0.04249288f, 
    0.08020625f, 0.11076432f, 0.00566441f, 0.04401456f, 0.18720280f, -0.15087874f, -0.03583714f, 0.01898180f, 
    -0.07834078f, -0.06427136f, 0.21563706f, -0.14426775f, -0.17450887f, -0.00428001f, -0.02939907f, -0.05209906f, 
    -0.04146808f, 0.06493098f, -0.06494875f, 0.03011239f, 0.20775411f, 0.16547579f, 0.06784414f, -0.10487150f, 
    -0.03817066f, -0.08808903f, -0.08535713f, -0.08634947f, -0.09568361f, -0.03431677f, 0.18271136f, 0.06628500f, 
    -0.00379694f, -0.04334100f, -0.09751696f, 0.06777122f, 0.02008394f, 0.04002322f, 0.17032774f, 0.10949470f, 
    0.03757493f, -0.23738644f, 0.19135647f, -0.25778821f, 0.04990674f, -0.03817454f, 0.00148893f, -0.11578174f, 
    -0.12538134f, 0.08252094f, -0.00381670f, 0.10873616f, -0.00184150f, -0.08437864f, -0.02536527f, -0.01982914f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04187119f, 0.01355155f, 0.16401406f, -0.04598589f, 0.03635462f, -0.02643560f, -0.01476964f, 0.03984300f, 
    -0.00342468f, -0.02471759f, 0.03188642f, -0.05983134f, 0.07149556f, -0.04875517f, -0.05794818f, -0.00881010f, 
    0.06543892f, 0.05112054f, -0.06782749f, 0.05025579f, 0.08216252f, 0.06511324f, 0.04180158f, 0.03540228f, 
    -0.09042421f, 0.00688129f, -0.03150964f, 0.01514773f, 0.01853054f, 0.01063688f, 0.07410756f, 0.07611701f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21772887f, 0.07869374f, -0.04332962f, 0.19103865f, -0.11849248f, -0.15786512f, 0.03816668f, 0.16353676f, 
    0.03428196f, -0.10610005f, 0.07173229f, -0.06028037f, 0.41054437f, 0.05396016f, -0.16509160f, 0.51927692f, 
    -0.15791927f, 0.24268930f, -0.09109436f, -0.24172041f, -0.07496057f, -0.34332755f, -0.23255706f, 0.09786236f, 
    0.11842711f, 0.07571895f, -0.04794275f, 0.24877115f, 0.00205890f, -0.11612764f, -0.34510300f, -0.07732058f, 
    0.00242292f, 0.06284131f, -0.11071534f, -0.06517231f, -0.07190084f, 0.15585630f, -0.03436831f, -0.17595851f, 
    -0.08066723f, -0.02850055f, -0.08484572f, 0.12361653f, -0.03092701f, -0.02918783f, -0.03853745f, 0.08052696f, 
    -0.08138525f, 0.00395680f, -0.05126723f, 0.05271082f, 0.03089537f, -0.07113427f, -0.03692932f, 0.14874560f, 
    0.09101469f, -0.13556497f, 0.16463037f, 0.06281234f, 0.09300189f, -0.00669119f, 0.02516766f, 0.08426432f, 
    0.29966143f, -0.12944846f, -0.08956309f, -0.06887190f, 0.07152378f, -0.10919003f, -0.00801129f, -0.06968212f, 
    -0.39664748f, 0.00108814f, 0.02453656f, 0.07503169f, 0.24891709f, 0.08065493f, 0.05793482f, 0.35663936f, 
    -0.36511469f, -0.12203258f, 0.04845925f, -0.22450413f, 0.20562339f, -0.22387825f, 0.02453868f, 0.05324980f, 
    -0.19447078f, -0.00026235f, 0.15660504f, -0.02349370f, -0.14487471f, -0.05173540f, 0.32206079f, 0.36838436f, 
    0.04723879f, -0.10873724f, 0.23451196f, -0.24880913f, -0.20907164f, -0.05012475f, -0.12352256f, 0.09208909f, 
    0.10763872f, 0.30125675f, 0.25900441f, -0.05875753f, -0.21347065f, 0.26281938f, 0.04253038f, -0.05822437f, 
    0.01552849f, -0.07742387f, 0.39628240f, 0.20817654f, -0.04486413f, -0.29971120f, -0.15670179f, -0.16553141f, 
    -0.31501782f, -0.17918578f, 0.11569986f, -0.13776284f, -0.01060105f, -0.01736903f, 0.13945071f, 0.04372719f, 
    0.35611099f, -0.01232953f, -0.03125008f, -0.23573871f, 0.14401524f, 0.13849847f, 0.34498674f, 0.11305722f, 
    0.13024484f, 0.27594721f, 0.25878975f, 0.05656619f, -0.09054328f, 0.03519061f, 0.07779304f, -0.19614843f, 
    0.15564521f, 0.05293856f, -0.27032495f, 0.00192945f, 0.25361341f, 0.32829660f, -0.05858334f, 0.12271612f, 
    -0.18994451f, -0.49070761f, 0.15435359f, 0.01307914f, -0.06959903f, -0.01493433f, 0.16508697f, -0.19309124f, 
    -0.18723832f, -0.05105713f, -0.15469292f, -0.13853244f, 0.22084063f, -0.01761034f, 0.15028380f, 0.11806424f, 
    -0.06202036f, 0.01631570f, 0.12712669f, -0.00787643f, 0.12478749f, -0.12604061f, 0.06397557f, -0.07956576f, 
    0.09602197f, -0.03015342f, 0.42189017f, 0.09901200f, -0.21303177f, 0.10138290f, 0.06651547f, -0.05791881f, 
    0.44234028f, 0.03214342f, 0.01185882f, -0.01608900f, 0.02591559f, 0.00420874f, -0.24701498f, 0.58158302f, 
    0.24573433f, -0.10108239f, 0.19684285f, -0.47153556f, -0.05779328f, 0.14231159f, 0.17911410f, 0.13134091f, 
    -0.05737044f, 0.23166691f, -0.02285974f, 0.09925102f, -0.21527286f, 0.30249348f, -0.02464212f, 0.24357054f, 
    -0.06554192f, -0.20162703f, -0.01336156f, 0.30973440f, -0.25807190f, -0.14951451f, -0.25467724f, 0.13595115f, 
    -0.46298090f, 0.09518392f, 0.14042149f, 0.14828871f, -0.09354253f, -0.11743028f, 0.14568904f, -0.26516041f, 
    0.01622076f, 0.05936031f, 0.17802481f, 0.21372905f, 0.00488466f, -0.09158929f, 0.47607860f, 0.02784018f, 
    0.14801800f, 0.22944808f, 0.04172594f, 0.00383667f, 0.10726858f, -0.31084475f, -0.09418280f, 0.03124965f, 
    0.00457593f, -0.32064810f, -0.06310111f, -0.17882694f, -0.36698925f, -0.07169951f, 0.10313100f, 0.11202082f, 
    0.16313967f, 0.27069113f, 0.07738374f, -0.04372879f, -0.09977231f, -0.10310765f, -0.22856565f, -0.30306363f, 
    0.02508976f, 0.11788169f, -0.06188762f, -0.05939035f, 0.18622522f, 0.10969184f, 0.22497778f, 0.12594086f, 
    -0.29054725f, 0.23762883f, 0.07206497f, 0.14807613f, 0.16077951f, 0.15132895f, -0.02598581f, -0.03326619f, 
    0.14676248f, 0.16150534f, 0.21057516f, 0.02222270f, 0.36988819f, -0.39486462f, -0.13549827f, -0.14375429f, 
    -0.15999936f, -0.11932506f, 0.02770693f, 0.31174225f, 0.08601241f, 0.08632628f, -0.25508919f, 0.42106518f, 
    0.12817608f, 0.06164126f, 0.06801046f, 0.44015452f, -0.04723879f, 0.16119069f, -0.02161548f, 0.00806297f, 
    0.13835090f, 0.21401966f, 0.14694043f, -0.14653666f, -0.15586345f, -0.06949018f, -0.03522983f, 0.28035054f, 
    0.04892652f, -0.24405356f, 0.16875672f, 0.07379188f, 0.31791258f, -0.15111604f, -0.05499198f, -0.04964528f, 
    -0.27172378f, 0.61453044f, 0.07716101f, 0.25236130f, -0.17595601f, -0.13103344f, -0.03316548f, -0.50928545f, 
    -0.07431521f, -0.11253532f, 0.18416689f, -0.07630207f, 0.00784267f, 0.16579761f, 0.05444250f, -0.13952255f, 
    0.41237953f, 0.02831423f, 0.03288006f, 0.05644498f, -0.03745693f, -0.15368731f, 0.03675803f, -0.09809765f, 
    0.11595108f, 0.21333285f, -0.01474909f, 0.06955773f, -0.50708097f, -0.25839055f, -0.29351273f, 0.09278764f, 
    -0.06562302f, 0.28944996f, -0.17579727f, -0.13565655f, -0.16190918f, -0.10415915f, 0.07953998f, 0.31045535f, 
    0.10575290f, 0.17299856f, -0.17244112f, -0.04169274f, 0.18335187f, -0.13518766f, 0.16310379f, -0.17057367f, 
    -0.00383021f, 0.02956290f, 0.19883546f, -0.06431594f, -0.00871572f, 0.13134430f, 0.14677756f, -0.05622024f, 
    -0.27670649f, 0.08547363f, 0.45494375f, -0.02845069f, -0.15441366f, -0.55266917f, -0.02939871f, 0.13094629f, 
    0.45931137f, 0.11229268f, -0.13990831f, 0.05258726f, -0.16830254f, 0.14714341f, -0.04041197f, 0.29961342f, 
    0.09192500f, 0.05021048f, 0.16641094f, -0.13707478f, -0.24767344f, -0.11529306f, 0.15644616f, -0.11697223f, 
    -0.31469107f, 0.14686018f, -0.02662807f, 0.13810247f, -0.03043994f, 0.22868676f, -0.09436872f, 0.39967492f, 
    -0.35810885f, 0.19640264f, 0.32453594f, -0.04197572f, -0.35342991f, 0.27523088f, -0.04423149f, 0.05723808f, 
    -0.05192951f, -0.13035756f, 0.07953245f, 0.19457626f, 0.02272269f, -0.07544311f, 0.04223053f, 0.00741211f, 
    -0.27080467f, -0.01530554f, 0.26878241f, -0.13697112f, 0.03128777f, 0.16565129f, -0.12170962f, -0.06304968f, 
    -0.08296955f, 0.25510183f, 0.04405219f, -0.15260582f, 0.15386717f, -0.10819574f, 0.00158607f, -0.38374653f, 
    0.10599413f, 0.01020212f, 0.00056398f, 0.13122904f, -0.19002916f, -0.23105282f, -0.20125094f, 0.10305587f, 
    0.25475568f, -0.00322010f, 0.10366911f, -0.18867090f, -0.10003386f, 0.13514027f, -0.11245080f, 0.24824719f, 
    0.02377186f, 0.01299265f, -0.13579848f, 0.08614355f, 0.02053807f, -0.06641308f, 0.08512615f, 0.09571911f, 
    -0.17189844f, -0.04810532f, -0.13280708f, 0.14464259f, -0.16080141f, -0.00282378f, 0.13851039f, -0.08573373f, 
    0.16339201f, -0.01173957f, 0.14069839f, -0.17650080f, -0.03744626f, -0.00451012f, -0.08464301f, -0.03477886f, 
    0.04965431f, 0.14470500f, 0.08901859f, -0.12654109f, 0.04761637f, -0.09492275f, 0.10610538f, -0.09679716f, 
    0.07813880f, 0.04034742f, 0.16422224f, -0.22254509f, 0.28615326f, -0.08843016f, 0.19030789f, -0.06029518f, 
    -0.09666844f, 0.19601615f, -0.30338416f, 0.14513354f, -0.25614521f, -0.10362899f, -0.02142843f, -0.32679367f, 
    -0.20826645f, 0.11947579f, 0.31100106f, 0.11343372f, -0.02150632f, 0.33001730f, 0.29306346f, -0.10980012f, 
    0.29582939f, -0.03752846f, -0.04312916f, 0.08625598f, -0.08058844f, 0.04905661f, -0.15504003f, -0.38842064f, 
    0.09321678f, 0.15421210f, 0.21052508f, -0.10836141f, 0.10500935f, 0.15590012f, 0.28859389f, -0.00441179f, 
    0.03447035f, 0.37501705f, -0.12724279f, 0.15518025f, -0.41205451f, -0.00986797f, 0.12242008f, -0.06690568f, 
    0.04959943f, -0.22796850f, 0.03137418f, 0.06838935f, -0.16829643f, -0.13451636f, 0.24434641f, 0.13090236f, 
    -0.35659426f, 0.04219023f, 0.09458028f, 0.16774775f, 0.07964358f, -0.10344209f, 0.18040942f, -0.27993742f, 
    0.06859428f, 0.08983114f, -0.09824914f, 0.07673452f, -0.20609014f, -0.04305644f, -0.16133046f, -0.01689041f, 
    0.04036406f, -0.06459184f, -0.19631086f, -0.09398121f, 0.04235272f, -0.10071492f, -0.17109032f, 0.05669410f, 
    -0.05803061f, 0.09352640f, 0.10706307f, -0.14877874f, 0.03481341f, 0.15154363f, 0.13314551f, 0.18366005f, 
    -0.06351469f, -0.14687149f, 0.01392364f, -0.11991396f, -0.08410882f, -0.06946953f, -0.18249473f, 0.11680706f, 
    -0.20477965f, 0.05134565f, 0.09867065f, -0.18397826f, 0.05707734f, -0.09537642f, 0.33684114f, 0.03790521f, 
    -0.07652746f, 0.14645469f, 0.07213672f, -0.13045734f, -0.04404495f, -0.01299252f, 0.12330752f, -0.45334777f, 
    -0.04461706f, -0.07923666f, -0.15812244f, 0.39917728f, -0.31363976f, 0.45642686f, -0.03736912f, 0.14915743f, 
    -0.02723948f, -0.37459192f, -0.03701466f, 0.14922595f, 0.03449336f, 0.16372141f, 0.08923249f, 0.35578048f, 
    0.18485723f, -0.05482982f, -0.05046437f, -0.25356376f, 0.06576214f, -0.13650569f, 0.10283509f, 0.04108084f, 
    0.00993992f, 0.21835999f, 0.16230652f, 0.05231592f, 0.04487233f, -0.28286567f, 0.08420270f, -0.09909233f, 
    0.36963460f, -0.34741431f, -0.03979496f, 0.24173075f, 0.01728917f, -0.41883269f, 0.11811742f, -0.00086206f, 
    -0.14583676f, -0.26203871f, 0.15686671f, 0.01868337f, 0.16957012f, -0.01270628f, 0.44681939f, 0.18438989f, 
    -0.10513102f, 0.11454266f, 0.14773940f, 0.31244063f, -0.22057934f, -0.16741996f, 0.34831783f, -0.11232232f, 
    0.25887585f, 0.02295297f, -0.26110843f, 0.10774800f, -0.04181831f, -0.22156493f, 0.15052263f, -0.12121360f, 
    -0.14105946f, 0.02535721f, 0.06053083f, 0.09978017f, -0.34754026f, 0.41760081f, 0.33417416f, -0.12452402f, 
    -0.11720284f, 0.20336990f, -0.13279361f, 0.35947269f, 0.18035522f, 0.16928594f, -0.09406668f, -0.24361859f, 
    0.17376545f, -0.15907297f, 0.22771165f, -0.13502510f, -0.19125104f, -0.05192546f, -0.16903763f, -0.12770613f, 
    0.10505270f, 0.22024253f, 0.28320161f, -0.13400863f, 0.10879724f, 0.05375074f, -0.04274484f, -0.00478889f, 
    0.13562030f, -0.39056414f, -0.05717148f, 0.19516516f, -0.19604127f, -0.25332448f, -0.07848611f, 0.10989129f, 
    -0.21882391f, 0.24900034f, 0.07131256f, -0.31375441f, -0.13026461f, 0.18156470f, 0.10174466f, 0.18571721f, 
    0.20857957f, 0.04914605f, -0.05317332f, -0.22428773f, -0.14310266f, -0.00487922f, -0.10557409f, 0.05215420f, 
    0.09117410f, 0.23920937f, 0.33326876f, -0.09319129f, -0.06006613f, 0.36374864f, 0.14800119f, 0.13766006f, 
    -0.31042349f, 0.14132197f, 0.34169284f, 0.10991915f, -0.29876965f, 0.43466353f, -0.31593683f, -0.06077271f, 
    0.21632710f, 0.01141515f, 0.02435789f, -0.19872341f, -0.10857838f, 0.07161810f, 0.14708847f, -0.04460691f, 
    0.00624224f, 0.03479262f, 0.17856161f, 0.34689569f, 0.25314924f, 0.05506537f, 0.34059545f, 0.15333857f, 
    0.31184351f, 0.31694221f, -0.19190919f, 0.05171655f, 0.05464719f, -0.09371735f, -0.13755339f, 0.04890456f, 
    -0.03768953f, -0.11910097f, 0.31801003f, -0.25327364f, -0.01806755f, -0.14001922f, -0.17251413f, 0.12111392f, 
    0.12462853f, 0.54604673f, 0.04343613f, -0.04244842f, -0.04362831f, -0.17210145f, -0.26589051f, -0.22985382f, 
    -0.07811837f, -0.06725649f, -0.07380536f, -0.09382470f, -0.13623498f, 0.12765698f, 0.06842855f, -0.05474831f, 
    -0.09879031f, 0.11937737f, -0.13487959f, -0.15403484f, -0.16233557f, -0.07191383f, 0.13557573f, -0.08080447f, 
    -0.06050213f, 0.00595055f, 0.11102527f, -0.12143007f, 0.08353050f, 0.11090793f, -0.12575367f, 0.17235447f, 
    0.01097625f, 0.01580812f, -0.10883228f, 0.00574887f, 0.03119630f, 0.00314995f, 0.11125849f, 0.01737645f, 
    -0.13333288f, -0.14765339f, -0.06944519f, 0.17308708f, 0.19575797f, -0.15584731f, -0.06829045f, -0.02925896f, 
    0.41489786f, -0.27476606f, 0.19236203f, 0.02803378f, 0.27219784f, 0.11361441f, 0.13777591f, 0.18184103f, 
    0.01364307f, 0.25662148f, -0.13878898f, -0.11770342f, 0.19613051f, -0.20355804f, 0.26919949f, 0.11784472f, 
    0.27889332f, 0.06035399f, -0.05574611f, 0.17761306f, -0.17636092f, -0.09476086f, -0.12459950f, -0.04171160f, 
    -0.28190753f, -0.17539729f, 0.12478420f, 0.01504022f, -0.28868204f, -0.14180669f, 0.00506795f, -0.00623391f, 
    0.25404030f, 0.16464700f, 0.14187180f, 0.10079178f, 0.09525040f, 0.04262834f, 0.06667022f, 0.38639683f, 
    -0.12677662f, 0.52863127f, 0.11775356f, -0.06525081f, -0.52363491f, 0.01057406f, -0.11015945f, -0.12625553f, 
    -0.19258408f, 0.17162713f, 0.08915871f, 0.17745586f, 0.10874850f, 0.15632932f, -0.11775941f, 0.20103930f, 
    0.12932116f, -0.12891513f, 0.11651754f, -0.28403294f, -0.05125213f, -0.04947260f, -0.13614221f, -0.01447213f, 
    -0.01127488f, -0.16197665f, 0.36788416f, -0.11705104f, 0.40473351f, 0.23095286f, 0.15736134f, 0.28523454f, 
    0.06200624f, 0.00637668f, -0.29046911f, 0.26125795f, 0.10361542f, 0.01425492f, -0.22226906f, 0.02263912f, 
    -0.12478808f, -0.33733380f, -0.08978214f, -0.04869230f, 0.16889831f, 0.06203028f, -0.11241940f, 0.20741667f, 
    0.08397640f, -0.07311447f, 0.15899929f, -0.03195119f, 0.16509683f, -0.01118621f, -0.23693722f, 0.05256429f, 
    -0.25936842f, 0.00794367f, 0.37482330f, -0.09467921f, 0.34601554f, -0.09555715f, -0.00958632f, 0.32369578f, 
    0.16149175f, -0.20591004f, -0.28615525f, -0.01801029f, 0.28589097f, -0.04658803f, -0.00864477f, 0.03287343f, 
    -0.11398869f, 0.17550689f, 0.08944660f, -0.10127853f, -0.11576395f, 0.12179338f, -0.25105497f, 0.01095135f, 
    -0.16979182f, 0.14126809f, 0.06720474f, -0.33169308f, 0.36451232f, 0.10985447f, 0.08154692f, -0.05648962f, 
    0.06102965f, 0.10988343f, 0.02003429f, -0.06830745f, -0.19587243f, -0.14552782f, 0.12047201f, -0.31584865f, 
    -0.27396291f, 0.23423208f, 0.22279301f, 0.04435211f, 0.21770568f, -0.03642742f, 0.21931899f, -0.14347687f, 
    0.23193146f, 0.13955669f, 0.00072173f, 0.29556525f, -0.09640130f, 0.13843682f, -0.10652738f, 0.06304468f, 
    0.04560345f, -0.07547186f, 0.11716362f, 0.14009331f, 0.03417876f, -0.05357061f, 0.14571790f, -0.06947554f, 
    0.21228898f, -0.03133566f, 0.02578962f, -0.07910525f, 0.06822676f, -0.30460224f, -0.01515515f, -0.17476264f, 
    -0.04994500f, -0.16289708f, -0.17159636f, 0.01627247f, -0.04537842f, 0.35860896f, 0.12099632f, 0.06147266f, 
    0.23275357f, -0.06919441f, 0.03471497f, 0.11277011f, -0.07728851f, 0.13004427f, -0.10819074f, -0.17233993f, 
    0.11952528f, -0.02524966f, 0.10914952f, -0.24474506f, 0.07825166f, -0.17052151f, 0.46435061f, 0.09093983f, 
    -0.26865849f, 0.01372861f, -0.20324934f, 0.13316154f, 0.22443923f, -0.04585189f, 0.10049629f, -0.13975263f, 
    -0.19444971f, 0.19284438f, 0.22017385f, 0.12014963f, -0.29560345f, 0.09561438f, 0.21978165f, 0.02875007f, 
    -0.11624712f, -0.24857509f, 0.00800286f, 0.37280217f, -0.07989345f, 0.09766833f, 0.07634822f, 0.05969250f, 
    0.06198486f, 0.14744174f, 0.10459529f, 0.13891378f, 0.07550737f, -0.13871340f, -0.21545318f, 0.13332222f, 
    -0.09341256f, -0.33502379f, 0.07400265f, -0.05460880f, 0.40710375f, -0.27197766f, 0.08464412f, -0.07583475f, 
    0.23861353f, -0.25677422f, -0.15985540f, 0.01745098f, 0.31797510f, -0.10089345f, 0.21255600f, 0.16166805f, 
    -0.14590806f, 0.24680059f, -0.02052362f, 0.17278798f, 0.09890402f, 0.03059872f, 0.07235128f, 0.26182860f, 
    -0.16361155f, 0.02526595f, 0.09976283f, 0.49296081f, 0.08636440f, -0.15167363f, -0.10035316f, 0.07196130f, 
    0.07259592f, -0.00875580f, -0.03848067f, 0.17551784f, 0.05964013f, -0.01713168f, 0.05680299f, -0.10286090f, 
    -0.29925156f, 0.23857249f, 0.12003083f, -0.23175770f, 0.15090795f, 0.06458684f, 0.22096056f, -0.00162466f, 
    0.20058846f, 0.17621693f, 0.06655382f, -0.28731656f, 0.02364089f, 0.05328397f, 0.25041658f, 0.13076396f, 
    -0.07543951f, -0.18157522f, 0.04934033f, 0.17743072f, 0.32527003f, 0.11544294f, 0.01989419f, -0.02386395f, 
    -0.28239149f, 0.25728178f, 0.10313991f, -0.04540501f, 0.21681368f, 0.27607578f, -0.00857119f, 0.07165736f, 
    0.22879992f, -0.21213923f, 0.42715606f, -0.15897064f, 0.33490613f, -0.41420925f, -0.24564071f, -0.17951988f, 
    0.29205686f, 0.38555321f, -0.15867969f, -0.01933518f, 0.11612031f, -0.13227449f, -0.30934724f, 0.35129938f, 
    0.05667892f, -0.07912897f, -0.17422257f, -0.26190951f, 0.02694138f, 0.14382303f, 0.20309666f, -0.01878538f, 
    -0.35162812f, 0.06659535f, 0.14746210f, -0.02243726f, 0.39480782f, -0.16718234f, -0.02559501f, 0.12725769f, 
    0.13184392f, -0.05531282f, -0.21283102f, -0.14492464f, -0.01508490f, 0.33195126f, 0.18915856f, 0.00467434f, 
    0.05168000f, -0.01161725f, 0.13413671f, 0.23843077f, 0.10057876f, 0.06249617f, 0.25761878f, -0.23386924f, 
    0.02148534f, -0.03657503f, -0.18132007f, 0.01149005f, -0.01717941f, -0.13713974f, 0.24757522f, 0.10923969f, 
    -0.28504235f, -0.21034998f, 0.16484761f, -0.01452977f, 0.15786114f, -0.01963265f, -0.11441682f, -0.12368215f, 
    0.00123714f, 0.17562334f, 0.23861200f, -0.01278293f, -0.27515328f, -0.02415930f, 0.13033266f, 0.09252534f, 
    0.31587067f, 0.16397004f, -0.12854700f, 0.15878704f, 0.10348321f, 0.01004581f, 0.05030978f, 0.17577453f, 
    -0.15642159f, -0.01539227f, 0.16680846f, 0.10377184f, 0.24189372f, -0.08005052f, 0.36912626f, 0.10989141f, 
    0.42305544f, 0.17107925f, -0.18024597f, 0.15981761f, 0.07452539f, -0.07090276f, 0.15209274f, 0.11124001f, 
    0.09040820f, 0.06103278f, -0.17101409f, -0.14331666f, 0.37895086f, -0.39984518f, -0.12772469f, -0.10450143f, 
    0.04151394f, -0.20926532f, -0.06722486f, 0.26764181f, -0.09975003f, -0.12467036f, -0.11197108f, -0.00994983f, 
    -0.09970642f, -0.10167086f, 0.22371854f, -0.13135320f, -0.00975297f, 0.13473731f, 0.28214407f, -0.00504491f, 
    0.18556164f, 0.35598162f, 0.11515202f, 0.11871997f, -0.14402899f, 0.01890102f, -0.17100167f, -0.20633325f, 
    0.38762352f, -0.16315329f, -0.20610844f, 0.03121744f, -0.70083433f, 0.29663768f, -0.26078358f, 0.01803185f, 
    -0.01262521f, 0.22113778f, -0.16491541f, -0.29628995f, 0.11014101f, 0.15188158f, 0.06537750f, 0.04637997f, 
    0.13992183f, -0.07837316f, 0.15061446f, 0.01362645f, -0.06388136f, -0.16142604f, 0.09688625f, 0.03729825f, 
    -0.24170180f, 0.33848637f, 0.18951993f, -0.00010112f, -0.20246790f, 0.32675588f, 0.12893394f, 0.03875178f, 
    -0.23795027f, 0.06312782f, 0.41964290f, -0.14811124f, -0.36531651f, 0.32512361f, -0.17481197f, 0.05987022f, 
    0.03469510f, 0.14827764f, -0.05573064f, 0.01900206f, 0.00524745f, 0.12301021f, -0.23251359f, 0.29456609f, 
    -0.34218854f, 0.11039034f, 0.07425095f, 0.03131090f, 0.11696459f, -0.03879586f, -0.26165923f, -0.11928513f, 
    -0.10531303f, -0.20432860f, -0.00686805f, 0.05361712f, 0.10374741f, 0.17385577f, -0.08334913f, -0.16130786f, 
    -0.27837503f, 0.31138980f, 0.03887526f, 0.03585454f, 0.24949618f, 0.26869339f, 0.12572315f, 0.10364740f, 
    0.16479585f, -0.17046776f, -0.04273712f, 0.05808768f, 0.03647964f, 0.04913526f, 0.07665087f, 0.32237482f, 
    -0.16088238f, 0.03738599f, -0.07496659f, 0.08375569f, 0.11398111f, 0.11532454f, 0.03953683f, -0.06464285f, 
    0.58600211f, 0.00371097f, 0.25519994f, -0.06161868f, 0.21578144f, -0.12705670f, -0.02770326f, 0.04084243f, 
    0.30312321f, 0.32706347f, -0.47193751f, 0.13113168f, -0.23365097f, -0.06294278f, -0.29065254f, 0.09328508f, 
    0.22977322f, 0.17206360f, 0.03727424f, 0.00140164f, 0.15240477f, 0.09232084f, -0.00260222f, 0.14591801f, 
    -0.08232846f, -0.01942011f, 0.07371330f, -0.09222831f, -0.17167237f, 0.07623129f, 0.08100551f, -0.10855500f, 
    0.42652115f, 0.11831824f, 0.13688634f, -0.12918751f, 0.30436850f, -0.26582980f, 0.04258251f, 0.25981253f, 
    0.48688844f, -0.05886586f, -0.18851241f, 0.20197889f, -0.06126753f, -0.35643047f, -0.27094680f, -0.00656437f, 
    -0.09229122f, 0.24774389f, 0.12901108f, -0.28294945f, 0.06749033f, 0.10028522f, -0.10643104f, 0.04422845f, 
    -0.27201295f, -0.17668000f, 0.23036297f, -0.11435341f, 0.11265774f, -0.13302998f, -0.10711993f, -0.08620033f, 
    -0.20618014f, -0.15516959f, 0.12377594f, 0.08376478f, 0.31639075f, -0.15433288f, -0.16453645f, -0.16688119f, 
    0.16289259f, -0.07037260f, -0.20421520f, -0.15853012f, 0.49331322f, -0.48150900f, 0.12994333f, -0.07101443f, 
    0.18547650f, 0.07770205f, 0.13661687f, 0.16821462f, 0.05589438f, 0.09444373f, -0.08762961f, 0.39481762f, 
    -0.10447083f, -0.03307363f, -0.10180888f, -0.11366609f, -0.07172738f, -0.09752762f, -0.03108414f, -0.13679382f, 
    0.12110128f, 0.11093841f, -0.07699650f, 0.08816843f, 0.06345400f, -0.04915081f, 0.03590407f, -0.11918706f, 
    -0.02560240f, 0.12417491f, 0.03328258f, -0.19190510f, -0.11293095f, -0.15105206f, 0.07905432f, -0.16574283f, 
    -0.14052752f, -0.04296298f, 0.12365434f, 0.01641826f, -0.14304227f, 0.13203610f, -0.05105568f, -0.10562026f, 
    0.28707626f, 0.11362257f, -0.06173533f, 0.14711073f, 0.10651193f, -0.12880835f, -0.29584759f, -0.00024497f, 
    -0.16494384f, -0.13712388f, 0.40879548f, 0.12504336f, 0.15660806f, 0.17996503f, -0.13968718f, 0.22439495f, 
    0.02364908f, -0.09963173f, -0.26011309f, 0.00781694f, 0.19977552f, 0.44461438f, -0.14337115f, 0.11296887f, 
    0.24393186f, -0.19586869f, 0.03620777f, 0.04323574f, 0.07071263f, -0.00836754f, 0.03176986f, 0.11819508f, 
    -0.03747125f, 0.07318524f, 0.20856556f, -0.04128143f, 0.10373566f, -0.06204517f, -0.11596470f, 0.12378228f, 
    0.26099366f, -0.15984967f, 0.25689921f, -0.13489342f, -0.10208727f, -0.22236781f, -0.13514778f, -0.04770552f, 
    0.05240162f, 0.02787126f, -0.50046021f, 0.40406838f, 0.04191427f, 0.56089896f, -0.02857331f, 0.04209092f, 
    0.23465775f, 0.21481074f, 0.08133120f, -0.03446559f, -0.01078391f, 0.15539587f, -0.27637756f, -0.13990326f, 
    -0.21006037f, 0.02633620f, 0.29523149f, 0.08517607f, 0.13464136f, 0.03699603f, -0.08961336f, 0.08409326f, 
    -0.14274976f, -0.16027316f, -0.29021436f, -0.07327861f, 0.10017330f, -0.01599086f, -0.12959266f, 0.03819109f, 
    -0.33651721f, 0.04223527f, 0.19065100f, -0.21906620f, 0.63073969f, -0.38726646f, 0.22832660f, 0.13881375f, 
    -0.11935700f, 0.22538237f, 0.16681898f, 0.08958465f, 0.06915695f, 0.14669332f, 0.04786033f, 0.27054918f, 
    -0.16876438f, 0.02864404f, 0.25217846f, -0.05446026f, -0.01577896f, 0.11331014f, -0.07695781f, 0.04514356f, 
    -0.10577304f, -0.18916890f, 0.25034118f, 0.01632532f, 0.01820826f, -0.12896192f, 0.00625455f, -0.17917362f, 
    0.28172481f, -0.20041142f, -0.09367941f, -0.09770753f, 0.10137856f, -0.28915128f, 0.13587433f, 0.05020371f, 
    0.18621327f, 0.04793108f, -0.03910141f, -0.20664410f, -0.05257306f, -0.16869727f, 0.32400581f, 0.43956465f, 
    -0.30880627f, -0.00082851f, 0.24400185f, 0.07391649f, -0.00415172f, -0.17327116f, -0.12593098f, 0.06862364f, 
    -0.25114620f, -0.06731740f, 0.03369144f, -0.11277582f, 0.26627705f, 0.05455967f, 0.11013360f, -0.13103095f, 
    0.16332139f, -0.35861745f, -0.02596565f, 0.08023053f, 0.40601858f, -0.30150568f, 0.10288740f, -0.03916238f, 
    0.10622903f, 0.49150395f, -0.09272073f, 0.14363474f, -0.00483233f, 0.01537386f, -0.03995683f, 0.07743672f, 
    0.17763318f, -0.11436227f, 0.00116468f, 0.50232971f, 0.00533981f, -0.05294816f, -0.32547763f, 0.16801584f, 
    -0.33852163f, 0.09819733f, 0.07753408f, -0.16434425f, -0.08607504f, 0.08100846f, -0.04491124f, 0.04078677f, 
    0.07892173f, -0.18870538f, 0.36838433f, 0.07376284f, 0.37564224f, 0.47850665f, 0.08700320f, -0.05588377f, 
    0.20407869f, -0.33291724f, -0.13178238f, -0.19300066f, 0.04493209f, -0.16309169f, 0.12583612f, -0.21486108f, 
    0.11533228f, 0.05935703f, -0.03349095f, -0.05513453f, -0.04491038f, 0.03368005f, 0.04654722f, -0.14755279f, 
    0.02860537f, 0.11051473f, 0.13727909f, 0.13435437f, 0.09551279f, 0.04184070f, -0.14367662f, -0.30666241f, 
    -0.10496747f, 0.20843288f, -0.06884849f, 0.25411251f, -0.35353950f, 0.56055230f, -0.10026368f, -0.16160314f, 
    0.28048840f, -0.48833394f, 0.03350542f, -0.29441580f, -0.15601918f, 0.00212774f, 0.30841777f, -0.07624876f, 
    0.38992408f, -0.05748801f, 0.09864672f, -0.17179137f, 0.19914690f, -0.01575810f, 0.30231321f, 0.09495869f, 
    -0.08408101f, 0.33663371f, 0.07387777f, -0.00888093f, 0.00986912f, 0.03888477f, -0.14775783f, -0.11478931f, 
    -0.00025185f, -0.31757912f, -0.42862135f, -0.11527210f, 0.17683277f, -0.18157573f, -0.09031908f, -0.08921440f, 
    -0.07919531f, -0.22877626f, -0.09427032f, 0.08180106f, -0.07157443f, -0.04041507f, 0.20743567f, -0.01943850f, 
    0.29116648f, -0.01253292f, 0.09027750f, -0.17708464f, -0.07985154f, -0.13546088f, 0.36682582f, 0.10036150f, 
    0.38852361f, 0.19754376f, -0.18492891f, 0.10283328f, 0.00500482f, -0.30704173f, 0.12155523f, 0.11307254f, 
    0.23643276f, -0.03483326f, -0.41879931f, 0.01918463f, 0.02700752f, -0.19998635f, 0.29813939f, 0.16907766f, 
    -0.05662921f, -0.38028085f, 0.05376758f, 0.08730030f, 0.14107767f, -0.03985018f, 0.35711658f, -0.21499322f, 
    0.30835497f, 0.03290547f, -0.14252235f, 0.13463779f, -0.13676450f, 0.00279996f, 0.19158389f, 0.00506360f, 
    0.36559284f, 0.30564404f, -0.42242923f, -0.01960931f, -0.03764618f, 0.06263372f, 0.06665125f, 0.09531482f, 
    -0.24587797f, 0.12629028f, 0.17018241f, 0.06636748f, -0.21521130f, 0.21697444f, 0.14744282f, -0.00535232f, 
    0.14792104f, -0.22724001f, 0.15417580f, 0.21928670f, -0.08551253f, 0.09699711f, 0.18800394f, -0.36173895f, 
    -0.04829556f, -0.04365157f, 0.13313979f, 0.15443318f, -0.17756079f, -0.10162250f, -0.05374353f, -0.08713100f, 
    -0.11870962f, 0.17060484f, 0.42080382f, -0.11323505f, -0.03576479f, 0.07495295f, 0.10946845f, -0.02680990f, 
    0.09153592f, -0.29766056f, 0.11519623f, 0.32812577f, 0.03927787f, 0.26544753f, -0.19556016f, -0.15963110f, 
    -0.22310150f, 0.47058222f, -0.00615188f, -0.18399176f, 0.04351534f, -0.06710547f, 0.03109780f, -0.15008634f, 
    0.35951680f, -0.04909272f, -0.09235207f, 0.07192873f, 0.08496401f, -0.09097458f, 0.31770486f, 0.13253161f, 
    -0.06379133f, 0.14998206f, 0.00356611f, -0.03855041f, 0.06618284f, 0.25142604f, -0.09949164f, 0.17090030f, 
    -0.02773286f, 0.09101263f, 0.42963243f, -0.12957442f, -0.19785546f, 0.01659746f, 0.23441042f, 0.08827516f, 
    -0.27049392f, -0.36701426f, 0.16124688f, 0.21441169f, -0.04029494f, -0.07432006f, 0.13608052f, -0.26722613f, 
    0.20556335f, 0.14028762f, 0.07736728f, 0.43596196f, 0.29438969f, 0.03800518f, 0.23032592f, 0.06952250f, 
    -0.08456460f, 0.33754677f, -0.27358487f, 0.08357689f, -0.37529001f, 0.01716311f, -0.17059121f, 0.03888548f, 
    0.04572472f, -0.00026903f, 0.18921855f, 0.02018949f, 0.37432393f, 0.09585150f, 0.04013103f, 0.14841595f, 
    0.25067919f, 0.31616411f, -0.13444321f, 0.13159768f, 0.00263655f, 0.15955943f, -0.30539259f, -0.23157933f, 
    0.05645042f, -0.16478111f, 0.16454302f, -0.30394238f, -0.00855520f, 0.11767811f, 0.36291942f, -0.16161023f, 
    -0.24768037f, 0.06940918f, -0.13737342f, 0.05677038f, 0.03263535f, 0.23264778f, -0.14039069f, -0.27080354f, 
    0.05500910f, 0.25770167f, -0.21103334f, -0.01687920f, -0.36527193f, 0.57965344f, 0.21140110f, 0.07451681f, 
    -0.03970695f, -0.29831377f, 0.17113376f, 0.03704239f, -0.03876964f, -0.06041955f, -0.03794917f, 0.03468847f, 
    -0.05997549f, -0.14500332f, -0.09074658f, -0.06381794f, -0.09452217f, -0.01787593f, -0.19598906f, 0.17438191f, 
    0.09973298f, 0.17557044f, 0.07930831f, 0.12791803f, 0.28814515f, -0.19832216f, -0.01628937f, -0.42745239f, 
    -0.07958518f, -0.18008751f, -0.31628370f, 0.11951543f, -0.01924447f, 0.48345485f, 0.05608520f, 0.08749224f, 
    0.41409153f, -0.28621629f, 0.10139237f, 0.04869094f, -0.15320739f, 0.01700259f, 0.42645058f, 0.08214131f, 
    0.27870193f, 0.14805649f, -0.16760772f, -0.04424070f, 0.05175668f, 0.07280434f, -0.10862229f, -0.00955172f, 
    0.52834111f, 0.29813722f, 0.13390675f, 0.01599660f, 0.20182431f, 0.15549350f, 0.16370712f, 0.20887145f, 
    0.10139412f, 0.09948201f, -0.27937615f, 0.17687656f, 0.38722834f, -0.29037878f, -0.19693865f, 0.16129418f, 
    0.22682284f, -0.37009689f, -0.05215931f, -0.27007526f, 0.06969632f, 0.13002321f, 0.26752001f, -0.10225184f, 
    0.14358437f, -0.14819288f, 0.06193085f, -0.17166527f, -0.29903728f, 0.10314310f, 0.24329482f, -0.15945607f, 
    0.27398059f, 0.27282080f, 0.15615532f, 0.05480396f, -0.07672659f, 0.36045390f, -0.05825251f, 0.36187994f, 
    -0.17819850f, 0.09279954f, -0.15118995f, 0.30258623f, -0.46056211f, -0.12356893f, -0.43573451f, 0.05729978f, 
    0.11322053f, -0.03261339f, 0.14300324f, 0.01116697f, 0.03100427f, 0.10083741f, -0.23694204f, 0.29879013f, 
    0.27267683f, -0.02220054f, 0.04888292f, -0.15436186f, 0.08072069f, -0.00530874f, 0.26966348f, 0.02346518f, 
    0.25456065f, 0.01303950f, -0.12277457f, -0.06190580f, 0.28126329f, -0.09587023f, -0.03789781f, 0.36480799f, 
    -0.16846241f, 0.40995342f, -0.40327799f, 0.08309271f, -0.04723534f, -0.35946622f, 0.02724826f, 0.06728294f, 
    -0.32696697f, -0.47105098f, -0.01847651f, 0.24748126f, 0.16422780f, 0.11139414f, 0.00285671f, 0.02167020f, 
    0.11194105f, -0.13962908f, -0.16734262f, 0.45168343f, 0.22701955f, 0.04402715f, 0.24388264f, 0.04905836f, 
    0.18119392f, 0.22643913f, 0.03700314f, 0.07723384f, 0.13298947f, 0.08158193f, -0.16922054f, 0.31127903f, 
    -0.01765577f, 0.02624081f, 0.31717622f, -0.18042752f, 0.44192812f, 0.09385666f, 0.15531929f, 0.00677320f, 
    0.26504061f, -0.06100453f, -0.12741578f, 0.08251432f, -0.13192901f, 0.10254779f, -0.30783746f, -0.16651627f, 
    0.21720044f, 0.06966610f, 0.05135732f, 0.11770534f, 0.22170889f, 0.04189034f, 0.14018123f, -0.12862875f, 
    -0.30567425f, 0.22403756f, -0.12503818f, -0.14883371f, -0.04379765f, 0.09644784f, -0.03844817f, 0.03010893f, 
    0.40545398f, 0.00526330f, 0.22599965f, 0.04119475f, -0.11483135f, -0.43787548f, -0.30013788f, 0.07429157f, 
    -0.51072532f, -0.18480328f, 0.04826181f, 0.05898992f, -0.15550275f, 0.07554487f, 0.02906069f, -0.09750697f, 
    0.28932372f, 0.00597505f, 0.06419258f, -0.00666109f, -0.06644583f, -0.01086740f, 0.25412488f, 0.01196134f, 
    0.01401605f, 0.27089116f, -0.16282912f, 0.13915028f, -0.20230204f, -0.13827229f, -0.10903014f, 0.16959620f, 
    0.11412510f, -0.14222229f, -0.05112500f, 0.31349140f, -0.25880358f, -0.00196010f, 0.30862302f, 0.08408582f, 
    -0.34922487f, -0.19220783f, 0.05815182f, 0.40269369f, 0.12359170f, 0.10407103f, 0.19591895f, -0.44891265f, 
    0.00649184f, -0.06185839f, 0.26119941f, -0.16261791f, -0.17469053f, -0.08955897f, 0.40710893f, 0.17149033f, 
    -0.13763984f, 0.08195849f, 0.00631320f, -0.06252074f, -0.22671980f, 0.32165313f, -0.08643648f, -0.07724920f, 
    0.16347283f, 0.24658702f, 0.26995572f, 0.26236168f, -0.35631934f, 0.18520375f, -0.07448376f, 0.06544990f, 
    -0.27040124f, -0.19994636f, 0.02759171f, 0.13893418f, 0.08616817f, 0.02812432f, -0.25839984f, -0.13712965f, 
    -0.17050013f, 0.07370508f, -0.18141086f, -0.15109572f, 0.02880994f, 0.10881992f, 0.07347431f, -0.13032743f, 
    -0.05103830f, 0.07164075f, 0.15142879f, -0.01725515f, -0.15078680f, -0.04626195f, 0.17386599f, -0.08905487f, 
    -0.17843750f, 0.14251405f, -0.01274373f, 0.00566366f, -0.02238139f, -0.06519813f, 0.08128181f, -0.02804236f, 
    -0.14817484f, -0.14076072f, -0.06299196f, -0.03089541f, -0.06628797f, -0.04762236f, 0.07624681f, 0.01060185f, 
    0.24126071f, -0.05942542f, -0.07537354f, 0.06379607f, 0.17896995f, 0.16355884f, 0.22190055f, 0.07021484f, 
    0.15792969f, 0.16832495f, -0.04179197f, -0.08801842f, -0.16837336f, -0.10203692f, -0.06269129f, -0.19256270f, 
    -0.15799275f, 0.02967465f, 0.04132518f, 0.17508923f, 0.25535780f, 0.31519878f, 0.37461174f, -0.05292372f, 
    0.11028633f, 0.08373720f, 0.01970493f, -0.01059454f, -0.06759724f, 0.16964130f, 0.21600345f, -0.41651025f, 
    -0.12817340f, 0.09781557f, -0.00280441f, -0.12272391f, -0.13939853f, 0.08216787f, -0.17411050f, 0.03690576f, 
    -0.04892882f, -0.12113455f, 0.06308833f, -0.01519491f, -0.07767966f, -0.11562692f, 0.15809700f, 0.12788256f, 
    -0.01586249f, 0.07229388f, -0.04864195f, -0.11490164f, -0.14442714f, -0.06906907f, -0.13735501f, -0.16262643f, 
    0.11199012f, -0.11067265f, -0.15731463f, -0.17087968f, -0.08032717f, -0.02818800f, 0.11331709f, 0.11521734f, 
    -0.21397549f, 0.10232352f, 0.07734888f, -0.33583117f, 0.23646063f, 0.05055550f, 0.10130589f, 0.00545747f, 
    -0.03955695f, -0.08394177f, 0.16504543f, 0.00496374f, -0.16940965f, 0.10841753f, 0.17607999f, -0.38042754f, 
    -0.22569150f, 0.32872683f, -0.03031051f, -0.06354395f, -0.03588686f, -0.39635816f, -0.00999913f, -0.14018829f, 
    0.19733228f, 0.19724800f, -0.06363477f, -0.11539892f, -0.16731635f, 0.09128145f, 0.24253142f, 0.27037373f, 
    0.21676290f, -0.10782604f, 0.19350369f, 0.27914914f, 0.19367123f, -0.03845286f, -0.01024544f, -0.06865986f, 
    -0.31558907f, 0.23731872f, 0.13765408f, 0.10257611f, -0.17698020f, 0.05413404f, -0.03329045f, 0.08305200f, 
    0.09807067f, -0.34496358f, -0.01087250f, -0.27003834f, 0.58991402f, 0.02574066f, 0.07430938f, -0.04695894f, 
    -0.10499080f, 0.35673833f, -0.08886595f, 0.14405783f, -0.08257697f, -0.00499636f, -0.35516939f, 0.00339554f, 
    0.19898392f, -0.05068363f, 0.06804002f, 0.21336159f, -0.16181704f, 0.09801599f, -0.13269722f, -0.15122302f, 
    0.25323030f, 0.11580779f, -0.13218613f, 0.13027789f, 0.06266891f, -0.26641324f, 0.14491883f, -0.10020918f, 
    -0.19468977f, 0.14471923f, -0.06300564f, -0.21685147f, -0.23603427f, -0.11281025f, 0.18360010f, -0.04996401f, 
    0.17583160f, -0.16889770f, -0.09288254f, -0.22809006f, 0.05557767f, -0.13788891f, 0.53811979f, -0.18086845f, 
    0.01522016f, 0.15233681f, -0.05906060f, 0.22530289f, -0.02319662f, 0.06287086f, -0.19884145f, 0.13590835f, 
    0.07555233f, 0.10833975f, 0.04017681f, -0.02230930f, 0.00262464f, -0.01747417f, 0.03411124f, 0.01613095f, 
    0.04446446f, -0.10078100f, 0.15156032f, 0.33798665f, 0.37293616f, 0.13132051f, 0.38449085f, 0.11265513f, 
    -0.01638489f, -0.18657853f, -0.12948766f, -0.00027900f, -0.16330640f, -0.16210146f, 0.42217642f, -0.41067854f, 
    0.32436624f, 0.16713601f, 0.04475776f, -0.12874188f, -0.20164284f, 0.15411133f, 0.11685849f, 0.13745452f, 
    0.23390247f, 0.25567022f, -0.01360380f, -0.16068769f, -0.07463558f, 0.22138356f, 0.17002426f, 0.42329156f, 
    -0.20291834f, 0.23105624f, -0.11120822f, 0.18639097f, -0.36605403f, 0.47031322f, -0.05545504f, -0.05528910f, 
    -0.23957945f, -0.30346841f, -0.06498170f, 0.29245862f, 0.07496890f, 0.15833631f, -0.11846326f, -0.33327401f, 
    0.12452906f, 0.16540311f, 0.07913863f, -0.30277115f, 0.25204530f, 0.06906515f, 0.25993466f, -0.02382983f, 
    -0.19906232f, 0.02207232f, -0.18262802f, -0.01279877f, -0.12834591f, 0.18221654f, -0.07792652f, -0.12353472f, 
    -0.34814164f, 0.17170085f, 0.09883831f, 0.06249089f, 0.13314815f, 0.38056546f, 0.21943012f, -0.02632430f, 
    0.18837075f, 0.24078305f, 0.04723040f, 0.23290625f, -0.04460721f, -0.03024577f, -0.26281846f, -0.23443823f, 
    0.31409365f, -0.08775820f, -0.17174312f, 0.45602944f, 0.14382018f, 0.16021149f, -0.12572525f, 0.12426589f, 
    0.48896530f, -0.12687661f, -0.18863256f, 0.06759515f, 0.27564386f, -0.07372662f, 0.12483057f, 0.13980964f, 
    0.08934981f, 0.07035396f, -0.06615873f, -0.26669401f, 0.40367365f, -0.16921382f, 0.33870080f, 0.00818797f, 
    0.34622496f, -0.01052259f, -0.02541076f, 0.14646821f, -0.17106177f, -0.03642413f, 0.32664713f, -0.21352309f, 
    -0.03454613f, -0.03429106f, 0.05845448f, 0.26354584f, -0.20959942f, -0.06894197f, -0.39712915f, 0.04979886f, 
    0.29013193f, -0.21487579f, 0.05032586f, -0.13599116f, 0.01441409f, -0.08052073f, -0.07540198f, 0.24291968f, 
    -0.17921472f, 0.19492412f, 0.13695237f, 0.26976088f, -0.23867084f, 0.24152797f, 0.09112477f, -0.00745569f, 
    0.22044028f, 0.17847380f, 0.02996270f, -0.32799402f, 0.16182752f, -0.05493886f, 0.44262451f, -0.08496004f, 
    -0.15528323f, 0.03331786f, 0.04396569f, -0.09192702f, 0.32168782f, -0.16594951f, 0.18145303f, -0.12502234f, 
    -0.14287126f, 0.18924630f, 0.00489723f, 0.09812730f, 0.18005629f, 0.10429895f, -0.07292512f, -0.14768012f, 
    0.19921908f, 0.00191546f, -0.04625701f, 0.09909465f, 0.48287156f, -0.28009501f, -0.11562680f, -0.03269172f, 
    0.23213807f, -0.20108612f, -0.06862954f, -0.10236492f, -0.01769909f, 0.00618344f, -0.24499196f, 0.51108390f, 
    -0.14811629f, 0.05111070f, 0.08060997f, -0.36851463f, -0.16344742f, 0.08131198f, -0.13736346f, 0.10636089f, 
    0.13524462f, -0.18298148f, 0.29680482f, -0.08087756f, 0.05213480f, 0.04649243f, 0.09177019f, -0.31264719f, 
    -0.04558990f, 0.22554010f, 0.02484395f, 0.47923949f, -0.30947843f, 0.43677336f, -0.13545464f, -0.10149442f, 
    -0.02811663f, -0.24982667f, 0.15979908f, 0.06984529f, -0.04484108f, 0.13468465f, 0.07246683f, 0.25745273f, 
    -0.13405654f, -0.03551497f, -0.18423921f, 0.01858176f, 0.29687181f, 0.15448511f, -0.00762417f, 0.12389571f, 
    -0.03888718f, -0.06925843f, -0.16211937f, 0.12368307f, 0.17257938f, 0.04380787f, -0.08179636f, -0.30800912f, 
    -0.02158360f, 0.18680106f, 0.35500675f, 0.09184827f, -0.07660894f, 0.07156457f, 0.13468190f, 0.06931489f, 
    0.43294135f, 0.06148579f, -0.04622493f, 0.20441578f, -0.01395163f, 0.06529142f, -0.19722815f, 0.10111763f, 
    0.14423969f, -0.15175533f, 0.12563814f, 0.09916441f, -0.11695613f, 0.16395195f, 0.15052669f, -0.06613638f, 
    0.07178802f, -0.31417018f, -0.15520324f, 0.05959577f, 0.03044366f, 0.02637194f, -0.16275129f, 0.21000001f, 
    -0.26052991f, 0.37650812f, -0.19420126f, 0.00496441f, -0.27259973f, -0.10701137f, 0.37441626f, 0.12518878f, 
    -0.16833718f, -0.03793370f, 0.01292421f, 0.25951061f, -0.16131744f, 0.01037862f, 0.13064024f, -0.01242761f, 
    0.14416990f, -0.03646556f, 0.05206903f, 0.17352435f, -0.15679649f, -0.01946696f, -0.31071374f, 0.08963257f, 
    -0.25830361f, -0.14224502f, 0.10371720f, 0.09705982f, 0.04840221f, 0.40910840f, 0.10046462f, 0.47306621f, 
    -0.35556498f, 0.34264565f, 0.46289730f, 0.12123125f, 0.20577860f, 0.39402547f, 0.21310025f, 0.03064698f, 
    -0.23973224f, -0.13229816f, 0.13075018f, 0.09166852f, 0.08845586f, -0.08245617f, -0.11339676f, -0.20827815f, 
    0.25677231f, -0.10427155f, 0.10298667f, -0.29042396f, -0.16514470f, 0.02721636f, 0.17539567f, 0.09263659f, 
    0.21137546f, -0.10646822f, 0.08273084f, 0.06936447f, 0.02307928f, 0.07849972f, 0.06919305f, -0.02410355f, 
    -0.15822542f, 0.24663566f, -0.41921192f, 0.03691908f, -0.41728216f, 0.41693553f, 0.23460121f, 0.14528343f, 
    -0.05082698f, -0.44063646f, 0.06792377f, -0.16698949f, -0.03466274f, 0.06271981f, 0.23662469f, 0.20656027f, 
    -0.05949529f, -0.12278315f, 0.15354925f, 0.32069385f, 0.30077490f, 0.02310134f, 0.02747446f, 0.03387425f, 
    0.12700447f, 0.10794708f, -0.01629253f, 0.02073636f, -0.05222980f, 0.14090340f, -0.00565730f, 0.05093352f, 
    -0.10155272f, 0.11345436f, 0.11912948f, -0.26958749f, 0.54832774f, -0.02151114f, -0.02050367f, -0.07311858f, 
    -0.04432753f, 0.18168262f, -0.15776105f, 0.19976811f, -0.13716759f, -0.00894497f, -0.33027947f, -0.16233206f, 
    -0.04632460f, 0.09104078f, 0.21954602f, -0.40526327f, -0.18620373f, 0.01501295f, -0.17106079f, 0.06254151f, 
    0.02153967f, 0.24572395f, 0.32779589f, -0.06962994f, -0.01893083f, 0.10736801f, -0.01541229f, -0.19160286f, 
    0.01995563f, 0.02880438f, -0.16372550f, 0.41853857f, -0.27164009f, 0.47776663f, -0.26650488f, 0.14424507f, 
    -0.16965850f, -0.03562923f, -0.10581825f, -0.06437767f, -0.06167910f, -0.00846665f, -0.09580112f, -0.19825862f, 
    0.25248587f, -0.05294670f, 0.04863233f, -0.01695483f, 0.02159984f, -0.00840540f, 0.27893865f, 0.06280991f, 
    0.15330379f, 0.00962419f, 0.02676095f, 0.06259260f, 0.08566920f, 0.05433928f, -0.06830405f, 0.09799463f, 
    -0.16374648f, 0.22386394f, 0.17516793f, -0.22078799f, -0.17757621f, 0.37026709f, -0.10872223f, -0.09007826f, 
    0.09337553f, -0.24720064f, -0.12474678f, 0.28529885f, -0.13279819f, -0.11055508f, -0.32895637f, -0.07681579f, 
    -0.10294330f, 0.05862298f, 0.04967452f, -0.10335686f, -0.19130298f, -0.11385935f, 0.02825621f, 0.03021630f, 
    0.09341352f, 0.00470465f, -0.16604549f, 0.11120474f, -0.09156380f, -0.15770866f, 0.15543447f, -0.14034972f, 
    0.08057862f, 0.08651628f, -0.17851982f, -0.08922385f, -0.14261575f, 0.08995900f, -0.05320333f, -0.13865995f, 
    -0.14904188f, -0.08965560f, -0.14863019f, -0.10223717f, -0.00589365f, 0.08423612f, -0.16602477f, 0.06159959f, 
    0.00933200f, -0.14043269f, 0.23879012f, -0.14933087f, 0.09336996f, -0.05690276f, -0.21536005f, 0.15851386f, 
    -0.43644103f, 0.13603181f, 0.13355303f, 0.16373266f, 0.03029850f, 0.29179066f, -0.02934546f, 0.30570728f, 
    0.07508071f, -0.05060639f, -0.15603250f, 0.04946630f, 0.06847991f, 0.18478094f, -0.12898004f, -0.08762808f, 
    -0.42893592f, 0.03125511f, -0.14623098f, 0.13265218f, -0.02236666f, 0.01291474f, -0.06250488f, 0.25883219f, 
    -0.19921750f, -0.06070836f, -0.03708050f, -0.15065162f, 0.05329915f, -0.15901081f, -0.02495201f, -0.12204836f, 
    -0.11330035f, -0.11140905f, 0.04074003f, -0.05702808f, -0.17930047f, -0.09196603f, -0.11575598f, 0.03176966f, 
    0.00121330f, 0.02049091f, 0.02324158f, -0.10428351f, 0.11701149f, -0.17256169f, 0.00867864f, -0.02340844f, 
    -0.05978258f, 0.04836498f, -0.01237115f, 0.08514018f, -0.05024022f, -0.09463447f, 0.08194648f, 0.13212599f, 
    0.02416423f, 0.15961032f, -0.08677398f, -0.08648773f, -0.14469296f, 0.04861704f, 0.08829216f, 0.00994670f, 
    -0.03582546f, -0.19660841f, -0.10055799f, -0.08332885f, 0.08762300f, -0.14756364f, -0.11748525f, -0.09492508f, 
    0.08611377f, 0.07853807f, 0.07989428f, -0.10336866f, 0.09269003f, 0.19010937f, -0.06465734f, 0.08353111f, 
    -0.14127536f, -0.11459631f, 0.05889065f, 0.13624458f, 0.02086486f, -0.14354022f, -0.06297083f, 0.00044186f, 
    0.20510396f, 0.19813685f, 0.16553770f, 0.12105754f, -0.11908080f, -0.08718105f, -0.45662177f, 0.05727684f, 
    -0.26688051f, -0.04018938f, 0.25747427f, -0.14289771f, 0.07493997f, 0.11627652f, -0.08780503f, -0.08705780f, 
    0.03467120f, -0.32257986f, -0.06196553f, -0.00555071f, 0.04572146f, -0.04629046f, 0.06613933f, -0.10401336f, 
    0.13857856f, -0.04635983f, 0.06002615f, -0.38963887f, -0.00812503f, -0.07369357f, 0.29258043f, 0.35737598f, 
    -0.22985317f, -0.13017388f, 0.14726932f, 0.32041293f, 0.32335204f, -0.02082810f, -0.12526374f, -0.17356881f, 
    0.29017401f, -0.12093522f, 0.02472967f, -0.04538034f, 0.01038552f, 0.04361264f, -0.08948123f, 0.15164810f, 
    -0.08429049f, 0.21329536f, 0.22164850f, -0.07740592f, 0.62788534f, -0.40115789f, -0.07780165f, -0.16183771f, 
    0.34509379f, 0.14779946f, -0.01721273f, 0.02549138f, -0.03697521f, 0.13144541f, -0.08843766f, 0.03083902f, 
    0.20646386f, -0.14415285f, 0.14665703f, -0.29970017f, -0.31522402f, 0.03345482f, 0.09231119f, -0.14669608f, 
    -0.07479157f, -0.11057603f, 0.02158202f, -0.02307977f, 0.27526110f, 0.03494538f, -0.10734349f, -0.03024414f, 
    0.19413325f, -0.10200435f, -0.38458779f, 0.41950166f, -0.06567102f, 0.35731936f, 0.04026321f, 0.17094563f, 
    -0.26633424f, 0.30436957f, 0.14465208f, 0.18954155f, -0.04874766f, 0.07145949f, 0.17379226f, -0.43939754f, 
    0.01459622f, -0.14034925f, -0.11428311f, -0.13987477f, 0.12350002f, 0.04570796f, -0.16348656f, 0.05487703f, 
    0.00476397f, -0.19206515f, -0.02734614f, 0.10470942f, 0.12217203f, -0.12004162f, -0.10177412f, -0.15217589f, 
    0.07603255f, -0.10015734f, 0.12604082f, -0.03534615f, -0.04890245f, -0.11376288f, 0.03905905f, 0.01168431f, 
    0.07333416f, 0.06195734f, 0.06677116f, -0.17047919f, -0.00739182f, -0.13517480f, -0.11403894f, 0.03856320f, 
    0.11736729f, -0.07110307f, 0.10354692f, 0.08798472f, 0.27812499f, 0.01877952f, 0.11567365f, -0.09796199f, 
    -0.07095619f, 0.41687065f, 0.12554701f, 0.16597603f, -0.27351522f, 0.17698999f, 0.16966531f, -0.08565121f, 
    0.27034974f, -0.37390971f, -0.10510703f, -0.05666253f, 0.24472578f, -0.11000721f, -0.11738926f, 0.10406847f, 
    -0.20312050f, 0.30924529f, 0.14624701f, 0.08585691f, 0.17064865f, -0.00916011f, 0.03271278f, -0.26310498f, 
    0.11215516f, -0.05388949f, 0.15245759f, 0.24433868f, -0.23833184f, -0.11688396f, -0.26273286f, 0.11384621f, 
    0.13076951f, -0.24481820f, -0.11711520f, 0.02336448f, 0.21667159f, -0.31433585f, -0.05411446f, -0.03528799f, 
    -0.18908997f, -0.07357196f, -0.17121378f, -0.03657364f, -0.00017183f, -0.17183386f, 0.41942653f, -0.17572671f, 
    -0.04951246f, 0.28425136f, 0.00459898f, 0.11142227f, 0.12618685f, -0.08943837f, 0.44230512f, -0.21489774f, 
    0.19263943f, 0.12128562f, -0.09041507f, 0.42586428f, -0.35981143f, -0.09100122f, -0.24199727f, 0.07187986f, 
    0.01906839f, 0.12223821f, 0.00530996f, 0.12595817f, 0.00558393f, -0.09990926f, 0.07338515f, 0.06137744f, 
    0.08897617f, -0.13416603f, 0.53580934f, -0.08166608f, -0.30822340f, 0.16451186f, 0.13465028f, 0.14137764f, 
    0.30643603f, 0.28631723f, -0.14932925f, -0.29640707f, 0.11507876f, 0.10683640f, 0.40132493f, -0.15685026f, 
    0.12042256f, 0.12244391f, -0.05085230f, 0.03374757f, 0.06163637f, -0.08234088f, 0.01620083f, 0.09922489f, 
    -0.14651737f, -0.07187890f, -0.04910369f, -0.01077885f, -0.16384840f, -0.02561782f, -0.10471234f, 0.00397932f, 
    -0.13227968f, -0.09346415f, 0.02014189f, -0.12622720f, 0.00675384f, 0.11862502f, -0.01147810f, -0.08264809f, 
    -0.15972976f, -0.08121236f, 0.13074605f, 0.06405545f, -0.12087701f, 0.08718231f, -0.01604054f, 0.04729053f, 
    -0.04354735f, -0.08990940f, 0.10386278f, -0.10002045f, -0.17814325f, -0.08653447f, -0.24315396f, 0.16788889f, 
    -0.10965601f, -0.24178715f, 0.23245390f, 0.13923816f, 0.23917392f, -0.35901904f, 0.16465868f, -0.19675136f, 
    0.30129206f, -0.17197642f, -0.01161463f, 0.07822530f, 0.06041857f, 0.18776566f, 0.07170792f, 0.03271842f, 
    0.25091732f, 0.00501517f, -0.01875723f, -0.39383858f, 0.09027705f, 0.13685699f, 0.38355806f, 0.31451187f, 
    -0.13399343f, -0.02962545f, -0.04585273f, -0.15676913f, -0.00311616f, 0.06810261f, 0.00827390f, -0.11945897f, 
    0.06278081f, 0.18483742f, -0.00484560f, -0.12373689f, -0.09731729f, 0.25641599f, 0.08711833f, 0.35422623f, 
    -0.08164436f, 0.53144449f, 0.30714470f, 0.20514342f, -0.15634543f, 0.21027625f, -0.15952608f, 0.03541607f, 
    -0.19261314f, -0.10322444f, 0.15338033f, 0.16156566f, -0.15561421f, -0.01912162f, 0.03631246f, 0.33025125f, 
    0.24277316f, -0.04014571f, -0.02693780f, 0.10684571f, 0.05934437f, -0.12010836f, 0.34880158f, 0.07384115f, 
    0.50994390f, 0.16561113f, -0.05776455f, 0.05724608f, 0.07222487f, -0.03472054f, -0.13904279f, -0.09838833f, 
    0.10557961f, -0.18297303f, -0.08006314f, -0.26377344f, -0.21476837f, 0.06169609f, -0.12611380f, -0.11082534f, 
    0.37959349f, 0.10192695f, 0.15644132f, -0.20382224f, 0.11756583f, -0.09583651f, -0.21091677f, -0.03466220f, 
    0.15553470f, -0.04162154f, 0.20609891f, 0.20748131f, 0.29572469f, -0.00030273f, 0.12793799f, -0.12865122f, 
    -0.33226004f, 0.15026475f, -0.04470288f, -0.02713197f, -0.05221411f, 0.23543714f, 0.12908272f, -0.05764063f, 
    -0.25074613f, -0.11401402f, 0.31345573f, -0.23175502f, 0.70973831f, -0.18775366f, 0.19556585f, 0.07478410f, 
    -0.05735765f, -0.02651027f, -0.07411289f, 0.00933938f, 0.13835727f, 0.08133564f, -0.18700111f, -0.13972746f, 
    0.30289894f, 0.16274630f, 0.02110032f, -0.25727618f, 0.06783522f, -0.06975523f, -0.00959635f, -0.11497875f, 
    -0.22350068f, 0.23293868f, 0.01107182f, 0.11951473f, -0.10523656f, 0.27676237f, 0.04051312f, 0.03536126f, 
    0.01936681f, 0.24732833f, 0.33627483f, 0.08873874f, -0.32329071f, 0.23096535f, -0.23416141f, -0.03345055f, 
    0.10199563f, -0.24508573f, 0.11031511f, -0.15752338f, -0.13922042f, 0.15397583f, 0.11339080f, 0.33053109f, 
    0.20648637f, -0.08949419f, -0.04574521f, 0.46145821f, -0.05204359f, 0.03596408f, 0.10818346f, 0.05112128f, 
    0.11439881f, 0.18993142f, 0.06612238f, 0.11912069f, 0.13679920f, 0.28418192f, -0.09436280f, 0.56266195f, 
    -0.27350602f, 0.13855824f, 0.20791027f, -0.28836283f, 0.37890983f, -0.22189811f, -0.12719202f, -0.03451607f, 
    0.01925619f, 0.11888568f, -0.04932031f, 0.25646821f, -0.03171227f, 0.00928155f, -0.10566770f, -0.26819798f, 
    -0.11542057f, 0.03277114f, -0.17694582f, 0.09415990f, -0.05427687f, 0.14011070f, 0.07306031f, -0.07750230f, 
    0.10075525f, -0.14435349f, 0.06863113f, 0.06114905f, -0.03303734f, 0.06230078f, -0.14428885f, -0.07535784f, 
    0.00348798f, -0.02391058f, -0.15756381f, 0.05406532f, -0.04741623f, -0.16982879f, -0.06800079f, 0.09869809f, 
    -0.05807381f, 0.14700173f, 0.04433659f, -0.05021695f, 0.06058390f, 0.12537688f, 0.09254314f, -0.13610582f, 
    0.01712773f, 0.04663756f, 0.20602331f, 0.21979751f, 0.16895713f, -0.03360143f, -0.23623091f, -0.06042612f, 
    -0.32801661f, 0.12303862f, 0.13326547f, 0.06632277f, 0.14411189f, 0.46121803f, -0.11215200f, 0.48063630f, 
    -0.21296611f, 0.14982130f, 0.00397852f, -0.20394632f, 0.44115561f, 0.18650481f, -0.31112620f, 0.00500303f, 
    -0.20104940f, 0.28390709f, -0.13929982f, -0.00463632f, 0.16071902f, -0.10897013f, -0.31743896f, 0.08207702f, 
    -0.15400811f, -0.16022329f, 0.01237858f, -0.14138612f, 0.06814500f, -0.14429599f, 0.12531504f, -0.13086297f, 
    -0.09769039f, 0.03670765f, -0.14245278f, 0.11008352f, 0.01547388f, 0.03685924f, 0.02892873f, -0.16974363f, 
    0.05209442f, -0.01685425f, -0.17731921f, -0.02886069f, -0.16066267f, -0.11196667f, -0.17467356f, -0.11949405f, 
    0.02159964f, 0.00413604f, -0.05255175f, -0.07473809f, 0.10662959f, -0.15959838f, -0.07462127f, -0.13416561f, 
    -0.11263446f, -0.08239906f, 0.03140266f, 0.07893787f, 0.18880168f, 0.07896764f, -0.15173022f, -0.01362975f, 
    -0.15317950f, -0.06518590f, 0.22902718f, -0.04475067f, -0.15919934f, -0.03240870f, 0.04589173f, -0.45344976f, 
    0.19721210f, -0.08732115f, 0.49687529f, 0.37259388f, 0.40643436f, 0.14967449f, 0.11191730f, 0.01674700f, 
    0.18097356f, -0.18831752f, 0.13142161f, 0.20564921f, -0.12334410f, -0.12342392f, 0.20404883f, -0.05481746f, 
    -0.07388640f, 0.07031886f, 0.20519359f, -0.13882335f, -0.20677495f, 0.09364602f, -0.26170859f, -0.12727623f, 
    0.13698573f, -0.38498393f, 0.16930589f, 0.17165074f, 0.26251954f, 0.13615692f, -0.11782821f, 0.08096289f, 
    -0.21561901f, 0.24853708f, -0.27085784f, 0.23849833f, 0.29698017f, 0.31252667f, 0.35963312f, 0.17852950f, 
    -0.25284597f, -0.11782350f, 0.06925914f, 0.05695538f, -0.10232882f, 0.06154269f, 0.02835341f, -0.20353374f, 
    0.01334304f, -0.10086033f, 0.00822047f, -0.14957462f, -0.05772293f, 0.00768980f, -0.06989614f, -0.07603039f, 
    -0.21387812f, 0.00560571f, -0.09107269f, -0.05792696f, 0.14819077f, 0.31895232f, -0.04168603f, 0.28958824f, 
    -0.33108988f, 0.51285970f, 0.31925690f, 0.12247574f, -0.43134636f, 0.09948121f, 0.14838874f, 0.08632860f, 
    -0.15453094f, -0.08425316f, -0.13419452f, 0.11422650f, 0.01177032f, 0.12787530f, 0.14246592f, 0.10699688f, 
    -0.17140950f, -0.14151105f, -0.12307394f, 0.15036717f, 0.35158387f, 0.17602181f, 0.26073331f, 0.01012413f, 
    0.22168627f, 0.26791140f, -0.17846671f, 0.16610476f, 0.01062326f, -0.22043230f, 0.03784483f, -0.21419996f, 
    -0.02495613f, -0.17307468f, 0.27407932f, -0.14508034f, 0.14533001f, -0.19989374f, 0.27101225f, -0.02606203f, 
    0.51263714f, 0.04564340f, 0.17257954f, 0.18577045f, -0.16368610f, 0.13738851f, 0.11774955f, 0.26449242f, 
    0.19835849f, 0.16401885f, 0.04068249f, -0.13280487f, -0.22172634f, -0.05270059f, -0.16532491f, -0.08204044f, 
    -0.12231755f, -0.13745484f, -0.08638028f, -0.09616948f, 0.22644189f, -0.00944548f, -0.02069884f, -0.08671228f, 
    0.11616082f, -0.00394163f, 0.13291901f, -0.20564687f, -0.32240081f, -0.14886680f, 0.33583918f, 0.02728905f, 
    -0.14406177f, 0.00860124f, 0.11523633f, 0.22249578f, -0.09359419f, 0.01301073f, 0.32774463f, 0.19256209f, 
    -0.12305357f, 0.04874142f, 0.03209331f, 0.04332461f, 0.05850837f, -0.12110585f, -0.19927633f, 0.10856792f, 
    0.07209936f, -0.02541734f, 0.09525690f, -0.12973796f, 0.02603554f, -0.15482889f, -0.09948262f, -0.32311967f, 
    0.34359342f, -0.31176156f, 0.05064300f, 0.28747910f, 0.34181345f, 0.40436783f, -0.02606846f, 0.15630268f, 
    0.44391695f, 0.12842728f, -0.00784996f, -0.20011672f, 0.13682041f, -0.03484031f, 0.26996404f, 0.19315313f, 
    -0.17554165f, -0.05711579f, 0.25525695f, -0.03337779f, -0.10339763f, -0.09804286f, 0.06802300f, 0.14099114f, 
    -0.33247048f, 0.22906567f, -0.03318719f, -0.05350207f, -0.02646387f, 0.09332472f, -0.08775134f, 0.36346483f, 
    -0.42711040f, 0.23001328f, 0.16380997f, -0.32212448f, -0.00631103f, -0.30712798f, -0.10169744f, -0.07046803f, 
    -0.13048144f, 0.08274448f, 0.13904735f, -0.00625692f, -0.10482591f, -0.09566333f, 0.06286491f, 0.37130609f, 
    -0.21787120f, 0.05754025f, 0.14875126f, 0.11731802f, -0.10847919f, -0.10142948f, -0.13792051f, 0.09196337f, 
    -0.11615057f, -0.26294836f, 0.13299115f, 0.07439202f, 0.28214416f, -0.24894148f, 0.04864450f, -0.24066421f, 
    0.23549508f, -0.17897314f, -0.01624214f, 0.03569236f, -0.02405629f, 0.23867294f, -0.08610719f, -0.04669540f, 
    0.37056816f, 0.34700340f, -0.04757338f, -0.17157133f, 0.00572350f, -0.01890568f, 0.18718751f, 0.37207383f, 
    0.21907270f, 0.16791221f, 0.12710829f, -0.03392947f, 0.06199002f, -0.17070183f, -0.01831618f, 0.10356835f, 
    0.08184831f, -0.14147890f, -0.13223854f, 0.11248056f, 0.26825669f, -0.16347030f, 0.09532083f, 0.35543084f, 
    -0.31930608f, 0.00488626f, -0.24603979f, -0.25285155f, 0.10613959f, -0.20018883f, 0.22396439f, 0.12366359f, 
    -0.16552523f, -0.02036579f, -0.10715153f, 0.47420236f, -0.13656974f, -0.08702839f, -0.09690181f, -0.19408223f, 
    -0.00055045f, -0.10460392f, 0.20103526f, 0.32466024f, 0.10567423f, -0.02511299f, -0.20521775f, 0.13025008f, 
    0.15867439f, -0.15617979f, -0.17705557f, 0.01542115f, 0.18112813f, -0.40835947f, 0.01385610f, 0.01291166f, 
    -0.21455167f, 0.19400753f, -0.31294027f, -0.22444201f, 0.18748368f, -0.04308818f, 0.41543654f, -0.12825879f, 
    0.11683787f, 0.23526248f, 0.03137982f, 0.00481626f, -0.15284951f, 0.13447507f, 0.09526309f, 0.20383540f, 
    -0.22579443f, -0.06274691f, 0.26731557f, -0.52686781f, 0.00097439f, -0.15970996f, 0.09506797f, 0.17989913f, 
    -0.05463795f, -0.03404921f, -0.00831168f, -0.09363706f, 0.08235264f, 0.00033604f, 0.06183432f, -0.30274490f, 
    0.13170081f, -0.06428467f, -0.25570852f, 0.23737982f, -0.13186809f, -0.03677048f, 0.12698263f, 0.09730625f, 
    -0.36250097f, 0.15152188f, -0.11062209f, -0.07149811f, -0.04074315f, -0.13494000f, 0.37968814f, 0.06179617f, 
    0.21023387f, -0.05237918f, -0.06977953f, 0.04942380f, 0.05919676f, -0.17033271f, 0.10867584f, 0.06173074f, 
    -0.10489257f, 0.34082618f, 0.33934292f, 0.14765556f, -0.03965356f, 0.42843896f, 0.15403736f, 0.13991719f, 
    0.20399952f, -0.02036387f, -0.29305333f, -0.05344595f, 0.06931311f, 0.21524470f, -0.22213866f, -0.12736090f, 
    -0.07387365f, -0.14030311f, 0.06865435f, -0.02360019f, 0.12302267f, 0.07595263f, 0.09716719f, -0.18663937f, 
    0.04689436f, 0.13071270f, -0.08251453f, -0.07794609f, 0.26630709f, -0.05351432f, 0.01648933f, 0.14816096f, 
    -0.19422269f, -0.18040101f, 0.21779019f, 0.12707663f, 0.03477004f, 0.25884625f, 0.13347359f, -0.04392030f, 
    -0.21657217f, 0.17126381f, 0.23676899f, 0.09060996f, -0.08810286f, -0.30004904f, -0.12125181f, 0.08428776f, 
    0.37854400f, 0.28752097f, -0.07174927f, -0.06207595f, -0.02006156f, 0.01291213f, -0.26252607f, 0.02936193f, 
    -0.13654767f, 0.05271679f, 0.25835720f, -0.10788692f, 0.19639562f, 0.08765228f, 0.02682399f, -0.04592839f, 
    -0.11627518f, 0.12094464f, 0.08523769f, -0.11074060f, 0.06373860f, -0.00267105f, 0.03242991f, -0.37493914f, 
    0.25041890f, -0.36425567f, -0.24286495f, 0.13110156f, 0.13602027f, -0.10652629f, -0.26518983f, -0.11755636f, 
    0.16920583f, -0.00017967f, 0.10543078f, -0.17424420f, 0.05281655f, -0.06114589f, 0.06292832f, 0.38368317f, 
    0.18506303f, 0.02932221f, -0.10527887f, 0.25574577f, 0.10956520f, -0.05624555f, -0.26722059f, -0.08425336f, 
    0.20186204f, -0.13932881f, 0.11344879f, 0.06719588f, 0.27986577f, 0.18300155f, -0.12811892f, 0.56132531f, 
    -0.09116551f, -0.02932186f, 0.21834175f, -0.02092631f, 0.30359206f, 0.22639351f, -0.11676576f, 0.07554571f, 
    0.04095436f, 0.39250663f, 0.07885612f, -0.26350501f, -0.08071096f, -0.07881256f, -0.06743006f, 0.01313966f, 
    0.07131236f, 0.09354966f, -0.03737620f, 0.36982667f, 0.10674483f, -0.16295205f, 0.19939183f, 0.09577769f, 
    0.35781386f, 0.33399215f, 0.02500857f, 0.17298236f, -0.05073419f, 0.18399286f, -0.16223432f, 0.24913293f, 
    0.01660030f, -0.12162165f, -0.12761377f, 0.17078051f, 0.07233797f, 0.14863092f, -0.10211398f, -0.02574174f, 
    0.22004020f, 0.35398501f, -0.10398278f, -0.22452886f, 0.12606782f, 0.13472874f, -0.23133342f, -0.35797870f, 
    -0.23767599f, 0.05292477f, 0.12447622f, 0.29725361f, 0.20774645f, 0.13928086f, -0.27657199f, 0.10985890f, 
    -0.21972638f, 0.20320641f, -0.00555624f, -0.02753646f, -0.09122729f, -0.08004471f, 0.13900936f, -0.21355978f, 
    -0.11581912f, -0.12750691f, 0.48029065f, 0.17465471f, -0.22454734f, 0.02182453f, 0.15148970f, -0.16791171f, 
    0.15771103f, 0.44734085f, 0.14843778f, 0.09433126f, -0.12783237f, 0.10825086f, 0.06518672f, -0.21252893f, 
    0.20606852f, 0.08189606f, 0.19216691f, -0.27341601f, -0.28633270f, 0.02173879f, 0.18534338f, 0.01931915f, 
    0.20107843f, 0.18750782f, 0.18072167f, -0.14556417f, 0.00155917f, -0.11943004f, -0.08675813f, 0.07558040f, 
    0.15858813f, -0.14038190f, -0.38106492f, 0.27471212f, -0.56715947f, 0.50076264f, -0.07739700f, -0.12397663f, 
    -0.17121351f, 0.30478430f, 0.08074465f, 0.01860807f, 0.13307525f, 0.00130969f, -0.08771994f, -0.14961074f, 
    -0.16051544f, -0.16093315f, 0.21228424f, -0.03084736f, -0.25578371f, 0.13856427f, 0.17509271f, -0.04690880f, 
    0.24607785f, -0.12877302f, -0.13076197f, 0.16380687f, 0.12215479f, -0.01687807f, 0.07350793f, -0.07433147f, 
    0.01619933f, 0.27640668f, 0.03961071f, 0.23824191f, -0.53868115f, -0.04537517f, 0.06816482f, 0.10280115f, 
    -0.03469254f, 0.18730786f, -0.15356639f, -0.21664427f, 0.11006499f, -0.12730558f, -0.11026986f, 0.27217290f, 
    0.04322084f, 0.14876756f, -0.03184723f, -0.09358144f, 0.18553366f, 0.13104376f, 0.01786992f, 0.16762361f, 
    0.41113746f, 0.08888373f, 0.19395842f, 0.06503783f, 0.24798554f, -0.10864291f, 0.06967326f, 0.22282021f, 
    0.34731141f, -0.14773028f, -0.48837340f, 0.20029463f, 0.20253780f, -0.50655937f, -0.01534319f, 0.05670181f, 
    0.11380115f, -0.44599491f, 0.04834140f, -0.17126451f, 0.09693056f, -0.07892610f, -0.02187626f, 0.17083482f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18776698f, -0.18660747f, 0.01484547f, -0.04452000f, 0.21712486f, -0.05552531f, 0.09581155f, -0.11781210f, 
    0.20096344f, 0.01439512f, 0.09032270f, -0.21016209f, 0.02461165f, -0.01987748f, -0.14528540f, -0.11216333f, 
    0.07832850f, -0.06393567f, 0.00044058f, -0.05242788f, 0.23144531f, 0.08426741f, 0.16476759f, -0.19554114f, 
    -0.03775379f, 0.10314641f, 0.17871660f, 0.05049776f, 0.18305612f, -0.01475201f, 0.05633814f, 0.16046061f, 
    0.09484823f, -0.14562225f, -0.03780516f, -0.07512704f, 0.17556356f, -0.02932239f, 0.01440995f, 0.00672055f, 
    0.14941917f, 0.14034708f, 0.13023490f, 0.13949160f, 0.09024642f, 0.20634681f, 0.03567624f, 0.00573820f, 
    0.09403244f, 0.03668400f, 0.14180210f, 0.09240286f, 0.12006934f, 0.21882008f, 0.12414039f, 0.17118143f, 
    0.15762612f, -0.01727583f, 0.23434898f, 0.28158605f, -0.02156862f, 0.07165364f, 0.15418650f, -0.13099031f, 
    -0.06551158f, 0.21021293f, 0.00940405f, -0.00371676f, -0.05163659f, -0.13830118f, -0.07599106f, 0.06492681f, 
    -0.16467978f, -0.09873517f, 0.17520635f, 0.07760514f, -0.05627454f, 0.02088305f, -0.04851705f, -0.03194407f, 
    -0.18839544f, -0.05479437f, 0.07025527f, 0.25842589f, 0.11501692f, 0.20632535f, 0.16893262f, 0.09886391f, 
    0.09454428f, 0.06511913f, -0.12918919f, 0.09502802f, -0.08724796f, -0.03522065f, -0.18170869f, -0.10470928f, 
    0.16425887f, -0.07884321f, -0.07893851f, 0.21712035f, -0.04303844f, 0.09431890f, -0.15071520f, 0.10427394f, 
    -0.03212061f, -0.16100171f, -0.12110234f, -0.14249280f, 0.10657266f, 0.27406061f, 0.10173934f, 0.07449240f, 
    -0.15156980f, 0.16075470f, 0.10794473f, 0.22751783f, 0.05633856f, 0.03075083f, -0.00972328f, -0.08574808f, 
    0.01225646f, 0.17213382f, 0.06224230f, -0.17084260f, 0.14907455f, 0.03320169f, 0.10251530f, -0.01282673f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.48939452f, 0.04465839f, 0.40667206f, -0.11764470f, -0.06494716f, 0.10090752f, -0.10089645f, -0.00964126f, 
    0.23089501f, -0.24647546f, -0.08509386f, 0.16471176f, 0.14102291f, -0.11970145f, -0.00491290f, -0.57016826f, 
    -0.30243871f, 0.02700606f, -0.28045151f, -0.34983468f, -0.25144568f, -0.01230725f, -0.03430272f, -0.00699006f, 
    0.05274898f, 0.02706093f, 0.17045230f, 0.15370505f, 0.16827902f, -0.21477279f, -0.16845138f, 0.06488297f, 
    0.05036411f, 0.01734573f, 0.26029599f, 0.16009076f, 0.08095224f, 0.04184033f, -0.28753933f, 0.22878307f, 
    0.08314559f, -0.06634599f, -0.13210061f, 0.13126932f, -0.02679095f, 0.11910465f, -0.27313900f, 0.23267296f, 
    -0.07327611f, -0.02527509f, -0.16315517f, -0.32943723f, 0.02522273f, -0.26962206f, -0.61685687f, -0.19480951f, 
    0.02992285f, -0.07689620f, -0.01821467f, -0.69444239f, -0.17354153f, 0.07732891f, 0.12414727f, 0.05357211f, 
    0.08276167f, -0.38512146f, -0.09391359f, -0.02610286f, -0.43697214f, -0.00371099f, -0.04451995f, 0.17595781f, 
    -0.22476321f, -0.43536875f, -0.00541298f, -0.04933675f, -0.07965687f, -0.33577865f, 0.15863010f, -0.39680126f, 
    -0.27423513f, 0.06053323f, 0.23342611f, 0.00404570f, 0.14216770f, -0.23102504f, 0.14969492f, 0.05026473f, 
    0.17024663f, 0.07148147f, 0.07008026f, -0.05583934f, 0.05103420f, -0.08772459f, -0.08481720f, -0.09501106f, 
    -0.16893892f, -0.46133450f, 0.07390603f, -0.34410548f, 0.09449803f, -0.24497226f, 0.20890266f, 0.06179187f, 
    0.23243932f, -0.02386268f, 0.29621291f, -0.06425729f, -0.27652821f, 0.01725693f, 0.17816746f, -0.17700362f, 
    0.08093088f, -0.40147769f, 0.35603935f, -0.14159837f, 0.18912917f, 0.05365079f, -0.10882293f, 0.08588850f, 
    0.21372959f, -0.09763186f, 0.20783469f, -0.16961840f, -0.22560395f, -0.13630199f, -0.08248414f, -0.05899696f, 
    0.05333630f, 0.03947908f, -0.09916450f, -0.04027721f, 0.02579930f, -0.07453728f, -0.23650758f, -0.15174527f, 
    0.04555519f, 0.22079995f, -0.23083326f, -0.21987750f, -0.73277295f, -0.04354556f, -0.02276385f, 0.12983517f, 
    -0.24630545f, 0.04214671f, -0.34842297f, 0.01432877f, -0.16458504f, 0.00814847f, -0.23238961f, -0.00401957f, 
    0.06599404f, 0.08629981f, -0.45349687f, 0.09133610f, 0.16010238f, -0.04522677f, 0.07645741f, -0.30768856f, 
    0.13089839f, -0.00127382f, 0.21167031f, -0.02649103f, -0.24054119f, 0.08018380f, -0.29672065f, -0.29914790f, 
    -0.01187644f, -0.01295105f, 0.11746850f, 0.20862506f, 0.07199956f, 0.14303280f, 0.16403094f, 0.08624776f, 
    0.03429566f, 0.19832063f, 0.17983709f, -0.31370237f, 0.03074265f, -0.10746825f, -0.15352395f, 0.17245166f, 
    -0.25566301f, 0.12291218f, -0.35791916f, -0.11754502f, 0.16545409f, -0.52340162f, -0.12398410f, 0.09199280f, 
    -0.07893383f, -0.16660118f, -0.27489674f, -0.04696986f, 0.04997299f, 0.05699617f, -0.22752368f, 0.26769671f, 
    -0.25220063f, 0.17303467f, -0.30117750f, -0.04530117f, 0.13135354f, -0.17068799f, 0.20020297f, -0.31333140f, 
    0.28652170f, -0.31077489f, -0.02222772f, -0.29966480f, 0.13432795f, -0.06660837f, -0.14932896f, 0.00759392f, 
    0.02708446f, -0.02883307f, -0.04434900f, 0.02776633f, 0.23248574f, 0.01633166f, -0.02288698f, 0.20409207f, 
    -0.05325320f, -0.25953490f, -0.04989441f, 0.01984454f, -0.26407373f, 0.20683080f, 0.20089866f, -0.26183686f, 
    0.11413514f, 0.06209349f, 0.13178778f, -0.04276027f, 0.25055540f, 0.05771736f, -0.59357065f, 0.08042687f, 
    -0.17704315f, 0.25190297f, -0.41204956f, 0.05189857f, -0.03824151f, -0.01950222f, -0.06468880f, 0.13410296f, 
    0.13437225f, 0.14191490f, 0.20570970f, 0.19017705f, 0.03741495f, -0.20331261f, -0.39960334f, 0.16100639f, 
    -0.35723892f, -0.08472691f, 0.42450997f, 0.17589106f, 0.12007494f, -0.25401369f, 0.12607643f, -0.33834261f, 
    -0.24333854f, 0.07923693f, -0.17291817f, 0.06342912f, -0.01768457f, -0.53202075f, -0.02203786f, -0.12837484f, 
    0.07626597f, -0.03903112f, -0.25914812f, 0.34805250f, -0.38306943f, 0.12889911f, 0.20075358f, -0.40220398f, 
    0.05263955f, -0.41356644f, -0.45518768f, -0.04153294f, -0.04404228f, -0.78828549f, -0.21028733f, -0.10783664f, 
    -0.07130720f, 0.03839610f, -0.24857044f, 0.09501734f, -0.26970798f, -0.37429243f, -0.11690223f, -0.08225593f, 
    -0.12173665f, -0.48715430f, -0.26200259f, -0.32476482f, -0.07575292f, 0.08244577f, -0.31784207f, -0.10443960f, 
    0.06968333f, -0.33475241f, 0.20982631f, 0.25565651f, 0.18022655f, 0.18745691f, 0.22661942f, -0.04474667f, 
    0.16676190f, -0.18215038f, -0.11384153f, 0.15347978f, 0.25041452f, -0.24033311f, -0.01978711f, -0.24881235f, 
    -0.16019244f, 0.28476503f, -0.27019596f, 0.00321898f, 0.24947251f, 0.00546537f, -0.11536662f, -0.10614972f, 
    0.36507544f, 0.30740967f, 0.06448242f, -0.28175375f, 0.18401884f, 0.25804251f, -0.45019582f, -0.25870207f, 
    -0.31807423f, -0.02006876f, 0.11861072f, 0.16894330f, -0.43327975f, -0.05845540f, -0.34167641f, -0.04403913f, 
    -0.00048535f, -0.04775858f, -0.00251228f, 0.25432989f, -0.29061747f, 0.05904279f, 0.03871169f, 0.07987969f, 
    0.21296486f, 0.48574710f, -0.04810852f, 0.15608636f, -0.09648403f, 0.03759228f, 0.02691741f, 0.22276433f, 
    0.01397479f, -0.07699956f, -0.13535838f, 0.05560361f, 0.08162495f, -0.01463961f, 0.08895675f, -0.24607292f, 
    0.18294144f, 0.02311441f, -0.11939181f, -0.16604066f, -0.41849366f, -0.09254243f, 0.05733944f, 0.15120053f, 
    -0.35736814f, -0.11094742f, 0.13092890f, -0.17022428f, -0.09234074f, -0.07970337f, -0.35720208f, 0.00849071f, 
    -0.08632807f, -0.06394095f, -0.18565506f, -0.40928337f, 0.18873200f, -0.06514714f, -0.10327935f, 0.13040698f, 
    -0.09770495f, -0.11463716f, -0.01646204f, -0.04111384f, -0.06184484f, -0.27558666f, 0.05692849f, 0.18017802f, 
    0.09371549f, 0.06315871f, 0.09316521f, 0.04233313f, 0.09760684f, -0.13192619f, 0.03121681f, 0.17228894f, 
    0.07063258f, -0.05972781f, -0.09292158f, -0.25167665f, -0.16015132f, 0.07110170f, 0.13240999f, 0.05049872f, 
    -0.34122112f, 0.02085789f, -0.13696557f, -0.01169384f, -0.03326951f, 0.15679571f, 0.22023234f, 0.11605714f, 
    -0.16468242f, 0.13084176f, -0.21238793f, -0.32316107f, -0.01538832f, -0.05105371f, 0.09059612f, -0.40930140f, 
    -0.27408022f, -0.58147877f, -0.24890529f, 0.24653579f, 0.19572246f, 0.21205032f, 0.26297498f, -0.60511118f, 
    0.05451405f, 0.27849028f, 0.18667941f, 0.07554746f, 0.17658715f, 0.22322501f, 0.04824105f, 0.17881554f, 
    0.27740139f, 0.08762672f, -0.03076996f, -0.00252739f, 0.20868507f, 0.08788165f, -0.15655304f, 0.08683483f, 
    0.07101560f, -0.13108364f, 0.18657142f, 0.12340846f, 0.13867895f, -0.36046386f, -0.01008803f, -0.34662828f, 
    -0.22821955f, -0.09005528f, -0.33531749f, 0.15789469f, 0.06898918f, -0.21968290f, 0.19870214f, 0.03250183f, 
    -0.22531377f, 0.01268102f, 0.03141129f, -0.57605368f, -0.09866882f, -0.17202371f, -0.05336946f, 0.15559667f, 
    -0.35628405f, -0.17683029f, -0.02742624f, -0.24439621f, -0.08175002f, 0.38987184f, 0.02432391f, 0.06645171f, 
    -0.01491381f, 0.03120365f, -0.21113765f, -0.03916606f, -0.20950978f, -0.27196699f, -0.17265379f, 0.20508593f, 
    -0.18322368f, -0.06702906f, -0.44568980f, -0.41514197f, -0.22893900f, -0.01706236f, -0.25810522f, 0.16129418f, 
    -0.15224530f, -0.06212466f, -0.18387587f, 0.30464941f, -0.27177325f, 0.05679843f, -0.07100216f, 0.01733341f, 
    -0.28583512f, -0.04827969f, -0.27433756f, 0.22478573f, -0.04937485f, -0.29812977f, 0.26569459f, -0.04131636f, 
    -0.03926161f, 0.35503340f, 0.02482406f, -0.37202060f, 0.17542614f, -0.01991305f, 0.08028172f, 0.21635455f, 
    0.35711548f, 0.06362025f, 0.01061412f, -0.27116722f, 0.13329732f, 0.05028709f, 0.07716336f, 0.13284940f, 
    -0.01466619f, -0.33290794f, 0.11255994f, -0.15579368f, -0.02373934f, 0.12100056f, -0.08555455f, -0.00062953f, 
    -0.19849811f, -0.01259356f, 0.01471017f, -0.59378159f, -0.39539543f, -0.00657531f, 0.09911601f, 0.23511866f, 
    -0.05070729f, -0.33142203f, -0.26554555f, -0.14038365f, -0.03450299f, -0.20928128f, 0.02126751f, 0.13323925f, 
    -0.18260883f, 0.04869261f, -0.04770263f, -0.17685026f, -0.00965205f, -0.20789160f, -0.14628638f, 0.20830369f, 
    -0.04124276f, 0.28688347f, 0.03731258f, -0.66466349f, -0.37934563f, 0.08269507f, -0.11139525f, -0.12188009f, 
    0.12704918f, 0.21828492f, 0.25647065f, -0.01925406f, 0.04906235f, 0.01998472f, 0.02415960f, 0.26037025f, 
    -0.24233286f, -0.02472476f, 0.11666400f, 0.18944150f, -0.40961310f, -0.11802365f, -0.09511622f, -0.08112912f, 
    -0.42560688f, -0.00593035f, 0.18350151f, -0.13903181f, 0.14533478f, 0.08883324f, -0.08087880f, 0.02934216f, 
    0.11981933f, 0.05513429f, 0.03056198f, -0.28469256f, -0.03964622f, 0.04717115f, 0.07593725f, 0.32609659f, 
    -0.15151177f, 0.01453926f, -0.04158515f, -0.58505583f, 0.06686382f, -0.41629982f, 0.22675429f, -0.01242210f, 
    0.09022214f, -0.02468332f, 0.13599104f, -0.01467589f, 0.04792927f, -0.02655232f, 0.12197107f, -0.19485603f, 
    -0.11485621f, -0.20625223f, 0.24501617f, -0.29718328f, -0.24381065f, -0.11074615f, 0.10321179f, 0.09038303f, 
    -0.26076913f, 0.02776240f, -0.09751386f, 0.11283814f, 0.29694605f, 0.04061541f, 0.00571456f, -0.33586368f, 
    -0.37310895f, 0.02091400f, -0.03936663f, 0.07309593f, -0.06932510f, 0.31140864f, -0.19544849f, -0.41935807f, 
    0.03265871f, -0.59057379f, 0.21972808f, 0.32810608f, -0.32786572f, 0.32628158f, -0.04498537f, -0.17634878f, 
    -0.11200858f, -0.07263707f, 0.20591278f, 0.16340683f, -0.26741076f, 0.05123382f, -0.19410776f, -0.17919131f, 
    -0.00935207f, 0.01994744f, 0.06279932f, 0.03898065f, 0.02845419f, 0.22000524f, -0.07552151f, -0.00474427f, 
    0.03230308f, 0.14481452f, 0.00186222f, -0.35014418f, 0.13504499f, 0.12709995f, -0.00425159f, -0.11343470f, 
    0.19953895f, 0.10042739f, 0.01115974f, 0.27385443f, -0.00103697f, -0.10794237f, 0.00860411f, 0.29669216f, 
    0.25039816f, 0.14146575f, -0.16053055f, 0.04105182f, -0.03821994f, -0.01847751f, -0.38824716f, -0.16547811f, 
    -0.36922121f, -0.25576577f, -0.06625338f, 0.20511706f, -0.06400587f, -0.02531171f, 0.03194742f, -0.31548107f, 
    -0.40307757f, -0.35367605f, -0.13512407f, 0.04928364f, -0.24688751f, 0.06199097f, 0.48536521f, -0.16547969f, 
    0.17151856f, -0.13454434f, -0.55308628f, -0.07790072f, -0.09697611f, 0.05978487f, 0.25241908f, 0.16508527f, 
    0.11846535f, -0.03423432f, -0.28468883f, 0.11164423f, -0.11778899f, -0.09165956f, -0.30644286f, 0.05111714f, 
    -0.00261068f, 0.02514641f, 0.00970854f, 0.13077603f, 0.07852963f, -0.11523557f, 0.01530488f, -0.20484319f, 
    0.03640483f, -0.18384486f, 0.06463289f, 0.20368543f, 0.02809217f, -0.35437962f, -0.09993245f, 0.02346518f, 
    -0.35773981f, -0.02891155f, -0.10759275f, 0.03704891f, 0.12214581f, 0.01867021f, -0.06428366f, 0.31630448f, 
    0.01686120f, 0.15337895f, 0.18242691f, 0.25109875f, -0.38951540f, 0.21713649f, 0.18713725f, -0.16380486f, 
    0.04493748f, 0.26121974f, -0.16542818f, -0.42682993f, -0.01094983f, -0.13048382f, 0.17176931f, 0.09260049f, 
    -0.05059201f, 0.07588218f, -0.26727471f, 0.22793014f, 0.11523178f, 0.02820810f, 0.22050688f, 0.40009680f, 
    0.07276482f, -0.17960189f, 0.22244763f, -0.36062229f, -0.11839334f, 0.17578101f, -0.05399533f, -0.58044910f, 
    0.04824131f, 0.05624887f, 0.16052234f, 0.33677322f, -0.08037816f, 0.13071980f, 0.03631173f, -0.14330620f, 
    0.04768683f, -0.22705036f, 0.12794358f, 0.15192828f, 0.08110105f, -0.38976458f, -0.07421213f, 0.01834559f, 
    -0.07215454f, -0.47278675f, 0.02429796f, 0.16784671f, 0.01691288f, 0.01655158f, 0.37673482f, 0.00791008f, 
    -0.26599252f, 0.20483267f, 0.40605938f, -0.05866085f, -0.00225048f, -0.07033120f, 0.02385297f, -0.47512066f, 
    0.05509977f, -0.10903411f, -0.53215885f, 0.04223965f, 0.12044894f, 0.13318376f, -0.44231299f, 0.11816809f, 
    -0.04355548f, -0.30584592f, 0.07480698f, -0.18384039f, 0.08508850f, 0.29628977f, 0.10578952f, -0.29588878f, 
    0.19389997f, 0.19250934f, 0.25537819f, -0.02229467f, -0.33604684f, 0.01069026f, -0.09252135f, -0.13027301f, 
    -0.27266154f, -0.14829837f, 0.05164961f, -0.33755246f, -0.44117597f, -0.23873042f, 0.05513058f, 0.14632906f, 
    -0.56532842f, -0.14725445f, -0.28799081f, 0.11227050f, -0.32146120f, 0.19870536f, -0.07419011f, -0.04219065f, 
    0.10502460f, 0.05579738f, -0.02726774f, -0.11743768f, -0.28111166f, 0.13832244f, 0.03889675f, 0.15168208f, 
    -0.30079526f, -0.48894942f, -0.01846664f, -0.07678166f, 0.06313656f, 0.36165881f, -0.29255286f, 0.06246646f, 
    -0.25787696f, 0.07306665f, -0.10676385f, -0.05162834f, -0.03099379f, -0.10647251f, -0.08974832f, -0.28842247f, 
    0.03106686f, -0.07374642f, -0.28409886f, -0.09890593f, -0.43105394f, -0.51861769f, 0.15550505f, 0.18885343f, 
    -0.33629766f, 0.14993669f, -0.12657942f, 0.07166056f, -0.22934140f, 0.16500473f, 0.11669783f, 0.19103667f, 
    0.01221410f, -0.04947049f, -0.15650803f, 0.04545559f, -0.14895277f, 0.27025023f, -0.26495299f, -0.03788355f, 
    0.11823800f, -0.09325173f, 0.01179700f, 0.34814796f, 0.11099061f, 0.05004708f, -0.02584266f, 0.14585096f, 
    -0.11261346f, -0.07148945f, -0.07553630f, -0.10956869f, 0.05223665f, -0.22507297f, 0.03361581f, 0.17987150f, 
    -0.00441782f, 0.02736189f, 0.09523735f, -0.35951617f, -0.27024958f, 0.15091008f, -0.10937915f, 0.04049015f, 
    -0.23916651f, 0.11596715f, 0.24753264f, -0.23442030f, 0.19178446f, 0.06137391f, -0.19392064f, 0.15950653f, 
    -0.00211709f, -0.05368552f, -0.10180806f, -0.15308893f, -0.03390413f, -0.30485344f, -0.41193706f, -0.06572179f, 
    -0.08896813f, -0.10217088f, 0.29005274f, -0.10209008f, -0.40599695f, -0.29326922f, 0.16431972f, 0.03341182f, 
    0.13752891f, 0.12494184f, -0.10682394f, -0.41756570f, -0.09664913f, 0.02345154f, -0.16613531f, 0.18171558f, 
    -0.06581037f, -0.17879303f, 0.04552481f, 0.05593100f, 0.00957583f, 0.08137119f, 0.02276360f, -0.13358387f, 
    -0.02646554f, 0.06409751f, -0.23293538f, -0.02485117f, 0.00918080f, 0.13063382f, 0.10994940f, -0.18049131f, 
    0.35522649f, -0.15532875f, 0.02077034f, -0.47402194f, 0.03409239f, -0.62097555f, 0.08126051f, -0.01819872f, 
    -0.24652655f, -0.06907772f, -0.06014804f, 0.14430824f, 0.18419799f, -0.43648759f, 0.00220461f, -0.12013837f, 
    -0.38069335f, 0.34183201f, 0.02702908f, 0.00291949f, 0.12460062f, 0.00377479f, 0.12209649f, 0.09734860f, 
    0.12870270f, -0.07937039f, -0.15305321f, -0.08439832f, 0.25013155f, -0.46877038f, 0.16200367f, 0.24251696f, 
    -0.00150644f, 0.11564733f, -0.22153367f, 0.10780443f, -0.45057046f, -0.19103687f, -0.30534995f, -0.20069249f, 
    0.24909371f, -0.20009467f, -0.00395675f, 0.06681430f, 0.21081959f, -0.53723085f, 0.01294399f, -0.17787054f, 
    0.10656441f, -0.07796486f, -0.37222973f, -0.26863730f, -0.39145240f, 0.05152946f, -0.23119813f, 0.35387939f, 
    -0.47943658f, 0.46084929f, 0.21708694f, -0.54966754f, -0.36463106f, 0.04568382f, -0.08038597f, -0.10186424f, 
    -0.10780963f, 0.06259641f, -0.38487929f, -0.17684163f, 0.23277825f, 0.13312431f, -0.21918951f, 0.21926732f, 
    -0.07272620f, 0.10252693f, 0.20524505f, -0.17145099f, 0.06889101f, -0.12496799f, 0.04692540f, -0.34153575f, 
    0.12844196f, 0.17995067f, 0.03034665f, 0.01379411f, 0.06476202f, -0.17433260f, 0.32186273f, -0.07794625f, 
    -0.11636795f, 0.19595034f, 0.29156086f, 0.03244510f, -0.04575244f, -0.12423246f, 0.14616467f, -0.04086354f, 
    0.15497503f, 0.17642495f, -0.17804928f, -0.28812185f, -0.33136421f, -0.14240053f, -0.18260285f, 0.25519332f, 
    -0.55316800f, 0.02141183f, -0.29017788f, 0.19988488f, -0.37118995f, -0.12928110f, -0.38873750f, -0.17042778f, 
    -0.35980421f, -0.23025346f, -0.38728240f, 0.01868043f, -0.11586031f, 0.02395832f, -0.26898652f, 0.00239543f, 
    0.10818042f, -0.08857870f, -0.41414863f, -0.14064717f, 0.04330127f, 0.31022879f, -0.35693014f, -0.13841113f, 
    -0.07821146f, 0.00976747f, -0.30163085f, -0.07661828f, -0.10514906f, -0.03234932f, -0.29063377f, 0.02366184f, 
    -0.10522760f, 0.00452269f, -0.05182213f, 0.02615791f, 0.00280896f, 0.10947465f, -0.01872492f, -0.00754410f, 
    0.30015385f, 0.44041884f, -0.02144855f, 0.23296213f, -0.28930497f, 0.14067155f, -0.31996784f, -0.36069655f, 
    -0.12111618f, 0.08753854f, -0.09167413f, 0.02814507f, -0.24720666f, 0.02188075f, -0.27220276f, 0.08663122f, 
    0.05110659f, 0.16833785f, -0.11903076f, 0.36867559f, -0.36280850f, 0.31733817f, 0.04067449f, -0.16539501f, 
    -0.19105010f, -0.02104169f, 0.20517585f, 0.18098532f, 0.28346428f, 0.23119740f, 0.27369398f, -0.13638720f, 
    -0.26059422f, 0.01198826f, -0.30798069f, -0.10005086f, 0.05751402f, 0.18832691f, -0.10343197f, -0.61402899f, 
    -0.15163468f, -0.43187967f, -0.15257742f, 0.13245441f, 0.10481327f, -0.08472154f, 0.04648199f, -0.01029542f, 
    -0.25872967f, 0.02093471f, 0.24224651f, -0.47430652f, 0.09441592f, -0.05344908f, 0.24308456f, -0.33202007f, 
    -0.08171039f, -0.08986227f, 0.04766154f, 0.08687417f, -0.00217337f, 0.00808847f, 0.08155639f, 0.11746394f, 
    -0.06980924f, -0.01769342f, -0.24765426f, 0.23858216f, 0.27393475f, -0.43379223f, 0.03959207f, 0.14378910f, 
    0.19943677f, -0.10618810f, -0.30768806f, -0.21739034f, -0.00975800f, 0.19960724f, 0.24717419f, -0.40723136f, 
    -0.10533368f, -0.19183406f, 0.21929550f, 0.46241668f, -0.23023993f, -0.32576752f, -0.24289247f, 0.14788447f, 
    -0.05148349f, -0.20316713f, 0.29484192f, 0.43442503f, -0.37014696f, -0.05538319f, -0.17593138f, -0.21047354f, 
    -0.47053152f, -0.08610160f, 0.20550561f, 0.07775307f, -0.03909573f, 0.02846193f, 0.08293298f, -0.16685864f, 
    -0.12719792f, 0.04652959f, 0.18934670f, 0.17416695f, -0.45612296f, 0.17599633f, -0.10686463f, 0.46023703f, 
    0.16413440f, -0.03286790f, 0.31533295f, 0.24061520f, -0.21146043f, 0.20597556f, 0.10918883f, 0.04241934f, 
    0.07605428f, 0.01949824f, 0.09647432f, -0.08078054f, -0.29319638f, 0.11606534f, 0.06772060f, -0.31962833f, 
    -0.13082118f, 0.06405634f, -0.08417205f, 0.11561427f, 0.11946325f, -0.60597545f, -0.21275099f, 0.16763681f, 
    -0.29385760f, -0.02849384f, 0.04902222f, -0.06142537f, 0.18541354f, 0.22020976f, 0.20813383f, -0.31795627f, 
    -0.00204674f, 0.19046520f, -0.37905669f, 0.15868147f, -0.45289573f, -0.20936938f, 0.06411804f, 0.06091387f, 
    0.34304845f, -0.01239475f, 0.05350797f, -0.14703846f, 0.01876504f, 0.16291949f, 0.06214515f, -0.29120311f, 
    0.04029945f, -0.02285645f, -0.02000330f, -0.37170216f, 0.03114256f, -0.26531559f, -0.06811573f, 0.04950255f, 
    -0.01202892f, -0.00715341f, -0.24238889f, -0.37279183f, -0.00092592f, -0.38971749f, -0.04974072f, 0.16049719f, 
    0.12233976f, -0.07367474f, 0.00537555f, 0.14602821f, 0.30551630f, -0.15181397f, -0.84489161f, -0.12709312f, 
    -0.00694542f, 0.05291940f, -0.03991408f, -0.15557589f, -0.03629883f, 0.03877242f, 0.10986384f, 0.28407314f, 
    0.12554418f, -0.06903433f, -0.39302403f, 0.34004864f, 0.15034665f, 0.10429533f, -0.47564861f, -0.36633527f, 
    -0.02524414f, -0.20024276f, -0.15651536f, 0.12742727f, 0.05752082f, -0.24360773f, -0.11223382f, 0.23688196f, 
    -0.08881819f, 0.06015488f, -0.23569030f, -0.26543796f, 0.02726085f, 0.31549719f, 0.14932473f, -0.42428827f, 
    0.17047715f, -0.08589264f, 0.16888677f, 0.02574043f, -0.37585220f, -0.49550492f, 0.22533377f, -0.01796744f, 
    -0.28911498f, 0.40793020f, -0.00042757f, 0.04288688f, 0.15759861f, 0.07093950f, -0.18260814f, -0.04926673f, 
    0.09706312f, 0.19418335f, 0.02372608f, 0.04254608f, 0.20669217f, -0.29922283f, -0.17624044f, -0.39666390f, 
    0.03199060f, 0.24174435f, -0.01366216f, 0.09133730f, -0.02707011f, -0.39457044f, 0.02908698f, -0.05294181f, 
    -0.08632329f, 0.01038877f, 0.06465236f, -0.37192413f, -0.15286706f, 0.15402535f, 0.02764000f, -0.17407981f, 
    0.34519365f, -0.08188478f, -0.01568389f, -0.08735387f, -0.19067511f, -0.27218148f, 0.04690250f, -0.32704175f, 
    -0.06935715f, -0.05791105f, -0.32928357f, -0.12309796f, 0.04756767f, 0.18434881f, 0.10041581f, 0.04540392f, 
    0.19119906f, -0.31769451f, -0.33683228f, -0.14985031f, 0.40314940f, 0.22399028f, 0.14727473f, -0.22773114f, 
    -0.47543326f, -0.29021186f, -0.37908208f, -0.26139605f, -0.03135107f, -0.05083811f, -0.02295209f, -0.08265039f, 
    0.32756796f, 0.01308896f, -0.32908782f, 0.00581702f, -0.03830161f, -0.34301814f, -0.02304940f, -0.26617205f, 
    -0.20016479f, 0.04153489f, 0.11989053f, -0.20156914f, 0.02617966f, -0.29714638f, 0.00264245f, -0.35943976f, 
    -0.18776272f, 0.02899779f, -0.26393160f, -0.28157550f, 0.07092509f, -0.07685233f, 0.16182232f, -0.05858712f, 
    -0.06603946f, 0.27234575f, 0.30813643f, 0.10564371f, -0.05238821f, -0.15339601f, -0.05564462f, -0.12798318f, 
    -0.16567916f, 0.07002655f, -0.35121214f, -0.32333806f, -0.19727431f, 0.11601753f, -0.30507740f, -0.12980182f, 
    0.05613326f, 0.27595752f, 0.11106718f, -0.23102261f, 0.05886618f, -0.06922357f, 0.07321440f, -0.14116505f, 
    -0.30386209f, -0.41720420f, -0.60478240f, 0.03431395f, -0.21765655f, 0.12974511f, 0.17427632f, -0.27120712f, 
    0.00217598f, -0.24566169f, -0.17563191f, -0.46005425f, 0.32040125f, 0.30587980f, 0.26917350f, -0.01242287f, 
    -0.68766975f, 0.02952141f, -0.07129523f, -0.06073092f, 0.00125354f, -0.02000090f, -0.14937535f, -0.44410434f, 
    0.12292293f, 0.07851961f, 0.31864771f, -0.11018912f, 0.23240930f, 0.33225513f, -0.30895463f, 0.18042728f, 
    -0.15514678f, 0.21345444f, 0.23683356f, 0.16584966f, -0.01601322f, -0.03129735f, 0.04423439f, 0.03648375f, 
    -0.10974140f, -0.08925456f, -0.04248543f, -0.52780908f, 0.11929508f, 0.03980325f, 0.01968201f, -0.43469733f, 
    0.14594860f, -0.08277996f, 0.06586586f, -0.32880154f, 0.21002454f, -0.01557028f, -0.22094297f, -0.09861204f, 
    0.21784833f, -0.00387681f, -0.04079859f, 0.01040824f, -0.27357551f, 0.18887992f, 0.19239616f, -0.20995016f, 
    -0.06988461f, -0.35303542f, -0.17351766f, -0.42552835f, 0.14960469f, 0.09870027f, -0.08123137f, 0.01655729f, 
    -0.24888964f, -0.44521728f, 0.20558603f, 0.13228798f, -0.24801096f, -0.04120088f, 0.15976332f, 0.14278196f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09387036f, 0.10730986f, -0.09465855f, -0.06144618f, 0.00234513f, 0.01630809f, -0.04995508f, -0.12298378f, 
    0.03510461f, -0.01878519f, 0.11144249f, -0.00546461f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
