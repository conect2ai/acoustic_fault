#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.61821210f, -0.82863891f, -0.84780890f, -0.46660644f, 0.46959391f, 0.76275533f, 0.26189917f, 0.02810142f, 
    0.40497190f, -0.63534170f, -0.77985758f, 0.90283686f, 0.83182091f, 0.44455364f, 0.65632004f, -0.11851786f, 
    -0.20950352f, 0.08689807f, -0.67370635f, 0.78634959f, 0.69579566f, -0.91353172f, 0.47329837f, 0.45487306f, 
    -0.24840432f, 0.23807302f, -0.29385614f, 0.24684164f, 0.15317135f, 0.12747544f, -0.65133995f, 1.07836556f, 
    -0.10083604f, 0.16957584f, 0.35065404f, -0.43158942f, 0.05987089f, -0.59395993f, -0.21475525f, -0.40035173f, 
    -1.00792193f, -0.02412104f, -0.26265180f, 0.03194079f, -0.61722940f, -0.53691387f, -0.67139512f, -0.03075111f, 
    -0.45404738f, 0.07142355f, 0.77008468f, -0.23242073f, -0.01758616f, -0.33099201f, 1.16255844f, 1.12695563f, 
    0.18900666f, -0.37807155f, -0.57348537f, -0.26224679f, 0.30154246f, 0.24217214f, 0.18957993f, -1.00667262f, 
    -0.10758770f, 0.77291626f, 0.62064683f, 0.28626323f, -0.80235398f, 0.35197723f, 0.18560275f, -0.34621871f, 
    -0.14130396f, -0.91108871f, -0.60833806f, -0.64649284f, -0.03513093f, -0.80046105f, 0.14991677f, 0.38188392f, 
    0.24903107f, 0.26835755f, 0.88307732f, 0.31588256f, 0.40468240f, 0.41879863f, 0.52232975f, 0.08041149f, 
    -0.31190747f, -0.59597307f, -0.41186622f, -0.82201922f, -0.49820337f, 0.77391618f, 1.05394411f, -0.17609510f, 
    -0.36140150f, -0.26161960f, -0.04391764f, 0.36059722f, -0.56215417f, 0.83096623f, -0.34778485f, 0.77537268f, 
    0.57066453f, 0.25538647f, 0.27128732f, 0.35415599f, -0.08981647f, 1.23408890f, 0.12821040f, -0.07689978f, 
    0.58871108f, -0.14863074f, 0.07586505f, -0.19507375f, 0.41966465f, 0.26731750f, -0.78144115f, -0.41850069f, 
    0.49539980f, 0.52707028f, 0.58057708f, -0.52184153f, 0.37689084f, -0.63507515f, -0.01102500f, -0.13933077f, 
    -0.76372689f, -0.15910836f, -0.89340442f, -0.46388048f, -0.40597618f, 0.43991920f, 0.52948916f, -0.58402276f, 
    -0.05700973f, 0.72227210f, -1.03693128f, -0.58962595f, -0.45761383f, 0.02835263f, -0.09960864f, 0.24092245f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28264603f, 0.21845008f, 0.25732687f, 0.15215434f, 0.34818342f, -0.23162383f, 0.09955402f, -0.10527268f, 
    0.51205945f, -0.03396457f, 0.02560390f, 0.14513172f, 0.15522671f, -0.03790976f, -0.10526210f, 0.16586918f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18739773f, 0.08730973f, -0.37412855f, -0.12850636f, -0.16933338f, 0.12534387f, 0.08369229f, 0.06335850f, 
    0.09951744f, -0.00141635f, 0.02175638f, 0.00057019f, -0.01752990f, 0.00485237f, 0.00506667f, 0.09967007f, 
    0.03890732f, -0.09608365f, -0.06397284f, 0.03971535f, -0.24854951f, 0.24920857f, -0.04165272f, 0.03212845f, 
    -0.24552131f, 0.06954721f, 0.02335603f, 0.05087912f, -0.00850341f, 0.06015200f, -0.06603723f, 0.09991176f, 
    -0.00717594f, 0.09315698f, 0.05452360f, 0.04991809f, 0.06416617f, 0.05926116f, -0.01950936f, -0.00220663f, 
    -0.32825410f, 0.40836301f, 0.04341720f, 0.10194217f, 0.17573750f, -0.01174782f, -0.05123993f, 0.19976753f, 
    0.00630713f, 0.10939878f, 0.13652697f, 0.10062629f, 0.02825429f, -0.00019254f, 0.05298029f, 0.06465090f, 
    -0.07363170f, 0.05521540f, 0.01740803f, -0.04510686f, -0.25222623f, 0.16230924f, 0.19515127f, 0.12906337f, 
    0.35264844f, 0.01846373f, 0.07823045f, 0.03344299f, 0.00969375f, 0.02240715f, 0.12293644f, 0.08211532f, 
    0.00323871f, 0.07632215f, 0.18429627f, -0.03305556f, 0.10365838f, -0.03099979f, 0.07277682f, 0.02261489f, 
    0.15394862f, -0.00552671f, -0.06112773f, 0.23460034f, 0.14743260f, 0.19535618f, -0.02011061f, 0.05692532f, 
    0.04087967f, 0.14427130f, -0.00575376f, -0.02561808f, 0.05492430f, 0.00551542f, 0.06229596f, -0.04965533f, 
    0.11747403f, -0.00018428f, -0.01464203f, 0.14361981f, -0.17678662f, 0.10693514f, -0.13860618f, -0.25362286f, 
    -0.08566662f, -0.01323028f, -0.02827824f, 0.05759392f, 0.08290619f, -0.10312486f, -0.02706645f, 0.00881775f, 
    -0.02748781f, -0.02857547f, -0.09877374f, 0.04016560f, -0.00083411f, -0.09726892f, 0.05431339f, -0.05077728f, 
    0.29811946f, -0.42693627f, 0.25832146f, 0.46239537f, 0.42104530f, -0.27767444f, 0.01405395f, 0.00933035f, 
    0.08633499f, 0.11090112f, 0.09254310f, 0.01118813f, -0.05211060f, 0.15531746f, 0.00837870f, 0.05092919f, 
    0.06533079f, -0.10968704f, -0.01769043f, 0.05850006f, -0.28569704f, 0.26023346f, -0.04629831f, -0.23392455f, 
    -0.19701523f, -0.03014884f, -0.03982230f, -0.08711533f, -0.08952235f, 0.01495385f, -0.12422549f, 0.15101697f, 
    -0.03135309f, -0.02820645f, -0.01683700f, -0.05181328f, 0.07374491f, -0.02581786f, -0.18412551f, -0.05811455f, 
    -0.14705944f, -0.08932369f, -0.04023979f, 0.28354639f, 0.03781535f, 0.17717133f, -0.01212872f, 0.12705272f, 
    0.21462844f, 0.09374881f, 0.02978250f, 0.11446600f, 0.18110032f, 0.06680415f, 0.08245184f, 0.08479976f, 
    -0.04263305f, -0.16343328f, 0.00204794f, 0.08129746f, 0.03956389f, 0.20160103f, 0.13404912f, 0.24887963f, 
    0.22345765f, -0.02308722f, -0.00714963f, 0.04253443f, 0.05191157f, 0.02344564f, -0.08839375f, 0.04138169f, 
    0.10856272f, -0.00231210f, -0.01973328f, 0.06844641f, 0.06032737f, 0.07020646f, 0.22411002f, 0.06741004f, 
    -0.28210884f, 0.17426747f, -0.41148683f, -0.03797876f, -0.25442603f, -0.04852841f, 0.02309930f, 0.03768095f, 
    0.09728581f, -0.13948213f, 0.04588168f, 0.13889816f, 0.14199582f, 0.02786530f, 0.16344780f, 0.04470794f, 
    0.18658479f, -0.00469286f, 0.06127330f, 0.05136726f, -0.38303098f, -0.08814884f, -0.03801881f, -0.00785501f, 
    0.00560389f, -0.03539328f, -0.05429522f, -0.00670225f, 0.10991354f, 0.06019127f, 0.08571450f, -0.04304248f, 
    0.02564269f, -0.01945046f, 0.01380364f, -0.03892865f, -0.00046554f, 0.00352048f, -0.00583505f, 0.00432238f, 
    -0.21012184f, 0.15022799f, 0.04108737f, 0.16878390f, 0.11934131f, -0.00715963f, -0.12861700f, 0.14044721f, 
    0.02028707f, 0.10630606f, 0.12993270f, 0.08802648f, 0.00653300f, 0.09545361f, 0.13656054f, 0.03347129f, 
    0.11715069f, -0.12947366f, 0.10352157f, 0.09022988f, -0.08669668f, -0.00700431f, -0.10848622f, -0.01352784f, 
    -0.08693590f, 0.20561844f, 0.04652512f, 0.01724765f, -0.08330223f, -0.01129187f, 0.05870815f, 0.07372396f, 
    0.10978549f, 0.04976760f, -0.04507457f, 0.13259137f, 0.09663749f, 0.01010150f, 0.08293203f, 0.03673809f, 
    0.33790171f, -0.22828373f, 0.04242451f, 0.17023724f, 0.06423231f, 0.00277899f, 0.17431149f, 0.10067389f, 
    -0.00120477f, -0.02264842f, -0.01971139f, -0.19406505f, -0.00293667f, 0.10777019f, 0.14617847f, -0.12063612f, 
    0.08214079f, -0.11940657f, 0.16794421f, 0.07875491f, -0.22008064f, 0.01857115f, 0.28056958f, 0.18968727f, 
    -0.06893835f, 0.18777730f, 0.10182799f, 0.01694167f, 0.06121149f, 0.16727468f, -0.00268569f, 0.04244576f, 
    -0.00569336f, 0.15976900f, 0.11466109f, 0.06724952f, -0.01348604f, -0.06529375f, 0.03076308f, 0.02426600f, 
    0.50565106f, 0.04412602f, 0.42675549f, 0.19588959f, 0.19643916f, -0.12869747f, 0.07755756f, -0.00493228f, 
    -0.12447659f, 0.07656700f, 0.07193508f, -0.04119060f, 0.00816003f, -0.02396682f, 0.03492522f, 0.00914011f, 
    -0.00521465f, -0.03657533f, -0.06067974f, -0.02200880f, -0.06464256f, 0.03331952f, -0.16583081f, -0.10411406f, 
    0.40583387f, -0.04064453f, 0.11077600f, -0.11872254f, 0.14471826f, 0.07187582f, 0.06155844f, 0.04985442f, 
    -0.00762394f, 0.04821536f, 0.11301570f, 0.03209095f, -0.05382776f, 0.01908281f, -0.05563547f, 0.07917050f, 
    0.08443668f, 0.08353296f, -0.23678972f, -0.23821327f, -0.01870585f, 0.01430163f, 0.11059628f, 0.05546434f, 
    0.01941102f, -0.03800029f, -0.09106453f, 0.07443482f, -0.00363106f, 0.04398166f, 0.01387425f, 0.12961297f, 
    -0.02251653f, 0.06767624f, -0.25730392f, 0.04447139f, 0.43208861f, 0.01009376f, -0.09819399f, 0.03049947f, 
    -0.03844056f, -0.03333311f, 0.07659061f, 0.10565291f, -0.02318339f, 0.05447729f, 0.04462441f, 0.12370528f, 
    0.00555019f, -0.06447809f, -0.08095442f, 0.06203633f, -0.00354333f, 0.07060412f, -0.04095943f, 0.03299955f, 
    -0.08339133f, 0.12265743f, 0.13671020f, -0.13062516f, 0.19802326f, 0.06003593f, 0.10496549f, 0.05302330f, 
    0.11176792f, 0.01067936f, 0.00776577f, 0.10726570f, 0.00623662f, 0.12427124f, -0.11506720f, 0.09946556f, 
    -0.00633665f, -0.10372195f, 0.08157146f, -0.00479791f, 0.03969162f, -0.15135728f, 0.26527736f, 0.06575730f, 
    0.22216898f, -0.00141292f, -0.16933012f, -0.25918660f, -0.06330157f, 0.00579077f, -0.07553098f, 0.04566168f, 
    0.12105858f, 0.11581759f, 0.03272754f, -0.17915630f, 0.10747778f, -0.11293504f, 0.04956206f, -0.01555865f, 
    -0.26583672f, -0.06113195f, -0.13382436f, -0.10043912f, -0.34354326f, 0.26722422f, -0.05136980f, -0.01042620f, 
    -0.10579470f, -0.10861935f, 0.20494756f, 0.13886234f, 0.12016600f, 0.13930982f, -0.04184484f, 0.03845307f, 
    -0.00326100f, -0.02279273f, -0.12544380f, -0.02277198f, 0.20133163f, 0.22916616f, -0.23831020f, -0.02664522f, 
    0.06805313f, 0.03202786f, 0.18886219f, -0.09837939f, 0.05439003f, 0.08276496f, -0.04482549f, -0.18945007f, 
    -0.05600572f, 0.03616339f, -0.01976383f, 0.09295505f, -0.04315884f, -0.05854817f, 0.16210063f, 0.01599068f, 
    0.50524455f, 0.24622464f, 0.08645692f, -0.17810974f, -0.08473384f, 0.04785738f, 0.13772053f, 0.02262980f, 
    0.05185051f, 0.00075684f, 0.08128214f, -0.00539211f, 0.02019559f, -0.08082845f, -0.04585107f, 0.07678074f, 
    -0.04443094f, 0.01017126f, 0.05801209f, -0.08627287f, 0.01240269f, -0.24494454f, -0.21342233f, -0.19995664f, 
    -0.31093961f, 0.15557936f, 0.09015781f, -0.04740101f, 0.05417932f, -0.05474841f, -0.11344311f, -0.05796625f, 
    -0.07249099f, 0.00387001f, 0.00255457f, -0.15225211f, 0.02600726f, 0.08447431f, -0.17498590f, 0.00416389f, 
    0.34970614f, -0.09050862f, 0.34733853f, 0.25449198f, 0.25489163f, -0.08723498f, -0.11455118f, 0.03519616f, 
    0.04977526f, -0.00061970f, -0.20287743f, -0.07703573f, 0.00045083f, -0.01950441f, -0.09915097f, -0.17299271f, 
    -0.06818636f, -0.06312657f, 0.03671607f, 0.09030695f, -0.14904888f, 0.14264838f, -0.11493792f, -0.26857021f, 
    0.33913320f, -0.17147632f, 0.01348950f, 0.08932190f, 0.12993518f, 0.16092269f, -0.03545288f, 0.04589815f, 
    -0.03473732f, -0.07818581f, -0.06251901f, 0.02185442f, 0.01622812f, 0.15527508f, 0.03703619f, 0.00793141f, 
    -0.17307778f, 0.05528813f, -0.36099783f, 0.10465655f, -0.15132023f, 0.18212056f, 0.04706174f, -0.15666303f, 
    0.02508575f, -0.11844744f, 0.07850412f, -0.00833931f, -0.01706884f, 0.00905050f, 0.10445837f, 0.09488144f, 
    0.09783752f, 0.01423809f, -0.01125751f, 0.01562329f, 0.17499465f, -0.09837662f, 0.30462739f, 0.20688742f, 
    0.22773601f, -0.03584545f, -0.02005089f, -0.06186160f, 0.09623777f, 0.15898882f, 0.13235800f, -0.00911826f, 
    -0.03416648f, 0.02267751f, -0.06218408f, -0.04205831f, 0.06536758f, -0.09555759f, 0.11902373f, -0.01718330f, 
    0.00520326f, 0.30050728f, -0.10722965f, -0.15174909f, 0.10588875f, 0.09919575f, 0.03732006f, 0.05259738f, 
    0.03927275f, -0.11042187f, 0.12302180f, 0.13843511f, -0.01560620f, -0.21674733f, -0.09215102f, -0.10769650f, 
    0.10005221f, -0.20150743f, -0.03375427f, 0.03176276f, 0.14364210f, 0.08034274f, 0.00763499f, -0.13745177f, 
    0.09061463f, -0.04071511f, -0.11660291f, -0.01688435f, 0.07369845f, -0.03866895f, 0.03736038f, -0.02258832f, 
    -0.02255373f, 0.03820628f, -0.04649318f, 0.00445949f, -0.04340366f, -0.10933227f, 0.09915376f, -0.08423561f, 
    -0.03187473f, 0.01405272f, 0.02381258f, 0.02586404f, -0.02470651f, -0.05467189f, -0.02712023f, 0.00457360f, 
    0.02991742f, -0.05212662f, -0.01219314f, -0.00330897f, 0.05389205f, 0.00844065f, -0.04466338f, -0.00449847f, 
    -0.02748130f, -0.02201581f, 0.04258705f, 0.04323809f, 0.04304980f, 0.03706088f, 0.04268575f, -0.02679884f, 
    0.04429192f, 0.04268552f, 0.03347510f, -0.05846256f, -0.01237014f, -0.02272808f, -0.02754152f, -0.00954380f, 
    -0.05454510f, -0.03346737f, -0.03524035f, -0.03314774f, -0.03847883f, 0.01226710f, -0.04052912f, 0.02688072f, 
    0.03440334f, -0.00485553f, -0.00387328f, 0.02794178f, 0.00130779f, -0.05067181f, -0.05623027f, 0.01271042f, 
    0.03379514f, -0.01305383f, 0.00341219f, -0.00616050f, -0.03447249f, -0.02307077f, -0.00830222f, 0.02444931f, 
    0.04207420f, 0.04774848f, 0.04105848f, -0.01643421f, -0.03282631f, -0.03623343f, 0.01878663f, 0.02381205f, 
    -0.04835768f, -0.01525230f, -0.01141098f, -0.05057142f, -0.05963164f, 0.01069145f, 0.04330161f, -0.02761705f, 
    0.02021914f, -0.03205658f, 0.00168930f, -0.03853788f, 0.04369273f, 0.03568673f, 0.00249977f, -0.01991251f, 
    -0.04296606f, 0.02695918f, -0.03303926f, 0.00347351f, -0.05914049f, 0.01495183f, 0.03286759f, 0.00978485f, 
    -0.04358172f, 0.00269422f, 0.03542863f, -0.03957910f, 0.01665908f, -0.04441024f, 0.02030169f, 0.04087826f, 
    -0.02421482f, 0.02536850f, -0.02222520f, -0.03600628f, 0.03495750f, 0.00690875f, 0.02353598f, 0.04557640f, 
    0.01217692f, -0.04730698f, -0.03970639f, 0.02589071f, 0.04887936f, -0.05482472f, -0.02072289f, 0.01521751f, 
    0.01288376f, -0.01596070f, -0.05434093f, -0.02602055f, 0.02769624f, -0.04742260f, -0.02287766f, -0.03301593f, 
    0.00853222f, -0.03266367f, -0.00614819f, -0.01799695f, -0.03143822f, 0.04206575f, -0.03978233f, -0.01556383f, 
    0.04913780f, -0.00046774f, 0.01812521f, -0.01933409f, 0.02017358f, -0.00368209f, -0.04547774f, -0.04757959f, 
    -0.01205879f, -0.05782047f, -0.01340629f, 0.03275636f, 0.04504118f, 0.02231350f, 0.02404453f, -0.03020552f, 
    0.00541611f, 0.02780138f, -0.03437556f, -0.05596033f, 0.02250893f, 0.01779901f, -0.01615344f, 0.04765992f, 
    0.04185454f, 0.03206724f, 0.04391567f, 0.04580890f, -0.03820107f, -0.04918285f, -0.00364204f, -0.03236092f, 
    0.04833436f, -0.05899528f, 0.04484493f, -0.04701029f, -0.01268410f, -0.02698469f, -0.02737197f, -0.05247461f, 
    -0.04301833f, -0.05538717f, -0.05372736f, -0.04462337f, -0.04640891f, 0.00759777f, 0.00791006f, -0.02750703f, 
    0.03536185f, 0.01645974f, -0.02568469f, 0.03064219f, -0.04103717f, 0.02771461f, 0.01404542f, -0.03993626f, 
    -0.05306359f, -0.01847443f, 0.00402926f, 0.04086165f, -0.04040231f, 0.04659696f, -0.03664753f, -0.00688701f, 
    0.01564631f, 0.01942419f, 0.00623393f, -0.00031492f, 0.00378295f, 0.01459449f, -0.03740745f, -0.00052651f, 
    0.02895452f, 0.01198897f, -0.02907240f, -0.04223716f, -0.03350570f, 0.01075063f, -0.05197451f, 0.05049716f, 
    -0.01708947f, 0.04072200f, -0.00344758f, 0.02811107f, 0.04445608f, -0.04637700f, -0.02606977f, 0.02503022f, 
    -0.00230892f, -0.04894148f, -0.00305358f, 0.01547486f, 0.03858721f, -0.04563527f, -0.04497725f, 0.04322413f, 
    -0.05254383f, 0.00359797f, -0.04711007f, -0.05635989f, -0.05647323f, -0.02180352f, -0.03916271f, 0.03546835f, 
    0.03073538f, -0.01198715f, -0.00386416f, 0.03173245f, 0.00413289f, 0.04287088f, 0.04501849f, -0.03994279f, 
    0.02815082f, 0.01103965f, -0.04757597f, -0.03256853f, -0.03943986f, 0.00851546f, -0.02229821f, 0.02839885f, 
    0.05156413f, -0.05058051f, 0.02601583f, -0.05083356f, -0.04209315f, -0.02911343f, 0.00937625f, -0.05062916f, 
    -0.02859775f, 0.04497106f, -0.00246294f, 0.01139555f, -0.04447116f, -0.05161726f, -0.01506208f, -0.02584856f, 
    0.01119737f, -0.00731823f, 0.02922485f, -0.02907138f, -0.02966651f, 0.01364823f, 0.04635481f, 0.03999808f, 
    -0.05737928f, 0.01588377f, -0.00885415f, -0.02618841f, 0.01626716f, 0.02874193f, -0.01216094f, -0.03488770f, 
    -0.05759034f, 0.00800404f, 0.00833569f, -0.05122190f, -0.04164584f, 0.03341684f, 0.03879946f, 0.03544194f, 
    -0.03852751f, -0.01777608f, -0.05964357f, 0.00659450f, -0.03151139f, -0.04572295f, -0.00540288f, 0.03314731f, 
    0.03708649f, 0.00100454f, -0.06092179f, -0.04689650f, 0.01084736f, 0.03978972f, -0.01829397f, -0.00309319f, 
    -0.00345701f, 0.02306823f, -0.03203408f, 0.02270442f, 0.05290336f, -0.01729910f, 0.05113370f, 0.00963353f, 
    -0.02443128f, -0.00475205f, -0.01074470f, -0.01287365f, -0.02112511f, 0.03202727f, -0.04666237f, 0.05107231f, 
    -0.37911540f, -0.21388020f, -0.03586653f, -0.16450441f, 0.09385708f, 0.02515757f, 0.01364759f, 0.02307565f, 
    0.11049005f, -0.16130090f, 0.03511912f, 0.13404667f, -0.03724886f, -0.11822841f, -0.13244303f, -0.02223985f, 
    0.03754549f, 0.01513890f, -0.00399770f, -0.04087686f, -0.16652521f, -0.10158151f, -0.18852128f, 0.11711478f, 
    0.05464290f, 0.01637232f, 0.01662671f, -0.03668042f, -0.00416078f, 0.13315082f, 0.05564477f, -0.04983638f, 
    0.03748094f, 0.10618497f, -0.16039041f, -0.02307942f, -0.07232790f, 0.07378096f, -0.05457382f, 0.04558454f, 
    0.48412931f, -0.32515162f, -0.07832707f, 0.05678899f, -0.10972278f, -0.13435608f, -0.13251179f, -0.10505632f, 
    0.02574227f, 0.03158057f, 0.06723539f, 0.15556052f, 0.01520522f, 0.03716983f, 0.06975650f, -0.15824430f, 
    0.02484299f, 0.15724292f, -0.02676025f, -0.02689550f, 0.24984294f, -0.42206219f, 0.08656747f, -0.08042160f, 
    -0.10378667f, 0.02436080f, 0.07522318f, 0.14879088f, 0.04960997f, -0.01265907f, -0.07061970f, 0.03477661f, 
    0.02298842f, -0.18302208f, 0.09643033f, 0.11499635f, 0.00444981f, 0.19391471f, 0.06492258f, 0.08383213f, 
    0.01534691f, 0.07862410f, -0.13891457f, 0.08584032f, 0.34541905f, 0.20062396f, -0.03592905f, -0.02886494f, 
    -0.09514538f, -0.01533478f, 0.01838396f, 0.03225364f, 0.03197636f, -0.02258447f, 0.04252280f, -0.00476948f, 
    -0.09773304f, -0.08205019f, -0.15889332f, -0.02579276f, 0.17948441f, 0.11705678f, -0.18704619f, -0.03921483f, 
    0.16046439f, 0.06641893f, 0.20182258f, 0.14344239f, -0.00779574f, 0.10970397f, -0.10717178f, -0.04155618f, 
    -0.07537667f, -0.10603008f, -0.16569068f, -0.03457647f, -0.00647904f, 0.07446246f, -0.01616637f, 0.07859062f, 
    -0.63407516f, 0.30308244f, 0.27362469f, 0.00169845f, -0.39760235f, 0.04993534f, -0.10789011f, -0.00014437f, 
    -0.03821054f, 0.08319705f, -0.07940547f, -0.08670392f, 0.07440022f, 0.17306390f, 0.07167725f, 0.06136917f, 
    0.05636885f, -0.04433766f, -0.00333193f, 0.09016644f, -0.07409897f, 0.41594896f, 0.12369268f, 0.06990489f, 
    0.12648663f, 0.01902753f, 0.11782752f, -0.00865275f, -0.16592704f, -0.04357136f, 0.00855725f, 0.02766897f, 
    -0.01672814f, -0.04606408f, 0.08586331f, 0.00262193f, 0.05235817f, 0.19607645f, 0.06642610f, -0.13800822f, 
    -0.10829603f, -0.04335213f, 0.02853276f, 0.02851225f, 0.23828545f, -0.04783598f, 0.00305731f, 0.06743316f, 
    0.04051332f, 0.12111811f, -0.04690718f, 0.10499486f, 0.10720876f, 0.01825373f, -0.10945202f, -0.06841405f, 
    0.11691229f, -0.13170506f, 0.07324670f, 0.07030343f, 0.07308660f, 0.09202324f, -0.04054932f, -0.23621780f, 
    -0.58955830f, 0.15128826f, -0.01058418f, -0.10235237f, -0.10119775f, -0.11182818f, 0.08300348f, -0.05097278f, 
    -0.06262630f, 0.09479154f, 0.17622395f, 0.08225916f, -0.05554711f, 0.15215421f, -0.04434626f, 0.01204359f, 
    -0.01647726f, 0.23138772f, 0.07451795f, -0.20002595f, 0.28753600f, 0.08511399f, 0.16969293f, 0.09208661f, 
    -0.00080061f, -0.07698163f, 0.10696890f, -0.01413467f, 0.12655707f, -0.04798506f, -0.07074852f, 0.06680055f, 
    0.17253192f, -0.04490949f, -0.01240300f, 0.07265868f, 0.17061941f, -0.09956209f, 0.06605831f, 0.02361820f, 
    0.02826174f, 0.00286498f, 0.08167472f, 0.05022583f, 0.02536665f, 0.16818722f, 0.06194482f, 0.06735262f, 
    0.00315939f, 0.04018798f, -0.02657637f, 0.01109667f, -0.03136751f, 0.12055567f, 0.02202484f, 0.11713342f, 
    -0.42771745f, -0.00172061f, 0.14277042f, 0.08577812f, -0.41722655f, 0.01786468f, -0.01865768f, -0.03666950f, 
    -0.00993747f, 0.09131004f, 0.04040305f, 0.05954017f, -0.06899699f, -0.16284873f, 0.06099006f, -0.02568333f, 
    -0.05528656f, -0.01414259f, 0.13601764f, -0.06760278f, -0.17643251f, 0.09356909f, 0.19847022f, -0.03699391f, 
    0.26377156f, -0.08963586f, 0.11937287f, 0.00576113f, 0.05509198f, 0.06356371f, 0.04948165f, -0.00162535f, 
    -0.12871963f, -0.03798218f, 0.03768502f, -0.11826883f, -0.03446765f, -0.00498346f, 0.03869015f, -0.16009250f, 
    0.02731284f, 0.00740171f, 0.05866540f, 0.04006734f, 0.06747885f, -0.09798971f, 0.07913382f, -0.01948465f, 
    -0.12925431f, -0.02869853f, -0.06012142f, 0.18550780f, 0.14515592f, -0.01012733f, -0.08403104f, -0.10568910f, 
    0.03751493f, -0.01755056f, 0.00699810f, -0.05778319f, 0.67997772f, -0.04663129f, -0.02632543f, 0.00846087f, 
    0.30441958f, 0.03967508f, -0.11107136f, -0.07762453f, 0.11590083f, 0.00888291f, 0.00208636f, 0.00737269f, 
    0.05811424f, 0.16328241f, 0.04695496f, 0.01356728f, -0.02150320f, -0.04832003f, -0.08348827f, 0.03551815f, 
    -0.42793754f, -0.03429639f, 0.11741634f, -0.09817266f, 0.07623240f, 0.04252514f, -0.08856604f, 0.04272199f, 
    -0.03602984f, -0.06670363f, 0.02705639f, 0.04805172f, -0.01525909f, -0.03533648f, -0.04887751f, -0.00605013f, 
    0.01066121f, 0.00491689f, -0.05695546f, -0.05872196f, -0.26393887f, -0.05215586f, -0.07024229f, -0.04620900f, 
    0.09367477f, -0.00812845f, 0.02909899f, -0.14150436f, 0.05857947f, -0.15447173f, -0.01705456f, -0.07557764f, 
    0.02271874f, 0.04099670f, -0.11302792f, 0.03003640f, -0.06202063f, 0.02145089f, -0.00733123f, -0.00887766f, 
    0.00902750f, 0.30155417f, 0.01509827f, 0.02575381f, 0.05212679f, -0.07801718f, -0.09260000f, -0.01231791f, 
    0.07149449f, -0.10652159f, 0.03562187f, 0.07716808f, -0.03908771f, 0.05734949f, 0.14416206f, -0.01296364f, 
    0.01125828f, -0.00641022f, 0.06872923f, -0.02262985f, 0.00051155f, 0.24646677f, -0.01867260f, -0.07930116f, 
    0.00659671f, -0.02290984f, -0.01594553f, 0.13115789f, -0.05018093f, -0.05644770f, -0.00199374f, 0.00526640f, 
    0.05312514f, -0.08552737f, 0.00605123f, -0.03770512f, 0.06677493f, -0.05726927f, 0.07128370f, -0.05364593f, 
    0.01834305f, 0.06795449f, -0.19744983f, -0.00982461f, 0.26825857f, 0.03090024f, -0.02931497f, -0.05366891f, 
    -0.01587442f, 0.04310416f, 0.07156045f, 0.14543030f, -0.03685173f, 0.06869141f, 0.12026376f, -0.06051721f, 
    0.00111454f, 0.13373768f, 0.12123767f, 0.11210483f, -0.29359156f, 0.19485395f, 0.20020515f, -0.24374479f, 
    0.25876531f, -0.04093927f, 0.05003757f, 0.07797433f, -0.03455658f, 0.11044748f, -0.08783531f, -0.07993473f, 
    -0.01023666f, -0.04827936f, 0.02654612f, 0.02867725f, 0.05588455f, 0.09206175f, -0.02869132f, -0.13311724f, 
    0.34177780f, -0.04308305f, -0.34484971f, 0.35715654f, 0.12950817f, 0.03116325f, 0.15872601f, -0.04777459f, 
    -0.01074586f, 0.07734721f, 0.16143420f, 0.07987475f, 0.04061893f, 0.04119840f, 0.19718345f, -0.05267025f, 
    -0.00009867f, -0.06649598f, 0.00974471f, 0.08769108f, 0.24673577f, 0.28477371f, 0.14613226f, -0.22234777f, 
    -0.10632750f, -0.00479493f, -0.06255816f, -0.04191505f, 0.02223027f, -0.15604462f, 0.04179424f, 0.01630075f, 
    -0.07891382f, 0.01829521f, 0.12397125f, -0.00889829f, 0.09882054f, -0.09615476f, -0.10718895f, -0.00599982f, 
    -0.37589440f, 0.41515425f, -0.04913414f, -0.08095198f, 0.10102981f, 0.01683946f, -0.06316803f, -0.05751272f, 
    0.09803900f, -0.15136427f, 0.09079725f, 0.01400485f, 0.18383135f, 0.02509487f, 0.04182013f, -0.06208922f, 
    -0.08877006f, -0.02758156f, 0.00169807f, -0.00851122f, 0.14257456f, -0.13480046f, -0.22418474f, 0.05133376f, 
    -0.29424053f, 0.09459121f, 0.05425116f, 0.00968004f, -0.02184765f, -0.00880108f, 0.08395202f, -0.02574926f, 
    0.11913337f, 0.02291913f, -0.09939092f, -0.08777089f, 0.00974072f, -0.02236965f, 0.13808754f, 0.02454348f, 
    -0.35999331f, -0.00403580f, -0.05520171f, 0.02310299f, 0.08754407f, 0.03747023f, -0.07170607f, 0.25412193f, 
    0.01422249f, 0.06273051f, 0.00511966f, -0.11997952f, 0.04184950f, -0.06906118f, 0.08479774f, -0.04258054f, 
    0.01577165f, 0.01663279f, 0.11723412f, 0.08374223f, -0.23592304f, 0.16582137f, 0.00169681f, -0.17203405f, 
    0.21345563f, -0.05773317f, 0.06409995f, 0.05058838f, 0.09363008f, 0.14676560f, 0.01238823f, -0.01245091f, 
    0.07522549f, -0.05496490f, 0.05700337f, 0.03871126f, 0.06418177f, 0.05144009f, -0.05499659f, -0.06479239f, 
    -0.16411068f, 0.20347607f, -0.13900007f, 0.35359856f, -0.20600334f, 0.10522802f, -0.03191252f, 0.09071618f, 
    0.09771700f, 0.01413380f, 0.14900698f, 0.09511422f, -0.01363369f, 0.01214493f, -0.06448478f, 0.00599630f, 
    0.01138396f, -0.14191230f, 0.22552580f, 0.07696339f, -0.50490785f, 0.13167980f, -0.00627585f, 0.09061493f, 
    0.06643564f, 0.04531554f, -0.04921236f, 0.04370877f, -0.14858688f, 0.05532469f, -0.05178156f, 0.00815762f, 
    0.04683814f, -0.02309066f, 0.05413081f, 0.03159762f, -0.09973843f, 0.01611506f, -0.01632658f, -0.14093797f, 
    0.22714840f, 0.24398306f, -0.17828996f, 0.10872235f, -0.22327682f, -0.15885982f, 0.03624828f, -0.07738125f, 
    0.06406575f, 0.02179264f, 0.14611843f, 0.08553812f, 0.06722477f, 0.08847038f, -0.00364939f, 0.03645033f, 
    0.09198057f, -0.02779507f, -0.00291762f, 0.06096712f, -0.18610451f, 0.01167106f, 0.23386106f, 0.18054187f, 
    0.26696169f, -0.04053086f, -0.02210942f, -0.00025590f, -0.00649649f, -0.04581569f, 0.03098262f, -0.07438923f, 
    -0.00026768f, 0.05154190f, 0.09583288f, 0.04387258f, 0.03790841f, 0.05121288f, -0.11091819f, 0.09622194f, 
    0.30409583f, 0.27247903f, -0.11343349f, 0.33632207f, 0.17241165f, 0.08679470f, 0.08894838f, -0.04595816f, 
    0.08683188f, 0.07649242f, -0.04262774f, 0.01344305f, -0.02718169f, -0.14329170f, -0.04845710f, 0.06175499f, 
    0.03564492f, 0.01539565f, 0.09312224f, -0.10546014f, 0.00999302f, 0.29509979f, -0.24897797f, -0.21978630f, 
    0.10684640f, 0.15616216f, -0.04133860f, -0.04553594f, -0.00942456f, 0.07012340f, 0.01310680f, -0.02756085f, 
    -0.06227335f, 0.11929382f, 0.01966058f, 0.06540739f, -0.10283182f, -0.07965099f, 0.00357551f, -0.04691579f, 
    0.55533278f, -0.09002060f, 0.05043563f, -0.01052335f, -0.24747448f, -0.12853295f, -0.02512072f, 0.13716505f, 
    -0.05810381f, -0.09967561f, 0.04064466f, -0.02013317f, -0.02338531f, 0.00301970f, -0.03049034f, -0.06181830f, 
    0.02098339f, 0.02786474f, -0.21013510f, -0.01450814f, -0.06035506f, 0.06083231f, 0.25097781f, -0.05258377f, 
    -0.08746395f, -0.00121639f, -0.05473096f, -0.06473535f, -0.10059549f, -0.08734898f, 0.18053716f, 0.01085341f, 
    0.04820651f, 0.01003178f, -0.14473325f, -0.00133297f, -0.09181388f, -0.06904916f, -0.05468853f, -0.06754326f, 
    -0.04008562f, 0.03832256f, -0.15261276f, 0.09199373f, 0.06386077f, -0.10508505f, 0.09921463f, -0.07198047f, 
    0.01687192f, 0.09927940f, -0.04650602f, 0.15783265f, 0.19336027f, 0.05290965f, -0.02200739f, 0.02730032f, 
    0.04215980f, 0.13139811f, -0.01568027f, 0.02115961f, 0.16470182f, 0.29678813f, -0.08986456f, 0.19208036f, 
    0.22322781f, -0.10788234f, -0.08438224f, 0.04157445f, 0.04531490f, 0.01773372f, -0.01537606f, -0.10334431f, 
    0.14983132f, 0.08250493f, -0.03236608f, 0.05523467f, 0.07281987f, -0.08104414f, 0.02227242f, -0.12169295f, 
    0.34947884f, -0.17973354f, 0.30967838f, 0.03831775f, -0.20725462f, -0.13476881f, -0.13771002f, 0.02086503f, 
    -0.20018293f, 0.02826357f, -0.11409509f, -0.03384228f, -0.01613359f, -0.10067891f, 0.09152471f, -0.09608369f, 
    0.03741474f, -0.03863421f, -0.10060948f, 0.09646584f, 0.13233759f, 0.39918816f, -0.13428819f, -0.42934358f, 
    0.07311834f, -0.12890978f, 0.01479794f, -0.10057332f, -0.14465560f, -0.04726528f, -0.11176982f, -0.27808726f, 
    -0.06591360f, -0.05890172f, -0.03860715f, 0.01999452f, 0.14861788f, -0.18866779f, 0.11391212f, -0.06918184f, 
    -0.07440151f, 0.04581315f, -0.05140475f, 0.27891055f, 0.13737671f, 0.12454537f, 0.06999229f, 0.00321580f, 
    0.02295014f, 0.01837511f, -0.01182901f, 0.08313818f, 0.04217690f, 0.06518168f, -0.01753801f, -0.03185234f, 
    -0.12271170f, 0.04892739f, -0.06011106f, -0.10824261f, 0.39136523f, -0.11597908f, -0.07863861f, -0.05855465f, 
    0.09541942f, 0.05205876f, 0.16255501f, 0.10227351f, 0.10174812f, 0.10684719f, -0.02082929f, 0.07399179f, 
    0.11704642f, -0.06032883f, -0.13246591f, -0.01901714f, -0.02301055f, 0.03355442f, -0.10395437f, 0.01824314f, 
    -0.47708306f, -0.04918265f, 0.10595030f, 0.27217361f, 0.25504521f, 0.11540371f, 0.03566231f, -0.05880825f, 
    0.04015775f, 0.16158611f, 0.00638498f, -0.02848817f, -0.01880134f, 0.06039936f, 0.00927462f, 0.03842974f, 
    -0.06103331f, 0.12985399f, 0.09036835f, 0.00558334f, -0.38008985f, 0.18706951f, 0.03916207f, -0.17246923f, 
    -0.17237234f, -0.03676632f, -0.03146034f, 0.00007255f, -0.00945274f, 0.11176560f, -0.06748132f, -0.06713833f, 
    -0.01090723f, -0.01171587f, -0.02030589f, 0.10620200f, -0.04869665f, -0.00402613f, 0.06145019f, -0.11159933f, 
    0.32029682f, -0.06076339f, 0.11927886f, 0.06757527f, -0.20853662f, 0.11866715f, 0.12953298f, 0.16380240f, 
    -0.00559943f, -0.05633959f, 0.00142931f, 0.07132895f, -0.05269651f, 0.11723099f, -0.06291530f, -0.03822923f, 
    0.03819061f, -0.20771721f, -0.09918490f, -0.00382846f, -0.26694500f, 0.14589831f, 0.12200797f, 0.30274290f, 
    0.03668407f, 0.18171504f, 0.00213878f, -0.03707854f, -0.17148067f, 0.04304534f, 0.04559476f, 0.16162527f, 
    0.06916085f, 0.08043278f, -0.08774766f, 0.11661805f, -0.02969646f, -0.06155370f, 0.00799371f, -0.06546959f, 
    -0.33395672f, 0.27276155f, -0.02745852f, 0.16498759f, -0.05467366f, -0.00657431f, 0.01483172f, 0.00797716f, 
    0.09860532f, 0.06061966f, 0.19021331f, 0.01565380f, 0.01876159f, -0.12175208f, 0.06410977f, -0.17360386f, 
    -0.01500617f, -0.08092384f, 0.04926172f, 0.04693556f, -0.17653303f, -0.40157604f, 0.09139246f, 0.05464927f, 
    0.05320362f, 0.05351253f, 0.08954613f, -0.03334970f, -0.12801531f, 0.00399759f, 0.14858410f, -0.00414559f, 
    0.08407659f, 0.05260639f, 0.07252557f, -0.08527615f, 0.10166867f, -0.00439811f, -0.05632433f, -0.01801173f, 
    -0.03859050f, 0.02337502f, -0.04462672f, 0.02534274f, 0.04989767f, 0.01460845f, -0.05266196f, 0.01619071f, 
    0.02713498f, -0.04280043f, -0.02864594f, -0.02762574f, -0.00011619f, -0.03411049f, 0.04509008f, -0.00071224f, 
    0.02137582f, -0.03568358f, 0.01621465f, 0.00237200f, 0.04535918f, -0.05374395f, -0.01856338f, 0.02966671f, 
    0.03914942f, -0.01681694f, -0.06132238f, -0.04159833f, 0.00529934f, -0.05701131f, -0.03806993f, -0.04205032f, 
    -0.05616030f, 0.02631512f, 0.04392450f, 0.01119695f, -0.03486674f, 0.00838307f, -0.05035190f, 0.00563816f, 
    0.00397109f, -0.03839453f, -0.02383625f, -0.03224248f, 0.01684694f, -0.05428923f, 0.04377412f, -0.03158797f, 
    -0.01000154f, 0.04082475f, -0.00792776f, 0.00395258f, 0.00535575f, -0.04447601f, 0.02235736f, 0.01432111f, 
    0.01355709f, -0.01320558f, 0.04354680f, 0.02869201f, 0.00521118f, 0.01082475f, -0.03028675f, 0.01982409f, 
    -0.00146493f, 0.03326271f, 0.03514449f, 0.02578738f, 0.01461091f, -0.03989276f, -0.03498604f, 0.04086896f, 
    -0.01547351f, -0.02673886f, 0.02852542f, 0.02446436f, 0.03104996f, -0.05297026f, -0.05739253f, -0.03615192f, 
    0.01977949f, -0.00922373f, -0.02674811f, -0.03438411f, -0.05523557f, 0.01895871f, -0.04013081f, -0.02478808f, 
    -0.05564371f, 0.00324313f, -0.03872219f, -0.00705378f, -0.05270191f, 0.03100537f, 0.00273212f, 0.01792609f, 
    -0.00595538f, 0.04212939f, -0.00278352f, -0.05190510f, 0.04051599f, -0.05140333f, -0.02915181f, -0.01164843f, 
    0.01030266f, -0.00423437f, -0.00680878f, 0.00579843f, -0.02903954f, 0.04377206f, -0.01190747f, 0.04225010f, 
    -0.01079983f, 0.04511024f, -0.05706295f, -0.05020919f, 0.00791031f, -0.02179831f, -0.05231577f, -0.03381272f, 
    -0.03637518f, 0.03174788f, 0.03157078f, -0.03116449f, 0.03668925f, -0.06250259f, 0.04266774f, -0.04264735f, 
    -0.04600726f, -0.05519663f, 0.02420079f, -0.01456342f, 0.02988114f, -0.00077129f, 0.02958924f, -0.04454579f, 
    -0.04232964f, 0.02418584f, -0.00819884f, 0.04432152f, 0.02972770f, -0.04375032f, 0.03344408f, -0.05895592f, 
    -0.04180996f, 0.03223576f, 0.00230122f, 0.01138894f, 0.01816423f, -0.00153788f, -0.01303323f, -0.02209976f, 
    0.04168808f, -0.02674852f, -0.02768765f, -0.01398832f, -0.02433288f, -0.05305059f, -0.00647872f, -0.03712828f, 
    0.00721455f, -0.03289310f, 0.04702156f, 0.00516135f, 0.02892155f, -0.00539697f, -0.05449732f, -0.02669035f, 
    -0.05111586f, -0.02313015f, -0.03611030f, 0.01849368f, -0.00933265f, -0.01628910f, -0.05136766f, -0.03849424f, 
    -0.02247609f, -0.04749185f, -0.01461300f, -0.02061918f, -0.05516432f, -0.00936518f, -0.05145300f, -0.05543370f, 
    0.00283589f, -0.03827248f, -0.03384281f, 0.04668026f, -0.04748308f, -0.03922923f, 0.00903461f, 0.00666799f, 
    -0.01714527f, -0.00798304f, -0.02318299f, 0.02229332f, 0.04332703f, 0.03685860f, -0.05221992f, 0.02908099f, 
    0.01380480f, 0.05267957f, 0.03881227f, 0.01502719f, -0.03723869f, 0.02323911f, -0.02582601f, 0.00788694f, 
    -0.02731134f, -0.02183601f, -0.01475991f, 0.02930524f, 0.04050028f, -0.04159346f, -0.02953805f, 0.04698455f, 
    0.04232364f, -0.00350878f, 0.01580657f, -0.05681277f, -0.04394400f, -0.01947179f, -0.05809284f, 0.00911728f, 
    -0.01145183f, -0.05526578f, 0.04454034f, 0.04879936f, 0.01290828f, -0.04267368f, -0.02453722f, -0.04089591f, 
    -0.03733882f, -0.01344090f, -0.05872473f, 0.04195194f, -0.06240073f, -0.01546625f, -0.00432552f, -0.05343151f, 
    0.02966096f, -0.02965098f, -0.02024034f, 0.04115697f, -0.01811389f, -0.00947895f, -0.02259323f, -0.05762495f, 
    -0.06143102f, -0.02002946f, 0.02499064f, -0.05159337f, -0.01618485f, 0.03751450f, 0.02914894f, -0.00377858f, 
    0.00212582f, -0.04346672f, 0.00895747f, 0.04802998f, 0.04798194f, 0.01621495f, 0.00734316f, 0.03886893f, 
    0.03705518f, -0.05819733f, 0.04897074f, 0.00884141f, -0.04281734f, -0.04218281f, -0.02326396f, 0.00489236f, 
    -0.05921078f, 0.01559096f, 0.03719329f, -0.04214347f, 0.02482769f, -0.01820993f, -0.04713532f, 0.01961789f, 
    0.02800623f, 0.01634229f, 0.04802556f, 0.00012507f, -0.04922866f, 0.01287928f, 0.04596228f, -0.04061770f, 
    -0.01722489f, 0.04197563f, -0.02127166f, 0.00161533f, -0.05610704f, 0.04920685f, -0.04429540f, -0.03290682f, 
    0.00807179f, 0.02752813f, -0.05345478f, -0.05047564f, 0.00091505f, -0.02622595f, 0.01363666f, 0.01675728f, 
    0.05022435f, -0.00128957f, 0.01244362f, 0.04066211f, -0.03517237f, 0.02119220f, -0.05729549f, -0.05992304f, 
    -0.04218338f, -0.00034359f, 0.02481129f, 0.00520117f, 0.02664780f, -0.04412401f, -0.03425680f, -0.03856068f, 
    0.00895814f, 0.19996172f, 0.15594229f, -0.14030930f, -0.07859183f, -0.10153800f, -0.00927768f, 0.07922491f, 
    -0.19484048f, 0.03840489f, 0.03472481f, -0.12383106f, 0.08505375f, 0.09130032f, -0.04322902f, -0.03545826f, 
    -0.05174428f, -0.01212107f, 0.02286232f, -0.09133945f, -0.58896226f, -0.09355948f, 0.11568391f, -0.04462420f, 
    0.09919204f, -0.15137792f, 0.18818122f, -0.01022655f, 0.25007468f, -0.05259637f, -0.08532041f, -0.00193263f, 
    -0.00607097f, -0.06683254f, 0.07197703f, 0.00589485f, -0.03176768f, 0.00457889f, -0.09823289f, 0.08380204f, 
    -0.29297471f, 0.56543183f, -0.28721589f, -0.21466263f, 0.10357578f, -0.03415382f, -0.03619512f, 0.04584865f, 
    0.06130919f, -0.02591885f, -0.01428598f, -0.03928021f, -0.00160579f, 0.08311769f, -0.04488173f, 0.04303726f, 
    -0.05308170f, -0.07307895f, 0.05447068f, 0.06349207f, 0.44690487f, 0.49189091f, -0.06845614f, -0.05554807f, 
    0.10648601f, 0.04096280f, 0.01285955f, 0.15085764f, -0.05807878f, 0.04519391f, 0.01408220f, 0.04067802f, 
    0.03732304f, 0.06253142f, 0.07194616f, 0.04804178f, 0.08421658f, -0.12770098f, -0.10719121f, -0.10426306f, 
    0.06921400f, 0.18262596f, -0.12478674f, -0.10289959f, 0.28681645f, 0.11288944f, -0.03128713f, 0.08389597f, 
    0.02282591f, -0.08367027f, 0.04245140f, -0.01662375f, -0.04043860f, 0.05751258f, -0.00118083f, 0.07900622f, 
    -0.00340599f, 0.16544487f, 0.16144454f, 0.01919051f, -0.29615229f, 0.34938687f, 0.17811614f, -0.02767291f, 
    0.01484024f, -0.02494928f, -0.14528808f, -0.07825960f, 0.02784162f, -0.03897803f, -0.01972578f, -0.01216224f, 
    0.10459051f, -0.00934809f, -0.02515553f, 0.05089688f, -0.06864309f, 0.03550341f, 0.04568139f, -0.15121582f, 
    0.67269206f, 0.42267659f, -0.40877995f, 0.05928323f, 0.36363932f, 0.15452184f, 0.14906020f, 0.06960630f, 
    0.22889075f, 0.01066945f, 0.19910760f, 0.22175451f, 0.01849872f, 0.09047572f, 0.02790583f, 0.02530932f, 
    -0.04665042f, 0.06042534f, -0.00441272f, 0.11792161f, 0.58318156f, -0.15339740f, 0.18347120f, 0.26357505f, 
    -0.03729476f, -0.10667475f, 0.04251392f, 0.03966804f, 0.12712798f, -0.07091743f, -0.02519646f, 0.05562012f, 
    -0.05852651f, 0.02881683f, 0.00248415f, -0.05856049f, -0.04438798f, -0.00933463f, -0.00027179f, 0.09272207f, 
    0.17236471f, 0.14322485f, -0.11850055f, -0.37400106f, -0.06053580f, 0.07709672f, -0.09309695f, -0.00868421f, 
    0.10199490f, 0.02608906f, 0.11937696f, -0.05043870f, 0.14744402f, -0.06734116f, -0.01621435f, 0.05992329f, 
    0.02934539f, 0.11548876f, 0.07391750f, -0.02301328f, -0.08595060f, -0.18856022f, -0.13127096f, -0.07982775f, 
    -0.33151746f, 0.10014005f, -0.08367866f, 0.03210701f, 0.04825268f, 0.05312050f, -0.03908652f, 0.02767946f, 
    0.15773411f, 0.08354307f, -0.01234755f, -0.07519405f, -0.00004434f, -0.06860879f, -0.00825687f, -0.04295214f, 
    0.54514289f, -0.15975641f, 0.28362250f, -0.19847620f, 0.02924474f, -0.19473907f, 0.09542805f, 0.13877326f, 
    0.07775352f, -0.08665182f, -0.05763500f, -0.02470279f, 0.04111210f, 0.07544360f, -0.00444213f, 0.05713172f, 
    0.04243108f, 0.01659455f, -0.06325053f, 0.11483926f, -0.00615700f, 0.35854831f, -0.19911654f, -0.06165077f, 
    0.39141136f, -0.07363181f, 0.04821883f, 0.04613536f, 0.15364458f, 0.16044267f, 0.14771473f, -0.01124368f, 
    0.08510780f, -0.14433555f, -0.00823631f, -0.07587518f, 0.01510844f, -0.04643577f, -0.15073688f, -0.19295059f, 
    -0.00818410f, 0.39058071f, -0.24547102f, 0.08208626f, -0.11740106f, -0.09413341f, -0.02282795f, 0.05108168f, 
    0.10971805f, 0.07073736f, 0.06871051f, -0.02776560f, -0.02867069f, -0.03355142f, 0.20696355f, 0.01261112f, 
    -0.10077965f, -0.07788271f, 0.06148580f, -0.04289261f, 0.14318830f, -0.19798589f, -0.04256178f, -0.08709793f, 
    0.00950161f, -0.04499914f, -0.00737369f, -0.09055829f, 0.05949907f, -0.00710077f, -0.06195296f, 0.10357336f, 
    0.05726412f, -0.03810833f, -0.14230977f, 0.01766059f, 0.09848338f, -0.11613131f, -0.18907885f, 0.01109715f, 
    0.26002938f, 0.12787654f, -0.17221677f, -0.15395717f, 0.02899570f, 0.11969398f, -0.01514438f, -0.03627329f, 
    0.03281829f, -0.06082866f, -0.00673383f, 0.19051662f, 0.07470821f, 0.05836642f, -0.03003772f, 0.13333786f, 
    0.01523570f, 0.13368814f, -0.00596906f, -0.16049114f, -0.14805016f, 0.15473990f, -0.06915960f, 0.11711731f, 
    0.14383003f, -0.03713053f, 0.03332242f, 0.08929665f, -0.03597313f, -0.05759744f, -0.07007721f, -0.03710584f, 
    -0.03180576f, 0.02595890f, -0.07347890f, -0.00686909f, 0.12815200f, -0.06326506f, 0.19354171f, 0.03470939f, 
    0.23683283f, 0.28167662f, -0.13941851f, 0.20225613f, -0.04945067f, 0.00088260f, -0.03042632f, -0.03700847f, 
    0.03039530f, 0.03231034f, -0.12609144f, -0.01223645f, -0.04907203f, -0.01985646f, 0.02581700f, 0.04194900f, 
    0.08287816f, -0.01513684f, -0.02910739f, -0.07851350f, -0.24335399f, 0.39132658f, -0.15035680f, -0.09042680f, 
    0.01333233f, 0.15144199f, 0.13813466f, 0.03418111f, 0.14802130f, 0.03300834f, -0.00004512f, 0.03266502f, 
    -0.06005170f, 0.09329660f, 0.08340769f, 0.07637229f, -0.05306920f, 0.01680351f, -0.02759536f, 0.01375090f, 
    -0.25815839f, 0.28181878f, -0.05157082f, -0.07269926f, 0.08905340f, -0.09249590f, 0.04406283f, -0.04046197f, 
    0.04942065f, 0.05218739f, 0.03918364f, 0.06761608f, 0.04032652f, -0.02821232f, 0.08463135f, 0.12192285f, 
    -0.03368688f, 0.03577645f, -0.03344311f, 0.08900216f, -0.20802787f, 0.05827795f, -0.02476631f, 0.03027998f, 
    0.08557528f, -0.01201708f, 0.09528631f, 0.07161201f, -0.03914155f, 0.17325462f, 0.10665556f, 0.01083748f, 
    -0.10698536f, 0.01541054f, 0.07889470f, 0.04067556f, 0.01556881f, -0.07918406f, -0.02371456f, -0.02889761f, 
    0.22081906f, -0.22293259f, -0.01957286f, 0.20347764f, 0.08927886f, -0.00421403f, -0.06756012f, 0.08313914f, 
    -0.02527364f, 0.07561634f, -0.00920796f, 0.12124825f, 0.12226161f, 0.07140022f, 0.11101740f, 0.10907378f, 
    0.09296990f, -0.01934336f, 0.04317014f, 0.05103263f, -0.25152552f, 0.09835802f, -0.17192242f, -0.07516479f, 
    -0.04084358f, -0.18809652f, -0.05091424f, -0.14444987f, 0.10790639f, -0.06491638f, -0.04896950f, 0.02580815f, 
    0.01103914f, -0.10886567f, -0.16731220f, -0.11157341f, 0.16078469f, -0.20393150f, -0.00311043f, -0.02677674f, 
    0.25736988f, -0.38449579f, 0.14255492f, 0.00055964f, 0.14714876f, 0.17217866f, 0.01406999f, -0.07261860f, 
    -0.01668833f, 0.05398913f, 0.25825775f, 0.10609693f, -0.00005448f, 0.16949257f, 0.11950891f, 0.05708528f, 
    -0.05196869f, -0.05946505f, -0.19047946f, 0.06252027f, -0.40472555f, 0.31672263f, -0.16860871f, -0.21718979f, 
    -0.02685948f, -0.02311474f, -0.13642126f, -0.05895485f, -0.05404546f, 0.06728285f, -0.11173285f, -0.04668923f, 
    -0.00403211f, 0.02922618f, -0.08312546f, 0.03445575f, 0.09204923f, -0.11148079f, -0.05040343f, -0.06165855f, 
    0.04628433f, -0.15381551f, -0.11254594f, 0.28478545f, -0.02756070f, 0.08652397f, -0.12887621f, -0.01083754f, 
    0.15189897f, 0.03342769f, 0.05406463f, 0.11214124f, -0.00866591f, -0.03020296f, 0.05798762f, 0.23201330f, 
    0.02436688f, -0.06076022f, 0.04722480f, 0.08200055f, -0.01495236f, -0.21506909f, -0.05437709f, -0.26266849f, 
    -0.01396127f, 0.15550803f, 0.15885819f, -0.05457824f, -0.07822382f, 0.04194115f, -0.04517861f, 0.08501191f, 
    -0.08076914f, -0.06527811f, 0.09713280f, -0.12880716f, 0.13565150f, 0.00813203f, -0.03762312f, 0.05908805f, 
    0.01953577f, 0.06980680f, -0.28304425f, 0.32172525f, -0.24857067f, 0.02028160f, -0.12225603f, 0.16691178f, 
    -0.00093150f, -0.00670919f, -0.08977916f, -0.09431154f, -0.00649941f, -0.03991362f, -0.07406351f, -0.12365349f, 
    0.02085747f, 0.10489602f, 0.00543004f, 0.01484650f, -0.51028341f, 0.01860032f, -0.21425159f, -0.26245841f, 
    0.11653508f, 0.02945199f, 0.01815887f, 0.06522092f, 0.09849591f, 0.19733822f, 0.00223206f, 0.12487555f, 
    -0.08620598f, 0.02900131f, 0.04133265f, -0.03102438f, 0.02733853f, 0.15871106f, 0.02544155f, 0.07089639f, 
    -0.11547272f, -0.16182716f, -0.22141236f, -0.19497280f, 0.13361995f, 0.07880523f, -0.01366006f, -0.07935794f, 
    -0.01867291f, 0.12417249f, 0.06416024f, -0.00924609f, 0.03894591f, 0.12651877f, 0.16457374f, 0.04068237f, 
    0.12112069f, -0.01690367f, -0.09350705f, 0.08685467f, -0.00745048f, 0.04081245f, -0.07579394f, 0.27083585f, 
    -0.10478411f, 0.18115681f, 0.03196239f, -0.02678650f, -0.11431935f, 0.10479701f, 0.00608293f, 0.03072694f, 
    0.11632828f, 0.11138584f, -0.19354983f, 0.05591857f, 0.11198779f, -0.10782081f, 0.16838554f, 0.16173884f, 
    0.19294153f, -0.08535978f, -0.02968415f, 0.22986989f, 0.17452878f, -0.15700109f, -0.02390015f, 0.18456483f, 
    0.01941522f, -0.07066463f, 0.07622059f, -0.08199548f, 0.03183057f, 0.05817814f, 0.00166588f, -0.07408804f, 
    0.19244520f, -0.10275584f, 0.00529151f, 0.14608608f, -0.22340250f, 0.14606272f, 0.12300750f, 0.06023036f, 
    0.13088535f, -0.05670691f, -0.04051648f, 0.01389649f, 0.20772517f, 0.09932867f, 0.04695301f, 0.07360380f, 
    -0.03257134f, 0.18500414f, 0.02110920f, -0.03428912f, 0.07657874f, -0.13523148f, -0.07571983f, 0.11873300f, 
    -0.03171361f, 0.01122584f, 0.00686460f, -0.05931722f, 0.03760906f, -0.02997142f, -0.02368805f, -0.02273233f, 
    -0.03380325f, -0.00753775f, -0.02351850f, -0.04887110f, -0.02109790f, -0.00092594f, -0.01224818f, -0.06286242f, 
    -0.04027255f, -0.02726065f, 0.04066398f, 0.04230088f, -0.00914591f, 0.03784363f, -0.06295710f, -0.02260719f, 
    -0.03456629f, -0.02183923f, 0.03644964f, 0.00237968f, -0.04335333f, -0.00737565f, -0.05542376f, 0.04591023f, 
    0.01869606f, 0.00554783f, -0.06265017f, -0.04824860f, -0.04691098f, -0.01964646f, -0.05422536f, 0.00441356f, 
    -0.04227632f, 0.02167407f, -0.01315418f, 0.01183312f, -0.02607195f, -0.04027279f, 0.02968687f, 0.04134778f, 
    -0.05020257f, -0.04215816f, 0.04088565f, -0.02370308f, 0.01296279f, 0.04126388f, 0.04172784f, -0.03546046f, 
    -0.04257834f, -0.04828094f, -0.00468247f, 0.03914484f, -0.05924050f, 0.01055603f, -0.03487534f, -0.00356062f, 
    0.03542885f, 0.00758785f, 0.00471119f, -0.05883968f, -0.04086616f, -0.03648977f, -0.05494602f, 0.00154625f, 
    -0.04569589f, -0.04827050f, -0.01361276f, -0.03286974f, -0.00053850f, -0.05800259f, -0.05288401f, -0.04395745f, 
    0.00111370f, -0.06186677f, 0.00110965f, -0.00206831f, 0.02792981f, 0.02677811f, 0.04023142f, 0.02388289f, 
    -0.01879598f, -0.00962133f, -0.03080458f, 0.01684797f, -0.00186205f, -0.02753493f, -0.05948017f, -0.00081699f, 
    0.00870962f, 0.00919681f, -0.00044406f, 0.02934192f, 0.00075238f, -0.04543326f, 0.01633460f, -0.05629416f, 
    -0.01188411f, 0.00403957f, -0.05163760f, -0.01456055f, -0.05521148f, 0.01461120f, -0.01013465f, 0.03460399f, 
    -0.04881245f, -0.02554125f, 0.03803626f, -0.01047483f, -0.01094154f, -0.05549384f, 0.01939186f, -0.05982778f, 
    0.03847023f, 0.02136035f, 0.04181738f, -0.02558308f, 0.03952215f, 0.03164482f, -0.05453046f, -0.02028920f, 
    -0.04862860f, 0.02905917f, 0.01650450f, -0.04033329f, 0.02316233f, 0.03163064f, -0.01348235f, -0.01516468f, 
    0.04784427f, 0.00093046f, 0.01117598f, 0.04360504f, -0.02598592f, 0.02056373f, -0.03431603f, -0.03280004f, 
    -0.00508328f, 0.03766193f, -0.03939528f, -0.05722466f, -0.04945633f, -0.03584695f, 0.01674489f, 0.01763525f, 
    0.00941775f, 0.04034441f, -0.05014563f, -0.01958052f, -0.00066798f, 0.01663098f, 0.04513165f, -0.01668591f, 
    -0.01211543f, -0.01734470f, 0.00467216f, 0.02613977f, 0.00319404f, 0.01094300f, -0.03403221f, 0.01101006f, 
    0.01802780f, 0.01452886f, 0.03996432f, 0.03384424f, -0.05048260f, -0.03926440f, -0.04766401f, 0.03508889f, 
    -0.01904522f, 0.03702834f, -0.03925297f, -0.02588283f, 0.01906406f, -0.03756484f, -0.04715181f, -0.01280845f, 
    -0.01035622f, -0.03773385f, 0.04304651f, 0.04886644f, 0.01507305f, 0.04110339f, -0.03883741f, -0.03597102f, 
    -0.03741645f, 0.03693096f, -0.03179681f, -0.02269525f, -0.05665213f, -0.05296122f, -0.02188461f, -0.01544966f, 
    -0.06210352f, -0.05021604f, -0.00002093f, 0.03001726f, -0.01124722f, -0.01887709f, -0.03028628f, -0.00471525f, 
    -0.05410494f, 0.03811815f, -0.00654845f, -0.02632663f, -0.01047635f, 0.00139171f, -0.02206988f, -0.03402773f, 
    -0.05146227f, 0.04190005f, -0.05279582f, -0.04806747f, 0.02387956f, -0.01330281f, -0.02571559f, -0.02530986f, 
    0.02170994f, -0.02905767f, -0.01790162f, 0.04473357f, -0.05319265f, -0.05381170f, -0.04444832f, 0.00438322f, 
    -0.01929483f, 0.01230510f, 0.02877403f, 0.03300162f, 0.00241008f, -0.03905111f, -0.01480291f, 0.03930977f, 
    -0.02217047f, 0.01659893f, -0.02654993f, 0.04636272f, -0.03487407f, 0.03054877f, -0.01447254f, 0.01527962f, 
    -0.05514600f, 0.01651825f, -0.01814155f, 0.03898401f, -0.04121246f, 0.04636828f, -0.03750470f, 0.01441958f, 
    0.02043845f, 0.00295557f, -0.04691354f, -0.01629761f, 0.02879836f, 0.04401062f, 0.04368528f, 0.01470922f, 
    -0.04415596f, -0.01371893f, -0.01254096f, -0.06167915f, -0.02429605f, -0.02452509f, -0.04555861f, -0.05562793f, 
    -0.01433620f, -0.04092525f, -0.01753625f, -0.02273765f, 0.03474647f, -0.01882110f, -0.05540873f, -0.05926374f, 
    -0.01164792f, -0.04675855f, -0.05440298f, -0.01196234f, 0.03176247f, -0.04095774f, -0.06296922f, 0.02082797f, 
    0.03133754f, -0.04121284f, -0.00973737f, -0.04297381f, 0.00838791f, -0.02799319f, -0.05874780f, 0.00488879f, 
    0.02791278f, -0.02549556f, 0.00575624f, -0.04267428f, -0.03260965f, -0.04057974f, -0.05196162f, -0.00570107f, 
    -0.00199751f, 0.01608496f, 0.01799884f, 0.02749673f, 0.04758339f, -0.01108616f, 0.01012532f, -0.03463382f, 
    -0.05492652f, -0.00479832f, 0.04082553f, -0.04381914f, -0.03035989f, -0.01240086f, -0.04567127f, 0.02172673f, 
    0.37779829f, 0.09491256f, -0.04275353f, 0.08954833f, -0.16487074f, 0.01334832f, 0.04285354f, -0.06616645f, 
    0.12738377f, 0.07787911f, -0.01546565f, 0.09656756f, 0.03575492f, 0.10096876f, 0.19724531f, 0.01509737f, 
    0.05739027f, 0.11326290f, 0.06092276f, 0.04915316f, 0.50477546f, 0.14355172f, 0.27442795f, -0.02317685f, 
    -0.00789491f, 0.04724496f, -0.08003990f, 0.14656691f, 0.15009673f, -0.01580075f, 0.09491837f, 0.11414348f, 
    -0.01247793f, 0.01403996f, 0.00159453f, 0.04793224f, 0.18054725f, -0.08688173f, -0.01411851f, 0.00847242f, 
    -0.04173223f, -0.30038854f, 0.21275017f, 0.14597110f, 0.16200235f, 0.15869941f, 0.07860627f, -0.13366613f, 
    -0.04949246f, 0.02099322f, -0.00069262f, 0.02458876f, 0.03757195f, 0.08939248f, 0.05059763f, 0.20760578f, 
    0.13868435f, -0.07259975f, 0.12441531f, 0.13246712f, -0.15999511f, -0.04742808f, 0.00683845f, 0.05972039f, 
    -0.06330353f, 0.02462552f, 0.13546887f, -0.05533411f, 0.10816590f, 0.18521652f, -0.07224295f, 0.01851403f, 
    0.03772141f, 0.05716658f, 0.12397972f, 0.08192026f, 0.10656212f, 0.04050650f, 0.06917901f, 0.14394498f, 
    0.34346551f, -0.12065660f, 0.19836158f, 0.34099236f, -0.09223895f, -0.04072264f, 0.06763414f, 0.14247330f, 
    -0.03712987f, 0.00742939f, -0.01537310f, 0.05700274f, -0.02667803f, -0.04913166f, 0.11516000f, 0.20305814f, 
    0.13635540f, -0.06620266f, 0.05728657f, 0.01432431f, 0.47983384f, -0.20993447f, -0.01393541f, 0.32682142f, 
    -0.10009772f, -0.05160712f, 0.13312273f, 0.02811373f, 0.11116856f, -0.02583682f, 0.00422148f, 0.16946048f, 
    0.05728242f, 0.08640154f, 0.05290416f, 0.15366201f, 0.14468773f, -0.02127257f, 0.08348616f, 0.22875334f, 
    -0.43536839f, -0.03524280f, 0.13472190f, -0.39650691f, 0.15223137f, 0.03180685f, 0.07324035f, -0.06545161f, 
    0.15482810f, -0.03113393f, -0.04943354f, 0.03789584f, -0.06685508f, -0.05554549f, -0.06087597f, 0.08932801f, 
    0.01285181f, 0.10214977f, 0.08427205f, -0.03957594f, -0.00610803f, 0.16107039f, 0.18302712f, 0.31258297f, 
    0.16925485f, 0.17406902f, 0.01939853f, 0.11249652f, 0.13067968f, 0.17644097f, 0.00718736f, 0.22007707f, 
    0.19229524f, 0.02504595f, 0.02732047f, 0.07002009f, -0.01106191f, 0.02243352f, 0.06563435f, 0.03154868f, 
    0.30737096f, -0.21824557f, -0.04604525f, 0.04841524f, 0.02753336f, -0.10612279f, 0.11948401f, 0.09477570f, 
    -0.06229602f, 0.09836894f, 0.03197183f, 0.00447681f, -0.15724599f, -0.01679878f, -0.02391362f, -0.01463000f, 
    0.19184476f, 0.18091488f, 0.19244441f, 0.14199959f, -0.26823753f, -0.04726458f, 0.07363513f, -0.25700834f, 
    0.11500447f, -0.05033171f, -0.01271759f, -0.02136066f, -0.01051623f, -0.01625682f, 0.08636837f, 0.07609929f, 
    -0.04699298f, -0.03590753f, 0.18611450f, 0.14874569f, 0.10404965f, -0.15568070f, -0.06957375f, 0.12352294f, 
    0.28851959f, 0.27929279f, 0.09441205f, 0.06163608f, -0.11981661f, -0.02442881f, -0.04265617f, 0.06938190f, 
    0.10106919f, 0.10742377f, 0.06697359f, 0.06349486f, 0.02699838f, 0.09855347f, 0.01555515f, -0.02415887f, 
    0.13590409f, 0.11723473f, -0.06046532f, 0.01576990f, 0.28373015f, -0.11041111f, -0.13444585f, 0.17199576f, 
    -0.19794607f, 0.07830933f, 0.11599475f, 0.08526710f, -0.05075273f, -0.12073396f, -0.04133792f, 0.12366165f, 
    -0.01474517f, 0.14118677f, 0.11645571f, -0.10736345f, 0.12679362f, -0.03741018f, -0.02898575f, 0.12672207f, 
    0.11931991f, -0.35351205f, 0.14069663f, -0.39804563f, 0.11441945f, 0.01197687f, 0.12074173f, -0.15123238f, 
    0.03739088f, -0.07065378f, -0.01567703f, -0.03306241f, -0.05098895f, 0.04902810f, 0.07232358f, 0.09731635f, 
    0.03329733f, 0.24190266f, -0.07842387f, 0.07207121f, 0.38321429f, 0.11831865f, -0.05186271f, -0.04476264f, 
    -0.13118826f, -0.03114302f, 0.08733637f, 0.16359986f, 0.15976495f, 0.07758412f, 0.06757723f, -0.02687010f, 
    0.15135604f, 0.05221517f, -0.00407492f, 0.10598457f, 0.11950806f, 0.09743295f, 0.05176024f, 0.12718530f, 
    0.34418619f, -0.02077423f, 0.01727790f, 0.14559838f, 0.24774151f, 0.08912664f, 0.03717628f, 0.02302831f, 
    -0.03096768f, 0.17330480f, -0.00866992f, 0.07123454f, -0.06282439f, -0.00944724f, 0.04992555f, 0.17893113f, 
    0.06550730f, 0.29520404f, 0.05516297f, 0.09018808f, 0.19704767f, 0.17561109f, -0.09694204f, 0.18623424f, 
    -0.02703999f, 0.00792954f, 0.11042857f, 0.06040734f, 0.06395011f, 0.14573908f, 0.00486996f, 0.06366515f, 
    -0.01271516f, -0.07758968f, -0.05766761f, 0.12506633f, 0.12290032f, 0.13827589f, 0.15067478f, 0.14726101f, 
    0.00560808f, -0.03027291f, 0.04227639f, 0.01761050f, 0.03784999f, -0.02533315f, 0.00942930f, 0.03363530f, 
    0.02760665f, 0.00806052f, 0.01410976f, 0.01515736f, -0.03230616f, 0.01720847f, 0.03720196f, -0.01256749f, 
    -0.03856773f, 0.00258258f, 0.04951640f, -0.04730976f, 0.03366605f, 0.02223183f, -0.01308794f, 0.03635473f, 
    -0.01016094f, -0.05061410f, 0.03582402f, -0.02675810f, 0.01462277f, 0.02269971f, -0.01673734f, -0.01200323f, 
    0.02720275f, 0.03127808f, 0.02475148f, -0.01076417f, -0.00792089f, -0.01181096f, 0.01346960f, -0.02893401f, 
    0.02466117f, 0.00517892f, 0.02773133f, -0.02848216f, -0.02454462f, 0.01788232f, -0.03912256f, -0.03906583f, 
    0.02743522f, 0.02749741f, -0.01350748f, 0.00744989f, -0.03168675f, 0.02986172f, 0.02419741f, -0.03123162f, 
    -0.04901246f, 0.02742293f, -0.01473891f, -0.02010761f, -0.02631624f, 0.04677048f, -0.02169995f, -0.00436819f, 
    -0.05231147f, -0.02024858f, 0.01141726f, -0.05452015f, -0.01644295f, -0.03413226f, 0.05087611f, 0.01193694f, 
    0.01374156f, -0.04719764f, -0.02069722f, -0.05678860f, 0.03781076f, -0.05779603f, 0.02830741f, -0.03578714f, 
    -0.01497174f, -0.04407319f, -0.01172098f, 0.04659542f, 0.02519445f, -0.00558016f, 0.04581827f, 0.00655633f, 
    -0.03929232f, -0.01724727f, -0.02037088f, -0.04759762f, -0.00170178f, -0.01252275f, -0.04996947f, -0.02093596f, 
    0.02159627f, -0.03042411f, -0.03531950f, -0.03314419f, -0.01392542f, -0.04863451f, -0.04554987f, 0.04793167f, 
    -0.00816224f, -0.02276898f, -0.02906285f, -0.00682534f, -0.02139377f, 0.00024462f, -0.03857975f, 0.03010170f, 
    -0.02254253f, -0.05683232f, -0.01259355f, 0.00573988f, -0.00745314f, 0.01038041f, -0.04594898f, 0.04477336f, 
    -0.03232861f, -0.03982608f, -0.03268668f, 0.02935580f, -0.04970102f, -0.01223260f, -0.02149588f, -0.00897329f, 
    -0.00208294f, 0.03839196f, 0.00170178f, 0.02656042f, -0.00498557f, -0.01522120f, -0.04515867f, -0.00249676f, 
    0.03592306f, 0.00314542f, -0.03681564f, 0.03175414f, -0.01610029f, -0.05882611f, -0.05558775f, -0.00446806f, 
    -0.06159027f, 0.01578936f, 0.04218319f, -0.00901062f, 0.04820427f, -0.05174763f, 0.04947020f, -0.03609707f, 
    -0.03454312f, -0.03919065f, 0.01501945f, 0.03749183f, 0.04751322f, -0.01957323f, -0.00339101f, -0.05828241f, 
    0.04996637f, -0.00647895f, -0.03467432f, 0.00639497f, -0.04468720f, -0.05463555f, 0.02945716f, 0.02613062f, 
    0.00765778f, -0.00056759f, -0.02521932f, -0.04974269f, 0.02340383f, -0.02932603f, -0.00618044f, 0.02867683f, 
    0.03469369f, -0.04596939f, 0.02301826f, 0.04089368f, -0.00405497f, 0.00926753f, 0.00910888f, -0.04458181f, 
    0.02868854f, 0.00663187f, -0.03242858f, -0.02456848f, 0.01655586f, -0.01551091f, 0.05517421f, 0.03047733f, 
    0.03655444f, 0.01361937f, 0.00607234f, 0.03675726f, -0.00736454f, 0.00171734f, -0.01103239f, -0.02097354f, 
    0.03288728f, -0.02265754f, -0.05583256f, 0.02111027f, 0.04110472f, 0.01638778f, -0.02076441f, -0.03114393f, 
    0.01305978f, -0.03547835f, 0.03788514f, -0.02774192f, -0.04665382f, -0.04586578f, -0.00263586f, -0.02332347f, 
    0.02766293f, -0.00717700f, -0.03119035f, 0.01037528f, 0.00275391f, 0.00475541f, -0.05142191f, -0.05002403f, 
    -0.01926374f, -0.03990747f, 0.01346400f, -0.03207191f, 0.03412225f, -0.00222841f, -0.02909736f, 0.00463382f, 
    -0.00996201f, 0.00278039f, -0.00024331f, 0.02081035f, -0.01729482f, 0.02758974f, 0.00682822f, -0.02650490f, 
    0.01459348f, 0.01861269f, -0.02870791f, -0.03824864f, 0.00791615f, 0.04200486f, -0.01274356f, -0.00560727f, 
    0.03058954f, -0.03560095f, -0.04914977f, 0.01482651f, -0.02927808f, 0.02023057f, 0.02194346f, -0.02315517f, 
    -0.04188918f, -0.01730543f, -0.02779011f, 0.00157890f, -0.05604637f, -0.03661136f, -0.00912668f, 0.04469527f, 
    -0.03596752f, -0.00476792f, -0.03001466f, -0.04858709f, -0.05008972f, -0.04443591f, -0.01932600f, -0.02816209f, 
    0.01487790f, -0.00113521f, 0.02946026f, -0.05003001f, 0.04693585f, 0.04854892f, 0.00274670f, -0.03106151f, 
    -0.01679750f, -0.00557672f, -0.03225606f, -0.05170662f, -0.01881915f, -0.00459452f, -0.03108427f, 0.03949298f, 
    -0.00664063f, -0.05937902f, 0.03577582f, 0.01026607f, 0.02985208f, 0.00561917f, -0.02854976f, -0.01983539f, 
    0.00184654f, -0.02115629f, -0.02601566f, -0.06176188f, -0.00310033f, 0.04386740f, 0.02331459f, -0.04020707f, 
    -0.01122782f, 0.00311781f, -0.05821146f, 0.03558445f, -0.04900804f, 0.02012091f, -0.05790649f, 0.00403359f, 
    0.04227209f, 0.00887762f, -0.06112922f, 0.02855839f, 0.01532775f, -0.04561790f, -0.01817835f, -0.00772346f, 
    0.24840517f, -0.31715158f, 0.21741775f, -0.01376179f, 0.11530938f, -0.17160337f, -0.01923832f, 0.26188979f, 
    -0.14105703f, 0.01751625f, 0.03747724f, 0.02173970f, 0.03992749f, 0.00080939f, 0.03842396f, -0.02587719f, 
    0.05845327f, -0.01510045f, -0.07076359f, 0.15491533f, 0.03603503f, -0.10701106f, -0.17548558f, -0.07781079f, 
    0.13558424f, -0.09905485f, 0.01914472f, -0.10709455f, -0.07768947f, 0.11736280f, 0.01955035f, 0.06111926f, 
    0.14251576f, -0.05085650f, 0.06910249f, 0.01761557f, -0.05438201f, 0.13821155f, -0.02044054f, 0.01317790f, 
    -0.04608798f, 0.05107641f, -0.12350939f, -0.20982675f, -0.00665902f, -0.00083544f, 0.22341242f, 0.06453934f, 
    0.04906983f, -0.05120110f, -0.00608212f, 0.08698611f, -0.02697217f, 0.05562775f, -0.00192154f, 0.01729189f, 
    0.03445457f, 0.19740617f, -0.08213392f, 0.01324078f, 0.32632068f, 0.02457826f, -0.27535099f, 0.17589183f, 
    -0.04435083f, 0.13180970f, 0.00108283f, 0.17869592f, -0.01227105f, -0.00832436f, 0.05822958f, 0.00236156f, 
    -0.08612005f, -0.02591614f, -0.01357725f, 0.09417614f, 0.06144011f, 0.08292191f, 0.11336831f, 0.17865607f, 
    -0.45971236f, 0.16840492f, -0.04898440f, -0.45615682f, 0.21440874f, 0.11695550f, 0.06445882f, 0.03741985f, 
    0.13668144f, 0.07738900f, 0.15645707f, 0.11619983f, 0.02191191f, 0.10105459f, -0.00345726f, 0.08281977f, 
    0.10271938f, -0.06583130f, -0.07341893f, 0.01350632f, -0.15012252f, -0.25858048f, -0.01977168f, -0.26634857f, 
    -0.03320860f, 0.03633440f, -0.16572846f, -0.09745987f, -0.06579694f, 0.08628071f, -0.08321379f, 0.09910410f, 
    -0.13740461f, -0.00446271f, 0.12238079f, 0.03030529f, 0.02797704f, 0.01077774f, -0.07981080f, -0.01175157f, 
    -0.16573450f, 0.12738071f, -0.19492559f, 0.22780524f, -0.28665012f, 0.32362929f, 0.10939143f, 0.05414299f, 
    -0.13684402f, -0.02872800f, 0.07568576f, 0.05805077f, 0.07871373f, 0.18100487f, 0.03712285f, 0.02904642f, 
    0.01777303f, -0.13524617f, -0.07575447f, -0.00505038f, -0.21324909f, -0.33338156f, -0.13454373f, 0.08804672f, 
    0.23140395f, 0.17923360f, 0.06450377f, -0.10673083f, 0.12442274f, 0.04119285f, 0.05502478f, -0.15358946f, 
    -0.01107077f, 0.02923188f, 0.03072479f, 0.09216522f, 0.12694670f, 0.09520255f, 0.02059324f, 0.10400324f, 
    0.17627621f, 0.38290098f, 0.01511577f, -0.10442694f, -0.02059817f, -0.07457064f, 0.00096315f, 0.00347121f, 
    0.05920430f, 0.09489156f, 0.00159458f, 0.08827133f, 0.18875559f, 0.12389183f, -0.00795499f, 0.23069230f, 
    0.15248919f, -0.02893526f, -0.08550401f, 0.06371016f, -0.02265517f, 0.21429406f, -0.03551421f, 0.13349541f, 
    -0.12386952f, 0.30944335f, 0.13960922f, -0.29624635f, -0.08107556f, -0.13476981f, -0.15562636f, -0.11171519f, 
    -0.02147801f, 0.07260501f, 0.12337793f, -0.11236110f, 0.03040174f, 0.19752280f, 0.12800306f, -0.10600625f, 
    0.43072391f, -0.20720308f, -0.21802224f, -0.08339008f, 0.04203118f, -0.00992923f, -0.10761145f, 0.06095787f, 
    0.02857155f, 0.12668382f, -0.07469819f, 0.05572276f, -0.01801238f, -0.17751460f, 0.02947506f, 0.10132175f, 
    -0.06683182f, -0.17703225f, -0.01124224f, 0.01892120f, 0.17403150f, 0.04233078f, 0.07987976f, -0.02789331f, 
    0.30372518f, -0.08201803f, 0.07096756f, -0.05824217f, -0.01347542f, -0.04924614f, -0.00812400f, 0.06283289f, 
    -0.06065676f, -0.07018089f, -0.17410569f, 0.16438356f, -0.00655627f, 0.03780694f, 0.19291513f, 0.11409279f, 
    -0.01239415f, 0.11094291f, -0.11408137f, 0.30957916f, -0.10467333f, 0.14651524f, 0.04099946f, -0.17390625f, 
    -0.12396775f, -0.04143406f, 0.02221414f, 0.00196168f, 0.01754398f, 0.01626947f, -0.00554447f, 0.11233886f, 
    0.03978490f, -0.07993167f, 0.19103363f, -0.00202370f, 0.16419496f, -0.14448579f, 0.06775252f, -0.05192850f, 
    0.21067165f, -0.23105738f, 0.04492887f, -0.02801128f, 0.14626962f, 0.05802729f, 0.06086356f, 0.08131227f, 
    -0.24976018f, 0.10625316f, 0.22267099f, -0.03142849f, 0.11715040f, -0.01603558f, 0.04530293f, 0.02869411f, 
    -0.04300273f, 0.09428401f, -0.25350517f, -0.24346441f, -0.06150269f, -0.02626224f, -0.05781038f, 0.09620585f, 
    -0.01580629f, -0.04293512f, 0.14889595f, 0.00796690f, 0.00842484f, -0.06427706f, -0.00980069f, -0.07585906f, 
    0.01142683f, -0.22180557f, -0.08737193f, 0.10609829f, 0.09260698f, 0.17277516f, 0.01732665f, -0.43966442f, 
    0.04225459f, -0.01331113f, -0.09699138f, -0.00857494f, 0.08078702f, -0.01325088f, 0.01023390f, -0.02941431f, 
    0.08136996f, 0.07843659f, -0.00285938f, 0.02755924f, -0.03255201f, -0.02937006f, -0.05067427f, -0.10571370f, 
    -0.09809766f, -0.07671541f, 0.05019506f, 0.01983863f, 0.19177374f, 0.08660308f, 0.07368129f, 0.07477616f, 
    0.10307134f, 0.15636805f, -0.00889469f, -0.14267221f, 0.14695732f, -0.02904212f, -0.05405015f, -0.07330095f, 
    0.04366954f, -0.07194814f, 0.13702594f, 0.01285398f, 0.60696679f, -0.26299402f, -0.27425689f, -0.13164791f, 
    0.34024552f, 0.10703854f, 0.11692879f, 0.03429727f, 0.03740454f, 0.25536585f, -0.06097103f, 0.13871865f, 
    0.02282112f, 0.27544510f, 0.07235081f, -0.06225897f, 0.08861762f, -0.13496494f, -0.04310956f, -0.06582219f, 
    0.18789165f, -0.07129660f, 0.29360089f, 0.09037790f, 0.03974279f, 0.04486930f, 0.09719267f, 0.05377758f, 
    -0.07928877f, 0.10916746f, -0.03807111f, -0.04081605f, -0.01579077f, -0.16194837f, 0.08238781f, 0.11850959f, 
    0.12932262f, -0.11610439f, 0.05463753f, 0.15268406f, -0.18172480f, 0.05468462f, 0.10751672f, 0.13947169f, 
    -0.09492990f, 0.19328851f, -0.01896337f, 0.06893457f, 0.04328718f, 0.02487809f, 0.00677860f, -0.02789054f, 
    0.12522097f, 0.02745372f, 0.08811273f, -0.01561979f, 0.13039286f, 0.03223397f, -0.00341243f, -0.03294828f, 
    -0.19931401f, -0.01162969f, -0.04271036f, -0.35658237f, -0.18468563f, -0.20138404f, 0.08304157f, 0.10928550f, 
    0.04834128f, -0.05531250f, -0.03311035f, -0.02209216f, 0.04415710f, 0.00595197f, -0.04628868f, 0.05907879f, 
    0.11181565f, 0.03618668f, 0.27593666f, 0.19161299f, -0.17644596f, -0.37566686f, -0.16035645f, -0.09985172f, 
    0.09595827f, -0.01388214f, 0.07035761f, -0.04780741f, -0.05361664f, 0.10629559f, -0.15902701f, -0.12889364f, 
    0.15305394f, 0.11357100f, 0.10828210f, 0.01585403f, 0.14640842f, -0.10237619f, 0.11501212f, 0.18609071f, 
    -0.26428309f, 0.21929708f, 0.27348587f, 0.09829422f, -0.50186998f, -0.00970423f, 0.16548452f, -0.11481617f, 
    -0.13510029f, -0.01929281f, 0.07846174f, 0.02535966f, 0.00626304f, -0.16062097f, -0.16534418f, -0.05462744f, 
    -0.00263046f, -0.02765845f, -0.12194268f, -0.12237583f, 0.22295134f, 0.08629997f, -0.34500280f, -0.36090505f, 
    0.18837865f, 0.16280414f, -0.04314731f, 0.03517289f, 0.04574125f, 0.07759282f, 0.02085839f, -0.01873212f, 
    -0.04511248f, -0.00898081f, -0.05919140f, 0.22318451f, -0.11292946f, -0.16343179f, -0.10171012f, 0.16852419f, 
    -0.21156278f, 0.21380554f, -0.22868413f, -0.11665543f, -0.06817435f, 0.03245849f, 0.06556506f, 0.08906068f, 
    -0.10173740f, -0.24652764f, -0.17208609f, -0.09063985f, -0.16467194f, -0.02856976f, -0.09979253f, -0.11527464f, 
    -0.05133694f, 0.26071045f, 0.06807021f, 0.09322886f, 0.05349772f, 0.05060818f, 0.02799734f, 0.29825693f, 
    0.23890910f, 0.03504416f, -0.02720599f, -0.07640740f, 0.05770373f, 0.08076693f, 0.08127107f, -0.14850970f, 
    0.04157072f, 0.02860440f, 0.06285567f, 0.10108694f, -0.07484170f, -0.27992809f, -0.25492138f, 0.05801127f, 
    -0.22023952f, -0.40718383f, 0.01738877f, -0.06156939f, 0.09068221f, 0.19349806f, 0.01780777f, -0.10232639f, 
    -0.07214921f, 0.18190651f, -0.02208609f, -0.00365857f, -0.01776265f, 0.24633983f, 0.05196458f, 0.03015383f, 
    -0.13023400f, 0.04828052f, -0.08999251f, 0.03506809f, 0.23785681f, -0.24141966f, 0.05212071f, 0.22462603f, 
    0.10604172f, 0.14379728f, 0.06330769f, -0.02946179f, -0.12208701f, 0.07972888f, -0.07390129f, -0.00304667f, 
    0.06990179f, 0.01546437f, 0.14220703f, 0.04400102f, 0.12100170f, -0.12061451f, -0.01954072f, -0.12197635f, 
    0.28802198f, 0.03160058f, 0.09149568f, -0.00477871f, 0.17441921f, 0.12042251f, 0.16299880f, -0.04206043f, 
    0.00696110f, -0.03944569f, 0.08313294f, 0.14169705f, -0.02001659f, -0.03664149f, -0.03347805f, 0.01099672f, 
    -0.00682093f, -0.08380395f, -0.02982687f, -0.09677823f, -0.26305482f, -0.07090144f, -0.02009813f, 0.03303752f, 
    0.09601386f, 0.07782382f, -0.00931995f, 0.06121615f, 0.05985117f, 0.08101172f, 0.00207952f, -0.04417940f, 
    0.01052186f, 0.19337076f, 0.23279762f, -0.03097088f, -0.03682350f, 0.07053535f, 0.00559953f, 0.07878178f, 
    -0.21553566f, -0.06750300f, -0.14524578f, 0.01334967f, -0.15490566f, -0.10678423f, 0.00596231f, -0.11619464f, 
    0.02337206f, -0.11631528f, 0.14917703f, 0.00740650f, -0.12133736f, -0.00957461f, 0.08190368f, -0.04938562f, 
    -0.00817797f, 0.14580773f, -0.00348588f, 0.19432245f, -0.03573769f, -0.10311429f, -0.09422986f, -0.32569185f, 
    0.07628085f, -0.08598764f, 0.11618838f, 0.01384853f, -0.02744515f, -0.02757194f, 0.03616451f, 0.09397328f, 
    -0.06549539f, -0.08810730f, 0.09457593f, 0.01682735f, -0.08056346f, 0.13551453f, 0.30567721f, -0.00661895f, 
    0.24675827f, 0.08109155f, -0.09346169f, 0.15078616f, 0.00580480f, 0.01143364f, 0.01158136f, 0.00167219f, 
    0.09581123f, 0.10612658f, -0.00558200f, -0.13248558f, 0.08542368f, 0.02468057f, 0.12425455f, 0.11062413f, 
    -0.00848851f, -0.00208260f, -0.04009234f, 0.11845637f, -0.00479943f, 0.04291875f, 0.15566196f, 0.05038812f, 
    -0.10465070f, -0.02546033f, 0.07970257f, 0.01623091f, -0.11651717f, 0.14095937f, 0.07701176f, 0.11849133f, 
    0.10476902f, 0.01811346f, 0.06514570f, -0.04754305f, 0.02988663f, 0.13148469f, 0.04416648f, 0.01023982f, 
    0.04325517f, -0.07441147f, -0.00109731f, -0.12129133f, -0.01108256f, 0.05570873f, 0.19756787f, -0.06694016f, 
    0.06654295f, 0.05534011f, 0.04515225f, 0.03991249f, 0.07686009f, -0.01118891f, -0.03659476f, 0.05857076f, 
    0.01336280f, 0.16644138f, -0.07575514f, 0.05201391f, 0.32801375f, 0.02044554f, -0.09879151f, 0.19467582f, 
    0.01109331f, 0.05522895f, -0.06948376f, 0.03495076f, 0.15827230f, 0.00014410f, 0.08169206f, 0.05943678f, 
    -0.08861121f, 0.10974306f, -0.04767307f, 0.03077019f, -0.00683051f, 0.04427416f, -0.01903438f, 0.02696867f, 
    -0.14558388f, -0.00251034f, 0.09992526f, -0.37799039f, -0.18225780f, 0.00966835f, -0.08041393f, -0.01728703f, 
    0.05240573f, 0.01210912f, 0.04814628f, -0.08913240f, 0.16224393f, 0.05326186f, -0.01840646f, 0.04284601f, 
    0.02408177f, -0.04644816f, -0.07941335f, 0.00904569f, -0.01461073f, 0.17326649f, -0.23082504f, 0.04189101f, 
    -0.26541451f, -0.00763022f, -0.07386934f, -0.01656128f, -0.00213640f, -0.03533205f, 0.15962204f, 0.04423095f, 
    0.02487994f, 0.04353369f, 0.00080275f, 0.06270463f, -0.07924198f, 0.03572955f, -0.03401439f, 0.13503440f, 
    0.50521952f, 0.34016329f, 0.10227629f, -0.25590003f, -0.10928438f, 0.22689478f, -0.03347965f, 0.06192577f, 
    0.03617661f, 0.03323826f, -0.02611047f, 0.01525191f, 0.02672375f, 0.19682536f, 0.01158383f, 0.09022511f, 
    -0.08837423f, -0.01315920f, -0.08391146f, -0.01493725f, -0.42470399f, -0.52900577f, -0.15195146f, 0.17086393f, 
    0.17107761f, 0.02659477f, 0.09252020f, 0.10196618f, 0.06897322f, 0.09799681f, -0.02535713f, -0.11856005f, 
    -0.00090776f, 0.06369558f, 0.02599529f, 0.07474367f, 0.00368569f, 0.01377393f, 0.11199808f, 0.05805734f, 
    0.09255217f, -0.14573798f, 0.00145119f, 0.03727621f, -0.07039831f, 0.00541690f, 0.02558515f, -0.01719574f, 
    -0.05128014f, 0.18627660f, -0.00189931f, 0.00430886f, -0.00198762f, 0.05069808f, 0.02256344f, 0.21968076f, 
    0.14496991f, -0.11751332f, -0.01769991f, 0.02330426f, 0.13071930f, 0.23916492f, 0.17061825f, 0.11478131f, 
    0.25023809f, 0.13605382f, 0.16827667f, -0.04452471f, 0.07588376f, -0.01860283f, -0.09872686f, 0.09938270f, 
    -0.10883843f, -0.02855822f, 0.05931994f, -0.01863648f, 0.01477364f, 0.06916150f, -0.04800196f, 0.02593043f, 
    0.41401759f, -0.12959258f, -0.12225795f, 0.04201173f, -0.10195747f, 0.20625290f, 0.07316197f, -0.14349288f, 
    -0.03177989f, 0.12762040f, -0.03549488f, 0.00220104f, 0.00900106f, -0.11631984f, 0.07359624f, 0.04755647f, 
    -0.07879226f, -0.09208468f, -0.08242273f, 0.01387812f, 0.15792988f, 0.03079941f, 0.07177459f, 0.09182456f, 
    -0.04029427f, 0.06922042f, 0.02796932f, -0.09357331f, -0.02050870f, 0.01768768f, 0.02847977f, -0.00114423f, 
    -0.03592968f, 0.05068776f, -0.07343636f, 0.03366500f, -0.14494324f, -0.00658545f, 0.06083567f, 0.03258697f, 
    0.53619701f, -0.09748357f, 0.03386257f, -0.02147037f, 0.11041246f, -0.04634553f, 0.07699479f, -0.02304851f, 
    -0.07394794f, 0.04673841f, -0.05734111f, -0.05240519f, 0.10478599f, 0.06059315f, 0.11482278f, 0.06576270f, 
    0.01314456f, 0.11648758f, 0.01486279f, -0.04167339f, 0.43245745f, -0.03128222f, 0.01393640f, -0.00971063f, 
    -0.03099663f, 0.04342536f, 0.10224241f, 0.00339931f, 0.02878175f, -0.11298531f, 0.07560020f, -0.00158226f, 
    -0.06538048f, 0.11411922f, 0.03554915f, 0.03856480f, 0.09876289f, 0.01432155f, 0.00602020f, 0.02419139f, 
    -0.50140446f, -0.09231479f, 0.03519214f, -0.25449720f, 0.13514429f, -0.00000650f, -0.20425658f, 0.19649360f, 
    -0.07561076f, 0.02934550f, -0.09358858f, -0.08860632f, 0.04842989f, 0.04315747f, 0.01395334f, -0.03592074f, 
    -0.08016196f, -0.10883572f, -0.09715032f, -0.06811977f, -0.11131741f, -0.09147419f, -0.15121788f, -0.33003509f, 
    -0.15801114f, -0.12449814f, -0.00630243f, 0.00585719f, 0.13146804f, -0.01233157f, -0.05939948f, -0.02843159f, 
    0.06657325f, 0.08827838f, -0.00869932f, -0.06402969f, -0.00186997f, -0.02251801f, -0.06166403f, 0.00182914f, 
    -0.04199250f, -0.00315275f, -0.05885808f, -0.03614732f, 0.03322178f, -0.05696460f, -0.05887303f, 0.03229677f, 
    0.03959961f, 0.00681324f, 0.04011511f, 0.02075380f, 0.03251401f, -0.05492353f, -0.00866786f, 0.02623330f, 
    -0.02604906f, -0.05638643f, 0.04180066f, -0.05364369f, 0.04265192f, 0.02969689f, 0.01942927f, 0.02204173f, 
    -0.03139376f, 0.01813053f, -0.04174548f, 0.04223394f, -0.02203880f, -0.02156813f, -0.01400192f, -0.01392285f, 
    -0.05712897f, 0.00588357f, -0.04117701f, 0.04110621f, -0.06362806f, -0.01224563f, -0.04494696f, 0.03465892f, 
    -0.00340197f, 0.00990609f, -0.01407889f, 0.02022929f, -0.00645844f, -0.04297596f, -0.00477842f, 0.04532700f, 
    -0.03561340f, 0.00832742f, 0.03602330f, 0.01060090f, 0.04439840f, -0.01701065f, -0.05503171f, -0.01705730f, 
    -0.01584219f, 0.03824866f, 0.00744157f, -0.01997105f, -0.01465298f, 0.02062885f, -0.01448461f, -0.03560718f, 
    -0.04024315f, -0.01073298f, -0.01938929f, 0.02621659f, 0.03244904f, 0.01798026f, 0.00264741f, -0.02581337f, 
    -0.02198712f, -0.04154828f, 0.03645887f, -0.00066807f, -0.00394645f, 0.03137578f, -0.02760818f, -0.03876351f, 
    0.00766553f, 0.03969733f, 0.03545871f, -0.06348068f, -0.00813674f, 0.02950740f, -0.04064095f, 0.00186055f, 
    0.01600528f, 0.00202847f, 0.00831028f, -0.05661214f, -0.00166729f, -0.02779895f, -0.04265289f, -0.02823596f, 
    -0.04046818f, -0.02723387f, -0.01186139f, -0.03472311f, -0.02304797f, 0.03953512f, 0.02048409f, -0.01641804f, 
    0.03635497f, 0.01423919f, -0.01169388f, -0.05824722f, -0.02217245f, 0.03618380f, -0.00730519f, -0.00684268f, 
    0.02973460f, -0.05178541f, 0.02900940f, 0.02158500f, -0.02733226f, -0.01102523f, -0.02024172f, -0.05293411f, 
    0.03715779f, 0.04175802f, 0.02787024f, -0.05191913f, -0.04124043f, 0.00453670f, -0.01143354f, 0.04363297f, 
    -0.00559376f, -0.00683358f, 0.03624053f, 0.00211307f, -0.02587638f, 0.00853588f, 0.03381402f, -0.02476978f, 
    0.00049309f, -0.01240281f, 0.00360054f, 0.02076425f, 0.00157783f, 0.00341886f, 0.03965267f, -0.01911178f, 
    -0.02880170f, 0.03351166f, -0.04568573f, -0.01091711f, -0.01785430f, 0.03689162f, -0.06143923f, -0.01441769f, 
    -0.01873833f, 0.03552160f, -0.05258705f, 0.00524177f, -0.06252985f, -0.04938661f, 0.03106406f, -0.01895068f, 
    -0.03493169f, 0.04268312f, 0.00318335f, -0.04337676f, -0.00754108f, -0.05883430f, -0.00329325f, 0.01287819f, 
    -0.05596692f, 0.04220599f, -0.06359590f, -0.05573864f, 0.02598280f, -0.03284307f, -0.00831605f, 0.03618247f, 
    0.02003019f, -0.04554445f, -0.05968279f, -0.00956972f, 0.03744053f, -0.02742417f, -0.06529130f, -0.04385028f, 
    0.02916239f, 0.03806091f, -0.00708793f, -0.03094745f, -0.01993352f, -0.02882012f, -0.04022127f, -0.02485144f, 
    0.03378734f, -0.04136862f, -0.03065024f, -0.01884756f, 0.04044379f, -0.03072564f, -0.04076151f, -0.06253628f, 
    0.00610991f, 0.00562164f, -0.06295560f, -0.06176086f, 0.01412354f, -0.05848264f, -0.00563751f, -0.05871284f, 
    -0.03280395f, 0.01468512f, -0.01324962f, 0.01378625f, -0.04346426f, -0.03638540f, -0.05635853f, -0.03452224f, 
    0.03002973f, -0.04673353f, -0.02570509f, 0.00979755f, 0.01084626f, -0.04999161f, -0.01123583f, 0.01820955f, 
    0.01537661f, -0.04235524f, -0.04023772f, -0.00904295f, -0.04578014f, -0.01603337f, 0.02912594f, -0.05245407f, 
    -0.03248027f, -0.00081748f, -0.02351530f, 0.03510710f, 0.00784614f, 0.01528774f, -0.01866628f, 0.01318953f, 
    -0.05219872f, -0.03556095f, -0.00417186f, 0.00838420f, -0.04228681f, -0.03852620f, -0.04383101f, 0.04273439f, 
    0.03921626f, -0.01954347f, 0.01493358f, 0.02687837f, 0.03720123f, -0.01348126f, 0.03759653f, 0.02057991f, 
    -0.00854222f, -0.00656977f, -0.02837241f, -0.00740311f, -0.05714481f, -0.01766237f, -0.02049881f, 0.03216903f, 
    0.00592191f, 0.04114110f, -0.02496010f, -0.05994786f, -0.05918397f, -0.02336359f, 0.03332534f, 0.02531646f, 
    0.01282555f, -0.04863548f, 0.01874417f, 0.01049421f, 0.01234602f, -0.06316363f, -0.06080375f, -0.00343674f, 
    0.04303681f, -0.05368068f, -0.02880078f, -0.04531860f, -0.02395670f, -0.05413383f, 0.03571948f, 0.01955351f, 
    0.04082871f, 0.04339211f, -0.01356873f, 0.05181022f, 0.00904913f, -0.04425441f, -0.00553910f, 0.00965260f, 
    -0.01404525f, -0.00917572f, -0.02655782f, 0.00623421f, -0.05881645f, -0.03281703f, 0.03321107f, -0.03057409f, 
    0.01107244f, -0.01121182f, -0.05826081f, -0.03519844f, -0.02979113f, -0.03043058f, 0.03978853f, -0.03948362f, 
    -0.01811394f, -0.00369006f, -0.02174188f, -0.06239258f, 0.03978826f, -0.06057326f, 0.02191683f, -0.06257626f, 
    0.02348367f, 0.02292487f, -0.00186994f, 0.05252516f, -0.05195787f, -0.01511707f, 0.01574484f, -0.01148927f, 
    -0.03491759f, -0.01323941f, 0.03902974f, 0.03678015f, 0.01738728f, -0.02525218f, -0.04813097f, -0.05730165f, 
    -0.02908587f, 0.04691348f, -0.05490853f, 0.00205474f, -0.04727988f, -0.02424014f, -0.05340993f, -0.01941820f, 
    -0.04998027f, -0.04974809f, -0.04434689f, 0.03477179f, -0.02973784f, 0.01427215f, -0.00077669f, -0.02823051f, 
    -0.04125313f, 0.04296739f, -0.04271610f, 0.02277053f, 0.04807014f, -0.02420889f, -0.05804317f, 0.01271609f, 
    -0.02308165f, 0.01328977f, 0.01327656f, 0.02593145f, -0.03560539f, -0.06065495f, 0.03877296f, -0.03823998f, 
    0.01128447f, 0.02957188f, 0.04299241f, -0.02045512f, 0.01930962f, 0.03083528f, 0.02258715f, -0.04112853f, 
    0.04641286f, -0.05162550f, -0.03992496f, 0.02445885f, -0.02457136f, -0.02057505f, 0.03238594f, -0.05118415f, 
    -0.02456388f, -0.05189746f, -0.05664194f, -0.01538416f, 0.01328045f, -0.04064969f, -0.03812988f, -0.04520868f, 
    -0.02966926f, -0.02678128f, -0.00804743f, -0.01684957f, -0.04119977f, -0.03563294f, 0.02134274f, 0.03692364f, 
    0.00490039f, 0.04083627f, -0.03818331f, -0.01179648f, 0.02636812f, -0.04852668f, 0.01585063f, -0.02796903f, 
    -0.03182441f, 0.05154011f, 0.00165580f, 0.05205423f, -0.02168653f, -0.00710232f, -0.03464430f, 0.00795848f, 
    0.02709570f, 0.02252467f, 0.00765623f, -0.04211423f, 0.03725169f, -0.02725244f, 0.05083653f, 0.00196875f, 
    0.00169780f, -0.01174355f, 0.04276836f, 0.00446209f, -0.01755465f, 0.02791439f, -0.02872601f, -0.05483298f, 
    0.03844498f, -0.03511880f, 0.05892471f, -0.03956458f, 0.04293552f, 0.03905437f, -0.00810338f, -0.05477907f, 
    -0.01627380f, -0.01077371f, -0.00340453f, -0.01701856f, 0.05551808f, -0.02244877f, 0.00893383f, -0.01426295f, 
    -0.05079677f, -0.05596515f, -0.05685937f, 0.02271428f, -0.05100211f, -0.02680492f, -0.01411090f, -0.03669427f, 
    -0.03974833f, 0.03525617f, -0.03137081f, -0.00170899f, -0.02603089f, -0.01542621f, -0.01643086f, -0.04192054f, 
    -0.04741126f, -0.05312157f, 0.03443288f, -0.02998617f, -0.04144000f, -0.02913431f, -0.05857427f, -0.05236585f, 
    -0.05271827f, 0.01953673f, 0.04669323f, -0.03635893f, 0.04886326f, 0.03688214f, 0.04466045f, -0.00805562f, 
    0.01203272f, 0.01956505f, 0.05514639f, -0.04556074f, 0.00838816f, -0.01213636f, -0.01994371f, 0.02763740f, 
    -0.04100081f, -0.02210935f, -0.05378369f, 0.01811963f, -0.04286862f, -0.01898095f, -0.05650011f, -0.03837881f, 
    -0.01577802f, -0.05556185f, 0.02290613f, -0.00106069f, 0.03259821f, -0.05189636f, 0.01042541f, -0.01768745f, 
    0.02459637f, 0.04989677f, -0.00597560f, -0.02794316f, -0.03330655f, 0.03679890f, 0.02081739f, 0.04022120f, 
    0.03980692f, -0.01126508f, 0.01727001f, -0.02979352f, 0.02426707f, 0.02092480f, -0.00049834f, 0.04140972f, 
    0.03407647f, -0.04442220f, 0.04319340f, -0.00194989f, -0.03679347f, 0.02138861f, 0.01170231f, 0.04275681f, 
    -0.00004953f, -0.04238191f, 0.01410736f, 0.02469881f, -0.01205266f, 0.01317673f, -0.04429085f, -0.02589650f, 
    0.01264987f, 0.04321183f, -0.02687086f, 0.00033094f, -0.03504637f, -0.01345003f, 0.04185638f, 0.02654058f, 
    0.00400577f, 0.00890734f, -0.06418563f, -0.01012169f, -0.01217633f, -0.04796814f, -0.00565133f, 0.01119225f, 
    -0.03616989f, -0.02973293f, 0.04785833f, -0.00810809f, 0.03360342f, 0.00867225f, 0.04614406f, 0.02714267f, 
    -0.04677334f, -0.00163131f, -0.04494677f, 0.02356158f, -0.00329318f, -0.05894353f, 0.01074400f, 0.04438059f, 
    -0.03858857f, -0.00648192f, 0.00475946f, -0.02871839f, -0.01470045f, 0.05640721f, 0.01965316f, -0.01732789f, 
    -0.05248078f, -0.00372287f, 0.04778752f, -0.01938260f, 0.02756554f, -0.02885662f, -0.02848425f, -0.03946471f, 
    -0.02533586f, -0.00249684f, -0.04572203f, 0.01229434f, 0.01665019f, -0.00821097f, 0.03990766f, 0.02972887f, 
    -0.03170570f, -0.02113334f, -0.04823226f, -0.04147485f, -0.02740269f, 0.00689823f, -0.05003634f, -0.00948024f, 
    -0.03921048f, 0.04217815f, 0.02920581f, -0.02364381f, -0.04148513f, -0.01837828f, -0.00467583f, -0.00362323f, 
    -0.00159978f, 0.01890569f, -0.03323682f, -0.01406867f, 0.01647944f, -0.03333398f, 0.03994372f, -0.00336226f, 
    0.04322827f, -0.04955992f, -0.04668447f, -0.00209539f, -0.03817111f, 0.03978355f, 0.02382901f, -0.02933599f, 
    0.03379212f, 0.04028053f, 0.03753002f, -0.02311573f, -0.03166717f, 0.00947311f, -0.03603117f, 0.00571851f, 
    0.03893919f, 0.02972668f, 0.02864202f, -0.01634385f, 0.00087411f, 0.01331998f, -0.01224096f, -0.02173137f, 
    0.04276614f, 0.00671891f, -0.05266553f, -0.01053277f, 0.01856006f, 0.00477155f, -0.06156201f, -0.04835678f, 
    0.00326142f, 0.04687286f, -0.00337680f, 0.00859153f, -0.02653890f, 0.02029518f, 0.01174982f, 0.02332544f, 
    0.00617491f, 0.00290368f, -0.02083859f, 0.03690893f, 0.01126702f, -0.02105435f, -0.00942027f, -0.03979350f, 
    -0.01666228f, 0.02776353f, -0.01944290f, -0.01784855f, 0.04227755f, -0.04968095f, 0.03987963f, -0.02279630f, 
    0.01976585f, 0.02561042f, 0.02135381f, 0.01219276f, 0.01791652f, 0.04746107f, -0.02613229f, 0.02777372f, 
    -0.04658256f, 0.02060001f, 0.02910302f, -0.04318403f, 0.01160799f, -0.04456803f, -0.03638383f, -0.03753193f, 
    -0.05818629f, 0.02141115f, 0.00047452f, -0.05929118f, 0.01368042f, 0.01164466f, 0.03283440f, -0.04848570f, 
    0.00115068f, -0.06368763f, 0.00162512f, 0.00561174f, -0.04298848f, -0.05895844f, 0.03083966f, 0.04579254f, 
    0.00019987f, -0.02113111f, -0.02973246f, -0.04526262f, 0.03465491f, -0.02774013f, -0.05205666f, 0.03921279f, 
    0.01903999f, -0.00774781f, -0.04326975f, 0.00665617f, 0.03189889f, 0.02323891f, -0.04315326f, 0.03324569f, 
    0.01370712f, -0.00960152f, -0.00604238f, 0.02533184f, -0.06282989f, -0.06110187f, 0.03211113f, -0.01555414f, 
    -0.04646457f, -0.01291519f, -0.03643689f, -0.01526226f, 0.03051268f, -0.05209228f, -0.00625488f, 0.02011660f, 
    -0.02974021f, -0.02674741f, -0.06238365f, -0.02306112f, -0.05378098f, -0.04605304f, -0.00031799f, -0.03700255f, 
    -0.01580581f, -0.00210313f, 0.01550408f, -0.00055350f, 0.00196867f, -0.03045431f, -0.05463399f, -0.03568090f, 
    -0.04500709f, -0.03230379f, 0.02488491f, -0.01827197f, -0.03887696f, -0.01079766f, 0.00581919f, -0.02515133f, 
    -0.03183473f, -0.05353749f, 0.03702312f, -0.04424763f, 0.03701976f, -0.01539193f, 0.00698196f, -0.00374920f, 
    0.02383408f, -0.00088743f, 0.03799010f, -0.05982457f, 0.05182698f, -0.02000448f, 0.04606658f, 0.04093854f, 
    -0.00993907f, -0.02233306f, -0.04034026f, -0.04943802f, -0.03663579f, -0.04718665f, -0.00368460f, 0.03860335f, 
    -0.03255846f, -0.04717604f, -0.00957752f, -0.03232780f, 0.00970151f, -0.02187631f, -0.01750831f, 0.02596946f, 
    0.02598116f, 0.04462717f, -0.02690976f, 0.03783258f, 0.02545063f, 0.01897324f, -0.04819759f, 0.00647967f, 
    0.00605823f, 0.03852913f, 0.02394448f, 0.03428770f, -0.02076370f, 0.04231509f, -0.00532164f, 0.02724789f, 
    -0.00476241f, 0.02793131f, 0.00786091f, -0.01444459f, -0.04839989f, -0.02052505f, -0.02754140f, -0.01428080f, 
    0.02576065f, 0.02870506f, 0.02730667f, -0.04976495f, -0.03215520f, 0.02595585f, -0.05121884f, 0.00369916f, 
    0.01958542f, -0.00546066f, 0.01014660f, 0.00540951f, -0.06199429f, -0.02360377f, -0.00732021f, -0.05576753f, 
    0.02409162f, -0.03754110f, 0.02153422f, -0.00497465f, -0.00039343f, 0.02896097f, -0.02811532f, -0.05558548f, 
    -0.06033578f, 0.01580035f, 0.00619276f, -0.04537171f, 0.03043890f, -0.00675381f, 0.02734498f, 0.00421338f, 
    0.02939247f, 0.01646689f, -0.05425071f, -0.01261400f, -0.02852127f, -0.00587814f, -0.06564976f, -0.00580349f, 
    0.04140402f, -0.05957038f, -0.05698421f, 0.02565639f, 0.05805662f, -0.00903631f, 0.01624168f, 0.02005831f, 
    -0.00931966f, 0.00472059f, 0.02555456f, 0.02323490f, -0.03746278f, -0.00569075f, -0.06034897f, 0.00438674f, 
    -0.03209976f, -0.00460979f, -0.02750820f, 0.04470756f, -0.02311231f, 0.01390708f, -0.03532678f, 0.05438098f, 
    -0.06049506f, -0.01676656f, -0.01779638f, 0.01663574f, 0.02349897f, -0.02938088f, 0.04721581f, 0.02825949f, 
    0.00478702f, -0.00927128f, 0.03253059f, -0.04130289f, -0.04127730f, 0.02075199f, -0.02062483f, -0.06298648f, 
    -0.03720161f, 0.03127795f, -0.04488111f, 0.01822618f, 0.04500084f, 0.01494664f, -0.04463661f, -0.05638656f, 
    -0.06442391f, -0.06195061f, -0.06443436f, 0.00119557f, 0.03120501f, 0.02965207f, -0.02285844f, 0.01395540f, 
    0.01025313f, 0.01736962f, 0.00746204f, -0.01500049f, -0.02772574f, -0.02596436f, -0.05957638f, -0.06183815f, 
    -0.01849670f, 0.01478129f, 0.03183031f, 0.02471012f, -0.03614087f, 0.02175047f, 0.04710895f, -0.01227572f, 
    -0.06064172f, 0.00082690f, 0.02721532f, -0.02717285f, -0.01484177f, 0.02231204f, -0.02356294f, 0.04183557f, 
    0.05457248f, 0.02817054f, -0.04616143f, 0.01712482f, -0.01203788f, -0.06541923f, -0.06066828f, -0.05146326f, 
    0.01443281f, -0.00685897f, 0.03631604f, 0.02307397f, -0.04667911f, 0.03673208f, 0.00992649f, 0.04549058f, 
    -0.05780087f, 0.00621249f, 0.04473603f, 0.02054805f, 0.03767774f, 0.00858236f, -0.02650720f, -0.03606785f, 
    -0.37445593f, 0.17593288f, -0.02057642f, 0.15184911f, 0.01540995f, -0.01277288f, -0.01450462f, -0.13527352f, 
    0.12353472f, -0.04841711f, -0.06455757f, 0.11516185f, -0.05418326f, -0.04632948f, 0.12463517f, -0.10394435f, 
    0.06079208f, 0.03375417f, -0.00582721f, -0.09622672f, 0.24201523f, 0.33959705f, 0.35172853f, -0.16845144f, 
    0.12905061f, 0.11999089f, -0.13796693f, -0.02892959f, 0.04667984f, -0.04767284f, 0.02120671f, -0.05856489f, 
    -0.00575123f, 0.04270758f, -0.08505277f, 0.03688380f, -0.06884661f, -0.07576951f, 0.06706696f, -0.00786302f, 
    0.38109550f, -0.25136936f, 0.28091279f, 0.16808577f, 0.09550577f, -0.03654167f, 0.00915779f, -0.24793358f, 
    -0.03265081f, -0.07521743f, 0.12055931f, 0.02370530f, 0.15228851f, -0.04664128f, 0.05579645f, 0.04481406f, 
    0.07723137f, -0.13059618f, 0.05420353f, 0.02674549f, -0.15226145f, -0.05366337f, -0.24633881f, 0.05960207f, 
    -0.21530735f, -0.01020043f, -0.06778038f, -0.03489965f, 0.04690131f, 0.10394854f, -0.02015732f, -0.02556148f, 
    0.01426661f, 0.07391638f, -0.03065419f, 0.09002081f, -0.12548462f, -0.11626415f, 0.02708851f, -0.08275373f, 
    0.23205736f, -0.38541079f, 0.00215608f, 0.17285168f, -0.24748570f, -0.13287449f, -0.12290864f, -0.11958924f, 
    -0.00030514f, -0.02099460f, 0.03224854f, 0.09881926f, 0.02737295f, -0.04784338f, 0.07593329f, 0.10578584f, 
    0.06801312f, -0.02957699f, -0.03576079f, 0.03791937f, -0.01529367f, 0.22929879f, -0.05994222f, 0.08099655f, 
    0.02078689f, -0.05328311f, 0.26833302f, 0.04675735f, 0.02949133f, -0.04000666f, 0.18457556f, -0.03297043f, 
    0.10647871f, -0.16936663f, -0.01541092f, 0.02263316f, 0.09908938f, -0.10415915f, -0.22120035f, 0.08117758f, 
    0.34868026f, 0.10395401f, 0.00232934f, -0.40808547f, 0.02631737f, 0.35789135f, 0.05973632f, -0.16611436f, 
    -0.18156183f, 0.01889363f, 0.02271903f, -0.12237885f, -0.00940862f, -0.10075147f, 0.28690314f, -0.05553315f, 
    0.06615437f, 0.03230285f, 0.12212257f, 0.04229510f, -0.24156471f, 0.16210473f, 0.23917165f, -0.04760600f, 
    -0.08096246f, 0.00037657f, -0.23628701f, 0.16618703f, -0.11625775f, 0.02443595f, 0.08154955f, 0.09720626f, 
    0.16398929f, 0.17320734f, 0.03031115f, 0.05292283f, 0.07521591f, -0.12551665f, 0.05467900f, -0.06652289f, 
    -0.49104714f, -0.02443642f, 0.08120467f, 0.04268827f, -0.04895684f, 0.02760200f, -0.00700605f, -0.01127350f, 
    -0.04622561f, -0.11605886f, 0.00662574f, 0.21545628f, -0.12563032f, 0.02910101f, 0.05999430f, -0.09268147f, 
    -0.00301338f, -0.00347258f, 0.02536510f, 0.12271821f, 0.27227244f, -0.01253221f, -0.19637333f, -0.35948399f, 
    0.15097593f, 0.08895274f, 0.16482206f, -0.04308895f, -0.25953981f, -0.02508597f, 0.10483939f, 0.13802615f, 
    -0.08970363f, -0.01399280f, 0.00366331f, 0.13886520f, 0.08373816f, -0.25630578f, -0.08152606f, 0.06486627f, 
    -0.33786753f, 0.21476391f, 0.18962738f, 0.28797665f, -0.06218259f, 0.08735915f, -0.05906031f, 0.11197567f, 
    -0.09046246f, 0.25838536f, 0.02792032f, -0.19473155f, -0.04438169f, -0.02544694f, -0.07666921f, -0.05495121f, 
    -0.05369521f, 0.07991508f, 0.05328770f, -0.13720910f, -0.11500855f, 0.04873298f, -0.10639720f, -0.04463497f, 
    -0.19812579f, 0.25579637f, 0.03661980f, 0.08304374f, -0.02560585f, -0.01422414f, -0.10985417f, 0.20361818f, 
    -0.14918646f, 0.20159194f, 0.13128419f, 0.05567127f, 0.03919993f, 0.02270931f, 0.02791626f, 0.13779119f, 
    0.46415555f, -0.38484693f, -0.07888407f, -0.17200136f, 0.17289443f, 0.03800852f, 0.04222008f, -0.16919996f, 
    -0.13104038f, -0.10824307f, 0.01276479f, -0.06757529f, 0.13107024f, 0.09401931f, -0.04355517f, 0.05407855f, 
    0.08841074f, 0.07601819f, -0.02220695f, 0.12731154f, -0.25136507f, 0.31978387f, -0.09021985f, 0.13451914f, 
    -0.18998405f, 0.05117233f, 0.00861596f, 0.14719854f, -0.06646703f, 0.11117562f, -0.08238710f, -0.09273693f, 
    0.05284058f, -0.07260484f, -0.09744912f, 0.02946895f, -0.13443822f, -0.07705684f, 0.04048653f, -0.05752325f, 
    -0.14899255f, 0.06248014f, -0.14971848f, 0.21773322f, -0.17251824f, -0.13331497f, 0.05524375f, 0.04675873f, 
    0.09381794f, 0.10269848f, 0.13001326f, 0.21954077f, -0.01519162f, 0.10183518f, -0.00728559f, 0.10822096f, 
    0.02822639f, -0.04653608f, 0.00805667f, 0.12066445f, -0.10196205f, -0.12083911f, 0.09702653f, 0.04912215f, 
    0.22422440f, -0.24846047f, 0.10008867f, -0.00984670f, 0.13782267f, 0.05085619f, 0.10392291f, 0.11294111f, 
    0.12304734f, 0.03092373f, 0.08324753f, 0.00540984f, 0.07180501f, 0.07885503f, -0.14228886f, 0.11376639f, 
    -0.00695828f, -0.03023129f, -0.06042976f, 0.01047044f, -0.00821985f, 0.00431349f, -0.03418243f, -0.00211704f, 
    0.03365050f, -0.01451454f, -0.01040585f, -0.00594304f, -0.04019778f, -0.01105807f, 0.03844756f, -0.02163338f, 
    0.04304738f, -0.05981798f, 0.02265659f, -0.03207868f, 0.04352058f, 0.01480796f, -0.03249644f, 0.02000625f, 
    -0.03437901f, -0.01113176f, 0.02686489f, 0.03047185f, 0.00029627f, -0.04002358f, 0.03474035f, -0.04388103f, 
    -0.04144129f, -0.02203035f, 0.03037957f, 0.03791038f, 0.02792231f, -0.01244292f, -0.01935396f, 0.02591107f, 
    0.04635068f, -0.04091699f, -0.05015181f, -0.03835065f, 0.03208850f, -0.01810917f, 0.01052649f, 0.03456977f, 
    -0.01694955f, 0.03280310f, -0.05670368f, 0.02641484f, -0.04414406f, -0.05119848f, -0.04557907f, -0.06167756f, 
    0.00079777f, -0.00427377f, -0.01018622f, -0.04420147f, 0.04812545f, -0.01986741f, 0.04655775f, -0.01792161f, 
    0.00083829f, -0.05093815f, 0.04476480f, -0.03978391f, -0.03001426f, 0.00103050f, -0.00011805f, -0.00807628f, 
    -0.03452828f, -0.00488403f, -0.01941873f, 0.01965898f, -0.01183036f, -0.03477758f, -0.03954749f, -0.01619654f, 
    -0.02027998f, 0.01001492f, -0.01977751f, -0.00259750f, 0.04436177f, -0.00767585f, -0.02101660f, 0.03349135f, 
    -0.03512269f, 0.02153656f, -0.03478939f, 0.00996174f, 0.01237665f, 0.02732137f, -0.04699971f, 0.00877076f, 
    -0.02181034f, -0.06087817f, 0.04246023f, 0.01712469f, 0.01844939f, -0.04537565f, -0.01700690f, 0.03103553f, 
    -0.06134368f, 0.01729047f, -0.02312790f, -0.05133470f, -0.03452250f, -0.03257348f, 0.03803338f, -0.05711346f, 
    0.01404597f, -0.06070324f, -0.02469726f, -0.05829700f, 0.03761898f, -0.04674504f, -0.04018949f, 0.00236519f, 
    -0.05494238f, -0.04592816f, -0.02470066f, 0.02366207f, 0.01654547f, 0.03683918f, 0.03082283f, 0.02158839f, 
    -0.02990625f, -0.02875993f, 0.00572944f, -0.05559915f, -0.01635777f, 0.03368106f, -0.01715116f, 0.03992022f, 
    -0.01885068f, 0.01569426f, -0.04400639f, 0.03488085f, -0.05891688f, -0.02400189f, 0.02803211f, -0.05966651f, 
    0.00860924f, -0.03233985f, -0.03542624f, 0.00325310f, -0.03929948f, -0.03940816f, -0.01067273f, -0.01489524f, 
    -0.00903790f, -0.03811008f, -0.02358313f, -0.03348387f, -0.00062898f, -0.03284561f, -0.04020165f, -0.03796136f, 
    0.04783960f, 0.04153529f, 0.01539389f, -0.02714510f, -0.05040535f, -0.00163221f, -0.04426908f, 0.00310557f, 
    0.03809398f, 0.01157557f, -0.03416304f, -0.04239324f, 0.02201109f, 0.03119152f, -0.02917083f, 0.02992676f, 
    -0.00649246f, 0.01411917f, -0.01295001f, -0.02315985f, -0.00079391f, 0.03051118f, -0.03804535f, 0.04113441f, 
    -0.05694317f, 0.01739434f, 0.00839232f, 0.00442906f, 0.04150694f, -0.05180204f, 0.04439177f, -0.02168078f, 
    0.04479261f, 0.04814612f, 0.02028665f, 0.01183078f, -0.03613403f, -0.04392917f, 0.00189868f, -0.02225908f, 
    -0.01200891f, -0.04825270f, 0.00984439f, 0.03421389f, -0.03112397f, -0.00060919f, 0.01803431f, 0.00999336f, 
    0.03460178f, 0.03690121f, -0.00285494f, 0.04405176f, -0.04480850f, -0.02552969f, 0.00599310f, 0.00901215f, 
    -0.01096709f, -0.03461617f, -0.04747498f, -0.00417899f, 0.01721347f, 0.04331161f, 0.04673713f, -0.02161094f, 
    -0.04473967f, 0.04782493f, -0.01136087f, 0.00544010f, -0.04512219f, -0.04425823f, 0.03575255f, 0.00677638f, 
    -0.02571743f, -0.06024592f, -0.00712453f, 0.00246966f, 0.00527830f, -0.05680673f, -0.00807080f, -0.02096238f, 
    0.02224470f, 0.03369722f, 0.00111691f, -0.00546916f, -0.03669693f, -0.04388840f, 0.00468711f, 0.03668682f, 
    0.02693219f, -0.01664686f, -0.05016058f, 0.00496548f, -0.01365239f, 0.04431407f, -0.03133082f, 0.01653806f, 
    0.03573559f, -0.01039295f, -0.05312551f, -0.00755522f, 0.02264319f, -0.00549762f, -0.03978793f, -0.01744557f, 
    -0.06082392f, 0.02371991f, 0.03509287f, -0.04698292f, -0.05454775f, -0.03523232f, -0.02668835f, -0.05237925f, 
    -0.04159096f, -0.00024524f, -0.03894817f, -0.01953566f, 0.03430170f, -0.00918576f, -0.02917651f, 0.04493134f, 
    -0.00630404f, -0.04874800f, -0.05945426f, -0.03083575f, -0.01771851f, 0.03396332f, -0.02391091f, -0.02610127f, 
    -0.05872094f, -0.05942027f, -0.04804456f, 0.00512968f, -0.03964849f, -0.03590165f, -0.00811174f, -0.01084307f, 
    -0.02599104f, -0.03412997f, -0.04135200f, 0.04849887f, 0.02330198f, 0.03547191f, -0.01588011f, -0.01496185f, 
    -0.04238879f, 0.02509824f, 0.01435240f, -0.01930758f, -0.04292168f, 0.02038635f, -0.03108136f, 0.03370973f, 
    -0.04743127f, -0.05086203f, 0.01067814f, -0.05004923f, -0.04785681f, -0.02490673f, 0.03834257f, -0.01087096f, 
    -0.22056015f, -0.14843006f, -0.08027411f, 0.00071532f, 0.05565407f, 0.04913441f, 0.09347533f, 0.13994190f, 
    0.12272659f, -0.03848744f, -0.00273067f, -0.00416817f, 0.10278213f, -0.02847305f, 0.04015628f, 0.11725423f, 
    0.03120308f, -0.00503743f, 0.03298690f, 0.15660042f, 0.03267852f, 0.16983472f, 0.02425894f, 0.07983420f, 
    -0.12581234f, -0.04340461f, -0.00557601f, 0.00975522f, -0.14858900f, 0.09442870f, -0.02878932f, 0.06171772f, 
    0.05219422f, -0.07388354f, 0.12075245f, -0.04287277f, 0.02638988f, 0.12285631f, 0.10816924f, -0.01994917f, 
    -0.04286603f, 0.18012740f, -0.02972869f, 0.06617327f, 0.14859052f, 0.02923405f, 0.02767388f, 0.07788202f, 
    0.02185069f, -0.02463049f, -0.03978414f, 0.10814185f, 0.05817576f, 0.04419224f, -0.03949809f, -0.02913277f, 
    -0.17985137f, 0.15262862f, 0.07686038f, -0.08898351f, 0.05976072f, 0.07021086f, -0.01489896f, 0.14181340f, 
    0.29826674f, 0.11126801f, -0.03341844f, -0.01031761f, 0.01738722f, -0.08159796f, 0.04043390f, 0.00255609f, 
    -0.01977612f, 0.05784184f, -0.03856332f, 0.00518725f, -0.05910463f, -0.01545532f, 0.15238944f, 0.01726410f, 
    -0.30868632f, -0.01717617f, -0.02632617f, -0.13531722f, -0.07150470f, 0.18651800f, 0.12546071f, -0.01355697f, 
    0.03029659f, 0.13584508f, 0.17995955f, -0.04184794f, 0.10343070f, 0.14016020f, -0.09435311f, -0.22828566f, 
    0.06925718f, 0.00483068f, -0.26233226f, -0.01959264f, -0.18716235f, 0.03067333f, -0.16610108f, -0.09893792f, 
    -0.11801852f, 0.02299387f, -0.00639876f, 0.14733769f, 0.07178380f, 0.03744999f, 0.01432975f, 0.02700767f, 
    -0.17489997f, 0.09040739f, 0.02604025f, -0.00700142f, -0.03010382f, 0.12462220f, 0.00807278f, 0.02575149f, 
    0.28463277f, -0.04680696f, 0.14328870f, 0.34446621f, 0.26471224f, -0.09929053f, 0.01510173f, 0.08947663f, 
    -0.01223883f, 0.00323719f, -0.03965671f, -0.16639754f, 0.02887169f, 0.17253865f, 0.12410055f, 0.06416981f, 
    0.02296583f, -0.07813540f, 0.08185904f, -0.02653388f, -0.25963292f, -0.45067841f, -0.02293523f, -0.13062015f, 
    -0.22061807f, 0.05871717f, -0.14786477f, -0.00756874f, -0.06844728f, 0.05066974f, 0.03097809f, -0.00068913f, 
    -0.05721252f, -0.07430815f, -0.01449093f, -0.05244455f, 0.14655802f, 0.05430366f, -0.01923362f, 0.01591176f, 
    -0.09863218f, 0.04821484f, 0.02738721f, 0.10124132f, -0.15081921f, 0.04259804f, 0.05127845f, 0.04640334f, 
    0.09581798f, 0.08063271f, 0.03265427f, 0.08980184f, 0.15586700f, 0.16741608f, 0.03339618f, 0.09023985f, 
    0.04357562f, -0.21439274f, -0.16538358f, 0.08046980f, 0.33314592f, 0.58609807f, 0.14845353f, 0.33555627f, 
    0.41655296f, 0.02423711f, -0.00359412f, -0.11217356f, 0.01568148f, -0.02561861f, -0.03183061f, -0.08417001f, 
    0.08217780f, 0.08237263f, 0.04916935f, -0.03741388f, 0.03540832f, 0.19616643f, 0.19119616f, -0.06426651f, 
    -0.02264467f, 0.04579186f, -0.24263966f, -0.10695463f, -0.02757260f, 0.08951166f, 0.00565649f, -0.05693970f, 
    0.07536259f, 0.06930435f, 0.19689615f, 0.01873415f, -0.02714419f, -0.10028809f, 0.28547743f, 0.16318876f, 
    0.06725709f, -0.16319485f, 0.10471670f, 0.03006130f, 0.22485243f, -0.03901169f, 0.16565013f, 0.08519223f, 
    -0.08050700f, -0.01337404f, -0.02019521f, -0.06945017f, -0.01797156f, -0.04193508f, 0.12110011f, -0.03566583f, 
    0.00144178f, 0.00387590f, -0.06746430f, 0.15904468f, -0.10039308f, 0.10184581f, 0.13014375f, 0.07474019f, 
    0.06941593f, 0.37217265f, -0.03521454f, 0.27545002f, 0.21287449f, 0.03425051f, 0.07748216f, 0.02093131f, 
    -0.06312240f, 0.13207588f, 0.04013571f, -0.06288435f, 0.11163158f, -0.00139185f, -0.06146833f, 0.00431021f, 
    0.01175170f, -0.02747431f, 0.15798078f, 0.00283279f, 0.02158846f, 0.19665864f, -0.14485398f, -0.03937816f, 
    0.15034844f, 0.05384323f, -0.02181862f, 0.06739687f, -0.00326214f, -0.01801509f, 0.05717791f, 0.02439294f, 
    -0.06441218f, 0.09029432f, 0.17284441f, 0.06943558f, 0.06298587f, 0.02446203f, -0.00444200f, 0.01801224f, 
    -0.31227189f, -0.18319339f, -0.01820791f, -0.14646943f, -0.21419749f, -0.08285723f, -0.06654369f, 0.05644466f, 
    -0.02400536f, -0.07596114f, -0.00798510f, -0.12498638f, 0.10400721f, 0.09158415f, 0.10678133f, -0.02359300f, 
    0.04596311f, -0.22842255f, 0.04093092f, 0.07274421f, 0.04798048f, -0.07766782f, 0.12790343f, -0.17805248f, 
    -0.24227569f, 0.09152820f, -0.04951875f, -0.02903551f, -0.02213232f, -0.00518280f, -0.07265107f, 0.07278780f, 
    0.04759236f, 0.16628183f, 0.18796149f, 0.01357674f, -0.05404917f, -0.00402483f, -0.24280496f, -0.07106012f, 
    0.18467520f, -0.08309568f, 0.27101743f, 0.00292455f, 0.02823252f, -0.03385009f, -0.09737626f, 0.04562624f, 
    -0.14703561f, 0.07486280f, -0.03201710f, 0.08578363f, 0.03087214f, 0.01644346f, -0.00203607f, -0.08529377f, 
    0.00530842f, 0.06135778f, -0.04941268f, 0.02358791f, 0.41490874f, -0.26622456f, -0.00286552f, -0.09353877f, 
    0.15741394f, 0.01289676f, -0.13914667f, -0.02584050f, 0.07565577f, -0.09084699f, 0.04196142f, -0.00779072f, 
    0.02085765f, 0.07937694f, -0.02443956f, 0.03124444f, 0.01089405f, -0.04311689f, -0.02503802f, -0.00612095f, 
    0.08696757f, -0.06657987f, 0.32623726f, -0.02124693f, 0.01936595f, 0.04440805f, 0.10777877f, 0.00984931f, 
    -0.03314251f, -0.05110957f, -0.00584420f, 0.01743619f, -0.10367472f, 0.06374534f, -0.04864635f, 0.06500922f, 
    0.07152251f, -0.11207488f, 0.09517414f, 0.00895028f, -0.13454589f, 0.20672102f, -0.08707792f, -0.01058986f, 
    -0.30943871f, -0.00264616f, 0.03818935f, 0.02730295f, 0.03478312f, -0.03259498f, -0.06469070f, -0.04308973f, 
    0.08005793f, 0.08925154f, 0.07433331f, 0.02168018f, -0.02626884f, -0.06506091f, 0.00256646f, -0.02989680f, 
    0.12060209f, 0.21211816f, 0.08589928f, -0.08326722f, 0.09503847f, -0.13612671f, 0.01989724f, 0.06249545f, 
    0.02838242f, -0.02755488f, 0.04809809f, -0.01952852f, -0.05450528f, -0.09569715f, -0.02971006f, 0.12056755f, 
    0.06215769f, 0.11626133f, 0.26813838f, 0.12731983f, 0.24496810f, -0.29094160f, 0.36837953f, 0.15538603f, 
    0.13779178f, 0.08078630f, -0.07531323f, 0.09115668f, -0.19543311f, -0.04416053f, -0.09358103f, 0.03071786f, 
    0.12025776f, -0.06449939f, 0.11365519f, 0.06738304f, 0.08802710f, 0.02276977f, -0.09733779f, -0.04316021f, 
    -0.14116466f, 0.00373059f, -0.49550968f, -0.04677006f, -0.12828134f, 0.19787970f, 0.15489914f, -0.03084194f, 
    0.04331218f, -0.04416964f, 0.10888770f, 0.08833977f, -0.01538381f, -0.22939801f, -0.05895378f, -0.09295141f, 
    0.05514536f, -0.06141517f, 0.09362005f, -0.03266123f, 0.24166282f, 0.28180373f, 0.03979680f, 0.06743575f, 
    0.36209026f, 0.10049576f, -0.06027904f, -0.07291265f, 0.10672601f, 0.05053506f, 0.09777435f, -0.06251302f, 
    0.02350313f, 0.13045584f, 0.10322727f, 0.01292767f, 0.00238877f, -0.09880579f, -0.04975808f, 0.15492940f, 
    -0.06651379f, 0.43255606f, -0.00023086f, -0.13645162f, 0.20977277f, -0.05183200f, 0.01136474f, 0.01614133f, 
    -0.17688327f, -0.04692974f, -0.01306384f, -0.02786013f, -0.00560863f, 0.04035346f, -0.03766692f, -0.10830820f, 
    -0.02348556f, 0.13840981f, 0.07904834f, 0.01583624f, -0.31426117f, -0.33277130f, -0.11642241f, -0.01820327f, 
    -0.31726196f, -0.06691129f, -0.02287638f, 0.02402004f, 0.03351226f, -0.02062199f, -0.02496721f, -0.04563754f, 
    -0.01237585f, -0.01286401f, -0.09228164f, 0.04209574f, -0.09502884f, -0.13097131f, 0.01740768f, 0.08906295f, 
    -0.04798379f, -0.08907530f, 0.19344933f, 0.06882541f, 0.10495652f, 0.01716753f, -0.11102362f, 0.05326692f, 
    -0.01478128f, 0.22503816f, -0.12573270f, -0.02491167f, 0.05886977f, -0.01133964f, -0.06038850f, 0.04164036f, 
    -0.09342036f, 0.11433264f, 0.03679990f, 0.02983606f, 0.16520025f, -0.01603345f, 0.03441506f, 0.11104040f, 
    0.02047699f, -0.00773233f, -0.01234129f, -0.01289273f, -0.02889042f, -0.09745506f, -0.03452849f, 0.07160828f, 
    0.06745722f, 0.07594198f, 0.07672353f, 0.07374652f, 0.07595057f, -0.03455115f, -0.10030048f, -0.15826313f, 
    0.32425541f, -0.20705840f, 0.02153857f, -0.08046631f, -0.12120508f, 0.13722405f, 0.04493532f, -0.07196078f, 
    0.20409173f, -0.15804437f, 0.05155078f, 0.04646380f, -0.06764642f, 0.11636769f, -0.10621753f, 0.04609892f, 
    -0.03153506f, -0.03482469f, 0.00950414f, -0.00159788f, 0.04116473f, -0.10442495f, -0.05737511f, 0.06545729f, 
    -0.12941299f, -0.01719154f, -0.09441493f, 0.10284139f, 0.13343993f, 0.08141304f, -0.04655874f, -0.02528740f, 
    0.07533418f, 0.06680183f, 0.14222166f, 0.02277762f, -0.08626925f, 0.11046376f, 0.04409678f, 0.08770749f, 
    0.30827659f, 0.34485149f, -0.16084088f, 0.18130860f, -0.01057941f, 0.00448434f, 0.07713249f, -0.16099960f, 
    0.12335869f, 0.06351298f, 0.14905414f, 0.03632440f, 0.02011939f, 0.04910922f, 0.00856787f, 0.20361412f, 
    -0.10754947f, 0.18330713f, -0.06050209f, 0.09270813f, -0.30833808f, 0.02814744f, -0.00327726f, -0.01565365f, 
    0.24700108f, -0.10743371f, 0.11345608f, 0.18461739f, -0.08324242f, -0.07146651f, 0.13174844f, -0.06669492f, 
    -0.12821117f, -0.17515379f, -0.17357652f, 0.06016037f, -0.03265049f, 0.16960168f, 0.12104056f, 0.00538138f, 
    0.03027446f, 0.03265719f, -0.02258617f, -0.01689151f, 0.02983075f, -0.01312106f, 0.00994804f, 0.00733734f, 
    -0.01921879f, -0.02344139f, 0.03755669f, -0.04559283f, 0.00739028f, 0.05638251f, 0.04537213f, -0.05466644f, 
    0.02297430f, 0.01370600f, 0.04141096f, -0.01017326f, -0.02856233f, -0.04637476f, 0.04332767f, -0.01784034f, 
    0.04122992f, -0.02952179f, 0.00867521f, -0.02454096f, 0.01509549f, -0.00828383f, 0.00186781f, -0.01203196f, 
    0.02403610f, 0.05739549f, -0.00590160f, 0.00251541f, -0.03755707f, 0.01023818f, -0.04090681f, -0.06037915f, 
    0.01040805f, -0.02786552f, 0.00295781f, 0.03082171f, -0.05522847f, -0.03611945f, 0.04446603f, -0.01929127f, 
    0.04464516f, -0.01740626f, 0.04807021f, -0.02132581f, -0.02073402f, 0.00168383f, 0.00653922f, -0.05913538f, 
    0.01014918f, -0.00528466f, 0.01166987f, 0.00299904f, -0.02848206f, -0.02041789f, -0.01345218f, -0.00874954f, 
    -0.04298618f, -0.03452418f, -0.00331700f, 0.02439360f, 0.03687765f, -0.00308414f, -0.01113925f, -0.03300557f, 
    -0.04120858f, -0.00685331f, -0.00450003f, -0.05255139f, 0.00825239f, 0.01323909f, 0.00093522f, 0.01257379f, 
    0.02219386f, -0.04031893f, -0.05043682f, 0.01679919f, -0.00712145f, -0.00056005f, -0.05143319f, -0.05223418f, 
    -0.03755423f, -0.00592206f, -0.04343192f, 0.01067418f, -0.00305354f, 0.02521372f, -0.00634579f, -0.01449455f, 
    -0.01788923f, -0.05624817f, 0.03334027f, -0.00787120f, -0.02101011f, 0.04936258f, -0.02467649f, 0.00697377f, 
    -0.04598191f, 0.02779720f, 0.02324865f, -0.05172623f, -0.03081169f, 0.04743499f, -0.03290998f, 0.01749097f, 
    0.05240659f, 0.00035399f, 0.04508110f, 0.01342716f, -0.00506077f, -0.02121766f, 0.00295438f, 0.03034010f, 
    -0.06154544f, -0.03303028f, 0.04221903f, 0.03690732f, 0.01033882f, -0.03294358f, 0.00050613f, -0.03310372f, 
    0.01993465f, 0.01095676f, -0.03017910f, -0.02464722f, -0.03952727f, 0.00871878f, -0.01594650f, -0.06081203f, 
    -0.03600514f, -0.01054180f, 0.01051741f, 0.01410874f, 0.00360022f, 0.03449785f, 0.01773799f, -0.02427011f, 
    0.02135252f, -0.04866825f, -0.01425356f, 0.03152525f, 0.00595003f, 0.04354949f, -0.02019162f, -0.03200643f, 
    -0.00557168f, 0.01932721f, -0.00341499f, -0.00119346f, 0.04176379f, -0.02808328f, 0.00825588f, 0.02985004f, 
    0.04758404f, -0.05105959f, -0.00957505f, 0.02947485f, 0.03784948f, 0.03386459f, 0.01777197f, -0.05845977f, 
    -0.00921788f, -0.05461917f, 0.03497298f, -0.04684851f, -0.01188602f, -0.06121184f, -0.05126465f, -0.02766048f, 
    -0.04362402f, -0.01098523f, -0.03203659f, 0.04683506f, -0.05194953f, 0.03994973f, 0.03764874f, 0.01982086f, 
    0.04185205f, -0.00201663f, 0.03154266f, -0.04491584f, 0.04128145f, -0.05090870f, 0.01591726f, 0.04807034f, 
    -0.02605966f, -0.02917028f, -0.05845686f, -0.04168953f, 0.04325030f, 0.01086039f, 0.02933964f, -0.01402393f, 
    -0.02082596f, 0.04748170f, -0.03696384f, 0.02272002f, -0.05018507f, 0.03118899f, -0.03256743f, 0.03453567f, 
    0.01754356f, -0.04989632f, -0.04821693f, 0.02468792f, -0.03292831f, 0.02172896f, 0.00662309f, 0.00663730f, 
    0.00863420f, -0.01247923f, 0.03984551f, 0.01018487f, -0.04341126f, -0.05511901f, -0.03662803f, -0.05870220f, 
    0.02883059f, 0.02355252f, -0.06054135f, -0.03518607f, -0.02882476f, 0.04512625f, -0.02841477f, 0.01228862f, 
    -0.02109033f, 0.00112929f, 0.00861689f, -0.01252825f, 0.01729382f, -0.04365164f, 0.00129778f, -0.04306663f, 
    -0.00854636f, 0.03591883f, -0.04737898f, 0.03931869f, 0.03316744f, 0.02391994f, -0.05344340f, -0.01462489f, 
    0.04227955f, 0.03775643f, 0.02028989f, 0.03376578f, 0.01836171f, -0.05401028f, -0.00005115f, -0.04259295f, 
    -0.05688813f, 0.04287848f, -0.02469702f, -0.05057043f, -0.00814584f, -0.03389177f, -0.05394772f, 0.03349391f, 
    0.02581896f, -0.03349231f, -0.00254869f, -0.04584193f, 0.03407203f, 0.00531592f, -0.05392458f, -0.02260239f, 
    -0.00396251f, 0.00927993f, -0.04789786f, 0.00705133f, 0.00925224f, -0.01663132f, 0.02806514f, 0.02302693f, 
    -0.02469682f, -0.02295561f, -0.03186859f, -0.04575265f, -0.03618507f, 0.03783389f, 0.04950691f, 0.04122410f, 
    -0.00086440f, 0.03280516f, 0.03880696f, 0.02506122f, -0.01011783f, 0.05924417f, 0.01858676f, -0.00293231f, 
    0.04540592f, 0.02307059f, -0.06037439f, -0.04929847f, 0.01628729f, -0.06159365f, -0.01030776f, -0.05799683f, 
    0.00808962f, 0.03313922f, -0.02538410f, -0.05687356f, -0.05287603f, -0.01813250f, -0.00821742f, -0.03122720f, 
    -0.04966598f, 0.01698299f, -0.04917478f, 0.04052620f, 0.00598315f, 0.04314631f, -0.02928760f, 0.02313386f, 
    -0.29374039f, 0.01140964f, -0.22644906f, -0.14065677f, 0.12146854f, 0.15864195f, 0.06698887f, -0.07156791f, 
    0.02320415f, -0.06004487f, 0.15539503f, 0.06221101f, 0.00197503f, 0.10290238f, -0.12060310f, -0.00229068f, 
    -0.05574907f, 0.00151441f, 0.20608659f, -0.02509861f, 0.13498220f, -0.16976604f, -0.09886768f, -0.04186609f, 
    0.00572476f, 0.05130357f, 0.00667191f, 0.03980675f, 0.09113804f, 0.07014256f, -0.00888424f, -0.00800072f, 
    -0.01466862f, 0.11601000f, 0.03888582f, 0.02789828f, 0.04535003f, -0.10512434f, -0.01384054f, -0.07714985f, 
    0.46867317f, -0.10785408f, 0.12231845f, 0.29066789f, -0.19662474f, 0.05506508f, -0.07448108f, 0.03095115f, 
    0.06655776f, 0.12695943f, 0.01748782f, 0.01961779f, 0.06980784f, -0.07178481f, 0.05837832f, -0.07523181f, 
    0.08124860f, -0.10773141f, 0.17299679f, -0.05164183f, -0.05391768f, -0.02279202f, 0.28973693f, -0.05785964f, 
    -0.08723298f, 0.10102455f, -0.04983658f, 0.01215247f, 0.10668366f, 0.00500770f, -0.05700413f, -0.00529981f, 
    0.19484401f, -0.00985668f, 0.02264478f, -0.02679204f, 0.12805751f, 0.05375129f, -0.05135074f, -0.11605936f, 
    0.10398833f, -0.02112563f, -0.29430160f, -0.08623224f, -0.04227296f, -0.05193724f, 0.09624407f, -0.06030587f, 
    0.00172611f, -0.05596573f, 0.00159884f, -0.02158774f, 0.11713381f, -0.05676603f, 0.09996238f, -0.01544193f, 
    0.05196277f, 0.28021508f, 0.22841407f, 0.07234109f, 0.09610046f, 0.18189311f, -0.27520561f, 0.05373929f, 
    0.17107776f, -0.01011005f, 0.13110334f, 0.13996892f, -0.01410707f, 0.12934472f, 0.03873914f, -0.07747199f, 
    0.12927140f, 0.02804372f, 0.12194185f, 0.15525649f, -0.04679319f, 0.07181323f, 0.24012598f, 0.02387940f, 
    0.11526522f, 0.57451379f, 0.29191089f, 0.09853527f, -0.27942392f, -0.15474540f, 0.08366967f, 0.08062822f, 
    -0.06271885f, 0.11277286f, -0.15194207f, -0.01164467f, -0.06877283f, -0.20071077f, -0.03301145f, -0.07085859f, 
    0.01427319f, 0.12555514f, -0.02247611f, 0.09260065f, 0.66114134f, 0.06943816f, 0.04881397f, -0.07275613f, 
    0.00802219f, -0.05300071f, 0.04312368f, -0.04513929f, -0.01153798f, -0.10269478f, 0.14090300f, 0.13626161f, 
    0.01812650f, -0.02098320f, -0.05519855f, 0.13761882f, 0.03890780f, -0.03309458f, -0.05511494f, -0.00686168f, 
    -0.25223657f, -0.05477448f, -0.04180996f, -0.13917525f, 0.11185704f, 0.08383603f, 0.00092367f, 0.08716839f, 
    -0.15691428f, -0.11795744f, 0.01686415f, -0.10888982f, -0.09077299f, 0.04967424f, 0.03503482f, -0.20332833f, 
    -0.04303266f, 0.27295905f, 0.19503027f, -0.00463873f, 0.09605323f, -0.03942567f, -0.05462560f, 0.18967755f, 
    -0.05922813f, 0.01266838f, -0.10925336f, 0.27592531f, 0.16429757f, 0.21938960f, 0.13644487f, 0.03640711f, 
    0.09518420f, 0.14575829f, -0.00202830f, 0.15946184f, -0.11716801f, -0.06753772f, -0.11716153f, 0.04694396f, 
    -0.20968436f, -0.24109773f, 0.21072528f, -0.20993100f, 0.28466502f, 0.12149698f, 0.08899567f, -0.09388105f, 
    -0.01917753f, 0.00585445f, 0.19349924f, 0.06296919f, -0.00548805f, 0.27724773f, 0.14889324f, 0.15869170f, 
    0.04881787f, 0.12063950f, -0.04795975f, 0.06746210f, 0.31340450f, 0.12681530f, 0.08847217f, 0.19247955f, 
    -0.11522254f, 0.10817640f, 0.00485117f, 0.02531934f, -0.08218343f, 0.08077202f, 0.01279110f, -0.01031464f, 
    0.07112183f, 0.03743941f, 0.06232132f, -0.06444127f, 0.04301734f, -0.21889511f, -0.06005828f, -0.19763866f, 
    0.14698574f, 0.20460221f, 0.26236698f, 0.13638292f, -0.17120938f, 0.04520495f, 0.08193319f, 0.26860517f, 
    0.05834926f, 0.03726159f, -0.03828958f, 0.14260054f, -0.10012774f, -0.04514269f, -0.14802808f, -0.09447230f, 
    -0.11868411f, -0.05106276f, -0.10448806f, -0.01853228f, -0.38989782f, -0.02130456f, -0.05154860f, -0.10491045f, 
    0.06600871f, 0.14490026f, -0.10810026f, 0.09352541f, 0.06498451f, 0.04263543f, -0.08037364f, 0.04198924f, 
    0.09779144f, 0.04753301f, 0.14327051f, -0.03131974f, -0.01407022f, 0.02032721f, -0.12417368f, -0.08941352f, 
    -0.20946057f, -0.06378215f, 0.07171253f, 0.11006115f, -0.17321871f, -0.00827955f, 0.05488828f, -0.10228380f, 
    0.06078904f, 0.15121426f, 0.05114832f, 0.14583866f, -0.08579157f, 0.06311351f, 0.13155846f, 0.00930662f, 
    -0.09108422f, 0.35581580f, 0.08285028f, 0.03712919f, 0.32103288f, -0.23153298f, -0.19679597f, 0.10471819f, 
    0.14357211f, -0.03400936f, 0.08725147f, 0.10348132f, -0.04671715f, 0.00619088f, 0.11201204f, -0.00535993f, 
    -0.05738112f, -0.07612310f, 0.08021950f, 0.00360803f, 0.01704181f, 0.10316844f, 0.21305804f, 0.04576692f, 
    0.25999728f, 0.13454407f, -0.02991013f, 0.21589331f, 0.02547005f, -0.00420353f, 0.10402085f, -0.08325879f, 
    0.15330806f, 0.11510416f, 0.06909047f, -0.15391508f, -0.04460795f, 0.10933249f, 0.10403849f, 0.11212888f, 
    -0.06366700f, 0.09585260f, 0.07655596f, 0.05605672f, 0.01538610f, 0.29401183f, 0.10653251f, -0.05750631f, 
    -0.06635263f, -0.07457286f, -0.01517323f, 0.07482146f, 0.01244830f, 0.00725850f, 0.09357741f, 0.09675155f, 
    -0.04170300f, -0.09315084f, 0.11035817f, 0.04957380f, 0.02066302f, 0.04749484f, 0.16363275f, 0.07123192f, 
    0.02524834f, 0.14753938f, -0.28406075f, 0.03666793f, 0.07058783f, 0.06576332f, -0.02156991f, 0.10628145f, 
    -0.09816298f, -0.01543895f, -0.06753559f, -0.01879911f, 0.03283953f, -0.01507457f, -0.00629364f, 0.03899822f, 
    -0.11928070f, 0.01614337f, -0.03800315f, -0.07356977f, 0.01146404f, 0.20138802f, 0.01066150f, -0.06384648f, 
    0.33689785f, -0.03708934f, 0.00246369f, -0.10863846f, -0.07929292f, 0.01693998f, 0.09974823f, 0.09667803f, 
    0.03522263f, 0.05884388f, -0.04852529f, -0.06894119f, -0.06791785f, -0.07560299f, -0.02274993f, -0.07494436f, 
    -0.12036274f, -0.30741587f, 0.19390564f, 0.26077017f, -0.20749895f, 0.00390797f, 0.08545527f, -0.06268025f, 
    -0.00686345f, 0.02724648f, -0.02356470f, 0.04008227f, 0.01497201f, 0.07278121f, -0.11762787f, -0.13769332f, 
    -0.02094712f, 0.01559396f, -0.15374984f, -0.08469194f, -0.00655566f, 0.01212197f, 0.06393473f, 0.21430777f, 
    0.07180929f, -0.03065785f, 0.06946117f, -0.01180927f, 0.21492071f, 0.07731162f, 0.15617348f, 0.08810882f, 
    -0.02926925f, 0.10147697f, -0.01524716f, -0.02546816f, -0.08265012f, 0.04885609f, 0.21643443f, 0.03218735f, 
    0.19933732f, -0.20082001f, 0.23798192f, 0.00872388f, 0.35368231f, -0.12206070f, -0.14425856f, 0.21134385f, 
    -0.01952700f, -0.03207318f, -0.06784246f, 0.02958176f, 0.10467560f, -0.02522216f, -0.01925201f, 0.04908809f, 
    -0.04725165f, 0.12023605f, 0.08373559f, -0.04063524f, 0.17786798f, -0.49691084f, 0.01419234f, -0.19719747f, 
    -0.38755044f, 0.00176210f, 0.04417168f, 0.09576791f, -0.02248960f, 0.07406719f, -0.02540257f, 0.09041030f, 
    0.03772497f, -0.09313597f, 0.01069541f, -0.12392105f, 0.02670619f, -0.01258305f, 0.13793509f, -0.09031425f, 
    0.35489821f, -0.27285567f, 0.12333871f, 0.07854161f, -0.34035480f, 0.03980481f, 0.10331415f, 0.05086606f, 
    0.06516575f, 0.02756503f, 0.05160575f, 0.01191326f, -0.01820220f, 0.02101115f, -0.03296880f, 0.03407623f, 
    -0.03833282f, -0.09740088f, -0.07241535f, -0.02179472f, 0.38226345f, 0.31912008f, 0.12143761f, 0.02376902f, 
    0.58885533f, -0.02734931f, -0.03283902f, 0.05596188f, 0.01367427f, 0.07465108f, -0.07580631f, -0.01723013f, 
    0.11914288f, 0.04753696f, 0.07440557f, 0.03944326f, 0.17808881f, 0.04620386f, 0.04927073f, -0.00068715f, 
    -0.03392633f, 0.02495738f, 0.13164480f, 0.19970395f, 0.03933633f, -0.07577536f, 0.00447097f, -0.07813492f, 
    0.15747967f, -0.08386855f, 0.15952553f, 0.03732584f, -0.10760742f, 0.06658966f, 0.06695089f, 0.01425120f, 
    0.05150500f, 0.03254157f, 0.02022286f, -0.02998705f, 0.04335035f, 0.15133621f, -0.08314592f, -0.13531789f, 
    -0.09166481f, 0.04104350f, -0.02610402f, 0.10736826f, -0.03158256f, -0.00071347f, 0.08392087f, 0.02077465f, 
    0.01038272f, 0.06143021f, -0.08330059f, 0.04436804f, -0.14466114f, -0.02256488f, 0.13356222f, 0.01913933f, 
    0.08563843f, 0.21263288f, -0.14615877f, -0.12157559f, 0.30701461f, -0.04760337f, 0.08189031f, 0.11818139f, 
    -0.21218389f, 0.02943108f, 0.00618480f, -0.09424905f, 0.12287997f, -0.01671219f, 0.11583941f, -0.02570572f, 
    0.01830614f, 0.02196628f, -0.06246302f, -0.01385255f, 0.17660284f, 0.16280816f, 0.12624550f, 0.07926023f, 
    0.07011311f, 0.09033129f, -0.02362035f, 0.05837005f, -0.00263934f, 0.05948744f, 0.13064928f, -0.00582540f, 
    0.02556367f, 0.00455666f, -0.09514990f, 0.09478614f, 0.10942665f, -0.10372897f, 0.04826829f, 0.10277466f, 
    -0.51647621f, -0.18491833f, 0.22418496f, -0.04380972f, -0.08953891f, 0.06314404f, -0.01693321f, 0.13814771f, 
    0.05822909f, 0.04227042f, -0.01642636f, -0.02156690f, 0.00382264f, -0.13168329f, 0.01702796f, -0.02143129f, 
    0.06200222f, -0.13996677f, 0.03892323f, -0.05752440f, 0.02857483f, -0.17581846f, -0.05161032f, 0.06212134f, 
    -0.44430158f, 0.10020985f, -0.01864607f, -0.03319401f, -0.02352466f, -0.00725546f, -0.01133184f, 0.09699902f, 
    0.02531439f, 0.03130613f, 0.02520350f, -0.08177308f, 0.12901892f, -0.00873811f, -0.08387210f, -0.01417118f, 
    0.03014983f, -0.05884804f, 0.00021582f, -0.02521105f, -0.02999898f, -0.01104056f, 0.04225716f, -0.04976485f, 
    0.03277459f, -0.01050706f, -0.00231286f, -0.05233569f, -0.04604923f, -0.00670559f, 0.02587003f, 0.01598285f, 
    -0.00026336f, -0.00530625f, 0.01770221f, 0.01620048f, -0.00760854f, -0.03665525f, -0.00920021f, 0.00439887f, 
    -0.03070023f, 0.02612358f, -0.05886141f, -0.00671421f, -0.01912229f, -0.04949194f, 0.04533144f, 0.03955334f, 
    -0.04535356f, 0.01665963f, -0.04445172f, -0.01473897f, -0.02389272f, -0.01028480f, -0.01607904f, 0.04295534f, 
    0.02161610f, -0.05720915f, -0.03123160f, -0.03950050f, 0.02996252f, 0.04509064f, 0.01465495f, 0.01547091f, 
    0.02827527f, -0.02028530f, 0.03445761f, -0.02332378f, -0.01013527f, 0.00215497f, -0.06579950f, -0.03800745f, 
    0.01904985f, -0.02286456f, 0.01117743f, -0.04506947f, -0.02548532f, -0.04924911f, -0.03142373f, 0.03281895f, 
    -0.05123339f, -0.01934159f, -0.05520405f, -0.02091669f, -0.03577858f, -0.00768806f, 0.03702379f, 0.04229246f, 
    0.01865706f, 0.01519177f, 0.00833875f, -0.03874964f, 0.03306948f, 0.00974860f, -0.03651295f, -0.00634753f, 
    0.02771232f, 0.02127104f, -0.03941449f, 0.02332265f, 0.04587566f, 0.00712630f, -0.03159538f, -0.04623835f, 
    -0.02737724f, -0.06063505f, 0.03857710f, -0.03860019f, -0.00990285f, 0.00839959f, -0.00637595f, 0.01078780f, 
    -0.00142098f, -0.03252756f, 0.01334123f, -0.03797898f, 0.01140407f, -0.03518828f, 0.02564559f, 0.00713744f, 
    0.03774026f, 0.01593254f, 0.04395639f, -0.03881053f, 0.04984384f, -0.04162537f, 0.02533378f, -0.04559992f, 
    -0.03341871f, 0.01369897f, -0.00510295f, -0.01229387f, 0.02059520f, 0.01518357f, 0.00175155f, 0.01259791f, 
    -0.05904165f, -0.02627875f, 0.03844575f, 0.04346698f, -0.01071941f, -0.02188245f, -0.01232538f, -0.04706533f, 
    -0.04205731f, -0.00811383f, -0.04337657f, 0.04162965f, -0.00749813f, -0.02910545f, -0.04652081f, -0.00352803f, 
    -0.03862192f, -0.02520413f, 0.01560300f, -0.00312054f, -0.03379382f, -0.06872967f, -0.04921610f, 0.00381965f, 
    -0.03517055f, -0.04377815f, -0.03120137f, -0.00570129f, -0.03113654f, -0.04775060f, -0.03913935f, -0.05742041f, 
    -0.02366040f, -0.03308989f, 0.02377165f, -0.02376952f, -0.03672569f, -0.01910929f, -0.05436905f, -0.01037413f, 
    -0.00466986f, 0.01082429f, 0.00831967f, -0.02603958f, 0.03620426f, -0.06231054f, 0.03482090f, 0.02458657f, 
    -0.01705720f, -0.04051472f, 0.00256519f, 0.03220008f, -0.02462730f, -0.05655579f, 0.02866575f, -0.02314998f, 
    0.02417666f, -0.02272362f, -0.02320129f, -0.05675295f, 0.00728218f, -0.00276745f, 0.03202022f, -0.00326938f, 
    0.02322602f, -0.00239888f, -0.00700717f, -0.00209396f, -0.00013397f, -0.02894572f, -0.02219420f, 0.04272780f, 
    -0.04095275f, 0.01282374f, 0.04208983f, 0.01968633f, 0.03764270f, 0.00049353f, 0.01853536f, -0.02939438f, 
    0.03192416f, -0.02690968f, -0.04905167f, -0.04677634f, 0.03998407f, -0.02020905f, 0.02477822f, 0.02682152f, 
    -0.05053085f, 0.04129012f, 0.05215688f, 0.04797392f, 0.00517651f, 0.01565482f, 0.00179595f, 0.01265344f, 
    0.02789500f, -0.05201324f, -0.02342296f, 0.01058343f, 0.02517718f, -0.04849583f, -0.04845585f, -0.05007332f, 
    -0.01138066f, 0.02636553f, -0.03618485f, -0.04715737f, -0.00895598f, -0.01752630f, -0.06017079f, 0.02927354f, 
    0.03974607f, -0.03447841f, 0.03796394f, 0.02434447f, 0.01556780f, 0.04011570f, -0.01966895f, -0.00248301f, 
    -0.02050496f, -0.05459695f, -0.00290969f, -0.00270153f, 0.05249123f, 0.01149410f, 0.02877782f, 0.00761528f, 
    -0.03417612f, 0.02354641f, 0.04885929f, 0.03288259f, 0.04609847f, 0.02911689f, -0.00930096f, -0.06287518f, 
    0.02668816f, 0.00529606f, -0.04451632f, 0.00356966f, 0.02228710f, 0.00805071f, -0.01267606f, -0.04258112f, 
    -0.00822216f, 0.03756091f, -0.05455832f, 0.03355485f, -0.04579934f, 0.01953874f, -0.03940232f, 0.04731635f, 
    -0.06513131f, 0.04784647f, -0.01387253f, 0.05181514f, -0.02090893f, -0.02247817f, -0.04161863f, -0.03626248f, 
    -0.00019272f, 0.03465791f, -0.02275060f, -0.00257081f, -0.04124459f, 0.00296922f, -0.00883046f, -0.01900101f, 
    -0.03797521f, 0.01603770f, 0.02832983f, -0.01125311f, 0.01663922f, -0.03292176f, 0.00115340f, 0.01356222f, 
    -0.01605599f, 0.01125813f, 0.03614707f, 0.01202235f, 0.00661829f, -0.03089323f, -0.01449860f, 0.04047969f, 
    -0.02312382f, -0.00052945f, 0.01197695f, 0.01437069f, -0.04306905f, 0.00748672f, 0.02243609f, 0.02294469f, 
    0.00152364f, 0.02987247f, -0.00074419f, 0.00253763f, 0.00774486f, -0.02909688f, 0.01948385f, -0.01947268f, 
    0.01502788f, -0.01850458f, -0.03889979f, 0.03892394f, 0.03339128f, 0.05537225f, -0.00917774f, -0.03454133f, 
    -0.05213819f, -0.05568552f, 0.01243363f, -0.05933917f, 0.01119071f, 0.00460575f, -0.05217073f, -0.06098498f, 
    0.01447562f, -0.03770084f, 0.00392850f, -0.02174416f, -0.00779164f, 0.02534774f, -0.05920475f, 0.02775989f, 
    -0.03760936f, -0.00877194f, -0.03208642f, -0.01205153f, -0.01562593f, -0.03017753f, 0.01677647f, -0.01024924f, 
    -0.00002728f, -0.01258065f, -0.01363244f, 0.00059189f, -0.04518383f, -0.03019981f, -0.00298785f, -0.02585861f, 
    0.01159566f, 0.04338186f, -0.03998231f, 0.01025494f, -0.04901627f, -0.05420751f, 0.00926767f, -0.00442029f, 
    0.00469735f, -0.05167199f, 0.04746104f, 0.02233212f, 0.04668038f, 0.04464492f, -0.00639368f, 0.03415768f, 
    0.02990889f, 0.03501176f, 0.00533347f, 0.00546354f, -0.01975936f, -0.05853658f, -0.05624200f, 0.04050671f, 
    -0.02199900f, 0.03851807f, -0.02032420f, -0.00314985f, 0.04960585f, -0.01880851f, 0.03359475f, -0.00659670f, 
    0.04218571f, -0.02110218f, 0.04110545f, 0.01717673f, -0.04905518f, -0.02599746f, -0.02421292f, -0.04066516f, 
    0.05020393f, 0.01025648f, -0.03180667f, -0.05760573f, -0.02567783f, 0.03022604f, -0.04246003f, -0.03741555f, 
    -0.00376740f, -0.02396784f, -0.02775537f, -0.06061471f, 0.03117296f, -0.01931351f, -0.05702827f, 0.04874917f, 
    -0.04702912f, -0.01385452f, 0.04985633f, -0.03997134f, 0.00640514f, -0.05543276f, 0.02510536f, 0.04341011f, 
    0.03085413f, 0.00518390f, -0.04958721f, -0.06008169f, -0.01202699f, -0.04595808f, 0.00009287f, 0.03791501f, 
    0.00654992f, 0.03087840f, 0.01317134f, -0.01774134f, 0.04654583f, -0.03380720f, 0.00740839f, -0.06014225f, 
    0.03479075f, 0.05429538f, -0.05656103f, -0.03828463f, -0.03064560f, -0.00031668f, 0.02232658f, 0.03174460f, 
    -0.00006474f, -0.01997214f, -0.04173803f, -0.03299156f, 0.03962724f, -0.00491181f, -0.03944463f, 0.00825224f, 
    -0.02082452f, -0.05873305f, 0.01282868f, -0.03258263f, -0.02118210f, 0.01495026f, 0.01538026f, -0.01785927f, 
    -0.00243596f, 0.03348906f, 0.00053334f, 0.00949781f, -0.02628038f, 0.00300373f, 0.00034715f, 0.03334438f, 
    0.03153669f, 0.03103540f, 0.01339528f, 0.05044524f, 0.01239734f, -0.05815322f, -0.00798699f, 0.01192705f, 
    0.04644339f, -0.01253038f, 0.04694420f, -0.02436681f, 0.02566216f, -0.01090270f, -0.00969979f, 0.00608462f, 
    0.00466361f, 0.01664586f, 0.02182755f, 0.00258488f, 0.03916706f, -0.02179029f, -0.03039710f, 0.01201521f, 
    0.04247797f, -0.01438165f, 0.04246335f, -0.02187824f, -0.00510674f, -0.04020769f, 0.04621372f, -0.05257832f, 
    -0.00982126f, 0.03685695f, -0.05172569f, -0.00298031f, -0.01033836f, -0.05343906f, -0.06055164f, -0.03296528f, 
    -0.05184495f, 0.02864281f, 0.04276096f, -0.00419440f, -0.00042825f, -0.03025926f, 0.02793885f, -0.05531028f, 
    -0.04005556f, -0.04313466f, 0.04838084f, -0.04162513f, 0.00031302f, -0.05087904f, 0.01895641f, 0.01306188f, 
    -0.01475879f, -0.03982104f, 0.01135355f, -0.03664104f, -0.00536157f, 0.01092929f, -0.04154110f, -0.01934890f, 
    -0.04745285f, -0.04042343f, 0.02073077f, -0.01463556f, 0.01068554f, -0.02350296f, -0.00822119f, -0.02106396f, 
    0.04910780f, -0.03837196f, -0.02888754f, -0.02001109f, 0.04069882f, -0.02641325f, 0.01789074f, -0.00228547f, 
    -0.04886033f, -0.03403091f, -0.05099170f, -0.03206869f, -0.03413842f, -0.01572360f, 0.01641452f, 0.04579141f, 
    0.01628845f, 0.03323442f, 0.04699343f, 0.03590832f, 0.01681682f, -0.03180137f, -0.00091628f, 0.04294154f, 
    -0.05797438f, -0.05370145f, -0.04849382f, -0.05951129f, -0.02099747f, 0.04398723f, -0.05624145f, -0.02089814f, 
    0.03363273f, -0.00442561f, -0.03512029f, -0.05594415f, 0.04338689f, 0.02044706f, -0.02929826f, -0.04970980f, 
    -0.05962136f, -0.00411443f, -0.00089196f, -0.05639912f, 0.02403807f, -0.01147367f, 0.04382009f, 0.03506855f, 
    -0.01040384f, -0.05027083f, -0.00538381f, -0.04956866f, -0.00451497f, 0.00871050f, -0.04753887f, -0.04459004f, 
    -0.02064802f, 0.04398469f, -0.01741000f, 0.03851397f, -0.01627049f, -0.05938270f, 0.00733790f, -0.02244540f, 
    0.01005088f, -0.05101964f, -0.02152389f, -0.02279177f, 0.03097855f, 0.03834892f, -0.06044335f, -0.01323141f, 
    -0.05054549f, -0.04397546f, -0.04471390f, -0.02522803f, -0.03192225f, -0.03534931f, 0.02005194f, 0.00564154f, 
    -0.05930505f, -0.00186597f, -0.04306904f, -0.04996787f, 0.02584739f, 0.01518939f, -0.00355368f, 0.00999246f, 
    0.03537806f, -0.00525670f, 0.04384990f, -0.03355918f, 0.00954557f, 0.02811961f, -0.03405450f, 0.03477194f, 
    -0.04609466f, 0.03623647f, 0.00202304f, 0.02006108f, 0.05167766f, 0.00230763f, -0.04826986f, -0.06013845f, 
    0.04267608f, -0.03473812f, -0.05839336f, -0.06358845f, -0.05232926f, 0.03662451f, -0.00983065f, 0.02397869f, 
    0.02458466f, -0.03182568f, 0.02329638f, -0.03814886f, -0.00736610f, -0.01410947f, 0.00366428f, 0.01894957f, 
    -0.01190951f, -0.02541091f, -0.04794999f, -0.02487523f, 0.00692259f, 0.01450746f, -0.04505973f, -0.03328633f, 
    0.03744568f, 0.00301029f, -0.00211360f, 0.00210951f, 0.04824836f, -0.05315321f, 0.00556418f, -0.05608927f, 
    0.03675699f, -0.02071896f, 0.03850956f, -0.03575299f, -0.02777920f, 0.03112013f, -0.00202114f, -0.03146384f, 
    0.03936595f, -0.00165770f, -0.01914771f, -0.04545482f, 0.02915534f, -0.05548974f, -0.02842035f, 0.01044299f, 
    -0.04657486f, -0.03628654f, 0.03571014f, 0.01208944f, 0.02216121f, 0.02086901f, -0.00673446f, 0.04254058f, 
    -0.05095235f, -0.00002520f, -0.00709142f, -0.02800378f, 0.02972690f, 0.01611500f, -0.00050202f, 0.01916516f, 
    0.02369015f, 0.03795296f, -0.02452101f, 0.00948832f, -0.01156063f, 0.01467415f, -0.05713371f, 0.02087194f, 
    -0.05676024f, 0.00460245f, -0.01389130f, -0.01474772f, -0.04792502f, -0.02939640f, 0.04385692f, 0.04299101f, 
    -0.02759635f, -0.00320179f, 0.02625064f, 0.02030513f, -0.06692018f, 0.03788563f, -0.02585173f, 0.04375362f, 
    -0.04601341f, -0.05901333f, -0.03201158f, 0.00453278f, -0.02375618f, -0.04864755f, -0.00971303f, 0.01963044f, 
    -0.02196699f, 0.04665741f, 0.03438780f, 0.02009352f, 0.00508420f, -0.02510999f, -0.02796290f, -0.01608570f, 
    -0.01636295f, 0.00282003f, 0.05877196f, -0.05284492f, -0.03449616f, 0.04654955f, 0.03741005f, -0.03544743f, 
    -0.01662829f, 0.05089811f, -0.03516129f, 0.01855921f, 0.05324133f, 0.00205495f, -0.00629979f, -0.04346680f, 
    -0.01534734f, 0.02014399f, -0.03616950f, 0.04710976f, 0.03810092f, -0.02017539f, -0.02441593f, 0.03667590f, 
    -0.01920902f, -0.01463237f, 0.02231000f, 0.03823677f, -0.01265498f, 0.00738074f, 0.01871688f, 0.04517375f, 
    0.01898485f, -0.00908504f, 0.01851908f, 0.02760526f, 0.00375269f, 0.00765521f, -0.01173858f, -0.04043210f, 
    -0.00795624f, -0.03879341f, 0.02481933f, -0.02765181f, -0.02585554f, -0.05256384f, 0.03100862f, -0.02322294f, 
    0.01027489f, -0.03130246f, -0.05520159f, -0.04269186f, 0.04311381f, 0.01383767f, -0.04058203f, 0.00721327f, 
    0.03761488f, -0.05237138f, -0.02478991f, 0.01819029f, -0.00392163f, -0.03489231f, 0.04351443f, -0.03125679f, 
    -0.04984067f, 0.00806623f, -0.01388513f, 0.03320178f, -0.04370306f, -0.00449656f, 0.02505258f, 0.03287594f, 
    0.03872857f, 0.03386312f, 0.01487436f, 0.00998607f, -0.05884631f, 0.01966043f, -0.04191410f, -0.02064075f, 
    -0.06100590f, 0.01982276f, 0.03124306f, 0.04283220f, -0.06642459f, -0.03052994f, 0.01274258f, 0.01816187f, 
    -0.00541734f, 0.02348554f, 0.01587349f, -0.01695864f, -0.04637786f, 0.01038703f, -0.00550543f, 0.01117182f, 
    0.03949171f, 0.00977365f, 0.00429333f, -0.04566642f, -0.03690906f, -0.03315403f, -0.06024080f, -0.03445988f, 
    0.01987957f, 0.05680761f, 0.04788708f, -0.01819198f, 0.00876088f, -0.02269366f, 0.03408020f, -0.02458951f, 
    -0.01653283f, -0.03453472f, -0.01765960f, -0.03386743f, -0.02201566f, -0.02028205f, 0.04199002f, -0.01709680f, 
    -0.00890459f, -0.00173832f, -0.03534083f, 0.04321876f, -0.05916069f, 0.03803649f, -0.03927014f, -0.03442430f, 
    -0.03509848f, -0.06766014f, 0.04153771f, 0.03594748f, -0.03361079f, -0.04434099f, -0.02887628f, -0.03449175f, 
    0.03582409f, -0.02122156f, -0.04578132f, 0.03936149f, -0.05133697f, 0.00228263f, -0.00153400f, 0.03903484f, 
    -0.03421851f, -0.03208521f, -0.03652512f, 0.03100132f, 0.01564945f, -0.02426352f, -0.05858971f, 0.03343070f, 
    0.02903329f, 0.03356767f, 0.03865556f, -0.00711416f, -0.04976626f, 0.01734037f, -0.05683499f, -0.01201079f, 
    -0.03471474f, -0.03485290f, -0.03098484f, -0.06081395f, 0.04188964f, 0.00614855f, -0.00002551f, 0.01169657f, 
    -0.05678919f, 0.03024594f, 0.03668911f, 0.00852444f, -0.04595967f, -0.06219774f, 0.01718088f, -0.04931413f, 
    -0.03817886f, -0.03991124f, -0.04849709f, -0.00938604f, 0.03436240f, -0.04767482f, 0.04645567f, 0.01746513f, 
    0.00494327f, -0.05843334f, -0.01575009f, -0.03496372f, -0.02142671f, -0.01303235f, -0.02305838f, 0.05170231f, 
    -0.00214270f, 0.03984133f, -0.00102633f, -0.04211481f, 0.02150503f, 0.04003305f, -0.01671460f, -0.01685395f, 
    -0.06274152f, -0.05402653f, -0.06433403f, -0.03458610f, 0.04416338f, -0.02327206f, -0.02862466f, 0.00946781f, 
    -0.01443409f, -0.00282290f, 0.03331264f, 0.04723900f, 0.01579463f, -0.03990410f, -0.02659784f, 0.01074008f, 
    0.02368879f, 0.00009514f, -0.05501077f, -0.04335183f, -0.04675209f, 0.04784862f, 0.01818592f, -0.05072559f, 
    0.04459154f, -0.05980096f, -0.03123476f, 0.01938772f, 0.00255616f, 0.03666708f, -0.02552378f, -0.04481853f, 
    0.00256738f, -0.00430715f, 0.03743701f, -0.01766117f, -0.05650438f, -0.00114573f, 0.04777403f, -0.05510788f, 
    0.00301358f, 0.03670882f, -0.02472363f, 0.03208036f, 0.00517408f, -0.00164443f, -0.05646629f, 0.01342515f, 
    0.04255414f, -0.01978746f, -0.00788088f, 0.01238072f, -0.02076015f, -0.02268737f, -0.02318047f, 0.00765827f, 
    -0.01740209f, -0.01545070f, -0.03160432f, 0.04528698f, -0.04290280f, 0.03291202f, -0.05574427f, 0.00896991f, 
    -0.01314968f, -0.02152824f, -0.03314138f, -0.01364189f, -0.05537048f, 0.01977243f, -0.04753581f, 0.00262444f, 
    -0.04093788f, 0.03482374f, -0.03860231f, -0.03614492f, 0.00378146f, -0.05425161f, -0.06010110f, -0.04058605f, 
    -0.06534203f, 0.00424269f, 0.04120502f, -0.04135594f, 0.01497198f, -0.04148328f, -0.04819482f, -0.05542236f, 
    0.03908442f, 0.04464676f, -0.05174863f, -0.00201698f, 0.03241261f, -0.01134175f, -0.04396142f, -0.05966406f, 
    -0.06038079f, 0.00746776f, 0.02834980f, -0.04834388f, -0.02734425f, 0.02442617f, 0.01580231f, -0.01783288f, 
    0.03945681f, -0.04594241f, 0.03132768f, -0.02647207f, -0.05226918f, -0.02365714f, -0.00182024f, -0.05664145f, 
    -0.02437361f, 0.01552114f, -0.02011497f, 0.03184004f, -0.01193741f, -0.04010735f, -0.00087967f, 0.04023737f, 
    -0.04069833f, -0.05595027f, -0.03112901f, 0.00323745f, -0.00756409f, -0.00021855f, 0.04573384f, 0.00794235f, 
    0.00855498f, 0.04139039f, 0.02291499f, 0.04179257f, -0.02430158f, 0.00356128f, 0.04194775f, 0.01815589f, 
    -0.03919021f, -0.00519934f, 0.04933726f, 0.03897331f, 0.04133776f, 0.04466590f, 0.01689598f, 0.04562320f, 
    0.01810580f, 0.02627449f, 0.01121617f, -0.04534872f, 0.03655735f, 0.04823630f, 0.02600147f, 0.02523416f, 
    0.03156878f, -0.04465378f, -0.00816043f, -0.03615250f, 0.04948824f, -0.00836497f, 0.03016847f, -0.02516003f, 
    -0.04778945f, 0.04866540f, 0.03710676f, -0.06171719f, -0.03648101f, 0.01273859f, -0.03145643f, -0.00724132f, 
    -0.01339745f, 0.02737859f, -0.02073430f, -0.03222201f, -0.05590368f, 0.03541844f, -0.01218500f, -0.00028758f, 
    -0.06449525f, 0.01094939f, -0.04979020f, 0.00231946f, -0.01468841f, 0.00305965f, 0.01416347f, 0.05364823f, 
    -0.03515178f, -0.03527600f, -0.05481215f, -0.04831974f, 0.00189504f, -0.02786626f, 0.04779140f, -0.04321669f, 
    0.03224005f, 0.00479633f, 0.03595113f, -0.03392499f, -0.01989619f, 0.00094716f, 0.00377734f, -0.04471222f, 
    -0.05345247f, 0.03258084f, -0.00511111f, -0.04637007f, 0.02503046f, -0.04066759f, -0.04966803f, -0.01488202f, 
    -0.03817071f, 0.02682959f, -0.06441537f, -0.03466306f, -0.02373137f, 0.03829142f, -0.02486417f, 0.04282912f, 
    -0.02756894f, -0.01369683f, -0.03485654f, 0.01567923f, 0.01433392f, 0.00013486f, -0.03855086f, -0.03199277f, 
    0.03018686f, 0.03599201f, -0.03123667f, -0.03297800f, 0.05252000f, -0.01905796f, 0.01534408f, -0.04593397f, 
    0.04151779f, 0.02663406f, -0.00542456f, 0.03945133f, -0.01407000f, 0.03844187f, -0.05054661f, 0.04860782f, 
    -0.05931550f, -0.05956363f, -0.00796835f, -0.02343375f, 0.03597584f, 0.03159813f, 0.01110838f, 0.04150850f, 
    0.01981647f, 0.04615693f, -0.06040427f, 0.02881973f, 0.00213626f, -0.02294820f, 0.01935581f, -0.04605195f, 
    -0.02716042f, 0.00951352f, -0.05764119f, 0.02029089f, -0.02180721f, -0.01956911f, -0.01230095f, -0.02147084f, 
    -0.03471496f, 0.00496193f, 0.01239515f, -0.04034149f, -0.03177623f, 0.05036755f, 0.04851736f, 0.03554707f, 
    0.04319923f, 0.01464045f, -0.05327565f, -0.05937156f, 0.03002247f, 0.02181130f, -0.04863209f, -0.06064197f, 
    -0.04897645f, 0.03127397f, -0.04741381f, -0.01072227f, 0.02282786f, 0.00332692f, -0.04663927f, -0.00186820f, 
    -0.01652011f, -0.03020938f, -0.03055991f, 0.05930459f, -0.02682960f, 0.02500664f, 0.02572233f, 0.03786930f, 
    -0.05384792f, -0.01140441f, 0.00179595f, -0.00364075f, -0.03559349f, 0.01260989f, 0.02167811f, 0.02106166f, 
    -0.00064709f, -0.04011589f, 0.01884518f, 0.02114544f, -0.04729721f, 0.00867849f, 0.00398359f, -0.03860570f, 
    -0.03220467f, -0.01332274f, 0.01817411f, -0.02722072f, 0.02450437f, 0.01047835f, -0.03584463f, -0.01958551f, 
    -0.01024094f, 0.01827656f, 0.03402815f, 0.05591667f, 0.01754443f, -0.00020867f, 0.00844979f, -0.03573165f, 
    0.05355733f, -0.17806268f, 0.00717679f, -0.06109710f, 0.01607674f, 0.09111787f, -0.02200196f, -0.02283432f, 
    0.00497910f, 0.03302161f, -0.01237664f, 0.16041790f, -0.09812462f, 0.02146561f, 0.02957671f, -0.06919188f, 
    -0.06116816f, 0.09969339f, 0.08851631f, 0.06793674f, 0.35401124f, -0.09932832f, -0.14322744f, -0.10022700f, 
    -0.04082340f, 0.04741027f, -0.17097779f, 0.03636423f, -0.00811984f, -0.07685994f, 0.08196469f, -0.00963477f, 
    0.00027009f, -0.05028341f, -0.01898268f, -0.03886231f, 0.08235271f, -0.07682165f, 0.02919485f, 0.03565041f, 
    0.15465367f, -0.12568316f, 0.33948398f, 0.12990157f, 0.03877452f, 0.12997848f, -0.01326434f, 0.05279653f, 
    -0.07357311f, 0.03485794f, -0.07787857f, -0.03324027f, -0.08332749f, 0.10994468f, -0.01986713f, -0.01731946f, 
    0.01871617f, -0.09750441f, 0.08453183f, -0.04893594f, -0.41442573f, -0.04992172f, 0.20951800f, -0.09837262f, 
    -0.07646459f, -0.03909193f, 0.05001342f, -0.09993054f, 0.02082722f, -0.07079357f, -0.07246710f, -0.07472317f, 
    0.08323430f, -0.01559970f, 0.07263579f, -0.06391210f, 0.04496137f, -0.03476325f, 0.11493730f, 0.14305682f, 
    0.21000564f, 0.16553770f, 0.10815573f, 0.35363230f, 0.08877403f, -0.05513195f, 0.10490394f, 0.05526301f, 
    -0.02644333f, 0.06855167f, -0.00689701f, -0.00870848f, -0.07708797f, -0.05787121f, 0.04740229f, -0.01193056f, 
    0.08639362f, 0.14957759f, 0.10027958f, -0.01234030f, 0.35861200f, -0.36802509f, 0.27157682f, 0.10826722f, 
    0.22824505f, 0.24464640f, 0.05839804f, 0.19323573f, -0.00948144f, 0.01672891f, -0.12711293f, 0.01208403f, 
    0.09422204f, 0.04285929f, 0.04173207f, 0.02728745f, 0.09250418f, 0.09180244f, 0.03998037f, -0.03359862f, 
    -0.65397084f, -0.50051665f, -0.03821808f, 0.13182895f, 0.00552641f, -0.31520784f, 0.13890010f, -0.00937495f, 
    0.00793981f, -0.08291322f, -0.07113937f, -0.05205547f, -0.06409379f, -0.23971687f, -0.00066125f, -0.04508781f, 
    0.17261671f, -0.08554165f, 0.10155072f, 0.04231958f, 0.05251362f, 0.54088324f, 0.11285862f, -0.04721092f, 
    0.13682115f, 0.07165302f, 0.08713128f, -0.06538326f, 0.02926793f, -0.02158266f, 0.02383476f, 0.02639380f, 
    -0.00524966f, -0.09688903f, 0.10501155f, -0.09462629f, -0.04649114f, -0.04452340f, -0.07354657f, -0.00044745f, 
    0.01706947f, 0.16286351f, 0.05641883f, 0.12796123f, 0.20761755f, 0.00105434f, 0.06416725f, -0.01084929f, 
    -0.06150856f, 0.01309343f, -0.07496074f, 0.00016697f, -0.00660732f, 0.02022957f, -0.04418879f, -0.12748662f, 
    -0.07472018f, 0.11890453f, -0.05347158f, -0.03618772f, -0.22198986f, -0.18130796f, 0.00685853f, -0.01661461f, 
    -0.16665684f, -0.18540257f, -0.07940503f, 0.09438777f, 0.04592415f, -0.01447561f, 0.02899086f, -0.10904328f, 
    0.00140082f, -0.03436625f, -0.05366595f, 0.19003062f, 0.06328336f, -0.05027763f, 0.05461714f, 0.04870909f, 
    -0.40552875f, 0.10177917f, 0.01617849f, 0.07138692f, 0.04953250f, 0.03652260f, -0.01954292f, 0.06176689f, 
    0.12324875f, 0.11478575f, -0.02864304f, 0.05311609f, 0.03443021f, 0.00914556f, 0.06947292f, 0.01804190f, 
    0.09086128f, 0.06585592f, 0.13319352f, 0.04262628f, -0.11203954f, -0.19548377f, -0.00935676f, 0.00091002f, 
    -0.15134400f, -0.06064791f, -0.03700164f, -0.01914196f, -0.00819016f, -0.25103244f, -0.07025279f, -0.02044252f, 
    -0.02392467f, 0.04994795f, 0.05734479f, 0.10522728f, 0.04971674f, -0.01506183f, 0.06519677f, 0.02595342f, 
    -0.24102430f, -0.11173395f, 0.22148125f, -0.08327343f, -0.15422904f, 0.10866556f, -0.00310114f, 0.06003312f, 
    0.11749627f, -0.08260276f, 0.02377938f, 0.04396868f, -0.06337874f, 0.11914025f, -0.16502967f, -0.00174623f, 
    -0.04890407f, -0.04051937f, 0.05391676f, 0.06917614f, -0.14890856f, 0.07674661f, -0.04879846f, -0.02337893f, 
    -0.01332672f, 0.02547534f, 0.02455288f, 0.18854964f, 0.04639866f, 0.05657778f, -0.07477998f, -0.03994570f, 
    0.07506589f, 0.04683556f, 0.14028871f, 0.04628913f, -0.12163822f, 0.06051856f, 0.01552013f, 0.04810624f, 
    0.37991899f, 0.16759367f, 0.13907743f, 0.18447813f, 0.07266822f, 0.02555600f, 0.11113486f, -0.10832725f, 
    0.07014155f, 0.08561181f, 0.06681501f, -0.02374954f, 0.07390480f, -0.02140878f, 0.03723369f, 0.12555605f, 
    0.05715708f, 0.09478066f, 0.02498324f, 0.06882412f, -0.05006208f, 0.05816941f, 0.19544072f, 0.29512131f, 
    0.07105906f, 0.17714919f, 0.10683925f, 0.04255388f, -0.10707949f, 0.02943236f, 0.09739371f, -0.08315688f, 
    0.07039376f, -0.08020914f, -0.04985243f, 0.13297027f, 0.01131879f, 0.09994595f, 0.09366082f, -0.04105666f, 
    -0.54672951f, -0.17631862f, 0.09428663f, -0.20832603f, 0.01097330f, 0.07187989f, 0.01728468f, 0.16179770f, 
    0.01244089f, -0.23526923f, 0.02048680f, 0.11876631f, -0.01088231f, -0.11648710f, -0.07293613f, 0.06279655f, 
    0.02386136f, -0.05291788f, -0.08676305f, 0.07717268f, -0.29627258f, -0.27472147f, 0.22464363f, 0.30381939f, 
    -0.04432013f, 0.00732318f, 0.01908734f, -0.01688405f, -0.12056508f, 0.01846041f, -0.08926931f, -0.08362331f, 
    0.00308178f, -0.00638550f, -0.04409008f, 0.06188346f, -0.01747692f, 0.11156204f, 0.02131505f, 0.01357288f, 
    0.02136133f, -0.21305464f, 0.13798316f, -0.04672215f, 0.04749578f, -0.06115862f, -0.00552949f, -0.05090097f, 
    0.07094575f, 0.06518120f, 0.09537419f, 0.09651674f, 0.10050445f, -0.02713969f, 0.00438642f, -0.02522539f, 
    -0.01521038f, 0.12849171f, 0.11026016f, 0.10497342f, 0.27479982f, -0.27412897f, -0.09611500f, 0.13623741f, 
    -0.09487659f, 0.00953817f, 0.00833184f, 0.09275256f, 0.09313697f, -0.04342886f, 0.04799540f, 0.02071116f, 
    -0.04520144f, -0.08686014f, 0.06216112f, 0.10346293f, 0.06030606f, 0.10982032f, 0.04674809f, 0.06687414f, 
    -0.00799344f, 0.19949058f, -0.10947745f, -0.16053560f, 0.20623663f, 0.18940276f, -0.15396921f, 0.02248306f, 
    -0.02637914f, 0.03541242f, 0.07464483f, 0.01257871f, 0.04541738f, 0.04928851f, 0.12549712f, 0.00372177f, 
    -0.03045940f, 0.03765873f, -0.10640695f, 0.00931881f, -0.12310424f, 0.30209130f, -0.00728110f, -0.12974523f, 
    -0.13336414f, 0.14947125f, 0.08396588f, 0.13661599f, -0.11314706f, -0.05557209f, -0.05262770f, -0.01713424f, 
    -0.20762800f, -0.14236055f, -0.02386085f, 0.12772952f, -0.01128942f, 0.03748856f, -0.21159968f, 0.12799640f, 
    0.10746430f, 0.37769938f, -0.19546634f, 0.06461869f, -0.14275360f, 0.16451918f, 0.01893773f, -0.13547838f, 
    0.12181007f, 0.12903988f, -0.03026140f, -0.10211755f, 0.01074193f, 0.23424055f, 0.02342125f, 0.07018894f, 
    0.02719679f, -0.10381404f, 0.01583768f, 0.07710354f, -0.31087059f, 0.04021031f, 0.25119227f, 0.41444618f, 
    0.22686778f, 0.05183928f, 0.06488972f, 0.10134852f, -0.03007262f, -0.01559970f, 0.04863216f, 0.07258264f, 
    0.00109049f, 0.00449818f, 0.13443519f, 0.00414497f, 0.07871950f, 0.17426898f, -0.07236569f, 0.05542644f, 
    -0.40677956f, 0.13458849f, 0.08012210f, 0.04056234f, 0.31561315f, -0.05208215f, -0.12715745f, 0.09159847f, 
    0.04788151f, 0.12625423f, -0.03254972f, 0.06286253f, 0.19952761f, 0.06981309f, 0.03130452f, 0.02036471f, 
    0.10891001f, -0.12182394f, 0.00959068f, 0.04705982f, -0.00747821f, 0.10430446f, 0.04874466f, 0.11748283f, 
    -0.39958581f, 0.07366531f, -0.04460037f, -0.07808334f, -0.06928106f, -0.13260201f, 0.04439232f, 0.04689511f, 
    -0.09241389f, -0.05433487f, 0.07173003f, 0.02135660f, -0.11141716f, 0.08297848f, 0.12947786f, -0.06337099f, 
    0.23456828f, 0.21086901f, -0.09353435f, -0.23302829f, -0.03708724f, 0.10413992f, 0.21910281f, 0.17027274f, 
    -0.13731731f, -0.02651929f, -0.05585049f, -0.00097393f, 0.06137073f, -0.10643048f, 0.03284181f, 0.09456866f, 
    0.12087857f, -0.20479177f, -0.01010652f, 0.09831966f, 0.10799344f, -0.12135210f, 0.12159780f, 0.13875915f, 
    0.22562419f, 0.10477518f, 0.05365168f, -0.04554432f, 0.00728182f, -0.02978262f, 0.11127034f, 0.01944450f, 
    0.02151363f, -0.00572466f, 0.02689602f, -0.04562483f, 0.01223761f, 0.05621446f, -0.13259514f, 0.09911583f, 
    -0.01477666f, -0.10513275f, 0.10460246f, 0.29243484f, -0.18972765f, -0.09942503f, -0.06270736f, -0.07775150f, 
    0.08666720f, 0.12996939f, 0.04388672f, 0.06056502f, -0.02026583f, -0.05471077f, 0.02805912f, 0.04568445f, 
    -0.12230214f, -0.06916821f, 0.14750220f, 0.00989405f, 0.12526245f, 0.06898122f, -0.00980090f, -0.04046698f, 
    0.06569913f, -0.01924548f, 0.08515851f, -0.01257724f, 0.04830555f, -0.16815363f, 0.01885845f, -0.08199228f, 
    -0.08136836f, -0.06153335f, 0.04890359f, -0.01827238f, -0.03322948f, 0.16331173f, -0.00269490f, -0.04239220f, 
    0.11295309f, 0.01353078f, 0.04412341f, -0.03106312f, 0.11875492f, -0.10745028f, 0.07273170f, 0.06966560f, 
    -0.15250599f, -0.00989570f, -0.06448707f, 0.08177297f, 0.10762892f, 0.20658471f, -0.04116534f, -0.02115864f, 
    0.01702567f, -0.02851886f, -0.06628837f, -0.07341672f, 0.29469991f, 0.00541374f, 0.25718737f, -0.09706543f, 
    0.31689209f, 0.06649500f, -0.11706813f, -0.01661921f, 0.16478638f, 0.05507709f, -0.04140906f, -0.08605476f, 
    0.02442461f, 0.15820816f, 0.10622629f, 0.12832792f, -0.15088427f, -0.04189304f, -0.13494270f, 0.07069010f, 
    0.10890184f, -0.17097393f, 0.41077653f, -0.17959101f, 0.15079558f, -0.16502337f, -0.04391252f, -0.00381250f, 
    -0.05620996f, 0.04665643f, 0.03898961f, -0.06225017f, -0.02174658f, 0.01061982f, 0.02774240f, -0.00358534f, 
    0.06513767f, 0.09390475f, 0.12323607f, -0.03903319f, 0.28459767f, 0.02780265f, -0.02189314f, -0.06511208f, 
    0.25218743f, -0.10966843f, -0.05312624f, -0.03182496f, 0.18120578f, -0.10798963f, -0.00191776f, 0.00180566f, 
    -0.01167921f, -0.05911188f, 0.02835421f, -0.02544971f, 0.01264955f, -0.00151609f, 0.00766664f, 0.03182597f, 
    -0.17279795f, 0.18285821f, -0.08605852f, 0.11238135f, 0.17093013f, 0.09235169f, 0.01490155f, 0.03601364f, 
    0.01131003f, -0.07439475f, -0.07596701f, 0.03619665f, -0.16328213f, 0.04248369f, 0.06953084f, 0.02268660f, 
    0.00566832f, -0.03378208f, -0.07786641f, 0.00252707f, 0.00431355f, 0.22368765f, -0.08270814f, -0.13008609f, 
    0.04045956f, 0.13528304f, 0.11193608f, -0.02443470f, -0.11863779f, -0.10462775f, -0.07196298f, 0.01790564f, 
    0.08673918f, -0.05822906f, -0.05274898f, -0.00331686f, 0.02591613f, -0.02259908f, 0.03768180f, 0.04321623f, 
    -0.23940174f, -0.01876359f, 0.08089165f, 0.01721925f, -0.04431077f, -0.04532807f, 0.19388755f, -0.02814993f, 
    -0.02459200f, -0.15712859f, 0.11012639f, 0.10678407f, -0.10810852f, 0.00468511f, -0.11808614f, 0.04821046f, 
    -0.00237079f, 0.02614034f, 0.07019805f, 0.04969160f, -0.02680483f, -0.38167897f, 0.40287215f, 0.00944228f, 
    0.28858170f, -0.03125120f, -0.03221579f, -0.04034195f, -0.07781389f, 0.13179915f, -0.06386060f, -0.02057775f, 
    0.04461290f, 0.05741981f, 0.14639123f, -0.03010010f, 0.10085522f, 0.05604618f, 0.02533144f, -0.06270888f, 
    -0.58554161f, -0.30335483f, -0.27664864f, 0.07651509f, 0.04769441f, 0.11542490f, 0.15040959f, -0.00900619f, 
    -0.07320748f, -0.06583290f, 0.13281146f, 0.17831293f, 0.09016228f, -0.06906463f, 0.02124250f, 0.02689265f, 
    0.01659497f, 0.04772316f, 0.10388204f, -0.04926139f, 0.44477254f, 0.11225012f, 0.01638705f, -0.19628626f, 
    -0.28416044f, 0.12056810f, 0.00551974f, -0.00160746f, 0.06070589f, 0.00682874f, 0.20674405f, 0.00418909f, 
    -0.04460316f, 0.05005652f, -0.03667064f, -0.05273006f, -0.04487579f, -0.01992670f, -0.00028519f, 0.00997111f, 
    0.19295113f, 0.31857497f, 0.03907427f, -0.33302733f, -0.20347290f, -0.04191397f, 0.05645638f, -0.06465623f, 
    -0.02260022f, -0.10962384f, 0.10797384f, -0.08205334f, 0.06110290f, 0.00210506f, -0.06078718f, -0.01051374f, 
    -0.00254456f, 0.01826130f, 0.00381988f, 0.04874132f, -0.12840036f, -0.07624961f, -0.19246730f, 0.05354099f, 
    -0.07518437f, 0.00176328f, -0.05834083f, -0.15948407f, -0.00431804f, -0.04488592f, 0.04870874f, -0.20753212f, 
    0.05341299f, 0.02611608f, 0.01912389f, -0.00928010f, -0.05540467f, 0.00075000f, 0.01213268f, -0.02468923f, 
    0.06606746f, 0.10308515f, 0.27635181f, -0.05922974f, 0.19926316f, -0.21532917f, -0.16665652f, 0.01101333f, 
    0.10463998f, 0.05872961f, 0.00976377f, -0.03277252f, 0.06149730f, 0.03147495f, 0.00842261f, 0.04372364f, 
    -0.02483975f, 0.12291110f, 0.09175159f, 0.00404565f, 0.25953233f, 0.14600325f, -0.03146607f, -0.06936283f, 
    0.16745669f, -0.03550990f, 0.09489267f, 0.00563134f, -0.01359331f, -0.13365629f, -0.00154135f, -0.04729210f, 
    0.06900824f, 0.02485960f, 0.03483347f, 0.07053816f, 0.16515562f, 0.02740001f, 0.03604053f, 0.00720348f, 
    -0.43067381f, 0.16649053f, -0.20721889f, 0.04396187f, 0.06309668f, 0.19485463f, 0.01558645f, -0.19224831f, 
    0.09424311f, -0.03435103f, 0.07055892f, 0.08618141f, 0.01307199f, -0.08414187f, -0.04537971f, -0.03024800f, 
    0.01590100f, 0.00999207f, 0.13356546f, 0.03737084f, 0.09735978f, 0.11431606f, 0.09589362f, -0.03884352f, 
    0.13249870f, -0.13063468f, -0.10045542f, -0.01473789f, 0.07185096f, 0.17516340f, -0.07155064f, -0.05206985f, 
    0.05175832f, -0.02996256f, 0.13802768f, 0.01576110f, 0.04498681f, 0.03375567f, 0.08826403f, 0.02355633f, 
    0.19665870f, 0.05872817f, -0.05810488f, -0.01938123f, -0.22638947f, 0.05926657f, 0.07596929f, -0.16211057f, 
    0.01583604f, -0.10836372f, 0.16342302f, 0.07460584f, 0.07888290f, -0.14658408f, 0.01269733f, 0.19571958f, 
    0.14606744f, -0.07280948f, 0.04086418f, -0.02641477f, 0.00744051f, 0.12284420f, -0.09618933f, -0.01442426f, 
    -0.09148011f, 0.01672776f, -0.00560988f, 0.08478484f, -0.09644818f, -0.08485858f, 0.03408951f, 0.07891693f, 
    -0.02810776f, -0.09761603f, -0.04770972f, 0.10522489f, 0.06018664f, 0.02874185f, -0.05307482f, -0.07756788f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.10984372f, 0.11115088f, -0.03951582f, 0.03328244f, 0.02494098f, 0.00746033f, 0.00828328f, 0.01179222f, 
    0.12892430f, -0.02985585f, 0.00275837f, 0.04913641f, 0.14633319f, 0.02456586f, 0.00388027f, -0.00261073f, 
    -0.02194657f, -0.00790832f, 0.04479598f, 0.01578998f, 0.02205518f, -0.07940151f, 0.03957362f, 0.00487578f, 
    0.03406378f, -0.05228634f, -0.05836780f, 0.03264787f, 0.00473813f, -0.10269475f, 0.12310120f, -0.00985086f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.33793601f, 0.07056615f, 0.07413146f, -0.23091936f, 0.52579713f, 0.01529755f, 0.10538581f, 0.36913428f, 
    0.11486614f, 0.17103237f, -0.20039280f, -0.17473756f, 0.32560146f, -0.00183488f, -0.11867253f, -0.09576953f, 
    -0.08320066f, -0.06193481f, -0.47417179f, 0.03855177f, 0.27822733f, 0.03194986f, 0.00783568f, -0.12436464f, 
    -0.06175878f, -0.09493961f, 0.16592555f, -0.12633759f, -0.01437897f, 0.03582405f, 0.19852023f, 0.12962829f, 
    -0.16248222f, 0.38331005f, -0.00350503f, -0.29136240f, -0.15285859f, 0.32618514f, -0.16223997f, -0.27896771f, 
    -0.01700218f, 0.02701433f, 0.09403643f, 0.00693745f, 0.05189278f, 0.32800823f, -0.12151513f, -0.13421397f, 
    0.11218686f, 0.04493979f, 0.11651260f, 0.14987206f, -0.01590916f, 0.24849075f, 0.12868480f, 0.19135597f, 
    0.29436895f, 0.10827485f, -0.14501891f, -0.13648438f, -0.02657748f, 0.36801535f, -0.40183491f, 0.32618597f, 
    0.05566014f, -0.15715717f, 0.08181567f, -0.09076972f, -0.15347531f, -0.01825999f, 0.05224408f, -0.06331878f, 
    -0.17504710f, 0.11449943f, -0.12465524f, 0.07622065f, -0.16383831f, 0.16883308f, -0.10180529f, 0.14899509f, 
    0.03618145f, 0.00920217f, -0.08256841f, 0.00139626f, 0.05199265f, -0.08283243f, 0.09033147f, -0.04206790f, 
    -0.17618124f, 0.02503173f, -0.13177104f, 0.14030106f, 0.12913138f, -0.17693070f, 0.10529493f, 0.06968926f, 
    0.06814520f, -0.09702576f, 0.11019498f, -0.43815339f, 0.48103279f, 0.53930509f, -0.03593092f, 0.17136072f, 
    0.37248340f, 0.05360394f, -0.09100583f, 0.12660182f, -0.13871504f, 0.22401743f, 0.05678660f, 0.15910992f, 
    -0.16932391f, 0.05959366f, 0.59982985f, 0.11251039f, -0.13292031f, 0.28437868f, 0.01224474f, 0.18539752f, 
    -0.20114125f, -0.05578664f, 0.13787699f, -0.00735969f, -0.17135789f, -0.22989304f, -0.25819936f, -0.20384358f, 
    -0.16410214f, 0.03327649f, -0.03751328f, -0.13040642f, -0.09405384f, 0.01564140f, -0.03148060f, -0.04592541f, 
    -0.14412346f, -0.11909926f, -0.18448041f, -0.11450556f, -0.15581161f, 0.09888198f, 0.03657211f, 0.15026973f, 
    0.12187407f, 0.05829197f, 0.17092066f, 0.04203175f, 0.02862984f, -0.18491802f, -0.07188635f, -0.05440894f, 
    0.09634006f, 0.08933056f, 0.07188922f, 0.08695132f, 0.07942181f, 0.07913306f, -0.07467306f, 0.11413237f, 
    0.33614990f, -0.46297631f, -0.06890365f, -0.61609262f, 0.00024910f, -0.28906170f, -0.09050808f, 0.33491242f, 
    0.12912562f, -0.08467394f, 0.26873994f, 0.09194320f, -0.63925493f, -0.37941074f, -0.05955379f, -0.06563008f, 
    0.06721444f, 0.00678102f, 0.06635844f, 0.08611122f, 0.06498356f, 0.08762235f, 0.13180038f, 0.03936527f, 
    0.16956924f, -0.16050875f, -0.04659541f, 0.11600375f, -0.15073951f, -0.05077985f, 0.03506600f, -0.24476020f, 
    -0.20626038f, 0.31046578f, 0.14578354f, 0.20022535f, 0.37982807f, 0.24332871f, -0.11512789f, 0.50181746f, 
    -0.12590587f, 0.06416396f, -0.11404940f, 0.09740410f, 0.20877126f, -0.39646283f, 0.37486851f, 0.12559935f, 
    0.08889610f, -0.12301121f, -0.01536112f, -0.01863584f, -0.02706307f, -0.05109818f, -0.10648017f, -0.00258889f, 
    0.03693312f, 0.02047731f, 0.04395818f, 0.02195164f, -0.06139431f, -0.57294065f, 0.40908429f, -0.20965001f, 
    -0.00265939f, -0.20840500f, 0.14298274f, -0.17416292f, -0.13759352f, -0.00153872f, 0.16623569f, -0.13640648f, 
    0.11656163f, -0.02830399f, -0.03385982f, 0.08968832f, -0.03119510f, -0.02032098f, -0.12693326f, -0.10739822f, 
    0.07227294f, 0.13044661f, 0.15610291f, -0.13834375f, -0.07611798f, -0.05117291f, -0.10948316f, 0.01388751f, 
    -0.09524954f, 0.03141755f, -0.17168561f, 0.07274848f, -0.03613438f, -0.08492792f, -0.13860257f, 0.14518529f, 
    0.24853982f, -0.15081365f, 0.01002206f, 0.41503638f, 0.31824285f, 0.31607050f, -0.13112482f, -0.21464400f, 
    0.15203825f, -0.15614027f, -0.14348260f, -0.05966369f, 0.12009088f, -0.27771157f, -0.17692339f, -0.14912912f, 
    -0.04130374f, -0.05477162f, 0.03661502f, 0.13729753f, 0.24283031f, -0.57149917f, -0.08899345f, 0.11245190f, 
    0.11303510f, -0.13176943f, 0.01377751f, -0.09789977f, -0.14532042f, 0.04922386f, -0.03211769f, -0.12623219f, 
    0.12738860f, 0.16174923f, 0.01523864f, 0.50181746f, 0.06212967f, -0.53661913f, 0.05374080f, 0.16925028f, 
    -0.12842350f, 0.09299792f, 0.15446465f, 0.02692002f, -0.08522137f, 0.06611253f, -0.20664768f, 0.01520380f, 
    0.00692753f, 0.14371647f, -0.19437121f, -0.07212589f, -0.10782277f, 0.19865772f, -0.06239103f, -0.01556205f, 
    -0.26240426f, 0.11865206f, 0.12899174f, 0.10313422f, 0.01205295f, 0.24002522f, 0.23386702f, 0.37729111f, 
    0.09097570f, 0.01869410f, -0.16164126f, 0.25424039f, 0.50256187f, 0.24241091f, 0.07739855f, 0.04399613f, 
    -0.31860733f, -0.07194889f, -0.20072891f, 0.12787765f, 0.19194734f, 0.14861031f, -0.21653987f, 0.07446273f, 
    -0.12736136f, -0.14555766f, -0.24276315f, 0.12609522f, 0.12310040f, 0.17063743f, 0.06936858f, 0.37122467f, 
    -0.06248714f, 0.08414915f, -0.01342542f, -0.14858234f, -0.16677403f, 0.20222451f, 0.14103964f, 0.33296627f, 
    -0.27256063f, 0.29705611f, -0.16370179f, 0.14736816f, -0.55384427f, -0.23906672f, -0.04736708f, 0.36271051f, 
    -0.31415182f, 0.01490392f, 0.20207475f, 0.12193308f, 0.12843513f, -0.11311777f, 0.22386888f, -0.00223975f, 
    0.12133715f, 0.17656912f, -0.37712163f, 0.02697967f, 0.02510592f, -0.23694079f, -0.02954640f, 0.19220454f, 
    0.37048653f, 0.03125419f, -0.05585094f, -0.08283328f, -0.09999691f, -0.39489108f, 0.00508154f, 0.27736011f, 
    0.37576213f, -0.41632336f, -0.13469474f, -0.04838352f, -0.05259926f, -0.39631215f, 0.15442123f, -0.31785253f, 
    0.30957153f, 0.03671270f, 0.22512792f, -0.04393373f, 0.06543308f, -0.61136079f, 0.07447618f, -0.12289184f, 
    0.09222508f, -0.01168254f, 0.43712044f, -0.00028241f, 0.44389245f, -0.20090157f, 0.02785483f, -0.34531885f, 
    0.21277325f, 0.07951804f, -0.07619186f, -0.05798972f, 0.10705500f, 0.18076244f, 0.25014508f, 0.11296726f, 
    0.04144741f, 0.02473477f, 0.02233821f, -0.15057249f, 0.01714044f, -0.03529684f, -0.10752664f, 0.08894921f, 
    -0.17279893f, 0.04351167f, -0.18519035f, 0.10014550f, -0.14813773f, 0.03481979f, -0.17923519f, 0.01549598f, 
    0.05322835f, -0.07845269f, -0.13559738f, -0.10897519f, -0.02016017f, -0.04668316f, 0.01871672f, -0.08850213f, 
    0.10377729f, -0.11610062f, -0.16000345f, 0.16454810f, 0.09289403f, -0.09661029f, 0.10327442f, -0.07589392f, 
    0.50172192f, -0.12288651f, -0.11499589f, -0.02605049f, -0.13076533f, 0.11682156f, -0.03596119f, -0.02113002f, 
    0.41045651f, 0.00965747f, 0.16327488f, -0.16946071f, -0.08469921f, -0.31676853f, 0.17039840f, -0.05257404f, 
    0.12729381f, -0.08211815f, -0.35427451f, -0.14907643f, -0.09835485f, -0.10612243f, -0.09399691f, 0.00105680f, 
    0.02340441f, 0.02526226f, -0.13607644f, -0.15807110f, 0.14161959f, 0.16149223f, 0.00349546f, -0.51122850f, 
    0.02322684f, -0.07229150f, -0.13906108f, -0.05522098f, 0.10133636f, 0.01828482f, 0.16761920f, -0.07899779f, 
    -0.20872803f, 0.08956340f, 0.01278559f, 0.10280861f, -0.11098529f, -0.09507367f, -0.08811659f, -0.00956473f, 
    0.14035234f, -0.05806326f, -0.14723451f, 0.13687474f, -0.01097359f, -0.19268399f, -0.15806469f, -0.17866760f, 
    -0.13651377f, -0.08464148f, 0.08364097f, 0.06739654f, -0.03687209f, -0.09349486f, -0.03602143f, -0.09398773f, 
    0.30098209f, 0.11301867f, 0.04229160f, -0.00671930f, 0.52506405f, 0.11661609f, -0.13286024f, 0.34615666f, 
    0.10895687f, -0.17050585f, -0.16193478f, 0.14311695f, -0.50714260f, -0.30031973f, -0.23995058f, 0.17309684f, 
    -0.17057525f, -0.07892302f, 0.11249311f, 0.03535265f, -0.05759046f, -0.02628415f, -0.16514422f, 0.10906271f, 
    0.22510237f, 0.02944613f, -0.17401588f, -0.16466762f, 0.10795266f, 0.14977871f, 0.05191757f, -0.04864261f, 
    -0.15033010f, -0.28585577f, -0.18398044f, 0.00710637f, 0.42515060f, -0.16818185f, 0.00610375f, -0.05874659f, 
    -0.47180662f, 0.04865681f, 0.13344845f, 0.13027476f, -0.00211471f, 0.60516119f, -0.08474839f, 0.16993029f, 
    0.02965465f, -0.12012500f, 0.21296230f, 0.03924254f, -0.03305995f, 0.48924243f, 0.07632523f, 0.29026905f, 
    -0.24407585f, -0.09939492f, 0.12816928f, -0.00686090f, 0.09573594f, 0.39214072f, 0.32747614f, 0.21475181f, 
    0.08385397f, -0.01655884f, 0.07135179f, 0.15766580f, -0.12087440f, 0.00499535f, 0.02478193f, -0.11969087f, 
    0.13999152f, 0.08258803f, -0.09635799f, 0.12429601f, -0.15414786f, -0.06796405f, -0.09343128f, 0.01467690f, 
    -0.08531070f, 0.12536287f, -0.02844881f, -0.16718815f, 0.06983504f, 0.11587700f, 0.05899902f, -0.05261652f, 
    -0.16113099f, -0.01790267f, 0.09885202f, -0.05648810f, 0.12700745f, -0.04274134f, -0.12700304f, -0.02125031f, 
    0.02037589f, -0.06765819f, -0.02869852f, -0.03162293f, -0.22396950f, 0.28406283f, 0.02676893f, 0.06939140f, 
    -0.00137424f, -0.00082842f, 0.32088235f, -0.03518913f, -0.43789881f, 0.16345888f, -0.17351781f, -0.07366052f, 
    -0.00550820f, -0.15865694f, -0.17612633f, -0.03911438f, -0.21061324f, 0.08797337f, -0.07772221f, 0.29253343f, 
    0.23215215f, -0.15385458f, -0.13262907f, 0.10169334f, -0.12916774f, 0.37294969f, -0.33857402f, 0.35190240f, 
    -0.09545181f, -0.18233027f, -0.11509468f, -0.20252632f, -0.07181080f, 0.07975796f, 0.06743062f, -0.05053693f, 
    0.10641746f, -0.03850559f, -0.03988583f, 0.10114162f, 0.17146668f, 0.13641429f, -0.18192635f, 0.01978544f, 
    -0.15984946f, -0.10145113f, -0.01744996f, -0.01884832f, -0.12551259f, -0.01852317f, 0.11616586f, -0.00654235f, 
    -0.14644949f, 0.00608447f, -0.08273521f, 0.15643333f, -0.01831951f, -0.07700443f, 0.13453130f, -0.04333083f, 
    0.11449893f, 0.11718552f, 0.01437766f, 0.66122216f, 0.32449433f, -0.18404871f, 0.01743605f, -0.03019294f, 
    0.36785501f, 0.06102592f, 0.09840250f, 0.17114688f, 0.06841460f, -0.02838242f, -0.21530800f, 0.01672962f, 
    0.04678426f, -0.06010000f, 0.25219756f, -0.08410925f, -0.17202823f, -0.23637947f, -0.06849133f, 0.29291320f, 
    -0.33226377f, 0.12142635f, 0.06389544f, -0.11724280f, -0.08304372f, -0.13516973f, 0.35409713f, -0.22991264f, 
    0.12129531f, 0.17997247f, 0.15897700f, -0.17959531f, -0.42106426f, -0.35073239f, -0.08666696f, 0.09439924f, 
    0.07004084f, -0.11978256f, 0.10075337f, 0.02748571f, 0.55745500f, 0.49328452f, 0.54319674f, -0.16408069f, 
    -0.13981582f, 0.05116662f, -0.29972416f, 0.05280928f, 0.29822701f, 0.13440634f, -0.08938261f, 0.08706744f, 
    0.12909596f, 0.10201676f, 0.02378141f, -0.05328150f, 0.01471746f, -0.34396556f, 0.10109171f, -0.11997488f, 
    0.03354853f, 0.02020571f, 0.13793029f, -0.03702753f, 0.07908344f, 0.10902034f, 0.12542751f, -0.17338037f, 
    -0.04569583f, -0.16960891f, -0.12986985f, 0.06484270f, 0.00531341f, -0.21598446f, -0.16316627f, 0.04261038f, 
    -0.06740505f, -0.10674667f, 0.05826432f, -0.11517555f, -0.03361335f, -0.14073595f, -0.10201780f, 0.02980316f, 
    -0.15401565f, 0.02532669f, 0.11469333f, 0.14036788f, 0.15642393f, 0.06068709f, 0.02335231f, 0.09303501f, 
    0.02374143f, -0.02174692f, 0.03352961f, 0.03140551f, -0.17688562f, 0.12280598f, -0.05616006f, 0.22567685f, 
    -0.35036537f, 0.02013327f, 0.15568705f, 0.10711750f, 0.24778453f, 0.10095438f, 0.04591567f, -0.02215353f, 
    -0.08761394f, -0.00952288f, -0.71698922f, -0.00787582f, -0.00055731f, 0.32538223f, 0.12063468f, 0.28365916f, 
    -0.26767454f, 0.11792967f, -0.11829761f, -0.04040641f, 0.04035407f, 0.30272710f, 0.07654651f, -0.23585191f, 
    0.29932839f, 0.22757848f, -0.04781948f, -0.04174802f, 0.11153342f, 0.45957133f, 0.10131823f, -0.21617077f, 
    0.05236094f, -0.11175688f, -0.14956640f, 0.16526617f, 0.11361524f, 0.36655754f, -0.00460234f, 0.04679545f, 
    -0.06433942f, -0.18229878f, -0.35308143f, -0.12288063f, 0.20896028f, -0.16724117f, -0.06523135f, -0.13327917f, 
    0.12934837f, -0.03636501f, 0.00354925f, -0.05076877f, 0.03832305f, -0.06139813f, -0.20380171f, 0.26249796f, 
    -0.10545208f, -0.07054387f, 0.08515596f, 0.22489212f, -0.29060325f, 0.41479266f, -0.12444005f, -0.26907840f, 
    -0.23922476f, -0.08590811f, 0.16152857f, -0.04000985f, -0.11296037f, -0.06910302f, 0.26838169f, 0.04630177f, 
    -0.00360088f, -0.03671519f, 0.37907228f, 0.06384708f, 0.13634019f, -0.00695188f, -0.03329099f, 0.15322824f, 
    0.25468639f, -0.06947636f, -0.08844541f, -0.15804641f, -0.04286778f, 0.18135822f, 0.12865274f, -0.47617093f, 
    -0.11757939f, 0.47471499f, -0.12394275f, 0.18032867f, -0.03279486f, 0.17690356f, 0.08020356f, -0.23889798f, 
    0.33264509f, -0.14568514f, 0.23041952f, 0.08783336f, 0.05369801f, -0.01573346f, -0.15672734f, 0.06116730f, 
    -0.05302247f, 0.06822874f, 0.28489831f, 0.12637407f, -0.38597545f, 0.57535565f, -0.02037354f, -0.30584285f, 
    -0.31964123f, 0.07109012f, -0.08760327f, 0.09302350f, -0.02111209f, 0.45749328f, 0.21032403f, 0.09825824f, 
    -0.03678104f, 0.23120575f, -0.02314585f, 0.00358004f, 0.57133526f, -0.21593133f, -0.16404508f, 0.24685064f, 
    0.06921766f, -0.05802555f, 0.12581000f, 0.02215530f, 0.33785179f, -0.34220636f, -0.23483042f, -0.11051931f, 
    0.13572855f, 0.07377046f, -0.01708463f, 0.09807923f, 0.05231430f, 0.22166003f, -0.07746863f, -0.22726889f, 
    0.09314073f, -0.09808418f, -0.11692832f, 0.02103338f, 0.05896483f, 0.12572005f, -0.19426934f, 0.63296962f, 
    0.03188760f, 0.53837305f, 0.00170743f, -0.27987108f, 0.16710444f, -0.08014197f, -0.16654183f, 0.40346387f, 
    0.39943880f, 0.08504345f, 0.09248976f, 0.16739284f, 0.22752364f, -0.22021620f, 0.07885691f, 0.09601598f, 
    -0.05466901f, -0.16862629f, -0.39175624f, 0.12104999f, -0.12480979f, 0.08392765f, -0.10243034f, -0.24416329f, 
    0.20697050f, 0.13831285f, -0.12369967f, -0.08525935f, 0.03435470f, -0.13968538f, -0.20670542f, 0.30997112f, 
    -0.04689176f, -0.09880531f, -0.17449170f, -0.04624288f, -0.14838956f, -0.12675503f, 0.05618017f, -0.06638677f, 
    -0.10622668f, 0.10626934f, -0.03377660f, 0.11432157f, -0.14738062f, -0.00630105f, 0.10645619f, 0.16087760f, 
    -0.07637428f, -0.16161332f, 0.12773339f, 0.13971157f, -0.11313616f, -0.03682668f, -0.11703501f, 0.08601660f, 
    0.06401726f, 0.07205309f, 0.14996956f, -0.02464655f, 0.15608633f, -0.16892236f, -0.10125221f, -0.02702291f, 
    0.25675088f, -0.25887671f, -0.11527047f, 0.14377761f, 0.01133379f, 0.41418669f, -0.01034681f, -0.17421553f, 
    0.06605918f, 0.05741524f, -0.01331229f, -0.17358157f, -0.42670253f, 0.63546014f, 0.14307414f, 0.10879543f, 
    0.12392307f, 0.06769598f, 0.08377712f, 0.12315421f, 0.42983398f, -0.34718040f, 0.14683512f, 0.49515823f, 
    0.37074584f, -0.08842444f, 0.02467115f, 0.15730700f, 0.02727338f, -0.09640842f, -0.09969211f, -0.31297916f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12589939f, -0.09912530f, 0.07681452f, 0.07086495f, 0.03503509f, -0.01850665f, 0.03325447f, 0.09620297f, 
    -0.03703666f, 0.05734913f, 0.06300208f, 0.14319795f, 0.14787234f, -0.11111566f, 0.16011979f, -0.02079722f, 
    -0.17944573f, -0.04133268f, -0.05240345f, 0.17028497f, -0.09096903f, 0.23281610f, 0.16884533f, -0.02679675f, 
    0.14327013f, 0.01430676f, -0.05624367f, 0.21572112f, 0.13011447f, 0.25245747f, -0.05610132f, 0.27147299f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.31840441f, -0.26345721f, 0.07669099f, 0.06641982f, -0.02971126f, 0.80286497f, -0.29097393f, 0.03298295f, 
    -0.16416885f, -0.06684730f, -0.53715634f, 0.05416546f, 0.33157328f, 0.10038944f, 0.28244171f, 0.05836713f, 
    0.25174454f, -0.23776627f, 0.01655604f, 0.18206006f, -0.03388750f, -0.10362973f, -0.02767591f, 0.14125638f, 
    -0.45324621f, -0.67625874f, 0.08086186f, -0.69937021f, -0.43143341f, -0.24503118f, -0.07690509f, 0.08240686f, 
    0.26100221f, -0.05143173f, 0.07016923f, -0.25298992f, -0.06370684f, 0.02155196f, 0.09966948f, -0.07728983f, 
    0.03754313f, -0.50279331f, -0.35054305f, -0.01568888f, 0.05938782f, 0.14546214f, 0.37736204f, -0.01485403f, 
    -0.20090221f, -0.74602073f, -0.09022436f, -0.29684228f, -0.16532327f, -0.36297098f, 0.27214682f, 0.06695907f, 
    0.08683022f, 0.47388250f, 0.07370454f, 0.14425907f, -0.31872490f, 0.14361134f, -0.07962456f, -0.01218627f, 
    -0.39674044f, 0.37073520f, -0.14614512f, -0.04836745f, -0.02011896f, -0.52784264f, 0.07716908f, -0.14652394f, 
    -0.62434977f, -0.23750807f, -0.03249874f, 0.53562379f, -0.35667443f, 0.17251888f, -0.35020834f, -0.18758217f, 
    -0.17852652f, -0.50530702f, 0.05173770f, 0.44685516f, 0.11322557f, -0.37336913f, 0.06192502f, 0.13140744f, 
    -0.05741503f, -0.10654149f, 0.01617375f, -0.67655891f, 0.16792455f, 0.24322551f, 0.15192500f, 0.08910432f, 
    0.24010102f, -0.01764617f, 0.11261216f, 0.22854364f, -0.14422277f, 0.39646411f, -0.42655122f, -0.11158231f, 
    -1.24461102f, -0.05673218f, 0.11993857f, -0.70003831f, 0.04731190f, -0.03038784f, 0.12335888f, 0.06922277f, 
    0.10487437f, 0.22812496f, -0.04295811f, 0.20280856f, -0.01172185f, -0.33614889f, -0.24281605f, 0.03556618f, 
    0.20210350f, -0.59937227f, -0.49367356f, 0.17250676f, 0.37174845f, 0.05767597f, 0.08515376f, -0.54792941f, 
    0.11978000f, 0.16753486f, 0.15256709f, 0.21663558f, -0.03105116f, -0.24856886f, -0.46452588f, 0.12624139f, 
    0.08049139f, -0.08469729f, 0.30363309f, -0.50987130f, -0.19637811f, -0.04751095f, -0.03147425f, 0.01865174f, 
    0.32534069f, 0.01422897f, 0.10100211f, 0.14360757f, -0.09921002f, 0.05551810f, -0.38534361f, -0.06356014f, 
    -0.20099933f, 0.65845203f, -0.15474565f, 0.00990464f, -0.08521144f, -0.12699576f, 0.07697432f, 0.20634040f, 
    0.11025848f, -0.60853630f, 0.04917192f, -0.26760018f, -0.00211869f, -0.11252867f, 0.26652730f, -0.14284191f, 
    0.47562164f, -0.04199721f, 0.30537233f, -0.29924950f, 0.30496138f, 0.02785310f, 0.07647758f, -0.07360804f, 
    0.02519565f, -0.00726762f, 0.03866247f, -0.44589472f, -0.15637197f, 0.32175690f, -0.21248531f, -0.09564898f, 
    0.00206921f, -0.09715210f, 0.25108024f, -0.54757118f, -0.14495805f, -0.49941140f, -0.10704955f, 0.05083289f, 
    0.09728643f, -0.27081510f, -0.09661637f, -0.35692778f, 0.01809151f, -0.34197643f, -0.21615657f, 0.03358442f, 
    -0.84981132f, 0.33348319f, 0.34188706f, 0.03881603f, -0.43222213f, 0.10300249f, -0.13820542f, 0.07437826f, 
    -0.35988683f, 0.36740443f, 0.10255881f, -0.01621038f, -0.03353019f, 0.15973005f, 0.24339455f, -0.00075047f, 
    0.46688032f, -0.08557452f, -0.26306584f, -0.34850621f, -0.33354586f, -0.25565472f, 0.16449590f, 0.01943180f, 
    -0.56665856f, 0.18440413f, -0.01261255f, -0.65161818f, -0.01572466f, -0.69037306f, -0.03370227f, -0.00277931f, 
    0.20528089f, 0.32467669f, 0.06898272f, 0.16101611f, -0.45642352f, 0.06696628f, -0.20399280f, 0.06277581f, 
    0.10682584f, 0.26609868f, 0.11763473f, 0.29239547f, -0.20005873f, -0.11587960f, -0.38135621f, 0.08228958f, 
    0.30558670f, -0.43616635f, 0.22464864f, 0.44537684f, -0.02616947f, -0.08019920f, -0.12481785f, -0.64156032f, 
    0.24226004f, 0.07855535f, -0.05635158f, -0.11949359f, 0.02683445f, -0.46731228f, 0.23331951f, -0.06165278f, 
    -0.36987257f, -0.14833088f, 0.02201143f, 0.11455269f, 0.17776231f, -0.07836083f, -0.82925367f, 0.00694567f, 
    -0.32493275f, 0.30926526f, -0.05365929f, -0.75857967f, 0.14220957f, -0.60095817f, 0.31097472f, 0.10781678f, 
    -0.47260886f, 0.06538752f, -0.10904843f, -0.17113529f, 0.22720556f, 0.04294615f, 0.11281061f, -0.05725682f, 
    -0.71452814f, 0.20114100f, -0.12283418f, 0.40971890f, -0.15332599f, -0.47663704f, -0.46974266f, 0.11449712f, 
    -0.39294285f, -0.19721934f, -0.20553556f, -0.51858658f, 0.00115780f, -0.01699201f, 0.02568971f, -0.13894565f, 
    -0.59934044f, 0.22342901f, -0.10086471f, 0.09999233f, -0.07872088f, 0.01516543f, 0.23595428f, -0.09091972f, 
    0.07186950f, -0.14437228f, 0.41830513f, 0.38476297f, -0.52811867f, -0.47257075f, 0.11748778f, 0.11277785f, 
    -0.02368353f, -0.19207747f, 0.12841249f, -0.59422159f, 0.05541494f, -0.38716072f, -0.14257158f, -0.04620945f, 
    -0.37914205f, 0.30476585f, -0.42591161f, 0.04567556f, 0.27787390f, -0.14161575f, 0.08385544f, -0.10743151f, 
    -0.13233551f, -0.43169087f, 0.14951889f, -0.21155284f, 0.13535233f, 0.39430088f, 0.04689528f, -0.10988036f, 
    -0.36499247f, 0.01347776f, -0.56466210f, 0.43016836f, 0.26111001f, 0.25455508f, 0.02251089f, -0.47098070f, 
    0.16854097f, -0.43473092f, -0.12707628f, 0.65668750f, 0.12798949f, 0.15440184f, 0.60630059f, 0.02957377f, 
    -0.71794802f, -0.06109828f, 0.03444362f, -0.13908783f, -0.52278304f, 0.03453444f, -0.00515066f, 0.16927893f, 
    0.33874053f, -0.04122248f, -0.07208054f, -0.37830362f, 0.10344703f, 0.35316959f, -0.05674969f, -0.00067295f, 
    -0.05454294f, -0.62009996f, -0.36363208f, 0.04303465f, 0.00460434f, 0.11276101f, -0.04260664f, -0.23255630f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.06833409f, 0.19996175f, 0.00590102f, -0.21005125f, -0.16073814f, 0.05741306f, 0.03814821f, -0.08360022f, 
    -0.09985992f, 0.02390872f, 0.02717164f, 0.07420554f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
