#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64726365f, -0.95700496f, 0.64104456f, 0.82778180f, -0.56503487f, -0.50409949f, -0.17021424f, -0.15830420f, 
    0.53657472f, -0.33497459f, -0.20731428f, -0.20211990f, -0.05263190f, -0.30186069f, -0.03470035f, -0.29835522f, 
    -0.06631462f, 0.42195749f, 0.41114491f, 0.10010775f, -0.33002836f, 0.26356599f, -0.30625901f, 0.17786147f, 
    -0.42107204f, -1.74569762f, 1.41816223f, -0.54772252f, -0.66859412f, 0.12190303f, 0.19984803f, 0.17639489f, 
    -0.40318391f, 0.16345906f, -0.73432946f, -0.14775711f, 0.03387832f, 0.00643279f, 0.21052237f, 0.06943302f, 
    -0.07160384f, -0.10285553f, -0.43292642f, -0.47863033f, -0.28164098f, 0.19480191f, 0.11908665f, 0.13254295f, 
    0.25741559f, 0.16458404f, 0.51126480f, 0.43739367f, -0.45911801f, -0.76662648f, -0.25633478f, 1.03457618f, 
    -0.10625510f, -0.41222718f, -0.97580141f, -0.55539107f, 0.21487130f, 0.49193555f, 0.26694453f, 0.32251012f, 
    -0.10492070f, -0.13928756f, -0.19497067f, -0.11141732f, -0.08348481f, 0.05532846f, -0.05042280f, -0.17340626f, 
    0.04533264f, 0.14865032f, 0.38980600f, 1.02410424f, 0.57638466f, 1.03473365f, 0.93745559f, 0.39350542f, 
    -0.56887448f, 0.07690834f, -0.59267056f, -0.65253556f, 0.08226028f, 0.30348784f, 0.12362758f, -0.10720849f, 
    0.27089208f, 0.00085211f, -0.11808982f, 0.17451219f, -0.04866221f, 0.19861351f, -0.29223081f, 0.17282180f, 
    0.01454040f, 0.21762343f, 0.11526693f, 0.11221435f, -0.73695254f, -0.61005807f, -0.78725374f, 0.13065770f, 
    0.14394918f, 0.54331565f, 0.43121645f, 0.55290705f, 0.56594867f, 0.22752671f, 0.09971558f, 0.05100140f, 
    -0.54751688f, -0.03982528f, 0.35746509f, 0.00366771f, 0.09107903f, -0.25670722f, -0.25993955f, -0.06231270f, 
    -0.43398896f, -0.47179127f, 0.31872058f, -0.23700900f, -0.22002457f, 0.65403360f, 0.26094449f, -0.41964766f, 
    1.03294778f, 0.66972500f, 0.75096118f, -0.53765744f, -1.01882195f, -0.81558126f, -0.17467719f, 0.02481930f, 
    0.14345236f, 0.17351700f, -0.03182378f, -0.20336637f, 0.17354539f, -0.17319067f, 0.28904957f, 0.09835491f, 
    0.14177980f, -0.01201180f, 0.08705980f, -0.14015208f, 0.24561357f, 0.23731835f, 1.03716588f, 0.39111161f, 
    0.68604612f, -0.39372531f, -0.34490135f, 0.18638873f, -0.94715488f, 0.29722852f, 0.18961626f, 0.55844676f, 
    0.52344733f, 0.18436025f, -0.14741006f, -0.46478119f, 0.07209276f, -0.35352448f, -0.06343567f, -0.30647135f, 
    -0.21523884f, -0.37737107f, 0.36611652f, 0.17170466f, 0.31461382f, 0.04397272f, -0.16861510f, 0.88900548f, 
    0.47072050f, 0.20354047f, -0.65653688f, -1.22992325f, -0.26479104f, -0.29947653f, -0.27392223f, -0.07511406f, 
    0.25100553f, 0.25838485f, -0.11580384f, -0.44464609f, -0.18869324f, 0.17556785f, 0.21452434f, 0.28654316f, 
    -0.12485839f, -0.05049938f, -0.16090383f, 0.29718542f, 0.36764348f, -0.45270413f, 0.50780499f, -0.46603954f, 
    -1.05854607f, 0.89256650f, 1.02889502f, 0.33037174f, 0.09724614f, 0.21131706f, 0.56748855f, 0.78664893f, 
    -0.14368759f, 0.03282130f, -0.68259513f, 0.05939984f, -0.22505298f, -0.19586074f, -0.07252984f, -0.45574346f, 
    0.06581257f, 0.08958171f, 0.00885664f, -0.46482667f, 0.09470298f, 0.03953730f, 0.05078709f, 0.43011472f, 
    0.04232218f, 0.43686551f, -0.83499116f, 1.02451587f, 0.61710185f, 0.82319504f, 1.13319933f, 0.16631711f, 
    0.18598448f, -0.18433912f, -0.07303475f, -0.04899390f, 0.13358703f, -0.01181885f, 0.15350860f, -0.10400333f, 
    0.42689067f, 0.43860784f, -0.04467968f, 0.16169788f, 0.17564242f, 0.02526348f, 0.30263644f, -0.06138417f, 
    -0.30021691f, 0.21670774f, 0.43179542f, 0.87417066f, 0.04063173f, 0.91173536f, 0.87880355f, 0.94715804f, 
    -0.14875236f, -0.88548851f, 0.68032062f, -0.30266449f, -0.77425629f, -0.29689413f, -0.43094420f, 0.25483930f, 
    -0.32944247f, -0.13670450f, 0.10556798f, -0.19751719f, -0.26149037f, 0.05384753f, -0.14194800f, -0.05012728f, 
    -0.46421984f, -0.21393061f, -0.11658372f, 1.30377638f, 0.74484336f, 0.92000633f, -0.67604810f, -0.35872495f, 
    -0.03865730f, -0.62420958f, -0.02366578f, 0.08211823f, 0.47016183f, -0.24346903f, 0.12780359f, -0.07888791f, 
    0.08682014f, -0.04672800f, -0.09439711f, -0.20515195f, 0.20867799f, -0.10151860f, 0.18843290f, -0.24558109f, 
    0.03682943f, 0.21240328f, -0.16782968f, 0.32750559f, -0.23840059f, 0.67298716f, -0.78754795f, -0.68853074f, 
    -0.95830196f, 1.17865944f, -0.35685053f, -0.60919952f, -0.38640144f, -0.11708388f, 0.16373852f, -0.52042180f, 
    0.56000745f, -0.09318361f, -0.12764461f, -0.23089540f, 0.17693160f, 0.25397483f, 0.01577452f, -0.35380173f, 
    0.14440666f, -0.13820006f, 0.02070564f, -0.04410945f, -0.00553135f, -1.13185334f, -1.23909485f, -0.80237365f, 
    0.51372272f, 0.11256232f, 0.47191593f, 0.20997086f, -0.20868881f, 0.58835584f, -0.29661995f, -0.46121448f, 
    0.32380784f, -0.15577705f, 0.72096920f, 0.33542439f, -0.14009888f, -0.08090549f, 0.07598423f, -0.16950482f, 
    0.01072176f, -0.09081510f, 0.09993453f, -0.29739845f, 0.06906100f, 0.00064828f, -1.02051246f, -1.02016127f, 
    0.04811979f, 0.33252203f, -0.05695069f, -0.20115723f, 0.92566329f, 0.86952227f, -0.85513091f, -0.33144051f, 
    0.41204193f, -0.12149160f, 0.15281668f, 0.18682849f, 0.48596671f, -0.42808658f, -0.04599017f, -0.10632539f, 
    -0.22833246f, 0.00158021f, -0.04343573f, 0.27920035f, 0.21214186f, 0.03370202f, -0.22817610f, 0.79187644f, 
    0.99936152f, 0.23316249f, 0.31539041f, -0.19511375f, -0.51169425f, -0.18772471f, -0.03646865f, 0.37958372f, 
    0.28582609f, 0.25553766f, 0.08386179f, -0.24574292f, -0.02099052f, 0.31633863f, 0.48700580f, -0.26791897f, 
    -0.15585127f, 0.65316468f, 0.47685882f, -0.46262342f, -0.20245664f, -0.42174837f, -0.07811187f, 0.23098481f, 
    1.26492536f, 0.04752959f, -0.29714176f, 0.65936029f, -0.20378658f, 0.30920279f, 0.37806469f, -0.08528598f, 
    -0.24137169f, 0.63906932f, -0.19529933f, -0.06490809f, -0.42135680f, -0.08780474f, -0.55899256f, -0.21205126f, 
    0.17443764f, 0.19436923f, 0.27368361f, -0.21922478f, -0.12346857f, -0.30274409f, -0.29057461f, -0.24602409f, 
    0.00177388f, -0.43986720f, -0.69951290f, -0.39371756f, -0.48137054f, -0.54908335f, -0.62658906f, -0.26590687f, 
    0.25005209f, -0.24031389f, -0.30200160f, -0.00480415f, -0.20070544f, -0.51839501f, 0.00982516f, -0.56678981f, 
    0.07000647f, -0.50537694f, -0.25605226f, -0.18669528f, 0.18355487f, -0.20732702f, 0.41512975f, 0.09524874f, 
    0.53939462f, 0.30484587f, 0.26441598f, 1.07239115f, -0.52186286f, 0.10491206f, 0.68639320f, -0.19565791f, 
    -1.11900163f, -0.77994210f, -0.79350448f, -0.02830219f, 0.55234063f, 0.23782681f, -0.10139026f, -0.06071633f, 
    -0.10992654f, -0.11980657f, -0.08994793f, -0.31294608f, -0.19278547f, -0.24597557f, -0.06861942f, 0.04630830f, 
    0.03159543f, -0.05136710f, 0.05459243f, -0.28012311f, -0.34834853f, 0.30368903f, 0.91499496f, 0.32485235f, 
    -0.77879524f, 0.29446527f, -0.21110590f, 0.14670305f, 0.20203771f, -0.59429777f, -0.21481375f, 0.29464921f, 
    0.46464866f, 0.01729680f, 0.42041114f, 0.30614045f, -0.21834414f, -0.32819763f, -0.08675101f, -0.20550370f, 
    -0.12921967f, -0.62028980f, -0.05413668f, -0.17446609f, 0.66970211f, -0.24942800f, -0.52724940f, 0.37281895f, 
    0.00985733f, -0.61988413f, -0.00107646f, 0.05345298f, -0.05398856f, -0.78595513f, 0.30617765f, 0.36230418f, 
    0.50972575f, -0.20603181f, -0.44785768f, -0.27635255f, -0.00493641f, -0.40448937f, 0.28788534f, -0.58318287f, 
    -0.19349971f, 0.28460306f, -0.15487948f, 0.62064976f, -0.28594014f, 0.15346853f, -0.74559247f, -1.00799656f, 
    -0.61472017f, -0.49091235f, 0.42736584f, 0.76141787f, 0.37184387f, 0.58906513f, 0.70070279f, -0.12389123f, 
    0.34175676f, -0.37303102f, -0.39578626f, -0.20605348f, 0.07306300f, 0.21343693f, 0.25690401f, 0.08322957f, 
    -0.07763629f, -0.22508611f, 0.04944003f, -0.21700920f, 0.31683466f, -0.18645489f, -0.55458522f, -1.28781652f, 
    -0.55012786f, 0.08424179f, -0.39573255f, -0.24541965f, -0.04776835f, -0.40846556f, -0.28593081f, -0.07189332f, 
    0.70311260f, 0.35962310f, 0.06659827f, 0.05654863f, 0.22239290f, -0.09555308f, 0.26990527f, 0.42628121f, 
    -0.24510615f, 0.05438945f, 0.10225428f, -0.15146658f, 0.17401829f, 0.39611942f, 0.01532413f, 0.04388901f, 
    -0.57524389f, -0.49456215f, -0.71198630f, 0.68628931f, 0.23202996f, -0.25224400f, -0.68909407f, -0.18597032f, 
    -0.30444419f, 0.07385492f, -0.58715123f, 0.40917003f, 0.18200207f, -0.32065004f, -0.01383777f, 0.07351305f, 
    -0.46467155f, 0.33446300f, 0.58099282f, 0.08730868f, 0.15851915f, 0.02613416f, 0.02426433f, -0.53128505f, 
    -1.15617847f, 0.22630024f, 0.57606620f, 0.09326980f, -0.81333292f, 0.69083858f, 1.19207203f, -0.19251586f, 
    0.28860828f, 0.59273708f, -0.34571373f, -0.49880293f, 0.30740395f, -0.31803572f, -0.21354139f, 0.29420355f, 
    -0.51287788f, -0.19545873f, -0.36685231f, -0.03188270f, -0.31397569f, -0.07911587f, 0.17571698f, 0.17126159f, 
    0.05881500f, -1.17158282f, 0.48488158f, -0.29374924f, -0.90551668f, -0.65951854f, 0.40260109f, 0.73707175f, 
    0.01615480f, 0.15527363f, 0.76058310f, -0.03217429f, -0.11711593f, 0.03794389f, -0.21527024f, 0.06456260f, 
    -0.00117457f, 0.12535165f, 0.21907695f, 0.18482821f, 0.06576724f, 0.07640874f, -0.13316675f, 0.12722719f, 
    -0.06625784f, 0.29472321f, 0.87794489f, 0.12238947f, -0.04777275f, 0.66090947f, 0.32498980f, 0.31483132f, 
    -0.80591094f, 0.74052882f, -0.23421595f, -0.42047375f, 0.39524460f, -0.18510790f, -0.32560417f, 0.14529411f, 
    -0.26748744f, -0.14204839f, 0.31389648f, -0.16702788f, -0.10028098f, -0.19682722f, -0.25220671f, 0.27932921f, 
    -0.04880418f, -0.39753279f, 0.22162305f, 0.16855927f, -0.39041814f, 0.06086342f, -0.29376599f, 0.74927127f, 
    -0.55969894f, -1.06395388f, -0.36413056f, 0.10560057f, -0.70784080f, 0.07101525f, 0.14138766f, 0.27309036f, 
    0.01991078f, -0.23635836f, 0.09947485f, -0.51945442f, -0.09409353f, 0.26366115f, -0.00100562f, -0.43743026f, 
    -0.25840136f, -0.10599493f, -0.13462840f, 0.09062430f, 0.77378565f, 0.69391453f, 0.82275397f, 0.79784346f, 
    -0.01633527f, 0.29613450f, 0.43714914f, -0.11923880f, -0.18096361f, -0.51950759f, 0.42450505f, 0.15139523f, 
    -0.05078726f, -0.01516705f, 0.18284960f, 0.35966673f, -0.34570727f, 0.25229365f, 0.20925929f, 0.56237441f, 
    -0.32586101f, 0.03833440f, 0.38619965f, 0.03990043f, 0.00215070f, -0.67350018f, -0.16121274f, 0.04196001f, 
    -0.05826087f, -0.14471903f, -0.71912950f, -0.17825298f, -0.65541506f, -0.54506528f, -0.68721342f, -0.23841386f, 
    0.59216571f, 0.41865161f, 0.58136666f, 0.03578353f, 0.52883387f, 0.36643463f, 0.19771142f, 0.55313975f, 
    0.19956651f, -0.15295266f, 0.15281032f, 0.12415859f, 0.03672968f, 0.06444888f, 0.68159622f, 0.72738218f, 
    0.37095702f, -0.26435250f, -0.11529003f, -0.44777992f, 0.99990636f, 0.37647590f, 0.01622163f, 0.86090875f, 
    -0.12871905f, 0.26974779f, 0.04172663f, -0.40434679f, -0.04601172f, 0.26493216f, -0.20941906f, -0.34372818f, 
    0.21092436f, -0.07030559f, 0.27663356f, 0.12355098f, -0.03261857f, 0.20056958f, 0.24596871f, -0.12707017f, 
    -1.77244544f, -0.26540321f, 0.25076044f, 0.61371303f, -0.08507799f, 1.04868674f, 0.75421262f, -0.46174744f, 
    0.56531602f, -0.23289664f, 0.40461701f, -0.27152181f, 0.08310917f, -0.18870030f, -0.15494117f, 0.01641787f, 
    -0.38195151f, -0.13584673f, -0.09250666f, 0.25010306f, 0.22724062f, 0.09828876f, 0.00385074f, 0.09135421f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08565788f, 0.38604745f, 0.37204391f, -0.03554778f, 0.03608517f, 0.17578445f, 0.28177890f, 0.13664202f, 
    0.24294887f, 0.11079718f, -0.07955573f, 0.20700891f, 0.10058320f, 0.16213080f, 0.20444027f, -0.07593983f, 
    0.09409336f, -0.00376087f, 0.04119073f, 0.05473146f, 0.18115072f, 0.01694699f, 0.23642841f, 0.13641559f, 
    -0.25455472f, 0.21770993f, -0.07345238f, 0.16577044f, 0.17506532f, 0.35141599f, 0.15377262f, 0.14435981f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22862047f, -0.18791999f, -0.25074014f, 0.50876516f, -0.05129278f, 0.07213104f, 0.13617167f, -0.01873416f, 
    0.12907843f, -0.03079206f, -0.14175691f, 0.03308793f, 0.20311210f, 0.04549753f, 0.10818609f, -0.19348072f, 
    0.00250040f, -0.11560334f, 0.03267743f, -0.01176843f, 0.02650980f, -0.14138046f, -0.13179225f, -0.12776640f, 
    -0.34274390f, 0.04231518f, 0.13194279f, -0.30814040f, -0.20049307f, -0.09733519f, 0.20003542f, 0.03517492f, 
    0.02347585f, 0.01664040f, -0.13215856f, 0.08941096f, 0.17283523f, 0.12930386f, -0.21842583f, 0.14701407f, 
    -0.31290653f, -0.13250756f, 0.00945050f, 0.03030097f, -0.00093790f, 0.02407988f, -0.02219793f, -0.01280467f, 
    0.05985402f, 0.07504267f, 0.01256743f, -0.15980470f, 0.07698243f, 0.16357933f, 0.01108598f, 0.08013038f, 
    -0.02130837f, -0.06609921f, -0.06550294f, -0.11423235f, 0.29332188f, -0.11419182f, 0.18802413f, 0.23514733f, 
    -0.09835952f, -0.04706261f, 0.03228085f, -0.01300670f, -0.10514773f, 0.12908408f, -0.13583180f, -0.06827787f, 
    -0.06610399f, -0.17957404f, 0.00831891f, -0.11887313f, 0.02705594f, -0.03028078f, 0.08454219f, -0.12823968f, 
    -0.09583189f, -0.12307723f, 0.03351239f, 0.02807106f, -0.25774106f, 0.09636992f, -0.16189048f, -0.05845329f, 
    -0.04699793f, 0.03023238f, -0.15008058f, -0.18527037f, -0.05496147f, 0.07192449f, 0.05142638f, -0.02199922f, 
    -0.28641379f, 0.17256209f, 0.10643104f, 0.17969410f, -0.12747049f, -0.06798705f, 0.03746458f, -0.09703429f, 
    0.01347723f, -0.15320913f, -0.01290090f, -0.06632384f, -0.10214370f, -0.11747305f, -0.06876588f, 0.28932908f, 
    -0.02523831f, 0.02102563f, 0.12498297f, -0.06822822f, -0.11884992f, -0.00538498f, 0.02464812f, -0.09274252f, 
    0.02096974f, -0.05811311f, 0.11908729f, 0.35567102f, 0.01420384f, -0.11394047f, 0.06746709f, 0.06726643f, 
    0.02508844f, -0.02620086f, -0.06432384f, -0.00939509f, 0.16151243f, -0.01997247f, -0.08739498f, -0.25569692f, 
    -0.09739082f, -0.25249273f, -0.04989842f, 0.09647343f, -0.00165378f, -0.06080608f, -0.08109757f, 0.04759298f, 
    0.29210693f, -0.23348339f, 0.00407207f, -0.21049346f, -0.09284201f, 0.04394727f, -0.03461654f, -0.01252839f, 
    -0.06963474f, 0.01803335f, -0.20044082f, -0.03209688f, -0.29317737f, 0.03734840f, -0.26333684f, -0.02900058f, 
    0.14191049f, -0.02022595f, -0.01071426f, 0.05719182f, 0.03315292f, -0.18862940f, 0.02544298f, 0.02300070f, 
    -0.43407187f, 0.20104815f, 0.07804713f, 0.06785421f, -0.00547967f, 0.01384677f, -0.11279052f, -0.06597252f, 
    0.03011402f, -0.01018382f, 0.11670550f, 0.16859312f, 0.11585198f, -0.00994048f, 0.06550132f, 0.00291036f, 
    -0.05587822f, -0.07857054f, 0.03190078f, 0.15875591f, 0.19210976f, 0.10139059f, -0.08653431f, -0.03159166f, 
    0.02691881f, 0.01955425f, 0.08927923f, 0.25305918f, -0.08727857f, -0.01680370f, -0.09185655f, 0.00884676f, 
    -0.01297860f, 0.11094164f, 0.04100861f, -0.10859811f, -0.31239596f, -0.28198963f, -0.16486686f, -0.02267504f, 
    -0.30075309f, 0.03905337f, 0.03055457f, 0.07358754f, 0.02228180f, 0.01684254f, 0.10000273f, 0.01168936f, 
    0.24453118f, -0.06465729f, 0.48779234f, -0.01328862f, -0.17675509f, -0.16482161f, 0.09548707f, 0.07974923f, 
    0.02452154f, 0.00181402f, 0.08115505f, 0.08486358f, 0.07088179f, -0.03908069f, -0.09253120f, 0.44544128f, 
    0.02956440f, 0.11875171f, 0.11925403f, -0.17317204f, -0.03257801f, -0.05112362f, -0.03868265f, -0.03554835f, 
    0.07152279f, 0.03302764f, -0.02199271f, 0.11492852f, -0.00231921f, -0.07565239f, -0.06080149f, -0.13089861f, 
    0.14093342f, 0.00501357f, 0.20513466f, -0.12211446f, 0.12668583f, 0.22245276f, -0.07432117f, -0.41946369f, 
    0.11888887f, 0.03412227f, 0.05244514f, -0.15428632f, -0.07448460f, 0.00376672f, 0.01643362f, 0.16908811f, 
    -0.20228340f, -0.45101696f, -0.19714428f, 0.12728055f, -0.01967035f, 0.02327823f, 0.06849750f, 0.10762555f, 
    -0.07833011f, -0.07151785f, 0.01438503f, -0.13523173f, -0.36428475f, -0.37020588f, 0.36291406f, -0.25511703f, 
    -0.06110585f, 0.07939574f, -0.13112181f, 0.01713466f, 0.00811788f, -0.10890790f, 0.10000830f, -0.09993031f, 
    0.73854971f, 0.23796242f, 0.20487620f, 0.01048984f, -0.08109714f, 0.10067743f, -0.05549803f, -0.03163654f, 
    -0.15557569f, -0.01700429f, 0.27545500f, 0.01514143f, 0.54907584f, 0.16869402f, 0.08524721f, -0.45262590f, 
    0.14182857f, 0.10905627f, -0.09845643f, 0.03033618f, 0.10775781f, -0.08436264f, -0.03749111f, 0.09358570f, 
    0.28921571f, -0.35273197f, 0.19610965f, -0.05157126f, -0.10768803f, 0.03107040f, -0.15802914f, 0.03259481f, 
    -0.20954165f, -0.03523218f, 0.06914743f, -0.16788417f, 0.03503156f, -0.24860655f, 0.14448822f, -0.20678993f, 
    -0.16028310f, -0.02275253f, -0.16867517f, 0.00695702f, 0.10092614f, -0.06388388f, -0.04768825f, -0.02924196f, 
    0.15426016f, 0.11871956f, -0.21913491f, 0.01547861f, -0.27566886f, 0.02564495f, -0.06957171f, 0.17820609f, 
    -0.00948533f, -0.02403788f, -0.13700528f, -0.10728599f, -0.57421666f, 0.00708545f, 0.06406625f, -0.02471105f, 
    0.01982424f, 0.08865835f, -0.00809636f, 0.03391970f, -0.07436319f, 0.05963481f, -0.17680299f, -0.12758163f, 
    -0.24285340f, -0.06286933f, -0.03620867f, -0.20166931f, 0.06564967f, -0.01924178f, -0.07451346f, -0.05268675f, 
    -0.06028843f, -0.00515065f, 0.07188778f, -0.08592446f, -0.21943359f, 0.12101503f, 0.01958996f, -0.15561247f, 
    -0.09606828f, 0.04700603f, -0.10905958f, 0.04443529f, 0.00317422f, 0.10071567f, 0.11556862f, -0.11254543f, 
    0.01877673f, -0.12805168f, -0.47141677f, 0.16295017f, -0.16393043f, -0.14945211f, -0.06351854f, -0.18439291f, 
    0.15321922f, -0.03443742f, 0.01488629f, 0.13333945f, -0.73414016f, -0.09734520f, -0.27149478f, -0.55945539f, 
    0.00070727f, 0.14480907f, 0.09072539f, -0.00794105f, 0.06425284f, 0.06548157f, 0.06584497f, -0.08239298f, 
    0.28509888f, -0.26441672f, -0.04150986f, -0.18185006f, -0.09523901f, 0.01710971f, -0.00839597f, 0.00320670f, 
    -0.07221443f, 0.04609971f, -0.04618839f, -0.12956259f, 0.25920421f, -0.01364404f, 0.21814866f, 0.32717621f, 
    -0.05077184f, 0.03078692f, 0.04188967f, 0.02637915f, 0.08305909f, -0.01975940f, 0.03468563f, -0.00759096f, 
    0.21048866f, 0.10808197f, -0.12793861f, 0.02727841f, 0.09193351f, -0.07302003f, -0.21495177f, -0.14343359f, 
    0.00667875f, 0.10133632f, -0.03794790f, 0.07516876f, 0.04573128f, -0.41473573f, 0.08827531f, 0.00571327f, 
    0.01719286f, 0.06953495f, -0.10574520f, -0.07289878f, -0.02001574f, 0.03561828f, 0.06376538f, -0.01293851f, 
    0.02267159f, 0.16585378f, 0.31303251f, 0.10215385f, -0.11547086f, -0.00611987f, 0.05288198f, 0.03737174f, 
    0.06204534f, -0.12156806f, 0.02504376f, -0.07754540f, 0.19386320f, -0.02296144f, -0.26407632f, -0.21629088f, 
    -0.05216780f, -0.09394421f, -0.06103190f, 0.16566867f, 0.00100376f, -0.01683776f, -0.09421721f, 0.14443904f, 
    0.12661089f, 0.27197596f, -0.10157447f, 0.24958199f, 0.01700768f, 0.02764659f, -0.00317359f, -0.01760039f, 
    -0.04898806f, -0.00531503f, 0.09398740f, -0.09948616f, 0.24700825f, -0.01658269f, 0.09083794f, 0.05372542f, 
    -0.27385518f, 0.11428180f, -0.06638924f, 0.00128589f, 0.01764306f, 0.06932832f, 0.19603157f, 0.01091988f, 
    0.32663289f, -0.14983152f, -0.11037546f, 0.02010722f, -0.11790686f, 0.00998010f, -0.04201356f, 0.05969594f, 
    -0.07100481f, 0.05023046f, 0.08409199f, -0.20053607f, 0.38494238f, -0.06952543f, -0.05061346f, 0.03069812f, 
    0.02853470f, -0.14127505f, 0.09671199f, 0.02543970f, -0.09210046f, -0.08377858f, 0.08507482f, 0.08737668f, 
    -0.13566035f, -0.08069704f, 0.04057566f, -0.31836215f, 0.15843353f, -0.12573630f, 0.14239037f, 0.04021688f, 
    -0.03123965f, -0.04543540f, 0.01334313f, -0.07047171f, 0.51925832f, 0.09331872f, -0.27351010f, 0.21740672f, 
    -0.04746531f, 0.06521451f, 0.07454917f, 0.19620316f, -0.19376700f, 0.06292101f, 0.04991558f, 0.03602734f, 
    0.05241719f, 0.07330350f, -0.15253936f, 0.24141341f, -0.18879050f, -0.04345968f, -0.10790329f, 0.02311057f, 
    -0.01514502f, -0.19060163f, 0.01110437f, -0.12123352f, 0.09490785f, -0.16114774f, -0.19052052f, 0.00288047f, 
    0.04531940f, -0.13319322f, -0.15036258f, 0.00018097f, -0.10703211f, 0.11314394f, -0.28685725f, 0.20839147f, 
    0.53776044f, -0.15210159f, 0.00128876f, 0.07597762f, -0.09575257f, -0.01721876f, -0.09132601f, -0.04944288f, 
    0.00240678f, -0.28417769f, -0.07434338f, 0.01012177f, -0.03124958f, -0.01906211f, -0.03768481f, -0.14868514f, 
    0.02405463f, 0.01879253f, -0.06399827f, 0.14436823f, 0.11133368f, 0.02438664f, -0.23181021f, 0.10597834f, 
    -0.10661806f, -0.28449860f, -0.04154953f, -0.44636863f, -0.01426625f, 0.05594543f, -0.00282547f, -0.13272120f, 
    0.01335330f, 0.00670036f, -0.12653337f, -0.06568484f, 0.08978274f, 0.00021105f, -0.19529688f, -0.06389280f, 
    -0.17562912f, 0.06832082f, -0.18972728f, 0.02394873f, -0.02612633f, -0.11910971f, 0.04567035f, -0.05802745f, 
    0.07938369f, -0.61851281f, -0.13599366f, 0.15120047f, 0.06261186f, -0.06870716f, -0.10845287f, 0.05738781f, 
    0.12138565f, 0.02425751f, -0.32213148f, 0.14588901f, 0.22399059f, -0.23539910f, -0.05731200f, -0.17087312f, 
    0.11240205f, 0.06328457f, 0.05290814f, -0.03464336f, 0.07077446f, -0.05065789f, -0.10791484f, 0.02434224f, 
    0.01813253f, 0.20545469f, -0.21052024f, 0.02628430f, 0.08302345f, 0.08406246f, -0.00659241f, 0.01346617f, 
    0.08322046f, -0.20237181f, 0.16130288f, 0.31577164f, 0.13632117f, -0.20429613f, 0.01118393f, -0.33012712f, 
    0.03105233f, -0.16592728f, 0.09487339f, -0.21293962f, -0.02819910f, 0.10886236f, -0.04405581f, 0.06080324f, 
    -0.77826405f, -0.08737759f, -0.09801613f, 0.00500675f, 0.04284802f, 0.01935225f, 0.07200929f, -0.21700656f, 
    0.02169530f, -0.03230659f, -0.05594986f, 0.00693980f, -0.29181981f, -0.02091392f, -0.17562266f, -0.37004533f, 
    -0.01374994f, -0.04406260f, -0.04933023f, 0.10204627f, 0.15518956f, 0.11466210f, -0.04687155f, -0.00436177f, 
    -0.02072146f, 0.05532140f, 0.27800503f, 0.40415385f, 0.03811979f, -0.05295713f, -0.06448972f, 0.02952170f, 
    -0.00313914f, -0.09198873f, -0.04340236f, 0.04412793f, -0.37218469f, -0.43237463f, 0.24135335f, 0.01912891f, 
    0.16784705f, -0.07731876f, -0.00084035f, 0.07297750f, -0.07017913f, 0.01780172f, -0.09903169f, 0.04488499f, 
    -0.05502608f, 0.03914812f, 0.39299941f, 0.05917467f, -0.13580774f, -0.04313184f, 0.07973238f, 0.02076287f, 
    -0.00671240f, 0.04074423f, -0.02640765f, 0.11100791f, -0.21061559f, -0.02147212f, -0.09548815f, -0.08310073f, 
    0.01457394f, 0.06102883f, 0.06739695f, 0.07624365f, 0.13164428f, 0.09160814f, 0.09610613f, 0.17911576f, 
    0.46726209f, 0.17087619f, 0.09773056f, -0.00519173f, 0.09708601f, -0.07148600f, -0.18865265f, 0.06469263f, 
    -0.00693096f, -0.06375016f, -0.08604220f, 0.01646665f, 0.30970719f, -0.26533967f, -0.07019309f, 0.03820920f, 
    -0.11767160f, 0.15694053f, 0.12387519f, 0.13185588f, 0.13505764f, -0.03399968f, -0.00857245f, 0.08665629f, 
    -0.50485939f, 0.14379072f, -0.23667818f, -0.05354069f, -0.12159971f, -0.02930835f, -0.04141357f, 0.16792029f, 
    0.10907874f, 0.03013775f, -0.15481776f, -0.09397654f, 0.14942539f, 0.12882411f, -0.29041463f, -0.26619929f, 
    0.00120413f, 0.18545662f, -0.04122965f, -0.07148599f, 0.05985556f, 0.00754134f, -0.05567221f, 0.06153054f, 
    -0.30205366f, -0.18273994f, 0.10475511f, -0.40169194f, 0.01526658f, -0.16537359f, 0.01830226f, 0.13759786f, 
    -0.08368737f, 0.03832569f, 0.02681706f, -0.09840148f, -0.07270417f, 0.23594727f, -0.21617414f, 0.02732451f, 
    0.09410544f, 0.18509676f, -0.01175780f, -0.04745815f, -0.06192157f, 0.11333117f, -0.05412994f, -0.10932921f, 
    0.24226388f, 0.05151920f, 0.05675066f, 0.19303642f, -0.04547703f, 0.00420539f, -0.06008393f, 0.30855310f, 
    -0.05613330f, -0.10373630f, 0.04222017f, 0.00303079f, -0.03650628f, -0.14357173f, 0.03258554f, -0.15444565f, 
    0.17511982f, -0.03549341f, -0.04951943f, -0.04275852f, -0.03776240f, -0.01265051f, -0.12705560f, -0.10489796f, 
    -0.17303406f, 0.12284724f, 0.14769395f, -0.07343990f, -0.08396960f, 0.01992664f, 0.09840021f, -0.00920114f, 
    -0.13187264f, 0.07130615f, 0.15114497f, 0.07572421f, -0.39758798f, -0.10058568f, 0.24471690f, -0.09637434f, 
    -0.05252085f, -0.08431701f, 0.15051343f, 0.08446427f, 0.06158054f, -0.08783084f, -0.00885775f, -0.01126053f, 
    0.32351196f, -0.15516402f, -0.28796202f, -0.11818504f, -0.03983534f, 0.10238297f, 0.02237615f, 0.02420116f, 
    0.03939108f, 0.06235506f, -0.03442692f, 0.09895858f, -0.11017295f, -0.22119860f, -0.03727598f, 0.08939733f, 
    0.04836470f, 0.11708022f, -0.07379453f, -0.10181258f, 0.04537943f, -0.15738665f, -0.16006294f, -0.00107889f, 
    0.16006139f, -0.42950547f, 0.11583661f, 0.12628342f, 0.19063939f, 0.02289422f, 0.08094956f, -0.31032985f, 
    0.03849500f, 0.09175020f, -0.05783394f, 0.02578201f, -0.33336860f, 0.06817517f, 0.03691860f, -0.22391415f, 
    0.11973990f, 0.08528483f, 0.04517921f, 0.09221623f, -0.12493627f, 0.00114612f, -0.08222672f, -0.05741087f, 
    -0.28986940f, 0.06665330f, 0.05620186f, -0.44351792f, 0.10428504f, 0.13402374f, -0.10453957f, 0.03281692f, 
    -0.04295068f, 0.01100011f, -0.06784876f, 0.09187749f, 0.21788447f, -0.03533043f, -0.20644000f, -0.04131032f, 
    -0.18834317f, -0.05357965f, -0.10050248f, 0.04310720f, 0.01567591f, -0.08160667f, -0.18134826f, 0.00751408f, 
    0.53833055f, 0.03782932f, -0.06417838f, -0.09072314f, -0.15398140f, 0.01105142f, -0.12377059f, 0.02267143f, 
    0.23723958f, -0.02755698f, 0.00191314f, -0.20994960f, 0.02843228f, 0.22382797f, -0.05442158f, -0.11380488f, 
    -0.03832958f, 0.09613767f, 0.15863673f, 0.08724638f, -0.11010755f, -0.01943104f, 0.04388110f, -0.20921883f, 
    0.09767296f, -0.17486580f, 0.10073368f, -0.16173264f, 0.00645338f, 0.00216320f, 0.07145527f, 0.15395427f, 
    -0.12490929f, 0.09427603f, -0.07490898f, -0.11711361f, -0.21970041f, -0.32804585f, -0.07841734f, 0.00456577f, 
    -0.02684707f, -0.10345040f, -0.23132870f, -0.18607906f, 0.06077736f, 0.06262136f, 0.18528919f, 0.07030945f, 
    -0.10375969f, 0.08737697f, 0.06416394f, -0.33770904f, 0.10914855f, -0.21205349f, 0.10476504f, -0.21991815f, 
    -0.03521880f, -0.00082257f, 0.05863583f, -0.13326110f, 0.26548538f, -0.03933299f, -0.13241197f, 0.02563874f, 
    0.01069426f, 0.05879877f, 0.01597717f, -0.17677841f, 0.00843044f, 0.03267262f, -0.07117545f, -0.02482751f, 
    0.07816941f, 0.17565967f, -0.08211488f, -0.24484922f, -0.07070068f, -0.05943101f, 0.05227124f, -0.06114841f, 
    -0.17915180f, 0.03966114f, 0.01223938f, -0.14313421f, 0.13640444f, 0.05942536f, 0.27733660f, 0.43753242f, 
    -0.15684031f, -0.09606632f, 0.04634396f, 0.12983228f, -0.04238844f, -0.10774868f, -0.00113898f, -0.01233750f, 
    0.47873586f, -0.55195445f, 0.14253648f, -0.08596326f, -0.17567287f, -0.08354009f, -0.18763821f, 0.07723735f, 
    -0.02708115f, 0.03879928f, 0.15253182f, -0.14304253f, -0.61448878f, -0.23428717f, 0.20681576f, -0.09907687f, 
    -0.09549516f, 0.26828569f, -0.13840534f, -0.06542119f, -0.01276152f, -0.13030712f, -0.12499157f, -0.04837988f, 
    0.67385978f, 0.03050715f, 0.07693386f, -0.11066631f, 0.05564969f, -0.02015550f, 0.08950502f, 0.26315069f, 
    -0.01586934f, 0.12559809f, 0.14954983f, -0.18521257f, 0.54426080f, 0.16663900f, 0.02807897f, 0.26109090f, 
    0.05775775f, 0.04045945f, -0.07681067f, -0.01394711f, -0.08753392f, 0.02139241f, 0.00826734f, -0.11392984f, 
    -0.70231050f, 0.23667407f, -0.15057136f, -0.22947055f, 0.14218232f, -0.15841274f, -0.05161013f, 0.11145137f, 
    0.06754964f, -0.03624042f, -0.04174707f, -0.08371060f, -0.26193756f, 0.05604923f, -0.43854070f, -0.29757521f, 
    0.03686199f, 0.11799978f, 0.05962394f, 0.02654206f, -0.14116155f, 0.05148930f, 0.02479522f, -0.26652601f, 
    0.09039529f, 0.07334911f, -0.11858251f, -0.02363417f, -0.00530484f, 0.03120883f, -0.05173235f, 0.00055617f, 
    -0.17205003f, -0.04106958f, -0.10759921f, 0.01732165f, 0.32408127f, 0.05141402f, -0.28091374f, -0.35408488f, 
    -0.11389487f, 0.02418253f, -0.05842997f, 0.14121915f, -0.17847309f, -0.17370710f, -0.24786830f, -0.09572456f, 
    0.08022265f, 0.17745993f, 0.05819832f, -0.03067516f, -0.02119531f, 0.01480015f, 0.12442514f, -0.13111925f, 
    0.01347175f, -0.02313128f, 0.00925206f, 0.01145174f, 0.30962059f, -0.33214399f, 0.18696314f, 0.19449136f, 
    -0.13707492f, -0.15138806f, 0.13035056f, -0.12099189f, 0.07479505f, -0.05912862f, 0.14098381f, 0.10429516f, 
    -0.06292490f, -0.04126748f, 0.06423192f, 0.00166530f, -0.01914966f, 0.05435545f, -0.05775495f, 0.14230202f, 
    0.06767106f, -0.06181226f, 0.04588539f, -0.07089531f, 0.61619872f, 0.53268784f, 0.11270709f, -0.08004133f, 
    -0.07885873f, 0.00112723f, 0.07341093f, 0.03328839f, -0.10938153f, 0.10695842f, -0.00788464f, -0.10774582f, 
    0.27778524f, 0.13474993f, 0.00707599f, 0.12791359f, 0.02538041f, -0.11399545f, 0.10028835f, 0.10603157f, 
    0.04798030f, 0.04783580f, -0.09691790f, -0.08106735f, -0.66037667f, -0.55371916f, -0.19931358f, 0.27114233f, 
    -0.06637932f, 0.09391575f, 0.00455340f, -0.07537828f, 0.01750992f, -0.14434557f, 0.11327890f, -0.15912290f, 
    -0.06477722f, -0.04365740f, -0.09840506f, -0.10302053f, 0.03782270f, -0.01905130f, -0.04168535f, -0.05914492f, 
    -0.01740233f, -0.02355538f, 0.14754346f, -0.08535569f, 0.38935304f, 0.03454167f, -0.06804933f, 0.34875581f, 
    0.05628389f, 0.03175595f, 0.08643565f, 0.06765833f, -0.05533755f, -0.06055355f, -0.09167693f, 0.00370589f, 
    -0.13573153f, -0.35275212f, -0.38508067f, 0.13286752f, -0.01487615f, 0.01509679f, -0.02431489f, -0.08620273f, 
    0.04649624f, 0.03420532f, -0.01961805f, -0.06528680f, -0.23324877f, -0.12321478f, -0.08095668f, -0.02935000f, 
    -0.16363631f, 0.10971981f, -0.08213590f, 0.17672420f, 0.05649011f, -0.02349914f, -0.08503757f, 0.01127019f, 
    -0.66663772f, -0.07755183f, -0.11261786f, -0.20127453f, -0.04193127f, -0.16895704f, 0.00886110f, 0.06944804f, 
    -0.03740580f, -0.01716536f, 0.04734966f, 0.04886495f, -0.55371922f, -0.34607738f, -0.16471463f, 0.25486475f, 
    0.04878297f, -0.05937417f, -0.04881165f, 0.00140799f, -0.06316564f, -0.03107137f, -0.02580970f, -0.09824990f, 
    0.52391797f, -0.43530628f, -0.37737709f, 0.19739386f, -0.06754646f, -0.07945313f, 0.01778685f, -0.08848017f, 
    0.03992597f, -0.02833205f, 0.08630598f, 0.00671153f, -0.22473571f, -0.34967372f, -0.51073998f, 0.12551686f, 
    0.05762648f, 0.02369606f, 0.03814355f, 0.04271537f, 0.03791239f, 0.12934221f, -0.08778925f, 0.03746731f, 
    0.32707462f, 0.19509360f, -0.16415001f, 0.05614224f, -0.04088420f, 0.08007707f, -0.01991030f, -0.03532674f, 
    -0.02223458f, -0.03625761f, -0.12863912f, 0.12750897f, 0.08710933f, 0.12558557f, -0.06730661f, 0.03418262f, 
    -0.11774005f, -0.13135517f, 0.04558433f, -0.12234525f, 0.03697768f, -0.11975154f, 0.20833331f, -0.14342663f, 
    0.23437396f, 0.12117707f, 0.15222386f, -0.10330834f, -0.07208949f, -0.08611251f, 0.00067407f, 0.02100195f, 
    -0.03794071f, -0.03982793f, -0.06312020f, 0.14763638f, -0.06249737f, -0.28287619f, -0.36981088f, 0.05587867f, 
    0.00438274f, -0.01192158f, 0.12128657f, 0.10621703f, 0.02366536f, -0.02869382f, 0.06799258f, -0.14422086f, 
    -0.03121554f, -0.14836045f, 0.14658247f, 0.07886520f, -0.13544877f, 0.13777061f, 0.02392146f, -0.06762275f, 
    0.05835657f, 0.11559220f, 0.14196388f, 0.17260340f, 0.23694952f, -0.00080346f, 0.10020185f, 0.04395622f, 
    -0.16685508f, -0.14508042f, -0.08220664f, 0.09346066f, -0.02368194f, -0.03294184f, 0.00981370f, 0.05380530f, 
    0.37239754f, 0.10693482f, -0.08683344f, 0.19563431f, 0.01096828f, 0.03978731f, -0.05981822f, 0.06327099f, 
    0.02731956f, 0.00323095f, 0.00436878f, -0.14679199f, -0.34699190f, -0.01350114f, 0.10671839f, 0.25196773f, 
    -0.00079083f, -0.00564286f, 0.27163523f, -0.06499235f, -0.13990346f, -0.03657935f, -0.10773644f, 0.12545891f, 
    0.08197988f, -0.01316722f, 0.21777196f, 0.07406970f, -0.00445697f, 0.04232873f, 0.13958754f, -0.01183539f, 
    0.09829446f, -0.03180931f, 0.05326551f, -0.01413857f, -0.19139393f, -0.13177177f, -0.05574029f, -0.15610340f, 
    -0.27629146f, 0.00171366f, 0.09142162f, -0.03146223f, -0.12996544f, -0.06802783f, 0.02018048f, -0.00493928f, 
    0.07580343f, -0.07264531f, -0.09946515f, -0.05239525f, -0.12744476f, -0.22859204f, 0.02774922f, -0.10173634f, 
    -0.04201556f, 0.12042470f, -0.02996831f, -0.06368020f, 0.05067218f, 0.10626093f, 0.03358382f, 0.09023573f, 
    -0.15369035f, 0.08169468f, 0.09863599f, 0.00286288f, -0.00088047f, -0.11354662f, 0.05869712f, -0.01131443f, 
    -0.48411241f, 0.11160910f, -0.00473617f, -0.12252246f, 0.01504963f, -0.03526453f, 0.02645783f, 0.06510288f, 
    -0.02973363f, -0.15521498f, 0.04725532f, -0.09356599f, -0.46073687f, 0.19789694f, 0.02883277f, -0.47478327f, 
    -0.04597779f, -0.02787417f, -0.08975026f, 0.02492906f, -0.02204557f, -0.26514515f, -0.11124808f, 0.11996330f, 
    0.36731327f, -0.03550316f, -0.03036367f, 0.22678624f, -0.18982273f, 0.17660728f, 0.15266676f, -0.03383436f, 
    0.00713236f, -0.13254111f, 0.05353389f, -0.09489899f, 0.05203917f, 0.13321508f, 0.20954739f, 0.28480339f, 
    0.00363179f, 0.14466774f, 0.01795585f, -0.08640787f, 0.04529889f, 0.13505721f, -0.08912464f, -0.10856084f, 
    -0.22658315f, -0.28441325f, -0.07740107f, 0.18609376f, 0.00427692f, -0.07281362f, -0.12095992f, 0.01800503f, 
    -0.00628495f, -0.06714183f, 0.02347396f, -0.11869570f, -0.16414598f, 0.16307847f, 0.19763707f, 0.06568095f, 
    0.11789096f, 0.03165770f, -0.03746527f, -0.08169594f, 0.01427395f, -0.08935962f, -0.04542776f, 0.04288648f, 
    -0.51372248f, -0.02999709f, -0.23440084f, -0.12340979f, -0.09163141f, -0.06057901f, -0.09901495f, -0.15894698f, 
    -0.22657762f, 0.10100493f, 0.18836659f, 0.03254960f, 0.11023342f, 0.12600517f, 0.05784599f, 0.19398504f, 
    -0.04431158f, -0.02539550f, 0.04446452f, -0.11749865f, -0.08645688f, 0.02075935f, -0.00432870f, -0.07633160f, 
    -0.17242984f, 0.15844296f, 0.05799634f, -0.04306308f, -0.00510065f, 0.10836851f, 0.06225993f, -0.06346221f, 
    -0.07917371f, -0.10668860f, -0.02119575f, -0.06338549f, 0.44869640f, 0.34177858f, -0.21409391f, -0.42444667f, 
    0.10968982f, -0.06983794f, 0.09260948f, 0.04983792f, 0.11385465f, -0.06016864f, -0.00967286f, -0.09799659f, 
    -0.09069236f, 0.18074936f, -0.03212962f, -0.12981987f, 0.17238188f, 0.05849210f, 0.01601438f, -0.09422851f, 
    -0.06213104f, -0.06829937f, 0.07932587f, -0.00299836f, -0.47197783f, -0.03315216f, 0.31621090f, 0.12011790f, 
    0.01020266f, 0.03016614f, -0.03403448f, 0.06996822f, 0.15949616f, -0.04044343f, 0.00909270f, -0.01408517f, 
    -0.19307683f, -0.16414386f, -0.05197265f, 0.12722979f, -0.11427474f, 0.09004442f, 0.06268164f, 0.14743672f, 
    -0.01138584f, -0.16196567f, 0.08897502f, 0.09233390f, -0.05267001f, 0.33635515f, 0.18900521f, 0.01789387f, 
    -0.12527364f, 0.05283829f, -0.07913705f, 0.02453543f, -0.02962005f, -0.15933371f, -0.01939012f, 0.10816810f, 
    -0.20852266f, -0.28485519f, 0.10382002f, -0.06181913f, -0.09057954f, -0.03191281f, -0.19128241f, -0.22789948f, 
    0.09740778f, -0.03817907f, -0.13614458f, 0.00504213f, 0.02930100f, -0.38804799f, 0.31278309f, -0.18858357f, 
    0.10798129f, 0.06234333f, 0.13068751f, -0.06606867f, 0.01749529f, -0.06135491f, 0.11972662f, 0.00129845f, 
    0.38689485f, 0.34479377f, 0.03054312f, -0.11170328f, -0.00969597f, -0.04363928f, 0.16999082f, 0.08351573f, 
    0.02667158f, 0.00144753f, -0.03833136f, 0.09848251f, -0.18446079f, 0.30746126f, -0.15861741f, -0.38879073f, 
    0.16951516f, -0.10907831f, 0.00313716f, 0.12937458f, 0.06547289f, -0.12203823f, -0.17190827f, -0.15272847f, 
    0.25508836f, 0.22400683f, -0.19048052f, -0.05707282f, -0.05444863f, 0.14830567f, -0.03153539f, 0.18831787f, 
    0.00235571f, -0.14383499f, 0.10629081f, 0.13426735f, -0.38328317f, -0.32094201f, 0.08835625f, -0.17455031f, 
    -0.16005734f, 0.21264645f, -0.08786467f, -0.00281303f, 0.12079912f, 0.15167119f, 0.08896614f, -0.01737680f, 
    0.04047982f, -0.03422587f, 0.04388149f, 0.22349705f, 0.05605891f, 0.00172768f, 0.26035368f, -0.07948839f, 
    -0.16641729f, 0.11413482f, -0.07691657f, 0.11759236f, -0.44040629f, 0.16730142f, -0.00725690f, -0.07943822f, 
    0.02252218f, -0.09463334f, -0.03481239f, 0.10192978f, 0.06760445f, -0.07454623f, 0.00417939f, 0.00184136f, 
    -0.65374339f, 0.14351101f, -0.08828674f, -0.15278639f, -0.03491364f, 0.03050924f, 0.05702882f, 0.16095150f, 
    -0.14701176f, -0.15344788f, -0.05075370f, 0.09225684f, -0.12626950f, -0.19252439f, 0.00018445f, -0.15070245f, 
    -0.20846225f, -0.09587174f, 0.03113842f, -0.08170704f, -0.05549771f, -0.08717791f, -0.03697057f, -0.32191992f, 
    -0.19468088f, 0.15135661f, -0.03084961f, -0.00522819f, 0.07453960f, 0.09548912f, 0.15935378f, -0.11240536f, 
    -0.14130655f, 0.05005269f, 0.07207863f, 0.16638103f, -0.10917913f, -0.01325545f, 0.01882043f, -0.04752995f, 
    0.15530062f, -0.00218551f, 0.03231405f, 0.16189599f, -0.22867328f, -0.00098059f, 0.04689686f, 0.02965982f, 
    -0.39684102f, -0.20426255f, 0.00787591f, 0.29547104f, -0.11382185f, 0.08925899f, -0.08714072f, -0.04737117f, 
    -0.07099190f, 0.06159911f, -0.00787945f, -0.02626081f, -0.30659878f, 0.16931324f, -0.11781833f, 0.15373567f, 
    0.06979983f, 0.16303502f, 0.04105800f, 0.08896997f, -0.01495637f, 0.07737539f, 0.02839146f, 0.06967071f, 
    0.01906250f, 0.00284222f, -0.01793029f, -0.08111915f, 0.03525311f, 0.00804253f, -0.10794925f, -0.02543575f, 
    -0.16733113f, 0.04212451f, -0.03758616f, -0.12636335f, -0.49991408f, 0.05733735f, 0.21214521f, 0.38089356f, 
    0.05578410f, -0.01120689f, -0.06540802f, 0.07728573f, -0.04864827f, 0.06138206f, 0.15512381f, -0.05626135f, 
    -0.24875723f, 0.00000489f, 0.12251490f, 0.05455407f, 0.08419546f, -0.04386354f, 0.04218313f, 0.16563386f, 
    -0.02498835f, -0.04123776f, -0.21297085f, -0.06663275f, 0.08634313f, 0.08480407f, -0.18679386f, 0.20142224f, 
    0.12035124f, -0.10011153f, 0.16634013f, 0.15813701f, 0.09315392f, -0.17573792f, 0.03311752f, -0.06965413f, 
    -0.53656346f, 0.01691064f, -0.20037270f, 0.08853865f, 0.09963585f, -0.16995510f, -0.16374128f, 0.31303972f, 
    -0.04421510f, 0.02074514f, -0.14163847f, 0.04702964f, -0.14081715f, -0.09553744f, 0.20350955f, 0.31100070f, 
    -0.07792689f, -0.13394250f, 0.16540442f, -0.03953873f, -0.06953631f, 0.02879387f, -0.05307297f, 0.09317265f, 
    0.20808838f, 0.06577957f, -0.08088232f, 0.02607851f, -0.15245904f, -0.00166609f, -0.11080951f, -0.05897984f, 
    0.04329177f, -0.04362783f, 0.02516802f, 0.24903792f, -0.14357395f, -0.10114314f, 0.00465713f, 0.22044376f, 
    0.00643606f, 0.00794721f, 0.02420660f, -0.00898271f, 0.16336073f, -0.10596310f, 0.07629589f, 0.01725033f, 
    -0.19478150f, 0.09694203f, 0.21304068f, -0.27950650f, 0.05285838f, -0.00664798f, -0.05392648f, 0.10578627f, 
    -0.03281032f, -0.05081326f, 0.03242457f, -0.24278341f, -0.06086063f, -0.00376920f, 0.22873729f, 0.15171209f, 
    0.14068891f, -0.04984383f, 0.03950981f, 0.01839195f, 0.12659696f, 0.03506821f, -0.01916360f, 0.00002510f, 
    -0.66854101f, 0.00297665f, 0.09872390f, -0.05068865f, -0.22589850f, -0.13143690f, 0.01263437f, -0.12882397f, 
    0.04379949f, -0.04729271f, 0.12828138f, -0.24180944f, -1.10341525f, 0.46855676f, -0.11932682f, 0.06848104f, 
    0.17407338f, -0.09524094f, -0.03381461f, -0.07719860f, -0.00370936f, -0.01799358f, 0.10352632f, -0.04784690f, 
    -0.07930790f, -0.01534770f, -0.01270023f, 0.08191960f, -0.22002916f, -0.08324438f, -0.13142443f, 0.22446023f, 
    -0.05806212f, -0.03557177f, 0.27642366f, -0.20390101f, -0.47426727f, -0.24884126f, 0.39438763f, 0.47051027f, 
    -0.13763838f, 0.06040997f, 0.09265425f, 0.00821491f, 0.06603989f, 0.06699561f, 0.00856229f, -0.04506122f, 
    -0.23704809f, -0.04740689f, 0.22966015f, 0.30632260f, -0.19093983f, 0.07948252f, -0.06400352f, 0.02709839f, 
    0.06076359f, -0.00442431f, 0.09081197f, -0.04962961f, 0.20220460f, 0.05823191f, 0.12202930f, 0.11536296f, 
    -0.03257537f, -0.16532138f, 0.01396663f, -0.02836253f, -0.10476841f, -0.08615687f, 0.10097647f, 0.18723378f, 
    -0.37235430f, 0.06955902f, -0.05266586f, -0.25672421f, 0.07393209f, -0.10529076f, 0.19360088f, -0.46155408f, 
    0.09904303f, 0.05924724f, -0.32009491f, -0.10079504f, 0.09040125f, -0.11548588f, 0.09788778f, -0.23448902f, 
    -0.04998877f, -0.01699469f, 0.19214125f, 0.12370026f, -0.00673396f, -0.05299139f, 0.13791373f, 0.19833128f, 
    0.25091463f, -0.10096452f, -0.06780568f, 0.28447151f, 0.16175602f, -0.14312026f, -0.05241507f, 0.13123378f, 
    0.19033837f, -0.06108591f, -0.15172628f, -0.03195578f, 0.02299463f, -0.01453915f, -0.09772332f, -0.06415810f, 
    -0.01717496f, -0.08154313f, -0.08823558f, 0.09683532f, 0.03434298f, 0.18148316f, 0.04046942f, -0.12432321f, 
    -0.29350871f, -0.03711695f, 0.10854047f, 0.10695440f, 0.02023241f, 0.08660553f, -0.08030899f, 0.04638149f, 
    0.11908963f, 0.10521539f, -0.14261618f, -0.18419561f, -0.36204696f, 0.30490857f, 0.29486227f, 0.11820414f, 
    -0.00715595f, -0.03540223f, 0.00057688f, -0.00539102f, 0.08553465f, 0.12179050f, 0.00464048f, 0.21196669f, 
    0.01032835f, -0.09211371f, 0.33706969f, -0.16890849f, -0.06680194f, -0.12899856f, 0.02408327f, -0.10263995f, 
    -0.11571337f, 0.03878622f, -0.12612504f, -0.03118390f, 0.01664973f, 0.12811822f, 0.12671643f, 0.03157790f, 
    -0.03461641f, -0.14196201f, 0.10605650f, -0.13281813f, 0.00169787f, -0.13385694f, 0.06169902f, -0.04361510f, 
    -0.36022881f, 0.02263058f, 0.08545160f, 0.00300571f, 0.16720991f, -0.00724078f, -0.13598932f, 0.07528945f, 
    0.09078046f, -0.24915540f, 0.11504349f, -0.36492079f, -1.00584388f, -0.01928202f, -0.19437762f, -0.25781041f, 
    0.10280669f, 0.21136941f, -0.02427492f, -0.22774769f, -0.01914840f, 0.21900198f, 0.12369591f, -0.18184523f, 
    -0.54467350f, -0.16349982f, -0.20395552f, -0.23625158f, 0.29159117f, -0.05364137f, 0.19792998f, 0.08338799f, 
    0.04204736f, 0.10237560f, -0.00910240f, -0.01095663f, 0.16297822f, 0.05468095f, 0.02958364f, -0.05426007f, 
    0.09515723f, 0.22575514f, 0.07115317f, -0.15732613f, -0.03521708f, 0.00169170f, 0.27234060f, 0.15901835f, 
    0.14853890f, 0.16483086f, 0.18842731f, -0.03510805f, -0.01109568f, -0.06135041f, -0.24266222f, 0.08006689f, 
    -0.05817850f, -0.00321058f, -0.00813242f, -0.01102652f, -0.06815647f, -0.20358476f, -0.08561636f, 0.07573521f, 
    0.13521473f, 0.17156586f, 0.23206420f, -0.01291587f, 0.07833240f, 0.04997796f, -0.11151197f, -0.11605356f, 
    0.00492037f, 0.02728527f, 0.19945182f, 0.38770834f, -0.09030753f, 0.01141336f, -0.01421825f, 0.09184529f, 
    -0.11265891f, -0.13259789f, -0.16477734f, 0.12674867f, 0.07491935f, 0.01369562f, 0.18422326f, -0.36304039f, 
    0.07766181f, -0.17002419f, 0.01144532f, 0.01927206f, -0.03245356f, -0.02615548f, 0.02495070f, 0.04150219f, 
    -0.04567245f, 0.25059605f, 0.15652424f, 0.01094873f, -0.16167633f, -0.17954363f, 0.05789451f, -0.03054300f, 
    -0.10899960f, -0.34790322f, -0.01711005f, -0.07524601f, 0.04324533f, 0.01254781f, -0.36258242f, -0.09643197f, 
    0.04507612f, -0.10723726f, -0.07264841f, -0.18807019f, 0.07955287f, -0.04485828f, -0.08334792f, -0.01957911f, 
    -0.40637851f, -0.06193783f, -0.04526728f, 0.06057983f, 0.11593963f, -0.01186197f, 0.00591792f, 0.04609785f, 
    0.09719646f, 0.01625694f, -0.07043759f, 0.04929483f, 0.08174589f, -0.12732892f, -0.36691016f, -0.01841407f, 
    0.18317157f, 0.02039173f, 0.02581254f, 0.07345709f, -0.07246576f, 0.17019653f, 0.06081437f, 0.13023412f, 
    -0.19004649f, -0.00570754f, -0.04488782f, 0.03264119f, -0.02363297f, -0.17388287f, 0.05687608f, -0.09432928f, 
    -0.03547123f, -0.18328646f, -0.14158197f, -0.08242308f, -0.36818150f, -0.15826981f, -0.22085309f, -0.03263489f, 
    0.24343430f, 0.08610064f, 0.02192098f, -0.16676928f, 0.11085559f, -0.03878095f, 0.19115824f, -0.00244448f, 
    -0.15159836f, -0.06421979f, -0.13237536f, 0.02140171f, -0.26837775f, -0.07279360f, -0.03242293f, -0.27450088f, 
    0.00744819f, -0.15889339f, -0.08682847f, 0.16739330f, 0.06724056f, 0.07838709f, -0.17775001f, -0.02314511f, 
    0.02119164f, 0.07387034f, 0.00117175f, -0.12044284f, -0.23485097f, -0.16906828f, 0.11566417f, 0.23942660f, 
    0.13294113f, 0.04721592f, -0.04747706f, 0.34444743f, 0.10087480f, 0.14371036f, 0.10290536f, -0.04456826f, 
    -0.01369496f, 0.12530917f, 0.09852413f, 0.07904679f, 0.08196649f, -0.08398759f, -0.18123281f, 0.10070665f, 
    0.08782421f, -0.12986548f, -0.10678684f, 0.00707581f, 0.00946313f, 0.02445609f, 0.32960850f, 0.26352775f, 
    0.17909576f, -0.25024009f, 0.01677002f, -0.23061442f, -0.32178557f, 0.12814757f, 0.06959284f, 0.01661507f, 
    0.07110995f, 0.16765411f, -0.00700847f, 0.13271683f, -0.41732401f, 0.36832440f, -0.13424993f, -0.30006826f, 
    0.00382995f, -0.02788460f, 0.02495861f, 0.06333384f, -0.07154002f, 0.00774046f, -0.10830506f, -0.13468070f, 
    0.14412621f, -0.07287287f, 0.16778231f, -0.26940656f, 0.13963839f, 0.03738690f, 0.33942190f, -0.05553179f, 
    -0.22975987f, -0.08474513f, -0.14359061f, 0.04765039f, 0.03894764f, -0.12926261f, 0.14810781f, 0.21705952f, 
    0.05972979f, -0.14211239f, -0.20722359f, -0.07975761f, -0.35575065f, 0.01290387f, -0.14778969f, 0.13081864f, 
    0.19570072f, -0.40471151f, -0.24190430f, 0.21685809f, 0.08337210f, -0.01031812f, -0.00396248f, -0.11098926f, 
    -0.07200413f, -0.19300747f, -0.00926902f, -0.02392172f, 0.20055436f, 0.34062019f, 0.16317436f, -0.56546283f, 
    0.04139921f, 0.00158981f, -0.04399218f, -0.01077387f, 0.04700037f, 0.06063886f, -0.08917305f, 0.09280524f, 
    -0.22997808f, -0.28988394f, -0.06361503f, -0.17879297f, -0.09060691f, -0.03742012f, -0.05991699f, 0.20860337f, 
    -0.14253420f, 0.06808468f, 0.11894653f, 0.12710358f, 0.16263713f, 0.00880191f, -0.24700192f, -0.20540935f, 
    -0.07160294f, 0.05096317f, -0.13793820f, -0.07437905f, 0.08732102f, -0.13724364f, -0.13454369f, -0.13935712f, 
    -0.61587846f, 0.26408249f, -0.14955206f, 0.29389369f, -0.03214705f, 0.02244293f, -0.09695056f, -0.01562805f, 
    -0.17957084f, 0.21230601f, 0.16594972f, -0.03518874f, -0.31081516f, -0.05731263f, -0.08662174f, 0.47608340f, 
    0.17326486f, 0.14096063f, -0.05375591f, -0.04688325f, -0.05309471f, -0.04471603f, 0.08360442f, -0.25723106f, 
    0.21847245f, -0.21129987f, -0.02333846f, -0.08384997f, -0.02677943f, -0.05193871f, 0.11079238f, 0.10500146f, 
    -0.00063904f, -0.03487317f, 0.00823844f, 0.05430810f, 0.23917730f, -0.21121924f, -0.07032846f, -0.10765557f, 
    0.00295657f, -0.05217792f, 0.05742692f, -0.06492510f, -0.12048470f, -0.03922968f, 0.07649932f, -0.28349847f, 
    -0.20193489f, 0.19202369f, -0.10764105f, -0.18105952f, -0.17368425f, 0.15865318f, 0.11395080f, 0.09761241f, 
    0.10560770f, 0.03157423f, -0.00632339f, 0.00970992f, -0.42933229f, 0.47166035f, -0.06360132f, 0.43091643f, 
    -0.15301198f, 0.13024309f, -0.00259439f, 0.10442253f, 0.06119185f, 0.11338921f, -0.08232553f, -0.14425169f, 
    0.42163914f, 0.08054771f, -0.13087344f, 0.48274553f, -0.18417756f, 0.06515647f, -0.03944543f, 0.07309319f, 
    -0.07528949f, 0.16630675f, 0.04213297f, 0.13943738f, 0.00544585f, -0.19703372f, 0.10306917f, -0.22237980f, 
    -0.03512070f, 0.01324962f, 0.04289595f, -0.10850975f, 0.16185746f, -0.06943303f, -0.07570312f, 0.03327363f, 
    0.22631067f, -0.49382690f, 0.14874788f, -0.02225025f, -0.06083273f, 0.00624106f, 0.04397867f, -0.12461897f, 
    0.11609555f, -0.05149167f, -0.02903942f, -0.14859773f, -0.18769008f, 0.33927241f, 0.17429376f, 0.04963722f, 
    0.05082393f, 0.04213671f, 0.07443582f, 0.18540855f, 0.13243677f, -0.05561484f, 0.02550769f, -0.22641845f, 
    0.10013469f, 0.01559874f, -0.04444625f, -0.23245260f, -0.13888258f, 0.12499855f, 0.02639115f, 0.05777011f, 
    0.04406404f, 0.04940893f, -0.11971992f, 0.05101475f, -0.14846809f, 0.10116193f, -0.39841843f, -0.22535487f, 
    -0.02788750f, -0.05075182f, 0.04632493f, -0.29934710f, 0.01215777f, -0.16153894f, 0.13988715f, 0.04825528f, 
    -0.01142644f, 0.09888296f, -0.27288502f, -0.03239514f, 0.10013042f, -0.01178538f, 0.04805075f, 0.09930713f, 
    -0.03758333f, 0.05453313f, -0.03417040f, 0.15173504f, 0.19649778f, 0.02986969f, 0.05457504f, -0.07995626f, 
    0.00952122f, 0.19997489f, 0.16323282f, 0.11338294f, 0.06480824f, 0.00408647f, 0.15568778f, -0.20811304f, 
    0.03207346f, -0.06571303f, 0.15265885f, -0.04832372f, 0.05838368f, 0.25725031f, 0.08073762f, 0.01527867f, 
    0.17899996f, 0.16153981f, 0.21549758f, -0.02086176f, -0.25364807f, -0.18811055f, -0.07491141f, -0.18501107f, 
    -0.03219656f, -0.01298015f, 0.06727422f, 0.03208363f, -0.15132646f, 0.13656433f, 0.07674926f, 0.07649989f, 
    -0.15836267f, 0.13012773f, -0.34204516f, -0.50517213f, -0.04202278f, -0.01783429f, -0.00119648f, -0.00294536f, 
    -0.06758558f, 0.05635200f, -0.19255577f, -0.12632324f, -0.19434598f, 0.10343109f, -0.19403462f, -0.33433300f, 
    -0.13723381f, -0.09491873f, -0.14174910f, -0.08170077f, 0.07418988f, -0.12143050f, 0.04618929f, -0.01252683f, 
    0.37678233f, -0.47178349f, 0.10211629f, 0.01526964f, -0.16371915f, 0.15653221f, 0.12804948f, -0.02233625f, 
    0.02285538f, -0.01999287f, 0.11899959f, 0.23333418f, -0.09771243f, -0.14822680f, -0.45426315f, 0.11340727f, 
    -0.12139834f, -0.02923175f, 0.00773494f, -0.06867392f, -0.07721236f, 0.03989499f, -0.13275415f, 0.01640684f, 
    0.00328888f, -0.05127852f, 0.10965230f, -0.24933559f, 0.13330008f, 0.06599339f, 0.07127865f, -0.07970461f, 
    0.03645980f, 0.13704723f, 0.02027605f, -0.03176214f, 0.05734100f, 0.13747859f, -0.07975848f, -0.30451632f, 
    -0.05226191f, 0.06096001f, -0.03544757f, 0.07036409f, 0.07105678f, -0.01388013f, -0.22703768f, 0.09348133f, 
    -0.00654700f, 0.16579904f, 0.18226743f, -0.16049591f, -0.05210396f, -0.00919122f, 0.02847560f, 0.00214248f, 
    0.12722048f, -0.07879872f, 0.04110434f, -0.17401055f, -0.07048145f, -0.05091657f, -0.05465167f, 0.03896644f, 
    -0.01062528f, 0.17283390f, 0.01818727f, -0.10505364f, -0.12174629f, -0.04123332f, -0.03370537f, -0.27173364f, 
    -0.45495650f, 0.27691934f, 0.14782804f, 0.29743990f, 0.01274737f, -0.04878570f, -0.03460976f, 0.01910119f, 
    -0.01177946f, -0.23203768f, 0.06666870f, -0.14165695f, 0.41172010f, -0.49315026f, 0.22488901f, 0.01145530f, 
    0.10105007f, -0.02313298f, -0.01881644f, -0.17390074f, 0.06898238f, -0.08247273f, 0.09294543f, 0.24064633f, 
    0.39585742f, 0.23280460f, -0.03610740f, 0.07688989f, -0.10371434f, -0.15302460f, 0.04160181f, -0.05795587f, 
    -0.04613147f, 0.05195181f, -0.11236411f, -0.14588922f, -0.03839627f, 0.09015951f, 0.10070156f, 0.25214085f, 
    0.14659560f, -0.06135208f, -0.03737387f, -0.00206995f, -0.13575065f, 0.01048160f, -0.10290156f, -0.01414191f, 
    -0.12388093f, -0.01365407f, -0.08280326f, 0.16559753f, -0.22394204f, -0.05840043f, -0.01838740f, -0.03944182f, 
    0.03755934f, 0.08860933f, -0.04866769f, -0.02801868f, 0.13206537f, -0.21609722f, -0.25376877f, -0.04075415f, 
    -0.02078609f, -0.08169965f, -0.00292278f, -0.06427339f, -0.06775591f, -0.01797260f, 0.00114111f, -0.08000083f, 
    -0.13823840f, 0.06947297f, 0.12980156f, 0.00735056f, 0.13754438f, 0.02347146f, -0.12009890f, 0.08359853f, 
    -0.05247498f, 0.01858085f, -0.00271233f, -0.03954398f, -0.74602395f, 0.21648474f, -0.06464785f, 0.10771704f, 
    -0.10992258f, -0.18516891f, -0.14039627f, -0.04000005f, -0.01445308f, 0.10807392f, 0.00437615f, -0.10887835f, 
    -0.40068915f, -0.11715443f, -0.21467975f, -0.38849697f, 0.10731410f, -0.00557606f, -0.05065628f, -0.04268808f, 
    -0.18708076f, -0.00893770f, -0.09179767f, -0.15686968f, -0.11762256f, 0.03195644f, -0.30189750f, 0.07781368f, 
    -0.14579414f, 0.01406654f, -0.05461472f, -0.05972825f, -0.03226150f, 0.00759615f, 0.07758979f, -0.09400875f, 
    -0.00310939f, -0.34644237f, 0.05065181f, -0.16379121f, 0.03047060f, -0.05467807f, -0.04817469f, -0.17362660f, 
    0.02576743f, 0.01734786f, -0.00549445f, -0.02068011f, -0.24081002f, -0.12852786f, -0.25709623f, -0.21972777f, 
    0.02474250f, 0.03381434f, -0.03281907f, -0.17312396f, -0.13555053f, -0.09385130f, -0.16842084f, -0.04602024f, 
    -0.02473675f, 0.50194949f, 0.18656112f, -0.13691874f, -0.01456957f, 0.04553788f, -0.02309080f, -0.07680739f, 
    -0.06669048f, -0.08008694f, 0.08489632f, 0.05603072f, -0.03059566f, -0.26002267f, -0.32256135f, -0.26847944f, 
    -0.00591787f, -0.07933608f, -0.11450700f, -0.03259639f, -0.17311880f, 0.06788191f, -0.00739859f, -0.12555173f, 
    0.05043395f, 0.25015610f, -0.06533515f, 0.41807377f, 0.11414141f, -0.05764680f, 0.01829367f, 0.19104762f, 
    -0.12572505f, 0.04839886f, 0.09012203f, -0.00274750f, -0.27360669f, 0.13219337f, 0.25973701f, -0.01124702f, 
    0.25034502f, 0.16931623f, -0.01719459f, -0.09362641f, -0.13685565f, 0.04187421f, -0.12095939f, -0.08204372f, 
    0.20969130f, -0.09984348f, 0.11273672f, -0.05500656f, 0.07008713f, 0.04361007f, 0.03391802f, -0.01072879f, 
    -0.13780305f, 0.08347237f, -0.14484717f, -0.02342990f, -0.48737642f, 0.11797919f, -0.16406332f, -0.14893159f, 
    -0.07691870f, 0.08721689f, 0.01965396f, -0.02622301f, 0.02150633f, 0.03485356f, 0.08196862f, -0.08838486f, 
    -0.21938005f, 0.12079745f, -0.03055533f, -0.15984838f, -0.07595790f, -0.10629663f, -0.04411587f, -0.04156751f, 
    -0.08505355f, 0.07825039f, -0.11565885f, -0.15485312f, 0.16357443f, 0.10776210f, 0.27650845f, 0.35250598f, 
    0.26374340f, 0.14550023f, 0.02780833f, -0.04543551f, -0.12152672f, 0.05988482f, 0.00061477f, -0.04154977f, 
    -0.66148651f, 0.07927027f, -0.06471573f, 0.20739749f, -0.01038555f, -0.26403812f, -0.18064491f, 0.01445646f, 
    -0.01490172f, 0.02617323f, 0.05890890f, -0.00866074f, 0.06287045f, -0.23998071f, -0.00540835f, -0.24451551f, 
    0.05334016f, -0.01287633f, -0.09480976f, -0.00706570f, -0.11674833f, -0.00569568f, -0.09636480f, -0.19893821f, 
    0.10601310f, 0.05509015f, 0.02545405f, -0.02373610f, -0.20857884f, -0.04908871f, 0.00595486f, -0.09427551f, 
    -0.22130965f, 0.00149841f, -0.11206194f, -0.08178492f, 0.04463677f, 0.27561608f, 0.15475889f, 0.17545064f, 
    0.12501940f, 0.01719351f, 0.00969440f, -0.06943744f, 0.01422093f, 0.17272685f, -0.00114872f, -0.11086512f, 
    0.13778177f, 0.14178228f, 0.24402273f, 0.13670579f, -0.19749661f, 0.06074486f, -0.01541101f, -0.11526262f, 
    -0.07402278f, 0.04572593f, 0.00605115f, -0.11850151f, -0.02754953f, 0.25469071f, 0.04609132f, 0.16996725f, 
    0.08748366f, 0.00520033f, -0.13692425f, -0.02857027f, 0.01966075f, -0.00731234f, -0.17113043f, -0.04229846f, 
    0.04029476f, 0.30282810f, 0.05746742f, -0.01319947f, 0.24856584f, 0.11972592f, -0.04357111f, 0.05107053f, 
    0.12517147f, 0.00949808f, 0.05893445f, -0.08987363f, 0.19354735f, 0.15914808f, 0.16390124f, 0.29149890f, 
    0.30092454f, 0.00465867f, 0.16586292f, 0.02997505f, 0.02755711f, -0.04283383f, 0.05745162f, -0.04593218f, 
    -0.10649893f, 0.16966482f, -0.13979071f, 0.04122534f, -0.13233060f, 0.00482065f, -0.07597709f, -0.04076190f, 
    -0.02680383f, 0.06090754f, -0.09823032f, -0.07703586f, 0.10589045f, -0.06138103f, -0.09528494f, 0.20136677f, 
    -0.10430957f, 0.00360682f, -0.05950381f, -0.02824785f, -0.09050106f, 0.06256425f, 0.01168925f, -0.06188871f, 
    -0.24455920f, -0.22271988f, -0.09034277f, 0.03905342f, -0.20697366f, -0.01192294f, 0.04612879f, -0.08141115f, 
    -0.00240020f, -0.08966805f, 0.09870325f, -0.00034310f, 0.13586412f, -0.09862675f, 0.04045403f, 0.11105970f, 
    0.00654472f, -0.12853467f, -0.06374566f, -0.13635983f, -0.04048111f, 0.05020814f, -0.07002692f, -0.13249759f, 
    0.02689783f, -0.23173612f, 0.00665388f, -0.20483133f, -0.05000527f, 0.08244354f, 0.02452201f, -0.09721507f, 
    0.12254729f, -0.00686251f, -0.05985764f, -0.04416262f, 0.14066327f, -0.38561019f, 0.32388854f, -0.08786262f, 
    -0.04859993f, 0.13278274f, 0.01233093f, 0.22833917f, 0.04915128f, 0.18636379f, -0.16955952f, 0.03647626f, 
    0.01642102f, -0.21114807f, 0.16460055f, -0.05059212f, 0.10710375f, -0.01404728f, -0.14184900f, 0.01621309f, 
    0.11166028f, 0.16946732f, 0.20856230f, -0.06481238f, -0.25945890f, 0.11058091f, -0.12009545f, -0.21834140f, 
    0.07112516f, -0.06259554f, -0.23116747f, -0.04110516f, 0.15843078f, 0.03021460f, 0.04825835f, 0.00885096f, 
    0.18863933f, 0.21216398f, -0.30112106f, -0.08065584f, -0.03959201f, 0.04749751f, -0.01106160f, -0.05708043f, 
    0.06541861f, -0.11083945f, 0.05113967f, 0.03575115f, -0.30738875f, -0.23999268f, -0.28660628f, 0.17846589f, 
    0.19141454f, -0.02236165f, 0.04034504f, -0.01329665f, 0.01333741f, 0.01427773f, 0.10941504f, -0.01114763f, 
    -0.14153303f, -0.08717452f, 0.17630310f, 0.19449152f, -0.05941427f, -0.14677471f, -0.04978929f, -0.27746916f, 
    -0.11409963f, 0.10119950f, -0.08369415f, 0.00529958f, -0.15674490f, -0.07771441f, -0.09078216f, 0.20589440f, 
    -0.09142075f, 0.06411607f, -0.02157526f, -0.03299361f, 0.12166057f, 0.10689400f, 0.10733511f, -0.04348469f, 
    0.23449035f, 0.08283979f, -0.11774500f, -0.14849003f, 0.05065851f, 0.00714714f, 0.08320551f, 0.02630676f, 
    0.12125472f, 0.09328027f, -0.22135338f, 0.05202723f, 0.19001378f, 0.21637753f, -0.30745620f, -0.30275881f, 
    0.02483798f, -0.08045640f, 0.05766489f, -0.00664354f, 0.13035418f, -0.16950244f, -0.13542704f, -0.03508657f, 
    0.16298686f, 0.14898182f, 0.09116571f, 0.12968442f, 0.09285645f, 0.06012556f, -0.04048918f, -0.12340324f, 
    -0.04867193f, -0.16512060f, -0.20415965f, -0.08773873f, 0.04618654f, 0.18452516f, 0.12770426f, 0.13997903f, 
    -0.11094238f, -0.15439662f, -0.08327486f, -0.05607316f, 0.10647006f, -0.04968297f, 0.03589312f, 0.12688099f, 
    -0.02934369f, -0.25963321f, 0.18003668f, 0.23612022f, 0.09546213f, -0.07349673f, -0.17950565f, 0.02753365f, 
    0.14227776f, 0.07759353f, 0.14018068f, -0.22405882f, 0.20827830f, 0.09506026f, -0.21398883f, -0.09719011f, 
    0.07555941f, 0.08420499f, -0.12706950f, -0.13230178f, 0.04809555f, 0.02324282f, 0.01557170f, 0.06675339f, 
    -0.12046366f, 0.34584957f, -0.14856009f, -0.37131101f, -0.03905250f, -0.04020430f, -0.16419490f, -0.09460589f, 
    0.12653764f, -0.04858452f, 0.15230887f, -0.02193530f, -0.09248838f, -0.31134909f, 0.35587183f, -0.15175460f, 
    0.04389921f, 0.02256455f, -0.13756745f, -0.17860463f, -0.11143109f, 0.04839905f, -0.01178338f, -0.13211262f, 
    -0.03565470f, -0.29291523f, 0.12679638f, -0.08714893f, -0.07244856f, -0.00244252f, 0.18568406f, -0.03749315f, 
    0.09959468f, 0.22132888f, 0.09432271f, 0.05286009f, 0.01368209f, -0.08844575f, -0.06416385f, 0.07516880f, 
    0.17578985f, -0.04920708f, -0.00834136f, -0.14133875f, -0.23295517f, 0.15522227f, 0.01139868f, 0.14330809f, 
    0.07450906f, 0.08172140f, -0.08065788f, 0.07990171f, 0.00702650f, -0.02798413f, -0.08440466f, -0.06932071f, 
    0.12434531f, -0.13231023f, 0.12021774f, -0.00932175f, -0.19036759f, -0.05696927f, 0.04635713f, -0.45816308f, 
    0.09902182f, 0.03920378f, 0.22336203f, 0.00414162f, 0.05561842f, -0.10571787f, -0.12724335f, -0.14955755f, 
    -0.26505581f, 0.08508664f, -0.41476485f, -0.17875104f, 0.12374225f, 0.09970246f, -0.16650181f, 0.08428521f, 
    0.10972235f, 0.03990357f, -0.01767464f, -0.00493787f, 0.03684181f, -0.14216638f, 0.00780445f, -0.07148025f, 
    -0.02937444f, -0.09888763f, -0.11960621f, 0.00864501f, 0.03049661f, 0.02608111f, 0.06301168f, -0.00753207f, 
    -0.18435620f, -0.12409579f, -0.12180033f, -0.19247894f, 0.01490530f, -0.05461464f, 0.05862193f, 0.05208693f, 
    0.02166159f, -0.24876998f, -0.01494156f, 0.05482686f, -0.00040857f, 0.20369951f, 0.07259542f, 0.23464648f, 
    -0.41606712f, -0.05425027f, -0.15042314f, -0.08313803f, 0.08377844f, -0.05027967f, -0.00484756f, 0.00296666f, 
    -0.25449109f, 0.01032660f, 0.08594991f, -0.18782671f, -0.00422479f, -0.00728441f, 0.14246553f, -0.08724654f, 
    0.02618427f, 0.14927407f, 0.06138459f, 0.12803139f, -0.36930114f, 0.07897794f, -0.10688752f, -0.07709130f, 
    -0.09744218f, -0.14043716f, -0.02477141f, 0.04287777f, 0.02963062f, 0.05574450f, 0.04389486f, -0.26014069f, 
    0.14088467f, -0.15666927f, 0.14992025f, -0.03487990f, 0.02729226f, 0.00499715f, 0.05296932f, -0.26266494f, 
    -0.10735207f, -0.22741884f, 0.03418350f, -0.05212718f, 0.03355860f, 0.10351492f, 0.01074490f, 0.20434250f, 
    -0.16801654f, -0.12544739f, 0.05484449f, 0.00934445f, -0.04233013f, 0.07317675f, 0.03431824f, -0.02976939f, 
    -0.33867869f, 0.07340278f, 0.07127891f, 0.00199001f, 0.03137080f, -0.00856044f, -0.13525760f, -0.00275467f, 
    0.08504076f, -0.08436377f, -0.03104868f, 0.03682438f, -0.28696308f, -0.12413009f, -0.15247549f, -0.44395739f, 
    -0.13975365f, 0.04849995f, -0.02305027f, -0.05539273f, -0.15680511f, 0.01156831f, 0.15426573f, -0.07392636f, 
    0.04603477f, -0.02703802f, -0.09269574f, 0.15697765f, 0.22123866f, 0.07052977f, 0.01534978f, -0.11912847f, 
    -0.17477517f, 0.14176573f, 0.06154845f, 0.09016535f, -0.06363252f, -0.13837436f, -0.19564384f, -0.38259444f, 
    -0.10186823f, -0.13524647f, 0.01084530f, -0.11477914f, 0.07879141f, 0.07352589f, 0.16059041f, 0.11680459f, 
    0.30948317f, 0.14102039f, -0.20528422f, 0.26062548f, 0.05479396f, -0.04710085f, -0.02048679f, 0.00033080f, 
    -0.14215517f, 0.12783027f, 0.00195035f, 0.12352449f, -0.23854795f, -0.08187010f, 0.08851744f, 0.11551291f, 
    -0.14305358f, -0.13736717f, -0.08600137f, 0.03074024f, 0.14050350f, -0.19690056f, -0.18122599f, 0.02708956f, 
    0.26550367f, 0.03152859f, -0.09320612f, -0.11714076f, -0.10581331f, -0.13185249f, -0.04917367f, 0.00777172f, 
    -0.03417402f, 0.01625025f, -0.00658703f, 0.13142423f, 0.07750881f, -0.76166141f, -0.09324389f, 0.18771160f, 
    -0.11244396f, 0.01521416f, 0.08409596f, 0.09690069f, -0.19790085f, -0.11337435f, 0.08592793f, -0.00520168f, 
    -0.23222013f, 0.30031821f, 0.26664278f, 0.03297995f, 0.07471716f, -0.07233556f, -0.22998609f, 0.06403729f, 
    -0.03795992f, 0.07371823f, 0.09960688f, 0.10894512f, -0.44237342f, -0.02647168f, -0.08965033f, -0.38169381f, 
    0.06901205f, -0.01195629f, -0.10337065f, -0.04528621f, -0.19377442f, 0.00378418f, -0.09457071f, -0.04770850f, 
    -0.08090686f, 0.00214016f, -0.18050395f, 0.22183111f, -0.01909282f, 0.11192755f, -0.00213946f, 0.10017720f, 
    0.06052409f, -0.04500956f, 0.17344517f, -0.17749916f, -0.48154694f, 0.56919497f, -0.36923057f, -0.33225462f, 
    -0.01113162f, -0.00837893f, 0.11361819f, 0.03948867f, 0.01002216f, 0.09576850f, -0.08949015f, -0.27079925f, 
    0.53724092f, 0.19686227f, 0.10447852f, -0.10944703f, -0.10415746f, -0.05180740f, 0.14467961f, -0.09749226f, 
    -0.13217710f, -0.02199567f, -0.08057572f, 0.05948601f, 0.27247980f, 0.25559676f, 0.15197624f, 0.12066504f, 
    -0.06162993f, 0.04243016f, 0.06318233f, 0.07038809f, -0.02265234f, -0.05431630f, 0.06555265f, 0.07088827f, 
    0.23004872f, -0.31720069f, 0.11195017f, 0.07390925f, 0.12301015f, 0.01389142f, -0.08147153f, -0.20214479f, 
    -0.21906817f, 0.09489316f, 0.07568131f, 0.27666739f, 0.52479279f, 0.43034035f, -0.32992002f, -0.54852396f, 
    0.32686380f, 0.03926468f, 0.04237610f, -0.12265480f, -0.11891770f, -0.07180260f, 0.01269539f, 0.00000808f, 
    -0.60881329f, 0.36494845f, -0.20486218f, -0.21466586f, 0.13892050f, 0.09505630f, -0.08984248f, -0.12677175f, 
    -0.17340347f, -0.10970823f, 0.00648276f, 0.10371733f, 0.35544765f, -0.21046251f, 0.25255138f, -0.07116131f, 
    0.14900902f, 0.01361170f, -0.01485105f, 0.03031012f, -0.11267316f, 0.06896479f, -0.12662300f, 0.00992809f, 
    -0.67462587f, -0.26304564f, 0.48965278f, -0.25748557f, -0.09686875f, 0.07063892f, 0.02334977f, -0.03912676f, 
    0.09332959f, -0.08626524f, 0.01390481f, 0.01145845f, -0.14670461f, -0.15570602f, 0.00614592f, 0.33100799f, 
    -0.02165686f, 0.03028153f, 0.03471642f, -0.13213597f, 0.09831105f, 0.05465702f, -0.04753822f, 0.14067616f, 
    0.33397499f, 0.06246118f, -0.08934339f, 0.11846415f, -0.01290343f, 0.05884846f, -0.13172622f, -0.04923554f, 
    0.09659243f, 0.02953524f, 0.03250890f, -0.02470636f, -0.17666893f, -0.14639333f, 0.24640627f, 0.12591663f, 
    -0.07227796f, -0.03836738f, -0.13980791f, -0.01979845f, 0.14344905f, -0.04120773f, 0.07096919f, -0.12498976f, 
    -0.42095116f, 0.16850375f, -0.04873144f, 0.09876467f, 0.06047511f, -0.00569492f, 0.16123287f, -0.01616532f, 
    0.01634001f, 0.17385575f, 0.06235910f, -0.08757529f, 0.24875113f, 0.05403334f, -0.15649618f, 0.17545474f, 
    -0.03525149f, 0.03168903f, -0.13562024f, 0.10897280f, -0.21669024f, -0.02510385f, 0.00215449f, 0.17565283f, 
    -0.10213279f, 0.10137592f, -0.00819301f, -0.59222007f, -0.12045598f, -0.03272692f, -0.21092081f, -0.07356113f, 
    0.03169189f, -0.05883482f, 0.10058327f, -0.00256418f, 0.07786999f, -0.11137424f, 0.12367579f, -0.14614123f, 
    -0.06171997f, -0.14588287f, -0.14049521f, -0.06757971f, 0.10842495f, 0.09442115f, 0.01327726f, 0.14418313f, 
    -0.32051533f, 0.08090377f, -0.26272091f, 0.03336962f, -0.13959251f, -0.02564599f, -0.01715553f, 0.08345795f, 
    -0.07395740f, 0.16332558f, 0.06776420f, 0.06899022f, -0.25597820f, -0.21354252f, -0.03915581f, 0.06842595f, 
    0.15547381f, 0.11801054f, 0.01397439f, 0.26357624f, 0.05733766f, -0.06272099f, -0.01525847f, 0.08249648f, 
    -0.02171647f, -0.18307248f, -0.02622327f, 0.11934227f, -0.01339051f, 0.04053593f, -0.05513996f, -0.22408925f, 
    -0.01050676f, 0.00462009f, 0.00561781f, -0.20925874f, -0.07396917f, -0.04188714f, -0.03823252f, 0.09799828f, 
    0.01755502f, 0.23315334f, -0.06583358f, 0.02138049f, -0.06520458f, 0.05907128f, -0.16305235f, 0.00615850f, 
    0.19445741f, 0.04792733f, 0.14319651f, -0.06752317f, -0.05003128f, -0.00931473f, -0.03492620f, -0.03477007f, 
    0.21079315f, 0.14202248f, 0.03943213f, 0.07941433f, 0.01900082f, -0.57669586f, 0.15323427f, -0.17144065f, 
    0.05638653f, 0.02621888f, -0.04338925f, 0.01610235f, -0.07500625f, -0.05093412f, -0.09515904f, 0.02015514f, 
    0.14889488f, 0.15268023f, 0.03447411f, -0.16939798f, -0.06343761f, -0.07615221f, 0.21336126f, 0.18979181f, 
    -0.02271745f, 0.18539619f, 0.05286586f, -0.13693990f, 0.01035004f, -0.02607797f, -0.23035811f, 0.03253452f, 
    -0.11278672f, -0.03166752f, 0.06438696f, -0.07471518f, 0.15489049f, 0.17335035f, 0.11415734f, 0.04494159f, 
    -0.01335359f, 0.09144033f, -0.19246820f, -0.09414428f, 0.08165953f, -0.03904008f, 0.03712906f, -0.02288387f, 
    0.01287957f, -0.11385708f, -0.21513382f, 0.05901625f, 0.12928261f, -0.07804532f, 0.02113562f, -0.07704245f, 
    -0.07947704f, 0.01268327f, -0.00231634f, 0.00239716f, 0.02339759f, -0.14711547f, -0.33688352f, -0.18943080f, 
    0.18438825f, -0.18918352f, 0.14298309f, 0.17859158f, 0.02999006f, 0.06157766f, 0.02973145f, -0.25679162f, 
    -0.15232840f, -0.00047276f, -0.11656307f, 0.10527241f, 0.20998526f, -0.07222691f, -0.35753596f, 0.02004538f, 
    0.08919174f, -0.00286401f, -0.07516091f, -0.12308858f, -0.14201824f, 0.11241937f, 0.00872485f, -0.04223891f, 
    -0.35676280f, 0.00220133f, 0.29431117f, -0.12268873f, 0.10792560f, -0.01405537f, -0.02565301f, -0.13998632f, 
    0.05404000f, 0.31067440f, -0.00981020f, 0.07044153f, -0.13632898f, -0.14402561f, -0.13336785f, 0.06749226f, 
    0.15366662f, 0.15962374f, 0.10866606f, -0.04067166f, 0.01664911f, 0.02539160f, 0.03832284f, -0.03121149f, 
    0.00873189f, -0.13363412f, -0.12820782f, -0.04397368f, 0.01956956f, 0.05229669f, -0.00888954f, 0.04955773f, 
    0.15202923f, -0.11703746f, 0.01249929f, -0.03763735f, -0.35812950f, -0.26086488f, -0.19542091f, -0.38070595f, 
    0.08885276f, -0.06567577f, -0.01052385f, -0.02026564f, -0.01711741f, 0.17749448f, 0.02624746f, 0.09457069f, 
    0.24085821f, 0.08718261f, 0.13719440f, 0.10912713f, -0.13136661f, -0.12536818f, -0.02140603f, -0.02220673f, 
    0.00079825f, -0.12074456f, -0.26485977f, 0.00102964f, 0.25440148f, -0.26509118f, -0.04596759f, -0.09002708f, 
    0.02139970f, 0.05913403f, 0.07656947f, 0.05443427f, 0.07584135f, 0.08954333f, 0.20315827f, 0.04720974f, 
    -0.53422499f, -0.03935193f, 0.12570979f, 0.02886871f, 0.02450988f, 0.20551141f, 0.05085690f, 0.01560040f, 
    0.07239655f, 0.02195928f, 0.03384416f, 0.04325468f, -0.42134362f, -0.00290612f, 0.27781594f, 0.14570840f, 
    0.21271959f, -0.09525609f, 0.00478508f, -0.05155265f, 0.07061347f, 0.03112411f, -0.04646580f, 0.18827939f, 
    -0.60700494f, 0.17186324f, -0.30117774f, -0.34340784f, -0.02192707f, 0.17141841f, -0.22712748f, 0.01164056f, 
    0.13728315f, 0.00082646f, 0.02397351f, -0.15503836f, -0.49043480f, -0.02062191f, -0.25269395f, -0.14171077f, 
    -0.13110933f, 0.03844338f, 0.05714914f, 0.07444195f, 0.12482996f, 0.09375358f, 0.20289692f, 0.17672141f, 
    -0.77602118f, -0.36396906f, -0.09133344f, -0.31610486f, 0.09281201f, -0.14765674f, -0.05614153f, 0.00861529f, 
    -0.05590496f, -0.01983991f, -0.19766012f, -0.17540322f, -0.97145808f, -0.31418803f, 0.34304237f, 0.12153881f, 
    0.15707259f, 0.02959970f, -0.02134245f, -0.11149324f, 0.02223841f, 0.03664808f, -0.08912751f, 0.08941524f, 
    -0.21075352f, -0.04744091f, -0.15104496f, -0.05750383f, 0.12411530f, -0.02051280f, -0.05858595f, -0.04573601f, 
    -0.01099479f, -0.04186436f, -0.02293807f, -0.28850272f, 0.54019982f, -0.06084472f, -0.12610395f, 0.16338162f, 
    -0.10654347f, -0.00790173f, 0.00782077f, 0.16216867f, -0.03409324f, 0.03080600f, -0.15591006f, -0.12662125f, 
    0.18452062f, -0.07811023f, -0.03276253f, 0.05088457f, -0.03248141f, -0.02383864f, 0.05035293f, 0.02777068f, 
    0.00991763f, 0.05748238f, -0.03815749f, 0.09646739f, -0.49713314f, -0.14004360f, 0.25112376f, 0.06351674f, 
    0.17697814f, -0.04691791f, -0.16483790f, -0.15804501f, 0.02158735f, 0.02187828f, -0.15652153f, 0.33965522f, 
    -0.47236443f, -0.24808197f, -0.27928221f, -0.01710377f, 0.16920199f, -0.03537187f, -0.07916985f, -0.16281950f, 
    0.06395093f, -0.33159125f, -0.03100790f, -0.01459393f, 0.14885692f, 0.09704684f, 0.03359174f, -0.19658607f, 
    0.12625292f, 0.08657757f, -0.01240447f, -0.11309375f, 0.15258005f, 0.10888061f, -0.05240827f, -0.08161119f, 
    0.29839268f, -0.01888626f, -0.22688755f, -0.02563405f, 0.19508390f, 0.19047759f, 0.07464754f, 0.01316984f, 
    0.09438990f, -0.10498849f, -0.06052429f, -0.11973086f, -0.09942864f, -0.06008190f, -0.02795370f, 0.00358680f, 
    -0.03897036f, -0.19064392f, -0.20587681f, 0.04119274f, -0.03150441f, -0.10622676f, 0.03471050f, 0.01584659f, 
    0.02245662f, -0.07870682f, 0.20388913f, 0.17446567f, 0.00587634f, 0.07918840f, -0.14852805f, 0.05345695f, 
    0.14108880f, -0.08116945f, 0.05967240f, 0.10976149f, 0.09972896f, 0.15456992f, -0.16861556f, -0.13436250f, 
    -0.04097570f, -0.14603245f, 0.01985320f, -0.04592031f, 0.18654968f, -0.03780835f, -0.08495019f, -0.18526380f, 
    0.23452070f, 0.06170699f, -0.01025202f, 0.13351856f, 0.09171017f, 0.15602867f, 0.03508173f, 0.02345035f, 
    0.00366696f, -0.00827868f, 0.11642808f, 0.18166567f, 0.21590719f, 0.15738164f, -0.04925441f, -0.00694861f, 
    -0.01286062f, -0.07625842f, -0.01189580f, 0.17237000f, 0.12901290f, 0.12523143f, -0.06587507f, 0.00136693f, 
    0.13796860f, 0.13225800f, -0.24662663f, 0.03068639f, -0.22535717f, -0.02798016f, -0.10682592f, -0.25791892f, 
    0.07704050f, -0.10286069f, 0.04751245f, -0.09396081f, 0.02109829f, 0.01041394f, -0.16995960f, 0.09177202f, 
    -0.19377950f, -0.09728796f, 0.07782154f, -0.08128465f, -0.01740009f, 0.25380516f, 0.10345467f, -0.09218416f, 
    -0.50609303f, -0.27662593f, -0.06640792f, -0.00954924f, 0.10735672f, 0.01206523f, 0.04306162f, 0.02462673f, 
    0.06912092f, 0.12448695f, -0.12495596f, 0.09256797f, 0.42417452f, 0.20067385f, 0.22004327f, -0.15629360f, 
    0.17711835f, 0.08958577f, -0.02697300f, 0.17612252f, -0.05232679f, -0.05291770f, -0.10039317f, -0.01805872f, 
    -0.67877501f, -0.31840873f, -0.18918467f, -0.41434512f, 0.03468198f, 0.01258442f, 0.00521626f, 0.01983375f, 
    0.17256063f, 0.23218037f, 0.03475894f, 0.14334700f, 0.24070378f, 0.09322867f, -0.09453058f, -0.03909336f, 
    -0.05854160f, 0.07299820f, 0.19687700f, 0.04129260f, -0.13071388f, 0.16995317f, 0.22956081f, 0.03261272f, 
    -0.23907910f, -0.22425619f, -0.21399406f, -0.01079741f, -0.00120938f, 0.19335887f, 0.03703025f, 0.18000123f, 
    0.21310098f, 0.09673059f, -0.16857331f, 0.10414277f, 0.35787791f, -0.05086291f, 0.02496351f, -0.02170232f, 
    -0.23113109f, -0.08412490f, -0.00521031f, 0.08073401f, -0.04945572f, -0.09319261f, -0.09443890f, 0.02955633f, 
    -0.26159155f, 0.08836029f, 0.25483450f, -0.30161828f, 0.34169737f, 0.03197834f, -0.05102409f, 0.03572525f, 
    0.02108154f, -0.12995949f, 0.03059601f, -0.05488525f, -0.28421554f, 0.02224070f, 0.03621959f, 0.23959455f, 
    0.03491242f, 0.07402026f, -0.06882718f, -0.05625923f, -0.04371604f, -0.15882312f, 0.15190646f, 0.14920589f, 
    0.01749107f, -0.35746607f, -0.08661097f, 0.26741517f, 0.15192598f, -0.00612734f, -0.01576246f, -0.00922967f, 
    0.08645704f, 0.02436909f, -0.07444803f, 0.13893715f, 0.51941729f, 0.18766597f, -0.37431347f, -0.25638276f, 
    0.00372657f, -0.05410200f, 0.02809891f, -0.01759450f, 0.00453481f, -0.01475064f, -0.14054309f, 0.09482943f, 
    0.05617680f, -0.12524287f, 0.05373880f, -0.15567647f, 0.00832995f, -0.01928904f, 0.05109119f, 0.10282914f, 
    -0.22462127f, 0.06390470f, 0.22907269f, 0.09626058f, -0.00770759f, -0.29433748f, 0.09868918f, 0.18922485f, 
    0.17925376f, -0.14506447f, 0.12979443f, -0.02310008f, -0.04541169f, -0.06134550f, -0.12197528f, 0.12507908f, 
    0.32600969f, 0.04212612f, 0.02807367f, -0.24445660f, 0.06799326f, -0.06592328f, -0.21110223f, 0.22504316f, 
    0.01362017f, 0.04459922f, 0.15660822f, 0.07169847f, 0.31044060f, 0.16578919f, 0.07665114f, -0.16159844f, 
    -0.20216833f, -0.07067939f, 0.03800373f, -0.11284034f, -0.03789711f, 0.05201956f, 0.00192112f, 0.06349955f, 
    -0.42360991f, -0.23597078f, 0.08880418f, -0.33904567f, 0.00449068f, -0.14758945f, -0.07705576f, 0.10347272f, 
    0.02695210f, 0.00658102f, 0.05230214f, -0.01532754f, -0.01274773f, -0.53231531f, 0.08311485f, -0.14042474f, 
    -0.11912065f, 0.06658969f, -0.01924787f, 0.03024887f, -0.11588039f, 0.04063841f, -0.05092312f, 0.05596269f, 
    -0.08346950f, -0.16303055f, -0.14620209f, -0.09946901f, -0.05640582f, -0.03962157f, 0.12335383f, 0.01740025f, 
    0.16509035f, -0.05395769f, 0.02123972f, 0.04457349f, 0.53978139f, 0.26333463f, -0.13400830f, -0.02531089f, 
    -0.03675685f, 0.05647877f, -0.09224154f, 0.00973499f, 0.05902142f, 0.03608904f, 0.03591869f, -0.01116116f, 
    0.14871989f, -0.55324918f, -0.39448446f, 0.05570270f, -0.21031560f, 0.14144020f, -0.18069692f, -0.26418090f, 
    0.19146031f, 0.06799389f, -0.08578193f, 0.04730958f, 0.53668112f, -0.08367354f, 0.10502003f, -0.14636347f, 
    -0.06367044f, 0.07457580f, -0.03652685f, -0.01384723f, 0.01111619f, -0.05073794f, 0.06780662f, 0.07520436f, 
    -0.40230888f, 0.00431676f, 0.19559242f, 0.02856244f, 0.04798406f, 0.17507568f, -0.01218785f, -0.01101363f, 
    0.06173849f, 0.07369449f, 0.14609697f, -0.03959612f, 0.42252529f, 0.05151263f, -0.07268822f, 0.05264898f, 
    0.00408447f, 0.07251160f, -0.03957457f, 0.04750998f, 0.01392856f, -0.09533601f, -0.15354985f, 0.03113620f, 
    -0.16012755f, -0.17625333f, -0.10134532f, -0.23478766f, 0.07640591f, 0.01543753f, 0.14845800f, 0.10222075f, 
    0.09285381f, -0.03669127f, -0.18854374f, 0.01515043f, -0.07571125f, 0.19550397f, 0.01270166f, 0.03120686f, 
    -0.17430399f, -0.08102779f, -0.16157703f, -0.06051989f, 0.04371819f, 0.05613101f, -0.00585942f, -0.04930307f, 
    0.40055180f, 0.09257149f, -0.27546442f, 0.30377713f, 0.07503389f, 0.06275032f, 0.09813238f, 0.05679115f, 
    0.04775579f, 0.09675954f, 0.09835272f, -0.05306697f, -0.35998690f, 0.18745151f, -0.05315690f, -0.24231997f, 
    -0.11520512f, -0.10674167f, -0.08289591f, 0.05233153f, -0.12248671f, 0.05860769f, -0.15809558f, 0.03941708f, 
    -0.30691841f, 0.21285318f, -0.04323214f, -0.08169353f, 0.14275001f, -0.03736205f, -0.01486336f, -0.09222760f, 
    -0.07780827f, 0.05987364f, 0.02281955f, -0.11284072f, -0.00505771f, -0.10911284f, -0.09684705f, 0.00436042f, 
    -0.06116005f, -0.09627997f, 0.09159064f, -0.07740774f, -0.18127221f, 0.10834251f, 0.00937001f, -0.24284284f, 
    0.16198434f, 0.16059576f, 0.01066329f, -0.15357205f, -0.00787979f, -0.13322604f, -0.04031799f, -0.12434218f, 
    -0.07547628f, -0.15677130f, -0.15134688f, -0.29708421f, 0.37851483f, -0.00353509f, 0.05579928f, 0.43854219f, 
    -0.00917637f, -0.12072769f, 0.15322737f, -0.10171162f, -0.12033881f, -0.09735946f, -0.06162382f, -0.02902993f, 
    -0.59135962f, -0.20560454f, -0.07309600f, -0.03907773f, -0.03651411f, 0.16991973f, -0.03327688f, 0.05688342f, 
    -0.02737496f, 0.06752051f, -0.15847895f, -0.11312157f, -0.06542382f, -0.08777833f, -0.05442727f, 0.20843215f, 
    -0.19303936f, 0.09215022f, -0.11841353f, 0.05537684f, -0.10247663f, 0.06045581f, -0.04156572f, -0.08572210f, 
    0.07277608f, -0.02161940f, -0.14802237f, -0.21516043f, 0.18008080f, -0.07186496f, -0.05307101f, 0.08953349f, 
    0.07494238f, 0.21362257f, 0.07454162f, -0.07284250f, 0.01074940f, 0.20935194f, -0.19775268f, 0.11594008f, 
    0.07211907f, -0.08084808f, 0.03800158f, 0.18180901f, -0.00751442f, -0.03887653f, -0.02574570f, -0.09749119f, 
    0.47589132f, -0.45978376f, -0.19506650f, 0.06229842f, 0.09167118f, -0.03202763f, -0.07664209f, -0.15639856f, 
    -0.03029110f, -0.02942264f, -0.04796170f, -0.07551443f, 0.04208149f, 0.06625468f, 0.03140421f, 0.04655239f, 
    -0.09160759f, -0.05916202f, 0.01376627f, 0.08404544f, -0.03857283f, -0.21697398f, -0.21817766f, -0.16811241f, 
    0.04020512f, 0.04732839f, -0.23910356f, -0.00964864f, 0.30450007f, -0.07444970f, 0.01377988f, 0.16210063f, 
    -0.00685831f, -0.03432170f, -0.06351602f, 0.02629927f, -0.39656910f, 0.03320824f, -0.15924904f, -0.00733051f, 
    0.05057707f, 0.00598482f, 0.12094624f, -0.07683853f, 0.10020756f, -0.11200009f, 0.15032078f, -0.06921540f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12390629f, 0.04700343f, -0.02834721f, -0.06540799f, 0.00292455f, -0.02652527f, 0.03966660f, -0.07884937f, 
    -0.06062106f, -0.00182175f, 0.06421291f, 0.04111210f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
