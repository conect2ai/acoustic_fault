#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72826421f, 0.30275637f, 0.40847677f, -0.76158893f, 0.23543528f, 0.06149174f, -0.74033153f, -1.03874457f, 
    -0.69392949f, -0.88184625f, -0.26592305f, 0.06061254f, 0.43397349f, 0.30498248f, -0.10313871f, -0.14160679f, 
    -0.24099234f, -0.21587251f, 0.10663602f, 0.49493492f, 0.14988275f, 0.23289707f, -0.06117409f, -0.13079220f, 
    0.24731530f, 0.95726174f, -0.62544429f, 0.81020087f, 0.45235696f, 0.56024760f, 0.39818773f, -0.84325325f, 
    -0.55183923f, -0.79808372f, -0.71968716f, 0.42512751f, 0.12060276f, -0.46425548f, 0.23153859f, 0.07887447f, 
    0.11673132f, -0.65573478f, -0.36970457f, 0.08383276f, 0.15213965f, 0.00238916f, 0.23607081f, 0.08358902f, 
    0.06320482f, 0.27227098f, -0.04633458f, 1.07310379f, 1.00699723f, 1.04762161f, 0.21037850f, 0.22894514f, 
    -0.01822463f, -0.58446878f, 0.84811288f, -0.22185719f, -0.62161261f, -0.36575541f, -0.18794556f, 0.53985959f, 
    -0.50829601f, -0.36392179f, -0.06765346f, 0.25222346f, -0.03858036f, -0.13582008f, -0.04584531f, -0.31443503f, 
    -0.35902280f, -0.34169945f, -0.28539109f, 1.16412401f, -0.58790118f, -1.08687639f, -0.26820883f, 0.84580052f, 
    0.37775001f, 0.08639953f, -0.34926099f, 0.20826800f, -0.06445961f, -0.46817383f, -0.13563530f, 0.20036443f, 
    0.05790890f, 0.22485740f, -0.04021058f, -0.44091856f, -0.26832202f, -0.23219265f, 0.11965895f, 0.20290378f, 
    -0.17655206f, 0.18619527f, 0.13178559f, -0.15151308f, -1.15571034f, -0.36597884f, 0.76655269f, -0.30259913f, 
    -0.16071066f, 0.58009797f, -0.47860855f, 0.11797210f, -0.97514868f, -0.57167214f, -0.25382134f, 0.51726192f, 
    0.04645205f, -0.03404690f, -0.19640665f, -0.67199439f, -0.30916274f, -0.38853702f, -0.24722454f, -0.48878196f, 
    0.12918553f, -0.09434668f, 0.29900995f, 0.17289488f, 0.18232109f, -0.95527500f, -0.60765958f, 0.22022492f, 
    0.05854369f, 0.37343916f, 0.41869304f, 0.36613059f, 0.03885969f, 0.29149178f, -0.53812480f, 0.32287949f, 
    -0.12011429f, 0.32901448f, 0.24088112f, 0.53258264f, 0.76805437f, 0.22594874f, -0.45999765f, -0.23491786f, 
    0.43846720f, 0.02477103f, 0.51526117f, 0.30724519f, -0.25259906f, 0.37577018f, 1.16720617f, 0.42269030f, 
    0.27061883f, -0.12434918f, -1.17085648f, 0.38945940f, 0.29280633f, 0.56175858f, -0.07818925f, 0.57785803f, 
    0.45773289f, 0.20290695f, 0.11467932f, -0.06798421f, -0.28298855f, 0.26897827f, -0.15392275f, -0.10137312f, 
    -0.17480585f, -0.15944099f, 0.24694318f, 0.31033525f, 0.20195597f, 0.13773602f, -0.16076085f, 1.02145433f, 
    0.50584638f, 0.33903581f, -0.27968833f, 0.87106168f, -0.33790430f, -1.02515435f, -0.68380320f, -0.24182765f, 
    -0.12076356f, -0.26877707f, 0.08560127f, 0.27770436f, -0.07631805f, -0.01869463f, -0.45763889f, 0.10021687f, 
    -0.21250014f, -0.16087912f, 0.04310656f, 0.08256110f, -0.07114715f, 0.00015851f, -0.24262802f, -0.05492215f, 
    0.33705485f, -1.60397935f, 0.40678346f, 1.15735376f, -0.36096621f, -0.92791879f, 0.84860164f, 0.56001872f, 
    -0.50469643f, -0.15964672f, 0.24557437f, 0.21864086f, 0.00176813f, -0.00013161f, 0.24974012f, -0.60946536f, 
    -0.11133137f, -0.12607500f, -0.00529976f, -0.52653050f, 0.00473010f, 0.13073210f, -0.00463971f, 0.22233032f, 
    0.13336024f, 0.11417932f, 1.06734169f, -0.14798887f, 0.46663108f, 0.58771825f, 0.44196269f, -0.01825198f, 
    -0.06884909f, -0.34795094f, 0.47511181f, -0.89994329f, 0.26580900f, 0.46930873f, 0.16122776f, 0.09524821f, 
    0.17012089f, 0.54022956f, 0.43253949f, 0.57028842f, 0.12234958f, 0.07852367f, -0.01447503f, -0.14537235f, 
    -0.58218056f, -0.19043197f, -0.23610567f, 0.99519908f, -0.39631221f, -1.03128493f, -0.47356036f, 0.02278523f, 
    0.50931478f, -0.23477198f, 0.57695776f, -0.15961632f, -0.47567174f, 0.15822607f, -0.48749444f, -0.13714541f, 
    -0.43487316f, 0.20370853f, -0.52863896f, 0.02460713f, 0.24688910f, -0.06581350f, -0.51300728f, -0.13696162f, 
    -0.12487759f, -0.04019126f, -0.20227067f, 1.58051205f, -0.08431083f, -0.91210842f, 0.60837036f, -0.41434920f, 
    -0.04013313f, -0.67165446f, 0.49361831f, 0.15311050f, -0.03999044f, -0.40446082f, -0.25456026f, 0.44057643f, 
    -0.26610816f, -0.18215761f, 0.33054286f, 0.28169113f, -0.43430325f, -0.24180369f, 0.33668211f, -0.02886983f, 
    0.12558298f, 0.18430765f, -0.14464304f, 0.06938794f, 1.03298688f, 0.30937108f, 0.52924699f, 0.25732690f, 
    0.27925289f, 0.22612564f, 0.64917988f, -0.22043638f, -0.66237903f, 0.67519784f, 0.13264000f, -0.01652238f, 
    -0.09714066f, 0.57330954f, -0.00356282f, 0.07563995f, 0.16895695f, 0.34178653f, 0.19314496f, 0.04052650f, 
    0.37621102f, -0.16837113f, 0.08836275f, -0.14482069f, 0.57047701f, -0.68875253f, -0.99896824f, -0.76008391f, 
    -0.41278183f, -0.29487452f, -0.03371362f, -0.62910688f, -0.29012704f, -0.10059132f, 0.43681303f, -0.07232474f, 
    -0.08605938f, 0.06153148f, 0.19629657f, 0.30251402f, 0.35614559f, 0.27551553f, 0.12608710f, 0.54942364f, 
    0.13996843f, 0.57965869f, -0.08576848f, 0.10195707f, 0.19800909f, 0.30978695f, 0.81299227f, 0.92307323f, 
    -1.09964788f, -0.61621964f, -0.84729224f, 0.70314550f, 0.12660120f, -0.58344287f, -0.31291273f, -0.76284581f, 
    0.24523158f, 0.47134230f, -0.00029136f, 0.35393506f, -0.09257033f, -0.10532932f, -0.09659701f, -0.21924241f, 
    -0.00906556f, -0.13884120f, 0.04616042f, 0.02889006f, 0.16928968f, -0.04119258f, 0.34765747f, 0.89362866f, 
    -0.06855601f, -1.07372260f, 0.24935247f, -0.48220390f, -0.41902611f, 0.05180786f, -0.38137752f, -0.02043758f, 
    -0.68610829f, 0.02461194f, -0.07189769f, 0.41863757f, 0.36442444f, -0.09061208f, -0.08840887f, -0.20476900f, 
    0.09348159f, 0.15373030f, 0.20231502f, 0.12514941f, 0.35657004f, -0.03070618f, -0.03585079f, 0.13182461f, 
    1.20895004f, 0.99220115f, 1.00938511f, 0.82521081f, 0.44777900f, -0.41242981f, 0.12905405f, -0.50303280f, 
    -0.39196759f, -0.09267929f, 0.06387246f, 0.34791026f, 0.11309367f, -0.05020778f, -0.11308560f, 0.08086521f, 
    0.14770663f, 0.29637843f, -0.18721016f, 0.01504965f, 0.16481100f, 0.25719091f, -0.17121501f, 0.20801648f, 
    0.34324044f, -0.81458426f, -0.57818347f, 0.33822066f, 0.65186095f, 0.45502996f, -1.10385990f, 0.46501949f, 
    0.65074807f, -0.65550405f, -0.66434461f, 0.34877419f, 0.21792662f, 0.07843217f, 0.41405836f, 0.13665953f, 
    0.34915012f, 0.12873630f, 0.11947060f, -0.14546910f, 0.15481821f, -0.18608181f, -0.17641056f, -0.23424385f, 
    0.01406537f, 0.20784919f, -0.37161466f, 0.04473142f, 0.77789783f, 0.59191447f, 0.06697715f, -0.34741211f, 
    -0.01214500f, -0.96740222f, -0.66561604f, -0.38349468f, 0.46527883f, 0.41254848f, 0.71252733f, -0.26685527f, 
    0.17955106f, 0.38025579f, 0.23489730f, 0.44849220f, 0.08748426f, -0.06712488f, -0.43983319f, -0.24726540f, 
    0.23182718f, 0.25077158f, -0.37075990f, -0.61386275f, -0.19128425f, -0.63504124f, -0.52832282f, -0.16283733f, 
    0.59127134f, 1.00441694f, -0.30753967f, 0.51397288f, 0.77469516f, -0.03161261f, -0.54245019f, -0.00572739f, 
    -0.40738118f, 0.00089523f, 0.10324030f, 0.05518336f, -0.07949232f, 0.15022615f, -0.36582717f, -0.24993981f, 
    -0.03853069f, 0.03312889f, 0.14547785f, 0.09029425f, 0.07401746f, -0.29327402f, -0.37559089f, 0.32006508f, 
    1.39243090f, 1.22855306f, 0.25482768f, -0.82757616f, 0.18013223f, -0.07617225f, -0.10063092f, 0.41878018f, 
    -0.24213046f, 0.40975448f, 0.39058414f, -0.17448513f, -0.27181476f, -0.14831391f, -0.28104258f, -0.25809982f, 
    0.37045336f, -0.00850548f, -0.00475344f, -0.16431911f, -0.15714504f, -1.24395657f, 0.53280896f, -0.10080053f, 
    -0.81154233f, -0.50175947f, 0.77740347f, 0.02843451f, -0.15907279f, 0.77045834f, 0.83908653f, 0.07067590f, 
    -0.22492252f, -0.36130533f, 0.21535949f, -0.16302042f, -0.07853667f, 0.03533202f, -0.24114706f, 0.27226770f, 
    -0.16739920f, -0.31081873f, -0.08830860f, -0.19873407f, -0.06902670f, -0.19451475f, 0.06853744f, 1.13695824f, 
    -0.18915425f, -0.73963422f, -1.06421697f, 0.84402615f, -0.47604159f, -0.48811069f, -0.71102434f, 0.07483117f, 
    0.16882640f, 0.35735971f, 0.17360398f, 0.42333746f, 0.14602944f, 0.17318511f, -0.28149348f, 0.07885386f, 
    0.06968805f, -0.13126656f, 0.01582105f, 0.10237166f, 0.11547308f, -0.12363014f, 0.39989975f, 0.88380867f, 
    -1.69508326f, 0.62590593f, 0.31953490f, 0.05828519f, 0.99169201f, 0.47586864f, 0.64498222f, 0.27719489f, 
    -0.24806194f, -0.21906419f, -0.24970110f, -0.02464735f, 0.13923021f, -0.42673203f, -0.32443184f, -0.22617903f, 
    0.03287536f, -0.00515875f, -0.04858392f, -0.07854217f, 0.22006978f, -0.18409523f, -0.08706459f, 0.02968483f, 
    -0.64689577f, -0.30357558f, -0.58000404f, -0.63489181f, -0.62612247f, -0.29060259f, 0.05264902f, 0.18332137f, 
    0.75215751f, 0.43067992f, 0.32691145f, 0.23241733f, -0.07524300f, -0.14469573f, -0.50447631f, 0.26341271f, 
    0.38270703f, -0.37771761f, -0.32334024f, 0.39464641f, 0.26061156f, -0.50712746f, 0.29780656f, -0.09129027f, 
    -0.13967583f, 0.56030530f, 0.19983289f, -0.41942763f, -0.78785318f, -0.32572711f, 0.50886834f, 0.50224924f, 
    1.11206996f, 0.53428012f, 0.58633417f, 0.02828521f, -0.23189317f, -0.31109828f, -0.65029973f, 0.34176916f, 
    -0.11486694f, 0.22177207f, -0.19540875f, 0.20369403f, 0.00816367f, -0.44639534f, -0.24333003f, -0.43316698f, 
    -0.39481571f, -0.10972153f, -0.45910680f, -1.11546683f, -0.83732629f, -0.35659629f, -0.73231447f, -0.07267343f, 
    1.07910895f, 0.42596474f, 0.02357197f, 0.42285749f, -0.06058968f, -0.19878425f, -0.06707569f, -0.15214276f, 
    -0.37739912f, -0.13810077f, -0.11748189f, 0.06881704f, -0.43272623f, -0.29024687f, -0.02738567f, 0.12234869f, 
    0.15573040f, 0.19778177f, 0.00476944f, -0.92049593f, -0.42815125f, -0.65903580f, -0.57559836f, -0.46339527f, 
    -0.85105813f, 0.82965755f, 0.50523180f, -0.49702054f, 0.31473473f, -0.02474292f, 0.27532962f, 0.53825921f, 
    -0.24540657f, 0.10202056f, -0.17774475f, 0.23963320f, 0.37262964f, 0.17224301f, -0.10581294f, 0.09199346f, 
    0.39726728f, -0.23457690f, -0.36058706f, -0.27902716f, -0.82585460f, 0.01274373f, -0.99947971f, -0.29383600f, 
    -0.80822939f, 0.89498711f, -0.16217308f, -0.37241945f, 0.27218947f, 0.15963817f, -0.56844211f, -0.26378271f, 
    0.09893323f, -0.32476649f, -0.06230604f, -0.16615167f, 0.34825757f, 0.49496680f, -0.09694073f, -0.25724760f, 
    0.33509159f, -0.15005791f, -0.22871940f, 0.04914790f, 0.31438673f, -0.73546892f, -1.27051497f, -0.49228683f, 
    0.29758391f, 0.75319469f, 0.21408747f, 0.54754913f, -0.09916934f, 0.08043291f, 0.50242168f, -0.10754590f, 
    0.46615493f, -0.34479490f, -0.11168431f, 0.17241250f, -0.18041264f, 0.40993372f, 0.50745833f, -0.25049859f, 
    -0.41015935f, -0.13792831f, -0.23776025f, -0.04884613f, -0.25677487f, 0.05396929f, 0.88405967f, 0.49677423f, 
    0.46072209f, 0.75913471f, 1.00372362f, 0.64331281f, 0.38187689f, 0.69910580f, 0.67516118f, 0.29546005f, 
    -0.44928801f, 0.19518369f, 0.06298168f, 0.14536461f, 0.12757219f, 0.18285605f, -0.05702875f, -0.09028176f, 
    -0.13363588f, 0.28651714f, -0.58063471f, -0.35163653f, 0.03902861f, 0.50046891f, -0.10245162f, 0.83335674f, 
    0.83915281f, 0.77058429f, 0.54511362f, 0.29729143f, -0.17820297f, 0.48337701f, 0.02695619f, -0.27014905f, 
    0.62460542f, -0.35253152f, 0.20144263f, -0.24276637f, -0.44558695f, -0.30953181f, -0.38993973f, -0.39050722f, 
    0.18457001f, -0.39018127f, -0.33058435f, 0.15218452f, 0.71505064f, 0.14460044f, 0.12516384f, 0.36470789f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31260410f, 0.40380812f, 0.07403922f, 0.39721778f, 0.30138981f, 0.27044603f, 0.17591238f, 0.08441649f, 
    0.07568173f, -0.08023876f, -0.11564639f, -0.11113740f, 0.25073886f, 0.28202000f, 0.32536396f, 0.50969160f, 
    0.34735724f, 0.44613937f, 0.30024725f, -0.00612876f, 0.31709048f, -0.04844852f, 0.32467890f, 0.23542830f, 
    0.16552091f, 0.16988263f, 0.21980356f, 0.45630819f, 0.01909634f, 0.00018518f, 0.12412839f, 0.45501930f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.78922611f, 0.04580222f, 0.31548834f, -0.23201098f, -0.05168016f, 0.06971251f, -0.06445371f, -0.03751946f, 
    0.02057050f, -0.07361062f, -0.21719579f, 0.05066464f, 0.17402384f, -0.16809638f, 0.04121078f, 0.07494033f, 
    -0.25624609f, -0.11795215f, -0.07120572f, 0.07745612f, -0.11615881f, -0.00057695f, -0.02867789f, -0.01423599f, 
    -0.08617869f, 0.06036460f, -0.27701381f, 0.39891243f, -0.06028402f, -0.02585409f, 0.06037628f, 0.02032909f, 
    0.02892253f, 0.02333018f, -0.18787304f, -0.03284746f, 0.00803399f, 0.02330002f, 0.07190513f, -0.11477263f, 
    -0.02750072f, -0.00115872f, 0.05092065f, 0.02842736f, -0.26703247f, 0.05897589f, 0.01782910f, -0.12357440f, 
    -0.73265493f, 0.09608807f, 0.28546068f, 0.02650634f, 0.05876277f, 0.06350270f, -0.05396089f, -0.00273364f, 
    0.06445804f, 0.10733271f, 0.04003065f, -0.01983167f, -0.18244144f, -0.07163388f, 0.06968411f, 0.04367675f, 
    0.00259776f, 0.23928088f, -0.03960766f, 0.04773892f, 0.06527805f, -0.00119374f, 0.06326089f, -0.09079972f, 
    -0.29723591f, -0.02850116f, -0.11506395f, -0.12231934f, -0.17402168f, -0.03106075f, -0.12433209f, -0.14659500f, 
    -0.20000267f, -0.00882593f, 0.06926084f, -0.04072599f, 0.17599197f, -0.03457432f, 0.28024247f, -0.33476651f, 
    -0.21064979f, 0.02792902f, -0.04170557f, 0.13978091f, -0.01224726f, -0.04827197f, -0.03657480f, -0.12010248f, 
    -0.00993688f, -0.14868011f, -0.31087461f, 0.41339141f, -0.18706664f, -0.09793428f, -0.05097340f, -0.16250961f, 
    -0.00424185f, 0.05493701f, 0.00483661f, 0.02597618f, 0.17353731f, -0.15067330f, 0.05736528f, -0.13526562f, 
    -0.13350222f, 0.15896341f, 0.10208280f, -0.01359525f, 0.24744137f, 0.19372050f, -0.15946531f, 0.22796880f, 
    0.33904389f, -0.10386185f, -0.02321089f, -0.62626451f, -0.03645106f, -0.01140295f, 0.07048289f, -0.11192735f, 
    -0.07516568f, -0.07932656f, 0.03466904f, -0.03085781f, 0.07108779f, -0.58494675f, -0.05918083f, 0.30736548f, 
    0.04612596f, 0.16232552f, 0.04079547f, 0.23447451f, -0.28544229f, 0.04096100f, 0.08165798f, 0.01119669f, 
    0.11312118f, 0.00760448f, 0.08547609f, -0.06116470f, -0.22747073f, -0.06776304f, 0.04207664f, 0.04487040f, 
    0.04965291f, 0.07021869f, -0.16170286f, -0.08785653f, -0.06660524f, -0.35301512f, -0.31393811f, -0.25163749f, 
    0.04304950f, -0.09661894f, -0.03769892f, 0.18404344f, -0.11575518f, -0.10475370f, -0.08199455f, 0.12057994f, 
    -0.24005574f, -0.06981867f, 0.11066096f, -0.28584695f, -0.19138545f, -0.00933193f, 0.05812006f, 0.08110189f, 
    0.00140716f, -0.03530522f, 0.03367377f, 0.09311709f, -0.22687002f, 0.00358507f, 0.18221188f, 0.11083281f, 
    -0.02581230f, -0.14136031f, 0.05745833f, -0.06019630f, 0.00343467f, 0.00256063f, -0.04806526f, 0.00421277f, 
    0.18007076f, 0.12391644f, -0.13735022f, 0.07518135f, -0.35462585f, -0.23938259f, -0.06173840f, 0.04049680f, 
    -0.07015131f, 0.00441577f, -0.28035733f, -0.04173594f, -0.37950441f, 0.16591464f, -0.16228594f, 0.15597644f, 
    -0.09207380f, 0.04547002f, 0.06482277f, -0.01827812f, 0.04629964f, -0.00806764f, 0.02823306f, -0.04529345f, 
    0.02839059f, 0.01368395f, -0.04069251f, 0.19365142f, 0.03000339f, 0.02513182f, 0.03404681f, -0.02478035f, 
    0.10878369f, 0.27652901f, 0.03928908f, -0.14143531f, 0.50347197f, 0.25672111f, 0.19102795f, -0.23970945f, 
    0.10116495f, 0.16759753f, -0.05733658f, -0.16482906f, 0.12529519f, 0.12371112f, -0.01978964f, 0.20568070f, 
    -0.09538446f, -0.13286458f, 0.27519262f, 0.21277784f, 0.08229842f, -0.10151071f, 0.00052017f, -0.15508911f, 
    -0.09339008f, -0.02407153f, 0.13857497f, -0.08905043f, 0.54835099f, -0.00971684f, -0.20399918f, 0.02576617f, 
    0.04350232f, 0.03999344f, 0.13404424f, -0.02050651f, 0.05098991f, 0.14435694f, 0.03364063f, -0.11711185f, 
    -0.10676767f, 0.15472010f, 0.12176738f, -0.34989864f, -0.08209232f, -0.00365077f, 0.17214470f, -0.07920241f, 
    -0.08911841f, -0.01674960f, 0.05792582f, 0.09869646f, 0.11641221f, 0.06803454f, 0.03365641f, 0.13702533f, 
    0.10937907f, -0.05238901f, 0.10786469f, -0.00559977f, -0.10692822f, 0.12132779f, -0.15405704f, -0.10726846f, 
    0.15404585f, 0.17386520f, -0.32667699f, -0.23663975f, -0.05068505f, 0.06268830f, 0.13047752f, 0.03104592f, 
    -0.06282752f, 0.09224378f, -0.04682814f, -0.10402279f, 0.00614050f, -0.05455356f, 0.02309544f, -0.32946450f, 
    0.17150477f, -0.08980790f, 0.12921280f, -0.12468246f, 0.02213308f, 0.06827809f, -0.02835029f, 0.10118405f, 
    0.01683109f, 0.22447531f, -0.01379778f, -0.36440954f, 0.01426122f, 0.03670154f, 0.02552124f, 0.04192280f, 
    -0.12319732f, -0.03462200f, 0.04623354f, -0.05392409f, -0.29593214f, 0.07077258f, 0.00741908f, -0.11092844f, 
    0.01983815f, -0.08346677f, 0.00522237f, 0.09535032f, -0.05059991f, -0.20024092f, 0.01417852f, -0.00665717f, 
    0.62970012f, 0.05372252f, -0.11961754f, -0.06481224f, 0.13623890f, -0.09230883f, -0.07649034f, 0.20961182f, 
    0.03282902f, -0.09203275f, -0.16747579f, 0.12252764f, -0.41210499f, -0.15958406f, -0.00213128f, 0.12638077f, 
    0.10858914f, 0.10812814f, -0.08570562f, 0.09214076f, -0.08583204f, 0.07188304f, -0.07274045f, 0.14762144f, 
    0.19531792f, 0.01224700f, -0.16885273f, 0.19976042f, -0.13659847f, 0.03336526f, -0.02548747f, 0.16068321f, 
    0.04874512f, -0.04666184f, 0.03384113f, -0.01445503f, 0.10690700f, 0.09420486f, 0.07654811f, 0.08161538f, 
    -0.29775614f, -0.11743857f, -0.10142165f, -0.06602187f, -0.08957060f, -0.00984949f, -0.08709797f, -0.03616698f, 
    -0.07048202f, -0.09134658f, 0.00152551f, -0.15304056f, -0.02625017f, 0.09835958f, 0.04512903f, 0.03651717f, 
    -0.10722411f, 0.23053984f, 0.08681464f, -0.00888510f, -0.15294477f, -0.01064716f, 0.17956734f, -0.09465136f, 
    0.06625843f, 0.07688473f, 0.06002634f, 0.07261241f, -0.01141720f, 0.12842257f, -0.13212231f, 0.07280427f, 
    0.29839784f, -0.01114760f, -0.14976597f, 0.26500234f, -0.16552112f, -0.04848383f, 0.03394512f, 0.05911627f, 
    -0.14497547f, -0.28051665f, 0.25694320f, -0.22781855f, 0.22879837f, -0.44616976f, 0.24686557f, -0.17700346f, 
    -0.02846449f, -0.01958240f, -0.08945929f, -0.00228342f, -0.01294050f, -0.00018360f, -0.13577712f, -0.01521181f, 
    0.16251436f, 0.16705844f, -0.44586930f, -0.09744360f, -0.12170353f, -0.04464316f, -0.10246318f, 0.05477400f, 
    0.01050651f, -0.10879196f, -0.27301365f, -0.28001478f, -0.24500951f, 0.23148032f, -0.15900047f, 0.04246140f, 
    -0.16189459f, -0.09213982f, 0.10043206f, 0.03711827f, -0.13548534f, 0.09843035f, -0.17681548f, 0.11889219f, 
    0.34471452f, 0.07122993f, 0.14004521f, -0.03234237f, -0.17447585f, -0.10859247f, 0.03526801f, 0.11691236f, 
    0.05507572f, -0.08404145f, -0.03761081f, -0.00100500f, 0.10153636f, -0.16639352f, 0.08706971f, 0.09864210f, 
    0.05287418f, -0.05615104f, 0.10854159f, 0.03549359f, -0.10890427f, -0.05504654f, -0.07811722f, -0.02930805f, 
    -0.53818899f, -0.25280419f, -0.00876041f, 0.30218524f, -0.12990381f, 0.11455293f, -0.08028229f, -0.01333086f, 
    0.08342518f, -0.14417990f, -0.11649642f, 0.02846083f, 0.21180315f, 0.17076641f, -0.03784883f, 0.05519639f, 
    0.14489433f, -0.12249179f, -0.14961925f, -0.11086743f, 0.09460487f, -0.07672276f, 0.05271255f, -0.07383432f, 
    -0.53472692f, -0.11437093f, -0.03351870f, -0.35288045f, 0.08587991f, 0.04338197f, -0.09297060f, 0.01278480f, 
    0.11162739f, 0.02444909f, -0.06301955f, 0.00215702f, 0.10480018f, -0.28992528f, -0.01588859f, -0.11445910f, 
    -0.10018326f, -0.25860277f, -0.00921899f, -0.02112113f, 0.07825111f, -0.00029756f, 0.02528431f, -0.10462283f, 
    0.33865517f, 0.10654584f, 0.00821761f, -0.03639742f, -0.09757765f, -0.07878789f, -0.01291039f, 0.03883124f, 
    0.00420779f, 0.04775475f, 0.12481095f, 0.00927793f, 0.29139727f, 0.10597703f, 0.17257364f, 0.06476510f, 
    -0.04500586f, 0.11945599f, 0.11119258f, -0.03363878f, 0.05102403f, 0.00290623f, 0.00446594f, 0.16302949f, 
    0.28916311f, -0.56982684f, -0.10434624f, -0.35247365f, 0.02981981f, -0.03817219f, 0.11752865f, 0.09011618f, 
    -0.29262179f, -0.01866788f, -0.00202412f, -0.03867250f, 0.39596426f, -0.69283724f, -0.19860154f, -0.07440943f, 
    -0.04518933f, -0.07060643f, -0.05463580f, 0.20780306f, 0.02462860f, 0.17206986f, -0.04694207f, 0.03670426f, 
    0.31786725f, 0.04009091f, 0.21136342f, 0.36525398f, -0.12912975f, 0.03389931f, 0.07545654f, -0.00723310f, 
    0.06198460f, 0.01120017f, 0.20801817f, -0.02371924f, -0.31704575f, 0.02052634f, -0.00765399f, 0.08019057f, 
    -0.08781732f, 0.00992727f, -0.11819577f, -0.11273415f, -0.12062600f, 0.00403932f, 0.01492186f, 0.05016199f, 
    -0.22953685f, -0.17480314f, -0.12039652f, -0.08047358f, -0.10406067f, 0.13867831f, -0.03721203f, -0.21060258f, 
    0.10002916f, -0.15374352f, 0.11083107f, 0.08639403f, 0.04518646f, -0.21202792f, -0.11859036f, -0.11648822f, 
    -0.04538839f, -0.12675487f, -0.13751830f, -0.00425162f, 0.04665680f, 0.04630524f, 0.00041707f, -0.07229726f, 
    0.31847006f, -0.09883778f, -0.10662676f, -0.19148947f, -0.05052040f, -0.10239919f, -0.03659381f, 0.05018258f, 
    -0.19349687f, -0.03415406f, -0.16039158f, 0.02230981f, -0.59526527f, 0.08333015f, -0.10845415f, 0.02011145f, 
    0.17997849f, -0.10597292f, -0.02559873f, -0.01475500f, 0.07474832f, 0.12448955f, -0.10541125f, -0.01613882f, 
    -0.10659675f, -0.10301001f, -0.09031811f, -0.23849002f, -0.09831836f, 0.06850458f, 0.10293572f, 0.07737535f, 
    0.08603194f, 0.08469497f, -0.01392501f, -0.00211411f, 0.37395483f, -0.29606840f, 0.02179579f, -0.00378204f, 
    -0.00736584f, 0.09663559f, -0.09112732f, 0.08722553f, 0.08160367f, 0.03074392f, 0.10664878f, 0.04047675f, 
    -0.10980786f, -0.17034160f, 0.07363740f, -0.21423228f, -0.02493643f, -0.00853927f, -0.02648656f, 0.07151366f, 
    0.11842079f, -0.22322711f, -0.00101028f, 0.11341432f, 0.25783283f, -0.13461150f, 0.09639964f, -0.13673869f, 
    0.07949105f, -0.01764158f, -0.17577910f, 0.07503403f, -0.02305578f, 0.10624532f, -0.03041018f, -0.07884319f, 
    0.28232589f, -0.28879046f, -0.14046253f, -0.06891810f, -0.08483712f, 0.06332283f, -0.03685902f, -0.00403395f, 
    0.13883345f, -0.06763292f, -0.09105676f, 0.12910694f, 0.20433797f, 0.09983790f, -0.12055804f, 0.01045896f, 
    0.00034028f, 0.01810412f, 0.05976782f, 0.00633509f, -0.02651844f, -0.10442163f, -0.00607737f, -0.15861943f, 
    -0.42520037f, 0.07778703f, 0.00219673f, -0.29718131f, 0.21854334f, -0.06401466f, 0.12929201f, 0.04206589f, 
    0.23692967f, -0.02634768f, 0.03366194f, -0.19648926f, 0.55217773f, -0.11813614f, -0.23402655f, 0.00670628f, 
    0.12673515f, 0.00933971f, -0.12460589f, 0.12199099f, -0.10546888f, -0.07785915f, 0.14261200f, -0.04877319f, 
    0.33377022f, 0.13799299f, 0.09383663f, 0.26689464f, 0.02963197f, -0.00597120f, -0.05112378f, -0.02345059f, 
    0.02984008f, 0.02439613f, 0.04895909f, 0.12583815f, 0.19889852f, 0.19973901f, 0.13112162f, 0.20236264f, 
    -0.16679406f, 0.28563032f, 0.20456097f, 0.09468726f, -0.00932784f, -0.18714707f, 0.01923651f, -0.15746377f, 
    -0.15129487f, 0.13438328f, -0.45984679f, -0.22072871f, 0.14509328f, -0.12091219f, 0.05457883f, -0.09715679f, 
    -0.01715857f, 0.06423157f, -0.11488449f, 0.04976952f, -0.34305122f, 0.06101933f, -0.23266023f, -0.10902461f, 
    0.10516843f, 0.08540769f, 0.08353376f, -0.10338529f, 0.03423575f, -0.09182893f, 0.03029105f, -0.19512282f, 
    0.18826865f, -0.14825879f, -0.25294247f, -0.06456923f, -0.02451299f, 0.07103503f, 0.02808759f, -0.09620330f, 
    -0.10580089f, 0.15970455f, -0.13396685f, 0.01830811f, -0.28076077f, -0.24045695f, 0.10588812f, -0.32465497f, 
    0.03910299f, 0.01243071f, 0.00430715f, -0.01423800f, -0.03525276f, 0.02443903f, -0.02944246f, -0.04169421f, 
    0.11690094f, -0.05733287f, -0.12237389f, -0.35663238f, -0.06937575f, -0.04323338f, -0.14027946f, 0.03858089f, 
    0.00485946f, 0.17545328f, 0.00350111f, -0.13669550f, 0.36319524f, -0.26146361f, -0.10120130f, 0.01262403f, 
    -0.09105233f, -0.01515073f, 0.04644416f, -0.06074569f, -0.02033473f, -0.06340460f, -0.08276874f, -0.09497188f, 
    -0.09481245f, 0.12780939f, 0.21404374f, -0.14518926f, -0.18582869f, -0.15021093f, 0.03708721f, 0.09942067f, 
    -0.11664114f, 0.00422640f, 0.07064717f, 0.01133178f, -0.30715576f, 0.23436248f, -0.08737461f, -0.20484895f, 
    0.22679546f, 0.04741592f, 0.07586058f, -0.24558575f, 0.01678359f, 0.05127096f, 0.07827654f, -0.01039204f, 
    0.69904381f, -0.02710843f, -0.11418479f, -0.15722485f, -0.16299060f, 0.11387015f, -0.05454050f, -0.07127994f, 
    0.06875147f, -0.00549152f, 0.02936526f, -0.12539156f, 0.07771989f, -0.13508619f, 0.07808606f, -0.08240609f, 
    0.08060329f, -0.04163741f, 0.11546016f, -0.18121155f, -0.10115802f, -0.00588963f, -0.12886420f, 0.06127495f, 
    0.09524956f, 0.19273181f, -0.39027447f, 0.01276073f, -0.07117181f, 0.16067876f, 0.14132577f, 0.08444836f, 
    -0.07085656f, -0.00266765f, 0.11253330f, -0.16472226f, -0.08973321f, -0.14252731f, -0.21112858f, 0.06619506f, 
    0.10915049f, 0.02623403f, 0.03745300f, 0.16750613f, -0.09442043f, -0.10233556f, 0.04068065f, -0.12897956f, 
    0.04588186f, 0.00833037f, 0.10586838f, -0.12568468f, 0.02971920f, 0.10118262f, 0.13156456f, 0.02112004f, 
    -0.19410232f, 0.04969358f, -0.07978951f, 0.03851103f, -0.05240886f, -0.23026979f, -0.06998216f, 0.09807768f, 
    -0.20085411f, -0.13631991f, -0.24314630f, -0.00686521f, -0.04970064f, -0.14671686f, 0.05320470f, 0.02590937f, 
    0.01994627f, -0.15769409f, 0.02775513f, -0.37529466f, -0.09272517f, -0.19556738f, 0.13501340f, -0.10039426f, 
    0.02394946f, 0.03035134f, 0.00042518f, -0.10248058f, -0.29308152f, -0.04499492f, -0.49341092f, -0.25005859f, 
    -0.01764004f, -0.08509381f, 0.09840784f, -0.17112629f, -0.05183753f, 0.06994335f, -0.19981241f, 0.01151809f, 
    0.00334329f, 0.19146201f, -0.14767081f, 0.01825008f, 0.11096416f, 0.05568234f, 0.01207840f, -0.07529364f, 
    0.04163218f, 0.06163539f, -0.05364398f, -0.05634343f, 0.48448589f, 0.03003894f, -0.20910421f, 0.01260996f, 
    0.00756615f, 0.13774638f, -0.02037217f, -0.02926062f, 0.02852864f, -0.07865329f, -0.10924808f, -0.00370175f, 
    0.34427047f, -0.07789434f, -0.09815698f, 0.03566551f, -0.01012648f, -0.00287526f, -0.11070871f, 0.08480196f, 
    -0.22521394f, -0.08704153f, -0.12493790f, -0.26652962f, 0.40760410f, 0.06043327f, 0.25387314f, 0.26277655f, 
    -0.11965671f, -0.04821941f, 0.05558750f, 0.10949779f, -0.07606479f, 0.04459516f, 0.01075226f, 0.04185671f, 
    0.17384093f, -0.37391418f, 0.18089513f, -0.05902716f, -0.00016860f, 0.04618073f, 0.01704908f, -0.06048191f, 
    -0.01783434f, 0.06241518f, 0.01054361f, -0.03109256f, 0.44502646f, 0.25342709f, 0.07699496f, 0.00414295f, 
    -0.04188874f, 0.03461142f, 0.17894731f, 0.07743588f, -0.24254805f, 0.11442056f, 0.07476588f, -0.17351551f, 
    -0.25827971f, -0.00425270f, 0.04240666f, -0.43225864f, -0.01079092f, -0.02309386f, -0.00209235f, 0.13094576f, 
    0.04589248f, 0.01477447f, -0.18418032f, -0.04870399f, -0.58699286f, 0.06986625f, 0.11716581f, -0.00424597f, 
    0.08124205f, -0.02301127f, -0.04300747f, 0.14798921f, -0.03021961f, -0.06033220f, -0.07989888f, -0.02845169f, 
    0.08322603f, -0.09340578f, 0.26844481f, 0.04846503f, -0.04959223f, 0.02347532f, -0.05074061f, 0.11158358f, 
    -0.02769790f, 0.01700874f, 0.05094866f, -0.15455671f, 0.06520484f, 0.20705616f, 0.08104022f, 0.20558846f, 
    -0.04437540f, -0.23795225f, 0.12009286f, 0.22177728f, -0.18520468f, -0.12090632f, 0.02161608f, -0.08282949f, 
    0.39756581f, -0.11688808f, 0.28600496f, 0.25982413f, -0.24067086f, -0.09623002f, -0.03655948f, 0.10328234f, 
    0.12977894f, 0.04377313f, 0.01730661f, -0.08253606f, 0.43223152f, -0.01732675f, -0.18896767f, 0.17880033f, 
    -0.20758297f, -0.04765585f, 0.07025094f, 0.02102401f, -0.05480083f, 0.00765340f, -0.07015991f, 0.10399650f, 
    -0.08955853f, 0.12492286f, -0.25493523f, 0.23262772f, -0.00980146f, -0.22975002f, -0.04801977f, -0.04909971f, 
    -0.05382978f, 0.04616183f, -0.18239896f, 0.18227224f, 0.38172838f, -0.47126549f, 0.10533609f, 0.16835731f, 
    -0.06236221f, -0.13572349f, 0.04283420f, 0.05981246f, -0.12178314f, 0.03424998f, -0.13059649f, 0.04144057f, 
    0.12710465f, 0.05666601f, -0.08646051f, 0.09610549f, 0.11227734f, 0.02521842f, 0.01561731f, 0.07800996f, 
    0.03055844f, 0.01273704f, 0.01010659f, -0.12737453f, 0.08522608f, 0.06826865f, -0.06073480f, -0.16385469f, 
    0.07987099f, -0.02946905f, -0.03625862f, -0.02291193f, -0.00557599f, 0.14406008f, -0.00505363f, 0.17222781f, 
    0.42526951f, 0.13090733f, 0.26931238f, 0.08549210f, 0.08872122f, 0.05440850f, -0.00411671f, -0.07088707f, 
    0.10753302f, -0.09035916f, 0.02319529f, -0.07137869f, 0.20224339f, -0.10110223f, 0.02640885f, 0.32728896f, 
    0.01607040f, 0.18621962f, -0.06033537f, 0.06781317f, 0.05476701f, -0.00123449f, 0.06518161f, -0.25387660f, 
    0.47062433f, -0.07759773f, -0.28660506f, 0.21201800f, -0.15631557f, -0.00324692f, 0.04509813f, -0.05916037f, 
    0.00053651f, 0.08982196f, 0.09784263f, 0.00273348f, 0.03002552f, 0.16076405f, 0.17088936f, 0.11300664f, 
    0.09188996f, 0.15121296f, 0.05143714f, 0.02300175f, -0.16571391f, 0.15012680f, 0.08850317f, -0.02358367f, 
    0.32159561f, 0.14930627f, 0.24030820f, -0.04802895f, 0.04777000f, -0.12179299f, 0.07411049f, 0.11472651f, 
    0.08423419f, -0.04474965f, -0.02446430f, 0.05703545f, -0.03734163f, 0.10738633f, -0.01243582f, 0.19898590f, 
    -0.08097631f, -0.03574498f, -0.01101544f, -0.02703584f, 0.05803496f, 0.00039926f, 0.02553574f, -0.01436050f, 
    -0.09641633f, -0.48329678f, -0.16285247f, -0.03782189f, 0.01461289f, 0.09984922f, -0.14529610f, 0.02380319f, 
    -0.03880642f, -0.05858405f, -0.05720080f, -0.04524549f, 0.07876915f, -0.06106248f, -0.02007398f, 0.24472028f, 
    0.02896022f, 0.09311447f, 0.12111299f, -0.16001800f, 0.07826629f, 0.06820621f, 0.02305934f, -0.04411973f, 
    -0.20910628f, 0.24503013f, 0.15788208f, -0.03492367f, -0.00997135f, 0.08352717f, -0.02135784f, -0.02505075f, 
    -0.08714995f, 0.04117507f, -0.07429938f, -0.00903940f, 0.15940835f, -0.35062310f, -0.18297453f, 0.30668268f, 
    -0.09464429f, 0.10639426f, 0.18917465f, 0.02192762f, -0.00768879f, -0.01214606f, -0.14412209f, 0.36152232f, 
    0.01700010f, 0.13302007f, 0.19145162f, -0.08753197f, -0.24474981f, 0.05965827f, 0.09401036f, 0.17511265f, 
    -0.12319390f, 0.08814602f, 0.14920035f, 0.13382272f, 0.51136851f, -0.16032304f, 0.14268185f, -0.00209058f, 
    -0.00163721f, 0.06074182f, 0.01018258f, -0.03339333f, -0.10117594f, -0.22177148f, -0.07667946f, 0.09742960f, 
    -0.92640233f, -0.37790647f, 0.00050340f, -0.01062451f, -0.05359940f, 0.05046676f, -0.05569861f, 0.00684345f, 
    -0.00525494f, -0.10198665f, 0.09280756f, -0.04982015f, 0.11733926f, 0.03609170f, -0.16827653f, -0.17545630f, 
    -0.21186779f, -0.13718589f, 0.00694607f, 0.01031448f, -0.05312926f, -0.16450723f, -0.01449791f, -0.03436571f, 
    0.20491430f, -0.03627947f, -0.00942810f, -0.02126485f, -0.03927296f, -0.03682169f, 0.00103689f, 0.14580920f, 
    -0.12506877f, 0.06921998f, -0.03764759f, -0.01770779f, 0.26349843f, -0.07895584f, 0.20222487f, -0.11144083f, 
    -0.03821961f, -0.00403748f, -0.00468512f, -0.02337249f, 0.01491534f, -0.08497430f, -0.05314061f, 0.10237291f, 
    -0.48235905f, -0.75239927f, -0.42713562f, 0.24665807f, -0.14233918f, 0.01495391f, 0.00359761f, -0.03971107f, 
    -0.06057439f, -0.03549172f, -0.09815428f, -0.04103314f, -0.27528402f, 0.12995815f, 0.37621856f, -0.07268859f, 
    0.06545451f, -0.09486811f, 0.11705024f, -0.06948850f, -0.02344653f, -0.07072604f, -0.18328395f, -0.08833259f, 
    -0.33090600f, -0.08809961f, 0.12940881f, 0.15372886f, 0.11484697f, 0.16532682f, -0.03741557f, 0.03786394f, 
    -0.04482710f, 0.11960320f, -0.15266943f, -0.09418891f, -0.28667396f, 0.21220192f, -0.07898645f, -0.13069698f, 
    -0.08538594f, -0.05462618f, -0.05168156f, -0.06806373f, -0.04223270f, -0.15838112f, -0.03330451f, -0.02709698f, 
    0.43428409f, -0.03891760f, -0.03986588f, 0.10841329f, -0.00170196f, 0.22972088f, -0.07471327f, -0.12949879f, 
    0.03008689f, -0.03372791f, -0.02790818f, 0.06632253f, -0.22261178f, 0.30532542f, 0.09761825f, -0.36354998f, 
    -0.00040247f, -0.06256412f, -0.14222664f, 0.04341052f, 0.10030916f, -0.16480200f, 0.12995985f, 0.02784946f, 
    0.20543537f, -0.01922237f, 0.02251288f, 0.04598770f, -0.15682471f, -0.00151984f, -0.09042270f, 0.16765924f, 
    -0.01186175f, 0.06664522f, -0.07844523f, -0.02529192f, -0.07759486f, -0.02874668f, -0.18067145f, -0.04454968f, 
    -0.02749628f, 0.15961087f, -0.10115066f, 0.07934072f, -0.03461368f, 0.09612425f, 0.01534603f, 0.04037485f, 
    -0.10426996f, 0.12724902f, -0.04390189f, -0.12805416f, -0.05760752f, 0.10034928f, -0.03799208f, 0.02664125f, 
    -0.02755421f, -0.05832158f, 0.07956593f, 0.05277470f, -0.30140132f, -0.15845577f, -0.02695857f, -0.16374350f, 
    -0.08832658f, 0.01562707f, -0.15644118f, -0.04803757f, -0.00051327f, -0.02177782f, 0.05297472f, 0.02458168f, 
    0.16191110f, -0.14203955f, -0.06942651f, -0.01848368f, -0.07498144f, -0.05270257f, 0.01471162f, 0.08559316f, 
    -0.22767782f, 0.05627481f, -0.00994873f, -0.03699426f, -0.08287030f, 0.05099599f, -0.05749303f, -0.12301023f, 
    -0.07362001f, -0.01606432f, 0.05460349f, -0.05988996f, 0.06099124f, 0.13971370f, -0.11332262f, 0.21044609f, 
    0.04901762f, 0.07898960f, -0.12069388f, -0.10818766f, -0.27321810f, -0.13236356f, 0.08311915f, 0.11308774f, 
    -0.18125151f, -0.04996936f, -0.11825261f, 0.00339092f, -0.05854614f, 0.07464040f, -0.00693394f, 0.08897001f, 
    -0.22436574f, -0.09545763f, -0.02249434f, 0.02635586f, 0.08224633f, 0.05561341f, -0.01676811f, 0.02353388f, 
    -0.83890200f, -0.17934577f, -0.28609139f, -0.28541175f, 0.00206009f, -0.23050210f, 0.06229973f, -0.02823236f, 
    0.12114991f, 0.02520637f, -0.03304984f, -0.02460872f, -0.69000930f, -0.49714890f, -0.35021827f, 0.01630305f, 
    0.05936299f, 0.03847110f, -0.16415051f, -0.01847546f, -0.00993146f, 0.03408561f, -0.01840380f, 0.09574565f, 
    -0.24177702f, 0.23456205f, 0.13011210f, -0.05773203f, 0.10068797f, 0.01172411f, -0.11318411f, 0.07382578f, 
    0.00857875f, -0.08752109f, 0.01299040f, 0.05197324f, -0.44369566f, 0.15890549f, 0.36510327f, 0.01294013f, 
    0.12585548f, -0.12218790f, -0.02925435f, -0.10809469f, 0.06780327f, -0.14350231f, 0.07867303f, -0.21103747f, 
    0.00557476f, 0.41576886f, -0.10753010f, -0.15454100f, -0.03174687f, 0.15514955f, 0.13284089f, 0.09130888f, 
    0.12741812f, 0.04589714f, 0.05282864f, 0.16894151f, 0.34359297f, 0.09894091f, -0.44721469f, 0.03161717f, 
    0.03504164f, -0.04628972f, -0.00608347f, 0.04939396f, -0.14186938f, -0.16181011f, 0.01892329f, 0.00848364f, 
    0.15360662f, 0.01684751f, 0.10586813f, -0.63581514f, 0.07928748f, -0.02791196f, -0.08635473f, 0.17009299f, 
    -0.05014608f, -0.14151579f, 0.01382810f, 0.07397447f, -0.02835487f, 0.02741223f, -0.15474829f, -0.33614397f, 
    -0.04627009f, -0.11805167f, -0.22938234f, 0.12277870f, 0.03491838f, -0.33002320f, 0.07145178f, -0.16588332f, 
    -0.35192695f, -0.07263508f, 0.17989515f, -0.20047158f, 0.06412460f, 0.11387422f, -0.20155519f, 0.07493053f, 
    -0.08921751f, 0.09894282f, -0.09162138f, 0.06997146f, -0.19122848f, -0.39646390f, 0.09944187f, 0.16680530f, 
    -0.10773969f, -0.04616768f, -0.13334560f, 0.03052151f, 0.06806438f, 0.03510344f, -0.11963705f, -0.01013898f, 
    -0.81076151f, 0.11921531f, 0.06704937f, -0.30284917f, 0.06433042f, -0.01410045f, 0.03386778f, 0.00299426f, 
    -0.23252994f, -0.04074072f, -0.09400613f, 0.01765905f, -0.04183239f, -0.10671592f, -0.13299201f, 0.22259320f, 
    -0.08427047f, 0.09873320f, 0.19642648f, 0.08071502f, 0.07403561f, -0.08168150f, -0.10289747f, -0.17125547f, 
    0.19615231f, 0.02743631f, 0.09932896f, 0.02835824f, 0.03900560f, -0.19220302f, 0.16201501f, -0.03081002f, 
    0.03391296f, 0.01830147f, -0.09903554f, 0.14192621f, 0.26602268f, 0.27841911f, -0.08295342f, 0.11360481f, 
    -0.20959580f, 0.12027173f, -0.09920365f, -0.13306941f, 0.06642509f, 0.25626862f, 0.03684934f, -0.10728037f, 
    -0.36432451f, 0.05577866f, -0.07263867f, -0.16807465f, 0.06509920f, 0.06323887f, -0.09876104f, -0.09072062f, 
    0.00483622f, -0.09763944f, -0.09314151f, -0.17644270f, 0.04342720f, 0.01828533f, 0.02546649f, 0.27201405f, 
    0.10531381f, 0.02246279f, 0.05547334f, 0.12520865f, 0.11784500f, -0.05902408f, -0.04678710f, -0.06767885f, 
    -0.32224420f, 0.03844028f, -0.12442528f, -0.09482608f, 0.02824490f, 0.06552391f, 0.10401628f, -0.01623720f, 
    0.06434739f, 0.01790341f, 0.04585736f, -0.03917143f, 0.17559081f, 0.22456966f, -0.03769305f, -0.01454599f, 
    -0.09681624f, 0.01129511f, -0.01243753f, -0.03804677f, 0.01102837f, -0.08779823f, 0.14702643f, -0.02012237f, 
    -0.09605353f, -0.00178008f, 0.21729532f, 0.03307937f, -0.11592808f, 0.04785851f, -0.08003504f, 0.09283910f, 
    0.26223424f, 0.03440057f, -0.05492596f, -0.05489422f, -0.42825529f, -0.11510652f, -0.07180273f, 0.03399298f, 
    0.13831468f, -0.25224969f, 0.12762700f, 0.02400316f, -0.10533568f, 0.03574121f, -0.08477025f, -0.03489965f, 
    -0.24977930f, -0.14362204f, 0.17706682f, -0.11494879f, -0.07342876f, -0.05463408f, -0.11523212f, -0.02129769f, 
    0.12506236f, -0.03198592f, -0.16632745f, 0.05900037f, -0.47255468f, -0.14157726f, 0.04071968f, 0.19220845f, 
    -0.01445668f, 0.01895384f, -0.03179129f, 0.04942262f, -0.18098998f, -0.01868524f, 0.07270857f, -0.04336371f, 
    -0.17282815f, -0.11432102f, -0.31116357f, -0.21480975f, -0.09000491f, 0.03332288f, 0.11391474f, -0.11543658f, 
    -0.02182275f, 0.02861034f, -0.03620271f, 0.02908228f, 0.70362186f, 0.02347162f, -0.03097189f, 0.17173043f, 
    0.03627583f, 0.02547886f, -0.04935682f, 0.21755365f, -0.00731274f, -0.00217852f, 0.11343990f, 0.17989299f, 
    -0.00560884f, -0.28960887f, -0.08184934f, 0.00011787f, 0.11226951f, 0.02594867f, 0.05886683f, -0.01321230f, 
    0.02614132f, -0.02239214f, 0.04650353f, -0.08409350f, -0.47699711f, 0.42035878f, -0.18916725f, -0.19548732f, 
    -0.04331006f, -0.01275703f, 0.05580237f, 0.02800406f, -0.11930319f, 0.05166438f, -0.00463510f, 0.09998630f, 
    0.33783177f, -0.02619217f, -0.03206952f, 0.23359400f, 0.07600477f, 0.06200630f, 0.00964446f, 0.02626508f, 
    -0.07104800f, 0.23890734f, 0.07854474f, 0.07457136f, -0.28271839f, -0.26615596f, 0.14308487f, 0.25961956f, 
    -0.03744638f, 0.14346053f, 0.04168812f, 0.08368724f, 0.00751486f, 0.03345792f, 0.19274183f, 0.12006984f, 
    -1.07459748f, 0.00284764f, 0.08588972f, 0.27030984f, 0.08792908f, 0.08026244f, 0.02922635f, 0.25392017f, 
    -0.07976343f, -0.02164464f, 0.10895779f, 0.02707320f, -0.08096202f, 0.10865942f, 0.33669826f, 0.06186377f, 
    -0.07281701f, -0.04584415f, 0.13719945f, -0.07168440f, 0.11521815f, 0.09800567f, 0.00007916f, -0.03952996f, 
    -0.24248596f, -0.31039631f, 0.04611646f, 0.03811892f, 0.11531430f, -0.00575553f, 0.15380855f, -0.00094675f, 
    -0.22850727f, 0.05250864f, -0.00902115f, 0.02946687f, -0.35492864f, 0.17543651f, 0.02789468f, -0.07152441f, 
    -0.01693686f, -0.10554903f, 0.12562014f, -0.11087942f, 0.03746689f, -0.01232284f, -0.08501460f, 0.03656150f, 
    0.10454194f, -0.04945200f, -0.25989965f, -0.02138760f, -0.01623094f, -0.08955722f, 0.03553852f, 0.16990931f, 
    -0.09064669f, 0.08816531f, 0.02987037f, -0.05576574f, -0.07767129f, 0.08309365f, 0.26072311f, 0.09028093f, 
    -0.01637356f, -0.07453868f, -0.01669193f, 0.04259445f, 0.16070744f, -0.00507918f, 0.00635736f, 0.08563916f, 
    -0.01611197f, -0.01057941f, -0.04922139f, 0.32954574f, -0.04978164f, 0.02362895f, 0.03022085f, 0.04988282f, 
    -0.20492768f, 0.12079990f, 0.14926928f, 0.03442776f, -0.03336327f, -0.10558706f, -0.02692655f, 0.35233250f, 
    -0.21129924f, 0.18544060f, -0.00125974f, 0.06340700f, 0.00591394f, 0.00253600f, -0.03791033f, 0.24801090f, 
    -0.09316812f, -0.11546831f, 0.28254306f, 0.11482559f, 0.16231900f, 0.05785157f, -0.11063848f, -0.04464753f, 
    0.03867276f, 0.04825164f, -0.09923143f, -0.08189513f, -0.06215991f, -0.08979837f, -0.17262961f, -0.21363144f, 
    0.01719692f, 0.01366526f, -0.10934857f, -0.02618234f, 0.15979476f, 0.00402830f, 0.06746750f, 0.08800004f, 
    -0.45242465f, -0.45568588f, 0.02912579f, 0.42923054f, -0.03960593f, 0.04181632f, 0.10560969f, 0.03543883f, 
    -0.11977851f, 0.00469009f, 0.07192092f, -0.02050982f, -0.13249873f, -0.06408755f, 0.02099849f, -0.02753251f, 
    0.13496612f, 0.13986672f, 0.08620062f, -0.04965050f, -0.06165151f, 0.15102294f, 0.02783740f, 0.24569479f, 
    0.47804400f, 0.07071052f, -0.14417642f, -0.03127784f, 0.00622125f, -0.21511009f, 0.08809939f, 0.11502811f, 
    0.21210478f, 0.01103038f, -0.08568098f, -0.11326936f, 0.05523691f, 0.09990908f, 0.01591816f, 0.28798753f, 
    -0.09226742f, -0.24201618f, 0.10806523f, -0.05925156f, -0.05360252f, -0.01671101f, 0.08459933f, 0.04742908f, 
    -0.44293568f, 0.21235076f, 0.05636215f, -0.11370312f, -0.04510539f, 0.03689678f, -0.04782869f, 0.13017529f, 
    -0.08615042f, -0.17543888f, 0.02579868f, -0.14971468f, -0.20940442f, 0.02384078f, 0.22305155f, -0.23556045f, 
    0.06065470f, -0.06309046f, 0.04536014f, -0.04085223f, -0.23771596f, 0.16937721f, 0.26085040f, 0.07529627f, 
    0.26116174f, -0.40557593f, -0.08378913f, 0.16737667f, 0.06421009f, -0.05481670f, -0.11300007f, -0.06783471f, 
    -0.10746830f, -0.17409684f, -0.01801418f, -0.07349940f, 0.22157301f, 0.05830039f, -0.07619763f, -0.17794377f, 
    -0.19961026f, -0.01951658f, 0.01569066f, -0.02494742f, -0.01152452f, -0.10839785f, -0.20893732f, -0.02165469f, 
    0.05057737f, 0.03241596f, 0.13289918f, 0.11845955f, -0.01117128f, 0.09847016f, -0.01576160f, 0.08069855f, 
    0.07653224f, -0.14239039f, 0.09865247f, 0.14061035f, -0.53740746f, -0.08991162f, -0.11655214f, 0.11853921f, 
    0.19041508f, 0.07626627f, -0.02226835f, 0.06371289f, 0.07462375f, 0.20971031f, 0.22295450f, 0.03093726f, 
    -0.20895785f, 0.21197531f, -0.04152511f, 0.23108441f, -0.08987097f, 0.04618588f, -0.10687394f, -0.00069042f, 
    0.15499420f, -0.09841850f, 0.05050827f, -0.06195451f, 0.01584645f, 0.09289563f, 0.10357122f, 0.24677110f, 
    -0.03064902f, -0.17417920f, -0.07541647f, 0.11415729f, -0.07164390f, 0.04945102f, 0.26901039f, -0.09174102f, 
    0.03063916f, -0.10964755f, 0.14110002f, 0.09269883f, 0.05949043f, 0.06320266f, -0.05494814f, -0.03262689f, 
    -0.15741126f, -0.01507966f, 0.14112119f, 0.19612111f, 0.10689971f, -0.18265721f, -0.12300194f, -0.16991791f, 
    0.11978159f, 0.01374923f, -0.02155353f, -0.00338211f, 0.05224508f, -0.01247723f, -0.00948566f, 0.11133291f, 
    0.05514098f, 0.27992374f, 0.09778789f, 0.09260167f, 0.05115317f, -0.04826667f, 0.15035789f, 0.19989529f, 
    0.02505336f, -0.09464642f, 0.22306286f, 0.32745257f, -0.35479906f, 0.01045082f, -0.26042306f, -0.15151674f, 
    0.06037063f, 0.06421161f, 0.04958264f, -0.09380887f, -0.01955794f, -0.08249240f, -0.12560445f, -0.00006555f, 
    -0.33865151f, -0.05183938f, 0.06717052f, -0.30462748f, -0.08128493f, 0.11751675f, -0.14233533f, 0.26849502f, 
    0.17151520f, 0.06963249f, 0.00140369f, 0.07996901f, -0.01914054f, -0.12708752f, 0.11162724f, 0.02714001f, 
    0.20769410f, -0.03071360f, -0.04278732f, -0.32305601f, -0.01210503f, -0.08149603f, -0.06078025f, -0.02334465f, 
    -0.56994438f, 0.10938966f, 0.09826564f, 0.10630620f, -0.00631359f, 0.03047929f, -0.03752253f, 0.00551759f, 
    -0.07017922f, 0.00809886f, 0.12982953f, -0.00917612f, -0.46346185f, 0.06450272f, 0.01744453f, 0.19029990f, 
    -0.18093379f, -0.03492160f, -0.25186008f, -0.12196052f, 0.05396597f, -0.21951969f, 0.01976203f, -0.22331536f, 
    0.15785594f, -0.22569476f, -0.27406695f, 0.23176268f, 0.01341094f, -0.06875988f, -0.04116625f, -0.26242861f, 
    -0.02271742f, 0.00170729f, -0.33472735f, 0.09593236f, 0.31066394f, 0.21187045f, -0.00569840f, -0.19627801f, 
    -0.01680191f, -0.07871434f, -0.23461182f, -0.34655970f, -0.10020969f, 0.01010448f, -0.11466721f, 0.10270198f, 
    -0.40138155f, -0.12746982f, -0.51580590f, -0.12184221f, 0.17415981f, 0.02805304f, 0.06630321f, -0.03428648f, 
    0.02151509f, 0.00782036f, -0.11780700f, -0.01533770f, -0.58685535f, -0.34226802f, -0.33636126f, 0.10355546f, 
    0.25012195f, 0.02033517f, -0.11392721f, 0.14367849f, 0.22034787f, 0.06746891f, 0.01147259f, -0.01802562f, 
    -0.02402078f, -0.11430299f, -0.06310720f, 0.02382336f, 0.11094577f, 0.32865319f, -0.20554006f, 0.02611424f, 
    0.03897224f, -0.13890073f, 0.19435571f, -0.10622706f, -0.33004925f, 0.45610213f, 0.06616264f, -0.23029463f, 
    0.14448321f, 0.13794388f, 0.06981180f, -0.14723378f, 0.02480011f, -0.16968028f, -0.01461682f, -0.21386746f, 
    -0.02177260f, 0.20358261f, 0.46197203f, -0.16640204f, 0.03730580f, 0.01410076f, 0.05683571f, -0.38864779f, 
    -0.17091477f, -0.04642791f, -0.09718227f, -0.06883412f, 0.00584832f, -0.14776164f, 0.09437893f, -0.04503172f, 
    0.00887565f, -0.15778755f, -0.11772545f, 0.13607872f, 0.03501756f, -0.02249048f, 0.09153812f, -0.16403566f, 
    0.19757059f, -0.34937605f, -0.18837661f, -0.11333746f, 0.03519940f, 0.05851730f, -0.04545504f, 0.04582555f, 
    0.00628723f, -0.28773677f, 0.04276329f, -0.07146779f, 0.17078669f, 0.00961443f, 0.02014787f, -0.31106392f, 
    -0.02888188f, -0.07516478f, -0.01402070f, -0.05623719f, -0.10400113f, -0.07525090f, -0.05097799f, -0.15590201f, 
    0.23414557f, 0.21657749f, 0.24244422f, -0.37209997f, -0.04962659f, -0.00373022f, 0.17465533f, 0.06706592f, 
    0.04139041f, 0.12215036f, -0.10528153f, 0.13290836f, -0.30736113f, 0.00324819f, -0.01790911f, -0.27372131f, 
    -0.14285581f, -0.07324951f, 0.14295989f, -0.05021730f, 0.17463522f, -0.04459716f, 0.13285582f, 0.02603175f, 
    0.05720674f, -0.18611117f, -0.12513049f, 0.01878039f, 0.07616592f, 0.05560242f, -0.12902437f, -0.12473390f, 
    0.13542436f, 0.09664544f, 0.10894199f, 0.16809393f, 0.02536011f, -0.17180602f, 0.01616292f, 0.00633814f, 
    -0.04103599f, -0.00374743f, -0.06226511f, -0.13531862f, -0.00197103f, -0.04960748f, -0.05205792f, -0.38791847f, 
    -0.34877491f, 0.20477642f, -0.04135885f, 0.43580103f, -0.01353803f, 0.15824038f, 0.00799230f, 0.03995944f, 
    -0.12354647f, -0.07077254f, 0.09705013f, -0.10215791f, -0.05269564f, 0.36393791f, 0.12328608f, -0.21934985f, 
    -0.08443220f, 0.13247663f, 0.02850010f, 0.10961884f, -0.09393672f, -0.07251272f, 0.08980480f, 0.16397604f, 
    0.78724605f, -0.24738811f, 0.14249475f, -0.17759314f, 0.15177314f, -0.03086792f, 0.19805010f, -0.00050913f, 
    0.04985843f, 0.09219317f, 0.13694502f, 0.04309124f, -0.21509841f, 0.16179134f, 0.10921068f, -0.04051441f, 
    -0.17487878f, 0.09102193f, 0.01350523f, 0.09616759f, 0.05287743f, -0.14613162f, -0.15510271f, -0.26777783f, 
    -0.23560427f, -0.10820113f, -0.05331662f, 0.24961674f, 0.17065030f, 0.18003178f, 0.16983683f, -0.18590838f, 
    0.11203220f, 0.15908144f, -0.07279295f, 0.06618261f, -0.23037519f, 0.01899670f, 0.30026817f, 0.01651204f, 
    0.17343073f, 0.04849728f, -0.06764530f, -0.01860251f, -0.08191468f, 0.01819961f, 0.05053824f, 0.04499360f, 
    0.19748126f, 0.07507364f, 0.13769852f, -0.00040829f, -0.02301881f, 0.03084408f, -0.12162150f, -0.07007760f, 
    0.08772218f, 0.01464452f, -0.06349509f, -0.01960051f, -0.44376308f, -0.03027670f, -0.12425032f, -0.45656201f, 
    -0.09147117f, -0.03994533f, -0.24602433f, -0.10636485f, -0.11340380f, -0.07339041f, -0.07623385f, -0.25433213f, 
    0.26754519f, -0.22931623f, -0.08554755f, 0.37249893f, 0.04983773f, -0.06754431f, -0.10498868f, 0.07729261f, 
    0.01038690f, -0.03745206f, -0.05981244f, 0.00554450f, -0.21718064f, -0.09186104f, -0.10968327f, 0.19364330f, 
    0.09619816f, 0.00822930f, 0.00211775f, -0.03093040f, 0.09373681f, -0.15856124f, 0.03820725f, 0.06305274f, 
    -0.14590137f, 0.21556027f, 0.05908717f, -0.24414070f, 0.11613956f, -0.02187567f, 0.00836166f, 0.03843284f, 
    0.00515185f, -0.00151294f, -0.08034925f, -0.16455041f, 0.19106172f, -0.05379546f, 0.10800225f, -0.04296292f, 
    -0.11040618f, 0.06258094f, 0.10653729f, 0.04197721f, 0.05007796f, -0.02655276f, 0.11045634f, -0.27301395f, 
    0.08840269f, -0.03605748f, 0.09681423f, -0.22169079f, -0.01973410f, -0.05754529f, 0.00609156f, -0.14104925f, 
    0.00918981f, 0.06048880f, -0.24056920f, -0.16723156f, -0.19726695f, -0.22913547f, -0.14505614f, -0.12117989f, 
    -0.14379925f, 0.16821937f, -0.00139987f, 0.01692849f, 0.00315275f, 0.11138948f, -0.01322821f, 0.04081188f, 
    0.04814408f, -0.26178694f, 0.02213452f, 0.03384408f, -0.06487818f, 0.08032956f, 0.04324880f, 0.02957215f, 
    0.02878723f, -0.10775559f, -0.01141683f, -0.04765346f, -0.11894293f, -0.19423546f, -0.21378854f, 0.04697498f, 
    -0.16515927f, -0.09459125f, -0.06290611f, -0.01141927f, -0.16826005f, 0.09842210f, -0.02715830f, 0.11190848f, 
    0.33646488f, -0.01573509f, -0.14046896f, 0.53368962f, 0.02320141f, 0.01008744f, -0.04293818f, 0.13288391f, 
    -0.07700707f, -0.06319137f, -0.19253071f, -0.00348525f, 0.35273233f, -0.39324838f, -0.02041223f, 0.13105254f, 
    0.05575845f, 0.06524999f, 0.16543159f, 0.04326686f, -0.05342397f, 0.03692542f, -0.05801516f, 0.14756697f, 
    -0.31898323f, 0.03130095f, -0.11799778f, -0.03058790f, 0.03939692f, -0.02801763f, -0.06870333f, -0.05896092f, 
    0.05484642f, -0.01940275f, 0.33874899f, 0.07753799f, -0.63993883f, -0.08486009f, -0.21561833f, 0.21766712f, 
    0.17903349f, 0.00619280f, -0.04649094f, 0.09241155f, 0.11269256f, -0.05742631f, 0.02988881f, -0.00411489f, 
    0.15295269f, -0.24973570f, 0.11751420f, -0.35041711f, -0.09295940f, -0.01305788f, -0.06167674f, -0.18193828f, 
    -0.17866892f, 0.04071241f, 0.07171382f, 0.23611124f, -0.41200238f, -0.31028962f, -0.14888719f, -0.10305181f, 
    -0.10694053f, -0.09095787f, -0.03592949f, -0.02092794f, -0.04985970f, -0.00502707f, 0.09654611f, 0.14688505f, 
    0.27943614f, 0.29195628f, 0.08688644f, 0.01610256f, -0.26825660f, -0.15137108f, -0.04419947f, -0.01050543f, 
    -0.12432670f, 0.22217232f, -0.13969822f, 0.15313201f, 0.06362601f, -0.35236672f, -0.04132833f, -0.15038750f, 
    0.02897848f, 0.02325161f, -0.06734733f, 0.27787614f, -0.02304551f, 0.04110182f, 0.02715635f, 0.12042551f, 
    -0.27714235f, 0.01738082f, 0.18523194f, -0.07909869f, -0.28925896f, 0.06721676f, 0.10671438f, 0.09679731f, 
    0.11740576f, 0.23397546f, 0.00547322f, 0.10354210f, -0.28480768f, 0.20794664f, 0.01829382f, 0.04535918f, 
    -0.01090215f, -0.12228019f, 0.07405508f, 0.15516721f, -0.12337473f, 0.01540529f, 0.01245057f, 0.13164569f, 
    0.16494729f, -0.00382616f, 0.04146929f, 0.31307611f, -0.01307508f, -0.05732466f, -0.04515934f, -0.02218058f, 
    -0.00298199f, 0.00697980f, -0.14038634f, -0.16912450f, -0.09427936f, -0.09233297f, -0.26134825f, 0.19172502f, 
    -0.12482449f, -0.17485324f, -0.11117744f, -0.05225193f, -0.01885104f, -0.07280023f, -0.07283912f, 0.00007322f, 
    -0.43586043f, -0.02946530f, 0.05419526f, -0.26040652f, 0.02879818f, 0.06857967f, 0.02930980f, -0.12591292f, 
    -0.07014125f, 0.04369439f, -0.05016622f, -0.03833004f, -0.05783645f, 0.07187377f, -0.11420406f, 0.04743139f, 
    -0.16184881f, 0.01518853f, 0.01214996f, -0.04768973f, -0.14023907f, -0.08526959f, -0.15626298f, -0.14704604f, 
    0.20597784f, -0.01653335f, 0.18475893f, 0.21836773f, 0.10063195f, -0.06245621f, -0.03010304f, -0.02798130f, 
    -0.08068964f, 0.02549694f, -0.07466975f, -0.24723531f, -0.03708706f, -0.01012910f, 0.09289155f, -0.08388825f, 
    0.02333758f, -0.02913320f, -0.09285413f, -0.03009859f, 0.00358023f, -0.06681119f, -0.00860616f, -0.10700236f, 
    -0.40106618f, -0.22647879f, 0.03450353f, -0.14748350f, -0.12552465f, 0.03723333f, -0.07259015f, -0.03971715f, 
    0.03294281f, -0.08372419f, -0.05900920f, -0.00839384f, -0.22884072f, -0.15098734f, -0.30234203f, 0.18141854f, 
    -0.07106034f, -0.03028475f, -0.08441180f, -0.06267022f, -0.26194504f, 0.02364065f, 0.08842820f, -0.08490449f, 
    0.57983559f, -0.05231111f, 0.15486452f, -0.14194845f, -0.07685173f, -0.09430952f, 0.04800566f, -0.04463875f, 
    0.01873054f, 0.01696221f, -0.08302861f, -0.02178225f, -0.12218513f, 0.24989021f, 0.11767320f, -0.09651157f, 
    -0.02784217f, -0.06637392f, 0.04830235f, -0.01891396f, -0.12362145f, 0.02766133f, -0.09440988f, 0.02305493f, 
    0.16223456f, 0.19061285f, 0.09217263f, 0.12543590f, 0.15147941f, -0.00754727f, -0.04239682f, -0.00758820f, 
    -0.02846890f, -0.02873866f, -0.05638375f, -0.02981449f, 0.03906523f, 0.29690105f, 0.06982589f, -0.01260430f, 
    -0.16853400f, 0.20098242f, -0.09582228f, 0.06885300f, -0.13458768f, -0.01596127f, -0.08898471f, -0.14164087f, 
    0.04900233f, -0.14814290f, -0.06740531f, -0.14997274f, -0.03556382f, -0.11477393f, 0.07309788f, -0.04937058f, 
    0.00762087f, -0.03765221f, -0.08301244f, -0.04147153f, 0.04118764f, 0.18402894f, 0.11136870f, 0.20640907f, 
    0.12848552f, 0.04364451f, 0.05521705f, -0.12047554f, -0.03672086f, 0.03086621f, -0.04568501f, -0.07810970f, 
    -0.15135604f, 0.14255267f, -0.15111175f, 0.12630168f, -0.22102346f, -0.07549963f, -0.00606572f, -0.06201485f, 
    0.07227379f, -0.00264155f, -0.08615164f, 0.11880234f, 0.02453795f, 0.13644603f, -0.01291434f, 0.08197986f, 
    -0.23397338f, 0.05514642f, -0.00815400f, -0.08066211f, -0.13341597f, -0.05220129f, -0.09775944f, -0.14366429f, 
    -0.23032254f, -0.17790499f, -0.11285347f, -0.16955604f, -0.01413474f, -0.06464145f, -0.04041526f, -0.02940414f, 
    -0.01418854f, -0.01089064f, -0.07121134f, 0.01382176f, 0.28352398f, -0.53625911f, 0.00760974f, -0.02377238f, 
    -0.10755046f, 0.00719801f, -0.05708243f, -0.01443772f, 0.01937348f, 0.11454874f, -0.07160154f, -0.02883609f, 
    0.01122818f, -0.19962852f, 0.05529350f, 0.09101514f, -0.01858073f, -0.18210512f, -0.01209298f, 0.10059848f, 
    -0.05252393f, 0.05751621f, -0.02734193f, -0.16230810f, -0.22278062f, 0.24985813f, 0.13361710f, 0.00083121f, 
    0.11618446f, 0.00876224f, 0.05841063f, 0.04341789f, -0.01312350f, 0.13814142f, 0.04994710f, 0.05548134f, 
    -0.35309145f, 0.21391419f, -0.04825291f, -0.11582764f, -0.08963774f, -0.01671494f, -0.09983556f, -0.05937502f, 
    -0.09024153f, 0.01852152f, -0.04339885f, -0.14078458f, -0.07975264f, 0.28297251f, 0.00004205f, 0.17301506f, 
    0.09208179f, 0.09881700f, 0.01848824f, 0.09233163f, 0.02521655f, -0.00635573f, 0.06664848f, -0.04162734f, 
    0.10519665f, 0.10073229f, 0.03318000f, 0.17029740f, 0.03520573f, -0.05696968f, -0.02980066f, -0.08124911f, 
    0.02630972f, -0.01124076f, -0.07594777f, 0.01459400f, 0.09906656f, -0.04259216f, -0.10757203f, -0.10585466f, 
    -0.07521186f, -0.12048496f, -0.06523519f, -0.09208804f, -0.05538601f, 0.04861619f, -0.08999142f, -0.10325736f, 
    0.05945710f, 0.21747626f, 0.11093882f, 0.15562424f, 0.00605479f, 0.02016061f, 0.14683022f, 0.01686402f, 
    0.10000992f, 0.09035175f, 0.00589518f, -0.17467874f, 0.01926417f, 0.13763626f, -0.00866169f, -0.06583088f, 
    -0.04684338f, -0.09068585f, 0.05912763f, -0.06296524f, 0.02799843f, 0.03997460f, -0.05422594f, 0.04033120f, 
    0.19000925f, 0.27730700f, 0.21388857f, 0.20119195f, -0.01229819f, 0.06604149f, 0.12515849f, 0.01441425f, 
    -0.08881094f, 0.16637963f, -0.05498280f, 0.00486641f, 0.26652274f, 0.12502339f, 0.19959910f, 0.04330282f, 
    0.16000602f, -0.00935789f, -0.05629404f, -0.08758055f, -0.12142604f, 0.03520836f, -0.08859886f, -0.06021797f, 
    0.11592594f, 0.21489188f, 0.06125691f, 0.29018617f, 0.15304480f, 0.09897038f, 0.13025849f, 0.01285324f, 
    -0.19809082f, 0.02064975f, 0.00856549f, 0.00120283f, -0.13672628f, -0.13107857f, 0.26064545f, -0.19252697f, 
    -0.04961783f, 0.06930566f, -0.01974581f, -0.04971396f, -0.06772193f, 0.07170949f, 0.01030417f, -0.08985764f, 
    -0.00912580f, 0.17801610f, 0.01053925f, -0.11787029f, -0.04662945f, 0.05044346f, -0.07593795f, -0.11028200f, 
    -0.06804720f, -0.07568663f, 0.03695195f, -0.14405885f, -0.09508106f, -0.17752849f, -0.11348006f, -0.24311393f, 
    -0.03434209f, -0.16300541f, -0.06812991f, -0.11901457f, -0.00239069f, -0.08500745f, -0.16123490f, -0.06300252f, 
    -0.15994664f, -0.21595025f, -0.24586728f, -0.59586126f, -0.05179079f, -0.05116221f, -0.13975328f, 0.01886780f, 
    0.10924768f, 0.11603682f, 0.14445427f, -0.22243893f, -0.22448945f, 0.06536858f, -0.01931994f, 0.18756655f, 
    -0.00036495f, 0.18713690f, -0.08384197f, -0.22985785f, 0.08556482f, 0.10883743f, -0.01151240f, 0.06376985f, 
    0.12827535f, -0.44490737f, 0.05246795f, 0.22167799f, 0.07973740f, -0.13305026f, -0.16722465f, 0.09601713f, 
    0.15018818f, -0.00858257f, 0.31382471f, -0.30643809f, -0.26199043f, 0.15514475f, 0.02057780f, 0.05785702f, 
    -0.12530163f, 0.00506104f, 0.04439327f, -0.11141489f, -0.02863157f, 0.13287598f, 0.01914095f, -0.19448525f, 
    -0.20278664f, -0.13386159f, 0.13943022f, -0.18020797f, 0.02302725f, 0.09105285f, 0.12265494f, -0.17414762f, 
    0.07009999f, -0.12776268f, -0.09319778f, -0.12329230f, -0.26564676f, -0.22870573f, 0.14888865f, -0.14655577f, 
    -0.10088316f, -0.02125594f, -0.03681253f, -0.07780751f, 0.00803009f, 0.15721260f, -0.03241412f, 0.08881196f, 
    0.24456267f, 0.32904831f, -0.12652037f, 0.01174039f, 0.11538961f, 0.05735988f, 0.11172915f, 0.00022808f, 
    0.12735301f, 0.12691292f, 0.10624708f, 0.10468901f, -0.34636027f, -0.37748870f, -0.10188676f, -0.21834105f, 
    0.08234155f, -0.10755447f, -0.17112227f, -0.09494076f, 0.18330997f, 0.18875298f, 0.12043785f, 0.00632804f, 
    0.05449950f, -0.10936304f, 0.01967994f, -0.25369644f, 0.10965245f, 0.01758738f, 0.05167333f, 0.11514180f, 
    0.08425530f, 0.05604095f, -0.01760095f, 0.05157876f, 0.18368462f, 0.08211897f, -0.23819731f, 0.13740374f, 
    0.12152688f, -0.16050068f, -0.28179246f, 0.00862128f, 0.00147258f, 0.03805237f, 0.15162869f, -0.20011874f, 
    0.05747053f, 0.23931414f, -0.35722807f, 0.08547192f, 0.07939736f, -0.27274093f, -0.25428221f, -0.00025773f, 
    -0.08497448f, -0.22437072f, -0.11642437f, 0.04932046f, -0.22955373f, -0.00593909f, 0.01434666f, -0.06471128f, 
    -0.05794551f, -0.17088988f, -0.00123661f, 0.00206919f, 0.22728685f, 0.06969927f, 0.06738742f, 0.18432726f, 
    0.18576980f, -0.04258458f, -0.23595524f, 0.14039490f, 0.08394025f, 0.04476677f, -0.09119997f, -0.04754596f, 
    0.02316010f, -0.05227097f, 0.20514385f, 0.10153928f, -0.33876741f, -0.00433196f, 0.20615667f, -0.06050581f, 
    -0.20762694f, 0.07786044f, -0.00380687f, -0.05049095f, 0.16950072f, -0.03744343f, 0.14249368f, -0.06723338f, 
    0.17923145f, 0.24325310f, -0.29166466f, -0.09678045f, -0.02963039f, -0.06876958f, -0.15576552f, -0.14653429f, 
    -0.02316299f, -0.12425429f, 0.01346459f, 0.01053534f, -0.15603776f, -0.14867982f, -0.30850840f, -0.21395059f, 
    -0.04356100f, -0.11014605f, -0.12092952f, -0.04172240f, 0.15993041f, -0.04851395f, 0.01562986f, -0.10000339f, 
    0.10716947f, -0.26625669f, -0.04002943f, 0.19784552f, 0.18843472f, 0.10315098f, -0.02152668f, 0.00167157f, 
    0.01413318f, -0.05232069f, 0.21111424f, 0.00407288f, -0.02687861f, -0.14745191f, 0.09090926f, -0.05433821f, 
    0.01693932f, -0.02640698f, 0.05263525f, -0.09834675f, -0.09190623f, 0.10301559f, 0.06355017f, 0.21340013f, 
    -0.03560605f, -0.34023896f, -0.17230248f, -0.09422304f, -0.15938281f, -0.04998805f, 0.04022336f, -0.12359840f, 
    -0.14205784f, -0.08118355f, 0.11997218f, 0.15051059f, -0.01947236f, 0.14219348f, 0.11781526f, 0.19812369f, 
    -0.19464357f, -0.00740806f, -0.07261959f, -0.08625820f, -0.01913015f, -0.09387542f, -0.08658997f, -0.08029952f, 
    0.15095603f, 0.01444463f, -0.00323489f, 0.18473910f, -0.02794207f, -0.09097935f, -0.03294388f, 0.02231534f, 
    0.20785914f, 0.07704549f, -0.11578801f, 0.01563001f, -0.06141074f, -0.13282523f, 0.20096561f, 0.12785292f, 
    -0.08964092f, -0.16561766f, 0.01623008f, -0.12297726f, 0.00617689f, -0.24622650f, 0.02012718f, -0.14609247f, 
    0.25526088f, 0.34323761f, -0.24814282f, -0.17637415f, 0.04514910f, -0.17637876f, 0.00396443f, -0.12881559f, 
    0.08961593f, -0.09040546f, 0.08678523f, 0.13445055f, 0.08844325f, 0.28195879f, 0.27000847f, 0.00162614f, 
    -0.10656072f, -0.06864531f, -0.12185188f, -0.02823796f, 0.14818850f, -0.17481884f, -0.03723558f, -0.17857541f, 
    -0.13052097f, -0.02393402f, 0.03992107f, 0.11701284f, -0.05323762f, -0.13076922f, -0.02380546f, 0.06099083f, 
    0.06842072f, -0.17936820f, -0.16601616f, 0.25657481f, 0.06776421f, 0.34833786f, -0.10014445f, 0.14015709f, 
    -0.16986394f, 0.10736022f, -0.00402988f, -0.06642709f, -0.04337010f, -0.01183537f, -0.12490935f, -0.05182295f, 
    -0.15098383f, -0.01419420f, 0.22209992f, -0.04255936f, -0.08633195f, 0.02814603f, 0.08283307f, 0.02999086f, 
    0.04557700f, -0.17528713f, -0.08161254f, -0.03678448f, -0.04042677f, 0.03416233f, 0.12068860f, -0.05925646f, 
    -0.15610655f, 0.12915714f, -0.20882498f, -0.10142367f, 0.06703275f, 0.03057419f, 0.07040119f, -0.00356759f, 
    -0.17022769f, -0.11408662f, 0.07727967f, -0.35313773f, -0.13692205f, -0.01391488f, -0.03871628f, 0.00658538f, 
    -0.06160797f, -0.00732706f, 0.08490541f, -0.14248762f, -0.40515244f, 0.01335286f, 0.13973679f, 0.10099566f, 
    -0.16254027f, 0.01876674f, -0.09781524f, -0.23073159f, 0.16123658f, 0.07604283f, -0.06986711f, 0.16305068f, 
    0.27637914f, -0.13799010f, 0.11629171f, 0.18333961f, -0.01034790f, -0.08622595f, 0.01914434f, -0.14484052f, 
    -0.07795981f, 0.06121967f, 0.03517822f, -0.01801186f, 0.29323474f, -0.10780354f, -0.11226437f, 0.14563245f, 
    0.10683629f, -0.03302666f, 0.00858562f, -0.02014704f, 0.04757790f, 0.04169566f, -0.12504217f, -0.06203965f, 
    0.00375400f, -0.08764690f, -0.21018675f, -0.20930938f, 0.05380472f, -0.15785123f, 0.03974051f, -0.00738384f, 
    -0.03644282f, -0.01990895f, -0.02904958f, 0.03496416f, 0.29435429f, 0.31052092f, -0.48753724f, -0.55076009f, 
    -0.12541565f, -0.05760089f, 0.11295763f, 0.00427498f, -0.04466382f, 0.07356700f, -0.02968106f, 0.05455768f, 
    -0.38411790f, -0.08648583f, 0.17887281f, -0.01141749f, -0.02014897f, -0.10362376f, -0.06204357f, 0.02791710f, 
    -0.10919795f, -0.00557979f, -0.00878434f, 0.12706575f, -0.46811065f, 0.62249315f, -0.22759070f, 0.32367122f, 
    0.05140249f, 0.13160050f, -0.01163843f, 0.15724036f, 0.01747590f, 0.02115295f, 0.09839016f, 0.04511918f, 
    -0.02405629f, -0.05353319f, -0.22791849f, 0.15890855f, 0.13308026f, -0.05431424f, 0.11662808f, -0.13264893f, 
    -0.02861624f, -0.01797462f, 0.05707369f, 0.21763593f, 0.34382579f, 0.01474996f, -0.19777454f, 0.29970598f, 
    0.11995301f, -0.10565423f, 0.05390421f, -0.02470654f, -0.04009695f, 0.00849011f, 0.04860341f, 0.02869826f, 
    0.32800084f, 0.19828205f, 0.05340977f, 0.11222400f, -0.04085432f, 0.02277915f, 0.19003320f, -0.35413188f, 
    0.09507081f, 0.01721751f, 0.06492828f, 0.11037636f, -0.08895250f, 0.09773088f, -0.09725247f, -0.24778074f, 
    -0.02768982f, 0.25830603f, 0.12998433f, -0.16044164f, 0.00659841f, -0.05749475f, -0.08253812f, 0.00153682f, 
    -0.20698854f, -0.02485845f, -0.11937170f, -0.15915127f, -0.05807317f, -0.14134920f, -0.11347039f, -0.01694556f, 
    -0.02898338f, 0.08478683f, 0.03361899f, 0.14576748f, 0.17419372f, -0.08736358f, -0.17947370f, -0.17264561f, 
    -0.13247778f, -0.02585136f, -0.01888325f, 0.07074764f, -0.00661927f, 0.18032454f, -0.22901432f, 0.15309316f, 
    -0.13833204f, -0.21305433f, 0.28306842f, 0.17381194f, -0.08515923f, -0.00986961f, -0.04009527f, 0.21743950f, 
    0.13759165f, 0.22076845f, 0.10070068f, -0.07384653f, -0.34813547f, 0.23953387f, -0.02982133f, -0.14390860f, 
    0.13058767f, -0.02980122f, 0.03021580f, -0.09439385f, -0.06705569f, -0.22785123f, 0.09753420f, 0.03174806f, 
    -0.26345134f, 0.26394632f, -0.14393599f, 0.04080335f, 0.06780264f, -0.06339826f, 0.04064651f, -0.01245684f, 
    -0.12563334f, 0.04949189f, -0.09683929f, -0.19750997f, -0.06248056f, -0.37614241f, -0.14129212f, -0.19215007f, 
    -0.03287603f, -0.06573139f, 0.11975774f, -0.03273673f, -0.06425089f, -0.14383946f, -0.10773298f, 0.07172653f, 
    -0.37045151f, 0.31890586f, 0.48378754f, 0.08154879f, 0.12526767f, 0.07497972f, -0.10020409f, -0.05045829f, 
    0.08772335f, 0.08215144f, 0.05918612f, 0.04905577f, -0.34553602f, 0.23981749f, 0.06646495f, -0.06428198f, 
    0.09978133f, 0.03082659f, 0.14599496f, -0.08075587f, -0.13584013f, -0.01577356f, -0.19736126f, 0.04541246f, 
    -0.28468293f, 0.07421442f, -0.03256754f, -0.29110551f, 0.09342755f, 0.02109311f, -0.10240724f, -0.04176508f, 
    -0.27452087f, -0.03021459f, -0.12859797f, -0.15558298f, 0.23507917f, 0.04679552f, -0.22494137f, 0.11141628f, 
    -0.04663904f, -0.04153238f, 0.03828312f, 0.19502260f, 0.13321668f, -0.04603126f, -0.00481173f, -0.07378713f, 
    -0.02114505f, 0.42013100f, -0.13706158f, -0.19244011f, 0.19102545f, 0.01855960f, 0.03974424f, 0.18466634f, 
    -0.12638220f, 0.03586035f, -0.17244779f, -0.23820361f, -0.14553858f, -0.36958691f, 0.17051539f, -0.05753446f, 
    0.15858831f, -0.12700966f, -0.03439685f, -0.02193068f, 0.08215790f, 0.06185497f, 0.09185193f, -0.05645853f, 
    -0.56304687f, 0.75516212f, -0.36471328f, 0.05410495f, 0.20230088f, -0.03208411f, 0.02416916f, -0.15444687f, 
    -0.04344943f, 0.08562514f, 0.11567372f, -0.01292637f, -0.50921208f, -0.33201844f, -0.01499531f, -0.35495707f, 
    0.01100149f, 0.07635415f, -0.05031671f, 0.10220929f, 0.16688988f, -0.11351571f, 0.14174020f, 0.00892757f, 
    -0.17282906f, 0.02544824f, 0.46603861f, -0.15559119f, -0.06222561f, 0.02789108f, -0.09808424f, -0.12268402f, 
    0.01083411f, -0.01772763f, -0.08428709f, 0.08702552f, 0.71754050f, 0.10652199f, -0.08796079f, 0.00164146f, 
    0.17182796f, 0.04471318f, 0.06253026f, -0.08959917f, -0.10273220f, -0.03542768f, 0.03674615f, 0.22246681f, 
    -0.21338798f, -0.11896542f, -0.00114473f, 0.03902974f, 0.17803727f, 0.04341640f, -0.02389845f, 0.17662251f, 
    -0.08433171f, -0.05416416f, 0.03408883f, -0.24248868f, 0.01030881f, 0.05561463f, -0.01081766f, 0.15841872f, 
    0.01853217f, -0.04303841f, 0.26799050f, 0.21742833f, 0.03548874f, 0.00875879f, -0.14126167f, 0.01302200f, 
    -0.10480592f, 0.00649454f, 0.02570481f, 0.03892454f, 0.11260112f, 0.00155696f, -0.16309007f, -0.00668215f, 
    0.16347192f, 0.09922571f, -0.05848833f, -0.03129376f, 0.27397594f, -0.36500284f, -0.10242797f, 0.06969142f, 
    -0.00738473f, 0.04506477f, -0.00681349f, 0.00875025f, -0.26155022f, 0.04449601f, -0.00602556f, 0.00914177f, 
    -0.48075667f, -0.35038745f, 0.33734998f, 0.03318880f, 0.03155445f, -0.02558273f, -0.00530640f, -0.03909042f, 
    -0.08805004f, -0.06075120f, -0.08061504f, 0.22127539f, -0.13192432f, -0.16127358f, 0.02575557f, 0.12560414f, 
    0.05099026f, 0.03377670f, 0.02777572f, -0.36365747f, 0.19377315f, 0.03995421f, 0.00996316f, -0.16827443f, 
    -0.19979870f, 0.14127831f, -0.41197366f, -0.21447642f, 0.09471913f, 0.08537536f, -0.09471051f, -0.08313359f, 
    0.14488141f, -0.15932621f, 0.07332968f, 0.04021537f, -0.01869799f, -0.04147012f, -0.07573537f, -0.16045743f, 
    0.14055051f, 0.10794718f, -0.02327925f, -0.28472862f, -0.22896443f, -0.07021277f, -0.13198894f, 0.07288359f, 
    0.26921445f, 0.12743066f, -0.11202095f, -0.09220561f, 0.13671128f, 0.02028742f, 0.09485383f, 0.05682418f, 
    -0.02701182f, 0.16133595f, -0.04908752f, -0.03952105f, 0.08540078f, 0.28025898f, 0.16513771f, -0.14479496f, 
    0.12876262f, -0.06748194f, 0.02227631f, 0.01885244f, -0.01883722f, 0.15601866f, -0.05637664f, 0.12072966f, 
    -0.92491138f, -0.25191379f, 0.06751856f, -0.32740247f, 0.23035185f, -0.22511156f, -0.22106473f, -0.00277793f, 
    -0.00563810f, -0.18384807f, -0.03605695f, -0.13879459f, -0.02598156f, -0.26750976f, 0.02732468f, 0.24355333f, 
    -0.09637784f, -0.05054619f, 0.16833328f, 0.04245807f, 0.07310169f, -0.05004264f, -0.12511064f, -0.02993600f, 
    0.21264619f, 0.23776691f, 0.07373507f, 0.13673918f, -0.01152612f, 0.18288784f, 0.08868816f, 0.02487803f, 
    0.08824232f, -0.02490704f, 0.04157329f, -0.31045875f, 0.26048160f, 0.19214329f, -0.08456273f, 0.00388217f, 
    0.00632656f, -0.08324535f, 0.24325344f, 0.06690715f, 0.13395816f, 0.02305036f, 0.10234929f, 0.21895996f, 
    -0.60736507f, -0.43342373f, -0.14440034f, 0.06566316f, 0.08104154f, -0.00129662f, 0.10931226f, -0.02286689f, 
    0.09697948f, -0.21364866f, -0.02606053f, 0.15106107f, -0.05508383f, -0.29935694f, 0.19291975f, -0.32953823f, 
    0.05686133f, 0.04953714f, -0.12854964f, 0.09788963f, -0.04898465f, -0.09247600f, -0.09600446f, -0.01182742f, 
    -0.01193550f, -0.05948532f, -0.02222527f, 0.20604774f, 0.04279939f, 0.12677127f, -0.03853956f, 0.04978048f, 
    0.07131052f, 0.01994209f, 0.06717733f, -0.02233060f, -0.36340210f, -0.31474313f, -0.31705019f, -0.18183711f, 
    0.13884604f, -0.05867011f, -0.27051923f, -0.07924362f, -0.07682895f, -0.01449429f, 0.28861418f, -0.13482238f, 
    -0.28568158f, -0.00409572f, 0.04566097f, -0.00582575f, -0.06128195f, -0.02066821f, 0.05490524f, -0.26449060f, 
    -0.00307851f, -0.19505517f, -0.20995536f, -0.10426630f, -0.91633934f, -0.60890371f, -0.07535489f, -0.09940831f, 
    0.07763287f, 0.08308583f, 0.06817107f, -0.18602079f, 0.11797592f, -0.02309113f, -0.13125323f, 0.12433969f, 
    -0.54438519f, -0.32697991f, -0.07572143f, 0.01249165f, 0.05168420f, -0.05763052f, 0.00138267f, 0.05602679f, 
    0.16075714f, 0.21634637f, 0.25012153f, 0.20309271f, 0.17095320f, 0.11530448f, -0.04773463f, 0.02479916f, 
    -0.01845161f, 0.10098737f, 0.09403137f, -0.16520016f, 0.01218295f, 0.19742770f, 0.06559812f, 0.01451784f, 
    -0.29172063f, -0.06908259f, 0.00933594f, -0.01494103f, 0.03492293f, 0.06418616f, -0.08275562f, -0.04169244f, 
    0.11783822f, -0.06318763f, -0.04598914f, 0.00669420f, -0.10071451f, -0.14163092f, 0.21103753f, 0.13794063f, 
    0.12485690f, 0.28738379f, -0.03133723f, 0.02093715f, 0.08195899f, 0.14817233f, 0.06719761f, 0.03341572f, 
    -0.80285078f, -0.34632510f, -0.04949790f, -0.43126252f, 0.07982750f, 0.10465372f, 0.00245533f, 0.01654558f, 
    0.11713897f, 0.07448015f, 0.11020663f, 0.18205501f, 0.13489874f, 0.12514114f, -0.16395941f, -0.04333850f, 
    0.02101284f, 0.09497679f, -0.01524759f, 0.18555292f, 0.02124355f, 0.19801798f, 0.10942230f, 0.13933989f, 
    -0.03066174f, 0.21252896f, -0.02715590f, 0.01342229f, -0.02853780f, -0.13489766f, 0.00727528f, 0.00141000f, 
    -0.05773875f, 0.05729123f, 0.33860612f, 0.10380569f, 0.25839946f, 0.00944491f, -0.26067108f, 0.08249485f, 
    -0.16886126f, -0.14680354f, 0.12501383f, -0.05709369f, 0.16119279f, -0.06934243f, -0.08038802f, -0.05678509f, 
    0.04802727f, 0.02498010f, -0.10782766f, 0.11342091f, 0.14232977f, -0.33152118f, 0.12548681f, 0.10794619f, 
    0.02163361f, -0.07968644f, 0.14307424f, 0.12967610f, -0.15357426f, 0.12699302f, -0.08505265f, 0.04921464f, 
    0.01720801f, -0.16234444f, 0.02142321f, -0.14124770f, -0.17052878f, -0.07716390f, -0.13708532f, -0.06501389f, 
    -0.17186615f, -0.02879814f, -0.17222404f, -0.00977241f, 0.04467111f, -0.01274816f, 0.01958706f, -0.00533672f, 
    0.01411570f, -0.04425936f, 0.14892244f, 0.02277589f, 0.09776735f, 0.00143059f, 0.15853083f, -0.03523239f, 
    -0.13305841f, 0.09135767f, 0.05549363f, -0.00435082f, 0.02363943f, 0.13276507f, 0.13201872f, -0.12206321f, 
    0.10127413f, 0.04839529f, 0.29286486f, -0.12479492f, -0.09479667f, -0.19180833f, 0.05106248f, -0.05173279f, 
    0.05334925f, -0.14914474f, -0.03481442f, 0.02297382f, 0.17546922f, -0.14144044f, -0.01936057f, -0.15410388f, 
    -0.11474165f, 0.14856516f, 0.04718757f, -0.09481764f, 0.00891865f, -0.11099657f, -0.21390912f, -0.11311037f, 
    0.31126618f, 0.05700317f, -0.13063446f, -0.05592958f, -0.26131761f, -0.11232829f, 0.10345215f, -0.13532624f, 
    0.10588090f, -0.14105403f, 0.05387051f, -0.07107491f, 0.16559677f, 0.07217196f, -0.00840709f, -0.17129837f, 
    -0.05875093f, 0.05769920f, -0.06673922f, 0.07454113f, -0.03743382f, 0.01353876f, 0.19670941f, -0.02663847f, 
    0.11465571f, 0.10890534f, -0.02972806f, -0.01506486f, -0.10902587f, 0.03225483f, -0.02912072f, -0.09254585f, 
    0.12215811f, 0.03870286f, 0.08896744f, -0.26935682f, 0.18212423f, 0.05743805f, -0.13781621f, 0.05538710f, 
    -0.00135677f, -0.16551714f, -0.08051510f, 0.07461551f, -0.11288489f, -0.01459443f, 0.03570573f, 0.04517186f, 
    -0.45514315f, -0.38654560f, -0.14732492f, -0.23362137f, -0.01255429f, 0.03078306f, -0.06287231f, -0.12566175f, 
    0.06783702f, -0.07520084f, 0.08584309f, 0.07036984f, -0.44330025f, -0.01170507f, -0.04105450f, -0.21354781f, 
    0.04132186f, 0.06348317f, 0.02883852f, 0.06761538f, 0.22583559f, 0.02318223f, -0.03862057f, 0.02377686f, 
    -0.01338192f, -0.07067191f, -0.07599581f, 0.40323815f, -0.13452806f, 0.04415898f, 0.02140320f, -0.01723979f, 
    0.05592880f, -0.19627652f, -0.14309262f, 0.00004813f, 0.23663999f, -0.45952466f, -0.15179861f, 0.06671317f, 
    0.16642985f, -0.09371498f, 0.01036310f, 0.04186948f, 0.05707022f, 0.01871281f, -0.03563176f, -0.01107019f, 
    0.13542111f, -0.12034979f, -0.04588674f, -0.41474128f, -0.13099471f, 0.03804088f, -0.02522720f, -0.03192981f, 
    0.14378414f, -0.02615009f, 0.03215823f, 0.15798341f, 0.14865606f, 0.02479973f, 0.11526491f, 0.11423039f, 
    0.12080880f, -0.20467445f, 0.07256421f, -0.10410979f, 0.14516553f, 0.06408063f, -0.00085740f, 0.10152317f, 
    -0.47795328f, -0.13249207f, 0.03141795f, 0.12855709f, -0.17513326f, -0.03559031f, -0.01156086f, -0.08730861f, 
    -0.15392397f, 0.13881551f, 0.09657587f, 0.10485896f, 0.03646860f, -0.04277431f, 0.31750113f, -0.06723703f, 
    0.02008631f, -0.02949046f, -0.04736580f, 0.02914310f, -0.07124930f, -0.05508450f, 0.03910038f, 0.04185288f, 
    0.10022173f, -0.28015924f, -0.05928380f, -0.14617847f, 0.18116787f, 0.01951510f, -0.22420396f, -0.01630724f, 
    -0.11653711f, 0.09344773f, -0.00028459f, -0.02925586f, 0.51465040f, 0.31470031f, -0.73122728f, 0.31580254f, 
    0.04261699f, -0.07893995f, 0.01748289f, 0.03675150f, 0.09315734f, 0.11543672f, 0.06120590f, 0.01021284f, 
    -0.48756436f, 0.25789714f, -0.08640746f, -0.00437633f, 0.25567049f, -0.11815420f, -0.03801392f, -0.01260158f, 
    0.01131486f, 0.05094736f, 0.10361752f, 0.01454108f, -0.26010108f, 0.01650880f, 0.02628601f, 0.10364557f, 
    0.11090337f, 0.07801346f, 0.07406192f, 0.09612539f, -0.00280228f, -0.23079759f, -0.02457863f, -0.11344220f, 
    -0.06182678f, 0.17385969f, -0.03889851f, 0.05022494f, -0.19698913f, 0.14262365f, -0.27763823f, -0.07261577f, 
    -0.03098414f, 0.21128535f, -0.01903353f, 0.02636431f, -0.11758887f, 0.40189636f, -0.04965701f, 0.15191771f, 
    0.23701289f, -0.06456856f, -0.11140004f, 0.00295770f, -0.00023633f, 0.03880892f, 0.08307209f, 0.10867423f, 
    0.33735082f, -0.14918052f, -0.25885946f, 0.10866614f, 0.11682704f, -0.00829407f, 0.15402070f, -0.01965061f, 
    -0.28536627f, -0.08081809f, -0.16202094f, -0.03178187f, 0.25386184f, 0.19524404f, -0.08241168f, 0.02486151f, 
    -0.28424013f, -0.01484635f, 0.00530382f, -0.06449708f, 0.07987625f, -0.03844267f, -0.02300543f, -0.22791454f, 
    0.21802707f, -0.14787999f, -0.22131753f, 0.09483101f, 0.13555886f, -0.01642038f, -0.09951525f, -0.21882123f, 
    -0.06303315f, 0.04912017f, -0.00971670f, -0.08575062f, -0.08385823f, 0.17892496f, -0.07887069f, -0.17538258f, 
    0.18135244f, 0.13371153f, 0.03780007f, -0.10609542f, -0.01406021f, -0.09086484f, -0.11541130f, -0.07519880f, 
    0.53921002f, 0.16497166f, -0.36349347f, -0.13916728f, 0.02046335f, -0.14966488f, 0.03050198f, -0.08691420f, 
    0.01847992f, 0.05149509f, 0.02172150f, -0.01158899f, -0.41509137f, 0.36154619f, 0.03074730f, -0.20095059f, 
    0.00758962f, 0.08572271f, -0.01853115f, 0.05794091f, -0.03901706f, -0.04129740f, 0.01523797f, 0.08432969f, 
    0.17919692f, -0.10836348f, -0.05939299f, 0.22911510f, 0.10939431f, -0.11632354f, -0.00335853f, -0.10007191f, 
    -0.08744714f, -0.04116220f, 0.05999010f, -0.13343224f, 0.12721093f, -0.22911733f, 0.11019631f, 0.05479905f, 
    0.00110149f, -0.06705406f, -0.00616275f, 0.09808980f, -0.11222908f, -0.00984581f, 0.02643022f, -0.12779810f, 
    0.26809645f, -0.17209001f, 0.27863145f, 0.43820783f, -0.12229310f, 0.14519285f, 0.07416585f, -0.09233634f, 
    0.04516571f, 0.06807557f, -0.01423720f, 0.05411432f, -0.14626403f, -0.17864522f, 0.03165095f, -0.03769814f, 
    -0.19177140f, 0.17305845f, 0.00657091f, 0.11516684f, 0.00555452f, -0.03029204f, -0.22202303f, -0.01059109f, 
    0.22271070f, -0.25879663f, -0.18219583f, 0.19720623f, 0.08541195f, -0.01732689f, -0.04673735f, -0.11186861f, 
    0.19575459f, -0.00263854f, 0.04622868f, 0.00192055f, -0.65117753f, -0.47840187f, -0.00826820f, -0.17849411f, 
    0.10633655f, -0.19376525f, 0.10761781f, 0.09658471f, -0.06182301f, 0.08111476f, -0.22750968f, 0.07749584f, 
    -0.14563560f, 0.22406447f, -0.04347362f, -0.21324404f, -0.11433359f, 0.10130307f, -0.00997003f, -0.05484892f, 
    0.05778390f, 0.04142568f, 0.11855858f, -0.11882785f, -0.37882850f, -0.08981240f, -0.06085347f, 0.00800047f, 
    0.02892603f, 0.03929231f, 0.09897359f, -0.00842723f, -0.03057333f, -0.03405262f, 0.12844449f, -0.07292195f, 
    -0.10516054f, 0.06972435f, 0.04415659f, 0.12514342f, 0.19225569f, -0.04617705f, -0.03432643f, -0.18905869f, 
    0.04077504f, 0.03004632f, -0.04457143f, -0.27141336f, -0.19152185f, 0.34691772f, -0.06829122f, 0.13022746f, 
    -0.04959908f, 0.05366312f, -0.00255287f, -0.16858192f, -0.03016135f, 0.02192468f, 0.09903220f, -0.18219593f, 
    0.22026370f, -0.14469349f, -0.16036986f, 0.07435536f, -0.23683675f, 0.03566649f, -0.17930198f, -0.13555728f, 
    0.09381789f, -0.04601505f, 0.05648842f, -0.09706865f, 0.26213753f, 0.15787928f, 0.04807673f, -0.06148286f, 
    -0.18554515f, -0.01907764f, 0.08404264f, 0.04849067f, -0.13100566f, 0.09236858f, -0.01172264f, -0.13062589f, 
    -0.19192924f, -0.39751217f, -0.18697844f, -0.25086731f, 0.06894501f, 0.00005430f, 0.02590602f, 0.11494026f, 
    -0.00362436f, -0.01628646f, -0.03380159f, -0.10863683f, 0.44480672f, -0.03261114f, -0.19291940f, -0.29430482f, 
    0.01456193f, 0.00617325f, 0.06593551f, 0.01213670f, 0.01532578f, 0.07770880f, 0.06988561f, -0.07210532f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13746136f, 0.06490804f, -0.02960670f, -0.05420044f, -0.00432197f, -0.01213685f, 0.04717759f, -0.09362378f, 
    -0.05463224f, 0.05529130f, 0.13223982f, 0.06672446f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
