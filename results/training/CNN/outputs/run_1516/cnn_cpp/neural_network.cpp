#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70650125f, -0.50419629f, 0.60765773f, -0.21498302f, -0.53023005f, 1.07992744f, 0.37062296f, -0.19026707f, 
    -0.38605464f, -1.09124041f, -0.57507938f, -0.83603603f, 1.12963104f, 0.88511539f, -0.15984704f, -0.47323588f, 
    -0.69451451f, -0.53201360f, -0.18134530f, 0.17657900f, 0.26707083f, 0.88481402f, -0.82198733f, -0.23187143f, 
    0.98398006f, -0.28534585f, -0.61439192f, -0.81088412f, -0.39829397f, -0.94816363f, -0.59329277f, -0.51350009f, 
    -0.67594475f, -0.79077595f, -0.32160795f, 0.84837121f, 0.77604300f, 0.16745628f, -0.58114839f, -0.36639580f, 
    0.38370284f, -0.58130878f, 0.94994885f, -0.87379783f, 0.72642356f, 0.01082301f, 0.38803962f, -0.27960584f, 
    -0.11948937f, -0.31695449f, 0.49705660f, -0.30470335f, -0.78079742f, 1.06340206f, 1.20114100f, 0.64340317f, 
    0.53545898f, -0.71611226f, 0.14767921f, 0.80766523f, 0.17562975f, 0.66932052f, -0.83209658f, -0.61534059f, 
    -0.66755515f, -0.32916695f, 0.84996581f, -0.43189344f, -0.75950497f, 0.69021714f, 0.84106833f, 0.81083655f, 
    -0.96316630f, -0.49969760f, -0.35512945f, 0.62848890f, 1.04373252f, 1.10766828f, 0.28440782f, 0.54538602f, 
    0.58682960f, -0.12155487f, 0.36039659f, -0.08779697f, -1.16574717f, -1.51271605f, -1.72775316f, -0.88606602f, 
    -0.53135711f, -0.38302192f, 0.97633421f, -0.95011908f, 0.79214913f, -0.29446027f, -0.09695949f, 0.08641735f, 
    0.45654985f, 0.44394630f, 0.43998137f, -1.60271633f, 0.61710173f, 0.33892846f, -0.42874449f, -0.11289519f, 
    1.65927517f, -0.24816133f, 0.13215148f, -0.16337216f, -1.42944157f, 1.98870516f, -1.63010406f, -0.43776694f, 
    -0.41499799f, 0.45473832f, -0.23820277f, -0.12964100f, 0.47403157f, -0.95706630f, -0.03069442f, 0.36602700f, 
    -1.36556113f, -1.10088849f, -1.44557977f, 0.91114348f, 0.44654757f, 0.20707841f, -1.69810975f, -0.87621015f, 
    -0.58215141f, -0.16247661f, -0.24216211f, -0.93986821f, -0.38421631f, -0.43416670f, -0.67206210f, 1.60956514f, 
    -0.23738305f, -0.60252053f, 1.09322703f, 0.71475327f, 0.61440223f, -0.38173956f, 0.74638444f, -0.67071027f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.75933486f, 0.43228838f, 0.82350928f, 0.32125524f, -0.07973958f, 0.85384309f, 0.96701431f, -0.04338163f, 
    0.24043921f, 0.35330507f, 0.54699320f, 0.66621047f, 0.77207518f, 0.58734268f, -0.17613873f, 0.53397262f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02983683f, -0.06996834f, 0.02033663f, 0.00609738f, -0.01083767f, -0.07395782f, -0.03058209f, 0.01929509f, 
    0.02967204f, -0.02869974f, -0.04977067f, -0.04164284f, 0.06060053f, -0.02284986f, 0.00648663f, 0.04428067f, 
    -0.00925673f, -0.02630490f, 0.04836149f, -0.01699707f, 0.01260603f, 0.05149671f, -0.07175361f, -0.03694378f, 
    -0.06149740f, -0.01313903f, -0.07943050f, -0.02465699f, 0.06959575f, 0.05567338f, -0.08079089f, -0.04600332f, 
    -0.02476003f, -0.01792345f, -0.05234820f, -0.01429135f, -0.06775112f, -0.03444734f, 0.06753765f, 0.03393356f, 
    0.07098446f, -0.04735543f, -0.06205815f, 0.06122870f, -0.08471419f, -0.05724502f, -0.07284568f, -0.04677999f, 
    0.02687512f, -0.04659420f, -0.00574503f, 0.03410422f, 0.03530616f, 0.01544116f, 0.03695533f, -0.08289279f, 
    -0.06385394f, 0.03008794f, -0.02143358f, 0.06248174f, 0.03246452f, -0.01668431f, -0.08749731f, -0.00327685f, 
    0.02059387f, -0.00227994f, -0.03902305f, -0.01995230f, 0.08017584f, -0.04918554f, -0.08557834f, -0.05123097f, 
    -0.00732420f, -0.02262066f, -0.07311009f, -0.02238930f, -0.02761344f, -0.00774913f, 0.06986818f, 0.05476552f, 
    0.00973462f, -0.06523628f, -0.06153436f, -0.06626350f, -0.05107331f, 0.04142897f, -0.08898523f, 0.02623187f, 
    -0.02366949f, -0.03351182f, 0.07080226f, 0.04663195f, -0.01119324f, 0.02048554f, 0.06164044f, 0.06305948f, 
    -0.00197731f, -0.08964416f, 0.05129562f, 0.07349987f, -0.04483100f, -0.04747765f, 0.05089507f, 0.05840034f, 
    -0.02702331f, 0.01742901f, 0.01340595f, -0.00489804f, -0.05362733f, 0.06564564f, 0.04748897f, -0.08455935f, 
    0.00613890f, -0.00412278f, -0.08442169f, -0.01914240f, -0.05873521f, -0.03397667f, 0.01338854f, -0.05501319f, 
    -0.07780436f, 0.02952093f, 0.03939760f, -0.04704998f, 0.07591651f, 0.00133163f, -0.01752582f, -0.06358635f, 
    -0.01117143f, -0.01525463f, 0.03853298f, -0.00489627f, 0.02594204f, 0.00743574f, -0.04740673f, -0.08154332f, 
    -0.00952519f, 0.00622749f, -0.00364561f, -0.01556096f, -0.04328966f, 0.02125358f, -0.06780175f, -0.07820399f, 
    0.06880262f, -0.13533908f, 0.12850191f, -0.04461497f, 0.05065181f, 0.02596612f, 0.16557750f, 0.30490923f, 
    -0.15201244f, -0.01675370f, 0.13093089f, -0.01275220f, -0.45181832f, 0.14596355f, -0.50359303f, 0.02961113f, 
    0.01677256f, 0.21245325f, 0.21756914f, -0.16078961f, 0.01096966f, -0.38040316f, 0.18448296f, 0.14776079f, 
    0.15923837f, -0.15329643f, 0.04717176f, -0.88746202f, 0.19055976f, 0.35162053f, -0.08152174f, 0.05600625f, 
    0.07945299f, 0.03444210f, 0.02229945f, 0.05484568f, -0.21148059f, 0.00268775f, 0.11691818f, 0.16573250f, 
    -0.02889335f, 0.05588228f, 0.17799611f, -0.36184871f, -0.44700116f, 0.01153764f, 0.05559858f, -0.06013361f, 
    0.12382963f, -0.08420582f, 0.02181749f, 0.15510176f, -0.09917451f, 0.15949143f, -0.08503659f, -0.07595976f, 
    0.01227655f, 0.12769942f, 0.24046680f, 0.07513742f, 0.26777074f, 0.07200897f, -0.00311624f, 0.37713590f, 
    -0.42526305f, 0.11683366f, -0.10092453f, 0.14156967f, 0.17309551f, 0.13638295f, 0.10925664f, 0.20409116f, 
    0.12196668f, -0.10166138f, 0.06234870f, -0.12096950f, -0.30648622f, -0.22750127f, 0.14591075f, 0.05734637f, 
    -0.07521228f, 0.05706519f, -0.17806707f, -0.78547692f, 0.19369648f, -0.14377478f, -0.09349688f, 0.17771119f, 
    0.13535640f, 0.11601019f, 0.06967539f, 0.05112689f, 0.20360507f, 0.31912425f, 0.03140989f, -0.00342463f, 
    -0.03718071f, 0.01852824f, -0.42494467f, -0.65264928f, 0.10195406f, 0.08973107f, 0.51341319f, 0.08816531f, 
    -0.16788526f, 0.18646669f, 0.02899642f, -0.10101184f, -1.26079726f, 0.13096549f, -0.72250742f, 0.09890001f, 
    0.06447499f, 0.36678988f, 0.07095648f, -0.16945125f, -0.08358701f, 0.47326845f, 0.83530045f, 0.06533511f, 
    0.06311310f, -0.35071352f, 0.12598975f, -0.24210428f, -0.11839403f, -0.03773215f, -0.62593138f, -0.17082851f, 
    0.33065340f, -0.00577012f, -0.35730553f, -0.25110030f, 0.05478393f, 0.01304011f, 0.13146093f, 0.69265729f, 
    0.25779167f, 0.49089444f, -0.27247018f, -0.05261421f, -0.00568818f, -0.06341728f, -0.09700566f, -0.16200089f, 
    -0.87167442f, -0.02618249f, -0.21656500f, -0.26581690f, -0.03109291f, 0.32182133f, -0.18598787f, 0.21171185f, 
    0.19436267f, -0.60551608f, -0.01848476f, -0.17287116f, -0.28853071f, -0.22386505f, -0.15918010f, 0.00614729f, 
    0.00132267f, 0.09328606f, -0.54327089f, -1.04378986f, 0.28625974f, 0.17278832f, 0.15674211f, -0.14080307f, 
    0.24604060f, -0.13647889f, 0.06708497f, 0.14919586f, 0.72118074f, 0.16648786f, -0.01844930f, -0.07116295f, 
    -0.03565548f, 0.14162038f, -0.00515668f, 0.05402609f, 0.19397718f, 0.20597526f, 0.77205652f, -0.29252020f, 
    0.20870596f, 0.08060890f, 0.04577694f, 0.14470094f, -0.01885763f, -0.49750265f, 0.40966591f, -0.09560923f, 
    -0.06507885f, -0.04803844f, -0.02312548f, 0.07590494f, 0.00333051f, 0.09392554f, -0.67925102f, -0.48897728f, 
    -0.58976310f, 0.02708956f, 0.19553158f, -0.12120311f, 0.15381067f, 0.19952881f, -0.06721588f, 0.59468716f, 
    0.07552041f, 0.09907487f, -0.28368095f, -0.37186715f, -0.19116127f, 0.38346836f, -0.01703642f, 0.10727054f, 
    0.05175529f, 0.14826550f, -0.07234087f, -0.43543285f, -0.24577808f, -0.05010625f, 0.28361332f, -0.09104683f, 
    0.19194284f, 0.23940742f, 0.09124828f, 0.42975709f, 0.05618363f, 0.20626348f, 0.08715660f, -0.02870962f, 
    -0.04274889f, 0.12494245f, -0.29563493f, 0.05793757f, -0.40558505f, 0.29547897f, 0.28829947f, 0.14060086f, 
    0.08896034f, -0.00168148f, -0.17398784f, -0.89132720f, 0.47151816f, -0.31344950f, -0.27230376f, -0.18102784f, 
    -0.06262615f, 0.04862339f, 0.19521773f, 0.22896884f, -0.26266053f, 0.14193968f, -0.34412274f, -0.08911011f, 
    0.24569817f, 0.09637489f, -0.00705320f, 0.00102887f, -0.07238014f, 0.30224487f, 0.45974180f, 0.44069505f, 
    -0.09409594f, -0.08646730f, 0.01937311f, -0.03019825f, -0.09215020f, 0.03948228f, -0.14823754f, -0.09021354f, 
    0.13549706f, 0.01518720f, -0.14812148f, -0.14160232f, 0.05633309f, 0.03205361f, 0.09789021f, -0.39276969f, 
    0.06147381f, -0.06427079f, -0.14540070f, -0.48928106f, -0.34924042f, 0.13373061f, 0.07782824f, 0.24250540f, 
    -0.47811666f, -0.28803772f, 0.00869648f, -0.01404683f, -0.15640341f, 0.07921951f, 0.15863529f, 0.08573692f, 
    -0.14188872f, 0.08237477f, -0.29123163f, -0.75501317f, -0.12490911f, 0.11432591f, 0.09907568f, 0.00910117f, 
    -0.11790519f, -0.17110558f, 0.14175488f, 0.08440588f, 0.17554918f, 0.14590363f, 0.02510041f, 0.09442150f, 
    0.25281212f, 0.16511229f, 0.19898950f, 0.11526370f, -0.03945167f, -0.48683977f, 0.18070079f, -0.08046503f, 
    -0.04037062f, -0.13440844f, 0.04641496f, 0.02059113f, -0.55680960f, -0.14867961f, -0.52715707f, 0.13875912f, 
    -0.29949230f, -0.26772848f, -0.10195667f, 0.22817710f, 0.24678582f, -0.03437556f, 0.26995578f, 0.06075398f, 
    0.05957928f, 0.03130387f, 0.03358309f, 0.23113313f, 0.21123467f, 0.23319839f, -0.64924568f, 0.14013383f, 
    0.62103993f, -0.16128054f, -0.04405003f, 0.03021707f, 0.04592817f, -0.03174997f, 0.15797091f, -0.35609829f, 
    -0.25657952f, -0.58801365f, 0.00500810f, -0.12760620f, 0.06515902f, 0.14233838f, 0.05792727f, -0.02345313f, 
    0.00847552f, -0.38486308f, -0.16059458f, -0.13683780f, -0.01560841f, 0.05024149f, 0.02815086f, 0.20205766f, 
    0.28332683f, -0.01120444f, -0.01084476f, 0.22235028f, -0.24996640f, -0.15887666f, 0.02723141f, -0.00569172f, 
    0.14463489f, 0.12235074f, 0.15108699f, -0.10984350f, -0.28401086f, 0.40166202f, -0.03391572f, 0.14949834f, 
    -0.09244587f, 0.37651634f, -0.24512312f, 0.76221132f, -0.20081867f, 0.06858571f, -0.04036643f, 0.05831585f, 
    0.20331392f, 0.05804802f, -0.06743182f, -0.12503386f, 0.31978464f, -0.45694694f, -0.77397281f, -0.07032831f, 
    0.24737841f, 0.10920100f, 0.01475443f, 0.04859133f, -0.03989395f, 0.43935975f, 0.08037867f, 0.07694057f, 
    -0.22365308f, -0.08813386f, 0.05477675f, 0.02216815f, 0.18080100f, 0.15078096f, 0.31301856f, 0.19423221f, 
    -0.52138782f, 0.10155205f, 0.08881611f, 0.12347839f, -0.11061712f, -0.06725200f, -0.18020856f, -0.31178451f, 
    -0.01620061f, 0.43300748f, 0.02900574f, -0.04256636f, -0.15832244f, -0.12782797f, -0.17606829f, 0.02736494f, 
    0.17501815f, 0.20938528f, 0.03754086f, 0.15741456f, 0.19732310f, 0.15715815f, -0.09195033f, 0.28601828f, 
    0.26933563f, -0.48686722f, -0.52109289f, 0.35248682f, -0.12472258f, -0.07423519f, 0.11238012f, 0.34348556f, 
    0.11656828f, 0.30460697f, 0.08892962f, -0.25731218f, 0.06456771f, 0.32739598f, 0.07214227f, 0.00102439f, 
    -0.03373789f, 0.26849517f, 0.29251379f, -0.97650963f, 0.02311869f, -0.41765183f, 0.06881271f, -0.02738171f, 
    -0.04701734f, -0.14353755f, -0.12789734f, 0.16248681f, 0.28257072f, -0.00642974f, -0.21844561f, 0.20732903f, 
    -0.18795030f, 0.10849282f, 0.29130179f, 0.08201479f, -0.01246873f, 0.13459131f, -0.04426381f, 0.12155242f, 
    0.10812014f, 0.08990006f, 0.16249561f, 0.17828719f, 0.34373218f, 0.45762986f, 0.12386377f, -0.19078660f, 
    -0.12353241f, 0.40675956f, -0.01519626f, -0.00607679f, 0.04282890f, 0.23566297f, 0.12338883f, -0.52502018f, 
    0.48041996f, 0.03794225f, -0.32340214f, 0.07729053f, 0.12946740f, 0.07862782f, -0.05460340f, -0.14991768f, 
    0.10859301f, 0.30163413f, -0.01360543f, -0.17088567f, -0.15635128f, -0.08044048f, 0.06189279f, 0.08390618f, 
    0.12574983f, -0.57939297f, -0.50913870f, -0.03703571f, 0.02777702f, 0.03763896f, -0.11173800f, 0.21043099f, 
    -0.07348582f, 0.41634023f, 0.30771390f, -0.13048556f, -0.40823257f, -0.04350673f, 0.05545280f, -0.00027844f, 
    -0.03199220f, -0.20953384f, -0.02161605f, 0.12614825f, -0.22737436f, 0.03091811f, 0.04791532f, 0.20114289f, 
    0.36257944f, 0.12007608f, 0.08530191f, 0.27894086f, 0.90750039f, -0.06788518f, -0.39530322f, 0.18004093f, 
    0.06199786f, 0.45329148f, 0.15031652f, 0.01413327f, -0.06689088f, -0.81838965f, -1.23167944f, -0.37208819f, 
    0.02954904f, 0.06982666f, -0.07883088f, 0.02670085f, -0.10204676f, -0.02457910f, -0.40658534f, 0.29751304f, 
    0.30444202f, -0.22136660f, -0.24979430f, -0.17207377f, -0.09299182f, -0.18475959f, 0.11268010f, -0.00840886f, 
    0.17630699f, 0.11191629f, -0.46379426f, -0.55646032f, -0.09736297f, 0.09724360f, 0.10310518f, 0.17744662f, 
    0.02025159f, 0.05925684f, -0.03833221f, -0.06478085f, 0.05219990f, 0.03988289f, -0.06407790f, -0.06590238f, 
    -0.07881315f, 0.01005264f, 0.05233104f, 0.06250204f, -0.01873946f, -0.00482000f, -0.03646690f, -0.00091267f, 
    -0.01908168f, -0.00069005f, 0.05880991f, 0.00484451f, -0.06935752f, 0.04968485f, -0.06959711f, -0.09127582f, 
    0.03442442f, 0.07528766f, -0.06701509f, -0.07110908f, -0.01810363f, -0.08678724f, -0.03349988f, 0.01291094f, 
    0.00293941f, -0.06586210f, -0.05653523f, -0.07843181f, 0.04528462f, 0.03519639f, 0.03277656f, 0.00865087f, 
    -0.00869970f, -0.03535924f, 0.00282028f, -0.03986295f, -0.01290495f, -0.05531247f, 0.00848977f, -0.01053917f, 
    -0.01633500f, 0.04571615f, -0.03344402f, -0.02034876f, -0.00619196f, 0.02568342f, 0.06048450f, 0.02688014f, 
    -0.06056667f, -0.07807892f, -0.02412241f, -0.01011202f, -0.07688211f, -0.04419522f, -0.03820330f, -0.02811374f, 
    0.04451457f, 0.05238230f, 0.04566775f, 0.04334171f, 0.00099575f, -0.08414737f, 0.03288134f, -0.04780587f, 
    -0.08240861f, 0.04864322f, 0.02859068f, -0.03066443f, -0.09319575f, -0.05994868f, 0.02483412f, -0.01612628f, 
    0.03642514f, -0.03671340f, -0.01380644f, 0.05494865f, -0.01863333f, -0.08196113f, -0.08250105f, 0.01275047f, 
    -0.04479913f, -0.03755858f, 0.01009957f, 0.04960687f, -0.09133108f, -0.03648869f, -0.08526267f, -0.03382308f, 
    -0.09304265f, -0.06761970f, -0.03675936f, 0.02579915f, -0.02750670f, 0.01635168f, 0.03328251f, -0.01966853f, 
    -0.01123499f, -0.06405804f, -0.01787135f, -0.03071963f, 0.06945799f, -0.07126499f, 0.03598459f, -0.08839270f, 
    0.01663390f, 0.01128510f, 0.04648940f, 0.00063150f, -0.09024698f, -0.02615219f, 0.03299927f, -0.07988203f, 
    -0.01681825f, -0.08440681f, -0.08311793f, 0.02853733f, -0.01944440f, 0.06596275f, -0.04944339f, 0.06368041f, 
    0.03391571f, 0.03077408f, -0.08421064f, -0.02794328f, 0.02510529f, 0.06577039f, 0.02872466f, 0.04003900f, 
    -0.06047132f, -0.07064803f, 0.03370624f, 0.03903918f, -0.09531393f, -0.03820347f, -0.08462877f, -0.01644346f, 
    -0.05813487f, 0.14003654f, 0.07168894f, -0.00039295f, -0.03674362f, 0.14667620f, 0.37324530f, -0.02113084f, 
    0.21078680f, 0.26567346f, 0.22107323f, 0.01664002f, 0.03315090f, 0.06405576f, 0.02555364f, 0.04457383f, 
    0.28776756f, 0.08098051f, 0.14003459f, 0.10167708f, 0.26590058f, -0.12273651f, 0.28084505f, 0.03744145f, 
    0.30729508f, 0.31272313f, 0.51617736f, -0.26089987f, -0.13494983f, 0.01267475f, -0.22216351f, 0.05565487f, 
    -0.12159090f, 0.02140683f, -0.04059502f, -0.12840043f, 0.06697685f, -0.20046367f, 0.04969348f, -0.12691963f, 
    0.12034962f, -0.21526597f, -0.01492931f, 0.12495176f, 0.03522447f, 0.05136716f, 0.07880828f, 0.37298116f, 
    0.18507078f, -0.16366012f, 0.31946748f, 0.49122745f, 0.12281371f, 0.11501712f, 0.09734035f, 0.01145196f, 
    0.02459580f, -0.12036601f, -0.00838652f, 0.23940146f, 0.35953215f, 0.05639457f, 0.22409134f, -0.87517929f, 
    -0.25679576f, 0.12493657f, -0.15445629f, -0.04201554f, -0.14285530f, -0.19096428f, -0.04804467f, -0.14750811f, 
    -0.31525621f, -0.07699202f, 0.12649330f, -0.17307757f, 0.08023767f, -0.18853496f, -0.13701749f, -0.18203303f, 
    -0.05306980f, -0.13243960f, -0.46978775f, -0.32894832f, -0.09159520f, 0.40510657f, 0.05304290f, 0.03008546f, 
    -0.12040021f, 0.16678789f, -0.17716709f, -0.12916924f, 0.14090540f, 0.11513713f, 0.01136915f, 0.08172160f, 
    0.00546407f, -0.07863618f, -0.24479860f, 0.05305165f, 0.31134290f, -0.05856183f, -0.17821240f, -0.04403043f, 
    0.19093977f, 0.59078491f, 0.52173960f, 0.35532442f, -0.13431422f, 0.04963319f, 0.27359509f, 0.23626712f, 
    0.17261545f, 0.01396653f, 0.12693858f, -0.01425168f, 0.35783970f, 0.10027887f, -0.15572231f, -0.43280330f, 
    0.03224665f, 0.11910893f, 0.13768248f, -0.14204456f, -0.06421089f, -0.47953376f, 0.19076568f, -0.00184825f, 
    0.03479113f, -0.09913447f, 0.20273367f, 0.01254727f, -0.10703244f, -0.08444538f, 0.11842235f, -0.12913039f, 
    -0.26149493f, -0.01238785f, -0.17388692f, -0.05209057f, 0.11882615f, 0.23692612f, 0.25407040f, 0.23999156f, 
    -0.06381176f, 0.02860090f, 0.03313202f, -0.06119839f, -0.09499675f, -0.02100533f, -0.02201283f, -0.08580702f, 
    -0.05067014f, 0.03149632f, -0.05163535f, 0.03829737f, 0.02819405f, -0.05173994f, 0.00054598f, 0.04697333f, 
    -0.08665681f, -0.03636994f, -0.06159756f, 0.03460023f, -0.06038453f, -0.07315741f, 0.03313869f, -0.06711899f, 
    -0.08632422f, -0.03422646f, -0.06386922f, 0.06071312f, 0.02541121f, -0.05706807f, -0.08677023f, -0.01780157f, 
    0.00036435f, 0.05023602f, 0.01817688f, 0.06441221f, -0.06549235f, -0.00424011f, -0.03656958f, 0.06712999f, 
    0.01153995f, -0.01980314f, -0.00470131f, -0.05753764f, 0.07333532f, -0.06970276f, 0.00286061f, -0.04583415f, 
    -0.02631022f, -0.00358874f, 0.00831616f, -0.02850768f, 0.06632197f, 0.06991138f, 0.03379641f, 0.03790636f, 
    0.03462644f, -0.02911985f, -0.09615082f, -0.06681155f, 0.06178208f, -0.06536770f, -0.01733775f, 0.07731067f, 
    -0.05094258f, -0.07827060f, -0.04213323f, 0.07336784f, 0.07117905f, -0.03528440f, -0.02098597f, -0.01471106f, 
    -0.05638507f, -0.06483801f, -0.02661408f, 0.01600551f, 0.01543990f, -0.05934312f, 0.02768370f, -0.08496362f, 
    -0.05288164f, 0.07973689f, 0.03242170f, 0.03389053f, -0.08621363f, 0.01054220f, 0.03400018f, 0.02199855f, 
    -0.06614486f, -0.09287015f, 0.05869433f, 0.04576292f, 0.01065078f, -0.04095253f, 0.04619789f, 0.03849148f, 
    -0.04938067f, 0.06776525f, -0.06179170f, 0.04969971f, 0.03289814f, 0.00858878f, 0.05863642f, 0.04053386f, 
    -0.08752223f, 0.04927919f, -0.06897427f, 0.03877150f, -0.08500644f, 0.01161995f, 0.06698331f, 0.03105213f, 
    0.01128236f, 0.03291024f, -0.06791521f, 0.00438999f, -0.05485011f, -0.07079743f, -0.05061260f, -0.06522715f, 
    -0.03287861f, 0.02036139f, -0.06093412f, -0.08754600f, 0.06674433f, -0.05196881f, -0.05552225f, 0.04342400f, 
    -0.07111041f, -0.05268784f, -0.01645539f, -0.09223073f, -0.05189260f, 0.04312765f, 0.00872073f, 0.01727504f, 
    0.06045409f, -0.06540588f, -0.08780387f, -0.09478410f, 0.02856353f, 0.01393138f, 0.02396072f, -0.08041366f, 
    0.32268700f, 0.30627814f, 0.44559947f, -0.14183934f, -0.18447433f, 0.16133998f, -0.23075704f, 0.03808530f, 
    -0.06511019f, -0.26470169f, -0.38110757f, -0.31379154f, -0.04641467f, 0.07647292f, -0.00849327f, -0.12440699f, 
    0.01093488f, 0.41288811f, 0.19954504f, 0.35933772f, 0.27287841f, 0.15126148f, 0.08362891f, 0.12374694f, 
    0.31693128f, 0.51108056f, 0.04552745f, 0.21114062f, 0.16365853f, -0.52921444f, -0.22166583f, 0.12906413f, 
    -0.11328983f, 0.11607127f, 0.03539092f, -0.08101825f, -0.01447950f, 0.48235425f, -0.39937308f, 0.18774250f, 
    -0.00789983f, -0.02869338f, 0.17254165f, 0.02563206f, -0.17506951f, 0.46835473f, 0.79735208f, -0.22182600f, 
    0.12134706f, 0.09582660f, 0.06356682f, 0.31675550f, 0.10137166f, 0.02967862f, 0.52552140f, 0.29803759f, 
    0.44662616f, 0.00412744f, -0.18013798f, -0.12448595f, -0.00322875f, 0.16126053f, -0.07528518f, -0.77420396f, 
    0.28995982f, 0.22273655f, 0.06355996f, 0.10268307f, -0.21329030f, -0.07925018f, 0.08937161f, -0.29770732f, 
    -0.32785127f, -0.30936813f, -0.36314949f, -0.13205509f, 0.06599143f, -0.14916198f, 0.10867795f, 0.04303854f, 
    -0.07243658f, -0.19027820f, 0.06665834f, -0.10390846f, -0.27891710f, 0.00387610f, 0.18451734f, 0.03963093f, 
    -0.00717592f, 0.14267160f, 0.67416197f, -0.03513508f, -0.21782354f, -0.17331758f, -0.04025649f, 0.12640797f, 
    -0.16821624f, 0.00063968f, -0.19802068f, -0.37189230f, 0.54983878f, -0.41709372f, -0.00145266f, -0.09149758f, 
    0.16987403f, 0.11685292f, 0.08137929f, 0.08210925f, -0.71261251f, -0.59717411f, -1.26858425f, 0.19735134f, 
    -0.19404048f, 0.26239592f, 0.31880978f, -0.04665724f, -0.15758000f, -0.59153861f, -0.14973153f, 0.13571200f, 
    -0.01894963f, 0.02331173f, -0.21992707f, -0.11863060f, -0.02508912f, -0.05790154f, -0.28288665f, 0.38059923f, 
    -0.64668989f, -0.38854021f, -0.33943927f, -0.11204229f, 0.03495147f, 0.08274081f, -0.14712407f, 0.40053600f, 
    -0.30181858f, 0.03271972f, 0.02487723f, -0.06366462f, -0.09578551f, -0.06201579f, -0.04156594f, 0.20407476f, 
    0.09011786f, -0.14822401f, 0.05562651f, 0.16406702f, -0.00454226f, -0.15004361f, 0.18733673f, -0.01902344f, 
    -0.11480018f, 0.19795930f, 0.07675544f, 0.24696387f, 0.04082072f, -0.03777811f, 0.09983514f, 0.38641670f, 
    -0.01399358f, -0.15091088f, -0.39155746f, -0.07475387f, -0.05456168f, 0.29876155f, -0.08508994f, -0.12364839f, 
    0.05751184f, 0.14567614f, 0.07144455f, 0.17564748f, 0.16848600f, 0.39199728f, -0.16428775f, 0.01973966f, 
    0.34083164f, 0.09763178f, -0.09090742f, 0.14056587f, -0.23498517f, 0.19804052f, -0.30063590f, 0.01503832f, 
    -0.21594307f, -0.12601960f, -0.10212006f, 0.23199423f, 0.03355534f, -0.35418674f, -0.08593980f, 0.37037864f, 
    0.25360736f, -0.13340007f, 0.10197233f, 0.10234419f, 0.12767500f, 0.32841355f, 0.00329307f, -0.56152821f, 
    -0.02382478f, 0.01881878f, -0.05460883f, -0.13985017f, -0.05674955f, 0.08364992f, 0.03552402f, -0.08360504f, 
    0.10068011f, 0.17495023f, 0.13346943f, -0.11598289f, 0.30695605f, -0.18917672f, 0.19513592f, 0.18325385f, 
    -0.52161491f, -0.51228362f, -0.58358753f, 0.04777308f, 0.12709065f, 0.20851825f, 0.00339890f, 0.10168612f, 
    0.15977836f, -0.14318754f, 0.10129312f, -0.40319926f, -0.00052723f, -0.22763607f, -0.33617216f, -0.10188914f, 
    0.07831261f, 0.07924077f, -0.09098420f, -0.08995668f, -0.46142358f, -0.19699045f, 0.07392783f, 0.13790840f, 
    0.06282596f, 0.17490417f, 0.16042843f, -1.71003330f, -0.18825766f, 0.39171037f, 0.07395537f, -0.13280596f, 
    -0.21560916f, 0.11438870f, 0.13118675f, -0.08317613f, -0.37777340f, -0.00210349f, -0.23415299f, -0.10910568f, 
    -0.10596251f, 0.09462786f, -0.07229625f, 0.11989107f, -0.02894711f, -0.19044372f, -0.04945514f, -0.07654138f, 
    -0.34931326f, -0.12377379f, -0.17122746f, -0.23782730f, 0.11863486f, 0.09007991f, 0.61712533f, 0.33081838f, 
    0.45626095f, 0.19692603f, 0.01984719f, 0.16701454f, 0.10358567f, -0.05932358f, -0.15241086f, 1.07978630f, 
    -0.45926648f, -0.49495199f, 0.05114850f, -0.08308123f, 0.04153214f, 0.03855520f, 0.18040569f, -0.16884841f, 
    -0.00382618f, -0.32012403f, -1.03059578f, -0.08027446f, -0.14166120f, -0.26092383f, -0.01134126f, -0.02049063f, 
    0.03504678f, 0.36996812f, -0.03370085f, -0.35172147f, 0.26315305f, -0.07908406f, 0.18657655f, -0.08347695f, 
    0.20686714f, 0.10237414f, -0.24808301f, -0.06957179f, -0.05645056f, -0.29458341f, -0.02029090f, 0.04565809f, 
    0.21897927f, -0.21466383f, 0.25192431f, 0.47235346f, 0.18515101f, 0.08494844f, 0.32003802f, -0.00705602f, 
    -0.22305185f, 0.06785160f, 0.22898091f, -0.11164116f, 0.23100561f, 0.37219343f, -0.29204467f, 0.02084092f, 
    -0.19781722f, 0.17301093f, 0.33806342f, 0.11919606f, 0.15577310f, -0.01833436f, -0.37880594f, -0.03386439f, 
    0.26555666f, -0.03704007f, -0.13902210f, 0.18670405f, -0.16599219f, -0.04743624f, 0.18224312f, -0.16980560f, 
    -0.48339245f, 0.30306366f, -0.19837864f, -0.38688284f, -0.14495444f, -0.19138221f, 0.06368939f, 0.33271801f, 
    0.79613650f, 0.30348548f, 0.36179748f, -0.15482388f, 0.00936762f, -0.04750770f, -0.08024475f, 0.28185070f, 
    0.03373827f, -0.46141917f, -0.51456618f, 0.24279881f, -0.12125368f, 0.28282234f, -0.11530634f, -0.19176942f, 
    0.17398070f, -0.00730259f, 0.37541196f, 0.40927956f, -0.31212705f, 0.02026192f, 0.12732734f, -0.10079838f, 
    -0.07424372f, 0.01246525f, 0.09876075f, -0.07118835f, -0.49055737f, 0.00063386f, -0.06058142f, 0.15840609f, 
    -0.14118275f, -0.04025056f, -0.25066698f, 0.02786539f, -0.54993671f, 0.06445004f, 0.09292296f, 0.26225626f, 
    -0.29760414f, -0.10124311f, -0.07656810f, 0.21073885f, 0.11863563f, 0.27749634f, -0.49816096f, -0.16175653f, 
    -0.21569529f, 0.28402805f, 0.04956627f, -0.14349882f, -0.22431894f, 0.35200858f, 0.41594249f, 0.40566817f, 
    -0.14261346f, 0.04910255f, -0.21363209f, 0.01558437f, -0.05385201f, -0.17408070f, 0.53885531f, 0.08411839f, 
    0.30598000f, 0.13656686f, -0.11850383f, 0.20754355f, 0.06180292f, 0.03965913f, -0.03045627f, -0.19735177f, 
    0.75481617f, -0.45485196f, -0.10384299f, -0.15071444f, 0.04310894f, -0.00393032f, 0.09110744f, 0.11545299f, 
    0.02671302f, 0.05313452f, 0.23965307f, 0.08333771f, -0.09766874f, 0.41079554f, -0.34737772f, -0.14176381f, 
    0.05837765f, -0.26404446f, 0.05564409f, -0.19315162f, 0.03255699f, -0.16491619f, -0.15447968f, -0.43679693f, 
    -0.62607431f, -0.79510897f, 0.28486094f, 0.08822380f, 0.15989134f, 0.00001006f, -0.19784075f, 0.13852213f, 
    -0.38025638f, 0.10844926f, -0.10307854f, -0.01653508f, 0.24684395f, 0.29556763f, -0.11144473f, -0.05112958f, 
    -0.06968007f, 0.17794988f, -0.10154770f, 0.14411528f, 0.09507964f, 0.18230432f, -0.13351297f, -0.77251065f, 
    -0.03039349f, 0.21032666f, -0.04702907f, 0.44856018f, 0.09042293f, 0.19596298f, 0.26063496f, 0.10006113f, 
    -0.12694491f, 0.31762403f, -0.22218722f, 0.21433809f, -0.06025405f, 0.09732925f, 0.11674676f, 0.02079152f, 
    0.29220346f, -0.06820223f, -0.10050697f, 0.35909590f, -0.13085210f, -0.02584404f, 0.12443027f, -0.16783100f, 
    -0.02577206f, -0.29956463f, -0.09807266f, -0.42242888f, -0.13941652f, 0.29066268f, 0.42288157f, 0.02991710f, 
    -0.07140039f, -0.09291711f, -0.06464483f, 0.37392369f, 0.11319302f, 0.15086713f, 0.11785430f, 0.22163673f, 
    -0.01658855f, 0.10270645f, 0.08118116f, -0.43113363f, 0.20766364f, 0.10067592f, 0.31536123f, 0.05395454f, 
    -0.03838423f, -0.59717524f, 0.05099070f, -0.10987008f, 0.24760571f, 0.29703125f, 0.26106188f, 0.00411222f, 
    0.01705435f, 0.58019525f, 0.34741771f, -0.29287463f, -0.27828309f, 0.43062109f, 0.38970605f, 0.09414505f, 
    -0.00431515f, 0.11968464f, -0.25619376f, -0.19406557f, -0.14682241f, 0.22411694f, 0.52264798f, 0.11491063f, 
    0.13960801f, -0.32756633f, 0.27233011f, 0.02716903f, -0.08402925f, 0.00578280f, 0.01917058f, -0.05209700f, 
    0.14700201f, -0.00837803f, 0.15187715f, 0.16300362f, 0.47183925f, 0.23341408f, -0.46929866f, 0.07014716f, 
    0.04755074f, -0.17359462f, -0.18172424f, -0.15051113f, 0.10423307f, -0.12543951f, 0.04695290f, -0.06602549f, 
    -0.16113338f, -0.13245295f, 0.22745259f, 0.29765487f, -0.17075834f, -0.01381371f, -0.41763437f, -0.21083258f, 
    0.05304468f, -0.08179434f, -0.07160752f, -0.02363770f, 0.04681246f, 0.06652073f, -0.03635082f, -0.03984204f, 
    -0.00625574f, -0.04950241f, 0.03578894f, -0.05045887f, -0.04447412f, 0.04078845f, -0.03151215f, -0.05271807f, 
    0.06784575f, 0.00710444f, 0.00327929f, 0.06922054f, -0.03890661f, -0.08897062f, -0.07536032f, -0.06400304f, 
    0.07031515f, 0.04714840f, 0.02610592f, 0.01026000f, 0.04765484f, -0.01862830f, 0.00020942f, -0.08386195f, 
    -0.02918014f, -0.01827450f, -0.04806494f, -0.03460607f, -0.04901835f, 0.04063765f, -0.06927452f, -0.03347420f, 
    0.02515247f, -0.00640288f, -0.07684039f, -0.08624512f, 0.05401346f, -0.00646945f, -0.05405919f, 0.05718578f, 
    -0.07135606f, 0.01347150f, -0.01987047f, -0.08320050f, -0.01743258f, -0.03045530f, 0.04718054f, -0.01903350f, 
    -0.03386849f, -0.09170748f, -0.03341876f, 0.01280641f, 0.03535683f, -0.08093509f, -0.06022044f, 0.04402858f, 
    0.01887738f, 0.00425823f, -0.03207570f, -0.01373901f, -0.08277959f, -0.08818409f, 0.05977701f, 0.01211787f, 
    0.06189983f, -0.07929052f, -0.07010994f, -0.08500904f, -0.08976479f, 0.03572524f, -0.00508057f, -0.02979622f, 
    0.02787121f, -0.07949029f, -0.08233076f, -0.01793274f, -0.08910871f, -0.07578360f, 0.03131928f, -0.05740282f, 
    0.04488205f, 0.01069696f, -0.02995202f, 0.04916339f, 0.06408200f, -0.04005678f, -0.05437668f, -0.03113553f, 
    0.01607687f, -0.04534142f, -0.01131979f, -0.03607313f, -0.07423261f, 0.05109116f, -0.07892029f, -0.00271535f, 
    -0.07670484f, -0.07120703f, -0.00480670f, -0.08797841f, -0.07220485f, 0.06078071f, 0.05718576f, 0.04479339f, 
    0.01761885f, -0.01220107f, -0.04933693f, -0.04763220f, 0.04284491f, -0.08909518f, 0.01846544f, 0.07114314f, 
    0.06953228f, -0.05871797f, 0.06601442f, 0.05991615f, -0.05137911f, 0.00268045f, -0.06256489f, 0.02320730f, 
    -0.03168628f, -0.07644697f, 0.04962029f, 0.03443023f, -0.02764942f, -0.00836399f, -0.00430466f, 0.04645770f, 
    0.03367542f, 0.00879516f, -0.07694931f, -0.08376002f, -0.05690956f, -0.03101508f, 0.06492697f, -0.00060414f, 
    0.19269302f, -0.17835926f, 0.12490685f, -0.01286922f, -0.43939212f, -0.03116601f, 0.14308168f, -0.04927816f, 
    0.24353878f, -0.73429829f, 0.57008088f, 0.08531389f, 0.10159347f, 0.17163111f, -0.01089610f, 0.16314694f, 
    0.09561531f, 0.02317185f, 0.09716278f, -0.05438399f, -0.15124403f, 0.40776429f, -0.10385101f, 0.15583599f, 
    0.16294280f, 0.19449289f, 0.47046614f, -0.12094437f, 0.16111323f, 0.34241524f, 0.00107654f, -0.15603995f, 
    -0.18234354f, 0.00330552f, 0.09273825f, 0.00807221f, -0.34762672f, -0.36706015f, -0.01552303f, -0.27205431f, 
    -0.45264354f, 0.09716882f, -0.15025997f, -0.00725704f, 0.20855390f, 0.15877923f, 0.54088157f, -0.39772245f, 
    0.29826805f, 0.00141861f, 0.13890634f, 0.07976805f, 0.50598061f, -0.02420326f, -0.15881063f, -0.18468899f, 
    0.31198052f, 0.00348561f, -0.23606841f, -0.17765883f, 0.13503100f, 0.00045933f, 0.14749293f, -0.31907040f, 
    -0.28903314f, 0.11757310f, -0.11902920f, -0.24445891f, -0.05305945f, -0.05549486f, 0.05700974f, -0.00779086f, 
    -0.06066684f, -0.17026635f, 0.41111290f, 0.02415245f, 0.28890061f, -0.04228966f, 0.15785027f, -0.05917125f, 
    0.22779453f, -0.17856738f, 0.05652652f, 0.34717920f, -0.18437196f, -0.06538925f, 0.07253255f, 0.06350283f, 
    -0.05037388f, -0.07384002f, 0.09872286f, -0.58226609f, -0.37747681f, -0.02667968f, 0.10285155f, 0.10397733f, 
    0.00892955f, -0.13544327f, 0.05338096f, -0.21734160f, 0.38344947f, -0.39601788f, 0.06500527f, -0.15099199f, 
    -0.27682719f, 0.04755090f, -0.02314415f, 0.06777867f, -0.02608785f, 0.12239786f, -0.44512403f, -0.20124774f, 
    -0.06347174f, 0.31532043f, 0.08235787f, 0.01760427f, 0.04692110f, -0.00367780f, -0.03988289f, 0.27120861f, 
    -0.00635743f, -0.18769981f, -0.21458732f, 0.01154072f, -0.15573411f, -0.02001043f, -0.80161470f, 0.34964338f, 
    0.12221010f, -0.03759427f, -0.03422854f, 0.02427520f, -0.12044130f, 0.17646176f, 0.06775452f, 0.05642371f, 
    -0.71711648f, -0.15342826f, -0.13898325f, -0.20294829f, -0.27688307f, 0.17890656f, -0.05386418f, 0.07303821f, 
    -0.15492743f, 0.03324185f, 0.46059680f, -0.20047428f, -0.24913353f, -0.08606841f, -0.08543125f, 0.13552141f, 
    -0.12221638f, 0.68753201f, -0.22653703f, -0.35781834f, 0.02166613f, 0.18512306f, -0.17910935f, 0.03145813f, 
    -0.07615616f, -0.02873654f, 0.14501913f, 0.08049008f, 0.28713176f, -0.47463608f, 0.20600633f, -0.44160229f, 
    -0.06851261f, 0.07559700f, -0.20180720f, 0.44041184f, 0.36288086f, 0.22929353f, -0.10241511f, 0.20286149f, 
    -0.14848168f, 0.06380361f, 0.12163226f, -0.12380930f, -0.55058634f, 0.17061877f, 0.97779405f, -0.16554181f, 
    0.21467541f, -0.05890748f, -0.14810066f, 0.21809791f, 0.45169860f, -0.16981959f, 0.58925211f, -0.09235070f, 
    0.06802464f, -0.08624545f, 0.26992294f, -0.17616211f, 0.16018419f, -0.07321677f, -0.11046167f, 0.25357148f, 
    0.24541815f, -0.11125892f, -0.21518408f, -0.27908686f, -0.12333961f, 0.23215215f, 0.12797333f, 0.47951004f, 
    -0.29542488f, 0.27600574f, 0.12400494f, 0.37468332f, -0.09654004f, -0.06374178f, 0.05021675f, 0.08082425f, 
    0.30069810f, 0.23327053f, -0.65583885f, 0.18599004f, -0.06432657f, -0.09834158f, 0.07485335f, -0.06888148f, 
    0.13037370f, -0.60687017f, -0.34022698f, 0.41959581f, -0.39462829f, -0.04144748f, -0.28544256f, 0.00072716f, 
    0.05653701f, -0.04804658f, -0.25404298f, -0.22405493f, -0.01703892f, -0.03486398f, 0.16671608f, 0.29132333f, 
    -0.21243295f, 0.01671185f, 0.00324785f, 0.21201368f, 0.94321924f, -0.44275674f, 0.23310404f, -0.29419401f, 
    -0.02701323f, -0.11924315f, -0.11068878f, -0.03540882f, 0.46912330f, -0.08804125f, -0.77728796f, -0.10761644f, 
    0.38991147f, 0.34050345f, 0.18087980f, -0.09654239f, -0.20545124f, -0.63321489f, -0.38839945f, 0.26346689f, 
    -0.44955158f, -0.02648606f, -0.13899331f, 0.21175723f, 0.10403559f, 0.17040615f, 0.52421361f, -0.05571213f, 
    0.01850227f, -0.09377602f, -0.02990597f, -0.02592229f, -0.01784479f, -0.03545631f, -0.05183285f, 0.03299895f, 
    -0.14817004f, 0.04458641f, -0.07869588f, -0.07451799f, 0.12347282f, -0.05340441f, -0.09029968f, 0.02701779f, 
    -0.07539926f, -0.12837730f, -0.23433612f, 0.12865795f, -0.24065980f, 0.00621524f, 0.12586713f, 0.18035598f, 
    0.03209473f, -0.42016652f, 0.07954419f, 0.35651937f, 0.08135645f, 0.11126122f, 0.01396245f, 0.09520263f, 
    0.02362867f, 0.27981311f, -0.15154000f, 0.02553968f, -0.15622775f, 0.16004717f, 0.20094663f, -0.41122597f, 
    0.33320805f, 0.06465511f, 0.03269677f, -0.23300689f, -0.31112722f, 0.23169403f, 0.23212884f, -0.08500329f, 
    -0.21732935f, -0.06971236f, 0.03230917f, 0.01014750f, 0.04154918f, -0.04521670f, 0.09573132f, 0.05019360f, 
    -0.08141761f, -0.48818827f, 0.11804009f, 0.19015542f, 0.06256651f, 0.37801114f, -0.17442836f, 0.04232785f, 
    -0.08422626f, 0.09886086f, -0.16724278f, 0.07208369f, 0.18022726f, -0.01433731f, 0.06929008f, -0.01638080f, 
    -0.21841459f, 0.17765898f, -0.06428238f, -0.25562191f, -0.16841987f, 0.03621801f, 0.02418373f, -0.19045213f, 
    -0.13351852f, -0.29155529f, 0.04980627f, -0.18831515f, -0.19506790f, 0.03147082f, 0.12613247f, 0.00864467f, 
    0.20224202f, 0.14722423f, 0.07781119f, -0.07626010f, 0.06344476f, -0.12971845f, -0.11579929f, 0.10113554f, 
    0.24849227f, 0.18459806f, 0.15331526f, 1.02294683f, 0.03363764f, -0.10986476f, -0.16458920f, 0.13670620f, 
    0.16795132f, 0.21109383f, 0.06544703f, -0.06567062f, -0.04681291f, 0.08308575f, 0.02678636f, -0.14676195f, 
    0.34229451f, 0.02593490f, -0.18981040f, 0.88726974f, 0.04674837f, -0.39238399f, 0.10428458f, 0.08878315f, 
    -0.02443477f, -0.08837850f, -0.18635859f, -0.11971393f, 0.29601929f, -0.32251996f, -0.22448820f, 0.13409205f, 
    0.14271098f, -0.20575078f, -0.00051854f, -0.05202442f, -0.14248565f, 0.03429303f, -0.30970073f, 0.41468173f, 
    -0.04866710f, -0.12171533f, -0.17700645f, -0.10357737f, -0.21670909f, -0.02876326f, -0.58116406f, -0.03635512f, 
    0.14466985f, 0.08811830f, 0.01677967f, 0.08437841f, -0.07407900f, 0.02696487f, 0.20264891f, -0.44070160f, 
    0.30083340f, 0.12882027f, -0.10318767f, 0.06094896f, 0.12696727f, 0.18343006f, 0.26773009f, 0.44646302f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01238500f, 0.26775134f, -0.03660795f, 0.07224092f, 0.44784498f, -0.02499360f, 0.47262248f, -0.00243008f, 
    0.24693041f, 0.06636246f, -0.24594690f, 0.03276099f, 0.05681466f, 0.44971615f, -0.20200089f, 0.05530437f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08619912f, 0.32849088f, 0.23379557f, 0.59608930f, -0.07445491f, 0.23280016f, -0.20310119f, -0.12535389f, 
    -0.62215459f, 0.65794104f, 0.53655332f, 0.03382330f, 0.09662011f, -1.21578956f, -0.10749746f, -1.02757180f, 
    -0.12956126f, 0.07063307f, -0.41836542f, -0.11104019f, -0.17747648f, -0.21730076f, 0.04062323f, -0.09014933f, 
    0.55958074f, 1.15305293f, -0.05685754f, 0.38316795f, 0.16670872f, 0.12410311f, -0.21677552f, -0.69103485f, 
    0.00233720f, -0.40359211f, -1.09384525f, -1.03063035f, 0.40334833f, -0.04700349f, 0.43176496f, -0.22096503f, 
    -1.80292749f, -0.68125468f, -0.64790857f, -0.07433456f, 0.04434168f, 0.92362946f, -0.68734676f, 0.22232346f, 
    -0.09905139f, 0.35661191f, -0.18891877f, 0.81261683f, -0.83733499f, -0.11418407f, 0.05635965f, 0.15486631f, 
    -0.76825929f, -0.50188518f, 0.27836594f, -0.26663694f, 0.11476961f, -0.06768442f, 0.22247869f, 0.38089481f, 
    -0.21002652f, 0.49377179f, 0.66052473f, -0.65478677f, -0.31447065f, 0.06154865f, -0.02354183f, 0.08546582f, 
    -0.30393502f, -0.29150951f, 0.10018569f, 0.06570353f, 0.04027910f, -0.01508916f, -0.19432192f, -0.01451413f, 
    0.00028953f, -0.02489962f, -0.31856152f, 0.36625269f, -0.26504347f, -0.12052783f, -0.24238396f, -0.05510542f, 
    -0.01305743f, 0.05615256f, 0.12019358f, 0.51851839f, 0.00349354f, 0.81471407f, -0.27304259f, 0.11650251f, 
    0.01043942f, -0.46360111f, -1.39892840f, -1.09213376f, 0.68956017f, 0.12098768f, 0.33922255f, 0.13515744f, 
    0.01329367f, 0.27775955f, -0.93661845f, -0.40410730f, -0.20060080f, -1.09910631f, -0.48299792f, 0.18762441f, 
    0.12219742f, -0.35469145f, -0.24121939f, 0.23491120f, 0.38067555f, -0.08513065f, -0.76834214f, -0.07513095f, 
    0.37794989f, -0.01981584f, -0.08954932f, -0.27663809f, -0.01737109f, -0.65603274f, 1.04253268f, 0.34794679f, 
    -0.02454735f, -0.55084372f, -0.37961909f, 1.34413910f, -0.13972446f, 0.17176388f, -0.31007850f, 0.19962367f, 
    0.09659696f, -0.68428570f, -0.61357230f, 0.70534450f, -0.22911300f, -0.82625806f, -0.39725271f, 0.40132308f, 
    0.22146843f, 0.68132234f, -0.07732131f, -0.55812001f, -0.20816256f, -0.05148888f, 0.45000666f, 0.20033115f, 
    -0.52271736f, -0.39329597f, -0.26824817f, -0.52264071f, -0.20665464f, -0.27312380f, -0.66929370f, 0.45226315f, 
    -0.18004403f, -0.52574730f, 0.43742198f, -0.50473273f, -0.17647263f, -0.14903975f, 0.25428095f, -0.23377867f, 
    -1.00013816f, -0.22162686f, -1.17761588f, 0.41389978f, 0.23111379f, -0.25123703f, 0.98418498f, -0.12134348f, 
    -0.06608055f, -0.27571523f, -0.95183909f, -0.68951851f, -0.57715893f, -0.13916101f, 0.27484244f, -0.22974788f, 
    0.85905629f, -0.33328733f, -0.40882647f, 0.04403271f, -0.15443118f, 0.74656475f, 0.50781453f, 0.19310494f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19169892f, 0.13278712f, 0.31173927f, -0.23863345f, 0.02798964f, -0.30869487f, -0.15796430f, -0.34747013f, 
    -0.15474500f, 0.71863049f, -0.15344833f, -0.01635685f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
