#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.86316782f, -0.50383651f, 0.41389912f, 0.00917589f, -0.04483438f, 0.53532302f, 0.07771125f, -0.51916897f, 
    0.16059791f, 0.64318132f, -0.17395614f, 0.33032897f, -0.16093220f, -0.11094005f, -0.14085469f, -0.17890537f, 
    0.03663353f, -0.23855495f, 0.20523369f, -0.05663652f, -0.00372213f, -0.06137111f, 0.13499537f, 0.09770484f, 
    0.21362069f, 0.57876098f, 0.38340804f, 0.17493533f, 0.24794707f, 0.29778248f, 0.24436945f, 0.43737295f, 
    0.09732541f, 0.13719304f, 0.11627551f, -0.16695103f, -0.01925302f, 0.04726266f, -0.08700541f, -0.05009064f, 
    0.13863778f, -0.14660329f, -0.20275387f, 0.09778185f, 0.01280845f, -0.10095087f, 0.14981362f, 0.12155129f, 
    -0.08266012f, -0.06826361f, 0.08950819f, -0.26035103f, -0.34824204f, -0.03752335f, -0.16026011f, -0.60388094f, 
    -0.01526289f, 0.42035523f, -0.14843930f, -0.14007588f, -0.25421301f, -0.10312215f, 0.15947910f, -0.08991593f, 
    -0.30584773f, -0.14550442f, 0.24755971f, 0.13176247f, -0.02074744f, 0.07654709f, 0.14688329f, -0.03019585f, 
    0.10275741f, 0.25563940f, 0.12304181f, 0.01790578f, 0.37496483f, 0.26760891f, -0.40761682f, 0.09421293f, 
    0.26623437f, 0.29076457f, -0.14620608f, -0.37128979f, -0.19865097f, -0.41032645f, -0.28211054f, -0.02250834f, 
    0.32590821f, 0.01637216f, 0.07924401f, -0.11620764f, -0.31625205f, -0.16952740f, -0.29734382f, 0.08239742f, 
    0.21333031f, 0.23929869f, 0.25492722f, 0.12615289f, -0.62669361f, -0.40605211f, -0.25364465f, -0.38694635f, 
    -0.25107008f, 0.08897917f, 0.02242941f, -0.50288665f, -0.24435914f, -0.35673693f, -0.27019653f, 0.03261432f, 
    -0.15862730f, -0.22463511f, -0.32938331f, 0.20131041f, 0.09405960f, -0.19904590f, 0.02210320f, 0.04470284f, 
    0.14084473f, 0.13880333f, 0.32405046f, 0.13904682f, 0.29573640f, -0.23818739f, -0.21441153f, 0.10049539f, 
    0.51489377f, -0.44817728f, 0.51038176f, -0.40495080f, -0.02800267f, -0.00406296f, -0.08655422f, 0.21272171f, 
    0.15652835f, 0.24052453f, 0.20447634f, -0.46863741f, -0.19143620f, -0.35983762f, -0.25321078f, 0.09985190f, 
    -0.05568962f, -0.22231184f, -0.33881348f, -0.02758218f, 0.02770095f, -0.38647625f, 0.53207684f, 0.96349823f, 
    0.47944322f, -0.51220828f, -0.48893374f, -0.49800497f, -0.09374309f, -0.16062833f, -0.38274679f, 0.31045604f, 
    -0.03223426f, 0.12503670f, 0.01585712f, -0.15615515f, -0.00797172f, -0.11715518f, 0.05159526f, 0.16538693f, 
    0.28837228f, -0.23819979f, 0.25844049f, -0.19516648f, 0.05628917f, -0.23154490f, -0.19077210f, -0.70525050f, 
    -0.44567287f, -0.42176709f, -0.29351270f, -0.33817396f, -0.04711408f, 0.16638565f, 0.29958618f, 0.42160147f, 
    0.54265976f, 0.37557814f, 0.12790225f, 0.13360418f, -0.16962649f, -0.00505773f, -0.03530817f, -0.13925584f, 
    -0.33449069f, -0.24332000f, -0.40773976f, -0.01595848f, -0.00607796f, 0.35190293f, 0.11830888f, 0.41718620f, 
    -0.95885980f, -0.68126118f, 0.19149162f, 0.62210077f, 0.68652195f, 0.65022713f, 0.53833252f, -0.26934499f, 
    -0.43297732f, 0.41102204f, 0.29837835f, -0.21489084f, -0.45821518f, -0.26881498f, -0.56475830f, 0.12386177f, 
    -0.00760916f, -0.15546718f, -0.17611842f, 0.13306805f, -0.06541026f, -0.30625117f, 0.13505650f, 0.03443667f, 
    -0.09430987f, 0.17150602f, 0.33666512f, 0.39558271f, 0.22666089f, -0.04440131f, -0.63108945f, -0.37142047f, 
    0.00747542f, -0.30803454f, -0.25097796f, 0.01020127f, -0.23046266f, -0.07196207f, 0.47154564f, 0.09904844f, 
    0.10527574f, 0.08822091f, 0.10442473f, 0.13705271f, -0.29189831f, -0.16563681f, -0.01729472f, 0.03935927f, 
    0.18558487f, 0.06910861f, -0.42174783f, -0.19220124f, -0.41029677f, -0.19417833f, -0.42078984f, -0.63073725f, 
    -0.52993578f, -0.34542000f, -0.51670164f, -0.78460723f, 0.17405497f, 0.38148320f, -0.13929553f, 0.01012951f, 
    0.29701611f, 0.19128366f, -0.03797230f, -0.07951535f, 0.04108883f, -0.03027322f, 0.08798460f, 0.24769381f, 
    -0.05907892f, 0.06719683f, 0.18041942f, -0.74050474f, -0.39766452f, -0.31478179f, 0.25180736f, 0.70636719f, 
    0.23059206f, 0.02106856f, -0.01492386f, -0.23667553f, -0.08694642f, -0.21122226f, -0.39432555f, 0.14440908f, 
    -0.00274364f, 0.10002919f, 0.03028669f, -0.24465416f, 0.21708335f, -0.32995969f, -0.45052871f, -0.12458448f, 
    0.07147163f, -0.18165624f, -0.44738972f, -0.41577578f, -0.36547562f, -0.14672835f, -0.15669207f, -0.66246605f, 
    -0.45759434f, 0.04070485f, 0.12327800f, -0.30479860f, -0.73762101f, -0.31564400f, -0.31402504f, -0.31367484f, 
    -0.31773543f, -0.04581458f, 0.12197927f, -0.16025056f, -0.52523005f, -0.25092345f, -0.30958596f, -0.53336406f, 
    -0.08743580f, 0.25748634f, -0.20670332f, 0.05818902f, -0.06868747f, -0.21012437f, 0.43913129f, -0.34231099f, 
    -0.39951438f, 0.46377298f, -0.10247513f, 0.24008630f, 0.47285858f, -0.26812187f, -0.49067530f, -0.05015187f, 
    -0.17264225f, 0.22351463f, 0.17191398f, 0.09625217f, -0.08280817f, -0.09549014f, -0.20229688f, -0.01570362f, 
    -0.03312924f, 0.06382004f, 0.23031451f, -0.20948288f, 0.11597500f, 0.06662182f, -0.45772755f, -0.43118569f, 
    -0.08250614f, 0.73818254f, 0.46328375f, 0.09601016f, 0.23668306f, -0.30932546f, -0.12722708f, -0.39604011f, 
    -0.15129530f, 0.10492596f, -0.05204603f, 0.36861876f, 0.33857971f, 0.11405192f, -0.34833670f, -0.24702133f, 
    0.35560367f, 0.13516173f, -0.12521456f, -0.24385384f, 0.18165545f, 0.21724834f, -0.36835989f, -0.78607827f, 
    0.45150790f, 0.81905603f, -0.27357262f, -0.61121130f, -0.82450032f, -0.21363941f, -0.34375489f, -0.18273564f, 
    0.18203869f, 0.64390016f, 0.21079749f, 0.09238315f, 0.17600641f, -0.06227854f, 0.04862291f, -0.41592163f, 
    0.13795412f, -0.51493698f, -0.12432575f, 0.20748737f, 0.17605585f, -0.15526216f, 0.03942557f, 0.13940850f, 
    0.34186113f, 0.12038797f, 0.01317116f, 0.05198308f, -0.02926309f, 0.23512203f, 0.02444572f, 0.02522548f, 
    0.03119735f, -0.15373439f, 0.02929989f, 0.31777272f, -0.25050616f, -0.36527371f, 0.34391257f, -0.12566963f, 
    0.28058264f, -0.19552884f, -0.21420662f, -0.31202969f, 0.33645770f, 0.29270443f, -0.19428708f, -0.38831645f, 
    0.02205462f, -0.02083071f, -0.84344494f, -0.48927930f, 0.79252201f, 0.23957834f, 0.30839401f, -0.48141095f, 
    -0.78116995f, -0.60227269f, -0.00402594f, -0.53605688f, 0.06928228f, 0.07817363f, -0.13930778f, -0.20282602f, 
    -0.16209902f, -0.03332283f, 0.12274813f, 0.01089093f, -0.16414474f, 0.06638443f, -0.03162029f, -0.29152322f, 
    -0.14013235f, -0.13977174f, -0.52671683f, -0.56814080f, -0.06725417f, 0.13105693f, 0.27009097f, 0.25373420f, 
    -0.52045935f, 0.20398802f, 0.40467131f, -0.33337381f, 0.55238390f, 0.12621646f, -0.09409148f, 0.12247029f, 
    -0.42558601f, 0.00020331f, 0.12423745f, -0.05065615f, -0.33001733f, -0.17906353f, 0.34384561f, 0.44997665f, 
    -0.01110175f, 0.00110181f, -0.05867972f, 0.17296202f, 0.17271499f, -0.00901330f, -0.24092063f, -0.12636089f, 
    -0.11420038f, -0.29221043f, 0.29941118f, 0.34045476f, 0.08282843f, -0.47406039f, 0.38016722f, -0.14266549f, 
    0.13267557f, -0.07907982f, -0.33882856f, 0.29784060f, -0.03714004f, -0.01685075f, 0.11636448f, -0.40700263f, 
    0.34508106f, 0.12810820f, -0.01717580f, -0.15557873f, -0.95226985f, -0.24074064f, 0.21271423f, -0.12141120f, 
    0.30972892f, 0.43125746f, -0.55273259f, -0.12998012f, 0.66507614f, 0.20476864f, -0.22501066f, 0.14954427f, 
    0.36925694f, -0.04545188f, -0.22591645f, -0.13782513f, 0.13047624f, -0.13329427f, -0.35302532f, -0.12119010f, 
    0.12172417f, 0.25606748f, 0.07775833f, -0.03122537f, 0.12107802f, -0.05399412f, -0.49564138f, -0.45306093f, 
    -0.22900641f, -0.39479804f, 0.09065726f, -0.12733477f, 0.62955648f, -0.26750657f, -0.32268718f, -0.46255976f, 
    -0.25083718f, -0.25312498f, 0.20783775f, 0.30217054f, -0.24362414f, -0.24253567f, -0.38094771f, 0.03851951f, 
    0.19535990f, 0.18933137f, -0.24624176f, 0.07387270f, 0.15382622f, -0.42027551f, 0.82317281f, 0.73895735f, 
    -0.12297181f, -0.13598207f, -0.12579499f, -0.47187889f, -0.38434756f, 0.48358053f, 0.17918813f, -0.46695730f, 
    -0.30420718f, 0.11693569f, 0.01224688f, -0.08354788f, 0.04400492f, 0.09794795f, -0.11427541f, 0.05410803f, 
    0.14920177f, -0.20789012f, -0.22048020f, -0.03942101f, -0.07287175f, 0.15555254f, -0.02709613f, 0.49996740f, 
    -0.43293858f, -0.51601702f, 0.37504721f, 0.35237014f, 0.47720227f, 0.58598846f, -0.06317282f, -0.36381629f, 
    -0.67974597f, -0.04603733f, -0.11517625f, 0.26780525f, -0.42523018f, 0.31156102f, -0.11469367f, 0.11807280f, 
    0.05404402f, -0.17230569f, -0.05289165f, 0.11332542f, -0.15580514f, -0.25442186f, 0.00533442f, 0.20972627f, 
    -0.55388129f, -0.30327454f, -0.68395156f, -0.57130188f, -0.56697679f, -0.18651593f, -0.01690263f, -0.43814903f, 
    -0.31568286f, 0.14176662f, -0.11067322f, 0.03705125f, -0.38842797f, -0.42960921f, -0.22701633f, 0.27665949f, 
    -0.24521735f, -0.16524722f, -0.12478883f, -0.00951512f, -0.10989302f, -0.22387773f, -0.03041261f, 0.17152895f, 
    -0.16850795f, -1.30069852f, 0.12123137f, -0.74612665f, -1.01818597f, -0.08073753f, 0.44711924f, 0.52511489f, 
    0.28527826f, 0.05857757f, 0.10159198f, -0.37153387f, -0.32729879f, -0.56869197f, -0.46500465f, 0.05679088f, 
    0.13487051f, -0.04638520f, -0.01061267f, 0.07043459f, -0.39352322f, 0.09744721f, -0.05983805f, 0.11225987f, 
    -0.07266575f, -0.03130563f, -0.38663718f, 0.28190109f, -0.21163321f, -0.11514945f, 0.07012045f, -0.11568375f, 
    0.14204234f, 0.33044380f, 0.02790133f, 0.10562648f, -0.12022165f, 0.30096331f, -0.15946244f, 0.05421138f, 
    -0.16799200f, -0.27013618f, 0.19905622f, -0.27877176f, -0.00511758f, 0.14131412f, 0.20815231f, 0.18075465f, 
    0.20774113f, -0.05008341f, -0.04597322f, -0.62182766f, -0.51738495f, -0.21544713f, -0.50323755f, -0.51595092f, 
    0.24275509f, 0.22881098f, -0.11115483f, 0.11960446f, 0.45039871f, -0.18132098f, 0.05780118f, 0.01387845f, 
    0.24005678f, -0.11313625f, -0.09774613f, 0.05027093f, -0.03021555f, 0.21100089f, -0.00909850f, -0.07849377f, 
    -0.21495169f, -0.02559259f, -0.27803898f, -0.26020354f, 0.87022859f, -0.81030834f, -0.65344083f, -0.46762848f, 
    -0.35766011f, 0.40540251f, 0.32032388f, 0.34517422f, 0.10248614f, 0.22011361f, 0.00414350f, 0.05347891f, 
    -0.11223827f, 0.08505905f, 0.11242862f, 0.00957010f, -0.17766774f, -0.07953283f, -0.04681911f, 0.16202591f, 
    -0.02555729f, -0.23665668f, 0.06375403f, 0.35552394f, -0.13113944f, 0.37082806f, -0.45667210f, -0.63077915f, 
    -0.63979328f, -0.33364609f, 0.04826697f, -0.09901372f, 0.09008329f, 0.35276905f, 0.36367255f, 0.20110789f, 
    -0.07741795f, 0.23469286f, -0.07511534f, -0.14094639f, -0.20469321f, -0.05027156f, 0.29359025f, 0.26666200f, 
    -0.12307123f, -0.11715876f, 0.02124554f, -0.12911138f, -0.47918350f, 0.37353832f, 0.31539157f, -0.68779045f, 
    -0.54623055f, 0.12865287f, 0.23676467f, 0.02327986f, 0.10044046f, 0.22747494f, -0.18361083f, -0.09624293f, 
    0.13242272f, 0.40359321f, 0.02254728f, -0.31652364f, -0.13398065f, -0.03808061f, -0.19238402f, -0.18677638f, 
    -0.05508544f, -0.00981373f, 0.13236330f, 0.23765840f, 0.08445154f, 0.06956465f, 0.21006623f, 0.43436360f, 
    0.10588956f, -0.22302812f, -0.43488643f, -0.36421084f, -0.29836705f, -0.15011401f, -0.12166566f, 0.25289059f, 
    0.05779634f, 0.34485769f, 0.28746170f, -0.07610714f, 0.40521595f, 0.13760191f, -0.02678464f, 0.07997566f, 
    -0.09831413f, -0.02591066f, -0.31601194f, -0.10831250f, -0.14487050f, -0.15619506f, 0.01433734f, -0.31632072f, 
    -0.53358912f, 0.04817402f, -0.54709560f, -0.32375029f, -0.42338324f, 0.31850079f, 0.32672986f, -0.18056391f, 
    -0.23514481f, 0.57603329f, 0.37777603f, 0.38468906f, 0.17635201f, 0.14329574f, 0.01930554f, -0.14910918f, 
    -0.20096913f, -0.16884910f, -0.04321823f, -0.00409050f, 0.33065483f, -0.12587054f, -0.03958889f, 0.31881359f, 
    0.16959545f, 0.01908437f, 0.30430841f, 0.36398861f, -0.54194236f, -0.35406512f, 0.35198835f, 0.31823024f, 
    -0.06612646f, -0.16775122f, -0.15065844f, 0.05138357f, -0.28710029f, -0.25386590f, -0.04029256f, -0.09861793f, 
    0.56579298f, 0.17459314f, -0.19691874f, 0.06269927f, -0.25659758f, -0.19450517f, -0.29972491f, -0.26746327f, 
    0.24339439f, -0.05710779f, 0.42723724f, 0.08306643f, -0.02636769f, -0.04494931f, -0.30280113f, -0.72918844f, 
    -0.66497380f, -0.72354418f, -0.66341662f, -0.83099550f, 0.24966025f, 0.28975126f, -0.06468173f, -0.01202003f, 
    0.09712018f, -0.05526907f, 0.25207806f, -0.09673664f, -0.01773611f, -0.03446930f, -0.30703914f, 0.07989975f, 
    0.02221640f, -0.03270245f, -0.06791876f, -0.22981413f, -0.34181410f, 0.02840476f, -0.07864470f, 0.51245499f, 
    -0.21352232f, -0.55431283f, -0.10718902f, 0.60790509f, 0.40268442f, -0.15227665f, 0.09910387f, -0.26182374f, 
    -0.03288952f, 0.19502369f, 0.01905791f, -0.23990697f, 0.06609944f, 0.16949069f, -0.27038437f, 0.04400638f, 
    0.12986742f, -0.26734814f, 0.03663572f, 0.34250632f, 0.06717128f, -0.50137293f, -0.31132466f, -0.48355225f, 
    -0.43571937f, -0.06535469f, -0.12636247f, -0.07945266f, -0.03445794f, -0.09751384f, -0.23241588f, -0.15508135f, 
    -0.10203660f, 0.13387971f, 0.16760524f, 0.03074275f, 0.27331588f, -0.02196437f, 0.14892185f, 0.06556819f, 
    -0.42262587f, 0.05327546f, -0.18796347f, -0.27997902f, -0.16335830f, 0.08099135f, 0.08186959f, -0.22815663f, 
    -0.45038673f, -0.48703873f, 0.08590063f, 0.12054200f, -0.15214601f, 0.33568716f, -0.05619866f, -0.16389236f, 
    -0.32717296f, -0.00583548f, -0.07290538f, 0.08693866f, 0.12617293f, -0.14070915f, -0.40284505f, -0.21471566f, 
    -0.33660337f, -0.39601198f, -0.26654562f, -0.21170387f, -0.45280686f, -0.54283571f, 0.17701313f, -0.16962208f, 
    -0.09276865f, 0.12386407f, 0.28032517f, -0.18927678f, -0.16379379f, -0.31036589f, 0.08142088f, 0.35563517f, 
    -0.29053402f, 0.17053106f, -0.27808872f, -0.19486633f, -0.10094752f, 0.00016704f, -0.18239306f, -0.19546461f, 
    0.09274432f, -0.00600811f, -0.07657200f, -0.33958742f, -0.09771460f, -0.33343622f, -0.35840321f, -0.68566740f, 
    0.19604363f, 0.12783964f, 0.16196761f, 0.26661476f, -0.05224914f, -0.25088355f, 0.65392065f, -0.30938980f, 
    -0.33837608f, 0.09465604f, 0.09901507f, -0.14892261f, 0.33631048f, -0.31984672f, 0.28524914f, -0.10954833f, 
    -0.15603384f, -0.00129118f, -0.03312610f, -0.17034264f, 0.22415511f, 0.18353459f, 0.16740844f, -0.17326143f, 
    -0.77823192f, -0.50974482f, 0.16358301f, 0.37611538f, 0.17038724f, -0.53480726f, -0.62666231f, -0.02369088f, 
    -0.44895229f, -0.44811532f, -0.05260093f, 0.16538887f, -0.28455958f, -0.09182683f, -0.58438587f, 0.02660559f, 
    0.08289529f, 0.00235226f, -0.25238547f, -0.39802557f, -0.25074425f, -0.02153572f, -0.10513590f, 0.00238427f, 
    0.13476428f, 0.37039462f, 0.38720834f, 0.26472253f, -0.22821584f, -0.19934887f, -0.17968352f, -0.15401973f, 
    -0.08953273f, 0.19746853f, 0.03817847f, 0.27607355f, 0.24731387f, -0.24338363f, 0.07695169f, -0.24102911f, 
    0.11224643f, 0.05410062f, -0.22259548f, -0.00690427f, 0.09209648f, 0.05985151f, 0.40413782f, -0.15734814f, 
    -0.21188012f, -0.02239255f, -0.41162819f, -0.34228146f, 0.15551755f, -0.14042683f, 0.43904841f, -0.44741413f, 
    -0.06698240f, 0.25209895f, 0.23248714f, 0.20457366f, -0.08525542f, -0.27663326f, -0.05285489f, 0.08220241f, 
    0.23574272f, 0.32395822f, 0.02358290f, -0.11662523f, 0.15908727f, -0.36699334f, 0.03981911f, 0.20566922f, 
    -0.21362408f, -0.09484401f, -0.35521725f, -0.76270866f, 0.24198927f, 0.48449361f, 0.37608251f, 0.00384960f, 
    -0.65362185f, -0.39412758f, 0.04882990f, -0.00913628f, -0.15384358f, -0.27579218f, 0.12084956f, -0.13392702f, 
    0.06877562f, -0.15901746f, -0.22068676f, 0.13436197f, 0.00645870f, -0.07798391f, 0.31591845f, 0.01302903f, 
    0.00219244f, -0.18526646f, -0.32246196f, -0.24855003f, 0.57778436f, -0.90819931f, -0.41233164f, 0.51207632f, 
    0.28720877f, 0.15590768f, 0.50534666f, 0.55950940f, -0.18601649f, -0.45280474f, -0.00596985f, -0.12252232f, 
    -0.06487442f, -0.28224611f, -0.15490973f, 0.18486845f, -0.16723834f, -0.01029680f, -0.06395193f, -0.03275012f, 
    0.08996104f, -0.23278886f, -0.27719817f, -0.17098740f, -0.29716074f, -0.01539863f, -0.12464034f, -0.18628024f, 
    0.31601721f, -0.38117999f, -0.07379197f, 0.59624279f, -0.64413643f, -0.53453755f, -0.27343562f, 0.11987116f, 
    -0.21874435f, -0.12535483f, -0.00855493f, 0.20762075f, -0.14539728f, 0.33958873f, -0.35987526f, -0.43310487f, 
    -0.15882125f, 0.09585930f, -0.12933983f, -0.12298799f, 0.03906645f, 0.19432892f, -0.79101002f, 0.15483885f, 
    -0.23182297f, 0.21624587f, 0.59202874f, -0.54543465f, 0.31444705f, -0.24819535f, 0.51863891f, -0.09569126f, 
    0.06963050f, 0.20999555f, 0.16892429f, -0.10228164f, -0.20708735f, -0.05772810f, -0.24829485f, 0.14810751f, 
    -0.34623972f, 0.26533350f, -0.23225693f, -0.12167767f, 0.20830432f, 0.12403136f, 0.10255096f, -0.32616150f, 
    -0.55036414f, -0.60120332f, -0.51071137f, -0.08727475f, 0.02509676f, -0.19884863f, -0.22333534f, -0.35916299f, 
    -0.71320522f, 0.60410053f, 0.46120292f, 0.48636025f, 0.07373602f, 0.03163452f, -0.23170960f, -0.17857541f, 
    -0.26623353f, -0.00301278f, 0.04772815f, -0.02220302f, -0.11684908f, -0.03206940f, -0.01230480f, -0.48864844f, 
    -0.32529742f, 0.41201940f, 0.22342539f, 0.00282043f, -0.21217932f, -0.26730427f, 0.33059096f, 0.20052011f, 
    0.12802246f, 0.17779490f, -0.17396089f, 0.32597154f, 0.53000480f, -0.37077412f, -0.38948852f, -0.18192515f, 
    -0.20612644f, -0.07451672f, -0.19272332f, 0.14231730f, 0.05949999f, 0.33273613f, 0.19996433f, -0.28104329f, 
    0.08474910f, 0.72051650f, -0.08446911f, 0.17469402f, 0.06698491f, -0.37226093f, 0.14233537f, -0.01753107f, 
    0.11026841f, 0.04527561f, -0.34721828f, -0.03881273f, -0.12129718f, -0.09882772f, 0.06805415f, -0.02407854f, 
    -0.14841713f, -0.30079415f, -0.01514023f, 0.24724077f, -0.10118499f, -0.29906660f, 0.01479431f, -0.29398596f, 
    -0.28741431f, -0.28674528f, 0.62128985f, -0.49492654f, -0.70037502f, -0.27279532f, 0.69915438f, -0.12436222f, 
    0.28287750f, 0.04507582f, 0.41943553f, -0.05286915f, -0.28754765f, -0.18992214f, 0.12262737f, -0.22267352f, 
    0.10745303f, -0.00801770f, -0.11508345f, -0.19558689f, 0.11294238f, 0.06526556f, 0.18870759f, -0.22495368f, 
    0.05931001f, 0.02315971f, 0.21946727f, -0.02000364f, -0.51786119f, -0.19984637f, 0.33731392f, -0.33504051f, 
    -0.40419388f, 0.03848769f, -0.31260577f, 0.51652986f, -0.45450658f, 0.11769235f, -0.26187044f, 0.23925245f, 
    0.07959069f, -0.15906459f, 0.05600879f, -0.16168463f, 0.09432508f, 0.13075362f, 0.11128704f, 0.04047357f, 
    0.06505344f, -0.02432768f, -0.33924955f, 0.32699186f, -0.15766773f, -0.06729639f, 0.09588093f, -0.13626979f, 
    0.21666531f, 0.20210464f, 0.22447471f, -0.19925800f, 0.10872228f, 0.12722413f, 0.14255039f, 0.20642488f, 
    -0.16576923f, 0.00937358f, -0.22366336f, 0.03699214f, -0.18378516f, -0.22039571f, 0.05043571f, -0.05211835f, 
    -0.12720656f, 0.18072294f, -0.01714216f, 0.10369553f, -0.21914215f, -0.58199167f, -0.17586474f, -0.26824892f, 
    -0.46493506f, -0.46887094f, 0.28999966f, 0.13923900f, -0.02626905f, 0.15474051f, 0.27223340f, 0.15336607f, 
    -0.11728161f, -0.00869002f, 0.05279497f, -0.05443737f, -0.04739552f, 0.00576167f, -0.03979374f, -0.19785902f, 
    0.06771345f, -0.22228298f, -0.04349826f, -0.30945349f, -0.20987833f, -0.13625041f, 0.34085926f, 0.47150645f, 
    0.33352360f, 0.02171502f, 0.12737286f, -0.19273350f, -0.14813741f, 0.25778991f, -0.05963041f, -0.06380673f, 
    -0.32118395f, -0.32501745f, -0.21337610f, 0.16753317f, 0.09316676f, 0.34292766f, 0.22873670f, -0.13562925f, 
    -0.16947046f, 0.01717036f, -0.02535978f, -0.14036219f, -0.19809490f, -0.34631947f, -0.36897188f, 0.57445091f, 
    -0.43156457f, 0.05446601f, 0.52572376f, -0.80213708f, 0.18302253f, -0.45105302f, -0.72860372f, -0.56201500f, 
    -0.82668114f, 0.43129015f, -0.04712482f, -0.07644182f, -0.20415437f, -0.13316649f, 0.11503991f, 0.18619506f, 
    0.17757195f, -0.12140428f, 0.12266427f, -0.28647864f, 0.12706953f, -0.15493983f, 0.09864587f, 0.17840524f, 
    0.74482465f, 0.38399038f, -0.34185231f, -0.52570629f, 0.17693761f, 0.04882850f, 0.07346718f, -0.27961448f, 
    -0.22480094f, -0.54652435f, 0.15648969f, 0.33718470f, 0.29945427f, -0.18794507f, -0.15793303f, 0.40972513f, 
    0.00063985f, -0.24057694f, -0.14889768f, -0.09738971f, -0.32180849f, -0.11112055f, -0.18697269f, 0.15325199f, 
    -0.27073377f, -0.96642452f, -0.18290074f, 0.22232531f, -0.89277637f, -0.52254581f, 0.42984563f, -0.14070295f, 
    0.37454894f, 0.55738741f, 0.35287365f, -0.14091626f, 0.02763359f, 0.05212299f, -0.27771014f, 0.15765055f, 
    -0.03960092f, -0.15549038f, 0.06671532f, 0.18634890f, 0.10608870f, 0.02870423f, 0.13365160f, 0.10967923f, 
    -0.19201697f, 0.13837509f, 0.19779833f, -1.03571737f, -0.49911961f, -0.40288171f, 0.29968894f, -0.04473491f, 
    0.13111393f, 0.04442933f, 0.15138736f, 0.41693673f, -0.10260149f, -0.02217214f, 0.18655165f, 0.09863088f, 
    -0.13062118f, 0.03382806f, -0.17227180f, -0.03756073f, 0.22935534f, 0.13039078f, -0.00057754f, -0.28837961f, 
    -0.18661334f, -0.03635903f, -0.02240546f, -1.08844519f, 0.36994955f, 0.42526621f, -0.60564494f, -0.34112993f, 
    -0.48917934f, -0.14308131f, 0.61556458f, 0.68206310f, 0.05984027f, 0.25369835f, -0.07559776f, -0.11077953f, 
    -0.03719638f, -0.29302430f, -0.04505086f, -0.11564793f, -0.00471191f, -0.16552246f, -0.01442367f, -0.10780832f, 
    -0.10324533f, -0.18139566f, -0.34456721f, -0.20411506f, 0.43680137f, 0.18810071f, 0.25928983f, -0.27592826f, 
    -0.37344885f, -0.44770357f, 0.18268445f, 0.09567712f, 0.06605667f, 0.03447481f, 0.31477901f, -0.17406195f, 
    -0.24785379f, -0.23393452f, 0.45657930f, 0.16785285f, 0.11008655f, -0.07526121f, -0.23336823f, 0.16575406f, 
    -0.22858571f, 0.01603874f, 0.29270709f, -0.06504153f, -0.08434658f, -0.16812810f, 0.47158375f, 0.12443146f, 
    -0.25820014f, -0.35890937f, -0.31909385f, 0.20310590f, 0.38656527f, 0.13499866f, -0.04980886f, -0.19677952f, 
    0.01700113f, 0.45000151f, -0.00539066f, -0.18512979f, -0.25568277f, 0.02402091f, -0.36751387f, 0.37981334f, 
    0.04412148f, -0.02076736f, 0.15689810f, -0.26311815f, 0.12983190f, 0.06141531f, -0.35973489f, -0.28801179f, 
    -0.34510472f, -0.05288876f, -0.17487928f, -0.39163026f, -0.27889499f, -0.41403744f, -0.45707420f, 0.17077991f, 
    0.30321598f, 0.39330032f, 0.14097451f, 0.17303190f, 0.12685537f, 0.08613352f, 0.17061016f, 0.02512428f, 
    0.13415544f, -0.01690844f, 0.20220369f, -0.02511200f, -0.05477849f, -0.07142117f, 0.13734290f, 0.58709836f, 
    -0.88616782f, -0.40677673f, -0.25699729f, 0.70901215f, -0.68169880f, -0.29207027f, 0.59380853f, 0.51802146f, 
    -0.08267620f, -0.01691255f, -0.01569907f, -0.12243025f, 0.02629096f, 0.15523838f, 0.16080913f, 0.04847488f, 
    -0.05861929f, 0.01366082f, -0.21966919f, -0.02297413f, 0.04147584f, 0.06662086f, -0.03938871f, 0.20337711f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07929122f, -0.23517177f, 0.11925195f, 0.05197529f, -0.14613630f, -0.10438775f, 0.32570010f, 0.21761034f, 
    0.22406727f, 0.00258595f, -0.00773298f, 0.08068546f, -0.23153375f, 0.11483791f, 0.17192726f, 0.20407063f, 
    0.11253985f, 0.18247209f, 0.03956358f, 0.21996453f, 0.18868810f, 0.07697950f, 0.22827676f, 0.33719295f, 
    -0.24299882f, -0.28316185f, 0.16220950f, 0.05023596f, 0.32208383f, 0.22810055f, 0.14873223f, -0.00588513f, 
    0.26788646f, 0.16208047f, 0.11824290f, 0.24390885f, -0.25237584f, -0.03900254f, -0.00204756f, 0.03306648f, 
    0.11721256f, 0.18526906f, 0.25191662f, 0.07017066f, 0.15669432f, 0.13363136f, 0.26211497f, 0.29315901f, 
    0.51516426f, 0.03798059f, 0.16947854f, 0.16965476f, 0.34252506f, -0.04003605f, 0.10883985f, -0.03267820f, 
    0.23935694f, 0.08217757f, 0.26854903f, -0.00678597f, 0.11954973f, 0.37554148f, -0.14004162f, 0.32011726f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30347726f, 0.13203996f, 0.07925475f, -0.25256085f, -0.13853471f, -0.07098570f, 0.11816917f, -0.00473191f, 
    -0.05968212f, -0.08330559f, -0.05088458f, -0.18343993f, -0.08599684f, -0.04791609f, 0.02514796f, 0.07564506f, 
    0.07002552f, 0.02917566f, 0.05103873f, 0.01208966f, 0.01850041f, 0.01406777f, 0.03379820f, 0.02717919f, 
    0.18187946f, 0.07066470f, 0.05940669f, -0.06762387f, 0.00889864f, -0.07837830f, 0.00760471f, -0.08554611f, 
    0.00670047f, -0.01336040f, 0.01148132f, -0.03131056f, -0.01685190f, -0.19732127f, -0.12754442f, 0.05573491f, 
    -0.04438296f, -0.08025335f, -0.00889889f, -0.00472993f, 0.00044613f, 0.00831638f, -0.05692658f, 0.00751208f, 
    0.31274426f, 0.15331222f, -0.21659327f, -0.20988081f, 0.06779963f, 0.09353603f, 0.08515956f, 0.06081605f, 
    -0.00608683f, -0.03244992f, -0.01717419f, -0.04155903f, 0.12491263f, -0.15178990f, 0.09322812f, -0.21302946f, 
    -0.02818828f, -0.06928196f, 0.02726085f, 0.00957034f, 0.05936039f, -0.05287826f, 0.08661918f, 0.13066266f, 
    -0.19948848f, -0.15035683f, -0.13484509f, 0.19023547f, 0.04995400f, -0.00210749f, -0.07205502f, -0.06368062f, 
    -0.02336254f, 0.00405132f, 0.00546280f, 0.05751438f, -0.00549531f, 0.04923009f, 0.04968633f, -0.04744910f, 
    0.13986129f, 0.08471201f, 0.06366777f, -0.11698684f, -0.08067569f, -0.12487730f, -0.07775948f, 0.00847966f, 
    0.75301015f, 0.01092223f, 0.05094700f, -0.15073554f, 0.01977078f, -0.04222342f, 0.09623001f, 0.01589938f, 
    0.01353363f, -0.04839196f, 0.03847681f, 0.06623937f, -0.01050281f, 0.01142679f, 0.08052281f, -0.18856247f, 
    0.00085896f, -0.01432894f, 0.03138360f, -0.13226110f, 0.04126533f, 0.02670625f, 0.00991906f, 0.03098738f, 
    0.29199961f, 0.15174860f, -0.20064428f, -0.16053802f, -0.03001986f, -0.11442374f, -0.07277349f, 0.02948144f, 
    0.01324572f, 0.02408256f, 0.03871116f, -0.03861165f, 0.33058569f, 0.03340477f, -0.08150216f, -0.01110544f, 
    -0.13134569f, 0.02784523f, 0.13550994f, -0.05849165f, -0.04615089f, -0.01311888f, 0.02471064f, 0.12895250f, 
    0.17522471f, 0.09479666f, -0.12314820f, -0.05494326f, 0.05996199f, 0.13451421f, -0.14535074f, -0.02792282f, 
    -0.18981104f, -0.19598593f, 0.00680327f, 0.00441388f, -0.04517789f, 0.01706794f, -0.05109629f, 0.10147060f, 
    0.15741915f, -0.05665842f, -0.18552537f, -0.06555078f, -0.04857317f, -0.07663513f, -0.03937190f, -0.12270012f, 
    0.09146545f, 0.00029543f, -0.02845471f, -0.12004101f, 0.09765395f, -0.00180170f, 0.04422911f, -0.06924149f, 
    -0.00273993f, -0.09767024f, 0.04590111f, -0.00824573f, 0.08719523f, -0.01629953f, 0.17345217f, -0.29960188f, 
    -0.16054723f, 0.11435150f, 0.03637105f, 0.09865928f, 0.00147872f, -0.02379356f, -0.00931583f, -0.09458068f, 
    -0.20273219f, -0.48551679f, -0.40297833f, 0.06289700f, 0.00550724f, -0.01141593f, 0.03376099f, 0.01813617f, 
    -0.05256860f, 0.00998027f, 0.01596035f, -0.19767974f, 0.32066336f, 0.18339892f, -0.01442594f, -0.09655938f, 
    0.15235452f, 0.02427077f, 0.17673856f, -0.15184663f, -0.08046325f, -0.07267066f, -0.07169301f, -0.06037033f, 
    0.10470567f, 0.26273021f, 0.17938252f, -0.24395752f, -0.04922453f, 0.22197606f, -0.11652111f, -0.10923445f, 
    -0.01130647f, -0.08118880f, 0.03885029f, -0.09268624f, -0.15779087f, -0.21220434f, -0.05147633f, -0.03088206f, 
    -0.02797857f, 0.03849575f, -0.01944974f, 0.00747514f, -0.15406832f, 0.02279769f, -0.11585616f, -0.08802416f, 
    0.04333939f, 0.36572555f, 0.36849880f, -0.19463263f, -0.12624471f, 0.12148528f, 0.01528364f, 0.01000761f, 
    -0.09794685f, 0.05856659f, 0.01458569f, -0.16025269f, 0.25755376f, 0.02831343f, 0.04981807f, -0.05585518f, 
    0.08981839f, 0.10293745f, 0.10631198f, -0.02911840f, -0.06755054f, 0.00282653f, 0.03008467f, -0.06281456f, 
    -0.50637174f, -0.15123408f, -0.06532306f, -0.02150673f, -0.01098995f, -0.02306381f, -0.01234600f, -0.03206307f, 
    0.01168856f, 0.02841484f, -0.01491870f, -0.03402414f, -0.03229455f, -0.61793077f, -0.37605268f, -0.04647690f, 
    -0.10834514f, -0.04584761f, -0.00204947f, -0.01868018f, -0.06744258f, -0.02993563f, 0.00870000f, -0.02693062f, 
    0.17983831f, 0.21204446f, -0.03681056f, -0.05871749f, 0.18334258f, 0.17854010f, 0.04298683f, 0.08323879f, 
    -0.06865563f, -0.02013063f, -0.06382049f, -0.04107772f, 0.07935064f, 0.20874336f, -0.17331748f, -0.02252556f, 
    -0.01849725f, 0.27918527f, 0.17793001f, 0.00434939f, -0.04042521f, 0.01529215f, 0.08234698f, 0.04045652f, 
    -0.11601016f, -0.05727286f, 0.03712659f, 0.02145089f, -0.07323559f, 0.05565317f, -0.00202489f, 0.03417812f, 
    -0.15507500f, -0.11531298f, -0.09559662f, -0.09500308f, 0.20259595f, 0.10553879f, 0.02780246f, 0.02950194f, 
    0.11477096f, 0.15940571f, 0.00709535f, -0.05372882f, -0.01520642f, 0.03986367f, 0.01167258f, 0.05454605f, 
    0.07634817f, -0.06468347f, -0.20890233f, 0.11576314f, 0.04686469f, -0.01804122f, 0.00101923f, -0.11242340f, 
    0.07933195f, -0.04038566f, -0.09123821f, -0.03348651f, 0.13546172f, -0.01625246f, -0.05998467f, 0.01971466f, 
    0.07937211f, 0.00899073f, 0.02002364f, -0.05675510f, 0.01273757f, -0.01223547f, 0.06693118f, -0.01371109f, 
    0.01235924f, 0.13888985f, -0.17264608f, 0.03498978f, 0.03718251f, -0.08814418f, -0.03067192f, -0.15159231f, 
    -0.10391501f, -0.09662227f, -0.06621913f, -0.11294841f, 0.11238937f, -0.07867338f, -0.00129645f, 0.02955249f, 
    -0.00968812f, 0.04480963f, -0.02409714f, 0.01257567f, 0.00010788f, 0.17362767f, -0.11740275f, 0.02977121f, 
    0.01119164f, 0.00694146f, -0.02717840f, -0.00788991f, 0.06565980f, 0.03418519f, 0.00113099f, -0.01803698f, 
    -0.10460404f, -0.07229667f, -0.07533368f, -0.01996800f, -0.12943502f, -0.08326364f, -0.17457953f, 0.01404166f, 
    -0.07105146f, 0.07505417f, -0.02699375f, 0.11049411f, -0.02661684f, -0.04024612f, 0.07142366f, -0.01587805f, 
    0.24630216f, 0.04204952f, -0.22430992f, -0.18068004f, 0.02001771f, -0.04268136f, -0.10313458f, 0.11847637f, 
    0.03408417f, 0.05736123f, 0.01598216f, -0.00273230f, -0.30140084f, 0.27091610f, 0.19291256f, -0.43186587f, 
    -0.11643875f, 0.01093976f, -0.01096366f, -0.01229967f, -0.02317827f, -0.05794306f, -0.04061393f, -0.16514073f, 
    0.24877395f, 0.05690313f, 0.07274485f, -0.08975403f, 0.15900330f, 0.20007540f, 0.10597496f, 0.04776842f, 
    -0.05643440f, 0.05855171f, 0.03514069f, 0.06390306f, 0.06171302f, -0.07040206f, -0.00370229f, -0.03537970f, 
    0.03361911f, 0.01702325f, -0.10984129f, -0.05603839f, 0.01380236f, 0.06487449f, 0.08034798f, 0.07070250f, 
    0.01246689f, 0.25454408f, 0.03178477f, -0.05810658f, 0.00178517f, -0.02221162f, -0.00999264f, -0.21123524f, 
    -0.06010450f, -0.06981139f, 0.04945073f, 0.05238679f, -0.16670218f, -0.01493852f, 0.11123678f, 0.02638841f, 
    -0.12580760f, -0.06258834f, 0.07146310f, -0.05395341f, -0.01756226f, -0.02024174f, -0.07337526f, -0.01697290f, 
    0.35844848f, 0.20810243f, 0.00610015f, -0.24709089f, 0.02388945f, -0.01189039f, 0.05646148f, 0.07803956f, 
    -0.02774522f, -0.14101589f, -0.18488550f, -0.06098149f, -0.07339054f, -0.12715034f, 0.00225613f, 0.00417523f, 
    -0.02901754f, 0.04758715f, -0.04350618f, -0.03106785f, -0.11281909f, -0.05169784f, -0.09905042f, -0.02515354f, 
    -0.16195014f, 0.05378607f, 0.14098656f, -0.02831665f, -0.04821913f, 0.02303454f, 0.03508938f, -0.04326680f, 
    -0.14007856f, -0.01244436f, -0.17833787f, -0.03465841f, 0.07891539f, 0.14066377f, 0.13543305f, -0.08208274f, 
    -0.02565776f, -0.07734147f, -0.02107805f, 0.07799315f, 0.04913491f, -0.12617585f, -0.08120147f, 0.00999331f, 
    0.22175817f, -0.55135578f, -0.39168915f, -0.04779669f, -0.01039475f, 0.02240312f, 0.05985775f, -0.01761809f, 
    0.03211671f, -0.01307335f, -0.02519785f, 0.05872687f, 0.17782222f, -0.04462480f, -0.15689659f, -0.18586339f, 
    -0.10743411f, 0.10053667f, 0.01810714f, 0.05960613f, -0.11391598f, -0.04074422f, 0.00384619f, -0.07262920f, 
    -0.18530081f, 0.30176163f, 0.06237860f, -0.32544845f, -0.00472881f, 0.01657625f, 0.07658955f, 0.06050831f, 
    -0.13297926f, -0.13291956f, 0.05089492f, -0.16153280f, 0.26685062f, 0.17354403f, -0.29237759f, -0.23596323f, 
    -0.00729234f, -0.10257778f, -0.03080020f, 0.12306042f, -0.07434423f, -0.11819484f, 0.01224414f, -0.04537819f, 
    -0.71535003f, -0.51881659f, 0.19520678f, -0.17174248f, 0.03304371f, -0.00414541f, 0.01872674f, -0.00870067f, 
    -0.02471901f, -0.03043882f, 0.02219003f, -0.05665042f, -0.27319166f, -0.41152477f, -0.02811054f, -0.03654060f, 
    0.05044640f, 0.00710683f, -0.06057543f, 0.00759594f, 0.01637867f, 0.00549454f, -0.01660941f, 0.06770927f, 
    -0.16902222f, 0.00859263f, -0.17254898f, 0.11035500f, -0.02815964f, 0.03789212f, 0.07157964f, -0.01058988f, 
    -0.06902277f, -0.04552995f, -0.05796638f, -0.12872823f, 0.21016453f, 0.16920882f, 0.11819634f, -0.29434013f, 
    0.00299048f, -0.16186169f, 0.11638938f, 0.07094889f, -0.02396583f, 0.00155015f, 0.00835939f, -0.00493725f, 
    -0.20565200f, -0.09270564f, -0.11728111f, 0.02434464f, 0.00888170f, -0.00629732f, -0.01786783f, 0.01362061f, 
    -0.15778504f, -0.03103063f, -0.06680021f, -0.10283558f, 0.05871515f, -0.03096488f, 0.08020113f, -0.00380610f, 
    0.05826146f, 0.10996321f, -0.05567839f, -0.07843722f, 0.05905547f, 0.05656793f, -0.04338073f, -0.01940268f, 
    -0.48718050f, -0.10416742f, 0.18571496f, 0.04135115f, 0.06663644f, 0.03779846f, -0.06710714f, 0.03457281f, 
    0.05435310f, 0.00900705f, -0.02192827f, 0.04190762f, 0.23874834f, -0.12496513f, -0.33569977f, -0.28448507f, 
    0.05438734f, 0.02843593f, -0.09731757f, 0.02283515f, -0.03448015f, 0.07999095f, 0.05457123f, 0.01015238f, 
    0.10452595f, -0.12966394f, -0.57418245f, 0.12214546f, -0.14275393f, -0.22056487f, -0.19172628f, -0.05660142f, 
    -0.21633266f, 0.01879516f, -0.12697223f, -0.04933599f, -0.11620575f, -0.05227057f, 0.19519134f, -0.12204461f, 
    0.01258567f, 0.19546480f, 0.00889652f, 0.06584877f, 0.06171191f, 0.00125168f, 0.02799680f, -0.05844599f, 
    0.08514772f, 0.12029029f, -0.05305076f, 0.06890563f, 0.10603046f, 0.02794581f, -0.00413121f, -0.08128632f, 
    -0.04252664f, -0.04867461f, 0.05206116f, 0.01877149f, -0.38023990f, -0.02837627f, 0.27548343f, -0.04969095f, 
    -0.02536933f, 0.03358102f, -0.00191718f, 0.15859194f, 0.11344081f, -0.00642030f, 0.04264233f, 0.08881653f, 
    -0.14284815f, -0.10728457f, 0.06626860f, -0.01965103f, 0.00037125f, -0.14709888f, -0.15779918f, -0.03932280f, 
    -0.18824889f, -0.01813061f, -0.13951014f, -0.04528961f, -0.36550200f, -0.60360456f, 0.18179469f, 0.05192812f, 
    -0.00431758f, -0.15190707f, -0.13538228f, 0.04265402f, 0.03473968f, -0.09860053f, -0.12765211f, -0.15428694f, 
    0.25455976f, 0.25576115f, -0.03706359f, -0.04731340f, -0.09531542f, -0.15792604f, -0.17101279f, 0.01238842f, 
    0.04465201f, 0.03519735f, 0.04486525f, 0.00546447f, 0.05207611f, 0.12842527f, -0.10691040f, -0.16022061f, 
    -0.12316468f, -0.05839193f, 0.01379590f, -0.27088106f, -0.20609118f, -0.08097436f, -0.17587981f, -0.00280032f, 
    0.06821314f, 0.21931298f, -0.03366657f, -0.21108870f, -0.14481162f, 0.06812537f, -0.02139033f, 0.03849357f, 
    -0.01902475f, -0.05074792f, -0.09684454f, 0.15327156f, 0.22659701f, 0.13028370f, 0.16359593f, 0.16580696f, 
    -0.07779929f, -0.06213577f, -0.02314138f, -0.03503725f, -0.06554759f, 0.08168540f, 0.06341113f, -0.06481635f, 
    0.08188376f, 0.13654909f, 0.06305416f, 0.10098681f, 0.10588237f, 0.04357018f, 0.16017461f, -0.15751937f, 
    -0.08153516f, -0.00677189f, -0.01601325f, 0.01080253f, 0.25225076f, -0.26794687f, 0.21187882f, 0.19821970f, 
    0.04860842f, -0.18927592f, 0.04034243f, 0.00771441f, -0.03382428f, -0.06094921f, 0.08426452f, -0.11719745f, 
    0.21224350f, 0.22239569f, 0.14258094f, 0.17416775f, -0.04650688f, 0.07364514f, 0.06339196f, 0.14995320f, 
    -0.04669910f, -0.02748971f, -0.05546237f, -0.05988867f, 0.09694613f, -0.03015163f, -0.19739197f, -0.22699878f, 
    -0.00025355f, -0.04508341f, 0.00009295f, -0.01449603f, -0.16178052f, -0.04986537f, -0.33979920f, -0.30366281f, 
    0.12942803f, -0.00804552f, 0.18925992f, -0.15865041f, 0.07845581f, 0.05924027f, -0.15390602f, -0.05701715f, 
    -0.02688823f, -0.11408292f, 0.06083087f, 0.01333875f, -0.21951561f, -0.09216362f, -0.27544421f, -0.37742940f, 
    0.01078566f, 0.09005585f, 0.03055801f, 0.06743742f, 0.03938918f, 0.13469991f, 0.10168451f, -0.00633303f, 
    0.58541679f, -0.19147491f, 0.06650692f, 0.21468683f, -0.04472497f, -0.01743223f, 0.00953780f, 0.01341658f, 
    -0.01934728f, 0.09289736f, -0.18689865f, 0.14181554f, 0.00625978f, -0.06202500f, -0.12331063f, -0.11504151f, 
    -0.09665751f, -0.08819193f, 0.08797996f, -0.03556018f, 0.01629598f, 0.02434755f, 0.03002320f, -0.01068286f, 
    -0.09150956f, 0.13042507f, 0.18384403f, 0.10158532f, -0.13114451f, -0.03133677f, -0.15842943f, 0.01219023f, 
    -0.10363738f, -0.02046103f, 0.03911509f, 0.05673296f, -0.22656588f, -0.16776256f, 0.00883866f, 0.17423348f, 
    0.07814515f, -0.00712005f, 0.01797874f, 0.05985785f, -0.19989805f, -0.33592087f, -0.05686688f, -0.25088465f, 
    0.06023244f, 0.02667053f, 0.34400299f, 0.19631398f, 0.04768660f, 0.04185041f, 0.11099246f, 0.21206407f, 
    -0.07550935f, 0.01848930f, 0.01825909f, 0.06701948f, 0.00456168f, -0.19585472f, 0.10600746f, 0.09963281f, 
    -0.05989684f, 0.03399912f, -0.01373342f, 0.02803067f, 0.02137752f, -0.00064909f, 0.05035877f, 0.00734470f, 
    -0.00462760f, -0.04476003f, -0.00853360f, 0.02992856f, -0.04813128f, 0.00325016f, 0.03200831f, 0.12310717f, 
    0.11903633f, 0.07363406f, 0.25049740f, -0.07063209f, -0.29444897f, -0.24784929f, -0.03387173f, -0.09955625f, 
    0.11703310f, 0.04906355f, -0.17899863f, 0.12010770f, -0.00250361f, -0.05569673f, 0.05770547f, 0.04467010f, 
    0.17086311f, 0.12317229f, 0.06096087f, 0.02797164f, 0.01030108f, 0.02333511f, -0.06183668f, 0.04940291f, 
    0.02300938f, 0.04037259f, -0.27332804f, -0.04347416f, -0.01815769f, -0.04851425f, -0.19307587f, 0.05177367f, 
    -0.01124505f, -0.03869527f, -0.05728634f, 0.03490217f, 0.10679409f, -0.05685124f, -0.04864586f, 0.07451153f, 
    -0.37702110f, 0.07348381f, -0.27772975f, 0.03729998f, 0.06288300f, -0.03059393f, 0.01689000f, 0.25052652f, 
    -0.11983978f, 0.05524669f, 0.03751486f, 0.05850866f, -0.02851770f, 0.04345152f, 0.11456095f, -0.07084364f, 
    0.12805159f, -0.08264946f, -0.00243085f, 0.02173971f, -0.05624682f, 0.10687657f, -0.05723739f, 0.15422502f, 
    -0.57865334f, 0.26384324f, -0.44740918f, 0.03617262f, -0.08641603f, 0.05700540f, 0.04044374f, 0.08357233f, 
    -0.09860854f, 0.03002086f, 0.06543075f, 0.01996337f, 0.02086289f, 0.05130962f, 0.16759984f, -0.04733166f, 
    0.08401230f, 0.06488708f, 0.03137602f, -0.20484701f, 0.02235734f, 0.03156505f, 0.04009099f, -0.06453157f, 
    0.23592044f, 0.01930019f, 0.28485194f, 0.00021065f, -0.03110942f, -0.02000868f, 0.06356510f, -0.15797451f, 
    -0.01240073f, 0.03254006f, -0.02349704f, 0.05508884f, 0.57444704f, -0.16513254f, 0.22355501f, 0.36214724f, 
    -0.01639118f, -0.07744466f, 0.05092961f, -0.08850361f, 0.15930565f, 0.04118761f, -0.03037609f, 0.04436268f, 
    0.29985008f, 0.25176233f, 0.10672450f, 0.08893697f, -0.03747667f, 0.14984354f, -0.16465430f, -0.21049432f, 
    0.01986267f, -0.00008824f, -0.03758708f, -0.00316749f, 0.14408433f, 0.23634221f, 0.14928056f, -0.06005340f, 
    0.12563965f, 0.04064345f, -0.15974084f, -0.07819802f, 0.02608228f, -0.00402637f, -0.23565523f, -0.23310934f, 
    -0.11639174f, -0.01214662f, 0.00768255f, 0.06844477f, 0.08351468f, 0.03198647f, 0.10049096f, -0.03136168f, 
    -0.06719054f, 0.00899730f, -0.02288459f, 0.07338321f, 0.09460227f, 0.04457800f, -0.07400226f, -0.03503720f, 
    0.00104259f, 0.09808257f, -0.09701347f, -0.21592642f, 0.03613908f, -0.11713348f, 0.05076061f, -0.06841239f, 
    0.55558437f, -0.12470439f, -0.15406500f, -0.04778265f, -0.03650109f, -0.01234066f, 0.02562137f, -0.01141107f, 
    0.10080119f, -0.10793344f, 0.05763547f, -0.06585345f, 0.10358397f, 0.02386859f, -0.03858513f, -0.17379557f, 
    -0.03249864f, 0.09658841f, -0.16268750f, -0.30142897f, 0.08148465f, -0.00566766f, 0.00342262f, -0.14469746f, 
    0.11470319f, 0.04723687f, -0.17677183f, 0.01335567f, -0.03948010f, 0.04782303f, 0.04458538f, 0.00956326f, 
    -0.09475079f, 0.13791154f, -0.05277623f, 0.06837607f, -0.15734833f, -0.22203344f, -0.08219482f, -0.09840813f, 
    -0.00754613f, 0.06052007f, -0.03411556f, 0.07361398f, 0.26331490f, -0.09737566f, -0.24503700f, 0.09738517f, 
    -0.11640472f, -0.14035079f, -0.16792870f, -0.09711593f, -0.00989285f, -0.01962420f, 0.03479284f, 0.11676659f, 
    -0.02245591f, -0.06521312f, 0.02653270f, 0.06337284f, 0.32922208f, -0.13305655f, 0.06753631f, 0.02587389f, 
    0.09065912f, -0.10091967f, 0.05638823f, -0.19233203f, 0.14790876f, -0.01340255f, -0.33470500f, -0.04916255f, 
    0.05449250f, 0.07403090f, -0.21990132f, -0.12401599f, -0.23066944f, -0.14549236f, -0.01449883f, 0.03651535f, 
    -0.09985672f, 0.02500422f, 0.00714879f, 0.13685519f, -0.35080621f, 0.25752664f, -0.02067014f, 0.03901187f, 
    -0.09259235f, 0.10995563f, -0.02382413f, 0.00600803f, 0.03938834f, 0.02947573f, 0.05140417f, -0.01706379f, 
    0.07041988f, 0.17752950f, 0.15793978f, 0.24112359f, 0.12852111f, 0.02290366f, -0.21035610f, -0.37299821f, 
    -0.04031923f, -0.03445774f, -0.03785074f, -0.07582890f, -0.02886193f, -0.00521176f, 0.06519907f, -0.12702359f, 
    0.07014306f, -0.00450265f, -0.02390104f, -0.04054930f, -0.26813900f, -0.06844167f, -0.15542762f, -0.24449807f, 
    -0.06165300f, 0.22107872f, -0.15576474f, -0.15817009f, 0.00090611f, 0.06212114f, -0.19248544f, -0.02645993f, 
    -0.04626624f, -0.00447328f, 0.04197347f, -0.15533535f, -0.18680046f, -0.36346692f, -0.04263096f, 0.06951445f, 
    -0.04248625f, 0.16460770f, 0.05851340f, 0.03428239f, -0.13424772f, 0.05305514f, -0.01145024f, 0.07104390f, 
    -0.25388557f, -0.19040196f, -0.12469684f, -0.10206782f, -0.03105291f, 0.06907089f, 0.07990655f, -0.11617277f, 
    0.03314516f, 0.12760355f, -0.05385179f, 0.05560227f, 0.04114434f, -0.00889213f, 0.13869019f, 0.01844104f, 
    0.03054993f, -0.04697685f, -0.06733215f, -0.00645937f, 0.05119286f, 0.01648412f, -0.01416871f, -0.02169350f, 
    -0.13206775f, 0.05669503f, -0.02569339f, 0.05057697f, -0.01122277f, 0.08024445f, -0.10068823f, 0.03904469f, 
    -0.09412806f, 0.04267733f, -0.02836768f, -0.00902813f, -0.32736817f, 0.07044457f, -0.14294276f, -0.37048504f, 
    0.15109867f, -0.26591578f, -0.02529995f, -0.03936157f, -0.01360942f, 0.02992073f, -0.04054114f, -0.03561069f, 
    0.47277445f, -0.08915460f, 0.22161853f, 0.10223796f, -0.08514859f, -0.00129719f, -0.02086370f, -0.09788188f, 
    -0.01925702f, -0.21789068f, 0.04028678f, 0.02624678f, -0.01220589f, -0.08901927f, 0.12426195f, -0.13619499f, 
    0.12200877f, -0.15066393f, 0.12794754f, -0.05864737f, 0.04382044f, -0.09242266f, 0.00918996f, 0.13185295f, 
    -0.21539053f, -0.13757628f, -0.10225909f, 0.09370410f, 0.03895346f, 0.04463064f, 0.03673825f, -0.07857048f, 
    0.11935607f, 0.11300040f, -0.20712903f, 0.22617486f, -0.10261714f, -0.04557096f, 0.03958327f, 0.15077852f, 
    0.00314909f, 0.11989678f, 0.16597016f, 0.09820436f, -0.04264516f, 0.07795878f, -0.00177883f, 0.08853640f, 
    0.17069019f, 0.07840816f, 0.21062453f, -0.01335644f, -0.05249958f, 0.09288286f, 0.04009222f, 0.00553453f, 
    0.00135696f, 0.08522139f, -0.16898221f, -0.00755105f, 0.24529935f, 0.01434743f, 0.01433138f, -0.02064083f, 
    0.00204829f, 0.01694075f, -0.04490279f, -0.02498767f, -0.10529301f, -0.17149898f, 0.13870507f, -0.06544340f, 
    0.22254980f, 0.09730455f, -0.01523051f, 0.38327515f, -0.10149908f, -0.01223659f, 0.00231444f, -0.02297286f, 
    0.04018926f, 0.00795498f, 0.02453470f, -0.12796000f, -0.23851973f, -0.05021611f, -0.07007043f, -0.17543095f, 
    -0.11106758f, -0.06669632f, -0.06027174f, 0.00810963f, 0.00157713f, -0.05122706f, -0.00424737f, -0.00744832f, 
    0.21839450f, -0.01001745f, -0.02493046f, 0.08070407f, -0.04616674f, -0.04966503f, 0.02682036f, 0.03937273f, 
    -0.07080459f, 0.05160901f, -0.06811715f, 0.00204418f, 0.14208364f, 0.05842161f, -0.08382752f, -0.05970821f, 
    0.02425021f, 0.04111700f, -0.07812937f, -0.14584987f, -0.07368445f, -0.01585508f, 0.06752104f, -0.25818983f, 
    0.11842243f, 0.08169118f, 0.07462794f, 0.11886907f, 0.00936890f, 0.00108836f, -0.05242362f, 0.03479901f, 
    0.03296775f, 0.10249201f, -0.05760705f, -0.01596098f, 0.03560640f, 0.10287900f, -0.19310255f, -0.53387082f, 
    -0.03464322f, -0.09968090f, -0.25334576f, -0.02851495f, 0.04136289f, -0.00837866f, -0.02991968f, 0.02532555f, 
    0.17905004f, -0.23970605f, -0.11701518f, 0.06620578f, -0.04314564f, -0.05129762f, 0.02527757f, 0.03675736f, 
    0.04205771f, 0.03348757f, -0.04997645f, 0.11789491f, -0.35793984f, 0.41183376f, -0.14178415f, -0.29871508f, 
    -0.08083773f, 0.04883937f, -0.21873897f, -0.04715420f, -0.16748159f, 0.03137850f, -0.05715655f, -0.04173755f, 
    0.02188835f, -0.05605026f, -0.14949988f, 0.02641402f, -0.09078933f, 0.05819391f, 0.07050361f, -0.13762727f, 
    0.04635499f, -0.09873540f, -0.01470439f, 0.01630219f, -0.60699004f, -0.33894855f, -0.00047151f, -0.22461858f, 
    -0.01847427f, 0.05347239f, -0.09844238f, 0.06789587f, 0.08405823f, 0.00260102f, -0.17189369f, -0.10200951f, 
    0.12007830f, -0.09446044f, 0.08777910f, 0.00881481f, -0.05008386f, 0.07845736f, 0.01663935f, -0.11691720f, 
    -0.01645519f, 0.09654260f, 0.05678311f, -0.12586489f, 0.05435306f, -0.13801432f, 0.12466453f, -0.10378242f, 
    0.02630053f, 0.02093982f, -0.01877371f, -0.02070574f, 0.10454714f, 0.07433402f, -0.08438615f, 0.18136911f, 
    -0.18966675f, 0.06505954f, -0.00437733f, 0.00777380f, 0.02917227f, -0.02304495f, 0.00730808f, -0.04097024f, 
    -0.06776356f, -0.04313819f, -0.01686538f, 0.01622560f, -0.02003625f, 0.44804841f, -0.08734345f, 0.19291748f, 
    -0.05395510f, 0.16045253f, 0.07670300f, -0.38095012f, 0.00713352f, 0.03672040f, 0.00186834f, 0.01814104f, 
    0.09030458f, -0.24008249f, 0.10728650f, 0.23603530f, 0.06059014f, -0.06242944f, -0.17353293f, 0.09636684f, 
    -0.07348635f, -0.03181288f, -0.04224815f, 0.17952110f, -0.18507384f, -0.24143380f, -0.10344514f, -0.05436527f, 
    -0.04308471f, 0.00540093f, -0.03858124f, 0.04232121f, -0.03728793f, -0.04963592f, 0.04982046f, -0.01250266f, 
    -0.04252992f, 0.14647329f, 0.10706561f, -0.12376255f, -0.07968634f, 0.11864975f, 0.16746515f, -0.11794031f, 
    0.00997873f, -0.03318586f, 0.05590961f, -0.08837565f, 0.15817168f, -0.14356141f, -0.15384106f, -0.17833120f, 
    0.11665472f, -0.05744010f, -0.02909081f, -0.05478727f, -0.01448816f, -0.01147717f, -0.05512094f, -0.07566080f, 
    -0.22948930f, -0.16307597f, 0.02095140f, -0.08869898f, -0.03119881f, 0.03569289f, 0.09285331f, 0.06989734f, 
    0.01575166f, -0.05561136f, -0.04008977f, -0.03105562f, -0.08524867f, 0.01141218f, -0.07900184f, 0.00117295f, 
    0.00659410f, -0.06350841f, -0.02234577f, -0.00923349f, -0.04725727f, -0.04356698f, 0.30572695f, -0.17263058f, 
    -0.02872949f, -0.12726046f, 0.34536457f, -0.27249691f, 0.05600294f, -0.07960699f, -0.11206735f, 0.01665404f, 
    0.06970405f, -0.04678211f, 0.03876454f, -0.00327093f, 0.13537829f, 0.28888246f, 0.05818846f, -0.00132940f, 
    -0.02947396f, 0.08805517f, 0.02574483f, -0.20252159f, -0.16950418f, -0.12778261f, -0.21088141f, 0.11931960f, 
    -0.18756324f, -0.14549154f, 0.17346507f, -0.12929569f, 0.01368469f, 0.01554910f, -0.00221555f, 0.02331905f, 
    0.05347738f, -0.05366854f, -0.08557570f, -0.04104426f, -0.31481653f, -0.07951166f, -0.03516481f, 0.13752337f, 
    -0.14424950f, -0.16452920f, -0.17791109f, -0.32337660f, 0.04824549f, -0.06987198f, 0.06826413f, -0.02693003f, 
    -0.73049021f, -0.41362038f, -0.27952784f, -0.20419268f, 0.00303995f, -0.10059714f, -0.00862778f, -0.05107030f, 
    0.03870093f, 0.03185007f, -0.08776908f, 0.02784499f, -0.09413824f, -0.10273389f, 0.10572276f, 0.00617101f, 
    0.02503271f, -0.04110067f, 0.00281797f, 0.10634517f, 0.07049745f, 0.16893689f, 0.04867757f, -0.10014355f, 
    -0.23882852f, -0.25303242f, 0.17734458f, -0.06368204f, 0.04615586f, -0.09316059f, -0.13873041f, 0.00030602f, 
    0.03055065f, -0.02058737f, -0.01701589f, -0.16687784f, 0.20228794f, -0.04091328f, -0.11375508f, 0.01434466f, 
    -0.19623443f, -0.05740498f, 0.06689729f, 0.06922096f, -0.03876415f, 0.03829261f, -0.08972262f, -0.19438763f, 
    0.03075780f, 0.14537922f, -0.08074183f, 0.09227596f, -0.03883508f, -0.04214229f, 0.02365532f, 0.04958237f, 
    -0.12429012f, 0.11201056f, 0.06104333f, -0.10560428f, 0.41089603f, -0.34849361f, -0.13872404f, -0.10278906f, 
    0.21052396f, -0.01492356f, -0.24060991f, -0.04737902f, -0.00395472f, -0.04215974f, -0.12409502f, 0.03270103f, 
    -0.12633532f, -0.12795962f, -0.15599556f, -0.01233987f, 0.03404601f, -0.03990790f, -0.05987586f, 0.04226489f, 
    0.05709128f, 0.02993152f, -0.21338777f, 0.16185778f, -0.03052562f, 0.07990158f, -0.07786447f, -0.01261785f, 
    -0.15215042f, -0.14499415f, 0.03105989f, 0.02573014f, -0.00853264f, -0.02676187f, 0.03961822f, -0.07423213f, 
    -0.13816312f, -0.11362573f, -0.36352849f, -0.02820157f, 0.01780558f, 0.00060169f, -0.08843479f, 0.08027817f, 
    0.06478914f, -0.00423165f, -0.24517362f, 0.04533961f, -0.15322626f, 0.16055378f, -0.01930308f, 0.06944697f, 
    -0.06810302f, 0.00134488f, 0.01464005f, 0.00722109f, 0.05966691f, 0.07260133f, -0.09108359f, 0.14222997f, 
    -0.05730135f, -0.05242455f, -0.27933124f, 0.34035319f, 0.11660643f, 0.03780422f, -0.02524829f, -0.00532304f, 
    0.14161539f, -0.04709666f, -0.09942309f, 0.11367791f, -0.19967186f, -0.05698963f, 0.31992856f, 0.31655943f, 
    -0.09277371f, -0.12416679f, 0.13522109f, -0.05796617f, 0.01165896f, 0.00234783f, -0.02697980f, -0.13660590f, 
    -0.24042670f, -0.20601664f, 0.18073803f, 0.04093695f, -0.03804163f, 0.06143253f, -0.00009203f, -0.06568538f, 
    -0.04285089f, -0.03112474f, -0.00030483f, 0.01398482f, 0.03504312f, 0.04612963f, -0.22272068f, -0.00713355f, 
    0.00113050f, -0.04912645f, -0.00019787f, 0.17288320f, 0.00977716f, 0.08780177f, -0.04385198f, -0.03649250f, 
    -0.27356115f, 0.09962071f, 0.19256158f, 0.01083262f, -0.00526605f, -0.12305246f, 0.11471763f, -0.03935809f, 
    -0.03948662f, 0.00112710f, -0.02892622f, 0.07613224f, -0.16175352f, 0.25739431f, 0.67061460f, 0.40968499f, 
    -0.00923841f, -0.10368007f, -0.08984314f, -0.00145024f, -0.02647953f, -0.02894485f, -0.06756186f, -0.08705691f, 
    0.08571137f, -0.08784956f, -0.04042063f, 0.02000151f, 0.03463833f, 0.06253889f, 0.04043851f, 0.00843128f, 
    0.03665357f, -0.00957610f, -0.13405573f, 0.04155246f, 0.07439559f, 0.13843459f, 0.16929714f, 0.21976808f, 
    -0.08393866f, -0.04441949f, 0.03764853f, 0.10814467f, 0.08879872f, -0.04677073f, 0.10730711f, 0.02461925f, 
    -0.22712566f, 0.30740166f, 0.29297775f, 0.04017447f, -0.03594118f, -0.03406220f, 0.07897689f, -0.14020145f, 
    -0.00159826f, 0.05210204f, -0.01341593f, 0.02008242f, -0.30575544f, 0.34343806f, 0.09218270f, 0.14059767f, 
    0.02603718f, 0.11356051f, -0.06756140f, 0.06665570f, 0.03016506f, 0.05886437f, 0.11803949f, 0.02564577f, 
    0.06083916f, -0.03153199f, 0.00868598f, -0.01471438f, -0.04235461f, -0.01930702f, -0.00869499f, -0.00872633f, 
    0.06349500f, -0.00708940f, -0.14319353f, -0.07226954f, -0.10227027f, 0.11006722f, 0.03143737f, 0.04069012f, 
    -0.05565906f, -0.01756469f, 0.03498815f, -0.24772458f, 0.07140812f, -0.03521748f, 0.01602281f, 0.27517170f, 
    0.21787004f, -0.17435044f, 0.08186069f, 0.08241658f, 0.02070051f, 0.01037302f, -0.03273087f, -0.01431580f, 
    0.01631216f, -0.04939433f, -0.08156549f, 0.01843409f, 0.10730471f, -0.07663424f, 0.06827135f, -0.13714802f, 
    0.02224105f, -0.06978837f, 0.00728811f, -0.07587471f, 0.08250661f, -0.04741224f, 0.10261811f, 0.12944035f, 
    -0.60625595f, -0.27206993f, -0.01965535f, -0.14508878f, -0.01715976f, 0.03954997f, -0.13342388f, -0.12688269f, 
    0.03323337f, -0.00700212f, -0.07342228f, -0.00961594f, -0.15105194f, -0.17007990f, -0.21155407f, 0.17845964f, 
    0.04409600f, 0.06380976f, -0.03121524f, 0.08572832f, -0.00402720f, -0.00867367f, 0.03174193f, 0.00522420f, 
    -0.29820624f, -0.01773090f, 0.11501462f, 0.04937552f, 0.01529830f, 0.05324451f, -0.00477363f, -0.14851293f, 
    0.02632383f, 0.04628199f, 0.02238316f, -0.00765594f, 0.00890202f, 0.06359944f, 0.11896163f, 0.18049726f, 
    -0.02899810f, -0.03173019f, 0.08576088f, -0.07894889f, 0.08589655f, 0.06685673f, 0.16432273f, 0.15405576f, 
    -0.09827301f, -0.15630993f, 0.03792647f, 0.09140334f, -0.03075044f, 0.02816576f, -0.01445831f, 0.04067950f, 
    -0.14872919f, -0.08431762f, 0.01152798f, 0.08850881f, 0.13604484f, -0.39153939f, -0.31100619f, -0.07232816f, 
    0.00342674f, -0.10102409f, 0.14149125f, 0.02669403f, -0.01697109f, 0.00627525f, -0.00910767f, 0.06570663f, 
    -0.26116431f, -0.15368873f, -0.47257549f, 0.06028961f, -0.06453186f, -0.03561705f, -0.00380734f, 0.04555258f, 
    -0.01265282f, -0.08689444f, 0.03493852f, 0.00850080f, -0.02025502f, -0.02477154f, 0.06901701f, -0.00461839f, 
    -0.02342947f, -0.04802394f, -0.13211955f, 0.10602219f, 0.09877043f, -0.04378218f, -0.02981187f, 0.07956389f, 
    0.05125011f, -0.12593307f, -0.06485180f, 0.10514440f, 0.04819807f, -0.00864673f, -0.01375697f, 0.00480718f, 
    0.10088670f, -0.00179550f, 0.01866290f, 0.04052540f, 0.14300084f, 0.11702196f, -0.23864122f, 0.00362713f, 
    -0.03656512f, 0.14402919f, -0.09559225f, -0.06970005f, 0.00152705f, -0.00178744f, -0.00959272f, -0.03076109f, 
    0.01125324f, 0.02063674f, 0.09670041f, 0.04543620f, -0.04220540f, -0.04078418f, 0.03257860f, 0.11905201f, 
    0.11793143f, 0.14123824f, 0.13327673f, 0.07227381f, -0.02469715f, -0.10337213f, 0.21692763f, -0.04254418f, 
    0.04920666f, 0.01481346f, -0.21043244f, -0.09806689f, -0.05793235f, -0.00060832f, 0.03826034f, 0.01138467f, 
    0.09065297f, -0.06076374f, -0.31071943f, 0.08725905f, 0.01075179f, -0.01811732f, 0.03152358f, 0.06223425f, 
    -0.10117802f, -0.03389481f, -0.03071622f, -0.14213799f, -0.14606391f, -0.08315484f, 0.09721512f, 0.01856095f, 
    -0.00852668f, -0.12844574f, 0.15451679f, 0.05812314f, 0.03415203f, 0.04441793f, -0.02983289f, -0.07539891f, 
    0.15573755f, -0.08623462f, -0.08021447f, -0.05475581f, 0.04026021f, 0.01125814f, -0.02578637f, 0.05221698f, 
    0.05214070f, -0.18406509f, 0.08982595f, -0.07993965f, -0.20136514f, 0.04833472f, -0.05432593f, -0.05665826f, 
    -0.01939542f, -0.03384759f, -0.01790793f, 0.00009712f, 0.01918700f, -0.02397746f, 0.03981496f, 0.03863043f, 
    -0.00346794f, -0.03093767f, 0.13808469f, 0.24889012f, 0.04567618f, -0.06383675f, -0.03293807f, 0.00238634f, 
    -0.03013783f, 0.07307898f, 0.01387492f, -0.04358189f, -0.31328279f, -0.02590379f, -0.21152185f, 0.13075010f, 
    -0.02696316f, 0.08929752f, 0.00073581f, -0.03978989f, 0.00214099f, 0.01955254f, 0.02755914f, -0.06524640f, 
    0.00078406f, -0.04489297f, 0.00359501f, 0.04024272f, 0.01234346f, -0.02421962f, 0.05967491f, 0.05064832f, 
    0.11546587f, -0.09321999f, -0.03535993f, 0.03724204f, 0.13471404f, 0.17011441f, 0.14569412f, 0.20121245f, 
    -0.02295489f, 0.01062355f, 0.01467819f, -0.01500444f, 0.08748079f, -0.02719446f, 0.02807200f, 0.15221408f, 
    0.00883503f, -0.09168467f, -0.19648387f, -0.08585110f, 0.04020841f, -0.00841715f, -0.05446546f, -0.05675680f, 
    -0.02699476f, -0.01995478f, -0.09847855f, 0.13058361f, -0.97042412f, -0.09603110f, -0.23885599f, -0.44920462f, 
    -0.13632138f, -0.08710012f, -0.03318004f, -0.24430007f, -0.02497836f, 0.03490332f, -0.02059280f, -0.03555912f, 
    -0.07614189f, -0.09733658f, 0.15933557f, -0.09303130f, -0.07349490f, 0.03522356f, 0.01247322f, -0.08585925f, 
    -0.00793315f, -0.00311214f, 0.11638187f, 0.01313432f, 0.20050654f, 0.50561929f, 0.04078504f, 0.34001085f, 
    0.03487360f, 0.13040216f, -0.07739472f, 0.05037556f, -0.05050796f, 0.05781174f, 0.01594920f, -0.02503530f, 
    -0.05735082f, 0.09828967f, 0.13109304f, 0.15172330f, -0.06371896f, -0.00821400f, -0.01920984f, 0.13315816f, 
    0.06833114f, 0.04469070f, 0.15516329f, -0.10933016f, 0.40772575f, 0.58706665f, -0.31756672f, 0.05677493f, 
    -0.04000764f, 0.04728309f, -0.00056798f, -0.14353514f, -0.04852109f, 0.05243904f, 0.04792485f, 0.03095722f, 
    -0.08069097f, -0.02797011f, 0.00571987f, -0.06615166f, 0.03464434f, 0.02037746f, 0.06266681f, -0.15963973f, 
    0.06072810f, 0.08622466f, -0.05928247f, 0.22247835f, 0.07656702f, 0.06604104f, -0.09451220f, 0.10536103f, 
    -0.07217645f, -0.00787145f, 0.05126632f, 0.04667732f, -0.04135530f, -0.19095366f, 0.03552824f, -0.09230319f, 
    0.00332249f, -0.21203652f, -0.03067188f, -0.00302622f, -0.10231750f, -0.02626912f, -0.12100501f, -0.06086700f, 
    0.03979203f, 0.02613242f, -0.03378380f, -0.00504876f, -0.12724380f, 0.33586401f, -0.04555902f, 0.27031472f, 
    -0.17575964f, 0.13388088f, -0.05957447f, -0.16245142f, 0.05827278f, 0.21091199f, 0.05252611f, 0.11364005f, 
    -0.19883280f, 0.24530922f, -0.09842438f, -0.16385525f, 0.17962633f, 0.08961834f, -0.03531045f, 0.03892110f, 
    -0.24123570f, 0.00151380f, -0.00794792f, 0.05525798f, -0.70390785f, -0.46713805f, -0.27538052f, -0.06059708f, 
    0.27479324f, 0.16409434f, -0.08772736f, 0.10494211f, -0.13969401f, 0.00109963f, 0.03683079f, -0.04197719f, 
    -0.01897937f, -0.01591854f, -0.12156129f, 0.05656311f, -0.17285064f, -0.07469715f, -0.01753820f, -0.03662540f, 
    -0.07959941f, 0.09227107f, -0.13075832f, -0.03275626f, 0.18454905f, 0.20461974f, 0.09075222f, 0.15797611f, 
    -0.09715767f, -0.09471831f, -0.20909032f, 0.06971268f, -0.19987033f, -0.22522044f, 0.02438523f, 0.04333284f, 
    0.03308632f, -0.04411973f, -0.03788211f, 0.13855714f, -0.05787428f, -0.00634157f, -0.02410867f, 0.06214520f, 
    0.01724922f, 0.02986907f, -0.10928624f, -0.03430089f, -0.35904685f, 0.02623916f, 0.08373671f, -0.07481470f, 
    -0.12360381f, 0.07624382f, 0.00205693f, -0.08228889f, -0.09956970f, -0.13645169f, 0.01941551f, 0.00193065f, 
    -0.39284295f, 0.11310463f, 0.27258641f, -0.04719925f, -0.26241562f, -0.03862122f, -0.11254131f, -0.01607092f, 
    -0.03107606f, 0.08672114f, -0.08562236f, 0.14624064f, 0.16601811f, 0.01973970f, 0.04296377f, 0.13901827f, 
    0.07173985f, 0.05708498f, -0.05352748f, -0.06779215f, 0.05077639f, 0.13965487f, 0.01702577f, 0.06975588f, 
    -0.51848787f, 0.57188678f, -0.51834393f, -0.70825481f, 0.07393236f, 0.16185990f, 0.02415856f, -0.00261695f, 
    -0.26340783f, 0.02868382f, 0.02409069f, 0.04661425f, 0.26626590f, -0.07870258f, 0.16232103f, 0.18085273f, 
    -0.14529827f, 0.06571230f, -0.03698760f, 0.06217190f, 0.08525785f, -0.00695199f, 0.14493668f, 0.02208908f, 
    0.09471671f, -0.23986073f, -0.01045335f, 0.01995648f, 0.05672492f, 0.09011524f, -0.01471735f, 0.12867469f, 
    0.18788293f, -0.05704765f, 0.04237797f, -0.12468585f, 0.00063727f, 0.22293937f, -0.22597434f, -0.03092368f, 
    0.07435682f, -0.03031452f, -0.11126547f, -0.03138228f, -0.13145158f, -0.00284421f, -0.01304465f, 0.02289469f, 
    -0.02770437f, -0.12689035f, 0.06013441f, 0.25967073f, -0.01063417f, -0.01506633f, 0.06240889f, 0.03423000f, 
    0.01472221f, 0.02011051f, -0.05842490f, -0.02077377f, 0.35796851f, -0.10754020f, -0.00964467f, 0.12470032f, 
    -0.01659298f, -0.06321447f, 0.25340414f, -0.09560762f, 0.01223797f, -0.14300190f, 0.10571301f, -0.25025943f, 
    -0.25907311f, 0.52025199f, -0.42729759f, 0.16834040f, -0.05185591f, 0.07367164f, 0.06253717f, -0.21790461f, 
    -0.02400705f, -0.21817477f, 0.10372555f, 0.15913674f, 0.26723814f, 0.10072984f, 0.11054169f, 0.04754309f, 
    0.07678983f, -0.01369323f, -0.07010481f, -0.05817587f, 0.07503977f, 0.14348461f, -0.01241884f, -0.10679969f, 
    -0.35511643f, -0.19680788f, -0.15464048f, 0.00762639f, -0.00273904f, 0.18852356f, 0.05125165f, 0.05839603f, 
    -0.06501023f, -0.08658193f, -0.23362957f, -0.01477268f, -0.12994890f, 0.15830447f, -0.21656887f, 0.20317371f, 
    -0.05767467f, 0.00640976f, -0.04344841f, -0.04811628f, -0.03686717f, 0.16150515f, -0.08531518f, 0.14138091f, 
    -0.03022674f, -0.14016259f, 0.04272538f, -0.19005617f, 0.06973229f, 0.07738771f, 0.13552415f, 0.14104062f, 
    0.00657719f, 0.20815070f, -0.10101891f, 0.15131149f, 0.04150616f, -0.19217372f, 0.01067075f, -0.31256580f, 
    -0.29295889f, -0.09847783f, -0.13090454f, 0.11145283f, 0.05525309f, 0.01073691f, -0.09461252f, 0.01568937f, 
    0.17488520f, -0.05656628f, -0.07421929f, -0.29949713f, 0.07315391f, 0.06185031f, -0.02767890f, 0.04812790f, 
    -0.00730411f, 0.07991220f, -0.12911069f, 0.00868986f, -0.10398136f, -0.08315841f, -0.09464891f, 0.17317154f, 
    -0.03648867f, -0.07639766f, -0.05345803f, 0.02887418f, -0.06125550f, -0.03693732f, 0.00635898f, -0.00092858f, 
    -0.23265043f, -0.14302580f, 0.42116302f, -0.00364992f, -0.16686659f, -0.03862275f, -0.24981381f, 0.01587987f, 
    -0.05555853f, 0.09964655f, 0.08078545f, -0.05808042f, -0.12278701f, 0.69757587f, -0.42795309f, 0.30569875f, 
    0.08739761f, -0.05157327f, -0.04237369f, -0.00365702f, -0.16472571f, 0.01159443f, -0.03060987f, -0.10003638f, 
    -0.00852323f, -0.15877925f, -0.05259221f, 0.14513949f, -0.04643128f, -0.03243840f, 0.01548728f, -0.05234211f, 
    0.07036826f, -0.00407454f, 0.03176640f, 0.11969478f, 0.59949148f, -0.18299711f, -0.07115629f, 0.18961291f, 
    0.21795721f, -0.03716294f, -0.00580091f, -0.04081006f, -0.14237282f, 0.04172002f, 0.13261351f, 0.18666503f, 
    0.33282724f, -0.01145611f, -0.22153169f, -0.08502050f, 0.08200685f, 0.02305218f, -0.01823946f, -0.11595716f, 
    -0.07951305f, -0.03925203f, -0.10364299f, 0.15403850f, 0.02863763f, -0.15649956f, -0.01673578f, 0.20406866f, 
    0.11429573f, 0.03095226f, 0.04748934f, -0.14466199f, -0.09716559f, -0.04613706f, 0.02405412f, 0.02060938f, 
    -0.58211267f, -0.04459994f, 0.02509712f, 0.13029081f, 0.03673051f, -0.02653442f, 0.10692817f, -0.10547306f, 
    -0.03145505f, -0.08360236f, 0.01360992f, 0.05066929f, -0.09271089f, -0.03784732f, -0.10502311f, 0.29966584f, 
    0.06371561f, -0.05042027f, -0.18951321f, -0.04981494f, -0.06839572f, -0.06992084f, 0.03816023f, 0.08332288f, 
    -0.11226045f, 0.14882794f, -0.11021009f, 0.06431780f, -0.04393132f, -0.11552633f, -0.17424244f, -0.13577358f, 
    -0.01263417f, 0.08990498f, 0.04365261f, -0.09021851f, -0.12417476f, -0.04780127f, -0.15139936f, 0.11372352f, 
    -0.06743076f, 0.02444449f, 0.00012134f, 0.09419499f, -0.03409417f, 0.05454447f, 0.06002242f, 0.14086881f, 
    -0.08672640f, -0.10593142f, -0.09381059f, 0.26299942f, 0.08431732f, -0.01856721f, 0.01337684f, -0.11993333f, 
    -0.05196798f, -0.01071959f, 0.00090369f, -0.03618752f, 0.15270326f, 0.10669617f, 0.16018090f, 0.11101668f, 
    -0.08355528f, 0.07009649f, -0.05846129f, 0.06540896f, -0.01918641f, 0.05672015f, -0.00512281f, -0.10589437f, 
    -0.05780427f, -0.23369399f, 0.08691159f, 0.24266504f, 0.02349462f, 0.09937506f, 0.03726072f, 0.10030023f, 
    -0.00070532f, -0.03020856f, -0.06577484f, -0.01974882f, 0.09780688f, 0.02769142f, -0.13467292f, -0.35161680f, 
    0.01550703f, -0.24015872f, -0.04272917f, -0.13078041f, -0.03409192f, -0.00255510f, -0.09371443f, -0.09392431f, 
    -0.15220445f, -0.24331096f, -0.00763446f, 0.17309278f, -0.10245024f, -0.03011996f, -0.04400640f, 0.01975141f, 
    0.12485685f, 0.09255399f, -0.00739518f, 0.04619833f, 0.07692385f, -0.04831108f, 0.05254657f, 0.10203184f, 
    0.04533271f, -0.00673918f, -0.05919190f, 0.03983217f, 0.02471402f, 0.06008942f, 0.12368459f, 0.04844845f, 
    0.02623622f, 0.03701773f, -0.17128016f, 0.06330765f, -0.08290087f, -0.03254717f, 0.11680598f, -0.01296711f, 
    0.10995789f, 0.02278898f, 0.07675478f, 0.11322229f, 0.29079771f, 0.19201215f, -0.15775898f, -0.32136407f, 
    -0.11903393f, -0.00483936f, -0.03721484f, 0.11254756f, 0.03076658f, -0.01831173f, 0.19520359f, 0.02657754f, 
    -0.11267637f, 0.04837227f, -0.09247307f, 0.09820288f, -0.05836842f, 0.00944867f, -0.00397336f, 0.07305615f, 
    -0.09801202f, 0.02199683f, -0.02742225f, 0.06023696f, -0.37789196f, 0.04247969f, -0.13121055f, -0.25303158f, 
    -0.11466286f, 0.03504971f, -0.14159399f, -0.07696367f, -0.01229268f, 0.01868007f, -0.09731009f, -0.08389007f, 
    0.30662191f, 0.11717369f, -0.21435189f, -0.40228811f, -0.03690499f, 0.03815943f, -0.07715902f, -0.02139474f, 
    -0.05469675f, -0.05112817f, 0.10196688f, 0.01733123f, 0.12095062f, 0.14368081f, 0.05910533f, -0.13146581f, 
    -0.05108933f, 0.02140440f, 0.04543706f, 0.02804860f, -0.09424946f, -0.04956014f, -0.07707678f, 0.07670036f, 
    -0.14597143f, 0.77751374f, -0.19290777f, 0.00206521f, 0.09535376f, 0.08335240f, 0.02908491f, 0.04044879f, 
    -0.10937028f, 0.04099876f, -0.03173751f, -0.10533365f, 0.03674610f, 0.01313372f, -0.07385319f, 0.29151985f, 
    -0.02647340f, -0.04713188f, 0.03742117f, 0.09942605f, -0.05710921f, 0.06491893f, -0.06633511f, 0.09052537f, 
    0.20644931f, 0.06504685f, -0.33323181f, -0.71341217f, 0.13289614f, -0.01966330f, -0.02145227f, -0.04074083f, 
    -0.13882031f, 0.11045863f, -0.11105980f, -0.16542473f, -0.06322517f, -0.13640010f, -0.10317148f, 0.13694373f, 
    0.09209305f, 0.02310768f, 0.06541951f, 0.09518524f, -0.06122100f, -0.03064304f, 0.05273651f, -0.00355098f, 
    0.15938272f, 0.03701076f, -0.11087140f, -0.15262751f, -0.10428670f, -0.04714502f, -0.11035428f, -0.04590667f, 
    -0.01214997f, -0.04966655f, -0.08143719f, 0.06133716f, -0.54492152f, -0.15939495f, 0.23309577f, 0.18759511f, 
    -0.03510849f, -0.10254343f, -0.07885452f, 0.01002451f, 0.10461740f, 0.07812234f, 0.07520247f, 0.00680411f, 
    0.14212960f, 0.60720348f, -0.39315271f, -0.19603711f, 0.14562048f, -0.15301228f, -0.02778727f, -0.03423385f, 
    -0.05953475f, 0.01231411f, -0.00748630f, -0.10537509f, -0.00279379f, -0.13957494f, -0.18062688f, 0.04487183f, 
    0.01996652f, -0.15624207f, -0.14097108f, -0.05449138f, -0.06090856f, -0.00534803f, -0.02547837f, -0.22493519f, 
    -0.08476608f, -0.01398101f, -0.45194781f, -0.20784152f, -0.00281374f, 0.10547701f, -0.12356983f, -0.01529576f, 
    -0.06576178f, -0.06951556f, -0.04909173f, -0.05581759f, 0.08221024f, -0.22335620f, 0.04404286f, 0.17314684f, 
    0.16153577f, 0.07569291f, 0.02926502f, -0.09669384f, 0.01675270f, 0.03871389f, -0.06515193f, -0.03181741f, 
    0.15988052f, 0.04781482f, 0.22584873f, -0.13496986f, -0.10326373f, 0.03956762f, -0.03065148f, 0.08017802f, 
    0.13342783f, -0.01492619f, 0.13100389f, 0.08896798f, -0.17172530f, -0.10638162f, 0.14547567f, 0.45923972f, 
    0.03379976f, -0.02506655f, 0.09878369f, -0.02999645f, -0.01892178f, 0.08278069f, -0.20781572f, 0.05952371f, 
    -0.22795610f, 0.01373905f, 0.25011092f, 0.15498279f, -0.00585256f, -0.02987274f, 0.05488252f, -0.01576203f, 
    -0.17578675f, 0.17395791f, -0.00610475f, 0.00916093f, 0.77752417f, -0.17685895f, -0.07510678f, 0.12337317f, 
    0.20137571f, 0.02984191f, -0.02975800f, 0.10666519f, -0.02346773f, -0.13509768f, -0.06022178f, 0.08080801f, 
    -0.24531460f, 0.00772154f, -0.14184316f, 0.00203327f, 0.08644176f, -0.03292268f, 0.11579154f, -0.20389621f, 
    -0.00831488f, -0.15625913f, -0.01754372f, -0.02464872f, 0.71191949f, -0.16119713f, 0.06327455f, -0.02613571f, 
    0.14598206f, 0.01908038f, -0.03778287f, -0.08854319f, -0.03977687f, 0.04207465f, -0.00613218f, -0.04753685f, 
    0.07725100f, -0.17774343f, 0.12930258f, -0.27472678f, 0.02452862f, -0.17406888f, -0.14882956f, -0.06266420f, 
    -0.10968234f, -0.04048038f, -0.20524573f, -0.04781094f, 0.06669343f, -0.02975047f, 0.00769405f, 0.08077260f, 
    -0.07864705f, -0.03241149f, 0.00999441f, -0.07354330f, -0.03030835f, -0.01992978f, 0.12633504f, -0.01728015f, 
    0.06861528f, -0.26256967f, -0.29991108f, 0.12831883f, 0.04043401f, 0.11260320f, 0.10635564f, 0.06427692f, 
    0.04542823f, -0.01329718f, 0.06101431f, -0.05055687f, -0.10350125f, 0.13723385f, -0.20598450f, -0.18057165f, 
    -0.11359082f, -0.12220044f, -0.11102869f, -0.10571416f, -0.18010333f, 0.04410389f, -0.09665026f, -0.06189965f, 
    0.15707128f, 0.03813117f, -0.44583490f, 0.13697420f, -0.11623120f, 0.03344137f, 0.10439368f, -0.15858196f, 
    -0.04260881f, -0.19041315f, -0.07735632f, -0.22389457f, 0.10512137f, 0.03180534f, -0.00590764f, 0.00578270f, 
    0.06086132f, 0.07551298f, 0.03973922f, 0.08307038f, 0.12138842f, 0.09574670f, 0.08174682f, 0.06730306f, 
    -0.18771569f, -0.14335880f, 0.01251998f, -0.09073620f, -0.09597808f, 0.00423813f, -0.00569730f, 0.00385326f, 
    0.04358352f, 0.02687668f, -0.02821974f, -0.05973426f, 0.08122629f, 0.03475394f, -0.18675946f, 0.15364236f, 
    0.08793513f, 0.20992079f, -0.01046297f, 0.07007092f, 0.03152661f, -0.03830719f, -0.04590938f, -0.19035003f, 
    -0.03971589f, -0.01619800f, 0.01511204f, 0.09177497f, 0.06408415f, -0.05267378f, -0.08066759f, -0.10568630f, 
    0.04123134f, 0.01761970f, -0.00362753f, -0.00690982f, 0.11268567f, -0.00401223f, -0.02381005f, 0.17661752f, 
    0.00932555f, 0.00721853f, 0.00981812f, 0.00790703f, 0.11329632f, 0.37014586f, -0.21435477f, 0.19722801f, 
    0.18634938f, -0.10578447f, -0.22589260f, 0.23875274f, -0.02277665f, -0.11149408f, -0.03792497f, -0.21486090f, 
    0.10064880f, 0.03567554f, -0.00633706f, 0.01263743f, 0.31901568f, 0.26462564f, 0.11543354f, 0.21344946f, 
    0.00079991f, -0.05226535f, -0.00015095f, -0.01405605f, -0.04449566f, -0.19937371f, -0.01334216f, -0.02811307f, 
    -0.04998344f, -0.44361377f, 0.14538443f, 0.15860979f, 0.01068702f, 0.04333565f, 0.03948240f, -0.03786957f, 
    -0.10247547f, 0.13102375f, -0.04553164f, -0.03553979f, -0.01854042f, 0.20872773f, 0.14185041f, 0.28479293f, 
    -0.05908972f, 0.17997441f, 0.00367290f, 0.22034538f, 0.04041671f, 0.00805190f, -0.13183025f, -0.02694795f, 
    0.09417989f, 0.20397529f, 0.26904780f, 0.20808019f, -0.11721728f, -0.01699921f, 0.07823110f, 0.12474842f, 
    0.07798028f, 0.02003469f, 0.00244881f, 0.00631914f, -0.11631547f, -0.16658321f, 0.03327041f, -0.06794225f, 
    -0.05470289f, -0.05051083f, -0.09439510f, -0.01149816f, 0.06045074f, 0.02499847f, 0.09416371f, 0.15336350f, 
    -0.04308274f, 0.08798941f, 0.01610141f, 0.09910107f, 0.09280819f, -0.00052969f, 0.08581331f, -0.12131932f, 
    0.01941662f, 0.02835658f, 0.06319036f, 0.02768218f, 0.02646672f, -0.31272924f, -0.01818806f, -0.11260189f, 
    0.05949811f, 0.03868086f, -0.22028209f, 0.10144611f, -0.00573694f, -0.14717478f, -0.08457224f, -0.09880496f, 
    0.02755304f, -0.21151036f, 0.25320789f, 0.09660771f, -0.02884080f, -0.08242460f, -0.03202529f, 0.10167893f, 
    -0.13735895f, 0.04548625f, -0.20922029f, 0.11026210f, -0.12577759f, 0.24282715f, 0.10292089f, 0.33934942f, 
    0.01291608f, 0.06052262f, -0.07794198f, -0.11266505f, -0.03816722f, -0.08482043f, 0.07783603f, -0.07895466f, 
    0.06284348f, -0.15862776f, 0.09332971f, -0.06923383f, 0.02197034f, -0.00764097f, 0.10709926f, -0.01682395f, 
    0.07078448f, 0.02808824f, 0.10317378f, 0.06595544f, 0.03338170f, -0.15291919f, 0.25025892f, -0.00634195f, 
    0.06934517f, 0.10208366f, -0.00123683f, -0.13133521f, -0.02702217f, -0.03761628f, 0.05668769f, -0.00124869f, 
    0.18804096f, -0.08897679f, 0.08864289f, -0.00319130f, -0.02685319f, -0.18207501f, -0.08033435f, -0.07708565f, 
    0.14294544f, -0.09997853f, -0.16142961f, -0.05469929f, -0.04286641f, -0.09242555f, -0.11066754f, -0.04375076f, 
    0.11719780f, -0.05928118f, -0.00829995f, -0.12231947f, -0.10780080f, -0.22237070f, -0.04535443f, -0.26911387f, 
    0.09325624f, -0.08061868f, -0.19827525f, 0.12475714f, -0.08109084f, -0.09611093f, 0.08681390f, -0.07332407f, 
    0.09906325f, -0.11461500f, -0.12237841f, -0.16817716f, -0.17466269f, 0.05566760f, -0.01643759f, -0.05387239f, 
    -0.17485888f, 0.07594467f, 0.04557413f, -0.08550216f, -0.04722897f, 0.00618848f, -0.08940073f, 0.07366656f, 
    -0.14864326f, 0.16100360f, -0.42082042f, 0.00255477f, 0.01681474f, 0.02292385f, 0.02893869f, 0.00952728f, 
    0.02929850f, 0.01143717f, 0.02481789f, -0.07916302f, 0.17276686f, -0.37100604f, 0.08579031f, -0.39564860f, 
    0.12226279f, 0.04211640f, -0.05260521f, 0.00049118f, 0.02851960f, -0.04462163f, 0.06793495f, -0.18132536f, 
    -0.03574668f, -0.03445528f, -0.00332908f, 0.08551911f, 0.01551962f, -0.07401001f, -0.07591188f, 0.04703515f, 
    -0.00786757f, -0.03243052f, 0.04527422f, 0.09498914f, -0.21658194f, -0.29579315f, -0.03465893f, 0.12116963f, 
    -0.06324299f, -0.06671402f, -0.12539200f, 0.08572546f, 0.02273952f, 0.05392610f, 0.03993871f, 0.00069337f, 
    0.08721826f, 0.09676652f, 0.07803665f, -0.10906299f, 0.02130573f, -0.07949102f, -0.00936490f, 0.05155786f, 
    0.04192397f, -0.05857120f, -0.16653521f, -0.21434605f, -0.15423876f, 0.06467911f, 0.03018698f, 0.04879262f, 
    -0.12166688f, -0.09625312f, -0.05118194f, 0.00647211f, -0.05449690f, 0.04799667f, -0.03122528f, 0.13689712f, 
    -0.12605326f, -0.04010335f, -0.02392036f, -0.01075199f, -0.03242292f, -0.03333135f, -0.04784090f, 0.00436172f, 
    -0.16210541f, -0.09485820f, -0.09923089f, 0.13433886f, -0.11716338f, -0.09746173f, 0.06679944f, 0.02006467f, 
    -0.09323412f, 0.03103980f, -0.10822722f, -0.04655742f, 0.03612529f, -0.08952707f, -0.06901063f, -0.05149836f, 
    0.08498259f, -0.06432837f, 0.14646405f, -0.10617080f, -0.05448984f, 0.02146917f, -0.19914994f, -0.01525792f, 
    0.04087940f, -0.12187217f, -0.03823052f, -0.03496474f, 0.01992271f, 0.14671768f, 0.06543143f, 0.09681882f, 
    0.06749421f, 0.01485922f, 0.07147598f, -0.04823299f, 0.10410813f, 0.04717708f, -0.00716091f, -0.00262321f, 
    0.16325036f, 0.24906500f, -0.09618377f, 0.11900336f, -0.01870071f, -0.04989630f, -0.01487070f, -0.02641450f, 
    0.00730221f, -0.01657166f, 0.00402492f, 0.01205755f, -0.07741721f, 0.05291860f, -0.36993989f, -0.03065145f, 
    0.11017515f, 0.02525230f, 0.06605950f, -0.13886899f, -0.34091395f, -0.09124921f, -0.07059590f, 0.05027997f, 
    0.09770830f, 0.32801259f, 0.28337780f, 0.18289578f, -0.00685043f, 0.10117767f, 0.01682330f, 0.02400406f, 
    0.03866664f, -0.11914778f, 0.02739305f, -0.11516972f, -0.41798967f, -0.06039582f, 0.05569705f, -0.04229600f, 
    -0.12545773f, -0.04832383f, 0.04092763f, 0.03451474f, -0.17301901f, -0.00101046f, -0.13435644f, -0.07494905f, 
    -0.07139662f, 0.07721536f, 0.08960877f, 0.02547097f, -0.04942138f, 0.02583863f, -0.01184440f, -0.02778881f, 
    -0.04246604f, -0.04225227f, 0.01475213f, 0.01744727f, -0.04875654f, 0.07916281f, -0.03085174f, 0.06299549f, 
    -0.05904523f, -0.05059249f, -0.00124613f, -0.05110323f, 0.12762977f, 0.00062858f, -0.00255266f, 0.33684054f, 
    0.09337501f, -0.01052410f, -0.02343260f, -0.01333278f, 0.01533552f, -0.01712794f, -0.02691194f, 0.01041092f, 
    -0.00299804f, 0.19499594f, 0.04232140f, 0.14841594f, 0.13817851f, -0.00232642f, 0.09951960f, 0.00255594f, 
    -0.07457473f, 0.02558818f, -0.14686602f, -0.08445892f, 0.01431300f, -0.15339705f, -0.00293800f, -0.10400091f, 
    0.09285870f, 0.02382747f, 0.21320784f, 0.14715594f, -0.08999643f, -0.01844642f, -0.05178063f, -0.06137763f, 
    -0.06285106f, -0.07857542f, 0.08008376f, -0.04024913f, 0.02715446f, -0.01504852f, -0.00340613f, 0.02775115f, 
    0.01191393f, 0.01498954f, 0.10956463f, -0.01779509f, 0.08873955f, 0.00423479f, -0.00005848f, -0.00208002f, 
    -0.19952263f, -0.05233509f, -0.06738587f, -0.10078949f, -0.06543337f, -0.02260341f, 0.03181221f, -0.03538054f, 
    0.13772647f, -0.09417524f, -0.05922784f, 0.10148227f, 0.05985285f, -0.11276831f, 0.14181761f, 0.34805354f, 
    -0.04847685f, 0.07832617f, 0.07008947f, -0.15924111f, 0.01063803f, -0.11319993f, 0.05916058f, 0.06947953f, 
    -0.11837443f, -0.31610587f, 0.02506027f, -0.14760907f, -0.03095267f, 0.00828841f, -0.03508499f, -0.01987309f, 
    0.13424863f, -0.03738964f, 0.02616804f, 0.21368270f, 0.01584060f, 0.13554302f, 0.01267022f, 0.07418560f, 
    0.02611674f, -0.22561997f, -0.03101264f, -0.03794117f, -0.12851967f, -0.01588234f, -0.09189180f, -0.01808765f, 
    -0.42231315f, -0.21825506f, -0.12594393f, -0.05888562f, 0.02236809f, -0.18452415f, -0.03878555f, -0.02036233f, 
    -0.11399056f, -0.04699304f, 0.02323121f, 0.00464094f, 0.09720310f, 0.14230742f, 0.21543351f, 0.14759751f, 
    -0.03418912f, -0.06419472f, -0.11121197f, -0.09865580f, 0.15674689f, 0.13362275f, -0.03404713f, 0.07380175f, 
    0.12213247f, -0.06551090f, -0.27344272f, -0.15678816f, 0.02839441f, 0.00525564f, 0.03939017f, 0.03597607f, 
    -0.09870863f, -0.11308082f, -0.17131272f, -0.37301046f, 0.04549896f, 0.13320711f, -0.07791843f, -0.05819114f, 
    0.00122812f, 0.02362322f, 0.01108200f, -0.09545212f, 0.03093093f, 0.13758376f, -0.13573684f, 0.22207326f, 
    -0.11456159f, -0.21462494f, 0.07769545f, -0.32064694f, 0.06293432f, 0.10939407f, -0.15689500f, 0.11417614f, 
    -0.12339018f, -0.03393584f, -0.05908576f, -0.03033548f, 0.00518111f, -0.15423614f, 0.15124558f, 0.07068457f, 
    -0.18268515f, -0.06464437f, -0.12486452f, -0.05985089f, -0.01921684f, 0.01542040f, -0.02789232f, -0.07268793f, 
    0.07927687f, 0.07571246f, -0.09452768f, 0.01536165f, -0.00523071f, -0.05182546f, 0.00998385f, -0.01414503f, 
    -0.08483918f, -0.25745544f, -0.10510456f, 0.01561529f, -0.01784961f, -0.00233817f, 0.04836480f, 0.05145968f, 
    -0.05264531f, -0.08316556f, 0.03980644f, 0.03090649f, 0.10489953f, -0.00275112f, -0.01081766f, 0.17460524f, 
    0.12741582f, 0.07683302f, -0.12793186f, 0.10765383f, 0.02632139f, 0.00445841f, 0.01811893f, -0.06170391f, 
    0.06234533f, 0.01058773f, 0.03004362f, 0.08713007f, 0.21523242f, 0.26401731f, 0.27264610f, -0.00645228f, 
    0.16097713f, -0.03376488f, -0.03275770f, 0.20763689f, 0.03870896f, -0.07550358f, 0.04553111f, -0.16394867f, 
    0.00160986f, 0.17007135f, 0.01267632f, 0.01466098f, 0.05761395f, 0.04603145f, -0.22650121f, -0.10496654f, 
    0.03996476f, -0.05700081f, 0.18058948f, -0.01940625f, -0.18480897f, 0.02755127f, -0.03916297f, 0.07514207f, 
    -0.17756331f, -0.21355473f, 0.02759944f, -0.14223845f, -0.05285428f, -0.02325105f, 0.01787700f, 0.02057648f, 
    -0.16205667f, -0.16156796f, -0.02384121f, 0.01031049f, -0.04915079f, 0.06461689f, -0.13491735f, 0.04523829f, 
    -0.24933046f, 0.02865325f, -0.16517656f, 0.02110808f, 0.05148634f, -0.03298992f, -0.12414062f, 0.02917866f, 
    -0.02911780f, -0.06001004f, 0.01833791f, 0.05772793f, 0.17123482f, -0.07466541f, 0.24746305f, 0.25171724f, 
    -0.08384251f, 0.13582982f, -0.10507973f, -0.04214318f, -0.05707428f, -0.02190320f, -0.02714068f, 0.05869624f, 
    -0.02208165f, -0.00808146f, -0.01249548f, -0.08199024f, -0.00978598f, 0.10792386f, -0.13549104f, -0.13551910f, 
    -0.00000382f, 0.03949679f, -0.10253450f, -0.04340743f, -0.11892319f, -0.06479232f, -0.23087308f, -0.26413983f, 
    0.08323635f, 0.08599044f, 0.21411353f, 0.09586237f, -0.19880983f, 0.00593399f, 0.09464626f, 0.04991201f, 
    0.13097385f, 0.06047275f, 0.00466703f, 0.02237132f, -0.15351731f, -0.27594298f, 0.12459764f, -0.33348447f, 
    -0.29630405f, 0.06744207f, -0.10225607f, 0.06484625f, -0.00429056f, -0.13440789f, -0.03814495f, -0.07117847f, 
    -0.64544255f, -0.42094675f, 0.40205747f, -0.03636197f, 0.06316303f, -0.11446011f, 0.00932494f, 0.06271090f, 
    0.17431130f, 0.09629298f, 0.17868191f, 0.04686258f, -0.04986541f, -0.14403634f, -0.14719054f, -0.00944345f, 
    -0.00188173f, 0.01392073f, -0.05548944f, -0.05349267f, 0.11722845f, -0.09857900f, -0.14010526f, -0.00912627f, 
    0.15214232f, 0.04346367f, -0.06291702f, 0.01681977f, 0.10159230f, 0.11427859f, -0.00546394f, 0.11673287f, 
    0.00465348f, 0.04665207f, 0.04320924f, 0.07343865f, -0.26138389f, 0.16394809f, -0.21959661f, -0.14985602f, 
    0.12621558f, 0.02436594f, -0.05344359f, 0.00600436f, 0.01641512f, 0.04770637f, -0.02994920f, 0.20397845f, 
    -0.15789007f, 0.13940245f, 0.14286087f, -0.10355655f, 0.15586437f, 0.00154382f, 0.12265587f, -0.03178563f, 
    0.01060034f, 0.00691453f, 0.07221386f, 0.08922014f, 0.03576051f, 0.04596067f, -0.05560477f, 0.06696649f, 
    -0.02881237f, 0.07287868f, -0.04094056f, -0.00149832f, 0.05322303f, -0.29246953f, 0.27960798f, -0.11920982f, 
    -0.06896827f, 0.07847470f, -0.24899420f, 0.12125476f, 0.06392603f, -0.04695937f, 0.14599217f, 0.22234683f, 
    -0.00236584f, 0.04369606f, -0.00041417f, -0.10134666f, -0.36075416f, -0.38007852f, -0.02654398f, -0.06227009f, 
    -0.10548105f, -0.07779339f, -0.05903558f, -0.02406116f, 0.12351028f, 0.03048500f, -0.04713087f, -0.04657347f, 
    -0.50258189f, 0.04369456f, 0.04802107f, 0.04127377f, -0.00891537f, -0.06143360f, -0.01844213f, 0.11656016f, 
    0.16463412f, -0.17620355f, -0.13637429f, -0.04581982f, -0.13012676f, -0.21996962f, -0.03119618f, -0.03459289f, 
    0.20962590f, 0.09178517f, -0.11698616f, -0.09060310f, -0.04223128f, 0.05598762f, 0.08048562f, 0.03597695f, 
    0.07056373f, 0.11140621f, 0.00819954f, -0.04310942f, 0.29482573f, 0.20498012f, 0.18749493f, -0.15030569f, 
    0.01210095f, 0.00835493f, 0.03298253f, 0.09469772f, 0.06500749f, 0.23111540f, 0.30330664f, -0.20152774f, 
    -0.09336590f, -0.08452409f, 0.03328439f, -0.03802012f, 0.08551017f, 0.00004662f, -0.18949978f, -0.06996618f, 
    0.06169692f, 0.14115901f, -0.08220031f, -0.30958846f, 0.01723021f, -0.07388391f, -0.02344057f, 0.05804769f, 
    0.07406660f, 0.05651120f, -0.03965027f, -0.08550858f, -0.11155137f, 0.23930667f, -0.11244523f, -0.06994559f, 
    0.01896468f, 0.00469231f, 0.06084805f, -0.02120758f, -0.04384311f, 0.14199856f, -0.03637154f, 0.13927490f, 
    0.10854074f, 0.02079264f, 0.07956829f, 0.00864401f, 0.00206951f, -0.12085683f, 0.05513744f, -0.07957204f, 
    -0.06167446f, 0.00957584f, -0.15195043f, -0.15001917f, 0.08946546f, 0.12007749f, 0.06891263f, 0.08209306f, 
    -0.01592617f, -0.01381946f, 0.15301132f, 0.06515401f, -0.06552796f, -0.05457221f, -0.07636826f, -0.00709474f, 
    0.07595804f, -0.15880612f, -0.20628491f, 0.16645826f, 0.02507482f, -0.07709002f, -0.07716165f, 0.02320825f, 
    0.13249022f, -0.04453614f, 0.36742836f, 0.07454026f, -0.01218334f, 0.24192759f, 0.29679701f, -0.21867928f, 
    0.05419406f, -0.10266091f, -0.09392702f, 0.14110456f, -0.02458997f, 0.04861505f, 0.01148180f, -0.14097106f, 
    0.30208540f, 0.03762323f, 0.03899129f, -0.02985008f, -0.04475340f, 0.02170397f, 0.15286185f, -0.26258597f, 
    0.10202338f, 0.01513950f, 0.19222839f, -0.04837669f, 0.18587595f, -0.11127778f, -0.08814603f, 0.15773180f, 
    -0.12844035f, 0.11961720f, -0.06199609f, 0.03270713f, 0.23804684f, -0.08012715f, 0.14778419f, -0.04488508f, 
    -0.07665382f, -0.31039476f, 0.34959278f, -0.03343266f, 0.10216265f, -0.10610664f, -0.05974800f, -0.11316904f, 
    0.10986805f, 0.00816278f, 0.10131169f, 0.13649964f, 0.17238984f, 0.08975514f, -0.09362334f, -0.04247328f, 
    0.15370324f, -0.14100432f, -0.21534356f, 0.23550895f, 0.01706269f, 0.09830513f, 0.03986623f, -0.04579523f, 
    0.25761813f, -0.11794409f, -0.21103124f, -0.01494243f, 0.09150669f, 0.09335756f, -0.07033262f, 0.09208449f, 
    0.06370697f, -0.01653980f, -0.06014050f, 0.01325156f, -0.31309968f, 0.12319043f, -0.12623464f, -0.29728544f, 
    -0.07116856f, -0.08594590f, -0.05418710f, 0.00796640f, -0.03776552f, 0.05694737f, -0.03578675f, 0.10282689f, 
    -0.08310819f, 0.09229580f, 0.08517485f, -0.07470876f, 0.04181245f, -0.04398331f, 0.06523729f, 0.03638961f, 
    0.02191050f, 0.00604170f, 0.00580532f, -0.01888103f, -0.60859168f, 0.34095809f, -0.21273716f, -0.46313012f, 
    -0.14173372f, -0.19743358f, 0.08647349f, 0.00411074f, 0.03904794f, -0.12417352f, -0.08525732f, 0.11725317f, 
    -0.03066630f, -0.06523976f, -0.10936891f, 0.12394878f, -0.09994735f, -0.13737851f, -0.12456245f, -0.12138358f, 
    0.14530504f, 0.05545014f, 0.14216839f, -0.00281123f, -0.21408674f, -0.16621916f, -0.05182983f, -0.18185638f, 
    0.00452896f, -0.02590396f, -0.01508005f, 0.15047444f, -0.07365021f, -0.02006037f, 0.00518734f, -0.20122336f, 
    -0.02125772f, -0.28351393f, -0.17464012f, -0.10048596f, 0.01705514f, 0.09132712f, -0.03097044f, 0.05941631f, 
    0.03262484f, 0.17835011f, -0.02259015f, -0.03501705f, 0.07010167f, -0.26592314f, -0.07981586f, -0.04243703f, 
    -0.08377632f, -0.06864806f, 0.08878952f, 0.32683575f, -0.01274641f, -0.03472918f, 0.03490010f, 0.15325630f, 
    -0.12205787f, -0.08319890f, 0.17504174f, -0.06051439f, -0.01678729f, 0.05137855f, 0.12177676f, -0.14843379f, 
    0.17814803f, -0.03327057f, 0.07174385f, -0.00566466f, 0.09292784f, 0.01250413f, -0.04102785f, -0.03402691f, 
    -0.01927783f, -0.02166241f, 0.02179706f, -0.06679182f, -0.36329362f, 0.11330961f, 0.23553747f, -0.30727220f, 
    -0.12386312f, 0.05804709f, 0.02880464f, -0.23350641f, -0.03612711f, 0.05458343f, -0.00491162f, 0.02967546f, 
    0.12762228f, 0.13332315f, -0.02261111f, -0.13673487f, -0.17815101f, 0.16082641f, -0.24078812f, -0.23374709f, 
    -0.07143778f, -0.03039130f, -0.04145477f, 0.06401354f, 0.05434179f, -0.13957398f, -0.01231724f, 0.04981397f, 
    0.08615227f, 0.10651880f, 0.15847927f, -0.11330106f, 0.18166129f, -0.14215183f, -0.08627275f, -0.12971379f, 
    0.02695940f, -0.04797174f, 0.07755334f, -0.02504495f, -0.29066068f, -0.39970228f, 0.32429999f, 0.10877527f, 
    -0.07605869f, -0.02244457f, -0.01564281f, 0.06381542f, 0.03497262f, -0.07489532f, 0.00811574f, 0.24696428f, 
    0.14087422f, -0.00271803f, -0.05408577f, -0.25079465f, 0.01993962f, -0.19609603f, -0.01329294f, 0.08843767f, 
    0.03889370f, -0.04338086f, 0.01838735f, -0.00529003f, -0.01940974f, -0.06701355f, -0.02705829f, -0.07733519f, 
    0.02069510f, 0.08909643f, 0.03251196f, 0.03764220f, 0.07042871f, -0.06229258f, -0.16776596f, -0.44126749f, 
    -0.01280441f, -0.20209146f, 0.24178505f, 0.05646134f, 0.00705271f, -0.01611579f, 0.10670720f, 0.05686796f, 
    0.10180819f, -0.14289235f, -0.16994968f, -0.14859885f, -0.07439860f, 0.19118057f, 0.09002826f, 0.02101150f, 
    0.24273224f, -0.21748362f, -0.00016825f, -0.21994740f, 0.23287797f, -0.04043052f, -0.07094070f, -0.12149023f, 
    0.07932764f, 0.05800711f, 0.25232080f, 0.01589086f, 0.19521739f, 0.06879330f, 0.04482082f, 0.03580246f, 
    0.16875376f, -0.04289340f, 0.09435004f, -0.03723578f, 0.00469580f, -0.03821512f, -0.21601111f, 0.01156393f, 
    0.12399592f, -0.10497942f, 0.02592974f, -0.06081156f, 0.02739770f, -0.00984581f, 0.01100005f, 0.04165804f, 
    0.01716563f, -0.22118497f, 0.12617858f, 0.02437409f, 0.06904710f, -0.11209235f, 0.07655534f, 0.11031380f, 
    -0.01639077f, -0.08361106f, 0.06997614f, -0.12077989f, -0.11367300f, -0.12014307f, 0.21798380f, 0.19390655f, 
    -0.09936544f, -0.05858861f, -0.00128700f, 0.14056012f, 0.05499634f, 0.09139062f, -0.00410706f, -0.12622865f, 
    -0.03422549f, 0.05586395f, -0.14284205f, -0.04302456f, -0.01011474f, -0.04018580f, 0.02590986f, 0.03535392f, 
    -0.25604558f, -0.08487483f, -0.18964145f, -0.32540402f, 0.11510968f, 0.13625081f, -0.02132644f, -0.10586192f, 
    0.01973500f, 0.06880076f, -0.27088937f, 0.08095904f, 0.11939304f, -0.05704186f, -0.01115608f, -0.07538885f, 
    0.03767789f, 0.02160448f, 0.30687907f, 0.30465132f, -0.23893851f, -0.02302248f, -0.01705614f, 0.07252076f, 
    -0.04742592f, -0.19436760f, 0.22352768f, 0.01753001f, 0.11984771f, 0.20934823f, 0.01320646f, -0.11643672f, 
    0.08613427f, 0.07179037f, -0.03450293f, -0.14616299f, -0.00154078f, -0.07042489f, 0.01664248f, -0.04305123f, 
    -0.35352862f, -0.20890491f, -0.26620892f, 0.34026492f, -0.01342781f, -0.12108367f, -0.00983124f, -0.00349949f, 
    0.03707306f, 0.00978344f, 0.28263173f, 0.18403727f, 0.03532477f, -0.00121138f, -0.30838668f, 0.00237790f, 
    0.05265835f, 0.04310385f, 0.03096905f, 0.01944598f, -0.12022712f, -0.03981273f, -0.35521564f, -0.42842957f, 
    -0.04946091f, -0.00871406f, 0.28100201f, -0.38892195f, -0.05776000f, -0.01331822f, -0.01572424f, -0.05407440f, 
    0.16782193f, -0.01382396f, -0.12400214f, 0.27321196f, 0.23578553f, 0.00757926f, 0.00144819f, 0.15684991f, 
    0.13176201f, 0.28568697f, 0.10186594f, -0.01467029f, -0.00203946f, 0.07993732f, 0.02434035f, 0.11019585f, 
    -0.30861756f, -0.11957855f, 0.05072056f, -0.08972462f, -0.01132348f, 0.00221342f, -0.04737133f, -0.04008527f, 
    0.13746102f, 0.08369815f, 0.05711845f, 0.08309402f, -0.30753535f, -0.05366822f, -0.11532096f, -0.13660932f, 
    0.01580377f, -0.02393389f, 0.01265381f, 0.08542251f, -0.02014552f, -0.03991939f, 0.01125684f, 0.16221593f, 
    -0.09427138f, -0.09436639f, -0.04849013f, 0.00611916f, -0.00283460f, 0.03353370f, 0.09834658f, -0.01756039f, 
    -0.07835694f, -0.02886981f, 0.09141409f, -0.15206113f, 0.18188964f, 0.13120887f, 0.02279863f, -0.01454500f, 
    0.10776652f, 0.19558288f, 0.19221327f, -0.04586068f, -0.00764745f, -0.01491935f, 0.08461171f, 0.07622401f, 
    0.04625945f, 0.18050608f, -0.16010943f, -0.24659407f, 0.06280123f, 0.13289027f, 0.03202718f, -0.09559457f, 
    0.03358740f, -0.27601597f, -0.04743696f, -0.00488532f, -0.50232565f, -0.55669755f, -0.21184868f, -0.08975449f, 
    0.12921539f, -0.06568909f, 0.05876366f, 0.06654206f, 0.10495731f, -0.04820615f, -0.06601734f, -0.00975844f, 
    0.20975257f, -0.12382530f, 0.10102842f, -0.13461387f, 0.07006157f, -0.01669344f, 0.01057693f, 0.14735863f, 
    0.05167535f, 0.04734022f, -0.04446324f, 0.10547724f, -0.47419250f, -0.08305307f, -0.16292296f, 0.20869963f, 
    0.06264857f, -0.03169623f, 0.05034108f, 0.03553117f, -0.24289316f, -0.12267853f, -0.28594133f, -0.23539804f, 
    -0.20509531f, 0.05931855f, -0.29280883f, 0.01141125f, 0.21787393f, -0.15148260f, -0.05543080f, 0.17325215f, 
    0.11385682f, -0.07681187f, -0.07780262f, 0.04624084f, -0.14814726f, -0.02641101f, -0.35821134f, 0.20788971f, 
    0.00979194f, 0.04825723f, 0.03504426f, -0.09626865f, 0.00318569f, 0.03757421f, 0.23770010f, 0.04599719f, 
    0.12565841f, -0.07779003f, 0.04259241f, -0.15685290f, 0.26506793f, 0.20599090f, -0.01913848f, 0.13328828f, 
    0.02789183f, -0.03264882f, -0.02455695f, 0.00666498f, 0.26517189f, -0.55192387f, 0.28119931f, -0.00627791f, 
    0.09236925f, -0.05295745f, 0.00147227f, 0.01046272f, 0.10629273f, -0.11551641f, 0.00701895f, 0.07712978f, 
    -0.13145407f, -0.29557377f, 0.08650636f, 0.37698126f, -0.00495951f, -0.07301314f, -0.03264748f, 0.03091108f, 
    -0.06274138f, 0.19116418f, 0.07139767f, -0.10164331f, -0.06364413f, -0.07220578f, -0.06642716f, -0.06641631f, 
    0.03107314f, 0.01969262f, 0.00877473f, -0.03837483f, -0.07842585f, -0.10803457f, -0.07931946f, -0.11987194f, 
    -0.28361008f, -0.20084067f, -0.30874825f, -0.36001644f, -0.24033335f, -0.07181599f, -0.01556524f, -0.08117657f, 
    0.05324539f, 0.01839339f, -0.10659054f, -0.00541203f, -0.16980475f, -0.07504378f, 0.03211520f, -0.13894156f, 
    -0.13804333f, 0.06278662f, -0.01706815f, -0.03015508f, -0.01091388f, 0.00217950f, -0.03345430f, -0.02709198f, 
    -0.28967208f, -0.43646550f, -0.33490452f, 0.19750568f, -0.07911248f, -0.28502139f, -0.17584269f, -0.30342528f, 
    -0.05724306f, 0.02569004f, -0.01948450f, -0.06112966f, -0.28759465f, 0.11237150f, 0.28329757f, -0.11654436f, 
    -0.03030260f, 0.01205431f, 0.01178262f, 0.02908161f, 0.16932090f, 0.19848950f, -0.03865296f, 0.17069836f, 
    0.27200177f, -0.22572182f, -0.28401965f, -0.12043667f, -0.08659259f, 0.08440752f, 0.24975266f, 0.15499389f, 
    -0.00348490f, 0.12731448f, -0.03516521f, 0.03706612f, -0.22193646f, 0.21613429f, 0.31328115f, 0.41650936f, 
    -0.05828971f, -0.14949021f, -0.10523070f, 0.21222927f, -0.08200604f, 0.02018713f, 0.14269170f, -0.09905928f, 
    0.10945182f, -0.18901148f, 0.11469571f, -0.04424520f, 0.07574876f, -0.00290412f, -0.06376233f, 0.02873859f, 
    -0.09980711f, 0.01658801f, 0.10793506f, -0.02614937f, -0.01055861f, -0.28037503f, -0.30249438f, -0.17472970f, 
    -0.03568035f, 0.12928867f, 0.07185888f, -0.13664509f, -0.11056856f, -0.02345664f, -0.03384734f, 0.07705671f, 
    -0.49551472f, -0.42184365f, -0.46598315f, -0.22099893f, -0.18844192f, -0.22250992f, -0.23719861f, -0.30936283f, 
    -0.03499968f, -0.01679863f, -0.00818837f, -0.05933145f, -0.12866136f, -0.10755983f, 0.05733515f, -0.03310478f, 
    -0.06226651f, 0.02190449f, 0.07512373f, -0.02324104f, 0.04875341f, 0.18745059f, 0.05759944f, 0.14934407f, 
    -0.50550330f, -0.56174368f, -0.07734648f, -0.36170089f, -0.04991802f, -0.09310516f, 0.08408339f, -0.18940778f, 
    0.01878203f, -0.02835317f, 0.02555345f, 0.03917428f, -0.28820744f, 0.10744236f, 0.09833550f, -0.11423855f, 
    0.09937002f, -0.07830013f, 0.06743740f, 0.00084908f, 0.04822166f, 0.03215924f, -0.02147549f, 0.05173171f, 
    -0.41784349f, -0.06974429f, -0.08144490f, 0.27487487f, 0.09491541f, 0.06397928f, 0.05980006f, 0.05444001f, 
    0.03768883f, 0.03496061f, 0.09328549f, 0.03103822f, -0.26667601f, -0.86956900f, -0.17632832f, -0.39460647f, 
    -0.08170880f, -0.20054546f, 0.03426079f, -0.19988091f, 0.01474045f, -0.00604140f, -0.02872040f, -0.10659482f, 
    0.19651499f, -0.02660830f, -0.02300915f, -0.17716323f, 0.00853782f, 0.01459103f, 0.08183511f, -0.06726683f, 
    0.05182148f, -0.08694655f, 0.14278249f, -0.16929118f, -0.53342837f, -0.72899616f, -0.43528551f, 0.39384314f, 
    0.03239862f, -0.03594483f, -0.01878418f, -0.22671910f, -0.03949110f, 0.03237247f, -0.04369028f, 0.07125222f, 
    -0.05947278f, 0.00411101f, 0.35995904f, -0.32604817f, 0.01670597f, 0.02262002f, -0.09008709f, 0.03266642f, 
    -0.05465796f, -0.05371540f, 0.01418144f, -0.23482987f, 0.19205692f, 0.23973306f, -0.07244222f, 0.08502425f, 
    -0.07510539f, 0.10699674f, 0.00215802f, 0.14308622f, -0.06135741f, -0.05952988f, -0.02836054f, -0.05233128f, 
    -0.07661637f, -0.10177997f, 0.14123698f, -0.14802556f, -0.00877783f, -0.02723798f, -0.03057500f, 0.08941720f, 
    0.03318652f, 0.16936205f, 0.12462965f, 0.09371356f, -0.36969483f, -0.13278471f, -0.27588683f, -0.04793746f, 
    -0.07645389f, 0.07823572f, -0.11765619f, -0.03171302f, 0.00112476f, -0.05724875f, 0.01641161f, 0.09763157f, 
    0.16892256f, -0.03676711f, -0.08889411f, -0.51538068f, 0.00838229f, 0.00667137f, 0.12290704f, 0.06923540f, 
    -0.04079834f, -0.02869112f, -0.00628711f, 0.00670594f, -0.29064792f, -0.04071598f, 0.05040342f, 0.25485656f, 
    0.12665901f, 0.02148105f, 0.00478508f, -0.07451153f, 0.04513564f, -0.03800257f, 0.02742777f, 0.05479341f, 
    -0.40239006f, -0.55518699f, -0.24854241f, -0.02811377f, -0.21995747f, -0.03264608f, -0.18775344f, 0.05359194f, 
    -0.00946955f, -0.00164520f, 0.04342250f, -0.02045200f, -0.26617303f, -0.40611538f, 0.02380219f, -0.13952351f, 
    -0.14632294f, -0.07938600f, 0.01623565f, 0.07678469f, 0.01054556f, 0.04027760f, 0.15479331f, 0.01388890f, 
    -0.05242884f, 0.02806899f, 0.07609380f, 0.04043248f, -0.08255225f, 0.06648196f, -0.19633633f, 0.04569047f, 
    0.09283281f, -0.13504098f, 0.07199995f, -0.12098364f, -0.17515162f, 0.06319227f, 0.22273652f, 0.10555729f, 
    -0.06708908f, 0.08829193f, 0.10850983f, 0.02935202f, -0.03027895f, 0.13087219f, -0.01462068f, 0.12519744f, 
    -0.04024493f, 0.45663095f, -0.01259385f, 0.09291209f, -0.01238040f, -0.00159187f, -0.06497695f, 0.15011062f, 
    0.13569552f, -0.06182283f, 0.14619377f, 0.05360378f, -0.03077841f, 0.23124446f, 0.09753843f, 0.25623104f, 
    -0.06794995f, -0.00086210f, 0.05074338f, 0.31759512f, 0.07526454f, 0.15077098f, -0.10088056f, 0.04546656f, 
    -0.14569826f, 0.19803864f, 0.13167955f, 0.02617551f, 0.00011159f, -0.02776102f, -0.19321710f, 0.11540465f, 
    -0.03453756f, -0.07543600f, -0.05085884f, -0.07716577f, 0.29366073f, 0.23620811f, -0.05716465f, -0.05374232f, 
    0.03563451f, 0.06572264f, -0.01866606f, 0.04126516f, 0.14695677f, -0.04401604f, 0.08999124f, -0.06542142f, 
    -0.06978597f, 0.08291505f, 0.35653999f, 0.14872254f, 0.01011223f, -0.10332345f, 0.00346248f, -0.09415907f, 
    -0.13554867f, 0.13308097f, -0.01056411f, 0.04653740f, 0.03257504f, 0.04412141f, 0.25358197f, -0.04618822f, 
    0.02199219f, 0.08627140f, 0.02617642f, 0.01847089f, -0.02842195f, 0.12177781f, 0.16120014f, 0.01731769f, 
    -0.33206931f, -0.57378757f, -0.34058952f, -0.08782356f, 0.03381057f, 0.12098673f, 0.08186840f, -0.26561698f, 
    0.06597386f, -0.03951087f, 0.00439213f, -0.04041807f, 0.07328261f, -0.16149600f, -0.28929305f, 0.05481872f, 
    0.05953509f, -0.07793570f, 0.09304877f, 0.02179583f, -0.00589062f, 0.01088393f, 0.02891654f, -0.04529980f, 
    -0.29159501f, -0.21672046f, -0.41703540f, -0.12615061f, 0.00480020f, 0.15268429f, 0.17685282f, -0.02089607f, 
    0.07422890f, -0.03726000f, 0.00065502f, 0.07210950f, 0.05455927f, 0.09935340f, -0.00640459f, -0.02526731f, 
    -0.02803899f, 0.06374171f, -0.00731774f, 0.05492894f, 0.06522727f, -0.00615892f, 0.18160002f, 0.10789638f, 
    -0.03787921f, -0.10919919f, -0.25679544f, 0.08819522f, -0.05183604f, -0.00511810f, 0.04725130f, 0.03880047f, 
    0.00652350f, 0.08955814f, 0.18829270f, 0.12377623f, -0.06371188f, -0.09230436f, 0.01842267f, -0.12354363f, 
    0.04629186f, -0.09106112f, -0.14969039f, 0.16114746f, -0.07610367f, 0.08339038f, 0.01989018f, -0.12603533f, 
    -0.43473640f, -0.50970411f, -0.44966310f, -0.11573671f, -0.23059018f, -0.09436898f, -0.09032435f, -0.31167871f, 
    -0.08758551f, 0.01086430f, -0.01382504f, 0.05519971f, 0.21291821f, -0.01635192f, -0.13017136f, -0.12329414f, 
    0.02950621f, 0.05142927f, 0.09011317f, -0.06377466f, 0.02901053f, -0.02487087f, 0.07290644f, -0.21451634f, 
    0.12825312f, 0.04759923f, -0.03715885f, -0.09290970f, -0.06963855f, 0.03816777f, 0.02354762f, 0.08490048f, 
    -0.04507659f, 0.06403475f, 0.03918274f, 0.03734661f, -0.29736072f, -0.21105786f, -0.34649003f, 0.05348947f, 
    -0.09975406f, 0.23042384f, 0.18646088f, -0.16414244f, -0.00803065f, 0.01967393f, 0.08604259f, 0.04959565f, 
    -0.24108186f, 0.16658632f, 0.02069601f, -0.03935438f, -0.00340154f, 0.05005065f, 0.06766716f, -0.13997306f, 
    0.13610622f, 0.08063791f, 0.07850182f, -0.12922500f, -0.38458580f, -0.31590551f, -0.28202674f, 0.11742978f, 
    0.02324272f, 0.02825999f, 0.11305971f, -0.14205521f, 0.02696954f, -0.04763898f, 0.11846470f, -0.00723947f, 
    -0.24522214f, 0.04883936f, 0.14604211f, 0.12398847f, -0.04271464f, 0.00464868f, -0.07085214f, 0.16477865f, 
    -0.01629007f, 0.05927772f, 0.16711169f, -0.12541299f, -0.65987247f, 0.27957419f, 0.28743654f, -0.25748840f, 
    -0.05885013f, 0.03668043f, -0.21327764f, -0.23677015f, -0.09913259f, -0.02177355f, -0.03116878f, 0.00606482f, 
    0.03238370f, 0.02613521f, 0.04048338f, -0.02952919f, 0.00060574f, -0.01157854f, 0.04340769f, -0.01110363f, 
    0.03037819f, 0.01347868f, -0.00660170f, 0.13577624f, 0.05475235f, 0.08249448f, 0.02734181f, -0.03696048f, 
    0.03367527f, -0.03641663f, 0.02296801f, -0.02267944f, 0.07696612f, 0.00030105f, 0.17490995f, 0.19872783f, 
    -0.09169614f, 0.00664583f, -0.25716200f, 0.15910219f, -0.03124680f, -0.10320622f, -0.04675531f, 0.09208011f, 
    0.01967084f, -0.07241025f, 0.06541366f, -0.02289982f, -0.31764030f, 0.00285411f, -0.10661336f, 0.31507435f, 
    0.00090235f, 0.00949191f, 0.04836872f, -0.27262932f, 0.06295374f, 0.00073359f, -0.08997737f, 0.02687124f, 
    0.05119228f, -0.01365447f, 0.12116512f, 0.04426849f, 0.07620854f, 0.03941810f, -0.06458212f, 0.04523620f, 
    0.00186401f, 0.11565425f, 0.13040200f, 0.04394249f, -0.03295898f, 0.08502074f, 0.20878913f, 0.06827354f, 
    -0.05998426f, 0.00869007f, 0.06788284f, -0.00483802f, -0.04448710f, 0.01331590f, 0.03354321f, 0.02604563f, 
    0.03417549f, -0.01645584f, -0.08847794f, -0.04137677f, -0.03055491f, 0.03557184f, -0.01495493f, 0.04209229f, 
    -0.10295147f, -0.09055538f, 0.07886048f, -0.02241839f, -0.47119409f, -0.65390491f, 0.07786731f, 0.10622802f, 
    0.02206511f, -0.07616751f, 0.07361045f, -0.44047201f, -0.01671945f, -0.05542659f, -0.06219502f, 0.01295373f, 
    -0.02502010f, 0.13570060f, -0.06625097f, -0.07994044f, 0.08021698f, -0.02676284f, 0.08600884f, -0.00674689f, 
    0.04169178f, 0.18581168f, -0.06090993f, -0.08770776f, -0.31221423f, 0.03897578f, 0.27791387f, 0.41278246f, 
    0.01731844f, -0.12157384f, 0.02656701f, -0.05123083f, 0.00781134f, 0.00722122f, 0.03353033f, 0.12301967f, 
    -0.07781534f, 0.17603721f, 0.09292190f, -0.00716729f, -0.01572596f, 0.01713190f, 0.02555186f, 0.20337246f, 
    0.07548889f, 0.11124697f, 0.00779446f, 0.10087186f, -0.22553171f, -0.01201164f, 0.09370510f, 0.21290348f, 
    -0.04573053f, 0.09193357f, -0.07398737f, 0.04196156f, 0.06718438f, 0.10599781f, 0.16744791f, -0.01976769f, 
    0.30066055f, -0.10851615f, -0.13965127f, 0.14669587f, -0.14822826f, -0.01021824f, 0.04194440f, 0.02579282f, 
    0.19933918f, -0.08533499f, 0.18170968f, -0.15249088f, -0.02777676f, 0.01907157f, -0.03389273f, -0.00462163f, 
    -0.04111375f, 0.00195284f, 0.06455237f, -0.05984702f, -0.14628753f, 0.02023315f, -0.14645961f, 0.12628196f, 
    -0.12563165f, -0.23183860f, -0.10160904f, 0.00408660f, -0.23586084f, -0.07258917f, 0.02035546f, -0.23402368f, 
    -0.00257087f, -0.02369211f, -0.05980448f, -0.01165835f, -0.22548176f, 0.40289143f, -0.33417219f, -0.08946560f, 
    -0.05566794f, -0.08018760f, 0.04753217f, 0.35677141f, 0.12483013f, 0.05027154f, 0.15148583f, -0.08764505f, 
    0.35127282f, 0.00023572f, 0.08302555f, -0.30570704f, -0.04422008f, 0.07596440f, -0.05454869f, 0.12585732f, 
    0.00871652f, 0.07500187f, 0.01120427f, -0.14623241f, 0.01410419f, 0.09134883f, 0.01786495f, -0.01625728f, 
    0.05718555f, -0.04487749f, 0.01744320f, -0.04509358f, 0.05780583f, -0.01432087f, -0.02389627f, -0.04044539f, 
    -0.36430553f, -0.27890885f, -0.10530183f, 0.13947999f, 0.03304183f, -0.24241562f, 0.01210036f, -0.06869710f, 
    -0.00481950f, 0.05587425f, -0.04583701f, 0.00815919f, 0.03575139f, 0.24246462f, 0.06962630f, 0.08961043f, 
    -0.14193949f, 0.09866406f, 0.07624289f, 0.05243484f, -0.01335721f, 0.03770696f, -0.00907741f, -0.05743871f, 
    -0.31659749f, -0.34290546f, -0.22021897f, -0.07815593f, -0.02161112f, -0.10766970f, -0.13643987f, 0.10143509f, 
    0.04053465f, -0.02846599f, 0.00144936f, -0.01473534f, 0.08092013f, 0.08558410f, 0.24264297f, -0.17542928f, 
    0.01108417f, -0.01224796f, 0.00346875f, 0.04566933f, -0.01838110f, 0.20343958f, -0.05142603f, 0.02808180f, 
    -0.06491248f, 0.09941190f, -0.08737401f, -0.05757969f, -0.01186635f, 0.06717277f, -0.10107632f, 0.09220448f, 
    0.05056274f, 0.01600328f, 0.04991825f, 0.03792317f, 0.55022925f, -0.44664329f, -0.52991086f, -0.31183535f, 
    -0.07521762f, -0.07140484f, 0.00338718f, -0.05985526f, 0.01846936f, 0.06360312f, 0.09266745f, 0.03955059f, 
    0.30923149f, 0.01770824f, -0.09572763f, -0.27396938f, 0.04445401f, -0.04411874f, 0.01395225f, 0.00260059f, 
    0.10188778f, 0.04143124f, 0.05132528f, -0.22571158f, -0.12347345f, 0.12755114f, -0.10038125f, 0.04067275f, 
    -0.20299667f, 0.00094518f, -0.12189198f, -0.01476233f, -0.01458170f, 0.00146415f, -0.00939434f, -0.02650726f, 
    -0.20493902f, -0.11144898f, -0.24622047f, 0.29559860f, 0.07234871f, 0.00464211f, -0.02534533f, -0.02089114f, 
    0.05512738f, 0.03018684f, 0.02945730f, -0.00023908f, 0.26693445f, -0.24949425f, -0.09519868f, -0.09128973f, 
    -0.02473348f, -0.04928933f, -0.05438622f, -0.04693394f, 0.11405564f, 0.09886295f, 0.01995892f, -0.03468667f, 
    -0.36807156f, 0.31907707f, 0.13117026f, 0.24607991f, 0.05672771f, 0.02751582f, 0.00428927f, -0.00551742f, 
    -0.09696373f, -0.02332775f, -0.03316669f, 0.12517217f, -0.02597702f, 0.27813604f, -0.08929127f, 0.12330242f, 
    0.17864782f, -0.19000192f, 0.09248570f, -0.13443069f, 0.01155249f, 0.01642242f, 0.07476688f, 0.05948706f, 
    0.16970716f, -0.06509648f, -0.07058652f, -0.20720485f, -0.01120402f, 0.14091358f, 0.02121470f, 0.00113526f, 
    -0.10919852f, 0.06808867f, -0.04265525f, 0.00461763f, -0.50984383f, -0.37892988f, -0.46408105f, 0.72549695f, 
    0.02518626f, -0.07652423f, -0.03964459f, 0.02910939f, -0.05075457f, -0.01812068f, 0.08673874f, 0.01294222f, 
    0.05823713f, 0.01562630f, 0.06669307f, -0.06704398f, -0.04026456f, -0.02333107f, 0.00494458f, -0.03016214f, 
    -0.00492057f, -0.03906326f, -0.01707500f, -0.08283443f, -0.10720643f, -0.43904787f, 0.57478052f, -0.39013162f, 
    -0.11611262f, -0.05170494f, 0.11131314f, 0.11266308f, -0.09710761f, -0.04765124f, 0.03209900f, -0.03544465f, 
    0.18339498f, -0.05496737f, 0.11778921f, 0.01464479f, 0.05623711f, 0.10780951f, -0.15852186f, 0.09145496f, 
    0.02465014f, -0.02893053f, -0.04027577f, 0.08138402f, -0.10364243f, 0.05548226f, -0.00133092f, -0.04418000f, 
    -0.06980312f, 0.04661817f, 0.05897262f, -0.07215860f, 0.02605815f, -0.09093648f, 0.04457676f, -0.12432585f, 
    0.46621767f, -0.08816199f, 0.13935509f, -0.40259400f, -0.03254722f, 0.09274668f, -0.07131146f, 0.05861102f, 
    -0.05599175f, -0.05986380f, 0.04153698f, -0.05021356f, -0.37283173f, 0.30750459f, -0.37750420f, -0.29198033f, 
    0.03938987f, 0.00137290f, 0.12617399f, -0.10098158f, -0.03038589f, -0.03912700f, -0.00571234f, 0.03723923f, 
    -0.14393066f, 0.26392478f, -0.20817097f, -0.04043873f, -0.06424123f, -0.00912159f, 0.02864187f, -0.05755457f, 
    0.05880422f, 0.00881915f, 0.05661310f, -0.02193172f, 0.02127840f, 0.02495239f, 0.08203549f, -0.19235976f, 
    0.04292218f, -0.00894962f, 0.04255568f, -0.02714902f, -0.07141678f, -0.01047602f, -0.00166025f, -0.06165006f, 
    -0.24653977f, -0.21826842f, -0.26925477f, -0.06029696f, -0.01244208f, -0.10070001f, 0.02266322f, 0.09633862f, 
    0.01315682f, -0.02327063f, -0.04448401f, 0.01633398f, 0.08987234f, -0.38423663f, -0.51502478f, -0.21033226f, 
    0.05933177f, -0.01734580f, 0.19346942f, 0.05883393f, 0.07721566f, -0.00844863f, 0.05587471f, 0.01920862f, 
    0.10150204f, 0.03920105f, -0.09562922f, -0.04527346f, 0.00278060f, -0.04808221f, 0.08069018f, -0.00716763f, 
    -0.02894874f, -0.07136129f, 0.01112213f, 0.00897081f, 0.17235920f, -0.31573814f, -0.20774393f, -0.35530737f, 
    -0.14040069f, -0.02484036f, -0.05025594f, 0.06306800f, 0.05794650f, -0.04835046f, -0.02355317f, -0.04373023f, 
    -0.12781253f, -0.14042518f, -0.18643099f, -0.06926226f, -0.06932790f, -0.05947261f, 0.04569625f, -0.03187725f, 
    -0.12463310f, 0.05327268f, -0.07542013f, 0.04108146f, -0.23648939f, -0.12727104f, -0.10981497f, -0.18254167f, 
    -0.16375002f, -0.11039963f, 0.02142507f, -0.16494374f, -0.02217257f, 0.01002467f, -0.02061974f, -0.01309704f, 
    -0.01122511f, -0.04124755f, 0.03766872f, -0.01603961f, -0.03870165f, -0.13485149f, 0.11593958f, -0.04150619f, 
    0.02631419f, -0.02593393f, 0.00694763f, 0.05578791f, -0.01401136f, -0.11993229f, -0.04321846f, 0.01464990f, 
    0.04123072f, -0.01072845f, -0.01093854f, 0.00863860f, -0.01268902f, -0.02580368f, 0.05709859f, -0.02489750f, 
    0.19116209f, -0.12105282f, -0.06627780f, -0.04469671f, 0.04317838f, -0.01707415f, -0.02107272f, 0.00859971f, 
    -0.02685926f, 0.02332042f, 0.05314085f, 0.06353623f, -0.11545738f, 0.06149806f, 0.05889112f, 0.23735780f, 
    -0.02000377f, 0.04508285f, -0.02096424f, 0.09862735f, -0.02600671f, -0.08724654f, -0.10445447f, -0.03101760f, 
    -0.42025998f, -0.09541979f, 0.01735835f, 0.21491517f, 0.04221978f, 0.01084445f, -0.00426878f, 0.03512688f, 
    -0.01071456f, -0.05541679f, 0.03583143f, -0.05693435f, 0.34407875f, -0.29279208f, 0.12295388f, -0.14141618f, 
    0.01978537f, 0.04165969f, -0.11204004f, -0.01008687f, 0.03121004f, 0.07065054f, -0.12104116f, -0.05738946f, 
    -0.38881060f, 0.01233707f, -0.01290018f, -0.02603381f, -0.06996069f, 0.06533948f, 0.26916739f, 0.05550003f, 
    -0.03921900f, -0.02307345f, -0.04406407f, -0.03467440f, -0.02779092f, -0.06584703f, -0.18012050f, 0.09083424f, 
    -0.04610015f, 0.00147556f, 0.00152568f, -0.00003665f, 0.11754718f, -0.00407057f, -0.00187814f, 0.07107695f, 
    0.02482474f, -0.15643914f, 0.16263667f, -0.17609105f, 0.06392035f, -0.08573678f, -0.02203323f, -0.03863284f, 
    0.10245103f, 0.05286816f, -0.00052084f, 0.11306126f, -0.02042869f, 0.16279571f, -0.18867993f, 0.08856887f, 
    -0.14501213f, -0.05209597f, 0.05032026f, -0.06193882f, -0.02315676f, 0.00113839f, -0.07471898f, -0.08851875f, 
    0.01615130f, -0.28290462f, 0.21940260f, 0.31955639f, -0.00512713f, -0.08451565f, -0.04899145f, 0.07276168f, 
    -0.04226347f, -0.08792167f, -0.04518090f, -0.04012400f, -0.00172287f, -0.05822441f, 0.03290681f, -0.02106199f, 
    -0.01010242f, 0.00507199f, -0.01736232f, -0.01840776f, 0.04656145f, -0.01361882f, 0.04231152f, 0.04661586f, 
    0.12591003f, -0.05015345f, -0.00063415f, 0.02608613f, -0.02646643f, -0.11335474f, -0.01603239f, -0.16954193f, 
    -0.09179956f, -0.05236692f, -0.04444289f, -0.11041982f, 0.17547907f, -0.14538312f, -0.28722960f, 0.14454885f, 
    -0.02267930f, -0.08592582f, 0.06909043f, 0.06832849f, -0.04272649f, 0.09111006f, 0.03592001f, 0.02989580f, 
    -0.03948927f, 0.01154504f, -0.11301744f, 0.06628281f, 0.00825973f, -0.12924251f, 0.07121680f, -0.02414829f, 
    -0.06610800f, 0.04812133f, 0.05029055f, -0.10356657f, -0.22119732f, -0.13607082f, 0.39135301f, -0.12619296f, 
    -0.12274134f, -0.01162614f, 0.05134694f, 0.09894994f, -0.10543679f, 0.03947070f, -0.10218391f, -0.08511602f, 
    0.38139963f, 0.01840597f, -0.25369751f, -0.12387094f, 0.03287942f, -0.02257212f, -0.00105912f, -0.06598619f, 
    -0.13945957f, 0.04779724f, -0.13087000f, -0.17964877f, -0.16251189f, -0.25413167f, -0.08353828f, -0.01440604f, 
    0.12497269f, -0.00116398f, 0.06268125f, 0.12458041f, 0.00827727f, -0.05961146f, 0.01553801f, 0.03288384f, 
    0.10455301f, 0.03994851f, -0.14471447f, 0.05602613f, 0.03034008f, -0.01342980f, 0.03865227f, -0.06712395f, 
    0.00450064f, 0.01281604f, -0.01405944f, -0.15849857f, 0.06776188f, 0.07320277f, -0.00368602f, 0.09200982f, 
    -0.02409116f, -0.04108902f, -0.00387918f, 0.00424613f, 0.07628410f, 0.08411098f, 0.03177961f, 0.04446960f, 
    -0.02713761f, -0.27897370f, -0.05722806f, -0.11726057f, 0.08162818f, 0.03338813f, 0.08403382f, -0.00844835f, 
    0.02370722f, 0.08009533f, 0.00051566f, -0.08856062f, -0.11668693f, -0.12319155f, -0.04681701f, -0.09166852f, 
    -0.03175670f, -0.16868912f, -0.00687188f, -0.04369696f, -0.04274072f, 0.01384637f, -0.03342178f, -0.01205402f, 
    0.06458672f, 0.01276041f, -0.00516405f, -0.14128460f, 0.04598531f, 0.02676920f, -0.02922788f, -0.01430466f, 
    0.02873913f, -0.11913107f, -0.12859851f, -0.19153361f, 0.21247754f, -0.33562210f, -0.16173692f, -0.19636753f, 
    -0.10513604f, -0.02452324f, -0.01303721f, 0.04986316f, 0.15897399f, -0.02715725f, -0.06864422f, 0.06299467f, 
    0.03795264f, -0.00477297f, 0.06558227f, 0.09299147f, 0.03160252f, -0.00272675f, 0.01501731f, -0.04246182f, 
    -0.05987163f, 0.02913134f, -0.00195596f, 0.05834247f, -0.49494356f, -0.39149860f, 0.44280049f, -0.14779849f, 
    -0.06648191f, 0.01909524f, 0.01191864f, 0.06199127f, -0.01138885f, -0.00600559f, -0.04173499f, -0.00043579f, 
    -0.19983444f, 0.08855106f, 0.09616795f, 0.08043195f, -0.00456923f, -0.10085928f, 0.07971030f, 0.03772906f, 
    -0.01206008f, 0.05076373f, 0.03191467f, -0.07963862f, 0.43448982f, -0.41613728f, -0.13632724f, -0.19779830f, 
    -0.09272917f, 0.02330524f, -0.33891895f, -0.04291271f, 0.12888148f, -0.03553938f, 0.03399052f, 0.02340119f, 
    -0.01735361f, -0.08619069f, -0.02812836f, -0.12983119f, -0.10470798f, -0.08178283f, 0.04502248f, 0.05913613f, 
    -0.07356410f, -0.00823619f, -0.06004620f, -0.05206938f, 0.47810420f, 0.13567382f, 0.08752120f, 0.14553516f, 
    0.06182178f, -0.00621698f, 0.01565278f, -0.01355550f, 0.09215841f, -0.01313405f, -0.02208611f, 0.05851415f, 
    0.02834120f, 0.10873126f, 0.08589115f, 0.00157767f, -0.01613305f, 0.02735983f, -0.00622274f, -0.03403111f, 
    -0.09923904f, -0.00047624f, -0.10166092f, -0.02442690f, 0.02838887f, 0.05513089f, -0.25706726f, 0.01938453f, 
    0.00342161f, -0.05140430f, -0.02670622f, -0.04669446f, -0.18102610f, 0.03968464f, 0.06631061f, -0.01870468f, 
    0.02121949f, -0.12978606f, -0.04608851f, 0.01654171f, 0.05460149f, -0.09120772f, -0.01470444f, -0.13874532f, 
    0.09469120f, 0.03299236f, 0.01155291f, 0.03826948f, 0.18851893f, -0.49538225f, -0.08658863f, -0.00790741f, 
    0.15580070f, -0.17775731f, 0.06793348f, -0.16824295f, -0.06082854f, 0.19696979f, -0.04093927f, -0.00734534f, 
    0.05034263f, -0.12934451f, -0.21759069f, 0.14848748f, 0.01108743f, -0.12044736f, 0.00075794f, 0.00223947f, 
    0.16977099f, 0.08572053f, 0.02988010f, -0.00743843f, -0.27971607f, 0.10503691f, 0.05545431f, -0.16383733f, 
    -0.04817735f, -0.05250873f, -0.04651246f, -0.06114299f, -0.10507946f, 0.00395614f, 0.01485856f, 0.08265873f, 
    0.05814929f, -0.03555031f, -0.06346390f, 0.38136417f, 0.11490046f, 0.01258337f, 0.14688461f, -0.03694569f, 
    0.05607583f, -0.02032864f, 0.00966912f, 0.08325417f, -0.51775503f, -0.02842015f, 0.06294328f, -0.06058933f, 
    -0.15204182f, -0.05892862f, -0.13701627f, -0.00351691f, -0.00213448f, 0.09408148f, 0.07066622f, 0.16932142f, 
    0.05668948f, -0.35544291f, -0.26991409f, 0.01744901f, -0.03658039f, 0.04160299f, -0.00732964f, -0.10472314f, 
    -0.05950494f, -0.00059207f, 0.02588256f, 0.10715469f, 0.09027787f, -0.00795719f, -0.16367510f, -0.05801887f, 
    0.02717424f, -0.00877574f, 0.04021249f, -0.03737848f, 0.00202227f, -0.06321722f, -0.14550492f, -0.23589301f, 
    -0.34352759f, 0.00272847f, 0.10328367f, 0.12151784f, -0.01521748f, -0.05776372f, -0.05949506f, 0.03038929f, 
    -0.14152032f, -0.06065728f, -0.01135245f, -0.05056433f, -0.23819058f, -0.28016073f, -0.51463789f, 0.08462275f, 
    0.12166100f, 0.15227363f, 0.07448833f, 0.12806062f, 0.07626843f, -0.01969339f, 0.00154874f, 0.05471523f, 
    0.10002935f, -0.01877157f, -0.25470731f, -0.42821950f, -0.07678263f, -0.06031553f, -0.05716822f, -0.01302376f, 
    0.08031308f, 0.03098966f, 0.16456208f, 0.04439121f, -0.09764200f, 0.21855778f, 0.10843381f, -0.03518873f, 
    0.05216838f, -0.17414252f, 0.07130985f, 0.02489043f, 0.14136256f, 0.04854128f, 0.09352399f, -0.02712658f, 
    -0.16754200f, -0.38029256f, -0.23664382f, 0.06362790f, -0.09347721f, 0.10818595f, -0.08535819f, 0.17685547f, 
    -0.04561706f, -0.00237794f, 0.03712791f, 0.00835196f, 0.11361092f, 0.09726562f, -0.24591345f, -0.16738133f, 
    -0.00967735f, -0.03740154f, 0.05816724f, 0.03710737f, -0.02009499f, -0.05686818f, -0.22670326f, -0.13263054f, 
    -0.44950616f, -0.46783632f, -0.35649619f, -0.32039222f, -0.05709077f, -0.01060936f, -0.03196732f, 0.08840410f, 
    0.06581140f, 0.07247713f, 0.03143933f, -0.09028696f, -0.07012790f, -0.00948117f, -0.09526627f, -0.03525180f, 
    -0.07299747f, -0.04158713f, 0.01414261f, 0.05568876f, -0.06068486f, 0.10755400f, 0.01883407f, 0.19885843f, 
    0.18955764f, -0.01243443f, -0.09749974f, -0.23362774f, -0.06533214f, -0.00320679f, -0.03058655f, -0.11132331f, 
    0.11030462f, -0.12057815f, -0.12138972f, 0.03232174f, 0.32326287f, -0.30613503f, -0.32941899f, -0.13358477f, 
    0.17719792f, -0.05963138f, 0.02768577f, 0.22426836f, -0.02304802f, 0.15264732f, 0.17930414f, 0.04764762f, 
    -0.41120887f, 0.01941070f, 0.15947881f, -0.05565821f, -0.03026705f, -0.04966003f, -0.01896733f, -0.04564155f, 
    -0.08211069f, -0.05006239f, 0.02322777f, 0.13177463f, 0.39561766f, -0.00627472f, -0.35384738f, -0.02487870f, 
    0.06648054f, -0.03379765f, 0.02523445f, -0.32918918f, 0.04631984f, -0.03506900f, 0.06437022f, 0.11765121f, 
    -0.00285153f, -0.19417711f, -0.21382675f, -0.01357196f, 0.08387191f, -0.13732652f, 0.08440086f, 0.00321491f, 
    -0.06552598f, -0.01433642f, -0.04734257f, 0.07785400f, -0.00739810f, 0.18670690f, -0.01985022f, 0.16674151f, 
    0.05873990f, 0.02787389f, -0.05269992f, -0.00823145f, -0.06249166f, 0.08462474f, -0.05109444f, 0.10451616f, 
    0.06756105f, -0.27779746f, -0.34505337f, -0.18831603f, 0.10596287f, -0.07498661f, 0.00351978f, 0.02508744f, 
    0.05062595f, 0.12307771f, 0.01899001f, 0.08279590f, 0.14787573f, -0.42459375f, -0.21149403f, 0.23989438f, 
    -0.06853732f, 0.10309037f, 0.18425854f, -0.05477473f, 0.02484490f, 0.01304227f, 0.07554279f, -0.02998028f, 
    -0.48177183f, 0.13954282f, 0.15635902f, 0.18515691f, 0.09061282f, -0.06293210f, -0.02399161f, 0.04867923f, 
    0.04104213f, -0.19864997f, 0.01883052f, 0.06818277f, -0.15230046f, 0.01999446f, -0.02772857f, 0.04307213f, 
    -0.18732181f, 0.02142583f, 0.03077378f, -0.08005492f, -0.00314111f, -0.01596787f, 0.00805663f, 0.11449295f, 
    -0.06311031f, -0.37341067f, -0.42940605f, -0.28432164f, -0.04997801f, 0.00207697f, 0.06814643f, -0.10991068f, 
    0.02934443f, -0.03525296f, -0.02820077f, -0.04158290f, -0.11713721f, -0.55524147f, -0.17266129f, 0.12576389f, 
    -0.13969868f, 0.05988627f, 0.05267549f, 0.07132683f, -0.06396101f, 0.11440894f, -0.03836961f, -0.10341746f, 
    0.00188958f, -0.02298433f, 0.04109935f, 0.03430982f, -0.01342103f, -0.00053575f, 0.02763384f, -0.04577044f, 
    0.03256536f, 0.08606356f, 0.10271215f, 0.12975395f, -0.05272146f, -0.13365041f, -0.13877667f, 0.09092598f, 
    0.11672553f, 0.10618330f, 0.10685492f, 0.14307518f, -0.10908294f, -0.03430844f, -0.11994624f, -0.16138062f, 
    -0.16194490f, -0.30445001f, 0.11998006f, 0.06662403f, -0.05909770f, 0.09413074f, 0.06169973f, 0.02545742f, 
    0.12788837f, 0.03731051f, 0.13479653f, 0.02571506f, -0.02889007f, -0.36754036f, -0.17642845f, 0.07881071f, 
    0.16852784f, -0.00088714f, 0.11277721f, 0.06406076f, -0.11090556f, -0.05127792f, -0.11690601f, 0.07375696f, 
    0.01771500f, -0.13547049f, -0.05715058f, -0.04246954f, 0.00526457f, 0.04880952f, 0.06152923f, -0.05016540f, 
    0.00222442f, 0.15049070f, 0.13074294f, 0.08035401f, -0.20852205f, -0.15027465f, -0.09854523f, -0.08505927f, 
    0.02294313f, -0.01740777f, -0.08434853f, 0.02774317f, -0.13368632f, -0.24891534f, -0.14597321f, -0.23184833f, 
    -0.18977925f, -0.34711975f, -0.15535533f, 0.10361950f, 0.04301022f, 0.06515908f, 0.09592531f, 0.03526457f, 
    0.11489553f, 0.00876383f, 0.07959270f, -0.00996331f, -0.34098557f, -0.14263555f, 0.11071259f, 0.16585127f, 
    -0.06609109f, -0.06424704f, -0.14102264f, 0.11451206f, 0.05959761f, 0.11952852f, 0.01277536f, -0.21785265f, 
    -0.11649003f, 0.06500732f, 0.04286247f, 0.04814470f, 0.08867582f, 0.06503406f, -0.06925885f, 0.03981449f, 
    0.00705347f, 0.06112415f, 0.01286204f, 0.01631556f, 0.54256546f, 0.01000559f, -0.06894909f, -0.30083454f, 
    0.22194169f, -0.15403354f, -0.00951759f, -0.07996925f, 0.00298018f, 0.11091963f, 0.09458938f, 0.07776438f, 
    -0.00900665f, -0.26129881f, -0.14239398f, 0.12873247f, 0.02797825f, 0.05102466f, 0.03339188f, -0.00447012f, 
    -0.03387504f, -0.11841349f, -0.07055584f, -0.06954831f, -0.08621587f, -0.12889738f, 0.03703891f, 0.06481958f, 
    0.06767970f, 0.05239082f, 0.02024905f, 0.05559646f, -0.19749074f, 0.01744376f, -0.19386175f, -0.55163759f, 
    0.15675355f, 0.01985615f, 0.10842300f, -0.05841210f, -0.00584759f, -0.02168945f, 0.05988468f, 0.01221051f, 
    -0.02859984f, -0.02841901f, -0.11317157f, -0.12663367f, 0.24628767f, 0.02575076f, -0.33521453f, -0.05412044f, 
    0.04032757f, -0.03482485f, -0.05409201f, 0.00184929f, 0.04310710f, 0.12143014f, 0.07256845f, 0.13197528f, 
    0.22027619f, 0.28366941f, -0.55956864f, -0.47644323f, -0.04627224f, -0.13326579f, -0.01285984f, 0.01979021f, 
    0.03071639f, 0.08538640f, -0.04235520f, 0.11837058f, -0.16923891f, 0.11466026f, 0.02185344f, 0.00398306f, 
    -0.01559445f, -0.01446790f, 0.03360575f, 0.04476033f, -0.10682376f, 0.03160742f, 0.03999953f, 0.02192263f, 
    0.11510141f, -0.05590671f, -0.02221272f, -0.09478188f, 0.07448891f, 0.04762643f, -0.00592312f, 0.02011519f, 
    0.01018330f, 0.10120672f, 0.05402253f, -0.06867705f, 0.43736213f, 0.26621240f, 0.08407030f, 0.00326584f, 
    0.14749157f, 0.16736393f, -0.05683600f, 0.08530103f, 0.03804657f, -0.03739740f, -0.05785910f, 0.02287970f, 
    0.04025125f, -0.27749845f, 0.00310471f, -0.03053923f, -0.10206566f, 0.05395948f, 0.00658965f, -0.04175233f, 
    0.02215047f, 0.05677957f, -0.13229401f, -0.10621197f, -0.42233160f, -0.08195121f, -0.04890710f, -0.03146225f, 
    -0.04260196f, 0.25683436f, 0.14981849f, -0.02233044f, 0.04328040f, 0.08364901f, 0.13585186f, -0.01985739f, 
    0.48956859f, -0.05373872f, -0.28524923f, -0.15913576f, -0.00564071f, -0.00113910f, 0.12261147f, -0.09191432f, 
    0.31964260f, 0.01596429f, -0.08601775f, 0.21863757f, 0.11562637f, -0.40066397f, -0.39478940f, -0.16726299f, 
    -0.09063780f, 0.10688486f, 0.09487716f, 0.05526254f, -0.04628071f, -0.07833126f, -0.05407505f, -0.05875225f, 
    0.06581857f, 0.18852262f, -0.03076578f, 0.01226605f, -0.00686341f, -0.01253361f, 0.00594916f, -0.03103587f, 
    -0.04571850f, 0.03048465f, -0.02647414f, 0.22071213f, -0.32525429f, -0.05940374f, 0.08547908f, 0.12487562f, 
    0.02837574f, -0.02931519f, -0.13465132f, -0.02528649f, -0.03795134f, -0.01348093f, -0.12544355f, -0.13887030f, 
    0.08818340f, -0.17725976f, 0.00686069f, -0.14937998f, -0.03142454f, -0.06549653f, -0.03956107f, -0.15692914f, 
    -0.03487810f, 0.08990312f, 0.11830958f, 0.12961248f, 0.21312718f, -0.05188512f, -0.07244714f, 0.05314050f, 
    0.14507626f, 0.21366362f, 0.08546667f, 0.10884178f, -0.04417175f, -0.00110328f, -0.08077420f, 0.01782648f, 
    -0.06861509f, 0.05812880f, 0.01133528f, -0.06973670f, -0.06026147f, -0.03565985f, 0.03726054f, -0.04682808f, 
    0.03321880f, 0.14767043f, 0.08929776f, 0.02147482f, -0.18737024f, -0.13736837f, -0.03003649f, -0.02172616f, 
    0.06279588f, 0.06712952f, 0.05659032f, 0.12701637f, -0.33215806f, -0.07777926f, -0.19875620f, -0.38407269f, 
    -0.35542488f, -0.04174828f, 0.08998682f, -0.00460442f, -0.05814721f, -0.07651515f, -0.06731266f, -0.11115840f, 
    -0.19720948f, -0.23128562f, -0.09079275f, -0.17348392f, -0.32377830f, 0.12537798f, -0.02901898f, 0.14293426f, 
    0.23587297f, 0.02820848f, 0.02214163f, -0.14964952f, -0.00787367f, 0.02166433f, 0.02140583f, 0.04992741f, 
    -0.34454200f, -0.08842821f, -0.06624001f, 0.17741637f, 0.06920565f, -0.04109462f, 0.06328732f, 0.10815646f, 
    0.07162958f, -0.04804248f, -0.19642064f, -0.06398129f, -0.10921706f, -0.31635040f, -0.28414190f, 0.24283104f, 
    0.03767043f, -0.01230278f, 0.14585637f, 0.08693989f, 0.05093116f, 0.01269050f, 0.05762954f, 0.00051169f, 
    0.20946109f, -0.19799529f, -0.09754100f, -0.00040934f, 0.00973643f, 0.03209987f, 0.05027881f, -0.06200698f, 
    0.07477617f, -0.10882290f, 0.11949150f, -0.01319570f, -0.10614160f, -0.11623165f, 0.00085757f, -0.06547081f, 
    0.01424503f, 0.12264581f, -0.01952602f, 0.02125071f, -0.07969145f, -0.12466815f, -0.07963260f, -0.16676752f, 
    -0.12591995f, 0.01744353f, 0.04860851f, -0.02988262f, 0.00946471f, 0.11412338f, -0.09504022f, 0.16132998f, 
    0.02193966f, -0.12173215f, 0.16538486f, 0.02641516f, 0.01760174f, 0.10713413f, 0.00543324f, 0.09840045f, 
    -0.03599344f, 0.11179852f, 0.13221940f, 0.13843316f, -0.01391898f, 0.01733129f, 0.16009893f, 0.02647044f, 
    -0.08843400f, -0.08777108f, -0.05227000f, 0.00909160f, -0.15192053f, -0.22744654f, -0.01770778f, 0.09624194f, 
    -0.05066102f, -0.01754669f, -0.04437378f, -0.00442554f, 0.49459746f, -0.24279647f, -0.27052599f, -0.17096499f, 
    0.34065652f, -0.02980264f, 0.13519494f, 0.13053821f, 0.06861024f, -0.05976324f, 0.05920154f, 0.23868285f, 
    -0.17860483f, -0.04695345f, -0.01933095f, -0.05987630f, -0.26348469f, 0.13673991f, -0.20205550f, -0.11048120f, 
    0.06863693f, -0.14334142f, -0.20439582f, -0.06227100f, -0.06265192f, -0.06829902f, -0.01831044f, -0.09313989f, 
    0.17066953f, 0.09890559f, 0.13054542f, 0.06595240f, 0.11117680f, 0.08539126f, 0.09347910f, 0.08039492f, 
    -0.22100694f, -0.07605940f, -0.14738266f, -0.18718223f, 0.11229607f, -0.25042000f, -0.13687006f, 0.02265697f, 
    -0.01880089f, 0.02973374f, -0.02063179f, -0.00576148f, -0.22050563f, -0.05901713f, 0.08957168f, -0.10081024f, 
    -0.05827967f, 0.02988346f, 0.05036769f, -0.00664654f, 0.03954443f, -0.05150546f, -0.03409495f, -0.17410581f, 
    -0.33397946f, -0.12128773f, 0.08055747f, -0.33503717f, -0.26386344f, -0.01605054f, -0.10317072f, 0.19433211f, 
    0.05424156f, -0.04352150f, 0.06241794f, -0.07131892f, 0.22835839f, -0.17301245f, 0.00712858f, -0.09686042f, 
    -0.02905973f, 0.03137915f, -0.04945501f, 0.06209607f, 0.03877686f, 0.13920179f, 0.07640468f, 0.08937237f, 
    -0.06800136f, 0.37221292f, -0.34220088f, -0.15409888f, 0.02800526f, 0.01148163f, 0.19331498f, -0.08863255f, 
    0.06281645f, -0.04975579f, -0.07988626f, 0.03761479f, 0.23425494f, 0.25049898f, 0.34028560f, -0.07556900f, 
    0.04274743f, -0.25224808f, -0.19304700f, -0.08962388f, -0.22903669f, 0.03588497f, -0.02742836f, -0.03572369f, 
    -0.27745140f, -0.17787205f, 0.19742860f, 0.38036725f, -0.04010844f, 0.10367392f, -0.19302197f, -0.03207619f, 
    -0.04241496f, 0.06129869f, 0.15061739f, -0.10545718f, -0.01247473f, 0.12417164f, -0.31532156f, 0.03281773f, 
    0.19544102f, -0.01712525f, 0.17237446f, 0.26641038f, -0.01837588f, -0.05239694f, -0.06654834f, -0.06256028f, 
    -0.14493503f, 0.13171279f, 0.03136149f, -0.26779121f, 0.01985715f, -0.07285292f, 0.16728394f, 0.08021037f, 
    -0.02686338f, -0.04360336f, -0.00055061f, -0.00424177f, -0.14156210f, -0.06479393f, 0.04754973f, 0.39956990f, 
    0.08326551f, 0.09761227f, -0.02978457f, 0.00353381f, -0.00381653f, 0.04518529f, 0.01551801f, 0.04246714f, 
    -0.05961085f, 0.14308903f, -0.00176729f, -0.04729586f, -0.20083264f, 0.13959506f, -0.03296051f, -0.00734871f, 
    0.07397763f, 0.03873541f, 0.03477306f, 0.07783245f, -0.41868341f, 0.08274098f, 0.07101066f, -0.07002429f, 
    0.12566437f, -0.31126162f, -0.06021602f, -0.21916139f, 0.01044056f, -0.14106996f, -0.00364815f, -0.00364784f, 
    0.16212118f, -0.14688115f, 0.22129501f, -0.00202740f, 0.04307835f, 0.05284114f, -0.23560885f, 0.01749640f, 
    0.00462436f, -0.16522753f, 0.01993467f, 0.06055985f, -0.42985898f, 0.59251469f, -0.50062060f, -0.12798354f, 
    -0.28585052f, -0.04054503f, 0.07158844f, -0.10190746f, 0.12402932f, 0.03931432f, -0.17350367f, -0.03321739f, 
    -0.02825423f, 0.02020337f, 0.02757485f, -0.03639888f, 0.02922350f, 0.12070804f, 0.03077862f, -0.02654458f, 
    0.05492778f, 0.04175632f, -0.04601169f, 0.06189284f, -0.20185700f, -0.65682769f, 0.25131458f, -0.21357165f, 
    -0.06788938f, 0.10336962f, -0.07470942f, 0.19762312f, -0.00725029f, 0.08977897f, -0.00140046f, -0.03090436f, 
    0.02185897f, 0.15308835f, -0.07297865f, 0.38990751f, 0.13315594f, -0.08828922f, -0.14281204f, 0.04192987f, 
    0.04906886f, -0.18704873f, -0.18351857f, 0.01937294f, -0.10323720f, -0.13039941f, -0.26750335f, -0.21650028f, 
    0.12186850f, -0.17324691f, 0.16032289f, -0.12808780f, 0.08389202f, -0.15015605f, 0.04307276f, -0.04857843f, 
    -0.03059855f, 0.14972647f, -0.04273071f, 0.18295376f, -0.12919490f, -0.08357374f, -0.06294367f, -0.09645300f, 
    0.05543466f, -0.11702450f, -0.23495376f, 0.06237754f, -0.05719772f, -0.04051214f, -0.34373689f, -0.09520149f, 
    0.00744449f, -0.06818713f, -0.02290446f, 0.06015369f, 0.03460588f, 0.00069571f, 0.08102025f, 0.01721943f, 
    -0.40634072f, -0.05941718f, -0.64747679f, 0.20248899f, 0.09023351f, -0.10936171f, 0.18931295f, -0.00912825f, 
    0.04876773f, -0.04173950f, -0.01162498f, -0.09092640f, 0.02793267f, -0.33972138f, 0.24561426f, -0.21864295f, 
    0.04384399f, 0.03965342f, -0.01645051f, -0.00736856f, -0.14885221f, -0.09709272f, -0.04313295f, -0.01890779f, 
    -0.32217923f, 0.01164887f, 0.32314757f, -0.26923305f, 0.08082717f, 0.02207264f, 0.04553354f, 0.10104907f, 
    0.02811860f, 0.01924375f, 0.04166353f, -0.00835281f, 0.11836948f, 0.00590306f, 0.07911861f, 0.08487679f, 
    0.17803858f, 0.02423417f, -0.04069965f, -0.18090904f, 0.06725547f, 0.04295452f, 0.02769317f, 0.06880464f, 
    -0.00959487f, 0.15260547f, -0.01751739f, 0.08445565f, 0.12060398f, -0.04230582f, 0.07053034f, -0.02131981f, 
    0.05189089f, -0.06165193f, 0.00991158f, 0.05110607f, 0.03184660f, -0.00344686f, -0.03146917f, -0.13142811f, 
    -0.08268264f, -0.08799356f, -0.22447862f, -0.11279811f, 0.17900723f, -0.00436349f, 0.04239902f, 0.09610237f, 
    0.19187036f, -0.09454656f, 0.29614320f, -0.03093609f, 0.11181703f, -0.16132951f, -0.10212559f, -0.05976642f, 
    -0.13036633f, 0.00536959f, 0.10454383f, 0.09491143f, 0.32397676f, 0.10532234f, 0.37322134f, -0.41401738f, 
    0.03276756f, -0.41141722f, 0.06872801f, -0.22632821f, -0.08941567f, 0.03992933f, -0.03273534f, 0.05812856f, 
    0.08431968f, -0.18851557f, 0.19420332f, -0.08406662f, 0.20004484f, -0.05808169f, -0.07917681f, 0.16151254f, 
    -0.13003139f, 0.01986780f, -0.03151301f, 0.02547487f, 0.00508683f, 0.15220311f, 0.23862354f, -0.05999865f, 
    -0.03269235f, -0.15297203f, -0.03930195f, -0.05384197f, 0.17202377f, 0.11078501f, 0.09003186f, 0.04604935f, 
    0.11052040f, 0.27656096f, 0.34313196f, -0.37656942f, -0.03753112f, -0.05845945f, -0.16888948f, -0.19198523f, 
    -0.09549804f, -0.07435670f, 0.10474209f, 0.13410918f, -0.11794899f, 0.00900743f, -0.17466229f, 0.04747532f, 
    -0.10082637f, -0.04993901f, 0.12334006f, 0.05756694f, 0.16102509f, 0.16475159f, -0.03497638f, -0.07862902f, 
    0.32868871f, 0.13474689f, -0.34576833f, -0.02643928f, 0.00402406f, -0.03773443f, 0.15211742f, 0.20749548f, 
    -0.02582490f, 0.03977630f, 0.00214901f, -0.05094914f, 0.15745789f, -0.25521159f, 0.09185072f, 0.27839205f, 
    0.06093567f, -0.05807012f, 0.06500295f, -0.17191885f, 0.13399106f, 0.04641900f, -0.12833372f, 0.06833597f, 
    0.08180600f, -0.00580710f, 0.05401466f, -0.02081779f, -0.19713660f, -0.04025063f, -0.05074671f, 0.17083247f, 
    0.00993242f, 0.10676502f, 0.06309336f, 0.07892565f, 0.03429334f, 0.10636128f, 0.04458679f, -0.06102939f, 
    -0.01920332f, -0.01935502f, -0.02577545f, 0.00480737f, 0.02192688f, 0.14026675f, 0.10585153f, 0.12408999f, 
    0.01001386f, -0.32843572f, 0.09061680f, -0.15746099f, 0.01505017f, 0.05234593f, 0.00426602f, -0.00733994f, 
    0.07211938f, -0.03558642f, 0.04453650f, 0.00365703f, -0.28262356f, 0.07716406f, -0.19349551f, 0.17472573f, 
    -0.01486128f, 0.05578535f, -0.06362975f, -0.04269317f, 0.02036322f, -0.29716781f, 0.07920302f, -0.20002499f, 
    -0.54423940f, -0.17454848f, -0.19794416f, 0.07911955f, 0.17244267f, 0.01769145f, 0.01236982f, 0.16196477f, 
    -0.02628034f, 0.09788315f, 0.04323446f, -0.08838506f, -0.17433433f, 0.18802443f, -0.26619694f, 0.12867261f, 
    -0.00872064f, 0.13286097f, 0.22267392f, 0.11020809f, 0.11963805f, 0.06322235f, -0.14636557f, -0.02228658f, 
    -0.09000782f, 0.11489481f, 0.02795332f, 0.37772796f, 0.08152848f, -0.01608738f, -0.01219791f, -0.16507137f, 
    0.21903491f, -0.03279852f, 0.03357897f, -0.09188851f, -0.41248313f, -0.11638067f, -0.45337814f, -0.08487108f, 
    0.03056056f, -0.09783431f, -0.01783819f, -0.02274963f, -0.02528979f, -0.02967467f, 0.01339407f, 0.04604954f, 
    -0.20705295f, -0.02597372f, 0.18893482f, 0.07441708f, 0.10697964f, 0.00308017f, -0.09353956f, 0.15438165f, 
    -0.01414106f, 0.11443943f, 0.04215589f, 0.17019579f, -0.00902105f, -0.10955167f, 0.00500589f, -0.31802154f, 
    -0.13614602f, 0.03885940f, -0.03595020f, 0.08650871f, 0.00319547f, 0.05320654f, -0.06558456f, -0.14081012f, 
    -0.53634614f, -0.21485855f, 0.18988852f, 0.13172986f, 0.22008555f, -0.09251855f, -0.08937149f, -0.14477931f, 
    -0.04644521f, -0.13057902f, -0.10762224f, 0.05568868f, -0.14347453f, 0.04584172f, 0.21984118f, -0.11681866f, 
    -0.01800807f, -0.15173911f, -0.05720277f, 0.11330168f, 0.01890842f, -0.05584726f, 0.08037131f, -0.01222262f, 
    -0.30406532f, 0.07791178f, -0.11019520f, 0.08842353f, 0.02955143f, 0.03684726f, -0.05761977f, -0.04663393f, 
    0.11100590f, 0.09470992f, -0.17833468f, -0.04780066f, 0.04797108f, -0.07337475f, 0.00508516f, -0.04127275f, 
    0.01431230f, 0.08557963f, 0.10765585f, 0.06784847f, 0.03798615f, 0.04274911f, 0.12444969f, 0.12874213f, 
    0.03300622f, -0.13744093f, 0.22218795f, -0.38864192f, 0.23171881f, -0.21158417f, 0.14813194f, -0.01033593f, 
    -0.12007132f, 0.05603793f, -0.07325429f, -0.06307552f, -0.04719175f, 0.14329445f, -0.14229706f, -0.35388148f, 
    -0.02001603f, -0.28788912f, -0.09197995f, 0.14898111f, 0.03536950f, 0.05901177f, -0.00289317f, -0.07313591f, 
    -0.05072294f, 0.07181489f, 0.20315315f, 0.09886692f, 0.01467891f, -0.01705348f, -0.10050349f, -0.11666480f, 
    0.05423276f, 0.07741713f, 0.04973063f, 0.00442343f, 0.06531928f, 0.07414375f, 0.07564683f, -0.01694415f, 
    -0.11113664f, -0.03259016f, -0.07799233f, -0.10421460f, 0.13946980f, -0.02736652f, 0.06799397f, 0.01912701f, 
    -0.09967243f, 0.00984771f, -0.33309582f, 0.03942723f, 0.13262296f, -0.02648430f, 0.15635754f, 0.05701945f, 
    0.06568996f, 0.03039241f, 0.02173793f, 0.09126992f, 0.21809335f, -0.19382170f, -0.15230325f, -0.18707135f, 
    -0.12934163f, -0.06437089f, -0.11661436f, 0.39056170f, 0.01384164f, 0.00490282f, 0.01131984f, -0.16047052f, 
    0.06673698f, 0.03832114f, 0.17666779f, -0.23428573f, 0.11234473f, -0.10622887f, 0.03948548f, 0.08309012f, 
    0.08417373f, -0.01599973f, 0.05712119f, 0.00077570f, -0.10151706f, 0.03996502f, -0.02934336f, -0.36084536f, 
    -0.01573213f, -0.24603340f, -0.05699859f, -0.15549745f, 0.13941956f, -0.08241285f, -0.03127168f, 0.05261276f, 
    0.06398810f, -0.11098935f, 0.33608112f, 0.09577069f, 0.04422375f, -0.19059484f, -0.04773952f, -0.16573484f, 
    0.02419575f, -0.01929995f, -0.02696767f, 0.12180930f, -0.46423361f, 0.12379666f, 0.05666908f, 0.17062619f, 
    -0.02577171f, -0.13694744f, -0.06471483f, -0.18764894f, -0.00235477f, 0.04670785f, 0.11052183f, 0.13901800f, 
    -0.04551981f, -0.10203014f, -0.16036955f, -0.41021225f, 0.05071409f, 0.13577163f, 0.04887696f, 0.21970530f, 
    -0.01133756f, -0.06192365f, 0.05583524f, -0.07074659f, -0.18232916f, 0.30135843f, -0.07095376f, -0.09208196f, 
    0.03579905f, -0.20627333f, -0.06131524f, 0.00628925f, 0.06664908f, -0.04475554f, 0.07317403f, 0.01436962f, 
    -0.02803250f, 0.17723480f, 0.18214822f, 0.01113489f, 0.01853579f, -0.03784112f, 0.12379748f, -0.02802809f, 
    -0.03065366f, 0.05128761f, -0.00676639f, -0.03747182f, -0.23203245f, -0.41973180f, 0.35379493f, 0.22822194f, 
    0.22066922f, -0.56492078f, 0.02665086f, -0.16709517f, -0.10036672f, -0.01301330f, -0.02838784f, -0.13334115f, 
    -0.03485297f, 0.14462884f, -0.00054036f, 0.05713219f, 0.08065576f, -0.09109106f, 0.09718867f, -0.15822250f, 
    -0.06117424f, 0.16016026f, 0.12215769f, 0.10694871f, -0.24101548f, -0.23438047f, -0.20983717f, -0.41304609f, 
    -0.15717018f, -0.15520127f, -0.03172506f, -0.09024471f, 0.01325238f, 0.06060979f, -0.15415590f, -0.04502175f, 
    -0.20856898f, -0.11165074f, 0.11632655f, 0.23481832f, -0.11732815f, 0.12504204f, -0.18238333f, 0.18523942f, 
    0.03871128f, -0.09606054f, 0.08849983f, 0.12999554f, 0.17127031f, -0.01583465f, -0.04344963f, -0.02902228f, 
    -0.10472651f, 0.10076471f, 0.04121870f, 0.05745532f, 0.02793572f, 0.17347386f, -0.05555108f, 0.19039342f, 
    0.05388502f, -0.01205919f, 0.02602429f, 0.08875716f, -0.09428012f, -0.07508490f, 0.03925944f, 0.14684968f, 
    -0.01139403f, 0.08587702f, 0.04372645f, 0.05500915f, -0.15610951f, 0.22619580f, -0.07877363f, 0.21357866f, 
    0.05232834f, 0.14181077f, -0.00777041f, -0.02874399f, -0.00215333f, -0.21980107f, -0.36049983f, -0.20363069f, 
    -0.04943034f, 0.07842851f, 0.05057072f, 0.03014261f, -0.11420245f, -0.23364623f, 0.11147392f, -0.02415097f, 
    -0.08462541f, 0.10443155f, -0.12620820f, -0.00658362f, -0.00468367f, -0.01932114f, 0.03731545f, -0.08822661f, 
    -0.10177069f, -0.03934959f, 0.09322134f, 0.02792316f, 0.04108450f, -0.10366932f, 0.01216474f, 0.10859347f, 
    -0.29874733f, 0.03933619f, 0.01958489f, 0.06139769f, 0.15937436f, 0.02248641f, -0.00932794f, -0.01916433f, 
    -0.02954294f, -0.02084149f, -0.07630308f, -0.03922873f, -0.17135879f, -0.02614960f, -0.03138376f, -0.19975841f, 
    -0.05075737f, 0.03203195f, 0.02807212f, -0.02466350f, -0.13168693f, 0.13205355f, -0.13485779f, -0.04182404f, 
    -0.10558414f, -0.16696300f, 0.08422540f, 0.07271533f, -0.06946369f, 0.09914738f, 0.07466232f, 0.12099189f, 
    0.00002433f, 0.09721065f, 0.05782036f, 0.00133621f, -0.01972386f, 0.06264061f, -0.25476182f, 0.05243352f, 
    -0.02656796f, 0.11811827f, 0.04307714f, -0.01586373f, 0.02163196f, -0.02160834f, 0.00642760f, -0.13435832f, 
    0.07231896f, -0.21403581f, -0.24156871f, 0.01673340f, -0.04316210f, 0.13025150f, 0.03780859f, -0.02270172f, 
    0.07916403f, 0.04735924f, -0.08414555f, -0.03735779f, 0.28447831f, -0.37120798f, 0.10970094f, 0.06637048f, 
    -0.20654529f, 0.23782121f, 0.14381698f, 0.06049023f, 0.08548266f, 0.02273769f, 0.05638833f, 0.18460827f, 
    -0.45653307f, 0.12554461f, 0.03084876f, -0.17741260f, 0.01401499f, 0.13639158f, -0.13073565f, -0.09745603f, 
    0.07701102f, -0.01252218f, -0.15172951f, -0.06514677f, 0.06088573f, -0.19127360f, 0.17986169f, -0.15262911f, 
    -0.20630804f, 0.08530326f, 0.10148244f, -0.04601733f, 0.02437404f, 0.00395301f, 0.17803988f, 0.12956332f, 
    0.10887524f, 0.06467728f, 0.11038113f, 0.06599241f, -0.05401136f, -0.12010956f, 0.00308799f, -0.08321887f, 
    -0.20547242f, 0.00744944f, 0.17583211f, -0.07859571f, -0.34955585f, 0.04665726f, -0.39132431f, 0.13566037f, 
    -0.06652957f, 0.21176520f, -0.01594749f, -0.09590479f, 0.08477920f, 0.00789000f, 0.03563161f, 0.02803356f, 
    -0.28889301f, 0.46042424f, -0.13208005f, 0.12235527f, -0.11304718f, -0.02305667f, 0.06590798f, -0.09442578f, 
    -0.07351060f, -0.00854709f, -0.00153720f, 0.11803164f, -0.11440870f, 0.10360827f, 0.18541576f, 0.19358559f, 
    -0.16850129f, -0.06566327f, 0.03455089f, -0.01093232f, 0.07282440f, 0.24827075f, 0.20464419f, 0.15370043f, 
    0.14537068f, 0.22633253f, 0.02571348f, -0.01435636f, 0.00642129f, 0.04119918f, 0.09364086f, -0.09871035f, 
    -0.07226046f, 0.00332766f, -0.02459151f, 0.01220278f, -0.05367888f, 0.00318284f, 0.13464177f, 0.20818524f, 
    -0.04607634f, 0.08337185f, -0.16036396f, 0.11110949f, 0.11979249f, 0.01766947f, -0.08091648f, -0.12317792f, 
    -0.23826049f, -0.01854168f, -0.15156800f, -0.13720839f, -0.10480467f, -0.07048193f, -0.01764750f, -0.07911151f, 
    -0.02537143f, 0.09762070f, 0.01071269f, -0.03370546f, -0.08995423f, 0.39887044f, 0.14519614f, 0.10664466f, 
    -0.01857787f, 0.11149987f, -0.13865134f, 0.03052453f, 0.03913239f, -0.04622967f, 0.22991623f, 0.21964049f, 
    -0.08314805f, -0.35427323f, -0.05965121f, -0.03353778f, -0.03748042f, -0.08297142f, -0.05344707f, 0.00471297f, 
    0.01792621f, 0.04289121f, -0.05178387f, -0.02630835f, 0.27391475f, -0.36049557f, 0.07497797f, -0.14919715f, 
    -0.05659708f, 0.02145898f, 0.01533748f, 0.10690232f, -0.04504845f, 0.06530412f, -0.11062245f, -0.24484755f, 
    0.00010298f, 0.02355240f, 0.24953122f, -0.17624272f, -0.09838777f, -0.03773132f, 0.06083915f, 0.09411757f, 
    -0.01920532f, 0.16509372f, 0.12976086f, 0.00136435f, -0.02414375f, 0.09352826f, -0.02417192f, -0.12859944f, 
    0.08185838f, -0.30211851f, -0.04078480f, 0.06494053f, -0.16565520f, 0.05075097f, -0.19719483f, -0.24500483f, 
    -0.19126752f, 0.11958066f, 0.04466749f, -0.01643443f, -0.01142058f, 0.00474675f, -0.12541199f, 0.07290328f, 
    -0.00378613f, 0.08396628f, -0.10114589f, -0.15394664f, -0.12799177f, 0.06842476f, -0.07724666f, 0.16276528f, 
    -0.00863560f, -0.09406208f, 0.16286965f, 0.03900060f, 0.14631969f, 0.02140754f, -0.00125415f, -0.14388195f, 
    -0.23727025f, 0.10877983f, 0.05446565f, -0.00983513f, -0.02654927f, 0.03563455f, 0.01058008f, 0.06057733f, 
    0.06159028f, -0.08669729f, 0.13615318f, 0.08204971f, -0.21516162f, -0.00871282f, 0.02198489f, -0.01196998f, 
    -0.01569027f, -0.03768313f, -0.03851950f, 0.05941174f, -0.16715819f, -0.25595751f, -0.16679989f, -0.19401786f, 
    0.04071778f, 0.06741956f, 0.18427303f, -0.10693094f, -0.02280809f, 0.10168251f, 0.04426421f, 0.09812189f, 
    -0.05975233f, 0.02382157f, 0.06210143f, -0.07634381f, 0.20426239f, -0.19990836f, 0.08818731f, -0.00359698f, 
    -0.08744250f, 0.05329737f, -0.01189611f, -0.06974121f, -0.01853898f, -0.03483415f, -0.12687136f, 0.03587317f, 
    -0.19007531f, -0.26741102f, -0.12260893f, -0.00729210f, 0.07763969f, -0.07729611f, -0.07557738f, -0.02231515f, 
    0.00895275f, 0.06700256f, 0.03893754f, -0.03789429f, -0.36926910f, 0.22041948f, -0.35408327f, -0.04951804f, 
    -0.09073399f, 0.09533625f, 0.17618950f, -0.10904364f, 0.09786350f, -0.06657343f, 0.12796263f, -0.09690671f, 
    -0.06664978f, -0.01035394f, -0.24745254f, 0.08194919f, 0.00737639f, -0.19521227f, -0.00211566f, 0.07374954f, 
    0.02277320f, 0.12989403f, -0.06409519f, -0.14461257f, 0.02296621f, 0.04246780f, 0.07852872f, 0.03562252f, 
    0.03642813f, -0.07210978f, -0.05603992f, 0.03856548f, -0.10768225f, -0.15534016f, -0.48021340f, -0.40028811f, 
    -0.17401265f, 0.18702671f, 0.03354544f, -0.00959826f, -0.03347851f, 0.06207347f, -0.02197381f, 0.00727839f, 
    -0.11309865f, -0.02301145f, -0.13818103f, -0.21963310f, 0.11368313f, 0.38451499f, 0.33305785f, 0.08522851f, 
    -0.13919659f, 0.15111762f, 0.06337048f, 0.21908247f, -0.03083689f, 0.12730332f, -0.00945460f, 0.16636653f, 
    -0.11568730f, 0.26038286f, -0.03108888f, 0.06932296f, -0.05412818f, 0.07515699f, -0.08796893f, 0.01498097f, 
    -0.07855404f, 0.07551865f, -0.08095565f, 0.01228448f, 0.01467969f, 0.01915443f, 0.03255161f, -0.01663121f, 
    -0.08779982f, -0.23803581f, 0.11444864f, 0.00067029f, -0.10526416f, 0.06742697f, 0.12854318f, 0.10131002f, 
    -0.09206171f, -0.06014912f, 0.05382696f, -0.21291238f, -0.14544247f, -0.02892783f, 0.08598371f, 0.03015441f, 
    -0.01108435f, -0.00625733f, -0.15076271f, 0.01570504f, 0.01460581f, 0.09728265f, -0.01091447f, -0.03586810f, 
    -0.09639956f, 0.06125843f, 0.02829967f, 0.05530889f, -0.10074599f, 0.05741553f, -0.07185886f, -0.13031943f, 
    -0.30933020f, 0.03511431f, -0.00558166f, -0.08792850f, 0.07647649f, -0.01260323f, -0.30007190f, 0.01182871f, 
    0.00784177f, -0.24246940f, -0.14918573f, -0.00290667f, 0.04016514f, 0.02388128f, 0.01845709f, 0.24457090f, 
    0.01300162f, 0.19077457f, -0.05756210f, 0.04895047f, 0.04091098f, 0.04619728f, 0.12272370f, -0.02009165f, 
    -0.16694279f, 0.31022120f, 0.41790479f, -0.01177300f, -0.05853852f, 0.14166316f, 0.04475955f, 0.07139800f, 
    -0.00237489f, -0.11080306f, 0.10034203f, 0.05335946f, -0.11234244f, -0.20964788f, -0.07665689f, 0.18956591f, 
    0.01668102f, 0.06019228f, -0.07839844f, -0.03251010f, 0.03076038f, 0.01408825f, -0.03773391f, -0.02574626f, 
    0.06806660f, -0.04841923f, 0.34863168f, -0.35980698f, -0.12363745f, 0.02225840f, 0.03741153f, 0.07322548f, 
    -0.02574651f, -0.19433139f, 0.10704082f, 0.11020305f, -0.01997661f, 0.01369825f, 0.01226372f, 0.07546839f, 
    -0.08959346f, -0.10847431f, -0.00404459f, 0.05857608f, -0.15191442f, -0.07534161f, -0.25915003f, -0.39034575f, 
    -0.25716758f, 0.18958467f, -0.10121949f, -0.08641708f, -0.19776596f, 0.11616174f, -0.06164274f, 0.06255627f, 
    0.11043485f, -0.00082099f, 0.04256636f, 0.01240823f, -0.33132100f, 0.32097331f, 0.34915501f, 0.10873660f, 
    -0.05124516f, 0.08614025f, 0.02827758f, 0.06993324f, -0.02166521f, 0.04071838f, 0.04712562f, 0.08675085f, 
    0.05249127f, 0.16993536f, 0.24910903f, -0.19276626f, 0.02464175f, 0.05153588f, 0.11673602f, -0.00540329f, 
    -0.07417018f, 0.03021556f, -0.05283440f, -0.02153925f, 0.02130168f, -0.05759041f, -0.14189045f, -0.14250183f, 
    0.01486656f, -0.06198109f, -0.04883480f, 0.08040058f, -0.09618590f, 0.07561805f, -0.13932809f, -0.43730173f, 
    0.08821210f, -0.12130073f, 0.03402653f, -0.14752164f, -0.16259989f, -0.10910769f, -0.04809267f, -0.07083648f, 
    -0.22530830f, -0.16606960f, -0.28700075f, -0.17605291f, -0.11874006f, -0.07594119f, -0.29654783f, 0.19458342f, 
    -0.11838771f, 0.16280128f, -0.18677329f, 0.10038679f, -0.02409947f, 0.04493027f, 0.06369974f, 0.08882159f, 
    -0.08182976f, -0.11442286f, 0.05956035f, 0.08602964f, 0.02557995f, 0.06507011f, -0.06005046f, 0.13238360f, 
    -0.02258010f, -0.12071332f, -0.19783615f, -0.14005077f, 0.41675407f, -0.21552554f, 0.18297985f, 0.10549300f, 
    -0.09382645f, -0.03540884f, 0.11810285f, 0.00694504f, -0.09912552f, 0.09983534f, 0.06631016f, -0.07134344f, 
    -0.33528090f, 0.19644833f, -0.15156485f, -0.10558750f, 0.08205044f, 0.00391474f, -0.18153678f, 0.01086640f, 
    0.07378010f, -0.03935669f, -0.03551694f, -0.20093969f, 0.40079170f, 0.05542268f, 0.20106934f, -0.26264289f, 
    -0.11800482f, -0.05680224f, 0.01176275f, 0.06073204f, -0.14628582f, -0.14612412f, -0.37944630f, -0.25424629f, 
    0.01012687f, -0.04658915f, 0.11569307f, 0.11232178f, -0.02886944f, -0.15464236f, 0.03862965f, 0.08258522f, 
    -0.28031331f, 0.06777574f, -0.01422724f, 0.11453918f, 0.18311062f, -0.09381749f, 0.24399550f, -0.05838108f, 
    -0.11316892f, 0.03071744f, 0.13488188f, 0.07068642f, 0.14182235f, 0.01077571f, 0.06555820f, 0.04783733f, 
    -0.40164563f, -0.05255504f, -0.04330794f, -0.05465320f, -0.03374596f, 0.06041836f, -0.01792304f, 0.02436944f, 
    -0.14237049f, -0.03765091f, 0.02317085f, 0.04208537f, -0.64883614f, 0.27278399f, -0.11859424f, -0.02959222f, 
    -0.08669654f, 0.18593390f, -0.08672711f, 0.31344151f, 0.05955906f, -0.01804012f, -0.10587612f, -0.02655057f, 
    -0.34547478f, 0.15996161f, -0.41907081f, 0.13085541f, 0.29084054f, 0.03842632f, 0.14395297f, -0.28162912f, 
    -0.07817052f, -0.00328589f, -0.16613486f, 0.01529112f, 0.24033149f, 0.08471997f, -0.14509855f, -0.04612242f, 
    -0.08435252f, -0.02263096f, -0.14312352f, 0.06705811f, -0.04343233f, -0.00668287f, -0.00930306f, -0.07669439f, 
    0.20031719f, 0.20794235f, 0.35126132f, -0.13287926f, -0.07855479f, 0.11766546f, -0.16605972f, 0.26793051f, 
    -0.08948466f, -0.01703891f, -0.03938616f, -0.13394102f, 0.01130659f, 0.09011997f, -0.07167190f, -0.25377414f, 
    -0.02964620f, 0.03373498f, 0.06136033f, -0.02991610f, -0.05063663f, -0.00318741f, -0.15157315f, 0.01265173f, 
    -0.11511298f, -0.05921870f, 0.07717416f, -0.09554806f, 0.01119501f, 0.01682302f, 0.02932174f, -0.20883197f, 
    0.02552563f, -0.00015534f, -0.07936351f, -0.14242931f, -0.06252419f, -0.22840632f, -0.05884275f, 0.27024513f, 
    0.08770239f, -0.09260253f, 0.05376067f, 0.01618941f, -0.09662383f, -0.10628419f, 0.08917554f, 0.23830673f, 
    0.21055822f, 0.13104610f, 0.46203741f, 0.04007204f, 0.00903228f, 0.05091253f, -0.05697827f, -0.07744399f, 
    -0.18835816f, -0.03250235f, 0.01641665f, -0.03188820f, -0.21664664f, -0.09673244f, -0.15581034f, -0.18773955f, 
    0.02214904f, -0.08289071f, 0.04407009f, 0.06953525f, -0.13687994f, 0.08361260f, -0.12567820f, -0.16643086f, 
    -0.72076857f, 0.24630551f, -0.54622579f, 0.11182977f, 0.05003038f, 0.03098088f, 0.01323409f, -0.21864580f, 
    0.03682488f, -0.00330891f, 0.27004096f, 0.02685883f, 0.60456300f, 0.10763980f, 0.41454351f, -0.05795782f, 
    0.13965228f, -0.09952428f, -0.20732379f, 0.00885072f, 0.00824034f, -0.04385069f, 0.00460222f, -0.03191402f, 
    0.06481641f, -0.03857094f, 0.02371559f, -0.15058611f, -0.11907413f, -0.12686886f, -0.07584222f, -0.09202253f, 
    0.03092832f, -0.04725133f, -0.05085093f, -0.06302145f, -0.32793841f, -0.03688610f, -0.23716256f, -0.02812098f, 
    0.10923731f, 0.05892131f, 0.01757947f, -0.01547480f, 0.07514933f, 0.00920001f, 0.18371221f, -0.01207773f, 
    -0.39129323f, -0.28618440f, -0.19564904f, -0.09670663f, -0.30427447f, -0.17773969f, -0.09366395f, -0.22555524f, 
    0.05813611f, 0.03154648f, -0.01134346f, -0.00615379f, 0.19763502f, 0.01975902f, 0.17997997f, -0.18180804f, 
    -0.11555695f, 0.28581443f, -0.24493754f, 0.22072603f, -0.12502034f, -0.08302186f, -0.03270822f, -0.02127917f, 
    -0.14751199f, 0.08446178f, -0.13200614f, 0.07213602f, 0.06716996f, -0.06194529f, 0.03770273f, -0.06517931f, 
    -0.00400480f, 0.05953972f, 0.02811858f, 0.18913956f, -0.14980423f, -0.22448821f, 0.11605736f, -0.04090459f, 
    0.05424700f, -0.09197538f, 0.15394355f, -0.07070106f, 0.00811911f, 0.07917902f, -0.03496303f, -0.05621473f, 
    -0.12703964f, 0.28612056f, -0.10083518f, 0.02586302f, -0.06623453f, 0.05834966f, -0.00208940f, -0.09944449f, 
    -0.04174371f, -0.02025493f, -0.02748485f, 0.00540712f, -0.44534370f, -0.14211902f, -0.25370383f, 0.22368267f, 
    -0.08495012f, -0.24119143f, 0.08097063f, 0.01662947f, -0.03114392f, 0.06012091f, 0.01072780f, 0.04641676f, 
    0.05647930f, -0.36039016f, 0.30437741f, 0.33086169f, -0.08332171f, 0.00054830f, 0.14886190f, 0.03882053f, 
    0.04224698f, -0.05577166f, 0.04194653f, -0.17148815f, 0.21440929f, -0.26573691f, 0.17765468f, 0.11776279f, 
    0.06187052f, 0.18377858f, -0.04009388f, 0.09325555f, -0.08992373f, -0.04148766f, 0.13045259f, -0.06738403f, 
    -0.22535886f, -0.41109535f, 0.12508911f, 0.34375000f, 0.13121136f, -0.09399772f, 0.02305705f, -0.04852392f, 
    -0.01375571f, -0.15782583f, -0.00900214f, -0.23395059f, 0.09542727f, -0.25626883f, 0.57086283f, -0.38882229f, 
    -0.06024203f, 0.02998191f, 0.14161643f, 0.04990391f, 0.01138013f, -0.07484731f, -0.07829361f, 0.04580661f, 
    0.61443323f, -0.12647663f, 0.19301301f, 0.22949326f, -0.07670189f, 0.07346774f, -0.23672189f, 0.24515857f, 
    -0.16918038f, 0.08664842f, -0.10451470f, 0.08504843f, -0.43799984f, 0.22168165f, -0.07615697f, -0.02873843f, 
    -0.02242694f, 0.00716315f, 0.20240246f, 0.01285406f, -0.11928149f, -0.00898143f, -0.01528651f, -0.09290341f, 
    -0.01308715f, -0.14200115f, -0.21721485f, -0.15273935f, -0.17218210f, -0.08834445f, 0.04900850f, -0.10852177f, 
    0.06716426f, 0.15422893f, -0.00353433f, -0.04157503f, -0.20078781f, -0.05624360f, 0.04883521f, -0.27130067f, 
    0.02772422f, 0.12119586f, -0.06491895f, -0.03095197f, -0.07977574f, 0.02628389f, 0.15994878f, 0.06034853f, 
    -0.10307145f, -0.02666256f, -0.02887435f, -0.15774009f, 0.00451882f, 0.16011804f, -0.05146137f, 0.08772228f, 
    -0.11160655f, -0.05471908f, 0.05638021f, -0.09070003f, 0.07866661f, 0.14008322f, -0.33349818f, -0.15751579f, 
    -0.09735598f, -0.10774732f, 0.07215026f, -0.01703857f, -0.01928290f, 0.11488841f, 0.00395703f, 0.11517807f, 
    -0.42878631f, -0.22846632f, 0.03775016f, 0.04284463f, 0.02575222f, 0.08431755f, 0.03730865f, 0.10533369f, 
    -0.22981957f, 0.04702774f, -0.18282087f, 0.00923484f, 0.06315603f, -0.11536241f, -0.04639168f, -0.13707654f, 
    0.00560464f, 0.04744155f, -0.02924311f, -0.03469489f, -0.01990377f, 0.01922609f, 0.13357751f, -0.16850723f, 
    -0.25673506f, -0.09218187f, -0.21374820f, 0.17518567f, 0.03556573f, 0.06727953f, 0.09522933f, 0.26101422f, 
    -0.01112712f, -0.11096710f, 0.00402620f, -0.31106132f, -0.04471120f, -0.29391494f, 0.11894374f, 0.05754457f, 
    -0.06958348f, 0.03519887f, -0.09033386f, -0.03045610f, -0.11471042f, 0.01090870f, -0.05356404f, 0.12586136f, 
    -0.34469301f, -0.00646715f, -0.34131968f, 0.08460221f, 0.07955440f, -0.16368888f, 0.07250304f, 0.10913721f, 
    0.05084495f, 0.06440844f, -0.20511489f, 0.01379409f, -0.05877404f, 0.14047126f, 0.08261739f, -0.08003156f, 
    -0.15089618f, 0.00459308f, 0.04589325f, 0.09400044f, -0.02901260f, -0.06089877f, 0.27775872f, 0.09165632f, 
    0.10685440f, -0.09036914f, 0.06396542f, 0.05181986f, -0.26352158f, -0.08308331f, -0.09053328f, -0.01091502f, 
    0.01216546f, 0.02006810f, -0.02921929f, 0.08970065f, 0.26299006f, -0.10137853f, -0.08269683f, 0.26217899f, 
    0.14807518f, 0.02228616f, 0.00485018f, 0.01304017f, -0.00356966f, -0.01384661f, 0.08147695f, -0.10277916f, 
    0.12935595f, -0.02109788f, -0.14168257f, -0.35635564f, -0.04432754f, -0.19671009f, -0.08206131f, 0.16933289f, 
    0.05985288f, 0.06019364f, -0.02393407f, -0.01023739f, -0.23817265f, -0.06711584f, 0.00381556f, -0.16512124f, 
    0.00327986f, -0.07896607f, -0.07092039f, 0.00256418f, -0.07362501f, 0.00640688f, 0.09890252f, 0.08400532f, 
    -0.05436283f, -0.00289434f, -0.05193689f, 0.16259328f, 0.06656586f, 0.09127000f, 0.05246763f, 0.01948105f, 
    0.02809551f, 0.05352153f, 0.00317200f, 0.12140078f, 0.06865402f, 0.03908624f, 0.33196533f, -0.23095793f, 
    0.11190754f, 0.16128539f, -0.17206804f, 0.05613286f, -0.08562114f, -0.13521060f, 0.09721233f, 0.14976576f, 
    -0.09139224f, -0.39432147f, 0.26425630f, 0.12397408f, -0.04042159f, -0.10449541f, -0.18489835f, -0.10610055f, 
    0.06680553f, 0.05344380f, 0.05404085f, -0.00325028f, 0.01958770f, 0.02920559f, 0.28787905f, 0.03998211f, 
    -0.06066620f, 0.11634715f, -0.05659427f, -0.03818262f, -0.15624052f, -0.02571076f, 0.05660579f, -0.04394692f, 
    0.17265333f, 0.02984700f, -0.17029549f, -0.08089286f, 0.03767831f, 0.08258219f, 0.09569620f, 0.01995182f, 
    0.09604153f, 0.11785857f, 0.19774151f, -0.01490018f, 0.15913251f, -0.24520712f, 0.09628975f, -0.38010991f, 
    0.06462596f, 0.00254103f, -0.03846545f, 0.09251192f, -0.08524682f, -0.01952440f, 0.06912196f, 0.13007815f, 
    -0.27795029f, 0.04746460f, 0.01632099f, 0.08814195f, 0.05572082f, 0.15852642f, 0.02771315f, 0.19302069f, 
    0.09025438f, 0.09784963f, 0.10963161f, 0.09971803f, -0.59108734f, 0.26656914f, -0.27000496f, 0.25243893f, 
    -0.06975873f, 0.01534250f, 0.15527219f, -0.15213627f, 0.08546723f, 0.00211602f, 0.11723086f, 0.09242662f, 
    -0.01781310f, -0.09923025f, -0.14437401f, 0.15017122f, 0.08701673f, 0.19383375f, -0.11091393f, 0.09294852f, 
    0.03368788f, 0.21060994f, 0.11201632f, -0.17450070f, -0.21069843f, -0.57805198f, -0.13857242f, 0.02000533f, 
    -0.24727057f, -0.02228285f, -0.05789409f, -0.17220943f, -0.03518987f, 0.03043953f, -0.02031325f, -0.03429184f, 
    0.03899322f, -0.03336235f, 0.13687606f, -0.24007165f, -0.02878387f, 0.14838657f, -0.07349750f, -0.02764197f, 
    -0.10787117f, 0.07528750f, 0.08023223f, -0.07864804f, 0.10731707f, -0.03906049f, 0.15798400f, 0.10835183f, 
    0.00476948f, 0.03144594f, -0.10344675f, 0.09081770f, 0.08929437f, 0.15024716f, 0.14588542f, 0.11701843f, 
    -0.26339528f, -0.31737855f, -0.05698078f, 0.28620058f, 0.14209205f, 0.11245290f, -0.05047123f, 0.08863408f, 
    -0.15956371f, -0.06371403f, 0.08930907f, -0.03797770f, 0.32637361f, -0.28116989f, 0.17982772f, 0.20228180f, 
    0.17431417f, 0.03110642f, 0.01198570f, 0.06940077f, 0.06037723f, -0.10450080f, -0.00928897f, -0.11199997f, 
    -0.13563190f, 0.01359384f, -0.20485649f, 0.00735782f, 0.05125383f, -0.04931674f, -0.01971803f, -0.02015015f, 
    -0.08457775f, -0.11237173f, 0.20220032f, 0.10360873f, -0.11254456f, 0.07685945f, -0.09281324f, -0.12556373f, 
    -0.07521407f, -0.09625165f, -0.08336899f, -0.03931562f, -0.03796933f, 0.08552460f, 0.04743738f, -0.06733014f, 
    0.35771701f, 0.10036442f, 0.12987423f, -0.18158329f, -0.05594381f, -0.04605490f, -0.04551692f, 0.03786043f, 
    0.07417826f, 0.10428973f, 0.04190902f, -0.00696132f, -0.20430283f, -0.01965760f, 0.06027921f, 0.49170005f, 
    -0.28628021f, -0.12293766f, 0.06757925f, -0.09721413f, -0.01360447f, -0.00433858f, -0.10528503f, -0.02559071f, 
    0.12806502f, -0.03070784f, 0.17450063f, 0.08052993f, -0.10647479f, 0.21428940f, -0.09570923f, 0.04367331f, 
    -0.02245295f, 0.20478278f, 0.15930092f, 0.06910775f, 0.04402962f, -0.18293028f, 0.22457457f, -0.24503659f, 
    0.09640222f, 0.08844882f, 0.22650573f, -0.10322211f, -0.02689793f, -0.04672254f, 0.02330028f, -0.13592565f, 
    -0.19551775f, 0.04203666f, -0.22350956f, -0.00875144f, 0.18963683f, 0.00984484f, -0.00983896f, 0.00579631f, 
    -0.04251061f, 0.14851405f, 0.01958234f, -0.01170158f, 0.31876728f, -0.37608808f, 0.15013832f, -0.22564442f, 
    0.08872434f, -0.04394956f, 0.10768480f, -0.02858357f, -0.02301066f, 0.16415200f, 0.13707930f, 0.03860527f, 
    0.06036748f, 0.18757252f, -0.09923112f, 0.12353322f, -0.02683351f, 0.00013036f, 0.00180631f, -0.15570605f, 
    -0.00529849f, -0.00843641f, -0.01827469f, -0.05373626f, 0.09759933f, -0.15554613f, 0.37611589f, -0.28736779f, 
    0.04291607f, 0.07992606f, -0.04447254f, 0.00392457f, -0.02843406f, 0.10999330f, -0.03023171f, -0.03443960f, 
    -0.07343641f, -0.00795655f, -0.13320710f, 0.07916955f, 0.15727095f, -0.13119940f, 0.05027729f, -0.22420204f, 
    -0.01113237f, -0.05363841f, -0.06713485f, -0.05528431f, 0.01435550f, -0.61191577f, 0.21237649f, 0.24619237f, 
    0.13179833f, 0.14108212f, -0.18684536f, 0.19001544f, -0.09275596f, -0.10585085f, 0.11799625f, -0.00636956f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11341067f, 0.08916640f, 0.03334991f, -0.10604326f, -0.05714886f, 0.08742648f, 0.04101090f, -0.10719640f, 
    0.07122581f, -0.02006153f, 0.02057850f, -0.02835572f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
