#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12020438f, 0.06123488f, -0.49309599f, 0.76563674f, -0.61522704f, -0.13141470f, -0.35148177f, 0.42743447f, 
    0.26838619f, 0.91262668f, -0.21273060f, 0.54958576f, 0.81220084f, 0.40048838f, 0.27076304f, 0.35330671f, 
    0.47005990f, -0.48371390f, -0.74347121f, -0.60371906f, -0.34942836f, 0.79404116f, 0.73684448f, 0.65668136f, 
    -0.17981641f, -0.19399108f, 0.19397019f, -0.19501017f, 0.15889834f, 0.19768284f, -0.82020551f, -0.69047815f, 
    -0.55064768f, 0.53504908f, 0.50653160f, -0.19830538f, -0.62585521f, -0.82542360f, -0.70748007f, 0.22350837f, 
    -0.08850858f, -0.27704075f, -0.33471793f, 0.26867253f, -0.46475238f, 0.40092552f, -0.24194826f, -0.22924446f, 
    -0.89271617f, -0.07333589f, -0.72682428f, -0.12692669f, 0.36645943f, -0.04906075f, 0.29137892f, 0.70176566f, 
    0.68643934f, -0.43879518f, 0.16013345f, 0.63639760f, 0.13086945f, -0.09757669f, -0.34577569f, -0.60371828f, 
    0.94633746f, -0.14232354f, 0.82349604f, -0.41846710f, -0.52813554f, -0.42889956f, -0.22618121f, -0.41493633f, 
    0.64156753f, 0.43898335f, 0.46772224f, 0.02587878f, -0.54080373f, 0.63604277f, 0.25977281f, -0.25862482f, 
    0.21668573f, -0.39000672f, -0.54733872f, -0.34327608f, -0.45299169f, 0.41903713f, 0.70965451f, 0.12124593f, 
    -0.21467689f, 0.66834593f, -0.89226818f, 0.29610997f, -0.47516161f, 0.45630172f, 0.35809538f, 0.60595340f, 
    0.33983248f, -0.54115331f, 0.12013111f, 0.45977497f, 0.51016706f, 0.39073303f, -0.93076563f, 0.15230560f, 
    -0.37842277f, -0.17340548f, -0.00482068f, 0.32907295f, 0.67586815f, 0.67418587f, 0.34561062f, 0.16620818f, 
    0.62381971f, -0.40497118f, -0.19227630f, -0.06363448f, -0.02118141f, 0.58830076f, 0.11724997f, 0.88315052f, 
    0.57855707f, -0.07501618f, 0.11181883f, -0.54328448f, -0.58321440f, -0.35925549f, -0.62588769f, -0.50042552f, 
    0.09323385f, 0.66608417f, 0.80797923f, -0.65573204f, 0.06650160f, 0.31733042f, -0.12405360f, 0.42131549f, 
    0.52180368f, 0.67684633f, -0.36073613f, -0.49904132f, -0.62161779f, 0.07562758f, 0.61868709f, 0.46091318f, 
    0.75030053f, -0.02633822f, 0.49383807f, -0.67402339f, -1.24338472f, 0.02658552f, -0.21977399f, 0.20220265f, 
    -0.20501512f, -0.26016054f, -0.59822953f, -0.58516937f, -0.28699255f, 0.30891487f, 0.28293517f, -0.63456523f, 
    -0.42592064f, -0.38251886f, -0.69978225f, 0.01157217f, 0.56125432f, -0.47430706f, 0.91217357f, -0.29044497f, 
    -0.14425091f, 0.23600526f, -0.11247656f, -0.62940067f, 0.21532787f, -0.41624787f, 0.04570207f, 0.65540236f, 
    -0.39359316f, 0.30483568f, 0.16338415f, -0.40656081f, -0.06804460f, -0.42003953f, -0.17003427f, -0.21708803f, 
    0.65874118f, -0.64780498f, -0.08498193f, -0.06333876f, -0.35430825f, 0.03263535f, -0.69077307f, -0.64238918f, 
    -0.55899006f, -0.51588029f, -0.18187740f, 0.52022982f, 0.16506860f, 0.37156072f, -0.05434952f, 0.46979278f, 
    0.41329154f, 0.77233881f, 0.12136217f, 0.40292111f, 0.51349163f, 0.20644453f, 0.32214963f, -0.27271014f, 
    -0.55845821f, -0.32797366f, 0.55152923f, 0.88263237f, 0.08742165f, 0.17839059f, -0.34327984f, -0.46686405f, 
    0.80283523f, 0.60114318f, 0.82361424f, 0.38305664f, -0.28088069f, -0.49540642f, 0.52840722f, -0.06829451f, 
    -0.13134758f, -0.10500272f, -0.64589888f, 0.81978357f, 0.44700393f, -1.06163561f, 0.85844415f, -0.12715490f, 
    -0.06610473f, 0.29954302f, -0.70212245f, 0.21844496f, 0.63615775f, 0.56576180f, 0.49637586f, 0.77163535f, 
    -0.39293155f, -0.29837593f, 0.03108493f, -0.71082169f, -0.51403719f, -0.76117069f, -0.52534616f, 0.47032335f, 
    0.60415930f, 0.28291357f, 0.23416223f, 0.04878991f, -0.21571681f, 0.70617270f, -0.72099638f, -0.35749081f, 
    -0.70876139f, -0.44141933f, 0.15155995f, -0.17779355f, -0.10602906f, -0.48640221f, -0.38143048f, -0.48237178f, 
    0.49328884f, -0.65950018f, 0.22938442f, 0.39218697f, -0.27725574f, -0.50433606f, -0.85258341f, -0.37436768f, 
    0.61710793f, -0.88467801f, -0.30480623f, 0.55548060f, 0.19813263f, 0.02689040f, 0.12717937f, 0.83923781f, 
    0.54379934f, -0.23934032f, -0.34383497f, 0.51337403f, -0.35122764f, 0.35274720f, 0.35383368f, -0.23052098f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21158510f, 0.08353800f, -0.05096873f, -0.16085011f, -0.19839843f, -0.04857408f, 0.34868789f, -0.22406952f, 
    -0.14073488f, -0.25196454f, -0.25932464f, 0.15886739f, 0.33337045f, 0.41092888f, -0.01566518f, -0.10465787f, 
    0.25400609f, 0.15042549f, -0.08577281f, -0.00100936f, -0.09987728f, 0.00180639f, -0.36042091f, -0.24094915f, 
    -0.14983651f, -0.04180824f, 0.32360247f, 0.05025604f, -0.06063505f, 0.23420307f, 0.34345651f, 0.18069395f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12379114f, -0.19372360f, -0.01199894f, 0.09094400f, 0.14105093f, 0.04213098f, 0.13675693f, 0.06588077f, 
    -0.00473418f, -0.20097904f, -0.17170103f, -0.11544944f, 0.10417084f, 0.09258357f, -0.06492267f, 0.01284385f, 
    0.07700496f, -0.09335892f, 0.23095560f, 0.13668381f, -0.07288928f, 0.06837015f, 0.09576669f, -0.08790936f, 
    0.01830234f, 0.11314234f, -0.01887745f, 0.07860624f, -0.01854081f, -0.01195341f, -0.01063056f, 0.02536346f, 
    -0.06333844f, -0.03925149f, -0.04368228f, -0.13915139f, 0.08144293f, -0.04149684f, 0.12023798f, -0.04151994f, 
    0.00877081f, 0.06275748f, 0.12759505f, -0.00387980f, -0.06444313f, -0.12066016f, 0.12647261f, 0.11533706f, 
    0.26712021f, -0.03713568f, 0.17350490f, 0.11288165f, -0.18825370f, 0.00943100f, -0.22331800f, -0.10472957f, 
    -0.06044713f, 0.02693863f, -0.00782931f, -0.00231226f, 0.14910878f, -0.05546220f, -0.14561146f, 0.08312897f, 
    -0.12685482f, -0.13560154f, 0.06836298f, -0.01356541f, 0.01241259f, 0.05073093f, -0.15644369f, -0.12927087f, 
    -0.17722306f, -0.39031181f, -0.09324154f, 0.02393849f, 0.03523232f, -0.06799286f, -0.10528389f, 0.01980601f, 
    -0.13600460f, 0.01502838f, -0.06425870f, -0.13104191f, 0.16408513f, -0.18174128f, -0.07535395f, -0.01184020f, 
    -0.03407950f, -0.06407981f, 0.10096881f, -0.02662899f, -0.06115331f, 0.06199781f, 0.01160195f, -0.04786805f, 
    -0.06338952f, 0.07641878f, -0.17627677f, -0.15024461f, 0.01904134f, 0.16577683f, 0.01061013f, 0.07137763f, 
    0.03026922f, 0.07922779f, -0.00505129f, 0.09462224f, -0.34316260f, -0.10777404f, -0.14521314f, 0.01798632f, 
    0.08929636f, -0.01570762f, 0.10049890f, 0.01643097f, 0.08549120f, -0.39536977f, -0.19532979f, 0.06821744f, 
    0.19448353f, 0.15201707f, 0.00661594f, 0.00044352f, -0.12524633f, 0.07813429f, 0.05125574f, 0.07290219f, 
    -0.18089114f, -0.04677390f, 0.10687883f, -0.00110010f, -0.01580055f, 0.17878439f, -0.03327068f, -0.11191007f, 
    -0.30061901f, 0.06543741f, -0.10782589f, -0.10973834f, -0.13507880f, 0.08661906f, -0.08185014f, 0.16078797f, 
    -0.00336155f, -0.15317157f, 0.03479493f, 0.00110003f, 0.02336695f, -0.00631547f, 0.03562128f, 0.18503882f, 
    -0.01365073f, 0.04912563f, 0.04714491f, -0.03324947f, -0.01094907f, -0.01128446f, 0.03520963f, 0.09523761f, 
    0.05502670f, 0.01238958f, 0.02919936f, 0.04524497f, 0.02371043f, -0.02168831f, 0.04751460f, 0.12222488f, 
    -0.02585101f, 0.18951552f, -0.00415918f, 0.05919953f, 0.06017324f, -0.02439441f, -0.14025678f, 0.04608816f, 
    0.10453280f, 0.09863501f, 0.19576372f, -0.01949923f, 0.05253674f, 0.08254918f, -0.03976427f, 0.02631039f, 
    -0.11593402f, 0.11832315f, -0.02191651f, 0.00482130f, -0.18946894f, 0.00879425f, -0.02242554f, -0.12004364f, 
    0.00605924f, -0.05040759f, 0.06161126f, -0.08271584f, -0.02151344f, 0.03543546f, -0.40883860f, 0.17743923f, 
    -0.18768142f, 0.24200724f, 0.03811493f, -0.12456387f, -0.04932361f, -0.13095845f, -0.00374911f, 0.13155386f, 
    0.08856010f, -0.08365706f, 0.01018659f, 0.05987953f, 0.23066141f, -0.02860530f, 0.12116209f, -0.16328506f, 
    -0.42480111f, -0.39935783f, -0.07441102f, -0.01013141f, -0.12895149f, 0.02957168f, 0.08326757f, -0.04378595f, 
    0.06761996f, 0.21350972f, -0.03488097f, 0.10313447f, 0.06140668f, 0.11495238f, -0.19812131f, -0.11852857f, 
    0.16984512f, 0.03974620f, -0.11340569f, 0.01897315f, -0.03412316f, 0.09071262f, 0.14376834f, 0.03049049f, 
    -0.04139197f, 0.19069724f, 0.00632697f, -0.06868426f, 0.03375898f, 0.05344061f, 0.20725738f, -0.07758129f, 
    -0.05830750f, 0.00139786f, -0.04221164f, 0.10416404f, 0.31872529f, -0.08738925f, 0.03349565f, -0.01090862f, 
    0.09742985f, -0.01673499f, 0.00068041f, 0.06687506f, -0.07012609f, 0.09092917f, 0.04482740f, -0.00510355f, 
    0.03799135f, 0.17056759f, 0.05580381f, 0.04113814f, -0.05306745f, 0.03780222f, -0.06567068f, 0.17302310f, 
    0.05026616f, -0.13020866f, 0.04892103f, 0.05982137f, 0.07767300f, 0.21180402f, 0.16117038f, -0.18725207f, 
    -0.09347725f, -0.07943792f, -0.03265648f, 0.07355614f, -0.13707024f, 0.03127312f, 0.00067586f, 0.01543986f, 
    -0.01755368f, -0.02757361f, 0.00627378f, 0.00052439f, -0.03664401f, 0.03644499f, -0.02547638f, 0.04552241f, 
    0.03211397f, 0.03651448f, -0.00771808f, 0.04638971f, -0.01504550f, -0.06106352f, -0.05725034f, 0.02687555f, 
    -0.01160545f, -0.01870576f, -0.02762042f, 0.02668324f, 0.01283158f, -0.05546302f, -0.02722714f, -0.03487641f, 
    0.02959790f, -0.02515921f, -0.05106746f, 0.02926258f, -0.03635059f, -0.03927431f, -0.03224509f, 0.00395475f, 
    0.02694758f, 0.02475394f, 0.03374650f, -0.03761721f, -0.00097617f, -0.05838041f, 0.01166441f, -0.02748188f, 
    0.00618962f, 0.01165871f, -0.00551702f, -0.00981237f, -0.02272286f, 0.01139258f, -0.05965978f, -0.06057861f, 
    0.01638802f, -0.01802670f, -0.03881647f, -0.03670577f, -0.03527745f, -0.02837845f, -0.01886927f, -0.01050997f, 
    0.01379724f, 0.01622667f, -0.00591248f, 0.04196805f, -0.01741922f, -0.01421295f, -0.02786334f, -0.02444365f, 
    0.04135686f, -0.01854502f, -0.06481262f, 0.01279737f, 0.03889541f, 0.02937676f, -0.01308290f, -0.00122612f, 
    -0.02288384f, -0.04418575f, -0.04411394f, 0.04713413f, 0.04584436f, 0.01662924f, 0.03925900f, -0.01727672f, 
    -0.02088747f, -0.01580931f, -0.01085105f, 0.00778491f, -0.01176611f, -0.01468654f, -0.01001280f, -0.05946464f, 
    -0.00858233f, 0.03141960f, 0.03713024f, 0.01734094f, -0.00676386f, -0.02623197f, -0.05587175f, 0.04971651f, 
    -0.06002301f, -0.00876890f, 0.00253103f, -0.00029680f, 0.02785492f, 0.03836515f, 0.00832211f, -0.06038596f, 
    -0.03402255f, 0.04702950f, -0.02426424f, -0.00670332f, -0.06310966f, 0.03780692f, -0.02772855f, 0.04448850f, 
    -0.04201045f, -0.00868105f, 0.03948858f, -0.04287535f, -0.01375917f, -0.01028532f, 0.01149509f, -0.03151435f, 
    -0.02235482f, 0.04598070f, -0.01800812f, -0.06425948f, -0.02604553f, 0.04954942f, 0.00289516f, -0.00177315f, 
    0.00157103f, 0.00423233f, -0.05032204f, 0.04301457f, -0.02403612f, 0.03244807f, -0.05246907f, 0.02714982f, 
    -0.01534132f, -0.03026243f, -0.00102394f, 0.00483855f, 0.03952208f, -0.05433267f, -0.02681377f, 0.04677963f, 
    0.01696155f, -0.02318912f, -0.06360506f, -0.00963686f, 0.01165623f, -0.04510584f, -0.00134648f, 0.00690126f, 
    -0.06462169f, 0.01014437f, 0.01349085f, 0.00635031f, 0.03715944f, 0.01127369f, -0.04363471f, 0.03874907f, 
    0.04128812f, 0.00691263f, -0.03620786f, -0.01919023f, -0.02915867f, -0.04537094f, -0.05319293f, 0.05088141f, 
    0.02043340f, -0.04517116f, -0.00446849f, -0.06386147f, -0.06012024f, 0.01803297f, -0.04991369f, -0.02150499f, 
    0.04574782f, -0.02052290f, -0.04942697f, -0.03114564f, -0.02201175f, 0.04188510f, -0.06466445f, 0.00196490f, 
    -0.01995733f, 0.03774001f, -0.04308577f, 0.04561775f, -0.04428350f, -0.00908082f, 0.03437334f, -0.03092950f, 
    -0.05922318f, -0.06388786f, -0.04582589f, 0.04604501f, 0.05268561f, 0.01741436f, 0.01355467f, 0.00621961f, 
    0.05122057f, -0.03461433f, 0.03811577f, -0.04696231f, -0.01158280f, -0.02076509f, 0.04103989f, -0.05600577f, 
    0.04150232f, -0.06078291f, -0.03129585f, 0.05066623f, 0.03257170f, -0.02109439f, -0.06044381f, -0.05961884f, 
    0.03105881f, -0.05792022f, -0.01508290f, -0.01571180f, 0.00808617f, 0.01988640f, -0.00744644f, 0.03940276f, 
    0.03693681f, -0.03619858f, 0.05223514f, 0.01256188f, -0.02305100f, 0.03965364f, 0.00340826f, 0.01070879f, 
    -0.01858648f, -0.05225720f, -0.03549756f, 0.00069174f, 0.00237518f, -0.01398221f, -0.05285719f, 0.02978875f, 
    -0.01667747f, -0.00491326f, 0.00680384f, 0.02312033f, 0.04567963f, 0.00247492f, -0.06415754f, -0.02212436f, 
    -0.06402529f, 0.04177180f, -0.03849266f, -0.04836674f, 0.02189253f, -0.01475531f, -0.04247672f, 0.00116576f, 
    -0.01579828f, 0.02770273f, -0.02082731f, -0.05051978f, -0.00194016f, 0.02036306f, -0.04379161f, -0.05978548f, 
    -0.02153335f, 0.00325743f, 0.01049407f, 0.01137513f, -0.06325930f, 0.03730889f, -0.03021438f, -0.06259551f, 
    0.00797245f, -0.05070740f, -0.04888871f, -0.00493267f, -0.01818519f, 0.02833980f, -0.02649921f, 0.03464410f, 
    -0.02874760f, 0.02971037f, -0.03561315f, -0.03218504f, -0.01293676f, -0.01169572f, -0.01307834f, -0.04098607f, 
    0.13615346f, -0.04005195f, 0.10180762f, 0.06328626f, -0.09347980f, -0.08459689f, -0.10316446f, 0.18830018f, 
    -0.00881528f, -0.26433310f, -0.08238869f, -0.10673466f, -0.07918893f, 0.01936260f, -0.00857550f, 0.07295752f, 
    0.06217040f, 0.05754914f, 0.13548431f, 0.25192994f, 0.07585642f, -0.24664441f, -0.17853951f, -0.11367631f, 
    0.01061498f, 0.00686605f, 0.07025608f, 0.26233041f, 0.21491270f, 0.15482502f, -0.13639112f, -0.08128215f, 
    0.05069151f, 0.00963165f, 0.02650629f, 0.07623487f, -0.17962991f, -0.05009170f, -0.16684884f, -0.11262263f, 
    -0.04545515f, -0.03917079f, -0.08472294f, 0.00264878f, -0.18265775f, 0.29076886f, 0.27584568f, 0.12817900f, 
    0.16797455f, 0.00721538f, 0.03713163f, 0.03077309f, -0.11877623f, -0.07954960f, -0.05800846f, 0.06590759f, 
    0.04833369f, 0.04145287f, -0.00605909f, 0.08429252f, 0.08726060f, -0.10809311f, 0.06609520f, 0.12301616f, 
    -0.22648539f, -0.10022631f, 0.07685532f, 0.09496881f, -0.04220558f, -0.25496715f, -0.10982978f, -0.10727719f, 
    -0.14566387f, -0.13892831f, -0.06931980f, 0.10527604f, -0.06311113f, 0.11527680f, 0.06007991f, -0.00335847f, 
    0.05863563f, 0.17477714f, 0.01631835f, -0.04259345f, -0.07583925f, 0.08784021f, -0.02453515f, 0.09832118f, 
    0.14255783f, -0.04526960f, 0.14894813f, 0.08628723f, -0.09765748f, -0.13116135f, -0.00594710f, -0.19257028f, 
    0.10490523f, -0.10236728f, 0.05783157f, 0.11175716f, 0.07174928f, 0.02277746f, 0.06114591f, 0.03000800f, 
    0.11875894f, 0.01826558f, -0.05392003f, -0.05467913f, -0.12225236f, -0.21596712f, -0.26715222f, 0.06488818f, 
    -0.02598138f, 0.03858137f, -0.09784739f, 0.10186779f, 0.00052199f, -0.26760727f, -0.15868607f, 0.06428341f, 
    0.08366576f, 0.08982290f, 0.04374634f, -0.16673344f, -0.07647561f, 0.09238294f, 0.04424498f, 0.02116866f, 
    -0.15897748f, -0.15292686f, -0.10737108f, -0.01509458f, 0.07165891f, -0.06631427f, -0.05728231f, 0.24193244f, 
    0.01009601f, 0.24792910f, -0.01567756f, 0.11401380f, -0.01367290f, -0.05855150f, 0.14433233f, 0.05836309f, 
    -0.22416721f, 0.18374023f, 0.01575581f, 0.12317463f, 0.09937553f, 0.20634998f, -0.01976833f, -0.03580895f, 
    -0.06293046f, 0.01718558f, -0.02958064f, -0.11677393f, -0.03572778f, 0.07624390f, -0.11629528f, -0.07956003f, 
    0.08409481f, -0.09507189f, 0.20763676f, 0.05076071f, -0.21512286f, -0.07074036f, -0.06996915f, 0.15108903f, 
    0.01257266f, -0.06143625f, -0.14771885f, 0.18097027f, -0.05468960f, -0.03567851f, -0.08377053f, -0.00360729f, 
    -0.02554711f, 0.08207705f, 0.02228138f, -0.17732480f, -0.12240485f, -0.00445422f, -0.04734163f, -0.04804637f, 
    0.02700796f, 0.03112431f, 0.06709303f, -0.18829113f, -0.06752360f, 0.34105188f, 0.05944858f, -0.18838936f, 
    -0.13429627f, -0.13857670f, 0.00698739f, 0.03623964f, 0.19275710f, -0.04136563f, 0.06975491f, 0.04616825f, 
    -0.09439112f, -0.10251264f, 0.05034981f, -0.01180579f, 0.05647747f, 0.03391981f, 0.13201216f, 0.14162368f, 
    -0.00070030f, 0.02643576f, -0.09343987f, 0.08198502f, -0.10083070f, 0.09985685f, -0.07927956f, -0.00975650f, 
    -0.20573819f, -0.25081891f, 0.00102553f, 0.22177377f, 0.12795247f, 0.13800597f, -0.07557277f, 0.02057653f, 
    0.04303155f, -0.31511977f, -0.00117038f, 0.05833328f, -0.02444271f, -0.10205103f, 0.04515022f, 0.00760767f, 
    0.17692302f, 0.06254026f, 0.07731528f, 0.13696265f, -0.02123955f, -0.11540642f, -0.12400772f, 0.08612002f, 
    -0.02910350f, 0.10117993f, 0.11763299f, 0.12545684f, 0.05869425f, 0.03761156f, -0.13910654f, 0.01750513f, 
    -0.05942598f, 0.00896310f, 0.07904645f, 0.06397174f, 0.06287745f, -0.19209775f, 0.04403291f, 0.13067417f, 
    0.07212862f, 0.11614601f, -0.07012241f, 0.04718877f, -0.16025358f, -0.05123015f, -0.03438724f, 0.00957165f, 
    0.02824212f, -0.06668421f, -0.02566692f, -0.05187801f, 0.07931937f, -0.08518529f, 0.16423324f, 0.14226712f, 
    -0.03318229f, -0.10227539f, -0.12863764f, 0.02760918f, -0.10011178f, 0.05785984f, 0.03115941f, 0.01039195f, 
    -0.02625806f, -0.21332774f, 0.01386512f, 0.03608107f, -0.00324643f, 0.03651463f, 0.05893186f, 0.07250635f, 
    0.16694677f, 0.17252280f, 0.16366145f, 0.00462806f, 0.05045569f, -0.15539750f, -0.01901947f, 0.07351495f, 
    0.05360445f, 0.21532352f, -0.23375520f, 0.14955750f, -0.04330794f, 0.08646717f, 0.07163914f, 0.08717208f, 
    0.06536463f, -0.05190831f, -0.07128798f, -0.05696156f, 0.04373000f, -0.00218940f, -0.03890626f, -0.03177390f, 
    -0.15448894f, -0.17378254f, -0.02841904f, 0.21824017f, -0.05117668f, -0.25046659f, 0.03905566f, 0.10917705f, 
    0.10603778f, -0.05276754f, -0.12443219f, -0.08549201f, 0.16272500f, 0.14779985f, -0.18084963f, 0.08706872f, 
    0.06952775f, 0.13786648f, 0.00468203f, -0.16999756f, 0.09067009f, -0.01041977f, 0.12208757f, -0.59246254f, 
    0.07913713f, -0.06241792f, 0.11851969f, -0.12600052f, -0.05312197f, -0.04697673f, 0.20539215f, -0.00290897f, 
    0.16240656f, -0.00491209f, 0.03513921f, -0.04597260f, 0.06110467f, -0.02893873f, -0.05265091f, -0.18810993f, 
    -0.10146052f, -0.03793392f, -0.08092885f, 0.11574704f, 0.01672241f, -0.14405259f, -0.07451580f, 0.03147516f, 
    0.23105454f, -0.01144182f, 0.21559505f, 0.08347742f, 0.05327337f, -0.02175156f, 0.01767608f, 0.05823323f, 
    -0.02333481f, 0.08238336f, -0.02889855f, 0.16979867f, -0.02612706f, 0.09400734f, 0.00951329f, 0.01562409f, 
    -0.11955349f, -0.09457276f, -0.30185232f, 0.07353258f, 0.03637717f, 0.00686783f, 0.01170775f, -0.13995749f, 
    -0.04353102f, -0.12005492f, -0.03424994f, 0.16369928f, 0.15857580f, -0.07017368f, -0.02428796f, -0.06109341f, 
    0.05712992f, -0.06282882f, -0.03911925f, -0.02116881f, 0.26597282f, 0.19807912f, 0.04331634f, 0.02707783f, 
    -0.08990954f, 0.17496108f, 0.00738379f, 0.00528664f, 0.06565002f, 0.17008415f, 0.09163389f, 0.08176871f, 
    -0.03824789f, -0.12708014f, -0.03256135f, 0.04276482f, -0.06300449f, 0.02456002f, -0.00362325f, -0.20068450f, 
    -0.20706868f, 0.02752596f, 0.01923332f, 0.18069831f, -0.01924543f, -0.17445019f, 0.07141679f, 0.26144728f, 
    0.16469741f, -0.08025950f, 0.06641831f, -0.10403613f, 0.03054389f, 0.03882056f, 0.01247498f, -0.09403652f, 
    0.06163264f, 0.26703256f, 0.02529818f, 0.09308001f, 0.02098321f, 0.08736434f, 0.04208960f, -0.00834288f, 
    -0.00523588f, 0.03857452f, -0.05743032f, -0.08163904f, 0.12652372f, 0.04497084f, 0.05482275f, -0.00736209f, 
    -0.15810280f, -0.12294433f, -0.10940186f, -0.04233041f, -0.02788450f, -0.10580496f, 0.02763776f, 0.09660333f, 
    0.03599101f, -0.06951206f, 0.06265832f, -0.33829471f, -0.14166394f, -0.06014457f, -0.02852111f, 0.04936508f, 
    -0.04607860f, -0.02330822f, 0.08177851f, -0.04286971f, 0.04334914f, -0.16463350f, -0.36217883f, 0.08702423f, 
    0.07076519f, 0.16916144f, -0.02741775f, 0.05424342f, 0.02862294f, -0.03439771f, 0.06555536f, -0.30564505f, 
    0.03942300f, -0.00370601f, -0.04366642f, -0.06580211f, 0.03675387f, -0.12524182f, -0.05923775f, -0.16672237f, 
    0.04671316f, -0.00272774f, -0.03704845f, -0.03130770f, 0.06813985f, -0.21024022f, 0.02211057f, 0.26688638f, 
    -0.25155872f, -0.19085021f, 0.10089675f, 0.05984200f, -0.04396849f, -0.05820887f, 0.05587811f, -0.08616183f, 
    0.55041927f, 0.09469537f, -0.04769497f, 0.01857623f, -0.17021206f, 0.13292396f, 0.11047477f, 0.02093756f, 
    -0.07573502f, -0.19533595f, 0.03139201f, 0.05563995f, 0.03630211f, -0.02054915f, -0.01782877f, -0.00133472f, 
    0.03584372f, 0.01019080f, -0.14562218f, 0.00127329f, 0.04145432f, -0.01476671f, 0.01891645f, -0.03579488f, 
    0.04798092f, -0.02885483f, 0.01314584f, -0.18402734f, 0.08594214f, -0.00477450f, -0.04125981f, 0.20908824f, 
    -0.03843194f, -0.11877476f, 0.07966884f, 0.00682938f, 0.09778121f, -0.06558026f, -0.26363480f, 0.10824559f, 
    0.12106233f, 0.13519578f, -0.02454989f, -0.10583417f, -0.05118635f, -0.15509042f, 0.27839980f, -0.08983096f, 
    0.07442537f, -0.16384032f, 0.04760877f, 0.14510900f, -0.04837111f, -0.02129706f, -0.16628103f, 0.13677296f, 
    -0.08548944f, 0.02558260f, 0.02532584f, -0.09396537f, 0.00344963f, -0.01955722f, -0.04027319f, 0.22632371f, 
    0.00867923f, 0.04281354f, -0.01640405f, 0.10707961f, 0.00560327f, -0.03274061f, -0.05997038f, 0.09019099f, 
    0.28658134f, -0.00628146f, 0.00621590f, -0.10934652f, 0.20249388f, 0.02734305f, 0.06137699f, 0.06921050f, 
    0.03774302f, -0.22300568f, 0.09438387f, -0.02419507f, -0.01035098f, -0.08859569f, 0.06044280f, 0.07568786f, 
    -0.12333883f, -0.03954774f, 0.07062178f, 0.16660729f, -0.15535666f, 0.05910344f, -0.01112484f, 0.12412862f, 
    0.07682767f, -0.05350253f, 0.12439076f, 0.04177789f, -0.07450420f, -0.09242645f, -0.01368152f, -0.12963879f, 
    -0.16880031f, 0.09013247f, 0.20730078f, 0.00369663f, -0.01050412f, 0.14351103f, 0.25383452f, 0.14174075f, 
    0.05819325f, -0.03314842f, -0.01086766f, -0.07718819f, -0.00588901f, -0.06857686f, -0.15722874f, 0.07692856f, 
    0.06382958f, 0.01269052f, -0.10503323f, -0.09413260f, -0.03233068f, 0.00146768f, 0.00594137f, -0.07573147f, 
    0.05255825f, -0.02776409f, -0.13006981f, 0.03724887f, -0.00215376f, -0.01690104f, 0.01470562f, 0.29582167f, 
    0.17700243f, 0.13516670f, 0.04598383f, 0.03687869f, 0.08823273f, -0.01669544f, -0.02349800f, 0.01899059f, 
    -0.01828452f, 0.01797475f, -0.23560628f, -0.12855865f, 0.09986221f, 0.00683327f, -0.03387059f, -0.12879431f, 
    -0.08701839f, 0.15062812f, -0.02904197f, -0.11049945f, 0.08623615f, 0.06725329f, -0.05606033f, 0.07009779f, 
    -0.28859469f, -0.09768833f, 0.05045696f, 0.10235053f, -0.03091782f, 0.05353906f, 0.08036739f, -0.06923772f, 
    0.04754821f, -0.01732186f, 0.13004832f, -0.00134074f, 0.06585247f, -0.12904674f, -0.03070246f, 0.09982733f, 
    -0.18750802f, -0.09735674f, -0.01174864f, 0.07982619f, -0.13308974f, 0.07402314f, 0.01434461f, -0.03697862f, 
    0.00711978f, -0.01677467f, -0.01924881f, -0.18503387f, -0.06329292f, 0.27640614f, 0.05334201f, 0.02907611f, 
    -0.03671405f, 0.07644335f, 0.09650297f, -0.01069514f, -0.09871148f, -0.10316849f, -0.08917587f, 0.33293033f, 
    0.03911712f, 0.09647786f, 0.02301750f, 0.05408162f, 0.07363385f, 0.10370766f, -0.09563278f, 0.12786339f, 
    -0.05823025f, -0.06700104f, -0.17491055f, -0.02852881f, -0.18393043f, -0.09202810f, 0.09335252f, 0.07511235f, 
    0.15029520f, -0.17922111f, 0.07920352f, -0.10568878f, 0.00676893f, -0.00243994f, -0.09660542f, -0.00327219f, 
    0.04026353f, 0.21043196f, 0.10714546f, -0.05441160f, 0.08300199f, 0.06275896f, -0.06067061f, 0.06899715f, 
    0.00139322f, 0.07558016f, -0.04716900f, 0.13869831f, 0.19813846f, 0.04273034f, -0.08076549f, 0.06961331f, 
    0.11108232f, -0.02721732f, -0.13813956f, 0.28919721f, 0.15048510f, -0.00366328f, 0.10288379f, 0.00387737f, 
    0.05759526f, -0.10198334f, 0.00152988f, 0.01383190f, -0.04778191f, 0.12346698f, 0.03219670f, 0.07183906f, 
    0.06450421f, 0.10652078f, -0.14020048f, -0.15757129f, -0.12250067f, -0.04426657f, -0.00688455f, -0.06306432f, 
    0.06146898f, 0.08056995f, -0.08355466f, -0.04647630f, -0.10296857f, 0.00323279f, -0.22114685f, 0.10239805f, 
    0.11956786f, 0.00737040f, 0.17292477f, -0.03747043f, -0.03585878f, -0.11438817f, -0.04959002f, -0.06283171f, 
    0.45974290f, -0.13574657f, 0.09458170f, -0.03574071f, 0.19563034f, -0.08824971f, 0.16817018f, 0.01238943f, 
    -0.25279307f, 0.14841609f, 0.05772440f, -0.15715398f, -0.03036351f, 0.00432250f, -0.00513491f, -0.06728081f, 
    0.04538267f, 0.15003985f, -0.17155787f, 0.08764812f, -0.02297591f, -0.05632637f, 0.09660608f, -0.19810377f, 
    -0.04678361f, -0.04881016f, 0.00905678f, 0.03357952f, -0.05990241f, 0.02736485f, 0.13067789f, -0.02475884f, 
    0.03131645f, -0.11181171f, 0.06260911f, 0.04936945f, 0.06667171f, -0.00840806f, 0.13776000f, 0.07362705f, 
    -0.09297563f, -0.02264307f, -0.12155426f, 0.02003978f, -0.10791957f, -0.03175927f, 0.06545303f, 0.05043340f, 
    -0.12214502f, -0.12664491f, -0.01913518f, 0.01439935f, -0.05246217f, 0.02508465f, 0.00878745f, 0.00440167f, 
    -0.03822997f, 0.16115968f, 0.09947031f, 0.03229307f, -0.13082419f, -0.04370520f, 0.02942795f, -0.32415208f, 
    0.16959438f, 0.04955423f, 0.05046202f, 0.03065251f, 0.04320659f, 0.12221555f, -0.05244298f, -0.22330587f, 
    0.06560146f, -0.09112228f, -0.08006417f, -0.06297163f, 0.02698057f, -0.04236310f, 0.01400856f, -0.08385872f, 
    0.03444447f, 0.02227061f, 0.03659491f, -0.00261881f, -0.02759439f, 0.03947086f, -0.03401360f, -0.06208174f, 
    0.03308627f, -0.01252689f, -0.05034479f, 0.04129510f, -0.02879283f, 0.04226563f, -0.04906359f, 0.03104978f, 
    -0.06425165f, -0.04670866f, -0.03999284f, 0.03936270f, -0.03815451f, 0.01149185f, 0.02531467f, -0.01330660f, 
    0.03457813f, -0.02327112f, -0.04401288f, 0.03036664f, 0.00881997f, -0.05513809f, 0.01143073f, -0.05725278f, 
    0.03088462f, -0.03147110f, -0.02254952f, 0.02376048f, 0.02532878f, 0.03981880f, 0.00584814f, -0.01927969f, 
    0.00987413f, -0.04053713f, -0.02494010f, -0.05171511f, -0.05137810f, 0.03218998f, -0.04280763f, -0.00657122f, 
    -0.06083836f, -0.02756964f, 0.00200514f, -0.05556148f, 0.03114888f, -0.01084006f, -0.03035741f, 0.04372501f, 
    0.02966467f, 0.01598934f, -0.02473838f, 0.00677619f, -0.00191659f, -0.00428209f, -0.02377392f, 0.04068024f, 
    -0.04437147f, -0.04141317f, 0.03618110f, 0.00451079f, -0.04923452f, 0.01076735f, 0.00267531f, 0.03926986f, 
    0.04047055f, -0.01931285f, -0.01988316f, -0.03615293f, -0.00095892f, -0.00584236f, 0.00853783f, -0.04466064f, 
    -0.00135591f, -0.02919992f, 0.04687733f, 0.04839754f, -0.04590816f, -0.01236377f, -0.04953616f, -0.03907783f, 
    0.02691554f, 0.02380428f, -0.02994026f, -0.03364059f, -0.06124851f, 0.02304139f, 0.04447557f, -0.05584554f, 
    -0.06006382f, -0.01640606f, -0.00084453f, 0.00262772f, -0.05528397f, -0.02595062f, 0.01809206f, -0.06001858f, 
    -0.01800536f, -0.02378175f, 0.04831547f, 0.00827837f, -0.06440612f, -0.01620070f, 0.04215302f, -0.06166970f, 
    0.00774090f, 0.00973905f, 0.04973192f, -0.01288521f, 0.01230321f, 0.01875200f, 0.03234974f, -0.01611263f, 
    -0.04239555f, -0.05190257f, -0.01748389f, -0.05349398f, 0.03377791f, -0.05002084f, -0.00899013f, 0.02285337f, 
    0.02527332f, 0.03159112f, -0.01406561f, -0.00319155f, -0.04198225f, 0.00950445f, 0.01958055f, -0.04820847f, 
    -0.05165161f, 0.04864918f, -0.01784779f, -0.02913244f, 0.04668955f, -0.06352519f, 0.03227367f, 0.01314135f, 
    -0.04221627f, 0.02636529f, -0.04925547f, 0.04939125f, 0.04106905f, -0.03391106f, -0.01173688f, 0.03884683f, 
    0.00317216f, 0.02095850f, -0.05523458f, -0.04337401f, -0.00737820f, -0.00840189f, 0.04867073f, 0.04225720f, 
    0.03712344f, -0.00531151f, -0.06848190f, -0.05398615f, -0.02349650f, -0.04378764f, -0.05410699f, -0.05151337f, 
    0.02755797f, 0.03263353f, -0.00730789f, -0.00051829f, -0.00529274f, 0.01113349f, 0.04219321f, 0.00271125f, 
    -0.03763512f, -0.06304734f, 0.01425012f, -0.05935051f, 0.03278584f, -0.04732998f, -0.05683874f, 0.04251130f, 
    0.02026063f, 0.03916479f, -0.04356907f, 0.01971279f, -0.01927453f, 0.02526773f, 0.02681340f, -0.01327113f, 
    -0.03717787f, 0.00097790f, -0.00376143f, 0.00110266f, -0.04658624f, -0.06295913f, -0.00315008f, -0.04515602f, 
    -0.01502716f, -0.00278201f, -0.03581733f, -0.06392872f, -0.04126892f, -0.03626655f, 0.05292026f, -0.02256331f, 
    -0.07349599f, -0.00295041f, 0.00857179f, -0.02456530f, -0.00435099f, 0.04363454f, 0.00465282f, -0.01859430f, 
    -0.03757152f, -0.06055326f, 0.04265066f, 0.02585964f, -0.00739049f, 0.05765628f, -0.04556167f, 0.00711448f, 
    0.02786202f, -0.05451568f, 0.02537221f, 0.04958257f, -0.02673157f, -0.05041415f, 0.02937088f, 0.01005843f, 
    0.03241739f, -0.02982517f, -0.04704726f, 0.00326997f, 0.03256515f, -0.01165201f, -0.00167105f, -0.01507773f, 
    0.02243665f, 0.01413510f, 0.00733651f, -0.04619064f, -0.03775454f, 0.00732182f, -0.05630405f, 0.04496129f, 
    0.02050088f, 0.02204287f, -0.00831490f, -0.00659277f, 0.00496477f, -0.05436721f, 0.04396418f, -0.00525134f, 
    -0.02749490f, -0.04662259f, -0.03638025f, 0.02179142f, -0.04851183f, 0.02939120f, -0.05029805f, 0.00122213f, 
    0.02473607f, -0.01408125f, -0.04135014f, -0.03673536f, -0.00768383f, -0.04058457f, -0.06321232f, -0.00526127f, 
    -0.01670015f, 0.01788842f, 0.03516919f, 0.04447793f, -0.01171270f, 0.02990287f, 0.01669221f, -0.02857373f, 
    0.04371486f, 0.01028535f, -0.04527588f, 0.02553925f, 0.02597647f, -0.03672377f, -0.03135942f, -0.01924669f, 
    -0.60113037f, -0.15867884f, -0.36028203f, -0.17584957f, -0.00347747f, 0.02133765f, -0.05674252f, 0.11516032f, 
    -0.02236687f, 0.20982018f, -0.06535310f, -0.13280815f, 0.09554460f, 0.06096619f, 0.14772557f, 0.15433584f, 
    -0.04054259f, 0.14675060f, 0.36828500f, 0.03588764f, -0.26684517f, 0.13779823f, 0.10323511f, 0.06623194f, 
    0.02323795f, -0.08843070f, 0.04457646f, -0.19569585f, -0.08573536f, 0.03912371f, -0.02428121f, 0.11332966f, 
    0.04307801f, 0.17192645f, 0.06342855f, 0.03371421f, -0.38778356f, -0.00024489f, 0.03091406f, -0.07740507f, 
    -0.01638591f, 0.05308127f, 0.15600206f, -0.01641165f, -0.14295690f, -0.22607282f, -0.24378127f, 0.08695545f, 
    0.11992882f, 0.17355400f, 0.11480943f, -0.13372086f, -0.10287993f, 0.16812973f, 0.24301666f, -0.07999299f, 
    0.17163429f, -0.26741424f, -0.00870754f, -0.24879336f, 0.06879985f, 0.14230283f, 0.03721805f, -0.33434886f, 
    0.04325593f, -0.05835248f, -0.21173213f, -0.25674731f, -0.16387855f, 0.05652459f, 0.17797163f, 0.10264834f, 
    -0.02073676f, 0.00053013f, -0.04966922f, -0.02474885f, -0.01847027f, -0.03471661f, -0.03794375f, 0.09315632f, 
    -0.08906531f, 0.08866045f, -0.31350887f, -0.18918505f, -0.00506689f, 0.08828328f, 0.03555214f, -0.02051648f, 
    -0.04799698f, -0.13043128f, 0.34257722f, 0.05091473f, -0.42075774f, 0.02158777f, -0.10983391f, -0.08410101f, 
    0.07000527f, -0.10007103f, 0.05259790f, 0.11796393f, -0.25844812f, -0.02718174f, -0.01171239f, -0.06071704f, 
    0.05222818f, -0.00154647f, 0.12624623f, 0.00915579f, 0.31075701f, 0.17661859f, -0.00754955f, -0.05290825f, 
    -0.03153113f, -0.03997813f, 0.04502986f, 0.10474424f, 0.13102056f, 0.27619797f, 0.03103407f, 0.34245813f, 
    -0.14355366f, -0.07756227f, -0.23050907f, 0.17844625f, 0.19208236f, 0.12196914f, -0.04783091f, 0.09204178f, 
    0.01024050f, 0.15483335f, 0.14981963f, 0.10427052f, -0.02023801f, 0.01495453f, 0.00106810f, 0.08839596f, 
    0.00991387f, -0.00750492f, -0.18947187f, -0.00287672f, -0.08930531f, -0.14119858f, 0.01142465f, 0.03727166f, 
    0.06615363f, -0.03481207f, 0.21119475f, -0.15964897f, 0.04848554f, 0.02945605f, 0.01918477f, 0.17614855f, 
    0.05555697f, 0.09073225f, 0.05472622f, -0.20518833f, 0.05971701f, 0.08031274f, -0.02962189f, 0.11956017f, 
    0.19406585f, 0.06501941f, -0.05013524f, -0.12183698f, 0.11531258f, 0.11909504f, 0.01107176f, 0.09115350f, 
    -0.17330828f, -0.05083767f, -0.10526355f, 0.00687456f, 0.08386013f, -0.06535747f, -0.00188676f, 0.08301432f, 
    0.13183248f, -0.00909138f, -0.09234841f, 0.05972680f, -0.11513237f, -0.25384477f, -0.04648136f, 0.06973124f, 
    0.10591115f, -0.00670439f, -0.05961837f, -0.20094587f, -0.01915777f, -0.42189446f, -0.17732650f, 0.04536704f, 
    0.12466945f, 0.07675806f, -0.04100439f, -0.17000572f, -0.03694630f, 0.02397012f, -0.33781707f, -0.10637287f, 
    -0.16642168f, 0.02201505f, 0.14569724f, 0.07037466f, 0.05318778f, -0.00054080f, -0.01364107f, 0.32790732f, 
    -0.10637299f, -0.34971723f, -0.07341720f, 0.18132100f, 0.02102366f, -0.02967834f, -0.02870643f, 0.03907139f, 
    0.17618461f, 0.16163312f, 0.14816503f, -0.19498298f, -0.09930898f, -0.05004285f, 0.11569215f, 0.11628152f, 
    -0.04636103f, -0.25722259f, -0.12196422f, 0.33249748f, 0.19636339f, 0.08147067f, -0.10968146f, 0.02208534f, 
    -0.09996362f, -0.14789677f, 0.27677715f, 0.15443562f, 0.21844681f, -0.02331401f, 0.03155261f, -0.07551979f, 
    0.11496992f, 0.06887921f, 0.09981751f, 0.18874389f, -0.32144412f, -0.20929846f, -0.00652652f, 0.08460433f, 
    0.07894895f, -0.04542777f, 0.05839734f, -0.06670742f, -0.23165064f, 0.05823326f, 0.03653791f, 0.00446223f, 
    0.05720742f, 0.02475144f, -0.06284732f, -0.10023917f, -0.04095538f, -0.08103116f, 0.05356751f, -0.05259045f, 
    0.07588001f, 0.05718011f, 0.15566032f, 0.04625938f, 0.01682989f, 0.04786340f, -0.36353964f, -0.23591405f, 
    0.12756860f, -0.06145696f, 0.02266531f, -0.08059111f, 0.00975229f, 0.08824097f, 0.10522784f, 0.22618330f, 
    0.12330145f, -0.04709063f, 0.05245356f, 0.03040196f, -0.04982334f, 0.00917983f, -0.03717744f, 0.14507082f, 
    0.12104430f, -0.10371210f, 0.13951728f, 0.06190346f, -0.12986994f, -0.09942427f, 0.13876206f, 0.14765064f, 
    -0.01698831f, -0.20042285f, -0.11387213f, -0.17666748f, 0.17151152f, -0.12156186f, -0.03209696f, 0.02813462f, 
    0.03087856f, -0.16120997f, 0.03721998f, -0.17077188f, -0.04403690f, 0.01727508f, -0.00976779f, 0.00841359f, 
    -0.04463837f, -0.02338359f, 0.02500929f, 0.18050539f, 0.16381514f, -0.00966056f, -0.20948812f, -0.10354688f, 
    -0.19280957f, 0.06116501f, 0.15905644f, 0.15523019f, 0.04139163f, -0.15497211f, 0.19158909f, 0.08041269f, 
    -0.11446331f, -0.06049509f, -0.01364883f, 0.03918016f, 0.23374532f, 0.17918800f, 0.00775617f, 0.15660749f, 
    -0.03367485f, -0.04745316f, -0.04801428f, 0.05916943f, 0.09595584f, 0.15124525f, 0.05650488f, 0.22140798f, 
    -0.08973913f, -0.11456800f, 0.09947944f, 0.02454886f, 0.01314767f, 0.01286077f, -0.18550453f, 0.15032792f, 
    -0.08001011f, 0.03516810f, -0.00935795f, -0.06516790f, 0.13331775f, -0.07884544f, 0.05808765f, -0.06075312f, 
    -0.11892478f, -0.00243848f, -0.07885383f, 0.02547169f, 0.03599361f, -0.06780899f, -0.17477544f, 0.06124561f, 
    -0.33831450f, -0.08326279f, 0.02878584f, -0.02534576f, -0.02515371f, -0.05583687f, -0.04660269f, -0.01471616f, 
    -0.02177262f, -0.08342901f, -0.11388849f, -0.07677586f, -0.06446910f, 0.11315274f, -0.09384888f, -0.01726643f, 
    -0.03360733f, 0.10814364f, -0.20116159f, 0.07751457f, 0.20845985f, 0.11576463f, 0.10614704f, 0.05347074f, 
    -0.07071479f, 0.03856031f, 0.01493769f, -0.02908586f, -0.11558242f, 0.18256716f, 0.07052914f, 0.13304216f, 
    0.12689295f, 0.05903905f, 0.06657331f, -0.02818000f, -0.01280709f, -0.10404737f, 0.20941277f, -0.12195553f, 
    0.13679391f, 0.05606072f, 0.26693803f, -0.08681836f, -0.06796587f, 0.04250800f, 0.11909562f, -0.11534806f, 
    0.01823409f, -0.09994292f, 0.02124495f, -0.27238396f, -0.05780231f, 0.00578343f, 0.07982086f, -0.04875337f, 
    -0.06711201f, 0.07683609f, 0.01154679f, -0.01636113f, -0.14208579f, 0.00302722f, 0.01520365f, -0.12246768f, 
    0.02666834f, -0.01946248f, -0.02198446f, -0.08967219f, 0.14486068f, 0.03874463f, 0.11372486f, 0.21447699f, 
    -0.12099572f, -0.19345762f, -0.11001179f, 0.20796303f, 0.00268442f, 0.08993098f, 0.06072807f, -0.14989783f, 
    0.00917176f, 0.12588134f, 0.00844038f, 0.19403128f, -0.18895845f, -0.18400270f, 0.00661790f, 0.14771710f, 
    -0.04747241f, 0.01488316f, -0.00154548f, 0.19405118f, -0.00811211f, 0.06518590f, -0.14180779f, 0.00331969f, 
    -0.23154223f, -0.05235296f, 0.13276218f, 0.08582266f, -0.16571786f, -0.06981429f, 0.16097994f, -0.06699959f, 
    -0.08723842f, 0.02860384f, -0.02063260f, 0.12220725f, 0.11206711f, 0.19498987f, -0.09047509f, 0.09526552f, 
    -0.02603351f, 0.01683732f, -0.05895153f, 0.10911613f, 0.16541401f, -0.04659297f, -0.11882249f, -0.05051393f, 
    -0.07081652f, 0.17290066f, -0.19922739f, 0.03317451f, -0.06459685f, -0.10073560f, -0.17306171f, -0.15912600f, 
    -0.13281947f, 0.04556142f, -0.21488172f, 0.01335176f, 0.01544477f, -0.12838502f, 0.13103737f, 0.01338610f, 
    -0.05138685f, -0.04345228f, -0.16801479f, 0.12313139f, 0.12121864f, -0.08309773f, -0.10572015f, -0.06096347f, 
    -0.27447674f, -0.01625780f, -0.05730481f, 0.03762065f, -0.16405876f, -0.04031580f, 0.13401720f, -0.00539429f, 
    0.02199555f, -0.09619965f, -0.14842723f, -0.06997938f, -0.13131888f, 0.15547141f, -0.00997306f, 0.18642566f, 
    0.03265521f, -0.04587681f, -0.11888302f, -0.06908586f, -0.03231480f, 0.03490979f, -0.04691700f, 0.08974801f, 
    -0.08069483f, 0.05466542f, 0.07283997f, -0.02360335f, 0.31326920f, -0.01038390f, -0.03407451f, -0.09047946f, 
    0.11295012f, 0.03329173f, 0.11675622f, 0.02352379f, 0.18387686f, 0.00767606f, -0.04993920f, 0.07909089f, 
    -0.03094677f, 0.08006980f, 0.07586593f, -0.06107266f, -0.00788538f, -0.00592828f, 0.10547535f, 0.23078737f, 
    -0.13857751f, -0.15057060f, -0.02433393f, -0.05588030f, 0.11320000f, 0.16600581f, -0.06796540f, -0.06091500f, 
    0.08666772f, 0.18965201f, 0.12545112f, 0.02203160f, -0.09842558f, 0.04977881f, 0.13373666f, 0.10518360f, 
    -0.00233721f, -0.00095218f, -0.03341756f, -0.06798489f, -0.04221750f, -0.02172126f, 0.04029505f, 0.05342373f, 
    -0.02092762f, 0.00470430f, 0.01869192f, -0.00040623f, 0.04357830f, -0.03444457f, 0.00826119f, 0.05032212f, 
    -0.05345504f, 0.01816916f, 0.01935020f, 0.04494307f, 0.00739419f, -0.00901847f, -0.02828539f, 0.03151874f, 
    0.02542685f, -0.01031180f, 0.01936315f, 0.03905442f, 0.04195805f, 0.04340939f, 0.01532486f, -0.06004050f, 
    0.01447342f, -0.01780420f, 0.00486038f, 0.02463676f, -0.04507437f, 0.05853900f, -0.04512712f, -0.05825217f, 
    0.03572170f, -0.03622697f, 0.04465772f, -0.04584767f, -0.04029308f, -0.05558437f, 0.02702519f, 0.03665446f, 
    -0.00105912f, 0.01557891f, 0.04055236f, 0.03667561f, 0.01592980f, -0.05689725f, 0.04107951f, -0.06138862f, 
    -0.03899016f, -0.02913904f, -0.01718679f, 0.03258740f, 0.02424813f, 0.00051696f, -0.01075541f, 0.05475965f, 
    0.00309556f, -0.00299226f, 0.00112554f, 0.04706652f, 0.01434206f, -0.01679500f, -0.01543978f, -0.04869266f, 
    -0.01417542f, -0.05967595f, -0.03609613f, 0.04024692f, 0.01205990f, 0.01844089f, -0.05237244f, -0.00696500f, 
    -0.01016011f, -0.01679813f, -0.03932528f, -0.04470967f, -0.04234572f, -0.01524640f, -0.05301701f, 0.04020252f, 
    -0.04404740f, 0.05386766f, -0.06443952f, -0.03698890f, 0.06093242f, 0.03789723f, -0.04628767f, 0.02521187f, 
    0.02874207f, -0.03126606f, -0.01287925f, -0.04439737f, 0.05281329f, -0.02747430f, -0.05815750f, -0.06086878f, 
    -0.04060318f, -0.00548496f, 0.00093997f, -0.00422903f, -0.02973246f, -0.03927438f, -0.00807462f, -0.01590200f, 
    -0.04560548f, -0.04352175f, -0.03719623f, -0.05622853f, 0.04057169f, -0.01946715f, -0.03239846f, 0.03535118f, 
    -0.02143284f, -0.05680683f, 0.01544974f, -0.00330272f, -0.01243780f, 0.02614714f, -0.02985591f, -0.01280299f, 
    -0.06614604f, -0.01258794f, 0.05014738f, 0.01813519f, -0.05622600f, -0.05215368f, -0.02593858f, 0.03469959f, 
    -0.06589668f, 0.00752087f, 0.00107363f, 0.02482732f, -0.04464411f, 0.01502527f, 0.00032747f, -0.00199375f, 
    0.00338111f, 0.01297246f, -0.02897844f, 0.01374633f, -0.06007326f, -0.06157602f, 0.01768123f, -0.01224587f, 
    0.03571685f, 0.03649537f, -0.01277866f, 0.05003106f, 0.03016350f, -0.01044435f, -0.06576380f, 0.05214326f, 
    0.01440961f, -0.05578149f, -0.02881376f, -0.01136667f, -0.03353912f, 0.03802611f, 0.04234445f, -0.04196531f, 
    -0.00234034f, -0.02480456f, -0.01828123f, -0.02233811f, 0.01170226f, 0.01119116f, 0.00864293f, 0.00140608f, 
    0.03632380f, -0.03701442f, 0.03979775f, -0.02387502f, 0.02976207f, -0.02740321f, -0.04047809f, 0.01113613f, 
    -0.04216720f, 0.00528799f, -0.04711945f, -0.04992073f, -0.00831915f, 0.02082736f, -0.05097998f, 0.03348522f, 
    0.00731480f, -0.01343337f, 0.04045607f, -0.00425554f, 0.02994010f, 0.02797715f, 0.00199375f, -0.01428323f, 
    -0.01740987f, 0.04562253f, 0.03720069f, 0.04165718f, -0.04920445f, -0.00260338f, 0.05182745f, 0.01437671f, 
    0.03982899f, -0.00561346f, -0.05233143f, -0.02779321f, -0.01903849f, -0.01853336f, 0.04137743f, -0.05240287f, 
    0.02661416f, -0.04637282f, 0.03849989f, -0.01156641f, -0.04021508f, -0.04354595f, -0.02026331f, -0.04245647f, 
    -0.03763610f, 0.04418732f, 0.00308787f, -0.00160607f, -0.04992488f, -0.02169650f, -0.05897449f, 0.04705876f, 
    -0.01914918f, 0.01241601f, -0.00291600f, 0.05063817f, 0.02448765f, -0.04149009f, -0.04260083f, -0.03411079f, 
    -0.01355774f, 0.00250427f, -0.04913558f, 0.01128305f, -0.05414303f, -0.02686563f, 0.05970998f, 0.03997648f, 
    0.02161297f, 0.00427326f, -0.01259250f, 0.05431438f, 0.05541382f, -0.05500505f, 0.05068985f, -0.04718114f, 
    0.03606886f, 0.05218687f, 0.04989679f, -0.05106476f, -0.04284092f, -0.00563832f, 0.00628117f, -0.02505898f, 
    -0.00000266f, -0.05155649f, 0.02694897f, -0.05458827f, 0.04566823f, -0.05499839f, 0.04728678f, 0.03860379f, 
    -0.00744863f, -0.00459955f, 0.04299327f, -0.02695317f, -0.01778939f, 0.02571987f, -0.03689886f, -0.05871890f, 
    -0.03787229f, -0.01952915f, -0.06355000f, -0.02266364f, -0.03331775f, -0.05305018f, -0.03180681f, -0.00231500f, 
    0.02511014f, -0.04943668f, 0.05760539f, -0.00545581f, -0.05289973f, -0.00461016f, -0.04815757f, 0.03456880f, 
    0.04595779f, -0.02549629f, -0.01104394f, -0.04737017f, -0.00794275f, -0.04428005f, 0.02688998f, 0.04355771f, 
    -0.04356359f, -0.06259838f, -0.02931289f, 0.05305930f, 0.04339507f, -0.04347228f, 0.00031132f, 0.02876418f, 
    0.04137620f, -0.00080869f, -0.04837896f, -0.04922657f, 0.04382484f, 0.04419818f, 0.01826585f, 0.01546214f, 
    -0.04156998f, 0.00559868f, 0.00842549f, -0.05234516f, 0.03790196f, -0.05144110f, 0.00614747f, 0.01711550f, 
    -0.04052014f, 0.02045273f, 0.05630640f, -0.03317107f, 0.04927800f, -0.04018694f, -0.00045947f, 0.00597431f, 
    -0.06144685f, -0.03428009f, -0.01742379f, -0.03730393f, 0.02051897f, -0.02060380f, -0.04317607f, -0.03782154f, 
    0.02318799f, 0.04908852f, 0.01264348f, -0.00044042f, -0.05831474f, 0.02643941f, 0.01628246f, 0.03665064f, 
    0.03896521f, -0.02377564f, -0.04971443f, -0.02226662f, 0.00022658f, 0.02861560f, 0.03126364f, -0.05249643f, 
    -0.03639546f, 0.03574725f, -0.04459498f, -0.04765015f, -0.05687819f, 0.03390387f, 0.02865222f, -0.03569213f, 
    -0.02205204f, -0.02934275f, 0.04712716f, -0.02584824f, -0.02464427f, -0.00566382f, -0.05918457f, 0.03441706f, 
    0.02346826f, -0.02984582f, 0.02316022f, -0.03408020f, -0.04169020f, 0.03763239f, -0.01170300f, -0.05372458f, 
    0.04536209f, 0.04290358f, -0.00064817f, -0.05558532f, -0.06756433f, -0.03030430f, -0.04385821f, -0.05323303f, 
    0.04244171f, -0.02180796f, -0.05368155f, 0.01604732f, 0.04813412f, 0.02708817f, 0.00252489f, -0.01169366f, 
    0.02765943f, 0.02053683f, -0.00502424f, -0.02439701f, 0.03446366f, -0.07154697f, -0.04571564f, 0.02052957f, 
    -0.01130113f, -0.05267952f, -0.01142240f, 0.01075240f, -0.01215898f, -0.02643547f, -0.01040587f, -0.00424164f, 
    0.00815110f, 0.01454027f, -0.06897586f, 0.03724060f, 0.00320993f, -0.00050264f, -0.05934833f, 0.00314304f, 
    0.01729272f, 0.03419195f, -0.00653605f, -0.06351971f, -0.00631330f, -0.05557005f, -0.02199460f, 0.01495330f, 
    -0.00900492f, 0.00570552f, 0.03906806f, -0.00357706f, 0.02959871f, -0.02215863f, -0.03184397f, -0.01437595f, 
    0.03351334f, -0.03837176f, -0.00042339f, 0.00955101f, 0.01020474f, 0.03465825f, 0.03300893f, 0.01061103f, 
    0.02241137f, -0.04153694f, 0.00037177f, 0.01991252f, 0.05546388f, -0.01465664f, -0.01719029f, -0.03535496f, 
    -0.00786652f, -0.01206830f, -0.06869125f, -0.01399041f, -0.01925762f, -0.03237306f, -0.02483163f, -0.05912880f, 
    0.05047052f, 0.01194293f, -0.05593139f, -0.05938638f, -0.02593325f, 0.03597621f, -0.03473449f, 0.02778316f, 
    0.04258906f, 0.01913792f, 0.01270076f, -0.02136542f, -0.03648463f, 0.02132544f, 0.01357034f, 0.01833260f, 
    0.01959243f, -0.00433040f, 0.01292731f, 0.04053262f, -0.04835697f, -0.02073108f, -0.00461824f, 0.00364101f, 
    -0.00175817f, -0.06013802f, -0.06723522f, -0.01661431f, -0.00649316f, 0.03245426f, 0.02421355f, 0.00936238f, 
    -0.04989794f, 0.04846137f, 0.01066657f, -0.03666613f, -0.03355540f, 0.03606072f, -0.00379217f, 0.03966508f, 
    0.02213120f, 0.01408952f, -0.02081902f, -0.06087894f, 0.05394878f, -0.01266252f, 0.02141991f, -0.06269266f, 
    0.03649962f, -0.00749324f, -0.04150817f, 0.03683079f, 0.00536464f, -0.00819738f, 0.02792891f, -0.04564415f, 
    0.02104075f, -0.02700328f, -0.02212124f, 0.00866076f, -0.04565932f, 0.04216718f, -0.06367770f, -0.01305971f, 
    -0.05971409f, -0.01387519f, -0.01044642f, -0.02928720f, 0.02219945f, 0.05266825f, -0.04261727f, -0.01088372f, 
    -0.05760399f, -0.00015247f, -0.05917886f, -0.05084157f, -0.02422032f, -0.05336412f, -0.04665815f, 0.01803368f, 
    -0.01227564f, -0.00901515f, -0.01840747f, 0.03657091f, -0.04466799f, 0.00581481f, -0.05223611f, -0.06731152f, 
    0.02184094f, 0.03777989f, 0.02660811f, 0.04928485f, 0.04435486f, -0.02087448f, 0.00700752f, -0.02031675f, 
    -0.01857585f, 0.01291188f, -0.01921605f, -0.02439617f, -0.02672639f, -0.00116104f, -0.03597433f, -0.04557251f, 
    0.04574919f, -0.03329512f, 0.03425980f, -0.03078262f, -0.04916277f, -0.06066324f, 0.02839414f, -0.06408718f, 
    0.05040618f, 0.01840665f, -0.05146447f, 0.00789483f, -0.02623981f, -0.00833424f, 0.05041561f, 0.02702657f, 
    0.03395583f, -0.01283372f, 0.02752459f, 0.03993602f, 0.00628414f, -0.05018767f, -0.01870542f, 0.00927088f, 
    -0.05828965f, 0.03334405f, 0.01696575f, 0.00904207f, 0.02654484f, -0.00173577f, 0.02846908f, -0.05665883f, 
    -0.06313145f, 0.02015462f, 0.00800878f, 0.00921867f, 0.04092772f, -0.02002659f, -0.01043132f, -0.05980098f, 
    -0.04030451f, 0.00072541f, -0.02899609f, -0.03089918f, -0.00744374f, 0.00565607f, -0.04133862f, -0.02451985f, 
    0.02511091f, -0.00218714f, -0.03868556f, 0.00457346f, 0.01895860f, 0.01823104f, -0.04646404f, -0.06295931f, 
    -0.04436376f, -0.02207258f, -0.03418497f, -0.01352312f, -0.01455655f, 0.03472190f, 0.00352464f, -0.04508857f, 
    -0.00252813f, -0.06107011f, -0.00428470f, -0.01071034f, 0.01459925f, 0.03252862f, -0.02874617f, 0.00380247f, 
    -0.05275447f, 0.01660535f, 0.00734593f, -0.03945384f, 0.02826920f, -0.01490622f, -0.00585015f, -0.03198889f, 
    -0.03780244f, -0.03450231f, -0.06304174f, -0.05817521f, 0.04476014f, 0.02122909f, -0.06443661f, -0.01570240f, 
    0.02432866f, 0.02190300f, -0.02525841f, -0.04529058f, -0.02964557f, -0.03416244f, 0.01108129f, 0.01880276f, 
    -0.00979845f, -0.00010151f, -0.02204932f, -0.03780204f, -0.04199170f, 0.01537104f, 0.02006705f, 0.03940595f, 
    -0.04907199f, 0.02151111f, -0.02378300f, -0.06428117f, 0.00680785f, -0.04377366f, -0.05639027f, -0.03918134f, 
    -0.06320313f, 0.00161266f, -0.05948492f, -0.00156594f, -0.06271251f, 0.01623953f, 0.03163862f, -0.04630185f, 
    -0.05313179f, 0.02726846f, -0.02403950f, -0.04396944f, -0.05874947f, 0.04945818f, 0.01805841f, -0.01469202f, 
    -0.01565600f, -0.05864825f, 0.00424488f, 0.02977817f, 0.05023200f, -0.00608780f, -0.00954454f, 0.00435838f, 
    -0.01379243f, -0.03961466f, -0.03580362f, 0.02878999f, -0.01786877f, -0.00140643f, 0.02249024f, -0.03735079f, 
    -0.02386617f, 0.04115642f, -0.02885697f, 0.04103536f, 0.00104679f, -0.03931923f, -0.05476111f, 0.01079223f, 
    -0.01259421f, -0.01872912f, 0.05162050f, -0.04053992f, 0.04441004f, 0.04510014f, 0.02306525f, -0.01495342f, 
    -0.05664460f, -0.00809876f, -0.01738191f, 0.01407034f, -0.00222628f, 0.01070311f, -0.06167855f, -0.03449084f, 
    -0.06384741f, 0.04849192f, -0.06143172f, -0.06468283f, -0.00749364f, 0.04863530f, -0.06378208f, -0.01021778f, 
    -0.00057620f, 0.04677183f, -0.04050814f, -0.03925033f, -0.03715554f, -0.02318163f, -0.05979851f, 0.02072924f, 
    -0.01378775f, 0.05132495f, 0.00376545f, -0.05744806f, 0.04884452f, 0.03587513f, -0.00790088f, 0.01825492f, 
    -0.00119917f, -0.01217561f, -0.04303054f, -0.01780680f, -0.01356150f, -0.03994543f, 0.02355050f, 0.00314579f, 
    -0.01852065f, -0.03127664f, -0.00975582f, 0.00613094f, 0.03178982f, 0.03506783f, 0.04169190f, -0.05469054f, 
    -0.01091682f, 0.03961483f, -0.04711508f, -0.03178198f, -0.04257324f, 0.03463555f, -0.01682206f, 0.04336031f, 
    0.02582626f, -0.05540623f, 0.01274061f, 0.04881961f, 0.05132708f, -0.04946173f, 0.02638715f, -0.04072063f, 
    -0.04647681f, 0.02997914f, 0.00048989f, -0.05852883f, -0.01379026f, 0.03075065f, 0.05059872f, 0.02144774f, 
    0.04825167f, -0.06398458f, -0.01451435f, 0.02074082f, -0.06092816f, -0.03278321f, -0.00891061f, -0.00209182f, 
    -0.06311212f, 0.04111561f, 0.01433101f, -0.05282435f, 0.00292791f, -0.04507449f, 0.01810290f, 0.04853737f, 
    0.02524280f, -0.03969546f, 0.00428901f, 0.04797033f, 0.02459457f, 0.05119455f, 0.00262136f, -0.05749666f, 
    0.01679848f, 0.00806252f, -0.02763571f, -0.00956487f, 0.03494627f, -0.05095509f, 0.01492761f, -0.06156057f, 
    -0.00859858f, 0.04955592f, 0.01070218f, 0.02611699f, -0.04113856f, -0.01591765f, 0.04512701f, -0.02819937f, 
    -0.00300670f, 0.02469703f, -0.00514982f, -0.06288067f, -0.03673372f, -0.00610656f, -0.05404124f, -0.05197832f, 
    -0.00372052f, -0.02455573f, -0.01442747f, -0.01732937f, 0.00507821f, 0.05097698f, -0.06255268f, 0.02713131f, 
    0.04986055f, 0.01072030f, -0.01326999f, -0.03419434f, -0.03154393f, -0.02635462f, 0.02506100f, -0.00384532f, 
    -0.00382259f, -0.03347921f, -0.03259031f, 0.01988365f, -0.04186594f, -0.00092768f, 0.03039837f, -0.05217785f, 
    0.01745325f, 0.03410918f, 0.01770961f, -0.05103826f, -0.02324575f, -0.00735699f, -0.00992402f, 0.00681776f, 
    -0.02813728f, 0.02697488f, -0.04318142f, -0.01419488f, -0.04621811f, -0.01198273f, -0.03748824f, -0.05961025f, 
    -0.05527521f, -0.01920494f, 0.02552085f, -0.03107064f, -0.04247940f, 0.00333917f, 0.04365572f, 0.01262129f, 
    0.01356246f, -0.01758282f, -0.05300798f, -0.04944668f, -0.03667928f, 0.03698054f, 0.04279768f, -0.03135459f, 
    -0.06257301f, -0.03134328f, -0.04744824f, 0.02436991f, -0.01457068f, 0.04843972f, 0.01148172f, 0.03197221f, 
    -0.04530166f, 0.01580590f, -0.01352727f, -0.04697809f, 0.00920747f, -0.02924962f, -0.04378900f, 0.04837832f, 
    -0.03770506f, -0.01176040f, -0.03684396f, 0.00935285f, 0.04274124f, -0.05676934f, 0.02034773f, -0.04106613f, 
    0.01479992f, 0.00363779f, 0.02893164f, -0.01317932f, 0.04813796f, -0.03973369f, -0.02714065f, 0.00720967f, 
    -0.02422286f, -0.04086584f, -0.01520692f, -0.04425190f, -0.02127016f, -0.03680617f, 0.03541565f, 0.02542232f, 
    0.02776469f, -0.04897007f, -0.04974872f, 0.05154232f, -0.00254553f, 0.00048070f, -0.02427828f, 0.05084741f, 
    0.00360597f, -0.00836042f, 0.06656897f, 0.04821168f, -0.03849190f, 0.04074052f, -0.00895967f, 0.00380638f, 
    0.04785420f, 0.03930821f, 0.00248780f, -0.05771277f, -0.03332828f, -0.01147885f, -0.01283891f, -0.03198561f, 
    -0.05731521f, -0.03347682f, -0.05499753f, 0.01174608f, -0.01741872f, -0.02797331f, -0.04599380f, -0.02722503f, 
    0.03618455f, -0.03177871f, -0.06538034f, 0.02361079f, -0.01158139f, -0.02169167f, 0.03589525f, 0.04469515f, 
    0.02535070f, -0.03881063f, -0.05723867f, -0.04199016f, -0.03540678f, -0.00667721f, -0.02387691f, 0.03618028f, 
    -0.01186449f, -0.04902883f, 0.03940328f, -0.04326715f, -0.00626978f, -0.00771690f, 0.01299426f, 0.00426109f, 
    -0.00769286f, -0.01076033f, 0.04256282f, -0.04622044f, -0.00292701f, 0.03393042f, 0.02219268f, -0.01041931f, 
    0.02575089f, 0.02669336f, -0.00872120f, -0.01507908f, 0.01818305f, 0.04359340f, 0.01465201f, 0.02384825f, 
    0.04550915f, -0.01529363f, -0.02743447f, -0.06080984f, -0.00960194f, -0.04005677f, 0.03302558f, -0.06066123f, 
    -0.05840073f, -0.02018725f, 0.05714679f, -0.01813314f, -0.03295634f, 0.02252172f, -0.00345950f, -0.02235807f, 
    0.03989293f, 0.01256607f, -0.05472165f, 0.04616776f, -0.03347967f, 0.00596402f, 0.03925429f, -0.05880686f, 
    0.03794963f, -0.03357399f, -0.00473744f, -0.00024932f, 0.05266024f, 0.01767327f, -0.03831464f, -0.00027557f, 
    0.02325271f, -0.00852595f, 0.02051153f, 0.03508363f, -0.01624244f, 0.04817200f, -0.02177855f, 0.04898453f, 
    0.03132666f, 0.05079151f, -0.04552975f, -0.01233019f, 0.05719220f, 0.00658588f, 0.03558616f, -0.04454917f, 
    -0.00165943f, -0.02104000f, -0.03349068f, -0.04070733f, 0.01752938f, -0.01975450f, -0.02453986f, 0.04804248f, 
    0.02384149f, 0.02402830f, 0.03536461f, -0.04194588f, 0.01184834f, -0.02273140f, -0.05566776f, 0.00786185f, 
    -0.03200831f, 0.02680524f, -0.06110006f, 0.04639854f, 0.00054964f, 0.01092858f, -0.04683172f, -0.04278884f, 
    -0.04976169f, 0.03807571f, 0.05521849f, 0.00370245f, -0.04824797f, 0.05320560f, -0.01902388f, -0.01218203f, 
    -0.04980012f, -0.03282811f, 0.03941668f, -0.05430906f, -0.02332079f, -0.03006881f, -0.01136215f, 0.04079961f, 
    0.01902084f, -0.03219732f, 0.00054316f, -0.02767848f, -0.00018423f, -0.02560109f, 0.01756862f, 0.00246755f, 
    -0.04534693f, 0.03075633f, -0.01072835f, -0.03125773f, 0.06203173f, -0.04479520f, -0.00280327f, -0.01150506f, 
    0.00046928f, -0.01559451f, -0.00341661f, 0.01893474f, -0.00296600f, -0.01538121f, 0.02990714f, -0.02574146f, 
    0.00637557f, -0.02657647f, -0.03410967f, -0.02116011f, -0.04975582f, 0.03620676f, -0.06956527f, -0.02614796f, 
    -0.05699119f, -0.01864036f, -0.01719659f, 0.02473637f, -0.00333122f, -0.06229335f, 0.01194877f, 0.03637142f, 
    0.02142198f, -0.03397877f, -0.00367176f, -0.04129564f, -0.04194098f, 0.02237256f, 0.04475375f, 0.01693989f, 
    -0.05173093f, 0.02338352f, 0.00917253f, 0.07920251f, -0.11114573f, -0.05884058f, -0.06443720f, -0.00438721f, 
    -0.10561159f, -0.18348360f, -0.13006514f, -0.00150839f, -0.08390715f, 0.08723932f, -0.00753257f, 0.05555785f, 
    -0.05646922f, -0.00142779f, 0.25617132f, 0.21650921f, -0.10609251f, -0.08701002f, -0.10623546f, 0.08224913f, 
    -0.03410454f, -0.00672811f, -0.01491134f, 0.42497286f, 0.15057851f, 0.04785673f, 0.05211343f, -0.01175626f, 
    -0.10223059f, -0.06912908f, 0.01019791f, 0.12934004f, -0.11429503f, -0.06515122f, 0.07139764f, -0.06819314f, 
    0.05654659f, 0.06226398f, -0.16629860f, -0.14078918f, 0.02508157f, 0.21724866f, 0.04454920f, 0.04013973f, 
    0.14771865f, -0.08282237f, 0.13520490f, 0.19104776f, 0.05713021f, 0.27510121f, -0.15881623f, 0.14493880f, 
    0.03824634f, 0.08042911f, -0.00205332f, -0.02572284f, 0.15530546f, 0.11030181f, 0.05207410f, -0.03368442f, 
    -0.21247405f, -0.15001398f, 0.02833389f, -0.01438966f, 0.28354052f, 0.15304655f, -0.09777980f, 0.06356276f, 
    -0.38939989f, 0.06488562f, -0.14741541f, 0.14323765f, 0.09333428f, 0.00275849f, -0.25514999f, 0.09526859f, 
    -0.12325148f, 0.31600896f, -0.01727260f, -0.18288559f, -0.17503630f, -0.15496756f, 0.19019748f, -0.03794361f, 
    -0.07671554f, -0.12684903f, 0.26808935f, -0.09090066f, -0.07201340f, -0.02901564f, -0.05242496f, 0.03141099f, 
    -0.02752460f, -0.11857875f, -0.03382463f, 0.20877653f, 0.35111216f, 0.13931571f, 0.07960372f, 0.07123983f, 
    0.09824902f, 0.10555457f, 0.01205632f, -0.02526200f, -0.25489911f, 0.04818585f, -0.00124190f, 0.07710858f, 
    0.08871963f, 0.13461500f, -0.01124175f, 0.00858706f, 0.04941069f, -0.26006773f, 0.12170757f, -0.02414812f, 
    0.00608937f, 0.01983527f, 0.09649579f, 0.04349744f, 0.01985493f, 0.14461455f, 0.18478261f, -0.01107091f, 
    -0.04550684f, -0.16491146f, -0.09706981f, 0.12013306f, 0.14452344f, -0.07873599f, -0.12896906f, 0.08620736f, 
    0.11191083f, -0.13872884f, 0.04229350f, -0.09146887f, -0.16226223f, -0.15058428f, 0.10245308f, -0.04916754f, 
    -0.02880420f, 0.30144566f, -0.02062851f, 0.13755418f, 0.06372638f, -0.01364685f, -0.08301038f, 0.09135388f, 
    0.06944867f, 0.15927155f, -0.34044477f, 0.05252218f, 0.00934113f, 0.01815845f, 0.18068363f, 0.03330959f, 
    -0.05352570f, 0.10865530f, 0.16185006f, -0.05037395f, -0.20343809f, -0.15547870f, 0.17873311f, -0.07994076f, 
    0.17440258f, -0.05648582f, -0.10015157f, 0.18872753f, -0.16475946f, -0.05429776f, -0.19011816f, 0.03234780f, 
    -0.00426437f, 0.01902915f, 0.07590091f, -0.09822981f, 0.03010074f, -0.22168884f, -0.07168838f, -0.05786023f, 
    0.10012069f, 0.20606047f, -0.08154313f, -0.15779382f, -0.03914906f, 0.13378438f, 0.02536244f, -0.02579293f, 
    0.05269204f, -0.14213732f, 0.18934682f, -0.04823956f, -0.06031211f, 0.00844432f, -0.07791381f, -0.05287813f, 
    0.06052883f, 0.09033215f, -0.10379948f, 0.01605088f, 0.09910069f, -0.22111328f, -0.11496853f, 0.24270955f, 
    -0.26509988f, -0.02078240f, -0.08885303f, -0.03575728f, 0.24042098f, -0.16036940f, 0.08364975f, -0.06196024f, 
    -0.48704129f, -0.06971876f, -0.01312280f, 0.17151615f, -0.01454398f, -0.13383968f, -0.13885334f, 0.09070780f, 
    0.04872075f, -0.05744790f, 0.14076227f, 0.15866183f, 0.06675365f, -0.01251421f, 0.07885951f, -0.15624425f, 
    -0.02650868f, -0.05708802f, 0.24290515f, -0.08516769f, 0.07533206f, -0.08205735f, 0.13765635f, 0.20997290f, 
    0.17721073f, -0.00937722f, 0.03837838f, 0.33683518f, -0.04316645f, -0.14679334f, -0.01796876f, -0.01677232f, 
    0.05570428f, -0.07649157f, 0.06299596f, 0.05195801f, 0.00176435f, 0.16912533f, 0.07551534f, 0.04975081f, 
    -0.01979487f, 0.05152421f, 0.06187456f, -0.03873403f, 0.13306211f, 0.03634049f, 0.00526631f, 0.02180748f, 
    -0.02129100f, 0.02347002f, 0.14904030f, -0.11727700f, -0.19132437f, 0.11678062f, 0.17467833f, 0.01748971f, 
    -0.07860090f, 0.06256242f, -0.07094454f, 0.07251873f, -0.01731594f, 0.12443846f, 0.00327707f, -0.14177069f, 
    0.08639712f, 0.08167767f, 0.11363341f, -0.04795996f, 0.02462181f, 0.13297474f, 0.13445090f, -0.00076312f, 
    -0.12052759f, 0.36822480f, 0.05681331f, 0.06281637f, -0.11000676f, -0.02127477f, 0.24693549f, -0.06634422f, 
    -0.08079056f, 0.21332379f, -0.17480551f, 0.04867764f, -0.01778927f, -0.03819422f, 0.16890271f, -0.05518286f, 
    0.17512614f, 0.08347906f, -0.24226451f, -0.21955691f, -0.11160498f, -0.01638535f, -0.04955661f, 0.08592804f, 
    0.09397074f, -0.05722352f, -0.04438598f, 0.19791642f, -0.03148153f, -0.15728611f, -0.09923499f, -0.09442485f, 
    0.03125620f, -0.08891289f, 0.18654677f, -0.05098915f, -0.02462575f, 0.00216405f, -0.23725434f, -0.04847405f, 
    -0.02816922f, -0.05263774f, -0.01913532f, 0.18782966f, -0.13083461f, -0.12738174f, 0.03915691f, -0.22944008f, 
    -0.04301707f, -0.02361249f, 0.21153697f, -0.12325627f, -0.02278128f, 0.00787428f, 0.23252183f, 0.01265517f, 
    0.17349799f, 0.04794057f, -0.11558246f, 0.09644791f, 0.08898016f, 0.06090003f, 0.22849064f, -0.28838643f, 
    -0.00235901f, 0.14316863f, 0.00575259f, 0.02144922f, -0.02317523f, 0.01926115f, -0.06365940f, -0.16765860f, 
    0.00773881f, 0.00442297f, 0.05922211f, 0.08381720f, 0.00994450f, 0.10870788f, 0.36247253f, 0.14984140f, 
    0.12683073f, -0.31040120f, -0.00239643f, 0.00311649f, 0.04585949f, -0.00149738f, 0.11166088f, 0.16079657f, 
    0.06003272f, -0.07881720f, -0.32285661f, -0.17857833f, 0.25111532f, -0.11711422f, -0.00893465f, 0.04789951f, 
    0.16214572f, 0.08859804f, 0.01593036f, 0.10508214f, 0.13141593f, 0.05842521f, 0.01387715f, -0.01639224f, 
    0.10395055f, -0.03823744f, 0.05396115f, 0.11103670f, 0.16804662f, 0.15927176f, -0.02613336f, 0.06465059f, 
    0.10610239f, 0.00685855f, -0.12789455f, 0.00243395f, 0.12864684f, 0.02787042f, -0.03137445f, 0.07825338f, 
    0.06726436f, 0.19560479f, -0.10836653f, 0.05145158f, -0.01542000f, 0.12809502f, -0.18727392f, -0.22203153f, 
    0.07449138f, 0.14423530f, 0.05799192f, 0.13009001f, -0.00800348f, 0.06240119f, -0.14233010f, 0.29484594f, 
    0.07685740f, -0.02877659f, -0.16210078f, -0.19911459f, 0.18704759f, -0.01040589f, 0.11249860f, 0.10079363f, 
    0.09067984f, 0.20764850f, 0.03188311f, 0.01752253f, -0.05476381f, 0.15764369f, 0.16523382f, -0.00194726f, 
    0.14653759f, -0.11646944f, 0.00231939f, -0.16155657f, -0.03205059f, 0.12014233f, -0.08571868f, 0.03251095f, 
    -0.23172729f, -0.01875296f, -0.10301936f, -0.09855767f, 0.17268150f, -0.01051078f, 0.20332804f, 0.11578886f, 
    -0.03471724f, -0.02136002f, 0.08741668f, -0.08412740f, -0.23376240f, 0.33514661f, 0.08451951f, 0.11231916f, 
    -0.02768192f, -0.04384507f, 0.12021945f, -0.04378209f, 0.03016366f, -0.10530113f, 0.03374526f, 0.16978613f, 
    0.23137191f, 0.07528980f, 0.06362598f, -0.26441297f, -0.02379894f, -0.25490886f, 0.10248774f, -0.13738863f, 
    0.04619948f, -0.04088331f, -0.11337265f, 0.15541208f, -0.05642098f, -0.03722822f, -0.10866414f, -0.45839646f, 
    -0.28109241f, 0.01208093f, 0.29056484f, 0.05234119f, -0.07806195f, 0.08863703f, 0.10588833f, -0.01832201f, 
    -0.18122612f, -0.24175867f, -0.00447472f, 0.07370657f, -0.07814933f, -0.02883551f, 0.12419622f, -0.15131885f, 
    0.29472277f, 0.15466936f, -0.05842661f, -0.13050190f, -0.17309459f, 0.11588880f, 0.07398097f, 0.09857447f, 
    -0.02740863f, -0.29454041f, 0.00655594f, 0.26820394f, 0.14181387f, 0.11557020f, 0.24056883f, 0.23183703f, 
    -0.09201387f, 0.18555291f, -0.04102385f, -0.09305665f, 0.07036485f, 0.07066855f, 0.19908974f, 0.04019504f, 
    0.02954249f, 0.05025649f, 0.05410564f, -0.29380494f, -0.11186223f, -0.19695395f, 0.01137641f, 0.19406760f, 
    0.06791110f, 0.00334052f, 0.24621750f, -0.15784062f, -0.04674017f, 0.02043780f, 0.13443704f, 0.21183121f, 
    -0.00853863f, 0.15636685f, 0.00179851f, -0.12840615f, -0.17783114f, -0.10492770f, 0.05023445f, 0.05717215f, 
    -0.03981849f, 0.04685669f, -0.05436820f, 0.03880407f, 0.15223292f, -0.14748743f, -0.07917392f, 0.13171971f, 
    0.00188601f, -0.04899370f, 0.10702492f, 0.01254454f, 0.15999821f, 0.05297541f, -0.01569032f, 0.12514694f, 
    -0.00858222f, 0.04835344f, 0.13989042f, -0.01227526f, 0.08968897f, -0.14544573f, 0.00506430f, 0.13244900f, 
    0.15061110f, -0.26538959f, -0.21595958f, -0.17542718f, -0.07713961f, -0.02659465f, 0.13468431f, -0.11171739f, 
    -0.04818526f, -0.10047999f, -0.06872387f, -0.11749930f, -0.01665648f, -0.14325339f, 0.01146534f, -0.08896151f, 
    0.01491222f, 0.08888663f, -0.03447021f, -0.40686443f, -0.19930018f, 0.04314483f, -0.01105710f, 0.13290076f, 
    0.09221431f, -0.08313231f, -0.05235602f, -0.07255288f, 0.00213370f, 0.09857544f, 0.02366456f, 0.07835906f, 
    0.04943444f, 0.00900568f, 0.02869949f, 0.05354173f, -0.00920330f, -0.02413601f, 0.05389155f, -0.14418861f, 
    -0.10636868f, -0.12252022f, 0.02018886f, 0.00190943f, -0.05433361f, 0.22175601f, 0.02097444f, -0.37833008f, 
    0.04898572f, 0.03631345f, 0.09361572f, -0.07101760f, -0.00366710f, -0.01595000f, -0.06832076f, 0.32711226f, 
    0.25305271f, 0.19594844f, 0.12538759f, -0.03454783f, 0.10639238f, -0.06339604f, 0.02126208f, 0.30627802f, 
    -0.09784101f, -0.00155522f, 0.02982838f, 0.00354025f, -0.01418100f, 0.20461732f, 0.00032920f, -0.01236924f, 
    -0.15456738f, 0.23810051f, 0.29839391f, -0.02522537f, 0.08093186f, -0.03503903f, -0.04766186f, 0.02064347f, 
    0.01474731f, -0.08953577f, -0.07509602f, 0.11618838f, -0.06027251f, 0.03584202f, 0.11378163f, 0.17979583f, 
    0.08406011f, 0.01625234f, 0.25960827f, -0.21114507f, -0.24742125f, -0.12381250f, 0.13231058f, 0.02710708f, 
    -0.04536351f, -0.06006326f, 0.01341828f, -0.09568784f, 0.14907651f, 0.25270543f, 0.11659689f, 0.07861680f, 
    -0.10218121f, -0.03223414f, -0.11965323f, -0.07557286f, -0.10926884f, 0.18933536f, 0.26358184f, -0.00668239f, 
    0.03988570f, 0.01369042f, -0.03326430f, 0.01497466f, 0.02166176f, -0.11070982f, 0.20841038f, 0.06363934f, 
    0.14924084f, 0.05512992f, -0.07842565f, 0.10828208f, 0.00906469f, 0.07033321f, 0.19279033f, -0.26110384f, 
    -0.23247455f, 0.04131029f, -0.01610302f, 0.06833752f, 0.13925619f, 0.06010737f, -0.17608789f, 0.01689697f, 
    0.08285611f, 0.23741734f, 0.06289250f, 0.14232144f, 0.00363247f, 0.07926477f, 0.02027286f, -0.01684128f, 
    -0.09821198f, 0.38852304f, 0.10833137f, -0.11644836f, -0.01313511f, -0.05983773f, -0.05824045f, -0.08153865f, 
    0.02967322f, -0.06730657f, -0.22178656f, 0.12558214f, -0.06704953f, 0.05425898f, 0.02840856f, -0.09974300f, 
    -0.01160213f, 0.05420036f, -0.03931351f, 0.00100046f, -0.36496451f, 0.05771945f, 0.10674404f, 0.22944184f, 
    -0.06927279f, -0.12188707f, -0.07457727f, 0.12353621f, -0.00927550f, -0.12800767f, 0.01218146f, -0.03272829f, 
    -0.07310631f, -0.07548667f, 0.00531779f, 0.03731295f, 0.18435439f, -0.13256793f, 0.02008075f, 0.05667762f, 
    0.01608194f, 0.09809334f, -0.07179829f, -0.02023855f, -0.07247423f, 0.04860853f, -0.03020111f, -0.30530244f, 
    -0.07960324f, -0.03822032f, 0.00950637f, 0.18869381f, -0.12992279f, -0.17271589f, 0.09131451f, -0.21224116f, 
    0.07946993f, -0.09309489f, -0.01072219f, 0.15118742f, 0.01031613f, -0.10637122f, -0.14925531f, 0.05789166f, 
    -0.35681060f, 0.03327306f, -0.14244819f, -0.04410009f, -0.02028470f, 0.03562026f, -0.05815163f, 0.22233935f, 
    -0.17857195f, 0.24979150f, 0.27746072f, 0.02079565f, -0.00024511f, -0.15143876f, 0.09580733f, 0.08809146f, 
    0.01716793f, -0.21464474f, -0.12450134f, 0.07747041f, 0.14215501f, -0.04124957f, 0.03032820f, -0.00028963f, 
    -0.01618287f, 0.08816710f, 0.29597867f, -0.29263934f, -0.09764888f, 0.06961256f, -0.01359762f, 0.06853821f, 
    0.14474414f, -0.11439712f, 0.01427311f, -0.10718723f, -0.15665016f, 0.01597305f, -0.12160882f, 0.17086993f, 
    0.09379967f, -0.07011435f, -0.03316955f, 0.08271646f, -0.13991836f, -0.06135175f, -0.16911256f, -0.07747044f, 
    -0.05959050f, -0.02027979f, -0.17328380f, 0.08089541f, -0.03405584f, 0.04995403f, -0.07531647f, -0.15152943f, 
    0.06956699f, -0.01454692f, -0.04626942f, -0.11960465f, -0.02483678f, -0.05144151f, -0.13302343f, -0.18440071f, 
    -0.04532992f, -0.05684594f, -0.10159121f, -0.00727010f, -0.14173290f, 0.05144523f, 0.09896123f, -0.09184726f, 
    0.10170177f, 0.07680444f, 0.12402949f, 0.07700288f, -0.09078550f, 0.08328499f, 0.10051648f, -0.06262313f, 
    0.24623583f, 0.06996756f, 0.06583182f, 0.11386221f, 0.13243590f, -0.01819529f, 0.17642386f, -0.02130618f, 
    -0.05890994f, -0.32105362f, -0.11698543f, -0.15647325f, 0.04646829f, 0.18668605f, 0.02092431f, 0.06339557f, 
    0.11202058f, -0.14643487f, -0.04251336f, -0.00294856f, 0.08681788f, 0.11188672f, 0.12710509f, 0.06232712f, 
    -0.05948119f, 0.02731391f, 0.25931719f, 0.03323707f, 0.03663038f, 0.02126953f, 0.08024467f, 0.12505983f, 
    0.07121939f, 0.09485069f, -0.01651721f, -0.01965736f, 0.03028414f, 0.12280755f, 0.07027076f, -0.24144110f, 
    -0.09567884f, -0.23619196f, -0.04891948f, -0.14028281f, 0.08561363f, -0.08732861f, 0.15640943f, -0.15911999f, 
    -0.29828700f, -0.00575665f, -0.18001729f, 0.07750057f, -0.00109158f, -0.03970629f, 0.12040384f, -0.13563436f, 
    -0.15214854f, -0.01707878f, 0.05770999f, 0.09217414f, -0.01632670f, 0.02647010f, -0.05078734f, 0.04696104f, 
    -0.14919899f, -0.09095959f, 0.08011273f, -0.13167591f, -0.09826507f, -0.03575232f, -0.15237452f, -0.11403678f, 
    0.10926127f, -0.15814020f, -0.04693171f, 0.01322116f, 0.04234392f, 0.10311266f, 0.09962407f, -0.09071107f, 
    -0.20360811f, 0.01326946f, 0.17338364f, -0.03741556f, -0.11891840f, 0.01918259f, -0.04147884f, -0.05675439f, 
    0.01218986f, 0.04073442f, -0.34257826f, -0.08596144f, 0.04907836f, 0.07034157f, 0.11068875f, -0.06487979f, 
    -0.14543205f, 0.16842093f, 0.16977431f, 0.18030497f, -0.11032552f, -0.03318553f, -0.07833532f, 0.08682045f, 
    0.09131391f, -0.04734344f, 0.02593337f, 0.12058790f, 0.19683811f, -0.09839401f, 0.02145423f, 0.07982534f, 
    0.06893453f, 0.10578837f, 0.01840034f, 0.04531200f, 0.17954481f, -0.12919787f, -0.26550594f, -0.09602606f, 
    -0.07680070f, -0.04734769f, 0.07203352f, 0.12057757f, 0.01003826f, -0.05905667f, 0.01783884f, 0.02186208f, 
    0.04302102f, 0.00253620f, 0.00578695f, 0.03770547f, -0.11001904f, 0.07908232f, -0.06236407f, 0.28180027f, 
    -0.10367750f, 0.02778542f, -0.00241266f, 0.05042665f, 0.08330306f, 0.07193995f, -0.07040044f, -0.05692759f, 
    0.10961850f, -0.03931094f, -0.14776498f, 0.06539123f, 0.11802503f, -0.03852877f, 0.16317970f, -0.08764872f, 
    -0.03461152f, -0.01095266f, 0.26491427f, 0.08248781f, -0.17923334f, 0.03078590f, 0.04885826f, -0.02667141f, 
    -0.13924573f, 0.02076637f, 0.01499651f, 0.00137764f, 0.12110017f, 0.04129286f, -0.15196846f, -0.03444675f, 
    0.02865095f, 0.06084499f, -0.05459184f, 0.05920832f, 0.25205162f, 0.09404047f, 0.05481870f, 0.02137598f, 
    -0.14138378f, -0.15897268f, 0.05461666f, 0.09146767f, -0.06634264f, 0.13153905f, -0.02624531f, 0.05219195f, 
    -0.01709328f, 0.04614640f, -0.16358261f, -0.02644088f, 0.02023277f, 0.11018697f, 0.03976510f, -0.15009136f, 
    -0.11053964f, -0.02907799f, -0.19484870f, 0.02424000f, 0.03653122f, -0.07729834f, -0.24011567f, -0.14225441f, 
    0.00832568f, 0.10796669f, 0.24038868f, 0.20122142f, -0.05120354f, 0.01466502f, -0.06170711f, -0.10613284f, 
    0.16531554f, 0.13473566f, 0.06187961f, 0.02967977f, -0.01001434f, -0.14978142f, 0.02235586f, 0.05704969f, 
    0.21797608f, -0.28230754f, -0.15372540f, -0.01356067f, -0.03576567f, -0.02089119f, 0.09688671f, 0.06930248f, 
    0.06961314f, 0.14296506f, -0.24139297f, -0.21168424f, -0.15763408f, 0.09789713f, 0.04046754f, 0.08670528f, 
    -0.09429035f, -0.02907555f, -0.22799885f, -0.00190688f, 0.01010916f, -0.01347412f, 0.03938080f, 0.04822283f, 
    -0.15958019f, 0.12421872f, 0.08135111f, -0.10847954f, 0.07961853f, 0.04589599f, -0.00940392f, -0.10055902f, 
    -0.06792478f, 0.00115115f, -0.02435330f, 0.10461777f, 0.01899604f, 0.15126123f, -0.04669292f, -0.17260689f, 
    -0.08052292f, -0.08755876f, 0.04737353f, 0.06490821f, -0.02235566f, 0.04917382f, 0.02632977f, -0.10319085f, 
    -0.06696433f, 0.11608415f, 0.08694694f, 0.00999972f, 0.11497577f, -0.06417951f, 0.00163000f, 0.16677609f, 
    -0.04173403f, 0.01053088f, 0.04840083f, -0.04564276f, 0.14956246f, -0.03280137f, 0.03888293f, 0.20666546f, 
    -0.08268613f, -0.05973688f, 0.02326808f, -0.01764962f, -0.04592794f, 0.12247330f, 0.00382075f, 0.04562159f, 
    -0.17739968f, 0.06314073f, -0.16090921f, 0.04574974f, 0.08067031f, 0.00213880f, 0.16341433f, -0.03452005f, 
    0.08672506f, 0.19507566f, 0.25221974f, -0.02666128f, 0.00574326f, -0.14556685f, -0.14939325f, 0.07805052f, 
    0.08379615f, 0.10567241f, -0.07664575f, -0.06838502f, 0.24153399f, -0.15995045f, 0.01307867f, -0.03735528f, 
    -0.05987185f, 0.04047733f, 0.21829787f, 0.09864927f, -0.06611324f, -0.16297394f, 0.03583344f, 0.00553458f, 
    0.02657518f, 0.00642831f, -0.08505658f, 0.02573833f, 0.08431226f, 0.28495204f, 0.24399418f, 0.04666260f, 
    0.00298135f, 0.12685893f, 0.09237008f, 0.22901516f, 0.16479346f, -0.11002869f, 0.26655388f, -0.19505185f, 
    -0.03709516f, 0.16100994f, 0.24376430f, -0.04044843f, -0.01338956f, -0.15090552f, 0.26309872f, -0.03951186f, 
    0.06621455f, 0.11921068f, 0.12348467f, -0.16190742f, 0.04096241f, 0.08005729f, 0.18665265f, -0.39960346f, 
    -0.29019931f, -0.19903368f, 0.22880082f, 0.13583033f, -0.11391588f, 0.12370020f, -0.02588108f, 0.07611223f, 
    0.04222304f, 0.11752287f, 0.03984443f, 0.11206061f, 0.03678406f, -0.11248038f, 0.06178476f, 0.21396534f, 
    0.13570288f, -0.09243611f, -0.06758454f, 0.19000186f, 0.18668227f, -0.10852030f, 0.11613827f, 0.02853221f, 
    0.10278247f, 0.15254149f, 0.07854168f, -0.11502175f, 0.18082991f, -0.18071330f, -0.04766544f, -0.12627542f, 
    0.08637486f, 0.14138469f, 0.07717792f, 0.05502013f, -0.18055715f, -0.21025112f, 0.14204064f, 0.25934261f, 
    -0.01862786f, 0.09278453f, 0.03798598f, 0.13398904f, 0.05918505f, -0.02384325f, -0.28253871f, 0.11748532f, 
    0.05878818f, -0.00620131f, -0.08457159f, 0.05870300f, 0.04631563f, 0.09140017f, 0.22834128f, 0.08253818f, 
    -0.00512497f, 0.02222422f, -0.06045828f, 0.15795061f, 0.10928157f, 0.00867479f, -0.14177357f, -0.32359761f, 
    0.06161735f, -0.21259573f, -0.01426859f, 0.11289571f, 0.04171653f, -0.07926677f, 0.12522617f, 0.06720743f, 
    -0.17161317f, -0.18537842f, 0.06113834f, 0.07555533f, 0.01742862f, -0.03151950f, 0.16300604f, 0.14028117f, 
    -0.10695426f, -0.06829916f, -0.13371594f, 0.21946229f, 0.08569670f, 0.05753659f, 0.15753080f, -0.05930209f, 
    0.01460647f, -0.21757253f, 0.19936030f, 0.14402157f, 0.17269269f, -0.05428125f, -0.06434958f, 0.07961125f, 
    0.02627086f, -0.02585751f, -0.09886950f, -0.26526663f, -0.23058413f, -0.01553048f, 0.16176356f, 0.04625871f, 
    0.03713341f, -0.15534995f, 0.03319054f, 0.05064459f, -0.19245368f, -0.29547483f, -0.18195324f, 0.18729705f, 
    0.09335980f, 0.12381538f, 0.07156783f, -0.16807510f, -0.02039057f, 0.10713024f, -0.09828589f, -0.06702787f, 
    0.02094348f, 0.16592135f, 0.04085418f, -0.05868463f, -0.02912325f, -0.21313439f, 0.20829298f, 0.00881113f, 
    -0.02736154f, -0.08277889f, 0.23161939f, -0.02876190f, 0.11452143f, 0.11147282f, 0.28414556f, 0.16689605f, 
    -0.12575684f, -0.07508622f, -0.15447159f, -0.01761304f, 0.06351183f, 0.12275484f, 0.26024562f, -0.06527486f, 
    0.02913668f, 0.01590559f, -0.09833325f, -0.15325207f, -0.15503579f, 0.00895867f, -0.05886540f, -0.12518096f, 
    0.03131042f, 0.10583117f, 0.08035105f, 0.37251168f, -0.04434606f, -0.15165102f, 0.09984823f, 0.02429809f, 
    0.06176151f, -0.01771347f, 0.09413195f, -0.09112887f, -0.07065899f, -0.19767047f, 0.03268261f, 0.14846030f, 
    0.07026925f, 0.13291505f, 0.25409839f, -0.05743869f, -0.00149557f, -0.06998045f, -0.10892489f, -0.12857218f, 
    0.08218874f, 0.14593235f, 0.14997295f, -0.12875092f, 0.06488325f, 0.12904991f, 0.02879252f, 0.09750734f, 
    -0.02540226f, 0.07799698f, 0.11342518f, 0.11079571f, -0.08428358f, -0.10547230f, -0.22122583f, 0.09538592f, 
    0.19780312f, 0.06282309f, 0.10267072f, -0.01560997f, -0.05844949f, -0.05306999f, 0.06929890f, 0.16615373f, 
    0.09364641f, -0.05849327f, -0.06207426f, 0.13203822f, 0.20336352f, -0.05916466f, 0.12377157f, -0.09856494f, 
    0.07401244f, 0.06227180f, -0.02728353f, 0.07457778f, 0.08549181f, -0.02334055f, 0.11460379f, 0.00307485f, 
    0.09783936f, -0.47208169f, 0.05727216f, 0.09528357f, 0.09190410f, 0.12188739f, -0.00119323f, -0.00310232f, 
    0.02861840f, 0.06376933f, 0.05589218f, 0.14319588f, 0.11835381f, -0.06357522f, -0.19668990f, -0.09196787f, 
    0.03422887f, 0.36140966f, -0.24971269f, 0.10168128f, -0.02456200f, 0.25722361f, 0.17307882f, 0.11263418f, 
    -0.03130087f, 0.05303717f, 0.22140443f, -0.05079685f, 0.19561520f, -0.01811488f, 0.05790368f, 0.04869200f, 
    -0.11711013f, -0.05427313f, 0.15844567f, -0.07903194f, 0.10260248f, -0.32390752f, -0.01994222f, -0.04374723f, 
    -0.13779649f, 0.03145776f, 0.07259292f, -0.33278090f, -0.19694334f, -0.10090891f, 0.32270575f, 0.10078267f, 
    -0.01690011f, 0.01875931f, -0.02609591f, -0.07595143f, -0.05114754f, -0.25166768f, -0.20447768f, -0.05348343f, 
    0.04823465f, 0.08669804f, -0.05155046f, 0.04298322f, -0.15870053f, -0.00676267f, -0.00304148f, 0.12727511f, 
    -0.04700323f, 0.01506026f, -0.09071352f, 0.05587300f, 0.10871555f, 0.19770682f, -0.02395019f, -0.42092034f, 
    0.08397705f, -0.15960668f, -0.00838350f, -0.04048839f, 0.01935375f, 0.11045925f, -0.07803186f, 0.01231384f, 
    -0.11615450f, 0.03722055f, -0.11479967f, -0.00076127f, 0.02806380f, 0.01418352f, -0.04522094f, -0.09514292f, 
    -0.01366280f, 0.14954695f, -0.17055814f, 0.14304246f, -0.07269619f, -0.03358183f, 0.05056413f, 0.16586865f, 
    -0.23357028f, 0.13499068f, -0.10359283f, -0.07086401f, 0.06349204f, 0.06835217f, 0.03278232f, 0.11724007f, 
    -0.06765649f, -0.00228548f, -0.10630140f, -0.27013922f, 0.06025904f, -0.15658085f, 0.10276156f, -0.09419735f, 
    0.07727787f, -0.05382450f, -0.03682369f, 0.02136154f, 0.02019453f, 0.04324058f, -0.13057207f, 0.10317008f, 
    -0.06393293f, -0.01701109f, -0.04562541f, 0.04871529f, 0.09607370f, 0.09405980f, 0.03577108f, -0.09287222f, 
    0.02624840f, 0.01326192f, -0.02785922f, 0.07493123f, -0.01069282f, 0.15128969f, -0.02750945f, -0.07915428f, 
    0.09896799f, 0.01258351f, -0.10469083f, -0.01233831f, 0.15590465f, -0.03135895f, 0.12423588f, 0.14327881f, 
    0.23674618f, -0.33098224f, 0.04517902f, 0.06705800f, -0.09819145f, -0.05550261f, -0.22252564f, -0.05532932f, 
    -0.06692464f, 0.02614754f, -0.06514300f, -0.09201015f, 0.03385113f, -0.07364216f, 0.08373725f, 0.26568297f, 
    -0.03978758f, 0.28030354f, -0.14704271f, 0.21142934f, -0.01182568f, 0.11728455f, 0.03758270f, 0.04726929f, 
    0.20539220f, 0.14484318f, -0.47957423f, 0.44941479f, 0.06801245f, -0.03078313f, -0.08403087f, -0.00554816f, 
    0.00419490f, -0.18287009f, 0.14188570f, -0.27844444f, 0.21308686f, 0.18285181f, 0.14695577f, -0.09491485f, 
    -0.12170023f, -0.02633352f, -0.04473659f, -0.04659281f, -0.28352204f, -0.06036193f, -0.02113451f, 0.13083994f, 
    -0.01404159f, 0.10732976f, -0.05783471f, -0.05885664f, 0.00812797f, -0.17967786f, -0.11637795f, 0.12500940f, 
    0.08617452f, 0.04300294f, -0.00770224f, -0.02460769f, -0.12964702f, -0.04668330f, -0.00815601f, 0.06076328f, 
    -0.21579458f, 0.02755572f, 0.02213753f, 0.15916492f, -0.00674723f, -0.15953182f, 0.02695176f, -0.00208261f, 
    -0.14581825f, 0.21973774f, 0.09029677f, -0.00330432f, -0.02045867f, -0.12471368f, 0.12105121f, -0.03557427f, 
    0.11331321f, 0.03643458f, -0.30222362f, 0.02804892f, -0.01959299f, 0.03663738f, -0.08300132f, 0.04756973f, 
    -0.09629078f, 0.17542093f, -0.24759038f, -0.21600175f, 0.01447007f, 0.06630273f, 0.01675027f, -0.03943511f, 
    0.06013132f, 0.11625383f, -0.01644625f, 0.28892210f, -0.05661755f, -0.00455219f, 0.00551271f, 0.05071256f, 
    0.06981175f, 0.02170299f, 0.19852106f, -0.36475539f, -0.16820046f, 0.16453181f, -0.04233848f, -0.02334729f, 
    0.01094395f, -0.05182915f, -0.03260643f, -0.00968825f, -0.31767863f, 0.21351820f, -0.03391509f, 0.05209835f, 
    0.02551402f, 0.13982041f, -0.14375292f, 0.17587551f, 0.08778199f, 0.02933756f, -0.09735024f, 0.18869801f, 
    0.05943222f, 0.22694387f, 0.22451872f, 0.10050045f, 0.06183134f, -0.08150675f, -0.04680816f, 0.01291232f, 
    -0.08550394f, 0.09535185f, 0.02105501f, 0.10075117f, -0.04614772f, 0.03923786f, 0.05358190f, 0.10115935f, 
    0.24672069f, 0.04374854f, 0.10758932f, 0.07598044f, -0.05967071f, -0.10582957f, -0.10583019f, -0.09082324f, 
    -0.35534015f, -0.30466127f, 0.11656850f, 0.01801478f, 0.05138942f, -0.05652276f, 0.07681780f, 0.01455357f, 
    0.00755708f, 0.20715411f, 0.18451695f, 0.12262551f, 0.02874308f, -0.10067248f, 0.05248892f, 0.06005789f, 
    -0.09996195f, -0.03551450f, -0.08812806f, -0.20690818f, -0.20052862f, -0.01258020f, 0.06434423f, -0.13513277f, 
    0.04391812f, -0.06671694f, -0.02427508f, -0.03835370f, -0.09633969f, -0.22502449f, -0.03686098f, -0.03656460f, 
    -0.00265356f, 0.01126286f, 0.15402076f, 0.18990013f, -0.14514185f, -0.07687931f, 0.08980390f, 0.07971233f, 
    -0.03494787f, -0.07207488f, -0.06794591f, 0.06348863f, 0.00652578f, -0.01241336f, -0.06436116f, -0.10741405f, 
    0.10644922f, 0.14176148f, 0.00797009f, -0.10676332f, 0.03267127f, 0.10495104f, 0.11871667f, 0.00924818f, 
    0.13414629f, -0.05215885f, 0.07744467f, -0.06505660f, 0.21360181f, 0.14328931f, 0.13448071f, -0.48423055f, 
    -0.15706916f, 0.25259763f, 0.04644093f, 0.12692168f, -0.09969909f, 0.06089786f, 0.08395665f, -0.08815427f, 
    -0.18405379f, 0.15699898f, 0.03995993f, -0.05137798f, -0.03362797f, -0.13797629f, -0.13590007f, 0.02538195f, 
    -0.08993344f, -0.26848769f, -0.34562457f, -0.20217130f, -0.09716430f, -0.11440992f, -0.08802745f, -0.12003153f, 
    -0.04203039f, -0.06610404f, -0.13573009f, -0.19651923f, -0.15976723f, -0.22722718f, -0.04222319f, -0.07907374f, 
    0.06934668f, -0.14665768f, -0.12128119f, 0.12207494f, 0.09517363f, 0.05433165f, -0.02970955f, 0.09882529f, 
    0.11571950f, 0.04195990f, -0.00220220f, 0.21472663f, -0.08509593f, 0.13277483f, 0.19756165f, 0.15792875f, 
    0.10176712f, 0.10308172f, 0.10242306f, -0.11857759f, 0.05566716f, 0.16596764f, 0.06816469f, 0.17668986f, 
    -0.14799081f, 0.02054027f, 0.07154644f, 0.16220921f, 0.16180272f, -0.00170617f, -0.33773169f, -0.36973029f, 
    -0.00881609f, -0.02023818f, 0.04559197f, -0.03349075f, -0.02792710f, -0.06087177f, 0.07052711f, 0.17802045f, 
    0.13241000f, 0.07524113f, -0.17440960f, 0.07830398f, 0.03865340f, -0.00594094f, 0.04523027f, 0.15815662f, 
    0.10075065f, 0.14845039f, -0.11638086f, -0.14597502f, 0.18805340f, 0.20040272f, 0.01839859f, 0.16868018f, 
    0.12135136f, -0.13968331f, 0.03339422f, -0.26033846f, 0.01120513f, -0.07199083f, -0.07355317f, 0.21852010f, 
    0.08393422f, 0.06385403f, 0.24223086f, -0.26957887f, -0.32988051f, -0.01717685f, 0.04104117f, -0.10162362f, 
    0.20496489f, -0.15542659f, -0.06097882f, -0.19848695f, -0.25645310f, -0.00841048f, -0.11265609f, 0.21719624f, 
    -0.05465722f, 0.01114721f, -0.23428023f, -0.03420084f, -0.07528131f, -0.18551289f, -0.26302189f, 0.07481305f, 
    -0.00744820f, 0.22053307f, -0.11060107f, 0.02436873f, -0.05660369f, -0.36339834f, -0.19508743f, -0.04765233f, 
    0.19354478f, -0.08351808f, 0.00602991f, -0.01057085f, -0.01003562f, 0.02304422f, -0.12460212f, -0.09457893f, 
    -0.05128529f, 0.04831702f, -0.03348995f, -0.05549708f, -0.02255013f, -0.13943285f, -0.19132324f, -0.02440555f, 
    -0.30490276f, -0.49182743f, 0.07700920f, -0.13358030f, -0.34580266f, 0.03544464f, -0.15015492f, -0.27291250f, 
    0.04332631f, 0.05460459f, 0.21274556f, 0.14771447f, -0.01085846f, 0.02188038f, 0.03647224f, -0.02044205f, 
    0.00283199f, 0.17277417f, 0.02854977f, -0.19807802f, -0.02378849f, -0.09762178f, -0.05968811f, -0.17509823f, 
    -0.00754331f, 0.14744414f, 0.20469168f, 0.05869569f, -0.15035473f, 0.03841325f, 0.05009461f, -0.02667595f, 
    0.14362846f, 0.02746818f, 0.05503415f, -0.16700380f, -0.39616504f, -0.31207523f, -0.01763826f, 0.12167832f, 
    -0.01237867f, 0.09281561f, -0.01422429f, -0.05899145f, 0.03328892f, -0.36905470f, 0.11622558f, 0.13746656f, 
    0.10080018f, 0.06276036f, -0.02352765f, -0.02036586f, 0.13042988f, 0.06672427f, -0.07804335f, 0.12364220f, 
    0.01459872f, 0.12871364f, -0.02342806f, 0.19053541f, 0.07036695f, -0.01010919f, 0.01063419f, -0.25850934f, 
    -0.36216009f, -0.01821936f, 0.04830573f, -0.05582294f, 0.03227741f, 0.01412458f, 0.17239286f, -0.04823197f, 
    0.18426821f, 0.13454381f, -0.01496069f, -0.00042691f, 0.06186269f, -0.08362903f, -0.15075555f, 0.11167549f, 
    0.04636831f, 0.03579158f, -0.02466041f, -0.21682502f, 0.12320903f, 0.04623312f, 0.07208281f, 0.12900081f, 
    -0.08673135f, -0.15373988f, 0.02838643f, 0.07159109f, -0.04035671f, 0.09316878f, -0.16346946f, 0.23440760f, 
    0.02198025f, 0.10990478f, 0.07282170f, 0.19752944f, 0.18178019f, 0.04458404f, 0.09401260f, -0.08120655f, 
    0.05491973f, 0.10109554f, 0.12188064f, 0.04409476f, -0.04213697f, 0.02568436f, 0.00018743f, -0.05807357f, 
    -0.10773545f, 0.00434417f, 0.02150302f, -0.11447303f, 0.10701878f, 0.17253450f, 0.12177757f, 0.06228124f, 
    -0.08792977f, -0.12363247f, -0.07286093f, 0.12703578f, -0.02828111f, -0.14181845f, -0.04696606f, 0.20748612f, 
    0.10047972f, 0.05706887f, 0.07798463f, -0.11640231f, -0.16961780f, -0.17547478f, -0.11857777f, -0.01873117f, 
    -0.07033645f, -0.04349627f, -0.00328564f, 0.01426158f, -0.02656646f, -0.04571941f, -0.06821007f, 0.28243738f, 
    0.02754009f, 0.04778262f, -0.07156619f, -0.04622180f, 0.05221833f, -0.14796183f, 0.16328338f, -0.15101221f, 
    -0.04327291f, 0.01261354f, -0.19138205f, 0.10820732f, -0.08484475f, -0.04355166f, 0.00661257f, -0.00669974f, 
    0.03889348f, -0.08922517f, -0.06146717f, -0.14035335f, 0.24565279f, -0.15541381f, 0.01138852f, 0.07716664f, 
    0.01686181f, -0.01535606f, 0.22366498f, -0.00440269f, 0.09566458f, -0.02463470f, -0.04801792f, -0.00540966f, 
    0.00646466f, 0.01168555f, 0.05158610f, -0.13043846f, -0.03394683f, 0.00560191f, 0.10537253f, 0.06130896f, 
    0.14241487f, -0.16624938f, -0.04626321f, 0.07473684f, -0.18367210f, 0.05980192f, 0.03630583f, -0.03269495f, 
    0.02183353f, -0.05991411f, -0.03483560f, 0.00108541f, 0.09179624f, -0.09798900f, -0.06586974f, 0.01871842f, 
    -0.04856052f, -0.01485072f, -0.01875338f, 0.12375128f, 0.06542803f, 0.17689012f, 0.17571521f, 0.22490901f, 
    -0.00305198f, -0.02991651f, -0.01828188f, -0.06573471f, 0.05984735f, 0.11031597f, -0.06472050f, 0.01198559f, 
    -0.12347894f, 0.17178717f, -0.13607781f, 0.05450292f, 0.19034457f, 0.04168108f, -0.05280994f, 0.11273279f, 
    0.08299079f, -0.11583532f, 0.07681401f, -0.19281951f, -0.02153285f, 0.03171688f, -0.06439872f, 0.06216959f, 
    0.01157314f, 0.08881142f, 0.21265513f, 0.05719188f, 0.01137023f, -0.05649317f, -0.14060317f, -0.04467620f, 
    0.09704740f, -0.00295402f, -0.30152360f, 0.09603787f, 0.00471450f, 0.08990252f, 0.00540340f, -0.04704833f, 
    0.06193095f, 0.02351938f, 0.10733881f, 0.31982079f, 0.14478858f, 0.21950181f, 0.16044173f, 0.08179401f, 
    -0.06576856f, 0.17090057f, 0.06572085f, -0.02247709f, 0.07096323f, 0.14491560f, 0.00129063f, 0.05808190f, 
    -0.08882041f, -0.00025836f, 0.03696595f, 0.00147922f, -0.07375352f, 0.12261909f, -0.03174274f, 0.00456325f, 
    -0.00481839f, -0.10018808f, 0.08269297f, 0.07712815f, 0.10613552f, -0.15755183f, -0.05480691f, 0.18342741f, 
    -0.00837886f, 0.08112781f, -0.12273752f, 0.09072235f, -0.01388799f, 0.08208193f, 0.20322521f, 0.27031961f, 
    0.22272781f, 0.08273941f, -0.05045629f, -0.08413576f, -0.00957387f, 0.23178525f, 0.02504887f, 0.01165320f, 
    -0.31356636f, 0.05811236f, 0.09612253f, -0.02673628f, 0.03591305f, -0.02284346f, -0.07708997f, -0.00018006f, 
    0.02630696f, 0.16566709f, -0.08394291f, -0.01050331f, 0.03497432f, 0.02694970f, -0.01858452f, -0.19060071f, 
    0.10513501f, -0.01292306f, 0.01007374f, -0.05560472f, 0.04233262f, -0.03200468f, -0.09493959f, -0.06487020f, 
    -0.01123006f, 0.06590429f, 0.10477964f, -0.11919782f, 0.13760480f, 0.08924857f, 0.18435833f, -0.07740188f, 
    -0.13408078f, 0.06424969f, 0.04908752f, 0.00839194f, 0.16751142f, 0.03189861f, -0.08960897f, -0.18042067f, 
    -0.05812509f, 0.10735375f, -0.23146410f, 0.12354416f, -0.26092768f, 0.08932802f, -0.04060305f, 0.15122208f, 
    0.07642681f, 0.08088499f, -0.16354790f, 0.08298364f, 0.06230556f, -0.03206463f, -0.08420161f, -0.06194245f, 
    -0.07115687f, -0.03606196f, -0.02203047f, -0.03640835f, -0.08569607f, 0.00349888f, 0.01885888f, -0.30742204f, 
    -0.21055466f, -0.03837828f, -0.02622575f, 0.14012815f, -0.04021369f, -0.07568026f, -0.07763264f, -0.00162453f, 
    -0.11465622f, -0.19901954f, 0.10099193f, 0.01708645f, 0.05341762f, -0.03941933f, -0.06214844f, 0.08496991f, 
    -0.03251621f, -0.02317976f, 0.00351833f, 0.01202200f, -0.00589604f, -0.00780186f, -0.02283737f, -0.08829203f, 
    0.12856612f, 0.02304786f, 0.17223769f, 0.27199200f, -0.02077749f, 0.02284663f, -0.06293495f, 0.01344690f, 
    0.06212848f, -0.01027380f, -0.00034384f, -0.32829803f, -0.01645899f, 0.03074262f, -0.03253289f, -0.06603738f, 
    0.01917196f, 0.03192472f, 0.10499072f, 0.02400816f, -0.07365844f, -0.17346351f, -0.02241747f, 0.07840098f, 
    0.14749105f, 0.05262627f, 0.11219629f, 0.03874807f, -0.02164073f, 0.28553224f, 0.01066522f, 0.01400765f, 
    0.05321327f, 0.06673552f, 0.16604917f, -0.02612451f, -0.01856499f, -0.03332636f, -0.24833484f, 0.15064321f, 
    -0.28129476f, -0.12277425f, -0.05217350f, -0.01006664f, 0.00647268f, -0.01519691f, -0.00412952f, 0.11128323f, 
    -0.44654518f, 0.00495171f, 0.00932885f, 0.19765727f, -0.05866762f, -0.00345155f, 0.11219095f, 0.00394232f, 
    -0.29552737f, 0.05270127f, -0.05224236f, -0.00849986f, -0.07605575f, 0.04906803f, -0.12223027f, -0.01383893f, 
    -0.02867713f, 0.30907547f, 0.15235251f, -0.04356164f, 0.02844588f, 0.09628294f, 0.04007249f, -0.07211312f, 
    -0.05921261f, -0.08258183f, 0.33125499f, 0.28490016f, -0.19241321f, 0.15085737f, 0.07492559f, 0.02919755f, 
    0.07218616f, -0.00306351f, -0.01503238f, 0.27085516f, 0.19164504f, -0.32044855f, -0.11438782f, -0.00231801f, 
    0.12535398f, -0.09974883f, -0.04632657f, 0.01381404f, 0.10339413f, 0.10566153f, 0.03656704f, -0.15374997f, 
    -0.05134599f, 0.04842157f, -0.07725496f, 0.01374665f, -0.03892104f, -0.11494280f, 0.04315095f, 0.05621441f, 
    0.00844377f, 0.04854082f, -0.02111887f, -0.07938255f, 0.12354179f, 0.06506764f, 0.14171560f, -0.41966704f, 
    0.13481075f, -0.02327212f, 0.08727472f, 0.08824247f, -0.01565978f, 0.09169523f, 0.02017713f, -0.17014641f, 
    0.19631712f, -0.03190315f, -0.11540205f, 0.02103904f, -0.15157342f, 0.05938929f, -0.07281606f, 0.07097825f, 
    -0.46588823f, 0.11403625f, -0.06798626f, 0.06698710f, -0.06892499f, 0.12042401f, -0.08380321f, 0.07631338f, 
    0.07367472f, 0.03660643f, -0.14878434f, -0.21939602f, 0.03011840f, 0.02734792f, -0.15728988f, 0.04226821f, 
    0.01502846f, 0.03648161f, -0.10887935f, 0.07288451f, -0.33302355f, 0.01615765f, 0.00361653f, 0.13314505f, 
    0.05503817f, -0.00038787f, -0.05490416f, 0.08782427f, -0.21996526f, -0.18896316f, -0.13421157f, -0.02819756f, 
    -0.00191395f, 0.11785942f, -0.03514674f, 0.03025413f, -0.04448383f, -0.17083819f, -0.43400601f, 0.16735637f, 
    0.07777311f, 0.14975643f, 0.05887914f, -0.07630136f, -0.21503496f, 0.20475066f, -0.25316265f, 0.12397894f, 
    -0.15737383f, 0.11384439f, -0.08008840f, 0.02382510f, -0.07086091f, -0.08138514f, 0.01570257f, 0.07733666f, 
    0.08482375f, -0.08115982f, 0.07311747f, -0.20981680f, -0.14949396f, -0.12293284f, 0.00573881f, 0.15049969f, 
    -0.04547931f, -0.04855990f, -0.03088553f, -0.03700027f, -0.03880555f, 0.06153386f, 0.06376476f, -0.02700272f, 
    -0.09576888f, -0.01083206f, 0.21949084f, 0.13377959f, 0.12592384f, 0.08238460f, -0.08210023f, 0.10511131f, 
    0.03148524f, -0.49729446f, 0.11923245f, 0.01291268f, -0.00462948f, 0.01110133f, -0.06719939f, 0.09363230f, 
    -0.09748374f, 0.09160647f, 0.13755517f, 0.22033577f, 0.01889652f, -0.04317349f, -0.06175941f, -0.01752407f, 
    -0.04941427f, 0.11311696f, -0.04163924f, 0.44932356f, 0.04056392f, -0.18782771f, 0.02570702f, 0.15476868f, 
    0.12204444f, 0.01522606f, -0.05205841f, 0.11089227f, -0.31961408f, -0.35444066f, -0.25791919f, 0.09689873f, 
    0.05435668f, 0.08516144f, -0.07888819f, 0.05094371f, -0.01997042f, -0.11594050f, 0.13471669f, -0.01923995f, 
    0.11015917f, 0.02861752f, -0.00708377f, 0.08420583f, 0.07030464f, -0.15659137f, -0.08742712f, -0.18625984f, 
    -0.18920083f, -0.01125409f, -0.15308629f, 0.05073081f, -0.04113018f, -0.01435223f, 0.05292636f, 0.22886178f, 
    0.08826736f, -0.09181657f, -0.05564138f, -0.11149555f, 0.10245271f, -0.02941846f, -0.01584423f, -0.03677301f, 
    -0.11621065f, -0.04656700f, 0.11632577f, -0.01246852f, -0.03047830f, 0.17471854f, -0.01706180f, -0.05755574f, 
    -0.13585547f, -0.12622827f, -0.02267353f, 0.04144270f, 0.01367488f, 0.13575305f, -0.02346535f, -0.03045151f, 
    0.02031043f, 0.01266619f, 0.21677297f, 0.09389891f, -0.02314482f, -0.09041726f, 0.09755553f, -0.10303700f, 
    0.14672433f, 0.05236394f, 0.17261286f, 0.03707115f, -0.18891358f, -0.05542054f, 0.20132500f, -0.08366173f, 
    -0.07382830f, 0.00277616f, -0.04491534f, -0.03779119f, -0.05114845f, -0.11582342f, 0.09265241f, 0.08028119f, 
    -0.05620028f, 0.07730201f, 0.02375184f, 0.03153873f, 0.18683821f, 0.12036651f, -0.22992566f, -0.03034596f, 
    0.17172226f, 0.05993241f, -0.01744198f, 0.02694291f, -0.00695073f, -0.04715623f, 0.01893485f, 0.17482793f, 
    -0.19770479f, -0.09653991f, 0.02591942f, 0.14137834f, 0.07557723f, -0.08821712f, -0.13178341f, -0.10936536f, 
    -0.56935120f, 0.08572759f, 0.09573494f, -0.01740155f, 0.12301047f, 0.08648476f, 0.01867554f, -0.27874333f, 
    -0.08498241f, 0.05133231f, -0.01571347f, -0.14540817f, -0.06877954f, 0.09752614f, -0.05482583f, 0.04360455f, 
    0.08696420f, 0.12381120f, 0.11159083f, 0.03073068f, -0.08874353f, 0.02307383f, -0.23033081f, 0.05571550f, 
    -0.07875287f, 0.02809440f, 0.40201849f, 0.22983903f, -0.10747810f, 0.01821173f, 0.03413644f, -0.18873774f, 
    0.00788334f, 0.04680344f, -0.06138976f, 0.17546630f, -0.01975776f, -0.11728162f, -0.05779359f, -0.06018849f, 
    -0.01449676f, 0.00982750f, 0.10858603f, -0.12538378f, -0.15804201f, 0.08009095f, 0.12432647f, -0.22277156f, 
    0.02385316f, 0.07372598f, -0.02826601f, 0.10592451f, -0.05756070f, -0.03516291f, -0.10320051f, 0.08197275f, 
    0.00671732f, 0.14419109f, 0.06468446f, -0.02575091f, -0.03603962f, -0.05654681f, 0.09252704f, -0.16615561f, 
    0.28959042f, 0.11153985f, -0.01374606f, 0.00645229f, 0.07697577f, -0.00298585f, 0.33944839f, -0.05540622f, 
    -0.11644473f, 0.01055194f, 0.04227914f, -0.08339889f, -0.09316334f, 0.22200969f, -0.10949571f, -0.15376779f, 
    -0.21364695f, -0.01252461f, -0.10305434f, 0.12621512f, 0.07524487f, -0.01464423f, -0.12703139f, -0.04759992f, 
    -0.10132341f, -0.19459350f, -0.19183692f, 0.00065828f, 0.03132620f, -0.01385019f, 0.10934314f, 0.09432850f, 
    0.19185810f, 0.05949140f, -0.11108006f, 0.11971831f, 0.03891233f, -0.01747270f, -0.05609613f, 0.00196835f, 
    -0.01793278f, -0.02506438f, 0.16918589f, 0.23238999f, -0.14118725f, 0.07625534f, -0.12804411f, -0.13508938f, 
    -0.19943255f, 0.15203997f, 0.06586363f, 0.08159509f, -0.16253881f, -0.12508157f, 0.14954893f, 0.07318525f, 
    -0.04057283f, 0.11554366f, -0.10851585f, 0.04243185f, 0.12208962f, -0.19340271f, -0.20913865f, 0.30844471f, 
    -0.10277241f, 0.13578726f, 0.03405162f, -0.04463994f, -0.00875295f, 0.06712916f, -0.38010472f, 0.06210644f, 
    -0.07643291f, 0.04815758f, -0.08583609f, -0.22491533f, 0.01381664f, -0.09847143f, 0.11052644f, 0.10974479f, 
    -0.23979627f, 0.05028418f, -0.19631526f, 0.10633561f, 0.03568072f, 0.04485903f, 0.07384963f, 0.01848777f, 
    -0.19686657f, -0.04676480f, 0.22809640f, -0.13729724f, 0.10572627f, 0.13760340f, 0.10157661f, 0.03113023f, 
    -0.03420785f, -0.02618548f, 0.21266784f, -0.04119882f, 0.16983132f, 0.03560063f, -0.08076796f, 0.00226964f, 
    -0.00245975f, 0.07042262f, -0.12037054f, 0.09897121f, 0.11004458f, 0.01115757f, 0.11137857f, 0.00316496f, 
    -0.03175687f, -0.02845253f, -0.03194584f, 0.22534081f, 0.00977733f, 0.00599572f, -0.08811082f, 0.06544000f, 
    -0.04276879f, 0.02374059f, 0.08701996f, 0.03642366f, 0.12329343f, -0.23507747f, -0.23113984f, -0.03852414f, 
    0.15960671f, -0.00512443f, -0.02039215f, -0.08911313f, -0.07647951f, 0.06644487f, 0.10769625f, -0.02155182f, 
    -0.02384461f, 0.10788961f, 0.02981803f, -0.05844636f, 0.19254169f, -0.08876487f, -0.12495103f, -0.01424553f, 
    0.01291908f, -0.10131834f, -0.13169727f, -0.04253440f, 0.01759448f, 0.00662918f, -0.01925080f, 0.00135344f, 
    -0.10928652f, -0.08562163f, -0.04112040f, 0.09232381f, 0.03296132f, 0.02567314f, 0.13309970f, -0.12974586f, 
    0.12310365f, -0.14902279f, 0.13147424f, 0.07217181f, 0.02288438f, -0.10566013f, 0.10338784f, 0.02831567f, 
    -0.08770639f, 0.08957187f, 0.09602053f, -0.02695398f, 0.08182495f, -0.06060131f, 0.06238235f, 0.02493564f, 
    -0.01034492f, -0.07924104f, 0.23811392f, -0.01157972f, 0.43939304f, -0.01839750f, -0.05717417f, -0.12699673f, 
    -0.14976604f, 0.00476242f, 0.04860770f, 0.04538534f, 0.21329843f, -0.03893070f, -0.03092792f, 0.07507419f, 
    -0.19154271f, -0.03448637f, -0.07981125f, -0.07625882f, -0.11508557f, -0.22479965f, 0.42059764f, -0.13077286f, 
    -0.10023502f, -0.00796091f, 0.04663217f, 0.10278642f, -0.02440052f, 0.05058259f, 0.08485758f, -0.14508533f, 
    -0.02283076f, 0.02204145f, -0.21350329f, -0.03924095f, -0.00672447f, -0.06011707f, -0.11412828f, 0.13546598f, 
    0.04806688f, 0.13795999f, 0.08557650f, 0.10310461f, -0.07833937f, -0.12766817f, -0.04586899f, 0.07570884f, 
    -0.15516359f, -0.22609122f, -0.01140477f, -0.00421063f, 0.05513390f, -0.06995477f, 0.05278049f, -0.01650913f, 
    -0.04852403f, -0.04515531f, -0.10519226f, 0.08298761f, 0.00646503f, 0.11070323f, -0.16093259f, 0.06287990f, 
    -0.05437705f, 0.06716506f, 0.03638835f, 0.15579167f, -0.04549952f, 0.08020690f, 0.02364086f, -0.04588026f, 
    0.14626141f, 0.06530049f, 0.19475192f, -0.00512953f, 0.09910579f, 0.10813459f, -0.01026442f, -0.19309023f, 
    -0.07663874f, 0.00949472f, -0.07216975f, -0.04078044f, 0.02753974f, 0.02868472f, 0.09226507f, 0.03580106f, 
    0.05481280f, 0.10218187f, -0.13368796f, -0.09592546f, 0.16726319f, -0.16471560f, -0.11645182f, 0.12024649f, 
    0.02513538f, 0.15106180f, -0.10858773f, 0.09995811f, -0.10059354f, 0.13927762f, 0.02629960f, -0.09878380f, 
    0.02748650f, 0.00595894f, 0.11973962f, -0.04159978f, 0.09364170f, 0.10730091f, 0.11043856f, -0.14272368f, 
    0.08250921f, 0.03011537f, -0.08186550f, -0.13681492f, 0.00582703f, -0.04270342f, -0.07385299f, -0.02437166f, 
    0.07049105f, 0.09961676f, 0.01476533f, -0.00741300f, 0.01018601f, -0.07962260f, 0.03872771f, -0.08477098f, 
    -0.29216579f, 0.03091641f, -0.23406042f, 0.11533847f, 0.03314338f, 0.01184464f, 0.04541900f, -0.01417547f, 
    -0.07231122f, -0.02230892f, 0.10389318f, 0.14031146f, -0.16637881f, -0.09253301f, -0.02158469f, -0.12332895f, 
    0.09922754f, 0.07807530f, 0.17942128f, -0.12095717f, -0.20818065f, -0.07841694f, -0.04216249f, 0.24052727f, 
    -0.06531815f, 0.02613364f, -0.00244672f, 0.12952566f, 0.03286430f, 0.10699245f, -0.04185735f, -0.17686996f, 
    -0.09107209f, -0.06336400f, 0.10666084f, -0.04421289f, -0.08588278f, 0.10158043f, -0.11901432f, -0.04247121f, 
    0.14731403f, -0.01631872f, -0.11084451f, 0.04441901f, -0.03993017f, 0.21165389f, 0.04688456f, -0.07513843f, 
    -0.09045643f, -0.09202435f, -0.04090899f, -0.03971095f, 0.08421785f, 0.05932099f, 0.39901796f, 0.16695650f, 
    0.02585616f, 0.09135610f, 0.00019010f, 0.23954882f, 0.02443263f, -0.03772093f, -0.00883917f, -0.00757957f, 
    0.10482119f, 0.29951560f, -0.11900919f, 0.05153506f, 0.05833426f, -0.01663141f, 0.05242608f, -0.02688838f, 
    0.08257581f, -0.05418731f, -0.07267907f, 0.05199464f, 0.11562024f, 0.12231559f, -0.11347773f, 0.03272714f, 
    0.00832609f, -0.17224650f, 0.03035325f, -0.07730360f, -0.13092035f, 0.09764419f, -0.16582327f, 0.16183282f, 
    -0.00842136f, -0.00985764f, 0.26947272f, 0.07512518f, 0.03342625f, -0.03113802f, 0.01740837f, 0.15478246f, 
    0.04308325f, 0.20820302f, -0.01621615f, -0.02094159f, 0.10069697f, 0.20663057f, -0.08000926f, -0.01080574f, 
    0.00039018f, -0.14483243f, -0.00964931f, -0.02519176f, -0.09209515f, -0.03995360f, -0.33515370f, -0.06155035f, 
    -0.03586541f, -0.07655315f, 0.02150555f, -0.07360080f, -0.01956812f, -0.16905673f, -0.06174990f, 0.22584440f, 
    -0.05141588f, 0.04417382f, 0.08159090f, -0.01260942f, -0.13881606f, 0.05326506f, 0.02940013f, 0.03206990f, 
    -0.00548340f, -0.16449280f, 0.04537924f, -0.13391259f, 0.01855700f, 0.01695715f, 0.03989554f, 0.14026052f, 
    0.11844645f, 0.03572820f, 0.12526327f, 0.08183983f, 0.01737733f, 0.18590730f, 0.02213645f, -0.16353257f, 
    -0.31360230f, -0.01203572f, -0.19136827f, 0.10800846f, -0.01989591f, -0.01550672f, 0.10705763f, -0.00055355f, 
    -0.00064092f, 0.01699207f, -0.11774652f, 0.24874353f, 0.02149540f, 0.05318734f, -0.03331896f, 0.10862930f, 
    0.03166917f, -0.18210082f, -0.09815906f, 0.14329280f, 0.03580958f, 0.21040389f, 0.10388211f, 0.17401890f, 
    -0.13396171f, -0.08355717f, -0.04944053f, 0.17734854f, 0.04876956f, 0.07362990f, 0.06185429f, 0.01577971f, 
    0.04620238f, 0.17187729f, 0.10405264f, 0.06762547f, -0.07154337f, 0.02852978f, -0.15981321f, 0.22253470f, 
    0.05201038f, -0.12182028f, 0.01047921f, 0.08344056f, 0.00410685f, 0.11469488f, 0.00723406f, -0.15526013f, 
    -0.11526795f, -0.08697414f, -0.04837721f, 0.06714727f, 0.19564073f, 0.10867013f, -0.07397799f, 0.04458535f, 
    0.11619600f, -0.04925361f, 0.10238432f, 0.01540421f, 0.01145165f, -0.00685622f, 0.02021291f, -0.04450532f, 
    0.00721538f, 0.20913050f, 0.02540210f, -0.06201008f, -0.08970447f, 0.05260847f, 0.07605828f, 0.24470381f, 
    -0.17704725f, -0.01033347f, 0.07997413f, 0.06104308f, 0.05719227f, 0.02240211f, 0.06589327f, 0.02947572f, 
    -0.10928164f, -0.28651968f, -0.00117456f, -0.15626720f, 0.10170396f, 0.05370925f, 0.01386298f, -0.10555493f, 
    -0.18628378f, -0.05023729f, -0.41955066f, 0.09960642f, 0.01363023f, 0.13872601f, 0.07666200f, 0.27772892f, 
    0.08055296f, -0.15478992f, -0.20580606f, 0.27673808f, 0.28347543f, 0.08395677f, -0.16105399f, -0.07335034f, 
    0.06235595f, 0.20956588f, 0.03143310f, -0.09208839f, -0.01690324f, 0.14677158f, 0.12645723f, 0.16674973f, 
    0.03738013f, 0.02230149f, 0.03469430f, 0.03439786f, -0.01791129f, 0.11590643f, 0.10636679f, 0.12209396f, 
    0.04266714f, 0.03708252f, 0.07292329f, 0.16250676f, -0.02341015f, -0.07896674f, -0.41905662f, -0.09173144f, 
    -0.11767470f, 0.19137608f, -0.04403997f, 0.02466590f, -0.03668089f, -0.10810111f, -0.17740399f, 0.18617564f, 
    0.15625308f, 0.06787725f, -0.04956490f, -0.01638638f, 0.02748113f, 0.05889796f, -0.08248734f, 0.10361403f, 
    0.11010465f, -0.01343814f, 0.01983378f, -0.22438978f, -0.00482987f, -0.11398863f, -0.00399188f, 0.07364605f, 
    0.12222458f, 0.32543859f, -0.00115804f, -0.16478613f, -0.00253486f, 0.07135341f, -0.08242899f, 0.15090324f, 
    -0.17436871f, 0.25439268f, -0.17546496f, -0.11197059f, 0.01951785f, 0.04239105f, -0.07167675f, 0.03638589f, 
    -0.08413682f, 0.03646520f, -0.06693123f, -0.34258017f, 0.08507600f, 0.23649745f, 0.09820738f, 0.07915405f, 
    0.04775278f, 0.01014038f, 0.06398153f, -0.04532207f, -0.00305213f, 0.05549410f, -0.29549953f, -0.03562760f, 
    -0.02163655f, 0.19618128f, -0.16373780f, 0.13887136f, -0.00077426f, -0.04358545f, 0.04441093f, -0.05459817f, 
    0.26369041f, -0.04991655f, -0.13266744f, 0.05014597f, 0.00494941f, 0.10126432f, -0.17776407f, -0.21687073f, 
    -0.00269776f, 0.19991024f, 0.10971924f, 0.15167229f, 0.02217835f, -0.00344791f, -0.25726622f, 0.05142912f, 
    0.12213280f, -0.17694001f, 0.15584891f, 0.19674125f, 0.11625500f, -0.01191721f, -0.13044706f, 0.05969887f, 
    0.15168549f, 0.12962168f, 0.15691832f, 0.03088452f, -0.07591062f, -0.01803135f, 0.08112819f, -0.04124916f, 
    0.08939452f, -0.17470469f, -0.23897757f, -0.10082645f, -0.17744295f, -0.13871203f, 0.03123289f, 0.01207423f, 
    0.02866817f, -0.10224054f, 0.01852285f, 0.13763337f, 0.04981973f, 0.09988996f, 0.11442612f, 0.08817360f, 
    -0.02147467f, -0.01547199f, -0.10897405f, -0.29447439f, -0.03081217f, 0.00316436f, 0.10911425f, 0.15958540f, 
    -0.04094614f, -0.07850085f, -0.08932674f, -0.05101244f, -0.08055986f, 0.14426172f, 0.25129032f, -0.01458436f, 
    -0.12358403f, 0.00411247f, 0.02017894f, 0.02058340f, 0.16966175f, -0.08609255f, -0.15324038f, -0.12584662f, 
    0.09635256f, 0.10572660f, 0.25383440f, -0.00922864f, 0.01301066f, 0.01977940f, -0.01059282f, -0.20732097f, 
    -0.06109733f, 0.16886576f, 0.06954776f, 0.00242884f, 0.01028738f, 0.05671810f, -0.00824923f, -0.09905164f, 
    0.26065865f, 0.04917535f, -0.01807707f, -0.11807502f, 0.04702256f, -0.06569716f, 0.04895380f, -0.18751855f, 
    0.22019514f, 0.12239184f, 0.01758130f, -0.14479630f, 0.03314056f, -0.05757253f, -0.07787400f, 0.13318034f, 
    -0.08330229f, -0.09798766f, -0.15601659f, -0.12281118f, 0.01544080f, -0.09093189f, -0.04868107f, -0.05672612f, 
    -0.10044286f, 0.08944909f, 0.08284467f, -0.07688609f, -0.01288707f, 0.03487273f, 0.05858809f, 0.06317248f, 
    0.03936227f, 0.16230394f, 0.05112596f, 0.09483901f, -0.06891856f, 0.03168674f, 0.06944562f, 0.07034931f, 
    -0.23960640f, -0.06076620f, 0.00774342f, 0.01285309f, -0.04108763f, -0.10517348f, 0.07929999f, 0.11426129f, 
    0.00203906f, 0.08450276f, -0.11643022f, -0.04317190f, 0.10699203f, 0.18484445f, 0.11562789f, 0.01410993f, 
    -0.07646491f, 0.06791629f, -0.01673357f, 0.05848742f, -0.07321249f, 0.09442770f, -0.15729547f, -0.12089325f, 
    0.20932028f, -0.06933718f, -0.01199609f, 0.08843821f, 0.05800214f, 0.03031433f, -0.12215162f, 0.17778884f, 
    0.11728822f, 0.03304923f, -0.12836048f, -0.18291472f, 0.16624083f, -0.12153983f, -0.01230370f, -0.00605763f, 
    -0.09872328f, -0.13036482f, -0.14626640f, 0.04900555f, 0.07788304f, -0.02678854f, -0.07255633f, 0.08277430f, 
    -0.02142241f, 0.09065235f, -0.42471775f, 0.05470614f, -0.02283693f, -0.05894494f, 0.12983584f, 0.04655918f, 
    -0.02611254f, -0.01043101f, -0.14636566f, 0.01375292f, -0.11342064f, 0.00980622f, -0.04934730f, 0.06948300f, 
    0.01458827f, -0.04277317f, -0.00371831f, -0.02691324f, -0.06927258f, 0.11562589f, -0.04601193f, 0.09182851f, 
    -0.07789799f, -0.10266937f, 0.05371185f, -0.05860010f, -0.14312792f, -0.05917775f, 0.01686457f, -0.06666730f, 
    0.00149664f, 0.18989624f, 0.06960483f, -0.02787368f, -0.09110635f, 0.16315399f, 0.07119133f, -0.02076730f, 
    -0.04946744f, -0.01460208f, 0.14079466f, 0.09298901f, 0.02285641f, 0.03007539f, -0.02634677f, 0.18086752f, 
    0.15451311f, 0.06358890f, -0.02733131f, 0.01808341f, -0.06319960f, 0.19246908f, 0.13987608f, -0.17572792f, 
    -0.22531568f, 0.06436930f, 0.10322755f, -0.16227187f, -0.12972264f, 0.00421293f, 0.05419802f, -0.02902556f, 
    0.09809975f, 0.07079557f, 0.01301401f, -0.00027861f, -0.03326501f, -0.05256004f, -0.07976555f, -0.14228022f, 
    -0.01081542f, 0.00593507f, -0.21527161f, 0.13334148f, 0.13404292f, 0.02732141f, 0.04017610f, -0.03751465f, 
    -0.01707028f, -0.01285190f, 0.15503828f, 0.20826656f, 0.02392930f, 0.15935259f, -0.19238017f, -0.14248106f, 
    0.01894829f, 0.06610428f, 0.03666888f, -0.05135826f, 0.20357090f, 0.02166889f, -0.10113680f, -0.07090582f, 
    0.08215921f, -0.01193495f, 0.02404194f, 0.16227385f, -0.07041889f, 0.07615599f, 0.18539423f, 0.08711115f, 
    -0.09394563f, 0.00694740f, 0.08526541f, -0.16288078f, 0.06497063f, 0.19302306f, -0.07260561f, 0.16567670f, 
    -0.10162199f, 0.15529354f, -0.08449171f, -0.17251445f, 0.00613681f, 0.14359149f, 0.02767931f, -0.00007526f, 
    -0.06631763f, 0.06140190f, 0.01116332f, 0.13789636f, -0.03135373f, -0.16444258f, 0.00434478f, -0.02052015f, 
    0.04874036f, 0.10383586f, -0.12381291f, -0.18252684f, -0.00117765f, 0.03692354f, 0.15177719f, 0.07597098f, 
    -0.47351366f, 0.04856477f, 0.01901140f, 0.05273086f, 0.08729316f, 0.05500763f, -0.07572949f, -0.03773564f, 
    0.03774219f, 0.19167633f, -0.08927554f, -0.13555613f, -0.04870826f, 0.07614151f, -0.03549574f, -0.04006271f, 
    0.01356668f, -0.16347231f, 0.08627315f, -0.13496834f, -0.04862449f, -0.02129331f, -0.01123430f, 0.13031806f, 
    0.01011634f, -0.03718949f, -0.07488677f, 0.17531218f, -0.14441103f, 0.07467007f, -0.08755929f, -0.04864319f, 
    -0.04945026f, 0.02879516f, -0.03725187f, -0.01777429f, -0.00026036f, 0.06888133f, -0.07846195f, 0.01205033f, 
    0.12288661f, -0.18764158f, -0.02847997f, -0.00662413f, 0.05980969f, -0.13380530f, 0.06265518f, -0.13390444f, 
    -0.00215688f, -0.04177076f, 0.04150515f, -0.01826895f, 0.00734032f, 0.06101042f, 0.26291105f, -0.32188746f, 
    0.05629786f, -0.04229212f, -0.02656331f, 0.05134241f, 0.12955026f, 0.09394914f, 0.07303624f, -0.20456389f, 
    -0.02412855f, 0.01423034f, -0.10917196f, 0.04883884f, 0.06034401f, 0.06313772f, -0.02113934f, -0.03196751f, 
    0.01058945f, -0.03124298f, 0.16299573f, 0.08162525f, -0.01245447f, -0.01777694f, 0.15240420f, -0.04845669f, 
    -0.04649683f, 0.12762003f, -0.16994898f, -0.06383498f, 0.02222167f, -0.15948808f, -0.08161228f, 0.12866193f, 
    0.06912253f, 0.01826680f, 0.04705184f, 0.08409341f, 0.04940543f, 0.17806524f, 0.26886272f, -0.03789882f, 
    0.06586774f, 0.04653071f, 0.07063764f, -0.14306672f, -0.32183453f, 0.13570404f, 0.10871202f, -0.14946291f, 
    0.18970907f, -0.04866539f, 0.00102962f, -0.17834504f, 0.54737169f, 0.25023001f, 0.00380168f, -0.15097649f, 
    0.00902450f, 0.06063147f, 0.18326074f, 0.32196555f, 0.05964886f, -0.20505854f, -0.19452433f, -0.12804717f, 
    0.04989748f, -0.22266380f, 0.01113589f, -0.06013151f, -0.21692048f, -0.32872874f, 0.06985974f, 0.02731423f, 
    -0.07973807f, 0.07212168f, -0.17407654f, -0.06970061f, 0.02865542f, 0.07824816f, -0.04755550f, -0.13537240f, 
    -0.21607552f, 0.07369174f, -0.11679748f, 0.12630211f, 0.10425045f, -0.10223730f, -0.16495182f, 0.09102112f, 
    0.11639522f, 0.02802362f, 0.06810918f, 0.06338304f, -0.16245334f, 0.01868839f, -0.00208305f, 0.09505526f, 
    0.12412110f, -0.14370172f, 0.20755406f, 0.00240754f, 0.13341723f, 0.00973688f, -0.13750751f, 0.14462054f, 
    -0.03554863f, 0.07308369f, 0.25962070f, 0.09647198f, 0.04412105f, 0.16437152f, 0.09240787f, -0.08654673f, 
    0.11267316f, 0.10522185f, -0.02409942f, -0.08225124f, -0.02080019f, -0.18810658f, 0.00556933f, -0.13360254f, 
    0.12605266f, -0.05726383f, -0.02699814f, 0.03312651f, 0.07057580f, 0.02731067f, -0.03375319f, 0.06351554f, 
    -0.10079107f, -0.05969575f, 0.01641446f, 0.01444172f, 0.14967307f, -0.16633378f, 0.05798823f, -0.24468401f, 
    0.00016541f, 0.05011493f, 0.00915329f, -0.02769652f, 0.01375670f, 0.15266255f, 0.14603475f, 0.42886916f, 
    -0.03386571f, -0.01167239f, 0.15395141f, 0.15526980f, -0.05416952f, -0.10771725f, 0.00985058f, 0.00483905f, 
    -0.24056473f, 0.09293564f, -0.15268584f, -0.01076494f, 0.16096531f, 0.06298029f, -0.09194808f, 0.06326531f, 
    0.07890513f, -0.26719943f, 0.04006641f, -0.09030117f, -0.15891424f, 0.07788569f, -0.11069465f, -0.02865835f, 
    -0.00618376f, 0.21846609f, 0.25081080f, 0.00103988f, 0.12473288f, -0.07451008f, -0.04238092f, -0.02327621f, 
    0.10183468f, -0.02793565f, -0.05311771f, 0.22402003f, -0.11468085f, 0.03884542f, 0.02049841f, -0.03725325f, 
    -0.22720660f, -0.05573917f, -0.01329182f, 0.17767635f, 0.17573890f, 0.03530879f, 0.07383528f, 0.12784573f, 
    0.02659573f, -0.00939374f, -0.02819495f, -0.14025547f, 0.13674960f, 0.15041761f, -0.10026620f, 0.03280634f, 
    0.01923588f, -0.10488860f, -0.05270835f, -0.15545024f, -0.24493234f, -0.05862432f, 0.02190176f, -0.03547181f, 
    0.06090665f, -0.15572770f, 0.07128744f, 0.04536548f, 0.06940330f, 0.01870369f, -0.20953485f, -0.15724735f, 
    -0.13166639f, 0.00553839f, 0.07200889f, 0.00268604f, -0.05243894f, -0.06567635f, 0.08912003f, 0.29317811f, 
    0.12943584f, -0.08024265f, 0.18986300f, 0.01804413f, -0.02390674f, 0.05992106f, -0.07980210f, -0.12337981f, 
    0.34677866f, -0.17813294f, 0.01456369f, -0.07223980f, -0.09601771f, 0.02493559f, -0.08275095f, 0.22972792f, 
    0.06091764f, -0.25733387f, -0.19558139f, 0.03594838f, 0.05801890f, -0.10023219f, 0.06111076f, 0.06868204f, 
    -0.02297495f, -0.01998426f, -0.35614747f, -0.19305059f, -0.02983111f, 0.10482650f, -0.00327609f, -0.12663122f, 
    0.02098778f, -0.05300484f, 0.17975412f, 0.06355216f, 0.24845333f, -0.01044480f, 0.15483989f, -0.12130905f, 
    -0.15448749f, -0.03108883f, -0.08360693f, 0.04760166f, -0.10770029f, -0.05584970f, 0.05530823f, -0.02408190f, 
    0.02835343f, 0.11312466f, -0.17741145f, -0.05147974f, -0.13820378f, 0.13388319f, 0.02004543f, -0.05668779f, 
    -0.01569170f, 0.11705366f, -0.07200523f, 0.15347326f, 0.06007779f, -0.05815798f, -0.30485672f, 0.15982237f, 
    0.03089356f, -0.11331550f, -0.09368559f, -0.04923328f, -0.09466898f, -0.00369064f, 0.15074141f, 0.06492925f, 
    -0.13174838f, 0.02079600f, 0.07862745f, -0.00071896f, 0.00624068f, 0.01771355f, 0.00053516f, -0.09299464f, 
    -0.06295815f, -0.03237965f, 0.00387543f, -0.03102656f, -0.01651415f, -0.00237166f, -0.00533350f, 0.03344472f, 
    -0.06169811f, -0.04126798f, 0.00979090f, 0.01700479f, 0.02352176f, -0.01294192f, 0.00968159f, -0.03143473f, 
    -0.04509325f, 0.00606777f, -0.04640132f, 0.04992795f, 0.01960008f, -0.03604380f, -0.00993097f, 0.02101954f, 
    -0.03458757f, 0.04713272f, -0.03206391f, -0.03257715f, 0.04209899f, 0.01835268f, -0.05577014f, -0.05969812f, 
    0.04743148f, 0.04114262f, -0.04080408f, -0.03357877f, 0.00165071f, -0.05372969f, -0.03729534f, 0.00437414f, 
    -0.03249556f, -0.00299126f, 0.00165064f, 0.04121297f, -0.05366271f, 0.01142597f, -0.01630909f, -0.01440878f, 
    -0.03486461f, 0.03378865f, -0.04822544f, 0.04774430f, -0.03021212f, -0.05031837f, -0.05223545f, -0.04404843f, 
    -0.00422986f, 0.03653720f, -0.03605530f, 0.05074861f, -0.01173162f, -0.03608802f, -0.00996766f, -0.00954077f, 
    0.04921157f, -0.04112915f, -0.00469030f, -0.01296086f, 0.05337546f, -0.04686757f, -0.00435122f, -0.03470663f, 
    -0.04817960f, 0.03348542f, 0.01554098f, -0.04759351f, -0.00896398f, -0.04179534f, 0.04881210f, -0.06738017f, 
    0.02908310f, 0.03182559f, 0.04191354f, -0.04166910f, 0.02312134f, -0.06876536f, -0.01359767f, 0.00619304f, 
    0.00761978f, -0.04149139f, -0.03786966f, -0.02441463f, 0.01156083f, 0.02879877f, -0.06794407f, -0.03515958f, 
    0.00816514f, -0.00991779f, -0.06452910f, -0.03412218f, -0.00495177f, 0.03082734f, 0.00482322f, -0.04270159f, 
    -0.01755685f, 0.05058007f, -0.04047634f, 0.02006468f, 0.03336529f, 0.04607601f, -0.03873111f, -0.05097910f, 
    -0.05706521f, 0.00893905f, 0.04722340f, 0.01280536f, -0.05141352f, -0.04870148f, 0.05028591f, 0.03765232f, 
    -0.03874048f, -0.02297852f, 0.03864098f, 0.02645703f, 0.02979821f, 0.02522129f, -0.02300834f, -0.03582435f, 
    -0.00021115f, -0.05810194f, -0.04529279f, -0.01780395f, -0.04838616f, 0.03867494f, 0.01348945f, 0.04413505f, 
    -0.06729336f, -0.03878935f, -0.00103881f, 0.03102746f, 0.02390237f, 0.00093349f, 0.00608822f, -0.05855010f, 
    -0.02214461f, -0.00285735f, 0.01655102f, 0.04336775f, 0.00934983f, 0.01440822f, 0.02863106f, -0.03835400f, 
    0.04000220f, -0.04364418f, -0.05131266f, 0.05038282f, -0.01704813f, -0.01490199f, -0.01101508f, -0.03583528f, 
    -0.00567617f, -0.03298511f, -0.03603475f, 0.00418620f, -0.02991841f, 0.00254207f, 0.04005244f, 0.02160453f, 
    -0.04844962f, 0.04563275f, 0.00958969f, -0.04488533f, -0.04235906f, 0.01057794f, -0.05062304f, -0.06143708f, 
    -0.02253947f, 0.02374761f, -0.02774722f, -0.06101261f, -0.04328227f, -0.02024751f, -0.01604344f, 0.04321416f, 
    -0.00047283f, -0.03371911f, 0.00347496f, 0.00320368f, 0.04922095f, -0.01614562f, -0.00828246f, -0.04308481f, 
    0.04919148f, 0.05948489f, -0.00135746f, 0.05238156f, 0.00419998f, 0.04676780f, 0.01304397f, 0.02074862f, 
    0.00632604f, -0.02980343f, -0.04030952f, 0.01695163f, 0.01192961f, 0.03556959f, 0.03318741f, -0.04678093f, 
    -0.00182657f, 0.00857372f, 0.03302552f, 0.01910161f, 0.01307545f, 0.05350474f, -0.05525542f, -0.05904599f, 
    -0.05877546f, -0.00460379f, -0.06807107f, 0.04203410f, 0.04559179f, -0.01619710f, 0.02323930f, -0.04330109f, 
    -0.03878594f, -0.06764864f, -0.03705130f, -0.01571174f, 0.01724621f, -0.06063259f, 0.02765403f, -0.02588773f, 
    -0.01688076f, 0.01649453f, 0.04809273f, 0.01503014f, 0.02432929f, -0.01914186f, -0.01060008f, 0.00632347f, 
    0.04570612f, 0.03562402f, 0.01652550f, -0.06331369f, 0.00607126f, -0.01419919f, -0.03363368f, 0.00670843f, 
    -0.04648767f, -0.00217286f, -0.00330934f, 0.04711275f, -0.00886962f, -0.02863027f, -0.01614833f, -0.03975027f, 
    0.00544925f, -0.04305358f, 0.04396864f, -0.03965481f, 0.02741756f, 0.00121482f, -0.00920674f, -0.00460863f, 
    -0.05263513f, 0.04646247f, -0.06316470f, -0.01076015f, -0.04461809f, 0.00703086f, -0.05154281f, 0.03043207f, 
    -0.04016402f, -0.01849560f, -0.04356259f, -0.00027011f, 0.01556705f, -0.06399907f, -0.02433615f, 0.03096363f, 
    0.04213894f, -0.07208245f, 0.02929190f, -0.01208881f, -0.01949902f, -0.02210696f, -0.03559374f, -0.05386435f, 
    0.11789400f, -0.11665389f, -0.11040590f, -0.26656625f, -0.05555983f, 0.02045255f, 0.13952406f, 0.05251115f, 
    -0.01924665f, -0.18510455f, -0.19017430f, -0.13830119f, -0.09999561f, -0.01252410f, -0.11018907f, 0.02209007f, 
    0.17169616f, 0.05293214f, 0.22160469f, 0.04184725f, -0.08679590f, -0.04638232f, 0.11702295f, -0.11039870f, 
    0.15370895f, 0.13589075f, 0.09333614f, -0.01135891f, 0.17457750f, -0.02902108f, 0.16109394f, -0.04339960f, 
    0.02716489f, -0.07203612f, -0.05298615f, -0.00813920f, -0.07775296f, 0.07387715f, -0.18779463f, 0.01974189f, 
    0.02056843f, -0.03191436f, 0.02373399f, -0.02339946f, -0.14020246f, 0.09311727f, 0.48048708f, 0.07935603f, 
    0.11072417f, 0.05511741f, 0.12607814f, 0.16626459f, -0.14926235f, -0.02005956f, -0.07813284f, -0.29767871f, 
    0.08691978f, 0.06970115f, -0.00242036f, -0.09467852f, -0.00800291f, -0.02472287f, 0.05014006f, 0.54971540f, 
    -0.40358248f, -0.24227364f, -0.03002086f, -0.02041337f, 0.09821546f, -0.04465357f, -0.20415132f, 0.06628162f, 
    -0.21049231f, -0.50000972f, -0.17909184f, 0.15647399f, 0.00154597f, 0.11825430f, 0.04032350f, -0.13669081f, 
    0.02243911f, -0.00666944f, -0.12372264f, -0.12478890f, -0.00659018f, -0.19499967f, -0.06015369f, 0.04721610f, 
    0.01212992f, -0.01053828f, 0.11289199f, 0.03489039f, 0.05075149f, -0.09068732f, 0.05001664f, 0.06023612f, 
    0.02954567f, -0.10766780f, -0.03213530f, -0.06053921f, -0.02498557f, 0.04708060f, 0.11468729f, 0.06533246f, 
    -0.00413633f, 0.00756493f, -0.09397367f, 0.00396911f, -0.17021318f, -0.28154755f, -0.08351503f, 0.02067303f, 
    -0.01869056f, -0.04115780f, -0.01507281f, 0.07711355f, 0.11117281f, -0.29168385f, -0.24117054f, 0.12797916f, 
    0.03201527f, -0.02040107f, 0.05706570f, -0.03591671f, -0.12246763f, 0.13261297f, -0.12359811f, 0.01534552f, 
    -0.07092567f, -0.08989574f, -0.00759525f, -0.13531162f, -0.07812154f, 0.06216175f, 0.15886497f, 0.13380072f, 
    -0.24921682f, 0.16215415f, 0.16007112f, 0.18652527f, 0.16457966f, 0.07462911f, -0.08050807f, 0.16299906f, 
    0.01879896f, 0.09879385f, 0.20493412f, 0.02940358f, 0.04458027f, 0.05288969f, 0.00125700f, -0.03337130f, 
    0.00363987f, 0.03486967f, 0.06593315f, -0.02558209f, -0.04014364f, 0.15784883f, -0.00068284f, -0.02709373f, 
    0.03750134f, -0.10938647f, -0.03928675f, -0.04301578f, 0.19010034f, -0.06930701f, -0.16554599f, 0.06610476f, 
    -0.05920739f, -0.07243380f, -0.02555046f, 0.07893780f, 0.07374687f, -0.10227966f, 0.08150321f, -0.05949994f, 
    0.14906065f, -0.03190431f, 0.05785037f, -0.11128639f, -0.18516997f, 0.05399615f, 0.11213870f, -0.06710622f, 
    0.02550343f, 0.17560951f, -0.12008432f, -0.00686987f, 0.01585842f, 0.16298166f, 0.12902410f, -0.28463686f, 
    -0.01895984f, -0.09953091f, 0.03969477f, 0.06287820f, -0.04761679f, -0.01888860f, -0.20734772f, -0.01292555f, 
    -0.10333364f, 0.03382017f, -0.15781976f, 0.05178519f, 0.08996975f, -0.03226947f, -0.05495110f, -0.05382182f, 
    -0.00105777f, -0.09108054f, 0.07203249f, 0.10015314f, -0.09949593f, 0.07165758f, 0.13074459f, 0.04582968f, 
    -0.21524613f, -0.33468899f, 0.08360775f, 0.12364975f, 0.07819293f, 0.10504197f, -0.01290195f, 0.04324179f, 
    0.00505417f, 0.01547946f, 0.02967451f, -0.00540703f, 0.11160087f, 0.04689999f, 0.10609613f, -0.07351460f, 
    0.01981290f, -0.01016262f, -0.16106045f, -0.03035043f, -0.02288263f, -0.07666395f, 0.11579379f, -0.05517474f, 
    0.05569378f, 0.02185392f, -0.03094692f, -0.07783615f, 0.15501030f, 0.01791874f, 0.06617235f, -0.05180104f, 
    -0.12868415f, -0.02339217f, -0.00448174f, 0.05526749f, 0.31963351f, 0.06191462f, -0.16453394f, 0.12459241f, 
    0.08377009f, 0.09617255f, -0.08280962f, -0.05379841f, -0.14303446f, 0.07034438f, -0.00406201f, -0.13261360f, 
    0.02441471f, 0.01190533f, 0.07970908f, 0.00256554f, 0.06056125f, 0.12357871f, -0.10412644f, 0.16016674f, 
    0.05738572f, -0.15273540f, -0.07053679f, -0.14569472f, -0.07158381f, 0.01745383f, 0.15671630f, -0.01454427f, 
    -0.23864967f, -0.24147095f, 0.08385403f, -0.04957306f, -0.05230869f, -0.06637732f, -0.09992775f, -0.02469081f, 
    -0.57715458f, -0.27297592f, -0.16791585f, 0.05214432f, -0.03329221f, 0.02745621f, 0.02012937f, -0.16516660f, 
    -0.06424570f, 0.02950932f, 0.05673057f, -0.11859581f, -0.01539762f, -0.06783814f, 0.06790634f, 0.05295610f, 
    0.03199604f, 0.01342947f, -0.04544731f, -0.11036689f, -0.04584989f, 0.12013317f, -0.04708121f, -0.01802642f, 
    0.01077131f, 0.16740999f, 0.08868740f, 0.00245077f, 0.09670827f, 0.06435521f, -0.14559579f, -0.03411373f, 
    0.04065536f, 0.19966711f, -0.00430590f, 0.01466141f, -0.26223731f, 0.03492737f, 0.27923945f, 0.23652731f, 
    0.22502662f, 0.06115247f, -0.04243607f, -0.10749488f, 0.14144060f, 0.15520667f, 0.00776054f, 0.06525264f, 
    -0.15260446f, -0.00611554f, 0.06443229f, -0.02756687f, 0.04234263f, 0.12346394f, -0.15562674f, 0.02432775f, 
    0.11667945f, -0.11926717f, 0.06287886f, 0.00708571f, 0.12613748f, 0.07383365f, -0.01061494f, 0.26533869f, 
    -0.00531441f, 0.02079297f, -0.12239075f, 0.21161731f, 0.04771395f, 0.01820267f, -0.05112451f, 0.10590377f, 
    -0.34077948f, -0.03807694f, 0.11551563f, -0.01516279f, 0.03430307f, -0.05467657f, -0.05325466f, -0.11474665f, 
    -0.10798702f, -0.02265402f, -0.05530658f, -0.12317043f, 0.09953162f, -0.01874184f, 0.04944492f, 0.00674096f, 
    -0.03382294f, 0.05104508f, -0.19188526f, -0.02753634f, 0.03173155f, 0.08078051f, 0.12729064f, 0.06882551f, 
    -0.14014652f, 0.05920728f, 0.08916292f, -0.21683641f, 0.00744735f, 0.16828284f, -0.18531673f, 0.05119738f, 
    0.02140179f, -0.10770736f, -0.00973358f, -0.11036662f, -0.10587244f, 0.12050982f, 0.18091325f, 0.05740381f, 
    -0.08562871f, -0.02403576f, 0.10292980f, 0.07683968f, 0.04703514f, 0.17813905f, 0.13798811f, 0.06557705f, 
    -0.07190705f, 0.04470799f, 0.00448728f, 0.05916084f, 0.13594788f, 0.13357183f, -0.32395861f, -0.28812471f, 
    -0.35962036f, 0.15634544f, -0.24410869f, 0.05340839f, 0.08528807f, 0.02248188f, 0.00347757f, -0.25127640f, 
    0.01508747f, 0.18491614f, -0.06157304f, 0.16206643f, -0.05487704f, -0.11134477f, 0.03617506f, -0.03400725f, 
    -0.13639310f, -0.29833949f, 0.20544110f, -0.12223341f, 0.10030834f, -0.10592408f, 0.06894165f, 0.11537249f, 
    -0.03256675f, 0.00805264f, 0.06765756f, 0.16843610f, 0.05262255f, 0.05939985f, -0.02941100f, 0.05036891f, 
    0.03397907f, 0.03612018f, -0.19623448f, -0.10011771f, -0.17033403f, 0.03896216f, -0.04108516f, -0.00921152f, 
    -0.15363587f, -0.12214735f, 0.05100869f, -0.19868547f, -0.20588543f, 0.11388108f, 0.24467441f, 0.12406342f, 
    -0.02451943f, 0.10814791f, 0.05384598f, -0.04440886f, -0.19082156f, 0.20360489f, 0.11782201f, 0.09987596f, 
    0.01404271f, -0.00094287f, 0.09230585f, 0.02292721f, 0.02424158f, 0.24030095f, 0.16736117f, -0.04564654f, 
    0.05268330f, 0.05234487f, 0.10889877f, 0.06048881f, -0.00442992f, -0.05554854f, 0.13238625f, 0.09253957f, 
    0.01976125f, -0.02758798f, 0.00329117f, 0.09100541f, -0.06322503f, -0.06009665f, 0.01919691f, -0.40212083f, 
    -0.07505704f, 0.16236858f, 0.14457391f, -0.11078209f, -0.02922314f, 0.03030970f, 0.11731134f, 0.03002719f, 
    -0.16270572f, 0.07073445f, 0.26360610f, 0.08699136f, 0.11478168f, -0.08280434f, -0.07778975f, -0.02719379f, 
    0.03248651f, 0.21458054f, -0.19003101f, -0.46079960f, -0.19741642f, 0.04846554f, -0.12185772f, 0.03638845f, 
    -0.07329904f, -0.14107306f, 0.36351845f, 0.10466766f, -0.21904789f, -0.08179406f, -0.12218904f, 0.01942837f, 
    0.03477002f, 0.10081917f, 0.07574011f, -0.40345010f, -0.21115363f, 0.16438556f, 0.10726800f, 0.01669578f, 
    -0.02143988f, -0.08340860f, -0.09372653f, -0.04795330f, 0.01842098f, -0.04204356f, 0.16801517f, -0.18986034f, 
    0.13516170f, -0.00234563f, -0.07106352f, 0.01466084f, 0.28194061f, -0.03432355f, -0.28698006f, 0.07924050f, 
    0.06336123f, 0.14107507f, 0.00505786f, 0.07989741f, -0.09333301f, 0.12758610f, -0.04435115f, 0.03757925f, 
    -0.11940399f, 0.01609325f, -0.00700721f, 0.00758735f, -0.01900737f, -0.01295899f, -0.08469032f, -0.11687354f, 
    0.00131103f, 0.18012507f, -0.10164433f, -0.00723212f, 0.03902296f, 0.08814137f, -0.16645814f, -0.10193600f, 
    0.02631888f, -0.19445351f, -0.19692798f, -0.14133613f, 0.13689019f, -0.07067480f, -0.07138915f, 0.14641708f, 
    -0.19312827f, 0.18556033f, -0.13527243f, 0.20184611f, 0.00631613f, -0.00946521f, -0.03129518f, -0.12605825f, 
    -0.07163218f, 0.08380108f, -0.02842768f, 0.27168429f, 0.08117820f, -0.04296228f, 0.09883651f, -0.13408935f, 
    -0.07563318f, 0.16451640f, -0.20312192f, 0.01157205f, -0.28385893f, -0.23373371f, -0.06415471f, -0.15468985f, 
    0.09681338f, -0.15917023f, -0.08193149f, 0.04467868f, 0.28983995f, 0.24767564f, -0.07220928f, -0.10059200f, 
    -0.10199678f, 0.03808952f, 0.11728369f, 0.02095660f, 0.07134247f, 0.07020779f, -0.34206688f, -0.17115124f, 
    0.09895293f, -0.07313761f, 0.04175061f, -0.09749593f, -0.09854152f, 0.01159954f, -0.02313917f, 0.11513268f, 
    0.13605362f, 0.03560933f, -0.09757344f, -0.07925780f, 0.08504407f, -0.16445526f, -0.02068242f, -0.50036871f, 
    -0.37428546f, -0.31965399f, -0.06373935f, -0.10956850f, 0.04429710f, -0.05870093f, -0.13621537f, -0.01923488f, 
    0.17619251f, -0.08175326f, 0.04523503f, 0.09728646f, -0.05374118f, -0.02700806f, -0.06407028f, -0.11273852f, 
    -0.00094243f, -0.05925212f, 0.33500656f, -0.02813718f, -0.00850764f, -0.11360478f, 0.03355747f, 0.03326558f, 
    0.01438282f, -0.15225077f, 0.17939217f, 0.25481254f, -0.06621934f, -0.15265623f, 0.08563948f, 0.03232355f, 
    0.02263300f, 0.04750427f, -0.16274741f, -0.14880697f, -0.38749376f, -0.08640344f, 0.03867022f, 0.02936805f, 
    -0.03504195f, 0.12186691f, 0.04160004f, -0.05816624f, -0.02651880f, -0.12693582f, 0.10852500f, 0.20689791f, 
    -0.06827196f, 0.00112045f, 0.00068210f, -0.01172842f, -0.14960533f, 0.25067484f, 0.03085309f, 0.19599791f, 
    0.05288525f, -0.02650081f, -0.07502897f, 0.10716765f, 0.06383952f, -0.01029294f, -0.19459409f, 0.00433610f, 
    -0.06517503f, 0.01192332f, -0.00307120f, -0.02385225f, -0.00456593f, 0.01944382f, 0.09642752f, -0.42012444f, 
    -0.26224735f, -0.10863867f, -0.01008363f, -0.03821385f, -0.08225911f, 0.08425577f, 0.08835680f, 0.03525890f, 
    -0.38602182f, -0.29194787f, -0.01680307f, 0.14696237f, -0.03827567f, -0.10784772f, 0.02416446f, -0.02395208f, 
    0.06093853f, 0.11291488f, 0.13302276f, -0.13457984f, -0.04433468f, -0.03515531f, -0.04750985f, -0.02579709f, 
    -0.03938420f, 0.01134506f, -0.34577978f, 0.07585312f, 0.02917537f, -0.05325816f, 0.15567818f, -0.01607858f, 
    0.05970998f, 0.05881269f, -0.16953054f, -0.11357491f, -0.11955381f, -0.12481019f, 0.05394248f, -0.09379733f, 
    0.11088714f, 0.10896545f, 0.11749301f, 0.03487433f, -0.03430519f, -0.19762774f, -0.26288265f, -0.00480384f, 
    0.17466648f, 0.09680285f, -0.01593217f, -0.03543492f, 0.02147406f, 0.28650728f, 0.03624464f, -0.10130345f, 
    0.02687470f, 0.04812748f, 0.07310728f, 0.11057478f, 0.14071351f, 0.06868130f, 0.29361954f, 0.02634632f, 
    0.15677671f, -0.19707097f, -0.03467834f, 0.11524802f, 0.08531944f, 0.08382987f, 0.04958963f, 0.01582723f, 
    0.05128713f, 0.14036530f, 0.16673964f, 0.12944356f, -0.02207011f, 0.06552720f, -0.09271494f, -0.09592050f, 
    -0.06118091f, 0.07618231f, 0.28490895f, 0.03792202f, -0.15238734f, -0.17118840f, -0.21582963f, 0.05966869f, 
    -0.00431198f, 0.03824652f, 0.07486616f, -0.16006930f, -0.02750016f, 0.06721722f, 0.10476093f, 0.03590478f, 
    -0.11974919f, 0.11016043f, 0.11509955f, 0.09610979f, 0.03432694f, 0.06365237f, 0.00680692f, -0.18769807f, 
    0.09387542f, -0.05968036f, -0.01933756f, 0.09396081f, 0.25604406f, 0.19475484f, 0.03224738f, -0.01958447f, 
    0.10918292f, 0.07842015f, 0.01256782f, 0.08072280f, 0.01547096f, -0.11648303f, -0.48110536f, 0.09819292f, 
    -0.01843259f, 0.17028056f, -0.08848751f, -0.12418063f, 0.00400837f, 0.17881656f, 0.28145450f, 0.01965012f, 
    0.08242110f, -0.06126253f, 0.11282926f, 0.03813118f, 0.06919447f, -0.02681961f, -0.11587598f, 0.40643400f, 
    -0.09662972f, 0.14628163f, -0.01166797f, 0.00878541f, 0.03864254f, -0.07317969f, 0.09529466f, 0.02708752f, 
    -0.34798959f, -0.05138036f, 0.09017316f, 0.12944368f, -0.00420907f, 0.04204127f, -0.00642479f, -0.00087783f, 
    -0.22150083f, -0.00695358f, -0.09907123f, -0.23569553f, 0.05659707f, 0.22966105f, 0.08132195f, -0.15798888f, 
    -0.16024403f, 0.34622604f, -0.12348141f, -0.08547071f, -0.09550989f, 0.06283262f, -0.09605894f, 0.01258056f, 
    -0.00902653f, -0.12683690f, 0.09803031f, -0.21482646f, 0.33768871f, 0.02772817f, 0.05382811f, 0.14456052f, 
    -0.05916754f, -0.01719721f, -0.03549221f, -0.18829359f, 0.14844981f, -0.35883379f, 0.16261017f, 0.04613857f, 
    -0.16508922f, -0.00741711f, 0.10595395f, -0.22804424f, -0.06631932f, -0.17709941f, 0.41178280f, -0.03166968f, 
    -0.12776600f, -0.00292152f, -0.06577727f, 0.05035887f, 0.18969308f, 0.08701506f, 0.06119809f, -0.23488083f, 
    0.32544473f, -0.05931394f, -0.06419881f, 0.07800934f, 0.14574875f, 0.24377830f, 0.09116536f, 0.22538133f, 
    0.00962894f, -0.00604127f, 0.07268746f, 0.06513017f, 0.05220574f, -0.04355660f, -0.14465784f, -0.08968725f, 
    0.00968895f, -0.47810647f, -0.09253146f, 0.00398744f, -0.00849437f, 0.03180636f, 0.04560708f, 0.13681130f, 
    0.25464472f, 0.09084314f, 0.07874282f, -0.12861691f, 0.07199764f, -0.01034065f, -0.06295147f, -0.01695627f, 
    -0.17945890f, 0.10530206f, -0.27090073f, 0.21427232f, 0.02755743f, -0.06275197f, 0.03407702f, -0.00135811f, 
    -0.13859077f, -0.12991707f, -0.07752533f, -0.27429229f, 0.09502997f, 0.05813067f, 0.08623115f, 0.00248617f, 
    -0.11152967f, 0.13474776f, 0.00617557f, -0.01143151f, 0.08758041f, -0.32253814f, 0.07545913f, -0.13451728f, 
    -0.26811808f, 0.17424344f, 0.12517610f, -0.00734868f, 0.35289991f, 0.06752742f, -0.15641242f, -0.11108878f, 
    -0.11621529f, -0.02905435f, 0.06396209f, 0.05127485f, 0.10132767f, 0.14420927f, 0.12363591f, -0.15089330f, 
    -0.06868533f, -0.14007837f, 0.02378937f, 0.09469660f, -0.01246250f, 0.05799124f, -0.06755573f, -0.36981800f, 
    0.09502068f, 0.00666103f, -0.21644238f, -0.01278293f, 0.01181488f, 0.11923444f, -0.01089910f, 0.01355759f, 
    0.02864487f, -0.50799555f, 0.02009985f, -0.01996375f, -0.15394628f, 0.14845212f, -0.17096592f, -0.04788161f, 
    0.10308744f, -0.01195474f, -0.17640650f, 0.15747297f, 0.03563076f, -0.06898049f, 0.20303045f, 0.07618684f, 
    -0.00076404f, -0.13331097f, -0.17431572f, 0.17367633f, -0.14040172f, 0.04173822f, -0.01368295f, -0.03884271f, 
    0.10019366f, 0.22649634f, -0.18468446f, 0.32214507f, 0.01125989f, 0.00059752f, 0.02942095f, 0.08868698f, 
    0.00498809f, 0.00365858f, -0.05614595f, -0.06794561f, -0.17732300f, 0.05291213f, -0.04300184f, -0.14243077f, 
    0.05922930f, -0.13767612f, 0.08204681f, 0.01103588f, 0.21085885f, -0.15487847f, -0.13958964f, 0.03845445f, 
    -0.10919256f, 0.02984501f, 0.05913018f, 0.07964234f, 0.23038617f, -0.08246558f, 0.11092491f, 0.05002951f, 
    0.11765337f, 0.03615497f, -0.04948048f, 0.04102818f, -0.12610249f, -0.08468480f, 0.12900305f, 0.08133232f, 
    -0.26746255f, -0.07259301f, 0.08237877f, -0.11214937f, -0.02944642f, -0.13199423f, -0.06429313f, -0.04889645f, 
    -0.36825952f, 0.18501775f, 0.00448636f, -0.11051407f, 0.15428928f, -0.04161739f, 0.13570067f, 0.01903911f, 
    0.10574483f, 0.11186226f, -0.32398552f, -0.20608476f, -0.04971233f, -0.19215989f, 0.05301718f, -0.11940651f, 
    -0.06762052f, 0.32146609f, -0.03646220f, -0.16050209f, -0.05832661f, 0.06218313f, 0.11551866f, 0.13174143f, 
    -0.14060022f, -0.02716194f, 0.01277544f, -0.05601037f, 0.09344808f, 0.06748442f, 0.04541179f, 0.04725017f, 
    0.02131298f, -0.07681727f, 0.14369850f, -0.12346506f, 0.07584915f, 0.26275778f, -0.05073772f, 0.00467967f, 
    0.08124292f, 0.07135221f, 0.15146066f, -0.05188499f, -0.04490658f, 0.12712641f, -0.19337437f, 0.18595916f, 
    0.05031877f, -0.04463130f, 0.01317051f, 0.04579557f, 0.08712388f, 0.00446269f, -0.01583077f, 0.09519084f, 
    -0.02034353f, 0.06269886f, 0.07082374f, -0.10720810f, 0.20544450f, 0.02887681f, -0.04608593f, 0.16769692f, 
    0.02760098f, 0.08754294f, -0.00637728f, -0.12199114f, 0.12436853f, -0.16532496f, 0.00639263f, 0.32470682f, 
    0.19174883f, -0.03495442f, -0.10897029f, 0.01155140f, -0.09003818f, -0.04448165f, 0.02295255f, 0.08232574f, 
    0.23152775f, 0.04266391f, 0.06913717f, -0.28471655f, -0.04765700f, 0.17270079f, -0.03714821f, -0.06314581f, 
    -0.25567165f, -0.05129761f, -0.09750263f, -0.06872009f, -0.04147572f, 0.04239379f, -0.01320384f, -0.11342337f, 
    -0.04051752f, -0.00707893f, 0.06995811f, -0.01990125f, -0.05235117f, 0.04528665f, -0.00251099f, 0.14772618f, 
    0.08239741f, -0.01688386f, 0.04640938f, -0.30896479f, -0.09679054f, 0.02495025f, -0.02311425f, 0.14477241f, 
    -0.02243338f, -0.18879497f, 0.09150660f, -0.11991530f, 0.15470029f, 0.01380039f, 0.06907725f, -0.03089251f, 
    -0.04427930f, -0.00794274f, 0.09098287f, -0.11705926f, 0.04227470f, -0.12507613f, 0.13241345f, -0.02543617f, 
    0.03024981f, -0.02746760f, -0.26751757f, 0.17681788f, 0.14237311f, 0.00263102f, -0.21454068f, -0.08834744f, 
    0.31210941f, -0.04666373f, 0.05715553f, 0.06606875f, 0.01734359f, 0.08318760f, -0.06127263f, 0.65773052f, 
    0.04331092f, 0.21226417f, 0.04019431f, -0.07205476f, -0.03188189f, 0.04825787f, 0.21877736f, 0.02562479f, 
    -0.04030142f, -0.13633023f, -0.00327247f, -0.08118936f, 0.00487312f, 0.09948137f, -0.02566241f, -0.19552492f, 
    -0.15941183f, 0.07900150f, -0.03622723f, -0.07204521f, 0.04735747f, -0.02678311f, 0.00158248f, -0.13631795f, 
    -0.09749833f, 0.07687993f, 0.09265445f, 0.21426222f, -0.06864016f, -0.09438600f, 0.02531574f, 0.05150437f, 
    0.04108578f, -0.06281234f, 0.16284554f, -0.06547713f, -0.00858623f, -0.02940267f, 0.02245277f, -0.09035650f, 
    -0.08552393f, -0.02348222f, 0.07270522f, -0.08777330f, -0.02563375f, 0.00156825f, 0.00597747f, -0.03186747f, 
    -0.14141862f, 0.09976383f, -0.12767506f, 0.13954604f, -0.04322056f, -0.03385933f, -0.10133035f, -0.09946978f, 
    -0.06747069f, -0.08184484f, 0.13782606f, 0.09048137f, 0.03359154f, -0.08072374f, 0.24825600f, 0.03535639f, 
    0.05376488f, 0.12992558f, -0.03796829f, 0.08982292f, -0.01421366f, 0.03284195f, -0.05831425f, -0.05863412f, 
    -0.19909143f, 0.09119093f, 0.02394967f, 0.03418777f, -0.03439343f, -0.06818518f, -0.06551334f, -0.09167055f, 
    0.12498970f, -0.21871322f, 0.18254271f, -0.03337132f, 0.00199699f, -0.07148930f, 0.11219012f, -0.02271270f, 
    -0.08144235f, 0.05721038f, 0.08745033f, 0.02044631f, -0.09035169f, 0.12580860f, 0.03674712f, 0.03283606f, 
    0.04531068f, 0.01312184f, -0.06184653f, 0.22406475f, 0.04363633f, -0.05095484f, -0.16474749f, 0.17843392f, 
    0.04586083f, 0.09920529f, -0.07312232f, 0.33181399f, 0.08737905f, 0.00064687f, -0.20395485f, 0.05425360f, 
    0.01710226f, 0.01212505f, 0.04948073f, 0.03057469f, 0.03213298f, 0.12203626f, 0.28059247f, -0.02847748f, 
    -0.02051183f, 0.06939265f, 0.01755259f, 0.02024983f, 0.04336888f, 0.11493441f, -0.01839312f, 0.01253841f, 
    -0.10221450f, -0.02922860f, -0.22239675f, -0.06362713f, -0.01919241f, -0.06379627f, 0.03529859f, 0.05966190f, 
    0.07771291f, -0.05698900f, 0.12087015f, -0.06185190f, -0.05793412f, -0.13442877f, -0.13125928f, 0.13232408f, 
    0.01424447f, -0.04538540f, 0.01269944f, 0.09224119f, 0.08546683f, -0.07873213f, 0.16801929f, 0.08451904f, 
    -0.27153531f, -0.15649188f, 0.22025290f, -0.12889720f, 0.06427909f, 0.03646044f, -0.10066170f, 0.08101864f, 
    -0.10256230f, 0.39034694f, -0.24487951f, 0.03182657f, 0.02213381f, -0.03730466f, 0.17592965f, 0.05545481f, 
    -0.09926127f, -0.03851927f, -0.18466283f, 0.08893315f, 0.02483263f, 0.11681639f, -0.04547650f, 0.10403663f, 
    0.03542928f, -0.02792631f, 0.04901200f, 0.06651501f, 0.21462244f, -0.04441197f, 0.00828678f, -0.01412363f, 
    -0.00303945f, -0.01656959f, 0.04150558f, 0.04383769f, 0.13091701f, 0.08962268f, -0.13773404f, 0.06886708f, 
    -0.05919321f, -0.02243057f, 0.02888273f, 0.09959991f, -0.09846042f, 0.16466275f, 0.00741318f, -0.09806434f, 
    -0.07592560f, 0.14008866f, -0.00093895f, 0.06730340f, 0.04113036f, 0.07159360f, -0.16901846f, 0.03538433f, 
    0.11225518f, 0.01186504f, -0.08028565f, -0.15669848f, -0.05978431f, 0.04048457f, -0.00417206f, -0.02429888f, 
    -0.07692444f, -0.08352269f, -0.06310133f, -0.01446766f, -0.06158376f, -0.20244615f, 0.06895792f, 0.02328879f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10005830f, -0.01198165f, 0.02390938f, 0.07495351f, -0.05005949f, -0.00530226f, 0.01994550f, 0.09891219f, 
    0.02310206f, 0.00419441f, -0.05475679f, -0.03335939f, 0.18983831f, 0.05502715f, 0.02027208f, 0.03187073f, 
    0.03098380f, 0.01945498f, 0.14918473f, -0.03957495f, -0.02962908f, 0.06547268f, -0.00683692f, 0.04817076f, 
    0.03049507f, -0.05398336f, 0.00214995f, 0.02919115f, 0.03034036f, 0.11098327f, 0.02676764f, -0.01514665f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42096829f, -0.09194484f, 0.14440352f, -0.19681340f, -0.12763010f, 0.01818184f, -0.12368110f, 0.18548697f, 
    0.07759146f, -0.05880067f, -0.02772484f, 0.03788892f, 0.12634306f, -0.10580395f, -0.20751615f, 0.07127992f, 
    0.22960466f, -0.06452361f, 0.04578074f, 0.31379119f, -0.02830764f, 0.28714448f, 0.16062343f, -0.45345432f, 
    0.27906239f, 0.14520514f, 0.03732673f, 0.10688321f, -0.05947142f, 0.33807215f, -0.06616716f, 0.11584962f, 
    -0.00679553f, -0.12733060f, 0.13050963f, -0.15811861f, -0.11322346f, -0.02505902f, 0.11577728f, -0.12942138f, 
    -0.07514741f, -0.03754243f, 0.11601561f, 0.04315814f, -0.02676894f, -0.09352802f, -0.12045615f, 0.13127221f, 
    -0.07161716f, 0.02175287f, -0.16015008f, -0.01650995f, -0.11333229f, -0.10130809f, -0.01480353f, 0.01980398f, 
    0.11247046f, -0.00344742f, 0.14742082f, 0.07896170f, -0.02426329f, -0.04746462f, -0.14065577f, -0.10592253f, 
    -0.13620812f, -0.17314395f, 0.13528146f, 0.14007325f, -0.27832109f, 0.01164470f, 0.14458703f, 0.24171089f, 
    0.11847807f, -0.07323886f, 0.11033329f, -0.08161776f, 0.26997262f, 0.16646340f, -0.15880901f, 0.16188647f, 
    0.13783318f, -0.02194857f, -0.63151479f, -0.19036075f, 0.00323006f, -0.08258910f, 0.29559678f, 0.07896062f, 
    -0.14594777f, -0.21152221f, -0.08135469f, -0.30505046f, -0.08155738f, 0.27737981f, 0.66589099f, 0.01749794f, 
    0.06494755f, 0.11528952f, -0.16151161f, -0.07040049f, -0.07571149f, -0.04725099f, -0.19183224f, 0.14938095f, 
    0.06216378f, 0.13306393f, -0.10241579f, -0.04942724f, -0.09277795f, -0.17771672f, 0.05155241f, -0.16152975f, 
    0.07412691f, -0.04635572f, -0.11176454f, -0.09978470f, -0.18058464f, 0.06189221f, 0.06907628f, 0.08454680f, 
    -0.11871773f, -0.06992432f, -0.07069894f, -0.02201801f, -0.17516334f, -0.13796614f, -0.06494713f, 0.13070220f, 
    -0.18136618f, -0.14482731f, 0.07297503f, -0.14515495f, -0.00314333f, 0.07684643f, 0.13015567f, -0.01273369f, 
    0.17043331f, 0.16079089f, -0.08829150f, 0.07782658f, 0.00767720f, -0.14694235f, 0.00426651f, 0.05941515f, 
    -0.03049335f, -0.13830702f, 0.04293768f, -0.14677736f, -0.17493658f, -0.15525913f, -0.08522854f, -0.01954618f, 
    0.06939905f, 0.05310298f, -0.10649092f, -0.02730655f, -0.10885170f, -0.01046719f, -0.03637280f, -0.06252225f, 
    -0.14382885f, -0.09521392f, 0.05222806f, -0.14402837f, 0.10465793f, -0.05615328f, -0.15196081f, -0.02555577f, 
    0.15787083f, 0.16552249f, 0.09769884f, -0.12475958f, 0.08178703f, 0.03537555f, -0.02129858f, -0.01250845f, 
    0.00101046f, -0.17266023f, -0.10313687f, -0.18038005f, -0.13259982f, 0.09274521f, 0.01466429f, -0.04220162f, 
    -0.14622159f, -0.15448937f, 0.00458347f, 0.13296859f, 0.07234556f, 0.12665230f, -0.03146204f, -0.03826701f, 
    -0.17692696f, 0.03464555f, 0.08638576f, 0.32097760f, -0.02141354f, -0.05082678f, 0.00897131f, 0.02627871f, 
    0.03302790f, -0.00264509f, -0.06127104f, 0.10628811f, 0.03473646f, 0.11773422f, 0.09938562f, 0.39002791f, 
    -0.16295359f, -0.20339657f, 0.05651107f, -0.21856749f, 0.13760063f, 0.24291825f, 0.11183219f, 0.27459368f, 
    -0.07862922f, 0.26305696f, -0.02435959f, -0.44197023f, -0.37729686f, -0.26814157f, 0.15828037f, -0.06735703f, 
    0.41317976f, 0.14939435f, 0.21345696f, -0.03321743f, -0.11056776f, 0.00276787f, 0.14244331f, -0.22063611f, 
    -0.13806807f, 0.02855534f, -0.04408737f, 0.06228226f, 0.13653505f, 0.28992441f, 0.56486422f, -0.33914211f, 
    0.15779237f, -0.33227283f, 0.20042415f, 0.28961906f, -0.04904490f, 0.11224959f, -0.30172044f, -0.15473118f, 
    0.28131261f, 0.04433824f, -0.17241301f, 0.78305238f, -0.38050002f, 0.33345941f, -0.14150649f, 0.19676486f, 
    0.12560341f, 0.11342664f, 0.02786272f, 0.41411892f, -0.15648377f, 0.11543492f, 0.22975983f, 0.17064267f, 
    0.14059193f, -0.02749472f, -0.12371549f, 0.17711675f, 0.38730687f, 0.40786386f, -0.24067135f, 0.03021869f, 
    -0.16628745f, 0.31367493f, -0.26315787f, -0.31158996f, 0.22294945f, 0.04447575f, 0.12649228f, 0.26330581f, 
    -0.38418403f, -0.19087900f, 0.08046490f, -0.36543754f, -0.12300317f, -0.49817950f, 0.29921502f, -0.05180452f, 
    0.22770908f, 0.07925169f, -0.28444797f, -0.09457249f, 0.13271561f, 0.03870291f, 0.03979633f, 0.16207182f, 
    0.09209105f, 0.06664883f, -0.12955806f, -0.15762967f, 0.05926291f, 0.16995697f, 0.19520319f, -0.00912397f, 
    -0.04417380f, 0.23726113f, 0.44459164f, 0.18942037f, -0.52274597f, -0.26854292f, -0.09925914f, 0.09791783f, 
    0.27466646f, -0.30867374f, -0.10436428f, 0.26666406f, 0.33267003f, -0.20147125f, -0.04421118f, 0.28498265f, 
    0.10597083f, 0.10309703f, -0.37102875f, -0.21780366f, 0.40612793f, -0.04724257f, 0.06209477f, 0.14760432f, 
    -0.15041146f, 0.11047956f, 0.08097581f, -0.12019871f, 0.06281041f, -0.18511191f, -0.51823294f, 0.43871832f, 
    0.00820876f, 0.46471927f, -0.27292198f, -0.03689558f, -0.01672147f, -0.16311117f, 0.32991576f, -0.00973441f, 
    0.37004185f, 0.09787554f, 0.11479466f, -0.17824727f, -0.02338055f, -0.25237942f, 0.37423810f, 0.27714434f, 
    0.15661629f, -0.03988327f, -0.23051471f, 0.07918544f, 0.26942879f, -0.02982501f, 0.32590371f, -0.27161869f, 
    0.13729399f, -0.13975705f, -0.04479571f, 0.09405904f, 0.20225874f, 0.28943458f, 0.03829230f, -0.21205580f, 
    0.12040061f, 0.04275863f, 0.27428114f, 0.06128567f, -0.19985852f, -0.46551770f, -0.14251426f, 0.26614448f, 
    -0.03341854f, -0.22391255f, 0.14408015f, -0.30998808f, 0.13593902f, 0.18365669f, -0.34769002f, -0.10213253f, 
    0.24670474f, -0.03902292f, -0.23004323f, -0.08816195f, 0.13204309f, -0.14678991f, 0.45782691f, -0.34370607f, 
    0.14172426f, -0.06590056f, -0.04893437f, 0.12086654f, 0.03288551f, -0.12257381f, -0.33173347f, -0.13972825f, 
    -0.02690252f, 0.19727059f, 0.07998995f, 0.31290209f, 0.26168361f, 0.26912296f, -0.07325196f, -0.08973172f, 
    0.32017490f, 0.45971882f, 0.14162029f, 0.03910572f, -0.24153146f, 0.12830484f, -0.17837447f, -0.01769424f, 
    0.28873721f, -0.13091213f, 0.04659269f, -0.21318473f, 0.46231827f, -0.05074302f, -0.24226336f, 0.10003126f, 
    -0.09989647f, 0.12919615f, -0.10726475f, 0.08060595f, -0.09219183f, -0.20059347f, -0.30024672f, 0.24991520f, 
    -0.11204854f, -0.06483255f, -0.02298863f, 0.32323059f, -0.15034804f, -0.30604532f, 0.16890511f, 0.26550514f, 
    0.17420998f, 0.35693794f, 0.12703550f, -0.09870557f, 0.49543056f, 0.13510785f, -0.52028131f, 0.08535580f, 
    -0.26572335f, -0.08415036f, -0.42176855f, -0.18398063f, 0.29529136f, 0.17808384f, 0.19335170f, -0.06088987f, 
    -0.03269894f, -0.15913567f, 0.12644026f, 0.02534873f, -0.17429674f, 0.13088271f, 0.42196128f, -0.10687641f, 
    -0.15784171f, 0.25347736f, 0.36044455f, 0.14394478f, -0.50535595f, -0.37286368f, 0.18701318f, 0.40747973f, 
    0.10869222f, -0.07400547f, 0.04059858f, -0.03478041f, 0.51062894f, 0.32142058f, 0.22310926f, 0.39198813f, 
    -0.01569824f, 0.01676275f, 0.37607387f, -0.01681933f, -0.32719776f, -0.09591439f, -0.18479130f, 0.07470050f, 
    0.06249084f, -0.01534892f, 0.06265235f, -0.16529241f, -0.15465510f, -0.03026855f, -0.05625327f, 0.15142466f, 
    0.41707376f, -0.03679010f, 0.01588329f, 0.07862338f, 0.23012914f, 0.33014676f, 0.20025888f, -0.41060057f, 
    0.06279580f, 0.38406879f, 0.14180085f, 0.33607244f, -0.10530642f, 0.39341915f, 0.42304188f, 0.14614975f, 
    0.06491856f, 0.16464479f, -0.15781708f, -0.10429488f, -0.18038824f, 0.14230335f, -0.17208898f, 0.16733538f, 
    -0.17107631f, -0.04353561f, -0.13817763f, 0.08528495f, -0.15054660f, -0.12455823f, -0.04723633f, -0.02455924f, 
    -0.06946895f, 0.04238928f, -0.13372257f, -0.05645298f, -0.05134203f, -0.00715910f, 0.12664375f, -0.16131350f, 
    -0.05962412f, -0.02028409f, 0.03192468f, -0.14926235f, 0.00972033f, 0.08144775f, 0.02643156f, 0.08112007f, 
    -0.07134448f, -0.03521004f, -0.10785242f, -0.09318288f, 0.24718983f, -0.04355644f, 0.25369292f, -0.14511342f, 
    -0.12025014f, 0.17053241f, -0.13773662f, -0.03802601f, 0.06776804f, -0.04265049f, 0.36761355f, -0.06019755f, 
    -0.32438177f, 0.42385620f, -0.15429091f, -0.13155459f, 0.13064308f, 0.19430566f, -0.17243084f, 0.13060306f, 
    0.42049712f, -0.19920886f, -0.10285623f, 0.04426610f, 0.00468116f, -0.02374205f, 0.44213912f, 0.34877345f, 
    0.00627740f, 0.07862927f, 0.11647388f, 0.41574481f, -0.25744843f, 0.09109834f, 0.08206734f, 0.11690646f, 
    -0.00993612f, -0.13679036f, -0.08101277f, 0.08160100f, 0.14077307f, 0.12012958f, -0.37614331f, 0.16225891f, 
    0.10909904f, -0.00520495f, 0.29144537f, -0.08902437f, 0.26263887f, -0.03777514f, -0.19257112f, 0.25214523f, 
    -0.37998164f, 0.36376467f, -0.04389670f, -0.25839096f, 0.04475421f, -0.10942757f, 0.05849200f, -0.30922613f, 
    -0.02805014f, 0.13751052f, -0.17740041f, 0.15913467f, -0.11105239f, -0.06140162f, 0.09036845f, 0.06590815f, 
    -0.08683565f, -0.14931335f, 0.13520043f, 0.13188618f, -0.06192961f, -0.17174625f, 0.13923709f, -0.06321528f, 
    -0.07794867f, -0.16379218f, -0.01036057f, -0.13621072f, -0.09435224f, 0.07980505f, -0.06484164f, 0.14981028f, 
    -0.10142600f, 0.03809560f, -0.16064841f, 0.14026825f, -0.11791952f, 0.00793600f, -0.17168973f, -0.07915166f, 
    0.24390934f, -0.16191135f, -0.15085256f, -0.04513765f, 0.22293909f, -0.13431945f, 0.19674769f, 0.23936498f, 
    -0.03542051f, 0.01184942f, 0.12637225f, -0.05879330f, -0.05755392f, -0.01847743f, -0.40534574f, 0.41313648f, 
    -0.00362873f, 0.41843432f, -0.01539182f, -0.10487400f, -0.51596117f, -0.33127955f, 0.19299626f, 0.19685750f, 
    0.20084955f, 0.14401388f, 0.09830732f, -0.49206904f, 0.09195355f, 0.19276130f, 0.22027522f, -0.15053065f, 
    -0.56990933f, -0.06221741f, 0.34110945f, -0.03207208f, -0.52509826f, 0.12730023f, 0.09499398f, -0.09922580f, 
    0.01810749f, -0.04965255f, -0.00994453f, 0.14268674f, -0.20946015f, 0.15366530f, -0.36427590f, -0.01780809f, 
    0.25082335f, 0.48949230f, 0.50285846f, -0.03593066f, 0.07357705f, -0.03876402f, -0.10033365f, -0.08177030f, 
    -0.28135234f, -0.11839128f, -0.00777135f, 0.03466566f, 0.21888401f, -0.60968977f, 0.39423594f, -0.00631286f, 
    -0.00783183f, 0.16984200f, 0.01946913f, -0.16288052f, 0.03002440f, -0.11319903f, 0.14838319f, -0.14262934f, 
    0.04504465f, -0.00442146f, -0.03073074f, 0.06060854f, -0.10732025f, -0.12198885f, 0.12814903f, -0.09649879f, 
    0.03131867f, -0.04506362f, -0.08031240f, -0.13550842f, -0.04501075f, 0.00667385f, -0.16414583f, -0.15765958f, 
    -0.01213180f, -0.03390389f, 0.05332339f, -0.11694530f, -0.03358729f, 0.09291970f, 0.01657555f, -0.01086464f, 
    -0.02626208f, 0.11806126f, -0.16996221f, 0.38397047f, -0.27942508f, -0.12537257f, -0.13210107f, 0.07915577f, 
    -0.03243648f, 0.02186555f, -0.08435068f, 0.03040933f, 0.08377375f, 0.16684814f, -0.00371530f, 0.08940391f, 
    0.20143299f, -0.15159543f, 0.44791800f, -0.26751050f, 0.23909833f, 0.09392252f, -0.20109329f, -0.01204232f, 
    -0.09215384f, 0.47024718f, 0.00896920f, -0.26020834f, 0.04204089f, 0.11392356f, 0.04518775f, -0.14011067f, 
    0.17735043f, 0.15392704f, -0.28660145f, -0.32293692f, 0.36489370f, -0.13408293f, 0.29834738f, 0.04929583f, 
    0.06862452f, 0.12303799f, 0.17670898f, 0.04218357f, -0.11049468f, -0.14653994f, 0.07350882f, -0.06867760f, 
    -0.11399044f, 0.33586201f, 0.13032611f, 0.35174870f, -0.39618313f, -0.05608491f, 0.13825580f, 0.20977539f, 
    0.16190121f, -0.18854690f, 0.10803416f, 0.02842277f, 0.25377712f, -0.15508419f, -0.25237319f, 0.34076497f, 
    0.00982444f, -0.17350796f, -0.09788475f, 0.23324880f, -0.12493686f, 0.14902219f, 0.21043609f, 0.07932436f, 
    0.01451756f, -0.08653618f, 0.01699720f, -0.09260017f, 0.12592781f, 0.23895921f, 0.34330329f, -0.21372987f, 
    0.00033384f, -0.17260377f, 0.18341033f, -0.08715802f, 0.33019531f, 0.27523986f, -0.02762490f, 0.13077350f, 
    0.18056844f, -0.20678139f, 0.04758377f, 0.07358159f, -0.24021521f, -0.26513699f, -0.07140247f, 0.04890721f, 
    -0.25855291f, -0.12964836f, -0.13670580f, 0.33457157f, 0.01191699f, -0.03124750f, 0.11684345f, -0.17512597f, 
    0.03977706f, -0.11275662f, -0.07071088f, 0.13463812f, -0.17552023f, 0.01533195f, -0.21668337f, 0.33157706f, 
    0.01319744f, 0.42620209f, 0.09229299f, -0.23928849f, 0.04946772f, -0.00174424f, -0.13136363f, 0.17586753f, 
    -0.22696267f, 0.16219296f, -0.15019144f, -0.23838308f, 0.15746520f, 0.12889220f, 0.53381956f, 0.20690958f, 
    -0.05428613f, 0.07867035f, 0.05470754f, 0.51536238f, -0.10905650f, -0.09076514f, -0.08991373f, -0.13331480f, 
    -0.10190207f, 0.06740785f, -0.07338510f, -0.09939549f, 0.08844717f, 0.28933936f, -0.12907024f, 0.25620496f, 
    0.16854559f, 0.22581790f, 0.08996055f, -0.11876597f, -0.36280507f, -0.24917080f, -0.06498367f, 0.06222707f, 
    -0.45043394f, 0.32727817f, 0.05311736f, -0.40986601f, 0.26322138f, 0.32981527f, 0.28734812f, -0.30296841f, 
    0.19683515f, 0.03498841f, -0.26620474f, 0.16345194f, -0.18039599f, 0.09292994f, -0.18297984f, 0.26520678f, 
    0.08443762f, 0.04783975f, 0.14769010f, 0.04440077f, 0.24058892f, 0.18615608f, 0.56886351f, 0.44991815f, 
    -0.20968617f, 0.13343965f, 0.18715522f, -0.19092408f, -0.46778715f, -0.01074319f, -0.18875122f, 0.30748910f, 
    0.24835363f, 0.01448619f, -0.11034177f, -0.08549303f, 0.02463114f, -0.25848898f, 0.21519110f, 0.32128090f, 
    -0.20147018f, 0.14996415f, 0.19361575f, -0.15001653f, 0.18570213f, 0.09469265f, -0.26198494f, 0.20361337f, 
    -0.07315874f, -0.13237229f, -0.02994064f, 0.15735422f, -0.04417367f, -0.17217447f, 0.22575769f, -0.09552927f, 
    0.26283070f, 0.09337218f, -0.31386259f, -0.08591263f, 0.58062202f, 0.13542452f, 0.45550928f, -0.10309349f, 
    0.27292839f, -0.19691442f, -0.15466912f, 0.00474917f, 0.30149445f, 0.11800732f, 0.41012549f, 0.26099792f, 
    -0.21904980f, 0.08706164f, 0.08788468f, -0.06843434f, -0.03446805f, 0.01359353f, 0.06228530f, -0.09296584f, 
    -0.00112175f, 0.09356616f, -0.10898749f, -0.15289162f, 0.13808009f, -0.13230133f, -0.02466710f, -0.09704766f, 
    0.19281237f, 0.30765459f, 0.23272657f, 0.05603926f, -0.03387488f, -0.13245936f, 0.26772258f, -0.24137489f, 
    -0.23837973f, -0.42794523f, -0.14188173f, -0.03267584f, 0.10826369f, 0.38648549f, 0.35174063f, -0.08747447f, 
    -0.15962586f, -0.11631959f, -0.08728640f, -0.02673164f, -0.10204464f, -0.16631854f, 0.08225309f, 0.08430284f, 
    -0.06927441f, -0.14652658f, -0.12942804f, 0.12284957f, -0.10314379f, -0.11347441f, 0.08830509f, -0.05223042f, 
    -0.11811522f, -0.14761496f, -0.11272763f, -0.04558243f, 0.16827221f, -0.11817363f, 0.00297085f, -0.02000930f, 
    0.07136095f, -0.04280982f, -0.08315913f, -0.03879580f, -0.13411555f, 0.07707106f, 0.06300341f, 0.05533531f, 
    0.06658234f, -0.08205854f, 0.12658970f, -0.05205038f, 0.07399118f, -0.04085963f, -0.01028433f, 0.01161862f, 
    0.02213736f, 0.03336833f, -0.02300463f, -0.04778711f, -0.16855285f, -0.12017243f, -0.00815194f, -0.05366817f, 
    0.11819065f, 0.02392690f, 0.01564711f, -0.14321519f, -0.15066580f, -0.04489251f, -0.07570108f, -0.08720505f, 
    0.01560960f, 0.05233640f, 0.14211720f, -0.08783711f, -0.01749134f, 0.05654154f, -0.12271971f, -0.07504883f, 
    0.10033280f, -0.05942095f, -0.42896202f, -0.07046654f, 0.34838212f, -0.01235278f, 0.45816123f, -0.36974788f, 
    0.17380889f, 0.12476721f, -0.10359850f, -0.10578591f, 0.10194257f, 0.06165348f, -0.06130189f, -0.29604807f, 
    -0.04907966f, -0.29868600f, 0.26570183f, 0.46642250f, 0.14410549f, 0.19439380f, -0.19044228f, 0.16006796f, 
    0.31427294f, 0.34450629f, 0.01455745f, -0.18360734f, 0.03880229f, 0.23675600f, -0.45062432f, -0.03291915f, 
    0.29452318f, -0.05912941f, 0.04694675f, -0.20958790f, 0.07901728f, -0.12914176f, 0.03403942f, -0.08712686f, 
    0.00466193f, -0.02343260f, 0.16929273f, -0.11084406f, -0.17841621f, 0.11861520f, -0.31855237f, 0.07090999f, 
    0.23890556f, 0.21813923f, 0.05823760f, 0.45064941f, -0.46379805f, -0.22663945f, 0.19464259f, -0.18112935f, 
    0.12727930f, 0.01874924f, 0.06183740f, -0.06827879f, 0.18093425f, 0.40373796f, -0.01725546f, -0.24431095f, 
    0.38398117f, -0.16888657f, -0.11211782f, -0.25154454f, 0.22811900f, -0.15481207f, -0.29564080f, 0.46295878f, 
    0.09233957f, 0.10574299f, -0.12874474f, 0.05556751f, 0.21453869f, 0.09584982f, 0.27199492f, 0.33285251f, 
    0.07747647f, 0.04615207f, -0.22994757f, 0.31065437f, -0.53711653f, 0.12101375f, 0.00270446f, -0.22895977f, 
    0.37755692f, -0.17894834f, -0.12203626f, 0.32405475f, 0.15880418f, -0.06574785f, -0.02650331f, 0.26755390f, 
    0.02825547f, -0.10181218f, 0.02049891f, -0.05062557f, -0.04917741f, 0.10637902f, -0.12712875f, -0.03049022f, 
    -0.13838898f, 0.05433872f, 0.14777884f, -0.10724761f, -0.12124693f, -0.00753960f, 0.01642742f, -0.09714906f, 
    0.12785879f, -0.15488717f, -0.11696853f, 0.10036337f, -0.06127601f, -0.09814358f, 0.04266220f, 0.02996847f, 
    -0.13055477f, -0.15260318f, -0.03298747f, -0.13933514f, -0.11884337f, 0.00425682f, 0.02824020f, -0.18670440f, 
    0.04256686f, -0.09850784f, 0.60747623f, 0.34828860f, -0.18579344f, -0.10267711f, -0.19223274f, 0.09072383f, 
    0.06360614f, 0.01202413f, 0.15017600f, 0.06421153f, 0.25160357f, 0.30367079f, 0.07708121f, -0.23019977f, 
    0.37387958f, -0.27738360f, 0.25192788f, -0.02433509f, 0.37753987f, -0.27647790f, 0.04842214f, -0.04895879f, 
    -0.30460319f, 0.05583875f, -0.10774934f, 0.28483963f, -0.27620491f, 0.16627321f, -0.29080227f, -0.27365500f, 
    -0.17197229f, 0.12306014f, -0.12068158f, -0.07931954f, 0.02965895f, -0.00050715f, 0.04646524f, 0.04465644f, 
    -0.06461213f, -0.02598939f, 0.02740529f, -0.00376921f, -0.00827570f, 0.10649278f, -0.12141236f, -0.14536503f, 
    -0.00875019f, -0.09449995f, 0.11797903f, -0.13787894f, -0.16085166f, -0.15535337f, -0.13932832f, -0.07899023f, 
    -0.13708983f, -0.01106837f, -0.02522327f, -0.08661219f, -0.12602080f, -0.05732054f, -0.04796337f, 0.12609471f, 
    -0.04348047f, 0.05874743f, 0.11281282f, 0.17347138f, -0.23624273f, -0.08504108f, 0.11561015f, 0.11673226f, 
    -0.12049460f, -0.07100461f, 0.05627241f, -0.16813226f, 0.31281996f, -0.12350687f, 0.11105189f, -0.33345973f, 
    0.36132708f, -0.06295542f, -0.00314270f, -0.22728088f, 0.44431508f, 0.07935520f, 0.13230915f, -0.06585604f, 
    -0.29878932f, -0.18807153f, -0.16553771f, -0.34922040f, 0.00450006f, 0.36882323f, 0.23077735f, -0.14474510f, 
    -0.20236674f, 0.01547118f, -0.12556988f, -0.17410710f, 0.03077165f, 0.07026527f, 0.31888768f, -0.39805850f, 
    0.14696805f, 0.14674066f, 0.10629180f, -0.01795207f, -0.12563902f, 0.08298306f, -0.07540557f, -0.25766042f, 
    0.35779729f, -0.19400944f, 0.31789336f, 0.32179105f, 0.29744947f, -0.01703218f, -0.24226034f, 0.02619838f, 
    -0.12956698f, 0.36302191f, 0.07233299f, -0.09572101f, 0.02093850f, 0.21087746f, -0.13851047f, 0.23773280f, 
    0.15010919f, 0.00933218f, -0.16776362f, -0.17218211f, -0.10344588f, -0.13609008f, 0.09831263f, -0.12200551f, 
    -0.05023875f, 0.11031409f, 0.12449774f, -0.02879471f, 0.07300880f, 0.11979317f, -0.05346054f, -0.15548225f, 
    -0.18707152f, -0.11833431f, -0.15095632f, -0.06441964f, 0.07958806f, -0.05180387f, -0.06836452f, -0.12895565f, 
    -0.19339380f, -0.13747002f, 0.01277614f, -0.15508869f, 0.07109976f, -0.01893318f, -0.11209814f, 0.06240210f, 
    0.29419026f, 0.04620894f, 0.19899200f, -0.21256316f, 0.25647289f, 0.00823844f, -0.14274253f, 0.51126111f, 
    0.17471768f, -0.13291864f, -0.03334629f, -0.03471536f, 0.28053805f, -0.16432557f, -0.00960441f, 0.22590297f, 
    0.01241017f, -0.22717008f, -0.63085246f, 0.29102689f, 0.50612020f, 0.38369787f, 0.30460328f, -0.09218232f, 
    0.38532662f, -0.00409356f, -0.10083583f, 0.11515603f, -0.10167556f, 0.07846592f, -0.18142880f, 0.03045180f, 
    -0.26445350f, -0.12833542f, -0.04132807f, -0.20362084f, 0.41911054f, -0.05907921f, 0.09970915f, 0.02506210f, 
    -0.06109009f, -0.05977559f, -0.00470831f, 0.12009159f, -0.10580293f, -0.02831306f, 0.03009424f, 0.16169471f, 
    -0.07281040f, 0.31891257f, -0.05925205f, 0.00875807f, -0.24516235f, -0.18565845f, 0.20510718f, 0.38782254f, 
    0.00483042f, -0.18811336f, -0.15869389f, 0.01586835f, 0.43096265f, -0.18456070f, 0.06445373f, 0.10557222f, 
    -0.08956601f, -0.09514807f, -0.13442929f, -0.08973881f, -0.06578921f, 0.03775616f, 0.08798434f, -0.12470797f, 
    -0.04319369f, -0.08133387f, 0.13507940f, -0.05725304f, -0.07320601f, -0.14918965f, -0.15832001f, 0.04383739f, 
    -0.04862501f, 0.14909831f, -0.15450744f, -0.01771696f, -0.09536716f, -0.11326069f, 0.12884711f, -0.09436563f, 
    -0.17193480f, 0.03038975f, 0.11036091f, -0.03206348f, -0.10813005f, -0.05846542f, -0.12370566f, -0.08290294f, 
    0.10424638f, -0.05468284f, -0.26344457f, -0.17512646f, 0.21680513f, -0.14470389f, 0.32801253f, -0.09811844f, 
    0.07482687f, 0.05650118f, -0.07803366f, -0.07637575f, -0.06038217f, -0.25288078f, -0.29653180f, 0.35562292f, 
    0.19262035f, 0.17128012f, -0.18419351f, 0.15241504f, 0.14702746f, 0.43394142f, 0.07164127f, -0.21844338f, 
    0.38637602f, 0.49123242f, 0.11661538f, 0.17695409f, 0.06066637f, 0.22241648f, 0.06803708f, 0.18450394f, 
    0.13469054f, -0.03786112f, 0.43843749f, -0.04032150f, 0.27080673f, 0.04197056f, -0.28827280f, 0.39631256f, 
    -0.15055054f, 0.06106720f, 0.13190728f, -0.01732316f, 0.27819151f, -0.04862157f, 0.04124697f, 0.27449811f, 
    0.02718598f, 0.23240294f, -0.42960724f, 0.04372568f, -0.18890287f, -0.02597959f, 0.37439591f, -0.22190508f, 
    0.23152857f, -0.15629281f, -0.05515562f, 0.20456479f, 0.17507942f, -0.13915101f, 0.26540059f, 0.06773809f, 
    0.19339222f, -0.12162327f, 0.55349433f, 0.02379982f, -0.31680691f, 0.07617735f, -0.06108170f, -0.08225263f, 
    -0.00601933f, -0.16169271f, 0.00759522f, -0.05585555f, 0.07205062f, 0.20381726f, -0.59783554f, -0.06593551f, 
    0.21831612f, 0.43373659f, 0.22778094f, 0.20250037f, 0.07307887f, -0.09024639f, -0.07012454f, -0.10442122f, 
    -0.32434699f, -0.11616324f, 0.03121743f, 0.30144122f, 0.00174278f, -0.07611376f, 0.23638003f, -0.12628810f, 
    -0.09036323f, -0.06341501f, 0.18118022f, -0.02204359f, -0.00605830f, 0.11107188f, 0.38648057f, -0.23137815f, 
    -0.12954801f, 0.13447835f, -0.14918652f, -0.13028085f, 0.10670185f, -0.17405589f, -0.03549125f, -0.38169864f, 
    0.02446995f, -0.16782224f, -0.19740917f, 0.08608072f, 0.70746648f, 0.43237156f, 0.09953149f, -0.07296906f, 
    0.26759440f, 0.11342943f, 0.00191774f, -0.26995856f, -0.11223665f, -0.08411551f, 0.27195621f, -0.07437789f, 
    -0.03757182f, 0.03470491f, 0.23706724f, 0.46628419f, 0.26400247f, -0.08780805f, -0.39479101f, 0.17360885f, 
    -0.16814367f, 0.04746179f, -0.01190590f, 0.02993830f, -0.09290224f, -0.15180169f, -0.52952164f, 0.29954457f, 
    -0.04184010f, 0.08047079f, 0.06973249f, 0.15817021f, 0.01626830f, 0.06546866f, 0.01634375f, 0.07353129f, 
    0.20928849f, 0.44558150f, -0.07743661f, -0.04024765f, -0.48519364f, 0.10278895f, -0.00642943f, 0.25704855f, 
    0.11348640f, 0.10548072f, -0.37367460f, -0.05353226f, 0.19200338f, 0.14625031f, 0.28072688f, 0.01532008f, 
    -0.13940229f, 0.04743733f, -0.11597563f, -0.10752825f, 0.10992775f, 0.08554343f, -0.15213278f, -0.09268552f, 
    -0.04330056f, 0.14783262f, 0.67531776f, 0.32532033f, 0.20358697f, -0.18702963f, -0.27747983f, 0.24421471f, 
    0.15862922f, 0.39764699f, 0.17956081f, -0.33657733f, -0.30593768f, -0.22067291f, -0.36253116f, -0.20190366f, 
    0.30606356f, 0.00523952f, 0.04515241f, -0.18536195f, 0.12934911f, 0.10755955f, 0.02946090f, 0.00792948f, 
    -0.16176581f, -0.15453759f, 0.16110669f, 0.05958860f, 0.11850531f, -0.03442253f, -0.34172350f, -0.31475005f, 
    0.12110075f, 0.29126978f, -0.18536761f, 0.22626457f, -0.01627259f, 0.06052910f, 0.31265727f, 0.03394323f, 
    -0.24993896f, -0.29239741f, -0.00676118f, -0.10062204f, 0.49694318f, 0.24587439f, -0.05777078f, -0.34330350f, 
    0.35966650f, 0.01909611f, 0.39341295f, 0.15641269f, -0.03710483f, 0.04709822f, -0.05309951f, 0.28613883f, 
    -0.13234961f, -0.16433546f, 0.17070432f, -0.10361493f, 0.13263884f, 0.27803871f, 0.05482011f, 0.12958723f, 
    -0.10757006f, 0.08174866f, -0.00948207f, 0.21895699f, 0.06439765f, 0.23348902f, -0.13288288f, 0.20197748f, 
    0.12608677f, -0.06259837f, -0.13527818f, 0.39970043f, -0.47745320f, -0.50408548f, -0.26581866f, 0.05655947f, 
    0.09459005f, -0.10921580f, -0.22933833f, -0.17345789f, 0.21194963f, -0.15700307f, 0.13161115f, -0.20150551f, 
    0.11094068f, 0.13392837f, -0.10975333f, 0.06152274f, 0.24449870f, -0.00898407f, 0.28571722f, -0.41980332f, 
    0.10491547f, -0.09279107f, 0.05780153f, 0.06452456f, 0.39589012f, 0.35748917f, -0.01143570f, -0.15357000f, 
    0.21776293f, -0.03269594f, 0.00541571f, -0.34774917f, -0.08148656f, -0.00534247f, 0.26734480f, 0.06623844f, 
    -0.11126576f, 0.02639274f, 0.18233202f, 0.37384656f, -0.08750275f, 0.16633423f, -0.26852906f, 0.35078508f, 
    -0.15389694f, -0.08158125f, 0.06240258f, -0.17141153f, 0.00510757f, 0.10385369f, 0.15758173f, 0.33143038f, 
    0.24758686f, 0.06392384f, 0.10860157f, 0.12249447f, -0.17503139f, -0.13250883f, 0.17276928f, -0.19602238f, 
    -0.22531566f, -0.09589135f, 0.11005404f, 0.18358089f, -0.26157728f, -0.30572832f, 0.09938205f, -0.08627421f, 
    0.28699678f, 0.16476767f, 0.09263452f, 0.08469956f, 0.22368631f, 0.03416580f, 0.09499409f, 0.30347824f, 
    0.03614211f, 0.13579680f, -0.02468541f, 0.05143260f, 0.32482523f, 0.10307892f, -0.44707188f, 0.04706436f, 
    -0.13604628f, 0.12918930f, -0.06966992f, -0.20703627f, 0.34384120f, -0.04195808f, -0.13288029f, 0.24821243f, 
    0.07529923f, -0.25180864f, 0.05925035f, -0.16163333f, -0.62786484f, -0.32611150f, -0.04534169f, 0.10944689f, 
    0.15443060f, 0.16241874f, -0.00058904f, -0.05368980f, -0.10617033f, 0.10834654f, -0.13754541f, 0.10301542f, 
    -0.00971398f, -0.06817337f, -0.13045438f, 0.14581329f, -0.14143918f, -0.15771995f, -0.07290357f, 0.08672392f, 
    -0.09558216f, -0.17743583f, 0.06453909f, 0.03087744f, 0.10323545f, 0.07433259f, -0.18593210f, -0.14106959f, 
    0.03634997f, 0.00782778f, -0.17765331f, 0.13662615f, 0.14927347f, -0.01735957f, 0.06596365f, -0.17758028f, 
    -0.19252659f, 0.07781745f, -0.19974379f, -0.10053631f, -0.11701332f, -0.01102736f, -0.04760670f, 0.12811863f, 
    -0.07163588f, -0.03971114f, 0.03630068f, 0.02645037f, -0.02624339f, -0.20983478f, -0.06443843f, 0.00831673f, 
    -0.09314509f, 0.09931377f, -0.09009656f, 0.08692880f, 0.14131485f, -0.00752879f, -0.18781179f, -0.00250444f, 
    0.03414370f, -0.18225148f, -0.14119774f, -0.04281337f, 0.06753295f, -0.03619681f, 0.14329726f, 0.07859558f, 
    -0.04307040f, -0.17137684f, 0.08659751f, -0.19431105f, -0.09971160f, -0.14695989f, 0.01993769f, -0.00092794f, 
    -0.12846792f, 0.00575853f, 0.08431093f, 0.17440671f, -0.18419009f, 0.03029402f, -0.01235991f, 0.01302852f, 
    -0.08989150f, 0.09879740f, 0.06183685f, -0.10457008f, -0.20446439f, -0.08037770f, -0.13322134f, 0.01582884f, 
    -0.11766518f, 0.03730122f, 0.01960037f, 0.01405686f, 0.01464510f, -0.06949387f, 0.15093267f, 0.15710211f, 
    -0.09724887f, 0.03731759f, -0.46431762f, 0.11639295f, -0.00573244f, 0.02888048f, 0.05159432f, 0.17623344f, 
    0.13040437f, -0.15143415f, 0.17072150f, 0.03926511f, 0.14149831f, -0.05690415f, 0.42629376f, 0.32547054f, 
    0.04735470f, -0.11843994f, 0.10606336f, -0.42655694f, -0.28032497f, 0.06359656f, -0.21964392f, 0.35140854f, 
    0.11118961f, 0.15043662f, 0.03024790f, -0.16147900f, 0.16843094f, -0.01392635f, 0.47164077f, 0.37085983f, 
    -0.40152597f, 0.15059555f, -0.21765727f, 0.32404822f, -0.11248271f, 0.01494452f, 0.30384648f, -0.30227575f, 
    -0.00416941f, 0.15160958f, -0.11839028f, 0.02207660f, -0.23195799f, -0.06538419f, -0.17151275f, -0.01027554f, 
    0.26751727f, 0.26400417f, 0.42515585f, 0.10859947f, 0.24335176f, -0.15691574f, 0.00556504f, 0.24321142f, 
    -0.18632512f, 0.35299224f, -0.12176110f, -0.14400688f, -0.11786903f, 0.05163987f, 0.05321041f, 0.16370027f, 
    -0.16991363f, 0.07933986f, -0.01156346f, 0.14805827f, -0.19102320f, 0.07430647f, 0.00665703f, -0.12717119f, 
    -0.10517961f, 0.06358969f, 0.08818423f, -0.17160735f, -0.19989890f, 0.03723743f, 0.03538343f, -0.11069369f, 
    -0.04192885f, 0.02347076f, 0.04244650f, 0.19848065f, -0.12432307f, 0.17998524f, 0.06604859f, 0.09428822f, 
    0.15887363f, -0.02495735f, 0.10449573f, 0.42298156f, -0.08128463f, -0.45209002f, -0.15414645f, 0.32088274f, 
    0.10800125f, 0.01247487f, 0.00973883f, -0.18265024f, -0.10815687f, -0.04668670f, 0.36553487f, -0.18472224f, 
    -0.14990556f, -0.09794865f, 0.05398214f, -0.07994702f, 0.30052480f, 0.05525731f, 0.37593424f, 0.10715143f, 
    -0.09119526f, 0.00047214f, -0.34734145f, -0.16395916f, -0.01500355f, 0.41201046f, -0.26510257f, -0.10586008f, 
    0.23253874f, 0.02949113f, 0.16413473f, 0.35643312f, -0.28569838f, 0.13902967f, 0.46909609f, -0.00377170f, 
    -0.32804525f, -0.11374401f, -0.08284575f, 0.35640392f, -0.04836341f, -0.15017846f, 0.09737615f, -0.05710860f, 
    0.13888901f, 0.12291049f, -0.08142594f, -0.10305877f, -0.04699761f, 0.28511271f, 0.21556497f, -0.01012408f, 
    0.16170160f, -0.08140602f, 0.47155556f, -0.21077818f, 0.02649678f, -0.38178432f, -0.21051812f, 0.34318614f, 
    -0.39342502f, 0.20906703f, -0.09052974f, -0.28910330f, 0.23759583f, 0.34346500f, 0.09173278f, 0.16086891f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09272192f, -0.08569240f, 0.08350158f, 0.13697080f, 0.15944481f, 0.02268183f, -0.07332864f, -0.14032689f, 
    0.21794744f, 0.02528009f, 0.16484421f, 0.01496030f, 0.01441090f, 0.16491440f, 0.14498670f, -0.01720653f, 
    0.15126051f, 0.09517083f, -0.04911702f, -0.06901513f, 0.14936630f, -0.08351642f, 0.09410559f, 0.25991374f, 
    0.09691507f, 0.19332379f, 0.03322360f, 0.09170277f, 0.06620876f, 0.06261515f, 0.04223216f, -0.11006264f, 
    0.07053096f, 0.16268590f, 0.07145890f, 0.27107269f, 0.09532081f, 0.17438860f, -0.03382384f, 0.06923213f, 
    0.03628621f, -0.11772265f, 0.00216120f, 0.02785409f, -0.13673043f, -0.04743929f, 0.07202554f, -0.14653736f, 
    -0.05725630f, -0.04262815f, 0.01890282f, 0.28311035f, 0.19192305f, 0.10127234f, 0.07495897f, 0.15097108f, 
    -0.06215365f, -0.04907010f, -0.10439588f, 0.15080355f, 0.11145012f, -0.13222793f, 0.10770443f, 0.17364360f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07360881f, 0.05289660f, 0.02302584f, -0.02503087f, -0.00565524f, -0.09778699f, -0.04443033f, -0.07505225f, 
    0.08445036f, -0.08337426f, 0.26779163f, 0.02024418f, 0.64706045f, -0.52364612f, -0.11142206f, -0.19564579f, 
    -0.02355857f, 0.30901116f, -0.14620338f, 0.02033223f, 0.17140353f, -0.34318137f, -0.00624804f, -0.44751045f, 
    0.29235765f, 0.01890430f, 0.01360588f, -0.26649550f, -0.23112531f, -0.24008122f, -0.34796381f, -0.06678228f, 
    0.00271786f, 0.36321449f, -0.01478776f, -0.16212025f, -0.06818489f, -0.44999158f, 0.12311102f, -0.18453850f, 
    0.07689099f, -0.05473572f, 0.07395472f, -0.01712800f, -0.03156506f, 0.34091914f, -0.21673903f, -0.02805464f, 
    0.34745917f, -0.51703632f, 0.25864428f, 0.07079587f, 0.04373157f, 0.23076016f, -0.82301211f, 0.27382132f, 
    -0.07863355f, -0.21061543f, -0.07413764f, -0.05713152f, 0.01533090f, 0.02400983f, 0.41850355f, -0.25162017f, 
    0.23671252f, -0.12219198f, -0.09153606f, -0.11515565f, 0.03944257f, 0.08802916f, 0.06116354f, 0.21026038f, 
    -0.13951793f, -0.21182275f, -0.48744389f, -0.10641393f, 0.28257537f, -0.33804697f, -0.12178369f, 0.17582996f, 
    0.01606742f, 0.02920852f, 0.10750693f, 0.08411323f, -0.55070287f, -0.07318632f, -0.03579062f, 0.34280056f, 
    -0.35969895f, 0.13320945f, 0.06624266f, -0.03877579f, -0.06963313f, 0.02987189f, -0.07509691f, 0.06303577f, 
    -0.06930882f, 0.29606393f, -0.37865463f, -0.24821718f, 0.02445845f, 0.08771756f, 0.03286952f, 0.26265520f, 
    0.41548631f, -0.05624308f, -0.07691163f, -0.56242079f, 0.07933451f, 0.18025245f, -0.46226007f, -0.07708706f, 
    0.32112357f, -0.02717392f, 0.22859535f, -0.20190999f, -0.18641259f, 0.35995370f, -0.31293073f, -0.25423431f, 
    -0.12700023f, 0.01447016f, -0.04015150f, 0.19063997f, 0.11164473f, -0.21657728f, 0.26316941f, 0.05809261f, 
    -0.27512953f, 0.00074656f, 0.18390146f, -0.07658559f, -0.06030677f, 0.04046006f, 0.20752111f, -0.53025746f, 
    0.25366783f, -0.53222585f, 0.06828569f, -0.31978193f, -0.35265431f, -0.40591922f, -0.31268919f, 0.12072705f, 
    0.07224488f, 0.12382129f, 0.12994511f, 0.00114677f, -0.50461513f, 0.22183748f, 0.05585290f, -0.06882016f, 
    -0.33908334f, 0.10300123f, 0.09537891f, -0.08032298f, -0.37322325f, 0.59075528f, 0.02937624f, 0.05430679f, 
    -0.10279911f, -0.47294390f, -0.76595980f, -0.46846935f, 0.11559314f, 0.23890111f, -0.05184337f, 0.30181029f, 
    -0.11211543f, -0.01308960f, 0.19986010f, 0.05429563f, -0.08404272f, -0.31461227f, 0.18997110f, 0.14446357f, 
    0.43582109f, -0.14241320f, -0.31288323f, 0.16389848f, 0.04370954f, 0.18262149f, 0.05843359f, 0.37299684f, 
    0.02944928f, -0.08392214f, -0.04018243f, -0.18628460f, 0.07761363f, 0.15422200f, -0.27713931f, -0.00925979f, 
    0.13378356f, 0.05927646f, -0.13171358f, 0.01830912f, -0.02112120f, -0.05325217f, -0.14201944f, 0.30129611f, 
    -0.24517950f, 0.16135268f, 0.06342445f, -0.73736250f, -0.17730571f, -0.19157048f, -0.16668299f, 0.29915869f, 
    0.11371989f, 0.20624991f, -0.50107497f, -0.02443059f, -0.30892006f, -0.03715041f, 0.08805950f, -0.40136614f, 
    0.12470620f, 0.00412844f, -0.18690321f, -0.61560851f, 0.13922147f, 0.23438342f, -0.36114988f, -0.02646387f, 
    -0.08409175f, -0.45581630f, -0.16977642f, 0.29341790f, 0.01901788f, 0.00715180f, 0.06843628f, -0.63557893f, 
    -0.44137725f, 0.07802863f, 0.25764403f, -0.09716862f, -0.11849356f, 0.13902229f, 0.28666160f, 0.13148002f, 
    -0.35810927f, 0.00615590f, -0.62637287f, -0.35867530f, 0.24766055f, -0.21245849f, 0.21118963f, 0.03595488f, 
    -0.03683260f, -0.13694584f, -0.01736901f, 0.08633772f, -0.36144271f, 0.31016985f, 0.32169515f, -0.46075290f, 
    0.04620460f, -0.04657619f, 0.12900585f, 0.10918857f, 0.01296659f, 0.09527352f, -0.43921643f, -0.33165947f, 
    -0.08031105f, 0.18444461f, 0.12804222f, 0.03288937f, -0.37507781f, 0.34467277f, 0.31789747f, -0.12235005f, 
    -0.12555955f, 0.03982722f, -0.29436043f, -0.02678561f, 0.20813355f, -0.74650162f, -0.05268607f, -0.28835174f, 
    0.26709223f, -0.13235742f, -0.14590199f, -0.08347280f, 0.05313353f, 0.26221797f, 0.43816242f, 0.03191307f, 
    0.00419999f, -0.09076342f, 0.11183895f, 0.23349844f, -0.02303512f, -0.27513289f, -0.03220733f, 0.13714653f, 
    -0.07909827f, 0.08912620f, 0.14659995f, 0.28845644f, 0.07156686f, -0.04373540f, 0.15433095f, -0.25543174f, 
    -0.21550727f, -1.11194623f, -0.26170927f, 0.31202543f, -0.27454185f, 0.12558587f, -0.14347762f, -0.25237036f, 
    -0.10665637f, 0.04716794f, 0.11475386f, 0.20352513f, -0.27173984f, -0.33139044f, -0.06299999f, -0.04024609f, 
    -0.19440432f, -0.07172458f, -0.39743325f, 0.07559431f, -0.09719776f, 0.00834185f, -0.14338227f, 0.03704781f, 
    -0.06747773f, 0.15915619f, -0.43615803f, 0.23903154f, 0.09555302f, 0.53532261f, 0.11968058f, -0.26674500f, 
    -0.11173975f, -0.29689592f, 0.13073382f, 0.09977448f, -0.11160463f, 0.59694451f, 0.12452085f, 0.05714969f, 
    0.22500598f, -0.00340003f, -0.12669316f, -0.01779972f, -0.10854337f, -0.45791754f, -0.08678678f, 0.09877054f, 
    -0.04134278f, 0.38158408f, 0.08710825f, -0.16893183f, -0.04733375f, 0.17804274f, 0.06671959f, -0.18629439f, 
    0.40247342f, -0.05610548f, -0.15514410f, 0.07814204f, -0.14760469f, -0.22215222f, -0.43891555f, 0.08665251f, 
    -0.34979504f, 0.28649858f, 0.51790231f, -0.00763395f, 0.09230281f, -0.17103562f, 0.18936729f, 0.11019194f, 
    0.08495807f, 0.06141525f, -0.08129903f, -0.09756485f, 0.19090667f, 0.14491674f, -0.58469117f, 0.19614635f, 
    -0.72408581f, 0.00452621f, 0.06078090f, 0.09953953f, -0.01746866f, 0.07916711f, 0.26325044f, 0.33979544f, 
    0.19287132f, 0.21265614f, -0.54308230f, 0.21541846f, -0.60937250f, -0.80713362f, 0.27445748f, -0.47295567f, 
    0.11557931f, 0.30725637f, -0.08332618f, -0.11304314f, -0.12495429f, -0.88771278f, 0.10902338f, -0.05277585f, 
    0.01761336f, 0.24846816f, -0.02174167f, 0.08497842f, 0.38315836f, -0.20735732f, -0.56586671f, 0.05260253f, 
    -0.07986186f, 0.01347937f, -0.54666865f, 0.03699911f, 0.05727280f, 0.08054803f, -0.03700310f, -0.03029618f, 
    -0.19307569f, 0.04835396f, -0.18932246f, -0.02885294f, 0.04197763f, -0.79267478f, -0.11963040f, -0.22945215f, 
    -0.25076801f, -0.77674961f, -0.01266736f, -0.34348604f, 0.15691984f, 0.10182957f, 0.03399063f, 0.16322175f, 
    0.09396343f, -0.10310446f, 0.08743810f, 0.26955602f, -0.13142912f, 0.11703309f, 0.31893378f, 0.23296046f, 
    0.23560306f, 0.06350788f, -0.57934171f, 0.04719976f, -0.07766620f, 0.02993382f, 0.10220514f, -0.02017394f, 
    -0.72620428f, 0.02427146f, 0.32172796f, -0.47702339f, 0.24266577f, 0.42146400f, 0.21238765f, 0.03345706f, 
    -0.07595570f, 0.02496708f, -0.59241676f, -0.12673777f, 0.20120086f, -0.01303437f, 0.00362933f, -0.34704521f, 
    0.25103438f, -0.26458865f, -0.30811483f, -0.29525086f, -0.03392475f, 0.17232689f, -0.03164362f, 0.04535787f, 
    0.07677904f, 0.26481986f, 0.22483692f, 0.14236319f, -0.11676551f, -0.41474426f, 0.12048294f, -0.17313793f, 
    -0.08179036f, 0.02147445f, 0.20208658f, 0.13773409f, -0.09310354f, 0.26514599f, 0.11172380f, -0.45321664f, 
    0.03971566f, 0.45780522f, 0.11770760f, -0.15324834f, -0.15960597f, 0.00336765f, -0.36833411f, -0.30478561f, 
    0.01099253f, -0.01562069f, -0.04962310f, -0.19710338f, -0.00265379f, 0.16615435f, -0.31550905f, -0.35347036f, 
    0.02338302f, -0.09559423f, 0.20539601f, -0.01350098f, 0.05644638f, -0.02962388f, -0.42181641f, 0.03428611f, 
    -0.19639824f, -0.32663974f, -0.38213977f, 0.06763205f, -0.11624920f, -0.22713043f, 0.14492796f, 0.42744860f, 
    -0.09517683f, -0.37939644f, -0.03178568f, -0.02126508f, 0.13468908f, -0.00941735f, 0.12326759f, -0.03896380f, 
    -0.27148852f, -0.31924212f, 0.27788350f, 0.35463402f, -0.57492131f, 0.08432151f, 0.29972395f, 0.05323735f, 
    -0.04903774f, -0.09877206f, 0.51909333f, -0.36485794f, 0.08838419f, 0.15259904f, 0.06579185f, 0.08993964f, 
    0.26487878f, -0.01606025f, -0.35732847f, -0.15026513f, -0.05144491f, 0.09784220f, -0.15995516f, 0.19851595f, 
    -0.20992318f, -0.15619528f, -0.74447334f, 0.21403746f, -0.46788704f, -0.21978125f, -0.03985219f, -0.50315958f, 
    -0.00089208f, -0.07774600f, -0.17358993f, -0.16641881f, 0.27607229f, -0.48417553f, -0.13898835f, 0.27279410f, 
    -0.34276187f, 0.09648092f, -0.02487450f, -0.00313342f, 0.07073883f, 0.04986950f, -0.02573209f, -0.51840156f, 
    0.15624097f, 0.17941558f, 0.15699767f, -0.07872786f, -0.20154878f, 0.00793631f, 0.24159214f, -0.18607058f, 
    0.01675870f, 0.24210168f, 0.07324473f, -0.02626939f, 0.32217854f, 0.72532731f, 0.08932461f, -0.03715342f, 
    0.12668431f, -0.17497490f, 0.40450001f, 0.26604533f, 0.17363988f, -0.19740395f, 0.20676106f, -0.04646026f, 
    0.01345906f, -0.34154969f, -0.01017509f, -0.07027517f, 0.00949072f, -0.36664206f, 0.10282393f, -0.22162646f, 
    -0.32666019f, -0.06859277f, -0.47962004f, 0.27355462f, -0.05831783f, -0.11997605f, -0.01597192f, 0.21574149f, 
    -0.52888525f, 0.20890662f, 0.02997258f, -0.00404838f, -0.15703806f, -0.17202912f, -0.11617199f, -0.05474063f, 
    -0.10067762f, 0.00277531f, -0.10814269f, 0.21140760f, 0.12915173f, 0.05511481f, -0.08357520f, 0.03060992f, 
    0.32795200f, -0.10982549f, 0.01936231f, -0.04242089f, 0.01046427f, 0.10210533f, -0.38411269f, 0.21812250f, 
    0.11804674f, -0.00974377f, -0.22945064f, 0.00971709f, -0.02415136f, -0.02040793f, -0.65354317f, 0.06923131f, 
    -0.11549535f, -0.54487520f, 0.11906943f, -0.08545627f, 0.01653154f, -0.48247424f, 0.10744646f, -0.06675723f, 
    -0.24458201f, -0.04574640f, -0.71340954f, 0.08075877f, -0.09338203f, -0.14208874f, 0.13081020f, 0.06486295f, 
    -0.04342036f, -0.16216211f, 0.32059044f, 0.17416263f, -0.05538918f, 0.35873085f, 0.07670629f, 0.19294350f, 
    -0.55213267f, 0.06032102f, 0.16405371f, -0.63026226f, -0.02041825f, -0.28187975f, 0.19106640f, 0.32332656f, 
    0.00213855f, -0.15873607f, 0.06105144f, 0.50787872f, 0.21170254f, 0.06339564f, 0.13086978f, 0.19022134f, 
    0.03758730f, 0.02781200f, 0.00498762f, -0.55150479f, -0.77149338f, -0.65429664f, 0.05203884f, -0.36261833f, 
    0.00065984f, 0.09695187f, 0.16842131f, 0.02452259f, 0.09081901f, -0.06485415f, 0.53598207f, -0.33413878f, 
    0.18036352f, -0.25427473f, 0.08213573f, -0.34673873f, -0.33283177f, -0.07538509f, -0.34446558f, 0.14288007f, 
    0.09584174f, -0.39423737f, 0.29448447f, 0.00974722f, 0.30968228f, -0.57961673f, -0.00146674f, 0.33926576f, 
    -0.47414187f, -0.08288516f, 0.06171817f, 0.22780709f, 0.20594831f, -0.14823493f, -0.58021736f, -0.03373814f, 
    0.01062680f, -0.28497612f, -0.15841427f, 0.00813217f, -0.05231082f, 0.09145692f, -0.07307562f, -0.05765557f, 
    -0.40771848f, -0.04918479f, 0.18604080f, -0.26583627f, 0.08563559f, 0.07951496f, -0.00836146f, -0.12249321f, 
    -0.36278003f, 0.41067246f, -0.06990691f, -0.39921525f, 0.08431555f, -0.33554193f, 0.38990605f, 0.14884184f, 
    0.05076852f, -0.08091307f, 0.01691469f, 0.25378942f, -0.06245351f, -0.24689193f, -0.07944737f, 0.03635994f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09354658f, -0.04813990f, -0.07523048f, 0.13956800f, 0.05166916f, 0.15542822f, 0.02423931f, -0.18146980f, 
    -0.08730348f, -0.10170557f, 0.08435220f, 0.08256098f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
