#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53825176f, -0.84078288f, -0.32303646f, 0.68456131f, 0.32438156f, 0.71855915f, 0.17828384f, -0.02485156f, 
    0.02430144f, -0.62692654f, -0.40560436f, -0.66230786f, 0.28891534f, 0.51945525f, 0.32192397f, 0.09870080f, 
    0.59042525f, 0.20255482f, 0.71418554f, -0.93389386f, 0.19136234f, 0.12188936f, -0.26492178f, 0.11481803f, 
    -0.14864197f, 0.07973785f, 0.08582644f, 0.43109536f, -0.51144564f, 0.29851663f, -0.01039168f, 0.49995327f, 
    -0.09755038f, 0.02169562f, 0.18480097f, 0.31145713f, -1.04427445f, 0.19658858f, -0.34350565f, -0.11611070f, 
    0.07965881f, -0.24836312f, 0.16000277f, 0.06148852f, 0.03035213f, 0.22227956f, -0.67243052f, 0.43995512f, 
    0.07959558f, -0.07819574f, -0.46075067f, -0.27123594f, -0.33521456f, -0.31645924f, 0.48711017f, 0.33747494f, 
    -0.16482940f, -0.31357026f, -0.62943619f, -0.25799492f, 0.19984826f, 0.57833177f, -0.32274359f, 0.37091747f, 
    -0.32650524f, -0.62667453f, -0.45196033f, -0.04096538f, -0.32188872f, 0.22806922f, 0.53520226f, 0.68369931f, 
    0.45588401f, 0.45230258f, 0.24635293f, -0.56137168f, -0.26572913f, -0.02123945f, -0.21418847f, 0.43662322f, 
    0.61737573f, -0.75185871f, -0.58953047f, -0.02024662f, 0.05010463f, -0.34667027f, -0.25736538f, -0.37391350f, 
    0.43802106f, 0.17860462f, 0.21398363f, -0.26918989f, 0.77625304f, -0.07224546f, -0.23099545f, -0.53024065f, 
    0.30190372f, 0.20392805f, 0.26927313f, 0.14239606f, 0.38811782f, 0.22527085f, -0.80048448f, 0.40719238f, 
    0.31557792f, 0.00623656f, -0.22967444f, -0.18957061f, 0.75600499f, 0.02486372f, 0.00650194f, 0.20571865f, 
    0.06942303f, 0.40497726f, 0.25947860f, -0.24867369f, 0.13756102f, 0.76622391f, 0.82142550f, -0.21547510f, 
    -0.22221637f, 0.16406998f, -0.36046144f, -0.18502159f, 0.21651374f, -0.02451823f, -0.32193434f, -0.05449462f, 
    -0.14274612f, -0.54037607f, -0.36441055f, -0.90079117f, 0.35661072f, 0.09176529f, 0.25368002f, -0.49321276f, 
    -0.12528358f, -0.35677874f, 0.80810690f, -0.30086124f, -0.65694439f, 0.19825265f, -0.23727833f, 0.24746598f, 
    0.80890107f, -1.09371614f, -0.20713741f, 0.39580289f, -0.46241686f, -0.28408253f, 0.28936845f, -0.10208659f, 
    -0.40054524f, -0.05470121f, 0.04212668f, 0.45229840f, 0.47924706f, 0.33097723f, 0.55937386f, -0.45397314f, 
    -0.35586420f, 0.31730869f, -0.78340340f, -0.45962545f, 0.47819561f, 0.57151848f, -0.33063841f, 0.43644217f, 
    -0.23533426f, -0.10826027f, -0.64276457f, -0.05643048f, -0.00637356f, 0.44179514f, 0.18129204f, -0.06694386f, 
    0.15143985f, 0.47046795f, -0.56275332f, 0.28039765f, -0.48523480f, 1.02844977f, -0.60395896f, 0.58713174f, 
    -0.09398832f, -0.30788258f, -0.09663886f, 0.30774856f, -0.07640243f, -0.52014172f, -0.37665951f, -0.09020138f, 
    -0.49086344f, -0.22186157f, -0.38359720f, -0.33823338f, 0.47470829f, -0.26180562f, -0.65074623f, 0.74366957f, 
    -0.20823953f, -0.24601498f, -0.15094660f, -0.18468148f, 0.16892141f, 0.25861877f, 0.31885138f, -0.11865124f, 
    0.33637992f, -0.77008545f, -0.24043082f, 0.06606244f, 0.17183666f, 0.35705894f, -0.17230423f, 0.15772970f, 
    -0.03003491f, 0.41347024f, 0.15293626f, -0.83646220f, -0.47639447f, -0.64880216f, -0.12990122f, -0.23698507f, 
    -0.17168003f, -0.06300551f, -0.24391644f, 0.05585126f, 0.11355936f, -0.65918911f, -0.37346429f, 0.17869832f, 
    0.61255276f, 0.48535690f, 0.05666821f, -0.59289068f, -0.62234694f, 0.33250368f, 0.74177241f, 0.36687133f, 
    0.10169024f, -0.32756254f, -0.53707075f, -0.08255377f, -0.42007053f, -0.17898944f, -0.26125330f, -0.64829594f, 
    0.78423417f, 0.36087430f, 0.01153230f, 0.29772204f, 0.24967203f, -0.39315853f, -0.40744209f, -0.51210195f, 
    1.07860065f, -0.53302598f, -0.11980113f, -0.24722910f, -0.33842561f, -0.40989873f, -0.36413109f, -0.93642646f, 
    -0.13280004f, 0.82000828f, 0.17903720f, -0.39071280f, -0.05295539f, 0.27650583f, 0.60247397f, 0.45604134f, 
    -0.01451414f, 0.48598400f, -0.30458176f, 0.30121085f, -0.31854552f, -0.29245478f, -0.35372072f, -0.91659600f, 
    -0.27291387f, -0.00553099f, 0.10519107f, -0.34650120f, -0.59217423f, -0.07339814f, -0.59294176f, -0.33600190f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.11133642f, 0.21174368f, -0.06142010f, 0.46363202f, 0.29555362f, 0.21470135f, 0.09409714f, 0.22533390f, 
    0.17932403f, -0.42989805f, 0.04543468f, 0.11581503f, 0.34477836f, 0.38920954f, 0.20221968f, 0.56542689f, 
    -0.06529456f, -0.17612946f, -0.21155256f, 0.29372424f, 0.16973177f, -0.35201460f, -0.04192844f, 0.26324937f, 
    0.23116396f, -0.00161414f, 0.06577448f, 0.02907146f, -0.23607479f, -0.23352142f, -0.16498516f, -0.00045524f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00218337f, -0.23263370f, -0.23167740f, 0.00925566f, 0.13841090f, 0.06226714f, -0.14664692f, -0.02068789f, 
    -0.00522444f, 0.11775474f, -0.03960007f, -0.16413645f, -0.11709125f, 0.06831903f, -0.03773900f, -0.00846691f, 
    0.09011783f, 0.16995783f, 0.30427432f, -0.09395554f, -0.12676126f, 0.28530702f, 0.13651362f, 0.25428480f, 
    0.07396999f, -0.25512573f, 0.04710151f, 0.03739595f, -0.09803430f, -0.14649270f, 0.04412036f, -0.01775366f, 
    -0.01104867f, 0.05200787f, 0.08470548f, 0.27379957f, 0.11460658f, 0.09764480f, 0.07212061f, 0.03394416f, 
    0.01849177f, 0.06135191f, 0.02036838f, -0.04797920f, -0.05642578f, 0.24024287f, -0.00470340f, -0.06347787f, 
    0.09457577f, 0.05400218f, -0.03761364f, -0.03740906f, 0.01937598f, -0.39832649f, -0.08452151f, -0.02749152f, 
    -0.09612250f, 0.15951627f, -0.06844693f, 0.15093186f, 0.02191146f, 0.10350812f, 0.12337755f, 0.13213708f, 
    -0.11448251f, 0.02143512f, -0.08553273f, 0.12847938f, 0.01151781f, 0.09440362f, 0.11424894f, 0.05801307f, 
    -0.08391548f, -0.35685018f, -0.05938384f, -0.14605606f, 0.02750453f, -0.04582694f, -0.13476899f, 0.01420376f, 
    0.09971927f, -0.10389089f, 0.00022783f, 0.13600305f, -0.01184024f, -0.14313899f, -0.11038597f, 0.07532454f, 
    0.00041850f, 0.04660660f, -0.11580069f, -0.07912008f, -0.13086677f, -0.01198886f, 0.04383835f, -0.00726260f, 
    -0.03652551f, 0.14141077f, -0.00723416f, -0.08928920f, -0.23732987f, 0.06028657f, -0.01752525f, 0.05290876f, 
    -0.01580874f, -0.14663623f, -0.13895637f, -0.09038522f, -0.27480021f, -0.13754837f, 0.03499718f, -0.07138392f, 
    0.05660110f, -0.02613861f, 0.00519766f, -0.03511837f, -0.05238923f, -0.13668984f, -0.24098663f, -0.02128996f, 
    -0.01879751f, 0.07860806f, -0.00287454f, 0.07117140f, -0.13084230f, 0.11723132f, 0.00146458f, 0.02776462f, 
    0.22105969f, -0.03173972f, 0.05563249f, 0.06493501f, 0.01957083f, 0.11277325f, 0.01510501f, 0.02329369f, 
    0.01950687f, -0.01337812f, 0.13168867f, -0.07427097f, 0.12073878f, 0.00302002f, -0.08843546f, 0.02328712f, 
    0.03193720f, 0.04296804f, -0.15802389f, 0.03958608f, -0.01707359f, 0.26207122f, -0.16945791f, -0.11676271f, 
    0.08550227f, -0.29676738f, -0.09262038f, -0.04226883f, 0.21870521f, 0.09087957f, 0.04666456f, -0.30884126f, 
    -0.08048845f, -0.22242284f, -0.19757217f, 0.00530489f, -0.20145708f, 0.12848288f, 0.06141188f, -0.00856488f, 
    -0.18992865f, -0.23929185f, -0.35225481f, -0.03486951f, -0.03652437f, 0.09179092f, 0.07397990f, -0.10904900f, 
    0.13926467f, -0.15771265f, 0.02551460f, 0.14514369f, -0.25106764f, 0.13275287f, 0.08514498f, 0.07833236f, 
    0.08712266f, 0.22847638f, 0.13731204f, 0.18715724f, 0.22054775f, -0.03427550f, -0.04512659f, 0.12117265f, 
    -0.04343846f, -0.02116683f, 0.03690855f, 0.05583459f, 0.05924154f, -0.05282534f, 0.04216746f, 0.05534452f, 
    0.05960951f, -0.00975481f, 0.05444583f, 0.08981179f, 0.12330200f, 0.13893370f, 0.05656077f, 0.25031561f, 
    0.05832579f, 0.08352242f, -0.05699761f, 0.06855588f, -0.01041603f, 0.04303739f, 0.09481927f, 0.00256335f, 
    0.06344030f, -0.05013514f, 0.15487935f, 0.05233793f, 0.15485625f, 0.05903524f, 0.06454343f, 0.07462437f, 
    -0.31081671f, 0.01469554f, 0.01842919f, 0.12562586f, -0.10996312f, 0.07451240f, -0.12122666f, 0.20071952f, 
    0.06020757f, 0.14800607f, 0.05808756f, -0.26128966f, -0.11238778f, -0.11286693f, -0.01899432f, 0.14786935f, 
    -0.08314286f, -0.10420604f, -0.14952196f, 0.04932636f, -0.09881161f, -0.07551531f, -0.30814710f, -0.05643915f, 
    -0.10110704f, 0.05380968f, 0.10369483f, 0.07816520f, 0.11032244f, 0.09437714f, -0.12749764f, -0.03577521f, 
    -0.00151610f, -0.00573725f, -0.06779324f, 0.07694426f, -0.02630938f, 0.18851228f, -0.06057400f, 0.01822896f, 
    -0.02129951f, -0.11238005f, -0.06022379f, -0.00820050f, 0.08161712f, -0.04457546f, -0.32898521f, -0.24856047f, 
    0.03146695f, -0.03595024f, -0.05120444f, -0.00668244f, -0.07501109f, -0.25375780f, -0.31991503f, -0.13059142f, 
    0.30116746f, 0.06199776f, 0.06017968f, -0.09232466f, 0.02012053f, 0.02368545f, -0.04445867f, -0.10094193f, 
    -0.04556735f, -0.02811184f, 0.00567464f, -0.04347461f, 0.00196580f, -0.01219761f, 0.01480902f, -0.04229598f, 
    0.02062540f, -0.00083704f, 0.01568331f, -0.03379086f, -0.00020717f, -0.04186117f, 0.03034746f, -0.01788819f, 
    -0.05705351f, -0.05365685f, 0.01251691f, 0.02986874f, 0.02549841f, -0.04476859f, 0.02614673f, -0.03375482f, 
    -0.03115518f, 0.04370160f, -0.03605985f, -0.04519248f, 0.00123354f, -0.02707080f, -0.06490786f, -0.02849153f, 
    -0.02498626f, 0.03058117f, 0.02799709f, 0.04306380f, 0.03201579f, -0.03884588f, 0.00164495f, 0.00787272f, 
    0.00751897f, -0.03822348f, 0.02976356f, 0.01825952f, -0.06623945f, 0.03578794f, -0.03664483f, -0.01741553f, 
    -0.00654693f, -0.02276354f, -0.02989465f, -0.04239731f, -0.02470725f, -0.00797180f, -0.03016455f, 0.04114249f, 
    -0.04581271f, 0.04819753f, 0.04413001f, -0.00006767f, -0.06466895f, -0.02184510f, -0.05175459f, -0.03058654f, 
    -0.05705277f, -0.02921673f, 0.02477536f, -0.03848729f, -0.06241830f, -0.00413166f, -0.02334633f, -0.04001195f, 
    0.03380167f, 0.03891227f, -0.01241807f, 0.04289182f, 0.04582873f, -0.00435045f, -0.00145552f, 0.03676350f, 
    -0.01853220f, -0.01264595f, 0.00390144f, -0.02357715f, -0.00638462f, 0.01020996f, 0.00814933f, -0.00503435f, 
    0.05265684f, -0.02471955f, 0.04149389f, 0.03364784f, 0.01591871f, -0.06472764f, 0.01181285f, -0.03666813f, 
    -0.03626091f, -0.06877715f, -0.06488867f, -0.03714089f, -0.06329320f, -0.03986107f, -0.03642231f, 0.00614760f, 
    -0.05399683f, -0.05161764f, -0.03145958f, -0.04729648f, 0.01326028f, -0.00606570f, -0.04324086f, 0.02231215f, 
    0.02839383f, 0.02933052f, 0.04656573f, -0.03365552f, -0.02412869f, -0.05756194f, -0.03240976f, 0.02663052f, 
    -0.04562100f, 0.00975973f, 0.00169953f, -0.03878310f, -0.05865090f, -0.06696825f, 0.00420580f, 0.01676758f, 
    -0.01486257f, 0.04644306f, -0.03215873f, -0.00160436f, -0.04042703f, -0.05946635f, 0.04452045f, 0.03243177f, 
    -0.02978064f, 0.04635031f, 0.04436506f, 0.00328921f, 0.00671695f, -0.02024493f, -0.06550059f, -0.05365624f, 
    -0.06117618f, 0.01298797f, -0.02825668f, -0.03367455f, -0.01260913f, -0.01990248f, -0.06025288f, 0.01482627f, 
    0.03207542f, -0.05096516f, -0.03390168f, 0.00034132f, 0.03310208f, 0.00475253f, -0.00499732f, -0.02511235f, 
    -0.03590962f, -0.04025337f, 0.01452185f, -0.01806154f, -0.02136713f, -0.03639701f, 0.04937435f, 0.01190659f, 
    -0.05712195f, -0.05398017f, -0.05845537f, 0.02314144f, -0.04645406f, 0.00185632f, -0.05161393f, -0.02721665f, 
    -0.00493411f, -0.05113601f, 0.04870716f, 0.00392827f, 0.01231947f, -0.03040585f, 0.00553754f, 0.04721978f, 
    0.04274125f, 0.04459816f, -0.03805042f, 0.03906443f, -0.02078843f, -0.02738983f, 0.00724582f, 0.02292556f, 
    -0.02566609f, -0.00445392f, -0.04968854f, -0.00619107f, -0.00118889f, -0.03796443f, -0.03039300f, -0.05190048f, 
    -0.02501434f, -0.04527043f, -0.02823409f, -0.03844538f, 0.00343461f, -0.02939696f, -0.03732130f, 0.03082626f, 
    -0.00591902f, -0.02161908f, -0.01505660f, 0.03482258f, -0.03668462f, -0.06051439f, -0.03794014f, -0.03960962f, 
    -0.04090270f, 0.03679119f, 0.03810012f, 0.00464633f, 0.01136561f, 0.03509685f, -0.04276391f, 0.01801805f, 
    -0.04104533f, 0.04643167f, -0.02575486f, 0.04427042f, -0.00645761f, -0.00055103f, -0.02790537f, 0.02422262f, 
    0.00964271f, 0.03685374f, 0.04051074f, -0.04179595f, -0.03357604f, 0.02250254f, 0.00472275f, -0.03337052f, 
    0.00617752f, 0.00738106f, -0.03270929f, -0.05097067f, -0.04908404f, -0.04007999f, 0.03987304f, -0.04390465f, 
    0.01663743f, 0.03933998f, 0.03940917f, 0.02248287f, -0.01816640f, -0.00549781f, 0.04996092f, -0.05424924f, 
    -0.01885184f, 0.01033911f, -0.03616906f, -0.03184589f, 0.00290391f, 0.01633821f, 0.00348327f, 0.02715730f, 
    -0.00341465f, 0.04322309f, -0.01103678f, 0.02164203f, 0.04067812f, -0.06626272f, -0.02557424f, -0.05344449f, 
    0.00961432f, -0.00141415f, -0.04209843f, 0.00645242f, 0.03118563f, -0.01440167f, 0.01806300f, -0.03718716f, 
    0.04634732f, -0.05367120f, 0.00152242f, -0.01179361f, -0.03435336f, -0.02603665f, -0.03048901f, 0.00593823f, 
    0.01360653f, 0.16559401f, 0.11825033f, 0.22540081f, 0.01002394f, 0.01788116f, -0.05240783f, -0.04165723f, 
    -0.01706593f, 0.02921194f, 0.25833377f, 0.17830653f, 0.17593524f, 0.01868975f, -0.17990232f, -0.06627840f, 
    0.10708696f, 0.07729571f, 0.12897268f, -0.18074058f, -0.09314824f, 0.32655424f, 0.05649200f, 0.25130093f, 
    -0.21702074f, -0.07710892f, 0.09579240f, 0.02828840f, 0.11427545f, 0.02239965f, 0.03705986f, 0.10075305f, 
    0.13004616f, -0.02239461f, 0.04826348f, 0.08937745f, -0.24656068f, -0.02394288f, 0.10068102f, 0.10290559f, 
    0.07511301f, -0.06211127f, -0.08644240f, 0.04832860f, 0.05648787f, 0.11732218f, -0.23953015f, 0.06659646f, 
    0.03603381f, 0.05579254f, 0.12713972f, 0.03656190f, -0.00311611f, -0.24714902f, -0.04331433f, 0.00212032f, 
    -0.15326850f, 0.07851805f, -0.02345374f, 0.10917341f, -0.06879362f, 0.14139603f, 0.21300571f, 0.02848319f, 
    0.11620254f, -0.18291138f, -0.12549154f, -0.08062229f, -0.02866959f, 0.07295615f, -0.01581499f, 0.05003323f, 
    0.06461886f, -0.05308950f, -0.19308119f, -0.04035579f, 0.07077558f, 0.00516746f, -0.10753475f, 0.02148057f, 
    0.15435015f, -0.17496364f, 0.14704520f, 0.00507422f, -0.02718291f, 0.06067948f, 0.12894206f, 0.02037275f, 
    -0.05942303f, 0.04519789f, 0.06594180f, -0.08927869f, -0.11760304f, -0.06852201f, 0.09431271f, -0.00394439f, 
    -0.07796540f, 0.19605327f, 0.02997128f, -0.09253079f, -0.02221573f, -0.07567836f, -0.02460039f, 0.16456226f, 
    0.00061211f, -0.04314731f, -0.23154454f, -0.18457998f, -0.09561516f, 0.09904724f, 0.08815955f, -0.00568384f, 
    0.06686191f, 0.06580311f, 0.00023128f, -0.21613137f, -0.06118068f, 0.08081394f, -0.05547361f, 0.01147337f, 
    0.00618868f, 0.10504110f, 0.06380113f, -0.06456804f, 0.30630854f, -0.14269228f, -0.22196506f, 0.15124093f, 
    0.06015931f, -0.04211152f, 0.07043349f, -0.00665718f, 0.12455361f, 0.09272283f, 0.00673550f, 0.01996952f, 
    0.16123070f, -0.03222317f, 0.08724719f, 0.01064921f, 0.06659783f, 0.06020506f, -0.00493824f, -0.14523675f, 
    0.22625688f, -0.50960463f, 0.16449124f, 0.08132410f, -0.10309517f, 0.01869866f, -0.11653823f, 0.00229766f, 
    0.01931987f, -0.22097361f, -0.01458457f, -0.02399350f, 0.05216287f, -0.14215465f, 0.15731302f, 0.10953688f, 
    0.07774770f, -0.11937015f, -0.24069326f, -0.08007018f, -0.19832596f, -0.00402151f, 0.13658108f, -0.04147709f, 
    -0.07994053f, -0.15282612f, 0.05558887f, -0.07150498f, -0.01794185f, 0.13646641f, -0.14931117f, 0.05260449f, 
    0.15300682f, -0.01374674f, -0.07074824f, 0.04545153f, -0.19730303f, 0.01556410f, 0.06814061f, 0.25231576f, 
    0.08379576f, 0.06484678f, -0.09446964f, 0.12567990f, -0.07651262f, -0.19861890f, 0.14543642f, -0.14045268f, 
    0.06899272f, 0.07823392f, 0.07154388f, 0.03897462f, 0.05249434f, -0.05711131f, -0.13531207f, -0.03837235f, 
    -0.19434036f, 0.00063469f, 0.15285814f, -0.16335763f, 0.02597131f, 0.15389033f, -0.01891343f, 0.02363912f, 
    0.07522079f, 0.10980659f, 0.16908957f, -0.02729959f, -0.04623894f, -0.04160966f, -0.06590444f, -0.12155950f, 
    0.02715015f, -0.24067949f, -0.19566685f, 0.16807549f, 0.06187872f, 0.04406926f, 0.12776469f, 0.25203007f, 
    -0.01431470f, -0.06130531f, 0.17051327f, -0.11412822f, -0.19856830f, 0.05511880f, -0.11252268f, 0.12245657f, 
    0.03118457f, 0.11897150f, -0.08634531f, -0.06510383f, -0.01159267f, 0.15641300f, 0.03113738f, -0.06735589f, 
    0.05131902f, -0.06753569f, -0.22564013f, 0.00484417f, 0.07324985f, 0.17436901f, 0.11184130f, -0.17696190f, 
    -0.13647142f, -0.06533041f, 0.03514096f, 0.02604743f, 0.08101465f, -0.28319031f, -0.20693237f, 0.17249906f, 
    0.04561243f, -0.09881821f, -0.04674884f, -0.12114538f, -0.39380056f, -0.11477170f, 0.17159551f, -0.13196485f, 
    0.14791399f, 0.01606727f, 0.07695264f, 0.01877413f, 0.03629499f, -0.10404877f, -0.17082256f, -0.15098794f, 
    0.01623923f, -0.19061385f, -0.01522716f, 0.06967917f, -0.01255260f, -0.15563382f, -0.20845972f, -0.23643437f, 
    -0.23393296f, -0.08682348f, 0.05415584f, 0.10921352f, 0.04014656f, -0.11639923f, 0.01458992f, 0.06606407f, 
    0.01844877f, -0.04480431f, -0.00332577f, 0.00367322f, -0.00597570f, 0.02397363f, 0.01851558f, -0.02346309f, 
    0.04340912f, -0.01075747f, -0.01397044f, -0.05403601f, -0.06343282f, 0.02943367f, -0.02487615f, 0.04543392f, 
    -0.01254252f, -0.03023891f, -0.03037906f, 0.01673008f, -0.00788997f, -0.01833007f, -0.00616075f, -0.01054269f, 
    0.02927115f, 0.00062995f, 0.02548980f, 0.04076847f, -0.02301711f, -0.02518618f, -0.04803912f, -0.01550062f, 
    -0.05473702f, -0.01391277f, 0.03742088f, -0.00768570f, 0.02091017f, 0.01604895f, -0.03833197f, -0.02774274f, 
    -0.05212598f, -0.01853811f, -0.04461548f, -0.00486983f, 0.00355445f, -0.01472672f, -0.03933994f, -0.00586017f, 
    0.02295142f, -0.03338319f, 0.01236110f, 0.02698532f, -0.01414340f, -0.06840493f, -0.04788177f, 0.02517296f, 
    -0.04305916f, -0.02895530f, -0.04040905f, -0.04548894f, -0.01308177f, -0.03696298f, 0.03441110f, 0.02882937f, 
    -0.01884062f, -0.02962675f, -0.05175666f, -0.02265185f, -0.01044133f, -0.06109631f, 0.03838497f, 0.00541350f, 
    0.02274253f, -0.00503351f, 0.04165716f, -0.01337699f, 0.00703371f, -0.01698730f, 0.04055738f, 0.03023448f, 
    -0.00478950f, -0.03197462f, 0.02816499f, -0.01073552f, -0.06971720f, -0.03621666f, -0.05509511f, 0.02056691f, 
    -0.00069657f, -0.06528186f, -0.06041868f, 0.01452647f, -0.02574310f, 0.05113092f, -0.05492897f, 0.04539946f, 
    -0.03797417f, -0.04430062f, -0.02108213f, 0.02857346f, -0.00934677f, -0.00306254f, -0.06779944f, 0.04135083f, 
    0.03582935f, -0.05198241f, -0.05454809f, -0.03332473f, -0.04625321f, -0.01562587f, -0.00536970f, -0.05600487f, 
    0.01287206f, 0.03870173f, -0.05060568f, -0.00959848f, -0.03323120f, 0.00927909f, -0.06048124f, -0.04046382f, 
    -0.01681483f, 0.03058553f, -0.03003472f, -0.06504649f, -0.03178161f, 0.04243227f, 0.01397261f, -0.01964973f, 
    0.04474396f, -0.04362612f, -0.03818810f, 0.01894485f, -0.05719415f, -0.06119971f, -0.01920778f, -0.03958817f, 
    0.04204131f, 0.01791817f, -0.03038264f, -0.05179020f, -0.02968178f, -0.03392339f, -0.01402393f, 0.02458963f, 
    0.01688800f, -0.00647366f, -0.00384389f, -0.04001457f, 0.02028916f, 0.00621748f, -0.06785633f, -0.00945079f, 
    -0.04380644f, -0.03859450f, 0.05132684f, 0.02175357f, 0.04104959f, -0.06271815f, -0.01300377f, 0.01500943f, 
    0.01053999f, 0.04140394f, -0.06582779f, -0.01190301f, -0.00483048f, 0.04757804f, 0.01481184f, 0.02885520f, 
    0.04198995f, 0.01342644f, 0.00258734f, 0.06320168f, -0.02226022f, -0.01554611f, -0.06672052f, -0.03532234f, 
    -0.01452915f, 0.00896120f, 0.01198118f, -0.01969428f, 0.00202534f, -0.01485031f, -0.00567911f, -0.04005621f, 
    0.03216265f, 0.00011753f, -0.00030517f, 0.00227246f, 0.01848567f, 0.02826600f, 0.01965460f, 0.01867940f, 
    -0.04957082f, 0.03472685f, 0.03727040f, 0.04113771f, -0.06639358f, -0.04353620f, -0.02313231f, 0.02494138f, 
    0.04378462f, 0.04330735f, -0.00062729f, 0.02662226f, -0.01835411f, -0.05557944f, -0.00640784f, -0.01773034f, 
    0.03365273f, -0.05712172f, -0.00078106f, -0.01625427f, 0.04767749f, 0.04362603f, 0.02722207f, -0.06091944f, 
    -0.06544737f, -0.04306124f, -0.02814033f, -0.01137622f, -0.02283119f, 0.02260756f, 0.03115165f, 0.04685545f, 
    -0.01765119f, -0.00823743f, -0.04608443f, -0.01888970f, -0.06366934f, -0.06350436f, -0.04084716f, -0.01561748f, 
    -0.04636554f, 0.04673244f, -0.01732124f, -0.03995913f, -0.03609168f, 0.00107885f, -0.03343029f, -0.04173701f, 
    0.00568839f, 0.00526841f, -0.01888668f, -0.06248222f, 0.01067134f, 0.04273621f, 0.02404669f, -0.00923628f, 
    -0.00955765f, -0.00624957f, -0.06648423f, -0.00145982f, 0.03814130f, 0.03428495f, -0.00806368f, -0.01878654f, 
    -0.02354226f, -0.03825272f, -0.06236828f, 0.03068942f, -0.06844500f, 0.00481441f, 0.04730745f, -0.06553666f, 
    -0.00387616f, 0.04741467f, -0.04177837f, -0.00728888f, -0.02400247f, -0.04016980f, 0.00176800f, 0.05216415f, 
    0.05074399f, -0.01961850f, 0.01057244f, 0.00104057f, -0.05147723f, -0.03711991f, 0.01751721f, 0.03599374f, 
    -0.00307524f, -0.02496899f, 0.02190487f, -0.03962694f, -0.04452221f, 0.01694777f, 0.00331123f, 0.00817457f, 
    0.01488894f, -0.00089265f, -0.22425501f, -0.11056714f, -0.03028223f, 0.05938995f, -0.04912916f, -0.02913900f, 
    0.01529532f, -0.02524010f, -0.09100319f, -0.12989859f, -0.08233848f, -0.00335174f, -0.00682842f, 0.06625474f, 
    0.11590092f, 0.10909500f, 0.60402375f, -0.19612302f, -0.24068125f, 0.16227402f, 0.18847555f, 0.00569171f, 
    0.02041916f, 0.19349301f, -0.12709090f, 0.15772943f, 0.06407431f, -0.02453039f, 0.03181691f, 0.03778640f, 
    0.00146712f, 0.09032345f, 0.17151384f, 0.00342318f, 0.09950451f, 0.04775552f, 0.00483534f, -0.04061721f, 
    -0.10678510f, 0.04190800f, 0.00264345f, 0.01799385f, -0.02175719f, 0.13153885f, -0.17219631f, -0.19017573f, 
    0.10436328f, 0.08065459f, -0.04925558f, 0.07544523f, 0.14593624f, -0.06009989f, -0.11644419f, 0.08661606f, 
    -0.20169234f, 0.05478765f, 0.01765353f, -0.06885597f, 0.06440538f, 0.06475924f, 0.06445696f, -0.20634155f, 
    -0.36967155f, -0.18483044f, 0.12855574f, 0.03315759f, -0.08244657f, 0.19503218f, 0.20428708f, 0.11165807f, 
    -0.06790373f, 0.17495595f, 0.14749494f, 0.03547474f, -0.09566983f, -0.09219809f, 0.08464568f, 0.00660920f, 
    0.04373992f, 0.10439357f, -0.18301304f, -0.15571584f, -0.00577411f, -0.21968728f, -0.08085785f, 0.07098887f, 
    -0.01876642f, -0.04780037f, 0.15728706f, 0.00099485f, 0.03351071f, 0.01948575f, -0.16859993f, -0.05956006f, 
    0.05103841f, 0.05705782f, 0.01085675f, -0.25615799f, -0.00672380f, 0.18675685f, 0.02036588f, 0.00774166f, 
    -0.00509747f, 0.02984790f, 0.11007808f, -0.17868000f, 0.11056689f, 0.19165766f, 0.15554594f, -0.07186972f, 
    -0.01597330f, -0.13718085f, -0.02189333f, 0.04018753f, 0.04239057f, -0.20293975f, 0.12916604f, -0.14237048f, 
    -0.06501827f, 0.01620107f, -0.04338752f, 0.24015644f, 0.09104897f, 0.03348862f, 0.05165651f, 0.05858861f, 
    0.01114317f, 0.04245161f, 0.04488995f, 0.05707945f, -0.06403833f, 0.09556420f, 0.04018365f, -0.04295354f, 
    0.10889839f, -0.05936103f, -0.04727225f, 0.00246717f, 0.06352372f, 0.14143020f, 0.15234149f, 0.01363935f, 
    0.29819882f, -0.08555506f, -0.31376699f, 0.19783105f, 0.07052680f, -0.11046728f, 0.03776297f, 0.16041496f, 
    0.25222647f, 0.06321011f, 0.05522795f, 0.19860861f, 0.04334798f, 0.02010818f, -0.21002729f, -0.01934674f, 
    0.01896992f, -0.22410601f, -0.04069388f, 0.08961343f, -0.33332822f, -0.06050734f, -0.17305544f, -0.08614986f, 
    0.08925280f, -0.22663231f, -0.30380237f, 0.18105122f, 0.04691719f, 0.07567027f, -0.03815500f, 0.02286558f, 
    0.00240412f, -0.10306947f, 0.08568992f, 0.02345929f, -0.07126115f, 0.12206279f, -0.07697108f, -0.08029672f, 
    0.14572239f, 0.15262325f, -0.04258755f, 0.13190630f, 0.07675939f, 0.03634712f, -0.08202351f, -0.09258351f, 
    -0.02373324f, -0.11719971f, 0.01244722f, 0.05856800f, 0.03349359f, -0.09283444f, -0.00420429f, -0.23438035f, 
    -0.03167442f, -0.10153594f, 0.00742723f, 0.03569995f, 0.04783515f, 0.11540635f, 0.13228776f, -0.10124213f, 
    -0.15428142f, -0.16753913f, -0.04031094f, 0.16709584f, -0.00627610f, 0.17517629f, 0.12800860f, 0.12736592f, 
    -0.30036619f, 0.04422471f, 0.28039864f, -0.02163283f, -0.01615672f, 0.07182563f, 0.11752267f, 0.14745395f, 
    0.01222268f, -0.12511858f, -0.20560406f, 0.02390128f, 0.14416975f, -0.02308506f, -0.04992707f, 0.12897702f, 
    0.10633818f, 0.05206820f, -0.03985588f, 0.09739345f, -0.08595976f, -0.26678255f, 0.05316669f, -0.01031436f, 
    -0.04909182f, -0.28308427f, -0.19473585f, 0.04310196f, -0.21122882f, -0.27217078f, 0.19983533f, 0.23478936f, 
    -0.15408283f, 0.08740044f, 0.16379289f, 0.12203199f, -0.04766288f, -0.13408893f, -0.24968258f, -0.07818471f, 
    0.09716959f, -0.08570921f, -0.10449027f, -0.28884614f, -0.04039301f, 0.18417110f, 0.27541411f, -0.01897134f, 
    0.02417554f, -0.08288643f, -0.07162743f, 0.02703910f, -0.06057264f, -0.01817738f, -0.08069685f, 0.05330404f, 
    0.03813130f, -0.04364378f, -0.03755246f, -0.09192808f, 0.13394158f, -0.08747006f, -0.06063856f, 0.04480165f, 
    0.04433145f, 0.10158550f, -0.02683942f, -0.12775703f, 0.02977598f, 0.13760349f, -0.05113207f, -0.07139847f, 
    0.08943533f, -0.31835905f, -0.25428063f, -0.03589502f, 0.05964982f, 0.30113795f, -0.01690424f, -0.00682523f, 
    -0.04983239f, 0.08201148f, -0.21450599f, 0.05232665f, -0.04747539f, 0.10314243f, 0.04581929f, -0.14652954f, 
    -0.18571892f, 0.05091073f, 0.21273357f, -0.02634426f, -0.11101793f, 0.03720884f, 0.05258409f, -0.07951353f, 
    0.07760233f, 0.30276775f, -0.16413164f, 0.13026817f, -0.05569432f, -0.08294774f, 0.03194800f, -0.01559306f, 
    -0.11478439f, 0.07759044f, -0.02286940f, -0.11265121f, 0.27886158f, -0.11652562f, -0.22572282f, 0.04369121f, 
    0.12935878f, -0.00652201f, 0.04970479f, -0.04796837f, 0.11585987f, 0.18453649f, -0.05546966f, 0.07873994f, 
    0.13487269f, -0.06011529f, -0.04796128f, 0.09923141f, 0.10249601f, 0.03625462f, 0.02376260f, 0.09168596f, 
    -0.06390249f, 0.09277045f, 0.02893116f, 0.14428185f, -0.02479825f, 0.03151043f, 0.01238972f, -0.10786125f, 
    -0.18380344f, -0.04997708f, -0.03038495f, 0.11198515f, -0.07321321f, 0.13172974f, 0.06497275f, -0.02516934f, 
    -0.00808575f, 0.10992482f, -0.10611208f, -0.01898237f, -0.03313114f, -0.16383623f, -0.21077774f, 0.02231041f, 
    0.00939889f, 0.06173787f, 0.08141924f, -0.11875052f, 0.24252762f, -0.24180500f, 0.01023350f, -0.06282199f, 
    -0.13098659f, -0.20654181f, 0.21009737f, -0.20905744f, -0.28624785f, 0.02703876f, -0.11939795f, -0.20122446f, 
    -0.11917020f, -0.06084929f, -0.28743428f, 0.13728793f, 0.35175502f, 0.18510069f, 0.00738148f, 0.12853299f, 
    0.05183787f, -0.03763543f, 0.08762410f, -0.02938965f, -0.29070312f, 0.22598293f, -0.01762443f, 0.04168878f, 
    0.15336303f, 0.11614027f, 0.13822664f, -0.05505847f, -0.06266673f, -0.17252760f, 0.19971564f, 0.12503392f, 
    -0.09933720f, -0.06149834f, 0.04562754f, 0.04938238f, 0.03999894f, -0.04594966f, 0.01444396f, -0.18137988f, 
    -0.07255991f, 0.16417040f, 0.23219351f, 0.13792278f, -0.04476267f, 0.12564988f, 0.02457899f, 0.08870300f, 
    -0.06511876f, -0.10578524f, 0.07931928f, 0.09132948f, 0.14945921f, -0.00436501f, 0.15151271f, 0.02188433f, 
    0.05256997f, -0.02590865f, -0.01511067f, 0.12787770f, -0.02401908f, 0.00181450f, -0.01081781f, 0.19472848f, 
    0.10308290f, -0.11682905f, -0.06221554f, -0.21330903f, 0.02675061f, 0.08410126f, -0.00922281f, 0.05499596f, 
    0.02833023f, -0.23719850f, 0.17850108f, -0.38685173f, -0.40260184f, -0.08611866f, -0.05484551f, 0.07092264f, 
    0.14192323f, 0.16785249f, 0.13018139f, 0.13141155f, -0.05407059f, -0.30993766f, 0.03732236f, 0.07441827f, 
    0.01983563f, 0.31964180f, 0.10037144f, -0.08291126f, 0.13389109f, -0.17930591f, -0.21611349f, -0.01540320f, 
    0.00624303f, -0.10719965f, 0.15644667f, 0.08558664f, 0.04270969f, -0.04362142f, -0.00240237f, -0.10890882f, 
    -0.03764201f, -0.12484968f, -0.00409311f, -0.04971392f, 0.00594967f, -0.01225800f, 0.22105563f, -0.07581288f, 
    -0.36379752f, -0.04106415f, -0.05155354f, -0.10882355f, -0.13489698f, -0.23050395f, -0.18738969f, 0.07839743f, 
    -0.08086921f, -0.02847511f, 0.03711916f, 0.17267513f, -0.15910517f, -0.11965501f, 0.00662156f, 0.04907959f, 
    0.21629953f, 0.12760927f, 0.13475886f, 0.18159342f, 0.15413678f, -0.09204488f, 0.01081373f, 0.00194022f, 
    0.09400431f, 0.02406969f, -0.14204325f, -0.01187622f, 0.02847236f, -0.02074469f, 0.08347759f, 0.05677260f, 
    0.16622789f, -0.27140325f, -0.06618040f, -0.10617387f, 0.03963792f, 0.05248625f, 0.10113955f, 0.31953087f, 
    -0.05787393f, 0.05157202f, 0.18147776f, 0.16301882f, -0.47106588f, -0.22056329f, 0.23872781f, 0.03754345f, 
    0.07611522f, 0.07709205f, 0.04209629f, -0.06917180f, -0.14159451f, -0.13890700f, -0.15974742f, 0.10027848f, 
    0.04170832f, 0.04276295f, -0.02767813f, 0.12652656f, 0.13422325f, 0.08733954f, -0.20331243f, -0.05287555f, 
    0.12477285f, 0.15406536f, 0.02430980f, -0.22274752f, 0.01591772f, 0.07784811f, -0.68848264f, 0.29077193f, 
    -0.01860597f, -0.12087110f, 0.03405902f, -0.00992101f, -0.03885020f, 0.03382375f, -0.13654119f, 0.18976174f, 
    -0.17155042f, -0.09076696f, -0.06740169f, -0.23813412f, -0.09174293f, -0.06721569f, 0.02307185f, 0.14993343f, 
    -0.02153985f, 0.00098253f, -0.06010462f, 0.01275871f, -0.04154425f, -0.02873931f, 0.04106730f, -0.02170767f, 
    -0.04216875f, -0.05108464f, 0.03169828f, 0.03470594f, -0.03165580f, -0.04674733f, -0.03426346f, -0.05272853f, 
    -0.01137171f, -0.03877324f, -0.00587415f, -0.01968647f, -0.00922918f, -0.03464245f, -0.02100958f, -0.02952369f, 
    0.02978189f, 0.03417013f, -0.06120514f, 0.03473457f, -0.04859681f, -0.00650304f, -0.00697339f, 0.02994874f, 
    0.00130042f, 0.03043727f, 0.05175112f, -0.05381576f, 0.03315973f, -0.03570538f, 0.00116764f, 0.03729170f, 
    0.01790197f, -0.03461161f, 0.00189083f, 0.00184724f, -0.00135063f, 0.00983325f, -0.06039088f, -0.04447656f, 
    0.01264496f, 0.03625462f, -0.00347886f, 0.04972617f, -0.01929288f, -0.01211942f, 0.00222255f, 0.02172418f, 
    -0.03835042f, 0.03889722f, 0.04008913f, 0.04920090f, -0.02722199f, -0.02323976f, -0.05778041f, 0.02203659f, 
    0.00807707f, -0.01621327f, -0.00898980f, 0.04977556f, 0.00079545f, 0.02454531f, 0.01032332f, -0.03252633f, 
    -0.06266049f, -0.03481087f, -0.00460883f, -0.05971368f, -0.05980682f, 0.05337202f, 0.01293370f, 0.00834948f, 
    -0.02204082f, 0.02591589f, 0.02036133f, -0.00253248f, -0.05352192f, 0.05244871f, -0.01855204f, 0.01465401f, 
    -0.01676174f, -0.02289730f, -0.00461074f, 0.05665335f, -0.04867546f, 0.06053193f, -0.00202233f, -0.00980783f, 
    -0.04649733f, -0.00508472f, 0.03849740f, 0.03863555f, 0.00990785f, -0.01752478f, -0.05577135f, 0.03573805f, 
    0.01982771f, 0.05541901f, -0.00704632f, 0.03640163f, -0.03555385f, -0.05119943f, 0.05856675f, -0.01715664f, 
    -0.00239908f, -0.04447458f, -0.04672724f, -0.04055068f, -0.05777780f, 0.00364212f, -0.06116963f, 0.03333599f, 
    -0.00638362f, -0.06019748f, 0.01294811f, 0.05447627f, 0.02069096f, 0.02272014f, 0.01415650f, -0.02683406f, 
    -0.04468748f, -0.03932440f, 0.00587752f, 0.03234510f, 0.00012406f, 0.05293733f, 0.05058152f, 0.02453915f, 
    0.01538442f, -0.04407312f, -0.02237657f, 0.04827843f, -0.04037471f, -0.00455608f, -0.02245793f, 0.02069853f, 
    -0.05156074f, -0.04086570f, 0.04747744f, -0.05533739f, 0.01293493f, 0.04523659f, -0.06462236f, -0.05219072f, 
    0.05297985f, 0.05376453f, 0.05500042f, 0.01858082f, -0.03100559f, -0.05515657f, -0.02585566f, -0.03058060f, 
    0.02359592f, 0.01203681f, -0.05493229f, -0.03714711f, 0.02962400f, -0.04284967f, -0.00938073f, -0.02570025f, 
    -0.04906173f, -0.01031433f, 0.00825519f, -0.00712278f, -0.05540111f, 0.02974395f, 0.01409450f, -0.02685403f, 
    -0.01871919f, -0.05820652f, -0.03629608f, -0.02813401f, 0.00874728f, -0.01861922f, 0.03333867f, -0.04782205f, 
    0.05230327f, -0.00835106f, -0.03039803f, -0.01038133f, 0.02372073f, 0.03518636f, 0.00884197f, 0.02393896f, 
    0.02937346f, -0.04703733f, -0.04274503f, 0.03485701f, 0.03589157f, -0.03947056f, -0.05389756f, -0.06574907f, 
    0.01256488f, -0.04576385f, -0.06138043f, 0.05706441f, 0.00419226f, 0.03766153f, 0.00834718f, -0.01450397f, 
    0.00356602f, -0.01927081f, -0.01493776f, 0.00980953f, -0.04410152f, 0.02891558f, -0.03477075f, -0.00693927f, 
    0.03495158f, 0.00891760f, -0.01299734f, -0.00581662f, 0.05210100f, -0.05944521f, 0.02234692f, -0.03609892f, 
    0.03795869f, -0.06257530f, 0.00076100f, 0.01268653f, -0.04229365f, -0.03674306f, -0.02162549f, -0.02643169f, 
    -0.03472741f, -0.02527265f, -0.01399337f, -0.00175594f, -0.02130827f, 0.02941616f, -0.02021595f, -0.04330275f, 
    -0.05130626f, -0.00030932f, -0.03848720f, -0.01527598f, -0.01702011f, 0.00907651f, 0.04778730f, 0.02865067f, 
    -0.01350501f, -0.04464230f, 0.02082718f, -0.01035749f, -0.05691022f, -0.04987534f, 0.02636964f, -0.01840234f, 
    0.05160354f, -0.04371888f, 0.04250797f, 0.02381038f, 0.04031855f, -0.03452118f, -0.00474810f, -0.03464410f, 
    -0.00009131f, -0.03409249f, -0.03718930f, 0.02339377f, -0.02071915f, -0.03037350f, -0.04425522f, 0.02174157f, 
    -0.04633607f, -0.05887301f, -0.02838735f, -0.03127982f, -0.01907204f, 0.01583774f, 0.02963867f, -0.03170953f, 
    0.04672972f, 0.03284282f, -0.05266801f, 0.01677146f, -0.05570889f, -0.01797774f, -0.02450180f, -0.02281819f, 
    -0.50651085f, 0.18658456f, -0.06314887f, 0.01775959f, 0.01900841f, 0.10106491f, -0.20877911f, 0.05083920f, 
    0.04988274f, -0.34489235f, 0.18713100f, 0.22248578f, 0.04232227f, 0.08652146f, -0.03823018f, -0.03035819f, 
    0.00097233f, -0.03533549f, 0.04499183f, 0.41461420f, -0.09641396f, 0.20277342f, 0.12085108f, 0.25519836f, 
    -0.08386882f, 0.04533691f, -0.02936211f, 0.07365967f, 0.03512754f, 0.02493672f, 0.10861234f, 0.01055903f, 
    0.03695894f, 0.02401314f, -0.02378971f, -0.10102150f, -0.50521207f, -0.15843746f, 0.15181798f, -0.01039989f, 
    0.13703276f, 0.05764489f, 0.04472985f, 0.09292135f, -0.07272740f, -0.04361390f, 0.00150754f, -0.02499403f, 
    0.08161931f, 0.13889572f, 0.13886002f, 0.03103042f, -0.01765476f, 0.09927494f, 0.43258387f, -0.14667028f, 
    -0.31775638f, 0.08722099f, -0.01939673f, 0.06381617f, 0.05364101f, -0.01552386f, 0.12557326f, -0.05306494f, 
    0.12533039f, -0.08078326f, -0.02849730f, 0.04308756f, -0.22795910f, -0.01522777f, -0.06622961f, -0.24623346f, 
    0.49875677f, 0.07064227f, -0.06455075f, 0.01721067f, -0.04466055f, 0.13682634f, 0.02226804f, 0.07244044f, 
    -0.09489758f, 0.21541809f, -0.63339442f, -0.13430041f, 0.12423082f, -0.07035743f, 0.01215446f, -0.16634305f, 
    0.02682557f, -0.08337271f, 0.32892969f, -0.03037831f, -0.11968683f, -0.09132022f, -0.14962758f, -0.02227095f, 
    0.03970774f, -0.07282720f, -0.15755728f, 0.25839126f, -0.10650850f, -0.16656366f, 0.03053313f, -0.04511363f, 
    0.05272604f, -0.03619014f, 0.10860833f, 0.09394103f, 0.03067448f, 0.12237916f, 0.05055367f, 0.12514707f, 
    -0.04755826f, -0.12714335f, 0.00050331f, -0.09431375f, 0.04650315f, 0.34361932f, -0.04286641f, 0.00839989f, 
    0.06515945f, 0.02046282f, 0.13319443f, 0.02896025f, 0.09061559f, -0.02587406f, -0.74105579f, -0.44663060f, 
    -0.33118996f, -0.07643222f, 0.15964161f, -0.13803191f, 0.04363133f, 0.05144107f, -0.07155523f, -0.22959496f, 
    0.02809046f, 0.48820955f, 0.00662758f, -0.04809771f, -0.00700924f, 0.11907703f, 0.00357247f, 0.06896882f, 
    -0.11953466f, 0.08249467f, -0.25733885f, 0.15689713f, 0.27487904f, -0.07224786f, 0.02737465f, -0.06563225f, 
    0.03484367f, -0.21674091f, 0.08968579f, -0.02463860f, 0.05406044f, -0.04980135f, -0.00829331f, -0.08477945f, 
    0.02667096f, -0.01957945f, 0.46783003f, -0.17644109f, -0.24846625f, -0.12990205f, -0.07809687f, 0.08956546f, 
    -0.18910031f, 0.09934954f, 0.28102231f, 0.10947032f, -0.00433481f, 0.09122671f, 0.09081016f, -0.02178490f, 
    -0.05999010f, 0.10446703f, 0.06149887f, 0.06706851f, -0.32385972f, -0.04030495f, 0.03179599f, 0.15283546f, 
    -0.07427399f, 0.03656008f, 0.24736537f, 0.01174872f, -0.11520841f, 0.56539029f, -0.29371870f, -0.26413056f, 
    -0.02774053f, -0.15738060f, 0.05701434f, -0.01426236f, -0.04879230f, 0.00223953f, -0.44203350f, -0.18994415f, 
    -0.22060123f, -0.06453384f, -0.05490286f, -0.03606198f, 0.12098128f, -0.17974730f, -0.15368289f, 0.06451467f, 
    0.09983356f, -0.01985111f, -0.05071487f, -0.03152931f, 0.00689826f, 0.15880357f, 0.05653032f, 0.07917838f, 
    -0.09470952f, -0.25109750f, -0.69119149f, -0.00611458f, -0.02435056f, 0.03244852f, 0.03414154f, 0.13052563f, 
    0.02581005f, -0.10281377f, -0.02262220f, -0.07111991f, -0.12113738f, -0.10520814f, -0.16449039f, 0.01996821f, 
    -0.13100523f, -0.10029827f, -0.28821576f, 0.22460631f, 0.00409522f, 0.08506732f, -0.02757620f, -0.08579420f, 
    0.13462830f, 0.09522549f, 0.41899353f, 0.14470735f, 0.29144385f, 0.00744447f, -0.11425899f, 0.16365372f, 
    -0.09275950f, 0.11773787f, -0.02038927f, -0.08918875f, -0.14035822f, -0.37828019f, -0.02042631f, -0.05602635f, 
    0.13938385f, -0.00167458f, 0.20425308f, -0.02634495f, 0.08621988f, -0.22737059f, 0.11669030f, 0.05326058f, 
    0.11178851f, 0.08741500f, 0.08667929f, 0.04264757f, 0.06031237f, -0.03925575f, -0.19225702f, -0.06283331f, 
    0.02616857f, -0.01822850f, -0.00006446f, -0.11697192f, -0.08565087f, -0.03846039f, 0.08230657f, 0.19210021f, 
    -0.15067251f, -0.52192914f, -0.12157232f, -0.13261954f, 0.03419889f, -0.07136218f, 0.05500992f, 0.10361404f, 
    0.27343476f, -0.01113620f, -0.25721794f, -0.12405508f, 0.02531424f, -0.06235836f, 0.07667189f, -0.00500951f, 
    -0.02413010f, 0.25299391f, 0.00437586f, -0.34253004f, -0.04624749f, 0.04920848f, -0.07724439f, 0.08118177f, 
    0.01795604f, -0.01473263f, 0.08422006f, -0.10306192f, 0.21671551f, 0.07945908f, -0.07134298f, 0.37182790f, 
    0.18779805f, 0.03781326f, -0.20366856f, -0.00576683f, 0.19016409f, 0.11452684f, -0.16363786f, 0.00559345f, 
    -0.01328541f, 0.11121124f, 0.03032767f, -0.08963403f, 0.74600929f, -0.00664073f, -0.32200462f, -0.07305194f, 
    -0.03104900f, -0.06866454f, 0.00905012f, -0.04026590f, -0.05548272f, -0.30118400f, -0.23633447f, -0.04822112f, 
    0.01812165f, 0.11063156f, -0.02957948f, 0.09782854f, 0.15213503f, 0.05578593f, -0.31407067f, -0.51237267f, 
    -0.10392697f, 0.06515943f, 0.07663829f, 0.12734567f, -0.06070771f, -0.05211191f, 0.08876453f, -0.17234327f, 
    -0.23887047f, -0.19758289f, 0.06557767f, -0.04474332f, 0.05529441f, 0.01208750f, -0.10259864f, -0.10090981f, 
    -0.21053387f, 0.00631773f, 0.01810402f, 0.13514723f, 0.08247689f, 0.16219829f, 0.05321864f, -0.05823360f, 
    -0.06821319f, 0.81786078f, 0.38465539f, 0.13452016f, -0.06279836f, -0.02453352f, -0.03907806f, 0.02067711f, 
    -0.10546158f, -0.12614501f, -0.20299974f, 0.00819483f, 0.23472691f, 0.07874703f, 0.12359918f, 0.10421257f, 
    0.01624594f, -0.03871819f, 0.05911536f, -0.14318138f, 0.07105505f, 0.04379256f, 0.04429125f, 0.05059219f, 
    0.12260395f, 0.02048539f, -0.13799167f, 0.11233035f, 0.24754047f, 0.16427319f, 0.15678272f, -0.00739835f, 
    -0.11482686f, -0.10313201f, -0.02900940f, -0.08108739f, 0.00410877f, -0.05043580f, -0.01581251f, 0.03666257f, 
    0.04888827f, -0.04720744f, 0.20491515f, 0.00476182f, -0.03724167f, -0.02468250f, 0.07578796f, -0.33872697f, 
    -0.03883449f, 0.04475930f, -0.03895490f, -0.07549439f, 0.00237334f, -0.07582609f, 0.05682035f, 0.22685438f, 
    -0.22012265f, 0.08884270f, -0.22482003f, 0.11626232f, 0.00269609f, -0.01879595f, 0.05792284f, 0.17776728f, 
    -0.15226133f, -0.11468545f, 0.15927720f, -0.05133466f, 0.13967167f, 0.29542884f, 0.09872582f, -0.12789209f, 
    0.01769290f, 0.12583533f, 0.16886123f, 0.04949600f, -0.17184350f, -0.11358111f, -0.10175687f, -0.06116600f, 
    -0.03272885f, -0.09676407f, 0.23190901f, -0.10111665f, 0.14617224f, -0.03364152f, 0.02493399f, -0.06163635f, 
    0.09332772f, 0.19737138f, 0.03600988f, 0.17211305f, 0.18870206f, 0.27008507f, -0.10896196f, -0.00881995f, 
    -0.01787976f, -0.04130949f, 0.02483770f, -0.02979371f, 0.26460570f, 0.14676827f, 0.15248410f, -0.21517561f, 
    -0.05622627f, 0.12782930f, 0.02895880f, -0.05570142f, 0.04213434f, 0.49669185f, 0.02825323f, 0.02035621f, 
    -0.06307930f, -0.07133742f, -0.04125546f, 0.09652830f, -0.07481654f, -0.01323954f, 0.43023646f, 0.09152360f, 
    0.28252879f, 0.14797437f, -0.03621162f, 0.10000428f, 0.00523301f, -0.03176390f, 0.10762582f, 0.06154795f, 
    -0.11079027f, -0.23703356f, 0.05624077f, -0.07404190f, 0.04999889f, -0.08666646f, 0.03210348f, -0.10872865f, 
    -0.44523621f, -0.39733359f, -0.08745189f, -0.04654764f, 0.11254775f, -0.03462568f, -0.01681850f, 0.11726569f, 
    -0.07443483f, -0.07046831f, -0.11809059f, 0.26794386f, -0.03943650f, 0.01234817f, -0.02569627f, 0.05520198f, 
    -0.11522912f, 0.18246113f, 0.12256475f, 0.00084338f, -0.23712769f, -0.16032739f, -0.11520728f, 0.06830841f, 
    0.03300947f, 0.00788225f, -0.13394889f, 0.05735761f, -0.15816642f, -0.09661267f, 0.16635872f, -0.09581215f, 
    -0.07825015f, -0.08669640f, -0.00614498f, -0.15328012f, -0.48485532f, 0.12538016f, 0.25189391f, 0.03797971f, 
    -0.04959215f, 0.09132725f, -0.15970516f, 0.04090282f, -0.00996869f, 0.41771725f, -0.06112417f, -0.14501256f, 
    0.08328936f, -0.04399808f, -0.01617048f, -0.02849425f, 0.03172807f, -0.10203788f, 0.10434341f, 0.13952452f, 
    0.11643081f, 0.09800833f, -0.07867908f, 0.01957227f, -0.14452828f, 0.08525505f, -0.03661594f, 0.45081660f, 
    -0.09411982f, 0.14915164f, -0.08728132f, -0.11488005f, -0.26518437f, -0.02325880f, 0.03275246f, -0.15707643f, 
    0.15196468f, -0.07497343f, 0.12829381f, 0.04103118f, 0.09672584f, -0.12722991f, -0.08709723f, 0.00803095f, 
    -0.01950069f, 0.17659526f, 0.04237182f, 0.04360465f, 0.03443700f, -0.01250556f, -0.09932162f, 0.04996070f, 
    0.08326165f, 0.01754225f, -0.12993075f, -0.15282547f, -0.07353044f, -0.00937214f, -0.03860338f, -0.25627071f, 
    0.27384037f, -0.05878883f, 0.04128775f, -0.11699676f, -0.12240969f, 0.00488018f, -0.05663545f, -0.16034035f, 
    -0.03117354f, 0.13413142f, 0.03969307f, 0.12558751f, 0.14619692f, 0.23342264f, 0.11815974f, 0.03075175f, 
    0.03749190f, -0.03035677f, -0.07806337f, 0.07932646f, 0.05697367f, 0.00608132f, 0.03649665f, -0.05814413f, 
    0.01098935f, -0.00964760f, 0.04189413f, 0.09139617f, -0.12828450f, -0.44311440f, -0.06453226f, 0.00986763f, 
    0.06952519f, 0.05616165f, 0.11940683f, 0.04018600f, -0.02916422f, -0.05457206f, 0.05300725f, 0.10729838f, 
    0.25933802f, 0.23324196f, 0.00606430f, 0.09090316f, 0.09908733f, 0.06414599f, -0.07613713f, 0.01691656f, 
    -0.13076195f, -0.23647054f, 0.02093647f, -0.01330571f, 0.13520972f, 0.03384769f, 0.16832823f, 0.04042033f, 
    0.07915959f, 0.26017085f, 0.19605692f, 0.19194423f, 0.05128223f, -0.01031447f, 0.03754393f, -0.03064867f, 
    0.04043149f, 0.10256525f, -0.14785212f, 0.00238181f, 0.05231704f, 0.16871658f, 0.11878753f, 0.10129444f, 
    -0.02624390f, 0.12166538f, 0.01620685f, -0.08147163f, -0.10538421f, 0.07226509f, 0.05105077f, 0.08194008f, 
    -0.02542905f, -0.18385914f, -0.10592004f, -0.08136776f, -0.07737856f, -0.16071126f, -0.11718167f, -0.04155470f, 
    -0.07986408f, -0.13844502f, -0.07608207f, -0.00185602f, 0.11278028f, -0.15039451f, -0.18471470f, -0.13554670f, 
    -0.02119962f, 0.01485843f, 0.09701587f, 0.12541361f, -0.11351025f, -0.06394103f, 0.06278768f, 0.19226040f, 
    0.35241893f, 0.11644331f, 0.12602876f, 0.09290550f, -0.00968909f, -0.09552141f, -0.06195898f, 0.31863081f, 
    0.22376502f, -0.16380949f, 0.01907781f, 0.02046038f, 0.04932602f, 0.04475616f, -0.06167084f, 0.10616704f, 
    0.11417684f, 0.17903273f, -0.06445693f, 0.08028540f, 0.01909993f, -0.02209494f, 0.04760022f, -0.21138330f, 
    -0.03628042f, -0.04534968f, -0.06969139f, -0.02351314f, 0.02073437f, -0.02836123f, -0.18167791f, -0.03145249f, 
    -0.27175981f, 0.06884848f, 0.19933112f, 0.05879321f, 0.21696962f, 0.04208836f, 0.21081834f, 0.08343229f, 
    -0.07260298f, -0.10073094f, -0.08022171f, -0.05476310f, -0.16273296f, -0.03001196f, -0.05510865f, 0.02536433f, 
    -0.11082109f, -0.07772732f, -0.03558761f, 0.02188360f, 0.07296218f, 0.05488213f, -0.21131060f, -0.15432429f, 
    -0.00402216f, 0.13804969f, -0.01084271f, 0.07733378f, 0.03571033f, 0.19809327f, 0.23732218f, 0.31378487f, 
    0.05044421f, 0.10143054f, 0.05307567f, -0.02194828f, 0.04148890f, -0.11441689f, 0.14935473f, 0.31571314f, 
    0.15267515f, 0.08060285f, 0.12272107f, 0.08820539f, -0.11266967f, -0.00484373f, 0.02190046f, 0.05748015f, 
    0.15998934f, -0.03633784f, -0.07419611f, 0.03575315f, 0.03028819f, 0.02679391f, 0.12363613f, -0.02503689f, 
    -0.06330419f, 0.09689724f, 0.14453702f, 0.05632636f, 0.12127717f, 0.05510190f, -0.08954985f, -0.11957632f, 
    -0.11766063f, 0.17985803f, 0.39228168f, 0.31311896f, 0.26785889f, 0.03679835f, 0.00215581f, 0.05982245f, 
    -0.00645979f, 0.11953825f, 0.14830621f, -0.12779278f, 0.14103207f, 0.11873837f, -0.08456907f, -0.15626132f, 
    -0.08386591f, 0.05351917f, -0.06508152f, 0.02510509f, -0.03839584f, 0.35256675f, -0.06176581f, -0.03587736f, 
    -0.28017104f, 0.01899122f, 0.07957483f, -0.07449508f, 0.18742433f, -0.02307952f, -0.05470664f, -0.01067630f, 
    0.00187486f, -0.05646126f, -0.02897388f, 0.09448612f, -0.18233675f, 0.23186162f, -0.00870024f, -0.03655452f, 
    -0.02762686f, -0.02032059f, 0.03444565f, 0.12348253f, 0.07620028f, 0.13266400f, -0.14708412f, -0.12264197f, 
    -0.03806770f, 0.02523977f, -0.04865787f, -0.03458451f, 0.13250729f, -0.15301800f, -0.16448569f, 0.33914807f, 
    0.17163935f, 0.15398581f, 0.12391815f, 0.05714071f, 0.08817247f, 0.06241169f, -0.04160052f, -0.08519197f, 
    -0.32331008f, 0.03751597f, -0.15234956f, -0.04123449f, -0.03279226f, -0.10153914f, -0.06752275f, 0.07888287f, 
    -0.00753194f, -0.28230238f, -0.07095622f, -0.09701665f, 0.05035111f, 0.12256389f, 0.05778760f, -0.03376345f, 
    -0.08746952f, -0.07107497f, 0.16772762f, -0.36758024f, -0.05240120f, -0.12956698f, 0.10565503f, 0.35200217f, 
    -0.03173293f, -0.19369254f, 0.10630465f, 0.10110192f, 0.05037080f, -0.02223096f, -0.11703998f, 0.11844100f, 
    0.17797744f, -0.04967999f, 0.08181714f, 0.10472310f, -0.21281545f, 0.03669746f, -0.01219746f, 0.03309789f, 
    0.13622428f, -0.04413164f, 0.02973924f, 0.19412999f, -0.09201160f, -0.06334991f, -0.06853644f, 0.18023783f, 
    -0.07805971f, 0.37650332f, 0.04655873f, 0.07419456f, -0.04210403f, 0.05768437f, -0.10421736f, -0.16520213f, 
    0.41698483f, 0.02153021f, 0.00237365f, -0.04342477f, 0.03273973f, 0.06998170f, 0.40257293f, 0.04503458f, 
    -0.22933511f, 0.00464797f, 0.12706992f, 0.06264797f, 0.11148561f, 0.06849428f, -0.08491261f, 0.01648496f, 
    0.25777507f, 0.13417338f, 0.05948082f, 0.11548491f, 0.02368678f, 0.04790466f, 0.17177567f, 0.10312399f, 
    0.16383216f, 0.01593455f, 0.21288790f, 0.14366157f, -0.11081468f, -0.11957125f, -0.09887740f, -0.07770578f, 
    -0.02220927f, -0.01389392f, 0.05681102f, -0.09595580f, -0.09597814f, -0.07982037f, 0.13396835f, -0.06061031f, 
    0.03460338f, 0.06346277f, 0.14211151f, -0.23961656f, 0.03947499f, 0.29051837f, -0.09760389f, -0.10692480f, 
    -0.17283385f, -0.11979410f, 0.03077488f, -0.09379189f, 0.00171280f, 0.23578614f, 0.11731201f, 0.05304087f, 
    0.00275339f, 0.06767745f, 0.01370295f, 0.07455420f, -0.03414639f, -0.10967166f, 0.00700557f, 0.06590887f, 
    0.06607052f, -0.00625929f, 0.05172706f, 0.04630098f, 0.05219338f, 0.17761591f, -0.16466077f, -0.00388785f, 
    0.15204307f, -0.23871341f, 0.04592367f, -0.14224736f, -0.06552996f, 0.14576887f, -0.02128172f, 0.01095618f, 
    0.15181087f, 0.38746387f, -0.04405181f, -0.00118824f, 0.04092552f, 0.00755076f, 0.08736299f, -0.06753925f, 
    -0.16246128f, -0.09554377f, -0.07527077f, -0.14788583f, 0.08141100f, 0.11588424f, -0.01886811f, -0.04371807f, 
    -0.07494599f, -0.17229915f, 0.08059304f, -0.08503193f, -0.04755345f, -0.02976723f, -0.16510411f, 0.11119653f, 
    0.02045372f, -0.09612051f, -0.04680770f, -0.07736595f, -0.01792959f, 0.16628116f, 0.07833649f, 0.03966429f, 
    0.00480020f, -0.30773270f, 0.05266841f, -0.00087403f, 0.05935084f, 0.14771825f, -0.00735605f, 0.01847002f, 
    -0.07644052f, 0.00683256f, 0.19590123f, 0.17150486f, -0.36712608f, -0.00420195f, 0.09704605f, -0.01384626f, 
    -0.00627730f, 0.10605351f, 0.18629509f, -0.06423188f, 0.03706018f, 0.09740953f, 0.04592849f, -0.07398199f, 
    0.09057734f, 0.10224053f, -0.31524056f, -0.08718624f, -0.09047198f, 0.08844903f, -0.38039225f, -0.16978680f, 
    -0.25991890f, 0.10547078f, 0.05484772f, 0.18222566f, 0.04275187f, -0.08842663f, -0.07632508f, -0.25131902f, 
    0.08037096f, -0.08621294f, 0.17998114f, 0.22939505f, 0.29777232f, 0.05370794f, -0.03180514f, 0.09110912f, 
    -0.21681486f, -0.24890599f, -0.15425952f, -0.22012527f, 0.02109221f, -0.01488554f, 0.06383501f, 0.11996688f, 
    -0.14086610f, -0.08563938f, -0.20340909f, 0.06617996f, -0.11035930f, -0.09343945f, -0.11489774f, 0.01595921f, 
    -0.03599212f, 0.03908065f, -0.08982597f, 0.01202009f, 0.11281353f, 0.15598918f, -0.11083667f, -0.07589451f, 
    -0.26496902f, -0.06121104f, -0.10642360f, -0.20143361f, 0.33016708f, -0.05832000f, 0.03191967f, -0.12017132f, 
    0.10221586f, 0.13777116f, -0.02462753f, -0.00219901f, -0.05409410f, -0.03443010f, 0.28876239f, 0.08823811f, 
    0.08139463f, -0.07836090f, -0.09257343f, -0.16392928f, -0.15735246f, 0.12534617f, 0.29982510f, 0.28694260f, 
    0.01746902f, 0.00318190f, 0.05373132f, 0.13568887f, -0.12599728f, -0.15544160f, -0.16701856f, -0.10916177f, 
    0.15927127f, -0.14722291f, -0.05866809f, -0.14505884f, 0.06237213f, -0.10167298f, 0.11022367f, 0.05881957f, 
    -0.14796665f, 0.17198746f, -0.24517998f, 0.04136125f, -0.09619153f, 0.06085352f, 0.06412487f, -0.12585336f, 
    -0.32801980f, -0.34619042f, 0.02691226f, -0.06586704f, 0.13773872f, 0.00186260f, 0.11024637f, 0.01828494f, 
    0.15170787f, -0.08986248f, -0.06722263f, 0.13034663f, -0.09983853f, 0.04391837f, -0.00514463f, 0.02563481f, 
    -0.18856221f, 0.13958558f, 0.20030801f, -0.00903644f, -0.23652434f, 0.09873147f, -0.03168342f, -0.03394099f, 
    -0.02466664f, -0.00668156f, -0.11163368f, -0.09846721f, -0.22100526f, -0.13192214f, -0.04615752f, -0.04777021f, 
    -0.02701033f, 0.04952019f, -0.10663269f, -0.02659410f, -0.00022159f, 0.09061856f, 0.14327607f, -0.10415938f, 
    -0.07747053f, 0.02897657f, 0.11998163f, -0.02830829f, -0.00066553f, 0.26411086f, -0.03561788f, 0.01385455f, 
    -0.10719279f, 0.13982752f, 0.06876084f, 0.04888587f, 0.08551396f, -0.17728865f, 0.34186170f, -0.13760319f, 
    -0.23649690f, 0.02011422f, 0.06573598f, 0.19040525f, 0.22084199f, -0.15186460f, 0.04764391f, 0.10095277f, 
    0.08331046f, 0.19966140f, -0.10230228f, 0.02196132f, 0.00841938f, -0.09915169f, -0.00572319f, -0.10403471f, 
    -0.13053502f, -0.23626409f, -0.29635125f, -0.03664640f, -0.06640377f, -0.11955258f, -0.08902048f, -0.10511755f, 
    0.02133434f, 0.07310199f, -0.20797952f, 0.21332675f, 0.02611389f, 0.07988540f, -0.15866135f, -0.00447211f, 
    -0.14623730f, -0.19064128f, -0.02402773f, -0.14915879f, -0.20004155f, -0.01475834f, 0.08103815f, -0.07459550f, 
    -0.14218646f, 0.01880484f, 0.06140380f, 0.08235217f, 0.03505109f, -0.25450572f, 0.14769489f, -0.08303177f, 
    -0.08124893f, 0.16251670f, 0.06997472f, 0.05669457f, 0.09495162f, 0.05749629f, -0.16096354f, -0.06562412f, 
    0.03958357f, -0.08283421f, 0.07056592f, -0.02003736f, 0.07676066f, 0.45087880f, 0.04216694f, -0.51225871f, 
    0.17437108f, -0.04239552f, -0.03826387f, 0.13438550f, 0.00682202f, 0.11278508f, 0.09689235f, 0.14904362f, 
    0.17399590f, 0.03069030f, -0.02283041f, -0.03823207f, 0.08787625f, 0.05917493f, -0.03853197f, -0.05149252f, 
    -0.00944941f, 0.09712378f, -0.03061886f, 0.00276496f, -0.01633450f, 0.10858896f, 0.08003233f, -0.06333831f, 
    0.35955811f, 0.12649477f, -0.02134350f, 0.09029569f, 0.28910920f, -0.01809485f, 0.04495288f, -0.22277564f, 
    0.04526984f, -0.03719373f, -0.07807035f, -0.20648926f, 0.03482019f, 0.05890296f, 0.04141047f, 0.05428128f, 
    0.22846012f, -0.16807486f, -0.63318384f, -0.14614402f, -0.07304106f, -0.13083205f, 0.19336689f, -0.01623748f, 
    0.20485704f, 0.00956134f, -0.03334952f, 0.00007583f, -0.04376204f, 0.04144311f, 0.15881737f, -0.05036181f, 
    -0.01579085f, -0.18355881f, -0.08855949f, -0.02414360f, 0.21729611f, -0.08155711f, -0.62033504f, 0.05212861f, 
    -0.13085149f, -0.04144524f, 0.12373786f, -0.08631576f, -0.01735718f, 0.02600772f, -0.15652953f, 0.33117959f, 
    -0.06861256f, 0.10197835f, -0.07295261f, -0.04771810f, -0.18007816f, 0.02996397f, 0.01551676f, 0.11162878f, 
    -0.18452658f, -0.16902445f, -0.11301193f, 0.07999805f, 0.11377096f, 0.07784695f, -0.21724556f, 0.11536117f, 
    0.05385263f, -0.20346504f, -0.04381523f, -0.01065627f, 0.01114845f, 0.16806222f, -0.11102083f, -0.05460436f, 
    0.13962536f, 0.08232492f, 0.13523203f, 0.09034149f, 0.04061003f, 0.06703867f, -0.02683215f, 0.03047868f, 
    -0.00035115f, 0.21791317f, 0.17116153f, 0.23083311f, -0.04364073f, 0.04455223f, -0.13011819f, -0.14386865f, 
    -0.09461378f, -0.02503277f, -0.14798775f, -0.44846985f, -0.01654909f, 0.02604729f, 0.07108141f, -0.01108337f, 
    0.06927294f, 0.10385206f, 0.03982978f, 0.24930988f, 0.04312445f, 0.15340020f, -0.00215306f, 0.04385099f, 
    -0.02652512f, -0.01440203f, 0.10225488f, -0.01584668f, -0.22161527f, -0.04393305f, 0.08303553f, 0.08581032f, 
    0.15958251f, -0.06275453f, 0.01325240f, -0.01891165f, 0.01632409f, -0.32670075f, -0.36105213f, -0.01154769f, 
    -0.10343851f, 0.15197758f, 0.17617577f, -0.04504289f, 0.18061990f, -0.07868683f, 0.33264890f, 0.28371757f, 
    0.03405258f, -0.04990256f, -0.03782740f, -0.09371628f, 0.17203251f, -0.12390249f, 0.10672408f, -0.22287028f, 
    -0.06727242f, 0.20592187f, 0.02570496f, 0.15849765f, 0.11350912f, 0.05301305f, 0.01999129f, -0.04062427f, 
    0.00846175f, -0.02928193f, -0.04405447f, -0.02844558f, -0.03920521f, 0.01533342f, -0.03359621f, -0.06170070f, 
    -0.02520446f, 0.02503774f, 0.00939393f, -0.00783970f, -0.04231401f, 0.01365893f, -0.01472611f, -0.01405340f, 
    -0.04509128f, 0.03933020f, 0.03524487f, -0.03623010f, 0.02944471f, 0.02461616f, -0.04118027f, 0.00336381f, 
    -0.04566770f, -0.02591208f, -0.02452270f, -0.02208137f, 0.01082522f, -0.00826193f, 0.03839064f, 0.03150949f, 
    -0.00137521f, -0.01959869f, 0.01235777f, -0.02671568f, -0.03111854f, 0.03879311f, 0.00909161f, 0.00301073f, 
    0.04711320f, -0.03324304f, -0.05772103f, -0.06334145f, -0.03933212f, 0.04076245f, -0.06375554f, 0.00920915f, 
    0.04014849f, -0.04134827f, 0.03123418f, -0.01256578f, -0.01188804f, -0.05767020f, -0.03719851f, 0.05128529f, 
    -0.01115924f, -0.02786991f, 0.03512183f, -0.00342253f, -0.02023243f, -0.02373877f, -0.02819962f, -0.04427722f, 
    0.03673838f, 0.02839736f, -0.05315847f, 0.04106187f, -0.05303282f, 0.02817122f, 0.02113595f, -0.05549293f, 
    -0.02218829f, -0.00818284f, -0.00550327f, -0.06199181f, 0.04019000f, 0.03012096f, -0.01358578f, -0.01971646f, 
    -0.02947215f, 0.05188397f, 0.01837248f, -0.02132485f, 0.04159768f, -0.02217061f, -0.00087498f, -0.03898506f, 
    -0.02842193f, 0.04459589f, 0.03135890f, 0.03761425f, -0.05044793f, -0.04712893f, 0.01283066f, 0.00990996f, 
    -0.03711608f, -0.01233053f, 0.02916175f, -0.00785813f, -0.05341168f, 0.03971979f, 0.02705341f, 0.04195610f, 
    -0.00883895f, -0.03695427f, -0.04638853f, -0.05008624f, -0.00577896f, 0.03999407f, -0.04839065f, -0.04251270f, 
    -0.04124985f, 0.03557756f, -0.00634307f, 0.02269756f, -0.03426631f, 0.01125250f, -0.06213243f, 0.04713042f, 
    -0.02053877f, -0.05634503f, -0.00394489f, 0.00745040f, -0.05571570f, -0.03180468f, -0.01141358f, 0.01166709f, 
    -0.04268522f, -0.05371858f, -0.03376755f, -0.05599615f, -0.05462882f, 0.01083710f, 0.02197332f, 0.02122513f, 
    -0.00942230f, -0.03289440f, -0.01317883f, -0.01508521f, -0.05319078f, 0.03792101f, 0.01821038f, -0.05489352f, 
    0.01546734f, -0.02162107f, -0.05297141f, -0.02875895f, 0.05245707f, 0.02228481f, 0.02338260f, 0.04309969f, 
    -0.02566327f, -0.00934669f, -0.01344255f, 0.04480286f, -0.02102818f, -0.06002624f, -0.06260839f, -0.03759789f, 
    -0.06167484f, -0.00132958f, -0.00356208f, 0.00440924f, -0.03162973f, -0.02953423f, -0.04339100f, 0.04574803f, 
    0.03386127f, -0.00990293f, 0.04500189f, 0.03616220f, -0.01825211f, 0.00089114f, -0.04944902f, -0.01048360f, 
    0.03484048f, 0.00146843f, -0.00279788f, -0.02909548f, 0.04481430f, 0.04619790f, -0.03388872f, -0.05904454f, 
    -0.06359781f, -0.04739088f, -0.04872251f, 0.04238126f, 0.00892770f, 0.01817220f, 0.04303952f, 0.00229588f, 
    -0.02422375f, 0.01070890f, -0.03693299f, -0.04206642f, -0.05642929f, -0.00002328f, 0.02109538f, 0.01404453f, 
    0.04783845f, -0.02773971f, -0.06005374f, 0.00163532f, 0.03772999f, -0.01946402f, -0.05061201f, -0.01145690f, 
    0.00388144f, -0.00885241f, -0.04526917f, -0.03682966f, -0.01919561f, -0.02586382f, -0.00708022f, 0.04084557f, 
    -0.03807304f, 0.00518590f, 0.01882864f, 0.04971489f, 0.00793479f, -0.02917723f, 0.03586578f, -0.00990577f, 
    -0.01707800f, 0.04744506f, -0.01888516f, 0.02645629f, -0.01775066f, -0.02211556f, 0.05183928f, -0.00517622f, 
    -0.05582040f, -0.03344689f, -0.04197318f, 0.03327401f, 0.05163688f, -0.04004865f, 0.00772496f, 0.01868481f, 
    -0.02781609f, 0.01681576f, 0.04307269f, -0.04579098f, 0.01188604f, -0.03984492f, 0.03191056f, 0.01800730f, 
    -0.04354967f, -0.05327709f, 0.00100412f, 0.03771479f, -0.02711795f, 0.05643547f, 0.00562443f, -0.03977038f, 
    -0.04574161f, 0.04718260f, -0.03420932f, -0.01531200f, 0.04209363f, 0.02985114f, 0.02186942f, -0.02005245f, 
    -0.01303596f, 0.03689210f, -0.00201059f, 0.04249790f, -0.01419006f, 0.02435275f, 0.00608821f, -0.01884626f, 
    0.00709856f, -0.00813043f, 0.02112319f, -0.00086539f, -0.03746384f, -0.01252973f, -0.02636678f, -0.03876780f, 
    -0.04859339f, -0.03003492f, 0.00316737f, -0.01201118f, -0.04599073f, -0.03286757f, 0.01447536f, 0.00482394f, 
    -0.13763267f, 0.24569552f, -0.10916135f, -0.12992655f, -0.04329970f, -0.05485702f, -0.01092889f, 0.01296151f, 
    0.01976047f, -0.06531402f, 0.23176508f, 0.03684644f, -0.25825086f, 0.09444125f, 0.02451871f, -0.02847658f, 
    0.01023462f, 0.00178438f, 0.42918947f, -0.35377470f, -0.23299199f, 0.05045998f, 0.10920694f, -0.14115421f, 
    -0.15871172f, 0.12160382f, -0.06994513f, 0.03707529f, 0.04886467f, 0.04385533f, -0.13444640f, 0.12075963f, 
    0.17772475f, -0.08520175f, 0.12968862f, 0.05928482f, 0.13289778f, 0.26898891f, 0.20700060f, -0.01061689f, 
    0.04657698f, 0.00406458f, 0.05842805f, 0.00462099f, 0.00564294f, 0.00586073f, -0.10272042f, -0.06872831f, 
    0.11761668f, 0.00350919f, -0.06314228f, 0.06562678f, 0.04789280f, 0.09479780f, 0.00849296f, -0.26388407f, 
    -0.05946786f, -0.06764160f, 0.10745654f, -0.09737995f, -0.12279181f, -0.13782007f, 0.28578705f, -0.13639140f, 
    -0.37110189f, 0.01387033f, 0.11163946f, 0.09215365f, -0.00023070f, -0.00409229f, -0.03553291f, 0.10684858f, 
    -0.14252092f, -0.20673874f, 0.01279707f, 0.06256822f, 0.02453553f, 0.01716672f, -0.12232895f, 0.12576467f, 
    0.05949258f, -0.42294306f, -0.12257458f, 0.42528895f, 0.01285105f, -0.00519582f, 0.01829483f, -0.02875482f, 
    0.04143265f, 0.11840881f, -0.40827295f, -0.09058665f, -0.24661539f, -0.08690248f, 0.05554030f, 0.09981529f, 
    -0.08310223f, -0.00056973f, 0.08539283f, -0.06050504f, -0.06700974f, 0.12663494f, 0.02480779f, 0.02264737f, 
    -0.04026410f, -0.00720468f, 0.00601620f, 0.08717702f, 0.01485059f, 0.09663370f, -0.00535012f, 0.05342984f, 
    -0.05341638f, 0.05422027f, -0.07603852f, -0.01533890f, 0.14148529f, -0.20441997f, 0.07847997f, 0.05284993f, 
    0.04596529f, -0.00886650f, 0.05757454f, -0.13141577f, 0.19975668f, 0.13883701f, -0.22048055f, -0.04903362f, 
    0.11814893f, 0.05488433f, -0.00684156f, 0.00720172f, 0.07075959f, 0.01840889f, -0.00938158f, -0.06646212f, 
    0.32250252f, 0.42203960f, -0.01842645f, 0.02795849f, 0.09312701f, 0.05755303f, 0.14268243f, 0.16536303f, 
    0.27861747f, -0.00177521f, -0.17342770f, -0.13600534f, -0.06248767f, -0.11826053f, -0.03053927f, 0.05102875f, 
    0.08645516f, -0.08412883f, -0.04883656f, 0.01459015f, -0.04093188f, -0.13648434f, -0.17408618f, 0.18379547f, 
    0.09586252f, -0.08544326f, -0.09903734f, -0.13603124f, 0.03478315f, 0.01122665f, -0.08224925f, 0.03483168f, 
    0.02904820f, -0.13681947f, -0.08575307f, 0.07211398f, 0.02100563f, -0.03422904f, -0.13725321f, 0.05630307f, 
    0.17593816f, 0.02077214f, 0.07704484f, 0.21291509f, -0.17308268f, -0.18921800f, 0.04473696f, -0.12577407f, 
    -0.04018334f, 0.26676413f, -0.01845779f, -0.05503365f, 0.02779389f, -0.32045573f, -0.19444863f, 0.05960255f, 
    0.08966621f, -0.06284687f, -0.06050529f, 0.03703120f, -0.06659724f, -0.05958391f, -0.12428827f, -0.57992321f, 
    -0.03966311f, 0.01564127f, -0.07154049f, 0.05974323f, -0.04281430f, -0.09556271f, 0.07484040f, 0.10996269f, 
    -0.16757311f, 0.19916275f, 0.06579837f, 0.10454494f, 0.07620778f, 0.08171351f, 0.13798217f, 0.14931478f, 
    -0.29310310f, -0.10066189f, -0.22013362f, 0.05828006f, 0.04838561f, -0.01780418f, 0.07320639f, 0.11837921f, 
    0.01895239f, -0.38405964f, -0.41008329f, 0.03927648f, -0.09951059f, -0.03132348f, -0.08145015f, -0.02030675f, 
    0.02467489f, 0.06200705f, -0.09098671f, 0.48028770f, -0.02673255f, 0.04033562f, -0.10326352f, -0.22353122f, 
    -0.08079638f, -0.14932469f, -0.06323864f, 0.07197011f, -0.04791129f, 0.21327132f, -0.12181971f, 0.18631978f, 
    -0.03444111f, 0.01259616f, 0.04774921f, 0.00822963f, -0.27405962f, 0.18898112f, 0.20782964f, -0.05115298f, 
    0.03945162f, -0.19001216f, 0.00265453f, -0.16362698f, -0.20500068f, 0.06656149f, 0.54828954f, 0.23951888f, 
    -0.03947233f, 0.03234089f, -0.13929239f, 0.06270635f, -0.06249430f, 0.04354212f, -0.07661716f, 0.09510823f, 
    -0.07387133f, -0.04513846f, -0.10978126f, -0.02889659f, 0.25697690f, -0.02843264f, 0.00673775f, -0.11550902f, 
    0.11409842f, 0.22597690f, 0.07283467f, 0.00986708f, -0.06151322f, 0.11019153f, -0.01362127f, 0.00835541f, 
    0.01942080f, -0.06437898f, -0.02541502f, -0.00448626f, -0.00211050f, 0.02820773f, 0.05028399f, 0.00379891f, 
    -0.00130207f, -0.00298129f, 0.01067980f, -0.06254971f, -0.01416133f, -0.00753782f, -0.06487224f, -0.04461420f, 
    0.02015150f, -0.05770677f, -0.03124738f, -0.03607328f, -0.03108086f, -0.00202153f, -0.04634483f, 0.05307490f, 
    0.01031361f, -0.02005363f, 0.01386322f, -0.05919020f, -0.03879294f, -0.04686614f, 0.04237466f, -0.01048885f, 
    0.01029144f, -0.01559727f, -0.00704065f, 0.02356879f, -0.02268782f, -0.05972309f, -0.00994199f, -0.04037387f, 
    -0.03515653f, 0.01912656f, 0.01768852f, 0.04195488f, 0.00636189f, 0.02703950f, -0.06276428f, 0.02596918f, 
    -0.01247938f, -0.04507808f, -0.00045359f, 0.01362129f, 0.00497957f, -0.06274751f, -0.02962838f, 0.01755005f, 
    -0.01783092f, 0.05347742f, 0.02747241f, -0.05482252f, 0.01220156f, -0.00960300f, -0.01568235f, -0.00057412f, 
    -0.03746238f, -0.03299390f, 0.04938092f, -0.01616280f, 0.04200579f, -0.00417405f, -0.04895160f, 0.00631560f, 
    -0.06621540f, -0.02533141f, 0.03908052f, 0.03911547f, -0.04009518f, -0.04142310f, 0.02851513f, -0.06066518f, 
    -0.02173965f, -0.02345622f, 0.02511957f, 0.04558309f, -0.02205741f, 0.04410837f, -0.01340080f, 0.01900264f, 
    -0.04161729f, 0.03931934f, 0.03530287f, -0.02730379f, 0.01831286f, -0.00567089f, 0.01404275f, -0.05508456f, 
    -0.00543542f, -0.01821026f, -0.02059445f, -0.02327801f, 0.03690926f, -0.06597464f, -0.02136334f, -0.00177332f, 
    0.03551202f, -0.00767476f, -0.05557418f, 0.05021198f, 0.01164475f, 0.01816398f, -0.02457438f, 0.00687894f, 
    0.01536842f, -0.01053212f, 0.00397489f, -0.02006136f, 0.04168751f, -0.00620240f, 0.04071089f, -0.02036278f, 
    0.03160251f, -0.01448414f, 0.01816173f, -0.00894473f, 0.02490159f, 0.01551314f, -0.04925807f, -0.01119493f, 
    0.02998892f, 0.01064266f, -0.03755071f, 0.00913458f, -0.05573728f, -0.02858201f, -0.03276418f, -0.00503349f, 
    0.00167000f, 0.03432540f, 0.04571924f, -0.01548481f, 0.04090461f, 0.01422228f, 0.04293355f, -0.02372831f, 
    -0.00222610f, -0.04136702f, -0.01076296f, -0.01371794f, 0.04225818f, -0.06589023f, -0.05038945f, -0.05340862f, 
    -0.02377607f, 0.00547244f, -0.01383078f, 0.01592229f, 0.00542822f, -0.00742470f, -0.02282920f, 0.01676115f, 
    -0.03004401f, -0.00575854f, -0.01867764f, 0.02029450f, 0.04571251f, 0.00976810f, -0.04718271f, 0.02169595f, 
    -0.02098660f, -0.00517290f, 0.01517850f, 0.00971021f, -0.00235667f, -0.05781393f, -0.05141017f, -0.05260705f, 
    0.00667645f, 0.04090047f, 0.00775240f, 0.01160894f, 0.02194128f, -0.06112709f, -0.03171158f, 0.02513949f, 
    0.03189062f, 0.02711597f, 0.04913504f, -0.02960292f, -0.03697225f, -0.06282795f, 0.01273617f, -0.05727994f, 
    -0.04484237f, 0.00319927f, -0.04897540f, 0.02668002f, -0.04985641f, 0.04262588f, 0.00779816f, -0.06493220f, 
    -0.06543863f, -0.05322942f, -0.06178140f, -0.06925338f, -0.05160010f, -0.05881945f, -0.05691352f, -0.04901616f, 
    -0.00911756f, -0.05353677f, 0.02848992f, -0.02197437f, -0.06279112f, -0.04595819f, -0.07093522f, 0.01266166f, 
    -0.00407547f, 0.03056490f, 0.04805453f, 0.02627515f, 0.04590676f, -0.02209594f, -0.00057945f, 0.03325917f, 
    0.05068990f, -0.01721611f, 0.04133204f, -0.03119843f, -0.02407658f, -0.01326010f, 0.01799243f, -0.04183927f, 
    -0.04311433f, -0.00398996f, -0.02021925f, 0.03507743f, -0.01297163f, -0.05453740f, -0.00712113f, -0.00421801f, 
    0.05234481f, -0.00258979f, 0.01671160f, -0.03561886f, -0.05332474f, -0.02828682f, -0.03163445f, 0.02449360f, 
    0.01830723f, -0.03177091f, 0.02278764f, -0.03402122f, 0.01279500f, 0.01339697f, -0.04418191f, 0.01865713f, 
    0.03846158f, -0.05780049f, 0.05699575f, 0.05411076f, 0.05074561f, 0.02944690f, -0.00132795f, 0.03004611f, 
    -0.03513168f, -0.00542002f, 0.02048253f, -0.06270828f, -0.04386224f, 0.01357031f, -0.03593552f, 0.03776285f, 
    -0.04260152f, -0.04114306f, 0.00815900f, -0.00934526f, -0.02990356f, 0.00258095f, -0.01511728f, 0.02475613f, 
    0.01946530f, -0.04895422f, 0.01632984f, 0.04907698f, -0.04493777f, -0.03964954f, -0.02355766f, -0.05815534f, 
    -0.07494260f, -0.02940971f, 0.03143671f, -0.02163417f, -0.04004841f, -0.03280982f, -0.06120585f, -0.04008679f, 
    0.02997317f, -0.08281963f, -0.05013349f, -0.00018124f, -0.05701046f, -0.08402413f, -0.05099914f, 0.02900713f, 
    0.00342069f, 0.02661854f, 0.01397637f, -0.01549676f, -0.07182896f, -0.05197171f, -0.03784845f, 0.02193078f, 
    0.00213114f, -0.04692724f, 0.00516688f, -0.04218299f, -0.02106457f, -0.02998814f, -0.08533239f, -0.05154347f, 
    -0.03700120f, -0.06400213f, 0.00861224f, -0.07731301f, -0.05966377f, 0.03247043f, 0.02511821f, 0.02588086f, 
    -0.05255059f, -0.03876805f, -0.00040283f, -0.04995290f, 0.00384713f, 0.01786612f, 0.02783749f, -0.04423780f, 
    -0.04935955f, -0.05182731f, -0.04990709f, -0.06134949f, -0.05479472f, -0.02718687f, 0.01057470f, -0.08892218f, 
    0.02249586f, -0.00060157f, -0.02089278f, 0.00846318f, -0.05496037f, 0.02129179f, 0.00277133f, 0.02132177f, 
    0.04194246f, 0.00050109f, -0.05105365f, -0.01867129f, -0.06841674f, -0.00902743f, 0.03420550f, 0.00889388f, 
    -0.01235133f, -0.06463818f, -0.03143536f, -0.06384770f, -0.03082661f, -0.06132945f, -0.05430175f, 0.01539808f, 
    -0.02883969f, 0.00500159f, -0.04356179f, -0.00399795f, -0.07805595f, -0.06069156f, -0.01357481f, -0.03875969f, 
    0.03258738f, -0.03088789f, 0.01894603f, -0.05137118f, -0.01176409f, -0.02042333f, -0.00005446f, -0.05249298f, 
    -0.00370627f, 0.00148271f, -0.04937606f, 0.02165196f, -0.07052288f, 0.00031687f, 0.00172545f, -0.00253858f, 
    -0.05933541f, -0.06888364f, -0.08132008f, -0.07434576f, 0.03228751f, 0.00462739f, -0.06921279f, 0.01135045f, 
    -0.05085496f, 0.01911344f, -0.00708739f, -0.02934939f, -0.07049309f, -0.01804730f, -0.03011494f, -0.04152672f, 
    -0.05377708f, 0.00393456f, 0.01743479f, -0.06596413f, 0.02515767f, -0.02854049f, -0.03146573f, 0.00044153f, 
    -0.05247797f, -0.05703156f, -0.03130498f, -0.06337103f, 0.00722513f, 0.04089111f, 0.05756133f, -0.03424879f, 
    0.02310343f, 0.02939145f, -0.07821042f, -0.06400556f, 0.01517340f, -0.01107473f, -0.03257113f, -0.01429745f, 
    -0.05260827f, -0.04076644f, 0.05676523f, -0.00659255f, -0.06819493f, -0.02206493f, 0.00026277f, -0.00297979f, 
    -0.07790682f, -0.01590291f, 0.03080053f, -0.03003276f, -0.02757536f, -0.01580949f, -0.07761002f, 0.03216214f, 
    0.00070596f, 0.01281103f, -0.04169895f, -0.07783633f, -0.05250780f, -0.06395327f, 0.03455691f, 0.02529679f, 
    0.01906438f, -0.02957591f, 0.03657838f, -0.04501066f, 0.00877291f, -0.05917967f, -0.07902580f, -0.06275251f, 
    -0.04261074f, 0.00398005f, 0.02115211f, -0.01500062f, -0.04515458f, -0.07349818f, -0.05173907f, -0.02746265f, 
    -0.04468690f, -0.06976803f, -0.04862837f, 0.03070126f, -0.06255277f, -0.04735327f, -0.05434838f, -0.04635769f, 
    -0.00864086f, -0.06436606f, -0.04383044f, 0.02337820f, -0.03786043f, 0.03515892f, -0.00930549f, -0.03741258f, 
    -0.05420404f, -0.04254847f, -0.04281102f, -0.00308676f, -0.04020638f, -0.01150118f, -0.02878317f, -0.00285285f, 
    -0.05505676f, -0.07697659f, 0.00328873f, 0.02229720f, 0.02178971f, -0.06399074f, -0.05746733f, -0.06394365f, 
    -0.00233785f, -0.06413895f, -0.03288142f, -0.03970186f, -0.05972990f, -0.02434819f, -0.08070930f, 0.03565797f, 
    -0.01999005f, -0.05852918f, -0.02530026f, -0.06637318f, -0.00841299f, 0.01831773f, -0.05267335f, -0.03463338f, 
    0.05973636f, -0.02610051f, 0.01058566f, -0.05520736f, -0.05471626f, -0.08591866f, 0.02957932f, -0.05269516f, 
    0.01309108f, -0.00036622f, -0.05597110f, 0.04129165f, -0.02576302f, -0.08189050f, -0.00667385f, -0.07804577f, 
    0.00978528f, 0.03561819f, 0.02015241f, 0.00042042f, -0.00221768f, 0.02211005f, 0.02908328f, -0.02949494f, 
    -0.04708703f, -0.02774459f, -0.02463405f, -0.03946875f, -0.04982550f, 0.02185760f, 0.03836824f, -0.03452902f, 
    0.01470997f, 0.01588374f, 0.01368130f, -0.03216870f, -0.00212620f, -0.03714956f, -0.04377618f, -0.00026386f, 
    -0.03393057f, 0.04117472f, 0.03972148f, -0.05230801f, -0.04555701f, 0.00639011f, -0.05605875f, 0.00992359f, 
    0.01403565f, 0.02903669f, 0.01378606f, -0.02961020f, -0.00885396f, -0.03825377f, 0.04171363f, -0.01398914f, 
    0.15437600f, 0.08666094f, 0.29591739f, -0.09623463f, -0.13278301f, -0.27591035f, -0.00593413f, -0.06575726f, 
    -0.07310723f, -0.13003437f, 0.18293227f, 0.37639421f, -0.06838414f, -0.01783324f, -0.21305433f, -0.08102765f, 
    0.05412445f, 0.06752262f, 0.30872181f, -0.22282487f, -0.51489937f, 0.05682676f, 0.00336846f, 0.16128956f, 
    0.08325954f, -0.01297235f, 0.06984829f, 0.12976752f, -0.00130034f, 0.03857453f, 0.10397208f, 0.14626594f, 
    0.01690525f, 0.11386825f, 0.04394706f, 0.08385900f, -0.61855465f, 0.11436588f, 0.21937287f, 0.13932194f, 
    0.22640049f, 0.06476303f, 0.04564135f, 0.03019528f, 0.02259762f, -0.21208204f, -0.15741408f, -0.14824183f, 
    0.16512810f, 0.02615583f, 0.16287409f, 0.12550777f, -0.04864905f, 0.20662421f, 0.37915742f, -0.14405921f, 
    -0.46338981f, 0.03892398f, 0.00890067f, 0.15210691f, 0.00239177f, -0.03584766f, -0.04858734f, 0.15601414f, 
    0.35978785f, 0.01107054f, 0.11674096f, -0.05605489f, 0.09643032f, 0.01492034f, -0.03398785f, 0.02876841f, 
    0.14804862f, -0.29086316f, -0.37890580f, 0.05324203f, 0.07649991f, 0.31542936f, -0.01971536f, -0.01110469f, 
    -0.22421120f, -0.46403146f, -0.18620959f, 0.16762690f, -0.01426644f, -0.27779579f, -0.18645196f, -0.09701458f, 
    -0.06137114f, 0.01420664f, 0.25415114f, -0.28883228f, -0.13742897f, 0.07295758f, 0.09412383f, 0.15892895f, 
    -0.08350465f, -0.03042071f, -0.19034946f, -0.26375395f, -0.29722014f, -0.42527941f, 0.04477232f, 0.08156584f, 
    0.06077757f, 0.20503122f, 0.09749007f, 0.27677330f, 0.12082415f, 0.02455319f, 0.06924549f, 0.00947200f, 
    -0.06908610f, -0.07711473f, 0.06453341f, -0.02334278f, -0.00527814f, 0.32148516f, -0.32604682f, -0.11690194f, 
    0.13129236f, 0.11573549f, 0.14828551f, 0.04789507f, 0.08713173f, 0.04766209f, -0.18749486f, -0.22452778f, 
    -0.13424473f, -0.07009301f, 0.11170157f, -0.09813493f, -0.02964042f, 0.03180693f, 0.07891455f, -0.19933879f, 
    -0.03505294f, 0.08349223f, -0.03456274f, 0.11596932f, 0.07253288f, 0.22358935f, 0.20902582f, 0.09722644f, 
    0.31517050f, -0.34154260f, -0.43401942f, -0.01259557f, 0.09031101f, -0.14207476f, 0.07919950f, -0.20126870f, 
    -0.15132582f, -0.20496243f, 0.19288909f, 0.11786111f, -0.15254547f, -0.10928826f, -0.06688281f, 0.10347879f, 
    0.06626710f, 0.18579961f, 0.09633520f, -0.23357740f, -0.34117573f, -0.24717596f, -0.12755878f, -0.00872743f, 
    0.16539572f, -0.09757332f, 0.30872443f, 0.02464496f, 0.03009189f, 0.12243974f, 0.05094961f, 0.03917376f, 
    0.12915954f, 0.06579501f, 0.09121865f, 0.05362409f, -0.10632686f, -0.28840780f, -0.28879476f, -0.14988311f, 
    0.05701017f, 0.08451077f, 0.19923784f, 0.10562799f, 0.19390360f, -0.34232509f, 0.03829384f, -0.08360449f, 
    -0.26541993f, -0.33732834f, -0.13265927f, -0.02554777f, -0.00605167f, 0.06950147f, -0.49975538f, -0.11539204f, 
    -0.38452005f, -0.10080282f, 0.05646059f, 0.08324779f, 0.08193336f, -0.14398991f, -0.01623212f, -0.17697912f, 
    0.16426511f, 0.03654201f, 0.13838981f, 0.13576855f, 0.30702651f, 0.15340963f, 0.03407561f, -0.03635616f, 
    0.19563110f, -0.21677119f, -0.99683326f, -0.00701388f, 0.06256997f, 0.20089354f, 0.04478916f, 0.09216295f, 
    -0.00245921f, -0.07493891f, 0.01637572f, 0.01227683f, -0.08370357f, 0.02769240f, 0.01639050f, -0.13779204f, 
    -0.09380794f, 0.02397815f, 0.06862606f, 0.06247324f, 0.43813106f, 0.00013148f, -0.14867902f, -0.12729689f, 
    0.22446881f, 0.02804706f, -0.01490893f, -0.28342935f, 0.19591454f, -0.14737140f, -0.09279715f, -0.10091837f, 
    -0.13844037f, -0.00406814f, -0.00718952f, -0.04668588f, -0.24997452f, -0.73804098f, -0.37979653f, -0.18706653f, 
    0.01559986f, -0.12809595f, 0.18110229f, -0.12796803f, -0.13230121f, -0.34751004f, -0.05567672f, -0.11072093f, 
    0.09365132f, -0.18979549f, -0.05924731f, 0.02018724f, 0.03775251f, -0.08422437f, -0.08255510f, -0.27369091f, 
    -0.07670978f, -0.01863982f, -0.02984269f, -0.04809872f, 0.05466909f, 0.02239783f, 0.15790308f, 0.14296190f, 
    0.07861896f, 0.08868621f, -0.18447581f, -0.09027591f, 0.11543335f, 0.03652015f, 0.05766506f, 0.10972162f, 
    -0.17927548f, -0.40876472f, -0.14235103f, 0.05741186f, 0.02300361f, 0.09478146f, -0.11709421f, -0.11450589f, 
    -0.06372887f, -0.13389190f, -0.20849144f, -0.06384230f, -0.00049132f, 0.01340147f, -0.01552228f, 0.03233897f, 
    -0.08813217f, 0.04908694f, -0.24832802f, -0.17616087f, 0.68071568f, 0.25141579f, 0.07341939f, 0.10937858f, 
    0.01044966f, -0.25527674f, 0.23012722f, 0.10451732f, 0.09621270f, 0.05271615f, 0.03161140f, -0.17253332f, 
    -0.03501616f, 0.00650940f, 0.14219283f, 0.16273510f, -0.25060752f, 0.05687284f, 0.13639192f, -0.02014575f, 
    0.07401359f, -0.00469377f, 0.02692678f, -0.05537855f, 0.10707300f, -0.07701930f, 0.18722938f, 0.14178056f, 
    0.03669121f, -0.12826429f, 0.07570561f, 0.14532630f, -0.19952577f, -0.06339512f, -0.13957904f, -0.07404067f, 
    -0.06629609f, 0.05160961f, 0.20972878f, -0.13110647f, 0.09067366f, 0.08565858f, 0.03170894f, 0.10584024f, 
    -0.00060007f, 0.06451884f, -0.21119578f, -0.09143009f, 0.03656105f, 0.04917188f, 0.02549982f, 0.05114925f, 
    0.02351901f, 0.01183306f, 0.14287329f, -0.02142591f, 0.04196065f, -0.03473390f, 0.08984275f, 0.00926748f, 
    0.04039861f, -0.22540615f, -0.23018885f, -0.37866187f, 0.09702778f, 0.09822617f, -0.04359392f, 0.19681315f, 
    -0.21855237f, 0.13832714f, 0.09061833f, 0.34246132f, -0.02189752f, 0.15369686f, -0.05784133f, -0.00717419f, 
    0.07598278f, 0.10597345f, 0.15140757f, 0.02540014f, 0.02810811f, -0.03017319f, 0.14533439f, 0.09284809f, 
    0.02878770f, 0.01169296f, 0.08561517f, -0.16042697f, -0.10345604f, -0.06892341f, 0.10837261f, -0.21128884f, 
    -0.07923009f, -0.06007271f, -0.05542224f, -0.00537265f, 0.13048941f, 0.07909098f, 0.14959134f, 0.00250607f, 
    -0.00332464f, 0.07231978f, 0.00293721f, -0.16119437f, 0.19073161f, -0.17194222f, -0.06469357f, -0.00833489f, 
    -0.13039552f, 0.02528556f, 0.07625124f, 0.00155379f, 0.07075357f, 0.02547296f, 0.05279122f, -0.09573700f, 
    0.24002972f, -0.27174312f, 0.08525216f, -0.06952582f, -0.03693743f, 0.03532412f, 0.04363117f, -0.07743639f, 
    -0.14382742f, -0.15523142f, 0.28969470f, 0.00707782f, -0.01527837f, -0.18389137f, -0.03048365f, -0.16234772f, 
    0.17984425f, -0.07349361f, -0.04565975f, 0.00491507f, -0.09001922f, -0.14809340f, 0.07792939f, 0.19763602f, 
    -0.04745855f, -0.05254265f, -0.11536624f, 0.14652039f, -0.01230949f, 0.04831893f, 0.04970475f, 0.01618079f, 
    -0.28669521f, -0.06180068f, -0.02750905f, 0.03979078f, 0.13867749f, 0.10473236f, -0.11152714f, -0.09568637f, 
    0.07461008f, -0.08253006f, -0.04527550f, -0.03080582f, -0.13499109f, 0.64254153f, 0.05868076f, 0.05887078f, 
    0.05053850f, -0.01564862f, -0.08819122f, 0.37400430f, 0.14535362f, -0.14002275f, -0.22959700f, -0.13453233f, 
    0.05476807f, 0.02371469f, 0.07623886f, 0.00838732f, 0.00417021f, -0.00829914f, -0.06392203f, 0.54929847f, 
    0.17926307f, 0.02672600f, -0.14640296f, -0.06860027f, 0.15673694f, 0.29675665f, 0.12435845f, 0.00998064f, 
    0.33030301f, 0.05373977f, 0.02705389f, -0.05744152f, 0.13211338f, 0.06700680f, 0.14103520f, 0.06042470f, 
    -0.15488224f, -0.04232599f, -0.23700102f, 0.13124749f, 0.02805995f, -0.11639655f, 0.03811509f, -0.01911602f, 
    -0.00727126f, -0.00330057f, 0.21023950f, -0.12173714f, 0.14144608f, 0.04506247f, -0.07496817f, 0.12710890f, 
    -0.04230169f, -0.03518764f, -0.15228765f, -0.07142726f, -0.18737686f, 0.16889885f, 0.14491701f, 0.12739776f, 
    -0.08210533f, 0.03402885f, -0.16444695f, 0.00411611f, -0.21110100f, -0.02290811f, -0.09261848f, -0.12783396f, 
    0.03121986f, 0.11148287f, 0.04804270f, 0.09475254f, -0.15510559f, 0.06179031f, -0.28152129f, 0.10797556f, 
    -0.12328705f, 0.08277892f, -0.04114165f, 0.33538440f, 0.00505026f, -0.03567171f, -0.05371921f, -0.01238558f, 
    0.13753124f, 0.06321278f, -0.04388266f, 0.03999266f, -0.07433108f, 0.03965311f, -0.04239492f, 0.00484093f, 
    0.00725867f, -0.21498570f, -0.07299979f, -0.00792105f, -0.15044238f, -0.20584528f, -0.08176291f, -0.21485591f, 
    -0.11892326f, -0.04433884f, 0.06494457f, 0.04385868f, -0.02638797f, -0.01034248f, 0.02626294f, -0.02299628f, 
    -0.12931269f, -0.35138553f, -0.10559741f, -0.18839574f, -0.06950614f, 0.02275223f, -0.06976321f, -0.17329504f, 
    0.11185545f, -0.22195540f, -0.16726916f, -0.20193186f, -0.07302955f, 0.06911390f, 0.01510003f, -0.03682707f, 
    -0.05140748f, -0.11505496f, 0.31729400f, -0.27738675f, -0.03715979f, 0.03712646f, 0.18674301f, -0.02044975f, 
    -0.16395304f, 0.01990965f, -0.14657563f, 0.09606317f, 0.09206705f, -0.01643978f, -0.04244152f, 0.14395231f, 
    0.19203284f, 0.02634207f, 0.06386670f, -0.12505375f, -0.33470723f, -0.44537765f, -0.26421225f, 0.11852753f, 
    -0.03284425f, 0.01727608f, 0.00273742f, 0.00939180f, -0.00555888f, 0.01954021f, 0.07077616f, 0.11573886f, 
    0.18417336f, -0.01788431f, 0.23679177f, 0.14830497f, 0.01137417f, 0.03559003f, 0.01649836f, -0.00594151f, 
    0.09390207f, -0.15901093f, -0.10118776f, -0.25308007f, -0.06632631f, 0.06370698f, 0.01216739f, -0.42854318f, 
    -0.12267165f, -0.08223813f, 0.05189518f, 0.09335320f, 0.13853599f, -0.00818530f, -0.03215235f, 0.09385412f, 
    0.47535422f, 0.20919251f, 0.24629040f, 0.05468510f, 0.02834909f, 0.00071237f, 0.00153109f, 0.14388971f, 
    -0.00362353f, 0.08943210f, 0.11863048f, 0.11169064f, -0.13766193f, -0.14369361f, -0.22116145f, -0.05300152f, 
    -0.09982107f, -0.07873701f, 0.11445364f, 0.03352322f, -0.01032549f, -0.15781730f, -0.10249085f, -0.10017054f, 
    -0.00187658f, -0.11308116f, -0.01398041f, 0.35120127f, 0.07569695f, 0.31687710f, 0.02147675f, -0.00950964f, 
    -0.00322520f, 0.02599922f, 0.17219339f, 0.13486469f, 0.25895405f, 0.28447270f, 0.17299734f, -0.02312368f, 
    0.04603821f, 0.02812924f, -0.12832338f, 0.02624216f, -0.04381266f, 0.58083940f, 0.39854392f, 0.28790212f, 
    -0.03540009f, -0.02954954f, -0.05939929f, 0.03620617f, 0.23542941f, -0.01471958f, -0.28751644f, -0.23646401f, 
    -0.12908743f, 0.03376803f, 0.00854420f, -0.07922782f, 0.03603132f, -0.00164284f, 0.08340348f, -0.11272047f, 
    -0.01108334f, 0.07931464f, -0.03572370f, 0.11252279f, 0.17463012f, 0.26816520f, 0.08397814f, 0.06183232f, 
    -0.31241906f, -0.35257575f, -0.07752912f, 0.04010419f, 0.06999727f, 0.21322002f, 0.04566357f, -0.09875269f, 
    -0.12777498f, 0.00265274f, 0.00490715f, -0.00012579f, -0.07555286f, -0.03867501f, 0.00137742f, 0.01469526f, 
    -0.10572013f, 0.07572036f, -0.15591121f, -0.55682629f, -0.07621701f, -0.04220423f, -0.07248131f, 0.07126269f, 
    0.17288055f, 0.06027347f, 0.07750206f, 0.15869881f, 0.06782068f, 0.01183432f, -0.04216615f, 0.03144496f, 
    0.02970064f, 0.09930346f, 0.01030216f, 0.01752232f, -0.20133288f, 0.10095510f, -0.20051377f, -0.12367961f, 
    0.18943906f, -0.19003509f, 0.27291435f, -0.11469287f, -0.03514506f, 0.37330204f, 0.09118652f, 0.08382704f, 
    0.01679812f, -0.22028472f, -0.04422677f, 0.05043793f, 0.01347662f, 0.06092272f, -0.39154872f, -0.26063865f, 
    -0.17169695f, 0.07704134f, -0.02455659f, -0.12967961f, 0.08433744f, -0.05195450f, -0.01646384f, -0.08133293f, 
    -0.17968920f, -0.11465285f, 0.05341149f, 0.05153766f, 0.01744600f, 0.04840912f, 0.07393272f, -0.01701145f, 
    0.32589680f, 0.23899160f, 0.18510969f, 0.05954286f, -0.16052717f, -0.10917468f, 0.09985057f, 0.00619707f, 
    0.04514607f, -0.33701944f, -0.19250868f, 0.06163074f, 0.02267332f, -0.05341662f, -0.15736170f, 0.05738609f, 
    -0.07530877f, -0.02082878f, -0.28257334f, -0.31970918f, -0.34788293f, -0.06494526f, 0.04344631f, 0.09583958f, 
    -0.03061197f, -0.07323546f, 0.26457515f, -0.16672465f, -0.43916589f, 0.19635163f, 0.10275796f, 0.03121768f, 
    -0.11215725f, 0.03943065f, -0.11124621f, -0.10970679f, -0.53789866f, -0.35427496f, -0.34555745f, 0.07092293f, 
    0.21047458f, -0.03858212f, 0.09496579f, -0.07125942f, 0.06446315f, -0.20112114f, -0.16475524f, -0.34483176f, 
    -0.04677865f, -0.04244394f, -0.20471102f, 0.07515179f, -0.06474850f, -0.13362740f, 0.20478255f, 0.02538488f, 
    0.14690638f, -0.16946983f, -0.10247255f, -0.03990790f, -0.09102925f, -0.01267647f, 0.09179645f, 0.19426095f, 
    -0.17213239f, -0.32327536f, -0.07044122f, 0.05031947f, 0.23606509f, 0.12453211f, 0.01696934f, 0.04996730f, 
    -0.07030156f, -0.03881717f, -0.33324674f, -0.15875416f, -0.01843005f, -0.05717852f, -0.05570517f, 0.03640189f, 
    0.06333486f, -0.05449340f, 0.04062809f, -0.09515455f, 0.02955741f, 0.00140533f, 0.01330105f, 0.10324211f, 
    0.09668351f, -0.04152098f, -0.23225340f, -0.77488440f, 0.02025184f, 0.18482126f, -0.01320338f, 0.36372283f, 
    0.07787731f, -0.23493466f, 0.06129499f, -0.00722851f, 0.01237053f, -0.01184298f, 0.01338465f, -0.04748555f, 
    -0.03036029f, 0.16626188f, -0.08264337f, 0.14952660f, -0.18758890f, -0.01942388f, 0.06575439f, -0.07024742f, 
    0.05451910f, 0.08372077f, 0.04954039f, -0.08786590f, 0.08618384f, 0.09982137f, -0.02506976f, 0.30579120f, 
    -0.00463569f, -0.02041120f, 0.06919877f, 0.01490124f, -0.11752569f, 0.07472764f, 0.11580707f, 0.00660513f, 
    0.22633536f, -0.03957820f, 0.15080741f, -0.20227487f, 0.03056545f, 0.00779033f, 0.12213999f, 0.05489602f, 
    0.07077433f, 0.13253944f, -0.00677944f, -0.11014040f, -0.13226824f, -0.19620751f, 0.07052177f, -0.05066875f, 
    0.00127526f, 0.10009402f, 0.14451669f, 0.14343472f, -0.09496545f, -0.10214382f, 0.04123596f, 0.07196455f, 
    -0.05492926f, -0.08737288f, -0.16318770f, -0.00155616f, -0.11843064f, 0.04538940f, -0.31995109f, 0.11956242f, 
    -0.10252158f, 0.01982577f, -0.06127414f, 0.04494069f, -0.00424247f, -0.16339573f, 0.03304195f, -0.13280575f, 
    0.16099672f, 0.00941873f, 0.03675162f, -0.17563301f, -0.21049176f, 0.09696904f, 0.01995640f, -0.09573339f, 
    -0.15096591f, 0.04518412f, -0.03845918f, -0.04493689f, -0.07149858f, -0.14417599f, -0.01806101f, -0.00594730f, 
    0.06371427f, 0.01421330f, 0.03630875f, -0.06102701f, 0.05426104f, 0.17121910f, 0.07181706f, 0.09634030f, 
    0.02862815f, 0.00819272f, 0.03075249f, 0.15908343f, 0.20989557f, -0.14044601f, 0.02238369f, 0.14194900f, 
    0.07376453f, -0.01380479f, 0.01496704f, -0.08345217f, 0.04930064f, 0.02335668f, 0.01834882f, 0.00054816f, 
    0.07277589f, 0.12009735f, -0.05150160f, 0.05350071f, -0.17902504f, -0.06924916f, 0.04887932f, 0.00712878f, 
    0.11725073f, -0.47210184f, 0.21125554f, -0.07258938f, 0.04116819f, 0.24927118f, -0.09070370f, -0.21546943f, 
    0.01077748f, -0.13731834f, 0.09706931f, -0.13373025f, 0.03514038f, -0.14214781f, -0.03503336f, -0.15553021f, 
    0.04260958f, 0.06738311f, -0.17596154f, -0.01445268f, 0.05385738f, 0.08192601f, 0.06346700f, -0.03505743f, 
    -0.10693089f, -0.23220040f, 0.13379751f, -0.09300831f, 0.06974801f, 0.10688832f, 0.13265587f, 0.05641834f, 
    0.01192962f, -0.12640826f, -0.12255234f, -0.10564381f, -0.32383698f, 0.15432127f, 0.01344669f, 0.00299779f, 
    -0.00699863f, 0.06754091f, 0.04996445f, 0.19912033f, 0.00661220f, -0.01627436f, -0.17469504f, 0.14269608f, 
    0.06616129f, -0.05696810f, 0.22573216f, 0.02777494f, 0.01971379f, 0.15616077f, -0.12786742f, 0.25122550f, 
    -0.07305753f, -0.14425282f, -0.08192501f, -0.19079721f, 0.17411643f, 0.15887426f, 0.10181522f, 0.09171043f, 
    -0.04712277f, 0.06382971f, 0.13720071f, -0.10089674f, 0.35152525f, -0.05515170f, 0.13655850f, -0.17357960f, 
    0.16165073f, 0.16768126f, -0.05808798f, 0.01148907f, -0.12097563f, -0.06361663f, 0.02421650f, 0.05352996f, 
    0.07224630f, 0.07058308f, -0.02086682f, 0.05273079f, -0.02197481f, -0.02605645f, -0.23624536f, 0.01167446f, 
    -0.00428062f, 0.08817506f, -0.00297865f, -0.36862370f, -0.22323687f, -0.03851452f, 0.02792061f, 0.12998956f, 
    -0.27189070f, 0.16267331f, 0.14490302f, -0.05991298f, 0.06069661f, -0.00081998f, 0.29467857f, -0.32599309f, 
    0.16367190f, -0.11619987f, 0.13157429f, 0.03776233f, 0.04614837f, -0.31723568f, 0.22193581f, -0.11248638f, 
    -0.03980790f, 0.23024024f, -0.07241753f, -0.00491533f, 0.11263006f, 0.01773877f, -0.09984837f, -0.20005846f, 
    -0.07379118f, -0.03739118f, 0.16778301f, -0.04797146f, -0.06181519f, -0.00186061f, -0.34110403f, -0.07723172f, 
    0.16667746f, 0.02231745f, 0.04314784f, -0.05981406f, -0.04716845f, -0.09814643f, -0.03218768f, -0.31738999f, 
    -0.08242387f, 0.04909139f, 0.06461179f, 0.14519958f, 0.05127409f, 0.07567345f, -0.11750975f, 0.11635378f, 
    -0.18322550f, 0.42713633f, 0.06831767f, -0.02240959f, -0.23266512f, -0.30742475f, -0.01777117f, 0.02773036f, 
    -0.00224142f, -0.01843352f, 0.20899279f, -0.03944074f, 0.11156996f, -0.16541088f, -0.11540968f, 0.12366870f, 
    0.08620335f, 0.09421489f, -0.47283310f, -0.40262467f, -0.12030791f, 0.02938037f, -0.05443738f, 0.22175291f, 
    0.07632547f, -0.11928569f, 0.07007406f, -0.16793472f, 0.04396502f, -0.07961513f, 0.07356367f, -0.01297084f, 
    0.10264055f, 0.12152433f, 0.11465829f, 0.21027687f, -0.15801226f, -0.07061387f, 0.16269957f, 0.00268968f, 
    -0.05140944f, 0.15000170f, 0.00435459f, -0.04473084f, -0.00082676f, -0.10636525f, 0.01708097f, -0.00634035f, 
    -0.09218505f, 0.06598400f, -0.04250419f, 0.00089331f, -0.03452476f, -0.04368047f, 0.15890396f, 0.16483943f, 
    0.36928925f, -0.07492936f, 0.03741971f, 0.00811504f, 0.03847305f, 0.16734579f, -0.14063026f, -0.01068015f, 
    0.26947200f, 0.16572917f, 0.00645131f, -0.16361143f, -0.03234325f, -0.00527668f, 0.07290798f, 0.15839732f, 
    -0.11842430f, 0.07911864f, -0.05272194f, -0.01086107f, 0.07818054f, 0.06139505f, 0.05048348f, 0.01040833f, 
    -0.01437509f, -0.08797346f, 0.11666524f, 0.07804281f, -0.15602498f, 0.01710588f, -0.08491961f, 0.04919082f, 
    0.04876458f, 0.02754532f, -0.02766916f, 0.10642178f, -0.15190390f, -0.00460844f, 0.20068234f, 0.02382970f, 
    0.21073470f, 0.02932446f, 0.04834564f, 0.07430791f, -0.38382408f, -0.23395251f, -0.02237941f, -0.09803753f, 
    -0.06510804f, -0.01473421f, -0.04054777f, 0.13768078f, -0.21512000f, -0.09095987f, 0.01104479f, 0.09685034f, 
    -0.02124685f, 0.09866340f, 0.08395797f, 0.03177367f, 0.09371471f, 0.08084326f, -0.11616835f, -0.06898706f, 
    0.05875939f, -0.01989585f, -0.01314267f, 0.00844132f, 0.16319437f, 0.00166140f, 0.09396088f, 0.24340616f, 
    0.28006357f, -0.02848263f, 0.08366287f, -0.05955897f, 0.07940431f, 0.03986041f, -0.00924933f, 0.03322311f, 
    0.02678861f, 0.17880793f, -0.02990862f, 0.00669669f, -0.18111135f, 0.01084364f, -0.05420300f, 0.00171554f, 
    -0.01387444f, -0.59452891f, 0.10152029f, -0.25168499f, -0.12715714f, 0.06640416f, -0.03322357f, -0.15991029f, 
    -0.03767623f, -0.00032254f, 0.16502278f, 0.08777151f, -0.02206111f, -0.04501575f, -0.03267594f, 0.13145871f, 
    0.03449515f, 0.19088003f, -0.46263236f, -0.05233885f, 0.21916249f, -0.08056715f, 0.23044093f, -0.19597127f, 
    -0.00862584f, -0.06524700f, -0.08883147f, -0.14779025f, 0.02339916f, 0.15155345f, 0.00339704f, 0.09875914f, 
    -0.05447932f, -0.01697130f, -0.00332723f, 0.09505354f, -0.31626114f, -0.12187216f, 0.01290484f, 0.13168550f, 
    0.19085337f, 0.14996894f, -0.03959240f, 0.13964221f, -0.06909464f, 0.02617151f, 0.23717043f, 0.28139260f, 
    -0.06459889f, -0.05877031f, -0.07497081f, 0.03315207f, 0.15876353f, -0.02716323f, -0.10696059f, 0.13536161f, 
    -0.29833999f, 0.00914633f, 0.22672291f, -0.08494437f, -0.00899211f, 0.10100917f, -0.09082779f, -0.18135536f, 
    0.20454903f, 0.27590930f, 0.06408251f, 0.01247722f, -0.16563106f, -0.03705779f, -0.01083017f, -0.01756535f, 
    0.22448926f, -0.00651042f, 0.24389207f, 0.13903704f, 0.12692375f, -0.23054674f, -0.01001511f, 0.02682647f, 
    -0.02222851f, 0.12700444f, 0.21250564f, -0.01521433f, -0.01435663f, 0.12021048f, -0.10697189f, 0.24341235f, 
    -0.00945732f, 0.05526296f, 0.12233684f, 0.13356709f, -0.14986500f, 0.04732845f, -0.37649804f, -0.04811909f, 
    -0.14222279f, -0.14548564f, -0.08056930f, -0.28191897f, 0.19712752f, 0.25644511f, -0.01038798f, -0.15381446f, 
    -0.14369622f, -0.10030001f, -0.04407319f, 0.14794387f, 0.17806178f, -0.03466404f, -0.18956755f, 0.06121055f, 
    -0.33428931f, 0.00400929f, -0.03628469f, 0.00234238f, -0.09571062f, -0.24191982f, 0.24203171f, -0.06366715f, 
    0.07589296f, -0.33341187f, -0.05309707f, 0.01484644f, -0.11857074f, 0.04327553f, -0.17328790f, -0.13880697f, 
    0.04280896f, 0.02153497f, -0.08402634f, -0.07451151f, 0.04431492f, 0.07663833f, 0.02326057f, -0.18999714f, 
    -0.16070941f, -0.05506977f, -0.00869174f, 0.06705905f, -0.06345212f, 0.00837519f, -0.01182923f, 0.13053504f, 
    0.23378247f, 0.13312350f, 0.17131354f, 0.07647005f, 0.00008999f, 0.04725566f, -0.00796526f, 0.05005231f, 
    0.03047315f, -0.05413723f, 0.04033368f, 0.02821492f, 0.03769752f, 0.00462030f, -0.04839241f, -0.04634319f, 
    -0.05269362f, 0.10788670f, -0.38561082f, 0.28273737f, 0.10877179f, 0.02133703f, -0.10913577f, 0.15879895f, 
    0.02450304f, 0.12526609f, -0.03024951f, -0.11963347f, 0.00225603f, 0.03900907f, 0.03838233f, -0.04273666f, 
    -0.03412087f, -0.17220309f, -0.15155895f, -0.23562612f, -0.09912261f, -0.10289011f, -0.17915580f, 0.02370479f, 
    0.01979732f, -0.04342750f, 0.01581385f, 0.03161150f, 0.00391077f, 0.04095093f, 0.04204915f, -0.18475039f, 
    -0.03948752f, 0.00317454f, -0.17057358f, 0.02367548f, 0.05167649f, 0.17119490f, 0.09773403f, 0.14949590f, 
    -0.20156379f, 0.02677168f, 0.02752835f, -0.00274970f, 0.10987932f, 0.04123611f, 0.03641757f, 0.00253039f, 
    -0.05541136f, -0.13088819f, 0.15154640f, 0.04569656f, -0.19024664f, 0.01991697f, -0.09616750f, -0.14304151f, 
    -0.02013074f, -0.00466220f, 0.00896510f, -0.05755651f, 0.06092636f, 0.01715032f, 0.05080451f, 0.01912653f, 
    -0.14812878f, 0.13960071f, 0.18154477f, -0.04175264f, 0.04480476f, 0.03232663f, 0.20463043f, -0.00234448f, 
    -0.12607282f, 0.03107890f, 0.15230361f, 0.01791427f, -0.00611446f, -0.00580452f, -0.04803430f, -0.08807317f, 
    0.00403365f, 0.03908877f, -0.09562264f, -0.05986873f, 0.27257082f, -0.06018981f, 0.07171790f, 0.02487814f, 
    -0.10588612f, 0.23025930f, 0.10575669f, 0.06699963f, -0.00406831f, -0.04940964f, 0.00637478f, 0.01684674f, 
    0.04798351f, 0.02699701f, 0.00940032f, -0.08024838f, -0.12004049f, -0.04651946f, 0.17357785f, -0.02347679f, 
    -0.03762746f, -0.06086876f, -0.03604819f, 0.18388164f, 0.13374500f, -0.04654248f, 0.01203480f, -0.04040832f, 
    -0.17839107f, 0.07545357f, 0.03790931f, -0.08699226f, -0.03905910f, -0.09360475f, -0.17303009f, -0.12813319f, 
    -0.21817271f, -0.00896146f, -0.06982576f, -0.15132910f, 0.15337814f, 0.08669294f, -0.06277714f, 0.02796175f, 
    -0.00753031f, 0.29715052f, -0.12040681f, 0.16725491f, -0.03953595f, 0.23833370f, -0.11853764f, 0.09813095f, 
    0.07018737f, 0.09819736f, 0.01401950f, -0.17270808f, 0.19840460f, 0.13043246f, 0.02423310f, -0.03299417f, 
    -0.10478611f, 0.06002211f, 0.18084058f, 0.04018555f, 0.20672642f, -0.00532829f, 0.10046642f, 0.10649056f, 
    0.00377686f, 0.05777870f, 0.21814260f, 0.07769476f, -0.13466765f, -0.10150449f, 0.02021991f, 0.05010248f, 
    0.09106717f, -0.01255212f, -0.34763908f, -0.27706316f, -0.18216486f, -0.08935688f, -0.00581032f, -0.11802818f, 
    0.04345862f, 0.09425572f, -0.04783750f, 0.00309310f, -0.21949366f, -0.09690613f, 0.07074362f, -0.12345181f, 
    0.00360401f, 0.06774145f, -0.00737238f, -0.04207399f, -0.07827386f, 0.01988704f, -0.00810466f, 0.08149049f, 
    -0.06663137f, 0.08058296f, 0.16778524f, -0.02342331f, -0.23837274f, 0.03243730f, -0.10511979f, -0.06834436f, 
    0.09007739f, -0.04248129f, -0.00050641f, 0.07703448f, -0.24339829f, -0.00616489f, -0.08992458f, -0.06233124f, 
    0.05615852f, 0.19085355f, -0.07418284f, -0.01766835f, -0.10095790f, -0.00557548f, -0.02464003f, -0.02728812f, 
    -0.01086454f, 0.02366813f, -0.02119553f, -0.05950133f, 0.18130837f, -0.02638684f, -0.09982500f, -0.09682973f, 
    -0.25013345f, -0.08895818f, 0.03094746f, 0.14647432f, -0.11405111f, 0.03437855f, 0.24182330f, 0.04217150f, 
    -0.02205131f, 0.30169874f, 0.13881424f, 0.18717091f, -0.02571663f, -0.02164783f, 0.08126507f, 0.05681586f, 
    -0.01376093f, 0.17283629f, -0.06957643f, 0.05505670f, 0.12202040f, 0.26941836f, -0.15567112f, 0.01970913f, 
    0.07589068f, 0.16506344f, -0.05874828f, 0.23302649f, 0.02642166f, -0.00405804f, 0.00136046f, -0.06653327f, 
    -0.05046178f, 0.09846350f, -0.08110339f, -0.03031956f, 0.13675094f, 0.00446239f, 0.06187148f, 0.01845023f, 
    -0.00463880f, 0.11170653f, 0.10676139f, 0.11704616f, 0.29266819f, 0.12744853f, 0.01398367f, 0.00292774f, 
    -0.02869683f, -0.08081948f, 0.00425858f, -0.03713792f, 0.10664656f, -0.07575698f, -0.13727468f, 0.05672152f, 
    0.21154350f, 0.30984631f, 0.33441663f, -0.22107361f, -0.05677153f, -0.11913808f, -0.08754916f, 0.05516552f, 
    -0.17673177f, 0.17531921f, 0.10038848f, 0.28994119f, -0.03445918f, -0.07707677f, -0.11878215f, 0.00048636f, 
    0.00476643f, -0.03610153f, -0.37005845f, -0.01068727f, -0.11904160f, -0.00214908f, -0.16499338f, 0.04297268f, 
    -0.05756629f, 0.04689270f, 0.04307592f, -0.01007112f, -0.01318619f, 0.04543426f, 0.03334283f, 0.01103027f, 
    -0.00072810f, -0.14405447f, 0.10402326f, -0.22077060f, -0.01538732f, -0.21123905f, -0.02125705f, 0.09502025f, 
    0.13245378f, -0.00437646f, 0.05020013f, -0.02792334f, 0.04237203f, -0.00235975f, 0.03079391f, 0.02270892f, 
    0.06971869f, 0.14689092f, -0.12081935f, -0.00971974f, 0.10539541f, 0.14708686f, 0.04357614f, -0.03641433f, 
    0.17043294f, -0.07841772f, -0.00119849f, -0.10204816f, -0.04923950f, -0.10466834f, -0.05288062f, 0.07598427f, 
    0.13143589f, 0.21671352f, 0.19367717f, 0.11638982f, -0.14651763f, -0.00328651f, -0.11475804f, -0.21972090f, 
    -0.13918824f, 0.08503693f, -0.03352667f, 0.03785965f, 0.07129575f, -0.06140294f, 0.09279512f, -0.09323625f, 
    -0.17619854f, -0.13699244f, -0.05371798f, -0.11484866f, -0.17415734f, -0.06269951f, -0.05074970f, 0.03458274f, 
    -0.05449490f, 0.04523326f, 0.02447817f, 0.11096743f, -0.00432582f, 0.09754688f, 0.06616133f, -0.16373268f, 
    -0.02318782f, -0.22337843f, -0.27513492f, -0.08155349f, 0.04945607f, -0.15397620f, 0.08718071f, 0.10476973f, 
    0.01205623f, 0.06908146f, 0.15168634f, 0.10740075f, 0.05388273f, 0.00660959f, 0.07493313f, 0.02060561f, 
    -0.00952101f, 0.14803536f, 0.09039824f, 0.14638227f, -0.06325749f, 0.03641818f, 0.06064701f, 0.02987041f, 
    0.08695301f, -0.10099097f, 0.01422005f, 0.12057691f, 0.12576039f, 0.16618221f, 0.03312042f, -0.02215013f, 
    0.00145634f, 0.10237836f, 0.12444524f, -0.15412821f, -0.03483914f, -0.07203376f, -0.07287240f, 0.17423305f, 
    -0.21244857f, 0.04493070f, -0.06594370f, 0.00301145f, -0.03376937f, 0.15914609f, -0.02902830f, 0.13887936f, 
    -0.04626902f, -0.13182902f, 0.20651749f, 0.06816800f, -0.23091686f, 0.06953217f, -0.10450505f, -0.00564760f, 
    0.25181407f, 0.03400699f, 0.11018647f, -0.02559232f, 0.04176400f, 0.09476391f, -0.05982775f, 0.02943566f, 
    0.12577191f, -0.08541166f, 0.00291595f, 0.08445219f, -0.07046645f, -0.30411473f, 0.14614929f, -0.14365976f, 
    0.05051884f, 0.11534857f, 0.15265304f, 0.00923038f, -0.06600271f, 0.00364717f, 0.06852496f, 0.06995954f, 
    0.06326492f, 0.06374367f, -0.01513318f, -0.07319898f, 0.01382750f, -0.12400459f, 0.05831513f, -0.00916652f, 
    -0.06887870f, 0.07227285f, 0.06676434f, -0.27725029f, 0.15591592f, -0.18862008f, -0.22712532f, -0.18328820f, 
    0.10725669f, 0.08989502f, 0.00553233f, -0.03333231f, -0.00828988f, 0.07023043f, -0.05274133f, 0.10593984f, 
    -0.01208239f, 0.04004373f, 0.06373337f, -0.09076767f, -0.05394299f, -0.33176476f, -0.08718615f, -0.01058062f, 
    0.07972949f, 0.00575704f, 0.01654431f, -0.13701244f, 0.02741254f, -0.03339792f, 0.12205905f, -0.07445071f, 
    -0.00844984f, 0.15174092f, -0.06898100f, 0.20973106f, 0.11281084f, -0.03771830f, 0.02531099f, 0.07043450f, 
    0.14288819f, 0.08563717f, 0.05704160f, 0.09060863f, 0.03668074f, 0.01163670f, -0.13748850f, -0.10097933f, 
    -0.24971978f, -0.15096678f, 0.00304383f, 0.08047459f, 0.19960967f, -0.02522419f, -0.08934397f, -0.05676400f, 
    -0.13189971f, 0.08510806f, 0.07060976f, 0.06429450f, 0.17950030f, 0.07165747f, -0.00678801f, -0.02531939f, 
    -0.05246921f, -0.11960204f, 0.02507587f, -0.15961868f, -0.07278638f, -0.27380493f, -0.11298271f, -0.02541973f, 
    0.08372422f, -0.04487273f, -0.08337333f, 0.20064789f, 0.19680186f, -0.13781269f, -0.13226463f, -0.09796592f, 
    -0.24469404f, -0.01153423f, -0.09989674f, -0.12018324f, 0.15706490f, -0.04376546f, 0.01141214f, -0.11109492f, 
    0.04788100f, 0.08746757f, 0.02520037f, 0.18345012f, 0.19492555f, 0.18401466f, 0.14780627f, -0.08511599f, 
    -0.06720885f, -0.09984117f, 0.12411309f, 0.37051249f, 0.01187684f, 0.00077248f, -0.07655419f, 0.07834759f, 
    0.17847851f, -0.25416332f, 0.19172850f, -0.22753827f, -0.05710119f, 0.02406354f, -0.00143814f, 0.01815884f, 
    -0.12636389f, 0.16727296f, -0.07186481f, -0.08716714f, -0.04735628f, -0.07091901f, 0.13931876f, -0.01243110f, 
    -0.04966355f, -0.04144766f, 0.06494152f, -0.56561041f, -0.44466448f, 0.06129776f, -0.05399362f, -0.18149225f, 
    -0.01209090f, 0.17288055f, 0.10069076f, -0.24904278f, -0.29082245f, 0.02699150f, -0.06793060f, -0.09918757f, 
    -0.04709624f, 0.01422630f, -0.00226862f, 0.07635448f, 0.02347463f, 0.23743325f, 0.20703432f, -0.21883929f, 
    0.01591454f, -0.14246589f, 0.04012138f, 0.08333463f, -0.12703142f, 0.16072208f, -0.27722442f, -0.39863673f, 
    -0.01802609f, 0.01037009f, 0.07554528f, 0.08647435f, -0.03266512f, -0.11749763f, -0.00490987f, -0.16049773f, 
    0.01055760f, 0.00797900f, 0.03060422f, -0.04447859f, -0.10743424f, 0.06925344f, 0.22998153f, 0.14403826f, 
    -0.02445011f, -0.04337414f, 0.02101491f, -0.12605870f, -0.10266306f, -0.03692985f, 0.01728396f, 0.24654199f, 
    -0.13527097f, -0.46767029f, -0.25187957f, 0.17132626f, -0.02071504f, -0.09932426f, -0.10651724f, 0.09083799f, 
    0.06984159f, 0.31220773f, 0.40848401f, 0.41191524f, -0.10925000f, 0.04408148f, 0.36182770f, 0.00231136f, 
    0.03072819f, 0.18860608f, -0.08643798f, 0.00046706f, -0.33199951f, -0.24434851f, 0.22494459f, -0.01889834f, 
    -0.09499412f, 0.00870200f, -0.02433673f, -0.25204009f, 0.02558468f, 0.03196074f, 0.14373255f, -0.14580889f, 
    0.03442928f, 0.16191275f, -0.01535694f, 0.06061095f, -0.06555323f, -0.11189279f, 0.03147383f, -0.02246165f, 
    -0.13113688f, 0.02700384f, -0.07791419f, -0.14743423f, -0.05469456f, -0.15949976f, -0.74804175f, -0.75415081f, 
    0.11448175f, -0.13210410f, 0.09500108f, -0.09466054f, 0.00626382f, 0.06253640f, 0.08384030f, 0.17807569f, 
    0.23628861f, 0.00993067f, 0.03148113f, -0.07647207f, -0.04911408f, 0.11502518f, 0.06160927f, 0.20181179f, 
    0.19191116f, 0.14151987f, -0.10718295f, 0.08425320f, -0.03565240f, -0.03990223f, 0.04398004f, 0.11418071f, 
    0.31248939f, -0.18663424f, -0.15842520f, -0.05351484f, 0.06864351f, 0.08088005f, 0.16985457f, -0.00297118f, 
    -0.02601407f, -0.00212261f, -0.30911142f, -0.21542446f, -0.00746202f, 0.03061353f, 0.03299408f, 0.06518696f, 
    0.00197876f, 0.03873510f, -0.07393619f, -0.01552877f, 0.19088781f, -0.22401047f, -0.00144913f, 0.12832905f, 
    0.00309988f, 0.01125101f, -0.15812197f, -0.40261266f, -0.04037667f, -0.24958670f, -0.27694938f, -0.04338493f, 
    -0.03566136f, -0.19716617f, -0.21232556f, -0.16181451f, 0.10478428f, -0.52934682f, -0.24614547f, -0.15921128f, 
    -0.27804199f, 0.28889149f, -0.04050041f, 0.09279021f, 0.07526313f, 0.22237796f, 0.27658224f, 0.33700746f, 
    -0.01054175f, 0.09386928f, -0.02147391f, 0.12376774f, 0.03460664f, 0.01273704f, -0.31809410f, -0.02169081f, 
    -0.04308121f, -0.04999422f, 0.04435949f, 0.26058000f, 0.04632770f, 0.18130535f, 0.07035947f, -0.17623954f, 
    -0.09746622f, 0.01393253f, -0.01999035f, -0.03528261f, -0.06200024f, 0.01138894f, 0.08386444f, -0.09783390f, 
    -0.10986476f, -0.03185091f, -0.04047218f, -0.04407653f, 0.14484450f, -0.07725699f, -0.02350487f, -0.06275032f, 
    0.04207082f, 0.02915742f, 0.18869849f, 0.22114061f, -0.01387437f, 0.06348185f, -0.01473701f, 0.01840024f, 
    0.05173373f, 0.07393770f, 0.06666604f, -0.27696705f, 0.21001282f, 0.05904406f, -0.11732265f, -0.07183950f, 
    0.09867739f, -0.06601810f, -0.08611670f, 0.04640033f, -0.04347378f, 0.18038271f, -0.09388535f, 0.10670494f, 
    -0.01863009f, 0.17211014f, 0.17193393f, -0.06521489f, -0.01339158f, -0.02162309f, 0.28002617f, 0.19965023f, 
    -0.05987079f, -0.05783477f, 0.15052378f, 0.10935020f, -0.10479908f, -0.03849929f, -0.01646623f, 0.23099808f, 
    -0.08870064f, 0.08612972f, 0.05037742f, 0.14086667f, -0.10079397f, 0.09258126f, 0.26494160f, -0.01435247f, 
    -0.18267411f, -0.02094482f, -0.06214523f, -0.18705696f, 0.02770738f, 0.01303348f, 0.03921856f, 0.23101385f, 
    0.23431666f, 0.15623681f, -0.09639350f, 0.09504518f, -0.05030346f, 0.03832388f, -0.01047850f, -0.03420861f, 
    -0.21426870f, -0.23138233f, 0.26628634f, -0.06425087f, -0.04602101f, 0.02356387f, -0.07456817f, -0.00650786f, 
    0.08961631f, -0.10159609f, -0.13600798f, 0.22447486f, -0.07923119f, -0.03154984f, 0.01722696f, -0.06626646f, 
    -0.08005469f, -0.03927454f, -0.25513783f, 0.15306775f, -0.01053094f, 0.22807667f, -0.02090020f, 0.06764787f, 
    0.14997831f, 0.21841782f, -0.09264264f, -0.09191021f, -0.15415393f, -0.00849584f, -0.05748393f, -0.09724650f, 
    -0.08129694f, -0.20558397f, -0.06564576f, -0.22948311f, 0.10674208f, 0.03210758f, 0.11739507f, 0.07656578f, 
    0.00192232f, -0.04436787f, -0.00802838f, 0.03780096f, 0.06797680f, 0.08909769f, 0.16629976f, 0.29030719f, 
    0.01828348f, 0.11061270f, -0.00639354f, 0.14505477f, -0.07268710f, 0.11119984f, 0.21689479f, 0.05308228f, 
    -0.05871756f, -0.04592639f, -0.01100667f, -0.15883830f, 0.07371664f, -0.20561942f, 0.10825250f, -0.01648128f, 
    0.11958037f, 0.12696123f, 0.06522977f, 0.00142105f, -0.05620368f, -0.10000173f, -0.07183514f, -0.30403361f, 
    -0.02805213f, -0.02249872f, -0.03563470f, -0.18720064f, -0.10025746f, -0.06678762f, -0.18089963f, -0.02819642f, 
    -0.06707381f, -0.03030934f, -0.06776929f, 0.31433043f, 0.29849601f, -0.02230258f, -0.09087420f, 0.05905887f, 
    -0.10303793f, -0.10717110f, 0.03055084f, -0.08490944f, 0.03062206f, 0.03998017f, -0.10287038f, -0.19375739f, 
    -0.10260417f, -0.15240906f, 0.06457769f, -0.01030786f, 0.22439273f, -0.06442018f, 0.12661989f, 0.06395392f, 
    -0.02998261f, 0.11262260f, 0.06519087f, -0.00346737f, -0.09563689f, -0.06762370f, -0.06407840f, 0.01783265f, 
    -0.00077282f, 0.08121351f, -0.04472149f, -0.05286512f, 0.03553289f, 0.02795758f, 0.29984298f, -0.02304257f, 
    -0.04870805f, -0.02398560f, -0.11243654f, 0.05558712f, -0.06737730f, 0.03117095f, 0.06460348f, -0.03432085f, 
    0.26492521f, 0.13447730f, -0.09251086f, 0.05020267f, 0.03815133f, -0.13748351f, -0.07586957f, 0.04725639f, 
    -0.09803975f, 0.13252477f, 0.08066440f, -0.05225480f, -0.00997764f, 0.10959871f, 0.04159382f, -0.10811458f, 
    -0.07910977f, 0.48171484f, 0.25876254f, 0.04557239f, -0.02575570f, 0.06481474f, 0.00086378f, -0.03783302f, 
    0.12539510f, -0.03696297f, -0.21019045f, -0.15431768f, 0.02360372f, 0.15492451f, 0.03734996f, 0.01599003f, 
    -0.00434931f, -0.08632003f, 0.05282518f, -0.27722353f, 0.11046036f, 0.11209564f, -0.06046988f, -0.04403606f, 
    0.03732697f, -0.04752123f, 0.27029553f, 0.11287250f, -0.09145681f, -0.00386976f, 0.05053973f, -0.00120387f, 
    -0.05613986f, 0.00913794f, -0.05133603f, 0.03103078f, 0.05189921f, 0.00657643f, -0.11287219f, 0.00351670f, 
    0.14295661f, -0.10985002f, -0.00153414f, 0.03576078f, -0.01753038f, 0.03033013f, 0.05372290f, 0.35288584f, 
    0.11336454f, 0.12644716f, 0.03959544f, -0.00023313f, -0.02302453f, 0.09751371f, 0.11738146f, 0.24689016f, 
    0.01392567f, -0.10927335f, -0.09134319f, -0.14320533f, -0.05260828f, -0.03762677f, -0.14087017f, 0.10167252f, 
    0.12241404f, 0.02082616f, -0.00228797f, 0.04762328f, 0.14982787f, 0.09513141f, 0.04563688f, -0.17829292f, 
    0.22880237f, 0.20249541f, 0.16886987f, 0.06969303f, -0.00810082f, -0.13542737f, -0.02384887f, 0.03281353f, 
    0.04053574f, 0.08467372f, -0.04276547f, 0.05009277f, 0.13376662f, -0.07640098f, 0.04427297f, -0.22062071f, 
    -0.21669832f, -0.28087094f, -0.28910497f, 0.12630217f, 0.20153090f, -0.12663361f, 0.09854880f, 0.01838217f, 
    -0.07047895f, 0.11848511f, 0.22067958f, 0.14443424f, 0.04762996f, -0.10496653f, 0.07198351f, -0.04138475f, 
    -0.05141575f, 0.14910038f, 0.03534652f, -0.17388386f, -0.09048983f, 0.32094660f, 0.15379898f, -0.06477975f, 
    0.13438261f, -0.04434131f, -0.10108138f, 0.06943969f, 0.22880159f, -0.17539802f, -0.09255546f, 0.32867509f, 
    -0.05072535f, 0.06254726f, 0.01314077f, -0.20350768f, 0.06866380f, 0.12941781f, 0.11005905f, 0.11591569f, 
    -0.01081166f, -0.01053874f, 0.04117041f, 0.05427596f, 0.11641537f, -0.09797381f, 0.01839312f, 0.02409747f, 
    0.06439681f, 0.30642897f, 0.11472021f, -0.08702946f, -0.02393570f, -0.02916134f, -0.07188742f, 0.13761353f, 
    -0.20926952f, -0.06851256f, -0.15473020f, 0.12439706f, 0.14013889f, 0.01372233f, -0.10064622f, -0.01194141f, 
    0.03123604f, -0.08871916f, -0.04404746f, 0.03280634f, 0.04262979f, 0.13229363f, 0.02406232f, 0.00592625f, 
    -0.10837668f, -0.04295281f, 0.32946101f, 0.19121833f, -0.18076284f, 0.05814417f, -0.04265589f, 0.22906226f, 
    0.05628604f, -0.17213523f, -0.08076328f, 0.15430963f, 0.12294232f, 0.09566814f, 0.02396162f, 0.19829188f, 
    0.11237226f, 0.04853244f, 0.00206537f, 0.17081542f, -0.11281051f, 0.15273200f, -0.02369670f, -0.01981218f, 
    -0.01655998f, 0.00241971f, 0.05487203f, 0.04376319f, 0.02410369f, 0.20108300f, 0.00550011f, -0.02925057f, 
    0.07477242f, 0.00683827f, 0.24018976f, -0.05088460f, 0.00685994f, -0.14675027f, 0.05159602f, 0.00096479f, 
    -0.14500259f, 0.15160939f, 0.01141177f, 0.04920685f, 0.04330854f, 0.12761103f, 0.13357514f, 0.06701327f, 
    -0.03005984f, -0.24911740f, -0.05883330f, -0.04453248f, -0.08012863f, 0.20354971f, 0.13344395f, 0.02361646f, 
    0.12420582f, 0.02470106f, 0.19949780f, 0.09816808f, -0.07579187f, 0.02385687f, 0.10369389f, -0.03794014f, 
    0.05184723f, -0.30276409f, -0.24593884f, 0.04643326f, -0.16794941f, -0.05659461f, 0.00853991f, 0.07615459f, 
    -0.02827672f, -0.06413073f, 0.01803176f, 0.15213554f, -0.02961138f, 0.05881437f, -0.05039919f, 0.00623073f, 
    0.06716032f, 0.00152455f, 0.09175847f, -0.01108848f, -0.05366105f, 0.03448521f, -0.07179281f, 0.02820942f, 
    -0.01654978f, -0.14197066f, 0.03534004f, 0.04138930f, 0.11645316f, 0.22352843f, 0.09451900f, 0.06320463f, 
    0.09992854f, -0.01515241f, 0.10203770f, -0.01577259f, -0.15687671f, 0.21576305f, -0.19616380f, 0.11277337f, 
    0.11137068f, 0.15065444f, 0.17184688f, 0.05839868f, 0.07119939f, 0.07852828f, -0.08480113f, 0.10948619f, 
    -0.14629963f, 0.06795067f, -0.03742895f, -0.05787190f, 0.05468227f, 0.14058697f, 0.01263685f, 0.11844590f, 
    0.06433394f, 0.02798951f, -0.03552555f, 0.06791222f, -0.09717532f, 0.11209297f, 0.02735015f, -0.00178605f, 
    -0.05370285f, 0.05599561f, -0.39720401f, 0.05753750f, 0.06769425f, -0.06903922f, -0.15941799f, 0.19198313f, 
    -0.03169033f, -0.12034632f, 0.04544522f, 0.04874211f, -0.01889589f, 0.07429782f, -0.10727885f, 0.09675811f, 
    -0.11347426f, -0.03882934f, -0.29345110f, -0.08261472f, -0.05284166f, -0.04183172f, -0.07119478f, -0.07755749f, 
    -0.19211490f, -0.16458304f, -0.51337856f, 0.03625977f, 0.12520717f, 0.24809624f, 0.02595397f, 0.00819330f, 
    0.06218801f, -0.00720582f, 0.07445794f, 0.02979118f, 0.09050646f, 0.10522784f, -0.03983228f, 0.07729043f, 
    0.08345756f, 0.19674259f, 0.02143528f, 0.04011825f, 0.01084768f, -0.12109864f, -0.11653887f, -0.10069695f, 
    0.01938259f, 0.09876290f, -0.03779922f, 0.09811789f, 0.01302466f, 0.05812096f, -0.13741808f, 0.08567908f, 
    -0.10150933f, -0.03657984f, -0.07476382f, 0.16046864f, 0.04686024f, 0.03309506f, 0.05699529f, -0.03055043f, 
    0.04027790f, -0.08131347f, 0.13930713f, -0.02576586f, 0.14229015f, 0.08887844f, 0.09394536f, 0.06512926f, 
    -0.18200856f, -0.06490921f, 0.02454947f, 0.10945268f, 0.09623200f, 0.05964747f, 0.03522628f, 0.01516204f, 
    0.02394966f, -0.13279764f, 0.13164562f, -0.20680271f, -0.08338396f, -0.02649043f, -0.03450899f, 0.13354705f, 
    0.12591997f, -0.03732120f, -0.08752293f, 0.06567071f, -0.01401877f, 0.09074567f, 0.06220080f, -0.15548302f, 
    -0.18953530f, -0.28274012f, -0.06973169f, -0.09463216f, 0.12454712f, -0.10672038f, 0.04526272f, 0.05087439f, 
    0.00269709f, 0.00067317f, 0.17225473f, 0.03913325f, -0.03438229f, 0.00810357f, 0.04975326f, -0.03726552f, 
    0.06127076f, -0.02899294f, -0.19291089f, -0.06443689f, -0.07507991f, 0.04432195f, 0.14233199f, 0.11292128f, 
    -0.06144652f, -0.17827216f, -0.03776761f, -0.00627952f, -0.29453269f, 0.12126529f, 0.09240039f, -0.09329794f, 
    -0.05112525f, -0.04874913f, 0.00330967f, 0.01676085f, 0.07941831f, -0.02733377f, -0.00865308f, -0.21800303f, 
    0.05677123f, -0.05624183f, -0.03279874f, -0.00936802f, -0.08471367f, 0.02950373f, 0.06863320f, -0.00708269f, 
    -0.28526005f, -0.03658165f, 0.10748798f, -0.12654129f, 0.00319301f, 0.01066983f, 0.02248565f, 0.00333341f, 
    0.04697864f, -0.29350883f, 0.16711292f, 0.30059126f, -0.01560398f, 0.08932509f, 0.09175453f, 0.12708239f, 
    -0.00391643f, 0.11598723f, 0.62630773f, -0.25889385f, -0.60624349f, 0.06892370f, -0.17661880f, -0.12298536f, 
    -0.15255105f, -0.16157992f, 0.00844969f, 0.11481214f, -0.09999625f, -0.07234538f, 0.05180429f, -0.06765538f, 
    0.06483930f, 0.10682799f, 0.08519777f, 0.17685960f, -0.08310688f, 0.20324950f, 0.18054737f, 0.12823756f, 
    0.08941174f, 0.00303383f, 0.00802185f, -0.01644950f, 0.03153789f, 0.18294849f, 0.05274728f, 0.07540704f, 
    -0.02498661f, 0.01654211f, -0.01464688f, -0.02195011f, 0.02101242f, 0.11537531f, -0.08471949f, -0.22641802f, 
    -0.12944500f, -0.17404188f, -0.00797209f, -0.03748566f, 0.11681924f, 0.12833939f, -0.01383769f, -0.17505828f, 
    0.02924784f, -0.05185676f, 0.07686580f, -0.09337871f, 0.00912860f, 0.06513530f, 0.02331376f, 0.03600998f, 
    -0.15712269f, -0.51171416f, -0.36533320f, -0.16256857f, -0.04853304f, -0.02723872f, 0.02224891f, 0.01201611f, 
    -0.02980107f, -0.02087255f, -0.03946198f, -0.00686062f, 0.00031745f, 0.02604812f, -0.09352202f, -0.00704480f, 
    -0.09936861f, 0.01675178f, 0.05018777f, -0.56777579f, -0.24452984f, -0.13751091f, -0.03190577f, -0.19093598f, 
    0.05402547f, -0.02625533f, 0.07045539f, 0.14144538f, -0.19798909f, -0.29635915f, 0.03155755f, 0.11563241f, 
    -0.09927152f, -0.09171952f, -0.02287429f, 0.35064211f, -0.03731678f, 0.14998445f, -0.01429326f, -0.17732805f, 
    -0.20827617f, -0.06841383f, 0.14254315f, 0.01216065f, 0.02189731f, 0.26323277f, -0.21743123f, -0.00203131f, 
    0.02792908f, 0.06239987f, 0.04940073f, 0.06396246f, 0.13241725f, 0.02530673f, -0.11376795f, -0.08117697f, 
    0.03847844f, 0.02676236f, 0.02636269f, -0.07955617f, -0.01876280f, 0.07999908f, 0.02664127f, 0.01166921f, 
    0.03958254f, 0.32658276f, 0.10435301f, -0.05833086f, -0.00109896f, 0.11918788f, 0.05067084f, 0.14474210f, 
    0.09084222f, 0.14711310f, 0.10551972f, -0.03459327f, 0.04849081f, -0.07320105f, -0.22962676f, 0.03375679f, 
    -0.08605021f, 0.06173657f, 0.07313765f, -0.11072771f, -0.38757646f, -0.10709023f, -0.02490835f, 0.00039981f, 
    -0.07358070f, 0.03685788f, -0.30666995f, -0.27392519f, 0.09599136f, -0.12414030f, 0.08095986f, -0.03407152f, 
    -0.17339480f, -0.04973594f, 0.03978936f, 0.08874688f, -0.09476035f, -0.00145843f, 0.04830179f, -0.23270200f, 
    0.17577435f, 0.00165209f, -0.10763575f, 0.02694534f, 0.40720257f, -0.27577299f, -0.09514057f, 0.15525378f, 
    0.01591500f, -0.05932749f, 0.23103483f, 0.13067262f, 0.18713234f, -0.11307350f, -0.13098130f, 0.07328288f, 
    -0.11017870f, -0.05235289f, -0.08868300f, 0.06879576f, -0.05797063f, -0.02712769f, 0.28482521f, -0.40844864f, 
    -0.19194424f, -0.00158523f, -0.10762230f, -0.17626430f, 0.05250895f, -0.00458988f, 0.04613772f, 0.24769720f, 
    -0.00013647f, -0.01350692f, 0.07779603f, 0.00047583f, 0.31612161f, 0.11092032f, 0.10313012f, 0.05243718f, 
    -0.13204995f, -0.37646881f, 0.12403334f, 0.03162538f, 0.12045795f, -0.04231051f, 0.14944659f, 0.05618041f, 
    -0.01021399f, -0.14802776f, -0.13191344f, -0.07178401f, -0.18780597f, 0.02230748f, -0.09096183f, 0.11317053f, 
    0.09241579f, 0.00154113f, -0.16315925f, 0.13385874f, 0.39364013f, -0.18022320f, 0.14050306f, 0.03452486f, 
    0.01361476f, 0.02787171f, 0.08277865f, -0.20987400f, -0.03967407f, -0.14506464f, -0.01181393f, -0.03331971f, 
    -0.05729060f, 0.08382951f, 0.04851568f, 0.02753803f, -0.06007408f, -0.18499932f, 0.09594205f, -0.01750510f, 
    0.08469740f, 0.06770031f, 0.01058153f, -0.10984122f, 0.17222728f, -0.39155507f, 0.07238114f, 0.14320692f, 
    -0.08446507f, 0.02499734f, 0.13708599f, -0.07342784f, -0.06187029f, 0.05020912f, -0.12732163f, -0.05875432f, 
    -0.00563893f, -0.06265970f, -0.23352557f, -0.28589544f, -0.17323063f, -0.13497768f, 0.13404597f, -0.31357700f, 
    0.02179381f, 0.27293134f, -0.07024015f, -0.04016660f, 0.07769824f, 0.03736460f, 0.13464570f, 0.06004133f, 
    -0.19705571f, -0.08458212f, -0.12413987f, 0.13226832f, 0.09229212f, 0.16886443f, 0.01479487f, 0.15426382f, 
    -0.03364133f, -0.14486383f, -0.26902792f, 0.21149571f, 0.15033358f, 0.03562624f, 0.10232074f, -0.06957134f, 
    0.02122926f, 0.01973035f, -0.47776118f, 0.31863284f, -0.05603351f, -0.18875434f, 0.06229371f, 0.01025640f, 
    0.06870658f, 0.17404433f, -0.04193742f, -0.03351903f, -0.04851566f, -0.09546651f, -0.05928644f, -0.15324458f, 
    -0.00685767f, 0.09132741f, 0.11644905f, -0.04771664f, 0.12312917f, 0.10336471f, 0.13146730f, 0.28493100f, 
    0.12983921f, -0.08547708f, 0.03063470f, -0.01117891f, 0.18954393f, -0.15449461f, 0.29498139f, 0.18575586f, 
    -0.05377132f, 0.10746153f, 0.04000960f, 0.17688821f, 0.35610700f, 0.14354615f, 0.06918394f, -0.12174257f, 
    0.05693607f, -0.06471863f, 0.07707465f, 0.01666185f, 0.08044506f, -0.06333943f, 0.12320364f, -0.04882318f, 
    0.02567402f, 0.29705310f, 0.15848289f, 0.15788598f, 0.06375340f, 0.06413607f, 0.06601481f, -0.06042869f, 
    -0.12422252f, -0.05449661f, -0.08050539f, -0.03142818f, 0.17748830f, -0.03573190f, 0.08203991f, -0.10563207f, 
    -0.13955620f, -0.00824346f, -0.04585431f, 0.02234290f, 0.18815987f, 0.00262148f, 0.18998030f, -0.01038111f, 
    -0.03584481f, -0.14876927f, -0.25499931f, -0.26859587f, -0.31218198f, -0.15985699f, 0.15350190f, 0.02374575f, 
    -0.06801214f, -0.04439204f, -0.19318539f, 0.15092489f, 0.04602876f, -0.02537523f, -0.09435865f, -0.09887848f, 
    0.04300009f, 0.13878095f, 0.03271108f, 0.17567880f, -0.00697593f, -0.03744520f, -0.05397724f, -0.09564709f, 
    -0.20061606f, 0.09004650f, 0.15585881f, 0.05810080f, 0.02757804f, -0.05219445f, -0.14859198f, 0.27913907f, 
    -0.06230016f, -0.14592493f, -0.16655025f, 0.07510645f, -0.07235534f, 0.03759126f, 0.07846363f, 0.03935625f, 
    -0.08102120f, 0.15733521f, 0.05239407f, 0.08079967f, -0.02725107f, -0.00994999f, -0.08020689f, 0.05960012f, 
    0.05898240f, 0.19136165f, 0.16641602f, 0.16104938f, 0.06041371f, 0.16975476f, 0.18154427f, 0.22052559f, 
    -0.28902251f, 0.26595610f, 0.44105759f, 0.01419026f, 0.07083412f, -0.12500523f, 0.08898846f, 0.05110881f, 
    0.15330395f, -0.01126279f, -0.17194833f, -0.21969725f, -0.02403439f, 0.24668998f, -0.14959890f, 0.05739582f, 
    0.18343981f, -0.11869877f, 0.24464871f, 0.34511736f, -0.33293080f, -0.01468436f, -0.07142002f, 0.32464421f, 
    0.18322396f, 0.34138072f, -0.04691391f, 0.01809278f, -0.07460197f, -0.08626917f, 0.00473938f, 0.12237333f, 
    0.19223019f, 0.27589813f, 0.19954757f, 0.10223300f, 0.07435311f, -0.25307661f, -0.02741379f, 0.28701130f, 
    0.02454826f, -0.07807905f, 0.23798077f, -0.11518276f, 0.16653286f, 0.20188408f, 0.07022890f, -0.02128627f, 
    0.12841210f, -0.07567969f, 0.07827472f, 0.02263250f, -0.17176558f, -0.09042066f, 0.27886963f, -0.06080798f, 
    0.11270993f, 0.16983539f, -0.05013455f, 0.14651348f, 0.04940555f, -0.30450025f, -0.05292965f, 0.16289906f, 
    -0.07528330f, 0.17036599f, 0.12599140f, -0.00918123f, 0.18549354f, 0.16018532f, 0.13014190f, 0.14370695f, 
    0.12562907f, -0.05125973f, 0.13069320f, -0.05426174f, -0.00664479f, 0.03847994f, 0.00814101f, -0.00529557f, 
    0.04345154f, -0.16376992f, -0.21513197f, -0.07373265f, 0.02994823f, 0.04771060f, 0.01354253f, -0.00501775f, 
    0.05133983f, -0.21023616f, 0.16818859f, 0.04381900f, 0.21037626f, 0.01597034f, 0.26553902f, 0.15014471f, 
    0.16404490f, 0.11428487f, 0.14100067f, -0.03833224f, -0.31864622f, 0.12255861f, 0.08556465f, 0.10023054f, 
    0.18344839f, 0.07453689f, 0.24451724f, -0.41690716f, 0.12595001f, 0.24316534f, 0.20229271f, -0.06587602f, 
    0.15957882f, -0.19090071f, 0.21145855f, 0.09974789f, 0.32830843f, 0.04473507f, -0.16836911f, 0.35365817f, 
    0.00666538f, 0.21914867f, 0.07986641f, 0.01797654f, 0.11492801f, 0.20428804f, -0.09941455f, -0.01274120f, 
    -0.06365344f, -0.12858337f, -0.13642599f, -0.03233360f, 0.13231036f, 0.04592131f, -0.01366732f, -0.01395344f, 
    0.31301990f, 0.13037160f, 0.05567138f, 0.01779088f, -0.14681253f, 0.02581204f, 0.03075366f, -0.06476995f, 
    -0.01137971f, -0.05773835f, 0.01456035f, -0.03955567f, -0.06012146f, -0.00380937f, 0.00389153f, -0.00771410f, 
    0.04440024f, -0.02706256f, -0.04230118f, 0.01165492f, -0.01883885f, -0.00012962f, -0.05998222f, -0.03654700f, 
    0.00557157f, -0.00902980f, 0.01920483f, -0.00774786f, 0.01768835f, -0.02522212f, 0.00934596f, 0.04253044f, 
    0.02510587f, 0.03831567f, 0.04498631f, 0.00077903f, -0.02011141f, 0.00378978f, -0.04860318f, -0.05134607f, 
    -0.06070178f, -0.01287384f, -0.04400663f, -0.03673805f, 0.04481759f, -0.02796426f, -0.04232250f, -0.04626139f, 
    -0.04675745f, -0.04576374f, 0.04366218f, 0.04608515f, -0.03416111f, 0.05137828f, -0.04682787f, -0.02357118f, 
    -0.04992127f, 0.02930916f, 0.01696222f, -0.01280065f, -0.06304053f, -0.00556327f, 0.00658431f, -0.02273487f, 
    -0.01390202f, 0.03835810f, 0.01661314f, 0.00260241f, 0.02598488f, -0.04855400f, 0.00134774f, -0.05683371f, 
    -0.03925747f, -0.00205154f, -0.03770424f, -0.05208774f, -0.04160993f, -0.04774547f, -0.00416147f, 0.02227697f, 
    -0.00434720f, -0.02156340f, -0.05074923f, 0.03558398f, -0.04519463f, -0.01171792f, -0.00003269f, 0.03848943f, 
    0.02953918f, -0.00728350f, -0.05488658f, -0.05807452f, 0.04169325f, -0.05877687f, -0.02265803f, 0.04545438f, 
    0.02458784f, 0.02552673f, -0.03859159f, -0.03594828f, 0.03225535f, 0.02489081f, -0.00328804f, -0.00238411f, 
    0.03845544f, 0.04032090f, 0.01324572f, -0.02790307f, -0.02159934f, -0.03088888f, 0.04665396f, -0.03411406f, 
    -0.00242318f, -0.01819967f, 0.02861691f, -0.05303084f, -0.05894842f, -0.05553209f, 0.04323068f, 0.01361227f, 
    0.00562500f, -0.04770765f, 0.00637404f, -0.00101247f, 0.02753340f, 0.01757205f, 0.03055695f, -0.02713327f, 
    -0.03609218f, 0.04820254f, 0.02871928f, 0.03919843f, 0.00921383f, 0.04158032f, -0.03157794f, 0.01849628f, 
    -0.02681699f, -0.05157694f, -0.05561791f, 0.00102160f, 0.02367579f, 0.03528146f, -0.02310489f, 0.01363149f, 
    0.00787668f, -0.01966816f, -0.04179474f, -0.04063451f, 0.01528961f, -0.03066378f, 0.01964491f, -0.01638348f, 
    0.02469375f, -0.02019522f, 0.00194923f, -0.04513193f, -0.04817420f, 0.02527748f, -0.05798815f, 0.02110906f, 
    0.02228765f, 0.03080743f, 0.03836225f, -0.00426520f, 0.01565412f, 0.00204469f, -0.04514367f, -0.01673625f, 
    -0.02166570f, 0.00161798f, 0.00508209f, -0.01164931f, -0.02098851f, 0.03419393f, -0.01154148f, -0.02889537f, 
    -0.01824920f, 0.01148436f, 0.03058746f, 0.03081349f, -0.02370987f, 0.00252767f, 0.01017073f, -0.00334247f, 
    0.05021778f, -0.02757883f, -0.05515747f, 0.04631243f, 0.03671668f, -0.05482883f, -0.04797456f, -0.00610167f, 
    0.02311065f, 0.03406692f, -0.02919974f, 0.01814345f, -0.04161570f, -0.05025829f, -0.04401138f, -0.01030843f, 
    0.05089851f, 0.04998875f, -0.05403816f, -0.00696661f, -0.04628026f, -0.01781011f, 0.03312260f, -0.06425962f, 
    -0.03263261f, 0.02521021f, -0.03141138f, -0.00166309f, -0.04422357f, -0.05627030f, -0.01241942f, -0.02568204f, 
    0.05342561f, -0.00053441f, -0.05060908f, 0.01583073f, 0.02106440f, -0.01835024f, 0.01492053f, 0.02174278f, 
    0.00260353f, -0.05637949f, 0.01425129f, -0.01048272f, -0.01891744f, -0.00092736f, -0.03583929f, 0.01891186f, 
    -0.06028770f, 0.04747992f, 0.05254526f, -0.02781979f, -0.03271128f, 0.00490752f, 0.02174089f, 0.05090751f, 
    -0.01750204f, -0.02393651f, -0.05295495f, 0.00037825f, -0.05753663f, 0.01203739f, -0.05449755f, 0.01853581f, 
    0.00895242f, -0.04461521f, -0.00064847f, 0.01550066f, -0.00170118f, 0.01280689f, 0.00612114f, -0.03540156f, 
    0.00130438f, -0.04351904f, 0.04176941f, -0.01804604f, -0.00968891f, -0.05271315f, -0.04193606f, -0.00235441f, 
    0.05573714f, 0.01795886f, 0.01965942f, -0.06276988f, 0.01569867f, -0.00537047f, -0.00822352f, -0.03808059f, 
    -0.04591602f, -0.05676810f, -0.00358397f, -0.04974197f, -0.02099155f, -0.02317563f, -0.02326795f, -0.03259970f, 
    0.00091114f, 0.00953965f, 0.04535663f, -0.03553823f, 0.01795055f, 0.04503187f, -0.00445610f, 0.03678631f, 
    -0.02995152f, -0.03528092f, -0.05486026f, 0.05449015f, 0.04165250f, -0.04405620f, -0.00404464f, -0.00301051f, 
    0.04448240f, -0.01987335f, -0.03463136f, -0.03544347f, -0.01543418f, -0.00731528f, 0.02164827f, -0.04450708f, 
    -0.05652372f, -0.06043761f, -0.05802276f, 0.04652033f, 0.00606151f, -0.01914558f, -0.05147931f, 0.01370500f, 
    0.01986049f, 0.00005775f, 0.04842667f, -0.01217292f, 0.00037120f, 0.03558220f, -0.02730143f, 0.00359097f, 
    -0.02152417f, -0.05012412f, 0.04703036f, -0.00767592f, 0.00243086f, 0.04476058f, -0.01977916f, -0.03341388f, 
    -0.03438266f, 0.03433559f, -0.02232241f, -0.00680810f, -0.04108872f, -0.01352905f, -0.02301502f, -0.00084134f, 
    0.02469913f, -0.06087625f, 0.04393191f, 0.01310364f, -0.06539345f, -0.00860176f, 0.00712249f, 0.04776933f, 
    0.04664657f, -0.01119608f, 0.04363468f, 0.01690743f, -0.03686742f, 0.01294226f, 0.02060960f, 0.01917073f, 
    -0.02693298f, -0.02185711f, -0.05501995f, 0.03301963f, -0.06073267f, -0.05875495f, -0.05153609f, 0.02690684f, 
    -0.01874437f, 0.04985935f, 0.00208187f, 0.00497229f, -0.00411952f, -0.04072042f, 0.00293433f, -0.01465412f, 
    -0.01448940f, -0.03346190f, -0.06152353f, 0.04156823f, -0.02765202f, -0.05469756f, -0.03527648f, -0.04479653f, 
    -0.05381638f, -0.04090697f, -0.02223119f, -0.04069664f, 0.02958662f, -0.03375210f, -0.02912137f, 0.03249769f, 
    0.03958175f, 0.02956833f, -0.00101243f, 0.02423297f, -0.05145719f, -0.03226144f, 0.02946463f, 0.01354295f, 
    -0.00973890f, -0.06553304f, 0.04149057f, 0.03861490f, 0.04658696f, -0.01059824f, 0.04769857f, -0.02404757f, 
    -0.06716851f, 0.01435836f, -0.04256568f, -0.00561984f, 0.00406808f, -0.03662403f, -0.00855093f, 0.04875968f, 
    -0.03466326f, -0.01368798f, 0.02455589f, 0.04552741f, -0.02862458f, -0.04981367f, -0.06526254f, 0.02736644f, 
    0.03041523f, -0.02650842f, 0.01007119f, -0.02180559f, 0.01791481f, 0.01201680f, -0.02244030f, -0.01255724f, 
    -0.04141401f, -0.03373693f, -0.04463998f, -0.00021621f, -0.03194528f, -0.02387290f, 0.04423754f, -0.05119537f, 
    -0.03129205f, -0.04266723f, -0.02132801f, -0.03762557f, -0.00659235f, -0.02817189f, -0.04872173f, -0.01971922f, 
    0.01216891f, -0.05861204f, 0.01634792f, 0.01351712f, -0.05074320f, -0.00534081f, -0.01193688f, 0.00765856f, 
    0.04932475f, -0.02630930f, -0.03532252f, 0.02697438f, -0.03193967f, -0.04593716f, -0.00030016f, -0.00009361f, 
    -0.04926062f, -0.00807298f, 0.02486755f, -0.02095100f, -0.01834468f, 0.00053012f, -0.02944759f, -0.03114904f, 
    -0.05118335f, 0.04182866f, -0.01155221f, -0.01131521f, -0.00163487f, 0.02609742f, -0.01543824f, 0.01460312f, 
    -0.03241423f, -0.04055128f, -0.05425946f, -0.02064894f, 0.00880910f, 0.00101152f, -0.01021950f, 0.00313208f, 
    -0.03035925f, 0.03852336f, -0.00647507f, 0.01677065f, -0.04240892f, -0.03672657f, 0.00428962f, -0.00194131f, 
    -0.05273888f, -0.03055919f, -0.05055521f, -0.05430838f, 0.01853717f, 0.02433576f, -0.01043799f, -0.05050206f, 
    0.01931948f, 0.01878251f, -0.04540129f, -0.00637448f, -0.04532592f, -0.02655403f, -0.02121560f, -0.01908054f, 
    0.01988966f, -0.02325155f, 0.04784900f, 0.00874660f, -0.06302130f, -0.05227972f, -0.02466228f, -0.01175764f, 
    -0.01655900f, -0.00411362f, 0.00376278f, -0.01919906f, 0.00996930f, 0.03137030f, -0.00840956f, 0.01748417f, 
    0.04845506f, -0.03875091f, -0.06434292f, 0.03428202f, 0.00213203f, 0.00371250f, 0.04135846f, -0.06636725f, 
    0.05064584f, -0.02012347f, 0.04480307f, 0.00588129f, -0.06326590f, -0.01992677f, 0.00814675f, 0.01004847f, 
    -0.01790662f, -0.00867087f, 0.01870669f, -0.00637375f, 0.04793622f, -0.03789168f, 0.00732813f, -0.00708280f, 
    0.03231374f, 0.01430511f, 0.00114766f, -0.04832658f, -0.00693409f, -0.01925263f, -0.01876038f, -0.00326491f, 
    -0.06479596f, -0.01091547f, -0.03846290f, -0.04230206f, -0.05767058f, 0.00138173f, -0.00899064f, 0.04914181f, 
    -0.02496761f, 0.04435265f, -0.06115722f, 0.00989950f, 0.00065059f, -0.01259299f, 0.05224437f, -0.00523297f, 
    -0.06169738f, -0.03468262f, 0.03513608f, 0.03551424f, -0.05412580f, -0.02958333f, 0.04066301f, 0.04174838f, 
    -0.03935876f, 0.01952268f, -0.03576909f, 0.00396679f, 0.04535684f, 0.03405329f, -0.06047461f, 0.04473245f, 
    0.03777100f, -0.03970657f, 0.03064244f, 0.04791508f, 0.03518686f, -0.04472486f, -0.05996123f, -0.01285106f, 
    -0.00712421f, 0.01163992f, -0.06005270f, -0.05510206f, -0.01220540f, -0.03258257f, -0.02873280f, -0.01502476f, 
    0.04755586f, 0.02138045f, -0.00418784f, -0.05564101f, 0.04911358f, 0.00402263f, -0.01341139f, 0.02017581f, 
    -0.06111560f, -0.05614128f, 0.04594377f, -0.02924942f, -0.00665045f, -0.05538493f, -0.05543903f, 0.03393641f, 
    -0.04980226f, -0.05418663f, -0.03586742f, 0.05084116f, 0.00980098f, -0.01240153f, -0.04432278f, 0.02463319f, 
    0.04392643f, 0.04341387f, -0.00664482f, -0.04836531f, -0.04407303f, -0.00430669f, -0.00355893f, -0.05682787f, 
    -0.04285181f, 0.04371002f, -0.03966947f, 0.05216528f, -0.01749775f, -0.01386269f, -0.02771838f, 0.02038065f, 
    0.03977836f, 0.01751825f, -0.04467827f, -0.05050045f, -0.03578690f, -0.05461518f, 0.01856629f, -0.01131571f, 
    -0.03136852f, 0.04355690f, -0.04101188f, -0.05236898f, 0.01320864f, -0.03769927f, -0.00895348f, -0.06169632f, 
    -0.04832138f, 0.01521376f, 0.03889098f, 0.03512436f, 0.03777632f, 0.00618064f, -0.02558583f, -0.02846065f, 
    0.03566534f, -0.00504444f, 0.01052419f, -0.01677591f, -0.05337984f, -0.01703090f, 0.03405269f, 0.05229426f, 
    0.01034682f, -0.03862431f, -0.05719211f, -0.01706628f, -0.01495286f, -0.00012022f, -0.05962959f, -0.00060935f, 
    0.05175839f, -0.00489413f, -0.06369708f, -0.00732841f, 0.02170188f, 0.01956988f, -0.00832562f, 0.04252302f, 
    -0.03111132f, -0.05647580f, 0.01077764f, -0.03255478f, -0.04171287f, 0.03646096f, 0.04628043f, -0.03638475f, 
    -0.01714473f, -0.02555494f, -0.01987974f, -0.03634556f, 0.03868345f, -0.05712298f, -0.04347691f, -0.03759860f, 
    -0.00598105f, 0.05043463f, 0.03813721f, 0.01766938f, -0.04310922f, -0.00989678f, -0.03051614f, -0.00692941f, 
    0.01781629f, -0.02133749f, -0.01114318f, 0.04745915f, 0.04062658f, 0.04443089f, -0.02018032f, -0.01176875f, 
    0.01088699f, 0.04522639f, -0.02910350f, -0.00766414f, -0.04241549f, -0.04505942f, 0.01164064f, 0.02014521f, 
    -0.02861909f, 0.02795499f, -0.04130374f, 0.05097738f, -0.03198671f, -0.01268358f, 0.00796150f, -0.03225334f, 
    0.02908249f, 0.04591451f, 0.02456770f, -0.01229356f, -0.01554674f, -0.04403504f, -0.02758883f, 0.03618788f, 
    0.01843023f, -0.05789114f, 0.01650331f, 0.00978558f, 0.02011199f, -0.01713579f, 0.04259367f, -0.04600993f, 
    0.03146299f, -0.03094488f, -0.04315190f, -0.01253504f, 0.02012809f, -0.04704469f, 0.01016167f, 0.02915151f, 
    0.05163459f, -0.04430520f, 0.00244227f, 0.05265396f, -0.03647762f, -0.06004973f, 0.04551736f, -0.03374081f, 
    -0.00411786f, -0.04590204f, 0.04293663f, 0.03290161f, -0.05797761f, -0.04467153f, -0.01837479f, -0.01590614f, 
    -0.01586265f, -0.02617904f, -0.01589021f, -0.00770187f, -0.00714008f, -0.03003028f, -0.03836421f, 0.04190742f, 
    0.03449276f, -0.03901302f, -0.02650099f, -0.02602212f, -0.02846147f, 0.03006890f, -0.06389844f, -0.05329665f, 
    0.04009918f, 0.01039597f, -0.03391396f, -0.03203119f, -0.04078579f, -0.01540196f, -0.04555039f, 0.03639357f, 
    -0.01759651f, -0.05316836f, -0.00346539f, -0.03855973f, -0.00843743f, -0.03290790f, -0.01982467f, -0.03010914f, 
    0.01163462f, 0.04131560f, -0.03290284f, -0.04243310f, -0.05382372f, -0.05030445f, -0.03661696f, -0.01164421f, 
    -0.02493624f, 0.03921907f, 0.04702426f, 0.05108371f, -0.00482571f, -0.02159561f, -0.03503629f, 0.01946643f, 
    -0.04805574f, 0.00951151f, 0.02367681f, 0.04983806f, -0.06030301f, -0.02296661f, -0.02461223f, 0.04678400f, 
    0.03559407f, -0.06187448f, -0.05726488f, 0.01148779f, 0.01523830f, 0.05407430f, -0.04308320f, -0.05283511f, 
    0.00779024f, 0.01042837f, -0.01510911f, -0.03509064f, 0.01543575f, -0.02358800f, 0.05749998f, 0.03585806f, 
    0.00053174f, 0.01000496f, 0.03693831f, 0.05369718f, -0.01670239f, 0.04394663f, 0.03687323f, -0.02268847f, 
    -0.05978479f, 0.03311073f, -0.05907727f, 0.01181545f, 0.05005674f, -0.01828873f, -0.03123919f, 0.00988219f, 
    0.00450723f, 0.01066671f, -0.04358821f, -0.02413460f, 0.01240385f, 0.04635880f, -0.04785261f, 0.01398503f, 
    0.08934559f, -0.35955083f, -0.47666648f, 0.02279376f, 0.00808331f, 0.02090511f, 0.05263137f, 0.05391311f, 
    0.07110803f, -0.16598681f, -0.19573814f, -0.45308858f, 0.13718762f, 0.09321937f, 0.07826499f, 0.10319269f, 
    -0.07786059f, 0.08027374f, 0.04073412f, -0.10660724f, -0.39253843f, -0.08687845f, 0.12192123f, -0.28006211f, 
    0.01230676f, -0.02848714f, -0.12760425f, -0.08633842f, -0.19050397f, -0.29277900f, 0.04426840f, 0.09984048f, 
    0.03468696f, 0.12382302f, 0.12784395f, 0.03515782f, 0.06120395f, 0.17743179f, 0.09438337f, -0.08068562f, 
    0.02822762f, 0.33110273f, 0.06173921f, 0.00851219f, -0.00545572f, 0.22904091f, -0.03272000f, -0.15101311f, 
    -0.04837850f, -0.09460287f, -0.00510430f, 0.06617349f, 0.09846846f, -0.05127222f, -0.03120574f, -0.00359778f, 
    -0.06220764f, -0.09163867f, -0.02759931f, -0.02955624f, -0.05688287f, 0.11146916f, 0.03890981f, 0.07967541f, 
    0.20309040f, 0.04114265f, 0.04506242f, 0.04854773f, 0.20103519f, -0.00399736f, 0.07478487f, -0.04325139f, 
    0.09390303f, -0.29157245f, -0.03573452f, -0.11419278f, -0.04475830f, -0.02255303f, 0.10288502f, 0.07516219f, 
    0.05704471f, 0.13068661f, 0.01883040f, 0.00038478f, 0.03539802f, -0.09642014f, -0.06296241f, 0.05733052f, 
    -0.03562304f, 0.03860099f, 0.03180768f, -0.00738352f, -0.14856753f, -0.14923206f, 0.03045984f, 0.01896702f, 
    0.14617471f, 0.08217617f, 0.07261330f, -0.22741666f, -0.31596744f, 0.39931452f, -0.15110748f, -0.21666729f, 
    0.02106444f, -0.03815065f, 0.05731023f, 0.01619757f, 0.10909002f, -0.04740316f, -0.15934689f, -0.08781853f, 
    0.04274368f, -0.03421245f, 0.05775159f, 0.20389614f, 0.00633803f, -0.13484426f, -0.36292288f, -0.21857969f, 
    -0.06271132f, -0.05834757f, -0.04560320f, 0.14759113f, 0.01915214f, 0.09609973f, 0.12835184f, 0.34880012f, 
    0.20798743f, -0.09750973f, -0.12713397f, -0.01647321f, -0.00482298f, 0.00439194f, 0.03570798f, -0.02389104f, 
    0.10460693f, -0.13989159f, -0.03081958f, -0.03151596f, 0.07802067f, 0.07875738f, 0.03231654f, 0.10502093f, 
    0.16653596f, 0.17382118f, -0.30231908f, 0.13922656f, 0.14194097f, -0.08533926f, 0.13532329f, -0.01871150f, 
    0.13120860f, -0.11488633f, -0.06587771f, -0.03281799f, 0.03496606f, 0.01227682f, -0.16940859f, 0.05170623f, 
    0.04607407f, -0.07653435f, 0.16215490f, 0.36638018f, 0.04524452f, -0.07040138f, -0.28241241f, 0.02078525f, 
    -0.01317193f, -0.05079629f, -0.10785418f, -0.03466978f, 0.00873060f, -0.16268069f, 0.01391740f, 0.07489876f, 
    -0.08063944f, 0.13029051f, 0.13700877f, -0.12504433f, -0.26249883f, 0.11777703f, -0.61912811f, -0.09502065f, 
    -0.13153139f, -0.00813845f, 0.01882877f, 0.10016883f, 0.05380186f, 0.21182926f, 0.12252402f, 0.16509975f, 
    0.07019007f, -0.04628768f, 0.01309641f, 0.08306896f, -0.01442944f, 0.07882868f, -0.01998874f, 0.02005731f, 
    -0.04768052f, -0.11021478f, -0.20920777f, 0.15150462f, -0.08696911f, 0.07662249f, -0.08839823f, -0.02237552f, 
    -0.13505799f, -0.32066375f, 0.02604600f, 0.18806043f, -0.01162414f, -0.04588521f, 0.12439418f, -0.19964224f, 
    -0.14794083f, 0.14039660f, 0.19764102f, -0.15879843f, -0.17185177f, 0.02526917f, 0.00047533f, -0.07216456f, 
    0.17498846f, 0.15570508f, 0.19446167f, 0.05794140f, -0.01399180f, 0.03299171f, 0.10251407f, 0.00843261f, 
    -0.04277259f, 0.19156019f, 0.39034614f, -0.43813887f, -0.35847014f, -0.04337309f, -0.09024129f, -0.00938406f, 
    0.09532531f, 0.21747056f, 0.04614783f, 0.08424081f, -0.03071717f, 0.19078954f, -0.06474701f, 0.02195160f, 
    0.02040038f, -0.04172657f, 0.19940309f, -0.17697453f, 0.39258522f, -0.21584567f, 0.06391592f, -0.12488967f, 
    -0.11983197f, 0.09824776f, -0.01156163f, 0.10616728f, -0.11529715f, 0.00285459f, -0.17708974f, -0.46120152f, 
    0.03579989f, 0.10814654f, -0.04539715f, 0.05105495f, 0.06719209f, -0.02993514f, 0.25976449f, -0.14030528f, 
    -0.08274470f, 0.00585059f, 0.02170270f, -0.07769045f, 0.17872477f, -0.03866635f, 0.09131607f, 0.21531567f, 
    0.26662520f, 0.12278954f, -0.03343942f, 0.05353022f, 0.01863738f, 0.13974033f, 0.01491815f, -0.03456594f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06980741f, 0.03613424f, 0.06108101f, -0.01686844f, 0.07509050f, 0.14474827f, -0.05263180f, 0.12489516f, 
    -0.07773792f, 0.03077631f, 0.12069375f, 0.01186009f, -0.05628590f, 0.16859795f, 0.04843080f, -0.00095296f, 
    0.29853186f, -0.03473948f, 0.26786587f, 0.03629367f, 0.03689423f, -0.19589370f, -0.02773229f, -0.10402302f, 
    0.05099152f, 0.16913252f, 0.21674624f, 0.08098131f, -0.06009757f, 0.04820067f, -0.05521626f, 0.05458103f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.40021923f, -0.13131735f, 0.14722987f, -0.03782147f, -0.16300170f, -0.09687845f, 0.13036036f, 0.27147865f, 
    -0.23840509f, -0.11104125f, -0.14395435f, 0.50128525f, 0.14079399f, -0.09201781f, 0.16027802f, 0.02241071f, 
    0.25323865f, -0.10792598f, 0.05215149f, 0.16765673f, 0.04369620f, 0.37035090f, 0.23454729f, -0.21611474f, 
    0.25749633f, 0.00287340f, 0.15311743f, 0.24092641f, 0.10715214f, 0.04331087f, 0.07163175f, -0.17189522f, 
    0.24167866f, -0.10482554f, -0.24598892f, 0.02367022f, -0.09042433f, 0.21649046f, 0.15750189f, -0.74002218f, 
    0.03636415f, 0.35468751f, 0.21245298f, 0.05041802f, 0.09653683f, 0.08844588f, 0.12524389f, -0.06630000f, 
    -0.36777449f, 0.02567640f, 0.13383900f, 0.13767560f, 0.18036003f, 0.07292585f, 0.31336978f, -0.42716497f, 
    -0.06321808f, -0.17381246f, 0.17517871f, 0.23040877f, 0.08680866f, 0.14097390f, -0.09089562f, -0.29249799f, 
    0.05704647f, -0.17214333f, 0.04586573f, -0.03401570f, -0.12970775f, -0.03094307f, 0.16956532f, 0.13533559f, 
    -0.39821160f, -0.03787307f, 0.06767706f, 0.05589221f, 0.07579292f, -0.00897874f, 0.13719426f, 0.01725864f, 
    0.13424765f, 0.12259874f, -0.02979031f, 0.21215813f, 0.14725870f, -0.26123789f, 0.23744614f, -0.01850629f, 
    0.02347114f, 0.20943494f, 0.41818452f, 0.08833436f, 0.12718244f, 0.01778919f, 0.07844452f, 0.12616719f, 
    -0.31006426f, 0.06805278f, -0.21962792f, 0.15210937f, 0.07018473f, 0.25487781f, -0.03184942f, 0.18462592f, 
    0.29939970f, -0.04952266f, 0.46410978f, -0.17170629f, -0.10466194f, 0.52977538f, -0.16322240f, -0.09193697f, 
    -0.21698318f, 0.12521748f, -0.03979808f, -0.22817603f, -0.37497291f, -0.04080987f, -0.14736627f, -0.47072315f, 
    0.22203667f, -0.19221751f, 0.12580900f, 0.34102476f, 0.13685963f, -0.15780257f, -0.09231647f, -0.06825145f, 
    -0.07216118f, 0.17016725f, 0.13064145f, 0.04655091f, -0.09200160f, 0.15626143f, -0.00845191f, -0.04592461f, 
    0.17164998f, -0.09318087f, 0.18410708f, 0.15067454f, -0.09463625f, 0.13573359f, 0.05507395f, -0.12794589f, 
    -0.18850236f, -0.34924823f, 0.54023629f, -0.17099939f, 0.05551242f, 0.08750163f, 0.16612853f, 0.43130037f, 
    -0.26204175f, 0.22341242f, 0.01368256f, -0.05993635f, 0.03349604f, 0.00930199f, 0.14247942f, 0.36705270f, 
    -0.05391493f, -0.00529057f, -0.03432698f, 0.01542282f, -0.08579869f, -0.15956639f, 0.11219889f, -0.20106773f, 
    0.11726177f, 0.27235293f, -0.00574707f, 0.19695304f, 0.17074648f, -0.26704502f, 0.04605623f, -0.12024886f, 
    0.12932743f, -0.30883694f, -0.47035652f, 0.15292233f, 0.15940711f, 0.00089923f, 0.01295769f, 0.47067392f, 
    0.02548644f, 0.03404350f, -0.12334087f, -0.01479770f, 0.00113354f, -0.06246224f, 0.16767508f, 0.44301909f, 
    0.50913674f, -0.02325959f, -0.20442136f, 0.13956557f, 0.42246833f, 0.13133642f, 0.07822075f, 0.02062480f, 
    -0.01737109f, 0.21622609f, 0.01052372f, -0.11638656f, 0.11135834f, -0.17755708f, 0.12339192f, -0.02918577f, 
    -0.16757955f, 0.03616060f, 0.06867875f, 0.08625278f, -0.10127260f, -0.22532742f, -0.41888765f, -0.12559868f, 
    -0.13066168f, 0.21922545f, 0.14467132f, -0.03917912f, -0.04829809f, 0.08540561f, -0.06181924f, 0.48458061f, 
    -0.15764858f, 0.00717314f, -0.08556918f, 0.08585007f, 0.00620875f, -0.27785999f, -0.07910930f, 0.30262634f, 
    -0.13695696f, 0.00652505f, -0.00999426f, 0.43852711f, -0.07882735f, -0.18895096f, 0.05777973f, -0.08424561f, 
    0.33833289f, 0.19709542f, 0.24094725f, 0.36680973f, -0.10742560f, 0.12386970f, 0.25559318f, 0.11477916f, 
    0.18644014f, 0.14910807f, 0.18410769f, -0.10999504f, -0.09351395f, 0.04092019f, -0.04560282f, 0.01115130f, 
    0.30621773f, 0.02915650f, 0.22403221f, -0.00873609f, 0.02805725f, -0.10535449f, -0.16502173f, 0.20840250f, 
    -0.11987714f, 0.26419392f, 0.32839394f, 0.08111648f, 0.03256258f, -0.12488260f, -0.03234378f, -0.01979098f, 
    -0.37640435f, 0.11741838f, 0.42621452f, 0.46098530f, 0.12830637f, -0.03465892f, -0.18631583f, 0.20446560f, 
    -0.19233361f, 0.08932739f, -0.19799119f, -0.06107581f, 0.10267404f, -0.17446238f, -0.14603624f, 0.35207215f, 
    0.35959783f, -0.16329245f, 0.15835617f, 0.16170920f, 0.24927892f, -0.06758683f, -0.04378339f, -0.08409890f, 
    -0.09142128f, 0.21328783f, 0.00462010f, -0.01213417f, -0.14019771f, -0.01923046f, 0.01714005f, 0.13738085f, 
    -0.37714061f, 0.40880728f, -0.04185459f, 0.12323333f, 0.22220476f, -0.02911073f, -0.26946062f, -0.22623383f, 
    -0.15755846f, 0.20098431f, 0.30905166f, -0.16397999f, 0.13744515f, 0.08440097f, -0.12424933f, 0.18193589f, 
    -0.04804661f, -0.02280140f, -0.59908968f, -0.08218646f, -0.09528209f, 0.53834379f, -0.13418712f, 0.01937928f, 
    0.33129978f, 0.15413010f, -0.48954380f, 0.31487745f, 0.16679676f, -0.21234593f, 0.11426622f, 0.00286951f, 
    -0.43490401f, -0.20518053f, -0.08781222f, 0.01373481f, 0.07236954f, 0.28631243f, 0.44090143f, 0.29280078f, 
    0.16993795f, -0.70061046f, -0.36641851f, 0.23546329f, -0.16705026f, -0.05242727f, 0.14117523f, 0.18994443f, 
    0.36678073f, 0.14021780f, 0.15544102f, -0.15582459f, 0.18412650f, -0.14923935f, 0.14918479f, -0.22219718f, 
    -0.00884936f, 0.01217894f, 0.47104803f, 0.07228043f, -0.13323100f, 0.36621723f, -0.01786972f, -0.15718669f, 
    -0.20669393f, 0.02324658f, 0.33232346f, 0.04377173f, -0.01800918f, -0.33624569f, -0.30311090f, -0.11978055f, 
    0.13363709f, 0.15237209f, 0.34985945f, 0.01388229f, 0.15989925f, -0.01701487f, -0.05183595f, -0.11130947f, 
    -0.12433777f, 0.14058174f, 0.00198107f, -0.12534623f, -0.33136111f, 0.16660005f, -0.13990863f, -0.31292918f, 
    0.04167514f, 0.26320890f, 0.08625346f, -0.00228834f, 0.15442602f, -0.28951848f, 0.02439292f, 0.14357850f, 
    0.19617313f, -0.29500958f, -0.56108057f, 0.02565415f, 0.36942771f, 0.02467312f, 0.05193610f, 0.58559805f, 
    0.14039753f, -0.03647815f, -0.32829922f, 0.11056597f, 0.00959174f, -0.07759517f, -0.08022498f, 0.24584416f, 
    -0.19688387f, 0.15388611f, 0.03536325f, -0.16667692f, -0.11269459f, 0.25655234f, 0.09744338f, -0.10197514f, 
    0.28481701f, 0.08271507f, 0.34669262f, -0.45944804f, 0.06546253f, 0.24115425f, -0.10229980f, -0.08798068f, 
    0.29178911f, -0.01029702f, -0.52513593f, 0.01929475f, -0.11522081f, 0.06318716f, 0.00408505f, 0.05977679f, 
    -0.03197356f, -0.13762000f, -0.32464918f, 0.20208056f, 0.01176990f, -0.04068911f, -0.01732332f, -0.09288926f, 
    0.07760123f, 0.15923223f, -0.15785921f, 0.13481285f, 0.11636679f, -0.48020372f, -0.07108865f, 0.03413926f, 
    0.30462062f, 0.24093488f, -0.12532751f, 0.36996529f, -0.03920540f, 0.23514111f, -0.05095463f, -0.02964696f, 
    -0.08075537f, 0.19148298f, -0.02581132f, 0.28690442f, -0.04178060f, -0.01261540f, 0.10682056f, 0.39087254f, 
    -0.12786236f, 0.15905981f, 0.11408204f, -0.15145826f, -0.04172420f, -0.17240638f, -0.06928697f, 0.33839351f, 
    -0.09127204f, 0.13943896f, -0.05888630f, -0.09961472f, 0.24790370f, -0.32648221f, 0.10173849f, -0.26980010f, 
    0.13133498f, -0.04570389f, -0.19773152f, 0.42314434f, -0.12200531f, -0.22101505f, -0.17746650f, -0.18698125f, 
    0.07172103f, 0.15919708f, 0.23332743f, 0.15621518f, -0.02718871f, 0.00016100f, 0.04699745f, 0.26349655f, 
    0.09461224f, 0.10795673f, 0.04102417f, -0.07699781f, 0.07357080f, 0.16737600f, 0.14911249f, 0.37735873f, 
    0.25780147f, -0.00311596f, 0.24749601f, -0.00203144f, -0.05910596f, 0.52000630f, 0.11536583f, 0.06575460f, 
    0.01411519f, 0.11219104f, -0.09179360f, -0.01302472f, -0.05454795f, -0.10321903f, 0.07304213f, -0.12858142f, 
    -0.34995025f, 0.22621702f, -0.06844898f, 0.20305887f, 0.31543124f, -0.00009232f, -0.08139583f, -0.26276308f, 
    -0.09836929f, 0.14805034f, 0.02471381f, -0.11914011f, -0.12795296f, 0.09715304f, -0.17160997f, -0.03547821f, 
    0.18069832f, 0.03606502f, 0.21798514f, 0.00373948f, -0.13759926f, -0.37990332f, 0.10187208f, 0.31238791f, 
    -0.06449588f, 0.01985328f, 0.06775227f, -0.08243927f, 0.16062833f, 0.02894840f, 0.02004731f, -0.12696877f, 
    0.13090760f, 0.15662681f, 0.00620755f, 0.26724568f, -0.15135056f, -0.33684766f, -0.04168362f, 0.20640761f, 
    -0.11570889f, 0.08511236f, -0.13347258f, 0.17337550f, 0.07781287f, 0.10880549f, -0.16251853f, 0.24670061f, 
    0.35933572f, -0.06735598f, 0.38945475f, 0.04266146f, 0.00075032f, 0.03835287f, 0.11682481f, -0.47701418f, 
    -0.28368697f, -0.04129497f, 0.08725232f, -0.02457853f, -0.03009927f, 0.11330624f, 0.00170259f, 0.15870401f, 
    0.14383297f, 0.10523456f, 0.32328176f, -0.01028292f, 0.44518453f, -0.34593341f, -0.23308873f, 0.30833560f, 
    0.04804997f, 0.05265476f, 0.43811676f, 0.02519282f, -0.16123334f, 0.10841358f, -0.02642144f, -0.38103509f, 
    0.30038387f, 0.02735016f, -0.32607642f, 0.15796483f, -0.15392731f, 0.08690863f, -0.13970630f, 0.29623860f, 
    0.48741773f, -0.13779578f, -0.13954289f, -0.07679743f, 0.02569152f, 0.06705303f, 0.16991532f, -0.11390372f, 
    -0.15112861f, 0.24475043f, -0.33334094f, -0.05378450f, -0.05573181f, 0.04168817f, 0.04160642f, -0.32700521f, 
    0.40179613f, -0.24773479f, 0.16501600f, 0.17232622f, -0.02299066f, 0.16978337f, -0.16783522f, 0.15941854f, 
    -0.24025527f, 0.01592498f, -0.23537596f, -0.04679029f, -0.13558319f, -0.06666470f, -0.13860126f, 0.51607895f, 
    -0.04616042f, -0.08021682f, 0.39840132f, -0.14702564f, -0.01845866f, -0.10603285f, 0.11913091f, 0.01776431f, 
    0.27318180f, -0.11521501f, 0.32167566f, 0.12554331f, -0.25572303f, -0.08194114f, -0.01764632f, -0.19829802f, 
    0.10383302f, 0.02384240f, -0.20726025f, 0.08287877f, 0.01118552f, -0.07382410f, 0.08184463f, 0.33109000f, 
    0.05797722f, 0.03601564f, -0.06745205f, 0.14447197f, -0.05443236f, 0.07988752f, -0.01161854f, -0.17578617f, 
    0.09168008f, -0.08167116f, -0.07121073f, -0.18297277f, -0.05826903f, -0.15957096f, 0.06782821f, -0.05406665f, 
    -0.20606470f, -0.01461596f, -0.05243133f, -0.15870953f, 0.07380284f, 0.03592854f, 0.06336869f, 0.11593960f, 
    -0.00686966f, -0.01146791f, -0.18708093f, -0.19899207f, -0.09258883f, -0.14658087f, 0.10939636f, 0.11519030f, 
    0.07285148f, 0.04229175f, 0.05319531f, 0.01615695f, 0.35184279f, -0.53749955f, -0.15281805f, -0.33816785f, 
    0.10865819f, 0.06472278f, -0.16239737f, 0.20275664f, -0.13129756f, 0.36680838f, 0.06765692f, 0.00483150f, 
    -0.02901973f, 0.28155947f, -0.09622597f, -0.30070132f, -0.25804290f, -0.23050889f, -0.21249163f, 0.19584113f, 
    0.06417519f, 0.23298930f, 0.24349923f, 0.10030135f, -0.02924079f, 0.09383132f, 0.11565007f, 0.20323229f, 
    -0.01695922f, 0.13021539f, -0.21362524f, -0.01173985f, 0.31382897f, -0.27421796f, 0.07503568f, -0.12855321f, 
    0.34913969f, 0.17674425f, -0.01495181f, 0.20849092f, -0.06298210f, -0.11839984f, 0.15172197f, -0.11019546f, 
    0.13094114f, -0.22783537f, 0.23790580f, -0.38457611f, -0.24057800f, 0.03579788f, -0.14887714f, 0.57237864f, 
    -0.07794318f, 0.20263816f, 0.07995950f, -0.00004658f, -0.17215218f, -0.16287749f, 0.14024243f, 0.45044649f, 
    0.14505942f, -0.15458496f, -0.03765956f, -0.06641576f, 0.32949254f, -0.23742367f, 0.11018931f, 0.11709256f, 
    -0.13915543f, 0.05563655f, 0.46560219f, 0.11764187f, -0.11784305f, -0.05399309f, 0.04970882f, -0.02299402f, 
    -0.43093279f, -0.08030315f, 0.17909464f, 0.02512465f, -0.10026174f, -0.48025292f, -0.35664952f, -0.08183922f, 
    -0.04316400f, 0.19857381f, -0.12731761f, 0.21979260f, 0.08793747f, 0.13792650f, -0.14191326f, 0.66356230f, 
    0.25075495f, 0.01916797f, 0.20287576f, -0.01076817f, -0.14610702f, -0.02035819f, 0.06931015f, -0.70062053f, 
    -0.15128006f, 0.21483739f, 0.04305558f, -0.35779497f, -0.00444830f, 0.06827849f, -0.06928286f, -0.15280329f, 
    0.25775164f, 0.33890843f, 0.23014531f, -0.20737617f, 0.26250586f, -0.44603434f, -0.16194235f, -0.16231695f, 
    0.24375698f, 0.07595301f, -0.09758586f, 0.23496628f, -0.04575742f, -0.16823974f, -0.08271428f, -0.38965395f, 
    0.24604255f, -0.01501758f, 0.25650445f, -0.06299866f, -0.02189919f, 0.55399227f, 0.15768108f, 0.41803551f, 
    -0.03486804f, 0.07821987f, -0.34348002f, 0.04627371f, 0.00364593f, -0.14674652f, -0.04196229f, 0.04596021f, 
    0.51379651f, -0.22218938f, -0.11534033f, -0.29556188f, -0.00474388f, 0.21677798f, 0.05825399f, 0.43407750f, 
    0.07921501f, -0.07835181f, 0.10035370f, -0.01181702f, -0.09681714f, 0.11540212f, -0.16177610f, -0.21339913f, 
    0.00649132f, -0.16175833f, 0.35451758f, 0.01629173f, -0.19233727f, 0.43003088f, -0.15339316f, 0.32410982f, 
    -0.35112736f, -0.02935449f, 0.34087121f, -0.13297814f, -0.01671053f, -0.19878663f, -0.11706687f, 0.19835763f, 
    0.03079448f, 0.05747443f, 0.34493548f, 0.27058625f, -0.02917597f, -0.35933611f, 0.17662445f, 0.06134762f, 
    0.00190071f, 0.24359913f, -0.09363578f, 0.19551562f, -0.00950413f, -0.02028228f, 0.04192699f, -0.12369403f, 
    0.19190581f, -0.06593505f, 0.09541041f, 0.15269119f, -0.10845939f, 0.36100599f, 0.16462110f, 0.35340270f, 
    -0.26366615f, -0.04539328f, 0.31760806f, -0.29803377f, 0.07135162f, -0.07413108f, 0.00403826f, -0.08489863f, 
    -0.04492511f, -0.02709622f, 0.19679151f, 0.21998419f, 0.31619260f, 0.07755618f, 0.13820003f, -0.30909002f, 
    -0.12837978f, -0.07985025f, -0.27202243f, 0.09276231f, -0.14708014f, -0.08747474f, -0.16393685f, 0.08113155f, 
    0.30846292f, 0.10632204f, 0.19715138f, -0.09753270f, 0.25264671f, 0.35438919f, 0.05379438f, 0.64464283f, 
    -0.11028840f, -0.07779135f, -0.20614141f, 0.24595527f, -0.13956469f, 0.30341831f, 0.05177823f, -0.00909797f, 
    -0.02274950f, -0.09898492f, -0.27310914f, -0.19360545f, -0.03690278f, -0.08800461f, -0.02545373f, -0.58040595f, 
    -0.05023777f, 0.18562701f, 0.39359462f, -0.07121937f, 0.00657291f, -0.08231604f, -0.07200201f, 0.12088589f, 
    0.14349626f, 0.07380220f, -0.04117124f, -0.15709485f, 0.05701896f, 0.12840587f, 0.05578177f, -0.42914408f, 
    0.05229395f, -0.09567611f, 0.05521015f, 0.27906007f, -0.14148077f, -0.25328669f, -0.00331313f, -0.12792230f, 
    -0.26336190f, 0.07532929f, 0.32209128f, 0.27446863f, 0.08631749f, -0.12216383f, 0.16765822f, -0.21980919f, 
    0.21587668f, 0.11157706f, 0.14736800f, 0.06792390f, -0.06479133f, 0.04231035f, -0.04464842f, -0.06146905f, 
    -0.35931566f, 0.16094965f, 0.16856258f, -0.16862664f, -0.27922696f, 0.60027587f, -0.14216281f, 0.38787976f, 
    -0.25229686f, -0.13322876f, 0.34554303f, -0.50412977f, -0.11653066f, -0.02959839f, 0.12062278f, 0.01142397f, 
    0.24245997f, -0.04877047f, 0.17837586f, 0.20403613f, -0.09607618f, -0.03816587f, 0.19541159f, -0.33459097f, 
    0.36273953f, -0.19192787f, 0.03698657f, 0.30529481f, -0.12054560f, 0.07220992f, -0.13007742f, -0.09081528f, 
    -0.17402817f, -0.17096838f, 0.08979560f, -0.06377301f, 0.01652297f, -0.07265497f, -0.11953960f, -0.11749429f, 
    0.25052744f, -0.30653504f, -0.14301284f, -0.24392511f, -0.08880889f, -0.02745604f, 0.08759406f, 0.17529926f, 
    0.19944142f, -0.18429844f, -0.29713985f, 0.21287090f, 0.14315236f, 0.13727194f, 0.21777855f, -0.14731883f, 
    -0.37215367f, -0.07928409f, -0.14941150f, -0.25259760f, -0.13062373f, 0.11659504f, 0.13015826f, -0.22039925f, 
    -0.15228039f, 0.09371582f, -0.00014899f, 0.05922514f, -0.00893226f, -0.02731052f, -0.04447823f, 0.11657265f, 
    0.12709925f, -0.06372955f, -0.34013879f, 0.26289561f, 0.01136338f, -0.17412682f, 0.09651166f, -0.16904396f, 
    0.48056492f, 0.35004750f, 0.10340226f, 0.10370344f, -0.10414311f, 0.15308554f, -0.16963677f, -0.00483444f, 
    0.26502532f, 0.18426509f, 0.18176845f, 0.00996250f, 0.04484790f, 0.12613042f, 0.03502935f, -0.37747133f, 
    -0.11882322f, 0.09314233f, -0.14678556f, -0.15754409f, -0.16494906f, -0.05873679f, 0.05373527f, -0.51955193f, 
    0.41222620f, 0.23602465f, -0.20062158f, 0.31868723f, -0.16160561f, 0.14709255f, 0.15038063f, 0.08462705f, 
    0.17578781f, -0.25523981f, -0.06473111f, -0.26529020f, 0.01012276f, 0.22984776f, 0.14016828f, 0.28707510f, 
    0.26744643f, -0.22324513f, -0.09030627f, 0.27964133f, 0.08710152f, 0.09342804f, 0.13719037f, -0.04122386f, 
    0.01010218f, 0.14296205f, 0.25196946f, 0.10955676f, -0.23950838f, -0.11160785f, 0.09784517f, -0.25815260f, 
    -0.20856407f, 0.24994405f, -0.27401713f, 0.01516918f, 0.07670336f, 0.43268695f, -0.16449390f, 0.09017719f, 
    0.01659579f, 0.06463709f, -0.35498166f, 0.16097994f, 0.31008211f, 0.01193808f, 0.12528245f, 0.48693004f, 
    -0.13799104f, 0.07321363f, 0.35929060f, -0.06186865f, -0.08708349f, 0.07653206f, 0.00176515f, -0.26966545f, 
    -0.02805624f, -0.03445148f, -0.16374439f, -0.16775937f, -0.30693474f, 0.07365195f, -0.16845329f, 0.62522054f, 
    -0.48541072f, 0.01572824f, 0.06246022f, 0.37903690f, -0.10682458f, -0.06736605f, 0.11064308f, 0.10627513f, 
    0.08806422f, 0.04006105f, -0.04531644f, 0.51030332f, 0.47658113f, 0.14093079f, 0.03028098f, 0.11504846f, 
    0.24778421f, -0.07220287f, 0.47165948f, -0.14724115f, -0.13826029f, -0.00918604f, -0.01972279f, 0.00031588f, 
    0.01525897f, 0.07474053f, -0.12803546f, 0.09177213f, -0.08564276f, 0.14982411f, 0.14865972f, -0.09670378f, 
    -0.12182036f, -0.16121528f, 0.08713636f, 0.00876519f, -0.10120153f, -0.21044539f, 0.00982729f, 0.14730236f, 
    0.14868748f, 0.21387143f, 0.05419689f, 0.08277393f, 0.12671363f, -0.28548127f, -0.02000859f, -0.45171157f, 
    0.40061125f, 0.18063465f, 0.23435818f, 0.21131858f, 0.02328398f, -0.13433380f, 0.03406411f, 0.13450183f, 
    -0.10644540f, -0.15771563f, -0.10206178f, -0.15239255f, 0.01492398f, -0.08744985f, -0.06547327f, -0.01138679f, 
    0.23897842f, 0.16307952f, -0.26282877f, 0.36499617f, 0.11749575f, 0.10561185f, -0.14509599f, -0.02546156f, 
    -0.14429823f, -0.28040236f, -0.27761543f, -0.04871830f, 0.06132260f, 0.32713246f, 0.17498462f, 0.22215982f, 
    0.29576939f, -0.18021220f, -0.21621865f, 0.22870727f, -0.13469386f, 0.14150088f, -0.04610816f, -0.03387688f, 
    -0.33645183f, 0.04566756f, -0.01032080f, -0.07641045f, -0.29053748f, 0.01521160f, -0.10763818f, 0.01785668f, 
    -0.00660591f, -0.00394902f, -0.25437143f, 0.09150768f, -0.09191671f, -0.25983205f, 0.02519083f, 0.00920851f, 
    0.21268603f, 0.24613038f, -0.11603933f, 0.34459203f, 0.25906333f, 0.06565237f, 0.24508373f, 0.18304029f, 
    0.42289960f, -0.09922138f, -0.09766610f, 0.21722548f, -0.06405001f, 0.07723250f, 0.14724422f, -0.34651342f, 
    -0.05788659f, -0.10240813f, -0.06434223f, 0.05663451f, -0.13917957f, -0.00237794f, -0.01927560f, 0.37219507f, 
    -0.29352975f, -0.04609095f, 0.20898725f, 0.10739820f, 0.04244314f, 0.31886458f, -0.03949156f, -0.07070349f, 
    0.12657425f, -0.02926054f, -0.24314044f, 0.16868414f, 0.17562327f, 0.10809994f, 0.26848257f, -0.33601582f, 
    0.41796124f, 0.17025974f, 0.36084235f, 0.20011763f, -0.10245131f, 0.10972147f, -0.00794051f, -0.47155228f, 
    0.17810743f, 0.11223926f, 0.16371648f, 0.06818902f, 0.18270983f, 0.53764576f, 0.09452358f, 0.32024923f, 
    -0.04191897f, -0.07357877f, -0.09838711f, -0.15333988f, 0.05333049f, 0.06557396f, 0.02486020f, -0.04819471f, 
    0.46267727f, 0.02994366f, -0.22667609f, -0.07407627f, 0.17659168f, -0.15746015f, -0.19634627f, -0.00911517f, 
    -0.02780149f, 0.06234464f, 0.28075129f, -0.08308438f, 0.07524110f, 0.01482368f, 0.06492623f, -0.17136976f, 
    0.27896500f, -0.02370295f, -0.28639358f, 0.16046223f, -0.08671931f, 0.31835127f, 0.15731132f, -0.23007889f, 
    0.38663703f, 0.19736862f, -0.25441128f, 0.03962496f, -0.01244710f, -0.60170859f, 0.09375564f, -0.06448738f, 
    0.06453209f, 0.02822150f, -0.07657939f, 0.02639790f, 0.13784662f, 0.14315100f, 0.25663656f, -0.08946355f, 
    0.28966627f, -0.39159647f, -0.61438346f, 0.18415201f, -0.05360044f, -0.11419491f, 0.15674150f, 0.26548097f, 
    -0.09347604f, -0.06993987f, -0.03137601f, 0.10999159f, 0.04734922f, 0.10915160f, -0.00606511f, -0.13214684f, 
    -0.17828101f, -0.00868878f, 0.03832467f, -0.18630691f, 0.13003893f, -0.03255819f, 0.14717238f, -0.11199539f, 
    -0.15251215f, -0.07700293f, -0.15332893f, -0.08187835f, -0.14110413f, 0.07027197f, -0.19574793f, -0.12913014f, 
    0.14092903f, -0.15197293f, 0.08972047f, -0.06538554f, 0.12106370f, 0.12437503f, -0.02445036f, 0.08863816f, 
    -0.07503968f, 0.16735169f, -0.12402806f, 0.00644923f, -0.00956597f, -0.14055254f, -0.01311009f, 0.06947967f, 
    -0.15249181f, -0.11990174f, -0.06566445f, -0.05723671f, -0.17604852f, 0.08415234f, -0.05051603f, 0.14342757f, 
    0.00231003f, -0.04447483f, -0.04180513f, 0.11043424f, -0.04919000f, 0.03220301f, 0.00089151f, 0.10601257f, 
    -0.09543099f, -0.00979673f, -0.17500000f, 0.00470657f, 0.12699945f, 0.15036333f, 0.05044172f, 0.02434037f, 
    0.39547223f, 0.15070261f, 0.21631382f, 0.00581053f, -0.18934387f, 0.13246921f, -0.11467642f, -0.34835988f, 
    -0.03252698f, 0.16058503f, 0.04749285f, 0.17589051f, -0.16715664f, -0.42484754f, 0.05076639f, -0.15678366f, 
    -0.18426889f, 0.24620533f, 0.26297042f, 0.54854751f, 0.43507233f, -0.21439795f, 0.20801291f, 0.01551448f, 
    0.12476092f, 0.04290926f, -0.16531727f, -0.02011622f, -0.04436348f, -0.00703283f, -0.08937394f, -0.19547865f, 
    -0.29439390f, 0.13048254f, -0.09250594f, 0.00289541f, -0.04782079f, -0.33483297f, 0.16282868f, 0.05312203f, 
    0.13202199f, -0.21690454f, 0.13165587f, 0.47853914f, 0.06949604f, 0.01722689f, 0.10563946f, -0.06349330f, 
    0.18182430f, 0.11769187f, 0.21184427f, -0.05407872f, 0.09026125f, 0.11962561f, 0.07709032f, -0.19750211f, 
    0.17814086f, 0.21470338f, 0.27128923f, 0.01455625f, -0.15986791f, -0.00010017f, -0.11739457f, -0.05621618f, 
    0.43821773f, 0.00566309f, 0.21124904f, -0.18162490f, 0.35140842f, 0.38614815f, -0.04830223f, 0.14249234f, 
    0.22880135f, 0.00486981f, 0.00525703f, -0.55863863f, 0.15065950f, 0.16220690f, 0.07643525f, 0.05719147f, 
    -0.01676573f, 0.12669012f, -0.01796935f, 0.00236933f, 0.08747486f, -0.16754153f, -0.26631701f, -0.40405697f, 
    -0.45749521f, 0.17969660f, 0.07076475f, -0.04432290f, -0.06940114f, 0.01488698f, 0.00357349f, -0.14760983f, 
    -0.51583314f, -0.13284470f, -0.17117201f, -0.13185845f, 0.20160119f, -0.18785207f, -0.03258030f, 0.22390632f, 
    0.19999595f, -0.27738130f, 0.43181410f, -0.18001458f, -0.10393145f, 0.35566384f, -0.11297954f, 0.00361393f, 
    -0.04243749f, -0.05291638f, 0.30740255f, 0.07371114f, -0.29444593f, 0.21746027f, 0.12571414f, 0.14349523f, 
    0.04773439f, 0.18525538f, -0.03301005f, 0.05389456f, 0.10264050f, 0.03852116f, -0.10205873f, 0.14204445f, 
    0.29833680f, 0.05838317f, -0.09346136f, -0.03707350f, -0.08170514f, -0.58781880f, -0.09630277f, -0.58757693f, 
    -0.19036378f, 0.20242053f, 0.10507283f, -0.08254828f, -0.16627090f, 0.17509304f, -0.15444149f, -0.14765418f, 
    0.01511590f, 0.07119438f, -0.41320556f, -0.00257269f, -0.08328329f, -0.00047681f, -0.25948322f, 0.52033222f, 
    -0.10482042f, 0.23643528f, -0.12740634f, 0.12188396f, -0.11434334f, -0.10247327f, -0.06419822f, 0.46451348f, 
    -0.29654443f, 0.01287786f, 0.13726850f, -0.16366394f, -0.22045647f, -0.14982161f, 0.16683447f, 0.21837309f, 
    0.21228285f, 0.12941499f, 0.49345911f, -0.22425574f, 0.02630808f, 0.27015164f, 0.02912797f, -0.13726029f, 
    -0.37048730f, 0.02799224f, 0.06261199f, 0.02500778f, 0.29015729f, -0.05610931f, -0.13106871f, 0.33243248f, 
    -0.12724783f, -0.18428002f, 0.01269505f, 0.19836527f, 0.17857152f, 0.00947892f, -0.12854899f, -0.48520499f, 
    0.43490463f, 0.13041694f, -0.08443293f, -0.11831847f, 0.23589301f, -0.05106537f, 0.00468401f, -0.18081757f, 
    0.05642983f, 0.28462511f, 0.14515986f, 0.24862729f, 0.11507526f, 0.13402417f, 0.05116631f, 0.06409207f, 
    -0.10682753f, 0.03005647f, -0.21265981f, -0.10504036f, -0.07886051f, -0.21103947f, 0.08441531f, -0.15390185f, 
    -0.32997978f, 0.25139391f, 0.13340636f, -0.06754454f, 0.08577217f, 0.09632466f, 0.06376231f, 0.22321063f, 
    -0.02103675f, 0.11661019f, 0.06007696f, 0.15835799f, 0.14810061f, -0.11548844f, 0.01857028f, 0.02208953f, 
    0.33317721f, 0.31972173f, 0.34862015f, -0.12659252f, 0.14973700f, -0.22806960f, -0.00414518f, -0.15993552f, 
    -0.36881766f, -0.01156600f, 0.38546863f, 0.02097213f, -0.01989037f, 0.07748508f, -0.02933246f, 0.26041573f, 
    0.04852235f, -0.10986719f, -0.20793128f, 0.01407185f, -0.01337842f, -0.00540826f, 0.12712434f, 0.27274317f, 
    0.08857188f, -0.11490265f, 0.00889219f, -0.06714937f, -0.10363439f, 0.17364165f, -0.02521484f, 0.16402845f, 
    -0.12439763f, 0.03904587f, 0.51895124f, -0.19717377f, -0.08359684f, 0.36783016f, -0.12543049f, 0.10675941f, 
    -0.37273172f, -0.29875806f, 0.13355045f, -0.13484421f, -0.20318870f, -0.11615673f, -0.08328676f, -0.37298280f, 
    -0.15696332f, 0.11688510f, 0.05729388f, 0.26770952f, -0.11598919f, -0.15376107f, -0.08205990f, 0.03229950f, 
    -0.13463685f, 0.10418577f, -0.11857495f, -0.08118071f, 0.06712924f, -0.21275921f, -0.05507741f, -0.29214430f, 
    0.26312715f, 0.02376401f, 0.01153040f, 0.08966685f, 0.01064300f, 0.17383923f, 0.07396548f, 0.01711226f, 
    0.47634959f, -0.26820073f, 0.19681576f, -0.42847881f, -0.19598645f, -0.09097636f, 0.12660813f, 0.33755279f, 
    -0.01955718f, -0.01219014f, -0.03930951f, 0.15484534f, 0.08310686f, 0.09105624f, 0.11898571f, 0.28647026f, 
    0.00920464f, 0.16762820f, 0.07645446f, -0.00586373f, -0.01477404f, 0.28721690f, -0.13962753f, -0.26596588f, 
    0.09089426f, 0.02436345f, -0.21190076f, 0.04413972f, 0.02848314f, 0.01842784f, 0.07283235f, 0.03487500f, 
    -0.02090436f, 0.14759167f, -0.13424493f, 0.13899907f, 0.01220385f, 0.10035514f, 0.20782083f, -0.49523550f, 
    0.22860551f, -0.04681263f, 0.20616059f, 0.15552008f, -0.17464863f, 0.09052379f, -0.05964005f, -0.09584898f, 
    0.33609024f, 0.07353790f, -0.03212774f, 0.05787110f, 0.03222344f, 0.31496710f, -0.17392750f, -0.34725177f, 
    -0.80967289f, 0.16346583f, -0.13648221f, 0.45371446f, -0.11229703f, 0.10163955f, -0.12306845f, -0.06868999f, 
    -0.13747807f, -0.30324489f, -0.23123513f, 0.11782178f, 0.11467515f, -0.07348870f, 0.51134217f, -0.23196594f, 
    0.20696390f, -0.14441095f, 0.00260801f, 0.15155655f, 0.03728757f, 0.04041284f, 0.12800269f, 0.40427476f, 
    -0.17416155f, 0.05866123f, 0.08706903f, 0.04827000f, -0.02300627f, 0.10284309f, -0.03081832f, -0.13652349f, 
    -0.05762100f, 0.09730158f, -0.05210844f, 0.01224083f, 0.01652250f, 0.12268411f, 0.12691784f, -0.12876661f, 
    -0.03108255f, 0.00536713f, 0.08224624f, 0.03148740f, -0.12666808f, -0.06357490f, -0.09052649f, -0.00750871f, 
    -0.05918383f, -0.04618948f, 0.01505785f, -0.19538450f, 0.12135682f, -0.12047002f, 0.14473464f, 0.12813994f, 
    0.18577076f, -0.02566128f, -0.09457268f, -0.03888297f, 0.26303947f, -0.13613576f, -0.03902940f, -0.09666771f, 
    -0.36010939f, -0.06734484f, -0.13618986f, 0.35583445f, -0.00347339f, -0.02629395f, -0.01988460f, -0.13945347f, 
    -0.20485343f, 0.43226889f, -0.19757923f, 0.14081332f, 0.18517408f, -0.11958569f, -0.05858051f, -0.33532315f, 
    0.24445939f, -0.00868840f, 0.07788785f, -0.02557430f, -0.01430270f, -0.11123261f, -0.13199143f, 0.11036846f, 
    0.42158684f, -0.00586315f, -0.19234678f, -0.01717560f, 0.30362442f, 0.12071879f, -0.03938486f, -0.64315528f, 
    0.03946889f, 0.33357769f, 0.14836447f, 0.29158533f, -0.00892222f, 0.13095719f, 0.01547768f, -0.13999812f, 
    -0.32151446f, 0.15131757f, -0.01804691f, -0.03953803f, -0.00009650f, -0.30119863f, -0.07815926f, -0.10765385f, 
    0.13363315f, 0.07305598f, -0.10706025f, 0.20248483f, 0.11523094f, -0.09450383f, -0.13663360f, 0.23066649f, 
    -0.12730832f, 0.13130206f, -0.09987939f, -0.16959523f, -0.07671322f, -0.18005209f, 0.13982116f, -0.13195965f, 
    -0.19379994f, -0.13161607f, 0.14721778f, -0.10985183f, 0.13905762f, 0.15327987f, 0.00071007f, -0.08325670f, 
    0.10836814f, -0.10267276f, -0.12983799f, -0.11018094f, -0.16742387f, -0.11700013f, -0.04482246f, 0.03585862f, 
    0.00038605f, 0.00648702f, -0.12075638f, 0.02215054f, 0.06520134f, -0.01629568f, 0.00792996f, 0.13566449f, 
    0.34809169f, -0.02083242f, 0.17387636f, -0.11153671f, 0.31837875f, 0.11138435f, -0.14420138f, 0.10274251f, 
    0.06167863f, 0.15679473f, 0.06694935f, -0.30493054f, -0.11335007f, 0.35469636f, 0.15888508f, -0.10876504f, 
    0.12644373f, 0.10926197f, 0.00939343f, -0.40161714f, -0.29189011f, -0.25423717f, -0.34710079f, 0.31210062f, 
    -0.27111521f, 0.06840885f, -0.00554382f, 0.04085760f, -0.14010008f, 0.15309314f, 0.14378674f, 0.33638334f, 
    -0.11454488f, 0.02513725f, 0.09608262f, 0.13194670f, -0.00191036f, 0.39372566f, 0.15600543f, 0.48809627f, 
    -0.04678342f, -0.16343306f, 0.27920383f, 0.04279219f, 0.18216015f, 0.32793227f, 0.09455824f, -0.01662175f, 
    0.24045025f, -0.39447117f, 0.13135991f, -0.26820847f, -0.09656304f, -0.13999228f, -0.03886212f, -0.18660827f, 
    0.10829203f, 0.06372856f, 0.24723510f, 0.26678574f, -0.01541954f, -0.11067809f, 0.05559880f, -0.05048134f, 
    0.27931765f, 0.03788730f, -0.32183817f, 0.14107300f, -0.20128186f, 0.23255880f, 0.09229146f, -0.13749777f, 
    -0.25437394f, -0.17006551f, -0.22748508f, 0.41355076f, 0.03564100f, -0.01033859f, -0.08460609f, -0.12094007f, 
    0.14783372f, -0.05325505f, -0.24114010f, 0.25197852f, 0.23998311f, 0.19973312f, 0.28423816f, -0.34998879f, 
    0.31196144f, -0.13102186f, 0.38735712f, 0.03822698f, 0.03462631f, -0.05318889f, 0.11023826f, 0.13824390f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09105837f, 0.23818167f, 0.22910586f, 0.06366039f, 0.30703455f, 0.24315579f, -0.06751361f, 0.09702021f, 
    -0.07994387f, 0.24325320f, -0.02398608f, 0.26059154f, -0.09165782f, 0.02760557f, -0.10272154f, -0.16393314f, 
    0.04500315f, 0.17410582f, 0.37150744f, -0.19216195f, 0.14342961f, -0.15253334f, 0.09913865f, 0.10851877f, 
    0.10834177f, 0.20155333f, -0.02431547f, 0.14915158f, -0.10577220f, 0.23633659f, 0.17140542f, -0.05769785f, 
    -0.17562981f, 0.13294329f, 0.04178659f, -0.10592765f, -0.06675424f, 0.12736686f, 0.05654795f, 0.07181704f, 
    0.20412891f, -0.10723303f, -0.08422906f, 0.01815939f, -0.14986798f, -0.09247281f, 0.12925336f, -0.09490456f, 
    -0.13494603f, 0.16115838f, -0.00379879f, 0.16905202f, -0.26509494f, 0.07211706f, 0.22891106f, 0.09363440f, 
    0.06855495f, -0.16235203f, 0.03102978f, 0.22017246f, -0.01747032f, 0.14407486f, 0.11097322f, 0.18773592f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.21404147f, -0.13892248f, -0.35790420f, -0.05183859f, 0.16974863f, 0.28629607f, 0.03949472f, -0.04291815f, 
    0.13748652f, -0.19058327f, 0.31148070f, -0.56339890f, 0.16979997f, 0.24990360f, 0.20266438f, 0.10500397f, 
    -0.25542346f, 0.02391410f, -0.67186821f, -0.07807720f, -0.18905763f, 0.00742607f, -0.01863748f, 0.28197828f, 
    0.00498592f, -0.65266365f, 0.10691056f, -0.42995924f, -0.13936441f, -0.04561046f, -0.23190844f, -0.34680066f, 
    0.15197626f, 0.08504277f, 0.10069690f, 0.03415818f, -0.33787826f, -0.48900145f, 0.11372021f, -0.01860488f, 
    -0.58197349f, 0.06935550f, 0.26263466f, 0.07258470f, -0.02389203f, -0.15673208f, -0.03980859f, -0.07267944f, 
    -0.00259411f, 0.24809496f, -0.12657598f, 0.02462911f, 0.26205683f, -0.40808639f, 0.23740624f, -0.23127888f, 
    0.09410842f, -0.03227406f, -0.62662280f, -0.04098572f, -0.07992493f, 0.27475035f, -0.36863837f, -0.27388704f, 
    -0.20056978f, -0.32389456f, 0.08183859f, 0.01568082f, 0.19953710f, 0.17321374f, 0.13086157f, 0.01034321f, 
    0.05964947f, -0.07390270f, -0.94902265f, 0.13059951f, 0.17544028f, 0.07957727f, 0.09823388f, 0.07105757f, 
    -0.43288106f, 0.12980835f, 0.13424604f, -0.59849906f, 0.46947783f, -0.07285882f, 0.25079972f, 0.32809213f, 
    0.30591157f, 0.11028437f, -0.08772608f, 0.02008104f, -0.21455009f, -0.15795626f, -0.00005230f, -0.14836395f, 
    0.03219788f, -0.00393153f, 0.06496004f, 0.01734048f, -0.51032913f, -0.01255485f, -0.09242259f, -0.26740363f, 
    -0.18795438f, -0.10015567f, -0.39191589f, -0.07216659f, 0.00040168f, -0.19230077f, 0.06919530f, -0.10992857f, 
    0.08253647f, 0.39161971f, -0.10539135f, 0.04469957f, 0.01470559f, 0.08776802f, 0.37307891f, -0.25038108f, 
    -0.15836444f, -0.09448677f, -0.61535025f, 0.08918877f, -0.10332978f, 0.33678669f, 0.13581368f, -0.53022194f, 
    0.12449629f, 0.26063737f, 0.06078647f, 0.46959662f, -0.01028625f, -0.54012281f, -0.35717288f, -0.11489087f, 
    -0.65417504f, -0.04223989f, -0.24441421f, 0.07839023f, -0.67993736f, 0.23603764f, -0.08237340f, -0.08699789f, 
    -0.20856875f, -0.19352257f, -0.00254641f, 0.03318900f, -0.85537094f, 0.03034444f, 0.19945458f, -0.09926510f, 
    -0.30451131f, -0.07597413f, -0.02590671f, -0.18728849f, -0.21550666f, 0.36490726f, -0.02809644f, -0.10922094f, 
    0.30159247f, -0.12977171f, 0.15784837f, 0.15077931f, -0.15055104f, -0.06728776f, 0.08772614f, -0.13322979f, 
    0.26452902f, 0.04225158f, -0.73347205f, -0.03553017f, 0.09316598f, -0.49991801f, 0.09021767f, 0.13708708f, 
    -0.07771087f, -0.39956534f, -0.09857820f, 0.17712332f, -0.55028540f, 0.24523669f, 0.09534010f, 0.14331760f, 
    0.31638727f, 0.06650463f, 0.01460666f, 0.00536363f, -0.02516507f, 0.05554781f, 0.29132277f, 0.26382649f, 
    -0.09581088f, 0.16385405f, -0.19224659f, 0.30152285f, -0.34797594f, -0.01411747f, 0.01126968f, -0.73729682f, 
    -0.26764098f, -0.33149400f, 0.26701048f, -0.27965555f, 0.15350090f, 0.44662654f, -0.28909355f, -0.24842218f, 
    -0.24037550f, -0.18773350f, -0.45890522f, 0.53484857f, -0.71779698f, 0.06730361f, -0.22499557f, -0.04788008f, 
    0.12611403f, 0.14526947f, -0.14422204f, -0.14148450f, 0.05557130f, -0.27504361f, 0.05779751f, 0.15568724f, 
    0.09046526f, -0.73566777f, 0.18035024f, -0.43835616f, -0.60280180f, 0.14666240f, 0.19925763f, 0.11009938f, 
    -0.00079504f, -0.31599703f, 0.37522635f, -0.06330622f, -0.10216987f, 0.01898317f, -0.77966750f, 0.19868292f, 
    -0.68838692f, -0.13667539f, -0.14995819f, -0.07459278f, 0.01870876f, 0.14323166f, 0.02173683f, 0.19248234f, 
    0.15837646f, -0.05594253f, -0.11256575f, 0.14606921f, 0.08619617f, -0.20837082f, 0.08079243f, 0.15058199f, 
    0.09304015f, 0.01817556f, -0.04423436f, -1.03108609f, 0.15263332f, 0.16862909f, -0.36869085f, 0.09428667f, 
    0.09797435f, -0.13833077f, 0.15807767f, -0.20729105f, 0.20134930f, -0.24421382f, 0.13948259f, 0.07383756f, 
    -0.02912042f, -0.22444496f, 0.01670990f, -0.32108852f, 0.15597382f, -0.05216726f, -0.22200665f, 0.03813986f, 
    -0.25475574f, -0.32122177f, 0.12878495f, -0.07906356f, -0.02081328f, -0.31397691f, 0.12627947f, -0.28434432f, 
    -0.15890755f, -0.11358670f, 0.19109999f, 0.25063130f, 0.53638345f, -0.19325119f, 0.20082533f, 0.17064615f, 
    -0.00537371f, -0.48234034f, 0.00234868f, 0.05839565f, 0.03445683f, 0.26170340f, -0.08703843f, 0.16674589f, 
    0.08288567f, -0.08877299f, 0.16351476f, -0.11920521f, 0.06463997f, -0.36676037f, -0.13895048f, -0.10736477f, 
    0.24157265f, 0.00046140f, -0.03696472f, -0.02176041f, 0.06475697f, -0.53387016f, -0.18615375f, 0.25705698f, 
    -0.05560589f, -0.03892668f, 0.12265366f, -0.31108451f, -0.15880205f, 0.07142245f, 0.36269516f, 0.08622325f, 
    0.21034713f, 0.25978789f, -0.16445754f, 0.05054481f, -0.18409492f, -0.52324361f, 0.22024624f, 0.25930017f, 
    0.02068047f, 0.06757667f, -0.14925624f, 0.00129059f, -0.25782615f, 0.00810659f, 0.18545985f, 0.05449336f, 
    0.24424890f, -0.22851650f, -0.28359666f, -0.11119281f, -0.17124136f, 0.22138287f, 0.13801914f, -0.42835754f, 
    -0.02184119f, -0.00225385f, -0.22085676f, -0.08581760f, 0.18946676f, 0.13056669f, -0.09546904f, -0.19097698f, 
    -0.04795800f, -0.21950510f, -0.12425860f, 0.04686062f, -0.02159868f, 0.13792486f, 0.02412986f, -0.14231499f, 
    -0.19836277f, 0.16854727f, -0.54786235f, 0.20454615f, -0.01493752f, -0.16129151f, -0.30580217f, 0.02058341f, 
    0.19291869f, -0.10015091f, 0.59186530f, 0.18611629f, -0.06436179f, -0.01667583f, -0.28486797f, 0.19061112f, 
    0.27837029f, -1.00095737f, 0.02594225f, 0.20364353f, -0.40268692f, -0.77949542f, -0.17112009f, 0.15712917f, 
    -0.49344930f, -0.15007876f, -0.64128774f, -0.18919049f, -0.80421281f, 0.18043908f, -0.22859852f, -0.15080217f, 
    -0.25331914f, 0.06401557f, -0.28575429f, 0.49502257f, 0.26425815f, 0.00382869f, -0.21705851f, -0.10721704f, 
    -0.76074129f, -0.47173384f, 0.34975004f, 0.01737493f, 0.02759157f, 0.30605736f, -0.14881863f, 0.29695296f, 
    -0.18512163f, 0.23791455f, -0.22989821f, -0.14957158f, 0.32379982f, 0.14295155f, 0.00145809f, 0.23726104f, 
    0.30066413f, 0.37271920f, -0.45591700f, 0.10927018f, -0.02811001f, -0.48844597f, 0.05012113f, -0.01932640f, 
    0.05849436f, -0.12365669f, -0.03554941f, -0.42657444f, -0.31108037f, -0.08345076f, -0.14378828f, 0.02554844f, 
    -0.65180558f, -0.11596394f, -0.11308487f, -0.95501709f, 0.04616731f, 0.10680516f, 0.26832479f, 0.18537055f, 
    -0.11618093f, 0.44813257f, -0.33699915f, 0.25237486f, -0.03881538f, -0.40605983f, -0.10512015f, 0.05958529f, 
    -0.07384907f, 0.04041141f, 0.41066644f, 0.10353108f, -0.74689388f, -0.11211953f, 0.04999473f, 0.15134183f, 
    -0.03079244f, -0.32043880f, 0.07568692f, 0.53924543f, -0.40866542f, -0.13895236f, 0.05398776f, 0.16183233f, 
    -0.61452222f, 0.16937047f, -0.26077816f, -0.23246422f, -0.23458423f, -0.31288064f, 0.13319001f, -0.13578135f, 
    -0.07473804f, 0.14874633f, 0.15134269f, -0.39372951f, -0.16267876f, 0.02697175f, 0.14527597f, -0.00132780f, 
    -0.10465313f, 0.13090749f, 0.14738812f, 0.06555766f, -0.09298602f, -0.02954204f, 0.14792882f, 0.14355141f, 
    0.15841372f, -0.51315260f, 0.11774020f, -0.04643771f, 0.22479266f, -0.11163388f, -0.00002747f, 0.04033859f, 
    -0.97895092f, 0.07898350f, -0.44489208f, 0.12108965f, 0.09951701f, -0.14557487f, -0.20725566f, -0.07340322f, 
    -0.38292325f, -0.05529649f, 0.02220053f, -0.06919571f, 0.25833142f, -0.64170295f, 0.35712627f, -0.33208105f, 
    0.34534612f, 0.28048447f, 0.05152537f, 0.20259891f, -0.73654485f, -0.27668881f, -0.34074914f, -0.43209812f, 
    0.54549330f, -0.06413465f, 0.19142404f, -0.22044043f, -0.17961305f, -0.13847132f, -0.28458488f, -0.19094341f, 
    0.11235090f, -0.01012902f, 0.22763683f, 0.20644176f, 0.23866828f, 0.39858064f, 0.07842519f, 0.05574378f, 
    0.22027516f, -0.27997893f, -0.66085666f, -0.03767409f, -0.28039134f, -0.01939131f, -0.57215446f, -0.51688713f, 
    -0.13156702f, 0.31563434f, -0.17301416f, -0.05751680f, -0.11473379f, 0.14869648f, -0.30036125f, 0.36038271f, 
    -0.17797382f, -0.56053460f, -0.04255458f, 0.13639209f, 0.05073453f, 0.22263458f, -0.51369971f, -0.08548025f, 
    -0.15828849f, 0.06972830f, -0.47401646f, -0.01907268f, 0.01611782f, 0.31200171f, 0.15758529f, -0.18484320f, 
    0.19135018f, -0.08129681f, 0.16637963f, -0.28503823f, -0.16055334f, -0.09183224f, -0.52966654f, 0.13220426f, 
    -0.34630513f, -0.34429163f, -0.14396407f, -0.20631595f, 0.14688382f, -0.04640511f, -0.42841059f, 0.13661394f, 
    -0.00451111f, 0.03924442f, 0.27593541f, -0.28260034f, -0.25711474f, -0.12278633f, -0.20976478f, -0.28339726f, 
    -0.69330984f, 0.34650439f, 0.26997158f, 0.16243951f, 0.08496272f, -0.15779130f, 0.19191836f, 0.14833200f, 
    -0.23521788f, 0.24558234f, 0.05407923f, 0.08320767f, 0.08031950f, 0.23789641f, -0.17924237f, 0.37537292f, 
    0.01226203f, 0.12716807f, 0.24264197f, -0.03168539f, 0.08180663f, 0.35278749f, 0.08088108f, -0.21382488f, 
    -0.29477510f, -0.45376602f, -0.50147885f, -0.38901779f, -0.51108348f, -0.33105919f, 0.17222615f, 0.18552189f, 
    0.21746576f, 0.00823523f, -0.08474616f, -0.29344600f, -0.05064837f, -0.30395898f, -0.04982927f, 0.25886929f, 
    -0.39943859f, 0.18893783f, 0.10649236f, 0.09096985f, -0.80606973f, -0.31961760f, -0.17364891f, -0.41004515f, 
    0.15664341f, 0.32442909f, -0.81441861f, 0.11958025f, -0.04422265f, 0.29369703f, 0.16209650f, -0.53584462f, 
    0.24859025f, 0.20952545f, 0.32167071f, 0.23748299f, -0.84232754f, 0.02402808f, 0.18679537f, -0.84173661f, 
    -0.07282963f, 0.54945761f, -0.37477237f, -0.02416740f, -0.01303929f, -0.35478100f, -0.03110224f, -0.14198892f, 
    -0.00624807f, 0.01347598f, -0.14629088f, 0.44388655f, -0.02407127f, -0.00429681f, -0.18704447f, 0.25307468f, 
    0.10729761f, -0.31407136f, -0.11316447f, 0.07192899f, -0.00768245f, 0.29079190f, -0.24820192f, 0.03972686f, 
    -0.64967382f, 0.07844327f, 0.44723848f, 0.08395570f, -0.12452152f, -0.08362721f, -0.72444659f, 0.03404743f, 
    -0.35566238f, 0.00954340f, 0.21716674f, 0.06178850f, 0.01444090f, 0.07747895f, -0.41624543f, -0.41453618f, 
    0.21541651f, 0.13905986f, 0.17951685f, 0.17982665f, 0.08399658f, -0.25171030f, -0.45391381f, -0.00995403f, 
    0.29638225f, -0.18045032f, -0.28122023f, 0.04480210f, -0.18281481f, 0.11661495f, -0.17786336f, -0.27556157f, 
    -0.08975197f, 0.09714889f, -0.14873710f, -0.53505474f, 0.12353378f, -0.12768222f, -0.55558026f, -0.50862497f, 
    0.17942455f, -0.20959193f, -0.56962991f, 0.23732212f, 0.36652091f, -0.22259377f, 0.12812014f, 0.32037684f, 
    0.23335037f, -0.37412104f, -0.38696551f, -0.23463939f, 0.19845544f, 0.03933176f, -0.29704335f, -0.01018718f, 
    0.17929439f, -0.74083108f, -0.34815744f, -0.00968034f, 0.01328573f, 0.16244596f, -0.03699870f, -0.44465545f, 
    0.19282746f, -0.51086515f, 0.32118776f, -0.26304457f, 0.11118983f, 0.37481093f, -0.29696059f, -0.08053261f, 
    -0.01152712f, 0.03558835f, -0.30504578f, -0.23837306f, -0.03424566f, -0.51831686f, 0.17269070f, -0.01515973f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09784328f, 0.15294303f, 0.14384349f, 0.04065072f, -0.19320102f, 0.04966235f, -0.03242159f, 0.00965588f, 
    0.11931524f, 0.04100534f, 0.04980668f, -0.03417719f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
