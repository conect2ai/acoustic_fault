#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14249042f, -0.52167946f, -0.35443622f, -0.63538098f, -0.42167398f, -0.16347022f, -0.34402066f, -0.39710984f, 
    -0.35389307f, -0.65630370f, -0.56837785f, -0.32993820f, 0.49445108f, -0.09603596f, -0.76543576f, -0.47115794f, 
    -0.13410950f, -0.52967292f, 0.23787099f, 0.27008447f, 0.01530485f, 0.20052607f, -0.22859164f, 0.19412342f, 
    -0.29975280f, 0.21183701f, 0.02614958f, -1.08960414f, 0.70909011f, -0.28805527f, -0.38433743f, 0.35004863f, 
    0.56115466f, -0.54221284f, 0.23118435f, 0.21395601f, 0.21513277f, -0.69017088f, 0.69405359f, -0.28242540f, 
    -0.33756784f, 0.04717317f, -0.05171879f, -0.07738142f, 0.46061736f, 1.14062095f, -0.46910796f, -1.04967320f, 
    0.22875446f, -0.15329151f, 0.62505454f, -0.16698717f, -0.10181414f, -0.13060707f, 0.18597397f, -0.51328433f, 
    0.09954338f, 0.14926791f, -0.24669744f, 0.16472228f, 0.25787723f, 0.04860104f, -0.12054114f, 0.13458027f, 
    0.15292716f, -0.02426245f, -0.25750256f, 0.47751853f, -0.08958407f, -0.30910388f, 0.37987801f, 0.11044551f, 
    -0.40673760f, -0.24400254f, 0.86788476f, -0.28022718f, -0.76342219f, -0.40645212f, 0.16949099f, 0.16004810f, 
    0.25589076f, -0.67557359f, 0.50875360f, -0.02071482f, 0.12860681f, 0.41891560f, -0.04317494f, 0.20930339f, 
    -0.34279105f, -0.29649553f, -0.49699739f, -0.40460420f, -0.40805346f, -0.18753923f, -0.20811605f, 0.53142905f, 
    0.45362192f, 0.18945940f, 0.13484035f, -0.50572485f, -1.21196866f, -0.04689484f, 0.72882921f, 0.62942857f, 
    -0.10173928f, 0.06683905f, -0.03750728f, 0.00691545f, 0.14568038f, 0.49144158f, -0.56127089f, -0.31395414f, 
    0.27878940f, 0.11800424f, -0.05225421f, 0.37222373f, -0.15023507f, -0.16334040f, 0.28802028f, -0.61609691f, 
    -0.60488278f, 0.91292775f, -0.51268828f, -0.24770863f, -0.18410286f, -0.50499314f, -0.74550450f, -0.39600658f, 
    -0.50069976f, 0.51665813f, 0.64308310f, 0.17603971f, -0.46405029f, -0.54418033f, -0.53629535f, -0.35722187f, 
    -0.39070541f, -0.20292032f, -0.26501894f, -0.47226915f, -0.81194937f, 0.04918602f, 0.15761684f, 0.34756902f, 
    0.69922841f, -0.48284471f, -0.62604487f, 0.03819091f, 0.42956230f, 0.37423360f, -0.11723810f, -0.31184852f, 
    -0.01992107f, -1.07116151f, 0.46877071f, 0.57291561f, -0.42542583f, 0.00650681f, 0.38124046f, 0.21646094f, 
    0.27468196f, -0.41135770f, -0.73649454f, 0.02596710f, -0.32134932f, -0.02194995f, 0.05142803f, -0.10883373f, 
    0.36171448f, 0.25376639f, 0.12409431f, -0.62731582f, 0.12972696f, 0.72886294f, -0.16668002f, -0.00869335f, 
    -0.33536404f, 0.06171158f, 0.06924380f, 0.14380178f, 0.45520225f, 0.02376235f, -0.04669362f, -0.08689623f, 
    0.49220386f, 0.20500256f, -0.20248681f, 0.40503752f, -0.29243481f, -0.27453905f, 0.70358634f, -0.25069469f, 
    -0.41436279f, -0.26428562f, 0.52326393f, -0.05277378f, 0.26082093f, -0.12705697f, 0.60545421f, -0.46706247f, 
    0.05450806f, 0.03251055f, -0.07493759f, -0.10574342f, 0.14762473f, -0.08297384f, 0.08973866f, -0.16998494f, 
    0.35423622f, -0.19143769f, 0.25481021f, -0.12760945f, 0.25021651f, 0.12033980f, -0.26176819f, -0.20753714f, 
    0.44137609f, 0.04276633f, 0.23334490f, -0.06508821f, 0.28836107f, -0.46346593f, -0.19363849f, -0.10516723f, 
    0.34890783f, -0.97871041f, 0.08873197f, 0.55743414f, 0.11845407f, 0.06960987f, -0.25734526f, 0.21365225f, 
    -0.49830219f, -0.56531918f, 0.26428649f, -0.54545569f, 0.45901644f, -0.43389452f, -0.04768874f, 0.25161666f, 
    -0.33960417f, 0.27156278f, 0.20171985f, -0.66583824f, -0.56570870f, -0.46096754f, 0.58686596f, -0.80947250f, 
    -0.56167197f, 0.06809146f, 0.39313075f, 0.05850830f, 0.29241738f, -0.69961888f, -0.79616165f, 0.56241989f, 
    0.26980352f, 0.56767219f, -0.30485344f, -0.11658236f, 0.01957368f, -0.53960431f, 0.16277044f, -0.70013535f, 
    -0.25148031f, -0.55231827f, -0.15182690f, -0.08176674f, -0.35500318f, 0.32088590f, 0.46044347f, 0.84117413f, 
    -0.40683517f, -0.72809458f, -0.67084670f, -0.70310527f, -0.18905467f, 0.20267329f, 0.18852156f, -0.00594574f, 
    0.16863863f, 0.06298611f, -0.45502439f, 0.39793581f, -0.00518162f, -0.32479793f, 0.17609611f, 0.20859781f, 
    -0.34620512f, -0.45979440f, 0.77453822f, -0.58195949f, -0.73640573f, -0.46128404f, 0.23120211f, -0.67832303f, 
    -0.05927888f, 1.00527978f, -0.42950931f, -0.22337608f, 0.59360760f, -0.31646854f, -0.57251692f, -0.40009388f, 
    -0.04569368f, 0.05115422f, -0.62360907f, -0.34592816f, 0.35057557f, 0.22066598f, 0.30669048f, 0.07854570f, 
    -0.08013538f, 0.12522914f, 0.08932743f, 0.41565725f, 0.17147276f, -0.19136831f, -0.11361148f, -0.05511076f, 
    0.07150996f, -0.13342769f, -0.07649206f, 0.26186219f, 0.73531932f, 0.31178674f, -0.96902233f, -0.37330699f, 
    -0.18029469f, 0.21127728f, 0.19529314f, -0.25846496f, 0.43670943f, 0.88176990f, -0.78787589f, -0.59606242f, 
    0.10349490f, 0.25609881f, 0.21271122f, -0.00391676f, 0.26935250f, -0.31509981f, -0.99532801f, -0.00044987f, 
    0.86239624f, 0.13333321f, -0.69429415f, -0.64665967f, -0.29002726f, 0.53402185f, -0.40211070f, -1.08335221f, 
    0.49778619f, -0.36038309f, -0.21838316f, -0.39915249f, 0.50305486f, 0.19094397f, 0.00032808f, -0.09769009f, 
    0.41897395f, -0.04352763f, -0.10912398f, -0.12801227f, -0.12040012f, 0.35807794f, 0.09128565f, 0.08408616f, 
    -0.22625263f, -0.44177264f, -0.80846548f, -0.75429291f, -0.03727525f, 0.36169559f, 0.51366687f, 0.12640393f, 
    -0.08054330f, 0.07008547f, 0.04818495f, 0.64628524f, -0.65278691f, -0.52880961f, -0.41959128f, -0.61051071f, 
    -0.26997831f, -0.45650223f, -0.40194210f, 0.21493636f, -0.47790772f, -0.30642933f, 0.05660703f, -0.01645972f, 
    0.00644681f, 0.02951912f, -0.07642179f, 0.45221296f, -0.02975934f, 0.29447469f, 0.17543350f, -0.02157652f, 
    0.18000484f, 0.24349336f, 0.11578607f, 0.09233075f, -0.16649137f, -0.95334285f, -0.58152717f, -0.45932263f, 
    0.19372948f, 0.19948676f, -0.18918566f, -0.14686246f, -0.62353516f, -0.24375609f, -0.07093275f, -0.32566056f, 
    0.33558023f, 0.44823101f, 0.56397069f, -0.42859966f, 0.31124717f, -0.33379045f, -0.35975343f, 0.54587823f, 
    0.42512059f, -0.46619821f, -0.23113461f, -0.15919967f, 0.12902637f, 0.32663316f, -0.25208357f, -0.07845099f, 
    0.28291881f, 0.15921247f, -0.51143450f, 0.37757492f, -0.42504764f, -0.64389294f, 0.38830769f, 0.45922840f, 
    0.14597905f, 0.14740866f, -0.26199827f, 0.09639002f, 0.60694641f, 0.00346817f, -0.50144684f, -0.59097171f, 
    0.22314849f, 0.47809795f, -1.20896173f, 1.03109622f, -0.08263630f, 0.42703301f, -0.17136365f, 0.08551893f, 
    -0.27810740f, 0.34313861f, -0.19817868f, 0.20502210f, -0.34992340f, 0.06017439f, 0.06070540f, 0.07102381f, 
    -0.40664166f, 0.23310260f, 0.29412177f, -0.02897730f, -0.04997455f, 0.12601352f, 0.25781417f, -0.49819860f, 
    -0.43943936f, 0.15620193f, -0.34365505f, 0.36608556f, 0.41970998f, -0.49485603f, -0.14222103f, -0.28105667f, 
    -0.67649955f, -0.54305756f, -0.50232661f, -0.34952956f, -0.46848589f, -0.61169356f, -0.81869143f, 0.22119904f, 
    0.56731826f, -0.33592707f, 0.46261296f, 0.13756819f, -0.55754524f, 0.27138025f, 0.09871768f, -0.29903120f, 
    0.01186467f, -0.16476332f, 0.18130240f, -0.41340747f, 0.31344262f, 0.12458995f, 0.12421888f, 0.06031090f, 
    -0.18714805f, -0.04525806f, 0.37774029f, -0.49447164f, -0.06481588f, 0.55559289f, 0.31659198f, -0.38572410f, 
    -0.04187935f, 1.04496276f, -0.96639603f, -0.63418949f, 0.40729931f, -0.08827282f, -0.00430901f, 0.22319233f, 
    -0.22004519f, 0.06716930f, 0.63930935f, 0.70191014f, -0.45953548f, 0.03801740f, -0.25423989f, -0.29010972f, 
    -0.34009200f, 0.36502734f, 0.05206345f, 0.56343728f, -0.06697285f, 0.18588693f, 0.24788326f, 0.07008803f, 
    -0.36705691f, -0.27730682f, -0.27834687f, -0.28557307f, 0.43643180f, -0.44515017f, 0.02717376f, 0.20577088f, 
    -0.20513634f, -0.11457723f, 0.10003864f, 0.14781877f, -0.12687437f, -0.02876956f, -0.27451703f, -0.34584084f, 
    0.52518040f, -0.44701213f, -0.56937641f, -0.18981530f, 0.08272085f, 0.34296823f, 0.37625390f, 0.75482047f, 
    0.29526922f, -0.62460160f, -0.35661802f, -0.17828271f, 0.08138498f, 0.08952343f, -0.10750817f, 0.22838382f, 
    0.36372858f, 0.55761629f, -0.68120193f, -0.33860415f, -0.09475800f, 0.13120693f, 0.03857091f, 0.14995733f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17571291f, -0.45320517f, -0.22809725f, 0.06627054f, 0.09228329f, -0.02002401f, -0.21277992f, 0.02225036f, 
    -0.00132911f, 0.08414334f, 0.16707407f, 0.00012886f, -0.16987802f, -0.34020618f, -0.38214281f, -0.12951791f, 
    0.09838019f, 0.05697050f, 0.21164384f, 0.07840849f, -0.12299930f, 0.03339543f, 0.00423101f, 0.13757013f, 
    -0.18863310f, 0.01180328f, 0.04325986f, -0.02291489f, 0.00865149f, -0.29536983f, -0.12014019f, 0.07821668f, 
    0.01841666f, 0.03429319f, -0.17289253f, -0.13413106f, 0.00675049f, 0.08632939f, 0.01956042f, 0.13724047f, 
    0.24288854f, -0.01127697f, -0.02840891f, -0.13572739f, -0.26253164f, -0.28993407f, 0.04737609f, 0.12379984f, 
    -0.01423584f, -0.06389664f, -0.02675245f, -0.20731531f, 0.07677209f, -0.35764652f, 0.07715169f, 0.05956941f, 
    -0.13504170f, 0.17499514f, 0.06476082f, 0.08738381f, -0.02569311f, 0.20337142f, 0.14051658f, 0.07437928f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13368833f, 0.08902528f, 0.16918263f, -0.19377507f, -0.16085559f, 0.02824793f, 0.07128002f, 0.06602754f, 
    -0.06539071f, 0.00731063f, -0.01838864f, -0.03185397f, -0.02998820f, -0.09559733f, -0.14592986f, -0.01103304f, 
    -0.10743301f, -0.02455736f, 0.08803471f, 0.06311335f, 0.32174903f, 0.16806304f, -0.04585294f, -0.20893563f, 
    -0.04992827f, 0.08587918f, 0.10926035f, 0.17407842f, -0.06097937f, 0.14291942f, -0.01055134f, 0.01105129f, 
    -0.01497345f, -0.09624334f, -0.00418135f, 0.05917516f, -0.09676003f, 0.05520311f, -0.06849142f, 0.06816776f, 
    -0.09973548f, -0.05039436f, -0.02513365f, -0.00220566f, 0.02739415f, 0.03904249f, 0.04219644f, 0.01730989f, 
    0.05768516f, 0.04792826f, -0.00308804f, 0.05486865f, 0.03190529f, -0.00970880f, 0.04721610f, -0.18566725f, 
    -0.17187552f, -0.11064431f, 0.00700522f, -0.01578736f, -0.52911264f, -0.23079365f, 0.20909818f, 0.10551295f, 
    0.07107937f, -0.01171359f, -0.00889481f, 0.05789210f, 0.08258863f, -0.14918329f, -0.10969496f, -0.05781214f, 
    0.01410603f, 0.00933503f, 0.07676373f, -0.05945507f, 0.03251317f, -0.02487334f, -0.11438269f, -0.01162429f, 
    -0.01109403f, 0.00856062f, 0.21035212f, -0.19890389f, 0.04581567f, -0.06850615f, -0.04743388f, 0.00084813f, 
    -0.19135335f, -0.09343360f, 0.08803465f, -0.01048464f, 0.00816229f, -0.04370224f, -0.14606979f, -0.03683217f, 
    -0.01095992f, -0.02407673f, -0.04560230f, -0.20340352f, -0.05105169f, 0.00121176f, -0.56164086f, 0.08863366f, 
    -0.06412017f, -0.04108270f, 0.06877105f, -0.00598051f, -0.04290746f, 0.00192370f, -0.02392872f, -0.05288299f, 
    -0.18953349f, -0.07771575f, -0.04272021f, 0.05528231f, 0.01901032f, 0.02969494f, 0.04750527f, 0.05000447f, 
    0.09364308f, 0.03469525f, 0.00106735f, 0.00338298f, 0.07610585f, 0.01709795f, 0.05679569f, 0.06510651f, 
    -0.02187640f, 0.07464782f, 0.03463543f, -0.11855075f, -0.02970002f, 0.07086989f, 0.05563670f, 0.01521797f, 
    -0.00804043f, 0.05514058f, -0.02915472f, 0.03613124f, -0.05618105f, -0.03529644f, -0.00475949f, 0.05078579f, 
    0.03025078f, 0.00064833f, -0.05166470f, -0.00075067f, 0.05416231f, -0.00177556f, -0.08471686f, 0.03077250f, 
    -0.07119568f, -0.19444607f, -0.04432613f, -0.03307910f, 0.00864345f, -0.02542255f, -0.01896071f, -0.01198791f, 
    0.24230540f, 0.26738366f, 0.11634131f, -0.19105637f, 0.03182328f, -0.06395026f, -0.03687911f, -0.08507849f, 
    0.01592757f, 0.13341671f, 0.07566487f, -0.05990291f, 0.00848320f, -0.02161523f, -0.05918870f, -0.01221142f, 
    -0.01607468f, -0.00421034f, 0.05652955f, -0.13022198f, -0.15297116f, -0.27445883f, 0.00912694f, -0.17008163f, 
    -0.08076340f, -0.04390880f, 0.02828468f, 0.01701953f, 0.08752559f, 0.02003868f, 0.01500428f, -0.03903091f, 
    -0.06162744f, 0.00134715f, -0.04045127f, -0.03789483f, 0.02758444f, 0.04376605f, -0.07388080f, -0.04642870f, 
    0.26628879f, 0.20707604f, 0.07082321f, -0.08309396f, 0.05235382f, 0.10405089f, 0.05535708f, 0.09478272f, 
    -0.12496183f, -0.21506056f, -0.06015797f, -0.08203809f, -0.02455368f, 0.01391951f, 0.02901428f, -0.01451318f, 
    -0.03709542f, -0.03225509f, 0.02652598f, 0.01769697f, 0.48768196f, -0.04475679f, -0.64647996f, -0.05799072f, 
    0.07784671f, 0.15351394f, 0.06153952f, 0.19321075f, -0.18269864f, 0.09386820f, 0.03785186f, 0.04199163f, 
    -0.05909899f, 0.11700129f, 0.02454046f, -0.01635130f, 0.11743498f, 0.05535742f, -0.03169443f, 0.04057302f, 
    -0.02589001f, 0.00620582f, 0.01786460f, 0.05487426f, 0.03391301f, 0.02207218f, -0.02735943f, -0.02196549f, 
    0.05005716f, 0.02817879f, 0.03518464f, -0.04194103f, -0.17974094f, 0.02449076f, -0.02949949f, -0.03064872f, 
    0.07218879f, -0.01659621f, -0.03806473f, 0.00072279f, 0.19964288f, 0.08652589f, 0.10245074f, 0.03291390f, 
    -0.22264697f, 0.04740275f, 0.05277884f, 0.05591085f, 0.03123263f, 0.12827398f, 0.00275232f, 0.02854123f, 
    0.00382570f, -0.10550101f, -0.15232834f, -0.09489559f, -0.08133119f, -0.07051602f, -0.02960938f, 0.10883974f, 
    0.34669188f, 0.06933825f, -0.07375254f, -0.02848453f, -0.02380746f, -0.00838142f, 0.06361081f, 0.13657235f, 
    -0.01136210f, -0.02766670f, -0.00962131f, 0.05859945f, 0.03469251f, 0.07270205f, 0.06741978f, 0.02158211f, 
    0.11457405f, 0.12381324f, 0.03788032f, -0.00155388f, 0.32000116f, 0.29193771f, -0.06892489f, -0.30830684f, 
    -0.09613358f, 0.03914503f, -0.01192641f, 0.10825281f, -0.01731665f, 0.03504062f, 0.06813632f, -0.04618723f, 
    0.04284213f, 0.00733065f, 0.00716143f, 0.01332840f, -0.05431198f, 0.02421872f, 0.01077070f, 0.01930476f, 
    0.03123831f, -0.18112993f, -0.39113596f, 0.13024990f, -0.05692899f, 0.00899281f, 0.02247068f, 0.01654286f, 
    -0.02929093f, 0.04096466f, 0.00400043f, -0.05500714f, -0.15902562f, -0.02561119f, 0.00826658f, 0.00897041f, 
    0.06459013f, -0.01822458f, 0.02228078f, -0.01017916f, -0.34579474f, 0.00746978f, 0.25872445f, 0.04566299f, 
    -0.07988259f, -0.17857416f, -0.03670122f, 0.08080509f, 0.08561402f, -0.11602753f, -0.02322849f, -0.08075264f, 
    -0.19008987f, -0.01183272f, -0.06231514f, -0.01772274f, -0.04069003f, 0.02799921f, -0.17387244f, 0.11061532f, 
    0.21010856f, 0.17099835f, 0.03149413f, -0.05987553f, 0.01163166f, 0.05825040f, 0.04241940f, 0.05200079f, 
    -0.03248267f, -0.13631131f, 0.02676182f, -0.12908052f, -0.04404152f, -0.01605063f, 0.03148039f, -0.04774104f, 
    -0.02897060f, -0.03114014f, -0.01964648f, -0.00174433f, 0.07386165f, 0.10054302f, 0.00866996f, -0.07984761f, 
    0.01206608f, -0.11798425f, -0.12168700f, 0.00702473f, 0.02966451f, -0.16605385f, 0.06639593f, -0.04015040f, 
    -0.07035103f, -0.03853402f, -0.12328637f, 0.02681859f, -0.03078195f, 0.00749531f, -0.01305263f, -0.11439867f, 
    -0.06977522f, -0.08496325f, -0.05794019f, 0.00285682f, 0.02450585f, -0.01597242f, 0.01154523f, 0.00919848f, 
    0.01389986f, 0.05099231f, 0.01916961f, 0.04298635f, -0.00150372f, -0.12880944f, -0.07652749f, 0.00305575f, 
    0.01175659f, 0.02897856f, -0.01258290f, 0.03723858f, -0.18767478f, -0.10792472f, 0.07857054f, 0.11576758f, 
    -0.14777823f, -0.25444287f, -0.21294047f, -0.06321112f, -0.05193855f, 0.03499189f, 0.02493696f, -0.00450017f, 
    -0.07994083f, 0.11973973f, 0.08883740f, -0.19249564f, -0.00985133f, -0.07759673f, -0.10902017f, 0.03141220f, 
    -0.09684215f, -0.02956785f, -0.00566482f, -0.00646438f, 0.05036702f, -0.20332266f, 0.01166064f, -0.09378380f, 
    0.05035933f, -0.01509162f, -0.02359759f, 0.07737865f, 0.03041227f, -0.00125379f, 0.03590546f, -0.09269799f, 
    0.01492843f, -0.03892063f, -0.12354259f, 0.05009129f, -0.22847855f, -0.21293043f, -0.05054382f, -0.08921051f, 
    -0.07145644f, -0.01810941f, -0.01845351f, 0.02408955f, 0.03735334f, 0.01794763f, -0.03418803f, 0.05328142f, 
    -0.02158334f, -0.05357600f, 0.00453782f, 0.01669588f, 0.01646268f, 0.03838487f, -0.02724998f, 0.02625010f, 
    -0.06084735f, -0.10064966f, -0.03130279f, 0.01881731f, -0.00792226f, 0.08446633f, -0.01810702f, 0.01122927f, 
    0.01483277f, 0.01076571f, 0.01882448f, 0.07415085f, 0.03850669f, 0.06071948f, 0.02643500f, -0.12826151f, 
    -0.01793400f, -0.21789768f, -0.04166221f, 0.00048626f, 0.25106809f, 0.13110930f, 0.05328477f, -0.32089296f, 
    0.07366119f, -0.16711642f, 0.01060752f, -0.05238841f, 0.06834508f, -0.06155447f, 0.05881665f, 0.00072442f, 
    -0.16253455f, -0.06455446f, -0.08126985f, 0.17286396f, -0.06454530f, -0.04490182f, 0.00637148f, 0.07645485f, 
    -0.12742947f, -0.04808513f, 0.14408836f, -0.02493047f, 0.00901791f, -0.12580988f, -0.03783779f, 0.06248821f, 
    -0.06299055f, -0.01078251f, -0.05254203f, -0.02759483f, 0.00236785f, -0.07925856f, -0.07848200f, -0.04012798f, 
    -0.07858764f, 0.01011501f, -0.01331078f, -0.05123755f, 0.27607396f, 0.18503906f, -0.05361270f, -0.26581517f, 
    -0.05968336f, -0.00948913f, 0.03344594f, 0.11305054f, -0.16290845f, -0.05211446f, 0.05883249f, -0.04911341f, 
    0.03631199f, -0.01731699f, 0.02915357f, 0.02260113f, -0.04341084f, -0.00801337f, -0.03277300f, 0.03357778f, 
    0.16647986f, -0.16120327f, -0.30137917f, 0.05419810f, 0.01883841f, 0.10590324f, 0.03359091f, 0.08766822f, 
    -0.18692352f, -0.02781982f, -0.03920784f, 0.03562696f, -0.00663501f, -0.06175047f, -0.04930494f, 0.02560931f, 
    0.09571109f, 0.02315396f, 0.01949325f, -0.01148498f, 0.25849819f, 0.23531266f, 0.11771289f, -0.17290221f, 
    -0.02907313f, 0.09683778f, 0.18590967f, 0.16316007f, -0.03403723f, 0.03126294f, 0.00197940f, -0.02475140f, 
    -0.01291979f, 0.01269718f, 0.03134166f, -0.05280055f, -0.03906982f, 0.01847167f, -0.09244250f, -0.00738775f, 
    0.04836461f, 0.19250657f, -0.20674454f, -0.11949193f, -0.26127061f, 0.10992478f, -0.07470905f, -0.07156464f, 
    0.02490638f, 0.07659803f, -0.00617306f, 0.01045180f, -0.00346064f, 0.07261783f, 0.06685809f, 0.01834927f, 
    0.00989753f, 0.08536015f, -0.11461602f, 0.05048542f, -0.14333925f, -0.17053917f, 0.12890191f, 0.11323802f, 
    -0.09877546f, 0.00046401f, -0.07431533f, -0.01711037f, 0.00735038f, -0.02385772f, 0.03689090f, 0.04591283f, 
    -0.09975962f, -0.05557682f, -0.01033935f, -0.09266291f, -0.00928080f, -0.00816462f, -0.06960239f, -0.01917842f, 
    0.24702284f, 0.27419561f, 0.15997428f, -0.45519000f, 0.04177963f, 0.01870365f, 0.06884616f, -0.06367983f, 
    -0.05199053f, 0.00313960f, 0.02571637f, -0.07220441f, -0.01523269f, 0.00136807f, -0.02293376f, -0.08002295f, 
    -0.05725329f, -0.01939134f, 0.07800540f, 0.00838421f, -0.21105349f, -0.07251814f, -0.31385031f, 0.17135656f, 
    0.08184656f, -0.11127450f, -0.14688458f, -0.09278468f, -0.09671292f, -0.02080570f, -0.04209284f, -0.01123527f, 
    0.03230640f, 0.04919239f, 0.01948215f, -0.06452460f, 0.04697175f, 0.01342752f, -0.13668031f, 0.00913386f, 
    0.08859997f, 0.03129123f, 0.02894402f, 0.03760265f, 0.06723507f, -0.00836575f, 0.00380672f, 0.07297340f, 
    0.05609692f, 0.03198152f, -0.06637003f, -0.15428209f, -0.07203511f, 0.02752404f, -0.00453010f, 0.00600781f, 
    0.05740883f, 0.01367128f, 0.02519584f, -0.00127196f, -0.04924785f, -0.08658564f, -0.02833376f, 0.02138895f, 
    0.01507406f, 0.04466146f, -0.02740108f, -0.01080615f, 0.03636906f, 0.00548077f, 0.01999913f, 0.00598796f, 
    0.00258349f, 0.05559080f, 0.07545683f, -0.08732828f, 0.00954966f, -0.10858600f, 0.02849122f, -0.05000574f, 
    -0.03254052f, 0.06166202f, -0.09738387f, -0.00156770f, -0.16948736f, 0.08371857f, -0.15944692f, -0.02354663f, 
    0.05579636f, -0.08310188f, -0.09649373f, -0.06799503f, -0.13624313f, 0.07412847f, 0.01982637f, -0.09962462f, 
    -0.08711158f, 0.01908228f, -0.04024515f, -0.18468985f, -0.05147234f, -0.11930633f, -0.31675434f, 0.10137785f, 
    0.03331983f, 0.03391454f, -0.04256337f, 0.00953173f, -0.09228605f, 0.06087774f, -0.05743038f, 0.01013615f, 
    -0.24983469f, -0.08626848f, -0.14660026f, 0.01085693f, 0.03587115f, 0.01367963f, -0.02070382f, 0.05758275f, 
    0.24997154f, 0.26999182f, -0.04217944f, -0.28077805f, -0.09835364f, -0.03314766f, 0.02480239f, -0.06686357f, 
    0.06799580f, 0.11722954f, 0.06475071f, -0.07232047f, -0.07005724f, -0.09025861f, -0.07117026f, -0.03356086f, 
    0.00019300f, -0.06574173f, 0.04958113f, 0.03896072f, 0.16874877f, 0.12045895f, 0.23710895f, -0.23148614f, 
    -0.07498719f, -0.09796029f, 0.09640845f, 0.05163577f, 0.05718810f, -0.11805106f, 0.03237943f, -0.03095322f, 
    0.00320873f, 0.01818527f, 0.03723481f, -0.00429399f, -0.04411323f, 0.01779415f, -0.09795570f, 0.01437509f, 
    -0.41800880f, -0.21229364f, -0.20400876f, 0.01569805f, -0.04071208f, -0.01601733f, -0.00202342f, -0.06622357f, 
    0.01389302f, 0.04732680f, -0.00157809f, 0.03254901f, -0.02066635f, 0.00353126f, 0.00410140f, -0.03215243f, 
    -0.17061020f, -0.00760067f, 0.02169488f, -0.01447986f, 0.31686899f, 0.10468920f, -0.09283014f, -0.02153475f, 
    0.05407073f, 0.20952351f, 0.13885047f, 0.26141047f, -0.08875547f, -0.09127967f, -0.04269852f, -0.06802958f, 
    0.00635316f, 0.04001343f, 0.04733092f, 0.04185340f, 0.03090664f, 0.03480846f, -0.00209895f, -0.01782483f, 
    -0.07959371f, 0.17140444f, 0.13285978f, -0.11915515f, -0.10914414f, -0.06486613f, 0.03219044f, 0.00092308f, 
    -0.05242880f, 0.01801102f, -0.05583139f, -0.04800529f, 0.01015717f, 0.02203305f, -0.01499311f, 0.00803337f, 
    0.00105170f, 0.02624151f, 0.00806955f, 0.10269303f, 0.14268745f, 0.17042397f, -0.05257269f, 0.07236592f, 
    0.11366745f, 0.06672748f, 0.04028746f, 0.05988159f, -0.07123954f, -0.05858709f, -0.07031183f, -0.11221457f, 
    0.01692343f, 0.04215832f, 0.05358791f, -0.05602307f, 0.02328407f, 0.02238843f, 0.04265939f, -0.01290059f, 
    -0.06669603f, -0.02021036f, 0.03691376f, 0.02224778f, 0.00653935f, 0.00615128f, 0.07099406f, 0.03856130f, 
    0.03919778f, 0.06896874f, -0.10804249f, 0.02886770f, -0.00215996f, 0.00294405f, -0.05249607f, -0.00231924f, 
    -0.09477278f, 0.02292997f, -0.02835973f, 0.03841842f, 0.40158820f, 0.15303496f, 0.07208291f, -0.16950811f, 
    -0.03915910f, 0.10963730f, 0.17602073f, 0.16757214f, 0.11170603f, 0.04376857f, 0.00539907f, -0.01837733f, 
    0.00828760f, -0.02255623f, 0.04983722f, -0.03018727f, -0.00506675f, -0.02331026f, -0.09803420f, -0.05031025f, 
    0.18149397f, -0.27031061f, -0.14997746f, -0.02761859f, -0.08153596f, -0.06491432f, -0.03987291f, 0.04737381f, 
    0.03905589f, 0.03786286f, 0.01409123f, 0.04702488f, -0.08605735f, 0.10980108f, -0.00157988f, -0.05778309f, 
    0.02762381f, 0.00809213f, -0.02398298f, 0.07104669f, -0.38929072f, -0.21566345f, -0.17134085f, 0.07934643f, 
    -0.17012680f, -0.03104892f, 0.05148592f, -0.07321750f, 0.05576696f, 0.02311101f, 0.01027561f, 0.00497572f, 
    -0.01832422f, -0.00364633f, 0.06199559f, -0.10812744f, 0.03019489f, -0.02377848f, 0.03621809f, -0.08757799f, 
    0.19988377f, 0.09174897f, -0.13884829f, 0.08703743f, 0.03870061f, -0.04991725f, 0.06052507f, -0.05494944f, 
    0.02753013f, -0.06165513f, -0.05518646f, 0.09618786f, -0.03431663f, -0.01552678f, -0.00943890f, -0.04347812f, 
    -0.03735060f, -0.03703033f, -0.03622331f, -0.03583111f, 0.14448634f, -0.07741130f, -0.06063772f, 0.06864002f, 
    -0.07562472f, 0.07081940f, 0.11887129f, -0.16707230f, -0.00857439f, -0.02556095f, -0.05858849f, -0.13636887f, 
    0.02461980f, -0.07761202f, 0.07579977f, -0.13298585f, 0.00175749f, -0.16951963f, 0.01798905f, -0.10033038f, 
    -0.54002512f, 0.18237422f, 0.00194380f, -0.19409266f, 0.06558321f, -0.26043636f, -0.01824744f, 0.10295223f, 
    0.05034841f, -0.01241750f, -0.15208648f, 0.03917994f, 0.02144643f, -0.12271087f, -0.10567117f, -0.14476196f, 
    0.05360086f, 0.02356739f, -0.24971372f, -0.00637739f, 0.07913800f, 0.06502399f, -0.03260463f, 0.03641834f, 
    0.03234336f, 0.02897246f, 0.04031856f, 0.02592582f, -0.00223748f, 0.01429192f, 0.07050531f, 0.11627223f, 
    -0.03185068f, 0.05331051f, -0.01103165f, 0.01265250f, 0.00456966f, -0.05359669f, -0.03747280f, 0.07230233f, 
    0.01113290f, 0.05306848f, 0.11672713f, -0.05521595f, -0.08378296f, -0.07229031f, -0.04161477f, -0.12387331f, 
    -0.06933683f, -0.05026045f, 0.04829701f, -0.03306032f, 0.02307403f, -0.02310556f, -0.08639282f, -0.06036152f, 
    -0.01735915f, 0.03074451f, -0.01153277f, -0.16038041f, 0.18982121f, 0.21066679f, 0.18996997f, -0.25187415f, 
    -0.05898079f, 0.07088213f, 0.09968314f, 0.14513193f, -0.01138395f, 0.09324188f, -0.03452090f, -0.04668278f, 
    0.00366927f, -0.06862078f, -0.08365121f, -0.04126912f, -0.10266820f, -0.00843940f, 0.08439217f, 0.13388970f, 
    -0.57328993f, -0.15982459f, 0.26133290f, -0.00548058f, -0.06364236f, -0.05083894f, -0.09807762f, 0.05054197f, 
    0.10336307f, -0.02363946f, -0.08156572f, 0.01398750f, -0.01906399f, -0.19595377f, -0.20584315f, -0.17196454f, 
    -0.04980121f, 0.01474409f, 0.04706964f, -0.09163053f, 0.12367026f, 0.05635677f, 0.04353508f, -0.03253650f, 
    0.05597697f, 0.04572178f, 0.02601305f, 0.01611996f, 0.00473649f, -0.02751500f, -0.05168136f, -0.05620787f, 
    0.00762893f, 0.00426899f, 0.01493616f, -0.01425918f, -0.02871836f, -0.02644580f, -0.01052884f, -0.02620122f, 
    -0.14113213f, -0.07622617f, 0.14610517f, -0.03783065f, 0.04742808f, -0.01986827f, 0.03065216f, -0.04387647f, 
    0.01588628f, 0.01286210f, -0.02616633f, -0.04791629f, -0.08932611f, 0.04430329f, 0.10615405f, -0.04016126f, 
    -0.11713257f, -0.02225682f, -0.01106369f, 0.01420187f, 0.13497448f, -0.09159197f, -0.78885698f, 0.01656654f, 
    0.07240514f, 0.04723667f, -0.01227971f, 0.06157795f, -0.08089343f, -0.05567544f, -0.09867422f, 0.03411161f, 
    -0.16744629f, -0.03438200f, -0.08658817f, -0.06100465f, 0.05441453f, -0.04776413f, -0.03223497f, 0.04693455f, 
    -0.21492803f, -0.22748697f, -0.40460044f, 0.09964723f, -0.14997464f, 0.02613878f, -0.02096223f, -0.08129413f, 
    -0.00781295f, 0.02078185f, -0.03117723f, 0.03259550f, -0.02248463f, 0.01497053f, 0.06233563f, -0.05157493f, 
    0.05014703f, -0.12534329f, 0.00903954f, -0.08943807f, -0.08222306f, 0.06618512f, -0.02856545f, 0.01987085f, 
    0.22035569f, -0.02189664f, -0.04578272f, -0.00001691f, 0.05035719f, 0.06725958f, 0.00741613f, -0.00355574f, 
    0.00516143f, 0.03739749f, 0.05633415f, 0.01595423f, 0.03815738f, 0.04114918f, -0.06790125f, 0.08002785f, 
    -0.01175228f, -0.00991731f, -0.04911833f, -0.01017218f, 0.02133487f, -0.01756805f, 0.03405295f, 0.01335596f, 
    0.01344045f, 0.01847412f, -0.05270413f, 0.06993382f, -0.03200059f, -0.02534518f, 0.00133808f, -0.03530820f, 
    -0.05695546f, -0.02695987f, -0.09061021f, 0.02129895f, 0.18085532f, 0.13229053f, -0.19651707f, -0.10192049f, 
    -0.06793316f, -0.04341889f, -0.08488846f, 0.00872010f, -0.07199142f, -0.01908204f, 0.00919799f, -0.09374508f, 
    0.02728762f, 0.01882093f, 0.02521297f, -0.01280245f, -0.04790530f, -0.04394301f, -0.02505394f, 0.00747850f, 
    -0.19967046f, 0.09703323f, -0.02900469f, -0.03057527f, -0.06266994f, 0.00276051f, -0.06199240f, -0.19139138f, 
    -0.02396403f, -0.07232594f, 0.02496873f, 0.00247209f, -0.00586314f, 0.02684071f, 0.03283629f, 0.05813448f, 
    0.07877913f, -0.06158447f, -0.08441978f, -0.05840811f, -0.07260418f, 0.03420215f, 0.11871190f, -0.04742678f, 
    0.02087556f, -0.07913477f, -0.05243671f, -0.20957999f, -0.00379635f, -0.01504813f, 0.05315015f, -0.00818504f, 
    0.01051858f, 0.06226185f, 0.02986537f, -0.01027962f, 0.08267194f, 0.01538423f, -0.11419047f, -0.12013569f, 
    -0.10690678f, 0.20329548f, 0.03568239f, 0.00918333f, 0.04054644f, 0.03879764f, 0.02098113f, 0.03451536f, 
    -0.07153273f, 0.03269298f, 0.00779836f, 0.04492173f, 0.02293283f, -0.00822662f, 0.07904531f, -0.03133250f, 
    -0.03580294f, 0.08557975f, -0.19779371f, -0.04593274f, 0.28008649f, 0.25987610f, 0.16386251f, 0.13039240f, 
    0.09397282f, 0.04008013f, -0.15972583f, -0.11362390f, 0.21720634f, 0.01880667f, 0.07130826f, -0.03245895f, 
    0.01887864f, 0.02102787f, -0.00388047f, -0.11043692f, -0.09168748f, -0.25931531f, 0.09429393f, 0.06050037f, 
    0.18965591f, 0.12341534f, 0.10254204f, 0.06648789f, 0.10535334f, -0.01124160f, -0.03703931f, -0.00325025f, 
    0.00281181f, -0.04608009f, 0.02432441f, -0.02986700f, -0.00056706f, -0.02080417f, 0.01968018f, -0.06088993f, 
    0.01377288f, -0.01358247f, -0.01195508f, -0.04920638f, -0.51081777f, -0.64177793f, -0.00751963f, -0.00749071f, 
    -0.06549200f, -0.03081470f, -0.05714667f, 0.05820448f, -0.04942130f, -0.08614650f, 0.04152105f, 0.02816381f, 
    -0.04252360f, 0.10507136f, -0.04858910f, 0.00647072f, 0.06766878f, -0.10224243f, 0.07743380f, -0.01301476f, 
    -0.25926036f, 0.15015478f, -0.09465588f, -0.00655073f, 0.03737153f, -0.20035121f, 0.08945102f, 0.16026880f, 
    -0.08331780f, 0.20022844f, -0.01866803f, 0.01398134f, 0.07425596f, -0.00332377f, 0.00486413f, 0.02588177f, 
    0.00918074f, 0.05861176f, -0.12346710f, -0.08659904f, 0.94514567f, 0.37747270f, -0.07445548f, 0.19880922f, 
    -0.50043714f, 0.01819875f, -0.02899979f, 0.03366633f, -0.08442820f, -0.01582974f, 0.02741123f, -0.09063651f, 
    -0.08546630f, -0.05686728f, -0.09049827f, 0.05387437f, -0.06916066f, -0.12672213f, -0.13147339f, -0.03140225f, 
    0.00007936f, -0.00450334f, -0.03772118f, -0.05436869f, -0.00665791f, -0.07137282f, -0.02669915f, 0.03613000f, 
    0.00416128f, 0.03151002f, -0.01717545f, 0.15819152f, -0.03802010f, 0.03420431f, -0.06085195f, -0.01480650f, 
    0.01974093f, -0.01855788f, -0.08630651f, 0.02561498f, 0.09492005f, 0.05346490f, 0.04958282f, 0.02269010f, 
    0.07101533f, -0.02685742f, -0.02064417f, -0.03771307f, 0.01316677f, 0.02557635f, 0.07896139f, 0.03691093f, 
    0.00256898f, 0.02553181f, 0.02398058f, -0.14282453f, 0.04228732f, -0.12024514f, 0.01609583f, 0.03488179f, 
    -0.30649164f, 0.15172853f, -0.04895194f, 0.01048043f, 0.12005904f, -0.00231687f, -0.10678174f, -0.10114662f, 
    0.14952594f, 0.01439973f, -0.10125332f, 0.02648942f, 0.04267716f, 0.06475998f, 0.02968250f, -0.04740601f, 
    -0.02648574f, 0.03620376f, 0.00582922f, 0.13765064f, 0.00627046f, -0.19635890f, 0.05954546f, 0.03572252f, 
    0.14542672f, 0.02279963f, -0.04640210f, 0.01495454f, -0.06812919f, 0.06516945f, 0.01385338f, 0.08216347f, 
    0.04658194f, 0.08145984f, 0.10092162f, 0.22652948f, -0.04169184f, -0.07591726f, 0.08440967f, -0.04958767f, 
    -0.45648828f, -0.07738639f, -0.21367911f, -0.00703124f, -0.02917999f, 0.00528069f, 0.10356763f, 0.12548080f, 
    -0.04510840f, 0.01327795f, -0.06791879f, 0.07014489f, -0.00771674f, 0.05059963f, -0.01326976f, 0.01417317f, 
    -0.00564508f, -0.00026843f, -0.04732509f, 0.02817219f, 0.27555674f, -0.35866204f, -0.22335297f, -0.02772656f, 
    -0.04086043f, -0.04122424f, 0.00951240f, 0.09961314f, 0.03249059f, -0.14049985f, 0.10064095f, -0.23554283f, 
    0.09964519f, -0.07328926f, -0.10109285f, -0.00645764f, -0.03446234f, -0.02834082f, -0.02663604f, -0.03675155f, 
    -0.06630036f, -0.05154535f, 0.08418913f, 0.01697815f, -0.06845701f, -0.00805520f, -0.00841198f, -0.02798198f, 
    -0.03774064f, 0.00283358f, 0.17509677f, 0.04194640f, -0.08411144f, 0.06706184f, -0.00621450f, -0.13776626f, 
    0.00651658f, -0.05836479f, 0.02952902f, 0.04216743f, 0.04006926f, -0.16944587f, 0.11512999f, -0.27702230f, 
    0.00090078f, -0.04543209f, -0.04197417f, -0.10084887f, 0.05419849f, 0.21619581f, 0.01065417f, 0.03871994f, 
    -0.00017894f, -0.01541433f, -0.03499281f, -0.16102996f, -0.26265636f, -0.29125652f, -0.08981242f, -0.07950641f, 
    0.00126160f, -0.01045540f, 0.32295883f, 0.04967765f, -0.17198165f, 0.03281866f, -0.02938706f, 0.06699294f, 
    -0.00994844f, -0.11653278f, 0.12774763f, -0.03352323f, -0.04796499f, -0.17689420f, -0.04054168f, 0.18741645f, 
    -0.01358220f, -0.17006637f, 0.10636002f, 0.00349667f, -0.12991442f, 0.11476890f, -0.02629782f, 0.24975491f, 
    0.13217027f, 0.00817955f, 0.10023584f, -0.03217494f, -0.02679929f, -0.09946925f, -0.04821210f, -0.00509866f, 
    0.00928880f, 0.03092085f, -0.00088179f, -0.00452081f, 0.00164289f, 0.02685130f, -0.08466458f, -0.00952047f, 
    0.68308508f, 0.04198614f, 0.25714564f, 0.15478933f, -0.16723485f, 0.01426168f, -0.00183151f, 0.08627028f, 
    -0.02783905f, 0.00499095f, 0.06499167f, -0.22206782f, 0.02118550f, -0.09765277f, -0.04036165f, 0.04329125f, 
    -0.03191490f, -0.01705016f, -0.08662982f, -0.02933326f, -0.14368713f, -0.36661911f, 0.05094301f, -0.03619206f, 
    0.12502538f, 0.03721014f, -0.03604306f, 0.06034936f, 0.09973029f, 0.02199764f, 0.03562022f, 0.02136526f, 
    0.10192231f, 0.03473032f, -0.09500621f, 0.03335401f, 0.06797581f, 0.05325171f, 0.17090933f, -0.02336456f, 
    -0.24304283f, -0.13947797f, -0.12203869f, 0.03657335f, -0.05433954f, 0.00763002f, 0.12980609f, 0.08119324f, 
    0.08856046f, 0.02032249f, -0.07852393f, 0.05631906f, 0.02910048f, 0.03751917f, 0.02114303f, -0.01298047f, 
    0.06290557f, -0.02205833f, 0.00589756f, 0.04457304f, -0.06764958f, 0.04730107f, 0.02134887f, 0.02402565f, 
    0.20590545f, 0.09535764f, 0.02630223f, -0.02351960f, 0.09937733f, 0.05472853f, -0.08091000f, -0.02757982f, 
    0.22185603f, 0.05172119f, 0.02183851f, -0.09655341f, -0.01361362f, 0.10624214f, 0.06402535f, -0.08865648f, 
    0.22357956f, 0.06570569f, 0.13490641f, 0.10025918f, 0.08733577f, -0.03313176f, -0.01084419f, -0.02196405f, 
    -0.02096663f, -0.00572650f, 0.02371382f, 0.03754710f, -0.01908004f, -0.01908544f, -0.03197508f, -0.14404087f, 
    -0.07886509f, -0.12471251f, 0.02419143f, -0.02044199f, -0.23042080f, -0.24386321f, 0.21861690f, -0.04048183f, 
    -0.01183569f, 0.11763020f, 0.05009604f, 0.05893923f, -0.05534088f, -0.03268486f, 0.10360613f, -0.00569993f, 
    0.03421784f, 0.08781381f, -0.14642745f, -0.05161427f, 0.07635466f, -0.03564990f, 0.03110631f, -0.00940672f, 
    0.03627176f, 0.19172034f, -0.01407615f, -0.03988438f, -0.00363023f, -0.07358456f, 0.07045921f, -0.11895468f, 
    -0.04801646f, 0.00003382f, -0.01472037f, -0.03822228f, 0.02657295f, 0.08886515f, -0.06071059f, 0.00782303f, 
    -0.04898551f, 0.07887781f, 0.06832438f, -0.02931261f, -0.11373451f, 0.09098189f, 0.09101196f, 0.06057219f, 
    0.04933812f, 0.02202570f, -0.03448990f, 0.03212601f, 0.02319923f, 0.01368544f, -0.02573718f, 0.00335291f, 
    0.05080042f, -0.04470831f, 0.11637956f, 0.10510270f, -0.13927716f, -0.03318649f, 0.07725931f, -0.03781142f, 
    0.17268603f, 0.14334770f, 0.04078333f, 0.01801506f, 0.08643645f, -0.00089793f, 0.00391743f, -0.00562536f, 
    -0.06599078f, -0.07287090f, -0.05393780f, -0.01585795f, 0.00378099f, -0.00243685f, -0.02218402f, 0.13850389f, 
    0.09986774f, 0.02682195f, -0.01910530f, -0.06802437f, -0.07452738f, -0.21304154f, -0.18046743f, -0.40263450f, 
    0.22724073f, 0.19339363f, -0.11961160f, -0.02472964f, -0.06846041f, 0.04351408f, 0.14624496f, 0.06843153f, 
    0.11368863f, 0.03092707f, 0.12332055f, 0.02527308f, -0.10817163f, -0.00764445f, -0.08702329f, -0.17649145f, 
    -0.01340716f, 0.05638532f, -0.00859964f, -0.05329656f, 0.09488403f, -0.08960231f, 0.08666066f, 0.09341926f, 
    -0.11226398f, 0.13772658f, -0.00173430f, 0.00716908f, 0.10296505f, 0.07217574f, -0.05723697f, 0.02962607f, 
    0.09446321f, 0.07789008f, -0.00713315f, 0.02048768f, -0.07750137f, 0.15685141f, -0.12341237f, 0.12682985f, 
    -0.03792746f, -0.12940453f, 0.13651668f, 0.04204920f, 0.15299828f, -0.06278837f, -0.04597082f, -0.05314145f, 
    0.02049257f, -0.03957265f, 0.02335244f, -0.01256881f, 0.05424971f, 0.03236726f, -0.06440351f, 0.07680596f, 
    0.57033515f, -0.19025263f, -0.12014808f, -0.00355866f, -0.23712680f, -0.02041733f, 0.06341386f, 0.04179554f, 
    0.02038153f, -0.07399704f, 0.08828341f, -0.18949504f, -0.05952043f, -0.04405737f, -0.04871783f, 0.02883294f, 
    0.04790376f, -0.05111468f, 0.00002806f, -0.02024584f, -0.27881113f, 0.17617598f, 0.13565947f, 0.36560357f, 
    -0.14818086f, -0.01706606f, -0.01799968f, -0.15660711f, -0.44503504f, -0.10180362f, 0.01132789f, 0.01590323f, 
    0.02173926f, -0.06300956f, -0.01780913f, 0.02547833f, 0.07120810f, 0.00491710f, -0.25674260f, -0.00681070f, 
    -0.24757975f, -0.26219189f, -0.33185998f, -0.11794048f, -0.51195085f, -0.12069258f, -0.13828051f, -0.18993418f, 
    0.00144522f, 0.00053285f, -0.02797405f, -0.02467640f, 0.00170969f, 0.02323288f, 0.01894048f, 0.02158961f, 
    0.08042037f, -0.13114601f, 0.00925845f, 0.11413959f, 0.14138439f, 0.01701382f, 0.06639957f, 0.02046824f, 
    0.09046075f, -0.04031593f, 0.02815069f, -0.05094288f, -0.00585393f, 0.02194156f, 0.03988207f, 0.01476338f, 
    0.07657177f, 0.03694753f, 0.01101251f, -0.01199093f, 0.11545815f, -0.10539626f, -0.00807326f, 0.03268432f, 
    -0.30744684f, 0.10727588f, -0.46229008f, -0.27960587f, 0.10581834f, -0.12556703f, -0.17662516f, -0.03753859f, 
    0.09928495f, -0.11918873f, -0.00330827f, 0.08391375f, 0.03410837f, -0.04746130f, 0.05367650f, 0.00864380f, 
    0.00143697f, 0.11145396f, -0.33771929f, -0.16797502f, 0.64572674f, 0.17238364f, -0.46785092f, 0.12804106f, 
    -0.35002130f, 0.03418769f, -0.04304491f, -0.13305044f, -0.03569727f, -0.19062684f, -0.05754167f, 0.03528379f, 
    0.01502782f, 0.06707742f, 0.02267046f, 0.11829939f, 0.05507435f, -0.15692884f, 0.05883036f, 0.04387169f, 
    0.04519856f, -0.06818562f, -0.02033438f, 0.04918678f, 0.00587784f, -0.03639327f, -0.01984179f, 0.04736594f, 
    0.02640299f, -0.00964998f, -0.07453907f, 0.01619487f, -0.01185577f, 0.05696443f, -0.07895685f, -0.01560026f, 
    -0.02206114f, -0.03834675f, -0.02663163f, -0.05631646f, 0.05292264f, 0.06030253f, 0.03053880f, 0.03144277f, 
    0.10633241f, 0.00635068f, 0.00993181f, -0.00739815f, -0.02386957f, -0.01552161f, 0.01303125f, -0.02288042f, 
    0.02346724f, 0.04652204f, -0.02993782f, 0.01383592f, 0.04239303f, -0.00024522f, 0.02447488f, -0.01366736f, 
    -0.16331896f, -0.09228264f, 0.05415852f, 0.01703463f, -0.22692768f, 0.06306279f, -0.00820791f, 0.08765391f, 
    -0.07448801f, 0.07795067f, 0.04898771f, 0.07444768f, 0.00599717f, 0.01353700f, -0.02888467f, -0.01757960f, 
    -0.11263016f, -0.01457412f, 0.09437152f, -0.03051678f, 0.54985809f, 0.04546815f, -0.09921359f, 0.00998560f, 
    -0.10881706f, -0.08382819f, 0.03037564f, 0.01191159f, -0.08063547f, 0.06249729f, 0.09124734f, 0.00497106f, 
    -0.00289176f, -0.01494939f, 0.05597593f, -0.03199481f, -0.00792124f, -0.06441906f, 0.00540452f, 0.06711932f, 
    -0.54711151f, -0.07288677f, -0.21764839f, 0.04476346f, -0.01665789f, 0.11983698f, -0.01420936f, -0.07165526f, 
    0.24900645f, -0.02612586f, 0.01422593f, 0.03319442f, 0.11919423f, -0.00320580f, 0.08214619f, -0.13211848f, 
    0.00317369f, -0.03036818f, -0.08809325f, -0.12357649f, -0.77629739f, -0.21980192f, -0.12666596f, 0.02483554f, 
    -0.06920293f, 0.05225156f, 0.05184673f, -0.17773195f, -0.21196117f, -0.07567415f, -0.08946418f, 0.03077380f, 
    0.02511598f, 0.00367008f, 0.00050257f, 0.00562267f, 0.02096184f, -0.02320734f, -0.05842077f, 0.02511676f, 
    0.23226860f, 0.11059155f, 0.13365911f, 0.09380056f, 0.04331797f, -0.02026418f, 0.03288144f, 0.04726667f, 
    -0.00414642f, -0.01352246f, -0.01227145f, 0.00106064f, -0.02159893f, 0.06253177f, -0.00913281f, -0.01484198f, 
    -0.03744649f, 0.08653104f, 0.00430923f, -0.04686535f, -0.19263047f, 0.09103540f, 0.06720410f, 0.10064989f, 
    -0.10530507f, -0.04950607f, -0.00884632f, 0.16367033f, -0.26169920f, -0.09916376f, -0.00815268f, -0.05470489f, 
    -0.02440335f, -0.07898180f, -0.06546291f, 0.00862160f, 0.04536428f, -0.04477323f, 0.00322785f, 0.02019921f, 
    -0.21236749f, -0.04316414f, -0.16389440f, -0.14476421f, -0.32821652f, 0.06249915f, -0.08767962f, -0.16039239f, 
    -0.14893505f, 0.07855754f, -0.01433760f, 0.04399058f, -0.00738236f, -0.00114108f, 0.03841984f, -0.16165178f, 
    -0.08981018f, -0.19809097f, -0.19855271f, -0.16727480f, 0.00957650f, -0.08882213f, -0.14272812f, -0.01969928f, 
    -0.16164841f, -0.04391945f, 0.05951953f, 0.13680637f, -0.11049733f, -0.05956687f, 0.06876109f, -0.07286151f, 
    0.13620655f, -0.01459477f, -0.04664500f, -0.05806262f, -0.00213875f, 0.00993687f, -0.00213419f, 0.01136941f, 
    0.10025986f, 0.04287474f, 0.09159274f, 0.10456302f, 0.10309033f, -0.01355408f, -0.03316457f, -0.02137903f, 
    -0.00397630f, -0.03402936f, 0.07119716f, -0.04920463f, 0.00100126f, -0.01567641f, -0.00159529f, -0.13175531f, 
    -0.06384035f, -0.08007173f, -0.03947687f, -0.03582427f, 0.25320154f, 0.19675039f, 0.31709257f, 0.06834910f, 
    0.08543666f, 0.09654468f, -0.14573304f, 0.04161457f, 0.07203873f, -0.13663352f, 0.04200369f, 0.03196055f, 
    0.00750902f, -0.15224847f, -0.01105975f, 0.17701282f, 0.04546793f, -0.13225715f, -0.03231020f, 0.00238702f, 
    0.24453405f, -0.10954175f, -0.00145862f, 0.13867638f, 0.01867809f, -0.03660906f, -0.03414862f, 0.00906234f, 
    0.01565319f, 0.02000761f, 0.02140333f, 0.05504977f, 0.13202551f, -0.13913295f, -0.07432473f, 0.08715423f, 
    -0.14809816f, -0.00039882f, 0.01330581f, -0.12394159f, -0.00184776f, 0.09299169f, 0.23973559f, 0.01589859f, 
    -0.01412482f, 0.03808358f, -0.01120285f, 0.00768110f, -0.02278686f, 0.01181018f, -0.00211380f, -0.03640794f, 
    -0.00245041f, 0.01977700f, -0.02550572f, 0.10865974f, -0.02352180f, 0.12345260f, 0.06782682f, -0.05786993f, 
    -0.11074767f, -0.02975720f, -0.07885988f, -0.04008214f, -0.10647636f, 0.05736429f, 0.07498287f, 0.04722852f, 
    0.05104347f, -0.06805695f, 0.09476445f, 0.06315698f, -0.11355712f, 0.01366471f, 0.03119822f, -0.02200248f, 
    -0.01570569f, 0.02165025f, 0.04166487f, 0.05536662f, 0.00251169f, 0.05202195f, 0.02266602f, 0.07208461f, 
    0.02521423f, 0.16043863f, -0.04915204f, 0.14878383f, 0.06015896f, -0.13595408f, -0.08871254f, 0.15635166f, 
    0.03181122f, 0.13818567f, -0.16950478f, 0.09636514f, 0.23430103f, 0.03067115f, -0.04112350f, 0.01965855f, 
    -0.63441664f, -0.09961025f, -0.09092008f, 0.09530942f, 0.05327958f, 0.08075099f, 0.08016773f, 0.01473134f, 
    0.04666818f, -0.12971501f, -0.10188027f, -0.10522027f, -0.08359039f, 0.19478689f, 0.13691765f, 0.02553121f, 
    0.08164177f, -0.10207613f, -0.10872683f, -0.17847374f, -0.02138095f, 0.02620259f, -0.02707682f, -0.07396583f, 
    -0.02141550f, -0.04664982f, 0.02806603f, 0.04793305f, 0.05829187f, 0.00680933f, -0.02755550f, 0.06719104f, 
    -0.06950180f, 0.07189962f, -0.02064462f, -0.05941581f, -0.02752090f, 0.02017886f, 0.02030714f, -0.02177844f, 
    -0.04539828f, -0.02326933f, -0.03475053f, -0.01101487f, 0.04290023f, 0.08285899f, -0.02445327f, -0.03395307f, 
    -0.01089152f, 0.11013436f, -0.00849874f, -0.02762946f, 0.03971108f, 0.10383134f, 0.05056485f, -0.01974703f, 
    0.03450537f, -0.03734069f, -0.01435906f, 0.15077046f, 0.05849032f, 0.16542545f, 0.05162422f, 0.02149452f, 
    0.00320901f, 0.16888916f, -0.07018596f, -0.14009511f, 0.00626291f, 0.04191168f, 0.02146044f, 0.05406213f, 
    0.06097244f, 0.04403880f, 0.08408991f, -0.15155508f, -0.07073306f, 0.15931290f, -0.16503751f, -0.11996361f, 
    -0.22660320f, -0.28225914f, 0.09785837f, 0.04944948f, 0.22824737f, -0.10016575f, 0.00341817f, -0.02338205f, 
    -0.03646615f, 0.05740609f, 0.26445991f, 0.05421206f, 0.03867479f, -0.03118906f, 0.10945252f, 0.08458783f, 
    0.05173983f, 0.00601277f, 0.04473282f, 0.00215825f, -0.12344480f, -0.08285117f, -0.04578871f, -0.05817525f, 
    -0.07325391f, 0.00853914f, 0.01488860f, 0.04323661f, 0.07115492f, -0.01619742f, -0.13323572f, 0.03394514f, 
    -0.01876914f, 0.06471615f, -0.03849569f, -0.06044715f, 0.00086084f, 0.02476688f, -0.03138857f, 0.01586623f, 
    -0.01064016f, 0.03399900f, 0.03892564f, 0.02492062f, 0.11598963f, -0.03719404f, 0.01140289f, 0.07846779f, 
    -0.01662408f, 0.00047668f, 0.04801374f, -0.00011129f, -0.00250452f, -0.05865180f, 0.10031762f, 0.14169939f, 
    -0.00443406f, 0.10945079f, 0.05184732f, -0.07565763f, 0.65704447f, 0.07986260f, -0.24722934f, -0.04356021f, 
    -0.23499463f, -0.10111636f, 0.06577163f, 0.04560348f, -0.20840137f, 0.08694151f, 0.17946489f, -0.05204730f, 
    0.19084287f, -0.09049454f, 0.04513105f, -0.04711924f, 0.00922548f, -0.06911619f, -0.00565028f, 0.04458690f, 
    0.12135097f, 0.12589115f, -0.03610020f, -0.00103631f, -0.08835917f, 0.07529284f, -0.06518355f, -0.09078143f, 
    -0.00957651f, -0.05192322f, -0.05484833f, -0.01537985f, -0.00137179f, 0.05514035f, -0.02521852f, -0.00543681f, 
    0.18122205f, 0.00633872f, 0.10625160f, 0.07109953f, 0.49585950f, 0.08106337f, 0.06731746f, 0.15797581f, 
    0.08135330f, -0.00883511f, 0.00385258f, -0.00814599f, 0.00159119f, -0.01376095f, 0.00269530f, 0.03945278f, 
    0.00176321f, 0.01856050f, 0.01733585f, 0.10256453f, -0.26441914f, -0.08942501f, -0.04485097f, -0.02460348f, 
    0.04230491f, 0.05033372f, -0.06495008f, -0.04411141f, -0.00957691f, -0.02949479f, -0.00303952f, 0.00595022f, 
    0.00932904f, 0.03646512f, 0.01852837f, 0.05426353f, -0.03181354f, 0.05140874f, 0.02423658f, -0.03896484f, 
    -0.03138158f, 0.02816991f, 0.04306998f, -0.00249572f, -0.09915848f, -0.05925493f, -0.18816958f, 0.10257355f, 
    -0.06698183f, 0.08713811f, 0.08095997f, -0.04936727f, 0.02921921f, -0.06069440f, -0.01697593f, -0.05162067f, 
    0.00884119f, -0.00442633f, -0.02113955f, -0.05012764f, 0.07166910f, 0.02601340f, 0.02772009f, 0.07695927f, 
    0.19608378f, -0.03741187f, 0.16571984f, -0.00032338f, -0.06816284f, 0.02163177f, -0.01869396f, -0.14796855f, 
    -0.04632785f, 0.02987192f, -0.00304283f, -0.04145496f, -0.01984453f, 0.03824132f, -0.00326585f, 0.04929487f, 
    0.12051018f, -0.13190888f, 0.09900325f, 0.02850675f, 0.17500158f, -0.00824404f, 0.04581765f, -0.04597262f, 
    0.05405478f, -0.02936342f, 0.00710426f, -0.16738829f, -0.03163951f, -0.03003852f, -0.02352605f, -0.02053333f, 
    0.01706134f, 0.03061133f, 0.00482179f, 0.05816785f, -0.01796024f, 0.01871243f, 0.03890071f, 0.00523146f, 
    -0.09413823f, -0.16492806f, -0.12953472f, 0.17792964f, -0.18979393f, 0.05347234f, 0.09753381f, 0.08913191f, 
    0.02096044f, 0.05352602f, -0.02949537f, -0.00043287f, 0.00194026f, -0.01075512f, -0.01183068f, -0.02246546f, 
    0.04167175f, -0.06548838f, 0.02974823f, 0.10034399f, -0.36881649f, -0.47368398f, 0.27286157f, 0.32130656f, 
    -0.34998903f, -0.02166429f, 0.02910052f, -0.05043746f, 0.15365322f, -0.12357862f, 0.00727962f, 0.01948296f, 
    -0.07676019f, 0.04994281f, -0.07608846f, 0.00525716f, 0.03841758f, 0.04413546f, 0.00707180f, 0.03141357f, 
    -0.17115520f, -0.18720855f, -0.04700729f, -0.18836671f, 0.03523010f, -0.00994935f, -0.02216891f, -0.03412798f, 
    0.01760370f, 0.03560687f, -0.00709410f, -0.05539205f, -0.03522217f, 0.01975398f, 0.05928690f, -0.04052791f, 
    -0.10263555f, -0.01366916f, 0.07162444f, -0.00807482f, 0.12952434f, 0.06357729f, -0.02512346f, 0.06687019f, 
    0.08632476f, -0.01521053f, -0.00564160f, 0.06677566f, -0.08565065f, -0.02541512f, 0.03157995f, -0.10489451f, 
    0.02937840f, 0.03919544f, 0.13194098f, -0.00087752f, 0.02845783f, 0.01620952f, 0.03410477f, -0.03460509f, 
    -0.04483108f, 0.06148185f, -0.11453379f, 0.07424337f, 0.01705718f, -0.10155247f, -0.06000613f, -0.11444283f, 
    -0.14685169f, 0.04216108f, -0.02426974f, 0.01067830f, 0.00670987f, -0.01559131f, -0.06021757f, -0.00597411f, 
    -0.02289271f, 0.03236443f, -0.19105698f, 0.04685332f, -0.59431887f, 0.60072428f, 0.31645480f, 0.18573555f, 
    -0.22577386f, -0.00452885f, -0.16196899f, -0.07811624f, -0.10699152f, 0.18952933f, -0.04376148f, 0.08390045f, 
    0.00815447f, 0.02313596f, -0.00424526f, -0.06300619f, 0.05883849f, -0.08603575f, 0.06034650f, -0.13980033f, 
    0.02965284f, 0.00615668f, -0.02157434f, 0.02312429f, 0.09155031f, 0.00153928f, 0.02693739f, -0.02720414f, 
    0.07298265f, -0.11892649f, -0.03009232f, -0.01613363f, -0.08131342f, 0.03415551f, 0.04698684f, -0.01505454f, 
    0.00472263f, 0.01852644f, -0.04119867f, 0.01572980f, -0.01639929f, -0.05605172f, -0.01338147f, -0.06498995f, 
    0.09155371f, -0.02648902f, -0.01112578f, 0.02761912f, 0.04756436f, 0.03085822f, 0.00536735f, -0.06575174f, 
    -0.05217719f, 0.04821812f, 0.00625051f, 0.04345539f, -0.11093236f, -0.03463668f, 0.04970954f, -0.03418281f, 
    0.06723841f, -0.12779225f, -0.10506586f, -0.01262822f, -0.04691000f, 0.13877137f, 0.01408760f, -0.13090019f, 
    0.00868056f, 0.03931046f, 0.04279637f, -0.01668510f, -0.02276736f, 0.00723821f, -0.11490115f, -0.00796848f, 
    -0.00023320f, 0.02113930f, -0.14232555f, -0.08914637f, 0.00642129f, -0.10021707f, -0.10053004f, -0.17352091f, 
    0.24701686f, 0.04516684f, 0.00761965f, -0.01097644f, -0.00502245f, -0.02283270f, -0.00306544f, 0.01645917f, 
    -0.05751841f, -0.02952560f, -0.00625678f, 0.14187256f, 0.03747382f, -0.00540637f, 0.05904622f, 0.06434590f, 
    -0.04049529f, 0.19757204f, 0.05684809f, 0.12507316f, 0.17582153f, -0.02376767f, -0.02581926f, 0.05956893f, 
    -0.03985810f, -0.04086171f, 0.04339997f, 0.13783439f, -0.01477965f, 0.05164576f, 0.06354177f, 0.00225174f, 
    -0.00320743f, 0.00813475f, -0.04257959f, 0.03660624f, 0.06425916f, -0.30148742f, 0.80102915f, 0.18644829f, 
    0.22538306f, -0.04364491f, -0.02994854f, -0.01121146f, 0.16646907f, -0.17104624f, 0.04880293f, 0.04584775f, 
    0.04834679f, -0.09723552f, 0.08772169f, 0.00753822f, -0.03678663f, 0.01698500f, -0.00416140f, -0.03859318f, 
    0.02622133f, -0.03797264f, 0.08870831f, -0.01334054f, 0.05310598f, -0.00259566f, -0.02208627f, -0.02846531f, 
    0.03514318f, 0.02403669f, -0.14430748f, -0.11583316f, -0.13519213f, 0.04141641f, 0.08204588f, 0.02975589f, 
    -0.08976136f, -0.00855839f, 0.01536415f, -0.09091851f, 0.04472319f, -0.67378473f, -0.04415162f, -0.12300038f, 
    -0.14375424f, 0.00678241f, -0.08494175f, -0.00631115f, -0.05705902f, 0.00642947f, -0.01302494f, -0.04650814f, 
    0.01907005f, -0.09593596f, -0.00761499f, 0.13911690f, 0.00974290f, -0.20723382f, 0.27754825f, 0.02227937f, 
    -0.33938971f, -0.31643593f, 0.51467597f, 0.23056960f, 0.06304913f, -0.05270440f, -0.16447465f, -0.17333393f, 
    -0.09292789f, -0.07358918f, 0.05708086f, 0.00715212f, 0.01399492f, -0.16429088f, 0.15099922f, 0.05377138f, 
    0.06440124f, 0.05294271f, -0.03284721f, -0.04241140f, -0.23862126f, -0.51582384f, -0.33073628f, 0.03882187f, 
    -0.39413565f, 0.02418825f, 0.01401033f, -0.00940499f, 0.00558565f, -0.16569586f, 0.03342875f, 0.06538253f, 
    -0.00460258f, 0.01969300f, -0.02743826f, -0.01826594f, -0.02964517f, -0.00387431f, -0.05527861f, -0.06429900f, 
    -0.12121460f, 0.26342535f, 0.33450884f, 0.02824661f, 0.04843113f, 0.03426715f, -0.05586957f, -0.03117533f, 
    -0.04827429f, 0.10499193f, 0.04011760f, 0.03315971f, 0.06886642f, 0.01248742f, -0.02818027f, -0.00029743f, 
    0.05727297f, -0.04865739f, 0.09142072f, -0.09692473f, 0.21967082f, 0.01112503f, -0.10025205f, -0.05752883f, 
    0.09480203f, -0.13765067f, 0.06635571f, -0.04463494f, -0.05978789f, 0.03240675f, -0.05345336f, -0.05512444f, 
    -0.05949060f, 0.09714636f, -0.18201996f, 0.05913990f, 0.00510466f, 0.00541993f, 0.03288064f, 0.06284194f, 
    0.14322931f, 0.05824510f, 0.10139722f, 0.12215263f, 0.12495255f, 0.00794668f, -0.04143757f, -0.06246025f, 
    -0.02524699f, -0.08388904f, 0.14354536f, 0.03144115f, 0.04850110f, 0.06342315f, 0.01023210f, 0.02656711f, 
    -0.04735977f, -0.03145636f, 0.02390767f, 0.01574806f, 0.28207821f, 0.09425582f, 0.06477419f, 0.01633852f, 
    0.10108729f, 0.02574724f, -0.11708666f, -0.14261241f, -0.00086441f, 0.21967284f, 0.02298224f, -0.03014059f, 
    0.06360922f, -0.04429159f, -0.04845278f, 0.06362317f, 0.02989587f, 0.01978104f, -0.05084975f, 0.03558030f, 
    -0.13644765f, -0.16708806f, -0.06349140f, -0.04032202f, 0.02985616f, -0.02927433f, -0.01374413f, -0.02515394f, 
    -0.00218786f, 0.02942931f, -0.00006044f, -0.03362724f, -0.13044812f, 0.10578272f, -0.01354071f, 0.06990874f, 
    -0.02479202f, 0.01730376f, 0.06299975f, -0.00902690f, 0.05638261f, -0.03947885f, -0.02916883f, -0.04360897f, 
    0.00953203f, -0.05401116f, -0.05264257f, 0.00714561f, -0.09678018f, -0.00617276f, 0.12952983f, -0.11075918f, 
    -0.10941067f, 0.04564170f, 0.03682072f, -0.03353671f, -0.07535467f, 0.08021661f, 0.04828538f, -0.09556811f, 
    -0.32801709f, 0.17639275f, -0.00352735f, 0.04045955f, -0.09987769f, -0.04942830f, -0.04859480f, -0.15287481f, 
    -0.09428762f, 0.03059403f, 0.03169403f, -0.00651463f, 0.00243059f, 0.05032720f, -0.06099759f, 0.01840579f, 
    0.03279949f, -0.10007409f, 0.00626127f, 0.03613040f, 0.01409477f, -0.10256463f, -0.13153228f, -0.13386896f, 
    0.06590533f, 0.02267082f, 0.00587591f, -0.01765320f, 0.00882852f, 0.05097611f, -0.02888853f, 0.01229994f, 
    -0.09806240f, 0.04017572f, -0.05794768f, 0.03803356f, 0.05750279f, 0.00588116f, 0.06283174f, 0.00517375f, 
    -0.26720139f, -0.03665345f, 0.07238419f, -0.17317107f, 0.03577887f, 0.01583440f, -0.06095424f, -0.01659460f, 
    0.00256044f, 0.08541287f, -0.01919845f, -0.02447565f, 0.07273760f, -0.06856345f, 0.01446211f, -0.05051328f, 
    -0.15990119f, -0.15279911f, 0.08885158f, 0.02104215f, 0.15562585f, 0.16458987f, 0.02223105f, 0.25854206f, 
    0.26734680f, 0.00830094f, 0.10058811f, -0.09563084f, 0.07468394f, -0.03764309f, -0.00727618f, -0.02427674f, 
    -0.07076186f, 0.02230008f, -0.05550486f, 0.04875293f, 0.20749760f, 0.14728370f, -0.11944509f, 0.13929734f, 
    -0.01965741f, 0.07698551f, -0.09070095f, -0.00358018f, 0.09921612f, -0.23785420f, 0.00225079f, -0.06392885f, 
    0.00544830f, 0.01062691f, 0.06904560f, 0.00202762f, -0.03838639f, 0.00881971f, 0.01755914f, 0.06747445f, 
    -0.08333914f, 0.01564367f, -0.03877040f, 0.01112675f, -0.08084290f, -0.33719787f, -0.07786933f, 0.23471072f, 
    -0.47819459f, 0.00561276f, -0.06419958f, -0.06686739f, 0.17377268f, -0.13584247f, 0.04538402f, 0.08575203f, 
    -0.04121328f, 0.03397866f, -0.04777984f, 0.01744531f, 0.01104388f, 0.05944558f, 0.06462079f, -0.06095509f, 
    -0.10850544f, 0.15688591f, 0.44233099f, 0.16042531f, 0.12109859f, -0.07133534f, -0.01588913f, 0.13525906f, 
    -0.19287235f, 0.03854340f, 0.17336413f, 0.05246047f, 0.04246991f, -0.07193290f, 0.06332722f, -0.06706599f, 
    0.00828330f, 0.09048554f, 0.03362433f, -0.04040861f, -0.53198850f, -0.58531052f, -0.48995772f, 0.19515727f, 
    -0.48394957f, 0.03870586f, -0.06829704f, 0.11043657f, -0.00979843f, -0.04490192f, -0.03321846f, -0.00381197f, 
    0.04297911f, -0.07568543f, 0.00990360f, -0.02492683f, -0.02706333f, -0.05718866f, -0.15168078f, 0.04249633f, 
    -0.60144317f, -0.78318399f, 0.33615497f, -0.40064088f, -0.12265044f, 0.05905680f, 0.05080619f, -0.43503904f, 
    -0.08510771f, -0.17549010f, 0.04341449f, -0.00645878f, 0.02036906f, -0.02036014f, 0.01511647f, 0.00805367f, 
    -0.04446097f, -0.06140785f, -0.17136882f, 0.04218962f, 0.01351762f, -0.00644714f, -0.02682601f, -0.06229259f, 
    0.12043364f, -0.03407073f, -0.00093050f, -0.00521792f, 0.00532906f, 0.03887988f, -0.05181311f, -0.04381583f, 
    -0.03982629f, 0.00786223f, -0.02126002f, -0.00470009f, -0.15429276f, -0.01716926f, 0.06135480f, -0.04220947f, 
    -0.15537666f, -0.12410112f, -0.37005988f, -0.05343158f, -0.14893317f, 0.00497646f, -0.04097646f, -0.01204474f, 
    0.08962757f, 0.11959721f, 0.01927356f, -0.01160254f, -0.01623573f, -0.01946630f, -0.02701356f, -0.06768721f, 
    0.03619328f, 0.08166005f, -0.09498002f, 0.10497942f, -0.66139835f, 0.48935938f, 0.02618452f, -0.16063574f, 
    -0.18289077f, 0.12773159f, -0.05193143f, -0.05730926f, -0.03138505f, 0.04627156f, -0.01326949f, 0.05521354f, 
    0.00138810f, -0.05486286f, 0.02944579f, 0.16091563f, 0.02947141f, 0.13853280f, 0.17444661f, 0.07592610f, 
    0.09065039f, -0.08335643f, 0.07275924f, 0.07312147f, 0.10591943f, 0.03575392f, 0.03724686f, 0.05450126f, 
    0.05697960f, 0.01527678f, -0.16583551f, -0.11282743f, 0.08821995f, -0.04354319f, -0.01436082f, 0.01527596f, 
    -0.05602216f, 0.00117337f, 0.01086174f, -0.01656192f, -0.19093551f, -0.02866654f, 0.02345739f, -0.03251556f, 
    0.01548319f, -0.03662654f, -0.06674933f, -0.02577260f, 0.02115851f, 0.04610392f, -0.04738576f, -0.04953164f, 
    0.01255755f, -0.00345846f, -0.01054649f, -0.14577207f, -0.23518708f, -0.10988551f, 0.02016474f, 0.01266166f, 
    -0.27882525f, 0.15098073f, 0.04701070f, 0.07015058f, 0.04323762f, -0.07065976f, 0.00899573f, -0.21554838f, 
    -0.35614389f, -0.19281077f, 0.01231998f, -0.03214548f, 0.09657755f, -0.04813412f, 0.01381445f, 0.03709774f, 
    0.03572692f, -0.05285488f, -0.08314715f, -0.08144326f, -0.03688232f, 0.17397729f, 0.25775445f, -0.01936328f, 
    0.12548470f, -0.01537230f, -0.01673142f, -0.02987084f, -0.03440776f, 0.06242971f, -0.01717671f, -0.00376016f, 
    -0.15438603f, 0.02577094f, 0.09028614f, 0.05376071f, -0.05366314f, -0.06608491f, 0.07394081f, -0.05224557f, 
    0.49192074f, -0.05329609f, -0.14379148f, 0.01079300f, 0.04214076f, 0.12297575f, 0.05205785f, -0.04517775f, 
    0.11654165f, 0.04412012f, -0.02805681f, 0.03054676f, -0.01657750f, -0.00988314f, -0.01582330f, 0.01278132f, 
    0.00978444f, -0.00170177f, 0.03467272f, -0.02322471f, 0.15840799f, 0.36562237f, -0.26741791f, 0.15246089f, 
    -0.11194377f, 0.02257410f, -0.05489554f, 0.06904156f, 0.02571576f, 0.06806311f, -0.02166850f, 0.02090560f, 
    0.02785023f, 0.06652984f, 0.01563028f, 0.00639786f, 0.01575447f, 0.00519773f, -0.04486300f, 0.06422094f, 
    -0.18622877f, 0.03294756f, -0.00384623f, 0.05688402f, 0.04318068f, -0.00871360f, -0.03381414f, 0.01036789f, 
    0.01019949f, 0.09783385f, 0.04553551f, -0.00051837f, -0.08968000f, 0.07840860f, -0.00692414f, -0.04175302f, 
    -0.12713276f, 0.12220888f, 0.05126799f, -0.02993985f, -0.00520045f, 0.26584256f, 0.40281543f, 0.19190776f, 
    0.29558060f, -0.15990873f, -0.03973971f, 0.09040964f, 0.12381323f, 0.05039902f, 0.02129449f, 0.04954479f, 
    0.04726939f, -0.06400620f, 0.06886379f, -0.01186292f, 0.01889101f, -0.02033321f, -0.01807516f, -0.02976388f, 
    0.00911104f, -0.44519427f, 0.19620959f, -0.07415748f, -0.18268929f, 0.02639857f, 0.01807066f, -0.10426109f, 
    -0.00638464f, -0.07390098f, -0.00248300f, -0.01261696f, -0.01937127f, -0.00574352f, 0.00885089f, -0.02389058f, 
    -0.06287960f, 0.10383989f, 0.15101567f, 0.10361839f, 0.05453984f, 0.00832934f, 0.00822175f, 0.11116055f, 
    0.01238898f, -0.01399693f, -0.05568007f, 0.00611019f, -0.11178448f, -0.39399406f, -0.12231795f, -0.03909357f, 
    0.09406108f, -0.02963671f, -0.01123090f, -0.02246362f, -0.03616777f, -0.00246369f, -0.00795681f, -0.03710018f, 
    -0.06469405f, -0.09798895f, -0.00658603f, 0.01130685f, 0.02151577f, 0.00072473f, -0.01205436f, 0.01640135f, 
    0.05613237f, 0.05700764f, -0.00596042f, -0.10772023f, -0.04985350f, 0.03477442f, -0.08844986f, 0.00834994f, 
    -0.00183120f, 0.02969077f, 0.00069681f, -0.01506289f, -0.33821729f, -0.33546486f, 0.55054790f, 0.44831297f, 
    0.10886032f, -0.04702318f, -0.01082589f, -0.07713957f, 0.18627775f, -0.04182618f, -0.00408347f, -0.00987418f, 
    0.03329789f, -0.04450390f, 0.03504959f, -0.04821440f, -0.02113835f, -0.01046201f, -0.04367738f, -0.01267334f, 
    -0.11198420f, 0.03988067f, -0.02029863f, -0.09130829f, 0.17068285f, -0.00085670f, -0.02001641f, -0.06135353f, 
    0.04893935f, 0.00003315f, -0.11990607f, 0.01690944f, -0.03023548f, -0.02295233f, 0.09061853f, 0.07437088f, 
    0.07273880f, -0.00569240f, 0.01930595f, -0.03651845f, -0.18244895f, -0.03156449f, 0.16258880f, -0.05415981f, 
    -0.22272082f, -0.00259137f, 0.03279453f, -0.05707781f, -0.04317205f, 0.05718604f, 0.02022910f, 0.01125159f, 
    -0.06683814f, 0.07427733f, -0.03373355f, -0.01665235f, -0.06581366f, -0.16597779f, 0.03338514f, -0.01740084f, 
    -0.04526034f, -0.00299589f, 0.00055260f, -0.02117414f, -0.00427643f, 0.09510440f, -0.16908666f, -0.34253728f, 
    0.01421982f, -0.03726961f, 0.01097926f, -0.03863795f, -0.05994833f, 0.05647109f, -0.03724968f, -0.00387054f, 
    -0.01224226f, -0.05945629f, 0.09078011f, -0.06137241f, -0.08469126f, 0.17494929f, -0.03241258f, -0.03032319f, 
    0.05853341f, 0.10248761f, -0.23356463f, -0.01797965f, 0.06385019f, 0.02841601f, -0.01982162f, 0.10489872f, 
    0.03227042f, -0.01864185f, 0.01647321f, -0.11389665f, -0.08415332f, -0.02743195f, 0.25582361f, -0.09172811f, 
    0.35599500f, -0.24478403f, -0.21541961f, 0.19412096f, 0.04960979f, 0.15089789f, -0.05302743f, -0.10325626f, 
    -0.00537147f, -0.00345583f, -0.07665437f, 0.17914096f, -0.04504276f, 0.14744872f, -0.02901332f, 0.07004548f, 
    0.02744658f, -0.05608290f, 0.24298204f, 0.05790559f, -0.02281491f, -0.02695773f, -0.03634230f, 0.00938862f, 
    0.07171362f, -0.01634871f, -0.08215184f, -0.10361093f, 0.07489865f, -0.00325074f, -0.12370484f, -0.26330304f, 
    -0.08004110f, 0.03034864f, -0.02051735f, -0.01334383f, -0.01303883f, -0.09405645f, 0.02939667f, 0.00828287f, 
    -0.09331077f, -0.00722049f, -0.06601388f, 0.05788786f, 0.05859985f, -0.08784317f, 0.02768141f, 0.02913627f, 
    -0.12081990f, 0.00643083f, 0.08093206f, 0.02901844f, -0.03004399f, -0.01471671f, -0.01337599f, 0.03732276f, 
    -0.03338436f, 0.01264303f, -0.19024031f, -0.03888486f, -0.46286142f, -0.55583215f, -0.31150779f, 0.03577541f, 
    -0.41060799f, -0.04578602f, 0.03921246f, 0.04028102f, -0.01986652f, -0.11882928f, -0.04220131f, -0.00093666f, 
    -0.00919276f, -0.05388970f, -0.01228774f, -0.11762866f, -0.06337501f, 0.00475686f, -0.03457562f, 0.13217159f, 
    0.38243860f, 0.16472110f, -0.18289760f, -0.04833452f, 0.16668275f, -0.12196932f, 0.08779357f, -0.01278841f, 
    0.00111954f, -0.02729758f, -0.18296453f, -0.04637620f, 0.08562213f, -0.03107565f, -0.00215153f, 0.04834866f, 
    0.10618924f, 0.02799076f, 0.05305877f, 0.03279594f, 0.03487013f, 0.08347956f, -0.01713637f, 0.08306075f, 
    0.06551114f, 0.03564900f, 0.01293133f, 0.04150650f, -0.01309479f, -0.12217683f, -0.02937049f, -0.00438121f, 
    -0.05405767f, 0.05832138f, 0.02540061f, -0.01174808f, -0.03653221f, 0.02484429f, -0.03376885f, -0.02382855f, 
    0.05111817f, -0.11183548f, -0.17514858f, -0.02953470f, 0.13360928f, 0.06548924f, -0.02171369f, -0.00634887f, 
    -0.01818418f, 0.00606564f, 0.06914608f, 0.06923108f, 0.04275914f, 0.06267285f, -0.18766576f, -0.07303524f, 
    0.08696050f, 0.12582542f, -0.02392668f, 0.00346119f, -0.21270312f, 0.37974510f, 0.20081005f, -0.05198193f, 
    -0.13919558f, 0.00130501f, -0.07993833f, -0.11348853f, -0.14693564f, -0.15598245f, -0.06797269f, -0.01515881f, 
    0.08874162f, -0.07536027f, -0.01176699f, 0.00084206f, 0.02765980f, 0.04809063f, 0.08154066f, -0.07357559f, 
    -0.21772487f, -0.10472860f, 0.20208924f, -0.27981818f, 0.04943740f, 0.01506261f, -0.04614430f, -0.11826833f, 
    0.06245928f, 0.06753421f, 0.00483693f, -0.00210983f, 0.00015345f, 0.03420274f, 0.03459886f, 0.06198391f, 
    -0.13661918f, -0.11777517f, -0.01517956f, 0.02725992f, -0.31226063f, 0.02175572f, -0.00513978f, -0.16109492f, 
    -0.07207751f, 0.04314239f, 0.01881979f, 0.02190563f, 0.02130253f, -0.00007562f, 0.00934413f, -0.00335224f, 
    0.02684826f, -0.00004928f, 0.05312314f, 0.11269357f, 0.09550225f, 0.12048475f, 0.18991949f, -0.05837720f, 
    -0.05764028f, 0.10856479f, -0.08674973f, 0.02687903f, -0.01303782f, 0.03193494f, -0.04103575f, -0.10357545f, 
    0.05567832f, -0.00457426f, -0.00995949f, -0.00672201f, -0.06497074f, 0.04469862f, -0.02206182f, 0.00485464f, 
    -0.05364438f, -0.01962318f, -0.01150980f, -0.02488673f, -0.00169155f, -0.17924921f, -0.05969425f, 0.19074547f, 
    -0.13723168f, 0.10148545f, 0.01305406f, 0.06105234f, 0.04367860f, -0.19082803f, 0.01289110f, 0.09640572f, 
    0.00487497f, 0.02653202f, -0.01148993f, 0.01098413f, -0.01997989f, 0.05246102f, 0.13337740f, -0.03108934f, 
    -0.34081402f, -0.22609320f, 0.32124650f, -0.23875979f, -0.06358009f, -0.00212465f, 0.09571867f, -0.05139881f, 
    -0.05038543f, 0.13193762f, 0.01836017f, 0.00510258f, -0.00482564f, 0.02667791f, -0.00259114f, 0.01063828f, 
    -0.05399915f, -0.10638534f, -0.05872605f, -0.03490847f, -0.26683101f, -0.08016104f, 0.13066053f, -0.06903604f, 
    0.00409261f, -0.08416682f, -0.03341442f, -0.09811501f, -0.07002731f, 0.10290050f, 0.04214655f, -0.00228941f, 
    0.01174693f, 0.00457912f, -0.02478034f, -0.00459802f, -0.06353797f, 0.04358794f, -0.11459454f, -0.06504463f, 
    -0.05664441f, -0.06298561f, -0.16559093f, 0.02560990f, 0.17520882f, -0.09953904f, -0.06404369f, -0.03635938f, 
    0.03482671f, -0.00087145f, -0.02089497f, 0.02221960f, -0.05015731f, -0.09582014f, 0.01451689f, -0.05040143f, 
    -0.03456128f, 0.06955384f, -0.01507656f, -0.05090803f, -0.12401798f, 0.07873730f, -0.22662351f, 0.10187564f, 
    0.23960602f, 0.01551564f, 0.04688081f, 0.08617897f, -0.03565778f, 0.08942663f, -0.13578460f, 0.08811464f, 
    -0.03505268f, 0.03695061f, 0.10684225f, -0.05013804f, -0.04903755f, 0.14708760f, 0.03413860f, 0.06066028f, 
    -0.19306430f, -0.22086841f, -0.20058942f, -0.09000128f, -0.33325127f, 0.01614620f, 0.14674182f, -0.06769898f, 
    0.08855944f, 0.01607866f, 0.06425596f, 0.06867128f, 0.00783341f, 0.08264735f, -0.00542053f, -0.01791669f, 
    0.01303080f, 0.19995049f, -0.19591863f, -0.14165637f, 0.66023088f, 0.10246915f, -0.15889068f, 0.00764575f, 
    -0.02308664f, 0.00800465f, -0.01350867f, 0.09428476f, -0.19949573f, -0.03173001f, -0.15412675f, 0.00688163f, 
    0.01240920f, 0.14614654f, -0.03710766f, 0.04381824f, 0.04940443f, 0.10942909f, -0.11314888f, -0.00119319f, 
    -0.12840217f, 0.02443964f, -0.05967549f, 0.01248760f, -0.01543614f, 0.08605500f, -0.03946831f, -0.03160814f, 
    -0.06922079f, -0.12790607f, 0.03675418f, 0.03111465f, -0.05367800f, -0.14266081f, 0.06765044f, 0.16929273f, 
    -0.02384504f, 0.12795210f, -0.18775006f, -0.16732158f, 0.06253752f, -0.01121038f, 0.17284642f, 0.23679325f, 
    0.38159060f, 0.05871954f, 0.01361225f, -0.09530991f, -0.05091251f, -0.09932293f, 0.00549776f, -0.07119023f, 
    -0.02219908f, 0.01111094f, -0.10123906f, 0.08016841f, 0.02767178f, 0.08066382f, 0.00756967f, -0.04291932f, 
    -0.34230891f, 0.11521164f, 0.18724917f, -0.02990981f, 0.28588974f, 0.04120759f, 0.10041171f, 0.06705991f, 
    0.06908078f, -0.00631968f, -0.29358873f, 0.13944808f, 0.00808322f, 0.04380185f, 0.03025698f, 0.10101248f, 
    0.12178421f, 0.16867679f, -0.07158031f, -0.01763864f, -0.22140048f, -0.15767619f, -0.02600078f, -0.12180126f, 
    -0.22976847f, 0.00970609f, -0.16459946f, 0.02322524f, -0.06128430f, -0.10947633f, -0.06337585f, -0.03482958f, 
    -0.00180733f, 0.07349517f, 0.01307920f, -0.01272107f, -0.02198750f, -0.03493786f, -0.08767946f, -0.07756484f, 
    0.07587826f, 0.02710384f, 0.01178987f, -0.02587141f, 0.20981358f, 0.03819465f, 0.08399460f, -0.01651667f, 
    0.06543691f, -0.08153899f, 0.08557180f, -0.04348651f, -0.08921549f, -0.01750189f, 0.02527559f, 0.04410078f, 
    -0.02091827f, 0.09415992f, -0.26183236f, 0.01487746f, 0.52137429f, 0.13858597f, -0.05799792f, -0.21256910f, 
    -0.20891815f, 0.10643326f, 0.08098992f, 0.05258833f, -0.07159799f, 0.08594999f, -0.11633202f, -0.10996211f, 
    0.14690359f, -0.18313663f, -0.03543140f, -0.15745993f, -0.11462487f, -0.15604895f, 0.07318719f, 0.02238891f, 
    0.01979722f, -0.11771682f, -0.16382274f, -0.03419409f, 0.21342888f, 0.09234779f, 0.04356914f, -0.01509214f, 
    -0.03126205f, -0.06616925f, -0.05595243f, 0.02657340f, 0.01461775f, 0.03309897f, 0.01115691f, 0.00570990f, 
    -0.02783699f, 0.07756673f, -0.01192989f, -0.00782405f, -0.89760226f, 0.73350310f, -0.19528680f, -0.13521531f, 
    0.26237378f, 0.27163449f, 0.07864822f, 0.04937855f, -0.05032663f, -0.00669885f, -0.30654809f, -0.02721614f, 
    -0.00300536f, 0.02790058f, 0.03929755f, -0.00749282f, -0.00822721f, -0.05436583f, -0.01078854f, 0.01316801f, 
    -0.07356601f, 0.14696407f, -0.23847657f, 0.17819774f, -0.03834387f, 0.09053607f, -0.07444610f, -0.01810133f, 
    -0.08541317f, -0.02653901f, -0.12862930f, 0.02940764f, 0.00167279f, -0.00943867f, 0.01097410f, 0.15163188f, 
    0.03250403f, 0.05563058f, -0.07335758f, 0.05268745f, 0.15671948f, -0.03707261f, -0.22999273f, -0.00726736f, 
    0.09821367f, -0.03767128f, 0.01326484f, -0.02501925f, 0.11034582f, 0.07875293f, -0.06196941f, -0.09213015f, 
    -0.01260451f, -0.01361757f, 0.06328768f, 0.13556854f, 0.19502430f, 0.06767928f, 0.07890164f, -0.00351783f, 
    0.12502275f, 0.14495802f, -0.15209801f, 0.06174458f, 0.14419933f, 0.18551329f, 0.09968331f, 0.09363230f, 
    0.06388102f, 0.12115449f, -0.12488359f, 0.02357455f, 0.07832220f, 0.05406315f, 0.09055078f, -0.12814307f, 
    0.10698195f, -0.00537928f, 0.10167207f, 0.03408332f, -0.07770492f, -0.09911151f, -0.30016091f, 0.03821095f, 
    0.13381974f, 0.12228257f, 0.00344407f, 0.07071340f, 0.15167150f, 0.08346972f, -0.05998620f, 0.01299774f, 
    -0.10859440f, 0.06024775f, -0.07453183f, 0.05055312f, -0.05724125f, 0.09580974f, -0.08025073f, 0.01034746f, 
    -0.01246121f, 0.37497741f, -0.00993980f, 0.12405029f, 0.01833873f, 0.06518155f, -0.05869188f, 0.01131265f, 
    0.00281659f, 0.00666655f, -0.10969076f, -0.06948707f, -0.08433837f, -0.06035105f, -0.01249837f, -0.05331623f, 
    -0.07482866f, -0.10031026f, -0.04242529f, -0.02687073f, 0.48246625f, 0.44720301f, -0.17581815f, -0.50944728f, 
    -0.07957461f, 0.04489448f, -0.11374508f, 0.03452080f, -0.05049089f, -0.05584286f, -0.11169042f, -0.08658724f, 
    -0.02441836f, -0.03982688f, -0.04771495f, 0.04852941f, 0.02384329f, -0.13114963f, 0.09397183f, 0.08182111f, 
    0.01194146f, -0.09678044f, -0.11790179f, -0.08458821f, 0.20411704f, 0.05177945f, 0.02581106f, 0.03079611f, 
    0.00328782f, -0.01712074f, -0.13386865f, 0.00323198f, 0.00600362f, 0.03006093f, -0.05970036f, 0.03212623f, 
    0.02313138f, -0.00693079f, 0.05408159f, 0.04491675f, 0.05670139f, 0.28528380f, 0.20006682f, -0.20657733f, 
    0.22240348f, -0.05365434f, 0.07674052f, -0.03711555f, -0.10574459f, -0.05653765f, 0.05070756f, 0.00728149f, 
    -0.08919674f, 0.03842855f, -0.01867402f, 0.04437412f, -0.01154629f, -0.06415133f, -0.05815795f, -0.02776652f, 
    -0.30002609f, -0.23832421f, -0.05831224f, -0.10644677f, -0.13664745f, 0.21959193f, 0.00857957f, 0.17946649f, 
    0.13555425f, -0.05372092f, -0.02446314f, 0.00189379f, -0.00338043f, 0.00778555f, -0.10006309f, 0.01265910f, 
    -0.08010583f, -0.10787271f, 0.02105740f, -0.07326896f, -0.01028334f, 0.19407602f, 0.03325619f, -0.18183340f, 
    -0.04702083f, 0.03515273f, -0.08147478f, -0.00018678f, -0.01322734f, -0.22501306f, 0.04915743f, -0.09341457f, 
    -0.15213281f, -0.04304826f, 0.00504529f, 0.03968091f, -0.13821322f, 0.17002039f, -0.03815412f, -0.04654684f, 
    -1.08050752f, -0.11379363f, -0.15232928f, 0.30862811f, -0.19391707f, 0.11243576f, -0.07022441f, 0.05873895f, 
    -0.03758207f, -0.10604347f, -0.03795528f, 0.08417248f, 0.01090977f, 0.05476935f, 0.08037397f, 0.05284565f, 
    0.15543008f, 0.18799633f, -0.06866609f, -0.28342324f, 0.18046685f, -0.23494036f, -0.02159756f, -0.20606752f, 
    -0.25645995f, 0.08861444f, 0.05894648f, 0.02594688f, 0.08769274f, 0.04178572f, -0.03597299f, -0.04335975f, 
    0.05395450f, -0.11260675f, -0.09220187f, -0.07138370f, -0.07005265f, 0.02394703f, -0.10274087f, -0.12631170f, 
    -0.13106589f, -0.36909229f, -0.22074924f, -0.11647896f, -0.28662941f, 0.07936151f, -0.20696467f, 0.22446050f, 
    0.02734463f, 0.03312643f, 0.06175146f, 0.05324951f, 0.06646400f, 0.02396279f, 0.07826578f, 0.05025534f, 
    -0.04211451f, 0.07221282f, -0.00368807f, -0.21378487f, 0.15182528f, 0.25540954f, 0.19462918f, -0.24385339f, 
    0.16516592f, -0.04832438f, 0.09648458f, -0.00009398f, -0.09668209f, -0.00725101f, -0.01608100f, -0.00780337f, 
    0.00398285f, -0.03894560f, 0.05397867f, -0.03873247f, -0.02970588f, -0.05787272f, 0.09458417f, 0.01495006f, 
    -0.19252822f, -0.01872813f, -0.18076980f, -0.01740281f, -0.21180031f, -0.00025048f, -0.11028489f, -0.00361041f, 
    -0.09407419f, -0.11030760f, 0.01450037f, -0.01389507f, -0.07102742f, -0.04114115f, 0.02074913f, 0.09469450f, 
    -0.04788979f, 0.16309127f, -0.07238758f, -0.12096550f, -0.15639371f, -0.12879643f, -0.29859790f, -0.08370968f, 
    0.23709059f, 0.09490451f, -0.02077991f, -0.00825858f, 0.15310456f, -0.03983641f, -0.02075408f, 0.01279982f, 
    -0.02033146f, 0.13036920f, -0.00187898f, 0.01776838f, -0.06869172f, 0.16890799f, 0.03873197f, 0.08432864f, 
    0.12398820f, 0.39229342f, 0.01042433f, -0.00891876f, 0.13391930f, 0.20921527f, 0.09161568f, -0.03065711f, 
    0.05291058f, -0.00182410f, -0.05307207f, -0.03394748f, 0.02924733f, 0.00153722f, 0.08385013f, -0.06790541f, 
    0.00693295f, 0.02836974f, 0.00462515f, -0.04399830f, 0.14701703f, -0.18542758f, -0.33615389f, 0.01612643f, 
    0.24735510f, 0.05599596f, 0.07367801f, -0.03259302f, -0.03767293f, 0.05224267f, -0.03280045f, 0.00713676f, 
    0.02247014f, 0.00590462f, -0.03385684f, -0.01254100f, -0.03709159f, 0.15616038f, 0.00846117f, -0.05682771f, 
    -0.03356782f, -0.10247464f, 0.27941880f, 0.14949021f, 0.35519272f, -0.09527078f, 0.13387372f, 0.02442667f, 
    0.05170348f, 0.08667257f, 0.10813382f, 0.10590575f, -0.05640902f, 0.00516796f, 0.08671321f, -0.08721209f, 
    -0.03704688f, 0.09004876f, 0.07992796f, 0.00356282f, -0.14768355f, 0.01197942f, 0.06053847f, -0.25103182f, 
    -0.30274332f, -0.07020320f, -0.22719114f, 0.02603671f, -0.05323025f, -0.14804028f, -0.03179315f, 0.00421893f, 
    0.05444711f, 0.02885200f, -0.02866023f, -0.04971445f, -0.01761938f, -0.15098460f, 0.01569315f, -0.01418583f, 
    0.00880857f, -0.05886609f, 0.12808576f, -0.01225437f, 0.20477980f, -0.09971080f, 0.13966428f, -0.07659121f, 
    -0.01833913f, -0.04082263f, -0.02704106f, -0.01884387f, -0.02413763f, -0.10082342f, -0.03212842f, 0.01400396f, 
    -0.01628353f, 0.12932912f, -0.21861009f, -0.10917155f, -0.45128486f, -0.09596859f, -0.13478334f, 0.28757682f, 
    -0.01003643f, -0.01689051f, -0.00670172f, 0.08590150f, -0.09744778f, 0.01373868f, -0.03950126f, 0.06503760f, 
    -0.10333714f, -0.06410017f, 0.15020113f, -0.08861610f, -0.02078396f, -0.02255541f, 0.06049898f, -0.03714820f, 
    -0.27998358f, 0.55416971f, -0.10955678f, -0.09049572f, 0.09803833f, 0.23782757f, 0.02635542f, -0.02137955f, 
    0.07384974f, -0.07787672f, -0.19965230f, -0.04075724f, -0.04798435f, -0.04970073f, -0.00191823f, 0.01990885f, 
    0.04117111f, -0.13099739f, 0.09515567f, -0.04506173f, -0.34485415f, -0.38889295f, -0.01757928f, -0.12726215f, 
    -0.05818673f, 0.04616183f, -0.00900707f, -0.09068108f, -0.02227378f, -0.01415524f, 0.05724755f, 0.05449968f, 
    0.03656750f, -0.00021026f, 0.01826304f, -0.00198244f, 0.02293608f, 0.11023694f, -0.08078852f, -0.13456625f, 
    -0.15712924f, 0.02418569f, -0.05351280f, 0.36924705f, 0.39321640f, -0.05838275f, 0.03960636f, 0.02083592f, 
    -0.15044893f, 0.02489154f, 0.01288738f, -0.00143173f, 0.03601009f, -0.08938345f, -0.13324758f, 0.03767867f, 
    0.01166966f, 0.06526651f, 0.07665036f, -0.09859245f, -0.40523735f, 0.23781636f, -0.01214561f, 0.15515876f, 
    0.21310796f, 0.02480308f, -0.06010005f, 0.05905333f, -0.08629586f, -0.04505680f, -0.12135547f, -0.00045942f, 
    0.04414826f, 0.02267899f, -0.05927010f, -0.03527189f, 0.00361364f, 0.01309608f, -0.07349591f, -0.04893173f, 
    -0.00488471f, 0.33304152f, -0.11363613f, -0.12307228f, 0.27742124f, -0.07793064f, 0.05301136f, -0.06204906f, 
    0.02843368f, -0.05990839f, -0.07550183f, 0.00750444f, -0.16733721f, -0.01286584f, -0.07049847f, -0.09945031f, 
    -0.11040326f, 0.08913522f, -0.07204036f, 0.03352757f, 0.29439643f, -0.04710056f, -0.20796762f, -0.11793092f, 
    0.14054354f, 0.04336031f, 0.01875123f, 0.05902652f, -0.01911482f, -0.23907933f, 0.02935117f, 0.00158328f, 
    0.00527091f, 0.10778800f, 0.03567360f, -0.05078623f, -0.07982422f, 0.12988448f, 0.09525590f, -0.10363370f, 
    -0.32933632f, -0.14656614f, 0.13556880f, -0.01780072f, -0.22346784f, 0.00657696f, -0.06000715f, -0.00844063f, 
    -0.07166054f, -0.20194094f, -0.03635600f, 0.01894204f, -0.08268920f, 0.00386106f, -0.04347465f, -0.08707108f, 
    -0.02306709f, 0.11298352f, -0.07508288f, -0.04497787f, -0.05771207f, 0.14980859f, -0.10633498f, 0.05866168f, 
    0.22032848f, 0.09867130f, 0.01749389f, -0.03624627f, -0.10252535f, -0.10189603f, -0.07226505f, 0.07923819f, 
    0.07105234f, 0.07653660f, 0.09712806f, -0.04363213f, -0.04050976f, 0.02029467f, -0.03494422f, 0.07468358f, 
    0.05432641f, -0.14515901f, -0.07249179f, 0.05865350f, 0.25687596f, -0.07432553f, 0.08429725f, -0.03726876f, 
    0.04544680f, 0.04598459f, -0.00446232f, -0.03225075f, -0.04635359f, -0.12529075f, -0.01097721f, -0.00026334f, 
    0.00420244f, -0.00800451f, 0.06754006f, -0.05471473f, -0.29760265f, 0.17097032f, -0.20249574f, 0.10626055f, 
    0.34380445f, 0.12316004f, -0.01602228f, 0.07388499f, -0.03642276f, 0.10072210f, 0.05328145f, 0.03577127f, 
    -0.11134586f, -0.16173299f, -0.05292500f, 0.11000503f, -0.00089428f, 0.16056746f, 0.00364928f, -0.07457557f, 
    -0.29000992f, -0.41096890f, -0.20453046f, 0.14138995f, -0.43646085f, 0.14823346f, -0.05164220f, 0.08742422f, 
    -0.00603143f, 0.02252225f, -0.05387897f, 0.01161067f, -0.02825167f, -0.05391633f, -0.02940827f, 0.04651198f, 
    0.03383333f, -0.11163607f, -0.07109449f, 0.06349791f, -0.03999960f, 0.06457686f, -0.16696374f, 0.01953461f, 
    0.26773474f, 0.10238056f, 0.05752530f, -0.05110549f, -0.03918175f, -0.00716211f, -0.03338764f, 0.12110570f, 
    0.03328941f, 0.10156340f, 0.13126586f, -0.02825825f, 0.05863642f, 0.02449049f, 0.04310974f, 0.02577144f, 
    -0.45715523f, 0.44663471f, -0.24520887f, -0.20996808f, -0.19858289f, 0.18660371f, 0.08187145f, 0.18395856f, 
    -0.01467683f, 0.01940558f, -0.07215505f, -0.12772155f, 0.06421268f, -0.06961235f, -0.06869666f, -0.06770392f, 
    -0.03099405f, -0.02774384f, 0.11448053f, 0.00288281f, -0.36879736f, -0.20472859f, 0.05555408f, 0.15735251f, 
    0.24281977f, -0.17569660f, 0.01335405f, -0.17825142f, -0.04227665f, -0.08160325f, -0.05116757f, 0.05610940f, 
    -0.01823570f, -0.05601929f, -0.02182379f, -0.03241536f, 0.02385419f, -0.01761756f, -0.01664665f, -0.05022460f, 
    -0.27116537f, -0.10624489f, -0.10890464f, -0.00952578f, 0.14054888f, 0.06714810f, 0.10943103f, 0.11065633f, 
    -0.00543018f, 0.04135942f, 0.06801312f, -0.08463234f, -0.02936621f, 0.03022455f, -0.11473813f, 0.05705450f, 
    -0.08668312f, 0.08348647f, 0.00237317f, 0.05615167f, -0.31951526f, 0.03087549f, -0.14045060f, -0.08961191f, 
    -0.05246609f, 0.00891814f, 0.09635442f, 0.09317558f, 0.05782561f, 0.07189096f, -0.08130720f, -0.03928335f, 
    -0.28203610f, -0.01752104f, 0.01318592f, -0.20753260f, -0.29326117f, 0.01528908f, -0.05208538f, -0.13747053f, 
    0.58621359f, 0.41144127f, -0.13778661f, 0.03983965f, -0.18341817f, 0.09245259f, 0.04755456f, -0.00674556f, 
    -0.14406094f, -0.08955289f, -0.14023916f, -0.14010139f, -0.05041333f, 0.01108291f, -0.09499010f, -0.02943546f, 
    -0.04131920f, 0.11173041f, 0.08202578f, 0.11220036f, -0.19320253f, -0.09072015f, -0.32349351f, 0.14231686f, 
    0.05983136f, 0.11278945f, 0.05039866f, 0.19787906f, 0.08901684f, 0.08161307f, -0.07172623f, 0.06024036f, 
    0.06911541f, 0.01752811f, -0.15306075f, 0.14572746f, 0.02629660f, 0.06248528f, 0.01059528f, -0.00175940f, 
    0.06716231f, 0.03828570f, 0.05028430f, -0.18660022f, 0.08415093f, -0.03844012f, -0.02704702f, 0.05429050f, 
    0.03288432f, -0.01971811f, 0.06225584f, -0.05078102f, -0.03024533f, 0.04577478f, 0.08623192f, -0.05350627f, 
    -0.07428942f, 0.04047562f, -0.18063724f, -0.03107081f, 0.03003536f, -0.04800324f, -0.11719343f, 0.00734924f, 
    0.19144237f, -0.03175331f, 0.11112501f, 0.08599009f, 0.01462809f, 0.10556583f, -0.05304541f, -0.03721992f, 
    -0.05781342f, -0.09029993f, 0.00738534f, 0.06803127f, -0.02065337f, 0.05075936f, -0.01950891f, -0.01604615f, 
    0.54313391f, 0.67174923f, -0.07937351f, -0.43398768f, -0.27000880f, -0.08204133f, -0.08259244f, -0.12763907f, 
    -0.19568573f, 0.02058154f, -0.20339766f, -0.14490436f, -0.02023522f, 0.06539206f, 0.06445049f, -0.09149703f, 
    0.08040797f, -0.09614130f, -0.03856941f, 0.03373090f, -0.09071876f, -0.12979646f, -0.12795454f, -0.12830511f, 
    0.14575431f, 0.03301044f, -0.03142384f, 0.03077842f, 0.05199982f, -0.11775270f, -0.00792713f, 0.00599955f, 
    -0.03770296f, 0.02128207f, -0.08442451f, 0.05521911f, -0.02473563f, 0.12145250f, -0.04541908f, -0.09595720f, 
    0.04895593f, -0.12889397f, -0.01812557f, -0.12160943f, -0.61347246f, 0.20720947f, 0.00272182f, -0.14926824f, 
    0.05259395f, -0.12981161f, 0.06002882f, 0.04983230f, -0.02391815f, -0.09103689f, -0.07778808f, -0.07481990f, 
    -0.00131456f, -0.11728648f, -0.05491630f, -0.09675216f, -0.68426812f, 0.17659499f, 0.23640737f, 0.09386541f, 
    0.43595520f, -0.03233900f, -0.07871266f, -0.08264742f, -0.22885822f, -0.01871425f, -0.07889837f, -0.04592079f, 
    0.02050406f, 0.04567027f, 0.06089317f, 0.08977249f, 0.09463441f, 0.11500549f, -0.15895586f, -0.13856511f, 
    -0.31660926f, -0.04271050f, 0.55925137f, 0.08417717f, 0.25076458f, -0.04532794f, -0.05816216f, -0.09649258f, 
    -0.08415072f, -0.06877322f, 0.09304842f, -0.01001325f, -0.09613508f, -0.00293980f, 0.07228404f, -0.02701331f, 
    -0.04944244f, 0.08631095f, -0.08820812f, 0.02498508f, -0.32548803f, -0.08521590f, 0.08305952f, 0.17242861f, 
    -0.24575728f, -0.01373633f, 0.00439014f, 0.11937957f, 0.10275906f, 0.07256920f, -0.02669654f, 0.07386123f, 
    0.07418311f, -0.09558368f, 0.05527462f, 0.00186719f, 0.00097506f, 0.00292879f, 0.02214764f, -0.03059996f, 
    -0.48125404f, -0.13584974f, -0.00136734f, 0.07074285f, -0.05265017f, 0.05671297f, -0.02871229f, 0.05670540f, 
    -0.05783682f, 0.00826387f, -0.13199756f, 0.02768334f, -0.00985260f, 0.04301426f, -0.10914396f, 0.05475798f, 
    -0.02787349f, 0.08872415f, -0.07349002f, -0.12123462f, -0.03913710f, -0.07586434f, -0.22724035f, -0.04161904f, 
    0.15773329f, 0.07617199f, 0.00706789f, 0.01981019f, -0.02630974f, 0.08757364f, -0.04325603f, -0.01156394f, 
    -0.15115778f, -0.01289208f, -0.04148413f, -0.07585902f, -0.11598378f, 0.10154160f, 0.03548582f, -0.02837436f, 
    -0.13246137f, -0.26764956f, 0.34941271f, 0.03266852f, 0.13353530f, -0.24758434f, 0.01496870f, -0.03142530f, 
    0.07104994f, -0.10057369f, 0.08557003f, 0.02117873f, -0.00977735f, -0.01385053f, 0.06079011f, -0.10049015f, 
    -0.03171062f, -0.04241390f, 0.02220621f, -0.04581644f, 0.06738232f, -0.19373997f, 0.30867508f, -0.06418125f, 
    0.04913469f, -0.11149363f, 0.05314054f, 0.08991994f, 0.05066656f, -0.05731105f, 0.11273541f, 0.00319593f, 
    0.02366067f, 0.02342346f, 0.05584386f, -0.02289101f, 0.00450906f, -0.01057903f, -0.04962157f, -0.09766994f, 
    -0.02309385f, 0.00358513f, 0.09533986f, 0.05214227f, 0.08433465f, -0.08851545f, 0.06575264f, -0.04230505f, 
    -0.03809003f, 0.03685547f, 0.00210829f, -0.02025216f, -0.01609802f, 0.05488582f, -0.00816423f, 0.08289362f, 
    0.13155469f, -0.01580312f, -0.07250205f, 0.08797563f, -0.06686608f, -0.16468856f, 0.23022680f, 0.13871661f, 
    0.11594807f, -0.11306526f, 0.02897998f, -0.08596054f, -0.16541845f, -0.09664784f, 0.01414545f, -0.00107384f, 
    0.07686538f, 0.00488902f, -0.02505592f, 0.09397755f, 0.12619585f, 0.07263456f, -0.08686561f, -0.09578449f, 
    0.05151638f, 0.05490758f, 0.00601834f, 0.00758496f, 0.02896819f, 0.05944060f, 0.02925602f, 0.05165765f, 
    0.05235099f, 0.02876002f, 0.10296949f, 0.08630881f, 0.01464979f, -0.01979737f, 0.08924986f, -0.01547388f, 
    0.06564005f, -0.00424483f, -0.05942792f, 0.03605555f, 0.17972738f, -0.17326115f, -0.07481900f, -0.13216718f, 
    -0.03441827f, -0.00500453f, -0.10178790f, -0.10526110f, 0.13626015f, -0.08000021f, -0.06415703f, -0.07513752f, 
    0.05330895f, -0.19702840f, 0.14295574f, -0.02391568f, -0.11891536f, -0.00763997f, -0.09312243f, 0.04224658f, 
    -0.09451172f, -0.05713417f, 0.03297867f, -0.00839836f, 0.10743301f, -0.10416400f, -0.01398623f, -0.06347951f, 
    0.02971259f, 0.02776778f, -0.10706031f, -0.02624076f, -0.01550569f, 0.06733613f, 0.02753424f, -0.08062974f, 
    -0.07505330f, -0.12561892f, 0.05168151f, -0.11709319f, -0.35043171f, -0.15815480f, -0.02269873f, -0.19685143f, 
    -0.06385323f, 0.03326097f, 0.07878559f, -0.07222670f, 0.02762366f, 0.00068402f, -0.05333189f, -0.11858027f, 
    0.01743203f, 0.12845539f, 0.00200031f, -0.12124586f, 0.03093299f, -0.01402702f, -0.07613690f, 0.08511188f, 
    0.05180009f, 0.01204048f, 0.05297930f, 0.00914394f, 0.01266839f, 0.01342816f, 0.02253697f, 0.05047733f, 
    -0.07542913f, -0.05298450f, 0.23582183f, 0.07407387f, -0.11093366f, -0.05210325f, 0.04824451f, 0.07688609f, 
    0.00585435f, -0.04380420f, -0.00059075f, -0.00704240f, 0.00810772f, 0.03488439f, -0.04180340f, -0.01478363f, 
    -0.04306456f, 0.08837616f, 0.07431415f, 0.03606901f, -0.03313649f, 0.04272326f, 0.03729824f, 0.07514951f, 
    0.01730529f, -0.07280298f, 0.07348981f, 0.08257791f, -0.12300596f, -0.00004895f, -0.05754295f, -0.00049109f, 
    -0.17465606f, 0.01235500f, -0.01163828f, 0.16034278f, 0.01482077f, -0.07765164f, 0.02449629f, -0.04114422f, 
    0.03367955f, 0.10719582f, -0.06466867f, 0.01224966f, 0.03640307f, 0.03208449f, 0.04193760f, 0.02486434f, 
    -0.06771172f, -0.11533532f, -0.05581372f, -0.12437931f, 0.20371880f, -0.37318781f, -0.09854508f, -0.09756888f, 
    -0.37717563f, 0.04459022f, -0.03034609f, 0.01566291f, 0.06155121f, 0.08352657f, 0.01485676f, -0.06380038f, 
    -0.02972003f, -0.01774021f, -0.21010242f, -0.04402163f, 0.03346614f, 0.06551725f, -0.15398614f, 0.16470303f, 
    0.05885279f, 0.01481535f, 0.12680674f, 0.03999175f, 0.08083876f, -0.13547254f, -0.06684663f, -0.08882629f, 
    -0.02374437f, 0.00670288f, 0.13450420f, 0.02067475f, 0.01576220f, 0.00549750f, 0.01730891f, 0.02411757f, 
    0.00137823f, 0.02031640f, -0.01508634f, -0.01177412f, 0.10099668f, -0.30331808f, 0.30998781f, 0.14319162f, 
    -0.00545539f, -0.22278939f, -0.10358340f, -0.04608710f, -0.04873009f, 0.14255016f, -0.00369413f, 0.03146579f, 
    -0.04703407f, -0.06940895f, -0.01948631f, 0.02686290f, 0.05674861f, 0.05617949f, -0.02976656f, -0.00667126f, 
    0.01000916f, -0.00360812f, -0.04746291f, -0.01598606f, 0.01241754f, 0.05535083f, 0.05239341f, 0.11323132f, 
    -0.01862888f, -0.00690031f, 0.00876022f, -0.05973651f, 0.06403065f, -0.19112670f, -0.05092970f, 0.03988857f, 
    -0.04219277f, -0.03309840f, -0.11603152f, -0.00080208f, -0.24903601f, 0.08618962f, 0.02304908f, 0.14219177f, 
    0.11180744f, 0.05722720f, 0.11619755f, -0.03815432f, -0.08995559f, 0.00542925f, -0.04595991f, 0.01414542f, 
    -0.01612155f, 0.07989386f, 0.03289730f, -0.00706716f, 0.12263302f, 0.23822340f, -0.19280888f, 0.13481267f, 
    -0.22252926f, -0.14944287f, 0.15024117f, 0.01820902f, 0.12761690f, -0.02068497f, 0.10491887f, -0.00613697f, 
    -0.05582400f, 0.11338473f, -0.02758811f, 0.04220508f, -0.00775529f, -0.10717259f, -0.04108342f, -0.10024679f, 
    0.04117455f, -0.02095600f, -0.00031209f, 0.08727723f, 0.21787857f, 0.21531846f, 0.30291170f, 0.23130906f, 
    0.24436329f, -0.13809784f, -0.07629161f, 0.00889005f, 0.00833273f, 0.20682958f, 0.00942564f, 0.06658508f, 
    0.04638867f, 0.02302533f, 0.06059135f, 0.00921309f, -0.06053333f, -0.09855450f, -0.04635623f, -0.19861099f, 
    -0.41301933f, -0.25125366f, 0.01738317f, -0.33453166f, -0.08262656f, -0.02945764f, 0.06460630f, -0.09499905f, 
    0.07077102f, 0.03633745f, -0.15833215f, -0.07955468f, -0.04139683f, 0.08707656f, -0.06502655f, -0.11333013f, 
    0.04236330f, -0.01668810f, 0.02947333f, -0.06232876f, 0.05420727f, -0.35584182f, -0.14887491f, 0.09347077f, 
    0.01228809f, 0.01382310f, -0.06098167f, -0.12780766f, -0.05330499f, -0.05942252f, -0.00984236f, -0.06575912f, 
    0.12288760f, 0.11180516f, -0.06842369f, -0.03698002f, -0.13348071f, -0.05304253f, -0.13362463f, -0.00545318f, 
    -0.00063708f, 0.07257819f, 0.03572709f, 0.12059318f, 0.00925375f, -0.00974021f, -0.03674809f, -0.08968253f, 
    -0.07065978f, 0.03915205f, 0.06151828f, 0.05750463f, 0.04042384f, 0.01536389f, 0.01393768f, 0.03983769f, 
    -0.00461231f, 0.02784345f, -0.06894816f, -0.03673229f, -0.15258563f, -0.01276035f, -0.09203548f, 0.18360592f, 
    -0.06884988f, -0.05053683f, 0.01031207f, -0.15191928f, -0.11906610f, 0.07041737f, -0.00894176f, -0.05377485f, 
    -0.08911694f, 0.10324458f, 0.02602955f, -0.00348362f, -0.04208799f, -0.07676163f, -0.14904401f, -0.02498458f, 
    0.10864989f, 0.12878180f, -0.03640698f, -0.01646078f, -0.03016390f, 0.08390094f, 0.01647372f, 0.00890072f, 
    0.05269013f, 0.04337531f, 0.09011966f, 0.08512534f, -0.02063101f, -0.07072362f, 0.15333204f, 0.07556256f, 
    0.03177359f, -0.05368361f, -0.07188547f, 0.07879516f, 0.10218364f, -0.03649058f, -0.06115332f, -0.05377593f, 
    0.06166260f, 0.01259521f, 0.03078797f, 0.02963795f, 0.05151236f, -0.06892623f, -0.05506618f, -0.05428106f, 
    0.06342376f, -0.12086031f, 0.02597768f, -0.14654249f, -0.08360892f, -0.04430199f, -0.17361224f, -0.05191341f, 
    0.22405320f, -0.06065436f, 0.10442039f, -0.08202001f, 0.14822692f, 0.10983230f, 0.08632249f, 0.16526046f, 
    -0.04746675f, -0.06301828f, 0.05901324f, 0.07249185f, -0.01679480f, -0.05553929f, 0.06543929f, -0.01318469f, 
    -0.05126904f, -0.14414151f, -0.15071234f, -0.06372641f, 0.12463161f, -0.05753281f, -0.03197843f, -0.05786452f, 
    -0.20334469f, 0.03716776f, 0.00596535f, 0.02835375f, 0.05673952f, 0.02686408f, 0.05756126f, -0.06799742f, 
    -0.08442222f, -0.04703581f, -0.11311132f, -0.04544490f, -0.00929955f, 0.00717242f, 0.02294487f, 0.05690143f, 
    0.02862182f, 0.01784307f, -0.01222766f, 0.08954415f, 0.17055857f, -0.00755957f, 0.08674912f, 0.05230216f, 
    0.04655016f, 0.00808773f, 0.08491439f, 0.08049430f, -0.01847054f, 0.04801887f, 0.04482869f, 0.11620254f, 
    -0.05410355f, 0.05684892f, -0.04776112f, -0.04588760f, -0.07420383f, -0.30838111f, -0.21224374f, 0.17108282f, 
    -0.28623611f, -0.03808390f, -0.08429492f, 0.13924013f, -0.33595598f, -0.05717579f, -0.09376825f, 0.00561952f, 
    -0.03371193f, 0.00773705f, -0.17303072f, -0.04453858f, 0.12902831f, 0.06576283f, -0.07694870f, 0.23815402f, 
    -0.04212565f, -0.05997305f, -0.00323405f, -0.04585900f, 0.05741078f, 0.17626785f, -0.06146234f, -0.03269569f, 
    -0.01017094f, 0.01147534f, -0.03989248f, 0.01599651f, 0.02396507f, -0.05421586f, 0.02448786f, -0.12344600f, 
    -0.14881775f, -0.06649381f, -0.02910975f, -0.07301857f, 0.28715584f, 0.17959535f, 0.25970942f, 0.22170696f, 
    0.06502710f, -0.06602220f, -0.06489711f, -0.09928630f, -0.05538488f, 0.06051088f, -0.02956947f, 0.01918147f, 
    -0.01192637f, 0.08512331f, 0.05903124f, 0.04300639f, -0.02496814f, -0.06879522f, -0.01983562f, -0.09643232f, 
    -0.29395294f, -0.16146974f, 0.15789241f, -0.02881991f, -0.02917502f, -0.20586720f, -0.02553484f, -0.12805864f, 
    -0.00772268f, 0.10340396f, -0.06461213f, -0.05474361f, -0.04932210f, 0.08840642f, -0.00848293f, -0.02409811f, 
    0.00200407f, -0.02192582f, -0.02024646f, 0.01716132f, 0.04202385f, 0.04511753f, 0.22934188f, 0.09969882f, 
    0.08373947f, -0.22039375f, -0.08219237f, -0.17076084f, 0.17151691f, -0.03342404f, 0.04905007f, -0.00682253f, 
    0.04109124f, 0.04235415f, 0.04548472f, -0.00291861f, 0.01802702f, -0.09773051f, 0.06886773f, -0.06960774f, 
    0.04595077f, 0.25126806f, 0.15705751f, 0.20874669f, 0.25335777f, 0.15570737f, 0.20913075f, 0.07623319f, 
    0.10267238f, 0.21471487f, 0.05868962f, -0.01271154f, -0.01948389f, -0.04022817f, -0.02852471f, -0.04702777f, 
    -0.00750810f, -0.04759410f, 0.16181368f, -0.05048003f, -0.04387841f, 0.01063709f, -0.10083679f, -0.07158732f, 
    -0.05669491f, 0.07200179f, -0.00638332f, -0.00537376f, -0.01125176f, 0.01028989f, 0.05821847f, -0.02199262f, 
    -0.02830223f, -0.07422062f, 0.04851885f, -0.02349560f, -0.17391852f, 0.01467085f, -0.08114494f, -0.05826944f, 
    -0.03677784f, 0.03966828f, 0.03974645f, 0.25920624f, -0.02540319f, -0.10472678f, 0.08680545f, -0.02062485f, 
    -0.01656610f, 0.01068842f, -0.00478498f, -0.03515553f, -0.05293529f, 0.04622412f, 0.00755120f, 0.06456321f, 
    0.07658819f, -0.16748725f, 0.12159894f, 0.21784098f, 0.26141164f, -0.02029353f, 0.41284037f, -0.58619744f, 
    0.15275989f, 0.01213434f, 0.07597405f, 0.04438319f, 0.04649479f, -0.04430230f, 0.03186003f, -0.00919965f, 
    0.04191789f, 0.01352644f, -0.04756241f, -0.12079860f, -0.08064653f, -0.06591887f, -0.14441986f, 0.02977590f, 
    0.07962385f, 0.02584830f, 0.05605578f, 0.03229010f, 0.00495562f, -0.00038015f, -0.04267576f, -0.00031082f, 
    0.05379307f, 0.07773159f, 0.08272304f, 0.00472498f, -0.07945645f, -0.10657581f, -0.02832520f, 0.03553060f, 
    0.00654877f, 0.00874418f, 0.00031406f, -0.01138407f, -0.01294781f, 0.00573900f, -0.02163152f, 0.07991324f, 
    0.10310954f, 0.01141653f, 0.03225444f, 0.07315765f, -0.04869037f, 0.02629669f, 0.05522462f, 0.07874792f, 
    0.01510257f, -0.01699060f, 0.05748737f, 0.11384375f, -0.01590673f, 0.04568740f, -0.04145906f, 0.01818369f, 
    -0.06280643f, -0.19585103f, 0.20035024f, -0.10958888f, 0.06062776f, 0.00402270f, 0.10495595f, 0.03222499f, 
    -0.20507681f, -0.01228738f, -0.02512788f, -0.09577847f, 0.04174282f, -0.13535221f, -0.09406538f, -0.07328518f, 
    -0.04195795f, -0.05291074f, -0.01254980f, -0.10355203f, -0.04060913f, -0.18826780f, 0.00734249f, -0.09255654f, 
    -0.01119075f, -0.06979201f, 0.01526943f, 0.01304664f, 0.01218680f, -0.17439629f, -0.04391269f, -0.13848804f, 
    -0.10046562f, 0.04052879f, -0.02208162f, 0.04936031f, -0.00074960f, -0.04839357f, -0.01884772f, -0.04894950f, 
    0.03670507f, -0.18709238f, 0.10642154f, 0.28154451f, 0.02105033f, 0.00219279f, -0.13319078f, 0.06073177f, 
    -0.35560715f, -0.05246207f, -0.14835890f, -0.02968779f, 0.00275236f, 0.03023981f, -0.05093731f, 0.02197282f, 
    -0.04925117f, 0.02088114f, -0.04729572f, -0.13446787f, 0.19883041f, 0.04306359f, 0.15734509f, 0.21765140f, 
    0.16922387f, -0.02198157f, -0.04833541f, -0.13327816f, 0.05321719f, -0.04988386f, 0.08272979f, -0.00392127f, 
    0.02590294f, 0.02821014f, 0.01285248f, -0.02988711f, -0.02861635f, 0.01718326f, -0.00212226f, -0.04512390f, 
    0.01533376f, 0.01622661f, -0.10268910f, -0.26799843f, -0.03024963f, 0.07617786f, -0.01576381f, 0.02749706f, 
    0.03522184f, -0.01861141f, 0.01128814f, 0.02719043f, 0.00067906f, -0.07718876f, 0.03331691f, 0.12982047f, 
    0.07652816f, -0.03226121f, -0.08109870f, 0.05963388f, 0.09643787f, -0.05593508f, 0.23943184f, 0.09508465f, 
    0.06056703f, -0.19086093f, -0.03679800f, -0.14816029f, -0.00412388f, 0.00424081f, 0.00022014f, -0.02250872f, 
    -0.00474362f, 0.04406809f, -0.00313350f, -0.00134293f, 0.01953830f, 0.03137961f, 0.00157217f, -0.03084615f, 
    0.05751154f, 0.15177895f, 0.05183860f, 0.08898722f, 0.04902950f, 0.06663860f, 0.13992512f, -0.00810264f, 
    0.11629367f, 0.12065864f, 0.00249631f, -0.02607804f, -0.01866846f, 0.00664244f, -0.04209204f, -0.02622114f, 
    0.12981257f, 0.03470349f, 0.10267415f, 0.24526767f, 0.19054937f, -0.03298480f, 0.16104831f, -0.03028381f, 
    -0.01793215f, 0.05266542f, -0.06716082f, -0.01074022f, -0.01855906f, 0.04375675f, -0.00182447f, -0.00512959f, 
    -0.01347245f, 0.06352042f, 0.04855266f, 0.05423465f, 0.01157354f, -0.01321474f, -0.02928336f, -0.06079608f, 
    0.07380556f, 0.03881534f, -0.02667729f, 0.01219641f, 0.02556005f, 0.08330087f, 0.08813399f, -0.00786387f, 
    0.06219567f, 0.05150498f, 0.16149965f, 0.08156443f, 0.08204624f, 0.03423923f, 0.10508676f, 0.07285429f, 
    0.02166885f, -0.02432339f, -0.02973180f, 0.05950264f, -0.11404356f, -0.12773384f, 0.04019200f, 0.17368217f, 
    0.12212643f, -0.19201168f, 0.01500614f, -0.04806348f, -0.21318607f, -0.14202197f, -0.03125932f, -0.00228879f, 
    0.01946171f, 0.02050933f, -0.01923657f, 0.03298539f, 0.04052155f, 0.07864720f, 0.02460895f, 0.06531224f, 
    0.06792175f, -0.04473662f, 0.09113593f, -0.11839140f, -0.13936144f, 0.06124868f, 0.04483034f, 0.02351494f, 
    0.03741702f, 0.10739366f, -0.04040818f, 0.07254876f, -0.06701694f, -0.14425105f, -0.12012637f, -0.04704597f, 
    -0.04000982f, 0.09102824f, -0.08452014f, 0.08329511f, -0.07103952f, -0.02630470f, -0.01351274f, -0.09552199f, 
    0.04355276f, 0.02888042f, -0.05414615f, 0.00632339f, 0.00631491f, 0.00816443f, 0.07025951f, -0.00379963f, 
    0.04333306f, -0.02535230f, 0.01317114f, -0.08601766f, 0.02259024f, -0.00780723f, -0.05960398f, 0.04291581f, 
    0.08481088f, 0.06947819f, 0.10127572f, -0.08299463f, -0.06629784f, 0.12234855f, 0.01031513f, 0.02261170f, 
    0.02707970f, 0.15243751f, 0.06553402f, -0.02956490f, 0.12041350f, 0.03763375f, 0.05925312f, 0.00476228f, 
    -0.04388122f, -0.14306544f, -0.10982667f, -0.14750199f, 0.15652451f, 0.00395282f, 0.03819803f, -0.18490788f, 
    -0.11844624f, 0.05224056f, -0.08004751f, 0.06761025f, 0.07851360f, 0.00442338f, 0.00511870f, -0.06527379f, 
    0.03105633f, -0.05998581f, -0.06023365f, 0.12611902f, -0.26541728f, 0.08475255f, -0.18545492f, -0.24113697f, 
    0.57498640f, -0.93276292f, -0.34655580f, 0.09004495f, -0.32313535f, 0.06853329f, -0.21832635f, -0.00520599f, 
    0.03919156f, -0.12219884f, -0.01422351f, -0.10153484f, -0.01343407f, -0.10880364f, 0.14006500f, 0.05444827f, 
    -0.02628248f, 0.00880404f, -0.13302064f, -0.05583882f, 0.12495330f, 0.05195385f, 0.08144616f, -0.04420419f, 
    -0.02766426f, 0.09958243f, 0.01208262f, 0.01453065f, -0.00883397f, 0.04883873f, 0.14381179f, 0.03248475f, 
    0.06992475f, 0.04621455f, 0.03426833f, 0.05548894f, -0.02560969f, -0.00754368f, -0.08501427f, -0.06379906f, 
    -0.03686615f, 0.03124357f, 0.01864436f, 0.02699303f, 0.07337960f, -0.03661190f, -0.08287365f, 0.04268349f, 
    0.12911469f, 0.10550550f, -0.04907862f, 0.00224068f, -0.02414780f, -0.06639674f, 0.02265797f, -0.06299233f, 
    -0.09327800f, -0.02108672f, -0.01102439f, -0.23785914f, -0.04592688f, 0.02617340f, 0.07132507f, 0.13307521f, 
    0.11177279f, -0.06702037f, 0.06417868f, 0.01917582f, 0.05666615f, 0.08744342f, -0.01135922f, 0.00037425f, 
    -0.00869651f, 0.07725203f, 0.01148378f, 0.13064003f, 0.17008565f, -0.05678616f, 0.05409665f, 0.19243486f, 
    -0.03886772f, -0.74259484f, -0.08241286f, 0.02893951f, -0.24404936f, 0.18130210f, -0.04840780f, 0.08589845f, 
    -0.00797206f, 0.01775773f, 0.02088195f, -0.17768088f, -0.01498353f, -0.01431472f, -0.05174946f, -0.18778168f, 
    -0.19546671f, -0.01951078f, -0.20291021f, -0.12294434f, 0.06469065f, 0.03841791f, 0.06991631f, 0.03709802f, 
    0.01009640f, -0.02026555f, -0.04472985f, -0.08867666f, -0.00996155f, 0.02995653f, 0.15775706f, 0.05544601f, 
    -0.00938762f, -0.01376325f, 0.01751301f, 0.06825311f, -0.01341880f, -0.05089335f, -0.00259752f, -0.03220375f, 
    -0.07771282f, -0.02612705f, -0.01315944f, -0.09768962f, -0.15366308f, -0.00309443f, -0.00818178f, -0.02031239f, 
    0.07866546f, 0.04731846f, 0.02836101f, -0.06531470f, 0.09005286f, 0.06047036f, -0.09807521f, 0.00390813f, 
    -0.05901334f, -0.08745431f, -0.03564467f, 0.10176906f, 0.14390333f, -0.34595478f, 0.17779660f, -0.04979380f, 
    -0.09862536f, -0.02240920f, 0.02980787f, -0.05848872f, -0.04459481f, -0.40904251f, -0.03017594f, -0.12374624f, 
    -0.03988817f, 0.00623976f, -0.08072674f, -0.06437239f, -0.02052527f, -0.10208934f, -0.03146995f, -0.08662878f, 
    0.04886267f, 0.03178995f, -0.19497015f, -0.00872777f, 0.12012670f, -0.01504550f, -0.01664688f, 0.13032462f, 
    0.02493856f, 0.03308590f, 0.01776277f, 0.05730319f, 0.04092027f, -0.05866132f, -0.01945934f, 0.04379764f, 
    -0.08331908f, 0.10455869f, -0.04032478f, -0.00951000f, 0.11864664f, 0.04413497f, -0.21464702f, -0.28167683f, 
    0.02621363f, 0.04033472f, 0.04388169f, 0.02161541f, 0.07156665f, 0.06273027f, 0.06800339f, 0.04497387f, 
    -0.00792703f, 0.00600727f, -0.01663966f, 0.05935735f, 0.09440263f, 0.05404192f, 0.04058969f, 0.28218505f, 
    0.09608515f, 0.00788650f, 0.06337218f, -0.10559590f, -0.03884079f, 0.09573417f, -0.00126094f, 0.01751446f, 
    -0.01032137f, -0.06875087f, 0.05743339f, -0.01123170f, 0.00053760f, -0.01751761f, 0.04437765f, 0.05599108f, 
    -0.04119321f, -0.06594411f, -0.10493790f, -0.04093775f, 0.17095035f, 0.08822132f, 0.29091653f, -0.00477834f, 
    0.06866252f, -0.12129987f, -0.11094787f, -0.00996662f, 0.03633138f, 0.02441698f, 0.02994138f, 0.00162608f, 
    0.01528706f, 0.04281954f, 0.02654013f, -0.04040155f, -0.05015690f, -0.07821130f, -0.13785958f, -0.12063312f, 
    0.12977389f, 0.12419519f, -0.12287963f, 0.20215663f, 0.23442672f, -0.04300156f, 0.02487216f, 0.07833284f, 
    0.01784466f, 0.00988170f, 0.04338415f, -0.02444556f, 0.01862370f, -0.02214619f, -0.00128624f, -0.11207344f, 
    0.02556170f, 0.06763634f, -0.06946529f, -0.00878246f, -0.06543426f, 0.00621816f, -0.02624312f, 0.16813570f, 
    0.15430956f, -0.07244434f, 0.05981880f, -0.06393234f, -0.05451395f, 0.08354035f, 0.07345818f, 0.00486937f, 
    0.03932798f, -0.04539549f, 0.03484270f, -0.03080148f, -0.00339055f, -0.15337294f, -0.00545656f, -0.01110312f, 
    0.17055479f, 0.02530736f, 0.16999042f, 0.12244704f, -0.10121118f, 0.11220395f, -0.04466598f, -0.00057172f, 
    0.09418615f, 0.02402863f, 0.08503708f, 0.05878016f, 0.05950398f, 0.04116164f, -0.02886575f, -0.01672356f, 
    -0.03353985f, -0.18834093f, -0.05481416f, -0.13498364f, -0.21887413f, -0.05184515f, 0.12691313f, -0.19939949f, 
    -0.13026778f, 0.11146574f, -0.01496528f, -0.02833449f, -0.11747161f, -0.06918236f, -0.01157150f, 0.00115658f, 
    0.03677221f, -0.02717061f, 0.04650474f, 0.05427184f, -0.02312166f, -0.17140479f, -0.10865670f, -0.05069435f, 
    -0.10863294f, -0.10933167f, -0.08983339f, 0.08593305f, 0.03839032f, 0.00151034f, 0.05255394f, -0.02451719f, 
    -0.06896295f, 0.00304741f, -0.01125422f, -0.06615296f, 0.02129055f, 0.00986637f, -0.01528422f, 0.14403449f, 
    -0.02442378f, -0.09108400f, -0.00766133f, 0.03912945f, -0.37750080f, 0.56477612f, -0.35803553f, 0.12626648f, 
    -0.02913931f, 0.10967577f, -0.02750375f, -0.09691121f, 0.04739955f, 0.14051665f, 0.04931635f, -0.04842496f, 
    -0.08057293f, -0.01760936f, -0.22594184f, 0.04512927f, -0.02651976f, 0.06539130f, -0.03392955f, 0.10933574f, 
    0.13192849f, -0.13520755f, 0.17102525f, 0.02045514f, -0.10782769f, 0.20263588f, 0.01076383f, -0.00724257f, 
    0.06374433f, 0.02030054f, 0.01776192f, 0.00063673f, -0.03856580f, 0.05916580f, 0.10610737f, -0.03435593f, 
    0.00625874f, -0.04885727f, 0.11351478f, 0.33054203f, -0.06176528f, -0.09652802f, 0.13528171f, -0.51017940f, 
    -0.04204036f, -0.04407117f, 0.06051966f, -0.04827045f, 0.06047653f, -0.05076545f, 0.02629637f, 0.03147193f, 
    0.01979508f, -0.09058937f, 0.03186074f, -0.02727320f, -0.01451680f, -0.08094359f, 0.19368464f, -0.03562528f, 
    0.16322620f, 0.03748733f, 0.01273626f, -0.04516386f, -0.08594406f, 0.03540314f, 0.00603193f, 0.01938616f, 
    0.02996240f, 0.02078367f, 0.04898169f, -0.14452308f, 0.12348631f, -0.09781344f, -0.06640127f, -0.04675467f, 
    0.00163942f, -0.00111432f, 0.04915354f, -0.04755874f, -0.00474927f, -0.09158239f, -0.22601378f, 0.08783861f, 
    0.02811506f, 0.06735707f, -0.01110316f, -0.00221232f, -0.02036751f, -0.03026022f, -0.02739931f, -0.15642585f, 
    0.03608028f, 0.06238845f, -0.10141050f, 0.08160805f, -0.03253294f, 0.14897485f, 0.01055763f, 0.01826062f, 
    0.03874755f, -0.19118033f, 0.21043377f, -0.08407589f, -0.29723012f, 0.03022082f, 0.10771298f, 0.06208618f, 
    -0.05623695f, -0.01481767f, 0.09060736f, -0.00014502f, 0.00365492f, -0.02691521f, 0.10004958f, 0.01217669f, 
    0.08216392f, 0.01052528f, 0.01404561f, 0.10353881f, -0.40019691f, 0.59859979f, -0.21275420f, 0.01864911f, 
    0.04915303f, -0.04271811f, -0.00106181f, -0.03483038f, 0.04398184f, -0.11538293f, 0.04227088f, -0.04940119f, 
    -0.15803075f, 0.01394311f, 0.07438236f, -0.16286871f, -0.04809579f, 0.09609804f, 0.07510061f, -0.11497979f, 
    0.01379716f, -0.05339933f, -0.03108729f, -0.03342310f, -0.14666389f, -0.00373566f, -0.04174553f, -0.00138231f, 
    0.11508446f, 0.14926487f, -0.04865264f, -0.10160229f, 0.02457146f, -0.02471250f, -0.01487598f, -0.03734494f, 
    0.09483141f, 0.01012512f, 0.02196179f, -0.00517957f, -0.37882563f, -0.11858113f, -0.27252245f, -0.48743761f, 
    -0.24006909f, 0.03565301f, 0.05589056f, -0.05946314f, -0.07195511f, 0.00835526f, 0.01406015f, 0.16073577f, 
    -0.14736964f, -0.07368180f, 0.00614056f, -0.02397363f, -0.03498304f, 0.04660315f, 0.06136573f, 0.01269279f, 
    0.24571149f, 0.00440059f, -0.19526461f, 0.03926890f, 0.03366305f, 0.08701326f, -0.07700337f, 0.03003493f, 
    -0.04188133f, 0.01431764f, -0.09963844f, -0.01462675f, 0.09026785f, 0.01807996f, -0.16707584f, 0.08256171f, 
    0.03169413f, 0.02035481f, -0.05827873f, -0.03135741f, -0.01578657f, 0.34642515f, 0.02824937f, 0.07751527f, 
    -0.00509219f, -0.00427059f, -0.20527935f, 0.02801314f, -0.03194269f, -0.26448685f, 0.00788531f, -0.04334336f, 
    0.01721953f, 0.04293470f, 0.00768651f, -0.02976419f, -0.09896371f, -0.00562883f, -0.10534707f, -0.31895590f, 
    -0.26693898f, 0.24931037f, -0.26668066f, -0.31673622f, -0.20192541f, -0.14263360f, -0.14286070f, -0.00746569f, 
    -0.09413748f, -0.02909028f, -0.10192961f, -0.04303456f, -0.09513278f, -0.02306639f, -0.02632472f, -0.19528329f, 
    -0.23545553f, 0.02414437f, -0.10870441f, -0.21608244f, 0.05714868f, -0.07923506f, 0.30228144f, -0.11426381f, 
    -0.08858088f, 0.13563983f, 0.05521800f, -0.01258154f, 0.06270216f, -0.12956904f, 0.06024297f, 0.01076531f, 
    0.05228486f, -0.00374989f, 0.01465600f, 0.01895153f, 0.06880148f, -0.03955045f, 0.12292522f, 0.23957953f, 
    -0.05073908f, -0.11168198f, -0.19654536f, -0.22142407f, 0.12638804f, -0.08160732f, -0.03252009f, -0.02414119f, 
    -0.01618915f, -0.00415594f, 0.00458811f, 0.14962204f, 0.05906275f, -0.03591137f, 0.05418061f, -0.02000134f, 
    -0.01222876f, 0.12500572f, 0.01170652f, 0.08175014f, -0.25988308f, 0.24933267f, 0.03494513f, 0.23104978f, 
    -0.17879522f, 0.02852207f, -0.06306478f, -0.13673542f, 0.02232925f, 0.10171425f, 0.03632561f, 0.00188146f, 
    -0.10856967f, -0.06400690f, 0.17102814f, -0.02389596f, 0.05457855f, 0.07815135f, -0.16242567f, -0.10403886f, 
    -0.09956060f, 0.12620209f, 0.03026450f, -0.08053868f, -0.13144098f, 0.00191965f, -0.04513571f, 0.05359860f, 
    0.07282752f, 0.01759802f, 0.07272290f, -0.01591584f, -0.04726144f, -0.07936700f, -0.04433518f, -0.05001332f, 
    0.03676790f, 0.04871450f, 0.01019340f, 0.03780783f, -0.14564797f, -0.28676087f, 0.15198353f, -0.04169492f, 
    -0.18351565f, 0.06093892f, 0.03095507f, 0.02962712f, 0.15637240f, -0.01788863f, 0.05158569f, -0.01664327f, 
    -0.08953420f, -0.04727052f, 0.13004969f, -0.01628502f, 0.01924425f, -0.03991683f, -0.01628163f, 0.15477557f, 
    -0.15980263f, -0.12388918f, -0.20442244f, -0.00116508f, 0.12010842f, 0.03477210f, -0.01921817f, -0.00016783f, 
    -0.06858856f, -0.05301427f, 0.01850544f, -0.14071693f, 0.05318874f, 0.18424122f, 0.07040022f, 0.03521243f, 
    0.02803242f, 0.31374243f, 0.04021122f, -0.07928167f, 0.02825422f, 0.16542058f, -0.20492987f, 0.19787073f, 
    0.02739494f, -0.00721939f, -0.15273508f, -0.12321484f, 0.00096045f, 0.11176734f, -0.17935537f, 0.07485423f, 
    0.02391785f, -0.04602240f, -0.09312060f, 0.17619097f, -0.04281189f, 0.08437341f, 0.06972250f, 0.05256160f, 
    0.02831245f, -0.23124902f, -0.02684979f, -0.05517980f, 0.05469708f, 0.14772336f, 0.02380183f, 0.14041393f, 
    -0.06182735f, 0.01166794f, 0.03580541f, -0.05506107f, -0.09881127f, 0.01216015f, 0.02792328f, 0.01360849f, 
    -0.03282665f, -0.01854098f, 0.05628580f, 0.05595067f, 0.12530023f, 0.16821416f, -0.19359694f, -0.07426949f, 
    0.10057030f, -0.03005953f, 0.02821827f, -0.08661893f, -0.06012725f, -0.00055013f, 0.01488301f, -0.06724705f, 
    0.00132417f, 0.13542272f, 0.01412540f, -0.07597332f, 0.00573511f, 0.08153136f, 0.04826644f, -0.08168434f, 
    -0.11369694f, -0.20968658f, -0.14957532f, 0.08293822f, 0.14255200f, -0.00877546f, 0.07436050f, -0.00695627f, 
    0.02411997f, 0.05346586f, 0.06966336f, -0.13922255f, -0.04514353f, -0.04188438f, -0.00174259f, -0.22163115f, 
    0.03045790f, 0.06221548f, -0.04784949f, 0.11706501f, -0.31123981f, 0.22133216f, 0.21897888f, 0.15524518f, 
    -0.22128423f, -0.00354395f, 0.00279827f, 0.03706380f, 0.15639094f, -0.16642720f, -0.09934489f, -0.05697655f, 
    -0.05202672f, -0.09143034f, -0.01393030f, -0.04493813f, -0.03239371f, -0.03500104f, -0.05144658f, -0.20990871f, 
    0.07866398f, -0.26385206f, 0.04039253f, 0.15399155f, -0.09078967f, 0.13714746f, -0.03083922f, -0.04639984f, 
    0.12600733f, -0.07059845f, 0.02822098f, 0.05357400f, -0.03312173f, -0.06194910f, 0.07308546f, 0.00899142f, 
    0.06325751f, -0.05260769f, 0.02724576f, 0.09011447f, -0.19183381f, -0.04232918f, 0.16532101f, -0.15049452f, 
    -0.10254996f, 0.21571802f, 0.07537410f, 0.02316887f, -0.18588859f, -0.01078056f, 0.13088134f, 0.05506527f, 
    0.01849232f, 0.02130549f, 0.02273619f, 0.02688286f, 0.00702849f, -0.03750633f, 0.10724954f, 0.07381034f, 
    -0.30189833f, 0.06924114f, -0.17887263f, -0.25956520f, 0.03091229f, 0.06670488f, -0.06466302f, -0.02399453f, 
    -0.07007387f, -0.03577109f, -0.08609985f, 0.09561177f, 0.00896700f, 0.00022524f, 0.06248065f, -0.03899505f, 
    -0.05177984f, 0.06441610f, 0.00225952f, -0.00211009f, 0.07018851f, 0.05039221f, 0.16751140f, -0.06710359f, 
    -0.05261662f, 0.19387800f, 0.00289201f, 0.11935508f, 0.18045017f, 0.12140882f, 0.04139264f, -0.01149293f, 
    0.01917673f, 0.09315512f, 0.01959538f, 0.05062141f, 0.01756963f, 0.03585884f, 0.10697875f, 0.14348851f, 
    0.30294722f, 0.25552225f, 0.03710334f, 0.09425724f, 0.05216528f, -0.07807586f, -0.04951989f, 0.05009703f, 
    -0.19007581f, 0.03693768f, -0.00534543f, -0.01065265f, 0.01035749f, -0.00856994f, -0.01306501f, 0.05635557f, 
    0.02715455f, 0.12012400f, -0.00368925f, 0.06248736f, -0.11386511f, -0.20396878f, -0.26867393f, 0.11404917f, 
    0.03715180f, 0.09952044f, 0.00848390f, -0.01526835f, 0.01066732f, -0.01454191f, 0.02842262f, -0.03983285f, 
    0.04851522f, -0.01259547f, -0.09163105f, 0.04769234f, -0.04218010f, 0.12366936f, 0.04840235f, 0.08205049f, 
    0.10570803f, -0.08355721f, 0.35796893f, 0.20271476f, -0.40038225f, 0.09499509f, 0.09470996f, 0.05012030f, 
    0.02539618f, 0.15232055f, 0.04937768f, -0.01339949f, 0.00125273f, -0.00349877f, 0.04822101f, -0.06296009f, 
    0.03284771f, 0.04407918f, -0.04880057f, -0.05902582f, -0.15553744f, 0.08056740f, 0.12671085f, -0.28439069f, 
    0.20012887f, -0.09041191f, 0.16356266f, -0.06357875f, -0.05124932f, 0.17655073f, 0.09081464f, -0.00114231f, 
    -0.02609011f, -0.02719956f, 0.01763555f, -0.14710239f, -0.11255012f, -0.14415218f, 0.10836200f, 0.03578776f, 
    -0.10667847f, -0.04605902f, -0.15714079f, -0.05598270f, -0.04202532f, 0.05038815f, -0.02100032f, -0.10671251f, 
    -0.00345463f, -0.00365223f, 0.21745707f, 0.02287304f, 0.02584364f, -0.05822349f, 0.03576923f, 0.02178310f, 
    0.00603587f, 0.07590513f, 0.00913380f, 0.02329116f, 0.14777078f, -0.17759259f, -0.11602992f, 0.03106621f, 
    0.02381070f, 0.02776763f, 0.12798651f, 0.01584097f, -0.02045026f, 0.06492835f, 0.00328628f, -0.06627692f, 
    0.01722438f, -0.07781123f, 0.02512861f, -0.03111915f, -0.02290421f, -0.00528080f, -0.07121293f, 0.02991951f, 
    0.52457803f, -0.06012824f, -0.20830543f, -0.09399670f, 0.01314645f, -0.07906686f, 0.03542779f, -0.07085000f, 
    0.02937092f, 0.15249650f, 0.05327721f, -0.01654627f, -0.04336494f, 0.04693251f, 0.06221714f, 0.08081377f, 
    0.14953770f, -0.03685559f, -0.07782657f, 0.33130634f, -0.14991874f, -0.15650898f, -0.05385264f, -0.15215001f, 
    0.04765861f, 0.12444689f, -0.01845787f, -0.04024709f, 0.01624257f, -0.10536040f, -0.02083716f, 0.05793042f, 
    0.17032903f, -0.08726279f, -0.02910483f, -0.06572787f, -0.00036635f, 0.11814430f, -0.03166068f, -0.02411931f, 
    0.07611497f, -0.12132074f, 0.32695460f, -0.11117069f, -0.23027276f, -0.08173525f, -0.06880502f, -0.00852822f, 
    0.07115674f, -0.04879309f, 0.09422035f, -0.04430792f, -0.06095936f, 0.03687704f, 0.04572320f, 0.04800111f, 
    0.01994292f, -0.00882406f, 0.04023695f, 0.08075993f, -0.27322364f, 0.24098542f, -0.02522810f, 0.22316761f, 
    -0.07650939f, -0.07437468f, 0.05658066f, 0.14183299f, -0.05066336f, 0.21089770f, -0.04534853f, -0.05764334f, 
    -0.00246422f, -0.02942777f, -0.04310012f, -0.00670907f, 0.04556430f, 0.03455114f, 0.05816576f, 0.08153668f, 
    -0.03382171f, -0.17589842f, -0.09708707f, -0.00367376f, 0.14434554f, 0.03899661f, -0.01648175f, -0.08413456f, 
    0.01220451f, 0.02042758f, 0.06064199f, -0.03050846f, 0.03963370f, -0.02403373f, 0.05920137f, -0.08430795f, 
    0.02539509f, -0.11652146f, 0.08572739f, -0.04424153f, -0.14037280f, -0.13170628f, -0.23397607f, -0.11057583f, 
    -0.17823873f, 0.14642332f, 0.00567525f, -0.05191635f, 0.04489636f, 0.15711322f, 0.07280783f, -0.00952392f, 
    -0.00830232f, 0.06956650f, -0.03434434f, -0.06431421f, 0.00548343f, 0.02076025f, -0.02708009f, 0.02501673f, 
    0.24206527f, 0.18501182f, 0.14578609f, 0.09947547f, 0.02967051f, 0.01902171f, -0.06069459f, 0.07853346f, 
    0.03045661f, 0.02531104f, 0.08236603f, 0.05419727f, 0.06750368f, 0.01617705f, -0.00375169f, 0.03351425f, 
    -0.06469346f, -0.02317958f, -0.19155949f, -0.24856703f, 0.04553634f, -0.11362881f, -0.03940263f, -0.16779734f, 
    -0.10074839f, -0.05241770f, -0.04955232f, -0.14701034f, 0.13898157f, 0.20698400f, -0.02935852f, 0.14989556f, 
    -0.05242739f, 0.00871400f, -0.01350799f, 0.02873767f, 0.04302500f, -0.01451992f, -0.01355294f, 0.11938275f, 
    -0.05994512f, -0.01735757f, -0.05367402f, 0.06459039f, 0.03771195f, 0.06491646f, -0.00581501f, -0.09122902f, 
    -0.03505297f, 0.02769143f, -0.09488618f, -0.06396807f, 0.04497430f, 0.11377345f, -0.00569678f, 0.07149453f, 
    0.10796982f, 0.12566797f, -0.01724288f, -0.03177871f, -0.36416194f, 0.06513392f, -0.05394844f, -0.11689842f, 
    -0.26087523f, 0.03668311f, -0.06813984f, -0.10196296f, -0.02812055f, 0.12285252f, 0.03553493f, -0.03656052f, 
    -0.01487972f, 0.08421347f, -0.00949326f, -0.14047159f, -0.05110266f, 0.04183088f, 0.01029265f, -0.03400882f, 
    -0.14736372f, 0.13091189f, -0.27984670f, -0.18895046f, 0.03768907f, -0.00438853f, 0.00390494f, 0.07621496f, 
    -0.03754246f, -0.10508988f, 0.04358586f, -0.04182734f, -0.20698136f, 0.19081759f, 0.13029231f, -0.04019902f, 
    0.03381838f, 0.01774398f, 0.05292215f, -0.00303463f, 0.43910858f, -0.13220587f, -0.39857501f, -0.06794108f, 
    0.17670445f, 0.13931458f, 0.05478483f, -0.08042543f, -0.05816340f, 0.04192039f, 0.03436042f, 0.05405884f, 
    -0.00008162f, 0.04644564f, -0.02589462f, 0.05075780f, 0.04334004f, -0.02780096f, -0.02643576f, 0.00072672f, 
    0.12405568f, 0.05497832f, 0.06924219f, -0.21523021f, 0.08907063f, -0.11319657f, -0.03925870f, 0.06832567f, 
    -0.06748641f, -0.02835323f, -0.04477555f, -0.04689106f, 0.06473640f, -0.05989276f, -0.03352951f, 0.08544290f, 
    0.04665620f, -0.05301539f, 0.04633419f, 0.07254395f, 0.05419796f, -0.10672747f, -0.01570581f, 0.02355762f, 
    0.09852307f, -0.24577883f, -0.01674163f, -0.17108066f, -0.23613836f, 0.09954258f, 0.15703939f, 0.02531338f, 
    -0.02521641f, -0.14664152f, 0.09819957f, 0.06332130f, -0.11160491f, -0.03695974f, 0.08551206f, 0.33794487f, 
    -0.88310605f, 0.59843791f, 0.25842008f, -0.12425938f, -0.00168011f, -0.10322516f, -0.05195929f, -0.24484213f, 
    0.06820944f, 0.03272457f, 0.18431148f, -0.02292779f, 0.03515806f, -0.12530920f, -0.18017280f, -0.03338177f, 
    -0.13269590f, 0.06139139f, 0.15449351f, 0.08562823f, 0.11047284f, 0.06101071f, 0.07647115f, -0.11476562f, 
    -0.00427497f, 0.09368794f, -0.06392001f, 0.03101951f, -0.06243550f, -0.04362611f, 0.06924946f, -0.10293294f, 
    0.02919238f, -0.05719325f, -0.00158054f, 0.00902544f, 0.04895993f, -0.01241759f, 0.01207807f, -0.04216277f, 
    0.07114547f, -0.03176757f, 0.08505628f, 0.11013957f, -0.09310664f, 0.00040520f, 0.06726535f, 0.00012732f, 
    -0.01023251f, -0.07135822f, -0.04856764f, 0.00745584f, -0.03865635f, -0.01792777f, -0.02603626f, 0.07590830f, 
    0.04296967f, 0.01137568f, -0.01619426f, 0.12711047f, -0.02914650f, 0.01879206f, 0.22327073f, 0.16786540f, 
    -0.13609266f, -0.00070418f, -0.11159745f, 0.03920560f, 0.03031940f, -0.02908456f, 0.00954611f, 0.01821333f, 
    0.05224644f, 0.01628724f, 0.03385177f, 0.06409822f, 0.00258486f, -0.30337974f, -0.31549260f, -0.44634068f, 
    -0.35344300f, -0.07567130f, -0.06000794f, 0.32528517f, -0.23205449f, 0.08216086f, -0.20674212f, -0.08738500f, 
    0.10743462f, -0.13114358f, -0.11462539f, -0.01020512f, -0.06562793f, 0.06207862f, -0.08141386f, 0.11437019f, 
    0.01681200f, 0.06901585f, -0.02632536f, 0.18210894f, -0.04732424f, 0.00201615f, 0.00586257f, 0.02901041f, 
    -0.03806162f, 0.04450750f, 0.00666047f, -0.00647657f, -0.03658190f, 0.02686484f, 0.06095725f, -0.03890042f, 
    0.06691599f, -0.04035224f, -0.03694804f, 0.03320907f, 0.06536807f, -0.03887678f, 0.08341435f, 0.04966587f, 
    -0.06967824f, -0.16125832f, -0.02748874f, 0.12790060f, -0.03257569f, 0.12524611f, -0.18677434f, -0.11449446f, 
    -0.05210519f, 0.11815789f, -0.04626464f, -0.01543833f, -0.02968161f, 0.08600630f, -0.06285532f, -0.08349124f, 
    0.01238036f, 0.00868277f, -0.06133064f, 0.01682542f, -0.11494435f, -0.05910399f, -0.04824011f, -0.33492413f, 
    -0.07726192f, 0.04383765f, 0.02774744f, 0.01905370f, 0.09366694f, -0.01044707f, 0.01152813f, 0.02943167f, 
    -0.13148418f, -0.05060175f, -0.02811862f, 0.09754952f, -0.04836993f, 0.07224594f, 0.10451846f, 0.05509521f, 
    0.29175246f, -0.10485802f, -0.22257276f, 0.03909094f, 0.14805867f, -0.02768984f, 0.13824084f, 0.07355458f, 
    -0.09667474f, -0.00316999f, 0.04963915f, -0.05894946f, 0.06383806f, -0.01900280f, 0.00801162f, 0.09546052f, 
    -0.08415592f, -0.11103653f, -0.10188383f, -0.05889432f, -0.07191040f, 0.07580370f, -0.12060357f, -0.14775655f, 
    0.04630322f, 0.05489299f, 0.03195130f, -0.05253909f, -0.02011105f, -0.00278090f, 0.04368563f, 0.01578163f, 
    0.01493504f, 0.01149992f, -0.00839197f, -0.23510823f, 0.02615660f, -0.02784263f, 0.13308610f, -0.16085589f, 
    0.06851223f, -0.03646636f, -0.00992965f, -0.07091708f, -0.01253685f, -0.02283013f, 0.04325080f, 0.02334993f, 
    -0.07162320f, -0.03238975f, 0.01503199f, -0.11836178f, 0.11240496f, -0.09045050f, -0.07343987f, 0.04429904f, 
    0.00436017f, -0.03694328f, 0.13461176f, 0.03675647f, 0.01142873f, 0.10248221f, 0.24255101f, -0.08784808f, 
    -0.02749163f, 0.09421223f, 0.03444166f, -0.03628686f, -0.03343311f, 0.04681580f, 0.07485473f, 0.09838240f, 
    0.05268328f, -0.01854754f, 0.01280305f, 0.07274424f, 0.01821905f, -0.06034910f, 0.08758284f, 0.18958089f, 
    -0.09303796f, 0.08550584f, -0.20232332f, 0.05411638f, -0.01633368f, 0.14694789f, -0.07093877f, 0.04894017f, 
    0.03148806f, 0.07005964f, -0.03109901f, 0.02573075f, -0.02178898f, -0.07664115f, -0.00477763f, 0.01675986f, 
    -0.08330463f, 0.31853750f, -0.03160741f, -0.06534230f, -0.23511672f, -0.02663360f, -0.14848305f, 0.17483912f, 
    -0.04818355f, 0.08251978f, -0.16572684f, 0.03852462f, 0.05748050f, 0.10189384f, -0.05140948f, 0.02225321f, 
    -0.03306713f, -0.03413726f, 0.03475235f, -0.01696695f, 0.05354481f, 0.12134403f, -0.15145987f, 0.03441089f, 
    -0.37578130f, -0.34862766f, -0.54075444f, -0.19584666f, -0.01882633f, -0.14745477f, -0.00052942f, -0.05148590f, 
    -0.07477073f, -0.12385214f, 0.04960476f, -0.01020220f, -0.02775206f, 0.05174579f, 0.02778884f, -0.04708202f, 
    0.01656268f, 0.03088531f, 0.15691483f, 0.07506343f, -0.16779843f, -0.37659600f, -0.65187693f, -0.05510294f, 
    -0.07137531f, 0.02743036f, -0.19688235f, -0.13398494f, -0.09432537f, -0.07070179f, -0.05170144f, 0.04024496f, 
    0.01333569f, -0.06413115f, -0.20781872f, -0.07221831f, -0.03736227f, 0.11535875f, 0.04603169f, -0.05222782f, 
    -0.01384912f, 0.00767234f, 0.08752988f, -0.08397986f, 0.05222601f, -0.05377407f, -0.03411037f, 0.02075172f, 
    -0.01431754f, -0.02214703f, -0.00184564f, -0.06506545f, -0.10412620f, -0.04129755f, -0.00484977f, -0.05016251f, 
    -0.04644123f, -0.07840629f, -0.04343424f, 0.07090624f, -0.23342815f, 0.05847970f, 0.08827040f, -0.12161450f, 
    0.29731762f, -0.03790002f, 0.05217722f, 0.05784946f, -0.03670852f, 0.25336501f, -0.02036842f, 0.14791802f, 
    0.00069189f, 0.11970472f, 0.02842690f, -0.00423683f, 0.01771663f, -0.02965423f, -0.02535469f, 0.02145209f, 
    0.03485010f, -0.12004717f, -0.24354531f, 0.04822446f, 0.13984933f, 0.01581520f, 0.04555744f, -0.04571817f, 
    0.20301768f, -0.01665393f, -0.03950397f, -0.01090782f, -0.08952070f, 0.03252745f, 0.04037748f, -0.00763511f, 
    0.05237678f, 0.03864508f, 0.07181104f, -0.02426572f, -0.11298690f, 0.47381097f, -0.05206754f, -0.22417168f, 
    0.34323624f, -0.00144684f, 0.00163532f, -0.00552985f, 0.10756031f, -0.09234402f, 0.07988009f, 0.06818514f, 
    0.13564180f, 0.03220847f, -0.01330962f, 0.05605885f, 0.01081213f, -0.02148665f, 0.08261948f, 0.01367305f, 
    -0.13873105f, 0.06997982f, 0.05798180f, -0.01146703f, -0.01957501f, -0.05564805f, 0.02159419f, -0.07958250f, 
    -0.07175714f, 0.02761825f, -0.02862575f, -0.13930486f, 0.02574931f, 0.01058132f, 0.08908138f, 0.02222202f, 
    0.01997168f, -0.05294025f, 0.04775053f, -0.03345134f, 0.01047669f, -0.01960380f, 0.02651065f, 0.00079766f, 
    0.02908733f, -0.00983562f, -0.00190710f, 0.00256768f, -0.00299746f, 0.01087313f, -0.05652577f, -0.01128631f, 
    -0.03125571f, -0.04461322f, -0.05890065f, -0.00453325f, -0.03564791f, -0.04496186f, -0.05362805f, -0.01305698f, 
    -0.30886492f, -0.46092367f, -0.33637801f, -0.04939413f, 0.19824278f, -0.06294118f, 0.06784548f, -0.09103749f, 
    -0.13444106f, -0.21819168f, 0.01732751f, 0.00639328f, -0.01598948f, -0.02794372f, 0.02583823f, 0.04213237f, 
    0.02848805f, 0.04424161f, 0.14661200f, -0.01674349f, -0.06345762f, 0.01696304f, 0.07459786f, 0.05327326f, 
    0.00100875f, -0.00848693f, -0.05731490f, 0.00478747f, -0.02517214f, 0.04328598f, -0.08638074f, 0.00158996f, 
    0.07019559f, 0.10454916f, 0.08085370f, 0.00709581f, 0.11474888f, 0.02556791f, -0.01740559f, 0.00292083f, 
    -0.34476835f, 0.29065940f, 0.14191802f, -0.04025264f, -0.06676803f, -0.19844973f, 0.00956573f, -0.16426665f, 
    -0.04799015f, 0.15212388f, -0.10364757f, 0.04988088f, 0.08516011f, -0.04380272f, 0.02966200f, 0.01037232f, 
    -0.01557125f, -0.00553455f, 0.02456414f, -0.04174839f, -0.49628964f, 0.30441856f, 0.46416172f, 0.03513683f, 
    0.28881741f, -0.08800770f, -0.05128391f, -0.08054849f, -0.13938746f, 0.13899922f, -0.11269982f, 0.14232758f, 
    0.11867610f, 0.03348552f, -0.01890046f, -0.01537091f, 0.02463578f, -0.01056383f, 0.00171035f, 0.01440679f, 
    0.11178660f, 0.07611458f, 0.04003818f, -0.00567265f, -0.00916158f, -0.04039460f, -0.01714895f, -0.00127208f, 
    -0.01738592f, -0.01978321f, -0.01964092f, -0.00403745f, -0.01185501f, -0.08522389f, 0.04052834f, 0.00893013f, 
    -0.12628022f, -0.06001092f, -0.05572369f, -0.04263717f, -0.21278659f, -0.19538386f, -0.03613286f, 0.16370240f, 
    0.02354241f, -0.11620643f, 0.11457483f, -0.01144969f, 0.10136462f, -0.22881739f, 0.02211019f, 0.00174571f, 
    0.04305096f, 0.07922883f, 0.08361100f, -0.01054666f, 0.08594035f, 0.12011736f, 0.09448416f, -0.00464335f, 
    -0.12590317f, -0.30055556f, -0.13181050f, -0.19553858f, 0.45819587f, -0.01498509f, 0.04876521f, -0.04239120f, 
    0.03160106f, 0.09068491f, 0.00198899f, 0.08258118f, 0.11833313f, 0.09105930f, -0.14043255f, 0.00717936f, 
    0.02661808f, 0.07125763f, 0.12163576f, 0.02459941f, -0.57658440f, -0.47408050f, -0.27599907f, -0.30245352f, 
    -0.16819815f, -0.16654074f, -0.12339534f, -0.23791116f, -0.12069333f, -0.30477637f, -0.01019936f, 0.01854163f, 
    -0.05731989f, 0.02243876f, 0.00203060f, 0.01887508f, -0.01268148f, 0.08692277f, -0.00934888f, -0.07467645f, 
    -0.17305513f, 0.23572473f, -0.05147573f, 0.03320612f, 0.26103845f, -0.00196554f, -0.02427371f, -0.03426967f, 
    0.03355675f, -0.04942627f, 0.17930534f, 0.09005198f, 0.12199263f, 0.04198369f, -0.04655674f, 0.02754208f, 
    0.00595471f, -0.09501810f, 0.07345584f, 0.04584436f, -0.15514582f, 0.02906836f, 0.00150424f, 0.09272362f, 
    0.05300484f, -0.11565234f, -0.01973321f, -0.04960481f, -0.00378627f, 0.11576135f, 0.02191336f, -0.03773781f, 
    -0.01001879f, -0.08831752f, 0.12119510f, 0.00780429f, 0.05094169f, -0.10937268f, 0.01968373f, -0.12305741f, 
    -0.42684364f, 0.09438603f, 0.28325164f, -0.04553901f, -0.05375269f, -0.14248472f, -0.03965978f, -0.04104189f, 
    -0.10719672f, 0.05640025f, -0.12725252f, 0.06311428f, 0.02481166f, -0.02558697f, 0.07446233f, 0.00510298f, 
    -0.00968460f, 0.00641533f, -0.00520935f, -0.07453516f, -0.17610477f, -0.32309434f, -0.08053163f, -0.00103305f, 
    0.18752870f, 0.00825047f, 0.13576600f, -0.08233442f, 0.01110224f, -0.02308228f, 0.06929556f, 0.00170558f, 
    -0.04549160f, 0.01789208f, -0.00840088f, 0.01972583f, 0.02065242f, -0.05940020f, 0.14052671f, -0.01906195f, 
    -0.03048205f, 0.05294632f, -0.01763417f, -0.05124013f, 0.00765161f, 0.00174744f, -0.07708596f, -0.02919705f, 
    -0.06951388f, -0.00583241f, -0.05779108f, -0.05196693f, 0.00273048f, -0.07368767f, -0.01284174f, -0.03551414f, 
    -0.00638694f, -0.07238592f, -0.04761027f, 0.02417189f, 0.12895906f, 0.01783071f, -0.16405541f, -0.07574788f, 
    0.17331499f, -0.07337283f, -0.01811185f, -0.00136822f, 0.16771756f, 0.01739745f, 0.01803336f, 0.04316606f, 
    0.07820447f, -0.12546617f, -0.07628246f, 0.11068887f, 0.01193964f, -0.10187103f, 0.02382294f, 0.01816124f, 
    0.17774804f, 0.06027444f, -0.13275521f, -0.07893561f, 0.03604072f, 0.04706046f, 0.03344924f, 0.16548774f, 
    0.03453140f, 0.07346294f, 0.01803849f, 0.04563551f, -0.04352334f, -0.07903183f, 0.10349987f, -0.04731568f, 
    0.01560293f, 0.03959437f, -0.14441994f, 0.02705093f, -0.02063527f, 0.06344035f, 0.06016017f, 0.04358418f, 
    0.06913230f, 0.02638856f, -0.01485654f, -0.02515252f, -0.00274876f, 0.02440552f, -0.00535886f, 0.01795376f, 
    0.06206697f, -0.03828270f, 0.04650181f, 0.01955682f, 0.08005950f, -0.03542370f, -0.07397610f, -0.01930564f, 
    0.07989151f, -0.17094354f, -0.07994073f, 0.11516849f, 0.03357120f, -0.05303207f, 0.01507874f, 0.07185015f, 
    0.02077761f, -0.01959981f, 0.02210717f, 0.00545247f, -0.07864529f, -0.00241537f, -0.00213752f, 0.08487267f, 
    -0.03175997f, -0.06823597f, -0.06585534f, -0.00987139f, 0.08126112f, 0.12818842f, 0.00057635f, 0.06731326f, 
    0.13987948f, -0.03560602f, 0.03093074f, 0.02518243f, -0.03987035f, 0.13548715f, -0.06521069f, -0.02369867f, 
    0.06991142f, 0.00617877f, -0.01387806f, -0.05339855f, 0.05834925f, -0.06386705f, 0.07994249f, 0.01002018f, 
    0.00064459f, 0.04428422f, -0.17034793f, -0.07986092f, 0.10050078f, -0.07608735f, -0.02095900f, 0.03803323f, 
    0.05550196f, 0.09076763f, -0.11466132f, -0.04623951f, -0.08796539f, 0.08316945f, 0.04116942f, 0.00018830f, 
    -0.01250829f, -0.02361431f, -0.01327222f, 0.00353533f, -0.63556737f, -0.32919070f, 0.14135918f, 0.05247552f, 
    -0.34464076f, -0.19060794f, -0.07099233f, -0.17364827f, -0.11242945f, -0.10329772f, -0.00933687f, 0.04453290f, 
    0.00912976f, 0.01845843f, 0.03263691f, -0.03334983f, -0.01454588f, 0.12625575f, -0.06009598f, -0.06256966f, 
    -0.25660634f, 0.39775756f, 0.16548415f, 0.02792342f, 0.39631894f, -0.02987480f, -0.11624772f, -0.06720234f, 
    0.06775135f, 0.03399221f, 0.06403919f, 0.16294447f, 0.11274873f, 0.09994763f, 0.00986970f, -0.01692435f, 
    -0.00914232f, 0.01043956f, 0.03880563f, 0.04597478f, -0.37969539f, -0.59190029f, -0.49112555f, -0.27931395f, 
    -0.35045052f, -0.17016537f, -0.04832746f, -0.17537323f, -0.03755325f, -0.14917913f, -0.03291465f, 0.01508284f, 
    0.00998624f, 0.07157806f, 0.00939598f, -0.03584115f, 0.01121794f, 0.03694163f, 0.06639013f, 0.04203837f, 
    0.03134309f, -0.58109438f, -0.81293559f, -0.26762354f, 0.12113016f, -0.10013517f, 0.00025575f, 0.20660488f, 
    0.07759732f, -0.59948862f, 0.07080270f, 0.00509670f, -0.03735090f, -0.06121512f, 0.02316274f, -0.02800308f, 
    0.01664294f, 0.12506388f, 0.01299995f, -0.07911806f, 0.00322801f, 0.05499137f, 0.04085830f, -0.02920870f, 
    0.07137448f, -0.00683094f, 0.01228623f, 0.06865416f, -0.01272675f, 0.08726590f, 0.07302404f, -0.01021852f, 
    -0.07020690f, -0.09243184f, -0.02764089f, -0.06623982f, -0.00391211f, -0.08072217f, -0.03636744f, 0.03629574f, 
    -0.56617337f, -0.78735119f, -0.64748240f, -0.22472751f, 0.31590667f, -0.07148625f, 0.13432674f, -0.04667532f, 
    -0.20850515f, -0.27453375f, -0.05706586f, -0.02738264f, 0.02234834f, 0.06575723f, 0.05186093f, 0.01241038f, 
    0.05376030f, -0.02668026f, 0.25907689f, 0.12622939f, -0.09776579f, -0.38263121f, -0.01851290f, -0.05878245f, 
    -0.24732696f, 0.00174286f, 0.12210558f, 0.12161394f, 0.13985913f, -0.16373244f, 0.05626146f, 0.00313246f, 
    -0.03630855f, 0.05392924f, 0.08000210f, 0.05949207f, 0.04425276f, 0.11179013f, -0.15869094f, 0.06117989f, 
    -0.19113539f, 0.00395652f, 0.21233891f, 0.00502341f, 0.03300960f, -0.05730874f, -0.02768693f, -0.04307950f, 
    -0.04834918f, 0.02084286f, 0.01926068f, -0.02415688f, -0.04248906f, 0.07529540f, 0.04071175f, 0.00786613f, 
    -0.02787556f, -0.04770157f, -0.03494407f, 0.03996238f, 0.13095595f, 0.04475387f, -0.07569521f, -0.07636306f, 
    0.03085199f, -0.03146060f, -0.04980926f, 0.04433795f, 0.03977140f, 0.03718875f, -0.02431016f, -0.01646150f, 
    -0.09222467f, -0.08771355f, 0.00470926f, 0.04858179f, -0.11348514f, -0.14035375f, -0.02377069f, 0.01600537f, 
    0.35982677f, 0.27443016f, -0.36410579f, -0.11635139f, 0.06505462f, -0.06522318f, -0.00767345f, -0.00787360f, 
    0.13894439f, 0.00403126f, 0.10246106f, 0.09527028f, -0.14515831f, -0.00818522f, 0.04490933f, -0.00701736f, 
    0.02733838f, -0.00999370f, -0.07552137f, -0.04334411f, -0.08837045f, 0.26158160f, 0.07137039f, -0.00760129f, 
    0.07385869f, 0.01189088f, 0.07405579f, 0.03663098f, -0.03062385f, 0.06529599f, 0.10746372f, 0.01447598f, 
    0.09043915f, 0.00852772f, -0.02857060f, 0.05893765f, -0.00790662f, -0.00593814f, 0.00773812f, -0.00452089f, 
    -0.55353040f, -0.64827412f, -0.59717685f, 0.10977498f, 0.03919531f, 0.06440096f, 0.14949842f, -0.06814058f, 
    -0.07505018f, -0.08903112f, 0.06674111f, -0.04906493f, 0.00506216f, -0.00605086f, 0.02514425f, 0.03856341f, 
    0.02537505f, 0.03579744f, 0.14067103f, 0.11340138f, -0.52549499f, -0.15083952f, -0.13450176f, -0.16799197f, 
    0.06548885f, -0.28558365f, -0.06284080f, 0.02780950f, -0.04058998f, 0.06591257f, 0.00441201f, 0.01853544f, 
    0.11002899f, -0.04476905f, 0.05652470f, 0.02477302f, -0.01259750f, -0.04257281f, 0.06953444f, -0.03678513f, 
    0.10343857f, 0.11266211f, 0.00198758f, -0.07858162f, 0.00105993f, 0.02164942f, -0.04221269f, 0.05056273f, 
    0.02731600f, 0.01317405f, -0.00130168f, 0.01113465f, 0.05728978f, -0.09284274f, -0.06402713f, -0.02917475f, 
    0.10488544f, -0.14587358f, 0.00826137f, 0.07298278f, -0.53530741f, 0.39792866f, 0.18369156f, -0.17830426f, 
    0.25452039f, -0.30190906f, -0.02089989f, -0.09755001f, -0.05762735f, 0.13725023f, 0.03543666f, 0.03514416f, 
    0.03725372f, 0.05305731f, 0.02078797f, -0.00843222f, -0.01409240f, -0.00062618f, 0.04933337f, -0.01353162f, 
    -0.41734856f, -0.42657661f, -0.53791738f, -0.07414462f, -0.05720028f, -0.16093919f, 0.12709430f, -0.03032332f, 
    0.10226891f, -0.34795573f, 0.00179032f, -0.02998852f, 0.03054271f, 0.02619355f, 0.07068203f, 0.00369671f, 
    0.04040090f, 0.13156736f, 0.14731702f, 0.04589315f, -0.21453735f, 0.30271173f, -0.01976789f, -0.02241067f, 
    0.02246761f, -0.03238034f, -0.05945304f, -0.15639049f, 0.02087407f, -0.03296160f, -0.02736169f, -0.00526408f, 
    -0.03070385f, 0.07490862f, 0.03653416f, 0.06030656f, -0.07488168f, 0.02781043f, -0.09093279f, -0.00594385f, 
    0.03257580f, -0.02299716f, -0.08031914f, -0.04010767f, -0.02896550f, -0.01831101f, -0.06084283f, -0.04118716f, 
    0.00126981f, 0.02611216f, -0.13341747f, -0.08181094f, -0.19854873f, -0.18735835f, -0.14600573f, -0.10295330f, 
    -0.07009207f, -0.06347033f, 0.01090670f, 0.02389158f, -0.40448150f, -0.61821240f, -0.38372156f, -0.33734998f, 
    0.14543647f, -0.05494189f, -0.09176376f, -0.05162997f, -0.26851258f, -0.00487491f, -0.04175823f, 0.04107420f, 
    -0.01648514f, 0.03019080f, -0.10931534f, -0.04213169f, -0.03304055f, -0.08199808f, 0.09259737f, 0.01760552f, 
    0.03978373f, 0.08113053f, 0.05512174f, -0.01676373f, -0.00832536f, 0.04963467f, 0.02615450f, -0.05285028f, 
    -0.05977406f, 0.03672599f, -0.07916471f, -0.01855707f, 0.04612902f, 0.09322722f, -0.06423183f, 0.04089668f, 
    0.08882129f, 0.00179576f, -0.00244940f, -0.00126799f, 0.27022278f, -0.01806243f, -0.07725750f, -0.09645066f, 
    0.03219583f, 0.07650805f, -0.01113878f, 0.09301665f, 0.05629989f, -0.00669498f, 0.05949242f, 0.00031606f, 
    -0.00338039f, -0.09736244f, 0.00238494f, 0.00729757f, 0.02591384f, -0.13619785f, 0.00496292f, 0.07751595f, 
    0.01713302f, -0.02531157f, 0.04530782f, 0.03697240f, -0.00052785f, 0.03291815f, -0.07486155f, -0.08875225f, 
    -0.05590999f, -0.18238868f, 0.03755477f, -0.16011116f, -0.08753561f, -0.01283425f, 0.03511615f, -0.00559029f, 
    -0.01883376f, 0.08400235f, -0.15495849f, -0.09440060f, -0.07768864f, -0.00823160f, -0.05426012f, -0.02022242f, 
    -0.02233939f, 0.16940759f, -0.03436066f, -0.04715109f, 0.12128198f, -0.19350690f, 0.11106456f, 0.04173577f, 
    -0.05367007f, 0.17185366f, -0.06445830f, -0.11916503f, -0.10868555f, 0.02938504f, -0.05259842f, 0.13970385f, 
    -0.28475690f, -0.08693831f, 0.15076022f, 0.15304467f, 0.05321382f, 0.00299648f, -0.02459190f, 0.00269616f, 
    0.01288912f, 0.20049843f, 0.16472866f, 0.01903985f, -0.00144028f, -0.18009830f, -0.08583862f, 0.03037126f, 
    0.07977397f, 0.00969059f, -0.02395263f, 0.06255104f, -0.09212528f, -0.02796050f, 0.11514059f, 0.03866421f, 
    0.00784041f, 0.00587982f, -0.01559919f, -0.04039909f, -0.12538947f, -0.09436034f, -0.12893014f, -0.14979300f, 
    -0.06275453f, 0.01873285f, 0.01030527f, -0.02472160f, -0.02976684f, 0.04184889f, -0.09200946f, -0.10396002f, 
    -0.01752559f, -0.07640384f, -0.32633215f, -0.04871384f, 0.20625576f, -0.01535374f, 0.03957744f, 0.03957522f, 
    0.08336388f, -0.00538825f, -0.01828255f, -0.05718562f, -0.06431350f, 0.00470187f, 0.04319678f, -0.01264137f, 
    0.04538687f, 0.01407869f, 0.11854988f, -0.04544107f, -0.14841384f, -0.24587171f, -0.39315629f, -0.24865401f, 
    0.02479549f, -0.16720143f, -0.02994233f, -0.09743872f, -0.05249482f, -0.18310215f, -0.03099281f, -0.02160329f, 
    -0.02720867f, 0.05407622f, 0.06845779f, -0.02404151f, -0.01493724f, 0.03275936f, 0.14612606f, 0.09707847f, 
    -0.16141817f, -0.11274762f, 0.14846903f, -0.10608553f, 0.19328040f, -0.03457981f, 0.08824550f, 0.09482229f, 
    -0.10184748f, 0.13935268f, 0.00557691f, 0.01434301f, -0.02066422f, 0.06116130f, -0.04094055f, -0.07899571f, 
    0.07983408f, -0.07694516f, 0.14697579f, 0.07760914f, -0.12945291f, 0.14210373f, 0.11540348f, 0.02542533f, 
    0.00697357f, -0.07693517f, 0.00478532f, -0.05095822f, -0.07657935f, 0.05430005f, -0.01503034f, -0.06020511f, 
    0.05668704f, 0.00398252f, 0.05143244f, 0.01657629f, 0.01652051f, -0.06689383f, 0.02955608f, -0.02670589f, 
    0.04891811f, 0.19471860f, -0.11659043f, 0.07178548f, 0.03571263f, -0.05463860f, 0.04328144f, -0.04439102f, 
    -0.05473569f, 0.14973901f, -0.07801618f, 0.05563291f, 0.13223511f, -0.04005568f, 0.00654060f, -0.17619066f, 
    0.04599467f, -0.15447299f, 0.08463351f, 0.05143822f, -0.26209062f, 0.50050849f, 0.02332600f, -0.05647520f, 
    0.17761511f, 0.05407806f, 0.07040724f, -0.07066863f, 0.10816896f, 0.00307910f, 0.06023718f, 0.04866690f, 
    0.02612460f, -0.02017536f, 0.14117320f, 0.07818887f, 0.02817441f, 0.10204487f, -0.03038242f, 0.03248081f, 
    0.17865841f, -0.11291268f, -0.09929220f, -0.08520809f, 0.00675513f, -0.00822075f, 0.03314745f, 0.11292604f, 
    0.02611672f, -0.10699882f, 0.00694719f, 0.01478393f, -0.04664977f, -0.01152166f, 0.02578126f, -0.02938436f, 
    -0.03698622f, 0.07269604f, -0.04939613f, 0.02746374f, -0.20536442f, -0.18358536f, -0.03479329f, -0.07048539f, 
    -0.21264687f, -0.01885346f, 0.04442472f, -0.00372870f, -0.02561653f, -0.00959998f, -0.00319461f, -0.03232816f, 
    0.00799094f, 0.03831695f, -0.01697682f, 0.14054985f, 0.09722967f, -0.02865644f, -0.03957159f, 0.00355751f, 
    0.00545528f, 0.02634175f, 0.05572680f, 0.05171442f, 0.01449009f, 0.04042790f, 0.02329900f, 0.04721466f, 
    -0.03594664f, 0.01577693f, 0.00628064f, -0.05053372f, 0.01995979f, 0.01302210f, 0.02257173f, -0.02931697f, 
    -0.04405830f, 0.04356484f, -0.08172824f, -0.09763434f, -0.48511899f, 0.00541109f, -0.06832375f, -0.05796542f, 
    -0.10209510f, -0.00819479f, -0.04405145f, -0.15256402f, -0.05195820f, -0.21583092f, 0.00043459f, 0.01033550f, 
    -0.00198161f, 0.04766510f, 0.00344931f, 0.00267583f, -0.01787655f, 0.12823404f, -0.09210013f, 0.01397011f, 
    0.19526894f, -0.27884150f, -0.43502876f, -0.22885801f, 0.07250073f, -0.05932564f, 0.08381040f, 0.21799284f, 
    0.03549236f, -0.01538270f, -0.00497252f, -0.01386332f, -0.02236664f, -0.08850195f, -0.00397352f, -0.01221065f, 
    0.00806528f, -0.02815461f, 0.14753927f, 0.05328027f, 0.14936824f, -0.26254299f, -0.34107998f, -0.19311380f, 
    0.17840801f, -0.09537513f, 0.12445203f, 0.19666898f, 0.10209121f, 0.01619900f, -0.04386360f, -0.03236702f, 
    -0.05566192f, -0.08100269f, 0.04518757f, 0.00229132f, 0.00847875f, -0.07637729f, 0.10311377f, -0.00254880f, 
    -0.30665857f, -0.27406293f, -0.12765411f, 0.12973690f, 0.05891488f, 0.07761487f, 0.01271383f, 0.01008046f, 
    0.03145112f, 0.02469720f, -0.02781357f, 0.01142828f, -0.03970527f, -0.07024448f, -0.09866595f, 0.03906328f, 
    0.10905935f, 0.01301653f, 0.07267492f, -0.03323626f, 0.21635398f, -0.35668871f, 0.02385167f, -0.50824398f, 
    -0.05195243f, -0.06734979f, 0.06695844f, -0.06603798f, 0.31636709f, 0.10827321f, -0.00666188f, 0.01600828f, 
    -0.05290087f, -0.07323982f, 0.02923767f, 0.00891962f, 0.00220871f, 0.05905018f, 0.08553340f, -0.02895858f, 
    0.01214454f, 0.08159723f, 0.03670806f, 0.02941622f, -0.05097445f, 0.00318521f, -0.01778199f, -0.00964117f, 
    -0.01125978f, -0.03690081f, 0.04473038f, -0.01814901f, 0.06032217f, 0.01456590f, 0.01253082f, -0.10329504f, 
    -0.08125940f, 0.05827696f, -0.00630286f, 0.04305800f, 0.46619919f, 0.33625725f, -0.10802031f, -0.01042952f, 
    -0.32279441f, -0.07362681f, -0.00785398f, -0.06395748f, -0.20860022f, -0.03912898f, 0.00615130f, -0.11548258f, 
    0.05956073f, 0.06332675f, -0.11265860f, 0.03198713f, -0.08081644f, 0.09845742f, -0.01941278f, -0.04332312f, 
    -0.04049702f, -0.17182378f, -0.10886390f, 0.10510895f, 0.00377751f, 0.01040473f, 0.02456419f, -0.09504971f, 
    -0.00642063f, -0.10638592f, 0.08617088f, -0.01419433f, -0.02910850f, 0.04451586f, -0.06919838f, 0.03300422f, 
    0.01544829f, 0.01295025f, -0.07906678f, -0.02800689f, -0.37275505f, -0.00263662f, -0.02931681f, 0.02888312f, 
    0.32654867f, 0.06832638f, 0.03766337f, 0.21773604f, -0.14034228f, 0.01976712f, -0.04989337f, 0.09925094f, 
    0.01475622f, 0.10038956f, 0.08597369f, 0.06985420f, -0.01064751f, 0.11932017f, -0.03401753f, 0.08088041f, 
    -0.01605385f, -0.01394220f, -0.04809887f, -0.05860293f, -0.02892767f, 0.07426725f, 0.04059704f, -0.01418614f, 
    0.00991973f, 0.03240076f, -0.03190633f, -0.03011577f, -0.18027522f, 0.08930513f, 0.08138349f, 0.01710365f, 
    0.02608342f, -0.00697414f, 0.02614412f, -0.00931350f, -0.01180464f, 0.08748925f, 0.00569381f, 0.01544443f, 
    -0.03475255f, -0.03741660f, 0.00933271f, 0.01048164f, -0.03797494f, -0.01377004f, -0.05877430f, -0.02903742f, 
    0.02645303f, -0.04903005f, -0.06530566f, -0.00975169f, -0.04439805f, 0.05429699f, 0.00753807f, 0.01330767f, 
    -0.39483288f, -0.36681241f, 0.00364445f, 0.32085472f, 0.05238578f, -0.01240191f, 0.03879250f, 0.01461789f, 
    -0.04772510f, -0.05306436f, 0.01704180f, 0.00494631f, 0.00229908f, 0.01368098f, -0.03585835f, 0.05960686f, 
    0.01481351f, -0.02099169f, 0.01341411f, -0.06304286f, 0.11764456f, 0.07397193f, 0.02148588f, -0.01032223f, 
    -0.15608606f, -0.02663679f, 0.06139943f, 0.01151641f, 0.02647440f, -0.01958455f, -0.08544060f, -0.05653554f, 
    -0.04937596f, -0.08146244f, -0.16934955f, -0.02186796f, -0.00082948f, -0.00672502f, 0.00011666f, 0.02653796f, 
    0.45383036f, -0.31566605f, -0.22917056f, -0.16369145f, -0.26719230f, 0.08246721f, -0.10326345f, 0.00499663f, 
    0.09040973f, 0.00021546f, 0.02316365f, 0.02563864f, 0.03219227f, 0.02094181f, 0.04768652f, -0.00673949f, 
    0.00511287f, 0.02642984f, 0.02171106f, -0.01207322f, 0.40444466f, -0.30182353f, -0.54430652f, -0.15314813f, 
    -0.15605484f, -0.04701172f, -0.01240411f, -0.10665672f, 0.17725246f, -0.13325410f, 0.02641740f, 0.08561555f, 
    -0.02696988f, -0.00936985f, 0.07310089f, -0.01182550f, 0.05328758f, -0.03341582f, 0.08788390f, 0.01763756f, 
    0.02380191f, 0.05720150f, -0.05772917f, 0.01826111f, -0.06746561f, -0.02125537f, -0.02834423f, -0.01510819f, 
    -0.04776382f, -0.00207656f, -0.04325833f, -0.02685351f, 0.12157221f, -0.00010139f, 0.04809150f, 0.04992335f, 
    -0.00709613f, 0.01453696f, -0.06614648f, 0.05637494f, -0.25056851f, -0.19257922f, 0.12195040f, -0.11162721f, 
    0.00968752f, 0.10115860f, -0.17486891f, 0.03273039f, -0.04672943f, -0.01475035f, 0.00190373f, -0.00652168f, 
    -0.05867921f, -0.10112512f, -0.11582678f, -0.00695630f, 0.09878984f, 0.12598737f, 0.03063863f, 0.02948751f, 
    0.29383972f, -0.56978375f, -0.54582047f, -0.29065996f, -0.39607027f, 0.03437041f, -0.04355432f, 0.05735160f, 
    0.18058161f, 0.08114404f, 0.04411880f, 0.03203696f, -0.03426348f, 0.14754575f, 0.08521030f, -0.15013121f, 
    -0.01309446f, -0.07834211f, 0.08387487f, 0.12524144f, 0.06164202f, -0.34099633f, 0.08524086f, -0.01174533f, 
    0.05192771f, -0.11034466f, 0.12942098f, 0.01801995f, 0.03444805f, 0.01920661f, 0.04372475f, 0.00894136f, 
    0.01747239f, -0.02559457f, -0.01541712f, 0.06700528f, 0.02719965f, -0.04651751f, 0.00883202f, 0.03033414f, 
    -0.25031561f, -0.09706312f, -0.10147954f, 0.02741539f, -0.01610015f, 0.02954929f, 0.02898482f, 0.16209812f, 
    -0.08003149f, 0.03453765f, -0.12216245f, 0.07519095f, -0.00718881f, 0.03155133f, -0.00515923f, -0.01177649f, 
    0.01829568f, -0.01173226f, 0.01351987f, 0.06882355f, 0.24317838f, 0.22231682f, -0.06841125f, 0.03456859f, 
    -0.18856530f, 0.11590660f, 0.07667302f, 0.06289801f, -0.04411905f, -0.00906819f, -0.11969095f, 0.01739028f, 
    -0.15471679f, -0.10158941f, 0.02085589f, -0.06448095f, -0.01240866f, 0.01228097f, -0.04372426f, -0.10779818f, 
    0.51714253f, -0.32966200f, -0.27906853f, -0.12905554f, -0.19700034f, 0.08071407f, -0.07285493f, -0.02492495f, 
    -0.06826196f, -0.01778889f, 0.02966031f, -0.00581800f, 0.03169414f, 0.03329762f, 0.04204287f, 0.03633478f, 
    0.01828054f, 0.02073509f, -0.00847921f, -0.00765688f, 0.03297008f, 0.04213995f, -0.22154434f, 0.14785786f, 
    -0.14220162f, 0.06232297f, 0.01611020f, 0.12431017f, 0.02396648f, -0.02002265f, -0.08587568f, 0.06977084f, 
    -0.00619909f, 0.00914038f, -0.09392314f, -0.00090101f, 0.00678449f, -0.00349814f, -0.04020389f, -0.02015918f, 
    0.03142320f, 0.04783830f, 0.01655162f, 0.04937239f, -0.09316857f, 0.01294918f, 0.01336372f, 0.00819671f, 
    -0.03523628f, -0.03077484f, 0.01133994f, -0.04157512f, -0.00647114f, -0.05901016f, 0.01095061f, 0.03558069f, 
    0.01249559f, 0.02158589f, -0.00450207f, 0.01542295f, 0.12444962f, 0.16365811f, -0.16640383f, -0.00967770f, 
    -0.14409751f, -0.02177345f, 0.04765819f, -0.01932911f, -0.10288505f, 0.03853519f, 0.04844218f, 0.00383035f, 
    -0.00309847f, -0.02255552f, 0.08896615f, -0.03837901f, -0.03543307f, 0.03585280f, -0.11301146f, 0.02342856f, 
    0.00013748f, -0.07160972f, 0.12292583f, -0.02477573f, 0.01992326f, 0.02078380f, 0.01185647f, -0.00081249f, 
    -0.06023418f, -0.04502652f, 0.06912548f, -0.03672286f, -0.01833079f, 0.00252263f, -0.04174723f, 0.04558518f, 
    -0.03237301f, -0.13732612f, 0.04648893f, -0.00042417f, 0.04652647f, 0.01469112f, 0.02772968f, 0.01982768f, 
    -0.04940366f, -0.01197196f, 0.03931760f, 0.01069873f, -0.02938821f, -0.00996316f, -0.03017062f, -0.07080962f, 
    -0.03499393f, -0.06802935f, -0.00533028f, -0.02917276f, -0.02886951f, -0.03532035f, -0.03888198f, 0.01362832f, 
    0.01261804f, 0.14726645f, 0.06739451f, -0.04496260f, -0.07005387f, -0.03066654f, -0.05560908f, -0.06349443f, 
    0.03147741f, 0.01137223f, 0.03905613f, 0.03991786f, 0.00376509f, 0.00559159f, -0.03626890f, -0.05577273f, 
    -0.17309268f, -0.15188639f, 0.02362296f, 0.02985234f, 0.20943020f, -0.35940075f, 0.16068064f, 0.02537627f, 
    -0.22644153f, -0.18819909f, -0.04081893f, -0.13370883f, 0.06732947f, 0.08885086f, -0.04250757f, 0.00118033f, 
    -0.04286776f, -0.11978023f, -0.14323553f, -0.11226703f, 0.05329489f, -0.15356290f, 0.05606560f, 0.11257567f, 
    0.02834736f, -0.02908523f, -0.06598216f, 0.02248336f, 0.00326074f, -0.03196984f, -0.01351138f, -0.00408998f, 
    0.02320637f, -0.04053598f, 0.02405653f, 0.01151907f, 0.02810410f, -0.03432991f, -0.08986206f, 0.01496856f, 
    -0.08077518f, 0.03430391f, -0.00991325f, 0.06294174f, 0.30723959f, -0.43620393f, 0.41273299f, -0.24894904f, 
    -0.06091475f, -0.19506806f, 0.23385815f, -0.01299267f, 0.17144620f, -0.01736172f, 0.02228187f, 0.00638515f, 
    -0.00435933f, -0.01230950f, 0.02404152f, -0.04726442f, -0.00489841f, -0.07011996f, 0.00689332f, -0.03338301f, 
    0.02099515f, -0.35047510f, -0.48872077f, -0.16822660f, -0.10754958f, 0.08864857f, 0.07938977f, 0.12036882f, 
    0.14501110f, 0.01038680f, -0.01595499f, 0.04558806f, 0.00552617f, 0.01705445f, 0.00426282f, -0.01221655f, 
    0.01326886f, -0.03672554f, 0.09075042f, 0.08532221f, 0.28983611f, -0.43838990f, -0.13867606f, -0.08417908f, 
    -0.06221071f, 0.01664299f, 0.07968359f, 0.08375666f, 0.05261710f, -0.02453971f, 0.03917281f, -0.03936305f, 
    -0.00736672f, -0.04474334f, -0.04467378f, -0.02970734f, -0.03469703f, -0.02325858f, -0.04653382f, 0.00367845f, 
    -0.80829060f, -0.13759363f, 0.07266136f, 0.08707649f, 0.06027427f, -0.00449591f, -0.05425712f, -0.01845902f, 
    0.04692971f, 0.05987686f, 0.08136162f, 0.02041578f, 0.05447696f, 0.02179832f, -0.01298235f, 0.04616254f, 
    -0.02797334f, -0.14239489f, -0.09566018f, -0.08883406f, -0.00881530f, 0.11048688f, -0.05635812f, 0.08352432f, 
    -0.09865171f, -0.03729003f, -0.02264516f, 0.00537367f, -0.07370348f, -0.04975476f, -0.03191337f, 0.01704546f, 
    0.04094687f, 0.01244077f, 0.03153168f, -0.10273756f, -0.19679350f, 0.08375227f, -0.03039665f, 0.04444998f, 
    -0.38230315f, -0.37437508f, 0.08550875f, 0.52027416f, 0.04821063f, 0.05166581f, 0.16337152f, -0.10045891f, 
    0.06097537f, 0.14351000f, -0.01270865f, -0.01632872f, -0.01885075f, 0.04788683f, -0.03028624f, -0.02897041f, 
    0.02856859f, -0.19863605f, 0.06958812f, -0.04613667f, -0.01294600f, -0.08009867f, 0.33033645f, -0.23094957f, 
    0.16222724f, 0.00382372f, -0.09146503f, 0.04858201f, -0.05878674f, -0.01802859f, 0.01769165f, -0.02223960f, 
    0.07629155f, 0.05567456f, -0.06228814f, 0.09789389f, -0.07592928f, 0.10269723f, -0.18282720f, -0.17723085f, 
    0.12370251f, 0.15327318f, -0.01931996f, -0.09101027f, -0.10469101f, 0.00758258f, 0.05656464f, -0.03171162f, 
    -0.03645338f, -0.04447710f, 0.01672531f, -0.05192923f, 0.04828540f, -0.04224294f, -0.01899851f, 0.05144815f, 
    0.05911998f, 0.01070425f, 0.00622024f, 0.00827830f, 0.02705923f, 0.06391352f, -0.00000045f, 0.04498661f, 
    -0.03855001f, 0.01891173f, -0.00029611f, -0.03625147f, -0.00356269f, -0.03105352f, 0.04016874f, 0.03369901f, 
    0.05142624f, 0.00162329f, 0.00252033f, -0.03106559f, -0.16205874f, -0.01090193f, -0.00412051f, 0.05866686f, 
    -0.10602044f, -0.03162476f, -0.03740373f, -0.07120176f, 0.06637226f, 0.06241880f, -0.00621033f, 0.00670235f, 
    0.05648612f, -0.01919843f, 0.00627793f, -0.01892713f, 0.05375177f, 0.01701641f, 0.01738619f, 0.09375761f, 
    -0.02102667f, 0.02403308f, -0.11097161f, 0.02238467f, -0.11558518f, -0.03435088f, -0.04110375f, -0.07989601f, 
    -0.02839484f, 0.05295784f, -0.11011126f, 0.04052587f, -0.04558379f, -0.00156950f, -0.17605501f, -0.01519450f, 
    -0.05239728f, 0.04694498f, 0.01576000f, 0.05640916f, 0.03550931f, 0.02417921f, 0.02636451f, 0.00950812f, 
    0.04378178f, -0.42077082f, 0.28982183f, 0.26815325f, 0.06870903f, 0.12950338f, 0.06642920f, -0.04427110f, 
    0.12510699f, 0.05789098f, -0.00582516f, -0.00317492f, 0.05390702f, -0.05505145f, -0.01083006f, -0.01872049f, 
    0.02085695f, 0.00042982f, 0.04731692f, 0.08118761f, 0.60031641f, -0.40063334f, -0.47757298f, 0.08069763f, 
    -0.16160049f, 0.00538054f, -0.05627539f, -0.03353884f, -0.02964491f, -0.12298267f, 0.02114598f, 0.02767181f, 
    0.04363788f, 0.00861404f, 0.01766565f, -0.00298343f, 0.00698408f, 0.05298819f, -0.03711995f, -0.10114769f, 
    0.03573065f, 0.00677424f, -0.01887019f, 0.00132907f, -0.03271744f, -0.03214487f, 0.03925674f, 0.03640684f, 
    -0.09532600f, -0.07557558f, 0.01482892f, 0.01444245f, 0.02629896f, 0.00969764f, -0.02126021f, 0.01365833f, 
    -0.09689814f, -0.03251896f, 0.04038068f, 0.04618561f, 0.54819906f, -0.49445948f, -0.48582059f, -0.39526314f, 
    -0.29322070f, 0.03383581f, -0.17995979f, 0.07011240f, 0.17130326f, -0.12546562f, 0.02882266f, 0.06376598f, 
    0.02206095f, -0.01605974f, 0.00653942f, -0.02573502f, 0.03193478f, 0.02134136f, 0.04839161f, 0.00681386f, 
    -0.28719056f, -0.11203226f, -0.01242855f, 0.24898712f, 0.01354500f, 0.01788110f, -0.00806572f, 0.07780359f, 
    0.01516770f, 0.08505012f, 0.02657924f, -0.02544891f, -0.00380745f, 0.00826689f, -0.05139356f, 0.03550250f, 
    0.09583583f, -0.00049577f, 0.04263444f, -0.04085723f, -0.11342552f, -0.16326696f, -0.00624418f, -0.10422327f, 
    0.02164364f, 0.00641576f, 0.07708066f, 0.03577697f, 0.05838130f, -0.06586045f, -0.03618160f, 0.04552399f, 
    0.03513487f, 0.05213383f, 0.02710612f, 0.01731852f, 0.03521184f, 0.01346483f, 0.00482200f, 0.03144032f, 
    0.04714505f, 0.11297645f, -0.01101444f, -0.01433272f, -0.09666449f, -0.02396659f, -0.00937928f, 0.00169024f, 
    0.02088900f, -0.01329791f, -0.05742563f, -0.04777903f, -0.00230597f, -0.04748653f, -0.03675168f, 0.06929427f, 
    -0.00860595f, 0.06599852f, -0.00600978f, 0.01947654f, 0.55338115f, -0.55010253f, -0.48016438f, -0.50000906f, 
    -0.28667527f, 0.05729092f, 0.02252772f, -0.11916107f, 0.24869654f, 0.03642305f, 0.01104821f, 0.06164161f, 
    -0.01665855f, 0.00467757f, 0.00344007f, -0.07699101f, -0.04032488f, -0.07097013f, 0.04291089f, -0.00488134f, 
    0.00644939f, 0.00491377f, 0.06818254f, -0.05580275f, -0.01320431f, -0.01593676f, 0.02421178f, 0.02931418f, 
    0.02403848f, -0.02042870f, 0.07950638f, -0.08121956f, -0.07400341f, -0.18081771f, -0.19965574f, -0.04393941f, 
    0.04052877f, -0.10898323f, 0.06334613f, 0.03127665f, -0.05973586f, 0.13150309f, 0.10074813f, -0.08008178f, 
    -0.03107325f, -0.04548508f, 0.04446111f, -0.04130223f, -0.04325212f, -0.01918824f, 0.04061668f, 0.01497901f, 
    0.03150420f, -0.01333412f, 0.01623182f, -0.03312554f, -0.02491893f, -0.06787779f, 0.01943883f, 0.00670484f, 
    -0.08590818f, -0.12575047f, 0.10868373f, -0.00831390f, 0.03628590f, -0.03939282f, 0.06249508f, 0.04932453f, 
    0.03011359f, 0.10158640f, -0.01625509f, -0.00833370f, 0.06262444f, 0.03724393f, 0.02897975f, -0.01233463f, 
    -0.01192715f, -0.06582962f, -0.01047759f, -0.08709560f, 0.07267772f, 0.13467370f, 0.14726780f, -0.11246116f, 
    0.11479352f, -0.23706797f, 0.23129992f, -0.03890395f, -0.04179076f, -0.01677552f, -0.03911667f, 0.03837777f, 
    0.04560961f, -0.11090653f, -0.08125853f, -0.05876793f, 0.00250571f, 0.06369656f, -0.13820055f, 0.07587379f, 
    0.54855156f, 0.16581254f, 0.06734624f, -0.30608881f, -0.32277408f, -0.04609891f, 0.01077385f, 0.05315066f, 
    -0.04717174f, -0.22101754f, -0.10718044f, -0.13143238f, 0.13685374f, -0.06593814f, 0.05763464f, -0.06537816f, 
    -0.04857624f, 0.09909514f, -0.05617471f, -0.07352114f, -0.09235569f, -0.07501905f, -0.01515193f, 0.01817884f, 
    0.07806690f, 0.07974210f, 0.03412109f, 0.02503009f, 0.02631440f, -0.00424423f, -0.01700971f, -0.00893384f, 
    0.12200189f, 0.09303258f, 0.09813789f, 0.03445964f, 0.03538077f, 0.02335635f, -0.00659805f, -0.02946136f, 
    -0.16911523f, -0.11561004f, -0.17048199f, 0.12770925f, -0.17307720f, -0.00277504f, 0.04286160f, 0.06669447f, 
    -0.03160017f, -0.01384192f, 0.01415643f, 0.01220420f, 0.01082622f, -0.02127978f, -0.06625868f, 0.05037177f, 
    -0.02330776f, 0.01648192f, -0.13896321f, 0.00588961f, -0.18434241f, -0.17906746f, -0.16745777f, 0.20433369f, 
    -0.07199000f, 0.08478358f, 0.01309614f, -0.02386150f, 0.08445961f, 0.10012396f, 0.02306059f, -0.01910532f, 
    -0.11130645f, -0.07456618f, -0.09185150f, -0.00656128f, 0.09865545f, -0.01630786f, 0.12116444f, 0.04252750f, 
    0.25878546f, 0.31772637f, -0.48957735f, 0.02833487f, -0.34896293f, 0.01782661f, 0.05321837f, 0.00169207f, 
    -0.04941723f, 0.05253864f, -0.18516135f, 0.16419955f, 0.11910072f, -0.13366388f, -0.13928844f, -0.14175411f, 
    -0.18411975f, 0.05269424f, -0.15534867f, -0.12187532f, 0.18361385f, 0.00128429f, -0.14542174f, -0.09873694f, 
    -0.04650781f, -0.00780111f, 0.01254335f, 0.01504681f, -0.01404891f, 0.00513682f, -0.01437582f, -0.07311200f, 
    0.04910416f, 0.03234301f, -0.01520524f, 0.00896359f, 0.00311035f, 0.00260196f, 0.04293296f, -0.01835484f, 
    0.07444192f, 0.14905918f, 0.03918120f, 0.01817119f, -0.11883853f, -0.01631289f, 0.09110925f, 0.03035716f, 
    -0.02535523f, -0.01234847f, -0.03793988f, 0.10023749f, 0.01030869f, -0.00617995f, -0.01749150f, -0.04514402f, 
    -0.01204020f, 0.02083379f, -0.05198783f, 0.04656251f, -0.20505603f, -0.45886579f, 0.36941516f, -0.34183499f, 
    0.24035479f, -0.09052677f, -0.12119690f, 0.13474861f, 0.00221361f, 0.07662439f, -0.06454884f, 0.07054834f, 
    -0.05617920f, 0.08455913f, 0.00533697f, -0.03537965f, 0.02450556f, -0.09784682f, 0.05576539f, -0.05158314f, 
    -0.14007542f, 0.15973125f, 0.07115501f, -0.02090611f, -0.02716353f, 0.00371978f, -0.09336586f, -0.05004044f, 
    -0.03620389f, -0.00211614f, 0.04524757f, 0.00077684f, 0.04509046f, 0.00333646f, -0.01940852f, 0.03311389f, 
    -0.15711677f, -0.05598447f, -0.01685726f, 0.02657777f, 0.02607112f, 0.04944992f, 0.01739704f, -0.03542078f, 
    -0.06173986f, 0.02456503f, 0.07172240f, 0.01669922f, -0.03086119f, 0.00682499f, 0.01490848f, -0.00900995f, 
    0.04623177f, 0.04236694f, -0.01361771f, 0.05281631f, 0.01863519f, -0.01124547f, -0.10400767f, -0.14252163f, 
    -0.08673151f, -0.05650712f, 0.08350512f, -0.07317083f, 0.04169169f, 0.03037153f, 0.00931896f, 0.03990701f, 
    0.00591605f, -0.02734088f, -0.03376519f, -0.10231163f, 0.00762344f, 0.04477201f, 0.04388430f, 0.00840629f, 
    0.01920894f, -0.07053023f, 0.04900414f, -0.01290190f, -0.37123641f, -0.43032628f, 0.31135839f, -0.27470288f, 
    0.06007893f, -0.21874915f, 0.11443423f, 0.03051577f, 0.09121765f, -0.08267844f, 0.00789403f, -0.00932867f, 
    -0.02891539f, -0.00655740f, 0.00088507f, 0.04445401f, -0.00673743f, -0.12672679f, -0.04812639f, -0.02660099f, 
    -0.14769362f, 0.09495503f, -0.10837780f, -0.00101976f, -0.13159429f, 0.04304672f, -0.02534466f, -0.18288651f, 
    -0.04776028f, -0.00775014f, 0.03740182f, 0.03852255f, 0.00525534f, 0.01710330f, -0.02733070f, -0.01954506f, 
    -0.01092015f, -0.09948052f, 0.04231134f, 0.01479891f, -0.08978913f, -0.02757846f, -0.09976730f, 0.03376587f, 
    -0.11246055f, 0.07798297f, 0.03838246f, -0.03999079f, -0.01880619f, 0.00960552f, 0.03508292f, 0.04004003f, 
    0.00306787f, 0.02592692f, -0.01122886f, 0.01482728f, -0.01436220f, -0.02213171f, -0.01467163f, 0.02622937f, 
    0.23447934f, -0.18187164f, -0.21298459f, -0.10505399f, 0.00797806f, 0.03588408f, -0.04018767f, -0.01724743f, 
    -0.08989187f, -0.15347803f, 0.00622589f, -0.01125493f, 0.02002234f, 0.06880616f, 0.06715903f, 0.03713784f, 
    0.00733592f, 0.05500861f, -0.07536784f, -0.14392500f, -0.00583845f, -0.12546542f, -0.49361214f, -0.33903164f, 
    -0.01061599f, -0.10894710f, -0.14925164f, 0.19583789f, -0.07567582f, -0.20332351f, -0.00670894f, -0.02457731f, 
    -0.04213151f, 0.02527927f, 0.07420373f, 0.04464461f, -0.01207446f, -0.05029967f, 0.05719779f, -0.17272173f, 
    -0.23412415f, -0.01675272f, 0.07915621f, -0.05222492f, -0.14115542f, -0.03953001f, -0.02949918f, -0.05252865f, 
    -0.02028732f, -0.01128497f, -0.07310926f, -0.05432069f, -0.02172878f, -0.02892814f, -0.02597363f, 0.04490966f, 
    0.04485002f, -0.00432669f, 0.01074911f, 0.04285974f, 0.30480954f, -0.17634359f, -0.15907651f, -0.16102117f, 
    -0.15987697f, 0.00469103f, 0.17835867f, 0.06230375f, 0.13978010f, 0.01318690f, 0.08426747f, 0.02217730f, 
    -0.07875861f, -0.12046368f, 0.01835790f, 0.07449558f, 0.10167060f, -0.06266829f, 0.07881566f, -0.06049302f, 
    0.49781686f, 0.02520082f, -0.02704434f, 0.01910956f, -0.17375451f, 0.06240724f, -0.11630156f, -0.11722408f, 
    -0.11443520f, -0.05286433f, 0.02167594f, 0.07012398f, 0.09021543f, -0.01697476f, -0.01402267f, -0.01511941f, 
    0.03460853f, 0.02560993f, 0.10793114f, 0.05538672f, -0.62492222f, -0.87008393f, 0.14929034f, 0.07355110f, 
    0.39350370f, -0.02002103f, 0.00788637f, -0.04799348f, -0.12710324f, -0.00268904f, 0.09546043f, 0.00211066f, 
    0.13099383f, 0.08922353f, 0.04872555f, -0.06645032f, -0.05200629f, -0.10081311f, -0.10827998f, 0.00434050f, 
    0.01872489f, -0.05378194f, -0.09950258f, -0.05901809f, -0.03923044f, -0.01896919f, -0.08404798f, -0.05889509f, 
    0.04280668f, 0.02272986f, 0.03376014f, 0.03488682f, 0.06619928f, -0.07900966f, -0.01390245f, -0.09272408f, 
    0.07394253f, 0.01667151f, 0.07007140f, 0.08027095f, -0.10740196f, 0.02919072f, 0.01779102f, -0.01056241f, 
    -0.12973015f, -0.06514245f, 0.00300865f, -0.03492229f, 0.00480845f, 0.01481371f, -0.00696819f, 0.02591954f, 
    -0.03409123f, 0.05525502f, 0.04184756f, 0.03753493f, 0.12276644f, 0.02090765f, 0.10547780f, 0.08252557f, 
    0.54458648f, 0.11061972f, 0.01350421f, -0.12511295f, -0.21040446f, 0.02261928f, -0.12946403f, -0.09312198f, 
    0.01428376f, -0.10186933f, -0.03588727f, 0.07222383f, 0.04976337f, -0.04380758f, 0.04653368f, -0.01564409f, 
    0.05490228f, 0.05130185f, 0.18066393f, 0.04589804f, 0.07076447f, 0.11243948f, 0.02304978f, 0.01175827f, 
    -0.13450402f, -0.05909709f, 0.00767207f, -0.07428665f, 0.00546263f, -0.10827200f, -0.02486425f, 0.14236474f, 
    0.04298387f, 0.03564447f, 0.10971876f, -0.08705323f, -0.02521337f, -0.09912973f, -0.05866365f, 0.04591361f, 
    0.03312645f, -0.32466999f, -0.33845621f, -0.20614608f, -0.01145574f, 0.00077361f, 0.08318764f, 0.10684259f, 
    0.08515705f, 0.11015875f, 0.03115180f, -0.10579813f, -0.12629974f, -0.05143543f, -0.06351987f, -0.01047539f, 
    -0.02003992f, 0.02143268f, 0.00898968f, -0.01254956f, 0.04732713f, -0.36892292f, -0.81775510f, -0.07207733f, 
    0.08600433f, -0.20466328f, 0.07428090f, 0.12640053f, 0.14490342f, 0.10373437f, 0.18891548f, -0.14230376f, 
    -0.00882755f, 0.07117623f, 0.00860565f, -0.07310496f, -0.01822557f, -0.02898697f, -0.02526705f, -0.02397933f, 
    -0.12651135f, -0.03897268f, 0.05591157f, -0.02980868f, -0.04267500f, -0.09256802f, 0.03603418f, -0.03248549f, 
    0.01068658f, -0.02819390f, 0.05675577f, -0.00790998f, -0.00565367f, 0.07089285f, -0.01308328f, -0.01036257f, 
    -0.00084069f, 0.05824282f, 0.16224450f, 0.09140884f, 0.10125706f, -0.25941783f, -0.11779803f, 0.00437199f, 
    -0.00359287f, -0.04671162f, 0.17375283f, -0.01531502f, 0.12466165f, 0.00637473f, 0.04262406f, -0.01792462f, 
    0.02264389f, 0.03933923f, 0.08854928f, -0.00586893f, -0.19186783f, -0.15914111f, -0.11511621f, -0.26864773f, 
    0.11507063f, -0.00060814f, -0.37149620f, -0.10778391f, 0.12537083f, -0.15316910f, -0.01580895f, -0.01740221f, 
    0.08287509f, 0.06444193f, 0.00319815f, -0.03718838f, -0.04199728f, -0.03972663f, -0.05316678f, 0.07876916f, 
    -0.07076932f, 0.01739061f, -0.16238154f, -0.18132769f, 0.02741378f, -0.42939144f, -0.39113227f, -0.11424062f, 
    -0.16027842f, -0.01158270f, 0.03880973f, 0.00991430f, 0.01682765f, 0.00427426f, -0.04618611f, 0.00648364f, 
    -0.00142990f, 0.00197835f, -0.00789751f, 0.01148741f, 0.06941052f, 0.07643850f, 0.06472594f, 0.06872788f, 
    -0.21548699f, -0.35273644f, 0.18899937f, -0.07494859f, 0.21323271f, -0.09364696f, 0.03452905f, -0.07758265f, 
    -0.06462701f, -0.05881247f, 0.04197542f, -0.00018493f, -0.06626458f, 0.08476494f, -0.02955167f, -0.00445655f, 
    -0.00266541f, -0.01462888f, 0.01103057f, -0.08895115f, 0.27473646f, 0.03673001f, -0.06552323f, -0.17723709f, 
    -0.08199497f, 0.08741298f, 0.09584001f, -0.02285671f, -0.00916297f, -0.17349410f, -0.00552478f, 0.03061871f, 
    0.05108839f, 0.06664401f, 0.10236935f, 0.01916996f, -0.02017689f, -0.06836146f, 0.14570794f, 0.09611554f, 
    0.03072741f, -0.20878772f, -0.26984724f, -0.10072674f, 0.04730170f, -0.06695277f, 0.03892937f, 0.03986148f, 
    0.01112564f, 0.10331751f, 0.01281850f, -0.01602409f, -0.12553704f, -0.04733353f, -0.05017906f, -0.01737525f, 
    0.01571174f, 0.05226739f, 0.01662980f, -0.00453368f, 0.32327330f, 0.06788564f, -0.03296259f, -0.08316477f, 
    -0.22162886f, -0.03414976f, -0.15662107f, -0.09141520f, -0.05192060f, -0.08927815f, 0.02105387f, 0.06547347f, 
    0.06079151f, -0.01852679f, 0.02150836f, -0.00946209f, 0.07979587f, 0.02634249f, 0.13770041f, 0.04381338f, 
    -0.23630387f, -0.00403048f, 0.09125566f, -0.02951197f, -0.09086551f, -0.09471285f, -0.02378962f, -0.02573830f, 
    -0.03842577f, -0.01527107f, -0.05801154f, 0.00262304f, -0.02194632f, 0.11983883f, 0.04350021f, 0.02499674f, 
    0.04717193f, -0.02803379f, 0.07307879f, 0.00679490f, 0.24846278f, 0.11817258f, 0.01370784f, -0.00818223f, 
    0.03079985f, -0.03131438f, 0.06289946f, -0.03606694f, 0.03541474f, -0.11687030f, -0.01554826f, -0.01535246f, 
    0.02870776f, 0.05302737f, -0.00672934f, 0.08325543f, 0.04619791f, -0.03775568f, 0.11309820f, 0.04459909f, 
    0.15073770f, -0.01361386f, -0.00737161f, 0.05745007f, -0.02386989f, -0.01232616f, -0.02364757f, -0.18378246f, 
    -0.02767535f, 0.01416849f, 0.02432899f, -0.03319032f, 0.03822707f, 0.02890706f, 0.02421128f, 0.01448976f, 
    0.06114133f, 0.09154860f, -0.03632208f, 0.10018196f, 0.00353410f, 0.06371090f, 0.08282160f, 0.01940642f, 
    -0.00384319f, -0.01491835f, -0.05658029f, -0.03995534f, -0.02077138f, -0.07718827f, -0.03604015f, 0.07332511f, 
    0.02333028f, 0.06891365f, 0.04785023f, 0.01940523f, 0.06382874f, -0.13833471f, -0.07709061f, 0.00933865f, 
    -0.14048040f, -0.02270086f, 0.01480530f, 0.03720133f, -0.17355619f, -0.04301381f, 0.03447424f, -0.09082872f, 
    -0.03503362f, 0.00091075f, -0.04347893f, 0.02244641f, -0.00580808f, -0.00410500f, -0.01714653f, 0.08598050f, 
    0.10185581f, 0.06926364f, 0.00487250f, 0.05491450f, 0.19638214f, 0.22781354f, -0.18075843f, -0.10934278f, 
    -0.10839906f, 0.14541008f, -0.00721047f, 0.04239022f, 0.13810563f, -0.00297072f, -0.02231676f, 0.06262492f, 
    -0.00507961f, 0.11928780f, 0.10814710f, -0.19273695f, -0.05748004f, 0.02544414f, -0.15655382f, -0.19777963f, 
    0.27072248f, 0.08102679f, -0.00916388f, -0.01187259f, -0.11916579f, 0.02653213f, -0.01829503f, -0.11666818f, 
    -0.05166089f, -0.00357832f, 0.07438438f, 0.03272059f, 0.01703238f, 0.01881620f, 0.04472056f, -0.00503797f, 
    0.10483395f, 0.00753552f, 0.07623514f, 0.03703368f, -0.04005355f, -0.41494045f, -0.51845551f, -0.15497093f, 
    0.10141779f, 0.00713576f, -0.05346536f, 0.06531366f, 0.01798184f, 0.17235665f, -0.04012439f, -0.01856605f, 
    -0.03030742f, 0.01082288f, 0.01187629f, 0.01889738f, 0.09481157f, 0.08360007f, 0.02696981f, 0.06077668f, 
    -0.08547705f, -0.51280844f, -0.14295255f, 0.01876801f, 0.19866793f, -0.03270875f, 0.07185560f, 0.13054691f, 
    -0.00795178f, -0.00010956f, 0.06731599f, -0.06969379f, -0.09301663f, 0.00896447f, -0.02789118f, -0.02738347f, 
    -0.05198811f, -0.02929868f, -0.04175079f, -0.09929388f, -0.13132057f, -0.45847729f, -0.56702453f, -0.55089498f, 
    -0.13188757f, -0.00107484f, 0.05786443f, 0.04375105f, 0.09026442f, -0.15855610f, 0.01922677f, -0.04395589f, 
    -0.05797822f, -0.04255215f, 0.03716837f, 0.05796378f, 0.00859079f, 0.02801934f, 0.05886396f, 0.04768777f, 
    -0.19831601f, -0.15780148f, 0.11979967f, 0.02479375f, -0.20831864f, 0.08926734f, 0.00373463f, -0.05395503f, 
    -0.02679575f, -0.23665114f, -0.08344734f, -0.03080276f, 0.01658995f, -0.02916197f, 0.01607087f, 0.01093615f, 
    0.00678959f, 0.07046330f, -0.12069198f, -0.08906358f, -0.05049435f, 0.05982347f, 0.05838034f, -0.02505405f, 
    -0.14024749f, -0.03822847f, 0.08570646f, -0.04624622f, 0.03879832f, -0.00665556f, -0.00517781f, 0.00855595f, 
    0.02341220f, 0.06789016f, 0.02820128f, 0.06515317f, 0.13726795f, -0.00874208f, 0.10344540f, -0.00524861f, 
    0.42777702f, -0.01275842f, 0.04357198f, -0.06422776f, -0.12742764f, 0.09625183f, -0.27928436f, -0.07221233f, 
    -0.03712495f, -0.16283293f, -0.01175093f, 0.07156764f, 0.05392491f, 0.04931289f, 0.00635797f, 0.06550732f, 
    0.05611485f, 0.02219119f, -0.01551977f, -0.19400468f, 0.07589573f, -0.48312622f, 0.06777094f, 0.16906044f, 
    0.03593938f, 0.04204458f, -0.00553759f, -0.06249498f, -0.09436131f, 0.04707416f, 0.05917498f, -0.04296932f, 
    0.05445666f, 0.00489919f, -0.02723303f, 0.07720997f, -0.07639819f, -0.05148137f, -0.16845274f, 0.01552124f, 
    -0.11187984f, -0.06474954f, -0.11780290f, -0.10054792f, -0.12120868f, -0.09148858f, 0.02227227f, 0.03735415f, 
    0.02279289f, 0.00665799f, 0.12120578f, 0.06240996f, 0.10200797f, -0.00346310f, 0.05401473f, 0.03532465f, 
    0.08977577f, -0.00659381f, 0.07393902f, 0.04118318f, -0.23671860f, -0.02520364f, 0.07347076f, 0.06320758f, 
    -0.06501067f, -0.06101100f, 0.02725668f, -0.04525869f, -0.03413084f, 0.01754165f, -0.03087274f, -0.04503255f, 
    -0.01032836f, 0.03376656f, -0.01213824f, 0.08045938f, 0.02786629f, 0.05444248f, 0.02713878f, 0.03494104f, 
    -0.34795487f, -0.21318792f, -0.05686428f, 0.05338864f, 0.27768078f, 0.06474981f, -0.00736823f, -0.10704921f, 
    -0.00576138f, -0.03258668f, -0.01214107f, -0.02441242f, 0.13218597f, 0.09221331f, -0.12252664f, 0.01246450f, 
    -0.03049141f, 0.04371245f, 0.03997904f, 0.14908215f, -0.08248418f, -0.19346468f, -0.00996573f, 0.02252129f, 
    0.04759761f, -0.03586118f, 0.06999829f, 0.03654972f, -0.03932250f, 0.07482782f, 0.12380363f, 0.02803350f, 
    0.02937289f, 0.10228767f, -0.01247717f, -0.01219187f, 0.05178842f, 0.04570867f, 0.07647759f, 0.02099445f, 
    0.41821563f, 0.26026681f, 0.08549163f, -0.28288978f, -0.05895719f, 0.12473934f, -0.02776023f, -0.06554127f, 
    -0.03578565f, -0.12198089f, 0.03596708f, 0.07110305f, 0.00626110f, 0.06114290f, 0.07038961f, 0.05379748f, 
    0.06205928f, 0.02013412f, -0.06785515f, -0.12381297f, 0.23642612f, -0.52764392f, -0.44775334f, -0.31848529f, 
    0.09505370f, 0.03504089f, 0.16023755f, -0.00644164f, 0.07026037f, 0.19484630f, 0.04348347f, 0.02671138f, 
    -0.05994201f, 0.00260987f, -0.07257085f, 0.05637321f, 0.01216584f, 0.00281492f, 0.01021293f, 0.02132426f, 
    -0.18539512f, 0.12295311f, 0.09682139f, 0.02623251f, -0.04598249f, -0.04385078f, -0.04303908f, -0.00687510f, 
    -0.03707547f, 0.04120205f, 0.00895045f, -0.01500832f, 0.00695274f, -0.01287127f, 0.01220152f, -0.00320103f, 
    0.05848799f, 0.02618084f, 0.02489567f, -0.00422006f, -0.13101168f, -0.60831523f, -0.68275571f, -0.43725789f, 
    0.16779423f, -0.01645365f, 0.25883669f, 0.17550249f, 0.11616907f, 0.00148996f, -0.00946489f, -0.10384551f, 
    -0.08335078f, 0.00775370f, -0.03314093f, 0.03092083f, 0.00040071f, -0.01938614f, 0.01819201f, -0.02071381f, 
    -0.01767113f, -0.12764107f, 0.05640682f, -0.00604024f, -0.00436041f, 0.03487514f, -0.03688012f, -0.09075610f, 
    0.00328160f, -0.21134856f, -0.00505557f, 0.02785101f, 0.06071471f, 0.02118005f, 0.00936355f, 0.05068030f, 
    -0.02990321f, -0.09583154f, -0.01016992f, -0.25380680f, -0.00521710f, -0.14071496f, -0.12361287f, -0.02859948f, 
    -0.00692536f, -0.01682256f, 0.00663686f, -0.02510774f, -0.06247509f, 0.07579728f, 0.04933653f, 0.07796947f, 
    -0.13940220f, -0.02661456f, -0.08453503f, -0.02635029f, 0.06465790f, 0.10495976f, 0.05147637f, 0.00779591f, 
    -0.11362189f, 0.03087378f, -0.00866348f, -0.08874734f, -0.09753711f, -0.08576240f, -0.03085739f, -0.01315868f, 
    -0.04220822f, -0.08904774f, -0.04878622f, -0.00528379f, -0.01344706f, 0.01137672f, 0.00854516f, 0.00472592f, 
    0.03186074f, 0.01907633f, 0.06253944f, 0.00863722f, -0.18008733f, -0.27378532f, -0.60958159f, -0.52436185f, 
    -0.08046026f, -0.09351440f, 0.03447024f, 0.17596801f, 0.05704832f, -0.13028900f, -0.03240762f, -0.05168668f, 
    -0.03266411f, 0.03559010f, 0.08982459f, 0.08315678f, 0.00546275f, 0.04047379f, -0.01189421f, -0.00291024f, 
    -0.08511304f, -0.02083713f, 0.03516310f, 0.08206777f, -0.11948642f, -0.05431067f, -0.03717354f, -0.05779644f, 
    0.03808028f, -0.02390929f, 0.08959675f, 0.02942203f, 0.06288207f, -0.04913946f, 0.14307792f, -0.15607181f, 
    0.08565162f, -0.03414197f, -0.05279740f, 0.08019429f, -0.29705769f, 0.09312877f, 0.08479277f, 0.10044912f, 
    0.05056373f, 0.01214722f, -0.02197911f, 0.01301908f, 0.04004004f, -0.10694335f, -0.05011482f, -0.07244562f, 
    0.03945624f, -0.02276483f, -0.01799296f, -0.00377317f, 0.01533894f, 0.03253323f, 0.05049866f, 0.00937308f, 
    -0.08823460f, -0.08634078f, -0.05110666f, 0.05179041f, -0.01086852f, -0.09313247f, -0.09948172f, -0.09481084f, 
    -0.02801320f, -0.02443930f, -0.10110144f, 0.08859229f, -0.00658617f, -0.02237631f, -0.00039172f, -0.04138925f, 
    0.14346378f, 0.18544330f, 0.09858654f, 0.18155804f, 0.12186176f, -0.16247492f, -0.09105696f, 0.04350327f, 
    -0.15713894f, -0.00349140f, -0.01468874f, -0.02536899f, 0.09467953f, 0.15460518f, 0.07142026f, -0.05413398f, 
    -0.03563803f, 0.01512862f, 0.11047967f, 0.12006094f, 0.13945884f, 0.06194225f, 0.08197327f, 0.01207962f, 
    0.45925498f, -0.04334211f, -0.08934927f, -0.04184599f, 0.05400394f, 0.03132502f, -0.00039579f, 0.07759289f, 
    0.01814158f, 0.03425115f, 0.11387581f, 0.13662472f, -0.08750138f, 0.04460650f, 0.07777732f, 0.01518312f, 
    0.05720252f, -0.06068284f, -0.06254461f, 0.12005824f, 0.01366163f, -0.02545785f, -0.04057996f, 0.03824852f, 
    -0.09136994f, -0.15781410f, -0.09436092f, -0.03176223f, -0.08504840f, 0.05022889f, 0.03923032f, 0.02998348f, 
    0.00077665f, -0.09186336f, -0.01173059f, -0.03562243f, 0.11377805f, 0.05309732f, 0.16927573f, 0.09274522f, 
    0.28699467f, 0.02819482f, -0.02398464f, -0.04037249f, -0.20617920f, 0.00152353f, -0.06604122f, -0.01962688f, 
    0.01655608f, -0.12072010f, 0.00703407f, 0.00116316f, 0.03703259f, 0.00158222f, 0.00230616f, -0.00031467f, 
    0.05829325f, 0.08138718f, 0.17675695f, 0.10658156f, 0.02614131f, -0.12646177f, -0.23979360f, -0.32111067f, 
    -0.20728819f, -0.08477687f, -0.09746353f, -0.09551372f, -0.08937825f, -0.24615192f, 0.02134923f, 0.01771148f, 
    0.03323759f, 0.06100367f, 0.06863753f, 0.07304239f, 0.04341952f, 0.12402854f, -0.06893741f, -0.19272122f, 
    0.28197587f, 0.27516097f, -0.01525899f, -0.10620555f, -0.36748442f, 0.04407078f, 0.12808502f, -0.03843874f, 
    0.11722571f, -0.08422326f, 0.13279460f, -0.01184922f, -0.12662567f, 0.02934588f, 0.09532572f, 0.14551103f, 
    0.07043857f, -0.07448665f, 0.09871453f, -0.08968440f, -0.00310458f, -0.13544723f, -0.13958420f, -0.04897144f, 
    0.01252650f, -0.01453403f, 0.04253399f, 0.00710086f, 0.00560749f, 0.08624393f, 0.01460451f, 0.00891803f, 
    -0.05469003f, 0.00132373f, -0.05613898f, 0.00347648f, 0.08770546f, -0.00014386f, 0.05120521f, 0.05685243f, 
    0.11018063f, 0.16141546f, -0.04707620f, -0.10236688f, -0.06796054f, -0.05397011f, 0.01747928f, -0.05140989f, 
    -0.02477018f, -0.05126023f, 0.03095295f, -0.05146244f, 0.01932356f, -0.04735718f, 0.03909245f, 0.05604933f, 
    -0.08528022f, -0.02933697f, 0.06974988f, -0.03562510f, -0.07874281f, -0.39639753f, -0.13115804f, 0.07744414f, 
    0.31927612f, 0.17027593f, 0.06850765f, 0.07072710f, -0.01390268f, 0.11171438f, 0.09648780f, 0.04729122f, 
    -0.10451156f, 0.04153488f, -0.02069526f, -0.07241797f, 0.06742822f, 0.02903254f, -0.16938655f, 0.03998176f, 
    -0.38138396f, -0.04901388f, 0.14458190f, 0.08906417f, -0.08528903f, -0.10197064f, 0.06083326f, -0.01932707f, 
    0.04457543f, 0.01930489f, -0.00279896f, -0.02839438f, -0.03017130f, -0.02190404f, 0.01392133f, -0.00108913f, 
    0.04863847f, 0.00483878f, 0.01739825f, 0.02656779f, -0.20816372f, -0.02075224f, 0.23393229f, 0.10810640f, 
    -0.07039977f, -0.07478624f, -0.07309107f, -0.13627228f, -0.03215181f, -0.06115125f, -0.05472617f, -0.05945956f, 
    -0.02647915f, -0.07313158f, -0.07253125f, -0.10308969f, -0.27111799f, -0.10378920f, -0.25553265f, -0.14794607f, 
    0.04653029f, -0.09982987f, -0.05927863f, 0.04165147f, -0.02108891f, -0.05201612f, -0.06794951f, -0.09212591f, 
    -0.00517523f, 0.07522269f, 0.02538368f, 0.04987283f, 0.01768903f, -0.03686393f, -0.02393252f, -0.04001902f, 
    0.15678827f, 0.04241858f, 0.08944248f, 0.10114186f, 0.19276202f, -0.30597627f, -0.27399373f, 0.10883377f, 
    0.05615398f, 0.10338537f, 0.00320454f, 0.06648337f, 0.07123691f, 0.11054640f, 0.00095000f, 0.03761477f, 
    0.03530305f, 0.02227420f, 0.03397921f, 0.05385611f, 0.05555158f, 0.12149007f, 0.07985505f, 0.04567818f, 
    -0.16236214f, 0.18113956f, 0.12097980f, 0.06240164f, -0.11910091f, 0.04760251f, -0.01919146f, 0.04324079f, 
    0.05987709f, -0.17850168f, -0.01783976f, -0.02655056f, 0.03763258f, -0.02763705f, -0.04611074f, -0.10527489f, 
    -0.05448010f, 0.04906782f, 0.02053623f, -0.00940894f, 0.08172732f, 0.23136088f, 0.07436182f, -0.02775223f, 
    -0.19314203f, -0.01607879f, -0.06859586f, 0.03755578f, -0.05932006f, -0.18201977f, 0.01033988f, -0.00221176f, 
    0.05891956f, -0.00514943f, 0.03023992f, -0.04630795f, 0.04767073f, 0.10620590f, 0.11745445f, 0.01430584f, 
    -0.03243193f, 0.00407161f, 0.06541204f, 0.12293248f, -0.06875031f, 0.00364067f, -0.20358504f, -0.00265045f, 
    0.11431861f, 0.11019341f, 0.00051861f, 0.05054080f, 0.02962442f, 0.02465266f, 0.06856082f, -0.01448085f, 
    0.05568306f, 0.09882781f, 0.10921292f, 0.09284267f, -0.03880663f, -0.34891230f, -0.12065028f, 0.07187244f, 
    -0.29818961f, -0.29570696f, 0.07150534f, -0.03949800f, 0.03771660f, 0.04392449f, 0.07768469f, 0.00150822f, 
    0.06998756f, 0.00920603f, -0.02961887f, -0.12581563f, 0.10221593f, 0.02316699f, 0.09658576f, 0.02654007f, 
    -0.11312860f, -0.00153977f, -0.20309781f, -0.06993526f, -0.00497735f, 0.12588444f, -0.02921706f, 0.15730660f, 
    0.01871747f, 0.00587557f, 0.09178651f, -0.06174555f, 0.07142585f, -0.00835699f, -0.08364623f, 0.07475673f, 
    0.02332903f, 0.04239239f, 0.02628625f, 0.05073269f, -0.37598109f, 0.25659433f, -0.13693421f, 0.30858824f, 
    -0.03856425f, 0.01161861f, -0.33352143f, -0.12245202f, -0.22104394f, -0.10056730f, 0.01604590f, -0.00786411f, 
    0.05227052f, -0.06974679f, 0.02064576f, -0.07317438f, -0.11730336f, -0.02385310f, -0.01510330f, 0.02972621f, 
    0.02682891f, 0.05405567f, -0.29072857f, 0.00130701f, -0.11976909f, 0.07837798f, 0.06467661f, 0.06424905f, 
    -0.02917397f, -0.07064802f, 0.04047972f, -0.04961405f, -0.00902346f, -0.08736564f, -0.01543809f, -0.01522665f, 
    0.02557896f, -0.05503610f, -0.04643831f, 0.01395291f, -0.09991260f, -0.61787009f, 0.01351141f, -0.66977906f, 
    -0.68716383f, 0.01153303f, -0.28307566f, 0.06109589f, 0.11793090f, -0.00933286f, -0.11402602f, 0.10538944f, 
    -0.02008859f, -0.15827926f, 0.05194458f, 0.09401181f, 0.05558163f, 0.03761663f, -0.10879040f, 0.13763323f, 
    -0.04862629f, -0.05557849f, 0.25711805f, 0.06097652f, 0.03117598f, 0.13341685f, -0.05894371f, -0.10388072f, 
    -0.16313343f, -0.03271433f, -0.02184690f, 0.06760928f, 0.12048874f, 0.00486520f, 0.04441401f, 0.06054496f, 
    -0.09057150f, -0.08007101f, -0.03959570f, 0.07114694f, -0.07037746f, 0.04293131f, 0.00659398f, -0.19056818f, 
    0.05786638f, 0.07838368f, 0.07026269f, 0.03342365f, 0.00507304f, -0.06959102f, 0.06118219f, 0.02771610f, 
    -0.04849410f, 0.11819569f, 0.04495006f, 0.09051664f, -0.03068727f, -0.00224663f, 0.00026419f, 0.03310219f, 
    0.21223807f, 0.19575042f, -0.41548857f, 0.12654854f, -0.25804079f, -0.05939721f, 0.07013538f, 0.08845209f, 
    0.09454785f, 0.11044868f, -0.00703934f, -0.02704102f, -0.09174964f, -0.04959625f, -0.05043831f, 0.00604848f, 
    -0.06668936f, -0.00775476f, -0.00729604f, -0.15598433f, -0.12005094f, -0.06605782f, 0.01946825f, 0.22853102f, 
    0.14421418f, -0.05488197f, 0.12874109f, -0.05249470f, -0.12541266f, -0.04579844f, 0.08798380f, -0.04922731f, 
    0.00161972f, -0.09235031f, -0.06099356f, 0.06692170f, 0.08420418f, -0.01730858f, -0.04620420f, 0.02258128f, 
    0.02752492f, 0.04437137f, 0.34720397f, 0.20652336f, -0.34041658f, 0.19540045f, -0.20209308f, -0.18261966f, 
    -0.06005064f, -0.04014439f, 0.06172622f, -0.04069788f, 0.08317840f, 0.04183992f, 0.03172901f, 0.00938874f, 
    -0.05046519f, -0.03056624f, 0.01169499f, 0.02251379f, 0.03458283f, 0.11774686f, 0.11930580f, 0.40322489f, 
    -0.37285006f, -0.15177949f, 0.12241753f, -0.44689757f, -0.02619339f, -0.30168372f, 0.07824080f, -0.03691882f, 
    0.11585400f, 0.14195140f, 0.03689239f, 0.05060509f, 0.04583137f, -0.02662681f, 0.05997662f, 0.07857282f, 
    -0.16581814f, 0.18182379f, 0.15665221f, -0.16289404f, -0.02652914f, 0.05803637f, -0.01780157f, -0.03319366f, 
    0.00414793f, -0.00739682f, -0.01003113f, 0.02202172f, 0.04402828f, 0.02994409f, 0.02298591f, -0.01128366f, 
    0.10260687f, -0.11172122f, 0.04010424f, 0.04851263f, -0.20879942f, -0.41254878f, -0.26532748f, -0.35317352f, 
    -0.10215452f, -0.02785970f, -0.06111628f, -0.06739973f, 0.02297952f, 0.04511118f, 0.00068652f, 0.01661175f, 
    0.02521023f, 0.01868642f, -0.04910927f, 0.02619554f, 0.22397873f, 0.04232738f, 0.07223466f, 0.13011332f, 
    0.09505082f, 0.13287283f, 0.04921950f, 0.48667738f, -0.17059752f, 0.02357552f, 0.01658899f, -0.12655023f, 
    0.05651219f, -0.05785247f, 0.06785141f, 0.00084619f, 0.05175874f, 0.03086282f, 0.00989233f, 0.10065878f, 
    0.13632758f, 0.06647609f, 0.05398809f, 0.15275389f, -0.14668916f, -0.01525232f, 0.09030668f, 0.12412297f, 
    -0.14243424f, -0.21987484f, -0.01147482f, 0.19726661f, 0.12557600f, 0.17237882f, -0.01322577f, 0.01572179f, 
    0.04199661f, -0.03590738f, 0.00125790f, 0.00303946f, 0.00919713f, -0.00565127f, 0.00195910f, -0.19780742f, 
    0.07507434f, -0.11918652f, 0.07814623f, -0.15296906f, -0.20126066f, 0.04441772f, -0.16329581f, 0.04699728f, 
    0.01013750f, -0.08894442f, -0.02438131f, 0.11461526f, -0.06664897f, -0.05622285f, 0.03062435f, 0.10161094f, 
    0.02866748f, 0.09204148f, -0.02535717f, 0.09365798f, -0.54700845f, -0.01631434f, -0.16635416f, 0.24441323f, 
    0.04342492f, 0.07503510f, 0.04902330f, -0.07093053f, -0.18960539f, -0.06214554f, 0.08196625f, 0.07416273f, 
    0.04007540f, -0.03741480f, 0.00894876f, -0.02373835f, 0.04860673f, -0.08469396f, 0.03555623f, 0.09444224f, 
    -0.05710028f, 0.01537643f, 0.23911266f, 0.15035807f, -0.11669549f, 0.11514229f, -0.06741988f, -0.14105012f, 
    -0.05875230f, 0.03994935f, 0.06266781f, -0.03625859f, 0.09176581f, 0.06129811f, -0.00651881f, 0.04217249f, 
    -0.06815029f, -0.03159539f, -0.00182283f, -0.02037115f, -0.13364583f, -0.05458242f, -0.27534962f, 0.12120517f, 
    -0.13699067f, -0.05374580f, 0.10370441f, -0.03187042f, 0.00578167f, -0.03600492f, -0.08540672f, -0.04325551f, 
    0.01534385f, -0.09743003f, -0.00677597f, 0.04945958f, -0.08259245f, 0.02724117f, -0.04618337f, -0.08659006f, 
    -0.06609210f, -0.04088826f, 0.01431789f, -0.20138049f, 0.13104063f, 0.02764567f, 0.09098013f, 0.08153115f, 
    -0.00821774f, -0.07223751f, 0.04167491f, 0.06216639f, 0.02884389f, -0.04797289f, -0.02204336f, 0.13434479f, 
    -0.00502970f, -0.02284415f, 0.00595941f, 0.02313324f, -0.45647404f, 0.13469766f, -0.23822844f, 0.14678332f, 
    -0.12075549f, 0.00925280f, 0.08965709f, 0.04027658f, -0.20016098f, 0.03310592f, 0.00556462f, 0.08190218f, 
    -0.02679056f, -0.02527956f, -0.06197646f, -0.01119078f, 0.16687199f, -0.12504598f, 0.09048430f, 0.09551834f, 
    0.00872184f, -0.12765519f, -0.04479586f, -0.23444328f, -0.06792062f, 0.10930070f, -0.02097267f, 0.01293306f, 
    -0.02642833f, 0.04264789f, 0.08175727f, -0.06201535f, 0.03969072f, -0.16244461f, -0.00689029f, 0.11849863f, 
    -0.01422445f, -0.10463960f, -0.04350084f, -0.06508981f, 0.04224497f, -0.00162961f, -0.02397384f, 0.03134568f, 
    0.11930004f, 0.02525701f, 0.02603664f, 0.08628904f, -0.05151356f, 0.01281494f, 0.06857669f, 0.01453092f, 
    0.02976930f, -0.00187767f, -0.05281935f, 0.03815906f, 0.06968923f, -0.01345968f, -0.03645103f, 0.11618983f, 
    -0.16212653f, -0.07356933f, -0.24187830f, -0.26371282f, 0.04861668f, 0.19084702f, 0.06815872f, 0.07877249f, 
    -0.04826150f, 0.05967638f, -0.00908964f, 0.03337434f, -0.09964722f, 0.02542676f, -0.01359376f, -0.13389793f, 
    -0.12194840f, 0.04302192f, -0.03835793f, 0.08106497f, -0.70321476f, -0.19295180f, -0.06081824f, 0.31596163f, 
    -0.18091902f, -0.03490577f, 0.13627215f, -0.06341166f, -0.00085795f, 0.07776950f, 0.07168587f, -0.06094810f, 
    0.04883396f, 0.06622089f, -0.00593092f, 0.01856699f, -0.01928871f, -0.00901070f, 0.13029544f, 0.05260407f, 
    -0.10747196f, -0.01058283f, 0.03087725f, 0.01110560f, -0.05305222f, 0.10947285f, -0.00266107f, -0.02057290f, 
    -0.05411610f, -0.15773334f, 0.12855305f, -0.10156487f, -0.02605716f, -0.03894344f, -0.10871407f, -0.03478316f, 
    -0.02665052f, -0.11537865f, -0.04871286f, 0.01361058f, -0.10259090f, -0.28972185f, 0.07417604f, -0.27608597f, 
    -0.09137339f, -0.11199904f, -0.08068217f, 0.05307239f, 0.06502203f, 0.06565843f, 0.00006095f, -0.03847772f, 
    0.02670120f, 0.01496330f, 0.05313457f, 0.03178450f, 0.00509540f, -0.05998779f, -0.01044598f, -0.07524344f, 
    0.14732674f, 0.01631723f, 0.15413201f, 0.10326674f, -0.29575518f, -0.07124756f, -0.17882372f, -0.17026527f, 
    0.11045659f, -0.13931705f, -0.00951531f, 0.07408936f, 0.03837521f, 0.05702264f, -0.01508992f, 0.05764285f, 
    -0.00486542f, 0.01350329f, -0.00223913f, 0.07345752f, -0.40552837f, -0.08744635f, 0.07556232f, 0.11575586f, 
    -0.34436291f, -0.16725494f, -0.12030744f, -0.10622206f, -0.11595657f, 0.16386601f, 0.01174970f, -0.00244196f, 
    -0.00477962f, -0.02219938f, -0.01440600f, -0.06460508f, -0.04107043f, 0.07536235f, -0.04747166f, -0.12225225f, 
    0.07729702f, 0.46040693f, -0.50238705f, -0.04116984f, -0.07109199f, 0.08143470f, 0.03063403f, 0.09499361f, 
    -0.10770485f, 0.24622841f, -0.01882572f, 0.03551229f, -0.00307574f, -0.01654010f, -0.04880149f, 0.00741623f, 
    -0.00135786f, -0.09548583f, -0.02460601f, -0.08910751f, -0.25430414f, 0.06542461f, -0.08201349f, -0.17995898f, 
    0.05080712f, 0.11864728f, 0.00696538f, 0.06552751f, 0.03560372f, -0.12597615f, 0.03397809f, -0.05334795f, 
    -0.01529908f, 0.12781523f, 0.10568761f, 0.03683583f, -0.03731209f, 0.03311824f, 0.00064035f, -0.06564531f, 
    0.18052571f, -0.14127584f, -0.60089064f, 0.15243252f, -0.24506642f, 0.10815419f, -0.12307334f, 0.06009905f, 
    0.07006466f, 0.16382338f, 0.04819504f, 0.02375125f, -0.00392050f, 0.02602065f, -0.01494629f, -0.06569851f, 
    0.04230952f, 0.05869600f, 0.07986666f, 0.05284772f, 0.19629279f, -0.61969763f, -0.05402093f, -0.09645433f, 
    0.11890081f, 0.07545759f, -0.02495047f, 0.14458033f, -0.05239312f, 0.12960385f, 0.01370483f, -0.04859371f, 
    -0.01112813f, 0.02225215f, 0.01528668f, -0.04246515f, -0.02583140f, 0.10992865f, -0.03924167f, -0.03148020f, 
    -0.09875624f, 0.16467729f, 0.09447365f, 0.28036311f, 0.13478945f, -0.02818916f, -0.00647312f, -0.12881435f, 
    0.01740451f, -0.15289484f, 0.01785693f, 0.05292230f, 0.09116898f, 0.06879649f, 0.04001649f, 0.06837466f, 
    -0.04003063f, -0.04018447f, -0.02155438f, -0.02660023f, -0.19916482f, 0.11018939f, -0.19548950f, -0.13910371f, 
    -0.09439056f, 0.10590288f, -0.06013747f, 0.07619348f, -0.00150195f, -0.01034958f, 0.07892729f, -0.00709049f, 
    -0.00194946f, 0.00058190f, 0.07048687f, -0.06728286f, 0.04276474f, -0.00506887f, 0.06462446f, 0.00064725f, 
    -0.26419845f, 0.32313663f, 0.12042865f, -0.44074473f, -0.31011596f, 0.07102569f, -0.27695122f, 0.03420754f, 
    0.00768801f, 0.05542374f, -0.06743692f, 0.07359341f, -0.02937566f, -0.06431553f, 0.05726667f, -0.04988432f, 
    -0.02126071f, 0.04274792f, 0.03615106f, -0.09872168f, 0.01367909f, -0.08115761f, 0.23569097f, -0.07889040f, 
    -0.16562143f, 0.10441953f, -0.17083417f, -0.07525622f, 0.05140117f, -0.03559459f, -0.02406348f, 0.10266811f, 
    0.06914447f, 0.03462385f, 0.06069816f, 0.02328374f, -0.04261603f, -0.03497188f, -0.02753706f, 0.07137388f, 
    -0.28890690f, -0.40360963f, -0.14582013f, -0.04416167f, -0.12361249f, -0.23674408f, 0.07627852f, 0.00476359f, 
    -0.13651177f, 0.12554409f, 0.01912801f, -0.00131905f, 0.01157402f, -0.02192089f, -0.05950458f, 0.08242831f, 
    0.03561033f, -0.01551594f, 0.05313080f, 0.01721951f, -0.59928614f, -0.07503118f, 0.30167502f, 0.23246481f, 
    -0.54513693f, 0.22331597f, -0.25885448f, -0.07065353f, -0.13068590f, 0.05523326f, 0.07949230f, -0.01243544f, 
    0.04853303f, 0.06263988f, 0.02804422f, -0.06336670f, -0.02642573f, -0.00981468f, 0.03480563f, -0.04083678f, 
    -0.08353533f, -0.09884477f, -0.17833388f, -0.01432171f, 0.08840922f, -0.01173235f, 0.10997292f, 0.12045471f, 
    0.01554630f, -0.07454155f, 0.00357945f, -0.00631467f, -0.00857118f, -0.05560867f, 0.04473595f, 0.08082811f, 
    0.09597090f, -0.06711262f, -0.01641271f, 0.03337626f, -0.02281440f, -0.07144079f, 0.17086715f, 0.40898469f, 
    -0.76754391f, 0.15713252f, -0.23003134f, -0.30985910f, 0.07181344f, -0.04211971f, 0.00955762f, 0.03136672f, 
    0.07377848f, 0.08596157f, 0.03800783f, -0.00482898f, 0.02056783f, -0.01361555f, 0.01216710f, 0.04223852f, 
    0.01619283f, -0.02168461f, -0.32440951f, -0.04094892f, 0.08386293f, 0.01548772f, -0.08617959f, 0.04542027f, 
    -0.09345885f, 0.18302594f, 0.00769125f, 0.02132713f, 0.00231521f, 0.07810946f, 0.03546802f, 0.03961458f, 
    0.13317609f, 0.12577806f, 0.00995769f, 0.15921484f, 0.04450545f, 0.11062308f, 0.28515485f, -0.04325359f, 
    -0.03999006f, -0.03033267f, 0.01880486f, -0.15330318f, -0.10085700f, -0.03097611f, -0.03240858f, 0.01701612f, 
    0.01436596f, 0.01560839f, 0.05015970f, -0.06287447f, 0.02150555f, -0.03582286f, -0.03986370f, -0.04722069f, 
    -0.17344160f, -0.01635021f, -0.05786418f, 0.00662011f, 0.12314857f, -0.00515691f, 0.09064680f, 0.12429456f, 
    0.00043347f, -0.03887142f, 0.13860878f, 0.16894475f, 0.10474037f, -0.07761608f, -0.03521137f, 0.16759722f, 
    0.04833146f, 0.03057416f, 0.04239364f, 0.08339100f, -0.10306049f, 0.03783667f, -0.04053267f, 0.46993792f, 
    -0.71045393f, -0.13207917f, 0.06904350f, -0.14205013f, 0.04732735f, 0.02080759f, 0.08191746f, -0.01848207f, 
    0.03326867f, 0.01669060f, -0.02356372f, 0.01938651f, 0.07794584f, 0.09001397f, 0.02621984f, -0.00690951f, 
    0.02115122f, -0.14007814f, 0.09125303f, 0.16987880f, 0.13730821f, -0.19866224f, 0.16119498f, -0.23032504f, 
    0.05076181f, -0.05295141f, 0.05815895f, -0.09916493f, 0.10239041f, -0.08033559f, 0.06887810f, 0.12098696f, 
    0.06724132f, -0.04312196f, -0.11513643f, 0.02068670f, -0.11533241f, 0.07653458f, -0.41348016f, -0.18817450f, 
    0.09932828f, -0.04675968f, 0.02872813f, 0.13809542f, -0.05180718f, 0.07613616f, -0.04655538f, 0.02668472f, 
    -0.04171471f, -0.00550420f, 0.03295652f, 0.00400961f, 0.09865899f, -0.01095567f, -0.02826843f, -0.00479663f, 
    0.16410297f, 0.14481932f, 0.17654525f, -0.11031930f, -0.06291215f, -0.04013638f, 0.07488418f, -0.02737610f, 
    0.07424209f, 0.13362059f, -0.05811942f, 0.03697431f, 0.04438744f, -0.03197164f, 0.05890323f, 0.01486711f, 
    0.00588619f, -0.06944877f, -0.13323492f, -0.09901568f, -0.13578886f, -0.36621740f, 0.01011578f, -0.13880000f, 
    0.09155463f, -0.16990557f, 0.13170066f, -0.03194810f, -0.16886361f, -0.07492220f, -0.00734776f, -0.02496420f, 
    -0.02941023f, -0.01958413f, -0.04129679f, 0.05405703f, -0.03396276f, -0.02480401f, -0.24910025f, -0.07959222f, 
    -0.43920723f, -0.03206186f, -0.25369945f, -0.10516313f, 0.20394437f, -0.02811795f, 0.06188600f, 0.04340250f, 
    -0.30888909f, 0.08727054f, 0.14799538f, -0.01538707f, 0.12042305f, -0.05699114f, -0.02412982f, 0.03947319f, 
    0.01507737f, -0.02827894f, -0.05062912f, -0.03250651f, 0.04900941f, -0.09138959f, 0.16738695f, 0.04019093f, 
    0.07765984f, 0.03778312f, 0.06024579f, -0.12220827f, -0.04521509f, -0.00089711f, -0.01120025f, 0.11833001f, 
    0.07707277f, 0.04016319f, 0.01894744f, -0.01137391f, -0.02956442f, -0.10349777f, -0.00944429f, 0.10386948f, 
    -0.09027918f, 0.17785430f, -0.25386187f, 0.03059643f, -0.12368786f, 0.00037697f, -0.05554626f, 0.11455204f, 
    -0.03583280f, 0.00071372f, 0.05671002f, -0.04961841f, 0.00781525f, -0.08877074f, -0.13312630f, 0.02623615f, 
    -0.01150982f, -0.00015647f, -0.00253319f, -0.04801030f, -0.23341502f, -0.21845637f, -0.00699932f, 0.20392458f, 
    -0.13009572f, -0.00071382f, -0.19122928f, 0.01130809f, 0.00257226f, 0.13423184f, 0.02665780f, 0.05758773f, 
    0.08652117f, 0.06824391f, -0.00862090f, -0.07760002f, 0.05257800f, 0.14700563f, 0.16592498f, 0.20515595f, 
    -0.58724988f, 0.07823476f, -0.10649604f, 0.14550304f, 0.15820701f, -0.00713893f, -0.04632017f, -0.15685879f, 
    0.09581435f, 0.00600482f, 0.05744704f, -0.00645041f, 0.02984420f, -0.01220072f, -0.03178138f, 0.13986538f, 
    -0.14798744f, -0.03624110f, 0.00604009f, -0.04835488f, 0.09135833f, 0.05262840f, 0.20262381f, 0.03600379f, 
    -0.04725810f, 0.07309382f, -0.04232619f, -0.11945914f, -0.07341488f, -0.01720930f, 0.07028868f, 0.04958010f, 
    0.11179650f, -0.01302465f, 0.00103950f, -0.01214045f, -0.10495708f, -0.07326099f, -0.00453041f, -0.02207067f, 
    -0.30307624f, -0.11490681f, -0.25179961f, 0.05806067f, 0.07643946f, -0.05333221f, 0.08823512f, 0.05935874f, 
    0.08526422f, -0.30110744f, -0.02474541f, 0.01988214f, -0.05237122f, -0.08345839f, 0.01089016f, -0.03678693f, 
    0.04836537f, -0.09827866f, 0.01754477f, 0.02293669f, 0.13705507f, -0.30542001f, 0.45027792f, -0.43299606f, 
    -0.48286787f, 0.00962031f, -0.12608922f, -0.09572212f, 0.03120306f, 0.12774524f, -0.01824815f, 0.04888798f, 
    0.02263542f, 0.02535857f, -0.02379765f, 0.02314739f, -0.01166995f, -0.01867988f, -0.06369852f, -0.06491839f, 
    0.02260971f, 0.09040218f, -0.22518249f, -0.17665052f, -0.02566896f, 0.15197760f, 0.04435285f, 0.15088597f, 
    0.02734327f, 0.13449843f, 0.05239547f, -0.05296389f, -0.07557255f, -0.05856675f, -0.02290038f, -0.00162497f, 
    0.02829005f, -0.00302053f, -0.00408757f, -0.10778783f, 0.01084979f, -0.37135404f, -0.03170395f, -0.02976041f, 
    0.14536515f, 0.00260872f, 0.02041466f, 0.06982878f, 0.04287361f, 0.07087361f, -0.05105885f, 0.00463377f, 
    0.01081990f, 0.00005940f, -0.04995748f, -0.00366505f, 0.13292794f, 0.08304428f, -0.01965186f, 0.06768621f, 
    0.07206258f, -0.03552745f, 0.20244531f, -0.07647800f, 0.03796961f, 0.05551884f, 0.01096359f, -0.13036779f, 
    0.05814229f, 0.01902232f, 0.04148708f, -0.00121515f, 0.07472918f, 0.02139149f, 0.06624309f, 0.04983215f, 
    -0.03089857f, -0.19035441f, -0.12648359f, 0.01543678f, 0.10680223f, -0.03724261f, 0.06159063f, -0.09976475f, 
    -0.18735884f, -0.28008947f, 0.09785969f, 0.03741785f, 0.03596771f, 0.09722834f, -0.03176469f, -0.03942826f, 
    0.03103192f, -0.00759972f, 0.05041797f, 0.01721594f, 0.00315571f, -0.01608185f, -0.10959382f, -0.18601356f, 
    -0.05321520f, 0.22192554f, -0.56624657f, 0.07870200f, 0.03087712f, 0.04186573f, 0.08710802f, 0.21608567f, 
    0.06780341f, 0.16790925f, 0.04022727f, -0.00126263f, -0.04373346f, 0.02717490f, -0.03883468f, 0.07712539f, 
    0.12483132f, -0.09120663f, -0.00714471f, -0.01100555f, -0.04570853f, 0.27598748f, -0.59489936f, 0.12628542f, 
    -0.02996400f, 0.14568755f, 0.07467977f, 0.16153912f, 0.01341175f, 0.06652166f, 0.03870707f, -0.02607970f, 
    -0.02987660f, -0.04762392f, -0.03220541f, 0.05543769f, -0.00875438f, -0.08257975f, 0.04717816f, 0.01280438f, 
    -0.17418543f, -0.01630100f, -0.24173568f, 0.06052365f, 0.01478001f, -0.02417509f, 0.06160770f, -0.09117623f, 
    -0.01739250f, -0.01645262f, 0.00155319f, 0.05690937f, -0.00803129f, 0.06770020f, 0.01659780f, 0.06600760f, 
    -0.04964598f, -0.11519535f, -0.12601568f, -0.16403776f, -0.20646615f, 0.06857374f, -0.29436091f, 0.09971659f, 
    0.01309783f, 0.01043120f, -0.07845070f, -0.03081267f, -0.10473523f, -0.05915502f, -0.00848007f, 0.08935804f, 
    0.09653639f, -0.05012186f, -0.01816391f, -0.05058263f, -0.02935642f, -0.14809150f, 0.01515559f, -0.10632638f, 
    -0.03090976f, -0.17035741f, -0.12504217f, 0.12321974f, -0.23401983f, -0.10058601f, -0.08522303f, -0.05537923f, 
    -0.07260939f, -0.01674500f, -0.11179851f, 0.03987026f, 0.00794348f, 0.01326325f, -0.04410593f, -0.01596329f, 
    0.02940967f, 0.03225548f, 0.05608498f, -0.02232461f, 0.37574378f, -0.15843706f, 0.24290660f, -0.15097418f, 
    -0.01344101f, -0.08851013f, 0.13332848f, 0.09884521f, 0.15214913f, 0.10259704f, -0.05622414f, 0.02726711f, 
    -0.15988737f, -0.09326738f, -0.13782592f, -0.04904253f, 0.01583778f, 0.12344784f, 0.17989834f, -0.05630134f, 
    -0.37497938f, -0.13212588f, 0.12782060f, 0.06220267f, 0.01244793f, 0.02567165f, -0.07834397f, 0.06070623f, 
    0.23339228f, 0.04604253f, -0.05245645f, -0.03319777f, 0.00554269f, 0.07305263f, -0.00591900f, 0.03664230f, 
    0.01728527f, 0.04000316f, 0.19530390f, 0.07653879f, -0.30236083f, 0.17873362f, -0.22234373f, 0.30481395f, 
    0.11717055f, 0.02174382f, -0.01610347f, 0.07538937f, 0.02980519f, 0.01012878f, 0.09781423f, 0.00752930f, 
    -0.09657137f, -0.03170155f, 0.01705301f, -0.04839437f, -0.09339116f, -0.08125868f, -0.08860753f, -0.02914151f, 
    -0.28127813f, 0.03637359f, -0.08741249f, 0.12494145f, 0.02551334f, -0.19525608f, 0.07399076f, -0.12911768f, 
    -0.01774291f, 0.06227157f, -0.03859261f, -0.14910753f, -0.06976409f, -0.04840409f, -0.04581993f, 0.05143858f, 
    -0.00037301f, -0.00977727f, 0.11693499f, 0.11533633f, -0.10224321f, -0.18854435f, 0.13554448f, -0.11302767f, 
    -0.10039400f, -0.03451050f, 0.01195358f, -0.07266392f, 0.04425726f, 0.01256974f, -0.08047253f, -0.05256243f, 
    -0.06521734f, -0.02050532f, -0.00563331f, -0.05770462f, 0.15720442f, 0.08713547f, 0.05912148f, 0.02581598f, 
    -0.31944993f, -0.08329076f, 0.04726323f, -0.11445078f, 0.04296960f, 0.03812078f, -0.05325449f, 0.11858105f, 
    -0.07466205f, 0.11143811f, -0.02623517f, 0.08098313f, 0.02598709f, 0.08803008f, 0.01966080f, 0.04589114f, 
    -0.00605289f, 0.03168798f, 0.05196599f, 0.09690470f, 0.25690061f, -0.30154216f, 0.24233063f, 0.09164372f, 
    -0.02393742f, -0.01706951f, -0.05440489f, 0.05074487f, 0.01042964f, -0.06642409f, 0.06072253f, -0.02312649f, 
    -0.09999218f, 0.06913001f, -0.05724900f, -0.09303354f, 0.05636817f, 0.04185541f, -0.10310441f, -0.03164958f, 
    -0.10820489f, -0.00736411f, 0.13472806f, 0.04351543f, 0.07215627f, -0.04012608f, 0.04025798f, -0.12863486f, 
    0.05963841f, -0.02401092f, 0.00367902f, 0.00981174f, -0.07330541f, 0.05970760f, 0.01539571f, 0.05351325f, 
    0.03085879f, 0.05575990f, 0.10203198f, 0.09906456f, -0.09218231f, 0.42541161f, -0.03792036f, -0.00117162f, 
    0.03552655f, 0.14327252f, -0.14605621f, -0.05819302f, 0.01569363f, -0.13375068f, -0.25196820f, 0.16120842f, 
    -0.09047892f, -0.14290896f, -0.12934209f, -0.02390133f, -0.07675519f, -0.08923342f, -0.00358664f, -0.06247076f, 
    0.00177364f, -0.23935930f, 0.21859238f, -0.04391507f, -0.04636127f, -0.04310853f, 0.08386900f, 0.05183389f, 
    0.07898937f, -0.04218270f, -0.01476844f, -0.07917400f, -0.02180052f, -0.07775618f, 0.05884061f, -0.07898165f, 
    -0.01563788f, 0.14135544f, 0.00063434f, 0.11574706f, -0.08616984f, -0.12445264f, 0.29367304f, 0.15764321f, 
    0.06595754f, 0.03069452f, 0.04699200f, 0.09545925f, -0.10985171f, -0.11623755f, 0.02215103f, 0.02454921f, 
    -0.00307610f, 0.02632385f, -0.02596569f, -0.09092095f, -0.09393146f, 0.11694526f, -0.17319579f, -0.16276069f, 
    -0.03149016f, -0.10938529f, -0.07742383f, -0.07361744f, -0.04919978f, 0.02692303f, 0.03027209f, 0.03674540f, 
    -0.01810327f, -0.05239162f, -0.00215553f, 0.02467729f, -0.11956439f, -0.13450228f, -0.16516267f, 0.01158895f, 
    -0.13823806f, 0.04065404f, -0.11162153f, -0.10115824f, -0.33014292f, 0.00035795f, -0.06612485f, -0.04416007f, 
    0.10207645f, -0.01875189f, -0.00035097f, -0.02305434f, -0.08443541f, -0.03664989f, -0.01139861f, 0.00858375f, 
    0.05518503f, 0.05730531f, -0.00432770f, 0.02456966f, 0.04633984f, -0.12715667f, 0.06089009f, 0.05229204f, 
    -0.09225824f, 0.12912028f, -0.13477466f, 0.10994058f, -0.00763648f, -0.01710822f, -0.00652241f, 0.03894290f, 
    0.00511394f, -0.06455864f, 0.10492174f, -0.00113250f, -0.05280911f, 0.01271312f, 0.06113010f, -0.00828970f, 
    -0.06303369f, -0.03778179f, 0.03069660f, -0.05855124f, 0.18135694f, -0.06350493f, 0.20990983f, -0.17358240f, 
    -0.00454120f, -0.08456456f, 0.03336711f, 0.04099935f, 0.04633057f, -0.01562368f, 0.00139466f, -0.00430736f, 
    0.02693645f, -0.02709563f, 0.10913179f, 0.04908354f, -0.04756958f, 0.04082244f, -0.02156565f, -0.02678083f, 
    0.02161444f, 0.03390327f, 0.00906972f, -0.03051413f, 0.08796997f, -0.04835346f, 0.02583968f, 0.04306113f, 
    0.09281763f, -0.05486470f, -0.06723214f, 0.00061645f, -0.00309808f, -0.04272006f, -0.00091159f, 0.02390276f, 
    0.04548791f, 0.03116862f, 0.10475693f, 0.09002610f, 0.03711280f, -0.06145490f, 0.14682123f, -0.04248044f, 
    0.02253547f, -0.03273331f, 0.04028498f, 0.12196851f, -0.09635953f, 0.03136343f, 0.02244726f, 0.02163373f, 
    -0.09827224f, 0.09944475f, 0.04998617f, -0.01533183f, -0.01370592f, 0.03731713f, -0.03315214f, 0.05230776f, 
    -0.01508912f, -0.20411405f, 0.13567980f, -0.20300922f, -0.19313285f, 0.00528791f, -0.07310688f, -0.15144739f, 
    0.00047626f, -0.03140934f, -0.08953273f, -0.05324217f, 0.03328915f, -0.02944509f, 0.01179176f, 0.07289442f, 
    0.04241145f, 0.05585954f, -0.04442535f, -0.08869760f, -0.01675479f, -0.18898168f, 0.05351998f, -0.15212026f, 
    0.00617259f, 0.05307756f, 0.04915058f, 0.14555545f, 0.13188058f, -0.03218670f, -0.08899185f, 0.03878183f, 
    0.03171846f, 0.01397425f, 0.11685043f, -0.01462736f, -0.05629098f, 0.16908160f, 0.00732948f, -0.10406248f, 
    -0.32705054f, 0.02865058f, -0.46911263f, 0.25507843f, -0.10402384f, -0.09052846f, -0.12233926f, -0.00277315f, 
    0.27384135f, 0.12852465f, -0.25611031f, 0.04117427f, 0.09128217f, -0.09472579f, 0.01010015f, 0.01411298f, 
    -0.09153023f, -0.01802037f, 0.19942231f, 0.16015325f, 0.11052751f, -0.09150839f, 0.08128655f, 0.16564904f, 
    -0.00300355f, -0.08680633f, -0.00056286f, 0.07688501f, -0.05021610f, -0.00742809f, -0.00816104f, 0.02084872f, 
    -0.08882405f, -0.00168427f, 0.02449326f, -0.07725077f, 0.00226214f, 0.04390845f, -0.00159529f, -0.02641315f, 
    -0.05615715f, -0.22908401f, 0.05017277f, -0.17460287f, -0.24174199f, -0.05162444f, -0.02852011f, -0.18166070f, 
    0.20101175f, -0.15243672f, -0.06484653f, 0.01649102f, 0.06846244f, -0.02931795f, -0.04968766f, -0.05507795f, 
    0.04481881f, 0.03563078f, 0.13266511f, 0.03404931f, 0.11354091f, -0.02174479f, -0.03252700f, -0.03665904f, 
    0.06950394f, 0.04145529f, -0.01793847f, -0.03656759f, 0.05563521f, -0.01523173f, -0.01704039f, -0.02794859f, 
    -0.01757616f, 0.06797704f, -0.01090558f, -0.01762173f, -0.19634672f, -0.04966220f, -0.13808928f, -0.05137074f, 
    -0.40928894f, -0.13432276f, 0.10530834f, -0.02600569f, -0.02798032f, 0.03328214f, 0.00387586f, 0.05008489f, 
    0.15646209f, 0.04335789f, -0.12185469f, -0.03211901f, -0.01701023f, 0.06334548f, 0.06505143f, 0.05105928f, 
    0.07831971f, 0.03365611f, 0.13983686f, -0.01341712f, -0.25881031f, 0.08823318f, -0.22404957f, 0.07683884f, 
    0.19801812f, 0.07590712f, -0.04960959f, 0.10940225f, -0.07507119f, -0.02004691f, -0.16262375f, 0.01286058f, 
    0.09497738f, -0.03472835f, -0.01903889f, -0.01194958f, 0.00400220f, -0.17025965f, 0.06473567f, 0.08562826f, 
    -0.12460242f, 0.11819104f, 0.05836096f, 0.11578422f, 0.02194185f, 0.07464388f, -0.04719348f, 0.00440546f, 
    0.03431311f, 0.04274160f, -0.02882541f, 0.06656834f, -0.01286619f, -0.07342550f, -0.13859172f, 0.03176431f, 
    -0.08587385f, -0.06849058f, -0.03888184f, -0.06788727f, -0.10421050f, -0.10205781f, -0.11729372f, -0.11294937f, 
    0.17494047f, -0.10850035f, -0.11103877f, 0.15192683f, 0.04436482f, 0.01427452f, -0.03453144f, 0.06816433f, 
    0.00105563f, 0.00468001f, 0.04829170f, 0.04915848f, -0.04835272f, -0.00110704f, 0.00638324f, -0.01826988f, 
    -0.28720009f, -0.19567731f, -0.13183686f, -0.07920694f, -0.06705101f, 0.07852725f, -0.07010319f, 0.19663589f, 
    -0.14696719f, -0.17243819f, -0.02930925f, 0.04125210f, 0.00908242f, -0.02634345f, -0.00847748f, 0.02385631f, 
    -0.04889788f, 0.05485557f, -0.06479164f, 0.00877530f, -0.06507591f, -0.09570040f, 0.16938692f, -0.00242734f, 
    -0.03401357f, -0.07424769f, 0.06162570f, -0.01657938f, 0.06124916f, -0.02710228f, -0.06662658f, -0.03771579f, 
    -0.09030830f, -0.04333751f, -0.00369814f, -0.00911759f, 0.16050722f, -0.00736228f, 0.05687301f, -0.04956813f, 
    -0.26423392f, -0.05110023f, -0.06576309f, -0.09097032f, 0.08726984f, 0.00382674f, -0.03262764f, 0.06326703f, 
    -0.07948647f, 0.04493143f, -0.06583975f, 0.07902681f, -0.05058049f, 0.10865715f, 0.01739064f, 0.09505529f, 
    -0.15503781f, -0.10045693f, -0.07373187f, -0.18080227f, -0.19880500f, 0.22753476f, -0.30617809f, 0.16289727f, 
    0.03102195f, -0.06480911f, -0.03706269f, -0.03911998f, 0.18368421f, 0.12851456f, -0.04502849f, 0.01663421f, 
    -0.11587733f, -0.03082717f, -0.01983665f, -0.14732416f, 0.11433164f, -0.31653300f, -0.01486988f, -0.00334209f, 
    0.27468878f, -0.09478774f, 0.04499114f, -0.10024448f, -0.06466206f, 0.04353621f, -0.05385490f, -0.02918772f, 
    -0.06454216f, -0.00857293f, -0.09581404f, 0.07115180f, -0.12456772f, -0.02473821f, 0.00290066f, -0.03309690f, 
    0.03191938f, -0.01705716f, 0.07545613f, -0.00313213f, -0.08920424f, -0.19433613f, -0.20821460f, -0.04357935f, 
    -0.25224176f, -0.08258086f, -0.08101577f, -0.01786854f, 0.06433530f, -0.04795662f, -0.09417313f, -0.03163650f, 
    0.03937417f, -0.08605645f, -0.04963803f, 0.03340219f, -0.02847683f, 0.00145460f, 0.08296923f, -0.07717299f, 
    0.01015943f, -0.13873731f, -0.15668637f, 0.38093686f, -0.10422079f, -0.09144533f, 0.02051085f, 0.15549339f, 
    0.10930022f, -0.11392844f, -0.01625720f, -0.09903450f, 0.06963737f, 0.12772326f, 0.14909241f, 0.03408307f, 
    -0.04558064f, 0.02314512f, 0.06447564f, 0.13069747f, -0.17007515f, 0.12678654f, 0.00030182f, 0.02504504f, 
    -0.04691782f, -0.00745832f, -0.00063805f, -0.11157851f, 0.05971080f, 0.05553467f, -0.05506458f, -0.05198569f, 
    -0.01095516f, -0.05344245f, 0.02452014f, -0.02693420f, -0.02505300f, 0.02399072f, 0.05304037f, -0.01889146f, 
    -0.08490653f, 0.08496135f, 0.04512821f, 0.06059142f, 0.18740296f, -0.04083847f, -0.04481025f, 0.11782255f, 
    -0.16143008f, 0.02902909f, -0.04044092f, 0.06359848f, 0.09322126f, 0.08701643f, 0.02703865f, 0.03985173f, 
    -0.06670667f, -0.17058678f, -0.18618973f, -0.02082860f, 0.11223290f, 0.00885001f, 0.14777254f, -0.16586401f, 
    0.09615041f, -0.12125152f, 0.09989168f, 0.20006895f, 0.19647262f, -0.02990837f, -0.08234677f, 0.01287263f, 
    -0.06908000f, -0.04619889f, 0.02832769f, 0.06377039f, 0.02039331f, 0.08232186f, 0.13057929f, 0.00606202f, 
    -0.01460945f, -0.09499145f, 0.06758644f, 0.00039942f, 0.09000577f, 0.05837085f, -0.01000839f, -0.07025313f, 
    -0.02856079f, 0.01442826f, -0.07953604f, 0.01022995f, 0.05196515f, -0.00826578f, 0.02153827f, 0.08958670f, 
    -0.03026268f, -0.02251915f, -0.03885436f, 0.07484347f, -0.31279469f, -0.04897267f, -0.02746760f, -0.08688255f, 
    0.00793928f, -0.03838510f, -0.05177009f, -0.18487264f, 0.05582340f, -0.02329127f, -0.04305809f, 0.03777052f, 
    -0.03553193f, -0.11376214f, -0.11085687f, 0.01098369f, 0.00231755f, -0.00285092f, 0.02172872f, -0.02384472f, 
    0.00881101f, -0.08331223f, -0.17082122f, 0.03060451f, -0.03574909f, -0.02759770f, -0.01793860f, 0.20209399f, 
    -0.15670052f, -0.10597605f, 0.05641783f, 0.06072082f, -0.01658590f, 0.00357329f, -0.00147255f, 0.06470004f, 
    -0.11145862f, -0.04660227f, -0.31797579f, -0.18662614f, -0.25335896f, 0.05376402f, -0.03316598f, 0.20660719f, 
    0.01053892f, -0.02079337f, -0.05840347f, -0.12960728f, 0.22645301f, -0.02384816f, 0.04665747f, -0.15524527f, 
    0.04473926f, 0.07103205f, 0.01309793f, 0.07587745f, 0.08443987f, -0.23297526f, 0.20269817f, 0.13050504f, 
    -0.03098301f, -0.39656377f, -0.16015969f, -0.25744748f, -0.15935753f, -0.11683798f, -0.09455026f, -0.01821969f, 
    -0.08391172f, -0.02926516f, 0.06248158f, 0.06539820f, -0.02860286f, 0.00233603f, 0.08287740f, 0.13468139f, 
    -0.01345223f, 0.04840549f, -0.04091565f, -0.03010196f, -0.21103674f, -0.00349548f, -0.18757182f, -0.05536397f, 
    0.03360532f, 0.00820534f, -0.17423999f, -0.06512535f, 0.01921912f, 0.07493721f, -0.07272322f, 0.12271642f, 
    0.03372119f, -0.18258598f, -0.10643865f, 0.04720011f, -0.00775460f, 0.02862905f, -0.02302880f, -0.06643845f, 
    0.04096350f, -0.01180473f, 0.30772212f, 0.07723269f, 0.00430589f, 0.01724498f, -0.12286403f, 0.04037632f, 
    0.00093825f, 0.01741939f, -0.15734863f, 0.01384781f, -0.16801549f, -0.01130583f, 0.02891519f, -0.06087193f, 
    -0.13326067f, 0.02076709f, -0.10220074f, -0.10209168f, 0.04833532f, -0.11461721f, -0.37062573f, 0.22302417f, 
    -0.06514110f, -0.05976228f, -0.07070224f, 0.20057914f, -0.05808573f, -0.08612684f, -0.08687147f, 0.02959051f, 
    -0.06206294f, 0.02254284f, 0.09631588f, 0.04258406f, -0.13443956f, 0.06969824f, -0.09787109f, 0.04434926f, 
    -0.03397928f, 0.00027822f, -0.07598878f, 0.05987668f, -0.03716334f, -0.01244001f, -0.01153610f, 0.05636203f, 
    0.01362507f, -0.02147279f, -0.00120747f, -0.03702736f, 0.11233369f, -0.00155984f, 0.01018829f, -0.01555019f, 
    -0.00970046f, 0.12513675f, 0.09273047f, 0.18198982f, -0.14624800f, 0.09824998f, -0.13716212f, 0.06040765f, 
    0.03250476f, 0.02647230f, 0.04458664f, -0.04712981f, -0.00768461f, 0.15951318f, -0.10133725f, 0.02877945f, 
    -0.00053832f, 0.00308292f, 0.07484102f, -0.07026108f, 0.23939852f, -0.13049780f, 0.01451250f, 0.05754911f, 
    0.43560413f, -0.07138889f, 0.26923653f, 0.12584163f, 0.04663957f, -0.03952806f, 0.16942240f, 0.18887453f, 
    0.14668612f, 0.07888799f, -0.01246909f, 0.11058471f, 0.16236520f, -0.06900372f, 0.08740738f, -0.04938228f, 
    -0.08759958f, -0.02322726f, 0.10664519f, -0.07974493f, -0.25260198f, 0.05691000f, -0.02693409f, -0.04185340f, 
    -0.11074963f, -0.10568549f, 0.02255830f, -0.00356008f, -0.07080473f, 0.05389978f, -0.12154207f, -0.03146462f, 
    0.00580288f, -0.09964792f, -0.10345199f, -0.01671939f, 0.05498241f, 0.09068073f, 0.04572627f, 0.27211988f, 
    -0.21166390f, -0.13591662f, 0.10162973f, -0.01497327f, 0.05185210f, 0.05901390f, -0.03701431f, -0.03316108f, 
    0.00323583f, -0.01990102f, -0.08190039f, -0.00632461f, -0.03509686f, 0.04340309f, 0.02351915f, 0.04173456f, 
    0.11854352f, 0.03073005f, 0.13087521f, -0.01121234f, -0.19939275f, -0.02518453f, -0.40832624f, 0.03527570f, 
    0.01011481f, -0.05572764f, 0.07246560f, -0.01689377f, -0.06030156f, -0.05371745f, 0.01118254f, 0.03882901f, 
    -0.00240642f, 0.00304949f, -0.02553379f, 0.09436309f, -0.12473372f, -0.15214664f, -0.13519518f, -0.24057841f, 
    0.41677669f, -0.29914322f, 0.30406892f, 0.01038545f, 0.10701438f, -0.12770294f, -0.00032098f, 0.02091202f, 
    -0.02262235f, -0.05136622f, -0.04995239f, 0.02818684f, -0.11041501f, 0.04779727f, -0.01245246f, 0.01482136f, 
    0.08861496f, 0.02704875f, 0.01875097f, -0.09726543f, 0.02256216f, 0.03255681f, 0.09491057f, 0.09063084f, 
    0.04915393f, 0.01103045f, 0.04056605f, -0.02455327f, 0.04715728f, 0.01373333f, -0.10529258f, -0.00455277f, 
    0.02131204f, -0.01422310f, 0.01349114f, 0.00467191f, 0.05768828f, 0.04979354f, 0.13809837f, 0.06612331f, 
    -0.16668494f, -0.36769864f, 0.17872094f, -0.05403757f, 0.00296354f, -0.07434460f, -0.05702664f, 0.04386338f, 
    0.05999904f, 0.00869361f, -0.10041637f, -0.07790926f, -0.16886818f, 0.17116252f, 0.06062781f, 0.10120526f, 
    -0.06425692f, 0.09236959f, -0.06418034f, 0.04989694f, -0.22558646f, 0.41453004f, -0.74304837f, 0.30818543f, 
    0.22492316f, -0.07803715f, -0.04365685f, -0.03244699f, 0.23905088f, 0.16422987f, -0.09462184f, -0.06211297f, 
    -0.02874759f, -0.02925029f, 0.10771910f, 0.07605568f, -0.00069782f, -0.28431341f, 0.20338227f, 0.10547756f, 
    -0.04333838f, -0.06036867f, 0.12056214f, -0.04061897f, -0.04057724f, 0.02769918f, -0.03113295f, 0.05116007f, 
    -0.02937304f, -0.04188694f, -0.05104789f, -0.02234846f, 0.06203515f, -0.03705131f, -0.01847111f, -0.10115720f, 
    0.01683327f, 0.13994874f, 0.04581418f, -0.00966279f, -0.04687551f, -0.01671637f, -0.03477573f, 0.04535547f, 
    0.01669535f, -0.09673273f, -0.00674051f, -0.01956110f, -0.00090179f, -0.09801616f, -0.01952676f, -0.07469623f, 
    -0.07792581f, 0.03305696f, 0.04141333f, -0.06340404f, -0.03800264f, -0.19991460f, -0.15668453f, -0.07248618f, 
    -0.22989535f, 0.10169803f, -0.15137161f, 0.13052586f, 0.04684651f, -0.07776076f, 0.02595290f, 0.01896441f, 
    0.07493272f, 0.11734386f, -0.10345653f, -0.07077748f, -0.02629102f, -0.06470497f, -0.03327479f, -0.04531986f, 
    0.01398818f, 0.04483165f, 0.11243279f, 0.19969465f, -0.13106132f, 0.12152881f, -0.15002623f, 0.02356274f, 
    0.07515703f, 0.06412067f, -0.01745243f, 0.05857997f, -0.03454797f, 0.04997237f, -0.03505738f, 0.00177628f, 
    0.02332040f, 0.01579825f, 0.00306198f, -0.04714650f, 0.06179945f, -0.20377004f, 0.05354239f, 0.05794758f, 
    -0.03606066f, -0.19665277f, 0.00697118f, -0.05424626f, 0.00714365f, 0.00810576f, -0.06340816f, 0.14353649f, 
    -0.05951119f, -0.03594180f, -0.08018547f, 0.06486788f, -0.02475218f, -0.04343034f, 0.00617976f, 0.02498441f, 
    -0.06812648f, 0.01262339f, -0.06817849f, -0.00974079f, -0.28335100f, -0.36097509f, 0.02095528f, -0.09774064f, 
    -0.00620415f, -0.03637436f, -0.07818519f, 0.11569621f, 0.09097448f, -0.03081349f, -0.10286306f, 0.11812855f, 
    -0.02057631f, 0.01463427f, -0.03012861f, 0.05899490f, -0.03485277f, 0.04798773f, 0.11688238f, 0.03046594f, 
    0.03599427f, -0.26554501f, -0.00368411f, -0.23419316f, 0.00926619f, -0.05280568f, -0.16441743f, 0.03952312f, 
    0.00514693f, -0.11681607f, -0.02339194f, -0.02322751f, 0.07271920f, -0.01790402f, -0.02272192f, 0.05984087f, 
    -0.03445234f, 0.03183494f, 0.10445260f, 0.03792410f, -0.16613951f, -0.10562090f, -0.21672152f, 0.13225016f, 
    -0.21326023f, -0.07130196f, 0.07187643f, 0.15284495f, -0.06143882f, 0.06048482f, -0.01279986f, -0.00299519f, 
    0.09009542f, 0.06885244f, 0.09415794f, 0.09612870f, 0.06162918f, 0.07467274f, -0.01987694f, 0.05140356f, 
    0.15401332f, -0.04981815f, -0.00178067f, -0.01945527f, -0.04622294f, -0.02065263f, 0.07087132f, -0.06503863f, 
    0.04293783f, 0.01236105f, -0.05920386f, 0.06347319f, -0.04466664f, -0.02507079f, -0.08456281f, 0.00236242f, 
    0.03975147f, 0.05571194f, -0.14851382f, -0.00131249f, 0.03768469f, -0.10920608f, 0.20385312f, -0.04852006f, 
    0.19426782f, 0.02897504f, 0.22382897f, -0.12259631f, 0.10174916f, -0.00365067f, 0.00649657f, 0.04853946f, 
    0.11566163f, -0.00468978f, 0.06432658f, -0.12115296f, -0.06959719f, -0.02922157f, -0.07108422f, 0.04688914f, 
    0.03778882f, 0.10906303f, 0.25987539f, -0.03533100f, -0.07752294f, 0.03201138f, -0.07543825f, 0.06754645f, 
    0.00748632f, -0.12606226f, -0.04509158f, 0.06521317f, -0.02059009f, 0.05982894f, 0.00636934f, 0.04851459f, 
    -0.10758872f, -0.09126555f, 0.00538687f, -0.11326012f, -0.40482607f, -0.56971729f, -0.00035243f, 0.35333335f, 
    -0.21214961f, -0.05933560f, 0.09779564f, -0.03322096f, 0.18812744f, -0.07274337f, -0.24868128f, -0.02787778f, 
    0.06670817f, 0.03725926f, 0.10848965f, 0.00063919f, -0.06896828f, 0.25531456f, 0.08353229f, 0.03546582f, 
    -0.07904930f, -0.15030096f, -0.04934467f, 0.25603780f, -0.01468683f, 0.01280748f, -0.02737483f, 0.04492318f, 
    0.08926060f, -0.02174789f, 0.05023173f, -0.08226421f, -0.05097029f, 0.03315341f, -0.06081708f, -0.00482346f, 
    -0.08075584f, 0.05684716f, -0.06835168f, -0.13938290f, 0.12252200f, 0.09361295f, -0.02282571f, 0.05876942f, 
    0.02456529f, -0.05848183f, 0.09290720f, 0.01256536f, 0.01651310f, -0.04112722f, -0.09997177f, 0.10199130f, 
    0.00666519f, 0.04884188f, 0.00754892f, -0.02032340f, -0.02105453f, 0.03753776f, -0.13988884f, -0.03830323f, 
    0.06736697f, -0.06084800f, 0.10527572f, 0.03170462f, 0.01540369f, 0.04424471f, -0.24061838f, 0.09884302f, 
    -0.22210503f, -0.15174231f, -0.00892076f, -0.00394443f, -0.01444301f, 0.03337953f, -0.08219570f, -0.02767400f, 
    -0.11143072f, -0.06132695f, -0.07196571f, 0.04373401f, -0.29680562f, -0.07987800f, -0.17199291f, -0.03284548f, 
    0.12005314f, -0.02122894f, 0.08796378f, 0.03002617f, 0.01712282f, 0.08348040f, -0.00604236f, 0.13255511f, 
    0.08067378f, -0.04789827f, -0.04332748f, -0.00262778f, 0.02338510f, 0.11404146f, 0.16126892f, -0.05311862f, 
    0.04928039f, -0.30946717f, 0.05020073f, 0.01653679f, -0.05276586f, 0.10991815f, -0.07188287f, -0.00278556f, 
    -0.03609492f, -0.06733731f, 0.02578239f, -0.00685336f, -0.04717436f, -0.06544045f, -0.06397859f, -0.01582569f, 
    -0.07100517f, 0.00216953f, -0.04067658f, -0.06197205f, -0.87483358f, 0.02441132f, -0.61028200f, 0.26534238f, 
    -0.51143765f, 0.18775287f, 0.00813792f, 0.07410387f, -0.11605525f, 0.11448733f, -0.11878601f, -0.13970509f, 
    -0.06139211f, 0.11445022f, -0.07073870f, 0.01644256f, -0.02813902f, 0.03365876f, -0.05217914f, 0.01028164f, 
    0.02735930f, -0.08010705f, -0.20941788f, 0.17826124f, 0.13397004f, -0.06669527f, 0.19554634f, -0.05532090f, 
    0.10905409f, -0.01437946f, -0.04403123f, 0.05176859f, 0.04292942f, 0.05083964f, 0.07836597f, -0.03848240f, 
    -0.01717248f, -0.01661323f, -0.06174960f, -0.07581223f, -0.26709956f, -0.08847096f, -0.45883140f, 0.30925706f, 
    0.22798929f, -0.09379533f, 0.16400802f, 0.10870606f, -0.13142660f, -0.07333679f, 0.03491924f, 0.08115114f, 
    0.04277918f, -0.04899646f, 0.01540959f, 0.16125080f, -0.02489118f, -0.04034211f, 0.09126437f, 0.16937092f, 
    -0.30904964f, -0.04421136f, -0.20267096f, 0.00205392f, -0.18898870f, 0.13168919f, 0.10142074f, 0.01924488f, 
    -0.15396100f, 0.01488909f, -0.03380124f, -0.03079028f, 0.10160498f, 0.14457165f, 0.06622148f, 0.00528671f, 
    0.05881346f, 0.01297476f, 0.01947545f, 0.10549756f, -0.07509098f, -0.14666881f, -0.17028552f, 0.00465687f, 
    -0.11700318f, 0.10236402f, -0.19491442f, -0.00335456f, -0.26876014f, -0.02879274f, 0.01686281f, 0.02285366f, 
    -0.01300278f, -0.02840144f, -0.05129914f, 0.02237550f, -0.05955575f, -0.00534024f, -0.08406498f, -0.07065877f, 
    -0.15196700f, -0.04882180f, -0.12400456f, 0.16170727f, -0.09672126f, -0.02027015f, 0.13417849f, -0.04032815f, 
    0.11808661f, -0.02798382f, -0.18269129f, 0.03360742f, 0.11448681f, 0.01510891f, 0.01514793f, 0.08176587f, 
    -0.03378348f, 0.06115377f, -0.03692516f, 0.16142339f, -0.03223957f, -0.09311996f, 0.00118268f, -0.16135308f, 
    0.18217453f, 0.03436686f, 0.11159198f, 0.07120856f, 0.03424311f, 0.05214068f, -0.05514168f, 0.11074671f, 
    0.02588217f, 0.07986636f, -0.01688787f, 0.10444805f, 0.09150932f, 0.05895108f, -0.13318419f, 0.04514595f, 
    -0.15949091f, -0.15152170f, -0.17490475f, 0.14111771f, 0.11133827f, -0.03245698f, -0.08290045f, -0.06911021f, 
    -0.08375793f, -0.01597905f, 0.01388975f, 0.06769670f, -0.03770405f, -0.08377238f, -0.10615066f, 0.00478531f, 
    -0.06771811f, -0.03306746f, -0.06714489f, -0.02277784f, -0.10041844f, 0.05482380f, 0.00135558f, -0.09963469f, 
    -0.00535162f, 0.04722107f, -0.03427185f, 0.11665910f, -0.08797623f, 0.03066155f, -0.08098506f, 0.00479069f, 
    -0.07315827f, -0.02724867f, -0.07089859f, -0.00046163f, 0.02585767f, -0.00286288f, -0.03316196f, 0.08289467f, 
    0.04416087f, -0.00771197f, -0.12859225f, 0.11893115f, -0.03312329f, -0.05629409f, 0.07763264f, -0.05085410f, 
    0.14607908f, -0.03064778f, -0.16654126f, -0.06615224f, 0.06120092f, 0.01755555f, -0.04743193f, 0.04072484f, 
    0.02429509f, 0.02487998f, -0.14160001f, 0.00056294f, 0.19346069f, -0.14897542f, 0.17794172f, 0.01647747f, 
    0.09321991f, 0.05359008f, 0.12197794f, -0.19319074f, 0.19638789f, 0.00467249f, -0.10617127f, 0.04973886f, 
    -0.03670050f, 0.06807791f, 0.07566366f, -0.00584528f, 0.01860756f, 0.02097929f, -0.00502086f, -0.04175758f, 
    0.01244727f, 0.07721383f, 0.15379727f, 0.21477503f, -0.22120595f, -0.07580611f, -0.02682407f, 0.02668950f, 
    0.07939047f, -0.10798526f, -0.10798052f, -0.08529191f, 0.00883497f, 0.02725695f, -0.00470822f, 0.03630228f, 
    -0.01624528f, 0.00173407f, -0.00656232f, -0.10668261f, -0.13194749f, -0.11987276f, -0.04561788f, 0.00264957f, 
    -0.03698639f, -0.00279505f, 0.01562159f, -0.05448193f, 0.04897864f, 0.00753972f, -0.00164912f, 0.07228339f, 
    0.03114948f, 0.07378178f, -0.00465988f, 0.04888493f, -0.04712513f, 0.03195608f, 0.04350347f, -0.00973807f, 
    0.19024381f, 0.24200681f, 0.11402937f, -0.04004957f, -0.19138746f, -0.01490630f, 0.02121891f, 0.03865386f, 
    0.10166582f, -0.03019349f, -0.04451998f, 0.00103458f, -0.03487020f, -0.01564791f, -0.01733870f, -0.01519631f, 
    -0.01729878f, 0.07180907f, 0.16214424f, -0.05913345f, -0.19301966f, -0.20141493f, -0.14881735f, -0.07478814f, 
    0.12571903f, -0.02055358f, 0.10818094f, 0.14913797f, -0.10571410f, 0.14006218f, 0.11843421f, -0.00275782f, 
    0.13683473f, 0.04640036f, 0.07841308f, 0.07670651f, 0.08789313f, 0.12789223f, 0.17361999f, -0.01329871f, 
    0.08578480f, 0.13371612f, 0.09889916f, 0.04842263f, -0.02902849f, -0.02530145f, 0.09872549f, 0.02210254f, 
    0.09103780f, -0.10653061f, -0.12244310f, 0.07695739f, 0.06981006f, -0.00790339f, 0.06063367f, 0.07998972f, 
    -0.09500653f, -0.00974992f, -0.03661958f, -0.12789522f, -0.05403850f, -0.11286513f, -0.11666323f, 0.30316564f, 
    -0.12748805f, -0.00525798f, -0.31497529f, -0.01303803f, -0.23511353f, 0.07718244f, -0.00462219f, -0.00885826f, 
    -0.06858321f, -0.05077689f, -0.04206542f, 0.04874901f, -0.00362413f, 0.06801717f, -0.01392398f, -0.06052500f, 
    -0.42890450f, -0.00634202f, 0.03493709f, 0.01480055f, -0.32320482f, 0.01038987f, 0.06417034f, -0.01218238f, 
    0.06409170f, 0.06317041f, -0.11443699f, -0.15041089f, 0.05238109f, -0.04622335f, -0.01334884f, 0.02469209f, 
    -0.10552431f, -0.01818719f, -0.04138595f, 0.06089762f, 0.05283272f, -0.14094923f, -0.06240440f, -0.55197334f, 
    -0.05484905f, -0.06163200f, -0.27621728f, -0.05764680f, 0.14827237f, -0.02764752f, 0.01584608f, 0.07625814f, 
    0.01887071f, -0.01149490f, -0.07023896f, 0.06392056f, 0.02427254f, -0.00970426f, 0.10478634f, -0.01588433f, 
    0.55755073f, -0.20530008f, 0.36318004f, 0.16481076f, -0.00377726f, 0.01489786f, -0.06156274f, -0.20033410f, 
    0.13495977f, -0.09901512f, -0.06543224f, 0.07041508f, 0.02368998f, 0.06602950f, 0.05399198f, -0.05285471f, 
    -0.01755068f, -0.00176401f, 0.13463669f, 0.08862144f, 0.22722046f, 0.09850900f, 0.04205657f, 0.02651398f, 
    0.07070740f, 0.00625781f, 0.08054073f, -0.01187809f, 0.02754175f, -0.02073131f, -0.13908646f, 0.11223196f, 
    0.08053091f, 0.04543465f, -0.07290401f, 0.01854711f, -0.02880409f, 0.02399733f, -0.04008538f, -0.02514586f, 
    0.13724960f, -0.28338635f, 0.19412346f, -0.06606437f, 0.13516170f, -0.01000422f, -0.34044042f, 0.13609909f, 
    -0.07991933f, -0.19803149f, 0.04512541f, -0.04596584f, 0.07158305f, -0.03323145f, 0.01243848f, 0.03922714f, 
    -0.05592715f, -0.06461030f, 0.07081022f, 0.02067583f, -0.09920517f, 0.13355389f, 0.10907222f, 0.31341034f, 
    -0.12006134f, -0.00222662f, -0.00637484f, 0.17068526f, 0.04476394f, 0.07070534f, -0.08897064f, 0.03257823f, 
    0.00024823f, -0.04122624f, 0.00356257f, 0.09057195f, 0.06669632f, 0.21698928f, 0.16907302f, -0.12345917f, 
    -0.24080315f, -0.10729916f, -0.16137591f, 0.04945732f, -0.05834493f, 0.01101549f, -0.00214172f, 0.04817067f, 
    -0.10916530f, 0.06576052f, 0.00624220f, -0.03697921f, 0.00921811f, 0.00274605f, 0.01790676f, 0.00138868f, 
    -0.10790159f, -0.07962661f, 0.00409051f, -0.05043899f, 0.23273174f, 0.04211357f, 0.24470793f, -0.00849357f, 
    -0.10033706f, -0.01393951f, 0.07838414f, -0.06039605f, 0.12048679f, 0.01566139f, -0.09158115f, 0.03347258f, 
    -0.02359094f, 0.00187319f, 0.00087753f, -0.01479072f, 0.08640424f, 0.01655916f, -0.06484704f, -0.02304422f, 
    0.22642283f, -0.31022480f, 0.35381269f, -0.03907468f, -0.00665549f, -0.09237666f, 0.02920976f, -0.00970540f, 
    0.10555895f, -0.09975219f, -0.07093556f, -0.00255689f, -0.11769992f, -0.01067798f, 0.10158076f, -0.11648144f, 
    0.10977894f, 0.13755356f, 0.08042726f, -0.16208284f, -0.31275004f, -0.04199126f, -0.20941019f, 0.24263625f, 
    -0.07824410f, 0.02786640f, 0.17128153f, 0.01529862f, 0.21050285f, -0.03048666f, -0.05318282f, -0.05009422f, 
    -0.01747462f, 0.00419342f, 0.00905228f, 0.01799322f, -0.00652874f, 0.06864067f, -0.04939195f, 0.09110676f, 
    -0.27997258f, -0.21078271f, -0.07306425f, 0.10994485f, -0.00120247f, 0.00502846f, -0.22255407f, 0.08815558f, 
    -0.13358712f, -0.07618026f, -0.02581352f, 0.06357034f, -0.04513599f, 0.14327332f, 0.03819686f, 0.01803877f, 
    0.01324461f, 0.08294866f, -0.01744169f, 0.10418943f, -0.01944790f, -0.31400862f, 0.17927445f, -0.40958014f, 
    0.09739739f, 0.08161804f, -0.12922634f, -0.31184253f, 0.15043697f, -0.05146329f, 0.01125901f, 0.09523173f, 
    -0.04204041f, 0.04018901f, -0.01115045f, 0.02493023f, 0.05580751f, -0.02619502f, 0.06123727f, -0.01894341f, 
    0.16467981f, -0.03568798f, 0.05724724f, 0.15929905f, -0.06778373f, -0.02173179f, 0.01221222f, -0.03380312f, 
    0.11099016f, -0.03251208f, -0.09263224f, -0.06891052f, 0.05079850f, 0.02986001f, -0.04097981f, 0.01058839f, 
    0.01106585f, 0.07155561f, -0.05412524f, 0.00516682f, -0.13247029f, -0.21195932f, -0.07890447f, -0.08899603f, 
    -0.61237389f, -0.06844882f, -0.01320750f, -0.17798929f, 0.00153373f, -0.02800564f, -0.04314766f, 0.00000253f, 
    0.06358735f, -0.03838421f, -0.04614302f, 0.02938891f, 0.00834812f, -0.02966021f, -0.00636407f, 0.03478712f, 
    0.08589389f, -0.30420616f, 0.01830134f, -0.03995696f, 0.19458415f, -0.07532621f, -0.17596605f, -0.07522202f, 
    0.02568682f, -0.08443909f, -0.01465758f, 0.04436251f, 0.05175845f, -0.02407564f, 0.00262396f, 0.09047382f, 
    -0.03062307f, -0.05173630f, 0.12679231f, 0.05553031f, -0.14060915f, -0.18175952f, 0.11844635f, 0.10446668f, 
    -0.04171677f, -0.10581607f, -0.04721767f, -0.02876383f, 0.09208092f, 0.03072536f, 0.01666961f, -0.12685998f, 
    -0.09009904f, -0.17773657f, 0.01463844f, -0.04091556f, -0.11995100f, -0.01452182f, -0.17551111f, -0.22631678f, 
    0.03226350f, 0.00131638f, 0.01733275f, -0.07696989f, -0.05331686f, -0.04649550f, 0.08726444f, -0.02210609f, 
    0.03345729f, -0.00625355f, -0.12601438f, 0.02911820f, 0.03126038f, -0.05388238f, -0.09350222f, 0.04069687f, 
    -0.01271036f, -0.02626893f, -0.13233028f, 0.00877402f, -0.10603780f, -0.22521332f, -0.16134948f, -0.16394016f, 
    -0.32807523f, -0.05856881f, 0.06214010f, 0.09300387f, -0.05660788f, -0.02075449f, -0.06313256f, 0.01923836f, 
    0.14839813f, 0.05808321f, -0.01802981f, -0.03747571f, 0.03867236f, 0.03893137f, 0.00057273f, 0.07737411f, 
    -0.53033632f, 0.08674114f, -0.18175085f, 0.10776882f, 0.00162181f, 0.06619418f, -0.00916466f, 0.06048207f, 
    -0.17697425f, 0.04327324f, 0.04816491f, -0.06584296f, 0.10824924f, 0.08890948f, -0.01275144f, 0.06029921f, 
    0.02541408f, 0.19786653f, 0.02416960f, -0.06255779f, 0.25120971f, 0.01439791f, 0.15150727f, 0.11086383f, 
    -0.13796628f, -0.07897051f, 0.01742872f, -0.11498478f, 0.11768700f, -0.05606459f, -0.09192446f, -0.05517660f, 
    -0.02535532f, 0.00255150f, 0.00414186f, 0.00138317f, 0.03615107f, 0.01892442f, 0.04346336f, 0.00489104f, 
    -0.13705902f, -0.03347783f, -0.09971417f, 0.23602417f, 0.10312692f, -0.20004721f, 0.00360027f, -0.01428752f, 
    -0.05080915f, -0.00917513f, -0.05478977f, 0.05734205f, -0.11576331f, -0.04479959f, 0.04498884f, -0.04435315f, 
    -0.06790577f, 0.15481433f, -0.13792183f, -0.20707904f, -0.20657597f, 0.19405949f, 0.05301818f, 0.21806844f, 
    -0.07541329f, -0.01193979f, -0.01467513f, 0.19226012f, -0.06371316f, 0.09352510f, -0.02772807f, -0.01158316f, 
    -0.06138065f, -0.01218144f, 0.13238269f, 0.00642880f, -0.17661084f, 0.11470690f, 0.08156323f, -0.26029316f, 
    -0.54329693f, -0.24641705f, -0.00524052f, -0.15424873f, 0.26474440f, 0.12421034f, 0.18516023f, -0.02134016f, 
    0.04278938f, 0.20192738f, -0.10829500f, 0.16931295f, -0.14928359f, 0.23211905f, 0.03603636f, 0.13342285f, 
    -0.06560253f, 0.07729105f, 0.02861842f, 0.06792267f, -0.11132900f, -0.00721444f, -0.26129580f, 0.21472032f, 
    0.01942636f, -0.11186301f, -0.05645534f, -0.01686232f, 0.01643114f, -0.07272602f, 0.02322790f, 0.02477635f, 
    -0.11103218f, -0.04156367f, 0.02965153f, 0.06691007f, -0.11316404f, -0.14841072f, -0.16979958f, -0.22618806f, 
    0.28783259f, -0.03178173f, 0.23670273f, -0.03539188f, 0.02082465f, 0.04173302f, 0.07207233f, -0.15582435f, 
    -0.04787105f, -0.11275829f, -0.10451468f, 0.08907785f, 0.05527362f, 0.09731680f, 0.01296223f, -0.04490137f, 
    -0.04613611f, 0.01581604f, -0.06351218f, -0.03905793f, 0.07570705f, -0.40189645f, -0.37817290f, -0.46001661f, 
    0.04597812f, -0.13512389f, -0.06619793f, 0.09477025f, -0.00672353f, -0.12116268f, -0.01323684f, -0.02560285f, 
    0.02503521f, -0.11650751f, -0.07495784f, 0.07938209f, -0.00528856f, -0.14368792f, 0.01887171f, -0.01581474f, 
    0.01280532f, -0.24187458f, -0.11974579f, -0.20660233f, 0.33554700f, 0.07383725f, 0.21065389f, 0.10129082f, 
    -0.06765254f, 0.00484486f, -0.07308276f, 0.06003205f, 0.10830045f, 0.06556563f, 0.13699552f, -0.11650108f, 
    0.07743578f, 0.01137668f, -0.06570919f, 0.05948942f, -0.04533679f, -0.15062740f, 0.04787761f, 0.02193373f, 
    0.00177362f, 0.04388613f, -0.01737787f, 0.01308900f, -0.04139955f, -0.02579331f, 0.00243051f, -0.02217666f, 
    -0.09034970f, -0.04915112f, 0.00976327f, -0.09651990f, -0.05412909f, -0.02265267f, 0.01607672f, -0.12507023f, 
    0.16305688f, -0.12138273f, 0.12606762f, 0.05763899f, 0.08742049f, -0.02881967f, 0.06222922f, 0.08398698f, 
    0.03350835f, -0.10684642f, 0.01248334f, -0.09015267f, -0.04619529f, -0.06421112f, -0.05409097f, 0.06600974f, 
    0.06775033f, -0.01393881f, 0.01734102f, -0.02876535f, -0.59475827f, -0.22743717f, -0.09906468f, 0.36011961f, 
    -0.39399964f, -0.05988418f, 0.05374342f, 0.00075788f, 0.15832908f, -0.00376784f, -0.13141051f, 0.00306208f, 
    0.06941221f, 0.05033089f, -0.10378273f, 0.02318913f, 0.00920207f, 0.17554913f, -0.03297324f, 0.01758566f, 
    0.28093284f, 0.01500385f, 0.14998794f, 0.25651917f, 0.01285207f, -0.06714538f, 0.06608906f, -0.11854313f, 
    0.07050444f, 0.09983270f, -0.06571172f, 0.05007391f, -0.03840169f, 0.07592514f, 0.05707158f, -0.06633224f, 
    0.05568251f, 0.06000335f, 0.01433006f, 0.01580136f, 0.02136433f, 0.05521461f, -0.03074667f, 0.03514194f, 
    -0.00587760f, 0.00537524f, -0.06374555f, 0.08366133f, -0.03415038f, -0.01118567f, -0.10047822f, -0.04705555f, 
    0.00253313f, -0.05908195f, -0.02044154f, 0.06845967f, 0.03776659f, 0.13066797f, 0.12758394f, -0.06925178f, 
    -0.10923417f, 0.01043333f, -0.07444029f, 0.21680525f, -0.03869623f, -0.04957626f, -0.02173012f, 0.06168910f, 
    0.05340556f, -0.01167405f, 0.01922908f, 0.05583593f, -0.09505167f, -0.02467525f, 0.00049712f, -0.02665790f, 
    0.02908038f, 0.00673753f, -0.07110070f, -0.15232782f, -0.23174182f, -0.11592636f, 0.02716025f, 0.28402424f, 
    -0.02617902f, 0.00279370f, -0.13101384f, 0.00719765f, -0.05580916f, 0.02954037f, 0.05176506f, -0.03021931f, 
    -0.09647226f, -0.02181414f, 0.05584133f, 0.10300663f, 0.00736966f, 0.12583405f, -0.00863689f, -0.07902206f, 
    0.42063779f, 0.11497293f, 0.37660867f, 0.04758431f, -0.10112723f, -0.08910026f, -0.01595769f, -0.20443362f, 
    0.09907851f, -0.07059276f, -0.11650134f, -0.02791596f, 0.00311457f, -0.00677631f, 0.00330426f, 0.01556413f, 
    -0.00426092f, -0.03062255f, 0.00285546f, 0.13756296f, 0.40040767f, 0.20972683f, 0.36686859f, -0.11309088f, 
    -0.13300349f, 0.08838981f, 0.01823318f, -0.06416068f, -0.01279017f, -0.10152543f, -0.11135944f, 0.02268106f, 
    0.01764024f, 0.04822568f, -0.02466210f, -0.04403547f, -0.06629542f, -0.06898178f, -0.02012465f, 0.09773356f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12052549f, 0.10823346f, 0.04232183f, -0.06482692f, -0.06202962f, 0.03741481f, 0.02581774f, -0.07045214f, 
    0.04123167f, 0.02282520f, 0.01215843f, -0.00188435f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
