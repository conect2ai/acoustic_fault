#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.22376831f, 0.85479611f, -0.62897873f, -0.24896534f, 0.25397038f, -0.06164171f, 0.72447175f, -0.16652009f, 
    0.47787097f, -0.12048205f, 0.71033639f, -0.21101403f, 0.71333015f, 0.43992823f, 0.45401326f, -0.36138111f, 
    0.42112482f, -0.14268136f, -0.38940421f, -0.97985566f, -0.94837230f, 1.09558737f, 0.29924801f, -0.24254906f, 
    -0.61214602f, -0.53906566f, -0.68493283f, -1.23874712f, 0.55835700f, 0.28038669f, -0.27974612f, -0.57769561f, 
    -0.31894052f, 0.15787657f, 0.87107843f, -0.04254718f, 0.20880619f, 0.24036184f, 0.34342822f, 0.48193991f, 
    0.75302577f, 0.56252795f, 0.09686647f, 0.45118272f, 0.30858323f, -0.42309603f, 0.23477945f, 0.37963903f, 
    -0.07144608f, -0.59406924f, -0.30735838f, 0.57915044f, -1.09985673f, 0.75463736f, 0.15633714f, -0.60227680f, 
    0.94861227f, 0.21333042f, 0.03996128f, 0.21179053f, -0.14015277f, -0.12051299f, 0.46138698f, -0.83288306f, 
    0.10375270f, 0.62021142f, -1.04664946f, -1.15716100f, -0.51499647f, 0.64205223f, -0.17875916f, -0.17144659f, 
    -0.17013350f, -0.29652339f, 0.08633346f, 0.45354444f, 0.36199212f, 0.15337695f, 0.67952150f, -0.18616308f, 
    0.32777837f, 0.60931361f, -0.60321897f, -0.94437176f, 0.55410129f, 0.49608773f, 0.59708393f, 0.39732605f, 
    -0.22825167f, 0.16200052f, -1.37989402f, -1.02038455f, -0.35390216f, 0.56408566f, 1.14790308f, 0.48639619f, 
    -0.00072481f, -0.37244260f, 0.19863823f, -0.18459816f, -0.24004807f, 0.09836501f, 0.15312229f, 0.46592987f, 
    0.94126171f, 0.05337901f, -0.29567221f, -0.49396917f, -0.49411488f, 0.79427218f, 0.32679096f, -1.04500353f, 
    -0.28641918f, 0.86238891f, -0.28797612f, 0.19368605f, 0.30334383f, -0.21638314f, -0.23096646f, 0.62559789f, 
    0.11761487f, 1.39191604f, -1.12165463f, 0.20131330f, -0.20083307f, -0.08799781f, -0.05541733f, -0.41403770f, 
    0.55868757f, 0.27495405f, 0.15218632f, -0.72190183f, 0.52243549f, 0.07878780f, 0.68546551f, 1.12837327f, 
    0.91157645f, 0.29314327f, -0.39853442f, -0.61352056f, -0.76495069f, 0.22561796f, 0.39475960f, 0.09016429f, 
    0.76487362f, -0.05460420f, -0.49451846f, 0.09681538f, 0.48458844f, 0.51998287f, 0.32455522f, 0.71610373f, 
    0.42997333f, -0.04230573f, -0.10602891f, -0.75475854f, -1.04440689f, -0.55726749f, -0.72639340f, -0.37625027f, 
    -0.10588638f, 0.93378246f, -0.62103689f, -0.18704757f, -0.52036494f, -0.61296511f, -0.60858834f, -0.89055282f, 
    -0.57101238f, -0.36700562f, -0.63273984f, -0.68551409f, 1.26554251f, -1.21605003f, 0.33844942f, -0.38235030f, 
    0.73485655f, -0.09874434f, -0.07744314f, 0.13210504f, -0.67851889f, 1.04199147f, -0.39754856f, -0.31464076f, 
    0.66899043f, 0.59102917f, 0.22099730f, -0.62224489f, 0.37500143f, 0.33031911f, -0.02397718f, 1.15808129f, 
    -0.04807233f, -0.21162032f, 0.63972354f, 0.28073782f, 0.42981741f, -0.19034143f, -0.78000778f, 0.26797834f, 
    -0.48920426f, -0.17276743f, 0.32169333f, -0.51370913f, 0.64409113f, 0.29059678f, 0.80149591f, 0.33604920f, 
    0.04467157f, 0.34084946f, -0.65527207f, 0.80738437f, -0.36750600f, 0.44371367f, -0.44233552f, -0.34999242f, 
    -0.31172207f, -0.97306538f, -1.15317619f, -0.68678892f, -0.53801912f, -0.67301774f, 0.45579827f, 0.13091825f, 
    -0.14887966f, -0.53574264f, 0.24423800f, 0.74438429f, 0.42729324f, 0.30418298f, 0.38875085f, -0.24578619f, 
    -0.26400319f, 0.42897442f, -0.25114319f, -0.26269644f, 0.06501020f, -0.77718371f, -1.04688191f, -1.00184619f, 
    0.44704354f, 0.39606842f, 0.68469656f, -1.51115930f, -0.75062478f, 1.33881676f, -0.29606009f, 0.57998210f, 
    -0.52631217f, -0.24766435f, -0.10043671f, -0.39511672f, 0.47949576f, -0.06043528f, 0.48759437f, 0.57825607f, 
    -1.11324596f, -1.17184961f, -0.38413569f, -0.40387574f, -0.43060094f, -0.03594882f, -0.07723726f, 0.27440634f, 
    -0.72446185f, -0.21367323f, 0.97861439f, 0.15696354f, -0.15212092f, 0.14966556f, 0.14664710f, 1.16965866f, 
    -0.51512212f, -0.51433921f, -0.05918510f, 0.01092505f, -0.10205664f, 0.46630916f, 0.45932814f, 0.23281829f, 
    0.65412521f, 0.40601861f, 0.15813275f, -0.00693834f, 0.03141987f, 0.43294206f, -0.76383358f, -0.64381331f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16353619f, -0.00954610f, 0.01114976f, 0.15811647f, -0.14821644f, 0.14635718f, -0.52567345f, 0.20792741f, 
    -0.05537536f, 0.36360624f, 0.08979762f, -0.17151359f, 0.29608729f, 0.13571818f, 0.22087893f, 0.33672556f, 
    -0.05998562f, -0.36526367f, 0.07474425f, -0.09607340f, 0.12943460f, 0.22822462f, 0.09743351f, 0.16869725f, 
    0.31388012f, 0.71589386f, -0.00328345f, -0.24686521f, 0.00013116f, 0.61058807f, 0.56261921f, 0.48036781f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.15199123f, -0.12661855f, -0.02482607f, 0.05210120f, 0.01111912f, -0.03107817f, -0.21801014f, -0.29530481f, 
    -0.48871914f, 0.08941964f, 0.10486615f, -0.11028095f, 0.13518769f, -0.05004765f, 0.15809231f, 0.08615465f, 
    -0.13920368f, 0.28375864f, -0.25303251f, 0.13222076f, -0.14564553f, -0.02131859f, -0.04698355f, 0.00305996f, 
    0.01986617f, 0.10445561f, 0.11673844f, 0.19756433f, -0.20319247f, 0.04610443f, 0.13566878f, 0.13343222f, 
    0.08634356f, 0.00685971f, 0.13521256f, -0.05101178f, 0.16921057f, 0.09626633f, 0.10639057f, 0.13703060f, 
    0.14003558f, 0.15829962f, -0.26756141f, -0.16324367f, -0.04669302f, 0.28764385f, -0.03444999f, 0.20358707f, 
    0.02710215f, 0.13930494f, 0.40593877f, -0.09297929f, 0.12823942f, -0.08152295f, 0.33297864f, -0.09729209f, 
    -0.15150671f, 0.16149199f, 0.13627097f, -0.02484862f, -0.31170875f, -0.27239141f, -0.21260491f, 0.40989441f, 
    -0.22037955f, 0.25382385f, 0.03211544f, 0.10277859f, 0.11171848f, -0.12309672f, 0.09761553f, -0.17635964f, 
    0.09370437f, -0.02141154f, 0.02197080f, 0.22222048f, 0.10243993f, 0.03418475f, 0.13400124f, -0.26002029f, 
    -0.19049889f, -0.07810123f, 0.04701529f, -0.04035812f, 0.11357255f, 0.17885025f, 0.05726540f, 0.02424335f, 
    0.11480439f, 0.23555693f, -0.89404780f, -0.15058321f, -0.23886882f, 0.08357868f, 0.12056453f, 0.11236649f, 
    0.19113952f, 0.13160931f, 0.17334764f, 0.09142715f, 0.18234502f, -0.17027183f, 0.06182633f, 0.05964787f, 
    0.09721776f, -0.05172429f, -0.07287078f, 0.69739765f, -0.04782669f, -0.00249117f, -0.36436823f, -0.07536747f, 
    -0.15213740f, -0.24372509f, 0.02537789f, 0.18619485f, 0.06396898f, -0.15016346f, -0.19694693f, -0.33551753f, 
    -0.04623702f, 0.16276418f, 0.02819207f, 0.20285316f, -0.26207635f, -0.00439209f, 0.09015355f, -0.09516138f, 
    0.04337883f, 0.12830402f, 0.07974232f, 0.00534289f, 0.02562563f, -0.33562642f, -0.41093042f, 0.36153191f, 
    -0.13286793f, -0.42447326f, 0.00817058f, -0.11247357f, 0.36077651f, 0.08257613f, 0.07342111f, 0.00923677f, 
    0.12065729f, -0.01103932f, 0.03884823f, 0.06526788f, 0.10603488f, 0.12176836f, 0.05866670f, -0.29250225f, 
    -0.08711231f, 0.32391328f, 0.12225554f, -0.27722719f, 0.39004421f, 0.08038349f, -0.24288432f, -0.10258480f, 
    -0.06989654f, 0.03369392f, 0.05916388f, 0.12640500f, 0.29343170f, 0.21224244f, -0.23943456f, -0.12253947f, 
    -0.05091221f, 0.03805650f, 0.01838619f, -0.01598626f, 0.25427350f, -0.53076065f, -0.01364894f, 0.02903913f, 
    -0.12383731f, 0.02958212f, 0.13129103f, 0.09800185f, 0.16074707f, 0.11313149f, -0.10564584f, 0.12165984f, 
    0.18251356f, -0.16865298f, -0.03788702f, -0.02593661f, 0.30608341f, 0.13778499f, -0.17040706f, -0.25311711f, 
    0.02558625f, -0.01918924f, 0.00899495f, -0.02738335f, 0.10890621f, -0.15570030f, -0.00380866f, -0.11594042f, 
    0.06010371f, 0.08831640f, -0.20037284f, -0.26197559f, 0.28528211f, -0.41592357f, -0.35458520f, 0.00253259f, 
    -0.09809319f, -0.05004373f, 0.18829319f, 0.11189406f, 0.25011283f, 0.16365084f, 0.09605068f, 0.26533255f, 
    0.13503054f, 0.15846187f, -0.11969859f, 0.23277657f, 0.02038329f, 0.04387088f, 0.01431226f, 0.07366443f, 
    -0.08594919f, 0.06301735f, -0.09437685f, -0.01474436f, -0.02479495f, 0.06667881f, 0.05806099f, 0.00037337f, 
    -0.07635587f, -0.19428408f, 0.19548741f, -0.13559060f, -0.22533028f, 0.04067316f, -0.02969179f, -0.07381513f, 
    -0.07447757f, -0.03891610f, -0.22531143f, -0.47881389f, 0.04734556f, -0.17130226f, 0.22975314f, -0.33442160f, 
    -0.00160718f, 0.03083169f, 0.09081190f, -0.02667492f, 0.50574636f, -0.14306898f, 0.03846550f, -0.07231627f, 
    0.14107093f, 0.34827968f, 0.09857470f, 0.16304466f, 0.20286551f, 0.24512196f, -0.07233372f, -0.12157880f, 
    0.12535439f, 0.01004939f, -0.06323093f, 0.02505925f, 0.12530719f, -0.13350034f, 0.14067878f, 0.01063520f, 
    -0.26001635f, -0.16866571f, -0.02065217f, -0.03584821f, 0.01401906f, -0.20434707f, -0.05844223f, 0.17381251f, 
    -0.22376734f, -0.15078864f, 0.15215582f, 0.03158806f, 0.09917853f, -0.02704978f, 0.01441722f, 0.13180591f, 
    0.19797705f, -0.00952854f, -0.12899242f, 0.08251604f, 0.13105041f, -0.24323116f, 0.06416924f, -0.03388813f, 
    0.05360377f, 0.19890475f, 0.14680701f, 0.25311494f, -0.49770549f, 0.02766403f, -0.22240089f, 0.18010700f, 
    0.04771294f, 0.16616713f, 0.04963688f, -0.14791076f, -0.50461143f, -0.05867182f, -0.06200833f, 0.13685048f, 
    -0.02579455f, 0.14598390f, -0.01679350f, 0.51772314f, 0.00106274f, 0.04265479f, -0.17803888f, -0.00818774f, 
    -0.15362212f, 0.00412428f, 0.05637702f, -0.07528640f, 0.08188331f, 0.16276948f, 0.20081106f, -0.13226067f, 
    -0.29346547f, -0.18108374f, 0.11927120f, 0.09899490f, 0.07879061f, 0.03458613f, -0.24093011f, 0.22519027f, 
    0.02330310f, 0.02668848f, -0.17996772f, -0.11937578f, -0.07975049f, -0.08485883f, -0.14715564f, -0.05766558f, 
    -0.06238175f, 0.06690693f, -0.16678411f, 0.14772823f, 0.29280835f, -0.03362776f, 0.05226210f, 0.48885688f, 
    -0.11551492f, 0.60107481f, -0.13847513f, 0.05622309f, -0.16729544f, 0.10687862f, 0.04195706f, 0.05037745f, 
    0.06059565f, 0.09249865f, 0.12644377f, 0.02697718f, -0.38844335f, -0.16142291f, 0.04048795f, -0.00156562f, 
    0.02168766f, -0.07067452f, 0.00633708f, 0.00899304f, -0.06674691f, -0.24396691f, -0.36294639f, 0.08365091f, 
    0.07080504f, 0.15708484f, 0.42558455f, 0.02288217f, 0.40632918f, -0.09173641f, -0.47293609f, -0.00346969f, 
    0.00951656f, 0.07521010f, 0.04655344f, 0.06110136f, 0.16471724f, 0.30936468f, -0.16148560f, -0.37368032f, 
    -0.30616283f, 0.05018763f, 0.05230619f, 0.21776542f, 0.29177263f, -0.65957218f, 0.21311520f, -0.27072901f, 
    0.18564408f, -0.37643152f, -0.15306075f, -0.06244247f, 0.05934183f, -0.53366232f, 0.17795010f, -0.15106969f, 
    0.09359009f, -0.34213215f, 0.11866459f, -0.05988608f, -0.26464236f, -0.22090881f, -0.07692558f, -0.01805453f, 
    -0.09301884f, 0.27995843f, 0.19992310f, -0.05497194f, 0.10501119f, 0.09930150f, 0.07857556f, -0.07919199f, 
    -0.28395423f, 0.13956915f, 0.08558580f, -0.00314099f, -0.04874565f, 0.00576772f, 0.07491771f, -0.09020262f, 
    -0.03251516f, 0.22885022f, -0.01819493f, -0.20494163f, -0.16440532f, -0.09329725f, 0.12238251f, 0.17011742f, 
    0.16255122f, 0.23437701f, 0.45357367f, -0.06415261f, -0.27634403f, -0.12851179f, -0.02263087f, 0.00925374f, 
    -0.01863148f, -0.05595190f, 0.17273898f, 0.15521677f, 0.25546208f, -0.13095061f, -0.07622372f, 0.04362054f, 
    0.04220730f, 0.14288327f, 0.04412803f, -0.15001996f, -0.59278983f, -0.32887417f, -0.31644648f, 0.28366542f, 
    -0.26956609f, 0.03563186f, -0.02441846f, 0.05303892f, 0.19682747f, 0.09022699f, 0.18062684f, -0.33740425f, 
    -0.02164683f, -0.35852870f, 0.10443427f, -0.01672977f, 0.05617156f, -0.10519636f, -0.08464464f, 0.15200883f, 
    0.10282214f, 0.15138786f, -0.05084205f, 0.27508482f, 0.07913321f, -0.06689724f, 0.27150723f, 0.14967513f, 
    -0.20814139f, 0.25392228f, -0.15877001f, -0.11349569f, -0.04631340f, 0.03822090f, 0.05270403f, -0.51922691f, 
    0.00848635f, -0.09364063f, 0.20223142f, -0.00913740f, 0.04881071f, 0.10583185f, -0.15915260f, 0.07072639f, 
    0.17378296f, 0.61980158f, -0.18381386f, -0.15180595f, -0.11550217f, -0.09881635f, -0.00686538f, 0.02193391f, 
    -0.08180153f, 0.22865972f, 0.05241014f, 0.31818220f, -0.08685560f, -0.20757110f, -0.01249101f, 0.06630190f, 
    0.02189675f, 0.03229130f, 0.40695387f, 0.40400651f, 0.28066438f, -0.04256803f, 0.02096222f, -0.11794519f, 
    -0.04493754f, 0.06001661f, -0.00570842f, 0.31076041f, -0.58292460f, 0.13685596f, -0.06124193f, 0.04147202f, 
    0.14754094f, 0.29290232f, -0.02562664f, 0.09032905f, -0.13886082f, 0.19303232f, 0.14150465f, -0.15195465f, 
    -0.09671903f, -0.08899909f, -0.12640344f, -0.13506240f, 0.04942999f, -0.31362218f, -0.14087573f, 0.30559516f, 
    -0.10148118f, 0.08159730f, -0.20712781f, 0.06304931f, 0.01512416f, 0.08319310f, 0.17196111f, -0.24584022f, 
    -0.20639911f, -0.07050307f, 0.20615447f, -0.02204720f, -0.04770938f, 0.08949669f, -0.07833193f, -0.17091522f, 
    0.07399863f, 0.08188317f, 0.10989252f, 0.28083190f, -0.18390089f, -0.06308433f, -0.23908965f, 0.15178098f, 
    0.01759140f, -0.00740119f, -0.06176775f, -0.04996866f, -0.01810059f, 0.03279350f, -0.00064830f, 0.01010269f, 
    0.01708827f, 0.04563048f, 0.04467424f, 0.03424106f, -0.01098016f, -0.05105217f, -0.00152499f, 0.03742335f, 
    -0.05911899f, -0.05812337f, -0.01777270f, 0.04864474f, -0.00576734f, 0.02650908f, 0.02436432f, 0.02486665f, 
    0.02561118f, 0.02469236f, -0.03695840f, -0.02561626f, 0.03959167f, -0.03203069f, -0.04234413f, 0.02329273f, 
    0.00102726f, 0.01919976f, -0.04951429f, -0.03824251f, -0.05592199f, -0.00291085f, -0.04018239f, -0.02428702f, 
    0.02207444f, 0.00688684f, 0.03703858f, -0.00217133f, -0.07352076f, -0.04689600f, -0.01798393f, -0.01229386f, 
    -0.05720415f, -0.04679609f, -0.00524793f, 0.04589203f, -0.04438722f, 0.01658365f, -0.05708014f, -0.04015453f, 
    0.04732270f, 0.03397838f, -0.05351170f, -0.02528590f, -0.07003742f, -0.04030407f, -0.05607184f, 0.00301997f, 
    -0.02269856f, -0.06860682f, -0.00328687f, 0.03624967f, 0.05116065f, 0.00164688f, 0.03753218f, -0.01610130f, 
    0.03828023f, 0.01655648f, -0.05469118f, -0.02452256f, 0.01697323f, -0.06038850f, 0.01010661f, -0.01308132f, 
    -0.05531697f, -0.02884337f, 0.03110133f, -0.04744547f, -0.01782592f, 0.00451766f, -0.02747259f, 0.01715547f, 
    0.01861591f, 0.00902658f, -0.05065670f, -0.02431798f, 0.02632729f, -0.01788259f, -0.03003677f, -0.00439585f, 
    0.02964532f, 0.02712290f, 0.00896996f, -0.04809208f, -0.05783258f, -0.01718969f, -0.04518700f, -0.03636810f, 
    0.03225877f, -0.06085328f, 0.00281890f, -0.03110647f, -0.06808572f, 0.04097278f, 0.03997621f, -0.00823348f, 
    0.04980221f, -0.01666501f, -0.02386368f, 0.01510078f, -0.04239656f, 0.03954345f, -0.01589684f, 0.00163296f, 
    0.03928081f, 0.04723174f, 0.03637705f, -0.01138023f, 0.00765717f, -0.03962678f, 0.02566828f, 0.05357726f, 
    -0.05700693f, 0.00623635f, 0.03686684f, 0.00739654f, -0.02411910f, 0.01010496f, -0.02315920f, -0.04163513f, 
    -0.00111469f, 0.03362040f, 0.01433372f, 0.05385912f, -0.03942771f, -0.01243776f, 0.04179581f, -0.01163593f, 
    0.04942843f, -0.05656561f, -0.02581684f, 0.02980731f, -0.02536618f, 0.02597192f, -0.04666056f, 0.00833860f, 
    0.01947072f, -0.06835189f, -0.02676741f, -0.06089694f, 0.01051155f, 0.02137960f, 0.00090681f, 0.00760108f, 
    -0.01518805f, -0.01637669f, -0.00271011f, 0.01851522f, 0.03894266f, -0.00631677f, -0.03531308f, 0.04479896f, 
    -0.05536146f, -0.05535140f, 0.01088605f, -0.01992146f, 0.01219486f, -0.00364435f, -0.06789470f, -0.01969654f, 
    0.05273806f, 0.03422462f, 0.05122797f, 0.01854600f, -0.06622122f, 0.02588674f, -0.01822705f, -0.05028770f, 
    -0.06313565f, -0.06097494f, -0.04725114f, -0.04363332f, -0.05153445f, 0.04378881f, -0.05260563f, -0.04171971f, 
    -0.03868623f, 0.01015795f, -0.01638132f, -0.01753718f, -0.01909036f, -0.07160246f, -0.00250095f, -0.01287283f, 
    -0.03299730f, 0.04991404f, 0.03928512f, -0.02590467f, -0.02936887f, -0.02759302f, 0.00103597f, -0.04852933f, 
    -0.02610543f, 0.03604592f, 0.04059599f, -0.01928076f, 0.05254300f, -0.03037535f, 0.00103086f, -0.01049239f, 
    -0.06191760f, -0.00121452f, 0.00028565f, -0.03161466f, -0.04861487f, -0.04398065f, -0.00696495f, 0.01255691f, 
    0.01207566f, -0.03089117f, -0.02890127f, 0.04925691f, 0.01380412f, 0.03442075f, -0.00571580f, 0.01652127f, 
    0.02416763f, 0.03037695f, -0.05486324f, 0.02686301f, -0.02599194f, 0.04837282f, -0.01221232f, 0.00802827f, 
    -0.03264591f, -0.03404086f, -0.03015437f, -0.00153807f, 0.05019706f, -0.07514843f, 0.04602459f, -0.02539149f, 
    0.02905816f, -0.04339516f, 0.00334393f, -0.04506890f, -0.03138992f, -0.05041210f, -0.02350597f, 0.00437882f, 
    0.06493305f, -0.01641222f, -0.03739957f, 0.02043065f, 0.03931873f, -0.03320445f, 0.02905334f, -0.03623944f, 
    0.03380486f, 0.03438351f, -0.01942296f, -0.02345130f, -0.00232440f, 0.04040271f, -0.02988447f, 0.02236949f, 
    -0.04472795f, -0.03335607f, 0.03344930f, -0.05908175f, -0.05572492f, -0.01239997f, -0.00057851f, -0.04456505f, 
    0.02325800f, -0.05210137f, -0.04716542f, -0.03966819f, -0.03336904f, 0.02094645f, 0.00203221f, 0.01399383f, 
    0.00779875f, 0.15049945f, -0.01018652f, 0.12010421f, 0.14731877f, 0.19033387f, 0.03767938f, 0.12154195f, 
    -0.01295422f, 0.04519486f, 0.07987324f, 0.06234270f, 0.18690600f, 0.09227026f, -0.10371757f, -0.12335579f, 
    -0.10195805f, 0.02110531f, 0.30918261f, 0.07225437f, -0.09092492f, -0.05930077f, -0.10874463f, -0.08043499f, 
    -0.20680065f, -0.16863984f, -0.08793005f, 0.08522926f, 0.10223156f, 0.37230027f, -0.02450417f, 0.16440120f, 
    0.09912089f, 0.02874447f, 0.04994247f, -0.02404431f, -0.03285784f, -0.02520942f, -0.02497569f, 0.04263626f, 
    0.01129981f, -0.12282032f, -0.06620355f, -0.06043918f, 0.02944054f, -0.10382933f, -0.09208801f, 0.39349049f, 
    0.17158574f, 0.03652060f, -0.21678418f, -0.15757440f, 0.11583874f, 0.04629957f, -0.19837618f, -0.03173557f, 
    -0.06210592f, -0.08292344f, 0.21757525f, -0.05268056f, -0.04585379f, -0.00603803f, -0.08954348f, 0.08773433f, 
    -0.00172716f, 0.36642182f, 0.09636763f, 0.07567365f, -0.00693573f, 0.05916356f, 0.11094525f, 0.23007657f, 
    -0.06474943f, -0.01488451f, 0.02604265f, -0.00824917f, 0.06687039f, -0.00714269f, -0.02395794f, 0.07096647f, 
    -0.01864255f, -0.07852729f, -0.18776858f, -0.06678749f, -0.03479272f, -0.07628169f, -0.05100698f, -0.02416217f, 
    -0.01070806f, -0.00699874f, 0.31799009f, 0.03649748f, -0.10094313f, -0.08103147f, -0.20364758f, -0.17126477f, 
    -0.01081320f, -0.00174922f, -0.00766754f, 0.02755729f, 0.06020761f, 0.00386335f, 0.12444264f, -0.05489605f, 
    -0.26964018f, -0.08930265f, -0.11924468f, 0.07192651f, -0.27651235f, -0.11440118f, -0.04020568f, 0.09577273f, 
    0.06633959f, 0.01067816f, 0.16868041f, 0.07854922f, 0.03474608f, -0.21344805f, 0.21522667f, 0.19548911f, 
    0.07187551f, -0.05809834f, 0.01675076f, -0.10081070f, 0.02707632f, -0.01622236f, 0.03325908f, 0.13262330f, 
    -0.01751803f, 0.09760821f, 0.11426896f, -0.00730703f, 0.10854098f, 0.27173856f, 0.08854859f, -0.45753735f, 
    -0.75010937f, -0.20042633f, 0.00651826f, 0.01720838f, 0.08056340f, 0.04119515f, 0.08031361f, 0.15648760f, 
    -0.09734772f, 0.05223680f, -0.05347475f, 0.11668254f, -0.06817602f, 0.07379039f, 0.03578037f, -0.03532551f, 
    0.02329404f, 0.04245889f, 0.43957785f, 0.35126409f, 0.03801530f, 0.09576903f, 0.10413001f, 0.17069721f, 
    0.02124275f, -0.05572835f, 0.31368288f, 0.26613057f, 0.18833101f, 0.09469195f, 0.11625208f, 0.01076536f, 
    0.07637888f, 0.05270262f, -0.11865185f, -0.21137741f, 0.10710469f, 0.32267234f, 0.03954586f, 0.05680611f, 
    0.00192633f, -0.09964748f, -0.02653273f, 0.03889222f, -0.18259953f, 0.02997726f, 0.12218177f, -0.04025070f, 
    -0.12046901f, -0.00843277f, -0.06881526f, 0.02729471f, 0.02362537f, -0.20143855f, 0.02339377f, -0.05825013f, 
    -0.03549805f, 0.21579143f, -0.06604926f, 0.20160747f, -0.00283352f, -0.08244459f, 0.16190524f, 0.32844383f, 
    0.14040616f, 0.16616718f, -0.01716287f, 0.02029246f, 0.03437416f, 0.10139467f, 0.10598145f, -0.24679768f, 
    -0.04246268f, 0.16922404f, 0.05058841f, 0.04610601f, -0.09727785f, -0.10488270f, 0.05191305f, -0.29284379f, 
    0.16641784f, 0.18298788f, 0.26163328f, -0.16494684f, 0.01855003f, 0.07350647f, 0.07313769f, -0.03248733f, 
    -0.16237997f, -0.13565052f, -0.02537613f, -0.12634356f, -0.07482270f, 0.05680598f, -0.12718967f, -0.02726142f, 
    -0.07942726f, -0.10553183f, 0.18354480f, 0.41218665f, 0.44662175f, 0.15328278f, 0.15395768f, 0.04261043f, 
    0.07604394f, 0.08955234f, 0.11494239f, 0.32310781f, 0.03366939f, 0.08445217f, 0.13375072f, -0.03480509f, 
    0.31492990f, -0.01876700f, 0.06366120f, -0.21422078f, -0.41377565f, -0.57635522f, -0.19747259f, 0.05251802f, 
    0.09474652f, 0.01028725f, -0.11093669f, -0.26554319f, -0.36488795f, -0.26233262f, 0.15552019f, -0.01830417f, 
    -0.07261018f, -0.09339409f, -0.16176073f, -0.09044494f, 0.00745998f, 0.00573359f, -0.02649051f, -0.10308288f, 
    -0.17207228f, -0.03168205f, 0.23373507f, 0.07733565f, 0.05316112f, 0.02884878f, 0.10144143f, -0.19804798f, 
    -0.22678992f, 0.07129584f, 0.07431759f, 0.10260067f, -0.14557692f, 0.05598044f, -0.14185810f, -0.14999793f, 
    -0.05578534f, -0.04087480f, 0.03318896f, -0.03514061f, -0.06368598f, 0.04508249f, -0.05285102f, 0.05156448f, 
    -0.03242690f, -0.04103493f, -0.03484743f, 0.00230494f, 0.02696970f, -0.03112677f, -0.04549694f, -0.04495683f, 
    -0.06209235f, 0.00563835f, 0.03014603f, -0.02223555f, 0.04976239f, 0.02737317f, 0.00136873f, -0.06036149f, 
    -0.02694569f, -0.04969190f, 0.02771823f, -0.02714473f, -0.06307656f, -0.02585546f, 0.02489491f, 0.00165126f, 
    -0.04115455f, -0.02304121f, -0.03879960f, -0.03580182f, 0.04387242f, 0.01454060f, 0.00517284f, -0.02814149f, 
    -0.00804447f, 0.05246405f, -0.04600106f, 0.02831999f, -0.01946509f, 0.03811422f, 0.02828668f, -0.02304866f, 
    -0.03874394f, 0.03752996f, -0.04387705f, 0.03410928f, -0.03546468f, 0.05063312f, 0.00282785f, -0.00131210f, 
    -0.02379412f, -0.05881898f, -0.01664477f, 0.04848568f, 0.03447069f, 0.04854225f, 0.05136286f, -0.05969350f, 
    0.01097153f, -0.01005112f, -0.02671465f, -0.00768535f, 0.02721227f, -0.00453210f, -0.04247659f, 0.01326316f, 
    -0.02821165f, 0.04255962f, -0.05144151f, 0.03484476f, -0.02792114f, -0.03434791f, 0.00337145f, -0.00729194f, 
    0.00824203f, -0.01387897f, -0.06308620f, -0.05408831f, -0.04797623f, -0.03238530f, -0.02321861f, -0.04455433f, 
    0.00408653f, -0.00966330f, -0.05219489f, -0.03547980f, 0.04328340f, 0.04706115f, -0.02073786f, 0.00858767f, 
    0.01757713f, -0.06352749f, -0.00450045f, -0.06482504f, 0.00299259f, -0.02354165f, -0.03828258f, 0.05102123f, 
    0.00318256f, -0.00381544f, 0.02417666f, -0.02157884f, -0.06331952f, 0.01701220f, -0.00394416f, -0.04610088f, 
    -0.01972537f, -0.03532264f, 0.04250603f, 0.01313987f, -0.01249742f, -0.05303767f, -0.02148548f, -0.03472826f, 
    -0.01913887f, 0.03215598f, 0.03082697f, -0.01765984f, 0.02661910f, -0.03984059f, 0.02628561f, 0.00299419f, 
    0.01070190f, 0.00739480f, 0.01536629f, 0.00394914f, 0.04642001f, -0.05441644f, -0.00181537f, -0.00889440f, 
    0.01758348f, -0.05001384f, 0.05094881f, -0.03717316f, -0.00143572f, -0.00495435f, 0.02009715f, -0.05553021f, 
    -0.05837448f, -0.01789919f, -0.00696388f, -0.01805376f, -0.06263985f, -0.04517599f, -0.04729785f, -0.05923617f, 
    0.00460429f, 0.03877905f, -0.00997360f, -0.02056334f, 0.02760659f, 0.01105414f, 0.03658323f, -0.05350857f, 
    -0.03476738f, -0.03783918f, 0.03013799f, 0.00188986f, 0.00612631f, -0.00277761f, -0.04760953f, -0.06415682f, 
    0.04176288f, 0.04703281f, -0.00616559f, -0.03619264f, -0.00238529f, 0.04527394f, -0.00503347f, 0.02584416f, 
    0.04120658f, -0.02252408f, -0.04155478f, 0.01613924f, 0.03849887f, -0.04852314f, 0.02895545f, -0.04235867f, 
    0.00832225f, 0.02044617f, -0.05951688f, -0.00321697f, -0.06402462f, 0.00380294f, -0.02569011f, 0.01673987f, 
    -0.02595959f, -0.05192275f, 0.05186035f, -0.02536536f, 0.01589880f, 0.02982919f, -0.04924590f, -0.02566732f, 
    -0.06296424f, -0.05014234f, -0.02204438f, -0.04861786f, -0.02999611f, 0.02026045f, -0.05671968f, 0.02052881f, 
    -0.02931959f, 0.04892813f, -0.02878473f, 0.05262771f, 0.01619933f, -0.02165068f, 0.01524672f, 0.00099623f, 
    -0.04540081f, 0.01384013f, -0.00944833f, -0.00104937f, -0.01057919f, 0.04924335f, -0.06039247f, -0.00990528f, 
    0.02769164f, 0.00661720f, -0.03133114f, -0.06346752f, -0.01081458f, -0.02479673f, 0.00324353f, 0.04673287f, 
    0.04387935f, 0.02786917f, -0.02050912f, -0.03070384f, -0.05634383f, 0.05122096f, -0.05201520f, -0.03507316f, 
    0.02997469f, -0.01719135f, 0.03275603f, -0.04496639f, 0.02226327f, -0.02504697f, -0.02622188f, -0.02189571f, 
    -0.04193442f, -0.05173686f, 0.05725489f, 0.01565573f, -0.03814768f, -0.04857589f, 0.00241272f, -0.01845782f, 
    -0.03615332f, 0.01383785f, 0.04750888f, 0.03738404f, -0.00712783f, -0.00756886f, -0.04819691f, -0.02867029f, 
    -0.04282040f, -0.01732497f, 0.02726640f, 0.01809022f, -0.04779878f, 0.01175157f, 0.03753495f, 0.00574473f, 
    -0.04890251f, -0.00335296f, -0.06463336f, 0.05087483f, -0.05989634f, -0.04120818f, 0.04495589f, -0.03692777f, 
    0.00173173f, -0.04853634f, 0.06028800f, -0.03263871f, -0.04309446f, 0.02359738f, -0.04880820f, -0.00868055f, 
    0.19628060f, -0.13678166f, -0.40280253f, -0.19152570f, 0.12281823f, -0.09974849f, 0.06041593f, -0.06707298f, 
    0.08385491f, 0.11999667f, -0.06271315f, -0.05085181f, -0.48879135f, -0.08322155f, -0.14769511f, 0.13674830f, 
    0.05404668f, 0.07276927f, -0.11912566f, 0.10175836f, -0.03275360f, -0.12426393f, 0.04381526f, 0.15460679f, 
    0.14982851f, 0.19322571f, -0.07251354f, -0.06855817f, -0.12116918f, 0.26312450f, -0.14472601f, 0.01189600f, 
    -0.00810065f, 0.08474000f, 0.02969379f, 0.04987576f, -0.05233655f, -0.11004339f, -0.04056025f, -0.25536528f, 
    -0.18097951f, -0.25647756f, 0.23016062f, 0.07275202f, 0.08056007f, -0.32865199f, -0.09830003f, 0.12315461f, 
    -0.04603512f, 0.05649170f, -0.03256596f, 0.07359205f, 0.09099240f, 0.12104590f, -0.19534652f, -0.23933549f, 
    -0.31525344f, -0.25835404f, -0.18269151f, -0.15501533f, 0.09748258f, 0.06376470f, 0.07616769f, -0.24498005f, 
    -0.82779956f, -0.03939934f, -0.07068317f, 0.00999877f, -0.25622779f, 0.10129890f, 0.06393912f, -0.00099910f, 
    0.09287784f, 0.11267548f, -0.05300933f, -0.26221895f, -0.30727327f, -0.18141168f, 0.11647273f, -0.04889906f, 
    0.04237274f, 0.26727152f, 0.30053750f, -0.13523594f, -0.25243652f, -0.15788183f, 0.19482763f, 0.05212215f, 
    0.03513391f, 0.03671245f, 0.11858467f, 0.62641388f, 0.55546266f, 0.01710523f, -0.23745756f, 0.05421668f, 
    0.01779168f, 0.02509116f, 0.04084636f, 0.01348630f, -0.07661548f, 0.09141402f, -0.05517705f, -0.02826902f, 
    -0.10429775f, 0.18817677f, 0.03096878f, -0.01339074f, -0.32117206f, -0.61472881f, -0.12266625f, -0.17384063f, 
    0.16231138f, -0.16675131f, 0.21276218f, 0.09704477f, -0.00452349f, -0.54451323f, 0.28207591f, -0.28640956f, 
    0.17223665f, -0.45030561f, 0.15281379f, 0.03569777f, -0.00843329f, 0.21470183f, -0.01624003f, -0.00883749f, 
    0.11531860f, 0.01662751f, -0.13104962f, 0.14937969f, 0.18985102f, 0.00283353f, 0.11537445f, -0.34408087f, 
    -0.56267005f, 0.10725921f, 0.10575334f, 0.08661923f, -0.08270273f, 0.09359055f, -0.25883725f, -0.15430318f, 
    0.17658810f, 0.11892304f, -0.23591770f, -0.07899286f, -0.28274521f, -0.10935471f, 0.16267338f, -0.01928113f, 
    0.03516908f, -0.41244149f, -0.51192480f, -0.36821851f, -0.17774090f, -0.12550439f, -0.07451866f, -0.02531007f, 
    0.01925650f, -0.05229998f, -0.25256816f, 0.03547246f, -0.14093880f, -0.07348281f, -0.06582001f, -0.01060449f, 
    0.02298368f, 0.04796342f, 0.09410325f, 0.13140982f, -0.23932205f, -0.46108142f, -0.06893621f, 0.29521653f, 
    0.01472964f, -0.10784587f, -0.03866358f, -0.05402530f, -0.03220766f, -0.03314786f, 0.06535392f, -0.21840115f, 
    0.08717533f, 0.03907209f, 0.12563606f, 0.21318151f, 0.01147529f, -0.06413251f, -0.41544694f, -0.19827752f, 
    0.22239988f, 0.01152886f, -0.16253471f, 0.01018114f, 0.17530124f, -0.01746110f, 0.28630754f, 0.27508691f, 
    -0.07959480f, 0.08079991f, -0.04362635f, 0.01860347f, -0.00563764f, -0.07235889f, 0.12529479f, -0.29777589f, 
    -0.14632995f, -0.21213257f, 0.29537007f, 0.04496938f, 0.15408300f, 0.09949185f, 0.32360470f, 0.24156597f, 
    0.03596729f, 0.64006412f, -0.30406266f, -0.06565997f, 0.00152497f, -0.04387432f, -0.02253602f, -0.01353202f, 
    0.04810375f, 0.12114830f, 0.00301905f, 0.16036126f, -0.06035049f, -0.01370577f, 0.10196982f, 0.23524258f, 
    0.21791144f, 0.17636940f, -0.18203799f, -0.37823638f, 0.07878753f, -0.28338572f, -0.10235087f, -0.22806838f, 
    0.02311960f, -0.05837465f, 0.05074605f, -0.14746058f, -0.34374526f, -0.18491635f, -0.22926222f, -0.06354302f, 
    -0.15113978f, -0.09278072f, -0.10521594f, 0.02343404f, -0.58208114f, 0.16191296f, 0.23207867f, 0.13388507f, 
    -0.02951330f, -0.11633740f, 0.13570547f, 0.00389101f, 0.22137989f, -0.17000957f, -0.13789725f, 0.02386895f, 
    0.20490015f, 0.34936130f, 0.07669381f, 0.15737122f, 0.33311921f, 0.02415526f, 0.18882763f, -0.38010097f, 
    -0.35596976f, 0.02410591f, 0.22934876f, 0.04869788f, 0.09752862f, 0.01403657f, -0.01138373f, 0.02600874f, 
    0.04056556f, -0.04403032f, 0.17413692f, 0.17234059f, 0.09448549f, 0.21514082f, 0.37770522f, 0.26215917f, 
    -0.04786536f, 0.03178860f, 0.01669559f, 0.23776324f, 0.31632319f, 0.19316934f, -0.13307145f, 0.12606879f, 
    -0.00558566f, 0.06926336f, 0.10969675f, 0.07830581f, 0.07790352f, -0.09558197f, 0.15326771f, 0.12863031f, 
    -0.13883936f, -0.10621329f, -0.16061056f, -0.27378154f, -0.10485049f, -0.06972167f, -0.02416302f, -0.13255046f, 
    -0.06526873f, 0.04305005f, 0.17605338f, 0.16850200f, -0.17871365f, 0.34634036f, -0.05265757f, -0.04578734f, 
    0.16103268f, 0.04355512f, -0.18332630f, 0.29082033f, -0.01567305f, 0.01739978f, 0.03140680f, 0.13379580f, 
    -0.08882561f, -0.00291056f, 0.06010000f, -0.23289669f, -0.07736900f, -0.38804856f, 0.19589740f, -0.18483959f, 
    0.24522126f, 0.09075014f, -0.17661886f, -0.10564426f, 0.37835619f, -0.04989526f, -0.01522618f, 0.05085935f, 
    -0.11565535f, -0.11807717f, -0.02604050f, 0.04879350f, 0.45590129f, 0.12050201f, 0.03270423f, -0.07279127f, 
    -0.20966959f, 0.14910586f, 0.16020739f, 0.03769337f, 0.28128639f, -0.02740053f, 0.12330931f, -0.07800391f, 
    0.02853910f, 0.00650205f, -0.09640282f, -0.04018250f, 0.09311556f, -0.01842450f, 0.02026332f, 0.07085943f, 
    -0.05557979f, 0.02527544f, 0.00360039f, -0.01521420f, -0.04509784f, -0.00069021f, 0.11529832f, -0.14063390f, 
    -0.13391997f, 0.06261618f, 0.16238827f, -0.37886781f, -0.22901329f, -0.14303839f, -0.02167964f, -0.16488901f, 
    0.01214964f, -0.13495407f, -0.05250205f, 0.06240500f, -0.00857398f, -0.07462823f, -0.17897625f, 0.17259759f, 
    0.03364236f, -0.08045570f, -0.26153910f, -0.26473084f, -0.09573682f, 0.08620335f, 0.02380819f, 0.28760007f, 
    0.13691843f, 0.03168830f, 0.06858001f, 0.04152090f, 0.28453338f, 0.28172126f, 0.02233143f, 0.04742420f, 
    0.00709031f, 0.22245757f, -0.00442135f, 0.28317687f, 0.27992639f, 0.00587591f, -0.00729601f, 0.16121385f, 
    -0.00939065f, -0.01521361f, 0.02492484f, 0.19343834f, -0.12059021f, 0.28546861f, 0.15306345f, -0.26612070f, 
    -0.02773291f, 0.37018576f, -0.01499367f, -0.13394108f, 0.07160692f, -0.00351111f, -0.05774663f, 0.00636931f, 
    -0.04538767f, -0.09118898f, 0.01911130f, 0.19574909f, -0.02720121f, 0.03825683f, 0.03432695f, -0.27298781f, 
    0.09619971f, -0.11259271f, -0.13127962f, -0.33285949f, 0.11207855f, 0.06429543f, -0.06668133f, -0.02240304f, 
    0.10637189f, -0.05135865f, -0.00059053f, -0.12639184f, -0.19349234f, 0.15978597f, 0.06668441f, -0.14870785f, 
    0.06270242f, 0.08246242f, -0.00038354f, -0.11693123f, 0.18711536f, -0.30796915f, 0.10789864f, 0.22717048f, 
    0.14734539f, 0.09708898f, 0.07347316f, 0.11673966f, 0.08322569f, -0.02498125f, -0.03211421f, 0.02935605f, 
    0.29532647f, -0.02280595f, 0.03242530f, -0.16071118f, -0.20920505f, 0.03709473f, 0.14541689f, 0.08778072f, 
    0.05023434f, 0.05386316f, 0.05135166f, 0.29311630f, 0.30351996f, 0.09669475f, 0.14013267f, 0.15501024f, 
    -0.04663425f, 0.04824290f, 0.19448903f, 0.22308815f, -0.01876562f, 0.15417306f, 0.13362753f, -0.01274924f, 
    0.04846671f, 0.15562771f, 0.04893485f, 0.08854058f, -0.12130497f, 0.24547218f, 0.08553178f, 0.12880938f, 
    0.19896619f, -0.02130140f, 0.05361957f, -0.01302758f, 0.03434029f, 0.08868691f, 0.02836858f, 0.06009055f, 
    -0.13628720f, 0.14469230f, 0.12925920f, -0.05296632f, 0.04125041f, 0.17005329f, -0.06444770f, 0.26959607f, 
    0.02817733f, -0.07060245f, -0.01039006f, -0.01394344f, 0.06249969f, -0.00978679f, 0.00496301f, 0.10678151f, 
    0.01564250f, 0.11553769f, -0.09718162f, 0.04307521f, 0.06200414f, -0.44801867f, 0.10610894f, -0.06655043f, 
    -0.05285667f, 0.07790865f, 0.05072185f, -0.16572827f, -0.21927036f, 0.08467241f, 0.00981834f, 0.03659467f, 
    -0.16147417f, 0.13154010f, -0.01980711f, -0.00109797f, -0.19353265f, 0.14263178f, 0.09281539f, -0.05623430f, 
    0.17744973f, 0.19196881f, 0.11896953f, 0.05868367f, 0.26269794f, -0.04523665f, -0.08399066f, 0.01963823f, 
    -0.00676317f, 0.25865993f, 0.03909943f, 0.16226263f, 0.05616245f, -0.04376635f, 0.25626266f, -0.02478793f, 
    0.14526607f, 0.11942629f, -0.04081395f, 0.04104451f, 0.00032078f, -0.04820901f, 0.02196546f, 0.00755524f, 
    0.25412190f, -0.08786736f, -0.35581282f, 0.10115948f, -0.04734399f, -0.10815202f, 0.03637679f, 0.56056368f, 
    0.37781569f, 0.50856692f, -0.37300599f, -0.23053069f, 0.07220951f, -0.36185706f, 0.06371725f, -0.05752325f, 
    0.03802381f, -0.05406950f, 0.63078398f, 0.26876572f, 0.11446685f, -0.00369885f, 0.00174213f, -0.00768582f, 
    0.31574598f, 0.00014419f, -0.14606996f, -0.00729994f, 0.13504109f, 0.38814282f, -0.18816671f, -0.02047324f, 
    0.09919166f, -0.08773497f, 0.27164647f, 0.08392641f, 0.03985048f, -0.23587416f, -0.20873551f, -0.14676352f, 
    -0.24250408f, 0.15899248f, 0.02136898f, 0.05963371f, 0.19331788f, 0.01388732f, 0.54574007f, -0.00173329f, 
    -0.23591840f, -0.05146132f, 0.09969015f, -0.07108172f, 0.14751856f, 0.10118904f, -0.19685739f, -0.33268887f, 
    -0.73271662f, 0.21508212f, 0.40009761f, 0.06320749f, 0.12412470f, 0.09845058f, 0.04918321f, -0.08538787f, 
    0.31880111f, 0.32325268f, -0.30296722f, -0.07028671f, -0.12951393f, -0.20322879f, 0.12283375f, -0.00659044f, 
    -0.38148817f, -0.05140527f, -0.37316212f, -0.03074514f, 0.01127972f, 0.11017881f, -0.14493090f, 0.13448989f, 
    0.13419113f, 0.27418935f, -0.59427667f, -0.70119685f, -0.12378167f, -0.02331388f, -0.02821185f, -0.05579707f, 
    -0.04928102f, -0.00762522f, 0.25408608f, -0.23488483f, -0.21167122f, 0.15078008f, 0.11825176f, 0.11080606f, 
    0.02750825f, -0.10856332f, 0.08724858f, 0.23916040f, -0.31644544f, 0.09053615f, -0.20888853f, -0.14442441f, 
    0.07547543f, 0.11907460f, -0.02065717f, 0.00109552f, -0.26362321f, -0.14486143f, -0.55193460f, 0.06399381f, 
    -0.18904807f, -0.06891725f, 0.27351001f, 0.05133261f, 0.12508011f, -0.00095160f, -0.89531821f, -0.20155448f, 
    -0.33882210f, 0.04644540f, 0.05961481f, -0.36255997f, 0.02018995f, -0.10276211f, 0.02916507f, 0.21515590f, 
    -0.07734030f, 0.11686397f, 0.03673892f, 0.11039910f, -0.02429096f, 0.15363197f, 0.17251448f, -0.15896872f, 
    -0.66087401f, 0.07827350f, -0.00272729f, -0.26599139f, -0.05910166f, 0.09378730f, 0.22901176f, 0.05374197f, 
    0.07514071f, -0.14101043f, -0.23587170f, 0.06206734f, 0.04507473f, -0.01998142f, 0.09345542f, 0.27631336f, 
    0.01904189f, 0.44231772f, 0.33441955f, 0.32042786f, 0.03978111f, 0.09589402f, -0.05430420f, 0.20644009f, 
    0.14479326f, 0.20050025f, 0.23453739f, 0.37253568f, 0.26540411f, -0.05082643f, 0.00112303f, 0.00006411f, 
    0.08898265f, -0.13736269f, 0.04045412f, -0.93536931f, 0.13704777f, -0.34176150f, -0.02183563f, -0.06386427f, 
    0.18832426f, -0.17324640f, 0.08193552f, 0.03302712f, -0.78525048f, -0.43362024f, -0.45063150f, -0.08978494f, 
    0.03642764f, -0.10933924f, 0.21586129f, -0.10329334f, 0.38120326f, -0.29015413f, -0.25917464f, -0.70915169f, 
    -0.00264669f, 0.00004743f, -0.13357368f, 0.12686326f, -0.04758385f, 0.06591617f, 0.13767862f, 0.02572768f, 
    0.25130495f, 0.19876023f, -0.00531306f, 0.02715182f, -0.21790005f, 0.08325187f, 0.40469271f, -0.21316284f, 
    -0.22306389f, 0.08802398f, -0.14636150f, 0.00459236f, -0.06015122f, -0.12600160f, -0.05546797f, -0.07131109f, 
    0.17207940f, 0.29850388f, 0.22244382f, -0.05023140f, 0.08898171f, 0.06646845f, 0.02837714f, -0.02944340f, 
    0.04116974f, -0.56802994f, -0.21503697f, -0.19596568f, 0.09475759f, -0.06930640f, -0.17409697f, 0.11562780f, 
    -0.06425504f, 0.07103059f, 0.25313246f, 0.31314614f, 0.40675345f, -0.10926917f, 0.04817712f, -0.04850817f, 
    -0.01813510f, 0.21626189f, 0.36529446f, 0.13808537f, 0.08640835f, -0.05292195f, -0.04884464f, 0.15200840f, 
    0.03635659f, 0.34473038f, 0.13786951f, -0.25516158f, -0.15886551f, 0.00616750f, -0.16867870f, -0.06819995f, 
    0.16612314f, -0.07389323f, 0.01800449f, 0.07051426f, -0.11033987f, -0.49771956f, -0.03435751f, -0.26711932f, 
    -0.17857657f, -0.09201074f, -0.16185839f, 0.19829136f, -0.00841602f, -0.02597819f, 0.08334976f, -0.63426995f, 
    -0.44530067f, 0.04341892f, -0.40545574f, -0.11785889f, -0.09193686f, 0.08091187f, -0.16322747f, -0.25464934f, 
    -0.14034805f, 0.06005427f, 0.04180021f, -0.01103992f, -0.02757300f, 0.14607617f, -0.21850762f, -0.29133004f, 
    -0.10590885f, -0.03941064f, 0.01356549f, 0.18505701f, -0.07413350f, 0.01559188f, -0.00166133f, 0.21266489f, 
    0.07859845f, -0.15050210f, -0.11690106f, -0.04274449f, 0.10912906f, -0.09785197f, 0.07854696f, 0.08102498f, 
    -0.10468788f, -0.18470353f, -0.12135104f, 0.25336379f, 0.16381107f, -0.10969507f, -0.05125296f, -0.22336876f, 
    -0.17329930f, -0.29005107f, -0.33387044f, -0.17927267f, -0.11328122f, 0.13807617f, 0.01115873f, -0.06188931f, 
    0.02933684f, 0.22819568f, 0.01263279f, 0.16606927f, -0.00878491f, 0.03190979f, 0.08933293f, 0.02413432f, 
    0.06202367f, -0.05767121f, -0.09029688f, -0.11422476f, 0.13099471f, -0.13649006f, 0.10339892f, -0.06524768f, 
    0.10215735f, 0.11926014f, 0.11972548f, 0.25927076f, 0.20316310f, 0.21757430f, -0.02585373f, -0.02114112f, 
    -0.12798020f, -0.11924285f, -0.05273656f, 0.04273849f, -0.06875899f, -0.10565048f, -0.13517655f, -0.14370729f, 
    -0.03724547f, 0.06755183f, 0.02600914f, -0.06048654f, 0.10317222f, 0.15438522f, 0.16554751f, 0.21868195f, 
    -0.10967797f, -0.05313600f, -0.00314598f, 0.13048552f, 0.11756626f, -0.00197005f, -0.15078072f, 0.09256085f, 
    0.12717794f, 0.18143295f, 0.03155327f, 0.17182226f, 0.09782200f, 0.10096442f, 0.12416744f, 0.06183930f, 
    0.06870470f, -0.03006195f, -0.19987516f, -0.11077071f, 0.09258002f, 0.34686664f, -0.20083900f, -0.13046411f, 
    0.12704533f, -0.14714360f, 0.02355966f, -0.11194760f, -0.15023547f, 0.07558001f, 0.03274722f, 0.02318935f, 
    0.09586132f, 0.01513519f, -0.27675223f, -0.39266905f, 0.10256198f, 0.08533905f, 0.34435394f, 0.13997677f, 
    0.12537730f, 0.17746927f, 0.16842881f, -0.03846622f, 0.20125197f, 0.10626566f, -0.31861615f, 0.18810935f, 
    0.09504750f, 0.24174137f, -0.22122444f, 0.19301954f, -0.09512829f, -0.10708283f, -0.06250882f, -0.08315886f, 
    -0.02909150f, 0.10813471f, -0.07107610f, 0.07706504f, 0.14710805f, 0.33284906f, 0.28936115f, -0.23230778f, 
    -0.31498730f, -0.28583390f, -0.01021363f, 0.02103877f, 0.02659942f, 0.29502147f, 0.18895952f, -0.04498839f, 
    -0.03123293f, 0.04834000f, 0.14121011f, 0.20795923f, 0.08655816f, 0.00757886f, -0.04250447f, 0.17712277f, 
    0.15831551f, -0.11623851f, -0.16548628f, -0.32201713f, 0.01721701f, -0.17913559f, 0.14060737f, 0.17612116f, 
    0.15342759f, 0.04327610f, -0.24754295f, -0.11565465f, -0.01028184f, 0.05758094f, 0.05088026f, 0.15750748f, 
    -0.15797512f, 0.02670293f, -0.07175697f, 0.06990527f, -0.15646021f, -0.23117547f, 0.05316358f, -0.20430902f, 
    -0.27428442f, 0.06393101f, -0.10442999f, -0.20620839f, 0.04038591f, -0.05747798f, 0.16107808f, 0.12267230f, 
    0.05229820f, -0.04474929f, 0.22416924f, -0.11116518f, 0.01930613f, -0.05117655f, -0.08806108f, -0.00356183f, 
    -0.07428664f, -0.17426960f, -0.04030827f, 0.05387256f, -0.00201775f, 0.25780803f, -0.20998859f, -0.15607323f, 
    -0.04361524f, -0.02936772f, -0.12715407f, -0.10078190f, 0.19282015f, 0.25912011f, 0.11962462f, 0.18708184f, 
    -0.43536681f, 0.10302683f, -0.09517476f, 0.17867076f, -0.04805346f, -0.05065888f, 0.04572633f, 0.01704048f, 
    -0.17539334f, 0.34313738f, 0.09454166f, 0.02699656f, -0.12837745f, 0.07121460f, -0.00525680f, 0.16915730f, 
    0.02111412f, -0.02464427f, -0.02488672f, 0.36636037f, 0.10454045f, 0.02699920f, 0.14356643f, 0.21661548f, 
    0.00951028f, 0.09759111f, -0.16120063f, -0.02245208f, -0.27166778f, 0.11906572f, -0.03023335f, 0.18028721f, 
    0.12069849f, 0.18189307f, 0.18587305f, -0.69819266f, -0.37872815f, 0.35345253f, 0.34123591f, 0.00502328f, 
    0.06048279f, -0.24211784f, -0.11836715f, -0.17058979f, -0.36652768f, -0.31733769f, -0.24682909f, 0.15023030f, 
    0.02159140f, -0.02593562f, 0.06553372f, 0.06394418f, -0.37598172f, 0.17439646f, 0.08208669f, 0.12957761f, 
    0.32559699f, 0.14364053f, 0.29180863f, 0.15182787f, 0.15974285f, 0.24306992f, 0.02892612f, -0.07129642f, 
    0.08909364f, -0.03064465f, -0.06500088f, 0.14433873f, 0.33223212f, 0.23082705f, 0.01986883f, 0.09824091f, 
    -0.18658078f, 0.08064628f, -0.05639751f, 0.12685463f, 0.17987600f, -0.03534841f, -0.06264352f, -0.12505533f, 
    -0.18211821f, -0.10511464f, -0.11703523f, -0.00272680f, -0.01339273f, -0.02566277f, 0.25275466f, -0.27859968f, 
    -0.09841841f, -0.30315602f, -0.12400998f, -0.08469333f, -0.13626415f, -0.16414030f, -0.01679355f, -0.02782449f, 
    -0.18659338f, 0.09374553f, -0.08344052f, -0.36405271f, 0.00166660f, -0.03766666f, 0.25257516f, 0.02493634f, 
    -0.08211940f, -0.16588491f, 0.19262539f, -0.41470999f, -0.43686023f, -0.24735801f, -0.03425658f, -0.11896142f, 
    0.13179944f, 0.06356703f, 0.04385136f, 0.00489112f, -0.00657775f, -0.03384920f, -0.18517889f, -0.24364167f, 
    -0.08084233f, -0.09096403f, -0.16414887f, -0.04288276f, -0.02631585f, -0.07233051f, 0.24141018f, 0.29061517f, 
    -0.22525693f, -0.00618165f, 0.30449748f, 0.18118101f, 0.07344140f, 0.10551287f, -0.14687806f, -0.15560842f, 
    -0.36603639f, -0.28251451f, -0.05633523f, -0.11803863f, -0.21609393f, 0.03068094f, -0.24609362f, -0.02130910f, 
    -0.00548166f, -0.09145813f, -0.33019519f, -0.01600249f, 0.08757631f, 0.03645888f, -0.01240558f, -0.02491290f, 
    -0.18690778f, -0.06352782f, -0.09427557f, -0.20568386f, 0.02264891f, 0.02655272f, 0.02600590f, -0.06091321f, 
    -0.13658786f, -0.32167983f, -0.04634469f, 0.07270414f, -0.10526354f, 0.08500472f, 0.16483137f, 0.05687168f, 
    0.08472196f, 0.10466181f, -0.60086840f, -0.80595177f, 0.06256045f, -0.02583871f, 0.14971060f, -0.03173105f, 
    -0.10796963f, 0.08094898f, 0.10742345f, -0.57705986f, 0.10999859f, -0.08289538f, -0.05403577f, -0.04392171f, 
    -0.05405129f, -0.24766856f, 0.22732612f, 0.04406087f, 0.36853966f, 0.19183987f, -0.22587515f, 0.20842609f, 
    -0.02872319f, 0.40082020f, 0.00412233f, -0.11142996f, 0.04618074f, -0.44382897f, -0.30802950f, 0.34359479f, 
    0.09594448f, 0.09892242f, -0.00324338f, 0.05426793f, 0.00459835f, 0.09618516f, -0.08270448f, -0.13070709f, 
    0.01578003f, -0.23483117f, 0.05254661f, -0.09951782f, 0.02087242f, -0.04076773f, -0.21217129f, 0.57240051f, 
    0.40783066f, 0.33128998f, 0.10963874f, -0.22987647f, -0.11879049f, 0.04684904f, 0.00577979f, 0.16279806f, 
    -0.00777610f, -0.08234096f, -0.17223544f, -0.07565155f, 0.01077228f, 0.02308840f, -0.05149569f, -0.14350440f, 
    -0.04904653f, -0.51105529f, -0.38987374f, -0.58228397f, 0.00507074f, 0.15993248f, -0.24070540f, 0.03686507f, 
    -0.05401028f, -0.07507578f, 0.26862642f, -0.18010268f, -0.64853752f, -0.39837131f, -0.18872660f, -0.15222485f, 
    0.08039974f, -0.11612784f, -0.02085272f, -1.19068825f, -0.33958724f, -0.42299205f, 0.05005473f, -0.12443357f, 
    0.51718980f, 0.22451292f, 0.00926603f, -0.06424391f, -0.15948834f, -0.09329861f, -0.17079738f, 0.09642952f, 
    0.05338391f, 0.20249604f, -0.01151349f, -0.04475005f, -0.05563597f, 0.45561829f, 0.36128819f, -0.04249946f, 
    0.02434034f, 0.08426040f, -0.08258697f, -0.07143891f, -0.02656120f, -0.18119670f, -0.36787289f, -0.29713130f, 
    0.00880897f, -0.11580720f, 0.17270230f, 0.13464640f, 0.22255732f, -0.17989951f, -0.18882552f, 0.21809323f, 
    0.22026981f, 0.52634788f, 0.09627414f, 0.08077224f, -0.12075881f, -0.11587416f, 0.13910760f, -0.04160801f, 
    -0.25884777f, -0.27802670f, -0.36927518f, -0.17575361f, 0.14270034f, -0.01617092f, -0.07688505f, 0.01232820f, 
    0.02870607f, 0.04789652f, -0.05559856f, -0.21864949f, 0.08989307f, 0.14348602f, 0.00190935f, 0.05365523f, 
    0.04304061f, 0.07588781f, -0.37073135f, -0.20535037f, 0.06049704f, -0.00131645f, -0.06104181f, -0.36191106f, 
    0.07285018f, 0.07570250f, -0.02901126f, -0.26401138f, -0.98532122f, -0.61799830f, 0.06092673f, 0.11826529f, 
    -0.04981594f, -0.08455312f, 0.00759486f, 0.00214930f, -0.22455810f, 0.51880711f, 0.48409295f, -0.10533464f, 
    0.05008753f, -0.04537890f, 0.04642757f, 0.01435160f, -0.00613627f, 0.40913376f, 0.29729083f, 0.15809004f, 
    0.12985118f, 0.16132954f, 0.05169091f, 0.20513816f, 0.20632537f, 0.09075915f, 0.22995989f, 0.14651075f, 
    0.10450216f, 0.24068409f, -0.04202225f, 0.18900976f, 0.15672059f, 0.04090241f, 0.13270804f, 0.29246712f, 
    0.33643252f, 0.38364628f, 0.01851662f, 0.00247816f, -0.06759062f, 0.12455042f, 0.22300620f, 0.10227785f, 
    0.06519194f, -0.01026301f, 0.07070658f, -0.04471048f, 0.13425413f, 0.10731508f, 0.15831560f, 0.03424862f, 
    0.02829864f, 0.24903703f, 0.03284860f, -0.03448786f, -0.39324397f, -0.08909175f, 0.16148207f, 0.18171363f, 
    0.00566245f, -0.04743967f, -0.03514001f, -0.17520012f, -0.25685543f, 0.09544440f, 0.11181881f, -0.12630410f, 
    0.05540229f, -0.27097723f, -0.18038318f, -0.15081075f, 0.31330612f, 0.43319410f, 0.07064015f, 0.11100588f, 
    0.05972487f, 0.01504040f, 0.19338609f, -0.23692785f, 0.15902658f, 0.01470870f, 0.01527948f, -0.18206811f, 
    -0.00327012f, -0.24022084f, 0.01307666f, 0.00628428f, -0.03501721f, -0.30934730f, -0.00602372f, 0.22126080f, 
    0.20717300f, 0.23330183f, -0.13328758f, -0.19948395f, -0.38627964f, -0.24519029f, 0.16489013f, 0.01989910f, 
    0.00223062f, 0.06268232f, -0.18717861f, 0.03023016f, -0.00156888f, 0.03808136f, -0.05444301f, -0.24198347f, 
    0.23603366f, 0.20297588f, 0.00446297f, 0.04139062f, 0.04296588f, 0.05516068f, 0.05917475f, -0.15264575f, 
    0.23037775f, -0.01378495f, -0.03295689f, -0.22266501f, -0.33163887f, 0.07035669f, 0.01190168f, 0.09678620f, 
    -0.00169473f, 0.00294728f, -0.17687549f, -0.22145718f, -0.05479570f, -0.06192672f, -0.20068428f, 0.04481303f, 
    -0.01937567f, 0.01660870f, 0.04172891f, -0.37030810f, 0.09772310f, -0.12363677f, -0.17481090f, -0.04009967f, 
    0.20876281f, -0.00355092f, -0.08609930f, -0.04132761f, 0.12771504f, -0.03295059f, -0.05261545f, -0.25987741f, 
    -0.38742837f, 0.14842734f, -0.09219012f, 0.04012389f, -0.81349772f, -0.61876982f, -0.03802977f, 0.17483197f, 
    0.04425439f, 0.10294923f, -0.12580733f, 0.15747696f, -0.04249667f, -0.16620548f, -0.35485989f, 0.66048074f, 
    0.21132064f, -0.55246496f, 0.03991745f, -0.25949812f, 0.10164870f, -0.17551477f, 0.09472954f, 0.06880119f, 
    -0.15935875f, -0.12912397f, -0.10647421f, 0.04479584f, 0.00462267f, 0.21253200f, 0.07335414f, 0.40205857f, 
    -0.61772895f, -0.54871118f, 0.26177654f, -0.01420637f, 0.11168199f, 0.07600448f, 0.17750329f, 0.10919853f, 
    0.06032240f, -0.01504537f, 0.02972558f, -0.18097132f, -0.03726976f, -0.05256045f, 0.03461760f, -0.06242288f, 
    -0.00766942f, 0.11639790f, 0.17474949f, 0.39305255f, -0.06439316f, 0.06798127f, 0.01517348f, -0.03064860f, 
    -0.02501072f, 0.13439582f, 0.12483951f, 0.26045325f, 0.24793839f, -0.01977127f, 0.03423379f, 0.00587480f, 
    0.15031730f, 0.03441173f, -0.01692331f, -0.12005394f, -0.17350304f, 0.14839137f, -0.22880477f, 0.01658490f, 
    0.14721064f, -0.06322810f, 0.07562331f, 0.03087519f, -0.10883745f, -0.19906943f, 0.07936019f, -0.15198377f, 
    -0.14118834f, 0.05663009f, 0.10411131f, 0.00490022f, -0.08543151f, -0.09083868f, 0.00940120f, -0.01073250f, 
    0.07517725f, -0.14252096f, 0.13715817f, 0.15494709f, 0.05592810f, 0.07700446f, 0.16544522f, 0.36147121f, 
    0.06650100f, 0.01959064f, -0.16313738f, 0.08222585f, 0.16507854f, 0.08395036f, 0.08659092f, 0.24015173f, 
    0.01814102f, 0.14602250f, 0.18602747f, -0.11196915f, -0.03590987f, -0.03817856f, 0.04044280f, -0.34979677f, 
    0.31216517f, 0.11615777f, 0.07926761f, -0.14893124f, -0.04301586f, -0.03639603f, 0.02041417f, 0.02216571f, 
    0.02126338f, -0.04951374f, -0.19821471f, -0.01551549f, 0.11577876f, -0.13992733f, 0.12126733f, 0.01666635f, 
    0.07173050f, -0.00476096f, -0.04137130f, 0.20315357f, 0.28098467f, 0.05565745f, 0.13646965f, -0.03955024f, 
    0.03131832f, 0.08515208f, -0.07088187f, -0.28181362f, -0.32366061f, 0.30766502f, -0.06276229f, -0.04731828f, 
    0.11044186f, 0.13475953f, -0.03250017f, -0.16989328f, 0.39815456f, 0.06441199f, -0.42806831f, 0.10637778f, 
    -0.11037540f, -0.12876403f, -0.00838302f, 0.06362627f, -0.07635029f, -0.62653804f, -0.04718034f, 0.38871485f, 
    -0.03059568f, -0.16027007f, -0.13682131f, 0.08889067f, 0.01010311f, 0.05315011f, 0.05770074f, -0.41454858f, 
    -0.24475393f, -0.07313919f, 0.16637796f, 0.20727149f, -0.03025024f, 0.05032931f, 0.20393766f, 0.22111665f, 
    -0.04643665f, -0.03120786f, 0.11287731f, -0.21994793f, 0.03402610f, 0.06871661f, -0.22568797f, -0.21596058f, 
    0.04430939f, -0.01962006f, 0.01141666f, 0.05120449f, -0.01142123f, -0.04138889f, -0.00316998f, 0.00625579f, 
    -0.03856314f, -0.02672606f, -0.02058583f, -0.05466881f, 0.03872457f, -0.02229947f, 0.00278252f, -0.06415904f, 
    -0.02575649f, 0.03843287f, 0.00467410f, -0.06524976f, 0.04855796f, 0.04198712f, -0.00887661f, -0.05574121f, 
    -0.05129979f, -0.00888897f, 0.02673399f, 0.03604518f, -0.06332912f, -0.02080619f, 0.00693628f, -0.05648899f, 
    -0.06452349f, -0.01619932f, -0.01618440f, -0.06192521f, -0.03985738f, -0.04457815f, 0.02767658f, -0.02026761f, 
    0.03322864f, -0.04024519f, 0.03199339f, 0.05223317f, 0.01291682f, 0.01467377f, -0.02862833f, -0.00066737f, 
    -0.04383741f, -0.05133490f, -0.05222642f, 0.00008108f, 0.00348481f, -0.02778052f, -0.03237499f, -0.05584514f, 
    -0.03893875f, -0.05110499f, -0.05617324f, -0.00824353f, -0.03667777f, 0.05577388f, 0.03287245f, -0.00601012f, 
    0.03795106f, -0.01285718f, -0.02350356f, -0.01302260f, 0.03780554f, -0.02043255f, 0.03199301f, -0.00150190f, 
    0.00204049f, -0.02981165f, -0.00857351f, -0.02020417f, -0.01752493f, -0.02603757f, 0.05629895f, 0.01512520f, 
    -0.03204758f, -0.04914171f, 0.02155150f, -0.04667832f, 0.00620810f, -0.00376092f, 0.03289659f, -0.04430141f, 
    0.01019331f, -0.04185561f, -0.02230488f, 0.00505562f, -0.02945604f, -0.00259685f, 0.03321285f, 0.00797566f, 
    -0.03554754f, -0.02795755f, -0.01955276f, -0.00225238f, -0.01419286f, -0.02130681f, 0.05874451f, 0.01180661f, 
    0.04768673f, -0.05869274f, 0.01737112f, 0.04414229f, -0.02115861f, -0.01254545f, 0.00132810f, -0.00049175f, 
    -0.06469236f, -0.05046050f, -0.01815593f, -0.02465038f, 0.00908114f, 0.03594029f, -0.05227251f, -0.02059937f, 
    -0.03927028f, -0.04917712f, -0.05255285f, 0.00902000f, 0.01839746f, 0.04470421f, -0.05462817f, -0.03734374f, 
    0.04953950f, -0.02103811f, -0.01665733f, 0.02475063f, -0.06289203f, -0.00589834f, -0.04646737f, -0.01726150f, 
    0.04653398f, -0.05143993f, 0.01533604f, -0.03599027f, 0.00166642f, -0.06412715f, 0.00041216f, -0.01452111f, 
    -0.04645838f, 0.05028273f, -0.04691951f, -0.03313801f, -0.00958562f, 0.04185161f, 0.02289611f, 0.01220186f, 
    -0.03491249f, 0.04258738f, -0.06437819f, -0.02474734f, -0.04301983f, 0.01368414f, 0.02294031f, 0.03206507f, 
    -0.03203592f, -0.06172966f, 0.04639266f, -0.02545889f, -0.03029427f, -0.06056181f, 0.02985409f, 0.00386734f, 
    -0.02082589f, -0.01667516f, 0.03914502f, -0.00190493f, -0.05219783f, -0.05134296f, -0.04435408f, -0.03835611f, 
    0.00357028f, -0.00167819f, -0.06054799f, -0.02122577f, 0.05184420f, -0.00727436f, 0.04173522f, 0.01934301f, 
    -0.03109160f, 0.04144371f, -0.01153262f, -0.01891313f, 0.00343527f, -0.00949487f, -0.04263924f, 0.02836299f, 
    -0.05809420f, -0.02600377f, -0.03545856f, 0.00944689f, -0.04295904f, 0.01361074f, 0.01426714f, -0.00799235f, 
    0.02546570f, -0.01488287f, 0.04052429f, -0.00588609f, -0.00603918f, 0.03736586f, 0.01109408f, -0.05577737f, 
    -0.03853310f, 0.02876505f, -0.02315640f, -0.01655294f, -0.01015571f, 0.01539063f, -0.01900906f, 0.00615644f, 
    -0.02545232f, -0.00035090f, -0.03281400f, 0.01314912f, -0.03040170f, 0.01079125f, 0.04598959f, -0.05972086f, 
    -0.05022984f, 0.04208801f, -0.01089279f, -0.03614189f, 0.03975692f, 0.01635174f, 0.01938654f, -0.05968698f, 
    -0.04974090f, 0.03184007f, -0.06249505f, 0.01955045f, 0.05769217f, -0.00201609f, 0.04705137f, 0.04632071f, 
    -0.05057744f, 0.03283488f, 0.00018024f, -0.02354713f, -0.01051822f, 0.04595988f, 0.02172470f, 0.03487640f, 
    -0.02484485f, 0.04575549f, 0.02578411f, -0.03502653f, -0.06358974f, 0.01969659f, -0.04589847f, -0.04883986f, 
    0.05205221f, -0.01902655f, -0.05087310f, 0.04714220f, -0.02139415f, -0.04748702f, -0.04810091f, -0.05654263f, 
    -0.00001926f, 0.03831974f, -0.06383663f, -0.01756015f, 0.05079084f, -0.01369456f, -0.03247110f, 0.04382578f, 
    0.03269873f, -0.05586890f, 0.00021140f, -0.04215541f, -0.02395828f, -0.01708078f, -0.02081507f, -0.04771990f, 
    -0.05055872f, -0.02016572f, -0.00642538f, 0.04210535f, -0.01525588f, 0.02849353f, -0.03736695f, -0.03514969f, 
    -0.18518119f, -0.25373951f, -0.02327101f, -0.00065368f, -0.16301671f, 0.01350453f, 0.01539159f, -0.03231958f, 
    0.00712507f, -0.07814888f, -0.28561690f, -0.22894041f, 0.00145943f, 0.00214115f, -0.05510048f, 0.18358126f, 
    -0.01346860f, 0.18308201f, -0.19303359f, -0.00968452f, 0.11518797f, -0.18787253f, 0.06937067f, 0.02581926f, 
    -0.01574620f, 0.10148356f, 0.18075569f, -0.24953413f, 0.20063253f, 0.05630498f, -0.00872498f, -0.16743731f, 
    -0.13974081f, 0.24676882f, -0.17329738f, -0.04673356f, 0.06369384f, -0.15564637f, 0.06921483f, 0.03149433f, 
    0.01314683f, -0.06384420f, 0.20172779f, 0.23902068f, 0.00602605f, 0.04196804f, 0.32382810f, 0.39737847f, 
    -0.31218821f, -0.25549740f, 0.14744428f, -0.14203353f, -0.13442600f, 0.26047561f, -0.08397916f, 0.00860174f, 
    0.03795392f, -0.06862336f, 0.18402073f, -0.14027934f, -0.00434219f, -0.14888184f, -0.11567332f, -0.08597547f, 
    -0.01487363f, 0.43959430f, -0.13178691f, 0.06929985f, -0.06565595f, 0.02461021f, -0.12378166f, -0.03914080f, 
    0.01228100f, -0.08460613f, 0.16992085f, -0.04339497f, 0.16531023f, -0.24598166f, 0.14829108f, 0.01341534f, 
    0.13097705f, -0.09956922f, -0.22092925f, 0.11050589f, 0.02264670f, -0.05386681f, -0.03423378f, -0.01287821f, 
    -0.01473097f, 0.19670318f, -0.45112219f, 0.16009308f, 0.23526965f, -0.20795423f, 0.05420187f, -0.33483499f, 
    0.19143319f, -0.27254397f, 0.15957057f, -0.22835791f, -0.06609740f, -0.24014033f, -0.07139641f, -0.00361314f, 
    -0.25045833f, -0.26743034f, -0.00726703f, -0.03181896f, -0.41820282f, 0.05878066f, -0.72894198f, -0.05779661f, 
    0.07177101f, -0.03042227f, 0.07236680f, 0.03443077f, -0.22654052f, -0.69872880f, -0.27759999f, 0.28869411f, 
    0.03434418f, 0.15310992f, -0.52403885f, -0.03075521f, 0.01835554f, 0.05099165f, -0.02160370f, -0.15634044f, 
    -0.02903961f, -0.02223014f, 0.10407238f, -0.17895418f, -0.22846729f, 0.25605187f, 0.17833352f, 0.73118347f, 
    0.43086478f, 0.09591121f, -0.18297665f, 0.00577332f, -0.03417954f, -0.01542564f, 0.02498295f, -0.05304411f, 
    0.07196078f, -0.25881714f, 0.12447865f, 0.03513077f, -0.06696253f, -0.08294222f, 0.16145636f, 0.05474024f, 
    0.10283140f, -0.18936624f, 0.43266895f, -0.00233220f, 0.02804272f, -0.13941967f, -0.19095717f, 0.19033854f, 
    -0.10766431f, -0.20142183f, -0.16182224f, 0.22429328f, 0.29860404f, -0.06738341f, 0.01992014f, 0.10198149f, 
    0.07267319f, 0.23826152f, 0.15004708f, 0.03707708f, 0.24783891f, -0.53117681f, -0.06754690f, -0.24689686f, 
    0.20308217f, -0.05890788f, -0.13117732f, -0.16217184f, -0.24154486f, -0.15764743f, -0.10690110f, -0.16516471f, 
    -0.29315525f, 0.19803743f, -0.14471014f, -0.07472771f, 0.08831338f, -0.03720377f, -0.06825422f, -0.00819971f, 
    0.07946234f, -0.00843006f, 0.06592227f, 0.04848391f, 0.11274274f, -0.23263769f, 0.00056850f, -0.11964836f, 
    0.19313346f, -0.00821809f, -0.02040184f, -0.03464268f, 0.10836111f, -0.20533523f, 0.10517588f, 0.44603837f, 
    0.00540462f, 0.13240363f, -0.15258355f, -0.08164769f, -0.09309277f, 0.22234198f, -0.00187258f, -0.09420626f, 
    -0.06413864f, 0.35417527f, 0.28263935f, 0.03461838f, -0.17294383f, -0.12339523f, 0.02183031f, 0.02683427f, 
    -0.09464474f, -0.47616234f, 0.07104634f, 0.13067794f, 0.08823188f, 0.09082922f, -0.04859880f, 0.07254813f, 
    -0.06679668f, -0.08028986f, 0.00744465f, 0.27782077f, 0.31090888f, 0.05692226f, 0.04281115f, -0.23440818f, 
    0.03038991f, -0.18614197f, -0.11052328f, -1.10052812f, -0.16845657f, 0.12079220f, -0.08684692f, 0.17731079f, 
    -0.38290089f, 0.05857649f, 0.15063605f, 0.09143251f, 0.08810031f, 0.14298974f, 0.45466813f, 0.08828902f, 
    -0.03634214f, 0.07151707f, 0.01154328f, 0.10008544f, -0.11621483f, -0.36154571f, 0.38622546f, 0.10660974f, 
    0.03058596f, -0.11198352f, -0.06533583f, 0.14748368f, 0.08064209f, 0.24958342f, -0.01029467f, 0.18111537f, 
    -0.14315477f, -0.00391636f, 0.17930004f, 0.10642249f, 0.06722979f, -0.00640133f, 0.03045658f, 0.42626262f, 
    0.28916854f, 0.18657967f, -0.08272055f, 0.00196735f, 0.06552351f, -0.01267283f, 0.25262347f, 0.08746730f, 
    -0.54177523f, -0.32174695f, 0.12216843f, -0.15424725f, 0.12970985f, 0.18049128f, 0.01465548f, -0.10034047f, 
    -0.08502901f, 0.44750211f, -0.22063431f, -0.47085857f, 0.11991731f, -0.23674284f, -0.01147982f, 0.00848602f, 
    0.00681789f, 0.01822026f, -0.02214726f, 0.17317940f, 0.11345036f, 0.16482799f, 0.16600293f, -0.21099862f, 
    0.26288569f, 0.07924906f, -0.16862524f, 0.02120384f, 0.14427504f, 0.12988375f, 0.04589349f, 0.02667615f, 
    0.08163843f, -0.14443886f, -0.07167571f, -0.03200345f, -0.01898420f, -0.58426583f, -0.40583009f, -0.10266017f, 
    -0.06746964f, -0.02981152f, 0.07243802f, -0.07821284f, -0.15310553f, -0.32859731f, 0.15925097f, -0.11752324f, 
    -0.02096223f, 0.06027568f, -0.10733452f, 0.07432526f, 0.05054175f, -0.01195091f, -0.70947677f, -0.26709491f, 
    -0.29244396f, -0.14044704f, 0.07628979f, 0.19991979f, -0.13526532f, 0.12529601f, -0.15767437f, -0.13377957f, 
    0.17228074f, -0.19564746f, -0.10770248f, 0.06079341f, 0.01909228f, -0.06662738f, -0.04792984f, 0.15000211f, 
    -0.10792422f, -0.19187726f, -0.26839954f, -0.13897978f, -0.09278946f, 0.13576391f, -0.07690785f, 0.06597073f, 
    0.13803925f, 0.58942127f, -0.07964945f, -0.10619346f, -0.09082007f, 0.06167216f, -0.01426026f, 0.15056947f, 
    0.06460977f, 0.24204229f, -0.13057530f, 0.12287746f, 0.57504416f, -0.10056078f, 0.01866489f, 0.08531096f, 
    0.15598041f, 0.25566876f, 0.05890352f, -0.11601723f, -0.01471211f, 0.20026985f, -0.02877314f, -0.00616353f, 
    -0.25363615f, 0.27873102f, 0.26556453f, 0.05068999f, -0.65377653f, 0.32246652f, 0.03335834f, 0.02655670f, 
    0.18506028f, 0.05149699f, 0.05173618f, -0.00828957f, 0.02270721f, 0.28957185f, 0.06004828f, 0.33833909f, 
    0.18374571f, -0.22997802f, 0.19943216f, 0.13268870f, 0.18247834f, -0.07200385f, -0.35394531f, 0.14454922f, 
    0.26027215f, 0.16562700f, 0.03868335f, 0.27975526f, -0.36388698f, -0.15430343f, 0.04912335f, -0.62075448f, 
    -0.18065169f, 0.51207304f, -0.31695697f, -0.34692383f, -0.06428719f, -0.22098677f, -0.13850138f, 0.10204279f, 
    -0.01380656f, -0.03571774f, -0.24730553f, -0.13277294f, -0.14978758f, -0.07167986f, 0.14693263f, -0.25733355f, 
    -0.10601795f, 0.09983046f, -0.05061679f, -0.17027850f, 0.02099324f, -0.05492094f, -0.15816545f, 0.03583890f, 
    0.05044779f, -0.29374135f, 0.01494596f, -0.00731818f, -0.08004264f, 0.06480567f, 0.02516672f, -0.06478975f, 
    -0.02178529f, -0.06787676f, -0.12155194f, -0.63181496f, 0.17057887f, 0.06777196f, 0.11550505f, 0.06497435f, 
    0.50150567f, -0.10354825f, 0.15901864f, 0.03517750f, -0.64499938f, -0.38338614f, 0.16195202f, 0.17542039f, 
    0.00563373f, 0.18523499f, -0.03313792f, 0.16955169f, 0.03100345f, -0.49042642f, -0.54626083f, 0.12618993f, 
    0.19382353f, -0.00093002f, 0.10222773f, 0.05113053f, 0.01652059f, 0.18358457f, -0.12714328f, -0.16421458f, 
    0.34703177f, -0.00855132f, 0.08931836f, 0.15109949f, -0.16428548f, -0.08393126f, -0.17181909f, 0.00489902f, 
    -0.13405190f, 0.16814989f, -0.33170927f, 0.21552615f, -0.10927005f, 0.08550265f, 0.01204058f, -0.15461315f, 
    0.21398114f, 0.14917722f, -0.07386186f, 0.17011344f, 0.02462333f, 0.06530106f, 0.12353642f, 0.04813610f, 
    -0.04289834f, 0.42342964f, -0.18828607f, -0.00408121f, 0.24594589f, -0.16418321f, 0.00848936f, 0.24295498f, 
    0.30241701f, -0.04466971f, 0.00965319f, 0.19334741f, -0.00538655f, -0.05590153f, 0.03446340f, -0.06460010f, 
    0.03053198f, -0.15909877f, -0.04463860f, 0.69633877f, 0.06058017f, -0.28343186f, 0.04400682f, -0.20481826f, 
    -0.08861297f, 0.17140611f, 0.16871697f, 0.10518628f, -0.14862168f, 0.19004285f, -0.07182528f, -0.18557124f, 
    -0.17081580f, 0.18105561f, 0.08318163f, 0.00435113f, -0.11679607f, -0.08480096f, -0.18114163f, -0.00496717f, 
    0.03139232f, 0.20539610f, -0.12338436f, 0.20813869f, 0.20327906f, -0.10871250f, -0.53721720f, -0.13652019f, 
    -0.27594161f, 0.04899792f, 0.06017966f, 0.08461227f, -0.07446080f, -0.12729371f, 0.05451604f, 0.03571100f, 
    0.06469796f, 0.08110198f, -0.14825174f, -0.08333568f, 0.27517748f, 0.32277495f, -0.10015911f, -0.10306107f, 
    0.07721504f, -0.01870052f, 0.02060381f, 0.11518234f, -0.31789407f, -0.08114802f, -0.02517633f, 0.17596956f, 
    -0.01176736f, 0.20994399f, 0.08035813f, 0.16359629f, -0.07516184f, -0.30367544f, -0.52105707f, -0.00844269f, 
    0.04514762f, 0.09022998f, 0.22479875f, -0.18992804f, -0.80064291f, 0.04681506f, 0.11515481f, -0.03755461f, 
    0.10309414f, -0.02368534f, -0.16185251f, -0.08581718f, 0.12141445f, 0.17647494f, -0.08888585f, 0.01645471f, 
    0.02106768f, 0.08620331f, 0.01044908f, 0.05645835f, 0.24398804f, 0.16146334f, 0.18300568f, -0.14642294f, 
    -0.22932081f, -0.40914229f, -0.02148260f, 0.07567295f, 0.03870823f, -0.03514589f, 0.48113850f, 0.41358212f, 
    0.10713781f, -0.06559831f, -0.06524446f, 0.08419174f, -0.01417248f, 0.12007774f, 0.13180846f, 0.12585953f, 
    -0.04131136f, -0.07399482f, -0.02182001f, 0.29328045f, 0.18941908f, 0.04912816f, 0.05530918f, -0.02855174f, 
    0.29570991f, 0.63944113f, -0.08198559f, -0.04318592f, -0.21242656f, -0.05255779f, -0.01501906f, -0.05063923f, 
    0.16090511f, 0.03625027f, -0.06132038f, 0.02267331f, -0.11506770f, 0.03551534f, -0.00274539f, 0.09749091f, 
    0.06608790f, 0.04025088f, -0.10791729f, -0.24213369f, 0.01916036f, -0.24855541f, -0.23490679f, 0.04565894f, 
    0.08546641f, 0.02060942f, 0.53548056f, -0.46325672f, -0.90044862f, 0.14911833f, -0.30967975f, 0.25393215f, 
    0.04261258f, -0.03645362f, 0.07068699f, 0.20575188f, 0.08042777f, 0.06058020f, -0.29665560f, -0.09376584f, 
    -0.54594988f, 0.10340581f, -0.02532912f, 0.01269165f, -0.47672600f, -0.61071974f, 0.38990369f, -0.07484724f, 
    -0.06769629f, -0.25080055f, 0.18262188f, 0.11527028f, 0.03230740f, 0.07157945f, 0.07577633f, -0.37739062f, 
    -0.06240127f, -0.13899243f, 0.14594327f, 0.06406856f, -0.06796139f, -0.10600896f, 0.06580716f, 0.01037764f, 
    -0.02512313f, 0.01358481f, 0.01745657f, 0.00786781f, 0.09857300f, 0.01090753f, 0.02829639f, 0.01936186f, 
    -0.11398493f, -0.11477029f, -0.02075655f, -0.08428794f, 0.01123611f, 0.19352999f, 0.15416873f, 0.03558408f, 
    0.04558019f, -0.03823570f, 0.09451231f, 0.10738520f, -0.11041460f, 0.11232748f, -0.03011236f, 0.21628487f, 
    0.08458308f, 0.21291392f, 0.40526748f, -0.13576308f, -0.09051460f, -0.05667056f, -0.06428301f, 0.06001670f, 
    0.02285609f, 0.10676366f, 0.14766413f, 0.36830813f, 0.10936596f, -0.06663483f, -0.02685761f, 0.04801798f, 
    0.14047831f, -0.08407169f, -0.04007691f, 0.06711263f, -0.26567531f, -0.47950667f, 0.03839260f, 0.30000401f, 
    -0.08766393f, -0.14615858f, -0.19077420f, 0.04174129f, 0.16092826f, 0.01856588f, 0.04841104f, -0.04780493f, 
    -0.25092533f, -0.16285837f, -0.05936933f, 0.13358362f, 0.03133433f, 0.12834874f, 0.19163358f, 0.03650181f, 
    0.02165478f, 0.02099416f, -0.10091403f, -0.00169114f, -0.11789837f, 0.01444098f, 0.06750049f, 0.02845202f, 
    -0.22605306f, 0.03434906f, -0.22215189f, 0.05328457f, -0.10345140f, -0.01645964f, -0.02237363f, -0.27058077f, 
    -0.02306131f, 0.23519219f, 0.01327424f, 0.04816955f, -0.16024724f, 0.13334246f, -0.20624138f, 0.21708454f, 
    0.13799582f, 0.06758332f, -0.25895229f, 0.06842327f, -0.02422905f, -0.07332864f, 0.03834813f, -0.03984106f, 
    -0.01787247f, 0.19681586f, 0.10360084f, 0.12819275f, 0.08008199f, -0.15370633f, -0.23020704f, -0.07356229f, 
    -0.01191087f, 0.02329134f, 0.15407372f, 0.31531674f, 0.10200410f, 0.08920991f, -0.17747720f, -0.13115776f, 
    0.01564253f, 0.00218789f, 0.04053139f, 0.55577123f, 0.20670238f, 0.07981574f, 0.13128285f, 0.04378517f, 
    0.37044272f, 0.04928823f, -0.09039422f, -0.19101213f, -0.47097287f, 0.28223130f, -0.65695262f, -0.09821130f, 
    -0.04933481f, -0.10534263f, 0.11147909f, 0.15136833f, 0.37100875f, -0.21091652f, -0.05040640f, 0.31367391f, 
    -0.23807868f, -0.05764508f, -0.19557913f, -0.01504643f, 0.12546043f, -0.08783012f, -0.04917134f, -0.26397386f, 
    0.08968115f, -0.06676374f, -0.03264460f, -0.13013984f, 0.02016049f, 0.14338017f, -0.06356120f, -0.11710735f, 
    0.18819852f, 0.07556162f, 0.01763249f, -0.01576308f, -0.14257509f, 0.13069406f, 0.10075710f, 0.09148590f, 
    0.01242283f, 0.16588709f, 0.11338186f, 0.11108939f, -0.00755121f, -0.01963788f, 0.17267185f, -0.06307754f, 
    -0.16899975f, 0.20279153f, 0.06121050f, 0.13677096f, -0.00995866f, -0.11148525f, -0.01575484f, -0.06439165f, 
    -0.02180109f, -0.17224166f, 0.24355803f, 0.37929410f, -0.31928128f, 0.11064914f, -0.02657121f, -0.53459030f, 
    0.01654923f, 0.01999833f, -0.03928074f, -0.35864118f, 0.24675246f, -0.17781582f, -0.22691062f, 0.08843564f, 
    -0.16097532f, -0.03722357f, 0.09876385f, -0.11375278f, 0.13677308f, 0.09176267f, 0.20014092f, -0.00884859f, 
    -0.03998463f, -0.07986004f, 0.01794245f, 0.04754319f, -0.09324707f, 0.14083588f, -0.00070793f, 0.08843367f, 
    -0.13783239f, -0.18709646f, 0.11253266f, -0.02152090f, -0.11510325f, -0.01068705f, 0.12366689f, 0.04806238f, 
    0.13365966f, -0.04044677f, -0.07832169f, -0.06104945f, -0.11306959f, -0.07218444f, -0.11409098f, -0.04571274f, 
    0.29855242f, 0.03004568f, -0.24171063f, -0.04710460f, -0.11574031f, -0.13927925f, -0.12816678f, -0.01144910f, 
    0.18961073f, 0.02642133f, 0.11551332f, -0.11314818f, -0.07568393f, -0.05146410f, 0.07072575f, 0.04676623f, 
    -0.14715095f, 0.48050311f, 0.08878269f, 0.21022762f, -0.05037137f, -0.06897613f, -0.09057830f, 0.04715899f, 
    0.05516618f, -0.06715012f, 0.19700104f, 0.21284615f, 0.19364434f, -0.13650939f, -0.00145303f, -0.27328670f, 
    0.17061314f, 0.18235679f, -0.15061800f, 0.30929360f, 0.12978533f, 0.21686837f, -0.02352659f, -0.01778686f, 
    -0.03455516f, 0.05313140f, 0.05319975f, -0.10309930f, -0.69545424f, 0.09273080f, 0.09957848f, 0.18157305f, 
    -0.08755761f, 0.15034299f, 0.04133188f, -0.03105723f, -0.11924878f, 0.09885391f, -0.13418318f, 0.14756890f, 
    -0.08000885f, -0.08573203f, 0.02101143f, 0.18077287f, 0.03879890f, -0.00588165f, 0.27200916f, 0.09086594f, 
    0.06468930f, 0.05909958f, 0.04656067f, 0.02603874f, -0.03072564f, -0.07868669f, -0.06266835f, 0.20802785f, 
    0.18031955f, 0.13491671f, 0.20038193f, 0.14230137f, 0.06478753f, 0.01289793f, 0.04799589f, -0.06808102f, 
    0.16550270f, 0.08437944f, 0.20521073f, 0.01319017f, 0.02926043f, 0.01625667f, 0.12267037f, -0.01354920f, 
    -0.25208884f, -0.10647288f, 0.04925429f, -0.29278234f, -0.21216144f, -0.29790825f, -0.25018379f, -0.04855670f, 
    0.01433471f, 0.01491308f, -0.35109991f, -0.28963277f, -0.39616495f, -0.16642138f, -0.26530746f, -0.13610646f, 
    0.04863465f, 0.02268544f, -0.01397888f, -0.73554033f, 0.03082872f, 0.17298727f, 0.13608922f, 0.03710483f, 
    -0.16660166f, 0.24080768f, -0.07545081f, 0.22194341f, -0.12872142f, 0.12184810f, 0.22646059f, -0.05879186f, 
    -0.11294978f, -0.03590945f, 0.01438531f, 0.05400813f, -0.00630942f, 0.11512822f, 0.03909614f, 0.14693068f, 
    0.15943642f, 0.04657663f, 0.02573960f, 0.09996975f, 0.06389777f, -0.04794574f, 0.19999056f, 0.09165333f, 
    -0.05435653f, 0.04215937f, 0.25945795f, 0.08199084f, 0.03793012f, -0.09793286f, -0.15940754f, 0.13100398f, 
    -0.19594651f, -0.02462366f, 0.20537712f, 0.15905295f, 0.02665477f, 0.11408335f, 0.16086355f, 0.08870807f, 
    -0.17470402f, -0.12750666f, 0.07137142f, -0.05130636f, -0.19986783f, -0.25017080f, -0.01488771f, -0.08849673f, 
    -0.00843038f, 0.11914997f, 0.03411529f, 0.22518015f, 0.08990484f, -0.01866001f, -0.06493077f, 0.02468801f, 
    -0.13479699f, -0.07571432f, 0.26232180f, 0.24302694f, 0.05394183f, -0.09779990f, -0.05025176f, -0.04340408f, 
    -0.14200234f, 0.00387887f, 0.00903405f, -1.39270747f, 0.23996635f, -0.13949956f, -0.13823301f, 0.13375510f, 
    -0.21505477f, -0.10901957f, -0.17546435f, -0.07045943f, -0.31087029f, -0.59348321f, -0.35019737f, -0.00287371f, 
    0.01559246f, 0.07401623f, 0.05066851f, 0.08779588f, 0.02837470f, -0.37114555f, 0.00106453f, 0.11162468f, 
    0.04593401f, -0.06257337f, 0.02512408f, 0.02269205f, 0.03343393f, -0.08795342f, -0.03495682f, 0.23135112f, 
    0.12423686f, 0.21996018f, -0.03138597f, 0.09270312f, 0.08285714f, -0.05416601f, -0.13848384f, 0.33426586f, 
    0.16672991f, 0.12077148f, 0.19208489f, 0.11914490f, 0.05703142f, 0.13599578f, 0.17568821f, 0.16734627f, 
    0.19120157f, -0.10482424f, -0.00215604f, -0.19605199f, -0.31197503f, 0.18530063f, -0.10001887f, 0.01972895f, 
    0.06686214f, -0.00796750f, -0.29579434f, -0.14034259f, -0.09980729f, -0.18281394f, 0.01489022f, 0.00140548f, 
    0.03163855f, 0.04135245f, -0.37426144f, -0.10803172f, 0.80046833f, -0.01599117f, 0.14400934f, 0.20301022f, 
    -0.01711642f, 0.09934382f, 0.10130109f, 0.18476266f, -0.17009816f, -0.17893040f, -0.01826630f, 0.10688241f, 
    -0.19129559f, 0.10662895f, -0.11126638f, 0.05528209f, 0.02644285f, -0.09949169f, -0.13224331f, -0.35514158f, 
    -0.19665222f, 0.01584130f, 0.08015195f, -0.00138775f, 0.04808995f, -0.15565231f, -0.17099643f, 0.07379860f, 
    -0.05576899f, -0.03988180f, -0.04182876f, -0.10341213f, -0.00864910f, 0.35768110f, 0.01135683f, 0.02991134f, 
    -0.04440788f, -0.15363167f, 0.08863649f, 0.00641062f, 0.10763517f, 0.20398615f, 0.15977205f, -0.64909273f, 
    -0.56757390f, -0.47567555f, -0.13868417f, -0.00449834f, -0.08360437f, 0.04796881f, -0.09371086f, 0.12350986f, 
    0.04697389f, 0.06942292f, -0.08149876f, -0.12651826f, -0.17840676f, -0.00379487f, 0.06760546f, 0.00790294f, 
    0.08703660f, -0.01336329f, 0.11473348f, 0.18486521f, -0.10118445f, -0.02437826f, 0.30351013f, 0.09557731f, 
    -0.02669508f, 0.05504051f, -0.28315642f, 0.14926127f, 0.56176621f, 0.05247626f, 0.19505560f, 0.05163554f, 
    -0.06705672f, 0.01612425f, -0.01559384f, -0.08909463f, -0.09916466f, -0.01329162f, -0.36930400f, 0.02422668f, 
    -0.31120485f, 0.09315798f, 0.08261641f, 0.00374364f, -0.08958370f, 0.05671515f, -0.40306479f, -0.02755515f, 
    -0.07285354f, 0.16946292f, 0.22426333f, 0.25651905f, 0.03010003f, 0.14740817f, -0.03829540f, 0.15961464f, 
    0.00863605f, 0.06242820f, -0.27687895f, 0.12576246f, 0.08485828f, 0.13881840f, -0.01125697f, -0.02981208f, 
    0.05945401f, 0.11474600f, -0.04292930f, -0.08106213f, -0.02072713f, 0.01261472f, 0.18671408f, -0.13343173f, 
    0.04428081f, 0.30807143f, 0.02355370f, 0.00821178f, -0.12703227f, 0.09777413f, 0.07410204f, 0.03338037f, 
    -0.00704140f, -0.03377423f, 0.00826027f, -0.44734424f, 0.02695967f, -0.00090012f, 0.03150325f, -0.05478664f, 
    -0.00027439f, -0.73851365f, -0.90450716f, -0.20298520f, -0.19682437f, -0.02673090f, -0.07879427f, 0.03180624f, 
    -0.05921822f, 0.07746445f, -0.55031604f, 0.02849742f, -0.23877296f, -0.08819534f, -0.04772338f, -0.10693182f, 
    -0.00282087f, -0.14178771f, 0.09920441f, 0.60621482f, 0.04324822f, 0.32811859f, 0.35022125f, -0.22459975f, 
    0.42102352f, -0.12988403f, 0.01566341f, 0.18744268f, 0.14367700f, -0.04983915f, -0.07142814f, -0.08136574f, 
    -0.29174078f, 0.27654207f, -0.08094279f, 0.08071567f, 0.12112956f, 0.09783756f, 0.04812379f, -0.02582440f, 
    -0.12049887f, -0.15076867f, 0.13852678f, 0.02207123f, -0.00093386f, 0.03831409f, 0.26299143f, -0.20257954f, 
    0.30524293f, 0.06130116f, -0.07017934f, 0.01885982f, -0.08458103f, 0.02661958f, -0.02475281f, 0.01108999f, 
    -0.08493965f, 0.32592750f, -0.06629900f, 0.09109250f, -0.06016521f, -0.05637058f, -0.25902227f, 0.22572000f, 
    0.14531538f, 0.28975925f, 0.23782751f, -0.09155740f, 0.05764897f, 0.00965358f, 0.03708143f, -0.00639546f, 
    -0.03395287f, 0.19882159f, 0.10137410f, -0.19109197f, -0.03376247f, -0.07605096f, 0.02787410f, -0.00630521f, 
    0.16220856f, 0.10560527f, -0.96140069f, -1.03739738f, -0.30578950f, -0.08684069f, 0.14320870f, -0.22030726f, 
    -0.03774038f, -0.08433743f, 0.10822307f, 0.41568691f, 0.43250319f, 0.35736004f, -0.03673262f, -0.17435168f, 
    -0.23290080f, -0.33597183f, 0.17022903f, 0.12767269f, -0.84028971f, -0.17205350f, 0.22105794f, -0.05005415f, 
    0.02299421f, -0.18092090f, 0.28690720f, 0.29312286f, 0.05417069f, 0.02327763f, 0.34870893f, -0.01383546f, 
    -0.00261231f, 0.15491924f, 0.19738762f, 0.04733209f, 0.20304811f, 0.04781355f, 0.30077496f, -0.16408475f, 
    -0.03720130f, 0.13034101f, -0.06286836f, 0.00359229f, 0.18086508f, 0.24145234f, 0.02817822f, 0.05800842f, 
    0.07991460f, 0.17984718f, -0.04050955f, -0.20742545f, -0.00001157f, 0.19107318f, -0.06970726f, -0.00584726f, 
    0.04224924f, -0.57628089f, -0.42042607f, 0.01347542f, -0.03913263f, 0.23975943f, 0.15766867f, 0.08098923f, 
    0.18097712f, -0.38010451f, -0.52708769f, -0.21240018f, -0.01109836f, -0.19000947f, 0.10609839f, 0.07778815f, 
    -0.02979098f, -0.09084670f, -0.26541936f, 0.30456987f, 0.18085784f, -0.11244980f, -0.04395154f, -0.16028228f, 
    0.03000714f, 0.00011310f, -0.09767037f, 0.51185429f, -0.19323955f, 0.09050737f, 0.03540815f, -0.07821596f, 
    -0.12405015f, -0.06143336f, -0.01016174f, -0.07654058f, -0.31180981f, -0.16171806f, -0.09593002f, -0.01838195f, 
    -0.27405265f, 0.01937872f, 0.12156674f, 0.14761336f, 0.13394530f, 0.28533697f, 0.13421910f, -0.05401080f, 
    0.10845050f, 0.14932954f, 0.18035965f, 0.14047059f, 0.17506425f, 0.07017934f, -0.05998133f, -0.16949572f, 
    -0.41255271f, -0.69045466f, -0.75071341f, -0.69956225f, -0.60652977f, 0.05986761f, -0.20090531f, 0.21107110f, 
    -0.14433956f, -0.03716648f, 0.16525228f, -0.02922970f, 0.01188816f, -0.00785183f, 0.12359689f, 0.06043426f, 
    -0.11406322f, -0.08101308f, -0.18270002f, 0.22193819f, -0.30111793f, -0.13915408f, 0.26069027f, 0.22483686f, 
    0.37456238f, -0.17598414f, -0.11793224f, 0.23155625f, 0.12043774f, -0.03140207f, 0.05139965f, 0.05186059f, 
    0.26412329f, 0.20867133f, -0.38327542f, 0.22821069f, 0.12175387f, 0.04475844f, -0.11611734f, 0.02093462f, 
    -0.01627478f, 0.07868788f, 0.02981508f, -0.34851819f, -0.34909594f, -0.17125432f, 0.07386671f, 0.04588909f, 
    0.07126187f, -0.31140500f, -0.31402916f, -0.38668615f, 0.66984683f, 0.06398413f, -0.36636016f, -0.12180117f, 
    -0.05638335f, -0.18852670f, 0.16847643f, 0.29132777f, 0.07598428f, -0.16887091f, -0.11125645f, -0.22976898f, 
    0.29518473f, -0.04090403f, 0.11661290f, 0.25644657f, -0.18111654f, 0.12472036f, 0.11289930f, -0.22491106f, 
    -0.28225487f, -0.08652852f, -0.01903903f, -0.04368251f, 0.10752843f, 0.34070960f, 0.16918264f, -0.54653996f, 
    0.02551070f, -0.01183733f, -0.03750101f, 0.03220709f, 0.03947049f, 0.21979502f, 0.01244753f, 0.16268699f, 
    -0.34197775f, -0.18316489f, 0.05646585f, -0.03138943f, -0.25697511f, -0.04131232f, 0.04982706f, 0.16235048f, 
    0.21907192f, -0.16150944f, -0.49418947f, 0.29202062f, 0.07098643f, 0.18093801f, -0.01412363f, 0.18806063f, 
    0.09614451f, -0.37590989f, -0.28363845f, -0.11207370f, 0.33438662f, 0.08275674f, 0.06043083f, 0.12538393f, 
    0.16431892f, 0.16068584f, -0.07843696f, 0.68343776f, -0.13285486f, -0.30994168f, -0.00799365f, -0.17052017f, 
    -0.13678990f, -0.08757673f, 0.01368177f, 0.16587201f, 0.12861606f, -0.28794527f, -0.30022126f, -0.26832446f, 
    0.18479912f, -0.01202021f, -0.03751202f, 0.24559556f, 0.05059622f, -0.41655120f, -0.15168898f, -0.13873504f, 
    -0.02398405f, -0.10517335f, -0.17709586f, -0.11253674f, 0.05954257f, 0.12852326f, 0.15343709f, -0.28608373f, 
    0.18847674f, -0.07954617f, 0.08587826f, 0.25157365f, 0.00735872f, 0.09649320f, 0.05208943f, -0.24817607f, 
    0.12200069f, 0.12763177f, 0.35820210f, -0.10567684f, 0.11452819f, -0.04100731f, -0.35810381f, 0.12446915f, 
    -0.05533307f, -0.18264753f, 0.34780365f, -0.01930116f, -0.05440746f, 0.16917406f, 0.04745168f, -0.01932988f, 
    -0.03440863f, 0.05331375f, 0.06940950f, -0.14242655f, 0.07617156f, -0.18148746f, 0.14408320f, 0.01840510f, 
    -0.06746624f, 0.08269618f, 0.12220766f, -0.24834031f, 0.22008643f, 0.07449892f, 0.07721542f, -0.08745105f, 
    -0.06865248f, 0.07675742f, 0.00366611f, -0.16132855f, 0.21882354f, -0.04851110f, 0.04061353f, -0.11128324f, 
    -0.27552867f, 0.01387332f, -0.12401813f, -0.10619006f, -0.21726447f, -0.04572439f, 0.45564654f, -0.23405957f, 
    0.02925934f, 0.03129439f, 0.39237398f, -0.04049579f, -0.21976022f, 0.27638605f, -0.13579223f, -0.16753317f, 
    0.08607204f, -0.03519524f, -0.08406509f, 0.17253344f, 0.16628042f, 0.00491093f, 0.20225203f, -0.05403244f, 
    -0.22343619f, -0.08602668f, -0.05236207f, 0.05516469f, 0.13632643f, 0.21860810f, 0.18281467f, -0.26373523f, 
    0.03165406f, -0.00003976f, 0.01895235f, -0.18319529f, 0.11247343f, 0.16345592f, -0.08402575f, -0.01052067f, 
    -0.01540478f, -0.04414595f, -0.04072920f, 0.01377471f, 0.01838888f, -0.03783083f, 0.03445256f, 0.00284642f, 
    0.04494020f, -0.01626751f, 0.03933119f, 0.01890895f, -0.05342463f, -0.06015719f, 0.02429520f, 0.03814877f, 
    -0.03924724f, -0.03016968f, 0.03123279f, 0.03462636f, -0.02186903f, 0.01781276f, -0.02177767f, 0.02675839f, 
    -0.03092253f, -0.01405342f, 0.02998384f, 0.03608128f, -0.00062228f, -0.04936541f, -0.04779133f, 0.03500376f, 
    -0.02610631f, -0.03928250f, 0.03231279f, 0.00589906f, 0.01143161f, -0.00321546f, -0.03744471f, 0.04025985f, 
    0.04652471f, 0.03749420f, 0.01132434f, -0.05281283f, 0.01580197f, -0.01804630f, -0.06469066f, -0.06733342f, 
    -0.05633890f, 0.04300284f, 0.01451052f, 0.01587444f, 0.01891505f, 0.03175202f, -0.00771275f, -0.03529348f, 
    -0.00174169f, -0.02465745f, 0.00884438f, -0.03204190f, -0.00436592f, 0.00609238f, -0.04667790f, -0.05164759f, 
    0.04485067f, -0.03511741f, -0.03313559f, 0.02084158f, 0.00483654f, -0.01937790f, -0.01650948f, -0.03039582f, 
    -0.01298990f, 0.03608455f, -0.02676787f, 0.01647584f, 0.04358414f, 0.03827016f, 0.00489444f, 0.02871364f, 
    0.02727299f, 0.02468636f, 0.01782954f, 0.00301214f, -0.03065457f, 0.01641934f, 0.04474936f, 0.01342497f, 
    0.01072025f, -0.00420468f, -0.01883621f, -0.03245527f, 0.02201521f, -0.02660673f, -0.06630857f, -0.06414107f, 
    -0.05977970f, 0.03600872f, -0.05716648f, 0.03880530f, -0.06185504f, 0.02296165f, 0.01447640f, -0.06077035f, 
    -0.03620449f, -0.05024252f, 0.00826353f, -0.06672534f, -0.00864933f, 0.00741423f, 0.02983875f, -0.06382648f, 
    -0.02591446f, 0.03701469f, 0.01554443f, 0.02584107f, -0.05895377f, 0.01666509f, -0.00108330f, 0.03494031f, 
    -0.02573077f, 0.03171502f, -0.05234580f, -0.02073413f, -0.06389407f, 0.04510228f, 0.02794317f, 0.03293874f, 
    -0.04635148f, 0.01538786f, 0.03606551f, -0.06581005f, -0.01754976f, -0.01425587f, -0.06881306f, 0.01289286f, 
    -0.04574576f, -0.06475211f, -0.02527716f, -0.02671312f, -0.03670080f, 0.03126070f, -0.00772351f, -0.05890931f, 
    -0.04123608f, -0.02807597f, -0.06339457f, 0.03413509f, -0.05385716f, -0.05666853f, 0.00325116f, -0.04423572f, 
    -0.02042240f, -0.00414637f, 0.04908751f, -0.01694367f, 0.00515130f, -0.05668654f, 0.04790289f, -0.00155033f, 
    -0.03095500f, -0.02243797f, -0.06580007f, -0.02252211f, -0.03703243f, 0.03890139f, 0.04260740f, 0.03118784f, 
    -0.01206026f, -0.03131468f, -0.04891346f, -0.04412016f, 0.03765276f, 0.04420030f, -0.05312228f, -0.05202983f, 
    -0.00084433f, 0.00796257f, -0.04660726f, 0.00483184f, 0.01884304f, 0.00924961f, -0.06495456f, 0.01036235f, 
    -0.05113827f, -0.03012514f, 0.00666660f, 0.00104228f, 0.02853592f, -0.04880401f, -0.04322252f, 0.01283321f, 
    -0.01724291f, 0.00949074f, -0.00223369f, -0.02902192f, 0.02367180f, -0.03754481f, -0.07031543f, -0.03152934f, 
    -0.06875308f, -0.01897397f, -0.02936123f, -0.06135302f, 0.03401318f, 0.02439799f, -0.05949887f, 0.05097067f, 
    0.00842250f, -0.02375481f, -0.04086387f, -0.01617836f, -0.04808710f, -0.01014230f, -0.05398493f, 0.02355138f, 
    -0.05807657f, 0.00229679f, -0.03192620f, -0.06241598f, 0.02281721f, 0.01108105f, -0.05312024f, 0.02217913f, 
    0.01466389f, 0.01990019f, -0.01567392f, 0.04335804f, -0.06023546f, -0.04538522f, -0.00047768f, -0.04824634f, 
    0.04422382f, -0.00830387f, -0.00146580f, 0.00682040f, -0.01547237f, -0.03234071f, -0.04444456f, -0.03673237f, 
    0.03570341f, -0.01204331f, -0.06223730f, -0.01362893f, 0.00149600f, 0.01136964f, 0.00164007f, -0.03073098f, 
    0.04350456f, -0.01238719f, -0.05339209f, -0.03232806f, -0.06383306f, -0.04862779f, -0.06231637f, 0.02980714f, 
    0.04170121f, 0.04572790f, -0.04944107f, -0.01254482f, -0.05200331f, -0.02823969f, 0.03094503f, 0.02769139f, 
    -0.01140465f, -0.04517899f, -0.01390718f, -0.01736346f, -0.03564051f, -0.04648467f, -0.00875108f, 0.01370029f, 
    -0.01856934f, 0.00886933f, 0.00359905f, 0.02611390f, 0.01653886f, -0.02008125f, 0.00954204f, 0.00859170f, 
    0.04308996f, -0.00806030f, -0.02486104f, -0.01954455f, 0.01638850f, 0.03821465f, 0.04877701f, -0.02931140f, 
    -0.09736130f, 0.11600612f, 0.09270570f, -0.00118355f, -0.13880305f, -0.07389469f, 0.05614078f, 0.13704006f, 
    -0.34669974f, -0.23415235f, 0.04628120f, 0.08489929f, 0.11633081f, 0.07791542f, 0.05507243f, -0.08690932f, 
    0.11988454f, -0.16466743f, 0.18491505f, -0.56536520f, -0.25636399f, 0.09091054f, 0.00364223f, 0.13991667f, 
    0.05515771f, 0.20129496f, 0.35958964f, -0.28371394f, 0.06699760f, -0.12316565f, 0.06792153f, 0.10804599f, 
    -0.19492173f, 0.30963594f, -0.16271387f, 0.20911646f, -0.16415618f, -0.09859022f, 0.00110435f, 0.07656533f, 
    0.11284876f, 0.13873075f, -0.02029022f, 0.12638925f, -0.03255856f, 0.11499566f, 0.00863789f, -0.19960222f, 
    0.04905339f, -0.12399658f, 0.25674030f, -0.02414603f, -0.17726004f, -0.06561732f, -0.26778850f, -0.05539927f, 
    -0.00397845f, -0.03104706f, -0.06445945f, 0.10495696f, -0.17012805f, -0.02910415f, -0.22185341f, 0.16993010f, 
    0.15545742f, -0.37177345f, 0.26491019f, 0.07770750f, -0.02444624f, 0.21102157f, -0.21110371f, 0.13420872f, 
    -0.07379040f, -0.02623094f, -0.01317260f, 0.01477682f, -0.08852649f, 0.03563756f, -0.22962943f, -0.08959525f, 
    -0.29898703f, -0.08271320f, -0.00330161f, 0.15030621f, 0.20379680f, -0.06244940f, 0.12307736f, -0.12060841f, 
    -0.01697279f, 0.25748062f, -0.27538317f, 0.03719634f, 0.08500036f, -0.14011346f, -0.05329648f, 0.10687046f, 
    -0.20492637f, 0.06133160f, -0.01945383f, -0.04235121f, -0.07850838f, -0.08586644f, -0.13920210f, 0.09349600f, 
    -0.05760626f, 0.00771116f, 0.06689157f, -0.31536660f, -0.08959190f, 0.38765454f, -0.28498349f, -0.12840439f, 
    0.16102961f, 0.04888537f, 0.12114353f, 0.05705246f, -0.22262202f, -0.09666646f, -0.28111815f, 0.09817884f, 
    -0.09347610f, 0.00664150f, 0.17124575f, 0.04073635f, 0.15252855f, -0.17063694f, 0.04650903f, -0.01332122f, 
    -0.10924374f, -0.08665014f, 0.09035558f, -0.02364892f, 0.11045720f, -0.11161122f, -0.51413494f, 0.39924642f, 
    0.31913450f, -0.03566092f, 0.24870108f, 0.06162959f, 0.31247249f, -0.01609093f, -0.00922514f, -0.11731580f, 
    -0.07078882f, 0.00891369f, 0.18050493f, 0.06501047f, -0.06760127f, -0.00933120f, 0.08595229f, -0.04468767f, 
    -0.04138106f, -0.41182557f, 0.03506295f, 0.05364398f, -0.05459554f, 0.30115497f, -0.24256994f, -0.12690863f, 
    0.00448221f, -0.11245845f, 0.01450369f, -0.12990427f, -0.17984648f, -0.10905628f, -0.03061665f, -0.01460483f, 
    0.15940563f, 0.11389568f, 0.28527442f, -0.16662331f, 0.02491416f, 0.27947497f, -0.07170510f, 0.08050951f, 
    0.09130248f, 0.38129771f, 0.11234397f, -0.10027111f, -0.09795538f, 0.14774410f, 0.06341584f, 0.13884728f, 
    0.05213903f, 0.15848735f, 0.15269801f, 0.21443567f, -0.17274718f, 0.13143684f, 0.21084218f, -0.10928346f, 
    -0.07656281f, 0.17602392f, 0.10385621f, 0.00988224f, -0.11399066f, -0.23445438f, -0.05851169f, 0.14113688f, 
    0.02034292f, -0.03284811f, 0.05281117f, -0.31777096f, -0.11947141f, -0.13543221f, -0.28343895f, 0.11120187f, 
    0.10762224f, 0.12311350f, 0.11307669f, 0.09022643f, 0.05589393f, 0.24543521f, 0.08987113f, 0.04373674f, 
    0.06306404f, -0.35834473f, -0.10237494f, 0.10524143f, 0.12971835f, -0.01068430f, 0.00166566f, 0.00771919f, 
    -0.05005422f, -0.32022077f, 0.16704002f, 0.08515242f, 0.04735194f, 0.05838462f, 0.21141753f, -0.11832476f, 
    0.19210197f, -0.31066576f, -0.20166701f, -0.12653260f, -0.27446893f, 0.20581602f, 0.38761082f, -0.25683185f, 
    0.06549825f, -0.32155946f, -0.11803856f, -0.23790199f, 0.12550004f, -0.50462985f, -0.26616019f, 0.06497014f, 
    0.14295326f, 0.19751419f, -0.15148982f, 0.41943610f, 0.43515414f, 0.14503101f, 0.17299998f, 0.32152349f, 
    -0.01007063f, 0.07847856f, 0.11027575f, 0.06206388f, 0.01163696f, 0.08203012f, 0.24367166f, -0.14790443f, 
    -0.06201036f, 0.32411656f, 0.26711741f, 0.03456884f, 0.18083769f, -0.07906675f, -0.08227128f, 0.33851063f, 
    0.12976587f, 0.13458654f, 0.01052729f, 0.03128566f, 0.12671736f, 0.03938855f, -0.27474454f, 0.09863708f, 
    0.10452445f, -0.01907176f, -0.05813774f, 0.14971989f, -0.00939589f, 0.07104590f, 0.12171842f, -0.11428600f, 
    0.05654565f, 0.00258415f, 0.03623093f, -0.03115308f, -0.01801832f, 0.01190924f, 0.07311775f, -0.07664820f, 
    -0.06020526f, -0.12838916f, -0.06370611f, -0.06124622f, 0.28494635f, -0.10442580f, -0.15369914f, 0.12869218f, 
    0.13378784f, 0.05989704f, -0.15952520f, -0.24764751f, -0.04528151f, 0.12155923f, -0.05960826f, 0.04385617f, 
    0.10374710f, -0.15115470f, -0.00907066f, -0.44949472f, 0.00324633f, 0.03858814f, -0.10702107f, 0.00273210f, 
    0.02552400f, 0.05936570f, 0.07820574f, -0.00329897f, 0.03695511f, -0.01883766f, 0.04141102f, 0.20669791f, 
    0.12015266f, -0.07890321f, 0.04623731f, 0.09842348f, 0.11652137f, 0.03665710f, -0.50994587f, 0.39762217f, 
    -0.02991050f, -0.14200990f, -0.08556260f, 0.15019384f, 0.01800777f, -0.21602556f, -0.09002485f, -0.03613651f, 
    0.05623437f, 0.07438283f, -0.00050667f, 0.05933293f, 0.13025858f, 0.05577446f, -0.10014553f, -0.27973178f, 
    -0.22779275f, -0.02336489f, -0.02155466f, -0.17263825f, -0.10566441f, -0.04260464f, 0.14960225f, -0.05925148f, 
    -0.00662995f, 0.07427698f, 0.28142905f, -0.05196967f, -0.05739122f, -0.05350179f, 0.09253974f, 0.07105242f, 
    0.04753914f, -0.19255459f, 0.31081277f, 0.21346310f, 0.03207716f, -0.24072671f, 0.04469965f, 0.06380630f, 
    0.12947954f, 0.07772069f, -0.65437579f, 0.40206149f, 0.55134904f, 0.06350691f, -0.05101668f, 0.01453035f, 
    -0.04078776f, 0.07201400f, 0.01667647f, -0.10520938f, 0.11905809f, -0.15017088f, -0.22870199f, 0.00967613f, 
    -0.03814159f, 0.20896198f, 0.07670277f, 0.26975417f, -0.04352486f, -0.23109829f, -0.38340989f, 0.06075637f, 
    -0.01569413f, 0.10301212f, 0.03712207f, 0.13393879f, -0.09948768f, -0.20805575f, -0.04417643f, 0.05767886f, 
    0.09328816f, 0.04762716f, 0.04567615f, -0.04228684f, -0.04533280f, 0.26146528f, 0.10120916f, -0.18479358f, 
    0.06987881f, 0.10712899f, 0.05754282f, 0.03466418f, -0.04645872f, 0.08426535f, -0.05516554f, 0.59805703f, 
    -0.86665469f, -0.41521683f, 0.05137610f, 0.11841454f, 0.00198772f, 0.05789647f, -0.07148276f, -0.06511463f, 
    0.24306348f, 0.26785991f, -0.02353240f, -0.14610876f, -0.17105804f, -0.09329511f, -0.04689063f, 0.07430598f, 
    -0.05776202f, -0.15874192f, 0.46532980f, -0.18361968f, -0.03963161f, -0.04989304f, -0.00859430f, 0.06908409f, 
    0.00004020f, -0.01832186f, 0.12999405f, 0.05101540f, -0.37419257f, 0.01780296f, 0.10919549f, 0.12238362f, 
    -0.05428866f, 0.02995547f, 0.15247747f, -0.48899043f, -0.14913431f, 0.36604545f, -0.28848317f, -0.06906257f, 
    -0.16315512f, 0.06100446f, -0.03054858f, -0.22469932f, -0.11872227f, -0.03389497f, 0.08673502f, -0.02115208f, 
    -0.10836896f, 0.14551178f, 0.10020867f, -0.07072829f, 0.03640095f, 0.14966024f, 0.06374752f, -0.05012785f, 
    -0.00239680f, 0.03763211f, 0.02961311f, 0.10197821f, -0.09782923f, 0.05901105f, -0.37525922f, 0.07827489f, 
    0.34853882f, 0.08407408f, -0.06202419f, -0.03829195f, 0.17607369f, 0.06756404f, -0.02990391f, 0.12016374f, 
    -0.14178857f, 0.03038719f, 0.11008989f, 0.10255069f, -0.12843691f, 0.15233867f, 0.09627299f, 0.22065867f, 
    -0.26373723f, 0.10956072f, 0.26886618f, 0.05400491f, 0.08807703f, -0.00741784f, 0.02328499f, 0.06727181f, 
    0.13130972f, -0.20305233f, -0.00296671f, 0.01480865f, 0.03392735f, 0.21625319f, -0.08327151f, 0.06922375f, 
    0.10864603f, 0.11298499f, -0.20285784f, 0.23980191f, 0.11760220f, -0.11338707f, -0.21691294f, 0.01906626f, 
    0.01954025f, 0.11131206f, 0.12062326f, -0.37959349f, -0.01741079f, -0.18181174f, -0.16732493f, 0.11523005f, 
    0.07066358f, -0.23834790f, -0.19728705f, -0.04156123f, -0.11936140f, -0.74209177f, -0.19066326f, 0.03342350f, 
    -0.02401349f, 0.03448197f, 0.19872154f, 0.02136927f, 0.01543951f, -0.11603476f, 0.36152777f, -0.11982976f, 
    -0.18022995f, -0.00517116f, 0.17912523f, 0.09712905f, 0.13779180f, 0.09566759f, 0.39029878f, -0.09219207f, 
    -0.36163139f, 0.15831749f, 0.18009602f, 0.07575766f, 0.01925621f, 0.04876778f, -0.08869401f, -0.03253025f, 
    -0.11257511f, 0.09383296f, 0.20995724f, -0.04362040f, -0.23203591f, 0.14852579f, 0.18655604f, 0.15206400f, 
    0.09700775f, -0.06681158f, -0.03719411f, 0.04273849f, 0.11596954f, -0.02197530f, 0.00444971f, -0.04681966f, 
    0.02493292f, 0.24252880f, 0.21708629f, 0.22838156f, -0.07044618f, -0.06639058f, -0.07239992f, -0.25523546f, 
    -0.29357731f, -0.31708610f, -0.18720482f, -0.80147672f, -0.62268382f, -0.09133146f, -0.25391600f, 0.13060927f, 
    0.04147342f, -0.03103414f, -0.11657458f, -0.42355213f, -0.12650177f, 0.22251870f, -0.06692840f, 0.18031691f, 
    -0.22945267f, -0.01903333f, -0.10199758f, 0.10719007f, 0.18370667f, 0.16797738f, 0.10740107f, -0.10229714f, 
    -0.06704473f, -0.14281505f, -0.22530822f, -0.17458375f, -0.14200127f, -0.03642388f, -0.17697930f, 0.49924111f, 
    0.17802021f, 0.20408958f, 0.14010975f, -0.12557767f, 0.17292169f, -0.00957010f, 0.18918386f, 0.06161759f, 
    -0.10306633f, -0.08659960f, -0.07649276f, -0.17520820f, -0.06449946f, -0.19350483f, -0.17419462f, -0.73078650f, 
    -0.35758114f, 0.15130968f, -0.01395129f, 0.23552211f, -0.01807722f, 0.00066428f, -0.04431605f, 0.09387437f, 
    0.15666306f, 0.07336113f, -0.08373840f, -0.03851169f, 0.02248538f, -0.01917337f, -0.11111902f, -0.02506053f, 
    -0.01878033f, 0.15606697f, -0.00823759f, -0.09066932f, -0.06996258f, -0.00920273f, 0.04370432f, -0.00441558f, 
    -0.06827266f, -0.10238515f, 0.02766181f, -0.36595938f, -0.57180220f, -0.40537483f, -0.21566026f, -0.11824173f, 
    0.15128441f, -0.07811429f, -0.04240618f, 0.08150607f, 0.11087313f, 0.15273459f, 0.02153793f, 0.03646111f, 
    0.02990896f, -0.03557355f, -0.19395332f, 0.10241028f, 0.02710844f, 0.03618785f, 0.07379031f, 0.01332347f, 
    0.08277319f, -0.04518124f, 0.31448242f, -0.00648024f, -0.15129970f, 0.37822342f, -0.04089051f, 0.23691916f, 
    -0.05258053f, 0.29852813f, -0.05251724f, 0.40947649f, -0.39014718f, 0.21485485f, 0.02501206f, 0.10988457f, 
    -0.01478983f, 0.16271043f, 0.12038247f, -0.00138364f, 0.05215934f, -0.09443661f, 0.15006973f, 0.28152478f, 
    0.05590886f, 0.04006141f, 0.00321788f, -0.03881952f, -0.07941040f, 0.09906611f, 0.14920552f, 0.10816156f, 
    0.10513607f, 0.02600961f, -0.08538557f, 0.09588744f, 0.09303734f, -0.06062725f, -0.06788399f, -0.04318424f, 
    -0.07534592f, 0.10139504f, -0.07556961f, -0.55302268f, 0.16913672f, -0.13050586f, 0.14745462f, -0.03545865f, 
    0.01712207f, 0.02929790f, -0.17206372f, -0.74582124f, -0.67113966f, 0.03026183f, 0.02209299f, -0.01785542f, 
    -0.03672634f, -0.03891946f, 0.05807696f, -0.06325819f, -0.30481094f, -0.30922014f, -0.16620041f, -0.00402647f, 
    0.23136199f, 0.03042131f, -0.04942365f, -0.11758851f, 0.05312674f, 0.08433274f, 0.05081582f, -0.08370504f, 
    0.05287220f, 0.11351293f, 0.03667175f, 0.02764514f, 0.03617215f, 0.20965911f, 0.20074120f, 0.23369755f, 
    -0.09665552f, -0.08918253f, -0.23983240f, 0.06751181f, 0.04243362f, 0.03037313f, 0.04263427f, -0.09756418f, 
    -0.18385701f, 0.04366408f, 0.20135263f, 0.06051143f, 0.11529438f, 0.04706201f, 0.01151434f, 0.09252378f, 
    -0.09020790f, 0.33855784f, 0.02402542f, 0.11704387f, -0.02130553f, -0.07996489f, -0.00172647f, 0.20098175f, 
    -0.11844437f, -0.01335294f, -1.27024686f, 0.11643908f, -0.00182179f, -0.07183499f, -0.02069466f, -0.00511328f, 
    0.08165689f, 0.22112702f, 0.15867348f, 0.09677336f, -0.11491455f, -0.03511231f, -0.04839115f, 0.05696195f, 
    -0.05362866f, -0.08873190f, -0.30028617f, -0.06234603f, -0.20845854f, 0.17968562f, -0.02604192f, -0.08041292f, 
    -0.11350919f, -0.06860792f, 0.10505366f, 0.13991910f, -0.28445008f, -0.34143683f, 0.02720596f, 0.07117175f, 
    -0.19690453f, 0.26036680f, -0.36866158f, 0.00286647f, 0.56925619f, 0.03629113f, 0.24357092f, 0.03739595f, 
    -0.05740878f, -0.06190228f, 0.05722590f, -0.00343498f, 0.08726573f, 0.04993480f, 0.04586284f, 0.20324096f, 
    0.06778986f, 0.20200114f, -0.09996360f, 0.24588910f, 0.03211167f, -0.00260408f, 0.18421459f, 0.08800965f, 
    -0.11915585f, 0.08512266f, 0.21644624f, 0.23891906f, 0.05202657f, -0.02159856f, -0.15481973f, 0.27179176f, 
    0.11803925f, 0.27334404f, 0.11313985f, -0.03058572f, -0.15772852f, 0.08837348f, 0.13914374f, 0.05305805f, 
    0.00189849f, -0.03292761f, -0.05444245f, 0.04717052f, -0.02071846f, 0.10782333f, 0.03127866f, -0.09683507f, 
    -0.17288209f, -0.08044897f, 0.12421918f, 0.08812175f, -0.13176161f, -0.13790123f, -0.12815061f, 0.05969042f, 
    -0.05356343f, 0.08601825f, 0.09784985f, -0.82222474f, -0.22487040f, -0.17949536f, 0.06632718f, -0.04998046f, 
    0.02722242f, -0.05570585f, 0.13689369f, -0.45674682f, -0.60588920f, 0.06860024f, -0.09105834f, -0.01732699f, 
    -0.01855086f, -0.01281457f, -0.02100307f, 0.00500373f, -0.00803343f, 0.09920506f, -0.03369216f, -0.06459951f, 
    -0.20551062f, -0.21385492f, 0.10365371f, 0.01461609f, -0.00393871f, 0.08701028f, -0.18985441f, -0.19477156f, 
    -0.03851588f, 0.01142545f, -0.21751893f, 0.06932875f, 0.08665634f, -0.18664332f, -0.12277324f, -0.07973998f, 
    -0.12877659f, 0.01147403f, -0.23221564f, -0.23023480f, 0.16205479f, 0.00988358f, -0.10375209f, -0.37777987f, 
    0.00602991f, -0.51866943f, -0.04277311f, 0.10150014f, -0.14463601f, 0.05465217f, -0.06383740f, 0.05206315f, 
    -0.15891328f, -0.01716277f, 0.10598988f, 0.01057983f, -0.07312233f, 0.00028187f, 0.11616208f, 0.08500945f, 
    -0.13432656f, -0.22727269f, 0.21606371f, -0.00255600f, 0.04466244f, 0.03132783f, -0.12839870f, 0.07971782f, 
    -0.00717113f, 0.09879375f, -0.40187308f, -0.23309888f, -0.04459676f, 0.00549942f, 0.07060438f, 0.12824689f, 
    0.06365117f, -0.09875626f, 0.00370838f, -0.14772740f, 0.10682996f, -0.13087934f, -0.10868004f, -0.01133453f, 
    -0.17394063f, -0.01317809f, 0.00517229f, 0.20235477f, 0.58290493f, 0.02209959f, -0.20948590f, 0.08041266f, 
    0.11107984f, 0.26071298f, 0.18363367f, -0.11697379f, -0.02482988f, -0.14881517f, -0.28849119f, 0.25555372f, 
    0.10589166f, 0.20055600f, -0.04843895f, 0.12067392f, 0.18049493f, -0.02151991f, -0.05528049f, -0.01829875f, 
    0.12202984f, 0.06017188f, -0.14002289f, -0.01554647f, 0.05896002f, 0.09447584f, -0.11151940f, 0.46871522f, 
    -0.21586637f, -0.10386778f, 0.07054993f, 0.09146258f, 0.02798494f, -0.00858627f, -0.24754351f, 0.01694798f, 
    -0.07788453f, 0.16829970f, -0.04242490f, 0.09793127f, -0.20791985f, -0.05579926f, 0.01619106f, -0.05142477f, 
    0.08152605f, -0.49966815f, -0.19311807f, -0.33189377f, 0.07337245f, 0.13142507f, 0.01447532f, 0.05792845f, 
    -0.05096934f, -0.19462232f, 0.06562652f, -0.18544988f, -0.90150851f, -0.02172123f, -0.01973260f, -0.17108387f, 
    -0.03238967f, 0.12803106f, 0.31463680f, -0.42416024f, -0.27992961f, -0.22465368f, 0.17181265f, -0.09907561f, 
    0.15977985f, 0.17868660f, -0.02944251f, 0.00849061f, 0.03560439f, 0.06535397f, -0.04741161f, 0.01548646f, 
    -0.00304887f, 0.14498520f, 0.14501867f, -0.08350900f, -0.01930292f, 0.25462550f, 0.10120577f, -0.10995647f, 
    0.01938881f, 0.12101138f, -0.02597399f, 0.14912055f, 0.01178970f, 0.02017178f, -0.45581728f, -0.00597488f, 
    0.18887132f, 0.08175411f, 0.12987688f, 0.11691567f, 0.01515979f, -0.07237592f, -0.06465640f, -0.05803991f, 
    0.09640650f, 0.03469021f, -0.02100047f, 0.02897213f, -0.05310880f, 0.09543704f, 0.20456778f, 0.23698594f, 
    -0.54199862f, -0.07446232f, -0.27618077f, -0.02106911f, 0.17816214f, 0.06945717f, -0.03312575f, 0.01596067f, 
    -0.12414521f, 0.04275834f, 0.08252157f, 0.05624318f, -0.04057661f, 0.00753850f, 0.10240674f, 0.20585226f, 
    0.08154410f, 0.13180237f, -0.12973759f, -0.07313817f, -0.24572277f, -0.04277716f, -0.00223217f, -0.08258205f, 
    -0.07934718f, -0.09559641f, -0.30525011f, 0.23738226f, -0.27174926f, -1.01371086f, -0.17945373f, 0.05639908f, 
    0.17967071f, 0.13205054f, -0.01198831f, -0.17949200f, -0.12709896f, 0.10069834f, 0.01013306f, -0.05927887f, 
    0.04378382f, 0.02256755f, 0.11952873f, -0.09675407f, 0.12501135f, 0.32864207f, 0.06173066f, -0.09064893f, 
    0.09223378f, 0.22301745f, 0.04772887f, 0.06628478f, 0.06117310f, 0.00840429f, 0.34088355f, 0.12483873f, 
    -0.05164359f, 0.06238224f, 0.02220340f, 0.31533688f, 0.14890379f, -0.14948770f, -0.06725360f, 0.07939484f, 
    0.32663441f, 0.03166289f, -0.06248802f, -0.10047684f, -0.13203338f, 0.00843107f, 0.25834218f, 0.42391190f, 
    -0.16735581f, -0.20847584f, 0.12610440f, -0.10742970f, 0.04123110f, 0.05440515f, -0.00043728f, 0.35641021f, 
    0.01579677f, -0.02855281f, -0.27416569f, -0.07772767f, -0.08814406f, 0.08169763f, -0.10608625f, -0.05938188f, 
    0.04142924f, -0.01048719f, 0.16993150f, 0.29747584f, 0.17638734f, -0.12003748f, 0.07386128f, -0.39522189f, 
    -0.04678985f, -0.11592775f, -0.12947059f, 0.09496154f, -0.00826805f, 0.08016735f, 0.04562794f, 0.05445066f, 
    0.12571175f, 0.14162050f, 0.00914375f, 0.20205878f, 0.00193096f, -0.08526388f, 0.04353936f, -0.08574888f, 
    0.08677473f, 0.03404577f, -0.10768832f, 0.10149178f, -0.06170196f, 0.08853407f, -0.14666739f, -0.00137437f, 
    0.17825650f, 0.09818140f, -0.06628672f, 0.07325093f, 0.09134179f, 0.26859322f, -0.00302323f, 0.12797615f, 
    0.13827859f, -0.16520397f, -0.06487108f, 0.05698952f, -0.05264357f, 0.11648169f, -0.16523933f, -0.20195922f, 
    -0.19210055f, -0.45262426f, -0.24754046f, -0.25779289f, 0.15820229f, 0.13294004f, 0.03597252f, 0.13198306f, 
    -0.17275643f, -0.06487992f, 0.12370818f, -0.08176968f, 0.03128536f, 0.16837770f, 0.03358907f, 0.18269150f, 
    0.04395220f, -0.23271213f, 0.01720974f, 0.24792661f, -0.02524951f, 0.16756088f, 0.02722169f, -0.02133729f, 
    0.27425936f, -0.11673778f, -0.32745814f, -0.07117171f, 0.12853071f, 0.02926461f, 0.25075340f, -0.12297945f, 
    -0.10382551f, -0.11357777f, -0.11219320f, -0.48545003f, -0.27112669f, 0.00711985f, 0.06670041f, -0.09580995f, 
    -0.11736009f, -0.09452421f, 0.05120113f, -0.00658674f, 0.10725761f, 0.05491828f, 0.49908030f, -0.10273936f, 
    0.22130047f, 0.00614924f, -0.01196944f, 0.36997309f, -0.03283729f, -0.27628383f, -0.15582779f, -0.22603500f, 
    0.03084088f, 0.10808613f, 0.07672372f, -0.00273780f, 0.15951072f, 0.20324950f, -0.09669399f, 0.00453397f, 
    0.02270070f, -0.08743442f, 0.08815514f, 0.17782119f, 0.13225374f, 0.25045013f, 0.17721732f, 0.16964543f, 
    -0.12929499f, 0.04495147f, -0.15316375f, -0.22223690f, -0.17934203f, -0.02456225f, 0.14080128f, 0.25668788f, 
    0.04166210f, -0.02759510f, 0.01389545f, -0.15306422f, 0.11765330f, 0.06929097f, -0.06505233f, 0.19826625f, 
    -0.01402927f, 0.03616147f, -0.08916234f, -0.46899870f, -0.25220188f, -0.10230262f, -0.24172464f, 0.12330084f, 
    0.01420526f, 0.19576882f, 0.22451951f, 0.18401355f, -0.07836755f, -0.07359679f, -0.22512263f, 0.06673136f, 
    -0.01938125f, -0.14822672f, -0.16456687f, -0.00082749f, -0.01075998f, 0.41959059f, 0.10283941f, 0.20101058f, 
    -0.04241354f, -0.15843242f, -0.12862194f, -0.02384413f, -0.26662505f, -0.12498360f, 0.25194770f, -0.00529135f, 
    0.01465266f, 0.10968160f, -0.06590717f, 0.01378759f, -0.02838812f, 0.20871766f, 0.02959444f, 0.12672721f, 
    -0.12328541f, -0.15529525f, 0.09547232f, -0.08219213f, 0.22639135f, 0.02818463f, -0.15345587f, -0.13796835f, 
    -0.06552123f, -0.22166938f, 0.10687564f, 0.19625540f, -0.07403177f, 0.21588589f, 0.11580965f, -0.03553418f, 
    -0.10427073f, -0.08635749f, -0.08228333f, -0.00850041f, -0.07175246f, -0.05391272f, -0.13600010f, 0.24245399f, 
    0.15930830f, 0.22860904f, -0.32514486f, -0.11835246f, -0.00063574f, 0.00201335f, -0.00126649f, -0.06032170f, 
    0.05119209f, -0.03637658f, -0.14100236f, 0.02368279f, -0.03864614f, 0.10194976f, -0.19820474f, 0.07014304f, 
    0.00058118f, -0.08655721f, 0.04919376f, 0.02855950f, -0.41103694f, 0.07577083f, -0.12754846f, -0.12069093f, 
    0.15053655f, 0.09215060f, 0.21941137f, 0.00999646f, 0.16655806f, 0.14872126f, -0.13091744f, -0.01370438f, 
    0.07385419f, -0.14054498f, 0.04618361f, -0.14631510f, -0.01522703f, -0.35400525f, -0.31868070f, -0.33231491f, 
    -0.21719126f, -0.05882014f, -0.03681824f, 0.04057351f, 0.08546461f, 0.07703786f, 0.02859950f, 0.32082531f, 
    -0.07723887f, -0.07294326f, 0.04823304f, 0.24389680f, 0.10097677f, -0.01701949f, 0.23994581f, -0.16535741f, 
    0.22851783f, -0.08131130f, 0.01780876f, -0.00129657f, 0.05555215f, 0.23638152f, 0.12581715f, 0.14165580f, 
    -0.01224496f, 0.06404238f, -0.05538361f, -0.07868111f, -0.05518811f, 0.09623040f, 0.06163566f, 0.29948997f, 
    -0.04786471f, -0.00808835f, -0.05200267f, -0.06232147f, -0.00565691f, -0.05236850f, -0.04202315f, 0.01587079f, 
    -0.04071068f, -0.02776938f, -0.00666634f, 0.04433861f, 0.03399418f, -0.01833985f, 0.02447844f, -0.04841928f, 
    -0.04570260f, -0.05721374f, 0.01874403f, 0.04470751f, 0.03620894f, -0.05320317f, -0.05351250f, 0.05206498f, 
    0.00429747f, -0.05561442f, -0.04872485f, 0.00988835f, -0.06260487f, -0.02393378f, -0.01364702f, 0.03335455f, 
    0.04533856f, -0.00393108f, -0.00669848f, 0.04333865f, -0.04891954f, -0.00871151f, -0.04304782f, -0.05182467f, 
    0.04136579f, -0.02884027f, -0.00473722f, 0.03194864f, -0.04071555f, -0.01741144f, 0.04575646f, -0.00640186f, 
    -0.06459284f, 0.01684419f, -0.01600011f, 0.01414391f, -0.05615577f, 0.03548110f, 0.04580138f, 0.03121346f, 
    -0.03260298f, 0.02090220f, -0.03241442f, 0.00521922f, -0.05988667f, -0.02920165f, -0.05575699f, 0.03537125f, 
    -0.00423732f, -0.00400266f, -0.03783030f, -0.01871774f, 0.03686517f, -0.00004972f, -0.01263229f, 0.02871025f, 
    -0.05621048f, -0.01583323f, -0.01381204f, 0.03157739f, -0.05404743f, 0.03807138f, -0.00711316f, 0.00020771f, 
    -0.03134552f, 0.00275435f, 0.00516276f, 0.02068790f, -0.05379632f, -0.03405311f, -0.04832793f, 0.03034294f, 
    -0.04600789f, -0.05840920f, -0.01482801f, -0.05777664f, 0.03590324f, 0.01702728f, -0.04633322f, -0.06380232f, 
    -0.00504712f, -0.02227593f, 0.01355042f, 0.03742858f, -0.06201631f, 0.04118819f, -0.02780127f, 0.00884439f, 
    -0.06388813f, -0.01433392f, 0.03059025f, -0.05178318f, -0.03565415f, -0.06578182f, 0.04190491f, -0.03859821f, 
    0.03876358f, -0.00575471f, -0.01672639f, -0.04100959f, -0.02907976f, 0.03034613f, 0.03505726f, 0.01308282f, 
    -0.03897066f, -0.05301566f, -0.00236427f, 0.04989626f, -0.04107984f, -0.05862720f, 0.05476728f, 0.01536206f, 
    -0.03766609f, -0.04080972f, 0.03651859f, -0.04414218f, -0.00158491f, -0.03338632f, -0.05632833f, -0.03119215f, 
    0.04187688f, -0.04723853f, -0.05425157f, -0.00242947f, 0.03356201f, 0.02998098f, -0.03165773f, -0.01948706f, 
    0.00614751f, -0.05757992f, -0.01421302f, 0.04541162f, -0.05502841f, -0.04416626f, -0.06375948f, -0.04130919f, 
    -0.01261105f, 0.00207644f, -0.02661897f, 0.00433277f, 0.02670965f, 0.00319671f, 0.03721968f, -0.00301086f, 
    0.04676608f, 0.01625336f, -0.05367334f, 0.02492961f, -0.00635461f, 0.01954997f, 0.00669027f, -0.03220194f, 
    -0.04700312f, 0.03756446f, 0.00778023f, -0.00671305f, 0.02354340f, 0.03738420f, -0.01986156f, -0.01973265f, 
    -0.02676232f, -0.05900912f, -0.05762845f, -0.05114588f, 0.00305983f, 0.04157681f, -0.01648142f, -0.01438648f, 
    -0.00738710f, 0.01807282f, -0.04861199f, -0.02088464f, 0.03784540f, 0.02079103f, -0.01046867f, -0.02751624f, 
    0.00599212f, -0.00879907f, -0.01313600f, 0.01146457f, -0.00094897f, -0.03698906f, -0.03866702f, 0.01041569f, 
    0.02866112f, -0.02741908f, -0.03132327f, -0.04726829f, -0.06618927f, -0.03130760f, -0.02896467f, 0.01022201f, 
    -0.06040777f, -0.01786281f, 0.01755976f, -0.04514191f, -0.05921743f, -0.04974543f, 0.01254441f, -0.06058789f, 
    -0.03891003f, 0.00928817f, -0.00870220f, 0.01546263f, 0.02631585f, 0.03820745f, 0.03591182f, -0.05410238f, 
    0.04143983f, -0.02803909f, 0.00925747f, 0.04391494f, -0.06543925f, -0.06256289f, -0.03680690f, -0.00144184f, 
    -0.03891489f, 0.01844759f, -0.03308329f, 0.03395752f, -0.00244073f, 0.01781061f, 0.04321751f, -0.03621461f, 
    0.02098810f, -0.04085341f, -0.05165844f, 0.02940789f, -0.06534138f, 0.03219740f, -0.05221494f, 0.00295565f, 
    0.00553685f, -0.05881730f, 0.02047883f, -0.01878405f, -0.05874993f, 0.01542032f, -0.00843973f, 0.00722930f, 
    -0.01482008f, 0.01876234f, -0.04883006f, 0.03459523f, 0.02321479f, 0.03183308f, 0.03202746f, -0.06342159f, 
    -0.02916788f, -0.05467305f, 0.03333299f, 0.01719993f, 0.04599882f, -0.04967297f, 0.01067711f, 0.02633336f, 
    -0.01025546f, -0.02299784f, -0.05962057f, -0.04299804f, 0.02969508f, -0.01931917f, -0.01032381f, -0.02254814f, 
    0.02380054f, -0.05904314f, -0.06289031f, -0.02330669f, 0.00814295f, 0.00017814f, -0.01160866f, -0.03272007f, 
    0.03743907f, 0.24633563f, 0.07849504f, -0.16692007f, -0.01230448f, -0.15419355f, 0.17626308f, 0.13011995f, 
    -0.19275065f, 0.10287010f, 0.16984329f, 0.15826619f, -0.58182317f, -0.28538212f, 0.03357087f, 0.09958095f, 
    0.05779177f, 0.05079367f, 0.04430939f, -0.52021539f, -0.01848083f, -0.06661855f, 0.04685540f, -0.13862202f, 
    0.12669751f, 0.08015427f, 0.15738036f, 0.53286630f, -0.15915893f, -0.14134946f, -0.16356574f, 0.25640169f, 
    -0.12457474f, 0.07699147f, -0.04804491f, 0.04137157f, -0.02415252f, 0.14732534f, 0.06118413f, -0.34713790f, 
    -0.22397360f, -0.17802393f, 0.06369054f, -0.02205678f, 0.00966995f, -0.28659666f, 0.47975153f, -0.08184815f, 
    0.17964399f, -0.10225991f, -0.08877838f, -0.02693121f, 0.18164526f, -0.20802097f, -0.10772898f, 0.15146503f, 
    0.02800926f, 0.24498978f, 0.07096630f, 0.37129733f, 0.05821827f, 0.07649904f, -0.09337640f, 0.01991484f, 
    0.06414315f, 0.08940879f, 0.01973517f, -0.00513164f, 0.00273051f, 0.02688740f, -0.03521934f, -0.00446529f, 
    0.15424715f, 0.01547969f, -0.05744265f, 0.20182714f, -0.02507037f, -0.37588367f, -0.00693600f, 0.02020610f, 
    -0.00318395f, -0.06128744f, -0.00756081f, 0.29960829f, 0.07012260f, -0.39446682f, -0.06743710f, 0.04280128f, 
    -0.03386253f, 0.08493499f, 0.31623322f, 0.09290168f, 0.01933124f, 0.25993901f, 0.15262701f, -0.13066679f, 
    0.08208431f, 0.00683629f, 0.02847283f, 0.10512178f, 0.20475450f, 0.08340710f, -0.11090044f, -0.27293849f, 
    -0.08009630f, 0.13831089f, -0.01127679f, 0.22707100f, -0.04225809f, 0.43983328f, -0.55630499f, 0.02708849f, 
    -0.04142148f, 0.15858097f, -0.21149760f, 0.05651370f, -0.07791954f, 0.02070742f, 0.25328293f, -0.16561864f, 
    -0.43295851f, 0.05134344f, -0.30447054f, -0.14166096f, -0.04185926f, -0.03017135f, -0.07067566f, 0.09416327f, 
    -0.11315058f, 0.17245032f, 0.03485471f, -0.13251309f, 0.04380782f, -0.16539060f, -0.12630148f, -0.49728930f, 
    0.37980017f, 0.02760572f, -0.01866233f, 0.13568977f, 0.05817345f, -0.04325704f, -0.04086013f, 0.01550495f, 
    -0.12176521f, -0.10785912f, 0.10576849f, -0.30435562f, -0.24442975f, -0.21923138f, 0.16021001f, -0.04376689f, 
    0.09345407f, 0.13812643f, 0.04659707f, 0.72466975f, -0.03304782f, 0.01804335f, -0.10286271f, -0.05688151f, 
    -0.14249589f, 0.06339841f, -0.06045970f, -0.21030959f, 0.22833253f, 0.02427814f, -0.03512242f, -0.06603621f, 
    -0.09717772f, -0.09452666f, -0.19500250f, -0.34017858f, -0.14069344f, 0.42706174f, 0.03548504f, 0.35373995f, 
    -0.01567319f, -0.18793699f, 0.20110123f, 0.01397453f, 0.15307905f, 0.26076469f, -0.00013451f, -0.36445755f, 
    -0.02440396f, -0.21551196f, 0.04092892f, 0.12254156f, -0.15102962f, -0.26587203f, 0.22861959f, 0.04169905f, 
    0.06065637f, 0.13252933f, -0.03149972f, 0.07161575f, 0.01290453f, -0.04141564f, 0.48919803f, 0.26132333f, 
    -0.03611470f, 0.15098400f, 0.12989631f, -0.08843960f, 0.01720622f, -0.09485665f, -0.03854195f, -0.02541607f, 
    0.07570645f, 0.03780081f, -0.12830804f, -0.05261656f, -0.02890495f, 0.33702940f, -0.06613608f, 0.18642505f, 
    0.18802825f, -0.24579652f, 0.33669925f, -0.04073061f, -0.12063857f, -0.00635704f, 0.03700806f, -0.03519050f, 
    0.04970337f, 0.11513904f, 0.11651973f, -0.09573671f, -0.40595838f, -0.09935717f, -0.11317375f, -0.00128418f, 
    -0.03279993f, -0.09573799f, 0.12312251f, 0.02316668f, 0.42802742f, -0.16467494f, 0.05651633f, 0.01929487f, 
    0.08737700f, -0.13423207f, 0.14055550f, 0.71989071f, 0.08228843f, -0.85058212f, 0.15402667f, -0.00965668f, 
    -0.06230084f, 0.12975453f, 0.25943658f, -0.08553290f, -0.13815005f, 0.32359177f, 0.32303220f, 0.00547390f, 
    0.10261574f, -0.08268636f, -0.00603269f, -0.01598508f, 0.10348713f, -0.23346941f, 0.11619156f, -0.43225342f, 
    -0.28401512f, -0.36595538f, -0.02132420f, -0.18887901f, -0.04908239f, -0.22012523f, -0.00608363f, 0.29556972f, 
    -0.19286342f, 0.04536429f, -0.06852801f, -0.01913551f, -0.02144396f, 0.11697564f, -0.10777455f, 0.04265165f, 
    -0.04709085f, 0.01439955f, -0.08708798f, 0.05810179f, -0.06315756f, 0.03461268f, 0.02055576f, 0.03437806f, 
    0.00420949f, 0.00383855f, -0.04920454f, -0.01843635f, 0.00968160f, 0.03199146f, 0.00433561f, 0.01039994f, 
    0.00059143f, -0.02604742f, -0.01050724f, -0.00077881f, -0.03451623f, -0.05816643f, 0.00590775f, -0.01945635f, 
    -0.04704504f, 0.04344328f, -0.02801500f, -0.03645984f, 0.05230655f, 0.02895547f, -0.03614055f, -0.05990078f, 
    -0.02956114f, -0.01231562f, -0.06598852f, -0.03534620f, -0.06591333f, 0.02622251f, -0.01706497f, 0.02769094f, 
    -0.02364954f, -0.05692741f, 0.04261617f, 0.03283393f, 0.03183554f, -0.03800554f, -0.02161140f, -0.00768667f, 
    -0.04619996f, -0.05609104f, -0.06281140f, -0.03483350f, -0.00986041f, -0.00976669f, -0.03112056f, -0.00731081f, 
    -0.05174314f, -0.02115943f, -0.01040740f, -0.03505989f, 0.02197944f, -0.04881262f, -0.04827021f, -0.06251609f, 
    -0.02416889f, -0.00333962f, -0.05010154f, 0.02920858f, -0.03312000f, 0.05190522f, 0.03578584f, -0.05770871f, 
    -0.06341027f, 0.02732496f, -0.04925584f, -0.05758702f, -0.01836479f, 0.02895547f, 0.00222418f, 0.04496178f, 
    0.04905609f, 0.04723324f, 0.05326086f, -0.04169497f, -0.05475924f, 0.03043782f, -0.01726812f, 0.02204097f, 
    -0.00397664f, -0.02903733f, -0.05426709f, -0.01142470f, -0.03598678f, -0.03550445f, -0.01381700f, -0.02767687f, 
    -0.02208984f, -0.01657870f, -0.02364996f, 0.02503490f, 0.04179877f, -0.02265385f, 0.04123547f, -0.01738024f, 
    -0.03474186f, -0.01849278f, 0.00628309f, 0.03658367f, 0.02140560f, 0.04751723f, 0.02554588f, -0.05105174f, 
    -0.02818831f, -0.03135453f, -0.04655457f, 0.00730869f, -0.02533947f, 0.04546504f, 0.00237151f, 0.03726179f, 
    0.00312434f, -0.03040391f, -0.00515072f, -0.04819281f, -0.03825769f, 0.01088259f, -0.00128406f, -0.06346549f, 
    -0.03593600f, -0.04716602f, 0.02757913f, 0.01735676f, -0.00202269f, -0.00152671f, -0.05195190f, -0.00136200f, 
    -0.00326011f, -0.03518011f, -0.06882051f, -0.00147131f, -0.00203911f, -0.04214907f, 0.01589699f, 0.03440172f, 
    0.03739152f, -0.06066778f, -0.04184955f, -0.01576780f, 0.02009430f, 0.02944264f, -0.04902022f, -0.01450299f, 
    -0.02223564f, -0.03819755f, -0.01947951f, -0.04185293f, 0.01124991f, -0.03272120f, 0.00345130f, 0.01084251f, 
    0.02692620f, -0.02401349f, -0.05814476f, -0.06008727f, 0.02216106f, -0.02754412f, -0.00611498f, 0.02195571f, 
    0.04705917f, 0.00752275f, -0.04784530f, -0.01546522f, -0.05829353f, -0.00679810f, -0.01219545f, -0.03143055f, 
    -0.05056258f, -0.06759890f, -0.02077123f, 0.02418726f, -0.02049413f, -0.01783669f, -0.02591567f, 0.04341870f, 
    0.00405348f, -0.03682919f, -0.03463919f, 0.01053048f, -0.00582520f, -0.04160751f, -0.06313822f, 0.03383609f, 
    0.02553627f, -0.02614730f, -0.04666933f, -0.05147183f, 0.04148915f, -0.00522593f, 0.00504585f, -0.02682993f, 
    0.01589446f, 0.03022670f, 0.01218591f, -0.06320425f, -0.05363028f, 0.00797751f, 0.04294939f, -0.04488725f, 
    0.02445798f, -0.01643277f, 0.03189362f, -0.04156774f, -0.04154505f, -0.06560849f, 0.03482540f, 0.02437752f, 
    -0.00648863f, 0.02586567f, 0.04351258f, 0.03955390f, 0.04464128f, -0.00672884f, 0.00425749f, 0.04266376f, 
    -0.05493514f, -0.01187835f, 0.00473880f, 0.04929195f, 0.01365732f, -0.05459423f, -0.01165161f, 0.04432396f, 
    -0.05027495f, 0.00822377f, -0.05155960f, -0.00270525f, -0.02754641f, -0.01993410f, 0.04199475f, -0.03659594f, 
    0.03968421f, -0.04500921f, -0.05880067f, 0.03847660f, 0.04353988f, -0.06409371f, -0.05713699f, -0.02184262f, 
    -0.04264888f, -0.00522681f, -0.02128258f, -0.01949891f, -0.06222878f, -0.06016424f, -0.01138916f, -0.03500394f, 
    -0.04220144f, -0.05110999f, -0.05557683f, 0.01986549f, -0.01856234f, 0.03402140f, 0.04176670f, -0.00258140f, 
    -0.03552229f, 0.02866133f, -0.00978433f, -0.04457795f, 0.04120928f, -0.00001015f, -0.02828465f, -0.00795614f, 
    0.03787013f, 0.05197990f, 0.00785720f, 0.02486831f, -0.03735277f, 0.04656370f, 0.04427880f, 0.03628968f, 
    -0.00568273f, -0.03386113f, -0.00761664f, 0.00899056f, 0.01048434f, 0.04711407f, -0.05382886f, -0.01322194f, 
    0.00410017f, -0.04215142f, 0.04089446f, -0.02558126f, -0.00932748f, -0.01888488f, -0.01099987f, -0.03081149f, 
    0.09680709f, 0.07031126f, 0.03956483f, 0.14741403f, -0.00098371f, -0.02078445f, -0.09133010f, 0.32833728f, 
    0.22391190f, 0.03205833f, 0.06783071f, 0.07217549f, 0.18457836f, 0.24255784f, 0.14077926f, -0.04532493f, 
    0.30007052f, -0.12637663f, -0.06337368f, 0.33557269f, -0.26260442f, -0.13907209f, -0.19339746f, -0.07337514f, 
    -0.02429089f, -0.29204434f, -0.22427203f, 0.33110398f, 0.31830665f, 0.22104548f, -0.07106551f, 0.01362018f, 
    -0.06054872f, 0.01532393f, 0.07343882f, -0.07090948f, 0.11723793f, 0.04736836f, 0.11025392f, 0.18243673f, 
    0.21656632f, 0.11703794f, 0.05651480f, 0.18294385f, 0.05218358f, 0.35887998f, 0.33685961f, 0.18193503f, 
    0.02445292f, -0.01580123f, 0.02472129f, -0.12079170f, -0.01193861f, -0.05586196f, 0.06986988f, -0.06138003f, 
    0.21147504f, -0.04511805f, -0.04489343f, 0.13022500f, -0.02320316f, -0.09899617f, 0.01399923f, 0.29602629f, 
    0.33876342f, 0.00787805f, 0.06234742f, -0.00173572f, 0.15865116f, 0.06986536f, 0.08819707f, -0.34524015f, 
    0.18620199f, 0.09103673f, 0.04474088f, 0.17753273f, 0.26992986f, 0.03317376f, -0.08953452f, 0.10106847f, 
    0.02456237f, 0.26745534f, 0.10149272f, -0.01607442f, 0.09079480f, 0.23158138f, -0.05165650f, -0.11493292f, 
    -0.00861604f, -0.02613386f, 0.17395133f, 0.20677283f, 0.28387803f, 0.10003719f, -0.02446029f, -0.13114205f, 
    -0.16649921f, -0.10554256f, -0.06355623f, 0.09099569f, -0.21264222f, 0.07686965f, 0.06610721f, 0.22719052f, 
    -0.09334383f, -0.01741532f, -0.01472142f, -0.40904677f, 0.10063212f, -0.08488967f, 0.29160789f, 0.05016556f, 
    0.02172076f, -0.17862222f, -0.27214476f, -0.00273450f, 0.06240254f, 0.23764186f, 0.00545283f, -0.12914525f, 
    0.06744975f, 0.19260374f, 0.30117550f, -0.21878371f, 0.12389179f, 0.06742987f, 0.00406976f, -0.16506195f, 
    0.04317048f, 0.01474876f, -0.08667853f, -0.12700167f, 0.25760910f, 0.18555593f, 0.15534778f, -0.62772882f, 
    -0.31768399f, -0.02669168f, 0.08376432f, -0.00105225f, 0.03491312f, 0.13462070f, 0.05963283f, -0.13951561f, 
    0.16492738f, -0.04161963f, 0.07777828f, 0.06399725f, 0.12064184f, -0.01973636f, 0.10828330f, 0.19479819f, 
    0.13615930f, 0.21338795f, 0.16619793f, 0.24483575f, -0.02308347f, -0.02359588f, 0.07703263f, 0.04425637f, 
    0.06170565f, 0.11174658f, 0.01888089f, 0.14987873f, 0.03425885f, 0.04402348f, 0.00634274f, 0.01255178f, 
    -0.01206412f, -0.10506818f, -0.20066586f, 0.36576858f, 0.25151625f, 0.65761197f, 0.12644394f, -0.12698457f, 
    -0.01624856f, -0.11623651f, 0.35164887f, 0.01625734f, 0.24317566f, -0.05923874f, 0.27096826f, 0.13067791f, 
    0.09631513f, -0.01077262f, -0.15663928f, 0.21110417f, -0.05828540f, -0.20189415f, -0.10969126f, 0.06995564f, 
    0.05355927f, 0.04897241f, 0.03871835f, 0.09550761f, 0.07602840f, -0.07783963f, 0.16191718f, 0.05660346f, 
    0.16507415f, 0.06885447f, -0.17824607f, -0.04386756f, 0.18100357f, 0.37736627f, 0.22656904f, -0.23048936f, 
    -0.09477510f, -0.06401970f, 0.13728587f, 0.01585576f, 0.09041312f, -0.33767390f, 0.04483819f, -0.17678708f, 
    0.25508466f, 0.21036057f, 0.06106294f, 0.00748333f, 0.00337317f, -0.01127147f, 0.06336750f, 0.06688470f, 
    0.10094655f, -0.10017674f, -0.13271977f, -0.04445697f, -0.00179419f, -0.07542689f, 0.03251338f, -0.10044080f, 
    0.02739179f, -0.09919445f, 0.32188496f, 0.13912210f, 0.34015766f, 0.13254732f, 0.04992690f, 0.03694512f, 
    0.13617224f, 0.11731450f, -0.00161671f, 0.31450889f, 0.15767792f, 0.28537080f, 0.05027438f, -0.28195235f, 
    -0.00028541f, -0.02057162f, 0.16385317f, -0.24313045f, -0.39073184f, -0.16997160f, -0.05211403f, 0.03087105f, 
    0.08213256f, 0.08767024f, -0.06718522f, -0.24334466f, -0.20168053f, 0.12313150f, -0.43374074f, 0.02340570f, 
    0.00390411f, -0.16109771f, -0.09044971f, -0.11402500f, -0.00653942f, 0.04777696f, -0.20670234f, -0.07870066f, 
    0.07018996f, -0.00666647f, -0.10161282f, -0.16794114f, 0.17441185f, 0.18721521f, 0.06538940f, -0.12753990f, 
    -0.17484000f, -0.09470183f, 0.18539055f, 0.05433200f, 0.08602908f, -0.06219424f, -0.14614832f, -0.12371763f, 
    -0.06563537f, -0.13778597f, 0.28506735f, 0.08671751f, 0.04834232f, -0.03364195f, 0.00717882f, -0.28332666f, 
    -0.17383963f, 0.16077244f, -0.06091632f, 0.09170263f, 0.19131979f, -0.16087493f, 0.11961745f, -0.05763588f, 
    -0.01817617f, -0.17249097f, 0.17800048f, 0.02833516f, 0.21920994f, 0.19314556f, 0.17063525f, 0.01268679f, 
    0.18658045f, 0.30874717f, 0.37464216f, -0.06816403f, -0.17961936f, -0.26474586f, 0.05432117f, -0.04873414f, 
    -0.00608853f, -0.37464723f, -0.13270888f, -0.03830435f, 0.12091575f, -0.04192205f, 0.06612144f, 0.09985197f, 
    -0.07563688f, 0.14664099f, -0.06488168f, -0.09497303f, -0.14634722f, -0.35415530f, -0.02839510f, -0.17759356f, 
    0.30997819f, 0.31380486f, 0.17821346f, 0.00957402f, -0.16582045f, 0.04385260f, 0.10306084f, 0.47841448f, 
    -0.13035265f, 0.05276512f, 0.29744971f, 0.13512057f, 0.23642753f, 0.10747645f, -0.06900287f, 0.04365832f, 
    0.31186780f, -0.31604612f, -0.15185271f, 0.08952808f, -0.02288793f, -0.08228670f, 0.05331517f, -0.18367812f, 
    -0.01083884f, 0.03516180f, -0.10520174f, -0.01472988f, 0.08470115f, 0.03763167f, -0.05112137f, -0.02757891f, 
    -0.18541950f, 0.05139451f, -0.00567755f, 0.28722543f, 0.01909458f, 0.01309108f, 0.00045782f, -0.20358840f, 
    0.14359109f, -0.43184713f, 0.21611506f, 0.22688937f, 0.07079180f, -0.17921695f, -0.01805968f, -0.03689517f, 
    0.02538199f, -0.16459705f, 0.12391195f, 0.27589637f, 0.10482565f, -0.13681372f, 0.10634211f, -0.06198445f, 
    0.01995170f, 0.11527596f, -0.26444879f, -0.16583793f, 0.11346555f, 0.05592909f, -0.09416377f, -0.08888590f, 
    0.06064865f, -0.00472281f, 0.02367019f, -0.09212760f, -0.20190975f, 0.05695155f, 0.11593299f, -0.45343992f, 
    -0.01687207f, 0.16281165f, 0.07964832f, -0.04430341f, 0.54845905f, 0.34075963f, -0.06055601f, 0.08724856f, 
    -0.20199139f, 0.09457508f, -0.10580758f, -0.11534296f, -0.43483791f, -0.01349030f, -0.53626448f, -0.03046038f, 
    -0.10249267f, 0.10361477f, 0.13815689f, -0.23368710f, 0.07488678f, 0.01303415f, -0.14695485f, 0.01695506f, 
    -0.03435221f, -0.05080092f, 0.24669859f, 0.05594915f, 0.05401224f, 0.09598130f, -0.07880381f, -0.04296075f, 
    -0.31530169f, -0.13338964f, 0.09068538f, 0.24008426f, 0.15612617f, 0.09619270f, -0.13769738f, -0.08766428f, 
    -0.11043385f, -0.10526603f, -0.04773807f, -0.02980656f, 0.09831724f, 0.06410279f, 0.14472559f, -0.10885449f, 
    0.04615328f, 0.12559128f, 0.16803578f, 0.16130713f, -0.06947791f, 0.46528864f, 0.02916056f, 0.05071648f, 
    -0.05554773f, 0.01208789f, 0.44545731f, 0.50475389f, 0.12661116f, -0.12076399f, 0.25726888f, 0.07879743f, 
    0.22370352f, -0.21465689f, 0.06955186f, -0.09152026f, 0.14299954f, 0.25566250f, 0.19973879f, -0.25217423f, 
    0.01595063f, 0.11542926f, 0.14108132f, 0.19987449f, 0.17059408f, -0.38825899f, -0.04332636f, 0.03642601f, 
    0.01957780f, 0.13964038f, -0.07911953f, -0.27722171f, -0.11499758f, -0.38426629f, -0.15133826f, -0.13736829f, 
    0.05274827f, -0.16831659f, 0.00544265f, 0.23266296f, 0.01047132f, 0.17912860f, 0.17442763f, 0.19090591f, 
    0.25751680f, 0.04037308f, 0.33156160f, 0.22053130f, 0.07185558f, 0.00499763f, 0.10772353f, 0.16077815f, 
    -0.00067455f, 0.13393201f, 0.06899326f, -0.20207065f, 0.12765799f, 0.16067740f, 0.02126582f, 0.09000909f, 
    -0.20035753f, -0.13021705f, -0.10043877f, -0.04028542f, -0.19250365f, -0.07936990f, 0.06123114f, -0.04414698f, 
    -0.16137177f, 0.00657697f, -0.39763421f, 0.24558008f, 0.46388209f, -0.63873965f, -0.17256437f, 0.11172097f, 
    0.33165148f, 0.22542091f, 0.40859601f, 0.00500063f, -0.21283245f, -0.00846589f, 0.20853612f, -0.04590012f, 
    0.10348590f, -0.07241055f, -0.03023480f, 0.28482923f, 0.27055568f, 0.13319527f, -0.10546342f, 0.03032740f, 
    0.02817187f, 0.19425578f, -0.04385250f, 0.11118770f, -0.13029489f, -0.17930853f, 0.00390999f, -0.16492230f, 
    0.09899049f, 0.17487718f, -0.14762214f, -0.08793201f, -0.04788894f, -0.19841324f, -0.26183960f, -0.21621035f, 
    -0.01988663f, 0.03999253f, 0.02561693f, 0.20954747f, 0.00764342f, 0.16956230f, 0.02635148f, -0.07115043f, 
    -0.00727542f, 0.10511883f, -0.01386773f, -0.09209912f, -0.06261533f, 0.25363624f, 0.16584726f, 0.19524997f, 
    -0.07704925f, 0.09474071f, 0.04323061f, -0.10645353f, -0.29317647f, 0.03435421f, 0.12997781f, 0.05833208f, 
    0.15272388f, 0.03756954f, -0.11166801f, -0.35474101f, -0.42099759f, 0.13612676f, -0.15776706f, 0.09577350f, 
    -0.02288759f, -0.35921922f, 0.34008235f, -0.18160893f, 0.09497897f, 0.15112601f, 0.12625128f, 0.16236874f, 
    -0.09221318f, 0.04928435f, -0.02212620f, 0.28557009f, 0.09840882f, -0.00683123f, -0.18089092f, -0.16012360f, 
    -0.05266843f, 0.10194834f, 0.04400225f, 0.06333102f, 0.01470579f, 0.12012993f, 0.24717231f, 0.58924043f, 
    0.25272349f, 0.12795638f, 0.05622324f, -0.00939874f, -0.19147836f, -0.28881425f, 0.13135941f, -0.09341304f, 
    -0.14944246f, 0.02428679f, -0.04043677f, 0.02761882f, 0.17867184f, 0.07348760f, -0.12722437f, 0.00817514f, 
    -0.10456432f, 0.09608678f, 0.02722729f, -0.16982135f, 0.11352098f, 0.03125814f, -0.06725336f, 0.05810068f, 
    0.03723465f, -0.08555774f, -0.12793694f, 0.11730640f, -0.12706000f, 0.00052257f, 0.05868972f, 0.15248451f, 
    0.08432160f, -0.16763924f, -0.12081108f, -0.04172634f, -0.15662743f, 0.05245258f, 0.20809461f, 0.03495725f, 
    0.13094930f, -0.05312085f, -0.33389997f, -0.56764746f, -0.32245579f, -0.01138784f, -0.06885694f, 0.19880208f, 
    -0.08508039f, 0.06583706f, -0.04287729f, 0.04685212f, -0.06280009f, -0.02287918f, -0.30447790f, 0.25540251f, 
    -0.09963462f, -0.25859424f, 0.15138115f, -0.05186060f, 0.16685462f, 0.15203151f, -0.30583981f, 0.12479699f, 
    0.02166880f, 0.05137966f, -0.03350050f, 0.25011763f, -0.28521115f, -0.13281931f, 0.12170138f, 0.19116673f, 
    -0.14072156f, -0.18206167f, 0.04719200f, 0.17765276f, 0.17426293f, -0.14885525f, 0.07684233f, -0.04147198f, 
    -0.09507614f, -0.04370627f, -0.05622044f, -0.15192811f, -0.04559794f, 0.18870664f, 0.03416745f, 0.15583058f, 
    0.28637505f, -0.05953720f, 0.06444376f, 0.02579096f, -0.11016966f, -0.06778499f, 0.15594575f, 0.16648455f, 
    -0.00928550f, -0.10003691f, -0.18684489f, -0.21450463f, -0.03313811f, -0.08550556f, 0.12318480f, 0.16499774f, 
    0.13910462f, -0.05224070f, -0.06679021f, 0.21582395f, -0.06934924f, -0.01104687f, -0.06037793f, 0.05065178f, 
    -0.02586128f, 0.11043101f, -0.07074331f, -0.03509950f, 0.19582303f, 0.09087443f, -0.07322652f, 0.21374179f, 
    0.18932314f, -0.08040199f, 0.24206240f, 0.36744058f, 0.03561410f, -0.01004421f, -0.21014874f, 0.12131728f, 
    0.64542198f, 0.08922763f, 0.35071635f, 0.11123478f, 0.07663325f, 0.01308840f, -0.06699499f, -0.19597457f, 
    0.07112133f, 0.21282104f, 0.01470652f, 0.18459272f, -0.09086852f, 0.06383991f, 0.03568565f, 0.03659831f, 
    -0.04875276f, 0.03655427f, 0.00321351f, -0.01087826f, 0.00235271f, -0.16517411f, -0.11722662f, -0.00992717f, 
    0.23800318f, 0.06640843f, -0.07886208f, 0.00896574f, 0.01159894f, 0.24597140f, -0.06749864f, -0.15928008f, 
    0.07519412f, 0.23464654f, 0.00550436f, -0.16590926f, 0.08081590f, 0.02382853f, 0.29266003f, -0.20946611f, 
    0.00502933f, -0.44904062f, -0.01746834f, -0.05423460f, -0.05337148f, 0.04189428f, -0.01703624f, -0.05704521f, 
    0.08577190f, -0.03188638f, -0.00748059f, -0.14987786f, -0.19148487f, -0.13561946f, 0.01549965f, -0.11898416f, 
    -0.02024352f, -0.07666006f, 0.00116228f, -0.28284147f, 0.37829867f, -0.02845960f, 0.01087747f, -0.02543250f, 
    -0.01866537f, -0.06835262f, 0.17799692f, -0.14432584f, -0.18742588f, 0.16635814f, -0.06641987f, -0.19609977f, 
    0.23982924f, 0.06235365f, 0.18130425f, 0.15190251f, 0.41437459f, 0.11541711f, 0.35612363f, 0.15882538f, 
    -0.13688624f, -0.03871068f, 0.09488695f, -0.04969889f, 0.07620070f, 0.06824777f, -0.22250609f, 0.04111573f, 
    0.10716295f, -0.13192479f, 0.05970156f, 0.02835028f, 0.13889031f, -0.12593229f, 0.17936943f, 0.36745095f, 
    -0.14773965f, 0.04103759f, 0.21736489f, 0.07508293f, -0.04495848f, 0.23906203f, -0.07094683f, -0.00655468f, 
    0.11559441f, -0.00407508f, -0.05103761f, -0.09804935f, 0.04100703f, -0.25619000f, 0.10891178f, -0.10453220f, 
    0.05134672f, 0.18161905f, 0.00531870f, -0.09310015f, 0.05111578f, 0.09469593f, 0.05330295f, 0.21415743f, 
    -0.06651971f, -0.04308064f, 0.06965602f, -0.00318433f, 0.14022231f, 0.01957444f, 0.20611748f, -0.14057370f, 
    0.03811208f, -0.11781301f, -0.14463526f, -0.18360549f, -0.57287145f, -0.00103252f, 0.04269387f, -0.17941500f, 
    -0.25128531f, -0.32529628f, -0.22480483f, -0.30620271f, -0.12010238f, 0.37339270f, -0.06262393f, 0.22137359f, 
    0.08531009f, 0.01737567f, 0.09124677f, 0.08872647f, -0.08740570f, -0.06827685f, -0.13181876f, 0.04303273f, 
    -0.04625982f, -0.06812967f, -0.23272008f, -0.00586877f, 0.00501148f, 0.07792722f, -0.06654653f, 0.08726748f, 
    0.05725576f, -0.10948354f, 0.31865317f, 0.17712222f, 0.02709012f, -0.05913990f, -0.04537947f, 0.03198019f, 
    -0.11485173f, 0.10645130f, 0.07374359f, -0.02109179f, 0.08610611f, -0.06966694f, 0.02554561f, -0.45414177f, 
    -0.38664508f, -0.07885676f, 0.12076707f, 0.14746173f, 0.13066354f, 0.16185790f, 0.01544344f, -0.01745533f, 
    -0.09635668f, 0.03946764f, 0.02140805f, 0.18389355f, -0.03351035f, 0.04312759f, -0.05720116f, 0.07668737f, 
    -0.02207770f, -0.14923246f, -0.02975987f, -0.13924499f, 0.07370641f, 0.05655837f, 0.01360056f, 0.04115088f, 
    -0.12276220f, 0.03528374f, -0.12542118f, -0.27692431f, -0.33423898f, 0.19507651f, 0.15724061f, 0.01628066f, 
    -0.01842540f, -0.00548595f, 0.04259879f, 0.09744160f, 0.19340335f, -0.26676023f, 0.13673006f, 0.01847072f, 
    0.13044804f, -0.18848206f, -0.06699800f, 0.05603772f, 0.43924493f, -0.00296927f, 0.11165656f, 0.11979022f, 
    0.14929190f, 0.36558935f, 0.17814103f, 0.25135708f, 0.06983962f, -0.02577750f, 0.28591529f, 0.22401996f, 
    0.27068135f, -0.00660110f, 0.03834089f, 0.29596883f, 0.12525098f, 0.16846436f, -0.04763721f, 0.07834642f, 
    0.08632471f, 0.08459309f, -0.07395875f, -0.07416952f, 0.12994455f, 0.17636985f, 0.25741002f, 0.08606116f, 
    -0.51041931f, -0.02549032f, 0.11796443f, 0.25671837f, 0.00619286f, -0.03423557f, 0.20127264f, 0.08474017f, 
    0.06686704f, 0.05164733f, -0.14799583f, -0.03063387f, 0.04500154f, 0.03504472f, -0.03539303f, -0.00081572f, 
    0.24469601f, 0.24286555f, 0.10434791f, -0.01467621f, 0.02819494f, 0.05135620f, -0.02981175f, 0.11008968f, 
    0.05186695f, 0.20755488f, 0.03724273f, -0.08615696f, -0.19801493f, 0.01263649f, -0.03339211f, -0.08293653f, 
    0.04581200f, -0.04027110f, -0.19276683f, -0.08733571f, 0.39643380f, -0.13951938f, 0.18636043f, -0.14755933f, 
    0.20587857f, 0.13863724f, 0.05249582f, -0.02925501f, 0.05303482f, 0.14988564f, -0.00408586f, 0.04602632f, 
    -0.04504031f, 0.22889024f, -0.02274870f, 0.19695407f, 0.05770329f, 0.10235349f, 0.13479424f, 0.04240211f, 
    -0.00676009f, 0.06174837f, -0.06983984f, -0.20019029f, -0.00687106f, -0.05433477f, -0.12875763f, 0.29365528f, 
    0.25209680f, -0.22124316f, -0.07052518f, 0.02705744f, 0.18910773f, 0.25812900f, 0.00855146f, 0.04589037f, 
    0.10297696f, -0.10700215f, 0.02572653f, 0.00362625f, -0.02874638f, -0.15354626f, 0.13343811f, -0.12813564f, 
    -0.11362492f, -0.13332699f, -0.23109956f, -0.17349842f, -0.03533690f, -0.06387107f, -0.09580882f, 0.01730764f, 
    0.10865530f, -0.07100169f, 0.05889317f, -0.06280170f, 0.03550581f, 0.00541339f, 0.02309569f, -0.06504139f, 
    0.00513851f, -0.04677035f, -0.08195627f, -0.11112399f, -0.16167778f, -0.17997445f, 0.01518966f, 0.08562493f, 
    0.18811987f, -0.01307588f, 0.20322405f, -0.07231659f, 0.12708965f, 0.16603358f, 0.08071771f, -0.00539935f, 
    0.06582583f, 0.00726183f, -0.06436769f, 0.05360412f, -0.26360127f, -0.15406020f, -0.01318396f, 0.10575610f, 
    0.20747972f, -0.03209474f, 0.04496441f, -0.17987278f, -0.05654087f, 0.18711050f, 0.01915432f, -0.06019399f, 
    -0.04997674f, 0.07858530f, 0.22834797f, 0.15286167f, 0.18706046f, 0.06578711f, 0.20184079f, 0.33648658f, 
    0.01044413f, -0.03098327f, 0.15099476f, 0.20880991f, 0.09497965f, 0.06820087f, 0.09616905f, 0.00252292f, 
    0.05712305f, -0.08083674f, -0.07486348f, 0.00757490f, -0.09604254f, -0.33201492f, 0.02435681f, -0.23590456f, 
    0.16089496f, 0.05325722f, -0.14184767f, -0.12382121f, 0.11240310f, -0.02572881f, -0.02145070f, -0.10999640f, 
    -0.02308656f, 0.02915264f, 0.02697496f, 0.00565411f, -0.08033098f, -0.32916489f, -0.26959714f, -0.01960472f, 
    -0.02348168f, -0.00742402f, -0.06984054f, -0.18115689f, 0.35409027f, 0.03212752f, 0.21435235f, 0.58744222f, 
    -0.09921165f, -0.00003930f, 0.14203861f, 0.32139912f, -0.43348503f, 0.01568120f, 0.15513635f, 0.00913138f, 
    0.02781998f, 0.00187081f, -0.07566015f, 0.00673974f, 0.07275654f, 0.07336403f, -0.00269042f, 0.01701278f, 
    -0.21860872f, -0.10650241f, 0.00453203f, 0.01106241f, -0.05011453f, -0.28463340f, -0.30181637f, 0.05793168f, 
    0.01901210f, 0.10446674f, -0.06539457f, -0.09880435f, -0.01098648f, 0.06637353f, 0.01256513f, -0.01461848f, 
    -0.24055506f, 0.07199176f, 0.20708609f, 0.13894831f, -0.02227707f, 0.17880449f, -0.10832599f, -0.26308444f, 
    -0.25982314f, 0.22116433f, 0.02899615f, 0.05355259f, 0.04702397f, 0.00842980f, -0.08894565f, 0.06514773f, 
    -0.03386093f, -0.04324101f, -0.06590682f, -0.07829387f, -0.06016766f, 0.08607837f, 0.02027164f, 0.07027020f, 
    0.00890970f, 0.03097713f, -0.04696804f, -0.01918518f, -0.19667068f, -0.15060003f, 0.24192278f, -0.01403414f, 
    0.01770709f, 0.08270173f, -0.03793100f, -0.22416797f, -0.00840483f, -0.14277960f, -0.09812572f, -0.13412246f, 
    0.08238144f, -0.00914113f, 0.05751465f, -0.12328967f, 0.02339131f, 0.03664437f, -0.10738022f, 0.09064951f, 
    -0.22024453f, 0.07023530f, -0.09047721f, 0.05196850f, 0.44392094f, -0.07380970f, -0.13245717f, -0.08909836f, 
    0.01696294f, 0.05552587f, -0.22889893f, 0.05722217f, -0.01182094f, -0.06602802f, 0.03512244f, -0.16707920f, 
    0.24029246f, 0.02629020f, -0.09663223f, 0.12236035f, 0.08583791f, -0.05419892f, -0.02426797f, 0.05566520f, 
    0.00786719f, 0.06666871f, 0.10250217f, 0.10569351f, -0.02808702f, 0.11521818f, 0.01488309f, -0.01665941f, 
    0.14880399f, 0.31596091f, -0.01016550f, 0.01468899f, -0.06252044f, -0.19195536f, -0.23913042f, 0.27081248f, 
    -0.02327273f, -0.01308157f, -0.08008001f, -0.22131094f, -0.07070636f, -0.03655690f, 0.08960067f, 0.00356686f, 
    0.05695708f, -0.22387011f, -0.15855017f, -0.31292021f, -0.09300913f, -0.00544871f, -0.16159175f, -0.05191399f, 
    -0.18438363f, -0.31415418f, -0.03868895f, -0.19869988f, 0.00403611f, -0.00339337f, 0.03727379f, 0.03653649f, 
    0.15813150f, 0.01793812f, 0.13619892f, -0.03211414f, 0.18013667f, -0.30019611f, 0.05669824f, -0.17052980f, 
    -0.00009843f, -0.15616551f, -0.07562314f, -0.08554555f, 0.16463186f, 0.09568114f, -0.20677277f, -0.12451416f, 
    -0.38411155f, -0.15829928f, -0.23398454f, -0.07475431f, 0.10368913f, 0.09547954f, 0.15279174f, 0.02372235f, 
    0.03648449f, -0.01422694f, -0.05427121f, 0.08138499f, 0.09712865f, -0.00411069f, 0.27355170f, -0.20219912f, 
    -0.22542803f, 0.23388919f, 0.24443588f, 0.01382101f, -0.02699781f, -0.17329469f, -0.13579257f, -0.07275587f, 
    0.02394255f, 0.03799209f, 0.11144792f, 0.07339195f, -0.05190186f, -0.16265832f, -0.00318589f, 0.08665717f, 
    -0.22303905f, 0.12992699f, 0.23653741f, -0.06925670f, -0.03512588f, 0.14449041f, 0.13573821f, -0.06404574f, 
    -0.31429866f, 0.11221154f, 0.09030292f, -0.10062566f, 0.11174178f, -0.00708255f, -0.09104029f, -0.02212145f, 
    0.20337150f, -0.02504831f, -0.17275020f, -0.04073585f, 0.21636441f, 0.00356931f, 0.08169655f, 0.04154997f, 
    -0.07993609f, -0.21273798f, -0.39286092f, 0.45495477f, 0.01686558f, -0.01795597f, 0.09559938f, -0.18676196f, 
    0.17772520f, 0.05387227f, 0.13392831f, -0.03740106f, -0.00436860f, -0.23238367f, 0.43950620f, 0.05235996f, 
    0.05130114f, 0.04219983f, -0.04933048f, -0.14990555f, 0.12838435f, 0.26374516f, -0.03714158f, 0.08541866f, 
    0.10618272f, 0.46495146f, 0.24185218f, -0.22164154f, 0.28932968f, -0.01031209f, 0.21538715f, 0.18550275f, 
    -0.00515407f, 0.09315015f, 0.19573160f, 0.07372096f, -0.05644383f, -0.01972102f, -0.09155717f, -0.06035021f, 
    0.10167296f, 0.16642317f, 0.06441155f, 0.09161180f, -0.13569897f, -0.10421122f, -0.25463301f, 0.11393254f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01812971f, -0.02127389f, -0.01775576f, -0.10941742f, 0.04297717f, 0.38521966f, 0.14070781f, -0.07314321f, 
    0.29618457f, 0.33259052f, -0.00037564f, -0.01496983f, 0.18253073f, 0.14721835f, -0.10863207f, 0.15957342f, 
    0.14212197f, 0.37279505f, -0.02284623f, 0.07441498f, 0.24292429f, 0.14728081f, 0.22737202f, 0.16960914f, 
    -0.02931282f, -0.32694075f, 0.01033571f, -0.16053228f, -0.12220868f, -0.01360390f, -0.01493008f, 0.15548733f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08781269f, 0.29639778f, -0.08018874f, 0.24654885f, 0.13827711f, 0.09958082f, -0.23745911f, 0.48365268f, 
    -0.17934018f, -0.36181030f, 0.29037878f, 0.16059153f, -0.72833961f, 0.39031971f, 0.64479756f, 0.06941049f, 
    -0.30936208f, -0.93025529f, 0.06775312f, -0.11482360f, -0.17452908f, -0.07454612f, -0.07596728f, 0.17300947f, 
    0.02261283f, 0.12815510f, 0.03368675f, 0.03504669f, -0.16160223f, -0.43922859f, -0.04455892f, -0.12940580f, 
    -0.22230689f, -0.26221424f, -0.10021326f, 0.16050400f, 0.08651108f, -0.07981393f, 0.24540111f, 0.45257530f, 
    0.20676321f, 0.26876906f, 0.00721077f, -0.15508446f, -0.11356675f, 0.35779941f, -0.02361906f, 0.10088930f, 
    -0.31052712f, -0.05362064f, -0.13115363f, -0.30589810f, 0.07002751f, 0.34012547f, 0.21553658f, 0.19721560f, 
    0.09154109f, -0.34638891f, -0.16534556f, -0.08374293f, -0.22940703f, -0.28296080f, 0.13973071f, 0.12195902f, 
    0.32326865f, -0.15286432f, 0.00589768f, -0.43739429f, 0.13488707f, 0.24743812f, 0.05903317f, -0.72928756f, 
    0.14333278f, -0.31528941f, 0.01296477f, 0.09133628f, -0.12218506f, 0.40411314f, -0.25241309f, -0.03863915f, 
    0.50766820f, 0.41788319f, -0.15345310f, -0.04271857f, -0.08951817f, -0.42722195f, -0.18560126f, 0.14362119f, 
    -0.02755517f, 0.00822648f, 0.03913978f, 0.03002510f, 0.09330172f, -0.37164491f, -0.30406219f, 0.13319410f, 
    0.12690252f, 0.00744422f, 0.17420554f, -0.14633811f, -0.06928033f, 0.06549397f, 0.33107150f, 0.01330782f, 
    -0.21250750f, -0.35756353f, -0.96218157f, 0.12176938f, -0.39401790f, 0.23999257f, 0.01869703f, 0.24645971f, 
    -0.57874554f, 0.41183165f, 0.12559831f, -0.31894165f, -0.66479671f, -0.50095242f, -0.33191499f, 0.02605023f, 
    0.10089618f, 1.07922316f, 0.15271425f, 0.30260918f, 0.30895528f, 0.01688352f, -0.35880139f, -0.24730651f, 
    0.01901961f, 0.19058786f, -0.05463192f, 0.16357394f, 0.16090043f, 0.01652806f, -0.20707120f, 0.29420081f, 
    -0.23076993f, -0.35708249f, 0.36152890f, 0.08478530f, 0.44359967f, 0.02736343f, -0.39517856f, 0.36278790f, 
    -0.20486362f, -0.22234502f, -0.08740544f, 0.14677049f, 0.20605057f, -0.01977005f, -0.08727299f, -0.28114676f, 
    -0.05665128f, 0.12147290f, 0.13656119f, 0.00095351f, -0.05937665f, 0.18875563f, -0.11736095f, -0.05176865f, 
    0.31877753f, -0.17919399f, -0.11072148f, 0.04443291f, -0.10011338f, -0.13159178f, -0.28403640f, -0.00500271f, 
    0.22594076f, -0.42315561f, 0.22016664f, 0.03693521f, 0.39534545f, -0.41839272f, 0.55689317f, 0.09650613f, 
    -0.13106115f, 0.35682887f, 0.16813242f, -0.04934666f, -0.19632328f, 0.03695253f, -0.53885251f, 0.12636654f, 
    0.14830637f, -0.40098509f, -0.13452463f, 0.17691724f, -0.42600280f, 0.46289727f, 0.17847921f, -0.44080991f, 
    0.15524989f, -0.56125134f, 0.14054166f, -0.53027332f, 0.00343865f, 0.55743039f, -0.06470004f, -0.62181622f, 
    -0.10523328f, -0.17840293f, -0.23562656f, -0.16716722f, -0.03640081f, -0.27427283f, -0.42147166f, -0.15070719f, 
    0.18992341f, -0.68843943f, 0.15692468f, 0.31075633f, 0.62858450f, -0.06014144f, 0.54769111f, -0.03415500f, 
    0.07594701f, -0.33051121f, -0.11219029f, -0.27963993f, 0.14419527f, 0.07074512f, 0.22304937f, -0.16355807f, 
    -0.03080145f, 0.16061319f, -0.01118505f, 0.00461709f, -0.10279445f, -0.00231313f, 0.18222728f, 0.01255160f, 
    -0.13055487f, -0.12581001f, 0.19895087f, -0.03761857f, -0.11894860f, -0.50363088f, 0.35934836f, -0.32763174f, 
    0.10033889f, -0.48052603f, -0.04957025f, -0.20268461f, -0.33566877f, 0.29321375f, 0.16973270f, -0.12880766f, 
    0.10969425f, 0.30540696f, -0.04481609f, -0.17418270f, -0.10418174f, 0.33729962f, 0.16079657f, 0.41247064f, 
    -0.32772365f, -0.14812954f, -0.03771720f, 0.16817631f, 0.00120783f, -0.58330446f, 0.02522630f, -0.41819045f, 
    0.43116978f, 0.77239788f, -0.10881756f, 0.16808853f, -0.66212112f, -0.80983865f, -0.57129359f, -0.49097633f, 
    -0.22938883f, 0.50391167f, 0.02568130f, 0.00149010f, 0.05511403f, -0.08246696f, 0.50900578f, 0.07767711f, 
    0.05107966f, -0.29627073f, -0.05398257f, 0.34504288f, -0.32310477f, -0.02286920f, 0.30600983f, -0.15323915f, 
    -0.15573758f, 0.64245993f, -0.16768415f, -0.09732620f, -0.05873242f, 0.55668873f, 0.19675213f, -0.33223376f, 
    0.28544599f, -0.19962625f, -0.34579778f, 0.16311292f, 0.43699074f, -0.12724370f, -0.27903697f, 0.23024853f, 
    -0.68782485f, -0.05908579f, -0.00106527f, 0.37210661f, 0.08960074f, -0.28881413f, -0.06045677f, -0.67351317f, 
    -0.17351829f, -0.31755307f, 0.14254645f, -0.34826514f, 0.03125304f, 0.10738213f, -0.17551702f, 0.23769155f, 
    -0.71128595f, -0.61691403f, 0.06354925f, 0.44611418f, -0.04403554f, -0.25817084f, 0.21640256f, -0.77780658f, 
    -0.14284410f, -0.99815166f, 0.48563516f, -0.02681721f, -0.34915480f, 0.08035162f, -0.41695639f, -0.31658104f, 
    0.13345098f, -0.00708485f, -0.06333794f, 0.05656932f, 0.11934828f, -0.35977837f, -0.30139881f, 0.17954598f, 
    0.01907813f, 0.56677324f, -0.06222583f, 0.33078921f, -0.40889728f, 0.36536801f, 0.40119505f, -0.33337370f, 
    -0.28451264f, -0.53020024f, -0.06679410f, -0.17312098f, -0.04267528f, -1.00737798f, -0.12283075f, -0.49270502f, 
    -0.01079898f, 0.69922441f, -0.21092018f, 0.01270098f, 0.79353958f, -0.50918525f, -0.26726037f, -0.00608130f, 
    0.27984780f, -0.12513414f, -0.06848920f, 0.01056016f, 0.19695696f, -0.18094154f, -0.03666168f, 0.57731748f, 
    0.02274633f, -0.30631354f, 0.03464846f, -0.04622868f, 0.51076013f, 0.05802255f, 0.16588919f, -0.08478352f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26383302f, -0.00689826f, -0.00556992f, 0.04038283f, -0.37784782f, 0.18620875f, -0.10822260f, -0.40224451f, 
    0.01570627f, 0.26397553f, 0.06141011f, -0.06080509f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
