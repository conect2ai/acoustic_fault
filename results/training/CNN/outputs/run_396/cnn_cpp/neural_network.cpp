#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.07707882f, -0.40347406f, 0.77437049f, 0.75233901f, 0.59097463f, 0.39129254f, 0.21632001f, -0.26839989f, 
    0.25791240f, 0.45394590f, -0.75230837f, -0.62268460f, 0.63863361f, -0.74195927f, 0.24840757f, -0.22454472f, 
    -0.23107509f, -0.38415238f, 1.01533139f, 0.77894562f, 0.90181196f, 0.00334034f, -0.50325632f, -0.35674298f, 
    0.28568980f, -0.11018824f, -0.47483143f, 0.45076847f, 0.64614725f, 0.28083792f, -0.21841739f, -0.61871564f, 
    0.13835306f, -0.69054872f, -0.00733473f, 0.22862524f, 0.37275425f, 0.99756110f, 0.48246154f, 0.80359018f, 
    0.46350941f, -0.85109520f, 0.07316143f, 0.04608662f, -0.27842000f, -0.00333823f, 0.94136548f, -0.58098108f, 
    -0.20522961f, 0.63132483f, 0.67236280f, 0.04362744f, 0.22660933f, -0.43289104f, 0.87770551f, 0.18823630f, 
    -0.75823063f, 0.25877902f, 0.63647938f, -0.31374666f, 0.14261705f, 0.40189493f, -0.16591454f, 0.56316674f, 
    0.78284442f, 0.93607879f, -1.24149930f, 0.34899420f, -0.64459664f, 0.25011000f, 0.06451786f, 0.02573974f, 
    -0.63133299f, -0.84738356f, -0.63938451f, 0.28989473f, 0.80846435f, -0.19116898f, -0.20801091f, -0.29537281f, 
    -0.25327504f, -0.68775368f, 0.10077910f, 0.87592918f, -0.57091403f, 0.60613590f, -0.02822409f, 0.36341938f, 
    0.09562448f, -0.11440380f, 0.66223854f, -1.13790059f, 0.56259185f, -0.51252985f, 0.73679620f, -0.62464231f, 
    0.49282169f, 0.34952530f, 0.04011792f, -0.63203937f, -0.07394653f, -0.81459665f, 0.15018475f, 0.81391227f, 
    0.54945725f, 0.14505084f, 0.07143188f, 0.31950450f, 0.26533857f, 0.42122555f, 0.00156806f, -0.93699843f, 
    -1.03684652f, 0.20750012f, 0.36227956f, 0.00072260f, -0.08012064f, 0.80800790f, 0.96254772f, 0.02946064f, 
    -0.39661813f, -0.48364931f, -0.23816513f, 0.54860771f, 0.39059481f, -0.06033098f, 0.16519001f, 0.89648449f, 
    -0.50926673f, -0.38954902f, -0.43594185f, 0.81024957f, -0.43731797f, 0.54468328f, -0.23591977f, 0.34555680f, 
    -1.09760094f, 0.34007135f, -0.09650584f, 0.14938906f, 0.52906370f, -0.28105277f, 0.42634323f, -0.46464700f, 
    -0.41353363f, -1.18351305f, -0.28901580f, 0.08118864f, 0.92443818f, 0.59423018f, -0.24599080f, -0.16061018f, 
    -0.61056137f, 0.60765123f, -0.34603697f, 0.43510690f, -0.66783065f, -0.65855318f, -0.67675459f, 0.34846601f, 
    0.57521605f, 0.45650512f, -0.32778999f, -0.71110380f, -0.76060140f, 0.13799223f, -0.17535757f, -0.60965472f, 
    -0.21238795f, 0.00214015f, -0.21888717f, 0.42462406f, 0.66881192f, -0.50702810f, -0.56466049f, -0.76351374f, 
    -0.91310263f, -0.01713165f, 0.04233618f, 0.39455655f, -0.78060740f, -0.89717513f, -0.79236573f, 0.08790115f, 
    -0.00102991f, 0.02798880f, 0.21192317f, 0.11829330f, 0.49259105f, -0.22851436f, -0.44864705f, -1.07630885f, 
    -0.85202396f, 0.06012677f, 0.61664981f, 0.27119076f, -0.26394889f, 0.37119514f, -0.08074047f, -0.32146406f, 
    -0.71418846f, 0.56554437f, -1.06119049f, 0.50600541f, -0.29794985f, -0.35289782f, 0.54922086f, -0.75599891f, 
    0.63013613f, 0.00820694f, -0.77097237f, 0.09366980f, 0.10947784f, 0.07274413f, 0.18009037f, 0.55832422f, 
    -0.71460038f, -0.82621294f, 0.20405343f, -0.30786118f, -0.55190784f, 0.69840842f, 0.41734737f, -0.05023193f, 
    0.22625723f, -0.68091607f, -0.89550620f, -0.00340504f, -0.66308206f, -0.81613624f, -0.47720578f, 0.61652231f, 
    -0.22626559f, -0.21278936f, -0.60144848f, 0.23984186f, -0.48757279f, 0.48840877f, 0.50393826f, 0.52173436f, 
    0.44500765f, 0.11732033f, 0.31639972f, 0.77332991f, -1.12860525f, 1.03618908f, 0.54154301f, -0.48611015f, 
    0.59088588f, 0.27337492f, -0.28004956f, -0.08699317f, 1.04037523f, -0.39954630f, 0.74898106f, 0.20247875f, 
    0.19972767f, 0.16478242f, -0.58970582f, -0.10824756f, -0.20384976f, 0.40160254f, 0.40027627f, 0.44721082f, 
    0.40855324f, 0.60569030f, 0.67975384f, -0.25803766f, 0.54883134f, 0.13718797f, 0.16818731f, 0.83215654f, 
    0.23843990f, 0.32197249f, 0.40519863f, 0.64114785f, 0.15778412f, -0.49646056f, -0.33699217f, -0.63202113f, 
    -1.03204560f, -0.46970639f, -0.46421564f, 0.35319501f, 0.74735039f, 0.42681488f, 0.00165856f, 0.03779118f, 
    -1.22850239f, 0.75833911f, 0.83866304f, 0.66890049f, 0.30830187f, 0.68222070f, -0.08871986f, -0.20954090f, 
    -0.33536923f, -0.09375153f, -0.01514050f, -0.97297585f, 0.52525371f, -0.77246141f, 0.37472209f, -0.66259456f, 
    -0.44367918f, -0.45214552f, 1.01361144f, 0.44273844f, -0.13415338f, 0.15592840f, 0.75211036f, 0.30626610f, 
    -0.56422389f, -0.04642900f, -0.45289564f, 1.08490133f, -0.63297057f, -0.91413695f, 0.71438289f, -0.57210577f, 
    -0.01373086f, -0.20239253f, 0.05222341f, -0.26091194f, -0.69879156f, 0.75956869f, 1.09445250f, 0.38418588f, 
    -0.37429443f, -0.11251494f, -0.11455296f, 0.11041400f, 0.42020035f, 0.68227375f, -0.04034338f, 0.33483616f, 
    0.46614394f, 0.33988532f, 0.45563516f, 0.35751620f, 0.34154266f, 0.58746225f, -0.74890256f, 0.91880351f, 
    -0.04124112f, 0.11238513f, -0.55100280f, -0.87461621f, 0.02453184f, -0.08609156f, 0.34429261f, -0.97357345f, 
    0.91008377f, -0.63042611f, -0.02019682f, -0.00205375f, -0.48412719f, 0.04291519f, 0.02809308f, -0.09202170f, 
    0.51246041f, 0.31595570f, 0.42154655f, 0.06435611f, -0.25543690f, 0.65328860f, 0.31434837f, -0.55587357f, 
    0.62846643f, -0.48915714f, -0.23750170f, -0.17662182f, 0.98647684f, 0.57474869f, 0.37626776f, -0.18441838f, 
    -0.67484915f, 0.23267335f, -0.89150137f, 0.10963594f, 0.84999800f, -0.75334650f, 0.65905052f, 0.25150225f, 
    -0.48605177f, 0.25477946f, 0.40596971f, -1.03152096f, 1.07205141f, 0.98621762f, 0.41326001f, 0.86349458f, 
    -0.29381290f, -0.22844672f, -0.21960963f, 0.19465047f, -0.64386564f, -0.71044493f, -0.68674707f, -0.66320395f, 
    0.54657698f, 0.58230370f, -0.22108412f, -0.16393963f, 0.08538678f, 0.56177193f, 0.75446701f, -0.07008823f, 
    0.45874041f, -0.59303606f, 0.58900660f, -0.02694130f, 0.14722589f, -0.12290094f, 0.66478831f, -0.72169602f, 
    -0.76569766f, 0.14275472f, 0.23549518f, -0.82460403f, -0.59304005f, 0.39659047f, -0.02927626f, 1.00383472f, 
    0.66084284f, 0.30618310f, -0.22484308f, 0.15563139f, 0.48804876f, 0.41819695f, 0.28638482f, -0.43090940f, 
    0.53878909f, 0.00547338f, 0.51837200f, 0.23806870f, -0.89426678f, -0.73857468f, -0.15158278f, -0.36093220f, 
    -0.34294581f, 1.06927836f, 0.92214507f, -0.37802505f, -0.25482810f, 0.07397797f, 0.00209086f, -0.00413873f, 
    -0.32227638f, 0.27744070f, -0.43055114f, 0.92737770f, -0.31538770f, -1.06589901f, 0.41151893f, -0.19375914f, 
    -0.02165803f, -0.48534697f, 0.08659744f, 0.37513977f, -1.06184995f, -0.80946571f, -0.82875860f, 0.46207169f, 
    -0.02345335f, 0.28053632f, 0.54144752f, 0.04926951f, -0.47392246f, -1.01792586f, -0.56036973f, 0.62712890f, 
    0.82685590f, 0.60309023f, -0.35019201f, -0.07985265f, -0.18771057f, -0.26783565f, -0.74151564f, 0.50698894f, 
    -0.35724682f, -0.90002120f, -0.27501947f, 0.33624291f, 0.33924723f, -0.20576122f, -0.97589242f, 0.44648868f, 
    0.27444866f, -0.31487975f, -0.08506837f, -0.76088142f, 0.43725193f, 0.41115850f, 0.34922561f, -0.23240191f, 
    -0.94136781f, 0.69987732f, 0.10684191f, 0.01641602f, 0.94859123f, -0.20595220f, -0.55661225f, 0.17486407f, 
    -0.18758692f, 0.66099674f, -0.74922055f, 0.78515065f, -0.48641783f, -0.81446850f, -0.21526694f, 0.52161676f, 
    0.03610973f, -0.54836553f, 1.00260305f, -0.88301891f, 0.17099373f, -0.26212579f, -0.73402029f, 0.20969921f, 
    -0.24365288f, -0.48241967f, 0.10708615f, 1.12429750f, -0.60570282f, 0.59067661f, 0.62432998f, 0.20184223f, 
    -0.36137962f, -0.38385800f, 0.27380240f, 0.70774359f, 0.35727802f, 0.60674191f, -0.21452105f, -0.48280960f, 
    0.61674660f, -0.38983122f, -0.17566082f, -0.11009987f, 0.96189648f, -0.35840949f, -0.89928168f, -0.54075867f, 
    -0.32423395f, -0.04238798f, -0.45561388f, -0.66041261f, 0.32661116f, -1.06617737f, -0.04032335f, -0.39090514f, 
    -0.14765026f, 0.74900895f, -0.32772684f, -0.39636332f, -0.22677392f, 0.49345502f, 0.48618993f, 1.05052614f, 
    0.78837234f, -0.56925994f, 0.82699633f, -0.01092591f, -0.24713390f, 0.52726692f, -0.09420589f, -0.45241502f, 
    0.42917961f, -0.32138848f, -0.58979535f, 0.01584128f, -0.80353653f, -0.31865045f, 0.46976185f, 0.34642765f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01821066f, 0.11117303f, 0.15680243f, 0.15067974f, 0.22407463f, 0.23155752f, 0.02379221f, -0.03647341f, 
    0.07239306f, 0.13744278f, -0.07027203f, 0.21024747f, 0.15212980f, -0.13752234f, -0.02223022f, -0.00252133f, 
    0.13537733f, 0.22844066f, -0.02515477f, -0.10396360f, 0.33834824f, 0.16654262f, 0.17404301f, 0.17375650f, 
    0.44468728f, 0.43494496f, 0.28208649f, -0.07798456f, 0.15087217f, 0.10897908f, -0.00415053f, 0.16278769f, 
    0.27247754f, -0.29863131f, 0.26589289f, 0.03711865f, -0.09530418f, -0.03882165f, -0.13399640f, 0.10528494f, 
    0.01785118f, 0.01223892f, 0.07794922f, 0.02754930f, 0.07206447f, 0.14691408f, 0.25745893f, 0.05433943f, 
    0.01579006f, 0.25781444f, -0.07116380f, 0.16228011f, 0.14111397f, 0.29036206f, -0.09378039f, 0.04962517f, 
    -0.07545380f, -0.16897939f, 0.26355213f, 0.22295164f, 0.20825790f, 0.20542280f, 0.00400332f, 0.24154723f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08695564f, 0.05898084f, 0.21623428f, -0.01007778f, -0.13938482f, 0.05448502f, 0.07789117f, 0.03829987f, 
    0.01484452f, -0.03678282f, -0.03963227f, -0.02031778f, 0.00227022f, -0.06863788f, -0.02527037f, 0.01755721f, 
    0.09242198f, -0.06518807f, 0.05959630f, 0.05058331f, 0.22177728f, -0.19221362f, 0.10401818f, 0.02661021f, 
    -0.20361246f, 0.04274101f, 0.07546675f, -0.02936971f, -0.01686377f, -0.06636027f, -0.11296695f, -0.06903601f, 
    0.03448942f, 0.03712015f, -0.01190356f, 0.06411066f, 0.01584693f, 0.02392218f, -0.02567307f, 0.02207308f, 
    0.11848027f, 0.05333073f, -0.00479790f, -0.13900349f, 0.07428223f, -0.19100314f, -0.16802205f, -0.03024637f, 
    0.06350815f, 0.05504644f, 0.04378891f, -0.01502226f, -0.09222336f, -0.02412745f, -0.05586708f, 0.05941980f, 
    -0.03997567f, 0.03584719f, 0.03502405f, 0.06849787f, 0.04874308f, 0.04894128f, -0.02036414f, -0.08226189f, 
    0.09670242f, 0.03952124f, -0.09541994f, -0.05970258f, 0.04106197f, -0.01382025f, 0.02873175f, -0.04608006f, 
    -0.09388926f, 0.04515010f, -0.01059345f, 0.00176022f, 0.02374589f, -0.08772899f, 0.05556084f, 0.12210448f, 
    -0.03355382f, 0.07924058f, 0.12811565f, -0.06152721f, 0.08380996f, -0.13128491f, -0.06189357f, 0.04635525f, 
    0.02548967f, -0.01401020f, 0.04954093f, 0.08514390f, -0.05719705f, 0.03152785f, -0.03295270f, 0.00174515f, 
    0.00689345f, 0.02508334f, -0.05069177f, -0.02982506f, -0.06464018f, 0.11269002f, 0.08415993f, -0.24199609f, 
    0.23758388f, 0.05269656f, -0.06475182f, 0.02785992f, 0.00454844f, -0.03925825f, -0.09130808f, -0.04869646f, 
    -0.04541048f, -0.06893715f, 0.06735971f, -0.04652208f, 0.07643779f, -0.09160396f, 0.00372840f, -0.08049211f, 
    -0.14719255f, -0.00796046f, 0.08260474f, -0.13014653f, 0.29460871f, -0.09824143f, 0.02257996f, -0.03169448f, 
    0.05840638f, -0.00930932f, 0.01688436f, 0.07622493f, 0.09348857f, -0.05054016f, 0.08756950f, -0.01268808f, 
    0.00152905f, 0.07062984f, 0.09448715f, -0.04201529f, 0.10671609f, 0.09689378f, -0.07769851f, -0.00750347f, 
    -0.01030947f, -0.14481774f, -0.12504575f, -0.10094096f, 0.02198057f, 0.05179162f, -0.00953999f, 0.01160935f, 
    -0.07704537f, -0.10646964f, 0.00446792f, -0.09845815f, -0.00025818f, 0.05745488f, 0.00584582f, -0.01995850f, 
    0.07487441f, 0.10557499f, 0.07758553f, -0.14535342f, -0.35248283f, 0.05238405f, 0.01373110f, 0.00140148f, 
    0.07254230f, -0.05718523f, 0.00866018f, -0.01525455f, 0.02216384f, 0.03522700f, -0.00101698f, 0.02112918f, 
    0.05809329f, 0.07148883f, -0.00346122f, -0.06643912f, -0.12067886f, -0.06391655f, 0.14011236f, 0.07844531f, 
    -0.12448161f, -0.00530652f, -0.08324153f, 0.01826572f, -0.01206973f, -0.01463856f, 0.00286460f, -0.00107135f, 
    0.07474031f, -0.01013954f, -0.01220710f, 0.07351492f, -0.02588584f, -0.06398489f, 0.00922702f, -0.06066196f, 
    0.07950300f, -0.23419021f, 0.06000376f, 0.16494569f, -0.40147206f, -0.14498957f, -0.16936356f, 0.02786829f, 
    0.01598803f, -0.03024305f, 0.01502962f, 0.12607436f, -0.05612523f, 0.04790144f, -0.08056842f, 0.00130867f, 
    -0.11337306f, 0.00648316f, -0.02262685f, 0.01213050f, 0.04667355f, 0.20040180f, -0.05011937f, -0.28255153f, 
    -0.15047345f, 0.09741817f, -0.03039613f, -0.10066933f, 0.06378280f, -0.04211210f, 0.04255950f, -0.00282776f, 
    -0.07241464f, 0.05707030f, 0.03124988f, 0.01344110f, 0.00526872f, 0.00301970f, 0.03613513f, -0.01562602f, 
    0.09452871f, -0.08432481f, 0.07211065f, -0.01413968f, 0.07200611f, -0.01337229f, -0.02743053f, -0.11430553f, 
    -0.01716934f, -0.02877171f, -0.05269776f, -0.04280240f, 0.11311767f, -0.11703368f, -0.01596270f, -0.02055266f, 
    0.06629557f, -0.09816821f, 0.01581241f, -0.00286019f, 0.10030826f, 0.07805659f, 0.18787421f, -0.06657141f, 
    0.22457695f, -0.10207672f, -0.01692917f, 0.00795717f, 0.06581660f, -0.02620747f, -0.00268629f, -0.01689379f, 
    0.00100193f, 0.04579839f, -0.00699777f, -0.01128239f, 0.03342699f, 0.06150972f, 0.06529748f, -0.00737985f, 
    0.01070639f, 0.02695359f, 0.09049649f, -0.23166290f, 0.23750511f, -0.02079438f, -0.01779437f, -0.11838785f, 
    -0.08211280f, 0.00079665f, -0.11086532f, -0.09545739f, 0.01927632f, -0.02534229f, 0.06078218f, -0.06876927f, 
    0.03352142f, -0.07090700f, -0.07576762f, -0.03858790f, 0.12228671f, -0.06583717f, -0.08563595f, 0.00159961f, 
    -0.41172621f, -0.11838418f, 0.02412318f, 0.00856666f, -0.00031619f, 0.04304105f, 0.03742116f, -0.00828339f, 
    0.10960153f, -0.01900498f, 0.00840737f, -0.00761433f, -0.01901352f, -0.07958097f, -0.20554419f, -0.01826455f, 
    -0.13307475f, 0.13629466f, 0.05720650f, -0.19002432f, -0.27096725f, 0.04840916f, 0.04497820f, -0.07307594f, 
    0.05824741f, -0.00048290f, 0.06616297f, -0.04541650f, 0.05074165f, 0.00369833f, -0.10492505f, 0.00095846f, 
    0.03128834f, 0.01923332f, -0.03081157f, 0.01789841f, 0.09104070f, -0.16038398f, 0.09114073f, 0.07295986f, 
    -0.07402287f, -0.03456511f, -0.01404832f, -0.05567623f, 0.01180530f, -0.00178174f, -0.08349795f, -0.00517219f, 
    -0.02529482f, -0.05186800f, -0.00390905f, -0.03597959f, -0.03108141f, -0.07953126f, 0.09502314f, -0.06513727f, 
    -0.16614756f, -0.36145991f, -0.01800726f, -0.03537149f, -0.16667074f, 0.04812289f, -0.07431827f, 0.03001167f, 
    0.02704561f, -0.06849861f, 0.00930096f, -0.15105344f, -0.02226178f, 0.07398383f, 0.08530536f, -0.04787100f, 
    0.03916137f, 0.06273241f, -0.02511759f, 0.07556367f, -0.03668501f, -0.17941210f, 0.18608247f, -0.02035094f, 
    0.11597057f, -0.05087839f, 0.03308711f, -0.08910796f, 0.07311467f, 0.10123120f, 0.01794619f, 0.03268915f, 
    0.06142295f, 0.04936234f, -0.03572879f, 0.07459342f, 0.00356374f, 0.00552833f, 0.06566945f, -0.08196787f, 
    -0.11903367f, -0.09138043f, -0.13377370f, -0.02531244f, -0.13170972f, -0.02824308f, -0.00536649f, 0.00762990f, 
    0.06649778f, 0.00884145f, 0.00198105f, 0.03479972f, -0.01060650f, 0.00250958f, 0.04932210f, 0.03613020f, 
    -0.00591961f, 0.04489826f, -0.03503383f, -0.05673794f, -0.38679317f, 0.15606949f, -0.11715735f, -0.05725874f, 
    -0.12202428f, -0.00818331f, -0.03795046f, -0.00683712f, 0.04639605f, -0.06342969f, 0.00655918f, -0.08787820f, 
    0.01674414f, 0.07143080f, 0.02039329f, -0.06406350f, -0.05205494f, -0.01627777f, 0.00750229f, -0.05918210f, 
    0.22216688f, -0.22478247f, -0.01257192f, 0.04082910f, -0.12141800f, -0.04256928f, 0.08764540f, -0.01829655f, 
    -0.04851174f, -0.07921346f, -0.02118492f, 0.07693528f, -0.05795116f, 0.02241272f, 0.07531337f, 0.12898417f, 
    -0.02613172f, 0.05701223f, -0.07931913f, -0.05202886f, -0.09676097f, -0.09197114f, 0.00564582f, 0.00888291f, 
    0.04571864f, 0.02710739f, -0.06572185f, -0.05356605f, 0.03401687f, -0.03777893f, -0.00886247f, -0.02395361f, 
    0.04863121f, 0.04492076f, 0.05389343f, -0.07330479f, -0.03613378f, 0.10428403f, -0.13576332f, -0.06885676f, 
    -0.15270399f, -0.07463741f, -0.08984902f, 0.03508722f, -0.12076515f, -0.02935118f, 0.02035851f, -0.10861753f, 
    0.00328863f, 0.05437690f, -0.00455378f, -0.00546323f, -0.05747788f, -0.05908193f, 0.03260930f, -0.01209638f, 
    0.01853247f, 0.00145222f, 0.04440361f, -0.02228720f, -0.16002461f, -0.38268048f, -0.13848558f, 0.07755211f, 
    -0.08920908f, -0.02482791f, -0.06613135f, -0.05749694f, 0.07420272f, -0.00665694f, 0.03014535f, -0.03387358f, 
    -0.08297478f, -0.08066811f, -0.03736120f, 0.01373477f, 0.01964403f, -0.02829542f, 0.02171369f, 0.00794086f, 
    0.17346588f, -0.02217227f, -0.00192858f, -0.19232149f, -0.12728934f, 0.00981394f, 0.02557735f, -0.03515452f, 
    0.01240121f, -0.01787989f, 0.01838208f, -0.02603143f, -0.02073849f, 0.07488591f, 0.06989947f, 0.04608421f, 
    -0.04799995f, 0.02636889f, -0.01129464f, -0.03014550f, 0.24991576f, -0.21558583f, 0.05567658f, -0.00305405f, 
    -0.32944003f, 0.01562296f, -0.01510031f, 0.05601303f, -0.01642819f, 0.04846155f, -0.15967950f, 0.02313411f, 
    -0.08382255f, -0.01934207f, 0.09861315f, -0.09762441f, -0.09975174f, 0.06160828f, 0.04109985f, 0.02870110f, 
    0.22853920f, -0.01080143f, -0.03197965f, 0.04974256f, -0.05226466f, -0.00682327f, -0.08373409f, -0.01485030f, 
    0.04827970f, -0.05077013f, -0.06317235f, 0.08626933f, 0.01988472f, -0.01043261f, 0.05714587f, 0.04159994f, 
    0.00256117f, 0.04530155f, 0.00380789f, 0.02890768f, -0.07176578f, 0.01716381f, -0.07419645f, -0.05263542f, 
    0.09491532f, -0.03384909f, -0.02774875f, -0.00176697f, -0.03768120f, -0.00746723f, 0.02122892f, -0.07891904f, 
    0.05131915f, 0.03047455f, 0.00753938f, 0.00078748f, -0.02213515f, -0.02559917f, -0.05372662f, 0.04296739f, 
    0.00532663f, -0.03111186f, 0.07662238f, -0.09090958f, 0.18321131f, -0.06112155f, -0.08432636f, 0.08080027f, 
    -0.02428156f, 0.00679330f, -0.02992459f, 0.06463198f, -0.03991529f, -0.03859137f, 0.08118793f, 0.06036611f, 
    0.08112153f, -0.09553006f, -0.04578782f, 0.02080393f, -0.23860078f, 0.12181832f, -0.17760548f, -0.01837389f, 
    -0.23444284f, -0.00979603f, 0.01092669f, -0.04892417f, 0.04513187f, 0.04662511f, 0.03121831f, -0.01881346f, 
    -0.11150430f, 0.05808641f, -0.02005531f, 0.03200141f, -0.09754953f, 0.00589270f, 0.06508995f, -0.02094079f, 
    0.06017478f, 0.06126240f, 0.20403776f, 0.09882500f, 0.13297623f, -0.00201751f, -0.03771018f, 0.08165614f, 
    -0.02991247f, 0.01903298f, 0.01146586f, -0.05325181f, 0.05961362f, -0.08997420f, -0.04287929f, 0.03378003f, 
    -0.04919803f, -0.11671541f, -0.01995182f, -0.01311707f, 0.28231326f, -0.21593674f, 0.04483525f, 0.08405130f, 
    -0.08491219f, 0.01761809f, 0.03395981f, 0.07334839f, -0.07484116f, -0.02782028f, 0.00370549f, -0.01947961f, 
    0.01870276f, 0.07873413f, 0.00600761f, 0.08906937f, 0.02061810f, 0.01920621f, -0.14083567f, 0.02292728f, 
    0.09843816f, 0.06870250f, 0.05734934f, -0.03855940f, 0.21003424f, -0.11096190f, -0.01368324f, -0.13622671f, 
    0.02606343f, -0.03049015f, -0.02104964f, 0.03455058f, 0.05610402f, -0.04758894f, -0.06782311f, 0.03310807f, 
    0.08148552f, -0.04760082f, -0.03201151f, 0.03398226f, 0.28686765f, -0.37236542f, 0.11869331f, 0.01582067f, 
    0.07764072f, -0.00432638f, 0.05948554f, 0.06201394f, 0.06946276f, -0.07095301f, -0.13710946f, -0.04537857f, 
    -0.03710028f, 0.05305409f, 0.01428531f, 0.04620221f, 0.03044729f, 0.07869735f, 0.01875449f, 0.04907757f, 
    -0.43346274f, 0.04942080f, 0.09895709f, 0.07718679f, 0.09352981f, 0.00499859f, -0.06485523f, 0.00577601f, 
    -0.09716307f, -0.01358540f, 0.01886985f, 0.00716869f, 0.04574880f, 0.05548800f, -0.02731583f, -0.08517831f, 
    0.01401457f, -0.00417159f, -0.00683747f, 0.02152005f, -0.05547353f, -0.06732821f, -0.12285890f, -0.07652445f, 
    -0.00567332f, 0.07547381f, -0.00253632f, 0.01671384f, -0.03141638f, -0.06191070f, 0.01540160f, 0.06031555f, 
    -0.01436869f, 0.05609236f, 0.06269313f, 0.07308350f, -0.08422697f, 0.00965168f, -0.06649513f, -0.02673793f, 
    -0.15189184f, 0.02340599f, -0.00496140f, -0.08900082f, 0.06551883f, -0.03519653f, -0.06438974f, -0.00908740f, 
    -0.14303020f, 0.01718631f, 0.03332088f, 0.04955975f, -0.00057344f, 0.08222392f, 0.00269166f, 0.02506232f, 
    -0.05288794f, 0.11129588f, -0.05126024f, -0.03839665f, 0.33616117f, -0.06126132f, -0.04578898f, 0.00620976f, 
    0.05360869f, 0.01341966f, -0.06643160f, 0.05668003f, -0.02207132f, 0.01961320f, 0.05574284f, 0.03262056f, 
    -0.07998537f, -0.01463849f, 0.03307392f, -0.03519106f, -0.05745718f, 0.09166370f, -0.05112405f, -0.09509029f, 
    0.05871191f, -0.07378604f, 0.00543125f, -0.12784192f, 0.09394862f, -0.06833560f, -0.06495004f, -0.12430347f, 
    -0.00623801f, -0.02684015f, -0.03670519f, -0.03815480f, 0.12080085f, 0.01239559f, 0.03555787f, 0.00066091f, 
    0.03163673f, -0.00589635f, -0.05432588f, 0.05429854f, 0.22659265f, 0.04188868f, 0.10865115f, -0.08132456f, 
    -0.14042297f, 0.06136409f, 0.07528398f, -0.01586359f, -0.02089074f, -0.08852974f, -0.00794872f, 0.00511229f, 
    -0.06881084f, 0.02212667f, 0.04108128f, 0.04179351f, 0.05257892f, 0.01580558f, -0.01308454f, 0.04490682f, 
    -0.09479774f, -0.01033414f, -0.03261442f, 0.19359793f, 0.03660526f, -0.01701251f, 0.04221068f, 0.05917577f, 
    0.11148224f, -0.03930783f, 0.05436085f, 0.01879762f, 0.01416805f, 0.02172323f, 0.01032052f, 0.06957480f, 
    -0.00238944f, 0.02754311f, 0.03200185f, 0.02479315f, 0.20504920f, -0.04598713f, 0.25528091f, 0.04000351f, 
    0.13931987f, -0.07810901f, -0.10002689f, 0.06808659f, 0.00107175f, -0.04304554f, 0.01240591f, -0.00320223f, 
    0.01644723f, 0.02287498f, -0.04065428f, 0.02730702f, -0.02544097f, -0.00841556f, -0.01417019f, -0.01265238f, 
    -0.19120741f, 0.29692817f, -0.16555387f, -0.19922243f, -0.21592438f, 0.02551049f, 0.03484479f, -0.03405291f, 
    0.04519319f, -0.00467102f, 0.04578313f, 0.00461801f, 0.01764295f, 0.07724694f, -0.04018505f, 0.03240950f, 
    -0.06372628f, -0.00090251f, 0.03072616f, 0.01279128f, 0.11601993f, -0.12810321f, 0.10044511f, -0.12306398f, 
    0.02690476f, -0.10271434f, 0.07733408f, -0.00156500f, -0.00854486f, 0.02035850f, -0.00800582f, -0.01854821f, 
    -0.04109918f, 0.00531177f, -0.02283396f, -0.03810461f, 0.02462214f, -0.03071826f, -0.06320201f, 0.06422872f, 
    -0.00337140f, -0.36427543f, 0.14414704f, -0.02610752f, 0.04122063f, -0.02275520f, -0.02982244f, 0.02455501f, 
    -0.06682543f, 0.01129176f, -0.08537828f, 0.12218820f, 0.04419765f, 0.01693190f, -0.01982132f, -0.08104769f, 
    0.03824914f, -0.04005591f, 0.01363727f, -0.02167054f, 0.15858248f, 0.10120220f, -0.00095575f, -0.19197068f, 
    0.18917747f, -0.17202021f, -0.06233077f, -0.09091861f, 0.04902104f, -0.02040657f, -0.07940224f, -0.01027106f, 
    0.01770751f, 0.02049849f, 0.05152317f, -0.04445963f, -0.04446713f, -0.06692784f, 0.02228072f, 0.00638951f, 
    0.09262956f, -0.15993817f, 0.13748099f, -0.00690551f, -0.04389480f, 0.02598239f, -0.12756307f, 0.02151755f, 
    0.01256808f, 0.04163849f, -0.14948772f, -0.01612969f, -0.02835912f, 0.04592328f, -0.03163937f, 0.11207239f, 
    -0.05588849f, 0.10453067f, 0.05041778f, -0.03109608f, 0.04035706f, 0.13415040f, -0.01402103f, -0.10411964f, 
    0.17851616f, -0.19092658f, -0.06123184f, -0.00283721f, 0.04210776f, -0.05545083f, 0.00001870f, 0.01217211f, 
    0.02480651f, -0.03134321f, -0.08029169f, 0.06122719f, -0.01545511f, -0.01825766f, 0.01070018f, -0.03186716f, 
    0.13008885f, -0.00143494f, 0.05703469f, -0.06980719f, 0.16641425f, -0.05584171f, -0.01177437f, 0.00131069f, 
    -0.07889807f, 0.00086620f, 0.03016903f, -0.04034816f, 0.02695580f, -0.02833490f, 0.12049941f, -0.07781878f, 
    -0.07848689f, 0.08184851f, 0.00949435f, -0.04397852f, -0.30498236f, -0.25930268f, -0.02845512f, 0.07316341f, 
    -0.10675947f, -0.06716952f, -0.12211287f, 0.02562752f, -0.06069070f, 0.06418281f, 0.01624392f, 0.04407912f, 
    0.00018790f, -0.02452497f, 0.09822396f, -0.03388807f, -0.09996265f, -0.07127577f, 0.02586652f, 0.03376080f, 
    -0.01855476f, 0.13020988f, 0.05565059f, -0.16870604f, -0.23279545f, 0.06944622f, 0.04607113f, 0.00893920f, 
    0.05710084f, -0.07839329f, 0.04688862f, -0.00510451f, 0.00952593f, 0.02249018f, -0.05866644f, 0.05029703f, 
    0.02318531f, 0.02387278f, 0.02946548f, 0.05338109f, -0.13625158f, -0.29215682f, -0.10761285f, 0.07617168f, 
    -0.20857137f, -0.06644359f, 0.02157678f, 0.02469797f, -0.02204072f, 0.00856340f, -0.05479929f, -0.00742336f, 
    -0.02300382f, -0.08841366f, -0.02065706f, 0.00299504f, 0.04816385f, -0.01379229f, 0.00063068f, -0.06456148f, 
    -0.20996802f, -0.16456787f, 0.02056624f, 0.04205155f, 0.04502739f, 0.12410489f, -0.02213372f, -0.02944450f, 
    -0.05977006f, 0.05473791f, 0.08338596f, 0.12573686f, -0.00940886f, 0.01113827f, 0.06564979f, -0.01795996f, 
    0.04992511f, 0.03856985f, -0.00374070f, -0.11111400f, -0.08796421f, 0.08239789f, -0.03182050f, 0.05348735f, 
    -0.22577035f, 0.03986094f, 0.04110106f, 0.01923933f, 0.05451741f, -0.07400551f, 0.02880182f, -0.06434508f, 
    -0.02492961f, -0.03970829f, 0.03892080f, 0.03754063f, 0.06698925f, 0.00831338f, 0.09012264f, 0.03262910f, 
    0.21693173f, -0.14923786f, 0.13579600f, -0.03218648f, 0.06065606f, -0.03447287f, -0.07079761f, 0.09064203f, 
    -0.14403294f, 0.03138847f, -0.07559115f, 0.02213336f, -0.03218661f, 0.12300508f, 0.02166593f, -0.02418081f, 
    -0.01979420f, 0.05376438f, -0.05571597f, -0.01353285f, 0.29060522f, -0.05203935f, 0.18748835f, -0.02933150f, 
    0.11533666f, -0.05307628f, -0.06421423f, 0.07370108f, 0.06490739f, -0.06106495f, 0.07486295f, 0.01478826f, 
    -0.02724682f, 0.02142041f, 0.04788461f, -0.01822217f, -0.01915424f, 0.12086018f, -0.02059036f, -0.14154725f, 
    0.18427539f, 0.02415516f, 0.04888014f, -0.09437176f, 0.18322089f, -0.04856735f, -0.04529102f, 0.06404989f, 
    0.00268454f, -0.08078766f, 0.02839152f, -0.01773131f, -0.01141826f, 0.05752845f, 0.03271664f, -0.01378800f, 
    0.04538426f, 0.02054677f, -0.09646217f, 0.02763292f, 0.09700032f, 0.05915171f, -0.05220373f, 0.06925301f, 
    0.00712500f, -0.07789112f, -0.13380530f, -0.08500013f, 0.01717181f, -0.01730034f, -0.07370499f, 0.05142865f, 
    0.00536063f, 0.00407680f, -0.01785295f, 0.06730365f, 0.04047704f, -0.10512100f, 0.00316229f, 0.10952589f, 
    -0.03555300f, -0.17578653f, 0.12922095f, 0.14258875f, 0.08292180f, 0.02515161f, 0.04133572f, -0.00832829f, 
    0.04161778f, 0.01431148f, -0.04152608f, -0.00889250f, 0.05198890f, 0.02701858f, -0.05519823f, 0.01312839f, 
    -0.01487380f, -0.05931179f, 0.03759501f, -0.09652963f, 0.35852933f, 0.11920647f, 0.04488832f, -0.04935824f, 
    -0.09077024f, -0.00665803f, -0.03426236f, -0.00594382f, -0.03769015f, -0.07553823f, 0.02097348f, -0.01671816f, 
    -0.02827429f, 0.00573640f, -0.04678144f, -0.02793822f, -0.13503820f, 0.01544990f, 0.00955811f, 0.00262187f, 
    -0.00198138f, 0.11943877f, -0.03982992f, -0.15602598f, 0.24693197f, -0.11247128f, -0.06833639f, -0.05125156f, 
    0.01179719f, 0.02735490f, -0.03005857f, 0.02233050f, 0.05619449f, -0.04137562f, 0.05547188f, -0.03769946f, 
    0.03966855f, -0.02381201f, 0.00653900f, -0.04922944f, -0.07239243f, -0.17797717f, 0.09026175f, -0.05628280f, 
    0.06271257f, -0.00391692f, -0.01401148f, -0.03133821f, -0.00306174f, 0.09251761f, -0.02816330f, -0.01391774f, 
    -0.04431203f, -0.00510381f, 0.00578580f, -0.06206177f, -0.01053800f, 0.05906007f, 0.06154131f, -0.01042735f, 
    -0.32523337f, 0.13452269f, -0.07776809f, 0.01134288f, -0.07973273f, -0.01705126f, 0.03433288f, 0.03501457f, 
    -0.02326537f, 0.10130467f, -0.05125080f, 0.07141752f, -0.07326928f, 0.00766832f, 0.07280419f, 0.06028404f, 
    -0.00213165f, 0.01898909f, 0.01623094f, -0.02570363f, -0.02595247f, -0.14019179f, 0.11555180f, -0.17988679f, 
    0.00429507f, -0.03117364f, 0.03447917f, -0.04806081f, -0.00790505f, 0.11343257f, 0.14998876f, -0.04541208f, 
    -0.00731367f, -0.02372794f, -0.07284545f, -0.03634225f, -0.02881988f, -0.11749631f, 0.04242541f, -0.02954409f, 
    0.08238727f, 0.06140911f, 0.03566289f, 0.11922278f, 0.03931822f, -0.03394096f, -0.01000652f, 0.01864278f, 
    0.01118853f, -0.03264482f, -0.04304416f, -0.02070420f, 0.05321901f, 0.00458868f, -0.05490240f, -0.03550529f, 
    0.06413400f, -0.02363726f, -0.06610148f, 0.02170685f, 0.16328014f, -0.06551218f, -0.05986347f, 0.03197504f, 
    0.07756443f, 0.00278225f, 0.02955665f, 0.03691725f, 0.03067096f, -0.01517780f, -0.01550505f, -0.08664652f, 
    -0.01471841f, -0.01366046f, 0.04925581f, 0.05880288f, 0.00365284f, 0.06989956f, -0.04628104f, -0.14638346f, 
    0.00064588f, -0.01396654f, 0.20567209f, -0.02650968f, 0.18004666f, -0.14151387f, -0.02232474f, -0.01648690f, 
    -0.02322575f, 0.00985253f, -0.11439504f, -0.08616300f, 0.06772863f, -0.02859016f, 0.04860945f, -0.03232041f, 
    -0.00457453f, 0.00226573f, 0.07244753f, 0.08586396f, 0.10388847f, 0.03664146f, 0.02147374f, -0.08347307f, 
    0.06861634f, -0.04887931f, 0.06537458f, -0.02182427f, 0.00355127f, -0.02360117f, 0.17554095f, 0.02806997f, 
    -0.00823968f, 0.09924560f, 0.01973295f, -0.04837986f, 0.04361070f, 0.13668270f, -0.02500706f, 0.07502108f, 
    0.31777400f, -0.34457168f, 0.05869305f, -0.10680778f, -0.12887482f, 0.02436403f, -0.09751944f, -0.03575420f, 
    -0.02364211f, 0.06058780f, -0.08947544f, -0.04248069f, -0.09214241f, 0.10388389f, 0.03650511f, -0.00238069f, 
    0.11635718f, -0.09188464f, 0.03531311f, 0.04744939f, 0.13242571f, 0.04300510f, -0.22726744f, 0.13217403f, 
    0.13012989f, 0.05347800f, -0.09517930f, 0.06407692f, -0.01162624f, -0.00734849f, 0.06821574f, -0.00750967f, 
    0.04201017f, 0.07846713f, -0.04255803f, -0.04812663f, 0.08185912f, -0.02295857f, -0.09367595f, -0.01675590f, 
    0.18085085f, -0.00261405f, -0.20664544f, -0.00891091f, -0.18500446f, 0.02169465f, -0.02882782f, 0.00077286f, 
    0.04634934f, 0.09412660f, -0.00805270f, 0.10552603f, -0.07334578f, -0.06246278f, 0.01336741f, 0.00062566f, 
    0.06247378f, -0.09736956f, -0.05720029f, 0.04696520f, -0.33581600f, 0.10070751f, -0.08626721f, -0.06221312f, 
    0.09435852f, -0.04239250f, -0.00173974f, -0.03580745f, 0.01110872f, 0.02432941f, -0.00477797f, -0.10281054f, 
    -0.00986284f, -0.01409920f, -0.06878158f, -0.03566847f, -0.02012806f, 0.01257124f, -0.08551470f, 0.03672852f, 
    0.12552206f, -0.33513862f, -0.02593485f, 0.03487790f, -0.02926401f, 0.02744416f, -0.02516626f, -0.07378441f, 
    -0.04502043f, -0.02489884f, 0.08213925f, -0.03206877f, 0.04440761f, -0.09133942f, -0.01925362f, 0.05899902f, 
    -0.00268124f, 0.01656760f, -0.00193652f, 0.02678318f, 0.14898615f, 0.03182623f, -0.10559932f, -0.04209145f, 
    -0.07304732f, 0.01749632f, 0.10908059f, -0.02501482f, -0.00358912f, -0.00075686f, -0.01625714f, -0.04541372f, 
    0.00460336f, -0.04892765f, 0.06739411f, 0.02776881f, 0.03153857f, -0.00654800f, -0.01306994f, 0.07088927f, 
    -0.21029778f, -0.09762591f, 0.02215877f, 0.00956095f, -0.00971777f, 0.03722923f, -0.04147133f, -0.00262426f, 
    0.10866947f, -0.10564402f, -0.00999591f, -0.00610990f, -0.10065867f, 0.09852556f, -0.06118641f, -0.00352427f, 
    -0.10775939f, -0.02345970f, 0.05034702f, -0.10652006f, 0.12738460f, -0.09296265f, 0.06727289f, -0.01831384f, 
    -0.01612385f, -0.11445571f, -0.11967227f, -0.00896784f, -0.06272655f, -0.04801385f, 0.00859897f, 0.02921058f, 
    0.02515548f, 0.03084643f, -0.00535329f, -0.02736592f, -0.01346416f, -0.11775608f, -0.05665226f, -0.04611091f, 
    -0.00940054f, -0.10771679f, 0.00608415f, -0.19949791f, 0.03346452f, 0.10409994f, -0.10695209f, -0.00738649f, 
    0.06393819f, -0.11857184f, 0.07548247f, 0.07841966f, -0.07806163f, 0.01884870f, -0.07634111f, -0.04247456f, 
    0.04490510f, 0.09435613f, 0.07075470f, -0.14431174f, 0.12133911f, -0.11331104f, 0.08029556f, 0.00740283f, 
    -0.06547598f, 0.08628830f, 0.08883024f, 0.07079999f, 0.03010459f, 0.02858034f, -0.06397776f, -0.02105573f, 
    -0.04704716f, 0.03113209f, -0.23894000f, 0.03062296f, 0.08995908f, -0.02270792f, 0.09946400f, 0.11491256f, 
    0.18931462f, -0.16919912f, -0.06578216f, 0.00667182f, -0.13329567f, -0.07112646f, 0.01062984f, -0.02937768f, 
    -0.03987990f, 0.01452449f, 0.07680611f, 0.06740133f, -0.06147601f, -0.00595875f, 0.00197721f, 0.05771455f, 
    0.00924890f, -0.04566195f, -0.04654021f, 0.03053460f, -0.01535768f, -0.15607394f, 0.05525650f, 0.05102815f, 
    -0.07756379f, 0.04091688f, -0.01283789f, 0.05157156f, 0.05420765f, -0.05587767f, 0.03117551f, 0.06295425f, 
    0.01239538f, 0.00595089f, 0.04859399f, 0.03134283f, 0.02489952f, -0.10684123f, -0.06676058f, 0.04855069f, 
    0.07615718f, 0.04912220f, -0.09947323f, 0.00263615f, -0.08142549f, 0.14033696f, -0.12049016f, 0.10191887f, 
    0.03513188f, 0.11574037f, -0.04690011f, -0.04875175f, 0.03413208f, -0.00164634f, 0.00538917f, -0.01473134f, 
    0.08178797f, -0.13848996f, -0.14249612f, -0.03454188f, 0.01622254f, -0.18420182f, -0.11010238f, -0.23222400f, 
    0.07647313f, 0.00493071f, -0.10557191f, 0.15099582f, 0.01785869f, -0.07112574f, -0.07664010f, -0.01570726f, 
    0.00219920f, -0.04575054f, 0.10272035f, -0.09702479f, -0.06669965f, -0.17758490f, -0.07197013f, 0.01571810f, 
    0.20513906f, 0.09134174f, -0.06346038f, 0.04158579f, -0.08082112f, 0.14258850f, -0.00011845f, 0.08975335f, 
    0.02234186f, 0.08403796f, -0.01646293f, -0.08106781f, 0.01095556f, 0.04536844f, -0.02013436f, 0.07284179f, 
    0.09295764f, -0.04808807f, 0.07459249f, -0.07811306f, 0.26742744f, -0.14390841f, 0.00475982f, -0.04139175f, 
    0.00175046f, -0.01409331f, 0.00250021f, 0.02863549f, 0.05975834f, 0.03699378f, -0.01179126f, -0.00896666f, 
    0.05481261f, 0.00496625f, 0.04748522f, 0.03025472f, -0.07679343f, 0.00737077f, -0.03008338f, -0.00687884f, 
    -0.33630225f, 0.13017736f, 0.01881078f, -0.08264022f, 0.03101793f, -0.08958556f, -0.13210504f, 0.08189928f, 
    -0.04281375f, 0.03718017f, 0.10163111f, -0.09736767f, 0.00702298f, 0.03863795f, -0.05797184f, -0.04860603f, 
    0.00854155f, -0.04733247f, 0.15142721f, 0.01686312f, -0.26184162f, 0.10799277f, -0.11315254f, -0.11173827f, 
    0.07875653f, 0.01764807f, 0.01904506f, -0.03137659f, -0.00418115f, 0.09826522f, -0.06975197f, -0.03228622f, 
    -0.01627954f, 0.00386138f, 0.06427901f, -0.00638711f, -0.01204094f, 0.01117149f, 0.05231756f, -0.00656850f, 
    -0.09091291f, 0.13730988f, -0.00320492f, 0.07830933f, -0.22036350f, 0.06241835f, -0.05476900f, 0.00028533f, 
    0.04621640f, 0.01330602f, -0.00563521f, -0.02483586f, -0.03002933f, 0.05009402f, -0.02231488f, 0.01223669f, 
    0.03238439f, -0.04342327f, -0.04667714f, 0.06559770f, -0.01232975f, 0.11626288f, -0.04310352f, 0.02940325f, 
    -0.23238790f, 0.12360559f, -0.01408434f, 0.05477928f, 0.03063343f, -0.02193229f, -0.02677491f, -0.04532929f, 
    0.03446458f, 0.13280979f, -0.05233954f, 0.00235798f, 0.05505830f, -0.09781137f, -0.10523826f, -0.12971932f, 
    0.01955649f, 0.06343630f, -0.08778998f, 0.02428501f, 0.02408132f, -0.01203893f, 0.00408655f, 0.03214686f, 
    -0.02257965f, 0.00118795f, 0.02898424f, 0.00083166f, -0.04084314f, -0.08236503f, -0.02713238f, 0.06648856f, 
    0.08876931f, -0.00422667f, -0.02217203f, 0.08732460f, -0.11769857f, 0.13834548f, 0.13941886f, 0.00924591f, 
    -0.08683401f, -0.02909823f, -0.04917692f, 0.03719651f, 0.02485727f, 0.14226283f, 0.15184514f, 0.07008141f, 
    0.04689167f, -0.00211842f, -0.05474986f, 0.00762218f, -0.00473566f, 0.02078345f, 0.05375573f, 0.01994796f, 
    0.26821953f, -0.01194187f, 0.05807874f, 0.08444565f, 0.06958874f, -0.06396227f, 0.00179726f, 0.02951208f, 
    -0.01811087f, 0.06805643f, 0.09892340f, -0.02469436f, 0.01133051f, -0.05923180f, -0.08985542f, 0.00663433f, 
    0.03403956f, 0.01134757f, 0.01634389f, 0.03962510f, 0.14876297f, 0.24901183f, 0.03308934f, 0.01741182f, 
    0.04159609f, 0.05149370f, 0.04733356f, -0.02565602f, 0.00103941f, 0.08925419f, -0.01198161f, -0.01644898f, 
    -0.03965950f, -0.03972422f, -0.12536512f, -0.05084997f, 0.08086845f, 0.05710818f, 0.04393155f, 0.01346428f, 
    0.06079322f, 0.18793082f, 0.07825682f, 0.04629368f, 0.16874468f, -0.08031120f, 0.04046394f, -0.04612609f, 
    -0.01405515f, -0.02109719f, -0.02717939f, 0.00387395f, 0.01176837f, 0.06280319f, 0.01978806f, -0.00284994f, 
    0.01594314f, 0.05237652f, 0.05393299f, -0.00911832f, 0.24783315f, -0.00600341f, -0.07637367f, 0.08977078f, 
    -0.04574522f, -0.03958055f, -0.00852406f, -0.01110650f, 0.08991075f, 0.03679235f, 0.04401500f, -0.09283400f, 
    0.01823319f, 0.03249611f, -0.02106305f, 0.03304550f, 0.01912634f, -0.01446858f, -0.03451048f, 0.00039940f, 
    -0.17314224f, 0.09095861f, -0.09449594f, -0.06482753f, 0.02854819f, 0.02222683f, 0.03461661f, -0.02881830f, 
    -0.05103633f, 0.02039099f, 0.00999030f, 0.12662220f, 0.01570427f, 0.00532636f, 0.04829817f, 0.04552712f, 
    -0.12253615f, 0.09314257f, 0.04933604f, 0.00952009f, -0.34200752f, -0.11638346f, 0.03757592f, -0.25194734f, 
    0.10947130f, -0.09403235f, -0.05536287f, -0.07848322f, -0.07429201f, -0.00787049f, 0.08086594f, 0.00761014f, 
    -0.03392694f, -0.11862297f, -0.06847094f, -0.11904372f, -0.06744497f, -0.01892546f, 0.13448758f, -0.03903360f, 
    0.24734236f, 0.08486987f, 0.10697440f, 0.03542253f, 0.07043595f, 0.01222351f, -0.07453346f, -0.04074147f, 
    -0.00143567f, -0.01424781f, -0.03406885f, 0.06077359f, -0.04764980f, 0.07171378f, -0.02826459f, -0.04112132f, 
    -0.00266905f, 0.00066453f, 0.06587474f, 0.01765761f, 0.08789170f, -0.38455954f, 0.20439513f, -0.29049626f, 
    -0.09385046f, -0.01076738f, 0.01610461f, -0.04364893f, -0.06900041f, -0.05756749f, 0.02533962f, -0.06705565f, 
    0.02106346f, 0.05210170f, -0.07641758f, -0.03882270f, -0.00052642f, -0.16907893f, 0.04312044f, -0.03656735f, 
    0.06686273f, 0.05027875f, -0.11179488f, -0.06692372f, -0.04111464f, -0.09333767f, 0.00826322f, 0.01145751f, 
    -0.14126810f, 0.08855086f, -0.02577413f, 0.04498776f, 0.02517080f, -0.01543101f, -0.05440995f, 0.04477581f, 
    -0.11671891f, 0.02380318f, 0.02580272f, 0.06386215f, 0.09971192f, 0.04172977f, 0.07312571f, 0.01225370f, 
    0.01658113f, -0.16861938f, -0.05519696f, -0.01812170f, -0.00358938f, -0.01136813f, 0.00300071f, -0.10207086f, 
    -0.01557099f, -0.07653540f, -0.03013794f, -0.04033028f, 0.03859056f, -0.02078757f, 0.05952619f, -0.02174129f, 
    -0.09158522f, -0.31315005f, -0.04703057f, -0.12083714f, 0.10883068f, 0.03503321f, -0.01798073f, 0.07823415f, 
    0.02603549f, 0.02700039f, 0.00161983f, 0.03679430f, 0.06557828f, 0.01344830f, 0.02136390f, -0.02623904f, 
    0.00100242f, -0.09251928f, -0.05388554f, -0.03387217f, -0.37495142f, 0.00383340f, -0.26994768f, -0.14831495f, 
    0.11957303f, 0.02470226f, 0.06306260f, 0.00763481f, -0.02448640f, 0.08681247f, 0.06075770f, 0.02212646f, 
    0.03653847f, 0.00035641f, 0.07879288f, 0.01105325f, -0.03328401f, -0.11504274f, -0.08046059f, -0.06191934f, 
    -0.01590936f, 0.11405253f, 0.12176897f, 0.10675357f, 0.20401241f, 0.07666955f, -0.08536281f, 0.09440561f, 
    0.00435103f, 0.04471005f, -0.02527236f, -0.02281149f, -0.02072838f, -0.00984123f, -0.01933397f, 0.07402619f, 
    -0.02959977f, 0.11292051f, 0.00122369f, 0.10070999f, -0.17973831f, 0.07718195f, -0.07923119f, 0.04074886f, 
    -0.08579452f, 0.00165463f, -0.00522890f, 0.01127032f, -0.10169751f, 0.09315649f, 0.06713241f, 0.12933344f, 
    0.00634505f, -0.01573999f, 0.01373004f, 0.06604098f, -0.00019623f, -0.07444313f, 0.02124701f, 0.06454679f, 
    -0.39870012f, 0.16321535f, -0.07428394f, -0.25618109f, 0.00298387f, -0.06580181f, 0.07752024f, -0.07304535f, 
    -0.08048028f, -0.03753980f, -0.04181118f, -0.03211941f, -0.01799898f, -0.01272467f, -0.07995194f, -0.12827088f, 
    -0.04284551f, 0.03758817f, -0.04235397f, 0.07342473f, -0.30617797f, 0.12278797f, -0.08591764f, -0.06080727f, 
    0.22383569f, -0.17556910f, 0.06331436f, -0.00352817f, -0.06562205f, 0.04048603f, -0.02135682f, 0.00293922f, 
    0.14711900f, -0.02249759f, -0.04985503f, 0.03903855f, -0.09429679f, 0.02602708f, 0.04489934f, -0.03004105f, 
    0.21436219f, -0.12150813f, -0.03639082f, 0.04694342f, -0.11384300f, -0.00113736f, -0.02448986f, -0.06937396f, 
    0.03024882f, 0.05170598f, -0.00724023f, -0.02694214f, 0.00889383f, -0.00681868f, 0.09808461f, 0.04834980f, 
    -0.03113076f, 0.02711826f, -0.09317362f, -0.03108506f, 0.09529819f, -0.05874820f, 0.09767354f, 0.09600196f, 
    0.27287984f, -0.00320684f, -0.09446181f, 0.01704771f, 0.00616062f, -0.03397558f, 0.05610909f, -0.02539717f, 
    0.01315274f, 0.07423141f, -0.03337378f, -0.01840517f, 0.04674705f, 0.03235317f, 0.08964997f, -0.03331341f, 
    0.20710562f, -0.26724175f, 0.06618011f, -0.23998336f, -0.05075335f, 0.01550868f, 0.00176688f, 0.00706362f, 
    0.07060489f, 0.03148570f, -0.10154185f, -0.07901852f, 0.03202758f, 0.01069073f, 0.01598685f, 0.03964864f, 
    0.02982400f, -0.04205393f, -0.01068016f, 0.01868885f, 0.15321147f, 0.05392223f, 0.10135100f, 0.18336977f, 
    0.06244032f, -0.11171544f, -0.07364520f, 0.02496608f, -0.02556846f, 0.01802969f, 0.00784430f, -0.01949801f, 
    -0.07936776f, 0.09549547f, -0.14546748f, -0.03374826f, -0.01248473f, -0.00085213f, -0.04377062f, -0.00442900f, 
    -0.07996215f, 0.09680851f, 0.04301647f, -0.08364762f, -0.02307325f, -0.00115797f, 0.02419581f, 0.05264310f, 
    0.00645462f, -0.02977072f, -0.00163775f, -0.03259741f, 0.16683185f, -0.03331028f, -0.00185769f, -0.02838071f, 
    -0.08913251f, -0.15965174f, -0.01109529f, 0.11083487f, 0.23341390f, -0.15123054f, 0.10900658f, -0.00756657f, 
    0.00299015f, -0.01010966f, -0.03052732f, 0.00579746f, 0.03706795f, -0.03896788f, 0.00286501f, 0.01227524f, 
    -0.06090378f, 0.05113711f, 0.02218532f, -0.00911971f, -0.03236835f, 0.01319759f, -0.04332748f, -0.05873578f, 
    0.17538582f, 0.01116321f, -0.24948528f, -0.31121650f, -0.09668867f, -0.00963275f, 0.08717985f, -0.03006701f, 
    0.15543495f, -0.01725868f, -0.00403599f, -0.04495964f, 0.03943016f, 0.10710999f, -0.06791570f, 0.05188225f, 
    0.00445534f, -0.00861104f, -0.16472366f, 0.01727128f, 0.29622993f, -0.36220443f, -0.08293165f, 0.08859614f, 
    0.07791071f, -0.06981002f, 0.04226370f, -0.01609725f, 0.10941571f, 0.02442469f, 0.02053281f, -0.00123886f, 
    0.00501567f, 0.05732863f, -0.04053552f, 0.22556837f, -0.00791496f, 0.06125544f, -0.04028572f, -0.06285645f, 
    0.18037781f, -0.04541822f, -0.13338616f, 0.04165711f, -0.15333834f, -0.02807088f, 0.07439639f, -0.05043882f, 
    -0.01467591f, 0.06197862f, 0.08475047f, 0.08213132f, -0.02327922f, 0.01187076f, -0.02423778f, 0.05531282f, 
    0.07140069f, -0.03116889f, -0.02391751f, 0.00510197f, -0.28438461f, 0.17161481f, 0.04991700f, 0.03834066f, 
    -0.28098485f, 0.03839772f, -0.06974497f, 0.01152518f, 0.11269449f, -0.04311348f, -0.06005238f, 0.01174636f, 
    0.07145245f, 0.04633504f, -0.02433915f, -0.04335650f, -0.01853904f, -0.07967601f, -0.07548362f, -0.00152331f, 
    -0.36445382f, -0.13710493f, -0.05382495f, 0.00372697f, 0.00864284f, -0.12230033f, -0.05008679f, 0.06456400f, 
    -0.07611043f, 0.16340289f, -0.03926628f, -0.01169121f, 0.03929967f, -0.04429490f, -0.06509272f, -0.02886042f, 
    -0.00942043f, 0.04566395f, -0.03474801f, 0.05389452f, -0.32835811f, 0.14635959f, -0.05221962f, 0.04118642f, 
    -0.19306658f, -0.03708095f, -0.01164922f, -0.07851187f, -0.13184139f, 0.12041653f, 0.12080874f, 0.11731708f, 
    -0.15746233f, 0.00205450f, -0.00509462f, 0.01067648f, -0.01054575f, 0.02778837f, 0.01232392f, 0.02409485f, 
    -0.31094843f, -0.26530030f, -0.08974887f, -0.22276056f, 0.20293806f, 0.06727199f, -0.09182605f, -0.00573453f, 
    0.00879463f, -0.04238662f, 0.05692912f, 0.11524675f, 0.03987738f, -0.13997781f, 0.05720456f, -0.03601113f, 
    -0.07739747f, -0.18920268f, -0.02282231f, -0.09442473f, -0.28422996f, -0.04116334f, -0.53558558f, -0.33786023f, 
    0.13426104f, 0.01592014f, -0.02495862f, -0.03697394f, -0.16301079f, 0.05621765f, 0.06671889f, -0.03508867f, 
    0.05625863f, -0.15876882f, 0.05201663f, -0.03943919f, -0.06903115f, -0.10651039f, -0.02369198f, -0.02699220f, 
    -0.07152278f, 0.03308837f, 0.04519376f, 0.00364136f, 0.10002848f, -0.01827945f, 0.01120224f, -0.06093841f, 
    0.06292864f, -0.03643039f, 0.02741623f, 0.03408533f, 0.02399736f, -0.03654897f, 0.13952985f, 0.04100204f, 
    -0.01013249f, 0.05890737f, -0.00828334f, -0.00950325f, 0.10697410f, 0.02783825f, 0.00469215f, 0.06254659f, 
    0.04129293f, 0.00747117f, -0.00055079f, 0.06510420f, 0.04092896f, 0.03738395f, -0.01845271f, -0.07577148f, 
    -0.07521831f, 0.00308144f, -0.02207202f, 0.05413620f, -0.09236169f, 0.04072157f, 0.04216287f, -0.07643015f, 
    0.13530141f, -0.31342810f, 0.00214071f, -0.26558292f, -0.12153833f, -0.04113235f, -0.07543201f, 0.02036894f, 
    0.05999819f, -0.01403445f, -0.07193524f, 0.01050104f, -0.08116617f, 0.00804642f, -0.06204243f, -0.11693110f, 
    -0.06424178f, -0.01717273f, 0.00520484f, -0.11411119f, -0.18101721f, -0.02608895f, -0.07902566f, -0.08203318f, 
    0.00008539f, 0.01032222f, 0.07809395f, -0.05624812f, 0.04217377f, 0.04589389f, -0.06446547f, 0.00813518f, 
    0.02943717f, -0.10052989f, 0.08891185f, 0.01185304f, 0.01294598f, 0.04243360f, 0.00643915f, -0.10961482f, 
    0.12039145f, 0.26129290f, -0.00281929f, 0.06881483f, 0.13685398f, 0.02248359f, -0.06774446f, 0.02462613f, 
    0.04082953f, 0.02734110f, 0.02873645f, -0.02524771f, -0.01530292f, 0.02709275f, -0.06121581f, 0.01288282f, 
    0.06618556f, 0.05468669f, -0.07643320f, 0.04564756f, -0.02605949f, -0.00532511f, -0.06575541f, -0.12571590f, 
    -0.02210264f, 0.01622388f, -0.02445186f, 0.06461579f, -0.02046470f, 0.08331399f, 0.00077577f, -0.00342997f, 
    0.05486301f, 0.06288743f, 0.08220965f, -0.10494456f, 0.02685205f, -0.01057378f, -0.13903359f, -0.00797440f, 
    0.21521948f, -0.02100116f, 0.09547014f, -0.05242918f, 0.09193572f, -0.08369969f, -0.03720422f, 0.01810045f, 
    0.04305677f, -0.02626766f, 0.08873203f, -0.00865277f, 0.01075588f, -0.08676191f, 0.03491791f, 0.01330969f, 
    -0.08691022f, 0.00435602f, 0.01865545f, 0.01478617f, -0.24830998f, -0.04163346f, 0.00024687f, 0.15032598f, 
    -0.04960781f, 0.04375349f, -0.02877213f, -0.05845854f, 0.04207851f, 0.05286221f, -0.00467313f, -0.08892699f, 
    -0.02804920f, 0.05641517f, -0.00343832f, 0.01349327f, 0.02357258f, -0.01118682f, -0.08572048f, -0.03333472f, 
    -0.05842348f, 0.00168530f, 0.01454392f, -0.07094788f, 0.10040082f, 0.02882808f, 0.06995847f, 0.04190918f, 
    0.03983220f, -0.03958010f, 0.00557050f, 0.00138869f, -0.02035810f, -0.04600513f, -0.00643467f, -0.02846517f, 
    0.06543228f, -0.03521123f, -0.09904221f, 0.00632804f, -0.17202361f, 0.02819808f, -0.08546419f, -0.07974069f, 
    -0.00418766f, 0.01642622f, 0.04422346f, 0.03216377f, -0.03345024f, -0.03063418f, 0.00612670f, 0.01282651f, 
    -0.02309076f, -0.01931523f, -0.08912205f, -0.05422752f, -0.02104307f, 0.05154112f, -0.05913603f, -0.05707379f, 
    0.17547278f, -0.23503406f, 0.06321955f, -0.04501157f, 0.02636429f, 0.06079413f, 0.03222399f, 0.08979559f, 
    0.02430996f, 0.00621187f, 0.00193019f, 0.03047589f, -0.00328102f, -0.02466178f, -0.03087456f, 0.01669191f, 
    -0.12060637f, -0.04871821f, -0.11674780f, -0.02662530f, 0.05950540f, 0.05327541f, -0.03138162f, -0.00560858f, 
    -0.04363876f, -0.02235534f, -0.03119713f, 0.05137363f, -0.02640203f, 0.02435331f, -0.00875029f, -0.01916580f, 
    0.11913618f, -0.01635092f, -0.07061195f, -0.01010319f, -0.04293859f, -0.06669183f, -0.00125712f, -0.05718389f, 
    0.07376426f, -0.05654469f, 0.06680886f, -0.20592853f, -0.05248458f, -0.06899554f, -0.03251991f, 0.05036779f, 
    0.02843147f, -0.00193539f, 0.01269001f, 0.01198726f, 0.12718199f, -0.07398261f, 0.01323883f, 0.08399808f, 
    -0.12434657f, 0.04282000f, 0.07116474f, -0.04524206f, 0.10739902f, 0.20726524f, -0.14223990f, -0.13749699f, 
    0.00082932f, 0.01879269f, 0.08841868f, 0.02283548f, -0.07687533f, -0.06045943f, -0.04001511f, -0.06528015f, 
    -0.10740013f, -0.10997172f, -0.00096215f, 0.01631791f, 0.04042350f, -0.06283095f, -0.03134476f, 0.04363918f, 
    0.23564762f, -0.20887758f, 0.09491905f, 0.00114941f, 0.20347741f, -0.12353299f, -0.07162241f, -0.12735437f, 
    0.01035275f, 0.02907474f, 0.08024390f, -0.01691475f, -0.00473345f, 0.07274235f, 0.04382951f, -0.01256772f, 
    -0.08100534f, 0.00997311f, 0.01723173f, -0.01459976f, 0.21392716f, 0.00550761f, -0.13173255f, 0.03840064f, 
    -0.15787312f, -0.01712674f, -0.00911229f, 0.06457144f, -0.03678693f, 0.00133529f, -0.00315787f, -0.05531511f, 
    -0.00221935f, -0.01427076f, -0.00528509f, 0.03707008f, -0.04054309f, -0.09764465f, 0.11464942f, -0.05521705f, 
    0.18629061f, 0.10011011f, 0.11038756f, -0.07127440f, -0.02414316f, -0.06329530f, 0.04414493f, 0.01960352f, 
    0.04245578f, 0.00011906f, 0.01005240f, -0.12353107f, 0.01043773f, 0.01503363f, -0.04960529f, 0.09684662f, 
    0.05787644f, 0.00388632f, 0.16191334f, 0.00183113f, 0.09462867f, 0.07558347f, 0.10776326f, 0.08520496f, 
    0.08478373f, -0.00779203f, -0.04324472f, -0.09977657f, 0.03180801f, 0.04756730f, 0.04128704f, -0.04049670f, 
    0.04381683f, -0.00769648f, -0.03391699f, -0.00886741f, -0.03147281f, -0.00689773f, 0.00867738f, 0.02780517f, 
    -0.13109908f, 0.00399899f, 0.00947354f, -0.07288773f, -0.06666126f, -0.03526279f, -0.00498389f, 0.04602338f, 
    -0.02925302f, 0.07168969f, -0.03922319f, 0.01024628f, 0.01475592f, -0.04337392f, -0.04195565f, 0.00109156f, 
    -0.06593505f, 0.02426955f, -0.04165683f, -0.04998689f, 0.06341343f, 0.06870024f, 0.08479911f, -0.10826863f, 
    0.03477829f, 0.02596093f, -0.00347036f, 0.15832624f, -0.03402535f, 0.00294236f, -0.05752140f, 0.07338343f, 
    0.04477338f, -0.07267466f, -0.03005792f, 0.08173439f, -0.06114078f, 0.06987001f, 0.04509764f, -0.00034284f, 
    -0.00195511f, 0.01896628f, -0.03722113f, -0.00374067f, -0.13841799f, -0.02044973f, -0.00090837f, 0.06900420f, 
    0.01399524f, 0.05673074f, 0.03023566f, -0.01826099f, 0.12415748f, -0.02753603f, -0.06645556f, 0.01952648f, 
    -0.01525990f, 0.01587392f, 0.00746101f, -0.01761870f, 0.01210383f, 0.07396261f, -0.03401311f, -0.04285566f, 
    0.04652570f, 0.01156218f, -0.02816375f, 0.02493869f, 0.05225106f, -0.03100363f, 0.01376257f, -0.01777881f, 
    0.03987962f, -0.03453567f, 0.04658331f, 0.05782777f, -0.05050842f, -0.06048107f, 0.06267717f, 0.03895804f, 
    0.12734717f, 0.00334548f, 0.10533528f, 0.13214971f, 0.15554316f, -0.05239759f, -0.08970264f, -0.00698109f, 
    0.04014726f, 0.03744197f, 0.03319447f, 0.00726710f, 0.00962658f, 0.00161805f, 0.00114329f, -0.00109838f, 
    -0.11187857f, -0.00250731f, -0.03322341f, -0.03249460f, -0.01443172f, 0.12049194f, 0.03373985f, -0.12573606f, 
    -0.07926597f, 0.03582013f, 0.06481408f, -0.02901335f, -0.03685956f, -0.03352457f, -0.01856201f, 0.01012588f, 
    0.00753248f, -0.12008952f, -0.06420726f, 0.03088989f, 0.02222450f, 0.03279020f, -0.00018991f, -0.02067910f, 
    -0.18861891f, -0.32052177f, -0.09211334f, -0.05195472f, -0.20465942f, -0.05816710f, -0.05604007f, -0.07076677f, 
    0.00122219f, -0.04058318f, 0.03967934f, -0.02669580f, -0.00279315f, 0.04579382f, 0.02901698f, -0.01878899f, 
    -0.09713979f, 0.05995967f, 0.03531582f, -0.04295409f, -0.25350881f, 0.00855690f, -0.04668932f, -0.25557765f, 
    -0.08263833f, 0.12723228f, -0.01487674f, 0.06711328f, -0.05704274f, 0.01258841f, -0.00958104f, 0.04024249f, 
    -0.00612553f, -0.11306126f, -0.01859186f, 0.04827477f, -0.00531389f, 0.18048427f, -0.01885490f, -0.04825278f, 
    0.11848488f, -0.09074917f, 0.11859586f, 0.01361838f, 0.04216508f, -0.06689496f, -0.06047050f, -0.13423789f, 
    -0.00832197f, 0.03270401f, 0.02647839f, -0.00441052f, -0.04302789f, -0.04995518f, -0.00009936f, -0.00854409f, 
    -0.04296689f, 0.03025248f, -0.03584589f, 0.04272078f, 0.30554932f, -0.10882223f, -0.14148727f, 0.21548741f, 
    -0.32159084f, -0.08293444f, -0.00572825f, 0.00860851f, -0.02356176f, 0.06040063f, 0.01607677f, 0.01502911f, 
    0.06063189f, 0.00305486f, 0.00662453f, -0.03525750f, -0.06215272f, 0.02878031f, 0.01169957f, 0.03947553f, 
    -0.10377494f, 0.12912808f, 0.00996657f, 0.07356834f, 0.00409149f, -0.00209793f, -0.08678639f, -0.12473440f, 
    -0.01323903f, 0.07331929f, -0.05298721f, -0.01732228f, -0.00820025f, 0.03177198f, 0.01180333f, -0.03234662f, 
    0.07660040f, -0.01287195f, -0.02719532f, -0.02826510f, 0.12122022f, 0.05181039f, -0.17719777f, -0.05376479f, 
    -0.14219418f, 0.06500844f, 0.03657523f, -0.06928518f, -0.08606281f, 0.03837791f, 0.00961911f, 0.00075464f, 
    -0.01680584f, -0.01107278f, -0.00142141f, -0.00035742f, 0.03391025f, -0.04002389f, 0.03736927f, 0.02714779f, 
    0.11111895f, -0.05787683f, -0.02603791f, 0.00306517f, -0.08999433f, -0.08398964f, 0.00224155f, -0.09239536f, 
    -0.02780853f, -0.02194107f, -0.01263611f, -0.02514390f, 0.02314349f, -0.07022006f, -0.01627709f, 0.05757123f, 
    -0.01861943f, -0.01719473f, 0.04541625f, -0.01278313f, 0.04693712f, -0.26042765f, -0.06759252f, 0.00708077f, 
    -0.19217186f, -0.12805137f, 0.04368713f, -0.06413890f, 0.01109426f, -0.03184136f, 0.01240410f, -0.00910068f, 
    0.08779850f, -0.00880257f, -0.04391379f, 0.04199215f, -0.01476227f, 0.00094644f, 0.04907206f, -0.05366443f, 
    0.10303853f, 0.08631987f, 0.10263881f, 0.03608895f, 0.09009731f, -0.01698577f, -0.06069281f, -0.05197666f, 
    0.04897387f, 0.04398273f, 0.02527760f, -0.01315768f, -0.03812869f, -0.01084747f, -0.02191003f, 0.03723776f, 
    -0.08769121f, 0.01267617f, 0.03852028f, -0.03234122f, -0.41944414f, 0.21706894f, -0.01616330f, 0.02112725f, 
    0.00608936f, 0.02460785f, 0.03087774f, -0.02465392f, 0.02140314f, -0.04699303f, 0.02407862f, -0.00902150f, 
    0.04414181f, -0.05072880f, 0.11606681f, 0.00110910f, 0.07955039f, -0.05028323f, 0.00896164f, 0.08527809f, 
    -0.33952060f, 0.11253311f, 0.00191811f, -0.16502021f, 0.06022081f, 0.10494306f, -0.02227027f, 0.07488892f, 
    0.07488534f, -0.00464091f, -0.07219952f, 0.03522439f, -0.03197709f, 0.00433899f, 0.04162993f, -0.10837373f, 
    0.00969176f, -0.02197766f, 0.00319403f, -0.00337186f, -0.00811084f, 0.04420512f, 0.04398562f, -0.05754543f, 
    0.01851843f, -0.02701712f, -0.03901200f, 0.03029906f, -0.00582796f, -0.03229511f, -0.03569917f, -0.00179643f, 
    0.06216490f, 0.03857827f, -0.00628361f, -0.06611789f, -0.09980672f, -0.09698530f, 0.01524395f, -0.01172528f, 
    0.06126222f, 0.01796090f, -0.01128387f, -0.11186597f, 0.01326770f, 0.06140210f, -0.05614875f, 0.05642187f, 
    0.04990738f, 0.00610131f, 0.01957894f, 0.00657552f, 0.02523647f, 0.04776932f, -0.04348172f, -0.07567371f, 
    -0.01132614f, -0.05566922f, -0.18415949f, -0.05244924f, 0.29785842f, -0.04972352f, 0.06877662f, 0.12603754f, 
    -0.00372359f, -0.11809781f, 0.03239395f, -0.01051211f, 0.00163134f, 0.09007533f, -0.00611900f, -0.01827830f, 
    0.04843626f, -0.01338539f, -0.04986040f, 0.08243147f, -0.09259848f, 0.04012426f, 0.08726346f, 0.02425819f, 
    0.20055830f, 0.06178977f, -0.11471552f, 0.02020030f, 0.08063933f, -0.07944695f, 0.00437764f, 0.01233186f, 
    0.07723827f, 0.03904909f, -0.02872413f, 0.03991310f, -0.02219858f, 0.03041203f, 0.00218794f, -0.00535705f, 
    -0.01906553f, -0.11522266f, -0.01719874f, -0.01670069f, -0.18835677f, -0.12205977f, -0.06531048f, 0.19294335f, 
    -0.14050929f, 0.05016548f, -0.06831633f, -0.04357482f, 0.05299560f, 0.04073655f, 0.01975620f, -0.06724776f, 
    -0.01992141f, 0.10468796f, -0.01884749f, -0.00133229f, 0.02730374f, 0.00906604f, -0.11571603f, -0.06285477f, 
    0.06859630f, -0.05892600f, -0.01781150f, -0.05576966f, 0.00976858f, 0.02529561f, -0.09212994f, 0.06158210f, 
    0.02978829f, 0.02627727f, -0.01239023f, -0.00792208f, 0.01713952f, 0.03931536f, 0.00850646f, -0.01143518f, 
    -0.00628759f, -0.03756220f, -0.02686445f, -0.05458648f, -0.25197092f, -0.21170448f, -0.00609505f, -0.06789327f, 
    -0.11251179f, 0.03397144f, -0.04955540f, 0.02201072f, 0.05098738f, 0.10204672f, -0.00102329f, 0.00842581f, 
    -0.00722019f, 0.00451779f, 0.00092996f, 0.07040534f, 0.02918057f, 0.01171673f, -0.02917132f, -0.06527706f, 
    0.22859193f, 0.15899415f, -0.13741814f, 0.05375241f, -0.18598758f, -0.03023910f, 0.12894320f, 0.02850231f, 
    -0.02718640f, -0.04832091f, -0.09648526f, 0.06167591f, -0.00285611f, 0.07781044f, 0.00291306f, 0.00354727f, 
    0.06510475f, 0.00743724f, 0.05796853f, -0.02451738f, -0.12283187f, 0.01546759f, 0.07655378f, -0.03002931f, 
    -0.00680578f, -0.06177993f, -0.03419239f, 0.00894513f, -0.03218029f, -0.02993867f, -0.12723500f, -0.00041386f, 
    0.01319017f, -0.01377780f, 0.02813652f, -0.02244787f, -0.07190291f, -0.00098955f, 0.00190008f, -0.00211059f, 
    0.02078926f, 0.12864843f, -0.11947098f, -0.18976562f, -0.10316594f, 0.13290964f, 0.04030299f, 0.00143879f, 
    -0.02933905f, -0.01318977f, -0.06562193f, 0.04611865f, -0.00522912f, -0.02099043f, -0.03955097f, -0.01782800f, 
    -0.00370406f, 0.06227021f, 0.03571617f, 0.00741115f, -0.01595738f, -0.12114429f, -0.17326495f, -0.18313710f, 
    -0.08533276f, 0.03631612f, -0.02618889f, 0.00411187f, -0.11862413f, -0.04003026f, -0.09757321f, -0.00788316f, 
    -0.06171120f, -0.04179303f, -0.04092479f, -0.01950978f, 0.03035861f, 0.09698005f, 0.01934577f, 0.01909343f, 
    -0.18958955f, 0.09806160f, -0.02285635f, 0.05714414f, -0.02498817f, 0.01297048f, -0.05161438f, 0.04280400f, 
    -0.00415424f, -0.06829919f, -0.00174527f, 0.07412802f, 0.00965477f, -0.05701965f, -0.00408917f, -0.09263703f, 
    -0.02156152f, -0.05565611f, -0.04852393f, 0.01134149f, 0.14793868f, 0.09373435f, 0.18168826f, 0.08976609f, 
    0.25096712f, -0.01858324f, -0.11248610f, -0.13310373f, 0.02507347f, 0.10111726f, 0.00947367f, -0.00848276f, 
    -0.00406269f, 0.00581855f, -0.02012228f, -0.07826997f, -0.04140870f, -0.05866496f, -0.03726080f, 0.01297388f, 
    0.23516831f, 0.01853092f, -0.22943835f, 0.01147719f, -0.12836784f, -0.04548103f, -0.02858129f, 0.06166822f, 
    0.01986587f, -0.00222990f, 0.02898407f, 0.02471315f, -0.00099623f, -0.03959501f, -0.02867655f, 0.01267414f, 
    0.08436791f, -0.08498143f, 0.02652246f, -0.02429250f, 0.22178729f, 0.02853481f, -0.06787094f, -0.01528147f, 
    -0.08402774f, 0.03526317f, 0.04464370f, 0.00746063f, -0.00258745f, 0.04789962f, 0.00945933f, 0.04217109f, 
    0.02713837f, -0.01204746f, 0.01890964f, 0.01276383f, -0.06110306f, -0.07269460f, -0.04749077f, -0.02926551f, 
    0.28474060f, 0.03084415f, -0.17118217f, 0.17193857f, 0.04831498f, -0.14061458f, 0.03412425f, -0.05192861f, 
    0.03582349f, 0.07153939f, 0.01556592f, 0.01872401f, 0.05942267f, 0.06126448f, -0.04378102f, -0.04887275f, 
    -0.03321528f, -0.06640770f, -0.00979740f, 0.07072472f, 0.02807521f, 0.02545191f, 0.04261733f, -0.01384392f, 
    -0.02825966f, 0.07003082f, -0.06531908f, 0.04272876f, 0.03031405f, 0.01980890f, -0.04412164f, -0.01209104f, 
    0.01961085f, -0.01717331f, -0.02169937f, 0.02870234f, -0.01725161f, -0.02776614f, -0.06847300f, -0.04858159f, 
    -0.23772877f, -0.23172635f, 0.03487032f, -0.20401989f, -0.13103180f, -0.10147480f, -0.04618002f, 0.04065301f, 
    0.01791100f, 0.02209010f, 0.03643710f, 0.01659524f, -0.02618667f, -0.02392140f, 0.01139779f, 0.03644050f, 
    -0.01832169f, 0.04676669f, -0.06146356f, -0.06648833f, 0.03574573f, 0.06748963f, 0.07495470f, -0.10142880f, 
    0.12009621f, 0.03427516f, -0.06008922f, 0.09625960f, 0.05524275f, -0.01158793f, -0.02407845f, 0.01945211f, 
    0.07573957f, 0.03473553f, -0.02550984f, -0.01326804f, -0.05551973f, -0.02681752f, 0.03452063f, -0.06982807f, 
    -0.18044844f, -0.19035868f, -0.00462328f, -0.05449393f, -0.02923237f, 0.09330162f, 0.07215436f, -0.00797591f, 
    -0.03579308f, -0.05155091f, -0.06528428f, 0.00589526f, -0.00244536f, -0.02250258f, -0.03451207f, 0.04952632f, 
    0.01060530f, -0.03582919f, -0.18301463f, -0.04918222f, 0.04353220f, -0.02893128f, -0.05616645f, -0.11603569f, 
    -0.00960241f, 0.03701845f, -0.06469389f, 0.11546009f, 0.00199437f, 0.00465193f, -0.05546449f, -0.00424433f, 
    0.04030539f, -0.08985703f, -0.02376626f, -0.05362910f, 0.01335001f, 0.07372112f, -0.01107956f, 0.01279048f, 
    -0.04595321f, -0.02910261f, -0.11709616f, -0.15140219f, -0.11741640f, -0.00979683f, 0.07379945f, -0.03229250f, 
    -0.06437906f, 0.04503349f, -0.12317227f, 0.07882036f, -0.01167710f, 0.00368866f, 0.14540261f, -0.03437094f, 
    0.00167700f, -0.01134657f, 0.02011359f, -0.07297644f, 0.49951637f, -0.19987972f, 0.09383810f, -0.11387131f, 
    -0.20391579f, -0.11748471f, 0.07082420f, 0.06947379f, -0.11034739f, -0.03180263f, 0.00697224f, -0.08277599f, 
    0.04213860f, -0.02453477f, -0.07863922f, 0.03947284f, 0.08344118f, 0.02479745f, -0.01620933f, 0.02751999f, 
    0.10645915f, 0.04306195f, 0.17606485f, 0.14877418f, 0.18764631f, -0.08602784f, -0.10741697f, -0.04960536f, 
    0.04430379f, 0.02609323f, 0.04065854f, -0.03853251f, -0.04322167f, 0.00016185f, 0.02142274f, -0.04099247f, 
    -0.02054598f, -0.05260405f, -0.01018000f, -0.02388101f, 0.07138351f, -0.10920645f, -0.05705513f, 0.06349251f, 
    -0.12052106f, -0.06811819f, 0.05766018f, -0.09878144f, -0.00615925f, -0.05100969f, 0.00044349f, -0.05587594f, 
    0.03491977f, -0.02632448f, -0.00379896f, 0.01099264f, 0.00691905f, -0.01569762f, 0.03698360f, -0.05534067f, 
    0.22055489f, -0.01032003f, -0.13966019f, -0.05096114f, -0.14782140f, 0.10300601f, 0.02434934f, -0.15705226f, 
    -0.02570307f, -0.00005749f, -0.01836784f, -0.04974878f, 0.02481721f, -0.06099110f, 0.02157708f, -0.02788793f, 
    0.01540818f, -0.05170511f, 0.04497127f, -0.08522662f, -0.04197473f, 0.07074463f, -0.03946505f, 0.04780667f, 
    0.00122039f, -0.01684307f, -0.05709803f, 0.02149990f, 0.03322190f, -0.00357016f, 0.04811595f, -0.02209265f, 
    0.04741524f, -0.08586313f, 0.05612151f, -0.02304327f, -0.02593729f, -0.11672334f, 0.08201261f, -0.01404497f, 
    -0.05818173f, -0.32071465f, 0.04983361f, -0.18484887f, -0.19385462f, 0.01848551f, -0.03186546f, 0.03732181f, 
    0.02090464f, 0.01319654f, -0.04689659f, -0.00845073f, 0.00290127f, -0.02715787f, -0.03105406f, 0.01810009f, 
    -0.05581124f, 0.05250467f, 0.03166320f, 0.01176137f, -0.02705591f, -0.26472393f, -0.15330830f, -0.17080480f, 
    -0.11080679f, 0.03073194f, -0.07709745f, 0.14535911f, -0.17820790f, -0.01777821f, -0.06252369f, -0.07565464f, 
    -0.06911213f, 0.02002970f, -0.10437681f, 0.00134191f, -0.08310112f, 0.10895730f, 0.01632132f, 0.01211218f, 
    0.06848534f, 0.00816813f, 0.04336515f, 0.00341980f, 0.01694712f, 0.02295228f, -0.02440971f, 0.04055538f, 
    -0.04016031f, 0.03440771f, -0.05560673f, -0.01660036f, 0.01104934f, 0.03428484f, -0.04001455f, -0.06920683f, 
    -0.05150435f, 0.04405404f, -0.06090919f, -0.05648118f, -0.27703702f, 0.08695494f, -0.05179154f, -0.06865916f, 
    0.02161114f, 0.01964437f, -0.02373420f, 0.01422819f, 0.05356164f, -0.04005249f, -0.00480085f, 0.00677012f, 
    0.02478548f, 0.02390909f, 0.00133610f, -0.14061771f, 0.01793208f, 0.01524984f, -0.06871305f, -0.02763895f, 
    0.00282713f, -0.17622195f, -0.12851658f, -0.02560642f, -0.28005064f, 0.00429992f, -0.02525353f, 0.05054993f, 
    0.04232129f, 0.06631748f, -0.00009063f, 0.01919139f, -0.03199009f, 0.02717570f, -0.03773208f, -0.07067128f, 
    -0.03447942f, 0.06757800f, 0.04638534f, -0.00354175f, 0.14465350f, -0.08299102f, -0.09212621f, -0.03389532f, 
    0.07370251f, 0.05648667f, -0.03827180f, -0.07883926f, 0.02756166f, 0.04152287f, 0.08356566f, 0.01934923f, 
    0.04654501f, 0.01182329f, 0.00318043f, -0.00948359f, 0.02012275f, -0.01522251f, -0.01286387f, -0.03925019f, 
    0.02667274f, 0.09896899f, -0.08706771f, -0.07819868f, 0.07629286f, 0.03553154f, 0.10727200f, 0.09259570f, 
    -0.03332658f, -0.07810798f, -0.01883122f, -0.01143194f, 0.02463803f, -0.01978128f, 0.03652230f, -0.03227722f, 
    -0.00588656f, -0.07193646f, -0.10738622f, 0.01004133f, -0.04063305f, 0.07330009f, -0.10021394f, -0.11679164f, 
    -0.06580545f, 0.05246842f, -0.00947974f, -0.03002877f, -0.02126283f, 0.01045904f, -0.01518329f, -0.01038841f, 
    0.00077991f, -0.08964186f, -0.00043583f, -0.03827355f, 0.04713672f, 0.00803789f, -0.01065618f, -0.03390063f, 
    -0.05808074f, -0.08667248f, 0.01536197f, -0.07660571f, -0.02079968f, 0.02959950f, -0.12276088f, -0.09689355f, 
    -0.04820935f, -0.05392165f, 0.04093823f, -0.04327769f, 0.01545698f, 0.01745564f, -0.00630538f, -0.03789589f, 
    0.00277808f, -0.04366943f, -0.07451159f, 0.01323328f, 0.02415604f, 0.04892290f, -0.08080098f, 0.11317652f, 
    -0.00994717f, 0.00479811f, 0.07562072f, 0.02076708f, -0.02893520f, 0.01155215f, -0.03177749f, 0.00237374f, 
    -0.03886911f, -0.02442733f, 0.01050543f, -0.00203251f, 0.06892087f, -0.03503235f, -0.02468907f, -0.05366112f, 
    -0.19109248f, -0.33583641f, -0.32481924f, 0.06395255f, 0.16628978f, -0.02597688f, 0.01640685f, 0.04019694f, 
    0.03539559f, -0.00943783f, -0.01026479f, 0.01693428f, 0.02226701f, -0.04829968f, -0.01643462f, -0.03881624f, 
    0.02208459f, 0.05784010f, 0.00526464f, -0.05193960f, -0.00878936f, -0.29295924f, -0.13309993f, 0.05348316f, 
    0.13415530f, -0.00984254f, 0.03730176f, -0.01701952f, -0.00764281f, -0.00482638f, 0.02138185f, -0.02950642f, 
    -0.02003835f, 0.07025613f, -0.01468981f, 0.03495806f, 0.01514924f, 0.07286463f, 0.00123884f, 0.02351120f, 
    0.33537605f, -0.21700421f, -0.13210912f, 0.10083573f, 0.01171388f, -0.06765179f, -0.11779962f, -0.12434007f, 
    0.07525066f, -0.01695295f, -0.04556958f, -0.03662228f, 0.01588275f, 0.02820635f, -0.02607573f, -0.02803289f, 
    0.06102940f, 0.00352106f, 0.00938287f, -0.01923229f, -0.16154698f, 0.00394107f, 0.02981793f, -0.08855097f, 
    -0.10424756f, -0.13115728f, 0.01014298f, 0.05117298f, 0.04305616f, -0.01133139f, -0.01314637f, 0.01460350f, 
    0.02007495f, 0.03077054f, 0.01144995f, -0.03534139f, 0.01952876f, -0.11861545f, 0.04500710f, 0.03579672f, 
    0.13306646f, -0.09179986f, -0.02273972f, 0.08181296f, 0.01732984f, -0.09483204f, -0.03809509f, -0.02273614f, 
    0.05445566f, -0.02504741f, -0.06643639f, 0.00142051f, 0.02323383f, 0.07266808f, 0.05992954f, -0.02108330f, 
    0.03225522f, -0.06758855f, 0.01448580f, -0.06688996f, -0.41653204f, 0.13814230f, -0.21219805f, 0.11847435f, 
    0.23847282f, 0.00892657f, 0.06094651f, 0.04162156f, 0.01630171f, 0.00883171f, -0.02166739f, -0.00596727f, 
    0.03192136f, -0.09272937f, -0.00375561f, 0.01902428f, 0.02666199f, -0.00354006f, 0.04002014f, 0.05416475f, 
    -0.06379049f, 0.03667907f, -0.09145713f, 0.05020670f, -0.00701561f, -0.08674037f, -0.21489592f, 0.06103176f, 
    0.03679834f, 0.02234355f, -0.04056795f, 0.02803996f, 0.02012726f, -0.04697823f, -0.00305685f, -0.04455357f, 
    -0.03493978f, 0.04009080f, 0.07905395f, -0.01116710f, -0.27355960f, 0.19368011f, 0.03772129f, 0.04111298f, 
    0.00018692f, 0.04430886f, -0.06543481f, -0.03408825f, 0.00336515f, -0.06474247f, -0.00558105f, -0.06209785f, 
    -0.02442712f, -0.00193920f, 0.00161207f, -0.04944045f, -0.03302256f, -0.12779057f, 0.07599760f, -0.02245871f, 
    -0.30587482f, 0.22045290f, -0.02158430f, 0.12012652f, -0.00463763f, -0.04650194f, 0.03837434f, -0.02310069f, 
    0.03406702f, -0.00907574f, -0.00328099f, 0.02217028f, 0.01095599f, -0.06169470f, 0.02950348f, -0.03930357f, 
    0.00788742f, -0.03671279f, 0.02717013f, -0.01199675f, -0.05707898f, 0.01009268f, -0.05564030f, -0.05529950f, 
    -0.08591346f, -0.03054062f, -0.07247467f, 0.04746182f, -0.07515074f, 0.01611000f, -0.03105895f, 0.02720935f, 
    -0.05352943f, 0.01265974f, -0.01290190f, 0.03059142f, -0.04026473f, -0.05400872f, 0.06473313f, -0.01781731f, 
    0.13063508f, -0.06868717f, 0.00449828f, 0.13078427f, 0.11427151f, 0.04082956f, 0.11103114f, -0.02315364f, 
    -0.03201085f, 0.02544197f, 0.03224473f, -0.06841333f, -0.01921912f, -0.05718789f, -0.02121012f, 0.04133824f, 
    -0.00742074f, 0.01417881f, 0.05769641f, -0.05080456f, -0.09378064f, -0.37085885f, -0.34551319f, 0.06019113f, 
    0.18018924f, -0.06726255f, 0.02833220f, 0.07312923f, 0.12146338f, 0.00761892f, 0.02792924f, 0.02647992f, 
    -0.00845767f, -0.09746063f, 0.06491694f, -0.07763594f, -0.05797351f, -0.02715040f, 0.01153411f, -0.05277898f, 
    0.03633582f, -0.28074586f, -0.04846704f, 0.07455386f, 0.04059681f, -0.11612700f, 0.01446011f, -0.00575751f, 
    0.06076609f, 0.05717700f, -0.03833684f, 0.08532541f, -0.01919911f, 0.07749592f, 0.07833421f, 0.01497439f, 
    0.02396597f, -0.06229308f, 0.02344841f, -0.01603550f, 0.12904656f, 0.00730805f, 0.10690235f, 0.05697404f, 
    -0.08635090f, 0.03646998f, 0.04396997f, -0.04695833f, -0.02454136f, -0.05903276f, 0.00921818f, 0.01948535f, 
    -0.06539399f, 0.02462627f, 0.00916250f, -0.02212886f, -0.07238661f, -0.06104689f, -0.01841214f, 0.01293779f, 
    0.00901473f, -0.13500644f, 0.02759841f, -0.04046061f, -0.14521036f, -0.05140605f, -0.11713636f, 0.02147847f, 
    -0.02294799f, 0.02371682f, -0.05351261f, 0.02578134f, 0.02449148f, -0.04525470f, 0.03035332f, -0.03059785f, 
    -0.00689502f, -0.00418502f, 0.06844866f, 0.06030278f, -0.01502381f, 0.06981155f, 0.00024056f, 0.15208843f, 
    0.10287447f, 0.03576964f, 0.07718273f, 0.03770386f, -0.00260931f, -0.00199601f, 0.04387430f, 0.02416123f, 
    0.01897321f, -0.08163664f, -0.05793091f, 0.06643564f, -0.06777840f, 0.07567984f, 0.02320083f, -0.02252393f, 
    0.14653669f, 0.05981346f, -0.06935566f, -0.04634853f, -0.07391814f, -0.16017550f, -0.11047716f, 0.02070408f, 
    -0.00842655f, 0.00439302f, 0.02461245f, -0.00796489f, 0.04519149f, -0.04459183f, 0.03315555f, 0.01906602f, 
    -0.00538301f, 0.15021358f, 0.00498447f, -0.02299980f, 0.16263103f, 0.06037655f, 0.08357901f, 0.04355668f, 
    0.14263232f, 0.08188117f, 0.07521071f, 0.06041926f, -0.00477598f, -0.02054238f, 0.03052506f, -0.04172239f, 
    -0.04699123f, -0.06365496f, -0.01143533f, 0.11730073f, -0.05411481f, 0.15153907f, 0.05889931f, 0.07444640f, 
    0.10273283f, 0.04318254f, -0.04169913f, -0.03883402f, -0.01949278f, -0.06466933f, -0.10838911f, -0.04174963f, 
    -0.01093127f, 0.00833254f, -0.06041352f, -0.01090410f, 0.04277421f, 0.03073275f, 0.04812080f, -0.04306113f, 
    -0.00498444f, 0.02224330f, -0.02985277f, 0.03552755f, 0.10720397f, -0.08204374f, 0.02849204f, 0.00499491f, 
    -0.10214711f, -0.10111350f, -0.05318098f, 0.06749441f, -0.07535796f, -0.01136944f, -0.06196817f, -0.00752544f, 
    -0.05205300f, -0.00368183f, 0.04577771f, -0.02461275f, 0.02833823f, 0.04405678f, 0.00159002f, 0.06138238f, 
    0.09103187f, 0.09728848f, -0.12300605f, 0.16087250f, -0.07082101f, -0.01909076f, 0.02728862f, 0.03476702f, 
    -0.00368012f, -0.01026566f, -0.03132330f, 0.01547564f, 0.00889380f, 0.00251573f, 0.02354500f, -0.03918005f, 
    0.02884815f, -0.00716755f, -0.06158077f, -0.01027603f, -0.23093300f, 0.17423342f, 0.04061019f, -0.00026826f, 
    -0.05009034f, -0.01277922f, -0.01508319f, -0.02281989f, 0.05395503f, -0.00917323f, 0.00829719f, 0.04309363f, 
    -0.05234553f, 0.03797388f, -0.05110418f, 0.02231159f, -0.01450815f, -0.03119403f, -0.01985005f, 0.01628499f, 
    0.10199242f, -0.00784734f, 0.10724325f, -0.01114498f, -0.03430177f, -0.07345258f, 0.00212847f, -0.02259731f, 
    -0.05259974f, -0.04434111f, -0.07164427f, -0.07503782f, 0.02185578f, -0.01938561f, -0.02306668f, -0.03322455f, 
    0.03319398f, 0.01496808f, -0.03332025f, -0.01313395f, -0.03362254f, 0.08421622f, 0.07633093f, 0.06578217f, 
    -0.00145065f, -0.06927303f, -0.00587910f, 0.02535561f, 0.00826241f, -0.00199677f, -0.03490432f, -0.02324130f, 
    0.02567462f, -0.01575486f, -0.01317510f, -0.04809903f, 0.02090636f, 0.02797445f, 0.08882282f, -0.05260921f, 
    -0.04764052f, 0.05145920f, -0.01647162f, -0.10529634f, -0.07014397f, -0.04374308f, -0.08175687f, 0.01676760f, 
    -0.03135001f, -0.03493999f, 0.00919557f, -0.02266683f, -0.01268219f, 0.02462280f, -0.02964432f, -0.00817813f, 
    -0.05334752f, -0.05875793f, 0.01659245f, 0.02447714f, 0.03469875f, -0.13304102f, -0.21140517f, -0.02573926f, 
    0.04824013f, -0.09459797f, 0.12924506f, -0.00664960f, 0.04588315f, -0.09469825f, -0.03776179f, 0.09740866f, 
    -0.01649513f, -0.06457549f, 0.01338857f, 0.03423303f, 0.03266179f, -0.02052698f, 0.01488610f, -0.01268946f, 
    -0.14539805f, -0.17094590f, -0.24887374f, -0.04824162f, -0.03635939f, -0.03844489f, 0.04442929f, 0.03038601f, 
    0.00303379f, -0.03701965f, -0.02994544f, -0.02550947f, 0.02064161f, 0.07571580f, -0.10275493f, 0.03649946f, 
    -0.06859626f, 0.02530850f, 0.01520663f, 0.02832547f, -0.17363790f, -0.29127029f, -0.00648671f, -0.09340354f, 
    -0.22663893f, -0.08313743f, -0.08575314f, 0.01709894f, -0.04258585f, -0.07799578f, -0.08610860f, -0.01640994f, 
    0.02036852f, -0.00789997f, 0.10744550f, 0.07118324f, -0.03094769f, 0.01087129f, -0.04884142f, 0.01301795f, 
    -0.46361893f, -0.24953115f, 0.03964565f, -0.10752875f, -0.14697687f, -0.09388691f, -0.05756332f, -0.05647182f, 
    0.03978098f, 0.00842038f, -0.04899031f, -0.03638890f, 0.05676252f, -0.04687899f, -0.00182284f, 0.06613426f, 
    0.00325043f, -0.07889125f, 0.08913075f, 0.07507992f, 0.14460202f, -0.10700106f, 0.09399010f, -0.01193145f, 
    -0.06421416f, -0.06346770f, -0.08623190f, -0.02929239f, -0.03173458f, -0.04209894f, -0.04356806f, -0.00208541f, 
    -0.04845636f, -0.02955005f, 0.07246508f, 0.01215634f, 0.07603528f, 0.02386958f, 0.03990947f, 0.01367854f, 
    -0.26164463f, 0.01160922f, 0.00365975f, -0.09450550f, -0.06932586f, -0.02930422f, -0.11379668f, -0.02374031f, 
    -0.00277667f, -0.06044298f, 0.02149399f, -0.04832980f, 0.01331725f, 0.01021021f, -0.05615944f, -0.01629912f, 
    -0.01232014f, -0.02737547f, 0.04722168f, 0.03871607f, -0.00327959f, -0.04019000f, -0.04166787f, 0.14866158f, 
    0.02450169f, -0.08295293f, 0.01447643f, 0.06363615f, -0.00620699f, 0.06031316f, -0.07479820f, -0.02189870f, 
    -0.03263720f, 0.01600101f, 0.04716750f, -0.02447472f, 0.06903425f, 0.03270714f, -0.00833040f, -0.02379654f, 
    -0.06902577f, -0.20869602f, -0.11461030f, -0.08075413f, -0.05511864f, -0.09293923f, -0.01824176f, -0.04166186f, 
    -0.00493419f, 0.04630959f, -0.08362241f, -0.02342285f, 0.08315168f, 0.03151605f, -0.00111998f, -0.01129803f, 
    -0.02035234f, -0.03981581f, -0.02459631f, 0.06599626f, 0.03382253f, 0.08970398f, 0.06517426f, 0.16504571f, 
    -0.01837437f, -0.04768807f, 0.08312441f, -0.03405204f, 0.06816158f, -0.02140186f, 0.01962969f, 0.03889278f, 
    -0.04334309f, -0.04533036f, 0.01772283f, 0.02166729f, 0.04984669f, -0.00679627f, -0.02008022f, 0.01459164f, 
    0.07286549f, -0.16571799f, 0.06667512f, 0.03761718f, 0.03426150f, 0.09025098f, -0.00812880f, 0.09060699f, 
    0.06467206f, -0.10434446f, 0.04201229f, 0.13061593f, -0.08898626f, -0.05474998f, -0.05700728f, 0.04367090f, 
    -0.03682214f, -0.05328711f, -0.04101354f, -0.00912636f, -0.13281074f, -0.21887293f, -0.10851016f, -0.04486558f, 
    -0.15525083f, -0.09921222f, -0.02103939f, -0.05721572f, 0.02819089f, -0.14565611f, 0.00376338f, 0.01116663f, 
    0.10340750f, -0.03203702f, 0.03689990f, 0.01180634f, 0.04578178f, 0.00255950f, -0.07099815f, -0.02167224f, 
    0.33443254f, 0.22420789f, 0.02821785f, 0.04822856f, 0.02302078f, 0.07390893f, 0.02861998f, 0.05128547f, 
    0.09528115f, -0.00450434f, 0.00514297f, 0.04279510f, -0.04572928f, -0.00414444f, -0.03374580f, 0.03178979f, 
    -0.03133247f, -0.02620623f, 0.02544401f, 0.04811764f, 0.32091957f, 0.26260316f, -0.03519360f, -0.03193306f, 
    0.02235734f, 0.03193472f, 0.00801490f, 0.04442108f, 0.07399974f, -0.00539014f, -0.00287230f, -0.03624541f, 
    -0.05745712f, -0.00485980f, -0.00196691f, -0.04652032f, -0.00299264f, 0.02547769f, 0.03584308f, 0.07383529f, 
    0.09700174f, -0.36923778f, -0.04707455f, 0.04289107f, 0.07952007f, 0.04461612f, -0.00472157f, 0.04703303f, 
    -0.06048141f, -0.03829082f, 0.06637550f, -0.03242295f, 0.02183511f, 0.08960443f, 0.05875076f, 0.08088884f, 
    0.12678893f, -0.00894241f, -0.08688116f, -0.05221249f, -0.10831232f, -0.14120549f, -0.18087482f, -0.06906655f, 
    -0.12520631f, -0.03710118f, -0.06345713f, 0.02968629f, -0.01350650f, -0.03751722f, -0.12874512f, -0.02333753f, 
    0.02157139f, -0.00997655f, -0.02119218f, 0.02523421f, 0.01478866f, 0.05201478f, -0.04691950f, 0.05453043f, 
    -0.29193240f, 0.24005760f, 0.10534719f, 0.06733768f, -0.01682875f, -0.00335972f, -0.05375521f, 0.00741464f, 
    -0.02606104f, -0.07370196f, -0.02757638f, -0.05121695f, -0.08032481f, 0.00994979f, -0.04850796f, -0.04675730f, 
    -0.00489821f, -0.06477396f, 0.02320384f, 0.01543050f, 0.06782514f, -0.02635779f, -0.02974875f, 0.01401969f, 
    -0.04364279f, 0.03794402f, -0.00883576f, -0.05217488f, 0.08190353f, -0.05516696f, 0.00988580f, -0.03991461f, 
    0.02726847f, 0.05079378f, -0.05523876f, -0.03239632f, 0.04476661f, -0.09205978f, 0.01610047f, -0.00804267f, 
    -0.03980176f, -0.02038495f, 0.02678391f, 0.04716186f, -0.03155897f, -0.06200593f, -0.12209649f, 0.08114025f, 
    -0.03829413f, 0.00338968f, -0.06867325f, 0.02812949f, -0.07104367f, 0.03375152f, 0.01949421f, 0.04523643f, 
    -0.01565738f, 0.04701833f, 0.09326676f, -0.01581540f, -0.00432144f, -0.13412572f, -0.26470506f, 0.06942371f, 
    0.08085898f, -0.04972916f, 0.04807843f, 0.01661093f, -0.03086671f, -0.01058541f, 0.02662523f, -0.00130672f, 
    0.00268486f, 0.03867121f, 0.05275331f, -0.01814676f, 0.01240378f, -0.02114336f, -0.03273582f, 0.01461959f, 
    0.08601352f, 0.04037108f, 0.04302016f, 0.07277844f, -0.06490586f, 0.00867239f, 0.08128903f, -0.00445855f, 
    -0.04359183f, -0.03314343f, -0.00868987f, 0.00927288f, 0.02594207f, 0.06930763f, -0.04176588f, 0.03724246f, 
    -0.03004477f, 0.04461452f, -0.01647270f, 0.04597358f, -0.24738991f, -0.51997125f, -0.17294528f, -0.06292736f, 
    0.12101664f, -0.04211646f, -0.02967685f, -0.01556640f, 0.06620821f, -0.08409875f, 0.00808772f, 0.05215042f, 
    0.03379337f, -0.03552812f, 0.05975929f, -0.08013880f, -0.09534071f, -0.10495239f, 0.02871461f, -0.09892601f, 
    0.02300778f, -0.09459402f, -0.11492567f, 0.09004948f, 0.11198244f, 0.08751843f, 0.11260049f, -0.03198152f, 
    -0.04675489f, 0.00781686f, 0.01954290f, 0.04798658f, -0.11310919f, -0.02894402f, -0.05774429f, -0.01059655f, 
    0.14222246f, 0.12606382f, 0.01463903f, -0.04190484f, 0.01940210f, -0.27474561f, -0.17619057f, -0.05204776f, 
    0.08281583f, -0.01336596f, 0.06087697f, -0.02647176f, 0.01372913f, 0.04474931f, 0.09000620f, 0.02974102f, 
    -0.00965804f, 0.03079836f, -0.02191350f, -0.04290274f, 0.00386660f, -0.02915519f, 0.00428778f, 0.00116831f, 
    -0.12745292f, 0.31175408f, -0.03618510f, -0.09300253f, 0.05181903f, 0.04607181f, 0.06961703f, 0.03128112f, 
    0.03501415f, 0.04419653f, -0.00923485f, -0.00704118f, -0.00032623f, -0.02814173f, -0.06384321f, 0.05143331f, 
    -0.01312817f, 0.06937148f, 0.14756578f, 0.02775047f, -0.02460252f, 0.06580971f, 0.02759740f, 0.08287561f, 
    -0.05689367f, -0.07964593f, -0.09458117f, -0.09885404f, -0.06490037f, -0.00437404f, 0.03789901f, -0.00771261f, 
    0.00851244f, -0.01446943f, 0.00953158f, -0.06265789f, 0.05764785f, 0.00605011f, -0.10153894f, 0.00963881f, 
    0.04200342f, -0.09969756f, -0.11852509f, -0.07370473f, -0.15416221f, -0.06205805f, -0.11736725f, 0.05051183f, 
    -0.07596313f, -0.01517012f, -0.05433348f, -0.00719626f, 0.05273558f, -0.03214997f, 0.05786598f, -0.01137271f, 
    -0.01988146f, 0.05407595f, 0.02914062f, 0.03759979f, -0.01880614f, 0.06546918f, 0.04318533f, 0.11425570f, 
    -0.01852158f, 0.00095338f, 0.03907685f, 0.03602272f, -0.05759624f, 0.00852160f, -0.01289754f, 0.05968770f, 
    -0.03382685f, -0.02101676f, -0.05027909f, -0.02572511f, -0.03566556f, 0.02777783f, 0.07027654f, -0.08579714f, 
    0.05451609f, 0.29273814f, 0.12519315f, 0.02064212f, -0.03980371f, 0.13074616f, 0.05129816f, 0.00774094f, 
    0.07897039f, -0.06083819f, -0.05317334f, 0.03144100f, -0.10773238f, 0.00518860f, -0.12785409f, -0.06179953f, 
    -0.01097818f, -0.08066127f, -0.02112435f, 0.02705003f, 0.18309087f, -0.17850685f, 0.08901325f, -0.07729223f, 
    -0.03329167f, 0.06477626f, -0.01904671f, -0.01471695f, -0.04630115f, 0.00918085f, -0.09523190f, -0.00327625f, 
    0.01128920f, 0.00830386f, 0.04025549f, -0.02016648f, 0.06583922f, 0.00972515f, -0.04203833f, -0.00108602f, 
    0.35969889f, 0.14517117f, -0.04611829f, 0.12221901f, 0.04259822f, 0.01969183f, 0.04522081f, -0.02241741f, 
    0.07474180f, 0.04539280f, -0.09601895f, 0.00348666f, -0.07552992f, 0.01734665f, 0.02825804f, 0.07636468f, 
    -0.00042743f, 0.04832754f, -0.04812541f, 0.02744954f, 0.44140458f, 0.30734000f, -0.02456613f, -0.00688557f, 
    0.05217043f, 0.00319369f, 0.03466281f, 0.05328656f, 0.03518230f, 0.04549500f, -0.00669534f, -0.13144311f, 
    -0.08101071f, 0.00380842f, 0.04066228f, -0.06078727f, 0.01117745f, 0.08209780f, 0.10238448f, 0.01943930f, 
    0.01545952f, -0.01284095f, -0.07307307f, 0.00315078f, -0.08536111f, -0.03267810f, -0.04300676f, 0.00914180f, 
    0.04008216f, 0.08835425f, -0.00980736f, -0.07286877f, -0.03315760f, 0.06176877f, -0.08003061f, -0.04506093f, 
    -0.02829004f, -0.01119796f, 0.01216730f, 0.09034339f, -0.03766004f, -0.39135844f, -0.14615552f, 0.05125184f, 
    0.14116061f, 0.00474185f, 0.03548925f, 0.04597536f, -0.03974858f, -0.09222123f, -0.02128636f, 0.00311893f, 
    0.00591443f, 0.08822590f, 0.02842725f, -0.02835793f, -0.01873367f, 0.07296440f, -0.04212517f, 0.02352190f, 
    0.10952293f, 0.00615794f, 0.10594869f, 0.01307819f, 0.05431991f, -0.00435287f, 0.04166628f, 0.00272814f, 
    -0.01259795f, 0.06356562f, 0.03257195f, -0.01377146f, -0.08033801f, -0.02697484f, -0.03144222f, 0.03405443f, 
    0.00239564f, 0.00330689f, 0.02688761f, 0.08122170f, -0.13811922f, 0.14972101f, -0.00151849f, 0.01476419f, 
    -0.04876193f, -0.04623454f, -0.06987838f, 0.02798388f, 0.01771259f, 0.02309371f, -0.02637162f, -0.01558144f, 
    -0.08099676f, 0.02439190f, -0.01921719f, -0.01679034f, -0.05660982f, 0.04033557f, 0.06970623f, -0.04719573f, 
    -0.43600258f, -0.00981053f, -0.11047511f, -0.07908154f, 0.12662703f, -0.10329834f, 0.03229544f, 0.01765494f, 
    -0.00749858f, -0.03302518f, -0.05098601f, -0.00758725f, 0.00531140f, 0.01682680f, 0.01152102f, -0.00118369f, 
    -0.09679592f, -0.12305091f, -0.00868845f, 0.02646965f, 0.07378341f, 0.08734221f, 0.03566434f, 0.05889928f, 
    -0.00400153f, -0.02570869f, 0.05675661f, 0.01394105f, -0.00157588f, 0.00238222f, -0.02610577f, 0.00400663f, 
    -0.04526747f, 0.06974497f, -0.02274080f, 0.03885193f, -0.00086680f, 0.07033697f, 0.01766180f, 0.03718742f, 
    0.02353422f, 0.24368401f, -0.19840442f, -0.10950427f, 0.05690250f, 0.02764334f, -0.06000786f, 0.01269292f, 
    0.08641730f, -0.10772189f, -0.03370193f, -0.07006772f, -0.05568141f, 0.04672568f, -0.02474403f, -0.01429731f, 
    0.03940207f, -0.09711365f, 0.00728846f, -0.02832766f, -0.17660499f, -0.02519291f, -0.17758408f, 0.12867092f, 
    -0.03238521f, 0.02677155f, -0.06836475f, 0.02738174f, -0.05462278f, -0.04768993f, 0.03309955f, -0.02128357f, 
    -0.00260713f, -0.00166192f, -0.00628809f, -0.01534811f, 0.00795969f, 0.00083717f, -0.03037399f, 0.06294207f, 
    -0.08390871f, -0.05800272f, 0.12255275f, 0.08619022f, -0.00024208f, 0.01118235f, 0.02982403f, -0.05821222f, 
    -0.01285096f, 0.05633594f, 0.06645039f, 0.00398374f, 0.01260811f, -0.02315988f, -0.01326574f, 0.04586348f, 
    -0.01808039f, -0.03759522f, 0.09569362f, 0.02861750f, -0.00793876f, -0.18538676f, 0.07323694f, 0.13588324f, 
    0.06351515f, -0.13406494f, 0.01201015f, 0.08528791f, -0.03945936f, 0.01266387f, 0.04331705f, 0.06758219f, 
    0.11377507f, -0.02491007f, -0.06471008f, -0.04798388f, 0.03568397f, 0.03254440f, 0.04162151f, 0.04692219f, 
    -0.15993664f, 0.18345569f, -0.07549321f, -0.10934764f, 0.04242130f, 0.00088312f, -0.01673235f, 0.01851217f, 
    0.07891575f, 0.01271057f, -0.03062128f, 0.01297863f, -0.03304591f, 0.05584610f, 0.01948546f, -0.06169236f, 
    0.09315254f, -0.03302339f, -0.01628394f, -0.01742991f, -0.03021428f, -0.15174553f, -0.03308250f, 0.03245201f, 
    -0.02347063f, -0.02916532f, 0.04557168f, 0.09022558f, -0.05370108f, 0.00663492f, 0.01802698f, -0.03299008f, 
    -0.01944383f, -0.01560765f, 0.02868277f, 0.05845253f, -0.01194964f, -0.03263465f, 0.03659925f, -0.01168940f, 
    0.02213351f, 0.04900444f, -0.00457651f, -0.06479375f, -0.13418110f, -0.03283794f, 0.04088204f, 0.03675340f, 
    -0.07728363f, -0.08056886f, -0.03317906f, 0.02983543f, -0.06258409f, 0.01773830f, -0.04914296f, -0.02051933f, 
    -0.01478401f, -0.04386644f, -0.08182125f, 0.03414280f, -0.44320872f, -0.15589629f, 0.18702796f, 0.16949740f, 
    0.01609287f, -0.08149124f, -0.06951462f, 0.06652077f, -0.02652299f, -0.05582449f, 0.04471005f, -0.06808282f, 
    0.01216967f, -0.10248917f, -0.02596158f, -0.04227822f, -0.02649972f, -0.11214504f, 0.04538324f, -0.01674263f, 
    -0.46779048f, -0.07888021f, 0.00461771f, 0.03522769f, 0.11248209f, -0.00212193f, 0.05665958f, -0.02858795f, 
    0.11175997f, 0.03001672f, -0.03825725f, -0.07396868f, 0.07644267f, 0.05049327f, 0.01307293f, -0.02924899f, 
    0.05036835f, 0.07519617f, 0.11250971f, -0.00357681f, -0.15064152f, 0.03975854f, -0.08914552f, -0.06939427f, 
    0.01392689f, -0.02183371f, -0.04632057f, 0.08468179f, 0.03935255f, 0.01462873f, -0.01971940f, 0.05149005f, 
    -0.07651523f, -0.01066305f, -0.02385306f, 0.00890889f, 0.05781548f, -0.12912014f, 0.03167645f, -0.04070130f, 
    -0.46595442f, 0.00375280f, 0.09352786f, -0.17511226f, 0.03043368f, 0.00644656f, 0.01908966f, -0.02942612f, 
    0.02345590f, -0.10135370f, -0.08149382f, 0.01860682f, -0.08946463f, -0.08218277f, 0.04890886f, 0.01483237f, 
    -0.02225031f, 0.01345263f, -0.01297299f, -0.04663751f, -0.13115780f, -0.04645292f, -0.03525019f, 0.02567366f, 
    0.09650028f, 0.00033471f, 0.00888229f, 0.06733590f, -0.07401816f, 0.07230395f, 0.01739794f, 0.01042242f, 
    0.06762622f, -0.02052152f, -0.02939902f, 0.02531048f, -0.03139000f, 0.03484123f, 0.05212554f, -0.08613303f, 
    -0.07889017f, -0.26328278f, -0.10062613f, 0.08879453f, -0.04243064f, -0.12836351f, -0.04496580f, 0.00467647f, 
    -0.17044331f, -0.00673886f, -0.00743095f, 0.07911322f, -0.02446621f, 0.01651537f, 0.10604291f, 0.02115625f, 
    -0.07191543f, 0.09823689f, -0.02809861f, 0.09400269f, -0.27355865f, -0.38591185f, 0.00576692f, 0.12556152f, 
    0.00406199f, -0.22190650f, -0.05876012f, 0.02815636f, -0.07957649f, 0.00287716f, 0.02299737f, -0.02374244f, 
    -0.07172433f, -0.08719623f, 0.01621452f, -0.03272561f, 0.01954510f, 0.12377793f, -0.04624594f, 0.03817374f, 
    0.18298282f, -0.29665220f, 0.01541581f, 0.03935289f, -0.17962286f, -0.10370365f, 0.01725451f, 0.22188590f, 
    -0.04950450f, 0.02687325f, -0.01303013f, -0.08076580f, 0.08360715f, -0.03593522f, 0.02126352f, -0.01024642f, 
    -0.08844642f, 0.05058033f, -0.01470086f, -0.00013638f, -0.42750338f, 0.09846434f, 0.05129221f, -0.07356191f, 
    -0.00184855f, 0.09154887f, 0.00116021f, -0.09085490f, -0.02938120f, 0.05042027f, -0.00006963f, 0.05407832f, 
    0.12608932f, -0.04381596f, -0.05249751f, 0.00348505f, -0.09100555f, -0.18083169f, 0.08061463f, -0.04946070f, 
    -0.62954926f, 0.04538600f, 0.06672332f, 0.08175451f, 0.13887282f, 0.11753876f, -0.00125141f, -0.02896841f, 
    0.03229287f, 0.10927357f, -0.07537474f, -0.01562285f, 0.02376760f, 0.10196880f, 0.07948929f, 0.03054607f, 
    0.11201832f, 0.01713389f, 0.07085875f, -0.09418207f, -0.12077100f, -0.28800181f, 0.08150841f, 0.12141281f, 
    -0.01382567f, -0.06075532f, 0.01557000f, -0.05935917f, -0.11378642f, -0.00003033f, 0.02498890f, 0.00952116f, 
    -0.00385740f, 0.00653711f, -0.00513731f, -0.09891922f, -0.05436191f, 0.02952316f, -0.02610797f, 0.04747206f, 
    -0.11422505f, 0.12510674f, 0.00024455f, 0.17421319f, 0.03595184f, 0.02339233f, 0.01874522f, 0.08095715f, 
    0.17969620f, 0.04053431f, 0.02929780f, 0.00756713f, 0.00286428f, 0.01576321f, -0.00096611f, 0.07947332f, 
    -0.05600757f, 0.03216390f, 0.10949442f, 0.09378585f, -0.10232011f, -0.25045541f, 0.08511657f, 0.15701000f, 
    -0.12294952f, -0.09672049f, 0.03818970f, -0.05986702f, -0.06734657f, -0.09744748f, 0.07022629f, 0.06653922f, 
    -0.00888011f, -0.00549034f, 0.04592782f, -0.08984745f, 0.11271212f, -0.02808981f, 0.07984784f, 0.02114766f, 
    -0.08372900f, 0.11131526f, -0.02330477f, 0.00840940f, 0.05214699f, 0.08052190f, 0.02681188f, -0.00613223f, 
    0.02726775f, 0.05445414f, 0.06113140f, 0.04193440f, -0.00532272f, -0.05979441f, -0.04120649f, 0.01309880f, 
    -0.10471082f, -0.00051404f, 0.03128227f, 0.03886672f, 0.16208388f, 0.05327662f, -0.19221607f, 0.03872804f, 
    0.06440042f, 0.06276868f, 0.02784563f, -0.00233801f, -0.01034534f, 0.02605221f, -0.03464348f, -0.00535629f, 
    0.00507084f, 0.00096793f, -0.03292993f, 0.00883249f, -0.07855375f, 0.07032785f, 0.01322318f, -0.08888236f, 
    0.01472555f, -0.16957378f, -0.09979068f, 0.09281737f, 0.07852802f, 0.00601362f, -0.09482057f, 0.01855339f, 
    0.00050741f, -0.04298546f, 0.07223385f, 0.06503849f, -0.00470149f, -0.06450146f, 0.07716724f, 0.00192603f, 
    -0.03084993f, -0.00890342f, 0.01753122f, 0.08268824f, -0.00319714f, -0.07306983f, 0.17305349f, 0.06199382f, 
    -0.00082122f, 0.02660133f, 0.02233354f, 0.09909831f, 0.01691524f, -0.06075279f, 0.02693161f, 0.00905521f, 
    -0.11835647f, 0.00256365f, -0.00048690f, -0.03623969f, -0.01198975f, -0.06952403f, -0.02762773f, -0.04732737f, 
    0.01573236f, 0.03038303f, -0.04384913f, -0.03318079f, 0.15306634f, 0.01860897f, 0.01009830f, -0.00258395f, 
    0.01844780f, -0.03322295f, -0.00844691f, 0.07149348f, -0.01562038f, -0.01311131f, -0.05892138f, -0.09356858f, 
    -0.02169292f, -0.03671899f, 0.03578840f, -0.01781015f, 0.05699733f, 0.02376296f, 0.00176585f, 0.02887206f, 
    0.08461633f, 0.05390695f, 0.03434822f, 0.01599525f, 0.03133642f, 0.02441062f, 0.07768010f, 0.04905474f, 
    0.00201651f, -0.04450029f, 0.04510774f, -0.00611738f, -0.04376533f, 0.03682152f, 0.02654683f, 0.06266797f, 
    -0.05061692f, 0.05263169f, -0.12390400f, 0.09155965f, 0.07585883f, 0.04285735f, 0.07079489f, 0.03439659f, 
    -0.05864654f, 0.02672325f, -0.01332423f, 0.05385763f, 0.07894995f, 0.02956237f, -0.02458753f, 0.05833980f, 
    -0.00601562f, -0.06743384f, 0.04778482f, -0.02697949f, -0.15165064f, 0.09225905f, 0.06850721f, -0.20838670f, 
    -0.00438692f, 0.05956600f, -0.04862017f, -0.04096607f, -0.06915853f, -0.02036512f, -0.04567563f, -0.08848396f, 
    -0.03513880f, -0.01912250f, -0.05009092f, -0.00929167f, -0.00872576f, -0.11296620f, -0.07148154f, -0.07608400f, 
    -0.08237237f, 0.16850266f, 0.13579468f, -0.07017503f, -0.14452381f, 0.09248937f, 0.06060259f, -0.01620457f, 
    0.00249200f, 0.00388787f, 0.10754441f, 0.03726514f, 0.04082435f, -0.03789414f, -0.03497566f, 0.00852057f, 
    0.02859228f, -0.02866338f, -0.03810899f, 0.05390183f, -0.17731565f, -0.01932611f, 0.01175162f, 0.02114168f, 
    0.04179876f, 0.00368473f, 0.01116400f, 0.03124472f, 0.06128696f, 0.04648403f, 0.03388561f, 0.00443102f, 
    0.11396041f, -0.00053237f, 0.00642401f, 0.10300984f, 0.06870636f, -0.03551145f, -0.06745030f, -0.03558314f, 
    0.14469096f, -0.03096294f, -0.02833370f, 0.08761061f, 0.03130877f, -0.03563713f, -0.03063453f, -0.02345185f, 
    0.00529797f, 0.01650068f, -0.01877423f, -0.02590036f, 0.10066985f, 0.04240595f, -0.09269771f, -0.07269481f, 
    -0.01619805f, -0.01391890f, 0.03934851f, 0.03831756f, -0.32139257f, 0.10211591f, -0.05948332f, 0.03106294f, 
    0.13367972f, 0.06761113f, 0.05392653f, -0.00350068f, -0.00958414f, 0.11484374f, -0.00711826f, 0.02075168f, 
    0.05113511f, -0.01221346f, -0.09079066f, -0.00254043f, 0.06090398f, 0.06649932f, 0.01406477f, -0.07396959f, 
    0.40861946f, 0.19294827f, -0.19849741f, -0.04380741f, 0.02779657f, 0.02152257f, 0.01588394f, 0.09437084f, 
    0.06554626f, 0.00064742f, -0.06576039f, 0.03216624f, 0.01324308f, -0.00314592f, 0.01130125f, -0.01062020f, 
    0.01533487f, -0.05657433f, -0.02644253f, 0.03249344f, -0.02225711f, -0.24253188f, -0.20080240f, 0.18683492f, 
    0.11825096f, 0.12296828f, -0.00537447f, -0.01731890f, 0.01098321f, -0.00718977f, 0.03381145f, -0.01375624f, 
    0.14514594f, -0.02190136f, 0.06188693f, 0.00182107f, 0.01581958f, 0.03593459f, 0.01844123f, 0.08481830f, 
    0.13564652f, 0.06301090f, 0.10044786f, 0.02916643f, -0.07274402f, 0.02073461f, -0.02950036f, -0.02937795f, 
    0.00124583f, 0.05806977f, -0.01211227f, -0.00230756f, -0.02814386f, -0.00227359f, 0.02737066f, 0.02527085f, 
    0.02544191f, -0.06022464f, -0.01098791f, -0.08926743f, -0.16537799f, 0.17642821f, -0.25427142f, 0.12183246f, 
    -0.30107647f, -0.11985292f, -0.02952328f, 0.05344698f, -0.10882136f, 0.04004562f, 0.03409097f, -0.04506167f, 
    -0.03759112f, 0.02088881f, -0.01285880f, 0.00798676f, -0.03524155f, 0.02875885f, -0.10396963f, -0.00433927f, 
    0.09861798f, 0.23169436f, -0.04871910f, -0.14156291f, 0.02272279f, -0.02891827f, -0.05603565f, -0.02208441f, 
    0.08822609f, -0.00629193f, -0.06981974f, 0.02767499f, -0.07943525f, -0.00082830f, -0.02297834f, -0.05728213f, 
    0.01692507f, 0.01213025f, 0.03134065f, 0.00788485f, 0.03581590f, 0.07233594f, -0.13409808f, -0.06623679f, 
    0.03562543f, 0.04145130f, -0.00470308f, -0.07279336f, 0.02100534f, 0.02754663f, -0.02368362f, -0.06277681f, 
    0.07106312f, 0.04941753f, 0.03971978f, -0.06716331f, 0.03336262f, 0.00142099f, -0.02386608f, -0.05000447f, 
    -0.03108781f, -0.11365628f, 0.20356071f, -0.10213702f, -0.11946385f, -0.06874782f, 0.13680929f, -0.04007446f, 
    0.04775192f, -0.09048922f, -0.00999290f, -0.06389505f, -0.06706347f, 0.06927156f, 0.03209914f, -0.09906965f, 
    0.03644587f, 0.00452590f, 0.05625708f, 0.08339059f, 0.15627597f, -0.00044803f, 0.14488973f, -0.11121265f, 
    -0.13370799f, 0.02681521f, 0.07133923f, 0.00693909f, 0.00165885f, 0.00041805f, -0.00687762f, 0.02172063f, 
    0.00643574f, 0.04267448f, -0.00673299f, -0.03042038f, 0.01455502f, 0.11056375f, 0.00872122f, 0.07413324f, 
    0.20646143f, -0.00619878f, 0.03819521f, -0.08614454f, 0.00239257f, -0.05457406f, 0.01156512f, -0.17714858f, 
    -0.05048420f, 0.02686124f, -0.05614636f, -0.02673290f, 0.02529079f, 0.04837206f, 0.01768022f, -0.27325755f, 
    -0.03727103f, -0.17547868f, 0.05430476f, -0.04850594f, -0.30369207f, -0.03342982f, -0.12935397f, 0.14305109f, 
    0.10757948f, 0.10227973f, -0.06070590f, -0.01077270f, -0.04896569f, 0.01414053f, -0.00234154f, 0.01415652f, 
    0.01637444f, 0.10253005f, 0.08251414f, -0.08139753f, 0.03933783f, 0.05967228f, 0.08663674f, -0.02485834f, 
    -0.24052326f, 0.12475850f, -0.01479472f, -0.02210163f, -0.06114365f, -0.06495016f, -0.09504529f, 0.01261789f, 
    0.08401817f, 0.03184276f, -0.02157394f, -0.05043913f, 0.00827031f, 0.04432290f, -0.00069404f, -0.01912057f, 
    -0.00233145f, -0.04781247f, -0.02014810f, -0.09185509f, -0.03367791f, 0.40318888f, -0.25858590f, -0.12836441f, 
    -0.05908972f, 0.03612465f, 0.00841012f, 0.14239006f, 0.00657484f, 0.02783816f, -0.01202946f, 0.08653487f, 
    -0.10429804f, -0.07917614f, 0.01933397f, 0.01238639f, 0.13944921f, -0.06970622f, -0.05022677f, -0.00809931f, 
    -0.18591864f, -0.00693026f, 0.04277123f, 0.07789812f, 0.12975600f, 0.04223711f, -0.06387194f, -0.03970767f, 
    0.07991804f, 0.10922880f, -0.01332785f, -0.10325411f, 0.02143212f, 0.01866134f, 0.02680070f, -0.04365098f, 
    0.03954557f, 0.03968484f, 0.05733312f, -0.10146195f, -0.02506508f, -0.11362520f, -0.03756966f, 0.02947658f, 
    -0.06383799f, -0.03032089f, -0.04214747f, -0.01401373f, -0.01048262f, -0.01849711f, 0.03136580f, -0.01803925f, 
    0.04883545f, -0.03536063f, -0.03446399f, 0.07447731f, -0.02132655f, -0.04733685f, -0.04277150f, -0.00078419f, 
    -0.01568532f, 0.27016965f, 0.02167218f, 0.17418775f, -0.19011547f, -0.00767693f, -0.02657903f, 0.02839213f, 
    0.05734350f, -0.18457526f, -0.03351006f, -0.01657373f, -0.05507797f, 0.03007651f, 0.03927124f, 0.01291981f, 
    -0.08916419f, -0.03302157f, 0.02012531f, 0.05863588f, -0.04194924f, -0.29082763f, 0.12697163f, -0.12905990f, 
    -0.04611608f, -0.08999433f, 0.01297522f, -0.05669697f, -0.00003873f, 0.07982440f, 0.05292390f, -0.02573010f, 
    -0.08768573f, -0.02747104f, -0.03626898f, 0.06834294f, -0.04649094f, -0.07548093f, -0.00991324f, 0.03139334f, 
    -0.06141904f, 0.04938336f, 0.18542255f, 0.17484215f, 0.00913421f, -0.00840318f, 0.04891882f, -0.05071701f, 
    0.02231186f, -0.06288040f, 0.06335761f, -0.04626248f, 0.02268537f, 0.09215125f, -0.05078688f, -0.10471212f, 
    0.05527169f, 0.06718528f, -0.01456758f, 0.07322784f, 0.16969456f, -0.09707060f, 0.02305055f, 0.00388716f, 
    -0.10863335f, -0.11343499f, -0.05668446f, 0.01430476f, -0.01689187f, 0.00102611f, -0.03560203f, 0.03932678f, 
    -0.00834240f, -0.09858558f, 0.02120537f, -0.02419335f, 0.02373057f, -0.00214816f, 0.00941939f, 0.06071027f, 
    -0.16374007f, 0.02979733f, 0.04512438f, -0.00657782f, -0.07920098f, 0.11324704f, -0.06171277f, 0.12908468f, 
    -0.17169270f, -0.03679314f, 0.14566839f, 0.00294427f, -0.07722133f, 0.02854152f, -0.00791743f, 0.01009143f, 
    0.05657378f, -0.07368597f, -0.10704998f, 0.00686283f, -0.23764576f, 0.30087268f, -0.08966745f, -0.00067410f, 
    -0.03699188f, 0.04544753f, 0.08225532f, 0.08794075f, 0.09956085f, -0.12490615f, -0.08148736f, 0.08679946f, 
    -0.02799874f, -0.01899210f, -0.08880045f, -0.05357643f, -0.09848654f, 0.03472556f, -0.00680364f, -0.10897890f, 
    -0.54479545f, 0.00645468f, -0.02852473f, 0.08982470f, 0.12399251f, 0.08858697f, -0.04932301f, 0.09127899f, 
    -0.00673627f, 0.10866854f, 0.01935816f, -0.00511370f, 0.05559170f, 0.00940431f, 0.04603469f, 0.02268584f, 
    -0.01280777f, 0.03087592f, 0.06370743f, -0.04630350f, 0.05484007f, -0.13959180f, 0.08641654f, 0.02535886f, 
    0.09535569f, 0.00707050f, 0.04222239f, -0.08966295f, -0.00147577f, 0.06906296f, 0.08365268f, 0.08102292f, 
    -0.07607839f, 0.03306285f, 0.01480441f, -0.05024676f, -0.05427286f, 0.01466742f, -0.00039057f, -0.01371107f, 
    -0.17066482f, 0.06117141f, 0.18001413f, -0.05800481f, -0.08304619f, 0.04804448f, 0.11365619f, -0.04648315f, 
    -0.06539803f, -0.07202833f, 0.02597737f, -0.04272011f, -0.07725858f, 0.06350279f, 0.03750647f, -0.08318368f, 
    -0.00893648f, 0.04145304f, -0.04557688f, 0.00431592f, -0.07598721f, -0.16160929f, -0.03132607f, -0.06669927f, 
    0.05589309f, -0.02650849f, 0.01677548f, -0.03598460f, 0.04141362f, -0.04000733f, -0.06953219f, -0.06576781f, 
    0.02106036f, 0.08559123f, -0.01373165f, -0.07691269f, 0.02153808f, -0.09006964f, -0.01560431f, -0.06067668f, 
    -0.05349249f, -0.06270471f, 0.04561846f, -0.17823492f, -0.25260112f, -0.06144740f, 0.01493435f, 0.00430820f, 
    0.08945049f, 0.02710194f, 0.03765950f, -0.15419216f, 0.02200790f, 0.04574844f, 0.13038135f, -0.06118445f, 
    0.03162751f, -0.02669440f, 0.03471808f, 0.07442728f, 0.10897768f, -0.01939625f, 0.06228068f, -0.09912147f, 
    -0.24816819f, 0.01171102f, 0.06643668f, -0.00005612f, -0.05144146f, 0.02534385f, -0.01829686f, 0.05031025f, 
    0.10863599f, -0.00517924f, 0.02982185f, -0.05093880f, 0.07102985f, 0.09001446f, 0.04728670f, 0.11799712f, 
    -0.00342490f, -0.09252280f, -0.15225762f, 0.11641188f, -0.05424257f, 0.13519232f, -0.08236095f, 0.10512704f, 
    0.01314420f, 0.02766174f, -0.02384577f, -0.05487287f, -0.01406814f, -0.05948663f, 0.02661448f, 0.03606379f, 
    0.02593411f, -0.03189390f, 0.04321767f, 0.02072895f, 0.08572347f, -0.09258123f, 0.08862748f, -0.01350758f, 
    0.03826905f, -0.00664482f, -0.06640214f, -0.00691142f, -0.04131682f, -0.01753285f, 0.07800081f, 0.06409336f, 
    0.04331397f, -0.00899704f, -0.04238753f, -0.05168492f, 0.10622811f, -0.00756118f, -0.00730965f, 0.05686667f, 
    0.17993356f, 0.05551568f, -0.16164714f, 0.05290112f, -0.11292583f, -0.02215321f, -0.07267282f, -0.00117536f, 
    -0.03505875f, -0.07930753f, 0.00314026f, 0.03213098f, 0.03129757f, -0.01966226f, 0.05418028f, 0.04195825f, 
    0.05283053f, 0.08531064f, 0.08066814f, 0.01293671f, -0.25160271f, 0.00209054f, 0.03945398f, -0.01582092f, 
    -0.04696985f, 0.01862555f, -0.06442355f, 0.01827675f, 0.02596912f, 0.03127179f, 0.04663135f, -0.06477199f, 
    -0.04014390f, 0.03947046f, 0.00293329f, 0.02485726f, 0.04343184f, 0.02110155f, 0.02926930f, 0.05036034f, 
    -0.32701328f, 0.05602365f, 0.14270996f, 0.02582127f, 0.07104835f, -0.04212051f, -0.07800121f, 0.09155895f, 
    0.05229133f, -0.02818897f, 0.07444464f, 0.01354323f, 0.02832172f, -0.11130206f, 0.02420567f, 0.12176651f, 
    0.01386702f, -0.07348190f, 0.02055400f, -0.02339738f, -0.01336701f, -0.01541464f, 0.18537274f, 0.05418319f, 
    -0.06595922f, 0.03769688f, 0.02877297f, -0.02273902f, -0.00749931f, -0.09925957f, 0.02770488f, -0.01829690f, 
    -0.02947153f, -0.03891926f, 0.07662382f, -0.00856593f, 0.00190233f, -0.09255111f, -0.00915404f, 0.00663801f, 
    -0.34441912f, -0.08552163f, 0.04881557f, 0.02693361f, -0.18941413f, -0.01405408f, -0.03293657f, 0.03157402f, 
    -0.05235105f, 0.01290152f, 0.02184705f, -0.12236439f, -0.00870978f, -0.05534012f, -0.09087522f, 0.02640636f, 
    -0.05165938f, 0.07558581f, -0.00839524f, 0.00422475f, -0.03006778f, -0.00024089f, -0.13272369f, -0.09199417f, 
    -0.02266103f, 0.03200149f, -0.01084651f, -0.04912238f, 0.03309893f, 0.03320820f, 0.06840641f, 0.12384035f, 
    0.02513997f, -0.04821039f, -0.00125403f, -0.05234445f, -0.04031381f, -0.10603227f, 0.03300126f, -0.02541789f, 
    -0.00107598f, -0.02259432f, -0.00738725f, 0.10543083f, 0.05729745f, -0.00623904f, 0.09478218f, 0.04125427f, 
    -0.02519466f, 0.00938906f, -0.06936803f, -0.01721391f, 0.08364246f, 0.02222935f, 0.16995701f, -0.03994086f, 
    0.05750518f, 0.05698368f, 0.01864600f, -0.01931957f, 0.08868129f, 0.08882079f, 0.07902611f, -0.01674560f, 
    0.02099343f, 0.00949586f, -0.13161857f, 0.04255181f, 0.02045945f, -0.01279930f, -0.11813481f, 0.04536482f, 
    0.02525710f, 0.02473764f, -0.01362201f, -0.01893297f, -0.07564519f, 0.04600978f, 0.10735244f, -0.00603497f, 
    0.00003488f, -0.17819941f, 0.07710576f, 0.12786929f, -0.07867388f, 0.06341872f, 0.02351721f, 0.00094800f, 
    -0.02599772f, -0.02831596f, 0.02176763f, 0.02555064f, 0.00973111f, -0.04593706f, 0.06396822f, 0.02497431f, 
    -0.06153807f, 0.01842464f, 0.07167812f, -0.00978852f, 0.09044944f, 0.09359648f, 0.04285742f, 0.03387639f, 
    -0.01594292f, -0.02667689f, 0.05406759f, -0.09773728f, -0.01013430f, -0.00484555f, 0.06954465f, 0.06314594f, 
    -0.12309024f, 0.00797155f, -0.00217354f, 0.01919456f, -0.07236046f, 0.10423104f, 0.10296143f, -0.02206376f, 
    -0.16425979f, -0.09288664f, -0.02909853f, 0.01186187f, 0.10364437f, -0.00831463f, -0.11448852f, 0.04925222f, 
    -0.03149752f, 0.02220801f, 0.07522183f, -0.01150710f, 0.00003750f, 0.01083025f, 0.02493893f, 0.01021307f, 
    -0.02797074f, -0.04514568f, -0.00091603f, 0.03883388f, 0.04195140f, -0.02350582f, 0.02560996f, 0.05021174f, 
    -0.10163575f, -0.09451291f, 0.01417028f, 0.05800108f, 0.04885099f, 0.05369420f, -0.08177464f, -0.09863167f, 
    0.14396679f, 0.04958640f, 0.17099014f, -0.02326830f, -0.05522611f, 0.01558016f, 0.01464905f, 0.02154613f, 
    -0.29106307f, 0.15872364f, -0.25820455f, -0.19074659f, 0.02053134f, 0.09512420f, 0.11143564f, 0.08539238f, 
    -0.08636298f, -0.03840182f, 0.03122114f, -0.03187463f, -0.04237632f, -0.08213602f, 0.04893674f, 0.00113553f, 
    -0.00468924f, -0.06878253f, -0.04753597f, -0.02633866f, -0.00878639f, -0.09086108f, -0.06537176f, -0.10479742f, 
    -0.19943093f, -0.05588719f, -0.01487586f, -0.01988276f, 0.02732226f, -0.08913592f, 0.00258798f, 0.00311219f, 
    -0.00841966f, 0.02988177f, -0.03426461f, -0.04964904f, 0.00244757f, 0.11948446f, -0.10531101f, -0.01707530f, 
    -0.32255414f, -0.07407123f, 0.02604309f, 0.01807824f, 0.05686076f, 0.01499684f, -0.04559296f, 0.12370273f, 
    0.11636713f, 0.03490833f, 0.00593639f, -0.08475622f, -0.00135929f, -0.05517844f, 0.12572405f, 0.00011042f, 
    0.06323156f, -0.10396927f, -0.02042820f, -0.02400483f, -0.40202627f, 0.09693038f, -0.02106437f, -0.04716130f, 
    -0.00159348f, -0.00376334f, -0.01231939f, 0.11384466f, 0.02790937f, -0.10148180f, 0.09424052f, 0.03671597f, 
    0.01763738f, -0.00762239f, -0.02990634f, 0.00200331f, 0.03344608f, -0.04658212f, -0.03137103f, 0.00755448f, 
    0.04094523f, 0.09316895f, 0.01621523f, 0.10288064f, 0.02873863f, -0.03020944f, -0.02733949f, -0.09163125f, 
    0.09311131f, 0.05602028f, -0.00257733f, -0.10412450f, -0.00596761f, 0.10311624f, 0.05356467f, -0.00544353f, 
    0.04562351f, 0.02228718f, -0.06757458f, 0.01473148f, 0.06974123f, 0.10683875f, -0.01480642f, 0.09273547f, 
    0.03220551f, -0.03286257f, 0.03590683f, -0.04820897f, 0.04001498f, 0.04942960f, -0.07240438f, -0.16297124f, 
    -0.05040266f, 0.04962684f, 0.07749134f, 0.04117312f, 0.08179378f, -0.07204776f, 0.01197269f, 0.02486350f, 
    0.02304555f, 0.13095324f, 0.06085183f, -0.00093263f, -0.02386453f, -0.06182386f, 0.16844770f, -0.00048449f, 
    -0.00771470f, 0.05168591f, -0.00538679f, -0.00914644f, -0.13584043f, 0.05750747f, -0.07222879f, 0.03256134f, 
    -0.07426963f, 0.00030388f, -0.01514948f, 0.01256606f, -0.43445304f, 0.24036683f, -0.05569170f, 0.10225584f, 
    -0.12307920f, -0.04854488f, -0.06146625f, 0.03881918f, -0.07087100f, 0.07989871f, -0.02850305f, -0.03817762f, 
    -0.14552546f, -0.14424193f, -0.05002458f, -0.05386409f, -0.07206733f, 0.09664585f, -0.06322507f, -0.09328543f, 
    -0.12042702f, 0.25332850f, -0.23977734f, -0.11546832f, -0.07826258f, 0.08271682f, 0.05733358f, 0.05754150f, 
    -0.08966517f, -0.10814166f, 0.01689805f, -0.03843424f, -0.14897765f, -0.03324768f, -0.02436402f, 0.00478393f, 
    -0.06710494f, 0.01645608f, 0.10376064f, 0.01320934f, -0.02620850f, 0.05668679f, 0.01058806f, 0.09269679f, 
    0.13192421f, -0.12536313f, -0.13163853f, 0.12779330f, 0.06317098f, 0.04255791f, 0.04415702f, -0.11857596f, 
    0.02941909f, 0.11412919f, 0.08926564f, 0.02963294f, 0.01127564f, -0.07631649f, -0.09186377f, -0.08045246f, 
    -0.18762372f, -0.01370286f, -0.15468720f, 0.00321664f, 0.04504402f, 0.08663567f, 0.16781420f, 0.01450045f, 
    -0.04838530f, 0.05840999f, 0.00544145f, 0.16079243f, 0.04944391f, -0.01352543f, 0.06566434f, -0.04087773f, 
    0.11775195f, -0.09935318f, -0.00187820f, -0.11539316f, 0.07169539f, 0.09691714f, 0.02392226f, 0.20483221f, 
    0.09076626f, -0.08785485f, -0.16536409f, 0.07391489f, -0.05589718f, 0.06643373f, -0.06252843f, -0.15048803f, 
    -0.02060993f, 0.13468719f, 0.01165862f, 0.01250396f, 0.02835837f, -0.19291636f, -0.00033181f, 0.02860207f, 
    -0.53543216f, -0.23616530f, -0.15841632f, -0.12433448f, 0.00443719f, 0.00117850f, 0.13447884f, -0.03249142f, 
    -0.04339198f, -0.11101113f, -0.03861270f, 0.05943194f, 0.11500998f, -0.02860142f, -0.01146324f, 0.02629634f, 
    0.07224518f, -0.07179523f, -0.02177603f, -0.01692115f, -0.31047502f, -0.12884110f, -0.05976457f, -0.06118660f, 
    0.06985652f, 0.03590301f, 0.03103941f, -0.11974215f, -0.01994669f, -0.05318918f, 0.04372000f, 0.05508763f, 
    -0.00716548f, 0.00215651f, -0.07407502f, 0.03868682f, 0.12000454f, -0.00436146f, -0.12904331f, 0.07400672f, 
    -0.06789783f, -0.11840877f, -0.00389379f, -0.05405890f, -0.03334191f, 0.09932756f, 0.10182338f, -0.08605020f, 
    0.08402134f, 0.09888765f, -0.05192721f, 0.07305468f, 0.04065410f, -0.04426972f, -0.15613672f, 0.07729865f, 
    0.04884592f, -0.01840743f, -0.09093197f, 0.07766393f, 0.03737493f, -0.06212871f, -0.05041728f, 0.12945113f, 
    -0.08144197f, -0.02438339f, -0.05675930f, -0.00365066f, -0.02454174f, 0.03328068f, 0.04296572f, -0.00036016f, 
    0.01482741f, 0.05911119f, -0.09915390f, -0.01066345f, -0.00029249f, -0.04927980f, -0.11265250f, -0.02204560f, 
    -0.05811924f, -0.23080225f, -0.12740420f, -0.05728108f, -0.00197384f, 0.06686032f, -0.00257927f, 0.11196681f, 
    0.03756116f, -0.00028998f, 0.03118710f, 0.03357599f, 0.01815609f, 0.07347976f, -0.03203803f, 0.03597758f, 
    -0.02075243f, 0.05835712f, -0.14432138f, 0.06348091f, -0.00014107f, -0.04679894f, -0.05366344f, -0.00403635f, 
    0.14194609f, -0.00190083f, -0.01635029f, -0.06921484f, 0.00949363f, 0.07452241f, 0.00498854f, 0.07395663f, 
    0.10666493f, 0.10440190f, 0.04785823f, 0.04216703f, 0.00420661f, 0.09645829f, -0.19044186f, 0.02172904f, 
    -0.24956830f, 0.03222739f, 0.05528319f, -0.03321773f, -0.02552146f, 0.01551516f, -0.01415312f, 0.05145213f, 
    -0.01633783f, -0.00778415f, 0.07848998f, 0.02630829f, 0.02779310f, -0.03815087f, 0.00778740f, 0.05945105f, 
    0.05121784f, -0.00722514f, -0.03554654f, 0.06381600f, -0.26536155f, -0.00134009f, 0.04026638f, 0.23873238f, 
    -0.08567744f, -0.08779022f, 0.13899410f, -0.05209333f, 0.01402404f, -0.00162641f, 0.07301544f, -0.11407059f, 
    0.02322841f, -0.00251200f, -0.02228685f, 0.11352070f, -0.03010995f, 0.00684110f, -0.09746183f, 0.00363472f, 
    -0.03104286f, -0.00345386f, 0.13960142f, 0.08926690f, 0.14709166f, 0.01594160f, -0.03179811f, -0.00237474f, 
    -0.08554433f, -0.04243752f, -0.08520533f, 0.02048378f, 0.00382229f, 0.07264266f, -0.00382487f, -0.04080596f, 
    -0.02468959f, 0.01422046f, -0.04854389f, -0.09452923f, 0.14577827f, 0.01918412f, 0.16823666f, 0.02825535f, 
    -0.03176392f, 0.03828513f, 0.06076575f, -0.07867438f, 0.04062208f, -0.03573631f, 0.05876613f, -0.01124697f, 
    -0.10529123f, 0.11375717f, 0.02495325f, 0.04443260f, -0.04725728f, 0.03825640f, 0.09296772f, 0.07158911f, 
    0.13449758f, 0.18090245f, 0.05133230f, 0.04064974f, -0.18228254f, 0.00100719f, -0.12190011f, -0.00081103f, 
    -0.05021923f, 0.11492128f, 0.01270566f, 0.00902489f, 0.03348309f, -0.00100011f, -0.05905676f, 0.04648579f, 
    -0.08218189f, 0.08301783f, 0.07783391f, 0.03477577f, -0.43791461f, -0.14601389f, -0.16479363f, -0.23409604f, 
    -0.05868720f, 0.10063706f, -0.01210538f, 0.03186034f, 0.07082416f, -0.13422921f, -0.00748941f, 0.06763300f, 
    -0.08224452f, -0.00812048f, -0.05421681f, 0.07530884f, -0.04395436f, 0.03204069f, -0.06444381f, 0.00462872f, 
    -0.19566633f, 0.01349297f, 0.22187859f, 0.06648222f, -0.23099212f, 0.06465144f, -0.06155728f, -0.02011654f, 
    -0.05684842f, 0.01691795f, 0.06447776f, -0.06945805f, -0.05287965f, -0.02932829f, -0.07708163f, -0.04113855f, 
    0.07760904f, 0.17963316f, 0.01020059f, -0.00543503f, 0.18266383f, 0.21217853f, 0.14158475f, -0.14650659f, 
    -0.07536200f, 0.08282182f, 0.07501098f, -0.00422876f, 0.05665786f, 0.11910607f, 0.00577434f, 0.10816575f, 
    -0.04489760f, -0.03048458f, -0.13414486f, -0.10000028f, 0.01415071f, 0.06967796f, 0.06177331f, -0.00354302f, 
    0.09721974f, -0.06523139f, 0.02810621f, -0.01148181f, 0.06838413f, -0.07703838f, 0.02983698f, 0.04071955f, 
    -0.07838938f, -0.01939465f, 0.02044579f, 0.02147651f, 0.07229092f, -0.00248660f, 0.06401654f, -0.05305585f, 
    -0.01079471f, 0.12900658f, 0.00822051f, 0.01430757f, -0.03407760f, -0.05043196f, -0.13769273f, -0.08506206f, 
    0.05158121f, -0.01842585f, -0.06304918f, -0.08640417f, -0.02376578f, 0.06525083f, 0.10115367f, 0.05333370f, 
    0.07267508f, -0.10083041f, -0.03194416f, 0.01741049f, -0.05145467f, -0.06060411f, 0.06613342f, -0.01173127f, 
    -0.22128032f, -0.19844723f, 0.05435753f, 0.17053534f, -0.16142409f, -0.02074974f, -0.00648684f, -0.03117330f, 
    0.05207027f, -0.03849573f, -0.08107897f, 0.02592120f, -0.01931504f, -0.01249751f, 0.16084400f, 0.00391570f, 
    0.06349751f, 0.00313363f, -0.01040230f, 0.02017096f, 0.12356870f, 0.10752329f, 0.19950348f, 0.05554975f, 
    0.06642079f, 0.01269196f, 0.06930429f, 0.11593626f, 0.05551516f, 0.05303810f, 0.09442313f, 0.00839817f, 
    -0.03582460f, -0.04047302f, -0.03895197f, 0.09801513f, 0.11532281f, 0.02907502f, 0.03956455f, 0.10184305f, 
    -0.09246417f, -0.03879994f, 0.07902563f, 0.17897825f, -0.13095203f, -0.13348828f, -0.12911020f, 0.06711926f, 
    -0.13529991f, 0.05429386f, -0.05588550f, 0.02500392f, -0.02222360f, 0.01018810f, 0.03109495f, 0.01015641f, 
    -0.02515853f, -0.11485806f, -0.00298515f, -0.02186782f, -0.12339759f, -0.08201326f, 0.13136907f, 0.14446300f, 
    -0.10998584f, 0.00097098f, -0.03861596f, 0.02847353f, -0.00706724f, -0.01579791f, -0.03567867f, 0.01322712f, 
    0.02819209f, 0.00938254f, -0.00232503f, -0.06511252f, -0.02580453f, -0.10761668f, -0.02958167f, 0.07146091f, 
    0.03206385f, 0.04806750f, 0.07206745f, 0.05782595f, -0.13866134f, -0.03752618f, 0.04035325f, 0.02934213f, 
    0.03684720f, 0.06357417f, -0.01316063f, 0.01862105f, -0.10232954f, -0.02662125f, -0.15055694f, 0.10943125f, 
    -0.05624459f, 0.04179354f, -0.02215199f, 0.04749499f, -0.09718490f, 0.17709614f, 0.08912136f, -0.06325119f, 
    -0.11575846f, -0.02448961f, 0.05837983f, 0.02078904f, 0.09504101f, -0.16488598f, 0.11118585f, -0.04916451f, 
    -0.01659980f, -0.14153522f, -0.01869168f, 0.10710962f, 0.04826625f, 0.02572513f, -0.04524609f, 0.01265358f, 
    0.09739145f, -0.12475180f, -0.15004925f, 0.00007190f, -0.21050560f, 0.11623328f, -0.03981833f, -0.04565242f, 
    -0.06009070f, 0.00219298f, -0.00687970f, 0.03239099f, 0.04019281f, -0.00323717f, -0.02067764f, 0.01844515f, 
    -0.05274163f, 0.06608687f, 0.07991322f, -0.05009593f, -0.24615781f, -0.02928748f, 0.17958190f, 0.14571527f, 
    -0.36189878f, 0.03681617f, -0.02577764f, -0.03977610f, -0.00223979f, -0.03674553f, -0.01198603f, 0.03336157f, 
    0.03098277f, 0.01028780f, 0.00511889f, -0.07385239f, -0.04382977f, 0.07964174f, 0.05511030f, 0.02617202f, 
    -0.38164234f, -0.04585855f, -0.30544305f, -0.20486702f, 0.03959326f, 0.08758994f, 0.10458145f, 0.01982971f, 
    0.00071526f, -0.09430254f, 0.04880647f, 0.08218638f, -0.05902718f, -0.04889100f, -0.10700473f, -0.00442326f, 
    0.00828711f, 0.01043243f, -0.02080888f, -0.00279355f, 0.04606797f, 0.05449098f, 0.01877124f, -0.03744627f, 
    -0.13376996f, -0.00916024f, -0.00172620f, -0.03185054f, -0.03112724f, 0.02465037f, -0.02608605f, 0.02803292f, 
    -0.06412008f, -0.00533453f, 0.02202994f, -0.01155910f, -0.04210254f, 0.05896108f, 0.04579283f, 0.00791023f, 
    -0.08977768f, -0.08848189f, -0.09607214f, 0.08204955f, 0.08394743f, 0.05306421f, -0.00726543f, -0.00718690f, 
    0.02971995f, 0.18624707f, 0.10583614f, -0.01590262f, 0.12927787f, 0.01037405f, 0.00110809f, -0.18434738f, 
    0.05804635f, -0.01454729f, 0.01708515f, -0.08671567f, 0.01882761f, 0.07676102f, -0.06321835f, 0.05586977f, 
    -0.03286346f, -0.05369448f, 0.03969311f, -0.07605451f, -0.03043369f, -0.01693341f, 0.02416080f, 0.02953978f, 
    0.06220582f, -0.06515343f, 0.06743172f, 0.08327216f, 0.09588037f, 0.10779814f, 0.03154439f, 0.03072016f, 
    0.06047532f, -0.03648962f, -0.13159363f, 0.07223909f, 0.25098649f, -0.06475058f, -0.10975068f, 0.03567435f, 
    0.00355890f, -0.02286555f, 0.04581336f, 0.02233701f, 0.00617931f, 0.06251454f, 0.11976752f, -0.05957359f, 
    0.03106694f, -0.03454504f, 0.02369718f, -0.09744243f, -0.04137158f, 0.04689764f, 0.05869034f, 0.06639530f, 
    0.16324177f, 0.00999486f, -0.07667436f, -0.01675052f, -0.08042526f, 0.12129813f, -0.03603979f, -0.12052722f, 
    0.03452815f, 0.03441889f, 0.02384113f, 0.02074954f, -0.01344389f, -0.04560843f, 0.07254048f, 0.02540950f, 
    -0.01847607f, -0.03701815f, 0.12161872f, 0.22935675f, -0.02445132f, -0.12155081f, -0.07556628f, -0.05395400f, 
    0.03774512f, 0.13024704f, 0.05411765f, 0.04694946f, 0.08358819f, 0.06888697f, -0.07059696f, -0.21741295f, 
    -0.08405791f, -0.10249487f, -0.01552826f, -0.02592001f, -0.36820671f, -0.21763915f, 0.02164787f, 0.01787533f, 
    0.02989740f, 0.07540651f, -0.17498635f, -0.00502634f, -0.02876114f, 0.02298573f, 0.00239211f, -0.05936123f, 
    -0.00356026f, 0.05017126f, 0.02996786f, -0.00696008f, 0.05121934f, -0.05454269f, -0.04895367f, 0.06457547f, 
    -0.13535827f, 0.15497045f, -0.15237972f, -0.08305312f, -0.01276134f, -0.00115264f, 0.05973527f, 0.04596866f, 
    -0.03566823f, -0.14942522f, -0.02156486f, 0.02547825f, 0.00815418f, -0.11465282f, 0.02115805f, -0.01283103f, 
    0.00259950f, -0.00368213f, 0.04862580f, 0.00384720f, 0.05147479f, -0.02917287f, -0.12513520f, 0.08962090f, 
    0.20371099f, 0.01557348f, -0.04301392f, -0.02132303f, 0.03891200f, 0.06515472f, 0.12927286f, -0.01441531f, 
    0.05808256f, 0.16222934f, 0.14649706f, 0.04279347f, 0.11466477f, 0.05166886f, -0.16124569f, 0.01653663f, 
    0.02448654f, -0.04564414f, -0.03768778f, -0.00060099f, -0.01029231f, -0.05489483f, -0.05624152f, -0.01728399f, 
    0.01148987f, -0.03992894f, -0.00245457f, 0.05010194f, 0.02171367f, 0.12144136f, 0.09915124f, -0.02678192f, 
    0.00110733f, -0.00583343f, -0.11614655f, -0.04918820f, -0.07421809f, 0.05739363f, -0.10854242f, 0.02270591f, 
    -0.01104663f, 0.01235556f, 0.02136303f, 0.04171777f, -0.00936088f, -0.01757086f, -0.05806213f, -0.03585263f, 
    -0.00949567f, -0.06569294f, -0.09123937f, 0.03164614f, -0.06924265f, 0.09629393f, 0.02108429f, 0.04437343f, 
    -0.17930514f, 0.10329256f, 0.02155439f, -0.03822847f, -0.08338598f, 0.01121799f, 0.10159562f, -0.02333747f, 
    -0.06537662f, 0.06652617f, -0.09548273f, -0.02994283f, 0.00902689f, -0.04634592f, -0.14456461f, -0.03946119f, 
    0.03768858f, -0.12450629f, 0.05512666f, -0.12411334f, -0.05634836f, 0.03407190f, 0.16569966f, 0.24613826f, 
    -0.12444578f, 0.00647035f, -0.06932085f, -0.01529484f, 0.07829531f, 0.01863227f, -0.07431566f, 0.03740290f, 
    0.00971477f, 0.04644106f, -0.12809010f, -0.07809571f, -0.02243652f, -0.22781947f, -0.02025233f, 0.06238156f, 
    0.03546973f, 0.16048920f, 0.07632580f, -0.04108006f, -0.02256727f, -0.13728991f, 0.06756967f, 0.01185071f, 
    -0.14641242f, 0.04621452f, 0.04677997f, 0.00138071f, -0.01096636f, 0.00464657f, -0.10041591f, 0.05323118f, 
    0.05438671f, -0.01310738f, 0.10366551f, 0.01395516f, 0.04469309f, 0.07891978f, 0.06087481f, 0.06356446f, 
    0.09433270f, -0.04464978f, -0.02084171f, -0.02424009f, -0.04718074f, 0.09486200f, -0.01035078f, 0.00069915f, 
    0.04150474f, 0.01837555f, 0.03767878f, 0.01300701f, -0.08392227f, 0.11996901f, -0.03975727f, -0.00563628f, 
    -0.00575364f, -0.07876455f, 0.02664640f, -0.04542598f, 0.09384827f, -0.03998359f, -0.02020286f, -0.04503782f, 
    0.01002139f, 0.06218700f, 0.01348210f, 0.01543935f, -0.00489343f, 0.00526843f, 0.04566371f, 0.03117077f, 
    -0.07872725f, -0.07677156f, -0.11053304f, 0.05416596f, -0.29793262f, -0.05589499f, -0.10526017f, -0.03510318f, 
    -0.04168647f, 0.04539023f, 0.05358770f, 0.02660935f, -0.01005675f, -0.00879679f, 0.05972811f, -0.01292969f, 
    0.04772778f, -0.00989893f, 0.00160615f, -0.03200293f, -0.03661148f, -0.14843567f, -0.03531474f, 0.02878911f, 
    -0.02637345f, -0.10792508f, 0.03728288f, 0.07217131f, -0.17805974f, -0.02392348f, 0.06311557f, -0.02858818f, 
    0.02862413f, 0.02550474f, -0.03556042f, -0.00344317f, 0.04613870f, 0.09781700f, 0.02833321f, -0.06569599f, 
    -0.14542083f, 0.04941053f, 0.06077378f, -0.00819356f, 0.09304205f, -0.01947570f, 0.02958700f, 0.07844587f, 
    -0.02262286f, 0.02954318f, 0.01257199f, 0.02760578f, 0.03340929f, 0.01368158f, 0.02149123f, 0.00305805f, 
    0.03268580f, 0.03781875f, -0.00488074f, 0.00986691f, -0.03284292f, -0.08487909f, -0.02689262f, -0.03117394f, 
    0.25822613f, -0.53504056f, -0.20534848f, 0.04943807f, -0.03629425f, -0.06336579f, 0.07175360f, -0.01494864f, 
    0.04574379f, 0.03403260f, 0.02243350f, 0.02708425f, -0.01596906f, 0.03657981f, 0.09407144f, -0.01101092f, 
    0.05015935f, 0.04457727f, -0.12178639f, -0.00624930f, -0.14857236f, -0.06111294f, -0.11925822f, -0.29504615f, 
    0.17787077f, -0.00168890f, -0.02429068f, 0.09913936f, 0.03175979f, -0.02914246f, -0.08437013f, -0.06024513f, 
    -0.05104822f, 0.00720974f, 0.03272042f, 0.02472838f, -0.00388827f, 0.09100179f, 0.03227592f, 0.06346606f, 
    -0.12230536f, 0.19842011f, 0.05053696f, 0.08257828f, -0.25228721f, -0.01807584f, -0.08499610f, 0.01495624f, 
    0.03013855f, 0.02512569f, 0.04033473f, 0.07652152f, -0.03804963f, -0.02700148f, -0.09759519f, 0.01130073f, 
    -0.06238290f, -0.01063132f, 0.02447477f, 0.04664639f, -0.16455598f, 0.27480784f, 0.07357308f, 0.00575929f, 
    -0.24447858f, -0.02312117f, 0.00471299f, 0.00279565f, 0.07229661f, 0.07955317f, 0.07707569f, 0.03669520f, 
    0.03324610f, -0.07700241f, 0.04725014f, -0.05149646f, -0.02262289f, -0.08359848f, -0.02421336f, -0.02344526f, 
    0.00394450f, 0.09249088f, -0.00019596f, 0.13315018f, -0.23805030f, -0.04924824f, 0.03065800f, 0.03015110f, 
    0.08269741f, -0.00439688f, 0.03469248f, 0.00005398f, 0.05579250f, -0.00802965f, -0.05172751f, -0.04377693f, 
    -0.01847883f, -0.01480877f, -0.13958047f, 0.08023779f, -0.22481318f, -0.00360105f, -0.03661739f, 0.13300385f, 
    -0.02282452f, 0.05076969f, -0.02673965f, 0.04796332f, -0.01168821f, -0.03727553f, -0.02442453f, -0.07360669f, 
    0.14067458f, 0.02790272f, -0.04829454f, 0.01219729f, 0.01095091f, -0.05676583f, -0.08354867f, -0.06137406f, 
    -0.11875876f, -0.18064871f, -0.11789192f, 0.13565005f, 0.04045501f, -0.00250848f, 0.14063995f, 0.01652973f, 
    0.08447263f, 0.03530997f, -0.07018916f, -0.01440887f, -0.03953308f, -0.05911289f, -0.03760711f, -0.00561147f, 
    -0.01665027f, 0.10709767f, -0.08896908f, -0.02690334f, -0.00393581f, 0.20912047f, 0.25707266f, -0.05436974f, 
    -0.29473075f, 0.13769273f, -0.02180460f, 0.05476911f, 0.01532821f, -0.01513164f, -0.01222095f, 0.03660706f, 
    -0.16766794f, 0.09779251f, -0.05761201f, 0.08112092f, -0.04824048f, 0.00296722f, 0.00678977f, -0.05161867f, 
    0.15869096f, -0.16141371f, -0.05165116f, -0.17774360f, 0.07067552f, -0.04158409f, 0.05402732f, -0.06663936f, 
    0.00894240f, -0.08990930f, 0.00683211f, 0.04796854f, 0.07132333f, 0.07685825f, 0.00193281f, 0.03926136f, 
    -0.01878707f, 0.01692324f, -0.10186626f, 0.11978038f, 0.24844931f, -0.19938520f, 0.09261244f, 0.09722827f, 
    0.01462105f, 0.10204700f, -0.00034687f, 0.03567194f, -0.04169709f, -0.03516816f, 0.05532611f, 0.02312983f, 
    0.03654943f, -0.05449863f, 0.02284414f, -0.04238016f, 0.11541554f, 0.06102340f, -0.04014215f, -0.04633432f, 
    0.34720013f, 0.18592204f, -0.00202313f, 0.00259515f, 0.08111131f, -0.04847668f, 0.00140068f, -0.06089011f, 
    -0.16547748f, -0.04518783f, -0.03038071f, -0.00622487f, 0.08907261f, -0.03624900f, -0.08415261f, 0.00551922f, 
    -0.05567327f, 0.12379827f, -0.09999510f, 0.05697078f, -0.11682379f, -0.13053887f, -0.03631030f, -0.03288982f, 
    0.04669292f, -0.02246615f, -0.04953806f, -0.03535837f, -0.04051957f, 0.00262444f, -0.01126127f, -0.05703783f, 
    0.02168394f, 0.03933516f, 0.00230778f, -0.07905386f, -0.04404685f, -0.08332348f, -0.05787975f, 0.04026668f, 
    -0.01768404f, 0.08553297f, -0.03734236f, -0.07277257f, -0.08979432f, -0.01144053f, 0.11844613f, 0.05946580f, 
    -0.04740641f, -0.02434126f, -0.02096060f, -0.06709933f, 0.00625788f, -0.06456941f, -0.10341959f, 0.05703267f, 
    -0.03537193f, -0.01429956f, 0.01533638f, 0.10493420f, -0.17299460f, 0.26369339f, -0.05737418f, 0.03543574f, 
    -0.23890847f, 0.08080859f, 0.02432593f, -0.01845380f, 0.01544627f, -0.02202214f, -0.01577630f, 0.07784954f, 
    -0.02983641f, 0.01732911f, -0.15531044f, 0.02473640f, -0.03380081f, 0.03264422f, -0.02793972f, 0.01161841f, 
    -0.11636171f, 0.16383918f, 0.06149540f, 0.01662906f, -0.04313478f, -0.08248113f, -0.13983200f, 0.08386858f, 
    0.06017544f, -0.00811836f, 0.02385598f, -0.00683931f, 0.15980686f, -0.00998087f, -0.02628565f, -0.00465746f, 
    -0.02677149f, -0.03059591f, -0.06025966f, 0.08059477f, 0.30697414f, -0.15160912f, 0.10645895f, 0.04919352f, 
    0.27619049f, 0.04633444f, -0.10632354f, -0.03281962f, 0.01025344f, -0.17102849f, 0.00426881f, -0.00815174f, 
    -0.00431200f, 0.01112591f, 0.16181031f, -0.07144020f, 0.02422498f, 0.10562366f, 0.06863835f, -0.01236184f, 
    0.15530130f, -0.38450530f, -0.00277816f, -0.19659570f, 0.05014459f, -0.02249139f, 0.00357131f, -0.00442503f, 
    -0.00042422f, -0.06632907f, -0.04165982f, 0.03021503f, 0.09746646f, 0.02677869f, 0.02448478f, 0.04045359f, 
    0.00732189f, -0.06229783f, -0.14908557f, 0.03387810f, 0.01272222f, 0.10557209f, -0.02289145f, -0.06704248f, 
    -0.05618791f, 0.05515145f, 0.08242740f, 0.03619281f, -0.06449967f, 0.02007988f, -0.04121118f, -0.04800101f, 
    -0.03395834f, 0.01112655f, -0.04806760f, -0.00322437f, -0.09131517f, 0.10851875f, -0.01534910f, -0.04029469f, 
    -0.22033809f, -0.05691514f, -0.12095731f, -0.42716900f, 0.15701422f, -0.05811084f, -0.01314985f, -0.12200145f, 
    -0.02605587f, -0.17233388f, -0.03924342f, -0.02815933f, -0.00337482f, -0.04121594f, 0.07207123f, -0.02037600f, 
    0.00832363f, 0.06406794f, 0.04142937f, 0.05000226f, -0.07947452f, 0.05044444f, -0.17754441f, -0.02044128f, 
    -0.22231591f, 0.06564671f, 0.12860252f, 0.00272808f, -0.03145495f, 0.10490650f, -0.07984170f, 0.07002947f, 
    -0.06077489f, 0.06960526f, -0.09947812f, 0.01541421f, -0.09609713f, 0.11893310f, -0.00339071f, 0.01789584f, 
    -0.08242579f, -0.02552912f, -0.03561911f, -0.18830825f, 0.08444931f, -0.05483251f, 0.01726112f, -0.01137636f, 
    -0.07370812f, -0.03312055f, -0.01037591f, -0.00883442f, -0.04503743f, 0.04552358f, -0.00605607f, -0.04251631f, 
    -0.01194186f, -0.05616247f, 0.00948690f, 0.06231238f, -0.29859778f, -0.02022645f, -0.01343645f, -0.16908887f, 
    0.05001313f, -0.00315412f, -0.03679362f, 0.11370994f, -0.08306137f, 0.07232336f, 0.05369707f, -0.03722525f, 
    -0.01382545f, -0.01450337f, 0.00752634f, -0.01003309f, -0.00334727f, -0.11412036f, 0.15187849f, 0.03231679f, 
    -0.01930704f, -0.08072568f, -0.06302365f, -0.20430021f, -0.05595791f, -0.00869192f, 0.07076927f, 0.03182083f, 
    -0.04446678f, 0.02380452f, -0.04561325f, -0.08201034f, -0.02586945f, 0.07416599f, -0.10836110f, -0.04890918f, 
    0.03160753f, 0.00488714f, 0.17630634f, -0.08692326f, -0.07474492f, -0.06128489f, 0.08404934f, -0.03247140f, 
    0.07362317f, 0.00616002f, -0.04671417f, 0.04094245f, -0.13807668f, -0.08381326f, -0.04459618f, 0.08734675f, 
    -0.02880301f, -0.04095875f, -0.03532936f, -0.00917237f, 0.04905438f, 0.04397716f, 0.08063360f, -0.04445138f, 
    -0.12285843f, -0.08600142f, 0.00633577f, -0.05728158f, -0.07484222f, 0.04635940f, -0.00001051f, 0.03745365f, 
    -0.07999345f, -0.03402951f, 0.01726248f, -0.02340869f, -0.01295493f, -0.02216388f, 0.07986435f, -0.05596070f, 
    -0.08579556f, 0.03679903f, 0.07080945f, -0.02793849f, -0.09833534f, 0.03628387f, -0.14256874f, -0.18574423f, 
    -0.04103884f, -0.03878132f, 0.00916908f, 0.02565130f, -0.04426214f, -0.00049872f, -0.01265899f, -0.04898531f, 
    -0.04142137f, -0.04075570f, 0.00881803f, 0.00046488f, -0.00472264f, 0.01695641f, 0.07035567f, 0.10403536f, 
    0.03956161f, -0.13846272f, -0.03783943f, 0.06304661f, -0.03410979f, -0.09652349f, -0.05477728f, -0.02340656f, 
    -0.02804833f, -0.00880821f, 0.02904578f, 0.00477021f, -0.00910540f, 0.03099632f, 0.07060190f, -0.14549644f, 
    -0.01517910f, -0.02834962f, -0.03067900f, -0.07082012f, 0.14049825f, -0.19615905f, 0.06270585f, 0.04169083f, 
    0.33591980f, -0.00994816f, 0.04213778f, 0.02814402f, 0.03194211f, 0.02121556f, -0.05814032f, 0.04279740f, 
    0.01596137f, 0.06949031f, 0.06753352f, -0.09681650f, -0.03777431f, 0.05164607f, 0.09347914f, -0.02507414f, 
    -0.09466571f, 0.00462323f, 0.05033626f, 0.00899345f, 0.16720696f, -0.06626780f, 0.01659816f, -0.10358710f, 
    0.05189215f, -0.00126331f, -0.09873318f, -0.01488531f, 0.02038218f, 0.04714574f, 0.15642889f, 0.01404829f, 
    0.04939517f, -0.08167215f, -0.01636252f, -0.02898499f, -0.11160927f, -0.07848927f, -0.02822601f, 0.21917525f, 
    0.02583773f, -0.09014665f, 0.01187485f, 0.05937208f, 0.06494101f, -0.00620002f, -0.03119243f, -0.03657684f, 
    -0.01990774f, -0.02479942f, 0.07111645f, -0.03968426f, 0.02672436f, -0.02210181f, -0.10042660f, -0.14073044f, 
    -0.16790447f, 0.02858748f, -0.03894022f, 0.11986386f, -0.10857484f, -0.03597225f, -0.03344029f, 0.00312978f, 
    0.03317041f, -0.01233210f, 0.03973220f, -0.02301815f, -0.00156867f, 0.01694540f, 0.05100143f, 0.05879705f, 
    0.02782926f, -0.12147813f, -0.01648474f, -0.09886378f, 0.12363759f, -0.05486095f, 0.07493977f, -0.15307170f, 
    0.04371830f, -0.01795937f, 0.00341555f, 0.09901651f, -0.09934267f, 0.05678339f, 0.02375064f, -0.05725583f, 
    0.07216536f, 0.04137348f, 0.07269537f, -0.04652943f, 0.00903217f, -0.04001862f, 0.00784405f, 0.00255566f, 
    0.15781963f, -0.10101283f, -0.08494559f, 0.06653152f, -0.09961521f, -0.09906332f, 0.01722568f, -0.00088474f, 
    -0.01955545f, 0.05866770f, 0.02790744f, -0.04199750f, 0.01253573f, 0.00075552f, 0.02634345f, 0.09789178f, 
    -0.00857618f, -0.06266230f, -0.02723604f, 0.03763298f, -0.24573594f, 0.00164720f, -0.17463474f, -0.16578725f, 
    0.03083269f, -0.12918140f, -0.05634836f, 0.05254594f, 0.02104100f, -0.08399701f, 0.07639818f, -0.12320299f, 
    -0.03313648f, -0.04105296f, -0.03297902f, 0.07043435f, -0.02356170f, -0.04679658f, 0.03849717f, -0.05452575f, 
    -0.19193175f, -0.05842471f, 0.02244725f, 0.07323451f, -0.02755619f, -0.00131261f, -0.02476286f, 0.00888375f, 
    0.04974724f, 0.01824184f, -0.03100094f, -0.10191832f, -0.02585724f, 0.07580763f, -0.05569319f, 0.06148728f, 
    -0.00877751f, -0.09686101f, -0.05473203f, 0.00053763f, -0.05145832f, -0.25816852f, -0.13492452f, -0.23709613f, 
    0.25523978f, -0.01669747f, 0.01465831f, 0.05774250f, 0.05859738f, 0.01730596f, -0.02661244f, -0.07854605f, 
    -0.08574308f, -0.02781307f, 0.01469763f, -0.02196568f, -0.03862746f, 0.14412193f, -0.03314614f, 0.05777878f, 
    0.22744110f, 0.13448271f, 0.07505482f, -0.02661263f, 0.09414707f, 0.05057688f, -0.10667089f, 0.03330721f, 
    -0.01058228f, 0.08785675f, 0.00300398f, 0.07085369f, -0.02661288f, -0.03148279f, -0.15705402f, 0.02981119f, 
    -0.01655913f, -0.07962013f, 0.00084590f, -0.05420470f, -0.13058889f, -0.27335474f, -0.02868827f, 0.12902057f, 
    0.11058141f, -0.08877490f, 0.04570488f, -0.03743138f, -0.02376774f, 0.11674300f, -0.05741558f, 0.04903961f, 
    0.03703248f, -0.00377966f, -0.00557725f, -0.01909673f, -0.06646526f, -0.07576896f, -0.04934998f, -0.17777763f, 
    0.12677246f, 0.05204977f, 0.02296220f, 0.03715863f, 0.22568256f, 0.08263705f, 0.05511402f, -0.00159057f, 
    0.09458818f, -0.01717387f, -0.10201786f, 0.03817863f, -0.00567765f, -0.03288291f, -0.13481568f, 0.04781343f, 
    0.07658020f, 0.04674238f, -0.03027029f, -0.01510005f, 0.00519932f, 0.04047040f, 0.07008003f, 0.07087373f, 
    0.14344227f, -0.00000965f, 0.00291655f, -0.02419540f, 0.04632683f, 0.01182091f, -0.03382900f, 0.05123530f, 
    -0.00457898f, 0.08210750f, -0.00465390f, 0.01092273f, -0.01381579f, 0.07410350f, 0.05235391f, 0.05344130f, 
    -0.29012612f, 0.03186423f, 0.06910486f, 0.02963760f, -0.06255979f, 0.04841777f, 0.06748562f, 0.01271380f, 
    -0.01222364f, -0.01934751f, 0.07051510f, 0.00811691f, 0.04537165f, 0.05289822f, 0.09862797f, 0.00207673f, 
    0.08380048f, -0.06644703f, 0.08399168f, -0.19581769f, 0.20197169f, -0.37383738f, -0.10492772f, -0.06933125f, 
    0.05708145f, -0.09238294f, 0.10236160f, -0.00161007f, -0.10540397f, 0.03115755f, -0.10470771f, 0.01242856f, 
    0.04536557f, 0.10873057f, 0.03870875f, -0.00987704f, 0.02037677f, -0.02040746f, -0.06577934f, -0.03627847f, 
    0.16333328f, -0.27529860f, 0.00518885f, 0.05007563f, 0.01072966f, 0.06127030f, 0.03239947f, 0.07314767f, 
    -0.04703040f, -0.02257390f, 0.07374921f, -0.00459766f, -0.01278536f, -0.02623998f, 0.01271119f, -0.02075219f, 
    0.00161760f, 0.02037026f, -0.00254871f, -0.06715718f, 0.31635281f, -0.09986497f, 0.01070193f, 0.05570368f, 
    0.02904099f, 0.02337880f, -0.00188038f, 0.05694903f, 0.09036664f, 0.06933904f, -0.02136916f, -0.04354126f, 
    -0.06613301f, -0.02645510f, -0.03229662f, -0.00095863f, 0.01791325f, 0.01056284f, -0.05415582f, 0.05508916f, 
    -0.22687052f, -0.12584372f, -0.06488375f, -0.27072260f, 0.13730751f, 0.01860125f, -0.10005580f, 0.02749134f, 
    -0.17081842f, -0.00895809f, -0.08346476f, -0.10135184f, 0.09045389f, 0.11453255f, 0.00493779f, 0.04101727f, 
    -0.03066305f, -0.07786426f, 0.04058059f, 0.09907374f, -0.14709590f, 0.15419106f, -0.05292271f, 0.10905997f, 
    -0.04795003f, -0.09492563f, 0.04192350f, -0.00373515f, 0.03265657f, 0.06183222f, -0.03919858f, 0.01859819f, 
    0.02971490f, -0.08963536f, 0.05575206f, 0.00826012f, -0.03004104f, -0.03273218f, -0.06970049f, -0.00148614f, 
    -0.03773345f, -0.19193639f, -0.07792860f, -0.20928025f, 0.10745806f, -0.07758378f, 0.04095001f, -0.04308910f, 
    -0.08277674f, -0.13507357f, -0.02251107f, -0.07828005f, -0.12866722f, 0.01635966f, -0.02938174f, 0.05263744f, 
    0.05082827f, 0.12375838f, 0.06968568f, 0.08090089f, -0.28114066f, 0.23853436f, 0.04004557f, 0.09326657f, 
    0.00532127f, 0.04922468f, -0.03129697f, 0.00507130f, 0.11371125f, -0.03796117f, -0.00281635f, 0.03160788f, 
    0.05706581f, 0.08165784f, -0.02793104f, -0.02339519f, 0.05877469f, -0.10859961f, 0.01673058f, -0.03686319f, 
    -0.09448166f, 0.19804962f, -0.09887540f, -0.05075054f, -0.24115804f, -0.05588064f, 0.07087369f, 0.09314446f, 
    0.04603878f, 0.07200488f, -0.02704210f, 0.02012870f, -0.00260185f, -0.06541765f, -0.00481337f, -0.02167680f, 
    -0.03172202f, 0.16293046f, 0.10733391f, 0.10831197f, -0.22166857f, 0.16774297f, -0.08587830f, 0.09044385f, 
    -0.26351357f, 0.07055226f, 0.02317206f, -0.02135082f, 0.02041422f, 0.00097628f, 0.00433080f, 0.04300951f, 
    0.02479490f, 0.01649203f, -0.07669643f, 0.01500381f, -0.05426532f, -0.01753616f, -0.01901269f, 0.02910623f, 
    -0.31053469f, 0.02984546f, 0.08292876f, 0.04027447f, 0.06111193f, 0.14894052f, -0.00157254f, 0.15507492f, 
    0.07748367f, -0.15045683f, -0.14200261f, 0.05585898f, -0.23579642f, -0.06861356f, -0.01227584f, 0.15075129f, 
    -0.00997405f, 0.12053768f, 0.17488439f, 0.07498025f, 0.06143910f, 0.07752462f, 0.04367999f, -0.19510381f, 
    0.18144637f, 0.00475008f, -0.03587611f, 0.01264476f, -0.03329628f, -0.02120746f, -0.03232910f, -0.13664341f, 
    0.05994963f, -0.09207637f, -0.05605521f, -0.10189939f, 0.09295563f, 0.07223538f, 0.05293074f, 0.06211010f, 
    -0.01600862f, -0.34626585f, -0.02464341f, -0.22339801f, 0.06141449f, -0.02751685f, 0.05970286f, -0.08668030f, 
    0.03752897f, -0.02908071f, -0.00951800f, 0.02209195f, 0.03179549f, 0.10255741f, 0.00914032f, -0.02965038f, 
    0.06953623f, -0.04561737f, -0.10594529f, -0.00948917f, -0.00542682f, 0.03786905f, -0.10709741f, -0.17375852f, 
    -0.08842119f, 0.03156402f, 0.00698098f, 0.08131532f, -0.12470190f, -0.06022172f, -0.02374012f, 0.00562894f, 
    -0.10438245f, -0.07075700f, -0.10508846f, 0.01680153f, -0.13257580f, 0.09503470f, 0.04991871f, 0.04464635f, 
    0.18456179f, -0.08960390f, 0.03295160f, 0.09358317f, 0.19998084f, 0.08490258f, 0.04415970f, -0.07617225f, 
    0.02089786f, -0.12271792f, -0.01904596f, -0.04194055f, -0.02622413f, -0.10529812f, -0.10026661f, -0.01641336f, 
    0.09374735f, -0.08820510f, -0.01689980f, -0.07140128f, -0.06020797f, -0.45718974f, 0.05069803f, 0.05493164f, 
    -0.00456829f, 0.07503617f, 0.06526900f, 0.07421047f, 0.02797766f, 0.06296417f, 0.06475978f, 0.00967095f, 
    -0.00039475f, 0.06827798f, 0.11330754f, -0.03568441f, 0.04637191f, -0.07110453f, 0.05483516f, -0.07135607f, 
    0.21373065f, -0.18748485f, -0.07238602f, 0.19248973f, 0.03091484f, -0.13424510f, 0.17798975f, -0.03016232f, 
    0.02604099f, -0.10652096f, 0.07881179f, 0.02361633f, 0.02652262f, 0.01163888f, 0.15315795f, 0.05721011f, 
    0.04939054f, 0.18305463f, -0.04951127f, 0.04573765f, -0.00818643f, -0.08280642f, 0.02445062f, 0.15384516f, 
    0.08432347f, 0.00993852f, 0.05826795f, 0.00647948f, -0.08224819f, 0.04670226f, 0.02720050f, 0.06182162f, 
    0.04237344f, 0.12145559f, 0.07606477f, 0.04321432f, -0.02469342f, 0.05980345f, -0.00930020f, -0.01978621f, 
    -0.09849979f, 0.02059457f, -0.06964834f, 0.15172221f, -0.10707648f, -0.06314927f, 0.01879078f, 0.01368244f, 
    0.06026222f, -0.02467636f, -0.04594834f, 0.01194574f, -0.00234097f, 0.01487128f, -0.02114393f, 0.01634524f, 
    -0.08090263f, 0.01380607f, -0.12322632f, -0.05477296f, -0.19748004f, 0.17461340f, 0.05597688f, 0.04501577f, 
    -0.01833111f, 0.04242415f, 0.02591438f, 0.03567853f, 0.10377359f, -0.00920339f, -0.04766589f, 0.01633930f, 
    -0.06867950f, -0.05002696f, 0.05427861f, 0.05311680f, 0.06048911f, -0.14656074f, 0.05632174f, -0.03786346f, 
    0.01035884f, -0.13168931f, -0.09571976f, 0.01225523f, 0.02358417f, 0.04408639f, 0.02528541f, 0.01394663f, 
    -0.01591317f, 0.00779109f, -0.00913769f, -0.04344286f, 0.04943611f, 0.05352051f, -0.13529550f, 0.04618449f, 
    0.06571735f, -0.04098127f, 0.07025664f, -0.00659556f, 0.07120885f, -0.07293392f, -0.03772942f, 0.01190002f, 
    0.13516995f, -0.02423843f, 0.07673405f, 0.03155587f, -0.07801665f, -0.09528576f, -0.01084514f, -0.02268596f, 
    -0.01388652f, 0.02018310f, 0.06298130f, 0.01249157f, 0.02912769f, 0.06269853f, 0.00690245f, 0.10190613f, 
    -0.25682512f, 0.16708645f, 0.11835005f, 0.07755955f, -0.24115041f, 0.01902473f, -0.05321097f, 0.00741555f, 
    -0.01778503f, 0.07782818f, -0.01603158f, 0.02890916f, 0.00202602f, 0.05399268f, -0.07540942f, 0.00688743f, 
    0.06746957f, -0.06379182f, -0.04559555f, -0.10716054f, -0.06216092f, -0.04572626f, -0.01947626f, 0.00103905f, 
    0.07350094f, 0.01186350f, 0.07420294f, 0.00617627f, -0.01965953f, -0.06190711f, -0.06504250f, -0.00967701f, 
    -0.03421914f, 0.01157760f, -0.02117403f, 0.04692617f, 0.00716521f, 0.12221006f, 0.11076385f, 0.00676588f, 
    0.09193933f, 0.03439131f, 0.07842104f, 0.00537902f, 0.12415187f, 0.05664323f, -0.02858839f, -0.05163169f, 
    0.00076882f, -0.00022932f, 0.00017452f, 0.00347748f, 0.02576657f, -0.02249974f, -0.02477381f, 0.00285003f, 
    -0.02138522f, -0.02988985f, -0.01381394f, -0.00751140f, 0.03239717f, 0.11274890f, 0.07651447f, 0.12872775f, 
    0.06093834f, -0.00360277f, 0.05875952f, -0.02341726f, 0.05994224f, -0.04815617f, -0.09673163f, 0.01801527f, 
    -0.05188460f, -0.04800005f, -0.02940018f, 0.02441569f, -0.01600484f, 0.02998985f, -0.00377983f, -0.01234211f, 
    -0.18523414f, -0.11676505f, -0.12640794f, -0.10565189f, 0.01826578f, -0.03617430f, -0.04830723f, -0.02046493f, 
    -0.01707433f, -0.07543241f, -0.04378065f, -0.00389006f, -0.01534185f, -0.02000839f, -0.00320611f, 0.02183431f, 
    -0.01997433f, -0.04483448f, -0.02988181f, 0.04032088f, 0.01909056f, 0.00763274f, -0.07940173f, -0.04832390f, 
    -0.02715556f, -0.03785417f, -0.03430871f, -0.04335586f, -0.03408746f, -0.02594848f, -0.04469578f, -0.00132805f, 
    0.02558435f, -0.01213051f, 0.00033556f, -0.02951999f, 0.01168563f, -0.06709746f, 0.01706392f, -0.00503200f, 
    -0.11874023f, 0.10163438f, -0.10049311f, -0.03328376f, -0.12303099f, -0.02238645f, -0.03384955f, 0.03709985f, 
    -0.04173887f, -0.11532027f, -0.03880019f, -0.00539892f, -0.02336781f, 0.03449834f, -0.04386691f, 0.01294368f, 
    -0.03433436f, 0.01774238f, 0.00117552f, -0.05257884f, 0.08390596f, -0.12484630f, 0.02343651f, -0.06012153f, 
    -0.05855715f, -0.03559278f, -0.06487997f, 0.00737032f, -0.05440430f, -0.00959392f, -0.00307196f, -0.01729260f, 
    -0.01188926f, -0.03367351f, -0.08190040f, 0.00252835f, 0.01490697f, -0.01017695f, -0.00111719f, -0.05557379f, 
    -0.22437623f, 0.07957599f, -0.08466964f, 0.01948502f, 0.06854371f, -0.06934718f, 0.00344566f, -0.04975576f, 
    -0.03673740f, -0.04329331f, 0.02525077f, 0.08793557f, -0.02913420f, -0.03412583f, -0.00160482f, -0.01394566f, 
    0.02853251f, -0.00310604f, -0.03583650f, -0.02185081f, 0.06827458f, -0.37976050f, 0.00607697f, -0.04600272f, 
    -0.08083428f, 0.00508524f, -0.02940345f, -0.00741533f, 0.01641231f, -0.03249115f, 0.00125508f, -0.02749411f, 
    -0.04763634f, -0.00410632f, -0.03143945f, -0.03299840f, 0.01185289f, 0.00752869f, -0.00630715f, -0.01143190f, 
    -0.04710631f, 0.12368401f, 0.21095552f, 0.05501159f, 0.12118889f, 0.08762086f, 0.07971993f, 0.04755190f, 
    0.01662336f, -0.03372040f, -0.03399672f, 0.02296117f, 0.06495990f, 0.00278753f, -0.08676632f, -0.00730674f, 
    0.00192079f, 0.00034692f, 0.04101788f, 0.00925085f, 0.17015477f, -0.06330150f, 0.09541652f, 0.02075114f, 
    0.07450549f, 0.05371310f, 0.02901782f, -0.05051317f, -0.06317811f, 0.03860895f, -0.01560020f, -0.05740878f, 
    0.01210411f, 0.00334350f, -0.00321165f, -0.02240238f, 0.03678086f, -0.01031641f, 0.03225223f, -0.02617253f, 
    0.15283214f, -0.00016733f, 0.04771243f, -0.04450467f, 0.15074651f, -0.16368146f, 0.04698218f, 0.02436376f, 
    0.01990722f, 0.03751183f, -0.01059074f, 0.05515734f, -0.09806275f, 0.05796301f, -0.02861581f, -0.03489538f, 
    0.02455500f, 0.03033568f, -0.04378708f, -0.01214085f, 0.03575015f, -0.11986868f, 0.11301748f, 0.00704637f, 
    0.01867267f, -0.00174414f, -0.05482114f, 0.00122825f, -0.01583966f, -0.01998279f, 0.03288944f, 0.05851978f, 
    -0.02790328f, 0.04037521f, -0.03746279f, -0.00073493f, 0.01701345f, 0.02618745f, -0.01992903f, -0.00519574f, 
    0.01705234f, 0.06960241f, -0.17334171f, -0.09405827f, 0.04966117f, 0.00766504f, -0.02390576f, -0.05464138f, 
    -0.05742894f, 0.01084866f, -0.05097697f, 0.00795662f, -0.03350946f, -0.04412756f, -0.00069013f, -0.06710979f, 
    0.01982407f, -0.00642018f, -0.02921799f, 0.01213366f, -0.46269447f, 0.05919474f, -0.11712567f, -0.08147707f, 
    -0.05263193f, 0.04466311f, -0.06141961f, -0.03282945f, 0.00822889f, -0.03403614f, -0.02089445f, 0.05911735f, 
    0.01544177f, -0.04124921f, -0.02374377f, -0.04813119f, 0.03944185f, 0.03548812f, -0.01246029f, 0.03315163f, 
    0.06351802f, 0.08518158f, -0.04756156f, -0.08570861f, -0.00829530f, -0.02709252f, -0.04771148f, -0.10701930f, 
    -0.03427818f, 0.03087050f, -0.00294558f, -0.00242635f, -0.00608422f, -0.02309529f, -0.00413696f, 0.01885244f, 
    0.04835137f, -0.00877390f, -0.02862120f, -0.02725118f, 0.15185374f, -0.08487977f, 0.05658543f, 0.07182202f, 
    0.14173856f, -0.06860417f, 0.07161107f, -0.01908274f, 0.11947592f, 0.03914737f, 0.04477377f, 0.03704108f, 
    0.01261284f, 0.04682201f, 0.02659925f, -0.01959779f, -0.01042465f, 0.04021969f, -0.01139699f, -0.02716575f, 
    0.08494945f, 0.02606485f, 0.17924370f, 0.02522707f, 0.06060006f, 0.01196620f, 0.07992884f, -0.03996422f, 
    0.00888669f, -0.04938565f, 0.02684161f, 0.06017598f, 0.02265424f, 0.00391125f, -0.08018698f, -0.00984582f, 
    -0.00588371f, 0.01440981f, -0.02861288f, -0.02137886f, 0.04606333f, -0.00229148f, -0.11557684f, -0.03120272f, 
    0.02643060f, -0.11780077f, -0.03576748f, -0.04299185f, -0.03736639f, -0.01326738f, -0.02632973f, -0.01907597f, 
    0.01828494f, -0.00822014f, -0.02002063f, -0.03510971f, -0.03208514f, 0.00257421f, 0.00992296f, 0.00779959f, 
    -0.00412818f, 0.12788935f, 0.21015875f, 0.07167611f, 0.21594109f, 0.08903543f, 0.07027274f, -0.05333736f, 
    -0.03213092f, -0.01786627f, -0.03436327f, 0.00855745f, -0.04224178f, -0.04292643f, -0.05528438f, 0.01695114f, 
    0.00262953f, 0.03324562f, 0.03161508f, 0.02282206f, -0.12087322f, 0.05925053f, -0.07648326f, 0.03987401f, 
    0.10393467f, 0.01171853f, -0.04642641f, -0.13935323f, 0.01739525f, -0.00844960f, -0.00693130f, 0.01307444f, 
    0.05245190f, 0.01571433f, -0.07472814f, -0.03212439f, -0.06384223f, 0.03005068f, -0.00901273f, 0.02351598f, 
    0.00598996f, 0.07271563f, 0.15484481f, 0.03268984f, 0.03054316f, 0.02106063f, 0.02918292f, 0.01068808f, 
    -0.03768264f, -0.00616513f, -0.01528516f, 0.03017985f, -0.02849430f, -0.01533812f, 0.00698296f, -0.01373425f, 
    0.00913691f, 0.01475513f, 0.05023723f, -0.05867422f, 0.10132351f, 0.06457850f, 0.14766581f, -0.02249553f, 
    0.06481737f, 0.02052156f, 0.02459085f, -0.05869196f, 0.02018126f, -0.02214343f, -0.01217597f, 0.02516796f, 
    -0.04210186f, -0.03593513f, -0.01497888f, 0.01020635f, -0.00060522f, 0.02287747f, 0.05101807f, -0.00679445f, 
    0.13356654f, 0.11660007f, 0.04699705f, 0.12223368f, 0.04387031f, 0.03524179f, 0.03302090f, -0.02356312f, 
    0.07226311f, -0.01010879f, -0.08699005f, -0.04469797f, -0.04475281f, 0.00414363f, -0.03282307f, -0.03621742f, 
    -0.01375088f, 0.00926611f, -0.01486682f, -0.03914385f, 0.08730160f, -0.22673473f, 0.09318098f, -0.00258839f, 
    -0.09487347f, 0.05300372f, -0.06030491f, -0.03119773f, -0.02208304f, 0.00364826f, 0.01958950f, 0.01046336f, 
    0.00375325f, 0.02163698f, -0.06611922f, -0.06863936f, 0.01263112f, -0.00405045f, 0.01772448f, 0.02117795f, 
    0.09378777f, -0.07276384f, 0.08828446f, 0.07377423f, 0.08773955f, 0.02125198f, -0.02130622f, -0.03028953f, 
    -0.05985337f, 0.01920456f, 0.00737267f, 0.00837994f, -0.05219768f, -0.01209069f, -0.03470884f, -0.05827378f, 
    -0.01448969f, -0.03588902f, 0.01408836f, -0.04416961f, 0.06744656f, 0.01945110f, 0.08388605f, 0.04277829f, 
    0.12376368f, 0.01735910f, 0.01756267f, -0.04984462f, -0.06192514f, 0.03136436f, 0.00738552f, 0.00838600f, 
    -0.00632000f, -0.08997846f, -0.01254985f, -0.02027940f, -0.04530968f, 0.01856047f, 0.07127052f, -0.00073591f, 
    -0.02430280f, -0.05079486f, 0.02823439f, -0.01073613f, -0.06782400f, -0.00610140f, -0.08154282f, 0.01211118f, 
    -0.03076719f, -0.01047772f, -0.02287454f, 0.00973759f, -0.00322237f, -0.01608786f, -0.01948961f, -0.00940553f, 
    -0.01546443f, 0.00408321f, 0.00409584f, 0.01017023f, -0.12363390f, 0.07313434f, -0.22597635f, -0.04687987f, 
    0.13349198f, -0.05743479f, -0.07147403f, -0.02540134f, -0.00856227f, -0.01459701f, -0.03785491f, 0.00250069f, 
    -0.03278641f, 0.01198321f, -0.02312841f, 0.01685336f, -0.10969087f, 0.01404602f, -0.04108890f, -0.01260856f, 
    -0.06261224f, -0.05134019f, -0.17407411f, -0.05185547f, -0.03522475f, -0.10886329f, -0.04428539f, 0.02726560f, 
    -0.00662758f, -0.03055806f, -0.01046347f, -0.03605194f, -0.01592503f, -0.01194448f, 0.00955833f, -0.00484736f, 
    -0.04734129f, -0.05423140f, -0.03643310f, -0.03085455f, 0.04322244f, -0.02017903f, -0.01599262f, -0.08369109f, 
    -0.05924316f, -0.07600593f, -0.08148338f, -0.00439540f, -0.05233468f, -0.07655992f, 0.09556110f, 0.00033219f, 
    -0.05451924f, 0.00566513f, -0.09033374f, -0.00817057f, 0.01409391f, 0.00996660f, -0.03064470f, 0.02173938f, 
    -0.00934549f, -0.13463247f, 0.02741494f, -0.08107893f, -0.15326257f, 0.01570035f, 0.01471355f, -0.01375551f, 
    -0.05013769f, -0.00844479f, 0.06102919f, -0.01676785f, -0.06330304f, -0.03349934f, -0.04406118f, -0.03490029f, 
    0.00281019f, 0.01316187f, -0.03751822f, -0.00839476f, 0.12410094f, 0.01402763f, 0.15843479f, 0.01906379f, 
    0.05109851f, -0.01047690f, 0.01101934f, -0.06331520f, -0.06253342f, 0.01061497f, -0.00026205f, 0.04893975f, 
    -0.00356348f, -0.00042709f, -0.01148141f, -0.01456230f, -0.03714574f, -0.01817949f, 0.05489410f, -0.08724320f, 
    0.00345372f, -0.10059489f, -0.01451813f, -0.03037371f, -0.11049391f, 0.02471015f, -0.00155814f, -0.02568333f, 
    -0.08485221f, 0.00739859f, 0.00706015f, -0.00861523f, -0.05006300f, -0.05278641f, -0.02666846f, -0.00352360f, 
    -0.03360760f, -0.00976552f, -0.04944396f, 0.01054938f, 0.16435443f, 0.20291004f, 0.06300996f, 0.14405175f, 
    0.11475490f, 0.00417426f, 0.07963446f, 0.00348175f, 0.01154654f, 0.01872238f, -0.04254824f, 0.02542486f, 
    -0.00660942f, 0.06105792f, 0.01230126f, -0.01560610f, -0.03991903f, 0.01583020f, -0.01274952f, -0.02776330f, 
    -0.13671602f, -0.07249114f, -0.05575789f, -0.05715048f, -0.08050411f, -0.04412747f, -0.01241653f, 0.02347464f, 
    -0.04091726f, -0.04343208f, 0.00879431f, -0.00090014f, -0.03806420f, -0.00705979f, 0.01396738f, -0.00499010f, 
    -0.02536749f, -0.02879486f, -0.04456129f, -0.01200585f, 0.01256626f, 0.09072395f, -0.04549279f, 0.08381102f, 
    0.09510877f, -0.09472411f, 0.10257620f, -0.10521292f, 0.01261584f, -0.03014273f, -0.10151686f, 0.03478013f, 
    -0.09177724f, -0.04357789f, 0.02735473f, 0.05120394f, -0.02832557f, 0.04714794f, -0.01211996f, -0.03697880f, 
    0.08228450f, -0.14520259f, -0.05938847f, 0.06529940f, -0.10012379f, 0.05083754f, -0.05817125f, -0.02375257f, 
    -0.02308837f, -0.04660397f, -0.03777594f, 0.02126383f, -0.01864868f, -0.02932492f, -0.06358548f, -0.01335648f, 
    0.05311438f, 0.00467091f, 0.06371024f, 0.00284167f, -0.14996016f, 0.01833623f, 0.00127270f, -0.09216977f, 
    -0.05699076f, -0.04557848f, -0.01243979f, -0.05932510f, -0.01837946f, -0.03981889f, -0.02431368f, -0.03273301f, 
    -0.04399848f, 0.02217238f, 0.01002586f, -0.05797479f, -0.01349189f, -0.00055448f, -0.05667676f, 0.04939630f, 
    -0.10324349f, -0.00100574f, -0.03946872f, 0.08555024f, -0.00858936f, 0.09471615f, -0.12233746f, -0.04369955f, 
    0.03791947f, 0.02076369f, -0.00610350f, 0.03739158f, 0.03829866f, -0.04126709f, -0.00946863f, -0.00411998f, 
    -0.00287983f, 0.04168680f, 0.03565478f, 0.03115832f, -0.14993346f, -0.00904756f, 0.03318172f, 0.00963974f, 
    0.00088722f, 0.08901133f, -0.09148272f, -0.01292807f, -0.00496998f, 0.01726777f, -0.01705437f, 0.00257447f, 
    -0.02575826f, -0.04969221f, -0.04383275f, 0.03645295f, -0.05198509f, 0.01485594f, 0.00501646f, -0.00128849f, 
    -0.11659220f, -0.00704646f, -0.07260761f, -0.11442602f, -0.12956634f, 0.01275243f, 0.00055340f, 0.03309634f, 
    -0.00706084f, 0.01782303f, -0.00920184f, -0.08375964f, -0.00845213f, -0.03829254f, -0.01381417f, -0.12418566f, 
    -0.00556961f, 0.01013530f, 0.00012852f, 0.02871945f, 0.01548289f, 0.09371904f, 0.05191408f, 0.00023181f, 
    0.00800502f, -0.03602562f, -0.00187539f, 0.01706160f, -0.02810509f, -0.00480831f, -0.02613041f, 0.00251590f, 
    0.04327264f, -0.00430761f, 0.00358908f, 0.02589040f, 0.01476025f, -0.02181306f, 0.03140370f, 0.02718261f, 
    0.21910745f, -0.28741986f, 0.07801110f, 0.04952491f, -0.02946083f, 0.04452561f, 0.03828624f, -0.00250324f, 
    -0.05520628f, 0.00236278f, -0.01813060f, -0.01638161f, -0.02704279f, -0.01157627f, 0.00419105f, -0.06060967f, 
    0.10027853f, -0.03198593f, -0.01096292f, -0.00397525f, 0.07257075f, -0.12424856f, 0.01915257f, 0.02995563f, 
    -0.12913695f, 0.05619975f, -0.04040841f, 0.00338026f, -0.00857543f, -0.01319847f, -0.00159927f, 0.04592794f, 
    -0.00559177f, -0.02222586f, -0.05037433f, 0.05585202f, 0.06843492f, -0.01298050f, -0.02735097f, 0.00804379f, 
    0.18858925f, -0.01506582f, 0.17184646f, 0.01503632f, 0.06326611f, 0.05010816f, 0.08074024f, -0.02480892f, 
    -0.00130987f, -0.00704018f, -0.00094853f, 0.06285488f, -0.03304772f, 0.01468091f, -0.07470893f, -0.01512984f, 
    0.06564574f, -0.01890435f, 0.03712715f, -0.01058179f, -0.01737787f, 0.08744868f, -0.11074103f, -0.12618133f, 
    -0.13091803f, 0.02358164f, -0.02766731f, -0.05732999f, 0.02241986f, -0.02717093f, -0.01987115f, 0.03939547f, 
    0.00741470f, -0.00691933f, -0.01916618f, 0.01012959f, -0.02472716f, -0.00141537f, -0.00795097f, -0.01256241f, 
    -0.01247341f, 0.06208571f, 0.02702511f, 0.04167007f, 0.12294771f, -0.02677668f, 0.01752274f, -0.04254351f, 
    -0.00157541f, -0.00231113f, 0.00413389f, 0.03389576f, -0.12352611f, -0.05708112f, -0.01538909f, -0.05220025f, 
    -0.00066643f, 0.01907120f, -0.04537459f, -0.02487338f, -0.26639557f, -0.05192333f, -0.06056101f, -0.12674841f, 
    -0.18423772f, 0.03113233f, -0.00313889f, 0.00733615f, -0.02572223f, -0.05861098f, -0.01635677f, -0.02127521f, 
    0.00896634f, 0.02783922f, -0.02378584f, -0.03066688f, 0.05402001f, -0.01184137f, 0.00859167f, 0.04435394f, 
    -0.05208345f, 0.03058461f, -0.18089241f, 0.05024511f, 0.07942923f, -0.04434730f, -0.06764725f, -0.08386421f, 
    -0.01656830f, -0.03283634f, -0.07310100f, 0.07393437f, -0.00404892f, 0.04608195f, -0.06204373f, -0.00063986f, 
    -0.07557367f, -0.06475191f, 0.00045834f, -0.00216310f, -0.20095402f, 0.06742074f, -0.00224028f, -0.09912546f, 
    -0.06184823f, 0.01896795f, 0.00566047f, -0.04121708f, -0.00259296f, -0.01024443f, -0.01335144f, 0.00670897f, 
    0.03042536f, -0.06840023f, -0.03587567f, 0.01567440f, -0.02317922f, -0.01044423f, 0.00521817f, -0.00648939f, 
    0.05650457f, -0.13727777f, 0.14005899f, 0.05776356f, -0.01121907f, 0.05141038f, 0.02930392f, -0.07310236f, 
    0.04017834f, 0.04466167f, 0.00412371f, 0.00685847f, -0.01483417f, -0.04229281f, -0.10115017f, -0.02759041f, 
    -0.02410662f, -0.02017330f, -0.02510257f, 0.04009661f, 0.14432575f, 0.09841586f, 0.20304593f, -0.06012384f, 
    0.11038729f, -0.10830430f, 0.08533220f, -0.08596574f, -0.01496013f, 0.01282240f, -0.02569789f, 0.05426264f, 
    -0.03351286f, 0.03022270f, -0.05002653f, -0.01938565f, -0.05245576f, 0.07818399f, 0.02655466f, -0.02867603f, 
    0.02271348f, 0.04229591f, 0.18909439f, 0.05217370f, 0.09242150f, -0.02329026f, 0.02073264f, 0.00081205f, 
    0.00965162f, -0.04404890f, -0.01404357f, 0.02210575f, 0.00492659f, -0.03101800f, -0.06023159f, -0.03566157f, 
    0.02778455f, 0.01081273f, -0.02075560f, -0.00922891f, 0.07444517f, -0.01486624f, 0.01499408f, 0.06037262f, 
    0.09535070f, -0.03025871f, 0.01591778f, -0.02192388f, -0.04969013f, -0.03278034f, -0.04980258f, 0.07099469f, 
    -0.07093985f, -0.07282344f, -0.02664429f, -0.05736981f, -0.03940932f, -0.00998550f, 0.00836220f, -0.00937726f, 
    0.07101078f, -0.15513961f, 0.05281539f, 0.02335661f, -0.03721114f, 0.04994200f, -0.07460159f, -0.03326565f, 
    0.05645473f, 0.02460046f, -0.01057967f, 0.02570941f, 0.01466593f, -0.03268662f, -0.01676271f, 0.03342973f, 
    0.04493089f, 0.04126299f, 0.04572765f, 0.06161559f, 0.02352676f, -0.19142438f, -0.06768445f, 0.00371077f, 
    0.11965592f, -0.04403083f, -0.04590835f, -0.02449406f, -0.00087761f, -0.04376692f, 0.01288337f, 0.01531728f, 
    0.00380722f, -0.00928282f, -0.06014240f, -0.00767047f, 0.00047456f, -0.05034404f, 0.01367172f, -0.00421430f, 
    -0.02172469f, 0.15078279f, -0.01950521f, 0.03586549f, 0.09550902f, -0.05694722f, -0.10081173f, -0.04721230f, 
    0.07213911f, -0.04119076f, 0.03353040f, 0.04823724f, -0.01123058f, 0.00903501f, -0.07152903f, -0.01175678f, 
    0.00355875f, 0.08992565f, 0.04148535f, -0.05251814f, -0.28050068f, 0.10489115f, 0.07647539f, 0.05624409f, 
    0.10102158f, 0.04038319f, -0.06252543f, -0.03619952f, 0.01908559f, -0.00689429f, 0.04595127f, -0.02290110f, 
    0.03899636f, -0.02646547f, -0.07226077f, 0.08407930f, -0.07318105f, 0.04257143f, 0.02818257f, -0.07050785f, 
    -0.12098569f, 0.06826082f, 0.05646034f, -0.06898254f, -0.08408625f, -0.06334095f, -0.07785409f, 0.00161349f, 
    -0.00087642f, 0.00089521f, 0.01357962f, 0.02085607f, -0.03705598f, 0.02049700f, -0.02393198f, -0.00028879f, 
    0.02815093f, -0.05802677f, -0.04206531f, 0.00709835f, -0.00427465f, -0.01990048f, -0.16599613f, -0.11821210f, 
    -0.08642023f, -0.06705714f, -0.07031584f, 0.00138299f, -0.00287056f, -0.05128154f, -0.01519500f, 0.00202490f, 
    -0.00887836f, -0.01749167f, -0.01000684f, -0.00329407f, -0.02231386f, -0.05991602f, 0.00369026f, 0.03059583f, 
    0.08037788f, 0.15599364f, 0.01786022f, -0.00272014f, 0.12314636f, -0.00838349f, 0.05416171f, -0.01878329f, 
    0.02204542f, 0.00492767f, -0.05710830f, -0.01764563f, -0.00039496f, -0.02780943f, -0.00009675f, 0.00149230f, 
    0.03169392f, 0.02775462f, -0.04200125f, 0.00369922f, 0.00830609f, -0.01696551f, 0.11191877f, 0.03186111f, 
    -0.01230747f, 0.04548412f, 0.01948083f, -0.01558262f, -0.01325224f, 0.00120707f, -0.04175815f, 0.03983399f, 
    0.01041501f, -0.02143166f, -0.01351030f, -0.03211303f, 0.02319631f, 0.00431677f, -0.03029022f, -0.01253568f, 
    0.07127079f, -0.28719473f, -0.03727093f, -0.10720136f, -0.15495397f, 0.01535785f, -0.02212260f, -0.01197622f, 
    -0.02574665f, -0.03931771f, 0.01288317f, -0.05226716f, -0.02288680f, -0.00927033f, -0.04557874f, 0.01850280f, 
    0.13039874f, -0.01602845f, 0.01880500f, -0.06283467f, 0.00526941f, -0.03081025f, 0.03287499f, -0.01969447f, 
    0.04207765f, -0.00357404f, -0.07755086f, -0.04369113f, -0.00259237f, -0.05083042f, -0.00484733f, -0.00424845f, 
    -0.00612697f, -0.02723852f, -0.01325071f, 0.00486901f, -0.01265073f, -0.03304195f, 0.01123357f, -0.01856871f, 
    0.01905813f, -0.04706711f, 0.09875512f, 0.05916337f, 0.08906224f, -0.05255898f, -0.00400064f, -0.00222901f, 
    -0.05103000f, -0.00513673f, -0.00502770f, -0.02844791f, 0.01566565f, 0.00406266f, -0.02726513f, 0.03217946f, 
    -0.03192233f, 0.00228634f, 0.04349804f, 0.06859498f, -0.12231958f, 0.04529299f, 0.10861423f, -0.12311733f, 
    -0.08660972f, -0.01410915f, -0.01089146f, 0.00608750f, -0.01070149f, -0.06453022f, 0.06494842f, 0.04073716f, 
    -0.00859681f, 0.02558993f, -0.03043705f, -0.12162408f, 0.02774557f, -0.07065215f, 0.03125805f, -0.09980483f, 
    -0.07959642f, -0.06239392f, -0.03118909f, 0.08729668f, 0.16036829f, 0.09178030f, 0.03863219f, -0.03926910f, 
    -0.00814858f, -0.02846964f, 0.00780599f, 0.01864204f, 0.02511117f, 0.04518948f, -0.04384894f, -0.02541549f, 
    0.06762531f, 0.05587976f, 0.01639030f, -0.10352079f, -0.15088256f, -0.15153953f, -0.07198856f, -0.06880242f, 
    0.08121067f, 0.05619692f, 0.03345894f, -0.09620728f, -0.00587796f, -0.01840570f, 0.05786081f, 0.01549370f, 
    0.03820966f, 0.03513724f, 0.07243762f, -0.04548668f, 0.03866957f, 0.02543576f, 0.00352541f, 0.00083829f, 
    0.13869002f, 0.09127814f, -0.10814763f, 0.08207314f, 0.07554377f, 0.00995364f, 0.00022255f, -0.00899833f, 
    -0.00702408f, -0.03471497f, 0.05052720f, -0.06957763f, -0.02024701f, -0.01049593f, 0.05257078f, 0.01472239f, 
    -0.02403708f, -0.00067589f, 0.07258318f, -0.04147986f, 0.06133200f, 0.11783773f, -0.10908261f, 0.12892805f, 
    0.06875119f, -0.01063308f, -0.07420949f, -0.03653887f, -0.06864419f, 0.00843259f, -0.10415329f, 0.03156621f, 
    -0.05246758f, 0.02292498f, 0.00816311f, 0.08377451f, -0.00590602f, 0.01881833f, 0.02764838f, 0.04529260f, 
    0.08670627f, 0.19293432f, -0.15129441f, 0.03606976f, -0.06896131f, -0.08321733f, 0.04185898f, -0.01572025f, 
    -0.08054371f, 0.03278965f, 0.06854028f, -0.04472625f, 0.03742183f, 0.04172404f, 0.02204805f, -0.05682011f, 
    -0.01434854f, -0.06874783f, 0.05575563f, 0.05912813f, -0.04793517f, -0.17238620f, -0.25474513f, -0.00214148f, 
    0.14047849f, 0.07788861f, 0.04870645f, 0.01226102f, -0.03463342f, -0.05570747f, 0.02836003f, 0.03383041f, 
    0.06725743f, 0.05631161f, 0.02024123f, 0.00635876f, 0.02997258f, 0.00001073f, 0.05969936f, -0.04336533f, 
    -0.10648009f, -0.13776255f, 0.17841753f, -0.00066442f, 0.02358347f, -0.03026737f, -0.05529729f, 0.02855258f, 
    -0.10649199f, 0.00432373f, 0.01958845f, -0.02752150f, -0.10104305f, 0.01876875f, 0.06426252f, -0.01869645f, 
    0.00404778f, -0.02919919f, -0.01053625f, 0.00066630f, 0.03292223f, -0.16286342f, 0.00543391f, -0.04488087f, 
    0.01609993f, 0.04979673f, -0.04676990f, -0.03936647f, -0.03012803f, -0.01791136f, 0.00022966f, 0.05515651f, 
    -0.05003203f, 0.05829331f, 0.03457814f, 0.03362030f, 0.00038955f, -0.01488439f, -0.02244261f, 0.04029144f, 
    0.08911165f, -0.01919939f, -0.08158413f, -0.10017088f, -0.07602576f, 0.04511535f, 0.06935160f, 0.00290211f, 
    -0.18001483f, -0.00899757f, 0.00559953f, -0.00720371f, 0.08580598f, 0.04021177f, -0.05266897f, 0.00035348f, 
    0.03234785f, -0.04734209f, 0.01358988f, 0.01066273f, -0.00547219f, -0.02708945f, 0.04798609f, 0.10278857f, 
    0.09812580f, -0.13564618f, -0.02513050f, -0.03594476f, -0.00818415f, 0.04303357f, 0.01344524f, -0.05452267f, 
    0.01076710f, 0.02980128f, -0.02830694f, 0.03749860f, 0.00873656f, 0.02539551f, 0.05946858f, 0.05093640f, 
    -0.14825869f, -0.06243066f, -0.06936336f, -0.22889470f, -0.08435421f, 0.04537082f, -0.04741983f, -0.01915590f, 
    0.08617210f, -0.06117002f, 0.04329672f, 0.04091229f, -0.03109351f, 0.03331001f, -0.03120883f, 0.04199562f, 
    0.03602411f, 0.01371596f, 0.03187246f, 0.00579952f, 0.01974998f, 0.08938876f, -0.23108482f, -0.02359290f, 
    0.05440767f, 0.08107127f, 0.07124259f, -0.07480126f, 0.02059485f, -0.01491188f, -0.02825180f, -0.02630284f, 
    0.01946203f, 0.04591980f, 0.02901429f, 0.08025414f, 0.01409892f, -0.01430078f, 0.10356133f, -0.03002600f, 
    -0.08950503f, 0.02266564f, -0.20174657f, 0.04482815f, -0.04527392f, 0.07048958f, -0.06083363f, -0.11510707f, 
    -0.05721807f, 0.02443292f, 0.01457851f, 0.05748096f, -0.12176060f, 0.08044458f, 0.02084408f, 0.00945485f, 
    -0.01584588f, -0.03504363f, 0.03351676f, 0.03003319f, -0.20504752f, -0.08755928f, 0.00782289f, -0.02443167f, 
    0.06654985f, -0.00043976f, 0.01635594f, -0.02173956f, -0.05215186f, 0.01910657f, 0.09648228f, 0.02245855f, 
    -0.06040297f, 0.06808116f, 0.10833365f, -0.00011035f, 0.05059576f, 0.04856637f, -0.08185913f, -0.02391658f, 
    -0.07820333f, 0.03547825f, 0.07058039f, 0.06274059f, 0.12148263f, -0.04861287f, -0.03784461f, 0.06495323f, 
    0.01263301f, 0.07081831f, 0.05865077f, 0.00028314f, -0.10089799f, -0.02823397f, 0.06865041f, -0.02218987f, 
    -0.00981374f, 0.04181823f, 0.02638564f, -0.00030406f, 0.02145072f, 0.00334139f, -0.06525491f, -0.15942957f, 
    -0.09390607f, -0.03756430f, -0.01879625f, -0.01476475f, -0.03001116f, -0.09039059f, -0.01534161f, 0.04436745f, 
    0.03237131f, 0.01230331f, 0.01965652f, 0.03780636f, 0.04979204f, -0.00388187f, -0.06491274f, 0.03107141f, 
    -0.04656700f, 0.07424242f, 0.18378249f, -0.13200447f, -0.11058319f, -0.00094229f, 0.01130688f, -0.03508770f, 
    -0.03877042f, -0.10881816f, 0.02485693f, 0.04387914f, -0.09863536f, 0.01921922f, -0.00277505f, -0.06789011f, 
    0.00975532f, -0.07021976f, -0.19041103f, -0.08962470f, -0.10799890f, -0.07013168f, -0.21148252f, -0.22873773f, 
    -0.10618030f, -0.00195223f, -0.05982520f, -0.09225580f, 0.02606906f, -0.04291987f, 0.11563252f, -0.00316158f, 
    0.10879380f, -0.08893159f, 0.08280035f, 0.01723133f, 0.03694795f, -0.11752138f, 0.02605267f, 0.00627458f, 
    -0.14933930f, -0.04441811f, 0.14508091f, -0.02809476f, -0.03485119f, -0.02856262f, 0.02901737f, 0.01647908f, 
    -0.02177684f, -0.06079183f, 0.00886165f, 0.01252810f, 0.04560704f, -0.01272113f, 0.01995574f, 0.02542958f, 
    0.01600682f, -0.02879165f, -0.03519186f, 0.01846403f, -0.22494961f, 0.06075999f, 0.09764841f, -0.09695012f, 
    -0.12627320f, -0.03170739f, 0.03422258f, 0.01694097f, 0.07024352f, -0.04711172f, -0.00247473f, -0.02220201f, 
    0.02936810f, 0.02510508f, -0.01285167f, -0.02668039f, -0.02812601f, 0.01895740f, -0.04444574f, 0.02610717f, 
    -0.15336427f, 0.06648128f, 0.06554228f, -0.09804862f, -0.05212653f, -0.03773895f, -0.00182303f, 0.01214538f, 
    0.02220159f, -0.02441587f, 0.05441466f, 0.00543089f, 0.07624952f, -0.06782729f, -0.00635009f, 0.00984742f, 
    0.00596821f, -0.04875538f, -0.04732552f, -0.03564165f, -0.00622369f, 0.11173194f, -0.00519070f, -0.04871035f, 
    -0.02745134f, -0.01547689f, 0.00161965f, -0.04888007f, -0.03477501f, 0.00655440f, 0.02165998f, 0.02206060f, 
    0.05086055f, 0.01311684f, -0.02041771f, 0.02910810f, 0.02706048f, -0.08512698f, -0.02240582f, 0.07277695f, 
    -0.11875347f, -0.10004870f, 0.10482678f, -0.04224752f, 0.06122100f, 0.00916070f, -0.01610520f, 0.05466027f, 
    -0.01009551f, -0.04881948f, 0.02920987f, 0.01200484f, 0.08879773f, 0.03768816f, -0.00863216f, 0.04363273f, 
    -0.00012046f, 0.03128567f, -0.22312482f, 0.05119122f, -0.16404153f, -0.12489075f, 0.12806988f, -0.18697619f, 
    -0.08217686f, 0.03368485f, -0.06245242f, 0.02449905f, -0.00957810f, -0.05707738f, -0.02387655f, 0.02355146f, 
    -0.05034337f, 0.04029458f, -0.04929525f, -0.03332500f, 0.03015560f, 0.03004140f, -0.21615916f, -0.01981948f, 
    0.05334254f, 0.02583907f, 0.02432587f, 0.08389064f, 0.09738967f, -0.07409178f, -0.05234670f, -0.03203646f, 
    0.00811054f, 0.01783740f, -0.08239050f, -0.05832981f, 0.03220382f, 0.01960255f, -0.00280656f, 0.00067180f, 
    0.02959460f, 0.00639872f, 0.01015398f, 0.04059702f, -0.02673628f, 0.17222555f, -0.00523167f, 0.02409646f, 
    0.02058090f, 0.06912109f, -0.04521575f, -0.06813531f, -0.06445459f, -0.13658568f, 0.08341017f, -0.00641695f, 
    -0.00533076f, 0.00789617f, -0.09306026f, -0.06894235f, 0.07189351f, 0.10544965f, -0.02661954f, -0.04017545f, 
    0.07870634f, 0.08069215f, 0.07684291f, 0.05890049f, 0.05247603f, -0.01408990f, 0.03135706f, -0.04535978f, 
    -0.07764993f, -0.04612011f, 0.06469961f, 0.00317626f, 0.03566117f, 0.03029035f, -0.03138045f, -0.11988006f, 
    -0.00941644f, 0.05662427f, 0.03837477f, -0.03066151f, 0.14521547f, 0.08647645f, -0.03212972f, 0.07197821f, 
    0.10462919f, 0.03151885f, -0.05140798f, -0.03293797f, -0.01738490f, -0.00311448f, -0.05547974f, -0.00085666f, 
    -0.06754840f, -0.00089361f, -0.03592103f, 0.00886181f, -0.05836039f, 0.02278439f, 0.03510494f, 0.02335758f, 
    0.14768307f, 0.18151128f, -0.00449729f, 0.08934957f, 0.10932916f, 0.00886422f, 0.05307371f, -0.11392296f, 
    -0.05785967f, -0.03647914f, -0.04742316f, 0.00518994f, -0.02418208f, -0.04955304f, -0.01220433f, -0.03159279f, 
    0.00759162f, 0.05161165f, 0.04658007f, -0.00645383f, -0.13769551f, -0.07827833f, 0.14236403f, -0.00525716f, 
    0.11690006f, -0.00582403f, 0.02104177f, 0.05782764f, -0.03870345f, -0.05715522f, 0.01698545f, -0.02615980f, 
    -0.00795913f, 0.09946895f, 0.06763896f, -0.00255297f, 0.00227659f, 0.01931403f, -0.09478518f, 0.06710802f, 
    0.09944311f, 0.08060544f, 0.06816918f, 0.01901131f, 0.11437698f, -0.03194017f, -0.06979685f, -0.03909805f, 
    -0.02077956f, -0.03039636f, -0.00522427f, 0.01527847f, -0.03850054f, -0.02705507f, -0.05611618f, -0.01349039f, 
    0.00644547f, 0.04099958f, 0.04353860f, 0.03041169f, -0.14500785f, -0.01015516f, -0.02476503f, -0.19976704f, 
    -0.20495564f, 0.04580249f, 0.00704857f, -0.06479852f, 0.04080679f, -0.03002497f, 0.00164010f, 0.00055389f, 
    -0.06728644f, -0.01010282f, 0.00977277f, -0.05249436f, 0.07187508f, -0.06378366f, -0.01833270f, -0.10818247f, 
    0.15985173f, 0.07760227f, -0.04692567f, 0.03856677f, 0.07195101f, 0.01440283f, -0.01909149f, -0.00320893f, 
    -0.03211514f, -0.06921882f, 0.06507600f, 0.06161458f, -0.02293681f, -0.04977025f, 0.04208644f, -0.08115265f, 
    -0.05288171f, 0.01424137f, 0.02870453f, -0.04461005f, -0.09466977f, 0.17389069f, 0.08112562f, -0.07028795f, 
    -0.18237649f, -0.09945451f, 0.01295431f, -0.01329022f, -0.05202703f, -0.05676509f, 0.05572917f, 0.04690098f, 
    0.04775770f, 0.02610220f, 0.03053079f, -0.09061372f, 0.03691033f, -0.10128117f, 0.09171715f, 0.00775812f, 
    0.06671396f, -0.10751470f, 0.00424920f, -0.14610781f, 0.06514049f, 0.07550314f, -0.03467706f, -0.02596326f, 
    0.00710777f, -0.03661713f, 0.11054591f, 0.03472333f, 0.07530495f, -0.02795843f, 0.04203293f, -0.01131549f, 
    -0.08211287f, 0.03549420f, -0.05866993f, 0.02357826f, 0.07331806f, 0.08912898f, -0.04118286f, 0.06345115f, 
    0.05744146f, -0.01616585f, -0.03465802f, 0.02318336f, -0.04772722f, -0.00309075f, 0.06583160f, 0.09797863f, 
    0.04364371f, 0.01254839f, -0.07935940f, -0.02249538f, 0.03719374f, 0.03076171f, 0.02174999f, 0.03279487f, 
    -0.16631155f, -0.03397112f, -0.12852874f, -0.14261466f, -0.12936391f, 0.03781315f, -0.07359306f, -0.06145959f, 
    0.00615906f, -0.02447926f, 0.10622146f, -0.00755810f, 0.06097341f, -0.04343956f, 0.01719983f, -0.05868069f, 
    -0.01739839f, -0.03911195f, 0.02104798f, -0.00136581f, -0.10891362f, 0.04365038f, -0.14014745f, -0.04238882f, 
    -0.11470520f, 0.01855763f, -0.05368729f, -0.16381437f, -0.04308705f, -0.02234208f, 0.07098467f, -0.02729991f, 
    0.02883566f, 0.01103315f, -0.03782112f, -0.01211462f, 0.00953824f, -0.13325466f, 0.03301474f, 0.03082498f, 
    0.10012816f, 0.07890158f, -0.03404228f, -0.03515334f, 0.08584335f, 0.03631157f, -0.00670149f, -0.11297323f, 
    0.02613299f, -0.08856975f, 0.03025527f, 0.03636351f, 0.03267376f, -0.04302141f, -0.05807161f, -0.10412256f, 
    0.01630617f, 0.07794451f, 0.03728462f, -0.04328570f, 0.13038935f, 0.08046318f, 0.08902097f, 0.01014441f, 
    0.07231123f, -0.08055536f, -0.04845016f, -0.04284467f, -0.03028116f, 0.02371310f, 0.02942385f, -0.05756151f, 
    -0.03665334f, -0.09905164f, -0.02426883f, -0.03033168f, 0.02085953f, 0.02961064f, 0.02203742f, 0.03121604f, 
    0.00751342f, -0.05337730f, 0.09739768f, 0.00993282f, 0.08139501f, -0.02312853f, 0.00952171f, 0.00645406f, 
    -0.04616662f, -0.00654606f, -0.02658749f, 0.01048295f, -0.02383728f, -0.05299053f, 0.05491787f, 0.03181020f, 
    -0.06466663f, 0.01101876f, 0.03140907f, 0.01553865f, 0.01415935f, 0.07328940f, -0.07433955f, 0.07407704f, 
    0.10566477f, 0.03384043f, -0.02474885f, -0.06380997f, 0.00869395f, 0.02593578f, 0.03558178f, -0.00601738f, 
    0.00748517f, -0.08269600f, 0.03569259f, -0.00982353f, 0.02527755f, -0.00974528f, 0.06481161f, 0.02111356f, 
    -0.17330642f, -0.04800877f, 0.13390929f, -0.01054475f, 0.06679727f, -0.05332044f, -0.00162282f, 0.04857762f, 
    -0.10761505f, -0.00684833f, -0.01991835f, -0.03401156f, -0.03261369f, -0.00811659f, 0.02883028f, -0.04042546f, 
    -0.08293243f, 0.02451185f, -0.03307556f, 0.00421719f, -0.01564779f, 0.08350921f, -0.08600674f, 0.01882990f, 
    -0.03002135f, 0.02803610f, 0.03572071f, -0.06696717f, 0.02906832f, -0.04072919f, 0.03801978f, 0.01550113f, 
    -0.03306604f, 0.01577934f, 0.04835308f, -0.05062190f, -0.01512738f, -0.01452839f, 0.07289763f, -0.04824929f, 
    -0.01770301f, 0.12889713f, -0.06400227f, -0.11069966f, -0.15407152f, -0.09806201f, -0.01515417f, 0.03179454f, 
    -0.05112688f, -0.02749482f, 0.02922938f, -0.05295064f, 0.04939668f, -0.07137257f, 0.00126417f, -0.05673556f, 
    -0.02559082f, -0.13910452f, -0.00955599f, -0.01539123f, 0.08014313f, 0.10029368f, -0.10972936f, 0.02933082f, 
    0.07956538f, 0.12738906f, 0.06023499f, -0.01858462f, -0.03502133f, -0.03540255f, 0.04280989f, -0.00474411f, 
    -0.01535501f, 0.04586282f, -0.06254356f, -0.04437857f, -0.00932652f, 0.04123977f, 0.04254099f, -0.04016767f, 
    -0.16988833f, -0.11581200f, -0.04092966f, 0.07059361f, 0.04962975f, -0.00491006f, 0.03358822f, -0.05188544f, 
    -0.02502682f, -0.05989608f, 0.05559246f, 0.03123664f, -0.01333677f, -0.02774585f, 0.05370533f, -0.05664358f, 
    0.11902463f, 0.02694099f, 0.03039812f, -0.12821585f, -0.04418318f, -0.01789514f, -0.14505753f, 0.07544864f, 
    -0.00750048f, 0.01481990f, 0.01859679f, -0.05869333f, 0.00920530f, -0.05556810f, 0.03097968f, -0.01311730f, 
    0.03454524f, -0.05621276f, 0.05244881f, -0.06786397f, -0.05211223f, -0.02323558f, 0.06638546f, -0.04140884f, 
    -0.04287841f, 0.11112228f, -0.20282562f, -0.02958064f, -0.01883097f, -0.02575399f, -0.10448124f, -0.06908503f, 
    -0.15122412f, 0.02802818f, 0.00651784f, 0.07749398f, 0.08756963f, 0.02047448f, -0.00138850f, -0.01419939f, 
    -0.12786913f, -0.11245324f, 0.02032640f, -0.04802359f, -0.09082588f, 0.27649274f, -0.00389854f, -0.07537167f, 
    -0.13099359f, -0.02036271f, 0.02591964f, -0.03698661f, 0.00206082f, 0.00217011f, 0.05914223f, 0.01011708f, 
    0.04312387f, 0.08587322f, 0.04410524f, -0.02560316f, 0.01998639f, -0.13217802f, -0.05077222f, 0.15058249f, 
    -0.03850614f, 0.02599366f, 0.10170212f, 0.00189879f, 0.09856706f, -0.08160775f, -0.06595830f, 0.01464021f, 
    -0.03275527f, 0.03501604f, 0.00535106f, -0.05426115f, -0.11159532f, -0.06823788f, 0.07257284f, 0.00951484f, 
    0.01106698f, 0.02111067f, 0.02698835f, 0.01717069f, -0.12636329f, -0.17068146f, 0.10403441f, -0.15616788f, 
    -0.03248578f, -0.01978424f, -0.03161114f, -0.00234139f, -0.04464269f, -0.05588092f, -0.01812916f, 0.00202467f, 
    -0.03268015f, 0.02187194f, -0.04487579f, 0.02046741f, -0.01319866f, -0.00050892f, -0.24228169f, -0.00550932f, 
    -0.03957948f, 0.06298883f, -0.09882326f, -0.08659289f, -0.10757526f, -0.03486589f, 0.00393439f, -0.00673822f, 
    0.02830412f, -0.11978781f, 0.08294851f, -0.03487765f, 0.02372217f, 0.00105613f, 0.02954868f, 0.07747196f, 
    0.04226416f, -0.05908365f, -0.02474296f, 0.09891465f, 0.01345176f, 0.10351200f, 0.07272453f, -0.03665350f, 
    0.11967151f, -0.05966517f, -0.00602278f, -0.06382637f, 0.00215181f, -0.06815840f, -0.04703715f, -0.03755059f, 
    0.07527384f, -0.00955718f, 0.02229403f, 0.00761076f, 0.01463117f, 0.08781410f, -0.08563148f, 0.00810725f, 
    -0.07578992f, 0.00006928f, -0.17026192f, -0.04689415f, -0.14148943f, -0.00065230f, -0.03559409f, -0.16040377f, 
    -0.05374765f, -0.00636532f, 0.08340305f, -0.01080726f, 0.01316932f, -0.09072839f, 0.06796076f, -0.00254253f, 
    -0.01724119f, -0.09742696f, 0.11722180f, 0.02103862f, -0.08002565f, 0.04157692f, -0.22246672f, -0.01948433f, 
    -0.09108695f, 0.03763012f, -0.03342378f, -0.21920262f, 0.00319440f, -0.01650207f, 0.05418805f, 0.01965102f, 
    0.01433264f, -0.00776312f, 0.00439140f, 0.02215179f, 0.01598481f, -0.13394031f, 0.06337605f, -0.02393443f, 
    0.11308660f, 0.07327648f, -0.05826411f, 0.03854026f, 0.04650363f, -0.02916830f, -0.01094208f, -0.14309281f, 
    -0.06731076f, 0.01423893f, -0.01484273f, 0.01812237f, 0.03732197f, -0.09952082f, -0.03275948f, -0.02620794f, 
    -0.00018718f, -0.01519732f, 0.11906312f, -0.02684101f, -0.00563855f, -0.00695962f, -0.00942967f, -0.06643570f, 
    0.04775491f, 0.03993888f, 0.04676930f, -0.10727739f, -0.02159316f, -0.03316862f, 0.04943214f, 0.08738437f, 
    0.00194478f, -0.00025418f, -0.03368277f, -0.10162292f, 0.01409390f, 0.08454520f, 0.02186536f, -0.02652437f, 
    -0.18347421f, 0.08367259f, -0.09400868f, -0.14043248f, -0.25215429f, -0.01635445f, -0.02651240f, -0.01663174f, 
    0.02287233f, -0.05157907f, 0.06586692f, -0.02823018f, -0.06596780f, 0.00167752f, 0.06585105f, -0.05731990f, 
    0.01864937f, -0.06300779f, 0.01237949f, -0.00130458f, -0.08927239f, -0.04841308f, 0.08656409f, -0.03833688f, 
    -0.07216106f, -0.01706047f, 0.00009892f, -0.01881300f, -0.09010800f, 0.07187986f, -0.00217034f, 0.00446239f, 
    -0.00237477f, -0.05294510f, -0.04636906f, 0.00014284f, -0.02847395f, -0.06748172f, 0.06241805f, -0.04647809f, 
    0.11615574f, -0.08057892f, -0.10425475f, 0.11255266f, 0.13071690f, 0.05209318f, 0.03418078f, -0.06727859f, 
    -0.05102576f, 0.00347196f, -0.04375955f, -0.00599498f, -0.02347093f, 0.02587503f, -0.00108525f, -0.00537962f, 
    -0.03491307f, 0.02081745f, 0.09062284f, -0.00461540f, -0.05724525f, 0.07839664f, -0.15073395f, -0.04085464f, 
    -0.08413307f, 0.01614997f, -0.06495122f, -0.07963548f, -0.01918548f, -0.03563760f, 0.03801144f, 0.00415087f, 
    0.00190068f, -0.01379068f, 0.05171667f, -0.00593234f, -0.04111550f, -0.08926594f, -0.00497824f, 0.01993345f, 
    0.11779778f, 0.00039724f, -0.03462151f, -0.06347215f, 0.05497646f, 0.11438103f, -0.05109245f, 0.03071035f, 
    -0.08485419f, 0.08579887f, 0.04842059f, 0.13679823f, -0.00151700f, 0.10262330f, 0.02232951f, -0.05932203f, 
    -0.04698204f, -0.08485039f, -0.02642909f, -0.06180703f, 0.20837244f, 0.13053407f, 0.06735580f, 0.05021627f, 
    -0.00026937f, 0.00159185f, -0.03432288f, 0.02644072f, -0.00625308f, -0.04742008f, -0.05115482f, -0.02180097f, 
    0.08271756f, 0.07347328f, 0.09001920f, 0.04824383f, 0.03495958f, 0.10396693f, -0.04486842f, -0.03077187f, 
    0.03474962f, -0.07593547f, 0.13803338f, -0.16258377f, -0.14006612f, -0.00949560f, 0.06450653f, -0.05688141f, 
    -0.05659686f, 0.05709820f, -0.03050473f, -0.01649203f, -0.08821657f, -0.06843601f, -0.01101289f, 0.00260261f, 
    -0.01015278f, 0.01987740f, 0.00362944f, -0.03086063f, -0.05499576f, -0.14089735f, -0.01497332f, -0.03667744f, 
    -0.07330842f, -0.03288092f, 0.09584280f, 0.00990679f, -0.06326339f, -0.06375872f, -0.06125417f, -0.02349146f, 
    -0.03079197f, -0.02010393f, -0.05527611f, 0.03608588f, 0.04492061f, -0.10966606f, -0.03746205f, -0.03690735f, 
    -0.28426424f, 0.10454799f, 0.08125924f, -0.23972905f, 0.09191314f, 0.08944856f, 0.01893131f, -0.05910995f, 
    -0.02797452f, 0.03434306f, -0.02132460f, 0.01876895f, 0.00644288f, 0.00664661f, 0.02602508f, 0.09494856f, 
    0.02464084f, 0.05374020f, -0.00690648f, -0.02578754f, 0.10282392f, -0.16373192f, 0.08683506f, 0.02053548f, 
    -0.06954792f, 0.08546273f, -0.02216844f, -0.02072927f, 0.10508016f, -0.00826970f, -0.04267490f, 0.05002104f, 
    0.02803189f, -0.07865687f, -0.04419529f, 0.02331538f, -0.05450499f, -0.09478138f, -0.12320131f, 0.08985237f, 
    -0.37670526f, 0.35694197f, 0.11115927f, 0.07955938f, -0.07240549f, 0.15244935f, 0.01616590f, 0.01822141f, 
    0.02704174f, -0.08450101f, 0.01267473f, -0.02495830f, 0.09075431f, 0.03958527f, -0.05096721f, 0.10822527f, 
    -0.03940252f, 0.05154441f, -0.05738102f, -0.03781111f, -0.09950677f, -0.18306588f, 0.11922876f, -0.30354443f, 
    -0.20548257f, -0.04125282f, 0.04762628f, -0.14097047f, 0.00653104f, 0.01305182f, -0.05115400f, 0.01997447f, 
    0.04405092f, -0.02334575f, -0.11655261f, -0.08380268f, -0.05973377f, 0.08637474f, 0.03029564f, 0.07138015f, 
    -0.16148569f, -0.19775644f, -0.11370617f, 0.15661810f, 0.03893778f, 0.02636675f, -0.04856304f, -0.04107454f, 
    -0.03495213f, 0.16306043f, -0.11684862f, 0.02052499f, -0.02695996f, 0.01286528f, -0.01796389f, 0.03230990f, 
    -0.06229067f, 0.02027323f, 0.01769243f, -0.03964388f, -0.01359587f, -0.18068391f, 0.09580138f, -0.01281003f, 
    0.12633602f, -0.00280440f, 0.07864829f, -0.01225717f, -0.05079667f, 0.07268623f, 0.09223391f, 0.02519812f, 
    0.01281060f, 0.00912287f, 0.08095153f, -0.04657664f, -0.05732205f, -0.01518495f, 0.07441504f, 0.10553655f, 
    -0.02793398f, -0.14606875f, -0.11168792f, -0.13758634f, -0.17042375f, 0.03840470f, 0.05779206f, -0.04227753f, 
    -0.05667874f, -0.00207411f, -0.12673561f, 0.08121671f, -0.10153554f, 0.21860366f, 0.00460830f, -0.09974538f, 
    -0.02902033f, -0.01995593f, 0.10785320f, 0.07358935f, 0.08028783f, -0.24019024f, 0.02914522f, 0.13521139f, 
    -0.07172265f, 0.05647968f, 0.05561739f, -0.04299700f, 0.08525428f, 0.01432707f, -0.03433327f, 0.09897464f, 
    -0.01457611f, -0.02037957f, -0.03732704f, -0.07280614f, -0.02223572f, -0.02408876f, -0.02952694f, 0.03116957f, 
    0.01269256f, -0.13683018f, 0.21008699f, -0.07997961f, -0.28367069f, -0.01129931f, -0.07531045f, 0.14398967f, 
    0.02156737f, 0.12567811f, 0.02938137f, 0.07900452f, 0.06028040f, -0.05495616f, 0.00568894f, -0.01347639f, 
    0.09091905f, -0.03428216f, 0.05827166f, -0.09982552f, -0.05017376f, 0.00221192f, 0.29214844f, -0.23614764f, 
    -0.27285028f, 0.03423438f, 0.01744935f, -0.01345535f, -0.05006117f, 0.07927167f, -0.05172605f, -0.05839163f, 
    0.04679320f, -0.08323418f, -0.03398941f, -0.06790331f, 0.02117428f, 0.03478174f, 0.00050250f, -0.07152276f, 
    0.04070812f, -0.23354587f, 0.01244253f, 0.12467135f, -0.13449477f, 0.00066081f, -0.01557969f, -0.09493358f, 
    0.02511259f, -0.03906872f, -0.02002550f, 0.13069685f, 0.05274874f, -0.00628418f, 0.00414152f, -0.04448965f, 
    0.05851811f, -0.01657489f, -0.00821327f, 0.05796593f, 0.35418871f, -0.18479113f, -0.26025563f, -0.07344727f, 
    -0.12134710f, -0.04427803f, 0.01966115f, 0.09441044f, -0.03320971f, -0.07736932f, -0.04006067f, -0.01822761f, 
    0.00835410f, 0.08287448f, 0.03987626f, 0.02526669f, 0.11814162f, 0.07812435f, 0.00435123f, 0.11790220f, 
    0.11450559f, -0.06417627f, -0.14857696f, 0.04154682f, -0.02384976f, 0.02460316f, 0.02015292f, -0.02158284f, 
    -0.03178630f, 0.09398706f, 0.00546132f, -0.05355269f, 0.03114154f, 0.03581926f, 0.05571594f, -0.00201854f, 
    -0.05730646f, 0.00050386f, 0.03455294f, -0.03974656f, -0.01607227f, 0.08843797f, -0.05509821f, -0.27111292f, 
    -0.12572871f, -0.08435570f, 0.06454155f, -0.00069124f, 0.01017737f, 0.02964084f, -0.07368369f, 0.02584617f, 
    -0.08458897f, -0.00630140f, 0.04821532f, -0.02396119f, -0.00896130f, -0.00313939f, 0.11931032f, 0.06788766f, 
    -0.04852101f, -0.19251068f, -0.02554612f, 0.13428615f, -0.06096832f, -0.00410798f, 0.10054412f, -0.06646677f, 
    -0.13841626f, 0.02992704f, -0.03169259f, 0.03161510f, -0.06197391f, -0.01120575f, -0.02825267f, 0.04826278f, 
    -0.07513450f, -0.02693938f, 0.02900981f, 0.02820666f, -0.26368511f, 0.07497778f, 0.12198997f, -0.25429291f, 
    -0.15923639f, -0.07575895f, 0.12311105f, -0.01724451f, 0.00634973f, -0.00516530f, 0.05175801f, -0.04887779f, 
    -0.06677648f, -0.08594067f, 0.01296829f, 0.00919210f, 0.03086938f, 0.09990905f, 0.05183365f, 0.01790332f, 
    -0.01765225f, -0.20338988f, -0.02260763f, 0.16774933f, 0.05010195f, -0.04586734f, -0.02984289f, -0.03764955f, 
    -0.00982214f, 0.05594893f, -0.03723026f, 0.06463674f, -0.11384680f, -0.00913414f, 0.05950467f, -0.07142982f, 
    -0.02634303f, 0.07015438f, -0.01835273f, 0.04887299f, -0.09443430f, -0.10991307f, 0.05042713f, 0.10513891f, 
    -0.02310372f, -0.06526276f, -0.01810283f, -0.05423345f, 0.11792386f, 0.00250561f, -0.05234595f, 0.03819348f, 
    -0.03792394f, -0.00860167f, 0.01501926f, 0.02408060f, 0.05265005f, 0.05673986f, -0.00662916f, -0.02180422f, 
    -0.08143107f, -0.04718802f, 0.09121346f, -0.07428129f, 0.01449034f, 0.03135832f, -0.00623432f, -0.04021016f, 
    0.03696669f, -0.05192262f, -0.02314936f, 0.00586264f, 0.08000759f, 0.06219617f, 0.12441362f, 0.06811026f, 
    -0.06564050f, 0.05405918f, -0.07144383f, 0.04396175f, 0.26473466f, -0.34277612f, -0.08087764f, -0.01173392f, 
    -0.03391676f, -0.07711786f, 0.01665714f, 0.03146330f, 0.11134223f, 0.00625430f, -0.04992472f, -0.07926848f, 
    0.11753666f, -0.08110037f, 0.05709969f, 0.02277984f, -0.05509962f, 0.08029187f, 0.05209675f, 0.05482054f, 
    0.17478219f, -0.02813639f, -0.09900261f, 0.02607547f, 0.07013477f, -0.08696695f, -0.01704804f, -0.00507730f, 
    -0.01424095f, 0.01991036f, -0.03237690f, -0.03579423f, 0.06609266f, -0.04504183f, 0.08103083f, 0.07893774f, 
    -0.05138536f, -0.02874882f, 0.03747938f, 0.10712875f, 0.05446400f, -0.08925888f, -0.03797647f, 0.02771276f, 
    -0.01037329f, -0.07300001f, 0.06501285f, 0.04679200f, -0.04712982f, -0.01304788f, 0.05939941f, 0.02033781f, 
    0.03983361f, -0.06036368f, -0.06955164f, -0.02894422f, -0.01978526f, -0.06006231f, 0.09872882f, -0.02245991f, 
    -0.03744663f, -0.13311788f, 0.05044010f, -0.00714053f, -0.09091489f, 0.02332203f, 0.06246284f, -0.06926589f, 
    0.01595347f, 0.01728410f, -0.04219808f, 0.05420763f, 0.03232509f, 0.02138080f, -0.05663988f, -0.11421220f, 
    0.03689271f, -0.02980264f, -0.03040449f, 0.00963757f, 0.56220454f, -0.04647526f, -0.24854684f, -0.07289094f, 
    -0.19889283f, -0.01230987f, -0.00890220f, 0.09894885f, 0.06235260f, -0.11261432f, -0.02699735f, -0.05997271f, 
    -0.01058512f, 0.08813301f, -0.02156095f, 0.03058121f, 0.01765599f, -0.14902686f, -0.02907634f, 0.06972638f, 
    0.15950555f, -0.03391388f, -0.16587017f, 0.07997209f, -0.22676450f, 0.04058431f, 0.04521802f, 0.04668027f, 
    0.09615277f, -0.02371680f, 0.02102428f, -0.09100962f, -0.00252298f, 0.03003218f, -0.04058223f, 0.03817785f, 
    0.03477221f, 0.02858133f, 0.00724739f, -0.00960324f, 0.00554364f, -0.06607818f, -0.02700072f, 0.02073693f, 
    -0.11617880f, 0.08186713f, -0.01341456f, 0.00463236f, -0.04072101f, -0.12763762f, -0.00865028f, 0.05684891f, 
    0.00555367f, -0.06991699f, 0.02505076f, -0.05084437f, -0.01507723f, -0.06415913f, 0.06930838f, 0.01333065f, 
    -0.04863776f, -0.08258628f, -0.07500848f, -0.03294494f, -0.02065165f, 0.04115519f, 0.10849003f, 0.05124095f, 
    0.02603664f, -0.01308938f, 0.05129902f, 0.00233992f, -0.06025575f, -0.06098928f, -0.02385682f, -0.00710408f, 
    -0.01642827f, -0.10466403f, -0.17075910f, -0.01297599f, 0.12126964f, -0.10616229f, -0.12683126f, 0.14056127f, 
    0.06495240f, -0.06313419f, 0.00262931f, -0.10919118f, 0.03459744f, 0.02416962f, -0.01986953f, 0.08725914f, 
    0.03139086f, -0.07048953f, 0.06822290f, -0.08320928f, 0.03016682f, -0.03885454f, 0.05676857f, -0.00613736f, 
    -0.12271819f, -0.13760252f, -0.02316226f, -0.06559100f, -0.01574653f, 0.03516104f, 0.03568255f, -0.07235993f, 
    -0.00004062f, -0.00864443f, -0.03320298f, -0.01276192f, 0.02418710f, 0.15308763f, 0.01910049f, -0.00076403f, 
    0.04868186f, -0.17167088f, 0.02151203f, -0.10103420f, -0.13096224f, 0.10628032f, 0.14196964f, -0.10317199f, 
    -0.02430804f, -0.05271211f, 0.05081675f, -0.06481064f, 0.03208199f, 0.00422619f, -0.15288746f, 0.02045738f, 
    0.00779762f, 0.14270626f, 0.15252401f, 0.11309092f, 0.01239576f, 0.05523620f, -0.03414755f, 0.04368969f, 
    -0.32400596f, 0.14175382f, -0.12254997f, 0.13700813f, -0.06515209f, 0.06656016f, 0.00498239f, 0.01367096f, 
    0.01958541f, -0.09042455f, 0.02569808f, 0.01126761f, -0.00077293f, 0.01564617f, 0.02417669f, 0.07715782f, 
    -0.06957530f, 0.08896362f, -0.05340014f, 0.07388273f, -0.05534222f, 0.24386090f, 0.10057247f, 0.21672246f, 
    -0.03068569f, 0.05904728f, -0.00094910f, 0.04705336f, 0.00417766f, -0.03299579f, -0.02389246f, 0.01990310f, 
    0.10470451f, 0.02666153f, 0.13192229f, 0.02085776f, 0.08204007f, 0.00412166f, -0.13306364f, -0.04478882f, 
    -0.00079472f, -0.03488507f, 0.01764624f, -0.20633794f, -0.12900592f, -0.00142835f, 0.05580658f, -0.07734173f, 
    0.04731515f, -0.01772705f, 0.04711616f, -0.11972402f, 0.05998139f, 0.03351083f, -0.00961847f, 0.05767834f, 
    -0.04219991f, -0.00590108f, -0.10925097f, -0.09251678f, 0.15802903f, 0.10150399f, -0.09287490f, 0.04755155f, 
    -0.13353214f, 0.06572802f, 0.03448607f, 0.01967535f, -0.07698897f, -0.14966749f, -0.09944117f, 0.06096074f, 
    -0.04391104f, 0.08807242f, 0.01631479f, -0.01660657f, 0.04568286f, -0.10428249f, -0.00957271f, 0.01703587f, 
    -0.11899113f, -0.07352190f, 0.05201736f, -0.13870382f, -0.02416591f, -0.11973099f, 0.08144061f, 0.03631593f, 
    -0.00869803f, 0.04470048f, 0.01199000f, -0.10469309f, -0.02179565f, -0.03778819f, 0.01684145f, 0.12555213f, 
    -0.03160930f, 0.07827111f, -0.01904604f, -0.06815339f, -0.10415096f, -0.41356149f, 0.01460782f, 0.00831486f, 
    0.04546955f, -0.08732098f, 0.02190573f, 0.00452823f, 0.03244478f, -0.09611415f, -0.08933304f, -0.09530380f, 
    -0.04161463f, -0.04114602f, -0.03004458f, 0.08991636f, 0.02040860f, 0.01830833f, -0.00878715f, 0.05524296f, 
    0.05428144f, 0.02615439f, -0.11610276f, 0.08950122f, -0.18348578f, -0.08524197f, 0.04138887f, 0.11704788f, 
    0.00184956f, -0.14182152f, 0.05880998f, 0.00254746f, -0.05370167f, -0.06955618f, -0.02563888f, 0.12707700f, 
    -0.00805344f, -0.10825584f, -0.10703000f, -0.01937625f, -0.07172175f, -0.00622211f, 0.04722796f, -0.06368847f, 
    0.02474198f, 0.09492315f, -0.07431879f, 0.04786390f, 0.03212709f, 0.16799147f, -0.07219422f, 0.00159663f, 
    -0.03489241f, 0.08456668f, -0.11944477f, -0.02169967f, -0.07733940f, -0.09484991f, -0.01463147f, -0.05705963f, 
    0.30164254f, -0.28019053f, 0.18080631f, -0.05878853f, 0.10113252f, 0.02936485f, 0.06100428f, 0.01591017f, 
    0.01762795f, -0.04189958f, -0.05609601f, -0.04132769f, 0.00102281f, 0.02677698f, 0.06513162f, 0.04126981f, 
    -0.02080067f, -0.06735060f, -0.05917355f, 0.02833641f, 0.11716918f, -0.26966754f, 0.08296714f, -0.20091550f, 
    0.13219550f, 0.03039660f, 0.02016748f, -0.07003710f, 0.04261056f, -0.11192713f, 0.04782231f, -0.07197427f, 
    -0.02506096f, 0.07963847f, 0.02873872f, 0.00038380f, 0.01080616f, -0.13830972f, -0.09060064f, -0.03446269f, 
    0.08286765f, -0.14386262f, -0.06605567f, 0.13874960f, -0.06837494f, -0.06807692f, 0.05415937f, -0.06450987f, 
    0.06909434f, 0.06557723f, -0.05351194f, 0.08536430f, -0.02016116f, -0.05672023f, 0.04463173f, 0.00873962f, 
    0.00127992f, 0.04403114f, 0.03522676f, 0.01826022f, 0.00319719f, 0.04827238f, 0.09620976f, -0.04242583f, 
    -0.02781175f, -0.02236270f, 0.02663985f, 0.04787853f, 0.09185835f, -0.05152749f, -0.00342530f, 0.00724497f, 
    -0.05889296f, -0.02236017f, 0.01732306f, -0.08762822f, 0.05200740f, -0.03722107f, -0.04389053f, -0.00480101f, 
    -0.25466096f, 0.18394269f, -0.11823778f, 0.04079309f, -0.07004315f, 0.08837458f, -0.01256281f, -0.03478338f, 
    0.06144116f, 0.09187039f, -0.00220202f, 0.03591365f, 0.00676751f, 0.00813800f, 0.08733963f, 0.12764092f, 
    -0.07870756f, 0.08976795f, 0.02889248f, 0.01533415f, 0.03918658f, -0.01939003f, 0.10162307f, 0.09091298f, 
    -0.32419053f, 0.06496412f, 0.08096734f, 0.10392489f, -0.02776580f, 0.05363416f, -0.06206168f, -0.08268119f, 
    -0.03557171f, -0.10966808f, 0.04697070f, 0.00578377f, -0.02145099f, 0.00705072f, -0.02442350f, -0.04226713f, 
    0.01663329f, -0.02268735f, 0.02765352f, -0.29057705f, -0.19456977f, -0.08379391f, -0.02763023f, -0.07495154f, 
    -0.00881769f, 0.05909443f, -0.07777929f, -0.00362217f, 0.02382773f, -0.09441759f, -0.00045816f, 0.10653568f, 
    0.03746388f, -0.05376257f, -0.02995035f, 0.00777836f, -0.17914002f, -0.01272243f, 0.14655925f, 0.02725145f, 
    -0.03881651f, 0.02095837f, 0.07147203f, 0.05415065f, -0.01952785f, -0.00418056f, -0.02332136f, -0.02062283f, 
    -0.00457717f, -0.01198735f, 0.01878484f, 0.00994306f, 0.01688426f, 0.05860671f, -0.09809392f, -0.03469391f, 
    0.34542924f, -0.36306897f, 0.06714831f, -0.05692289f, 0.07119542f, -0.15243493f, -0.07434252f, -0.01024524f, 
    0.09365927f, 0.01445356f, -0.00838816f, -0.04710045f, 0.06874721f, -0.09060652f, -0.11118983f, 0.06064349f, 
    0.14731136f, 0.09705331f, 0.00933175f, 0.02703490f, -0.31023428f, -0.17747915f, -0.07733192f, 0.11110191f, 
    -0.08961064f, 0.04555647f, 0.11247841f, -0.08830868f, -0.05989134f, 0.04339543f, 0.02137084f, 0.01326489f, 
    -0.02931397f, 0.06870872f, 0.05758885f, -0.04977790f, -0.08379761f, 0.01169998f, 0.02613625f, -0.05076233f, 
    0.05586377f, 0.00412111f, -0.06767567f, 0.09023982f, -0.01156155f, 0.07551125f, -0.01232591f, -0.05759118f, 
    -0.02671357f, 0.08742803f, -0.05445110f, -0.05971770f, 0.00020215f, 0.03506788f, -0.04473552f, 0.02086015f, 
    -0.09048026f, 0.04982518f, 0.00695761f, -0.00387944f, 0.15355974f, 0.01022632f, -0.10341481f, -0.06269657f, 
    0.00370978f, -0.03020328f, -0.03088972f, 0.04457686f, -0.03107740f, -0.01428419f, 0.01797831f, 0.00592957f, 
    0.01693350f, -0.11832545f, -0.03139871f, 0.05464150f, 0.07283892f, -0.06925344f, 0.14732535f, 0.06377792f, 
    -0.00254953f, -0.06343863f, -0.05047888f, -0.06005871f, 0.23260480f, -0.19541582f, -0.01102246f, 0.11100663f, 
    -0.02792680f, 0.01163277f, -0.05494086f, -0.04960114f, -0.00644879f, -0.11831313f, -0.02829889f, 0.07433439f, 
    -0.15814880f, 0.02864071f, 0.05798990f, 0.10136455f, 0.46986404f, 0.13179684f, -0.00870836f, -0.05817931f, 
    0.02188911f, 0.07748628f, 0.00625703f, -0.02817998f, 0.01026974f, -0.04027260f, 0.02028733f, 0.07080968f, 
    0.05417163f, 0.05375645f, -0.08892825f, 0.05740905f, 0.01038893f, -0.08191374f, -0.06271957f, -0.00311379f, 
    -0.41779658f, 0.11599963f, 0.12645690f, 0.01972645f, 0.08744297f, 0.04274135f, -0.01432891f, 0.00932835f, 
    0.01921035f, 0.03900310f, -0.07592507f, 0.01214386f, 0.02787100f, 0.07643735f, -0.14847885f, 0.07978084f, 
    -0.07337207f, 0.03547272f, 0.04018285f, 0.05614197f, -0.31518981f, -0.27099097f, 0.18232679f, -0.20178790f, 
    0.09925140f, -0.05385946f, 0.04136492f, -0.04095937f, 0.08703450f, -0.02792111f, -0.12298853f, -0.11333197f, 
    -0.01728783f, -0.05187576f, -0.00879672f, 0.03231202f, 0.04918287f, 0.05452282f, -0.04109151f, 0.08252414f, 
    -0.02073612f, -0.12243766f, 0.14435376f, -0.17075247f, 0.04972647f, 0.09084593f, 0.03318800f, 0.09631062f, 
    0.02701211f, -0.05405419f, 0.04685780f, 0.05513359f, 0.00251694f, 0.04157486f, -0.02343466f, 0.02133328f, 
    0.01940329f, -0.00032677f, -0.08937521f, 0.05374890f, 0.16974385f, -0.09072269f, 0.04051508f, 0.04139410f, 
    -0.15233062f, 0.00150955f, 0.08309736f, 0.05041262f, -0.01608292f, -0.05285998f, 0.00282873f, -0.02194263f, 
    -0.02692189f, -0.07547113f, -0.01185549f, -0.02222054f, 0.05209809f, -0.11117312f, 0.02415070f, -0.05003433f, 
    -0.29136238f, 0.12352102f, -0.00531638f, -0.00409061f, -0.04985878f, 0.01470893f, 0.02044079f, -0.09592705f, 
    -0.01160871f, 0.00013189f, -0.01524287f, -0.01785362f, 0.03724750f, 0.08553965f, 0.09146937f, 0.06647305f, 
    -0.00950376f, 0.10182822f, -0.05843640f, 0.06312536f, 0.35009280f, -0.15772374f, -0.01078139f, 0.08098479f, 
    0.11238369f, -0.05313829f, -0.10343538f, 0.04101009f, 0.04934298f, 0.03635196f, -0.01808262f, 0.06893846f, 
    -0.01633893f, 0.05328273f, -0.04036238f, -0.04225760f, 0.01956590f, 0.06595241f, -0.00736228f, -0.00401683f, 
    0.14330515f, -0.31369218f, 0.19003890f, -0.03139772f, -0.09013069f, 0.12812504f, 0.06396373f, -0.08085048f, 
    -0.03006705f, -0.06672137f, -0.03332339f, 0.01170313f, -0.07983174f, -0.04128499f, -0.01672248f, -0.07180585f, 
    -0.01357088f, -0.01786256f, 0.03229762f, 0.05811333f, 0.04054883f, -0.09746151f, -0.02352378f, -0.04017659f, 
    0.08871464f, -0.09807090f, -0.01658320f, 0.06654673f, 0.08689399f, 0.01591716f, 0.01374310f, -0.03845774f, 
    -0.05591264f, -0.00047301f, -0.08237055f, 0.03632709f, -0.01549774f, 0.00505960f, 0.02602963f, 0.10299234f, 
    0.02779443f, 0.12112086f, -0.13191970f, 0.04710320f, -0.03273037f, -0.04325200f, -0.05635330f, -0.04810587f, 
    0.02371168f, 0.00979517f, -0.00966497f, -0.00456157f, 0.00162343f, -0.05737200f, 0.01662876f, -0.05162069f, 
    0.01956063f, 0.04542632f, 0.02562097f, 0.04020694f, -0.10571752f, -0.03751404f, 0.06646732f, 0.02060288f, 
    0.06268896f, 0.06692986f, -0.04041152f, 0.05095794f, -0.00366404f, 0.06643948f, 0.01873641f, 0.05302685f, 
    -0.00886009f, -0.02479006f, -0.01139308f, -0.02425377f, -0.07302653f, -0.10261796f, 0.00216483f, 0.01051837f, 
    -0.39009169f, -0.08391047f, -0.02278724f, -0.13898611f, -0.27599829f, 0.04924023f, -0.01876198f, 0.00876651f, 
    -0.03152852f, 0.05759116f, 0.02051083f, 0.04864249f, -0.03267535f, 0.11633526f, 0.01074428f, 0.02862532f, 
    -0.04488670f, -0.03792794f, -0.03549783f, -0.06624651f, -0.23653883f, -0.03911388f, 0.05530519f, -0.03070722f, 
    -0.03184800f, 0.07898591f, 0.00193395f, -0.04073006f, -0.02961334f, -0.00977779f, 0.00047047f, 0.00341389f, 
    -0.01731372f, 0.07844727f, 0.03329979f, 0.05706814f, -0.05909744f, 0.01387202f, -0.00700673f, -0.02897372f, 
    -0.53677517f, -0.18849871f, -0.21487884f, -0.13902113f, -0.16185370f, 0.05209786f, 0.07654961f, -0.04741367f, 
    -0.02169904f, 0.03092794f, 0.09457024f, -0.01446259f, 0.05980457f, 0.00261229f, 0.02540126f, -0.00089646f, 
    -0.06363606f, 0.02938951f, 0.07650673f, -0.04696253f, 0.02825231f, 0.00307470f, 0.00901612f, -0.00344721f, 
    0.03249593f, -0.03576833f, 0.04910127f, -0.07243632f, -0.03255004f, -0.01260891f, -0.02380386f, -0.01389876f, 
    -0.04983838f, 0.04990633f, 0.11881165f, -0.02520422f, 0.08743018f, 0.09172945f, 0.04870205f, 0.01424653f, 
    -0.18602122f, -0.14695027f, -0.10595046f, 0.03002112f, 0.00733640f, 0.07334536f, -0.00242040f, -0.04860083f, 
    -0.00521344f, 0.02304848f, 0.11556951f, -0.09940007f, -0.05397113f, -0.07645668f, 0.00664017f, 0.01655202f, 
    0.08347780f, 0.00460897f, 0.11384498f, 0.06226993f, -0.28037661f, -0.15265791f, 0.10311759f, -0.15640271f, 
    -0.15685323f, 0.08069368f, 0.04479263f, 0.02622860f, 0.07399900f, 0.04712018f, -0.00307853f, 0.06850369f, 
    -0.04312305f, 0.13508046f, 0.01755559f, 0.11188348f, -0.01835215f, 0.03808183f, -0.04946185f, -0.03412992f, 
    0.22092177f, 0.03422783f, -0.07763645f, 0.09519174f, -0.10174108f, -0.13040113f, -0.10714897f, -0.00229559f, 
    0.01070641f, -0.02974857f, 0.02949799f, 0.02657745f, -0.10064679f, -0.04032813f, -0.12334036f, -0.07310589f, 
    -0.01062886f, -0.11807036f, -0.10048100f, -0.06897020f, -0.13787752f, 0.12787379f, -0.08445842f, -0.02377196f, 
    0.08151443f, 0.03363264f, 0.04180596f, 0.01852978f, 0.02912297f, 0.05815006f, 0.02728906f, 0.04526960f, 
    -0.03321858f, -0.01065292f, 0.01083534f, 0.10494542f, -0.01113701f, 0.09052426f, -0.04529428f, 0.09665897f, 
    -0.03406097f, 0.00318815f, -0.02211555f, -0.05829774f, -0.24370696f, 0.02725284f, 0.05167339f, -0.01835833f, 
    0.07851815f, 0.05758025f, 0.03189592f, -0.00935004f, 0.01701204f, -0.14245667f, -0.02478993f, 0.07239360f, 
    0.05503284f, 0.03558363f, 0.02238320f, 0.12224349f, 0.15230605f, 0.02523651f, 0.03092292f, 0.04644829f, 
    0.00978448f, -0.10160362f, -0.03542671f, -0.04292248f, 0.01764198f, -0.04228928f, 0.00325405f, 0.03932115f, 
    -0.02095822f, -0.03559538f, 0.06346083f, 0.00801503f, 0.07159454f, 0.04869317f, -0.01315270f, -0.00636384f, 
    0.04985663f, 0.16355450f, 0.08706791f, 0.01393759f, 0.04357193f, 0.09418532f, 0.05204294f, 0.02543516f, 
    0.03957011f, -0.05879999f, -0.09052785f, 0.05478284f, 0.03105229f, 0.02833381f, -0.02116590f, 0.03494823f, 
    0.05792285f, -0.01727118f, -0.07200977f, 0.06132488f, -0.30825016f, -0.15623495f, -0.18704981f, -0.03697298f, 
    -0.02606031f, 0.08781419f, -0.05517863f, -0.05832703f, 0.01627136f, -0.05425372f, 0.03077142f, 0.08458932f, 
    -0.01144387f, 0.14210685f, -0.07661128f, 0.06543201f, 0.05258575f, 0.00146260f, -0.06396080f, -0.02844867f, 
    -0.16395296f, -0.06260660f, -0.09836932f, 0.04560060f, 0.10950539f, 0.04783197f, 0.03284831f, -0.06174310f, 
    -0.01103838f, -0.03431335f, -0.00674245f, -0.01820640f, -0.08755364f, 0.05113764f, 0.03142930f, -0.04834173f, 
    0.16034009f, -0.04241451f, 0.00823511f, 0.05498636f, 0.01506919f, -0.03554972f, 0.03405900f, -0.09299962f, 
    0.05710793f, 0.03967176f, 0.05815572f, -0.00964739f, -0.02158186f, -0.00042250f, -0.03201751f, 0.02278248f, 
    0.02452631f, -0.04665672f, 0.03435849f, -0.09587080f, 0.04410404f, 0.06258352f, 0.00951983f, 0.08419397f, 
    0.22652987f, -0.00706788f, -0.04483272f, 0.00488199f, 0.04436213f, -0.16543369f, -0.08814883f, -0.02376545f, 
    0.03775908f, -0.03878193f, -0.00905065f, 0.03156818f, -0.07842340f, -0.11920249f, -0.04209628f, -0.06508718f, 
    0.00881872f, 0.02295137f, -0.05473109f, -0.01346962f, 0.07908047f, 0.09279483f, 0.12633337f, -0.06121784f, 
    -0.07863151f, 0.11492588f, 0.01577677f, -0.02567264f, 0.08634346f, 0.02525261f, -0.01179829f, 0.00631128f, 
    0.04591146f, 0.00351171f, 0.00577441f, 0.08642170f, 0.09833654f, -0.03470856f, -0.05040440f, 0.06380757f, 
    0.18995968f, 0.00247864f, -0.05985601f, 0.04067184f, -0.12107481f, 0.03002706f, -0.07614773f, 0.05438452f, 
    0.01116322f, 0.03496491f, -0.01611240f, -0.02354217f, -0.00859821f, -0.01322348f, -0.07291044f, -0.08603320f, 
    -0.03668704f, -0.25847709f, -0.06474969f, -0.11946677f, 0.11655194f, -0.00496554f, 0.20547204f, -0.00628666f, 
    -0.08373113f, 0.10905129f, 0.00915709f, 0.00191325f, 0.02562436f, -0.02514280f, -0.03732102f, 0.02524224f, 
    0.00194529f, 0.02245512f, -0.06536247f, -0.03039670f, 0.01493089f, -0.26217270f, -0.08879058f, -0.16718794f, 
    0.11014615f, 0.07360305f, 0.01722710f, 0.01200488f, -0.08773747f, -0.01685717f, -0.04337664f, 0.05646230f, 
    0.03310431f, 0.00451758f, -0.02199685f, -0.02087388f, 0.04344851f, -0.03755283f, -0.02193479f, 0.04623796f, 
    0.04238826f, 0.02623069f, 0.00202914f, -0.03943454f, 0.03521577f, -0.02273948f, 0.04340358f, -0.01976053f, 
    0.06068125f, 0.03614964f, 0.09815741f, -0.00587573f, 0.02290530f, -0.04458818f, -0.01983943f, 0.04830343f, 
    0.03713392f, 0.01681714f, -0.01258207f, -0.01685216f, 0.05202133f, -0.00317721f, -0.10557669f, 0.03151348f, 
    0.01738838f, -0.05359403f, 0.05332927f, -0.02542592f, 0.10329294f, -0.00139482f, 0.01879419f, 0.10936300f, 
    -0.01909494f, 0.00244176f, 0.01088072f, -0.00093647f, -0.04515005f, 0.00175753f, 0.05497592f, 0.05637893f, 
    0.04077740f, -0.01726118f, 0.00295931f, 0.06031451f, 0.10950810f, 0.13120154f, -0.04375510f, 0.03420801f, 
    0.06596656f, -0.00190040f, 0.02202275f, -0.01388990f, 0.05264663f, 0.02457889f, -0.01033325f, 0.00028842f, 
    0.04296442f, 0.01764764f, 0.07770871f, 0.10200298f, 0.04770952f, 0.09581476f, -0.05004685f, 0.06170445f, 
    -0.01739486f, 0.14496979f, 0.00448588f, -0.07581445f, -0.02278264f, 0.05351278f, 0.02792102f, 0.06332844f, 
    0.06342944f, 0.02300567f, 0.01331892f, 0.04507280f, 0.02332659f, 0.01754152f, -0.00702337f, 0.02979574f, 
    0.09187178f, 0.02848886f, -0.05956177f, 0.03750443f, 0.15319623f, 0.15300070f, 0.06061818f, -0.08690838f, 
    -0.06238846f, 0.07591824f, -0.04327416f, 0.04782712f, 0.03763956f, -0.01724323f, -0.02776575f, -0.03093906f, 
    0.01232554f, 0.04005572f, -0.00405023f, 0.08633962f, 0.02826208f, -0.05161462f, -0.09372547f, 0.00727552f, 
    0.11947095f, 0.03564120f, 0.03493476f, 0.01436899f, -0.00850936f, -0.02077862f, 0.00208355f, 0.00940830f, 
    0.04927107f, 0.00619650f, -0.01105573f, 0.00682907f, -0.02716723f, 0.00203705f, 0.07872599f, 0.02941357f, 
    0.10023136f, 0.10120541f, 0.04334700f, 0.01273654f, -0.37488836f, -0.13891356f, 0.16903935f, 0.04635897f, 
    -0.03507513f, 0.03269559f, -0.05980985f, -0.01467999f, -0.05420245f, 0.02672107f, -0.08244998f, 0.03371084f, 
    0.01575128f, -0.03347330f, 0.03261808f, -0.06729779f, -0.00948572f, 0.05656876f, 0.00746502f, 0.04384273f, 
    -0.36752027f, -0.27408764f, 0.09670237f, -0.05230447f, -0.19223043f, -0.00806647f, 0.02328837f, -0.00864401f, 
    -0.06287321f, -0.02464538f, 0.05571266f, -0.01889685f, 0.08998965f, -0.07026725f, 0.03764686f, -0.05220284f, 
    -0.04427344f, 0.03428533f, 0.00213726f, 0.05612236f, -0.11161363f, -0.05473848f, -0.05959147f, -0.07951262f, 
    -0.03753874f, 0.00689618f, 0.03991001f, -0.04363623f, 0.00484274f, 0.02927356f, 0.00288619f, -0.06328736f, 
    -0.02429054f, -0.03743143f, -0.02714244f, -0.04917805f, 0.03454136f, 0.08723386f, 0.06867874f, 0.09611426f, 
    -0.17375563f, -0.12963054f, -0.11126874f, -0.11059494f, -0.00264164f, 0.07826655f, 0.01212924f, -0.10384888f, 
    -0.06692910f, -0.04148864f, -0.08838360f, -0.00528209f, -0.14759640f, -0.02074376f, 0.03710651f, -0.08989798f, 
    0.03239278f, 0.16214585f, 0.03259365f, 0.03899488f, 0.09389943f, 0.03769517f, 0.01162259f, -0.06900207f, 
    -0.01622176f, -0.00120821f, -0.00127557f, -0.00041853f, 0.02953034f, 0.01132621f, -0.03682649f, -0.00559097f, 
    -0.01627710f, 0.03334613f, -0.05350425f, -0.06534924f, 0.06429426f, -0.00550918f, -0.06900866f, 0.08019266f, 
    -0.22369009f, 0.00847156f, -0.12978782f, -0.09235004f, -0.00861490f, 0.08062275f, 0.05847751f, -0.07371272f, 
    0.02953811f, 0.00184112f, 0.00059707f, 0.02472999f, 0.00628599f, -0.01515087f, 0.04458170f, -0.06006371f, 
    -0.00057758f, 0.10427116f, 0.02744709f, 0.03537008f, -0.07326778f, -0.14630808f, -0.00292403f, -0.08061039f, 
    0.06244465f, -0.00704934f, -0.03515217f, -0.02692102f, -0.02810267f, -0.04464127f, -0.02935076f, 0.02701106f, 
    -0.12753166f, -0.09882244f, -0.06927180f, -0.01589607f, -0.06690569f, -0.12039001f, -0.06154899f, 0.05517603f, 
    -0.20000340f, -0.20389786f, -0.03314418f, -0.03132388f, -0.00637619f, 0.01166247f, 0.01731961f, 0.03417860f, 
    -0.03871235f, -0.04930366f, 0.07209828f, -0.04442897f, -0.02944877f, -0.06090241f, -0.00251149f, 0.01569876f, 
    0.02504885f, 0.03853742f, 0.07557340f, 0.02831084f, -0.20750147f, -0.18568835f, -0.00888580f, 0.01523934f, 
    0.09647088f, 0.05719737f, 0.02951964f, 0.05631566f, -0.01360942f, 0.01491755f, 0.02138626f, -0.09380633f, 
    0.02129221f, -0.01408507f, -0.03812069f, -0.01961336f, -0.08077814f, -0.08342586f, 0.10855701f, 0.01919012f, 
    -0.31158951f, 0.04128780f, -0.14707682f, -0.10505980f, 0.06800403f, 0.02907466f, -0.09041285f, -0.04593778f, 
    -0.04783506f, 0.09730184f, 0.01937710f, -0.04361519f, 0.05881158f, -0.02872906f, 0.01661444f, -0.01284034f, 
    0.06869664f, 0.08528782f, 0.01790302f, 0.01850532f, -0.17774515f, -0.09376171f, -0.00005637f, 0.01685967f, 
    0.00141161f, -0.02177745f, -0.03810087f, 0.04146859f, -0.01742771f, 0.01351754f, 0.05952698f, -0.06641649f, 
    -0.01798531f, 0.01442861f, -0.03827499f, 0.06279971f, 0.04105259f, 0.05769774f, 0.07526442f, 0.03144849f, 
    0.05921405f, 0.12645090f, -0.22567463f, 0.04374948f, 0.14570186f, 0.07282382f, -0.02593615f, -0.03059815f, 
    -0.05540011f, 0.07897058f, -0.03567822f, -0.01643419f, 0.04833650f, -0.05756561f, 0.03623866f, -0.00837424f, 
    0.05123185f, -0.04916723f, -0.07225255f, -0.03900224f, -0.00178671f, 0.03990484f, -0.03688345f, 0.11443458f, 
    0.07949791f, 0.01121954f, -0.00271159f, -0.01641771f, 0.02995824f, 0.01187792f, 0.04676620f, 0.04711842f, 
    0.01992516f, 0.00908201f, 0.09176911f, 0.01300634f, 0.01413319f, -0.12779972f, -0.05300574f, -0.03715100f, 
    -0.24815619f, -0.14725654f, -0.00759682f, -0.09063572f, 0.03868264f, -0.02040552f, -0.00121207f, 0.02441420f, 
    -0.05792320f, -0.00951761f, -0.06704902f, -0.01117675f, -0.05972369f, 0.05779912f, 0.01236860f, 0.00438503f, 
    0.04121464f, 0.02528622f, 0.09523695f, 0.09554894f, 0.16906114f, 0.12345479f, -0.07532554f, 0.01043871f, 
    -0.05565340f, -0.08693130f, -0.07591568f, 0.04216028f, 0.03818179f, -0.05092100f, 0.03711565f, -0.00482790f, 
    -0.00712879f, -0.11520158f, -0.02962157f, -0.02998498f, -0.04805435f, 0.03665429f, 0.04395654f, -0.06599627f, 
    -0.11170682f, 0.05135272f, -0.11194179f, -0.06644680f, 0.08979870f, -0.03661333f, 0.05385294f, 0.01922416f, 
    0.03067921f, 0.05605729f, 0.05349450f, 0.06294286f, 0.04603133f, 0.01778610f, 0.02242826f, 0.09367883f, 
    0.04360301f, 0.08051416f, -0.04723443f, 0.10956594f, -0.42832208f, 0.00153889f, -0.31716597f, -0.08793908f, 
    0.09742786f, 0.07067373f, -0.00567652f, -0.14887871f, -0.03884130f, 0.03584054f, 0.06821535f, -0.00868555f, 
    0.00188845f, -0.07165034f, 0.05134080f, -0.08741409f, -0.04775007f, 0.12575446f, 0.04957731f, 0.02014093f, 
    0.17594974f, -0.04268236f, -0.00194575f, -0.00616821f, -0.00115463f, -0.06201552f, 0.00117491f, -0.03345300f, 
    0.04861130f, -0.08626175f, 0.03494083f, 0.09259032f, -0.00643844f, -0.03947212f, -0.05453792f, -0.08137342f, 
    0.03435831f, -0.03529676f, -0.14182922f, 0.02665514f, -0.30476597f, -0.27751699f, -0.03910215f, -0.04735581f, 
    0.06995489f, 0.08545204f, 0.04740537f, 0.01226202f, -0.01794315f, -0.01227792f, 0.03425331f, 0.00679903f, 
    -0.08225814f, 0.01345275f, 0.00879501f, 0.06652477f, 0.03007590f, 0.08190394f, 0.08813612f, 0.05848743f, 
    -0.03372419f, -0.02381727f, -0.00917338f, 0.02676253f, -0.01702384f, 0.03899141f, 0.07214753f, 0.00351432f, 
    0.04415443f, 0.05057510f, 0.02422744f, -0.06683847f, 0.07276321f, -0.02728493f, -0.01270942f, -0.03100861f, 
    0.04507164f, -0.17204551f, 0.04226460f, -0.01089761f, -0.43836775f, -0.31903324f, -0.19338600f, -0.05584860f, 
    -0.13608696f, 0.06646395f, -0.03408965f, -0.06074716f, -0.07515547f, -0.01543495f, 0.02942250f, 0.00001324f, 
    -0.09188917f, 0.09129445f, 0.00875082f, -0.01587905f, 0.08854792f, 0.09479772f, -0.03514417f, 0.05799903f, 
    -0.21619833f, 0.01612052f, 0.19521458f, -0.10654088f, -0.20265497f, 0.05932362f, -0.02835077f, 0.06507474f, 
    -0.03933799f, 0.10911729f, -0.03162246f, -0.01986969f, -0.06161592f, -0.00033393f, -0.01652178f, -0.11299040f, 
    -0.08082508f, -0.14651917f, -0.08415885f, -0.08437761f, -0.36558425f, -0.17372252f, 0.00876016f, -0.00720382f, 
    0.02576854f, 0.02163428f, 0.03597935f, -0.00056915f, -0.04362614f, -0.06441285f, 0.05629548f, 0.01889874f, 
    -0.03158575f, 0.04585563f, 0.03148142f, 0.01542789f, 0.01579720f, 0.02059807f, -0.02503028f, 0.01632594f, 
    -0.07249732f, 0.02801503f, 0.07846291f, 0.20036729f, 0.15236585f, 0.05052149f, 0.13426724f, -0.08032958f, 
    -0.03061159f, -0.04840192f, 0.01549630f, -0.02326790f, 0.05033135f, -0.03684060f, 0.16292182f, 0.01503534f, 
    -0.08933634f, -0.05256934f, -0.17081991f, -0.06630103f, 0.08591475f, -0.13244647f, -0.08224754f, -0.04066885f, 
    -0.06954174f, -0.00451964f, 0.08539921f, -0.02734513f, 0.03669230f, 0.04127613f, -0.01112365f, -0.14377032f, 
    -0.07235789f, 0.02576311f, -0.09804332f, 0.03473987f, 0.06211509f, -0.00965222f, 0.05301798f, 0.04570383f, 
    0.21033713f, 0.07588378f, 0.00948259f, -0.01340435f, -0.04743590f, -0.19555561f, -0.07704308f, -0.02158647f, 
    0.02459967f, -0.09136646f, -0.04932780f, 0.02005143f, -0.06461171f, -0.06368594f, -0.01756915f, -0.07360183f, 
    -0.01806878f, 0.03974341f, -0.03109161f, -0.04486249f, 0.17761372f, 0.19803993f, 0.08737831f, -0.05266532f, 
    -0.07681951f, 0.05613734f, -0.00082701f, 0.02548625f, 0.05016560f, -0.00046231f, -0.00498693f, -0.04623933f, 
    0.05788079f, 0.01751677f, 0.00296098f, 0.01112960f, 0.11893938f, 0.00837666f, 0.00922735f, 0.07263302f, 
    0.10614188f, 0.11632512f, -0.22563796f, 0.02408988f, 0.13325793f, -0.05039399f, -0.07390784f, 0.00452465f, 
    0.05441912f, 0.08617812f, 0.00156089f, 0.01012134f, 0.05931996f, -0.08460123f, -0.00023704f, 0.12151411f, 
    0.05688002f, 0.01292535f, 0.01079128f, 0.03661684f, 0.03360749f, 0.02266111f, 0.06137637f, -0.00030183f, 
    0.06348740f, -0.08779121f, -0.00216018f, -0.04270901f, 0.02322925f, -0.05790033f, -0.01090162f, 0.02509794f, 
    0.04426141f, -0.02220138f, -0.00585435f, -0.03700477f, 0.01875234f, 0.04117141f, -0.02429855f, -0.00071476f, 
    0.00081285f, -0.04321336f, -0.12197600f, 0.02462474f, 0.05985715f, 0.07834308f, 0.00586247f, 0.03683575f, 
    -0.04127437f, 0.03516317f, 0.01072875f, -0.01978230f, 0.08202676f, -0.07145127f, 0.02064541f, -0.00976900f, 
    0.01532966f, -0.11148251f, 0.05425444f, 0.07684997f, -0.17752539f, -0.06874141f, -0.10993160f, 0.16205245f, 
    -0.03290130f, 0.07963050f, 0.00383677f, 0.03527817f, 0.03175262f, -0.04509250f, 0.06291971f, 0.04722004f, 
    -0.00057996f, -0.01213626f, 0.12014648f, 0.00148643f, -0.09339195f, -0.23882236f, -0.03676810f, -0.05476597f, 
    -0.10698675f, -0.04920118f, -0.10217997f, -0.05938994f, -0.01942292f, 0.00743387f, 0.02111733f, -0.06788576f, 
    -0.04926681f, -0.04946543f, 0.00894444f, 0.00601642f, 0.02238886f, -0.07237381f, 0.07524242f, -0.01268043f, 
    -0.00495092f, 0.02913230f, 0.06378703f, -0.03263469f, -0.33132562f, -0.08279769f, 0.05710290f, -0.02544731f, 
    -0.14651155f, 0.04843702f, 0.02725887f, -0.03180797f, -0.02787833f, 0.02571551f, -0.00598891f, -0.00797263f, 
    0.00460443f, 0.05902828f, 0.01743554f, -0.01550668f, -0.08002444f, 0.02834126f, 0.01868172f, 0.01544735f, 
    -0.15545177f, -0.19958945f, 0.04803360f, 0.05816757f, 0.02930006f, 0.02054017f, 0.08436920f, 0.04199698f, 
    0.01044312f, -0.01966277f, 0.04034651f, 0.02819310f, 0.03871633f, -0.00844306f, 0.04153552f, -0.01182499f, 
    -0.04431299f, -0.06831428f, -0.03245008f, -0.02943561f, 0.13212442f, 0.07196299f, -0.08663922f, 0.10416588f, 
    -0.03475260f, -0.08349288f, -0.02547836f, 0.05739761f, 0.03411118f, 0.01615387f, 0.01767199f, 0.04594449f, 
    0.04374411f, -0.06223538f, 0.04533862f, -0.01626234f, 0.07699921f, -0.00035416f, -0.06418904f, -0.05464789f, 
    -0.46826971f, -0.31589684f, -0.24260001f, -0.04321242f, -0.18808624f, -0.00752813f, 0.03739049f, -0.07886726f, 
    -0.07465453f, 0.04078006f, 0.05512115f, -0.02097490f, -0.04847272f, 0.04059721f, 0.01903180f, 0.06631229f, 
    -0.00434266f, 0.06769136f, 0.01650953f, 0.04103626f, 0.13015142f, 0.03269171f, 0.00074786f, 0.05271055f, 
    0.07159781f, 0.05205571f, 0.01700394f, 0.03077489f, 0.02461516f, 0.03429507f, 0.01678713f, 0.02125492f, 
    0.02911574f, -0.02877019f, 0.03829615f, 0.05624294f, 0.07128065f, -0.03518372f, -0.00641291f, 0.01462125f, 
    -0.27581784f, -0.11582056f, 0.05922566f, 0.01789766f, 0.08776855f, -0.04252283f, 0.08377086f, 0.04004004f, 
    0.06773235f, -0.10306220f, -0.05765936f, 0.03512583f, 0.08060990f, 0.04806214f, 0.02935174f, -0.01906458f, 
    -0.04025026f, -0.00825688f, -0.11413629f, -0.04234043f, 0.13962343f, -0.08180939f, 0.00006997f, 0.01471746f, 
    -0.00198354f, 0.00935989f, -0.09562835f, -0.00663721f, 0.00130152f, -0.06414245f, -0.02679615f, 0.00661219f, 
    0.03323708f, -0.04490493f, -0.02356018f, 0.00660261f, -0.01208464f, 0.01941060f, 0.07128826f, 0.04250009f, 
    0.38206804f, 0.02749433f, -0.16261072f, -0.18197230f, -0.05850739f, 0.00061907f, -0.02823536f, -0.05668943f, 
    0.02907086f, -0.00300081f, 0.04983914f, 0.02590889f, -0.00650503f, 0.01603219f, -0.00248184f, -0.00236048f, 
    -0.01131542f, -0.01725296f, -0.00083738f, -0.00562434f, 0.08882359f, 0.18520670f, -0.03927657f, -0.09609520f, 
    -0.09930546f, 0.00020838f, 0.04350758f, -0.03427956f, 0.05772231f, -0.05578095f, 0.06898677f, -0.03991922f, 
    -0.03061830f, 0.01669383f, 0.01909979f, 0.04511958f, 0.01414675f, 0.01859259f, -0.01541058f, 0.12121192f, 
    0.28223810f, -0.05783958f, -0.24071503f, 0.08154887f, -0.24270770f, 0.01314278f, 0.00593949f, 0.07958993f, 
    -0.05002780f, -0.00774197f, 0.01806836f, 0.01088805f, -0.03077402f, 0.01719971f, -0.01402408f, 0.03340631f, 
    0.02598332f, -0.07673866f, -0.01634321f, -0.07860398f, -0.21829043f, 0.02829615f, -0.03398636f, -0.00707719f, 
    -0.17602223f, 0.09863777f, 0.03660350f, 0.07425334f, 0.00097047f, 0.06746057f, -0.07655518f, -0.03905796f, 
    0.02399176f, -0.06301849f, 0.00705733f, -0.04055953f, 0.01991547f, -0.06814165f, -0.08655927f, -0.03277721f, 
    0.04331153f, -0.01820720f, 0.00347938f, 0.05505554f, -0.04656023f, 0.08354030f, 0.06882676f, 0.01825897f, 
    -0.02135782f, 0.02327833f, -0.00810059f, -0.01472894f, -0.02245520f, -0.02515719f, -0.05782599f, -0.10924126f, 
    -0.00612820f, -0.04220654f, -0.05823068f, 0.02226381f, 0.44467095f, 0.13450114f, -0.20332710f, -0.02939338f, 
    0.14313792f, -0.03147720f, -0.06728950f, -0.04657849f, 0.02531739f, -0.02112516f, 0.05620371f, 0.06637035f, 
    0.00417118f, 0.02590080f, -0.01892172f, 0.04959734f, 0.04369444f, 0.03224112f, -0.02557949f, 0.02521406f, 
    0.08760025f, -0.01584468f, 0.03745968f, -0.03442458f, -0.06316958f, -0.07515335f, -0.06252238f, 0.05876762f, 
    -0.11971381f, -0.14628291f, -0.11050957f, -0.10109186f, 0.07343066f, -0.00550387f, 0.00200198f, -0.02821810f, 
    -0.03931128f, 0.02234599f, -0.08615184f, 0.05147268f, 0.04080563f, 0.22054233f, -0.02423494f, 0.03799423f, 
    0.11660270f, 0.00158845f, 0.07265914f, -0.01454784f, 0.04104579f, 0.02277751f, -0.01195496f, 0.07613997f, 
    0.08350655f, 0.04364633f, 0.03799455f, 0.01621182f, 0.03514928f, 0.01041422f, 0.01482947f, 0.01518799f, 
    -0.04239289f, 0.22122951f, -0.10900094f, 0.10317449f, 0.28869623f, 0.19592240f, -0.05944425f, -0.02358649f, 
    0.04526956f, 0.06127659f, -0.03056117f, -0.05097486f, 0.07429009f, 0.06820655f, -0.01279112f, 0.03654433f, 
    0.04914204f, 0.07613631f, -0.06185693f, -0.10469145f, -0.02039520f, -0.06419236f, 0.06230552f, -0.01629427f, 
    -0.01760590f, 0.01687297f, 0.04662595f, 0.03122341f, 0.00797215f, 0.05301427f, -0.05641891f, -0.04880029f, 
    0.03832553f, -0.02008255f, -0.06465085f, -0.01658626f, 0.01869630f, -0.01056324f, -0.05462333f, -0.09409761f, 
    0.07377749f, 0.18956798f, -0.10117887f, -0.10476726f, 0.12621850f, 0.10864663f, 0.06086234f, -0.01891131f, 
    0.07229672f, -0.01356750f, 0.04974229f, 0.05426154f, -0.03173313f, 0.02627810f, 0.02344901f, 0.02192162f, 
    0.04536957f, -0.00313009f, 0.04281254f, 0.08397406f, 0.40375763f, 0.13630033f, -0.09587315f, -0.00779590f, 
    0.00222487f, 0.10405151f, 0.09523183f, -0.01241108f, 0.01762496f, 0.01854517f, 0.09174270f, 0.07443080f, 
    0.05429519f, -0.00899192f, 0.02341138f, -0.03475352f, -0.09456727f, -0.02312310f, 0.00331103f, 0.10415796f, 
    -0.24226484f, 0.36420739f, -0.02363304f, 0.06449611f, -0.05399983f, 0.15970172f, 0.08007730f, 0.00028170f, 
    -0.02022189f, -0.02670111f, 0.05340500f, -0.00490956f, 0.07319707f, -0.08010989f, 0.03685148f, 0.05786458f, 
    -0.00748533f, -0.00772767f, -0.00887574f, 0.01335602f, -0.42338863f, 0.13324186f, -0.07917131f, -0.13557313f, 
    0.18454322f, -0.08460180f, -0.09335964f, -0.01880154f, 0.08313134f, 0.08597655f, 0.02111269f, 0.04295423f, 
    -0.02862941f, 0.05568709f, 0.03953882f, 0.10062233f, 0.00724639f, -0.01055718f, -0.14332329f, -0.17416714f, 
    -0.18052739f, 0.01584749f, -0.03809627f, -0.00063816f, -0.04275298f, -0.01487102f, -0.03622694f, 0.02637315f, 
    0.00273357f, 0.00535203f, 0.00092569f, -0.04687837f, 0.03590001f, -0.02093334f, -0.01058267f, -0.03987899f, 
    -0.04627395f, -0.04078804f, -0.05180930f, 0.03654944f, -0.00082300f, 0.04756269f, -0.09519729f, -0.00557191f, 
    0.19685963f, 0.11740791f, -0.10571373f, -0.06419763f, 0.07532660f, 0.05404935f, 0.01591550f, 0.08044554f, 
    0.03807958f, -0.04312711f, 0.03876203f, 0.00099441f, 0.02184159f, 0.07751130f, 0.01859636f, 0.06013807f, 
    0.19271268f, -0.08296651f, -0.10497492f, -0.10577059f, -0.06315392f, -0.20684999f, -0.17152828f, -0.00425546f, 
    -0.14154766f, -0.04005973f, 0.01316923f, -0.03274961f, 0.05083643f, 0.03838561f, -0.13157846f, -0.02238406f, 
    -0.11165829f, -0.00435058f, 0.08557728f, 0.04273165f, 0.18505056f, 0.12192019f, -0.27647597f, 0.02070947f, 
    0.12605549f, 0.00983454f, -0.01455880f, -0.04826954f, 0.06443898f, -0.00895432f, 0.04633893f, 0.08315165f, 
    -0.04284095f, 0.00429533f, -0.08441880f, 0.05008987f, 0.04565367f, 0.08311474f, -0.02514462f, 0.04379058f, 
    0.16110264f, 0.02579368f, 0.01772683f, -0.05610158f, -0.00882875f, -0.07237251f, -0.01352025f, 0.09715413f, 
    -0.07647710f, -0.05783265f, 0.05374572f, -0.08019488f, -0.00057348f, -0.01048360f, -0.02550086f, 0.02072191f, 
    -0.04805727f, 0.01741068f, -0.05312300f, -0.06305319f, -0.15610540f, 0.14868727f, 0.01185288f, -0.02611621f, 
    0.02592576f, -0.03401444f, -0.06246553f, -0.00216936f, -0.08742583f, -0.00027958f, 0.03713418f, 0.02842060f, 
    0.02318606f, -0.01184883f, -0.01530067f, 0.04216656f, 0.05446748f, -0.05157835f, 0.06795119f, 0.00860524f, 
    0.17683965f, 0.00846636f, 0.02147126f, 0.02429030f, 0.06733216f, -0.01619392f, -0.03143270f, 0.03522643f, 
    0.03498709f, -0.03754044f, 0.00478706f, 0.02525694f, 0.04891331f, 0.05923992f, -0.07920890f, -0.03034294f, 
    0.00380756f, -0.00544468f, -0.07054873f, -0.09565398f, -0.16733946f, 0.08425895f, 0.01670033f, -0.00248552f, 
    0.01322681f, -0.07894869f, 0.01177651f, 0.00860093f, 0.00087614f, -0.02280354f, 0.00039910f, 0.02042023f, 
    0.00701545f, -0.02145393f, -0.02043174f, -0.00806823f, 0.01293116f, -0.01320868f, 0.02583501f, -0.02997234f, 
    -0.17957129f, 0.16482654f, -0.00577821f, -0.05794991f, 0.03698104f, -0.04717053f, 0.01470895f, 0.00262197f, 
    -0.05624560f, 0.03119662f, 0.00972690f, -0.00652404f, 0.04846947f, -0.02814017f, 0.05354699f, -0.03151900f, 
    -0.02389999f, -0.02282834f, 0.00710882f, -0.06485663f, -0.08029085f, 0.06100306f, -0.04576309f, -0.12318459f, 
    0.12066985f, -0.12915158f, -0.03853238f, 0.06960280f, 0.01057745f, -0.06131266f, 0.00164624f, -0.03438713f, 
    -0.00472631f, 0.00508646f, 0.04757154f, -0.02681894f, -0.02024426f, -0.01606500f, 0.08640246f, 0.03836383f, 
    -0.05292724f, -0.13322653f, 0.07690200f, -0.00632936f, 0.03975717f, 0.02749072f, 0.06833258f, 0.01742199f, 
    -0.00444816f, 0.07086742f, -0.06344159f, -0.00774622f, 0.02727504f, -0.02898776f, -0.04483747f, 0.03039128f, 
    -0.03099889f, 0.01360012f, -0.06943978f, -0.08577391f, -0.15244555f, -0.13966265f, -0.02947141f, -0.11901956f, 
    0.12150162f, 0.05470880f, -0.10455082f, -0.00289098f, 0.10908987f, 0.11233427f, 0.00359437f, 0.05483850f, 
    0.09122847f, 0.01071917f, -0.01320929f, 0.07418604f, 0.04811554f, -0.05963219f, -0.00703993f, -0.09081393f, 
    -0.17653520f, 0.00616022f, -0.10450322f, -0.17159282f, 0.06183714f, 0.02768096f, -0.05677393f, 0.06086134f, 
    0.01774965f, 0.10649810f, 0.01463762f, 0.02859687f, -0.06517481f, 0.06245195f, 0.05469142f, 0.01684649f, 
    0.07261747f, -0.04342675f, -0.00894203f, 0.01427739f, -0.22840533f, -0.18944640f, -0.14464913f, -0.10032457f, 
    -0.17765351f, 0.02654503f, 0.01447679f, 0.00135590f, 0.00324367f, 0.12031976f, 0.02548103f, -0.04650914f, 
    -0.04920764f, -0.10253149f, -0.02999497f, -0.08491919f, -0.05413094f, -0.01693949f, -0.12271311f, -0.05850234f, 
    -0.11651103f, -0.44414982f, -0.10007560f, -0.06103319f, -0.21175569f, 0.05267034f, 0.07168026f, 0.01672379f, 
    0.05468825f, 0.04248074f, -0.02845118f, 0.01223164f, -0.01675398f, -0.01505951f, 0.02476766f, -0.03281238f, 
    -0.01014674f, -0.04589080f, -0.06425272f, 0.02474802f, -0.23032264f, 0.22865701f, -0.02615338f, -0.00564481f, 
    -0.01441011f, -0.04689559f, -0.04204466f, 0.00828098f, -0.07863760f, -0.01275052f, 0.00440683f, -0.00985401f, 
    0.00095040f, -0.11753519f, 0.00977090f, 0.01203547f, -0.03597812f, -0.00757791f, -0.00753211f, -0.02391039f, 
    -0.35800666f, -0.17268483f, 0.02426454f, -0.02678189f, 0.06933957f, -0.00840124f, 0.05304198f, -0.02235531f, 
    0.03069825f, -0.06903236f, -0.02787153f, 0.05875013f, 0.05131547f, 0.04950039f, 0.01685738f, -0.02722226f, 
    0.03090770f, 0.00140607f, -0.05605666f, 0.00352607f, 0.15336840f, -0.06665811f, -0.06129527f, 0.01688371f, 
    -0.06078639f, 0.04847962f, -0.02751411f, -0.08308175f, -0.08329099f, -0.04338365f, -0.04947717f, -0.07376905f, 
    0.11856250f, 0.01659602f, -0.08600456f, -0.09012738f, -0.00303185f, -0.04853608f, 0.05581711f, 0.05250376f, 
    -0.19450440f, 0.03378123f, -0.11064560f, 0.00845345f, -0.28837851f, 0.08413815f, 0.02378746f, 0.07558084f, 
    0.00993818f, 0.02833720f, 0.01751976f, 0.01153123f, -0.04151933f, -0.00822690f, 0.03638455f, -0.08139902f, 
    0.01360540f, -0.04452001f, -0.06695492f, -0.01229625f, 0.05474490f, 0.04763914f, -0.05235714f, 0.05801668f, 
    0.10747181f, 0.11042041f, -0.11840978f, -0.02467668f, -0.05198383f, -0.00810074f, -0.04475599f, 0.05716532f, 
    -0.01662626f, -0.03228384f, -0.00275527f, -0.08325567f, 0.05372478f, 0.02818865f, -0.00545261f, 0.04111429f, 
    -0.02747492f, -0.12747554f, 0.06202909f, 0.13086657f, 0.08816283f, -0.03340635f, 0.18204395f, -0.01083069f, 
    -0.01213297f, -0.06060402f, 0.10048844f, -0.07739648f, -0.04826992f, 0.07786903f, 0.00029955f, -0.01606100f, 
    -0.00783979f, -0.07047695f, 0.06508871f, 0.06022002f, -0.16463995f, -0.12188119f, -0.13649869f, -0.07788333f, 
    -0.00667217f, 0.13026837f, -0.04148886f, -0.02082108f, -0.01466081f, 0.04556245f, -0.01160573f, 0.02255893f, 
    -0.01595141f, -0.02893802f, -0.02465557f, -0.03981442f, -0.07943314f, 0.01264358f, -0.10870434f, -0.11733256f, 
    -0.05205327f, -0.17201298f, -0.07115515f, 0.10054476f, -0.03508199f, -0.03202633f, 0.06443956f, -0.01636075f, 
    0.02771048f, -0.10484528f, 0.05794734f, -0.08937174f, -0.04562526f, 0.07817219f, 0.06465658f, 0.03609178f, 
    -0.01736193f, 0.00390191f, 0.05879182f, -0.01560668f, -0.06368723f, 0.03216604f, -0.09797336f, 0.04137217f, 
    -0.03416779f, -0.11264300f, -0.01573559f, -0.05414017f, 0.00546001f, -0.07104438f, 0.06768806f, -0.00287201f, 
    0.04907186f, 0.01432884f, -0.00136803f, 0.06614860f, 0.07538794f, -0.01481570f, 0.05615022f, -0.13515136f, 
    0.07911195f, -0.10666067f, -0.11770948f, -0.02198960f, -0.03674305f, 0.02881250f, -0.01588426f, -0.02222516f, 
    0.10154584f, 0.04624649f, -0.01682005f, 0.01015298f, 0.00517474f, -0.06760252f, -0.02167457f, -0.02414788f, 
    -0.02601898f, 0.01242886f, -0.04494087f, -0.03739015f, 0.00348328f, -0.28365985f, 0.06682318f, -0.02592016f, 
    -0.01477372f, -0.04114028f, 0.06456274f, 0.05180602f, 0.01683830f, -0.05018881f, -0.05328047f, -0.10743100f, 
    0.05924417f, 0.05784509f, -0.05062889f, -0.15755516f, -0.07960282f, -0.03982894f, -0.04336082f, -0.03546013f, 
    -0.35773829f, 0.23633634f, 0.04452182f, 0.00836858f, 0.12813577f, -0.10064828f, -0.05439709f, -0.02647334f, 
    0.05779619f, 0.03664963f, -0.00462637f, 0.07217073f, 0.04558990f, -0.02682253f, -0.02805207f, 0.03497928f, 
    -0.04494676f, -0.09607947f, -0.01739224f, 0.02589813f, -0.22526461f, -0.10113437f, -0.05441912f, 0.06154554f, 
    -0.07921669f, -0.07473347f, 0.05776881f, -0.06160205f, -0.00309456f, 0.03290592f, 0.00349009f, -0.02019962f, 
    0.07901035f, 0.07868224f, 0.04368280f, 0.05983466f, -0.00146040f, -0.13411470f, -0.01001988f, 0.04695419f, 
    -0.06290241f, 0.12231293f, 0.04775201f, -0.01998950f, -0.08858391f, 0.00128838f, -0.12648182f, -0.03119096f, 
    -0.06287042f, -0.09774382f, 0.03912985f, -0.02567846f, 0.04294101f, -0.10240319f, 0.02297263f, 0.08068887f, 
    0.06930187f, -0.07420996f, 0.02079805f, -0.01945658f, 0.12807496f, 0.00321047f, -0.00529894f, -0.04266516f, 
    -0.05078480f, 0.18130687f, 0.02087346f, -0.02100663f, -0.03281303f, -0.01566969f, 0.01031798f, -0.01501802f, 
    0.00880597f, 0.00744567f, -0.01877601f, -0.03624837f, 0.01467090f, 0.01370327f, 0.04409253f, 0.03864545f, 
    0.05095099f, -0.04413175f, -0.10451664f, 0.03715705f, 0.02517933f, 0.01721504f, 0.00073635f, 0.03525512f, 
    -0.11530044f, 0.00919678f, 0.03257193f, 0.02119644f, -0.03466276f, 0.00564647f, -0.01065018f, 0.04908949f, 
    0.02845789f, -0.00202973f, -0.02927829f, -0.05009604f, 0.24085513f, 0.01529287f, -0.13412990f, -0.06395092f, 
    -0.12689871f, 0.10348530f, 0.09944733f, 0.04653286f, -0.03171660f, 0.00098353f, 0.06774820f, 0.01967302f, 
    -0.02011020f, -0.04890148f, 0.04903515f, 0.01596944f, -0.09203640f, -0.02777776f, -0.08810316f, 0.01409715f, 
    0.22466744f, -0.03926741f, -0.12526935f, -0.10489559f, 0.03833848f, 0.02354680f, -0.03739363f, -0.00958081f, 
    0.00149275f, 0.00425658f, 0.02751046f, -0.05511757f, -0.01754017f, 0.01626736f, -0.02580292f, 0.07535651f, 
    0.05183518f, -0.03367825f, 0.01609382f, 0.04934069f, 0.17237699f, 0.20108017f, -0.11868182f, 0.07134465f, 
    -0.05194439f, 0.10065462f, 0.10925092f, -0.02289389f, 0.06014878f, 0.01478062f, -0.02209825f, 0.00376950f, 
    -0.02109244f, 0.00273129f, 0.07544477f, -0.05491124f, 0.09222677f, 0.01112557f, 0.01136977f, 0.05994730f, 
    0.00342876f, -0.02139474f, -0.15304907f, -0.00769989f, -0.26537916f, -0.13551323f, 0.07582655f, -0.09862861f, 
    -0.03967746f, 0.01344636f, -0.05736203f, -0.00902082f, 0.01596961f, 0.00352014f, 0.04169453f, 0.04320364f, 
    0.07198095f, 0.09712369f, 0.05349101f, -0.02966287f, -0.23144785f, 0.12915568f, -0.10424453f, -0.09774218f, 
    0.05403517f, 0.10508143f, -0.10009286f, 0.06755195f, -0.02155804f, -0.00811988f, -0.02393021f, 0.08664129f, 
    0.05427822f, -0.05623599f, 0.05275291f, -0.01175741f, 0.02590585f, -0.07401947f, 0.04500338f, -0.09021873f, 
    -0.04806140f, -0.10697383f, 0.04042586f, 0.01656456f, -0.05576249f, 0.01094901f, 0.00106176f, 0.00595352f, 
    -0.04985924f, -0.00105963f, -0.03543885f, -0.07199229f, 0.01581411f, -0.01081548f, -0.00951554f, -0.04652831f, 
    -0.04813605f, -0.01413612f, -0.08595280f, 0.00277662f, -0.07330345f, 0.05308988f, -0.02828092f, -0.05483662f, 
    0.18714848f, 0.02793504f, -0.01616073f, 0.03782565f, 0.04735769f, 0.07100704f, -0.07522105f, -0.04979604f, 
    0.00137274f, 0.02746644f, 0.15578385f, 0.03751947f, -0.01123672f, -0.03698427f, 0.04813726f, 0.01623622f, 
    -0.04221494f, -0.01439982f, -0.00446038f, 0.08371921f, -0.08197872f, -0.06022948f, 0.02859038f, 0.06801400f, 
    0.09319154f, -0.06984729f, -0.00359505f, -0.12532225f, -0.04491854f, 0.03129301f, 0.00698662f, 0.02221721f, 
    -0.02484092f, 0.00429094f, 0.10884438f, -0.06683080f, -0.38201562f, 0.12766621f, 0.11792277f, -0.06348152f, 
    0.09211864f, 0.01288081f, -0.06905293f, -0.00962362f, 0.04487117f, 0.02456171f, -0.02170745f, -0.03951104f, 
    0.04037825f, -0.05277406f, -0.11535867f, -0.06680708f, -0.11103283f, -0.02900201f, -0.11832746f, -0.01152934f, 
    0.03297136f, 0.02650718f, -0.04825392f, 0.16339438f, -0.05098940f, 0.10762594f, -0.01164341f, 0.01288113f, 
    -0.04196951f, -0.08713584f, 0.08137034f, 0.01516693f, 0.02066519f, 0.06576549f, -0.09845355f, 0.02189921f, 
    -0.04170831f, 0.06269462f, -0.11138565f, -0.12917979f, 0.01504614f, -0.15148629f, -0.11296137f, 0.02238063f, 
    0.02956685f, -0.11718089f, -0.00255476f, -0.02830837f, 0.01286066f, -0.08128932f, 0.01978133f, -0.02723355f, 
    -0.04262570f, 0.07675219f, -0.08321230f, 0.10161006f, 0.04879383f, -0.02968103f, -0.01402518f, -0.08928993f, 
    -0.10638374f, -0.21385257f, -0.07344724f, 0.02959665f, -0.17877118f, 0.08161028f, 0.04496101f, 0.03144091f, 
    0.03011946f, 0.02702945f, -0.06691206f, -0.02534544f, 0.00748860f, 0.01622292f, 0.00710640f, -0.08326843f, 
    0.02852933f, -0.03685582f, -0.07676364f, -0.03892307f, -0.00059222f, 0.08907104f, -0.02509306f, -0.23766650f, 
    -0.09324150f, 0.03183735f, -0.03281493f, -0.01096112f, 0.04373589f, 0.01840331f, 0.05077602f, -0.04971615f, 
    0.02488513f, -0.01162016f, 0.02343300f, -0.02523288f, 0.02867244f, 0.00834502f, 0.01410533f, 0.00779699f, 
    -0.10755078f, 0.19941850f, -0.06921285f, 0.04611681f, 0.04156522f, 0.08606541f, -0.05927351f, -0.00371580f, 
    0.00180401f, -0.02166406f, 0.09080780f, 0.07799248f, -0.04012404f, -0.05320345f, 0.07493390f, -0.01500483f, 
    0.08777625f, 0.01769197f, 0.00860395f, 0.02940684f, 0.00229912f, 0.05782923f, 0.00529454f, -0.03492155f, 
    -0.02837332f, 0.00483325f, 0.00277312f, -0.03524170f, -0.04218633f, -0.04761566f, -0.11845736f, 0.00343323f, 
    0.01572055f, 0.03718002f, -0.00510720f, 0.02646143f, -0.01842950f, 0.01526000f, -0.04336722f, 0.00453968f, 
    0.50547427f, -0.01281564f, -0.23307356f, -0.04476680f, -0.19330111f, -0.02990624f, -0.03015494f, -0.01686931f, 
    0.02707400f, 0.07213050f, 0.05331252f, -0.01858762f, 0.01746649f, -0.09044400f, 0.03286482f, 0.02747437f, 
    -0.02071773f, 0.00249741f, -0.01180733f, 0.02813507f, -0.02892280f, 0.02177276f, -0.10268483f, -0.01744142f, 
    -0.05152137f, -0.02783027f, -0.03161968f, -0.02179049f, 0.03751011f, -0.02380366f, -0.01809028f, 0.01503112f, 
    0.02702463f, -0.03741164f, -0.02551597f, 0.04203911f, 0.02096349f, 0.00632061f, 0.01436131f, -0.02475279f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03297130f, 0.01659257f, -0.02374088f, -0.00633185f, 0.00651225f, -0.01421168f, 0.00237551f, -0.01324031f, 
    0.01296925f, -0.01835980f, 0.06598923f, 0.00934131f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
