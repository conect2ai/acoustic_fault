#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17795195f, 0.08673371f, -0.32093075f, -0.96139169f, -1.00919104f, -0.08702984f, 0.26516721f, 0.66512471f, 
    -0.12900656f, 0.25518563f, -0.43473187f, -0.37938872f, -0.39026803f, 0.03725626f, 0.40866324f, 0.36752930f, 
    0.05731413f, -0.25546163f, -0.14338453f, -0.02217626f, -0.37277988f, -0.08129164f, 0.07430047f, -0.27860740f, 
    -0.55110776f, 0.09513807f, 0.35329407f, -0.68883550f, -0.76380694f, 0.03854498f, 0.14974596f, -0.51025391f, 
    -0.04842292f, -0.61507845f, -0.63391978f, 0.42031360f, -0.07234255f, 0.72685754f, -0.28729585f, -0.06428830f, 
    0.08324217f, -0.29253072f, -0.24306609f, 0.09370255f, -0.03859905f, 0.06777193f, 0.18218583f, 0.24549389f, 
    0.00175807f, 0.19156766f, 0.58290374f, 1.38566673f, 0.23291597f, -0.61774546f, -0.11081982f, -0.11062657f, 
    -0.11546725f, 0.12719466f, -0.22771201f, -0.14731403f, -0.18176109f, 0.42600426f, 0.01391749f, 0.00334535f, 
    -0.31613278f, 0.01081630f, 0.23128252f, -0.19630469f, 0.00322421f, -0.32489657f, -0.29171079f, 0.18017584f, 
    -0.24720694f, 0.07741646f, -0.14916849f, -0.36464807f, 0.15908517f, 0.27721110f, -0.77632326f, -0.91212827f, 
    0.28839082f, 0.44152629f, 0.27093098f, 0.12739229f, -0.16551252f, 0.31590563f, 0.33958936f, -0.06091284f, 
    0.17268196f, -0.55974513f, -0.10948001f, -0.07818841f, -0.30807370f, 0.36324745f, 0.01736192f, 0.23552965f, 
    -0.15882237f, 0.30291179f, -0.39853933f, -0.16155793f, -1.08158600f, 0.33614710f, 0.54289407f, 0.21579219f, 
    0.32373315f, -0.33306029f, 0.13839565f, 0.54683548f, 0.38552460f, -0.10674128f, -0.42602193f, 0.43383244f, 
    -0.48743257f, 0.42462283f, -0.22555941f, 0.03976314f, -0.14137973f, -0.47048825f, -0.39394060f, 0.23546785f, 
    -0.08223726f, 0.45176974f, 0.17118250f, 0.06697024f, -0.04199992f, -0.36546040f, -0.60050559f, -0.39032575f, 
    0.85491925f, 0.40256992f, 0.70675474f, -0.14865200f, -0.28388035f, -0.48715463f, 0.21300882f, 0.42369908f, 
    -0.23146744f, 0.05967766f, 0.04579122f, -0.17144179f, 0.13509326f, -0.02673646f, 0.25479326f, 0.18437874f, 
    -0.06681850f, -0.28336471f, 0.37495428f, 0.18513252f, 0.04199173f, 0.11190802f, -0.15356715f, -0.44359687f, 
    -0.24457969f, -0.25225613f, -0.14369807f, -0.14938210f, -0.39737418f, -0.17269561f, -0.28458676f, -0.26872566f, 
    -0.15128852f, -0.44605190f, -0.21501897f, 0.49839699f, -0.79016888f, -0.05751460f, -0.18514091f, -0.27115732f, 
    0.02843863f, 0.01162266f, -0.16733949f, -0.18175630f, -0.34597999f, -0.25220829f, 0.12673678f, -0.60669136f, 
    0.05045124f, -0.20413609f, -0.51292354f, -0.35672110f, -0.01635972f, 0.08373728f, -0.42271802f, -0.36147147f, 
    0.30089408f, 0.30252692f, 0.39019269f, 0.11486685f, -0.39656407f, -0.49298143f, -0.00387079f, 0.00908241f, 
    0.11150630f, 0.13592999f, 0.28220466f, -0.00703139f, -0.10132951f, -0.67657179f, -0.47069374f, -0.19975837f, 
    0.57307315f, -0.72520572f, -0.55613381f, -0.33023074f, -0.59843683f, 0.49085706f, 0.09987600f, 0.18357173f, 
    -0.12434581f, -0.07609054f, 0.10279626f, -0.04439646f, -0.38495424f, -0.45960754f, 0.21824419f, -0.11991796f, 
    -0.08750336f, 0.40303907f, -0.21754462f, 0.42583466f, -0.19912001f, -0.21444426f, 0.22312884f, 0.37247980f, 
    0.41649935f, 1.12698734f, -0.70472318f, -0.92469257f, -0.57160336f, 0.03228470f, 0.47589594f, 0.40319139f, 
    0.44251564f, 0.18967935f, 0.02750367f, -0.02825865f, 0.11758041f, 0.01284521f, -0.10121217f, -0.16970290f, 
    0.11176300f, -0.08460210f, -0.33166939f, -0.24826141f, -0.42613357f, 0.18731353f, -0.23701090f, -0.15758236f, 
    0.06104748f, -0.13724795f, -1.15956879f, -0.61884928f, -0.29490083f, -0.16185732f, -0.38823652f, 0.11745691f, 
    0.06462798f, -0.50838250f, 0.26073036f, 0.31223467f, -0.08721276f, -0.09561153f, 0.28801295f, -0.13114190f, 
    -0.24934983f, 0.13192283f, -0.39816484f, -0.28313267f, -0.34890783f, -0.12572999f, 0.15726538f, 0.28711423f, 
    0.17023274f, 0.04215141f, 0.03404410f, 0.52693099f, 0.44656134f, 0.45014933f, 0.51840770f, 0.44553766f, 
    0.07404953f, 0.24062465f, 0.24904631f, 0.00427556f, 0.28017905f, 0.11471301f, -0.08731045f, 0.11336875f, 
    0.07265466f, -0.08465245f, -0.10420147f, 0.19337493f, -0.05001134f, 0.10580330f, -0.29035240f, -0.08401822f, 
    -0.44263300f, -0.23432653f, 0.02902955f, 0.00000705f, 0.59615308f, 0.82343447f, -0.17396097f, -0.33892554f, 
    0.88829064f, 0.15258670f, -0.37669140f, -0.49009600f, -0.63391155f, -0.57238799f, -0.17004134f, -0.01324022f, 
    0.14831589f, -0.23598872f, -0.02734317f, -0.08545998f, -0.01178053f, -0.00741883f, 0.00518019f, 0.30487835f, 
    -0.13750553f, 0.15440269f, -0.12386802f, 0.09479588f, -0.01001792f, 0.48641402f, -0.11248566f, 0.16132461f, 
    0.01273623f, 0.41233921f, -0.48000821f, -0.14956757f, 0.32755491f, -0.23438920f, -0.18679781f, -0.17241728f, 
    -0.04837982f, 0.06240639f, -0.05451475f, -0.17746298f, 0.23058417f, -0.32811296f, -0.01279445f, -0.06332080f, 
    -0.41121158f, 0.03750657f, 0.20691484f, -0.08981424f, 0.43426332f, 0.49043083f, 0.67552078f, -0.08647580f, 
    -0.12911262f, -0.25288099f, 0.16527583f, -0.26581293f, 0.33085737f, 0.11837599f, 0.31292343f, -0.19555770f, 
    -0.42414227f, 0.18410976f, 0.08212721f, 0.28816772f, 0.06573360f, 0.01559930f, -0.26260740f, 0.03611558f, 
    0.29221541f, -0.37492880f, 0.21007751f, 0.37291670f, 0.41771364f, -0.25875726f, -0.23573473f, 0.02791366f, 
    -0.16705367f, -0.20768408f, 0.35812968f, 0.31440619f, -0.05659942f, 0.01356190f, 0.34386814f, 0.23787634f, 
    0.29419285f, 0.02595990f, 0.17618944f, -0.01835810f, -0.15179236f, 0.27410561f, -0.36039653f, 0.23550479f, 
    0.13161759f, 0.09843047f, -0.19568202f, 0.27575737f, 0.15392350f, -0.31041345f, 0.49225065f, 0.40596998f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05104386f, 0.06370763f, 0.46126598f, 0.27389094f, 0.33914712f, 0.39969680f, -0.24008468f, 0.10864796f, 
    -0.09506777f, -0.02889167f, -0.08857128f, -0.16346912f, 0.21826102f, 0.33538058f, 0.28340510f, 0.04662021f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00771932f, 0.00714815f, 0.20659021f, 0.12178619f, 0.16634083f, 0.05172330f, 0.10920677f, 0.00649637f, 
    0.08607170f, 0.14369160f, -0.07924099f, 0.20853159f, 0.33456311f, 0.07927039f, -0.05461813f, 0.04053606f, 
    -0.09607069f, -0.01247757f, 0.08320124f, 0.07557900f, 0.03744029f, 0.07392262f, 0.02550926f, -0.01423415f, 
    -0.28608394f, -0.20268774f, -0.02365168f, 0.24103309f, -0.03132807f, -0.13681440f, 0.07587953f, -0.19914632f, 
    -0.08654293f, -0.04940044f, -0.05985881f, 0.08954912f, 0.15224564f, -0.05644814f, -0.03732529f, -0.17609587f, 
    -0.06431626f, -0.24243313f, 0.16996139f, 0.12796102f, -0.06259517f, -0.02504005f, 0.04343551f, 0.08779918f, 
    -0.14153582f, -0.28156608f, -0.01610849f, -0.18508305f, 0.10715863f, 0.16998328f, -0.07048173f, 0.21577501f, 
    0.03615524f, -0.03311957f, -0.03490997f, 0.27743107f, 0.15965118f, 0.04769014f, 0.09854402f, -0.02309231f, 
    -0.10818963f, -0.00521265f, 0.13939279f, -0.05395264f, -0.12035643f, 0.02301982f, -0.03350997f, -0.15734078f, 
    0.11052485f, 0.09804477f, -0.05178060f, 0.02948209f, 0.13666335f, 0.20907779f, 0.00702979f, 0.16611144f, 
    -0.03973762f, 0.00430359f, 0.18780094f, -0.02762442f, 0.26956612f, 0.05905614f, -0.11547630f, 0.04769270f, 
    0.05163654f, 0.09505101f, -0.00902843f, -0.10916994f, 0.25574890f, 0.12514950f, 0.11954668f, 0.08352089f, 
    0.21954279f, 0.20078683f, 0.08052545f, 0.04551590f, 0.16757119f, -0.16948703f, 0.18461479f, -0.02929731f, 
    -0.11985262f, -0.02659609f, -0.20329970f, -0.03721724f, 0.36202514f, -0.17422305f, 0.07445341f, 0.54480058f, 
    -0.02940068f, -0.06957743f, -0.03211174f, -0.02408658f, 0.03758028f, -0.04536197f, 0.05721993f, 0.24833006f, 
    0.37882739f, 0.38587382f, -0.05255768f, 0.16235203f, 0.03469490f, 0.03060013f, 0.01547811f, 0.02052561f, 
    -0.00727131f, -0.17338280f, -0.06032752f, 0.13302858f, -0.36740085f, -0.44682956f, -0.20994920f, 0.12476449f, 
    0.00337831f, 0.16203366f, 0.07731623f, -0.00045974f, 0.09475285f, 0.02659832f, 0.05121164f, 0.07453173f, 
    0.09111723f, 0.24301991f, -0.30773506f, 0.01689664f, 0.12311339f, -0.07072219f, 0.03856526f, 0.27318880f, 
    -0.02112480f, 0.07959060f, -0.09121431f, -0.22446969f, -0.25892434f, -0.14665273f, 0.10326684f, -0.05938677f, 
    -0.14510766f, 0.23326555f, 0.16202061f, 0.02965115f, -0.23523244f, -0.36531618f, -0.15140058f, -0.20331064f, 
    -0.09608689f, -0.20279332f, -0.05874265f, -0.03566463f, -0.09123593f, 0.10310862f, 0.08801638f, 0.07257461f, 
    0.08602110f, -0.32658824f, -0.21257636f, 0.02672222f, -0.18967216f, 0.20052044f, -0.03032286f, 0.06536977f, 
    -0.06592165f, -0.10888497f, -0.02710010f, -0.09019344f, -0.10937321f, 0.07124395f, -0.00131419f, -0.23823319f, 
    -0.17942876f, 0.30814469f, 0.30601671f, -0.20163235f, -0.09115157f, -0.24112904f, 0.00048142f, 0.14011730f, 
    0.19603170f, -0.14333485f, -0.16188483f, 0.01738085f, 0.12860802f, -0.12349259f, 0.53169495f, 0.14772511f, 
    0.01433353f, 0.44480953f, 0.03430172f, 0.10504118f, 0.01799389f, -0.02748591f, -0.03690751f, -0.10948888f, 
    0.13397206f, -0.10047315f, 0.07550205f, 0.19012935f, 0.03628399f, 0.19626638f, -0.22053804f, -0.23071034f, 
    -0.02056875f, 0.01468151f, 0.19092269f, -0.21735227f, -0.01985268f, 0.06713064f, -0.26393577f, -0.06526963f, 
    0.17042415f, 0.08635565f, 0.12473495f, 0.04573774f, 0.04849577f, 0.05704494f, -0.01636306f, 0.09894826f, 
    0.02456193f, -0.39988276f, 0.14355966f, 0.17739998f, 0.02891047f, -0.17437994f, -0.17215623f, -0.02131415f, 
    0.01261730f, -0.10399199f, -0.07584469f, 0.08571604f, -0.19374169f, 0.27140522f, -0.19489759f, 0.24991402f, 
    0.12079480f, 0.08251701f, 0.34261608f, -0.16943048f, 0.18173273f, -0.03104911f, 0.13973118f, 0.22080839f, 
    -0.09156480f, 0.36537561f, 0.32450679f, 0.23715623f, 0.10798436f, 0.05196670f, -0.03793314f, -0.01736694f, 
    0.00635674f, -0.15281984f, 0.09052197f, -0.15653889f, -0.03633837f, 0.16055840f, -0.10950511f, 0.05260874f, 
    -0.03647384f, -0.06430195f, 0.02190249f, 0.18157114f, -0.10880488f, -0.04849530f, 0.10709294f, -0.06918767f, 
    -0.00333523f, 0.34177065f, 0.39708158f, 0.34073544f, -0.00628274f, 0.30751741f, 0.03201906f, 0.18138978f, 
    0.08367302f, 0.15407319f, -0.14373383f, -0.03114882f, -0.20402771f, -0.14986429f, -0.01722289f, -0.00025858f, 
    -0.08527222f, 0.06602224f, -0.09737221f, 0.12769784f, 0.10313525f, -0.23684666f, -0.25911728f, 0.03488909f, 
    -0.08387183f, 0.06893411f, 0.21612953f, 0.29013357f, 0.18508747f, -0.08846486f, -0.06764165f, 0.15135516f, 
    0.05463361f, -0.16953570f, 0.07397325f, -0.06125762f, 0.05311831f, -0.07439257f, -0.05335807f, 0.09820367f, 
    -0.03756095f, -0.04105647f, -0.18361911f, -0.01855392f, 0.02028143f, -0.08425283f, -0.16421266f, -0.03019296f, 
    0.24740846f, 0.46861097f, 0.32015169f, -0.19198006f, -0.04938624f, 0.15198429f, -0.16892213f, -0.00866306f, 
    -0.04609122f, 0.02045607f, 0.03426616f, -0.23941277f, 0.21860969f, -0.17213899f, 0.19624425f, -0.07506526f, 
    -0.01460026f, 0.19492705f, -0.05610248f, 0.24738817f, 0.03881094f, 0.02041946f, -0.08499923f, -0.09087989f, 
    0.27426779f, -0.31092232f, -0.05348568f, -0.07664726f, -0.09806371f, 0.05917161f, -0.12218960f, 0.01214753f, 
    0.05111901f, 0.27557793f, 0.17576580f, -0.08107717f, -0.21458532f, -0.11784985f, 0.00930350f, 0.10297151f, 
    0.05083786f, -0.07923199f, -0.06234227f, 0.12499397f, 0.01023733f, 0.16690026f, 0.14231938f, -0.05632545f, 
    0.05426850f, -0.10123830f, 0.09659441f, 0.35795379f, 0.00996637f, 0.14759582f, 0.12155559f, -0.00486169f, 
    -0.07605963f, -0.07629404f, -0.13033241f, -0.07800823f, -0.08561175f, -0.33613253f, 0.08535792f, 0.13346535f, 
    0.07828005f, 0.03912765f, 0.10029018f, -0.01209037f, -0.01085138f, 0.00614765f, 0.17167091f, 0.01447764f, 
    0.15257327f, 0.12490024f, 0.79238743f, -0.20028698f, -0.10329217f, -0.18452607f, -0.09138560f, 0.06297936f, 
    0.02194120f, -0.05170032f, 0.11684021f, 0.30532041f, 0.27482951f, -0.12537470f, 0.18636668f, 0.19459268f, 
    -0.11541487f, 0.12165780f, 0.09414475f, 0.04734702f, -0.16847722f, 0.08251601f, 0.06280954f, 0.01802263f, 
    0.48555329f, 0.03957764f, -0.11741927f, -0.39817649f, -0.18764959f, 0.12410214f, 0.00217596f, -0.03447365f, 
    -0.10503718f, 0.04362272f, 0.02202994f, 0.13346756f, -0.24630317f, 0.41782525f, -0.31811607f, -0.08605213f, 
    0.16638508f, 0.04147049f, 0.42514375f, 0.17834114f, -0.07587955f, 0.02319689f, 0.16638038f, 0.12881197f, 
    -0.10012075f, -0.16737540f, -0.06867740f, 0.02709776f, 0.10668358f, -0.04566123f, 0.21703702f, -0.04473337f, 
    0.02858041f, -0.17207813f, 0.01918285f, -0.08195596f, 0.10017602f, -0.24231584f, -0.23791486f, 0.06056633f, 
    0.03124855f, 0.04019030f, -0.15826687f, -0.09163413f, -0.11837461f, -0.15161934f, -0.11571214f, -0.02033957f, 
    -0.17457561f, 0.20134410f, -0.00319988f, 0.19380893f, 0.11855922f, 0.15008509f, 0.18785450f, -0.00232604f, 
    0.08795844f, 0.04122648f, -0.08611462f, -0.07082400f, -0.03641748f, -0.03787613f, -0.29408386f, 0.15954749f, 
    0.06988125f, 0.02699155f, 0.14328720f, 0.10198167f, -0.04828671f, -0.13891916f, 0.04014399f, 0.02212237f, 
    -0.01708899f, -0.14113143f, 0.02066265f, 0.23542219f, -0.03254114f, 0.22636932f, 0.11910571f, 0.12063829f, 
    -0.12522714f, 0.22355905f, 0.11380663f, -0.02272837f, 0.17003813f, 0.40428314f, 0.12564301f, -0.26640841f, 
    -0.25095102f, -0.13345511f, -0.07465246f, -0.09371163f, 0.02225038f, 0.04055651f, -0.06189904f, -0.20001327f, 
    0.10762555f, -0.05486232f, 0.33963478f, 0.15933916f, -0.23808502f, -0.14800592f, -0.14105487f, 0.01667464f, 
    -0.09698873f, -0.01592616f, 0.01338883f, 0.07046907f, 0.25058818f, 0.39694527f, -0.06612568f, -0.01164438f, 
    -0.25662383f, -0.01460479f, 0.01863501f, -0.15702879f, -0.02642156f, 0.01476058f, 0.03887768f, 0.12273873f, 
    0.16359887f, 0.25934306f, 0.23519988f, 0.09573158f, -0.18087719f, 0.20346558f, -0.07698826f, 0.12545910f, 
    -0.12149685f, -0.05820308f, 0.27703345f, 0.11741257f, -0.02213191f, 0.13692372f, -0.09907892f, -0.18987550f, 
    0.05642233f, 0.05638971f, 0.00970416f, -0.06324573f, 0.05660390f, 0.03508288f, -0.00984725f, 0.10498341f, 
    -0.46726447f, 0.26020330f, 0.28730348f, -0.07678352f, 0.06003137f, 0.01750948f, 0.10715086f, -0.05617493f, 
    -0.04521216f, 0.17381936f, -0.18710244f, 0.03674876f, 0.11607521f, 0.24536978f, -0.18321863f, -0.12164549f, 
    -0.00967968f, 0.11490002f, 0.06041980f, 0.17344134f, 0.07442590f, 0.18507209f, -0.17908788f, -0.18347467f, 
    -0.23875852f, 0.11691742f, 0.09709914f, 0.14499211f, -0.05856593f, -0.11609514f, 0.08502080f, 0.13320433f, 
    0.05879358f, -0.03830275f, -0.05275142f, 0.13985620f, -0.00660639f, 0.14552344f, -0.08837905f, -0.51444900f, 
    -0.07596628f, -0.07000735f, 0.17728333f, 0.09409289f, 0.09466099f, -0.02388266f, 0.08336952f, 0.09085516f, 
    -0.06574213f, -0.10228799f, -0.15870245f, -0.03873276f, 0.31701770f, 0.18738627f, -0.09824095f, -0.20709026f, 
    0.01176564f, -0.10433707f, -0.07872138f, 0.13285245f, 0.32294065f, -0.38644856f, -0.21203628f, -0.10289443f, 
    0.00234304f, 0.15463334f, 0.05175889f, -0.05296028f, -0.19575433f, 0.02017981f, 0.06421076f, -0.04813996f, 
    0.07195517f, -0.04701644f, 0.15376100f, -0.03381636f, 0.13422777f, 0.05140357f, -0.00214256f, 0.26685908f, 
    0.11287189f, -0.03226502f, 0.01587123f, 0.14100079f, 0.22877605f, 0.25794008f, 0.07080834f, -0.14451894f, 
    -0.12289469f, 0.07052977f, -0.07700847f, 0.09824423f, 0.23980059f, 0.11619675f, 0.07278644f, -0.08000077f, 
    0.11657966f, -0.11431279f, 0.02551975f, -0.27028671f, -0.04542262f, -0.17935428f, 0.08325117f, 0.05285524f, 
    -0.08161541f, -0.10517377f, -0.13806558f, -0.04125018f, -0.09245820f, -0.23326565f, 0.42577860f, 0.28700492f, 
    -0.13162541f, -0.10777295f, 0.12131646f, -0.10952275f, -0.11489322f, 0.15367904f, 0.07256495f, 0.21230777f, 
    0.46251661f, 0.32182232f, -0.25334457f, 0.02657024f, 0.10838079f, -0.09419127f, 0.04123916f, 0.12878504f, 
    0.06125901f, 0.04811912f, 0.07372473f, 0.10673799f, 0.06142132f, -0.06017986f, 0.02588859f, 0.05384738f, 
    -0.05807746f, 0.10129175f, -0.01878821f, -0.03199476f, 0.25042924f, 0.02965662f, 0.00679045f, 0.14834651f, 
    0.51635045f, 0.18766341f, -0.09618896f, -0.03215738f, -0.08482709f, 0.00608461f, 0.08374414f, 0.17147535f, 
    0.12958719f, -0.00372986f, -0.10986797f, -0.06801786f, 0.29522595f, 0.22174700f, 0.19643818f, 0.34366229f, 
    -0.15396112f, -0.07017563f, -0.09899694f, -0.21984197f, -0.03912421f, -0.16816984f, -0.20149992f, -0.52017707f, 
    0.31508470f, 0.01906231f, -0.05588130f, 0.13709177f, -0.07348849f, -0.08113342f, -0.02107216f, -0.05100006f, 
    0.09881736f, -0.05681865f, -0.00252936f, 0.07892610f, 0.20756270f, -0.03672886f, -0.29126328f, -0.24946046f, 
    0.01144692f, 0.02584213f, -0.31597823f, -0.38746956f, -0.20071386f, 0.15330300f, -0.24007922f, -0.48603860f, 
    -0.10610646f, 0.17288642f, -0.11190456f, -0.26731110f, -0.05826103f, 0.06993515f, -0.02654932f, 0.18927558f, 
    0.08344475f, -0.00158879f, 0.19633339f, 0.04847204f, -0.08511637f, 0.52957046f, 0.04597360f, -0.29606265f, 
    0.10411691f, -0.03640371f, -0.00300901f, 0.11488985f, -0.00024199f, -0.00877123f, -0.05016400f, -0.10778204f, 
    0.22930215f, -0.01355163f, -0.55133086f, 0.00770912f, 0.04215950f, 0.13451718f, 0.06101615f, -0.03018291f, 
    0.10484486f, -0.14980794f, 0.16515803f, -0.02809241f, -0.28727615f, 0.31221884f, -0.04458482f, -0.06102848f, 
    0.05330035f, -0.08315557f, -0.04882044f, -0.10999221f, 0.23756918f, 0.08757189f, 0.22282866f, 0.13648069f, 
    -0.26848561f, -0.05989219f, -0.12148927f, 0.36948454f, 0.00104686f, 0.06778257f, -0.04541946f, -0.14682978f, 
    0.03067617f, -0.03827208f, -0.04254704f, -0.12913169f, 0.09889628f, -0.27766877f, 0.32460365f, -0.05029649f, 
    0.13860302f, 0.04981061f, -0.15741695f, 0.12745376f, 0.03148960f, -0.12051502f, -0.13996165f, -0.16986924f, 
    0.01004802f, -0.06556094f, 0.10804143f, -0.09249140f, -0.06758054f, 0.06777564f, -0.08925167f, 0.08788892f, 
    0.04610738f, 0.17480528f, 0.04394870f, 0.28581467f, -0.04439953f, 0.07818636f, 0.34310159f, -0.10600120f, 
    -0.09121014f, 0.08147201f, 0.19189328f, 0.04803170f, 0.15897305f, 0.27389908f, 0.17696983f, 0.25362822f, 
    0.17923489f, -0.11718218f, 0.11383779f, -0.10429356f, -0.13942440f, -0.00101350f, 0.00795345f, -0.02130348f, 
    -0.21509781f, -0.21177183f, -0.00913127f, -0.01669278f, -0.03636260f, 0.06875202f, 0.26024362f, -0.23790090f, 
    0.04438486f, -0.12375926f, 0.01713274f, 0.02091834f, 0.08426572f, 0.07446351f, 0.14942466f, 0.08298159f, 
    -0.03624400f, 0.09761903f, 0.06731536f, -0.10407346f, 0.00837257f, -0.18962891f, -0.13549039f, -0.14705683f, 
    0.07112948f, -0.08761813f, -0.14676374f, 0.07602960f, -0.01940451f, -0.20257893f, -0.05883298f, 0.08822867f, 
    0.10780516f, -0.01101544f, 0.13398340f, 0.00491138f, -0.01950603f, 0.19526669f, 0.10307984f, 0.09690454f, 
    0.28758886f, 0.18499567f, 0.07924341f, -0.14425471f, 0.12915006f, 0.15570217f, 0.04199480f, 0.03425030f, 
    0.09566207f, -0.14703749f, 0.03766929f, -0.01389171f, 0.13781556f, -0.12332552f, -0.06817958f, 0.06135856f, 
    0.33666331f, 0.00514453f, -0.08718342f, -0.12450428f, -0.08990528f, -0.16155866f, -0.23470165f, -0.14711230f, 
    0.04747180f, -0.16525896f, -0.01942660f, -0.02078619f, 0.12811261f, -0.06371605f, 0.12626366f, -0.05468963f, 
    0.17987485f, 0.18672588f, 0.00302593f, -0.08021610f, 0.01439238f, -0.28326592f, -0.10016327f, 0.14922655f, 
    0.04769518f, 0.08322550f, 0.01515265f, 0.01926142f, -0.10027177f, 0.10833175f, -0.09506125f, -0.00550561f, 
    -0.02212351f, -0.35753334f, -0.12954229f, 0.42547619f, 0.22743312f, -0.02483010f, 0.21342044f, 0.06577338f, 
    -0.17716399f, 0.05895726f, -0.13979408f, 0.06099229f, 0.06438425f, 0.13052042f, -0.08705589f, 0.45658836f, 
    0.05334203f, 0.11193306f, 0.17765367f, 0.04883627f, -0.02691572f, 0.04067498f, 0.04357508f, 0.09909611f, 
    -0.34907284f, 0.36730316f, 0.12992866f, 0.18969747f, -0.25677279f, -0.17774136f, 0.00743215f, 0.04513156f, 
    0.19015364f, -0.01406836f, -0.09025253f, 0.08613542f, 0.08144587f, -0.31415945f, -0.45278224f, 0.28421262f, 
    -0.00284587f, -0.03385480f, 0.15349869f, 0.21677233f, -0.19018719f, 0.06117488f, -0.13216515f, -0.03002833f, 
    0.33682469f, 0.31491473f, 0.07049028f, -0.21865091f, -0.12175108f, -0.14322990f, 0.04466146f, -0.00523238f, 
    0.08681004f, 0.09279656f, 0.02351762f, -0.07711704f, 0.25629812f, 0.03841426f, -0.02885857f, -0.35908058f, 
    -0.01687023f, 0.20688093f, -0.07255147f, 0.01326246f, -0.03242402f, 0.27703685f, 0.10920516f, 0.17820668f, 
    0.11065762f, 0.06877474f, -0.01308343f, 0.24185863f, 0.06215225f, 0.12453011f, 0.04817543f, 0.08896244f, 
    0.07922315f, -0.06863131f, -0.10579911f, 0.00425019f, -0.04668316f, -0.04886252f, 0.04588389f, 0.28299344f, 
    0.20254907f, -0.11800302f, -0.17972355f, 0.12260247f, -0.14910841f, -0.20209125f, -0.12459435f, 0.00869152f, 
    -0.07428128f, -0.10062549f, -0.09042346f, 0.25173521f, -0.05706517f, -0.12542994f, -0.05571179f, -0.03595632f, 
    0.03909446f, 0.02629588f, 0.02853837f, 0.15393201f, -0.04142473f, -0.27813232f, -0.28815913f, 0.29019275f, 
    -0.04893927f, 0.04180369f, 0.06307945f, -0.09374389f, 0.05501406f, -0.06526139f, -0.15200195f, -0.20569059f, 
    0.39539608f, -0.12607008f, -0.09550332f, 0.04411478f, 0.16020758f, 0.28260234f, 0.03150518f, 0.18384030f, 
    -0.05208218f, 0.17605090f, 0.11367916f, 0.09867220f, 0.02919132f, 0.05252651f, 0.01787732f, -0.03169781f, 
    -0.05999745f, -0.06782895f, -0.01986567f, -0.10777539f, 0.08405745f, 0.02678309f, 0.04759083f, 0.01650950f, 
    0.01193652f, 0.19863512f, 0.17614265f, 0.07549527f, -0.18492116f, -0.20472276f, 0.17347600f, -0.01874443f, 
    -0.01442465f, -0.00952785f, -0.08016194f, -0.11181883f, 0.02771905f, 0.25192568f, 0.10072026f, 0.18618594f, 
    -0.03115598f, -0.21487612f, -0.07141025f, -0.17771794f, 0.03658460f, 0.06744956f, 0.02753847f, 0.10006250f, 
    -0.13899520f, 0.14459310f, -0.06880380f, 0.07732169f, 0.01412988f, -0.10040040f, 0.07987857f, -0.07866219f, 
    0.00025396f, -0.07706165f, 0.09550271f, 0.32613871f, 0.08433487f, -0.01527424f, 0.03415576f, -0.24899822f, 
    0.01979749f, -0.02476936f, 0.00024843f, -0.15654223f, 0.11629489f, 0.04525551f, 0.19567619f, 0.19533761f, 
    -0.19702271f, 0.03669610f, -0.23371717f, 0.10236355f, -0.11717278f, -0.16331103f, 0.07502118f, 0.19529478f, 
    0.10637058f, -0.06330129f, -0.02870117f, 0.05291872f, -0.03450118f, -0.44993368f, 0.05299585f, -0.16207656f, 
    0.13821603f, 0.12571910f, 0.11641083f, -0.08865874f, -0.14182694f, 0.18420289f, -0.12917791f, -0.07805299f, 
    0.47093099f, 0.17516267f, 0.24605584f, 0.22086382f, 0.01661272f, -0.02556544f, 0.05827795f, -0.05632326f, 
    0.03100750f, 0.05312072f, 0.05183533f, 0.12956706f, -0.21666217f, -0.61031163f, -0.13102902f, -0.27328128f, 
    0.08140586f, -0.07272726f, -0.05885079f, -0.10505717f, 0.22213350f, 0.29286888f, 0.06367353f, -0.02426285f, 
    0.18443306f, 0.00611913f, 0.29583335f, 0.01344452f, -0.22418965f, 0.12303863f, 0.04018597f, 0.02352725f, 
    0.10460456f, -0.06204249f, 0.13479701f, -0.05095312f, -0.03191760f, -0.00138536f, -0.09006204f, 0.03818761f, 
    0.33479324f, 0.09558718f, 0.16636774f, 0.08172365f, -0.29253361f, 0.11813676f, 0.00336902f, 0.03865982f, 
    0.05326699f, -0.27318391f, -0.10787258f, -0.01246986f, 0.18830222f, -0.05593129f, 0.17259598f, 0.00839901f, 
    0.12989245f, -0.03377686f, 0.09150635f, 0.18351881f, -0.24789047f, -0.08175370f, -0.21928856f, 0.17940217f, 
    0.00243594f, 0.19540703f, 0.23676571f, -0.00807350f, 0.14779669f, 0.10926998f, 0.14100437f, 0.02005098f, 
    -0.31228054f, -0.26122892f, -0.55235779f, 0.23906732f, -0.15314849f, -0.03324392f, -0.02811033f, 0.08602973f, 
    -0.01472325f, 0.01140308f, -0.12425922f, -0.13923685f, 0.15361539f, -0.50085378f, -0.67161787f, 0.01116098f, 
    0.05871806f, -0.06096391f, -0.04253522f, 0.11375507f, 0.26672277f, 0.10404892f, 0.20886594f, 0.00957975f, 
    -0.23368081f, -0.81473732f, -0.54731756f, -0.55777490f, -0.05923911f, 0.09988062f, 0.03944354f, -0.00876549f, 
    -0.23200920f, 0.18848677f, 0.08422180f, -0.11519819f, 0.32258853f, 0.34609312f, 0.18736510f, 0.11543489f, 
    -0.08079015f, -0.04157118f, -0.01185074f, -0.03992631f, 0.14369932f, 0.04329018f, 0.01285629f, -0.00875231f, 
    0.69332182f, 0.76220846f, 0.13747309f, 0.22781478f, 0.04636742f, -0.01529898f, -0.02965410f, 0.00590371f, 
    -0.08711605f, 0.00490963f, 0.01598752f, 0.11644000f, 0.37215164f, 0.36548972f, 0.00165440f, -0.01017839f, 
    0.05502261f, -0.07673960f, -0.07973514f, -0.18765901f, -0.10781354f, -0.08442054f, -0.08153041f, -0.00974905f, 
    0.45163637f, 0.16056351f, 0.14420803f, 0.08371060f, -0.01099870f, 0.10390437f, -0.03599374f, 0.11879328f, 
    -0.04840819f, -0.13221687f, 0.07371477f, -0.15207100f, 0.06626344f, 0.08594061f, 0.05071238f, -0.02785887f, 
    0.04853539f, 0.01214680f, 0.05144725f, -0.02301456f, 0.03172794f, -0.11939429f, -0.09916780f, -0.03900275f, 
    -0.07294701f, -0.15595883f, 0.16040015f, -0.07204810f, 0.02523375f, -0.00127954f, 0.04756003f, 0.20575516f, 
    -0.05168672f, 0.10907345f, 0.18370433f, 0.30993873f, 0.36826512f, 0.06370074f, 0.16333556f, 0.20180728f, 
    -0.14227180f, 0.13761440f, -0.07891344f, 0.20840231f, -0.01779777f, 0.01838271f, -0.16610652f, -0.12792015f, 
    -0.05165029f, -0.22554240f, 0.13389948f, -0.03290599f, 0.06684455f, 0.04227459f, 0.04833544f, -0.13758366f, 
    -0.11318051f, 0.22288959f, 0.05153713f, 0.07737237f, 0.15205392f, -0.24932274f, 0.10418531f, -0.15372434f, 
    0.19977304f, 0.11782639f, -0.14143123f, -0.06363657f, -0.35476375f, 0.20471188f, 0.22339582f, -0.00983588f, 
    -0.37681693f, -0.30613300f, 0.27326122f, -0.17547280f, 0.12872544f, 0.06178994f, -0.07937037f, 0.16845222f, 
    -0.01327966f, -0.02808395f, 0.09635094f, 0.00385961f, -0.09993462f, 0.08494384f, -0.06492838f, 0.13345209f, 
    0.22099908f, 0.13902530f, -0.02145908f, -0.03592545f, 0.00076847f, -0.13890044f, -0.08954622f, -0.21658731f, 
    0.06247910f, -0.11935109f, 0.20481370f, 0.19701077f, 0.06331987f, -0.13459852f, 0.10060239f, 0.09933601f, 
    -0.03470098f, -0.05205602f, 0.21827631f, 0.14252488f, 0.23792641f, 0.34122527f, 0.05798755f, 0.16926555f, 
    -0.10644745f, -0.21076584f, 0.04608096f, 0.05609795f, 0.11299451f, 0.11558146f, 0.07094955f, 0.04987950f, 
    0.46127456f, 0.40640122f, 0.05811507f, 0.26949427f, 0.07140580f, -0.12020373f, -0.04776859f, 0.01319532f, 
    -0.10735432f, 0.00854246f, -0.12395021f, -0.03303783f, 0.17191955f, -0.04895753f, 0.03705633f, 0.18516487f, 
    0.00175791f, 0.05122641f, -0.10313164f, 0.00341830f, -0.18315031f, -0.10236131f, 0.14430282f, 0.20354669f, 
    0.25778607f, 0.53206509f, 0.02960885f, 0.02588730f, 0.09496009f, -0.15236296f, -0.01772613f, 0.15553878f, 
    -0.00574880f, -0.10619010f, 0.09885984f, 0.06394230f, -0.12971222f, -0.26501659f, -0.25651950f, -0.09693117f, 
    -0.02391624f, 0.19719149f, 0.11794769f, 0.09294769f, 0.10341620f, 0.25790587f, 0.07329663f, 0.14166316f, 
    0.53053164f, 0.23782521f, -0.08428486f, 0.16316473f, -0.23478878f, -0.15363988f, -0.31339699f, 0.12135351f, 
    -0.02193273f, 0.05080214f, -0.03700588f, -0.05696297f, 0.02655955f, 0.03362769f, 0.13266073f, -0.07847313f, 
    -0.21057419f, -0.09230483f, 0.00666137f, 0.05092281f, -0.06187918f, -0.15525064f, -0.14808239f, -0.13107920f, 
    0.36217672f, -0.10313866f, 0.02311616f, -0.01258891f, 0.06159104f, 0.07556971f, -0.06221714f, 0.21073502f, 
    0.17956482f, -0.03309104f, -0.09190233f, -0.31027955f, -0.02481668f, 0.06435142f, -0.11166351f, 0.05636429f, 
    0.20121214f, -0.05864130f, 0.00266722f, 0.11141416f, 0.07812483f, 0.18138619f, -0.08182967f, -0.11654034f, 
    -0.01540155f, -0.08246279f, -0.24470437f, 0.19195494f, 0.02599988f, 0.16017416f, 0.16831391f, 0.13662413f, 
    -0.07949398f, -0.19059944f, 0.13222520f, 0.24616180f, -0.16417579f, 0.38416272f, 0.01469494f, -0.07380634f, 
    0.08327603f, 0.00613922f, 0.07682630f, 0.04343872f, 0.07232931f, 0.13400510f, 0.01810662f, -0.32929796f, 
    -0.18288255f, 0.12324853f, -0.01815584f, -0.15404241f, -0.07731789f, 0.09356822f, -0.15384035f, -0.03223979f, 
    0.02775873f, 0.06078647f, 0.09285189f, 0.01975136f, -0.04638733f, 0.27731591f, 0.16874380f, 0.41768852f, 
    0.15329030f, 0.26030040f, 0.00070532f, -0.07122039f, 0.02898941f, -0.07988835f, 0.11680478f, -0.10162323f, 
    0.29111183f, 0.31971610f, -0.26094392f, -0.22889137f, 0.00888431f, 0.07475905f, -0.16639577f, -0.17865297f, 
    -0.06597227f, -0.06515726f, 0.05637587f, 0.03071566f, 0.06208869f, 0.14225331f, 0.18793604f, -0.25298315f, 
    0.05796326f, -0.03001018f, -0.35067329f, 0.04247096f, 0.07667631f, -0.07625535f, 0.04236734f, -0.18151052f, 
    -0.10794896f, -0.19859104f, 0.06350785f, 0.05833948f, -0.01928119f, 0.01528137f, -0.09011268f, 0.09334432f, 
    0.09250346f, 0.09863488f, 0.03438575f, 0.03411264f, -0.10002445f, -0.00702671f, 0.10122604f, 0.15917122f, 
    0.14631724f, 0.08706722f, 0.18043318f, 0.03222549f, -0.02513219f, 0.13654302f, -0.10821466f, 0.09171917f, 
    -0.26867983f, -0.03982957f, 0.08924000f, 0.16215925f, -0.10724948f, -0.14882015f, -0.06957430f, -0.02498182f, 
    -0.11643814f, -0.08812064f, 0.12105282f, -0.08198638f, -0.49146578f, 0.10183606f, 0.10994767f, 0.01394941f, 
    0.13821588f, 0.04676680f, 0.09314312f, -0.16070274f, -0.01728967f, 0.16092196f, 0.21729137f, 0.13118209f, 
    0.04492969f, -0.15523276f, -0.01452483f, 0.13491401f, -0.02059830f, 0.01078181f, -0.05986281f, -0.23539816f, 
    0.19043168f, 0.14188083f, -0.09178941f, 0.12402129f, -0.20131238f, -0.06318804f, -0.04605823f, -0.13126296f, 
    0.08505923f, -0.11179985f, 0.08073255f, 0.06330144f, -0.06798171f, 0.18992943f, 0.03602217f, 0.29709408f, 
    -0.04602249f, -0.04629016f, 0.79517132f, 0.12327872f, -0.02695869f, 0.11184293f, 0.05630029f, 0.09593640f, 
    0.08117074f, -0.01586593f, -0.02386900f, -0.04950551f, 0.00127118f, 0.06480904f, -0.04723443f, 0.18718831f, 
    0.18624662f, -0.30862203f, -0.20705587f, -0.09588379f, -0.09150076f, -0.02542543f, 0.04953258f, -0.12230278f, 
    -0.20967816f, 0.05120979f, 0.05623508f, 0.12450568f, 0.13865760f, 0.03945038f, -0.01443851f, -0.07330510f, 
    0.06799403f, 0.01797920f, 0.11970005f, 0.03902214f, 0.19475389f, -0.18521757f, -0.17448160f, -0.07313284f, 
    -0.02647870f, -0.10877654f, 0.04400410f, 0.01508683f, -0.23796920f, -0.17515157f, -0.18746825f, 0.09309506f, 
    0.05368654f, 0.02713477f, 0.00054703f, 0.32162204f, 0.04757106f, 0.09052326f, 0.15451095f, -0.15350090f, 
    0.00781042f, -0.12368775f, -0.06179428f, 0.33107060f, 0.14425001f, 0.31400865f, -0.17962116f, -0.02933685f, 
    0.23854476f, 0.18616650f, 0.08513242f, -0.10207044f, 0.03255884f, 0.01737379f, 0.00415245f, -0.30417582f, 
    -0.00684535f, -0.10952739f, 0.27512032f, -0.24343148f, 0.19381191f, -0.00635974f, -0.47785023f, -0.32415396f, 
    -0.00642505f, 0.01023688f, 0.05941499f, 0.03448732f, 0.27289328f, 0.03108964f, -0.07599825f, 0.26165095f, 
    0.07930294f, 0.11379977f, -0.08569386f, -0.11910202f, 0.01512940f, 0.12089418f, 0.21963294f, -0.02240176f, 
    0.44992447f, -0.21391095f, -0.42575598f, -0.42619422f, -0.05080524f, 0.13505460f, -0.11308216f, 0.21691728f, 
    -0.04982683f, -0.13366395f, -0.05068336f, 0.06703112f, -0.09713199f, 0.42727625f, -0.15120915f, -0.28858709f, 
    0.10051047f, -0.06974812f, 0.25101590f, 0.05206011f, -0.02566264f, -0.20095719f, 0.09204597f, 0.01247756f, 
    -0.05224834f, -0.32989442f, 0.14617617f, 0.06659175f, 0.22140580f, 0.09737080f, -0.02290447f, 0.04974665f, 
    -0.00421687f, -0.20819886f, 0.09225022f, 0.04506850f, 0.38541415f, -0.08888385f, -0.21186635f, 0.26921687f, 
    0.06519911f, -0.00862195f, -0.16723794f, -0.09880286f, 0.10372612f, 0.14732753f, 0.10882700f, 0.05505630f, 
    -0.17421348f, 0.22272176f, 0.09913616f, 0.16170579f, 0.21220228f, 0.04850490f, 0.08338008f, -0.26051226f, 
    -0.04291409f, 0.07797940f, -0.08167613f, -0.15758467f, -0.13758469f, 0.14290410f, -0.15751006f, 0.49608314f, 
    0.01904793f, 0.01524977f, 0.21603557f, -0.04149370f, -0.02331980f, 0.11971404f, 0.11682221f, 0.29300416f, 
    0.43549567f, 0.10716704f, 0.03212525f, 0.44327587f, 0.12557942f, -0.05370530f, 0.04952594f, -0.04528327f, 
    0.03785940f, -0.01835939f, 0.00109560f, 0.16489953f, -0.00797192f, 0.18787645f, 0.10771509f, -0.01255424f, 
    -0.15084556f, -0.27568546f, -0.00975663f, 0.08021578f, -0.03647720f, 0.11451633f, -0.05193841f, 0.09721366f, 
    0.03029091f, 0.31721231f, 0.56529927f, 0.10971382f, 0.09380368f, 0.12884218f, -0.16366366f, 0.06971630f, 
    -0.12265100f, 0.06952727f, -0.00892991f, -0.05599468f, 0.17020547f, 0.22085410f, -0.02044183f, 0.15593152f, 
    -0.04596953f, -0.01144907f, 0.06822441f, -0.09741764f, -0.29384172f, -0.17257325f, -0.09421528f, -0.19724119f, 
    0.20585597f, -0.02233645f, 0.01809847f, 0.27539152f, -0.16499908f, 0.20552164f, 0.07096450f, -0.01313543f, 
    -0.08287024f, -0.28623980f, 0.02767350f, -0.21467245f, -0.08792241f, -0.04349067f, -0.30931339f, -0.14019862f, 
    0.02163425f, -0.14725934f, -0.00241716f, -0.02372314f, -0.33932042f, -0.08925992f, -0.14576299f, -0.18881552f, 
    0.40368593f, -0.21691552f, -0.11353087f, 0.09153967f, -0.03230032f, 0.25103793f, -0.08827331f, 0.17494851f, 
    0.04767144f, 0.00998163f, 0.38007572f, -0.20601436f, -0.14628623f, -0.11441353f, -0.26032925f, -0.23424146f, 
    -0.12861435f, -0.10917880f, -0.02133528f, 0.05325707f, -0.20428506f, 0.08145524f, -0.00960768f, 0.05730683f, 
    -0.21385755f, 0.02663247f, 0.29947364f, -0.29441875f, 0.10606870f, 0.08291068f, -0.00310456f, 0.32037362f, 
    -0.06687462f, -0.06156374f, -0.17093694f, 0.30713695f, -0.11493156f, -0.22567677f, 0.13284390f, 0.15779077f, 
    -0.16911629f, 0.53946733f, -0.06729027f, 0.12328205f, 0.08598608f, 0.13032044f, 0.10249616f, 0.05026983f, 
    -0.26762632f, 0.09480269f, -0.25559947f, -0.04414447f, -0.02564494f, -0.03073867f, -0.07846279f, -0.14331646f, 
    -0.03442129f, -0.01908037f, 0.28302145f, 0.38346988f, -0.19156888f, 0.09271745f, -0.06302982f, -0.18790399f, 
    0.11007638f, -0.01618141f, 0.11570989f, 0.13053222f, 0.04053223f, 0.04092303f, 0.06381296f, -0.02908897f, 
    0.19694924f, -0.11451184f, -0.20309192f, -0.03135185f, 0.11764640f, 0.00542940f, 0.27369893f, 0.12125178f, 
    0.22896251f, -0.01857118f, 0.05832122f, 0.04232096f, -0.07580034f, 0.03078749f, 0.03341794f, -0.02363092f, 
    -0.17026253f, 0.19705901f, 0.05690977f, 0.06864710f, -0.00047734f, -0.03511867f, -0.12824987f, 0.01555498f, 
    0.17677148f, -0.21436030f, -0.13570553f, -0.21665844f, 0.10472579f, 0.21249864f, 0.01182032f, 0.04652891f, 
    0.11985201f, -0.19218528f, 0.06076886f, -0.01560636f, 0.11446048f, 0.09732223f, -0.01933413f, -0.05271747f, 
    -0.05241425f, 0.10300059f, 0.03560855f, -0.10679103f, -0.02291649f, 0.46219599f, 0.21104226f, -0.01467783f, 
    -0.32792446f, -0.29963973f, -0.09942226f, -0.04913644f, 0.01938883f, 0.15681300f, 0.09504170f, 0.02929131f, 
    -0.02719465f, 0.21656221f, -0.08124057f, 0.00550235f, 0.02586020f, 0.17552990f, 0.21918528f, -0.08957843f, 
    -0.06388704f, -0.05820078f, -0.06996772f, -0.08430267f, -0.29281130f, -0.15722080f, 0.05496929f, -0.10017051f, 
    -0.19920067f, -0.48768127f, -0.02782964f, 0.04893633f, 0.19676445f, 0.18739730f, 0.22027923f, -0.15342040f, 
    -0.08715701f, -0.00039351f, -0.05754927f, 0.02498145f, 0.08537500f, 0.07992686f, -0.14740366f, -0.07988361f, 
    0.20539154f, -0.12302783f, 0.08079269f, -0.06362094f, 0.01348726f, 0.16548122f, 0.09613286f, 0.09668847f, 
    0.00258054f, 0.14745590f, 0.05901682f, 0.04297283f, 0.12733534f, 0.27138260f, -0.07328260f, -0.07402568f, 
    -0.00165027f, -0.03116544f, 0.08025396f, 0.18752639f, -0.16751409f, -0.09421354f, 0.02604842f, -0.14753485f, 
    0.07460196f, -0.10271178f, 0.07230714f, 0.02835906f, 0.31438088f, 0.07586021f, 0.02136447f, 0.20287891f, 
    -0.03197099f, 0.01298630f, -0.00453508f, -0.02390512f, 0.04014746f, -0.07336090f, -0.01882575f, -0.02723961f, 
    0.06402484f, 0.00424249f, 0.05550734f, -0.00088639f, -0.05979803f, 0.03605456f, 0.00726688f, -0.07496719f, 
    -0.06198131f, 0.02213858f, 0.02180423f, 0.02230785f, -0.02147099f, 0.02428786f, 0.01563532f, 0.04320674f, 
    -0.05616976f, -0.05162181f, -0.01927890f, 0.06552938f, -0.06307749f, -0.04743076f, -0.03811154f, 0.03895724f, 
    -0.05895745f, -0.05611767f, -0.00034467f, -0.02058637f, 0.05197885f, 0.02523135f, -0.01226616f, 0.06296864f, 
    -0.04733637f, 0.04726957f, 0.02813529f, -0.02498124f, 0.05150064f, -0.02817784f, -0.02879486f, 0.06687827f, 
    -0.06442347f, -0.07678795f, -0.07148046f, -0.03694890f, -0.03037000f, -0.01912114f, -0.05523170f, -0.02627324f, 
    -0.03222850f, 0.01810730f, 0.01345465f, -0.00305992f, -0.02072764f, -0.02108239f, 0.01716429f, -0.00101084f, 
    -0.01476151f, -0.07762185f, 0.05448380f, -0.05797495f, 0.02939436f, 0.04503240f, 0.01682654f, -0.01122743f, 
    -0.04835262f, 0.02139987f, 0.04123817f, -0.06247978f, 0.05433182f, -0.07447146f, -0.00009911f, 0.06075723f, 
    -0.03151830f, 0.01036443f, 0.00871429f, 0.04947430f, 0.02377878f, 0.06256595f, -0.00991452f, -0.07142287f, 
    -0.05903917f, -0.05024822f, -0.04089132f, -0.05137056f, -0.06174389f, -0.06824672f, 0.05971169f, -0.00702224f, 
    -0.02355381f, 0.02304702f, 0.05548678f, 0.03418764f, -0.07047322f, -0.05189427f, -0.02058493f, -0.00773667f, 
    -0.07552263f, 0.00814397f, 0.01955896f, -0.02037567f, 0.01756867f, 0.01068357f, 0.03685132f, -0.00131788f, 
    -0.04449043f, 0.04504604f, -0.02246288f, -0.01626402f, 0.04672645f, -0.00202165f, -0.03668103f, -0.04950182f, 
    0.03479456f, 0.03840698f, -0.03760496f, -0.06128648f, -0.06460863f, 0.03483490f, 0.05017545f, 0.01472761f, 
    -0.03296985f, 0.01465413f, -0.02672964f, 0.03604184f, -0.06495010f, -0.06958092f, -0.00674978f, -0.06124397f, 
    0.01954525f, 0.04521907f, -0.04704860f, -0.02977032f, 0.00996364f, 0.00717023f, -0.05375245f, 0.03169085f, 
    -0.07090323f, -0.05396140f, -0.00958380f, 0.01184543f, 0.00564933f, -0.00595433f, 0.03341498f, 0.03103996f, 
    -0.06430037f, 0.04597782f, 0.02274221f, 0.02941863f, 0.01030898f, -0.06485857f, -0.07703812f, -0.01902603f, 
    -0.06158594f, -0.06509073f, -0.03202127f, -0.01296851f, -0.03217609f, -0.04705412f, -0.04956039f, -0.03680277f, 
    -0.04657396f, 0.05480020f, -0.06396967f, -0.04380317f, 0.06171684f, -0.07685680f, -0.05770618f, 0.01528176f, 
    0.02388707f, -0.01845324f, -0.07270925f, 0.02556848f, -0.06941216f, 0.00880159f, 0.03031340f, -0.06757275f, 
    -0.06169191f, -0.07437085f, 0.06197805f, -0.03542507f, -0.04958495f, 0.04114774f, -0.02231605f, -0.02204617f, 
    -0.07187225f, 0.34619790f, 0.44229826f, -0.24477637f, -0.07489428f, 0.17021570f, -0.08227524f, -0.24544461f, 
    0.08593123f, 0.12585993f, 0.14891928f, 0.18579994f, -0.18078750f, -0.05402224f, -0.09093872f, -0.44561884f, 
    -0.04522341f, -0.12014354f, -0.00119548f, 0.03566676f, -0.02856135f, -0.13698167f, -0.09885245f, -0.02184770f, 
    0.29417962f, -0.31948644f, 0.12864457f, -0.38583609f, 0.03290237f, 0.01208172f, -0.08198698f, 0.06071427f, 
    -0.11679419f, 0.06891517f, 0.13069136f, -0.00126276f, 0.06404752f, 0.53339767f, 0.37070525f, -0.06780361f, 
    0.02394920f, -0.02852012f, -0.03636527f, -0.03181423f, 0.25324833f, 0.02716967f, -0.00065946f, 0.09366699f, 
    0.11543187f, -0.23274013f, -0.32041180f, 0.04057416f, -0.13403885f, 0.12642877f, -0.00758867f, 0.11392106f, 
    0.02676601f, -0.00555181f, -0.08260349f, 0.28053948f, -0.15950797f, 0.08712482f, 0.08453707f, 0.28126732f, 
    0.12853660f, -0.10528522f, 0.17590262f, 0.34436122f, -0.05740274f, -0.23369926f, 0.03008655f, -0.17368154f, 
    -0.32911482f, -0.15063310f, 0.06605557f, -0.35871732f, -0.06100775f, 0.03013792f, 0.12245158f, -0.24036370f, 
    -0.02435548f, -0.07940588f, 0.29892316f, 0.12496722f, 0.22422405f, -0.12210712f, -0.22128449f, 0.00689021f, 
    -0.12329874f, 0.18376128f, -0.11867592f, -0.23552606f, 0.30271158f, 0.22632208f, 0.03596285f, 0.06559222f, 
    -0.08922174f, 0.49869436f, 0.48075476f, -0.14581797f, 0.04029736f, 0.07492094f, 0.10041319f, -0.26233691f, 
    -0.15613787f, -0.05649436f, -0.04328747f, -0.06591434f, 0.10331178f, 0.36796409f, 0.28034058f, -0.11734305f, 
    -0.03044539f, 0.02746638f, -0.00279056f, 0.14478593f, 0.07322570f, -0.00846003f, 0.14357921f, 0.12063859f, 
    -0.15464313f, 0.17016046f, 0.04236257f, 0.40536878f, -0.23361290f, -0.13665560f, 0.01084189f, -0.18806261f, 
    -0.02684919f, -0.29562429f, -0.11659230f, -0.18346334f, -0.09958853f, -0.08195066f, -0.02303133f, -0.06643277f, 
    0.12934165f, -0.03691205f, 0.01664330f, 0.18153766f, -0.14502242f, -0.08174427f, -0.00928860f, -0.06292300f, 
    -0.20612250f, -0.11068642f, 0.13640513f, -0.10077871f, 0.12734643f, -0.00624784f, 0.00249466f, 0.13398065f, 
    -0.08902512f, 0.14298303f, 0.11071383f, 0.01210540f, 0.03340216f, -0.15643418f, -0.22734936f, -0.12157515f, 
    -0.02545558f, 0.09714303f, 0.09355506f, 0.09393563f, 0.03038950f, -0.00684083f, -0.01694753f, -0.04065513f, 
    0.12422645f, -0.04275553f, 0.05259128f, 0.13189657f, -0.02649194f, 0.29256827f, 0.15059902f, 0.10171899f, 
    0.08477709f, -0.18738596f, 0.09513223f, -0.05189898f, -0.09150928f, -0.00111267f, -0.06376609f, 0.12324322f, 
    0.11044820f, 0.02059140f, 0.13723533f, 0.21996501f, -0.04788215f, 0.07192109f, 0.01889939f, -0.04205045f, 
    0.43304417f, -0.36945215f, 0.15895905f, 0.22776701f, 0.01509854f, 0.08405790f, -0.14133368f, 0.00853367f, 
    -0.12648058f, 0.12625301f, 0.05033062f, -0.16297540f, -0.13260858f, -0.08563194f, -0.39394397f, 0.08350082f, 
    0.03738501f, 0.13808779f, 0.19723731f, -0.10343304f, -0.17881949f, -0.03232538f, 0.06671764f, 0.23879930f, 
    -0.52821994f, 0.10280975f, 0.43943551f, -0.05291107f, -0.14343308f, -0.15994200f, -0.19101115f, -0.11304878f, 
    0.14760903f, 0.01374348f, -0.13006088f, 0.21543340f, -0.00500141f, -0.28101632f, -0.11661422f, 0.07462185f, 
    -0.09499860f, 0.11637699f, 0.02249709f, 0.03143556f, -0.02958584f, 0.09229384f, 0.05862895f, 0.02084841f, 
    -0.05340818f, 0.07430784f, -0.16080816f, 0.02245407f, -0.07556662f, -0.21761091f, -0.05521960f, -0.06339739f, 
    -0.01848829f, 0.17162409f, -0.04938948f, 0.05546358f, 0.11167563f, 0.17182852f, -0.30533624f, -0.29864585f, 
    -0.07015605f, 0.05321746f, 0.14811629f, 0.08188285f, 0.07932090f, 0.03306439f, 0.07313821f, 0.20535330f, 
    0.16386466f, -0.11169083f, -0.06691448f, 0.13968852f, 0.09468473f, 0.21069443f, 0.06919511f, -0.04492129f, 
    -0.01802380f, -0.25663757f, 0.00723409f, -0.22152770f, -0.00193489f, -0.05597164f, -0.06652595f, -0.04238240f, 
    0.12512949f, -0.07471538f, -0.10295171f, 0.10891512f, -0.17574514f, -0.06951211f, -0.03657005f, -0.14913161f, 
    0.19326220f, 0.05126639f, -0.07816623f, -0.04315615f, 0.19231214f, 0.32613248f, 0.14863446f, 0.04514965f, 
    0.11860555f, -0.07691353f, 0.05808543f, 0.14622293f, 0.53365469f, 0.24097088f, -0.03543112f, 0.11570725f, 
    -0.07833519f, 0.07590148f, 0.15845791f, -0.16052899f, 0.03506321f, 0.07337847f, -0.01370622f, -0.04598660f, 
    0.00971026f, -0.16476926f, 0.00487093f, 0.14012231f, 0.24586342f, 0.25326183f, 0.09718628f, 0.21921915f, 
    0.02076846f, 0.12172918f, -0.07873968f, 0.15981828f, -0.05752514f, 0.17166054f, 0.11658736f, 0.04495778f, 
    -0.17231144f, -0.12487482f, -0.24853837f, -0.32912359f, -0.05839562f, -0.21805629f, 0.05317260f, -0.15601118f, 
    -0.09818819f, -0.21804395f, -0.26237947f, 0.07420494f, -0.15803610f, -0.17791848f, 0.03122002f, 0.01922053f, 
    -0.03263481f, -0.07343502f, -0.04011639f, 0.00638240f, -0.03858544f, 0.35432729f, 0.12018918f, 0.15600549f, 
    -0.18238480f, -0.03795977f, 0.14583981f, 0.02830837f, 0.11755071f, 0.21307248f, 0.15253669f, 0.28716937f, 
    -0.18886064f, 0.09406849f, -0.01856168f, 0.11632967f, -0.00530150f, -0.01403058f, -0.04266516f, -0.11512171f, 
    -0.02019292f, 0.02696541f, 0.16427478f, 0.01472920f, -0.21882357f, 0.06297933f, 0.02874324f, -0.14953208f, 
    0.01662518f, -0.04733036f, 0.00341690f, -0.05500267f, 0.28394821f, 0.04151468f, 0.01489200f, 0.15246680f, 
    0.21435958f, -0.04919739f, -0.11122329f, 0.08086962f, 0.22748648f, 0.05124846f, -0.01280273f, 0.06370448f, 
    0.19859174f, 0.14027026f, 0.00998011f, 0.03116688f, 0.14181429f, 0.50297338f, -0.53423673f, -0.11488875f, 
    0.26905149f, 0.21046919f, 0.20651279f, -0.05263344f, -0.06082515f, 0.03823764f, 0.18755944f, 0.06346367f, 
    -0.27466768f, 0.15558769f, -0.31190783f, 0.38741633f, 0.02116946f, -0.25073445f, -0.04726969f, -0.17185123f, 
    0.24304797f, -0.05060743f, 0.01090264f, 0.01200374f, -0.14305018f, 0.31369439f, -0.62610084f, -0.00285561f, 
    -0.04983045f, -0.09696318f, 0.09047640f, 0.12663771f, 0.14107670f, 0.01997594f, 0.12367789f, 0.19303846f, 
    -0.07138284f, 0.18287346f, -0.01802504f, 0.57704222f, -0.03325806f, -0.21116568f, -0.03913648f, -0.19669391f, 
    -0.06263916f, 0.05606513f, -0.20153689f, -0.15340696f, 0.33916688f, -0.22752753f, 0.19698958f, -0.39856374f, 
    -0.08822443f, 0.21176895f, -0.08918159f, 0.04997487f, 0.20466138f, 0.05652245f, 0.03178963f, 0.04554486f, 
    0.26164904f, 0.24524899f, -0.05611826f, -0.03988162f, -0.04756108f, 0.23031104f, -0.13208814f, 0.13688689f, 
    -0.14981031f, 0.02389382f, 0.06944589f, 0.02495265f, -0.11171791f, 0.24314013f, 0.21818382f, -0.21039152f, 
    0.18829820f, -0.01118464f, -0.20120955f, 0.29522488f, 0.02899589f, 0.16350813f, 0.18264554f, 0.26358789f, 
    0.28654987f, -0.17834130f, -0.09876105f, -0.37165123f, 0.01256651f, 0.21728233f, -0.04488030f, -0.08371583f, 
    0.00038697f, -0.01983206f, 0.09164355f, 0.08155750f, 0.29182315f, 0.16155642f, 0.28807047f, -0.05401406f, 
    0.01202514f, -0.16692199f, 0.18133850f, -0.36104852f, 0.13961001f, 0.04852429f, -0.24568714f, -0.13069589f, 
    0.08882893f, 0.24591663f, 0.11464530f, -0.21903971f, 0.20598446f, 0.27073392f, 0.06706943f, 0.06608467f, 
    0.10922421f, -0.12904601f, -0.09132435f, 0.27432251f, -0.13228370f, -0.18304813f, 0.04512644f, 0.27627012f, 
    -0.14457433f, -0.09592307f, -0.12576564f, -0.12994094f, 0.00683695f, -0.16696984f, 0.05131729f, 0.04203580f, 
    -0.05591170f, 0.02845565f, -0.10228472f, -0.04282721f, 0.17418602f, 0.10426558f, 0.18357839f, -0.01301601f, 
    0.13946809f, -0.08374922f, -0.05013990f, -0.15027948f, -0.18327670f, 0.03379326f, 0.15661778f, 0.40271381f, 
    0.17958093f, 0.03016784f, 0.13723074f, -0.11307854f, -0.02613048f, 0.02752081f, -0.11101332f, 0.11339834f, 
    -0.26977769f, -0.08757415f, -0.23640347f, 0.21827358f, 0.19682720f, -0.25020358f, 0.08536643f, -0.19137304f, 
    0.20980023f, 0.17412083f, 0.05846249f, 0.17235416f, -0.09856004f, -0.32619464f, 0.07861453f, 0.08540197f, 
    -0.21298496f, 0.08233312f, -0.20632342f, -0.21141370f, 0.13207680f, 0.24775884f, 0.19101241f, 0.21059388f, 
    -0.12421424f, 0.18309896f, -0.20082492f, -0.05636554f, -0.10268553f, 0.06297544f, 0.12137332f, 0.22843307f, 
    0.20788558f, -0.06607315f, 0.09303721f, 0.27049249f, -0.13648401f, 0.35634246f, 0.31911540f, 0.09063829f, 
    0.09876430f, -0.08385029f, -0.00876179f, 0.00828539f, 0.02667294f, -0.17820907f, -0.01412171f, -0.06163663f, 
    0.29433766f, 0.15824318f, -0.17257249f, -0.06513473f, -0.24926971f, 0.11351730f, 0.15675370f, -0.02351154f, 
    0.07832044f, 0.08314264f, 0.10087501f, -0.01051889f, 0.20516512f, 0.37638810f, 0.31094956f, 0.28102264f, 
    0.15937829f, -0.12986755f, 0.04697759f, 0.02750967f, 0.16778289f, 0.01929446f, 0.20743443f, 0.30189750f, 
    0.21568993f, 0.38142154f, 0.08660569f, 0.20448457f, -0.01539818f, 0.01068868f, 0.02547392f, -0.14338632f, 
    -0.03346630f, -0.05647340f, 0.13748820f, -0.15718435f, 0.03686311f, -0.18590231f, 0.36253628f, 0.01742671f, 
    0.16991717f, 0.10574333f, -0.29217276f, -0.04111680f, -0.12186848f, -0.12823078f, -0.07619283f, -0.19196792f, 
    -0.18079455f, 0.11390977f, 0.09906796f, 0.00770054f, -0.13249010f, -0.01065078f, -0.05532790f, -0.01054443f, 
    0.07731228f, 0.29663479f, -0.07945006f, 0.16451676f, -0.11956713f, -0.10775329f, 0.23769698f, -0.01482274f, 
    0.07667645f, -0.00132658f, 0.25806066f, 0.13502203f, 0.01572627f, 0.13234463f, 0.04252433f, 0.29862648f, 
    -0.31514841f, -0.03588763f, 0.10300520f, 0.09758756f, 0.01551302f, -0.06604162f, -0.08477971f, -0.06900328f, 
    -0.24216186f, -0.01262659f, 0.04208023f, 0.00464536f, -0.26427263f, 0.22981499f, 0.18887897f, -0.17366007f, 
    -0.08002865f, -0.21529457f, -0.19374070f, -0.09662375f, 0.18345982f, 0.20406032f, 0.20039900f, 0.03658900f, 
    -0.06193573f, -0.07864460f, 0.15124924f, -0.04148954f, -0.06601808f, -0.12064905f, -0.19354425f, -0.08774339f, 
    0.06688725f, -0.05024134f, -0.16332944f, -0.01802929f, 0.06021412f, -0.07307912f, -0.02022794f, -0.03489118f, 
    -0.03243631f, -0.06052946f, 0.03473163f, 0.15346602f, -0.01295497f, 0.29278493f, 0.05662012f, 0.23688076f, 
    0.00634881f, -0.08144011f, 0.39515442f, 0.02367159f, 0.15259117f, 0.23334025f, 0.27082539f, 0.21526718f, 
    0.02402663f, -0.07731054f, 0.07191312f, -0.08537129f, -0.04869797f, -0.16510384f, -0.12499975f, 0.05380632f, 
    0.25957447f, -0.06631585f, -0.10836513f, 0.04327175f, -0.15152445f, -0.25587580f, -0.18719187f, -0.25719878f, 
    -0.16070853f, 0.09053522f, 0.04143805f, 0.07070888f, 0.11615902f, -0.05372742f, 0.02238060f, 0.09529267f, 
    0.19739863f, 0.16303471f, -0.01689842f, 0.06629287f, 0.06529696f, -0.24178855f, -0.07678059f, 0.05087831f, 
    -0.08527050f, 0.09783095f, 0.07790281f, 0.02912259f, -0.19686545f, -0.01644820f, -0.04968408f, 0.03631830f, 
    0.06891755f, 0.20992713f, 0.15668209f, -0.17275582f, -0.06282280f, -0.10600577f, -0.09200334f, -0.17880565f, 
    0.03241959f, 0.12613168f, 0.08130730f, -0.11807294f, 0.18058538f, 0.06569020f, 0.27282795f, 0.22362038f, 
    -0.07411256f, -0.14591099f, -0.08282491f, -0.02225830f, -0.02878310f, 0.03314238f, -0.18116687f, 0.20232177f, 
    0.44093502f, -0.06015311f, -0.62034172f, -0.00482957f, 0.00940040f, 0.06369364f, 0.15179659f, 0.01537555f, 
    0.08315875f, 0.21648878f, -0.20611390f, -0.06789324f, -0.08006594f, 0.00014620f, 0.10893750f, -0.35015124f, 
    0.12568761f, -0.19496693f, -0.00417844f, -0.07913234f, -0.01883717f, -0.05606491f, -0.16556698f, -0.04219870f, 
    -0.39002764f, -0.27042443f, 0.35042155f, 0.27465510f, -0.00034716f, -0.08043838f, 0.10544613f, 0.00375717f, 
    0.10604206f, -0.00173711f, -0.09414515f, -0.05601763f, 0.16567884f, -0.31021401f, 0.14688447f, 0.23821585f, 
    -0.12282357f, 0.04741100f, -0.07381979f, 0.09134809f, 0.06574709f, 0.07558227f, -0.06351826f, 0.03914205f, 
    0.03716081f, 0.12740158f, -0.02431629f, -0.01427714f, -0.03127661f, -0.00937031f, 0.10141567f, -0.08509578f, 
    -0.12239199f, -0.08457099f, -0.16805558f, -0.06470680f, -0.04847490f, 0.11183889f, 0.12248141f, -0.17196485f, 
    -0.06890333f, 0.04715660f, 0.21163219f, 0.01176652f, -0.01255279f, -0.13572477f, 0.15277244f, -0.01173527f, 
    0.32106611f, 0.05091453f, 0.04918362f, 0.06726126f, 0.01296056f, -0.05954607f, 0.12560016f, 0.08825238f, 
    0.02082499f, 0.06563241f, -0.07823125f, 0.12691393f, 0.52504790f, 0.02323159f, -0.00717832f, -0.17105630f, 
    -0.05744367f, -0.00953361f, -0.09893896f, 0.12419158f, 0.05042265f, 0.04124350f, 0.11904666f, 0.06056114f, 
    -0.03764115f, 0.20352390f, -0.06540042f, -0.15461022f, -0.00120039f, -0.01592140f, 0.09865031f, 0.03075957f, 
    -0.09973979f, -0.23829544f, 0.04860708f, -0.01177552f, 0.17291039f, -0.25329626f, -0.21376023f, 0.10679065f, 
    0.17642269f, 0.13089180f, -0.01532912f, 0.06117417f, 0.14836170f, 0.02902547f, -0.05809487f, -0.03654488f, 
    -0.03092614f, -0.06301266f, -0.64266002f, -0.04991110f, 0.00862012f, 0.01160708f, 0.18592156f, 0.07150576f, 
    0.09646912f, 0.10610938f, -0.00799735f, 0.13918377f, -0.08355401f, -0.03286440f, 0.16124031f, -0.21132028f, 
    -0.13530801f, 0.14996411f, 0.23708646f, 0.19066411f, 0.09656752f, 0.03946906f, -0.04406442f, 0.09783477f, 
    0.04673185f, 0.12865783f, -0.04892448f, -0.11529483f, 0.00290615f, -0.08537755f, 0.16103333f, 0.16184245f, 
    0.07854577f, 0.06325151f, -0.10377306f, -0.16553746f, 0.08667661f, 0.02660769f, 0.08885861f, 0.07422165f, 
    0.10739195f, 0.16121726f, 0.01566904f, 0.16794918f, 0.11694031f, -0.02201382f, 0.00899135f, -0.01901802f, 
    -0.03392243f, -0.03723770f, 0.00171340f, 0.04018574f, -0.03853171f, 0.00611042f, -0.05681942f, -0.00835960f, 
    -0.01241680f, -0.03959712f, 0.00510626f, -0.03910866f, -0.01331091f, -0.03049838f, -0.05253733f, 0.03918315f, 
    -0.07318090f, 0.00100158f, 0.00737578f, -0.01193148f, -0.07863105f, -0.06057561f, -0.06617086f, -0.02040343f, 
    0.02517680f, -0.01922486f, 0.00178563f, -0.01388595f, -0.08131428f, 0.00421386f, 0.02417707f, -0.05011461f, 
    0.05382076f, -0.04948815f, 0.02400745f, 0.01082406f, -0.07053274f, -0.02355268f, 0.01513314f, 0.02355775f, 
    0.01230040f, 0.00358308f, 0.04707606f, -0.04045686f, 0.04978209f, -0.00706464f, -0.06992255f, -0.07567416f, 
    -0.00550083f, 0.03183122f, 0.01532515f, 0.02580782f, -0.01665163f, 0.00070123f, -0.02273545f, -0.06852059f, 
    -0.03247066f, 0.01872530f, -0.03222008f, 0.02495718f, 0.05253116f, 0.00550965f, 0.00376047f, -0.07838310f, 
    -0.06667297f, -0.04437685f, -0.03274094f, 0.05339264f, -0.04844085f, -0.06913664f, -0.00397904f, -0.03923534f, 
    -0.03920934f, 0.06469113f, 0.02564225f, 0.04259016f, -0.05067733f, -0.02916979f, -0.03879590f, -0.05099100f, 
    -0.01924944f, 0.04146291f, -0.05233608f, 0.01162454f, 0.02198218f, 0.02328462f, 0.01432967f, -0.00953446f, 
    0.00380864f, -0.05276980f, -0.07813741f, -0.06299693f, -0.04175546f, 0.04648067f, -0.02950613f, -0.02677773f, 
    0.01194872f, 0.06470546f, 0.03540465f, -0.07061714f, 0.04549048f, 0.03582221f, -0.05092098f, 0.03136436f, 
    -0.05965162f, -0.02901821f, 0.01874794f, -0.03732564f, 0.04983732f, -0.06120282f, 0.01233558f, -0.03498358f, 
    -0.03892881f, 0.05094703f, 0.05344588f, -0.05732943f, 0.05889226f, -0.00244782f, 0.05751697f, -0.01141056f, 
    0.05082446f, -0.06068492f, -0.00449019f, 0.05608639f, 0.06789175f, -0.06769538f, -0.06608240f, 0.05346509f, 
    -0.01998636f, 0.00493692f, -0.02945992f, -0.03130560f, 0.03755613f, -0.01879634f, -0.01857561f, -0.00925208f, 
    -0.05468488f, 0.00186067f, 0.05473226f, -0.04414391f, 0.05538962f, 0.03064958f, 0.00280794f, -0.03277933f, 
    -0.06805395f, 0.00220657f, -0.07894970f, -0.05427934f, -0.03587689f, -0.04158272f, 0.04891218f, -0.00042361f, 
    -0.04431866f, 0.00185470f, 0.02059133f, 0.05056940f, -0.04866701f, 0.03577418f, -0.03165218f, 0.03862805f, 
    -0.03543417f, -0.02449800f, 0.05459790f, -0.03770790f, -0.04440727f, 0.02565825f, -0.06750870f, -0.05622013f, 
    -0.08673645f, 0.05580821f, -0.02994057f, -0.08328868f, -0.06789864f, -0.08410269f, 0.01008036f, 0.04453703f, 
    -0.07142029f, 0.01342228f, -0.01954048f, -0.02550204f, 0.04417558f, -0.08162008f, 0.03301967f, 0.04675022f, 
    -0.07638521f, -0.07522932f, 0.05274521f, 0.05068912f, -0.04570588f, 0.02214531f, 0.02130483f, 0.01267313f, 
    -0.19303140f, -0.09220462f, 0.32383299f, 0.19422135f, 0.23760052f, 0.05870597f, -0.04061397f, -0.25566223f, 
    -0.06148699f, -0.07583242f, -0.08327861f, -0.09294790f, 0.17564136f, -0.22006218f, 0.11487537f, 0.35578969f, 
    0.00880133f, 0.12691182f, 0.25633460f, -0.10419940f, -0.08613099f, -0.07047978f, 0.06117998f, 0.16097912f, 
    -0.01625574f, -0.26882628f, -0.04570311f, 0.13854621f, 0.09512331f, -0.04305372f, -0.09175334f, -0.08064434f, 
    -0.01146127f, 0.02528793f, 0.11241327f, 0.08509803f, 0.21278651f, 0.03977051f, -0.23144993f, -0.24973319f, 
    0.08137918f, -0.04925608f, -0.06806697f, 0.12680897f, -0.34425369f, -0.03241643f, -0.26365158f, -0.21702993f, 
    -0.20787525f, -0.11043228f, 0.13828142f, 0.09119704f, 0.08037923f, -0.13032007f, -0.03948244f, 0.07647739f, 
    0.01414836f, 0.08678510f, 0.11392108f, 0.13008823f, -0.01406228f, 0.08065807f, -0.05998268f, 0.20627388f, 
    -0.00390156f, -0.00520648f, 0.06740995f, -0.00820562f, 0.23191868f, -0.06618576f, 0.10032292f, 0.19051658f, 
    -0.09860685f, 0.19360022f, 0.02893631f, 0.14984442f, 0.09843856f, -0.02819260f, -0.03911491f, -0.09394347f, 
    0.05395531f, -0.15213788f, -0.00165773f, -0.16415049f, 0.20529799f, 0.10214973f, -0.06577265f, 0.02483041f, 
    -0.02287376f, 0.01833472f, -0.09892493f, 0.09005468f, -0.01366743f, -0.13809562f, -0.12107398f, -0.13698457f, 
    0.48027343f, 0.50356436f, 0.24176309f, 0.07332524f, 0.01854002f, 0.14622162f, 0.08258784f, -0.03488396f, 
    0.12511244f, 0.03194992f, 0.04626602f, 0.02223818f, 0.48001823f, 0.13112283f, 0.08490504f, -0.22732647f, 
    -0.13090041f, 0.03164263f, 0.07019701f, 0.06809688f, 0.15298899f, -0.17750452f, -0.20562759f, -0.06016730f, 
    0.02674109f, 0.13675916f, 0.12716521f, 0.32815930f, -0.04825470f, 0.02349184f, 0.13311167f, 0.43176448f, 
    0.04887822f, -0.09370895f, -0.03840201f, -0.14795414f, -0.08588281f, -0.17383602f, 0.03275109f, 0.06583031f, 
    0.00659888f, -0.02492978f, 0.03793002f, -0.00053900f, 0.05114157f, -0.04767615f, 0.00008129f, 0.00758377f, 
    0.09591101f, 0.12324814f, -0.41933799f, 0.04067699f, -0.20269643f, -0.19957228f, -0.26456830f, -0.20362149f, 
    -0.14580418f, -0.05876074f, 0.02127993f, 0.04752807f, 0.12981649f, 0.16001897f, 0.21882582f, -0.01266363f, 
    -0.20544168f, 0.12730643f, -0.02138772f, 0.05097704f, -0.05940903f, 0.08623791f, 0.04497713f, 0.26676902f, 
    0.06233458f, -0.10319905f, 0.00592568f, -0.02196868f, -0.14382435f, -0.14622803f, 0.07927193f, 0.03578961f, 
    -0.17525555f, 0.05944561f, -0.03176961f, 0.07060645f, -0.17756949f, -0.01708747f, 0.08651268f, 0.09940161f, 
    -0.05389972f, -0.04965540f, -0.03113416f, 0.02708494f, 0.08525471f, 0.01156398f, 0.11776170f, 0.10502791f, 
    0.24107824f, -0.13500780f, 0.24515131f, 0.07952795f, 0.03930078f, 0.08911328f, 0.04091222f, 0.05562815f, 
    0.12121370f, 0.08466716f, 0.02696490f, 0.00719654f, -0.11205879f, -0.56615359f, 0.36905584f, 0.06453516f, 
    -0.09240270f, -0.02986239f, -0.08648195f, 0.01833059f, -0.04126448f, -0.17358801f, 0.07511581f, 0.05944689f, 
    0.32942763f, -0.10666290f, 0.62522191f, -0.50458515f, -0.22475247f, -0.17438346f, -0.08999715f, 0.00992023f, 
    -0.01234697f, 0.15495449f, 0.04068597f, 0.19702224f, 0.50857753f, 0.11837559f, 0.60887063f, 0.41117293f, 
    -0.06532715f, 0.22381906f, 0.08446310f, 0.11185470f, 0.02250193f, 0.11022664f, 0.01134572f, 0.14462133f, 
    0.12911801f, 0.42047253f, 0.15132602f, 0.06133622f, -0.18843769f, -0.08605330f, -0.01240393f, -0.09693033f, 
    -0.04615052f, -0.07628601f, 0.20291038f, 0.16938503f, -0.39272636f, 0.14161444f, -0.09429562f, 0.30198467f, 
    0.10883248f, 0.01386196f, 0.03996960f, 0.04542090f, -0.03356465f, -0.11887511f, -0.05433723f, 0.10171121f, 
    -0.32556576f, 0.05847144f, -0.20217407f, -0.03231672f, 0.05114566f, -0.11399424f, 0.19540738f, -0.21416873f, 
    0.14728498f, 0.26064155f, 0.05288474f, -0.03167990f, -0.05127024f, -0.27370051f, -0.12050115f, 0.08493441f, 
    0.10538267f, 0.02355927f, 0.04793961f, -0.01006530f, -0.01915580f, -0.12940340f, -0.04411321f, 0.02429409f, 
    -0.32443547f, 0.16969669f, 0.16527203f, 0.21826391f, 0.05374562f, 0.08677222f, 0.02645246f, 0.08466920f, 
    0.15461962f, 0.03387210f, 0.06059364f, -0.02121763f, 0.14848961f, 0.67879593f, 0.19125971f, -0.12333810f, 
    0.01249614f, 0.03346244f, -0.23382679f, 0.11520950f, 0.24456081f, 0.08121639f, 0.02803297f, -0.01521690f, 
    -0.34329465f, -0.18469043f, 0.26260462f, 0.18460310f, -0.20315813f, 0.06774927f, 0.05151361f, -0.00610913f, 
    -0.19181025f, 0.15247555f, 0.02439656f, 0.02973662f, -0.04437480f, -0.02018515f, -0.10133181f, -0.37895736f, 
    -0.36352617f, -0.23873226f, -0.18152988f, -0.16842502f, -0.06902461f, 0.00856214f, -0.08203655f, -0.26593313f, 
    -0.09257814f, -0.61619222f, 0.12188756f, 0.22457901f, 0.02159582f, -0.00147762f, 0.04295575f, 0.07086229f, 
    0.02854231f, 0.03437726f, -0.01978792f, 0.11847871f, 0.05654614f, -0.07884225f, -0.12635149f, -0.02392411f, 
    -0.04537832f, 0.07633267f, 0.06689090f, 0.06405635f, 0.05925377f, -0.01238613f, 0.21081641f, 0.16216843f, 
    -0.07690734f, 0.27778783f, 0.19188267f, -0.11170463f, -0.14505622f, 0.26337117f, -0.11934946f, 0.17759384f, 
    -0.14336932f, 0.12429372f, 0.03082389f, 0.10927194f, -0.34207270f, -0.00003890f, -0.03586096f, -0.02825583f, 
    -0.00513004f, -0.08720162f, 0.07421632f, -0.14655583f, 0.14886333f, -0.14500199f, 0.05459221f, -0.01391514f, 
    -0.22699843f, 0.37000284f, 0.27619213f, -0.28616980f, -0.01282165f, -0.04414902f, 0.05580067f, 0.09539548f, 
    0.05828335f, -0.06352291f, 0.03467961f, 0.01155242f, -0.28067982f, -0.13472590f, 0.34327352f, -0.37339085f, 
    0.04138590f, 0.13091308f, 0.11853892f, 0.19446243f, 0.11648492f, 0.05164400f, 0.00792630f, 0.11530028f, 
    0.30178186f, -0.20800209f, -0.11231671f, 0.02384681f, 0.01621475f, -0.02358394f, 0.00701159f, 0.09201568f, 
    0.09049763f, -0.12877226f, 0.23225820f, -0.09472701f, -0.26347131f, 0.40444049f, -0.06677916f, -0.31505707f, 
    -0.01728580f, -0.09844770f, 0.12289682f, -0.07638589f, 0.25268170f, 0.02044097f, 0.22777285f, 0.29300916f, 
    -0.07654781f, -0.23749243f, -0.19353054f, 0.66927731f, -0.00668183f, 0.04736711f, -0.09447750f, -0.00311513f, 
    0.16102332f, 0.00638735f, -0.13581072f, -0.13521104f, -0.14921340f, -0.21045195f, -0.06194799f, 0.20690937f, 
    0.18859631f, -0.01099446f, 0.17516740f, 0.31284702f, 0.16341694f, -0.22050279f, -0.00903933f, -0.07869692f, 
    -0.20506716f, 0.13470858f, 0.25877729f, 0.07750960f, -0.03891956f, -0.05271257f, -0.03791160f, 0.02757892f, 
    0.26880854f, 0.01376870f, 0.10288922f, 0.19099648f, -0.13709100f, 0.03737293f, 0.20015673f, -0.14268300f, 
    -0.10348079f, 0.04567683f, 0.01631044f, 0.13001348f, 0.15569827f, 0.08588270f, -0.06123125f, 0.12152713f, 
    -0.07097583f, 0.03433966f, 0.30976218f, -0.29278305f, -0.25828162f, 0.19422741f, 0.08841499f, 0.17884658f, 
    -0.02697798f, -0.03020057f, -0.04855538f, -0.07277352f, -0.18555088f, -0.28912076f, 0.53640032f, -0.33249903f, 
    0.03673902f, -0.13374223f, -0.01230250f, 0.20907655f, 0.04989456f, -0.03358708f, -0.05749691f, -0.06651656f, 
    -0.40615329f, -0.06905895f, 0.15144791f, 0.07719375f, -0.01226446f, -0.15748596f, -0.09563974f, 0.14191055f, 
    0.25487971f, -0.04668263f, 0.01167064f, -0.15735887f, 0.07936116f, -0.06449002f, 0.08556130f, -0.00506662f, 
    -0.14198215f, -0.09569672f, -0.15500557f, -0.02020706f, -0.01800424f, -0.09672458f, 0.05131445f, -0.23920530f, 
    0.31204870f, 0.25240114f, 0.28119159f, -0.38655612f, -0.03494034f, 0.01244933f, -0.09266316f, 0.09214600f, 
    -0.07227873f, -0.07451064f, 0.00246469f, 0.11116901f, 0.39316326f, -0.08112292f, 0.08038597f, 0.04558349f, 
    0.03885515f, 0.06508870f, 0.04885657f, 0.18905486f, 0.05058384f, -0.05670118f, -0.13093528f, -0.03729006f, 
    0.30946082f, -0.29171383f, 0.00483937f, -0.02220034f, 0.10720234f, 0.05705221f, -0.08901607f, 0.02488748f, 
    0.08574165f, 0.18906589f, 0.26541677f, 0.04267538f, -0.07374535f, -0.19377983f, -0.09969791f, -0.03043178f, 
    -0.09358718f, -0.01077264f, 0.00159460f, 0.03940075f, -0.10499802f, 0.05422356f, 0.05953598f, 0.04665316f, 
    -0.07178965f, -0.05964611f, 0.24120776f, -0.15153535f, 0.10429230f, -0.07918766f, -0.08849297f, -0.03817137f, 
    0.04333513f, 0.16772206f, 0.03680493f, -0.09086717f, 0.06219731f, -0.22667813f, 0.09893104f, 0.04633584f, 
    -0.31724462f, -0.16659196f, 0.03269817f, 0.23559579f, -0.08017268f, 0.02203258f, -0.18457650f, 0.01608127f, 
    -0.16895808f, 0.17789775f, 0.27214518f, 0.17599320f, -0.04651703f, -0.10826156f, 0.27494398f, -0.01883486f, 
    0.07574879f, 0.13342327f, -0.14319681f, 0.29363713f, 0.08334850f, 0.07047416f, 0.21721795f, -0.53409308f, 
    -0.12860185f, -0.14462954f, 0.05692560f, 0.21969037f, 0.11894783f, 0.05054620f, 0.06590090f, 0.10210012f, 
    -0.42209768f, 0.39783779f, 0.33730906f, 0.38002053f, 0.17355642f, 0.05503619f, -0.05455539f, -0.09660780f, 
    0.09434303f, -0.14141855f, 0.12565169f, 0.04314960f, 0.10624560f, -0.47001344f, 0.01589828f, 0.16829903f, 
    0.06418646f, 0.21835093f, -0.19154128f, 0.26841885f, -0.07761951f, 0.13364165f, -0.10320693f, 0.00236815f, 
    0.02580203f, 0.03606314f, -0.18488057f, 0.08273394f, 0.09575013f, -0.13250013f, 0.21015842f, 0.15721692f, 
    0.10839329f, 0.10885218f, -0.04319645f, 0.03838690f, -0.12742513f, 0.23010434f, 0.30617347f, -0.18266183f, 
    -0.17444396f, 0.04950120f, -0.05803924f, 0.07164384f, 0.19758059f, -0.13652880f, 0.05974338f, -0.15650690f, 
    0.47047001f, -0.11381397f, -0.14329085f, -0.38030905f, -0.03820533f, -0.35674009f, -0.02499375f, 0.31979755f, 
    -0.09833413f, -0.14369005f, -0.13437518f, 0.06846163f, 0.36635530f, -0.12655149f, 0.63087082f, 0.07541485f, 
    -0.06473605f, -0.17004062f, -0.01946059f, -0.19903633f, -0.21253015f, 0.17437963f, -0.00731730f, -0.10078061f, 
    -0.16397591f, 0.18935946f, -0.14772822f, -0.15862380f, -0.18929504f, -0.07034073f, -0.09213214f, 0.19866499f, 
    -0.18927889f, -0.04010873f, -0.12268594f, 0.04626399f, 0.14032696f, 0.00759710f, 0.00068051f, 0.11984684f, 
    -0.12196799f, -0.00215404f, -0.08221946f, -0.19515672f, 0.16504906f, 0.13197041f, 0.13974360f, 0.05886281f, 
    0.64801776f, -0.18674472f, -0.51301169f, 0.17039570f, 0.10174526f, -0.19309221f, 0.21488905f, 0.11959647f, 
    -0.07270788f, -0.09802645f, -0.10086403f, 0.09075531f, 0.03818686f, 0.15973119f, 0.31126896f, 0.24046806f, 
    -0.04271692f, -0.14182384f, -0.03930253f, -0.17374153f, -0.03843014f, -0.07268817f, -0.08880664f, -0.15323853f, 
    0.38717005f, 0.09689645f, -0.06555077f, -0.06408548f, 0.21897496f, -0.14069831f, -0.16571841f, -0.00065464f, 
    0.00814919f, 0.13880055f, -0.07337238f, 0.20060074f, 0.08481964f, 0.07095452f, -0.03604332f, -0.08592846f, 
    -0.01315605f, -0.15540765f, 0.03258806f, -0.21652213f, 0.11327869f, 0.04134544f, -0.07784146f, -0.01564844f, 
    0.15889733f, 0.20496936f, 0.04256220f, -0.30435982f, -0.11902787f, -0.16560847f, 0.04377028f, 0.30604920f, 
    0.15056929f, -0.11654671f, 0.00507864f, -0.20412463f, 0.06980629f, -0.24323474f, 0.59199274f, 0.18791533f, 
    -0.09520333f, 0.20411134f, 0.00127930f, 0.06522119f, 0.03789040f, -0.04521634f, 0.03064042f, 0.11706588f, 
    0.69048333f, -0.00272816f, -0.09564921f, 0.18626967f, 0.06779870f, 0.07942523f, 0.12924594f, 0.07768257f, 
    0.06536324f, 0.13915719f, -0.05031775f, -0.10365240f, -0.06747711f, -0.06307644f, 0.03040781f, -0.25878325f, 
    0.07816329f, 0.11430819f, 0.11297000f, -0.01417383f, 0.02372491f, 0.05692858f, -0.07329498f, 0.00334591f, 
    -0.38905680f, -0.10857808f, 0.50801778f, 0.37575644f, -0.02760463f, -0.26993111f, -0.08512012f, -0.04209761f, 
    0.11361540f, -0.09976237f, 0.28772712f, 0.02581087f, -0.14107876f, -0.21572745f, -0.11424834f, 0.34883893f, 
    0.16293836f, 0.07335291f, -0.05086784f, -0.04275618f, 0.04253566f, 0.04127900f, -0.06104875f, -0.00586877f, 
    0.09836242f, 0.29894185f, 0.11484858f, 0.10726359f, -0.02172053f, -0.11610189f, 0.06954315f, -0.11336842f, 
    0.08743363f, 0.32874516f, -0.02725762f, 0.07988468f, -0.22524868f, 0.08247294f, 0.20970443f, -0.08129527f, 
    -0.10366602f, -0.02926327f, 0.28110290f, 0.08440260f, -0.12283941f, -0.17848101f, 0.03070470f, -0.16499358f, 
    0.16385736f, -0.10790700f, -0.02243824f, 0.08041290f, 0.00763707f, 0.14253142f, -0.13189052f, 0.34433070f, 
    0.09049690f, 0.07872129f, 0.00222942f, 0.09715535f, 0.05363674f, -0.08273980f, -0.02296496f, -0.43311006f, 
    0.14035814f, -0.04470190f, -0.16400628f, 0.24430811f, 0.21366008f, -0.08018114f, -0.02310730f, -0.12271700f, 
    -0.47615722f, -0.09170355f, 0.23880926f, -0.16370098f, 0.01132124f, -0.04494910f, -0.09854312f, -0.01747763f, 
    0.01550542f, 0.19004223f, 0.05885898f, -0.05711183f, 0.21760948f, -0.01239480f, -0.05023620f, 0.03791905f, 
    -0.06921776f, 0.02302764f, -0.12672549f, 0.05026795f, -0.04138323f, -0.16365458f, -0.20686461f, -0.17983116f, 
    0.24010481f, 0.06698097f, -0.33828685f, -0.14774661f, -0.01223961f, 0.16892052f, 0.23016195f, -0.00836571f, 
    0.01400618f, 0.00992479f, -0.06714340f, 0.01532358f, 0.11747727f, -0.29794112f, 0.04463563f, -0.31412163f, 
    0.03877876f, 0.10650191f, -0.00969738f, 0.17151830f, 0.06742724f, 0.03894481f, 0.00067405f, 0.19346258f, 
    0.11733648f, -0.13547887f, 0.04454347f, -0.11667379f, 0.06444608f, -0.11775121f, -0.07341671f, 0.06496937f, 
    0.03666238f, 0.30685550f, -0.06038897f, 0.00923465f, -0.23836327f, -0.03746768f, 0.02513916f, 0.08602138f, 
    -0.12792529f, -0.09554666f, -0.03499620f, 0.03787032f, 0.00826473f, -0.02331388f, 0.02988515f, -0.02961817f, 
    -0.02974256f, 0.04041453f, -0.06494378f, -0.01588843f, -0.00784183f, -0.04429306f, -0.06391960f, -0.05104844f, 
    0.06281107f, 0.04358225f, -0.01218108f, -0.05115499f, -0.00669527f, -0.04393852f, -0.06841965f, -0.06050634f, 
    -0.04831165f, 0.00758256f, -0.04153033f, -0.06981850f, -0.00239570f, 0.02069826f, -0.07019106f, 0.06066826f, 
    0.02805826f, 0.06300306f, 0.05561741f, -0.04663914f, -0.04556824f, 0.05483738f, -0.03351286f, 0.04216411f, 
    -0.03663941f, 0.06359147f, -0.00092046f, -0.05435722f, -0.02610917f, -0.02989024f, -0.02364063f, 0.06579450f, 
    -0.07510578f, 0.05112015f, 0.05628576f, -0.06340083f, 0.04957207f, 0.02764337f, 0.05276749f, -0.04674536f, 
    -0.05815893f, 0.03858556f, -0.04848156f, 0.02807943f, -0.06433507f, -0.07530674f, 0.00360461f, 0.05203524f, 
    -0.03114495f, -0.07485297f, 0.02011375f, -0.07153471f, -0.03340961f, 0.03850829f, 0.05445502f, 0.03592313f, 
    -0.04260719f, 0.05077385f, 0.00433272f, -0.06410304f, 0.04897074f, -0.05222096f, -0.06350530f, -0.07356058f, 
    -0.07208756f, -0.01054104f, -0.04598188f, 0.05403090f, -0.04690051f, -0.01988264f, -0.03343049f, -0.04857549f, 
    0.04617432f, -0.06236040f, 0.00935914f, -0.02456403f, 0.02171236f, -0.04406769f, -0.07751756f, 0.04380507f, 
    0.04462681f, -0.01884264f, -0.06493738f, 0.02311697f, 0.02291729f, 0.03225502f, -0.06119888f, -0.02886968f, 
    -0.04606317f, -0.01521974f, 0.01690851f, 0.00525521f, -0.07642620f, -0.06651362f, 0.04645375f, -0.04100024f, 
    -0.04388971f, 0.01651155f, 0.02309704f, -0.04945973f, -0.07224374f, -0.00644469f, 0.03457846f, -0.01007984f, 
    -0.00302308f, 0.00790132f, -0.00087129f, 0.06064690f, 0.05423570f, 0.01524427f, 0.01569629f, -0.03428096f, 
    0.01050913f, -0.03622337f, 0.05151073f, -0.07001163f, -0.05013390f, -0.00377723f, 0.00572649f, -0.00630814f, 
    -0.01477865f, 0.06281454f, 0.05353006f, 0.05247181f, 0.04701375f, -0.03751146f, -0.06529771f, 0.04163551f, 
    -0.05575553f, -0.03896912f, 0.06389223f, -0.03962955f, -0.02747351f, -0.04500400f, -0.00237535f, -0.00613387f, 
    0.01661549f, -0.00308146f, 0.06489635f, 0.02997619f, -0.06888202f, 0.05661959f, -0.07807216f, 0.03392304f, 
    -0.02741598f, -0.01677802f, -0.00283255f, -0.06958338f, -0.06728788f, 0.02997689f, 0.02690765f, -0.03410336f, 
    -0.05954363f, 0.00848952f, 0.02047788f, 0.02542144f, 0.02136747f, -0.04162272f, -0.04248370f, 0.04407305f, 
    0.05599723f, 0.05995458f, -0.05338199f, -0.01565197f, -0.02928444f, 0.06140642f, 0.05908346f, 0.02771714f, 
    -0.03705985f, -0.02057938f, 0.01826766f, -0.03438502f, -0.07388453f, -0.02296115f, 0.02377716f, 0.02581769f, 
    -0.03312282f, -0.05972306f, 0.00596063f, -0.01630770f, -0.01314520f, 0.01352089f, 0.04763979f, 0.01356786f, 
    -0.07317688f, 0.10727902f, 0.07059442f, -0.08790297f, -0.07710007f, 0.01625963f, 0.16849257f, 0.21169008f, 
    0.03672620f, -0.04303955f, 0.04848573f, 0.01695941f, -0.32011226f, -0.16873398f, 0.43929744f, -0.04153306f, 
    -0.09164245f, 0.12580153f, 0.00813480f, 0.10616452f, 0.01182461f, -0.15740713f, -0.00234166f, -0.13778353f, 
    0.31627813f, -0.15848236f, 0.47919500f, -0.23582421f, -0.12325776f, 0.06174897f, -0.11291625f, 0.03282809f, 
    -0.05912555f, 0.08950926f, 0.20024052f, -0.03011242f, 0.07032967f, 0.27847615f, 0.32320437f, 0.07193391f, 
    -0.09793648f, 0.24354589f, 0.14499299f, -0.06504057f, 0.08688907f, 0.11034597f, 0.12069216f, 0.17700566f, 
    0.34825251f, 0.08977586f, -0.10362405f, 0.03804335f, -0.06147414f, -0.13973899f, -0.11415376f, -0.11366905f, 
    0.06074522f, -0.04634702f, 0.10865863f, 0.20968051f, -0.44158873f, 0.21472396f, -0.07624692f, 0.28979146f, 
    0.15643147f, -0.00407427f, 0.18387599f, 0.12633494f, -0.04125444f, -0.15872179f, 0.12285855f, 0.01352717f, 
    -0.22410201f, -0.02030157f, 0.08831014f, 0.03714354f, -0.00511647f, -0.03518600f, 0.04308527f, -0.08081003f, 
    0.15399027f, 0.18621181f, 0.13092776f, 0.08322737f, -0.06971289f, -0.22527575f, 0.05141488f, 0.00808916f, 
    0.03602041f, 0.11423893f, 0.19532281f, 0.13018093f, 0.02156419f, 0.02794059f, -0.00102437f, -0.08983387f, 
    -0.30721414f, 0.14563061f, 0.36831233f, 0.13838330f, -0.12398645f, 0.32204250f, -0.10460420f, 0.14928348f, 
    -0.05547353f, -0.07244510f, 0.01289404f, -0.08220379f, -0.40315613f, 0.16872129f, 0.12284541f, -0.35419971f, 
    -0.02408219f, -0.01207978f, -0.13616948f, 0.10987637f, 0.02668194f, -0.05015888f, 0.04165692f, 0.01298236f, 
    -0.32868984f, -0.28503436f, 0.11228804f, 0.21482384f, -0.06867726f, -0.13885675f, -0.06423593f, -0.05286367f, 
    0.04292401f, 0.09895808f, 0.01014879f, -0.12844390f, 0.09633156f, 0.12502474f, 0.06401795f, -0.25832939f, 
    -0.04161294f, -0.10120668f, -0.03188829f, -0.05346390f, -0.03915920f, 0.00600367f, -0.05413956f, -0.10002324f, 
    0.05550918f, -0.04561235f, 0.61663282f, -0.04564142f, -0.03715252f, 0.20452814f, 0.04135649f, -0.09222933f, 
    -0.18860826f, -0.08269259f, 0.02969991f, -0.05668025f, 0.29203451f, -0.14486814f, -0.17063913f, -0.03804433f, 
    0.06445152f, -0.03922217f, -0.16484633f, 0.17361361f, 0.07114504f, 0.02945320f, 0.07707535f, 0.04378358f, 
    0.14905103f, 0.04497474f, 0.02290941f, -0.01063581f, 0.01833065f, 0.28929901f, -0.13777925f, 0.01355225f, 
    -0.00020262f, 0.22805208f, 0.28838673f, 0.00894660f, -0.07766770f, -0.03749981f, -0.16669780f, 0.04696828f, 
    0.13399890f, 0.02634829f, 0.09984638f, 0.10182554f, 0.05000901f, 0.06317358f, 0.09534877f, 0.14403830f, 
    -0.03121015f, 0.02200859f, 0.06553594f, -0.01041085f, -0.02864993f, -0.04007336f, 0.01208141f, -0.02783346f, 
    -0.04239157f, -0.04502161f, -0.06856973f, 0.06340134f, -0.00786072f, 0.05427453f, -0.04992944f, 0.01756399f, 
    -0.04318364f, -0.06099683f, 0.01716406f, -0.02048801f, 0.00086457f, -0.06197605f, -0.05598199f, 0.02578266f, 
    -0.02539831f, -0.01057250f, -0.06891130f, 0.06218276f, -0.03806458f, 0.04297491f, 0.02184234f, -0.06089503f, 
    0.07028921f, -0.04248849f, 0.04654848f, -0.04378978f, -0.05967310f, 0.00314903f, 0.02958767f, 0.03620648f, 
    0.07092898f, -0.00866504f, 0.02848750f, -0.02542187f, -0.02634528f, 0.06116903f, 0.02995067f, -0.06220142f, 
    -0.03568082f, -0.05296414f, 0.03700636f, 0.03575073f, 0.03783662f, 0.06597795f, -0.00124803f, -0.04944224f, 
    -0.05161276f, -0.07653847f, -0.01290344f, 0.00714980f, 0.03978703f, -0.04665720f, -0.03008405f, 0.01803351f, 
    -0.06560196f, 0.06243744f, -0.01312018f, 0.01567515f, 0.05369847f, -0.06414386f, -0.04220835f, -0.05940954f, 
    0.00474825f, -0.03605774f, -0.05416977f, 0.03637412f, -0.03867998f, -0.05603901f, -0.05123602f, -0.07188200f, 
    -0.00650112f, 0.00933088f, -0.05064912f, 0.04665430f, 0.00133353f, 0.03677360f, -0.04155181f, -0.06230539f, 
    -0.05616717f, -0.05752304f, -0.02268789f, 0.04298218f, 0.02187083f, 0.04893810f, -0.01892861f, 0.00807898f, 
    -0.00890795f, 0.05274883f, -0.05806068f, -0.00050147f, -0.01822148f, 0.05215484f, -0.06568206f, 0.05052869f, 
    -0.07302056f, 0.02313716f, -0.01487274f, 0.02134178f, -0.00779967f, 0.04567309f, -0.00819869f, -0.04517861f, 
    -0.04373723f, -0.02813782f, 0.02971352f, -0.04680710f, -0.03796584f, -0.02739631f, -0.05002423f, 0.03022088f, 
    0.02620079f, -0.00394131f, -0.01555247f, -0.01642739f, 0.01281953f, -0.06358447f, 0.01016089f, 0.02750983f, 
    0.03761391f, -0.06657372f, 0.01328785f, 0.06639277f, 0.03766047f, -0.01161101f, -0.05851361f, -0.05892258f, 
    0.01069365f, 0.03173435f, -0.03254113f, -0.02967655f, 0.00373374f, -0.01162032f, -0.02156192f, -0.02742042f, 
    0.03746856f, -0.07461145f, -0.06993145f, 0.00599456f, -0.04547392f, -0.02588658f, 0.03994224f, -0.06980378f, 
    -0.04482429f, -0.07539279f, -0.01273973f, 0.06668677f, 0.03232876f, -0.02028986f, -0.07155739f, 0.00567117f, 
    -0.02543320f, -0.03646561f, -0.06091685f, -0.00033468f, -0.01306254f, -0.04964841f, 0.04507606f, 0.04855131f, 
    0.04936608f, -0.00334784f, 0.04686727f, -0.03008435f, -0.07596872f, -0.07657348f, -0.00222905f, -0.02292716f, 
    0.05232353f, -0.02640565f, 0.04232531f, 0.00804870f, 0.06092251f, -0.07122520f, -0.02479482f, -0.00415441f, 
    0.00115970f, -0.04096526f, 0.05110086f, -0.05528054f, 0.04158070f, -0.01803811f, 0.05872710f, -0.00226799f, 
    0.04040655f, 0.30607426f, 0.05418739f, 0.03863407f, 0.15154162f, 0.14156711f, -0.04697376f, 0.15941027f, 
    0.00180724f, -0.05649244f, 0.17988969f, 0.00301607f, 0.27129921f, 0.53346890f, 0.08845390f, -0.00041288f, 
    0.04748206f, 0.10434691f, 0.09456018f, 0.16170032f, -0.17913459f, 0.04108299f, -0.23789588f, 0.05123292f, 
    -0.04404083f, -0.15588136f, -0.85683000f, 0.57982963f, 0.05419027f, 0.23681012f, 0.11401027f, 0.08193613f, 
    -0.01748058f, -0.03113238f, -0.04783857f, -0.15437895f, -0.39988092f, -0.18016809f, -0.27014235f, -0.07374205f, 
    0.04034092f, 0.12107886f, 0.08910025f, 0.01732766f, 0.06316689f, -0.05956772f, 0.01204321f, 0.00404541f, 
    -0.62407500f, -0.71680737f, 0.06394286f, 0.23691036f, 0.02528500f, -0.13018958f, -0.03411176f, -0.02466378f, 
    0.04463962f, 0.11318164f, 0.06396141f, 0.05352923f, 0.08330046f, -0.14402436f, 0.20775899f, -0.03054441f, 
    -0.00905347f, 0.04372253f, 0.15191045f, -0.06541698f, 0.12212895f, 0.03108813f, -0.10476238f, -0.24413790f, 
    0.40642762f, 0.13807249f, 0.17197087f, 0.05813606f, 0.04063610f, 0.23588413f, 0.17460839f, 0.22290228f, 
    -0.03916246f, -0.19429539f, -0.00693691f, 0.19839336f, 0.02472674f, 0.25800556f, 0.17915502f, 0.15093946f, 
    0.15537973f, 0.18258519f, 0.33254969f, 0.06868614f, 0.04006193f, -0.05733238f, 0.11658792f, -0.01220390f, 
    0.58909833f, 0.07900771f, -0.08008698f, 0.09284651f, 0.06151207f, 0.09679450f, 0.05071234f, 0.18118230f, 
    -0.05737944f, -0.10656685f, -0.32100710f, 0.01378683f, 0.08419957f, -0.60485011f, -0.47798225f, -0.08063647f, 
    -0.09393060f, -0.02026270f, -0.01152833f, 0.01568782f, 0.11880539f, 0.15123041f, 0.21754755f, 0.12701380f, 
    0.11759819f, 0.27038378f, 0.04105175f, -0.08975036f, 0.08778282f, -0.01859523f, 0.00886556f, -0.14401351f, 
    -0.06242355f, -0.11443938f, -0.14207932f, -0.06499715f, -0.06453541f, -0.48348287f, -0.17354257f, 0.12452921f, 
    0.06847788f, -0.09522694f, -0.10510760f, -0.12435015f, -0.06145298f, -0.09722837f, 0.02079279f, 0.08611455f, 
    0.14079218f, 0.38417780f, -0.29562736f, -0.22834553f, -0.03254382f, 0.13205147f, 0.08059972f, 0.09754319f, 
    -0.07644445f, -0.08947477f, -0.08304902f, 0.02119652f, -0.01762204f, 0.00937890f, 0.06198410f, -0.15680936f, 
    0.20348939f, 0.04826510f, -0.04031589f, -0.01161291f, -0.01646688f, 0.08092532f, -0.12168212f, 0.00479005f, 
    -0.04524283f, -0.23614098f, -0.09867366f, -0.14479873f, 0.04007407f, -0.11953617f, 0.23341094f, 0.09664739f, 
    0.16484068f, 0.11540418f, 0.04198436f, -0.09877338f, -0.16029125f, -0.39976501f, -0.15425460f, -0.11018111f, 
    0.07810102f, 0.04680724f, 0.02161089f, 0.10524336f, 0.03573150f, 0.01737581f, 0.07281850f, 0.09329329f, 
    0.18849137f, 0.01938049f, -0.20306523f, -0.00991385f, -0.07082654f, 0.06175471f, 0.02308682f, 0.14531603f, 
    -0.04195612f, -0.20438918f, -0.03771416f, -0.17652549f, -0.05183484f, 0.31972045f, -0.28697130f, -0.18288280f, 
    0.19455346f, 0.14869203f, 0.24696882f, 0.12665637f, -0.09434277f, 0.05907014f, -0.00241973f, 0.11283179f, 
    -0.29404297f, 0.10098497f, -0.27945411f, -0.03376566f, 0.04466275f, 0.21006994f, -0.13280654f, 0.12323498f, 
    0.06623873f, -0.15745828f, 0.16639864f, 0.08629525f, -0.64653921f, -0.07589205f, -0.43910262f, 0.14559260f, 
    -0.11127524f, 0.37934262f, 0.17715488f, 0.07297888f, 0.20016246f, 0.02250969f, -0.00729870f, 0.11704511f, 
    0.02132542f, -0.14718454f, -0.26197261f, 0.02600070f, -0.09630441f, 0.02118907f, 0.04137790f, -0.10969247f, 
    -0.12482483f, 0.22306886f, -0.08268924f, 0.08437983f, 0.03561148f, 0.13291730f, 0.07409875f, -0.35853890f, 
    -0.11945475f, 0.01094946f, 0.35364863f, 0.11939563f, 0.06138973f, -0.00292992f, 0.15648252f, 0.01121612f, 
    0.44450280f, 0.01885455f, 0.10787614f, -0.07810437f, 0.11773560f, 0.01567361f, 0.00756884f, 0.18170813f, 
    -0.11786322f, -0.07613358f, -0.22879347f, 0.16899382f, -0.06347051f, 0.06657404f, -0.06898726f, -0.19547255f, 
    -0.03058653f, 0.22830248f, 0.00557932f, 0.18966483f, -0.16563624f, -0.04232197f, -0.04446322f, 0.05030375f, 
    0.42993912f, -0.31461555f, -0.04892678f, -0.31989324f, -0.02439531f, 0.38208091f, 0.10360008f, -0.00708928f, 
    0.09605259f, -0.06290723f, 0.01547268f, -0.08118891f, -0.23465194f, -0.36691368f, -0.48079476f, -0.13690159f, 
    0.04190935f, 0.09977830f, 0.18033104f, -0.09170954f, 0.00664693f, 0.10100844f, 0.15513939f, -0.09532037f, 
    -0.01638879f, -0.19119237f, -0.03773071f, -0.14783242f, 0.35300204f, 0.12757246f, 0.09193739f, -0.10133561f, 
    0.10139934f, 0.10952732f, -0.01077776f, -0.10274840f, 0.04007069f, 0.20112091f, 0.17523906f, -0.05252774f, 
    0.06898785f, 0.03587082f, -0.07346940f, -0.06690048f, -0.05956426f, -0.19022833f, 0.05512601f, 0.01513628f, 
    -0.38089252f, 0.12572092f, 0.33459976f, -0.31627581f, -0.00673779f, 0.14236970f, 0.08879673f, -0.04696564f, 
    0.12107412f, -0.04983171f, 0.05360063f, 0.09600524f, 0.27434140f, 0.21172719f, -0.06408982f, -0.08334090f, 
    0.13246821f, 0.01541824f, -0.05662543f, -0.14655508f, 0.10787396f, 0.15852790f, 0.09391627f, 0.20929506f, 
    -0.09743868f, 0.04628760f, 0.01468884f, 0.04764860f, 0.01647666f, -0.01892052f, 0.13125837f, -0.17878178f, 
    -0.03893825f, 0.00449423f, 0.15020157f, -0.00140477f, -0.01391660f, -0.17972060f, -0.10902892f, -0.16402639f, 
    0.06419864f, 0.15272066f, 0.02327176f, 0.05131639f, 0.11339797f, 0.03506999f, 0.22253029f, 0.23513190f, 
    0.02040913f, -0.13971089f, -0.04676984f, 0.24556725f, 0.11739086f, 0.10531130f, 0.18914166f, 0.00885398f, 
    0.10710966f, -0.02048778f, 0.01267951f, 0.06139227f, 0.00415275f, 0.15697493f, 0.24202715f, 0.41472787f, 
    0.00823482f, 0.15485476f, 0.00578263f, -0.09827432f, -0.01891844f, -0.12161440f, 0.18515332f, -0.07258824f, 
    -0.24982861f, 0.05665893f, -0.05627557f, 0.00702234f, -0.14886603f, -0.05229440f, 0.01719264f, -0.10409705f, 
    0.12658310f, 0.17291473f, -0.02917593f, -0.04220673f, 0.32891575f, 0.34017101f, 0.20610429f, 0.38321480f, 
    0.02257795f, 0.19571249f, 0.08906800f, 0.04171222f, -0.04253597f, -0.05239436f, -0.04922502f, -0.12854470f, 
    0.12576687f, 0.18581720f, 0.03404684f, -0.07391173f, 0.03729201f, -0.16694318f, -0.10884826f, -0.12840271f, 
    -0.02587651f, -0.00473294f, 0.25627059f, 0.12987116f, 0.16659530f, 0.00311941f, 0.16406134f, 0.11995905f, 
    -0.01262743f, 0.07652616f, -0.30095685f, -0.09364307f, 0.14305618f, 0.25255036f, 0.00180260f, 0.15357111f, 
    -0.14712515f, 0.17598979f, 0.09232732f, 0.18653771f, -0.02625183f, 0.11239526f, -0.13253596f, -0.10042848f, 
    0.02737709f, 0.16277650f, 0.22079486f, 0.02201958f, -0.04060313f, -0.00183314f, 0.16326550f, 0.24011891f, 
    0.16261439f, -0.02697801f, -0.00824887f, 0.08488633f, -0.04856862f, 0.13343309f, -0.01598372f, 0.00374136f, 
    -0.35419628f, 0.12592432f, 0.22558542f, 0.39673343f, -0.03098781f, 0.01183608f, -0.24267127f, -0.03730180f, 
    0.03070583f, -0.09252264f, 0.20985162f, 0.16034836f, -0.12898463f, 0.43510428f, 0.23956354f, -0.03305000f, 
    -0.10429630f, 0.08647255f, -0.03555697f, -0.20027632f, 0.20594852f, -0.07566253f, -0.08913769f, -0.01197540f, 
    -0.02929591f, -0.03335126f, 0.14874977f, 0.11337446f, -0.09900936f, 0.12192846f, -0.05038565f, -0.04807174f, 
    0.02926597f, 0.08536553f, 0.01746498f, 0.21983062f, -0.23208354f, -0.26419845f, -0.18289194f, 0.02106616f, 
    -0.08579075f, -0.04488345f, 0.04118947f, 0.00592326f, 0.06659338f, 0.15729192f, 0.01562557f, 0.12336234f, 
    -0.08509333f, -0.14569113f, 0.24214306f, 0.16528334f, 0.10438135f, 0.20675561f, 0.35922346f, -0.04443189f, 
    0.03140508f, -0.09327932f, 0.02229095f, -0.15088898f, -0.18499015f, -0.35497868f, 0.07919304f, 0.01502191f, 
    0.20624125f, -0.05484622f, 0.01023931f, 0.11758113f, 0.02304485f, 0.03230227f, 0.19536342f, 0.04701203f, 
    -0.28095958f, -0.00600131f, -0.10725678f, -0.04498654f, 0.21159495f, 0.13145334f, 0.01562498f, -0.05564129f, 
    0.13393182f, 0.23740743f, -0.03264224f, 0.35257885f, -0.10840024f, -0.11888105f, 0.00670237f, -0.01313944f, 
    0.01827769f, -0.05939709f, 0.03403204f, 0.03254300f, 0.13924129f, 0.05675792f, 0.13901213f, 0.17655952f, 
    0.14049731f, 0.21259320f, -0.37870237f, 0.20811559f, 0.07738456f, 0.00015989f, 0.21994647f, 0.18290566f, 
    -0.06343064f, -0.07866978f, 0.14257917f, 0.15582791f, -0.17348920f, 0.47230092f, 0.11369199f, 0.03035218f, 
    0.02957978f, -0.05023335f, 0.09093983f, 0.06339923f, -0.14253111f, -0.02692490f, 0.02998724f, -0.12613761f, 
    0.11688289f, 0.12665029f, -0.15740609f, -0.00827979f, -0.12054367f, -0.06413756f, 0.18366191f, -0.07057388f, 
    0.10225481f, 0.05734940f, 0.02750754f, -0.09392539f, -0.06120482f, 0.35577080f, 0.04456835f, 0.47877637f, 
    -0.02113089f, -0.08535504f, -0.04881826f, -0.14356975f, 0.05240718f, 0.05987068f, 0.03883889f, 0.04199064f, 
    0.19225259f, 0.20061672f, -0.28314406f, 0.00747840f, -0.07897521f, -0.00931809f, -0.05588495f, -0.14975262f, 
    0.08073714f, 0.02723280f, -0.01439199f, -0.07144275f, 0.23498183f, -0.19596195f, 0.20907123f, -0.32005537f, 
    -0.09948920f, 0.12159116f, -0.25613394f, 0.08413458f, -0.20751007f, 0.02545378f, -0.13956831f, -0.35272035f, 
    -0.07434442f, 0.03249961f, 0.06762919f, 0.20600413f, -0.04015960f, -0.00004737f, -0.02916243f, 0.14725597f, 
    0.11557013f, 0.23626177f, -0.08974277f, 0.16701940f, -0.10076644f, -0.14965649f, 0.26439226f, 0.09380216f, 
    0.03004596f, 0.04474481f, 0.10908440f, 0.11641958f, 0.06592202f, 0.13133544f, -0.11826379f, 0.19496688f, 
    -0.20636477f, -0.07830805f, 0.09101141f, 0.07520501f, -0.00687111f, -0.15556018f, -0.08374494f, -0.01066202f, 
    -0.24549718f, 0.05633739f, 0.25976911f, -0.09740688f, -0.19136269f, 0.16705568f, 0.15532392f, -0.01246999f, 
    -0.04250355f, -0.19547996f, 0.11336696f, -0.15251423f, -0.10787629f, 0.27662531f, 0.13228458f, 0.08421549f, 
    0.07333584f, -0.14660200f, 0.14912182f, 0.04892043f, 0.07147885f, 0.10381190f, -0.01013152f, 0.07275732f, 
    0.20044382f, 0.16342951f, -0.10327983f, 0.07406964f, 0.06796709f, 0.04981153f, 0.05163870f, -0.13441873f, 
    -0.06953683f, -0.07466766f, 0.05737830f, -0.12993748f, -0.08676349f, 0.11803405f, 0.00766810f, 0.33701462f, 
    -0.01223642f, -0.04115902f, 0.42613742f, 0.09582765f, 0.22670460f, 0.07394097f, 0.16762669f, -0.00183019f, 
    0.00577518f, -0.16704494f, 0.07502790f, -0.16826062f, -0.05009156f, 0.00741812f, -0.11578325f, 0.12159932f, 
    0.34562933f, -0.40520588f, 0.03505560f, -0.05190833f, -0.13714983f, -0.08277526f, -0.15811288f, -0.26139620f, 
    -0.13016957f, 0.13977586f, -0.15293182f, 0.00119070f, 0.16903955f, -0.10300880f, 0.00875373f, -0.08364052f, 
    -0.10730102f, 0.02224878f, 0.00476552f, 0.03703580f, 0.07350779f, -0.25793079f, -0.16308568f, -0.27850473f, 
    -0.02257348f, 0.06071496f, 0.17509398f, -0.08933473f, -0.26236200f, -0.07512239f, -0.12548056f, 0.02876692f, 
    -0.05195108f, 0.08912591f, 0.26749235f, 0.03889830f, 0.14335735f, 0.07539016f, 0.02165039f, -0.01530856f, 
    0.09794988f, 0.09716257f, -0.03396898f, 0.00152887f, 0.24829355f, 0.18222421f, -0.03250060f, 0.22428945f, 
    -0.12080024f, -0.06140795f, 0.07958205f, 0.17537054f, 0.02476580f, -0.03946918f, -0.04614455f, 0.15707834f, 
    -0.32030767f, -0.22336511f, -0.21209246f, 0.07805765f, 0.11704778f, -0.16445166f, 0.18404549f, -0.08756052f, 
    -0.13357766f, -0.08167249f, -0.12579681f, 0.13071734f, -0.04167550f, 0.19847453f, 0.00658087f, -0.14559384f, 
    0.00969524f, -0.10510460f, 0.21676953f, 0.32071370f, -0.02349098f, -0.17643061f, -0.08485560f, 0.04947362f, 
    -0.36269954f, -0.31743401f, -0.11037435f, -0.03642261f, 0.14288829f, 0.13776365f, -0.10084955f, 0.10431760f, 
    -0.00527780f, 0.12354245f, 0.13181274f, 0.14164406f, 0.08673780f, -0.04737459f, 0.06512074f, -0.03099651f, 
    -0.18980497f, -0.03000641f, 0.24308981f, 0.07611318f, 0.01949959f, 0.18578207f, -0.04353634f, 0.02311037f, 
    0.06279756f, 0.16870497f, 0.05113025f, -0.05381438f, 0.16617209f, 0.03519376f, 0.08545653f, 0.08227541f, 
    -0.06614890f, -0.04452463f, -0.00209305f, -0.02966836f, 0.22026317f, 0.16597748f, 0.04090765f, 0.08663897f, 
    0.07938810f, 0.07024089f, 0.04803482f, -0.01685730f, 0.23431939f, -0.03916159f, 0.08799004f, -0.01817791f, 
    0.43003809f, 0.28358328f, 0.18080606f, 0.02712534f, 0.16982144f, -0.08921348f, 0.24121985f, -0.04922384f, 
    -0.08423334f, -0.00327773f, -0.20953213f, 0.02619648f, 0.41571990f, -0.06684043f, 0.01718345f, 0.48591071f, 
    -0.14651354f, -0.19332574f, -0.00104053f, 0.08663143f, 0.07974818f, 0.08347397f, 0.02667939f, 0.17511344f, 
    0.37193620f, 0.50114423f, 0.06204946f, 0.22835857f, 0.02131736f, -0.03665578f, 0.09430227f, 0.25530237f, 
    -0.09563635f, -0.15177526f, 0.04432079f, 0.12154616f, -0.42660648f, -0.41002291f, -0.36509022f, -0.04182794f, 
    0.01472686f, 0.28096148f, 0.01056220f, -0.13272671f, -0.06818536f, -0.08174603f, 0.02444193f, -0.03858806f, 
    -0.06134210f, -0.24231905f, -0.65229928f, -0.04232790f, 0.15167783f, -0.10137989f, 0.11083712f, 0.12740567f, 
    -0.05705599f, 0.18233369f, -0.04063058f, -0.08011365f, -0.39364523f, -0.05020076f, -0.07746907f, -0.09992871f, 
    -0.15705954f, 0.15268792f, 0.24589303f, 0.06165913f, -0.21804364f, -0.15419485f, 0.01228532f, -0.15503515f, 
    -0.12191872f, -0.11334777f, -0.09966353f, -0.14175254f, -0.18088886f, 0.01539025f, 0.09439941f, 0.04790497f, 
    0.03510320f, -0.17365310f, -0.09419543f, 0.05245068f, -0.15580483f, 0.07598756f, -0.15015028f, -0.22045706f, 
    0.13131148f, 0.01235236f, -0.04969562f, -0.06119276f, 0.07941575f, 0.24929239f, -0.00362688f, -0.30548611f, 
    0.04214630f, -0.01497704f, 0.04735831f, -0.04483257f, 0.05657784f, -0.00903315f, -0.02128029f, -0.04936640f, 
    0.00881445f, -0.02838247f, -0.04030718f, -0.05036061f, 0.04395716f, -0.05733633f, -0.01007600f, 0.05139552f, 
    -0.04219661f, 0.02285139f, 0.00824232f, -0.02181774f, -0.07866271f, -0.05557878f, -0.05252272f, 0.01192725f, 
    -0.03652648f, -0.06143099f, 0.08057475f, 0.02083321f, 0.04799268f, -0.06281374f, -0.01800780f, -0.06728350f, 
    0.02335105f, -0.05637784f, 0.01609066f, -0.01652247f, -0.00816958f, 0.02642718f, -0.05404726f, -0.04437724f, 
    0.02143809f, 0.05711295f, 0.02338010f, 0.05020053f, -0.05055169f, 0.01108191f, -0.03783566f, 0.03523631f, 
    -0.00690303f, -0.05725184f, 0.04086679f, -0.03168241f, 0.04708622f, 0.03794760f, 0.02092671f, 0.04592092f, 
    0.02107900f, -0.05247905f, -0.05692224f, -0.08666679f, -0.02090092f, -0.07535931f, 0.05223210f, 0.01144778f, 
    0.02329561f, 0.04198291f, -0.06513601f, -0.02861417f, 0.00996321f, 0.02055734f, 0.04347017f, -0.04063175f, 
    -0.00726196f, -0.01851662f, -0.05776898f, 0.02887565f, -0.06135517f, -0.00121927f, 0.01671823f, 0.06607097f, 
    -0.02163840f, 0.03135956f, 0.02952679f, -0.00868955f, -0.01510103f, -0.02557182f, 0.02612099f, 0.02500920f, 
    0.04468355f, 0.05023498f, 0.06561879f, -0.04280843f, -0.05781180f, 0.05719025f, -0.01496963f, -0.01146761f, 
    0.04195116f, 0.00578111f, 0.06171928f, -0.04826165f, 0.00252619f, 0.04125289f, 0.03005766f, 0.00724856f, 
    -0.00644842f, 0.03280108f, 0.03983331f, -0.06154401f, 0.05652901f, 0.02095206f, -0.01850733f, -0.03983531f, 
    0.02680755f, -0.08375819f, 0.04336930f, 0.02109166f, -0.08108961f, 0.05149126f, -0.06267518f, 0.05059849f, 
    -0.03174660f, 0.03337812f, -0.07370804f, 0.02998758f, -0.05875010f, -0.02093066f, 0.02384156f, 0.02463639f, 
    -0.03768385f, -0.09186067f, -0.03593343f, 0.05405794f, -0.04136651f, 0.04205129f, -0.05502301f, 0.01774924f, 
    0.04355542f, -0.02436270f, 0.00468513f, 0.03663952f, -0.03448078f, -0.08413898f, -0.02612437f, -0.05171552f, 
    -0.08869054f, -0.07677963f, 0.01474774f, -0.08155020f, -0.02062718f, 0.06755387f, -0.01865687f, 0.04289516f, 
    -0.02389336f, -0.03245880f, 0.00203820f, 0.01706342f, 0.00454794f, -0.08635531f, 0.00999905f, -0.01691282f, 
    -0.01973452f, -0.07597356f, -0.05018675f, -0.08184218f, -0.07532262f, 0.04723999f, -0.04793816f, -0.08918805f, 
    0.04568769f, -0.02326247f, -0.01084828f, -0.07452551f, -0.03731646f, 0.05802092f, -0.05316198f, -0.05882412f, 
    -0.06331037f, -0.00179386f, -0.09045158f, -0.01961166f, -0.02041822f, -0.02951127f, -0.05817461f, -0.07919726f, 
    0.02629539f, 0.00086066f, 0.00825723f, 0.03583549f, -0.07310014f, -0.01050246f, 0.05123111f, -0.02074368f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12114237f, 0.15683478f, 0.08998692f, -0.10725516f, 0.08190277f, -0.03465267f, 0.06679682f, -0.14644808f, 
    0.10044485f, -0.07004377f, 0.23741831f, -0.06188409f, 0.10261966f, 0.03574458f, 0.12307033f, 0.16837917f, 
    -0.10744592f, 0.05175018f, 0.00812850f, 0.34049687f, 0.33419901f, 0.19190685f, 0.23113851f, -0.06463583f, 
    0.31220484f, 0.04286357f, 0.04409649f, 0.07224897f, 0.08332715f, -0.08209325f, -0.16305296f, -0.02974740f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28337044f, 0.35158032f, 0.30807236f, -0.21227489f, 0.03726995f, -0.01620162f, -0.01438510f, 0.05772721f, 
    0.46162727f, 0.32666099f, -0.05859633f, 0.02264559f, 0.03694519f, -0.20327169f, -0.27741459f, 0.39436439f, 
    -0.28490531f, -0.13000794f, -0.12207340f, 0.28226361f, 0.31596437f, -0.31394964f, 0.06705354f, 0.13331744f, 
    0.48562744f, 0.05839338f, -0.04142070f, 0.10902331f, 0.07250263f, 0.28515586f, -0.31962234f, -0.15960436f, 
    -0.41373450f, -0.14318873f, 0.14157090f, -0.13281409f, -0.13097876f, 0.16135669f, 0.16071250f, -0.29693606f, 
    0.16543682f, 0.11992587f, 0.33627406f, -0.16483487f, 0.40785599f, -0.06340701f, -0.18226758f, 0.10925550f, 
    -0.06081303f, -0.00176209f, -0.25623211f, 0.34136373f, -0.12392842f, -0.33513522f, -0.09779579f, -0.07874087f, 
    0.21425009f, 0.15957931f, -0.42833570f, 0.07805662f, 0.19838499f, 0.15493326f, -0.43717006f, -0.12988454f, 
    -0.14759879f, 0.03844034f, 0.10465655f, 0.18067327f, -0.41012505f, 0.46437719f, 0.08677809f, -0.14548364f, 
    0.03893375f, -0.16407596f, 0.08768579f, 0.03597164f, -0.81750607f, 0.47392577f, 0.25178105f, -0.08918662f, 
    -0.19172382f, -0.09702976f, 0.19413878f, 0.06437071f, -0.12387105f, 0.32038829f, 0.09400608f, 0.06882489f, 
    0.12721099f, 0.02995608f, 0.02908939f, -0.06333750f, 0.24881130f, 0.21613739f, 0.06059086f, -0.07297431f, 
    -0.11548698f, 0.22140047f, -0.49457401f, 0.09676737f, 0.51284385f, 0.00519400f, -0.17187963f, -0.06815344f, 
    0.31489888f, -0.23198916f, -0.35504609f, -0.05747260f, 0.17920476f, -0.62232739f, 0.01117387f, 0.45326778f, 
    -0.03403707f, -0.01788534f, -0.11432754f, -0.21890074f, 0.55550426f, 0.16128018f, 0.25576115f, -0.08913455f, 
    0.25933912f, 0.13465878f, 0.09491619f, -0.19267279f, 0.14930318f, 0.37874013f, -0.00936380f, 0.17983709f, 
    0.44094715f, 0.22986877f, -0.23301321f, 0.29681030f, 0.01671378f, 0.23477939f, 0.40212530f, 0.39344394f, 
    0.59485525f, 0.38711888f, -0.43499172f, -0.02853213f, -0.28152752f, -0.24475747f, -0.10671720f, 0.43431363f, 
    -0.42078266f, 0.14966016f, -0.27906689f, -0.26536497f, -0.72060663f, -0.18253158f, -0.24967806f, 0.09131138f, 
    -0.28503442f, 0.11468142f, 0.22006454f, -0.53865647f, 0.18564422f, 0.44234949f, 0.20654871f, -0.14088109f, 
    -0.08258179f, -0.25463414f, -0.06848792f, -0.15332785f, -0.22441040f, 0.16543362f, 0.25801036f, -0.06197468f, 
    0.10310713f, -0.44509441f, 0.04025174f, 0.01186442f, -0.16669598f, -0.11645728f, -0.13759907f, -0.21001524f, 
    -0.04336942f, -0.15529865f, -0.07172224f, -0.37100708f, -0.04040010f, 0.16176447f, 0.03192993f, -0.07819498f, 
    -0.11318525f, 0.12332806f, 0.07033338f, -0.13784681f, -0.15027450f, -0.06738836f, 0.09844159f, -0.14267185f, 
    -0.10468765f, 0.10878949f, -0.07952419f, -0.02407665f, -0.23394632f, 0.14716758f, -0.05223898f, -0.04859144f, 
    -0.11246898f, -0.12411826f, 0.40128642f, 0.09639970f, 0.21714057f, 0.51511723f, 0.15254903f, -0.32963896f, 
    -0.07103321f, -0.04836712f, 0.21454796f, 0.24043810f, 0.03275029f, 0.29768166f, -0.14700399f, 0.06929713f, 
    -0.00591348f, -0.01698871f, -0.29319876f, 0.02875323f, 0.25589311f, -0.35616794f, -0.02087113f, 0.12942296f, 
    0.00929681f, 0.22252952f, 0.29606962f, 0.48316821f, -0.01121111f, 0.10361598f, -0.00334345f, -0.10759395f, 
    0.03094046f, 0.27486956f, 0.10885296f, 0.05833739f, 0.27341211f, -0.22574490f, -0.03878379f, -0.10493451f, 
    -0.32682097f, -0.01133835f, -0.13190643f, 0.06375170f, 0.36033234f, 0.09317847f, -0.21565489f, 0.10765763f, 
    0.25614169f, 0.03399580f, -0.25973368f, 0.18143566f, -0.26547620f, -0.03706711f, -0.28082266f, -0.02084981f, 
    -0.09470170f, -0.05917219f, -0.10231403f, 0.03019082f, -0.16352095f, -0.04796423f, -0.06418560f, -0.02457578f, 
    -0.09728028f, 0.11884344f, -0.05923840f, 0.06435541f, 0.03596378f, -0.12041602f, 0.05204557f, 0.09490187f, 
    -0.12677461f, -0.13159561f, -0.07752042f, -0.18168592f, -0.00801333f, -0.09346380f, -0.19686483f, 0.05139941f, 
    -0.13817991f, -0.16785961f, 0.04792296f, 0.09839999f, -0.26269603f, 0.14828172f, -0.14623109f, 0.13538989f, 
    0.30171105f, 0.12231376f, -0.21029316f, 0.28034043f, 0.00981065f, 0.15849091f, -0.17539231f, 0.06414234f, 
    -0.19901143f, -0.30977648f, -0.38793233f, 0.16586252f, -0.19290727f, -0.30339780f, 0.37105101f, 0.41315988f, 
    0.19175123f, 0.09023471f, 0.28700978f, 0.18978566f, 0.04467944f, 0.44897747f, 0.28248203f, -0.07083438f, 
    -0.16168733f, -0.14098313f, 0.12150910f, -0.39247167f, 0.26629853f, 0.15923071f, 0.25814474f, 0.11244465f, 
    0.02534128f, -0.47158226f, 0.25022605f, -0.24889073f, 0.27355236f, 0.07157117f, 0.41779530f, -0.41215089f, 
    -0.16837548f, 0.02594906f, 0.01024127f, -0.17226636f, -0.22764841f, 0.09634609f, 0.31594238f, 0.22173087f, 
    0.13844897f, -0.09115824f, 0.00194080f, 0.02943278f, 0.09549343f, 0.17751884f, -0.03347895f, -0.02439310f, 
    -0.21014158f, -0.15555167f, -0.06981449f, 0.15802902f, -0.18992922f, 0.31334913f, -0.39964035f, 0.07995294f, 
    -0.04393356f, -0.05454531f, 0.09046604f, 0.00961903f, -0.09618198f, -0.13330498f, -0.12269539f, 0.06634526f, 
    0.11356499f, -0.12397595f, -0.22987929f, 0.14337000f, 0.12726389f, -0.16735947f, 0.13738865f, 0.11811154f, 
    -0.18541597f, 0.10424036f, -0.02845700f, -0.06933795f, -0.03117417f, -0.17735958f, -0.17671026f, 0.05811844f, 
    -0.05487460f, 0.05339199f, -0.01147674f, -0.11072562f, -0.08109567f, -0.07214776f, -0.03588276f, -0.08675272f, 
    0.08325842f, -0.03437265f, -0.20044959f, 0.09048475f, -0.16960607f, -0.13913576f, -0.13610572f, -0.06585547f, 
    -0.17910101f, -0.10136064f, -0.17751063f, -0.01258134f, 0.05930962f, 0.04752386f, 0.01840457f, 0.02175115f, 
    -0.02869797f, 0.04565282f, -0.11764838f, 0.11357342f, 0.03458294f, -0.06566542f, 0.02806988f, -0.10088516f, 
    -0.05723794f, 0.15056333f, -0.17830411f, -0.09825691f, -0.15936409f, 0.04020723f, 0.09066282f, 0.12069248f, 
    0.01068300f, -0.30773690f, 0.29203618f, 0.32913211f, 0.02089039f, 0.36845985f, 0.25234056f, -0.24885258f, 
    -0.12940459f, -0.37135860f, 0.14059688f, 0.07416163f, -0.19639048f, -0.01397496f, -0.05927000f, 0.11346120f, 
    -0.14231694f, -0.06878503f, -0.08522522f, 0.07923135f, 0.18924822f, 0.26834640f, -0.19452569f, -0.13262290f, 
    -0.11789599f, -0.05435045f, 0.36974278f, -0.17692304f, -0.15866394f, 0.12447190f, -0.26686096f, 0.05665466f, 
    -0.13340841f, 0.27254450f, 0.14002572f, -0.68724227f, -0.21522969f, 0.22850063f, 0.25985509f, -0.13358673f, 
    -0.24758108f, -0.16671470f, 0.44949070f, -0.04223286f, -0.32972702f, 0.66173965f, 0.17947206f, -0.13278481f, 
    -0.32630092f, -0.02324359f, 0.13205460f, 0.49874282f, -0.22584793f, -0.05364558f, 0.40748647f, 0.02560676f, 
    0.25644162f, -0.02683335f, 0.00071671f, 0.03741236f, 0.21210806f, -0.20520200f, -0.18357728f, 0.01247391f, 
    -0.25642422f, -0.39040095f, -0.07595510f, 0.02338813f, 0.36155072f, 0.06806032f, 0.19731817f, 0.06587838f, 
    0.09023833f, -0.15110652f, 0.36402300f, 0.01421898f, -0.17438483f, -0.10269795f, -0.00023883f, 0.39178652f, 
    0.02272564f, -0.06443649f, -0.47230685f, 0.11503699f, -0.09441964f, 0.33351219f, 0.26432502f, 0.00785281f, 
    -0.08433560f, 0.03074314f, 0.28330600f, -0.11557606f, -0.11873351f, 0.43668559f, -0.23633428f, 0.12740816f, 
    0.00884259f, -0.09701796f, -0.01856215f, 0.09181029f, 0.14189073f, -0.17443793f, -0.23255968f, -0.06419905f, 
    -0.07407996f, 0.04296598f, -0.04599158f, 0.00658365f, 0.20552938f, 0.14710201f, 0.13488688f, 0.17053244f, 
    -0.17987216f, 0.11727756f, -0.20281436f, 0.13115479f, 0.17437540f, 0.15318307f, -0.23897502f, -0.07308310f, 
    0.10683845f, -0.14800397f, -0.29198200f, -0.22808471f, 0.03843236f, -0.10024462f, 0.12967852f, -0.05193080f, 
    -0.12015936f, 0.26556459f, 0.12059209f, 0.06515580f, 0.10278571f, 0.26322901f, 0.11159389f, 0.03448307f, 
    0.32006121f, 0.39827591f, 0.06450955f, -0.10811371f, -0.01279851f, 0.44401103f, 0.34501845f, -0.06826211f, 
    -0.20337482f, 0.07262719f, 0.16292621f, -0.34045261f, 0.03301242f, -0.49986887f, -0.31470522f, 0.05300596f, 
    -0.13418362f, 0.05639181f, 0.14139464f, 0.54884732f, 0.15493874f, 0.29690090f, -0.03482417f, -0.02485011f, 
    -0.01653021f, 0.19546342f, 0.37861428f, -0.23554803f, -0.15041269f, -0.10139517f, 0.03351494f, 0.23028407f, 
    -0.03730896f, 0.11310270f, -0.02713079f, -0.06900414f, 0.53707445f, 0.15867172f, -0.13371430f, 0.18126446f, 
    -0.31572786f, 0.10055871f, 0.11514686f, 0.65524721f, 0.05123512f, 0.09092870f, 0.02195450f, -0.08940499f, 
    0.36430994f, -0.14257732f, -0.56162333f, -0.62244838f, 0.03494115f, -0.33470240f, 0.19549830f, 0.05117455f, 
    -0.03200052f, -0.14158723f, -0.39847577f, 0.13413468f, 0.36233413f, -0.06250067f, -0.32158482f, -0.20820670f, 
    0.26877040f, -0.04602386f, -0.05772880f, -0.11543062f, -0.08338701f, -0.03628860f, 0.49734196f, 0.37760347f, 
    -0.27282321f, 0.14654148f, -0.22428100f, -0.08906369f, 0.33641997f, 0.09293428f, -0.16263895f, 0.08597538f, 
    0.15268534f, -0.04482345f, 0.19849828f, 0.15632120f, 0.19805373f, 0.49516702f, -0.06621321f, -0.02602175f, 
    -0.10590929f, 0.06148240f, -0.05814647f, -0.10036225f, 0.19979006f, -0.21560273f, -0.19347101f, -0.22384469f, 
    -0.15158066f, -0.34943932f, 0.59148717f, -0.03570512f, 0.11107496f, 0.51076937f, 0.18395513f, 0.03708229f, 
    -0.04896259f, -0.04209474f, 0.02130906f, 0.14588860f, 0.62213534f, 0.33731815f, 0.36786398f, -0.01060741f, 
    0.15021947f, -0.04917267f, 0.04143031f, 0.07928943f, -0.10891259f, 0.04524710f, 0.07528622f, -0.07502650f, 
    0.43844506f, 0.30167550f, 0.27564695f, 0.58509326f, -0.03679621f, 0.32127297f, 0.18930766f, 0.26885617f, 
    -0.25418621f, 0.21456508f, -0.12716535f, -0.03535722f, -0.07384426f, -0.09689429f, 0.10909727f, -0.16539551f, 
    0.04061843f, 0.12685873f, 0.14637004f, -0.18638381f, 0.00123802f, 0.40785563f, -0.04867062f, -0.06837197f, 
    -0.06339896f, -0.09943810f, 0.22738539f, -0.10539445f, 0.20103909f, -0.33406344f, 0.54338741f, 0.04151704f, 
    0.05709047f, 0.28287283f, -0.19490401f, 0.33452588f, 0.29643899f, -0.15103546f, 0.40072519f, 0.31313348f, 
    -0.01762244f, -0.00169802f, 0.14623736f, -0.01528243f, -0.21891707f, 0.15732983f, 0.30094329f, -0.22640698f, 
    -0.24665315f, 0.00939355f, -0.08468943f, -0.24456203f, 0.33350313f, 0.14086011f, 0.20991752f, -0.13785677f, 
    0.03900774f, -0.07797709f, 0.65736622f, 0.12514202f, -0.29345384f, -0.25868520f, 0.14819488f, -0.06938119f, 
    0.04426945f, 0.05393999f, 0.26238310f, 0.15340316f, 0.07267744f, 0.14325893f, 0.38488463f, -0.30171138f, 
    -0.04262194f, 0.55464494f, -0.24337555f, -0.03976273f, 0.11750451f, -0.19341943f, -0.12080293f, 0.08778679f, 
    -0.04712959f, 0.01285918f, -0.03890940f, 0.00676642f, 0.13658613f, -0.08500167f, -0.10505831f, 0.09477419f, 
    0.11511964f, -0.13166189f, -0.12348196f, 0.12776735f, -0.29787761f, 0.16227172f, -0.29360515f, 0.02608597f, 
    0.23253341f, 0.36596778f, -0.16306004f, -0.02736896f, 0.38197398f, -0.31684399f, -0.04277381f, 0.25979814f, 
    -0.18645905f, 0.10912023f, -0.24337183f, 0.09500412f, 0.22252607f, -0.37371430f, 0.21949363f, 0.33200669f, 
    0.16174819f, -0.15538895f, 0.08324031f, 0.23829564f, 0.19518974f, -0.04399318f, 0.52803755f, 0.16967855f, 
    0.07811141f, -0.05073575f, 0.23577049f, -0.20650372f, 0.10269690f, -0.28874302f, 0.08670189f, -0.03268933f, 
    -0.18599194f, -0.05186228f, 0.10103802f, 0.09276158f, 0.09418540f, -0.02868039f, 0.13126977f, -0.14935692f, 
    0.04076416f, 0.02478021f, -0.22933084f, 0.10214952f, 0.08615983f, 0.05297698f, 0.16010436f, 0.20408028f, 
    0.02275984f, 0.10542709f, -0.01727505f, 0.15874739f, -0.13457915f, 0.03210941f, -0.18867207f, 0.14765435f, 
    -0.17991559f, -0.01552646f, -0.18451090f, -0.00325797f, -0.05110126f, 0.00412336f, 0.07890302f, -0.17114168f, 
    0.32343501f, -0.02536083f, -0.11270779f, 0.20334759f, 0.12907094f, 0.01045027f, -0.52931714f, 0.08639061f, 
    -0.08082265f, 0.23896854f, 0.16625719f, 0.08458643f, 0.38703385f, 0.23272111f, 0.29075247f, -0.12758225f, 
    0.01821166f, -0.01670239f, 0.18067893f, -0.19437376f, -0.27525347f, 0.11191045f, -0.28403002f, 0.01695747f, 
    -0.47977158f, -0.10218057f, 0.41829291f, 0.33523580f, -0.11040184f, -0.28193647f, 0.35588282f, -0.06456663f, 
    -0.07961819f, -0.13808750f, -0.05751586f, 0.46308848f, 0.14599390f, -0.14387102f, 0.15718701f, 0.13494354f, 
    0.14460610f, -0.29832351f, 0.35418704f, 0.00338601f, 0.16606376f, -0.26496199f, -0.43896630f, 0.18990751f, 
    -0.11603126f, -0.09383810f, -0.29762572f, 0.08244345f, 0.29266086f, 0.57633728f, 0.15587129f, -0.03627115f, 
    0.26624775f, 0.10466924f, -0.02967266f, -0.08747239f, 0.01448603f, -0.02349178f, -0.37880033f, -0.11995213f, 
    -0.14917326f, -0.11477804f, 0.09293737f, -0.21114235f, 0.13879190f, 0.22033656f, -0.19682941f, 0.07608566f, 
    0.52226043f, 0.11544915f, 0.44356108f, -0.10643376f, -0.13595173f, 0.05966324f, 0.02639250f, 0.04368449f, 
    -0.00986384f, -0.11186468f, -0.24452907f, -0.02641523f, -0.36042905f, -0.07999545f, -0.11495221f, 0.00768315f, 
    0.13800772f, 0.04601160f, -0.04336411f, 0.18343391f, 0.21007295f, 0.30544889f, -0.28036559f, -0.05389135f, 
    0.16544855f, -0.04222869f, 0.10904162f, 0.32864621f, 0.03543008f, -0.21733142f, 0.28722504f, 0.19354019f, 
    -0.19448371f, 0.31469035f, 0.04947253f, -0.12777074f, 0.25979444f, 0.14611508f, -0.35484663f, -0.34460229f, 
    -0.10900971f, -0.12505203f, 0.12494816f, 0.01096956f, 0.19358915f, -0.02038802f, -0.17027956f, -0.05383842f, 
    0.18148850f, 0.06434879f, 0.02608557f, -0.23368095f, 0.04904715f, -0.11596315f, 0.30191475f, -0.09612112f, 
    0.22949335f, -0.27522919f, 0.11704820f, 0.27238089f, 0.15118656f, -0.01002525f, -0.45014417f, -0.00888705f, 
    0.50939673f, 0.43966091f, 0.08473299f, -0.02834224f, 0.28653103f, 0.09951872f, 0.32174152f, 0.30888027f, 
    -0.47118831f, 0.04169859f, -0.17951784f, 0.22176298f, -0.17379254f, 0.09020413f, -0.51375163f, -0.01200292f, 
    -0.08638968f, -0.13247852f, -0.42857364f, -0.43228576f, 0.10380227f, 0.39349502f, 0.03623938f, -0.08764143f, 
    -0.36553046f, -0.13331318f, -0.05653611f, 0.17110913f, 0.14291665f, -0.20715509f, 0.13735342f, -0.30126208f, 
    0.27635235f, -0.07411717f, 0.23625822f, 0.13921078f, 0.36607417f, -0.24995089f, -0.04407462f, 0.18430531f, 
    0.14831784f, -0.09321072f, 0.03158407f, 0.10548293f, -0.05696639f, 0.15270175f, -0.15162452f, -0.04548385f, 
    0.19430219f, 0.17114660f, 0.16409017f, 0.22032650f, 0.08203627f, 0.12457899f, -0.30788526f, 0.05732684f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13277894f, 0.24373502f, 0.17019889f, 0.13378887f, -0.15308209f, 0.02475717f, 0.13354570f, 0.15117644f, 
    -0.02699490f, 0.23151894f, -0.06045335f, -0.01602915f, -0.15680106f, 0.12296287f, 0.18050463f, 0.02290925f, 
    -0.02924238f, 0.21312408f, 0.32358262f, 0.05637723f, 0.27701578f, 0.04130744f, -0.08764021f, -0.13052623f, 
    0.04523639f, -0.13226883f, -0.07853566f, 0.19353555f, 0.00430528f, -0.23377483f, 0.09752402f, 0.16303493f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.84019917f, -0.38778955f, -0.07149609f, -0.37199098f, 0.27863419f, -0.37581205f, -0.18081465f, -0.20548901f, 
    -0.10691930f, 0.10127892f, -0.26090571f, -0.08082440f, -0.04685178f, 0.11964888f, -0.18878894f, -0.35277686f, 
    0.24700798f, 0.06259929f, -0.62804693f, -0.13523604f, -0.55918962f, 0.12401799f, 0.23762597f, -0.30753121f, 
    0.02332780f, -0.34712765f, 0.48493305f, -0.33287385f, -0.22737990f, -0.01598621f, -0.06655786f, -0.04540261f, 
    -0.51161426f, -0.23710443f, 0.09524317f, -0.47642735f, -0.82735050f, 0.33976728f, 0.16522171f, -0.21207796f, 
    -0.12125377f, 0.01828691f, 0.09776269f, -0.10294617f, -0.08514739f, 0.29433334f, 0.13667926f, 0.27072480f, 
    -0.36433169f, 0.00632470f, 0.20907503f, -0.55669802f, 0.09588116f, 0.23413533f, 0.23825176f, 0.19858727f, 
    0.03604059f, 0.06012775f, 0.21686189f, 0.02766274f, -0.50052685f, 0.55687588f, -0.56152308f, -0.10292562f, 
    0.02766885f, 0.16511258f, -0.45679373f, -0.02095410f, -0.50639606f, -0.28573999f, 0.11754645f, 0.24086966f, 
    0.03324175f, -0.05666209f, -0.40312892f, 0.12982252f, 0.04325620f, -0.37009954f, -0.17660230f, -0.77751076f, 
    0.38855720f, 0.10160349f, 0.29159445f, 0.24626043f, 0.06621309f, -0.26036236f, -0.32287320f, -0.01316772f, 
    0.08406315f, 0.02300020f, -0.05762980f, -0.25175574f, -0.17006749f, -0.04653152f, 0.59582442f, 0.12038392f, 
    0.21005459f, -0.35442758f, 0.11999697f, -0.20801659f, 0.17019840f, -0.54868084f, 0.05000063f, -0.42229384f, 
    0.02974044f, -0.04860050f, -0.15933587f, 0.12236319f, 0.13728654f, -0.36608440f, 0.08859164f, 0.02775190f, 
    0.07713494f, 0.26508465f, 0.12810990f, -0.05173822f, -0.49497214f, -0.06609308f, -0.18640843f, 0.21620263f, 
    -0.11679800f, -0.11742320f, -0.15737547f, -0.21236749f, 0.40945652f, 0.08546881f, 0.44684362f, -0.83313912f, 
    -0.00815987f, -0.08392492f, -0.29276338f, 0.52975219f, 0.23765655f, 0.00712319f, -0.12103137f, -0.57496625f, 
    -0.24802594f, 0.22614662f, 0.16149421f, 0.05890159f, -0.11269852f, 0.02925009f, -0.29258665f, -0.52551758f, 
    -0.16659833f, 0.05467521f, -0.13438945f, -0.03186242f, -0.41325879f, 0.05046827f, -0.10831357f, 0.16614898f, 
    0.17529428f, -0.02194081f, -0.19868548f, -0.40149847f, -0.16318309f, 0.06895481f, -0.14980486f, 0.06974433f, 
    -0.01467277f, -0.36890212f, 0.06355965f, 0.13370982f, -0.30706704f, -0.85661864f, -0.02748220f, -0.15589428f, 
    -0.27100515f, 0.00804328f, 0.00787369f, 0.11488798f, -0.07536562f, -0.30503786f, 0.30379495f, -0.21870007f, 
    -0.08529584f, 0.29802632f, -0.33630827f, 0.23874800f, 0.19846021f, -0.08623184f, 0.33016470f, 0.01570258f, 
    0.13652831f, -0.14646110f, -0.08329637f, -0.69282055f, -0.05066165f, -0.53094876f, -0.83523870f, -0.01858024f, 
    0.20244919f, 0.32657018f, -0.69282091f, 0.07616505f, -0.28981930f, -0.32208669f, -0.22486867f, -0.16909255f, 
    -0.09185385f, -0.31361678f, 0.16814919f, 0.06270126f, -0.10364407f, -0.05704886f, 0.11458844f, 0.35482144f, 
    0.01053126f, -0.44343856f, 0.19218720f, -0.01731578f, 0.16549349f, -1.01031375f, -0.40295935f, -0.10159654f, 
    -0.05650209f, -0.07246898f, -0.36021683f, 0.19806588f, 0.24823789f, -0.31065387f, -0.02158936f, 0.29006743f, 
    0.09659825f, 0.14416738f, 0.21538429f, 0.04529141f, 0.09761108f, -0.43445104f, -0.33981958f, 0.21407053f, 
    -0.07769858f, -0.16999799f, 0.14768569f, -0.02574770f, 0.16321525f, 0.22459020f, -0.27872777f, 0.18010740f, 
    -0.31329697f, 0.26140723f, -0.72362965f, 0.26041940f, -0.10818481f, -0.14623688f, -0.16972663f, 0.29136112f, 
    -0.59741443f, 0.01110223f, -0.32708710f, -0.13805479f, -0.12240454f, -0.19233429f, 0.04381362f, 0.07568538f, 
    0.02760698f, 0.21108119f, 0.25237197f, -0.66370410f, -0.65018535f, -0.49595624f, 0.42337972f, -0.03204074f, 
    -0.10976470f, -0.75276840f, -0.30566573f, 0.14283305f, -0.07113513f, 0.06343823f, 0.41272357f, -0.28827685f, 
    -0.29400823f, 0.09845271f, -0.03777841f, -0.16741061f, 0.17455125f, -0.23944543f, -0.14943062f, -0.01864759f, 
    -0.46251929f, -0.11020597f, -0.74551576f, 0.10346641f, 0.26292142f, -0.16857129f, 0.05080854f, 0.09115268f, 
    -0.39973879f, -0.22954124f, -0.13825473f, 0.36214307f, -0.19787429f, -0.44212136f, -0.00314903f, -0.20350455f, 
    0.01129649f, 0.25164619f, -0.12429595f, 0.08777786f, -0.08849077f, 0.34233552f, -0.59202445f, 0.17284149f, 
    0.16570570f, -0.61829209f, -0.18652365f, 0.41381106f, 0.20107318f, -0.30209538f, 0.07869928f, -0.41575101f, 
    -0.16224620f, -0.17735630f, -0.00389415f, 0.21066466f, 0.06838851f, -0.21062391f, 0.24228488f, 0.24837352f, 
    -0.12806991f, 0.00406425f, 0.43808708f, -0.25160271f, -0.21716405f, -0.27763024f, 0.07493225f, -0.40187398f, 
    -0.03625061f, 0.43503380f, -0.69850552f, -0.04962880f, -0.13735263f, -0.43897590f, 0.40225831f, -0.24028844f, 
    -0.03498288f, -0.60210747f, 0.51468748f, -0.52119589f, -0.02687737f, 0.16613002f, -0.66013414f, -0.47022310f, 
    0.11899279f, -0.01352918f, -0.63407981f, -0.20928021f, -0.35025197f, -0.52667087f, -0.39362773f, -0.21328354f, 
    0.46576545f, -0.00669283f, -0.24062893f, 0.01282982f, -0.13986625f, -0.04842545f, -0.30289617f, 0.37818801f, 
    0.02500750f, -0.54970860f, -0.54943281f, -0.15969801f, -0.07109218f, -0.02325482f, -0.10356194f, -0.16369104f, 
    -0.43766657f, -0.20403311f, 0.22317787f, -0.47722024f, 0.03290154f, -0.05312724f, 0.33123353f, 0.20975584f, 
    0.02856574f, -0.16591674f, -0.33042634f, 0.36498904f, -0.20014593f, 0.44957781f, -0.66087127f, 0.08540174f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19080825f, -0.02910768f, 0.12537591f, -0.22167420f, -0.08980689f, -0.00360236f, 0.16147512f, -0.29171857f, 
    0.31306118f, 0.04429865f, 0.18799157f, -0.19264175f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
