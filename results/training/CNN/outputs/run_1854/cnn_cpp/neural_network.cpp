#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12613860f, 0.14732698f, 0.48457417f, 0.98722351f, 0.05933777f, 0.00630893f, -0.10521881f, -0.40900242f, 
    -0.59763288f, -0.73862439f, 0.26209059f, 0.09051752f, 0.22391233f, 0.22755998f, 0.54509753f, -0.44820258f, 
    -0.15882428f, -0.29122037f, -0.22524035f, 0.18518175f, 0.41875759f, 0.41058785f, -0.23559196f, 0.06564088f, 
    -0.19603063f, -0.41704455f, -0.51487172f, 0.11645298f, 0.31467882f, 0.24505013f, 0.41456380f, -0.38979265f, 
    -1.27383149f, -0.68209130f, -0.02500016f, 0.69785279f, -0.25176740f, -0.36450660f, -0.64578182f, 0.90157306f, 
    -0.34660083f, -0.19880787f, -0.14671721f, 0.08758254f, -0.02922368f, 0.14251167f, 0.29827341f, 0.28027242f, 
    0.05397217f, 0.24723990f, -1.38148332f, -0.64468217f, 0.07092237f, 0.69564605f, 0.99489951f, 0.06225392f, 
    -0.05873663f, -0.15960188f, -0.07204659f, 0.20580299f, 0.31705570f, 0.45235792f, 0.02869817f, 0.36509371f, 
    -0.49831462f, 0.03683858f, 0.03445052f, -0.21308954f, -0.30373222f, -0.45457935f, -0.44004130f, 0.14033346f, 
    -0.34772164f, -0.19140305f, -0.44254026f, 0.28563970f, 0.10062917f, -0.20576908f, -1.21556008f, -0.93635106f, 
    -0.03632322f, -0.25077197f, -0.00823729f, 0.58290982f, 0.61623764f, -0.38397440f, -0.41019350f, 0.01178335f, 
    -0.16618462f, 0.69182181f, -0.24398158f, 0.08075096f, -0.46052533f, 0.00473426f, 0.51889437f, 0.08702813f, 
    -0.03428878f, -0.00146619f, -0.29592049f, -0.20383754f, 0.63330054f, 0.88362330f, 0.50937939f, -0.30051002f, 
    -0.34691492f, 0.05680929f, -0.53360629f, -0.53211641f, 0.05232882f, -0.81367511f, 0.27033228f, -0.53704429f, 
    0.08033961f, 0.29627648f, 0.04875070f, 0.55831361f, 0.13686965f, -0.17555533f, 0.14462790f, 0.26991001f, 
    -0.35078153f, 0.21808913f, 0.18225306f, -0.00167856f, 0.50712532f, -2.01794505f, -0.28853592f, -0.06272054f, 
    -1.02944779f, -0.85683781f, 0.50920820f, 0.79683316f, 0.66911209f, 0.17220044f, 0.85224247f, 0.04169562f, 
    -0.07157719f, -0.08517392f, -0.24160700f, 0.09863146f, 0.00685274f, 0.30675125f, -0.22938001f, -0.27437583f, 
    -0.05520664f, -0.32152575f, -0.21445082f, -0.08699391f, -0.24587017f, -0.51688010f, 0.46438470f, 1.15165019f, 
    0.81101024f, -0.58849758f, -0.36126119f, 0.22362256f, -0.07325945f, -0.35955557f, -0.26192662f, -0.32267246f, 
    0.13497852f, -0.32685983f, -0.24128892f, -0.02422648f, -0.44843054f, -0.36732405f, -0.17049845f, 0.09208114f, 
    0.45089179f, 0.09052505f, 0.40739796f, -0.06775731f, 0.29162377f, -0.49106428f, -0.46945190f, -0.02729924f, 
    0.58355993f, -0.02028100f, 0.55873501f, -0.85319960f, 0.70136493f, -0.52252018f, 0.20251563f, 0.43957171f, 
    0.34658456f, 0.07726558f, -0.26929978f, -0.11583917f, -0.40300775f, -0.48699468f, 0.25906011f, 0.11897837f, 
    -0.09375674f, -0.03420936f, -0.20313582f, -0.48754203f, 0.10001238f, -0.37048471f, -0.52036309f, -0.58901656f, 
    -1.53119433f, -0.55504942f, -0.36941442f, -0.34471378f, -0.10495373f, -0.27300510f, -0.64768004f, -0.99905676f, 
    -0.95955360f, -0.49996784f, -0.22485082f, -0.17491545f, 0.46877345f, -0.76367068f, -0.29545707f, 0.39379603f, 
    0.33239862f, 0.12951162f, 0.21579884f, 0.45485780f, 0.16922322f, 0.00468200f, 0.05190390f, 0.09827760f, 
    0.34457618f, 0.64901865f, 0.58308572f, -0.65582877f, -0.37149051f, -0.64969671f, -0.55217636f, -0.27118778f, 
    0.56851608f, 0.94908327f, 0.77250051f, 0.06469046f, 0.02219298f, 0.01990115f, 0.62330258f, -0.26259431f, 
    -0.50698853f, 0.03177105f, 0.45825416f, -0.08967110f, -0.39313477f, 0.20176949f, 0.00190264f, 0.34402800f, 
    -0.12215000f, -0.22609960f, 0.28181309f, 0.35217366f, 0.61446184f, -0.07804690f, -0.29933700f, -0.33575529f, 
    0.45562032f, 0.34260035f, -0.15537222f, -0.03290163f, 0.16574369f, 0.23939945f, 0.73391289f, -0.85954946f, 
    -0.39199412f, 0.34156781f, 0.03010656f, -0.57180852f, -0.01009050f, 0.06689738f, -0.16002142f, 0.40585598f, 
    -0.38359705f, -0.35475147f, 0.46669352f, -0.18033889f, -0.57952821f, -0.79503447f, -0.13629013f, -0.31708479f, 
    -0.80051196f, -1.02957606f, -1.36928415f, -1.27575827f, -1.09657669f, 0.23709907f, -0.14195020f, 0.06046430f, 
    0.46249479f, -0.12860706f, -0.46032873f, 0.13978133f, -0.46531108f, -0.22896531f, -0.45771983f, -0.29223713f, 
    0.11155447f, 0.27149200f, -0.13121717f, -0.35454267f, 0.41380817f, -0.03838859f, 0.46078596f, 0.60923636f, 
    0.47646564f, 0.88560450f, 0.75770116f, 0.58205861f, 0.20193259f, -0.07782128f, -0.01163240f, 0.29604116f, 
    0.29941869f, -0.36772752f, -0.13746074f, -0.42573270f, 0.05674028f, -0.16396077f, -0.18187457f, -0.08045521f, 
    0.13609289f, 0.29546368f, -0.12846781f, -0.23900716f, -0.03338597f, -0.44764683f, 0.14817418f, -2.10345912f, 
    -1.78986311f, -1.22676980f, 0.57734358f, 0.71759415f, 0.86311412f, -0.40403807f, -0.63055629f, -0.40316662f, 
    0.22634928f, -0.60859549f, -0.77201855f, -0.67419779f, 0.00300987f, -0.51074982f, -0.06375526f, -0.09196363f, 
    -0.30589366f, 0.22031526f, -0.03694880f, -0.05508853f, -0.05926104f, -0.22033851f, -1.66100121f, -0.41848534f, 
    -0.26119116f, 0.10350409f, 0.57878804f, -0.20195109f, -0.50549716f, 0.45306098f, 0.02730885f, -0.49107856f, 
    0.72233206f, 0.61993122f, 0.29427350f, 0.32736254f, -0.02849078f, -0.17754248f, 0.05639292f, -0.24177857f, 
    0.15334104f, 0.02665407f, 0.09288248f, 0.32155848f, 0.60278082f, -0.00475289f, -0.20734581f, 0.60697061f, 
    0.92857134f, 0.40379381f, 0.34496048f, 0.38162753f, -0.65555048f, -0.40132549f, -0.00230399f, 0.67557377f, 
    0.26383504f, 0.35909665f, -0.04612790f, -0.37491843f, -0.42980075f, 0.46610078f, -0.18627881f, 0.00637518f, 
    0.00119624f, -0.16784568f, 0.00694223f, -0.10599189f, 0.10126949f, -0.17473115f, 0.28213257f, -0.12284944f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03963930f, 0.67395699f, -0.13614057f, 0.81054080f, 0.61679894f, 0.20280068f, 0.59673244f, 0.33163700f, 
    -0.14939724f, 0.47217450f, 0.77333862f, -0.03943654f, -0.14462692f, -0.09660698f, 0.63021648f, 0.18846986f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24891238f, -0.21679173f, 0.01132310f, -0.15632214f, -0.21563055f, 0.19852020f, 0.02140092f, 0.06685853f, 
    0.11518861f, 0.12406481f, 0.09660351f, -0.20408274f, 0.28675950f, 0.32647225f, -0.41890234f, -0.56578618f, 
    0.07844941f, 0.02541404f, -0.08335395f, -0.00786832f, -0.10752450f, -0.07078912f, 0.06950624f, -0.19276528f, 
    0.30147880f, 0.36852211f, 0.08232151f, -0.31080961f, -0.18409133f, 0.14367361f, 0.09168576f, 0.00968168f, 
    -0.09842015f, 0.14677647f, 0.00750148f, 0.23531303f, -0.13227312f, -0.09587222f, 0.23884715f, -0.17637499f, 
    -0.28192735f, -0.08725658f, -0.32021824f, -0.20573778f, -0.04141742f, -0.16886155f, -0.04536286f, -0.07434762f, 
    0.06745913f, -0.10343966f, -0.11868607f, 0.06384030f, -0.18295893f, 0.00731939f, -0.34475246f, -0.15471113f, 
    -0.08760911f, 0.00131150f, 0.02649030f, -0.04216563f, -0.08777472f, -0.12682468f, 0.05687178f, -0.09972870f, 
    0.13397188f, 0.16685013f, -0.00596134f, -0.07198796f, 0.07170983f, 0.12704392f, -0.05449640f, 0.06052320f, 
    -0.78137815f, -0.69107425f, -0.90901065f, 0.45391291f, 0.04119490f, -0.09091966f, -0.06364844f, 0.05662238f, 
    -0.04975439f, -0.07628417f, 0.01601750f, 0.08593448f, -0.92989808f, -0.18890616f, -0.12101009f, -0.15772697f, 
    0.10483082f, -0.07326591f, 0.08347597f, 0.06311443f, -0.27777058f, -0.05411527f, -0.01072245f, 0.10643467f, 
    0.68649828f, 0.54403919f, -0.38776886f, -0.39152598f, 0.31317851f, 0.13887477f, 0.10257024f, 0.20522927f, 
    -0.05670195f, -0.01052890f, 0.03188968f, 0.03767300f, -0.04036808f, -0.22479038f, 0.02341882f, 0.16018020f, 
    0.00066484f, -0.00826169f, 0.05171714f, 0.11656441f, -0.14472143f, -0.41826165f, -0.42409247f, -0.20673926f, 
    -0.43153685f, -0.23888479f, -0.18423055f, 0.08104713f, -0.07201760f, 0.01553073f, -0.07098468f, -0.02648198f, 
    -0.21869047f, -0.09509022f, -0.03527641f, -0.12314468f, 0.68903548f, 0.43599409f, -0.11962737f, -0.39207754f, 
    0.29684305f, 0.06472750f, 0.04218852f, 0.19534582f, -0.07186548f, -0.12311650f, -0.13967581f, -0.12502314f, 
    -0.12008251f, -0.15664251f, -0.06834257f, 0.09012940f, 0.15714674f, 0.02883037f, 0.14368632f, 0.12803371f, 
    -0.06615364f, 0.05727143f, 0.19506328f, -0.20713221f, 0.36623901f, 0.12659106f, -0.60525852f, -0.05290806f, 
    0.23556302f, 0.49244532f, 0.04633334f, -0.06634463f, -0.00018377f, -0.05882414f, -0.09743191f, 0.18325241f, 
    0.19543557f, 0.27306017f, 0.07094538f, -0.09344032f, -0.01720480f, 0.22412571f, -0.06795915f, -0.11652718f, 
    -0.08397696f, -0.22983159f, 0.03463612f, -0.07079108f, -0.37846294f, 0.00621353f, -0.08078734f, 0.12917386f, 
    0.04843630f, 0.10552302f, 0.05042051f, 0.07048577f, 0.00700146f, 0.00017236f, -0.04415114f, -0.00078030f, 
    -0.02289813f, 0.01389612f, -0.21796304f, -0.10511189f, -0.08417747f, -0.25518933f, 0.00623009f, -0.08307315f, 
    -0.07406592f, -0.07647205f, 0.16175169f, 0.02858752f, 0.01734369f, 0.00770297f, 0.11897583f, 0.07209596f, 
    0.19177713f, 0.25069878f, 0.10655215f, 0.40817994f, 0.07258014f, 0.05028915f, 0.12778924f, -0.04156828f, 
    -0.06821338f, -0.20838846f, -0.50752413f, 0.20901603f, -0.20856531f, -0.07211541f, 0.12573066f, 0.09610753f, 
    -0.15138175f, -0.39888844f, -0.49494278f, -0.07779838f, 0.01959516f, -0.10474329f, -0.10637869f, -0.15782315f, 
    0.10228053f, 0.33992919f, -0.39909616f, 0.04286806f, -0.16731088f, 0.13343894f, 0.06256556f, -0.17623167f, 
    0.14101048f, -0.17624743f, -0.11459341f, -0.13135219f, -0.08827845f, -0.02138106f, -0.03567376f, -0.18258765f, 
    -0.14284414f, 0.06392755f, -0.03156899f, -0.03523879f, 0.29939061f, 0.05958498f, -0.19225737f, -0.16156010f, 
    0.08641534f, 0.13743554f, -0.19699250f, -0.14122202f, 0.12699644f, -0.07237997f, -0.15247828f, -0.30200288f, 
    0.56233251f, -0.01791646f, -0.03309569f, -0.17552193f, -0.01571988f, -0.17348193f, -0.05516507f, 0.02449917f, 
    -0.11697131f, -0.01960031f, 0.20935205f, -0.03678136f, -0.12447836f, 0.30810007f, 0.20524129f, -0.04862714f, 
    -0.10251567f, -0.04834718f, -0.21017505f, 0.06345883f, -0.28933987f, -0.26942539f, -0.36148024f, -0.19373658f, 
    0.12620474f, 0.32056737f, 0.10955747f, 0.16026407f, -0.14292608f, 0.07954795f, -0.01783642f, -0.19418594f, 
    -0.00319691f, -0.04287725f, -0.10573214f, -0.04168703f, -0.40217528f, -0.14257100f, 0.31877571f, -0.13347097f, 
    0.03763826f, 0.00883789f, 0.08722278f, 0.09200989f, 0.21296193f, 0.15755142f, 0.15638424f, 0.03301594f, 
    0.37273785f, -0.13719237f, 0.27889088f, 0.05977167f, -0.02173611f, 0.08165906f, -0.12062837f, -0.05470944f, 
    0.00324206f, 0.00814191f, -0.00293542f, 0.10514615f, -0.24842702f, -0.18366484f, -0.16163813f, -0.26286936f, 
    -0.07442877f, -0.31758225f, 0.29262868f, -0.04407334f, 0.01581467f, 0.13412201f, 0.16924170f, 0.16799401f, 
    0.35673437f, -0.10767236f, 0.30770957f, 0.32311258f, -0.13246293f, -0.07696228f, -0.07015364f, -0.00655434f, 
    0.11013302f, -0.03122998f, -0.18020463f, 0.22560193f, 0.44722569f, 0.48620969f, 0.14642309f, -0.07274695f, 
    -0.33118871f, -0.01977531f, -0.09417174f, 0.02585589f, 0.03194538f, -0.02787263f, -0.42594534f, 0.03375845f, 
    -0.50420845f, -0.12799129f, -0.24451894f, 0.18960692f, -0.09209792f, 0.19651465f, 0.25162303f, 0.27742937f, 
    -0.20254247f, 0.17301640f, 0.09383561f, 0.08301398f, 0.08872063f, 0.06523120f, 0.23418614f, 0.21267565f, 
    -0.06398486f, -0.07537115f, 0.02768204f, -0.08442791f, -0.02875477f, 0.04479979f, -0.08362762f, 0.14099085f, 
    -0.11280397f, 0.34999290f, -0.35092595f, -0.03072693f, -0.06672616f, -0.65579408f, -0.08026288f, 0.20123658f, 
    0.09931970f, 0.12205239f, -0.07596469f, 0.02779030f, -0.57455391f, -0.38302192f, -0.24847129f, -0.41089755f, 
    0.27483979f, 0.16662511f, -0.12076047f, 0.16046411f, -0.06289853f, 0.04625968f, -0.09102285f, -0.05827842f, 
    0.25328317f, -0.21285664f, -0.25064719f, 0.07466590f, 0.01214064f, -0.14450923f, -0.05447167f, 0.04508150f, 
    0.09026612f, -0.11499994f, -0.07135490f, -0.12927422f, -0.08684926f, 0.16160214f, -0.03888672f, 0.50573492f, 
    0.01765684f, 0.07634953f, 0.16508357f, -0.17757352f, 0.15936321f, 0.12246906f, -0.11045315f, 0.16825317f, 
    -0.32008624f, -0.12434491f, 0.14353748f, -0.10351387f, -0.16986655f, -0.16562286f, -0.01253201f, 0.06728844f, 
    0.01215457f, -0.07502644f, -0.11355536f, 0.01519739f, 0.43136644f, 0.34816802f, 0.43763688f, 0.29797730f, 
    -0.10704219f, 0.10785817f, 0.19535466f, -0.10105666f, 0.01387619f, 0.09057809f, 0.01498057f, 0.07503119f, 
    0.10771202f, 0.16800109f, 0.57510871f, -0.85899150f, 0.11648509f, -0.05888034f, 0.11534600f, 0.17050846f, 
    0.13663483f, -0.00504625f, 0.11133052f, 0.01198338f, -0.25183362f, 0.06000716f, -0.27704394f, -0.05895077f, 
    -0.02087965f, 0.00251892f, -0.17629737f, 0.02821735f, 0.24366230f, 0.19612204f, 0.08360823f, 0.08119393f, 
    -0.72197932f, -0.75352824f, -0.21674719f, -0.10842340f, 0.01551150f, -0.16647029f, 0.13902783f, -0.05448039f, 
    -0.08700962f, 0.01360377f, -0.03968221f, -0.02009967f, -0.28314745f, 0.39534956f, -0.07763963f, 0.15871711f, 
    0.04101565f, 0.13863531f, 0.06360395f, -0.15772742f, -0.07369758f, -0.22388749f, 0.31970492f, 0.04680529f, 
    0.10866133f, -0.25346291f, -0.16435352f, 0.08544853f, 0.01985743f, 0.07277518f, 0.02127101f, 0.15488940f, 
    0.28498137f, -0.27117467f, -0.03078984f, 0.02342294f, -1.41026735f, -0.73559409f, -0.23628356f, -0.41097367f, 
    0.06000861f, -0.00349190f, -0.12121823f, -0.24690063f, -0.04301403f, -0.02834390f, -0.06164608f, 0.01020658f, 
    0.08949257f, -0.08809409f, -0.33087128f, 0.03205233f, -0.04284801f, -0.10492878f, 0.08847553f, 0.14208335f, 
    0.01113338f, -0.17635235f, -0.00229468f, -0.01612906f, 0.08829280f, 1.00240159f, 1.02179337f, 0.20211668f, 
    -0.03777513f, -0.28160238f, 0.25762191f, -0.05859882f, 0.06651716f, -0.06463595f, -0.11184155f, -0.12146910f, 
    0.08657590f, 0.04274521f, -0.17286499f, 0.04999106f, 0.11190116f, -0.20987934f, 0.02360522f, -0.08042655f, 
    -0.02821304f, 0.07967541f, -0.08376698f, -0.04307068f, -0.33056372f, -0.59698403f, 0.21631700f, 0.18700604f, 
    -0.02030717f, 0.04386801f, 0.03582067f, 0.07754944f, 0.00935136f, 0.04366972f, -0.20154032f, 0.13945252f, 
    0.07617100f, -0.04668714f, -0.18679819f, 0.59423959f, 0.11512724f, 0.07167433f, -0.02410650f, 0.31754470f, 
    -0.02184601f, -0.30045006f, -0.06465086f, 0.02315381f, 0.03867831f, -0.09491187f, 0.04236940f, -0.00937089f, 
    -0.10018712f, 0.06342003f, -0.05532402f, -0.24345390f, 0.05958038f, -0.10544149f, -0.04604561f, 0.00760551f, 
    -0.23052879f, 0.59611583f, -0.45281392f, -0.49737665f, 0.03281570f, 0.01005763f, -0.00246275f, 0.11341925f, 
    -0.16567837f, -0.02321630f, -0.24119776f, 0.25551242f, 0.44749430f, -0.22583543f, -0.25850996f, 0.23219389f, 
    -0.07138526f, -0.00422003f, -0.08494033f, -0.26620576f, -0.04767333f, -0.11095482f, -0.32387051f, 0.17382409f, 
    0.05875085f, -0.37770876f, 0.70048386f, 0.07303050f, -0.02239523f, 0.07006344f, -0.13324554f, 0.09312654f, 
    0.11156659f, -0.10192499f, 0.15756978f, -0.39440903f, 0.87597704f, -0.36017108f, 0.01249909f, 0.15620568f, 
    0.49707556f, 0.00734020f, 0.20403309f, -0.11525899f, -0.28989211f, 0.03610212f, 0.13837254f, 0.14443484f, 
    -0.23119374f, -0.08833259f, 0.84801900f, -0.12414433f, -0.31584799f, 0.19546053f, -0.13049877f, -0.03141793f, 
    0.17043804f, 0.06590304f, -0.09386705f, -0.07950530f, -0.03562156f, -0.25101390f, 0.49430302f, -0.24714781f, 
    -0.22089341f, 0.13211124f, 0.12727618f, 0.36100644f, 0.14957815f, 0.17182784f, 0.18930157f, -0.01020409f, 
    -0.13867775f, -0.40329909f, -0.20420514f, 0.30317360f, 0.17835228f, 0.07054936f, -0.06339716f, -0.25436082f, 
    -0.15311129f, 0.21863092f, -0.17897326f, 0.04938191f, -0.13424964f, -0.06800608f, -0.03952756f, 0.03320238f, 
    -0.16505189f, 0.24117979f, -0.27138236f, -0.11518358f, -0.20140733f, -0.09062775f, -0.34373790f, 0.11188623f, 
    -0.28209051f, -0.13553663f, -0.24505705f, -0.17453521f, -0.07380755f, -0.07572481f, -0.37505019f, -0.03370715f, 
    -0.00929391f, -0.01705423f, -0.02409538f, -0.06900055f, -0.04202168f, -0.40188879f, -0.26256153f, 0.51233768f, 
    0.03247524f, 0.03610794f, -0.04630965f, 0.28385884f, -0.14051224f, -0.09832250f, -0.14579812f, -0.14033151f, 
    -0.40302241f, -0.06182598f, 0.19704421f, -0.04216566f, 0.50147641f, 0.36321965f, 0.19645426f, 0.22610018f, 
    -0.30022261f, 0.15550441f, 0.02988101f, 0.01174585f, 0.35013115f, -0.36129111f, -0.20058896f, 0.66556096f, 
    0.24521430f, 0.00239025f, -0.05634570f, 0.00540281f, -0.05944711f, 0.14571419f, 0.19385469f, 0.24600761f, 
    0.19677159f, -0.35522532f, -0.33804259f, -0.40251639f, 0.17934310f, 0.23786090f, 0.07680137f, 0.04293294f, 
    0.24653551f, -0.11045342f, 0.06182317f, 0.00187539f, -0.61390984f, -0.25008121f, 0.08109728f, -0.28725654f, 
    -0.72168171f, -0.39470097f, -0.17063716f, -0.15487172f, -0.02628861f, 0.12074387f, 0.03241134f, -0.01449892f, 
    -0.10300194f, -0.22650911f, 0.28391346f, 0.16087668f, 0.28845885f, 0.15195313f, -0.01995415f, 0.04660355f, 
    0.12357346f, -0.01133447f, -0.17967089f, -0.03853375f, 0.21555030f, 0.04711549f, 0.14867476f, 0.10558352f, 
    0.11191953f, -0.07509618f, -0.07750683f, -0.24386406f, -0.33005366f, -0.16320580f, -0.22635633f, -0.07000896f, 
    0.12205888f, -0.32519895f, 0.29900515f, 0.39567581f, -0.00895841f, -0.06860709f, -0.06806479f, -0.16344069f, 
    0.06073247f, 0.27626804f, 0.28695861f, 0.36263913f, -0.64158046f, 0.06987858f, -0.23669490f, -0.18544897f, 
    -0.28164649f, -0.22373599f, -0.18915920f, -0.08155785f, -0.07961233f, -0.17232063f, -0.06044011f, -0.00001522f, 
    0.04305534f, 0.08356189f, -0.04564368f, 0.15307319f, -0.02712358f, 0.19853391f, -0.30021140f, 0.16518058f, 
    0.00447499f, -0.18024038f, -0.24657582f, -0.16168383f, -0.17567390f, 0.12955923f, 0.13765807f, 0.03272393f, 
    -0.16854095f, -0.23868062f, 0.19380572f, 0.05231632f, -0.02726057f, -0.00604293f, 0.10330035f, 0.20793208f, 
    0.41641504f, -0.14442378f, -0.80284381f, 0.50135279f, 0.19801129f, -0.04956276f, -0.00518698f, -0.15340838f, 
    0.13879207f, -0.00351344f, -0.03450938f, 0.04703007f, 0.50220072f, -0.52514482f, -0.28789845f, -0.24355856f, 
    0.02330323f, -0.08216327f, 0.15956978f, -0.09738328f, 0.33351362f, -0.11093263f, 0.36945021f, 0.02328424f, 
    -0.04686471f, 0.02474967f, 0.26251405f, 0.26299080f, -0.23085786f, -0.13039193f, -0.01497691f, -0.06422830f, 
    0.02244026f, -0.00500051f, 0.03167552f, 0.01605981f, -0.10721175f, 0.02002810f, -0.08388125f, 0.18334655f, 
    0.08768839f, 0.02827097f, 0.06177152f, -0.03590838f, -0.19105525f, -0.24937378f, -0.13622841f, 0.03599104f, 
    -0.03672353f, -0.12411795f, -0.13262957f, -0.43430087f, -0.00216036f, -0.13055015f, 0.06148707f, 0.10474142f, 
    0.01069524f, -0.04856548f, -0.31574124f, -0.37267557f, 0.09878004f, 0.42148095f, 0.48408103f, 0.23264048f, 
    -0.03596397f, 0.16516502f, 0.02284539f, 0.17461285f, 0.08109605f, -0.05662340f, 0.02556590f, -0.00544223f, 
    0.18782753f, 0.10380522f, -0.16014938f, -0.18385540f, 0.18034589f, 0.10661090f, 0.09465675f, -0.02589652f, 
    0.08154203f, 0.00521604f, -0.06548093f, -0.24415909f, -0.40971732f, -0.14021428f, 0.26617014f, -0.10510337f, 
    -0.05742513f, -0.28528029f, -0.16511945f, -0.05747394f, -0.01735642f, -0.05227315f, 0.20031968f, -0.05071094f, 
    0.07602059f, -0.12382052f, 0.17408267f, -0.11521549f, 0.03114636f, -0.16343020f, -0.24058875f, -0.23635000f, 
    0.24522662f, -0.01842536f, -0.10850030f, 0.05506013f, -0.12803265f, -0.00370486f, -0.12305637f, -0.05059868f, 
    0.08539468f, 0.07336426f, 0.12123757f, 0.14335835f, 0.01963347f, -0.01497844f, 0.12272879f, 0.02513031f, 
    0.33632204f, -0.25739986f, -0.12314977f, 0.21310936f, -0.01080339f, 0.08641917f, -0.11682213f, 0.00979905f, 
    -0.24439074f, -0.03842188f, -0.12536119f, 0.00909699f, 0.00390843f, 0.10243705f, 0.26245186f, -0.21595719f, 
    -0.17576778f, -0.01684993f, 0.28829238f, 0.21649279f, 0.18958794f, 0.10244975f, 0.00558290f, 0.12175697f, 
    -0.24485359f, -0.00852346f, 0.40541765f, -0.29046783f, 0.13007346f, -0.16824114f, -0.02702442f, 0.13075978f, 
    0.12163685f, -0.32403532f, -0.00331097f, -0.11161133f, 0.09016042f, -0.21726801f, 0.14958781f, 0.00592337f, 
    0.16950174f, -0.27644658f, 0.08424744f, 0.29346657f, 0.05890786f, -0.08080423f, 0.15472333f, -0.03294122f, 
    -0.13773197f, 0.10099384f, -0.29167366f, 0.10690888f, 0.16246690f, 0.07177710f, 0.23303877f, -0.16716811f, 
    0.15159465f, -0.01347545f, 0.14565179f, 0.20993473f, -0.94831282f, -0.09028676f, -0.47126135f, -0.16566376f, 
    0.00635468f, 0.02841603f, -0.11064864f, 0.13533603f, 0.20904185f, -0.15063658f, -0.07566214f, -0.15001687f, 
    -0.33397543f, 0.02470045f, -0.45820266f, 0.06655604f, 0.12678507f, -0.03893087f, 0.06663758f, 0.19995210f, 
    -0.08918960f, -0.08866743f, -0.21251760f, -0.21597308f, 0.26543936f, -0.49363828f, -0.34898967f, -0.02432291f, 
    0.02221529f, 0.13941303f, 0.13741159f, 0.12548748f, -0.17359535f, -0.30036899f, -0.36715445f, -0.04682014f, 
    -0.14131355f, 0.19175583f, 0.36410579f, -0.20059676f, 0.26780853f, 0.13824154f, 0.00965346f, 0.30617228f, 
    -0.06206821f, -0.03505073f, 0.11666752f, 0.13068594f, 0.55326271f, -0.20034836f, -0.38921648f, 0.02603669f, 
    -0.12379953f, -0.14676711f, -0.30571100f, -0.07458901f, 0.15529233f, 0.02727360f, 0.04175712f, -0.11398456f, 
    -0.20551628f, -0.13186842f, -0.69201493f, 0.47266540f, 0.25064826f, -0.24213244f, 0.15477735f, -0.01045399f, 
    0.07091115f, 0.05280213f, 0.13564058f, 0.57710117f, 0.05263663f, 0.37756851f, 0.31110597f, -0.26021066f, 
    0.27083820f, 0.19398583f, -0.08300254f, -0.33776122f, -0.02362619f, -0.00948562f, -0.02194990f, -0.01297138f, 
    -0.06085994f, -0.04415134f, -0.28479895f, 0.11385456f, 0.02077457f, -0.10640130f, -0.14364414f, -0.22408764f, 
    0.03984804f, -0.13898937f, 0.21218169f, -0.16693604f, -0.21206719f, 0.30263132f, -0.17896014f, -0.57611334f, 
    0.02218009f, -0.04478424f, 0.06467435f, -0.05461186f, -0.00510544f, -0.12410428f, 0.19065829f, -0.16021419f, 
    0.07091217f, 0.05699411f, -0.09299243f, 0.01522991f, 0.04457928f, -0.24251099f, 0.10755115f, -0.12861717f, 
    0.23329081f, 0.16917773f, -0.01801074f, -0.10510390f, -0.27089018f, -0.06781660f, -0.10598473f, 0.26307070f, 
    0.11359931f, -0.14601539f, -0.06715602f, 0.01089221f, 0.03387890f, 0.02709087f, 0.07282414f, 0.04470802f, 
    -0.18113743f, -0.49688718f, -0.06614553f, 0.23612353f, 0.18350716f, 0.29943350f, 0.22053736f, -0.18803553f, 
    -0.02043326f, -0.20651713f, 0.14012563f, 0.00465949f, -1.12416255f, -0.88556880f, 0.14752893f, 0.27571639f, 
    -0.27168074f, 0.03661856f, -0.21597016f, -0.31009805f, -0.06044071f, -0.22085671f, 0.06603398f, -0.11030370f, 
    -0.33908719f, -0.09144199f, 0.52607602f, -0.20843637f, 0.03089059f, 0.06172461f, -0.02172130f, 0.16226381f, 
    0.22249117f, 0.14077193f, 0.32246783f, -0.13347806f, 1.07227755f, 0.40070805f, -0.22422278f, 0.76648659f, 
    -0.05119992f, 0.16206981f, 0.13879648f, 0.39380312f, 0.10699088f, -0.16741346f, 0.21411075f, 0.17239898f, 
    0.19703181f, -0.21138144f, -0.09957518f, -0.12830311f, -0.03000254f, 0.01709294f, 0.42561108f, -0.04823849f, 
    0.06473427f, -0.20676628f, -0.06577286f, 0.00755515f, -0.53160465f, 0.33674192f, 0.49311069f, 0.17544056f, 
    -0.17061856f, 0.07298450f, 0.08790950f, 0.06688969f, -0.23382619f, -0.07485072f, 0.23467298f, 0.30522907f, 
    -0.13901734f, -0.23056526f, -0.02299400f, -0.21074246f, 0.15320598f, 0.32271135f, 0.00768332f, -0.14242649f, 
    0.02990294f, 0.08416041f, 0.15278241f, 0.09205531f, 0.23708844f, 0.19653223f, -0.01171786f, -0.16490683f, 
    0.11273611f, -0.04892713f, 0.04849708f, -0.05733344f, 0.54073662f, 0.45745066f, 0.28351119f, 0.05135677f, 
    -1.32038736f, -1.04096949f, -0.19844483f, -0.08502174f, -0.33907264f, -0.01258254f, 0.07145210f, -0.45696670f, 
    -0.02586197f, 0.03408178f, -0.09292804f, -0.08776765f, 0.60409182f, 0.45829457f, -0.12485893f, 0.22199897f, 
    -0.07952348f, 0.05266739f, -0.01809340f, 0.16248456f, 0.27600649f, 0.21416293f, -0.01783036f, -0.20109092f, 
    0.29221675f, -0.01961239f, -0.09921037f, -0.09080599f, 0.03990689f, 0.04239286f, 0.16187257f, -0.13229384f, 
    0.04929676f, 0.07884175f, -0.11997344f, -0.35310945f, -1.69796896f, -1.97409356f, -0.33219925f, -0.05427350f, 
    -0.03643513f, 0.04347078f, -0.31917202f, -0.36767864f, -0.13276625f, -0.09533183f, -0.07385035f, -0.01645245f, 
    -0.15456718f, 0.07851082f, -0.00929311f, -0.12498973f, 0.13639534f, 0.00404124f, -0.10808858f, 0.01968653f, 
    0.12850060f, -0.12602808f, -0.38504148f, -0.00841473f, -1.24306548f, -0.53293544f, 0.22077075f, 0.27637008f, 
    0.00395172f, -0.09825558f, -0.31088367f, -0.04218395f, 0.05337171f, 0.10958361f, 0.00435404f, -0.10117338f, 
    -0.81063861f, 0.23813494f, 0.66608888f, 0.00755504f, -0.59093857f, -0.00206251f, -0.21946761f, -0.35831639f, 
    -0.29289049f, -0.17583494f, 0.02349132f, -0.08312556f, 0.02627340f, -0.09095056f, -0.31125054f, -0.07834825f, 
    -0.08402471f, 0.00910856f, 0.21086656f, 0.09670281f, -0.01669365f, 0.02427056f, -0.02224729f, -0.26879123f, 
    -0.05549506f, 0.13144763f, 0.11138050f, -0.15973888f, -0.08040220f, 0.01736554f, 0.07600727f, 0.01127794f, 
    0.10215974f, 0.12706563f, -0.04653206f, -0.12854642f, -0.11002544f, -0.69181114f, 0.70276541f, -0.27629834f, 
    -0.17512970f, -0.17166293f, -0.27616102f, 0.16499698f, 0.05431593f, 0.10751625f, 0.02770175f, 0.01780024f, 
    0.57724136f, 0.04748467f, -0.25383577f, -0.30491111f, 0.09648738f, 0.19163428f, 0.07228287f, -0.02997885f, 
    0.28779495f, 0.21754955f, 0.03107038f, -0.16914041f, -0.90534896f, 0.21609959f, -0.30612344f, 0.14404914f, 
    -0.11334947f, 0.10208262f, 0.08593252f, -0.45068341f, -0.08625244f, 0.05361661f, 0.00105344f, -0.29493499f, 
    -0.28666744f, 0.26389140f, 0.06901654f, -0.07275603f, -0.19393960f, -0.02851455f, 0.06631321f, 0.09722625f, 
    -0.09194807f, -0.05540840f, 0.10373148f, -0.00934598f, 0.75663984f, -0.89123940f, -0.46049830f, -0.05797215f, 
    -0.03084708f, -0.15871364f, -0.19470936f, 0.10577784f, 0.11514397f, 0.04419921f, 0.00196105f, 0.02468446f, 
    -0.09203446f, 0.40727106f, -0.28936857f, -0.11862080f, -0.02392134f, -0.07828812f, -0.16820410f, 0.00610099f, 
    0.13017000f, 0.13491294f, 0.10979754f, 0.05558023f, 0.24450547f, 0.32099771f, 0.26131350f, 0.04094472f, 
    0.09343240f, 0.01503569f, -0.05352737f, -0.11227191f, -0.05934592f, 0.04859507f, -0.09306883f, -0.08349018f, 
    0.04877814f, -1.23438358f, 0.18138413f, -0.27653366f, 0.30305484f, -0.00347107f, -0.14519669f, 0.39935315f, 
    0.08805649f, -0.05942309f, -0.06784993f, -0.04493681f, 0.13010675f, -0.03238299f, -0.02308810f, -0.14868020f, 
    -0.03074314f, 0.04049571f, -0.02882377f, -0.16543148f, -0.24253820f, -0.16444588f, 0.14869855f, -0.20507737f, 
    -0.01506215f, 0.20514283f, -0.04912313f, 0.10112993f, 0.06052739f, -0.02893906f, -0.00549192f, -0.19160055f, 
    -0.05068982f, 0.12076014f, -0.16278306f, -0.12770918f, -1.11926925f, -0.15813383f, 0.68242776f, 0.71330065f, 
    -0.00901626f, -0.42996684f, 0.04689499f, 0.24882042f, -0.03869886f, -0.11367856f, -0.10531544f, -0.07568223f, 
    0.14188652f, 0.32511270f, -0.00788225f, -0.07679702f, 0.00580543f, 0.03672457f, 0.12287335f, 0.03223698f, 
    0.02467329f, -0.02545494f, -0.12263992f, -0.31590366f, -1.26813436f, 0.36735451f, -1.44856644f, -0.05463982f, 
    0.24721050f, -0.48144144f, 0.60382879f, 0.00804139f, -0.05274720f, -0.11234179f, 0.02645860f, 0.01089084f, 
    0.64910048f, 0.22014506f, 0.03117819f, -0.00033852f, 0.31792229f, -0.05332470f, -0.01866374f, -0.11562333f, 
    -0.07251051f, -0.00944364f, 0.10954023f, 0.02583899f, 0.05383744f, -0.14971745f, 0.10905639f, -0.28775120f, 
    -0.08050084f, 0.02816607f, -0.15272160f, -0.06420703f, 0.15667579f, 0.00550868f, 0.10543580f, -0.06060898f, 
    -0.02865372f, -0.01412815f, 0.24009290f, -0.50766426f, -0.30828404f, -0.15722518f, -0.15918300f, -0.15824167f, 
    -0.06465369f, 0.17470357f, 0.07191944f, 0.07873801f, 0.48839897f, -0.46331385f, -0.03294779f, -0.10210104f, 
    -0.04102001f, -0.01360070f, -0.06671938f, 0.11952241f, 0.12382330f, 0.16364321f, 0.12034412f, 0.24747036f, 
    0.31602630f, -0.13911606f, -0.73969686f, -0.59037888f, 0.02131314f, -0.15235610f, -0.08487391f, -0.06531808f, 
    -0.03576713f, -0.10550728f, 0.04509320f, -0.38568416f, -0.04968210f, -0.41883630f, 0.35733926f, 0.49360248f, 
    0.22220626f, 0.44000924f, 0.20538147f, 0.03700438f, -0.10296693f, 0.06946195f, 0.25817540f, -0.13144195f, 
    -0.53748780f, 0.23022650f, 0.34265563f, 0.21668224f, 0.22406735f, -0.04254032f, -0.02231510f, 0.07342336f, 
    0.16035414f, 0.13121276f, 0.28984302f, 0.12499341f, -0.23662399f, -0.63826925f, -0.32086405f, 0.13399445f, 
    -0.01110083f, 0.26954007f, 0.06501415f, 0.30292240f, -0.04889458f, 0.06089926f, -0.13943917f, -0.57843846f, 
    -0.36328548f, 0.31058410f, 0.37929779f, 0.16088939f, -0.19401719f, -0.07240786f, -0.38779041f, 0.00015529f, 
    -0.32773665f, -0.07684597f, -0.25305212f, -0.07023249f, -0.49091575f, 0.33579960f, -0.05247305f, 0.14633155f, 
    -0.01572222f, -0.25765029f, -0.16333073f, -0.05492916f, -0.16566084f, 0.09242739f, -0.46508479f, -0.31781000f, 
    0.26057225f, -0.11287617f, -1.03490233f, 0.08400539f, 0.22985768f, -0.05816502f, 0.25219125f, -0.32722420f, 
    -0.00684424f, -0.07884481f, -0.11827199f, 0.02713677f, -0.47404695f, 0.47500578f, -0.03577646f, -0.05899771f, 
    0.32624140f, 0.18001635f, 0.02632393f, 0.07430814f, 0.01662408f, 0.18579306f, 0.03652959f, 0.35865894f, 
    -0.14872898f, 0.48127037f, 0.04920405f, 0.09123753f, 0.05801327f, -0.00434557f, -0.02254728f, 0.01501928f, 
    -0.10022046f, 0.05985351f, 0.00905281f, 0.09666399f, 0.03231892f, -1.06622815f, -0.23239756f, -0.08778170f, 
    -0.00556544f, -0.20053583f, -0.09571534f, -0.06510107f, 0.19799756f, 0.06414308f, -0.07622267f, 0.10923547f, 
    -0.45623058f, -0.05506270f, 0.11442097f, -0.34498283f, -0.29921603f, -0.08610787f, -0.00131925f, -0.18551134f, 
    -0.06172957f, 0.15264682f, 0.02837799f, 0.25314015f, 0.31497329f, -1.74144542f, -0.45717058f, 0.47417438f, 
    -0.30575126f, 0.35914862f, -0.02429873f, 0.11836521f, -0.04517555f, 0.11437351f, 0.03733740f, -0.03970004f, 
    0.21172866f, -0.34494245f, -0.34900942f, -0.11554861f, -0.11077737f, -0.21048659f, 0.04872441f, 0.10182619f, 
    -0.05292400f, 0.09761186f, -0.04776690f, 0.05246456f, 0.02764511f, 0.41809130f, 0.25715563f, -0.31006315f, 
    0.08994149f, -0.08661856f, -0.01556999f, 0.00256943f, -0.11031389f, -0.10014678f, 0.01953119f, 0.05444773f, 
    0.18129914f, -0.29827893f, 0.28208807f, -0.10042387f, 0.27380604f, 0.32156733f, -0.13742425f, -0.16587605f, 
    0.04861733f, -0.07116259f, -0.19318701f, -0.01010235f, 0.50483143f, -1.24248791f, 0.25844312f, -0.19020706f, 
    0.03568973f, -0.15085168f, -0.59091425f, -0.09041245f, -0.10614418f, -0.27077034f, 0.00441564f, -0.26474780f, 
    -0.17181593f, -0.32522064f, 0.09418169f, 0.83823746f, 0.02076318f, 0.03901067f, -0.23525780f, 0.01047652f, 
    0.10063478f, 0.29796371f, 0.09690404f, -0.14826003f, -0.30530420f, 0.26934773f, 0.17948391f, -1.02863157f, 
    -0.24263828f, -0.19584249f, 0.10363367f, -0.35337222f, 0.07513949f, 0.12125551f, 0.29340228f, 0.10136914f, 
    0.11829856f, 0.01405144f, -0.69093317f, -0.02316571f, 0.13025382f, -0.12847659f, 0.23324950f, 0.14172000f, 
    -0.28734747f, -0.15620779f, -0.20896700f, -0.25434369f, -0.18656358f, 0.41607097f, 0.18699157f, 0.61849684f, 
    -0.08897559f, -0.29572606f, -0.22239536f, -0.18250212f, 0.03035053f, -0.09902410f, 0.11986000f, 0.00693440f, 
    -0.13945240f, 0.09872437f, -0.23251088f, -0.08744437f, 0.07459367f, 0.14781848f, 0.20794898f, -0.18868777f, 
    0.06579266f, 0.07066918f, -0.04953820f, 0.35891265f, 0.03254205f, -0.23236124f, -0.09645435f, 0.05478976f, 
    0.05989773f, 0.17003284f, 0.09079769f, -0.00198114f, 0.12907913f, 0.10263398f, 0.27723181f, 0.14694373f, 
    -0.91850162f, -0.01866925f, 0.29236740f, -0.19580974f, -0.50554174f, -0.01305430f, -0.01238078f, 0.31687713f, 
    0.11203675f, -0.08033404f, 0.10107309f, -0.03450999f, 0.13772494f, 0.25489017f, 0.20986755f, -0.11251681f, 
    0.01399380f, -0.20318018f, 0.15503913f, -0.23136766f, -0.00803019f, 0.08306524f, -0.26793626f, -0.07014294f, 
    -0.66672206f, 0.13163087f, -0.34146780f, 0.01893614f, 0.24609067f, 0.23856169f, -0.00253535f, 0.23657712f, 
    0.14104335f, 0.07062314f, -0.19791985f, -0.06822184f, 0.00156159f, -0.40234020f, 0.05648135f, -0.25954309f, 
    -0.12079825f, 0.10354937f, 0.17737062f, 0.38428152f, -0.01113996f, 0.16211231f, 0.02708858f, -0.18675096f, 
    -0.24962901f, -0.26709950f, 0.63110900f, 0.11183824f, 0.12752567f, -0.00592053f, -0.17630643f, 0.12701283f, 
    0.00376314f, 0.17530037f, 0.02671608f, 0.06953438f, -0.14032726f, 0.01783315f, 0.47850844f, -1.12240875f, 
    0.06478006f, -0.11153807f, 0.22410250f, -0.00412135f, -0.09470298f, 0.14918911f, 0.15201031f, -0.08081517f, 
    0.08635066f, 0.29075518f, 0.21957284f, 0.59959638f, 0.22666864f, -0.30053031f, -0.20588671f, 0.07173356f, 
    0.25913328f, -0.40822110f, 0.00296521f, 0.03902166f, -0.08583894f, -0.26602367f, -0.79910827f, 0.20414202f, 
    0.04226749f, 0.37093580f, 0.05804893f, -0.21080519f, 0.06820186f, -0.23549087f, -0.00455315f, 0.01164926f, 
    -0.01638600f, -0.21971144f, 0.13264452f, -0.17357311f, -0.16977151f, 0.36254025f, 0.14238155f, -0.09080712f, 
    0.13751771f, 0.20243776f, 0.17196161f, 0.03279720f, -0.48042655f, 0.58378130f, -0.05781858f, 0.44311911f, 
    -0.07964239f, -0.03755953f, 0.08480652f, -0.13758832f, 0.05456892f, 0.16483401f, 0.02952046f, 0.30902955f, 
    -0.34626558f, 0.85791618f, 0.17274249f, -0.09082960f, -0.04803144f, 0.03878724f, 0.06638394f, 0.06772932f, 
    -0.40472347f, -0.45114657f, -0.79268992f, -0.16078186f, 0.11233053f, 0.40072596f, 0.36832705f, 0.10266858f, 
    -0.01662607f, -0.20167105f, 0.07769655f, 0.08569471f, 0.15781078f, 0.26299673f, -0.10228790f, -0.27209699f, 
    0.19408347f, -0.18791303f, -0.33731741f, 0.14820793f, -0.12956499f, 0.13194349f, 0.24382190f, -0.22509944f, 
    -0.00905329f, 0.29121628f, -0.15207347f, 0.14119713f, 0.58619291f, -0.34251410f, 0.51753718f, -0.36850962f, 
    0.02463632f, -0.21579245f, -0.14510134f, 0.05799017f, -0.19694637f, 0.12493327f, -0.30939457f, -0.64874727f, 
    0.23546045f, -0.25177643f, -0.06109005f, 0.40228280f, -0.09810333f, -0.39193985f, -0.11186438f, 0.13477732f, 
    0.02827200f, -0.01666098f, -0.57248354f, 0.04444215f, 0.11412209f, 0.02783061f, -0.07815082f, 0.29014349f, 
    -0.11828370f, 0.29463753f, 0.02025791f, -0.24861588f, -0.23112257f, -0.30104238f, -0.54578561f, -0.08358974f, 
    -0.24290146f, -0.81152040f, 0.33501989f, 0.03757820f, -0.13377792f, 0.31340608f, -0.13492453f, 0.23666473f, 
    -0.25569984f, -0.10370089f, 0.27109382f, 0.06913245f, -0.01643404f, 0.28953966f, -0.25240594f, -0.30829775f, 
    -0.47967592f, -0.28654599f, 0.36070627f, -0.09823045f, 0.05535874f, -0.04366877f, 0.15640818f, 0.24073546f, 
    0.17214958f, -0.27168730f, 0.74908257f, -0.18716510f, -0.20456937f, -0.13040587f, 0.47350645f, 0.34977415f, 
    0.08307504f, -0.30823380f, 0.11550619f, 0.06520114f, -0.36600181f, 0.04450550f, -0.91262704f, 0.29237255f, 
    -0.15536530f, -0.00440777f, -0.12246680f, -0.20034650f, 0.08294971f, 0.06547785f, -0.05597981f, -0.09850441f, 
    -0.10540120f, -0.34852818f, 0.00835059f, -0.48541388f, -0.13822538f, -0.24108981f, 0.03422554f, -0.14207755f, 
    0.15783623f, 0.08172520f, 0.10611270f, 0.09802856f, 0.31293884f, -1.22438455f, 0.32062367f, 0.04126827f, 
    -0.16402502f, 0.05480247f, 0.04517643f, 0.17233451f, 0.05826876f, -0.18943933f, -0.28760919f, -0.21154998f, 
    -0.09500067f, 0.19723125f, 0.15196978f, 0.32449207f, -0.27348131f, 0.16576831f, 0.13554981f, 0.48112273f, 
    -0.21514493f, 0.22296610f, 0.03599142f, 0.33996215f, -0.22393888f, 0.01160695f, -0.69386649f, -0.64159727f, 
    -0.14610317f, -0.23821856f, 0.24209797f, -0.25360000f, -0.16715759f, 0.15147604f, 0.24086656f, 0.06898818f, 
    0.15514666f, 0.75266808f, -0.20270185f, -0.19797772f, -0.06107947f, -0.28397599f, -0.03051594f, -0.04230663f, 
    0.14148840f, -0.15701793f, 0.05818623f, 0.15385245f, -0.54761088f, 0.76280397f, -0.70662212f, 0.29475054f, 
    -0.24303898f, -0.09631582f, 0.28400493f, -0.36607993f, -0.04971353f, -0.18912521f, 0.09740993f, -0.26422632f, 
    -0.45655581f, -0.00861144f, -0.55327570f, 0.07279016f, 0.22926873f, 0.19289032f, -0.11401968f, -0.09780240f, 
    0.00914268f, 0.14331725f, 0.32497326f, 0.14742562f, 0.32347918f, -0.15985642f, 0.69915628f, -0.56708115f, 
    -0.01889217f, 0.00804374f, 0.21779197f, -0.02576737f, 0.08035131f, 0.09849267f, -0.08856859f, 0.09761678f, 
    0.64330006f, -0.10379586f, 0.55717117f, 0.19263537f, 0.00060946f, 0.10457354f, -0.21176128f, 0.06105645f, 
    -0.02111963f, -0.32932469f, -0.01537536f, -0.13867246f, -0.53946519f, 0.08348984f, -0.36047998f, -0.43163273f, 
    -0.08306215f, -0.07564418f, 0.04225557f, -0.10943305f, 0.00505763f, 0.09833967f, 0.01316369f, -0.01741282f, 
    0.23663509f, -0.12978856f, 0.46675593f, -0.10868139f, -0.12502958f, 0.09518360f, 0.14534968f, -0.17323706f, 
    -0.13516761f, -0.06311009f, 0.26793739f, 0.06537782f, -0.12579231f, -0.11116342f, 0.01714511f, 0.33268705f, 
    0.04008792f, -0.13912347f, 0.20961186f, -0.12492320f, -0.06633403f, 0.28164300f, 0.24339904f, 0.18151249f, 
    -0.04700536f, 0.05251222f, -0.16558212f, 0.01973493f, 0.00237856f, -0.26875481f, 0.08019880f, -0.32381251f, 
    0.00957018f, 0.03367577f, -0.24850607f, -0.31147420f, 0.39455718f, -0.80356348f, 0.48007968f, 0.13424331f, 
    -0.02386867f, 0.09474035f, -0.10198083f, 0.19283342f, -0.23404068f, 0.02156611f, 0.22047092f, -0.08304974f, 
    -0.09018517f, 0.13408899f, 0.64324343f, -0.46101955f, -0.31441516f, 0.29247791f, -0.10607479f, 0.09481476f, 
    -0.25188372f, 0.22294548f, 0.41381434f, -0.10881718f, -0.41603321f, -0.69572020f, -0.18814102f, 0.08028823f, 
    -0.46497026f, -0.20415977f, -0.02887137f, -0.12419464f, 0.11830997f, 0.06467921f, 0.03439045f, 0.03622476f, 
    -0.40530208f, 0.23680942f, -0.56961787f, -0.23086193f, 0.01953263f, 0.19497141f, 0.07308159f, 0.14736845f, 
    -0.27435505f, -0.00909634f, -0.03028649f, -0.20078225f, -0.51222450f, 0.30389282f, 0.22024068f, -0.10825813f, 
    -0.09929467f, 0.34987861f, -0.08179588f, 0.10921454f, 0.12949225f, 0.20334935f, 0.10894177f, 0.04490149f, 
    -0.05066808f, -0.35080397f, 0.36625534f, -0.18645328f, -0.05375441f, 0.27227405f, -0.13238537f, 0.13032582f, 
    -0.02460503f, -0.10831866f, -0.16454764f, -0.39167923f, 0.84353209f, 0.44896698f, -0.00257683f, -0.02214262f, 
    -0.13151847f, 0.12025638f, -0.19219109f, 0.19846751f, -0.22287352f, 0.02998534f, -0.32924196f, -0.16973865f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38547623f, 0.16438858f, 0.07104445f, -0.21182226f, -0.14659701f, 0.20317037f, 0.07670408f, -0.24024859f, 
    0.21794485f, 0.05420339f, 0.02427094f, -0.00210050f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
