#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06226229f, 0.44045642f, 0.65480542f, -0.74410439f, -0.60577399f, 0.12598112f, 0.34700736f, -0.21143274f, 
    -0.28037679f, 0.16696392f, -0.03725709f, -0.29778114f, 0.13646513f, 0.04471980f, 0.02381229f, -0.17004900f, 
    -0.20348683f, 0.23542523f, 0.16793875f, 0.35960558f, 0.24563164f, 0.16254361f, 0.15802717f, -0.37875265f, 
    -0.14546001f, 0.23894206f, 0.15947104f, 0.09811602f, -0.53170121f, -0.15243828f, 0.24770299f, 0.23827603f, 
    -0.26408604f, 0.01422559f, -0.08744249f, 0.29607186f, -0.34266770f, -0.05348762f, -0.03968924f, 0.02105288f, 
    0.11784384f, -0.29637554f, -0.21006130f, 0.15667887f, 0.07992820f, -0.27845481f, 0.16599745f, 0.16169205f, 
    -0.34784302f, -0.31888804f, -1.30727303f, -0.70769215f, 0.49203700f, -0.22210594f, -0.34283543f, 0.84146422f, 
    0.56197065f, -0.27550912f, -0.39000228f, -0.10140802f, 0.07640962f, -0.05412981f, -0.02922284f, 0.49966007f, 
    -0.48425573f, 0.10034000f, -0.00028443f, -0.38081649f, -0.21376690f, -0.00749908f, 0.12238402f, -0.03721038f, 
    -0.09935626f, -0.06253514f, -0.09983590f, 0.18985985f, -0.12958995f, -0.16887473f, -0.15148932f, 0.17397472f, 
    0.35038000f, 0.08089784f, -0.22994848f, -0.27654228f, 0.24172677f, 0.17988490f, 0.15229368f, -0.08394074f, 
    -0.07500203f, -0.08820724f, 0.18914188f, -0.29837567f, 0.14615023f, -0.37141487f, 0.06556742f, -0.27661443f, 
    0.20198332f, 0.31073761f, 0.14765392f, 0.07015183f, -0.06768245f, 0.07539365f, -0.31014052f, 0.05455672f, 
    -0.46564686f, -0.13652141f, -0.32237303f, 0.06448070f, -0.30885050f, -0.04679377f, 0.31258065f, 0.07422274f, 
    0.14916694f, -0.16041550f, -0.10248562f, -0.05512613f, 0.13601285f, 0.08930852f, 0.02582894f, 0.17926310f, 
    -0.11621187f, -0.27093884f, -0.07646906f, -0.24214791f, 0.13252710f, -0.28065020f, 0.14155674f, -0.34972095f, 
    -0.57498389f, -0.43641260f, -0.35654801f, -0.56856155f, -0.38232905f, -0.47252780f, -0.28223425f, 0.04802714f, 
    0.25617751f, 0.40147451f, -0.28847551f, -0.24517944f, 0.21888177f, -0.23215722f, 0.00899434f, 0.31205076f, 
    -0.08017252f, 0.05790471f, 0.12884714f, -0.18066177f, -0.20858444f, 0.31467310f, 0.54444951f, 0.48423338f, 
    -0.11862413f, -0.10614179f, -0.24138495f, -0.01547001f, 0.08637794f, 0.09712560f, 0.16582234f, 0.27993253f, 
    -0.26852626f, 0.04187603f, -0.04501295f, -0.32865155f, -0.31097475f, -0.09014773f, -0.19432768f, -0.04132294f, 
    0.17894454f, -0.24701744f, 0.14273694f, -0.09854993f, 0.12384822f, -0.16443212f, 0.22112848f, -0.09884974f, 
    0.38902408f, 0.47752574f, -0.18523929f, 0.07674985f, -0.17248742f, -0.06553944f, 0.10128736f, -0.16469182f, 
    -0.16494614f, -0.37940171f, 0.39136595f, 0.29985136f, -0.10683302f, -0.17567614f, -0.01268352f, -0.14322519f, 
    -0.17751928f, 0.18490627f, 0.11002699f, -0.09957211f, -0.12252067f, -0.19528793f, 0.06098768f, 0.16522849f, 
    -0.02161488f, 0.07285320f, -0.13699433f, 0.03461786f, -0.36965194f, -0.16962643f, -0.06425124f, -0.43525919f, 
    -0.42310631f, 0.37082464f, -0.32553947f, 0.14565352f, -0.35448068f, -0.61368775f, 0.32791451f, -0.03906647f, 
    0.38378945f, -0.18968521f, -0.10041095f, 0.23477273f, 0.03589588f, -0.04057432f, -0.02651383f, -0.05907144f, 
    -0.22546500f, 0.41350758f, -0.12776676f, -0.44726247f, -0.00384387f, -0.25871891f, 0.10702806f, -0.08385935f, 
    -0.09486651f, 0.02794178f, 0.08468415f, 0.34417310f, -0.01950373f, 0.19550212f, 0.13141181f, -0.00357940f, 
    -0.07691339f, -0.22617394f, 0.02866656f, 0.08828931f, -0.57247287f, 0.18888396f, 0.17157072f, 0.39670420f, 
    0.27385914f, 0.02681771f, 0.40404442f, -0.19672348f, 0.21973182f, 0.53891397f, 0.43344027f, -0.53149140f, 
    -0.22451183f, -0.22529973f, -0.24310686f, -0.12018992f, 0.31408414f, -0.09033682f, 0.17302889f, 0.18219933f, 
    -0.13040633f, -0.21385542f, 0.15883087f, -0.13597342f, -0.00831015f, -0.29642466f, 0.04987869f, -0.01651045f, 
    0.15524396f, -0.03160270f, 0.07852684f, 0.11276707f, -0.81192827f, -0.54034328f, 0.27147210f, 0.41804922f, 
    -0.03978407f, 0.11609530f, -0.38188061f, -0.43696332f, -0.07519327f, -0.49550867f, -0.45852679f, 0.30656174f, 
    -0.35138378f, 0.28061479f, 0.07961896f, -0.06288957f, -0.06784651f, 0.06388590f, -0.11196060f, -0.02145145f, 
    -0.23641151f, -0.40854853f, -0.30188060f, -0.19556497f, -0.67211443f, 0.01465129f, -0.01891602f, 0.01261909f, 
    0.30244303f, 0.30344328f, -0.14781603f, -0.14307937f, -0.35192585f, -0.25467551f, 0.06625798f, 0.76129723f, 
    -0.27931058f, -0.16995262f, 0.01280753f, -0.56173873f, 0.39649320f, -0.32159469f, -0.13030405f, -0.24399219f, 
    0.16473392f, -0.17746225f, -0.03741052f, -0.14331223f, 0.26573056f, 0.05770362f, -0.10355604f, -0.14906479f, 
    -0.33931467f, -0.14717044f, -0.31254536f, -0.51243550f, -0.68872392f, -0.72881866f, -0.63506991f, -0.00344830f, 
    0.14976494f, -0.16507585f, 0.04205443f, -0.30194837f, -0.16491319f, 0.24537100f, -0.14158829f, -0.14103833f, 
    -0.43926421f, -0.10315309f, 0.10140689f, -0.09398776f, 0.12293794f, -0.17936386f, -1.07054353f, -0.85127330f, 
    -0.33180916f, -0.05196067f, 0.05717113f, 0.08235506f, 0.17399980f, -0.48319605f, 0.05838175f, 0.72070867f, 
    0.45177820f, -0.13238551f, -0.10148159f, 0.08795577f, -0.06612916f, 0.00277096f, 0.08798356f, -0.43878490f, 
    -0.37174067f, -0.30795306f, -0.01971092f, -0.29764214f, 0.16267291f, 0.27979484f, 0.08054656f, -0.24282247f, 
    -0.65390682f, -0.31074426f, -0.00182104f, 0.00523724f, -0.64099532f, -0.61714578f, -0.35563958f, -0.47145700f, 
    -0.57139957f, 0.22402708f, 0.29663214f, 0.20687123f, 0.44679835f, 0.13869894f, 0.28119832f, -0.36083156f, 
    -0.31064707f, 0.03548640f, -0.08599599f, -0.07359159f, 0.28285363f, -0.11923955f, 0.10793889f, 0.02768720f, 
    0.52639049f, -0.78170890f, 0.32646665f, -0.07614741f, -0.30005190f, -0.31912807f, 0.22762968f, -0.30796933f, 
    -0.17152543f, 0.44690996f, -0.33374280f, 0.22458062f, -0.19516043f, 0.03993068f, 0.09561382f, -0.29576164f, 
    -0.21449772f, 0.10786236f, 0.02289005f, -0.41701758f, -0.17892919f, -0.21497907f, -0.18324815f, 0.09965973f, 
    -0.24642795f, -0.52331072f, -0.09413139f, -0.38223803f, -0.71414298f, -0.16928221f, 0.10537997f, 0.50665200f, 
    0.48836046f, 0.61736751f, 0.10592959f, -0.11120173f, -0.33825585f, -0.04121545f, -0.33776885f, -0.16151264f, 
    -0.17913271f, -0.27246267f, 0.12973703f, 0.20556040f, -0.17356531f, -0.01512113f, 0.43053755f, 0.07778830f, 
    -0.11481109f, 0.21884644f, -0.26194650f, -0.67921799f, -0.68608356f, 0.24544102f, 0.64696419f, -0.23265751f, 
    -0.14015512f, -0.06003268f, 0.23846653f, 0.39072308f, -0.33627647f, -0.38036153f, -0.26366445f, 0.16863893f, 
    -0.21726660f, 0.11979594f, 0.15387575f, 0.16624911f, 0.35527641f, 0.13424151f, -0.18821417f, -0.04205795f, 
    -0.24384053f, -0.35530517f, -0.30415040f, -0.19407468f, -0.32849932f, -0.07093118f, 0.11079001f, -0.05238083f, 
    -0.52417898f, -0.49871635f, -0.24247040f, 0.16456981f, -0.16813520f, 0.06476309f, 0.00324093f, 0.24223845f, 
    0.28528348f, -0.10550044f, 0.05821679f, -0.27963620f, -0.16239606f, -0.47397590f, -0.30669364f, -0.05570951f, 
    -0.11412376f, -0.12933777f, -0.32629561f, -0.08022864f, -0.10107060f, -0.09342434f, 0.19702521f, 0.04962965f, 
    -0.19339734f, 0.19726397f, 0.04860057f, -0.23537670f, -0.11601833f, 0.32754347f, 0.04641896f, -0.19909371f, 
    0.51501983f, -0.41033813f, -0.06381979f, 0.25022736f, -0.45955569f, -0.11737613f, 0.02569126f, -0.02677288f, 
    0.20083766f, 0.13077392f, -0.11809584f, -0.08960293f, 0.31440109f, -0.69330770f, -0.29639509f, -0.34848747f, 
    -0.36751401f, 0.05128795f, -0.40269369f, -0.47407228f, -0.30531058f, -0.27607211f, -0.29899946f, 0.11321401f, 
    -0.36852157f, -0.36623847f, -0.08526777f, 0.02580800f, -0.06405703f, -0.18321474f, -0.28442082f, -0.30082133f, 
    -0.32369569f, -0.18282822f, -0.17299111f, -0.10601239f, -0.04530541f, 0.14873669f, 0.53804433f, 0.17948559f, 
    0.12407460f, -0.03679251f, 0.06667654f, 0.26799914f, 0.20108521f, -0.11518359f, -0.07157812f, 0.14831340f, 
    -0.11757769f, 0.18154128f, -0.19278817f, 0.08230907f, 0.25455111f, -0.01161418f, -0.23357524f, 0.05632555f, 
    -0.04801170f, -0.07632481f, 0.05331449f, 0.05753979f, 0.00525114f, -0.12448373f, -0.05614190f, 0.12628415f, 
    0.18322800f, 0.14410585f, -0.01848913f, -0.27991766f, -0.50806350f, 0.42812088f, 0.49092904f, -0.02090211f, 
    -0.18955241f, -0.24378236f, -0.10296927f, -0.31342605f, 0.08947946f, 0.38003153f, 0.38368300f, -0.13669860f, 
    -0.14644817f, -0.12805037f, 0.12561345f, 0.08702695f, -0.19367848f, -0.18157947f, -0.00224525f, 0.04312206f, 
    -0.81025714f, -1.03122318f, -0.32017630f, 0.56108236f, 0.46566716f, 0.69885451f, 0.39535612f, -0.31084180f, 
    -0.30551618f, 0.21368070f, -0.09328775f, -0.66211689f, -0.16890384f, 0.44612366f, 0.15413329f, -0.18710358f, 
    0.12821475f, -0.25556824f, -0.14893731f, -0.23508567f, 0.01983216f, -0.04959241f, -0.23128666f, 0.22598337f, 
    -0.15707548f, 0.55267829f, 0.78094995f, 0.44627133f, -0.24017189f, -0.35225224f, -0.75470316f, -0.53326178f, 
    -0.20720045f, -0.32619146f, -0.53055489f, -0.02574361f, -0.09748957f, -0.10929340f, 0.17021953f, 0.29921097f, 
    0.35729516f, 0.14754213f, 0.24226241f, -0.05203325f, 0.12405103f, -0.11485471f, -0.01651323f, -0.30708086f, 
    -0.14035991f, -0.21567160f, 0.67200977f, -0.62823826f, -0.14640948f, -0.12546480f, 0.21566530f, 0.34022063f, 
    0.50044972f, 0.04426931f, -0.41188103f, -0.19104779f, -0.23418440f, 0.24069011f, -0.17700623f, -0.26267961f, 
    0.34378061f, 0.15100557f, -0.27828971f, -0.20195681f, 0.00049156f, -0.20010370f, 0.26859930f, -0.19543099f, 
    0.04609287f, 0.09928098f, 0.23364982f, -0.30731398f, -0.33420959f, -0.23763651f, -0.08833746f, -0.49038741f, 
    -0.36839488f, -0.41832700f, -0.37136909f, -0.48072937f, -0.39322060f, -0.14797561f, -0.16421010f, -0.30607638f, 
    -0.16607285f, -0.09678242f, -0.04795796f, -0.26003227f, -0.06857586f, 0.16190694f, -0.18568367f, 0.09223563f, 
    -0.07625347f, -0.15434042f, 0.09709482f, 0.23828366f, 0.75189769f, 0.47642484f, 0.42158636f, -0.39169306f, 
    0.22014503f, -0.30292827f, -0.12769651f, 0.27684620f, -0.32704765f, -0.51609188f, 0.02539922f, 0.35468826f, 
    -0.15562560f, -0.21319373f, -0.02597776f, -0.14406404f, 0.19350407f, -0.12204161f, -0.24103479f, 0.18834245f, 
    -0.13976225f, 0.03431781f, -0.07009215f, 0.00678705f, -0.20185661f, 0.34669986f, 0.40439597f, 0.36034381f, 
    -0.15759028f, -0.26336181f, -0.18164322f, -0.29173061f, -0.13130127f, -0.01480170f, 0.24769650f, 0.08909475f, 
    -0.13132118f, -0.09069542f, 0.02963284f, -0.10862995f, 0.02130487f, -0.13782990f, -0.02503373f, 0.20685273f, 
    0.08002201f, -0.00870412f, 0.26165092f, -0.30010173f, -0.30073410f, -0.20180373f, 0.07345528f, 0.18904048f, 
    0.21743643f, 0.12368760f, 0.06871936f, 0.06620106f, -0.28012839f, -0.26320004f, 0.08982875f, 0.23977979f, 
    -0.07306031f, 0.21894081f, 0.27910519f, -0.28994474f, -0.29061025f, -0.21631381f, 0.02386856f, -0.00759305f, 
    0.14330557f, -0.27829093f, 0.12923294f, 0.07220604f, 0.24577691f, 0.13349675f, -0.29163074f, -0.95705628f, 
    -0.42359984f, -0.36117303f, -1.01936269f, -0.90072215f, 0.85789633f, -0.03138328f, -0.54252982f, 0.29836082f, 
    0.33141205f, -0.32714984f, -0.42470160f, -0.22515327f, -0.31937999f, -0.29352164f, 0.09835348f, -0.02117245f, 
    -0.07223475f, -0.02195125f, -0.02680498f, -0.12546314f, 0.07227632f, 0.00553204f, -0.06318267f, 0.00575096f, 
    1.01089406f, -0.32429433f, -0.34672651f, -0.44228670f, 0.11261320f, 0.28078100f, 0.22267930f, 0.07237997f, 
    0.18650892f, -0.31719345f, -0.28833458f, -0.20581852f, 0.02931289f, -0.24622783f, 0.26123255f, -0.08152882f, 
    0.01006660f, -0.06727915f, -0.23664688f, -0.31240016f, -0.31743166f, -0.36908591f, -0.42275047f, -0.50991428f, 
    -0.41598353f, 0.40287125f, 0.38335824f, 0.22236851f, -0.45859525f, -0.58309627f, -0.34823644f, -0.10136036f, 
    -0.23772004f, 0.08219707f, 0.00654722f, 0.40112799f, 0.00035993f, -0.13718024f, 0.33181596f, 0.31997791f, 
    -0.02379304f, -0.04447595f, 0.24085337f, -0.21365024f, -0.18519334f, -0.07350599f, 0.17273968f, -0.19240522f, 
    -0.26863742f, 0.17274927f, 0.88948739f, -0.17665525f, -0.23557101f, 0.23366103f, -0.09629732f, 0.30046958f, 
    0.20771049f, 0.27091956f, -0.64400005f, -0.66542745f, -0.44113952f, -0.19067307f, 0.13389893f, -0.08037340f, 
    -0.24138755f, 0.23479965f, -0.05190771f, 0.32222408f, 0.03323726f, 0.07439581f, 0.03520781f, -0.24454872f, 
    -0.07362391f, -0.05228048f, -0.01926588f, 0.40131941f, 0.09903197f, -0.59505677f, -0.07774848f, 0.26523203f, 
    -0.42956290f, 0.19708282f, 0.27740425f, 0.12603562f, 0.21221052f, -0.25976643f, -0.39792237f, -0.27542382f, 
    0.15068994f, -0.13440280f, 0.25098038f, -0.19010416f, 0.26478231f, 0.06663044f, -0.17262007f, -0.12530573f, 
    0.09508678f, 0.19652264f, -0.11848903f, 0.02825249f, 0.74447048f, 0.37714803f, -0.45722696f, 0.01083496f, 
    -0.50484091f, -0.54564977f, -0.43417642f, 0.35311121f, 0.21224913f, 0.05191650f, -0.20735650f, -0.09658317f, 
    0.69222003f, -0.12661240f, -0.11429210f, 0.06628554f, 0.09727705f, -0.18796299f, -0.15384690f, -0.05201114f, 
    0.11654879f, -0.08392651f, -0.23480935f, 0.15927598f, -0.07867783f, -0.03022642f, -0.23712927f, 0.30735338f, 
    0.09978608f, 0.29545349f, 0.09985746f, 0.00873331f, -0.01412742f, -0.13721862f, -0.06383830f, 0.22906755f, 
    -0.25387320f, -0.18293819f, 0.12129325f, -0.20393674f, -0.38127089f, 0.07746679f, 0.11729947f, 0.17564680f, 
    0.18244249f, 0.16539505f, -0.22256386f, -0.48108235f, 0.14189970f, 0.36465454f, -0.10723931f, -0.41488597f, 
    0.25442109f, 0.65621054f, 0.02073701f, 0.27343860f, -0.27035999f, -0.18492578f, -0.29560897f, -0.03342364f, 
    -0.30140942f, 0.25653026f, -0.19150676f, -0.09431490f, -0.03131704f, 0.11860569f, -0.28885403f, -0.04598957f, 
    0.35386264f, 0.31338528f, -0.26640585f, -0.09707967f, -0.15201515f, 0.15023626f, -0.39637071f, -1.06558442f, 
    -0.19269450f, -0.15280958f, -0.73303646f, -0.86865228f, 0.18228036f, -0.03082255f, -0.31645826f, 0.07017133f, 
    0.29764181f, -0.07297423f, 0.05362777f, 0.05249929f, 0.13080414f, -0.16661765f, 0.20250896f, 0.15474126f, 
    0.09199433f, -0.12122765f, 0.07096430f, -0.05366448f, 0.13074046f, 0.11902611f, -0.14037146f, 0.30163157f, 
    -0.32656908f, 0.09261560f, -0.12993674f, 0.28506520f, -0.40645024f, -0.36047560f, 0.12485265f, -0.36446470f, 
    -0.70109034f, -0.23785509f, 0.10026128f, -0.04984856f, -0.17440961f, -0.23978449f, -0.33703753f, -0.41903135f, 
    -0.00425682f, 0.17808585f, -0.32260001f, -0.45229045f, 0.03356573f, -0.23971558f, -0.15218839f, 0.18724737f, 
    0.28639081f, 0.18530662f, -0.11601216f, 0.03676840f, 0.31520474f, -0.30878922f, -0.59442216f, -0.35104820f, 
    0.30702886f, 0.29904419f, -0.10626517f, -0.00834981f, -0.15008113f, -0.23249201f, 0.02451255f, -0.19992135f, 
    -0.04405965f, -0.05387306f, -0.03371294f, 0.32007739f, -0.21142629f, -0.14144194f, 0.06123447f, -0.11545492f, 
    -0.12100647f, -0.10952812f, -0.02338665f, -0.30914575f, -0.43037850f, -0.06236897f, -0.16208296f, -0.18055260f, 
    0.08302931f, -0.70195079f, -0.63512743f, -0.65648663f, 0.38374144f, 0.24415287f, 0.38313404f, 0.13308425f, 
    0.23191169f, -0.00335029f, -0.50019431f, -0.47703597f, -0.18956815f, -0.07632422f, -0.14057343f, 0.00437858f, 
    0.25098825f, -0.01460910f, -0.38280568f, -0.14327380f, -0.95858395f, -0.51891428f, -0.32714289f, 0.27287200f, 
    0.21821502f, 0.41907078f, 0.11213713f, 0.10771474f, 0.30074564f, 0.24768890f, 0.14441310f, -0.25785586f, 
    -0.21245439f, -0.06022841f, -0.24274321f, -0.02728890f, -0.07099927f, -0.07124943f, -0.22372077f, -0.27188447f, 
    -0.12146942f, -0.19379286f, -0.34930325f, -0.19381708f, 0.11416142f, 0.20707729f, 0.11832570f, -0.04030799f, 
    -0.27077964f, -0.08107775f, -0.26495993f, 0.03776507f, 0.18020003f, 0.14286922f, 0.20293601f, -0.08655399f, 
    -0.35741511f, -0.10226773f, 0.34903949f, -0.15152256f, -0.14286543f, -0.01015642f, 0.35514176f, 0.04480476f, 
    0.12470111f, -0.08690652f, -0.11719846f, -0.11446632f, 0.16543476f, -1.03764546f, 0.11182915f, -0.00854747f, 
    -0.00958594f, 0.51719904f, -0.45377356f, -0.12185048f, 0.67036241f, -0.10135800f, 0.08274269f, -0.41832054f, 
    0.03480211f, -0.19368567f, 0.47784361f, -0.14143239f, 0.12438209f, 0.03957465f, -0.10424426f, 0.18473233f, 
    -0.18802300f, -0.14227912f, -0.22747463f, 0.06905279f, 0.18021816f, -0.17116930f, 0.45086330f, 0.32282394f, 
    -0.22670338f, -0.15972123f, -0.38472164f, 0.15602885f, 0.12607990f, 0.52116895f, -0.16800109f, -0.11797401f, 
    -0.01874338f, -0.20679553f, -0.18809833f, -0.03980906f, 0.01668396f, 0.41087270f, -0.25157234f, -0.30959296f, 
    0.26326382f, -0.14640641f, 0.10208003f, 0.19884717f, 0.21811551f, -0.28384748f, -0.07681856f, 0.03366473f, 
    -0.12194080f, -0.29384467f, -0.19401868f, -0.54160404f, -0.45085672f, -0.26592636f, -0.12185057f, 0.00791680f, 
    -0.31840590f, -0.05858925f, 0.02378528f, 0.31290531f, 0.36720994f, 0.18477458f, -0.18836106f, -0.22235271f, 
    0.05328622f, -0.23838267f, 0.10444569f, -0.12376991f, -0.22097890f, -0.25224930f, 0.02626897f, -0.41092855f, 
    0.76315504f, 0.27569935f, -0.29205015f, -0.24698725f, -0.27945456f, -0.31014270f, -0.37517333f, 0.13080116f, 
    0.19110943f, -0.09438723f, -0.04249431f, -0.06648709f, 0.11462738f, 0.17647919f, 0.16503300f, 0.17739953f, 
    0.23597458f, -0.01932674f, -0.50839037f, -0.16826312f, 0.17662789f, -0.29130659f, 0.00842540f, 0.17790663f, 
    0.23317717f, 0.32459024f, 0.23816666f, -0.45802543f, 0.02321588f, -0.02860737f, -0.25127637f, -0.03645982f, 
    -0.08721343f, 0.21846281f, 0.30190587f, -0.15267135f, 0.19708838f, -0.22926633f, 0.15292777f, -0.12746477f, 
    0.08457806f, -0.03034239f, -0.18636687f, -0.08977973f, -0.07707483f, -0.33469927f, -0.16807780f, -0.10115340f, 
    -0.32488182f, -0.01319185f, -0.26927277f, 0.16908500f, 0.45636466f, -0.13574225f, -0.11848314f, -0.50306982f, 
    -0.45749205f, -0.04429071f, -0.07618490f, -0.26991451f, 0.00799400f, 0.40351981f, -0.40183192f, 0.39618498f, 
    -0.03804055f, 0.08847523f, -0.02543109f, -0.07577357f, 0.00091432f, -0.01766168f, 0.12826757f, 0.23725200f, 
    0.19638313f, -0.27024952f, -0.12686135f, -0.62493426f, -0.07652891f, 0.30145952f, 0.52081960f, -0.04605202f, 
    -0.51450646f, -0.73286021f, -0.31010854f, 0.49841547f, 0.65754902f, -0.21491282f, 0.01305139f, 0.03588959f, 
    0.13240579f, 0.23518543f, 0.14134757f, -0.05273028f, -0.28048930f, 0.08584841f, -0.45907807f, 0.04656881f, 
    -0.00992610f, 0.27042672f, 0.05776633f, -0.13093887f, -0.42145932f, -0.59478551f, -0.08614712f, 0.45802227f, 
    0.21520635f, -0.37421760f, -0.33897686f, -0.34704420f, 0.21659496f, -0.40447375f, 0.21589391f, 0.45152393f, 
    0.16042301f, 0.00825665f, -0.21107879f, -0.23308097f, 0.15999563f, 0.06644541f, -0.25727651f, 0.03718283f, 
    -0.18249318f, 0.19272690f, 0.11578229f, -0.10348360f, 0.06375565f, 0.85428327f, -0.11051635f, -0.57329953f, 
    -0.68104863f, -0.80797803f, 0.39976656f, 0.16844220f, 0.11892650f, 0.26216203f, 0.14987606f, -0.16282715f, 
    0.36111161f, 0.19162683f, 0.00399403f, 0.19709603f, -0.17020981f, -0.00656303f, -0.20388544f, -0.11888561f, 
    0.20121421f, -0.01835774f, 0.11466310f, -0.25502068f, 0.21854863f, -0.08637431f, -0.40354598f, 0.05858497f, 
    -0.10517421f, 0.31439820f, 0.15335420f, -0.23052253f, -0.02908910f, 0.16957958f, 0.28742644f, -0.13095954f, 
    0.02618821f, 0.13516605f, 0.24020188f, -0.70293677f, 0.15614742f, 0.00242135f, 0.00979630f, -0.19138354f, 
    -0.01128645f, -0.24337026f, -0.06098227f, -0.24117282f, -0.34559920f, -0.24587728f, -0.45954758f, 0.54939389f, 
    -0.02161073f, -0.44201913f, -0.31725267f, 0.04959758f, 0.64857656f, 0.50844496f, -0.34498721f, -0.87559503f, 
    -0.46083292f, 0.08640129f, -0.14045852f, -0.12407988f, -0.33829224f, -0.27044076f, -0.38813999f, -0.20457083f, 
    0.39415759f, -0.32235521f, 0.05240423f, 0.36253381f, -0.17142184f, -0.29882550f, 0.01462071f, -0.28395760f, 
    -0.12017363f, -0.36996046f, -0.11011747f, 0.24597190f, 0.28655726f, -0.32094872f, -0.50497377f, 0.06957022f, 
    0.51516616f, 0.08636329f, 0.18695222f, -0.07280467f, -0.25332668f, 0.25865757f, -0.03775864f, -0.00008344f, 
    0.23165032f, 0.13496295f, -0.40741852f, 0.15320472f, 0.12625691f, 0.19826093f, 0.15949842f, 0.07951522f, 
    -0.06564478f, -0.02896843f, -0.05237595f, 0.14310662f, -0.94289160f, -0.81432825f, 0.05050589f, 0.21739390f, 
    0.40461066f, 0.18507443f, -0.01764998f, -0.16332850f, -0.25305453f, 0.01640552f, 0.19988455f, 0.03391587f, 
    0.09342224f, 0.01710453f, -0.11856836f, -0.19682200f, 0.11151067f, -0.24112490f, -0.22677074f, 0.14363876f, 
    -0.31275481f, -0.33580029f, -0.65864277f, -0.59748983f, -0.16016400f, -0.35811481f, -0.73778838f, 0.61705643f, 
    0.40984723f, 0.24016851f, -0.20935261f, -0.01177391f, -0.04425608f, -0.17703919f, 0.35125777f, 0.32822019f, 
    0.04431143f, -0.25256845f, -0.23050678f, -0.00683179f, 0.02638752f, 0.07613885f, 0.07973851f, 0.03046330f, 
    0.44172266f, 0.14423819f, -0.22850433f, -0.32837424f, -0.33923036f, -0.17704777f, -0.29738635f, 0.17220595f, 
    0.45108500f, 0.63729060f, 0.24204704f, 0.13108513f, 0.54648912f, 0.09469537f, -0.01137008f, -0.34401745f, 
    -0.11065325f, 0.51330066f, -0.19985911f, -0.01480399f, -0.13687566f, -0.18336537f, -0.35501677f, -0.16443759f, 
    -0.24491102f, 0.17735811f, 0.06170286f, 0.04133988f, -0.18836816f, -0.22354034f, 0.26877311f, 0.11040705f, 
    -0.08294141f, -0.38176012f, 0.08066846f, -0.25130966f, -0.44019821f, -0.54181385f, 0.41543543f, -0.09587663f, 
    0.20085061f, 0.01658825f, 0.27458811f, 0.07548515f, 0.02464905f, -0.02503363f, 0.13687186f, -0.19394429f, 
    -0.37604800f, -0.27622360f, 0.18078993f, 0.26048908f, 0.20194063f, 0.00197992f, 0.18639374f, 0.11603162f, 
    0.28309605f, 0.25860736f, 0.19978471f, -0.32908079f, -0.15975317f, 0.20305744f, 0.36177114f, -0.27272645f, 
    -0.00341525f, -0.01086393f, 0.06770094f, -0.14387384f, -0.12669648f, 0.01602976f, -0.11230671f, 0.09643471f, 
    -0.09608721f, -0.04805430f, -0.26920623f, 0.06163693f, -0.23845918f, -0.20836484f, 0.44774157f, 0.56343734f, 
    -0.13974243f, -0.71954799f, -0.58001381f, 0.24108614f, 0.62452418f, -0.02628143f, -0.21967062f, -0.25889996f, 
    0.22821364f, -0.02264070f, -0.21878189f, 0.03625748f, -0.05504746f, -0.08744347f, 0.03100979f, 0.41522363f, 
    -0.04090400f, -0.05401520f, -0.15170038f, 0.02517491f, -0.11547457f, -0.18600306f, 0.34297991f, -1.18520617f, 
    -0.36395326f, -0.45168591f, -0.17798144f, -0.11455406f, 0.44778594f, 0.63286591f, -0.52602476f, -0.36660245f, 
    0.62363315f, -0.25190401f, -0.52012169f, -0.12732524f, -0.32077074f, -0.39690161f, 0.06364211f, 0.15337712f, 
    0.00624369f, -0.13759948f, -0.27849814f, 0.04809951f, -0.08615516f, 0.07102888f, -0.05266702f, -0.09405882f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27421787f, 0.20075426f, 0.08098908f, 0.38258135f, 0.01432045f, -0.26075774f, 0.26345870f, 0.10165887f, 
    0.09791470f, -0.08265655f, 0.19287927f, -0.23899949f, 0.11813004f, -0.20698692f, 0.14249106f, 0.01860170f, 
    0.23029110f, -0.08431565f, 0.02139248f, 0.06262829f, 0.14713413f, -0.26519907f, -0.05950543f, 0.30749062f, 
    0.10183491f, 0.12227450f, 0.22157316f, -0.38075593f, 0.11898084f, 0.05498002f, -0.04158233f, -0.25619814f, 
    -0.02699146f, 0.17088018f, -0.06440988f, -0.02754347f, 0.18697739f, -0.06476579f, 0.00309580f, -0.01925782f, 
    0.00320273f, 0.08250625f, -0.16845094f, 0.12561010f, 0.34002200f, 0.16862395f, 0.22015856f, -0.15479252f, 
    0.34529483f, 0.09413132f, 0.04610441f, 0.28657877f, 0.31792361f, 0.43300211f, -0.16084273f, 0.05817958f, 
    0.33858660f, 0.08356919f, 0.07055450f, 0.20020822f, 0.11762545f, 0.11260371f, 0.28032517f, -0.35071906f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15821959f, -0.15131657f, -0.12643842f, 0.04358083f, -0.10184089f, -0.12999927f, 0.02804256f, -0.11394381f, 
    -0.02325350f, -0.09873393f, 0.00485131f, -0.06070161f, -0.16380839f, -0.30767152f, -0.33589810f, -0.05320066f, 
    0.04221841f, -0.07943234f, 0.08162620f, 0.08162379f, -0.05631681f, -0.03428235f, -0.08206070f, -0.00309446f, 
    0.36458799f, 0.05090268f, -0.34390089f, -0.18115403f, -0.07765260f, 0.03461232f, 0.04080830f, 0.12930937f, 
    -0.04919706f, -0.06340201f, -0.04569390f, -0.07605717f, -0.05488925f, -0.00258766f, -0.11589576f, 0.07054707f, 
    -0.03421723f, -0.06411491f, 0.03227407f, -0.01644088f, -0.07276530f, -0.02420353f, -0.19658482f, -0.04412715f, 
    0.15099482f, 0.12912159f, -0.00051663f, -0.00706960f, 0.07366066f, -0.18648402f, -0.00700811f, 0.10232664f, 
    0.08792515f, 0.07456443f, -0.00193780f, -0.00608799f, 0.24210109f, 0.17211966f, -0.16490045f, -0.09732718f, 
    0.14779697f, 0.01658518f, 0.07899197f, 0.02302251f, 0.05605692f, 0.01530058f, 0.03206728f, -0.01533743f, 
    -0.59220511f, -0.18612593f, -0.36992523f, 0.11679751f, 0.05860937f, 0.03616467f, 0.03423734f, 0.07563574f, 
    0.00272771f, -0.03530219f, 0.02743839f, 0.02886031f, -0.17491923f, -0.07115088f, -0.09228820f, 0.03806788f, 
    0.05820002f, 0.03118022f, 0.01457458f, 0.04487673f, -0.03974430f, 0.01426143f, 0.03865874f, 0.01056198f, 
    0.10832278f, 0.26815394f, 0.03879537f, -0.10306799f, 0.07172685f, 0.04089373f, -0.09390627f, -0.02772212f, 
    -0.06854166f, 0.02501261f, 0.00121372f, -0.07037960f, 0.02751701f, 0.03380015f, -0.01574826f, 0.03827793f, 
    0.03755526f, 0.01843587f, 0.00718132f, -0.24139567f, -0.12258047f, -0.12950186f, -0.13303894f, -0.06199758f, 
    -0.64921039f, 0.14216490f, 0.26627398f, -0.34844816f, -0.03730400f, -0.03298291f, 0.00083048f, -0.03239315f, 
    0.02429347f, 0.00221474f, 0.02887462f, -0.00884243f, 0.24972501f, 0.08443815f, 0.00470823f, -0.00293082f, 
    0.00669825f, 0.03631936f, 0.16240451f, -0.12930776f, -0.10829542f, -0.09003720f, -0.06595391f, -0.00490438f, 
    -0.00672273f, 0.11345294f, -0.03467439f, -0.12074134f, -0.07535475f, 0.06600712f, -0.03173542f, -0.06636302f, 
    -0.07804012f, -0.06785943f, -0.15050568f, -0.21117678f, 0.25010809f, 0.12201781f, -0.23567601f, -0.11655172f, 
    0.06901305f, 0.06059804f, -0.00552979f, 0.12625170f, 0.01241051f, 0.00674918f, -0.02018163f, 0.00177131f, 
    0.25455517f, 0.21569069f, 0.14516810f, -0.17080776f, -0.03965363f, 0.17231160f, 0.05947438f, -0.00342891f, 
    -0.15376258f, -0.03148592f, -0.05133455f, -0.10344476f, 0.29230493f, 0.23383768f, -0.17230086f, -0.18008395f, 
    -0.06989563f, -0.05111541f, 0.05187311f, -0.05657791f, -0.02946071f, 0.03453954f, -0.05096646f, -0.00612196f, 
    0.07462100f, 0.05704663f, 0.02532629f, -0.00840403f, -0.02557708f, -0.04240049f, -0.05433014f, -0.19594967f, 
    -0.04178142f, -0.02158975f, -0.12309609f, 0.12528265f, 0.02963040f, -0.20414737f, -0.03312117f, -0.02986866f, 
    0.04943685f, 0.15698957f, 0.07051732f, -0.00709524f, 0.05249982f, -0.01513682f, -0.00245730f, 0.04233652f, 
    0.18311295f, 0.13134007f, 0.15031821f, -0.04034014f, 0.03567808f, 0.11512890f, 0.07271567f, -0.08581325f, 
    0.02145342f, 0.08420241f, 0.08035499f, 0.00917759f, 0.15494300f, 0.16465598f, 0.10770045f, -0.14087917f, 
    -0.19480504f, -0.15690681f, -0.09871409f, -0.01813351f, -0.03859103f, -0.09955607f, 0.00204971f, -0.03416818f, 
    0.06708220f, -0.18705730f, -0.13270867f, -0.26116902f, 0.02011354f, -0.14825897f, 0.13399234f, -0.03345802f, 
    -0.06563276f, -0.07255854f, -0.14680648f, -0.12023707f, 0.26946837f, 0.20280944f, 0.10912062f, -0.11840859f, 
    0.08205181f, 0.21643259f, -0.00325898f, 0.08443152f, -0.10324026f, -0.03705039f, -0.06010079f, -0.11801055f, 
    -0.10405617f, -0.04949451f, -0.02037374f, 0.04379202f, 0.07349721f, 0.06646908f, 0.01325513f, 0.04458094f, 
    -0.09833902f, 0.08503366f, 0.03909041f, -0.12413494f, -0.45131111f, -0.50257200f, 0.34450054f, 0.06812672f, 
    0.05959857f, -0.03227518f, -0.07915169f, -0.01521571f, 0.01391237f, 0.01108363f, 0.06228923f, -0.07884301f, 
    0.45083740f, -0.02468545f, -0.04829731f, -0.14280511f, -0.04761261f, 0.00160089f, 0.04595527f, -0.09186944f, 
    0.02167178f, -0.06720968f, -0.02172062f, 0.01602508f, 0.02107398f, 0.05032097f, 0.03545703f, -0.12257403f, 
    -0.02039851f, -0.05192262f, -0.04032243f, -0.01102161f, 0.05101231f, 0.07924870f, 0.02030743f, -0.00084721f, 
    -0.05991079f, -0.00892522f, -0.36033174f, 0.11278350f, -0.03316065f, -0.11751740f, 0.04902664f, -0.13470680f, 
    -0.03226510f, -0.04338194f, -0.01357614f, -0.20778918f, 0.24619244f, 0.17172703f, -0.08006437f, -0.17967469f, 
    0.18201518f, 0.03492064f, 0.13170905f, 0.05416192f, 0.00440494f, -0.02957021f, 0.02654739f, -0.02940175f, 
    -0.20891324f, -0.20628923f, -0.44800520f, 0.06735606f, -0.00982901f, 0.02312320f, -0.04743813f, 0.00299225f, 
    0.04525362f, 0.05120612f, 0.02357790f, 0.00219330f, -0.28845000f, -0.10462173f, 0.00699716f, 0.06807049f, 
    0.06028504f, 0.03562551f, -0.01162661f, -0.02969133f, -0.04033143f, -0.06208355f, 0.04686058f, -0.02964367f, 
    -0.04723699f, -0.08947700f, -0.08182270f, 0.05879919f, 0.01571689f, -0.00185543f, 0.06932119f, 0.01702472f, 
    -0.02560626f, -0.02041654f, 0.03335591f, 0.05541964f, 0.17306004f, 0.21461716f, -0.05824574f, -0.14453028f, 
    0.10115044f, 0.26453319f, 0.09447194f, 0.08278780f, 0.00025098f, 0.07518901f, 0.01991297f, 0.01712977f, 
    -0.14861546f, -0.34785122f, -0.24648750f, 0.11590031f, -0.04216217f, 0.03967018f, 0.03737949f, -0.03039974f, 
    0.00729944f, -0.00055407f, 0.04874043f, 0.17522272f, 0.10681284f, -0.13875054f, 0.05154732f, -0.01798841f, 
    -0.08411381f, 0.00070132f, -0.08613192f, -0.16058877f, -0.07934530f, -0.02524293f, 0.00734183f, -0.06410060f, 
    0.11753694f, -0.59308344f, 0.04880292f, -0.07321798f, 0.05576287f, 0.01890726f, -0.10214533f, 0.02104801f, 
    0.03311279f, 0.08030707f, 0.00634483f, 0.03245577f, -0.03086508f, 0.22023173f, 0.07669869f, 0.08729519f, 
    -0.01864811f, -0.00707868f, 0.02728829f, 0.08849676f, -0.00647315f, 0.01976941f, -0.04940905f, -0.05873186f, 
    -0.04799222f, -0.06809056f, 0.14840567f, -0.05460909f, -0.02017842f, -0.01497234f, -0.08684590f, -0.16622521f, 
    -0.02194631f, -0.10014325f, -0.09119539f, 0.13335016f, 0.20791939f, -0.31619391f, -0.15360582f, 0.03879395f, 
    0.00026467f, 0.03956770f, 0.04793059f, 0.13809207f, 0.02858077f, 0.00865780f, 0.03426086f, 0.06612321f, 
    0.04136000f, 0.04139345f, -0.01891718f, -0.22167899f, 0.06634846f, -0.04057998f, 0.02184996f, -0.23770578f, 
    -0.05879020f, -0.01897403f, 0.04150235f, -0.10451754f, 0.19791283f, 0.07935797f, 0.08527941f, -0.22725542f, 
    0.03275005f, 0.15568519f, 0.02527939f, 0.00301397f, -0.00329346f, 0.00394041f, 0.08467925f, 0.03755476f, 
    0.15131594f, 0.15186508f, -0.05112814f, -0.16421595f, -0.06541506f, 0.03278053f, -0.03010937f, 0.03746509f, 
    -0.03768256f, -0.08788786f, 0.01110848f, -0.01030808f, -0.07776032f, 0.10350351f, 0.25583714f, -0.11643210f, 
    -0.04713086f, -0.05284064f, -0.06848020f, 0.03479162f, -0.06321422f, -0.03643009f, -0.08175903f, 0.10130364f, 
    0.33376983f, 0.20739125f, -0.23247541f, -0.14845273f, -0.05325453f, -0.11326841f, 0.06561147f, 0.11141124f, 
    -0.03388948f, 0.02346883f, -0.04569294f, 0.00613430f, 0.16569723f, -0.05585955f, -0.23111059f, 0.04814676f, 
    0.07972270f, 0.05483054f, 0.04885485f, -0.05973290f, 0.00918272f, 0.08512668f, -0.00635724f, 0.08585246f, 
    -0.23321815f, -0.09674295f, 0.00050959f, 0.00661256f, -0.05494849f, -0.06761039f, -0.12603393f, -0.07862679f, 
    -0.06668724f, -0.03941762f, -0.01057340f, -0.08339767f, -0.02336317f, -0.04366528f, 0.15371825f, -0.02462751f, 
    -0.15676914f, 0.09762716f, 0.06330542f, -0.03392918f, -0.13223475f, 0.06502841f, -0.07544142f, -0.01133415f, 
    -0.24022672f, -0.21325321f, -0.15181732f, 0.04947712f, 0.05234412f, 0.02726444f, 0.01611209f, -0.00075147f, 
    -0.03821454f, -0.07650886f, -0.18894874f, -0.11616136f, 0.20113711f, 0.03173374f, -0.01039952f, -0.10273103f, 
    0.00232215f, -0.14613231f, -0.18122324f, -0.03322914f, 0.06148705f, -0.02573104f, -0.00173714f, 0.07130041f, 
    0.10036144f, -0.03330474f, -0.03759279f, -0.12681946f, -0.08866875f, -0.04720037f, -0.16429929f, -0.12076098f, 
    -0.01742475f, -0.05940014f, -0.10008461f, -0.07818966f, -0.39862701f, -0.04018190f, -0.04058958f, -0.03805667f, 
    -0.02399772f, 0.04656056f, 0.02518937f, -0.02019216f, -0.20776574f, -0.02145130f, -0.12960285f, 0.01295740f, 
    0.02284854f, 0.08402909f, 0.08259015f, -0.05035362f, -0.14987063f, 0.03464597f, -0.18471475f, 0.01661389f, 
    0.00302966f, 0.04237518f, -0.10037196f, 0.02015099f, -0.04425351f, 0.16539541f, 0.25589332f, -0.41907352f, 
    -0.13924401f, -0.05825261f, 0.01667289f, 0.00947921f, 0.03582943f, -0.20822956f, -0.18045337f, -0.11424556f, 
    0.19687563f, 0.26778677f, -0.00146011f, -0.27481163f, -0.00471952f, -0.01349164f, -0.04995567f, -0.08499783f, 
    0.02618470f, -0.00868590f, -0.00025909f, -0.01657058f, 0.00468842f, -0.35614499f, -0.11642043f, 0.14704275f, 
    -0.00099110f, 0.02798740f, -0.11583733f, 0.02508468f, -0.12623022f, -0.14109439f, -0.04840992f, -0.07320221f, 
    -0.34212524f, 0.07380716f, 0.01930897f, 0.02757126f, -0.02632290f, -0.00110611f, 0.07062664f, 0.02469041f, 
    -0.15367715f, -0.09665366f, 0.29785115f, 0.21896587f, 0.14543182f, -0.07355196f, -0.55991858f, 0.12382845f, 
    0.02438749f, -0.09436528f, -0.02511903f, -0.04281310f, -0.09451286f, -0.01391844f, -0.04095818f, -0.00097890f, 
    -0.02117928f, 0.11570096f, 0.16679087f, -0.06852172f, -0.16158894f, 0.04286081f, -0.16479592f, -0.15180364f, 
    -0.10097242f, -0.06274540f, -0.15913612f, -0.06566069f, -0.07533995f, -0.12048794f, 0.02373775f, -0.06870569f, 
    0.06100023f, 0.10116673f, -0.13548520f, 0.00770591f, 0.00055220f, -0.02387238f, 0.15422456f, -0.01688088f, 
    0.16223453f, -0.14322110f, -0.12051260f, -0.03941698f, 0.07719325f, 0.13141644f, -0.10363710f, -0.11342031f, 
    -0.05091638f, -0.03262057f, -0.06003872f, 0.05363700f, 0.15410472f, -0.23659123f, -0.14306229f, 0.15823720f, 
    0.03724580f, 0.03169690f, 0.04597522f, -0.00991939f, -0.05093206f, -0.02529919f, -0.15077735f, -0.06133868f, 
    0.19119245f, 0.01103137f, -0.05956769f, -0.20819236f, 0.05170257f, -0.11425412f, -0.04493035f, -0.04290614f, 
    0.02529198f, 0.05299559f, 0.00738746f, 0.03674372f, -0.42288154f, -0.14414692f, 0.02444478f, -0.03466946f, 
    0.06455354f, 0.02000205f, 0.07246328f, 0.02020894f, 0.00290100f, -0.03296933f, 0.09315483f, 0.04121683f, 
    0.06859672f, -0.50469083f, -0.23825787f, 0.06058957f, -0.04712871f, 0.02935854f, -0.24677365f, -0.11943283f, 
    -0.01625317f, -0.02153373f, -0.09285818f, -0.01087994f, 0.38957778f, 0.26558813f, -0.04659411f, -0.03944770f, 
    0.04537404f, 0.08333924f, 0.04866706f, 0.01400196f, 0.06781885f, 0.06241748f, -0.03444853f, -0.03944009f, 
    0.08631081f, -0.07053500f, 0.01903628f, -0.14135370f, -0.09363731f, 0.10997456f, -0.11458161f, 0.23282552f, 
    -0.22545999f, -0.00252839f, 0.11269610f, 0.02485197f, 0.17480814f, 0.05916309f, -0.02221415f, -0.00309517f, 
    -0.02478306f, -0.09225906f, -0.15796450f, 0.12718843f, -0.15199760f, 0.08088262f, 0.08699893f, -0.34612152f, 
    0.12810846f, -0.28985196f, 0.19184513f, 0.00728343f, 0.04650429f, -0.10751574f, 0.09462658f, -0.01981655f, 
    0.03707116f, -0.11856710f, 0.03597924f, -0.04406900f, 0.18324082f, 0.00608451f, -0.01438409f, 0.00816199f, 
    0.05412429f, -0.10199700f, 0.06124425f, 0.00177097f, -0.07535774f, 0.08697820f, -0.09310053f, 0.08248990f, 
    -0.09656578f, -0.02414053f, 0.01463146f, -0.13833284f, -0.06197200f, 0.05022639f, -0.08331490f, -0.13997328f, 
    0.07282808f, -0.05046898f, -0.00954224f, 0.03035679f, 0.09916364f, 0.02331633f, 0.21743806f, 0.18045031f, 
    -0.32073736f, 0.13574661f, -0.37709990f, -0.11348553f, -0.05762722f, 0.02003824f, -0.01979586f, 0.04668729f, 
    0.36714244f, 0.24448793f, 0.33593524f, -0.01279414f, -0.01662205f, 0.03356119f, 0.00799451f, 0.00297236f, 
    -0.04607466f, 0.00509801f, -0.00803711f, -0.03767809f, 0.17455061f, 0.01217592f, 0.19657955f, 0.03616529f, 
    -0.01534235f, -0.02293462f, 0.02500511f, -0.13097396f, 0.05295763f, -0.02677650f, 0.08888111f, 0.00840361f, 
    0.09470219f, -0.07084676f, -0.02346015f, -0.29042235f, 0.14881569f, -0.00818169f, -0.16492198f, -0.12583211f, 
    0.02884231f, -0.01245384f, -0.12813219f, 0.04834786f, 0.07136758f, 0.03254703f, -0.01841397f, -0.08249222f, 
    -0.06880108f, 0.00976058f, -0.03561158f, 0.17792466f, -0.13155532f, -0.06076441f, 0.10101626f, -0.04080197f, 
    -0.04811210f, 0.47814605f, -0.07301401f, 0.00986914f, -0.05558174f, -0.04963910f, 0.03763801f, -0.08659787f, 
    -0.03441880f, 0.03333869f, -0.02358031f, -0.01648422f, 0.05565186f, -0.10201181f, -0.08520425f, 0.16109429f, 
    0.08984753f, -0.11900707f, 0.04687206f, 0.00780944f, 0.10087102f, -0.08541650f, -0.03410553f, -0.03698865f, 
    -0.34398869f, -0.32456678f, -0.21366802f, -0.04669026f, -0.08998604f, -0.08940592f, -0.00306569f, 0.17936493f, 
    0.10948546f, 0.00303206f, -0.29799265f, 0.08643605f, 0.04121528f, -0.10450315f, -0.04974551f, 0.13073376f, 
    -0.17501752f, -0.09364607f, -0.01931975f, 0.01888999f, -0.02620965f, 0.01382878f, 0.04066642f, 0.10625517f, 
    0.10018874f, -0.06544705f, -0.22696546f, -0.19012779f, 0.00372125f, 0.01990828f, 0.09876597f, -0.03820700f, 
    -0.01815688f, -0.04363187f, 0.14464536f, -0.08778252f, -0.28048056f, -0.10730069f, 0.03714639f, 0.15506241f, 
    -0.15488902f, 0.10366206f, -0.00694522f, 0.11461578f, -0.05182499f, 0.02706334f, 0.06076117f, 0.01482951f, 
    0.13717836f, -0.05029504f, -0.03769440f, -0.26461256f, -0.00725401f, 0.05294783f, -0.05213813f, -0.15474367f, 
    -0.14277989f, -0.14086966f, 0.18390036f, -0.22414589f, -0.44554392f, 0.25167188f, -0.31194067f, -0.32980120f, 
    -0.13149680f, -0.04491490f, -0.04390867f, -0.08359657f, -0.04049878f, 0.00304494f, -0.19533317f, -0.08409030f, 
    -0.28287429f, 0.09332614f, -0.06899861f, 0.00535934f, -0.07110900f, -0.18012154f, -0.20790148f, -0.06197780f, 
    -0.03479879f, -0.23134330f, -0.01135006f, -0.00641954f, -0.36440432f, -0.11593045f, -0.24403296f, -0.03586990f, 
    0.03539354f, -0.01264625f, 0.06661087f, 0.06277113f, 0.05124590f, -0.08300202f, 0.01685623f, 0.06109158f, 
    0.06220756f, 0.02487396f, -0.02431089f, 0.13276830f, -0.07339853f, 0.14789845f, 0.06033936f, 0.00849149f, 
    -0.03077943f, -0.04338299f, 0.04940860f, 0.07642836f, 0.05289080f, 0.13149689f, 0.15928754f, 0.04141707f, 
    0.16126654f, 0.10682493f, 0.06137283f, 0.15629137f, 0.01177839f, 0.00995354f, 0.02219745f, -0.05543799f, 
    0.16848329f, 0.17964263f, 0.07152261f, 0.16262931f, -0.03501623f, -0.01621750f, -0.05727620f, -0.01310684f, 
    0.06610562f, 0.07541364f, -0.03299905f, -0.10483903f, 0.13913211f, -0.01679842f, 0.14986387f, 0.11089664f, 
    0.00178521f, 0.00500548f, 0.06291641f, -0.07354149f, 0.13671838f, 0.06653352f, 0.03560060f, -0.00658006f, 
    0.16097046f, -0.31812304f, 0.11528309f, 0.01283841f, 0.04141995f, 0.01204801f, 0.07350958f, 0.01696017f, 
    0.11671127f, -0.14258258f, 0.17929207f, -0.25312141f, 0.01512910f, -0.10206167f, -0.05844954f, -0.22320186f, 
    -0.02001479f, -0.13897489f, -0.01191516f, 0.04683432f, -0.04143738f, 0.05972742f, -0.02512879f, 0.04114456f, 
    0.54598808f, -0.14123477f, -0.03580781f, 0.21018669f, -0.12093706f, 0.10727125f, 0.03386070f, -0.05250391f, 
    0.01803222f, 0.00016592f, 0.04404018f, 0.07150105f, 0.14804615f, 0.17580605f, 0.19151227f, 0.07200751f, 
    -0.16992678f, 0.04700035f, -0.05785982f, -0.08783267f, -0.04419651f, 0.01442919f, 0.02053683f, 0.00152546f, 
    0.33580318f, 0.04657437f, 0.23955421f, -0.01720315f, -0.01517461f, -0.12637120f, -0.03735224f, -0.05015625f, 
    0.01472044f, 0.04720603f, -0.07531940f, 0.06669728f, 0.10016853f, 0.09806014f, 0.10275224f, -0.00731918f, 
    0.07285431f, -0.04393739f, -0.08134071f, 0.04661643f, 0.03308572f, -0.00230401f, 0.04101706f, -0.07889169f, 
    0.07140857f, 0.08660082f, 0.04630017f, 0.07054581f, 0.07630950f, -0.05720475f, 0.02216960f, 0.00767734f, 
    -0.04726968f, -0.00253495f, -0.01039595f, 0.05648136f, 0.44699675f, 0.53311926f, 0.08647273f, -0.06274342f, 
    -0.01511246f, 0.08147938f, -0.04987377f, 0.07923578f, -0.04288269f, -0.00896093f, -0.03761318f, -0.15934707f, 
    0.36195302f, -0.05018027f, 0.08379932f, 0.03652780f, 0.02264300f, 0.03713145f, -0.06219485f, -0.05352454f, 
    -0.33802849f, -0.12058409f, -0.35270840f, -0.34384826f, -0.02730803f, -0.11306179f, 0.08258978f, -0.18944649f, 
    0.02550354f, 0.11718769f, -0.15611158f, 0.12999208f, 0.22896533f, 0.14370774f, -0.14834559f, 0.11782094f, 
    0.68056071f, -0.00901970f, -0.10915608f, -0.05188071f, -0.04542629f, -0.04355368f, -0.15570547f, 0.01442947f, 
    0.19575769f, -0.00810659f, -0.03107836f, 0.04478451f, 0.06552321f, 0.22090928f, 0.27954516f, -0.03621209f, 
    0.02253769f, -0.03784553f, 0.01922795f, -0.08138871f, -0.06927927f, 0.04993187f, -0.05033322f, -0.02474278f, 
    0.08941796f, -0.29279593f, 0.08021451f, -0.05397657f, 0.07594918f, 0.02008043f, 0.06011836f, -0.04667930f, 
    0.06128306f, -0.01557927f, -0.04763718f, 0.09673286f, -0.02781425f, 0.40018567f, 0.01825518f, 0.08132961f, 
    -0.06668191f, 0.00134560f, 0.01833375f, -0.03609224f, 0.15593210f, -0.05681523f, -0.02104501f, -0.02475970f, 
    0.06465481f, 0.06568392f, -0.07291189f, -0.08243051f, -0.06388307f, 0.00435178f, -0.00430748f, 0.09574927f, 
    0.05465629f, -0.07187362f, 0.15483764f, -0.17124645f, 0.08194888f, 0.17396635f, 0.09939679f, 0.07543705f, 
    0.08196212f, 0.02542772f, -0.16210952f, -0.18244880f, -0.08353098f, -0.07416827f, 0.01234721f, -0.00909604f, 
    -0.08869974f, -0.23791675f, 0.13071017f, -0.28211465f, -0.01699547f, -0.17726567f, -0.20671044f, -0.12760670f, 
    0.01222880f, 0.00961162f, -0.00714648f, 0.05783571f, -0.21334615f, 0.12800862f, 0.07732456f, -0.13993190f, 
    -0.01453935f, -0.05033083f, -0.06548764f, -0.08532954f, 0.03358281f, -0.05168481f, -0.00681483f, -0.06965414f, 
    -0.08001085f, -0.17945591f, 0.17196274f, -0.05959609f, -0.10738239f, 0.11347251f, 0.06597281f, 0.18390591f, 
    0.07715664f, -0.01080210f, 0.02020394f, 0.09392872f, 0.07802166f, -0.09193084f, -0.24148721f, -0.08720019f, 
    -0.10676727f, 0.00421406f, -0.02144421f, 0.01776291f, -0.04368414f, -0.20409921f, -0.24300310f, -0.09374462f, 
    0.07976940f, 0.07852092f, 0.10933758f, -0.08939307f, 0.14906478f, 0.06250833f, 0.08915017f, 0.05142083f, 
    0.05262600f, -0.01602829f, -0.04705724f, -0.07763378f, -0.74524009f, -0.18524320f, 0.05424475f, 0.06858317f, 
    0.14296097f, 0.14929885f, -0.01370332f, -0.07359607f, 0.21572773f, -0.05847267f, -0.01051653f, 0.02619908f, 
    0.33341607f, -0.05250828f, 0.07310306f, 0.20767152f, -0.04924077f, -0.04691838f, -0.00082644f, -0.02811830f, 
    -0.05107225f, 0.08987574f, -0.05177715f, 0.02171217f, 0.01942416f, -0.03425987f, 0.07031255f, -0.14284231f, 
    0.09780276f, 0.05250018f, -0.10708540f, 0.02251633f, 0.07507890f, -0.02210047f, 0.08265090f, 0.01996543f, 
    0.19130965f, -0.02081528f, 0.07025046f, -0.10221537f, -0.00527841f, 0.15757123f, 0.25388345f, -0.08947549f, 
    -0.00579579f, -0.01608218f, -0.01907766f, 0.08106647f, -0.05458442f, 0.09003456f, 0.05410490f, -0.04712833f, 
    0.08007862f, 0.00109084f, -0.04836229f, 0.00248492f, 0.09419229f, 0.10112833f, -0.36720654f, -0.06737918f, 
    -0.05495504f, -0.07851372f, -0.11945283f, -0.04945633f, -0.06465326f, -0.12944630f, -0.06539385f, 0.11123417f, 
    -0.08058308f, -0.06341487f, 0.05823261f, 0.00058631f, -0.72042263f, -0.04330953f, -0.06593490f, -0.24292736f, 
    0.07547399f, -0.03729415f, 0.02056404f, 0.19608228f, -0.07426673f, 0.07835231f, 0.21859729f, -0.02120392f, 
    -0.38452131f, 0.02564375f, -0.28348634f, 0.03921011f, 0.05923324f, -0.01197982f, 0.09331114f, 0.09567505f, 
    -0.07462630f, 0.01314401f, -0.06048779f, 0.06311789f, 0.36521870f, -0.31472695f, -0.15988080f, -0.14606653f, 
    0.06186740f, -0.01006325f, 0.02355051f, 0.02813782f, 0.09752189f, 0.21973805f, -0.03426565f, -0.01823183f, 
    0.01792920f, -0.01139400f, 0.10598430f, 0.01513519f, 0.03872598f, -0.02942868f, -0.00532050f, -0.02682449f, 
    -0.34150612f, -0.16461970f, -0.21024173f, -0.19723733f, 0.50778383f, -0.35674968f, 0.03986987f, -0.20631270f, 
    0.03497475f, -0.02902703f, -0.05006481f, 0.06038904f, 0.05398076f, -0.06768608f, -0.03902035f, 0.03346270f, 
    -0.16259854f, 0.06653546f, -0.04857171f, 0.07423617f, 0.08232651f, -0.01038777f, 0.08443409f, 0.00515202f, 
    -0.08712724f, -0.02650813f, 0.00078937f, 0.02978193f, -0.00370260f, -0.01371909f, 0.10879919f, -0.06895855f, 
    0.08111808f, 0.05130219f, -0.22372305f, -0.20486389f, 0.03170432f, 0.02305830f, 0.07304274f, -0.19152872f, 
    -0.16356689f, -0.02521364f, 0.22138649f, -0.20292044f, -0.14508693f, 0.02475092f, 0.24733332f, -0.05611240f, 
    -0.10671939f, -0.02193949f, 0.07925931f, -0.00524268f, 0.14443420f, 0.09120568f, 0.05405748f, -0.00018780f, 
    -0.01626787f, -0.01593870f, -0.03405915f, -0.02621387f, 0.04493665f, -0.01206242f, 0.03977722f, -0.08873171f, 
    -0.14374720f, -0.02474055f, -0.08986102f, -0.11440392f, -0.05364367f, 0.03686849f, 0.03146007f, -0.02637727f, 
    0.03956766f, 0.02037792f, 0.02248964f, -0.02211044f, 0.01625285f, 0.29711473f, 0.11810907f, 0.07567396f, 
    0.04339546f, 0.02199238f, -0.06350269f, -0.01883969f, -0.02364078f, 0.14321639f, 0.12885173f, 0.02491473f, 
    0.32786366f, -0.37714142f, 0.00819063f, -0.11142515f, 0.06713152f, -0.02853432f, -0.01483550f, -0.07672289f, 
    0.04150186f, 0.01725547f, -0.04220767f, 0.00617778f, 0.56020224f, -0.00138760f, 0.19046570f, -0.12366901f, 
    0.04130761f, -0.06460065f, 0.03737357f, -0.04336248f, 0.05424326f, 0.05076105f, -0.17350061f, 0.04000975f, 
    0.21668379f, 0.00408504f, 0.06298161f, 0.00954473f, 0.00804289f, -0.10947982f, -0.08153854f, 0.07632563f, 
    0.10338075f, 0.10333666f, -0.00556282f, -0.16540506f, 0.01043392f, 0.03766564f, 0.12662065f, -0.04060322f, 
    0.00799314f, -0.02973549f, 0.04747169f, -0.13341954f, 0.14586648f, 0.01312631f, 0.11163931f, 0.15441605f, 
    0.40450275f, -0.02992892f, 0.48203361f, 0.34877658f, 0.12122118f, -0.02925207f, -0.07072818f, 0.15338480f, 
    0.07896636f, -0.06904959f, 0.08387863f, -0.03274526f, -0.04830382f, -0.03558316f, 0.04416427f, -0.05170577f, 
    0.04171110f, 0.00410147f, 0.02531959f, 0.00395266f, 0.00893476f, -0.02268283f, -0.05236622f, -0.00636335f, 
    0.02170916f, -0.00763923f, -0.02538463f, -0.03293434f, 0.08713651f, 0.08782588f, -0.03544607f, -0.14898793f, 
    0.06675735f, 0.11598188f, 0.04432273f, 0.05290832f, -0.33468097f, -0.49774069f, -0.26295969f, -0.23796628f, 
    0.13436121f, 0.02677223f, -0.11962948f, -0.04976127f, -0.00343532f, -0.01004467f, 0.00456365f, -0.05330117f, 
    -0.08440542f, -0.11596873f, 0.22409974f, -0.18380301f, 0.00732699f, 0.03276212f, -0.03960088f, 0.05824933f, 
    -0.01746087f, -0.05106296f, 0.02969569f, -0.09239382f, -0.03430833f, 0.07738209f, -0.01045459f, -0.19886404f, 
    -0.09570587f, 0.04752607f, -0.00682364f, 0.05189865f, 0.00508017f, -0.00447739f, 0.01574849f, -0.12771894f, 
    0.00165185f, -0.11096448f, 0.08268934f, 0.04446686f, -0.01098722f, 0.02816778f, -0.05711271f, 0.03355033f, 
    -0.02543833f, 0.07269942f, -0.12967432f, 0.00513029f, -0.25113630f, -0.04651851f, 0.00273025f, 0.03211743f, 
    -0.03510778f, -0.03275011f, -0.11377970f, -0.09412085f, 0.05975312f, -0.17516916f, 0.01364606f, 0.01482794f, 
    -0.29501790f, 0.19033274f, -0.07488167f, 0.17083144f, 0.04727235f, 0.00795601f, -0.01089838f, 0.06015167f, 
    0.04806818f, -0.02194322f, 0.00835721f, 0.01176408f, -0.08098653f, -0.18428133f, -0.02017115f, 0.20579357f, 
    -0.02683676f, 0.05024929f, -0.20551614f, 0.03884434f, -0.01968457f, 0.00074914f, 0.00904448f, -0.25245047f, 
    0.16024444f, -0.05170194f, -0.17515731f, -0.15780994f, 0.10566723f, -0.07176908f, -0.09070627f, 0.07460000f, 
    -0.01229962f, 0.02245990f, -0.18722317f, 0.08350507f, -0.72174758f, -0.51466864f, -0.13183516f, -0.39947671f, 
    0.03459860f, -0.04340100f, -0.01040080f, -0.08325578f, 0.01210603f, -0.06343836f, -0.03511807f, 0.02513229f, 
    0.07178017f, -0.14629969f, 0.26035875f, 0.05264280f, 0.07896864f, 0.02136280f, -0.05335457f, 0.10440553f, 
    -0.05669185f, -0.16427024f, -0.08520377f, 0.18235224f, -0.52785939f, -0.53998554f, -0.41899070f, -0.02091355f, 
    0.15111260f, -0.03049550f, 0.06936307f, -0.05158918f, 0.05083923f, -0.00522795f, 0.00389896f, 0.01986462f, 
    0.01730704f, 0.15006559f, 0.13748141f, -0.11064544f, -0.08360533f, -0.03627196f, -0.03209577f, 0.01853455f, 
    -0.07848059f, 0.00539364f, 0.08153749f, 0.08822174f, -0.54067224f, 0.59544533f, 0.29610780f, 0.06422453f, 
    -0.03141823f, 0.07943542f, -0.13281666f, -0.03732819f, 0.05452557f, -0.02708706f, -0.04688266f, -0.16492882f, 
    -0.05752230f, -0.11308109f, 0.00687473f, 0.10382727f, 0.00813211f, 0.06409518f, -0.07422774f, 0.13425779f, 
    0.07562043f, 0.02937413f, 0.08134767f, -0.07272724f, -0.06184532f, -0.11914732f, -0.09443266f, 0.12368791f, 
    0.04398551f, -0.03426870f, -0.02315104f, -0.00574457f, 0.01669628f, 0.03184411f, -0.04208791f, 0.02370782f, 
    0.02360822f, -0.15712360f, -0.08165513f, 0.02807110f, 0.11416238f, 0.02160241f, -0.11460309f, 0.14691883f, 
    -0.02984985f, -0.10584433f, 0.19994584f, 0.18127292f, -0.46741480f, -0.16519283f, -0.11903203f, -0.03278486f, 
    -0.01101394f, -0.11894585f, -0.06036544f, -0.08125111f, -0.06644121f, -0.03391234f, -0.02045265f, -0.03812791f, 
    -0.06151951f, -0.02998847f, -0.01408773f, -0.09307205f, -0.05360713f, -0.01520694f, -0.01150681f, 0.03668284f, 
    -0.06758188f, -0.02626015f, -0.07563827f, 0.09261308f, 0.13207243f, -0.08533108f, -0.03866490f, -0.03044374f, 
    -0.01086807f, 0.01859058f, -0.04498576f, 0.02552311f, -0.06590106f, 0.05363495f, -0.02022511f, 0.09961440f, 
    -0.10235520f, -0.01459642f, 0.42146984f, 0.22613782f, 0.02687221f, 0.00977975f, -0.02062585f, 0.10590680f, 
    0.02018140f, -0.06430482f, 0.10568393f, -0.03778251f, -0.21799412f, -0.12746432f, 0.17313196f, -0.20061417f, 
    0.02844051f, -0.07755731f, -0.30529335f, -0.29106405f, 0.02843671f, 0.03022630f, -0.03587243f, 0.07652687f, 
    -0.05756227f, -0.17726411f, 0.00345706f, 0.02216328f, -0.08883651f, -0.01503911f, -0.08842218f, 0.02857284f, 
    -0.02006372f, -0.02715821f, -0.05946805f, -0.01649535f, -0.85847354f, -0.45082021f, -0.32416511f, -0.25112972f, 
    0.04949931f, 0.09077088f, 0.02607694f, -0.04017523f, -0.03969654f, -0.02483683f, 0.00866260f, -0.01870989f, 
    -0.18989719f, -0.29017258f, -0.10252505f, -0.27611807f, -0.04821820f, -0.03771516f, -0.02588956f, -0.08745896f, 
    0.01123532f, -0.01963253f, -0.11877515f, 0.09193178f, -0.11746644f, -0.00111210f, 0.06287195f, -0.09881693f, 
    0.02249705f, 0.04709379f, -0.20158008f, 0.02985198f, -0.02454156f, -0.03722833f, -0.01278984f, 0.04642035f, 
    -0.19297114f, -0.19876188f, 0.06280955f, -0.15881652f, -0.01571579f, -0.03396344f, 0.01923667f, 0.08593228f, 
    0.02798788f, -0.02961694f, 0.03717376f, -0.03196091f, -0.15011320f, 0.46928921f, 0.54257482f, 0.66459239f, 
    -0.02697292f, 0.02264008f, -0.03399942f, 0.13915864f, -0.02490335f, 0.00455442f, -0.00556825f, 0.01863874f, 
    -0.08127519f, 0.07553425f, 0.03577304f, -0.00403950f, 0.00631455f, -0.04014076f, -0.00097799f, -0.04662520f, 
    0.16437799f, 0.23179661f, 0.12001227f, 0.09391632f, -0.09584899f, 0.00670335f, 0.10115644f, -0.05308532f, 
    0.08894409f, -0.00882237f, -0.19210821f, -0.05608897f, 0.09954862f, 0.10879514f, -0.03153243f, 0.13674624f, 
    -0.38311344f, -0.05211711f, -0.20922948f, -0.29791442f, 0.06102750f, -0.01754952f, 0.03315386f, -0.33640540f, 
    0.02316546f, -0.02228273f, 0.07110861f, -0.07039206f, -0.00682568f, -0.10063096f, 0.24503952f, 0.03045158f, 
    0.03650710f, 0.05998527f, 0.01245115f, 0.02798452f, 0.00127018f, -0.06897044f, 0.06173471f, -0.05845229f, 
    -0.42864731f, 0.23825648f, 0.05429427f, 0.17365351f, -0.12531723f, 0.05473433f, 0.02505071f, -0.08717146f, 
    -0.03582733f, -0.06108796f, -0.04083523f, -0.09069014f, 0.00916357f, 0.22928607f, -0.33845514f, -0.27303421f, 
    0.03481258f, 0.02369720f, 0.01074807f, 0.10623399f, -0.05551884f, -0.02124634f, 0.03417683f, -0.02100381f, 
    -0.09908799f, 0.14525792f, -0.19538786f, 0.02737673f, 0.04574133f, -0.03341479f, -0.02002493f, 0.00590255f, 
    -0.05332729f, -0.02525836f, 0.05014477f, -0.07317169f, 0.28109804f, 0.13011952f, 0.15573466f, 0.42741835f, 
    -0.16984028f, 0.13027182f, 0.03060487f, 0.03188907f, 0.01680937f, 0.01289881f, 0.00941850f, 0.04526410f, 
    -0.09366436f, 0.03144642f, 0.08107775f, -0.16649757f, 0.14041896f, 0.03850031f, 0.04083871f, -0.11814164f, 
    -0.01263867f, 0.02429266f, 0.05697082f, -0.03664227f, -0.23688860f, 0.01068314f, -0.09087388f, 0.06157767f, 
    -0.01590213f, 0.06230262f, 0.01745708f, -0.08430011f, 0.03213910f, -0.03296026f, -0.01610825f, -0.00964361f, 
    -0.48264039f, -0.38226372f, -0.01827734f, -0.35468790f, 0.10548247f, -0.15149091f, 0.04100413f, -0.09137346f, 
    -0.06857824f, -0.01861069f, -0.04609379f, -0.03046464f, 0.03802555f, 0.07991262f, 0.25717333f, 0.05989176f, 
    0.02427613f, -0.04532916f, -0.01673482f, 0.01046299f, 0.02275504f, 0.03582439f, 0.02944929f, 0.03711234f, 
    -0.04849105f, 0.03099467f, 0.02713037f, -0.04856098f, 0.04179114f, 0.14562505f, -0.03561843f, 0.13146146f, 
    0.03152869f, 0.06187534f, -0.00136771f, 0.02047190f, 0.10850256f, -0.21057028f, -0.08769162f, 0.11956479f, 
    0.05400706f, 0.06106969f, 0.06582161f, -0.11838092f, -0.12931421f, -0.04110358f, 0.08391861f, -0.03852053f, 
    -0.00088375f, -0.19379656f, 0.01155599f, -0.12287776f, 0.03610134f, 0.03599988f, -0.00203259f, -0.01227661f, 
    0.01262468f, -0.12268851f, -0.02760055f, 0.24076079f, -0.18168727f, 0.02021726f, 0.00843610f, 0.17482114f, 
    -0.04918062f, 0.02571434f, 0.08409224f, -0.20395735f, -0.05899812f, 0.07765011f, 0.00763603f, -0.01892343f, 
    -0.40789866f, 0.12344170f, 0.11515254f, 0.10688199f, -0.12201504f, 0.08641271f, 0.09979744f, -0.08303387f, 
    0.02328100f, 0.01505049f, -0.01764517f, -0.00306810f, 0.02593470f, 0.05043117f, -0.00392200f, 0.06520147f, 
    -0.02507829f, -0.00089915f, 0.01032864f, -0.06901770f, 0.08310893f, 0.03472385f, 0.07600064f, 0.17867555f, 
    0.06601036f, -0.08616079f, -0.12144361f, -0.00985966f, 0.13382916f, -0.10484313f, 0.07107702f, -0.10691189f, 
    0.05777494f, -0.03010200f, -0.01973320f, 0.04689500f, 0.14329609f, -0.11783109f, -0.09765998f, 0.26586175f, 
    0.00958437f, 0.04692543f, -0.04632420f, -0.09666017f, -0.01577923f, -0.04721002f, -0.08606036f, 0.02846406f, 
    -0.04347855f, -0.01395677f, -0.31198615f, 0.02582964f, 0.03165618f, 0.01802025f, 0.05698667f, 0.02828501f, 
    0.00093185f, -0.06310188f, -0.01614778f, -0.03234211f, -0.14108160f, 0.33757761f, 0.10498855f, 0.13899305f, 
    -0.02485837f, 0.00973746f, 0.01574615f, -0.12028085f, -0.09764014f, -0.01564307f, -0.15672643f, 0.11688417f, 
    -0.01569510f, -0.05719421f, -0.08754542f, 0.06569168f, 0.00316050f, -0.03142339f, 0.00852147f, 0.04671019f, 
    0.00601825f, 0.03321370f, 0.19126303f, 0.12381878f, -0.03670554f, -0.05431381f, 0.00213816f, -0.40142387f, 
    0.03022649f, -0.02272136f, 0.02023314f, -0.01949876f, -0.02629380f, 0.05189401f, -0.03394030f, -0.04849962f, 
    -0.05184124f, -0.02950630f, -0.07095443f, 0.09055198f, -0.22051753f, -0.03534920f, 0.04962054f, -0.04026441f, 
    -0.04196843f, 0.08618497f, 0.05483661f, 0.08445197f, 0.01491725f, 0.30144343f, 0.00584099f, 0.02955674f, 
    0.03071284f, -0.01075693f, 0.20179830f, -0.15088221f, 0.01115448f, 0.02583232f, 0.02014801f, 0.01889991f, 
    -0.02665924f, 0.07009919f, 0.37427711f, 0.12908745f, -0.10351635f, -0.13551484f, 0.24174188f, -0.05349186f, 
    0.04464603f, -0.07159913f, 0.05193462f, -0.12075955f, -0.18704467f, -0.25418583f, 0.38809714f, 0.02627970f, 
    0.00938745f, 0.02123798f, 0.06201558f, 0.03033659f, -0.10413565f, 0.01338015f, -0.07024971f, 0.02387297f, 
    -0.03094933f, -0.06499237f, -0.06915141f, 0.03913243f, 0.00392372f, 0.02862374f, -0.03889918f, -0.19091101f, 
    -0.03783461f, 0.00838017f, 0.08467451f, -0.02178572f, -0.14250360f, 0.01178010f, -0.08393366f, -0.02404286f, 
    -0.02499825f, 0.01991532f, 0.02407691f, 0.04867037f, 0.02499172f, -0.08497433f, 0.06072775f, -0.03127451f, 
    0.04968283f, 0.23523791f, 0.17231025f, -0.29173294f, 0.05346037f, -0.11425027f, -0.16912970f, 0.00792587f, 
    0.05679985f, -0.06156455f, -0.00505315f, 0.01019856f, -0.29405648f, -0.38204977f, 0.49465945f, 0.35807747f, 
    0.01278247f, 0.01173795f, -0.10863246f, 0.05390311f, 0.05284278f, -0.03029080f, 0.06642727f, -0.16434970f, 
    0.17209427f, -0.00945324f, 0.24876325f, 0.19852211f, -0.09719265f, 0.11111885f, -0.10424364f, -0.17765372f, 
    -0.05734769f, -0.02429621f, 0.02328646f, -0.19102433f, 0.07338907f, 0.00443829f, 0.12698300f, -0.00044602f, 
    -0.09759206f, 0.11935358f, -0.08890054f, -0.04725397f, -0.06622607f, -0.12976333f, 0.01796318f, 0.02173987f, 
    -0.13203864f, 0.18875340f, 0.05578876f, 0.08864026f, 0.08436994f, 0.06149804f, -0.13025209f, 0.05582919f, 
    -0.29907072f, 0.11121513f, 0.01466855f, -0.04354757f, -0.20472372f, -0.04883643f, -0.26271570f, -0.22716914f, 
    -0.01957621f, -0.12153407f, -0.10942847f, -0.20544764f, -0.01165042f, 0.09202990f, 0.06035154f, -0.09216643f, 
    -0.04613338f, -0.11951690f, -0.04863875f, 0.06913929f, 0.05038556f, 0.14173391f, -0.08017964f, -0.11812312f, 
    -0.05300409f, -0.03815075f, -0.09398393f, 0.11460966f, -0.02825510f, -0.05933138f, -0.00832860f, 0.07759430f, 
    0.04477566f, 0.09974872f, -0.05069886f, -0.07090513f, 0.00589253f, -0.05590419f, -0.02517031f, -0.04247560f, 
    -0.05136949f, 0.03634772f, 0.04084958f, 0.02031354f, -0.09177151f, 0.13490488f, -0.12810971f, 0.02085457f, 
    -0.03051498f, 0.08529265f, 0.09166218f, 0.00024288f, -0.03640105f, 0.21601535f, 0.29786253f, -0.49640185f, 
    -0.31011525f, -0.02753585f, -0.20745081f, -0.06692379f, 0.05858562f, -0.10614538f, 0.05199312f, 0.15083247f, 
    -0.05622608f, -0.19975379f, -0.04034697f, 0.10867278f, -0.05147561f, -0.06726528f, 0.02670442f, -0.07146910f, 
    0.03206291f, 0.04798853f, -0.17891212f, 0.19139646f, -0.04632279f, 0.10355799f, 0.04419010f, 0.11383609f, 
    -0.08345330f, 0.09651663f, 0.04500216f, -0.21991353f, 0.02035819f, 0.08707244f, 0.22138026f, -0.17979118f, 
    -0.04405192f, -0.00612980f, 0.02324010f, 0.18897739f, -0.10287242f, -0.10085872f, -0.07046736f, -0.06929124f, 
    -0.04370642f, -0.04374672f, 0.05597860f, -0.00507795f, -0.07757913f, 0.26607788f, -0.28096932f, 0.20197839f, 
    0.05630028f, -0.02199156f, 0.02135548f, 0.00728820f, 0.11539723f, 0.13369486f, -0.06185999f, 0.00817949f, 
    -0.03163340f, 0.04420680f, -0.17210561f, -0.04596764f, -0.02234210f, -0.02551589f, 0.06652778f, -0.08541092f, 
    -0.09453016f, -0.07500163f, -0.06190521f, 0.03409244f, 0.00198066f, -0.16806917f, 0.04190271f, 0.23697332f, 
    -0.01184232f, 0.04932105f, 0.07565412f, 0.04697917f, 0.00334427f, 0.08621700f, -0.15418635f, -0.00555138f, 
    0.02201772f, -0.16151813f, -0.04074874f, -0.05524630f, 0.08161558f, 0.04496734f, -0.01866229f, -0.20003881f, 
    0.00196517f, 0.05659769f, -0.02790599f, 0.05063541f, 0.01362473f, -0.16549948f, -0.18734756f, 0.05615566f, 
    0.13468137f, 0.08361890f, 0.05431869f, 0.12227221f, -0.01040919f, -0.04873119f, 0.10152615f, -0.09409197f, 
    -0.47207618f, -0.13065015f, -0.05791578f, 0.10235988f, -0.10014901f, -0.01057781f, 0.01478751f, -0.13682160f, 
    0.10228790f, -0.06519190f, 0.03878143f, -0.00953657f, 0.82896751f, -0.07015114f, -0.10266767f, 0.27132982f, 
    0.27299020f, 0.17019831f, 0.03493689f, 0.15336289f, -0.00434748f, 0.02992156f, 0.15338139f, 0.05206720f, 
    0.18494929f, 0.11722264f, -0.22392251f, 0.00168878f, 0.03526285f, -0.04154195f, -0.02841147f, 0.02512073f, 
    0.01572288f, -0.03725193f, -0.01745678f, 0.05104281f, 0.07689141f, -0.04975481f, -0.10578179f, 0.06040964f, 
    -0.03216548f, -0.04625453f, -0.05765656f, 0.14549044f, -0.04904553f, 0.07132390f, 0.04910086f, -0.04376904f, 
    -0.04860075f, -0.03412658f, -0.10546380f, -0.11748227f, -0.00046842f, 0.02460213f, -0.30055162f, -0.11501808f, 
    -0.08237920f, -0.06567289f, -0.00936663f, -0.20511712f, 0.00192211f, -0.15955612f, -0.10691228f, 0.01695370f, 
    -0.00512586f, 0.00454436f, -0.03288307f, 0.01516037f, -0.04938838f, 0.00219560f, -0.02383929f, -0.03584708f, 
    -0.61803514f, -0.33892518f, -0.51523310f, -0.03427166f, 0.17973110f, -0.16686726f, -0.20318504f, -0.06329572f, 
    -0.05390070f, -0.14877182f, 0.08595394f, 0.02351875f, 0.13926065f, -0.03867316f, -0.06322780f, -0.13695046f, 
    -0.04923652f, -0.13429044f, 0.03963990f, -0.00774410f, -0.11972605f, -0.16219969f, 0.01683260f, -0.10071652f, 
    -0.19901828f, 0.39668557f, -0.28405038f, -0.17260173f, 0.23909704f, 0.11343040f, -0.08434830f, -0.00474253f, 
    -0.25801080f, -0.11206894f, -0.02427924f, 0.00811837f, 0.03175065f, -0.28096989f, 0.37441149f, 0.14235005f, 
    -0.14343771f, 0.07710267f, 0.06740829f, 0.05953694f, 0.09887303f, 0.02054330f, 0.06239788f, 0.05863522f, 
    -0.58441889f, 0.61486971f, -0.16843286f, 0.23989204f, 0.12849407f, -0.08473378f, 0.10138487f, -0.18255033f, 
    -0.15065409f, -0.10156786f, 0.15306050f, -0.04789824f, -0.05724365f, -0.13084465f, 0.01429547f, 0.11515751f, 
    0.00059529f, -0.04476355f, 0.03677597f, 0.06196019f, -0.00465841f, -0.00698419f, 0.00209107f, -0.02556237f, 
    -0.40444234f, -0.23857713f, 0.65844280f, 0.22136310f, -0.18622150f, -0.23515546f, -0.08913546f, -0.07343734f, 
    0.02997978f, -0.06847434f, -0.07463562f, 0.11978240f, -0.36831504f, 0.05395017f, 0.23662272f, -0.19991651f, 
    -0.03128397f, 0.00482249f, -0.05265482f, 0.03252010f, 0.16483390f, -0.06656537f, 0.10292808f, -0.06723244f, 
    -0.07503258f, -0.05293863f, 0.01106576f, -0.10360099f, -0.02659719f, 0.25893715f, -0.01685909f, -0.17543916f, 
    0.03658402f, -0.01587455f, -0.13645285f, 0.14847130f, 0.28823438f, -0.21368580f, 0.02966740f, 0.14993204f, 
    0.06954410f, 0.03614506f, 0.04488525f, 0.00183584f, 0.08114450f, 0.06685731f, 0.08480512f, 0.14176804f, 
    -0.16575202f, 0.35176998f, -0.09166273f, 0.12458080f, 0.03489964f, 0.02251834f, -0.03998679f, -0.03554482f, 
    -0.00687928f, 0.21033958f, -0.10538303f, 0.00535485f, -0.14788634f, -0.15099815f, 0.05652859f, 0.00044762f, 
    -0.04032621f, 0.17031784f, -0.05798534f, -0.04373727f, -0.10237278f, -0.11388335f, -0.02991179f, -0.03026458f, 
    0.10484415f, 0.42470202f, 0.07229163f, 0.51622576f, 0.21310897f, 0.08562538f, 0.09592620f, 0.06153080f, 
    0.11913831f, 0.16226263f, -0.00510233f, -0.04211193f, 0.31641752f, 0.10205644f, -0.30004632f, 0.02225082f, 
    -0.06101402f, -0.05917351f, -0.17050536f, 0.05473503f, -0.04863211f, -0.06729278f, 0.20365398f, -0.01862541f, 
    -0.11625632f, -0.01538323f, -0.21608242f, 0.13627033f, -0.11819844f, -0.02675058f, -0.05546986f, -0.06461900f, 
    -0.04945147f, 0.13049234f, -0.04720953f, -0.04291773f, -0.26245102f, 0.43302611f, -0.21295542f, -0.15235433f, 
    -0.10230389f, -0.14550561f, 0.09881794f, -0.07867020f, 0.03766046f, 0.03326184f, 0.00890711f, -0.10249976f, 
    -0.51923329f, 0.51160312f, -0.21202445f, 0.26747605f, 0.06609908f, -0.14072548f, -0.03279794f, 0.06820309f, 
    0.07669545f, -0.11724228f, 0.00260483f, 0.07918906f, 0.18320912f, -0.28012115f, 0.02551205f, 0.24352397f, 
    -0.00877565f, -0.03481277f, -0.15991308f, -0.12698822f, -0.06387540f, 0.12712641f, -0.06287149f, 0.06220333f, 
    0.02315211f, -0.03815712f, 0.00001895f, 0.15817374f, 0.00897540f, -0.02423163f, -0.02248445f, 0.02882739f, 
    -0.06997302f, 0.05714808f, -0.08989754f, 0.07297172f, -0.11124451f, -0.10148658f, 0.04662449f, -0.12725285f, 
    -0.15309002f, -0.13596874f, -0.03810772f, 0.08520690f, -0.11532947f, 0.00525702f, 0.00830981f, -0.13702011f, 
    -0.03238542f, -0.12258235f, -0.09754164f, 0.18775839f, 0.13632283f, -0.00127204f, 0.09564134f, 0.11749234f, 
    -0.02446224f, -0.07855798f, 0.08469082f, -0.05460251f, -0.19788238f, 0.14583936f, -0.16648573f, 0.08637139f, 
    0.11470648f, 0.04088440f, 0.09906875f, -0.08722601f, -0.14383474f, -0.00016381f, -0.07262854f, -0.02541961f, 
    -0.14486930f, -0.20977092f, 0.06964786f, -0.11755990f, -0.17296641f, -0.02445059f, -0.19188443f, -0.05567614f, 
    -0.02723666f, -0.20243829f, -0.06901391f, -0.13647300f, 0.44881672f, 0.29352528f, -0.38236150f, -0.35173967f, 
    -0.15221836f, 0.09481697f, -0.06623963f, -0.26011989f, -0.14060570f, -0.17102481f, 0.07664022f, 0.05060290f, 
    -0.06577522f, 0.16116755f, 0.00225761f, 0.29085240f, 0.13939984f, 0.22278978f, -0.20288672f, 0.06050905f, 
    -0.09686457f, -0.29573086f, 0.17306028f, 0.15788810f, -0.02977357f, -0.07991202f, -0.06808993f, 0.09335175f, 
    -0.01567263f, 0.07889964f, 0.11294362f, 0.11508148f, -0.03724200f, 0.12324482f, 0.04605095f, -0.01717237f, 
    -0.16839589f, -0.10930643f, 0.09763978f, 0.12386610f, -0.11843809f, -0.06729708f, 0.05117426f, 0.00309941f, 
    -0.06707445f, -0.02301657f, -0.09728689f, -0.14295696f, 0.03593129f, -0.02199325f, -0.16895333f, 0.01888413f, 
    -0.09133193f, -0.00451535f, -0.16945423f, -0.01667147f, -0.04068920f, -0.00847661f, 0.07674316f, 0.00036252f, 
    0.10218303f, 0.05131972f, -0.00323801f, -0.14775753f, 0.06966399f, 0.16708642f, -0.08175077f, -0.04036446f, 
    0.15915368f, -0.15841460f, 0.12099855f, -0.12110677f, 0.30395427f, 0.10628489f, -0.01423292f, -0.14773175f, 
    -0.05752498f, -0.11785480f, -0.05871084f, -0.16262934f, 0.04280818f, -0.05838007f, -0.07939119f, 0.09472609f, 
    -0.02449982f, -0.07493839f, -0.17297745f, 0.02851417f, 0.02865225f, 0.02936284f, 0.03580758f, 0.17103033f, 
    -0.11315737f, 0.03145960f, -0.07958959f, -0.03151421f, -0.41096574f, -0.07658188f, 0.02382036f, 0.21446860f, 
    -0.06777113f, -0.05576005f, -0.09157716f, -0.13125709f, 0.02102218f, 0.00212350f, -0.06646860f, 0.12431964f, 
    0.02459089f, 0.07446244f, -0.22144952f, -0.22597881f, 0.06225036f, 0.05961823f, 0.00518288f, -0.11765109f, 
    0.10746686f, 0.24110593f, -0.25349578f, -0.19824132f, -0.12876092f, 0.19499470f, 0.05291921f, 0.20863803f, 
    -0.01274617f, 0.07934209f, 0.08046728f, 0.03332225f, -0.03324056f, -0.04798980f, 0.05104190f, -0.00049876f, 
    0.11861377f, -0.24666548f, 0.03989458f, -0.41645542f, -0.00678976f, -0.06135821f, -0.16920201f, 0.03641798f, 
    -0.05260711f, 0.01944085f, -0.02462120f, -0.20634335f, 0.23381574f, -0.14811146f, 0.13223183f, 0.28992072f, 
    0.04278303f, 0.06677667f, 0.01270772f, -0.07295122f, 0.02513814f, 0.13680126f, -0.01621843f, 0.15810108f, 
    -0.11250014f, -0.00420487f, 0.08072316f, 0.15237376f, 0.10391527f, 0.05967373f, 0.01628204f, 0.00003905f, 
    0.07547388f, 0.01359190f, 0.10070564f, -0.05957293f, 0.27878615f, 0.00650898f, -0.26610592f, -0.06222617f, 
    0.26530963f, 0.10711415f, 0.22891700f, -0.13281839f, -0.25004295f, -0.02304956f, -0.04475630f, -0.02267757f, 
    0.02893234f, -0.07857104f, -0.05446872f, 0.14782025f, -0.02602176f, 0.16267341f, -0.05669758f, 0.05317819f, 
    -0.03341633f, -0.02544560f, -0.03594699f, -0.05109559f, -0.10671629f, -0.05248951f, -0.13765910f, -0.23341376f, 
    -0.22520325f, 0.08178809f, -0.05586705f, -0.01943304f, 0.09015483f, 0.05492742f, -0.05638511f, -0.00514614f, 
    0.02404696f, -0.08841148f, -0.14861025f, 0.41133675f, 0.00194606f, -0.00024254f, -0.24694575f, -0.03594422f, 
    -0.11094288f, -0.01110533f, 0.10102104f, -0.19595057f, 0.09386092f, -0.05383412f, -0.11862564f, -0.03329393f, 
    0.15746482f, 0.09926226f, 0.02369981f, -0.05123624f, -0.02785887f, 0.10115537f, 0.00162979f, 0.10090991f, 
    0.04830545f, 0.04629482f, -0.12417752f, 0.02771378f, -0.01520284f, 0.02649329f, -0.11034069f, -0.23368657f, 
    -0.01477870f, 0.01021985f, -0.09913371f, 0.03442656f, -0.09531668f, -0.02089902f, -0.09645412f, 0.02845105f, 
    0.06104298f, 0.05304857f, -0.06992774f, -0.18075041f, 0.00728827f, -0.20998119f, 0.01156167f, 0.05673784f, 
    0.01645331f, -0.16314662f, -0.03447943f, 0.02256185f, -0.04127503f, -0.12900864f, 0.06521852f, -0.24268192f, 
    -0.03060233f, -0.01907887f, -0.02174296f, 0.00072800f, 0.07612066f, 0.01888342f, -0.07985884f, 0.04080363f, 
    0.08682775f, 0.03218147f, -0.01829357f, 0.00762135f, -0.17435805f, -0.19296904f, 0.07736478f, -0.17372504f, 
    0.02254964f, 0.08433525f, 0.03599084f, 0.11563922f, 0.00229890f, -0.04692114f, -0.10231315f, 0.03379469f, 
    0.00696517f, 0.03479232f, 0.02522826f, -0.05489253f, 0.06127337f, 0.11296580f, 0.12677225f, 0.11467697f, 
    -0.04572850f, -0.15706830f, 0.07033246f, 0.08033792f, 0.06415610f, -0.02332971f, 0.00638424f, -0.01423519f, 
    -0.03905088f, -0.07492692f, -0.54602855f, -0.29162434f, 0.12978891f, 0.01053516f, 0.07373533f, 0.04087860f, 
    0.03909126f, -0.01561483f, -0.05924274f, -0.08585654f, 0.01363691f, -0.04835415f, -0.10887807f, 0.08815102f, 
    0.03892048f, -0.01048591f, 0.05689360f, 0.06339578f, 0.06548183f, 0.01273021f, -0.06742629f, -0.07749501f, 
    -0.00788148f, 0.02490091f, -0.05247936f, 0.05314945f, 0.05361228f, 0.07398469f, 0.04579884f, -0.09528299f, 
    -0.07192218f, -0.06218259f, 0.00622900f, -0.11023069f, 0.09166743f, 0.06664934f, 0.13372225f, 0.01140138f, 
    0.09727266f, 0.08995810f, 0.11055598f, 0.05766125f, -0.01445900f, -0.15243630f, -0.10736440f, 0.00487757f, 
    -0.06972416f, -0.19762225f, 0.35246766f, 0.33041748f, -0.01807009f, 0.03788573f, 0.00431288f, 0.10733213f, 
    0.03804130f, -0.04904130f, -0.02346059f, -0.02979489f, 0.01983918f, -0.11636046f, 0.09051844f, -0.18525603f, 
    -0.07782968f, 0.14245552f, -0.08792845f, 0.05163500f, -0.00834962f, 0.04369999f, 0.04667248f, 0.20260426f, 
    0.21392497f, -0.12803398f, -0.04824681f, 0.21404797f, 0.02869476f, -0.21072756f, 0.06235356f, -0.08516219f, 
    -0.17391123f, 0.03539046f, 0.01726872f, -0.19871490f, 0.00604110f, 0.18538809f, 0.17266712f, 0.14266364f, 
    0.10602117f, 0.04388051f, 0.01306723f, 0.08997665f, -0.02866707f, -0.00315423f, 0.01941659f, -0.06552172f, 
    0.10641969f, 0.27976006f, -0.14255446f, 0.23161067f, -0.06591145f, -0.08362306f, -0.01562351f, -0.16627847f, 
    -0.27629554f, -0.20189500f, -0.08866990f, -0.04438898f, 0.24501546f, 0.13283682f, 0.36350104f, 0.12033555f, 
    -0.20527747f, -0.00331242f, -0.03821225f, 0.20536979f, 0.08200519f, 0.01980110f, -0.03751244f, 0.02919493f, 
    -0.11820350f, 0.07299082f, -0.08686086f, -0.08135005f, 0.07669053f, -0.10318717f, -0.03058219f, -0.03448752f, 
    -0.10377322f, 0.06439436f, -0.14138959f, 0.01119680f, -0.37529299f, -0.02436114f, 0.04960923f, -0.00602016f, 
    0.03360159f, -0.00989004f, -0.06140262f, 0.11414915f, 0.04507525f, -0.10116113f, -0.10681710f, -0.13983840f, 
    -0.18584049f, -0.17590186f, 0.11867032f, -0.00878479f, -0.12852283f, 0.09191211f, -0.05874154f, 0.00378531f, 
    -0.04390726f, 0.01727737f, -0.09238809f, 0.03405872f, 0.12754452f, 0.06821677f, 0.13192724f, 0.06674973f, 
    -0.03146606f, 0.10802676f, -0.02864492f, -0.14616564f, -0.03530738f, 0.06626344f, 0.03119490f, 0.11150928f, 
    0.15219989f, 0.12145398f, -0.24871372f, -0.01499015f, -0.21316227f, 0.01046134f, 0.07792751f, 0.00791784f, 
    -0.11986984f, -0.07412205f, -0.22618328f, -0.24516891f, 0.03544699f, 0.05879478f, 0.06716646f, 0.14362340f, 
    0.00629209f, -0.08081158f, -0.04949317f, -0.03221658f, -0.01391901f, -0.00395346f, 0.02769180f, 0.15754111f, 
    -0.04986414f, -0.08307735f, -0.05012354f, -0.02305661f, 0.05713189f, 0.05483813f, 0.05189826f, 0.00261440f, 
    0.07724533f, 0.09404203f, 0.04950216f, 0.10723653f, -0.21130857f, 0.33711550f, -0.30737841f, -0.19268680f, 
    0.07628126f, 0.16430439f, -0.15442573f, -0.01071384f, -0.07238695f, 0.08634272f, -0.15341456f, 0.00918840f, 
    -0.02030604f, -0.18791445f, -0.09453951f, -0.09111849f, -0.20584714f, -0.07340152f, -0.05945259f, -0.06841622f, 
    -0.03633261f, 0.10452845f, -0.15081252f, -0.01300841f, 0.10064524f, 0.28843617f, -0.06590780f, 0.24175684f, 
    0.18466434f, 0.19422506f, -0.05571918f, 0.05140873f, 0.10069306f, -0.06562607f, -0.05014658f, 0.01946692f, 
    0.24600090f, -0.28593275f, -0.17215577f, -0.02571763f, 0.03545581f, 0.08225518f, 0.03835548f, 0.08988645f, 
    -0.00965074f, 0.02856892f, -0.21798666f, -0.11088642f, 0.00263628f, 0.04083666f, 0.07353684f, 0.08997027f, 
    -0.07625739f, 0.06574946f, 0.05496505f, 0.10036331f, 0.02100312f, 0.02113144f, -0.02046935f, 0.00799660f, 
    0.35005835f, 0.11551946f, -0.42330375f, 0.07582354f, 0.05233330f, 0.08364256f, 0.12897985f, -0.04739644f, 
    0.09019592f, -0.00695219f, 0.04002617f, -0.05182908f, 0.18975098f, -0.10035588f, -0.08577185f, 0.12112010f, 
    0.02238334f, 0.02534396f, 0.08517350f, -0.19518013f, 0.08535366f, 0.05476207f, -0.00269598f, 0.09508975f, 
    0.01267195f, 0.10923324f, -0.07970323f, 0.06534146f, 0.07649813f, -0.06121915f, 0.05930149f, -0.00651076f, 
    0.05761594f, -0.00964822f, -0.01806224f, -0.10851243f, -0.21518834f, -0.12270661f, -0.03772647f, 0.17918634f, 
    -0.08640442f, -0.09337310f, -0.04476053f, -0.09421571f, 0.00606561f, 0.01065215f, 0.07510822f, 0.06450363f, 
    0.06348769f, -0.06095662f, 0.12174737f, -0.12064812f, 0.00711288f, -0.01101905f, 0.00270491f, -0.04409283f, 
    0.12500979f, 0.08042335f, 0.19491364f, 0.37462053f, -0.08039192f, 0.13321693f, -0.00067492f, 0.06647547f, 
    0.02257453f, -0.01924821f, -0.04432299f, -0.07632072f, 0.00589417f, 0.07348322f, 0.04109629f, -0.13078040f, 
    -0.10222568f, 0.12569752f, 0.16654417f, -0.09430090f, 0.02425781f, 0.14659356f, 0.09408135f, 0.03091625f, 
    0.02352117f, -0.06866672f, 0.03473067f, -0.00447101f, -0.51510924f, -0.25717610f, -0.06708602f, -0.24738191f, 
    0.14346859f, 0.10411350f, -0.00518271f, 0.09406003f, 0.02403751f, -0.00774633f, -0.01437904f, -0.00995317f, 
    -0.16490300f, -0.05625579f, 0.00783808f, -0.10948751f, -0.10030445f, -0.03240580f, -0.18050587f, -0.04867733f, 
    -0.09311280f, 0.00866166f, -0.02734952f, -0.20847987f, -0.11399131f, -0.23250763f, 0.10320858f, 0.27493992f, 
    0.09912467f, 0.03711773f, -0.07380407f, 0.09761894f, 0.01800954f, -0.00430775f, -0.03299344f, -0.03398556f, 
    0.09585583f, -0.31861845f, 0.32131073f, 0.11637292f, -0.10775902f, 0.05369938f, -0.07719744f, 0.10224283f, 
    -0.16401534f, 0.04927219f, -0.03930321f, 0.19013804f, 0.06287429f, 0.12484495f, -0.00953359f, 0.04781069f, 
    -0.11113935f, -0.18480903f, -0.02431704f, -0.18702106f, 0.07501476f, 0.06046066f, 0.02761911f, 0.02238728f, 
    -0.06095836f, 0.07407188f, 0.05269488f, 0.13770065f, 0.09164517f, -0.07640312f, 0.07105084f, 0.02672204f, 
    -0.10989426f, 0.00050300f, -0.05035836f, -0.14303583f, -0.02410783f, -0.07876066f, -0.18528520f, -0.13575043f, 
    0.00477825f, 0.09228857f, 0.00136695f, -0.00641589f, 0.11599275f, 0.05309515f, 0.03929707f, 0.02899854f, 
    0.16370745f, 0.25622281f, 0.24361689f, 0.11683035f, -0.00719169f, 0.03928569f, -0.05545834f, 0.06061621f, 
    0.12129956f, 0.07017060f, 0.02455427f, 0.08424553f, -0.06425060f, -0.01148062f, 0.03149267f, -0.04756054f, 
    -0.07202537f, 0.01350287f, -0.00820928f, 0.05250789f, 0.18043077f, -0.05000956f, 0.08411799f, 0.07779454f, 
    -0.08285415f, 0.07141249f, -0.17385957f, 0.04204017f, -0.09234328f, -0.03959859f, -0.12668848f, 0.00945920f, 
    -0.05175613f, 0.06980687f, -0.08050881f, -0.01812826f, -0.29840133f, -0.15480803f, 0.09772312f, -0.11222845f, 
    -0.17684731f, -0.09340134f, -0.17343776f, 0.05833471f, -0.05281930f, -0.05357369f, 0.00830852f, -0.08576971f, 
    -0.03945089f, 0.09606266f, -0.20599766f, -0.40801850f, 0.12543887f, -0.02428493f, -0.04116562f, 0.02405188f, 
    0.10251823f, 0.03743519f, -0.17860588f, -0.06961000f, 0.00538592f, 0.11674993f, 0.11940726f, 0.19728099f, 
    0.00268978f, 0.01934645f, 0.06426948f, 0.08132318f, 0.14983614f, 0.03108760f, -0.02542818f, 0.08832669f, 
    -0.07218391f, -0.07952162f, -0.00139726f, 0.03606782f, -0.08790531f, -0.11924331f, -0.27342895f, 0.03945385f, 
    -0.08099420f, 0.01292638f, 0.00847287f, -0.10923780f, -0.22407709f, -0.05664189f, -0.06372679f, -0.08770736f, 
    -0.01204372f, -0.00190476f, 0.03220895f, -0.03823440f, -0.05049742f, 0.14013536f, 0.12099756f, 0.09879062f, 
    0.01561951f, -0.05295128f, 0.04100410f, 0.22826624f, 0.04772428f, -0.06909799f, 0.14121951f, -0.04138688f, 
    0.14369841f, -0.04733485f, -0.00070277f, -0.04428385f, -0.30681980f, 0.00695103f, -0.27220309f, 0.16420722f, 
    -0.04844040f, 0.09721801f, 0.03755994f, -0.13973998f, -0.08846048f, -0.05759277f, -0.06756373f, -0.06949526f, 
    0.08726159f, -0.07048873f, 0.24559058f, 0.00938509f, -0.11269406f, -0.08468661f, -0.05939338f, -0.14067774f, 
    0.00149480f, -0.04272342f, -0.00148274f, -0.07975032f, -0.12339697f, 0.04777328f, 0.03181643f, -0.00959415f, 
    0.01936844f, -0.03607231f, -0.02825749f, 0.06145983f, -0.08620761f, -0.18451531f, -0.03789570f, -0.05279192f, 
    0.06645081f, -0.08511144f, 0.04702621f, -0.11217012f, 0.02624565f, -0.00552461f, -0.00009669f, 0.03946422f, 
    0.07646592f, -0.04448521f, 0.19559830f, 0.21109071f, -0.05927947f, -0.03687374f, -0.07107579f, -0.02041448f, 
    0.13312551f, -0.06377823f, -0.02011968f, -0.03194043f, 0.05069425f, -0.02802843f, -0.00643781f, -0.13133228f, 
    0.01361983f, -0.09886099f, 0.01543084f, -0.04054093f, -0.11818811f, -0.06369603f, 0.06934757f, -0.07555863f, 
    0.06005319f, -0.07854757f, -0.09563417f, -0.04513558f, -0.24156106f, 0.13948296f, -0.02179572f, -0.01321462f, 
    0.03594257f, -0.23344567f, 0.00864800f, -0.09183428f, -0.12096260f, -0.10728125f, -0.01566727f, 0.19764109f, 
    0.19605096f, 0.22855166f, 0.04901078f, 0.02956789f, -0.16296522f, -0.18631034f, -0.04266092f, -0.04373841f, 
    -0.00339179f, 0.00153198f, -0.02493806f, 0.09216136f, 0.06211566f, 0.06946156f, -0.01206774f, -0.04065356f, 
    -0.02511746f, -0.01127656f, 0.06505261f, 0.09387668f, -0.02559606f, -0.19297256f, -0.05212362f, -0.01868851f, 
    0.01897456f, 0.19753240f, 0.10365560f, 0.23379989f, -0.12499519f, -0.10783572f, -0.01744186f, 0.20841508f, 
    -0.12221147f, -0.04632620f, -0.05228012f, -0.04167555f, 0.01028337f, -0.16918272f, -0.09024469f, 0.01110816f, 
    0.02787106f, -0.00891421f, 0.08576648f, 0.00777609f, 0.03699447f, 0.04795449f, -0.02651931f, 0.10837866f, 
    -0.03339275f, 0.19904660f, -0.14217722f, -0.04537445f, 0.13433716f, -0.03353270f, -0.12084844f, -0.03881866f, 
    -0.06635938f, 0.04217478f, 0.14225528f, -0.14767006f, -0.21738498f, -0.14025235f, -0.02240645f, 0.06110878f, 
    -0.09692563f, 0.01272983f, 0.05061173f, -0.10348608f, -0.00732701f, -0.10312259f, 0.10428308f, 0.03897154f, 
    -0.27631342f, -0.01514850f, -0.16456105f, 0.00673880f, 0.11111464f, -0.18201305f, 0.13552152f, 0.12962906f, 
    0.09827118f, 0.06743976f, -0.05165372f, -0.00392721f, -0.17803492f, 0.03175290f, -0.24237828f, -0.19486566f, 
    0.05989027f, 0.12770200f, 0.14129448f, -0.01520000f, 0.06012547f, 0.10731854f, -0.22058265f, -0.01067602f, 
    -0.34502482f, 0.13945007f, -0.07661308f, -0.04163311f, 0.09302972f, 0.04480428f, -0.09714399f, -0.02910798f, 
    0.09821635f, 0.08161357f, -0.14140053f, -0.04830505f, -0.08962646f, 0.02516572f, 0.02844734f, -0.00575677f, 
    -0.12702231f, 0.11328919f, -0.03348783f, -0.04215096f, 0.20251188f, -0.14654005f, -0.03253198f, 0.10807293f, 
    0.14078465f, 0.02076192f, -0.05962411f, -0.01733866f, 0.01691343f, -0.06006816f, 0.03186877f, 0.08986466f, 
    -0.12896387f, 0.02866768f, 0.09120182f, 0.07898413f, -0.03676682f, 0.13028018f, 0.05032360f, 0.00004396f, 
    0.27547312f, 0.13345765f, 0.02864131f, 0.01311935f, -0.02939947f, 0.04687114f, 0.01577206f, 0.06016834f, 
    0.19914086f, -0.06453760f, -0.12114062f, 0.29624480f, 0.03117415f, -0.02217828f, -0.04360215f, -0.03639277f, 
    0.10824452f, 0.06372239f, -0.05023930f, 0.15581441f, -0.17604026f, -0.07860949f, -0.23623863f, 0.33934358f, 
    0.05800930f, 0.04861934f, -0.10341140f, 0.00581679f, -0.10171684f, 0.00787521f, 0.01025422f, 0.13694267f, 
    0.01811811f, 0.09116272f, 0.12040929f, 0.09364846f, -0.08553557f, -0.14923753f, 0.06689060f, 0.28178698f, 
    -0.04153209f, -0.00203171f, 0.21640889f, -0.11386488f, 0.03945795f, -0.05582189f, -0.05397219f, -0.15003678f, 
    0.01164888f, -0.03423791f, -0.17704506f, -0.15619569f, 0.07212560f, 0.11660790f, -0.02684089f, -0.08383464f, 
    0.23082344f, -0.45001933f, 0.03199508f, -0.15600416f, 0.11248706f, -0.03046254f, -0.01170392f, 0.04713675f, 
    -0.01103342f, 0.03269154f, 0.01705431f, 0.09315918f, 0.04595691f, 0.04002186f, 0.23890492f, -0.10538962f, 
    -0.08899201f, -0.19574636f, -0.20267698f, -0.05747648f, -0.05465702f, -0.06242695f, -0.02315790f, -0.15665363f, 
    0.14064573f, 0.30138960f, 0.20341748f, -0.01164879f, -0.02316041f, 0.07990217f, -0.01080899f, -0.04959342f, 
    0.08086286f, -0.10579319f, 0.34614369f, 0.19419861f, 0.12709066f, 0.25883764f, 0.10616327f, -0.19345003f, 
    0.11373687f, 0.00930820f, -0.03113190f, -0.11447275f, 0.02469913f, 0.00636234f, 0.08269344f, 0.05247029f, 
    -0.44020551f, -0.12379494f, 0.21489890f, -0.06634976f, -0.07915427f, 0.02762085f, -0.03317703f, 0.16547956f, 
    0.26570207f, 0.11161187f, -0.07473447f, -0.05382318f, 0.08205597f, 0.16356964f, 0.01919566f, -0.20702204f, 
    0.24675931f, 0.03531514f, 0.08346394f, -0.18218528f, -0.00023688f, -0.00686602f, -0.05911716f, 0.09703398f, 
    0.34015021f, -0.00941208f, 0.09665722f, 0.11509317f, 0.02344548f, 0.06048969f, 0.09283590f, 0.09104426f, 
    0.14926435f, -0.06028374f, -0.02405680f, -0.16779399f, -0.18262003f, -0.17532064f, -0.29953581f, -0.13679601f, 
    -0.07738764f, -0.10201287f, 0.09870271f, -0.04173868f, 0.01132624f, -0.00484511f, 0.15016150f, 0.06227492f, 
    0.05586889f, -0.07344911f, 0.20851479f, -0.08774423f, -0.15727639f, -0.17404693f, 0.07096857f, 0.00785329f, 
    -0.08936029f, 0.06865249f, -0.06167130f, -0.04878077f, 0.16816492f, 0.09614719f, 0.23511808f, 0.12486433f, 
    0.01013999f, 0.06338286f, 0.03285208f, -0.08307491f, -0.01342106f, -0.08072698f, -0.07882188f, -0.12026236f, 
    -0.27021921f, 0.01567151f, -0.00762638f, -0.06058603f, 0.07422227f, -0.09998662f, -0.07659837f, -0.00541755f, 
    0.17748974f, 0.05646714f, -0.00470637f, 0.39926776f, -0.01230952f, 0.09743202f, 0.11885531f, 0.07339744f, 
    -0.11809900f, -0.01358647f, -0.01726208f, -0.15615728f, 0.11988250f, -0.02009341f, -0.00322084f, 0.04954404f, 
    -0.05174327f, -0.08182849f, -0.07843563f, -0.01587406f, 0.04523661f, -0.01707537f, -0.01431179f, -0.02550029f, 
    0.11692578f, -0.02618199f, -0.00124922f, -0.05749266f, -0.07149275f, -0.10803945f, -0.07250798f, 0.03028805f, 
    0.07247251f, -0.11323275f, -0.03626295f, 0.10289258f, 0.08180695f, -0.08924276f, -0.06077859f, 0.08317649f, 
    -0.25453746f, 0.17443916f, 0.17042504f, -0.04554702f, -0.07289044f, -0.15668558f, -0.06438254f, 0.00500920f, 
    0.03464571f, 0.05515066f, -0.27857220f, 0.06171271f, -0.07756111f, -0.01453159f, -0.11451288f, 0.12569885f, 
    -0.05692557f, 0.00871717f, 0.03145539f, 0.01823766f, -0.08708277f, 0.05332050f, 0.06905380f, -0.05845005f, 
    -0.11126952f, -0.08507383f, 0.17617108f, -0.41620713f, 0.10319279f, -0.08460523f, -0.07321374f, 0.12413580f, 
    0.06971706f, 0.07893781f, -0.05786636f, 0.11553714f, 0.07604455f, 0.14736137f, 0.13650331f, -0.01128845f, 
    0.15579170f, 0.12710689f, -0.00697937f, -0.04945358f, 0.06851147f, 0.02353518f, 0.03106850f, 0.14868048f, 
    -0.28252152f, -0.10461985f, -0.39870656f, 0.12612335f, 0.19889913f, 0.10206367f, -0.06576904f, -0.08413281f, 
    -0.06596825f, -0.09180209f, 0.09958186f, -0.03126052f, -0.08771500f, -0.17122887f, -0.08997531f, 0.10925084f, 
    0.01611566f, -0.04466195f, 0.00653664f, 0.08978159f, -0.09833945f, 0.01637174f, -0.09703873f, -0.01642569f, 
    -0.13004129f, -0.11028434f, 0.02809736f, 0.02152988f, -0.13663593f, -0.00017645f, -0.10032774f, 0.02387605f, 
    0.06345580f, 0.02979548f, 0.05405949f, 0.02165345f, -0.27875736f, -0.12189607f, -0.05046225f, -0.32888123f, 
    0.06294546f, -0.11542208f, 0.07226989f, -0.11778892f, 0.01063047f, -0.10449357f, -0.04719748f, 0.08877891f, 
    -0.08500917f, -0.13634130f, -0.18108052f, -0.11484487f, 0.02726361f, 0.06274787f, 0.09245069f, 0.01181382f, 
    0.07925690f, -0.43140876f, -0.22278036f, -0.58196080f, 0.03097159f, 0.00107322f, -0.15426809f, 0.11231471f, 
    -0.03999062f, -0.09111092f, 0.18700248f, 0.07253946f, -0.15326943f, -0.10253174f, 0.04041261f, -0.02735909f, 
    -0.24659230f, 0.07950309f, -0.46788147f, -0.09631655f, -0.03698764f, -0.04952879f, 0.02169354f, -0.00090488f, 
    -0.16125226f, -0.00968728f, -0.01154676f, -0.17182261f, 0.37588534f, -0.01917782f, -0.04235374f, -0.05013878f, 
    -0.03185190f, 0.00753588f, -0.02657255f, 0.05460976f, 0.03930566f, -0.05674763f, 0.02283155f, 0.03151340f, 
    0.52798748f, 0.15348426f, -0.07862471f, 0.05194821f, 0.12354264f, 0.04378086f, -0.00735398f, 0.03311042f, 
    0.10798866f, -0.03747851f, 0.09135216f, 0.01034612f, 0.09350524f, -0.44687071f, -0.03650338f, 0.08722532f, 
    0.05284463f, -0.08174465f, 0.02065324f, 0.00358488f, -0.05264598f, 0.04017279f, 0.02145308f, 0.12504414f, 
    0.03570930f, -0.18608415f, 0.10194290f, 0.06926198f, 0.00006394f, -0.03776309f, 0.01485580f, -0.07554354f, 
    -0.00125135f, 0.06720462f, -0.08704087f, -0.11530462f, -0.29286826f, -0.16798186f, -0.15115482f, -0.22355486f, 
    0.16680521f, 0.07540222f, 0.12276649f, 0.18374513f, 0.01805184f, -0.04035218f, 0.03563330f, 0.00601204f, 
    0.14945540f, 0.18723090f, -0.01444590f, 0.07019737f, 0.03719142f, 0.19793740f, 0.06720047f, 0.07960765f, 
    0.05379618f, -0.00336699f, 0.00449669f, 0.02574449f, 0.39456576f, -0.07583286f, 0.02896191f, 0.27260044f, 
    -0.00045622f, -0.01055737f, -0.02687109f, 0.11540199f, -0.01832405f, 0.04818858f, -0.06796549f, -0.03239027f, 
    -0.04151991f, 0.19341634f, -0.02529792f, -0.11150205f, 0.14680830f, -0.05022086f, 0.01699409f, -0.28865653f, 
    -0.13550940f, 0.04022154f, -0.02929358f, -0.03727532f, 0.13629523f, -0.14924116f, -0.05730138f, -0.21413907f, 
    0.04527342f, 0.00155947f, -0.01165149f, -0.02372214f, -0.06635150f, -0.14668612f, 0.02824066f, 0.02020377f, 
    -0.09804803f, -0.09308886f, -0.09170516f, 0.18592040f, 0.00569845f, -0.10033040f, 0.02485844f, 0.11487503f, 
    -0.07791277f, 0.08295626f, 0.04412667f, 0.12906723f, -0.01485770f, 0.02538043f, 0.09341571f, 0.15433194f, 
    0.11200570f, -0.30899855f, 0.05996118f, 0.08562535f, 0.06027470f, 0.06377449f, 0.00646525f, 0.02040095f, 
    0.18703699f, -0.02497834f, -0.08640672f, -0.37569860f, -0.03295121f, 0.08677576f, 0.01246761f, -0.00008305f, 
    0.11309692f, 0.00149333f, 0.13340729f, -0.14855875f, 0.09671864f, 0.02318621f, -0.06419560f, 0.01439341f, 
    0.04525075f, 0.00387034f, -0.05337818f, -0.15943882f, -0.23663272f, -0.09194954f, -0.02320515f, -0.13005662f, 
    0.00639000f, 0.00812456f, -0.15184103f, 0.01657232f, 0.08963824f, 0.11835540f, -0.09435963f, 0.07540578f, 
    0.08709808f, 0.02406878f, -0.02671068f, 0.12056603f, 0.31102955f, -0.11361314f, -0.03644675f, 0.07193585f, 
    -0.01139681f, 0.02199476f, 0.13142350f, 0.03835008f, 0.03260671f, -0.27289236f, -0.06145262f, -0.25373554f, 
    0.03535715f, -0.07741018f, 0.10926075f, 0.02867173f, -0.03011461f, 0.02306944f, 0.12763011f, 0.12150196f, 
    -0.06769012f, 0.12900238f, 0.02014310f, 0.02934869f, -0.04130378f, -0.10233990f, 0.36572307f, 0.18459469f, 
    -0.11602856f, -0.06474756f, -0.08802000f, 0.12771034f, 0.03812932f, 0.09815460f, -0.08782869f, 0.06294899f, 
    0.29962483f, 0.11405925f, 0.26495418f, 0.08897590f, 0.01227798f, 0.04018648f, 0.11391441f, -0.00349468f, 
    0.12961920f, 0.03439875f, 0.05986401f, -0.00356056f, 0.02655425f, -0.13202600f, -0.28121164f, -0.17786352f, 
    0.03924933f, -0.01528875f, 0.07133915f, 0.08242884f, 0.09690541f, 0.01444743f, 0.11222588f, -0.08559186f, 
    -0.01831868f, -0.05162670f, -0.08330560f, 0.14079939f, 0.05207854f, -0.00303371f, -0.00953148f, 0.04296505f, 
    -0.00425318f, -0.25770369f, -0.14840557f, -0.11190167f, -0.13662691f, 0.30399093f, -0.20705198f, -0.27228594f, 
    -0.08309525f, 0.07293096f, -0.13529292f, 0.08650380f, -0.00094357f, -0.02924869f, -0.01143076f, -0.07603269f, 
    0.10045452f, -0.07322183f, 0.05073016f, 0.02953872f, -0.00018192f, 0.06376444f, -0.03211684f, -0.06514454f, 
    0.07651353f, 0.03209298f, 0.16541831f, 0.04558658f, 0.09258496f, -0.02784253f, -0.36672357f, -0.09184961f, 
    0.00478263f, 0.09246267f, -0.04997557f, 0.12573041f, 0.04345753f, -0.09063611f, -0.22336431f, -0.17574017f, 
    -0.08355303f, -0.03502914f, -0.37541211f, -0.04361357f, 0.16064292f, 0.11055525f, -0.17866714f, -0.02077033f, 
    0.14488736f, 0.09527259f, -0.07799471f, -0.17174599f, -0.29921383f, -0.08574865f, -0.23603778f, -0.04059104f, 
    -0.03067509f, -0.06405260f, -0.02673510f, 0.00732056f, 0.17612354f, 0.04412153f, -0.09584403f, 0.02546308f, 
    0.07930178f, 0.09320451f, 0.02594187f, -0.08946861f, 0.14908515f, 0.09845094f, 0.14286986f, -0.19176400f, 
    0.05088669f, -0.01744735f, -0.02538897f, 0.07138731f, -0.04320749f, -0.32807091f, 0.14105320f, 0.11768341f, 
    0.02550199f, -0.01009373f, 0.03616077f, 0.02446569f, 0.01057243f, -0.18362474f, 0.02215314f, -0.02692503f, 
    -0.07895979f, 0.18859056f, -0.57838476f, -0.27047053f, -0.01182708f, 0.03288601f, 0.09776989f, 0.06332851f, 
    0.15710343f, -0.14634632f, -0.07641137f, 0.33931345f, -0.61315978f, 0.12254381f, 0.04079134f, -0.24009934f, 
    -0.14896123f, -0.07860937f, -0.11001016f, 0.05118052f, -0.09365573f, -0.07011476f, 0.08508731f, -0.00912275f, 
    0.20072569f, -0.16197029f, -0.07161783f, 0.08355451f, 0.13717534f, 0.02258731f, 0.07247404f, -0.01116553f, 
    0.01876807f, -0.01065129f, -0.10228315f, 0.06018976f, 0.16649443f, 0.04464774f, 0.07540338f, 0.11337695f, 
    0.00954839f, 0.07988682f, -0.03732219f, -0.02060481f, -0.01831517f, -0.01520889f, 0.18401086f, 0.05535881f, 
    -0.29112145f, -0.42249373f, 0.63474828f, -0.17116958f, 0.04483039f, 0.00440206f, 0.07050414f, -0.23275550f, 
    -0.04922576f, 0.11214037f, 0.03143398f, 0.04441155f, 0.06855910f, -0.07326614f, 0.02601448f, 0.05904406f, 
    0.06175509f, -0.02514974f, -0.07427868f, 0.05636141f, -0.01181160f, 0.03770126f, 0.03037741f, -0.12952165f, 
    -0.08693376f, -0.03196040f, -0.04837448f, -0.05261509f, -0.18449858f, 0.02798384f, 0.06083715f, -0.02136920f, 
    0.10958762f, 0.02543232f, -0.00102629f, -0.00878572f, -0.54541832f, -0.67381966f, -0.29487050f, -0.38423282f, 
    -0.05426628f, -0.15562962f, -0.03000794f, -0.29767990f, 0.02565307f, 0.00757970f, -0.04878705f, -0.03925406f, 
    -0.15325165f, -0.02682232f, -0.17070696f, -0.24045272f, 0.02559459f, -0.00441228f, 0.04352464f, -0.03816897f, 
    0.00454678f, 0.01503068f, -0.01636157f, -0.02153421f, -0.20111205f, -0.05957201f, -0.09686274f, -0.07086477f, 
    0.04291473f, 0.04767190f, 0.01326072f, 0.02261948f, -0.02681916f, -0.02758552f, -0.04377103f, 0.05529016f, 
    -0.38550010f, -0.29197168f, -0.28663316f, 0.26388347f, 0.00258280f, 0.20633045f, 0.13890080f, 0.03398769f, 
    0.06791218f, -0.04956664f, 0.11356071f, 0.08065063f, 0.06496654f, 0.07557759f, -0.04306319f, -0.05563665f, 
    -0.04734717f, -0.14167520f, -0.05969896f, 0.08277106f, 0.03677189f, 0.04714083f, -0.12896763f, -0.08148183f, 
    -0.08106247f, -0.36371395f, -0.23090513f, -0.08477980f, 0.09513850f, 0.08859042f, 0.06156315f, 0.04007235f, 
    -0.01654904f, 0.02521645f, -0.06886707f, -0.05414812f, -0.18659584f, -0.29517889f, -0.34223801f, 0.22716132f, 
    -0.14569525f, -0.08718198f, 0.17847358f, -0.11497237f, -0.00216908f, 0.03859473f, 0.06328264f, 0.03505076f, 
    -0.31745991f, -0.09889233f, 0.23644954f, 0.11968593f, -0.01597804f, 0.05860783f, 0.06953394f, -0.06006953f, 
    0.08210772f, 0.01363295f, 0.17524748f, -0.03680587f, -0.37268367f, -0.54582393f, -0.38244531f, -0.19632751f, 
    -0.01327883f, -0.02242057f, -0.07990150f, -0.24819139f, 0.01990177f, -0.04464008f, -0.02833697f, -0.04489107f, 
    -0.19375399f, -0.11552470f, 0.24845901f, 0.10232824f, -0.06067080f, -0.10120613f, -0.08666014f, 0.14447132f, 
    -0.04938746f, 0.14824747f, 0.06973547f, -0.15738332f, -0.80095655f, -0.27548721f, -0.15518327f, -0.15427239f, 
    -0.05461274f, -0.30524254f, -0.24646829f, -0.29994857f, -0.06336118f, -0.03743964f, 0.01139542f, -0.01114173f, 
    0.22844999f, 0.03054695f, -0.08926870f, 0.20419233f, -0.08294368f, -0.02776680f, 0.16212031f, 0.13060601f, 
    0.11472882f, 0.12856503f, 0.13414064f, 0.11573602f, -0.28134224f, 0.10269663f, 0.37645558f, 0.40211564f, 
    -0.13418823f, -0.05071757f, 0.02869319f, 0.12258293f, 0.02963672f, 0.05622461f, -0.02615090f, 0.09746616f, 
    0.01472503f, -0.04516590f, 0.02651075f, 0.12183602f, -0.02772542f, 0.03393794f, 0.10879935f, 0.20861258f, 
    0.11596848f, 0.15071441f, 0.12519157f, 0.02998383f, -0.20368423f, -0.05925087f, -0.28461993f, -0.28141776f, 
    -0.05238452f, -0.11165343f, -0.07743738f, -0.01477208f, -0.08187186f, -0.00478054f, -0.01379860f, 0.04809282f, 
    0.08403584f, -0.09013376f, 0.29023990f, 0.17231265f, 0.12874387f, -0.15492940f, 0.07041701f, 0.01457827f, 
    0.04430439f, 0.14845347f, -0.13304745f, -0.00099972f, -0.52466536f, -0.50785089f, -0.47013670f, -0.34589410f, 
    -0.10905042f, -0.14452156f, 0.04164633f, -0.13451703f, -0.07432978f, -0.07680529f, 0.02171765f, -0.04735897f, 
    0.09715441f, -0.02183936f, -0.07249687f, -0.04847832f, 0.02645822f, 0.03619706f, 0.04302804f, 0.02148365f, 
    -0.07589773f, -0.09628102f, -0.12166326f, -0.03980741f, 0.11703065f, 0.11092274f, 0.00845746f, -0.04889235f, 
    -0.02135156f, 0.02989385f, 0.09567016f, -0.11234610f, 0.00564787f, -0.07552173f, 0.11853910f, 0.01466609f, 
    -0.24917328f, -0.13438365f, -0.02727880f, -0.16087642f, 0.01890601f, -0.02750833f, 0.00570505f, 0.06115423f, 
    0.04024261f, 0.10997484f, 0.06251846f, 0.08560562f, 0.14372931f, -0.29148015f, -0.31480101f, -0.15344934f, 
    -0.02123439f, 0.13576868f, 0.23370633f, -0.05661497f, 0.09536386f, -0.05893290f, 0.01500883f, 0.00758955f, 
    -0.18319774f, -0.03437050f, 0.09843202f, 0.00795379f, 0.02426469f, -0.11818750f, 0.07224710f, 0.03385331f, 
    -0.02262740f, 0.02341812f, 0.06569094f, -0.05288462f, -0.31020236f, -0.44627094f, -0.45558637f, -0.33277521f, 
    -0.08259505f, -0.30488566f, -0.06436732f, -0.37340418f, -0.05363039f, -0.03207015f, -0.05046821f, -0.03317214f, 
    -0.08859023f, -0.21595770f, -0.00626018f, -0.40912956f, 0.08949225f, 0.08302894f, 0.14306627f, -0.02106924f, 
    -0.03622941f, -0.07037316f, 0.05426791f, -0.01003396f, 0.25532216f, -0.11393038f, -0.16340126f, -0.06429187f, 
    -0.03367306f, 0.07434922f, 0.14907086f, 0.05117358f, -0.04137617f, -0.02724282f, 0.06146312f, -0.01390846f, 
    0.05658848f, -0.19547743f, -0.34446916f, -0.08535931f, -0.01759693f, 0.03143245f, 0.00245565f, -0.04687957f, 
    -0.00055500f, 0.00193582f, -0.03567581f, -0.03492208f, -0.44600761f, -0.54808569f, 0.04083661f, 0.05387409f, 
    0.09287205f, -0.12245180f, -0.07846443f, 0.00391768f, -0.03556789f, 0.03124002f, -0.00803140f, 0.07049906f, 
    -0.01692852f, 0.14360045f, -0.09870696f, 0.02242786f, -0.00722675f, 0.02749307f, 0.08086880f, 0.03240502f, 
    0.09377146f, 0.02635504f, 0.21642756f, 0.20559689f, 0.28636923f, 0.04842987f, -0.16697505f, -0.01779358f, 
    0.01694919f, -0.06664359f, 0.13647962f, 0.10048679f, 0.06909324f, -0.07655476f, 0.09080307f, -0.03105501f, 
    -0.51672131f, -0.19127488f, 0.15402734f, -0.04839436f, 0.06813884f, 0.02573178f, 0.08166629f, -0.18902326f, 
    0.02453894f, 0.04896281f, 0.00574971f, 0.11872801f, -0.12609150f, 0.00581951f, -0.11777165f, -0.17797141f, 
    0.00149691f, -0.01352315f, -0.06145144f, 0.13670336f, 0.07786248f, 0.01846446f, 0.02606458f, -0.03630045f, 
    0.50981790f, 0.22284603f, -0.50790125f, -0.52292967f, -0.09688541f, -0.00585097f, 0.19249518f, 0.15069278f, 
    -0.06769196f, 0.15954991f, -0.10314416f, 0.00456900f, -0.12668623f, 0.09733142f, 0.01335537f, -0.03077929f, 
    0.13382685f, -0.02043756f, -0.00971453f, -0.03331342f, -0.02290864f, -0.05483811f, -0.00242644f, 0.08111835f, 
    -0.24344458f, -0.02465040f, -0.10324662f, 0.28369877f, 0.05397719f, 0.12702477f, 0.10781146f, -0.01151691f, 
    0.16176951f, 0.03780584f, 0.05640314f, 0.08873676f, -0.71178883f, -0.10869420f, 0.19783998f, 0.09340591f, 
    0.00000660f, -0.12099045f, 0.13242665f, -0.01983950f, 0.01612356f, 0.05702489f, -0.05487029f, -0.04806376f, 
    -0.20854515f, -0.44672710f, -0.30668116f, -0.26875809f, -0.02658929f, -0.05495368f, 0.07907938f, -0.12179373f, 
    0.00802193f, 0.05557365f, -0.08178858f, 0.09959414f, 0.06324068f, 0.14417353f, -0.28101069f, -0.26040140f, 
    -0.02523460f, -0.00158755f, 0.07257652f, -0.04127501f, -0.04338182f, 0.04056707f, 0.02169595f, 0.08511937f, 
    -0.92553806f, -0.08994468f, -0.01617725f, 0.37124842f, 0.00306440f, 0.01625602f, -0.30513906f, -0.21802750f, 
    0.00039473f, -0.12559325f, 0.02752956f, 0.01641943f, -0.22949976f, 0.28536987f, 0.20089869f, 0.02663868f, 
    -0.02184432f, 0.03454049f, -0.00962514f, 0.07349828f, 0.00347593f, 0.17127001f, 0.18547885f, 0.05574356f, 
    0.24542463f, -0.09002926f, -0.15834545f, 0.18310063f, 0.00254537f, 0.01122632f, 0.15184057f, -0.08989342f, 
    0.05470709f, -0.09720744f, 0.06820688f, -0.00116516f, -0.06040600f, 0.02992687f, 0.00736266f, -0.08743700f, 
    -0.14939414f, -0.03246901f, 0.10110425f, 0.23621838f, 0.02111424f, 0.12877402f, 0.03683428f, 0.12999099f, 
    0.16163862f, 0.11945536f, -0.06015221f, -0.26205170f, 0.03076813f, -0.03581101f, 0.05030235f, 0.07726251f, 
    0.03389008f, -0.05219309f, 0.10918874f, -0.24366999f, -0.09757984f, -0.10751136f, -0.26623604f, -0.15653077f, 
    -0.15865487f, -0.03930718f, 0.03888866f, 0.02496038f, 0.06839453f, -0.08409385f, -0.02807154f, 0.08320302f, 
    0.42159465f, 0.12551971f, -0.13701586f, -0.25594673f, -0.07384448f, -0.10252543f, 0.10951003f, 0.09844651f, 
    0.05318894f, 0.01310500f, 0.01056315f, -0.11425485f, 0.12390970f, 0.16957363f, -0.07504915f, 0.04443864f, 
    -0.01509667f, -0.02133273f, 0.03306386f, 0.06622539f, -0.03040325f, 0.13356799f, 0.10062809f, 0.02646438f, 
    -0.16778770f, -0.18807068f, -0.07536975f, -0.03258693f, -0.00887030f, 0.01148416f, -0.04883216f, -0.32737845f, 
    0.03924859f, -0.08772658f, 0.00121571f, -0.05793146f, -0.00724138f, -0.35581043f, -0.37957135f, 0.10633434f, 
    0.00490304f, 0.01750236f, 0.04844866f, 0.10482156f, -0.04774049f, 0.05169617f, -0.07484565f, -0.01520561f, 
    -0.65865999f, -0.37123388f, 0.12158379f, -0.05591670f, -0.12734790f, 0.01505508f, -0.24523608f, -0.15994105f, 
    -0.07739444f, -0.02179477f, -0.07188018f, -0.00644716f, 0.35671765f, 0.38535729f, -0.06387786f, 0.08109988f, 
    0.03175647f, -0.05766508f, -0.01529767f, 0.01687165f, -0.02330441f, -0.08787902f, 0.02969108f, 0.12194218f, 
    0.03172267f, 0.07481489f, -0.05322260f, -0.08045410f, 0.02498386f, 0.02442931f, -0.00126829f, -0.00647712f, 
    0.06462137f, 0.28140643f, 0.12164872f, -0.06594202f, -0.36775446f, -0.48180553f, 0.12288694f, 0.11312710f, 
    0.17560609f, 0.02779182f, -0.00380569f, -0.22291152f, 0.04434443f, 0.05591178f, -0.03903135f, 0.08699255f, 
    -0.02476715f, -0.01096945f, -0.14242603f, 0.01117834f, -0.07890659f, 0.00601556f, -0.23559113f, 0.00535160f, 
    0.12269670f, -0.16278265f, -0.01045152f, -0.13877670f, 0.24346255f, 0.06827154f, 0.04402039f, 0.15727194f, 
    0.01329132f, 0.12165266f, 0.01040952f, 0.12587562f, 0.06945537f, -0.07164921f, -0.04022017f, -0.00938515f, 
    -0.31828791f, 0.24744019f, 0.22283682f, -0.13085514f, -0.06501296f, -0.09061059f, -0.22832681f, -0.02362399f, 
    -0.13082978f, -0.01067352f, -0.10638797f, 0.13900940f, 0.03813371f, 0.06722597f, 0.11310519f, 0.09707671f, 
    -0.04196435f, -0.01698518f, -0.01973164f, 0.09048964f, -0.00465173f, -0.00969421f, 0.19636680f, 0.10527107f, 
    -0.42944813f, -0.35465768f, -0.16499881f, -0.12309960f, -0.15450940f, -0.24399582f, -0.12072198f, -0.18582179f, 
    -0.06801242f, -0.00462268f, 0.00307005f, -0.02545149f, 0.06840383f, 0.01056671f, -0.14635804f, 0.00531056f, 
    -0.01717417f, 0.02682637f, -0.03129165f, 0.02959601f, -0.03928354f, -0.03577445f, -0.03464494f, -0.01309837f, 
    0.13066396f, 0.08630229f, 0.19217741f, 0.00770268f, 0.07369034f, -0.06185566f, 0.20546208f, 0.13891132f, 
    0.05828582f, 0.01712156f, 0.08207124f, -0.15710199f, 0.10018708f, -0.29848430f, 0.11660942f, -0.27891985f, 
    -0.09182698f, 0.00969620f, 0.10677338f, 0.07847734f, -0.05288839f, 0.15442911f, -0.00049743f, 0.08927638f, 
    -0.16158511f, 0.17395234f, -0.06303655f, 0.06633697f, -0.12772833f, 0.10491879f, -0.10843790f, -0.05589201f, 
    0.00562667f, -0.04670523f, 0.01496750f, -0.03248039f, -0.04547626f, 0.08868270f, 0.08238804f, 0.04027864f, 
    -0.06113562f, -0.02537634f, 0.09810451f, 0.00038592f, 0.00309179f, -0.09335994f, -0.01717662f, 0.00940569f, 
    0.10628609f, 0.17171185f, -0.03793823f, -0.32330438f, -0.01770134f, 0.01466365f, -0.17434457f, 0.21105921f, 
    -0.04067307f, 0.08093084f, 0.02012689f, 0.05972601f, 0.01261798f, 0.04307480f, 0.09717785f, -0.06293871f, 
    -0.03555342f, 0.00556027f, 0.00338365f, -0.05577181f, 0.03797703f, -0.10797978f, 0.01102274f, -0.10640272f, 
    -0.19070423f, -0.06398214f, -0.20741834f, -0.02124240f, 0.04253073f, -0.01992124f, 0.00512021f, 0.02865449f, 
    0.00141759f, -0.03391287f, -0.03936599f, 0.02662241f, -0.29683062f, -0.32061419f, -0.17731415f, 0.10803436f, 
    0.09504984f, -0.00682398f, 0.10603423f, 0.11492434f, 0.03099298f, -0.02721954f, -0.01207364f, 0.02614618f, 
    -0.05795727f, -0.02645460f, -0.05118821f, -0.06236602f, 0.08173639f, 0.05012675f, 0.03277946f, -0.00021021f, 
    0.06085465f, 0.04167847f, 0.01910869f, -0.03929911f, 0.01537905f, 0.17505708f, -0.10851044f, -0.00504107f, 
    0.03732998f, -0.00017058f, -0.05367864f, 0.00484639f, -0.00078296f, 0.09230951f, -0.02621418f, -0.04437105f, 
    -0.05069695f, -0.29852062f, 0.00465085f, -0.07951063f, 0.08616270f, 0.04385834f, -0.01158124f, 0.01392389f, 
    -0.06821363f, -0.02357192f, -0.04918139f, -0.02813032f, -0.03963139f, -0.03495074f, 0.10476119f, 0.03213606f, 
    0.01399813f, -0.10133472f, 0.04667571f, 0.02084423f, -0.01603983f, -0.04777976f, 0.02645140f, 0.06469830f, 
    -0.01177163f, -0.17507920f, 0.04989388f, -0.06212701f, 0.00154518f, -0.00688442f, 0.01891148f, -0.02256748f, 
    0.03661899f, -0.01672655f, -0.03482777f, 0.00191932f, -0.22435632f, -0.32063428f, 0.19650881f, -0.28342807f, 
    0.02151559f, 0.00111306f, 0.17706841f, 0.06704190f, -0.02583609f, -0.02595442f, 0.03719597f, -0.00599940f, 
    0.20851535f, 0.08620332f, -0.00201261f, -0.00773394f, 0.07540936f, 0.09800962f, 0.06632479f, 0.02115100f, 
    -0.09319914f, -0.16289601f, 0.04918556f, -0.14883757f, -0.41938594f, -0.07290129f, 0.12725025f, 0.18742409f, 
    0.06857192f, 0.06043943f, 0.07146276f, 0.11401160f, 0.02401803f, -0.07339489f, -0.04002731f, -0.06151014f, 
    0.64236528f, -0.76090658f, -0.19936250f, -0.47506815f, -0.18674950f, 0.00825145f, -0.14234518f, 0.07091591f, 
    0.11871386f, 0.13988927f, -0.06232591f, 0.01802384f, -0.53453583f, -0.44486859f, -0.02059740f, 0.19534467f, 
    0.12352895f, 0.00313472f, 0.05181190f, 0.06255865f, -0.00328871f, 0.08033004f, 0.02558545f, -0.00905716f, 
    -0.23741949f, -0.45752937f, 0.09389749f, -0.01812079f, -0.08018216f, -0.06103875f, -0.17512095f, -0.03467985f, 
    -0.01312500f, -0.04162475f, -0.07303240f, -0.00712889f, -0.01892817f, -0.47681189f, -0.50653458f, -0.43466142f, 
    0.07675181f, 0.10806401f, 0.15661639f, 0.03476008f, 0.04960691f, -0.09444929f, -0.01529390f, -0.05719355f, 
    0.11789028f, -0.20625634f, -0.00147957f, -0.21915734f, 0.04922432f, 0.06191995f, 0.04218241f, -0.01909250f, 
    -0.08932020f, -0.13115244f, -0.17457885f, 0.05645969f, -0.26394513f, -0.28392765f, 0.00089909f, 0.24774426f, 
    0.00803216f, 0.03073696f, 0.03445581f, 0.02794131f, 0.01630490f, 0.01142708f, 0.07248995f, 0.01141917f, 
    0.13424972f, 0.05945797f, 0.14454947f, -0.10348506f, 0.11332411f, 0.01917691f, -0.01026098f, 0.02337248f, 
    -0.04675655f, 0.02855436f, -0.07654032f, -0.10361021f, -0.10547818f, -0.25723439f, -0.13336526f, 0.24020706f, 
    0.02334853f, -0.02700746f, 0.03766461f, 0.09037367f, -0.06121928f, -0.04869329f, -0.09097512f, 0.03013932f, 
    -0.00321318f, -0.00016836f, 0.10410053f, 0.00386362f, -0.03924181f, 0.00581908f, 0.02829582f, -0.02905926f, 
    0.07024635f, -0.07120678f, -0.01478753f, -0.16754681f, 0.05119541f, 0.22893181f, -0.11346905f, 0.20169672f, 
    -0.08247419f, 0.01004510f, 0.05715439f, -0.07422579f, -0.26772955f, 0.00901521f, -0.19597049f, 0.02229447f, 
    0.52175128f, -0.67064011f, 0.12977673f, -0.71891862f, -0.00385174f, 0.03033763f, -0.03751696f, 0.01891353f, 
    0.04951889f, 0.29993573f, 0.04320838f, 0.00171863f, -0.19779779f, 0.19246410f, -0.28604528f, 0.00049388f, 
    -0.03806807f, 0.00606451f, 0.01061844f, 0.01439381f, -0.01686071f, -0.02539128f, 0.05677698f, 0.06382953f, 
    -0.00357501f, 0.14086793f, 0.21574001f, 0.00893176f, 0.06493253f, -0.01583399f, 0.12876840f, -0.02643515f, 
    -0.04448761f, 0.00724459f, -0.06232604f, -0.04743487f, -0.22327226f, -0.38801387f, -0.12407063f, 0.20657727f, 
    0.12660795f, 0.01584663f, -0.06167959f, 0.16481936f, 0.03963250f, -0.01270176f, -0.05323158f, -0.02003900f, 
    -0.04516181f, 0.18606007f, -0.01858569f, 0.04872304f, -0.03713243f, -0.10912067f, -0.05681033f, 0.04039739f, 
    0.05263914f, 0.03049565f, 0.07587497f, -0.07130232f, 0.03813326f, 0.06936631f, 0.07100534f, -0.02637717f, 
    -0.03553235f, 0.06410199f, -0.01139902f, -0.01304574f, 0.03056622f, 0.11562426f, 0.03797100f, 0.06296660f, 
    0.01701351f, 0.01026052f, 0.06618007f, -0.02459695f, 0.00802289f, -0.02437869f, -0.04844046f, 0.03366109f, 
    0.05441100f, 0.03052594f, 0.00253371f, -0.04105614f, -0.05208480f, -0.33391324f, -0.30075997f, -0.44593874f, 
    -0.03697252f, 0.22438905f, -0.22586580f, 0.20612626f, 0.06313314f, -0.02882938f, -0.02035265f, -0.05053292f, 
    -0.00718116f, -0.07338058f, -0.07458673f, 0.03694985f, -0.03475216f, -0.10340050f, 0.00290910f, -0.00974279f, 
    -0.00189750f, 0.02189687f, 0.13079090f, 0.04757754f, -0.09490207f, -0.03182057f, -0.04890595f, 0.06626935f, 
    0.01667828f, 0.02987265f, 0.09537295f, -0.04792076f, -0.03166278f, -0.02122495f, -0.01162144f, -0.08686994f, 
    0.07166184f, 0.19174975f, -0.01067409f, 0.10043172f, 0.02871581f, -0.11175910f, 0.14311774f, 0.05994572f, 
    -0.09592191f, 0.04294383f, 0.04932428f, 0.08783571f, -0.18539776f, -0.04452301f, -0.01816849f, 0.07566247f, 
    0.02533954f, 0.03510483f, 0.09600375f, -0.05102989f, -0.03515539f, -0.00287345f, 0.02455433f, 0.05870385f, 
    -0.56415474f, -0.09735584f, -0.29584712f, 0.11521049f, 0.06803512f, -0.01255869f, -0.04814618f, -0.03276102f, 
    0.06928728f, -0.06983806f, 0.02416111f, -0.05093592f, 0.16148543f, -0.03067107f, -0.02595305f, -0.09919042f, 
    0.02385402f, 0.04756919f, -0.01270642f, -0.01806319f, -0.01047035f, 0.10424633f, 0.03932772f, -0.02869548f, 
    0.10222723f, -0.03857653f, 0.02481989f, -0.09598643f, -0.02040142f, -0.08193123f, -0.01566591f, 0.01880236f, 
    -0.19550484f, 0.05848204f, 0.05153396f, 0.01848903f, 0.24050663f, -0.38382694f, -0.24031956f, -0.34086138f, 
    -0.05341120f, 0.04551222f, -0.18422377f, 0.06915738f, 0.10385908f, 0.09076326f, 0.05812758f, 0.05267342f, 
    -0.14978790f, 0.19689324f, 0.13232958f, 0.19158539f, -0.04272624f, -0.07985303f, -0.03453465f, 0.07512243f, 
    -0.02310182f, -0.10746443f, -0.08700403f, 0.01114581f, 0.05992134f, -0.03870216f, 0.20721871f, 0.01149065f, 
    -0.01023207f, -0.00452767f, -0.00342592f, -0.17002882f, -0.01423294f, 0.02964623f, -0.03301227f, 0.00348242f, 
    -0.35221928f, -0.12655392f, 0.32950926f, -0.04449755f, 0.25968575f, -0.08309526f, 0.10508662f, 0.11901071f, 
    -0.02922042f, -0.08635097f, -0.01780723f, 0.01011797f, 0.25934851f, -0.35376835f, -0.01712121f, -0.22312105f, 
    0.06491810f, -0.13478719f, -0.00406698f, -0.03676092f, 0.08051703f, 0.11021896f, 0.09836584f, -0.05815110f, 
    -0.02025905f, -0.07769349f, 0.02918166f, -0.00483934f, -0.05350523f, 0.12226292f, -0.13351880f, -0.03264397f, 
    0.01613796f, 0.07708613f, -0.00893388f, -0.03595405f, 0.50548983f, 0.08553414f, -0.39800087f, -0.16507171f, 
    -0.09273119f, -0.09144014f, -0.02350008f, -0.19113220f, -0.01180015f, 0.04505596f, -0.16633756f, -0.03553625f, 
    -0.34791845f, 0.27832896f, -0.07986124f, 0.26583576f, 0.02958303f, -0.03101590f, 0.12052292f, -0.11313920f, 
    -0.10687204f, -0.09965888f, -0.12109405f, 0.06187866f, -0.31242785f, -0.21130848f, -0.19729710f, 0.04357124f, 
    0.06079225f, 0.05387991f, 0.02786335f, 0.10803845f, 0.01806283f, 0.06405369f, -0.03628226f, -0.02989180f, 
    -0.31288755f, 0.01771327f, 0.03610063f, 0.14138108f, 0.04113534f, -0.04592823f, -0.05679576f, -0.00001149f, 
    0.00381892f, -0.01176076f, -0.05356850f, -0.03050681f, -0.03375894f, -0.14990862f, 0.05781704f, -0.08420749f, 
    -0.01873256f, -0.00027807f, 0.00211288f, -0.02773199f, 0.05658313f, 0.02449021f, 0.06245367f, 0.04726835f, 
    -0.19444042f, 0.03488070f, -0.03434194f, 0.06635914f, -0.07784262f, -0.06753812f, 0.00891037f, -0.12306499f, 
    0.00952489f, 0.04809026f, 0.03309045f, 0.02212226f, 0.24506845f, -0.35036585f, 0.15415952f, 0.10151587f, 
    -0.00198612f, 0.04367615f, -0.08506040f, -0.14678666f, -0.02419933f, -0.00310411f, -0.04180183f, -0.01404248f, 
    -0.04031713f, -0.66120464f, 0.03250271f, 0.04107083f, -0.00905926f, -0.06076588f, -0.02581726f, 0.03010890f, 
    -0.07472210f, -0.03465499f, 0.07111600f, 0.00438064f, -0.21499260f, -0.10195304f, -0.06600136f, 0.01514115f, 
    -0.06661996f, 0.02772861f, 0.02348717f, -0.02304830f, -0.15379240f, -0.20343880f, 0.05980999f, -0.06161174f, 
    0.15954706f, 0.08168741f, -0.10186191f, -0.07651457f, -0.03535776f, -0.00230351f, 0.00006139f, -0.05946511f, 
    0.04831216f, 0.01821097f, -0.02247020f, -0.05381634f, 0.12712769f, 0.32163173f, 0.26963598f, 0.08656507f, 
    -0.14528477f, -0.07041197f, 0.12498470f, 0.10557131f, -0.07562990f, -0.06512602f, 0.10875133f, -0.12117172f, 
    0.06915922f, -0.07810131f, 0.04199950f, -0.05183260f, -0.08970240f, -0.06671667f, -0.14577329f, -0.04084655f, 
    -0.02266871f, -0.00868317f, 0.01402620f, -0.03547471f, -0.30840966f, 0.01249024f, -0.12068335f, 0.07726891f, 
    -0.13169518f, 0.14969464f, 0.09427441f, 0.05418342f, 0.04095538f, 0.00940686f, -0.05249954f, -0.02267414f, 
    0.34960556f, -0.26554981f, -0.46055311f, -0.45126864f, 0.01967714f, 0.01757394f, -0.13566329f, 0.06449962f, 
    0.02718729f, 0.07885630f, 0.04335540f, 0.01444466f, 0.20720220f, -0.32159624f, -0.04907040f, -0.15851662f, 
    0.07228144f, 0.05130399f, 0.01548627f, -0.09753340f, 0.02838588f, -0.07807393f, -0.07565260f, -0.15130430f, 
    -0.35195929f, -0.17282413f, -0.02126841f, 0.08922842f, -0.06710325f, -0.16900533f, 0.06278748f, 0.08069959f, 
    -0.09013651f, 0.00121704f, -0.00063587f, 0.03051962f, 0.16311717f, 0.01020657f, 0.09735408f, -0.08161840f, 
    0.01386866f, -0.00486196f, -0.02970925f, -0.03139155f, -0.00144670f, -0.01507991f, -0.01290397f, -0.01167215f, 
    -0.39471748f, 0.31294924f, 0.13832678f, 0.16850179f, -0.16705301f, 0.05474893f, 0.15765676f, -0.02297830f, 
    0.01194671f, -0.01872223f, -0.01335782f, -0.05399833f, 0.52990443f, -0.42130396f, 0.00394731f, -0.32597074f, 
    0.08504669f, 0.05262821f, -0.07249674f, 0.16296768f, 0.01950025f, -0.04581052f, 0.01277521f, 0.02629161f, 
    -0.12295455f, -0.11810110f, 0.02211550f, 0.11592899f, 0.03924245f, -0.03682082f, -0.03344913f, 0.15456124f, 
    -0.06428909f, 0.05135148f, 0.03916131f, 0.06113526f, -0.08699110f, -0.01242764f, 0.12369011f, 0.09496024f, 
    0.03461362f, -0.00689766f, -0.04432378f, 0.07698753f, 0.05280522f, 0.08096887f, -0.28848055f, -0.18262655f, 
    0.04826128f, -0.12152927f, -0.34432283f, -0.15835597f, -0.15966250f, 0.10690391f, 0.17197582f, 0.18612012f, 
    -0.04550166f, -0.11110287f, -0.02446985f, 0.07115168f, -0.06846274f, -0.04106895f, 0.07684398f, 0.03940213f, 
    -0.08749887f, 0.00456366f, 0.01346552f, 0.05949287f, 0.11952373f, 0.12454524f, 0.06322624f, 0.08073400f, 
    -0.08001214f, -0.03094038f, -0.07395075f, 0.10251950f, 0.04018815f, 0.01055808f, 0.01573804f, -0.03980680f, 
    -0.01901062f, -0.09613851f, -0.02599109f, -0.12408624f, -0.24291570f, -0.24365197f, -0.09164140f, 0.18350963f, 
    -0.10618085f, -0.05924860f, -0.03406102f, 0.01688827f, -0.06155957f, 0.03194751f, -0.01893580f, -0.05736351f, 
    -0.34389025f, 0.18726541f, 0.14653057f, 0.12937957f, -0.11199541f, -0.13280930f, -0.07417517f, -0.09001438f, 
    -0.05555965f, -0.01885845f, -0.00227568f, 0.08382887f, 0.10074239f, 0.02617571f, -0.00060700f, -0.06218307f, 
    0.00138954f, -0.07500024f, 0.03900630f, 0.04765198f, 0.03323008f, -0.04079061f, -0.05746906f, -0.06637581f, 
    -0.11546703f, -0.00519693f, 0.08317554f, 0.18068253f, 0.07258489f, 0.08852156f, -0.05290385f, -0.14162019f, 
    -0.01853308f, 0.02187181f, 0.02859844f, -0.02727616f, -0.14416438f, -0.11150539f, -0.07252369f, -0.04297613f, 
    0.13415954f, -0.00621367f, -0.01578004f, 0.05267427f, 0.03892248f, 0.12971357f, 0.12912062f, 0.12960105f, 
    0.30078632f, 0.22263575f, -0.04484126f, -0.13415372f, 0.03576738f, -0.02615557f, -0.03844250f, -0.04691170f, 
    0.00953309f, 0.08699432f, 0.06955231f, 0.05656927f, 0.35632727f, -0.14244252f, -0.23413050f, -0.12534256f, 
    0.04022979f, 0.15328901f, 0.14341749f, -0.10728637f, 0.06473220f, -0.05511092f, -0.12236846f, -0.15753032f, 
    0.14759314f, 0.05797485f, -0.09505640f, -0.33659163f, -0.04782264f, -0.02431436f, 0.11239178f, -0.02874737f, 
    0.11790633f, 0.11782709f, 0.06291728f, 0.10891369f, -0.11764397f, -0.02069214f, -0.27932122f, -0.21423849f, 
    -0.11268818f, 0.01032875f, -0.07335170f, -0.08535585f, 0.01676621f, 0.09030920f, 0.04892715f, 0.03270745f, 
    -0.09459330f, -0.49623883f, -0.43880677f, -0.42038202f, 0.03207354f, 0.24504890f, 0.13834555f, 0.08916371f, 
    0.13207935f, -0.00289476f, 0.10933309f, -0.00219232f, 0.20647067f, -0.44188789f, -0.20080014f, -0.02325787f, 
    -0.05485373f, 0.08903725f, -0.04980676f, 0.12113534f, 0.05924591f, 0.07121863f, 0.06449144f, 0.00608147f, 
    0.44593379f, -0.07701444f, -0.00832775f, 0.11084308f, 0.16135299f, 0.06869078f, 0.01500705f, 0.06235263f, 
    0.18195353f, 0.05116252f, -0.01248026f, -0.22619930f, 0.03665429f, -0.34383979f, -0.12916587f, 0.28007364f, 
    -0.10314181f, 0.00390163f, -0.03589555f, -0.01576350f, -0.07820414f, 0.15389611f, -0.07626641f, 0.08146597f, 
    0.22644740f, 0.05533791f, -0.11997195f, -0.11841210f, 0.16286436f, 0.09771648f, 0.21071333f, 0.00169112f, 
    0.01389693f, -0.08870732f, -0.03057628f, -0.05591536f, 0.35878131f, -0.23753925f, -0.16110009f, -0.28295046f, 
    0.07534323f, 0.09137396f, -0.00456728f, 0.07952658f, 0.05100166f, 0.03682370f, -0.08819614f, -0.23475285f, 
    0.09183642f, -0.01242605f, -0.23416242f, 0.24876925f, 0.07940137f, -0.00815395f, 0.08894741f, -0.08416191f, 
    0.03209202f, 0.18997023f, 0.05179431f, -0.12861808f, -0.15251273f, -0.25861138f, -0.30692926f, -0.45101112f, 
    -0.09041902f, -0.22473395f, 0.01339886f, -0.08483753f, 0.08548272f, -0.01197448f, -0.00060560f, 0.00766882f, 
    -0.29426843f, -0.01803799f, 0.09264969f, -0.12189161f, -0.01665309f, 0.00851615f, -0.02047501f, -0.02160175f, 
    -0.10516890f, -0.08119190f, -0.11843336f, 0.04987475f, -0.08079205f, -0.20211330f, 0.13398695f, -0.05168781f, 
    0.04146270f, 0.05209716f, -0.00850781f, 0.06911561f, -0.00049771f, -0.09972438f, 0.15087545f, -0.16894320f, 
    0.03951290f, -0.15166280f, -0.43926066f, -0.54085076f, -0.05180108f, 0.00657931f, 0.04438801f, 0.03179790f, 
    0.11770372f, -0.12838149f, -0.08065837f, 0.02421423f, -0.41939288f, -0.00959756f, 0.19338761f, 0.18214849f, 
    0.19315724f, -0.02319107f, -0.19840604f, -0.04266693f, -0.07951848f, -0.09776054f, 0.01242381f, -0.13522437f, 
    0.00965333f, -0.36025751f, 0.08128986f, -0.16769198f, -0.10278768f, 0.07885101f, -0.06025641f, -0.01879911f, 
    0.08051633f, 0.07688969f, 0.23476647f, 0.12495224f, -0.13483033f, -0.30090654f, -0.21529652f, -0.16852184f, 
    -0.11087770f, -0.12286583f, -0.09666545f, -0.17117605f, 0.03901154f, -0.00070328f, 0.04760351f, 0.01514401f, 
    -0.54826593f, 0.13805529f, 0.12783664f, 0.02416319f, -0.05901425f, -0.07544900f, -0.08853435f, -0.01657898f, 
    -0.05091409f, -0.08562700f, -0.05287160f, -0.03654652f, -0.25561944f, 0.05776770f, 0.07290427f, 0.01762505f, 
    -0.02875225f, -0.07394388f, -0.18143837f, -0.09040254f, -0.27100438f, -0.08038282f, -0.12235274f, -0.15137441f, 
    0.05961742f, 0.16334368f, -0.00714896f, 0.02283857f, -0.03450182f, -0.10463627f, -0.06377266f, -0.05978907f, 
    -0.00114647f, 0.07571294f, -0.00972458f, 0.09447838f, -0.22959960f, -0.49094281f, -0.51430082f, 0.20377211f, 
    0.06391554f, -0.00865341f, 0.20690167f, -0.04202401f, -0.05080411f, -0.02172129f, 0.01663943f, 0.02147028f, 
    -0.20328845f, -0.16613856f, 0.04402801f, -0.00984333f, 0.00044761f, 0.03550556f, -0.04572232f, -0.02834238f, 
    -0.07458240f, -0.12312729f, -0.19002827f, -0.36745894f, -0.28467062f, 0.09966080f, 0.08141714f, 0.09423218f, 
    0.08150264f, -0.13345313f, -0.07647119f, 0.07518518f, -0.05092802f, -0.13987027f, 0.07031009f, 0.00699594f, 
    -0.33845866f, -0.13498481f, 0.14759184f, 0.13505484f, -0.04839616f, 0.10357094f, -0.03948553f, -0.32739264f, 
    -0.04732334f, -0.20227800f, -0.09539712f, -0.00664937f, -0.03471962f, -0.07249043f, 0.20049010f, 0.01557805f, 
    -0.06063081f, 0.02359346f, -0.05093348f, -0.12161542f, 0.03274944f, -0.04018311f, -0.05364306f, 0.01934639f, 
    -0.36706582f, 0.07495079f, -0.01097960f, 0.30083323f, 0.13098754f, 0.09322244f, -0.00218215f, -0.04485139f, 
    0.06620725f, -0.00958688f, 0.05936827f, 0.10631464f, 0.11974294f, 0.20306483f, 0.20559265f, -0.09589396f, 
    -0.07737859f, -0.13936937f, -0.01925938f, 0.00307493f, 0.01830171f, -0.02454884f, 0.10327160f, -0.07591456f, 
    0.13887292f, 0.06553026f, -0.06778306f, -0.12020623f, 0.05442521f, 0.01303700f, 0.02570821f, -0.12868816f, 
    -0.03603042f, -0.01075437f, -0.11503040f, -0.10657517f, -0.50214946f, -0.52031505f, -0.36841100f, 0.19282565f, 
    0.14269018f, -0.08471996f, 0.06967165f, 0.12267691f, -0.01586803f, -0.08567785f, -0.07035109f, -0.04462177f, 
    -0.03507619f, 0.07951216f, -0.12484219f, -0.15921330f, -0.01736154f, -0.00373668f, 0.07977913f, -0.02769290f, 
    0.07210112f, 0.12102785f, 0.09269992f, 0.02240488f, 0.03569599f, 0.25253862f, 0.12689376f, 0.10526169f, 
    0.05320513f, -0.01027602f, 0.00400279f, 0.01367495f, 0.01248392f, -0.06821824f, 0.02774299f, -0.12660435f, 
    -0.05072398f, -0.45491576f, -0.47791213f, -0.16332185f, -0.16127013f, 0.09386753f, 0.01264836f, -0.00947963f, 
    0.07134910f, 0.03802787f, -0.01579288f, -0.04709883f, -0.03359159f, -0.08602478f, 0.00289036f, -0.03244503f, 
    -0.00983973f, 0.04410912f, 0.07683301f, 0.04024126f, -0.14029402f, -0.07627818f, -0.12902322f, -0.38046634f, 
    -0.05711409f, 0.02908914f, 0.07187633f, 0.04587895f, 0.12522309f, 0.02131705f, -0.01044204f, 0.04564421f, 
    0.01756839f, -0.08741584f, 0.07344541f, 0.05477176f, 0.45889783f, 0.13435797f, -0.44172627f, -0.07046673f, 
    0.14411680f, 0.06553508f, 0.11672920f, 0.20795573f, 0.11901625f, 0.00228638f, 0.06317592f, -0.06303952f, 
    -0.44549385f, -0.12610915f, 0.26240653f, 0.17431153f, -0.12138964f, 0.05015622f, -0.11532286f, -0.06685250f, 
    -0.07528228f, 0.21951091f, 0.08106630f, 0.04697661f, 0.05172318f, -0.14771490f, 0.04309886f, 0.02665198f, 
    0.13410029f, 0.08252821f, 0.04604097f, 0.12445839f, -0.08368222f, -0.13191196f, -0.06822562f, -0.09360216f, 
    -0.39053318f, -0.02905817f, 0.15359549f, 0.19637118f, 0.11590570f, -0.12586352f, -0.12269378f, 0.06828677f, 
    0.09909115f, 0.00181973f, 0.15155801f, 0.09375033f, -0.05279321f, 0.07887942f, 0.08506668f, -0.06268639f, 
    0.00959753f, 0.04319641f, 0.00303534f, -0.07433306f, -0.07293398f, -0.01309347f, -0.09197981f, -0.12827349f, 
    0.10552900f, -0.06153665f, 0.02962272f, -0.01803358f, 0.03798407f, -0.04167924f, -0.18233994f, 0.05696332f, 
    -0.02353830f, 0.08026350f, 0.07365701f, 0.08509395f, 0.58334953f, 0.03122812f, -0.00228157f, -0.17165577f, 
    0.22437559f, 0.06356981f, -0.00512777f, 0.00569271f, 0.05058524f, 0.08751887f, 0.23463307f, 0.00886835f, 
    0.22684439f, -0.21376000f, -0.18767257f, 0.03254756f, 0.00084319f, 0.00315981f, -0.05415349f, 0.00188315f, 
    0.05329299f, 0.14937352f, 0.06728084f, 0.09503829f, -0.39590943f, -0.07030717f, 0.08826613f, 0.16127476f, 
    0.03650530f, 0.13667290f, 0.06371367f, 0.01397281f, 0.03267204f, 0.15464617f, -0.01682434f, 0.02376737f, 
    0.09003769f, -0.09734842f, -0.06333181f, -0.11952386f, 0.02909075f, 0.02280754f, 0.01756001f, 0.00925348f, 
    -0.03033868f, 0.01956794f, -0.19215386f, -0.17106673f, -0.23949850f, 0.09252130f, -0.05551663f, 0.04564643f, 
    -0.07884768f, -0.01268255f, 0.03056542f, 0.00598099f, 0.03100663f, -0.01644178f, 0.05746956f, 0.03551224f, 
    0.09579746f, 0.01757768f, -0.09039976f, -0.06909674f, 0.18419659f, 0.00602353f, 0.07814059f, -0.00965655f, 
    0.11788555f, 0.05920764f, 0.07779445f, 0.15915704f, -0.11103161f, -0.18774448f, 0.14307562f, 0.14342083f, 
    0.09282319f, 0.07172677f, -0.01839071f, 0.13680157f, -0.27507383f, 0.05705523f, -0.00492353f, -0.30271101f, 
    -0.17021920f, -0.44606972f, -0.12039953f, 0.00553937f, -0.05679562f, 0.16932090f, 0.20355588f, 0.14549363f, 
    0.07416352f, 0.03747689f, -0.01133958f, 0.04728368f, -0.27623776f, -0.30068192f, -0.12948115f, -0.16259953f, 
    -0.08950908f, 0.07642961f, 0.00700257f, 0.07094527f, 0.10134605f, 0.01984747f, 0.10244946f, 0.01860492f, 
    0.02944483f, 0.03796853f, 0.05586655f, 0.01125789f, 0.02218159f, -0.14881389f, -0.02018790f, 0.15222475f, 
    0.16475406f, 0.01644412f, -0.02943814f, 0.04999479f, 0.04422546f, 0.04743556f, -0.10832046f, -0.24350610f, 
    -0.01114147f, -0.10051825f, -0.03867832f, -0.06887387f, -0.16484366f, -0.12207669f, -0.29421845f, -0.13267224f, 
    -0.46284053f, -0.09684508f, 0.27951303f, 0.27786562f, -0.03812157f, 0.10962535f, 0.09492009f, 0.19286864f, 
    -0.02575228f, 0.05604837f, -0.03419000f, 0.14401573f, -0.06656927f, 0.00461263f, -0.14009836f, -0.11581749f, 
    -0.03382867f, 0.05874075f, 0.03808873f, 0.10494334f, 0.00413322f, 0.05008743f, -0.10189670f, -0.13692470f, 
    -0.11056460f, 0.38793650f, -0.19439769f, -0.47941780f, -0.05705795f, 0.07244797f, 0.01870020f, -0.10912558f, 
    0.11351772f, -0.04292329f, -0.07696261f, 0.24584053f, 0.03431990f, -0.02684965f, 0.04351607f, -0.19991966f, 
    -0.11206560f, -0.01025018f, -0.01694699f, 0.02953060f, 0.06771967f, -0.03351437f, 0.12859824f, 0.09255425f, 
    -0.60710371f, 0.06657667f, -0.42936295f, 0.14747441f, -0.22366108f, 0.18370922f, -0.12263904f, 0.06239375f, 
    0.09662718f, -0.11889715f, -0.03343404f, 0.01891280f, 0.08968525f, -0.20232941f, 0.18141477f, -0.10546929f, 
    0.13914964f, -0.00519673f, 0.05052904f, 0.00836380f, -0.06528189f, 0.00278541f, 0.02385767f, -0.05730330f, 
    0.00740747f, 0.27286896f, 0.03411818f, -0.13157263f, -0.00784945f, -0.11178980f, 0.09190679f, 0.09427361f, 
    -0.02743306f, 0.03555779f, 0.06167486f, 0.01080327f, -0.27409628f, 0.38369468f, 0.07854629f, -0.19576077f, 
    -0.29678923f, -0.11631354f, 0.21454020f, 0.14930734f, 0.00445040f, 0.02944738f, 0.03587043f, 0.04002895f, 
    0.01529844f, -0.09859583f, -0.13445069f, 0.07121750f, 0.03651818f, -0.01236033f, 0.09715979f, -0.01393475f, 
    -0.02663015f, 0.05023724f, -0.04766561f, -0.03133599f, -0.27930880f, -0.24021441f, -0.12535049f, -0.03750047f, 
    0.11324781f, 0.02526996f, 0.14978945f, 0.10535880f, -0.02476726f, -0.10873995f, 0.00197244f, -0.02511524f, 
    0.04422258f, -0.15788475f, -0.01962749f, -0.28906566f, -0.11310987f, -0.07888753f, -0.06582508f, -0.01380215f, 
    0.04465942f, 0.02503333f, 0.02919325f, 0.11957882f, 0.21979629f, 0.08105088f, 0.17896272f, -0.08348846f, 
    0.13257587f, -0.07388830f, 0.02837945f, -0.11757299f, 0.08411815f, 0.02464560f, -0.15391307f, 0.03092893f, 
    0.02670986f, -0.46268639f, -0.18135114f, 0.07268232f, 0.11719992f, 0.14080982f, 0.05593354f, -0.01337442f, 
    -0.01095509f, -0.02674031f, -0.02816529f, -0.16595902f, -0.14042813f, -0.28220418f, 0.14252727f, -0.22068435f, 
    0.13151234f, 0.04906378f, 0.01211648f, 0.03283611f, 0.08050051f, 0.08369057f, -0.05527864f, 0.18986844f, 
    -0.16994163f, -0.14957863f, 0.00936966f, 0.02130439f, 0.08454120f, 0.04318932f, -0.16667214f, -0.07808852f, 
    -0.14369191f, 0.13417633f, -0.03303418f, -0.09854920f, -0.19745372f, 0.06702624f, -0.03696011f, -0.07382106f, 
    0.01669023f, 0.06780518f, 0.15306349f, 0.17608541f, -0.00096763f, 0.16707537f, -0.01234934f, -0.07450947f, 
    0.09662771f, 0.04300519f, 0.34850550f, 0.22699034f, -0.06218297f, -0.09751586f, -0.30341065f, -0.12715854f, 
    -0.09906998f, -0.01335408f, 0.05707569f, -0.04163405f, -0.03890050f, 0.17991230f, 0.12535731f, -0.00432684f, 
    -0.08111985f, -0.13630523f, 0.06438657f, -0.02725869f, -0.03329674f, -0.01852409f, -0.01060673f, -0.06929836f, 
    -0.05191780f, -0.19025801f, 0.13765620f, -0.37267432f, 0.00338941f, -0.05545019f, -0.12390976f, -0.02936192f, 
    0.00096974f, -0.09304384f, -0.00202654f, 0.13497601f, 0.31324813f, 0.00031897f, 0.10585994f, 0.04330824f, 
    0.11795343f, -0.19251095f, -0.04404688f, -0.07259352f, -0.11651250f, 0.02055219f, 0.03486162f, 0.05019269f, 
    0.01336964f, -0.11381572f, 0.22241138f, 0.23264161f, 0.03137355f, -0.11803513f, -0.07785070f, -0.05824587f, 
    0.17645279f, 0.01068483f, -0.08249316f, 0.15273954f, -0.13901806f, 0.12800999f, -0.05796653f, 0.14047536f, 
    -0.04360886f, -0.03855884f, 0.04041712f, 0.01729302f, 0.12535860f, 0.09912793f, 0.00178517f, -0.02667036f, 
    -0.06485236f, -0.23531108f, -0.22955558f, -0.19433691f, -0.14536166f, 0.11649528f, -0.01435126f, 0.01271493f, 
    0.09360448f, 0.08781242f, -0.26864722f, -0.15246135f, -0.33542860f, -0.08218687f, 0.19875258f, 0.12785536f, 
    0.03490488f, -0.06296183f, 0.10302524f, 0.13444401f, 0.08582005f, 0.07605766f, 0.06951383f, -0.00700095f, 
    0.07583218f, -0.00918104f, 0.05447347f, -0.24239789f, 0.00375609f, 0.08455580f, 0.05005180f, -0.00932762f, 
    0.11804751f, 0.02418204f, 0.09973423f, 0.12926522f, -0.23242587f, -0.00505095f, -0.18807319f, 0.03276872f, 
    0.04794141f, -0.02357308f, 0.01507952f, 0.04188861f, 0.08284388f, 0.00473112f, 0.09122699f, 0.02038521f, 
    0.03269110f, -0.19380878f, 0.12744345f, 0.59830886f, -0.03664291f, 0.12838244f, -0.19536158f, -0.02235488f, 
    -0.12364984f, -0.06048172f, 0.08748155f, -0.05626414f, 0.06643660f, 0.34230590f, -0.52897811f, -0.07681116f, 
    0.03229211f, 0.06062983f, 0.18757200f, 0.04449261f, -0.05186341f, 0.01382974f, -0.00134465f, 0.05262061f, 
    -0.03165979f, -0.20257193f, 0.19209641f, -0.53070581f, 0.13495390f, 0.01016802f, -0.12700360f, -0.06045635f, 
    -0.05191799f, -0.08224728f, -0.09936380f, 0.03003573f, -0.11619715f, -0.00456530f, -0.09712899f, -0.22225419f, 
    -0.16238533f, -0.14579807f, 0.07190414f, 0.16323239f, -0.01582160f, 0.04676909f, 0.04695183f, -0.04965406f, 
    -0.20322295f, -0.14040138f, -0.44143900f, 0.06766488f, 0.07683580f, 0.14182775f, 0.12681797f, 0.19305089f, 
    0.07709864f, -0.08860025f, -0.02897012f, -0.13137129f, -0.02587164f, -0.00429437f, -0.29249719f, -0.00787068f, 
    0.02200047f, 0.13828567f, 0.16656181f, -0.02698805f, 0.03306920f, 0.01834397f, 0.00302713f, 0.11016509f, 
    -0.05791074f, -0.37284002f, -0.08699670f, 0.16928032f, 0.08840806f, 0.19273673f, 0.12656905f, -0.09936035f, 
    0.06007841f, -0.19111873f, -0.16999325f, -0.00785469f, -0.11800994f, -0.21444014f, -0.28697842f, -0.48378488f, 
    -0.31785816f, -0.04644566f, 0.06423791f, 0.02717243f, 0.05896454f, 0.00059447f, 0.04138230f, -0.01853753f, 
    0.09554998f, -0.12143539f, 0.11406114f, -0.05576999f, 0.08296041f, -0.01405576f, 0.04114746f, -0.01969391f, 
    0.04254036f, 0.00935098f, 0.19171771f, 0.20924228f, 0.01613293f, 0.35936844f, -0.20815922f, -0.10367200f, 
    -0.16839316f, -0.09005266f, 0.05291157f, 0.01533961f, 0.05740457f, 0.11062346f, 0.04754886f, -0.05938467f, 
    -0.08727328f, -0.28631458f, 0.06608864f, -0.14848635f, 0.16613643f, -0.01011151f, 0.04917541f, 0.15645756f, 
    0.01304993f, 0.04368618f, -0.12873705f, 0.07967860f, 0.03245993f, -0.35016602f, -0.30390024f, -0.02834382f, 
    0.12895025f, -0.14878222f, 0.10933858f, 0.00072164f, -0.04750926f, -0.00855567f, -0.10049037f, -0.07938729f, 
    -0.42610848f, 0.38510290f, -0.20813744f, -0.10388139f, 0.01435955f, -0.21708688f, -0.01250830f, -0.15699688f, 
    0.01239446f, 0.04750992f, 0.03473909f, -0.10552792f, -0.26664373f, -0.49507076f, 0.03965210f, 0.11035519f, 
    -0.06737393f, 0.02158510f, 0.06989346f, -0.00797249f, -0.13728265f, 0.08676323f, -0.07851096f, -0.05007027f, 
    0.16893694f, -0.19535768f, 0.10721026f, -0.19790544f, -0.03619166f, 0.01882507f, -0.14959033f, 0.09053172f, 
    0.06208416f, 0.00505408f, 0.05776368f, 0.01023661f, -0.35018137f, 0.08180362f, -0.18005492f, -0.35351849f, 
    -0.18944886f, -0.11752398f, 0.05619441f, 0.02074048f, 0.10036481f, -0.03417941f, 0.06169236f, 0.00232064f, 
    -0.27288744f, -0.09745079f, -0.08174764f, -0.00453413f, -0.06411006f, 0.08719945f, 0.03239474f, 0.02546933f, 
    0.02038136f, 0.10616163f, 0.03088902f, 0.02498102f, -0.09822780f, -0.06550026f, -0.31846514f, 0.16223812f, 
    -0.02916294f, 0.07593708f, 0.13792981f, 0.04592997f, 0.03565593f, 0.04383279f, 0.05413905f, -0.01801937f, 
    0.13692398f, 0.02370517f, 0.20623940f, -0.35437092f, -0.16117541f, -0.08503053f, -0.09444999f, -0.00114232f, 
    0.10431629f, -0.09329093f, 0.03589595f, -0.06292542f, 0.20026419f, -0.02270382f, 0.34569892f, 0.26272112f, 
    0.04244006f, -0.08770686f, -0.12260933f, -0.14119203f, 0.07483909f, 0.05514906f, 0.11629406f, 0.04594245f, 
    0.06974391f, -0.01716519f, -0.12053304f, -0.22083773f, -0.00400513f, -0.02072931f, 0.05203743f, -0.14857389f, 
    0.01256268f, -0.00080265f, -0.00206653f, 0.00415916f, -0.27288696f, 0.04630913f, -0.31078941f, 0.42160687f, 
    0.04029774f, -0.15886222f, -0.18960331f, -0.16523230f, 0.08276477f, -0.13165824f, -0.02423241f, -0.09498473f, 
    -0.22716169f, -0.10761861f, -0.15080309f, -0.15167823f, -0.00742243f, -0.10893720f, 0.06533308f, 0.02641268f, 
    -0.01961507f, 0.01114673f, -0.00374484f, -0.04950247f, 0.00874771f, 0.30528480f, -0.01266303f, -0.07643486f, 
    -0.11275247f, -0.13068084f, -0.01631973f, 0.04439156f, -0.00352525f, 0.03995044f, 0.03483216f, 0.03623547f, 
    -0.13490185f, 0.19072236f, -0.18172240f, -0.06320503f, 0.04460176f, -0.21598536f, 0.07932616f, -0.08419640f, 
    0.03623313f, -0.05464989f, 0.04230767f, -0.13035086f, 0.02810881f, -0.01072358f, 0.09337823f, -0.07468672f, 
    0.05003602f, -0.02525381f, 0.01600616f, 0.05517647f, 0.02059248f, 0.06479370f, 0.12319350f, 0.04461375f, 
    0.14156879f, 0.44268098f, -0.46590352f, -0.03370618f, -0.00228138f, 0.05579830f, -0.00854931f, 0.02159840f, 
    0.00257346f, -0.09478537f, -0.07666114f, -0.13420916f, 0.19096468f, 0.13782091f, -0.13916832f, 0.18230726f, 
    -0.00958572f, 0.08167682f, -0.01589946f, 0.00508273f, 0.16915950f, -0.15114301f, -0.00740921f, -0.02829770f, 
    -0.12415191f, -0.05766901f, -0.04752177f, 0.04893403f, 0.10853650f, -0.20918600f, -0.07649951f, 0.14359348f, 
    0.00993345f, -0.07560459f, -0.02625008f, -0.04970592f, 0.04677663f, 0.17310262f, 0.45758569f, -0.48693106f, 
    -0.05701404f, -0.16853021f, -0.07016520f, -0.06357594f, 0.00396703f, 0.03313588f, 0.10994472f, 0.06354689f, 
    -0.20199373f, -0.05648196f, 0.17010814f, 0.22194545f, 0.02540103f, 0.04880817f, -0.03063571f, -0.07319040f, 
    0.12072708f, -0.01530886f, -0.03861279f, 0.08782547f, 0.01802796f, -0.29466355f, 0.15251267f, -0.19038734f, 
    -0.10297391f, 0.08578881f, 0.08411288f, 0.09800643f, 0.04262827f, 0.03303425f, -0.02867328f, 0.07153840f, 
    0.12468272f, -0.04117043f, 0.04093492f, 0.15031643f, 0.18122852f, -0.00933455f, 0.08877443f, 0.06547619f, 
    0.06125484f, 0.00293618f, -0.07674102f, 0.06091384f, -0.12893897f, 0.16978312f, -0.08511122f, -0.33862171f, 
    -0.14718065f, -0.16618799f, 0.06649970f, -0.00828671f, 0.05555443f, 0.05625492f, 0.23469304f, 0.14962220f, 
    0.09642716f, 0.11273860f, -0.15602063f, -0.01683759f, -0.10842938f, -0.09397342f, -0.24188542f, 0.03844627f, 
    0.00711705f, -0.05664990f, 0.07166701f, 0.07079510f, 0.22671100f, 0.25728762f, 0.26085627f, 0.26176468f, 
    0.00590510f, -0.06445944f, -0.10357949f, -0.17966162f, -0.03889934f, 0.04855879f, 0.11122726f, -0.12189159f, 
    0.09437529f, -0.09760838f, 0.00307289f, -0.17611861f, 0.14372499f, 0.07125547f, -0.04936935f, 0.23539317f, 
    -0.06374767f, 0.02466434f, -0.04507655f, -0.04021127f, 0.05484502f, -0.23127453f, 0.07402718f, 0.06514497f, 
    0.12320763f, 0.05436452f, 0.06489612f, -0.07482218f, 0.00200925f, -0.04015472f, -0.01829694f, 0.07147342f, 
    -0.07504877f, 0.05594851f, -0.01062372f, -0.36359614f, -0.10415014f, 0.03880953f, 0.08744423f, 0.00513563f, 
    -0.01565262f, 0.05754786f, -0.07990212f, -0.06865344f, 0.06618824f, -0.17851344f, -0.19295502f, 0.26024508f, 
    0.00238401f, -0.01758622f, -0.11526626f, -0.11136605f, 0.09740587f, 0.00111815f, -0.07189930f, -0.03517564f, 
    0.13744660f, -0.14260514f, 0.16726345f, 0.12146413f, 0.09290793f, -0.26890320f, 0.14975767f, 0.03364890f, 
    0.03099415f, -0.06065046f, -0.03514503f, 0.07329533f, 0.12468506f, -0.03892329f, 0.27554867f, 0.19552891f, 
    0.04255825f, -0.05822814f, 0.06812302f, 0.06698892f, -0.10201167f, 0.02849001f, -0.49636582f, -0.08206979f, 
    0.33521408f, 0.47027338f, -0.10387466f, -0.07387361f, 0.14014998f, -0.14296059f, -0.11436107f, 0.06025331f, 
    -0.12708624f, 0.09159699f, -0.05501806f, 0.03743441f, 0.02374070f, 0.21998458f, 0.00771897f, 0.17259608f, 
    -0.05288471f, 0.00257785f, 0.05253140f, -0.00540779f, -0.10239984f, 0.11273991f, 0.03166587f, 0.22102937f, 
    -0.13047375f, -0.15408029f, 0.12482163f, 0.06275012f, 0.06054438f, 0.10267496f, 0.06658542f, -0.01629973f, 
    -0.05550849f, -0.01081014f, -0.03522921f, -0.11654473f, -0.08381438f, -0.46899417f, 0.01115273f, -0.11070038f, 
    0.03563869f, -0.03090173f, 0.10325849f, 0.07482468f, 0.03663594f, 0.01618803f, 0.04513761f, 0.04385503f, 
    -0.10157839f, 0.17567994f, -0.18395023f, -0.21086577f, -0.11076866f, -0.08162677f, 0.07558151f, 0.04279019f, 
    -0.03582755f, 0.03213901f, 0.02195697f, 0.18250063f, -0.05213428f, -0.10929946f, 0.08003675f, -0.00080995f, 
    -0.15423605f, -0.02229889f, 0.06741191f, -0.01433726f, 0.15247293f, -0.01678025f, 0.01123570f, -0.03047445f, 
    -0.03255151f, 0.05743652f, 0.19173993f, 0.07755578f, -0.02427089f, 0.04007553f, 0.01402415f, -0.13933656f, 
    0.03193431f, 0.00045864f, 0.09379599f, -0.01378238f, -0.04494762f, 0.02467515f, -0.20929530f, 0.17781422f, 
    -0.10458908f, 0.08323597f, 0.19092382f, -0.04571515f, -0.06178625f, 0.17710505f, 0.03682763f, 0.23854777f, 
    -0.39238971f, -0.24139538f, -0.35031480f, 0.13032120f, -0.11802318f, 0.09300643f, 0.01446039f, 0.08679314f, 
    -0.02117412f, 0.11022582f, 0.12119761f, 0.03512090f, -0.25383836f, 0.28678149f, 0.00341036f, -0.03558421f, 
    -0.04167781f, 0.08757330f, -0.08815182f, 0.05521160f, 0.08457438f, -0.03631223f, 0.10419792f, -0.07693951f, 
    0.09218837f, -0.01058251f, 0.22561282f, -0.02874348f, -0.04002434f, 0.00950194f, 0.05151846f, 0.16690202f, 
    0.00498969f, 0.12569807f, 0.08871340f, 0.02439930f, -0.12261101f, -0.22270873f, 0.10424860f, 0.04339624f, 
    -0.16002019f, -0.14134704f, -0.07979957f, -0.10841154f, 0.08818509f, 0.07190361f, 0.01580897f, 0.00899606f, 
    -0.40474212f, 0.14105390f, -0.24688371f, 0.09552144f, 0.03966330f, -0.02372881f, 0.08829018f, 0.00632047f, 
    -0.14777400f, -0.01107452f, -0.12050786f, 0.04696336f, -0.40558302f, 0.01276570f, -0.11723021f, -0.00010617f, 
    0.01543885f, 0.07534413f, -0.04996443f, -0.03160473f, 0.01964769f, 0.08422404f, 0.01321078f, 0.00870148f, 
    -0.38469777f, 0.24473612f, 0.10713115f, 0.03155913f, 0.07787612f, 0.13276593f, 0.02507704f, 0.17033307f, 
    -0.17735368f, -0.00708029f, -0.16013697f, -0.22045326f, 0.13716049f, -0.03498853f, 0.32086962f, -0.15785669f, 
    -0.15103740f, 0.01235036f, 0.08907984f, -0.13317394f, -0.00578075f, 0.00409706f, -0.01459318f, -0.14385113f, 
    -0.33035234f, 0.17279322f, -0.18814115f, -0.08827533f, 0.05156128f, 0.06118070f, 0.10969082f, -0.11221636f, 
    -0.10257956f, -0.01244822f, -0.16672063f, -0.27163270f, -0.13157430f, 0.12728791f, -0.07198887f, -0.07692128f, 
    0.06051681f, 0.05271697f, 0.06338008f, 0.02410604f, -0.08846873f, 0.02617004f, -0.18662909f, -0.06562133f, 
    -0.07112899f, 0.00175877f, 0.47087169f, 0.11342164f, -0.10136130f, 0.12831524f, -0.14219159f, -0.01437800f, 
    -0.01061966f, -0.19710526f, 0.32231656f, 0.10012483f, -0.06570847f, -0.18084183f, -0.47265416f, -0.14414139f, 
    -0.04733157f, 0.01031926f, -0.00416365f, 0.00926613f, 0.06164947f, 0.10455615f, -0.02010276f, -0.06940449f, 
    -0.12053528f, 0.00776924f, -0.09913445f, -0.18504944f, -0.11948937f, -0.12958722f, -0.00789229f, -0.05438370f, 
    -0.19864440f, 0.04476981f, 0.00533536f, -0.05895655f, 0.05030983f, -0.10512646f, 0.11963918f, -0.15876377f, 
    0.03984409f, 0.03132287f, 0.00281900f, 0.06656300f, -0.00555844f, -0.00092352f, -0.10842958f, -0.08595159f, 
    -0.28904802f, 0.28481373f, -0.41180623f, 0.11494257f, 0.09116112f, 0.09831951f, 0.00358522f, 0.06275973f, 
    -0.01003386f, 0.03260159f, -0.03523977f, -0.00550947f, -0.03619575f, -0.19350033f, -0.05752691f, -0.08177054f, 
    -0.02165206f, -0.20938146f, 0.00317933f, -0.15182921f, -0.17648979f, -0.02043942f, -0.13330232f, -0.06257078f, 
    -0.15903392f, 0.44793370f, 0.16202998f, 0.09407587f, 0.04558618f, 0.00355766f, 0.06622614f, 0.23198891f, 
    0.10614455f, 0.07732844f, 0.19328237f, 0.15101348f, -0.15922216f, -0.39892912f, -0.21250635f, -0.06155663f, 
    -0.11216389f, -0.01898056f, -0.20834586f, -0.06765953f, 0.07296477f, 0.02057854f, 0.08970160f, 0.04979078f, 
    -0.14928886f, -0.37178791f, 0.20322055f, -0.18597426f, -0.22653869f, -0.29773700f, 0.15060696f, 0.16405965f, 
    -0.18076880f, 0.01326816f, 0.10430487f, -0.12064072f, 0.06030143f, 0.08578594f, -0.11386377f, 0.00919047f, 
    -0.17039351f, -0.32177544f, 0.14819916f, -0.07800675f, -0.06609218f, 0.09209944f, -0.22891799f, -0.03834750f, 
    -0.28116351f, 0.08397090f, -0.19463646f, -0.14272802f, -0.14218356f, -0.06022513f, -0.09564880f, 0.00207662f, 
    -0.03537595f, 0.12687911f, 0.09114692f, 0.12280692f, 0.03520280f, -0.23398745f, -0.00073501f, 0.06098251f, 
    0.13004437f, -0.06755963f, -0.04219205f, -0.06803530f, -0.05220677f, 0.01418313f, -0.07694753f, -0.26719257f, 
    -0.18956727f, 0.40481663f, -0.08943140f, -0.08868869f, 0.00747410f, -0.05622634f, -0.06088446f, 0.17911470f, 
    -0.13788460f, -0.29704759f, -0.18265834f, -0.34119838f, -0.00465384f, -0.11610337f, -0.12654848f, 0.01569017f, 
    0.01207352f, -0.09340930f, 0.13281518f, -0.02836126f, -0.15471366f, -0.13148265f, -0.08114481f, 0.06487674f, 
    -0.21733809f, -0.13928051f, -0.02810514f, 0.04145589f, -0.19106734f, 0.05595741f, -0.36756760f, 0.08688548f, 
    -0.08711370f, -0.12840433f, 0.05576851f, 0.06159431f, -0.24377604f, 0.17143002f, -0.22759023f, 0.11101092f, 
    -0.22417474f, 0.07303023f, 0.04969548f, -0.15944113f, 0.11589612f, 0.20472637f, -0.07336310f, 0.11531571f, 
    -0.18752348f, -0.14229399f, 0.10462437f, 0.25298098f, -0.02936151f, 0.08190902f, 0.07242981f, 0.15735219f, 
    -0.09613439f, -0.16856645f, 0.04788469f, 0.11682926f, -0.07439475f, -0.14687392f, -0.03237363f, 0.14324255f, 
    -0.10963425f, -0.06540797f, -0.06865656f, -0.22263612f, 0.08936780f, 0.08739137f, 0.00365936f, -0.09803853f, 
    -0.20898037f, -0.02154844f, 0.08107487f, 0.07582758f, -0.07984204f, 0.11537679f, -0.07943548f, 0.01116337f, 
    0.06005856f, -0.17413650f, -0.14033723f, -0.24000989f, 0.15539853f, 0.19972523f, 0.01484169f, -0.10920894f, 
    -0.04943910f, 0.08679552f, 0.07769444f, 0.20399641f, -0.14926036f, 0.10322790f, 0.01458259f, 0.04069383f, 
    0.02104114f, -0.16329049f, 0.02082184f, 0.06932833f, -0.00711779f, 0.14722447f, 0.05816474f, 0.05116178f, 
    0.10898263f, 0.03560296f, -0.03758469f, -0.05671902f, -0.12224226f, 0.12753920f, 0.02707028f, -0.09923562f, 
    -0.00651116f, -0.00777897f, -0.07846884f, -0.03996462f, -0.02193983f, 0.05190743f, -0.06453375f, -0.07690983f, 
    -0.20110594f, -0.23950991f, 0.04064195f, 0.18898177f, -0.03452414f, 0.11342323f, -0.03028164f, 0.07337108f, 
    0.08879101f, 0.14206566f, -0.03928076f, 0.00258661f, -0.25349098f, 0.14363268f, -0.07490726f, -0.01810658f, 
    0.07594745f, -0.05389827f, -0.08270156f, 0.04114569f, -0.16875589f, -0.10343889f, -0.26140723f, -0.39363602f, 
    -0.01273606f, 0.04053611f, -0.06419869f, -0.06169252f, -0.02447238f, -0.06155859f, 0.06657941f, -0.10168272f, 
    0.08802762f, 0.08335937f, 0.02706757f, 0.02740872f, -0.01419839f, 0.26661018f, 0.35921302f, 0.00581494f, 
    -0.05724670f, 0.17952245f, -0.09566436f, 0.27476662f, -0.08187892f, 0.10639077f, -0.03360009f, 0.06975877f, 
    0.05792346f, -0.17337580f, 0.08186419f, 0.18332863f, -0.09616662f, -0.04762491f, 0.04365852f, -0.08779045f, 
    0.05068217f, 0.14216886f, -0.43745586f, -0.01007119f, -0.12086585f, 0.01965958f, -0.04710257f, -0.01444333f, 
    -0.03406656f, 0.02709066f, 0.02221923f, -0.10296191f, 0.04511367f, -0.05761231f, -0.08990154f, -0.05460314f, 
    -0.10247138f, -0.05173427f, -0.17559190f, 0.08241041f, 0.01820331f, 0.01767199f, -0.01560032f, 0.05100156f, 
    -0.06814126f, 0.00969606f, 0.08215672f, 0.02125156f, -0.13799357f, 0.18773960f, 0.18478507f, -0.06550423f, 
    -0.01290611f, -0.06642178f, 0.08084895f, -0.04051121f, 0.06752810f, -0.13580546f, -0.07041162f, -0.09896886f, 
    -0.06431305f, 0.20390804f, 0.24300823f, 0.03333173f, 0.09302201f, -0.11556403f, 0.12179781f, 0.14778674f, 
    -0.15390205f, 0.13009264f, 0.12156913f, 0.12165196f, -0.36536834f, 0.10329811f, -0.00257072f, -0.18866627f, 
    0.01779789f, 0.10569379f, 0.03164003f, -0.06040549f, -0.04033510f, 0.03434198f, 0.00070314f, 0.05616587f, 
    -0.40015888f, 0.20362198f, 0.02733495f, 0.07650375f, 0.01936371f, 0.12710789f, -0.01694713f, 0.07506454f, 
    -0.06301838f, 0.11336750f, 0.04232614f, 0.10635000f, -0.06721145f, 0.13980256f, 0.09294503f, 0.14597012f, 
    -0.01736724f, -0.02442372f, 0.01835310f, 0.05786642f, 0.00369698f, 0.14611197f, 0.01464524f, -0.20982027f, 
    -0.10057754f, 0.12474961f, 0.11290424f, -0.27272686f, -0.09023015f, 0.00699131f, -0.12820412f, 0.05750302f, 
    0.03634651f, -0.26390758f, -0.33200148f, -0.22991441f, 0.04101503f, -0.04256237f, -0.03170726f, 0.20091440f, 
    0.14423548f, 0.00048600f, -0.05126264f, 0.05380347f, -0.00915970f, -0.18932277f, -0.10000341f, -0.02742684f, 
    -0.25829592f, 0.20018609f, -0.12777348f, -0.06628843f, -0.01329305f, 0.05434370f, 0.01358477f, 0.05318230f, 
    -0.07186753f, 0.03495271f, 0.05628297f, 0.09659168f, 0.13632061f, -0.18712136f, 0.05359568f, 0.11490323f, 
    0.02833824f, -0.14581189f, -0.00157107f, 0.09294572f, 0.01236246f, 0.04094646f, -0.28981778f, -0.27331093f, 
    0.13944663f, 0.09367237f, 0.13290802f, 0.16520834f, 0.03724855f, -0.16738510f, -0.08856721f, 0.20133205f, 
    -0.15658242f, 0.16099995f, -0.09007261f, 0.02602005f, 0.00796131f, 0.36430028f, 0.05140106f, -0.12144537f, 
    -0.04893204f, -0.15759027f, 0.08012000f, -0.00913026f, 0.04209070f, 0.20083053f, -0.01094220f, 0.01928942f, 
    -0.14121222f, -0.00520840f, 0.16311634f, 0.19037536f, 0.07838768f, 0.06534733f, -0.01539131f, 0.02296132f, 
    -0.00669055f, 0.08301393f, -0.00947014f, 0.09536249f, -0.25366089f, 0.25722387f, -0.27210227f, -0.07792386f, 
    -0.22757107f, -0.05661460f, -0.02938156f, -0.04272278f, -0.02753065f, 0.06759467f, -0.12099887f, -0.10731106f, 
    0.20108995f, -0.20190606f, 0.27690330f, 0.13338968f, -0.05527761f, -0.02102615f, 0.19622861f, -0.01875779f, 
    -0.13300867f, 0.05380529f, -0.09805356f, 0.04600231f, -0.19988032f, -0.08050869f, -0.03725716f, 0.14480263f, 
    0.04187750f, -0.12717952f, 0.07644603f, 0.07576139f, -0.13857609f, 0.07593074f, 0.05921977f, -0.12481546f, 
    -0.16537341f, 0.02860449f, 0.32885081f, 0.01788296f, 0.05734975f, 0.04012246f, 0.16264203f, -0.15494186f, 
    0.06163850f, -0.00311507f, -0.09233377f, 0.00829520f, -0.05587972f, -0.07636941f, -0.03567018f, 0.06335056f, 
    -0.04697764f, 0.08776505f, -0.09594199f, -0.01329039f, 0.02064269f, 0.04179945f, 0.28478000f, 0.20681408f, 
    -0.42340314f, -0.09459054f, -0.12519345f, 0.22655982f, 0.03556997f, -0.01446196f, 0.11642379f, -0.09249000f, 
    -0.06512999f, -0.07126275f, -0.01143693f, 0.16967849f, -0.17929967f, 0.15547882f, -0.21937181f, 0.02508671f, 
    0.00946769f, 0.13973504f, -0.06141538f, 0.02310196f, -0.22683333f, -0.03496632f, 0.01315356f, -0.07126472f, 
    -0.02128246f, -0.07883859f, 0.12961058f, -0.03570685f, -0.07131819f, -0.15692876f, 0.11398698f, -0.03538867f, 
    0.01513791f, 0.00175726f, -0.10946252f, -0.03440789f, 0.06160722f, -0.27946177f, -0.01880339f, -0.24325520f, 
    -0.03025910f, -0.23024932f, 0.01672706f, -0.12927455f, 0.02451935f, -0.01879919f, -0.06346904f, -0.03638807f, 
    0.12182438f, -0.26371661f, 0.12071741f, 0.10304011f, -0.01567160f, -0.06674822f, -0.09299617f, -0.04514010f, 
    -0.16627900f, -0.01230678f, 0.02796094f, -0.04809858f, 0.28088447f, 0.10127441f, 0.26855412f, -0.12345433f, 
    0.00939190f, 0.06115814f, -0.03773233f, 0.02397645f, -0.08848987f, 0.19883831f, -0.15011188f, 0.06406202f, 
    -0.02843818f, 0.24069583f, -0.07910243f, 0.08110578f, -0.05835437f, -0.06656931f, 0.10787564f, -0.06572161f, 
    0.13008273f, 0.11537793f, -0.04626564f, -0.03438671f, -0.02832455f, -0.03962201f, -0.06983487f, 0.05513605f, 
    0.00835516f, -0.00267895f, 0.13076745f, 0.16134328f, -0.11517528f, -0.09127492f, -0.12857923f, -0.06053917f, 
    0.24060869f, 0.31163126f, 0.10541075f, -0.13678668f, -0.02657568f, 0.02526625f, -0.01837915f, 0.05090742f, 
    0.01640256f, -0.00119605f, 0.08086980f, -0.05164684f, -0.46700519f, -0.14202267f, -0.03863933f, 0.10075392f, 
    -0.04749733f, 0.02122175f, 0.13351375f, 0.04213822f, -0.12016512f, 0.15987489f, 0.16081081f, 0.06143067f, 
    -0.36249444f, 0.10992340f, -0.13175453f, 0.17890689f, 0.06122806f, 0.10055882f, -0.05014328f, -0.11655511f, 
    0.02042287f, 0.06130894f, -0.05801205f, 0.05639039f, -0.18722774f, -0.13161786f, 0.22709030f, 0.13532566f, 
    -0.27194414f, -0.08888455f, -0.01027125f, -0.19759789f, 0.03553989f, 0.06498129f, 0.01200913f, -0.06761593f, 
    -0.58637714f, 0.20278524f, -0.44735181f, 0.17124602f, 0.14235112f, -0.20173794f, 0.02439570f, -0.10283577f, 
    0.04287552f, 0.06556810f, 0.04265752f, 0.01157430f, -0.12187950f, -0.27179733f, 0.08843981f, -0.06526743f, 
    0.01030824f, -0.17060402f, -0.21722160f, -0.07237060f, -0.01741530f, -0.13100396f, -0.00007920f, -0.04565835f, 
    -0.24259998f, 0.07329044f, -0.52114880f, 0.14257017f, 0.03282338f, -0.03905619f, 0.14565809f, 0.22094415f, 
    -0.05262153f, 0.09656235f, -0.08660681f, 0.14431429f, 0.13532940f, -0.31942245f, -0.16283312f, -0.34055325f, 
    0.14913227f, 0.00365351f, -0.02918392f, 0.00079172f, -0.10566638f, 0.01229499f, 0.18638024f, -0.20117310f, 
    0.05678273f, 0.05561707f, -0.34695244f, 0.12895244f, 0.14814521f, 0.10777039f, 0.11587653f, 0.01364249f, 
    0.08476227f, 0.21719936f, 0.14827174f, 0.03697648f, -0.18558906f, -0.53948987f, 0.07738065f, -0.07368144f, 
    0.13900922f, 0.01453070f, -0.08809839f, -0.02999527f, 0.03395783f, 0.02904874f, 0.14058153f, 0.14262003f, 
    -0.27677187f, 0.11321878f, 0.06939039f, -0.00592425f, -0.00510471f, -0.03628348f, 0.04119499f, -0.05470064f, 
    -0.06094340f, -0.12914823f, -0.05119157f, -0.04227148f, -0.18024734f, -0.43743858f, 0.07799456f, -0.05372934f, 
    -0.14521696f, -0.12128326f, -0.12288594f, -0.13586390f, 0.01007028f, 0.07918882f, 0.07887979f, -0.00137545f, 
    0.03632471f, 0.12773237f, -0.13047953f, 0.10186604f, -0.00237895f, 0.03358495f, 0.00664402f, 0.05895315f, 
    -0.09711829f, 0.00537343f, 0.05579978f, 0.10883054f, 0.18129037f, 0.04588000f, 0.01616845f, 0.01262425f, 
    0.01511567f, -0.04036728f, 0.13080616f, 0.16182652f, 0.11704950f, -0.08280633f, -0.00188133f, 0.09736279f, 
    -0.73740077f, 0.09968333f, -0.38907424f, 0.43329012f, 0.21322528f, -0.02723036f, 0.10290476f, -0.03943155f, 
    -0.01811498f, 0.07766978f, 0.16710943f, 0.21278384f, 0.41803420f, -0.03122493f, 0.38541108f, -0.10173754f, 
    -0.07342481f, -0.16234805f, -0.27254099f, 0.06605846f, -0.00265440f, -0.03695277f, -0.03503263f, 0.00785591f, 
    -0.42495692f, 0.14697430f, -0.36766911f, 0.27598965f, -0.03056488f, 0.08495712f, -0.00621101f, 0.03066145f, 
    -0.19947900f, -0.14667250f, -0.16989967f, -0.04534369f, 0.06052860f, -0.34392989f, -0.27458340f, -0.09930553f, 
    -0.15091421f, -0.25685847f, -0.04914615f, -0.02133329f, -0.00523056f, 0.02763520f, -0.06029275f, -0.08407687f, 
    0.45342961f, 0.21538797f, 0.11429924f, 0.07257321f, -0.26644471f, 0.14435294f, -0.16417068f, 0.07293370f, 
    -0.08287624f, 0.08364381f, 0.05157489f, -0.01547296f, 0.15766546f, -0.00104286f, 0.20313685f, -0.06055836f, 
    -0.05068751f, 0.03161536f, 0.01462732f, 0.05586806f, -0.04779347f, 0.03921878f, -0.00056652f, 0.04190696f, 
    0.14198384f, 0.12103866f, 0.22167583f, -0.06885219f, 0.01890919f, -0.01376002f, 0.04713998f, -0.00953725f, 
    -0.14390749f, -0.05347245f, -0.09390412f, -0.21381713f, -0.16810244f, 0.06654007f, 0.15621775f, -0.20138194f, 
    -0.04909174f, 0.02635191f, 0.12483229f, -0.05622382f, -0.01086082f, -0.00602409f, -0.00380692f, -0.05963579f, 
    -0.20231919f, 0.01323988f, 0.00597531f, 0.03585799f, -0.04092036f, 0.03570038f, 0.00323984f, 0.02166818f, 
    0.00049975f, 0.15788427f, 0.02303171f, 0.02590318f, 0.09106744f, -0.12924832f, 0.22851615f, 0.08209418f, 
    0.04246224f, 0.03898392f, -0.06303838f, -0.05952017f, -0.01601534f, -0.08908764f, -0.03702065f, 0.12266700f, 
    0.17654958f, 0.25287166f, 0.10271697f, -0.19092518f, -0.07325103f, -0.09833518f, -0.00439128f, 0.24773671f, 
    -0.11798579f, 0.05495838f, -0.12606275f, -0.01989087f, 0.16150123f, -0.05708285f, -0.22886582f, 0.25751004f, 
    -0.05719989f, 0.05914288f, -0.08768234f, -0.05795598f, -0.16800860f, -0.07587841f, -0.01663948f, -0.02215179f, 
    0.34728190f, -0.62161362f, 0.51548123f, -0.26025209f, 0.06178079f, -0.00488960f, 0.08143260f, 0.19095473f, 
    -0.02955400f, 0.06186081f, 0.16536571f, 0.00396759f, 0.00764390f, 0.02946517f, 0.10465586f, -0.07102481f, 
    0.03148257f, -0.01394624f, 0.01085606f, -0.06615184f, -0.09265741f, -0.03143445f, -0.06107801f, 0.00834548f, 
    -0.05262972f, 0.05507177f, -0.05940190f, -0.03396013f, 0.09666737f, -0.11699647f, 0.16238613f, 0.08493350f, 
    -0.02306903f, 0.03175774f, -0.20043653f, 0.18529344f, -0.01735684f, 0.12558126f, 0.17332529f, -0.34345394f, 
    -0.01635325f, -0.08916760f, 0.10647128f, -0.10440718f, 0.04942298f, -0.06565297f, -0.09027041f, -0.16047756f, 
    -0.09601710f, -0.19412662f, -0.14289629f, 0.17340153f, -0.10582906f, -0.13042817f, -0.11220261f, -0.06030601f, 
    0.02787303f, 0.08335169f, 0.06191647f, -0.11252800f, 0.28443515f, -0.26921338f, 0.10146450f, 0.18951707f, 
    0.05797739f, -0.07900410f, 0.03747718f, 0.14061260f, 0.03095673f, 0.05049909f, -0.01407603f, 0.04766902f, 
    -0.49687049f, -0.69076556f, -0.27384818f, 0.18279152f, -0.27105126f, -0.01935332f, -0.03214480f, -0.11913376f, 
    0.00116693f, 0.06567177f, -0.02081095f, 0.02071436f, -0.35377237f, 0.01398434f, -0.39598864f, -0.11514710f, 
    0.05841462f, 0.00624219f, -0.05311292f, -0.00569694f, 0.03776319f, 0.06426454f, 0.09954955f, 0.05600128f, 
    0.19402631f, 0.08790476f, 0.09916050f, 0.09129719f, 0.00338267f, -0.07308240f, 0.05410927f, 0.04203601f, 
    0.03514624f, -0.04426249f, -0.00053412f, 0.08736879f, 0.08004009f, -0.27894318f, 0.33504260f, -0.23841944f, 
    0.09457909f, 0.26446930f, 0.06306512f, -0.02298066f, -0.10444321f, 0.16092861f, 0.00102023f, 0.08090387f, 
    0.00027016f, -0.15919037f, 0.09422711f, -0.13612589f, -0.12080748f, -0.09923399f, -0.00214289f, -0.01866831f, 
    -0.12606153f, -0.09924753f, 0.19353876f, 0.12154017f, 0.02269547f, -0.29268298f, 0.07718555f, -0.21131870f, 
    0.00904102f, -0.13626096f, -0.03276818f, -0.07438575f, 0.00529753f, 0.04680311f, -0.03520376f, 0.05321298f, 
    0.30706072f, -0.27117395f, 0.13338149f, -0.04534830f, 0.10960077f, 0.01104893f, -0.00296925f, 0.10884149f, 
    -0.16049431f, -0.03511471f, 0.00232045f, 0.06742953f, 0.09056952f, -0.06927066f, 0.01177569f, 0.07659127f, 
    0.05475745f, 0.03906351f, -0.07683817f, -0.01684238f, 0.02300598f, -0.01187348f, 0.07669742f, 0.00007884f, 
    -0.03618850f, -0.07350077f, 0.40167764f, -0.00314764f, -0.01335679f, 0.06787202f, 0.01833425f, 0.00024821f, 
    0.00642572f, -0.13595957f, -0.06027376f, 0.00962550f, -0.06134309f, 0.16110289f, -0.11408745f, 0.07507688f, 
    0.18522917f, -0.01968256f, 0.08537339f, -0.07151677f, 0.00653611f, 0.18901792f, -0.01982355f, 0.04772808f, 
    0.01461279f, -0.28677008f, -0.04486763f, 0.12960467f, -0.07627724f, 0.06488913f, -0.05139515f, -0.10736957f, 
    0.05202641f, -0.03454191f, 0.00952884f, -0.11288334f, -0.17762917f, -0.25228018f, 0.15646359f, -0.00503506f, 
    -0.02831959f, 0.05333008f, -0.02686049f, 0.07114048f, -0.02323380f, 0.01393255f, -0.12378139f, -0.13432616f, 
    0.03056593f, -0.03143921f, -0.11831720f, -0.16182625f, 0.04818232f, -0.02358843f, 0.01545027f, 0.03657144f, 
    0.14128131f, 0.15151729f, 0.04903491f, 0.04724286f, -0.61400938f, 0.32171386f, -0.10677557f, 0.17326568f, 
    -0.17609814f, 0.13603508f, 0.03268401f, -0.08925360f, -0.01568413f, 0.15113480f, 0.13689737f, 0.02863434f, 
    0.11679543f, -0.06153195f, 0.16656494f, 0.16315104f, 0.04636188f, 0.11406694f, 0.06162422f, 0.06649594f, 
    -0.01211860f, 0.06512532f, 0.03737047f, -0.23149268f, 0.02733739f, -0.02343705f, 0.12751128f, -0.25061449f, 
    -0.04652482f, -0.09039451f, 0.14722814f, 0.03548018f, 0.05170953f, 0.01629622f, 0.02865499f, 0.05291095f, 
    -0.10932303f, -0.05573721f, 0.02324376f, 0.20586820f, 0.10524073f, 0.06246521f, 0.11556010f, -0.03249494f, 
    -0.07512690f, -0.08943193f, -0.20211864f, -0.18483087f, -0.60235792f, 0.08137847f, -0.39302754f, -0.00994224f, 
    0.03693664f, 0.03306669f, -0.00328997f, -0.03931893f, -0.13308443f, -0.01991787f, 0.00491478f, 0.10838650f, 
    -0.07350863f, 0.05000473f, 0.18662107f, 0.14581814f, -0.03470552f, -0.03662737f, -0.02594437f, -0.16163839f, 
    -0.01474147f, -0.06555716f, -0.03804276f, -0.06011166f, 0.07363239f, 0.03862797f, -0.10704639f, 0.03000622f, 
    0.03477985f, -0.04787761f, -0.00188639f, -0.01763018f, 0.03578171f, 0.05098156f, -0.05278737f, -0.05010453f, 
    -0.29635611f, 0.19732364f, 0.22185956f, 0.00736753f, -0.12603946f, 0.10089649f, -0.15414827f, 0.01602818f, 
    -0.20704544f, 0.03609568f, 0.20167273f, 0.07629050f, -0.49218157f, 0.39907911f, -0.48014942f, 0.35203442f, 
    0.07018864f, 0.07498898f, 0.05921526f, -0.13365053f, 0.03724078f, 0.03212208f, 0.09284728f, 0.04753355f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14130896f, 0.09958075f, 0.05964190f, -0.09411366f, -0.06402586f, 0.05220465f, 0.00145673f, -0.11229039f, 
    0.08596919f, 0.03673041f, 0.05156971f, -0.05775464f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
