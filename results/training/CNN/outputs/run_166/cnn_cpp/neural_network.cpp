#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35269380f, 0.96250528f, 0.62807500f, -0.14309120f, 0.60816842f, -1.47668648f, 0.31969330f, -0.49057889f, 
    -0.85891265f, -0.79456538f, 0.06468318f, 0.04519857f, -0.07197477f, -0.01469166f, 0.24600020f, 0.01492998f, 
    0.04521722f, 0.23024856f, -0.07162453f, -0.06723069f, -0.16148408f, -0.04659885f, 0.29816949f, 0.26675969f, 
    0.14101189f, 1.06816769f, 0.25918871f, -0.96712661f, -0.64113563f, -0.50386333f, -0.26133940f, 0.09846900f, 
    -0.67225146f, -0.12346978f, 0.00492123f, -0.65108085f, 0.11193361f, 0.13596793f, -0.26285985f, -0.51672912f, 
    -0.17938997f, -0.15096904f, -0.14317594f, -0.22372892f, -0.00212217f, 0.17298223f, 0.25466612f, -0.04149092f, 
    0.04381769f, 0.19029066f, -0.32634082f, 0.33691913f, -0.72055489f, -0.52272922f, -0.58478189f, -0.50800574f, 
    0.63772404f, 0.32603252f, -0.32207191f, -0.04584906f, 0.67432255f, 0.09731371f, -0.20130181f, -0.14539564f, 
    -0.15366292f, 0.19826621f, 0.32841468f, 0.39106798f, 0.30147150f, -0.02316741f, 0.19450878f, 0.18357509f, 
    0.34084070f, -0.25675893f, 0.34737757f, 1.01658452f, 0.14127542f, 1.03177285f, 0.18441628f, -0.00012074f, 
    0.81247801f, 0.12810159f, -0.07834242f, -0.42526183f, 0.27712700f, 0.27670938f, 0.45077202f, -0.00603408f, 
    0.57264167f, 0.10629159f, 0.21466652f, -0.35328481f, -0.22416876f, 0.09573117f, -0.35166332f, 0.01905915f, 
    0.25975463f, 0.21421511f, -0.17006734f, 0.08542016f, -0.83521068f, 0.98639989f, 0.61136919f, 0.61973166f, 
    0.76068044f, 1.06191003f, -0.10717770f, -0.93545663f, 0.23350359f, -0.37365794f, -0.37501693f, -0.07998282f, 
    0.15364620f, 0.48535034f, -0.33781308f, -0.13770077f, 0.08506709f, 0.09755527f, -0.40764344f, -0.04917619f, 
    -0.20063896f, -0.12913702f, -0.22845212f, -0.03693569f, -0.31341198f, -0.45225888f, -0.52809519f, -0.66383505f, 
    -0.63063031f, -0.57488120f, 0.50905955f, 0.11667126f, -0.53200674f, 0.44202527f, -0.18611816f, -0.35417488f, 
    -0.66084123f, -0.17387842f, -0.54560918f, -0.35051399f, -0.22622097f, 0.02334225f, 0.11364637f, 0.26565042f, 
    0.21509841f, -0.15407343f, 0.01288793f, -0.14716047f, -0.11064673f, 0.03733233f, -0.17100251f, 0.05019658f, 
    -0.63680923f, -0.95693272f, 0.14527698f, 0.65288681f, 0.17855607f, -1.04564106f, -0.03928883f, -0.14640231f, 
    -0.30891478f, 0.24271394f, 0.54042864f, 0.35340628f, -0.00464454f, -0.30484995f, 0.27012107f, 0.03601261f, 
    -0.27470067f, -0.30275601f, 0.18644233f, -0.50923568f, 0.15209641f, -0.22448860f, -0.34132323f, -0.83252120f, 
    -0.39705405f, 0.19982235f, -0.09711152f, 0.49769902f, -0.90258729f, 0.47625697f, 0.24121912f, -0.70195824f, 
    0.10290584f, 0.39433223f, 0.43696201f, 0.13483278f, -0.11642358f, 0.00927352f, 0.17505060f, 0.05913690f, 
    -0.05890946f, 0.37693599f, 0.23700218f, 0.02366944f, 0.05381348f, 0.23417367f, 0.10214172f, 0.13548560f, 
    -1.46188915f, 0.74457181f, -0.46241874f, -0.98802567f, -0.04871158f, 0.73193675f, -0.55205321f, -0.13655916f, 
    0.26200822f, 0.08442048f, 0.25106278f, -0.20149022f, 0.09732836f, 0.36958843f, 0.21774058f, 0.10556067f, 
    0.02165578f, -0.11912702f, -0.23048054f, 0.02258389f, 0.09804883f, 0.33666122f, 0.44395584f, 0.16303754f, 
    0.12651862f, -0.62863022f, -0.45807824f, -1.33805811f, -0.57741904f, 0.42322353f, -0.73350519f, 0.47062343f, 
    0.64852178f, -0.25696763f, 0.34285691f, 0.41207868f, -0.10918822f, 0.52771980f, -0.37520424f, 0.31597507f, 
    -0.14563309f, 0.05464990f, 0.02051189f, -0.27288929f, -0.27863374f, 0.12429456f, 0.04131390f, -0.13671187f, 
    0.10875267f, -0.02976069f, -0.88053447f, -0.72301739f, -0.70960462f, -0.41319308f, -0.03722392f, -0.69683731f, 
    -0.17902662f, 0.42536074f, 0.67356765f, 0.08803750f, 0.25458893f, -0.10059968f, 0.19646092f, 0.13945235f, 
    -0.04197938f, 0.27362546f, 0.11149768f, 0.08511100f, 0.39737034f, 0.17492382f, -0.22411628f, -0.31296688f, 
    0.19549808f, -0.10095802f, 0.03488982f, -0.82705623f, 1.45710969f, -0.31935677f, -1.00719190f, 0.78723717f, 
    -0.51052272f, 0.27084121f, 0.62863171f, -0.06622572f, 0.34315488f, -0.18354067f, -0.03761228f, -0.22417416f, 
    -0.32373393f, -0.38470888f, 0.16154738f, -0.10522977f, -0.17996392f, 0.07523274f, -0.06067985f, -0.29052448f, 
    -0.01974467f, -0.19940384f, -0.31357548f, -0.05893485f, 0.06150943f, -1.58248222f, 0.43564323f, 0.85108125f, 
    -0.25243714f, -0.22785918f, 0.86050820f, 0.85472226f, -0.45878902f, -0.16908504f, 0.09570713f, 0.23969586f, 
    0.13972914f, 0.16632243f, -0.15302691f, -0.56714797f, -0.04006445f, -0.05413284f, 0.12686701f, -0.10159251f, 
    -0.29643983f, 0.14840880f, 0.24868844f, -0.09250752f, 0.10094367f, -0.54539239f, -0.37535909f, -0.71166408f, 
    0.02641416f, 0.27487206f, 0.14189087f, 0.34984201f, -0.09709173f, 0.03318123f, -0.50971282f, 0.12613653f, 
    -0.12050441f, -0.12490183f, -0.31032214f, -0.46021807f, -0.33654955f, 0.50465268f, -0.82152385f, -0.30462071f, 
    -0.39481384f, 0.09109227f, 0.39372972f, 0.32899463f, 0.09314424f, 0.11365655f, 0.11117360f, 0.87077242f, 
    0.90564167f, -0.00930899f, -0.06320307f, 0.47662616f, -0.48360360f, 0.68034226f, -0.13535681f, 0.60504210f, 
    -0.58101219f, 0.00280252f, 0.06153180f, -0.08210094f, -0.35088384f, -0.25722978f, 0.16000965f, -0.13658035f, 
    -0.52852207f, -0.49584767f, 0.27196094f, -0.13998784f, 0.24041888f, -0.21249305f, -0.07940274f, 0.40793881f, 
    -0.25833187f, 0.49431527f, 0.78363246f, 0.67262322f, -0.97516501f, -0.34056196f, -0.16550370f, 0.21467605f, 
    0.52370393f, 0.36771592f, -0.09344434f, -0.37014797f, 0.32239896f, 0.29042897f, -0.50715661f, -0.03322138f, 
    0.16012163f, 0.10723456f, -0.28264853f, -0.28041542f, -0.24346049f, -0.24268459f, -0.07053547f, 0.11760401f, 
    0.57198524f, 0.86704522f, -0.58766389f, -0.30107138f, -0.09791379f, 0.11832409f, -0.68223411f, -0.56372070f, 
    -0.37228116f, -0.50636190f, 0.02142001f, -0.03353738f, 0.38094175f, 0.11929665f, 0.19493671f, -0.13984060f, 
    -0.72143066f, 0.29131809f, -0.26213199f, -0.10754050f, 0.03647818f, 0.04855452f, -0.12870060f, -0.02669008f, 
    -0.20881073f, 0.99868172f, -0.86668634f, -0.28273240f, -0.86399823f, -0.11678328f, 0.71723163f, -0.55139148f, 
    0.33033091f, -0.27335712f, -0.13027084f, -0.08707644f, -0.10127496f, 0.09324711f, 0.08914354f, -0.21485509f, 
    -0.04734477f, -0.00052735f, -0.28679678f, -0.29170659f, -0.23363383f, -0.13349073f, 0.01240559f, 0.46401867f, 
    0.20323296f, 0.31276646f, 1.05472672f, 0.00859512f, -0.92087674f, -0.74151677f, -0.33303592f, 0.12842533f, 
    0.43576962f, 0.14309226f, -0.48091421f, -0.02330745f, 0.19220409f, -0.51368481f, 0.33722046f, -0.18247555f, 
    0.23915534f, 0.17470214f, -0.05971030f, -0.08736927f, -0.07310058f, 0.14005543f, 0.59907353f, -0.08803052f, 
    0.49952668f, -0.01533547f, -0.21086659f, -0.23062865f, -0.96826994f, 0.77889937f, 0.63046175f, -1.03021467f, 
    0.46186432f, -0.25703269f, 0.31732473f, -0.36699152f, -0.39327547f, -0.23330243f, -0.54450637f, -0.47519043f, 
    -0.25392404f, -0.40554965f, 0.02872598f, 0.35487363f, -0.14452940f, -0.15705311f, -0.04227005f, -0.03842242f, 
    0.22349130f, 0.06803206f, 0.23988733f, -0.31662163f, -1.36997223f, 0.44519505f, -0.14877410f, -0.01735972f, 
    -0.05799548f, 0.88267517f, 1.30719233f, 0.26689515f, 0.54412949f, 0.55532980f, -0.29045847f, -0.42247865f, 
    0.06241092f, -0.19755629f, -0.02049524f, -0.17817159f, -0.08807110f, -0.21259540f, 0.02763763f, -0.22962378f, 
    0.07065792f, -0.13588069f, -0.00774923f, 0.03328977f, 0.18760838f, -0.44935030f, -1.13530767f, -0.90651053f, 
    -0.59654856f, -0.48810646f, -0.24604225f, 0.83793271f, 0.80583251f, 0.28697720f, 0.50646460f, -0.45077112f, 
    -0.15852945f, -0.26117966f, -0.23959279f, -0.11816921f, 0.07015309f, 0.18071663f, 0.01833342f, -0.07560752f, 
    -0.25408301f, -0.12300678f, -0.27239877f, -0.09310599f, -0.10633045f, 0.29254648f, -0.41114157f, -0.59436417f, 
    0.56383497f, 0.72667789f, 0.41048136f, -0.53209591f, -0.23941579f, -0.45837677f, 0.03557082f, -0.34864530f, 
    0.67468083f, -0.15383680f, 0.14628009f, 0.20120640f, 0.05568310f, 0.46624890f, 0.08217288f, 0.17958471f, 
    0.08425076f, 0.48156512f, -0.35647562f, -0.22228323f, -0.04260128f, -0.29942259f, 0.25342023f, 0.21969207f, 
    0.31649911f, 0.28204593f, -0.09733988f, -0.66478199f, -0.00099965f, 0.24187964f, 0.40718347f, 0.03100663f, 
    -0.99421650f, -0.46331540f, 0.24715292f, -0.23230611f, 0.01467884f, 0.39520168f, -0.27479142f, -0.07038293f, 
    -0.15506753f, -0.06305104f, -0.44602290f, 0.29449835f, 0.26361644f, -0.64566344f, 0.61495125f, -0.50430048f, 
    1.30188262f, 0.21416642f, -0.08017338f, 1.11771357f, 0.79907823f, 0.40271857f, 0.29157662f, 0.24197666f, 
    -0.35727510f, -0.17802687f, -0.62847328f, -0.41045383f, -0.02284455f, -0.14515753f, -0.13815840f, -0.11032698f, 
    -0.15798941f, 0.08612818f, -0.08341122f, 0.11033543f, 0.04008319f, 0.25311363f, -0.12014413f, -0.10126682f, 
    -0.29071075f, 0.44363728f, -1.03713691f, -0.47846335f, 0.59680468f, -0.09476011f, -0.85522091f, 0.79344106f, 
    0.19741887f, 0.52351701f, -0.36419290f, -0.16233985f, 0.13553073f, 0.12486129f, 0.32379282f, -0.11655102f, 
    -0.24608956f, -0.31290218f, 0.27486530f, -0.26862264f, -0.25503737f, 0.08755901f, 0.19105463f, 0.05493056f, 
    -0.10323522f, 0.04968001f, 0.94203204f, 0.80390412f, -0.35776806f, -0.93452215f, -0.24083371f, 0.36996448f, 
    -0.62380475f, 0.13034406f, 0.29247177f, 0.33274660f, -0.02469776f, 0.35856017f, -0.04590394f, 0.23004504f, 
    -0.16272287f, 0.17875241f, 0.19649377f, 0.10584185f, -0.00757208f, 0.24920583f, -0.49308276f, -0.18536903f, 
    -0.42582041f, 0.08349555f, 0.32741827f, 1.22097576f, 0.54705471f, 1.20871544f, -0.12377845f, -1.08134520f, 
    -0.57684994f, -0.18899989f, -0.14335109f, 0.25799608f, 0.39953050f, 0.11113294f, -0.03952955f, -0.39001277f, 
    -0.05072762f, 0.10627708f, -0.06183428f, 0.06217869f, 0.07194924f, -0.16888051f, -0.04457729f, 0.00154126f, 
    -0.10079025f, 0.03666200f, -0.06687929f, -0.08167125f, -0.00920483f, 0.26121488f, -0.22252518f, -0.77512908f, 
    -0.19838919f, -0.29743913f, -1.01269066f, -0.53874993f, -0.04009208f, -0.60662943f, 0.40430534f, -0.00724330f, 
    0.36768970f, -0.07598870f, -0.11542454f, 0.28394195f, 0.25448024f, -0.22565243f, 0.33522090f, 0.15124519f, 
    0.21953136f, 0.04874801f, 0.03854907f, 0.36158258f, 0.43087524f, 0.73206544f, 0.74279255f, 0.44130641f, 
    0.62729615f, 0.88912576f, 0.22736955f, -0.21206790f, -0.81609571f, 0.32072139f, -0.36940062f, -0.02995194f, 
    0.08190949f, -0.44389963f, 0.46883351f, -0.22797807f, 0.35072857f, -0.05809674f, -0.28285798f, -0.07399883f, 
    -0.41111019f, 0.27923658f, 0.20153184f, 0.25426897f, 0.12394247f, 0.09773579f, 1.22380686f, 0.76187932f, 
    0.25723743f, 0.62680209f, 0.27732801f, 0.51524031f, 0.35623688f, 0.11653849f, 0.15456955f, 0.25337496f, 
    0.03942304f, 0.58853912f, -0.28152680f, -0.21680300f, 0.09616631f, 0.37831733f, -0.04757207f, 0.30358788f, 
    -0.16471164f, 0.14362444f, -0.27290198f, 0.08474929f, -0.19099167f, -0.08382534f, 0.42666936f, 0.79076153f, 
    0.79305547f, 0.97841954f, 0.59984875f, 0.69087058f, -0.17460088f, -0.29401535f, -0.32395276f, -0.61896700f, 
    0.02833242f, -0.00838472f, -0.00019609f, 0.13830040f, 0.03332023f, 0.04921095f, -0.10508703f, 0.11947899f, 
    0.27923808f, 0.45567375f, 0.26009759f, 0.24314915f, -0.09096900f, -0.12694179f, 0.25427398f, 0.36111996f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37190276f, 0.09116838f, 0.25238493f, 0.08839383f, 0.03931804f, -0.01878370f, 0.17429976f, 0.41040236f, 
    0.21883194f, 0.30106327f, 0.35990384f, 0.28968859f, 0.06628332f, 0.29520702f, 0.13743404f, -0.21440181f, 
    0.04106446f, 0.05050844f, 0.14642416f, 0.17811497f, 0.13731182f, 0.17381582f, 0.27660879f, 0.18087733f, 
    0.08155502f, -0.00329874f, 0.16687845f, 0.22447102f, 0.45615706f, 0.29736662f, 0.43023860f, 0.15419708f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15919431f, 0.12488212f, -0.12631218f, 0.03752831f, 0.03254975f, -0.08970545f, -0.03396069f, -0.10646560f, 
    -0.03646581f, -0.12196373f, 0.01995758f, -0.18521854f, -0.17497055f, -0.18969177f, 0.21603593f, -0.19471273f, 
    -0.02989331f, 0.04477772f, 0.04794520f, 0.01355068f, -0.10633682f, 0.10815012f, 0.12354370f, -0.00947215f, 
    -0.10654898f, -0.02315668f, 0.18526807f, -0.13108191f, 0.12411015f, -0.00896032f, 0.05365224f, 0.11819667f, 
    -0.06341468f, -0.17542346f, 0.00798247f, 0.01827182f, 0.20939454f, -0.08766784f, 0.03670960f, -0.04512382f, 
    -0.04298453f, -0.02514032f, -0.06314517f, 0.02787276f, -0.05323231f, 0.17654337f, -0.02541488f, -0.03530909f, 
    -0.19611506f, -0.04368000f, 0.10212453f, 0.23385717f, -0.01617907f, -0.23964523f, 0.12854843f, -0.05501500f, 
    0.04605618f, -0.03471275f, -0.10604673f, 0.14670563f, 0.22111399f, -0.10063584f, -0.00281856f, -0.31006676f, 
    0.09842756f, -0.01322981f, 0.01247623f, 0.01799937f, 0.00891141f, 0.11879867f, 0.05604276f, 0.07148997f, 
    -0.12549524f, -0.06139832f, 0.10073305f, -0.32815474f, -0.06950227f, 0.01346265f, 0.05388158f, -0.06291622f, 
    -0.13621309f, 0.02915007f, -0.08528583f, 0.00598231f, -0.46005893f, 0.00394298f, -0.11611605f, 0.06206453f, 
    0.04397839f, -0.00515352f, -0.06955732f, 0.07570961f, -0.01801107f, -0.01131531f, -0.08744125f, -0.04657672f, 
    0.40358543f, -0.22453244f, -0.06976264f, -0.13696343f, -0.04214088f, 0.10781621f, -0.05536594f, -0.17338146f, 
    0.06490123f, -0.09047996f, 0.01331619f, -0.04362372f, -0.57922196f, 0.13379522f, -0.08323380f, -0.02226233f, 
    0.01432645f, -0.07833686f, -0.08327293f, -0.04418541f, -0.08730786f, 0.04920806f, -0.04496917f, 0.11154799f, 
    -0.06741586f, 0.32633209f, -0.32260174f, -0.15698875f, -0.09803452f, -0.00922533f, 0.02247802f, 0.09781006f, 
    0.04992962f, -0.01430934f, -0.07086076f, -0.10057683f, -0.06981810f, -0.10447476f, 0.12753335f, -0.37737611f, 
    -0.09361412f, -0.17648683f, 0.12737624f, -0.03101834f, 0.02771366f, -0.09189526f, -0.16643447f, -0.09834415f, 
    -0.12218034f, 0.15921985f, -0.18566820f, 0.27906707f, -0.21247791f, 0.04268307f, 0.09449657f, -0.02945113f, 
    0.08476692f, 0.02880811f, -0.11301387f, 0.13339174f, -0.20875722f, 0.17147557f, -0.02738679f, -0.00224098f, 
    0.03734064f, 0.01573354f, -0.01327231f, -0.06090386f, -0.14581102f, 0.04745174f, 0.01624057f, -0.26046610f, 
    -0.28877893f, -0.00999544f, -0.02413122f, 0.08934667f, -0.12690373f, -0.11816867f, 0.10880248f, -0.02080863f, 
    0.02923722f, -0.01733836f, -0.00868503f, 0.04492220f, 0.34527647f, 0.01262509f, -0.20396993f, 0.41255906f, 
    -0.27218720f, -0.16627863f, 0.13769034f, -0.14286183f, -0.18391371f, -0.03281389f, -0.04521504f, -0.06645298f, 
    0.05175893f, 0.19401792f, 0.24222037f, -0.43985042f, -0.19222268f, -0.03925197f, 0.10010623f, 0.02670828f, 
    0.08908202f, -0.03869386f, -0.14281751f, 0.13449937f, 0.45509997f, -0.25896779f, 0.17573455f, -0.49495289f, 
    0.08097360f, -0.02627088f, 0.02668217f, -0.13385236f, -0.28127584f, 0.10478346f, -0.06162329f, -0.09645902f, 
    -0.53646392f, -0.05183919f, 0.19264691f, -0.34223676f, -0.16985540f, -0.02637687f, 0.10279895f, -0.03334384f, 
    -0.15783143f, -0.00469715f, 0.03801304f, 0.05042123f, -0.19549946f, 0.03713169f, 0.07327846f, 0.33834893f, 
    0.02766044f, -0.00369589f, 0.04831107f, 0.03297386f, -0.16039947f, 0.01379076f, -0.05579345f, -0.10822190f, 
    0.66153121f, 0.18368588f, 0.23619005f, -0.08351222f, 0.02325121f, 0.08563233f, 0.03334637f, -0.06336424f, 
    -0.02298547f, -0.05399539f, -0.10105071f, 0.12430984f, -0.10468887f, 0.23594289f, -0.07342923f, -0.50979978f, 
    0.12155536f, 0.06112096f, 0.10118330f, 0.10003071f, 0.09530972f, -0.03990147f, 0.05293958f, 0.13956770f, 
    0.17526847f, -0.09585243f, -0.22902741f, 0.23655151f, -0.07358213f, 0.08540511f, 0.04196569f, 0.08671924f, 
    0.12067772f, 0.00664868f, -0.08262061f, 0.00890409f, -0.19376037f, 0.18374610f, 0.03147139f, 0.10048072f, 
    -0.02358733f, 0.07367940f, -0.03764108f, -0.09889295f, -0.09661410f, 0.00255131f, -0.02151750f, -0.13210398f, 
    0.39531177f, 0.06622814f, -0.18859141f, 0.38401765f, -0.17879781f, 0.06469378f, -0.11626702f, 0.11704734f, 
    0.00779355f, -0.02722407f, 0.06987292f, -0.02285586f, -0.09907825f, 0.11658891f, -0.14064237f, 0.25111783f, 
    -0.00032270f, -0.00871566f, 0.05902743f, -0.12224108f, 0.05459343f, 0.15186198f, 0.00057167f, -0.02341884f, 
    0.15071101f, -0.02464357f, 0.10149752f, -0.52576482f, -0.06391651f, 0.02042932f, -0.01277444f, 0.09473290f, 
    0.01055902f, 0.01649985f, -0.07419628f, 0.06620345f, 0.04097031f, -0.03377112f, -0.18157780f, 0.18014918f, 
    -0.11674386f, -0.17821655f, -0.04177416f, -0.00340406f, 0.02309527f, -0.03327724f, -0.01200248f, -0.01242376f, 
    -0.48670876f, -0.00218993f, 0.35450909f, -0.02426060f, -0.02223308f, -0.04854501f, 0.05940418f, 0.05534127f, 
    0.15142000f, -0.06537179f, 0.11887641f, -0.00015328f, 0.12790626f, 0.06031295f, 0.00054353f, 0.02350902f, 
    0.07464270f, -0.12668635f, -0.00226787f, 0.01610241f, 0.02855211f, -0.00449364f, 0.11784001f, -0.11223594f, 
    0.19194257f, -0.05552757f, -0.10386796f, 0.07525974f, -0.21834816f, -0.07907244f, -0.04084389f, 0.20198023f, 
    0.14925323f, 0.13948753f, 0.01978076f, -0.02228330f, 0.21160917f, 0.12715510f, -0.00440107f, 0.00069226f, 
    -0.06693135f, -0.09569504f, -0.02254771f, 0.06745027f, 0.00956498f, -0.10110579f, -0.10867870f, 0.08886674f, 
    -0.27693731f, 0.25989717f, -0.23424162f, -0.35672516f, 0.03025225f, 0.19888793f, 0.02194707f, 0.00599814f, 
    0.06721020f, 0.14636029f, 0.07041489f, 0.14356910f, 0.34192547f, -0.25962892f, 0.14635020f, -0.47398272f, 
    0.07535528f, -0.17620602f, -0.06596724f, 0.10933682f, -0.20838282f, -0.19194478f, 0.07846064f, -0.11822644f, 
    0.13113230f, -0.00407468f, -0.45889613f, -0.14344350f, -0.13104825f, 0.07186442f, -0.05584301f, 0.03504170f, 
    0.22094323f, -0.01853084f, 0.03466417f, 0.03761518f, 0.16700689f, 0.20088507f, 0.16278170f, -0.06065831f, 
    -0.12664229f, 0.08175172f, 0.06670222f, -0.03059793f, 0.00802988f, -0.06592660f, -0.01610404f, 0.02743624f, 
    0.04958402f, 0.15731959f, -0.09514785f, 0.00625247f, -0.11078639f, 0.10732353f, -0.00598283f, -0.08039916f, 
    -0.06529360f, -0.01926978f, 0.24031575f, -0.10786636f, -0.32238856f, 0.00096855f, 0.09159233f, -0.16647907f, 
    0.09660774f, -0.19534953f, -0.10385890f, 0.15116328f, 0.10847624f, 0.10822225f, -0.02032932f, -0.01923853f, 
    -0.14149894f, -0.09018069f, 0.11100653f, -0.11565359f, -0.06234837f, -0.19482423f, 0.12447883f, -0.01375142f, 
    -0.11677949f, -0.17153402f, 0.08586380f, -0.15661314f, 0.08009265f, 0.06386717f, -0.20071124f, -0.07699718f, 
    -0.11505866f, 0.03449466f, -0.10273122f, -0.04170119f, -0.05577149f, 0.09397735f, 0.01034957f, -0.00814988f, 
    -0.59741145f, -0.04927903f, -0.03589229f, -0.24728476f, 0.03422835f, -0.02990046f, 0.08969665f, 0.06055623f, 
    0.15958309f, 0.16469918f, 0.00463492f, -0.07766599f, 0.57925218f, -0.09896125f, -0.04138272f, -0.15786391f, 
    0.09421909f, 0.05594274f, -0.05105192f, 0.01989212f, -0.07325090f, -0.19306041f, 0.09408945f, -0.05016632f, 
    0.11493446f, -0.09399457f, 0.00013505f, -0.03707171f, 0.13852639f, 0.01397241f, 0.01819532f, 0.24462165f, 
    0.01930324f, -0.01572064f, -0.02812446f, 0.14431939f, -0.08339678f, 0.27370149f, -0.06696182f, -0.73445863f, 
    0.14327201f, 0.08885832f, -0.06967227f, 0.02593894f, 0.15088587f, -0.13049412f, -0.00349707f, 0.00895699f, 
    -0.21415269f, -0.04064441f, -0.07212719f, 0.25045523f, -0.20785613f, -0.10679298f, -0.02687989f, -0.05843834f, 
    -0.01084660f, -0.28225380f, 0.07622913f, -0.08532451f, 0.00012729f, -0.23947939f, -0.33435410f, -0.05327563f, 
    0.19029810f, 0.04989328f, -0.07902171f, 0.02121815f, 0.11193651f, -0.02019597f, -0.18131980f, -0.07067050f, 
    0.38431525f, 0.25892115f, 0.09602467f, 0.05281707f, -0.04629638f, 0.01604684f, 0.08603777f, -0.12195919f, 
    0.01315009f, -0.12700491f, 0.07322188f, -0.15545681f, -0.05824619f, -0.18334360f, -0.04793014f, 0.09725918f, 
    -0.09118783f, 0.01006385f, -0.10041760f, 0.09248463f, -0.02225683f, -0.02498181f, -0.02094560f, -0.01901329f, 
    -0.00202017f, -0.48965934f, 0.00917789f, -0.07275842f, -0.03690640f, -0.14126985f, 0.01843427f, -0.01080468f, 
    -0.07169677f, 0.13189414f, -0.02257691f, -0.02442334f, 0.15213688f, -0.32770258f, 0.00127533f, -0.30703562f, 
    0.09514235f, 0.00110388f, -0.03780209f, 0.11824977f, -0.02019040f, -0.16578352f, 0.12453221f, 0.04722255f, 
    0.40929091f, -0.23743206f, 0.07454120f, -0.25210324f, -0.00874058f, 0.00673060f, 0.02820341f, -0.04239991f, 
    -0.00719559f, 0.15571621f, -0.07744958f, 0.09312315f, -0.42547798f, 0.05901720f, -0.29127958f, 0.22969952f, 
    -0.09979841f, -0.06069438f, -0.01468936f, -0.03079243f, 0.20529845f, 0.10379931f, -0.03921656f, -0.09903621f, 
    -0.40903950f, -0.00084567f, -0.07690932f, -0.01528612f, 0.12225828f, 0.04637654f, -0.08060189f, -0.02011643f, 
    0.03509210f, 0.20839322f, 0.01762917f, -0.14395602f, 0.21791391f, -0.25478661f, 0.01503206f, -0.05990335f, 
    0.10323551f, 0.00499815f, -0.16410609f, 0.01419219f, -0.00247265f, 0.04928247f, 0.00944626f, -0.11284938f, 
    -0.30335653f, 0.05348500f, -0.03552755f, -0.03465494f, 0.10387958f, -0.05331281f, -0.12154859f, 0.03881185f, 
    -0.14462340f, 0.01105287f, 0.00655767f, 0.11392704f, -0.14200309f, -0.05000586f, -0.19450639f, 0.18802252f, 
    -0.05105477f, -0.25486705f, -0.11622211f, -0.02686246f, 0.01510430f, 0.01645567f, -0.32024518f, 0.12226584f, 
    0.21347100f, -0.11099496f, 0.21086240f, 0.25615719f, -0.12987745f, 0.11147910f, -0.03173689f, 0.03703778f, 
    0.01274050f, 0.06409837f, -0.01492192f, 0.19527891f, 0.26036203f, -0.55697119f, -0.02576923f, 0.07967675f, 
    -0.08748151f, 0.03570444f, -0.04903977f, 0.06189535f, -0.02897395f, -0.19006176f, -0.05027647f, 0.04554768f, 
    0.17356537f, -0.24655707f, 0.09126762f, -0.23796205f, -0.04088503f, -0.03038994f, 0.05294014f, -0.03919929f, 
    -0.02248356f, 0.11278905f, 0.17353196f, 0.01161908f, 0.25764364f, 0.15585402f, -0.38359892f, -0.03352229f, 
    -0.08424239f, -0.20039573f, -0.04930101f, 0.02753525f, -0.03476850f, 0.00571599f, -0.00747157f, -0.06167075f, 
    -0.21948849f, -0.10328058f, -0.12966470f, -0.16753185f, 0.00602553f, 0.01391207f, 0.10439784f, 0.10506249f, 
    0.07437499f, 0.26590577f, 0.01354227f, 0.11207934f, 0.18197264f, -0.15083066f, 0.15624832f, 0.24524011f, 
    -0.03795734f, -0.02767980f, 0.06419875f, 0.04564264f, 0.05010109f, 0.08651000f, -0.20600471f, 0.08999699f, 
    0.37665534f, 0.04453066f, 0.18828660f, 0.22272368f, 0.05428052f, -0.01010490f, 0.00735324f, -0.07488785f, 
    -0.09129044f, 0.07140193f, -0.03267127f, 0.11619802f, 0.27333537f, 0.03755968f, 0.00254002f, 0.27044189f, 
    -0.08833100f, -0.02685774f, 0.09731419f, 0.00457770f, -0.00702493f, 0.11928427f, 0.02134659f, 0.06923662f, 
    0.34503213f, 0.01547284f, -0.60341829f, -0.16467436f, 0.21282068f, -0.04076151f, -0.06390559f, -0.02640075f, 
    -0.12917155f, 0.00313096f, -0.06279312f, -0.16613056f, -0.08897310f, 0.15604451f, -0.10768198f, -0.31692186f, 
    -0.00713835f, -0.11726069f, -0.00429732f, -0.21965560f, -0.03415045f, 0.14755817f, -0.08673581f, 0.11268479f, 
    -0.05540390f, 0.08662543f, 0.14216554f, 0.16940665f, 0.00291715f, -0.11981142f, 0.03196426f, 0.01725982f, 
    -0.13003336f, 0.00600897f, 0.09280697f, -0.04637628f, -0.16241044f, -0.01398160f, -0.07976496f, -0.20651264f, 
    -0.02622950f, 0.13209674f, 0.00635711f, 0.00496979f, -0.05605151f, 0.02847955f, -0.05964041f, -0.10308770f, 
    0.24183683f, -0.12984526f, 0.01719912f, 0.02207521f, 0.05148837f, -0.01302492f, -0.06617800f, -0.16602331f, 
    -0.00309802f, 0.05110657f, -0.08835182f, 0.11408480f, -0.18542038f, -0.07575073f, 0.04311406f, 0.11556581f, 
    -0.08544743f, 0.08613377f, -0.10462478f, 0.06968558f, -0.09510282f, -0.00864354f, 0.10676297f, 0.15743099f, 
    0.11731903f, -0.03741592f, 0.05421317f, -0.31859291f, 0.00843118f, 0.06003272f, -0.03220585f, 0.04768240f, 
    -0.09417617f, -0.05762516f, -0.23422877f, 0.04051042f, 0.49678800f, -0.24106030f, -0.14506835f, 0.04565131f, 
    -0.01890913f, 0.01096803f, 0.00632361f, -0.07513028f, -0.05854925f, -0.12934491f, 0.00081679f, 0.00105003f, 
    0.03150343f, 0.43298614f, -0.04582267f, 0.00104197f, -0.00021190f, 0.03919119f, -0.08674935f, 0.00935961f, 
    -0.18232821f, -0.01293452f, -0.09788987f, -0.00250914f, 0.33117169f, -0.03573563f, 0.00429130f, 0.22947545f, 
    -0.03674133f, -0.05531065f, -0.14537621f, -0.01060560f, 0.03649100f, 0.07900932f, -0.12193739f, 0.02050403f, 
    -0.01405423f, -0.06102526f, -0.04404407f, 0.21881075f, -0.18001659f, -0.01306050f, 0.02005801f, 0.06033850f, 
    -0.00623041f, 0.09592170f, -0.08286775f, -0.02186248f, 0.32639775f, -0.02122208f, -0.33200589f, -0.11422437f, 
    0.12226132f, 0.18502130f, 0.16002144f, 0.00308205f, 0.02125875f, 0.12824127f, 0.09846112f, 0.03439159f, 
    0.48587960f, -0.14665395f, 0.03813379f, -0.02751250f, -0.14273259f, 0.03919492f, -0.00694325f, 0.09360565f, 
    -0.00714459f, 0.03116302f, -0.06266341f, -0.02505634f, -0.10506988f, -0.19240090f, 0.07800347f, -0.04322138f, 
    -0.06951314f, -0.13967150f, -0.11891474f, -0.19220532f, 0.08795018f, 0.01542060f, 0.09194275f, -0.02714660f, 
    0.20267153f, 0.00970993f, -0.02590566f, -0.00161595f, 0.02780752f, 0.10090033f, 0.05583001f, 0.03772035f, 
    -0.05513496f, 0.09222270f, -0.02707950f, 0.09728907f, 0.03444891f, 0.06416026f, -0.10645993f, 0.16847894f, 
    -0.00700558f, 0.11402228f, -0.07937858f, -0.06383300f, 0.03266239f, 0.14632307f, 0.06206649f, 0.02399193f, 
    -0.30076081f, -0.23874961f, -0.06933572f, -0.42364407f, 0.08656225f, -0.12890106f, 0.20030776f, -0.23282290f, 
    0.01067430f, 0.12767838f, -0.10236945f, -0.16986161f, -0.83493859f, -0.00257822f, -0.16414839f, 0.07991823f, 
    0.17603457f, -0.05330300f, -0.08190082f, -0.05950169f, -0.21295536f, 0.07662132f, -0.08996496f, 0.02853535f, 
    -0.17661239f, -0.08306153f, -0.15659711f, -0.02653879f, -0.14975321f, -0.16605981f, -0.01094753f, -0.13235579f, 
    -0.03169348f, -0.07893347f, -0.03070323f, 0.12351701f, -0.50457561f, -0.51958269f, -0.08943627f, -0.23432949f, 
    -0.21918967f, 0.17232865f, -0.12898085f, -0.03308397f, 0.10937746f, 0.00441192f, 0.10469361f, -0.19325839f, 
    0.47151366f, 0.12716773f, 0.14126793f, 0.15090631f, -0.00276808f, 0.00157584f, 0.01815734f, 0.06543163f, 
    0.03400882f, 0.03641154f, -0.01322430f, 0.00793643f, 0.52960062f, 0.18781987f, 0.19867884f, 0.47651729f, 
    -0.22702917f, -0.15780751f, 0.14155889f, 0.23952027f, 0.07912064f, 0.00260696f, 0.02775243f, 0.10075425f, 
    0.24307434f, -0.00309429f, -0.32697117f, 0.16497020f, -0.17398852f, -0.07641979f, -0.05444259f, -0.06523669f, 
    -0.17801435f, -0.06020958f, -0.08648500f, -0.06703826f, -0.29094762f, 0.15350652f, -0.18429044f, -0.27641046f, 
    -0.10100479f, -0.03729213f, 0.05023742f, -0.04176936f, -0.06329019f, -0.13681500f, -0.01301440f, 0.10257017f, 
    -0.31767100f, -0.04075141f, 0.06941189f, -0.14515021f, 0.24288215f, -0.06385615f, -0.08932155f, 0.01418049f, 
    0.00859586f, 0.06261891f, 0.05724842f, 0.01381938f, 0.40978608f, 0.08134675f, -0.18379036f, 0.02413472f, 
    -0.18949540f, -0.01833324f, 0.14619724f, 0.05612466f, 0.04270838f, 0.04056978f, -0.05700108f, -0.04133078f, 
    -0.11950780f, 0.04200494f, -0.01885379f, -0.14251095f, 0.05510121f, -0.18289725f, 0.15388033f, -0.03760902f, 
    -0.07783323f, 0.04887683f, 0.04823863f, -0.09654225f, -0.37746823f, 0.00773715f, 0.02696644f, -0.25938457f, 
    -0.00105011f, 0.02673412f, 0.08487745f, 0.11437952f, -0.03848007f, -0.00515196f, -0.07337298f, -0.10665108f, 
    -0.65864205f, -0.14344695f, -0.06787837f, -0.21095806f, 0.11278170f, -0.05116414f, 0.01069541f, -0.15554489f, 
    -0.02301898f, -0.01167035f, 0.03588086f, -0.13550770f, 0.26366612f, -0.11909321f, -0.20353290f, 0.04897911f, 
    0.10722266f, -0.05589515f, -0.00235511f, -0.16282579f, 0.04222266f, 0.03634595f, 0.11416545f, -0.09781529f, 
    0.26067641f, -0.02624871f, 0.04596023f, -0.06534183f, 0.12210977f, -0.03474981f, 0.04298067f, 0.05181688f, 
    0.05065693f, 0.01931795f, 0.13389568f, -0.04401416f, -0.16266440f, 0.00216370f, -0.12525287f, 0.09782301f, 
    0.08206204f, 0.09812670f, 0.01521325f, -0.09468224f, 0.03598448f, -0.04034125f, -0.02009635f, -0.09518642f, 
    -0.20975606f, 0.24995850f, 0.29640096f, 0.08324259f, 0.07227652f, 0.04372418f, 0.06089927f, 0.09950504f, 
    -0.02050643f, -0.03149919f, -0.02631069f, -0.30274966f, 0.12095331f, -0.12890190f, 0.11989395f, 0.06825583f, 
    -0.01235834f, 0.00632157f, 0.00315435f, 0.08807997f, -0.03635921f, 0.19906197f, -0.12775293f, 0.12359344f, 
    -0.16348070f, 0.02266615f, 0.00054825f, -0.19174215f, -0.09257194f, 0.03823123f, 0.14576997f, -0.06346283f, 
    0.04498458f, 0.06629185f, -0.18365681f, 0.04268655f, -0.48680529f, -0.55613089f, -0.14379232f, 0.15539432f, 
    -0.05920948f, 0.03681568f, 0.04225889f, -0.01389109f, -0.08866336f, -0.12732512f, -0.07104707f, -0.00527628f, 
    0.88115418f, -0.15943560f, -0.12048180f, 0.28612739f, 0.09436049f, -0.02868566f, -0.09191328f, 0.09743556f, 
    -0.05699520f, 0.03064741f, -0.10755956f, 0.03830773f, 0.00362525f, -0.05950709f, -0.05878082f, -0.06510389f, 
    -0.12421323f, 0.01519956f, 0.12343379f, 0.11767207f, 0.01654649f, -0.07691491f, -0.01018070f, 0.08281712f, 
    0.34727520f, 0.19780594f, 0.09936697f, 0.09449986f, -0.07123915f, -0.04226715f, -0.06270161f, -0.12039135f, 
    -0.11233351f, 0.05376286f, -0.00441860f, 0.08868907f, -0.21589836f, 0.19348018f, 0.35348484f, 0.09446172f, 
    -0.00508916f, -0.10718632f, -0.08075988f, -0.00351569f, 0.03544699f, 0.02304547f, -0.11635211f, 0.01365234f, 
    0.41524482f, 0.33328530f, 0.03004353f, -0.06418002f, -0.06500699f, -0.14149454f, 0.00620701f, 0.05730018f, 
    0.03281626f, -0.11537072f, -0.11134662f, -0.12029443f, -0.02645281f, 0.00269054f, 0.00895646f, 0.12062030f, 
    -0.05203513f, -0.22395849f, -0.04820902f, -0.23498692f, -0.09831116f, 0.15725556f, -0.03872694f, 0.00508215f, 
    -0.03324349f, -0.02428681f, 0.00235715f, -0.08588010f, -0.18023339f, -0.08883681f, 0.02149809f, 0.00765717f, 
    -0.02934187f, -0.01125004f, -0.05409259f, -0.03277831f, -0.19626383f, 0.37321132f, 0.04628924f, -0.16398774f, 
    -0.07794613f, 0.04334175f, -0.14127351f, 0.16842461f, 0.13160783f, 0.17945719f, -0.03580158f, 0.09335519f, 
    0.01959730f, -0.06838928f, 0.09411685f, -0.15948248f, -0.06401337f, 0.15073793f, -0.12323233f, 0.03479391f, 
    -0.05596839f, 0.00427752f, -0.01329289f, 0.03075296f, 0.09562670f, 0.18072730f, 0.04138664f, 0.15314956f, 
    -0.19801641f, -0.10379872f, 0.09390645f, -0.07277172f, -0.06914983f, 0.26741704f, -0.04725944f, 0.07772381f, 
    -0.37609491f, -0.50953144f, -0.23708424f, 0.13071238f, -0.11480613f, -0.02496846f, 0.03811824f, 0.03909392f, 
    0.16875076f, 0.06353773f, -0.06199056f, 0.05168299f, -0.44740909f, -0.01495447f, 0.08274686f, 0.33329770f, 
    -0.15280181f, 0.15037613f, 0.17552374f, -0.19473444f, 0.04962183f, -0.12346446f, 0.06092630f, 0.00908071f, 
    0.26285276f, 0.15979867f, -0.01133882f, 0.05935545f, 0.10168571f, 0.04403995f, 0.06983035f, -0.11685812f, 
    -0.02366496f, 0.08537894f, 0.03055811f, 0.08026391f, 0.12393568f, 0.01519644f, -0.13646828f, 0.17607975f, 
    -0.04523009f, 0.00180767f, -0.07923417f, 0.23024125f, -0.06694514f, 0.22515661f, -0.06811684f, -0.00806698f, 
    0.06080754f, -0.26679072f, -0.10652286f, 0.06218522f, -0.01772560f, 0.04339529f, -0.00958161f, 0.03531131f, 
    -0.09386904f, 0.07752111f, 0.01460364f, 0.03163816f, 0.15358448f, -0.03869967f, 0.05727393f, 0.02241101f, 
    0.16908866f, 0.00135638f, 0.04380992f, 0.25333750f, -0.09779653f, -0.01303804f, -0.04478121f, -0.10384898f, 
    -0.50728971f, 0.14797190f, -0.10517704f, -0.32836825f, -0.05178339f, -0.04945667f, 0.12384339f, 0.08777732f, 
    -0.01001577f, -0.15349087f, -0.05861185f, -0.09655527f, 0.01441508f, -0.08842902f, -0.01537568f, -0.07284933f, 
    -0.03445297f, -0.03943440f, 0.04858748f, -0.02301310f, -0.20861533f, 0.06318998f, 0.00999814f, -0.03813280f, 
    -0.36900148f, 0.00370600f, 0.07623678f, 0.09744773f, 0.12461025f, 0.12986867f, 0.12457512f, -0.02964930f, 
    -0.07076395f, 0.04580438f, -0.13577127f, -0.23904638f, -0.00313383f, -0.02419751f, 0.10050643f, -0.11184444f, 
    -0.01382979f, 0.16702220f, 0.07455207f, -0.11353566f, -0.24402328f, 0.04205385f, -0.00500637f, -0.02677829f, 
    -0.17016798f, -0.62119341f, -0.04375124f, 0.07661937f, -0.05854051f, 0.03319000f, 0.07522902f, -0.04238970f, 
    0.04614833f, -0.10892168f, 0.11535851f, -0.03025635f, 0.14105478f, 0.12863652f, 0.07373899f, 0.05492189f, 
    0.01704394f, -0.02852470f, -0.06934649f, -0.08068133f, -0.01077418f, 0.09033211f, -0.09412203f, 0.07352511f, 
    -0.08399656f, -0.18081215f, -0.14615147f, 0.03436650f, -0.26380062f, -0.06887398f, 0.08358910f, 0.10399541f, 
    0.03046227f, 0.11651040f, -0.06948166f, -0.00364582f, -0.32400435f, 0.10306830f, -0.35317662f, 0.05856113f, 
    -0.10284470f, 0.10646248f, -0.03938419f, 0.06682281f, 0.02134922f, 0.06715375f, -0.02662648f, -0.00993938f, 
    0.22938502f, 0.07694294f, 0.02730717f, 0.11617329f, 0.07620557f, 0.00051438f, 0.01466896f, -0.09077295f, 
    0.04707924f, -0.02063035f, -0.10757855f, -0.15002598f, 0.36586189f, -0.46489811f, -0.15625925f, 0.04752996f, 
    -0.08484811f, 0.00668190f, -0.01993162f, -0.14649236f, 0.01989580f, -0.04076518f, 0.12176838f, -0.09058332f, 
    -0.45168582f, -0.59569496f, -0.43188074f, 0.03041009f, -0.22615373f, -0.24247594f, -0.01622049f, 0.08377998f, 
    0.00428844f, 0.00076143f, 0.01872440f, 0.01559877f, -0.46821666f, -0.79076147f, 0.03903148f, 0.27663529f, 
    -0.08447938f, -0.04889911f, 0.07371841f, -0.09803239f, -0.00284132f, -0.06626391f, 0.02345222f, 0.03171169f, 
    -0.27981299f, -0.00298193f, 0.45758992f, 0.07568111f, -0.03786019f, -0.03252412f, -0.08175962f, -0.11747534f, 
    -0.00037248f, -0.07887705f, -0.07907069f, 0.00004731f, -0.04271716f, -0.11847088f, -0.09339160f, 0.15096633f, 
    -0.10094253f, -0.10564090f, -0.04445229f, 0.06452183f, -0.02058917f, 0.11066330f, -0.19862229f, 0.00990745f, 
    -0.14790951f, -0.12107160f, 0.06653593f, -0.08396207f, 0.07280026f, 0.10640550f, 0.12985894f, 0.07158688f, 
    0.01088576f, 0.03266554f, -0.04503750f, 0.02476673f, -0.62986767f, 0.02964019f, 0.04180085f, -0.18113783f, 
    0.16106218f, -0.25581554f, -0.34660500f, 0.11264380f, 0.10791659f, 0.01150050f, 0.07662413f, -0.08112271f, 
    -0.04954725f, 0.34957144f, -0.10545304f, -0.26251382f, -0.02727097f, 0.28781238f, 0.09902170f, 0.08790698f, 
    -0.06585974f, -0.01115063f, -0.09967481f, 0.04393535f, -0.17158890f, -0.02108318f, 0.03193877f, 0.24924719f, 
    0.00844538f, 0.02331876f, 0.06858221f, 0.03345499f, -0.06073586f, -0.05353268f, 0.15757091f, 0.15806548f, 
    -0.21958557f, 0.12373260f, 0.10267992f, 0.10998421f, 0.07812882f, -0.04906362f, 0.09925392f, 0.10654871f, 
    0.10953136f, 0.14566539f, -0.20360678f, -0.02028058f, -0.30069548f, -0.09790460f, 0.03249817f, -0.01016713f, 
    -0.06055133f, -0.03423553f, 0.00520241f, 0.02828480f, 0.01875963f, 0.03784054f, 0.03625687f, -0.02423385f, 
    0.52078158f, 0.02351047f, -0.20135511f, -0.02205137f, 0.07361981f, -0.06056589f, 0.02067209f, 0.13489760f, 
    0.08604499f, -0.15857790f, -0.06168615f, -0.10527360f, 0.10412786f, 0.10980303f, -0.16593535f, 0.07069258f, 
    -0.02065905f, -0.05362150f, 0.10994009f, -0.01958255f, 0.09467266f, -0.09181912f, -0.04893468f, -0.11061166f, 
    0.21869351f, 0.05147067f, -0.10949802f, 0.37044820f, 0.04571062f, -0.00992456f, -0.05383752f, -0.05908855f, 
    0.19026294f, -0.02115365f, 0.02947373f, -0.07876171f, 0.29337713f, 0.07159699f, -0.15222812f, 0.16675489f, 
    -0.28810871f, 0.02689829f, 0.09740431f, -0.18174714f, -0.08148577f, -0.00318342f, 0.02412126f, 0.04828984f, 
    -0.74526989f, 0.21890363f, -0.10865466f, -0.22478777f, 0.04594714f, 0.04542952f, -0.08164950f, 0.07864468f, 
    -0.10297216f, 0.01092397f, -0.09855701f, 0.03314083f, 0.07297504f, -0.01003216f, -0.21441282f, -0.25389582f, 
    0.06306692f, -0.01783877f, -0.01258453f, 0.09585587f, 0.03105822f, 0.00649564f, 0.11439885f, 0.04846286f, 
    0.20837992f, -0.19316699f, 0.15479957f, 0.09596645f, -0.05066224f, 0.05837065f, -0.01382030f, 0.09504054f, 
    -0.01335276f, 0.06503779f, 0.02253894f, 0.16978765f, -0.15640303f, -0.23160231f, 0.05201416f, 0.09815304f, 
    0.12212725f, -0.03142234f, 0.03955379f, 0.03095349f, 0.23915029f, 0.21051724f, -0.09982540f, -0.07300459f, 
    -0.08591855f, 0.03221996f, -0.08146945f, 0.03277183f, -0.19359683f, 0.08106685f, -0.10848493f, -0.16039146f, 
    -0.14076898f, 0.00390584f, 0.05177445f, 0.09755162f, -0.26482749f, 0.22242886f, -0.10303561f, 0.05924243f, 
    -0.01430894f, 0.12231052f, -0.03224960f, -0.10900122f, 0.00948809f, -0.01378949f, -0.12896460f, -0.03645020f, 
    0.26585415f, 0.01545539f, 0.03197303f, -0.11055027f, -0.05431789f, -0.07114712f, -0.12471858f, 0.00653206f, 
    -0.10429589f, -0.09909507f, -0.10750511f, -0.13573389f, 0.05343734f, -0.04624373f, 0.03074478f, -0.15917727f, 
    0.02606571f, 0.20412965f, -0.12187220f, 0.09492471f, -0.12931530f, -0.04112446f, 0.02862632f, 0.21079646f, 
    -0.09891844f, -0.07689787f, -0.10197654f, 0.08352190f, 0.06455438f, -0.09061842f, 0.13573039f, 0.02876144f, 
    0.07093353f, -0.13988833f, 0.00778254f, 0.05545639f, -0.75029767f, -0.09007512f, 0.18371490f, 0.35090786f, 
    0.01279541f, -0.01644778f, 0.09609497f, 0.18527372f, -0.05498781f, -0.04727737f, 0.08537994f, 0.06145425f, 
    -0.29710999f, -0.02398212f, 0.06558999f, 0.03811223f, 0.05530513f, -0.01197480f, -0.04151973f, -0.05589227f, 
    0.02625384f, -0.01217551f, -0.05143705f, -0.15780956f, 0.24737448f, -0.23430358f, 0.10497539f, -0.55283999f, 
    0.23952910f, -0.08703378f, 0.24418128f, -0.02471792f, -0.20026428f, 0.06394878f, 0.28500697f, -0.00047490f, 
    0.49751082f, 0.24791723f, -0.16024721f, -0.04269015f, 0.07155638f, 0.07947223f, 0.10333005f, -0.00661808f, 
    0.02257261f, 0.03872810f, -0.00663862f, 0.08858708f, -0.18413155f, 0.18029420f, -0.08054820f, 0.00309032f, 
    0.00770778f, -0.00487394f, -0.03726060f, -0.15240745f, 0.04674550f, -0.06403518f, -0.08676887f, 0.05747183f, 
    -0.07224887f, -0.40157524f, -0.05232718f, 0.12396999f, -0.10264084f, -0.02458544f, 0.05441008f, 0.07959731f, 
    -0.14600077f, -0.06918106f, 0.09463362f, -0.04011779f, -0.27340499f, -0.38576460f, 0.17237441f, -0.31955808f, 
    -0.00200673f, 0.13526930f, 0.05191291f, -0.07222635f, 0.05486249f, 0.09631571f, 0.05721092f, 0.05521038f, 
    0.09605175f, -0.12244559f, -0.05229732f, 0.17300363f, -0.14841709f, 0.06303582f, 0.10057981f, 0.03130817f, 
    -0.01942962f, 0.04057262f, 0.01505473f, -0.12211809f, 0.02719241f, 0.14312744f, 0.13386382f, 0.22910570f, 
    -0.27236119f, -0.05527119f, -0.08184654f, 0.01766398f, 0.05772206f, 0.00881834f, -0.02035841f, 0.12589931f, 
    -0.12152819f, 0.07187495f, -0.04766840f, -0.14364144f, -0.08626186f, -0.00172957f, -0.03413883f, 0.01100822f, 
    -0.00910970f, -0.11081778f, -0.05667534f, -0.15989663f, -0.28267220f, -0.07978994f, 0.08970521f, -0.03760555f, 
    -0.09417952f, -0.00714027f, 0.05567101f, 0.13149507f, 0.14851899f, -0.05526812f, -0.03567494f, -0.16956805f, 
    0.25059023f, -0.07460993f, -0.09529613f, 0.36006522f, -0.13156696f, -0.09231528f, 0.12771574f, 0.14884245f, 
    0.01923537f, -0.06781781f, 0.08374923f, 0.14716487f, 0.13354471f, -0.16140378f, -0.17354718f, 0.13069594f, 
    -0.00373583f, 0.09244231f, 0.10849695f, 0.11411472f, 0.19526066f, -0.20787576f, -0.13083571f, -0.23743443f, 
    -0.15278763f, -0.05867803f, -0.09168986f, 0.09599125f, -0.02657551f, 0.04735076f, -0.17872223f, 0.07820184f, 
    0.28575596f, 0.07794908f, -0.04180203f, 0.13105151f, 0.07192070f, 0.03057311f, 0.23207717f, 0.24444565f, 
    -0.09482981f, 0.07153557f, 0.07348283f, 0.15715797f, 0.13170563f, -0.08148340f, 0.03265321f, 0.13258602f, 
    -0.21787989f, -0.22183329f, 0.58732098f, 0.03279260f, -0.11137778f, -0.06329819f, 0.08368253f, -0.03943681f, 
    -0.10210939f, -0.02395442f, -0.15916559f, -0.08731496f, 0.26482064f, 0.06954131f, -0.41307905f, 0.03536528f, 
    0.08392100f, 0.17176966f, -0.02141568f, -0.07263817f, -0.10233735f, -0.03318959f, -0.09389810f, -0.24784856f, 
    -0.36809838f, -0.15658568f, 0.01202990f, -0.10197495f, -0.07736158f, 0.15349188f, -0.04178323f, 0.10816202f, 
    0.21610539f, -0.13563414f, 0.37985069f, -0.04113253f, -0.01445555f, -0.28492874f, -0.04440038f, -0.30377537f, 
    0.09883323f, -0.10382700f, 0.09781577f, 0.00692841f, 0.04332861f, 0.10431662f, 0.03720279f, 0.17561190f, 
    -0.42964503f, -0.38729191f, 0.16365661f, 0.17046653f, -0.14922903f, -0.03304630f, 0.17506970f, -0.17917188f, 
    -0.00331920f, 0.03150002f, 0.02383393f, 0.11889596f, -0.93448246f, -0.12913562f, -0.07219325f, -0.28999782f, 
    0.06659452f, 0.08091253f, 0.08548057f, 0.00067191f, 0.01137620f, 0.05917150f, -0.02346379f, 0.04173584f, 
    -0.25481737f, -0.40861708f, -0.17455551f, -0.09615897f, 0.10708170f, 0.09119225f, -0.05048357f, -0.17316839f, 
    -0.02421455f, 0.07908077f, -0.03229626f, 0.12759572f, 0.15078141f, -0.26843295f, 0.11691764f, 0.15412728f, 
    -0.20743534f, -0.05491096f, -0.14789109f, -0.20636635f, -0.09913111f, -0.01578823f, 0.05129699f, 0.13031346f, 
    -0.47406307f, 0.18232265f, 0.06516179f, -0.10169376f, 0.19971886f, -0.11566138f, -0.04017641f, -0.00732661f, 
    -0.02425065f, -0.08704878f, 0.10706586f, -0.18512316f, -0.05633560f, 0.16721727f, 0.22571218f, -0.02277982f, 
    -0.09452134f, 0.20002678f, 0.18122695f, 0.08997997f, 0.12704322f, -0.14045613f, -0.31175566f, -0.06872141f, 
    -0.02654631f, -0.15797409f, -0.06199577f, -0.01496179f, 0.16625491f, -0.25748503f, -0.01838840f, 0.04693944f, 
    -0.00298155f, -0.13653491f, -0.11492707f, -0.30890873f, 0.04794184f, 0.03317446f, 0.04566633f, -0.41507816f, 
    0.07704338f, 0.12350970f, -0.08277510f, 0.04475943f, -0.07344307f, -0.10391979f, 0.26187167f, -0.10764223f, 
    -0.03590452f, 0.06528662f, 0.13934383f, 0.27883860f, -0.07286779f, -0.04459970f, 0.05134078f, 0.14554700f, 
    -0.24309595f, -0.14720942f, 0.06675071f, -0.08254256f, -0.01802134f, -0.29177308f, 0.17352772f, 0.21200527f, 
    -0.11623380f, 0.03856653f, 0.03550278f, 0.16913019f, 0.25946683f, -0.04846525f, 0.12577112f, -0.10493863f, 
    0.17687850f, -0.07693260f, -0.00828736f, 0.21685171f, 0.07365698f, -0.06342632f, -0.03309559f, 0.22221452f, 
    0.24056867f, 0.20482491f, 0.05941822f, -0.20260058f, -0.21320108f, 0.18396182f, -0.23357196f, -0.06448017f, 
    0.09509724f, -0.16394553f, 0.07410899f, -0.07378932f, -0.02135522f, 0.04991368f, -0.03290308f, -0.17596461f, 
    -0.36203074f, 0.14699587f, 0.09892131f, -0.10335451f, -0.01111643f, -0.01320556f, 0.08956067f, -0.18651360f, 
    0.07987269f, -0.15086506f, 0.07346984f, -0.11499872f, -0.19003056f, 0.17008589f, -0.50970536f, -0.29811308f, 
    0.08721664f, 0.19961470f, -0.06931652f, -0.09840870f, 0.05237628f, -0.08640427f, -0.13905197f, 0.04847748f, 
    0.13389170f, -0.09363965f, -0.09423619f, -0.21606886f, 0.01420793f, 0.11895864f, -0.01607681f, -0.13364036f, 
    0.05416685f, -0.01098752f, 0.24989861f, 0.25953519f, 0.01208832f, 0.03707346f, 0.00914170f, 0.19688019f, 
    -0.06769159f, 0.13775560f, -0.18220754f, 0.34407377f, 0.02070629f, -0.09190533f, 0.04357179f, -0.37389377f, 
    -0.06853723f, 0.06439680f, 0.25590846f, -0.21622752f, -0.05336292f, -0.18041950f, -0.02335196f, -0.06576257f, 
    0.01479342f, 0.03871507f, 0.01863414f, -0.08193723f, -0.41795737f, -0.02165177f, -0.10191216f, -0.01646842f, 
    0.22762679f, -0.12360403f, -0.18412739f, 0.04322712f, 0.08641156f, 0.04348139f, 0.04602745f, -0.19971564f, 
    -0.00590619f, 0.09534113f, -0.00031998f, -0.09399514f, 0.02645352f, 0.12101646f, -0.17239930f, -0.26157081f, 
    -0.24202636f, -0.13882840f, 0.07386624f, -0.02614915f, 0.05346930f, 0.09056798f, -0.04668641f, 0.12992206f, 
    -0.05073251f, 0.06000932f, 0.01491700f, 0.01057521f, -0.09302337f, -0.01077434f, 0.17952752f, -0.06193211f, 
    -0.02837930f, 0.09262612f, 0.18690881f, 0.16612011f, 0.12728447f, -0.04592879f, -0.14002877f, -0.11305583f, 
    -0.04867323f, -0.07770312f, -0.08438569f, 0.27155823f, 0.07665171f, 0.03987680f, 0.00470379f, 0.09853987f, 
    -0.04898887f, 0.06729923f, 0.10930375f, -0.02984939f, 0.03689224f, 0.07401970f, -0.04597273f, 0.12357225f, 
    -0.01839746f, 0.03511743f, 0.12950367f, -0.06474351f, 0.03860239f, 0.23273346f, 0.04019234f, -0.01704838f, 
    -0.05006528f, 0.09866859f, -0.01085247f, 0.18440883f, 0.10779272f, -0.05772303f, 0.12250143f, 0.03718419f, 
    -0.10385492f, 0.07116386f, 0.01619013f, -0.10862645f, -0.15447868f, 0.12127183f, 0.08533007f, 0.17195868f, 
    0.11277383f, -0.01214350f, 0.00463782f, -0.25927606f, 0.08801959f, -0.14175746f, -0.03237832f, 0.06749056f, 
    -0.02245867f, 0.10265104f, -0.29304329f, -0.01530944f, 0.01757508f, -0.04034213f, -0.22518677f, 0.17681742f, 
    0.01862014f, 0.14874174f, -0.00544631f, 0.00272582f, -0.09520477f, -0.06941549f, 0.03730869f, 0.04672854f, 
    -0.15455563f, -0.21862094f, -0.28910518f, 0.41323146f, 0.00499494f, -0.14482524f, 0.15587361f, -0.06041200f, 
    -0.02175654f, 0.04977820f, -0.06526335f, -0.18710499f, -0.02512571f, 0.17993887f, -0.02400954f, 0.18040138f, 
    -0.08614288f, -0.08346856f, -0.02745187f, 0.03340166f, -0.16847049f, 0.03929435f, -0.02572316f, -0.14012268f, 
    0.37334076f, -0.14868380f, -0.06805969f, -0.12638164f, -0.02003475f, 0.10659575f, 0.05088030f, 0.08225060f, 
    0.09958455f, 0.10974743f, -0.02343235f, 0.10932185f, -0.04354732f, 0.03120204f, -0.19837117f, -0.37283042f, 
    -0.19651772f, -0.06371143f, -0.06730423f, -0.04693436f, 0.04458322f, -0.02060181f, -0.06894354f, 0.14261609f, 
    0.11089434f, -0.37390065f, -0.05730901f, 0.02790668f, -0.01992681f, -0.05775392f, -0.06265485f, -0.06580515f, 
    -0.06729505f, 0.05513848f, -0.07720926f, 0.08271503f, 0.20524463f, 0.06096344f, -0.14314424f, 0.32556841f, 
    0.01019609f, 0.10202646f, -0.07848826f, -0.04378670f, -0.02955874f, -0.12178113f, -0.04933605f, -0.05715648f, 
    0.09024675f, -0.01204048f, 0.04349189f, 0.03680553f, -0.13209328f, -0.04904089f, -0.14917341f, -0.00901642f, 
    -0.34324846f, 0.05339643f, 0.05137438f, -0.18333763f, -0.44678333f, -0.05105437f, 0.03215420f, -0.21816929f, 
    -0.05881905f, -0.01517623f, 0.09165882f, 0.06370111f, 0.02423525f, -0.08073002f, 0.02778335f, 0.03193924f, 
    -0.50946176f, -0.03269089f, -0.09564988f, -0.25535101f, -0.01753769f, 0.07915439f, 0.06277151f, 0.07787026f, 
    0.08821154f, -0.08230384f, 0.07607506f, -0.07689667f, -0.66890591f, -0.00569564f, -0.00072792f, 0.10111260f, 
    0.11388322f, 0.01082073f, 0.21849723f, -0.05975569f, 0.03240887f, -0.15422587f, 0.02820823f, 0.08948077f, 
    0.73476136f, -0.68959963f, 0.22535880f, 0.03593548f, -0.05569971f, 0.01786627f, 0.16296934f, -0.13254911f, 
    0.09619828f, 0.08596440f, 0.03774561f, 0.01452552f, 0.21347444f, -0.07095972f, 0.04084389f, 0.15916061f, 
    -0.07281179f, -0.24193485f, -0.05389395f, -0.18002827f, -0.04208599f, -0.01533857f, 0.19246434f, 0.05620516f, 
    -0.17361382f, 0.43060559f, 0.11640301f, 0.26470128f, -0.12795077f, 0.19077927f, 0.00529818f, 0.12450122f, 
    -0.04357801f, 0.15983851f, 0.03637474f, 0.19211647f, 0.41489664f, 0.27712756f, 0.17190643f, -0.12481603f, 
    -0.21811138f, 0.04026943f, 0.06429283f, 0.03303057f, 0.06541868f, 0.12819144f, -0.19207235f, 0.23175168f, 
    0.08800571f, 0.01223629f, -0.28149262f, 0.13522300f, 0.07239678f, 0.05419165f, -0.04087175f, 0.01681031f, 
    0.26074621f, -0.09981255f, -0.02820227f, 0.16682985f, 0.03976239f, 0.00768305f, -0.41295084f, -0.04135969f, 
    -0.02118686f, 0.13317312f, 0.03536684f, -0.13799028f, -0.03006496f, 0.11481141f, -0.11683296f, 0.10629503f, 
    -0.27346447f, 0.06956679f, -0.39965025f, 0.11378550f, 0.15859726f, -0.00305219f, 0.05082387f, -0.06560907f, 
    0.09802059f, -0.11246748f, 0.11991728f, -0.00715314f, 0.18898033f, -0.20472302f, 0.04697022f, -0.28645098f, 
    -0.08568985f, 0.07089438f, -0.03481079f, 0.14168853f, 0.03956671f, -0.10690543f, 0.10569987f, 0.19222231f, 
    0.14245813f, -0.47771543f, -0.03543800f, 0.20165212f, -0.17385636f, 0.06332266f, 0.01903460f, -0.00353526f, 
    -0.08028455f, 0.05426592f, -0.04572911f, 0.17103183f, -0.29540768f, -0.52670896f, -0.16474836f, -0.33662039f, 
    0.08417168f, 0.07746167f, -0.08117180f, -0.14137627f, 0.03093716f, -0.01340713f, 0.24009453f, 0.19030316f, 
    0.28459331f, 0.11972170f, 0.09801732f, -0.10821000f, -0.19220391f, 0.00266542f, 0.10120474f, 0.15086414f, 
    0.04103575f, 0.01731049f, -0.02456832f, -0.42167836f, 0.14492533f, 0.25839120f, 0.01741186f, 0.06029017f, 
    0.01046264f, 0.04801542f, 0.05241742f, -0.13580213f, 0.13390498f, -0.02054339f, -0.00942013f, 0.20665441f, 
    -0.05149252f, -0.08831263f, 0.09831813f, -0.40252545f, -0.15859438f, 0.07372173f, -0.06022403f, 0.06803781f, 
    -0.09020039f, -0.05505661f, 0.07646132f, 0.04265827f, 0.31301799f, -0.00260957f, 0.18679217f, -0.32524022f, 
    0.11777990f, 0.00614791f, 0.27456656f, -0.02785856f, -0.19240177f, -0.01341271f, 0.16438520f, 0.09539565f, 
    -0.12448745f, 0.12077150f, -0.23354974f, 0.40814877f, 0.09463597f, 0.03882955f, -0.02730460f, 0.10018862f, 
    0.19528688f, 0.06612306f, -0.10632231f, -0.16650692f, -0.52125853f, 0.19011587f, 0.10959355f, 0.32986280f, 
    0.08436720f, -0.02934758f, 0.05646674f, -0.02207650f, 0.03342079f, -0.06658857f, -0.04468330f, -0.16609745f, 
    -0.07469174f, -0.25985074f, -0.31263778f, 0.01102551f, -0.04644414f, 0.00594071f, -0.07452391f, -0.16902593f, 
    -0.21068633f, -0.19536674f, -0.05051805f, -0.27094486f, -0.13858917f, 0.20528321f, -0.04070466f, -0.41964495f, 
    0.11392485f, -0.02165613f, -0.04291970f, 0.05337214f, -0.14373437f, 0.18373837f, 0.10222700f, -0.07250272f, 
    -0.21203543f, 0.17287387f, 0.13994667f, 0.02650900f, -0.22501458f, -0.10306945f, -0.01627800f, 0.09529094f, 
    0.04452677f, -0.10970227f, 0.07061460f, -0.18747286f, 0.08922379f, 0.21865843f, 0.17752446f, -0.46125755f, 
    0.00994138f, -0.05787110f, 0.02479850f, 0.04579091f, 0.12287738f, -0.08620997f, -0.07098507f, -0.09327025f, 
    0.24178250f, -0.50657570f, 0.25286371f, 0.17865914f, -0.10599643f, -0.17468964f, -0.08637176f, -0.03479840f, 
    -0.03993151f, 0.03508713f, -0.05646278f, -0.11653819f, 0.04640651f, 0.04094233f, -0.12085815f, 0.13412495f, 
    -0.16345300f, -0.06006173f, -0.10665175f, -0.04027470f, -0.02108877f, 0.04302855f, 0.00979338f, -0.00918770f, 
    0.26695126f, 0.25715223f, 0.25407118f, 0.03643154f, 0.12293251f, -0.05000315f, 0.02078161f, -0.03550912f, 
    -0.01466642f, -0.07136907f, -0.06587861f, -0.10984863f, -0.11199620f, 0.01005019f, -0.25838333f, -0.19313896f, 
    -0.07805593f, -0.03832991f, 0.07634252f, -0.04083646f, -0.12382024f, 0.00035311f, 0.01369947f, 0.00764732f, 
    -0.47753513f, 0.21156400f, -0.07374024f, -0.02724770f, 0.01894843f, -0.04988584f, 0.03233868f, -0.15444715f, 
    -0.15813558f, 0.11934795f, 0.00599788f, -0.10948647f, 0.16924785f, 0.29835281f, 0.05856549f, 0.21713728f, 
    0.22979829f, 0.14320315f, 0.15884104f, 0.04281413f, -0.10191944f, 0.01797793f, -0.02342855f, -0.09715933f, 
    0.00258309f, 0.25974187f, -0.14358948f, 0.10391331f, 0.12744650f, -0.00342022f, -0.06710161f, -0.08853087f, 
    -0.00918221f, 0.00315545f, 0.02683699f, -0.01254063f, 0.15559606f, -0.27832162f, 0.19027288f, 0.02063090f, 
    0.11051282f, 0.01879086f, -0.03110842f, -0.09885093f, -0.05835132f, 0.04798853f, -0.12654249f, 0.03931952f, 
    -0.11248282f, 0.22240300f, 0.02124715f, 0.24783529f, 0.14853582f, -0.09408642f, 0.00023990f, -0.03707740f, 
    -0.10306724f, 0.04106920f, -0.07621908f, -0.00767475f, 0.05015204f, -0.03830177f, 0.27934235f, 0.11843836f, 
    -0.02405018f, 0.04448592f, -0.08458916f, 0.00002735f, -0.03089780f, 0.05809639f, 0.03170811f, -0.00202896f, 
    0.05246765f, 0.10051679f, 0.17639983f, 0.05380831f, 0.17197822f, 0.01261818f, -0.07032204f, -0.19183066f, 
    0.03008219f, -0.00615735f, 0.03556030f, -0.06742616f, 0.03228251f, -0.07500407f, 0.22889543f, 0.32771376f, 
    0.15604270f, -0.08340001f, -0.11589868f, -0.12517594f, -0.01453816f, -0.07674223f, -0.05265220f, -0.07810232f, 
    0.38308102f, -0.16552134f, 0.05191850f, -0.17376521f, -0.03238769f, 0.04242411f, -0.05557748f, 0.05253765f, 
    -0.00757277f, 0.14823841f, -0.15301551f, 0.02212700f, -0.16093880f, 0.03531827f, 0.17665105f, 0.02447683f, 
    0.16573499f, 0.00504183f, -0.00582148f, 0.09455530f, -0.14789277f, 0.01117074f, 0.02975815f, -0.04345245f, 
    -0.00637761f, -0.16681980f, -0.15538047f, -0.19966643f, 0.00156269f, -0.05043678f, 0.04951660f, -0.12844194f, 
    -0.07635991f, -0.07739940f, -0.17171450f, 0.06603518f, 0.24764188f, -0.00185827f, -0.21964888f, -0.22571506f, 
    0.01666459f, 0.02736672f, 0.01168520f, -0.06730919f, -0.09490544f, -0.01913863f, -0.03011301f, -0.10451379f, 
    -0.13140653f, 0.18242925f, -0.10751984f, 0.17166817f, -0.02912911f, -0.01725524f, -0.11035056f, 0.07210173f, 
    -0.05902941f, 0.05998287f, 0.03420402f, 0.07409081f, 0.00962111f, 0.18380733f, 0.04413201f, 0.20226115f, 
    -0.06393734f, 0.00802885f, -0.14184882f, 0.03746549f, -0.11259683f, -0.04364463f, -0.10477842f, -0.02569251f, 
    -0.18731464f, 0.12478375f, 0.03292141f, 0.00894352f, -0.01819266f, -0.06093217f, -0.03294752f, -0.03513652f, 
    -0.09964481f, -0.06874619f, -0.04691708f, -0.06065465f, 0.18339412f, 0.16742688f, 0.10540687f, 0.24568050f, 
    0.05975401f, -0.07518215f, 0.00744609f, -0.04997459f, 0.00032660f, 0.09724613f, 0.06875340f, -0.13893884f, 
    -0.19028977f, 0.07862858f, -0.00138864f, -0.03179936f, -0.01756713f, -0.15523314f, -0.00980259f, 0.11351102f, 
    0.04751882f, -0.03001926f, 0.01078989f, -0.04063185f, 0.17729530f, 0.13101965f, 0.25361741f, 0.18162853f, 
    0.04070215f, 0.08923440f, 0.04124807f, -0.08556732f, -0.02877088f, 0.04425358f, -0.00479438f, -0.05037211f, 
    -0.03790025f, -0.18711732f, -0.08438839f, -0.07840969f, -0.20597579f, -0.03160286f, -0.03407232f, -0.09323267f, 
    -0.00778696f, 0.01999576f, -0.01763589f, 0.00120332f, 0.12585902f, -0.35284895f, 0.01619307f, -0.03313315f, 
    -0.18587542f, -0.01993029f, -0.07744385f, -0.16778031f, 0.07491411f, -0.12305888f, 0.09332425f, -0.11059466f, 
    -0.09884347f, 0.18484388f, 0.13049586f, 0.00791390f, -0.10895093f, -0.01422542f, -0.03613257f, -0.10521874f, 
    0.03480951f, -0.03308550f, -0.07288497f, -0.06197810f, 0.32169750f, 0.04560696f, 0.03225547f, -0.30195078f, 
    -0.11985147f, 0.11332566f, -0.01684617f, 0.00222447f, -0.08956987f, 0.03051247f, 0.01649765f, -0.07569057f, 
    0.00988052f, 0.04338004f, -0.24097897f, 0.05543381f, 0.05772217f, -0.03223087f, -0.15309088f, 0.04950825f, 
    0.04976519f, 0.08923461f, -0.00073120f, -0.01355350f, -0.06542658f, -0.31540728f, -0.15758918f, -0.17196770f, 
    0.00477270f, 0.01695853f, -0.02037514f, -0.00263707f, -0.01640053f, -0.10042747f, -0.04520457f, 0.00516763f, 
    -0.02411420f, 0.18735895f, -0.10772049f, 0.19794728f, -0.00555273f, -0.17454860f, -0.12652247f, 0.00135236f, 
    0.05547339f, -0.06114989f, -0.08463830f, -0.06994427f, -0.65261668f, 0.04092572f, -0.27793771f, -0.06347105f, 
    -0.16039331f, -0.05052889f, 0.02478822f, -0.10009220f, -0.08830346f, 0.06402284f, 0.00662666f, -0.00493328f, 
    -0.47605899f, 0.20043789f, 0.07218222f, -0.14817254f, -0.10063394f, 0.00283698f, -0.00110117f, -0.02172792f, 
    0.02176825f, 0.00686090f, -0.01348546f, -0.01541233f, -0.33386934f, -0.01618887f, -0.25382382f, -0.16551442f, 
    -0.10723315f, 0.02037561f, -0.07719071f, -0.00374811f, -0.01047499f, -0.00931953f, -0.05065950f, -0.08042848f, 
    -0.12920704f, -0.18044890f, -0.23954217f, -0.07500961f, -0.01712708f, 0.02254391f, -0.03556391f, -0.09872006f, 
    0.10220160f, 0.09014919f, 0.07097469f, 0.13600692f, -0.03815397f, 0.11873157f, -0.21737477f, -0.04720256f, 
    -0.03571349f, 0.08866872f, -0.08559188f, -0.00639764f, 0.20634909f, -0.06983526f, -0.03492327f, 0.05576652f, 
    0.02427224f, 0.13611756f, -0.00720286f, -0.03782051f, -0.04783428f, 0.03355736f, 0.02666524f, -0.00798602f, 
    -0.06792404f, -0.09436968f, 0.06978831f, 0.13930763f, 0.15464446f, 0.14486134f, -0.05953665f, 0.13800511f, 
    0.17801648f, 0.04107856f, -0.03355086f, -0.16450207f, 0.04623982f, 0.03518491f, 0.20791949f, -0.04914892f, 
    0.00453775f, -0.23573162f, -0.07312883f, 0.07551289f, -0.02461790f, -0.14498663f, -0.13363282f, 0.01610195f, 
    0.19664510f, -0.10087748f, 0.08007123f, -0.13237406f, -0.26765454f, -0.18655869f, 0.04081625f, -0.06547388f, 
    0.01113783f, 0.04771519f, -0.08873773f, 0.04137062f, 0.04077737f, -0.06991184f, -0.03443318f, -0.16706327f, 
    -0.02913830f, -0.00188003f, -0.14555927f, -0.12096790f, -0.03098948f, -0.04024035f, -0.13475086f, -0.05643094f, 
    0.01029859f, 0.04481172f, 0.03755886f, -0.08744851f, -0.01629372f, -0.06419451f, 0.10149355f, -0.08894779f, 
    -0.07637055f, 0.06945174f, 0.05721916f, -0.18717346f, 0.02938233f, 0.07410254f, 0.03648133f, 0.14474386f, 
    -0.16964473f, 0.17798136f, 0.05532405f, -0.10320126f, 0.04741219f, -0.16708125f, 0.09515529f, 0.03218513f, 
    0.10201125f, 0.11740599f, 0.00463836f, 0.08824676f, -0.17469302f, 0.20482998f, 0.11096033f, 0.02961444f, 
    -0.04745800f, 0.12581709f, 0.00083268f, -0.04983736f, 0.04575232f, 0.05786052f, 0.03834587f, 0.06794232f, 
    -0.32427394f, -0.07885507f, 0.23216973f, 0.00117098f, -0.18991071f, 0.01946919f, -0.03508879f, -0.16993269f, 
    -0.01334496f, -0.10233559f, 0.09189481f, 0.12792617f, 0.02576461f, 0.22701222f, -0.06614450f, 0.18165888f, 
    0.03815667f, 0.00569141f, -0.34737065f, -0.28334457f, -0.08304715f, 0.08282802f, 0.08129911f, -0.17458659f, 
    0.09743623f, -0.20067495f, 0.04140993f, -0.13696902f, 0.08864512f, -0.00752941f, 0.09054646f, -0.03700258f, 
    0.07127199f, -0.12123848f, 0.11189153f, 0.01322706f, -0.20769057f, -0.02657267f, 0.04639462f, -0.03946698f, 
    -0.14757217f, 0.00125643f, 0.01733993f, -0.09403469f, 0.06558167f, -0.37601602f, -0.23263137f, 0.15688881f, 
    0.05805288f, 0.03741028f, -0.01882776f, -0.13749266f, 0.05273186f, -0.03685276f, -0.11949436f, 0.03253176f, 
    0.00448221f, -0.04038260f, 0.04121165f, -0.18473938f, -0.14346766f, -0.00624590f, 0.07818519f, -0.06516284f, 
    0.16072632f, 0.00582815f, -0.09496697f, -0.01365319f, 0.01664399f, 0.02222617f, 0.07688252f, -0.06896210f, 
    -0.16396374f, 0.04461007f, -0.43205604f, -0.18368439f, 0.17828710f, 0.01632700f, -0.23867203f, 0.16932456f, 
    0.12281959f, -0.08446029f, 0.14720601f, -0.16605709f, -0.18973060f, 0.32288924f, 0.08441491f, -0.30502039f, 
    -0.04938651f, 0.07235771f, -0.04051260f, -0.05538904f, 0.08992878f, -0.18463406f, -0.00796502f, 0.03651788f, 
    -0.05260338f, 0.32755589f, -0.16672260f, -0.26117554f, -0.03172378f, -0.01574370f, 0.05830607f, -0.03375096f, 
    0.07852411f, 0.01763218f, -0.17663568f, -0.20465103f, -0.16987360f, -0.11868442f, 0.05441062f, -0.39515921f, 
    -0.09233999f, -0.23851782f, 0.12038148f, 0.02676451f, 0.13484617f, -0.12398195f, -0.16718291f, 0.13928509f, 
    0.30763698f, 0.12136165f, -0.01941960f, 0.18227868f, -0.12361037f, -0.01231841f, -0.15510325f, -0.07255876f, 
    -0.02254468f, -0.09482946f, -0.10826673f, -0.19987562f, -0.27719530f, 0.15701862f, 0.13288105f, 0.07510491f, 
    -0.22101323f, 0.00796899f, -0.03668034f, 0.12357651f, 0.04339624f, 0.02151689f, -0.32189658f, -0.04422945f, 
    -0.09184325f, -0.33754814f, 0.04284163f, -0.03128781f, -0.00584840f, 0.06858600f, -0.04702463f, -0.21354176f, 
    -0.10793343f, 0.10071954f, -0.05440324f, 0.16077730f, 0.16337030f, -0.16427720f, 0.00738026f, -0.21609035f, 
    0.01205665f, 0.06077480f, 0.09100009f, 0.21864918f, 0.02913130f, 0.03142028f, -0.10245610f, 0.02247551f, 
    0.09512079f, 0.18902959f, 0.11621199f, 0.25975582f, 0.04111875f, -0.04506643f, -0.05193097f, 0.05067662f, 
    0.05788868f, -0.02325406f, 0.05201476f, -0.23961587f, -0.05374312f, -0.09542585f, 0.06934878f, -0.18447149f, 
    -0.05025496f, -0.04457411f, -0.00659791f, 0.12168116f, 0.05036153f, -0.10553980f, -0.06794763f, -0.25358692f, 
    -0.03383679f, 0.33963728f, -0.32951617f, 0.02045854f, -0.08886074f, -0.01175389f, -0.20505738f, -0.03088396f, 
    0.00645364f, -0.01389486f, -0.01147631f, 0.25529462f, 0.25573865f, -0.17945381f, -0.06639007f, -0.14761852f, 
    0.16687375f, 0.04307105f, -0.08514951f, -0.03122311f, 0.08172453f, 0.00210519f, -0.02269332f, 0.01831614f, 
    -0.07593970f, 0.22886166f, -0.23292011f, -0.42767787f, -0.09286112f, -0.03674452f, -0.05212507f, 0.13714801f, 
    0.14723885f, -0.04814466f, 0.11899815f, 0.08891356f, -0.16320589f, -0.22750147f, -0.00467651f, 0.17830417f, 
    -0.00654729f, 0.07063236f, -0.04771833f, -0.00655283f, 0.10352150f, -0.13701314f, 0.14481334f, 0.01035760f, 
    0.24819392f, 0.11691346f, 0.17085688f, 0.16760467f, 0.08002157f, 0.02990966f, -0.04054199f, -0.08979170f, 
    -0.14913286f, 0.02854175f, -0.13202859f, 0.09637438f, -0.13391210f, -0.19660451f, -0.00331994f, 0.26650703f, 
    0.20577517f, -0.03693892f, 0.00684752f, -0.11782730f, 0.04459427f, 0.07356906f, 0.20731261f, -0.06493297f, 
    0.06512956f, -0.32800502f, -0.09365531f, -0.39099333f, -0.13350198f, 0.12919681f, -0.07041959f, -0.00774181f, 
    0.00167085f, -0.16341977f, 0.11944960f, -0.05574486f, -0.22156334f, 0.28868243f, 0.12807666f, -0.10915451f, 
    0.00928558f, 0.01890551f, -0.06078350f, -0.16133478f, 0.06063344f, 0.10626063f, 0.05045424f, 0.09120478f, 
    -0.09271996f, -0.33096102f, 0.08794631f, -0.08901232f, 0.04953333f, -0.07327387f, -0.14106701f, 0.08281434f, 
    -0.25150248f, -0.00528643f, -0.02215139f, -0.02003694f, 0.18546270f, 0.34008718f, -0.11148153f, -0.30146620f, 
    0.02262938f, 0.15465511f, 0.03450803f, -0.14540839f, -0.09088919f, 0.00942189f, -0.05524966f, 0.02125206f, 
    -0.21734633f, 0.19977818f, -0.21582271f, -0.19852901f, -0.08924290f, -0.06081410f, -0.09585758f, 0.10306142f, 
    -0.07737531f, -0.01568019f, -0.02564328f, 0.04752626f, -0.46693876f, -0.31208429f, 0.06356065f, 0.01155742f, 
    0.14300945f, 0.08115144f, -0.04741984f, 0.05894293f, -0.07646415f, 0.01059644f, 0.03048903f, 0.11474280f, 
    -0.48877469f, 0.09965473f, 0.04722492f, 0.05893564f, 0.09471510f, 0.08195377f, -0.17689137f, 0.02748912f, 
    0.12460004f, -0.04697115f, 0.00117576f, 0.03207089f, 0.06669006f, -0.20670050f, -0.01029817f, -0.04551125f, 
    0.07362215f, 0.08480207f, 0.00045543f, -0.00074527f, 0.09067167f, -0.01734094f, 0.00456762f, -0.22747223f, 
    -0.35365036f, -0.49989718f, -0.01496518f, -0.12439918f, -0.05373914f, -0.03451860f, 0.02191779f, 0.05146889f, 
    0.00448681f, -0.31153634f, 0.08233460f, 0.02778497f, 0.21601343f, -0.66038942f, -0.01434077f, 0.02403194f, 
    -0.05513742f, -0.09215864f, -0.10665804f, 0.17925410f, 0.05802738f, 0.09655891f, -0.06845154f, -0.01451995f, 
    0.12161724f, -0.41794369f, -0.09590813f, 0.11380801f, 0.00846367f, -0.04559875f, -0.09626479f, 0.07432501f, 
    -0.16064985f, -0.11307026f, -0.03183863f, -0.13200232f, 0.35456035f, -0.97302616f, -0.18274215f, 0.11303851f, 
    0.07918701f, 0.01589311f, 0.00147771f, 0.20886043f, -0.04648277f, 0.12125506f, 0.08887672f, -0.05612838f, 
    0.35104859f, 0.02185110f, -0.11678888f, 0.13217090f, 0.14853495f, -0.00087223f, 0.06592271f, 0.00777516f, 
    -0.13886420f, 0.02194219f, 0.02059941f, 0.13786577f, -0.03730126f, -0.25657848f, -0.11539800f, 0.31301707f, 
    0.04566716f, 0.03760848f, -0.17485806f, 0.19849773f, -0.08485872f, 0.05174871f, 0.22835226f, 0.06326117f, 
    0.13462916f, -0.07621081f, 0.12627029f, -0.16737728f, -0.02370435f, 0.10508037f, 0.04572886f, -0.20163617f, 
    -0.02615050f, 0.11894409f, 0.00380494f, 0.13947663f, -0.37604624f, -0.16825078f, 0.13139470f, -0.33642364f, 
    0.13054152f, -0.16185553f, 0.10614875f, -0.10066302f, 0.14366873f, 0.03943097f, 0.12683766f, 0.02762109f, 
    -0.36595997f, -0.10078703f, 0.38304755f, -0.10418305f, 0.06308161f, 0.15399775f, 0.07597009f, 0.06001561f, 
    0.07928588f, 0.09169824f, 0.04246502f, -0.06681105f, 0.47029752f, 0.17879203f, -0.02657707f, 0.41915184f, 
    -0.05170838f, -0.02497180f, 0.03401460f, 0.07074392f, -0.01924084f, -0.07453518f, 0.07744881f, 0.09013630f, 
    -0.44506288f, 0.27742910f, 0.08331394f, 0.19869827f, 0.08930163f, 0.19201320f, 0.06542527f, -0.05099442f, 
    -0.15922092f, -0.03120949f, 0.16816019f, 0.14571500f, 0.54938185f, 0.07767242f, -0.06561408f, -0.16918996f, 
    0.18191248f, 0.07715425f, -0.02081897f, -0.00741227f, -0.17947625f, 0.01338508f, 0.08769208f, 0.02063344f, 
    0.15905833f, -0.23148119f, 0.17138985f, -0.02833797f, 0.16255248f, 0.03133660f, -0.03988630f, -0.12821795f, 
    0.01788703f, 0.05931248f, 0.05870017f, 0.12447884f, -0.05871702f, -0.06714962f, -0.15108569f, -0.04632866f, 
    0.00372336f, -0.02274857f, 0.14848828f, 0.07329951f, -0.03440851f, 0.02360604f, -0.06384684f, -0.18321553f, 
    -0.00987911f, 0.19011979f, 0.03475597f, 0.09558638f, 0.07535492f, -0.19121452f, -0.00849629f, 0.07811121f, 
    0.15112807f, 0.09405506f, -0.12541996f, -0.05070067f, 0.01123991f, -0.04540843f, 0.01223335f, 0.18881561f, 
    0.14100261f, 0.01576300f, -0.02756455f, 0.00718385f, 0.20210734f, 0.02575419f, -0.09056498f, 0.01377320f, 
    -0.50652683f, 0.31982800f, -0.57710832f, -0.03205444f, 0.04208386f, -0.02890040f, 0.17404075f, 0.05424087f, 
    -0.17746750f, -0.12075796f, -0.12701876f, 0.02573938f, -0.24859749f, 0.11910065f, 0.03326969f, 0.11814640f, 
    -0.18334091f, 0.05764422f, 0.03622215f, -0.10532826f, -0.02471728f, 0.05721863f, -0.00491093f, 0.17942163f, 
    0.18992515f, 0.34597805f, 0.38166851f, -0.09160000f, -0.04854397f, 0.06377697f, -0.06062685f, 0.06435802f, 
    -0.01508514f, 0.03260161f, -0.11877666f, -0.02298989f, 0.59525710f, -0.03334228f, 0.18050919f, 0.03581817f, 
    0.07943062f, 0.12402292f, -0.03970669f, 0.02185859f, -0.01672082f, -0.09285349f, -0.03172069f, -0.01767741f, 
    0.13093798f, 0.00299349f, 0.08620321f, -0.31369290f, -0.04245696f, -0.08878960f, -0.01695685f, 0.07022982f, 
    -0.06314626f, -0.06029014f, 0.00711066f, -0.18475235f, -0.34324196f, 0.29946810f, -0.02889081f, -0.44624847f, 
    0.00147626f, 0.09093485f, -0.14625363f, -0.08770294f, -0.12775210f, -0.19939840f, -0.00999503f, -0.06489333f, 
    -0.24384560f, 0.23661353f, -0.16809663f, 0.03456526f, 0.18228476f, 0.03580693f, -0.00757561f, -0.02881127f, 
    -0.00158266f, 0.06140752f, 0.02654572f, 0.00704350f, -0.03580847f, 0.04930246f, -0.08607494f, -0.31242198f, 
    0.10359260f, -0.04216016f, -0.10568393f, 0.06290521f, -0.09677937f, -0.08549848f, -0.27473167f, -0.00471988f, 
    0.00018512f, 0.28876331f, -0.12812369f, -0.07703487f, -0.03128227f, 0.07876126f, 0.17475905f, 0.00177468f, 
    0.09246366f, 0.11497897f, 0.05767227f, 0.22566774f, -0.57746369f, -0.13792823f, 0.16590048f, 0.07171301f, 
    0.08847585f, 0.06917311f, -0.05022735f, -0.10477337f, 0.27904189f, -0.21396577f, 0.06599605f, -0.14575106f, 
    0.07352263f, 0.03234395f, 0.11966654f, -0.04730373f, -0.05310504f, 0.02215460f, -0.05525858f, -0.02939495f, 
    0.04400949f, 0.11688930f, 0.22281142f, 0.03278474f, -0.55910474f, -0.51986849f, -0.01326049f, -0.03790266f, 
    0.08354886f, -0.10857188f, 0.06140926f, -0.06127988f, 0.07248937f, 0.09179179f, 0.14324659f, 0.00562738f, 
    -0.50903505f, -0.19043431f, -0.27570802f, -0.28913444f, 0.22295330f, -0.20855446f, -0.17264777f, -0.01390787f, 
    -0.03543292f, -0.19556418f, 0.06999224f, -0.01697177f, 0.18949680f, 0.06388565f, 0.03440987f, -0.05660717f, 
    -0.16222909f, -0.06384752f, 0.03332599f, -0.29125899f, 0.09870814f, 0.10307218f, -0.03389949f, -0.22095634f, 
    0.16400956f, -0.04371437f, -0.19959839f, -0.04211153f, -0.03837962f, -0.23232755f, 0.12248243f, -0.02323626f, 
    -0.20067517f, -0.00337073f, 0.03209972f, -0.22820985f, 0.09067421f, 0.24498253f, -0.10335392f, 0.01001300f, 
    0.12955546f, 0.21837711f, 0.11176391f, 0.07700168f, 0.04339242f, 0.05776856f, 0.13103390f, 0.13212882f, 
    -0.02487820f, 0.01257719f, -0.15417439f, -0.12590657f, 0.05485880f, 0.11460093f, 0.00587739f, -0.08317561f, 
    -0.04087091f, 0.33196548f, 0.08807454f, 0.25636634f, 0.27502090f, 0.16162370f, 0.03443600f, -0.01490554f, 
    -0.07178934f, 0.13523075f, 0.07480864f, 0.14450020f, 0.01951353f, 0.01410972f, -0.06057490f, -0.06200032f, 
    0.25412136f, 0.10878726f, 0.17595682f, -0.26634976f, 0.11369336f, -0.01564746f, 0.02472738f, 0.00522553f, 
    0.02068322f, 0.13219480f, 0.05885673f, 0.07203182f, -0.25625694f, 0.12847944f, -0.03572264f, 0.00761417f, 
    0.13161123f, 0.08013183f, -0.04198243f, -0.12637997f, -0.02756433f, -0.03872270f, -0.18735324f, 0.03012829f, 
    0.05951204f, 0.03512706f, -0.06171989f, 0.00099253f, -0.00280703f, -0.01271805f, 0.01069339f, -0.05416215f, 
    0.00428482f, 0.03895744f, -0.02631537f, -0.09186965f, 0.30710119f, 0.04165379f, 0.09614121f, 0.11189031f, 
    0.00611409f, 0.02486347f, 0.00414745f, -0.08381380f, 0.11828420f, -0.13095507f, -0.09691603f, 0.05869850f, 
    -0.66872054f, 0.12410895f, -0.22198129f, -0.09634289f, 0.19097556f, 0.03618035f, -0.21333532f, 0.01292086f, 
    -0.04728673f, -0.24853018f, -0.04176721f, -0.10400901f, -0.05833806f, 0.02437416f, 0.06611506f, 0.00450318f, 
    0.08841833f, -0.02909432f, 0.01079853f, 0.09370927f, -0.25558376f, 0.06946502f, -0.10502841f, -0.07605635f, 
    0.09646183f, -0.16982131f, 0.14922270f, 0.00097733f, 0.02301141f, 0.10033251f, -0.10612415f, 0.07554545f, 
    -0.06920111f, -0.12169906f, -0.15163170f, -0.13738082f, -0.28504592f, -0.07915044f, 0.28504035f, -0.06647701f, 
    0.02054407f, -0.07189754f, 0.08882160f, -0.12623702f, 0.12838814f, 0.00299832f, 0.00574763f, -0.21613106f, 
    0.02904812f, -0.02666832f, 0.13900684f, 0.07939371f, -0.12760064f, 0.01464877f, 0.04258439f, -0.11459748f, 
    0.06340025f, 0.11003941f, 0.14167857f, -0.02824468f, -0.04907067f, 0.01550522f, 0.12807284f, 0.24612023f, 
    -0.02429157f, -0.12668824f, 0.09152706f, -0.17697692f, 0.10352907f, -0.01626126f, 0.05963377f, 0.03818285f, 
    0.24041791f, 0.08625439f, -0.33634999f, 0.05002424f, -0.18641295f, -0.11996640f, -0.04659536f, 0.01278935f, 
    0.16589817f, 0.08242796f, 0.01027620f, -0.07901704f, 0.48432142f, 0.05980356f, 0.03928033f, -0.15785864f, 
    -0.28423834f, -0.03577834f, -0.08511598f, -0.09871654f, 0.06414064f, -0.06053141f, -0.13815519f, -0.13411394f, 
    0.06996650f, 0.18327305f, 0.04511772f, -0.04913833f, -0.03387772f, -0.01542610f, -0.05690629f, 0.21974562f, 
    -0.04423364f, 0.02818457f, 0.12985015f, 0.23271744f, 0.01464983f, -0.06905844f, 0.05625944f, -0.03072516f, 
    -0.06378319f, -0.11065982f, -0.04345344f, 0.02303765f, 0.11906589f, 0.02780819f, 0.03045741f, 0.02724004f, 
    -0.50717056f, -0.43802193f, -0.10378778f, -0.45550877f, -0.11936816f, -0.10348829f, -0.11165810f, 0.03995908f, 
    0.01171613f, -0.00667440f, -0.04807056f, -0.04177084f, -0.04588401f, -0.35416153f, -0.03083337f, 0.09498719f, 
    0.05170409f, -0.00134425f, 0.00638975f, 0.08212709f, -0.05213049f, -0.01682492f, -0.06589150f, -0.01145423f, 
    -0.39487964f, -0.31721205f, -0.05083805f, 0.19180712f, 0.07740044f, 0.05324173f, 0.07882006f, -0.13571925f, 
    0.07082751f, -0.07383644f, 0.06409307f, 0.02333666f, -0.92867035f, -0.20648681f, 0.22781502f, 0.19279493f, 
    0.18327388f, -0.04313678f, 0.02594326f, -0.25217405f, -0.02935710f, 0.02610185f, -0.00391717f, 0.13564400f, 
    0.26894209f, 0.20458172f, 0.17067875f, -0.07204527f, 0.24653152f, 0.12651353f, 0.03760881f, 0.00793956f, 
    -0.02767936f, 0.19081110f, 0.06008974f, 0.13148895f, -0.45568219f, -0.13836627f, 0.01051546f, -0.20994163f, 
    0.10237446f, 0.01436580f, -0.02908119f, 0.16611150f, 0.09263648f, -0.02163655f, -0.01003492f, 0.08259703f, 
    -0.75810599f, -0.45632762f, -0.27506077f, -0.29188618f, 0.03214428f, 0.05259653f, -0.07197409f, -0.14964189f, 
    0.12108250f, 0.03636849f, 0.12330469f, 0.23127785f, -0.45591277f, -0.17445987f, -0.07191651f, -0.32472593f, 
    -0.02721310f, 0.03274516f, -0.04595805f, 0.10634197f, 0.12439580f, 0.17900461f, 0.07504801f, 0.11003496f, 
    0.24996537f, -0.00066345f, -0.13927630f, 0.37128931f, 0.05255650f, -0.07030747f, 0.02488128f, 0.08605751f, 
    0.03826483f, 0.00212464f, -0.02766857f, -0.06778432f, 0.10189354f, 0.43457419f, -0.23500650f, 0.01750428f, 
    0.13513090f, -0.08617867f, -0.00429357f, -0.18961394f, -0.03834829f, 0.14244014f, 0.00043600f, 0.13832986f, 
    0.13167374f, 0.00531074f, -0.05970088f, 0.03157423f, 0.02591264f, 0.06675304f, -0.07644852f, -0.17397171f, 
    -0.17880706f, 0.08811478f, -0.06167777f, -0.18986572f, 0.56358397f, -0.49796689f, -0.23951150f, 0.01709047f, 
    -0.01916241f, 0.03603912f, -0.01971671f, -0.03391648f, 0.11636918f, 0.08938698f, -0.08960111f, -0.03491591f, 
    -0.11874452f, -0.31804040f, -0.07764819f, 0.01381507f, -0.03763279f, 0.02543131f, 0.07700694f, 0.03467198f, 
    0.11703374f, -0.09215075f, 0.11886011f, 0.16839300f, 0.24934679f, -0.24823053f, -0.07827709f, -0.03554380f, 
    -0.16098805f, -0.07495029f, -0.05739630f, -0.17818940f, 0.00498429f, -0.19949165f, -0.06937920f, -0.11248428f, 
    0.45809758f, -0.24289595f, -0.33091527f, 0.23436986f, 0.00995818f, 0.32024297f, 0.03320792f, -0.00681933f, 
    0.04424700f, 0.02441224f, -0.10157284f, 0.14402060f, -0.25832248f, 0.29719004f, -0.22075619f, -0.00057832f, 
    -0.13743013f, -0.02848130f, 0.02838865f, 0.14220995f, -0.07913680f, -0.00884527f, -0.01222366f, -0.16368806f, 
    0.10192181f, -0.11165456f, -0.03838380f, 0.30774951f, 0.13871810f, 0.17038457f, -0.13294090f, 0.02544540f, 
    -0.03880054f, -0.13723552f, 0.00063745f, 0.17981987f, -0.17845011f, 0.17320120f, -0.04221601f, 0.01143922f, 
    -0.01863982f, 0.08686382f, 0.02116530f, -0.13762523f, -0.07290574f, 0.02813526f, 0.14733425f, -0.05246991f, 
    0.04187138f, 0.28312847f, 0.08128335f, -0.22709043f, -0.15644503f, -0.02107755f, 0.08525334f, -0.15408216f, 
    -0.00258928f, 0.15339446f, -0.04567355f, -0.07513361f, -0.54709917f, 0.25302064f, -0.05650168f, 0.25310731f, 
    0.11915252f, 0.08689615f, 0.01797951f, 0.22909199f, 0.11112419f, -0.01856106f, 0.13111424f, -0.02520439f, 
    -0.57638460f, 0.11197060f, -0.05812697f, 0.06387787f, 0.11328876f, -0.01590667f, -0.07728327f, 0.10245306f, 
    0.13884789f, 0.07271738f, -0.09521095f, -0.04776856f, -0.09890580f, -0.03532581f, 0.02262419f, -0.00817322f, 
    -0.19647670f, -0.07617319f, -0.01811492f, -0.17359556f, -0.02850435f, 0.03583943f, 0.13278188f, 0.02712497f, 
    0.00719875f, -0.05321021f, -0.02567778f, -0.49557546f, -0.08161887f, 0.10149153f, -0.11632745f, 0.08320543f, 
    0.13024470f, 0.02789118f, 0.06660895f, -0.00304191f, 0.12558459f, 0.12396254f, -0.29540607f, -0.38830674f, 
    0.21721956f, -0.17462982f, 0.04664905f, 0.13430649f, -0.06254154f, -0.10708129f, -0.10522550f, 0.11991088f, 
    0.20084307f, 0.08743698f, -0.20963551f, 0.23613644f, 0.23067097f, -0.04160810f, 0.02816246f, -0.05084239f, 
    0.21231669f, -0.01172854f, -0.07073240f, 0.00570159f, -0.12017021f, -0.31168655f, -0.14293888f, -0.06249286f, 
    -0.09889089f, -0.36762354f, 0.00368563f, 0.00857343f, -0.18604879f, 0.12054005f, 0.15531866f, -0.00293956f, 
    -0.02101508f, 0.05404799f, 0.06967608f, 0.04757600f, 0.21325202f, -0.03313392f, -0.06532649f, -0.06606620f, 
    -0.00299326f, -0.08154146f, -0.10377434f, 0.10959481f, -0.09591365f, -0.23731767f, 0.20273407f, -0.19051835f, 
    -0.07832929f, 0.03358707f, -0.13137394f, -0.04169470f, -0.01666049f, -0.03274528f, 0.02322226f, -0.09654485f, 
    -0.42496490f, -0.39475212f, -0.08529256f, -0.02846330f, -0.08102896f, 0.04351265f, 0.02014500f, 0.30476931f, 
    -0.22243142f, 0.09422534f, -0.05178192f, 0.07899961f, -0.11305758f, 0.23247524f, -0.08445393f, 0.09479997f, 
    -0.13136607f, -0.11832731f, 0.10112227f, -0.15573037f, -0.02777204f, 0.19994123f, 0.10244729f, -0.13239169f, 
    -0.16212332f, -0.06662188f, 0.06140343f, -0.01004347f, -0.04146010f, -0.06292440f, -0.01209292f, 0.12485649f, 
    -0.03652276f, -0.13769732f, 0.02815452f, 0.02940781f, -0.29286024f, 0.14895165f, 0.07199250f, -0.19282439f, 
    0.01122027f, 0.09286723f, -0.08219874f, -0.25992024f, -0.13232140f, -0.07876144f, 0.04726197f, -0.03710616f, 
    -0.51647091f, -0.21946153f, 0.05350922f, -0.17721345f, 0.19259529f, 0.06836417f, 0.12556645f, -0.22111478f, 
    0.03535409f, -0.05605869f, -0.06787228f, -0.01131029f, -0.41798672f, 0.21757585f, 0.05720412f, -0.21657006f, 
    0.15732892f, -0.11932988f, 0.00358820f, 0.06937959f, 0.08669779f, 0.03170528f, 0.08900700f, -0.19141260f, 
    0.12119853f, -0.03473591f, 0.00771331f, 0.21441856f, 0.19332318f, -0.11030255f, 0.08192626f, -0.08753815f, 
    0.06547554f, 0.10727115f, -0.13668862f, -0.00659803f, 0.62872910f, 0.32259306f, 0.08810990f, -0.24109724f, 
    0.02812553f, -0.07552135f, -0.01214472f, 0.02300858f, 0.12066583f, 0.01759526f, 0.07700930f, 0.18859991f, 
    0.26234329f, -0.10346679f, -0.16323030f, 0.14441453f, -0.06220678f, 0.08028548f, 0.06050530f, -0.01726622f, 
    -0.05498421f, 0.01466045f, -0.24266605f, -0.02209592f, 0.28827855f, -0.13381730f, -0.17823721f, -0.08678170f, 
    -0.06207062f, 0.00541700f, 0.06778402f, 0.04147323f, 0.05417224f, -0.04092381f, -0.03643196f, -0.11020672f, 
    0.20380488f, -0.31970477f, -0.09810415f, -0.32111236f, 0.17222187f, -0.04181748f, 0.12756710f, -0.01055199f, 
    -0.07376263f, -0.00329814f, -0.12190005f, -0.13294089f, 0.35746950f, 0.16422284f, -0.34398186f, 0.04956536f, 
    0.01728133f, -0.17411415f, -0.01572011f, -0.00845317f, -0.01158970f, -0.11082788f, -0.00694907f, -0.05564526f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06344692f, 0.06505322f, -0.03710280f, 0.03705445f, -0.00516322f, 0.00794338f, 0.01722783f, -0.10985792f, 
    -0.00240176f, 0.00597664f, 0.09758284f, 0.02564206f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
