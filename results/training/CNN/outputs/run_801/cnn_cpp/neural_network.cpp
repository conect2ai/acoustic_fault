#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.25415775f, -0.25930208f, 0.77386028f, -0.65646213f, 0.28688461f, -0.56039810f, -0.03355720f, -0.10255735f, 
    0.14117737f, -0.22823265f, 0.31354129f, 0.38181397f, -0.74018705f, -0.46890235f, -0.17409332f, -0.21443340f, 
    0.62022120f, -0.06094342f, 0.65675092f, 0.54576355f, 0.37367523f, 0.07556547f, -0.13736261f, 0.58571166f, 
    -0.41902661f, 0.26989612f, 0.53266430f, -0.77742547f, -0.01656818f, -0.04385569f, 0.54092729f, -0.68638611f, 
    0.62709105f, -0.41500419f, 0.13698375f, 0.21993220f, 0.63405097f, 0.74072742f, 0.61581010f, 0.21676387f, 
    -0.35969028f, -0.43511716f, -0.07050384f, 0.23685601f, 0.12480216f, -0.26983115f, -0.61827892f, -0.55841160f, 
    0.38734445f, -0.41556457f, -0.41001061f, -0.36755407f, -0.21217726f, -0.14079168f, -0.52494657f, -0.44810754f, 
    -0.35733128f, 0.06617244f, 0.57499534f, -0.17287670f, 0.13526009f, 0.36544266f, 0.40372929f, -0.79478210f, 
    -0.56567729f, -0.83975548f, 0.21984854f, 0.26079729f, 0.38622671f, 0.17651308f, 0.14784992f, -0.46435833f, 
    0.63465011f, 0.87050897f, -0.63958091f, 0.22850041f, 0.52515936f, 0.15374832f, 0.38225836f, 0.24699651f, 
    0.05409533f, 0.20147762f, 0.39118749f, 0.35864776f, 0.43619469f, 0.58070409f, 0.51776183f, -0.19344293f, 
    0.06754929f, -0.16362926f, 0.71670508f, 0.61308950f, 0.16987246f, -0.12706812f, -0.58149415f, 0.41792333f, 
    -0.28442338f, 0.02557965f, -0.22179832f, -0.03509419f, 0.67877191f, -0.76358640f, 0.70386231f, -0.57279468f, 
    -0.30104563f, -0.15555415f, 0.38986301f, 0.07070702f, -0.75898546f, 0.03861987f, -0.33027703f, -0.12433956f, 
    0.23647247f, -0.46364012f, 0.13933398f, 0.45915028f, -0.53557336f, 0.46649879f, 0.59365219f, -0.31100237f, 
    -0.62614298f, -0.37570059f, -0.42906672f, 0.52931952f, -0.00554802f, 0.20196810f, -0.74848640f, -0.20179646f, 
    -0.02805498f, 0.50442308f, 1.04211640f, 0.22783613f, -0.01658524f, -0.46103853f, -0.24286310f, 0.17222467f, 
    0.66537207f, -0.69504642f, 0.58817613f, 0.33382693f, -0.24677174f, -0.16993685f, -0.26829806f, -0.23067029f, 
    -0.08955989f, -0.86364639f, -0.35941252f, 0.80488122f, 0.24995427f, 0.67186439f, -0.20718651f, -0.28031576f, 
    -0.15517616f, 0.12991165f, 0.52449292f, 0.32964858f, 0.49103186f, 0.44608659f, -0.76885688f, -0.00600185f, 
    0.50539672f, 0.35524958f, 0.41293883f, 0.37274933f, 0.75483423f, 0.56247133f, 0.01280525f, 0.37230995f, 
    -0.00438507f, 0.29076776f, -0.38673705f, -0.75995368f, 0.84819615f, -0.41219461f, -0.43063128f, 0.27248302f, 
    -0.45847267f, -0.23130611f, -0.35866836f, 0.28911436f, -0.15814506f, 0.25133550f, 0.02412156f, -0.46603847f, 
    -0.13859522f, -0.26807150f, 0.53073835f, 0.00410084f, 0.64083248f, 0.04673601f, -0.77262712f, -0.72044277f, 
    -0.36399853f, -0.51041859f, -0.04457113f, -0.30845612f, 0.31324825f, 0.41793787f, -0.81499583f, -0.08047918f, 
    -0.28766906f, -0.54945892f, -0.37619981f, -0.47685099f, 0.34703493f, -0.18773513f, -0.10827087f, -1.03386939f, 
    -0.20217781f, 0.58972716f, 0.77976620f, 0.39889422f, 0.25309590f, 0.31016004f, 0.01169617f, 0.10807595f, 
    0.66465187f, 0.34604281f, 0.33507758f, -0.80963451f, -0.74389625f, -0.57869905f, -0.19423890f, -0.26613349f, 
    -0.15481435f, 0.99357748f, -0.99110419f, 0.51937884f, 0.53630102f, -0.56788373f, 0.49394315f, 0.30356762f, 
    -0.24838953f, -0.33106229f, 0.81717640f, 0.74635869f, 0.68468982f, -0.64961380f, 0.54045832f, -0.42673689f, 
    0.33845568f, -0.06669284f, -0.23021062f, -1.00660503f, -0.30765623f, -0.37868685f, 0.29588652f, 0.35788387f, 
    0.62755144f, 0.03330724f, -0.47174364f, 0.53891182f, -0.27928197f, -0.71207047f, -0.46921000f, -1.01324093f, 
    0.62497795f, 0.10599614f, 0.49519765f, 0.12267889f, 0.02145289f, 0.02587026f, 0.83357859f, 0.24323411f, 
    -0.12047963f, -0.50008148f, -0.71767569f, -0.40713102f, -0.31291088f, 0.16786355f, 0.03921664f, -0.55622792f, 
    -0.04849628f, -0.47160536f, 0.00336627f, -0.76860774f, 0.48265424f, 0.74126673f, 0.02017599f, 0.26120865f, 
    -0.39204961f, -0.30242723f, -0.33879253f, 0.92505985f, -0.56787044f, -0.35627383f, -0.00788407f, -0.33311591f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15386020f, -0.03552888f, 0.01035714f, -0.27441847f, 0.00123626f, -0.10701859f, 0.10260520f, -0.06422519f, 
    -0.35615695f, 0.18948066f, 0.07284747f, -0.21221149f, -0.09622058f, 0.11420052f, -0.07014861f, -0.11304763f, 
    -0.23614733f, 0.00342246f, 0.24491245f, -0.30917650f, 0.09715555f, 0.25307131f, 0.40457410f, -0.13532726f, 
    -0.09213810f, -0.22826718f, 0.17132580f, 0.27112514f, -0.02161565f, -0.12103500f, -0.02251853f, 0.00702200f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00578545f, -0.02248958f, -0.05479810f, 0.01794119f, -0.00033347f, -0.01218078f, -0.01829437f, 0.01785453f, 
    -0.03553191f, -0.04346329f, -0.06135420f, 0.02445713f, -0.04996963f, -0.05481060f, -0.06244905f, -0.06012950f, 
    0.00182734f, -0.06446730f, -0.05657699f, 0.02538656f, -0.01935757f, -0.03333526f, -0.03404593f, 0.03185790f, 
    -0.05247844f, -0.04941288f, -0.06184032f, -0.05787010f, -0.04625818f, -0.05414804f, 0.01094481f, 0.05622673f, 
    -0.05631836f, -0.01046255f, 0.05144943f, 0.04614054f, -0.02028467f, -0.04545174f, 0.02599677f, 0.00389297f, 
    -0.02612890f, -0.05446281f, 0.05147090f, -0.05634413f, -0.03656425f, 0.00076719f, 0.02800222f, -0.00381704f, 
    -0.05585252f, 0.00646733f, 0.04802901f, 0.02026615f, -0.03717997f, 0.04992790f, 0.03596427f, 0.01994650f, 
    0.04556710f, 0.03387621f, 0.02158013f, -0.05203726f, -0.01535745f, 0.04593802f, -0.02529986f, 0.02838910f, 
    0.00145018f, -0.01465277f, -0.00941495f, -0.00490442f, -0.04722163f, 0.05041212f, 0.02161989f, 0.01085621f, 
    0.01731138f, 0.04241553f, -0.05729714f, -0.06173212f, 0.03921382f, -0.01400771f, 0.01463379f, -0.01904931f, 
    0.02338667f, -0.05026263f, -0.04331054f, -0.02817133f, 0.04554449f, 0.02598378f, -0.05292163f, 0.01687208f, 
    -0.02416544f, 0.00819273f, 0.01060491f, 0.04502733f, -0.05733827f, -0.02699666f, 0.03574919f, 0.01743354f, 
    0.02303590f, -0.05287113f, -0.03236463f, -0.03249772f, -0.04165494f, -0.00277925f, 0.02827318f, 0.05370163f, 
    0.05227302f, -0.03011513f, 0.04543651f, 0.00120025f, -0.05443038f, 0.03707890f, 0.03233976f, -0.00348695f, 
    -0.05607037f, -0.04164278f, -0.02661183f, 0.04673102f, -0.01283118f, -0.03219266f, 0.00105194f, 0.02608626f, 
    -0.06030216f, -0.05981446f, -0.02564621f, -0.06365164f, -0.05437969f, 0.02873173f, 0.01115697f, -0.05741654f, 
    0.00552048f, -0.03197914f, 0.00441992f, -0.03998423f, 0.04748693f, 0.01203280f, -0.00276261f, 0.05226786f, 
    -0.00987959f, 0.03748799f, -0.04533164f, 0.02405933f, -0.00157515f, -0.01707833f, 0.05268246f, 0.02345381f, 
    -0.04105428f, -0.05049988f, 0.00101744f, -0.02490837f, 0.00715675f, 0.02505607f, -0.03400165f, -0.05467978f, 
    0.02009673f, -0.04153972f, -0.03637299f, -0.00608383f, 0.01681974f, -0.03717222f, -0.00712873f, 0.02330878f, 
    -0.06366021f, -0.03983930f, 0.03019678f, -0.05633451f, -0.04777049f, -0.00158018f, 0.01812706f, -0.03860957f, 
    0.04631562f, 0.04453494f, -0.05421726f, -0.03997195f, 0.03330990f, 0.03258886f, 0.04293589f, -0.00648702f, 
    -0.04573055f, -0.04049492f, 0.02877061f, 0.00664599f, 0.03349176f, 0.03125546f, -0.03018454f, -0.06416240f, 
    -0.04389973f, -0.00038975f, -0.02691453f, 0.04755615f, 0.01250679f, -0.00759246f, -0.00439779f, -0.04222571f, 
    0.02478537f, -0.03150165f, 0.02118451f, 0.02383041f, -0.05454293f, -0.01718849f, 0.01749181f, -0.06345376f, 
    -0.06069214f, -0.04076776f, 0.01026000f, -0.04156616f, 0.04594662f, -0.00389051f, 0.01702000f, 0.00719960f, 
    0.04531012f, 0.03573731f, 0.02555320f, 0.01192247f, -0.00406162f, -0.03621434f, -0.05808163f, -0.04593454f, 
    0.03249514f, 0.04690073f, -0.03401498f, -0.00719170f, -0.03778487f, -0.05073432f, 0.01152826f, 0.01011331f, 
    0.04547988f, -0.01714947f, -0.01062477f, -0.03901529f, -0.00487686f, 0.00861493f, -0.04694210f, 0.03614825f, 
    -0.01986142f, 0.04653885f, 0.03125134f, 0.05125128f, 0.03270792f, -0.05226531f, -0.00554812f, 0.00519040f, 
    0.05226520f, -0.06393430f, -0.02768732f, -0.05747349f, -0.03342379f, -0.01864319f, -0.03097250f, -0.05224493f, 
    0.04965137f, 0.03735024f, -0.03889371f, 0.01648601f, -0.06265459f, -0.05602802f, -0.06180968f, 0.02769981f, 
    0.01390693f, 0.02048030f, -0.02696242f, -0.02432465f, -0.02191064f, -0.04325116f, -0.02595882f, 0.04118834f, 
    -0.00733819f, 0.01579274f, 0.04877491f, -0.02862061f, -0.04275915f, -0.02578310f, 0.03254547f, 0.00975052f, 
    -0.00752304f, 0.03841849f, -0.02619041f, 0.00361290f, -0.06393458f, 0.02885447f, -0.03170965f, 0.03711559f, 
    -0.01695833f, -0.05166135f, -0.03113000f, -0.04068125f, 0.02957525f, -0.03457579f, -0.00198721f, 0.00149344f, 
    0.01666142f, -0.01290596f, -0.04822049f, -0.01931943f, 0.04612122f, -0.04310310f, -0.04092100f, -0.04178884f, 
    -0.00860275f, 0.02828015f, 0.05287726f, 0.03523302f, 0.00783686f, 0.03461871f, -0.02527691f, -0.00681780f, 
    0.01008023f, -0.00854319f, -0.05436854f, 0.03011150f, -0.00874238f, -0.00568652f, 0.03964315f, -0.02840356f, 
    0.02325936f, 0.03292271f, -0.05812858f, 0.02784024f, 0.00112208f, -0.02222426f, 0.04369301f, -0.00534226f, 
    -0.03505062f, -0.02132492f, -0.01070618f, -0.00297097f, -0.02931520f, -0.00164187f, 0.01412023f, 0.00189334f, 
    0.02010898f, -0.04290541f, -0.04680500f, -0.06457733f, -0.02433403f, -0.03739899f, -0.04318700f, -0.02936795f, 
    -0.04204976f, 0.03037370f, 0.01260120f, 0.00984401f, -0.03713143f, -0.00471099f, -0.05571445f, 0.02473995f, 
    0.00426893f, -0.02848768f, -0.00013667f, 0.03116260f, -0.02263439f, 0.03163368f, 0.02439129f, 0.04807396f, 
    -0.03929515f, -0.01030025f, 0.02667494f, -0.00496353f, -0.04084517f, 0.04029110f, -0.05064863f, 0.02323966f, 
    -0.00577439f, -0.05722047f, -0.01373145f, 0.01959066f, 0.02999802f, 0.02548881f, -0.03620126f, 0.03673217f, 
    -0.05527558f, -0.00555933f, -0.04397349f, -0.02611049f, -0.00553840f, -0.00713392f, -0.01451722f, -0.00142306f, 
    0.04492546f, -0.04606720f, -0.05854431f, 0.00202409f, 0.05025275f, 0.04491961f, -0.03063771f, 0.04343710f, 
    0.02341682f, 0.02739443f, 0.01543037f, 0.02141665f, 0.02510670f, 0.01157005f, 0.03302289f, 0.04376920f, 
    -0.05054421f, -0.02231528f, -0.02639842f, -0.06764135f, 0.05594971f, 0.02284485f, -0.04771011f, 0.00910388f, 
    0.03007772f, -0.02063011f, -0.00864572f, 0.03446124f, 0.04892001f, -0.06419198f, 0.05436440f, 0.05460789f, 
    -0.03359170f, -0.00156992f, -0.03550119f, -0.01135070f, -0.00017733f, 0.00195883f, -0.04699487f, 0.05417043f, 
    -0.01956481f, 0.01318203f, -0.00035252f, -0.04225720f, 0.03648537f, -0.04948730f, -0.04188580f, -0.02873155f, 
    -0.03581760f, -0.02774047f, -0.00483944f, 0.00216464f, 0.03117384f, 0.01987753f, 0.01646768f, 0.03875245f, 
    -0.02889467f, -0.04368316f, 0.05015991f, 0.05148824f, 0.00765031f, -0.02106573f, -0.03312797f, -0.04616023f, 
    -0.02653366f, 0.05265948f, 0.03274664f, -0.04928683f, -0.02071499f, 0.04365256f, -0.02899040f, -0.01604673f, 
    0.05322313f, -0.02075145f, -0.02761109f, -0.00679739f, 0.00289455f, 0.01008335f, -0.05495318f, -0.06568700f, 
    0.01387427f, 0.00265948f, 0.01905076f, -0.04441154f, -0.01405398f, -0.05180722f, -0.04066788f, -0.01287652f, 
    -0.03137884f, 0.04988338f, -0.01474153f, -0.05169977f, 0.03646721f, -0.01700999f, 0.04203487f, 0.01960867f, 
    -0.03258014f, -0.05268040f, 0.01800712f, 0.05198472f, -0.02237553f, 0.00388515f, 0.02757029f, 0.01151715f, 
    0.01031420f, -0.05659646f, -0.06042765f, 0.04823948f, 0.00708482f, -0.04137913f, -0.01639443f, 0.00063930f, 
    -0.04875050f, 0.04066616f, -0.01725073f, 0.04648705f, 0.04408456f, 0.02043568f, -0.04038877f, 0.05188799f, 
    0.04449104f, -0.06183055f, -0.00285466f, -0.03603520f, 0.04498376f, 0.03624379f, 0.02004252f, -0.04394510f, 
    -0.04801226f, 0.02844846f, -0.03966228f, -0.02062644f, 0.05000805f, -0.01211064f, -0.00440509f, 0.04301476f, 
    -0.03911797f, 0.03543552f, -0.06021551f, 0.02690414f, 0.00621487f, -0.04953598f, 0.00617220f, -0.02257133f, 
    -0.00576012f, -0.04222893f, 0.03133972f, 0.02866582f, -0.00593738f, 0.01305643f, 0.00459422f, -0.02702250f, 
    0.02986980f, -0.03653492f, -0.05222423f, 0.00436448f, -0.05899994f, 0.02959469f, -0.06098194f, -0.03597534f, 
    -0.02344614f, 0.03271522f, -0.03349418f, -0.00365597f, -0.05791437f, 0.01846758f, -0.00041446f, 0.02592297f, 
    -0.00897221f, -0.03433301f, -0.04325397f, -0.00964822f, -0.00514148f, -0.03952701f, -0.03978610f, 0.01850114f, 
    -0.06122873f, 0.02551120f, -0.01128173f, -0.05558990f, -0.03884584f, -0.02363256f, -0.05102836f, 0.01552975f, 
    -0.05312946f, -0.05995654f, 0.03412945f, 0.00706563f, 0.00411786f, -0.03718507f, 0.04003337f, 0.04903056f, 
    0.03180095f, -0.05260482f, -0.04005130f, -0.04450272f, -0.03496171f, -0.03165012f, -0.04406670f, -0.03288640f, 
    -0.06788184f, 0.12998450f, -0.01582558f, 0.03217252f, 0.12977809f, 0.14446349f, -0.15456516f, -0.02316722f, 
    0.05094232f, -0.18108718f, -0.06890652f, 0.11860105f, -0.22450434f, -0.00790786f, -0.02784158f, 0.07479308f, 
    -0.08774967f, -0.04950728f, 0.16538759f, 0.11288057f, -0.01240330f, -0.06588376f, -0.15821455f, -0.06918932f, 
    0.13847354f, -0.03736807f, -0.08766373f, -0.02781514f, -0.11841430f, -0.01337417f, -0.06335107f, 0.15031184f, 
    0.23690486f, -0.13062443f, 0.12649523f, 0.08155262f, 0.34985137f, -0.16152616f, -0.03413088f, -0.03335425f, 
    0.00002672f, 0.00908070f, -0.11847507f, -0.00198562f, 0.10005856f, 0.10972033f, 0.12863496f, 0.00300490f, 
    0.01219922f, -0.05203418f, -0.03702865f, 0.19558679f, 0.05294319f, 0.13161965f, 0.02765455f, 0.18609482f, 
    0.09107415f, 0.07689212f, 0.03986334f, 0.09845435f, -0.04199267f, -0.04214636f, -0.10632927f, 0.06225479f, 
    0.23472886f, -0.08236013f, 0.07915905f, 0.08221641f, -0.03796570f, 0.14486022f, 0.18379560f, 0.14657253f, 
    0.04187215f, 0.00539737f, 0.01352325f, -0.05929982f, -0.12883484f, 0.01323789f, -0.07383832f, 0.08006558f, 
    0.24562773f, -0.52380705f, 0.01320420f, -0.11248539f, 0.03775370f, -0.05038591f, 0.01797782f, 0.02870410f, 
    0.03894005f, 0.07790052f, 0.09786277f, -0.28395322f, -0.00196943f, -0.02929860f, -0.01199727f, 0.06815656f, 
    0.06480719f, 0.01252758f, -0.01644908f, 0.43110427f, 0.11040185f, 0.05170397f, -0.08439740f, -0.00266510f, 
    -0.01190168f, -0.04317414f, 0.00199667f, 0.01639921f, 0.06502042f, 0.38380623f, 0.08307237f, -0.01559185f, 
    0.00434759f, 0.01935340f, 0.13673122f, -0.13526025f, -0.18122652f, 0.12342406f, -0.01913906f, -0.07742387f, 
    -0.17790748f, -0.17368859f, -0.01766300f, 0.01322504f, 0.03442429f, -0.22764866f, -0.05336700f, 0.22771917f, 
    0.14210284f, 0.04967416f, -0.00760547f, -0.01904592f, -0.09638187f, -0.03676951f, 0.08386248f, 0.21866906f, 
    0.04487629f, -0.17511705f, 0.02821228f, -0.00362066f, -0.10537945f, -0.15126656f, 0.08739825f, 0.10693083f, 
    0.27726561f, 0.10230424f, -0.03598894f, 0.04709815f, 0.17029026f, -0.15998672f, 0.00784606f, 0.03379201f, 
    0.16159980f, 0.35890836f, -0.07910398f, 0.18075535f, -0.09055084f, 0.00923723f, -0.01089125f, 0.08819830f, 
    -0.11157900f, -0.15486945f, -0.32627699f, -0.01939022f, -0.12166232f, -0.11297285f, -0.01285457f, 0.04788654f, 
    0.08752289f, 0.12672077f, 0.01018640f, 0.06887107f, 0.16748708f, 0.02851176f, 0.06354335f, -0.13863695f, 
    0.06322774f, -0.01855692f, -0.21606688f, -0.03318291f, -0.25629097f, -0.03752639f, 0.02745694f, 0.08944005f, 
    0.03477013f, 0.06441325f, 0.00734206f, -0.01413596f, -0.12459023f, 0.14283887f, 0.17153601f, -0.10882276f, 
    0.00317822f, -0.08093575f, -0.04329293f, 0.05120890f, 0.01882835f, 0.02762980f, -0.20310038f, 0.13501501f, 
    -0.02864388f, -0.03777279f, 0.03873497f, -0.11267978f, -0.12814558f, -0.05637415f, -0.01437679f, -0.29133159f, 
    -0.02732199f, 0.04741810f, 0.09779264f, 0.06151185f, -0.03233137f, -0.06387985f, 0.09611107f, 0.29541853f, 
    0.14444153f, -0.20105483f, 0.00009411f, -0.06155153f, 0.06802861f, 0.01590682f, 0.02716558f, -0.02729677f, 
    0.21677423f, -0.03356386f, -0.43161517f, -0.07007062f, 0.01503348f, 0.10101857f, 0.07669958f, -0.02675297f, 
    0.16990885f, 0.08918756f, -0.00321645f, -0.27370977f, -0.12019192f, -0.05420390f, -0.07569174f, 0.15016112f, 
    -0.02402470f, -0.00272443f, 0.08773436f, 0.12112488f, 0.08285230f, -0.09292651f, -0.04867525f, 0.00609482f, 
    -0.04481484f, 0.06153889f, 0.00549126f, 0.02509962f, -0.19369392f, 0.21735498f, -0.19056599f, 0.04753817f, 
    -0.01107178f, 0.05830327f, 0.00888499f, 0.03554890f, -0.10450361f, 0.08739407f, -0.15977611f, -0.04291409f, 
    -0.07338949f, 0.06556141f, 0.07244077f, 0.01352877f, -0.10007036f, 0.07940377f, -0.04524400f, 0.07746268f, 
    0.00717667f, 0.08311391f, -0.03451901f, -0.09822928f, 0.14940742f, 0.00079627f, -0.11156947f, 0.23103824f, 
    0.15484475f, -0.01641184f, 0.00598796f, -0.00036308f, 0.00390818f, -0.20607790f, -0.06277485f, -0.08421879f, 
    -0.03165583f, 0.00259912f, -0.05076806f, -0.02261647f, -0.02646257f, 0.04114790f, -0.01549961f, -0.01199984f, 
    0.02129490f, -0.00779221f, 0.02512104f, -0.02264065f, -0.03537192f, 0.02427110f, 0.00875579f, -0.00183734f, 
    0.02008778f, -0.07743964f, 0.04328100f, 0.01723055f, -0.03264474f, -0.05433257f, -0.03298096f, -0.07023828f, 
    -0.05530270f, -0.05407643f, 0.01768282f, 0.01526122f, -0.03165271f, 0.03906085f, -0.02071266f, -0.07902913f, 
    0.01907189f, -0.01325174f, -0.01801019f, 0.01763586f, 0.03499291f, -0.06839175f, -0.02513123f, -0.06005602f, 
    -0.02958325f, 0.03610569f, 0.02197684f, -0.04919898f, -0.03673445f, -0.06525369f, -0.05549408f, -0.05231345f, 
    -0.06733678f, -0.06749226f, -0.05117128f, -0.05453563f, -0.06487907f, -0.06639244f, -0.01268210f, 0.02857652f, 
    -0.06186858f, 0.02265656f, -0.04878576f, 0.00161226f, -0.00827467f, -0.00968345f, 0.03613723f, -0.01769173f, 
    0.04069911f, 0.00810937f, -0.05266152f, -0.03624631f, -0.05592726f, -0.01501423f, 0.00827073f, -0.04713957f, 
    0.04734922f, -0.04297071f, -0.00349441f, 0.02428167f, -0.02006726f, 0.00714187f, 0.03040774f, 0.01536936f, 
    0.02004045f, -0.05095682f, -0.01090360f, 0.02931646f, -0.04225611f, -0.04214783f, -0.01171026f, -0.00194512f, 
    -0.06365722f, 0.02605537f, 0.04138965f, 0.02627745f, -0.00660320f, -0.00187387f, 0.03214391f, -0.00452750f, 
    -0.01420960f, 0.03747648f, 0.01702838f, 0.00560378f, -0.00273827f, 0.03373598f, -0.03929583f, 0.00198462f, 
    0.02205550f, -0.04581479f, 0.03671218f, -0.03044344f, -0.03595480f, 0.00569167f, -0.02968884f, 0.02871256f, 
    -0.00750849f, -0.00272959f, 0.02877693f, -0.04479686f, 0.01713655f, -0.03243839f, -0.02207798f, -0.00542857f, 
    -0.04526055f, -0.06421029f, -0.05361580f, -0.04173766f, -0.06397921f, -0.07376597f, -0.06513041f, 0.00724872f, 
    0.03365281f, 0.01928041f, -0.00964465f, -0.01386948f, -0.03806416f, -0.02628962f, -0.03617613f, -0.07199167f, 
    -0.05583497f, 0.05204434f, -0.00920348f, 0.05133057f, -0.00308230f, -0.03569610f, -0.05743472f, -0.02705376f, 
    -0.00877667f, -0.02323350f, -0.01216727f, -0.06581913f, -0.04265735f, 0.05275795f, 0.04789092f, -0.02839344f, 
    -0.01199638f, 0.02996142f, 0.01827324f, -0.03883198f, -0.05570639f, -0.00412058f, -0.02034926f, 0.02590935f, 
    -0.03544978f, -0.07114201f, -0.00353908f, -0.04077483f, 0.00305580f, -0.03279029f, -0.01305487f, -0.06640039f, 
    -0.03976585f, -0.01053511f, -0.00926060f, -0.05233023f, -0.05081345f, -0.07831526f, 0.02585007f, 0.03614167f, 
    -0.06501593f, -0.05484327f, -0.05089555f, 0.00951855f, -0.04644369f, -0.05821675f, -0.02029601f, -0.04180921f, 
    0.00929499f, -0.03231589f, -0.01668053f, -0.00773775f, -0.03904550f, -0.05938090f, -0.04878329f, -0.00730724f, 
    -0.06477533f, -0.00032546f, -0.01256049f, -0.02863503f, -0.02150869f, -0.02792925f, -0.00640457f, 0.03276610f, 
    -0.02802959f, -0.04289772f, -0.00353271f, -0.02207455f, -0.03714495f, -0.02305599f, 0.00795946f, 0.04435522f, 
    0.05066926f, 0.04919348f, -0.04090243f, -0.01505935f, -0.03751824f, 0.01385366f, -0.04327581f, -0.02079255f, 
    -0.00753640f, -0.01103504f, 0.01805017f, -0.01621288f, -0.00279813f, -0.04204649f, -0.06729519f, -0.07371969f, 
    -0.05173739f, -0.02328200f, -0.02937267f, 0.03181443f, -0.05508457f, -0.06485675f, -0.01137170f, -0.05536788f, 
    -0.00467852f, 0.01750598f, -0.04098624f, -0.06302334f, -0.05129680f, 0.01563589f, -0.00958579f, -0.04697603f, 
    0.01964933f, 0.03749593f, -0.03144547f, 0.00768181f, -0.00950819f, -0.06243764f, 0.02512459f, -0.02133675f, 
    -0.05338806f, 0.02148963f, 0.03294709f, -0.00328819f, -0.03353766f, -0.03216891f, -0.06076175f, 0.03067530f, 
    -0.01125447f, -0.03721329f, -0.05279526f, -0.07655400f, -0.06764763f, 0.03680325f, -0.04348078f, -0.04399803f, 
    -0.04767157f, 0.03340890f, -0.06446680f, -0.00900571f, -0.07723194f, -0.02466105f, 0.01827176f, 0.00153899f, 
    0.03327115f, -0.03709064f, -0.02689038f, 0.03571877f, -0.06014150f, 0.01497934f, -0.05935934f, -0.06258551f, 
    -0.00561344f, 0.03608397f, 0.00865753f, -0.02180035f, -0.03860900f, -0.07175855f, -0.06088953f, -0.06062924f, 
    0.03804754f, -0.01249296f, -0.05955090f, -0.00219269f, -0.03128046f, 0.02714803f, -0.02685081f, 0.02312884f, 
    0.02943669f, 0.02043844f, -0.00055414f, 0.03718550f, 0.00282763f, 0.00297143f, -0.04407780f, -0.01744124f, 
    -0.03027127f, -0.05902633f, 0.03302146f, -0.01345785f, 0.02809504f, -0.04847975f, -0.05387842f, -0.04488632f, 
    -0.01537331f, -0.00439676f, 0.04181015f, -0.04721397f, 0.03649946f, 0.00229505f, 0.03440748f, 0.04329980f, 
    0.02536976f, 0.02563148f, -0.02310264f, -0.05608048f, 0.01776689f, -0.05035302f, 0.02387690f, -0.02634421f, 
    -0.00510267f, 0.03173118f, 0.03658796f, -0.01234693f, -0.02353801f, 0.03548510f, 0.02667054f, 0.03231461f, 
    0.02447473f, -0.00790233f, 0.04941071f, -0.05652321f, -0.03750565f, -0.00118831f, 0.00502941f, -0.03377016f, 
    0.04517972f, -0.04935879f, 0.04920549f, -0.05443998f, -0.02044077f, 0.00825489f, 0.00892270f, 0.00274432f, 
    -0.03100521f, -0.00509546f, -0.04383469f, -0.01312069f, 0.00813903f, -0.03720588f, 0.01515755f, -0.03179357f, 
    -0.06772424f, -0.02374308f, 0.04490907f, 0.01316842f, 0.04886972f, 0.02703594f, 0.01665970f, -0.02464747f, 
    0.02082198f, -0.04871003f, 0.01456379f, -0.04849788f, -0.03953902f, -0.04858536f, -0.02816421f, 0.04610221f, 
    0.01322321f, 0.02008330f, -0.04878293f, 0.03876085f, 0.04881395f, -0.03386110f, -0.00031742f, 0.03793695f, 
    -0.04406387f, 0.03477770f, 0.03469062f, -0.05466919f, -0.05392008f, 0.00518086f, 0.02899385f, -0.01011128f, 
    -0.03667680f, 0.04071759f, 0.02109871f, 0.00246155f, -0.01086186f, 0.04767266f, 0.02545028f, -0.00352405f, 
    0.00742075f, 0.02377713f, 0.01355337f, -0.02779294f, 0.05001279f, 0.02742710f, 0.03596758f, -0.05477606f, 
    0.02342897f, 0.01191866f, 0.04215546f, 0.02809244f, -0.01680926f, -0.03861361f, -0.05245858f, 0.05094801f, 
    0.02656094f, -0.06548906f, 0.01874033f, -0.04625801f, 0.00905938f, -0.03152720f, -0.01561737f, 0.04572593f, 
    0.00550980f, 0.03969679f, -0.00174455f, -0.00440972f, 0.01877599f, -0.02358478f, 0.00093225f, 0.03945940f, 
    0.01268978f, -0.05877329f, -0.03086560f, 0.04408924f, -0.06389128f, -0.03927100f, -0.05749017f, -0.05038267f, 
    -0.02756286f, -0.04281783f, 0.02577841f, -0.00302344f, -0.05095942f, -0.04360818f, 0.04155436f, 0.04033945f, 
    0.04242124f, -0.01683806f, 0.02946006f, 0.04068339f, -0.04298774f, 0.03256093f, 0.01084035f, -0.01696430f, 
    -0.05072438f, -0.00923702f, 0.04971715f, -0.06033277f, 0.01480419f, -0.01779022f, -0.02792959f, -0.00902703f, 
    0.04066002f, -0.02073728f, 0.03005739f, 0.02798134f, 0.02865764f, -0.06040785f, -0.02996445f, -0.00772326f, 
    0.02343725f, -0.00315106f, -0.06044734f, 0.03249636f, -0.04369649f, -0.05445842f, 0.03810356f, -0.05028718f, 
    -0.03758754f, -0.06418090f, -0.05519122f, 0.02618656f, -0.02880373f, -0.06135173f, -0.01864737f, 0.03059149f, 
    -0.04598073f, -0.00952032f, -0.00791852f, 0.04723945f, 0.00109142f, 0.04838150f, 0.02691542f, 0.04746716f, 
    0.04372960f, 0.01237868f, -0.05415791f, -0.01112788f, 0.02968411f, 0.01267552f, 0.03919830f, -0.06229439f, 
    -0.03855842f, 0.03038696f, -0.05234821f, -0.05979611f, -0.02553217f, -0.01960245f, 0.00860594f, -0.03254884f, 
    -0.03174067f, -0.04921824f, -0.05923666f, 0.00981595f, 0.00995916f, -0.00493921f, -0.01122910f, 0.02334279f, 
    0.00223423f, -0.01101956f, -0.03526436f, 0.05212285f, -0.01454683f, -0.04996869f, -0.01797725f, 0.01113418f, 
    -0.01949591f, -0.05923323f, 0.03170330f, -0.05202055f, -0.03921267f, 0.03185088f, -0.04543190f, -0.03271503f, 
    -0.00433877f, 0.02427186f, 0.01968424f, -0.05817992f, -0.02762228f, 0.02188565f, -0.03260358f, -0.01653733f, 
    -0.00170082f, 0.03905934f, 0.05036238f, -0.01818777f, 0.01870474f, -0.03017947f, -0.05108004f, -0.05282470f, 
    0.00383253f, 0.02941099f, 0.00408287f, -0.06503192f, -0.04935667f, 0.03330186f, -0.06300592f, 0.02924124f, 
    -0.06083166f, -0.02731980f, -0.00688908f, -0.00155900f, -0.00584853f, 0.04221418f, -0.03441313f, -0.00914493f, 
    0.00502625f, 0.01771994f, -0.03303294f, -0.01455016f, 0.02316885f, -0.03137494f, -0.06410461f, -0.00034922f, 
    -0.00525841f, 0.04428267f, -0.06919380f, 0.04874618f, -0.04321510f, 0.03994031f, -0.14234965f, -0.13461593f, 
    0.17323089f, 0.10168187f, -0.07444625f, -0.10028738f, -0.03837271f, -0.12984946f, -0.08616649f, 0.00443430f, 
    -0.07112725f, -0.00214937f, 0.06340922f, -0.01948463f, -0.13355318f, 0.10322724f, -0.10383760f, -0.04600126f, 
    -0.21022743f, 0.12100203f, 0.09580907f, 0.22594947f, -0.18779197f, 0.17923956f, -0.03779385f, -0.19202672f, 
    0.09522525f, 0.08687775f, 0.13010490f, 0.01672846f, 0.09112972f, 0.09617037f, -0.08383516f, -0.06512336f, 
    -0.10151373f, 0.12894748f, -0.15614852f, 0.15361670f, 0.05273345f, 0.29000959f, 0.12960805f, 0.03068651f, 
    0.12727493f, -0.03964084f, 0.11219208f, -0.01995774f, 0.04390924f, -0.13493176f, -0.07542589f, 0.15581611f, 
    0.18815872f, 0.12259639f, -0.06490282f, 0.01818011f, 0.00672533f, 0.04443160f, -0.01962133f, 0.00841763f, 
    -0.01988843f, 0.27680999f, 0.19323479f, 0.00337641f, 0.10112198f, 0.05274130f, 0.23043093f, 0.20804496f, 
    -0.17237622f, 0.19235754f, 0.02525546f, -0.14143349f, -0.14897695f, -0.17622522f, 0.20762582f, 0.02436231f, 
    0.06695152f, -0.07523389f, -0.16265084f, -0.05679599f, -0.00364704f, 0.01913221f, -0.17748939f, 0.09180485f, 
    -0.13179496f, 0.15165874f, 0.04405630f, -0.29664758f, 0.08250890f, 0.04863513f, -0.12922442f, -0.03152527f, 
    -0.18655847f, -0.08030527f, -0.05540146f, 0.32573557f, 0.22570886f, -0.03263383f, -0.24384306f, 0.03744678f, 
    -0.12547335f, -0.05446366f, 0.14284378f, -0.23397541f, 0.35137406f, 0.06386678f, 0.19093530f, 0.12994146f, 
    -0.00055036f, 0.04186226f, -0.03034237f, -0.08830680f, -0.06756047f, -0.25226656f, -0.04600253f, -0.13945603f, 
    -0.10096537f, -0.12255985f, -0.07545324f, -0.18033320f, 0.05514675f, -0.17729849f, 0.16057585f, 0.27845156f, 
    0.08122762f, 0.21896440f, 0.03776387f, -0.06597587f, 0.02179120f, 0.07001393f, 0.10203909f, 0.25670862f, 
    -0.03876900f, -0.05187234f, -0.07330579f, 0.03066870f, -0.07539628f, 0.04549576f, -0.02323015f, -0.09945178f, 
    0.24283688f, 0.03747068f, -0.13653129f, 0.09768071f, 0.09868988f, 0.04039375f, 0.12268977f, -0.01543459f, 
    0.03178600f, -0.03332140f, 0.08345510f, -0.06264592f, 0.01014579f, -0.05342640f, 0.14962244f, -0.07464655f, 
    -0.02405113f, -0.13426869f, 0.06548240f, -0.08613853f, -0.00140547f, -0.08345055f, -0.05499734f, -0.07585556f, 
    -0.01836543f, -0.09666844f, -0.05194507f, 0.05197237f, 0.06615223f, 0.01530355f, 0.04425093f, 0.00410882f, 
    0.01373769f, -0.05823504f, -0.04056125f, -0.13364129f, -0.04041481f, -0.12550236f, -0.04004015f, 0.02227985f, 
    -0.05446692f, 0.11239126f, -0.06590430f, -0.12517641f, -0.02002257f, 0.17910522f, 0.28562543f, 0.09183604f, 
    -0.06815594f, -0.06277611f, -0.08894886f, 0.04576175f, 0.03549918f, 0.04236746f, 0.25101906f, -0.11072627f, 
    0.09928679f, -0.02579927f, -0.03549353f, 0.06119637f, -0.12854530f, 0.03219514f, -0.24409807f, 0.20896809f, 
    0.01722536f, 0.03460643f, -0.02382275f, -0.00351153f, -0.01309231f, 0.02837344f, 0.14469162f, 0.02911568f, 
    0.15362157f, -0.25167051f, 0.23497365f, -0.01230471f, -0.03837537f, 0.01645369f, -0.09605633f, 0.04332604f, 
    -0.09289544f, 0.05175918f, -0.14821756f, -0.20994067f, -0.11826715f, -0.08376023f, -0.18248725f, -0.07486476f, 
    -0.22514971f, -0.02266361f, -0.56256270f, -0.08932228f, -0.03386204f, -0.01813098f, -0.04024684f, -0.00974844f, 
    -0.07860184f, 0.01333752f, 0.06674044f, -0.00396736f, -0.08110826f, 0.13454968f, 0.07658653f, -0.00292670f, 
    -0.01673824f, 0.09920367f, -0.07728470f, -0.01520327f, -0.03641581f, 0.04940639f, 0.13230324f, 0.25277930f, 
    -0.14613695f, -0.10231686f, 0.01029342f, -0.11525439f, -0.14179984f, 0.00055726f, -0.08379861f, 0.03280251f, 
    0.03178254f, -0.15220119f, -0.08619485f, -0.20564093f, 0.04670386f, -0.04340899f, 0.25460526f, 0.05098723f, 
    0.26209444f, -0.09559713f, 0.05596200f, -0.02254941f, -0.08782575f, -0.03560232f, -0.01730699f, -0.01176281f, 
    0.21514882f, 0.10972756f, 0.09600465f, 0.07428945f, -0.01711592f, -0.06950039f, -0.08740810f, -0.17098272f, 
    -0.01904066f, -0.03337051f, -0.14287336f, 0.15177108f, -0.03914448f, -0.02213209f, 0.07055213f, 0.05857679f, 
    0.03345790f, -0.10097329f, -0.01430819f, -0.16011758f, -0.03519562f, 0.08426212f, -0.00386073f, 0.03955371f, 
    -0.05455479f, -0.00747238f, 0.02370564f, 0.21894918f, -0.16122159f, -0.03585635f, -0.19191700f, -0.02974942f, 
    -0.08646103f, -0.07739380f, 0.15257902f, -0.19331485f, 0.19294772f, -0.22992755f, 0.14246041f, 0.02513680f, 
    -0.03543389f, -0.07180051f, 0.13172857f, 0.08292771f, -0.01148579f, -0.05388734f, 0.07564549f, -0.05069482f, 
    0.00093619f, 0.04618893f, 0.04567677f, -0.06086017f, 0.07321391f, 0.09408161f, -0.10805656f, -0.16245869f, 
    -0.02118068f, 0.12948956f, -0.00245867f, 0.13888468f, 0.06548847f, -0.09895954f, 0.11332054f, -0.05822254f, 
    -0.02794525f, -0.00721036f, 0.08066498f, -0.05499117f, 0.10203777f, -0.03005986f, 0.08693765f, 0.25367984f, 
    0.03206726f, -0.13959023f, 0.07064886f, -0.10840514f, -0.07484305f, 0.20432706f, 0.09804855f, 0.13226372f, 
    -0.01132471f, -0.06385355f, -0.00641404f, -0.21948722f, 0.08436031f, -0.12741400f, -0.14727792f, 0.01596853f, 
    0.03765957f, 0.12412030f, 0.18353790f, 0.10691883f, -0.05348928f, -0.04764316f, -0.15710223f, 0.15398708f, 
    0.01913254f, 0.01402488f, 0.04980378f, 0.04549674f, -0.07998155f, -0.00013971f, -0.27417618f, 0.16678700f, 
    -0.06860545f, -0.04499022f, -0.08445829f, -0.08976690f, -0.21661046f, -0.27178743f, 0.07095756f, -0.02726187f, 
    0.00272753f, 0.00164698f, -0.08699677f, 0.07428285f, -0.19915743f, -0.24867006f, -0.12611087f, 0.02096725f, 
    -0.07705679f, 0.12823784f, 0.10968351f, 0.01152161f, 0.01212769f, 0.18171495f, -0.13890584f, -0.12463074f, 
    0.02375402f, -0.04618645f, 0.08040657f, -0.17701928f, -0.01925762f, 0.05902771f, 0.05357170f, 0.03428694f, 
    -0.13039622f, -0.09464192f, 0.01639020f, -0.08194798f, 0.05668484f, 0.05988902f, -0.10542247f, -0.02485895f, 
    -0.47080436f, -0.04092956f, -0.09456240f, -0.02374384f, -0.18870296f, -0.02928901f, 0.12644988f, -0.17035061f, 
    -0.00731696f, -0.11945495f, -0.09486065f, -0.01778203f, -0.04724382f, -0.19572002f, 0.13018291f, -0.06254475f, 
    -0.07103750f, -0.09427264f, 0.00592744f, 0.06779695f, -0.03817453f, 0.08622885f, -0.10299915f, -0.09056876f, 
    -0.12063979f, 0.21042356f, 0.16170679f, 0.07355455f, 0.12911683f, 0.01805267f, -0.09440526f, -0.14464943f, 
    0.11905657f, -0.04120176f, -0.01778223f, 0.03146473f, 0.07624409f, 0.04948947f, 0.25059262f, 0.16777700f, 
    0.10121547f, -0.18036002f, 0.02840902f, -0.02541462f, 0.14019151f, -0.06379270f, -0.16487177f, 0.02148901f, 
    0.04055780f, 0.06689124f, -0.00480960f, -0.05131103f, 0.06220407f, -0.27311519f, -0.18556240f, 0.10222264f, 
    0.03610527f, 0.11910091f, 0.02167661f, 0.05377991f, -0.10846335f, 0.15719533f, 0.06711338f, -0.00661519f, 
    -0.12911598f, 0.05939288f, 0.03271443f, 0.19390738f, -0.09182890f, 0.02768647f, -0.14997949f, -0.32823569f, 
    -0.03442706f, 0.02209043f, -0.04605680f, 0.10418034f, -0.03941184f, -0.08622390f, 0.04345716f, 0.07366924f, 
    -0.00034787f, -0.03923539f, -0.08428228f, -0.01279545f, -0.08624031f, 0.03081673f, -0.02330400f, -0.08064058f, 
    -0.10868432f, -0.28552940f, 0.20167869f, 0.23302208f, 0.12961625f, 0.05681182f, -0.03222970f, 0.00940227f, 
    -0.01002616f, -0.09830491f, 0.20089495f, 0.17170823f, -0.00370005f, -0.01856488f, 0.04113854f, 0.04226098f, 
    -0.04826386f, 0.08035716f, -0.12192099f, 0.17808098f, 0.32826054f, -0.22850595f, 0.09536746f, -0.06787872f, 
    -0.09634407f, -0.05406148f, -0.04842451f, -0.07451630f, 0.32807836f, -0.09631815f, 0.18506239f, 0.03683363f, 
    0.14993176f, 0.03056344f, 0.06705565f, 0.07417649f, -0.13789810f, 0.01949392f, -0.09790879f, 0.10771718f, 
    0.02339412f, 0.02774911f, 0.12184563f, -0.21155709f, -0.01385300f, -0.00118482f, -0.01796844f, -0.14952961f, 
    0.18664549f, -0.09416446f, -0.04468663f, 0.07058624f, 0.02222150f, 0.07720464f, -0.05222001f, 0.03536986f, 
    -0.31462172f, 0.01497257f, 0.15309936f, 0.30876896f, 0.14503925f, 0.02785331f, 0.01413432f, -0.23225537f, 
    0.17180602f, 0.00495544f, -0.07231261f, 0.11094297f, -0.06616074f, -0.02230343f, 0.00317905f, -0.06053967f, 
    -0.11417125f, -0.03208934f, 0.19286874f, -0.12457631f, -0.05251683f, -0.03062438f, -0.03529843f, 0.00399742f, 
    0.11331189f, -0.01506981f, -0.20305723f, 0.07000848f, -0.08698922f, -0.00603656f, 0.03153574f, 0.28650221f, 
    -0.11831546f, 0.07033848f, 0.06330703f, -0.06829792f, 0.01206777f, -0.13495079f, 0.00410061f, -0.09078591f, 
    0.00540917f, -0.08559780f, 0.09146722f, -0.12681875f, -0.00300335f, 0.07223789f, 0.14492610f, 0.01630003f, 
    0.08975635f, 0.06304085f, -0.00538269f, 0.08844948f, -0.15005791f, -0.32640460f, -0.10095218f, 0.28600183f, 
    0.03653171f, 0.04245489f, -0.02654573f, 0.01880294f, -0.01123750f, 0.03415331f, 0.07158861f, -0.00223592f, 
    0.10611951f, -0.02789107f, -0.03776204f, -0.05843760f, 0.08055381f, -0.08387776f, -0.05389940f, -0.06176620f, 
    -0.00780869f, 0.15174252f, -0.09078767f, 0.01793237f, 0.06120844f, 0.00928110f, -0.12075550f, 0.03677544f, 
    0.41595644f, -0.12727158f, -0.17368330f, -0.12944318f, -0.00854878f, 0.06831701f, -0.07921984f, 0.08170684f, 
    0.08328021f, 0.02300118f, 0.02454268f, -0.09257614f, -0.02600400f, -0.11333831f, 0.09043694f, 0.00547990f, 
    -0.05584847f, 0.09873678f, -0.22220439f, 0.11850580f, -0.11957890f, 0.01496554f, 0.03348319f, 0.13769461f, 
    0.05216287f, 0.00932805f, 0.14815341f, -0.15138370f, -0.07036225f, 0.14048567f, -0.08455763f, 0.10140686f, 
    -0.04128154f, -0.22807460f, -0.04973326f, -0.01364938f, 0.17149240f, -0.21859312f, -0.19204129f, -0.02926394f, 
    0.00656485f, -0.17739761f, -0.08844045f, -0.07306431f, 0.00438750f, 0.07169833f, 0.17754474f, 0.01480176f, 
    0.00627271f, 0.20414324f, -0.08609274f, -0.13228674f, 0.11689145f, -0.06373838f, 0.23423566f, -0.08590819f, 
    0.02378245f, -0.05892346f, -0.24369551f, 0.11084118f, 0.06558638f, 0.02592949f, 0.06953813f, 0.34413761f, 
    -0.08584858f, 0.14151146f, -0.05954378f, 0.02483508f, -0.17423858f, 0.05710999f, 0.01854126f, 0.10254630f, 
    -0.10503207f, 0.07951666f, 0.14226004f, -0.03278699f, -0.16522652f, -0.03335787f, 0.04856811f, -0.07765356f, 
    0.15971254f, 0.03429688f, -0.29480940f, -0.18901691f, 0.12993635f, 0.05431280f, 0.09305157f, -0.05854025f, 
    -0.10614100f, -0.01192145f, -0.02755440f, 0.02068495f, 0.01671411f, 0.00169149f, 0.06244507f, 0.00002417f, 
    0.04193950f, 0.04863196f, -0.03029487f, -0.12921590f, -0.09364696f, -0.08005401f, 0.08926285f, 0.16308242f, 
    -0.11059325f, 0.04826440f, 0.01963194f, 0.01564406f, 0.20760797f, 0.12825172f, -0.01012687f, -0.04237445f, 
    0.16121872f, -0.07842729f, -0.09719461f, -0.10110885f, -0.15090017f, 0.24187061f, -0.11854701f, -0.16037638f, 
    0.10145275f, 0.00262003f, -0.00719148f, 0.06781124f, 0.01977291f, -0.12272214f, -0.04788924f, -0.19390747f, 
    0.11060391f, 0.02290426f, 0.07306201f, -0.12917079f, 0.11001678f, 0.01783669f, 0.04425626f, 0.59088004f, 
    -0.15130678f, -0.04437613f, -0.23789138f, -0.08519996f, -0.03458240f, -0.23978221f, 0.06531175f, -0.10614733f, 
    -0.12506509f, 0.25102526f, 0.07468136f, -0.00894725f, 0.03128982f, -0.11557744f, 0.04702589f, 0.24383178f, 
    0.05910692f, -0.27712432f, 0.36230293f, -0.16828163f, 0.07977200f, 0.05273667f, -0.09125832f, 0.01059467f, 
    -0.07911208f, 0.15217257f, 0.15075146f, 0.28800067f, 0.16345987f, 0.15988758f, 0.10325215f, 0.01121376f, 
    -0.09335864f, -0.02225881f, 0.03572611f, 0.15460509f, 0.00775460f, 0.16316760f, 0.06217137f, -0.20543487f, 
    -0.02871514f, -0.00424165f, -0.01737855f, -0.08801530f, 0.43284208f, 0.06686912f, -0.07376894f, -0.03631932f, 
    0.10991893f, -0.01223959f, -0.02279909f, -0.02416329f, 0.06301526f, -0.06120311f, 0.10765452f, -0.07280306f, 
    -0.02350658f, 0.19537613f, -0.13615742f, 0.06818399f, 0.11058720f, 0.11639254f, 0.13636464f, 0.06201607f, 
    0.01012854f, 0.13949074f, -0.00835869f, -0.01631915f, -0.02906374f, 0.06633038f, -0.04960952f, 0.03528603f, 
    0.00457025f, -0.12352926f, 0.02003217f, 0.01710783f, 0.10166351f, -0.15127064f, -0.15813644f, 0.17157093f, 
    -0.03622487f, -0.15529104f, 0.11558638f, 0.11249175f, -0.02425843f, -0.12873441f, -0.08256291f, -0.08087207f, 
    0.02204499f, 0.13844229f, -0.03600201f, 0.19644938f, -0.15357405f, 0.13268255f, -0.09584489f, -0.14588232f, 
    0.10417578f, 0.22421484f, -0.19618511f, 0.12169301f, 0.08661316f, 0.05878240f, 0.09211364f, -0.08057800f, 
    -0.00844950f, 0.01075780f, -0.17187829f, -0.30468914f, -0.13132063f, -0.39425439f, 0.06597458f, 0.03317275f, 
    -0.08568329f, -0.03239910f, -0.07119150f, -0.01806899f, 0.10161507f, 0.28573218f, 0.18539003f, -0.21783043f, 
    0.02704074f, -0.05533170f, 0.01651091f, 0.03855314f, 0.06667384f, -0.08202988f, -0.03762180f, -0.05284948f, 
    0.09481724f, 0.09622283f, -0.09846219f, 0.29341248f, -0.00928029f, 0.18713176f, 0.07232849f, -0.14402986f, 
    -0.09941602f, 0.06300741f, 0.02720160f, -0.11788800f, 0.05241100f, 0.02876085f, -0.17433275f, -0.22271016f, 
    -0.12134366f, -0.27431533f, 0.03937408f, 0.23868021f, 0.06506149f, 0.01954147f, -0.04883754f, 0.02491936f, 
    -0.32221818f, 0.07014160f, 0.15922809f, 0.19388628f, 0.16863373f, -0.06166640f, 0.00724767f, -0.04387202f, 
    -0.18797913f, -0.00067292f, 0.04441477f, -0.05073916f, 0.18486655f, 0.12075695f, 0.18393399f, 0.09992011f, 
    0.07233458f, -0.04206124f, 0.05627990f, 0.11177067f, 0.21534835f, -0.13505028f, -0.08028733f, -0.02311586f, 
    -0.20120569f, 0.14466764f, 0.00994910f, -0.28381634f, -0.05655842f, 0.31448469f, -0.01637692f, -0.14176536f, 
    -0.11814321f, -0.06050051f, 0.01514760f, -0.00182121f, -0.29490945f, -0.24474587f, -0.05286499f, 0.07145406f, 
    0.03001989f, 0.06075747f, -0.02752072f, 0.02750160f, -0.04906669f, 0.06778697f, 0.06249697f, 0.18647644f, 
    -0.08131896f, -0.20222567f, -0.03452678f, -0.15499136f, 0.00718438f, -0.08121746f, 0.27088135f, -0.11856204f, 
    -0.21588448f, 0.05829723f, 0.12793718f, 0.11514508f, 0.06959975f, -0.09818587f, -0.00500746f, 0.08931583f, 
    0.02787188f, 0.31063113f, 0.00756483f, -0.08140668f, -0.06745470f, 0.09646079f, 0.24990407f, 0.06577455f, 
    0.58293718f, 0.11007454f, -0.51869768f, 0.19498125f, 0.01343619f, 0.13325289f, -0.06522869f, -0.18398157f, 
    0.08892278f, 0.05207440f, 0.12804513f, 0.07413127f, -0.02268892f, -0.11121473f, 0.05116209f, 0.14295420f, 
    0.16926442f, -0.01844550f, 0.09646803f, 0.12491776f, 0.19671422f, 0.05255013f, 0.04329287f, 0.23906130f, 
    0.11183973f, 0.00570005f, -0.11537551f, 0.40477207f, -0.24083157f, 0.01506500f, -0.24237227f, -0.17651317f, 
    -0.12257607f, -0.04122731f, -0.13584179f, -0.04618822f, 0.02969845f, 0.17730702f, -0.05730294f, 0.06805981f, 
    -0.04320815f, 0.04721200f, -0.12562563f, 0.02652763f, 0.06170530f, -0.21950869f, 0.02695509f, -0.08599729f, 
    0.00599239f, 0.12781996f, -0.09966958f, 0.01516885f, -0.03409632f, 0.00683929f, -0.11135968f, -0.05443304f, 
    0.01534825f, 0.14340554f, 0.09826735f, 0.11013965f, 0.12672152f, 0.02270000f, 0.09627836f, -0.04192292f, 
    -0.14640391f, 0.05590676f, 0.08526213f, 0.13291472f, -0.02319765f, -0.04285123f, -0.01364347f, -0.11744473f, 
    0.14150336f, 0.05489968f, 0.22703001f, -0.20558152f, 0.12174631f, -0.07073482f, -0.08049909f, 0.11719091f, 
    -0.00950633f, 0.52770585f, -0.04639408f, -0.06639037f, -0.31883830f, 0.06646060f, 0.15101936f, -0.07643743f, 
    0.02868175f, 0.12886617f, 0.11068614f, 0.01168729f, 0.16705272f, -0.01980305f, -0.11712385f, 0.00405079f, 
    -0.07483054f, -0.06127305f, 0.03455210f, 0.25139272f, 0.07339256f, -0.11300544f, 0.15375653f, -0.01490361f, 
    0.15650468f, 0.00801450f, 0.07348792f, -0.03645106f, -0.02682508f, -0.13246150f, -0.27360797f, 0.07281306f, 
    0.07067961f, -0.02867178f, 0.08611913f, -0.09157223f, -0.06227165f, 0.10666652f, 0.15527837f, 0.00154560f, 
    -0.09829640f, 0.11528469f, -0.21269502f, 0.06876700f, 0.00224939f, 0.09328156f, -0.04519061f, -0.06551457f, 
    -0.13113223f, -0.04274588f, 0.16194946f, -0.24821813f, 0.00313146f, -0.06226467f, -0.02672298f, -0.31030321f, 
    -0.07433628f, -0.32205731f, 0.19259201f, 0.05165891f, -0.05166581f, 0.01043617f, 0.13353460f, -0.00261162f, 
    -0.11627418f, 0.01571946f, 0.20438340f, 0.00996960f, -0.00558170f, 0.07070861f, 0.18699624f, -0.12519673f, 
    -0.00083873f, -0.05154951f, 0.03884178f, 0.11443062f, 0.08890050f, 0.02045180f, -0.05227758f, -0.03473379f, 
    0.03586646f, 0.01295207f, -0.42923933f, -0.50978303f, 0.00399422f, 0.12743883f, 0.05401564f, 0.06313539f, 
    0.06751342f, 0.14386350f, -0.02595382f, -0.04253520f, -0.00698544f, 0.12570505f, -0.19922681f, -0.04147265f, 
    0.03110493f, -0.01104437f, 0.17712486f, -0.07135904f, -0.08576388f, -0.45091286f, -0.20327653f, 0.05590358f, 
    0.07078604f, 0.06410401f, 0.07334585f, 0.07653786f, -0.03576442f, -0.09601130f, 0.10192097f, -0.09250147f, 
    -0.08555858f, -0.12152581f, 0.09961323f, -0.06845588f, -0.06899824f, 0.10517946f, 0.06815376f, 0.17526190f, 
    -0.00317035f, -0.18996452f, -0.06114218f, -0.10189986f, 0.04056186f, 0.32938913f, -0.04414229f, 0.07010738f, 
    0.03470962f, -0.13722572f, -0.08438835f, 0.09160289f, -0.05076979f, -0.04329808f, 0.15121369f, -0.01767838f, 
    -0.10152217f, -0.10428976f, -0.08270574f, 0.03632415f, 0.05534223f, -0.12621763f, 0.09558819f, 0.19140211f, 
    -0.06615451f, -0.40616569f, -0.03342477f, 0.15642217f, -0.02174100f, -0.00413102f, -0.01406771f, 0.06765052f, 
    0.03137458f, -0.01979140f, -0.20815085f, -0.57980007f, 0.10651900f, 0.17609911f, 0.09023099f, 0.08892400f, 
    -0.07591955f, 0.01108086f, -0.16443561f, 0.52488893f, -0.18193838f, 0.06601143f, 0.06826020f, 0.11344610f, 
    -0.01837166f, -0.07561381f, 0.01243110f, 0.10149123f, -0.06310552f, 0.08391049f, 0.02980132f, -0.06647323f, 
    -0.09635543f, -0.02416408f, -0.07030819f, 0.07171414f, -0.04794327f, 0.15480614f, -0.04000355f, -0.07025214f, 
    0.20147648f, -0.05931766f, 0.08650122f, 0.00182792f, 0.02650092f, 0.05750240f, -0.09367751f, 0.07120110f, 
    -0.00714731f, -0.07327379f, 0.01577130f, 0.06882904f, -0.03743724f, 0.21234865f, 0.13707419f, 0.34795871f, 
    -0.24017821f, 0.00130712f, 0.08012280f, 0.04024687f, -0.01620933f, -0.16171014f, -0.00431177f, 0.00556354f, 
    0.01653765f, 0.19298176f, -0.04952088f, 0.06395224f, 0.15225074f, 0.05670806f, -0.08884176f, 0.20049863f, 
    0.11327792f, -0.09371623f, -0.15802027f, -0.07624047f, -0.11357531f, -0.00016246f, 0.02409028f, -0.04173443f, 
    0.13684006f, -0.02330158f, -0.42677721f, -0.12899271f, 0.00167102f, 0.09160748f, 0.10061589f, 0.06482702f, 
    0.06298967f, 0.00851601f, -0.01609856f, 0.02145256f, -0.06706046f, 0.00189520f, -0.05668465f, 0.04126567f, 
    -0.06802233f, 0.07642432f, -0.07342099f, -0.16985121f, 0.05782792f, 0.18073653f, 0.02064004f, 0.11365320f, 
    -0.03809064f, -0.04595894f, -0.03657638f, 0.02133244f, 0.00825433f, 0.24630144f, 0.12908117f, -0.04518553f, 
    -0.03597653f, -0.26181728f, -0.10160465f, 0.16620876f, 0.19268347f, 0.05051767f, -0.05227120f, 0.11222077f, 
    -0.01658648f, -0.05087649f, -0.08441112f, 0.04589274f, -0.00590819f, -0.11725666f, 0.11776758f, 0.16592443f, 
    0.09873450f, 0.10461711f, -0.01464978f, -0.04486566f, 0.10793197f, -0.07444280f, 0.00140220f, 0.09689838f, 
    0.17495771f, 0.08070868f, 0.03469352f, 0.06988169f, -0.01570766f, 0.02592797f, 0.08557069f, -0.05705051f, 
    -0.06640913f, -0.11152309f, -0.16642807f, -0.10404465f, 0.03456861f, 0.03202151f, 0.02699632f, 0.03431091f, 
    0.18027331f, -0.12402791f, -0.27511227f, -0.24304281f, 0.22577505f, 0.14714405f, 0.17578943f, 0.00584006f, 
    -0.00082848f, -0.06089770f, -0.17412622f, 0.15921459f, 0.15610608f, 0.02946197f, -0.12720393f, 0.03697988f, 
    0.04592934f, -0.06212340f, 0.09358957f, -0.05806531f, -0.08689841f, 0.06101192f, 0.00474581f, -0.05059181f, 
    -0.00033908f, -0.23354259f, -0.08644696f, 0.14298984f, -0.05566206f, 0.24147530f, -0.05455235f, -0.08348216f, 
    0.09026672f, 0.04601041f, 0.07705811f, -0.04505795f, 0.07681061f, 0.02076308f, 0.19249471f, 0.18641502f, 
    -0.07368451f, -0.01386229f, -0.23017807f, -0.09341951f, -0.16642956f, 0.02852305f, 0.18917653f, -0.04713379f, 
    0.09312101f, -0.05660929f, -0.19437234f, -0.00485903f, -0.00249518f, 0.02832879f, -0.07436424f, -0.01735237f, 
    -0.51636678f, -0.03022885f, -0.13426489f, 0.10886490f, -0.00266084f, 0.11101974f, 0.03204843f, -0.14264622f, 
    -0.03191107f, -0.10668033f, -0.13241540f, -0.09311450f, 0.20721330f, 0.03377283f, -0.09122118f, 0.12323924f, 
    0.01516138f, -0.23876572f, -0.14227678f, 0.11502936f, -0.10360120f, 0.21402602f, 0.03454332f, 0.08543804f, 
    0.02178552f, 0.04114292f, -0.08769315f, -0.05699164f, -0.27712423f, 0.27075416f, -0.07831944f, 0.01967946f, 
    -0.11993466f, 0.01812811f, 0.11336005f, 0.19702603f, 0.02906395f, 0.08927778f, -0.01752038f, 0.06315245f, 
    0.02879003f, -0.10918625f, -0.07485551f, -0.12465463f, 0.10205648f, 0.08012728f, -0.00931173f, 0.17500632f, 
    -0.14193633f, -0.04039244f, 0.12178660f, 0.05630212f, -0.04622172f, 0.05583933f, -0.14626284f, -0.03124122f, 
    0.09757911f, -0.06457544f, -0.26679718f, -0.03602025f, 0.08533419f, -0.03683582f, 0.17409179f, -0.06485314f, 
    -0.03639546f, 0.23617333f, -0.13061136f, -0.06018044f, -0.05186497f, 0.03727143f, 0.07190780f, -0.08965311f, 
    0.03649069f, 0.30955204f, -0.22947575f, 0.01991885f, -0.09826888f, 0.02502259f, 0.10660974f, -0.16331980f, 
    0.06671906f, -0.00878923f, 0.14180830f, 0.03839484f, 0.00645551f, 0.04169519f, 0.01653885f, 0.05056690f, 
    0.16034433f, 0.10549236f, -0.33374774f, 0.03074301f, -0.00845267f, 0.10536763f, 0.03701151f, 0.11810977f, 
    -0.05454655f, 0.19493060f, -0.22276405f, -0.08384274f, 0.08669060f, -0.32384539f, -0.04850787f, -0.09149015f, 
    -0.00715764f, 0.00733766f, -0.00590551f, -0.13960522f, -0.03682841f, -0.23711933f, -0.03143745f, -0.02875006f, 
    0.07963356f, -0.21692276f, 0.22440392f, 0.03958576f, -0.14494748f, 0.16322754f, 0.13723552f, -0.38314047f, 
    0.17311534f, -0.00104240f, 0.09007894f, -0.02265216f, -0.01184340f, -0.12138753f, 0.10170766f, -0.07719648f, 
    0.07431494f, 0.03230867f, 0.11026540f, -0.04249579f, 0.08564525f, -0.05957675f, -0.06116069f, -0.04848612f, 
    0.01116227f, -0.19813694f, -0.03070370f, -0.02492188f, 0.08625114f, 0.01579346f, 0.08738983f, 0.00500985f, 
    0.16040924f, 0.15675229f, 0.10184643f, -0.09646036f, -0.06238523f, 0.00883381f, 0.02208208f, 0.05710136f, 
    -0.06407725f, 0.22070332f, -0.02667661f, -0.44531202f, 0.02076226f, -0.05069173f, -0.06185236f, -0.10025901f, 
    -0.03343454f, 0.33812743f, -0.03824143f, 0.19375813f, 0.10679001f, -0.07817589f, -0.01168865f, -0.02112512f, 
    0.03669942f, 0.07497015f, -0.00788846f, 0.04253685f, 0.07699718f, -0.48968899f, 0.33390772f, -0.12463658f, 
    0.01634139f, 0.00441519f, 0.11908033f, 0.07183065f, 0.04341487f, -0.13437274f, -0.18161134f, 0.16346852f, 
    0.11629364f, -0.00801418f, -0.15870987f, 0.01105527f, 0.10276613f, -0.26400518f, 0.36905369f, 0.11689341f, 
    0.03959298f, -0.13972254f, -0.03996613f, -0.02875568f, 0.11520283f, 0.03695361f, -0.27191964f, -0.04095399f, 
    0.04109288f, 0.02215953f, 0.08825028f, 0.07356685f, 0.07568470f, -0.07379930f, -0.11029370f, 0.01423343f, 
    0.09824605f, 0.22946714f, 0.01761636f, -0.01962845f, -0.03919279f, 0.02762596f, -0.06124751f, 0.24110535f, 
    0.18049981f, -0.19260560f, -0.08876435f, 0.05905547f, -0.04127282f, -0.07017186f, 0.13452932f, 0.04164810f, 
    -0.08442660f, -0.30489492f, 0.17541900f, -0.02911712f, -0.01333088f, 0.11402769f, -0.08762199f, -0.08412086f, 
    0.06353059f, -0.14744000f, 0.00848300f, -0.08674873f, -0.25559542f, 0.05000186f, 0.05621974f, -0.00365581f, 
    -0.05707566f, -0.01082333f, 0.04358793f, 0.15318674f, -0.06642181f, 0.27533451f, -0.18574926f, -0.04620389f, 
    -0.02272116f, 0.02272870f, -0.01490858f, 0.10208998f, -0.14832655f, -0.01874672f, 0.13719688f, -0.00524455f, 
    -0.01876617f, 0.06564830f, -0.00215884f, -0.01628823f, -0.04484180f, -0.08265405f, -0.11279596f, -0.18636928f, 
    0.13653669f, -0.02600178f, -0.10617906f, 0.04210456f, 0.03133346f, 0.11847973f, 0.11222924f, 0.09159406f, 
    -0.04433810f, -0.12288212f, -0.08668711f, -0.08016836f, 0.07909295f, 0.13684161f, -0.03304858f, -0.07723553f, 
    0.04402871f, -0.36924776f, 0.12897970f, 0.04362390f, -0.00194669f, 0.14305890f, -0.14471593f, -0.15176864f, 
    -0.04223205f, -0.13802005f, 0.09545627f, 0.02781767f, 0.08545037f, -0.10132942f, 0.06486028f, -0.07217421f, 
    -0.08224973f, 0.09759806f, -0.06628262f, -0.15769994f, -0.06342947f, -0.04471720f, 0.00354357f, 0.12599489f, 
    -0.15537380f, 0.09321731f, 0.01827419f, 0.17333277f, -0.15654668f, 0.25639996f, -0.13992463f, 0.02065160f, 
    -0.02096386f, 0.05192553f, 0.02545871f, -0.15040000f, 0.11681689f, -0.01642861f, -0.04201041f, 0.13552855f, 
    -0.14119086f, -0.14878899f, -0.01256366f, 0.00422245f, 0.23126097f, 0.13976972f, 0.09516824f, 0.18201521f, 
    -0.08622468f, 0.02132488f, 0.06845334f, -0.05830855f, 0.06082936f, 0.19686529f, -0.24282961f, -0.05978466f, 
    -0.05502602f, 0.10887310f, -0.08419681f, -0.01265059f, -0.12333988f, -0.03691645f, 0.07025383f, 0.03493854f, 
    -0.29687020f, 0.01881637f, 0.18251526f, -0.04380642f, 0.02177663f, -0.06317067f, -0.00155668f, 0.11013155f, 
    0.12846582f, -0.22255184f, 0.05973041f, -0.00735103f, 0.02768673f, -0.06369793f, 0.04951817f, 0.01523840f, 
    0.13056365f, -0.00124113f, -0.06657405f, -0.04646464f, 0.03221688f, -0.19804877f, -0.10093504f, 0.10506547f, 
    0.21271008f, 0.23164377f, 0.02139157f, -0.12161718f, -0.02681329f, 0.02666280f, -0.09913561f, 0.05551053f, 
    0.11925420f, -0.07669058f, 0.08073661f, 0.06870020f, -0.04151339f, 0.18932882f, -0.21291253f, 0.11821545f, 
    -0.01253031f, 0.03596664f, 0.10905097f, -0.04207654f, -0.13697694f, -0.09891168f, 0.14724858f, 0.09207593f, 
    -0.07936011f, 0.10851849f, -0.12740874f, -0.04214919f, 0.02554825f, -0.12884115f, -0.18455014f, -0.12496838f, 
    -0.05945804f, 0.17855658f, -0.07982229f, -0.04183460f, -0.05336305f, 0.30165479f, 0.05111151f, 0.02673228f, 
    0.15341203f, -0.18099664f, 0.17154913f, 0.12473553f, -0.11184319f, 0.14152548f, -0.07889934f, 0.20555750f, 
    -0.19100508f, -0.01269722f, 0.01132306f, -0.14593707f, -0.03765081f, 0.03790048f, -0.09826281f, 0.10379079f, 
    -0.26201829f, -0.16534659f, -0.00321982f, 0.08347654f, -0.15095453f, -0.12455764f, -0.00924098f, -0.00244409f, 
    0.04210116f, -0.10014895f, -0.28987971f, -0.04976852f, 0.23205273f, 0.06656659f, -0.02910099f, -0.14850014f, 
    -0.09612834f, 0.21789466f, 0.27009508f, 0.08928477f, -0.05099569f, 0.04141187f, -0.01487166f, -0.00194610f, 
    0.04514446f, 0.21271713f, 0.04675430f, -0.04670674f, 0.12339842f, 0.04318461f, 0.08887123f, -0.20132543f, 
    0.03883115f, 0.03210131f, -0.04064833f, -0.14050606f, 0.01828460f, -0.20325723f, -0.14273511f, 0.01344031f, 
    0.00007484f, -0.01381329f, -0.06392312f, 0.07518779f, 0.16824158f, -0.06970906f, 0.01556872f, 0.07421752f, 
    0.00591648f, 0.02802691f, 0.06184919f, 0.11614103f, 0.08970844f, -0.19788289f, 0.02046533f, -0.00228228f, 
    -0.04348677f, -0.00595232f, 0.00079033f, -0.00109223f, 0.05319376f, 0.03800905f, -0.10713180f, -0.22933985f, 
    -0.20068538f, -0.19352837f, 0.03390807f, 0.02217181f, -0.23329720f, -0.03669990f, -0.12585515f, -0.57111996f, 
    0.03739288f, 0.19805549f, -0.02531955f, 0.04824389f, -0.03113428f, 0.13504370f, 0.01505473f, -0.03187471f, 
    0.28818759f, 0.18441591f, 0.04265660f, 0.00097780f, -0.14693812f, 0.16653335f, 0.05250611f, -0.07037405f, 
    0.07045814f, -0.22719416f, -0.11920589f, 0.14532976f, 0.07763978f, 0.11269487f, 0.12349358f, 0.01600384f, 
    0.04613350f, -0.05947283f, 0.50354737f, 0.01735399f, 0.00645158f, 0.00741932f, 0.01735170f, 0.19162293f, 
    0.01900928f, 0.08160362f, -0.02308236f, -0.11076982f, 0.31496060f, -0.04574163f, 0.02056512f, 0.08774916f, 
    0.07902978f, -0.00642800f, 0.02009751f, -0.08095153f, -0.15889846f, 0.11018653f, -0.35820934f, -0.01804568f, 
    0.14549713f, 0.00435098f, -0.07329544f, -0.03818393f, 0.03150905f, 0.19176164f, 0.13545212f, -0.02801380f, 
    0.04624087f, 0.07944131f, -0.01063641f, -0.18828385f, -0.02170287f, 0.10723484f, 0.05240920f, -0.19815168f, 
    0.04515864f, 0.05430911f, -0.06722680f, 0.01992421f, -0.05518952f, 0.10686271f, -0.14611644f, 0.02716777f, 
    -0.23499432f, -0.34580511f, 0.10124496f, 0.04667372f, 0.16787368f, 0.09554224f, -0.10195861f, -0.26494974f, 
    0.00546472f, -0.04720854f, 0.20092097f, -0.01326655f, 0.02303201f, 0.02200841f, 0.03963016f, 0.05980377f, 
    0.02001958f, 0.12312445f, -0.05517750f, 0.15203224f, -0.11374601f, -0.09671753f, -0.14717732f, -0.10066018f, 
    -0.06173519f, 0.09816081f, -0.26443166f, 0.04419836f, -0.12151452f, 0.04249011f, 0.05020436f, -0.02658796f, 
    0.04186602f, -0.03659997f, 0.00864216f, 0.00094359f, 0.03552976f, -0.14694789f, 0.08101316f, -0.10848846f, 
    -0.07435271f, 0.07626615f, 0.20834602f, -0.13437662f, -0.11959930f, -0.05489495f, -0.00241640f, -0.01758830f, 
    0.06201546f, 0.05824734f, 0.03000361f, 0.06867401f, 0.07217640f, -0.00187320f, 0.05859890f, 0.00180083f, 
    -0.09190614f, 0.02733830f, 0.00147108f, -0.07970780f, -0.02018312f, -0.11807957f, 0.02428029f, 0.02260755f, 
    0.12625904f, -0.03141805f, 0.00884515f, 0.20182450f, -0.02939440f, 0.06712774f, 0.02719337f, 0.05405161f, 
    -0.02499457f, 0.08050472f, 0.00403467f, -0.08872014f, 0.02245842f, -0.09879984f, 0.11908297f, 0.07518756f, 
    -0.32769889f, 0.21402055f, -0.03233648f, 0.06560711f, -0.28302395f, 0.00875316f, 0.09989212f, -0.05225951f, 
    0.12371407f, -0.03146753f, 0.00727760f, -0.11671032f, 0.18320736f, 0.10965517f, 0.02984305f, 0.14239283f, 
    -0.20326498f, 0.03916518f, 0.02584086f, 0.06371197f, -0.17522439f, -0.15839106f, 0.03791881f, 0.02233313f, 
    0.07532135f, 0.14459062f, 0.02870583f, 0.07119138f, 0.25375697f, 0.11171792f, -0.00489122f, -0.13560486f, 
    0.00733697f, 0.07300525f, 0.17955968f, -0.20236924f, -0.03274597f, 0.01277951f, 0.15903141f, -0.16214433f, 
    0.04431763f, -0.10175818f, 0.02322415f, 0.11858849f, -0.13784690f, 0.12634304f, -0.00048975f, 0.13104413f, 
    -0.08084310f, -0.12182896f, 0.03235188f, 0.01970237f, 0.04737924f, -0.02880565f, -0.03245051f, 0.21445885f, 
    -0.00002129f, -0.03685063f, -0.01614344f, -0.02051618f, 0.04088288f, 0.14183438f, 0.02151577f, -0.13222556f, 
    0.01242109f, -0.12079334f, 0.03225854f, 0.09622098f, 0.09234292f, 0.01012007f, -0.03116841f, -0.07463089f, 
    -0.00792912f, 0.02450891f, 0.06037309f, -0.03528784f, -0.05360904f, -0.03427776f, -0.18107513f, 0.02088729f, 
    0.11312770f, -0.00242891f, 0.01496534f, 0.17588097f, 0.03676737f, -0.03802510f, 0.13129196f, 0.14770514f, 
    0.10686110f, 0.00580451f, -0.00117450f, 0.03643115f, -0.01602940f, 0.20452398f, 0.05508701f, 0.10396940f, 
    0.22342151f, -0.07954427f, -0.01168340f, 0.05830587f, -0.18392342f, 0.18561602f, -0.07660899f, -0.22498481f, 
    -0.12876053f, 0.02129477f, 0.12390623f, -0.34227437f, 0.15527433f, -0.12318654f, 0.19503683f, 0.04660266f, 
    -0.10863309f, -0.16817252f, 0.13625386f, -0.09754393f, 0.08155783f, 0.17298444f, -0.05259378f, 0.13162091f, 
    -0.08370680f, 0.16608161f, 0.08796725f, 0.18177833f, 0.13271639f, -0.13487022f, 0.16066837f, 0.00120075f, 
    0.05544773f, 0.01180048f, 0.00885864f, 0.01845820f, 0.10938837f, -0.01536742f, -0.03224292f, -0.11561575f, 
    0.22844486f, -0.20028934f, 0.11310464f, -0.03958474f, 0.01750944f, -0.15040256f, 0.05969673f, -0.03388878f, 
    0.21960939f, -0.02679691f, 0.03711041f, -0.09614858f, -0.05493540f, 0.09924373f, -0.04488868f, 0.16458578f, 
    -0.02524387f, -0.41141328f, -0.21007669f, -0.39562926f, 0.10308801f, 0.05735293f, -0.16596302f, 0.15284580f, 
    -0.05133740f, -0.15761936f, -0.12207601f, -0.05634727f, -0.03174182f, 0.15144774f, -0.03496972f, 0.15864280f, 
    0.10674359f, -0.05401804f, 0.00508538f, -0.09086286f, 0.05193071f, -0.04069233f, -0.00516164f, 0.00935254f, 
    0.04452825f, 0.05628822f, 0.03906782f, 0.02127079f, -0.23514959f, -0.06802389f, -0.05726372f, 0.07736937f, 
    0.06826244f, -0.07639975f, -0.07181644f, 0.03269576f, -0.04775519f, -0.09928648f, -0.12867714f, 0.15445216f, 
    -0.01667035f, 0.01749433f, -0.02658134f, 0.00376171f, 0.21351586f, -0.15430006f, 0.04118526f, -0.05806988f, 
    0.16057666f, 0.04561584f, -0.06392119f, 0.12002499f, 0.11833516f, 0.05238476f, -0.15013254f, 0.05638073f, 
    0.08684796f, 0.08601306f, -0.04688558f, 0.00462273f, -0.09039904f, 0.09044253f, -0.08425370f, -0.14216068f, 
    -0.02443485f, -0.01376938f, 0.01751821f, -0.00966659f, 0.00771665f, 0.02299332f, -0.06111752f, -0.00047820f, 
    0.03629597f, 0.00510297f, -0.04655149f, -0.03586137f, -0.04207537f, 0.04427217f, 0.00338515f, -0.05798305f, 
    0.03229948f, -0.03657044f, 0.05008867f, -0.05238621f, -0.04331953f, 0.04019029f, 0.02517140f, -0.04855532f, 
    0.02235351f, -0.04469744f, 0.02137668f, -0.00795391f, 0.02057678f, 0.02770554f, 0.01327708f, 0.04655359f, 
    0.01202090f, -0.05483251f, 0.01287488f, -0.05809699f, 0.04150797f, 0.02517845f, -0.06744680f, -0.02059580f, 
    -0.04753325f, 0.03661247f, 0.02447875f, -0.00424865f, 0.01240957f, -0.04869388f, -0.06044292f, 0.01018452f, 
    -0.00807488f, 0.02063452f, -0.05475123f, 0.01069133f, -0.03741634f, 0.01447230f, -0.03621850f, -0.02637868f, 
    -0.06081207f, -0.05523006f, 0.02586710f, -0.01465749f, 0.02118133f, 0.00367612f, 0.01354655f, 0.00544655f, 
    0.04276954f, 0.04262107f, 0.03613758f, -0.00364440f, 0.02953970f, -0.02524582f, 0.02443085f, 0.00422509f, 
    -0.03708405f, -0.01959439f, 0.02437598f, -0.00473957f, -0.03148335f, 0.02464677f, 0.02946542f, 0.02529707f, 
    -0.00618729f, -0.00000748f, -0.03816737f, 0.04300042f, -0.02741300f, 0.03438950f, 0.03680035f, 0.01268436f, 
    -0.03848558f, 0.03117971f, -0.04966569f, -0.04760064f, 0.00539674f, 0.02628408f, 0.04656060f, -0.03512730f, 
    -0.01489839f, 0.01337944f, -0.03513283f, 0.02098029f, -0.05553456f, -0.03057445f, -0.02295301f, 0.01126175f, 
    0.02282542f, -0.00708558f, -0.02896127f, -0.00825652f, -0.00051691f, 0.03571955f, 0.02585186f, -0.06813943f, 
    0.03627336f, -0.00194388f, 0.04766654f, -0.05423488f, -0.03964207f, 0.02877430f, 0.04818756f, 0.02209048f, 
    0.02058403f, -0.05523510f, -0.03386139f, -0.00142423f, -0.03069304f, 0.00771922f, -0.06464072f, 0.04639592f, 
    0.03710497f, -0.02178933f, 0.04055719f, -0.01019538f, -0.01667681f, -0.01899722f, 0.02658362f, -0.05588439f, 
    -0.01511098f, -0.00565429f, 0.04282030f, 0.02474180f, -0.03543114f, 0.04097003f, -0.05167177f, 0.04724909f, 
    -0.01762946f, 0.02366834f, -0.02056256f, 0.02817038f, -0.05140138f, 0.02786270f, -0.00127674f, -0.00670262f, 
    -0.01558003f, 0.00586784f, -0.03751752f, -0.06196968f, -0.05827963f, -0.05282267f, -0.03919053f, -0.06992938f, 
    0.03088666f, 0.02376454f, -0.02414937f, 0.04459830f, 0.00329480f, -0.02076560f, -0.05229421f, -0.00760458f, 
    -0.01044033f, -0.05478435f, -0.00545966f, 0.01983210f, 0.01791657f, -0.04078221f, 0.00349998f, 0.01331006f, 
    -0.04947278f, -0.01387594f, -0.01855576f, 0.04276587f, -0.00096697f, 0.01761009f, 0.02366925f, -0.03125735f, 
    -0.04870332f, -0.02691007f, -0.05937232f, -0.05896500f, -0.00617438f, -0.04277286f, 0.01609084f, -0.05689310f, 
    -0.06221179f, 0.04057705f, 0.02632439f, -0.06489575f, -0.02694419f, -0.05330696f, 0.01914618f, 0.01556128f, 
    -0.03130865f, -0.00700790f, -0.03169853f, -0.03440190f, 0.04680200f, -0.01684288f, -0.01354398f, -0.02112185f, 
    -0.04785330f, 0.03981409f, -0.04025612f, -0.03953474f, 0.04488084f, 0.02501250f, -0.00652224f, -0.00137902f, 
    0.03459053f, 0.00934319f, -0.01347785f, 0.02827955f, -0.01811732f, -0.06187332f, -0.00945973f, -0.03801266f, 
    -0.00078700f, 0.02696179f, -0.06680357f, -0.03292023f, 0.04093162f, 0.04544157f, -0.02251325f, 0.04544534f, 
    0.04190154f, -0.03625593f, -0.05849214f, 0.03278435f, -0.01304710f, 0.01118700f, 0.02567353f, -0.04752555f, 
    0.02725395f, -0.05276996f, 0.02139359f, -0.05893730f, -0.04962955f, -0.01505447f, -0.04365240f, -0.00067585f, 
    0.04617394f, 0.01474587f, -0.04703070f, -0.01554586f, -0.04295689f, -0.02983466f, -0.05619635f, -0.07079009f, 
    0.03915271f, -0.03881440f, -0.00802544f, -0.04022305f, -0.00739886f, 0.00940502f, -0.01490017f, -0.06800191f, 
    0.03315293f, -0.02057115f, -0.02817606f, 0.04183851f, -0.02035994f, 0.02556566f, -0.04915699f, -0.03791091f, 
    -0.00894231f, 0.02750912f, 0.04081294f, -0.00475354f, 0.02830105f, 0.01084693f, -0.04686429f, -0.03535132f, 
    0.02110760f, 0.03048250f, 0.02349325f, -0.04535034f, -0.02251826f, -0.02576903f, 0.01065614f, -0.06678181f, 
    -0.06074825f, -0.03703596f, 0.01555883f, 0.02311376f, -0.03693959f, -0.04794470f, -0.00190223f, 0.04671483f, 
    -0.00758240f, -0.05159134f, -0.02974938f, 0.00226297f, 0.05108445f, 0.02034086f, 0.01640093f, 0.02322440f, 
    -0.01130955f, 0.02896755f, 0.01484570f, 0.03125200f, -0.03008696f, 0.04593918f, -0.00561011f, 0.02558435f, 
    0.03000266f, -0.01844876f, 0.00674661f, 0.02015119f, -0.06072370f, -0.01487114f, -0.06155604f, -0.00274548f, 
    -0.01962546f, -0.01004542f, -0.00163417f, 0.03572387f, 0.03517576f, -0.06375001f, -0.06049743f, -0.05518806f, 
    -0.01161472f, -0.01809935f, 0.04435770f, -0.02843774f, -0.04692242f, 0.02727040f, 0.02940587f, -0.04755981f, 
    -0.05210416f, -0.01548252f, -0.01509028f, -0.05364486f, -0.03035173f, -0.06162448f, -0.02912169f, 0.04307983f, 
    -0.04088826f, -0.04570389f, 0.01189195f, -0.05717831f, 0.01218674f, -0.03231534f, -0.02870705f, 0.02432691f, 
    0.03590458f, -0.01246985f, 0.00237855f, -0.00980426f, 0.01989814f, -0.02275516f, -0.05295607f, 0.01590348f, 
    0.01450596f, -0.04430654f, -0.01050159f, -0.03196016f, 0.01997666f, -0.03713258f, 0.04255322f, -0.03068234f, 
    0.03143653f, 0.05155047f, -0.04002029f, -0.02033448f, 0.04216097f, 0.02942209f, -0.00476501f, 0.04788732f, 
    0.02947729f, -0.04417714f, -0.05243590f, 0.03485328f, -0.00068762f, -0.00788814f, -0.02265882f, 0.00205200f, 
    -0.02288635f, 0.01257876f, -0.01193027f, 0.04414402f, 0.01373503f, -0.00626667f, 0.01192428f, 0.01179938f, 
    -0.03639992f, 0.00796644f, 0.02897916f, 0.02268915f, -0.05560684f, 0.04719913f, -0.01396074f, -0.05458692f, 
    -0.00270651f, -0.00501799f, -0.03694689f, 0.01730528f, 0.02969203f, 0.03452630f, 0.02500927f, 0.02004490f, 
    -0.05570657f, -0.00640831f, -0.05797033f, 0.02851258f, -0.01498354f, 0.04757690f, -0.02914111f, 0.02313960f, 
    -0.00948835f, -0.04882574f, 0.00240632f, 0.02180135f, -0.02590132f, 0.02221708f, -0.05009816f, -0.00710112f, 
    -0.02024592f, 0.00942966f, -0.00725555f, 0.00439757f, -0.02940936f, -0.00753836f, -0.06140226f, -0.03271244f, 
    -0.01812101f, -0.02426555f, -0.04625091f, 0.02992227f, -0.05207151f, -0.01823386f, -0.02479718f, 0.00115852f, 
    -0.04577314f, -0.06177606f, 0.04246121f, 0.03839422f, -0.04204629f, 0.02837167f, -0.06105962f, -0.01836084f, 
    -0.01328311f, 0.01422975f, 0.03467951f, -0.04084067f, -0.05266507f, 0.01796816f, -0.05635251f, 0.01435051f, 
    -0.00009853f, 0.00761168f, -0.03921694f, -0.04062162f, -0.03747066f, -0.03243190f, -0.03135059f, -0.04095661f, 
    0.04069397f, -0.03649371f, -0.02000132f, -0.02722004f, 0.01195248f, -0.03185218f, 0.00851073f, 0.04764800f, 
    -0.04092123f, 0.00016589f, -0.00941575f, -0.00892311f, -0.03600243f, -0.01733002f, -0.02893489f, 0.01339062f, 
    -0.03476805f, -0.06077825f, 0.02791454f, 0.01868678f, 0.04861573f, -0.00415262f, -0.03623960f, -0.04455237f, 
    -0.05748725f, -0.03693067f, -0.03835104f, 0.00507021f, -0.04403832f, -0.01572843f, 0.02633285f, -0.05268966f, 
    -0.01689804f, -0.02672038f, -0.05219740f, -0.06254671f, 0.00299300f, 0.04675733f, 0.01140808f, -0.02292925f, 
    0.05208865f, -0.06002070f, 0.04344082f, -0.03417042f, 0.01911244f, -0.00757583f, 0.00595249f, -0.04195940f, 
    0.04804170f, -0.05658041f, 0.01361233f, 0.01195623f, 0.01821814f, 0.05318933f, -0.01607805f, -0.01642190f, 
    0.03136334f, -0.02730082f, -0.05474012f, 0.04113219f, 0.05020825f, -0.02782128f, -0.03410348f, -0.02244972f, 
    -0.05287976f, -0.05670914f, 0.00179493f, 0.04509870f, -0.02158229f, -0.03470523f, -0.01070019f, -0.02973648f, 
    -0.02803464f, 0.01854829f, -0.01224420f, -0.04485232f, -0.04338283f, 0.00124161f, 0.05162007f, -0.03460568f, 
    0.01844245f, -0.02505149f, 0.04071687f, -0.01622204f, -0.00172601f, -0.00770653f, 0.04751292f, -0.03903797f, 
    0.04380906f, 0.02299585f, -0.04931736f, -0.05881855f, -0.04048327f, -0.01696386f, -0.00846140f, -0.04780339f, 
    0.05290203f, -0.01626276f, 0.01948290f, -0.00973227f, -0.00469698f, -0.04370345f, -0.04307747f, 0.00581911f, 
    0.04153712f, -0.01838908f, 0.01719532f, -0.03196157f, -0.01715046f, -0.00538378f, 0.02464840f, 0.01785904f, 
    -0.00977017f, 0.16585441f, 0.01113563f, 0.04807420f, -0.15860945f, -0.01339744f, 0.01245067f, 0.13017631f, 
    0.10457560f, -0.07494877f, -0.18098055f, 0.04224308f, 0.07765221f, -0.01658822f, -0.08695366f, -0.09698993f, 
    -0.03677841f, 0.07477161f, 0.18261954f, -0.00724955f, 0.11396331f, 0.21121864f, 0.02556058f, -0.14971982f, 
    0.00899033f, -0.06697676f, 0.10107543f, -0.37608671f, -0.08142164f, 0.12438872f, -0.04099599f, -0.07304869f, 
    0.00335759f, -0.14113681f, -0.01064185f, 0.00319274f, 0.06735849f, -0.20076765f, 0.18826282f, 0.15291591f, 
    0.08445042f, -0.05975430f, 0.12517932f, 0.01940583f, 0.00604033f, -0.19194143f, -0.02313882f, -0.12991184f, 
    0.02578037f, 0.12974496f, 0.07208274f, 0.08789062f, -0.02690792f, 0.03840342f, -0.15336694f, -0.12229231f, 
    0.01098451f, -0.19379598f, 0.03260166f, 0.13679118f, -0.14430135f, -0.15988435f, 0.03243254f, -0.09490461f, 
    0.07932960f, 0.18527003f, -0.08934797f, 0.05843905f, -0.12843437f, -0.18920518f, -0.04970467f, -0.08600827f, 
    0.33399165f, 0.01373136f, 0.06118801f, 0.02691160f, -0.19836804f, -0.15004954f, 0.06136329f, -0.11042818f, 
    -0.02062841f, 0.06600492f, 0.11158457f, 0.11175250f, -0.12191792f, -0.06918747f, -0.18169607f, 0.01442039f, 
    -0.00527844f, -0.03297511f, 0.14975706f, -0.20373447f, 0.02919599f, 0.15594891f, -0.04346905f, -0.05508811f, 
    0.05755827f, -0.01858095f, -0.00622481f, 0.12888956f, 0.18936326f, -0.13349797f, 0.21943715f, -0.08994026f, 
    0.06880130f, -0.05110654f, -0.10634634f, -0.08929551f, -0.17917091f, -0.04592642f, 0.00647014f, -0.02541911f, 
    0.12797336f, 0.13993788f, 0.13847627f, -0.00736935f, 0.05637699f, 0.12479302f, -0.05332868f, -0.00203941f, 
    0.23568149f, -0.05196340f, 0.02034464f, 0.05748621f, 0.02205623f, 0.07716458f, -0.20485620f, -0.07933500f, 
    0.01874974f, -0.16147861f, 0.06124713f, -0.09953938f, -0.02384525f, 0.00174485f, -0.13528453f, 0.21602164f, 
    0.18868522f, -0.15354045f, -0.04494539f, -0.09451094f, -0.19773328f, -0.00367960f, -0.06987403f, 0.08640525f, 
    -0.03759100f, 0.10285851f, -0.00529763f, -0.15226367f, -0.01049614f, -0.30052286f, 0.02986317f, 0.11496027f, 
    -0.00777001f, 0.18058689f, 0.05293504f, -0.11887527f, 0.03348455f, -0.13800040f, 0.06542517f, 0.11348824f, 
    0.20816921f, 0.04213373f, 0.04579376f, 0.09485595f, 0.28030801f, 0.03067062f, -0.02736036f, -0.14639753f, 
    -0.06226614f, -0.03719484f, -0.01502869f, -0.11503920f, 0.28762770f, -0.11295640f, -0.05857902f, -0.02458458f, 
    -0.00339614f, 0.05802328f, 0.02963014f, 0.04900375f, 0.12557665f, 0.13511287f, -0.07975843f, 0.16128652f, 
    0.05694221f, 0.05487905f, 0.15564343f, 0.11371217f, 0.08297437f, 0.06690736f, 0.04445421f, -0.01261092f, 
    0.05060223f, 0.07553092f, 0.14196184f, -0.01417027f, -0.08379081f, -0.02657255f, -0.22048227f, 0.18218629f, 
    0.06141977f, 0.01631871f, -0.06398614f, -0.01647658f, -0.01532202f, 0.12019281f, 0.12048974f, -0.19621326f, 
    -0.09402222f, 0.07935197f, -0.14369297f, 0.04251582f, -0.11063100f, -0.10439488f, -0.07156534f, -0.08060324f, 
    -0.06101673f, -0.27910352f, 0.03075373f, 0.11688782f, -0.04635294f, 0.17490993f, -0.12771796f, 0.04497453f, 
    -0.14128891f, 0.16762194f, 0.25270644f, 0.11247125f, 0.17468733f, -0.12986279f, -0.04664582f, -0.05543990f, 
    0.04769647f, 0.17654145f, -0.00928906f, -0.20069163f, 0.02304657f, 0.24069951f, 0.05154920f, 0.14475870f, 
    0.03300463f, 0.00320002f, 0.11278522f, -0.08731052f, 0.01601483f, 0.11847224f, -0.10013048f, 0.04821131f, 
    0.05240226f, -0.06216876f, 0.04964068f, -0.07884327f, -0.12435320f, -0.02936522f, 0.17444782f, 0.01421496f, 
    -0.00314433f, 0.00231402f, -0.02837059f, -0.00673789f, -0.02708523f, -0.19216140f, -0.24581072f, -0.05525660f, 
    0.09347836f, 0.12143758f, 0.10872908f, 0.10623445f, -0.08188324f, -0.01057235f, 0.24797171f, 0.14486192f, 
    -0.20805275f, 0.04748908f, -0.19459286f, 0.24402633f, -0.11149562f, 0.09075562f, -0.08447775f, 0.15793812f, 
    0.12666172f, -0.08398662f, -0.01929830f, 0.06086965f, 0.11878469f, 0.15736127f, -0.08986544f, 0.07009207f, 
    -0.10152270f, -0.06007930f, -0.17562868f, -0.08713694f, 0.16638538f, -0.11119895f, -0.07448045f, -0.10237543f, 
    -0.00733335f, 0.00430086f, -0.02054538f, 0.07036481f, -0.05442751f, 0.10314655f, 0.01261906f, 0.07900695f, 
    0.07539145f, 0.04959993f, 0.30090219f, 0.12551332f, 0.21601728f, 0.03313852f, 0.06070308f, -0.02599590f, 
    0.05123394f, 0.05974616f, 0.01376238f, -0.22645856f, -0.24614152f, 0.18446897f, -0.06278571f, 0.19702047f, 
    -0.00867721f, 0.05470131f, -0.08097535f, 0.08074701f, 0.30355722f, 0.09458265f, -0.00214708f, -0.02763599f, 
    0.08565582f, 0.04788529f, -0.01778762f, -0.07507798f, -0.05458404f, -0.23313266f, 0.13986649f, -0.15742351f, 
    -0.05622151f, 0.00236085f, 0.08432983f, 0.16918574f, 0.03784856f, -0.09763342f, -0.33091179f, -0.25873357f, 
    0.12977360f, -0.02048444f, 0.10866001f, -0.02419943f, -0.09140550f, -0.12052825f, -0.02747416f, -0.12718864f, 
    -0.03178333f, -0.03459719f, 0.03000763f, -0.02506430f, 0.11303426f, 0.09146503f, 0.13607837f, -0.03827440f, 
    0.13934223f, -0.06430215f, 0.16117521f, -0.04468767f, -0.13099515f, -0.14041230f, 0.10595562f, 0.10409051f, 
    -0.13517918f, 0.22039913f, -0.13737226f, 0.03644026f, 0.02458770f, 0.03134811f, -0.04709976f, 0.07401807f, 
    0.13072011f, 0.06471279f, 0.13916488f, 0.08300238f, 0.17164771f, 0.10139643f, 0.19826292f, 0.03077864f, 
    -0.01094840f, -0.01072514f, 0.05391579f, -0.12972017f, 0.01674439f, 0.19361916f, -0.05378715f, 0.07123186f, 
    0.09906477f, 0.06620216f, -0.20860657f, 0.02002325f, -0.24074432f, -0.11150247f, 0.26862228f, 0.09791026f, 
    0.08771981f, -0.04406020f, 0.06721655f, 0.04728372f, -0.21028976f, 0.03976065f, -0.07080521f, -0.06052462f, 
    -0.13075069f, -0.00611696f, 0.10583426f, 0.14444780f, -0.07503976f, -0.01590248f, -0.45526633f, -0.31103969f, 
    -0.10987610f, -0.08212321f, -0.00889810f, -0.06666500f, -0.01539381f, 0.16172500f, 0.06603938f, -0.04569779f, 
    0.21530072f, 0.32305527f, 0.05878950f, -0.09926271f, -0.05791767f, -0.16391890f, -0.09659859f, -0.00097954f, 
    -0.20436376f, 0.05135882f, -0.10077871f, -0.01473577f, 0.02653549f, -0.00026611f, -0.00618172f, -0.10538366f, 
    0.05082025f, 0.02727650f, -0.18186535f, -0.07985150f, 0.10189972f, 0.12349105f, 0.09283637f, 0.25149983f, 
    0.01443029f, -0.01198096f, 0.27651295f, -0.14649494f, 0.07819500f, 0.00953109f, -0.00991252f, 0.12120549f, 
    0.14914809f, 0.02588107f, 0.02283375f, -0.31720802f, -0.05819226f, 0.24145395f, -0.18714221f, 0.13830073f, 
    0.11056821f, -0.00373442f, -0.11568576f, -0.15831672f, 0.08371884f, 0.11526566f, -0.10160046f, -0.07184480f, 
    0.04291777f, -0.01500358f, 0.26312250f, -0.27215523f, 0.05668421f, -0.07024456f, -0.10058618f, -0.24929771f, 
    -0.00041072f, 0.03872267f, -0.09751286f, -0.11566415f, -0.03150417f, -0.12378033f, 0.08378731f, 0.05179713f, 
    -0.02227915f, 0.04158171f, 0.07428522f, 0.01341498f, 0.10796759f, -0.07360857f, -0.12640156f, -0.22956492f, 
    -0.61825085f, -0.22577095f, 0.03603607f, 0.03427362f, 0.01121349f, -0.01572103f, -0.01562062f, -0.07899972f, 
    0.15777592f, -0.04557955f, 0.00446942f, -0.10234106f, -0.06499813f, 0.01680151f, -0.13923739f, -0.01969526f, 
    0.03260777f, 0.03321331f, -0.06291307f, -0.08203182f, -0.09028624f, 0.03971257f, 0.15871775f, 0.12517987f, 
    0.01897650f, 0.06040803f, 0.21433336f, 0.23513782f, 0.20722479f, 0.04816983f, 0.04545282f, -0.02503875f, 
    0.04744739f, 0.03775404f, -0.04727077f, -0.46597770f, 0.02181591f, 0.02776435f, 0.08971773f, 0.11649096f, 
    0.04725804f, -0.03090002f, -0.02772952f, 0.09986729f, -0.05715205f, -0.15114006f, -0.12305848f, -0.06716910f, 
    0.20708026f, 0.09293369f, 0.07882614f, 0.10553393f, -0.06018335f, 0.12844586f, 0.07971191f, 0.07409143f, 
    0.05811200f, -0.01912623f, 0.04350531f, -0.09310374f, -0.05252818f, -0.05130243f, 0.36682352f, -0.16009742f, 
    -0.20042540f, -0.03756789f, 0.02813898f, -0.04842621f, -0.05849939f, -0.17943186f, 0.01552884f, 0.04301969f, 
    0.11024779f, -0.03696648f, 0.03896354f, 0.13528630f, 0.07249232f, -0.08264966f, -0.12118446f, 0.03348781f, 
    -0.06013918f, 0.15218835f, -0.16825764f, 0.01438327f, -0.05102533f, 0.02204427f, -0.06622578f, 0.04879694f, 
    -0.07267834f, 0.19749732f, -0.02603844f, -0.19579476f, -0.17273773f, -0.03981091f, 0.02886614f, 0.03563592f, 
    0.09456508f, -0.00017207f, -0.13506638f, -0.21918976f, -0.09123155f, 0.00924206f, 0.06050207f, -0.02724958f, 
    0.04870934f, -0.00210063f, 0.22883429f, 0.05137457f, 0.10082048f, -0.09377038f, 0.17118256f, 0.00873556f, 
    0.15502030f, 0.02779724f, 0.14590815f, -0.03170277f, -0.23654418f, -0.10318124f, -0.17608967f, 0.15787490f, 
    0.10986363f, -0.05540228f, -0.18210475f, 0.02253389f, 0.07443466f, 0.06009500f, 0.18459296f, -0.03532593f, 
    -0.08283588f, -0.03319621f, 0.00580119f, 0.00740206f, 0.03356782f, -0.10842955f, 0.17613196f, 0.17115685f, 
    0.06263255f, -0.19222085f, -0.05043071f, 0.06372291f, 0.06074012f, 0.10196183f, 0.05119572f, 0.23191793f, 
    0.06357502f, 0.08652664f, -0.20456289f, 0.00529780f, -0.00566102f, 0.00317411f, 0.08094663f, 0.00558092f, 
    -0.27105159f, -0.22567497f, -0.19580266f, -0.12897649f, -0.06866807f, -0.08546104f, 0.04944690f, -0.04672353f, 
    0.03676378f, 0.05361924f, -0.01592728f, -0.02259260f, -0.06320031f, 0.05634475f, -0.05329385f, -0.00390055f, 
    0.09322839f, 0.05496177f, -0.32486537f, -0.14484869f, -0.00261501f, -0.01817240f, -0.17673045f, 0.04703002f, 
    -0.06759404f, 0.02385560f, 0.10118413f, 0.07922690f, -0.23157173f, -0.15543093f, 0.18614055f, 0.04163914f, 
    -0.02823471f, 0.01711984f, 0.04870776f, -0.04048436f, 0.04431466f, -0.01697365f, -0.00012929f, -0.04992281f, 
    -0.12787478f, 0.21986233f, 0.17066638f, 0.08221371f, 0.04851349f, 0.16133814f, -0.08669493f, 0.14468431f, 
    -0.12164472f, 0.08697744f, 0.09459166f, 0.09909670f, -0.04195358f, 0.12730862f, 0.10602060f, -0.04141993f, 
    -0.00802305f, 0.03932087f, 0.15505692f, -0.03441201f, -0.05210683f, -0.09263380f, -0.11760280f, -0.17645162f, 
    -0.09181397f, -0.05948385f, -0.01916838f, 0.13632326f, -0.01122265f, 0.11471904f, -0.02580219f, -0.27282831f, 
    0.05226745f, 0.26342362f, -0.04112104f, -0.07057235f, 0.19137603f, -0.14730805f, 0.09535350f, -0.03492601f, 
    -0.06039772f, -0.23831931f, -0.06506999f, -0.28596556f, 0.05887881f, -0.06694905f, -0.02244138f, 0.02998526f, 
    0.15331104f, 0.22803412f, -0.27410230f, -0.02933052f, -0.03594518f, 0.04796238f, 0.10004196f, 0.01241591f, 
    0.00599572f, 0.05763046f, 0.06906738f, 0.08930126f, -0.14987588f, -0.04705461f, -0.02113467f, 0.10287236f, 
    -0.06761186f, -0.31206661f, -0.04166226f, -0.13147883f, 0.02185196f, 0.00191360f, -0.03619921f, -0.18802734f, 
    0.18235126f, 0.11054110f, 0.19110155f, -0.03559062f, 0.08362591f, 0.11609825f, 0.03059823f, -0.01322352f, 
    0.13007690f, -0.07008006f, 0.12583983f, 0.00584090f, 0.08680733f, 0.01226591f, 0.19585949f, 0.04364789f, 
    -0.06311411f, 0.01985897f, 0.03340133f, 0.10598943f, -0.09942372f, -0.08931638f, 0.01432103f, 0.01341485f, 
    0.12844582f, 0.00736858f, 0.11771980f, 0.05608662f, -0.02354981f, 0.16020709f, 0.00419828f, 0.17609036f, 
    0.08364186f, 0.16691960f, 0.18331999f, -0.01095658f, 0.09017768f, 0.04397731f, -0.10863149f, -0.06340059f, 
    -0.09212920f, -0.60429329f, 0.08941325f, 0.09125566f, 0.14712238f, -0.06281544f, -0.10726038f, -0.00430313f, 
    0.06903139f, 0.08380087f, -0.25585786f, -0.03936226f, -0.03344491f, 0.15880182f, 0.03299091f, 0.04350102f, 
    0.07286631f, 0.20397218f, -0.04674647f, 0.29928136f, 0.15058817f, 0.08943380f, -0.17233202f, 0.03024356f, 
    0.10818663f, 0.10067977f, -0.03934789f, 0.03642409f, -0.05205685f, -0.05078562f, 0.03343554f, 0.11837837f, 
    -0.06738598f, -0.01229398f, 0.03308731f, 0.04529324f, -0.05821624f, -0.02981202f, -0.01347314f, -0.00381525f, 
    0.08930599f, 0.07743468f, -0.04441988f, -0.28390035f, -0.02308845f, -0.08446365f, 0.04774587f, 0.04636929f, 
    0.05414188f, -0.01834508f, -0.10221950f, 0.07217696f, 0.05705461f, 0.10081837f, -0.03749653f, -0.00807055f, 
    -0.05809340f, -0.03650318f, 0.00602200f, -0.11563299f, 0.01633253f, -0.02791033f, -0.08663893f, -0.16371168f, 
    -0.00150007f, 0.17087537f, -0.41486949f, -0.03909072f, 0.06976344f, -0.03465541f, 0.06318358f, -0.12075257f, 
    -0.14894629f, -0.09516564f, 0.02125581f, -0.23788026f, 0.02395440f, -0.01516671f, 0.08867539f, -0.02220387f, 
    0.02842748f, 0.02643172f, -0.18344307f, 0.02573333f, 0.04629092f, 0.07985806f, 0.07950748f, 0.12818207f, 
    -0.06579237f, -0.00187649f, 0.10679043f, -0.03482934f, 0.12136556f, 0.13335326f, -0.03424436f, 0.01051806f, 
    0.00816513f, -0.04549194f, 0.09410937f, 0.12404709f, -0.20085038f, -0.16004691f, 0.04142888f, 0.01887342f, 
    0.14754888f, 0.05515939f, -0.06923572f, -0.03352577f, 0.00479074f, -0.26928875f, -0.21906053f, 0.13937339f, 
    -0.22993204f, 0.14713502f, -0.01448292f, -0.09732399f, 0.09914136f, 0.12287956f, 0.23334968f, 0.03326729f, 
    0.18981676f, -0.00502537f, -0.18714531f, -0.00451449f, 0.10521977f, 0.03995025f, -0.11779353f, 0.26448449f, 
    -0.08683190f, 0.17766495f, 0.07358674f, 0.14340018f, -0.10975631f, 0.12183999f, 0.06358772f, 0.05883141f, 
    0.21521464f, -0.06255516f, -0.01993859f, -0.09562615f, -0.08894864f, 0.03720141f, 0.07617871f, 0.00067923f, 
    -0.01731535f, 0.09517270f, 0.14545265f, 0.10270806f, -0.02011438f, -0.08236202f, 0.08328617f, -0.02984301f, 
    -0.07486098f, 0.19415930f, -0.31405726f, 0.09494838f, -0.07623961f, -0.09569041f, 0.04264799f, 0.20711379f, 
    -0.00826620f, 0.04509690f, 0.01663807f, 0.01038330f, -0.36910459f, 0.14082462f, -0.15832870f, 0.03700874f, 
    0.17322001f, -0.05656247f, 0.11752256f, -0.08876086f, -0.00998864f, -0.16320252f, -0.27272981f, 0.21601924f, 
    -0.15193129f, -0.08012044f, 0.06930888f, 0.06447741f, -0.07861714f, -0.03270181f, -0.08172117f, -0.03360482f, 
    0.01788874f, 0.04947734f, 0.12385277f, 0.09236457f, -0.03293587f, -0.01287800f, 0.23979735f, 0.08592584f, 
    0.10756363f, 0.16636038f, -0.04622187f, 0.07224042f, 0.10270317f, -0.04756333f, -0.07807685f, 0.14652516f, 
    -0.11823095f, 0.07018983f, -0.15445775f, 0.17855830f, -0.08704775f, -0.11337100f, 0.03482427f, 0.05549848f, 
    0.07736005f, 0.22800411f, 0.23188248f, -0.09517395f, -0.16148710f, 0.03532413f, 0.01866157f, 0.00883420f, 
    0.20002230f, 0.02583443f, -0.10661826f, -0.02473392f, -0.08556451f, -0.03062765f, -0.00044548f, -0.05783551f, 
    -0.03018728f, 0.04006371f, -0.17410587f, 0.06365272f, -0.11197622f, -0.09426441f, 0.06248510f, 0.02730404f, 
    0.05522038f, 0.01592009f, 0.09004364f, -0.20585394f, -0.26764515f, -0.35739589f, 0.01479766f, 0.05121540f, 
    -0.04916416f, -0.04896092f, 0.07191944f, -0.07487904f, -0.06459992f, -0.00805014f, -0.06323785f, -0.04630532f, 
    0.05804368f, 0.05765936f, -0.11166090f, -0.12741202f, -0.07961171f, 0.20536897f, -0.25796404f, 0.11175354f, 
    0.08894690f, -0.16240442f, -0.06925317f, -0.03848813f, -0.05655511f, -0.05467657f, 0.03476800f, -0.47042769f, 
    -0.09442762f, 0.08152148f, 0.00326907f, -0.17248768f, -0.07948234f, 0.01750485f, 0.10592867f, 0.35868981f, 
    0.19228153f, 0.15184540f, -0.14139622f, -0.11518264f, 0.11803707f, -0.08344173f, 0.04232900f, -0.16451831f, 
    -0.18615866f, 0.02237374f, 0.04058553f, 0.03848888f, 0.02849696f, 0.04163010f, -0.19107205f, 0.06104871f, 
    0.04523213f, -0.39346629f, 0.28698608f, 0.02905106f, -0.08511611f, -0.12059072f, -0.01496069f, -0.10313740f, 
    0.04853928f, 0.07902703f, -0.05557306f, 0.24022828f, -0.04346646f, 0.07691859f, 0.05655520f, 0.12226085f, 
    0.08613868f, 0.00311113f, -0.09638814f, 0.15998368f, 0.18675350f, 0.06734708f, 0.10086577f, -0.09190615f, 
    -0.14076649f, -0.03160918f, -0.01916515f, 0.13898483f, 0.41124302f, -0.02947749f, 0.11695678f, -0.22497247f, 
    0.02637893f, 0.13046536f, -0.03796021f, -0.00930102f, 0.07867797f, -0.13530801f, -0.10830035f, -0.13889062f, 
    0.02860627f, 0.07982301f, 0.02931396f, -0.10057726f, -0.08318208f, -0.07420034f, 0.10463821f, -0.05874243f, 
    0.04518743f, -0.06811502f, -0.06816393f, -0.02591549f, -0.05990094f, -0.01735662f, -0.18719913f, -0.13280886f, 
    -0.20563765f, -0.03892404f, 0.03709662f, 0.05383369f, 0.04533026f, -0.23402970f, -0.09024790f, -0.08093844f, 
    0.28899592f, 0.13273895f, -0.21334086f, -0.27903420f, -0.04623156f, -0.03668237f, -0.10185240f, 0.07258070f, 
    -0.01754703f, 0.06779030f, -0.02159577f, -0.06592362f, -0.00155510f, 0.08868963f, -0.01322395f, 0.10557419f, 
    0.03936049f, 0.15366785f, 0.14849095f, 0.19329986f, 0.16562738f, -0.01247265f, 0.07794821f, 0.10603632f, 
    0.00332315f, -0.19800539f, 0.16298531f, -0.25173497f, -0.09953659f, 0.07598974f, 0.01190270f, 0.15011564f, 
    0.19817315f, -0.05135574f, -0.07852594f, -0.05739661f, 0.31822467f, -0.02504503f, 0.11326887f, -0.01186673f, 
    0.17297557f, 0.07599576f, 0.03723627f, -0.06213068f, 0.16953474f, -0.02925932f, -0.05499322f, -0.64252025f, 
    -0.17120641f, 0.02238254f, -0.05598397f, 0.13473566f, 0.10054511f, 0.12856077f, -0.15190072f, -0.00699523f, 
    -0.04602189f, 0.18035834f, 0.07561329f, -0.00198834f, 0.04386241f, -0.07124072f, -0.06673911f, -0.05468195f, 
    0.29432517f, -0.23722075f, 0.05159215f, 0.01751565f, -0.00159129f, -0.06975050f, 0.05758242f, 0.04389213f, 
    -0.03437634f, -0.05865012f, 0.10518138f, -0.08348887f, 0.06514324f, -0.15786186f, -0.01914483f, 0.02835904f, 
    -0.12041444f, 0.01837711f, -0.03992098f, 0.16687113f, 0.07588614f, 0.11796703f, 0.10103460f, 0.07983267f, 
    -0.04418238f, 0.09344557f, 0.09369653f, 0.13091268f, 0.02378843f, 0.08783681f, 0.17661917f, 0.06105843f, 
    0.14946850f, -0.02745556f, 0.13808438f, 0.06322398f, 0.09180328f, 0.16183107f, -0.05672601f, -0.06921438f, 
    -0.19520544f, -0.08468598f, 0.00389988f, 0.01246180f, -0.06460453f, 0.04581075f, 0.05465576f, -0.02214036f, 
    -0.00492308f, -0.04021310f, 0.11933681f, 0.08651949f, 0.20347461f, 0.00205654f, 0.09125067f, 0.09838638f, 
    0.06984255f, -0.10777206f, -0.04397853f, 0.05318847f, 0.01937446f, -0.06791736f, -0.23516679f, -0.18717049f, 
    0.02821319f, 0.06891464f, -0.01395928f, 0.09770866f, -0.08437265f, -0.10351185f, -0.06164368f, -0.14806980f, 
    0.02781196f, 0.32964465f, -0.15134706f, 0.05555309f, 0.05109191f, -0.09249875f, -0.06778499f, 0.07395486f, 
    -0.22398728f, -0.02960137f, -0.22016387f, -0.11653138f, 0.15426919f, 0.01001446f, -0.21297406f, 0.01904636f, 
    0.01674701f, 0.08071315f, -0.14114642f, 0.07648104f, 0.14645495f, 0.12622815f, 0.06094164f, 0.02695566f, 
    -0.15210862f, 0.02997885f, -0.14186445f, -0.05726291f, 0.34180942f, 0.06316584f, 0.19349644f, 0.15441528f, 
    0.08298201f, 0.12846495f, -0.03983910f, -0.03728903f, -0.08718878f, 0.09885011f, -0.15209281f, -0.12105577f, 
    -0.21165530f, 0.14032044f, -0.01486349f, -0.01560715f, -0.03636715f, 0.01264650f, -0.01415531f, -0.02213937f, 
    0.11987209f, 0.03733825f, 0.03718264f, 0.01069250f, 0.11788598f, -0.01415984f, -0.03781492f, -0.44329256f, 
    0.14304948f, 0.04270497f, 0.04374873f, 0.01888483f, 0.06056497f, 0.20145470f, 0.12821047f, -0.00065084f, 
    -0.25773284f, 0.10992353f, -0.03384129f, -0.09422943f, 0.22338910f, 0.10681096f, -0.02266228f, -0.51498979f, 
    -0.40317073f, -0.12589811f, 0.11249480f, -0.09018562f, -0.00125382f, 0.05992747f, -0.04431576f, -0.02676637f, 
    0.14221369f, 0.11575583f, -0.13697669f, -0.08581908f, 0.05733942f, -0.03074714f, 0.07843935f, 0.03261223f, 
    0.06699941f, -0.35475150f, -0.13844453f, -0.18498126f, 0.00347668f, 0.00372929f, 0.08995894f, -0.00543810f, 
    -0.03188396f, -0.04442194f, 0.13268688f, 0.16528670f, 0.14371425f, -0.15123819f, 0.16964141f, -0.01043849f, 
    -0.11378546f, -0.01414020f, -0.01134203f, -0.28912672f, -0.28309810f, 0.08061011f, 0.07491048f, 0.12747531f, 
    0.05813184f, 0.00950282f, -0.04636123f, -0.02444468f, -0.18695474f, -0.13850397f, -0.03643429f, 0.17578810f, 
    0.00632532f, -0.15762366f, 0.10598893f, 0.10195377f, -0.02678270f, 0.23195639f, 0.00535333f, -0.05977321f, 
    0.00435199f, -0.00485349f, -0.11298164f, -0.03001707f, 0.10432403f, 0.15991324f, 0.00599123f, 0.03702190f, 
    -0.27801859f, -0.01393855f, -0.14727570f, 0.13080701f, -0.08273096f, 0.07793419f, -0.01581067f, 0.09293545f, 
    -0.11815076f, -0.07768138f, 0.00938707f, -0.01206726f, 0.00089471f, -0.06484249f, -0.02703076f, -0.10331618f, 
    -0.00463588f, 0.02265742f, 0.03224655f, 0.02166361f, -0.00671243f, 0.04033687f, -0.03921566f, 0.03860673f, 
    0.03481553f, 0.03279687f, 0.00995949f, -0.00774924f, -0.03495515f, -0.05205478f, -0.02699801f, 0.00817622f, 
    0.01563434f, 0.02560247f, -0.05221847f, -0.02927623f, -0.01717882f, 0.00691733f, -0.03280659f, 0.01675107f, 
    0.02214249f, -0.01584333f, 0.00364407f, 0.00655208f, 0.03289817f, 0.02725213f, -0.02115168f, -0.05573821f, 
    -0.05740096f, 0.02107879f, 0.00869240f, 0.04620197f, -0.02458586f, 0.04190129f, 0.02493436f, -0.02258931f, 
    0.00144130f, 0.00233596f, -0.05843105f, -0.02855898f, -0.04425682f, -0.06050814f, -0.01098504f, -0.02616859f, 
    -0.06193244f, -0.00054196f, -0.04972802f, -0.05506980f, 0.00591540f, 0.05010401f, -0.03009531f, -0.06335872f, 
    -0.04741734f, 0.03496420f, 0.02930711f, -0.02038914f, 0.02920309f, -0.04928714f, 0.02267354f, -0.05425127f, 
    0.00582691f, -0.03050099f, -0.04780951f, 0.04818429f, 0.04132127f, -0.05062468f, 0.00463753f, -0.04531879f, 
    -0.01512600f, 0.02793892f, -0.02033967f, -0.04637998f, 0.01375890f, -0.05948043f, -0.04906966f, -0.03970120f, 
    -0.05956265f, -0.03887895f, -0.04749864f, -0.05861945f, -0.00087049f, 0.01934583f, -0.00890182f, 0.00896314f, 
    -0.02755556f, -0.02069035f, 0.02818938f, 0.01690171f, 0.04464782f, 0.03834328f, -0.06906752f, -0.06590673f, 
    0.02172493f, 0.04416491f, -0.04647824f, -0.04018792f, -0.02063220f, 0.00564310f, 0.02525507f, -0.05411668f, 
    -0.03599895f, 0.02585396f, 0.02104861f, -0.05432729f, -0.02758026f, 0.03651023f, 0.04224567f, 0.03451924f, 
    0.00862165f, -0.01398069f, -0.00738303f, -0.00655288f, -0.04945791f, -0.06570969f, -0.02267358f, -0.02658793f, 
    -0.04489930f, -0.04348758f, -0.05603123f, -0.02471999f, -0.05609197f, -0.03038200f, 0.04296396f, -0.04938499f, 
    -0.05266499f, 0.05637715f, 0.01504960f, -0.01453339f, -0.04818808f, -0.03376377f, -0.00565283f, -0.04157337f, 
    0.02369043f, 0.03398201f, -0.05750000f, 0.02382112f, -0.04959011f, 0.04192946f, 0.01769703f, -0.05016315f, 
    0.03755210f, -0.06148069f, 0.03185191f, -0.02494209f, -0.01552216f, 0.02866305f, 0.02823083f, -0.01792939f, 
    -0.03616690f, 0.01479996f, 0.00632649f, -0.00487130f, 0.04139405f, 0.05334323f, 0.04854261f, -0.05081272f, 
    0.02124839f, 0.01427824f, -0.00255443f, -0.05899454f, 0.00996246f, 0.01459799f, -0.02135322f, 0.03064594f, 
    0.03613023f, 0.02386023f, -0.03264920f, -0.01254783f, 0.01477041f, -0.00282268f, 0.04339116f, 0.01911206f, 
    0.04137553f, 0.00761990f, 0.03318745f, 0.02831651f, -0.03974748f, -0.00096907f, 0.02434327f, -0.05633745f, 
    0.03244209f, -0.05407834f, -0.06438697f, 0.02409866f, -0.04546663f, 0.02415083f, 0.03668062f, -0.02656208f, 
    0.01161943f, 0.03541754f, -0.05968846f, 0.03712698f, -0.01837131f, -0.06507090f, 0.03342681f, -0.04034278f, 
    -0.01930172f, 0.00339517f, 0.02887218f, -0.06449677f, -0.04932537f, -0.01925121f, 0.01539524f, -0.02886368f, 
    0.03009183f, 0.04346265f, -0.01987436f, -0.05360955f, -0.03590940f, 0.03534201f, -0.02520923f, -0.06293255f, 
    -0.06559148f, -0.05312590f, -0.04172298f, -0.04361110f, 0.00789412f, -0.06010071f, 0.04584236f, 0.02682631f, 
    -0.05491137f, -0.01043798f, 0.03731902f, 0.01936782f, -0.00198216f, 0.00930672f, -0.00842180f, 0.03999026f, 
    0.00282045f, -0.02709386f, 0.01208207f, 0.03454829f, -0.01333427f, 0.01491499f, -0.02706732f, -0.03076206f, 
    0.04299242f, -0.05818907f, 0.03903837f, 0.01428306f, 0.00986884f, -0.06052797f, 0.01870601f, 0.03651114f, 
    -0.00705493f, -0.01559943f, -0.03189777f, -0.00050321f, 0.00857281f, 0.02285135f, 0.00017265f, 0.00849639f, 
    -0.05523260f, -0.02007331f, -0.01346317f, 0.03974903f, -0.02499416f, 0.04430023f, -0.02486936f, 0.02261698f, 
    -0.01099556f, 0.02010715f, 0.03164250f, -0.02204921f, -0.02724061f, 0.03802301f, 0.01940066f, -0.03825754f, 
    0.03183599f, -0.05115972f, 0.04786634f, -0.05030596f, 0.04367187f, -0.02856237f, -0.03512083f, -0.01615510f, 
    0.02694000f, -0.02512982f, 0.03400083f, -0.03677278f, 0.00458760f, -0.03638068f, 0.03020639f, -0.05312768f, 
    -0.01029053f, -0.00637465f, -0.05805509f, 0.00135247f, -0.02698233f, 0.04700641f, -0.05148378f, -0.02465456f, 
    -0.00292918f, 0.03385080f, 0.01327368f, 0.02086901f, -0.02238095f, 0.04537643f, -0.00964011f, -0.05483679f, 
    -0.02349071f, -0.02237478f, -0.06227932f, -0.06301557f, -0.06378116f, -0.00974768f, 0.03706415f, 0.00546897f, 
    0.03580153f, -0.00897548f, -0.00563545f, 0.04814249f, 0.02491144f, 0.00295822f, -0.03366375f, 0.01253001f, 
    -0.00988591f, 0.01013545f, -0.00779864f, -0.01644638f, -0.02494163f, -0.03690997f, -0.00308687f, -0.02012399f, 
    0.04003841f, -0.06022888f, 0.04829889f, 0.00742069f, 0.00150614f, -0.03510031f, -0.03220324f, -0.06370153f, 
    0.03463954f, -0.02122698f, 0.04193115f, -0.02874898f, 0.01304520f, 0.02809169f, -0.03225359f, 0.03523510f, 
    -0.05898005f, -0.05488882f, 0.02211899f, 0.03885386f, -0.00202384f, 0.04685150f, -0.02306578f, -0.02491363f, 
    -0.05210188f, 0.02410628f, 0.01548827f, 0.00494129f, -0.04070014f, 0.02697322f, 0.02884706f, 0.01753959f, 
    -0.04355223f, 0.05707581f, 0.03115983f, -0.01339684f, 0.01789760f, -0.05215441f, -0.01214923f, 0.00704362f, 
    0.00867410f, -0.03566575f, 0.00776542f, -0.05034163f, 0.03524791f, -0.03203989f, -0.03485538f, -0.03811629f, 
    0.02452283f, -0.05351253f, 0.03858460f, -0.01071471f, -0.05822726f, -0.03104562f, -0.02439775f, -0.04754453f, 
    0.05191991f, -0.01393447f, 0.03706969f, 0.04654878f, -0.05786683f, -0.00063724f, -0.06385314f, -0.05377387f, 
    0.01341807f, -0.06232093f, -0.03639605f, 0.03968661f, -0.05805323f, -0.01314423f, -0.00662340f, -0.05574854f, 
    -0.02840398f, 0.04530713f, -0.01170679f, -0.03130406f, -0.01015044f, -0.03281134f, 0.00982255f, -0.04731731f, 
    0.04534090f, -0.04201771f, -0.00288173f, 0.04033239f, -0.02452038f, 0.02544503f, 0.01653297f, -0.03486266f, 
    0.02091704f, 0.00518038f, 0.02154102f, -0.00253320f, -0.05018738f, -0.03473637f, -0.04847498f, 0.04423479f, 
    0.00091216f, 0.02632295f, -0.00254812f, 0.01728491f, -0.00497658f, 0.03463800f, 0.01483869f, -0.01653410f, 
    -0.01158312f, -0.01550139f, 0.01717998f, -0.02631621f, 0.00798457f, 0.03818334f, -0.02716812f, 0.04283736f, 
    -0.03298462f, 0.03171368f, -0.04161336f, 0.03057951f, 0.01605027f, 0.04564610f, 0.03075270f, 0.03237432f, 
    -0.06205736f, -0.03714266f, -0.06353893f, 0.05322430f, -0.01195963f, -0.04615440f, 0.01362169f, -0.02895378f, 
    0.02190202f, -0.03746941f, -0.00248939f, -0.04042271f, 0.00661715f, -0.06367210f, -0.01342650f, -0.01527658f, 
    0.04584847f, 0.04014166f, -0.01199778f, -0.03474193f, -0.01084598f, -0.05359923f, 0.04351464f, 0.05271105f, 
    0.05147425f, -0.05215538f, -0.03674026f, -0.06097820f, 0.03106905f, -0.02120770f, -0.04252138f, -0.01565680f, 
    -0.03925452f, -0.02434836f, -0.04909799f, -0.05447122f, -0.00241312f, -0.01229106f, -0.00751876f, -0.00101325f, 
    -0.06414514f, -0.00852141f, -0.05855552f, -0.00531853f, -0.00162116f, -0.01440943f, 0.03431228f, -0.02525430f, 
    -0.01450044f, -0.04394193f, -0.02234688f, -0.05910883f, 0.05333138f, -0.01612409f, 0.00405804f, -0.03591121f, 
    0.03536421f, -0.02454459f, -0.05742084f, -0.00394629f, 0.03251378f, 0.00117205f, -0.03441461f, 0.02788086f, 
    -0.05361602f, 0.04128959f, 0.03992517f, -0.04054119f, -0.00306804f, 0.02916433f, 0.02308724f, 0.03297627f, 
    -0.02734786f, 0.01771291f, -0.01694623f, -0.05070609f, -0.04903851f, -0.03136184f, -0.05839717f, -0.01136464f, 
    0.02502792f, 0.04837776f, 0.05071009f, -0.05423132f, -0.01600609f, 0.04821271f, 0.01136168f, -0.06218399f, 
    0.02381626f, 0.02142334f, -0.02881395f, -0.01669103f, 0.00071775f, 0.01748825f, -0.05043971f, -0.02381485f, 
    0.01403207f, 0.00450484f, -0.01556203f, -0.03677887f, -0.01692864f, 0.02330038f, 0.04502467f, -0.02918110f, 
    -0.02134853f, 0.02075521f, -0.03428975f, -0.03180502f, -0.04992908f, 0.00207663f, 0.03913085f, 0.03145690f, 
    -0.01087873f, 0.01057543f, -0.00865604f, -0.01861712f, -0.04120258f, -0.05186603f, 0.02115181f, 0.03346876f, 
    -0.06405834f, -0.03182385f, 0.02887617f, -0.04046813f, 0.00946497f, -0.03792968f, -0.05718049f, -0.00787881f, 
    0.08584478f, 0.07943354f, 0.11088746f, 0.07521819f, -0.02181487f, -0.11159252f, 0.08264584f, -0.05356308f, 
    -0.06309858f, -0.02864983f, 0.10023435f, 0.11088932f, -0.03405965f, 0.00478732f, -0.20704781f, 0.04225663f, 
    0.16315275f, 0.13868687f, -0.29676130f, -0.05982089f, 0.12389112f, 0.03853562f, 0.00714965f, -0.06664159f, 
    -0.02631272f, 0.13149489f, -0.13835202f, -0.08246265f, -0.47534934f, -0.12124414f, 0.09685813f, -0.07362759f, 
    -0.01029206f, 0.15093739f, -0.05507978f, -0.04365099f, -0.15709285f, 0.07763179f, 0.07271110f, 0.05319572f, 
    0.01633977f, -0.00050397f, 0.05227125f, 0.06000024f, 0.01235793f, -0.01693191f, -0.01918878f, 0.18325014f, 
    -0.10132708f, -0.07387637f, 0.08315661f, 0.02344857f, -0.11808010f, 0.18292178f, 0.01701855f, 0.13835429f, 
    0.14663193f, 0.01433967f, -0.11421122f, -0.01160441f, 0.00148398f, 0.11798953f, -0.02755183f, 0.00587369f, 
    -0.15819280f, 0.10215067f, -0.15800118f, 0.03368104f, 0.20049575f, -0.04906689f, 0.01386257f, 0.15304036f, 
    -0.21991919f, -0.27063528f, -0.21921851f, -0.03476004f, -0.14918287f, -0.01698881f, 0.02331869f, 0.06650409f, 
    -0.03986293f, -0.20791617f, -0.00968636f, 0.14562966f, -0.02068538f, 0.10824413f, 0.17100325f, 0.22589563f, 
    0.03737174f, -0.12361015f, -0.40278026f, -0.04148335f, 0.18726200f, 0.07987613f, 0.05400192f, -0.02898640f, 
    -0.02478742f, -0.02960840f, -0.10473404f, 0.13223517f, -0.00820956f, -0.16476116f, -0.17119186f, 0.11931558f, 
    0.09162478f, 0.10218925f, -0.06150552f, -0.08240961f, 0.05351277f, 0.15303272f, -0.01147172f, 0.00832493f, 
    -0.16765979f, 0.08222800f, -0.07056908f, -0.12474936f, 0.23826610f, -0.22995147f, -0.13265738f, -0.04660088f, 
    -0.02494475f, 0.11630765f, -0.15491821f, -0.03999737f, 0.14766593f, 0.10646857f, 0.22330345f, -0.29718357f, 
    -0.18290946f, -0.01814203f, -0.02537185f, 0.13925028f, 0.09149867f, 0.02195183f, -0.04169412f, -0.02924530f, 
    -0.20103170f, -0.05748171f, 0.04973767f, 0.08600114f, 0.12347025f, 0.13899598f, -0.02287574f, -0.03239677f, 
    0.04985762f, -0.39257365f, -0.09465947f, 0.06248550f, 0.16609327f, 0.05094894f, -0.09180900f, 0.07203471f, 
    -0.04807585f, -0.22173028f, -0.06278937f, -0.21547927f, 0.15954936f, -0.05726862f, -0.04032276f, 0.18949144f, 
    0.08253263f, 0.11011466f, -0.02246135f, 0.05311357f, 0.06312162f, 0.08005675f, -0.02670895f, 0.34168416f, 
    -0.02173967f, 0.04348485f, 0.01680475f, 0.25018638f, 0.32922813f, 0.04979953f, -0.01023233f, 0.09780793f, 
    -0.19223686f, 0.04323167f, 0.02908296f, -0.08683266f, -0.02817684f, -0.01294580f, 0.04149145f, 0.05483169f, 
    0.02235931f, -0.10943840f, -0.17386048f, 0.00494666f, 0.03751438f, 0.10836158f, 0.04348438f, 0.32373384f, 
    0.04860243f, -0.09662943f, 0.12974674f, 0.10175058f, 0.01525954f, -0.03515816f, 0.17218968f, 0.19286650f, 
    0.17575264f, 0.12377742f, -0.00175796f, 0.09152213f, 0.05608878f, -0.13415666f, 0.10980028f, 0.25600770f, 
    -0.27378654f, -0.31498426f, -0.08210889f, -0.07180451f, 0.19617604f, 0.01667902f, 0.00341172f, -0.23613928f, 
    -0.29158428f, 0.12588435f, 0.36305305f, -0.01386865f, 0.06134968f, -0.22647366f, 0.20962116f, 0.03711153f, 
    0.03308523f, 0.10359735f, 0.13943671f, -0.03004503f, -0.10122816f, 0.14914665f, -0.02937759f, 0.04237374f, 
    0.08746640f, -0.05441159f, -0.37943774f, 0.28339458f, 0.17060639f, 0.10181734f, 0.05660196f, -0.10876536f, 
    0.03764387f, -0.01095196f, 0.03223225f, 0.08222070f, -0.08132317f, -0.09294485f, 0.07520857f, -0.03854852f, 
    0.06428511f, -0.08198092f, 0.02810088f, -0.04623915f, 0.11190508f, -0.00625324f, 0.08632150f, 0.06575357f, 
    -0.07405636f, 0.09165289f, -0.08717470f, -0.01348988f, -0.00486321f, 0.15927492f, 0.10211416f, 0.07998806f, 
    0.08350521f, -0.00113013f, -0.12595342f, 0.00878533f, 0.01509755f, 0.02739885f, 0.11837645f, -0.01351523f, 
    0.15331665f, 0.06892372f, -0.01511950f, -0.12832691f, -0.11791407f, -0.08014534f, 0.14715001f, -0.04453430f, 
    -0.13474968f, 0.13876571f, -0.00762340f, -0.03985791f, -0.00256325f, 0.09745815f, 0.01038137f, 0.05145933f, 
    0.09705509f, 0.17348294f, 0.06694024f, -0.02025065f, -0.00562519f, 0.06164318f, 0.00472529f, 0.07662591f, 
    -0.09292188f, 0.12127683f, -0.03420024f, -0.14901915f, -0.08534858f, 0.03425793f, 0.01255085f, -0.15893511f, 
    -0.09163010f, 0.18172704f, -0.05835941f, -0.17954864f, -0.00542880f, -0.12849782f, 0.10165552f, -0.05193357f, 
    0.05148774f, 0.02095662f, 0.18897989f, -0.26724586f, 0.03294186f, -0.14746104f, -0.02445331f, 0.14179552f, 
    0.05884068f, -0.15039508f, 0.14308397f, 0.07346000f, 0.08567775f, -0.19984627f, 0.00701360f, 0.02438982f, 
    0.14266002f, 0.11130011f, 0.01086930f, -0.12428307f, -0.02144284f, -0.14751472f, 0.04130990f, -0.43407810f, 
    -0.02491497f, -0.04043363f, -0.02915569f, 0.10960483f, 0.17558680f, -0.11775255f, 0.04716364f, 0.01167295f, 
    -0.02991432f, -0.18593563f, -0.15476602f, 0.04012698f, 0.02446867f, 0.04501649f, 0.14104909f, 0.11171378f, 
    -0.06340894f, -0.08516868f, -0.00931361f, -0.01656968f, -0.14712480f, 0.17431995f, 0.12327445f, 0.03093015f, 
    -0.23815696f, -0.13636881f, -0.03756737f, -0.01142892f, -0.25642514f, -0.10850122f, 0.03242345f, 0.11573921f, 
    0.04404775f, 0.01511102f, -0.00122380f, 0.04815447f, 0.04719819f, -0.02702384f, -0.20629169f, 0.06413170f, 
    0.09309862f, 0.13187219f, -0.08150698f, -0.14536455f, 0.00266930f, -0.00748484f, 0.01573734f, -0.08555714f, 
    0.01507705f, -0.09406374f, 0.05543959f, 0.17197777f, -0.14249560f, -0.07093380f, -0.03701608f, 0.18292618f, 
    0.04042684f, -0.05540534f, -0.23644595f, -0.23998070f, -0.14320347f, -0.01421741f, 0.16053820f, -0.13709606f, 
    0.13003729f, 0.05507236f, -0.05731725f, -0.00651947f, -0.02117290f, 0.06104940f, -0.06868651f, 0.07505823f, 
    0.01667989f, 0.09581217f, 0.10466281f, 0.00533454f, -0.12067096f, -0.11660344f, -0.04321223f, -0.06447783f, 
    -0.06992516f, 0.01652454f, 0.10605023f, -0.03707854f, 0.11862772f, -0.01139777f, -0.10812290f, 0.07863731f, 
    -0.00112892f, -0.00817189f, 0.05926728f, 0.02405583f, -0.10875378f, 0.06039805f, 0.03053490f, -0.18259542f, 
    0.15616539f, 0.01440325f, -0.23311827f, 0.11731192f, 0.06154060f, -0.18368824f, 0.19664212f, 0.12523815f, 
    0.01140250f, 0.03554682f, 0.02593180f, -0.07354999f, 0.06751750f, 0.07433923f, 0.10510797f, 0.05686687f, 
    -0.12395702f, 0.25781280f, -0.15589350f, -0.10114564f, 0.12565236f, -0.09785292f, 0.11923531f, 0.04753868f, 
    -0.03355975f, 0.16703139f, 0.07814389f, 0.12835617f, -0.09842891f, 0.01337273f, -0.08879534f, 0.01375346f, 
    0.09083337f, 0.03316015f, -0.05748428f, -0.23708650f, 0.01883440f, -0.03408109f, 0.01213873f, -0.03113542f, 
    0.01874950f, 0.18738335f, 0.01457797f, -0.09547780f, -0.00464447f, -0.07560927f, -0.02175728f, -0.08346547f, 
    -0.07306152f, -0.08513132f, 0.14602743f, -0.03030828f, -0.03216935f, 0.22335997f, 0.04405261f, 0.02183447f, 
    0.05396419f, 0.02556367f, 0.00617393f, 0.14667518f, -0.00195550f, -0.09743092f, -0.02160551f, -0.16983387f, 
    -0.20776471f, -0.04867889f, 0.16828388f, 0.02362299f, -0.03832955f, 0.14153557f, 0.04829448f, 0.09819622f, 
    0.13352104f, 0.10627891f, 0.06137473f, -0.08505568f, 0.00785769f, 0.21238659f, -0.14775902f, -0.01308069f, 
    -0.11655269f, -0.09170458f, 0.06308699f, 0.13199140f, 0.11544690f, 0.06961600f, 0.01160271f, 0.25997475f, 
    0.03798497f, 0.06211726f, -0.07597509f, -0.25030389f, -0.06733944f, 0.15872049f, 0.06732546f, 0.13893604f, 
    -0.10816491f, 0.06126644f, 0.20229088f, 0.25804344f, 0.14811432f, -0.15274665f, -0.03413489f, 0.06219219f, 
    -0.12542224f, 0.03124293f, 0.05871160f, 0.08241973f, -0.22047441f, -0.16416641f, 0.09830393f, 0.13082197f, 
    -0.22921799f, -0.02463746f, 0.05689132f, 0.03533619f, -0.18260746f, 0.09575361f, -0.10175883f, -0.02087119f, 
    -0.06624062f, 0.15952188f, 0.24972747f, -0.07762467f, -0.13756366f, -0.16939016f, 0.14318541f, 0.16354506f, 
    -0.10862036f, -0.12781887f, -0.15582648f, 0.09783368f, 0.03637161f, -0.30607730f, -0.08413131f, -0.06410866f, 
    -0.02653851f, 0.00882022f, 0.09407419f, -0.02436709f, -0.00282422f, 0.13849743f, 0.05289806f, -0.06611811f, 
    -0.05672696f, 0.14933580f, -0.14050472f, 0.02112306f, -0.00912570f, 0.00535879f, -0.03366046f, 0.03903784f, 
    0.00603903f, 0.17977819f, 0.09089091f, -0.06598046f, -0.13992463f, -0.05772439f, -0.07059211f, 0.10814600f, 
    0.00835399f, 0.12704833f, -0.13692446f, 0.05706239f, -0.04883491f, 0.04339367f, 0.03867939f, 0.11854538f, 
    0.17812085f, -0.03475900f, -0.21024896f, -0.05076702f, -0.07421714f, -0.15299204f, -0.01398182f, 0.23688051f, 
    0.18314137f, -0.00226305f, -0.10329393f, -0.09244252f, 0.37207711f, 0.10778693f, -0.15792207f, 0.04094619f, 
    -0.03830658f, -0.00546335f, 0.13766761f, -0.09439256f, -0.06363807f, 0.18666540f, -0.10574272f, 0.17695725f, 
    -0.09048721f, -0.21257375f, 0.11475838f, -0.08661807f, -0.00501341f, 0.15692843f, 0.05480177f, 0.02103564f, 
    0.13045701f, -0.11428884f, -0.06392045f, 0.02042014f, 0.08246866f, 0.00755882f, -0.05331866f, 0.06309111f, 
    0.07850409f, 0.21751592f, -0.02443575f, -0.02131475f, 0.07830365f, -0.10486060f, 0.04412232f, 0.01221003f, 
    0.08617634f, -0.17210752f, -0.02566607f, 0.23985870f, 0.13421480f, 0.08614490f, -0.01321793f, -0.00333122f, 
    -0.03042013f, -0.09850973f, -0.17607149f, -0.21525508f, 0.03795486f, 0.12868980f, 0.14000739f, 0.03393424f, 
    -0.05234787f, 0.01504983f, 0.18688546f, 0.13314994f, -0.09672436f, 0.08651450f, 0.09929678f, 0.17226890f, 
    0.03726337f, 0.05997209f, -0.10813271f, 0.04629780f, -0.13435744f, 0.12889516f, 0.16193257f, 0.07733756f, 
    0.01121815f, 0.11020411f, -0.03673283f, -0.03935444f, 0.20148847f, 0.08668513f, -0.01786664f, -0.17473483f, 
    -0.11425303f, -0.12094009f, -0.07970221f, 0.03679914f, 0.18729079f, 0.30069813f, 0.16291311f, -0.15790185f, 
    0.18193245f, -0.03561784f, -0.03804174f, 0.01815282f, 0.07562573f, -0.00610724f, -0.40392736f, -0.29675511f, 
    0.11070378f, -0.08281045f, -0.06954820f, 0.22336410f, -0.21532163f, 0.25942931f, 0.09139421f, 0.17667313f, 
    -0.02423104f, 0.01414174f, 0.22393861f, -0.01093607f, 0.20370291f, -0.15750855f, -0.02809064f, -0.07185591f, 
    -0.20364915f, -0.13968101f, 0.15215550f, 0.10493203f, 0.02330138f, 0.09468602f, -0.15701185f, -0.10151093f, 
    0.07270212f, 0.16965558f, -0.19111648f, -0.39274144f, -0.00334380f, -0.01427018f, 0.01973405f, 0.13270572f, 
    -0.18110381f, 0.03010393f, 0.28045794f, -0.16097060f, -0.05868475f, 0.07808008f, 0.04249307f, 0.08060271f, 
    0.02017284f, -0.00228266f, 0.19016977f, -0.10226580f, -0.00773635f, -0.07846140f, -0.16200498f, 0.06043344f, 
    -0.00715623f, -0.27412453f, 0.01619353f, 0.03983846f, 0.07424191f, -0.04149765f, -0.06561702f, 0.01023137f, 
    -0.04183170f, 0.02783841f, 0.12348928f, 0.01772705f, -0.12461767f, 0.14024468f, -0.09770498f, -0.00458192f, 
    0.11547713f, -0.08412734f, 0.04501260f, 0.13824835f, 0.09547129f, -0.15097623f, -0.01746779f, 0.12980738f, 
    0.07972054f, 0.08623056f, 0.04981057f, -0.02167252f, -0.02855881f, 0.14316852f, 0.05651501f, -0.07060244f, 
    -0.17325054f, -0.04250478f, 0.05229514f, 0.11004119f, 0.17150424f, 0.05430695f, 0.14525595f, -0.02305769f, 
    0.40168816f, 0.30799788f, -0.14821054f, 0.02142295f, -0.02849380f, -0.08362007f, 0.02123804f, 0.07979678f, 
    0.07857175f, -0.17035210f, -0.06889349f, -0.14014673f, 0.22080152f, -0.01964898f, -0.04049493f, -0.03940138f, 
    0.05031919f, -0.09017240f, 0.58857518f, 0.23555095f, -0.14027569f, 0.06217573f, -0.09220705f, -0.12426391f, 
    0.06451081f, -0.04570485f, 0.12878999f, -0.09859664f, -0.00693817f, 0.18693216f, -0.05779105f, 0.02314130f, 
    0.19605145f, 0.03459461f, -0.09063931f, 0.04028775f, -0.10819461f, -0.03790207f, 0.08854038f, -0.02252521f, 
    -0.02584776f, -0.02897387f, -0.09065522f, 0.14638376f, 0.01449208f, 0.30194223f, 0.06513291f, -0.30752060f, 
    0.03909455f, -0.02000652f, -0.09059521f, -0.03570900f, -0.05329233f, -0.09111140f, -0.04113386f, -0.19715993f, 
    -0.13147582f, 0.04265397f, -0.08741337f, 0.06791776f, 0.03124241f, 0.04578028f, -0.04997987f, -0.09216300f, 
    0.09422036f, 0.12504847f, -0.02442197f, -0.10329705f, 0.15318881f, -0.19090572f, -0.02066813f, 0.13634183f, 
    0.00144314f, 0.01573569f, 0.02398487f, -0.00865278f, -0.03135879f, -0.04515366f, -0.00583902f, -0.06266264f, 
    -0.04590053f, -0.04983293f, -0.02597991f, -0.03563084f, -0.04377257f, -0.05393783f, -0.03690059f, 0.01054233f, 
    -0.04142973f, 0.02241815f, 0.04798521f, 0.01012533f, 0.04008767f, 0.06201221f, 0.01213110f, 0.05147350f, 
    -0.06199169f, 0.01598198f, 0.04197095f, 0.03338509f, -0.00836252f, -0.05527516f, 0.05486266f, 0.03558756f, 
    -0.06710517f, -0.05255187f, -0.06535368f, 0.00858398f, 0.00349504f, -0.01645897f, 0.01664244f, 0.02509610f, 
    -0.01853582f, 0.00910291f, -0.05574226f, -0.01610333f, -0.00016397f, -0.00587173f, 0.02176888f, -0.08720749f, 
    -0.05171809f, -0.06451256f, 0.04515766f, 0.01802561f, -0.01789190f, 0.03748797f, -0.02908412f, -0.00633649f, 
    -0.06993493f, -0.02056571f, -0.04344792f, -0.03077375f, -0.06723135f, 0.04047333f, -0.01128567f, -0.06388669f, 
    -0.02286687f, 0.01425603f, -0.02793937f, 0.00573718f, -0.04370408f, -0.04768355f, -0.05421441f, 0.04808530f, 
    -0.01353675f, -0.04113464f, -0.02355937f, -0.05831738f, 0.02544549f, 0.01074780f, 0.04760678f, 0.00863517f, 
    0.05340424f, 0.04197709f, 0.03553129f, -0.03358559f, 0.04232756f, -0.00684191f, 0.03879469f, -0.05336806f, 
    0.04441761f, 0.03557286f, -0.01283697f, 0.01884729f, -0.00032098f, 0.04692027f, -0.07716120f, 0.01707068f, 
    -0.00494092f, 0.00343409f, 0.03247359f, -0.01615246f, 0.01722816f, 0.03697830f, -0.05914062f, -0.04871521f, 
    0.02060268f, 0.02095012f, 0.03685429f, -0.06199931f, 0.01437013f, -0.06338187f, -0.00273695f, -0.01490140f, 
    -0.03369751f, -0.06241542f, -0.02131952f, 0.02961999f, -0.00118881f, 0.04885372f, 0.03695226f, 0.00385323f, 
    -0.03535938f, 0.03432893f, 0.04812136f, 0.02544820f, -0.06109652f, -0.02508471f, -0.02481370f, 0.01773295f, 
    0.00868971f, -0.00114839f, -0.02045775f, 0.03698802f, -0.03386195f, -0.03488642f, 0.02354216f, -0.01088058f, 
    -0.05125201f, -0.04509603f, 0.01089421f, -0.04257471f, -0.05065190f, -0.01579152f, 0.02632433f, -0.00505810f, 
    -0.04576172f, -0.07194503f, -0.00023182f, 0.00452931f, 0.03684835f, -0.01224955f, 0.01062480f, -0.05496129f, 
    -0.04800043f, -0.00975300f, 0.01081722f, -0.01930845f, 0.01914269f, -0.02077123f, -0.03248613f, 0.03310945f, 
    0.03166690f, -0.01564381f, 0.02925206f, 0.03073040f, -0.03466194f, 0.01840832f, 0.03557634f, 0.00687587f, 
    -0.05580606f, 0.01821902f, 0.01211808f, -0.03191580f, 0.01163464f, 0.02459239f, 0.00749029f, 0.03635868f, 
    -0.06697953f, -0.00793604f, -0.00337910f, -0.05878709f, -0.05886220f, 0.00449671f, -0.05895268f, -0.00128165f, 
    0.00200375f, 0.01313840f, 0.03856428f, -0.03549863f, 0.02955388f, 0.00745556f, -0.00304499f, -0.00626254f, 
    0.00352487f, -0.01483022f, -0.06985965f, -0.03382448f, -0.03691760f, 0.00874070f, -0.08544893f, 0.02490728f, 
    0.02816759f, -0.08102060f, -0.06649947f, -0.00001234f, -0.03259222f, -0.04621898f, -0.00770263f, 0.00626041f, 
    -0.05996379f, -0.01565249f, 0.00534773f, 0.02782497f, -0.05603040f, 0.00711187f, -0.02263298f, -0.00708978f, 
    -0.05845217f, -0.03180069f, -0.02097270f, 0.01154216f, 0.02312675f, -0.00141503f, 0.04208224f, 0.03148043f, 
    -0.03503562f, 0.01367187f, -0.05490302f, 0.04506692f, -0.00458331f, -0.08712735f, -0.01306314f, 0.00528185f, 
    -0.01451785f, 0.02865334f, -0.01383501f, -0.06577013f, 0.01872143f, -0.00348625f, -0.00971007f, -0.02593352f, 
    -0.06155396f, -0.03655381f, -0.03338992f, -0.07824884f, -0.02350327f, 0.00735926f, 0.04101482f, -0.07007631f, 
    0.03052057f, 0.01390858f, 0.02238891f, 0.02953563f, -0.01280243f, -0.05144649f, 0.01293208f, -0.07203133f, 
    -0.02887242f, -0.05372982f, -0.06822544f, -0.04642871f, -0.02927813f, -0.01971570f, -0.07718001f, -0.02464123f, 
    -0.04860853f, 0.04659071f, 0.01744534f, 0.01099718f, -0.01667231f, 0.03445261f, -0.05132503f, 0.03548624f, 
    -0.01558077f, -0.01544888f, -0.04618431f, 0.04835358f, -0.05713710f, -0.04917330f, 0.03582169f, -0.06993137f, 
    -0.03579316f, 0.02302587f, -0.00275133f, 0.02623445f, 0.04357900f, -0.02889114f, -0.06537757f, 0.03052775f, 
    -0.08539078f, -0.11091541f, -0.06377088f, 0.07112234f, 0.15356208f, -0.08573716f, -0.09077009f, -0.06623071f, 
    0.09647505f, -0.33736375f, 0.09423947f, -0.32048374f, 0.00468883f, 0.01884821f, -0.11124172f, -0.18374060f, 
    0.02658112f, -0.04911853f, -0.05338820f, 0.05287130f, -0.11934876f, -0.03720543f, -0.04362689f, 0.04597041f, 
    0.16650033f, 0.11536236f, -0.15396629f, 0.12998085f, 0.11226710f, -0.05881018f, 0.04041591f, 0.05655901f, 
    0.12619580f, -0.02320589f, 0.10055447f, -0.00581497f, -0.10963421f, 0.17243938f, -0.16634919f, -0.06199793f, 
    -0.13640730f, -0.06175521f, 0.02321297f, 0.00997977f, 0.08864415f, 0.22275071f, 0.12346841f, 0.08068588f, 
    -0.02966322f, -0.01420300f, 0.01729532f, 0.01420023f, 0.01421275f, 0.08622127f, 0.34804705f, 0.12601732f, 
    0.02717589f, -0.06431463f, 0.00340158f, 0.09446485f, 0.08885428f, 0.01134207f, 0.01651250f, 0.33105356f, 
    0.16794133f, 0.08864840f, 0.04007586f, 0.02354402f, 0.14570582f, 0.05380804f, 0.21368991f, 0.26153493f, 
    -0.17336705f, -0.06902788f, 0.03015593f, 0.07740277f, 0.13613006f, 0.09208927f, 0.11124501f, 0.00755582f, 
    -0.09289532f, 0.15795451f, 0.01262668f, 0.02022711f, -0.08301235f, 0.17494768f, 0.11665502f, 0.18540937f, 
    0.11201100f, 0.04338614f, 0.00232966f, 0.09141340f, -0.03813916f, -0.09421567f, 0.04788576f, 0.04870768f, 
    0.08395493f, 0.04549706f, 0.04367145f, -0.20186098f, 0.07684648f, -0.11841667f, -0.15015665f, 0.01129231f, 
    -0.02660160f, 0.12495738f, -0.08221129f, 0.09588087f, 0.17784914f, 0.21620250f, 0.09328285f, 0.01818468f, 
    -0.03731228f, 0.09082594f, 0.00705804f, 0.00764044f, 0.03534322f, -0.49293715f, -0.00727887f, 0.07185107f, 
    -0.01821607f, 0.01544989f, 0.10412679f, -0.07964310f, 0.09116232f, 0.15254824f, 0.26066253f, 0.34020698f, 
    0.15216824f, 0.11050661f, -0.11085110f, 0.12972522f, 0.17804967f, 0.04837796f, 0.11912502f, -0.02813870f, 
    0.07158714f, 0.17410222f, -0.13450386f, 0.08648618f, 0.07493512f, 0.21289378f, 0.16481897f, -0.07753160f, 
    0.12522823f, 0.29847911f, 0.17547734f, -0.13038012f, 0.00830495f, 0.22007087f, 0.22021301f, 0.01318269f, 
    0.13574187f, -0.13212116f, 0.08706529f, -0.05934352f, 0.08407199f, 0.00845874f, -0.05373958f, -0.02080872f, 
    0.07542609f, -0.05014409f, 0.02770545f, -0.01625979f, -0.02489857f, -0.09605777f, 0.03069229f, 0.10520197f, 
    0.10278347f, 0.10262550f, -0.03615406f, 0.17460743f, -0.03420468f, 0.13584386f, 0.11792754f, 0.00787977f, 
    0.04902128f, 0.10272812f, -0.08775890f, 0.09040665f, -0.17857410f, 0.01734310f, -0.09056652f, 0.09354764f, 
    0.00227679f, -0.15194371f, -0.16590439f, -0.02773075f, 0.09870350f, 0.02043037f, 0.01417715f, 0.11831722f, 
    0.03423534f, 0.01933171f, -0.00453766f, 0.00099849f, 0.06186288f, 0.03035371f, 0.04627191f, -0.03777726f, 
    0.00136607f, -0.00688561f, 0.05328337f, -0.01160919f, 0.08362414f, -0.02531086f, 0.09239609f, 0.30001861f, 
    0.22541757f, 0.14099351f, -0.11796308f, -0.04596497f, 0.14904088f, 0.06316997f, 0.01455310f, 0.08854324f, 
    -0.13457915f, 0.06221344f, -0.25727528f, -0.00159329f, 0.08289247f, 0.06513847f, -0.00847366f, 0.05111719f, 
    0.01845642f, -0.19704992f, 0.05510247f, -0.00821191f, -0.11521477f, 0.23052426f, -0.19234002f, -0.04713256f, 
    0.02269603f, -0.09061911f, 0.12528662f, 0.15996218f, -0.03320899f, -0.03848906f, 0.02994200f, -0.03075245f, 
    -0.07919712f, 0.00771577f, -0.04540186f, 0.09260376f, 0.19886391f, -0.04529290f, 0.00714177f, 0.01303262f, 
    0.17782314f, 0.08778126f, 0.03757876f, 0.10609384f, -0.01470207f, 0.33200520f, 0.11959462f, 0.06361473f, 
    0.06945194f, 0.00502184f, 0.00785482f, 0.04130688f, 0.08879999f, -0.30597371f, 0.15937462f, -0.20560589f, 
    -0.02946118f, -0.04641027f, -0.16653392f, 0.13905609f, 0.04105319f, 0.04940987f, -0.31287795f, -0.00228653f, 
    0.07436243f, 0.06802297f, 0.21444348f, 0.06392642f, -0.13212369f, 0.18352088f, -0.16373836f, -0.24522205f, 
    0.03029322f, 0.18143518f, -0.08516712f, 0.02387437f, -0.12036900f, 0.06202539f, 0.15538219f, -0.04390378f, 
    0.11249858f, -0.17119719f, 0.23101939f, 0.00767811f, -0.04123695f, -0.01121158f, 0.07859481f, 0.06420048f, 
    0.06269929f, -0.18356201f, -0.15821379f, 0.06550016f, 0.04685967f, -0.10013694f, -0.09551139f, 0.00899401f, 
    0.05095315f, -0.00366374f, 0.08122282f, 0.06813791f, -0.14463620f, 0.08171140f, 0.02361078f, 0.11681461f, 
    -0.05451704f, -0.00676941f, -0.04617084f, 0.19944605f, 0.13114713f, 0.16779920f, -0.12084518f, 0.15163715f, 
    0.13337421f, 0.07603469f, 0.00091061f, -0.11791442f, 0.15159307f, 0.02520318f, 0.04623934f, 0.08704960f, 
    -0.09110627f, 0.02404228f, -0.05055614f, 0.05986015f, -0.09083277f, 0.02301089f, 0.15019047f, 0.10795307f, 
    -0.13618201f, -0.18827769f, 0.17239384f, 0.00420437f, 0.06701974f, 0.06674924f, -0.06763981f, 0.11084542f, 
    0.11302014f, -0.05994732f, 0.04089464f, 0.10195946f, 0.11534727f, -0.13135560f, -0.04335989f, -0.00776917f, 
    0.10615158f, 0.35807806f, 0.05058973f, 0.02936041f, 0.08886365f, 0.04251210f, -0.01457800f, 0.15244204f, 
    -0.17352526f, 0.07686172f, 0.22142150f, 0.27422243f, 0.04959892f, 0.00156008f, 0.18608704f, 0.09895128f, 
    -0.08116527f, -0.00558114f, -0.06200356f, -0.03991808f, 0.06622688f, 0.07458988f, 0.14431229f, 0.04348045f, 
    -0.07523311f, -0.18377806f, -0.04786379f, 0.01865062f, -0.41313121f, -0.03692688f, 0.10560524f, 0.03409485f, 
    0.00038659f, -0.05116825f, -0.07658199f, 0.22241913f, 0.07709536f, -0.01093093f, -0.01331635f, -0.00566920f, 
    -0.07851523f, -0.18167934f, 0.20515838f, 0.02968907f, 0.22205251f, 0.20993829f, 0.00614536f, -0.03237600f, 
    -0.13397244f, -0.10795547f, -0.06921594f, 0.11422404f, 0.03091651f, -0.18776244f, 0.22799671f, -0.11043942f, 
    0.04674702f, -0.15013772f, -0.05050690f, -0.04147056f, 0.01678139f, 0.04942071f, -0.02118414f, 0.11567279f, 
    0.23510450f, 0.08050935f, -0.09775340f, 0.10626134f, -0.01132405f, 0.18107837f, 0.15612307f, 0.11497360f, 
    0.08527686f, 0.04485900f, -0.04785096f, -0.02412723f, 0.02620077f, 0.01210056f, 0.17663935f, -0.00282566f, 
    0.17637256f, 0.09596510f, 0.34570992f, -0.13191615f, 0.02492579f, 0.08348456f, -0.08606305f, -0.14215308f, 
    0.21652685f, 0.11082280f, 0.06405088f, 0.02990285f, 0.07505246f, -0.01380068f, 0.09217869f, 0.02139677f, 
    0.01949446f, -0.15853742f, 0.16239989f, -0.07714186f, -0.11963803f, 0.12529312f, 0.10334172f, 0.18082823f, 
    -0.01605862f, -0.18130755f, -0.25975397f, -0.05281999f, -0.02149590f, 0.18088320f, 0.06981761f, -0.05177517f, 
    -0.27836329f, 0.01823899f, 0.21977155f, -0.06165395f, -0.04545980f, 0.11165503f, 0.16179709f, 0.03169527f, 
    -0.21754536f, -0.21189222f, -0.08442202f, 0.04768596f, -0.01385773f, 0.10765567f, 0.09453005f, 0.07148065f, 
    0.00589689f, -0.08108896f, -0.08187405f, 0.00208653f, -0.03194359f, -0.00631619f, 0.04081124f, 0.08298407f, 
    -0.04724192f, 0.03760775f, -0.12748659f, -0.07108923f, -0.04922717f, -0.06843176f, 0.13705313f, 0.07286858f, 
    0.06788773f, -0.04161061f, 0.25777614f, 0.02349243f, 0.15494114f, -0.07185163f, -0.07854405f, -0.18834026f, 
    -0.05494189f, -0.08746461f, -0.29529047f, -0.01099982f, 0.01052701f, -0.04382070f, 0.09201473f, 0.04342941f, 
    0.11707386f, -0.08948347f, 0.01402266f, -0.30515495f, -0.09702386f, 0.06599540f, 0.04394754f, 0.12415150f, 
    -0.29194397f, -0.26100281f, 0.10924578f, 0.08059010f, -0.12353058f, -0.00054939f, 0.09670188f, -0.00748340f, 
    -0.02062171f, -0.11802231f, 0.04095460f, -0.08220688f, -0.00203778f, 0.18398522f, -0.02556038f, 0.04416259f, 
    0.08325414f, 0.01191533f, -0.11096425f, 0.03866748f, -0.19999307f, 0.15226981f, -0.00420581f, -0.03235918f, 
    0.10198091f, -0.01574981f, -0.09471828f, -0.09304340f, 0.03635269f, 0.01687222f, -0.13819416f, 0.13789326f, 
    0.07968757f, -0.14981471f, 0.02130849f, 0.00371580f, 0.12341201f, 0.06524857f, -0.00688954f, -0.04079542f, 
    0.02481402f, 0.02864935f, -0.06458349f, -0.02779843f, 0.03676656f, -0.01414930f, 0.09432503f, -0.00668541f, 
    0.21468027f, 0.13084987f, -0.17419365f, 0.08821671f, -0.02148108f, -0.01186826f, -0.08656580f, -0.00139989f, 
    -0.14245054f, -0.08946098f, -0.12964202f, 0.18730502f, 0.03836675f, -0.02534906f, -0.09990351f, 0.02271927f, 
    0.04546943f, -0.08805536f, 0.06395183f, -0.06933636f, 0.02922574f, -0.11960556f, -0.03205788f, 0.13011518f, 
    0.05466814f, -0.21660087f, 0.07659084f, 0.00354311f, -0.15353698f, -0.05186183f, -0.06017319f, -0.13326398f, 
    -0.00596863f, 0.17744771f, 0.04158400f, -0.20807251f, 0.10945280f, 0.00314694f, 0.08409229f, 0.01262644f, 
    0.12535706f, 0.02347295f, -0.05423182f, 0.11120186f, -0.02696727f, 0.03609336f, -0.12467109f, -0.05688496f, 
    -0.09395947f, 0.01268491f, -0.09846172f, 0.20634097f, -0.01120457f, 0.23923144f, 0.02413196f, 0.14572881f, 
    0.05627933f, -0.08987399f, 0.04307302f, -0.01280994f, -0.12614755f, 0.10637272f, -0.08146204f, -0.14439496f, 
    0.24552681f, 0.01890496f, -0.03016284f, -0.02792192f, -0.07077329f, -0.06955509f, 0.01329823f, -0.29440102f, 
    0.04629889f, 0.09863066f, -0.00576850f, 0.06806540f, 0.06839982f, -0.03385353f, 0.02864489f, -0.04392086f, 
    0.19265197f, 0.26392376f, -0.18346609f, -0.11725964f, 0.06633926f, -0.03589110f, -0.12942415f, -0.06331366f, 
    0.11772873f, 0.09433576f, 0.13120541f, -0.06865025f, 0.13605042f, -0.03879707f, -0.24204956f, 0.05325213f, 
    -0.09404980f, 0.09326943f, 0.14388680f, 0.07567936f, 0.18052092f, -0.11332177f, 0.04730022f, -0.04474469f, 
    0.00553521f, 0.12407787f, -0.00126486f, -0.27058220f, -0.16992964f, -0.20400412f, 0.17140278f, -0.10230004f, 
    -0.18030356f, -0.04600364f, 0.07037570f, -0.08329926f, -0.35470119f, -0.30618522f, 0.07597920f, -0.01371191f, 
    0.02082513f, 0.08329214f, -0.09023361f, -0.11337724f, -0.09902876f, 0.04306577f, 0.01915109f, -0.12579268f, 
    -0.07876886f, -0.01058800f, 0.07443652f, -0.08749075f, -0.03848840f, 0.01779001f, 0.03016664f, -0.07123356f, 
    0.09034809f, -0.04031714f, -0.04403259f, -0.07564683f, 0.01165863f, -0.04482048f, 0.04682700f, 0.15306213f, 
    0.06138770f, -0.37708199f, 0.05761608f, -0.20152284f, -0.01868183f, 0.02231178f, 0.09870079f, 0.11894910f, 
    0.29915714f, 0.09652379f, -0.11481293f, 0.09448946f, -0.07783848f, 0.07265640f, -0.04833387f, -0.00642773f, 
    -0.08341713f, 0.14261979f, 0.06517406f, -0.13273329f, 0.09335183f, -0.11538097f, 0.06326941f, 0.12331984f, 
    0.14314096f, -0.00943457f, -0.01622758f, 0.22383404f, 0.10765312f, -0.06253178f, -0.06984325f, -0.08844747f, 
    0.07287774f, 0.01582768f, 0.06085078f, -0.14597714f, -0.14512792f, -0.23733772f, -0.03072281f, -0.11650327f, 
    0.10880351f, 0.02430640f, -0.15786369f, -0.01417000f, 0.05649335f, -0.07443804f, -0.11841010f, -0.00429563f, 
    -0.05937054f, 0.12171911f, -0.05244360f, 0.11951982f, 0.09353929f, -0.15152119f, -0.19001980f, 0.17104891f, 
    0.08762675f, 0.03810519f, 0.02023988f, -0.04216900f, -0.07078971f, 0.03512866f, -0.34927994f, 0.05574030f, 
    0.03985509f, 0.06622427f, 0.05819888f, 0.08980265f, -0.02548162f, -0.05103050f, -0.01530228f, -0.25648794f, 
    0.18496162f, 0.15442048f, -0.04868403f, -0.00507793f, 0.02893438f, -0.21517801f, 0.10436971f, 0.07144607f, 
    -0.03304214f, -0.07128632f, -0.02277931f, -0.17471418f, 0.04616345f, 0.08664025f, 0.06698518f, 0.07285248f, 
    0.12287833f, 0.33463657f, -0.00887100f, 0.10549735f, -0.04110067f, -0.04345657f, 0.04546841f, -0.07597275f, 
    0.03165480f, 0.11418813f, 0.11898820f, 0.07314596f, -0.08190767f, 0.02226826f, -0.14518268f, 0.04351317f, 
    0.06595051f, 0.00460916f, 0.06643421f, 0.17610222f, 0.10306337f, 0.11906334f, 0.02083459f, -0.10565784f, 
    0.21781248f, 0.11959277f, 0.03029955f, 0.04433101f, -0.29016846f, -0.20937036f, 0.05892009f, 0.12244342f, 
    0.02094777f, 0.09151364f, -0.08067457f, 0.00975284f, 0.06717426f, -0.19632058f, -0.20982273f, -0.11247825f, 
    -0.07666232f, -0.05555063f, 0.04608795f, -0.10737387f, 0.21058962f, 0.01741954f, -0.27930790f, -0.20520158f, 
    0.22270620f, 0.21068056f, 0.04535002f, 0.06480886f, -0.02256808f, -0.05025071f, 0.00404941f, 0.03847067f, 
    -0.22242449f, -0.17800194f, 0.12326920f, 0.02605197f, 0.00194073f, 0.02490351f, -0.10957361f, 0.05235044f, 
    -0.02793006f, -0.06761123f, -0.03275352f, 0.01902518f, -0.00807362f, -0.03014104f, 0.03230926f, -0.03758840f, 
    -0.01126960f, -0.01260413f, 0.03479735f, 0.04472521f, 0.00662920f, 0.05696477f, -0.01326884f, -0.05791486f, 
    0.01362960f, -0.04137637f, 0.04720687f, -0.02390500f, -0.03594215f, 0.02234047f, 0.03892329f, 0.02515663f, 
    -0.05296359f, 0.03798325f, 0.04046042f, -0.04631066f, -0.01801032f, -0.01510354f, 0.01394779f, 0.00974778f, 
    0.03797383f, 0.02825568f, 0.05301930f, 0.00814985f, -0.03361483f, -0.05172195f, 0.04550738f, 0.01830503f, 
    0.01778673f, -0.03152432f, 0.02156204f, -0.03964133f, -0.04966850f, 0.00291465f, 0.02936069f, 0.00315924f, 
    -0.01665065f, 0.03002426f, -0.05264304f, 0.02782227f, -0.00830072f, -0.04172275f, -0.03673060f, -0.01925704f, 
    0.04821930f, 0.00729705f, 0.04616033f, -0.04522885f, -0.05323524f, -0.02823448f, -0.02566432f, -0.03686057f, 
    0.00241186f, -0.00385353f, -0.03497476f, -0.01978456f, -0.06503958f, 0.01070638f, 0.00803748f, 0.01208795f, 
    0.04541654f, -0.05458346f, -0.00951641f, 0.00714057f, -0.03359418f, 0.03475893f, -0.05194816f, 0.02924589f, 
    -0.04687442f, -0.01257475f, -0.02467371f, 0.01650733f, -0.05836809f, 0.03893324f, -0.06300130f, -0.01278241f, 
    -0.02102890f, -0.05819415f, -0.04305893f, -0.00827729f, -0.02641639f, 0.04698819f, -0.01083491f, -0.04622784f, 
    -0.04174713f, -0.01816121f, 0.04108075f, 0.03635811f, 0.02369116f, -0.03176928f, 0.00038246f, -0.00173345f, 
    0.01616992f, 0.02966991f, 0.01801799f, -0.03689698f, -0.00691651f, -0.02660178f, -0.05081067f, 0.01277411f, 
    0.04432394f, -0.05834169f, 0.00744884f, 0.03704660f, 0.05711247f, -0.00064863f, -0.03402288f, -0.04910338f, 
    -0.04448930f, 0.04215875f, 0.01748174f, -0.03013479f, -0.04182555f, 0.02514402f, -0.02630742f, 0.01611899f, 
    0.02982168f, -0.02117732f, -0.05676169f, -0.02344300f, 0.00165692f, 0.04463510f, 0.01557829f, -0.00485827f, 
    -0.06079721f, 0.03069386f, -0.04237378f, -0.04657074f, 0.04613998f, -0.03436878f, 0.02911047f, 0.03731992f, 
    0.03010765f, 0.04536114f, 0.02207513f, 0.03934492f, 0.04052942f, -0.00092801f, -0.05294413f, -0.00108230f, 
    -0.02430150f, -0.01813732f, 0.02005782f, -0.02327152f, -0.05822876f, 0.04476972f, 0.03587145f, -0.00394510f, 
    0.04915877f, 0.02742403f, 0.02536830f, 0.03049567f, 0.04454024f, -0.04274268f, 0.02848707f, -0.02290598f, 
    -0.03031973f, -0.00319414f, 0.04879032f, -0.05405932f, -0.03190209f, -0.05786075f, 0.03669595f, -0.03901204f, 
    0.00646225f, 0.02042389f, -0.01179846f, -0.02005285f, 0.03701258f, -0.03251718f, -0.04879460f, 0.01876906f, 
    0.01934913f, -0.05282332f, -0.03118077f, -0.04143548f, -0.01044357f, -0.05520788f, 0.01603505f, -0.06665749f, 
    -0.04239427f, 0.01695967f, -0.03286298f, 0.02667264f, -0.04372769f, -0.04794479f, 0.03712858f, -0.05187356f, 
    -0.02061496f, -0.06371898f, -0.01976505f, 0.02783869f, -0.03703434f, 0.01783536f, 0.04427882f, -0.01151607f, 
    0.04731605f, -0.02465407f, 0.01732139f, -0.00861964f, -0.06223237f, -0.02725091f, -0.00440651f, 0.01145972f, 
    0.00732908f, 0.02718006f, -0.00267953f, -0.02126194f, -0.04794855f, -0.04985495f, -0.02123964f, 0.00199213f, 
    0.00329180f, -0.04521505f, 0.05088043f, -0.05998632f, -0.04836022f, 0.04102853f, 0.03850222f, -0.04897083f, 
    0.01517765f, -0.01189585f, -0.06701120f, 0.04821825f, -0.00770733f, 0.04174031f, -0.00737164f, 0.01950966f, 
    0.01620154f, -0.04694851f, 0.02631589f, 0.00556108f, 0.00331362f, 0.04129009f, 0.00831894f, -0.05689438f, 
    0.03849903f, -0.01324788f, -0.01536326f, -0.03024232f, 0.03990999f, -0.04024339f, 0.01457501f, -0.00639440f, 
    -0.00525468f, -0.06108492f, -0.03298207f, 0.02084533f, -0.01118084f, -0.03932690f, -0.00083794f, -0.01280471f, 
    -0.00364030f, -0.00848002f, -0.04468297f, -0.05114527f, -0.05863302f, 0.03786382f, -0.00894614f, 0.04580674f, 
    0.04223575f, 0.03562491f, -0.03983181f, -0.03328256f, -0.05068658f, -0.04025885f, -0.02793715f, 0.00750869f, 
    -0.04036145f, -0.03332128f, -0.02137269f, -0.00635169f, -0.04915608f, 0.06085119f, 0.02951357f, -0.05536284f, 
    -0.05735163f, 0.05366758f, -0.01756925f, 0.03333696f, -0.00029267f, -0.00138604f, -0.04780813f, 0.04695326f, 
    -0.02574630f, -0.01182922f, 0.01280747f, 0.01617774f, 0.03965960f, -0.03632995f, -0.03128370f, 0.03864946f, 
    -0.05602882f, 0.02544771f, 0.01958172f, 0.02139743f, 0.00079819f, 0.04840351f, 0.03258690f, -0.05422091f, 
    0.04910711f, -0.00781239f, 0.01162595f, -0.02042007f, 0.02202881f, 0.00670223f, -0.03518072f, -0.02078515f, 
    -0.05187214f, 0.00167511f, -0.00273792f, 0.03405885f, 0.02533173f, -0.03927226f, -0.03389709f, -0.01407654f, 
    0.04020763f, -0.00094747f, -0.06254981f, -0.06035208f, -0.06028292f, -0.03298020f, -0.02898392f, 0.04865794f, 
    -0.01627216f, -0.06022247f, -0.04498959f, 0.01236606f, 0.02267847f, -0.03262632f, -0.05883494f, 0.03203853f, 
    -0.05003930f, 0.02067552f, -0.03389481f, 0.01828993f, -0.05549824f, -0.04519861f, -0.04003366f, 0.02238199f, 
    -0.02632718f, -0.04185681f, -0.01574735f, -0.06029810f, -0.01793802f, -0.03683729f, -0.04942474f, -0.04406444f, 
    -0.06013740f, 0.04288270f, 0.04162277f, -0.00048367f, 0.04034685f, -0.04075658f, -0.04656788f, -0.04151735f, 
    -0.01825176f, -0.00458383f, -0.00701275f, -0.05830972f, 0.04919480f, 0.04412600f, -0.01503245f, -0.00259694f, 
    -0.02846442f, 0.02104615f, 0.03251741f, -0.06066912f, -0.03609679f, -0.00892335f, -0.02203287f, -0.06046463f, 
    -0.05892522f, 0.04762574f, -0.05296625f, -0.01370061f, -0.02593491f, -0.01403205f, -0.02911799f, 0.01081576f, 
    0.04365689f, -0.03706495f, 0.02807255f, 0.03972548f, -0.05141040f, -0.01590868f, 0.01033007f, 0.00177734f, 
    -0.06205849f, 0.04198077f, -0.04956999f, 0.00877828f, 0.04866740f, 0.01162136f, -0.03055248f, -0.02965863f, 
    0.04605936f, 0.00982596f, -0.01109127f, -0.04853000f, 0.03517741f, -0.00602534f, -0.01778335f, 0.01328217f, 
    -0.01374833f, -0.05704549f, 0.04552943f, -0.03327243f, 0.04523247f, 0.01357751f, -0.02365450f, -0.01662816f, 
    -0.05618724f, -0.04116480f, 0.02347558f, -0.05734647f, 0.04643622f, -0.01480190f, -0.03073324f, 0.01630921f, 
    -0.05701428f, -0.02767980f, 0.01774950f, -0.02118259f, 0.00113809f, -0.01818007f, -0.03022595f, -0.03879904f, 
    -0.00982856f, -0.05647283f, 0.00339566f, 0.02287293f, 0.03923477f, 0.03724960f, 0.02943613f, 0.00597654f, 
    -0.05273391f, 0.01741180f, 0.03054206f, 0.04226135f, 0.03366187f, -0.00671993f, 0.02320741f, -0.05650272f, 
    -0.04599087f, -0.00943519f, -0.00198400f, 0.03191483f, -0.04641981f, 0.05470585f, 0.04054051f, -0.03306893f, 
    0.02773687f, 0.04713444f, -0.05915198f, 0.03140350f, -0.02474928f, 0.04619287f, 0.03673004f, -0.04915140f, 
    0.01038086f, 0.04541412f, 0.00664195f, -0.05970735f, 0.01227462f, 0.01117212f, -0.00555683f, -0.05720954f, 
    -0.03561811f, -0.00914952f, -0.02218191f, -0.03732264f, -0.04042039f, -0.04528395f, 0.04038449f, -0.05223507f, 
    -0.06179521f, -0.05288880f, -0.05989822f, -0.04209801f, 0.04336435f, 0.03964473f, 0.01801674f, -0.04510020f, 
    0.00958383f, -0.04279297f, -0.03205500f, 0.05159197f, -0.01451982f, 0.04889456f, 0.01405003f, 0.04743895f, 
    0.00299080f, 0.00970408f, 0.05150348f, -0.05969414f, -0.00981751f, 0.03207503f, -0.04634497f, -0.06458224f, 
    0.04825703f, -0.03861982f, 0.01849325f, 0.02438196f, -0.01649431f, -0.05185640f, -0.02186754f, 0.01482252f, 
    -0.01560264f, -0.04631158f, -0.02507290f, 0.03899392f, 0.00661105f, -0.03296058f, -0.03293369f, -0.01114530f, 
    -0.02941474f, -0.03853111f, 0.03306758f, -0.03300608f, -0.01957122f, -0.05134941f, 0.01378666f, 0.02809425f, 
    0.00810828f, 0.02115952f, -0.02750926f, -0.00895682f, -0.04585832f, 0.00933906f, -0.02713102f, -0.05364151f, 
    0.03004447f, 0.05179556f, -0.03420339f, -0.00953425f, 0.03835750f, -0.04630645f, -0.05374587f, -0.01782173f, 
    -0.06423151f, -0.01148472f, -0.00848319f, 0.05417978f, -0.01994788f, 0.00294495f, 0.02028940f, -0.00038510f, 
    -0.06342854f, -0.00844952f, 0.02412142f, -0.03040010f, -0.02472736f, -0.00571706f, -0.01244916f, 0.02780720f, 
    -0.04153672f, -0.03178677f, 0.02266545f, 0.02395497f, -0.01459117f, 0.04168777f, -0.04208510f, 0.01742321f, 
    -0.44182691f, -0.17245254f, -0.22935705f, 0.07217412f, -0.03008604f, -0.10551255f, -0.00772488f, 0.02028683f, 
    0.11963685f, -0.42580017f, -0.16817610f, -0.08910293f, -0.09547566f, -0.09268587f, 0.03696331f, 0.02546682f, 
    -0.05642761f, -0.08709545f, 0.23435014f, -0.01756183f, 0.16009438f, 0.06427393f, 0.01828185f, 0.03323765f, 
    -0.04263697f, 0.17057572f, -0.06467851f, 0.02752356f, 0.03071747f, -0.02706320f, 0.00378120f, 0.26913756f, 
    0.06205748f, -0.10165554f, 0.03535720f, -0.14214380f, -0.01723553f, 0.17002198f, 0.02686255f, 0.08226059f, 
    -0.11932535f, -0.03672388f, -0.17268214f, 0.08887886f, 0.04525790f, 0.55098307f, 0.26901913f, 0.00944050f, 
    -0.14480552f, -0.09535624f, -0.06423544f, 0.07278942f, 0.11031966f, 0.01773720f, 0.23480277f, -0.04381295f, 
    0.01585071f, -0.05473270f, 0.05397484f, 0.10382333f, -0.16503279f, -0.01629658f, -0.04895376f, 0.28657570f, 
    0.05638874f, 0.09199548f, 0.10367126f, -0.13640107f, 0.10464770f, 0.04938667f, 0.10482963f, 0.03992699f, 
    0.10542212f, 0.22721043f, -0.08032730f, 0.05462754f, -0.06243761f, -0.22576590f, 0.07248301f, -0.14228831f, 
    0.10040469f, 0.30322462f, 0.06524269f, 0.22107127f, 0.09687465f, -0.00008687f, 0.04745015f, 0.19374894f, 
    0.07604771f, 0.13743307f, -0.04988595f, -0.05464872f, 0.09194867f, 0.02697611f, 0.07067803f, 0.13923016f, 
    0.04950558f, 0.08268473f, -0.00968262f, -0.31638616f, -0.10870884f, -0.19453609f, 0.07044399f, 0.00182225f, 
    0.02994178f, 0.16326861f, -0.02094795f, -0.10791480f, 0.17526497f, -0.04249857f, 0.08067563f, 0.03269387f, 
    -0.02504293f, 0.16648206f, 0.13330315f, -0.00588448f, 0.04056127f, -0.48903999f, -0.09130668f, 0.01160741f, 
    -0.13125639f, -0.00593864f, 0.15344925f, 0.04807431f, -0.02996505f, 0.06641258f, 0.16433299f, -0.08037273f, 
    0.21765186f, 0.10043639f, -0.03485797f, -0.02414726f, 0.07330627f, 0.07489157f, -0.05076706f, -0.33003736f, 
    -0.03778500f, -0.15518174f, -0.01391591f, -0.10802389f, -0.07895581f, 0.04023518f, 0.06580864f, 0.09487250f, 
    0.14416270f, 0.08766640f, -0.00771117f, -0.02172815f, -0.04557438f, 0.03809774f, 0.11960648f, -0.11629159f, 
    -0.07665560f, 0.24592009f, 0.19671370f, -0.06603928f, 0.11161482f, -0.17907961f, -0.15326828f, -0.02610246f, 
    0.12560706f, 0.13168144f, 0.13312076f, 0.03402549f, 0.15816072f, -0.00607212f, 0.01939457f, -0.07670385f, 
    0.04301847f, 0.02759874f, 0.11497635f, 0.01460561f, 0.06155342f, 0.01860580f, 0.06632072f, -0.00017869f, 
    0.05824028f, -0.20358714f, -0.01371619f, -0.04416076f, -0.12990615f, -0.17257439f, -0.07268209f, -0.07760326f, 
    0.00732850f, -0.02858008f, -0.03305713f, -0.01276149f, -0.00343373f, -0.02493463f, 0.26457804f, -0.12600033f, 
    0.03326398f, -0.13233724f, -0.01025056f, -0.05727598f, 0.05342371f, 0.09102979f, 0.24685292f, -0.09241737f, 
    0.05458575f, -0.08585896f, 0.10416108f, 0.13440707f, -0.01142317f, -0.05347347f, 0.12900445f, 0.16372348f, 
    0.03436352f, 0.00874680f, 0.05779505f, 0.07683440f, 0.09967861f, -0.05559414f, -0.06528128f, 0.06047622f, 
    -0.67033350f, -0.35918865f, -0.04021382f, -0.03449605f, -0.00130016f, 0.04362273f, 0.06810193f, -0.00151672f, 
    0.01677408f, 0.04445624f, -0.02507316f, -0.30976120f, 0.04386658f, 0.01366800f, -0.02676737f, -0.06791859f, 
    -0.02447609f, 0.06509905f, -0.04736784f, 0.14708029f, 0.04401289f, 0.04935407f, 0.04715062f, -0.04277566f, 
    0.01483874f, -0.08032034f, 0.01365914f, 0.28456563f, 0.01878919f, 0.12462335f, -0.01454970f, 0.01125949f, 
    0.07384244f, -0.05474831f, -0.00694853f, -0.00592164f, 0.01394492f, -0.07343525f, 0.01147044f, 0.04277201f, 
    -0.03055074f, -0.04002342f, 0.00484967f, -0.11665806f, -0.00946103f, -0.56777138f, -0.07815576f, -0.03952628f, 
    0.12757327f, -0.01861897f, -0.00378992f, 0.04005777f, 0.02831913f, -0.04041401f, -0.39801452f, -0.12836464f, 
    -0.02399321f, -0.07968951f, 0.05634442f, 0.19316018f, 0.02216477f, 0.04719742f, 0.02704967f, -0.12587969f, 
    -0.13058712f, -0.16328789f, 0.10531621f, -0.05322440f, 0.12631845f, -0.01713334f, 0.01048306f, -0.19466650f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03923089f, -0.03679619f, -0.04072714f, -0.03675691f, -0.06445075f, -0.04721630f, 0.04846845f, 0.02753864f, 
    0.07856839f, 0.05748650f, 0.06335144f, 0.03206336f, 0.09126491f, 0.02801926f, -0.02075055f, 0.02653820f, 
    0.05050870f, 0.14524233f, 0.05680757f, 0.01192475f, -0.02268154f, -0.02958475f, 0.14498462f, 0.14036717f, 
    0.07124513f, -0.07011208f, 0.09281546f, -0.01531197f, 0.14691907f, 0.04521370f, -0.00735173f, 0.04362344f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13850972f, 0.06398022f, 0.25005779f, 0.16316445f, 0.04699200f, 0.07240860f, -0.34098458f, 0.08107647f, 
    0.22235163f, -0.02757243f, -0.47392547f, -0.04838773f, 0.43616137f, 0.08016072f, -0.14209168f, -0.38944116f, 
    -0.38279435f, -0.24751137f, -0.32798174f, 0.12341223f, 0.08555713f, -0.13607183f, 0.07089001f, -0.24906167f, 
    -0.08044730f, 0.13880932f, 0.29002512f, 0.30859289f, 0.03536059f, -0.01096102f, 0.14474712f, 0.15675911f, 
    0.06660877f, -0.06764761f, 0.50863206f, 0.03728561f, 0.01444057f, -0.00383438f, 0.31780452f, -0.43623602f, 
    0.18551074f, -0.28475276f, -0.00940634f, 0.39421853f, 0.19694604f, 0.06864435f, 0.11527165f, 0.07649875f, 
    -0.32203439f, 0.14619754f, -0.05089464f, -0.31948113f, 0.15516205f, 0.10087471f, -0.07416102f, 0.32233486f, 
    -0.11759458f, -0.12790480f, 0.22547697f, -0.06115063f, 0.29268244f, -0.18038972f, -0.03523498f, 0.11912919f, 
    -0.06338833f, -0.09485944f, -0.38402468f, 0.09895576f, 0.12252392f, -0.29772100f, -0.01831971f, 0.38478374f, 
    0.05578948f, -0.22543162f, -0.03120965f, -0.41104943f, 0.11571474f, -0.14562954f, -0.07113507f, 0.12145467f, 
    0.17986536f, 0.34066147f, 0.01606533f, 0.19943801f, 0.12983519f, -0.02090506f, 0.16119269f, 0.02111387f, 
    0.05256799f, 0.03473775f, 0.02034136f, -0.07603018f, 0.19978413f, -0.15317048f, 0.07069825f, 0.09573795f, 
    -0.03213939f, 0.15725888f, -0.29768845f, 0.02766251f, -0.00291013f, 0.18211021f, -0.13593927f, 0.09286048f, 
    -0.15307294f, 0.19986650f, -0.37848064f, -0.36726549f, 0.32582420f, -0.08398670f, -0.16393717f, -0.17702183f, 
    -0.20234352f, 0.05522928f, 0.21803764f, -0.14335665f, -0.10207242f, 0.16153723f, 0.43368411f, -0.03609896f, 
    0.07882862f, 0.07805929f, 0.11647922f, 0.33749926f, -0.10644553f, -0.05126117f, 0.16406290f, 0.01050423f, 
    -0.07542099f, -0.16635893f, 0.24562407f, -0.02606951f, -0.11999842f, -0.00463226f, 0.15661775f, -0.34935251f, 
    -0.35878032f, 0.14528179f, 0.23108009f, 0.39688441f, 0.28532085f, 0.00947508f, -0.04055345f, 0.44703922f, 
    -0.12856278f, 0.36473933f, -0.02390162f, 0.22429767f, 0.00043433f, -0.10531626f, -0.19766162f, 0.35748228f, 
    0.13411827f, 0.09592352f, -0.15163271f, 0.01476432f, -0.03836587f, -0.03788661f, 0.08596788f, 0.13457716f, 
    0.17706555f, 0.02527692f, -0.39792308f, -0.09103929f, 0.00414380f, -0.17197396f, -0.15450227f, 0.17152333f, 
    0.26088464f, -0.01426983f, -0.35904071f, -0.30218694f, -0.11319915f, 0.05485937f, 0.03846654f, -0.11870178f, 
    0.28075546f, -0.38079458f, 0.04513060f, 0.14744172f, 0.13115422f, 0.09304259f, 0.30984893f, -0.23101981f, 
    -0.07736633f, -0.09034784f, 0.28641585f, 0.12115336f, -0.03243716f, 0.08324227f, 0.07133424f, 0.09172190f, 
    0.07633156f, 0.08567373f, -0.15092526f, 0.01546218f, 0.09097687f, -0.14638092f, 0.07735550f, -0.09391374f, 
    -0.36647412f, 0.50377542f, -0.09418694f, 0.01570520f, 0.19546777f, 0.00091280f, 0.07774463f, 0.28359476f, 
    -0.07362568f, 0.31540912f, -0.04562892f, -0.11247893f, 0.00073262f, -0.12365687f, 0.58027631f, 0.07152216f, 
    0.28440604f, -0.15455641f, -0.08319861f, -0.00429605f, -0.58564907f, 0.01463621f, -0.16875388f, -0.32334244f, 
    0.07100901f, 0.10933018f, 0.00472139f, -0.19098575f, -0.12048757f, 0.28555414f, 0.15793146f, -0.36290309f, 
    0.31834403f, -0.11812013f, -0.55909735f, 0.20026134f, 0.13328598f, -0.13819255f, 0.11595849f, -0.04064506f, 
    0.29839867f, 0.16566266f, -0.29745218f, 0.20644042f, -0.15978576f, 0.08498774f, 0.15741926f, 0.39264315f, 
    -0.24378258f, 0.14271444f, 0.11097357f, -0.05641891f, 0.03251100f, -0.07789060f, 0.03497662f, 0.31724882f, 
    -0.04912575f, 0.03556671f, 0.10355500f, -0.05607913f, 0.02085268f, 0.11827047f, -0.21533141f, -0.08286572f, 
    -0.04736798f, 0.05791378f, 0.05130396f, 0.19455372f, 0.27325600f, 0.15587981f, -0.09929104f, 0.44039503f, 
    0.10986741f, 0.12463334f, -0.27729887f, 0.10914621f, -0.13036104f, 0.05190463f, -0.12698874f, 0.57235789f, 
    0.17292477f, -0.01854599f, -0.20473590f, -0.06855827f, 0.02050160f, -0.08437323f, 0.12826850f, 0.21027598f, 
    0.14745662f, -0.06899709f, 0.22460745f, 0.14756957f, -0.09967498f, -0.26487195f, -0.23406705f, -0.03055084f, 
    0.06238210f, 0.34868154f, -0.52923280f, 0.05933662f, -0.01106583f, -0.06456583f, -0.10290731f, 0.29570776f, 
    0.24169686f, -0.33591494f, -0.00973383f, 0.35844430f, 0.01227151f, -0.15984367f, 0.34205499f, -0.04225676f, 
    0.15222649f, 0.14747307f, -0.14743067f, 0.09652405f, -0.35983232f, 0.10525354f, 0.12275088f, -0.21821105f, 
    0.00586339f, -0.11088901f, -0.04365621f, 0.07925531f, -0.01528483f, -0.04777959f, -0.15780823f, -0.16160075f, 
    -0.04787602f, 0.01007320f, 0.00239095f, 0.04010806f, 0.08787969f, 0.13059013f, 0.15774032f, -0.04269448f, 
    0.05384877f, -0.16513127f, -0.02231905f, -0.07828933f, 0.11791651f, -0.09070177f, -0.09858135f, 0.14923154f, 
    -0.15313528f, 0.12264501f, -0.10747151f, -0.06342869f, -0.15026686f, 0.07308270f, 0.17627811f, 0.11273445f, 
    -0.12526688f, -0.15712732f, -0.09424442f, -0.00414019f, -0.01992085f, 0.64023477f, -0.42713088f, -0.07048294f, 
    -0.08984274f, 0.25835535f, 0.39295372f, -0.58584899f, 0.26514012f, -0.13165344f, 0.01664416f, -0.07498311f, 
    0.18254307f, 0.09944584f, -0.02771020f, -0.28911132f, 0.04410314f, -0.16597541f, 0.18980913f, 0.45371127f, 
    0.04943082f, 0.16490597f, -0.04550712f, 0.19614507f, -0.02061185f, -0.06357373f, -0.04430170f, 0.28609982f, 
    -0.10022276f, 0.01582239f, 0.35411933f, -0.00883467f, -0.12287005f, 0.25842297f, -0.14794287f, -0.09476949f, 
    0.58622080f, -0.14495930f, -0.48576567f, -0.01838112f, 0.09265530f, 0.17939667f, 0.09712326f, -0.11150418f, 
    0.04136295f, -0.36044264f, -0.40192205f, 0.27893955f, 0.02022844f, -0.08445638f, 0.26714170f, 0.04483651f, 
    0.07350051f, -0.10646046f, 0.03819649f, 0.03587689f, 0.00479167f, -0.03279306f, 0.06632829f, 0.02867994f, 
    0.08728655f, -0.15905459f, 0.03519993f, 0.04419230f, 0.12942728f, 0.01604909f, -0.09171058f, 0.03505828f, 
    -0.10233606f, 0.08511815f, -0.17210105f, -0.17580093f, -0.02392417f, -0.17044523f, -0.02187620f, -0.07430900f, 
    -0.08453856f, -0.03574341f, 0.03547465f, 0.03937940f, 0.16031015f, -0.09090336f, -0.18028608f, 0.03796328f, 
    -0.13741583f, 0.15616243f, 0.02328835f, -0.03113156f, 0.07110445f, 0.07717801f, 0.14397244f, 0.03544644f, 
    -0.02532693f, 0.13926113f, 0.41832137f, 0.00132336f, -0.17438287f, 0.07715239f, 0.34994972f, -0.23062754f, 
    0.35484675f, -0.36672047f, -0.18789437f, 0.02419504f, 0.04780228f, -0.04121122f, -0.15683082f, -0.09814953f, 
    -0.11388068f, -0.06854917f, 0.03653152f, 0.08089083f, -0.00460101f, -0.09630401f, 0.12729120f, 0.21973294f, 
    0.03536418f, -0.08450747f, -0.05260578f, -0.15834105f, 0.37563515f, 0.08559801f, -0.12062894f, 0.45855680f, 
    -0.10924146f, -0.11595716f, -0.23049963f, 0.10569548f, -0.02078788f, 0.18151523f, 0.21512665f, -0.16870642f, 
    0.23732999f, -0.15620117f, 0.41912404f, 0.04177343f, 0.07048631f, 0.06743365f, 0.08209287f, 0.17698519f, 
    -0.08378915f, 0.06782617f, -0.31350312f, -0.28690073f, -0.09403039f, -0.02396648f, 0.01246154f, 0.38294563f, 
    -0.13463323f, 0.12247369f, 0.19102547f, -0.04863724f, 0.55696356f, -0.06607703f, -0.18266527f, 0.49855861f, 
    0.04510481f, 0.09979434f, 0.31980374f, -0.04205951f, -0.13409878f, -0.19791892f, 0.11401524f, 0.14143640f, 
    -0.30054823f, 0.29009199f, 0.33804742f, 0.19864124f, -0.09380133f, 0.07722008f, 0.10013528f, 0.37263510f, 
    -0.32871410f, -0.01328554f, 0.22919284f, 0.06363999f, -0.03714373f, -0.09893355f, -0.19072033f, 0.10976383f, 
    0.41745809f, -0.01359405f, -0.21006954f, 0.22073658f, -0.05754543f, 0.16165429f, -0.14023572f, -0.26880452f, 
    -0.08549155f, 0.09801872f, -0.20226340f, -0.01255447f, 0.04488021f, -0.03780529f, 0.58242673f, 0.05961245f, 
    -0.10649016f, -0.32679033f, -0.38511682f, 0.58396429f, 0.09692623f, 0.06838389f, -0.06396307f, -0.13890693f, 
    0.05135114f, 0.49787593f, 0.41957244f, 0.08021860f, 0.06100391f, 0.07398688f, 0.01085783f, 0.02789498f, 
    -0.01687659f, 0.03575372f, 0.13468583f, -0.25032315f, -0.10388876f, -0.00290560f, 0.18345664f, 0.20395447f, 
    0.03078583f, 0.02905928f, -0.14517328f, 0.00601063f, -0.12907019f, -0.11327073f, 0.09280290f, 0.01825142f, 
    0.06056435f, 0.03220011f, 0.05629634f, -0.06684469f, -0.01679201f, 0.04575654f, 0.00666335f, -0.03688856f, 
    0.12242536f, -0.03053933f, -0.18143195f, 0.08553407f, -0.10848266f, -0.06766352f, -0.10543469f, 0.00721598f, 
    -0.19151217f, -0.04576094f, -0.17083634f, -0.05399010f, -0.10963251f, -0.14725390f, -0.11524630f, 0.10937541f, 
    0.09573177f, 0.12060880f, 0.19484243f, -0.08763114f, 0.04104854f, 0.09929163f, -0.39426982f, -0.27665824f, 
    0.26812413f, -0.13603510f, 0.03497204f, 0.01818237f, 0.19898325f, -0.00082483f, -0.09654253f, -0.28498811f, 
    0.05934719f, -0.32059461f, -0.34845096f, 0.09506973f, 0.01867706f, 0.07019384f, -0.07659496f, -0.19875199f, 
    0.16581084f, 0.12432477f, 0.21887143f, 0.35555309f, -0.04889271f, -0.01068767f, -0.09510035f, 0.15993227f, 
    0.05676727f, 0.09240506f, -0.27215853f, -0.01721071f, 0.10438789f, -0.37538975f, -0.44096199f, 0.02422108f, 
    0.33723342f, 0.13474944f, -0.34114692f, -0.14552402f, -0.04213726f, 0.13511801f, -0.16446416f, -0.01664915f, 
    0.26830545f, -0.24493334f, -0.20311338f, 0.04575977f, 0.16089320f, -0.01925484f, 0.01362692f, 0.08834603f, 
    0.41003105f, 0.16603784f, -0.01461528f, 0.22326308f, 0.04569515f, -0.05082711f, 0.02580136f, -0.21353827f, 
    0.17669991f, -0.08515225f, -0.02994987f, -0.07065225f, -0.02092080f, 0.45493257f, -0.13558698f, 0.14804703f, 
    -0.21877569f, 0.35705033f, -0.26526704f, -0.22074036f, 0.39229068f, -0.10565144f, -0.17499314f, -0.25183529f, 
    -0.17758115f, 0.15409054f, 0.14119436f, -0.16806734f, 0.16523884f, 0.02607284f, -0.06692288f, 0.26042071f, 
    0.20653318f, 0.13436259f, 0.04479618f, 0.27238020f, -0.31449822f, 0.13301888f, -0.07990939f, -0.03136433f, 
    -0.08281554f, -0.13003173f, 0.02818058f, -0.01451183f, 0.13867870f, 0.15035065f, 0.13147309f, 0.11139160f, 
    0.10063465f, -0.08758507f, -0.10467676f, -0.10800764f, 0.02430766f, -0.00566159f, -0.15096533f, -0.07105773f, 
    0.04411406f, -0.03663805f, -0.13625558f, -0.07541037f, -0.17479585f, -0.02922606f, -0.16788943f, -0.07557113f, 
    -0.19268867f, -0.17463320f, -0.06568310f, -0.07376817f, -0.01545243f, 0.13099240f, 0.16810004f, -0.14707164f, 
    -0.17193319f, 0.13676065f, 0.04987432f, -0.12898324f, -0.11061586f, 0.13663681f, -0.22425447f, -0.11803927f, 
    0.06497682f, 0.15413924f, -0.13932092f, -0.03827868f, 0.38392338f, 0.12032950f, 0.05736064f, -0.18501605f, 
    -0.23555440f, 0.07005423f, -0.21181919f, -0.10203820f, 0.06786802f, -0.15935323f, 0.21931596f, -0.13812123f, 
    0.36559123f, -0.03119854f, -0.00959429f, 0.13823085f, -0.50645506f, -0.08915912f, -0.07139261f, 0.10907245f, 
    0.03503188f, -0.03375180f, -0.36639357f, -0.07474490f, 0.00686208f, 0.37791309f, 0.24320170f, -0.00552663f, 
    0.17702322f, -0.08490285f, 0.07042503f, -0.26732832f, -0.15009861f, -0.17026629f, -0.16631038f, -0.02671792f, 
    0.25079209f, 0.36942950f, 0.16371818f, -0.19042155f, 0.15248427f, -0.14168543f, 0.06361103f, 0.37703374f, 
    -0.07351178f, -0.03903226f, 0.18190475f, -0.17399658f, 0.36032268f, -0.10259695f, -0.01006291f, 0.20051286f, 
    0.13412170f, -0.12331036f, 0.04794892f, -0.06711348f, -0.09072503f, -0.13011537f, -0.06944504f, -0.07924978f, 
    0.06336628f, 0.11294210f, -0.07721002f, -0.16644400f, 0.05933049f, -0.05087242f, 0.12869875f, -0.15176994f, 
    -0.17920254f, 0.06526203f, -0.14894037f, -0.09876107f, 0.15600763f, -0.06392726f, -0.13745677f, -0.13852736f, 
    -0.14727983f, 0.00994179f, 0.01232592f, -0.09854182f, 0.06292474f, -0.08230778f, 0.12811354f, -0.03004496f, 
    0.02489679f, -0.08282642f, -0.22185300f, 0.13384920f, 0.11715042f, -0.30028340f, 0.40712026f, 0.11781773f, 
    -0.13679846f, 0.21745265f, 0.18116170f, 0.50369573f, -0.03370834f, 0.07414268f, 0.03097449f, 0.33849272f, 
    0.27973008f, 0.37395445f, 0.06117418f, 0.14542207f, 0.07064992f, 0.11749052f, 0.11271755f, -0.08672848f, 
    0.03226612f, -0.16694242f, 0.04088090f, -0.30794102f, 0.13158990f, -0.13712998f, 0.16193388f, -0.15703113f, 
    0.00174598f, 0.05737222f, 0.41132849f, -0.01173154f, -0.08694992f, 0.15647037f, 0.13711181f, 0.10838598f, 
    -0.33229589f, 0.02920225f, 0.08008416f, 0.01863332f, 0.24745831f, 0.15324330f, 0.16686390f, -0.16347784f, 
    -0.53484201f, 0.11761302f, 0.43963778f, 0.04294180f, -0.01075488f, 0.02905262f, -0.14726467f, -0.11018703f, 
    0.22808929f, -0.01767280f, 0.21891078f, 0.11597723f, -0.20086956f, 0.12575535f, -0.17008851f, 0.10227800f, 
    -0.04228331f, -0.09185103f, 0.19058177f, 0.10451415f, 0.11881362f, 0.08753436f, 0.34161073f, -0.01188339f, 
    -0.44337237f, 0.28564951f, 0.60348445f, 0.36333627f, -0.05183578f, -0.08652757f, 0.05057371f, 0.00280199f, 
    -0.37363166f, 0.14110233f, 0.44293234f, -0.30526984f, 0.08894264f, 0.09892681f, -0.03858003f, -0.02801943f, 
    0.08456436f, -0.06086686f, 0.18587987f, 0.20105253f, 0.02974159f, -0.12284995f, -0.07390480f, 0.25313684f, 
    -0.12023290f, 0.14919521f, 0.56955206f, -0.01128616f, 0.16150433f, 0.25050125f, -0.03089581f, 0.12318230f, 
    0.46520832f, -0.18363751f, -0.16666661f, -0.12963250f, 0.03043530f, 0.09432258f, 0.03154521f, -0.09637302f, 
    0.14318053f, -0.35295957f, -0.26606947f, 0.16240591f, -0.00041229f, -0.07539485f, -0.18937708f, -0.05702505f, 
    -0.22446863f, -0.14926839f, 0.18051335f, 0.33477128f, 0.25271142f, 0.01729230f, -0.02919620f, 0.03733052f, 
    -0.10207089f, -0.03231878f, 0.01141654f, -0.00920520f, -0.09163961f, -0.04478836f, -0.13450202f, 0.34492669f, 
    0.02309626f, 0.42233542f, -0.25926557f, -0.01848790f, -0.03623274f, 0.06432112f, -0.08134098f, -0.12850007f, 
    -0.33640808f, -0.14799652f, 0.27261847f, -0.03244150f, -0.12941378f, -0.03962261f, 0.34573743f, -0.11516629f, 
    0.14823584f, 0.00622490f, 0.18714896f, 0.05706442f, -0.12032025f, 0.13307178f, -0.12484806f, -0.44320002f, 
    -0.08560333f, -0.08584560f, -0.33774805f, -0.03847609f, 0.00385852f, -0.40285972f, -0.21368904f, 0.35154620f, 
    0.24690184f, -0.22490580f, 0.26259539f, -0.31118089f, -0.14476949f, -0.01443331f, 0.13619468f, 0.03019344f, 
    0.10665169f, -0.07840699f, 0.02304392f, 0.01313290f, -0.13375507f, -0.16996017f, -0.06019472f, -0.14884084f, 
    0.43264440f, -0.14494558f, 0.01826852f, 0.12051219f, 0.29507214f, 0.11940303f, 0.00449431f, 0.15630732f, 
    -0.04570139f, -0.17234588f, 0.43006352f, -0.02759029f, 0.07109987f, -0.17307064f, 0.18300653f, -0.39084521f, 
    -0.01101509f, 0.00384871f, 0.28890571f, 0.46647653f, -0.15351830f, 0.13731296f, 0.06662776f, 0.20451865f, 
    0.14483897f, 0.02914333f, -0.25312269f, 0.22031233f, 0.14510562f, -0.09135550f, -0.03999024f, 0.21015777f, 
    0.22344077f, -0.11381137f, -0.07274335f, -0.20787570f, 0.15618223f, 0.14299634f, -0.01754710f, 0.17720439f, 
    0.02967963f, -0.01240940f, 0.17406157f, 0.12224814f, -0.12484536f, 0.10519498f, 0.47729969f, 0.20557134f, 
    0.19247808f, -0.12560767f, -0.25216067f, 0.47220311f, 0.08176401f, 0.01349192f, -0.12713994f, -0.18624136f, 
    0.14396533f, -0.01387993f, 0.09002462f, 0.33989877f, 0.01524128f, 0.07016236f, -0.10128449f, -0.21196117f, 
    -0.18541759f, 0.15844618f, -0.09484337f, -0.19224118f, 0.03078626f, 0.07595251f, -0.09439176f, -0.10472069f, 
    0.09834550f, 0.01482074f, 0.17479189f, -0.01576547f, -0.08393671f, -0.27029622f, -0.03224367f, 0.02096845f, 
    0.19787021f, 0.05114185f, -0.05335198f, 0.08179952f, -0.10862479f, -0.05251139f, -0.03551905f, 0.23493387f, 
    0.46662256f, -0.06686920f, -0.34865403f, 0.23500003f, 0.14024691f, -0.15292478f, 0.23605077f, 0.05778479f, 
    -0.18151723f, 0.14510013f, -0.13446623f, -0.09696056f, -0.12464364f, -0.17235641f, -0.00454910f, -0.30446944f, 
    0.12314770f, -0.13734350f, -0.19631884f, 0.13402174f, 0.12329000f, -0.09502553f, 0.01468005f, -0.04928910f, 
    -0.19275355f, 0.13024411f, -0.00653865f, -0.07739495f, 0.14126332f, 0.10005497f, -0.05947934f, -0.16224548f, 
    -0.07792401f, -0.04589322f, 0.03662656f, -0.03573450f, -0.11597906f, -0.10048470f, -0.01205907f, -0.19465972f, 
    0.03868224f, -0.12396349f, -0.04448254f, -0.00505561f, 0.02510295f, 0.00311134f, 0.05401913f, -0.09540265f, 
    0.09285796f, 0.09413975f, -0.00948902f, -0.01510794f, -0.11063529f, -0.11778466f, 0.15070310f, -0.04083657f, 
    -0.18059009f, 0.05936297f, 0.00915671f, -0.15020712f, -0.13601857f, -0.03875710f, -0.07879768f, -0.09496351f, 
    -0.11601531f, 0.03456132f, 0.08256561f, -0.11989207f, -0.08713892f, -0.00968859f, -0.07078733f, -0.20123279f, 
    0.08289564f, -0.14171362f, -0.17791268f, 0.09317512f, -0.12337664f, 0.13954568f, -0.07910223f, -0.04247198f, 
    0.08907580f, 0.02847262f, -0.07301483f, -0.19074823f, -0.01955130f, -0.33168206f, 0.27067363f, 0.01276938f, 
    0.39054623f, -0.37537959f, -0.03383625f, 0.07007482f, -0.05718316f, 0.00049761f, -0.03793419f, -0.24684852f, 
    -0.18263657f, 0.09488602f, 0.02926843f, -0.09544870f, -0.11630198f, -0.04868871f, 0.12355365f, 0.01773510f, 
    0.04617804f, 0.07005835f, 0.35222208f, -0.17601673f, 0.52483559f, 0.00082749f, 0.03537093f, 0.06925286f, 
    0.04389775f, 0.04576173f, -0.18361837f, 0.01997749f, 0.16070975f, -0.20418161f, -0.08321327f, 0.24266943f, 
    0.31643555f, -0.05349882f, -0.44069487f, -0.00288999f, 0.07806645f, 0.05433830f, 0.07505774f, -0.04949420f, 
    0.35033023f, -0.31623778f, -0.49982455f, 0.30326036f, -0.14187874f, -0.05799777f, 0.04509358f, -0.33865303f, 
    0.23943892f, -0.04624174f, -0.02160307f, 0.20434289f, -0.10226859f, 0.05196036f, 0.14248089f, -0.02751736f, 
    0.11043304f, 0.08793359f, -0.16644382f, -0.10732442f, -0.04438743f, 0.08383666f, 0.30334082f, -0.09513488f, 
    -0.23580758f, -0.09516773f, 0.06705220f, 0.28036046f, 0.29520851f, -0.14293242f, 0.14901654f, 0.12720948f, 
    -0.24591504f, 0.32413173f, 0.05903044f, -0.01049412f, 0.00460878f, -0.05999560f, -0.12834685f, -0.04578852f, 
    -0.05720071f, 0.06116125f, 0.12789376f, 0.08443593f, -0.01557255f, 0.08434564f, -0.09151585f, 0.30756909f, 
    -0.13365409f, 0.09157967f, 0.04691763f, -0.12795724f, -0.13444521f, -0.01703727f, 0.24223252f, 0.21889934f, 
    0.51136398f, -0.45303905f, 0.00543532f, -0.02536668f, 0.00859466f, -0.05932014f, -0.02982916f, -0.25086966f, 
    0.13240989f, -0.30924338f, -0.05921529f, 0.08347214f, -0.12810749f, 0.15712470f, -0.04354566f, -0.53300595f, 
    -0.18018849f, -0.05115926f, 0.34661183f, 0.22713105f, 0.29293123f, -0.09675222f, 0.08653317f, 0.44268143f, 
    -0.01720451f, 0.11040977f, -0.18438782f, -0.03794793f, 0.03528115f, -0.17704849f, 0.17135549f, 0.26006249f, 
    -0.29539651f, 0.14980772f, -0.29692101f, 0.40923041f, 0.23286766f, -0.14102869f, -0.12486944f, 0.28274059f, 
    0.17535688f, 0.27530459f, 0.38539192f, 0.40632007f, -0.09638043f, 0.13148217f, -0.03875637f, -0.33778113f, 
    0.16523615f, 0.03156163f, -0.10655766f, 0.10316823f, -0.49958742f, 0.10694634f, -0.07148837f, -0.23880635f, 
    -0.09942448f, -0.02339730f, 0.42319533f, 0.08683664f, -0.05500687f, -0.10946438f, -0.41708258f, 0.16886126f, 
    0.25466371f, 0.11175407f, 0.39389831f, -0.14672017f, -0.09855373f, 0.14777066f, -0.17299055f, 0.33793563f, 
    0.08683463f, -0.39637333f, -0.03979949f, 0.29057595f, 0.15796447f, 0.01012079f, -0.06807101f, 0.03466639f, 
    0.31210738f, 0.10968167f, -0.15654694f, 0.05649894f, 0.20746394f, -0.00436609f, 0.09176920f, -0.28865093f, 
    -0.07030326f, -0.15901965f, 0.57922429f, 0.15381351f, 0.13974832f, 0.45636022f, -0.15650453f, -0.25899240f, 
    0.39355642f, -0.14331083f, 0.17762303f, 0.20022133f, 0.27123919f, -0.00893131f, -0.15132070f, -0.21217303f, 
    -0.18261173f, -0.24813347f, -0.20309883f, -0.13466896f, -0.16593884f, 0.15114835f, -0.14301825f, -0.13431962f, 
    -0.28241071f, -0.05399697f, 0.25034550f, 0.32035801f, 0.23521601f, -0.16338612f, -0.14224078f, 0.24494492f, 
    0.16277625f, -0.14213803f, 0.00510518f, -0.04774694f, 0.04575802f, 0.28293812f, 0.15108857f, -0.01848172f, 
    0.08976872f, -0.05004057f, -0.53877020f, -0.14455937f, 0.08357874f, 0.02665160f, -0.09119847f, 0.32202819f, 
    0.12438586f, 0.37471789f, 0.09669391f, 0.34494862f, -0.01370750f, -0.16035041f, 0.25165415f, 0.44043857f, 
    -0.19058992f, 0.06235607f, -0.22564687f, 0.00369067f, -0.00347222f, -0.14880337f, 0.04283204f, 0.22673143f, 
    0.17336766f, 0.12943026f, -0.29751575f, 0.12618789f, 0.09956352f, -0.42743853f, 0.06415810f, 0.22155365f, 
    -0.01259034f, 0.10250045f, 0.44102281f, 0.04347835f, -0.05214052f, 0.11960264f, -0.06137485f, -0.13097571f, 
    -0.14408885f, -0.15381333f, 0.19188838f, -0.47744513f, -0.04754086f, -0.05886493f, 0.18166767f, -0.35106888f, 
    0.26604849f, 0.10065182f, 0.19585395f, 0.21441756f, 0.08388841f, -0.07154570f, -0.12544380f, 0.14215864f, 
    -0.15404731f, 0.18239832f, 0.03699183f, 0.12195048f, -0.11726455f, 0.13631977f, 0.02362209f, -0.05960296f, 
    -0.05251996f, -0.02847418f, 0.41144365f, 0.36385256f, 0.03046457f, 0.00223464f, 0.06414473f, 0.37985742f, 
    0.10560775f, -0.03269307f, 0.27059069f, 0.11714140f, -0.06274635f, 0.00978185f, -0.34296510f, 0.20646375f, 
    0.25309041f, -0.02419191f, -0.11719271f, -0.19781910f, 0.16716784f, 0.14879583f, 0.11923303f, 0.22986807f, 
    -0.13865782f, -0.00984791f, 0.02242993f, -0.02266170f, -0.02263840f, -0.15582465f, 0.29320288f, 0.34059408f, 
    -0.21439286f, 0.30003691f, 0.23241408f, 0.01317506f, -0.38968521f, 0.10359001f, 0.05159917f, 0.04004893f, 
    0.27700740f, -0.12808107f, 0.13509493f, 0.00942066f, 0.12225275f, 0.04809500f, 0.38571438f, -0.11229058f, 
    -0.19170015f, 0.12322754f, 0.12207604f, -0.09126583f, -0.16232137f, -0.13027860f, 0.01811145f, 0.05627175f, 
    0.06757596f, 0.02761065f, 0.04819207f, -0.10661174f, 0.10702046f, -0.37546489f, 0.13752584f, 0.21327002f, 
    0.17016606f, -0.18718195f, 0.42522824f, 0.33859912f, 0.08003686f, -0.03002463f, -0.02509418f, -0.08017680f, 
    -0.42731732f, 0.09678695f, 0.31266233f, -0.06085902f, -0.08040763f, 0.12415920f, -0.28285065f, 0.16713874f, 
    0.37776178f, 0.12748748f, -0.15094750f, 0.10834608f, 0.51232100f, -0.14036316f, 0.03942737f, -0.10391288f, 
    0.05780790f, 0.09930679f, -0.02386254f, -0.02023924f, -0.05549249f, 0.39266834f, -0.13669841f, 0.00686441f, 
    0.01615623f, 0.00172479f, 0.17745531f, -0.13723101f, -0.16832051f, 0.05034265f, 0.17133428f, 0.21719211f, 
    0.63894069f, -0.22258724f, -0.23261184f, 0.20175815f, -0.05564734f, 0.05436290f, 0.10569224f, -0.14962208f, 
    -0.08142017f, -0.07219432f, -0.09187065f, 0.17391807f, -0.02060994f, 0.08040965f, 0.14606518f, 0.48309165f, 
    0.15981318f, 0.06218595f, -0.01170755f, -0.10783967f, 0.10729854f, -0.12523700f, 0.01378596f, 0.18519503f, 
    -0.18022735f, -0.07291017f, -0.35928798f, 0.07297380f, 0.09519533f, -0.02134692f, -0.04078508f, 0.40647000f, 
    0.13511345f, 0.32100189f, 0.03996805f, 0.37216568f, -0.14253521f, 0.17386672f, -0.10692732f, 0.26875576f, 
    0.36030695f, 0.03705176f, -0.20987663f, -0.12490860f, -0.20376696f, 0.08823468f, -0.10562194f, 0.17142840f, 
    -0.07700288f, -0.10824143f, -0.03534857f, 0.13265194f, -0.12159979f, -0.00010834f, -0.23494041f, 0.02173256f, 
    -0.14991206f, 0.01217327f, -0.41296354f, 0.28041527f, 0.26834422f, -0.13183779f, -0.07604706f, -0.13691069f, 
    0.16228917f, 0.23111166f, -0.22808057f, 0.45495409f, 0.06555527f, 0.14914562f, -0.04952339f, -0.25800520f, 
    0.25015768f, 0.08109260f, 0.04738650f, 0.09824919f, -0.48145193f, 0.03623569f, 0.04458485f, -0.18563421f, 
    0.08927612f, 0.01222310f, -0.13849579f, 0.00876790f, 0.11501205f, 0.05494853f, 0.07859174f, -0.16595164f, 
    -0.05709252f, -0.04860887f, 0.14138557f, 0.07319296f, -0.06605151f, 0.14918490f, -0.10358855f, 0.04341426f, 
    0.03256435f, -0.02109233f, -0.19466263f, -0.14823639f, -0.13165914f, -0.05939468f, -0.13586439f, 0.00139596f, 
    -0.18986380f, 0.13323532f, 0.11601965f, -0.19520432f, -0.01536826f, 0.04823343f, -0.05879093f, 0.15823816f, 
    0.09323190f, -0.01955740f, -0.08300097f, 0.17441833f, -0.14966236f, 0.08664957f, -0.08661125f, 0.06015431f, 
    0.01445986f, 0.11798874f, -0.04162358f, -0.18114336f, -0.08974830f, -0.01044411f, 0.05048073f, -0.02297113f, 
    0.11611848f, -0.13713428f, 0.04113263f, 0.05465303f, 0.15665755f, -0.11286078f, -0.12485556f, -0.14553823f, 
    0.04772894f, -0.10856665f, -0.06312948f, -0.17586632f, 0.08962434f, 0.12455437f, 0.09839067f, 0.07034273f, 
    -0.07465916f, 0.11942722f, 0.02681407f, -0.11402011f, -0.05121995f, 0.24227794f, -0.10899328f, -0.11456017f, 
    -0.19202912f, 0.23702841f, -0.33709002f, 0.12235227f, 0.39788955f, 0.11734232f, -0.13788782f, -0.15239851f, 
    -0.41527298f, 0.07897221f, 0.23455529f, -0.00756213f, -0.14630727f, -0.11910290f, 0.28407806f, 0.10928667f, 
    0.17785788f, 0.07143196f, 0.11521586f, 0.11627773f, -0.35066605f, -0.08230191f, -0.10062771f, -0.24621195f, 
    -0.01249119f, 0.03778125f, -0.14266288f, -0.13402873f, -0.07091048f, -0.43669564f, 0.36089954f, 0.30868620f, 
    -0.43419689f, 0.23631141f, 0.16881038f, 0.16426060f, 0.04871643f, -0.13313936f, 0.04499741f, 0.39173719f, 
    0.32764792f, -0.03343423f, 0.41766080f, -0.01319943f, -0.02505126f, -0.00078044f, -0.07557195f, -0.16990091f, 
    0.33765611f, -0.03110656f, 0.04557344f, 0.03052531f, -0.32873282f, -0.08015255f, 0.01917475f, -0.01420150f, 
    -0.15454723f, -0.07966837f, -0.46086824f, -0.12472593f, -0.05585286f, 0.10051847f, 0.10042340f, 0.22888124f, 
    0.06707723f, -0.17371118f, 0.31901976f, -0.36277807f, -0.08107119f, -0.04466198f, 0.15536293f, -0.15725055f, 
    0.22971715f, -0.08400183f, 0.02124686f, -0.26666683f, -0.15851918f, 0.17570047f, 0.04807200f, -0.15629113f, 
    0.12548804f, 0.02954153f, 0.26316431f, 0.24651216f, 0.27541715f, 0.07295569f, -0.05221303f, 0.36416575f, 
    0.02040158f, -0.04435960f, 0.04788781f, 0.05973427f, -0.07165561f, -0.24141337f, -0.44793877f, 0.26457036f, 
    0.23119187f, 0.26512986f, -0.29155150f, -0.29590738f, -0.14558068f, -0.15076280f, 0.17547724f, 0.10609990f, 
    0.42871627f, -0.37188044f, -0.03562748f, 0.27735895f, -0.10476343f, -0.07331183f, 0.18663903f, -0.07018708f, 
    0.44817996f, -0.06519242f, -0.10143029f, 0.23382922f, -0.16093174f, 0.11576054f, 0.09051533f, -0.42883137f, 
    0.08357861f, 0.14945668f, 0.01192644f, -0.04469161f, -0.16594824f, -0.30632004f, -0.20042489f, -0.01418121f, 
    0.24947622f, 0.02691776f, -0.21457219f, 0.10898309f, 0.02224752f, 0.00034067f, 0.09830601f, 0.34367406f, 
    0.34496966f, 0.02297069f, -0.36202690f, 0.47158614f, 0.16266179f, 0.03075860f, 0.16816720f, 0.03639864f, 
    0.40458155f, 0.12577935f, -0.21206017f, 0.10569520f, -0.00101465f, -0.04484612f, -0.09748279f, -0.32267240f, 
    -0.10670324f, -0.16778344f, -0.12334059f, -0.00611825f, -0.17601573f, -0.28229296f, 0.05148195f, 0.35613644f, 
    -0.29178515f, -0.36811098f, -0.24575004f, -0.10471223f, 0.06847467f, -0.00950331f, 0.02481467f, 0.33763158f, 
    0.11194952f, 0.08121245f, 0.42202386f, 0.19708769f, -0.07317993f, 0.07522582f, -0.27752230f, 0.43495661f, 
    -0.07159860f, 0.16756497f, -0.06923267f, -0.08020257f, 0.45110896f, -0.12629411f, 0.07165091f, 0.13865148f, 
    -0.12807640f, 0.01560387f, 0.18988772f, 0.03773684f, 0.15878549f, -0.21711728f, 0.33810657f, 0.18828198f, 
    0.15673947f, 0.14886607f, 0.09338516f, 0.15344523f, -0.01908008f, -0.15135852f, 0.08806552f, -0.07353924f, 
    -0.39221171f, 0.27547216f, -0.02424346f, -0.17499973f, 0.01333819f, 0.14494942f, 0.36650497f, 0.17561005f, 
    -0.26487914f, -0.11441410f, 0.12161145f, -0.10034490f, 0.37330568f, -0.18129621f, 0.06171456f, -0.27157027f, 
    -0.01801894f, 0.17287071f, -0.04043020f, -0.11384405f, 0.15964122f, -0.34246904f, 0.36732897f, -0.11219084f, 
    0.09118196f, 0.13210431f, -0.36944801f, 0.40299338f, -0.31068879f, -0.16110900f, 0.02374393f, -0.07036392f, 
    0.18092287f, -0.02334253f, 0.34668559f, -0.11361437f, 0.07651596f, -0.04053210f, -0.11909860f, 0.25549647f, 
    -0.17537501f, 0.09678426f, -0.06603892f, -0.16460440f, 0.27463558f, 0.10706523f, 0.12752432f, 0.30784491f, 
    -0.09439664f, 0.09345607f, 0.21233349f, -0.15272023f, -0.07863264f, 0.68908513f, 0.11173958f, -0.23761058f, 
    -0.24275860f, 0.05541864f, 0.22056998f, -0.04954491f, 0.26813734f, -0.05299219f, -0.04564083f, 0.41302916f, 
    0.22974251f, 0.22163491f, 0.02432484f, -0.03442668f, 0.07412525f, -0.16637330f, -0.03910276f, 0.27045506f, 
    -0.19950393f, -0.15286106f, -0.08266649f, 0.12017544f, -0.27131423f, -0.05000337f, 0.03429439f, 0.55957645f, 
    0.09554775f, 0.06190147f, 0.13727152f, -0.09299026f, -0.12528042f, 0.21354499f, 0.15273607f, -0.06363817f, 
    -0.10024566f, 0.29782128f, 0.10243012f, -0.05954365f, -0.18595244f, -0.14615102f, 0.03316353f, 0.42227241f, 
    0.47730246f, 0.45250356f, -0.18059571f, 0.20801595f, -0.08042063f, -0.17185692f, -0.01992607f, 0.33160475f, 
    -0.26386940f, 0.05910021f, 0.02761849f, -0.07774732f, 0.08668039f, 0.15674348f, -0.07139638f, -0.22900623f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03726140f, 0.10286591f, 0.24915749f, 0.12325718f, 0.06099222f, 0.18490106f, 0.22904581f, 0.20686495f, 
    0.00283734f, 0.13297200f, -0.15309063f, 0.03752376f, -0.05381255f, 0.02288776f, 0.24517874f, 0.18275793f, 
    -0.11887833f, 0.06514402f, -0.06610475f, 0.11849807f, 0.22170681f, 0.01833703f, -0.12947007f, 0.12229843f, 
    0.07269569f, 0.02126216f, 0.16769311f, -0.00130150f, 0.08710579f, -0.22040692f, 0.25044343f, 0.28730252f, 
    -0.14940622f, 0.04496755f, 0.18967754f, -0.18386589f, -0.10818368f, 0.25814077f, 0.26770562f, 0.15883520f, 
    -0.10980736f, -0.18939927f, -0.10606705f, -0.21845233f, 0.00275955f, 0.16751814f, 0.16867870f, 0.02526717f, 
    0.19106574f, 0.10728364f, 0.18618824f, -0.04693360f, 0.03010948f, -0.13563646f, 0.13899611f, 0.10388829f, 
    0.01943973f, -0.06610147f, 0.03604471f, 0.01902012f, 0.07780509f, 0.00349288f, -0.10893881f, 0.02410508f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.38511047f, 0.38178375f, -0.00609927f, 0.10453861f, -0.26407212f, 0.07496566f, -0.18127759f, -0.00425941f, 
    -0.41417402f, -0.27780670f, 0.10783485f, -0.32265157f, 0.04474598f, -0.09619890f, 0.15047857f, 0.28809440f, 
    -0.28943819f, -0.03574039f, -0.08613583f, 0.23055406f, -0.11362667f, -0.18213369f, -0.07971736f, 0.00612568f, 
    -0.08638777f, 0.00072198f, -0.05986006f, 0.13359590f, 0.07547122f, 0.16234839f, 0.22235219f, -0.10819133f, 
    -0.14708167f, -0.12463433f, -0.15795015f, 0.04962503f, -0.18048863f, 0.46062782f, -0.17958653f, 0.12976290f, 
    0.21205391f, -0.54305023f, -0.20038109f, 0.38597101f, -0.28061557f, 0.26982298f, -0.29212657f, -0.04405621f, 
    0.14157349f, -0.48092902f, -0.68268859f, -0.23053156f, 0.03728952f, 0.07700021f, 0.09760743f, -0.38425538f, 
    0.06190829f, -0.32592177f, -0.18873656f, -0.41405126f, 0.36917791f, -0.37392461f, -0.43329579f, -0.25075588f, 
    -0.40958107f, 0.38005009f, -0.10122396f, -0.28680390f, 0.05787528f, -0.06844510f, -0.09849162f, 0.17210807f, 
    -0.06176944f, -0.28092736f, -0.07341856f, -0.06687214f, -0.04771662f, -0.00139900f, 0.36273974f, 0.29989526f, 
    -0.24714766f, 0.40898731f, -0.02427245f, -0.27531081f, -0.33665761f, -0.34359390f, 0.08523255f, -0.35698667f, 
    0.20965627f, 0.09703599f, 0.11552427f, -0.09166218f, 0.10771719f, -0.09347615f, -0.26669639f, -0.15989308f, 
    0.22193792f, 0.21539932f, -0.33127922f, 0.02919776f, -0.09754885f, 0.25611705f, -0.36546484f, 0.15108025f, 
    0.02316880f, -0.30968636f, -0.27958006f, 0.06009001f, 0.15471941f, 0.03317062f, 0.13792345f, 0.15437472f, 
    -0.06239304f, 0.00766105f, -0.02116315f, -0.86600989f, -0.10825023f, -0.09475287f, -0.19510330f, -0.02768474f, 
    -0.00484281f, -0.66118985f, -0.15308721f, -0.07265531f, 0.11565903f, 0.58708459f, 0.21622965f, 0.08302008f, 
    -0.29636246f, -0.46031719f, 0.19262703f, 0.02456626f, -0.45962581f, 0.15117070f, -0.22128861f, -0.72646946f, 
    -0.61336654f, -0.22040720f, 0.08021060f, -0.56989557f, -0.44978741f, -0.08854587f, -0.21447898f, -0.35369030f, 
    0.24369885f, 0.30632874f, 0.10388988f, -0.57510698f, 0.03577858f, -0.02543026f, 0.09356596f, -0.44930109f, 
    0.03247490f, -0.11811392f, -0.01125880f, 0.28881431f, 0.12822336f, -0.10564796f, 0.31190321f, 0.43009001f, 
    -0.59717244f, 0.25465402f, -0.20848840f, 0.03671288f, 0.00279001f, 0.13172548f, -0.06354807f, -0.15130913f, 
    0.13764031f, 0.28265822f, 0.09978805f, -0.51334137f, -0.16853517f, 0.24141636f, 0.08972482f, 0.20534296f, 
    0.25262186f, -0.33318484f, 0.06568178f, 0.10284423f, -0.10579772f, -0.04041019f, -0.11607637f, 0.31684738f, 
    0.21188010f, 0.18440053f, -0.14367203f, 0.43403706f, 0.09368500f, 0.04307557f, -0.70925128f, -0.15085247f, 
    -0.01811500f, -0.08517705f, -0.31508532f, 0.20218311f, 0.15059461f, -0.19651580f, 0.30949509f, -0.13021991f, 
    0.06025799f, 0.37702814f, 0.07530767f, 0.06730961f, 0.09364196f, -0.09952867f, -0.27495247f, -0.39139667f, 
    0.35579485f, -0.73537570f, -0.05457534f, -0.21621516f, -0.03311004f, 0.15407147f, -0.11090824f, 0.05207601f, 
    -0.19245920f, -0.03184700f, -0.19609502f, 0.18142721f, 0.01378263f, -0.11285260f, 0.36597449f, -0.71506196f, 
    -0.08871195f, -0.02870977f, 0.22879165f, -0.05758089f, -0.02163787f, -0.62937438f, -0.68445021f, -0.22029972f, 
    -0.72638035f, -0.13282616f, 0.29089233f, -0.07699279f, 0.21218863f, -0.15275848f, -0.15060820f, 0.17789313f, 
    -0.29802644f, -0.25288334f, -0.02559629f, -0.32224038f, -0.03613229f, 0.02439559f, 0.30179679f, -0.12048245f, 
    -0.51165324f, 0.28569824f, -0.00291146f, 0.29248160f, 0.23885635f, 0.30715328f, 0.08073216f, 0.21889462f, 
    0.08448247f, -0.41321412f, 0.14779676f, 0.35562941f, -0.31058624f, 0.33859241f, 0.12982365f, -0.08957329f, 
    -0.17235287f, 0.06733895f, 0.09606306f, 0.09708861f, 0.01349496f, 0.01548323f, -0.11985491f, 0.00493668f, 
    -0.32519299f, -0.19752558f, 0.02083047f, 0.11817793f, 0.17133012f, 0.08010717f, 0.08459067f, 0.22742759f, 
    -0.00731581f, -0.11656305f, -0.12598361f, -0.08271926f, -0.18205144f, -0.18050131f, 0.06879955f, 0.18313286f, 
    -0.44949862f, -0.80532235f, -0.55871511f, -0.01012413f, -0.18930121f, -0.05771973f, 0.25319019f, 0.02749682f, 
    0.04003277f, 0.05243525f, -0.19340244f, -0.21597347f, 0.07564531f, 0.14312015f, -0.19337282f, 0.11510991f, 
    -0.33936742f, 0.22044654f, 0.05131680f, 0.04765363f, -0.09371211f, 0.07650560f, 0.05407754f, 0.03951389f, 
    0.22981399f, 0.14127830f, -0.01377132f, 0.06710357f, -0.15079309f, 0.32614872f, 0.06908387f, -0.21721095f, 
    0.12692772f, 0.06148552f, 0.05985256f, -0.13992321f, 0.17483072f, -0.14224836f, -0.39056128f, 0.25125924f, 
    0.14957841f, -0.12253207f, 0.05211054f, -0.30589026f, 0.16544122f, -0.01716339f, 0.24429110f, 0.02281652f, 
    -0.27027783f, 0.21677862f, -0.02708977f, 0.03779138f, -0.10597847f, -0.04828717f, -0.08960722f, -0.12029023f, 
    -0.01496537f, -0.10680041f, -0.07826626f, -0.05720274f, -0.40234551f, 0.22613542f, -0.30182645f, -0.14274116f, 
    0.01565826f, 0.40440345f, 0.09890275f, -0.04998977f, 0.04396849f, -0.05724342f, 0.13921849f, 0.14283584f, 
    0.05610428f, 0.00792426f, -0.05812472f, 0.15224919f, 0.33848608f, -0.63609117f, 0.08652727f, -0.45526764f, 
    -0.07138020f, 0.05615180f, 0.23326516f, 0.23484378f, 0.02045836f, 0.04461351f, 0.02567921f, -0.34435296f, 
    -0.22039872f, -0.20726465f, 0.09018116f, 0.52442032f, -0.11004185f, -0.32402357f, 0.10388725f, 0.18142295f, 
    -0.11894802f, -0.36167923f, 0.01046971f, -0.24522069f, -0.24970269f, 0.29431182f, 0.13659851f, 0.04067401f, 
    -0.16199805f, 0.38174874f, -0.11644599f, -0.51082462f, 0.19515894f, -0.00528778f, -0.21100388f, -0.34797117f, 
    -0.21447095f, 0.03909635f, 0.03495388f, 0.00808740f, 0.26861715f, -0.44384399f, -0.10940261f, -0.16836387f, 
    -0.24259788f, -0.07142792f, 0.15731052f, -0.53179210f, -0.51312137f, 0.09823640f, 0.04150299f, -0.08276661f, 
    0.05897425f, 0.26968595f, 0.46879363f, 0.08327013f, -0.01245430f, -0.02570191f, 0.40310404f, -0.49777025f, 
    0.04974571f, 0.22747350f, 0.12825124f, -0.26940483f, 0.02432894f, -0.09219370f, -0.20095645f, 0.37423241f, 
    -0.33674258f, 0.21461840f, -0.00943113f, 0.33467597f, -0.01698307f, 0.07187839f, -0.16869837f, 0.05703613f, 
    -0.19698559f, 0.43081903f, 0.27125463f, -0.80635035f, 0.00400326f, -0.11018766f, -0.34636542f, 0.21612386f, 
    0.19600545f, 0.05702936f, -0.46913746f, 0.13672140f, -0.17086378f, -0.00558552f, -0.02733767f, -0.12597887f, 
    -0.28208366f, -0.30783910f, -0.01280203f, 0.26633313f, -0.01873522f, -0.05428810f, -0.44919252f, -0.10981157f, 
    -0.16036056f, -0.19024000f, -0.03309326f, 0.32346323f, -0.60622144f, 0.26988807f, -0.06332004f, 0.12083940f, 
    -0.16525184f, -0.10441216f, -0.46818051f, 0.22113693f, 0.23276289f, 0.34481028f, 0.04976564f, -0.33039936f, 
    -0.34694186f, 0.00716466f, -0.29432657f, -0.09976929f, 0.06027017f, -0.38509986f, -0.32181013f, 0.05119875f, 
    0.06662075f, -0.15234669f, -0.26227003f, 0.45590073f, -0.26808375f, 0.03839057f, -0.21049300f, -0.06075450f, 
    -0.34630105f, 0.19163856f, -0.72258687f, 0.02177494f, -0.06898972f, -0.11389734f, 0.16354214f, -0.24390078f, 
    0.09103376f, -0.28035092f, -0.75693250f, -0.17639865f, -0.28931484f, -0.13330393f, 0.31493261f, -0.11462925f, 
    -0.60017425f, -0.01220788f, 0.03106568f, -0.62322485f, 0.36083952f, -0.51611799f, -0.36313847f, -0.45222345f, 
    0.15325007f, -0.41094694f, 0.10586195f, -0.00909808f, -0.69739407f, -0.06815948f, -0.24188189f, 0.28834403f, 
    0.39364493f, -0.28417739f, -0.02356050f, -0.14449619f, -0.43608585f, -0.33112654f, -0.10366081f, -0.38333952f, 
    -0.11027764f, 0.05005088f, 0.15001908f, -0.05709351f, 0.26235834f, -0.05643881f, -0.67085081f, 0.03645200f, 
    0.29276335f, -0.16502972f, 0.09936102f, 0.01297121f, 0.07795902f, -0.26497808f, -0.36086708f, 0.14696322f, 
    -0.04738666f, -0.02890948f, 0.27348623f, 0.02219379f, -0.22073141f, 0.08190497f, 0.31702334f, 0.11930273f, 
    0.10504059f, 0.34128064f, 0.03135896f, -0.19878484f, -0.00440735f, -0.06183043f, -0.53595054f, 0.22080201f, 
    0.06722343f, -0.36484027f, 0.03363558f, -0.07757962f, -0.09028204f, -0.22080718f, 0.26240972f, 0.30596665f, 
    -0.03048403f, 0.00279623f, 0.10336012f, -0.16022900f, -0.40801591f, 0.17170414f, -0.58965033f, 0.02217989f, 
    0.05876413f, -0.13406122f, 0.00232835f, 0.31517959f, 0.24432927f, 0.04110950f, 0.14620502f, 0.32128105f, 
    -0.28527018f, -0.54958767f, -0.01935300f, 0.26122212f, 0.45495111f, -0.04853768f, 0.08919861f, -0.04696457f, 
    0.18151596f, 0.05233868f, -0.17360966f, -0.43010509f, -0.46532056f, 0.21956539f, -0.16670759f, 0.38850808f, 
    -0.01480504f, -0.67922384f, -0.06965432f, 0.06150945f, -0.09799220f, 0.23873894f, 0.26107994f, -0.49435180f, 
    0.08662751f, -0.85865510f, 0.35175407f, 0.13611953f, -0.06328894f, 0.09753556f, 0.04928031f, -0.37239519f, 
    0.09687202f, 0.14682002f, -0.15675330f, -0.47142386f, 0.01671591f, 0.04068766f, -0.29315850f, -0.35196528f, 
    0.21784231f, 0.36954269f, 0.15986021f, -0.60311025f, -0.12564969f, -0.59806401f, -0.18071519f, -0.03666597f, 
    -0.32136935f, -0.11191272f, 0.17699446f, 0.20052199f, 0.25039017f, -0.25772789f, 0.40161291f, -0.01313461f, 
    0.11261750f, -0.19269964f, 0.02849822f, 0.23221892f, -0.54003423f, -0.04053887f, -0.63340729f, 0.07740653f, 
    -0.04405558f, 0.36661711f, -0.10188006f, -0.45047995f, -0.15312670f, 0.22459662f, -0.06262555f, 0.07666956f, 
    0.24534106f, -0.04759669f, 0.29588154f, -0.06539319f, 0.12646979f, -1.07416284f, 0.03102356f, -0.29546413f, 
    -0.17436567f, -0.01762878f, -0.18315788f, 0.08330089f, -0.08514827f, -0.19168085f, -0.71245480f, 0.18447614f, 
    -0.68303657f, 0.21621007f, -0.44205785f, -0.64132899f, 0.13817273f, 0.10134137f, 0.00392790f, -0.00363921f, 
    -0.01307887f, -0.34065419f, 0.17091401f, 0.17459753f, -0.12448760f, -0.03303864f, 0.22420797f, 0.16688396f, 
    -0.00015219f, -0.19178744f, -0.03057843f, -0.30377984f, 0.07910425f, 0.49809119f, 0.05786308f, 0.26260227f, 
    -0.04951005f, 0.09179071f, -0.24542874f, -0.23162964f, 0.31028026f, -0.48819730f, 0.00476703f, -0.27067339f, 
    0.09754239f, 0.18717347f, 0.07271646f, -0.35353783f, -0.11502653f, -0.02097077f, -0.03375573f, -0.38089609f, 
    0.43657956f, 0.03859257f, -0.13666487f, 0.18275371f, 0.13633694f, 0.02301889f, -0.08701818f, 0.18989432f, 
    -0.54952735f, 0.05743205f, -0.01354758f, 0.19597466f, 0.11179882f, -0.26799160f, -0.02564470f, -0.02427896f, 
    0.37198454f, -0.03006852f, -0.21721116f, -0.09403233f, 0.08340049f, -0.24577302f, 0.02880897f, 0.00836185f, 
    -0.30983591f, 0.28183135f, 0.20340382f, -0.12382050f, -0.29979554f, 0.10668833f, 0.25088295f, -0.49566177f, 
    0.19278876f, -0.36796334f, 0.26018158f, 0.38982409f, 0.02334919f, -0.07202713f, 0.15743449f, 0.23339610f, 
    -0.34228584f, 0.17957966f, 0.21915503f, -0.51520860f, -0.34256709f, -0.24555023f, -0.15408984f, -0.39911255f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05769678f, -0.06006063f, -0.16928594f, -0.12172219f, 0.09178799f, -0.01443193f, -0.00599552f, -0.35262376f, 
    -0.10481902f, -0.00886942f, 0.04335841f, -0.07994073f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
