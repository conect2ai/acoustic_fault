#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64545864f, 0.78171217f, 0.61540502f, 0.06012015f, -0.11911150f, -0.76076943f, -0.53450602f, -0.10623476f, 
    -0.07917215f, -0.19070935f, 0.06589656f, -0.53067803f, -0.39889917f, -0.18899457f, -0.07678760f, -0.11329119f, 
    0.38461986f, 0.28405508f, 0.27139893f, 0.25358102f, -0.01495436f, -0.22914568f, -0.34143549f, -0.26422036f, 
    -0.15039067f, -0.03337409f, -0.73211849f, -0.12648815f, 0.00216055f, 0.41518861f, -0.01473601f, -0.05892379f, 
    0.10010327f, 0.09327822f, -0.06569123f, 0.21543469f, 0.37736893f, -0.14225511f, -0.18980782f, -0.00189572f, 
    -0.23045886f, -0.14181232f, 0.03130289f, -0.29743892f, -0.21744744f, 0.17505002f, 0.53179091f, 0.17615728f, 
    0.38972363f, 0.72593844f, 0.51026684f, 0.49998698f, 0.07475211f, -0.53142154f, 0.60618985f, -0.90516007f, 
    -0.44800994f, 0.08277841f, 0.06452437f, 0.68035614f, -0.07978237f, 0.18366694f, 0.46655941f, -0.03841973f, 
    -0.13015087f, 0.09525498f, -0.05627763f, 0.00395506f, 0.22342293f, -0.23412615f, 0.36675295f, -0.19484487f, 
    -0.09142385f, 0.36681315f, -0.36362082f, 0.51077342f, 0.98660946f, 0.71742570f, -1.01480389f, -1.07164502f, 
    -0.08117687f, 0.04040092f, 0.05365577f, 0.12784460f, -0.34442067f, -0.13404100f, -0.23805614f, -0.03605270f, 
    0.29097429f, 0.09348776f, 0.42496344f, -0.05457014f, 0.05182233f, -0.42389959f, 0.14566399f, -0.13977179f, 
    -0.15495984f, -0.17709908f, -0.26807451f, -0.49589753f, 0.80357182f, -0.41330793f, -0.27086750f, 0.19130005f, 
    0.70763946f, 0.31468147f, -0.26175755f, -0.25152901f, 0.17895927f, 0.37293941f, -0.11186995f, 0.08493566f, 
    -0.15057695f, -0.70485914f, -0.07622144f, -0.31151316f, -0.27847072f, 0.09160117f, -0.07004490f, -0.04400171f, 
    -0.03519589f, -0.26546031f, -0.07213954f, 0.20540878f, 0.37666088f, -0.08335425f, -0.23796767f, -0.90943187f, 
    -0.49366117f, -0.09446226f, -0.76851457f, -0.86041021f, -0.40594092f, -0.81093132f, -0.94367194f, 0.48972473f, 
    -0.63791567f, 0.32618803f, 0.54621166f, -0.13558444f, 0.17941394f, -0.03692532f, -0.12255521f, 0.12089453f, 
    -0.08979414f, -0.20724563f, 0.12493676f, 0.44654796f, -0.04615853f, 0.33193552f, 0.39253271f, 0.45898905f, 
    0.52593511f, 0.05950285f, -0.64977396f, -0.14218193f, 0.13513201f, -0.06496719f, -0.05631924f, -0.00438725f, 
    -0.22789815f, -0.16330878f, -0.14312607f, -0.05971556f, -0.28040656f, 0.19152294f, 0.38975918f, -0.25912908f, 
    -0.01970547f, 0.21011221f, -0.08900321f, -0.01896210f, 0.00421994f, 0.26954246f, 0.66270912f, -1.27182257f, 
    -1.03647673f, -0.27555430f, 0.26643348f, 0.55277967f, -0.12152971f, -0.44701114f, -0.75078952f, -0.42272955f, 
    -0.03402516f, -0.30578649f, -0.57710218f, -0.41263473f, 0.21603096f, -0.48501343f, -0.27386853f, -0.49139383f, 
    -0.39962840f, -0.34594244f, -0.42413908f, -0.39092296f, -0.21194504f, -0.29932258f, 0.04249518f, -0.26303914f, 
    -0.76536262f, 0.42897299f, 0.37195641f, 0.60751832f, 0.33017650f, -1.11492777f, -0.68061155f, 0.39735466f, 
    0.22341213f, 0.18963018f, -0.17834502f, 0.64304984f, -0.40164617f, 0.15984681f, -0.13299757f, -0.08183759f, 
    0.13518429f, -0.00900203f, -0.45170629f, -0.32144147f, -0.35331076f, 0.12259495f, 0.08721551f, -0.06254362f, 
    0.12789387f, 0.45594239f, 0.22361913f, 0.71946305f, 0.28303453f, 0.11125419f, -0.13679421f, -0.71688914f, 
    -0.68933219f, -0.41364583f, -0.24560793f, 0.26966506f, -0.09189641f, 0.12266389f, -0.09915856f, 0.58996266f, 
    -0.27165404f, -0.13203916f, 0.01361816f, 0.19085713f, 0.09961661f, -0.07351578f, 0.18992035f, 0.03444485f, 
    0.12524410f, 0.07267215f, 1.30702353f, -1.03691995f, -0.74118090f, -0.92989314f, -0.80238724f, -0.04072972f, 
    0.74861300f, 1.01547277f, 0.13833760f, -0.02593585f, -0.00339056f, 0.09057003f, -0.08172930f, -0.61467499f, 
    -0.18177207f, 0.29993546f, -0.21907249f, 0.03636073f, 0.26365477f, -0.15063973f, 0.10109179f, -0.09995704f, 
    -0.23450334f, 0.27110630f, 0.44488978f, -0.14512187f, -0.02542196f, 0.44255579f, 0.58714926f, 0.00997571f, 
    0.15569921f, 0.04521107f, -0.11488451f, 0.20416822f, 0.36211675f, 0.44273338f, -0.43910363f, -0.48924950f, 
    0.03378978f, -0.01510044f, -0.18604992f, -0.17885505f, -0.20723210f, 0.46352774f, 0.09834773f, -0.12510243f, 
    -0.20679666f, -0.33268300f, 0.17363636f, -0.19017813f, -1.60268164f, -0.54930466f, -0.12926510f, -1.15048814f, 
    -0.66847587f, 0.87753499f, 0.62909108f, -0.98548472f, -0.58907193f, 0.87072855f, 0.12343252f, 0.45252234f, 
    -0.70615023f, -0.51846969f, -0.71010137f, -0.10794759f, 0.40662193f, -0.02482988f, 0.38873377f, 0.03094886f, 
    0.18369378f, -0.08216136f, -0.05372666f, 0.02430957f, -0.14815356f, 0.46416271f, 0.51766139f, 0.49423495f, 
    0.15142736f, 0.38207445f, 0.17309593f, 0.24010812f, 0.29358837f, -0.07608979f, 0.15284765f, 0.32770556f, 
    0.07758111f, 0.15105307f, 0.02530856f, 0.27371007f, 0.30816185f, 0.07580085f, -0.13658476f, -0.16908121f, 
    -0.41975948f, -0.11877628f, 0.29914778f, -0.02475918f, 0.01446609f, 0.08705311f, 0.63143200f, 0.07568765f, 
    0.11647383f, 0.22151297f, 0.46678260f, -0.08197932f, 0.08242416f, 0.13369447f, -0.06384894f, 0.07399197f, 
    0.19948629f, 0.28970942f, 0.07773312f, -0.29305407f, 0.18901066f, 0.01660713f, 0.31465605f, 0.12890705f, 
    -0.01012036f, -0.05094519f, 0.10425850f, -0.07350241f, -0.13563040f, -0.30211967f, -0.42640543f, 1.19660151f, 
    -0.49732241f, -0.32660684f, -0.02235444f, -0.10878129f, 0.61274976f, 0.23252036f, 0.16193129f, 0.03784487f, 
    0.04811806f, 0.00744826f, -0.20753320f, -0.26160857f, -0.32435516f, 0.08195833f, 0.12812875f, 0.00450963f, 
    -0.01011457f, -0.21188255f, -0.29450557f, -0.16987497f, -0.18863228f, -0.22965768f, -0.39111692f, -0.41280717f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03267821f, 0.08031344f, 0.25062579f, 0.49867982f, 0.71055806f, 0.31724599f, 0.43185928f, 0.18126775f, 
    0.28726178f, 0.31804302f, 0.49279472f, -0.13264726f, -0.00309586f, 0.21060140f, -0.24054867f, 0.33052608f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08225481f, -0.18478461f, 0.25940526f, 0.26997095f, -0.00257974f, 0.03004694f, -0.08533566f, -0.00129274f, 
    -0.00422104f, -0.06503896f, -0.07879131f, -0.08575387f, -0.09780765f, -0.12906247f, -0.08616959f, -0.06948188f, 
    -0.14097071f, 0.05294003f, -0.11323996f, -0.01114586f, 0.19044246f, -0.02322482f, 0.05308840f, 0.05974869f, 
    0.26532722f, -0.17908110f, 0.15165751f, -0.02012309f, -0.20120884f, 0.00995986f, -0.02391985f, 0.07913201f, 
    -0.13340826f, 0.02544394f, 0.04771220f, -0.09478442f, -0.00139415f, -0.16690998f, 0.07622594f, 0.07850721f, 
    0.06212606f, -0.03545045f, -0.15759629f, 0.02648263f, -0.24346983f, -0.08215973f, 0.07269554f, -0.15766400f, 
    -0.14438614f, 0.24477610f, -0.14726081f, -0.04750403f, -0.14959484f, -0.04860888f, -0.08943167f, -0.01945973f, 
    0.01601944f, 0.03532026f, 0.10553439f, 0.22208303f, 0.01947544f, -0.06146314f, 0.12662612f, 0.25488129f, 
    0.18882695f, 0.23401757f, -0.07834247f, -0.08299088f, 0.10026153f, -0.02964890f, 0.13887240f, 0.12240236f, 
    -0.11799984f, 0.05880832f, 0.20253311f, 0.12212646f, 0.16347297f, -0.18360366f, -0.14470890f, 0.01401777f, 
    0.09068658f, 0.10719395f, 0.05990807f, 0.12928171f, -0.20918883f, 0.17045403f, 0.08439543f, -0.09735362f, 
    0.05587146f, 0.09611975f, 0.10174287f, 0.04911140f, 0.24393605f, 0.22537555f, 0.12898724f, 0.15639924f, 
    0.82400811f, 0.42806414f, 0.27383158f, 0.08479054f, 0.09770715f, -0.05956040f, 0.05969626f, -0.04703138f, 
    -0.01683177f, 0.05867553f, 0.18960027f, 0.07303195f, -0.07575026f, 0.07026031f, 0.18053913f, 0.09769843f, 
    0.03391896f, -0.13752931f, 0.01105566f, 0.02787866f, 0.06958967f, 0.01739271f, -0.00988017f, 0.05095035f, 
    0.06976980f, -0.12388056f, -0.03273637f, 0.26712739f, -0.02294564f, -0.01765391f, -0.35454243f, 0.23950715f, 
    0.13141218f, 0.10451851f, 0.17762485f, 0.22628051f, 0.00973849f, -0.00256486f, -0.12523283f, -0.06618923f, 
    0.07380030f, -0.17684409f, -0.01873407f, -0.00077759f, -0.11262578f, -0.05627440f, 0.01286959f, 0.12485863f, 
    -0.44296342f, 0.15616108f, -0.02411605f, 0.27580354f, 0.01512573f, 0.13934310f, 0.21511844f, -0.06261019f, 
    -0.11906420f, 0.06014822f, 0.22365969f, 0.00838545f, -0.15055430f, -0.05985763f, -0.10117724f, 0.03194828f, 
    -0.01519625f, -0.02672180f, -0.05927623f, -0.02041287f, -0.01914514f, -0.06680996f, 0.03521921f, 0.14593078f, 
    -0.09334935f, -0.09256423f, 0.01254462f, -0.00418723f, 0.03895143f, 0.01802146f, 0.05843504f, -0.04599592f, 
    -0.07852066f, 0.22387139f, -0.13270843f, -0.28088501f, -0.37781981f, 0.15547317f, -0.24936716f, -0.15630610f, 
    0.07054137f, -0.00463824f, 0.09301671f, -0.01789057f, -0.02495334f, -0.11557320f, -0.02571228f, -0.19100188f, 
    0.22736374f, -0.24555592f, 0.23724341f, -0.02132803f, -0.08537567f, -0.12723850f, -0.01307337f, 0.02886065f, 
    -0.13364851f, -0.15106511f, -0.01883966f, -0.06095766f, -0.12070640f, -0.00082102f, -0.08584885f, 0.02008560f, 
    0.18843895f, 0.00606146f, -0.21249925f, -0.04019045f, -0.12090231f, 0.03427092f, -0.02139700f, -0.01156413f, 
    0.16182107f, 0.29714087f, 0.37197497f, 0.05569850f, 0.00108955f, 0.07391473f, -0.13788942f, -0.11176088f, 
    0.04481235f, -0.03830877f, 0.11680597f, 0.10718082f, 0.13452022f, 0.03292717f, 0.39593944f, -0.23401618f, 
    0.15168497f, -0.08675237f, 0.32377258f, 0.23091014f, 0.24520727f, 0.05168396f, 0.01574819f, -0.01240290f, 
    0.45218116f, 0.48670918f, 0.17974024f, 0.38977760f, -0.21869269f, -0.08723653f, -0.02763545f, -0.02232186f, 
    0.04563023f, -0.04117253f, -0.06300062f, 0.03165143f, -0.18312795f, -0.19087683f, -0.02207049f, 0.33073285f, 
    -0.19052367f, -0.11182971f, 0.21279688f, 0.10389760f, -0.17356892f, -0.04329409f, -0.00392393f, 0.06230278f, 
    0.17509641f, 0.01164218f, 0.05144208f, -0.05846744f, -0.11710899f, -0.02870850f, 0.02069560f, -0.05425821f, 
    -0.05308459f, -0.03261611f, -0.01051707f, -0.04156756f, -0.35265329f, -0.08967485f, -0.12710726f, 0.47260952f, 
    0.17318107f, 0.11986126f, 0.16872729f, 0.20358750f, 0.19521293f, 0.09164535f, 0.11843207f, 0.02251425f, 
    -0.02414251f, 0.19663353f, -0.06940462f, 0.00633937f, 0.28969750f, 0.09421987f, -0.07225706f, -0.04936606f, 
    0.10949349f, 0.07914843f, -0.00146734f, 0.16983536f, 0.26970214f, 0.18265370f, -0.07556958f, -0.07572333f, 
    -0.07719308f, -0.06896945f, -0.14566064f, -0.16004242f, -0.16707744f, -0.04640052f, -0.05238742f, 0.05165297f, 
    0.39373806f, -0.05017376f, 0.56509292f, -0.18074706f, 0.01312999f, 0.07736974f, 0.10694750f, 0.09865370f, 
    0.04750775f, 0.02464838f, 0.06088860f, -0.00582109f, 0.02975950f, 0.02750053f, -0.09632920f, 0.02251260f, 
    -0.10660049f, -0.01920500f, 0.00003395f, -0.13707833f, 0.35056713f, 0.03974741f, 0.09448779f, -0.01266536f, 
    0.04916015f, -0.12561028f, -0.12724525f, 0.08726165f, -0.01677370f, -0.10823820f, -0.21793899f, 0.12021591f, 
    -0.04053043f, -0.05696701f, -0.05453952f, 0.29995668f, 0.14214855f, 0.23006688f, 0.08603372f, 0.01739736f, 
    -0.17870253f, -0.11354124f, -0.03268593f, -0.05960689f, -0.02311186f, 0.17428362f, 0.17939009f, 0.07187801f, 
    -0.04012499f, -0.00723570f, 0.06706538f, -0.07382789f, -0.15037228f, 0.02040724f, 0.01783421f, 0.00549135f, 
    0.10757238f, 0.13666271f, 0.02729562f, -0.03281000f, 0.36643684f, 0.24560608f, 0.21919712f, 0.20923087f, 
    -0.09329513f, -0.12255938f, -0.12604178f, 0.01968864f, -0.38222215f, -0.05160104f, -0.14984635f, -0.07447866f, 
    0.05498780f, 0.39835078f, -0.10122961f, 0.22788146f, 0.26863769f, 0.11978242f, 0.17177884f, 0.11285960f, 
    0.28106135f, -0.11428980f, -0.04298254f, 0.17927824f, 0.15623304f, -0.13871001f, 0.19686350f, -0.13385820f, 
    0.22113238f, 0.02965794f, 0.08269770f, -0.15755916f, -0.32137474f, -0.42257002f, -0.48196411f, -0.69967049f, 
    -0.54276013f, -0.02988359f, -0.34012499f, 0.09127278f, 0.19765402f, -0.02064849f, 0.09827180f, -0.62681055f, 
    0.11978070f, -0.09547704f, -0.07110442f, 0.05521250f, -0.56627023f, 0.62201202f, -0.32592621f, 0.48044345f, 
    -0.08452937f, 0.10935522f, -0.07867211f, 0.06171355f, 0.16578028f, 0.02979604f, 0.17592484f, 0.36389616f, 
    0.05492552f, -0.11755311f, 0.23474374f, -0.31595972f, 0.13258626f, -0.10164097f, -0.06975596f, -0.21556403f, 
    -0.08347727f, -0.01000108f, -0.14446960f, -0.36456501f, 0.30444780f, 0.34735292f, 0.02480035f, 0.01016943f, 
    0.06128630f, 0.06006780f, 0.10846406f, 0.29380050f, -0.04386009f, -0.05199370f, 0.11673354f, -0.12489689f, 
    -0.17825073f, 0.14821450f, -0.18619369f, 0.01192935f, 0.16939507f, 0.19793984f, -0.10855831f, 0.19023085f, 
    -0.46424791f, -0.08491918f, -0.29293618f, -0.53522503f, 0.54138893f, 0.14199753f, 0.28162599f, -0.18635643f, 
    0.04628664f, -0.10829984f, 0.04243000f, 0.16188844f, 0.18858649f, 0.18663248f, -0.00951265f, 0.04484644f, 
    0.04452688f, -0.13836651f, 0.28023461f, 0.20589447f, 0.07830335f, 0.06073407f, 0.03016272f, -0.33745748f, 
    0.04375789f, -0.15322383f, 0.01810111f, -0.23262446f, -0.47227150f, 0.09172744f, 0.06495908f, -0.09998444f, 
    0.10106422f, 0.14766745f, -0.01629919f, 0.07465461f, -0.01430567f, -0.10328059f, -0.03764722f, -0.36918002f, 
    -0.19132565f, -0.21701340f, -0.06128814f, 0.04967259f, 0.18642783f, -0.30721328f, 0.02806858f, 0.14476573f, 
    -0.23180997f, 0.16812415f, -0.02733916f, -0.06023668f, 0.08208421f, -0.13635820f, 0.28545868f, -0.15995649f, 
    -0.19704008f, 0.25802243f, 0.33509958f, 0.11217357f, 0.06093879f, 0.24681373f, -0.32468894f, 0.26620293f, 
    0.23681597f, 0.09703320f, -0.10289259f, -0.22017780f, -0.02475552f, 0.04718423f, -0.03364208f, 0.07244835f, 
    0.29255810f, 0.00819253f, -0.02233068f, -0.03752399f, -0.07932825f, -0.08348908f, 0.03226187f, -0.00526944f, 
    0.02902970f, -0.01329741f, 0.09757435f, -0.41090605f, -0.12694561f, -0.16302112f, 0.02699712f, -0.11089372f, 
    -0.20447972f, 0.01825031f, 0.04119533f, -0.08203926f, 0.31856167f, 0.07682317f, 0.15730144f, -0.01589168f, 
    0.10391547f, -0.08553805f, 0.08192471f, 0.25649577f, -0.05092053f, -0.32695886f, 0.24678318f, 0.21304621f, 
    -0.08680674f, -0.11972500f, 0.19836657f, 0.00796479f, 0.18968740f, 0.16146220f, 0.17177983f, 0.34181702f, 
    -0.18782803f, 0.00331001f, -0.02627568f, 0.03146795f, -0.04048466f, -0.14245453f, -0.09920114f, -0.01895156f, 
    -0.32723218f, -0.16068000f, -0.05996401f, -0.56491011f, -0.05648977f, -0.22953984f, -0.10766704f, -0.04796619f, 
    -0.07720917f, 0.11335843f, -0.00968906f, 0.02456963f, 0.17120807f, 0.10889187f, 0.14132807f, 0.01356354f, 
    0.15865245f, 0.19580568f, 0.26324818f, 0.01746912f, 0.01534510f, 0.03798798f, 0.02734517f, 0.03407228f, 
    -0.02049131f, 0.10619493f, 0.03578146f, 0.08482960f, -0.59000826f, 0.08044966f, -0.13175426f, 0.04370054f, 
    -0.01514846f, -0.05805359f, 0.07578722f, 0.14922374f, -0.26715320f, -0.01149741f, -0.12532140f, -0.12471495f, 
    0.20410112f, 0.21316274f, 0.21727125f, -0.10617756f, -0.11791094f, -0.09548829f, -0.13347881f, -0.12233461f, 
    -0.01500127f, -0.09410249f, 0.00761842f, 0.19209123f, -0.17966263f, -0.08363134f, 0.09428807f, 0.41281727f, 
    0.13931432f, 0.20761809f, 0.09918913f, 0.14749597f, -0.02508476f, -0.08115936f, -0.00811903f, 0.24216403f, 
    -0.09961479f, 0.12171375f, 0.10263462f, 0.17449570f, 0.19013172f, -0.02953082f, -0.09718160f, 0.08580513f, 
    0.17085792f, 0.30263704f, 0.21848437f, 0.19733019f, -0.12344876f, 0.04938889f, 0.17001270f, 0.08948294f, 
    -0.04573405f, -0.01691323f, 0.10617290f, 0.17377385f, 0.15210250f, 0.06294020f, -0.06486268f, -0.02503237f, 
    1.02767360f, 0.42907116f, 0.30832720f, 0.49741811f, 0.22339907f, -0.14228800f, 0.04105340f, -0.25026628f, 
    0.19141005f, -0.04809485f, 0.31741044f, 0.16882604f, -0.01450049f, 0.33095413f, 0.26449138f, 0.02315104f, 
    0.09957218f, -0.16130693f, -0.01338181f, 0.12058181f, -0.03360417f, 0.14819111f, 0.05907720f, -0.11090784f, 
    -0.13514410f, -0.41071051f, 0.58046132f, 0.05262148f, -0.03354412f, 0.19121213f, -0.11011029f, 0.14116509f, 
    0.00224579f, 0.03922293f, 0.15810505f, 0.13086528f, 0.00610914f, -0.06523314f, 0.06062732f, -0.29020283f, 
    -0.05725721f, 0.00227833f, -0.08283342f, -0.06971340f, -0.04413534f, 0.19202520f, 0.02268922f, -0.00543496f, 
    -0.50406295f, 0.12441574f, -0.04340271f, 0.16758135f, 0.05728937f, 0.00062263f, 0.01326406f, 0.17071846f, 
    0.02858612f, -0.03949084f, 0.01052280f, -0.04491430f, -0.22687140f, 0.04378444f, -0.05439265f, -0.08045889f, 
    -0.06225788f, -0.05627177f, -0.08292454f, -0.05915248f, 0.22707285f, 0.12546413f, 0.09693598f, 0.19010203f, 
    -0.22288591f, 0.03709075f, -0.00056604f, -0.12840840f, 0.00863134f, 0.04972928f, -0.06151305f, -0.00948113f, 
    0.02246263f, 0.20227097f, 0.09430436f, -0.09830956f, -0.48854384f, 0.06456193f, 0.23223490f, -0.06622517f, 
    -0.00638457f, -0.13042656f, -0.19092393f, -0.13482009f, -0.04622818f, -0.26914755f, -0.20774500f, -0.20766395f, 
    -0.03916780f, -0.25501800f, -0.16272029f, -0.04344856f, -0.20996889f, -0.04215148f, 0.10119440f, -0.09681571f, 
    -0.03552850f, -0.03519897f, -0.00680911f, -0.04581786f, -0.07299910f, 0.09018356f, -0.02524001f, 0.02611417f, 
    0.01848691f, -0.02379937f, -0.06167778f, -0.16878036f, -0.14096721f, 0.01421005f, -0.09515665f, -0.05762475f, 
    -0.13759635f, 0.20820494f, 0.01971325f, 0.10707501f, 0.11287287f, 0.03337861f, 0.00745161f, -0.10043295f, 
    0.06654102f, -0.11662075f, 0.03667731f, 0.07029667f, 0.14034565f, 0.00848181f, -0.01880327f, -0.12240187f, 
    -0.12365323f, -0.02188083f, 0.03192608f, 0.31024674f, 0.09441944f, 0.15476951f, -0.15241851f, 0.04732597f, 
    0.22586291f, 0.34410316f, -0.08971271f, 0.36350670f, -0.11968154f, 0.03787801f, -0.03245992f, -0.09815503f, 
    0.10671090f, -0.05870315f, 0.06876636f, 0.19398050f, 0.15149499f, 0.12937412f, -0.34614632f, -0.16551304f, 
    0.04156733f, 0.00332283f, 0.33471143f, 0.16921403f, -0.15530634f, -0.00201202f, -0.10809746f, 0.00208417f, 
    0.05521908f, 0.02812180f, -0.03104015f, 0.12835689f, -0.14817427f, -0.09200745f, 0.10429889f, -0.09575842f, 
    0.01096798f, -0.04393271f, -0.11737119f, 0.00959932f, 0.04112457f, 0.29758000f, -0.11865049f, 0.26117775f, 
    0.22558641f, 0.25371116f, 0.28630009f, 0.16879940f, -0.04774311f, 0.06162569f, 0.04054585f, -0.06383035f, 
    -0.57017696f, 0.54611546f, 0.15218861f, -0.11230944f, 0.19597277f, 0.09937659f, 0.10556847f, 0.07665259f, 
    -0.06301937f, 0.05010884f, -0.06118617f, 0.21554403f, 0.21734598f, -0.20634840f, -0.18748300f, 0.04280097f, 
    0.04389988f, 0.23642552f, 0.10884432f, -0.21271697f, -0.17704816f, -0.01446485f, -0.01756124f, 0.09910925f, 
    0.83039236f, -0.17048489f, 0.08230411f, -0.28400844f, 0.14373618f, -0.12349714f, 0.05849803f, -0.10534972f, 
    0.06908412f, -0.09336373f, -0.08732012f, -0.03239309f, 0.02721652f, 0.03742060f, 0.03643017f, 0.23462400f, 
    -0.02897407f, 0.10561141f, -0.10635393f, -0.09629698f, 0.35362524f, -0.11084123f, 0.06863890f, -0.13519165f, 
    0.06615102f, -0.10092284f, 0.03468610f, -0.28518543f, 0.09884008f, 0.24211851f, -0.02705085f, 0.01836371f, 
    -0.18038611f, 0.05494125f, -0.07644989f, 0.05091728f, 0.01407139f, 0.01936632f, 0.13882352f, 0.17530806f, 
    0.01932741f, 0.00032880f, -0.03251771f, 0.01381904f, 0.04542952f, 0.13624161f, 0.14028592f, 0.01878351f, 
    0.05298422f, 0.03999042f, 0.06526317f, 0.06844050f, -0.06990962f, -0.06412373f, -0.04532336f, 0.01991421f, 
    0.21852016f, 0.15021005f, 0.06234356f, -0.02745933f, 0.40784144f, 0.02062936f, -0.03501777f, 0.00899841f, 
    -0.09591997f, -0.07803462f, -0.01003864f, -0.04520897f, 0.08524621f, 0.08556800f, -0.14948486f, -0.20118298f, 
    -0.05030882f, -0.02112129f, 0.03943295f, 0.04202540f, -0.07305707f, -0.07713951f, 0.04697205f, -0.01562626f, 
    -0.02801647f, -0.03856631f, 0.00704154f, -0.03711029f, -0.03882660f, -0.05016808f, 0.04528532f, 0.00704813f, 
    -0.05869681f, 0.05384236f, 0.06515425f, 0.01965719f, 0.00092579f, -0.01722168f, -0.04933712f, 0.01225342f, 
    -0.00816977f, 0.00512595f, 0.02013706f, 0.07203335f, -0.06471734f, 0.04480767f, -0.00562939f, 0.03042754f, 
    -0.04052530f, -0.06460026f, 0.03868878f, 0.00057464f, -0.03726969f, -0.06755643f, -0.04697527f, -0.05611704f, 
    -0.01479660f, -0.03714132f, -0.06121818f, 0.02372907f, 0.04474693f, -0.07060453f, 0.05395843f, -0.00386049f, 
    -0.02454592f, -0.07719801f, -0.00607414f, -0.03623622f, -0.00784893f, -0.03112076f, -0.01746585f, 0.06429929f, 
    -0.04996687f, -0.03832542f, -0.00067355f, -0.03677535f, 0.00922993f, 0.03174223f, -0.01741094f, 0.04864190f, 
    0.06877938f, -0.06068588f, -0.00023005f, 0.00907356f, -0.01797798f, -0.04835316f, 0.03472872f, -0.06215011f, 
    0.06930505f, -0.03902733f, 0.01217867f, -0.06124743f, 0.04857412f, -0.03849338f, -0.03388627f, -0.07283184f, 
    0.01917439f, -0.04531262f, 0.01736923f, -0.06141078f, -0.04896713f, 0.04056235f, -0.01206907f, -0.01252668f, 
    -0.00540876f, 0.06878198f, -0.06374165f, -0.03078224f, 0.06329188f, -0.07138891f, 0.04574918f, 0.05042155f, 
    -0.00964003f, 0.06075348f, 0.01859981f, 0.04869712f, 0.03674337f, -0.04397900f, 0.02213134f, -0.05296079f, 
    -0.03499845f, -0.03102023f, -0.01637715f, -0.03217274f, 0.06673083f, -0.05343387f, -0.07189718f, -0.00283075f, 
    -0.02818472f, 0.02966923f, -0.04396186f, 0.05098431f, -0.03684102f, 0.03633780f, -0.05877934f, -0.04405897f, 
    -0.05234954f, 0.05323467f, -0.03136984f, -0.06947851f, -0.01805033f, -0.04338871f, 0.06786891f, 0.00969342f, 
    -0.04440819f, 0.00252673f, -0.05514650f, -0.04753521f, -0.02360174f, -0.04378419f, 0.06908331f, 0.03246728f, 
    0.01044912f, -0.03083368f, 0.01975989f, 0.02048384f, -0.00036493f, -0.06199597f, 0.04589886f, 0.04848857f, 
    -0.05917516f, -0.00210279f, -0.04620086f, 0.00344717f, 0.00403320f, 0.04003664f, -0.00056798f, -0.00874978f, 
    0.00877184f, 0.03183652f, -0.04621755f, -0.00122087f, -0.05544207f, 0.01800271f, -0.03775294f, 0.03807652f, 
    -0.00244413f, -0.00904749f, -0.07643891f, 0.05837264f, 0.06481468f, 0.02088983f, 0.05239109f, -0.05684740f, 
    -0.00099744f, 0.04719821f, -0.04331490f, 0.01838560f, -0.06430253f, 0.03691543f, -0.03446223f, -0.05431234f, 
    0.04045128f, 0.01335337f, -0.01775472f, 0.01942702f, -0.03488581f, -0.03749722f, -0.00022570f, 0.05466060f, 
    0.06096643f, 0.06533780f, 0.00251485f, 0.01314476f, -0.04673159f, 0.07110782f, 0.01078189f, -0.04690886f, 
    0.02157211f, 0.16555811f, -0.22058879f, -0.07129695f, 0.13220119f, 0.03383102f, -0.04013123f, 0.00250275f, 
    0.01000158f, 0.11552973f, 0.00160172f, 0.20537692f, 0.03179023f, -0.02089470f, -0.02392961f, 0.05718879f, 
    0.13309300f, 0.10591900f, -0.06324710f, -0.15144233f, 0.01240032f, 0.09730647f, -0.07370111f, 0.04268564f, 
    -0.45145103f, 0.14539407f, 0.01851847f, 0.14769119f, 0.16598119f, -0.19925213f, -0.07127827f, -0.29716864f, 
    0.22684240f, -0.13588785f, 0.12105953f, 0.14674872f, -0.16391554f, 0.28271526f, -0.30050707f, -0.08174060f, 
    0.08098542f, -0.04587122f, -0.03436288f, 0.05287931f, 0.22996417f, 0.22087422f, 0.03864508f, 0.21165800f, 
    0.24196602f, -0.15243874f, 0.19156516f, 0.13919370f, 0.02572210f, 0.16179293f, 0.19851024f, 0.03003238f, 
    -0.03205250f, -0.01089532f, 0.00543219f, 0.08645014f, 0.11155878f, 0.33096206f, -0.12800424f, -0.50519794f, 
    0.02903404f, -0.04391813f, 0.28669548f, 0.15377824f, -0.03314593f, 0.10112225f, 0.02001981f, -0.10315859f, 
    -0.02283921f, 0.06693136f, -0.15022174f, -0.10194847f, -0.01747335f, 0.11387146f, 0.13665655f, 0.12379459f, 
    0.03705592f, 0.00938592f, -0.05233319f, -0.02128797f, 0.35994300f, 0.05139070f, 0.10130463f, -0.01150878f, 
    -0.03879520f, 0.03056139f, 0.22167201f, 0.09904658f, -0.12122024f, -0.11594921f, -0.15598240f, -0.09512518f, 
    -0.63273078f, -0.02332343f, -0.16221984f, 0.05524297f, 0.06511862f, -0.05996469f, 0.04600117f, -0.02820540f, 
    0.14330959f, 0.02895726f, -0.15046184f, 0.04135040f, 0.23657265f, -0.14098971f, -0.22052057f, -0.05524642f, 
    -0.04616129f, 0.03479585f, -0.00278699f, -0.08447836f, 0.00777092f, -0.04485091f, -0.04770323f, 0.07333689f, 
    0.22551036f, 0.16717207f, 0.12270533f, -0.40498331f, 0.14931805f, 0.04691956f, 0.19101711f, -0.32681727f, 
    -0.10297081f, -0.01331856f, -0.03558395f, 0.06338037f, -0.04833551f, -0.01339966f, 0.04771340f, 0.23734675f, 
    -0.14777295f, 0.07242595f, -0.01960251f, 0.10155427f, -0.06629661f, -0.09849315f, 0.02370376f, -0.08558209f, 
    0.13560520f, -0.11618346f, -0.11593838f, -0.45377961f, -0.15017337f, 0.23399487f, -0.22988376f, 0.13686331f, 
    0.23868760f, -0.01909016f, -0.14988357f, 0.13113141f, -0.09041991f, -0.08229312f, 0.05505346f, 0.17165899f, 
    -0.03278683f, 0.06818219f, 0.06146780f, -0.01176440f, 0.01478630f, 0.05399577f, -0.05830758f, -0.07551774f, 
    -0.10052226f, -0.11776872f, 0.11924761f, -0.03678717f, 0.08577245f, -0.09030239f, -0.00132004f, -0.09418146f, 
    0.11081879f, -0.11247925f, 0.05583085f, 0.21496859f, 0.48630026f, -0.27683580f, 0.25903812f, -0.01806782f, 
    0.01699354f, -0.03602535f, 0.09105486f, -0.04350976f, 0.00296505f, 0.17971258f, -0.17147450f, -0.11770284f, 
    0.26938045f, -0.41863674f, -0.08980824f, 0.23531514f, 0.01799472f, 0.07608450f, 0.20132163f, 0.05652759f, 
    0.02663765f, 0.05948136f, -0.02633573f, 0.01841119f, -0.12336309f, -0.09488782f, 0.09970561f, 0.08199942f, 
    0.01438086f, -0.10595749f, -0.06387820f, 0.15629435f, 0.18544291f, -0.33174363f, -0.17631307f, -0.40466717f, 
    0.34536397f, 0.02834423f, 0.03375290f, -0.13745283f, -0.00203788f, 0.39763919f, 0.05044743f, 0.20159574f, 
    -0.09488218f, -0.04330123f, -0.05256505f, -0.04829959f, 0.35463879f, 0.04075914f, 0.03458462f, -0.29141131f, 
    -0.03702312f, 0.11695726f, 0.18221757f, -0.15662628f, 0.11527926f, 0.02839987f, 0.21987337f, 0.20202543f, 
    -0.26259565f, -0.13657500f, -0.05830944f, 0.37850276f, 0.09340665f, 0.11996259f, 0.00637419f, 0.16372101f, 
    -0.16220066f, 0.01369124f, -0.01574035f, -0.08373349f, 0.03730480f, -0.05411983f, 0.04595527f, 0.11828114f, 
    -0.03108311f, 0.07470252f, -0.25718158f, 0.11669417f, 0.12775403f, -0.21263804f, -0.03504039f, -0.04548464f, 
    -0.18707590f, -0.43026474f, 0.01516233f, 0.06089913f, 0.16435747f, 0.00726118f, 0.07436604f, 0.08413230f, 
    -0.06428787f, -0.15515259f, -0.21701671f, -0.15359648f, -0.46326789f, 0.08049746f, -0.04837229f, 0.08769763f, 
    -0.00131294f, 0.21845283f, 0.09249356f, -0.23520087f, 0.10855530f, 0.13400269f, 0.16600366f, 0.19767378f, 
    -0.00276851f, 0.01239647f, -0.15829012f, 0.36624297f, -0.06044952f, 0.33668536f, -0.02106676f, 0.03840446f, 
    -0.11992314f, 0.03410636f, 0.01143729f, -0.18862274f, 0.21349701f, 0.02815235f, 0.16308361f, 0.16719002f, 
    0.28088984f, 0.17566648f, 0.34417725f, 0.23820031f, 0.02024909f, -0.09572016f, -0.07200108f, -0.12824135f, 
    -0.42566824f, 0.07261886f, 0.47225100f, -0.05748550f, 0.17826860f, -0.00859871f, -0.20178121f, 0.31004742f, 
    -0.23491041f, 0.13649662f, 0.26820973f, -0.07742038f, -0.45838457f, -0.18639603f, -0.14416577f, 0.31304047f, 
    0.02845993f, -0.09406173f, 0.04579920f, 0.03051621f, 0.23332977f, 0.10608688f, -0.04161503f, 0.13928513f, 
    -0.41166025f, 0.16723284f, 0.16878358f, 0.15779178f, 0.03846832f, -0.12991251f, 0.32058486f, -0.21139403f, 
    -0.03466850f, 0.15851378f, 0.13090934f, 0.13485286f, -0.05127662f, -0.20219812f, -0.35076934f, -0.24773279f, 
    0.20486638f, 0.22423466f, 0.08790924f, 0.09059823f, 0.06147196f, 0.09087441f, 0.00509874f, 0.00248061f, 
    0.02055342f, -0.20251925f, -0.47223619f, -0.21593030f, 0.03901464f, 0.18834509f, -0.07261497f, 0.15021089f, 
    0.21897185f, 0.29602063f, 0.05903021f, 0.01959236f, -0.39106861f, 0.20706660f, -0.25626397f, -0.03497771f, 
    -0.06233907f, -0.04230895f, 0.03950882f, 0.19518372f, 0.16438773f, 0.06670696f, 0.16151550f, 0.15909554f, 
    0.12311178f, -0.20222679f, 0.64881349f, -0.07418820f, -0.15832528f, -0.05883182f, 0.00703809f, 0.22126381f, 
    0.13752505f, 0.00421189f, -0.24149673f, 0.11014443f, -0.05088823f, 0.01112197f, -0.20771399f, -0.04661384f, 
    0.06418851f, 0.13180631f, 0.14098428f, -0.22484495f, 0.09436750f, 0.20547554f, -0.10882477f, -0.02549828f, 
    -0.13195293f, 0.18666950f, 0.55240911f, -0.00908345f, -0.16240492f, -0.06928866f, -0.28873393f, -0.35995066f, 
    0.05118585f, -0.23730384f, 0.23598969f, 0.15003558f, -0.11027106f, -0.02101010f, 0.37937307f, 0.25102574f, 
    -0.43389094f, 0.22942300f, 0.07112289f, 0.23500109f, 0.08921569f, 0.07096175f, 0.01134101f, 0.01490543f, 
    -0.30566221f, 0.36879995f, 0.17368987f, -0.08940399f, -0.05118652f, -0.19052988f, -0.23445989f, -0.35347661f, 
    0.08179472f, -0.08343708f, -0.15026806f, -0.13044420f, 0.23904313f, -0.04224516f, -0.06422494f, 0.07526115f, 
    0.09544569f, 0.23612516f, -0.05349382f, -0.05126520f, 0.00416921f, -0.12032444f, -0.02285182f, -0.23189335f, 
    0.52516854f, -0.02929147f, 0.02003154f, -0.13187884f, 0.00728005f, 0.04930665f, -0.04293701f, -0.31657124f, 
    -0.00451159f, -0.00359795f, -0.01382766f, 0.18961826f, 0.14656037f, 0.24151565f, 0.02603461f, 0.04887715f, 
    0.19045492f, 0.13138992f, 0.09127715f, 0.04774459f, -0.25913119f, -0.08170917f, -0.02546792f, -0.06924632f, 
    0.35139135f, 0.05080294f, 0.45158836f, -0.38621411f, -0.05231936f, -0.06097802f, -0.28364277f, -0.11719430f, 
    -0.11762474f, 0.10015513f, -0.08045131f, -0.11598141f, 0.24939923f, -0.00189179f, 0.19146591f, -0.02636122f, 
    -0.04272557f, 0.00644411f, -0.30673608f, -0.05951761f, 0.21234027f, -0.06465114f, 0.04821128f, 0.01961546f, 
    -0.06482358f, -0.19638832f, -0.40323797f, 0.40922001f, 0.13138440f, 0.01256704f, 0.13110179f, 0.02029427f, 
    -0.04559565f, 0.07744947f, 0.05198324f, -0.05612925f, 0.23145671f, 0.00490005f, 0.25629857f, -0.08541740f, 
    -0.02052859f, 0.12116959f, 0.41723511f, -0.20249546f, 0.15648757f, -0.14616142f, 0.00293163f, 0.07255471f, 
    0.25046217f, -0.02205377f, -0.28045645f, -0.03759233f, 0.15842661f, 0.30688867f, 0.19916356f, 0.11555287f, 
    0.06106996f, 0.07093270f, 0.15740205f, 0.12142057f, 0.08514566f, 0.15397203f, 0.03346661f, 0.09920394f, 
    -0.38996515f, -0.38243380f, -0.22179087f, -0.22974086f, -0.20493254f, -0.02841926f, 0.09446111f, -0.21743651f, 
    0.27440381f, 0.24851798f, 0.02579165f, 0.27996889f, -0.30507371f, 0.07331041f, -0.25730726f, -0.02377640f, 
    0.02125779f, 0.20424193f, 0.09357856f, 0.10175656f, -0.19995895f, -0.07440769f, -0.32308295f, 0.06590027f, 
    0.01616469f, 0.19005619f, 0.18990423f, -0.05423754f, 0.08722134f, 0.02974320f, 0.00573323f, -0.01406784f, 
    -0.33352891f, -0.36097398f, 0.61314732f, -0.17467222f, -0.16940907f, -0.02916528f, 0.06441772f, -0.16885161f, 
    -0.08253784f, 0.09531275f, -0.12849055f, 0.14141363f, -0.10588928f, 0.26596341f, -0.14146724f, -0.00943938f, 
    0.05232370f, 0.04069974f, -0.06470829f, 0.06889431f, -0.09004634f, 0.17186080f, 0.09396604f, -0.10963180f, 
    0.34567860f, 0.08406121f, 0.33223328f, 0.30616412f, -0.02605378f, 0.24983031f, -0.22909814f, 0.10700309f, 
    -0.12187704f, -0.08252166f, 0.20927903f, 0.13855965f, -0.05530767f, -0.24702847f, 0.67217076f, -0.08653429f, 
    -0.13761872f, 0.08773738f, 0.10991438f, -0.09594155f, 0.22583519f, 0.23777191f, 0.14551835f, 0.15930454f, 
    -0.38445854f, 0.22248863f, 0.19390902f, 0.13930970f, 0.02560237f, -0.06715491f, -0.26355845f, -0.22306934f, 
    -0.04194411f, 0.07550289f, -0.03916094f, -0.09940395f, -0.16525985f, -0.44090921f, -0.31312490f, -0.09868078f, 
    -0.04222563f, -0.02791765f, -0.17066044f, -0.13745484f, 0.09393898f, -0.05809877f, 0.03754600f, -0.10777865f, 
    0.00435050f, 0.08495775f, 0.31319651f, -0.25692835f, -0.01141218f, -0.07412366f, -0.06609625f, -0.18015538f, 
    -0.15487123f, -0.14832498f, -0.05977796f, -0.11918050f, -0.01396443f, 0.00697556f, -0.23464739f, 0.07183564f, 
    0.03481450f, 0.10964674f, -0.02470303f, -0.01927842f, -0.16882539f, -0.02016934f, 0.09024837f, -0.05139676f, 
    0.51870096f, 0.24462222f, -0.06021665f, -0.39195916f, -0.03475843f, 0.01106852f, -0.04052124f, 0.24584772f, 
    -0.16171096f, 0.15215863f, -0.05344430f, 0.12900412f, -0.02697746f, 0.05232210f, 0.25182995f, -0.00889479f, 
    0.04312572f, 0.03386064f, -0.10540645f, -0.14149600f, 0.08319508f, 0.05248290f, 0.02365639f, -0.02230755f, 
    -0.11974456f, 0.46597767f, 0.07866222f, 0.37978244f, 0.05794843f, 0.28227311f, 0.25005266f, -0.09304792f, 
    -0.02024865f, -0.01108770f, 0.10031269f, -0.05002061f, 0.09665319f, 0.03509387f, 0.03319012f, -0.19505973f, 
    -0.04609416f, 0.04285374f, 0.08582144f, -0.06999814f, 0.23460732f, -0.02204778f, 0.14637063f, 0.12163889f, 
    0.41937083f, -0.05206880f, 0.05878812f, 0.29968655f, 0.13082454f, 0.17763154f, 0.23395923f, 0.08683577f, 
    -0.07556847f, 0.10788021f, -0.01477736f, 0.06493240f, 0.09156176f, 0.23595233f, 0.07534467f, -0.11298263f, 
    -0.27797654f, -0.19859244f, -0.10509228f, -0.04072195f, -0.30670896f, -0.00636736f, 0.15873834f, -0.23722008f, 
    -0.05109280f, 0.01136798f, -0.18318416f, -0.09928843f, -0.58958757f, 0.13980608f, -0.19406778f, -0.03266089f, 
    -0.04530224f, 0.16308063f, -0.20765249f, -0.07018498f, -0.38943863f, 0.50563377f, -0.09540854f, 0.13252297f, 
    -0.00529237f, 0.25861931f, 0.06731885f, -0.11670024f, 0.05805508f, 0.17945991f, 0.18560900f, 0.10660426f, 
    0.04249833f, 0.01605877f, 0.63776201f, -0.33358231f, -0.08927468f, -0.12072130f, 0.05678805f, 0.11142593f, 
    0.13376561f, -0.10343370f, -0.05894383f, 0.01960215f, -0.04338777f, 0.22410753f, -0.12649125f, -0.01730531f, 
    -0.05380057f, 0.14378227f, -0.10863042f, -0.09447597f, -0.18217921f, 0.15106837f, -0.04598364f, -0.04955893f, 
    -0.02114119f, 0.05824305f, 0.27911577f, 0.10245524f, -0.09185715f, -0.09325399f, -0.11237159f, -0.13926399f, 
    0.00875549f, -0.06478669f, 0.19162719f, 0.05583035f, -0.16601704f, -0.28038567f, 0.29588982f, 0.10394407f, 
    0.10670044f, -0.00832481f, -0.21201605f, -0.03806319f, 0.21677494f, 0.01070951f, 0.10683156f, -0.08536193f, 
    0.04953817f, 0.31682751f, 0.05711218f, -0.06362623f, -0.17131943f, 0.01966198f, -0.01482854f, 0.00083731f, 
    0.08481248f, 0.04214920f, -0.08880512f, 0.05231309f, 0.12885171f, -0.09990926f, -0.07185441f, -0.06419325f, 
    -0.08642810f, -0.01260490f, -0.02069538f, -0.18411617f, 0.02403310f, -0.09765609f, 0.06807601f, -0.07842175f, 
    0.15008467f, 0.11865311f, 0.13444325f, -0.08414467f, -0.20378810f, 0.03750000f, -0.07695957f, 0.02283699f, 
    -0.05372455f, 0.04548546f, 0.04748871f, -0.00462388f, 0.12237364f, 0.07533873f, 0.03064678f, -0.00699650f, 
    0.20082644f, -0.13187943f, -0.22287601f, 0.17191428f, 0.05571340f, -0.03466778f, 0.00117114f, 0.04140413f, 
    0.33340147f, -0.08321499f, 0.35997814f, -0.41855648f, -0.06135858f, 0.02506355f, -0.14200337f, 0.04008269f, 
    0.05008248f, 0.17256457f, -0.00942405f, 0.05086507f, -0.13074432f, 0.14094047f, 0.10058788f, -0.09870986f, 
    -0.11864862f, -0.11801438f, -0.36004803f, -0.01275027f, -0.02979717f, 0.08867598f, 0.06472593f, 0.00154809f, 
    0.37558213f, 0.51534235f, -0.23809381f, 0.29502067f, -0.00354708f, 0.22583602f, 0.14237238f, -0.02675512f, 
    0.02351966f, -0.01446519f, -0.05811916f, -0.06263986f, 0.07398436f, 0.03879283f, -0.09556942f, -0.20443402f, 
    -0.02314316f, -0.00717601f, 0.15303428f, -0.01878652f, 0.09908856f, 0.15183972f, 0.10012834f, 0.00733088f, 
    0.58170575f, 0.02730071f, -0.07076874f, 0.19286510f, 0.18038309f, -0.02746738f, -0.04322266f, 0.18778674f, 
    0.00738123f, 0.05126799f, -0.17001063f, 0.23265846f, -0.01328437f, 0.01140340f, 0.02833088f, -0.02107122f, 
    -0.05119110f, -0.12821063f, -0.00526320f, 0.06486306f, -0.08964097f, 0.07856680f, 0.10174635f, 0.09432150f, 
    -0.11689672f, -0.02941549f, 0.08880065f, 0.09788857f, -0.14343993f, -0.15835135f, 0.03890357f, 0.09343344f, 
    0.12765394f, 0.03358076f, 0.05433739f, 0.21383682f, -0.14967574f, -0.06024649f, -0.10983201f, 0.07664501f, 
    0.03327254f, 0.05456613f, 0.04185688f, 0.03226872f, -0.10947877f, 0.03523915f, -0.16990535f, 0.07948337f, 
    0.02270674f, 0.02644460f, -0.05773081f, -0.07395291f, 0.00894033f, 0.03174386f, 0.03167132f, -0.03502293f, 
    -0.00570842f, -0.06887458f, -0.00606568f, -0.08663666f, -0.01652208f, -0.03440220f, -0.05690966f, -0.03508867f, 
    -0.08113948f, -0.05416199f, -0.00113364f, -0.08818679f, 0.00219041f, -0.02168812f, 0.01566010f, 0.04580750f, 
    -0.00153721f, 0.03772739f, 0.00283197f, 0.04986301f, 0.00529440f, -0.03730434f, -0.01772913f, -0.08235177f, 
    -0.02947581f, -0.03403980f, 0.03430279f, -0.00677905f, 0.01064319f, 0.00096268f, 0.00317677f, -0.09023934f, 
    0.00362433f, -0.05183987f, -0.02398048f, 0.05363645f, -0.07233376f, 0.07002051f, -0.03516371f, 0.03563025f, 
    0.06376708f, -0.06928978f, 0.02885309f, -0.03596234f, 0.03066064f, -0.03467040f, -0.00713682f, -0.05256880f, 
    -0.06405540f, -0.00468784f, -0.00031585f, 0.02474523f, -0.04817035f, -0.06968733f, -0.03605699f, 0.04840040f, 
    0.03843747f, -0.01839799f, 0.04134212f, -0.05140529f, -0.05279877f, 0.00257028f, 0.02228670f, -0.03742088f, 
    0.04740418f, -0.01150077f, -0.04707258f, -0.06889187f, 0.01511844f, 0.05108754f, -0.07653960f, -0.00212344f, 
    0.04324172f, 0.01013541f, 0.00599427f, 0.01544902f, -0.00514872f, -0.05878357f, -0.07423501f, 0.04006265f, 
    -0.03461206f, -0.08237045f, -0.00072400f, -0.07536675f, -0.09521571f, 0.03164251f, -0.00768778f, -0.00183678f, 
    -0.04696879f, -0.04369830f, 0.01390958f, 0.02778094f, -0.04503669f, -0.05061693f, 0.01887813f, -0.06983410f, 
    -0.02810821f, -0.01697706f, -0.03680968f, -0.00935750f, -0.02560564f, -0.03225784f, 0.01732277f, 0.00876331f, 
    -0.00898844f, -0.07271045f, 0.00035698f, -0.03085757f, -0.10566462f, 0.00576584f, -0.09553121f, -0.04812656f, 
    0.04992233f, 0.01921793f, -0.03868493f, -0.04864153f, 0.01341550f, -0.03872876f, -0.00307584f, 0.03350291f, 
    0.04499633f, 0.03247049f, 0.04067199f, -0.06503793f, -0.07517263f, 0.00822579f, 0.02786082f, -0.01697708f, 
    -0.01473056f, -0.02498930f, -0.07510283f, -0.05589328f, 0.00472630f, -0.03164310f, -0.07341831f, -0.03445398f, 
    -0.03705163f, -0.04021270f, -0.08424085f, -0.01954433f, -0.05710349f, -0.08680924f, -0.08601181f, -0.06751838f, 
    0.04386088f, -0.02487044f, 0.02339109f, 0.03894523f, 0.01193372f, -0.00457854f, -0.01357497f, 0.00835059f, 
    -0.07144114f, -0.05433452f, -0.07214519f, -0.05595763f, 0.03556104f, -0.03792201f, -0.09344196f, -0.06241397f, 
    -0.00388811f, -0.05691883f, 0.04745894f, 0.04046200f, -0.05857548f, -0.06932431f, 0.02266557f, 0.00255884f, 
    -0.03362090f, -0.09566317f, -0.04003594f, -0.00277934f, 0.03345627f, 0.01393236f, -0.08120864f, 0.00342338f, 
    -0.01049396f, -0.06536544f, 0.02143833f, -0.05630414f, -0.01843509f, -0.03877828f, -0.00550994f, 0.05145555f, 
    0.13151164f, 0.10314339f, 0.16938849f, -0.05361410f, -0.13832797f, -0.02460284f, -0.22151348f, -0.01411622f, 
    0.17903009f, 0.07455695f, -0.10948946f, -0.00853833f, 0.11215270f, 0.31888285f, 0.15425757f, 0.10895213f, 
    -0.26029405f, 0.01568356f, 0.19262312f, 0.07280361f, -0.01743485f, -0.01692210f, 0.00766493f, -0.07380572f, 
    -0.44025287f, 0.21963421f, 0.23750095f, -0.03350602f, -0.31452847f, 0.06638157f, -0.11422857f, 0.02636020f, 
    0.17082830f, 0.22972549f, 0.06965820f, 0.01484156f, 0.36427858f, -0.14582963f, 0.22026566f, -0.14797077f, 
    -0.04311178f, -0.14383166f, 0.06845492f, -0.03668390f, 0.02392872f, -0.08585054f, 0.00170776f, -0.13379039f, 
    -0.12271135f, 0.32514825f, -0.02324892f, 0.19501387f, -0.31484050f, -0.11341649f, -0.10663125f, -0.03296825f, 
    0.20309807f, 0.00999429f, -0.19644311f, -0.10116591f, -0.26902798f, -0.07111356f, -0.10706072f, 0.51401383f, 
    -0.00279839f, 0.11863256f, 0.34082410f, -0.11562188f, 0.02173303f, -0.06582291f, 0.13287680f, 0.05122051f, 
    0.19124591f, 0.05192476f, 0.14755076f, -0.04742187f, -0.08983664f, 0.12801303f, -0.07351650f, -0.13879415f, 
    0.14223625f, -0.01985491f, -0.03114382f, -0.15170676f, -0.44969347f, 0.29470697f, -0.18793537f, 0.23063935f, 
    0.09332465f, 0.08557528f, 0.00033314f, 0.19656612f, 0.04503516f, 0.05980780f, -0.06024086f, 0.01867838f, 
    -0.53558415f, -0.02567941f, 0.67880917f, -0.01051498f, -0.16546811f, -0.07282964f, 0.04555592f, -0.14228371f, 
    -0.24591897f, -0.02457005f, -0.13783212f, 0.39428794f, -0.73196018f, 0.05578591f, 0.01992095f, -0.01342191f, 
    0.05153986f, 0.11492207f, -0.01108307f, 0.12875964f, -0.14261600f, 0.13836764f, 0.09728235f, 0.09776013f, 
    0.26341450f, 0.73799020f, 0.02665307f, 0.23516630f, -0.07409514f, 0.30991676f, 0.01919717f, -0.03407552f, 
    0.15382276f, 0.02997465f, -0.10086752f, 0.02073709f, -0.07944430f, 0.02580596f, -0.11635906f, 0.00057194f, 
    -0.14307271f, -0.11113391f, -0.17023523f, -0.04575318f, 0.34983692f, 0.03364054f, -0.46052948f, -0.00885676f, 
    0.54955083f, 0.00308721f, 0.53835875f, 0.32541475f, 0.14693914f, -0.57450187f, -0.28718594f, 0.10903785f, 
    -0.07002369f, -0.17737582f, -0.01540802f, 0.10858725f, -0.03520844f, -0.32753900f, 0.06715162f, 0.13988313f, 
    -0.13961782f, -0.24322480f, -0.04049912f, -0.12138706f, 0.07656473f, 0.19939607f, 0.02983716f, 0.18815778f, 
    0.01648694f, 0.04907520f, 0.07833038f, -0.02145710f, -0.24530797f, -0.21405357f, -0.16572210f, -0.06889073f, 
    0.04142699f, -0.07502897f, 0.12156919f, 0.08427407f, 0.03172533f, 0.70583034f, 0.00282190f, 0.01364230f, 
    -0.09190328f, -0.05022646f, -0.18406779f, 0.00519674f, 0.03441819f, 0.11001933f, -0.16794352f, 0.05407965f, 
    -0.00381081f, 0.02107242f, 0.05418343f, -0.06567681f, 0.05303584f, 0.05134439f, -0.02006621f, 0.00422984f, 
    0.03115755f, -0.03287978f, -0.04528004f, 0.03324236f, -0.05060146f, -0.04589259f, -0.02872316f, -0.00659936f, 
    -0.01639518f, -0.04189858f, 0.03979504f, 0.05021903f, 0.04743657f, -0.06096341f, -0.05309463f, 0.02850657f, 
    0.00200907f, -0.05804230f, -0.05704206f, 0.01500566f, -0.00537173f, 0.02328016f, 0.00443744f, -0.03047535f, 
    -0.07203624f, -0.00903978f, -0.07318226f, 0.05618735f, 0.05710518f, -0.06993400f, 0.00155057f, 0.01760563f, 
    0.04970640f, -0.04815117f, -0.07750161f, 0.03167479f, 0.02158647f, 0.01060576f, -0.05074905f, -0.08331445f, 
    0.02666457f, -0.07819052f, -0.07076523f, 0.02292541f, -0.05642242f, -0.00327117f, -0.06150372f, -0.06223921f, 
    -0.06945194f, -0.00571192f, -0.03919930f, -0.08135276f, 0.02602957f, 0.05883635f, -0.03025689f, -0.06118204f, 
    0.00546830f, -0.04916823f, 0.02177779f, 0.00547127f, -0.01692083f, 0.04640977f, -0.06038129f, -0.00697624f, 
    -0.05082076f, 0.01169015f, -0.06270745f, -0.06732670f, -0.04412371f, 0.00904232f, -0.06891058f, -0.04190945f, 
    -0.05561381f, -0.06020193f, -0.02487929f, 0.05744893f, 0.01604072f, -0.06426574f, 0.04656471f, 0.01280943f, 
    0.00966050f, -0.08133192f, -0.00358490f, -0.02958201f, -0.06298485f, 0.05270644f, -0.03884805f, 0.03228879f, 
    -0.02822151f, -0.02095497f, 0.02798091f, -0.01757161f, -0.03632927f, 0.05136078f, 0.04195100f, -0.02259806f, 
    0.03162401f, 0.01038357f, -0.06321121f, -0.00535246f, -0.01351953f, 0.05370023f, 0.04847001f, 0.01341629f, 
    -0.07472105f, 0.00567365f, 0.03212170f, -0.02630000f, 0.01294919f, 0.01047694f, -0.03490691f, -0.00844514f, 
    0.02711742f, 0.06480958f, -0.00167723f, -0.00264247f, -0.05742969f, -0.01160498f, -0.05200746f, -0.01125447f, 
    0.04146989f, 0.00617168f, 0.00622496f, -0.03699994f, -0.01708963f, 0.01960350f, -0.07219378f, 0.02033974f, 
    0.05963597f, -0.03285658f, 0.05902835f, -0.00483629f, -0.00180202f, -0.03101201f, -0.05311774f, 0.03705153f, 
    0.03723473f, 0.05112365f, -0.03690336f, -0.04365284f, -0.05027081f, -0.04698929f, 0.05801284f, 0.02019998f, 
    -0.08027415f, -0.03890525f, -0.02631857f, -0.01908212f, -0.01209771f, 0.05086530f, -0.01620018f, 0.01391907f, 
    0.00907523f, 0.04360031f, 0.05015460f, 0.00866315f, -0.05665326f, 0.00931921f, 0.04825624f, 0.03005330f, 
    0.00700451f, 0.05910859f, -0.01261443f, -0.05802508f, 0.02128447f, 0.02565133f, -0.07033452f, 0.02501987f, 
    -0.05507929f, 0.05136550f, -0.05887091f, -0.00131887f, 0.02655661f, 0.05639137f, -0.02014793f, -0.06368054f, 
    -0.06956341f, -0.05978698f, -0.07761513f, -0.00551604f, -0.05324519f, -0.00849990f, -0.00986302f, -0.07144511f, 
    -0.32748443f, -0.44353092f, -0.17076533f, 0.25848141f, -0.13779090f, 0.17808354f, 0.36756679f, -0.21615796f, 
    -0.09631887f, -0.02787741f, -0.00015443f, -0.12856485f, -0.01216328f, -0.18510856f, -0.05622442f, -0.01060057f, 
    -0.00976878f, -0.16045062f, 0.03080980f, 0.14043699f, 0.15107109f, 0.07174175f, 0.16843897f, 0.21760240f, 
    -0.04043177f, 0.15736338f, -0.40029800f, -0.09801205f, 0.03527409f, 0.01240390f, 0.14874265f, 0.11669721f, 
    -0.00159115f, 0.21912491f, -0.11674605f, -0.01799344f, 0.21212199f, 0.09657560f, 0.16312200f, 0.06423065f, 
    -0.22354662f, -0.05760152f, 0.09030433f, 0.09065300f, -0.04894928f, 0.02992444f, 0.17706716f, 0.11026807f, 
    -0.10966154f, 0.00358210f, 0.05138582f, -0.30356070f, 0.03295233f, -0.02865308f, -0.05511354f, -0.00243468f, 
    0.05579441f, 0.04816525f, 0.15159549f, 0.05494003f, -0.28258312f, -0.48981112f, -0.38103881f, 0.24919069f, 
    0.23119456f, -0.04770942f, -0.12716426f, -0.00910252f, -0.01201407f, 0.06889293f, -0.02683086f, 0.05418808f, 
    -0.19964711f, 0.06905451f, -0.01209838f, 0.05223291f, 0.16315816f, 0.02225225f, 0.07022756f, -0.07808533f, 
    0.13296591f, 0.08144755f, 0.13415146f, 0.00019619f, -0.36322120f, 0.02910303f, -0.34704870f, 0.05462342f, 
    0.01492101f, 0.18796407f, 0.05849376f, 0.00839728f, -0.03064051f, 0.05333718f, 0.11834989f, -0.07242870f, 
    0.89877313f, 0.47575617f, -0.28983107f, -0.27309188f, 0.13391872f, 0.20423935f, 0.10725603f, 0.05423427f, 
    -0.06348476f, 0.12993850f, 0.13709384f, -0.10291766f, 0.03592458f, -0.31946859f, 0.02006203f, 0.11055630f, 
    0.16986771f, 0.13340996f, 0.25463361f, 0.24479976f, 0.05121187f, -0.00265219f, -0.02377129f, 0.02510759f, 
    -0.02362984f, 0.11451896f, 0.29270408f, 0.45953035f, 0.00686486f, -0.04070222f, 0.19448709f, 0.35160580f, 
    0.17521340f, 0.06070873f, 0.20310007f, 0.16565199f, 0.12261180f, 0.08198308f, -0.01749058f, -0.27548763f, 
    0.06599781f, 0.11722811f, -0.13316284f, -0.02096623f, -0.05494845f, -0.08749031f, -0.00244466f, -0.13343936f, 
    -0.08827454f, -0.34056005f, 0.21752514f, 0.46303138f, 0.20304270f, 0.14567539f, 0.16164656f, -0.13335809f, 
    -0.10053657f, 0.03538395f, 0.07929634f, 0.00777973f, -0.10864827f, 0.06235550f, -0.06129823f, -0.15774332f, 
    -0.00022611f, -0.00043302f, 0.13425338f, -0.02769296f, -0.00395644f, 0.03838874f, 0.09090572f, -0.03486143f, 
    -0.12002775f, -0.11683329f, -0.05978067f, -0.17986692f, -0.01200640f, 0.05983708f, 0.03616720f, -0.08198496f, 
    0.11018882f, 0.20223451f, -0.06192565f, -0.05073147f, -0.24290195f, 0.44656596f, 0.18356054f, -0.03234005f, 
    -0.11314984f, -0.12751390f, -0.04230878f, -0.09319469f, 0.24352318f, 0.14001261f, 0.36532813f, 0.01813201f, 
    0.15447178f, -0.19840737f, -0.43800709f, -0.20362529f, 0.03959660f, -0.08445656f, 0.08179174f, 0.03781927f, 
    -0.13532849f, 0.11794005f, 0.04386932f, 0.02946186f, -0.20191377f, -0.17762958f, -0.01260911f, -0.10304594f, 
    0.04541531f, -0.18861397f, 0.15004593f, 0.04471222f, 0.07204980f, -0.08173641f, -0.00340710f, -0.00300565f, 
    0.29655275f, -0.25311938f, -0.09381405f, 0.02567935f, 0.21414664f, 0.06038596f, 0.14463109f, 0.14620931f, 
    -0.03650936f, 0.20942712f, -0.14515959f, 0.00632596f, 0.27907816f, 0.30017269f, -0.35720903f, -0.11519749f, 
    -0.00428635f, 0.15095770f, 0.45691904f, 0.10430028f, 0.17502528f, 0.13902175f, 0.12129794f, 0.18008083f, 
    0.19558869f, -0.18686269f, 0.22815664f, -0.09668104f, 0.13736357f, 0.08255550f, 0.00030494f, -0.02305081f, 
    0.05098810f, 0.05745498f, 0.08854505f, 0.00721332f, -0.40916851f, -0.09023661f, 0.05175690f, -0.02551997f, 
    0.07602288f, 0.13490906f, -0.04449031f, -0.25860021f, -0.04283449f, -0.13478628f, -0.06593204f, -0.08208531f, 
    0.02115524f, -0.10364970f, -0.03977098f, -0.09859011f, 0.23506580f, -0.03324358f, -0.01006234f, -0.05288646f, 
    -0.04783759f, 0.05088640f, -0.08919839f, 0.10052401f, -0.15037268f, -0.26851141f, 0.47895223f, 0.18947706f, 
    0.04977870f, 0.01452789f, -0.00687668f, 0.20469026f, 0.00833787f, 0.18484317f, 0.05195750f, 0.10894861f, 
    0.14925118f, -0.53481477f, -0.30183670f, 0.59782040f, 0.16131166f, 0.11349797f, 0.05630364f, 0.06026178f, 
    0.19957653f, -0.07788833f, -0.00338752f, -0.07400739f, 0.04972905f, -0.23027678f, -0.20988975f, -0.07963907f, 
    0.01373717f, 0.16405420f, 0.17933543f, -0.04073819f, 0.01473428f, -0.12825088f, -0.14807978f, 0.03685301f, 
    0.01106726f, 0.02602250f, 0.07890438f, -0.28944048f, -0.06217344f, -0.01580315f, 0.38808134f, -0.06420971f, 
    -0.05477906f, 0.21309872f, 0.36436880f, 0.01796248f, -0.12518725f, 0.14283746f, -0.04389371f, -0.11662012f, 
    -0.06781373f, 0.07419212f, -0.02992885f, 0.03472381f, -0.08777843f, 0.13707818f, 0.17720430f, -0.11523683f, 
    -0.73421460f, -0.13254169f, 0.36602193f, -0.25787619f, 0.02877513f, 0.23623821f, 0.20253493f, 0.30719352f, 
    0.00211206f, 0.01183975f, 0.06972665f, -0.05022795f, 0.17340381f, -0.00485261f, -0.04062546f, -0.06324802f, 
    -0.07357553f, -0.05471605f, -0.01961333f, -0.05643296f, 0.06145105f, -0.07960130f, 0.12392176f, -0.05792633f, 
    -0.01258960f, -0.06086782f, -0.06460637f, -0.14453441f, -0.06464770f, 0.06227362f, 0.00403092f, 0.02311520f, 
    0.08907859f, 0.19244996f, 0.10479161f, -0.03380338f, 0.15206163f, -0.00940449f, 0.22771595f, -0.12828425f, 
    -0.02762052f, -0.06755431f, 0.07244130f, -0.07501785f, 0.24301904f, 0.11062179f, 0.34299925f, 0.04068396f, 
    0.18419167f, 0.46207470f, 0.01327790f, 0.11875118f, 0.05768818f, -0.00933466f, -0.01716316f, 0.15249734f, 
    0.12009127f, 0.10930253f, -0.04494752f, 0.00580830f, 0.03189406f, -0.00150555f, 0.06386434f, 0.04153060f, 
    -0.11707716f, 0.01724705f, -0.04147076f, -0.00839405f, 0.07244868f, -0.24245927f, -0.09469568f, -0.07801513f, 
    0.23102689f, -0.33385360f, -0.01826262f, 0.04217451f, -0.10376175f, -0.00023676f, 0.09953311f, 0.00032027f, 
    -0.03029342f, 0.15292495f, -0.08388991f, -0.05810413f, 0.01057245f, 0.18579011f, -0.18286231f, 0.02223150f, 
    -0.08580130f, 0.15675913f, 0.03647669f, -0.32642376f, -0.05489313f, -0.13472122f, 0.07995538f, -0.00294577f, 
    -0.03901911f, -0.09262370f, 0.07720247f, -0.15953314f, 0.10715087f, 0.04974813f, -0.03641923f, 0.11456875f, 
    0.01443672f, -0.12461782f, -0.10332948f, -0.08226476f, -0.01550313f, 0.24207695f, 0.44423056f, 0.01851204f, 
    0.10455165f, 0.17897856f, 0.00913388f, -0.01753196f, 0.09297344f, -0.12821713f, 0.04294497f, -0.04685567f, 
    0.06925716f, -0.09071840f, 0.09851276f, 0.04656679f, 0.33896202f, 0.04127271f, -0.20770676f, 0.09977702f, 
    0.03722359f, -0.02021259f, -0.02183566f, -0.03505909f, 0.03609485f, -0.04481336f, 0.33527264f, -0.14610483f, 
    -0.09970880f, -0.09288422f, -0.12754713f, 0.04184641f, -0.08663362f, 0.03222490f, -0.09823207f, 0.17220376f, 
    -0.16834863f, -0.62016881f, 0.24980730f, 0.53078407f, 0.01195091f, -0.20888895f, 0.01412916f, -0.07023039f, 
    0.07169587f, -0.12889461f, 0.19241977f, 0.00963115f, -0.26964808f, 0.24929756f, 0.15178755f, 0.06255203f, 
    0.07455798f, 0.09521775f, 0.07420168f, 0.14539063f, 0.05158630f, 0.05445229f, 0.04553657f, -0.05107660f, 
    -0.32519194f, -0.02724450f, -0.06567487f, -0.02724795f, -0.10406283f, 0.05139003f, -0.28957951f, 0.16885009f, 
    -0.03466222f, -0.03713179f, 0.07607809f, 0.08352047f, -0.04431004f, 0.06216630f, 0.04399786f, -0.02440717f, 
    0.05233401f, -0.05056012f, 0.14129934f, 0.07520100f, -0.06786850f, 0.04829249f, -0.23167995f, 0.24524459f, 
    -0.40223497f, 0.20801194f, 0.15911673f, -0.03536417f, -0.02630150f, -0.24966176f, 0.09838049f, 0.13482092f, 
    0.06786881f, 0.04250103f, 0.32717770f, -0.10956760f, 0.09375526f, 0.01537432f, -0.04991882f, -0.01360111f, 
    0.08998059f, 0.07193691f, -0.02090792f, 0.07209620f, 0.06882317f, -0.16460131f, -0.05199178f, 0.07619411f, 
    0.05561982f, 0.01540666f, 0.03775592f, 0.01757069f, 0.13877636f, 0.01114808f, 0.00920768f, 0.04631105f, 
    -0.11579995f, 0.03415220f, 0.16181043f, -0.03682376f, -0.09704932f, 0.05216546f, -0.13842598f, -0.11077102f, 
    0.00197852f, 0.07289416f, 0.00610723f, -0.03354264f, 0.08403473f, -0.14422080f, -0.05599605f, 0.04758644f, 
    -0.17227028f, -0.21570967f, 0.51893872f, -0.03518163f, -0.05956310f, 0.10699074f, 0.13195890f, 0.19318858f, 
    0.16380712f, 0.21785019f, 0.09027241f, 0.33262753f, -0.17285621f, -0.07771078f, 0.03906970f, 0.06483432f, 
    0.02896129f, -0.16805235f, -0.17325917f, -0.11280410f, -0.47623891f, -0.18159463f, -0.41427103f, -0.55079460f, 
    -0.18283127f, -0.17539890f, 0.07422195f, 0.14519517f, 0.26741242f, -0.04234877f, -0.01754470f, -0.14309260f, 
    0.23002172f, -0.13456228f, 0.19107656f, -0.09429718f, 0.13870020f, 0.14237726f, 0.42906827f, 0.03514352f, 
    -0.06363539f, 0.12934276f, -0.07146926f, -0.11242736f, 0.02203250f, 0.32608029f, 0.19866094f, 0.27465761f, 
    0.05226834f, 0.14149101f, 0.33321235f, -0.26000673f, 0.09711926f, -0.12467144f, -0.06735733f, -0.04904585f, 
    -0.11629587f, 0.14635916f, -0.04470190f, -0.18166399f, -0.13178517f, -0.25429428f, -0.13897958f, -0.00586667f, 
    -0.08332185f, -0.03630809f, -0.05269806f, -0.03103406f, 0.06646325f, -0.12250400f, 0.05564825f, -0.16880831f, 
    -0.17530878f, 0.41346282f, 0.21532282f, -0.25292945f, 0.14703335f, -0.07179440f, -0.09635373f, 0.16593097f, 
    -0.50630385f, -0.29324281f, -0.33028653f, -0.27314481f, -0.05100343f, 0.04111350f, -0.05596270f, 0.07895295f, 
    0.10691980f, 0.08843576f, -0.12062284f, 0.09472907f, -0.05761576f, 0.12237879f, 0.13824314f, 0.01554350f, 
    0.48642421f, -0.09678892f, -0.32965422f, -0.22783197f, -0.15687217f, 0.00760444f, 0.13157773f, 0.04806099f, 
    0.03859489f, 0.04942127f, -0.22144622f, 0.16081387f, -0.12524803f, -0.25569710f, 0.24459322f, 0.09146741f, 
    0.08232907f, 0.05891096f, 0.02700434f, 0.14802925f, -0.07154563f, -0.31004223f, -0.14886563f, -0.13558345f, 
    -0.30893829f, 0.73903430f, 0.22169961f, 0.27218145f, -0.23257671f, 0.19036126f, 0.25384089f, -0.20827942f, 
    0.04596671f, -0.09957658f, 0.11328238f, 0.10392825f, 0.18108296f, 0.08120519f, -0.21033494f, -0.18251818f, 
    -0.14836974f, -0.05081729f, 0.33257717f, 0.07659160f, -0.14091344f, 0.09155015f, 0.16358292f, 0.33850792f, 
    0.37518242f, -0.24643481f, 0.14823058f, 0.40564975f, 0.08382475f, 0.04838942f, -0.09756409f, -0.03273399f, 
    0.01042577f, -0.07837486f, 0.01088830f, 0.19609822f, -0.12811479f, -0.19928531f, 0.11889388f, 0.11895812f, 
    -0.15598957f, -0.25869861f, 0.07783537f, 0.08281670f, -0.25967622f, -0.27665815f, -0.06168969f, -0.16682705f, 
    -0.39023629f, -0.26627031f, -0.05567114f, 0.00468026f, -0.14160927f, 0.04456714f, 0.04404173f, -0.16624974f, 
    0.29006681f, 0.03906588f, -0.13069841f, 0.39591599f, -0.04134815f, 0.35454598f, 0.19241688f, 0.08430076f, 
    0.05766347f, 0.21617411f, 0.08599348f, -0.20086439f, 0.24481130f, 0.24491860f, 0.24734294f, 0.30760327f, 
    -0.11189618f, 0.18303400f, 0.28176963f, -0.46248323f, -0.02098753f, -0.18559404f, -0.15789557f, 0.02130222f, 
    -0.06099826f, -0.19725037f, -0.05861313f, -0.12664057f, -0.13253595f, 0.12988490f, -0.30835739f, -0.12679993f, 
    0.09607590f, 0.23858486f, 0.11676055f, 0.09800357f, -0.09704310f, 0.16660085f, 0.18441635f, 0.10643417f, 
    0.39488840f, -0.01204671f, 0.37417546f, 0.25798282f, 0.01008975f, 0.18669309f, -0.18783991f, 0.29548344f, 
    -0.07289441f, 0.13723223f, 0.17508055f, 0.29097205f, 0.11189692f, -0.52200979f, 0.37780514f, -0.23468509f, 
    0.32554340f, -0.09152523f, 0.00736691f, 0.18722948f, 0.17319670f, 0.11871257f, -0.07756561f, -0.01371752f, 
    0.23727414f, 0.30131179f, -0.10181820f, 0.55384463f, -0.23254623f, 0.01216721f, -0.00513849f, -0.04984789f, 
    0.02942473f, -0.18281469f, 0.03498609f, 0.10890585f, 0.08668711f, 0.02890362f, -0.10452720f, -0.23695998f, 
    -0.00446692f, -0.13024479f, 0.09252227f, -0.21217938f, -0.10433902f, 0.08690575f, -0.01263160f, 0.12829891f, 
    0.10245853f, 0.03480342f, 0.15102276f, -0.24293949f, -0.08229195f, 0.05158102f, 0.07165579f, 0.01626652f, 
    -0.00548764f, -0.09569089f, -0.09527373f, -0.06762433f, 0.29385120f, -0.14009894f, -0.01081100f, -0.09337400f, 
    0.17874166f, 0.00061663f, 0.02028417f, 0.06237633f, 0.05066081f, 0.03145500f, 0.03202626f, -0.13820094f, 
    -0.20714493f, 0.24761678f, 0.32998249f, -0.17057611f, 0.24007268f, 0.06240239f, -0.04262822f, 0.24560136f, 
    0.10341884f, 0.10998959f, -0.15391077f, 0.20953912f, -0.02603775f, 0.19623666f, -0.24525538f, -0.24789134f, 
    -0.01974367f, -0.02103909f, -0.02708683f, -0.13067985f, -0.08397695f, 0.04134970f, 0.12159474f, 0.14647819f, 
    0.31376970f, 0.14366910f, 0.02654451f, -0.12542281f, -0.07388003f, 0.19058195f, 0.04286363f, 0.14969058f, 
    0.18188387f, -0.05285242f, -0.08168867f, 0.05634542f, -0.05732017f, -0.00473627f, -0.02501002f, -0.17724848f, 
    -0.05011155f, -0.16170077f, -0.02904340f, -0.31443095f, 0.07294579f, -0.14588866f, 0.09118711f, 0.00645092f, 
    0.28092432f, 0.15379617f, 0.12934193f, -0.02711163f, 0.07815416f, 0.07506371f, 0.03998201f, 0.11784066f, 
    0.01501997f, -0.10363627f, -0.08016374f, 0.06203290f, 0.24546933f, 0.14259034f, 0.07441644f, 0.07666967f, 
    -0.04035764f, -0.21466860f, 0.02158851f, -0.03269896f, -0.14289969f, 0.07037457f, 0.12721457f, 0.01399730f, 
    -0.06074858f, -0.05520830f, -0.01613009f, -0.03582151f, -0.31337446f, -0.19127220f, -0.02639176f, -0.01839708f, 
    -0.22174908f, -0.13107948f, -0.07405695f, -0.18422003f, 0.30304495f, 0.09117512f, 0.07453066f, 0.16942446f, 
    -0.06307724f, -0.23332016f, -0.08203517f, -0.15556501f, -0.09231760f, 0.05238770f, 0.01927538f, 0.02973486f, 
    -0.05907594f, -0.00851768f, 0.05570767f, -0.03933297f, -0.06920881f, -0.04242623f, -0.04131789f, -0.02353747f, 
    -0.00989148f, 0.06331898f, -0.04678391f, -0.06164138f, 0.04374513f, 0.04466556f, 0.02117086f, -0.01765512f, 
    -0.06820951f, -0.05444865f, -0.07647572f, 0.04416205f, -0.01387811f, -0.00135346f, 0.03212525f, -0.06069213f, 
    -0.01479169f, -0.06143982f, 0.04817038f, -0.02085925f, -0.01970019f, 0.00254464f, 0.04441851f, -0.01143195f, 
    0.02210333f, -0.04297458f, -0.04519834f, 0.05168588f, 0.02016211f, 0.03330779f, -0.04076456f, -0.01324628f, 
    -0.06038867f, 0.01509565f, -0.03977698f, 0.01346660f, -0.06352688f, -0.01798833f, 0.00203522f, -0.07216331f, 
    -0.05293822f, -0.06161373f, -0.06923076f, -0.06537058f, 0.03713220f, -0.04860301f, 0.01426748f, -0.02603306f, 
    0.06533769f, -0.01126921f, -0.06221197f, 0.02871164f, 0.05821728f, -0.00729079f, 0.04784532f, 0.01556287f, 
    0.03591077f, -0.05966864f, -0.02822619f, -0.02526930f, 0.00732696f, -0.04183428f, -0.03485753f, -0.07749736f, 
    -0.06056798f, 0.02489895f, -0.03437151f, 0.05587713f, -0.07437645f, 0.05102164f, 0.01943997f, -0.07833405f, 
    0.04780468f, -0.01265881f, -0.06379972f, 0.04381893f, -0.00906428f, -0.02407241f, -0.04401375f, -0.04955117f, 
    -0.04790055f, -0.06190525f, -0.01272359f, -0.02799582f, 0.00511943f, -0.06386384f, 0.01458773f, 0.06140323f, 
    -0.00705785f, 0.01081188f, -0.05962540f, 0.04653686f, -0.07269549f, -0.00983991f, -0.05309358f, -0.05588156f, 
    -0.03390474f, -0.05742642f, -0.00947694f, 0.00941822f, -0.00085442f, 0.05194987f, -0.01612073f, -0.06120485f, 
    0.03264540f, -0.04072131f, -0.01068292f, -0.05133329f, -0.01580292f, 0.06321952f, 0.02123346f, 0.02449879f, 
    -0.05127776f, 0.04248559f, -0.04711465f, 0.03468305f, -0.04511437f, 0.06625392f, 0.03539905f, -0.03885887f, 
    0.01812497f, -0.01494683f, -0.00717170f, 0.04705692f, -0.04116791f, 0.00048124f, 0.02502863f, -0.08430378f, 
    -0.01220948f, 0.00040755f, -0.04537531f, -0.03251419f, -0.00232440f, -0.06199119f, -0.00356898f, 0.05647214f, 
    -0.01052736f, -0.04930758f, -0.02488617f, 0.01656117f, 0.01646992f, 0.04786618f, 0.05795737f, -0.02431303f, 
    0.03685799f, -0.02252509f, -0.05845758f, -0.02944010f, 0.04208443f, 0.05718239f, -0.03109511f, -0.08362173f, 
    -0.01590716f, 0.02081889f, -0.05852077f, 0.02512776f, 0.04988119f, 0.03925162f, -0.07524702f, 0.02791159f, 
    -0.06897251f, 0.04880923f, -0.04133399f, 0.03051894f, 0.00119710f, -0.05404684f, 0.03956053f, -0.03323637f, 
    -0.00334419f, 0.04184345f, 0.03026583f, -0.00753841f, 0.03054523f, -0.00359463f, -0.05384001f, 0.04840851f, 
    -0.03787092f, 0.04861322f, 0.02630833f, -0.07403481f, 0.02573660f, -0.03567857f, 0.00575808f, 0.01218575f, 
    0.11055612f, 0.32158598f, 0.04019817f, -0.08006158f, -0.38563892f, -0.29195601f, 0.24420226f, -0.09432071f, 
    0.00907088f, 0.01004941f, -0.04195875f, 0.01994391f, 0.16420506f, -0.07689215f, -0.01455399f, -0.04550881f, 
    0.03355137f, -0.02646161f, -0.02264698f, 0.02518162f, -0.11462236f, 0.02277726f, 0.00794202f, -0.03516435f, 
    0.11348780f, 0.04126895f, -0.04893878f, 0.13260296f, 0.04141810f, -0.06993002f, -0.00638553f, -0.01684809f, 
    0.16733332f, -0.07027864f, 0.09706743f, 0.08358582f, -0.11054963f, 0.18106697f, -0.14410813f, 0.07061376f, 
    0.07028393f, 0.32909673f, 0.16524050f, 0.11080083f, 0.28028053f, 0.39090511f, 0.01329591f, 0.09408580f, 
    0.58262724f, 0.26539126f, 0.31538308f, -0.09445121f, -0.00233097f, -0.09993294f, 0.00112386f, 0.02020201f, 
    0.14961898f, 0.04921386f, 0.05611939f, -0.01443407f, -0.20068662f, -0.40867618f, -0.35860375f, -0.10854135f, 
    0.04415481f, -0.33822614f, -0.17583194f, 0.11960962f, -0.14357433f, -0.08257602f, -0.05866817f, -0.08349156f, 
    -0.00165796f, 0.12888137f, -0.02424507f, 0.07206785f, -0.15282537f, 0.02958683f, 0.04550617f, -0.01270131f, 
    0.04721451f, 0.05600448f, -0.10604955f, 0.07044151f, 0.22915325f, -0.31750903f, -0.46318957f, -0.06876009f, 
    0.20435029f, -0.08877265f, -0.08463030f, 0.17557666f, -0.19101836f, -0.01192227f, -0.07036862f, -0.04328755f, 
    0.27351904f, -0.09190683f, -0.07079823f, 0.07294613f, -0.26828605f, 0.05001134f, -0.15644117f, -0.11348011f, 
    0.01502103f, -0.11303439f, -0.04337232f, 0.13241015f, -0.09558795f, 0.06708299f, 0.07219794f, 0.13429722f, 
    -0.13615143f, -0.04903474f, 0.01323424f, 0.23907390f, -0.10740401f, -0.01142437f, -0.01274647f, -0.08419715f, 
    -0.22182596f, -0.08468729f, 0.17497115f, 0.06471904f, -0.07423481f, 0.09642352f, 0.32626441f, -0.06896746f, 
    0.07292216f, 0.14582272f, 0.26266623f, -0.17224070f, 0.35342056f, 0.20771345f, -0.04666822f, -0.12865226f, 
    -0.11134937f, 0.07243315f, 0.06217657f, 0.03708693f, 0.33526623f, 0.09314249f, 0.11369485f, -0.09949561f, 
    0.10072803f, -0.63363874f, -0.16377848f, -0.03962505f, 0.06433746f, -0.24469797f, -0.05492374f, 0.38908973f, 
    -0.02740421f, -0.10451302f, -0.15703280f, 0.01976260f, 0.30682710f, 0.30965790f, 0.26383841f, 0.13498937f, 
    -0.07388085f, -0.09644517f, -0.00757572f, -0.05341410f, 0.19182362f, 0.03732595f, -0.10030228f, 0.07996889f, 
    0.01358523f, 0.04875596f, 0.12101483f, 0.05736574f, 0.01365059f, -0.04581758f, 0.06740182f, -0.11015757f, 
    0.25447106f, -0.10542127f, -0.01536585f, 0.18696643f, 0.24935408f, -0.01998640f, 0.26667327f, -0.13342637f, 
    0.02175052f, -0.02361057f, -0.04023811f, -0.03783050f, 0.35359550f, 0.33509690f, -0.09524482f, -0.02240365f, 
    -0.18224293f, 0.22609328f, -0.26682669f, -0.13451834f, 0.04461069f, 0.05610182f, 0.07008617f, 0.09101404f, 
    -0.07734902f, -0.12439161f, -0.03164107f, 0.23322931f, -0.07473742f, 0.07236865f, 0.09145366f, -0.08113708f, 
    0.03078244f, 0.11212727f, -0.01641273f, -0.03030806f, -0.24713509f, 0.10547667f, 0.08146136f, 0.02772331f, 
    -0.39423165f, -0.22377323f, 0.50036824f, 0.36534271f, 0.28649017f, -0.18043558f, -0.25199953f, -0.20181932f, 
    0.10776430f, 0.11403114f, 0.04923989f, -0.00005583f, -0.30665842f, 0.30657801f, -0.15436970f, -0.30155063f, 
    0.15388884f, -0.03140786f, 0.08572962f, 0.07473797f, 0.10148446f, 0.12134088f, 0.04392457f, 0.14203840f, 
    -0.17186062f, -0.56122679f, -0.06975219f, -0.04094801f, 0.21688116f, 0.25002977f, 0.12611444f, 0.09655660f, 
    -0.21981183f, -0.10965557f, -0.07853269f, -0.04216845f, 0.12623398f, 0.37662566f, 0.31464317f, -0.13777317f, 
    -0.05012635f, 0.10760652f, 0.24315441f, 0.08946266f, -0.09780579f, 0.08949076f, 0.05955924f, 0.05118287f, 
    -0.38041964f, -0.28372368f, -0.37185287f, -0.21461660f, 0.17276496f, 0.24147263f, 0.30074829f, 0.25467685f, 
    -0.11980235f, -0.09257036f, -0.20288707f, -0.03319294f, 0.36813343f, 0.15208228f, 0.41410193f, 0.20577836f, 
    0.18407929f, 0.12171035f, 0.07073150f, 0.12214176f, 0.09110098f, -0.14292771f, -0.09294348f, -0.10805590f, 
    -0.70793170f, -0.36068675f, -0.07826359f, 0.14218596f, 0.25146386f, 0.21546791f, 0.10518291f, -0.19654106f, 
    0.04023557f, 0.01060061f, -0.21702847f, 0.11894936f, -0.01709870f, 0.17724617f, -0.29407802f, -0.48260951f, 
    0.08414450f, 0.14489578f, -0.08132031f, 0.16532862f, 0.08779640f, 0.02759695f, -0.00786243f, -0.09276381f, 
    0.50307304f, 0.35511491f, 0.52499241f, -0.50329119f, 0.13259457f, 0.05176128f, 0.23514344f, -0.10952430f, 
    -0.03730165f, 0.03053001f, -0.14173429f, 0.09984524f, -0.57056111f, -0.40294212f, -0.14261599f, -0.13365048f, 
    -0.00079085f, -0.01511447f, -0.15428628f, -0.09280523f, -0.06680584f, -0.08421423f, 0.06558140f, 0.12369507f, 
    0.38574162f, 0.25975844f, 0.24529240f, -0.30624574f, -0.11927530f, -0.09663057f, -0.08138269f, 0.24417758f, 
    0.21840364f, -0.10225397f, 0.17154765f, -0.00997211f, -0.40292922f, -0.44681770f, -0.15487924f, 0.12375661f, 
    0.09887050f, 0.05610435f, 0.01282789f, -0.20788924f, 0.13777304f, 0.09030722f, 0.10685737f, 0.01782232f, 
    -0.30420420f, -0.38588810f, 0.13784942f, -0.18652293f, -0.04171864f, 0.00906888f, 0.13558179f, -0.09134287f, 
    0.03967811f, -0.11730838f, 0.21491395f, 0.18512659f, 0.27132058f, -0.51547086f, 0.19463877f, 0.16243914f, 
    -0.16518840f, -0.15941800f, -0.03355156f, -0.23824319f, -0.07914815f, 0.10353200f, -0.09451572f, 0.16284806f, 
    -0.03552360f, 0.02736117f, -0.26127645f, 0.30915323f, 0.08486843f, 0.10380536f, 0.06429414f, 0.10010900f, 
    0.05907735f, 0.11706312f, -0.04847080f, 0.03204690f, -0.01876810f, -0.12685999f, 0.18450700f, 0.08083925f, 
    -0.17437343f, 0.04312658f, -0.03356088f, -0.10061429f, 0.12424345f, -0.15682530f, -0.06132736f, 0.00220840f, 
    -0.41009519f, 0.22275832f, -0.21445939f, 0.04102249f, 0.01506500f, -0.11954533f, 0.16242038f, -0.06473622f, 
    0.04312026f, 0.00832733f, -0.22020946f, -0.17777725f, -0.09679728f, 0.33383548f, -0.42932987f, 0.08221650f, 
    -0.16698788f, 0.07388112f, 0.12690458f, 0.00102888f, -0.01770542f, 0.08433697f, -0.03927339f, 0.14640301f, 
    0.04136245f, -0.03336848f, 0.18369232f, -0.03537593f, 0.04329002f, 0.00091634f, 0.02051681f, 0.04753229f, 
    0.11200967f, -0.02838228f, -0.08090518f, 0.10214405f, -0.20307916f, 0.05006220f, -0.25163573f, -0.04927671f, 
    0.15891464f, 0.28558838f, 0.32554308f, 0.13909949f, 0.00610462f, -0.04045887f, 0.05290619f, 0.12829095f, 
    -0.03018280f, -0.04851396f, -0.28105736f, 0.13193402f, 0.03390855f, 0.04826231f, -0.01502539f, 0.00136628f, 
    0.14917259f, -0.02590031f, 0.00933393f, 0.00788552f, -0.07714250f, 0.26548386f, 0.16813949f, 0.05900051f, 
    -0.12498322f, -0.05965448f, 0.16682066f, 0.25999695f, -0.06680126f, 0.07479250f, -0.08766790f, 0.09573255f, 
    -0.23464172f, 0.06035989f, 0.23091850f, 0.49634457f, -0.07976270f, -0.05464811f, 0.19623221f, -0.04170374f, 
    -0.01666734f, -0.03908839f, 0.03312000f, 0.00621730f, -0.15559991f, -0.22486791f, 0.00589017f, 0.09700200f, 
    0.20356470f, 0.22401233f, 0.31562483f, 0.19488747f, -0.07738837f, -0.01095400f, -0.06333998f, -0.04347911f, 
    -0.06999060f, 0.24691463f, 0.27285945f, -0.05150079f, 0.00397256f, 0.08912995f, 0.04958453f, 0.04302198f, 
    0.01566282f, 0.08395132f, 0.08457031f, 0.15006992f, -0.13925922f, 0.05191571f, 0.04506412f, 0.14442314f, 
    -0.02592950f, -0.04737167f, -0.13975385f, -0.04168371f, -0.04943450f, -0.08162301f, -0.18464787f, -0.04325056f, 
    -0.40575638f, -0.12008538f, 0.49155995f, -0.23597425f, 0.01146209f, 0.02394303f, -0.11089303f, 0.14140749f, 
    -0.02127735f, 0.00849295f, -0.05696374f, -0.08376973f, -0.23050809f, -0.20499420f, 0.04173040f, 0.13130352f, 
    0.04442627f, 0.05500963f, 0.06956145f, -0.04539907f, 0.11719690f, 0.02517565f, -0.05903691f, 0.17345665f, 
    -0.15045959f, -0.16389760f, 0.01529000f, -0.11050952f, 0.15573782f, 0.00806282f, -0.17795107f, -0.07242721f, 
    0.13403648f, -0.00288361f, 0.13292710f, -0.01466748f, -0.03781186f, 0.16577367f, 0.15857086f, -0.14456816f, 
    -0.04576031f, 0.05573951f, 0.01199671f, 0.01260486f, 0.31876105f, 0.08326416f, -0.09517040f, -0.20651165f, 
    -0.02870140f, 0.15982553f, 0.25966907f, 0.05060489f, 0.11957308f, 0.12352218f, -0.12497952f, 0.12079183f, 
    -0.04075537f, 0.02518735f, -0.05498989f, -0.15404835f, -0.06500067f, -0.14957079f, -0.04789558f, -0.10786106f, 
    -0.13733780f, 0.13355783f, -0.00618837f, -0.16861165f, 0.05442722f, -0.11415145f, 0.08963469f, -0.04711772f, 
    0.02339180f, 0.05430919f, 0.05669471f, 0.10346781f, -0.00475662f, 0.12718323f, 0.06222293f, 0.08144794f, 
    -0.28186911f, 0.01103640f, -0.03370676f, 0.03808250f, -0.29617897f, -0.18087795f, -0.23659410f, 0.20307057f, 
    -0.01547768f, 0.12252173f, 0.14183386f, 0.19081062f, -0.11706890f, -0.11585782f, -0.20428234f, -0.03651138f, 
    -0.16047598f, 0.21286057f, 0.05991629f, 0.15342665f, -0.05679183f, 0.05510396f, -0.00853721f, -0.04654102f, 
    0.05972181f, -0.07105730f, 0.07209697f, 0.12137116f, 0.32149783f, 0.33877569f, -0.00401794f, -0.06668950f, 
    0.15449834f, 0.41033402f, 0.18542822f, 0.10383798f, 0.04466314f, 0.10348190f, 0.02149963f, 0.11426916f, 
    -0.00335067f, -0.10623304f, 0.03829681f, 0.10015223f, 0.15541579f, -0.07788859f, -0.19646893f, 0.00310029f, 
    -0.00072826f, 0.06492177f, -0.01423777f, 0.18178399f, 0.45520377f, 0.25006300f, 0.23851129f, -0.17853220f, 
    -0.04184116f, -0.03508417f, 0.15835598f, 0.12007353f, 0.18214732f, 0.02827270f, -0.00892084f, 0.10134290f, 
    0.07466168f, 0.18040302f, 0.85394108f, 0.39757630f, 0.16949145f, -0.06037815f, 0.05112945f, 0.04201858f, 
    0.00439318f, -0.02147208f, 0.16001274f, 0.03904336f, -0.05695548f, 0.18679106f, 0.07035722f, -0.13882980f, 
    0.10882071f, 0.02699847f, 0.07907781f, -0.18915097f, -0.00864493f, 0.07329259f, 0.07489444f, 0.04026075f, 
    0.03806241f, -0.70164788f, -0.19205415f, 0.06024076f, 0.32936174f, 0.08442887f, -0.23753451f, 0.08385049f, 
    -0.05327391f, -0.00298941f, -0.01144008f, 0.29053950f, -0.20277704f, -0.14085320f, 0.10683580f, 0.01141059f, 
    0.01727897f, -0.03728255f, -0.02859964f, -0.15433733f, -0.03268733f, 0.04468760f, -0.01235724f, 0.07185014f, 
    -0.31104663f, 0.36970440f, -0.04509638f, -0.49591142f, 0.10284564f, 0.42015365f, 0.29968992f, 0.35831830f, 
    0.01943680f, -0.02667440f, 0.11597522f, -0.17213209f, -0.14051117f, -0.05971986f, -0.08393276f, -0.00686632f, 
    -0.08924627f, 0.00978451f, -0.01247153f, -0.05934631f, -0.03796949f, -0.02865494f, -0.05008079f, 0.11862837f, 
    -0.03121128f, -0.01579125f, 0.04454426f, 0.01817337f, -0.03123100f, 0.05274059f, -0.12531465f, -0.03040457f, 
    -0.34741911f, 0.03415993f, 0.10674358f, -0.26607168f, -0.34695432f, -0.34653082f, -0.30655032f, -0.03141281f, 
    0.06555207f, 0.04669984f, 0.08739416f, -0.05980645f, 0.17640516f, -0.07952321f, -0.21128531f, -0.28636834f, 
    -0.02511524f, -0.00551024f, -0.01623190f, -0.01760131f, 0.03461241f, -0.01993703f, -0.02129139f, 0.00416480f, 
    -0.02594803f, -0.08157034f, -0.04738114f, 0.00186519f, 0.04114144f, 0.04658696f, 0.04508354f, -0.07936188f, 
    0.01388984f, 0.01675222f, 0.01910432f, -0.07370763f, 0.02731843f, 0.02097298f, -0.03547239f, 0.05426059f, 
    -0.00475209f, -0.04266349f, 0.05048059f, -0.03224840f, -0.06175469f, 0.03063880f, 0.03412007f, -0.03465633f, 
    0.01170188f, -0.01227942f, 0.06357277f, 0.02261442f, 0.04369780f, 0.04700535f, -0.07231312f, 0.03497095f, 
    0.01284346f, -0.00011012f, 0.03849274f, -0.02765837f, -0.07550296f, 0.03807190f, -0.08067402f, -0.06364502f, 
    -0.04981134f, 0.00273138f, 0.01536012f, 0.02730339f, -0.07374018f, 0.03233964f, -0.05574010f, -0.03960232f, 
    -0.00691440f, -0.04570618f, 0.02514892f, 0.01565227f, 0.00124988f, 0.03994031f, -0.07845831f, -0.03694621f, 
    -0.04189278f, 0.01124161f, -0.02619345f, -0.04632269f, 0.03191744f, 0.01763343f, -0.00358711f, -0.05173555f, 
    0.05490971f, -0.01293312f, -0.04524087f, -0.06053068f, 0.01576091f, 0.06579702f, -0.06586378f, 0.01453723f, 
    0.06114080f, -0.02133710f, -0.05211089f, -0.04916063f, 0.04508115f, -0.03306087f, 0.04881870f, -0.04023441f, 
    0.04686524f, -0.03833253f, -0.00053106f, 0.00826459f, -0.00123263f, -0.04328112f, 0.05719234f, -0.02735706f, 
    -0.03008698f, 0.06624585f, -0.01694658f, 0.03845531f, -0.07148335f, -0.00503209f, 0.04205515f, 0.01762642f, 
    0.03846739f, -0.00639396f, -0.03681506f, 0.01908929f, 0.00034276f, -0.07163622f, -0.06834858f, -0.04547709f, 
    0.00997202f, 0.01075244f, -0.01740245f, -0.04487795f, -0.00789725f, 0.03275516f, 0.04812582f, -0.00302201f, 
    -0.06385607f, -0.04897638f, 0.04701544f, -0.06948812f, 0.05527003f, -0.04661381f, 0.02874037f, -0.01485618f, 
    0.00014689f, -0.07505841f, -0.05266322f, -0.00582814f, -0.05626787f, -0.06783888f, 0.04828691f, -0.02524059f, 
    0.02954976f, -0.00816737f, -0.04777851f, -0.01780980f, -0.05736511f, 0.02632148f, -0.03330873f, 0.04895412f, 
    0.04202372f, 0.04919638f, 0.01711192f, 0.04645361f, 0.01024469f, 0.05491932f, -0.03208066f, 0.00199532f, 
    -0.04932988f, -0.08070146f, 0.01794256f, 0.01530711f, 0.00757492f, -0.06601829f, -0.05664558f, -0.04029748f, 
    -0.05299212f, 0.02113511f, -0.02219386f, 0.03700342f, -0.07332085f, 0.06147725f, -0.03008276f, -0.05128622f, 
    -0.01150205f, 0.02899831f, 0.06687450f, 0.04274939f, -0.02616741f, -0.07172961f, -0.03116885f, -0.02936075f, 
    0.00521941f, 0.00109373f, -0.03091837f, -0.06500459f, 0.02231773f, 0.05178672f, 0.03710199f, -0.04301553f, 
    -0.05657606f, -0.00011329f, 0.03574708f, 0.01419260f, -0.01185916f, -0.07249059f, -0.05005372f, 0.04348327f, 
    0.43387851f, 0.32110128f, 0.06021303f, 0.29815963f, 0.10708182f, 0.11123975f, 0.27107400f, 0.22519940f, 
    0.26236534f, 0.07718936f, 0.02250043f, 0.28258416f, -0.09148918f, -0.12142408f, 0.25018358f, 0.17666817f, 
    0.26807702f, -0.37518358f, -0.28940776f, -0.20461521f, -0.41101751f, -0.26331812f, -0.45294574f, -0.69339061f, 
    -0.05489790f, -0.26270548f, -0.21847811f, -0.14507496f, 0.08884449f, 0.14568196f, 0.07140943f, -0.41306406f, 
    0.06766000f, -0.12279335f, 0.03886615f, 0.00710072f, -0.06062309f, 0.33365336f, -0.13210067f, 0.04118852f, 
    -0.01322719f, 0.12083740f, -0.01828456f, 0.03113931f, 0.04514710f, 0.11171007f, 0.30625948f, 0.29708040f, 
    0.09039514f, -0.37734300f, 0.12380669f, -0.18231277f, 0.15412287f, -0.14284040f, -0.01724290f, -0.07317577f, 
    -0.41815037f, 0.06340156f, -0.11161930f, -0.19329679f, 0.14003471f, 0.17300554f, 0.31955770f, 0.21074240f, 
    0.02577052f, -0.00109682f, -0.09575524f, 0.51796114f, 0.01526183f, -0.18116200f, 0.09585392f, -0.28497982f, 
    -0.30764228f, -0.17886788f, -0.03949291f, -0.00672951f, 0.29979414f, -0.08202237f, -0.02713056f, 0.10547437f, 
    -0.41492394f, -0.19214511f, -0.24857149f, -0.62814039f, -0.07232784f, -0.06518734f, 0.12475167f, 0.08463813f, 
    -0.04924156f, 0.10669401f, 0.13905220f, -0.04929953f, 0.00659039f, 0.11604932f, 0.14104541f, 0.29798895f, 
    0.23566525f, -0.22490278f, -0.27269292f, 0.35302678f, 0.17365013f, 0.03303881f, -0.05014792f, -0.25032517f, 
    -0.14117700f, -0.15621379f, 0.10145514f, -0.07001899f, 0.29385942f, 0.33866170f, 0.27022073f, 0.16789138f, 
    0.00753832f, 0.05462742f, 0.13946022f, 0.21690437f, -0.01322957f, -0.21746905f, -0.25247797f, -0.15159306f, 
    -0.39689851f, -0.05306978f, 0.29832035f, -0.11347146f, 0.10237830f, -0.21281059f, 0.12943397f, 0.13762625f, 
    -0.13737892f, 0.05275374f, 0.25937587f, -0.04558184f, -0.03387442f, -0.35903475f, 0.03858319f, 0.03591684f, 
    -0.24110700f, 0.01881234f, 0.31563967f, 0.35895640f, 0.04473490f, 0.20109077f, -0.04543229f, 0.28896758f, 
    -0.04190668f, 0.06706260f, -0.25528196f, 0.36838758f, -0.05899767f, 0.01977355f, -0.00774988f, -0.12462730f, 
    -0.04451909f, 0.09383019f, 0.14858362f, 0.19717602f, -0.09194626f, -0.04366022f, -0.20517072f, -0.20069142f, 
    0.04113469f, 0.20557685f, -0.14990577f, -0.03941130f, -0.02684369f, -0.14288406f, -0.04786877f, -0.18780804f, 
    -0.00201792f, -0.03918931f, -0.23160474f, -0.19315374f, 0.16201654f, 0.04455612f, 0.21266770f, -0.11180839f, 
    0.15646535f, 0.22997145f, -0.11611123f, 0.22827305f, -0.19385137f, -0.37742272f, 0.04347224f, 0.15003124f, 
    0.01125271f, 0.04249967f, 0.26611453f, 0.02876662f, 0.06145745f, 0.25390291f, 0.18759571f, 0.46548498f, 
    0.19970220f, 0.28371868f, 0.00377454f, 0.08978980f, 0.12930179f, 0.00105160f, -0.21861750f, 0.09485783f, 
    -0.04207577f, -0.09421983f, 0.08097477f, 0.03068719f, 0.14350496f, 0.18087041f, 0.06102749f, 0.09636690f, 
    0.28733626f, 0.04500366f, 0.04664344f, 0.04130111f, 0.06157487f, 0.23045191f, 0.09065002f, 0.16008927f, 
    -0.11119650f, -0.30489805f, -0.05848894f, -0.23541771f, 0.12853409f, -0.17549035f, -0.33122393f, 0.02680995f, 
    0.00067447f, 0.01703522f, 0.07557835f, 0.08415332f, -0.08671127f, -0.12802972f, 0.04515521f, 0.08480508f, 
    0.15641528f, 0.19467820f, -0.24016972f, 0.02378569f, -0.00845093f, 0.25949490f, 0.06977232f, -0.00092640f, 
    -0.07678857f, -0.28047714f, -0.42962748f, -0.30427653f, -0.05827018f, -0.11191359f, -0.01393660f, 0.05964188f, 
    -0.01828281f, 0.02246546f, 0.02113896f, 0.09704663f, 0.70361793f, 0.61716706f, 0.89271230f, 0.36525539f, 
    -0.04052531f, -0.05735405f, 0.13875771f, 0.27075306f, -0.05939348f, 0.03220234f, 0.12456716f, 0.02571893f, 
    -0.05417938f, -0.02827572f, -0.12377273f, -0.05202195f, 0.03188067f, -0.10667976f, 0.01133065f, -0.02329840f, 
    0.05518606f, 0.13391332f, 0.16679376f, 0.11235520f, 0.46726516f, 0.09005592f, 0.34562576f, 0.08907901f, 
    -0.11681444f, -0.26947477f, 0.10971161f, -0.07541370f, 0.09093273f, -0.02763299f, -0.00484049f, 0.08030899f, 
    0.15714781f, 0.12658109f, -0.09193646f, -0.45305520f, -0.02411205f, -0.15512550f, -0.15472838f, 0.01515565f, 
    0.12571763f, 0.09459822f, -0.07721039f, -0.03154925f, 0.37941244f, 0.26433736f, -0.13208267f, -0.03468671f, 
    -0.12376004f, 0.01114458f, -0.16297987f, 0.02413449f, 0.00608065f, 0.01756904f, -0.00414752f, 0.16587479f, 
    0.72393626f, -0.03509318f, -0.27288458f, 0.18908383f, 0.19894953f, 0.07202481f, 0.03553782f, -0.13069695f, 
    -0.11488064f, 0.13080812f, -0.08016075f, 0.05771917f, -0.07215755f, -0.28611466f, -0.16567245f, -0.17043196f, 
    0.00587934f, -0.13151447f, 0.03756844f, 0.00920327f, -0.01558158f, -0.08827455f, 0.27754056f, 0.12187888f, 
    0.57528013f, 0.39995095f, -0.29715022f, 0.09505957f, 0.10262657f, 0.33906257f, 0.35061932f, -0.10759688f, 
    -0.06354560f, -0.05373236f, -0.10775960f, 0.00314253f, -0.24615115f, -0.18980576f, -0.30543986f, -0.21130331f, 
    -0.09151658f, 0.04881841f, -0.04425548f, -0.05239562f, 0.01614803f, 0.10832863f, 0.15472086f, 0.06765745f, 
    -0.20891961f, -0.10475742f, -0.03908442f, -0.01310448f, -0.09068673f, 0.02830194f, 0.05018573f, -0.03158563f, 
    -0.04059252f, -0.05427561f, -0.01112338f, 0.00202680f, -0.10978949f, -0.78533709f, -0.32942954f, -0.17696103f, 
    0.06345323f, 0.00657890f, -0.00720531f, 0.08662799f, -0.20732424f, -0.10125561f, 0.03356972f, 0.10368815f, 
    0.03953861f, 0.11626648f, -0.31234816f, 0.19502206f, 0.18761708f, 0.07884269f, -0.04291776f, -0.01552137f, 
    0.19529213f, 0.10766993f, 0.01003565f, 0.00128082f, 0.00328115f, -0.27819535f, 0.18409748f, 0.10214157f, 
    -0.08899722f, 0.14228469f, 0.22122093f, 0.13300180f, 0.16866165f, -0.28490368f, -0.21594526f, -0.30347741f, 
    -0.14266542f, -0.39472547f, -0.52872920f, -0.41719759f, -0.12070268f, -0.30360812f, 0.04712502f, 0.09111805f, 
    0.07096329f, 0.20871954f, -0.23216580f, -0.32371053f, 0.13567057f, 0.12288797f, -0.24823900f, 0.28118387f, 
    0.00324772f, 0.13792923f, -0.13190085f, -0.07692386f, 0.00559178f, 0.04721964f, 0.24784729f, 0.03559894f, 
    0.28100410f, -0.09331052f, 0.16816226f, -0.17506099f, 0.13055004f, 0.01094810f, 0.11654363f, 0.13214403f, 
    -0.06097171f, 0.05824087f, -0.06776082f, 0.21693167f, -0.14180106f, 0.08391170f, 0.26159367f, 0.14746006f, 
    0.20207879f, 0.16891567f, 0.08049854f, 0.05378904f, 0.03718108f, -0.09445623f, 0.06145819f, 0.00372489f, 
    -0.11952851f, -0.02250236f, -0.29309079f, 0.07272543f, 0.30897126f, -0.16996989f, -0.05024185f, 0.07111470f, 
    0.08958426f, 0.06037153f, -0.24168824f, -0.14500289f, -0.12637438f, 0.02594181f, 0.16421463f, 0.00871900f, 
    -0.11395575f, -0.01235196f, 0.04808988f, 0.04769983f, 0.10618568f, 0.11404391f, 0.00355774f, 0.16836445f, 
    0.21996358f, -0.16466568f, 0.05344756f, 0.44052118f, -0.25859362f, -0.10359722f, 0.07941017f, 0.00852678f, 
    0.02518007f, 0.04030960f, 0.16117813f, 0.12292922f, -0.33086419f, -0.21443245f, -0.01334261f, 0.25821573f, 
    0.19090439f, 0.10027792f, 0.04938487f, 0.13795674f, 0.04426223f, -0.19986987f, -0.12816972f, -0.04980618f, 
    0.13776085f, 0.38927385f, -0.14500350f, 0.38568282f, 0.01883811f, 0.13052262f, -0.05333588f, -0.10755199f, 
    0.19105607f, 0.05706267f, 0.13591956f, 0.08667269f, -0.03372221f, 0.19449137f, -0.04179834f, -0.17339222f, 
    0.05478926f, -0.09782349f, 0.04596986f, 0.24334054f, -0.13923329f, 0.03398411f, -0.11618355f, 0.00429937f, 
    -0.24864480f, -0.05881277f, 0.26401606f, 0.14767708f, -0.02604162f, -0.12372784f, 0.00704424f, 0.01911413f, 
    -0.05915502f, 0.05145930f, 0.04809528f, 0.12698527f, -0.36568266f, -0.48809394f, -0.23338766f, 0.15965648f, 
    0.10073004f, 0.02913821f, -0.24332069f, -0.00761428f, 0.26940188f, 0.03001558f, -0.12674899f, 0.17550032f, 
    -0.16280153f, -0.34802946f, -0.13742457f, -0.02173017f, 0.28338587f, -0.32710615f, -0.23635882f, -0.36383566f, 
    0.25612280f, -0.06673195f, 0.00348238f, 0.15561406f, 0.22737546f, 0.18647738f, -0.04120182f, -0.32364762f, 
    0.08964297f, 0.09447056f, -0.03010815f, 0.13587728f, 0.23878385f, -0.08712824f, 0.10563137f, 0.01551885f, 
    0.16634129f, 0.22278345f, 0.07297582f, 0.15626770f, 0.00552525f, -0.03318002f, -0.06601782f, 0.34355044f, 
    0.03001119f, 0.08958896f, 0.13279481f, 0.00883355f, -0.00292339f, 0.01708275f, -0.00533696f, 0.00191068f, 
    -0.01657457f, -0.08810008f, 0.16542821f, 0.01697638f, -0.01815534f, -0.07883308f, 0.11098973f, 0.04745270f, 
    0.25101218f, 0.04091006f, -0.19772339f, -0.09291938f, 0.10468999f, 0.01157631f, 0.04866139f, -0.03231520f, 
    -0.00325440f, 0.06294004f, -0.04480674f, -0.05633000f, -0.03521943f, 0.15859558f, -0.02123231f, 0.32527816f, 
    0.09669071f, 0.42412183f, 0.38507766f, 0.37933934f, -0.03644883f, 0.19419102f, 0.09602144f, 0.24468705f, 
    0.18405367f, 0.07262068f, 0.18593051f, -0.16330303f, -0.04444204f, 0.00296709f, -0.12800384f, -0.03354224f, 
    -0.02977373f, -0.00472845f, -0.02592715f, 0.06958439f, 0.23153542f, -0.23944534f, -0.00039258f, 0.10789528f, 
    0.18978049f, -0.03984909f, -0.04034244f, 0.07827107f, -0.01279871f, 0.00308037f, -0.11854228f, -0.03701861f, 
    0.08999667f, -0.00480605f, -0.02930135f, 0.04436734f, 0.07458925f, -0.03628324f, -0.02451751f, -0.20880046f, 
    -0.03828994f, -0.04385846f, 0.03988375f, 0.03905027f, 0.08628991f, -0.29751951f, -0.09902219f, -0.16504475f, 
    -0.01549151f, -0.27852798f, -0.05630203f, 0.15295145f, -0.00665732f, -0.02863822f, -0.05727664f, 0.20951681f, 
    0.47701460f, 0.01589292f, 0.29330680f, 0.01924098f, 0.03340996f, 0.07874221f, -0.08918471f, -0.04266534f, 
    -0.00530120f, 0.02041286f, 0.12605746f, -0.09288638f, 0.07993151f, 0.05228050f, -0.01021952f, -0.03336190f, 
    0.12318449f, 0.07537236f, 0.23149364f, -0.02997511f, -0.02455161f, -0.06176319f, 0.02106051f, -0.05447920f, 
    -0.25605217f, -0.84570557f, -0.78111410f, 0.21155031f, 0.14020364f, 0.12325838f, 0.47314960f, 0.14408588f, 
    0.03636307f, 0.13023634f, 0.03768967f, 0.10275374f, 0.24140015f, 0.15553713f, 0.16808403f, -0.18722719f, 
    0.05726574f, 0.09878323f, -0.11825159f, -0.11926639f, 0.20796105f, 0.27691498f, 0.13844921f, -0.13322262f, 
    -0.69740206f, -0.39874437f, -0.68254769f, -0.40752518f, -0.06353237f, 0.11003277f, -0.01374396f, 0.16755272f, 
    -0.06965369f, -0.09188034f, 0.10390253f, -0.06138203f, 0.21272960f, 0.26323581f, 0.06446186f, 0.01862714f, 
    -0.00820514f, -0.04444860f, -0.07024735f, -0.03382519f, 0.01754061f, -0.10951994f, -0.00245931f, -0.06035522f, 
    0.04501865f, 0.01646059f, 0.03543280f, -0.03617128f, -0.08536293f, -0.01062770f, -0.05535865f, -0.05105503f, 
    -0.03229833f, -0.12128776f, 0.09413975f, -0.01069222f, 0.21417272f, -0.12864466f, 0.17395680f, -0.05344605f, 
    -0.10060053f, -0.05355889f, -0.00851302f, 0.04819004f, 0.17447536f, -0.04897726f, 0.13335422f, 0.00394176f, 
    0.28196141f, -0.06008752f, -0.28836140f, -0.32050335f, -0.00298847f, -0.02306519f, 0.43059152f, -0.08395029f, 
    -0.03667949f, 0.02110905f, 0.05379969f, 0.15688202f, -0.27753130f, -0.14827837f, -0.07131090f, -0.02395129f, 
    0.02611740f, -0.18755566f, 0.01844173f, 0.23990279f, -0.11348464f, 0.08397815f, -0.10294640f, -0.13166878f, 
    0.37165532f, -0.23616788f, 0.01877851f, 0.07889687f, -0.04402760f, -0.16946290f, -0.09428848f, 0.16465332f, 
    0.03299902f, -0.03276032f, 0.03752601f, -0.02742491f, 0.44619730f, 0.28408635f, -0.11419876f, -0.26735675f, 
    0.12022490f, 0.06998115f, -0.04073683f, 0.10095372f, 0.25581893f, 0.27034521f, 0.17883649f, 0.25188059f, 
    0.64768565f, -0.05127694f, -0.01240197f, 0.21256052f, 0.10359427f, -0.04825163f, 0.05556328f, -0.00646760f, 
    -0.09248939f, 0.09959399f, -0.08108364f, 0.07238118f, -0.34303224f, -0.02690334f, 0.35689664f, -0.20399922f, 
    0.09868326f, -0.09875974f, 0.03451313f, -0.11424915f, 0.02225671f, 0.00372892f, 0.00735387f, -0.09116071f, 
    0.06097975f, -0.04209052f, -0.09600488f, -0.04614532f, -0.05533344f, -0.01352738f, 0.13402264f, 0.04328651f, 
    -0.08161780f, -0.09425496f, -0.16181013f, -0.07160210f, -0.15466501f, -0.45615286f, 0.25261515f, 0.24698350f, 
    -0.06024472f, -0.24984124f, -0.13396105f, 0.14539313f, 0.03489342f, 0.04635931f, 0.14448145f, 0.08308231f, 
    -0.29760543f, -0.30275360f, -0.79402393f, 0.12271880f, -0.00009299f, 0.25789323f, 0.01756833f, 0.13046233f, 
    -0.07839401f, -0.02043108f, 0.01768842f, -0.09780867f, 0.17371361f, -0.13198259f, -0.17718862f, 0.06064069f, 
    -0.09734399f, 0.18123555f, 0.14371288f, 0.00851322f, 0.00111266f, -0.20544475f, -0.03209793f, -0.03281263f, 
    0.36053109f, 0.73325831f, 0.22554813f, -0.24783939f, -0.23864810f, -0.22151890f, 0.35028130f, -0.04257664f, 
    0.05573511f, 0.17684071f, -0.02552299f, -0.28460225f, 0.13062243f, 0.04942810f, -0.05776424f, 0.16212480f, 
    -0.01203586f, -0.01379437f, -0.00288592f, 0.00765035f, -0.16792350f, -0.17655170f, 0.24243781f, -0.14296021f, 
    -0.24538434f, -0.17315750f, 0.38198891f, 0.20996591f, -0.10034456f, 0.07095610f, 0.02208873f, -0.04070744f, 
    -0.01844177f, 0.15901579f, -0.03793840f, 0.11806964f, 0.33222535f, 0.01565953f, -0.01055954f, 0.07107444f, 
    0.06351738f, -0.07911847f, 0.01896618f, 0.08745983f, -0.05925739f, -0.08150083f, -0.15303271f, -0.15618774f, 
    0.16657186f, -0.07236968f, -0.05886511f, 0.05170299f, 0.00587143f, -0.11921223f, 0.07844540f, 0.05235224f, 
    0.11036682f, -0.15093182f, -0.16534097f, -0.05690396f, 0.81037843f, 0.09446201f, 0.30697933f, -0.05551352f, 
    0.04673214f, -0.04489579f, -0.03343375f, -0.00939979f, 0.09096316f, 0.03241478f, 0.40329173f, 0.35603064f, 
    0.40113384f, 0.20163889f, -0.15358117f, -0.18732528f, 0.04931834f, -0.19746245f, -0.03615745f, 0.15481424f, 
    -0.01990269f, -0.15461615f, 0.05216165f, 0.18022425f, -0.17814638f, 0.02426623f, -0.03782474f, 0.00909752f, 
    0.07315765f, 0.06798068f, -0.00485644f, 0.25157526f, -0.25867516f, -0.29968545f, -0.18901418f, -0.35950258f, 
    0.34305340f, -0.10463842f, 0.27125794f, 0.00656138f, -0.00597974f, 0.31246892f, -0.13608505f, 0.30589217f, 
    -0.03708623f, -0.13877726f, 0.04998767f, -0.08518130f, 0.28064883f, -0.14885873f, 0.20200476f, -0.26575381f, 
    0.25645921f, -0.03225253f, -0.01632963f, -0.13559817f, 0.13749978f, 0.09622728f, 0.07656004f, 0.17549214f, 
    0.00373053f, 0.18330222f, -0.17929743f, 0.68081886f, -0.00338050f, 0.11431924f, -0.00797508f, 0.20867074f, 
    -0.22778493f, 0.01745386f, -0.10836485f, -0.07615867f, 0.15779164f, 0.29247501f, 0.31106448f, -0.20449944f, 
    -0.07394631f, -0.07995282f, -0.03474430f, 0.06510493f, 0.03067950f, -0.02851088f, -0.02871077f, -0.05585166f, 
    0.09613103f, -0.19046678f, 0.07283210f, 0.05002737f, -0.04460185f, 0.03660493f, 0.10258192f, 0.01611108f, 
    -0.14158136f, -0.09623916f, -0.15126862f, -0.13069846f, 0.17948072f, -0.19960295f, 0.01220862f, -0.07055537f, 
    -0.12585232f, -0.00441592f, -0.08089203f, -0.11741346f, 0.04239808f, 0.08622757f, 0.10965047f, 0.15762727f, 
    -0.60613966f, -0.05993151f, 0.03444925f, 0.20011382f, -0.08525102f, 0.16918093f, 0.04988682f, 0.13128825f, 
    -0.00903246f, -0.08340184f, -0.02863006f, 0.10083707f, 0.11898395f, 0.25848079f, -0.12129579f, 0.03674895f, 
    0.17261924f, 0.24576581f, 0.17811964f, -0.06983456f, -0.19839965f, -0.04483787f, -0.03490301f, -0.00858417f, 
    0.12244199f, 0.11599209f, 0.09356543f, -0.45670155f, -0.02607425f, -0.28633794f, -0.09568664f, 0.15514342f, 
    -0.05674138f, -0.00344121f, 0.00850424f, -0.29217866f, -0.07890378f, 0.00875307f, -0.07484861f, 0.41263422f, 
    -0.00125501f, -0.07683517f, 0.15557729f, 0.03173582f, 0.13638014f, 0.01848949f, -0.01500132f, 0.22181040f, 
    0.00083137f, 0.26034099f, 0.06702920f, 0.02677627f, -0.01824804f, -0.24202481f, 0.14562050f, -0.18444696f, 
    -0.04483629f, 0.10711497f, 0.05644056f, -0.07071499f, 0.23125392f, 0.09150704f, -0.04474135f, -0.00762352f, 
    0.12204953f, 0.07933767f, -0.04133593f, 0.03565548f, -0.10475589f, 0.13891853f, 0.00682767f, 0.00799032f, 
    0.18544458f, 0.06858663f, -0.02537211f, 0.14328392f, -0.01563398f, -0.00562523f, 0.01078845f, 0.12523220f, 
    -0.12071253f, -0.06267401f, -0.14369121f, -0.11107071f, 0.34757227f, -0.03300502f, -0.19344053f, 0.12132552f, 
    -0.07491469f, 0.07120922f, -0.10707591f, 0.19244394f, -0.09906683f, 0.12273973f, 0.10604644f, 0.45607525f, 
    0.27764910f, 0.37160552f, -0.45938635f, 0.26815936f, -0.02670006f, -0.08517420f, -0.05418993f, -0.08537711f, 
    0.12262279f, 0.07429040f, 0.01602821f, -0.00361266f, 0.11890451f, 0.22709399f, 0.13998030f, 0.04081942f, 
    -0.00181302f, 0.06837510f, 0.21372679f, -0.00048741f, -0.23157190f, -0.20470120f, 0.12346117f, 0.08204471f, 
    -0.50354779f, 0.36384413f, -0.33057410f, -0.19756068f, -0.06675590f, 0.29001030f, 0.01243544f, -0.23407459f, 
    0.14874665f, 0.04032760f, -0.06214054f, 0.02558298f, 0.09804066f, 0.14613892f, 0.07215249f, 0.05258200f, 
    -0.02558256f, -0.07743780f, 0.22980818f, 0.05633678f, -0.25359997f, 0.01356279f, -0.21301688f, 0.19547141f, 
    -0.25186050f, -0.05510151f, -0.18125089f, -0.00945221f, 0.09864964f, 0.04816638f, 0.03670503f, 0.05132159f, 
    -0.00256365f, -0.10759955f, 0.07550712f, -0.14161253f, 0.23543593f, 0.33151054f, 0.04817145f, 0.52542526f, 
    -0.14897372f, -0.18232188f, 0.19180050f, 0.40533826f, -0.05538496f, 0.14008172f, -0.08314856f, 0.10505398f, 
    -0.06799915f, -0.12241269f, 0.01859497f, 0.00996766f, -0.17946698f, 0.11474403f, 0.10593273f, -0.04034808f, 
    -0.00721857f, -0.07433531f, -0.02289811f, -0.12428431f, 0.08653090f, 0.12275973f, -0.33355299f, 0.24803562f, 
    0.09881134f, 0.20050465f, 0.10883334f, -0.05376669f, -0.04319543f, 0.09269799f, -0.00384055f, -0.01601427f, 
    -0.61088866f, 0.05860642f, 0.34960458f, 0.02172999f, -0.17953883f, 0.06327145f, 0.13781987f, -0.09363020f, 
    -0.02349881f, -0.16750136f, 0.02012457f, -0.10246865f, -0.17046393f, 0.08759072f, 0.06204291f, 0.11967355f, 
    0.06708876f, 0.18713371f, 0.25932956f, 0.12562506f, -0.12973543f, 0.03852018f, -0.06492843f, 0.00553852f, 
    -0.18866381f, -0.19707985f, 0.22148368f, -0.16328411f, 0.05038223f, 0.07814430f, 0.10754250f, 0.29106799f, 
    -0.00111010f, -0.15672198f, -0.09800265f, 0.07978694f, -0.02299041f, -0.05347143f, 0.06604204f, 0.10430042f, 
    -0.13073441f, 0.14999957f, -0.13607523f, -0.08041697f, 0.48358431f, 0.18456364f, -0.24979487f, -0.00115701f, 
    0.67990458f, 0.01535072f, 0.12008468f, 0.08070807f, -0.04800831f, -0.39410222f, -0.20998231f, -0.05666726f, 
    -0.08781081f, -0.06040185f, 0.10415574f, -0.02703603f, -0.01102482f, -0.10001283f, 0.01511648f, -0.12497816f, 
    0.04115935f, -0.04446876f, 0.11374836f, -0.09976862f, -0.04423102f, 0.07873770f, -0.02021319f, -0.07789527f, 
    0.08719596f, 0.06050791f, -0.10475770f, -0.16789423f, -0.00819505f, 0.10006719f, -0.00823185f, -0.07244359f, 
    -0.07679397f, -0.10407761f, 0.03199143f, -0.02873796f, 0.23112783f, 0.27373457f, 0.08048061f, 0.13386492f, 
    -0.07483783f, -0.07890388f, -0.00032091f, 0.27864712f, -0.16184723f, 0.10414575f, 0.06515457f, 0.06120868f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19995616f, 0.18369009f, -0.10896066f, 0.25228491f, 0.24284539f, -0.02920688f, 0.01689022f, 0.13315830f, 
    -0.22520140f, -0.01086525f, -0.07038265f, 0.01978632f, 0.00558063f, -0.01471123f, 0.24063152f, 0.30595708f, 
    0.04179084f, 0.06019424f, 0.14847161f, -0.03081471f, 0.23193404f, 0.02751980f, 0.11150238f, 0.01141209f, 
    -0.06547800f, -0.14569998f, -0.11793919f, 0.16246758f, -0.07194258f, 0.22028214f, 0.07641351f, -0.09045672f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09473592f, -0.61496806f, 0.48822266f, -0.68217546f, 0.00146276f, -0.12614864f, 0.25608894f, -0.29665878f, 
    0.36795270f, 0.00365319f, 0.15721077f, 0.14813489f, -0.18183739f, 0.04194350f, -0.41548923f, -0.83232409f, 
    0.02890742f, -0.19952343f, 0.22832459f, 0.03317269f, -0.19113019f, 0.25710753f, -0.13383004f, 0.33848718f, 
    -0.03509822f, -0.02662763f, 0.25608349f, -0.28930500f, -0.23422180f, -0.37426203f, 0.10095862f, 0.13062154f, 
    -0.04742901f, 0.37311947f, -0.87806362f, -0.21913369f, 0.26262516f, -0.08852179f, 0.09866419f, -0.79499626f, 
    0.04676836f, -0.27466500f, 0.16370273f, 0.14802906f, 0.13912220f, -0.01222678f, -0.29538450f, -0.15914516f, 
    -0.15846322f, -0.25532824f, 0.47392958f, -0.03701081f, 0.19918558f, 0.46091491f, -0.20184796f, -0.22052775f, 
    0.08009847f, -0.87428921f, 0.26305342f, -0.19477072f, 0.05451657f, 0.19500841f, 0.23502840f, -0.05101569f, 
    -0.01091077f, -0.14396288f, -0.22033165f, 0.00926350f, -0.36929008f, 0.03289910f, 0.11512410f, -0.23747787f, 
    -0.54283988f, 0.66946524f, 0.09602854f, 0.08924243f, 0.44569626f, -0.07690040f, 0.01292270f, -0.10446196f, 
    0.11751230f, 0.72944492f, 0.24187452f, 0.07758649f, 0.03297788f, 0.24681477f, 0.17486688f, -0.34091434f, 
    0.06303556f, -0.32044023f, -0.42518058f, -0.02590074f, -0.73935241f, 0.13382185f, -0.05849865f, -0.35551411f, 
    0.16821818f, -0.12999618f, -0.06842913f, -0.08981752f, -0.04031733f, 0.03646847f, -0.24193180f, 0.01802971f, 
    0.60571450f, 0.52676314f, 0.20162311f, 0.10742336f, 0.17575781f, 0.12894492f, 0.24504711f, -0.50601161f, 
    -0.33769745f, 0.52183861f, -0.48560101f, 0.14673725f, -0.47724128f, -0.25158548f, 0.01826828f, -0.23133034f, 
    -0.02095245f, 0.08601771f, 0.15573625f, 0.07366025f, -0.06419422f, -0.32464823f, -0.41517523f, 0.02563195f, 
    0.06711923f, -0.34877190f, 0.32306260f, -0.01341309f, -0.31894404f, 0.07973357f, -0.09086517f, 0.16587800f, 
    -0.34715664f, -0.94515145f, -0.12392709f, -0.14110847f, 0.02248782f, -0.11264294f, -0.28148371f, -0.33421692f, 
    0.32690498f, -0.02874841f, -0.47500515f, -0.02949830f, 0.10418158f, 0.06852002f, 0.09298705f, -0.16723990f, 
    -0.10215588f, 0.49497610f, 0.13267727f, 0.36536098f, -0.07944289f, -0.01525305f, 0.24399133f, 0.28191245f, 
    0.29213852f, -0.16085334f, 0.00278813f, 0.36566520f, 0.06650923f, 0.11473095f, -0.05895218f, -0.07642221f, 
    0.06791866f, -0.92415762f, -0.18659033f, -0.09057636f, -0.19267516f, 0.10745000f, -0.14358519f, 0.20029843f, 
    0.29292658f, -1.12356722f, -0.12735237f, -0.02348061f, -0.51502144f, 0.10438698f, 0.35419279f, 0.50711948f, 
    -0.07076980f, -0.52948964f, 0.10122934f, 0.26184437f, 0.06268602f, -0.03331520f, -0.03723309f, -0.38849142f, 
    -0.14584148f, -0.25419727f, -0.69238371f, -0.64921910f, 0.02627928f, -0.00160917f, -0.04644204f, 0.28243437f, 
    -0.66259259f, 0.27376896f, -0.33767295f, -0.01700630f, -0.28942132f, -0.08151358f, 0.31788674f, 0.21734095f, 
    -0.11755279f, 0.30775157f, 0.02478752f, -0.13020244f, -0.00216780f, -1.41566205f, 0.00127258f, -0.56173837f, 
    -0.03680119f, -0.08774652f, -0.82070345f, 0.38717157f, -0.05458215f, 0.43264878f, 0.21036638f, -0.34016168f, 
    -0.26420066f, -0.15104075f, 0.79732698f, -0.05183533f, -0.36944503f, 0.06132956f, -0.02246722f, -0.67459130f, 
    0.38875157f, -0.04706142f, -0.02075217f, 0.00517487f, -0.35514876f, 0.08751936f, -0.03273065f, 0.18342766f, 
    0.04628042f, 0.25037882f, -0.27538553f, -0.02942067f, 0.28299248f, -0.58876127f, -0.06528007f, -0.08536915f, 
    0.03502540f, 0.36134455f, -0.50261116f, 0.01344996f, 0.30715454f, -0.08204435f, -0.36136666f, 0.20209455f, 
    0.35619152f, 0.14606281f, -0.40473774f, 0.53157145f, -0.00845625f, -0.03735694f, -0.22494039f, -0.67193598f, 
    -0.21681218f, 0.23282377f, 0.04236291f, -0.10246284f, -0.74808699f, -0.17608927f, 0.44036692f, -0.20891856f, 
    -0.40448922f, -0.15003270f, 0.20243688f, 0.10860454f, 0.00912623f, -1.14841378f, -0.25942868f, 0.20280996f, 
    0.03095929f, -0.42268777f, 0.06231054f, -0.21197362f, 0.05891979f, -0.14345074f, -0.57584333f, -0.26155171f, 
    -0.29112092f, 0.14202371f, 0.23323704f, -0.17575690f, 0.20824631f, -0.05475497f, 0.58308846f, 0.23066628f, 
    -0.75376946f, -0.35330445f, -0.68486005f, 0.14068592f, -0.73070461f, -0.12349806f, -0.00977388f, 0.07933258f, 
    -0.44285592f, -0.02502097f, -0.32233530f, -0.12444162f, -0.01713124f, 0.52754861f, 0.20727134f, -0.31578499f, 
    -0.02153547f, 0.46924773f, -0.12566568f, -0.32180169f, -0.18026333f, 0.17307952f, 0.03559062f, 0.14294426f, 
    0.13998927f, 0.18416862f, -0.58119744f, 0.24821253f, 0.17615588f, 0.03410869f, -0.64995199f, 0.08483922f, 
    -0.39888176f, -0.02057458f, -0.24586524f, -0.14159267f, 0.61388087f, -0.15080853f, 0.38994092f, -0.33790103f, 
    -0.44273856f, -0.84544688f, 0.12581082f, -0.11093452f, -0.58346891f, -0.38364735f, 0.34384000f, 0.15356906f, 
    -0.17119326f, -1.17810667f, -0.36482710f, -0.20553021f, -0.31117806f, -0.39974940f, -0.07385799f, 0.79576200f, 
    0.12640418f, 0.25812560f, -0.61844051f, 0.15599449f, -0.28965858f, -0.13191490f, -0.55596757f, 0.56560296f, 
    0.27135414f, 0.63733488f, 0.04098941f, -0.06482878f, -0.39935145f, 0.12465229f, -0.22524706f, 0.00268037f, 
    0.06856336f, -0.41676801f, 0.29841179f, 0.00284857f, -0.15585205f, -0.26196817f, -0.83231848f, -0.02507646f, 
    0.13988735f, 0.36939502f, -0.12977841f, -0.77868146f, -0.00923902f, 0.04267092f, 0.56699115f, -0.18190949f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07404602f, -0.03311603f, 0.18204108f, -0.13237529f, -0.07615666f, -0.00422419f, 0.19011395f, -0.34384653f, 
    0.04238016f, 0.13503754f, 0.05485879f, 0.01417096f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
