#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94733053f, -0.79256642f, -0.39452764f, -0.54682195f, -0.53197914f, 0.45171839f, 0.00940461f, 0.51193857f, 
    0.32271945f, -0.62168974f, -0.65678114f, 0.18000162f, -0.57252032f, -0.74418932f, 0.05182567f, -0.34516168f, 
    -0.11668741f, -0.52495575f, -0.89943522f, 0.82366103f, 0.55976278f, 0.02300433f, 0.70746487f, 0.51963186f, 
    -0.17838144f, 0.32104549f, 0.23602407f, -0.67898256f, -0.16444848f, 0.00261066f, 0.92729372f, 0.82046247f, 
    0.37147015f, 0.47401327f, -0.31629807f, -0.37055930f, 0.69479001f, 0.91169316f, 0.67583317f, 0.60244107f, 
    -0.83785033f, -0.07314626f, -0.28285897f, -0.15270920f, 0.01338380f, 0.31527418f, 0.24858092f, 0.01434507f, 
    -0.38070107f, -0.79693305f, 0.06116514f, 0.57470375f, 0.33010650f, 0.70202547f, -0.09959897f, 0.23853651f, 
    -0.56208056f, 0.83246130f, -0.38408831f, -0.51081103f, -0.27676246f, 0.20572381f, 0.43718278f, -0.04105988f, 
    -0.61722636f, -0.42557269f, -0.31756854f, 0.82703197f, -0.54583508f, -0.25525770f, -0.28693461f, -0.52831286f, 
    -0.02635336f, 0.39388448f, 0.44570443f, 0.25425038f, 0.29531983f, 0.85911626f, 0.21893686f, -0.71324068f, 
    -0.03417655f, -1.02164459f, -0.58591002f, -0.80310732f, 0.18427794f, 0.88652867f, 0.47597140f, 0.01043679f, 
    -0.38901368f, 0.04709865f, 0.00271108f, 0.31885150f, 0.14720501f, -0.72627872f, -1.00907671f, -0.77638853f, 
    -0.53758031f, 0.30821350f, 0.08020777f, 1.11135197f, 0.12518063f, -0.51268244f, -0.34304869f, 0.57849669f, 
    0.46266118f, -0.32563713f, -0.21135759f, 0.30979574f, 0.53426087f, 0.72418773f, 0.76944405f, -0.62694460f, 
    0.64512670f, 0.00844923f, -0.21690062f, -0.08541375f, -0.20227468f, 0.86921573f, 0.60009784f, 0.75025159f, 
    0.18050103f, -0.09877782f, -0.45089045f, 0.29993027f, 0.20079650f, 0.34278107f, 0.83756483f, 0.86670500f, 
    -0.56430852f, 0.27015871f, -0.06868935f, -0.38499975f, 0.61434186f, 0.54215300f, -0.22110948f, 0.84253126f, 
    -0.97012269f, -0.07542356f, 0.58061588f, -0.36815628f, 0.24247625f, 0.44688797f, -0.34041736f, 0.14302078f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15106702f, 0.19687977f, -0.16455010f, -0.11274514f, 0.39750198f, -0.31400782f, -0.25583091f, -0.00754818f, 
    0.39831761f, 0.17346482f, 0.54057938f, 0.39230061f, 0.38100922f, 0.03410894f, -0.51785940f, -0.02892390f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05268155f, 0.01849082f, -0.02775092f, -0.01262835f, 0.02908311f, 0.07552897f, -0.05710065f, -0.02485877f, 
    -0.06429693f, -0.06607942f, 0.07138151f, -0.04193790f, -0.05080664f, 0.03581775f, -0.06219756f, 0.02029861f, 
    -0.06245505f, 0.03343119f, -0.07894365f, -0.00991913f, -0.08180311f, -0.03612789f, -0.06945072f, -0.03072022f, 
    -0.07769211f, -0.02212076f, -0.03547316f, -0.03478457f, 0.02698598f, -0.01309558f, -0.05213730f, 0.07339825f, 
    -0.07138483f, 0.05460973f, 0.02008659f, 0.04070367f, -0.03930200f, -0.05278426f, 0.02967621f, 0.03556601f, 
    -0.00939352f, 0.05184748f, 0.02498254f, -0.01393449f, 0.05572303f, 0.01310347f, 0.04199180f, 0.00078710f, 
    0.02088610f, -0.04528027f, 0.04268074f, 0.01169207f, 0.08293387f, -0.03760534f, -0.06792502f, -0.02146134f, 
    0.00527538f, 0.01862749f, -0.05374716f, -0.07575735f, 0.08036005f, -0.06012247f, 0.01813085f, 0.02718779f, 
    -0.01767149f, -0.00241360f, -0.02128074f, -0.04823374f, -0.03070363f, -0.01585885f, -0.08117364f, -0.00196903f, 
    0.08057370f, 0.01905086f, 0.05114944f, 0.04415287f, -0.01362285f, -0.03844106f, -0.04920437f, 0.03220230f, 
    -0.04132910f, -0.05803829f, -0.04550429f, 0.07230857f, -0.04654897f, -0.06160466f, 0.05028012f, -0.07368147f, 
    -0.05248510f, 0.06241896f, -0.05190781f, -0.07890054f, 0.08007827f, 0.07071161f, 0.05330672f, -0.06969162f, 
    -0.06946921f, -0.02272119f, -0.03212152f, -0.07292758f, 0.02933793f, -0.05255628f, 0.06354599f, -0.04935125f, 
    -0.01483134f, 0.04947756f, -0.01616612f, 0.05713628f, -0.05442812f, -0.06812014f, 0.02830878f, 0.08053406f, 
    -0.03589491f, 0.01617136f, -0.05454243f, 0.04869165f, -0.02175959f, 0.04058190f, 0.07864349f, -0.05299965f, 
    -0.04566957f, 0.05124570f, -0.02301338f, -0.06747842f, -0.03149803f, -0.02013936f, 0.06346267f, 0.02417792f, 
    -0.07928851f, -0.01838714f, -0.04309990f, -0.04737261f, -0.03713175f, -0.06284766f, -0.05887987f, -0.01371234f, 
    -0.03125646f, 0.02950610f, -0.01617137f, 0.05145150f, 0.00326582f, -0.04343275f, -0.06533952f, -0.07975765f, 
    -0.48321933f, -0.54363006f, 0.24615395f, 0.25281671f, -0.02452327f, -0.01974102f, 0.13042134f, -0.20915665f, 
    0.03813172f, -0.01515850f, -0.20752713f, -0.23233528f, 0.04256668f, 0.16246928f, 0.01347888f, 0.01456083f, 
    0.29538792f, 0.04761076f, -0.68997753f, 0.05033357f, -0.10522326f, 0.07251782f, 0.02152322f, 0.04450788f, 
    -0.00328814f, -0.06182874f, 0.07350867f, -0.06879476f, -0.29387894f, 0.12265299f, -0.08645647f, -0.07566734f, 
    0.23882471f, -0.07788651f, 0.01642438f, -0.02266795f, -0.08017822f, 0.17467520f, -0.21535604f, 0.12014990f, 
    0.04584859f, 0.06191073f, 0.00114690f, 0.05935588f, 0.01378212f, 0.13774686f, -0.05220645f, -0.31350479f, 
    0.05530932f, -0.04120559f, 0.13723782f, 0.12484080f, -0.02513910f, -0.06585726f, 0.07202017f, -0.00404073f, 
    -0.12759079f, 0.01126135f, -0.05538658f, 0.01693703f, -0.11086861f, -0.03222016f, -0.05533086f, -0.22993058f, 
    -0.27928925f, -0.07517985f, -0.02079927f, 0.03533739f, 0.15519382f, -0.04833223f, -0.02769027f, 0.15079390f, 
    0.10427221f, -0.00246824f, -0.17076033f, -0.02920909f, 0.00295340f, 0.01108252f, 0.10743913f, 0.04116167f, 
    0.11770879f, -0.33374223f, -0.41461220f, 0.52881414f, 0.03912986f, 0.03334191f, 0.18644962f, -0.24679202f, 
    0.13375573f, 0.03254597f, -0.06613091f, 0.20144415f, -0.39788979f, 0.03229415f, 0.06466965f, -0.16245036f, 
    -0.06690893f, 0.09178668f, 0.05204700f, 0.38840857f, -0.25894475f, 0.35108152f, 0.02168861f, 0.01799623f, 
    -0.02881456f, -0.02020614f, -0.16609880f, 0.11930558f, -0.35072327f, 0.14467391f, -0.13167569f, 0.14678481f, 
    -0.04588088f, -0.10973448f, 0.04002001f, 0.14705169f, -0.04289493f, 0.24481827f, 0.30969694f, -0.09761363f, 
    0.00733327f, 0.06768114f, -0.07019231f, 0.09475712f, -0.13162225f, -0.07840334f, 0.34117070f, 0.18094470f, 
    -0.36897177f, -0.17475437f, -0.16065258f, -0.09628917f, -0.01887431f, 0.19108962f, -0.03041275f, -0.01828148f, 
    -0.23957449f, 0.36168149f, -0.12179352f, 0.14061750f, 0.06401236f, -0.10161292f, -0.01922038f, 0.05622031f, 
    -0.31163645f, -0.09300206f, -0.17850600f, 0.29542345f, 0.28304762f, 0.03111990f, -0.01602638f, -0.15515669f, 
    -0.13123991f, 0.01338447f, 0.15173195f, 0.02633931f, 0.19136958f, 0.04415578f, 0.14160959f, 0.09231623f, 
    -0.09275866f, -0.21456620f, -0.03142220f, -0.50991255f, 0.08510786f, -0.03071279f, -0.05198598f, -0.27253687f, 
    0.00442279f, 0.00890547f, 0.02952532f, 0.08062357f, -0.13902636f, 0.15169555f, -0.08203609f, -0.28768399f, 
    -0.28384185f, 0.11616651f, 0.05224717f, -0.03871707f, -0.29376462f, 0.24777515f, 0.04378707f, -0.01979721f, 
    -0.01163047f, -0.01787787f, -0.09027993f, 0.15536164f, 0.05148385f, 0.08682030f, 0.24798293f, -0.17774186f, 
    0.08809853f, -0.28386009f, 0.04793964f, 0.02786534f, 0.11151053f, 0.48493898f, -0.43338561f, 0.28168458f, 
    -0.30638263f, 0.29117942f, 0.04423218f, 0.13311203f, 0.26444998f, 0.07899282f, -0.07955068f, 0.02597040f, 
    -0.00522653f, -0.52837932f, 0.18424211f, 0.09609944f, 0.15022027f, -0.01545010f, -0.34048092f, -0.11472825f, 
    0.21665876f, 0.12264429f, 0.14103091f, 0.00026054f, -0.11672178f, 0.07094712f, 0.28561735f, 0.10934354f, 
    0.07411965f, -0.03856656f, 0.06571899f, 0.00299786f, 0.02274118f, 0.02400245f, -0.05617144f, 0.00827538f, 
    -0.25371057f, -0.28464857f, 0.06408107f, -0.01132699f, -0.32505715f, 0.11130605f, 0.08536387f, 0.39346021f, 
    -0.18220820f, 0.11468462f, -0.07778638f, -0.23190992f, -0.31268278f, 0.04775989f, 0.25946173f, -0.25681758f, 
    -0.03852978f, -0.09358424f, -0.09650344f, 0.07452083f, -0.03264809f, -0.00665351f, -0.02593403f, 0.05076743f, 
    0.05796165f, -0.04735885f, -0.07523715f, 0.11544418f, 0.14579339f, 0.07718593f, 0.26528478f, -0.13868807f, 
    0.15880498f, -0.01882479f, 0.10074961f, 0.01237442f, -0.02510892f, -0.07475504f, 0.32348543f, 0.15469822f, 
    0.01758284f, 0.25798851f, 0.03860083f, -0.06214561f, -0.12530354f, -0.41784084f, 0.34760964f, -0.05353061f, 
    -0.01729860f, 0.12014734f, 0.04624034f, 0.14089546f, 0.01757337f, 0.24222931f, 0.05252293f, 0.08235489f, 
    0.06388213f, -0.07712285f, 0.02835666f, -0.03984362f, 0.04204842f, 0.06183692f, -0.07735944f, 0.03205013f, 
    0.01836859f, 0.04365930f, -0.02766827f, 0.00112694f, -0.09915318f, -0.06956366f, 0.00134142f, -0.06616215f, 
    0.03491161f, -0.00144877f, 0.05363367f, -0.09110431f, 0.05171155f, 0.03682836f, 0.01089785f, 0.01941236f, 
    0.00081636f, -0.06071058f, -0.12657320f, 0.00263790f, -0.00781211f, -0.06074955f, 0.03042332f, -0.05748044f, 
    0.00503646f, 0.03743289f, -0.07772253f, 0.04074074f, -0.03352290f, 0.03473610f, -0.04061537f, -0.00235565f, 
    0.03238535f, -0.00639752f, 0.01121189f, -0.05273807f, 0.07568717f, -0.06074887f, 0.07528306f, 0.03836317f, 
    0.04248666f, -0.10383073f, -0.04543120f, -0.08467939f, 0.02917354f, -0.00907417f, 0.04921278f, -0.03597630f, 
    -0.06745926f, -0.08392013f, 0.00304935f, 0.03352058f, 0.00426236f, -0.07477335f, 0.00185673f, -0.06767669f, 
    0.00761964f, 0.05199450f, 0.00953579f, -0.04608417f, -0.00425008f, 0.07495859f, 0.02164194f, -0.06683622f, 
    0.00073231f, 0.01391863f, -0.01040417f, 0.04444600f, 0.04162421f, -0.08978137f, 0.06282560f, -0.08572354f, 
    -0.00280210f, -0.03016154f, -0.01842374f, 0.06608257f, -0.08051059f, -0.06385250f, 0.06173402f, 0.04192034f, 
    -0.05392611f, -0.08371645f, 0.05720445f, -0.05938068f, -0.00233809f, 0.02338979f, 0.02064464f, -0.06425004f, 
    0.04549485f, 0.00241203f, -0.08836579f, -0.03506865f, -0.08232389f, -0.04188171f, -0.00265666f, -0.05179334f, 
    0.03305602f, -0.05309284f, -0.03241952f, -0.02808267f, 0.05872690f, 0.04571505f, -0.06836118f, -0.03957467f, 
    -0.07595576f, -0.09376501f, 0.04192879f, 0.00666316f, 0.02940751f, 0.02575340f, -0.03963047f, 0.00052197f, 
    -0.04072855f, -0.06988550f, -0.09479723f, 0.06945823f, 0.00522972f, -0.06493651f, -0.03221144f, 0.04998924f, 
    0.08332866f, -0.02109028f, -0.00236890f, -0.06357086f, -0.00056546f, 0.01613152f, 0.00899363f, -0.08076589f, 
    -0.05387977f, 0.00277919f, -0.04800446f, -0.08302590f, -0.05420256f, 0.07588863f, 0.05937953f, -0.10306265f, 
    -0.07413963f, 0.00683661f, 0.01702283f, 0.07631360f, -0.00159852f, -0.03231743f, -0.03961047f, -0.02932068f, 
    0.05761001f, 0.01915779f, -0.02005313f, -0.07762082f, -0.06640176f, 0.03498048f, -0.06704419f, -0.04699520f, 
    0.00528527f, -0.04476520f, 0.02120562f, -0.00654202f, -0.02416653f, -0.08385637f, -0.07438056f, -0.05020543f, 
    -0.09249487f, 0.05181241f, -0.02238894f, -0.08173292f, -0.06242659f, -0.06561203f, 0.05766820f, -0.03270435f, 
    -0.04488191f, 0.00841558f, -0.05795652f, -0.05172985f, 0.03740826f, 0.04849170f, -0.02371365f, 0.05524472f, 
    -0.07581585f, 0.04021430f, -0.03805924f, 0.06756728f, 0.06597956f, 0.02393686f, -0.05161078f, -0.02165966f, 
    -0.05207224f, 0.02712003f, -0.02260895f, -0.04335152f, -0.04632159f, 0.00290005f, 0.01587395f, -0.01952306f, 
    -0.01765173f, -0.06446579f, -0.06153222f, -0.03958211f, 0.00559956f, -0.05780777f, -0.03606698f, -0.07870577f, 
    0.03053121f, 0.03556192f, -0.08421775f, 0.00866967f, 0.01095004f, 0.06136059f, 0.02170424f, -0.05229482f, 
    -0.03107724f, -0.02485093f, 0.02591848f, -0.07259787f, 0.02412479f, -0.07675263f, -0.00103753f, -0.04825428f, 
    -0.08592621f, 0.07135644f, -0.01541971f, -0.08484519f, 0.01445028f, -0.08107151f, 0.02299034f, 0.04840569f, 
    0.00780225f, 0.04201111f, 0.01935317f, -0.02550807f, -0.02141129f, -0.08841060f, -0.08473343f, -0.02636833f, 
    0.00096570f, 0.05039348f, 0.02841689f, -0.09338392f, -0.01823929f, 0.03358238f, -0.01305051f, 0.03619614f, 
    -0.03876732f, -0.06804662f, -0.00851860f, 0.03478410f, -0.02329238f, 0.06193146f, -0.05796617f, -0.08050618f, 
    -0.02925547f, -0.05594487f, -0.07925889f, -0.06138753f, -0.04037480f, 0.05582444f, 0.06710431f, 0.00136406f, 
    -0.09708514f, -0.06309177f, -0.06540927f, -0.08209002f, -0.00428323f, 0.05938701f, -0.02265047f, -0.03986850f, 
    -0.01177041f, 0.00420619f, 0.01028366f, -0.08498266f, 0.01193377f, 0.02874402f, -0.02732651f, -0.06434495f, 
    0.05183002f, -0.01834835f, 0.04025682f, -0.03555126f, 0.06785062f, 0.02041056f, -0.04371728f, -0.03369983f, 
    -0.11722600f, -0.27963749f, -0.26708359f, 0.10838011f, 0.04513061f, 0.03079740f, -0.11254267f, -0.14910072f, 
    -0.02316770f, -0.23977092f, -0.03637392f, -0.00842887f, -0.15877974f, 0.06404763f, -0.09529792f, 0.03576211f, 
    0.07227501f, -0.01517129f, 0.45650744f, -0.02431991f, -0.06239011f, -0.26844245f, 0.17005257f, 0.06568440f, 
    -0.24028654f, 0.07492415f, -0.22052427f, 0.11504897f, -0.08165838f, -0.17736240f, -0.01140840f, 0.27728096f, 
    -0.01462838f, 0.08711009f, 0.01608675f, -0.12716146f, 0.00388633f, 0.23060517f, 0.54532212f, -0.25993726f, 
    0.10329477f, -0.05351096f, 0.03230407f, 0.09466744f, -0.03244832f, -0.09717382f, -0.01704847f, -0.30295414f, 
    0.00763079f, -0.03517867f, 0.03136672f, -0.09067847f, -0.05497593f, -0.14218327f, -0.17081970f, -0.30163574f, 
    0.00250089f, 0.11647031f, -0.01430383f, 0.02119275f, 0.07705987f, 0.05182481f, -0.08944401f, 0.14060281f, 
    -0.11070205f, -0.14753087f, 0.11694948f, 0.06807116f, 0.15789431f, 0.08338065f, 0.17086977f, 0.25220296f, 
    -0.21893495f, -0.20486656f, 0.04289331f, 0.01646683f, 0.08303243f, 0.30627191f, 0.28330651f, 0.12253211f, 
    -0.13525392f, 0.41236520f, -0.26950517f, -0.39137122f, 0.19599420f, 0.11505759f, 0.18551791f, -0.08914867f, 
    -0.15266091f, -0.08967295f, 0.05416980f, 0.21007371f, 0.27782393f, -0.16079786f, 0.07336786f, -0.04807587f, 
    0.05302011f, 0.11565300f, 0.25673211f, -0.06177131f, -0.35199356f, 0.22765407f, 0.00468459f, -0.05090074f, 
    -0.18546014f, -0.10926311f, 0.04625378f, 0.03354750f, -0.05384157f, 0.30787879f, 0.35828826f, 0.00413158f, 
    0.06349231f, 0.08023670f, 0.03462250f, -0.04497190f, 0.07523159f, -0.10178673f, -0.02646127f, 0.28881446f, 
    -0.43512946f, -0.03740482f, 0.07152396f, -0.05031874f, -0.00369826f, 0.03483446f, 0.34075543f, 0.17638099f, 
    -0.10398468f, -0.33759430f, -0.15921324f, -0.27915838f, -0.14297561f, 0.10508226f, -0.12043194f, 0.17445019f, 
    0.02314101f, -0.19988942f, -0.00938379f, 0.09238527f, 0.03533978f, -0.27165088f, 0.00942289f, -0.10103081f, 
    -0.39209607f, -0.00259556f, -0.22933757f, 0.18955581f, 0.15332080f, 0.07318259f, 0.07635623f, 0.09507664f, 
    -0.02183389f, 0.00087168f, -0.16777377f, -0.11898583f, -0.04907893f, 0.03435495f, 0.10696211f, 0.21628948f, 
    0.13581105f, -0.01496650f, -0.13879932f, -0.19688968f, 0.16357863f, 0.03856459f, 0.21923965f, -0.01904051f, 
    0.17504521f, -0.05468145f, 0.03975292f, -0.03985947f, 0.36607400f, -0.16116296f, 0.10841921f, 0.02463537f, 
    -0.00720761f, 0.06389417f, -0.03097760f, -0.06841715f, -0.26803532f, 0.05715275f, 0.39159870f, 0.07078183f, 
    0.13105708f, 0.16299528f, 0.17110167f, -0.06624009f, 0.19573034f, 0.02791193f, -0.06300721f, -0.28260422f, 
    0.02071267f, -0.01340934f, -0.04929104f, 0.02766452f, -0.01651779f, 0.09102865f, -0.35102051f, -0.02917438f, 
    -0.21840569f, -0.12887815f, 0.14083473f, -0.05782458f, 0.02002043f, 0.07581551f, 0.10911071f, -0.10413386f, 
    0.13612667f, 0.19072209f, 0.23322111f, -0.15091993f, -0.21334937f, -0.15534605f, -0.00116722f, -0.29332671f, 
    0.19108710f, -0.00763556f, -0.11365683f, 0.11285744f, -0.01579935f, 0.16283104f, 0.27113020f, -0.06558392f, 
    -0.15865058f, -0.63041341f, -0.04054005f, -0.37728584f, 0.10295628f, -0.05822648f, 0.01605500f, 0.04573419f, 
    -0.02588503f, -0.11391903f, 0.24169251f, -0.06148481f, 0.30272749f, -0.34820208f, 0.09051945f, 0.15575352f, 
    -0.05245553f, 0.13206877f, 0.15607087f, 0.14391439f, -0.43449327f, -0.12303724f, 0.00016134f, 0.09804596f, 
    0.06470712f, 0.05100494f, 0.13689399f, 0.06777662f, -0.27125609f, 0.52027375f, 0.41836271f, -0.02256163f, 
    0.15086845f, 0.08223759f, 0.16215643f, -0.10994515f, 0.08561198f, -0.23338476f, 0.03127763f, 0.39636850f, 
    0.01231120f, 0.19067577f, -0.06529205f, -0.04046695f, -0.08760066f, 0.14689437f, -0.25698483f, -0.30779669f, 
    -0.24649812f, 0.05887796f, -0.33451402f, -0.05983442f, -0.04359863f, -0.18413024f, -0.24455036f, -0.33099914f, 
    -0.14628647f, -0.43117568f, 0.12928747f, -0.11028845f, 0.15670076f, -0.06113920f, -0.10100260f, 0.07098110f, 
    0.26841927f, -0.33519214f, 0.02334476f, 0.07092969f, -0.15888719f, 0.13712285f, -0.07108241f, -0.09089116f, 
    -0.00780949f, -0.34989715f, -0.06320270f, -0.33044451f, 0.03847833f, 0.06265039f, 0.11486953f, 0.03903975f, 
    0.02674605f, 0.16788860f, 0.43087089f, 0.22314014f, -0.24323545f, -0.32707798f, -0.00106399f, 0.13366278f, 
    -0.12569451f, 0.07804998f, 0.05097247f, 0.47063437f, 0.17628564f, 0.17670806f, -0.24249017f, -0.12110135f, 
    -0.14585359f, -0.00063607f, 0.10950096f, 0.09216412f, -0.20742089f, -0.16460231f, 0.08006395f, 0.10994250f, 
    0.14376485f, 0.20962815f, -0.19583136f, 0.01265256f, 0.13077787f, -0.18292142f, 0.07346851f, -0.00224739f, 
    -0.09798995f, -0.01543315f, 0.10070557f, -0.07954440f, -0.20808388f, 0.12889694f, -0.35314688f, -0.18501274f, 
    -0.02512132f, -0.08676396f, 0.13104348f, -0.09031709f, -0.25197256f, 0.13118221f, -0.09234633f, -0.07264116f, 
    -0.37058052f, -0.49893591f, 0.18990470f, 0.19203550f, -0.12793861f, -0.01513301f, -0.14303614f, -0.23673230f, 
    -0.29164517f, 0.30728486f, -0.19787942f, 0.35703480f, -0.03091487f, -0.03853362f, 0.20312263f, 0.16836926f, 
    0.11329450f, 0.42912817f, 0.44040620f, 0.09056377f, -0.10708751f, -0.18701601f, -0.08726469f, 0.23831566f, 
    -0.02707691f, 0.05230448f, -0.01029641f, 0.11997259f, -0.18749642f, 0.07644764f, 0.04871578f, 0.13129663f, 
    -0.05210774f, 0.27158818f, -0.02485018f, 0.20915617f, -0.14894667f, -0.01663743f, 0.06148029f, -0.22378249f, 
    -0.03614748f, 0.13483262f, -0.02834590f, 0.25678068f, -0.29619560f, 0.24013211f, -0.23065731f, -0.01500447f, 
    0.13534117f, 0.15882805f, 0.03359419f, -0.12482295f, -0.21653081f, -0.20471855f, -0.13793369f, 0.04379428f, 
    -0.03222972f, 0.16396308f, 0.03044394f, 0.08134823f, -0.08836464f, 0.05594803f, 0.20851816f, -0.54914278f, 
    -0.06214618f, -0.02407791f, -0.06452890f, -0.01722624f, 0.05883754f, -0.04001046f, -0.05146370f, -0.44924423f, 
    0.24957597f, 0.11528254f, -0.18000284f, -0.10884208f, -0.01910219f, 0.17074017f, 0.09073871f, -0.07961868f, 
    -0.02915626f, 0.03144664f, -0.02272631f, 0.04856047f, -0.09405164f, 0.02665100f, -0.03608977f, -0.06419101f, 
    -0.05223925f, -0.07284145f, 0.04588833f, -0.04699783f, 0.06581102f, -0.03854385f, -0.04986481f, -0.08065014f, 
    0.02844863f, -0.08748417f, -0.07973179f, -0.08736994f, 0.05628838f, 0.02039458f, -0.07528209f, 0.06990553f, 
    0.04797639f, 0.06286385f, -0.01496407f, 0.03833618f, 0.06777118f, -0.03554569f, 0.05231720f, 0.00161813f, 
    0.05431015f, -0.02039725f, -0.00824421f, -0.03126295f, 0.04932578f, -0.07906789f, -0.07715967f, -0.09041265f, 
    -0.04632444f, -0.00730707f, 0.03312841f, -0.03390622f, -0.03003078f, -0.01709606f, 0.07347757f, -0.02140081f, 
    0.01955677f, 0.05085708f, -0.00324446f, -0.04231029f, 0.04921119f, -0.04689058f, -0.07072752f, 0.06280583f, 
    -0.03410757f, -0.06618328f, 0.04556636f, -0.05812709f, 0.01611729f, 0.07042924f, 0.00101515f, -0.04981324f, 
    -0.08685195f, -0.04597838f, -0.09341088f, 0.05450199f, 0.00171155f, 0.05923390f, 0.06227823f, 0.02513114f, 
    0.01152616f, -0.02565726f, -0.03508853f, -0.06351712f, -0.09398986f, 0.03529183f, -0.05295709f, 0.04357073f, 
    -0.01538585f, -0.05371751f, -0.04947247f, 0.04903570f, 0.04195342f, -0.09138321f, -0.03713529f, 0.05146162f, 
    0.01433796f, 0.05776562f, 0.07013002f, -0.06320585f, -0.07478964f, 0.06754558f, -0.03607178f, -0.06675543f, 
    -0.04272640f, 0.00132775f, 0.05229957f, -0.08351740f, 0.03246364f, -0.02689439f, -0.00968183f, 0.04146628f, 
    0.02629381f, -0.04014399f, -0.02158787f, -0.00421202f, 0.05211598f, -0.04336999f, -0.08350920f, -0.08787291f, 
    -0.06065798f, -0.02942953f, -0.03164604f, -0.05317225f, -0.06751146f, -0.06688056f, -0.08367384f, -0.06411376f, 
    -0.05572478f, -0.07237026f, -0.01817592f, 0.02460878f, 0.01376941f, -0.06600659f, -0.03880870f, 0.01030893f, 
    -0.07662016f, 0.00678836f, -0.08434682f, 0.04729850f, -0.00362645f, 0.04382649f, -0.06419205f, -0.05817870f, 
    -0.02039002f, -0.04059779f, 0.06997517f, -0.02145499f, 0.03863625f, 0.03075861f, -0.07925481f, -0.08708764f, 
    0.21612197f, -0.31432751f, -0.04536253f, -0.07117645f, -0.02311861f, -0.23551702f, 0.04348317f, 0.14702734f, 
    -0.02339355f, 0.16195562f, -0.27502224f, 0.24458139f, -0.01982114f, 0.06636120f, -0.12281469f, 0.04053216f, 
    -0.08554944f, 0.07899167f, -0.15416753f, 0.03595518f, -0.14371394f, -0.02702881f, 0.05858359f, 0.15216976f, 
    -0.01527979f, -0.02624494f, -0.13804910f, 0.10774107f, -0.07300043f, -0.14419845f, 0.15029821f, 0.05813968f, 
    0.02190864f, -0.04038012f, 0.27090275f, -0.07185582f, -0.43832687f, -0.13539489f, 0.13302654f, -0.02947180f, 
    -0.00366909f, 0.26643568f, 0.08828719f, -0.04418565f, -0.11487161f, 0.11101508f, -0.51493472f, 0.06701515f, 
    -0.13138598f, 0.10596093f, -0.21246330f, 0.04654777f, -0.04282410f, -0.32351753f, 0.27991274f, -0.38286829f, 
    0.36884716f, -0.18905497f, -0.04403326f, 0.19482630f, 0.00058706f, -0.02734664f, -0.03642588f, -0.23198545f, 
    0.01977758f, 0.32569262f, -0.50003213f, -0.05607091f, 0.19381066f, -0.02689877f, -0.05209022f, -0.05840602f, 
    -0.53753716f, -0.30279815f, -0.18448116f, 0.18679811f, 0.04411810f, 0.30447394f, 0.08901738f, -0.05138295f, 
    -0.23078264f, 0.16031224f, 0.12233491f, 0.03651525f, -0.13416591f, 0.10622655f, -0.19151972f, -0.10274269f, 
    0.23313332f, 0.18189886f, 0.68600553f, 0.13451408f, 0.36709979f, 0.14749108f, 0.09073004f, -0.23213863f, 
    0.17165688f, 0.05364237f, 0.14799103f, 0.18195744f, -0.05791965f, 0.13954660f, 0.23341428f, 0.31302693f, 
    -0.07495303f, 0.20045356f, 0.13601410f, -0.19849874f, 0.14416601f, 0.06650967f, -0.01098699f, 0.10733040f, 
    0.22296757f, 0.06422214f, 0.04827145f, -0.00821611f, -0.08207492f, -0.57638645f, -0.47195166f, -0.04179599f, 
    -0.03314243f, 0.04171592f, 0.00246147f, 0.12046251f, -0.02775414f, 0.20606551f, -0.34826198f, -0.22567758f, 
    -0.00670036f, -0.01206395f, -0.14958373f, -0.17006892f, 0.17918627f, 0.08413520f, 0.06720708f, -0.15354845f, 
    -0.04842696f, -0.01114502f, -0.04863169f, 0.19713111f, 0.11772659f, 0.03792889f, 0.15471658f, -0.21693335f, 
    -0.36469650f, 0.34119341f, 0.20737465f, -0.00417930f, -0.08417638f, -0.15446135f, -0.11840481f, 0.11364373f, 
    0.04252598f, -0.02056818f, 0.29435313f, 0.14714853f, 0.06781291f, 0.02245640f, 0.16431808f, -0.04519990f, 
    -0.15872155f, -0.05593651f, -0.21145886f, 0.04880672f, -0.04805506f, -0.04610954f, -0.27701452f, -0.18116990f, 
    0.10342242f, -0.02160459f, 0.09439508f, 0.18126257f, 0.17151427f, 0.18428390f, 0.19505368f, -0.16591313f, 
    -0.33622766f, 0.27627185f, 0.13239636f, 0.20813771f, -0.02291431f, -0.25262043f, -0.00214867f, 0.00712982f, 
    -0.01122485f, 0.26749647f, -0.00712076f, -0.13350791f, 0.12975751f, 0.38274229f, -0.28967157f, -0.24160354f, 
    -0.16441007f, 0.15333477f, -0.10162630f, -0.07387549f, -0.18407182f, 0.02534566f, 0.42762372f, -0.05780699f, 
    0.15155357f, -0.33141693f, -0.08961283f, -0.10247767f, 0.14481547f, 0.11137246f, -0.05141472f, 0.13137114f, 
    0.19809526f, -0.19105969f, 0.15497114f, 0.11827452f, 0.21262966f, -0.12446943f, -0.11337272f, -0.20366637f, 
    -0.15660381f, -0.14576924f, 0.20045030f, 0.15862016f, -0.05353295f, -0.12835312f, 0.09841568f, -0.05130477f, 
    0.15239811f, 0.43030968f, 0.41498330f, 0.14019102f, 0.12968755f, 0.25622728f, -0.09590146f, 0.14603783f, 
    0.14311318f, -0.09772976f, 0.15592468f, -0.20921975f, 0.09036925f, -0.13332638f, 0.08914974f, 0.04836440f, 
    -0.07092706f, -0.19944674f, -0.07945535f, -0.17695625f, -0.25700626f, -0.43674624f, -0.11244892f, 0.07932501f, 
    -0.04962394f, 0.04607843f, -0.04613710f, 0.06920341f, -0.33716831f, -0.23891741f, 0.22497833f, -0.05707941f, 
    0.21396491f, 0.02629264f, -0.19949700f, -0.12380096f, 0.07846690f, -0.49643591f, -0.24283443f, 0.08484416f, 
    -0.13018309f, 0.06113113f, 0.32237273f, -0.19139621f, -0.04681885f, 0.18067935f, -0.02967910f, -0.36849779f, 
    -0.25287011f, -0.11246800f, -0.01471804f, -0.18447214f, -0.11386970f, 0.09052248f, -0.15483041f, 0.18771040f, 
    0.15035792f, -0.15725236f, 0.07792817f, 0.06851981f, 0.07425562f, -0.07585889f, 0.08149623f, 0.17698373f, 
    0.02122137f, 0.06388932f, -0.03842650f, 0.02438872f, -0.06698386f, -0.01364628f, -0.06121961f, -0.08666873f, 
    0.01355788f, 0.00558827f, -0.07221392f, -0.05885537f, -0.05822174f, 0.01213989f, -0.00051701f, -0.02943646f, 
    -0.01979323f, 0.05224944f, 0.00399233f, -0.04021483f, -0.07785442f, 0.05148102f, -0.01396602f, 0.06807475f, 
    0.00319184f, 0.07430615f, 0.01356584f, 0.05930743f, -0.04366874f, 0.06217904f, -0.04272577f, -0.01975841f, 
    -0.07861250f, -0.03463591f, -0.02809114f, 0.00733882f, -0.03092885f, 0.03369849f, 0.03533917f, 0.01853765f, 
    -0.02418174f, -0.01421502f, 0.01230692f, -0.05770745f, 0.04432274f, -0.04091773f, -0.00250508f, -0.06212208f, 
    0.00121950f, 0.01362664f, -0.02651376f, 0.06659387f, 0.04260257f, 0.03462783f, -0.00529973f, 0.00339864f, 
    0.01794761f, 0.03060483f, -0.00338514f, -0.01624300f, -0.07295765f, 0.04465267f, 0.07229711f, 0.07507872f, 
    -0.07154743f, -0.07197020f, -0.03097795f, 0.06259529f, -0.00190489f, 0.07370071f, 0.02848282f, 0.02298974f, 
    -0.09494898f, -0.06156198f, 0.03253921f, -0.05953409f, -0.03187529f, 0.01571180f, 0.03653543f, -0.04597768f, 
    -0.04181843f, -0.00621851f, 0.05327045f, -0.07620353f, -0.01952299f, 0.02153993f, -0.08850797f, -0.06914604f, 
    0.02049457f, 0.02848869f, -0.08577484f, -0.02745717f, 0.03624242f, 0.03668853f, -0.01582504f, 0.04321995f, 
    0.00287263f, -0.00314789f, -0.09148604f, 0.00935244f, 0.07397681f, -0.04910784f, -0.06253320f, -0.03658224f, 
    0.07387482f, -0.09138320f, -0.08544095f, -0.06673001f, 0.03650898f, 0.02928839f, 0.04219134f, -0.08435213f, 
    0.04570664f, -0.06523985f, -0.05713761f, 0.00379545f, -0.01431674f, -0.04788914f, -0.00520949f, -0.05791091f, 
    -0.02428895f, 0.02765043f, 0.01984195f, 0.02774607f, 0.03609436f, -0.03405936f, -0.03991663f, -0.00689980f, 
    0.02343630f, -0.06545422f, -0.02398811f, -0.07883351f, 0.01326223f, -0.06491551f, 0.03097351f, -0.02534949f, 
    0.07057251f, -0.06373463f, 0.02130863f, 0.02446152f, -0.07644291f, -0.08329117f, -0.06464095f, -0.05171845f, 
    -0.22609179f, -0.05137283f, -0.36102310f, 0.01288305f, 0.03511868f, -0.21746771f, 0.04933521f, -0.10341103f, 
    -0.06689599f, -0.26294991f, -0.32855114f, -0.36547869f, -0.17801952f, 0.01768492f, 0.01655521f, -0.08377512f, 
    0.16054150f, 0.01306783f, -0.48752820f, -0.22480309f, -0.08912072f, -0.10631128f, 0.18857627f, 0.04744550f, 
    -0.00295311f, -0.08290730f, -0.06920838f, -0.59032410f, -0.12731120f, 0.02997588f, -0.18511489f, 0.03792592f, 
    -0.11073347f, 0.03997379f, 0.15590173f, -0.01860743f, 0.43768838f, 0.05551745f, 0.07905577f, 0.09907765f, 
    0.10705229f, 0.14409919f, 0.05786328f, -0.16430186f, 0.16895507f, 0.03327255f, -0.08796172f, -0.01990174f, 
    0.12348060f, 0.01036758f, 0.03861647f, 0.10135724f, -0.23333634f, 0.22037949f, -0.41663438f, 0.10244664f, 
    -0.21643594f, -0.06835166f, 0.27273130f, -0.13705651f, 0.01336822f, 0.21627112f, -0.09330922f, -0.13820939f, 
    -0.18485358f, -0.25505117f, 0.07516284f, 0.03955509f, 0.26431599f, 0.00832662f, 0.00007821f, -0.09672157f, 
    -0.12338842f, 0.15208949f, 0.05528353f, 0.04963640f, 0.10365663f, 0.05762992f, 0.02936565f, 0.04447120f, 
    0.18453845f, -0.38615617f, -0.13449681f, -0.05803464f, -0.14067741f, 0.11272313f, -0.14844416f, -0.09208381f, 
    -0.02197640f, -0.11756869f, 0.24782741f, -0.15720846f, 0.08131083f, 0.01379142f, 0.04424917f, 0.10331178f, 
    0.04822518f, 0.00019867f, 0.06278624f, 0.03425356f, -0.13161364f, 0.08008126f, 0.13982220f, 0.11649538f, 
    -0.08938352f, -0.03320266f, -0.05554504f, 0.01142759f, 0.50805974f, 0.20210816f, 0.14730890f, 0.03441093f, 
    0.04330585f, -0.04456407f, -0.03646080f, 0.09177417f, 0.01350639f, 0.56775874f, 0.01800189f, 0.11021654f, 
    -0.07298888f, -0.11495575f, 0.17986801f, 0.07223652f, 0.03649997f, 0.00690164f, 0.36888853f, -0.19779052f, 
    0.08821674f, -0.12389257f, 0.07025293f, -0.14827387f, -0.02618188f, -0.01868815f, -0.00934241f, -0.61170709f, 
    -0.00436006f, -0.31621617f, -0.11088941f, 0.01754694f, -0.08043425f, 0.02356050f, -0.09969508f, 0.03950511f, 
    -0.48470724f, -0.16281651f, -0.37915444f, 0.08824572f, -0.04927202f, 0.03900927f, 0.12632452f, 0.05807332f, 
    -0.16112910f, -0.55453902f, -0.54928547f, 0.07720074f, 0.00165353f, 0.05642464f, 0.20281056f, 0.05889467f, 
    0.01059301f, -0.01177929f, -0.13365838f, 0.26000491f, 0.19417544f, 0.15082796f, 0.10085066f, -0.14931431f, 
    0.20515686f, 0.09851678f, 0.17683510f, -0.05608257f, 0.35554913f, -0.02315960f, -0.05851508f, 0.07150078f, 
    -0.16416499f, 0.00283038f, -0.13864797f, -0.24319483f, -0.24592957f, -0.16048577f, 0.12804370f, -0.05597474f, 
    0.18029195f, 0.08674315f, 0.20819962f, 0.00429728f, 0.07558476f, -0.17188396f, -0.00534603f, 0.07948094f, 
    -0.15995404f, -0.12423181f, -0.13752879f, 0.00771124f, 0.08829048f, 0.20291382f, -0.34989527f, -0.39455584f, 
    -0.17886713f, -0.12999825f, 0.12339476f, -0.12822363f, 0.08293618f, -0.01753811f, 0.01803177f, -0.30496594f, 
    -0.29892531f, -0.07301833f, 0.15548171f, -0.03889808f, 0.05114812f, 0.07569454f, -0.03010779f, -0.16779220f, 
    -0.07972909f, 0.18828274f, -0.18671572f, 0.04471849f, -0.00334139f, 0.09571448f, 0.15690374f, 0.20989810f, 
    0.01634346f, 0.54058957f, 0.31940392f, -0.61173296f, 0.08777373f, 0.09223458f, -0.03062306f, 0.17880186f, 
    -0.05723051f, -0.09327964f, -0.01216947f, -0.07881954f, 0.31153315f, -0.05910807f, -0.09699862f, 0.18434954f, 
    -0.15028374f, 0.08753587f, 0.29958200f, -0.11230245f, 0.08795951f, -0.24845284f, -0.04839151f, 0.05727712f, 
    -0.02827075f, -0.02341527f, 0.08327980f, 0.07857342f, 0.37515870f, 0.17347117f, -0.20637497f, -0.10202801f, 
    -0.08264847f, 0.09963493f, -0.03940964f, 0.00593188f, 0.03701521f, -0.05048636f, -0.10054081f, -0.08030059f, 
    -0.00957662f, -0.19350594f, 0.09712242f, 0.02861528f, -0.11197007f, 0.17153902f, -0.01216320f, -0.16269937f, 
    0.23555475f, -0.09673239f, -0.11235084f, -0.04909385f, -0.13987878f, 0.04757893f, 0.11321330f, -0.20720933f, 
    -0.41385826f, 0.10163743f, 0.14191033f, 0.22188681f, -0.09539499f, 0.02025150f, -0.10209057f, -0.06174972f, 
    0.11249474f, 0.06989787f, 0.09213207f, 0.07421438f, -0.07981365f, 0.13689022f, 0.06024697f, -0.02336995f, 
    -0.01101239f, 0.17671572f, 0.02043419f, 0.10796411f, 0.00307304f, -0.01921793f, 0.01435854f, 0.22421995f, 
    0.05740100f, -0.14440046f, 0.15359631f, -0.12848270f, 0.02473427f, -0.13831526f, 0.13679168f, -0.12882309f, 
    -0.01670851f, 0.07504818f, 0.15994936f, 0.72294277f, 0.44974059f, 0.16189188f, 0.10612156f, -0.19313577f, 
    0.09994457f, 0.06814880f, 0.23396516f, 0.04174226f, -0.28908107f, 0.00043033f, -0.39647606f, -0.18360075f, 
    0.05707888f, 0.14746249f, 0.03279591f, -0.00526500f, -0.03147121f, -0.37791815f, -0.04033156f, -0.16619910f, 
    -0.14068733f, 0.04550936f, -0.10024079f, -0.29346538f, -0.02290342f, -0.00940910f, 0.18936026f, 0.12267940f, 
    0.09520967f, -0.00480441f, -0.00733413f, -0.09051564f, -0.02872949f, 0.09337736f, -0.03865565f, 0.28758258f, 
    0.32755092f, 0.02785129f, -0.09275881f, -0.01247180f, 0.06860619f, -0.12713829f, 0.01627079f, -0.08199473f, 
    -0.42767701f, -0.14298852f, -0.51477289f, 0.10283654f, 0.20450506f, 0.14778355f, 0.07897817f, -0.25497186f, 
    -0.16771874f, 0.33654958f, 0.26000082f, 0.24456681f, 0.24355707f, -0.05254238f, 0.13210902f, 0.12935434f, 
    -0.01093336f, -0.07469476f, -0.29571533f, -0.20404835f, -0.45379388f, -0.16249393f, -0.17187692f, 0.01141542f, 
    -0.05938081f, -0.02079546f, 0.08275032f, -0.43367097f, 0.04844850f, -0.17134146f, 0.11514834f, 0.27957177f, 
    0.09419265f, -0.01295815f, 0.12859380f, -0.02905340f, -0.34949762f, 0.21532923f, -0.14320879f, -0.09970663f, 
    -0.03668695f, 0.03127482f, 0.13840835f, -0.16904190f, -0.08224934f, -0.15528463f, 0.36237565f, 0.03286748f, 
    -0.08516890f, -0.05393517f, -0.11411931f, -0.11978976f, 0.02097835f, 0.10135677f, -0.00976008f, -0.04362887f, 
    -0.09526051f, -0.09936203f, -0.07834374f, -0.14796752f, 0.30104551f, 0.07106900f, -0.08280998f, 0.01250918f, 
    0.15461881f, -0.02654744f, 0.06138103f, -0.07325892f, -0.00772899f, 0.04049293f, -0.12453639f, 0.17254885f, 
    -0.08984052f, 0.62486309f, -0.02009955f, -0.03954941f, 0.13279486f, -0.11124255f, 0.11945724f, 0.18622708f, 
    0.23270179f, -0.31586248f, 0.50936031f, 0.11052420f, 0.12937731f, -0.04758260f, -0.18725604f, -0.00574467f, 
    -0.08114192f, 0.24261598f, 0.35416681f, 0.32069659f, 0.32748958f, -0.13951519f, -0.25943208f, -0.26034045f, 
    0.08619604f, 0.35229915f, 0.00600958f, -0.35401648f, 0.27239692f, 0.41476712f, -0.09584980f, 0.04619085f, 
    0.20769446f, -0.21388415f, 0.14674768f, 0.00231402f, 0.58228320f, -0.29561770f, 0.02914589f, 0.25942677f, 
    0.07683959f, 0.04652484f, 0.06673971f, 0.10117049f, 0.00533694f, 0.75561792f, 0.06407534f, 0.00129216f, 
    0.15254837f, -0.24960774f, -0.08087197f, 0.00189869f, -0.00125784f, -0.00183563f, 0.44036606f, -0.18025164f, 
    -0.06520823f, 0.19388551f, 0.06834458f, -0.09908032f, 0.02673994f, 0.03202337f, -0.01675562f, -0.04841704f, 
    0.26605332f, -0.12179369f, -0.34442970f, 0.24922505f, -0.06991548f, -0.19009084f, 0.26544833f, -0.03063015f, 
    -0.08092400f, -0.12143281f, 0.00783136f, -0.15575299f, -0.08226368f, 0.21309233f, 0.10407169f, 0.09130830f, 
    -0.13508765f, -0.22234368f, 0.20954038f, 0.50093919f, -0.27351120f, 0.02272949f, 0.08348287f, -0.19059157f, 
    -0.02777882f, 0.18655172f, -0.19736429f, -0.07372880f, -0.22035927f, 0.20478193f, -0.28060630f, -0.34683496f, 
    0.29049605f, -0.06671803f, -0.01927779f, -0.40912262f, 0.20227037f, -0.34921661f, -0.10080589f, 0.15496743f, 
    0.15772676f, 0.01506553f, 0.02218308f, -0.32331869f, 0.05831596f, -0.25734508f, 0.01380024f, 0.17522548f, 
    0.07159354f, 0.12389070f, 0.16127533f, -0.05758292f, 0.00793152f, 0.26860431f, -0.21872580f, -0.15117179f, 
    0.26893583f, 0.10912939f, 0.17820087f, -0.08975542f, -0.11649857f, -0.04234723f, 0.30092403f, -0.16179796f, 
    -0.00147529f, 0.01952109f, -0.17663608f, -0.10432886f, 0.25865933f, -0.32474229f, 0.22678174f, 0.01546949f, 
    -0.05528537f, -0.05594807f, -0.15398681f, -0.09159280f, -0.11933275f, -0.29617876f, 0.08052058f, -0.16242823f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05591196f, 0.21700977f, 0.23699968f, -0.02238354f, -0.01222627f, 0.15492430f, 0.19662389f, 0.19123577f, 
    -0.04897808f, 0.26031637f, 0.00035692f, -0.08017426f, 0.12504627f, 0.33062360f, -0.05263881f, -0.14457121f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11740747f, 0.11111099f, -0.16534618f, 0.24727139f, 0.18190303f, -0.10813326f, 0.18273383f, -0.01727116f, 
    0.21112648f, -0.24987602f, -0.15066898f, 0.19166732f, 0.01046363f, 0.04637685f, -0.17348000f, -0.18575022f, 
    -0.18749645f, 0.29077429f, 0.12106793f, 0.05414507f, -0.15272507f, -0.18692745f, 0.04199465f, 0.23343594f, 
    0.22028488f, -0.38399082f, -0.25067210f, -0.11169893f, 0.02782976f, 0.23054925f, -0.69352657f, 0.37957588f, 
    -0.14272609f, -0.18277112f, 0.10164068f, 0.07240188f, 0.11333290f, 0.42420980f, -0.29871225f, 0.20583761f, 
    0.08874679f, -0.14993575f, -0.47917178f, 0.03876710f, -0.57730711f, 0.61527771f, -0.32737103f, 0.23543470f, 
    0.08685559f, 0.11605763f, -0.31379372f, 0.15457629f, -0.09653414f, -0.08516069f, 0.47850960f, -0.31754437f, 
    -0.00291845f, 0.55154961f, -0.19653150f, 0.10756049f, 0.38825712f, -0.61536646f, -0.76837444f, 0.38662988f, 
    0.19431156f, 0.82279879f, -0.25054461f, 0.12106080f, -0.01547923f, 0.33160549f, -0.13380766f, -0.25473163f, 
    -0.19600058f, 0.57212341f, 0.08986079f, -0.06452763f, -0.40737817f, -0.53054726f, -0.38683465f, 0.12441663f, 
    -0.06881207f, -0.40433195f, -0.07010040f, 0.02914150f, 0.08382564f, -0.45318592f, -0.00732223f, 0.11003274f, 
    0.05697592f, 0.42143503f, 0.60027242f, -0.11250529f, -0.07179359f, 0.61413366f, -0.10575201f, 0.26086915f, 
    0.06102878f, -0.11281978f, 0.50043082f, -0.04873089f, -0.24456087f, 0.16401555f, 0.50530076f, -0.46348572f, 
    -0.12307997f, -0.25210637f, 0.87652737f, 0.23246929f, 0.45181185f, 0.50941104f, -0.61398578f, -0.02749496f, 
    -0.22172156f, -0.57610965f, 0.04797739f, -0.10053033f, -0.06551541f, -0.17105536f, -0.27630067f, 0.65442181f, 
    -0.06212635f, 0.16568327f, 0.22036919f, 0.09680077f, -0.05927445f, -0.39798054f, -0.44968915f, 0.46078682f, 
    -0.10077360f, 0.84932584f, 0.05166699f, -0.14419425f, -0.15609363f, 0.04295016f, 0.03333196f, 0.14682087f, 
    0.20813453f, 0.12402649f, 0.25440621f, 0.00966820f, -0.27314931f, 0.15718977f, -0.03930581f, -0.32024136f, 
    0.14845395f, -0.04008955f, -0.10503715f, -0.16724744f, -0.17605016f, 0.10619854f, -0.17276919f, -0.08271790f, 
    0.00579742f, 0.07075840f, -0.03225132f, 0.01634270f, -0.14652926f, -0.19598153f, -0.22496912f, -0.18413459f, 
    -0.09269220f, 0.41979033f, -0.03573695f, 0.07044061f, -0.02908387f, -0.31935742f, 0.12878551f, 0.46421459f, 
    0.06719676f, 0.28157562f, -0.02589801f, -0.07329100f, -0.23632337f, -0.68164170f, -0.25940013f, 0.26156443f, 
    0.12366474f, 0.09959605f, 0.45530158f, -0.12697636f, 0.18417233f, 0.43877509f, 0.09388480f, -0.20680860f, 
    0.07430145f, 0.07029808f, 0.19728699f, 0.07081503f, 0.36761910f, 0.50541526f, 0.13592610f, -0.24197404f, 
    0.24193805f, -0.18273738f, -0.19174562f, -0.08513509f, -0.07520226f, -0.13672912f, 0.05883748f, -0.24301423f, 
    0.19142111f, -0.25843272f, -0.12157775f, 0.24259451f, 0.17599070f, -0.00738815f, 0.15268570f, -0.15599284f, 
    0.14257377f, 0.10922537f, 0.18768100f, 0.03404117f, -0.22994505f, 0.24649569f, -0.46045041f, 0.39245671f, 
    0.26573357f, -0.10236414f, 0.20234089f, 0.06216161f, -0.09263778f, -0.09879231f, -0.20980836f, 0.33527866f, 
    0.03163636f, 0.08563773f, -0.01086881f, 0.01526693f, 0.10716704f, 0.04672122f, -0.03972840f, -0.02385692f, 
    0.18742761f, 0.37863633f, -0.12474638f, 0.07492030f, -0.73006630f, 0.57246971f, -0.04384869f, -0.26379585f, 
    -0.22985014f, 0.58695161f, 0.24842009f, 0.07146659f, -0.19470312f, 0.63280070f, -0.16123664f, -0.16513309f, 
    0.02124917f, -0.11081241f, -0.47723556f, 0.06978202f, 0.28642407f, -0.77172220f, 0.11564174f, 0.26713333f, 
    -0.03808978f, -0.38916948f, -0.28836611f, -0.09740503f, 0.15209430f, 0.11236811f, -0.39023757f, -0.29557958f, 
    0.12895407f, 0.46918735f, 0.50066847f, -0.01827698f, -0.13487653f, 0.40550196f, 0.12208629f, 0.33345538f, 
    0.22356561f, 0.55708104f, 0.58111382f, -0.24077661f, -0.03555089f, -0.30543339f, -0.50809264f, 0.49857458f, 
    0.07317623f, -0.10790027f, 0.10211370f, 0.06076474f, 0.59259188f, -0.33494103f, 0.27060196f, 0.13257332f, 
    -0.05664924f, 0.75467736f, 0.52393198f, -0.14223082f, 0.18742043f, 0.34799680f, 0.65346152f, -0.10844702f, 
    -0.10399379f, -0.09845931f, -0.35666001f, 0.03062204f, -0.29653400f, -0.10313399f, 0.06241993f, -0.02646867f, 
    -0.19418758f, 0.14824757f, 0.76002985f, -0.21516390f, -0.12915367f, 0.07852191f, 0.18453974f, 0.48458683f, 
    -0.02783908f, 0.31894249f, -0.14934576f, -0.15151142f, 0.43411860f, 0.39554024f, -0.20539193f, -0.31674650f, 
    -0.17028406f, 0.73872018f, 0.05661646f, 0.06081757f, -0.06193689f, 0.50511932f, 0.39497304f, -0.20078534f, 
    0.08845082f, -0.40622392f, -0.31576452f, -0.15744957f, -0.75573015f, 0.30286384f, 0.48055395f, 0.14999524f, 
    -0.07342231f, 0.07558645f, 0.20765865f, 0.02643390f, 0.19237821f, -0.17965150f, -0.16678753f, -0.12458780f, 
    0.19775650f, -0.22778559f, -0.23296204f, -0.10830174f, 0.10537049f, -0.25264665f, -0.15734397f, -0.19028687f, 
    0.14883375f, 0.09553252f, 0.26332593f, 0.03296590f, 0.09786907f, -0.26115137f, 0.34506986f, -0.35761815f, 
    0.05436851f, -0.02326197f, 0.48364854f, 0.04222617f, 0.29603451f, -0.18632713f, -0.13613050f, 0.38258746f, 
    -0.14086896f, -0.13476312f, -0.20974337f, -0.06966650f, 0.14493568f, -0.42453384f, 0.26872370f, -0.06510910f, 
    -0.04497332f, 0.55878615f, 0.35657209f, -0.24941450f, -0.37903962f, 0.17929581f, 0.35153601f, 0.19773190f, 
    -0.16162902f, -0.06339555f, -0.11225373f, 0.11861350f, -0.17983259f, -0.25181746f, 0.03395883f, -0.07261147f, 
    0.20691416f, 0.15340310f, -0.06312666f, 0.11393775f, -0.03070942f, -0.04973283f, -0.03132448f, -0.19124317f, 
    0.22977924f, -0.20938422f, -0.01973995f, -0.00773932f, -0.15190840f, 0.03302262f, 0.29449591f, 0.43380353f, 
    0.23832744f, 0.09912910f, -0.14875519f, -0.10557137f, 0.65133363f, -0.48236445f, -0.44148192f, 0.36944044f, 
    0.24591973f, -0.33324787f, -0.50572115f, -0.18821280f, -0.12450639f, 0.51183254f, 0.55244106f, 0.17399654f, 
    -0.20521168f, 0.07526399f, 0.05733964f, -0.17373030f, -0.07158169f, 0.51588660f, 0.51652426f, -0.04749158f, 
    -0.18236461f, -0.29638103f, -0.56868231f, 0.26122311f, 0.23540232f, -0.08777377f, 0.00291223f, -0.09202523f, 
    0.08208250f, 0.20022441f, 0.55014068f, 0.04786941f, -0.29857087f, -0.52383858f, 0.66731495f, -0.05760233f, 
    0.21225110f, 0.02408947f, -0.25306916f, 0.08326311f, -0.00058285f, 0.04998753f, 0.20735942f, -0.23131438f, 
    0.03453245f, 0.08855598f, 0.32053512f, -0.07614740f, 0.25316343f, -0.06126670f, 0.42126349f, -0.11657046f, 
    0.21636128f, -0.12998289f, -0.08881423f, 0.22301960f, 0.06825164f, -0.22513455f, 0.09592429f, 0.01035982f, 
    0.23631522f, -0.12801072f, -0.13267332f, 0.08841452f, 0.03070572f, 0.01530039f, 0.02475640f, -0.23039478f, 
    0.04406565f, -0.23062132f, 0.49547595f, -0.18336821f, 0.23048680f, 0.59431028f, 0.28678143f, 0.13835645f, 
    -0.09767868f, 0.02138014f, -0.46495125f, -0.08014096f, -0.15242489f, 0.43422315f, 0.10062312f, -0.15285487f, 
    -0.00176552f, 0.09319964f, 0.10173085f, 0.11043059f, -0.11011110f, 0.08428097f, -0.07522028f, -0.18397646f, 
    -0.16442278f, -0.26909429f, -0.10261779f, -0.06627624f, -0.31667152f, -0.07556991f, 0.02499893f, -0.14257236f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14933690f, 0.06042013f, 0.34477985f, 0.37697113f, 0.27445456f, 0.33759433f, -0.15299641f, 0.00106138f, 
    -0.15681592f, -0.32149011f, -0.07705285f, 0.30687538f, 0.19032796f, -0.59598440f, 0.16386269f, 0.08917969f, 
    -0.09353481f, 0.04311016f, 0.59826636f, 0.86432129f, -0.11980052f, 0.23247516f, -0.49286842f, 0.22449186f, 
    0.15231341f, -0.16915695f, 0.34810796f, -0.10518721f, 0.27411383f, -0.11304715f, 0.78152770f, -0.03643227f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04760162f, -0.59608740f, 0.43469673f, -0.85151994f, 0.02672836f, 0.30030987f, -0.25124022f, -0.25371015f, 
    -0.04426660f, -0.02155716f, -0.29164782f, 0.05446691f, 0.13811404f, -0.13043463f, 0.41099417f, -0.28483593f, 
    0.47073805f, -0.43534222f, -0.10142585f, -0.10898516f, 0.55015153f, 0.02066050f, -0.54365927f, 0.15601334f, 
    -0.02675818f, -0.56671292f, 0.19527353f, -0.85190785f, -0.08228808f, -0.00748741f, 0.23515838f, -0.04775770f, 
    0.10644761f, -0.03908045f, 0.41510311f, -0.66336429f, -0.58958292f, -0.03559606f, 0.40431398f, -0.14564529f, 
    0.04189299f, -0.15435810f, -0.46145988f, 0.27270266f, 0.06569091f, -0.02998316f, -0.15120175f, -0.51576012f, 
    -0.05268241f, -0.23509292f, -0.07505748f, 0.17935766f, -0.29441449f, 0.06029936f, -0.46890607f, -0.44734976f, 
    0.11982206f, -0.05632642f, 0.22081253f, 0.77075398f, -0.03760129f, -0.07867919f, 0.24878399f, -0.09273431f, 
    0.04450526f, -0.19130798f, -0.10972698f, -0.47586218f, -0.30275577f, -0.31893724f, -1.55280900f, 0.34953335f, 
    -0.00116105f, -0.02474520f, 0.36523440f, -0.21784933f, 0.03726558f, 0.25040802f, 0.06200520f, 0.40812868f, 
    -0.50413251f, 0.56906492f, 0.06599483f, 0.18833876f, -0.14431816f, 0.18312982f, -0.95923084f, -0.80367625f, 
    -0.01614898f, 0.22269754f, 0.17068738f, -1.03120458f, -0.22127058f, 0.03387087f, 0.26322037f, 0.00259047f, 
    -0.15997376f, -0.32287174f, -1.32489491f, 0.31780520f, 0.64156002f, 0.30571669f, 0.43643320f, 0.22030395f, 
    0.22934625f, -0.04886390f, 0.14695702f, -0.30396768f, -0.09456708f, 0.04779211f, 0.09784873f, -0.59119195f, 
    0.29437307f, -0.21910948f, -0.62382853f, -0.22826380f, -0.30271551f, 0.13346574f, -0.01664587f, 0.00662590f, 
    -0.07673622f, 0.07591276f, -0.01425040f, -0.43496561f, -0.15472557f, -0.04369107f, -0.54263479f, 0.14726841f, 
    -0.11377311f, 0.17534645f, -0.10450251f, 0.41124895f, 0.11755521f, -0.16161561f, -0.24729097f, -0.27529299f, 
    -0.02938416f, -0.12979016f, 0.12598802f, -0.35546961f, 0.04519590f, -0.57093090f, 0.42274556f, -0.01111318f, 
    -0.25745323f, -0.69178092f, 0.25821459f, -0.17791469f, 0.35938954f, -0.00764328f, -0.00745175f, 0.18381047f, 
    0.06961908f, 0.16134879f, 0.31583175f, -0.04701221f, 0.19336656f, -0.14822572f, 0.01908207f, -0.20189895f, 
    0.05198967f, 0.47403723f, -0.81106555f, -0.28466439f, -0.68737483f, -0.02030677f, 0.40615290f, -0.46049124f, 
    -0.28239241f, -0.15052520f, -0.47494313f, 0.42582253f, 0.05413660f, -0.51338196f, -0.41080055f, -0.27729842f, 
    -0.23158295f, -0.09049020f, 0.23508731f, 0.16342038f, 0.07885887f, 0.17165644f, -0.02563986f, -0.13372703f, 
    0.06188932f, -0.26756850f, 0.05675155f, 0.13771763f, 0.25808582f, 0.02492611f, 0.13550167f, -0.16825293f, 
    -0.15226069f, -1.22764182f, -0.60195345f, 0.36748540f, -0.12191360f, -0.35743609f, 0.09245612f, -0.45311895f, 
    -0.25196013f, 0.04858232f, -0.60021061f, 0.38273999f, 0.02050697f, -0.18688530f, -0.80948466f, 0.59053904f, 
    0.08082549f, -0.04284937f, 0.10266982f, 0.03034538f, -0.29969612f, -0.03600832f, 0.01038711f, -0.75560075f, 
    -0.05045860f, 0.25242645f, 0.02889265f, -1.14873433f, 0.23654306f, -0.05482592f, 0.08001591f, 0.05617122f, 
    -0.15937911f, -0.39663219f, -0.79975593f, -0.74605876f, -0.28574857f, 0.29437584f, -0.45218119f, -0.00672477f, 
    -0.80622298f, -0.11417941f, -0.43423310f, -0.28986523f, 0.15476647f, -0.22611342f, 0.17053157f, -0.10504533f, 
    0.43030450f, 0.12666549f, -0.67530864f, -0.58500892f, -0.08044340f, 0.05009970f, 0.16501029f, 0.23046748f, 
    -0.17038567f, -0.24312170f, 0.28188032f, 0.29761931f, 0.38606063f, 0.11453606f, -0.42494610f, -0.07829674f, 
    0.11259897f, 0.38443625f, -0.19411682f, -0.09068677f, -0.64312929f, -0.06411160f, 0.47601143f, 0.26622230f, 
    -0.21985751f, -0.03711377f, 0.16270135f, -0.33009043f, -0.05831876f, 0.27520990f, -0.59956980f, 0.17801641f, 
    -0.35390234f, 0.30868736f, -0.05499336f, -0.24362573f, -0.11603007f, 0.04974545f, 0.47539249f, -0.32585889f, 
    -0.00993303f, 0.17427082f, -0.56479162f, -0.03377220f, -0.25771046f, 0.06699703f, -0.25540748f, 0.09837095f, 
    0.11208943f, 0.37168214f, 0.24215426f, -0.04935605f, 0.65752745f, -0.56692111f, -0.16879842f, -0.65640020f, 
    0.28790355f, -0.14537691f, -0.14664255f, 0.02665352f, 0.04027756f, -0.05085717f, 0.36105666f, 0.50958359f, 
    -0.23837893f, 0.14025237f, 0.20310205f, -0.10551855f, 0.47687870f, 0.13507126f, -0.02480205f, -0.04218484f, 
    0.00087087f, -0.39229405f, -0.32988515f, 0.11685228f, -0.14283958f, 0.07100125f, -0.00611243f, -0.09327172f, 
    -0.12217208f, -1.50234914f, -1.53434014f, -0.09171903f, -0.14235269f, 0.37660345f, -0.28087783f, 0.20230518f, 
    0.37042657f, -0.19285563f, 0.25624359f, -0.02024221f, 0.08013727f, -0.22328113f, -0.15956053f, -0.64689344f, 
    -0.01912282f, 0.46216664f, -0.19922228f, 0.32515681f, -1.46944118f, -0.08820034f, 0.06124935f, 0.24202400f, 
    0.12745909f, -0.06215008f, -0.32124200f, -0.56174040f, 0.06919244f, -0.13296032f, -0.10608834f, 0.13547474f, 
    -0.04716959f, -0.43456435f, -0.14411916f, 0.69070727f, 0.21841164f, 0.19695677f, -0.34235612f, 0.55722600f, 
    -0.79073882f, 0.04572796f, 0.20408067f, -0.42020664f, -0.13077943f, 0.11960275f, -1.03484178f, 0.03941332f, 
    0.16402797f, -0.14585990f, -0.24605103f, 0.00970893f, -0.87481290f, -0.14998959f, -0.13108945f, 0.15127093f, 
    0.06434145f, 0.19421718f, -0.19409169f, -0.86791480f, -0.50306994f, -0.00079339f, 0.03833864f, 0.08353849f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.24955730f, -0.02720341f, 0.26312110f, -0.56764901f, 0.28912041f, 0.27253902f, -0.23915242f, -0.32462317f, 
    -0.48325956f, -0.03949920f, 0.52997935f, 0.01524219f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
