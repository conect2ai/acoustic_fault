#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.71940589f, -0.66446811f, -0.93974471f, 1.02301991f, 1.10592568f, 0.61869752f, -0.19352916f, -0.13983682f, 
    -0.30650783f, -1.22738016f, -1.30584550f, 0.53872627f, -1.38870823f, -1.43937838f, -1.10659432f, 0.55390781f, 
    0.36960986f, 0.07390622f, -0.16627161f, 0.88704616f, -0.93157303f, -0.71256268f, -0.89418590f, -0.86701232f, 
    -0.65198666f, -0.60450703f, -0.62674356f, -0.63767093f, 0.07351173f, 0.63568723f, -0.18029860f, 0.56362462f, 
    0.96882075f, -0.77623951f, -0.85301203f, -0.17918062f, 0.89629900f, 0.73972291f, -1.25520861f, 0.04453016f, 
    -0.17137919f, 0.17870116f, 0.08842717f, -0.27352387f, -0.31524581f, 0.31845236f, -0.11410474f, 0.51815164f, 
    0.44531596f, 0.76805049f, 0.59457701f, 0.25616914f, 0.39822510f, -0.03207548f, -0.96257687f, -1.37322819f, 
    0.52519661f, -0.28152966f, -0.64485174f, 0.60654342f, -0.75963479f, -0.91332543f, -0.77178997f, 0.47392872f, 
    -0.40897682f, 0.71273947f, -0.66898292f, -1.08994389f, -1.14774227f, 0.17059879f, -0.86426163f, -0.80963224f, 
    1.36239994f, 0.06857711f, 0.64918256f, -1.06681216f, -0.88326472f, -0.31150565f, -0.28786752f, 0.16872981f, 
    0.52123147f, 0.54365236f, 0.71318293f, 0.42677847f, 0.40145198f, 0.45593098f, -0.36413646f, 0.38833106f, 
    -0.07929073f, -0.34080580f, -0.91614366f, -1.39501071f, -1.52586830f, -0.80730337f, -0.75925761f, 0.81364799f, 
    0.50978726f, 0.18925850f, -0.21921510f, 0.33001298f, -0.00382432f, -0.46679884f, -0.23779406f, -0.12300649f, 
    -0.76409250f, 0.83701569f, -0.13273512f, 0.83779252f, -0.77637261f, 1.01751149f, 0.70298105f, -0.09742896f, 
    -0.50704223f, 0.03631813f, -0.43409812f, 0.38466153f, 0.54815555f, 1.44377708f, -0.55645257f, -0.31107169f, 
    0.32779285f, 0.60952437f, 0.51539993f, -0.39924499f, -0.23155229f, -0.47059864f, 0.96373606f, 0.43160570f, 
    -0.27888036f, -0.45490670f, 1.14871645f, -0.52051491f, -0.62655431f, 0.18502600f, -0.34656319f, 1.41719866f, 
    -1.66080248f, -0.29364181f, 0.71397686f, -0.64823896f, 0.49295989f, -0.03896863f, -0.01606867f, -0.08168624f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41644293f, 0.46889576f, -0.30174670f, 0.04484803f, 0.52847654f, 0.11605982f, -0.01072717f, 0.23015209f, 
    0.26766962f, -0.01811062f, 0.76657563f, 0.00084394f, 0.50608039f, 0.22507173f, 0.39670691f, 0.57972723f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43232951f, 0.01441652f, -0.51508325f, -0.06561448f, -0.03055130f, 0.15419963f, 0.22432838f, 0.12340625f, 
    -0.02849703f, 0.09499123f, -0.15437320f, -0.02508058f, -0.04682529f, 0.08991566f, -0.01999587f, 0.04095066f, 
    0.15351847f, 0.00900678f, 0.02079421f, 0.08930375f, 0.44627351f, 0.49102139f, 0.18131039f, -0.73339540f, 
    -0.12523064f, 0.10551899f, 0.15650135f, -0.11228710f, -0.02367613f, 0.01814675f, 0.02797635f, -0.08442560f, 
    -0.07433788f, -0.00511350f, 0.02141287f, 0.03696917f, -0.08907115f, -0.09692716f, 0.06506097f, 0.03804019f, 
    -0.00726889f, 0.51900661f, 0.31184801f, -0.18132085f, -0.25757265f, -0.05974282f, 0.12911052f, 0.05543847f, 
    -0.06410048f, 0.06689909f, -0.02344326f, -0.12696274f, -0.01725211f, 0.08578960f, 0.01485700f, -0.03643748f, 
    -0.02100070f, 0.07744859f, -0.05780657f, 0.21132977f, -0.16726705f, -0.44513476f, 0.52326310f, 0.08353141f, 
    0.24013884f, 0.03049259f, -0.01574156f, -0.04744117f, 0.14287643f, 0.09394170f, 0.12139590f, 0.19608976f, 
    0.10621609f, -0.02112753f, 0.05958275f, -0.03554171f, 0.01361226f, 0.14247085f, -0.02839791f, -0.03958727f, 
    -0.69728070f, -0.45430782f, -0.85287321f, 0.22590098f, -0.97490382f, -0.05969244f, -0.01961685f, -0.10592628f, 
    0.02465821f, 0.03149686f, -0.04866264f, -0.06461193f, -0.11470159f, -0.06541125f, -0.01778685f, -0.02141087f, 
    -0.02181079f, -0.06343811f, -0.00016882f, -0.16074602f, 0.01073519f, -0.00188964f, 0.05212215f, 0.09901580f, 
    0.14471184f, -0.00557810f, 0.04515141f, 0.00167763f, 0.08646321f, 0.09765592f, -0.23767971f, -0.33155102f, 
    -0.10161392f, -0.28811175f, -0.30233380f, -0.00430065f, -0.03288344f, -0.04664610f, 0.01248901f, 0.00561658f, 
    0.66076273f, 0.33239675f, 0.53747308f, -0.44537893f, -0.04092395f, 0.05087754f, 0.12446850f, 0.18888493f, 
    -0.02327623f, -0.08012164f, 0.01304832f, -0.05641177f, 0.01069084f, -0.24768414f, -0.31807202f, -0.04806382f, 
    -0.24744423f, -0.07076411f, 0.11857568f, 0.01510481f, 0.14704749f, 0.39109620f, 0.24231303f, -0.49643236f, 
    0.11084328f, -0.10411324f, 0.13639846f, -0.18152334f, -0.17713355f, 0.09033211f, -0.00645978f, -0.12633799f, 
    -0.01535036f, -0.01047410f, 0.00418195f, 0.06521445f, 0.02073584f, 0.14991485f, 0.00834207f, 0.09718639f, 
    -0.19604971f, 0.15778638f, 0.22917999f, -0.39577883f, -0.27406791f, 0.01490478f, -0.07212583f, -0.45207116f, 
    -0.29205927f, -0.30324268f, 0.02028518f, 0.02149961f, 0.02296762f, 0.03915659f, 0.04759456f, -0.01560439f, 
    0.12687466f, 0.02451057f, -0.06759762f, -0.09734228f, -0.23916633f, -0.23492917f, -0.21515332f, -0.00686039f, 
    -0.00305467f, 0.05350065f, 0.03668534f, 0.02467061f, 0.04441529f, 0.08435076f, -0.04286170f, 0.05202840f, 
    0.00855194f, 0.10936336f, -0.02392370f, -0.08824611f, -0.14739026f, -0.03870737f, -0.00970606f, 0.01105457f, 
    0.56811374f, 0.30323011f, 0.10984533f, -0.38182601f, -0.22760104f, 0.19453929f, 0.16322564f, 0.04630211f, 
    -0.22513919f, -0.26963797f, -0.07068517f, -0.06297052f, -0.04628788f, 0.05520958f, 0.10874622f, 0.01285671f, 
    -0.16392189f, -0.02050221f, -0.08416514f, 0.08622767f, 0.33709896f, 0.28524059f, -0.03916846f, -0.13835254f, 
    -0.04183568f, -0.08272942f, 0.12735544f, -0.01893581f, -0.20374978f, 0.01724442f, 0.02066034f, 0.30886281f, 
    -0.26654497f, -0.04919955f, -0.01332473f, -0.10640696f, -0.15515189f, -0.02676874f, 0.00616600f, -0.16882442f, 
    -0.32722998f, -0.27320445f, -0.06901190f, 0.06756880f, -0.19075520f, -0.11492327f, -0.19511119f, 0.01975720f, 
    0.14862050f, -0.10092093f, 0.08644091f, 0.06247712f, -0.00761703f, 0.01427470f, -0.13690156f, -0.33215636f, 
    -0.13490409f, -0.12430022f, -0.11110443f, -0.13885053f, -0.29880089f, -0.30479985f, -0.45832658f, -0.01613863f, 
    -0.25700146f, -0.02975332f, 0.05243239f, -0.00887841f, 0.10714274f, 0.14418234f, 0.16040187f, 0.02298767f, 
    -0.00724846f, -0.05335307f, 0.01606078f, -0.10231324f, 0.10842329f, 0.20062234f, -0.02667649f, 0.12948525f, 
    -0.74053508f, -0.55861765f, -0.29657760f, 0.29740483f, -0.17641723f, 0.10693852f, 0.04698707f, -0.07694512f, 
    0.05094200f, 0.06878950f, -0.09475344f, 0.06601249f, -0.07390504f, 0.00659623f, -0.01077305f, 0.06218550f, 
    0.06682757f, -0.06750313f, -0.18318163f, 0.09856191f, 0.03989264f, -0.43917108f, -0.53110921f, -0.12148198f, 
    -0.01690544f, -0.19506146f, -0.14335814f, 0.09198100f, -0.25259274f, -0.02387467f, -0.23623537f, -0.14781891f, 
    -0.17128393f, -0.14401859f, -0.21739775f, -0.05469470f, 0.04818068f, -0.16121283f, -0.23400809f, -0.07570275f, 
    0.21513253f, -0.37602338f, 0.10457025f, 0.13153245f, -0.30148938f, 0.03776447f, 0.06269886f, 0.15064253f, 
    0.03523703f, -0.29863590f, 0.27984923f, -0.06073061f, -0.08780254f, -0.10848548f, -0.01268245f, 0.07219230f, 
    -0.04045589f, -0.17289619f, 0.05662094f, -0.02380898f, -0.39390928f, 0.24685587f, -0.18208922f, 0.17920455f, 
    0.35563377f, -0.10008238f, 0.07559606f, -0.16738033f, 0.19916750f, -0.00525666f, -0.05903378f, 0.01567924f, 
    0.10445172f, -0.01510999f, 0.05665781f, 0.00725511f, -0.00397400f, 0.22701333f, -0.18254673f, 0.11319946f, 
    -0.38961384f, 0.17675179f, -0.14422819f, 0.13173328f, -0.56431919f, 0.21074106f, 0.06162592f, -0.17427655f, 
    -0.30459523f, -0.04642729f, -0.06978334f, 0.04464033f, 0.01622143f, -0.01837936f, -0.00434428f, -0.23661730f, 
    -0.05299140f, -0.12861100f, -0.28228158f, -0.26811546f, -0.45244488f, -0.59543377f, 0.27634177f, 0.13017599f, 
    0.39710531f, -0.05871822f, 0.00995038f, 0.03106013f, -0.09323864f, 0.04162652f, 0.09391877f, 0.15644291f, 
    -0.11675526f, 0.02051774f, 0.00080624f, 0.26916197f, -0.02479278f, -0.04885058f, 0.17438471f, -0.04794899f, 
    0.22815078f, 0.06452820f, 0.39629227f, 0.22899641f, -0.17634036f, 0.04517861f, -0.15883638f, 0.06725825f, 
    -0.05131433f, -0.04361909f, -0.06588940f, -0.02740459f, 0.00233718f, -0.00053947f, -0.05075300f, 0.05901666f, 
    -0.27292088f, 0.12783062f, 0.12319905f, -0.13288559f, 0.19683221f, -0.03533586f, 0.09934777f, 0.17452510f, 
    0.13451281f, -0.13283865f, -0.02310413f, -0.02026877f, -0.03327164f, -0.06997977f, 0.17877041f, 0.18196931f, 
    0.07259952f, 0.01597311f, 0.03155966f, -0.12819330f, -0.06624109f, -0.01195004f, -0.04587403f, -0.06201531f, 
    -0.06094105f, 0.43754193f, 0.08535880f, 0.02877682f, -0.01103931f, 0.09520186f, -0.08596922f, 0.12474949f, 
    0.06079086f, 0.02654836f, 0.04222100f, 0.00900031f, 0.03852639f, -0.17725685f, 0.10693618f, 0.09343672f, 
    -0.09177341f, -0.08744090f, -0.00204215f, -0.01192234f, -0.21695539f, 0.12845421f, -0.47891471f, -0.40560111f, 
    -0.01996773f, 0.16193831f, -0.28678963f, -0.06931798f, 0.14622526f, -0.10770091f, -0.05298397f, 0.04416215f, 
    0.05362178f, -0.06139661f, 0.04342341f, 0.05849447f, -0.14156000f, -0.37735325f, -0.35581040f, -0.45834222f, 
    0.21267353f, 0.17096066f, -0.15299730f, -0.40078008f, -0.22940730f, -0.17879727f, -0.23298731f, -0.35121766f, 
    -0.48053667f, 0.08559116f, -0.08488598f, -0.00186501f, 0.02848528f, 0.10090195f, -0.01203698f, -0.02735475f, 
    0.08393525f, -0.09910028f, 0.12719554f, 0.08082612f, 0.25572658f, 0.04399679f, -0.02976260f, 0.18358390f, 
    0.14913502f, -0.07381154f, -0.05969204f, 0.01073079f, -0.06325229f, -0.07613769f, 0.00115900f, -0.01669468f, 
    -0.07222508f, 0.01449114f, 0.03919970f, 0.12762594f, 0.00666718f, -0.10588720f, 0.14849585f, -0.11190245f, 
    -0.32062897f, 0.29415333f, -0.19392622f, 0.00826440f, 0.15040095f, 0.11772907f, 0.11458487f, 0.29876220f, 
    -0.15742078f, 0.05072163f, -0.06092863f, 0.02087392f, -0.06402179f, -0.02805882f, 0.00389905f, 0.07694396f, 
    -0.01931950f, -0.04895168f, -0.13658407f, 0.03994352f, -0.14757770f, 0.03352894f, -0.15818931f, -0.14129134f, 
    -0.15130824f, 0.02381626f, -0.02158770f, 0.10472406f, 0.25922051f, -0.20252350f, 0.18219806f, 0.04443093f, 
    0.11941306f, 0.11790602f, 0.02729066f, 0.00019595f, -0.02584550f, 0.12442038f, 0.04417050f, -0.00910257f, 
    -0.09346674f, 0.05329108f, 0.01881738f, -0.05051976f, 0.12997445f, 0.06506391f, -0.20018999f, 0.00834219f, 
    -0.01379671f, -0.01988103f, -0.16743468f, -0.08666428f, 0.17997302f, -0.00226813f, -0.06443619f, -0.34233984f, 
    0.20573127f, 0.04079535f, 0.03480715f, 0.01623754f, 1.09618664f, 0.04766895f, 0.08606804f, 0.21784812f, 
    -0.09551317f, -0.03211484f, 0.03465449f, -0.00802886f, -0.04596400f, 0.00547989f, -0.20398065f, -0.00805864f, 
    -0.16543917f, 0.02026018f, 0.10822362f, 0.01367583f, -0.03615350f, -0.11720890f, 0.05164101f, -0.10441837f, 
    0.63095099f, -0.06528380f, -0.19326533f, -0.16334417f, 0.00009651f, -0.02859775f, -0.06767254f, -0.05240436f, 
    -0.03911579f, 0.00455790f, -0.07962476f, 0.10262159f, 0.01662060f, -0.07223868f, 0.00776077f, -0.22633511f, 
    -0.07570591f, -0.27788562f, 0.20868106f, 0.15482949f, 1.18699408f, 0.36194062f, -0.54472965f, -0.19566049f, 
    -0.22156227f, -0.08819467f, 0.08936097f, -0.10110889f, -0.01893833f, 0.05541489f, 0.15101017f, -0.07175658f, 
    0.10045765f, -0.24241762f, -0.02726515f, -0.09252076f, 0.14291227f, -0.10670798f, -0.14003815f, 0.21080001f, 
    -0.19119915f, -0.27844256f, 1.10497832f, 0.33192191f, 0.42281502f, -0.07300339f, 0.00705507f, 0.12872246f, 
    0.15589716f, -0.11834595f, 0.06254444f, 0.06814056f, 0.02365545f, -0.23435155f, 0.13408391f, 0.05948878f, 
    -0.00877859f, 0.07899439f, 0.03122428f, 0.05340790f, -0.23698792f, -0.85652059f, -1.11800480f, 0.06721445f, 
    -0.75331521f, 0.11303612f, 0.29758245f, -0.10334687f, 0.29509813f, -0.04636344f, -0.04852130f, 0.02105718f, 
    -0.03238106f, 0.05267899f, -0.06151806f, -0.03356658f, 0.04994143f, 0.00601610f, -0.31865522f, 0.03612712f, 
    -0.39267623f, -1.41086745f, -0.08544534f, -0.31577531f, -0.27218908f, 0.08808903f, -0.07467210f, -0.16055794f, 
    -0.00155241f, -0.29430628f, -0.05806047f, -0.04839988f, 0.04597398f, -0.12615706f, 0.01815021f, -0.18059643f, 
    -0.08841196f, 0.05777861f, 0.20149674f, 0.23527589f, 0.17771475f, -0.09043639f, -0.68165445f, -0.00130130f, 
    0.08545896f, -0.00036507f, 0.03181259f, -0.03473629f, 0.01110788f, -0.03724615f, -0.15287876f, -0.11711023f, 
    0.02750865f, 0.00563433f, -0.06732072f, 0.00832419f, 0.20137045f, 0.19041903f, -0.11160672f, 0.04803960f, 
    -0.26261392f, 0.26823354f, 0.49909249f, -0.07906199f, -0.41969490f, 0.01890876f, -0.02676941f, -0.00430891f, 
    -0.03514479f, 0.15461075f, -0.05601508f, 0.05148952f, -0.08610540f, 0.07376851f, 0.07641421f, 0.13603644f, 
    -0.13088444f, -0.02097743f, 0.15690540f, -0.10531650f, 0.00182013f, -0.16784014f, -0.10518653f, -0.07987691f, 
    0.12527622f, -0.02794962f, -0.02659364f, 0.05685521f, 0.02376265f, 0.06744584f, -0.12011541f, -0.03662665f, 
    -0.01375285f, 0.01066818f, 0.00511841f, 0.06053947f, 0.01337653f, -0.05129610f, 0.00287566f, -0.08167327f, 
    -0.07391626f, -0.29753205f, -0.04699475f, 0.52700919f, 0.47871673f, -0.03646984f, 0.02447668f, -0.06087806f, 
    -0.05308075f, 0.08539804f, 0.03439876f, -0.05648936f, 0.01900834f, 0.00014248f, -0.01268235f, 0.15757625f, 
    0.17913970f, -0.02414009f, -0.25453094f, 0.15986881f, -0.72623765f, 0.00817073f, 0.05371399f, -0.22449559f, 
    -0.44491094f, 0.08282414f, -0.23829234f, -0.06472135f, 0.08594938f, -0.16922276f, 0.04601049f, 0.01174770f, 
    -0.00719854f, -0.02174427f, -0.10709266f, -0.19186433f, -0.02766920f, 0.32177502f, 0.05698790f, 0.10587512f, 
    -1.31349862f, 0.08170967f, 0.37632686f, -0.12451013f, -0.23212285f, -0.30843616f, 0.21991310f, -0.20710512f, 
    -0.38555503f, 0.15331298f, 0.00989037f, -0.04729292f, 0.03980425f, 0.06230811f, -0.02661867f, -0.01889071f, 
    -0.02750126f, -0.08079097f, -0.33245349f, -0.06720051f, -0.22298874f, -0.23180877f, 0.20744540f, -0.50988346f, 
    0.16173205f, 0.09437574f, -0.05948222f, -0.07470284f, 0.10487792f, 0.05363163f, -0.01343990f, 0.01557701f, 
    -0.00737577f, 0.05588857f, -0.10557645f, 0.11314771f, -0.08059629f, -0.14172970f, 0.06712460f, -0.02008322f, 
    -0.05817594f, 0.53969175f, 0.13519444f, 0.40558219f, 0.40669325f, 0.08047248f, -0.03823261f, 0.25482383f, 
    0.07423476f, 0.02470299f, -0.07200065f, 0.14734586f, 0.01169857f, 0.02057529f, 0.06938870f, 0.04029365f, 
    0.03404591f, -0.03951526f, -0.10058719f, -0.00415821f, -0.21031636f, -0.19412868f, -0.14654751f, -0.12089001f, 
    -0.07896741f, 0.05759658f, -0.49064741f, -0.56859958f, -0.18357505f, -0.42988658f, 0.08604681f, -0.11216444f, 
    0.11027034f, -0.01574883f, -0.05319775f, -0.02579361f, -0.09919060f, -0.11374106f, 0.00971472f, -0.16898012f, 
    0.15315723f, 0.18611291f, 0.08017516f, -0.09528559f, 0.31324467f, 0.02903984f, 0.04295754f, -0.12755518f, 
    0.07739189f, 0.08690821f, 0.05493345f, -0.05683530f, 0.04859111f, -0.06267571f, 0.04847829f, 0.07923865f, 
    -0.13375635f, -0.07693042f, 0.03953382f, 0.06388243f, -0.32586646f, -0.01164166f, 0.09267925f, -0.08680724f, 
    -0.06167013f, 0.00027606f, -0.04246372f, -0.07438220f, -0.03085238f, 0.15747987f, -0.04340400f, 0.04237525f, 
    -0.04764954f, 0.07371888f, 0.03117989f, 0.07850152f, 0.07359482f, 0.15031110f, 0.18834238f, -0.08921709f, 
    -0.12577026f, -0.21760613f, 0.22218162f, -0.51569426f, -0.31142884f, -0.03056800f, -0.02842552f, -0.10178667f, 
    0.09343348f, 0.03656323f, 0.01423351f, -0.07518789f, 0.00889282f, 0.04647783f, 0.07722595f, 0.19603369f, 
    -0.10262729f, -0.38566104f, 0.24710551f, 0.00666206f, -0.21912417f, 0.71962827f, 0.05040511f, 0.18007280f, 
    -0.18598749f, -0.00929760f, 0.02776376f, -0.23129229f, -0.03719779f, 0.27339634f, 0.12591630f, 0.26634288f, 
    0.13636445f, -0.03063780f, 0.15353273f, -0.05963637f, -0.03397705f, 0.15796961f, 0.04563838f, -0.14540766f, 
    0.28949857f, 0.39727929f, -0.20683429f, -0.16923715f, 0.38237923f, 0.47456074f, 0.07102409f, 0.00449813f, 
    -0.11838786f, -0.15659647f, -0.47225946f, -0.00040811f, 0.00479619f, -0.05655485f, 0.05312165f, -0.18232264f, 
    0.11048622f, -0.12038050f, 0.11167590f, 0.16660717f, 0.05861374f, -0.07475372f, -0.33593792f, -0.02788263f, 
    0.34827816f, 0.13987122f, 0.08078618f, -0.07430564f, 0.13603508f, -0.01273626f, 0.03353880f, -0.05440285f, 
    0.02128274f, -0.09246565f, 0.02901064f, -0.03106126f, -0.18399702f, 0.12941734f, -0.21814515f, 0.04130493f, 
    0.36918238f, -0.26402986f, -0.00292315f, -0.10089089f, 0.52769560f, -0.22006120f, 0.26627475f, 0.10452338f, 
    0.19877996f, 0.10927659f, -0.14059988f, -0.03504026f, -0.13324563f, -0.26655400f, -0.01183348f, 0.02378271f, 
    -0.04603793f, 0.06981532f, 0.12081087f, 0.10143846f, 1.20488918f, 0.61365169f, -0.07764865f, -0.20447478f, 
    -0.82629031f, 0.07761443f, 0.08789590f, -0.05369964f, 0.34184423f, 0.06246289f, -0.01270178f, -0.22980727f, 
    0.24556591f, 0.06784283f, 0.02231487f, 0.09002371f, 0.04229787f, -0.30629531f, 0.06678316f, -0.00610068f, 
    0.19684479f, -0.50594723f, 0.03725378f, 0.49082813f, 0.47838187f, -0.18588640f, -0.11322597f, -0.55520797f, 
    -0.04083664f, -0.12080077f, -0.01666813f, -0.02491943f, 0.07107591f, 0.02306990f, -0.06020121f, -0.10516871f, 
    0.13244782f, 0.19226632f, -0.12505467f, 0.06301025f, -0.54127347f, -0.48510236f, -0.43228731f, -0.25130624f, 
    -0.40558362f, 0.28825286f, -0.00151963f, 0.03597913f, -0.20433326f, -0.09713633f, -0.24929903f, 0.02446185f, 
    0.02697679f, -0.24402061f, -0.11727010f, 0.04713175f, 0.08539106f, -0.24505614f, -0.05044541f, -0.03943733f, 
    -0.24207130f, 0.35473680f, -0.28170013f, -0.51579648f, 0.25827312f, 0.07788241f, 0.11875849f, -0.28498483f, 
    0.28511918f, -0.03740576f, -0.07791606f, -0.01801880f, 0.01056065f, -0.00006355f, -0.06049777f, -0.09866013f, 
    0.12083766f, -0.02076287f, -0.16409940f, -0.08699313f, -0.15913661f, -0.25484741f, 0.33226624f, 0.11079006f, 
    0.30763361f, -0.07495862f, 0.08756935f, 0.12835687f, -0.07000473f, 0.00012339f, 0.01519083f, 0.01379981f, 
    0.06587713f, -0.04568167f, 0.14604305f, -0.00168929f, -0.09274483f, 0.12688875f, -0.13533555f, 0.09453663f, 
    -0.53491467f, -0.37223613f, 0.53185713f, 0.39779079f, 0.15410790f, -0.19763623f, -0.13245127f, 0.30384269f, 
    -0.21341766f, -0.13742362f, 0.20986336f, 0.17796908f, -0.38773313f, 0.04052160f, 0.30410352f, -0.04575273f, 
    -0.03415672f, 0.07460220f, -0.02107984f, -0.06285184f, -0.44538832f, -0.28722918f, -0.58081943f, 0.13614401f, 
    -0.30908811f, 0.01598419f, -0.37725237f, -0.02167199f, 0.11302090f, 0.06457447f, 0.02902207f, 0.04124834f, 
    0.10327565f, -0.10583021f, -0.08145049f, -0.09148671f, 0.01343289f, -0.07195558f, -0.05460897f, 0.03642918f, 
    0.13728273f, -0.09428260f, -0.25018165f, -0.08898263f, 0.45122790f, 0.05139273f, -0.12939748f, 0.01043040f, 
    -0.03054768f, -0.25721648f, -0.06673129f, -0.00605365f, 0.05679237f, 0.05132160f, 0.14263718f, 0.06175454f, 
    -0.07411743f, 0.14454229f, -0.07119136f, -0.05602478f, -0.00951030f, -0.02240529f, -0.35691148f, -0.01405701f, 
    0.19202185f, 0.07440806f, 0.19793487f, 0.17639770f, 0.01572689f, 0.11659902f, 0.07632565f, -0.20824298f, 
    0.14822601f, -0.12487751f, -0.08618742f, 0.24845001f, 0.05403574f, 0.30437061f, 0.13315830f, -0.07973717f, 
    0.05658287f, 0.81405151f, 0.65474546f, -1.15333378f, 0.41599813f, -0.22899202f, -0.05179948f, -0.14701153f, 
    -0.33837891f, -0.18343987f, 0.10166665f, -0.14135872f, -0.16388124f, 0.10381936f, -0.04327511f, 0.03700679f, 
    -0.05734126f, -0.03697516f, -0.29511985f, -0.00434217f, -0.95721579f, 0.32807538f, 0.10546245f, 0.23789920f, 
    0.01333184f, 0.38949144f, -0.16557695f, 0.39596462f, -0.02913211f, -0.02014840f, 0.11273499f, -0.00923160f, 
    -0.01997278f, 0.07302577f, -0.05836581f, -0.20175019f, 0.01246412f, -0.14480475f, -0.01752361f, -0.04971876f, 
    -0.35960028f, 0.10231668f, 0.07250634f, 0.21512948f, -0.37855777f, -0.18357658f, -0.19854845f, -0.04126319f, 
    0.25285092f, -0.08343741f, -0.11338440f, -0.12839176f, 0.07904042f, -0.03646214f, 0.01421619f, -0.08905058f, 
    0.07644071f, -0.13780679f, 0.09090467f, -0.05349682f, -1.38751650f, 0.54243630f, 0.34609720f, -0.62431639f, 
    0.52878582f, -0.01538379f, -0.03879392f, -0.06299198f, -0.50989914f, -0.18900698f, -0.18217525f, 0.03050582f, 
    -0.09280556f, 0.09459428f, 0.00913737f, 0.02318739f, 0.12107316f, 0.33689946f, -0.23469730f, -0.25118771f, 
    -0.21441878f, -0.46835139f, 0.50763500f, 0.05527754f, -0.06528725f, -0.41862544f, -0.08097684f, -0.11928112f, 
    0.02239254f, 0.17437975f, 0.01544320f, 0.01528174f, -0.12205917f, -0.13271208f, 0.04407069f, 0.03907879f, 
    0.03475126f, 0.01985877f, -0.05628158f, -0.00535164f, 0.08311261f, 0.22719792f, 0.46011102f, 0.39558390f, 
    0.16084364f, -0.30678174f, -0.10470913f, -0.01809421f, -0.12102526f, 0.11781384f, 0.01747581f, -0.00636998f, 
    0.00287199f, 0.08579785f, 0.08421758f, -0.04117472f, -0.02803445f, -0.17153643f, -0.15117377f, -0.16047011f, 
    0.06481529f, 0.10376504f, 0.09851468f, 0.26812068f, 0.06812050f, -0.04317622f, 0.11119665f, 0.07267335f, 
    0.13467103f, 0.12754764f, 0.04883676f, -0.00755962f, -0.00162352f, 0.04336923f, -0.00865708f, -0.05033656f, 
    0.17489867f, 0.03886015f, 0.18385902f, 0.20815843f, -0.53092033f, -0.28374031f, -0.32431716f, -0.43852550f, 
    -0.50974476f, 0.09345303f, -0.01055071f, -0.03572242f, 0.10116870f, 0.13508818f, 0.02493248f, -0.10954485f, 
    0.07647873f, -0.06308083f, -0.04365588f, -0.14517251f, 0.09818707f, 0.08945855f, 0.09776404f, 0.27535436f, 
    -1.01521540f, 0.15053229f, -0.32854000f, -0.65250468f, -0.24540034f, 0.06756830f, -0.05436220f, -0.01758236f, 
    0.01389783f, 0.04352430f, -0.08089837f, -0.05145379f, 0.17612447f, 0.02185957f, -0.03775785f, -0.17503154f, 
    -0.04515807f, -0.11701252f, -0.13098098f, -0.07718457f, 0.14948377f, 0.04244497f, -0.05843342f, -0.10784028f, 
    -0.04593508f, 0.07631522f, 0.02836681f, 0.05498636f, 0.01312898f, 0.06720494f, -0.03407182f, -0.09073342f, 
    -0.00620429f, -0.03369072f, 0.00500138f, 0.11438459f, 0.04314542f, -0.05358775f, -0.09346213f, 0.07058434f, 
    -0.53572226f, -0.33335820f, -0.20137672f, -0.01534064f, -0.06063926f, -0.31192791f, 0.00548471f, 0.11414311f, 
    -0.43506601f, -0.08876666f, -0.00453945f, 0.10752702f, -0.02276265f, 0.10485335f, -0.00860103f, -0.13281116f, 
    0.12473712f, 0.18889196f, 0.12248769f, 0.23215006f, 0.25383219f, 0.04476556f, 0.02661708f, 0.21478054f, 
    -0.07309390f, 0.02884879f, 0.02857638f, -0.04470843f, 0.12647697f, 0.18056035f, -0.12501557f, 0.01661851f, 
    -0.02796522f, -0.05264487f, -0.04428561f, 0.07586022f, 0.12310216f, -0.29614401f, 0.07124566f, 0.35254127f, 
    0.11318421f, -0.06701279f, -0.04455875f, -0.02890201f, 0.68857759f, 0.01732327f, 0.28539312f, 0.15461853f, 
    0.22220422f, 0.03410508f, 0.02731395f, -0.05623343f, -0.03732046f, -0.12176128f, 0.03164075f, -0.03388008f, 
    -0.14419250f, -0.00456536f, -0.05671677f, -0.24844413f, 0.14165561f, 0.07921269f, 0.00000788f, -0.04124302f, 
    -0.03195842f, 0.18187249f, 0.00520112f, 0.04862487f, -0.01233970f, 0.06796194f, 0.10724270f, -0.01415452f, 
    -0.05927564f, 0.03171256f, -0.01429605f, 0.05566831f, 0.15682818f, 0.00907836f, -0.03572692f, 0.06592084f, 
    0.06202002f, 0.17896314f, 0.33118910f, 0.22627701f, 0.20408911f, -0.15915860f, -0.03776134f, -0.09248397f, 
    -0.12325087f, -0.00572271f, 0.09537084f, 0.02805906f, 0.00557711f, 0.03487265f, -0.03137081f, 0.03118994f, 
    -0.06180370f, -0.06304953f, 0.07908016f, -0.07845548f, 0.06698804f, 0.07600555f, 0.21078919f, 0.02744543f, 
    0.00201671f, 0.17596599f, 0.19416384f, -0.18382089f, 0.09011275f, 0.30541545f, -0.04960740f, 0.02271261f, 
    -0.02780549f, -0.08931258f, 0.04563154f, -0.12595667f, -0.09106372f, -0.38254932f, -0.15796155f, -0.43498534f, 
    0.05455801f, -0.12084994f, -0.32364231f, 0.06002863f, -0.04902088f, 0.18867503f, -0.02894738f, -0.18631649f, 
    -0.09831055f, -0.03183245f, 0.10565570f, -0.14197609f, -0.15178806f, -0.11346027f, 0.07642177f, -0.03135488f, 
    -0.27797329f, 0.01147112f, -0.13451304f, -0.19521105f, -0.05953072f, 0.19328900f, -0.02445365f, -0.44464418f, 
    -0.28707796f, 0.12230780f, 0.00618602f, -0.07119402f, 0.06822907f, 0.10243540f, 0.11028246f, 0.08107258f, 
    0.04376760f, 0.06889606f, 0.00212245f, 0.02806029f, 0.08459358f, -0.14752747f, 0.01969619f, 0.04893583f, 
    -0.20453191f, 0.47703877f, -0.39688197f, -0.01940231f, 0.06438696f, 0.07433621f, 0.03040745f, -0.02032533f, 
    0.05874716f, 0.03273994f, 0.11888037f, 0.07188378f, 0.01573319f, -0.00205418f, -0.00145048f, 0.09340891f, 
    0.01704136f, 0.11548813f, -0.21285945f, -0.05009057f, 0.06509422f, -0.68764824f, -0.08544344f, 0.03720140f, 
    -0.37459248f, -0.09263016f, -0.04989701f, 0.06464860f, -0.04352581f, -0.43967596f, 0.00964336f, -0.18927935f, 
    -0.23709564f, 0.13749993f, -0.09570141f, -0.11834425f, -0.14868711f, -0.10144114f, -0.10814768f, -0.19983229f, 
    -1.11034596f, 0.48899850f, -0.68071973f, -0.51676971f, -0.20743619f, -0.04883439f, 0.00667669f, -0.03306606f, 
    -0.10509052f, 0.09772836f, 0.01967447f, -0.04475327f, -0.05650271f, 0.01217130f, -0.11813056f, -0.14181606f, 
    -0.15136312f, 0.17670478f, -0.15878870f, -0.03007911f, 0.25161526f, -0.20409994f, 0.51880568f, -0.04578417f, 
    -0.50379097f, 0.21993928f, 0.07433101f, 0.20363751f, -0.07267811f, -0.11766232f, 0.16748488f, 0.01554620f, 
    -0.07671754f, 0.03270992f, 0.09059609f, -0.08693898f, 0.05486288f, -0.16862027f, 0.18513660f, 0.13751137f, 
    0.23570795f, 0.21013705f, 0.34891745f, 0.14269045f, 0.02329561f, 0.00175690f, -0.20267221f, 0.02855013f, 
    0.22611818f, 0.06197351f, 0.10508609f, 0.02519078f, 0.01798660f, 0.08553804f, 0.00618338f, 0.20964287f, 
    -0.03973544f, -0.21023801f, -0.41935661f, -0.47002113f, 0.26832730f, 0.21436551f, -0.10904577f, -0.01048422f, 
    -0.01855282f, 0.05667083f, -0.08219995f, -0.02633746f, -0.06157808f, -0.00936171f, -0.09150006f, -0.09279479f, 
    -0.16422179f, -0.00474412f, 0.09675884f, -0.10895815f, -0.12022427f, 0.03655286f, -0.14862524f, -0.05729400f, 
    0.85627896f, 0.06984662f, -0.49907786f, -0.67125517f, 0.33350423f, 0.10354598f, 0.19768035f, -0.08653144f, 
    -0.12925452f, 0.13703589f, 0.10393208f, 0.03667687f, -0.06412798f, -0.01069576f, 0.07927825f, 0.00523078f, 
    0.23622620f, -0.15771310f, 0.04684322f, 0.10042594f, 0.01517124f, -0.12019245f, -0.37141272f, -0.00589389f, 
    0.05373842f, 0.07203736f, 0.02323162f, -0.14691687f, -0.05414611f, 0.03818002f, 0.05648070f, 0.04760686f, 
    -0.05324868f, 0.12567379f, 0.20676494f, -0.05981950f, 0.10438291f, 0.18470426f, 0.12280882f, 0.01425635f, 
    0.24659428f, -0.23075174f, 0.09768764f, 0.01986869f, -0.34892493f, -0.02717316f, -0.18839987f, -0.00922783f, 
    -0.08623751f, 0.00631690f, 0.05831715f, 0.05764741f, -0.10271628f, -0.12232430f, 0.06948385f, -0.07241547f, 
    -0.23284873f, -0.02766617f, -0.32044631f, -0.16099900f, 0.14531516f, 0.03774751f, 0.38983694f, 0.06609020f, 
    -0.23900664f, -0.09468704f, 0.18165390f, 0.04670189f, 0.21379581f, 0.04494652f, 0.06016777f, 0.10518141f, 
    0.05600681f, 0.01394069f, 0.06488664f, -0.12099561f, -0.03387090f, 0.05275908f, 0.03864480f, -0.25748032f, 
    -0.01081131f, -0.31349134f, -0.21061212f, 0.24427077f, -0.10654006f, 0.15532506f, 0.07863237f, -0.05671751f, 
    0.08051685f, 0.16195035f, 0.06883825f, 0.04814218f, -0.05591958f, -0.03419553f, 0.04334400f, -0.01047574f, 
    0.04079475f, 0.08026135f, -0.10445584f, 0.11856556f, -0.22173843f, -0.08129777f, -0.24794410f, -0.03850887f, 
    0.20815961f, 0.09648630f, 0.00134311f, -0.09770914f, -0.01516323f, -0.08463793f, 0.15679561f, -0.04555386f, 
    -0.03445075f, -0.00859017f, 0.01742112f, -0.15954991f, -0.09580272f, -0.01382769f, -0.12966549f, -0.07187323f, 
    -0.15101305f, -0.16901168f, -0.03415634f, 0.11710819f, -0.37242162f, -0.13231990f, 0.08534307f, 0.01851574f, 
    0.06324954f, 0.26196864f, 0.04111512f, -0.07656977f, -0.01821135f, -0.05510078f, -0.12779550f, -0.09711642f, 
    0.07671188f, 0.06525976f, 0.08902146f, 0.04699565f, 0.17735510f, 0.05979060f, 0.07679396f, -0.33432850f, 
    -0.00295100f, -0.25262851f, -0.04330435f, 0.03401572f, -0.12856914f, -0.01721180f, -0.23759107f, -0.17136915f, 
    -0.11000150f, 0.03275147f, -0.00073885f, 0.04338240f, 0.19398972f, -0.01558779f, -0.04249070f, 0.46728849f, 
    -0.25975108f, -0.28245059f, -0.08542038f, 0.37165689f, -0.04488099f, -0.05535727f, 0.14999178f, -0.07979151f, 
    0.08546218f, 0.13658130f, 0.05912686f, 0.07360529f, 0.01544491f, -0.01647752f, 0.05562318f, 0.31241453f, 
    -0.16176385f, -0.06503970f, -0.04571577f, 0.19838786f, -0.27413583f, -0.25188088f, -0.01554774f, -0.10551081f, 
    0.41656652f, -0.02850006f, 0.03245033f, -0.07557203f, -0.05417855f, -0.06700278f, 0.21231382f, -0.07446466f, 
    0.03878328f, -0.14815293f, 0.06294626f, -0.14348039f, -0.11911756f, 0.32291156f, 0.10129414f, 0.01574053f, 
    0.14494804f, -0.06035389f, -0.18742661f, -0.00673986f, 0.15473983f, -0.02013555f, -0.01249654f, 0.05487870f, 
    -0.08574845f, -0.00878927f, 0.18048786f, -0.20105650f, 0.03966304f, 0.00866203f, -0.02614997f, -0.04089980f, 
    -0.23566712f, 0.38051915f, 0.07094477f, -0.31062752f, -0.01692355f, -0.24181317f, 0.27319607f, -0.08851340f, 
    0.12971565f, -0.04967172f, 0.08807505f, -0.10522202f, -0.05272622f, 0.04429636f, 0.08505554f, 0.09050550f, 
    0.04860543f, -0.12855388f, -0.08887035f, 0.06404400f, -0.18805982f, -0.06620476f, 0.40279162f, 0.05080377f, 
    -0.58107871f, 0.27915490f, 0.70650017f, 0.10861389f, 0.56752264f, -0.24416678f, -0.14834245f, -0.01526779f, 
    -0.17656477f, 0.23460244f, -0.02985484f, 0.13771367f, 0.26381063f, 0.15871064f, 0.00762837f, 0.02608911f, 
    -0.00150509f, 0.08013767f, 0.10767021f, 0.06040325f, -1.26499665f, -1.54107118f, -0.83057165f, -0.24033837f, 
    0.29161385f, -0.17691146f, -0.08195280f, -0.27375519f, -0.14642809f, -0.47702938f, -0.01229477f, -0.01332209f, 
    -0.05867311f, -0.14801952f, 0.04443207f, 0.03837749f, 0.04731874f, 0.04153473f, 0.39314494f, -0.01341060f, 
    -0.78690034f, -0.67268366f, -1.38423336f, -0.23601054f, -0.22576521f, -0.22166604f, 0.11219965f, -0.17591183f, 
    0.11402451f, -0.40977132f, 0.05202962f, -0.09513836f, -0.00210306f, 0.09494910f, 0.10101105f, -0.03733516f, 
    -0.12006392f, 0.28153133f, 0.09545849f, -0.01953208f, -0.24248204f, 0.26509908f, -0.14256935f, -0.26694834f, 
    0.04854833f, -0.07390378f, 0.01236486f, -0.09317262f, 0.02980190f, 0.12880692f, -0.11357038f, -0.13243812f, 
    0.09954699f, -0.01788651f, -0.11143823f, -0.04129679f, 0.21614255f, 0.02757103f, -0.01946313f, -0.13992210f, 
    0.23272358f, 0.08117308f, 0.07761753f, -0.36589363f, 0.04087185f, 0.03771794f, 0.01246373f, 0.14998882f, 
    0.13800225f, -0.24398504f, 0.07224140f, 0.07045327f, 0.15167132f, -0.08835199f, 0.00128018f, 0.18489425f, 
    0.00197504f, 0.06134360f, -0.12949933f, 0.07034049f, 0.00009531f, 0.04970720f, 0.04670835f, -0.06378036f, 
    0.05445963f, 0.02202598f, 0.01372663f, -0.05317022f, -0.07015502f, 0.12034488f, -0.03261549f, -0.01680885f, 
    0.18425776f, 0.03424174f, -0.00701448f, 0.00907740f, -0.06006515f, -0.05990367f, -0.04919001f, -0.07013869f, 
    0.31454909f, -0.31977281f, -0.96922624f, 0.01325283f, 0.30120069f, -0.10587702f, -0.19099368f, -0.03327744f, 
    -0.06758693f, 0.05874085f, -0.11278763f, -0.10017201f, 0.01268514f, 0.03645995f, -0.14688176f, -0.05974501f, 
    0.23188700f, -0.02955279f, 0.31192777f, -0.17304233f, -0.66682708f, -0.66217220f, -0.83510751f, 0.04383773f, 
    0.05886847f, 0.09849937f, 0.24058415f, 0.04591308f, -0.16734549f, -0.45701262f, 0.03514252f, 0.05278450f, 
    0.02949637f, 0.01993262f, 0.04844772f, 0.03087171f, 0.00425007f, 0.20645586f, 0.23036857f, 0.12257234f, 
    0.52220821f, -0.68331540f, -1.24844551f, -0.31823269f, 0.24373473f, -0.29509044f, 0.16048490f, 0.47289315f, 
    0.05977654f, -0.08217139f, 0.04100772f, -0.05253439f, -0.19784395f, 0.00186009f, 0.13824214f, -0.03609712f, 
    -0.02343548f, 0.11733132f, 0.05884964f, 0.17511919f, 0.11383122f, -0.11521210f, -0.00601808f, -0.08664002f, 
    -0.18717667f, -0.02626757f, 0.01109181f, 0.10725378f, -0.04064105f, -0.04980018f, -0.07216811f, -0.15752691f, 
    0.00207431f, -0.20671941f, -0.12455348f, 0.05337187f, -0.08733432f, 0.05999025f, -0.09533799f, 0.09505530f, 
    -1.08922958f, 0.65633273f, 0.26702783f, -0.00762094f, -0.21182474f, -0.51422369f, -0.09186378f, -0.05336886f, 
    0.00412029f, -0.12081294f, -0.00686237f, -0.00571109f, 0.09081768f, -0.03076655f, 0.00606777f, 0.00536033f, 
    -0.07864672f, -0.05043418f, 0.14393562f, -0.16422689f, 0.05259245f, 0.07993810f, -0.13031171f, -0.06287848f, 
    0.06738075f, -0.07119263f, -0.40164217f, -0.33146426f, 0.04158551f, -0.44464323f, 0.08327535f, -0.05092445f, 
    -0.21777946f, -0.07651638f, 0.04005213f, -0.07100195f, -0.09347604f, 0.15660301f, -0.38348746f, -0.43843254f, 
    -0.05641262f, -0.35085282f, -0.24742524f, 0.06770455f, 0.34935877f, -0.06133754f, 0.23909275f, 0.06867968f, 
    -0.01033678f, 0.09200136f, 0.10611035f, -0.09239935f, -0.09631770f, -0.07310927f, 0.04179468f, -0.03382117f, 
    0.13096368f, -0.08174203f, 0.17924957f, -0.05233366f, -0.20596600f, 0.11605257f, -0.01823364f, -0.18106304f, 
    0.09719263f, -0.00549543f, 0.02369147f, 0.01488225f, -0.04136216f, 0.00349656f, 0.11749596f, -0.19305803f, 
    0.09290220f, -0.10389614f, -0.09924549f, 0.00629919f, 0.05571154f, -0.19364816f, 0.00786399f, 0.23307984f, 
    -0.19248807f, -0.21175419f, 0.18516853f, 0.13751589f, -0.21189412f, 0.03969035f, 0.04997071f, 0.07959490f, 
    -0.10044233f, -0.12962063f, -0.05120027f, -0.06992042f, 0.04724054f, -0.02358096f, -0.05488018f, 0.07255350f, 
    0.11279384f, 0.09789807f, -0.15862504f, 0.11896204f, -0.41784281f, 0.76039678f, 0.07323536f, 0.05647778f, 
    0.12606066f, 0.07275753f, 0.10525083f, 0.29680389f, 0.25585642f, 0.09008146f, 0.14446636f, 0.04218082f, 
    0.25174564f, 0.07744485f, 0.22241433f, 0.10926954f, 0.03240790f, 0.05123898f, -0.02344306f, 0.05833323f, 
    0.96814948f, -0.41850483f, -1.03534472f, -0.22278672f, -0.41644615f, 0.16913153f, -0.13208894f, -0.10283419f, 
    0.22009856f, -0.06452778f, -0.02250730f, 0.05262702f, -0.04814765f, 0.03111801f, 0.01421677f, -0.01998563f, 
    0.00976030f, -0.00874726f, 0.07040551f, 0.10891578f, 0.02634004f, -0.96418661f, 0.00362918f, 1.08706725f, 
    0.30976051f, 0.00593303f, 0.02932872f, 0.12089255f, 0.00900453f, 0.19176967f, 0.02119640f, 0.03739372f, 
    -0.13568720f, -0.05896005f, -0.03358602f, -0.02928654f, 0.07993725f, -0.13621660f, 0.05617609f, -0.10983085f, 
    -0.41601658f, -0.41461787f, 0.04876382f, 0.22301003f, -0.07944288f, 0.27950847f, -0.00266655f, 0.14535065f, 
    0.00347158f, 0.24412301f, 0.02952965f, -0.12319031f, -0.06834012f, -0.05916214f, 0.00460482f, 0.15218809f, 
    0.17798746f, -0.14577618f, -0.01567429f, 0.12649716f, 0.11444922f, 0.16148341f, -0.34313619f, 0.20068428f, 
    -0.42440763f, 0.02835808f, 0.14761667f, 0.01448535f, 0.00728357f, 0.02086383f, -0.20305695f, 0.19740178f, 
    -0.04157430f, -0.01975070f, -0.05765236f, 0.13758817f, -0.07428569f, -0.05861679f, -0.16456361f, 0.04514479f, 
    -0.33403784f, 0.08454446f, 0.10456593f, 0.01377504f, 0.12247670f, 0.03388255f, 0.07151768f, 0.16679560f, 
    -0.13962993f, -0.05601661f, 0.07303831f, -0.03420050f, 0.10276739f, -0.06367842f, 0.04018180f, 0.02628657f, 
    -0.18606165f, -0.14716527f, -0.10418949f, 0.11819012f, 0.04037973f, 0.18088125f, 0.08637834f, -0.06606268f, 
    -0.15183476f, -0.04487656f, -0.01159788f, 0.01857976f, -0.05192096f, -0.11764631f, -0.02253020f, -0.30272162f, 
    -0.39668277f, -0.36756957f, -0.31780130f, 0.07093883f, -0.06491057f, 0.00669006f, -0.00881569f, -0.06987280f, 
    0.23597518f, -0.94095933f, -0.57786179f, -0.11297439f, 0.18555881f, 0.18064456f, -0.04584429f, -0.18611123f, 
    0.13941196f, -0.03186001f, 0.00970677f, 0.12558468f, -0.13759944f, 0.11512218f, 0.02749622f, -0.11653350f, 
    -0.14534386f, -0.12544633f, 0.04507232f, -0.06409808f, -0.42212245f, -0.79122704f, 0.39141625f, 0.33032125f, 
    0.14725038f, -0.11354482f, 0.19033921f, -0.05783412f, -0.20648250f, 0.11488545f, -0.01584707f, -0.03648544f, 
    0.02549760f, -0.02528076f, -0.01068472f, 0.16590312f, 0.17052443f, -0.08352193f, -0.02774903f, -0.19008216f, 
    -0.52955210f, -0.21202371f, -0.11724373f, 0.09536215f, -0.28327402f, -0.00369157f, -0.24475083f, -0.06202295f, 
    -0.04035592f, 0.18680222f, 0.09397484f, 0.02307203f, 0.00299597f, 0.02079722f, -0.07926309f, 0.17306113f, 
    -0.05176215f, -0.11922448f, 0.01941364f, 0.09517209f, 0.01856866f, 0.08297963f, 0.14394623f, -0.09953833f, 
    -0.08122349f, -0.01245799f, 0.05990157f, -0.02334322f, 0.00955988f, -0.07166976f, 0.11786262f, 0.05508633f, 
    0.08479619f, -0.01446280f, 0.05952680f, -0.07825889f, -0.05898197f, 0.12670930f, 0.08094592f, 0.01918061f, 
    0.78590167f, -1.30616307f, -1.08384514f, -0.50934136f, -0.30350038f, 0.13663608f, 0.11765283f, -0.13872765f, 
    0.07039851f, 0.02415516f, -0.04753838f, 0.07127202f, 0.04150608f, -0.03649005f, 0.05259603f, -0.07852688f, 
    0.02023431f, 0.04640461f, -0.11221999f, -0.11673522f, -0.29239690f, -0.34109238f, 0.09770594f, 0.13569126f, 
    0.05123955f, 0.19334045f, 0.11170219f, 0.13249661f, 0.30468127f, 0.17594647f, 0.18926355f, -0.10752145f, 
    0.09046921f, 0.03353473f, 0.05433151f, 0.08107232f, 0.00812391f, -0.18252812f, -0.07446285f, -0.06361915f, 
    0.13420394f, 0.20349446f, -0.16524933f, 0.04974745f, -0.30252662f, -0.06333353f, 0.03278897f, 0.09977176f, 
    -0.03777225f, -0.15068141f, -0.04212599f, 0.08433331f, 0.09792015f, -0.03100061f, -0.08262996f, -0.02095499f, 
    -0.10525668f, 0.25670007f, -0.11572082f, -0.13482092f, -0.04954786f, -0.00531914f, 0.02202486f, 0.19146968f, 
    -0.07908110f, 0.09143805f, 0.13511026f, 0.15016720f, -0.14604113f, -0.05686672f, 0.02274710f, 0.04392610f, 
    0.01110190f, 0.09602270f, -0.04113359f, 0.15476248f, 0.00229015f, -0.27071741f, 0.09694869f, -0.03442394f, 
    -0.13313976f, 0.09372620f, 0.02948816f, 0.03026721f, -0.10341617f, -0.01551301f, -0.02238245f, 0.09659941f, 
    -0.10840100f, -0.08826555f, 0.08327126f, -0.01088698f, 0.09352421f, 0.09478512f, 0.06455152f, 0.01232804f, 
    -0.08027829f, -0.01900723f, -0.16186221f, -0.05021607f, -0.22139242f, -0.88055706f, 0.34544390f, -0.58963394f, 
    0.36927441f, 0.05343523f, -0.04266880f, 0.17838290f, -0.37650129f, 0.01581238f, -0.14191848f, -0.08342988f, 
    0.09179957f, 0.08213501f, -0.02881819f, -0.09430852f, -0.06205955f, -0.05896701f, -0.02044332f, -0.22346886f, 
    0.03748954f, -0.67617863f, -0.72738385f, -0.01712025f, 0.39654610f, -0.21946271f, 0.05292416f, 0.29808310f, 
    0.30977032f, 0.00373131f, 0.07867058f, 0.00134196f, -0.00270358f, -0.04771491f, -0.13366245f, -0.01372075f, 
    -0.07915764f, -0.03537662f, -0.06760145f, -0.18767962f, 0.54665059f, -0.38948172f, -0.57499462f, -0.30579612f, 
    -0.07114217f, 0.07850069f, -0.24085064f, 0.09488616f, 0.16250554f, 0.12178421f, -0.00798254f, 0.03553128f, 
    0.15211043f, 0.08839788f, 0.07544047f, 0.04839284f, 0.01752532f, 0.09115955f, 0.08407013f, 0.13521479f, 
    -0.01631841f, -0.26845378f, -0.30667666f, -0.26602614f, -0.23713741f, -0.01212999f, -0.25246835f, -0.08752963f, 
    -0.23124796f, -0.28730977f, 0.11699325f, 0.01744437f, 0.05688461f, -0.03466997f, 0.05869147f, 0.15044184f, 
    -0.01856736f, -0.02339476f, -0.13391256f, -0.37205741f, 0.06578598f, 0.18564770f, 0.32465425f, 0.10090180f, 
    -0.47046465f, -0.11491393f, -0.13673927f, -0.09489945f, -0.04422626f, -0.22390528f, -0.08608615f, 0.01913922f, 
    0.09821068f, -0.03017691f, -0.08548889f, -0.22265480f, -0.11921646f, -0.20484613f, -0.10051660f, -0.44704545f, 
    -1.02165818f, -0.02815222f, 0.33084530f, 0.21391878f, 0.50459516f, -0.06852781f, 0.03151552f, -0.06736655f, 
    -0.09701645f, 0.01812494f, 0.01884028f, -0.07950146f, 0.09802987f, 0.01713329f, 0.06149253f, -0.13469873f, 
    -0.09467148f, -0.02692999f, -0.14986056f, 0.10005812f, -0.31307605f, -0.03851997f, 0.09918034f, -0.14693919f, 
    -0.23676385f, -0.17427340f, 0.05976044f, -0.02103738f, 0.03553457f, 0.02473113f, 0.10721114f, 0.06595393f, 
    0.08883917f, 0.05778969f, 0.14316018f, -0.00406812f, 0.07509413f, -0.02377946f, 0.09416388f, 0.06365998f, 
    0.47330490f, 0.17198886f, -0.57565570f, -0.30963871f, 0.08076330f, 0.15537374f, -0.14243843f, -0.01544658f, 
    0.15198039f, 0.17060952f, 0.10143816f, 0.02569888f, 0.03447066f, 0.09841312f, 0.27555311f, -0.03438616f, 
    -0.19638981f, -0.07572223f, -0.35870078f, -0.71978462f, 0.51501340f, 0.21763185f, 0.36555222f, 0.00920024f, 
    -0.25384143f, 0.23852699f, -0.38690898f, -0.06001631f, -0.09559079f, -0.17856996f, -0.07139001f, 0.06241985f, 
    0.06553295f, 0.00752591f, 0.01714742f, 0.04182036f, 0.08065096f, -0.12474322f, -0.18918546f, -0.53774613f, 
    0.40390348f, 0.30465612f, 0.13028175f, 0.30244195f, -0.38460338f, 0.14199623f, -0.07212044f, -0.16710894f, 
    -0.18722440f, -0.06436156f, 0.08029665f, 0.04145323f, 0.13295877f, -0.05726095f, -0.00429465f, -0.04207687f, 
    0.03589309f, 0.15809695f, 0.07799757f, -0.04842927f, -0.55153269f, 0.27120328f, 0.25065836f, 0.03770382f, 
    -0.17771551f, -0.14020444f, -0.11128841f, -0.04738302f, 0.08952133f, -0.09603183f, -0.23527041f, -0.06654125f, 
    0.03254212f, -0.08385570f, 0.00607275f, 0.02921017f, 0.01397684f, 0.05741229f, -0.01021839f, 0.02912247f, 
    -0.28535795f, -1.02782714f, -1.43578541f, -0.46302736f, 0.28068218f, 0.10578451f, 0.14590612f, 0.19159408f, 
    0.13376698f, 0.33242577f, -0.03416729f, -0.17944968f, -0.08179221f, -0.05616700f, -0.03582589f, -0.01085971f, 
    -0.02367980f, -0.06533657f, 0.03391099f, 0.08910552f, -0.00900171f, -0.25666857f, -0.32008088f, -0.01507769f, 
    0.10235600f, -0.04721320f, -0.24659993f, -0.19515447f, -0.12524107f, -0.00025590f, -0.10078851f, 0.25367922f, 
    0.14841126f, -0.07408468f, 0.05931392f, -0.08498427f, 0.07923266f, 0.37202385f, 0.29311243f, 0.48434621f, 
    0.43515736f, 0.06116028f, 0.12994975f, -0.01193142f, -0.31633860f, 0.05434244f, -0.09099976f, 0.07987931f, 
    0.00847787f, -0.15691465f, -0.07735389f, 0.17417270f, 0.05373062f, 0.07394286f, 0.00755917f, 0.14193457f, 
    0.24119151f, 0.01915797f, 0.13962398f, 0.21570602f, -0.54014951f, 0.04318516f, 0.40261760f, 0.03020225f, 
    -0.01196639f, -0.11618963f, 0.03619929f, -0.15628895f, -0.10843670f, -0.01613362f, -0.18827647f, 0.02254712f, 
    -0.00086338f, 0.08490886f, 0.00868876f, -0.10249659f, -0.02990590f, 0.00400229f, -0.14587104f, -0.04982361f, 
    -1.06994772f, 0.09816154f, 0.38342026f, 0.14347361f, -0.08912697f, -0.11185531f, 0.01196715f, -0.19420321f, 
    -0.04956070f, 0.05926285f, -0.15840980f, -0.01127307f, -0.01752857f, -0.03172342f, -0.04564995f, 0.03744396f, 
    -0.27071312f, -0.09916553f, -0.13604149f, -0.07415978f, 0.67405361f, -0.26340246f, -0.34395629f, 0.16364346f, 
    0.27656150f, 0.27351394f, -0.05595613f, 0.17120571f, -0.05522007f, 0.27564061f, 0.12615044f, 0.31038228f, 
    0.21836403f, 0.23284601f, 0.16885194f, -0.14043576f, 0.18203889f, -0.03780478f, -0.23406155f, 0.16612969f, 
    0.04133881f, 0.21358013f, 0.34061241f, 0.71990544f, -0.49470323f, -0.09972356f, -0.25597259f, -0.49376500f, 
    -0.09513465f, -0.17278154f, 0.18935475f, -0.14164196f, 0.11836173f, 0.13694420f, 0.12090631f, 0.18611279f, 
    0.05388061f, 0.08415971f, 0.06417882f, 0.05949593f, -0.24150896f, -0.29833797f, 0.02011436f, 0.21308763f, 
    -0.29392803f, -0.16031872f, -0.46406749f, 0.17901911f, -0.02458576f, 0.12531903f, -0.01192626f, 0.06070061f, 
    0.00661289f, -0.03893088f, -0.06077572f, 0.11198035f, 0.02241706f, -0.04993972f, 0.14383243f, -0.21868888f, 
    -0.42754504f, -0.52000904f, -0.50877601f, 0.13051930f, -0.03412198f, -0.00259321f, -0.18354549f, 0.05633579f, 
    -0.23198868f, 0.10748369f, 0.05708116f, 0.04983608f, 0.03086552f, 0.09644186f, -0.00326114f, -0.04564632f, 
    0.11097804f, 0.34774613f, 0.08214519f, 0.14164355f, -0.23050869f, 0.24785919f, -0.23097287f, 0.35802323f, 
    0.15321308f, -0.02047471f, -0.08976725f, 0.07168005f, 0.11170408f, -0.10535941f, 0.00367424f, -0.03329949f, 
    0.00688667f, -0.04428961f, -0.15114029f, -0.02509273f, -0.00748776f, 0.08848801f, 0.20383509f, 0.21592693f, 
    -0.01634794f, -0.18926816f, -0.40917000f, -0.37166452f, -0.05065647f, -0.04376255f, -0.05226589f, 0.14146625f, 
    0.02153981f, 0.11770474f, -0.04072717f, -0.05798414f, -0.04979716f, -0.16595058f, 0.02637706f, 0.10611048f, 
    0.26747081f, -0.02850863f, -0.15279700f, 0.18550962f, -0.14293665f, 0.10418621f, 0.15487461f, 0.08607730f, 
    0.19107082f, 0.01864047f, 0.05472243f, -0.08253101f, -0.02824261f, -0.28995249f, 0.14347580f, 0.23497492f, 
    0.15172465f, -0.00482207f, -0.04808821f, 0.24303922f, -0.03110499f, -0.04935705f, -0.12359656f, 0.04273941f, 
    -0.18086898f, 0.38457766f, -0.30994144f, 0.66231436f, -0.73939657f, -0.02073456f, 0.06330294f, -0.15707675f, 
    0.22182500f, -0.00343465f, 0.15522894f, -0.05193150f, 0.16374876f, 0.09169507f, 0.07492759f, 0.02404142f, 
    0.08512256f, 0.01760304f, 0.19895741f, 0.31943518f, 0.62952489f, -0.53250444f, -0.94922405f, 0.18621357f, 
    -0.08346721f, -0.28669873f, 0.16148177f, -0.01396425f, 0.02054388f, 0.23505853f, 0.03870082f, -0.04393030f, 
    -0.06893424f, -0.00777733f, -0.09027147f, -0.09058021f, 0.02693808f, 0.02435077f, 0.14379603f, 0.13364546f, 
    -0.07445312f, 0.36394349f, -0.97079635f, -0.13945024f, -0.08497604f, 0.48566502f, 0.03491826f, 0.36363897f, 
    -0.26236564f, 0.04999844f, 0.09622946f, -0.11634552f, -0.07557376f, -0.10478710f, -0.08220047f, -0.01584349f, 
    -0.06968479f, -0.12407156f, -0.08817827f, -0.21155706f, -0.09628843f, -0.21900672f, -0.19972542f, -0.01861416f, 
    0.27196380f, -0.07413346f, 0.25143647f, 0.27794594f, 0.02786179f, 0.04769849f, 0.04649897f, 0.18698131f, 
    -0.06948617f, -0.04177999f, 0.02664271f, 0.05043754f, 0.00286249f, 0.16598943f, 0.01937148f, 0.02819015f, 
    -0.49225056f, -0.52596730f, 0.56393445f, 0.53740239f, -0.99449569f, 0.42412442f, -0.42415103f, -0.12647982f, 
    0.05454536f, 0.15536839f, -0.02413361f, 0.06174829f, 0.07059172f, 0.10225787f, 0.09542485f, -0.02841225f, 
    -0.08301684f, -0.02454943f, 0.02269314f, 0.00712998f, 0.24220933f, 0.23147465f, -0.19843543f, -0.29327303f, 
    -0.22179832f, 0.10559375f, 0.07901566f, 0.17229885f, 0.03473687f, 0.13236460f, -0.12438700f, -0.08097885f, 
    -0.12873287f, -0.21081114f, -0.05814743f, -0.01905792f, -0.16145658f, -0.14537570f, -0.10562383f, -0.23333485f, 
    -0.36431232f, 0.28661352f, -0.59647322f, 0.02173368f, -0.23980477f, 0.02477471f, 0.01432620f, 0.20677498f, 
    -0.09604292f, 0.02741498f, 0.00474723f, -0.12675333f, -0.26996994f, -0.10630974f, -0.16809882f, 0.21225147f, 
    -0.18618087f, -0.08788554f, 0.00376673f, -0.07980488f, -0.06316137f, -0.37643316f, -0.13964094f, -0.28453928f, 
    0.13282354f, -0.02065951f, -0.04873985f, 0.02661134f, 0.00214857f, -0.17537193f, -0.18563417f, 0.07340174f, 
    0.00392856f, -0.12734970f, 0.00737627f, 0.20275614f, 0.08686487f, -0.05492097f, 0.00653627f, 0.17119484f, 
    -0.06138464f, -0.34775552f, -0.28831342f, -0.89679605f, 0.26401201f, 0.13559662f, 0.09306151f, 0.19146846f, 
    0.12978666f, 0.17469621f, 0.06781528f, 0.03128837f, -0.11777394f, 0.03284424f, -0.00590483f, 0.05494478f, 
    0.27108365f, 0.01525318f, -0.10677022f, 0.01583750f, -0.20224668f, -0.80907035f, 0.13853481f, -0.47184831f, 
    -0.51247770f, 0.04060845f, -0.24487494f, -0.19675460f, 0.02835224f, -0.09205747f, -0.07899074f, 0.10969820f, 
    -0.01129939f, 0.28200176f, 0.00866941f, 0.16104873f, -0.06750867f, -0.04749145f, -0.19887091f, -0.01373129f, 
    0.47123274f, 0.04128252f, 0.04896978f, -0.19162065f, -0.03467651f, 0.04046126f, 0.07485402f, -0.08477273f, 
    -0.03091726f, -0.01222397f, -0.25871551f, 0.18521321f, -0.14664088f, -0.20479161f, -0.29304132f, -0.07464752f, 
    -0.16115645f, 0.03081131f, -0.08791561f, -0.20087923f, -0.56903303f, 0.16978920f, -0.55558658f, -0.11773428f, 
    0.19120768f, 0.00217760f, -0.18737857f, -0.05893790f, -0.12628403f, 0.19392987f, -0.08942340f, 0.18732959f, 
    -0.09181523f, 0.14444105f, 0.02203095f, 0.21302578f, 0.01056139f, -0.10394596f, 0.03196204f, 0.05400782f, 
    0.00439641f, -0.15810485f, -0.78936905f, -0.09236122f, 0.07057949f, -0.07555427f, 0.13945839f, 0.28368500f, 
    -0.20114158f, -0.19910428f, 0.02077568f, 0.09646885f, -0.07322601f, 0.08241472f, -0.07560091f, 0.13001464f, 
    -0.20692322f, -0.13687050f, -0.51121348f, -0.46944630f, 0.18382013f, -0.41166070f, 0.38084164f, -0.12556089f, 
    -0.07496999f, -0.17306755f, 0.02713934f, 0.00702374f, 0.00785598f, -0.09761138f, -0.03962120f, 0.01308002f, 
    -0.24047846f, 0.11290786f, -0.10454792f, -0.00501265f, -0.17300585f, -0.09227027f, -0.30303520f, -0.46449968f, 
    0.07584009f, 0.00297980f, -0.53321862f, 0.46369958f, -0.12283695f, 0.01155009f, -0.16742231f, 0.29555768f, 
    -0.03371934f, 0.07818416f, 0.14464402f, 0.21112891f, -0.18811403f, 0.11154526f, 0.10782250f, -0.15284410f, 
    -0.18272026f, 0.18188141f, -0.26398608f, 0.20281535f, -0.04746874f, -0.52748263f, 0.17367360f, -0.07982477f, 
    -0.42403862f, -0.06297969f, -0.17958502f, 0.07049949f, 0.12738581f, 0.03871351f, -0.02693542f, -0.08535410f, 
    -0.12207979f, 0.01752992f, 0.07982773f, 0.09615362f, -0.07619980f, -0.00611492f, 0.29889455f, 0.05258264f, 
    -0.46609494f, -0.01773088f, 0.23351036f, 0.42094895f, 0.07863519f, -0.11519557f, 0.05645027f, 0.19567491f, 
    0.16280414f, 0.00333893f, -0.12681556f, -0.01392596f, -0.13042057f, -0.06697617f, -0.16194735f, 0.01635354f, 
    -0.24261078f, -0.00395773f, -0.23205821f, -0.21315341f, -0.18478222f, -0.00286262f, -0.50481147f, -0.06848191f, 
    0.15554163f, 0.18883520f, -0.21306998f, 0.01773564f, -0.12256749f, 0.14984025f, 0.02941183f, 0.08190464f, 
    -0.07136466f, 0.09667942f, 0.01737832f, 0.14597616f, -0.23646237f, -0.15261474f, -0.29919881f, -0.09607158f, 
    -0.86050844f, -0.50294453f, -0.23588525f, 0.08453079f, 0.00168910f, -0.19773164f, -0.19074698f, -0.09575703f, 
    0.48707455f, 0.03138762f, -0.33654800f, 0.00151441f, 0.07382511f, -0.00546601f, 0.00995167f, 0.16884282f, 
    -0.07774186f, -0.07162313f, 0.28396469f, 0.07013467f, 0.21889332f, -0.62143993f, 0.10915753f, -0.06441937f, 
    -0.66033214f, -0.30300111f, -0.40921026f, -0.13342316f, -0.00341771f, -0.16523008f, -0.04794783f, 0.05451325f, 
    -0.17022365f, 0.09429576f, 0.17578968f, -0.04021461f, -0.10104496f, -0.02728392f, -0.10087588f, -0.00937946f, 
    -0.38095590f, 0.01941927f, 0.11623236f, 0.01587512f, 0.21404512f, -0.12242264f, 0.07856323f, -0.36356023f, 
    0.23052129f, -0.10303667f, 0.10020467f, -0.08460797f, -0.11521149f, -0.02533423f, -0.11037287f, 0.05163277f, 
    0.07047236f, 0.02599695f, 0.05131157f, 0.05839650f, -0.24850757f, -0.05749309f, 0.10773697f, 0.55817056f, 
    0.11763401f, -0.16485991f, 0.16464306f, 0.08323517f, -0.18612693f, -0.04896650f, -0.14239725f, -0.07002891f, 
    0.26363683f, 0.27924025f, 0.05376606f, 0.14508440f, 0.13111506f, 0.08064533f, 0.27739784f, 0.59391099f, 
    0.13783671f, -0.62864619f, 0.29975051f, 0.13117555f, 0.01619639f, -0.15368427f, 0.04092783f, 0.21944703f, 
    -0.03373950f, 0.16287275f, -0.01718041f, -0.02778746f, 0.06241322f, -0.10748253f, 0.16190855f, -0.01273209f, 
    0.09514046f, 0.14850217f, 0.14525425f, 0.10559203f, -0.44025180f, -0.01632613f, -0.03610992f, -0.00190246f, 
    -0.20155634f, 0.02492955f, -0.15908469f, -0.25350431f, 0.12191070f, -0.08199964f, 0.06231030f, 0.17529303f, 
    0.08487491f, -0.06767837f, 0.02321282f, -0.03682854f, -0.06715540f, -0.05178330f, -0.04041036f, -0.19662899f, 
    -0.02882484f, 0.09745297f, 0.68906713f, 0.23644896f, -0.06264585f, -0.10791752f, 0.00514983f, -0.01303247f, 
    -0.05091221f, -0.23711421f, -0.06384053f, 0.05077395f, 0.02135460f, 0.10697000f, 0.06511770f, -0.12285984f, 
    0.09060471f, 0.28540209f, -0.18234588f, -0.05219752f, -0.85139948f, 0.51948059f, 0.05045951f, 0.49155715f, 
    0.46083695f, 0.11167576f, -0.14511526f, 0.05147609f, 0.56419456f, 0.22270752f, -0.11023518f, -0.09815213f, 
    0.03239969f, -0.19105245f, 0.16990326f, -0.07524502f, 0.09490462f, -0.05648720f, 0.34472558f, 0.36715856f, 
    -0.86592442f, -0.10884646f, -0.41467568f, 0.19441885f, -0.61001152f, 0.00505126f, 0.14218734f, -0.02119139f, 
    -0.24737915f, 0.16950448f, -0.18056534f, -0.15215069f, 0.07565182f, 0.03783462f, 0.07286967f, -0.12869948f, 
    -0.05900491f, -0.05509746f, -0.07061110f, 0.16843818f, -0.05191069f, -0.56390834f, -0.20429116f, -0.08027606f, 
    -0.07081302f, -0.07350419f, -0.33456033f, 0.10760553f, -0.23818345f, -0.13185397f, 0.01691799f, -0.03354950f, 
    0.06318168f, -0.09463963f, -0.07038564f, 0.07295108f, 0.03264325f, 0.05529425f, 0.07236561f, -0.12454335f, 
    0.17093508f, -0.63074386f, -0.40112942f, -0.46979907f, 0.29330832f, -0.26690850f, -0.47607756f, -0.16889608f, 
    0.06541892f, -0.11056542f, -0.03051982f, 0.06281497f, 0.00654868f, -0.15978344f, -0.07653423f, 0.08007656f, 
    0.02342900f, -0.30949363f, 0.23747683f, 0.09357323f, 0.01700008f, -0.23465504f, 0.00659891f, -0.36314893f, 
    0.46961316f, 0.04494403f, 0.02144062f, 0.04136779f, -0.10777169f, -0.16636547f, 0.08715260f, -0.02968085f, 
    -0.07713856f, -0.02282618f, 0.00952802f, 0.06662446f, -0.04488485f, 0.01473756f, 0.01574578f, 0.04518266f, 
    0.43884215f, -0.38930303f, 0.05988203f, 0.41124347f, -0.01627822f, -0.03601437f, 0.20682637f, -0.23717235f, 
    0.50572217f, -0.03646957f, -0.18848954f, 0.03884255f, -0.00132378f, 0.12934102f, -0.02771700f, -0.11937819f, 
    0.00223280f, 0.21573749f, 0.20426463f, -0.08604944f, -0.35206768f, 0.06782728f, -0.07989462f, 0.07927864f, 
    -0.17779902f, -0.03494412f, 0.16628462f, 0.16100714f, 0.14060424f, 0.00306935f, -0.20213348f, 0.03678287f, 
    -0.00763189f, 0.14605731f, -0.07561413f, -0.01988860f, -0.02475223f, -0.05289974f, -0.22849810f, -0.11245200f, 
    0.26145568f, -0.95509934f, 0.57660991f, -0.30182046f, 0.10125830f, 0.13664469f, 0.13132994f, 0.16677237f, 
    -0.00981551f, -0.12414117f, 0.03868025f, -0.16619684f, 0.22573692f, 0.24289736f, 0.06599493f, 0.10384653f, 
    0.24183264f, 0.15846227f, -0.03348241f, -0.02156949f, 0.13764726f, -0.19316538f, 0.35501000f, 0.19059189f, 
    -0.00969180f, -0.14828105f, -0.51066667f, 0.16942614f, -0.22540765f, -0.13264760f, 0.04095580f, 0.00360590f, 
    0.06200128f, 0.01401763f, -0.02953097f, -0.00969251f, 0.01419738f, 0.08326785f, 0.15573449f, 0.11776823f, 
    0.86859012f, 0.26692146f, 0.83819449f, 0.10978050f, -0.18726794f, -0.02379294f, -0.00257167f, -0.22627142f, 
    0.30040738f, -0.24002865f, -0.24485871f, 0.04121117f, 0.10738572f, 0.06230967f, -0.00342888f, -0.07841421f, 
    -0.04188212f, 0.12177473f, 0.14116220f, -0.00793378f, 0.20140417f, 0.10697164f, 0.16769044f, 0.00465311f, 
    -0.29880023f, -0.21509169f, 0.11297087f, -0.15912639f, -0.05383261f, 0.16884980f, -0.09188098f, -0.09355775f, 
    0.01887746f, -0.04361557f, -0.14203574f, -0.02053149f, 0.11449611f, 0.10603666f, -0.03821957f, 0.01059568f, 
    0.12629890f, -0.63063174f, 0.17500935f, -0.35070312f, -0.32271886f, 0.13741265f, -0.02651200f, -0.36692110f, 
    -0.01839446f, 0.00833736f, 0.16323492f, 0.03585426f, 0.02522737f, -0.09900650f, 0.04762569f, 0.02969541f, 
    -0.07318823f, 0.00515954f, 0.08237827f, -0.12429389f, -0.15972358f, -0.47100571f, 0.10629886f, 0.37521777f, 
    0.04625022f, -0.10093675f, -0.11010300f, -0.11578488f, -0.22909720f, -0.07272647f, 0.13428646f, 0.05987724f, 
    -0.12061802f, -0.11857449f, -0.08842243f, -0.09960198f, -0.02765102f, 0.04811573f, -0.12662168f, -0.33505800f, 
    0.36511320f, -0.01707464f, 0.44637260f, -0.39215139f, -0.04556027f, 0.13464083f, 0.27762976f, -0.11002868f, 
    0.27600521f, 0.01847522f, -0.17159745f, 0.20290759f, -0.00065562f, 0.26500329f, -0.01642229f, -0.12580009f, 
    0.11766081f, -0.14503704f, -0.29716241f, 0.05583396f, -0.28715920f, -0.04376036f, -0.36840963f, 0.25716510f, 
    -0.11046993f, -0.08952522f, 0.05832243f, -0.15239879f, 0.16015823f, -0.06605699f, -0.41830808f, -0.00677991f, 
    0.03156821f, 0.08897565f, -0.01905645f, 0.15596575f, -0.01165309f, 0.03928346f, -0.29073560f, -0.12655008f, 
    0.46740460f, 0.13926667f, -0.38473004f, 0.40096340f, 0.35865575f, -0.01602494f, 0.11933499f, -0.18607600f, 
    0.13358593f, -0.02528239f, -0.06764092f, 0.12438246f, -0.08225257f, -0.13421093f, -0.07206013f, 0.16839893f, 
    0.07081867f, -0.08630197f, 0.17702751f, 0.04839740f, -0.74389642f, -0.25522047f, 0.19351558f, 0.70613247f, 
    -0.72139269f, 0.10343435f, 0.04820053f, -0.01359263f, 0.27929935f, -0.09696141f, -0.15220653f, -0.01349237f, 
    -0.08655796f, 0.14793718f, 0.12621285f, 0.06540758f, 0.04283983f, 0.22111066f, 0.06375000f, -0.17193955f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24614260f, 0.10528012f, 0.06240128f, -0.15030906f, -0.02759073f, 0.02111574f, 0.00718737f, -0.16709644f, 
    0.09145387f, 0.05702892f, 0.04629784f, 0.02321811f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
