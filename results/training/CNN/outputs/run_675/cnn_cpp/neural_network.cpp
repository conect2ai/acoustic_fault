#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46301866f, -0.47140202f, -0.77601886f, -0.64839846f, -0.53803068f, 0.38170210f, 0.80835104f, -0.22438240f, 
    0.22762944f, 0.57046288f, -0.34445533f, -0.38096124f, -0.00955889f, -0.49126282f, -0.07834840f, -0.40878701f, 
    0.16977237f, 0.16087079f, 0.12304986f, -0.42754796f, -0.07418541f, -0.22414723f, 0.00296596f, -0.02226802f, 
    -0.07492289f, -0.42662457f, -0.38996944f, -0.45098501f, -0.36217773f, 0.14428817f, -0.85303253f, -0.44021627f, 
    -0.56685424f, -0.57908946f, 0.15986010f, 0.26180583f, 0.50594699f, -0.14426193f, 0.04084750f, -0.10403498f, 
    0.33262631f, -0.20417419f, -0.01135498f, -0.32394105f, 0.55066192f, 0.21579899f, -0.22664776f, 0.24529395f, 
    0.48472014f, -0.35741839f, -0.93579185f, 0.12709388f, -0.04146688f, 0.00542749f, -0.79285252f, 0.75941110f, 
    1.04153538f, 0.07797197f, -0.19416645f, 0.25693703f, 0.17815447f, -0.00177514f, -0.01518186f, 0.07379465f, 
    0.06611758f, -0.06117189f, -0.38130891f, 0.03519324f, -0.06456486f, 0.11979362f, 0.12255508f, -0.07585873f, 
    0.21238463f, 0.09071466f, -0.04512953f, -0.73877782f, 0.32395187f, 0.25232899f, -0.86604220f, 0.52336180f, 
    -0.16335857f, 0.14113808f, -0.65296030f, -0.52084857f, -0.55133682f, -0.05075906f, 0.13473924f, -0.32778686f, 
    -0.07020734f, -0.49041560f, -0.18945873f, -0.11415831f, -0.26766005f, -0.19213229f, 0.12226598f, 0.05774995f, 
    0.09329619f, -0.02421959f, 0.17016670f, -0.03439863f, -0.50772989f, -1.42790759f, -0.82045507f, -0.29156843f, 
    0.08380015f, -0.81732953f, 0.47775811f, 0.23804513f, -0.79093945f, 0.22911468f, 0.28025186f, 0.21728393f, 
    0.28894806f, -0.03698882f, -0.00492029f, -0.15791827f, 0.19678943f, 0.00535982f, -0.10161282f, -0.04422411f, 
    0.07149459f, -0.13203637f, 0.06510805f, -0.09418803f, 0.02930266f, -0.73880202f, -0.53869271f, 0.83583146f, 
    -0.27473432f, -0.85854256f, 0.46609622f, -0.60097861f, 0.28326407f, -0.06297108f, -0.08051996f, -0.07991023f, 
    -0.10929412f, 0.09866672f, 0.24543187f, 0.00579103f, -0.07822525f, 0.13707711f, 0.15222727f, -0.11980471f, 
    -0.02802178f, 0.02465751f, 0.31058639f, 0.35014564f, 0.13367115f, 0.15078139f, -0.62521082f, -0.84572995f, 
    -0.19526541f, 0.26806813f, -0.07333381f, -0.16743989f, -0.23729198f, -0.08711319f, 0.65916514f, 0.18272662f, 
    0.79585522f, 0.26670671f, -0.11624442f, 0.29992163f, -0.10445797f, 0.12697148f, 0.19929187f, 0.37751645f, 
    -0.14749388f, 0.20533401f, 0.00913563f, -0.00100674f, 0.13999854f, -0.16847852f, 0.42851532f, 1.14002383f, 
    0.09001615f, 0.11862357f, 0.62436140f, 0.79460096f, 0.25246626f, 0.25659442f, 0.14837359f, 0.00402329f, 
    0.41222572f, -0.49817562f, -0.25483584f, -0.18254083f, 0.10014630f, 0.00991538f, -0.06139985f, 0.12547535f, 
    0.29843482f, 0.35518268f, 0.07247115f, 0.14114557f, 0.22958353f, -0.20993619f, -0.07843877f, -0.01624486f, 
    -0.10438988f, 0.58654469f, 0.75402462f, 0.41184419f, 0.02382657f, -0.44209582f, -0.36678869f, -0.77332389f, 
    -0.49315351f, -0.53216738f, 0.12187829f, -0.04786015f, 0.26294792f, 0.14966835f, 0.42409101f, 0.03371229f, 
    0.00078353f, -0.11899661f, 0.31115311f, 0.08388224f, -0.08889534f, 0.21855479f, 0.11988889f, -0.14546239f, 
    0.15893255f, 0.48866808f, 0.41345775f, 0.40359417f, 0.49332580f, -1.11933017f, -0.30259377f, 0.51580834f, 
    0.26251134f, 0.06621362f, 0.44895908f, 0.48980430f, 0.33188912f, 0.08019863f, 0.08917237f, -0.09185463f, 
    0.14287750f, -0.27148041f, 0.06624363f, -0.21597573f, -0.54325217f, 0.20490059f, 0.31680730f, 0.00790795f, 
    0.06353518f, -0.16722122f, 0.91336298f, 0.85097831f, 0.75139576f, -0.36588496f, -0.24487628f, -0.39107940f, 
    -0.49569437f, -0.13963167f, 0.19764422f, 0.07488954f, -0.06497155f, -0.08569750f, -0.24511063f, -0.12094484f, 
    -0.13702856f, -0.32252610f, -0.12736295f, -0.15728122f, -0.10217460f, -0.11534074f, 0.04982636f, -0.06957375f, 
    -0.19234911f, -0.00822194f, -0.07838611f, 0.17193721f, 0.36346996f, 0.55691057f, 1.12375247f, -0.18699346f, 
    -0.38424960f, 0.03780188f, -0.39088383f, 0.54289675f, -0.22739898f, -0.27091613f, -0.17454903f, -0.23882553f, 
    -0.06625822f, -0.35341004f, -0.01060257f, 0.36799660f, -0.25970736f, -0.42555144f, -0.31931740f, -0.43771952f, 
    0.01776376f, -0.30607212f, 0.05264469f, -0.08360001f, 0.70276016f, 0.46530989f, -0.12608859f, 0.95872462f, 
    0.92277133f, 0.67353868f, -0.28917116f, -0.43215212f, 0.01989419f, 0.18647297f, 0.24353498f, 0.50778461f, 
    -0.22892311f, 0.25601357f, 0.08109848f, 0.26985613f, -0.20484076f, 0.10322917f, 0.13024008f, 0.09406268f, 
    0.18288369f, 0.00262164f, -0.00916154f, -0.22018708f, -0.14665104f, -0.97989082f, 0.20834793f, 0.03469349f, 
    -0.52121586f, 0.34907445f, 0.96932060f, -0.39576533f, -0.53823614f, 0.24798630f, -0.31419623f, -0.09477486f, 
    -0.17732337f, 0.22950217f, -0.02427424f, 0.08605471f, -0.01563161f, -0.15405592f, 0.12456654f, -0.33908871f, 
    -0.14400542f, -0.18514304f, -0.06170888f, 0.25355724f, 0.18477644f, 0.20046486f, 1.16943312f, 0.70010287f, 
    0.24749075f, 0.36665618f, 0.88939571f, 0.48907214f, 0.23087840f, -0.64904553f, 0.62242419f, -0.25710750f, 
    -0.04839395f, 0.01029585f, -0.00408065f, -0.09337663f, -0.06123151f, -0.31815237f, -0.15919885f, -0.15083438f, 
    -0.14491843f, -0.13496161f, -0.04279274f, -0.06454926f, 0.23490740f, 0.00680264f, 0.22808406f, -0.16241984f, 
    -0.56911355f, 0.23619737f, 0.90433693f, 0.66500932f, 0.54026133f, 1.03189981f, 0.73025697f, 0.41061452f, 
    0.27861366f, -0.02667554f, 0.04654589f, -0.22480759f, 0.33315772f, -0.12140223f, -0.08377177f, -0.25470278f, 
    0.15216760f, -0.12604254f, -0.11917897f, 0.09627581f, -0.09574071f, -0.04019717f, 0.21547911f, -0.08808272f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13945460f, 0.37614873f, 0.02108232f, 0.20904252f, 0.25978962f, 0.15520637f, 0.45247936f, 0.03855487f, 
    0.16302800f, 0.21821836f, 0.10772653f, 0.19050962f, 0.14955918f, 0.09752160f, 0.32004684f, 0.18390937f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06883467f, -0.01085718f, 0.04412574f, -0.06060091f, -0.05284992f, -0.06707186f, 0.06391452f, 0.01614562f, 
    0.01498986f, -0.03358931f, 0.00584197f, -0.02276948f, -0.02569156f, 0.05175806f, 0.02492670f, -0.03134982f, 
    0.00444650f, 0.04135820f, 0.04742915f, -0.00634523f, -0.02704659f, -0.06647947f, -0.01866809f, 0.05083030f, 
    -0.06481311f, 0.01215676f, -0.05551466f, 0.06004056f, -0.06607495f, -0.03965629f, -0.06942204f, 0.05282134f, 
    -0.05745834f, -0.04004529f, -0.03323618f, -0.06774139f, -0.06562749f, 0.00313125f, -0.03051311f, 0.00580986f, 
    0.02582970f, 0.03157988f, 0.00258907f, 0.05088987f, -0.02962329f, 0.00610798f, -0.04899897f, 0.00615715f, 
    -0.03543424f, 0.04896517f, 0.04615547f, 0.05792456f, -0.02107530f, -0.00191514f, 0.03289549f, 0.04977060f, 
    0.05397177f, 0.06173722f, -0.04282803f, -0.03255699f, -0.06899496f, -0.04609086f, -0.00564794f, 0.00870763f, 
    -0.03309502f, 0.00624936f, 0.05621385f, 0.05254423f, 0.04484309f, 0.03684661f, -0.06289463f, -0.02476672f, 
    -0.06379371f, 0.02534973f, -0.00520512f, 0.01523248f, -0.02415334f, 0.00465916f, 0.01217984f, -0.06385365f, 
    0.02925701f, -0.05490303f, 0.01626859f, 0.00994579f, -0.04895847f, -0.02989097f, 0.05497838f, 0.04582089f, 
    -0.06221118f, -0.00967579f, 0.01626703f, 0.06048670f, -0.06083798f, 0.01152644f, 0.04811839f, 0.03870613f, 
    0.05618865f, -0.04602110f, 0.02243204f, -0.04469329f, -0.06481349f, 0.06302749f, -0.04603195f, -0.02630654f, 
    -0.01853621f, 0.03749665f, -0.04130120f, 0.05621045f, 0.04635476f, -0.03795392f, -0.06030301f, 0.04934460f, 
    -0.06843227f, -0.06667693f, 0.01203026f, 0.02430384f, -0.07537808f, -0.07761278f, -0.05715432f, -0.01672558f, 
    -0.05413017f, 0.00502046f, 0.04068779f, 0.04154475f, -0.01446167f, 0.05542447f, -0.03769205f, 0.02524748f, 
    -0.01927581f, -0.02646803f, 0.05969528f, -0.00307944f, -0.01137733f, -0.05105608f, 0.04075257f, -0.04913424f, 
    0.00656067f, -0.00704901f, -0.01936061f, -0.07241187f, -0.07328033f, 0.03111253f, -0.05854935f, -0.05829850f, 
    -0.04828199f, 0.01048172f, -0.00668824f, -0.00289948f, 0.01124942f, -0.06934326f, 0.06475514f, 0.01023387f, 
    -0.02013255f, 0.05859314f, -0.03425061f, -0.02235674f, -0.04589404f, 0.05283732f, -0.02449592f, 0.01304329f, 
    0.03636108f, 0.02860084f, 0.02972345f, 0.03694560f, -0.04385643f, 0.02993164f, 0.01493389f, -0.05614375f, 
    -0.04948959f, -0.07954124f, -0.01298289f, -0.07457258f, 0.01960695f, 0.01650541f, -0.03307875f, 0.01930493f, 
    0.01804009f, -0.02605897f, -0.01897978f, 0.00667105f, -0.03604098f, -0.07639752f, -0.05852139f, -0.00279212f, 
    0.05868379f, -0.07877213f, -0.05158892f, -0.06445699f, -0.01810532f, -0.04084922f, 0.01390978f, -0.02972687f, 
    -0.24983770f, -0.00955636f, 0.14336310f, 0.44290680f, -0.12502460f, -0.18573302f, 0.13493101f, -0.09239060f, 
    0.05237773f, 0.09203591f, 0.04037534f, -0.04825824f, 0.31600884f, -0.12394378f, -0.07670523f, 0.18348961f, 
    0.10028050f, 0.07288461f, 0.09912843f, 0.03562331f, 0.06115409f, 0.17908263f, 0.11552990f, -0.00147055f, 
    -0.34108701f, 0.06936566f, 0.05170023f, 0.10616356f, -0.01939913f, -0.02207932f, -0.08266483f, 0.22941145f, 
    -0.14082600f, -0.00441252f, 0.02721769f, 0.01004506f, 0.04283924f, 0.40971789f, 0.08045506f, 0.09472306f, 
    -0.06799152f, 0.03780452f, -0.07885106f, -0.02835924f, 0.12230868f, 0.01679737f, 0.04961159f, 0.10995351f, 
    -0.24071398f, 0.28160962f, 0.07466263f, 0.12298167f, 0.20320223f, -0.01079790f, -0.03918706f, -0.04714245f, 
    0.08434344f, -0.02541378f, 0.08723162f, -0.01052494f, 0.21298118f, -0.05388137f, -0.25343627f, -0.10571578f, 
    -0.07544333f, 0.05688936f, -0.22299576f, 0.08473291f, 0.02020138f, -0.18485728f, -0.04529582f, -0.08929792f, 
    0.25017828f, 0.27576807f, -0.02955982f, -0.14524381f, 0.10788319f, 0.05907759f, -0.02261445f, 0.09539054f, 
    0.13228366f, 0.06273402f, 0.07885141f, -0.15781786f, -0.33075622f, -0.01822731f, -0.23178834f, -0.12469763f, 
    0.05526019f, 0.01655933f, 0.12054520f, -0.02618972f, 0.06880942f, -0.06017014f, -0.07088745f, 0.17481083f, 
    -0.08944073f, -0.02543806f, 0.14469570f, 0.39182150f, -0.09081964f, 0.05971830f, -0.02229988f, -0.04570447f, 
    0.00095597f, -0.08349998f, 0.15811937f, -0.06102712f, -0.26322639f, -0.38312462f, 0.10903557f, -0.20735469f, 
    0.12004653f, 0.03359648f, 0.03336775f, -0.07034039f, 0.01147807f, 0.02886464f, -0.06060327f, 0.07740377f, 
    -0.00054708f, -0.21572405f, 0.13906203f, 0.00148827f, -0.04448052f, 0.09608956f, 0.09935483f, -0.13809106f, 
    0.15938030f, 0.04395144f, 0.08122518f, 0.08370486f, -0.17241590f, 0.11784541f, 0.05405587f, -0.10527252f, 
    -0.08544195f, 0.14493455f, -0.04295686f, 0.13859077f, -0.05453211f, 0.02443586f, -0.07993115f, 0.09885602f, 
    0.12547021f, -0.17718408f, -0.07587578f, 0.07761329f, 0.26501194f, 0.08917988f, 0.02798219f, 0.08592908f, 
    -0.00300383f, -0.00470443f, -0.03856375f, 0.19651608f, 0.31681025f, 0.26886991f, -0.07878548f, 0.16302042f, 
    -0.11058363f, 0.03198722f, -0.00712561f, 0.12574615f, -0.45355704f, -0.07417535f, -0.02024183f, -0.10978824f, 
    0.15021490f, -0.19311102f, -0.04338498f, -0.05545905f, -0.06046746f, 0.06363460f, 0.05620324f, 0.00453174f, 
    0.15230902f, 0.02055030f, -0.06373877f, 0.07386751f, -0.44984955f, 0.16052431f, -0.22898105f, -0.14122374f, 
    -0.05452962f, 0.00071989f, -0.00894959f, 0.09205365f, -0.04719419f, -0.07037804f, 0.11125346f, -0.01326446f, 
    0.11718221f, -0.01834670f, 0.11852434f, -0.02245367f, 0.00266501f, 0.09424645f, 0.26243582f, 0.22359249f, 
    -0.00103637f, 0.23371644f, -0.10851885f, 0.45301366f, 0.14938933f, -0.04440595f, 0.20809402f, 0.18694709f, 
    0.03542132f, 0.01163063f, -0.02776477f, -0.07221758f, 0.17252517f, -0.07081361f, 0.06906810f, -0.26854536f, 
    0.56438810f, 0.47547042f, 0.15850215f, -0.31148857f, 0.02061729f, -0.00370683f, 0.02528972f, 0.19088769f, 
    0.01729485f, -0.20672594f, 0.06058913f, 0.09446820f, 0.05476188f, -0.02963494f, 0.10896765f, -0.10180428f, 
    0.08088782f, -0.03790037f, -0.01863465f, -0.13660567f, 0.11584195f, -0.02195865f, 0.30163863f, 0.13267358f, 
    0.31607515f, -0.15206654f, 0.13657361f, 0.04253810f, -0.04484732f, 0.02488239f, 0.03893399f, -0.00762500f, 
    -0.10088337f, 0.17164512f, -0.12907170f, -0.01294115f, 0.71436518f, 0.16701695f, -0.07557819f, -0.15849148f, 
    0.18082115f, -0.09077380f, -0.16444148f, 0.02011657f, -0.11977852f, 0.20890608f, -0.05640581f, 0.20552324f, 
    0.30529928f, -0.31710625f, 0.08978577f, 0.07310028f, 0.06588522f, -0.00763545f, -0.10997351f, 0.04118049f, 
    -0.00547419f, -0.02170436f, -0.20905918f, -0.42610505f, 0.02437393f, -0.03791199f, -0.13605641f, 0.05245522f, 
    0.07908576f, -0.03337552f, 0.05215413f, -0.33354741f, -0.13350327f, -0.01416102f, 0.11695573f, 0.19439809f, 
    -0.21758851f, 0.19622466f, 0.03461453f, 0.11646594f, 0.05529728f, 0.02960027f, -0.30921373f, -0.02807013f, 
    -0.12647147f, -0.24240875f, -0.13147186f, -0.06130598f, -0.32820579f, 0.11378749f, 0.04493413f, 0.14807259f, 
    -0.00590406f, 0.03505616f, -0.03599924f, -0.16247033f, -0.06534310f, 0.18306912f, -0.01847947f, -0.10578333f, 
    -0.02173073f, -0.18928629f, 0.01936945f, 0.06632710f, -0.15245803f, 0.13405621f, 0.09686408f, -0.39024344f, 
    -0.03826341f, 0.07691365f, 0.22945783f, 0.09703413f, -0.08068611f, 0.04160944f, -0.08554810f, 0.28619492f, 
    0.22704005f, 0.03866644f, -0.11694212f, 0.03678691f, 0.08956967f, 0.17556180f, 0.12755702f, 0.11149362f, 
    0.11152629f, 0.13069756f, 0.01402872f, -0.03297184f, 0.12542276f, -0.03064355f, -0.08420285f, -0.12142609f, 
    0.09055310f, -0.29647583f, -0.11006822f, -0.25504252f, 0.40498179f, 0.21592507f, 0.03961708f, -0.20302574f, 
    0.22757530f, -0.30489430f, -0.15352635f, 0.09170169f, 0.01225669f, 0.06277618f, 0.09676869f, 0.11854976f, 
    -0.02924064f, 0.19353107f, 0.04262989f, -0.44071516f, 0.05325072f, -0.16481839f, -0.19270265f, -0.21569698f, 
    -0.07406569f, -0.06489073f, 0.14770886f, 0.11677488f, -0.12860084f, -0.13473462f, -0.20307451f, -0.08782218f, 
    0.01439808f, -0.20341296f, 0.09112737f, 0.02899028f, 0.08427347f, -0.06072801f, 0.18896890f, 0.10182191f, 
    -0.16477841f, 0.07008735f, -0.27320725f, 0.02560222f, -0.19772486f, 0.14004172f, 0.08283056f, -0.27210742f, 
    -0.05777101f, 0.01397743f, -0.09033454f, 0.04248007f, 0.05935558f, 0.46207866f, -0.27296528f, -0.11729042f, 
    -0.00131724f, 0.10301625f, -0.05054113f, -0.00209050f, -0.05405046f, -0.01760763f, -0.00702659f, 0.15891789f, 
    0.18051769f, -0.10229661f, -0.07624937f, 0.08871034f, -0.18594719f, -0.02619898f, 0.03214384f, 0.06627835f, 
    -0.10842983f, 0.01063284f, 0.09558163f, 0.05352980f, 0.23934805f, 0.07398036f, 0.24244040f, 0.48328784f, 
    0.05655930f, 0.10772063f, -0.04523026f, -0.01571334f, 0.06821545f, 0.00241166f, -0.15604813f, 0.21118137f, 
    -0.49504104f, 0.16312696f, -0.03470153f, -0.19943300f, 0.08854714f, 0.00999194f, -0.00306857f, -0.18342994f, 
    0.09788925f, 0.17468935f, -0.03639158f, 0.10366751f, 0.04421955f, -0.40465230f, 0.19947056f, 0.14709596f, 
    0.00859187f, 0.09594041f, -0.01144673f, 0.02302915f, -0.03262888f, -0.01857192f, 0.06517240f, -0.12275289f, 
    -0.07886610f, 0.09191313f, 0.40211087f, -0.28830743f, -0.10496388f, -0.19710913f, 0.06130680f, -0.20143297f, 
    0.13750984f, 0.11475905f, -0.02748709f, -0.05915586f, -0.61279202f, 0.07221945f, 0.21640249f, -0.29304144f, 
    0.07281603f, -0.08247318f, 0.08830719f, 0.00003154f, 0.00389297f, -0.07254510f, 0.09904946f, 0.01865123f, 
    0.28988463f, -0.13738796f, 0.09272306f, 0.29740191f, 0.13235052f, -0.05274277f, 0.14804684f, 0.08082017f, 
    -0.07373352f, 0.11575814f, 0.09567855f, -0.01761066f, 0.24862264f, 0.03225458f, 0.10898644f, 0.06825165f, 
    0.21200405f, -0.01992665f, -0.05140499f, -0.02077941f, -0.00664421f, 0.08890919f, 0.15405044f, -0.06603392f, 
    -0.01579162f, 0.08815866f, -0.07590159f, 0.15837409f, 0.22130486f, 0.03193140f, -0.08726738f, 0.02391934f, 
    0.09328133f, 0.09229982f, 0.14143811f, 0.07601643f, -0.02804304f, 0.17293847f, 0.40941733f, -0.41076076f, 
    0.07443282f, -0.09800614f, -0.00178488f, 0.10208409f, 0.01291384f, 0.09873981f, 0.09099536f, 0.07384469f, 
    0.10078403f, 0.11703323f, -0.11432706f, -0.11326441f, 0.06831470f, 0.09114483f, 0.11347095f, 0.07843709f, 
    -0.01445586f, -0.10987021f, 0.11681441f, 0.04545857f, 0.48714286f, -0.02450588f, 0.02578966f, 0.24350235f, 
    -0.05705437f, 0.09726153f, 0.08827577f, -0.01274510f, -0.04030684f, 0.21374461f, 0.00730857f, 0.08271861f, 
    -0.32757273f, -0.11971748f, -0.18030669f, -0.11322395f, 0.12033687f, 0.07801179f, -0.00164190f, 0.00028194f, 
    0.21051617f, -0.00162954f, 0.05259304f, 0.10701384f, -0.13526893f, -0.25712696f, 0.26522407f, -0.25691178f, 
    -0.08640415f, -0.08900072f, 0.12307827f, 0.08303788f, 0.07554870f, -0.12647398f, -0.00296010f, 0.06064741f, 
    0.24947734f, -0.06084533f, -0.11024583f, 0.00225355f, -0.24661656f, -0.01618283f, 0.15142746f, 0.00210060f, 
    0.16201413f, -0.12838198f, 0.00920814f, -0.18865675f, 0.42788199f, -0.08309577f, -0.00566110f, 0.14797038f, 
    0.17338949f, 0.00697603f, 0.03319531f, 0.04874161f, -0.00245328f, 0.09631482f, 0.00220166f, 0.07691889f, 
    -0.05912391f, 0.13885559f, -0.12718539f, -0.16745524f, -0.03736766f, -0.06470701f, 0.04434255f, 0.00076493f, 
    0.04042435f, 0.06073464f, 0.06090920f, -0.10209930f, 0.01455273f, 0.39551440f, 0.16783643f, -0.13011762f, 
    -0.00273379f, 0.11557438f, 0.17530386f, 0.11841214f, 0.23909248f, 0.19394980f, 0.04670449f, 0.04512118f, 
    -0.12445882f, 0.02478145f, -0.35059842f, 0.01667764f, 0.08862110f, -0.09968229f, -0.03107761f, -0.06344357f, 
    -0.06024734f, -0.05483443f, 0.11460893f, 0.00755705f, -0.13498344f, -0.17030288f, -0.07824355f, -0.04215763f, 
    -0.22052756f, 0.07689556f, -0.15786666f, 0.06214800f, 0.08336055f, -0.01903945f, -0.02321199f, 0.03107751f, 
    0.08917377f, 0.14667332f, -0.18890502f, 0.05200672f, 0.04345984f, 0.03498345f, 0.10507631f, 0.13408367f, 
    0.12811111f, 0.00411250f, 0.20479544f, 0.13724993f, -0.30293077f, -0.20837851f, 0.06445283f, -0.03799618f, 
    0.09212819f, -0.13977708f, -0.02170658f, -0.00014229f, 0.13683179f, 0.10936586f, 0.09440255f, 0.14822006f, 
    -0.15032645f, 0.28882012f, 0.03379877f, 0.11361825f, 0.08234774f, 0.24196990f, -0.01170107f, 0.02757016f, 
    -0.06912190f, 0.07980140f, 0.10305873f, 0.17623830f, -0.37999547f, -0.01277720f, -0.13609804f, 0.05421966f, 
    0.00374694f, 0.00665698f, -0.11600905f, -0.05849949f, 0.06689362f, -0.09019422f, -0.00071314f, 0.16314276f, 
    -0.16634798f, 0.05805751f, 0.03599637f, -0.08065777f, 0.06230083f, 0.13339120f, 0.00881456f, 0.01677599f, 
    0.12524422f, 0.15755361f, 0.01232109f, 0.05914390f, -0.23833692f, 0.07244428f, -0.02040836f, 0.21298017f, 
    -0.06915081f, 0.16835524f, 0.02053366f, 0.11262003f, -0.01490802f, 0.02783370f, -0.09127378f, 0.15857480f, 
    0.41418961f, -0.32215637f, 0.08001716f, 0.15658131f, 0.20749299f, 0.06963694f, 0.06830472f, 0.03479023f, 
    0.13763605f, 0.02239654f, 0.05491910f, 0.22883153f, 0.21059363f, -0.08658458f, 0.12709378f, 0.17498671f, 
    0.08492140f, -0.03105830f, -0.04428154f, 0.10166444f, -0.13875027f, -0.03506041f, 0.07274488f, -0.02392452f, 
    0.34988457f, -0.40917504f, -0.02871608f, -0.06181537f, 0.06767015f, -0.02963098f, 0.02708538f, -0.04086912f, 
    0.19640885f, -0.11340763f, -0.01120355f, -0.03224401f, -0.43140414f, 0.55366224f, 0.00354575f, -0.18003818f, 
    0.02196210f, -0.03138771f, -0.01425194f, -0.09745885f, 0.06021538f, -0.07088893f, 0.02580077f, -0.10392381f, 
    0.30413887f, 0.04162386f, -0.32754424f, -0.16466869f, 0.16638701f, 0.03377726f, -0.13643953f, 0.03517557f, 
    -0.00102732f, -0.09680138f, 0.07510901f, -0.17514980f, 0.33183250f, -0.15895170f, 0.04200473f, -0.05226581f, 
    0.10792083f, -0.01699793f, -0.18997703f, -0.03910523f, 0.06431257f, -0.06855856f, -0.07692069f, 0.13969079f, 
    0.14878637f, 0.07535297f, -0.19162798f, -0.06332534f, -0.11309961f, -0.07211311f, 0.13547391f, -0.09575490f, 
    0.05752330f, 0.10864411f, 0.10098141f, -0.10954424f, 0.14230666f, -0.13839434f, -0.06151671f, 0.25104448f, 
    -0.04093309f, 0.15352312f, 0.09146865f, -0.01174235f, 0.05058622f, 0.05141954f, -0.02270308f, 0.06092655f, 
    0.27300715f, -0.13850868f, -0.21851435f, -0.06426254f, 0.02084828f, 0.08646087f, -0.10265573f, 0.19627967f, 
    0.02802187f, 0.05242648f, -0.06490066f, -0.07246378f, -0.32478055f, 0.06320415f, 0.06277467f, 0.60164118f, 
    -0.02195087f, 0.05164958f, 0.05993563f, -0.10614219f, 0.06178540f, 0.04266592f, 0.15343592f, 0.01064139f, 
    -0.02032085f, 0.06531227f, -0.03713436f, -0.00330378f, 0.00927275f, -0.04566441f, 0.12764992f, 0.04069238f, 
    0.04601183f, 0.04096394f, 0.12219021f, 0.23424096f, -0.02640038f, -0.01833074f, 0.23916893f, -0.13492520f, 
    -0.00497068f, -0.07119026f, -0.00919779f, 0.02438541f, 0.04582049f, 0.09066247f, 0.03135752f, -0.00446330f, 
    0.34181684f, 0.20757703f, 0.02482780f, -0.01648888f, 0.02896548f, 0.01431472f, 0.05757976f, -0.09048735f, 
    -0.13331935f, 0.09927935f, 0.14174490f, 0.31555435f, 0.00731535f, 0.24931596f, -0.00202627f, -0.02122034f, 
    -0.26593196f, 0.04471370f, -0.00844960f, 0.01857421f, -0.02224850f, -0.11557253f, 0.09351718f, 0.06965175f, 
    -0.20281212f, 0.08629560f, 0.15487182f, 0.05908514f, -0.00143359f, -0.09196354f, -0.07738764f, 0.05456663f, 
    -0.15479447f, 0.03446360f, -0.09223477f, 0.02852744f, -0.03106427f, 0.01621469f, 0.08170675f, -0.07514130f, 
    0.14590329f, 0.05685219f, -0.09743141f, -0.09551003f, -0.08908340f, 0.02369243f, -0.03962098f, -0.11329419f, 
    -0.11503771f, 0.18660861f, 0.01468614f, -0.30766165f, 0.07276693f, -0.08076406f, -0.14769018f, 0.07377413f, 
    0.01601352f, 0.24310035f, 0.01141424f, 0.08608080f, -0.15529041f, -0.15636207f, 0.14704540f, 0.02898891f, 
    0.08695947f, 0.03651537f, 0.05869965f, -0.05725428f, -0.04583568f, -0.01994125f, -0.01443334f, 0.11412217f, 
    -0.49356773f, 0.17296913f, -0.00506400f, -0.14040786f, -0.05097981f, 0.02586849f, 0.05426770f, -0.07344417f, 
    0.04447098f, -0.06505606f, -0.02599526f, 0.01158926f, 0.28491729f, 0.11836764f, 0.06304268f, -0.23048472f, 
    0.15640530f, 0.01466249f, -0.11599436f, 0.07258781f, -0.08299820f, 0.03924586f, -0.02071371f, -0.03932760f, 
    -0.03543966f, -0.07279527f, -0.05708237f, 0.01727687f, 0.05999110f, -0.02977897f, -0.07083721f, 0.05737188f, 
    0.05921614f, 0.04244592f, -0.06988675f, 0.04256306f, -0.05355155f, -0.03424653f, -0.02535566f, -0.01148514f, 
    -0.05093630f, -0.02677161f, 0.04195425f, 0.04623165f, 0.00067033f, -0.04278990f, -0.07230224f, -0.02854747f, 
    -0.02725518f, -0.02399731f, -0.03224107f, 0.04481973f, -0.04048136f, 0.05236507f, -0.06686404f, -0.07031132f, 
    0.01786406f, 0.01779916f, 0.00090520f, -0.06550953f, 0.00015034f, -0.00853816f, -0.03495618f, 0.05447840f, 
    -0.01290877f, -0.01368536f, -0.08690663f, -0.06912592f, -0.03768675f, 0.05552720f, -0.03777064f, 0.06034946f, 
    -0.01694318f, 0.00755042f, -0.01794329f, -0.03570615f, -0.04729518f, 0.00037669f, 0.01417849f, -0.04862113f, 
    0.06008620f, 0.02396567f, 0.03566865f, -0.04835033f, 0.05628196f, -0.05974841f, 0.03072585f, 0.04824431f, 
    0.00770854f, -0.04036618f, 0.03206568f, -0.04412020f, 0.04158599f, 0.05444953f, -0.07147238f, -0.00219223f, 
    -0.05468605f, 0.01527973f, 0.01461545f, -0.03549650f, 0.02601591f, 0.05948132f, -0.07703727f, -0.04297923f, 
    0.05205527f, -0.01734667f, 0.03067982f, 0.02079729f, -0.01337035f, 0.01879685f, 0.01968341f, -0.05727855f, 
    0.00581032f, 0.00132317f, 0.05718747f, -0.01390151f, 0.05183163f, 0.03507143f, -0.05397285f, -0.02452638f, 
    -0.06946406f, 0.05509016f, 0.02649380f, -0.04922235f, -0.07143801f, -0.01435124f, -0.07151099f, 0.00663383f, 
    -0.00846579f, -0.01117345f, -0.04209009f, -0.03136529f, 0.03412585f, -0.01941722f, -0.04733868f, 0.03761118f, 
    0.00008044f, 0.00793488f, -0.00012603f, 0.05392223f, -0.07760620f, -0.07531229f, 0.05022017f, -0.06639155f, 
    0.04150779f, 0.00076493f, 0.04913079f, -0.00969869f, 0.03703249f, -0.05310654f, 0.05575579f, -0.04718797f, 
    -0.01017227f, 0.01736081f, -0.02996669f, 0.01697913f, -0.03620829f, -0.01708544f, -0.05516662f, -0.00044466f, 
    0.01904358f, -0.03747217f, -0.02389292f, -0.04849922f, -0.01098122f, -0.05839436f, 0.02978888f, -0.04220978f, 
    -0.04215860f, -0.06998530f, -0.07950899f, -0.06638689f, -0.07777309f, -0.04320769f, -0.08247913f, -0.00155886f, 
    0.06461946f, -0.01161269f, -0.03025135f, -0.01543716f, 0.02742139f, -0.04749023f, 0.04667896f, -0.07256171f, 
    0.06070969f, -0.00969916f, 0.05284734f, 0.02506925f, -0.02648942f, 0.05134785f, -0.03954606f, 0.03085808f, 
    -0.01158702f, -0.07627595f, -0.01528460f, -0.03600115f, 0.02854696f, 0.01637732f, 0.04296311f, 0.06327342f, 
    -0.00735806f, 0.05377570f, 0.06055667f, -0.07216024f, 0.01377342f, -0.02041487f, 0.04427038f, 0.01610716f, 
    0.00048640f, -0.05181400f, 0.03920329f, 0.04152945f, -0.02592570f, 0.01533699f, -0.00833850f, -0.08379545f, 
    -0.36117050f, -0.05538713f, 0.29968759f, 0.14186315f, -0.15871193f, -0.13102360f, 0.08213184f, 0.05728863f, 
    -0.01839154f, -0.10434806f, -0.16006193f, -0.24630859f, 0.01547702f, 0.12026209f, 0.06796911f, 0.10952664f, 
    0.12066085f, -0.14140396f, 0.08485216f, -0.00930887f, 0.19335373f, 0.03590904f, -0.08465945f, 0.07443562f, 
    -0.05332856f, 0.15643466f, 0.10917121f, -0.00364061f, -0.08717537f, -0.24165712f, 0.03848317f, 0.13167897f, 
    0.04930253f, -0.07485362f, -0.06189638f, 0.05686046f, 0.36482421f, 0.07862611f, -0.06558441f, -0.21436508f, 
    0.07676031f, -0.18754975f, -0.07918695f, 0.04455599f, 0.20757225f, 0.14048281f, -0.21298540f, -0.04732801f, 
    0.17316547f, -0.22423570f, 0.09226425f, -0.14024365f, -0.17422485f, 0.00523332f, -0.10344646f, 0.01655620f, 
    0.03655384f, 0.04397662f, 0.01023819f, 0.04746544f, 0.41812307f, -0.15270266f, 0.07870840f, -0.29747716f, 
    0.01754854f, -0.14707780f, 0.04881182f, 0.02289258f, -0.07885726f, 0.01956708f, 0.13613376f, -0.01129593f, 
    0.20293167f, -0.10397898f, 0.34965089f, 0.20152393f, 0.12936631f, -0.04960711f, 0.11423878f, -0.01763051f, 
    -0.07294543f, 0.11184870f, 0.28460091f, 0.19067875f, -0.29509181f, 0.17997506f, -0.17515734f, -0.08860207f, 
    0.17130108f, -0.06315781f, 0.02007055f, -0.14790675f, 0.10642496f, 0.14063236f, 0.16284136f, -0.10228701f, 
    -0.35092071f, -0.17341934f, -0.07350156f, -0.00860317f, 0.12332527f, 0.22528097f, -0.02672295f, 0.01417350f, 
    -0.01035444f, 0.11512694f, 0.03698814f, 0.06442688f, 0.00295592f, 0.01156862f, -0.01966520f, -0.07067558f, 
    0.01544859f, 0.02452861f, 0.06025427f, 0.08667045f, 0.12005662f, -0.09460187f, -0.03204639f, 0.08180072f, 
    -0.18036617f, -0.54698080f, -0.01442008f, -0.07909740f, 0.19837514f, 0.24847643f, 0.07221244f, -0.01653594f, 
    0.00947371f, 0.24672332f, -0.14035004f, -0.11201620f, -0.27884161f, -0.18752554f, -0.13266212f, 0.26068574f, 
    0.19209296f, 0.05411822f, -0.16198377f, 0.09381986f, 0.05638348f, -0.01043617f, -0.05467266f, 0.13171884f, 
    -0.00651378f, 0.10589200f, -0.06778527f, 0.21224411f, 0.13234092f, -0.08421426f, 0.09386100f, 0.00667712f, 
    0.01959495f, 0.07693525f, 0.12079586f, 0.21379349f, -0.18928777f, 0.21648282f, 0.00295879f, -0.07097095f, 
    0.12041543f, -0.12814511f, -0.07721768f, 0.06684898f, 0.06469475f, -0.02778232f, 0.02664251f, -0.03923124f, 
    0.14864400f, -0.15171751f, 0.06755207f, -0.17326595f, 0.17563589f, 0.15937260f, 0.02609636f, -0.10680970f, 
    0.08596867f, -0.01037593f, -0.08601785f, 0.12800732f, 0.30516475f, 0.29220182f, -0.06245679f, 0.05967853f, 
    0.03234722f, -0.17933621f, -0.12773675f, -0.04934788f, 0.06839618f, 0.10575655f, 0.05141898f, -0.13414972f, 
    0.31857032f, 0.42671570f, -0.06610033f, -0.14832194f, -0.16198786f, 0.15159512f, 0.01710103f, -0.16453424f, 
    0.03054926f, -0.09882957f, -0.07003243f, -0.19244491f, 0.24921714f, 0.09189416f, -0.12835190f, -0.11479938f, 
    -0.11450870f, -0.15791085f, -0.03301012f, 0.07654675f, -0.06860857f, 0.04984443f, -0.03640027f, 0.26337212f, 
    0.05424572f, 0.06891197f, -0.04132025f, 0.01322265f, -0.17861719f, -0.13245453f, 0.22096030f, 0.03041060f, 
    -0.01052369f, 0.05953640f, 0.04295677f, 0.25643024f, -0.22893947f, -0.06004651f, 0.32284990f, 0.12798040f, 
    0.00983645f, 0.05821514f, 0.03554064f, 0.16442476f, 0.08840457f, -0.01922723f, -0.20814200f, -0.02846691f, 
    -0.16428438f, 0.05791535f, 0.24185590f, -0.19941480f, 0.02378440f, -0.00939803f, 0.03321299f, -0.06167749f, 
    0.06436084f, 0.05061046f, 0.05127241f, 0.16272806f, -0.13115533f, 0.02768946f, 0.43087795f, 0.32891273f, 
    -0.07062132f, 0.13865298f, 0.19824462f, 0.01323374f, 0.03457773f, 0.15286951f, 0.09127141f, -0.06633843f, 
    0.03240474f, 0.10116038f, 0.13044274f, 0.01329608f, -0.01910761f, -0.05726125f, 0.01335408f, 0.03106174f, 
    0.05704300f, 0.04293571f, -0.00086847f, 0.19139171f, 0.04225363f, -0.17962767f, 0.12367931f, 0.27006665f, 
    -0.16850425f, -0.03668747f, -0.13640140f, 0.00135608f, -0.08346164f, 0.19998083f, 0.11138213f, -0.11691637f, 
    -0.08027472f, -0.06753643f, 0.10950759f, 0.00441581f, 0.09189310f, -0.13192299f, 0.11621875f, 0.00614560f, 
    0.05623068f, 0.22761561f, 0.09078009f, 0.32277718f, 0.06701064f, -0.13330570f, -0.31075472f, 0.01477482f, 
    -0.00097325f, 0.10404545f, -0.20775992f, -0.04949593f, 0.00002109f, -0.10646492f, 0.02267494f, 0.12918381f, 
    -0.18054260f, -0.06215150f, -0.25407791f, -0.13010029f, 0.04692959f, -0.16107027f, -0.02119196f, 0.11082423f, 
    0.05480045f, -0.05789151f, -0.06330260f, -0.02783821f, 0.07085598f, -0.31973776f, -0.09176960f, 0.06466484f, 
    0.15531649f, -0.22066070f, 0.09865603f, -0.04786602f, 0.05345980f, -0.17641374f, -0.05229161f, 0.03641934f, 
    -0.08627988f, -0.19485940f, -0.00042645f, 0.16540484f, -0.00692904f, -0.03649150f, -0.10655249f, 0.03601404f, 
    0.04527664f, 0.09265660f, -0.14594093f, 0.06473699f, -0.05162460f, 0.07187059f, 0.13025102f, 0.04691801f, 
    0.22275577f, 0.04192252f, 0.13952664f, -0.14661668f, 0.10075475f, 0.12145156f, 0.06210713f, -0.07868113f, 
    -0.23939045f, -0.28978914f, -0.01412278f, 0.24077873f, -0.06337847f, 0.12300260f, -0.03271906f, -0.06898393f, 
    -0.02850011f, -0.06950602f, 0.04113607f, 0.01357681f, 0.20813026f, 0.17608453f, 0.12173373f, 0.13157895f, 
    0.12163670f, 0.07516285f, -0.04610427f, 0.08947126f, 0.07635944f, -0.04068121f, -0.02611280f, -0.17179734f, 
    -0.21931840f, -0.08629180f, 0.16389570f, 0.08215091f, -0.18545194f, -0.32728100f, -0.10532303f, 0.04294578f, 
    0.14689377f, -0.11121627f, 0.09056216f, -0.17289168f, -0.33103988f, -0.34114563f, -0.16468909f, -0.14160354f, 
    -0.18366292f, -0.14240405f, 0.21126351f, 0.04185679f, 0.13118508f, 0.10567456f, -0.06955800f, 0.18466069f, 
    -0.27229187f, 0.06662255f, 0.07037433f, 0.20223193f, -0.00748031f, -0.13749270f, 0.03775151f, -0.05062485f, 
    -0.17298570f, -0.17828543f, -0.06711915f, 0.00609394f, 0.01860023f, -0.00394785f, -0.24203829f, -0.38006482f, 
    0.01982056f, -0.11005120f, -0.06120089f, 0.04390460f, 0.08869589f, 0.19175301f, -0.06251752f, 0.02269161f, 
    -0.01160956f, -0.06678478f, 0.04280594f, -0.09675587f, -0.26134577f, -0.02900159f, -0.03501593f, 0.13724492f, 
    0.07856901f, 0.05856741f, 0.03107207f, 0.06762023f, 0.24616751f, 0.04171407f, -0.11034766f, -0.58288401f, 
    0.01501999f, 0.04920601f, 0.01184866f, -0.03409817f, 0.01480429f, 0.04015784f, -0.05715214f, 0.03386788f, 
    0.13030066f, 0.04037182f, 0.17251959f, 0.07608156f, 0.23544878f, 0.09937622f, -0.02991404f, 0.04667338f, 
    0.01234909f, 0.02208263f, 0.20911071f, 0.10192007f, 0.22289094f, 0.20002063f, 0.05170848f, 0.24434049f, 
    0.08762620f, -0.01785561f, 0.04311847f, -0.02595221f, 0.28955066f, 0.10359063f, 0.02015928f, -0.14313456f, 
    -0.55949533f, -0.32658049f, 0.08020410f, 0.00855958f, 0.10042315f, 0.17417184f, -0.01919955f, -0.10141261f, 
    0.13513654f, -0.00901360f, 0.06308649f, 0.14815785f, 0.23638368f, -0.01388102f, -0.01433931f, -0.17007279f, 
    0.09838324f, -0.06289489f, 0.09856986f, 0.01455939f, -0.15346892f, -0.06495927f, -0.09623890f, 0.07692870f, 
    -0.07029730f, -0.37470436f, -0.09742565f, 0.00014291f, 0.15358269f, 0.11958699f, 0.03017904f, 0.08450194f, 
    0.05639521f, 0.03870964f, -0.06830123f, 0.02124086f, 0.00697812f, -0.10451100f, -0.13826272f, 0.43445730f, 
    0.13973343f, 0.14921628f, 0.00048134f, 0.03245416f, -0.00419266f, -0.12316801f, -0.17112976f, -0.06228500f, 
    0.05602717f, -0.01620857f, 0.25756595f, 0.33122432f, 0.12195253f, -0.09460293f, -0.09342176f, -0.12767352f, 
    -0.10035879f, 0.08138412f, -0.11717876f, 0.08362728f, -0.28038651f, 0.36099386f, -0.08460346f, -0.46345618f, 
    -0.00950514f, -0.05957594f, -0.15194280f, -0.07215795f, 0.02856879f, 0.03684682f, 0.05652197f, 0.02057451f, 
    0.41221744f, 0.03019614f, 0.25725886f, 0.51562732f, 0.01611152f, 0.12415837f, -0.09541217f, -0.12122782f, 
    -0.02927031f, -0.01214967f, 0.02403267f, 0.03685330f, 0.42951137f, 0.27954873f, -0.11618199f, 0.36056632f, 
    -0.07412406f, -0.07330962f, -0.03687845f, -0.03433399f, -0.09975654f, 0.10735771f, 0.03247382f, -0.02098233f, 
    -0.03661763f, -0.04022668f, -0.05080703f, 0.05127364f, -0.05633016f, -0.05656298f, 0.02093767f, -0.04173957f, 
    -0.06710391f, -0.02389993f, 0.01723451f, -0.00925804f, 0.00378016f, -0.07900591f, -0.02409048f, -0.05185283f, 
    0.04232730f, -0.01738975f, 0.01420481f, -0.07437866f, 0.06499325f, -0.01783196f, 0.05383171f, -0.06523070f, 
    0.02962560f, -0.07065167f, -0.04131619f, -0.00663581f, -0.07711315f, 0.04793006f, -0.04741520f, -0.04384972f, 
    -0.03665194f, -0.05788273f, 0.04270485f, -0.06054663f, -0.06870487f, -0.07977613f, -0.01477191f, 0.02830092f, 
    -0.07214333f, 0.05440129f, -0.03775574f, 0.02681455f, 0.04510881f, -0.01861715f, -0.02542179f, -0.02803104f, 
    0.00472092f, -0.03946313f, 0.01944124f, -0.03074205f, 0.05082416f, -0.03468014f, 0.00594568f, -0.06040793f, 
    0.03169638f, -0.01023336f, 0.05548023f, -0.00509811f, 0.05442977f, -0.00045892f, 0.01216641f, 0.03839805f, 
    -0.03310131f, -0.06531528f, -0.02492051f, 0.02023308f, -0.06682324f, 0.03383140f, 0.02814841f, -0.05189969f, 
    0.02233676f, -0.04471875f, -0.03920276f, -0.05881815f, 0.00653004f, -0.07469177f, -0.07631896f, 0.01375208f, 
    0.00666641f, 0.00262883f, 0.00093987f, -0.03785709f, 0.02488297f, -0.05574162f, 0.04403626f, 0.06390469f, 
    0.00352276f, 0.01722161f, -0.00051525f, -0.01075718f, 0.00777902f, 0.00198503f, -0.05845270f, 0.05333697f, 
    0.01644509f, -0.06210207f, -0.02166045f, 0.03467745f, -0.05563844f, 0.06110387f, -0.04084310f, -0.01150424f, 
    -0.01709490f, -0.05597266f, 0.06483165f, -0.01942929f, -0.06489489f, -0.07639767f, -0.03103291f, -0.03423025f, 
    -0.02696588f, 0.03385860f, 0.02318601f, 0.02595347f, 0.00768271f, 0.01536896f, -0.04235747f, -0.03384800f, 
    -0.08046987f, -0.01987196f, 0.05897146f, 0.06147983f, 0.02325104f, -0.01001371f, -0.05913465f, -0.01255114f, 
    -0.02278094f, -0.05061118f, 0.03719427f, 0.02414877f, -0.01498721f, 0.04402692f, -0.05532957f, -0.02873950f, 
    0.03336946f, 0.03297082f, -0.01591752f, -0.06789045f, 0.04265018f, -0.05963705f, 0.03287224f, 0.03080961f, 
    0.00643536f, -0.04139207f, 0.06552798f, 0.01234278f, 0.00266901f, -0.00123245f, -0.03572489f, -0.06452918f, 
    0.00692288f, 0.05400361f, 0.05736235f, -0.01309434f, -0.02383222f, 0.03551432f, -0.02211598f, 0.00077130f, 
    0.04168670f, 0.01052977f, -0.08119434f, -0.06714261f, 0.05833838f, -0.01545754f, 0.05998847f, 0.05478203f, 
    0.04167239f, 0.06238323f, -0.00769670f, 0.04500871f, -0.01071397f, 0.04037447f, 0.01571597f, -0.00432079f, 
    -0.06321624f, -0.00698492f, -0.05657395f, 0.05750076f, 0.00765688f, -0.07044409f, -0.06485639f, -0.06010363f, 
    0.00746928f, 0.00168600f, -0.02258610f, 0.05916604f, 0.03602635f, 0.03661165f, -0.01311972f, -0.06754424f, 
    0.16074325f, -0.10045371f, 0.12081654f, 0.08793225f, 0.15903006f, 0.03809642f, 0.10378984f, 0.21091205f, 
    -0.09052707f, 0.09227676f, -0.04618353f, 0.17217708f, -0.05531706f, -0.06605033f, 0.16761962f, -0.04024417f, 
    0.15675165f, 0.07444903f, -0.12345839f, 0.01918560f, 0.09134585f, -0.12942410f, 0.10937173f, -0.29169837f, 
    0.23830378f, 0.20870917f, 0.23679310f, 0.01534460f, 0.08307301f, 0.06747098f, -0.19220909f, 0.05700269f, 
    0.15406981f, -0.10957622f, 0.04476305f, -0.09444117f, -0.06922121f, -0.16439685f, -0.04524826f, 0.10987381f, 
    -0.07047937f, 0.04670723f, 0.02646233f, -0.12998608f, -0.12602706f, -0.13674960f, 0.14167364f, -0.06888065f, 
    0.51366055f, -0.10771456f, -0.05789838f, 0.09972622f, -0.11564145f, 0.00052673f, -0.06378679f, -0.11979447f, 
    -0.15722741f, 0.10824518f, -0.09989284f, -0.09906629f, 0.17788817f, 0.11777742f, -0.26564261f, -0.08806292f, 
    0.12113890f, 0.02874277f, -0.08697245f, 0.02873179f, -0.02340383f, 0.01375125f, 0.07193881f, 0.14235523f, 
    0.08834540f, -0.13500886f, 0.01309680f, 0.11313603f, -0.14500988f, -0.02809882f, -0.03101854f, 0.07030094f, 
    -0.14359009f, -0.00574916f, -0.07682788f, -0.24833156f, -0.39884159f, 0.12817308f, -0.18013251f, 0.10451747f, 
    0.18156561f, 0.15696551f, 0.04439877f, 0.01205159f, 0.02704248f, -0.15790907f, -0.07730537f, -0.02885352f, 
    0.00541136f, 0.07117409f, -0.15298566f, 0.13563511f, 0.11742700f, 0.03556739f, -0.10346602f, 0.04751627f, 
    -0.07068283f, -0.20649377f, -0.07689408f, -0.19827835f, 0.04773952f, 0.13711074f, 0.12147406f, 0.14665803f, 
    -0.02291216f, 0.07823729f, 0.03481475f, 0.03949893f, 0.07827878f, 0.13725767f, -0.07241388f, -0.06045859f, 
    0.38685217f, 0.21888822f, -0.01588192f, -0.13695517f, 0.00007607f, 0.06017958f, 0.15502869f, -0.00241045f, 
    0.05299523f, 0.01489600f, 0.10258599f, 0.00895751f, -0.14222603f, -0.01654187f, -0.24493076f, -0.00030556f, 
    -0.08009563f, 0.01900649f, 0.01768081f, 0.01189844f, -0.05268777f, 0.15605824f, 0.06713051f, -0.08035202f, 
    0.06644658f, 0.21285713f, 0.03136404f, 0.07893953f, 0.17789395f, -0.01726284f, 0.11158901f, 0.00833595f, 
    -0.08728240f, -0.09092063f, 0.06725345f, -0.10678612f, 0.01261458f, 0.00750791f, 0.03797304f, 0.17397435f, 
    -0.03336382f, -0.00424775f, -0.06176942f, 0.11224404f, -0.03367734f, -0.05258330f, 0.07882951f, 0.03930928f, 
    0.13635638f, 0.19312587f, -0.01257040f, -0.13714032f, 0.17501779f, 0.00250331f, -0.03202405f, 0.00060875f, 
    -0.03168096f, 0.10007671f, 0.05358003f, -0.02421804f, -0.10526844f, -0.04354239f, 0.05256270f, 0.07949719f, 
    0.02162323f, -0.06767880f, 0.12866032f, -0.02257741f, 0.03256958f, -0.01993703f, 0.08273301f, 0.14907041f, 
    0.08009466f, 0.11303484f, -0.08631612f, -0.08153065f, 0.08675419f, 0.09130196f, 0.07869904f, 0.03375382f, 
    0.09807662f, -0.10594040f, 0.10681736f, 0.06448738f, 0.17297640f, -0.24497467f, 0.16184969f, -0.12674364f, 
    -0.06541053f, 0.00620283f, -0.03876738f, 0.01667989f, 0.08567345f, -0.02592636f, -0.09588752f, 0.04417817f, 
    0.29440647f, 0.25221997f, -0.01402695f, -0.11186191f, 0.02059873f, -0.10341059f, 0.08073324f, 0.03390334f, 
    0.16576007f, 0.04913267f, 0.04995708f, -0.06541675f, -0.02461551f, -0.06537225f, 0.09025205f, -0.00256542f, 
    0.11421631f, 0.06462788f, -0.00630867f, -0.12779203f, 0.10687026f, 0.06952082f, -0.17580132f, -0.03315270f, 
    0.09717767f, -0.27300900f, -0.08614478f, -0.13044181f, 0.03240042f, 0.00711030f, -0.05915327f, 0.25361589f, 
    0.02925085f, -0.00185841f, -0.06407712f, -0.02652536f, -0.19098385f, 0.05797255f, 0.04061210f, 0.21470492f, 
    0.12031332f, -0.02833666f, 0.06774410f, 0.05908080f, 0.01491034f, 0.08632778f, 0.08277249f, 0.04484261f, 
    -0.36403540f, -0.02165842f, -0.01481802f, 0.15630218f, -0.06078973f, 0.14023589f, -0.00739094f, -0.01063456f, 
    -0.03699686f, 0.17705762f, 0.06085435f, 0.23359172f, 0.41432253f, 0.04973553f, 0.32181823f, -0.20321815f, 
    -0.14487228f, -0.07854652f, -0.08424562f, -0.02689344f, 0.00920146f, 0.14254171f, 0.04330666f, -0.03525380f, 
    0.06432663f, 0.25286776f, 0.05480772f, 0.00923070f, -0.05973603f, -0.04639240f, 0.14242595f, -0.06582379f, 
    -0.17152470f, 0.21659143f, -0.02368712f, 0.11215347f, -0.17448458f, 0.15723442f, 0.05471681f, -0.12797625f, 
    -0.18627834f, -0.05268933f, 0.07146661f, 0.08447647f, -0.04703429f, -0.14803350f, 0.16217159f, 0.03496476f, 
    -0.43622226f, -0.00126994f, -0.01810300f, 0.13783984f, 0.01273602f, 0.06116674f, 0.06242920f, 0.07429856f, 
    -0.19477212f, 0.10028427f, 0.01898996f, -0.02535018f, 0.05464206f, 0.04490955f, -0.05054056f, 0.16953273f, 
    -0.01102502f, 0.10886493f, -0.01816204f, -0.13052660f, -0.10214118f, 0.05126202f, -0.16070123f, -0.01578678f, 
    -0.07675436f, -0.00880543f, -0.01653599f, -0.12363648f, -0.07302132f, 0.08983763f, -0.05054003f, -0.06821238f, 
    0.00334413f, 0.11208117f, 0.00581106f, 0.02785586f, -0.20447257f, -0.16760051f, 0.13780645f, -0.03783326f, 
    0.06122316f, 0.04206561f, -0.05034988f, -0.10742724f, -0.05046885f, 0.04581467f, -0.07630074f, 0.05215283f, 
    0.02705249f, 0.20792302f, 0.10773338f, -0.04509373f, -0.10047676f, 0.02909295f, 0.19235992f, -0.05420883f, 
    -0.02898463f, 0.01700793f, -0.00063013f, -0.06947666f, 0.04467790f, 0.27042398f, 0.21934912f, -0.15328823f, 
    0.07953236f, 0.03551299f, -0.00384307f, 0.07065144f, 0.12921304f, -0.04501583f, -0.05203865f, -0.14638706f, 
    0.01286614f, -0.06688257f, -0.07638212f, -0.07428975f, 0.02360559f, -0.04926053f, 0.02772455f, -0.02612902f, 
    0.06198329f, -0.03720383f, -0.06047934f, 0.04039900f, 0.03631063f, 0.02583252f, -0.06690193f, 0.04687523f, 
    -0.03575936f, 0.04759124f, 0.00312890f, -0.03658702f, -0.01265067f, 0.05312951f, -0.02317545f, 0.05560523f, 
    0.06147596f, 0.04457234f, -0.08085706f, 0.01080529f, -0.00659304f, -0.03527055f, -0.06197453f, 0.01836081f, 
    0.00393006f, -0.07477046f, -0.00781805f, 0.01015625f, 0.03283460f, -0.04408633f, -0.05828419f, -0.00158492f, 
    0.03463304f, 0.03582983f, -0.03349635f, -0.04486167f, -0.03458917f, -0.00845265f, 0.04706715f, -0.00760251f, 
    -0.07307775f, 0.04482201f, -0.01689046f, -0.03089432f, 0.03570862f, -0.04441792f, -0.03767395f, 0.00205659f, 
    -0.06107220f, -0.05194191f, -0.01166734f, -0.01695366f, 0.02437975f, 0.01880536f, 0.00242062f, -0.06177505f, 
    -0.00549396f, -0.06498320f, -0.03536974f, -0.02477461f, 0.02182299f, 0.05124671f, 0.00085835f, -0.05866665f, 
    0.06520227f, -0.01480064f, -0.05703888f, -0.06768634f, -0.06782015f, -0.06523290f, 0.05494170f, -0.06056748f, 
    -0.01388034f, 0.01785938f, 0.02825514f, 0.06355491f, 0.03959415f, 0.02508221f, -0.01851328f, 0.04781712f, 
    -0.06300156f, -0.01392041f, -0.04226540f, -0.05367456f, 0.03717576f, -0.03965995f, -0.06977854f, 0.00011299f, 
    0.02903882f, -0.04307535f, -0.00230159f, -0.05928028f, 0.00409786f, -0.01771601f, -0.07118252f, 0.06108733f, 
    -0.05085808f, 0.04382649f, -0.06646358f, 0.04680314f, 0.01808259f, 0.04384371f, 0.01291651f, -0.02360460f, 
    0.05426609f, -0.03296738f, 0.04717627f, -0.04053089f, -0.02782125f, 0.02815671f, -0.00753125f, -0.05105352f, 
    0.02216627f, 0.04769967f, -0.07772478f, -0.08023974f, 0.05523557f, 0.04879448f, -0.01104632f, -0.06131794f, 
    0.04254146f, -0.04713513f, 0.01711797f, -0.03013156f, 0.01445107f, 0.00860225f, -0.06672896f, -0.07331625f, 
    -0.05120629f, -0.02213657f, -0.07250647f, 0.01964562f, 0.02703837f, -0.06118735f, -0.00291086f, 0.04656767f, 
    -0.07105608f, -0.05252795f, 0.02414941f, -0.04501765f, 0.01697842f, 0.02658923f, 0.05815401f, -0.04124612f, 
    -0.03403426f, -0.00688215f, 0.04517771f, -0.02568620f, -0.00848062f, -0.01411915f, -0.04672724f, 0.04199987f, 
    0.00405513f, 0.02030201f, 0.05111513f, 0.06285297f, 0.00414405f, -0.07549749f, 0.04221508f, -0.03778603f, 
    -0.03068924f, 0.04773247f, 0.03939587f, 0.02364592f, -0.01051448f, 0.01284187f, 0.05577438f, -0.04633805f, 
    0.04174593f, 0.05063954f, -0.06551425f, -0.05663642f, 0.02107133f, 0.03871058f, -0.02080401f, 0.06890403f, 
    -0.06812776f, -0.05668525f, -0.06401380f, -0.07696790f, -0.03879643f, -0.06563000f, -0.07409289f, 0.01129542f, 
    -0.00493758f, 0.03143063f, 0.04770205f, -0.01688869f, 0.04753558f, -0.05412756f, -0.03840704f, 0.02744394f, 
    0.03036842f, -0.04063810f, -0.07861915f, 0.03616275f, 0.01771225f, -0.05624440f, 0.03726954f, -0.00778143f, 
    -0.07695780f, -0.05113510f, -0.03014079f, 0.00618038f, -0.05684749f, 0.04816794f, -0.01330352f, 0.04940215f, 
    0.03536602f, 0.00693256f, 0.04770786f, -0.07873635f, -0.03119839f, -0.07109426f, -0.06434714f, 0.02525377f, 
    0.03441786f, -0.03224153f, -0.02029018f, -0.06852175f, -0.02862151f, 0.01849762f, -0.04834465f, 0.03405888f, 
    0.05971687f, 0.03120451f, -0.06289665f, -0.01126096f, 0.05791602f, -0.03290467f, -0.00914222f, 0.02835567f, 
    -0.01543287f, 0.03235208f, 0.05109047f, 0.04527478f, 0.03062672f, -0.06869396f, 0.00120001f, -0.06368291f, 
    0.05623497f, -0.02028148f, 0.01153859f, 0.03021521f, 0.04243170f, 0.00324353f, -0.05886880f, 0.05438966f, 
    0.03405827f, 0.00942397f, 0.00596321f, -0.01240408f, 0.06508576f, 0.04696669f, -0.07752749f, 0.06514911f, 
    0.02413370f, -0.00650770f, -0.01194534f, 0.04337547f, -0.00775083f, -0.04086376f, 0.01520648f, -0.04641069f, 
    0.02675026f, -0.03806522f, -0.07331773f, -0.07897786f, -0.01690690f, 0.05034858f, 0.04061887f, 0.02236310f, 
    0.02230962f, -0.03415779f, -0.07455940f, -0.04627362f, -0.05716691f, -0.01790994f, -0.03876231f, -0.00565708f, 
    -0.00264905f, 0.00376569f, 0.01054769f, -0.02221805f, -0.00528921f, -0.07532407f, -0.07597185f, -0.04862723f, 
    -0.05387088f, -0.05143533f, 0.02571485f, 0.01789914f, -0.05384744f, -0.05259177f, 0.02291780f, 0.02682459f, 
    0.04755349f, 0.00754060f, 0.04258739f, 0.06050592f, -0.03474268f, -0.01618556f, 0.05342571f, 0.03143771f, 
    -0.04496435f, -0.00272978f, 0.05072786f, -0.04704483f, -0.00003301f, 0.03058780f, -0.03886811f, -0.07640332f, 
    0.04299630f, 0.00428742f, -0.03467851f, -0.05155034f, -0.06673125f, 0.02517234f, -0.06839322f, -0.06909194f, 
    -0.04153828f, -0.02943945f, -0.00116692f, 0.03357227f, 0.02211037f, -0.06041125f, 0.00799482f, -0.06549313f, 
    -0.07753827f, 0.02135715f, 0.00621325f, -0.04545976f, 0.02042093f, -0.01667803f, 0.06184302f, -0.01253038f, 
    -0.05448375f, -0.02300394f, -0.02427522f, 0.01360498f, -0.01916198f, -0.00501885f, -0.02906648f, -0.04713840f, 
    -0.02728313f, -0.06006636f, 0.00066903f, -0.00757667f, 0.04841238f, -0.07964803f, -0.04285365f, 0.00544681f, 
    -0.00919948f, 0.00170209f, -0.06488728f, 0.03017124f, -0.07199673f, -0.05334628f, 0.00435536f, -0.07814084f, 
    -0.01244770f, 0.03272290f, 0.00915368f, -0.04315596f, -0.04826276f, 0.01393563f, 0.01126963f, -0.07613352f, 
    -0.06125586f, -0.05003651f, 0.02636980f, -0.05515721f, -0.05156995f, 0.02892225f, 0.03465395f, -0.02576125f, 
    0.00049557f, -0.13147920f, -0.03220918f, 0.20692208f, 0.22243612f, 0.08341289f, -0.08538211f, 0.08293592f, 
    0.04488114f, 0.07834285f, 0.08720288f, 0.11082106f, 0.05160320f, -0.13848808f, 0.13199235f, -0.12808564f, 
    -0.06742799f, -0.00544412f, -0.00667741f, -0.02419029f, -0.00065006f, -0.05506912f, 0.00038677f, 0.05744904f, 
    0.26053730f, -0.01679225f, 0.01081269f, 0.13352229f, 0.08938629f, -0.05916445f, 0.11436658f, 0.01034283f, 
    0.06960616f, 0.19910344f, 0.03884370f, -0.15896848f, 0.06179954f, -0.25571948f, -0.27497852f, 0.11255161f, 
    0.01352638f, -0.01775756f, 0.02330071f, -0.17164598f, 0.01920370f, 0.15363410f, 0.01046478f, 0.19225317f, 
    0.10657839f, -0.05378961f, -0.18390359f, -0.03598407f, 0.17289613f, 0.18979910f, 0.00423663f, 0.06595644f, 
    0.02753969f, -0.07848753f, 0.05568114f, -0.15846956f, -0.10514766f, 0.01874811f, -0.09946748f, 0.15750554f, 
    0.10895858f, -0.07613047f, -0.04150337f, 0.02686321f, 0.01103798f, -0.07319669f, -0.01314980f, 0.05913486f, 
    -0.11566325f, -0.06804829f, 0.03990662f, 0.10971475f, -0.03871096f, 0.01320421f, -0.03059017f, 0.02027382f, 
    -0.05237259f, 0.09779300f, -0.08989765f, -0.01395127f, 0.12015421f, 0.16793895f, 0.26705813f, -0.30052930f, 
    0.10233511f, -0.03637642f, 0.04609413f, 0.02266784f, -0.06374226f, 0.03010038f, -0.15669389f, 0.06580649f, 
    0.34194690f, 0.26733372f, 0.03301644f, -0.18189502f, -0.15512273f, -0.12009248f, 0.04928732f, -0.00152148f, 
    -0.02990179f, 0.07434198f, 0.06604517f, -0.03447997f, 0.16341637f, 0.14097868f, 0.29522458f, -0.18631057f, 
    -0.07668047f, -0.01207344f, 0.21689086f, 0.11989439f, -0.02492752f, 0.05320776f, 0.26001322f, 0.00922280f, 
    -0.14890009f, 0.15003017f, 0.24290758f, 0.18441243f, 0.02135883f, 0.11349099f, 0.06146072f, -0.03116053f, 
    -0.09738573f, -0.02788037f, 0.02736283f, -0.02359201f, 0.05663772f, 0.18528640f, 0.32013211f, -0.21295156f, 
    0.06926530f, 0.18677008f, -0.24814211f, -0.07398045f, 0.01177559f, 0.14293648f, 0.00324087f, 0.06790406f, 
    -0.17272311f, 0.21138895f, 0.03341079f, -0.41620842f, -0.04158501f, 0.04077366f, -0.06458355f, 0.06834547f, 
    0.05136562f, 0.02125713f, 0.08751642f, -0.02635336f, -0.40135002f, -0.15990935f, 0.08290029f, 0.06080260f, 
    -0.00825080f, 0.04565637f, -0.06197283f, 0.07897624f, -0.04931102f, 0.02761685f, 0.06548698f, 0.10244111f, 
    -0.27753204f, 0.34424657f, 0.10507172f, -0.17851330f, 0.08101034f, 0.00188940f, 0.21837068f, 0.00595460f, 
    0.07594609f, -0.04418159f, 0.00664051f, -0.05069034f, 0.15737681f, -0.19581814f, 0.15154247f, -0.17557760f, 
    0.12061638f, -0.03991977f, -0.04166256f, 0.14035958f, -0.00745071f, -0.02404858f, -0.06429594f, 0.00424318f, 
    0.04334326f, -0.01782493f, 0.04969082f, -0.03908126f, -0.08291669f, -0.04653385f, 0.01529022f, -0.02599520f, 
    -0.06484189f, -0.02158168f, -0.07352977f, -0.06745729f, 0.02541216f, -0.02199478f, -0.04991850f, 0.04298561f, 
    0.06066050f, -0.00156697f, -0.07974452f, 0.02226206f, -0.02188881f, -0.01677174f, 0.03691434f, -0.07772452f, 
    0.01702350f, -0.01556838f, -0.04119469f, -0.06329781f, -0.05978404f, 0.01200894f, -0.02384271f, -0.05943708f, 
    0.00045540f, -0.05514472f, -0.04954988f, 0.05498852f, 0.03013386f, 0.00885733f, 0.03816872f, -0.00159299f, 
    -0.05145572f, 0.04327335f, -0.01791004f, 0.05702750f, 0.03055380f, 0.03196288f, 0.03602952f, -0.05067623f, 
    -0.02205962f, -0.01002372f, 0.05946280f, 0.03422276f, -0.07757774f, -0.00895945f, -0.00427476f, 0.01499473f, 
    -0.05307176f, -0.01360248f, 0.00413388f, 0.01042734f, -0.08143451f, 0.01394474f, -0.06930729f, 0.01564696f, 
    -0.02515296f, 0.05045828f, -0.07001064f, -0.07593633f, 0.04441499f, -0.07692402f, -0.04032038f, -0.07720378f, 
    -0.05792127f, 0.04059048f, -0.07339188f, -0.06755506f, 0.04062964f, 0.02461712f, -0.03759524f, -0.04196370f, 
    -0.07085375f, -0.00565103f, -0.00643995f, 0.03351241f, -0.04210982f, -0.06268203f, -0.02833932f, 0.00098659f, 
    0.06186871f, -0.03483193f, 0.03515168f, 0.06320097f, 0.04080757f, -0.00437267f, -0.04181150f, 0.00482442f, 
    -0.06850375f, 0.02352894f, 0.05131469f, -0.03237991f, 0.00434042f, 0.02575763f, -0.00257594f, -0.05855164f, 
    -0.02209143f, 0.06083582f, 0.01378547f, 0.05487395f, 0.02196199f, 0.06371076f, -0.02356829f, 0.04826306f, 
    -0.04072199f, -0.03662145f, 0.02349946f, -0.06141045f, 0.04854198f, 0.00306576f, 0.03094076f, 0.04340231f, 
    -0.05598260f, -0.01445969f, 0.05648189f, -0.03411480f, -0.04167873f, -0.04795128f, -0.04774215f, 0.02922884f, 
    0.00493993f, -0.01883974f, -0.00676243f, -0.04334455f, -0.00296198f, -0.06333867f, -0.02032849f, 0.01837114f, 
    -0.06339975f, 0.03478776f, -0.05053960f, -0.00250599f, 0.01481819f, 0.05991762f, -0.07597215f, 0.04184638f, 
    -0.02729254f, -0.05964164f, -0.01055399f, -0.02632802f, -0.02254250f, -0.07569621f, 0.03064367f, -0.04184545f, 
    0.00452028f, 0.04302526f, 0.01114844f, -0.07363937f, -0.06052812f, 0.00990648f, -0.02376765f, 0.04170883f, 
    0.06620420f, 0.05280374f, 0.00662743f, -0.04874343f, 0.04173333f, -0.04113444f, 0.06198876f, -0.00644779f, 
    -0.05358427f, -0.04822256f, -0.03459765f, 0.03838026f, 0.01238267f, -0.00845286f, 0.00016510f, -0.06791604f, 
    -0.01727165f, 0.03224833f, 0.05426267f, 0.02354010f, -0.03247885f, 0.01848317f, -0.00127899f, 0.02359813f, 
    0.06105155f, 0.01339863f, 0.01944276f, -0.07023375f, 0.01137396f, -0.03098711f, 0.02030128f, 0.00665214f, 
    0.03886400f, 0.12870410f, -0.03762374f, 0.14189467f, 0.07536107f, 0.05913464f, 0.00142099f, -0.03412578f, 
    0.00978824f, -0.00944525f, 0.10624012f, 0.11097103f, -0.19212574f, 0.13680527f, -0.15688214f, -0.14253534f, 
    -0.07123419f, 0.03339416f, -0.09632547f, -0.05513628f, -0.02102380f, 0.09501458f, 0.15191096f, -0.21504131f, 
    0.16635808f, -0.18893869f, -0.01815518f, 0.12064429f, -0.03559417f, 0.03896373f, -0.00103216f, -0.00541382f, 
    -0.07564104f, 0.06896471f, -0.06710824f, 0.00924744f, 0.02141283f, -0.13564795f, 0.02280877f, 0.23024055f, 
    0.06609091f, 0.00050687f, -0.06094206f, -0.08658361f, -0.04760420f, -0.02114956f, -0.02570400f, 0.05255017f, 
    0.60856342f, 0.19247717f, 0.31624177f, -0.05109669f, 0.03076066f, 0.00855430f, 0.04642104f, -0.03058998f, 
    0.07298528f, -0.11637864f, -0.01995210f, -0.04926947f, -0.34722793f, 0.06266826f, 0.00982799f, 0.09055541f, 
    -0.11418679f, 0.09136086f, -0.05574274f, 0.05017293f, 0.06855761f, -0.11857978f, 0.04176684f, -0.13564822f, 
    -0.02823240f, 0.05221854f, -0.01742023f, -0.19758280f, -0.13906102f, 0.05286285f, -0.15574826f, -0.06568638f, 
    -0.10718678f, -0.15773557f, -0.06213733f, -0.09632532f, 0.38407317f, -0.12919872f, 0.25903374f, -0.16178504f, 
    0.06546264f, 0.10512267f, 0.01364826f, 0.07078113f, 0.14088345f, -0.10797313f, -0.15182744f, 0.10157679f, 
    0.04191054f, -0.08812845f, 0.02345824f, 0.13262995f, 0.05666486f, -0.00407570f, -0.03273361f, 0.00288509f, 
    0.11493185f, -0.14134958f, -0.06051529f, -0.12544690f, 0.27280751f, -0.07890508f, 0.16138886f, -0.05433716f, 
    -0.06422719f, -0.01852700f, -0.03749436f, 0.11775119f, -0.07254718f, -0.03564559f, -0.08118799f, -0.08944715f, 
    -0.07770115f, 0.19438086f, -0.25617686f, 0.11718908f, 0.01240419f, -0.17279828f, 0.02690065f, 0.11506546f, 
    0.07921159f, 0.02977415f, 0.06710856f, 0.07076788f, 0.35830760f, 0.16740800f, -0.14378075f, -0.24648131f, 
    -0.05831739f, 0.11675718f, 0.21720660f, 0.01346781f, 0.00961355f, 0.08580177f, 0.10045071f, 0.01814514f, 
    0.16560294f, -0.18732667f, 0.26645362f, 0.16293201f, -0.09300794f, 0.04470568f, -0.06869933f, -0.09852749f, 
    0.06481151f, -0.13336751f, -0.11873899f, -0.14712131f, 0.29544547f, -0.05102688f, -0.15528788f, -0.07006620f, 
    -0.14382100f, 0.01117638f, 0.08755758f, 0.01348304f, -0.06407262f, 0.10137496f, -0.12916106f, 0.05372636f, 
    0.37611741f, 0.04688999f, -0.01555578f, 0.43722859f, -0.13614954f, 0.02261779f, -0.04697383f, -0.02971093f, 
    -0.06738091f, 0.17705205f, 0.20460957f, 0.06086610f, 0.16842060f, -0.42946279f, 0.15563586f, -0.00256809f, 
    -0.03865028f, 0.16061538f, 0.14190240f, 0.14027326f, -0.06255799f, 0.19499554f, 0.04466001f, 0.16625582f, 
    -0.01965683f, 0.11682796f, 0.13601154f, 0.23039380f, 0.33262295f, 0.29203421f, -0.07494041f, -0.06379230f, 
    0.05029074f, 0.04641589f, 0.01794096f, -0.14647135f, 0.41297075f, -0.15976845f, 0.09667371f, 0.11532575f, 
    0.06040381f, 0.01916945f, 0.08857524f, 0.05825524f, 0.06554884f, 0.02286185f, 0.04115150f, -0.08952095f, 
    0.20954099f, -0.23240662f, -0.07984164f, 0.04478950f, 0.28541654f, 0.19826940f, 0.05610213f, -0.07100011f, 
    0.04678738f, 0.23102950f, 0.11462650f, 0.22486115f, -0.01568072f, 0.05205870f, 0.22593860f, 0.19942777f, 
    0.07740405f, 0.02623634f, -0.06688165f, -0.14732172f, -0.14421257f, 0.04076365f, -0.04438375f, 0.05089420f, 
    0.08750983f, -0.06874520f, 0.16895603f, 0.23808397f, 0.07141296f, 0.06382735f, -0.11311368f, -0.11838853f, 
    0.02094506f, 0.18109962f, -0.09818435f, 0.07237536f, -0.00192322f, 0.14866647f, -0.01506928f, 0.34977847f, 
    0.20876621f, 0.04909829f, 0.06550787f, 0.07165582f, 0.32825741f, 0.05031237f, 0.07485245f, 0.03360060f, 
    -0.08608162f, -0.26009381f, -0.06022353f, 0.06923373f, 0.29929245f, 0.21275900f, 0.03217910f, 0.02096476f, 
    0.04890431f, 0.20633601f, -0.11487135f, 0.14444767f, 0.13853994f, -0.44129613f, -0.34525821f, -0.35075665f, 
    -0.01050307f, -0.12008926f, -0.00892510f, -0.11801225f, 0.04081656f, 0.19294918f, -0.18746950f, -0.13224043f, 
    0.25824255f, 0.00718046f, 0.33137223f, 0.17732334f, -0.02521647f, -0.03877776f, 0.11355681f, -0.00246397f, 
    -0.12992932f, 0.20429908f, 0.18979837f, 0.18708228f, -0.28859210f, -0.40122873f, 0.00215353f, -0.38745993f, 
    -0.25275254f, 0.09709436f, 0.06283079f, 0.13490230f, -0.22757195f, 0.00444600f, -0.05508850f, 0.11398514f, 
    0.02382986f, 0.15383665f, 0.07683685f, -0.04596606f, -0.05281573f, -0.01544404f, -0.01496847f, -0.09404454f, 
    0.05081613f, 0.05014512f, 0.19442973f, -0.11309731f, -0.09261624f, 0.05492912f, -0.02733427f, -0.11128631f, 
    -0.16477565f, -0.23222956f, -0.23508681f, 0.02631682f, -0.19717385f, -0.12393967f, 0.10890315f, 0.02317483f, 
    -0.11412949f, -0.24778330f, -0.23146518f, -0.25282431f, -0.25292167f, -0.05590010f, -0.06210407f, -0.20006830f, 
    0.01506744f, 0.16872235f, -0.08272842f, 0.00884352f, -0.15386859f, 0.07862327f, -0.04361278f, 0.09946126f, 
    0.13745728f, 0.00044264f, 0.09365499f, 0.17399484f, -0.34626886f, -0.09865724f, 0.03839594f, -0.01026623f, 
    -0.44060758f, -0.04314538f, -0.11994383f, -0.36399320f, 0.00152365f, -0.04661425f, -0.04541100f, -0.16232561f, 
    -0.08743139f, 0.05696724f, -0.01287244f, -0.01478977f, -0.22629237f, -0.44600561f, -0.51896554f, -0.38919160f, 
    0.03410392f, 0.04712214f, -0.16785559f, -0.03845522f, 0.03438976f, -0.06493477f, -0.13081637f, 0.07873710f, 
    0.16164663f, 0.00187087f, 0.05414579f, -0.20857295f, -0.00204158f, -0.08035102f, 0.12751311f, 0.14661106f, 
    -0.01560436f, 0.10788634f, 0.06991056f, 0.14248459f, -0.05034678f, 0.12989734f, -0.02072082f, -0.17305245f, 
    -0.10355297f, 0.14113927f, 0.06857064f, 0.11366802f, 0.06491260f, -0.01352874f, 0.15175000f, 0.03371634f, 
    0.45613754f, 0.06448372f, 0.04674976f, -0.09282937f, -0.04933913f, -0.13105479f, 0.04799490f, -0.00130181f, 
    0.01708735f, -0.02951214f, -0.09249526f, 0.07501866f, -0.14406762f, -0.04833117f, -0.14756130f, -0.36138108f, 
    0.20341240f, -0.00436777f, 0.06548589f, 0.03911743f, 0.11165741f, -0.09066764f, -0.03559926f, -0.04327190f, 
    0.31702590f, -0.18652692f, -0.05248958f, -0.13445438f, -0.10871395f, -0.04133351f, 0.11333513f, 0.17020343f, 
    0.08620223f, 0.00913558f, 0.00009953f, 0.05826478f, -0.09235660f, 0.05947992f, 0.09691213f, -0.31395766f, 
    -0.05826278f, -0.02746783f, 0.07321537f, -0.03822453f, 0.03355062f, 0.14239660f, 0.04215343f, 0.09913689f, 
    -0.04052410f, -0.29915816f, -0.06438123f, 0.20838779f, -0.02567126f, 0.11441722f, 0.00235852f, 0.14911908f, 
    -0.05799389f, -0.03405669f, 0.00501192f, 0.13004319f, 0.39043596f, -0.12858866f, 0.21580952f, 0.17948280f, 
    -0.05065225f, 0.09889188f, -0.15071172f, 0.04504586f, 0.04408402f, 0.10580485f, 0.07351945f, 0.04070743f, 
    -0.22401026f, 0.26613635f, 0.02571119f, -0.25591484f, 0.08144169f, -0.00641473f, -0.03729855f, -0.08783434f, 
    0.01293310f, 0.01354504f, -0.10647219f, -0.02195580f, -0.30176744f, 0.10690553f, -0.07930430f, 0.15654685f, 
    -0.06470834f, 0.15367487f, 0.06309311f, 0.05476506f, -0.01884081f, 0.04848118f, 0.06641570f, 0.01969784f, 
    -0.56753045f, 0.08557555f, 0.06039631f, 0.09700122f, 0.01967935f, 0.05436430f, 0.07406928f, -0.02191428f, 
    0.12668411f, 0.01293200f, -0.11450002f, -0.08647139f, 0.25779399f, 0.04890929f, -0.02636317f, 0.34217975f, 
    0.17282395f, 0.00609642f, 0.00953479f, -0.03727941f, 0.12233420f, -0.14122172f, 0.08688103f, 0.05020396f, 
    0.15724283f, -0.17536901f, 0.13877206f, 0.12025303f, -0.21311587f, -0.00412550f, -0.06178975f, -0.06390371f, 
    0.24524523f, 0.07713603f, -0.01719739f, -0.08359934f, -0.01239038f, -0.05188390f, -0.02866837f, -0.28807467f, 
    0.12205137f, -0.01069602f, -0.04870778f, -0.08999138f, 0.07335490f, 0.16592713f, -0.07457983f, 0.07442255f, 
    0.08505581f, 0.09513345f, 0.08355945f, 0.21699116f, 0.03959860f, 0.02243507f, 0.04922960f, 0.03185769f, 
    -0.08296852f, 0.06429738f, 0.12660685f, 0.15794617f, 0.51221693f, -0.32368603f, -0.11856359f, 0.31502113f, 
    0.07654272f, 0.04338305f, -0.05879363f, 0.14460903f, 0.05253744f, 0.15420215f, 0.08986287f, 0.09043916f, 
    -0.10723700f, -0.00781201f, 0.35824344f, 0.56687582f, -0.10195746f, -0.18715982f, 0.00622277f, 0.18710534f, 
    0.03467606f, 0.06133854f, 0.08949194f, 0.08050917f, 0.23060213f, -0.08780565f, -0.10628062f, 0.05356071f, 
    0.04583150f, 0.11416741f, 0.00464752f, 0.00986713f, 0.14468610f, 0.09452046f, 0.14291678f, -0.05037950f, 
    -0.30505887f, 0.03530687f, 0.16806410f, 0.13147461f, 0.02970012f, 0.05056537f, -0.02292978f, 0.07180869f, 
    0.04206783f, 0.07741100f, -0.02652824f, 0.07854284f, 0.13744588f, 0.30043861f, -0.16109820f, 0.04511647f, 
    0.03587258f, -0.14870812f, -0.04118439f, 0.03527857f, 0.06388054f, 0.12142492f, 0.25170836f, -0.13559468f, 
    0.67934179f, 0.14040041f, 0.13470845f, 0.14955558f, 0.00292320f, 0.03074925f, 0.01496800f, -0.00503880f, 
    0.01365750f, -0.02673123f, 0.03791298f, 0.06552512f, 0.14946568f, 0.13033414f, -0.18241717f, -0.21254382f, 
    0.13684782f, 0.06284991f, -0.25740558f, 0.10936288f, -0.02811991f, 0.01689328f, -0.05270464f, 0.08512893f, 
    0.39497280f, 0.16864349f, 0.09469374f, -0.06038503f, 0.08109758f, 0.04459156f, -0.01086508f, 0.17658906f, 
    -0.11161179f, 0.00742401f, 0.07330496f, -0.04221602f, -0.14398694f, -0.18067192f, -0.19786394f, -0.03810403f, 
    -0.03393279f, -0.01407390f, 0.06777777f, -0.02912587f, 0.02646654f, -0.11209930f, -0.16994037f, -0.11063211f, 
    -0.29027098f, -0.05394295f, -0.02953329f, 0.15971413f, 0.00860902f, 0.17587158f, -0.14030150f, -0.07192182f, 
    0.02244483f, -0.12190869f, -0.05286857f, -0.03654290f, -0.09907368f, -0.29306450f, 0.17362517f, -0.12781397f, 
    -0.00421701f, 0.18896513f, 0.14121147f, -0.06111304f, -0.04025556f, 0.08841339f, -0.18765365f, 0.03333439f, 
    0.22442977f, -0.19539890f, 0.06179653f, -0.09861488f, -0.03092242f, 0.15621504f, 0.07129434f, -0.10749923f, 
    -0.00988236f, 0.11916618f, 0.04176906f, 0.09110531f, -0.07049480f, -0.03937148f, -0.09677435f, -0.04998329f, 
    0.05413030f, 0.07218651f, 0.06963488f, 0.01318855f, -0.00232022f, 0.10208307f, -0.04741713f, 0.08644394f, 
    -0.01002077f, -0.25608134f, -0.00930376f, 0.18234417f, 0.04047855f, -0.19255173f, 0.03696314f, -0.04376281f, 
    -0.10076910f, -0.09893583f, -0.03820715f, -0.11317968f, 0.14617565f, 0.53186136f, -0.35106224f, 0.08195968f, 
    0.01498879f, -0.05790587f, -0.08617453f, 0.31583592f, -0.10205646f, -0.04859693f, 0.10829594f, -0.00799936f, 
    0.25963843f, -0.18313202f, -0.03172710f, 0.02518297f, -0.02361856f, 0.04711662f, 0.01831025f, -0.09203305f, 
    -0.01584101f, 0.18118216f, 0.07339649f, 0.01084992f, -0.08100685f, -0.11610513f, -0.29325572f, 0.07321421f, 
    -0.09626664f, -0.10871141f, -0.06829670f, 0.01978692f, -0.05947687f, 0.01264108f, 0.06434224f, 0.00924219f, 
    -0.14422919f, 0.15251499f, 0.27278388f, 0.31754524f, 0.03487995f, 0.02767722f, -0.03154863f, 0.12744406f, 
    0.14687262f, -0.08088966f, -0.00043484f, -0.12945110f, 0.04420646f, -0.11326215f, 0.18148324f, 0.06052302f, 
    -0.04200511f, -0.08229431f, 0.24391884f, -0.08431759f, 0.00694761f, 0.17766312f, -0.15331061f, 0.17016515f, 
    -0.31201804f, -0.01065873f, 0.07179376f, 0.11431549f, 0.04720905f, 0.02594118f, 0.03142523f, 0.09778471f, 
    -0.04587995f, 0.08759575f, -0.08149238f, 0.19525744f, 0.02061539f, 0.07066481f, -0.10431746f, -0.00196439f, 
    -0.11976869f, -0.10677604f, -0.08883060f, 0.06115998f, 0.04217372f, 0.02126680f, 0.06726001f, -0.01452906f, 
    -0.31518322f, 0.04920507f, 0.22166996f, 0.10619426f, 0.14617237f, 0.22625165f, 0.02890882f, -0.10334199f, 
    -0.00014448f, 0.12676401f, -0.02907956f, 0.02731678f, 0.25911269f, 0.16985431f, 0.05536822f, 0.11909070f, 
    0.06081337f, -0.05303167f, 0.08348735f, 0.03866895f, 0.02333488f, -0.02990478f, -0.06904344f, -0.04355849f, 
    0.11744056f, 0.04602868f, 0.28256288f, 0.09184863f, 0.27795702f, 0.05275855f, 0.09908906f, 0.01722898f, 
    0.02971654f, 0.08092172f, -0.01241775f, 0.03032505f, 0.11320341f, 0.15356305f, -0.35572538f, 0.07642221f, 
    0.05953197f, -0.04697134f, 0.01093896f, -0.06150120f, 0.06155501f, 0.16090710f, 0.04291039f, -0.11995070f, 
    0.06053700f, -0.18253535f, 0.06309058f, 0.07790554f, -0.04823980f, -0.01619905f, -0.04802208f, -0.14904721f, 
    0.07843119f, 0.05735467f, 0.05355464f, 0.13691448f, 0.35860133f, -0.18284896f, -0.12036778f, -0.19994015f, 
    0.06370678f, 0.03250014f, 0.09650302f, 0.03059197f, 0.07679439f, -0.02681859f, 0.10303777f, 0.10604569f, 
    0.31088904f, -0.33980733f, 0.25889555f, -0.14780347f, 0.00842855f, 0.15185343f, -0.08790293f, -0.02825921f, 
    -0.11318905f, 0.00011816f, 0.05652277f, -0.03711240f, -0.05265539f, -0.17776045f, 0.05850611f, -0.09772100f, 
    0.05751921f, -0.21015088f, -0.17090431f, -0.06644362f, 0.03312663f, -0.06145019f, -0.04904984f, 0.04864107f, 
    -0.44188151f, 0.10757875f, -0.21113992f, -0.07004275f, 0.04454039f, -0.21257719f, 0.00066444f, 0.00991023f, 
    -0.01595214f, -0.02994087f, 0.06508787f, 0.10877600f, -0.49160764f, 0.19955747f, 0.06511515f, -0.00607777f, 
    0.00501338f, 0.03124690f, 0.01301376f, -0.04407873f, 0.09393556f, 0.01001610f, 0.10748054f, -0.04346332f, 
    -0.06260648f, 0.10364127f, 0.00085757f, -0.00878470f, 0.12876754f, 0.10058603f, -0.02929262f, -0.12530400f, 
    0.04442986f, -0.08845122f, -0.19505896f, 0.03744982f, 0.07408741f, 0.11234722f, -0.22480759f, 0.07832246f, 
    -0.14827302f, -0.07975113f, -0.07396255f, -0.07122378f, -0.07631507f, 0.08631571f, 0.08081559f, -0.05042215f, 
    0.05360215f, -0.03676188f, 0.00650291f, -0.02263414f, -0.07417110f, 0.01389461f, -0.05308222f, 0.00947541f, 
    -0.04393523f, -0.02603178f, 0.03438533f, 0.05893157f, 0.04915466f, -0.00602509f, 0.01260717f, -0.07644761f, 
    0.06504216f, 0.05518607f, -0.03522757f, -0.01882899f, -0.05085990f, -0.04828293f, 0.03870430f, 0.02454327f, 
    0.04152193f, 0.03214786f, -0.01028514f, 0.03259723f, -0.02832354f, 0.04998384f, -0.06857780f, -0.03430603f, 
    -0.06243264f, -0.05468556f, -0.04924218f, -0.00054703f, -0.00103282f, 0.05145048f, -0.01457614f, -0.01714381f, 
    -0.01518840f, 0.05343891f, 0.05576716f, -0.03179569f, -0.03286413f, 0.06039719f, 0.01790322f, -0.05145786f, 
    -0.07415634f, -0.07243550f, 0.04005973f, -0.01141841f, -0.00690836f, -0.03526278f, -0.01472476f, 0.01931934f, 
    -0.00528481f, 0.06248176f, 0.01037822f, -0.03534985f, -0.06723681f, -0.00003554f, 0.04970670f, -0.00006403f, 
    0.02422614f, -0.03503102f, -0.03883033f, -0.06479230f, -0.03979972f, -0.07929514f, 0.02595222f, 0.05403338f, 
    0.01338839f, -0.03771651f, 0.01112744f, -0.05265635f, -0.06422403f, -0.00951017f, 0.03097048f, -0.07119276f, 
    0.02724220f, 0.01724726f, -0.01513509f, -0.05572373f, 0.03509016f, 0.02483572f, 0.04829881f, 0.05240579f, 
    -0.01383845f, 0.00140304f, 0.05360473f, 0.04575796f, 0.05861217f, 0.02207273f, -0.00622161f, 0.03241874f, 
    -0.02552328f, -0.02540835f, -0.01310464f, -0.06724306f, 0.05882833f, 0.04736882f, 0.04176348f, -0.03558296f, 
    0.06038466f, -0.03392991f, 0.01215173f, 0.03944477f, 0.04499805f, -0.07252494f, -0.08291936f, -0.06301726f, 
    0.06221023f, -0.06140748f, -0.06336105f, -0.05562910f, 0.04065602f, -0.00570171f, 0.04757053f, -0.01046521f, 
    0.06111671f, 0.02210890f, -0.03518633f, -0.06519604f, 0.05316221f, 0.02188266f, 0.05577511f, -0.04781336f, 
    0.02751502f, 0.02156762f, 0.04417425f, -0.04727813f, -0.06717353f, 0.02574905f, 0.06684533f, 0.05520971f, 
    -0.04264593f, -0.00698943f, -0.01038698f, -0.03994279f, 0.00343677f, -0.06799421f, -0.00742146f, -0.03993031f, 
    -0.07317115f, 0.02679912f, -0.06170319f, -0.07070100f, -0.01349754f, 0.04599109f, -0.08042887f, -0.07812789f, 
    0.03250655f, -0.07009133f, -0.01859180f, -0.02587366f, -0.05891551f, 0.00190252f, -0.02848042f, 0.03077599f, 
    -0.04071838f, -0.04765088f, 0.04219217f, -0.04844738f, -0.06268118f, -0.00789435f, 0.04689359f, -0.06745449f, 
    0.02315280f, 0.02441771f, -0.05600044f, -0.05237097f, -0.03594624f, -0.04031622f, -0.04292029f, -0.02474556f, 
    -0.05126451f, -0.04974262f, 0.03526647f, -0.05530129f, 0.02161043f, -0.02044387f, -0.04275907f, -0.07535117f, 
    -0.05618719f, 0.01317810f, -0.04241364f, -0.02578112f, 0.00946609f, -0.00995730f, -0.06820470f, 0.02712959f, 
    -0.07735443f, -0.02544543f, 0.02297443f, 0.06457534f, 0.00493074f, -0.02381289f, -0.04680296f, -0.03313721f, 
    -0.02127867f, -0.07002101f, 0.04721677f, -0.00464150f, -0.06348303f, -0.00563496f, -0.07077896f, -0.07200278f, 
    0.04419823f, -0.05481889f, 0.03332964f, 0.00460536f, 0.01055512f, -0.03070992f, -0.00891693f, -0.01784630f, 
    -0.00119462f, 0.04098770f, -0.00509559f, -0.02640939f, 0.02439009f, 0.04213259f, -0.01296934f, 0.06618726f, 
    -0.05730122f, -0.07385632f, 0.01615076f, 0.01170121f, 0.02649391f, -0.04770992f, -0.05005164f, -0.03253081f, 
    0.04507046f, -0.04355984f, 0.01200386f, 0.02748221f, -0.05899823f, 0.04200238f, 0.05859026f, -0.03799985f, 
    0.02289507f, -0.02545213f, -0.02058043f, 0.05384137f, -0.05200439f, 0.01914817f, 0.04084377f, -0.05539272f, 
    -0.06486104f, -0.03545880f, 0.00454728f, -0.02893349f, -0.01015805f, -0.02749245f, -0.06700061f, 0.04419778f, 
    0.01049385f, -0.03236501f, 0.06658713f, -0.00569020f, 0.01101567f, -0.05876032f, -0.01093877f, -0.02157982f, 
    -0.01634289f, -0.05231896f, 0.02308586f, -0.02062167f, 0.02277809f, -0.03042548f, -0.05867804f, -0.06563012f, 
    -0.00710490f, -0.07588992f, -0.02724963f, 0.03639948f, -0.01592226f, -0.06937555f, 0.00712915f, -0.04185788f, 
    0.02001846f, 0.02872949f, -0.00070243f, -0.03018079f, -0.01623529f, -0.00258057f, 0.01084431f, -0.05145530f, 
    0.05685786f, 0.06034220f, -0.07345580f, -0.05202626f, -0.06719472f, -0.01012815f, 0.01030193f, 0.05145887f, 
    -0.02672599f, -0.02804250f, -0.02754953f, -0.01129088f, -0.07070675f, -0.02651280f, 0.01794019f, -0.07272595f, 
    -0.04470132f, 0.02869042f, -0.05675372f, 0.00727745f, 0.02841998f, -0.02822690f, -0.05940302f, 0.00950815f, 
    0.00639693f, -0.00742266f, -0.05149208f, -0.03189185f, 0.05058516f, 0.01229469f, -0.06709857f, -0.00185720f, 
    0.01297974f, 0.05397535f, -0.04860398f, -0.06717304f, -0.01525918f, -0.00970029f, 0.05020215f, -0.07097277f, 
    0.03970865f, -0.07127671f, -0.01598633f, -0.01826641f, 0.00032940f, -0.02445169f, -0.02329769f, -0.05919172f, 
    -0.06902437f, 0.02246819f, 0.00155096f, -0.05926265f, -0.00882827f, 0.03179843f, 0.03798315f, 0.05550636f, 
    0.01493326f, -0.02820313f, 0.03368050f, 0.01851106f, 0.03168223f, 0.02240065f, -0.02685717f, 0.02068454f, 
    0.03774136f, 0.06369582f, -0.03409786f, 0.01487494f, -0.04277330f, -0.06272291f, 0.04511296f, -0.01781895f, 
    -0.05831151f, -0.01748391f, -0.03713926f, 0.00053204f, 0.00792208f, -0.03760041f, 0.05151813f, -0.06821984f, 
    0.02960636f, 0.03512188f, 0.05878155f, 0.07115997f, 0.03909977f, -0.03660272f, -0.07527246f, -0.05516772f, 
    0.02946630f, 0.04910903f, -0.06097781f, 0.05577924f, -0.00609244f, 0.00856069f, 0.05038433f, -0.04467142f, 
    -0.22479038f, 0.15596187f, -0.03321726f, 0.14830899f, -0.06017959f, 0.05265799f, 0.02589651f, -0.09881736f, 
    0.00894382f, 0.09998241f, -0.01241399f, -0.02427821f, 0.02393078f, 0.06125304f, 0.00554306f, 0.09182660f, 
    0.01968740f, 0.00242464f, 0.16543274f, -0.02098812f, 0.00887988f, 0.10003516f, 0.04209608f, 0.17961642f, 
    -0.13943149f, 0.00816261f, 0.02447522f, 0.16232809f, 0.05771434f, 0.19468677f, 0.08272451f, 0.08664655f, 
    -0.07449823f, -0.04240664f, 0.05289077f, 0.10524216f, 0.08240538f, 0.17619912f, 0.06785746f, 0.31194216f, 
    -0.01861865f, -0.00476385f, -0.14128684f, 0.03597388f, 0.05403384f, -0.11295813f, 0.05655950f, 0.19020937f, 
    -0.38370728f, 0.28789884f, 0.11178257f, 0.07168868f, 0.16756672f, 0.16430314f, 0.00608692f, -0.11608469f, 
    0.08214902f, 0.08426728f, -0.12391209f, -0.00099479f, 0.34012431f, 0.00746405f, 0.01441953f, 0.08548669f, 
    0.09163935f, 0.09241065f, -0.02669456f, -0.01097433f, -0.09647504f, -0.06970163f, 0.02168143f, -0.01503734f, 
    0.05355791f, 0.21437033f, 0.14823784f, -0.12820549f, 0.15316419f, -0.00201612f, -0.08795991f, -0.12288102f, 
    0.12710924f, 0.16758142f, -0.02867061f, -0.14612511f, -0.44490737f, 0.03325833f, -0.15972048f, 0.04280186f, 
    0.05301669f, 0.02769196f, 0.18253356f, 0.01057369f, -0.11155599f, -0.05099179f, 0.04803218f, -0.02730322f, 
    0.07386379f, -0.14456886f, 0.14638919f, 0.24624006f, -0.06788106f, -0.01734589f, 0.01281625f, 0.09548058f, 
    0.14417350f, 0.04288277f, 0.07770222f, -0.03382870f, 0.11976334f, -0.18531181f, 0.04121951f, -0.05022446f, 
    0.12825608f, 0.09593108f, 0.01411797f, -0.09437301f, 0.05345361f, 0.08864927f, 0.11306908f, 0.01541494f, 
    0.28904292f, -0.11059370f, -0.00954222f, -0.12749098f, 0.07343134f, 0.00272195f, -0.09625857f, -0.06366194f, 
    0.02661542f, 0.08586205f, 0.09578518f, 0.04450298f, -0.09913459f, 0.05192535f, 0.33568281f, -0.18622369f, 
    -0.02238353f, -0.05789623f, -0.02860676f, 0.09590618f, 0.04154151f, 0.02741764f, 0.06837333f, 0.12167018f, 
    -0.13557538f, 0.15205458f, -0.15259279f, -0.05194115f, 0.10177165f, 0.02801810f, 0.10009672f, 0.04943717f, 
    -0.09574815f, -0.08959434f, 0.03029636f, 0.05706949f, 0.23811637f, 0.16468972f, 0.01958876f, 0.13157822f, 
    -0.04155094f, -0.02607205f, -0.01215287f, 0.02329210f, -0.09126502f, -0.04023233f, 0.02983182f, -0.13410339f, 
    -0.28802755f, 0.10313731f, -0.08195903f, -0.21231860f, -0.02746706f, -0.01034121f, 0.04620000f, -0.04974477f, 
    0.12963203f, -0.07908063f, -0.10980271f, 0.06633100f, -0.16688572f, 0.04096915f, 0.01669936f, -0.04100362f, 
    -0.16832750f, -0.00321296f, 0.09117601f, 0.00304419f, 0.01349737f, -0.12729399f, 0.04723432f, -0.06616321f, 
    -0.28642884f, -0.02556383f, 0.14741901f, 0.11988530f, -0.12140173f, 0.01506733f, 0.09627705f, 0.13863799f, 
    -0.14548394f, 0.22835930f, 0.05455517f, 0.30624002f, -0.39019433f, 0.19326596f, 0.02100781f, 0.08337764f, 
    -0.00740713f, 0.17727371f, 0.07238220f, 0.00598328f, -0.01059899f, -0.00815975f, 0.08088855f, -0.13066958f, 
    -0.04693238f, -0.14440091f, 0.23046663f, 0.06108217f, 0.09101376f, 0.12252680f, -0.07522368f, 0.07381988f, 
    0.07052443f, -0.01203463f, 0.04934007f, 0.07057204f, 0.05520610f, 0.01902734f, 0.03194795f, 0.04641291f, 
    0.00497924f, 0.09232010f, -0.05924508f, 0.00120969f, -0.15984467f, -0.01241522f, 0.17609800f, 0.09097790f, 
    -0.05904229f, 0.12067356f, 0.25000790f, 0.02800159f, -0.04490533f, 0.05474526f, 0.13185138f, -0.10916838f, 
    -0.10609905f, 0.15998141f, -0.02669526f, 0.03664185f, 0.47244075f, -0.10352116f, -0.02916253f, -0.33763373f, 
    0.18363564f, 0.03155980f, -0.09027592f, 0.02299788f, -0.10268706f, -0.11084948f, 0.01488579f, 0.09550831f, 
    0.13355371f, -0.12705475f, 0.20665072f, -0.09139289f, -0.07373876f, 0.02369129f, -0.00918203f, -0.16902290f, 
    -0.01479723f, -0.06964048f, -0.03595154f, -0.21094957f, -0.44821227f, 0.20419674f, -0.24107651f, 0.11534693f, 
    0.03622717f, 0.15732555f, 0.15715759f, -0.03454356f, -0.13497604f, -0.18315963f, -0.01155633f, -0.07364161f, 
    -0.11211933f, -0.26197478f, -0.00086332f, -0.05146338f, 0.12946625f, 0.05764823f, -0.09562548f, 0.07113033f, 
    0.04248663f, -0.22773466f, -0.13795723f, -0.29186052f, 0.19950110f, -0.05063831f, 0.13211393f, -0.01440843f, 
    0.15425844f, 0.13344257f, 0.02151076f, -0.02332609f, 0.03042168f, 0.15481454f, -0.09607869f, -0.11580304f, 
    0.24815021f, -0.15030025f, 0.04163164f, 0.05513245f, 0.11885886f, 0.11987972f, 0.05933325f, -0.05624670f, 
    0.11937205f, 0.08968234f, 0.12170876f, 0.05604332f, 0.03099591f, -0.02155382f, 0.01926629f, -0.05925449f, 
    -0.03362194f, -0.06511609f, 0.01717648f, 0.01678246f, 0.09947397f, 0.16976911f, 0.21271631f, 0.06057768f, 
    -0.12549435f, 0.17956717f, -0.05967791f, 0.10268474f, 0.02706054f, 0.03527014f, 0.09298760f, -0.03500649f, 
    -0.07677214f, -0.14338097f, 0.11827209f, -0.11203006f, 0.28148398f, 0.19515149f, -0.19322203f, 0.12336339f, 
    -0.01581403f, -0.05493410f, -0.01286093f, 0.14122859f, 0.04135912f, -0.09742256f, 0.03654945f, -0.00001909f, 
    -0.00733984f, 0.20288666f, 0.00098011f, -0.04934064f, 0.07866901f, 0.09066985f, -0.10995200f, -0.01866629f, 
    -0.03111583f, 0.03021342f, 0.02487335f, 0.09552933f, -0.04307457f, -0.27692109f, -0.04501890f, -0.03691721f, 
    -0.06431761f, -0.15574470f, -0.00936408f, -0.02311634f, -0.02982513f, 0.07110536f, 0.06940389f, 0.21128003f, 
    -0.30031940f, 0.01188298f, -0.11006641f, -0.10756345f, 0.23900634f, 0.19577552f, -0.08563666f, 0.13541789f, 
    -0.00127714f, 0.09910231f, 0.17338361f, 0.22810739f, -0.14027305f, -0.20100558f, 0.21298216f, 0.27708179f, 
    -0.04824182f, -0.00450960f, 0.02123171f, 0.01081456f, -0.03814796f, 0.07922573f, -0.00548336f, 0.08304944f, 
    -0.36896619f, 0.21891998f, -0.01408476f, 0.10749570f, 0.27656269f, 0.14386617f, 0.04323409f, -0.08967984f, 
    0.13442999f, 0.05853251f, -0.00500585f, 0.01707246f, 0.08904247f, 0.05066349f, 0.24683718f, 0.13375421f, 
    -0.01394615f, -0.00581920f, -0.01063434f, 0.05763562f, -0.10975298f, -0.06763312f, 0.08812319f, -0.01048310f, 
    -0.26465952f, 0.10327338f, 0.01199971f, 0.03715564f, 0.19852854f, 0.06607252f, 0.00052293f, 0.15950531f, 
    0.05021083f, 0.07842597f, 0.02040224f, -0.04822950f, 0.26016811f, 0.15882725f, -0.04601591f, 0.35975343f, 
    0.22826861f, -0.08438603f, 0.04375318f, 0.07617607f, -0.01494199f, -0.16108669f, -0.08615541f, 0.04985807f, 
    -0.10101528f, 0.30840236f, -0.11068116f, 0.01674999f, 0.03527023f, 0.10890567f, 0.03735761f, -0.11242925f, 
    0.05480252f, 0.09366156f, 0.00668932f, -0.09631518f, 0.45295098f, 0.13073948f, 0.00405922f, -0.00547089f, 
    -0.22800955f, 0.10122294f, 0.10032620f, -0.01996589f, 0.00734078f, -0.02981798f, 0.03580992f, -0.02578511f, 
    0.02270688f, -0.17994124f, 0.20957434f, 0.02321051f, 0.05322270f, -0.06439377f, 0.03265520f, 0.10528048f, 
    0.01821917f, -0.17727008f, 0.02835147f, -0.10349941f, 0.01331560f, -0.08729941f, -0.00322442f, -0.03327201f, 
    -0.06660770f, 0.02784388f, 0.09025196f, 0.08303898f, -0.03822630f, -0.09743088f, 0.06768720f, 0.05919398f, 
    0.14235818f, -0.18496256f, -0.17252815f, 0.14988308f, -0.10748759f, -0.00412153f, -0.06701934f, 0.04871257f, 
    -0.13109417f, -0.13572228f, -0.00506636f, -0.06893566f, 0.14777775f, 0.17065953f, 0.11141231f, 0.02202379f, 
    -0.06879299f, 0.12935401f, 0.14686516f, -0.01192093f, -0.09092189f, 0.03498014f, 0.16228636f, -0.00075459f, 
    -0.21288627f, 0.36651161f, -0.00578597f, -0.20172073f, -0.14080228f, 0.06060137f, 0.00638776f, -0.07768645f, 
    -0.12979542f, -0.12208825f, -0.04075041f, -0.00926292f, 0.00517457f, 0.12648781f, -0.10052712f, -0.01323788f, 
    -0.03452288f, -0.15536346f, 0.11676566f, 0.02852534f, 0.08028546f, -0.11746325f, 0.06818990f, -0.11547218f, 
    -0.07332207f, 0.44592765f, 0.03107213f, -0.03814582f, -0.23996891f, -0.08354908f, -0.03467881f, 0.17759225f, 
    -0.16162239f, -0.08032227f, -0.05361804f, 0.05481275f, -0.11646756f, 0.11928160f, 0.06158330f, -0.08510014f, 
    0.10647708f, 0.07036155f, 0.08748639f, 0.06193226f, -0.05106910f, 0.13028653f, 0.09842875f, 0.10203303f, 
    0.00344744f, -0.01555585f, -0.04996241f, -0.06988074f, -0.06353285f, -0.01113678f, -0.03094492f, -0.01821628f, 
    0.02071225f, 0.03864864f, 0.05644025f, 0.03376530f, -0.02896691f, 0.02629171f, -0.04284352f, -0.02213862f, 
    0.00241486f, -0.02008523f, 0.04750306f, 0.04947921f, -0.02374282f, -0.05762903f, -0.04213766f, -0.01648381f, 
    -0.01821512f, -0.00996309f, -0.01775369f, 0.00948766f, -0.07802378f, 0.05403344f, -0.02155316f, -0.07253478f, 
    -0.01262120f, -0.03728938f, 0.03461007f, 0.00894819f, -0.07091819f, -0.01219597f, 0.01478506f, -0.05676772f, 
    0.03496655f, -0.03529091f, 0.03007247f, -0.05090515f, 0.05687051f, 0.01450054f, -0.01048981f, 0.00861987f, 
    0.01061824f, -0.05168888f, 0.05357983f, -0.04835730f, -0.05171067f, -0.07092252f, 0.01928556f, -0.07167116f, 
    -0.06254910f, 0.00711282f, -0.06004550f, -0.01547202f, -0.02869293f, -0.04725026f, -0.07832768f, -0.02693086f, 
    0.06004153f, -0.07098220f, 0.05791403f, -0.00603904f, -0.02498657f, 0.02750513f, -0.04388710f, -0.05290338f, 
    0.02157792f, 0.05641642f, -0.00565625f, -0.06029030f, -0.02900976f, -0.02111390f, 0.02603776f, 0.05687779f, 
    -0.03960654f, -0.02760302f, 0.02385950f, -0.01196578f, 0.03446434f, 0.04533616f, -0.01869277f, -0.02456194f, 
    -0.03131779f, 0.06264508f, 0.02104422f, 0.02574004f, -0.03188682f, 0.05064781f, -0.07090905f, -0.03674846f, 
    -0.02350718f, 0.01587764f, -0.06082949f, -0.05872213f, 0.03940725f, 0.05966501f, 0.04891305f, -0.07943267f, 
    0.02280851f, 0.01753185f, -0.01765515f, 0.04605465f, -0.03731385f, 0.02888534f, 0.03532568f, -0.02790119f, 
    -0.07266129f, 0.03907884f, 0.00924507f, 0.02121982f, 0.04358099f, -0.07587778f, 0.01919634f, -0.03064173f, 
    -0.03396070f, -0.02430242f, 0.03308957f, -0.04719337f, -0.04256370f, 0.04808974f, 0.01522445f, -0.02019109f, 
    0.00494291f, 0.02674683f, 0.04842952f, 0.01244876f, -0.02412244f, 0.01527941f, 0.02878049f, 0.00383862f, 
    -0.02575629f, 0.04069288f, -0.06372396f, -0.00506498f, 0.05896060f, 0.04855087f, -0.06047942f, -0.03330142f, 
    0.05788719f, 0.04505702f, 0.04772696f, -0.00884964f, -0.05733276f, -0.07957578f, -0.03540981f, -0.06737328f, 
    -0.03463275f, 0.02342913f, -0.02910283f, -0.06163328f, -0.01346349f, 0.02478952f, 0.04437558f, 0.00277321f, 
    -0.07096663f, 0.04591960f, 0.02828396f, 0.05726798f, -0.07717048f, -0.03932830f, 0.05478679f, 0.01065241f, 
    -0.02903043f, -0.01237799f, -0.02768363f, -0.02390105f, 0.04202479f, 0.00175944f, -0.08190623f, -0.03498472f, 
    -0.07584549f, 0.00861909f, -0.04742264f, 0.03870742f, -0.03097386f, -0.06802740f, -0.04707133f, -0.00504237f, 
    0.03698823f, -0.04287740f, -0.02680815f, -0.06902455f, -0.07202499f, 0.01324593f, 0.02626085f, -0.05858142f, 
    -0.05957597f, 0.01666334f, 0.06438029f, 0.05508933f, -0.05162741f, 0.06809679f, -0.02313952f, 0.01858910f, 
    -0.07487076f, 0.01476919f, -0.04746572f, 0.03734891f, 0.05735232f, -0.01249709f, -0.04538076f, 0.04003248f, 
    -0.00866287f, 0.04956788f, -0.04581899f, -0.01687950f, -0.02013588f, 0.02728657f, -0.07317041f, -0.08563200f, 
    0.03849567f, -0.07846234f, 0.00603818f, 0.01369680f, 0.07559299f, 0.00768319f, -0.02619951f, -0.01969014f, 
    -0.05635045f, 0.04955605f, 0.00887039f, -0.02300070f, 0.05565435f, 0.04345528f, 0.01887564f, -0.04433797f, 
    -0.00999420f, -0.05119245f, -0.00437675f, 0.00562833f, -0.01863221f, -0.05022760f, 0.00336784f, 0.01588043f, 
    0.00696691f, -0.01548142f, -0.02981804f, -0.02233117f, -0.00064888f, -0.05325928f, -0.04757513f, -0.06480007f, 
    -0.03446985f, 0.04147936f, 0.06705847f, -0.02510139f, -0.00516601f, -0.01281144f, -0.07898315f, -0.01016781f, 
    -0.00223381f, 0.05124910f, 0.01277541f, 0.03223052f, -0.01931038f, 0.04502168f, -0.06678610f, -0.02388463f, 
    0.02625812f, -0.03250596f, -0.04866612f, 0.05403685f, -0.07128535f, 0.04008550f, -0.06561770f, 0.04360810f, 
    0.02325497f, -0.02224964f, 0.02200943f, -0.04597530f, -0.00516715f, -0.06438357f, -0.08116178f, -0.00725630f, 
    0.03429690f, -0.05240739f, -0.07054024f, -0.05099035f, -0.03755033f, -0.00476869f, 0.02847668f, -0.05298299f, 
    0.07027261f, 0.00924172f, -0.03593712f, -0.03236412f, -0.05795612f, 0.04795015f, 0.01427201f, 0.03891218f, 
    0.01331005f, -0.05933087f, -0.07441854f, -0.00605304f, 0.01114179f, 0.05175730f, 0.01621379f, -0.02342088f, 
    -0.02379633f, 0.03515579f, -0.08042166f, 0.01627192f, -0.06883771f, -0.02568470f, -0.02472101f, -0.02599815f, 
    0.03564536f, -0.06858321f, 0.00444830f, -0.06031032f, -0.03075487f, -0.03979152f, 0.00985567f, -0.06758894f, 
    0.00111139f, 0.01102724f, -0.01611817f, 0.03985704f, -0.03308478f, 0.01452579f, 0.04135498f, -0.02940181f, 
    0.05546565f, -0.06604121f, -0.07717079f, 0.05356901f, -0.05689650f, 0.02342140f, 0.04138675f, -0.06388714f, 
    -0.08344446f, 0.03708448f, 0.03726843f, 0.00698499f, -0.02908846f, 0.01090485f, -0.01415946f, -0.05369183f, 
    -0.03973816f, -0.05583222f, -0.02266538f, -0.01416305f, -0.05776875f, 0.05408956f, -0.03044364f, -0.06473680f, 
    0.05475850f, 0.06203888f, 0.06346954f, 0.04003425f, -0.07832929f, -0.00259465f, 0.00555845f, -0.02406110f, 
    -0.03329796f, -0.00475494f, -0.07595810f, -0.05537603f, 0.00497292f, -0.06065230f, 0.01791183f, -0.01762535f, 
    0.06819329f, -0.02654400f, -0.04194883f, -0.08473878f, -0.03012474f, 0.05644650f, 0.01349657f, -0.04223013f, 
    0.02559019f, 0.00461476f, -0.01393079f, 0.01347622f, 0.03060161f, -0.00426894f, -0.02404719f, -0.06052731f, 
    0.33889326f, 0.39598182f, -0.01692805f, 0.00000816f, -0.14563066f, 0.14180829f, 0.12504801f, -0.09656808f, 
    -0.12622839f, -0.02543497f, 0.13291724f, 0.11807238f, 0.31303918f, 0.37360284f, 0.18748970f, 0.09131840f, 
    0.03421209f, 0.08327346f, -0.05219217f, -0.08297215f, -0.15392858f, -0.08227503f, 0.00290332f, -0.10817728f, 
    0.15771937f, 0.19974455f, 0.05666756f, 0.00605982f, 0.00573213f, -0.02923966f, 0.19619676f, 0.00302176f, 
    0.21019968f, 0.03958988f, -0.02816446f, 0.23487724f, 0.54136246f, 0.48877186f, 0.22840825f, 0.04440856f, 
    -0.06118737f, 0.05101929f, 0.12619883f, 0.20567015f, -0.12174387f, -0.02590642f, -0.02948033f, -0.03748563f, 
    0.47286487f, 0.11217960f, 0.14042947f, 0.10788811f, 0.02348343f, -0.02610722f, -0.04671396f, 0.18829751f, 
    -0.13216817f, -0.01098823f, -0.02850552f, -0.02128282f, 0.22815169f, 0.19483426f, 0.32059690f, 0.29574105f, 
    0.25623438f, 0.01398502f, -0.04531466f, 0.09900608f, 0.05594227f, 0.03494699f, 0.02207371f, 0.06075021f, 
    0.19471848f, 0.11872932f, 0.17184633f, 0.06062599f, -0.02734969f, 0.10232182f, 0.08490383f, -0.02355350f, 
    0.12415747f, 0.06455550f, 0.13253270f, -0.00993240f, -0.48379323f, -0.43080974f, -0.04237158f, -0.04757882f, 
    -0.19408055f, -0.01571752f, -0.16031012f, -0.08604939f, -0.07509174f, -0.02928029f, 0.05017724f, -0.02980828f, 
    -0.16996813f, -0.20553781f, -0.14959626f, 0.02522366f, 0.25494117f, 0.02775362f, 0.08070721f, 0.05685331f, 
    -0.20961866f, -0.09981494f, 0.00593459f, -0.22780782f, -0.30577061f, 0.08771636f, -0.18765993f, -0.02370233f, 
    -0.16004179f, 0.31043354f, -0.22943434f, -0.03255850f, 0.05426418f, 0.00203804f, -0.08235217f, -0.03405424f, 
    -0.27797550f, -0.34171119f, -0.28186747f, 0.05280488f, 0.08403540f, -0.02684960f, -0.01146598f, -0.03032157f, 
    0.04213729f, -0.09965926f, -0.15388884f, 0.16956438f, -0.26059538f, -0.35230497f, 0.00154179f, 0.10022976f, 
    -0.17454210f, -0.19914335f, 0.03601681f, 0.21267402f, -0.07136557f, -0.20345603f, 0.03716892f, -0.03448357f, 
    -0.25686562f, -0.24060126f, -0.38828757f, 0.05924011f, 0.09617088f, -0.09004756f, -0.18275955f, 0.01709301f, 
    -0.17059524f, -0.09254914f, -0.18483667f, -0.08135728f, 0.25685421f, 0.35465863f, 0.06425571f, 0.12542710f, 
    0.02515591f, 0.00968223f, -0.08607984f, 0.14530703f, 0.01013392f, -0.04935954f, -0.03332473f, 0.07889259f, 
    -0.42347571f, -0.37430102f, -0.33623797f, -0.16560189f, -0.05459465f, -0.05836965f, -0.03963229f, -0.00222763f, 
    -0.11333174f, -0.08499881f, -0.11027896f, -0.04637609f, 0.12975203f, -0.00300867f, 0.00022438f, 0.10629607f, 
    0.03572887f, -0.09698598f, -0.09798194f, -0.00367411f, 0.15021633f, 0.04365982f, -0.24743706f, 0.04302946f, 
    -0.05835254f, -0.06650003f, 0.03144982f, 0.05917756f, -0.00616000f, -0.04904899f, 0.01631320f, -0.03577550f, 
    -0.06595609f, 0.05569913f, 0.00639035f, -0.00323460f, -0.05603004f, 0.02131160f, -0.04813504f, -0.00386565f, 
    -0.01830560f, -0.04017779f, 0.00266492f, -0.01748231f, 0.04838359f, -0.06897480f, -0.03454039f, -0.03342275f, 
    -0.02072937f, -0.00235869f, 0.00215358f, 0.01635334f, -0.03604377f, -0.01122024f, 0.00063849f, 0.04567565f, 
    0.03136681f, -0.02185028f, -0.04335316f, -0.04939025f, -0.03657155f, 0.04682907f, 0.01425517f, -0.03105181f, 
    0.05843983f, 0.02356035f, -0.06142965f, -0.00775959f, -0.03231854f, -0.03864070f, -0.03120382f, 0.03505906f, 
    0.05137902f, -0.06715782f, -0.02829070f, 0.02993141f, 0.02351861f, -0.01556695f, -0.02631549f, -0.06394023f, 
    -0.01806501f, 0.01823319f, 0.02289667f, -0.03823888f, -0.04863235f, -0.04943455f, 0.01912309f, 0.02208609f, 
    -0.05364355f, -0.01463305f, 0.02557358f, -0.02109201f, 0.06055290f, -0.04982323f, 0.00004717f, -0.03502814f, 
    0.05600787f, -0.02603760f, 0.01215971f, 0.03376072f, 0.00446346f, -0.02454820f, -0.06143051f, -0.01647855f, 
    -0.06315222f, 0.00024959f, -0.06833380f, -0.05102290f, 0.04813077f, -0.00235307f, 0.05148441f, 0.06889381f, 
    -0.05183055f, 0.01568253f, 0.03457002f, 0.02653359f, 0.00844447f, -0.07138845f, -0.02889234f, -0.04893485f, 
    0.01684603f, -0.06981019f, 0.05016310f, 0.00164881f, -0.02446730f, 0.00365253f, 0.02119647f, -0.00380025f, 
    -0.00444900f, -0.05354591f, -0.05179440f, 0.02729315f, -0.02878042f, -0.07155801f, -0.01152868f, 0.01892277f, 
    0.06947847f, -0.06646126f, -0.06000863f, -0.00849765f, 0.02283727f, 0.03304747f, 0.05938717f, -0.01435258f, 
    0.03324520f, -0.04535142f, 0.00782255f, -0.00954916f, -0.01582189f, -0.02612175f, 0.02502456f, -0.06761283f, 
    0.01906120f, -0.00999932f, -0.04042226f, 0.03360772f, -0.06513266f, 0.06103381f, 0.01039176f, 0.05162794f, 
    -0.01791540f, -0.05273200f, -0.01482642f, -0.00106076f, 0.05381777f, 0.01117880f, -0.03596216f, 0.02136308f, 
    0.02575387f, -0.00265803f, -0.06057626f, -0.05559815f, -0.01162960f, 0.01222180f, 0.01989670f, 0.06676618f, 
    -0.02964098f, 0.06793332f, -0.04666832f, -0.04168434f, 0.06587696f, -0.00835001f, -0.00369368f, -0.02453412f, 
    -0.03661153f, -0.01145614f, -0.04414437f, -0.03593594f, 0.03208259f, -0.04130112f, -0.00627455f, -0.03156158f, 
    0.05027415f, -0.01067279f, 0.02251285f, -0.06211590f, -0.03123071f, -0.00038040f, 0.00250744f, -0.05553960f, 
    -0.06691878f, -0.00675762f, -0.04550095f, -0.01691798f, -0.06734184f, 0.02697084f, 0.04297428f, 0.04981906f, 
    -0.03307654f, -0.04632540f, -0.02684534f, 0.00977034f, -0.07058743f, 0.03343644f, -0.06928337f, 0.00461023f, 
    -0.07404643f, -0.06264582f, 0.01833913f, -0.06643330f, -0.05203587f, -0.00572082f, 0.01082698f, 0.03019398f, 
    -0.06536864f, 0.05069213f, 0.04587751f, 0.01948069f, 0.03835244f, 0.02684355f, -0.06699593f, -0.06257135f, 
    -0.00241759f, -0.04841318f, 0.03074572f, -0.06932680f, -0.00127754f, 0.01830560f, -0.05812659f, -0.04159475f, 
    -0.03300834f, -0.02482641f, -0.02910943f, 0.04523946f, -0.01385060f, 0.02906530f, -0.02886468f, -0.04130010f, 
    0.01744457f, -0.00503841f, 0.03248174f, 0.04099258f, 0.02853849f, -0.00184699f, -0.03672529f, -0.00021214f, 
    0.00826950f, -0.07013823f, -0.06202988f, 0.01519712f, 0.04367698f, -0.03483707f, 0.04928574f, -0.02635035f, 
    0.02250047f, -0.05741480f, -0.07155387f, 0.04788611f, -0.02987017f, -0.07379922f, 0.03740956f, 0.04267983f, 
    -0.04581796f, -0.06353759f, -0.05422248f, -0.05956332f, 0.02335772f, -0.05581173f, -0.06436814f, -0.03039173f, 
    -0.02137728f, 0.02851500f, 0.03893484f, -0.06503073f, -0.03352481f, 0.02680383f, -0.03001014f, -0.06090074f, 
    0.03333090f, -0.06839481f, 0.03274930f, 0.03985053f, 0.05334368f, 0.05265950f, -0.06881600f, -0.05889097f, 
    -0.02167750f, 0.01343493f, -0.00534901f, 0.06309415f, -0.02648818f, -0.04476563f, 0.04698641f, 0.05116002f, 
    -0.05289590f, 0.06280287f, 0.05756512f, 0.02967858f, -0.03087967f, -0.00674476f, -0.03048288f, -0.03462325f, 
    0.04170728f, 0.00518891f, 0.06038022f, 0.05683014f, 0.02069569f, 0.00157702f, 0.04738745f, -0.05036629f, 
    -0.05490559f, 0.06449027f, -0.05935484f, -0.03664681f, -0.05558158f, -0.03121251f, -0.04602182f, -0.06872442f, 
    0.01530855f, -0.05507007f, -0.08000913f, 0.00760086f, 0.03663999f, 0.02772516f, -0.06201797f, 0.02844621f, 
    -0.00123114f, -0.07279015f, 0.02132162f, 0.00177186f, -0.01976024f, 0.03843124f, -0.01478238f, 0.01847834f, 
    0.03240201f, 0.00418640f, 0.03389942f, -0.04503651f, -0.07652266f, 0.00163029f, -0.01993223f, -0.04712854f, 
    0.05792576f, 0.02794856f, -0.04247043f, -0.02780026f, -0.02150179f, 0.01776153f, 0.00188849f, 0.02855396f, 
    0.02338227f, 0.02717366f, -0.04802064f, -0.04745911f, 0.04364667f, -0.01925206f, -0.06744748f, -0.06067799f, 
    -0.00708763f, -0.04958702f, -0.06937705f, 0.05549080f, 0.02463286f, 0.03484247f, -0.03688367f, -0.00971542f, 
    0.01487351f, -0.04643336f, -0.03345923f, -0.02143016f, -0.04152387f, -0.04495540f, -0.03272644f, -0.00835794f, 
    -0.05801894f, -0.07928123f, 0.04047145f, 0.03039104f, -0.06110844f, -0.01458434f, -0.07052211f, -0.01026606f, 
    0.00055433f, 0.05008978f, -0.04283198f, -0.07178369f, -0.04661709f, -0.00294745f, -0.06075810f, 0.02785783f, 
    -0.02834677f, -0.01506395f, -0.06147768f, -0.07020438f, 0.04079211f, 0.05550100f, -0.04479153f, 0.00948923f, 
    0.06230016f, -0.02863880f, -0.07452951f, -0.07169139f, 0.02097128f, -0.05286707f, -0.01182752f, 0.02810180f, 
    -0.00517102f, 0.04231028f, 0.05576127f, -0.01109731f, -0.06500124f, 0.03889246f, 0.05429073f, 0.06033489f, 
    -0.03099508f, -0.05156954f, -0.07431885f, -0.01684064f, -0.02419933f, -0.06616826f, -0.02899393f, -0.04759711f, 
    0.05546506f, -0.07407822f, -0.06941121f, -0.02639558f, -0.05956661f, -0.03815840f, 0.01954048f, -0.06657826f, 
    -0.04297921f, -0.01292324f, -0.05231685f, -0.01919524f, -0.00776336f, 0.00209734f, -0.00801375f, -0.07784344f, 
    0.00423428f, 0.01741736f, 0.03472244f, 0.05292706f, -0.00541952f, 0.02539671f, 0.00178937f, -0.06229920f, 
    0.05300958f, 0.00349609f, -0.06459599f, 0.01655104f, -0.03165149f, 0.03978019f, 0.01405807f, 0.02502041f, 
    -0.05341871f, -0.05988479f, 0.02327069f, -0.00692242f, -0.02585389f, -0.01770572f, 0.01268797f, 0.05520522f, 
    0.03412179f, 0.02498464f, -0.03221123f, -0.00196018f, -0.03219419f, 0.03087189f, -0.04182392f, 0.05086562f, 
    -0.07787733f, 0.01555759f, 0.05186513f, -0.03684914f, 0.05583546f, 0.02702643f, -0.00335917f, 0.04463729f, 
    0.01804914f, 0.02552794f, -0.01205356f, 0.02601558f, -0.03546592f, -0.07536788f, -0.05955487f, -0.05327589f, 
    -0.05440640f, -0.04858634f, 0.03866985f, -0.03104194f, 0.03970347f, -0.01731384f, -0.06861469f, -0.04349510f, 
    -0.07493882f, 0.01001860f, 0.02226903f, -0.07275188f, -0.04376247f, -0.00017950f, -0.02623852f, 0.02280067f, 
    -0.04915133f, -0.00808859f, -0.03536668f, 0.03231589f, -0.07561080f, -0.00460809f, -0.05517618f, -0.06931036f, 
    -0.03235208f, -0.06248166f, 0.00986409f, -0.01400849f, 0.04904501f, 0.00969537f, -0.07437138f, 0.04524622f, 
    0.05146682f, 0.04707120f, -0.02296439f, 0.02911729f, 0.05249448f, 0.04038209f, -0.01809490f, 0.02681064f, 
    -0.02543220f, -0.04088271f, 0.00355369f, -0.01366116f, -0.06552150f, -0.06905727f, -0.02482844f, -0.03792807f, 
    0.03140292f, -0.02304232f, 0.00288966f, 0.02173579f, 0.02530402f, 0.05503392f, 0.05435882f, -0.01410161f, 
    -0.06276908f, -0.00247212f, -0.00320431f, -0.00773485f, 0.04121613f, -0.04558821f, -0.07306837f, 0.00030791f, 
    -0.05901177f, -0.05835926f, -0.07594068f, 0.05485111f, -0.06330849f, 0.02337735f, 0.06020569f, 0.06492081f, 
    0.02748084f, 0.04057628f, 0.02724004f, 0.02977850f, -0.00896409f, 0.01169073f, -0.06915590f, -0.01373078f, 
    -0.01220123f, -0.04186373f, 0.05651968f, -0.00533594f, 0.01995274f, -0.07080545f, -0.00956660f, -0.02903901f, 
    -0.04392214f, -0.05387519f, -0.01241435f, -0.03896509f, -0.05618050f, -0.06533218f, -0.05077869f, -0.01873494f, 
    0.00129742f, 0.06454837f, 0.04850404f, -0.03310216f, -0.06423163f, 0.05389206f, -0.01646498f, 0.02413787f, 
    -0.04766813f, 0.04517877f, -0.05841503f, -0.04508023f, -0.02549664f, -0.07029963f, 0.06421150f, -0.02218682f, 
    0.01283837f, 0.03921974f, -0.03974161f, -0.05933627f, 0.01904182f, -0.03796161f, -0.07349356f, -0.03924346f, 
    -0.04209522f, -0.02899543f, 0.04759712f, -0.02015392f, -0.06089325f, -0.01769333f, 0.05841402f, 0.04999123f, 
    0.00921647f, -0.04572888f, -0.07121679f, -0.00966559f, 0.03174942f, 0.01519715f, -0.06903434f, -0.04525757f, 
    0.02088109f, -0.01238400f, -0.05633976f, 0.05463445f, -0.05916671f, -0.05928448f, 0.00975156f, -0.00259161f, 
    -0.04461922f, -0.04660970f, -0.05661074f, 0.04958783f, -0.04607693f, -0.05579101f, 0.01530460f, 0.04060094f, 
    -0.07480310f, -0.05277411f, 0.03372271f, -0.05187738f, 0.06208495f, 0.00060942f, -0.02770314f, -0.00900309f, 
    -0.06871899f, 0.04414066f, -0.04983509f, 0.04891101f, -0.04920244f, -0.02087049f, 0.01452735f, -0.06705708f, 
    -0.07110967f, -0.04126145f, 0.04983994f, -0.00108583f, -0.00709594f, 0.02496246f, -0.05786180f, 0.05369852f, 
    -0.07136475f, -0.03370470f, 0.04655991f, 0.02580459f, -0.01848953f, -0.02600100f, -0.04550218f, 0.03861164f, 
    -0.03439821f, -0.06634471f, -0.02103271f, 0.05019544f, -0.07157414f, 0.06333206f, -0.06687535f, 0.05906774f, 
    -0.00679398f, -0.01963114f, -0.04886418f, 0.04042888f, 0.05900729f, -0.04504637f, -0.02209892f, -0.06222233f, 
    -0.02570864f, -0.05493119f, 0.03221733f, -0.02971436f, -0.05567930f, -0.00006484f, -0.05716792f, -0.06290448f, 
    0.01843479f, -0.00804945f, 0.04740942f, 0.06067079f, -0.01021863f, 0.03475924f, 0.03376941f, -0.07681908f, 
    -0.06883847f, -0.01994494f, 0.06270790f, -0.06374580f, -0.04196812f, 0.04711174f, -0.03883909f, -0.07190362f, 
    0.06422119f, -0.05330551f, 0.04016253f, 0.02873621f, -0.04575037f, 0.00543123f, 0.04436872f, 0.00396175f, 
    -0.03018481f, 0.06503243f, 0.00716788f, -0.00053679f, -0.00753022f, 0.01380500f, -0.01238320f, -0.03116520f, 
    -0.02512881f, -0.03200947f, 0.03604502f, 0.04441901f, -0.06861945f, -0.02324591f, 0.07167859f, -0.02275557f, 
    -0.05531288f, -0.00071775f, 0.01502320f, 0.05932187f, -0.07739528f, 0.03668098f, -0.03282845f, -0.03532926f, 
    -0.07127514f, -0.06745227f, 0.01445992f, 0.02493982f, 0.00509849f, -0.07095478f, -0.06476478f, 0.03245730f, 
    0.03489338f, 0.01688158f, -0.06106422f, 0.06182302f, 0.03489551f, 0.01310755f, -0.06803938f, -0.00079818f, 
    -0.05676502f, -0.05029170f, -0.06866071f, 0.00942759f, 0.06007244f, -0.04030817f, -0.01024715f, 0.04055091f, 
    0.05294842f, -0.00715822f, -0.00047547f, -0.06613140f, -0.05237069f, 0.05018694f, -0.04897439f, -0.06961704f, 
    -0.05536547f, 0.00841173f, 0.03748140f, 0.03215521f, 0.02596786f, -0.00431510f, -0.03503869f, 0.06217468f, 
    0.08275821f, -0.11706143f, -0.14684378f, -0.18637188f, -0.32327005f, 0.00083568f, 0.13539074f, -0.16449438f, 
    0.03628793f, -0.04151626f, -0.01099487f, 0.14702897f, -0.09934377f, 0.25274655f, -0.11395170f, 0.02195028f, 
    0.05847199f, 0.08136453f, 0.18056397f, 0.04320828f, -0.00531892f, -0.05812350f, 0.09097829f, 0.12606592f, 
    0.06432106f, -0.12467693f, -0.11195962f, -0.07362941f, -0.10464327f, -0.09488425f, 0.01497638f, 0.02257970f, 
    -0.02373149f, -0.01612954f, 0.03039734f, -0.01201774f, 0.07534967f, 0.20908241f, 0.03996170f, -0.25332567f, 
    0.08615171f, -0.02020106f, 0.10362956f, 0.17495555f, 0.18566892f, 0.05355087f, 0.04200673f, 0.12791218f, 
    -0.44201389f, 0.01889606f, -0.19187349f, -0.03252126f, -0.07332372f, -0.05726132f, 0.17821741f, 0.02107675f, 
    0.13285783f, -0.03334176f, 0.06619335f, 0.14416306f, 0.06791180f, -0.25068620f, 0.17681569f, -0.32654440f, 
    -0.21036901f, 0.04515487f, 0.06103954f, 0.06347384f, 0.00256158f, 0.04117255f, 0.09439802f, 0.12906785f, 
    0.11252823f, -0.11233123f, -0.00226166f, -0.01008045f, 0.02040286f, -0.02700791f, 0.02584314f, 0.01979679f, 
    0.14030840f, 0.06123493f, 0.10077164f, 0.04744447f, -0.14303647f, -0.10986845f, 0.24015012f, 0.02937095f, 
    0.03579367f, -0.00855915f, -0.02871696f, 0.08569781f, 0.12118973f, 0.03293945f, 0.13700448f, 0.12913848f, 
    -0.13770202f, 0.15203167f, 0.12205121f, -0.11479098f, 0.17218512f, 0.12392700f, -0.00417257f, 0.12525065f, 
    0.18450813f, -0.04695896f, -0.04458236f, 0.09572320f, -0.34788537f, 0.17009346f, -0.06461499f, 0.15633431f, 
    0.17358035f, 0.02251379f, -0.11734996f, -0.00590909f, 0.00980087f, 0.20114338f, 0.05653140f, -0.05901763f, 
    -0.31256759f, 0.08377469f, 0.15749153f, 0.20100430f, 0.10001042f, 0.07194571f, -0.07077485f, -0.06567661f, 
    0.24358433f, -0.00414777f, 0.02927363f, 0.04611069f, -0.03159998f, 0.06670352f, 0.19952333f, 0.18726900f, 
    0.06136743f, 0.00304930f, 0.03919381f, 0.16221014f, 0.11048964f, -0.01332280f, 0.00054120f, 0.15276107f, 
    0.54476839f, -0.23632100f, -0.01321855f, 0.17531177f, -0.01607467f, 0.14218897f, 0.01091389f, 0.04898085f, 
    0.18050691f, -0.06033304f, 0.06021691f, 0.03652073f, 0.29840639f, -0.02288807f, 0.12224950f, -0.03464589f, 
    -0.00824907f, -0.03694040f, -0.00766701f, -0.05620864f, 0.02383128f, 0.17478058f, -0.07424836f, 0.00959835f, 
    0.20971844f, -0.18392156f, 0.06549779f, 0.03291544f, 0.14779916f, -0.01136160f, -0.03699937f, 0.09200773f, 
    0.17480685f, 0.03276125f, 0.08153034f, 0.12669165f, 0.06200635f, -0.18916336f, 0.00117193f, -0.00063366f, 
    -0.08991669f, -0.12949617f, 0.05400540f, 0.09727430f, 0.09762450f, -0.03013326f, 0.08200566f, 0.02818049f, 
    -0.06080606f, 0.04361207f, 0.05654784f, 0.04023670f, 0.04558157f, 0.06289489f, 0.00164255f, 0.06165215f, 
    -0.01404968f, -0.06525813f, 0.04319655f, -0.03304768f, -0.04710377f, -0.00961961f, -0.04367115f, 0.03097937f, 
    0.02927800f, -0.03107507f, -0.00200542f, -0.06812654f, -0.06649385f, 0.04713565f, -0.04182157f, -0.03306399f, 
    0.04485928f, -0.04989605f, -0.04624910f, -0.02279689f, 0.03673833f, 0.00324480f, -0.06210281f, -0.04608447f, 
    0.05280434f, 0.02443505f, -0.07580791f, -0.06572176f, 0.05221478f, 0.01230728f, -0.06984264f, 0.00645938f, 
    0.03324126f, 0.03481878f, 0.03493494f, -0.04120529f, 0.05355497f, -0.06434105f, -0.00354073f, -0.03088436f, 
    -0.00335577f, 0.05502648f, -0.07296045f, -0.03553560f, -0.01944573f, -0.03293255f, 0.04480408f, -0.01857376f, 
    -0.04060015f, 0.06169367f, -0.05727911f, 0.01859722f, 0.04070822f, 0.02106245f, 0.00873110f, -0.05420816f, 
    -0.03552846f, -0.05906137f, -0.03051991f, -0.07171888f, -0.03827436f, -0.01870614f, -0.03279536f, 0.06127149f, 
    0.05749854f, 0.01830600f, 0.04642293f, -0.00055083f, -0.05517709f, 0.02767989f, 0.05457247f, 0.02731470f, 
    0.06365613f, -0.07917938f, 0.03397094f, 0.01185654f, 0.06384373f, -0.04104023f, -0.07148295f, 0.00071267f, 
    0.03975448f, 0.01294069f, -0.00362564f, -0.07381463f, -0.02639171f, -0.05461412f, 0.01316533f, 0.03206525f, 
    -0.07968303f, -0.06090203f, 0.01617577f, 0.05102115f, -0.03347490f, -0.08266602f, 0.03809252f, 0.05690366f, 
    -0.00526910f, -0.00556167f, 0.03237050f, 0.07152174f, -0.02577502f, -0.05167727f, -0.01691555f, 0.00275123f, 
    -0.06768880f, -0.07115238f, 0.03701037f, 0.03297824f, -0.05777154f, 0.05218513f, 0.03214666f, -0.04406199f, 
    -0.06760369f, -0.04656361f, -0.03326644f, -0.06453495f, -0.02645043f, -0.06613047f, 0.04878970f, -0.04829116f, 
    0.02111564f, -0.01579498f, -0.07826506f, 0.01969895f, -0.02796088f, -0.03534380f, 0.01235430f, -0.01923203f, 
    -0.02409953f, 0.03708914f, -0.00318781f, 0.02879108f, -0.07253220f, -0.06798689f, 0.01081711f, -0.02922489f, 
    -0.06624193f, -0.00679277f, 0.01834491f, -0.04941540f, -0.06446143f, -0.05958517f, -0.01280648f, 0.04950166f, 
    0.01294121f, -0.06422887f, -0.05833162f, 0.04915991f, -0.07075134f, 0.00471000f, 0.03442526f, -0.07462660f, 
    -0.02817670f, -0.06442847f, -0.03283832f, -0.02839826f, 0.03157977f, -0.02991858f, 0.03957200f, 0.01181243f, 
    -0.02865903f, 0.00256111f, -0.02900966f, -0.06435510f, 0.02224682f, -0.05098832f, -0.04122404f, -0.01302695f, 
    0.03028254f, 0.00957679f, 0.04437366f, 0.00921383f, -0.01113524f, -0.00582802f, 0.03007434f, -0.03880942f, 
    -0.05459617f, -0.05045297f, 0.02264165f, -0.07777739f, 0.04026300f, 0.05443107f, 0.04662557f, -0.05921338f, 
    -0.28479394f, -0.38385394f, -0.33598030f, 0.00967551f, 0.04973580f, 0.03308611f, -0.10340493f, 0.12234765f, 
    -0.06955606f, -0.10260589f, 0.16314198f, -0.04186084f, -0.11820667f, -0.08730545f, -0.10974530f, 0.00114962f, 
    0.06468313f, -0.15150493f, 0.17322828f, -0.02271500f, -0.09179047f, 0.02310176f, -0.11694467f, 0.15309350f, 
    -0.45925227f, -0.26148036f, -0.18887995f, -0.03957846f, 0.08134738f, 0.15012591f, 0.06928518f, 0.13057730f, 
    0.03104762f, 0.07336185f, -0.06648798f, -0.02259191f, -0.08192527f, -0.01009811f, -0.12581608f, 0.22763956f, 
    -0.12032128f, -0.16349196f, -0.04443966f, 0.00535065f, -0.07670296f, 0.17824017f, -0.04441405f, 0.10903908f, 
    -0.67964035f, 0.00947388f, -0.28164414f, -0.13809034f, 0.24729826f, 0.07487203f, 0.04818454f, -0.01947005f, 
    -0.11887048f, -0.02922980f, 0.17242390f, -0.04618110f, -0.24587828f, -0.12050807f, -0.21665162f, 0.09752899f, 
    -0.01613555f, 0.02175426f, -0.06655356f, -0.00216859f, 0.02199465f, -0.15959948f, -0.03042205f, 0.12465346f, 
    -0.23020490f, 0.10628116f, 0.01568827f, -0.17162907f, 0.10050844f, 0.03146885f, 0.13703498f, -0.06843249f, 
    0.20035225f, 0.04601005f, -0.08547217f, 0.23448345f, 0.16508348f, 0.23532282f, 0.11854748f, -0.19752920f, 
    0.06523304f, -0.15326834f, -0.10076319f, -0.06503494f, 0.08416555f, -0.01075472f, -0.00616552f, -0.00920884f, 
    0.25217718f, 0.03999815f, 0.21026231f, 0.17921203f, -0.19918008f, -0.08294087f, 0.03875128f, -0.04965416f, 
    0.09204895f, 0.02719723f, -0.04294310f, 0.17939940f, 0.45378008f, 0.15503722f, 0.02976097f, 0.07426368f, 
    0.19639781f, -0.06744999f, 0.18349616f, 0.26045331f, 0.16351511f, 0.04701770f, 0.17454475f, -0.00678229f, 
    0.25829741f, -0.04325734f, 0.29420105f, 0.26410562f, 0.01282143f, 0.12862080f, -0.23720880f, -0.01224879f, 
    0.05495785f, 0.10584006f, 0.17197631f, -0.01005195f, 0.03780559f, 0.16097824f, 0.36234614f, -0.00034532f, 
    -0.05580741f, -0.01079761f, -0.10576291f, -0.04973075f, 0.06185653f, 0.24369851f, -0.00648173f, 0.06164481f, 
    -0.10466261f, 0.19526801f, 0.11975949f, -0.18349117f, 0.09459489f, -0.03143208f, 0.00509307f, -0.11619177f, 
    -0.02209846f, 0.15521348f, 0.19947445f, 0.20552167f, -0.41357946f, -0.19380161f, 0.01209937f, -0.02696316f, 
    -0.03901953f, 0.13695671f, 0.00704492f, 0.04504824f, 0.08890301f, 0.01690177f, -0.00552861f, 0.11016002f, 
    0.03914851f, 0.15372157f, 0.24945796f, 0.04380842f, 0.02396363f, 0.08109383f, 0.02340204f, -0.00080822f, 
    0.17386644f, -0.06810829f, 0.01426926f, -0.04380967f, -0.08255450f, 0.16008499f, 0.01567276f, -0.18197617f, 
    0.31339520f, 0.04685692f, 0.10155395f, 0.16440372f, 0.03016418f, 0.08935194f, 0.00163488f, -0.00012947f, 
    0.08684813f, -0.22319072f, 0.04723189f, -0.20370215f, 0.18228857f, 0.02678254f, -0.05325666f, 0.10962792f, 
    -0.04075190f, 0.05064813f, 0.02105247f, 0.03508885f, -0.20943815f, 0.13665588f, -0.09670650f, -0.24052942f, 
    0.05576796f, 0.05408116f, -0.08950207f, -0.03162812f, 0.07904964f, 0.00238860f, 0.10248419f, 0.03701215f, 
    0.12056810f, -0.29169244f, -0.04376624f, 0.04057824f, -0.13877575f, 0.08924304f, -0.04148868f, -0.09176558f, 
    0.04449083f, 0.07132983f, -0.07023485f, 0.04473430f, -0.09971491f, -0.35726801f, -0.40683898f, -0.20527819f, 
    -0.05038811f, -0.05238984f, 0.06320564f, -0.03159901f, -0.05457903f, 0.02568034f, 0.01825214f, -0.02216174f, 
    0.58456123f, -0.07059855f, 0.01829496f, -0.05179923f, -0.09279073f, 0.05956761f, 0.13947695f, 0.03172180f, 
    0.01565005f, -0.00557008f, 0.08435809f, -0.06521636f, -0.36675507f, 0.33455899f, -0.04995747f, -0.04614310f, 
    0.08274356f, -0.10169477f, 0.10401499f, 0.05257422f, -0.06834321f, 0.10890169f, 0.17508298f, 0.04698680f, 
    0.02257900f, -0.13297121f, 0.01687001f, 0.07480329f, -0.02015273f, 0.09336635f, -0.06227917f, 0.09200162f, 
    -0.11224492f, -0.09662189f, -0.02658053f, 0.07943364f, 0.16023776f, 0.08490033f, -0.03355706f, 0.20215379f, 
    0.11697035f, -0.02893202f, -0.03883498f, 0.14952070f, -0.00259150f, -0.01450738f, -0.02655951f, -0.08613339f, 
    0.14431499f, -0.07487246f, -0.24358413f, -0.42901948f, 0.04875513f, 0.02959539f, -0.00610713f, -0.03823458f, 
    0.15489873f, -0.04273685f, -0.13643649f, 0.10314984f, 0.45991072f, 0.29323706f, 0.08242534f, 0.03374474f, 
    -0.11649929f, 0.11221157f, 0.15386635f, 0.07240688f, 0.03572925f, -0.01296409f, 0.03217273f, 0.08058948f, 
    0.11217307f, 0.06908611f, 0.15742880f, -0.07148603f, 0.00544171f, 0.07147232f, -0.01610928f, -0.00200362f, 
    -0.02778222f, -0.00648846f, -0.09091605f, -0.05044950f, 0.07572597f, -0.09684984f, -0.02866428f, -0.06351691f, 
    0.17807148f, -0.02928285f, 0.00559506f, -0.03927192f, 0.06432522f, -0.04630560f, 0.13288490f, 0.06596337f, 
    -0.13583162f, 0.16026896f, 0.13200594f, -0.01118464f, -0.06859171f, -0.08227872f, -0.08975954f, -0.06834269f, 
    0.06526660f, 0.16707982f, -0.01160637f, -0.07100692f, -0.47271955f, -0.13324061f, -0.04739935f, -0.09047780f, 
    -0.01370005f, 0.03389135f, -0.03405085f, 0.00205843f, 0.27962947f, 0.02326939f, 0.00863393f, 0.09134830f, 
    -0.08224977f, 0.08187813f, 0.06822532f, 0.14536382f, 0.06772101f, 0.04224866f, -0.04682760f, 0.02307626f, 
    -0.04836907f, 0.17027792f, 0.07489435f, 0.02507143f, 0.60870427f, -0.13742280f, -0.09908917f, 0.25952375f, 
    0.07654438f, 0.10389742f, -0.10324603f, 0.13089588f, -0.06452159f, 0.17640027f, 0.02281873f, 0.10862782f, 
    -0.12755866f, -0.09838816f, 0.14296509f, 0.03087419f, 0.30110762f, 0.07807665f, 0.07845348f, 0.12446472f, 
    -0.02318372f, 0.01897685f, 0.11793844f, 0.16113847f, -0.14412034f, -0.44155365f, 0.23894756f, 0.34025279f, 
    0.01918513f, 0.01617008f, 0.17295894f, 0.13511205f, 0.10873423f, 0.06667563f, 0.02422511f, -0.09686274f, 
    -0.05538907f, 0.26872140f, 0.17626572f, -0.06546382f, 0.26451901f, 0.20885916f, -0.10463860f, -0.04463257f, 
    0.15755512f, 0.04082687f, 0.02679797f, -0.02248271f, -0.11671095f, -0.04533376f, 0.22917788f, 0.17134964f, 
    0.03628582f, 0.11714859f, 0.12025028f, -0.04382079f, 0.02772239f, -0.00338498f, 0.13046733f, -0.00574495f, 
    -0.58701724f, 0.00091120f, -0.07813235f, 0.27577534f, 0.10455291f, 0.10908943f, -0.00272605f, 0.05935179f, 
    -0.11679534f, 0.01552795f, -0.04565229f, -0.03952201f, 0.33434927f, 0.00831943f, -0.16652712f, 0.10708796f, 
    0.18023203f, 0.03661463f, -0.02713396f, 0.02990099f, 0.14320780f, -0.13399218f, -0.17426389f, 0.20061363f, 
    -0.16966717f, 0.07916760f, -0.32026413f, 0.08433412f, 0.04333415f, 0.10362293f, -0.07419240f, -0.03384839f, 
    0.11945377f, 0.03671423f, -0.12803277f, -0.15700492f, 0.25571498f, 0.21463451f, -0.13010930f, 0.09632216f, 
    0.02959938f, 0.11559452f, 0.04474265f, -0.10516700f, -0.09912932f, 0.06702127f, 0.00137581f, 0.07278927f, 
    0.02701946f, 0.08336841f, 0.10873041f, 0.14909929f, -0.09694286f, 0.15609965f, -0.00930330f, 0.10072265f, 
    -0.10249174f, -0.06307442f, 0.03688028f, -0.07609737f, -0.00208998f, 0.14533058f, 0.12620777f, 0.09498820f, 
    0.09235818f, -0.09528713f, 0.07946827f, 0.05152813f, 0.11590485f, 0.06080265f, 0.09146436f, -0.07736048f, 
    0.42908818f, -0.02616668f, 0.19183546f, -0.03378823f, -0.06432705f, 0.16558798f, 0.06134782f, -0.00191690f, 
    -0.04262714f, 0.05577640f, 0.16623859f, -0.05122397f, 0.03872764f, 0.13197128f, -0.02082935f, 0.11779138f, 
    -0.06618194f, 0.10954697f, -0.09584314f, 0.07339490f, -0.07266672f, 0.11138202f, -0.04466839f, 0.05879066f, 
    -0.18404685f, 0.34152821f, -0.03741438f, -0.09062722f, 0.17186671f, 0.17371401f, 0.06548441f, -0.05828037f, 
    -0.07466739f, 0.03219311f, 0.15769969f, 0.04343501f, -0.05349172f, -0.16745330f, 0.14865372f, 0.05635840f, 
    0.02564885f, -0.06517857f, 0.08233391f, 0.05954852f, 0.04976926f, -0.13175656f, 0.12060902f, 0.00858963f, 
    0.10919636f, 0.33321398f, 0.04296110f, -0.15869577f, 0.03443387f, -0.11140323f, 0.15824240f, 0.08932326f, 
    0.02328471f, -0.06211327f, -0.10826454f, -0.12354992f, -0.56856543f, 0.27495423f, 0.03004908f, -0.16991408f, 
    0.12317379f, 0.02669138f, 0.20424463f, -0.09048565f, -0.07922604f, -0.02276128f, 0.08129687f, 0.03444309f, 
    0.01177671f, 0.07896472f, -0.02545152f, -0.09535143f, -0.08320849f, 0.09970490f, -0.06060277f, -0.01101253f, 
    0.05912210f, -0.12424204f, 0.00547623f, 0.11072727f, -0.33765274f, 0.00891516f, -0.12264084f, 0.05744890f, 
    -0.07759579f, -0.03043881f, 0.10849402f, 0.01827662f, -0.06178467f, 0.05364693f, 0.04443016f, -0.00991048f, 
    -0.28502512f, -0.09015515f, -0.10947578f, -0.10614789f, 0.00340313f, 0.17122312f, -0.00135109f, -0.04655272f, 
    -0.01870713f, -0.05069881f, -0.07621362f, 0.18485020f, -0.14103788f, 0.01973292f, 0.24724062f, -0.04992476f, 
    0.08392283f, -0.08029107f, 0.07177407f, 0.06110888f, 0.01399623f, 0.05139008f, -0.02571185f, 0.07375877f, 
    -0.46958554f, 0.24266143f, 0.11895756f, -0.06815515f, 0.10312594f, -0.07827330f, 0.09647026f, -0.01922091f, 
    0.22331937f, -0.00730017f, 0.10314875f, 0.08335932f, -0.13830316f, -0.12405849f, 0.17422178f, -0.06879083f, 
    -0.09845568f, 0.10995127f, -0.02970439f, 0.05243505f, 0.15319447f, -0.13339730f, -0.08305180f, -0.06728470f, 
    -0.26166415f, 0.17295787f, -0.11588902f, -0.14571111f, 0.03940822f, 0.11893842f, -0.09448382f, 0.01514034f, 
    0.17507543f, -0.07085799f, -0.02595049f, 0.05644433f, 0.65212339f, -0.03641167f, 0.15255649f, 0.28204665f, 
    -0.09327582f, 0.06854483f, 0.00135875f, -0.03166911f, 0.05283524f, 0.13799290f, 0.03968135f, 0.15862124f, 
    0.01707182f, -0.09973038f, 0.17880996f, 0.23659775f, -0.03339301f, 0.01117561f, -0.00346025f, 0.04137098f, 
    0.20532475f, -0.05235658f, -0.00108128f, 0.06774303f, 0.20262317f, -0.17632230f, -0.08300327f, -0.03347167f, 
    0.16125701f, -0.05310158f, -0.19392793f, 0.07567782f, 0.01212276f, 0.05558213f, 0.04239517f, -0.08750556f, 
    0.31196281f, 0.20635492f, -0.26348853f, 0.14326151f, -0.08788343f, -0.12450825f, -0.00337948f, 0.02988764f, 
    0.04245799f, -0.00799419f, 0.05191110f, 0.03242731f, 0.36308172f, 0.03854001f, -0.08482503f, 0.17032902f, 
    -0.13665591f, 0.03228234f, 0.16196537f, -0.00276042f, 0.07448285f, 0.07577471f, 0.07161362f, 0.10344598f, 
    0.28914663f, -0.11272971f, 0.31001437f, 0.27308837f, -0.06968424f, 0.08174958f, 0.01693015f, 0.02590860f, 
    0.02455172f, -0.05686324f, -0.13018623f, -0.01661481f, 0.24391189f, -0.07888135f, 0.16179977f, -0.14348322f, 
    -0.00143931f, -0.06612632f, 0.04846253f, -0.13167164f, 0.01698069f, 0.08742419f, -0.09441731f, -0.07008069f, 
    0.64590520f, -0.21365871f, 0.14105225f, 0.39188236f, -0.03522503f, -0.13714500f, -0.09842671f, 0.01200251f, 
    -0.04921079f, 0.11925124f, 0.08545440f, -0.03148511f, -0.25771141f, 0.10765547f, 0.06197909f, -0.05392230f, 
    -0.04741555f, 0.20498028f, 0.12474045f, 0.00756570f, 0.02711436f, 0.04097673f, 0.11569095f, -0.03148464f, 
    -0.17254452f, -0.05479907f, -0.01030604f, 0.18159980f, 0.02442405f, 0.19418178f, -0.00885971f, -0.00256011f, 
    0.00710364f, -0.11109146f, -0.09162804f, -0.15830001f, -0.20298569f, 0.28006977f, 0.03794168f, -0.14635167f, 
    0.06965773f, -0.17067987f, -0.03042625f, -0.05212086f, -0.01551935f, 0.03586791f, -0.21443950f, 0.08018894f, 
    0.01223784f, -0.13836201f, 0.03201792f, 0.03060702f, 0.03172733f, 0.02773320f, -0.01453022f, 0.07466383f, 
    -0.06562092f, -0.09931593f, 0.11689725f, -0.17594805f, 0.28854421f, -0.15023685f, -0.08746056f, 0.27172253f, 
    0.00569727f, 0.04447217f, 0.06114037f, -0.06311254f, 0.06195259f, 0.16656385f, -0.13492130f, 0.11076036f, 
    0.06647012f, -0.07135777f, -0.01657196f, -0.02922682f, 0.12097919f, 0.08970608f, -0.09148314f, -0.08830165f, 
    -0.07292867f, 0.06773075f, -0.02333574f, 0.07849050f, 0.10186860f, -0.24961333f, 0.02005145f, 0.09670372f, 
    0.16553275f, -0.08154513f, 0.01870717f, -0.01903298f, -0.01620148f, 0.00627431f, 0.13271858f, 0.04893917f, 
    -0.21357730f, -0.26941112f, 0.38935056f, 0.04316259f, -0.16444862f, -0.07767034f, 0.13016719f, -0.13306561f, 
    0.05778456f, -0.01631690f, 0.03324091f, 0.23558083f, -0.33574268f, 0.38778910f, 0.18833886f, -0.26837420f, 
    0.24807850f, -0.08519727f, -0.03063713f, -0.11910082f, 0.05132733f, -0.12737390f, 0.06071612f, -0.00763275f, 
    0.18258817f, -0.08466805f, -0.15525544f, 0.23461239f, 0.13617574f, 0.03356285f, 0.07269675f, 0.03928148f, 
    -0.16396007f, 0.18752630f, 0.09528534f, 0.00590904f, 0.55227453f, 0.18222573f, 0.01191780f, -0.07357759f, 
    0.07783861f, -0.17690782f, 0.02254428f, 0.10227568f, 0.18985736f, 0.02440511f, 0.08073437f, -0.04471761f, 
    0.38847777f, -0.05830306f, 0.00743477f, 0.11511817f, 0.18124318f, 0.14150669f, 0.02649398f, 0.07557499f, 
    -0.03011009f, 0.07653662f, 0.08151390f, -0.00027762f, -0.22347546f, 0.01691649f, 0.03167941f, -0.08053007f, 
    0.09894081f, -0.03856471f, -0.20521620f, -0.02786964f, -0.00411907f, 0.16970178f, -0.12234387f, -0.04801573f, 
    -0.08691635f, 0.27048662f, 0.00586091f, -0.11794224f, 0.09385497f, 0.03290286f, 0.07533329f, 0.01430844f, 
    -0.10403710f, 0.00848998f, 0.15502711f, 0.11671561f, -0.22081082f, -0.22089408f, 0.27076656f, 0.21395423f, 
    0.04071194f, 0.22704338f, 0.01284626f, 0.02747507f, 0.14243011f, 0.16391422f, 0.01031098f, 0.07820077f, 
    -0.04115737f, 0.09934951f, 0.02353089f, -0.09371768f, 0.29157972f, 0.13788559f, 0.07126355f, -0.20117399f, 
    0.02987249f, -0.05162496f, -0.01800524f, -0.08793228f, -0.03043030f, 0.02782938f, 0.25941974f, -0.21438383f, 
    0.06474897f, -0.18238813f, 0.06336021f, -0.13198611f, 0.04063508f, -0.03829295f, -0.01765943f, -0.12835559f, 
    0.34942520f, -0.21422508f, 0.00434151f, -0.07655542f, 0.08782015f, 0.02266538f, -0.07289705f, 0.09820751f, 
    0.01002725f, 0.06665371f, 0.09659531f, 0.14906266f, 0.00339282f, -0.10408409f, -0.02411360f, -0.17588040f, 
    0.06738336f, 0.05903630f, 0.08211362f, 0.10810710f, -0.00417133f, -0.02131721f, 0.18514860f, 0.01273927f, 
    0.29399115f, -0.19973849f, -0.03310685f, -0.00428768f, -0.08393080f, 0.14052978f, 0.00441701f, -0.05744103f, 
    0.02855858f, 0.04810229f, -0.01374826f, 0.07201131f, -0.32836550f, -0.15982720f, -0.45226890f, -0.30547175f, 
    -0.14865531f, -0.12030019f, 0.01155953f, 0.01641724f, 0.02883703f, 0.02729981f, 0.22070341f, 0.04432902f, 
    -0.02381718f, -0.01530023f, -0.20048605f, 0.13700317f, -0.05323836f, 0.12259590f, 0.18389668f, 0.05139749f, 
    -0.03708586f, 0.02683122f, 0.05803721f, -0.07998342f, -0.28927505f, 0.16474047f, -0.05495510f, -0.19168858f, 
    -0.09720917f, -0.03451620f, -0.04346713f, -0.08141234f, 0.09917614f, 0.05647804f, 0.11205882f, 0.06432032f, 
    0.14178212f, -0.20819776f, -0.13301064f, 0.14561523f, 0.08133530f, 0.07568627f, 0.02834092f, 0.33557266f, 
    0.00633050f, -0.04338351f, -0.09484418f, -0.00823577f, 0.33896413f, -0.01126168f, -0.11879479f, 0.20310783f, 
    0.12234995f, -0.02986447f, 0.03090892f, 0.13321094f, 0.11665734f, 0.14499156f, -0.20936468f, 0.11827393f, 
    0.11633084f, 0.21534029f, -0.07026627f, -0.38146734f, -0.06378217f, 0.03560162f, 0.09447233f, -0.03297678f, 
    0.12509339f, -0.05050770f, -0.08667304f, 0.22244729f, 0.13609895f, 0.32635683f, 0.01545228f, 0.11758891f, 
    -0.00500262f, 0.11520577f, 0.14470407f, -0.07351153f, -0.04877385f, 0.16190442f, 0.04117151f, -0.01299338f, 
    0.15179710f, 0.44012573f, 0.25278732f, -0.12985881f, 0.04034148f, 0.17929718f, 0.02677338f, -0.01161776f, 
    0.22779472f, -0.00006506f, -0.02349690f, 0.05789214f, 0.18532133f, 0.04690111f, 0.06350826f, -0.08274829f, 
    0.04726939f, -0.07418713f, -0.03680446f, 0.02702305f, 0.11977566f, -0.03837641f, 0.16745657f, 0.07987544f, 
    0.05274359f, -0.00190737f, 0.13157582f, -0.11882863f, 0.10049675f, -0.08385085f, 0.05061269f, -0.01824060f, 
    0.17233664f, 0.17713726f, 0.03054677f, -0.01548155f, -0.29227805f, -0.22348234f, 0.02923748f, -0.02842016f, 
    -0.00987532f, -0.02047066f, -0.00420348f, 0.16791110f, 0.10071827f, 0.06021912f, 0.04991826f, 0.18279055f, 
    0.12221224f, 0.06700466f, 0.10281106f, 0.01299284f, 0.13366491f, -0.02777419f, 0.01398595f, 0.01528751f, 
    -0.05422476f, 0.04746479f, 0.17118807f, 0.05501051f, 0.33632401f, -0.23142765f, -0.07631581f, 0.30596760f, 
    0.17380750f, 0.15284623f, 0.01476405f, 0.20203683f, -0.05991171f, 0.16579485f, 0.10452645f, 0.11982222f, 
    -0.23630668f, 0.02381593f, -0.25132647f, -0.10878995f, -0.16202581f, 0.08751954f, -0.05322191f, -0.00360861f, 
    0.05822216f, -0.05453819f, 0.10549439f, -0.03441975f, -0.13703962f, 0.28752244f, -0.09832355f, 0.17247687f, 
    -0.00725290f, -0.19694591f, -0.06924509f, -0.02089432f, 0.00749181f, 0.07817280f, -0.00740765f, 0.03508471f, 
    -0.68084264f, -0.14135724f, -0.24991851f, 0.03983299f, 0.01608593f, 0.04951333f, -0.03772229f, -0.06138312f, 
    -0.03926176f, -0.05592204f, -0.12254200f, 0.04486487f, 0.30788961f, 0.25887653f, 0.28488374f, 0.26147246f, 
    0.07177879f, 0.00712294f, 0.09895618f, 0.16206706f, -0.00830531f, 0.14228810f, -0.16569665f, -0.00408136f, 
    -0.00315690f, 0.21523650f, 0.03321011f, 0.04831909f, 0.07292024f, -0.09803351f, -0.03662582f, 0.00271412f, 
    0.07449663f, -0.01493547f, 0.10852065f, 0.05420636f, -0.28741437f, -0.13629895f, 0.13112339f, 0.17321207f, 
    -0.06136539f, 0.05174347f, -0.00844343f, 0.06890107f, -0.00711692f, -0.15789033f, 0.04207412f, -0.06208897f, 
    0.02025276f, 0.37353030f, -0.08457093f, -0.13790251f, 0.06262707f, -0.00823630f, 0.15492764f, -0.15595457f, 
    0.14980717f, -0.09014253f, 0.13269132f, 0.02007432f, 0.13361837f, -0.10119580f, 0.08823816f, -0.12385552f, 
    -0.10810154f, -0.04619105f, -0.10786545f, -0.09501043f, 0.10532109f, -0.04877010f, 0.09273647f, 0.05429785f, 
    0.06213289f, -0.36907682f, -0.02378183f, 0.27492443f, 0.12111918f, 0.05412227f, 0.02168527f, -0.03442284f, 
    0.16016322f, -0.10305924f, 0.15922004f, 0.06998012f, 0.20539874f, -0.24254870f, 0.05034840f, -0.07744817f, 
    0.08613448f, -0.05610355f, -0.15660767f, 0.09764910f, 0.09287939f, -0.00356321f, 0.05471436f, 0.11429586f, 
    0.18030080f, -0.09606887f, -0.24137002f, 0.27607641f, 0.06444208f, -0.10363966f, -0.08607391f, 0.08652709f, 
    0.00705049f, 0.07064860f, -0.05867363f, 0.10370623f, 0.12576953f, 0.07171165f, 0.02723112f, -0.12088031f, 
    -0.11592378f, 0.06110259f, 0.14593753f, 0.06564841f, 0.04482966f, 0.03797239f, -0.00463046f, 0.06718535f, 
    0.02881485f, 0.03758413f, 0.03939708f, 0.07276261f, -0.04948608f, 0.07473052f, -0.00009309f, -0.04178652f, 
    -0.06960335f, -0.03664541f, -0.11004940f, 0.04842990f, 0.16283628f, 0.02872159f, -0.05400615f, -0.02036159f, 
    -0.03072960f, 0.13144733f, 0.15085591f, 0.07990228f, 0.05081704f, 0.07577383f, -0.00008139f, 0.05627099f, 
    0.33415788f, -0.18810798f, -0.01253881f, 0.16393539f, -0.14548163f, -0.02540322f, -0.01577902f, -0.04637979f, 
    -0.05340688f, 0.02800576f, 0.09260287f, 0.02929179f, 0.02355837f, 0.05715972f, 0.04506703f, -0.11885998f, 
    0.08086116f, -0.01402068f, -0.03527567f, 0.02752817f, -0.02574979f, 0.04346796f, -0.00237937f, -0.00660408f, 
    -0.08872279f, -0.00675322f, 0.11023742f, 0.05522897f, 0.09695844f, 0.03417659f, 0.06737554f, 0.14187016f, 
    -0.01155471f, 0.03348086f, -0.08413896f, -0.00132589f, 0.01525637f, 0.28285995f, 0.13425706f, -0.12060156f, 
    0.04962597f, 0.05641188f, -0.10862818f, -0.02283385f, 0.09791250f, 0.02982873f, -0.09956286f, 0.01239049f, 
    0.20708926f, 0.15000771f, 0.10116033f, 0.03196194f, 0.14345933f, -0.22760536f, 0.13920271f, 0.04642418f, 
    0.12497042f, -0.10932278f, 0.00734488f, -0.06320137f, 0.42543459f, -0.15696405f, -0.06731590f, 0.02629121f, 
    0.21939960f, 0.03410980f, -0.00587500f, -0.10550592f, -0.00944940f, 0.10246965f, -0.18699312f, -0.02301637f, 
    0.85738599f, -0.43221462f, 0.09491686f, -0.14243111f, 0.01246253f, -0.03696197f, -0.17232510f, 0.19077894f, 
    0.01752306f, 0.05247942f, 0.06302753f, -0.00620839f, 0.13469361f, -0.02797244f, 0.12159966f, 0.08345291f, 
    0.26975232f, 0.00636201f, 0.17331864f, -0.03691716f, -0.00346066f, 0.04903056f, 0.13082811f, 0.02325285f, 
    -0.13263826f, -0.37955895f, 0.29458255f, 0.10251002f, -0.12895554f, 0.06852146f, 0.04281495f, -0.14237863f, 
    -0.13482264f, 0.02444498f, 0.19981956f, 0.29572812f, -0.06206949f, 0.19253446f, 0.26036671f, -0.11899944f, 
    0.08358035f, 0.02462561f, -0.14255433f, -0.07113917f, 0.11906957f, 0.03461903f, 0.11196295f, -0.05416859f, 
    0.00296454f, 0.04099071f, -0.13689917f, -0.02479101f, 0.12024768f, -0.03864693f, -0.00992833f, 0.02416097f, 
    -0.19621827f, 0.12066079f, -0.00839803f, -0.14271399f, -0.05367714f, 0.21002677f, -0.03269776f, -0.08432461f, 
    -0.20451590f, -0.01227719f, 0.12507860f, 0.21470746f, 0.05025634f, -0.15036581f, 0.00800512f, 0.04837391f, 
    -0.42587602f, -0.27420014f, -0.06144824f, 0.10677977f, 0.07756303f, -0.00165883f, 0.08976813f, 0.06742202f, 
    -0.15446880f, 0.07398491f, -0.13185839f, -0.18134047f, 0.03247274f, -0.01742593f, -0.25277251f, 0.27023166f, 
    0.15617935f, 0.09190630f, -0.08518816f, -0.02812373f, 0.00633338f, 0.13932557f, -0.10231151f, -0.03327576f, 
    -0.02403510f, 0.08036626f, -0.09369683f, 0.14339425f, -0.07941398f, -0.02874056f, -0.08350125f, -0.03219239f, 
    0.00128112f, 0.03570034f, 0.08043335f, -0.00205340f, -0.22046685f, 0.02588291f, -0.01910150f, -0.16948518f, 
    0.02945997f, 0.02501014f, -0.11688771f, -0.12857774f, 0.12948698f, 0.15726833f, 0.06690832f, 0.04260739f, 
    -0.01101836f, 0.05052448f, 0.00372173f, -0.03355750f, 0.10233074f, 0.10510067f, 0.05951135f, -0.14536299f, 
    -0.07226516f, 0.08210406f, 0.03486253f, 0.02458884f, 0.27474940f, -0.07013939f, 0.16473380f, 0.04391477f, 
    0.11329167f, -0.07696787f, -0.09219554f, -0.03166917f, 0.11378960f, -0.04305850f, -0.05894604f, -0.12417823f, 
    -0.42865649f, -0.05964686f, 0.23329006f, 0.31432810f, 0.06005227f, -0.06285381f, 0.08724870f, 0.04477793f, 
    -0.07320224f, 0.10521422f, 0.09163374f, 0.01773191f, 0.38629046f, -0.06478725f, 0.26925975f, 0.17218858f, 
    0.10504316f, 0.00723797f, 0.07121695f, -0.05278398f, 0.08616944f, 0.07990561f, 0.00120334f, 0.06133723f, 
    -0.38351899f, 0.18498103f, 0.02090153f, 0.05962893f, 0.19315884f, -0.00372578f, 0.04027120f, 0.12327224f, 
    0.08058560f, 0.04422604f, 0.03617368f, -0.03074412f, 0.30162209f, 0.42256263f, 0.06651307f, -0.12929389f, 
    0.10532049f, -0.07879044f, -0.11164178f, -0.04286373f, 0.05087047f, 0.00003290f, -0.00362496f, -0.13039877f, 
    -0.00606073f, -0.04808799f, 0.01174621f, 0.10240296f, 0.12724024f, 0.07800561f, -0.02000676f, 0.13876590f, 
    0.00667605f, 0.03655982f, -0.13495220f, -0.02204978f, 0.45413280f, 0.09980325f, -0.17728235f, 0.03409743f, 
    0.22282681f, -0.02503032f, 0.04000815f, -0.03863529f, -0.07290999f, -0.05175460f, -0.04609987f, 0.02736417f, 
    0.05282718f, 0.14679879f, 0.01116768f, 0.07215068f, 0.22090362f, 0.13507755f, 0.08094233f, 0.00572360f, 
    -0.08121578f, 0.03785688f, 0.16093065f, 0.02779888f, -0.19721030f, 0.06981469f, -0.10291407f, -0.10922364f, 
    -0.07002401f, 0.08171256f, 0.11099318f, -0.04256713f, 0.01493770f, -0.03622708f, 0.10643081f, 0.04929755f, 
    -0.21512341f, -0.01681595f, 0.14429209f, -0.00175288f, -0.07913558f, 0.02525551f, -0.05429092f, 0.14442325f, 
    -0.00253986f, -0.06681672f, 0.16169660f, -0.01612605f, -0.40601429f, -0.20242013f, 0.08137448f, -0.11885092f, 
    -0.08687374f, 0.12314488f, 0.19464813f, 0.01565673f, 0.02693113f, -0.04100887f, 0.04975986f, 0.10810170f, 
    -0.26362601f, -0.43976495f, 0.13718851f, 0.12840627f, -0.11567239f, 0.05933385f, 0.07778707f, -0.02873343f, 
    -0.01794829f, 0.14410582f, -0.04600400f, 0.04397658f, -0.18331291f, 0.00995656f, 0.12731649f, 0.09078304f, 
    -0.02100166f, 0.17661449f, -0.03334813f, 0.15720180f, -0.08935826f, 0.09112772f, -0.03011873f, 0.17764390f, 
    -0.28046992f, 0.06335387f, -0.18736614f, -0.11687341f, 0.06403324f, 0.07206705f, 0.03363187f, 0.08949299f, 
    -0.09304827f, -0.12815689f, -0.01573866f, 0.16390914f, -0.02267288f, 0.37769201f, -0.24670646f, -0.08531913f, 
    -0.08372825f, 0.01997306f, 0.08195712f, 0.12264831f, -0.24627849f, -0.08378696f, 0.10790610f, -0.10273487f, 
    -0.34422436f, 0.13610746f, -0.05808096f, -0.19200999f, -0.17562544f, -0.06554003f, -0.07937210f, -0.04197071f, 
    -0.00118435f, -0.13851705f, -0.01920186f, 0.06823492f, -0.18746528f, 0.13701652f, -0.27093282f, -0.01044187f, 
    -0.10269174f, -0.17548485f, 0.02184246f, 0.11123725f, 0.01075907f, 0.03242029f, 0.06303716f, 0.08769582f, 
    -0.02634483f, -0.06122069f, -0.02185169f, -0.06351445f, 0.06131751f, 0.01875284f, 0.05442291f, 0.01019640f, 
    0.00501651f, -0.01042276f, -0.01591618f, -0.06042609f, -0.04001125f, -0.02053034f, -0.04106728f, -0.00201883f, 
    0.00948322f, 0.05123932f, 0.05417295f, -0.01863251f, 0.01853070f, 0.00310320f, -0.01390590f, -0.05718730f, 
    -0.07721561f, 0.04661310f, -0.02194677f, -0.01759825f, -0.06445488f, 0.02204636f, 0.02623750f, 0.00080528f, 
    0.02817509f, -0.07584761f, -0.04703876f, 0.05887590f, 0.00289700f, 0.05901358f, 0.05906497f, -0.02675881f, 
    -0.03859678f, 0.05578529f, -0.07018552f, -0.02048241f, 0.02381027f, -0.04161146f, -0.06052497f, 0.04456203f, 
    -0.03873617f, -0.04953572f, 0.03621728f, -0.05180571f, 0.06130620f, -0.05900677f, -0.03849832f, 0.04378651f, 
    -0.02053152f, 0.02108222f, -0.03001195f, -0.06093756f, 0.05344769f, 0.00956469f, -0.04498973f, -0.02545054f, 
    -0.00462541f, 0.00662326f, -0.04849157f, 0.05537419f, 0.05454633f, -0.00878177f, -0.03831875f, 0.04375679f, 
    0.02840740f, -0.01986120f, -0.05859255f, -0.01819472f, 0.02470806f, -0.03638155f, -0.03256679f, 0.02591667f, 
    0.04654593f, 0.03391144f, -0.03131657f, -0.05514131f, -0.03156296f, -0.04955339f, 0.01615058f, -0.02212887f, 
    0.00865378f, 0.01322761f, -0.06874296f, -0.01789032f, -0.06532177f, -0.03482122f, -0.06143463f, 0.01853365f, 
    0.03928154f, 0.04383983f, -0.05920758f, 0.00788865f, 0.05247188f, 0.00569360f, -0.02120048f, 0.04305872f, 
    0.03144663f, 0.01848742f, -0.00552195f, 0.03512340f, 0.01219272f, -0.07783213f, 0.01351599f, -0.03874514f, 
    0.05610795f, -0.00958887f, 0.04289089f, -0.07385450f, -0.04783147f, 0.04794920f, -0.04185852f, 0.02267964f, 
    0.03192612f, -0.02921155f, -0.01224897f, 0.06137998f, -0.04691857f, -0.08157267f, -0.06744868f, 0.03110006f, 
    0.04709095f, -0.06403956f, -0.05438438f, -0.05509485f, 0.02703307f, 0.03352663f, -0.04139734f, -0.02461251f, 
    -0.02080411f, 0.02856372f, -0.03849044f, -0.08142416f, -0.07138138f, -0.01112889f, 0.04306601f, -0.02844436f, 
    -0.08249535f, -0.07854593f, -0.02246178f, 0.04221643f, 0.03045758f, 0.05974459f, 0.03306274f, -0.04948536f, 
    -0.00377978f, 0.01348453f, -0.03932409f, -0.05736366f, -0.03298082f, 0.01970162f, 0.01161764f, -0.00755458f, 
    -0.00913960f, 0.05344208f, -0.01354179f, -0.07568318f, -0.05282584f, 0.00138685f, 0.03765421f, 0.01480051f, 
    -0.03186160f, -0.08105352f, 0.00900162f, -0.02465415f, 0.03200374f, 0.03835713f, -0.02922954f, 0.04502327f, 
    -0.04635698f, -0.03377736f, 0.02088469f, -0.07369477f, 0.00322444f, -0.07515749f, -0.07105941f, 0.01534934f, 
    -0.03921977f, 0.05718113f, -0.02715817f, -0.01581926f, 0.04471165f, 0.04736852f, 0.02096756f, 0.03299098f, 
    -0.09474224f, 0.17343275f, 0.01199276f, 0.15676047f, -0.25654843f, -0.06155501f, -0.07148062f, -0.28944400f, 
    -0.04134618f, -0.11414149f, 0.10804021f, 0.12147881f, 0.00678808f, 0.09529522f, -0.21217817f, -0.29059869f, 
    -0.26602396f, 0.09257376f, 0.07290684f, -0.00054670f, -0.02772219f, 0.09301101f, -0.07945043f, 0.32227689f, 
    0.34487164f, -0.00297230f, -0.04226352f, 0.13881214f, -0.18335398f, -0.17161781f, 0.12157376f, 0.01337118f, 
    -0.15636460f, 0.04635574f, 0.05237171f, 0.15058443f, -0.14769571f, -0.05935103f, -0.08463880f, -0.19545397f, 
    0.18181412f, 0.02493502f, -0.12597372f, 0.00926896f, 0.08812380f, 0.03741911f, -0.08454832f, 0.17538281f, 
    -0.30248168f, 0.23455769f, 0.21529259f, -0.32992887f, 0.03527261f, 0.00851181f, 0.04759277f, 0.04907891f, 
    0.22302884f, -0.08169456f, -0.02579433f, 0.04482234f, -0.07242323f, -0.13416846f, 0.23407367f, 0.01664037f, 
    -0.16513421f, 0.13046731f, 0.03796077f, -0.07150190f, 0.01221857f, 0.03710498f, 0.09286962f, -0.07717859f, 
    -0.00768588f, 0.04477216f, 0.24476065f, -0.13708574f, 0.12014167f, -0.06068059f, -0.02543809f, -0.02826204f, 
    0.02460688f, 0.14578775f, 0.04602686f, 0.03298694f, 0.23769273f, -0.02511478f, 0.39033738f, 0.01239772f, 
    0.07130477f, 0.01814316f, 0.04277227f, 0.18514329f, 0.08088692f, 0.22031531f, 0.08867005f, 0.04590354f, 
    -0.04281572f, 0.01953245f, 0.12901898f, -0.28567198f, 0.00805109f, -0.17520237f, 0.11477510f, -0.04016452f, 
    0.18737760f, 0.15601090f, 0.03900965f, -0.00607243f, -0.00785844f, -0.03476007f, 0.05876212f, -0.06414365f, 
    0.03293293f, 0.11598368f, 0.05455558f, -0.09527037f, -0.10323725f, 0.02278388f, 0.16402391f, -0.09537543f, 
    -0.72146028f, 0.01986298f, -0.07228555f, 0.01857468f, 0.16162878f, 0.02352734f, -0.06098434f, 0.01781959f, 
    0.15229583f, -0.01664801f, -0.10026348f, -0.07812497f, 0.25040069f, 0.03761599f, 0.24257982f, -0.05840933f, 
    0.16019186f, 0.01788888f, -0.00666321f, -0.00923905f, 0.07953860f, -0.05302886f, -0.05831916f, 0.01078493f, 
    0.09478783f, -0.08493824f, 0.03541398f, -0.04372475f, -0.00039219f, -0.06655258f, -0.14553009f, 0.18109447f, 
    0.16401123f, -0.02837633f, -0.17545904f, -0.09190009f, 0.07797870f, 0.14279908f, -0.07390878f, -0.07825778f, 
    0.04203543f, 0.10223427f, -0.00889989f, -0.03453620f, -0.15210699f, 0.25571278f, 0.01437965f, -0.03998818f, 
    -0.40408242f, 0.00185055f, 0.00981208f, 0.25052062f, 0.07604437f, -0.06207142f, -0.01155400f, -0.09992518f, 
    0.08263016f, 0.02879056f, 0.10997530f, -0.00037477f, 0.49648419f, -0.41647357f, 0.17549551f, 0.20021048f, 
    -0.14349253f, -0.05534671f, 0.01708506f, 0.18836416f, -0.06862821f, -0.09003673f, -0.02922255f, 0.05717023f, 
    0.07664293f, 0.01499226f, -0.01126073f, -0.18523890f, -0.08136739f, -0.11579239f, -0.05412163f, 0.05070920f, 
    -0.00390503f, 0.20202950f, 0.00443803f, 0.18517426f, 0.18414444f, 0.16402143f, 0.05992183f, 0.23617741f, 
    0.02951514f, 0.22365402f, 0.07003574f, 0.08895754f, 0.02527704f, -0.00740732f, 0.19375882f, 0.14289208f, 
    0.30927160f, 0.23122734f, 0.06071833f, -0.00024320f, -0.02128101f, 0.07503390f, -0.02418697f, 0.09417000f, 
    -0.05804893f, -0.11363939f, 0.11735057f, 0.15612671f, 0.00697611f, 0.18640198f, 0.13667707f, 0.13379365f, 
    -0.02093326f, 0.11072008f, -0.10041597f, 0.07086270f, -0.00273453f, -0.16364753f, 0.13847880f, -0.03137864f, 
    0.11634116f, -0.00825667f, 0.13964549f, 0.02469853f, -0.02125066f, 0.03516446f, -0.05997744f, 0.00477799f, 
    -0.17866795f, 0.10659609f, -0.10973743f, -0.01524733f, 0.26263228f, 0.18270648f, 0.08598251f, 0.02541817f, 
    0.16281287f, -0.02463117f, 0.11469987f, -0.08633914f, 0.00648421f, 0.25188264f, 0.19896039f, -0.09134772f, 
    0.17352065f, 0.04470038f, 0.04099913f, 0.02478791f, 0.10136632f, -0.08982247f, 0.01661073f, -0.03708470f, 
    -0.05190591f, -0.03693850f, 0.00279326f, -0.16764100f, -0.26388216f, 0.00176022f, -0.16505907f, 0.12901339f, 
    -0.16375843f, 0.00571584f, -0.03825793f, -0.08031989f, -0.20906751f, 0.04543512f, 0.06501219f, -0.10047542f, 
    -0.25284648f, 0.09581663f, 0.10867929f, -0.14680071f, 0.17381383f, -0.07555240f, -0.04749586f, 0.07253861f, 
    0.03822763f, 0.11089500f, 0.00740363f, 0.03858271f, -0.31102586f, 0.10132697f, -0.14427607f, -0.06251686f, 
    0.06133593f, 0.21648413f, 0.03826745f, -0.13800818f, -0.06782170f, 0.06511512f, 0.02941182f, -0.02807541f, 
    -0.30723947f, -0.10448761f, 0.07752345f, -0.03700409f, 0.12175440f, -0.20464855f, -0.07727619f, -0.09494818f, 
    0.07442226f, 0.08984160f, -0.05278547f, -0.04735842f, -0.16031034f, -0.02431797f, 0.01502133f, -0.05681641f, 
    0.02348690f, -0.12554862f, 0.22191453f, 0.02827043f, 0.19534174f, -0.05008853f, 0.07200932f, 0.09857195f, 
    -0.06476460f, 0.12355445f, -0.26971221f, 0.02204930f, -0.06663682f, -0.09308937f, 0.02663198f, 0.04460467f, 
    0.02467962f, 0.05033434f, 0.13761964f, -0.17439064f, 0.37368530f, 0.33314133f, -0.18313196f, 0.04081763f, 
    0.11262078f, -0.22847033f, 0.01379199f, -0.11852510f, 0.08203894f, -0.08200416f, 0.10919181f, 0.00723941f, 
    -0.56231260f, 0.16366924f, -0.08761718f, -0.29186741f, -0.01749684f, 0.03102553f, -0.12124470f, -0.03051968f, 
    0.05665174f, 0.17921992f, 0.08608270f, 0.09824872f, 0.13533770f, -0.23112056f, -0.11720111f, -0.06974135f, 
    -0.13436525f, 0.00311074f, -0.10017589f, 0.01828606f, -0.03141321f, 0.02906250f, 0.00809189f, 0.08004361f, 
    0.05433299f, -0.00216542f, -0.08034579f, 0.04788412f, -0.07075452f, -0.07018360f, -0.03156253f, -0.05217718f, 
    -0.01592790f, 0.06229019f, -0.03362272f, 0.00169957f, 0.02566141f, -0.06088172f, 0.02535411f, 0.04714513f, 
    0.02241024f, 0.03305842f, -0.04536014f, 0.03404505f, 0.01388849f, -0.00499978f, 0.03395838f, -0.03799727f, 
    -0.03098906f, 0.05212395f, -0.02439927f, -0.03380889f, -0.06503450f, -0.07223399f, -0.00994052f, 0.04385668f, 
    -0.06747385f, -0.07742801f, 0.01970012f, -0.02476158f, 0.02248458f, -0.02675995f, -0.01193428f, -0.06841809f, 
    0.00122426f, -0.06354744f, -0.00212105f, 0.03815854f, 0.04128606f, -0.01871240f, 0.00288429f, -0.01623737f, 
    -0.01154171f, 0.04981500f, -0.06305975f, -0.06281264f, -0.00500901f, -0.03138768f, 0.03058739f, 0.01741765f, 
    0.05541752f, 0.03347434f, -0.05279838f, -0.01873841f, -0.01820745f, -0.05168068f, -0.05094619f, 0.03728599f, 
    0.00080546f, 0.03972503f, -0.03749644f, -0.03238330f, 0.04230164f, -0.02472707f, -0.03030892f, -0.00556018f, 
    0.02938658f, -0.05610236f, -0.02840795f, 0.00660907f, -0.08405226f, -0.03446786f, -0.00477540f, -0.04018762f, 
    -0.07038735f, -0.02790863f, 0.06287551f, 0.01785990f, -0.03160500f, 0.04896472f, 0.03024435f, -0.06183032f, 
    0.02494809f, -0.02707900f, 0.06395236f, -0.00011844f, -0.07106166f, -0.07878064f, 0.02794455f, 0.04575122f, 
    0.05701185f, 0.02052901f, 0.00427911f, -0.03897240f, -0.03802932f, -0.00048513f, 0.02810785f, -0.01437243f, 
    -0.05718010f, -0.04305390f, 0.05570682f, -0.04058429f, -0.07504114f, 0.00124851f, -0.01975826f, -0.05303543f, 
    -0.03383308f, 0.01980398f, -0.06846330f, -0.03320306f, -0.02849802f, -0.06860542f, -0.00108560f, -0.07367980f, 
    0.01174474f, 0.00408783f, 0.05145795f, 0.05417429f, 0.04258994f, -0.06431102f, -0.05188171f, -0.01078427f, 
    0.01539355f, -0.08101069f, 0.05112035f, -0.06788690f, 0.01484769f, 0.03672418f, -0.04410984f, 0.03530019f, 
    0.04901305f, 0.00781796f, -0.06929679f, 0.01729594f, 0.01164011f, -0.03000756f, -0.02954466f, -0.01511693f, 
    -0.01515607f, -0.05951744f, 0.05098164f, -0.02345389f, -0.03272249f, 0.02867312f, -0.06682694f, 0.04860933f, 
    0.01928399f, 0.03236943f, -0.00988987f, 0.05609466f, 0.03804926f, 0.04593847f, 0.05958972f, 0.00622053f, 
    -0.07218614f, -0.06227931f, -0.00015310f, -0.03321332f, -0.07684004f, -0.07648432f, -0.06912243f, 0.00362336f, 
    0.00800173f, -0.07426333f, -0.02564650f, -0.06186650f, 0.01096937f, 0.03199685f, -0.01641117f, -0.05795681f, 
    -0.01820505f, 0.01945884f, 0.01067642f, -0.02253410f, -0.00554529f, 0.01675843f, 0.03735493f, -0.01210985f, 
    0.06437658f, -0.02264332f, 0.03455251f, 0.06526063f, 0.04314737f, 0.04644923f, 0.05287442f, 0.07047723f, 
    0.01034163f, 0.05775276f, -0.02797209f, -0.04333294f, -0.01179031f, 0.02715019f, -0.05060404f, -0.05704603f, 
    -0.06610253f, -0.06744920f, -0.05836143f, -0.05404956f, 0.01709503f, 0.02899131f, 0.03458593f, -0.02673006f, 
    -0.04883418f, 0.00426283f, -0.04614867f, -0.03795644f, -0.06932390f, 0.03037249f, -0.02771273f, -0.07078707f, 
    -0.07551844f, -0.05955476f, 0.05468898f, 0.01805337f, -0.00601494f, 0.06034341f, 0.00210266f, 0.01739872f, 
    -0.02870975f, 0.04308744f, -0.02487716f, 0.00497695f, 0.02713626f, -0.01667042f, -0.02353782f, -0.02590852f, 
    0.03109525f, 0.03133706f, 0.02162920f, 0.03989276f, 0.00833433f, 0.04603364f, -0.05662584f, -0.00486148f, 
    -0.06926253f, 0.04443427f, -0.05870877f, -0.04965305f, -0.04705488f, -0.02933291f, -0.05606114f, -0.00952147f, 
    -0.00950745f, -0.06342711f, -0.02169546f, -0.02221151f, -0.00916997f, -0.06265374f, 0.02285523f, -0.02251220f, 
    -0.06249001f, 0.01543541f, -0.07270814f, -0.07939137f, 0.03061027f, 0.04476336f, -0.05449282f, -0.04901803f, 
    -0.03501872f, 0.05102027f, -0.01658804f, -0.06063594f, 0.03274967f, -0.01628715f, -0.07992519f, -0.02371946f, 
    -0.04821144f, -0.02643503f, 0.04297511f, 0.04460756f, -0.02609686f, -0.00854514f, 0.04403904f, 0.02051806f, 
    -0.05079480f, 0.00854796f, -0.02706634f, 0.03295382f, -0.07622246f, 0.02414151f, -0.02830607f, 0.00327894f, 
    -0.02659779f, 0.04380475f, -0.03886014f, 0.01918093f, 0.04707133f, 0.03028616f, -0.04981977f, -0.07371797f, 
    -0.04396291f, 0.04196386f, 0.01567573f, 0.01718469f, -0.01233075f, 0.05608443f, -0.05680400f, -0.03282956f, 
    0.03602573f, -0.07309841f, -0.04272915f, -0.04905157f, -0.05212075f, -0.01367506f, 0.01197620f, -0.04487437f, 
    -0.04701757f, -0.02364630f, 0.06096622f, -0.06406163f, -0.04760894f, 0.01209130f, -0.00295379f, -0.04246490f, 
    -0.02693123f, -0.06430966f, -0.02718452f, 0.03520412f, 0.00668781f, 0.01005991f, -0.03446247f, -0.03126979f, 
    0.02748630f, -0.04418364f, -0.04614014f, 0.05458310f, -0.02376429f, 0.06241468f, -0.05863404f, 0.02677574f, 
    0.04096980f, -0.07518819f, -0.02289134f, 0.05947289f, -0.03920843f, 0.06137663f, -0.05941562f, -0.03431109f, 
    0.04089364f, 0.03173122f, 0.03532877f, -0.06762455f, -0.06177201f, -0.03167882f, 0.05068538f, -0.07113440f, 
    0.03553938f, -0.05623260f, 0.04288001f, -0.07349637f, -0.05540323f, -0.04250918f, -0.01000720f, -0.00882240f, 
    0.01384806f, -0.06403300f, -0.00923909f, -0.00956946f, -0.03788159f, -0.08160712f, 0.04898595f, 0.01994467f, 
    0.02300934f, -0.02669274f, -0.04180955f, -0.03468763f, -0.04657504f, -0.02963199f, 0.00778152f, -0.03378901f, 
    -0.00766447f, -0.05780278f, -0.07145686f, 0.06225552f, -0.01277696f, -0.02305773f, -0.02343914f, -0.05787921f, 
    0.01175775f, -0.20158964f, 0.02334465f, -0.01400156f, -0.03956771f, -0.06514272f, -0.04607430f, -0.08718010f, 
    -0.10612797f, 0.24028268f, -0.03900992f, 0.13326782f, 0.07191785f, 0.24697877f, -0.04506066f, -0.12572500f, 
    -0.01198090f, 0.14303127f, -0.13047391f, -0.04897860f, 0.00786504f, 0.00622212f, 0.14566010f, -0.15083691f, 
    0.26747736f, -0.13392384f, -0.05176750f, 0.15169090f, -0.12588918f, 0.13184832f, -0.08018207f, 0.00359698f, 
    0.06754924f, -0.01945780f, 0.03433836f, 0.00065233f, 0.04293676f, -0.17968458f, -0.23635381f, 0.13578874f, 
    -0.08835195f, 0.07325817f, -0.06881963f, -0.02852702f, 0.00849780f, -0.01819823f, 0.11469103f, 0.09361599f, 
    0.64677107f, 0.00484651f, -0.04325983f, 0.07563655f, -0.09704192f, 0.06137018f, 0.01182547f, -0.06042330f, 
    -0.02186668f, 0.02061737f, -0.12950055f, 0.00221761f, -0.07057469f, 0.14875416f, -0.10224162f, -0.01009629f, 
    0.08086883f, -0.04407740f, 0.12071883f, -0.03404884f, -0.06832500f, 0.09695321f, 0.08296240f, 0.05809115f, 
    0.21841964f, -0.04555910f, 0.15997747f, -0.11160138f, 0.01662732f, -0.06713241f, 0.02673840f, 0.02144034f, 
    -0.14184102f, 0.07690319f, -0.02077954f, -0.25221127f, -0.43700171f, -0.03419874f, 0.00352102f, -0.10863359f, 
    0.15706702f, 0.10403362f, 0.18857034f, 0.04842544f, -0.04030580f, -0.08164185f, -0.06227718f, 0.02160315f, 
    0.23117004f, -0.01058680f, -0.16170506f, -0.17077674f, 0.05507236f, -0.04360642f, 0.01076181f, -0.06677942f, 
    0.09812862f, -0.09242111f, -0.02507097f, -0.14170486f, 0.08994077f, 0.21323791f, 0.23453540f, 0.00622375f, 
    0.03010999f, 0.18751203f, 0.08879642f, -0.12771077f, -0.08271311f, 0.05180981f, 0.01581407f, -0.04716582f, 
    0.00586098f, 0.14652696f, 0.06702733f, 0.04184320f, 0.04835032f, 0.06391368f, 0.04156678f, -0.03314839f, 
    0.12157985f, 0.00512842f, 0.00853954f, 0.16206279f, 0.04186205f, 0.18136206f, 0.14594589f, -0.45840123f, 
    0.15343997f, -0.04141935f, 0.02561411f, 0.06111207f, -0.06496315f, 0.08683226f, 0.19355308f, 0.01955523f, 
    0.07267836f, 0.10224754f, -0.02248382f, -0.19867270f, 0.05003553f, -0.06909283f, 0.08694604f, -0.00990544f, 
    -0.00018824f, -0.04264959f, 0.00744206f, -0.13846754f, 0.08858484f, 0.09876487f, -0.17738836f, 0.11593360f, 
    0.00754017f, 0.01326455f, -0.04133389f, 0.13176703f, -0.01545608f, 0.00722460f, -0.00665188f, 0.07836651f, 
    -0.34181991f, 0.22285146f, -0.08158484f, -0.12845652f, -0.00026654f, 0.03024592f, -0.01468730f, -0.06831790f, 
    0.02288378f, 0.17433836f, 0.22025354f, 0.09488396f, 0.36833316f, -0.52365899f, 0.06153021f, 0.06789932f, 
    -0.00040739f, -0.06637691f, -0.06081601f, 0.11790628f, 0.04231210f, 0.10464352f, 0.09800836f, 0.20652941f, 
    0.26513490f, 0.42271495f, 0.05276344f, 0.13126674f, -0.14336739f, 0.09234253f, 0.21778879f, -0.08405160f, 
    0.05201471f, -0.18061753f, -0.12812832f, -0.25034356f, 0.23657532f, -0.11852157f, 0.00590639f, 0.00254050f, 
    0.11439595f, -0.17040829f, -0.02220466f, 0.05820312f, 0.04794722f, 0.01189566f, -0.03036276f, 0.08529925f, 
    0.17021041f, 0.25081405f, 0.03307487f, -0.02951682f, 0.02674551f, -0.06228567f, 0.00092911f, 0.04909054f, 
    0.03535931f, -0.01469389f, 0.19245337f, -0.03655650f, 0.05352604f, 0.09157316f, 0.36143249f, 0.31947353f, 
    0.06888224f, 0.19268477f, 0.06223897f, -0.01409921f, 0.07057811f, -0.05553490f, -0.04029283f, 0.01796853f, 
    -0.13294117f, 0.16496623f, -0.03319849f, -0.13435556f, -0.02693962f, -0.17551368f, -0.09755015f, -0.04533406f, 
    -0.02223097f, -0.02717166f, 0.03936996f, 0.08010575f, -0.03967945f, -0.11571892f, 0.13731106f, 0.25266081f, 
    -0.05534988f, 0.19465248f, -0.09282766f, -0.01586097f, 0.03856217f, -0.02312706f, -0.00595312f, -0.11869967f, 
    -0.00204263f, 0.09004444f, 0.03759717f, 0.06414302f, -0.06156885f, -0.04067402f, -0.00633112f, -0.01919795f, 
    0.11240661f, 0.07762612f, 0.09215377f, 0.16741200f, -0.29318738f, -0.15518454f, -0.01875346f, 0.09067930f, 
    0.00302673f, 0.00632593f, -0.09942571f, -0.03658352f, -0.01226230f, 0.05308862f, 0.16048349f, -0.06084113f, 
    0.06367034f, -0.01726303f, 0.00918588f, 0.37101546f, 0.00646172f, 0.14017089f, -0.04628980f, 0.00309701f, 
    -0.10468408f, 0.20266415f, 0.12408482f, 0.10809336f, -0.00623878f, -0.08659494f, -0.18970551f, 0.01778661f, 
    0.04141439f, -0.09416658f, -0.14556277f, 0.06556898f, 0.07609991f, 0.05255730f, -0.00794765f, -0.06857562f, 
    0.13088009f, 0.02692405f, -0.20934372f, -0.17184426f, 0.02056444f, -0.04765008f, 0.05246308f, 0.00108347f, 
    -0.06986484f, 0.09140676f, 0.16087496f, 0.08519468f, -0.11980939f, -0.15153374f, -0.15075003f, 0.20399168f, 
    -0.00284122f, -0.22333114f, -0.06830022f, -0.04281818f, 0.07315413f, 0.00650830f, -0.24450241f, -0.06840675f, 
    0.07696835f, -0.18026890f, -0.01574301f, 0.28376269f, 0.20389265f, -0.00034821f, 0.09995104f, 0.04212260f, 
    -0.08135151f, 0.16869354f, 0.05682574f, 0.15385741f, 0.13532282f, 0.07175123f, 0.30304471f, 0.23914486f, 
    0.05861135f, 0.13494410f, 0.00000331f, -0.04498202f, -0.11240450f, 0.04235100f, 0.04524686f, -0.05508813f, 
    0.32667959f, -0.34485683f, -0.09384374f, 0.02659074f, 0.12557799f, 0.15636666f, 0.06379227f, -0.08525229f, 
    0.18818527f, 0.03637786f, -0.09996319f, -0.00807663f, -0.48789719f, 0.36089602f, 0.13039649f, -0.18749127f, 
    -0.06121254f, 0.02667159f, 0.00373080f, -0.02955548f, 0.13713041f, -0.10075420f, -0.09355190f, -0.16371152f, 
    -0.17018008f, -0.35928798f, -0.18719073f, 0.01721642f, -0.03769705f, -0.11977260f, -0.17377302f, -0.00658673f, 
    0.08293898f, 0.16476382f, 0.12543939f, 0.10672834f, 0.24331133f, 0.03808982f, -0.09106269f, -0.03975587f, 
    0.17654628f, 0.14928742f, -0.18825363f, -0.00640903f, -0.03323674f, -0.04421475f, 0.00688038f, -0.13879181f, 
    -0.16507232f, 0.02025442f, -0.22992577f, 0.16910653f, -0.07737435f, 0.19246094f, 0.05278960f, 0.10063659f, 
    0.01383916f, 0.10487083f, 0.10155393f, -0.11777405f, 0.24075599f, 0.12204605f, -0.33325258f, 0.13189356f, 
    -0.08101536f, 0.08021276f, -0.04315620f, -0.00802197f, -0.03799956f, 0.04657691f, 0.28726885f, 0.17087419f, 
    0.20463377f, -0.02181167f, -0.39281747f, 0.06637717f, 0.11517266f, 0.03780749f, -0.00252384f, 0.11543646f, 
    -0.01539553f, 0.03172223f, -0.02506818f, -0.10989683f, -0.08177744f, -0.04699957f, -0.24488336f, -0.01425889f, 
    0.05030782f, -0.04324520f, -0.08632154f, 0.14093663f, 0.01807226f, -0.01245715f, 0.11088569f, 0.06911756f, 
    0.37869000f, 0.35442236f, -0.04293483f, -0.08156925f, 0.00284137f, -0.03344465f, 0.12372705f, 0.06971493f, 
    -0.02006767f, 0.03434310f, -0.03772281f, -0.24213281f, -0.49454519f, 0.03572312f, 0.08583605f, -0.29279590f, 
    0.15845117f, 0.04165992f, 0.15389644f, 0.09367678f, 0.03112466f, -0.17943998f, -0.13388391f, 0.17449586f, 
    0.11493093f, 0.11329752f, 0.07376677f, -0.08439404f, 0.03434452f, 0.08385082f, 0.03873791f, 0.00305675f, 
    0.00393160f, -0.19760257f, 0.09286109f, -0.02727463f, -0.01795563f, 0.11263058f, 0.35649943f, 0.09738057f, 
    0.08065107f, 0.11348399f, 0.13429554f, -0.02415858f, 0.10537378f, 0.03127844f, 0.05376285f, 0.07078951f, 
    -0.00767906f, -0.02119188f, 0.23542289f, 0.18327980f, 0.05649436f, 0.07490266f, 0.03497012f, 0.00928486f, 
    0.01511735f, 0.13633077f, 0.10153581f, 0.15023461f, -0.08259364f, 0.28585386f, 0.37852958f, -0.51945668f, 
    0.06151684f, 0.24517766f, 0.08308286f, 0.17210345f, -0.14204624f, 0.19137147f, 0.28094795f, 0.14688210f, 
    0.05061373f, 0.21362124f, -0.10430431f, -0.25805119f, 0.07847445f, 0.06112825f, 0.00949768f, 0.10794642f, 
    0.03648866f, -0.09257106f, 0.08833816f, 0.05893302f, 0.09967867f, 0.10096323f, -0.21329467f, 0.06319416f, 
    -0.13231304f, 0.06053190f, 0.06320827f, 0.22671799f, -0.11668590f, -0.11823996f, 0.06768165f, 0.12179790f, 
    -0.33106440f, 0.20956866f, -0.09207828f, -0.25921926f, -0.08901490f, 0.00053993f, 0.11654784f, 0.07517220f, 
    0.01630577f, 0.08622196f, 0.13605641f, 0.02868911f, 0.06716380f, -0.26301894f, 0.00639377f, -0.09917164f, 
    0.14177379f, -0.03745338f, 0.10456596f, 0.23425588f, -0.10509047f, 0.04543631f, 0.12228271f, 0.24259625f, 
    -0.29799891f, 0.05392987f, -0.05968061f, -0.03782262f, 0.03018062f, 0.09207346f, -0.00085433f, -0.01095085f, 
    0.07900317f, -0.11165335f, 0.14627805f, -0.03468732f, 0.23765685f, -0.17937237f, 0.10646390f, 0.17261471f, 
    0.03650739f, -0.18415639f, 0.13069539f, 0.04202937f, 0.04361059f, 0.12031870f, -0.04642059f, 0.19804323f, 
    -0.51165497f, 0.13722549f, -0.19488868f, 0.01524875f, 0.06014532f, -0.07562292f, 0.16915891f, -0.10050280f, 
    0.05640985f, 0.01497915f, -0.02688683f, 0.08877655f, 0.27424046f, 0.42978558f, 0.25759339f, -0.15914920f, 
    0.11210687f, -0.00875612f, 0.11509565f, 0.13267162f, -0.04271420f, 0.12058725f, -0.06031770f, -0.07152464f, 
    -0.17001937f, -0.03165837f, 0.03349823f, -0.08080660f, 0.19232252f, 0.10580648f, 0.07371555f, 0.23956974f, 
    0.14204118f, -0.07818218f, 0.06577349f, 0.07613028f, 0.02151712f, -0.09006210f, 0.04804686f, 0.16018018f, 
    -0.00225952f, -0.04683700f, 0.04786966f, 0.09253738f, -0.03686732f, 0.02928953f, -0.09956156f, -0.01312656f, 
    -0.01333039f, 0.34604186f, -0.05560165f, 0.01630709f, 0.18130563f, 0.13551986f, 0.17736329f, 0.00112593f, 
    0.04770533f, 0.04306141f, 0.20224027f, 0.16568170f, 0.41241208f, 0.02486461f, 0.05916235f, -0.06003496f, 
    -0.21422110f, -0.03520614f, -0.08754582f, 0.00386002f, 0.10961765f, 0.10050991f, 0.09053680f, 0.02861685f, 
    -0.08881041f, -0.05252150f, 0.21113862f, -0.02740387f, -0.09717570f, 0.02800871f, -0.04233014f, -0.01075885f, 
    0.01084044f, 0.13852705f, 0.11357231f, 0.11463603f, -0.42173180f, -0.13147053f, -0.04175636f, -0.07762150f, 
    -0.05750937f, -0.05804527f, -0.00198443f, 0.12924723f, 0.08396851f, -0.13273744f, 0.11503199f, 0.21654895f, 
    -0.39192459f, -0.34708089f, 0.12997046f, 0.22325990f, 0.03246751f, -0.10564324f, -0.02797946f, 0.02717854f, 
    -0.09333904f, -0.03474934f, -0.09095605f, -0.02381117f, 0.13143696f, 0.15076500f, 0.12844416f, 0.20993233f, 
    -0.09407834f, 0.15719987f, 0.03604233f, 0.11443681f, -0.05761290f, -0.02263001f, -0.03156056f, 0.06164576f, 
    -0.16411625f, -0.06133526f, -0.00272645f, -0.14106540f, -0.10745621f, 0.03143177f, -0.05854226f, 0.06988725f, 
    -0.04553163f, -0.01048516f, 0.04841125f, 0.10656117f, -0.01169748f, 0.25008714f, -0.19036536f, -0.19346178f, 
    -0.04189337f, -0.03573187f, 0.04141610f, -0.05503530f, -0.04216449f, -0.08033549f, -0.01255764f, -0.11853676f, 
    -0.08893176f, -0.07226905f, 0.14728582f, 0.00998495f, -0.26757616f, -0.07277514f, -0.02252951f, 0.06495218f, 
    0.00330645f, -0.06416319f, -0.03027177f, 0.03260498f, 0.07599523f, 0.22684446f, -0.05485306f, -0.02964276f, 
    -0.01265118f, 0.02081869f, -0.08187109f, 0.04437489f, -0.06608780f, 0.05860130f, 0.02715421f, -0.07511254f, 
    0.04968679f, -0.01880934f, -0.16301320f, -0.07883843f, -0.20971373f, -0.06249455f, -0.14401288f, -0.04101183f, 
    0.18780512f, -0.04439220f, 0.08178139f, -0.14720714f, 0.14930552f, 0.00313213f, -0.03258604f, 0.12757805f, 
    0.04475592f, -0.02453361f, 0.04045022f, 0.04894403f, -0.00084002f, 0.17164646f, 0.08445007f, -0.05237466f, 
    -0.55937719f, -0.13595051f, -0.21311150f, -0.09185941f, 0.05889479f, -0.05425473f, 0.09576634f, 0.03464920f, 
    -0.05259497f, 0.07540834f, -0.03210645f, -0.05540944f, 0.14636183f, 0.32149282f, 0.13408895f, -0.07682607f, 
    0.00895648f, -0.00512197f, 0.10996187f, 0.07015728f, -0.03857180f, 0.25471604f, -0.03826589f, 0.10799076f, 
    0.06402080f, 0.17384614f, -0.14269547f, -0.05301437f, -0.02323999f, -0.13435556f, 0.01882574f, 0.09615925f, 
    0.08440568f, -0.08197622f, 0.09519587f, 0.08728332f, -0.35405332f, -0.11116459f, -0.01871408f, -0.07021135f, 
    -0.19637771f, -0.01245497f, -0.05769097f, 0.19360101f, 0.05715429f, -0.06388887f, 0.01062670f, -0.01618947f, 
    0.06607517f, 0.29298288f, -0.17509691f, -0.10890481f, 0.11807113f, 0.07336288f, 0.12638868f, -0.00625245f, 
    0.01222008f, -0.12421545f, 0.17817853f, 0.15836659f, 0.31795484f, -0.27262190f, 0.01439014f, -0.15564428f, 
    0.02355794f, -0.01745884f, -0.14151654f, 0.01071149f, 0.20128185f, 0.06123600f, -0.05501365f, 0.22763798f, 
    -0.00217742f, -0.01854127f, 0.05008549f, 0.17081366f, 0.01326468f, 0.18997955f, 0.06659924f, -0.00348358f, 
    0.10488115f, -0.08963598f, 0.11549459f, 0.11638323f, -0.16987376f, -0.23078255f, -0.00222600f, -0.03188396f, 
    -0.04603638f, -0.02884177f, 0.01670021f, 0.11073730f, 0.02194882f, -0.13428700f, -0.06551073f, 0.09139540f, 
    -0.16891062f, 0.04921155f, -0.05921187f, 0.20192531f, -0.06771592f, -0.07713681f, 0.06314828f, 0.07409684f, 
    0.02119479f, -0.00080525f, 0.01694687f, 0.03917830f, 0.06293455f, 0.14589666f, 0.09326018f, -0.03785531f, 
    -0.08724803f, 0.19055593f, 0.11974807f, 0.10682137f, -0.04724829f, -0.01770547f, 0.01928457f, 0.10992581f, 
    0.32594427f, -0.31253904f, 0.10031506f, 0.07127500f, -0.05501920f, 0.00087954f, 0.00709781f, 0.06473839f, 
    0.14724958f, 0.04584117f, -0.12207422f, 0.20317598f, 0.18630227f, -0.03968268f, -0.10920331f, -0.12966578f, 
    -0.07865439f, 0.04788540f, 0.13434047f, -0.00923935f, -0.08242930f, 0.01546821f, -0.01401256f, 0.06347527f, 
    0.44851631f, -0.42944312f, 0.10287148f, 0.20015725f, -0.18344893f, -0.07280551f, 0.10856472f, 0.05815047f, 
    -0.04270880f, 0.05277460f, 0.15476938f, 0.06387497f, -0.11133805f, 0.09447700f, 0.02399736f, -0.06333604f, 
    0.07388771f, 0.08130253f, 0.02202372f, 0.13402867f, -0.07173696f, 0.13994873f, 0.04774913f, 0.02606752f, 
    0.01632803f, -0.06846104f, -0.17616640f, -0.57913059f, 0.21705356f, 0.13984631f, 0.03355540f, 0.14396292f, 
    0.07110135f, 0.01059053f, 0.13518240f, 0.20881665f, -0.10623157f, -0.12636930f, 0.11266863f, 0.27193770f, 
    0.10206177f, 0.05240933f, 0.01177068f, 0.09818941f, 0.05464377f, -0.09218675f, 0.01460426f, -0.10713867f, 
    -0.06571377f, 0.25186455f, -0.03175165f, -0.29853323f, 0.14820161f, 0.16710357f, 0.05214540f, -0.12184226f, 
    0.27566788f, -0.03657220f, 0.11098271f, 0.06104207f, 0.06049242f, 0.07944836f, 0.30213019f, 0.05608318f, 
    -0.04441013f, 0.17233193f, 0.21227123f, 0.15020539f, -0.06336875f, -0.16893876f, 0.08047767f, -0.11209791f, 
    -0.35258582f, -0.08648828f, -0.28722826f, 0.14384456f, -0.05970354f, -0.03834469f, 0.00177782f, 0.10693727f, 
    -0.05353896f, 0.07753015f, -0.04552522f, 0.08710058f, 0.14911202f, -0.08897346f, -0.02371001f, 0.14596669f, 
    0.06795764f, -0.10080093f, 0.07627159f, 0.15434676f, 0.03469073f, 0.00477869f, -0.09265893f, 0.19051056f, 
    -0.07191408f, 0.21488117f, -0.31969059f, 0.16648704f, -0.06537537f, -0.05189418f, 0.06746088f, -0.11822208f, 
    0.07409488f, -0.00048809f, 0.00356334f, 0.04407362f, 0.12805682f, 0.13066992f, 0.02698291f, 0.20528747f, 
    -0.14329608f, 0.06771844f, 0.02584213f, -0.09018923f, -0.07011580f, 0.00298279f, 0.14007108f, 0.02037645f, 
    -0.08537570f, 0.11030553f, -0.02278961f, -0.04227106f, 0.14415029f, 0.14985557f, 0.13181826f, 0.25665277f, 
    -0.20658131f, 0.00663107f, 0.02103235f, -0.03235788f, -0.24878223f, 0.24576220f, -0.01481720f, 0.26693678f, 
    -0.01958946f, -0.05812261f, -0.02258434f, 0.08081723f, 0.06518677f, -0.03975085f, 0.02084126f, -0.06636405f, 
    0.15401912f, 0.10855604f, -0.08735299f, 0.12076361f, 0.01694808f, 0.05035116f, 0.07854320f, 0.06937969f, 
    -0.11547026f, -0.02338319f, -0.04809820f, -0.03424472f, -0.10052513f, 0.12503871f, -0.13590173f, 0.26058817f, 
    -0.01132597f, -0.00479096f, 0.13256848f, 0.04714462f, -0.06150414f, -0.02377478f, 0.08670924f, 0.01592403f, 
    0.02029286f, 0.26696995f, 0.04194497f, 0.00741471f, 0.10959647f, 0.11311531f, 0.03290452f, -0.06954687f, 
    0.00286702f, 0.10448675f, 0.06686151f, 0.03383218f, 0.10667427f, -0.06450063f, 0.19660692f, -0.00348142f, 
    -0.05405720f, -0.13152826f, 0.03751269f, -0.06120716f, 0.26452947f, -0.16191109f, 0.00418640f, 0.03793020f, 
    0.14468099f, 0.19927981f, 0.04618710f, -0.12629648f, -0.10913432f, -0.13332671f, -0.02762844f, 0.17766784f, 
    -0.03318636f, -0.13902600f, -0.04371796f, 0.04999974f, -0.43168005f, 0.49578229f, 0.18458043f, -0.03608538f, 
    0.20615011f, 0.03345320f, 0.10863928f, -0.09824210f, 0.00535287f, -0.01119031f, 0.08318921f, 0.01764801f, 
    0.57633597f, 0.13555966f, -0.03227087f, -0.02131826f, -0.03244874f, -0.09957071f, 0.03831437f, 0.01035610f, 
    0.02928406f, -0.12740050f, 0.09516338f, -0.24582441f, 0.36054149f, -0.06268568f, -0.01081703f, -0.09994343f, 
    0.07598381f, 0.01592637f, -0.16910578f, 0.02213764f, 0.05597100f, 0.08267292f, 0.09491163f, -0.05532202f, 
    0.04258538f, -0.01756305f, 0.04108828f, -0.01558805f, -0.09945519f, 0.05539398f, -0.00294115f, -0.07018685f, 
    -0.08022758f, 0.00615500f, -0.04799471f, 0.09470820f, -0.24281810f, 0.13262095f, -0.00475577f, 0.17863362f, 
    -0.15817843f, 0.00459505f, -0.03046694f, 0.03978652f, 0.07778143f, -0.06957950f, 0.02515510f, -0.17140783f, 
    0.43954182f, 0.06600080f, -0.04035738f, 0.04557440f, -0.13210884f, -0.02822203f, 0.05124477f, -0.09126204f, 
    -0.14265044f, -0.07139712f, 0.05969620f, 0.05223603f, -0.51020753f, 0.24712756f, -0.03306475f, 0.23141871f, 
    -0.20612933f, 0.10233457f, 0.00645007f, -0.03603480f, 0.03702926f, 0.16336586f, 0.03261110f, -0.05649172f, 
    0.18769622f, 0.18631563f, -0.04803710f, 0.07049796f, 0.06058024f, -0.02120162f, 0.08096363f, 0.34206378f, 
    -0.12113645f, 0.01417944f, 0.01928439f, 0.00438619f, 0.10329624f, -0.45700881f, -0.08930025f, 0.19883288f, 
    0.00107386f, 0.01982992f, -0.03646452f, 0.00953487f, 0.10738348f, 0.03926270f, -0.14445032f, 0.02782247f, 
    0.02929148f, 0.11198966f, -0.08634889f, 0.05179828f, -0.05656891f, 0.05191293f, 0.02581479f, -0.09856947f, 
    0.10170015f, 0.07807210f, 0.00064328f, 0.15632121f, -0.09395376f, -0.09449974f, -0.02618714f, 0.11057734f, 
    -0.09000317f, 0.21994025f, -0.13526925f, 0.01175563f, 0.04065163f, -0.01857626f, -0.12428480f, 0.17620192f, 
    0.06489482f, 0.25275442f, -0.11841335f, -0.17349753f, -0.10213387f, -0.12551434f, 0.02987998f, -0.03839096f, 
    0.13391462f, 0.02086509f, -0.01615397f, 0.09047953f, 0.01791839f, -0.17291529f, -0.21112087f, 0.00902042f, 
    -0.04977635f, -0.06898019f, 0.14557810f, -0.05969117f, -0.06285135f, -0.09009674f, 0.03703468f, 0.05656931f, 
    0.23388334f, -0.33681238f, 0.05170782f, 0.27908668f, 0.06312776f, -0.11135512f, -0.06239660f, -0.02185571f, 
    0.05088800f, 0.22629818f, -0.02272785f, -0.02676636f, 0.02859763f, 0.12279294f, -0.05488780f, 0.14292794f, 
    0.15977797f, -0.01497903f, 0.08302340f, 0.17715377f, 0.03151658f, -0.05842303f, -0.12363470f, 0.06992859f, 
    0.18070666f, -0.36766407f, -0.04617439f, 0.22117405f, -0.06813013f, 0.00131513f, 0.04731988f, -0.03205558f, 
    -0.04960135f, 0.07446032f, 0.08116391f, 0.11455619f, 0.08934232f, 0.14140496f, -0.23152748f, 0.00372859f, 
    0.02294767f, 0.13057941f, -0.09405395f, 0.02264570f, 0.02407888f, 0.09157670f, 0.00272688f, 0.04425002f, 
    0.17270200f, -0.06889567f, 0.21215440f, 0.15508585f, 0.06631826f, -0.05706018f, 0.02415515f, 0.06507558f, 
    0.00946371f, 0.07016176f, -0.09681097f, -0.09819330f, 0.13038471f, -0.18099177f, 0.10045524f, 0.09583112f, 
    -0.01365277f, -0.02994512f, 0.25524876f, 0.05624069f, 0.06540743f, 0.04677814f, -0.00557024f, 0.06095731f, 
    -0.11260002f, -0.07492635f, 0.10861426f, -0.04076955f, 0.01710967f, 0.16209610f, -0.09815442f, 0.04582305f, 
    0.05353865f, 0.04351194f, -0.06328326f, 0.14297540f, -0.26982072f, 0.07064538f, -0.14473757f, -0.09762517f, 
    -0.15913239f, -0.08301564f, -0.00187678f, 0.07856174f, 0.05080884f, -0.00252780f, 0.12705699f, -0.06921250f, 
    -0.36709005f, 0.12595735f, 0.05826310f, 0.17597093f, 0.00095893f, 0.06127286f, 0.09825605f, -0.15496697f, 
    -0.03592375f, 0.01273598f, 0.10709015f, -0.00228734f, 0.22768162f, 0.22940911f, 0.01762911f, -0.14280476f, 
    -0.01004731f, 0.03704643f, 0.03855150f, -0.10375345f, 0.04625492f, 0.02198379f, -0.12047002f, 0.02912380f, 
    0.07288501f, -0.03806066f, 0.06171612f, 0.14175673f, 0.21736987f, 0.06257600f, -0.03960957f, 0.14204641f, 
    0.06208018f, 0.01021066f, -0.07168756f, 0.06077580f, -0.14969110f, -0.01865311f, -0.31867626f, 0.22787333f, 
    0.14252807f, -0.00007653f, 0.05099641f, 0.07523765f, -0.00787258f, 0.01901102f, -0.06301978f, -0.09862138f, 
    0.09096154f, 0.07234418f, 0.02526022f, -0.03613530f, -0.18431173f, 0.03804637f, -0.08675326f, -0.03960989f, 
    0.05034170f, 0.07405111f, -0.04825577f, 0.26627612f, 0.17458460f, 0.04788781f, -0.15825160f, 0.01475381f, 
    0.13588560f, 0.01746769f, -0.02908931f, -0.10080145f, 0.10284999f, 0.09478789f, -0.02549198f, 0.07675529f, 
    0.53060079f, 0.14548878f, 0.29314163f, -0.26085237f, -0.07609847f, 0.13101137f, -0.09024394f, -0.07052784f, 
    0.11897579f, 0.02221153f, 0.13091779f, 0.00954734f, -0.06166121f, -0.15445207f, -0.03192954f, 0.05663125f, 
    -0.04699057f, -0.19068027f, -0.15413108f, -0.02364782f, 0.13910896f, -0.03369078f, -0.13898256f, -0.00553818f, 
    -0.06428879f, -0.05095110f, -0.04028008f, 0.07976183f, 0.24028826f, -0.08989920f, 0.13077140f, 0.03215262f, 
    0.03002089f, 0.10866146f, 0.13005508f, 0.11720316f, -0.22660388f, 0.00223504f, 0.17616712f, 0.12691329f, 
    0.14223780f, 0.09011671f, -0.06425160f, 0.04508348f, 0.01346697f, -0.10804146f, 0.09136851f, 0.01053724f, 
    0.09692355f, -0.01748326f, -0.05970282f, -0.09354208f, 0.20321134f, 0.13883278f, -0.07422005f, 0.05707910f, 
    0.07747418f, -0.10499926f, -0.14419705f, -0.01535998f, -0.20235337f, 0.29708090f, -0.20443276f, 0.06156491f, 
    -0.00360742f, -0.03539396f, -0.03961513f, -0.05823786f, -0.01851745f, 0.03117752f, -0.05174117f, 0.01414431f, 
    -0.01829117f, -0.01141677f, 0.00098436f, 0.04505344f, 0.05067115f, 0.01722825f, 0.00512549f, -0.05967551f, 
    -0.00813435f, -0.05356480f, -0.02828244f, -0.04274367f, -0.00185146f, 0.05871988f, 0.04313912f, 0.04809134f, 
    -0.06707096f, 0.02295941f, 0.05763791f, -0.06030363f, -0.01417267f, 0.02737830f, -0.04349687f, -0.01915921f, 
    -0.03484525f, -0.04398563f, 0.05350013f, -0.03285385f, -0.05896590f, -0.04740769f, 0.01402439f, 0.04434970f, 
    0.04255211f, 0.06150429f, 0.01396778f, -0.05716913f, -0.06598981f, 0.01582570f, 0.02049220f, 0.01050809f, 
    -0.05470033f, 0.03026846f, -0.04462059f, -0.03231041f, -0.05300105f, -0.03718043f, -0.02413599f, 0.04994398f, 
    -0.00753626f, 0.05313931f, -0.03550451f, -0.03137721f, -0.00206528f, 0.00957979f, -0.03312383f, 0.05039775f, 
    -0.07318807f, -0.00523612f, -0.07440072f, 0.00933837f, 0.06018854f, -0.00911259f, -0.02981649f, 0.05829279f, 
    -0.05760786f, 0.03103989f, 0.05198989f, -0.07052304f, 0.01084624f, 0.00709365f, 0.00177513f, -0.05526239f, 
    -0.01082463f, -0.01795834f, -0.06889161f, -0.01053356f, -0.02407023f, 0.00034524f, 0.03112302f, -0.01357592f, 
    -0.05386238f, -0.01368292f, -0.03417556f, 0.05300130f, 0.04158776f, -0.03332034f, -0.02064268f, -0.06645309f, 
    -0.04376943f, 0.03971390f, -0.04362179f, -0.00435757f, 0.03001104f, 0.02460326f, -0.03272450f, 0.04404816f, 
    -0.00200696f, 0.04599479f, -0.01579137f, 0.05281724f, -0.04089718f, 0.03036330f, -0.03766529f, 0.02240142f, 
    0.04102499f, -0.04213070f, 0.05880470f, 0.01652921f, -0.00950057f, -0.00917990f, 0.03845308f, 0.00862811f, 
    -0.03920533f, 0.06132344f, -0.03123215f, -0.00518794f, -0.03100430f, -0.04427705f, -0.02325355f, -0.01155862f, 
    0.04323617f, 0.03471350f, -0.06223590f, -0.04097409f, -0.00730113f, -0.05884372f, 0.01655627f, 0.02147705f, 
    0.01344762f, -0.01095760f, 0.02871882f, -0.04083364f, -0.05936444f, 0.00748426f, -0.00734275f, -0.04260606f, 
    0.02348975f, 0.03045681f, 0.03104398f, 0.03261852f, -0.01934628f, -0.04425079f, 0.03535824f, -0.05384935f, 
    -0.06225568f, -0.00431701f, -0.04374640f, 0.04375929f, -0.05630716f, -0.05718323f, -0.02089214f, 0.02848897f, 
    -0.07334855f, 0.00678044f, 0.04957155f, -0.00692888f, 0.04636556f, -0.03616767f, 0.03927098f, -0.03624989f, 
    -0.06669897f, 0.01131977f, -0.02107657f, -0.03829911f, 0.00738249f, -0.04494630f, -0.04244462f, 0.05495409f, 
    -0.05621370f, 0.05482727f, -0.03385037f, -0.04403773f, -0.01155263f, -0.05530470f, -0.02572720f, 0.03072629f, 
    -0.06416747f, 0.02151949f, -0.03758413f, -0.07027141f, 0.02942690f, -0.02885027f, -0.04615365f, 0.02937067f, 
    0.05383235f, -0.00140050f, 0.01952204f, 0.05442471f, -0.02657064f, -0.00135809f, -0.02425672f, -0.06015003f, 
    -0.01904999f, 0.00627617f, -0.07270485f, 0.06287867f, 0.05748970f, 0.06337300f, 0.05365758f, 0.01009061f, 
    -0.04863811f, 0.03085169f, 0.03432041f, -0.03080935f, -0.00779619f, 0.04585496f, -0.02932823f, -0.05733769f, 
    -0.05952628f, -0.01699948f, 0.04483156f, -0.06723279f, -0.01232147f, 0.01249881f, 0.03797100f, -0.05976992f, 
    0.00831903f, 0.01675926f, -0.06771038f, -0.00599660f, 0.04592180f, 0.03937545f, 0.03424453f, -0.00126253f, 
    0.03764376f, -0.07786070f, 0.03397904f, -0.01346729f, 0.02355431f, 0.01529875f, 0.00034460f, 0.00118286f, 
    -0.04901455f, -0.00569491f, 0.02670669f, -0.01833796f, -0.07709851f, 0.03032423f, -0.00628436f, -0.01528241f, 
    -0.07517892f, 0.04924929f, 0.02545565f, 0.03938663f, -0.03557173f, 0.01994109f, 0.01875123f, -0.03472967f, 
    0.02730232f, 0.03178670f, -0.02711938f, -0.00539208f, 0.00136352f, -0.00339214f, -0.05008778f, 0.02841225f, 
    -0.02472276f, 0.04574351f, -0.06450012f, 0.00612153f, 0.02104724f, -0.00209846f, 0.02800604f, 0.06501160f, 
    -0.04608646f, -0.02158633f, -0.03667488f, -0.07261881f, 0.05623113f, -0.02495652f, -0.05907666f, 0.01110779f, 
    -0.01794672f, 0.06189212f, 0.05669322f, -0.02069298f, 0.06232614f, -0.05167085f, 0.05480495f, -0.02845265f, 
    -0.07322242f, -0.03098700f, 0.01042970f, -0.04224096f, -0.05381156f, -0.04232624f, 0.05233887f, -0.06722318f, 
    0.02851892f, -0.01644049f, -0.03140274f, -0.07045186f, 0.05968639f, -0.00669547f, 0.03776375f, -0.07781772f, 
    0.02774026f, -0.00565198f, -0.02795735f, -0.02267645f, -0.04873106f, -0.07285713f, 0.01791060f, 0.04784479f, 
    -0.05439370f, -0.02510098f, 0.06034885f, -0.07053864f, 0.03772831f, 0.04745496f, -0.07214917f, 0.00529134f, 
    0.01751397f, -0.00223870f, -0.01947328f, 0.02974618f, 0.03569472f, 0.05627871f, -0.06824446f, 0.00565761f, 
    -0.03949897f, 0.05991584f, -0.01303746f, -0.02317526f, -0.01092104f, -0.06744843f, -0.06006705f, -0.03657373f, 
    0.04665305f, -0.00945848f, 0.01443213f, -0.06100249f, 0.03346262f, -0.07575788f, 0.01310073f, -0.02406867f, 
    -0.05419049f, -0.04980692f, 0.05251513f, 0.05620389f, -0.02392221f, -0.04195771f, 0.01419401f, 0.04446509f, 
    -0.07049084f, -0.06331782f, -0.07912617f, -0.04407963f, -0.01275253f, -0.07139613f, -0.03851142f, -0.06022448f, 
    0.02919501f, -0.01069338f, 0.01776826f, 0.00153524f, -0.02142815f, -0.07761329f, -0.02659101f, 0.05402978f, 
    -0.00082854f, 0.05456789f, -0.06222252f, -0.02299581f, -0.04466557f, -0.06835000f, -0.01503929f, 0.01184340f, 
    -0.06365318f, -0.00735854f, -0.03051894f, 0.05438703f, 0.01308323f, -0.02553079f, 0.03205089f, 0.02409648f, 
    0.03541643f, -0.05538220f, 0.06239923f, -0.01381977f, -0.07434944f, -0.04901584f, -0.05697982f, -0.00523539f, 
    0.02603337f, -0.01977873f, -0.06390482f, 0.00519153f, 0.00286574f, -0.04970809f, 0.06572892f, -0.06964152f, 
    -0.02348446f, -0.01525459f, -0.03716918f, -0.00386920f, -0.02949802f, 0.00047044f, 0.02253575f, -0.01491023f, 
    0.03331551f, 0.01053950f, -0.01190302f, 0.05686381f, -0.02784779f, -0.03285208f, -0.00783449f, -0.08235066f, 
    0.03330851f, -0.01314142f, -0.02663604f, 0.05844124f, -0.07466475f, -0.07458349f, 0.02095972f, -0.01158559f, 
    -0.07318925f, 0.01288017f, -0.04707560f, -0.00812124f, 0.04688008f, 0.00646503f, -0.04306668f, 0.00280217f, 
    0.05302533f, 0.03050517f, 0.02759940f, 0.04163266f, -0.00947609f, 0.05912178f, 0.01782500f, 0.01907339f, 
    -0.02093200f, -0.02557716f, 0.00694345f, 0.00293446f, 0.01216864f, -0.02107464f, -0.03443693f, 0.00305806f, 
    -0.03647725f, 0.05218917f, 0.00396321f, -0.05518619f, -0.01416680f, 0.06122391f, 0.05825901f, -0.04742104f, 
    -0.04937468f, -0.06279621f, -0.07165869f, -0.04251606f, -0.04308080f, 0.04720773f, -0.04940842f, 0.05647061f, 
    0.06107326f, 0.05847818f, 0.01588358f, -0.02011158f, -0.07585268f, -0.02105753f, 0.00766664f, 0.00906798f, 
    0.00298373f, -0.02263427f, 0.01367202f, -0.04425475f, -0.07340418f, -0.04491531f, -0.02631013f, -0.00848946f, 
    0.03558682f, 0.03232935f, 0.03447049f, 0.00381167f, -0.01596991f, 0.04864852f, -0.06855672f, 0.00372926f, 
    0.05479749f, -0.04703160f, 0.05903948f, -0.01087070f, -0.07064167f, 0.00049385f, -0.04525287f, -0.07065462f, 
    -0.00808719f, -0.06020634f, -0.02706037f, 0.01245683f, -0.05770956f, -0.04605667f, 0.01388538f, -0.02864994f, 
    0.01574671f, 0.00913833f, -0.04280579f, 0.04036199f, -0.05728563f, -0.07181589f, 0.01391621f, 0.05015908f, 
    -0.04653422f, -0.06854282f, -0.03294461f, -0.01122520f, 0.03195327f, 0.05422906f, 0.00310281f, -0.00926733f, 
    0.00564027f, -0.02347425f, -0.05430324f, -0.07711820f, 0.04608322f, 0.01743829f, 0.04775197f, 0.02004066f, 
    -0.05751386f, -0.05220478f, -0.04361675f, -0.00735856f, -0.07019489f, 0.03132148f, 0.06372784f, -0.04761970f, 
    0.01701494f, -0.03831919f, -0.06437046f, 0.02279761f, 0.00226387f, -0.07200813f, -0.07342489f, -0.04094240f, 
    0.01780791f, -0.01897873f, -0.02537686f, 0.00185988f, -0.04843837f, 0.00780905f, -0.07273475f, 0.02611612f, 
    0.06078838f, 0.01313053f, -0.06835285f, 0.00565056f, 0.03788288f, 0.03847885f, -0.07572725f, 0.05315044f, 
    -0.01752189f, -0.03696174f, 0.04220750f, 0.05477002f, -0.02106400f, -0.02598020f, -0.06361008f, 0.04606324f, 
    0.01750909f, 0.02779695f, -0.02137644f, 0.01722831f, -0.01769536f, -0.05028886f, -0.02153710f, 0.04412342f, 
    -0.03489755f, -0.07551091f, -0.01343656f, 0.01749625f, -0.02035648f, 0.03319890f, 0.04451860f, -0.04826541f, 
    -0.06525031f, 0.12268117f, 0.07517862f, -0.05712277f, 0.07025712f, 0.02515706f, 0.12230217f, 0.01645971f, 
    -0.07840950f, 0.18754496f, 0.05063400f, 0.35871375f, -0.07768606f, -0.15747441f, 0.15423226f, 0.11585392f, 
    -0.10428044f, 0.20042875f, 0.06865612f, 0.00386358f, 0.09603754f, -0.07620061f, 0.16192728f, -0.16158773f, 
    0.52333045f, 0.29414392f, 0.11020402f, -0.03906780f, 0.14209582f, 0.07533225f, -0.05659897f, -0.06804761f, 
    0.14348221f, -0.00061323f, 0.14237516f, 0.06959344f, -0.13384357f, -0.03527188f, 0.20035399f, -0.03917195f, 
    0.01241069f, 0.08681190f, -0.02617511f, -0.13209234f, -0.08034467f, -0.19965822f, 0.17058913f, 0.02026125f, 
    0.01745129f, 0.03464728f, 0.14293171f, 0.02768300f, -0.03383170f, 0.01550983f, 0.01814312f, -0.00471607f, 
    -0.00841563f, 0.02738658f, -0.17559709f, 0.04378820f, 0.33364224f, 0.19971076f, -0.13873431f, -0.05783094f, 
    0.11533765f, 0.09429982f, -0.10383362f, 0.02015954f, -0.03481788f, -0.07223269f, -0.06982575f, 0.05478997f, 
    -0.06447908f, 0.04635072f, -0.16893706f, 0.00567907f, -0.05083895f, 0.07250078f, -0.18211116f, 0.02684478f, 
    -0.10026101f, 0.05430208f, -0.16056181f, -0.24123888f, 0.25088340f, 0.02131513f, 0.07601191f, 0.14859784f, 
    -0.13360387f, 0.14384544f, 0.05731265f, 0.10724087f, -0.03254906f, 0.02215530f, -0.08258654f, 0.13988182f, 
    -0.14089434f, 0.21007615f, 0.20410477f, -0.09064283f, 0.10300232f, -0.07041015f, -0.02415088f, 0.11647313f, 
    -0.07777990f, -0.15863256f, -0.07106009f, -0.31498182f, -0.40701795f, 0.04472945f, 0.15404929f, 0.05437772f, 
    -0.01758252f, 0.18291199f, 0.02152460f, -0.01162067f, -0.18605642f, 0.10881545f, -0.02731372f, -0.10042117f, 
    -0.24173146f, 0.11811837f, -0.00322047f, 0.08919261f, -0.09591228f, -0.03158438f, 0.15847431f, -0.02997649f, 
    -0.04398084f, 0.03184628f, 0.07792986f, -0.11425550f, 0.18554370f, 0.20477198f, 0.04319191f, 0.05519956f, 
    0.01246851f, 0.19183002f, 0.10092290f, 0.00457159f, -0.08487985f, 0.05099820f, 0.09507665f, 0.06398223f, 
    0.11169823f, 0.15042211f, 0.06186056f, -0.01297035f, -0.18609568f, 0.15163046f, 0.00794615f, 0.00470788f, 
    0.02172182f, -0.19718327f, 0.01070747f, -0.19489929f, 0.35919321f, 0.15350309f, -0.12278339f, 0.01047750f, 
    -0.00445830f, -0.10812681f, -0.04823360f, -0.00378723f, -0.02582161f, -0.13316925f, 0.04751964f, -0.05771766f, 
    -0.12649567f, 0.32215300f, 0.02464689f, -0.09298345f, -0.03979047f, -0.13197535f, -0.01776190f, 0.18849510f, 
    -0.11216938f, 0.08278842f, 0.01426829f, 0.09545328f, -0.25151882f, -0.23913205f, 0.00601817f, -0.02567138f, 
    -0.04986609f, -0.03053312f, 0.09091922f, 0.08814276f, 0.02905311f, -0.01747794f, 0.15113103f, 0.12592462f, 
    0.38155520f, 0.20814246f, -0.00151363f, -0.10714730f, 0.09937576f, 0.13229884f, 0.08164626f, 0.03003136f, 
    0.08984537f, -0.11799607f, 0.11943792f, -0.12063708f, -0.19997402f, -0.02643984f, 0.00567067f, -0.03189432f, 
    -0.09501240f, -0.11771483f, -0.12892859f, 0.03983189f, -0.02351632f, 0.02375038f, 0.07257247f, -0.08358420f, 
    0.05814208f, -0.01784066f, 0.06439681f, -0.11829689f, -0.01529215f, -0.03511639f, 0.00391740f, -0.13383968f, 
    -0.02758850f, -0.07531596f, 0.02820885f, 0.08297587f, -0.13432491f, -0.19979863f, 0.16920467f, 0.18817534f, 
    0.06041104f, 0.02337116f, 0.03450882f, -0.02997699f, -0.10937748f, 0.04024083f, -0.13518104f, -0.12554222f, 
    0.44023970f, 0.10509796f, 0.24023324f, 0.01509115f, -0.03495362f, -0.18255043f, 0.00459002f, 0.01749245f, 
    0.00769613f, -0.06946742f, 0.14245535f, 0.13841113f, -0.48722106f, 0.20102979f, 0.09852052f, 0.15672287f, 
    -0.08603776f, 0.07387907f, 0.06028586f, 0.01521930f, 0.08611405f, 0.04367010f, -0.08224304f, -0.04323968f, 
    -0.12393774f, -0.11122964f, -0.07642215f, 0.04445041f, -0.13994323f, 0.09722135f, -0.00485518f, 0.05609188f, 
    -0.05922619f, -0.17988621f, 0.01476785f, 0.08859112f, 0.48253995f, -0.14210922f, 0.09239990f, 0.30017602f, 
    0.03153927f, 0.01410983f, -0.16675597f, 0.03087272f, 0.12671191f, 0.06680416f, -0.02299907f, 0.02053383f, 
    0.06976425f, -0.05389070f, -0.11071071f, 0.16421907f, 0.01646691f, 0.05569800f, -0.06259499f, 0.04310129f, 
    0.07130858f, -0.04490188f, -0.10213693f, 0.05790334f, 0.30433106f, -0.11620061f, -0.15919136f, 0.11248382f, 
    -0.15605427f, -0.04027065f, -0.16178924f, 0.10053461f, -0.00767287f, -0.04490426f, -0.09612896f, -0.00758155f, 
    0.25036204f, 0.19150446f, -0.29167041f, -0.06365256f, -0.01820363f, -0.08332058f, 0.04381058f, 0.14253806f, 
    0.07842616f, -0.07448986f, 0.07764513f, 0.03016527f, 0.31937042f, -0.12303672f, -0.42907596f, 0.20975703f, 
    0.01403577f, -0.00985594f, 0.19414417f, -0.16034816f, 0.03787727f, -0.00266012f, -0.07739735f, -0.13555914f, 
    0.26431429f, -0.23355827f, 0.30894750f, 0.40344241f, 0.02692148f, 0.00692004f, -0.07712060f, -0.09243116f, 
    0.09697486f, 0.10133076f, -0.16682179f, 0.00505562f, 0.01215131f, -0.13867870f, 0.14392275f, 0.00319408f, 
    0.14125825f, -0.04456052f, 0.06615775f, -0.13092288f, 0.10241859f, 0.02252150f, -0.05225715f, 0.08285820f, 
    0.65281594f, -0.22360754f, 0.19267569f, 0.45484403f, 0.01414821f, 0.00168192f, -0.05909235f, -0.02181429f, 
    -0.10039264f, 0.08338533f, 0.10228570f, 0.00887286f, 0.06638666f, 0.08663327f, 0.15945868f, 0.09351809f, 
    -0.01297800f, 0.26995656f, 0.01317626f, -0.01425685f, 0.02051721f, 0.17254575f, 0.03109952f, 0.02329725f, 
    0.22673199f, -0.22126564f, -0.10250068f, -0.14104052f, 0.07237450f, -0.07161940f, -0.04458348f, 0.00970483f, 
    0.07151365f, -0.00259868f, -0.04779924f, -0.05502128f, 0.05988930f, 0.09248538f, 0.01615454f, -0.22833538f, 
    0.00641684f, -0.03150070f, -0.20586076f, 0.05412731f, 0.02491627f, 0.03250251f, -0.02171940f, -0.06071644f, 
    0.09547735f, -0.27467951f, -0.01743991f, 0.06302064f, -0.12680845f, 0.00957039f, -0.08573056f, -0.03242904f, 
    0.01590793f, 0.05309226f, -0.13865957f, -0.08494845f, -0.16225751f, -0.21395387f, -0.37199455f, -0.00193695f, 
    -0.11317930f, 0.02871862f, -0.07662997f, 0.08084366f, -0.03426545f, 0.12276703f, -0.01939997f, -0.02400029f, 
    0.53814423f, -0.03621780f, -0.02068133f, 0.04484627f, -0.13403144f, 0.04742942f, -0.00947022f, -0.00796591f, 
    -0.00961825f, 0.08778352f, 0.14201543f, 0.01421819f, -0.35573065f, 0.14608765f, 0.02514303f, -0.00971075f, 
    -0.08994547f, -0.01598215f, 0.12560840f, 0.01465818f, 0.08062440f, 0.10343028f, 0.20549004f, 0.07016252f, 
    0.12176067f, -0.17782347f, 0.15456827f, -0.00641901f, -0.01656847f, 0.03272818f, -0.00310472f, 0.19088915f, 
    -0.08357813f, -0.14234094f, 0.04626343f, 0.11705334f, -0.08348643f, 0.02744138f, -0.08291483f, -0.05158675f, 
    0.11972333f, -0.06540156f, 0.06918977f, -0.02105750f, 0.06932019f, 0.02315865f, -0.13066888f, 0.05322136f, 
    0.30677065f, 0.00026065f, -0.23375440f, -0.16553988f, 0.05125846f, 0.04718411f, 0.05275260f, -0.05059317f, 
    0.04323665f, -0.08171499f, -0.00543421f, 0.20777659f, 0.41633013f, 0.21777387f, 0.07720222f, 0.07867555f, 
    0.07602841f, 0.03895235f, -0.00571487f, 0.06766182f, 0.04009125f, 0.02827710f, 0.00118599f, 0.17960520f, 
    0.31338108f, 0.21667910f, 0.01196400f, -0.10068566f, 0.08060230f, 0.07633243f, 0.04585641f, 0.09587716f, 
    0.02958837f, 0.04210584f, -0.01678405f, 0.02299047f, -0.07526369f, -0.04921304f, -0.04479292f, -0.24361655f, 
    0.04991434f, -0.06779926f, -0.03774989f, -0.02790680f, -0.01492304f, -0.07617673f, 0.03650552f, -0.04232538f, 
    0.08892785f, -0.06003433f, 0.10063991f, -0.15450840f, 0.03024189f, -0.13811366f, 0.01126658f, -0.04250579f, 
    0.07910918f, 0.09456041f, -0.00972665f, -0.00266393f, -0.36774713f, -0.23528957f, 0.11512450f, 0.16078980f, 
    -0.07055248f, 0.00875158f, 0.12800552f, 0.06354059f, 0.08515292f, 0.11751033f, -0.08935940f, 0.18277633f, 
    0.05060925f, -0.11873049f, 0.05040270f, 0.13168854f, 0.11304107f, 0.17548203f, 0.07015701f, -0.13642067f, 
    0.02290867f, 0.10366097f, 0.13628605f, 0.05797406f, 0.61391991f, -0.18163861f, -0.03991324f, 0.08993857f, 
    0.07856497f, -0.00590210f, -0.10087216f, 0.00271335f, 0.02767060f, 0.13360538f, 0.07859091f, 0.09994912f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01441320f, 0.02852936f, -0.08111262f, 0.09724211f, 0.10121872f, 0.02507188f, -0.04221862f, 0.07461785f, 
    0.03166701f, -0.00331678f, 0.01152228f, -0.05875266f, 0.02931391f, 0.04524626f, -0.01051806f, 0.09384719f, 
    0.01367094f, -0.08001382f, 0.00331463f, -0.01470096f, 0.01279076f, 0.03319287f, -0.00100976f, -0.04818567f, 
    0.00984159f, -0.05735131f, -0.05794960f, -0.01588822f, -0.06335469f, 0.16099794f, -0.03514623f, 0.05592537f, 
    0.01512667f, -0.01618285f, 0.06286545f, 0.04893341f, 0.13856186f, 0.07692975f, -0.09844243f, -0.00153271f, 
    0.01243821f, 0.03072422f, 0.11668854f, 0.02138678f, 0.00627305f, -0.00168479f, 0.07511374f, 0.01666683f, 
    -0.01462864f, -0.03861009f, 0.00275348f, -0.02007988f, 0.20401636f, 0.09432404f, 0.10385258f, 0.05529643f, 
    -0.01301542f, -0.05194413f, 0.05462913f, -0.02839690f, 0.04933544f, -0.02709147f, -0.09912606f, 0.13178693f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00940808f, -0.30167660f, 0.44887188f, -0.42023206f, 0.15146323f, -0.02531435f, 0.07343534f, -0.46657425f, 
    0.25152585f, -0.47700703f, 0.00499872f, 0.00843586f, 0.14269453f, 0.05436515f, -0.11934063f, -0.15688404f, 
    -0.11836640f, -0.10366756f, 0.32479453f, 0.22543518f, -0.43873021f, -0.37261197f, -0.08697389f, 0.09439493f, 
    -0.20751840f, -0.29439670f, 0.01128607f, 0.01655381f, 0.03923236f, -0.80788946f, -0.10019855f, -0.03885984f, 
    -0.01993278f, 0.09175664f, 0.14745030f, 0.02211762f, -0.23306669f, -0.14050332f, 0.23146260f, 0.23883635f, 
    -0.55235910f, 0.13130651f, -0.35269636f, -0.24625540f, -0.34009179f, 0.01252919f, -0.01154203f, 0.19571729f, 
    -0.04528692f, -0.05387795f, -0.51329243f, 0.27433026f, -0.46012807f, -0.08352695f, -0.08293457f, 0.30923274f, 
    0.24291638f, 0.16885035f, 0.00992340f, -0.00937308f, 0.10148478f, 0.30000329f, 0.28817785f, -0.22055858f, 
    -0.02308638f, -0.41491991f, -0.65515149f, -0.72098053f, -0.08276498f, 0.17714742f, -0.04372641f, -0.12332927f, 
    0.05726944f, 0.27617487f, -0.01632117f, -0.20192552f, 0.05681142f, -0.06961671f, 0.07589882f, -0.02333838f, 
    -0.06248420f, 0.28331584f, -0.41949505f, 0.17833203f, 0.22847815f, 0.11223872f, -0.05324979f, -0.08327974f, 
    -0.39158866f, -0.37134573f, 0.06910363f, 0.03616198f, 0.00384098f, 0.35738444f, 0.08809024f, -0.04960859f, 
    0.07485374f, 0.06265634f, -0.08149662f, 0.00119919f, 0.05820873f, 0.28858531f, -0.13501368f, 0.13167886f, 
    -0.34844458f, 0.14311719f, 0.26024657f, 0.02105328f, -0.22596769f, -0.10624595f, -0.05661532f, -0.22038867f, 
    0.09257679f, 0.01296952f, -0.09998789f, -0.23399359f, -0.16557080f, 0.21783760f, 0.34052169f, -0.05348705f, 
    0.29022637f, -0.10286566f, 0.06350373f, -0.06699379f, -0.08704003f, -0.16857709f, 0.32556996f, 0.21568525f, 
    -0.12555137f, -0.04100040f, 0.49676883f, -0.31980845f, 0.10433099f, -0.03868685f, 0.08568954f, 0.13090689f, 
    -0.47540066f, -0.10244533f, 0.10510901f, 0.40066916f, 0.18909529f, 0.02764296f, 0.11276045f, 0.21324426f, 
    0.09317181f, 0.27213165f, -0.35258573f, 0.22640020f, 0.33449799f, -0.52694952f, 0.08325537f, -0.02004989f, 
    -0.53152853f, -0.01151794f, -0.44916779f, 0.07897430f, -0.10598007f, -0.38133022f, -0.03680110f, 0.01372689f, 
    0.11741946f, -0.02429081f, -0.04373280f, -0.08274025f, -0.42473209f, 0.09508970f, -0.12272343f, -0.34909123f, 
    0.25711143f, 0.07662091f, -0.53135777f, 0.41589561f, -0.08846030f, -0.11201150f, -0.22570507f, -0.21529326f, 
    0.00634875f, -0.10280896f, 0.21617456f, 0.13066943f, -0.11409596f, -0.62824404f, -0.13988511f, -0.28095984f, 
    0.06816833f, -0.13804594f, -0.10052853f, 0.06275286f, 0.03167371f, 0.07157669f, 0.18011427f, 0.20357276f, 
    -0.06938284f, 0.11040957f, 0.22747479f, 0.19210346f, 0.21828470f, -0.42780745f, 0.06947815f, 0.31650576f, 
    -0.04189963f, -0.48189256f, -0.12158187f, 0.04936868f, -0.30942428f, -0.02664128f, 0.10950565f, -0.66375428f, 
    0.11157521f, -0.04675039f, -0.52029967f, -0.08289389f, 0.15444624f, -0.24285050f, -0.06892156f, -0.08516698f, 
    0.01928072f, 0.27818349f, 0.03505801f, -0.03466517f, -0.09100265f, 0.26080662f, 0.03029087f, 0.07852660f, 
    -0.04789119f, 0.11501969f, 0.21658565f, 0.12540868f, -0.82858264f, -0.49383521f, -0.08270288f, 0.01908625f, 
    -0.07891653f, -0.42628959f, 0.34188262f, 0.10307071f, 0.17410427f, 0.01317620f, -0.47808337f, 0.18368648f, 
    -0.02000464f, -0.11821119f, -0.07900624f, 0.15858956f, -0.07652993f, 0.15987664f, 0.22099768f, 0.23521334f, 
    -0.06450178f, -0.28936705f, 0.11039213f, -0.05932629f, -0.04079339f, 0.02360308f, -0.00871087f, -0.31685218f, 
    0.04344601f, 0.48864809f, 0.10138370f, -0.22171363f, 0.11233332f, -0.65411997f, -0.00875097f, 0.05856238f, 
    -0.35687688f, 0.56050581f, -0.03541160f, -0.21131341f, -0.07675660f, -0.06885070f, -0.06705955f, 0.00922346f, 
    -0.09344729f, -0.12964813f, 0.03132161f, -0.03342540f, 0.27312404f, 0.24311730f, 0.06410208f, -0.00887987f, 
    0.12568796f, 0.10428507f, 0.14117971f, 0.03571139f, -0.03161383f, -0.53115523f, 0.10566756f, -0.01651668f, 
    0.04544936f, -0.02182987f, 0.11501076f, -0.01708505f, 0.08465222f, -0.39584371f, 0.22470647f, 0.14367394f, 
    -0.38044894f, -0.02203055f, 0.01810649f, -0.27896821f, 0.37918448f, 0.12602800f, 0.22033535f, -0.18387705f, 
    0.00842980f, 0.06155165f, -0.35751170f, -0.14315745f, -0.07679850f, 0.28860834f, 0.19950761f, -0.08567166f, 
    -0.35840312f, 0.14555427f, -0.00027733f, -0.11392566f, 0.08180444f, 0.15960188f, -0.28003982f, -0.47720674f, 
    0.01000054f, -0.09482911f, -0.56861067f, 0.22388020f, 0.21045960f, 0.38487104f, 0.10195696f, 0.06692468f, 
    0.02846191f, -0.27746111f, -0.04953191f, -0.26222342f, 0.28426063f, -0.10725800f, 0.08191948f, 0.20958966f, 
    -0.01408770f, -0.25117639f, -0.03046658f, -0.22540526f, -0.72866142f, 0.02751772f, 0.08338533f, 0.03615756f, 
    -0.02770079f, -0.50166923f, 0.10846563f, 0.06699528f, -0.08615720f, 0.23921466f, 0.03619213f, -0.02024325f, 
    -0.04038445f, 0.10138510f, 0.03541020f, -0.07816488f, 0.31055123f, -0.25808370f, 0.19919702f, 0.06968002f, 
    0.42771453f, -0.12103522f, 0.24058963f, 0.00792823f, -0.03411710f, 0.11468608f, -0.19171962f, -0.66854542f, 
    0.08272237f, 0.09858972f, -0.45699412f, 0.26713049f, -0.09226085f, 0.23401545f, 0.16448763f, 0.18773670f, 
    -0.38581276f, -0.08390413f, -0.07031047f, -0.03409776f, 0.10645079f, -0.26498657f, -0.06485912f, -0.11922136f, 
    -0.01991593f, -0.37712964f, -0.01385990f, 0.43522772f, -0.30709118f, 0.18373814f, -0.04019518f, -0.50978869f, 
    -0.15027329f, -0.96277362f, 0.08778058f, -0.14008044f, 0.03781043f, -0.05424638f, -0.12848189f, 0.27581081f, 
    -0.09463808f, 0.34633020f, -0.36436409f, 0.22607337f, -0.40304977f, -0.56181943f, 0.05150372f, 0.00038756f, 
    -0.03322274f, 0.12762235f, 0.06510428f, 0.11243609f, -0.04484179f, -0.00123673f, -0.00449499f, 0.06188940f, 
    0.07947917f, 0.11784952f, 0.20843729f, 0.00485611f, 0.00742737f, 0.12442515f, -0.11823258f, -0.03725278f, 
    -0.08921647f, 0.11938745f, -0.01771000f, -0.00615129f, -0.14927715f, -0.00978516f, 0.62038338f, 0.21129620f, 
    -0.03517505f, 0.10779706f, 0.47835246f, -0.64331084f, 0.16845885f, -0.06410901f, -0.03854957f, -0.08869005f, 
    -0.47022009f, -0.51875788f, 0.10674289f, 0.02650193f, -0.00405997f, 0.28940159f, -0.25628799f, 0.05039718f, 
    -0.07082845f, 0.00627590f, 0.17529358f, 0.03634750f, -0.70644683f, 0.14800888f, -0.05524829f, -0.08979728f, 
    0.12523289f, 0.07428111f, 0.04628554f, 0.06276444f, 0.10376553f, -0.13402301f, -0.11042612f, 0.05522657f, 
    -0.08972695f, 0.15877748f, 0.58685273f, -0.36681622f, 0.17517817f, 0.25917983f, -0.05760809f, -0.06494997f, 
    0.25869367f, 0.16679661f, 0.26356670f, 0.03365360f, 0.11869632f, 0.18835199f, 0.04005022f, -0.05430244f, 
    -0.08109394f, -0.07493436f, -0.72918844f, -0.09222683f, -0.26755312f, -0.03059709f, 0.06469315f, -0.29873022f, 
    0.04546297f, -0.43705443f, -0.04576378f, 0.08831279f, 0.22482301f, 0.07854266f, 0.16259857f, 0.19492081f, 
    -0.01907153f, 0.00036292f, 0.10574209f, 0.10012980f, -0.18329802f, 0.07015579f, -0.47029045f, -0.19147271f, 
    -0.00792543f, -0.19067292f, 0.10178006f, -0.11361676f, 0.02533493f, 0.19577079f, -0.01797545f, -0.22157104f, 
    0.08726132f, -0.38172355f, -0.36343783f, 0.17786463f, -0.31483588f, -0.45576075f, -0.03183970f, 0.27160138f, 
    0.31341931f, 0.38782060f, 0.03846583f, -0.32163590f, -0.21320537f, 0.07055427f, -0.07827678f, -0.16780542f, 
    0.07283723f, -0.02350589f, -0.14861913f, 0.14467892f, -0.15451208f, 0.41634735f, -0.06690849f, 0.08222563f, 
    0.00785698f, 0.26462132f, -0.28456461f, -0.12143078f, -0.08884205f, -0.26692656f, 0.05205050f, 0.00602199f, 
    0.08612800f, -0.05827680f, 0.16397357f, -0.06484205f, 0.02953706f, 0.20544311f, -0.32342485f, 0.17201601f, 
    0.34203550f, 0.03877632f, 0.00121822f, 0.10101236f, -0.34165549f, 0.07500868f, 0.40492222f, -0.10711467f, 
    0.05747110f, 0.06053833f, -0.16571094f, 0.06472848f, -0.62031460f, -0.12869810f, -0.20143546f, -0.44712931f, 
    -0.17264807f, 0.24008906f, 0.02146146f, 0.08789706f, 0.09031309f, -0.46714190f, 0.17098810f, 0.17307925f, 
    -0.05284294f, -0.34533998f, 0.23487952f, -0.25069481f, -0.24466506f, 0.06575386f, 0.00449853f, 0.10977425f, 
    -0.60349858f, -0.05109898f, -0.10992883f, 0.28750607f, -0.12816291f, -0.04031490f, 0.00639977f, 0.18599099f, 
    -0.08382169f, -0.61633539f, -0.40823165f, -0.04810230f, -0.12822691f, 0.30568397f, -0.06251407f, -0.04822622f, 
    0.03294563f, 0.29722989f, 0.13084751f, -0.04361209f, 0.10417024f, -0.01806521f, 0.01043370f, -0.11834885f, 
    0.06867089f, -0.11587536f, -0.06982202f, -0.02795896f, 0.11057366f, 0.28472760f, 0.29314965f, -0.37505400f, 
    0.19104594f, 0.20275505f, -0.39647955f, -0.02484498f, 0.20565267f, -0.11511636f, -0.70640594f, 0.20678540f, 
    0.04516167f, -0.08796259f, 0.25908667f, -0.49784631f, 0.10106930f, -0.13814522f, -0.48699263f, 0.20365368f, 
    -0.43980235f, 0.30894578f, -0.00210385f, -0.11121663f, -0.02629075f, 0.02179358f, -0.44623852f, 0.20877334f, 
    0.08198594f, 0.13582094f, -0.12528656f, 0.12286477f, 0.32915828f, 0.48214093f, -0.11272177f, 0.21103120f, 
    0.27270463f, 0.09499964f, -0.05140181f, -0.30883488f, 0.12393980f, -0.13259229f, 0.05093826f, 0.01726416f, 
    0.01676920f, -0.54878354f, 0.54048657f, 0.06566918f, 0.09066519f, 0.09586599f, 0.00577581f, 0.01823912f, 
    0.02245330f, -0.46800014f, -0.30812168f, -0.10130267f, -0.06059124f, 0.26710752f, 0.03954886f, 0.00335075f, 
    -0.10524071f, 0.01630012f, 0.10013202f, -0.03654043f, -0.30695519f, -0.04941426f, -0.38261724f, -0.69205880f, 
    -0.28773159f, 0.00466544f, -0.34834278f, -0.02529300f, 0.18601850f, -0.03676516f, 0.29376432f, 0.27183020f, 
    -0.01107563f, 0.00032667f, 0.11400024f, 0.13114770f, 0.05747773f, 0.18787605f, 0.04669670f, -0.28405216f, 
    0.32286102f, 0.08517680f, 0.04840086f, -0.06357969f, -0.05789245f, -0.25523210f, -0.44740787f, 0.06819259f, 
    0.03591944f, 0.32335395f, -0.38969466f, 0.33278182f, 0.14813447f, -0.19173975f, 0.03133607f, -0.42641905f, 
    -0.11124995f, -0.59676987f, 0.05705285f, 0.13640064f, -0.67913616f, 0.05966885f, -0.04235545f, -0.13618053f, 
    0.01221475f, 0.22485381f, -0.03957555f, -0.43965665f, 0.22390667f, -0.01858788f, 0.04221771f, -0.09230385f, 
    0.20518720f, 0.19182901f, -0.15221620f, 0.08802178f, -0.04745024f, -0.47092071f, 0.00143307f, -0.08473232f, 
    -0.01066894f, -0.06490041f, 0.00726488f, 0.04929739f, 0.05676297f, -0.10271524f, -0.00263208f, 0.15693106f, 
    0.06744882f, 0.10276042f, 0.23202637f, -0.70615095f, -0.39927202f, 0.09836794f, -0.25445241f, -0.22708943f, 
    0.07886229f, -0.01915260f, 0.21917856f, 0.24548766f, 0.10059201f, -0.46532911f, 0.18887123f, -0.19140674f, 
    0.32372361f, 0.27187115f, -0.03205128f, 0.01562276f, -0.10287328f, -0.23868738f, 0.11700786f, 0.20107789f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16642113f, -0.00287227f, -0.09087013f, -0.07205466f, 0.00816147f, -0.06446961f, -0.07592293f, -0.24529375f, 
    -0.02365443f, 0.11383195f, 0.04560185f, 0.12113242f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
