#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24765788f, -0.56761551f, 0.46486026f, 0.33146372f, -0.85863882f, 0.25676537f, -0.34178627f, -0.47064611f, 
    -0.41837168f, -0.25834724f, 0.33581224f, -0.19305630f, 0.22179958f, 0.66404229f, -0.03086545f, -0.06208689f, 
    0.08007170f, 0.04113180f, -0.41466779f, -0.26088032f, 0.15658754f, 0.16635239f, -0.09004585f, 0.00659890f, 
    -0.08764461f, 0.39109057f, 0.61980605f, 0.16359250f, -0.75052440f, -0.39810941f, -0.60972357f, -0.05559552f, 
    0.28698450f, -0.05101879f, 0.14337265f, -0.52942234f, -0.11324982f, -0.17545600f, 0.09932953f, 0.47571275f, 
    0.39922768f, 0.27594396f, -0.16439421f, -0.39153442f, -0.36404994f, -0.10083633f, -0.05989984f, -0.39581829f, 
    -0.43296364f, -0.56138176f, -0.07370189f, -0.72349989f, -0.45235494f, 0.40144023f, 1.12921810f, -0.25323221f, 
    0.68052638f, -0.66270727f, -0.84439164f, -0.56993622f, 0.24069929f, -0.20124598f, 0.61447626f, -0.39134219f, 
    -0.22789755f, 0.32443538f, -0.41734004f, -0.23432454f, 0.05995248f, -0.02048909f, -0.19306289f, 0.17997479f, 
    0.05748565f, -0.09274501f, -0.13361865f, 0.07669111f, 0.32456756f, -0.02544642f, 0.14385523f, -0.30889130f, 
    0.12036122f, 0.21818236f, 0.08493926f, -0.05743375f, 0.51725978f, -0.15557210f, 0.07071096f, -0.00222115f, 
    0.11563569f, 0.03802898f, -0.02112662f, -0.13352995f, 0.26994818f, 0.13390033f, 0.26009539f, -0.03938030f, 
    -0.00817870f, -0.35054293f, -0.18706663f, 0.28765056f, -0.41298994f, 0.11649760f, 0.20170966f, -0.64523780f, 
    -0.71033752f, 0.96349877f, -0.12718646f, -0.75937718f, -0.34409460f, 0.86886817f, -0.00320252f, -0.03358830f, 
    -0.19294043f, -0.11356935f, 0.32430866f, 0.14405239f, 0.17062742f, 0.30233452f, 0.09279964f, -0.38795030f, 
    -0.25072736f, 0.08792835f, 0.06950689f, -0.11265773f, -0.15408728f, -0.81396878f, -0.93345201f, -0.52172732f, 
    -0.10051258f, -0.09073254f, 0.36430749f, 0.45378968f, 0.30674666f, 0.11129154f, 0.57909590f, 0.08935197f, 
    0.12392104f, 0.21717918f, 0.36774847f, -0.06825010f, 0.09981846f, -0.05354861f, -0.22678617f, -0.03211921f, 
    0.01298613f, -0.15538381f, -0.21345079f, 0.14810093f, -0.12810346f, -0.11394698f, -0.51599365f, -0.19085090f, 
    -0.71400905f, -0.39516297f, -0.03492636f, -0.11799550f, -0.05885737f, 0.10354208f, -0.28198045f, -0.17090210f, 
    -0.41458714f, -0.46556672f, -0.24046746f, -0.13414353f, -0.29037821f, -0.23261328f, 0.06644478f, -0.18571313f, 
    -0.15636216f, -0.32178426f, -0.04216055f, 0.31000459f, 0.02202429f, -0.24520680f, -0.24568893f, 0.22875966f, 
    0.13436328f, 0.05318061f, 0.59685403f, -0.94061017f, -0.77699506f, -0.90383112f, 0.27781850f, 0.67900842f, 
    0.70964903f, 0.35922390f, 0.16508131f, -0.07598981f, 0.14842579f, -0.26668245f, -0.19501856f, -0.06716166f, 
    0.53349084f, -0.34599522f, -0.26706952f, 0.00961267f, 0.18570410f, -0.13680349f, 0.26759246f, 0.01105296f, 
    -0.11945593f, -0.30605188f, -0.43789548f, 0.30217946f, -0.31627303f, -0.61309588f, -0.35999215f, -0.41970664f, 
    -0.22692913f, -0.09323964f, -0.11368422f, -0.23886971f, 0.03189636f, -0.03681635f, -0.44457394f, -0.17370050f, 
    0.13423450f, -0.09437482f, -0.49783409f, -0.34091508f, -0.19379056f, 0.25138849f, 0.30584586f, 0.12087538f, 
    0.45956627f, 0.56316286f, 0.04277496f, -0.40080637f, -0.04808465f, 0.12384804f, 0.63620865f, 0.59993196f, 
    -0.00739932f, -0.62291038f, -0.50352597f, 0.40832829f, 0.09324314f, -0.06458636f, -0.49250740f, 0.14855477f, 
    -0.23487371f, -0.29498449f, 0.20975752f, 0.02654256f, 0.10670052f, 0.22147106f, 0.14409868f, -0.17567140f, 
    -0.04167149f, -0.26393905f, 0.90611517f, 0.27975532f, 0.18066956f, 0.06314749f, -1.08795047f, -0.59683740f, 
    0.32881778f, 0.01722825f, -0.68567133f, -0.55039304f, -0.52564096f, -0.12113431f, 0.45103940f, -0.52184302f, 
    0.01500846f, -0.13595791f, 0.09169418f, 0.35216674f, 0.04554050f, -0.17111360f, 0.21008715f, -0.16442700f, 
    -0.11465502f, -0.05387510f, -0.06563938f, 1.06686759f, -0.55571157f, -0.45833290f, 0.36417347f, -0.21090133f, 
    0.35753265f, 0.15068702f, -0.04903146f, 0.12789151f, 0.13142557f, 0.24797878f, -0.11802842f, -0.33348206f, 
    -0.25006136f, -0.07246593f, -0.11915964f, 0.19230299f, 0.00491999f, 0.06587388f, -0.30122772f, 0.10361069f, 
    -0.24800666f, -0.30640087f, -0.29848287f, -0.07932927f, 0.43835521f, -0.98986417f, -0.72946376f, 0.09817942f, 
    -0.10934891f, 0.52717322f, 0.71322817f, -0.11190939f, -0.21112160f, -0.15128034f, 0.03468889f, -0.24995108f, 
    0.00302354f, -0.19869499f, 0.28547820f, -0.14451370f, 0.20140554f, 0.05369114f, -0.27547336f, -0.12657060f, 
    0.10756452f, -0.11431843f, -0.02711188f, 0.60697931f, -0.04103807f, 0.20498252f, -0.39327228f, -0.74227458f, 
    -0.74051398f, -0.26987624f, 0.18514219f, 0.16481088f, -0.06792037f, -0.35672548f, -0.07731637f, 0.56409371f, 
    0.61560518f, 0.31876335f, 0.26619551f, 0.09210264f, -0.14192191f, -0.24229906f, -0.18206002f, -0.10831218f, 
    -0.40387329f, 0.14287232f, 0.45788571f, -0.21393181f, 0.11946861f, 0.08701191f, 0.74837548f, 0.42975110f, 
    0.51107907f, 0.48193893f, -0.17261346f, -0.14358637f, -0.31375846f, -0.08112025f, 0.32995790f, -0.31681308f, 
    0.05785023f, -0.12907715f, 0.04729592f, 0.06851981f, -0.17215915f, -0.14136949f, 0.13791446f, 0.16286266f, 
    -0.21188746f, 0.04225786f, -0.03735439f, 0.06880821f, -0.08781128f, 0.12420429f, -0.06771859f, 0.34996542f, 
    0.29510495f, 0.34152946f, -0.16287583f, 0.12513942f, -0.08870412f, 0.38334551f, 0.20707873f, 0.12515657f, 
    0.31731594f, -0.36086899f, 0.48172918f, 0.12561281f, -0.40242165f, -0.11580849f, -0.11086566f, 0.09978716f, 
    -0.30806646f, -0.05325722f, -0.23646465f, -0.30713910f, 0.27620584f, 0.36863807f, -0.04339412f, -0.11363063f, 
    -0.71136403f, -0.68993938f, -0.81644297f, -0.67058343f, -0.77829516f, 0.46698797f, 0.38466957f, 0.48943838f, 
    0.37216693f, 0.62883359f, -0.05415436f, 0.47133878f, -0.04888467f, -0.19661628f, -0.04504298f, -0.44298744f, 
    -0.00605442f, 0.05731505f, -0.02890429f, 0.03192137f, -0.13360250f, 0.14527616f, -0.12305810f, 0.21360494f, 
    -0.15779293f, 0.09712390f, 0.00855653f, -0.11207635f, -0.16768546f, -0.19456662f, -0.64725208f, -0.44595230f, 
    -0.01979765f, -0.17161646f, -0.51623690f, -0.08665702f, 0.07380798f, -0.05625253f, -0.43183717f, 0.57860267f, 
    -0.08868450f, 0.42169762f, -0.01343400f, 0.20514703f, -0.16431625f, -0.21533628f, -0.32594499f, -0.02165155f, 
    0.07832790f, 0.26408929f, -0.30581573f, -0.11716566f, 0.22663687f, 0.17784071f, 0.23027228f, -0.16317897f, 
    0.40673366f, -0.08696010f, -0.28858072f, 0.14927699f, 0.38886791f, -0.07589281f, -0.07680225f, -0.44956678f, 
    0.05376987f, -0.05808859f, 0.42008033f, 0.00650044f, 0.27326486f, -0.26267534f, -0.05182633f, -0.37564099f, 
    0.31106755f, 0.03172975f, -0.30167991f, -0.22244678f, -0.26218277f, -0.56889951f, -0.31734383f, -0.42018086f, 
    -0.35723397f, -0.27266768f, -0.61379200f, -0.41184309f, -0.46001172f, 0.10830031f, 0.34963384f, 0.13689677f, 
    -0.24858002f, -0.06903332f, 0.21238604f, 0.22895184f, 0.05384090f, 0.07675660f, 0.16015477f, -0.01194171f, 
    0.01278460f, 0.32729119f, -0.29580995f, -0.27548286f, -0.18322149f, -0.93331176f, -0.18994284f, 0.35963789f, 
    0.42687035f, 0.09010019f, -0.36387390f, -0.70073324f, -0.62723255f, -0.23334053f, -0.21694596f, 0.19504844f, 
    0.18583231f, -0.44507965f, -0.16968590f, -0.34367704f, 0.12991686f, -0.02366837f, -0.23430197f, -0.21356978f, 
    0.28888574f, -0.43229368f, -0.11384163f, -0.01900338f, 0.08512098f, -0.58827180f, -0.27089575f, -0.15272525f, 
    0.20005818f, 0.44854051f, 0.32055750f, 0.21593669f, 0.05847696f, -0.01301219f, 0.38036916f, 0.19357882f, 
    0.34317347f, -0.22507034f, -0.05793857f, 0.06634308f, -0.68113822f, 0.17550337f, 0.24964255f, -0.45116511f, 
    -0.04599831f, 0.15120901f, 0.18304215f, -0.09645522f, -0.01544582f, 0.30898479f, 0.67679954f, -1.47785056f, 
    0.42655286f, -0.02587657f, 0.48069140f, -0.45306316f, -0.36313534f, 0.46412089f, 0.20781985f, -0.30579022f, 
    -0.12217576f, -0.10079515f, -0.08287565f, -0.19161154f, 0.27952883f, -0.06237704f, 0.08970506f, -0.14638089f, 
    0.02250332f, 0.04443691f, 0.02098019f, 0.04669638f, -0.22257961f, 0.03964497f, 0.17266051f, -0.28049767f, 
    -0.59587258f, -0.74796253f, -0.73125911f, 0.01378174f, 0.31469715f, -0.25039682f, -0.33670259f, 0.04555741f, 
    0.51979023f, 0.21411966f, -0.34729746f, -0.16402772f, -0.17400557f, -0.26992750f, -0.11202516f, -0.30981871f, 
    -0.26079726f, 0.52345812f, 0.00877002f, -0.08678785f, -0.19014931f, -0.02536963f, -0.10955088f, 0.41114160f, 
    -0.80654746f, -0.42851520f, -0.09715118f, 0.55344886f, 0.30029386f, -0.31183058f, -0.80683208f, 0.27764139f, 
    0.36925098f, -0.11530832f, 0.24977177f, 0.22426872f, 0.13112529f, -0.13389479f, 0.00626378f, -0.10935802f, 
    -0.07201909f, 0.11910228f, -0.43383008f, -0.37500244f, 0.12217328f, 0.41357571f, 0.30464846f, 0.04591875f, 
    0.27488559f, 0.23342992f, 0.44071475f, 0.22016239f, 0.23887847f, 0.20264687f, 0.23386557f, -0.00015176f, 
    -0.05659644f, 0.21706608f, -0.13937493f, -0.10348287f, -0.53897917f, 0.00076775f, 0.05744751f, -0.03630017f, 
    -0.07672761f, 0.04690360f, -0.21651424f, -0.03665949f, -0.07569373f, -0.40904972f, -0.24928109f, -0.24691641f, 
    -0.48234046f, -0.72023106f, -0.29224345f, 0.13013576f, -0.03972967f, -0.10402117f, 0.22155583f, 0.78651845f, 
    0.04262743f, -0.44434908f, 0.41389903f, -0.11217192f, 0.38949093f, -0.17670374f, 0.18745323f, -0.38159776f, 
    -0.01050130f, -0.17063145f, 0.01259266f, 0.08453170f, -0.09339940f, -0.22078945f, -0.06548016f, -0.10641818f, 
    0.19596645f, 0.33900079f, -0.07597346f, 0.45223212f, 0.37839922f, -0.55589074f, -0.33473393f, 0.24644138f, 
    0.16207430f, -0.23507608f, -0.17833416f, -0.26117778f, 0.28373358f, -0.12867512f, 0.25479314f, -0.12904286f, 
    -0.22699273f, 0.53545606f, -0.05185238f, 0.05502626f, 0.12931101f, -0.19096793f, 0.00408197f, 0.14583020f, 
    0.23609726f, 0.16318427f, -0.26909861f, -0.18026823f, 0.34285203f, 0.32556972f, 0.00934064f, -0.12269378f, 
    0.10250338f, 0.03767653f, -0.38755167f, -0.09696569f, 0.26424474f, -0.43486512f, -0.27384987f, 0.14296088f, 
    -0.03422024f, 0.28054288f, -0.27934882f, 0.02867647f, 0.19419807f, 0.06551754f, -0.29958230f, 0.08852219f, 
    -0.00310491f, 0.20238104f, 0.26391143f, 0.13208941f, 0.21339865f, 0.55534780f, 0.40391690f, 0.12146098f, 
    -0.01655163f, -0.35625404f, 0.17862174f, -0.18844810f, 0.00004691f, 0.02082945f, -0.18431291f, 0.19369839f, 
    -0.08389860f, -0.07135320f, -0.45133319f, -0.30285695f, 0.24537987f, 0.26362213f, 0.06070916f, -0.01302471f, 
    0.05407331f, 0.07194655f, -0.39245912f, -0.31416428f, 0.08178084f, -0.05392298f, -0.81427920f, -0.66974521f, 
    -0.04171960f, 0.35197881f, 0.78190738f, -0.44806737f, -0.42698386f, 0.26089096f, 0.35186523f, 0.44953558f, 
    -0.39765739f, -0.43800589f, -0.20648916f, -0.09171245f, 0.38209563f, 0.00385238f, -0.24665488f, 0.08632727f, 
    0.32044372f, 0.06956405f, -0.46878901f, 0.02299339f, -0.23354879f, -0.01461490f, -0.11368866f, 0.15675914f, 
    -0.69425333f, -0.56038338f, -0.21085325f, -0.48256987f, 0.08874238f, 0.14360616f, -0.13186416f, 0.05238369f, 
    -0.23321499f, -0.21475926f, -0.33643511f, -0.59740829f, 0.44680360f, -0.22991264f, -0.07540530f, 0.18292595f, 
    -0.07937920f, 0.09917065f, -0.23531224f, 0.08429682f, -0.29564518f, -0.41807216f, -0.39931747f, -0.46302789f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30004781f, 0.04695804f, -0.00642958f, -0.07725073f, 0.38447946f, -0.10561568f, -0.05579489f, 0.15139675f, 
    -0.05935716f, 0.20424603f, -0.04206161f, 0.20838484f, 0.25691655f, 0.12343995f, 0.14744931f, 0.47061101f, 
    0.29070532f, 0.13709091f, 0.11162615f, -0.21397924f, -0.14633057f, 0.24310316f, 0.10447554f, -0.03837965f, 
    0.29054070f, -0.00916222f, 0.06859343f, 0.34295654f, 0.16691646f, 0.31632626f, 0.18258666f, -0.11199151f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00054143f, -0.00638767f, -0.00494292f, 0.00931420f, -0.00974981f, -0.03551789f, 0.00840210f, 0.02651137f, 
    -0.02243571f, -0.03269044f, -0.01044478f, 0.01544917f, -0.00172804f, 0.00205790f, -0.02044757f, -0.03443632f, 
    -0.04412647f, 0.03030103f, -0.04263154f, -0.02564634f, 0.02195125f, 0.00325607f, -0.02470388f, -0.04933394f, 
    -0.01035542f, 0.01808237f, 0.02188593f, -0.02714430f, -0.00486975f, 0.00968073f, 0.03532058f, 0.03865591f, 
    0.03630418f, 0.01453917f, -0.01208196f, 0.01359805f, -0.03056954f, -0.03725412f, -0.05310866f, 0.02550296f, 
    0.00297208f, -0.03138503f, -0.03701884f, 0.03435573f, -0.05873934f, -0.03328033f, -0.02297874f, -0.01365624f, 
    0.00962431f, -0.04172242f, -0.03626575f, 0.03609246f, -0.00940775f, 0.02423456f, -0.03739576f, 0.01467732f, 
    0.00532753f, -0.02074039f, 0.02723958f, 0.03666317f, 0.03230774f, 0.01369086f, 0.03608534f, -0.05407786f, 
    -0.04591826f, 0.03205585f, -0.03672303f, -0.04350760f, 0.03506876f, 0.00389487f, -0.01884193f, 0.03182679f, 
    0.05134049f, 0.02956076f, -0.00505355f, -0.00779221f, -0.00425057f, -0.02617382f, 0.01649817f, -0.05088530f, 
    0.01953834f, 0.02841920f, -0.02339340f, -0.01135941f, 0.01891786f, -0.00293883f, -0.00357640f, -0.02404733f, 
    0.03567225f, 0.00440258f, -0.02024177f, 0.03370427f, 0.01616924f, 0.03505665f, 0.03476078f, 0.01306183f, 
    -0.00941729f, -0.02714733f, -0.01611212f, -0.00121910f, -0.02408580f, -0.00169353f, -0.01148275f, -0.00085549f, 
    0.04381024f, 0.00513452f, -0.00955202f, -0.02291882f, 0.00328082f, -0.01406435f, -0.05065136f, -0.04235371f, 
    -0.03826224f, -0.03115392f, -0.03735966f, -0.04356395f, -0.00812094f, 0.02049471f, 0.01106231f, 0.03503323f, 
    0.04087638f, -0.01768848f, 0.03154553f, 0.01845271f, -0.00617590f, 0.01181293f, 0.01091913f, -0.04896853f, 
    -0.01019325f, -0.02421096f, -0.02464702f, 0.00725085f, 0.03911392f, -0.02745013f, -0.00502090f, -0.00676549f, 
    -0.02204414f, -0.04560161f, -0.05705180f, -0.05552350f, 0.01894908f, 0.03016950f, -0.01950501f, 0.03519642f, 
    0.01189915f, 0.00845230f, 0.01251102f, -0.04418581f, -0.04887569f, -0.02737515f, 0.00695678f, 0.01670884f, 
    0.02259899f, -0.01807424f, -0.00492117f, -0.00794593f, 0.02313701f, 0.03157392f, -0.02697864f, -0.01027145f, 
    0.02732091f, -0.00109069f, 0.03567186f, 0.03411265f, -0.04591110f, -0.05275385f, 0.01225226f, 0.03919615f, 
    -0.03850447f, 0.02776974f, 0.03268835f, -0.02982871f, 0.03159892f, -0.01660891f, -0.02683773f, -0.01341447f, 
    -0.03531227f, -0.00075979f, -0.04094375f, -0.01107436f, -0.02457328f, -0.00078421f, -0.05480613f, 0.02121906f, 
    -0.02355878f, -0.00591046f, -0.02512560f, -0.03331606f, -0.05572337f, -0.05149835f, 0.01852920f, 0.03718590f, 
    0.00761984f, -0.02665101f, -0.05221089f, -0.01461906f, -0.01920337f, -0.00679009f, -0.05335189f, -0.03502809f, 
    -0.03034703f, -0.04011009f, 0.02416121f, 0.02198033f, 0.03251568f, 0.04448424f, 0.01261192f, 0.01171394f, 
    -0.03773127f, 0.04854345f, 0.03770896f, -0.05396359f, 0.03404942f, -0.02250690f, 0.00219471f, -0.01262138f, 
    -0.01090463f, -0.03057712f, -0.04922289f, -0.01901651f, -0.03263646f, 0.02196094f, 0.03558827f, 0.03507226f, 
    -0.00623468f, 0.02820001f, -0.02742666f, 0.02101617f, 0.06151314f, -0.03241301f, -0.02618229f, 0.03767145f, 
    -0.00093544f, -0.04294536f, -0.01035645f, 0.03456524f, -0.02271287f, -0.04962577f, 0.01465290f, -0.01467492f, 
    -0.01686812f, -0.02373589f, 0.03444164f, 0.03405510f, 0.04366582f, 0.01423184f, -0.00922728f, 0.00961815f, 
    -0.03715838f, 0.02030697f, 0.02560828f, 0.02830061f, 0.03327694f, -0.02699776f, -0.02322087f, -0.03323728f, 
    -0.00882346f, -0.04686322f, 0.02664493f, -0.00169108f, 0.02860835f, 0.00298268f, -0.01134525f, 0.03069435f, 
    0.00724096f, 0.02913486f, 0.03694513f, -0.05004659f, -0.01193353f, 0.00372694f, -0.04835182f, -0.01057509f, 
    0.03360519f, -0.05744256f, -0.05112997f, -0.00535045f, -0.01156812f, -0.02890268f, 0.00719753f, 0.03000434f, 
    0.04536759f, -0.02936780f, 0.03709072f, 0.01458131f, -0.01300960f, 0.03535162f, -0.00646495f, -0.04488402f, 
    -0.01099153f, 0.01504439f, 0.00638951f, -0.01895053f, -0.02116352f, -0.01217192f, 0.01048437f, -0.03847943f, 
    0.01259764f, -0.04484736f, 0.01269260f, -0.02207749f, -0.03863521f, -0.00162691f, -0.04253222f, 0.01063306f, 
    -0.02875811f, 0.02697906f, 0.01677850f, -0.01377865f, 0.03468032f, 0.00681399f, -0.04277370f, 0.01129871f, 
    0.01983090f, 0.00768881f, 0.00801268f, -0.00800607f, 0.02507545f, 0.03051981f, 0.02044216f, -0.05524427f, 
    0.03801843f, -0.00771815f, 0.02640927f, 0.03062552f, -0.02091889f, 0.00548685f, -0.01748360f, -0.06139408f, 
    -0.03537446f, 0.00880268f, 0.01345881f, 0.00221276f, 0.02832214f, 0.02515624f, 0.02213755f, 0.02499387f, 
    -0.03622473f, 0.00037902f, 0.02619339f, -0.00395152f, -0.05306789f, -0.04138308f, 0.02184425f, -0.05891328f, 
    0.04176726f, -0.04131411f, -0.01384640f, -0.01153783f, 0.01976706f, -0.04073212f, 0.02449690f, -0.02866208f, 
    -0.01064464f, -0.04701257f, 0.00090791f, -0.03494463f, -0.03236508f, -0.04199776f, -0.05095257f, -0.02289408f, 
    0.02834314f, -0.01184633f, 0.02079672f, -0.00534783f, -0.01848094f, 0.03342196f, 0.00903253f, 0.02620935f, 
    0.02459785f, -0.00024710f, 0.01250947f, 0.01354382f, -0.03301874f, -0.02711640f, -0.04599831f, 0.02737235f, 
    -0.01583866f, -0.00207617f, 0.00871652f, -0.01477828f, -0.03795046f, -0.03251752f, 0.01452268f, -0.06250882f, 
    0.04492024f, -0.16395620f, 0.08477143f, -0.11731809f, 0.04225730f, 0.11721641f, -0.04593996f, 0.01441121f, 
    0.13313383f, 0.10181578f, -0.01862235f, 0.23200123f, 0.02160059f, 0.00796856f, 0.01908901f, 0.20210202f, 
    0.00636836f, 0.11178466f, 0.14631356f, 0.26162863f, 0.02142532f, 0.04805806f, 0.12825817f, -0.22880889f, 
    0.04951007f, 0.42351541f, -0.04592159f, 0.20515415f, 0.26288086f, 0.02895581f, 0.00690961f, 0.00543561f, 
    0.10287118f, 0.11759566f, -0.04237614f, -0.04459526f, -0.08753318f, -0.16172519f, -0.14737152f, 0.04342119f, 
    -0.05487200f, -0.25125951f, 0.27226755f, -0.14419752f, -0.14078999f, -0.10759106f, -0.13708287f, -0.01572510f, 
    -0.01184327f, 0.10070223f, 0.12129283f, -0.11507352f, -0.04187357f, 0.08655807f, 0.20416856f, 0.26888618f, 
    0.07081355f, 0.00621359f, 0.03368837f, -0.00186022f, -0.09622751f, 0.10769269f, -0.25158954f, -0.18202044f, 
    0.07170892f, 0.08209762f, -0.17774360f, 0.23092954f, 0.05289780f, 0.05508411f, -0.02355936f, -0.05938196f, 
    0.13166356f, 0.12640803f, -0.00891170f, -0.05414630f, -0.03778050f, 0.02586961f, -0.03013092f, -0.07613361f, 
    -0.05753975f, -0.04665222f, -0.05416739f, -0.16926812f, 0.85210508f, -0.47179070f, 0.01662998f, 0.34839356f, 
    -0.15476397f, 0.14557169f, 0.12426668f, 0.10238466f, -0.07612225f, -0.06719398f, -0.12666149f, -0.06530683f, 
    0.08417680f, 0.04072388f, 0.01572949f, -0.31994471f, -0.10569070f, -0.12799104f, -0.04085429f, -0.01694132f, 
    0.04182367f, -0.00393663f, -0.05960765f, -0.02021665f, -0.26296368f, 0.33961582f, -0.16060518f, 0.14729059f, 
    -0.18020965f, -0.10765032f, 0.21345505f, 0.07199858f, 0.15506637f, 0.08411863f, 0.06700733f, 0.07601415f, 
    -0.10729862f, -0.09316181f, -0.03655587f, 0.22042790f, 0.08237644f, 0.13351233f, 0.13512285f, -0.01165301f, 
    -0.00505788f, 0.15110086f, 0.06704237f, -0.08119898f, -0.29222101f, -0.12292171f, -0.03533086f, 0.09411424f, 
    -0.02046256f, 0.02987481f, 0.32183516f, 0.15072794f, -0.04569760f, 0.02498175f, 0.14824577f, -0.13607772f, 
    -0.32452887f, 0.11136931f, -0.19490200f, -0.00625835f, 0.05658184f, -0.03042975f, -0.03489202f, -0.09360567f, 
    -0.06256828f, -0.00800706f, -0.10174228f, 0.02566949f, -0.02997488f, 0.10688400f, -0.39527223f, 0.00537813f, 
    -0.01895648f, -0.18140379f, 0.04680469f, -0.07356858f, -0.22528416f, -0.06786092f, -0.06898854f, -0.03182189f, 
    0.07146767f, -0.04222980f, 0.13384846f, -0.26581603f, -0.07375912f, -0.03711410f, -0.10543301f, -0.05402072f, 
    -0.11524805f, -0.20175637f, -0.16487300f, -0.01064917f, 0.04657403f, 0.18157688f, -0.06068511f, 0.13149104f, 
    -0.07585307f, -0.01923012f, -0.10874789f, 0.09631459f, -0.08585271f, -0.00539820f, 0.15211894f, 0.13510114f, 
    -0.12546976f, -0.21946871f, -0.14807250f, -0.08217266f, -0.03594647f, 0.13205609f, -0.03574493f, 0.12758337f, 
    -0.02459236f, 0.15626870f, 0.11733124f, -0.01062680f, -0.02263176f, -0.03124656f, 0.06705932f, -0.13096446f, 
    0.10869770f, 0.06794138f, -0.04299457f, 0.19246657f, 0.01943024f, 0.05502241f, 0.02876751f, 0.16591462f, 
    -0.13202365f, 0.13869072f, -0.02790771f, -0.13985217f, 0.14159960f, 0.16466329f, -0.03447818f, 0.00332343f, 
    -0.01297079f, -0.03514405f, 0.16920680f, 0.04882833f, 0.21751088f, 0.06484491f, -0.13317966f, -0.14560449f, 
    0.13800323f, 0.16810016f, 0.14329150f, -0.04668670f, -0.16226733f, -0.09688739f, -0.05777139f, -0.02883594f, 
    0.08907252f, 0.18310298f, 0.00469795f, -0.06589338f, -0.00713704f, -0.07302468f, 0.02762884f, -0.07649592f, 
    -0.05556399f, -0.11054811f, 0.03438208f, -0.16231593f, -0.14654772f, 0.03245924f, -0.05123319f, -0.18524785f, 
    -0.21622275f, -0.05882847f, -0.01229040f, -0.06774360f, 0.07866354f, 0.13862532f, 0.20387852f, 0.07755990f, 
    0.33131993f, -0.26980227f, 0.21830045f, -0.03662041f, 0.22254357f, -0.18216583f, 0.24857052f, 0.07813926f, 
    0.08716910f, 0.11004808f, 0.23928624f, 0.07596344f, 0.07243407f, 0.00968471f, -0.01067107f, -0.17683692f, 
    0.21828765f, 0.00968992f, 0.04807159f, 0.07765252f, 0.11099109f, 0.05678898f, -0.03799477f, 0.11504674f, 
    0.13622223f, -0.04953537f, 0.30590945f, 0.08590199f, -0.14946814f, 0.21017855f, 0.01641501f, -0.09948129f, 
    0.10429931f, -0.13944907f, 0.16925487f, -0.33834535f, -0.12270270f, -0.15350376f, 0.00512605f, -0.04647641f, 
    -0.01807806f, 0.11141345f, 0.07933504f, 0.08835733f, 0.01412952f, -0.14197542f, -0.13149217f, -0.07847304f, 
    0.09473008f, -0.23008436f, 0.35184047f, -0.02887796f, -0.34352136f, 0.19159339f, -0.25693479f, 0.01730083f, 
    0.08089864f, 0.12992822f, 0.19499825f, 0.05539771f, 0.02750759f, 0.27785036f, -0.07894668f, 0.14238907f, 
    0.05529987f, -0.11518056f, 0.15621552f, 0.05017488f, -0.11416626f, 0.02650196f, 0.14090775f, -0.21729086f, 
    -0.08597727f, -0.11298119f, 0.05198314f, -0.19549774f, -0.11422952f, -0.01307879f, -0.09860618f, 0.01521755f, 
    0.02398338f, 0.09097000f, 0.05663322f, -0.07224766f, -0.21640645f, -0.16998589f, -0.07524889f, -0.14399903f, 
    0.11429768f, -0.03957884f, -0.09024323f, 0.10521273f, -0.16798007f, 0.00689081f, 0.07883286f, -0.01346861f, 
    0.37041682f, 0.04229534f, 0.26342717f, -0.13284951f, 0.02010333f, 0.16301578f, 0.18530573f, 0.00939557f, 
    0.03662512f, -0.03137536f, 0.07246619f, 0.10227708f, 0.10455417f, 0.05099470f, -0.00176515f, -0.06567286f, 
    0.07522792f, -0.05237987f, 0.15998816f, -0.00343664f, -0.10271358f, 0.00989449f, -0.02787422f, -0.13120273f, 
    0.26748556f, -0.20642689f, -0.11265453f, -0.35379130f, 0.06693278f, 0.09118982f, -0.12597381f, 0.04332193f, 
    0.08691766f, -0.01219351f, 0.03906370f, 0.05005040f, 0.16955376f, 0.08522904f, -0.10641842f, 0.04803099f, 
    -0.19837447f, 0.11891146f, 0.03007645f, -0.05900017f, 0.11035149f, 0.17053197f, 0.21292700f, 0.23714384f, 
    0.21971890f, 0.32031631f, -0.37635610f, 0.02945446f, 0.30322179f, -0.18770473f, -0.10771932f, 0.03771937f, 
    0.02024245f, 0.09781172f, 0.00920359f, 0.00256013f, 0.25435898f, -0.11839250f, -0.12794411f, -0.10367058f, 
    0.03450420f, -0.08491161f, 0.03149645f, 0.05198611f, -0.01543396f, 0.05459726f, -0.00098112f, -0.01390773f, 
    0.33624148f, -0.28794467f, 0.09715917f, -0.12790816f, 0.01475496f, 0.02009445f, -0.11196147f, 0.00919035f, 
    0.03306581f, 0.05879469f, -0.06875185f, 0.28085396f, -0.00921095f, 0.22939096f, 0.57543623f, 0.30523330f, 
    -0.03758598f, 0.01175652f, -0.05471992f, 0.14133075f, 0.10331368f, 0.00913004f, 0.01571569f, 0.13179411f, 
    0.13739471f, -0.00998154f, 0.02142422f, -0.12129698f, -0.04370538f, 0.04255370f, 0.06052624f, 0.08710646f, 
    -0.05287865f, -0.00070968f, -0.06914062f, 0.12494416f, 0.31076840f, 0.04523703f, -0.25750726f, -0.00427171f, 
    -0.17769295f, 0.12456740f, 0.13649355f, -0.01984923f, -0.03516473f, 0.07404228f, -0.12108929f, -0.00360484f, 
    0.02944633f, -0.01427071f, -0.00193059f, -0.36656687f, -0.09123490f, 0.00433178f, -0.03071171f, 0.00223345f, 
    -0.14514223f, -0.08521516f, -0.14247818f, -0.18433070f, -0.01780972f, -0.01035856f, 0.15733288f, -0.20458524f, 
    0.01449826f, -0.16793682f, -0.08343077f, -0.06743790f, 0.14300737f, 0.03075347f, -0.09411084f, 0.14963986f, 
    -0.19805020f, 0.03268540f, -0.09940226f, -0.21865402f, 0.16737178f, -0.04539522f, 0.30543789f, -0.04877248f, 
    0.11387040f, 0.20493956f, -0.13647769f, 0.04805846f, -0.16302960f, 0.00805164f, -0.00487245f, -0.11270405f, 
    -0.04736581f, -0.07980131f, 0.00670074f, 0.05062571f, 0.25463167f, 0.25436077f, 0.01232549f, 0.10496528f, 
    0.14872177f, 0.08143697f, -0.11121286f, -0.14817613f, 0.02637119f, -0.17428973f, -0.20764710f, -0.25952625f, 
    -0.03381756f, -0.16761512f, -0.18093060f, -0.04810158f, 0.21079357f, 0.50854635f, -0.04949064f, -0.11929030f, 
    0.09564915f, -0.16163719f, -0.07990637f, -0.11218926f, -0.00383437f, 0.00206649f, -0.08701988f, -0.10497490f, 
    -0.17343307f, -0.23601554f, -0.19840661f, 0.02639491f, -0.05357377f, 0.20136233f, 0.07475235f, -0.14346673f, 
    -0.09121729f, -0.20855883f, -0.15844227f, -0.11863352f, 0.06985413f, -0.11654733f, -0.11138880f, 0.00263246f, 
    0.00699723f, 0.03731386f, -0.00825628f, 0.02819324f, -0.10786953f, -0.02402646f, 0.01433032f, 0.22923459f, 
    0.07414102f, 0.28340960f, 0.28980589f, 0.28411415f, -0.09456045f, 0.00085816f, 0.05116301f, -0.06449284f, 
    -0.04261573f, 0.01622952f, 0.04037274f, 0.22249174f, 0.02372724f, -0.14265266f, -0.02291764f, -0.22597334f, 
    0.03413702f, 0.10342570f, 0.05713839f, 0.11300723f, 0.15983473f, 0.01819538f, 0.03876817f, -0.03232674f, 
    0.04624562f, -0.27008846f, 0.06828558f, 0.01393878f, 0.23860951f, -0.05265428f, -0.06318134f, 0.10322544f, 
    0.10840201f, 0.14632504f, -0.04772158f, 0.14314221f, 0.04600895f, 0.09221418f, -0.01474372f, -0.12543781f, 
    0.12647930f, 0.11454086f, -0.00848850f, 0.09682389f, 0.02926451f, 0.10130902f, 0.15275672f, 0.09589259f, 
    0.25021523f, 0.12705407f, -0.12552503f, -0.08666439f, 0.20637549f, 0.05288617f, 0.08364071f, 0.01714816f, 
    -0.01889910f, 0.02251455f, -0.04472578f, -0.03681418f, -0.10600656f, -0.02489969f, 0.47514656f, 0.21166047f, 
    0.13214833f, -0.09133685f, 0.00234757f, -0.01597098f, -0.13416389f, 0.14848608f, -0.23481137f, 0.09859470f, 
    -0.49340278f, -0.11706145f, -0.10201936f, 0.07123429f, -0.11010416f, -0.11466956f, 0.10143425f, -0.02469874f, 
    0.00600250f, -0.14475209f, 0.14299241f, -0.15894066f, -0.04239098f, 0.06861527f, 0.23796745f, 0.03433594f, 
    0.02952997f, -0.07840971f, -0.05819693f, 0.09979822f, -0.01258067f, -0.08808046f, 0.04933897f, 0.01180780f, 
    -0.18545218f, -0.01060787f, 0.13616979f, -0.15305340f, 0.04173613f, 0.03920307f, 0.09810120f, -0.07922287f, 
    0.09784769f, -0.26315317f, -0.14106736f, -0.29701561f, -0.10356721f, -0.10062676f, -0.13339575f, 0.05580488f, 
    -0.09382188f, -0.01728640f, 0.02957258f, 0.07522200f, 0.08523306f, 0.03618774f, 0.09451614f, 0.17889285f, 
    0.08833030f, -0.28279319f, 0.18809733f, -0.22008269f, -0.01682808f, 0.00226130f, -0.04106504f, -0.13845254f, 
    0.08050721f, 0.08124281f, 0.15162957f, 0.07411042f, 0.19927877f, -0.06781224f, -0.10543886f, -0.20116623f, 
    0.05079959f, 0.05613686f, -0.02827241f, 0.12322241f, 0.09393954f, -0.13546604f, -0.02507598f, 0.06566960f, 
    -0.21228315f, -0.23544434f, -0.16551593f, -0.14611921f, -0.00513968f, 0.12215501f, -0.07201823f, 0.02529986f, 
    -0.07288224f, -0.29213482f, -0.27225304f, -0.34509116f, -0.33869219f, -0.08404802f, -0.22283015f, -0.10545751f, 
    0.04151829f, 0.10029241f, 0.07886067f, -0.04577088f, 0.16662006f, 0.15305260f, 0.02820597f, 0.07313579f, 
    0.19413435f, 0.10555079f, 0.12747899f, 0.17788640f, -0.03069360f, 0.00621318f, 0.11014681f, 0.12594800f, 
    0.11121487f, -0.05350953f, 0.11036302f, 0.19401062f, 0.08152308f, -0.06581780f, 0.05162678f, 0.06651820f, 
    0.05653035f, 0.12350630f, 0.05258466f, -0.03415132f, 0.09990434f, 0.11423982f, 0.20397425f, 0.31899589f, 
    0.20468378f, 0.20358866f, -0.16483843f, 0.20998771f, -0.02809120f, 0.16190191f, 0.00569032f, 0.09424252f, 
    0.02799721f, 0.14135447f, -0.10720947f, 0.00204826f, 0.04704311f, 0.05204446f, 0.07735315f, -0.12137460f, 
    -0.11753199f, -0.03140547f, 0.05425733f, 0.10147741f, -0.01566183f, 0.07347761f, 0.24193817f, 0.04157387f, 
    0.07536390f, 0.40951669f, -0.10999081f, 0.13390394f, 0.15195185f, 0.04344124f, -0.36221796f, -0.06645166f, 
    -0.04049568f, -0.02201935f, -0.02992108f, 0.05990871f, -0.17081928f, -0.12558408f, -0.12746917f, -0.04029466f, 
    0.02622469f, -0.06887182f, 0.11822682f, -0.02335341f, -0.11182469f, 0.16037947f, 0.00373439f, -0.02474624f, 
    -0.09609822f, 0.12726316f, -0.32470238f, 0.00265670f, -0.14930919f, -0.06501592f, 0.18923728f, -0.06509769f, 
    -0.01414248f, -0.04643283f, -0.03165067f, 0.07496207f, -0.31738096f, 0.04383212f, -0.07378144f, -0.04929023f, 
    0.12775883f, 0.00947869f, -0.03957347f, 0.02176072f, -0.01728101f, -0.04263046f, -0.11556949f, 0.09080078f, 
    0.14542812f, -0.03331147f, -0.14833152f, -0.00322240f, 0.02394578f, 0.11916686f, -0.03059000f, -0.01185091f, 
    -0.00864348f, 0.03810738f, 0.04969004f, 0.11955409f, 0.36876777f, 0.02580933f, 0.03603783f, -0.01704603f, 
    -0.01603644f, 0.03412410f, 0.14535673f, -0.01185897f, -0.21374318f, 0.07552822f, -0.07342779f, 0.09089663f, 
    0.20109338f, 0.19054623f, 0.05520326f, -0.02624593f, -0.07893207f, -0.07207461f, 0.10367182f, 0.17319804f, 
    -0.02500312f, 0.03805273f, 0.05794349f, 0.01406706f, -0.42235970f, 0.20422658f, -0.17426790f, 0.20475118f, 
    -0.12274383f, 0.16678219f, -0.01144203f, -0.15189986f, -0.05505363f, -0.03749311f, -0.01622468f, -0.05071914f, 
    -0.18125580f, 0.06237730f, 0.18725149f, 0.34060159f, -0.05816776f, 0.00924879f, 0.12930325f, 0.05511550f, 
    0.00807764f, 0.10351600f, -0.05348643f, -0.05079255f, -0.24270344f, -0.04801328f, -0.08432427f, 0.17091210f, 
    -0.01543018f, 0.05169266f, 0.04675729f, 0.14724143f, -0.02571467f, 0.12001840f, 0.06754380f, -0.02580839f, 
    -0.13425024f, 0.51782644f, -0.56106645f, 0.27298307f, 0.22329614f, 0.01215378f, -0.11171938f, 0.08047361f, 
    -0.23742713f, -0.07546084f, -0.10854240f, 0.09110749f, 0.31385824f, 0.32081145f, -0.00705485f, 0.27427664f, 
    0.05751720f, -0.02244845f, 0.08269431f, -0.01710140f, 0.10383156f, -0.07486802f, 0.06520423f, -0.10963232f, 
    -0.01252841f, -0.17438015f, -0.13233466f, 0.09717810f, 0.07425907f, 0.10199032f, 0.05282808f, -0.01965700f, 
    -0.07180820f, -0.03779599f, -0.05320245f, -0.09847376f, -0.23161782f, -0.03255483f, -0.05369295f, -0.07015819f, 
    -0.01131090f, 0.01559284f, -0.03628793f, -0.07263130f, -0.07975381f, -0.06126383f, 0.04114737f, 0.14012115f, 
    0.05941831f, -0.04789616f, 0.11516247f, 0.05860561f, 0.13675854f, 0.10449591f, 0.06567115f, 0.13624823f, 
    0.03489446f, 0.10464645f, 0.08997476f, 0.02296187f, 0.24324730f, 0.05831549f, 0.30829588f, 0.02467572f, 
    -0.08260830f, -0.02157422f, -0.08028140f, 0.25416565f, -0.04292988f, -0.04031570f, 0.02128056f, -0.02097604f, 
    -0.13812369f, -0.03962456f, -0.03588837f, 0.02798922f, 0.15363230f, 0.08497335f, -0.00545626f, -0.05775140f, 
    0.03879985f, 0.07984276f, 0.04414811f, -0.06418789f, 0.28099096f, 0.02443730f, 0.04602868f, 0.15215392f, 
    0.08449423f, 0.05762050f, 0.11111117f, 0.05230623f, -0.01121724f, 0.03159656f, 0.02173616f, 0.01137614f, 
    0.12699497f, 0.19697431f, -0.19574483f, 0.09205822f, 0.05575615f, 0.00639378f, 0.02523872f, -0.05709431f, 
    -0.10179553f, 0.16059120f, 0.00696779f, -0.04583435f, -0.21346276f, 0.08532353f, -0.03887017f, 0.13799159f, 
    0.02226264f, -0.05807801f, -0.02895197f, -0.04603259f, -0.09864115f, 0.03096771f, 0.15089749f, 0.02935065f, 
    -0.45460349f, 0.03306853f, 0.35010028f, -0.04783696f, 0.16009431f, -0.04238408f, 0.01452624f, 0.28992426f, 
    -0.02665464f, -0.10302417f, 0.03948471f, 0.00475681f, 0.15058638f, 0.00303450f, -0.12308402f, -0.04762388f, 
    0.07342450f, -0.11331251f, -0.02959667f, -0.02471139f, 0.00064941f, 0.04006785f, 0.03939182f, 0.08122604f, 
    0.20355919f, 0.19052285f, 0.22437063f, -0.15114923f, 0.02830550f, 0.05757215f, 0.01755673f, 0.11173575f, 
    0.07363342f, -0.05483212f, -0.01993306f, -0.09925514f, -0.11542558f, -0.11339759f, -0.03087810f, 0.00435097f, 
    -0.00299410f, 0.03377072f, 0.05533480f, 0.00647310f, 0.16626465f, 0.08259258f, 0.16608644f, 0.26391095f, 
    -0.04717626f, -0.12674119f, 0.17048752f, 0.16696247f, 0.14717947f, 0.15676354f, -0.07085525f, -0.12935679f, 
    -0.11598796f, 0.06813192f, 0.01862798f, 0.09564152f, -0.12007287f, 0.17301825f, -0.06461295f, 0.00070350f, 
    -0.01237856f, 0.07551663f, 0.01429707f, -0.13556260f, 0.08754145f, 0.02665005f, 0.00352929f, -0.09096538f, 
    0.04214422f, -0.04720943f, 0.03539348f, 0.08598187f, 0.06407437f, 0.14019996f, -0.11863419f, 0.03536707f, 
    -0.02510412f, -0.02741418f, -0.05666197f, -0.13723341f, -0.20733353f, -0.12325677f, -0.15916443f, 0.07833366f, 
    -0.07672956f, -0.03044922f, 0.03703196f, 0.11643121f, 0.04925361f, 0.07866506f, 0.01284347f, -0.09572633f, 
    0.10522869f, 0.17767814f, 0.26722729f, -0.11547753f, -0.03217406f, 0.02450492f, 0.12248155f, 0.09304757f, 
    0.03646858f, 0.08046519f, 0.09189963f, 0.13418496f, 0.17518088f, 0.05689386f, -0.05386724f, 0.17467676f, 
    0.14425229f, 0.05612896f, -0.00423925f, 0.14281258f, 0.01225325f, 0.15105543f, 0.06234860f, 0.24734192f, 
    0.02340422f, -0.02989062f, 0.02016276f, -0.03140039f, 0.00801844f, 0.01649877f, -0.05402430f, 0.02546093f, 
    -0.00290928f, 0.04069303f, -0.02929188f, 0.03912929f, 0.03054376f, -0.00744190f, 0.00013620f, -0.05186691f, 
    -0.01387010f, -0.03646775f, 0.04473662f, 0.00988022f, -0.02802539f, -0.02043874f, -0.04665706f, 0.03632267f, 
    -0.03645372f, -0.02246724f, -0.00377224f, 0.02277958f, -0.01123222f, 0.02419260f, -0.02917236f, -0.03310867f, 
    0.01554505f, 0.02043008f, -0.03716578f, -0.03344771f, -0.05352545f, 0.03558019f, 0.04448137f, -0.03113234f, 
    0.02600420f, 0.01539314f, -0.03092668f, 0.00041100f, -0.05440331f, 0.03357903f, -0.00911504f, -0.03679876f, 
    -0.01025978f, -0.05335947f, -0.04851740f, -0.04281498f, -0.02430530f, -0.05296568f, -0.03629196f, -0.04317379f, 
    0.00237652f, -0.04843617f, 0.00222188f, -0.03028120f, 0.03572428f, 0.03028424f, 0.03397640f, -0.05630016f, 
    0.02729947f, -0.04318548f, -0.01848478f, -0.03778046f, -0.01624451f, -0.04610585f, 0.02213549f, -0.03830739f, 
    0.01739864f, -0.00786848f, -0.05423517f, 0.02221709f, -0.00655633f, -0.01151942f, -0.01821602f, -0.02706938f, 
    0.00136655f, -0.01593276f, 0.01868840f, -0.00953145f, 0.02590653f, -0.05070950f, -0.03104036f, -0.04022372f, 
    -0.03979089f, 0.00209101f, -0.02071750f, 0.04122803f, 0.01771385f, 0.01629565f, -0.02161525f, 0.00518268f, 
    -0.00860646f, -0.02903727f, 0.02165227f, -0.03521453f, -0.00803782f, -0.04436993f, -0.01845156f, -0.00126267f, 
    -0.00098589f, -0.05262125f, -0.04138151f, 0.04047869f, -0.05254230f, 0.00435238f, 0.02319155f, 0.01375444f, 
    0.00144002f, -0.02758483f, -0.01547437f, -0.01364201f, 0.02010138f, 0.00640609f, 0.02569227f, -0.04731419f, 
    0.02533682f, -0.00450482f, 0.00336891f, 0.04248574f, 0.01310476f, 0.02608434f, -0.02884938f, -0.02752792f, 
    -0.01612296f, 0.02414929f, -0.03530272f, -0.02573935f, 0.01262410f, 0.00136059f, -0.01769831f, -0.00626928f, 
    0.01286866f, -0.02293225f, -0.02826488f, -0.03279577f, -0.00704514f, -0.05523895f, -0.02303243f, -0.00556624f, 
    0.01342521f, 0.04495735f, 0.04245831f, -0.05618758f, -0.04374216f, 0.01264685f, 0.04108968f, 0.00909499f, 
    0.03339874f, 0.02424999f, 0.02329779f, -0.03861260f, 0.04029511f, 0.00241852f, -0.00934447f, 0.01033939f, 
    0.00427130f, 0.04209838f, -0.00439896f, 0.00829494f, -0.00218160f, -0.02621992f, -0.04221098f, -0.02913170f, 
    -0.00721620f, -0.03001476f, -0.01892427f, -0.04103483f, -0.03603882f, -0.02158427f, -0.02374538f, 0.01656258f, 
    -0.01521116f, 0.00701066f, -0.01164344f, -0.05408786f, 0.02502932f, 0.03516619f, -0.03718365f, 0.01649750f, 
    -0.02948727f, -0.03246525f, -0.00587001f, 0.02749797f, 0.01048313f, -0.04880220f, -0.00321198f, -0.04165341f, 
    -0.02559245f, -0.04433648f, 0.03584313f, -0.02423125f, 0.01346661f, -0.05182716f, -0.05349031f, -0.04168589f, 
    -0.05443665f, -0.02235221f, 0.02078184f, 0.01111360f, -0.04890109f, 0.03161410f, -0.04475624f, -0.04124032f, 
    0.01194872f, 0.03055247f, 0.04138314f, -0.01352992f, -0.01458412f, 0.00753801f, -0.02719812f, -0.01691924f, 
    -0.05412204f, -0.04160751f, 0.01547888f, 0.04068696f, 0.02209598f, 0.03105721f, -0.03152279f, -0.03192261f, 
    -0.02943773f, 0.02170816f, 0.02021803f, -0.01531280f, -0.01983597f, -0.00073934f, 0.02913987f, 0.01683201f, 
    0.03708637f, 0.01912638f, 0.00095760f, 0.00119663f, -0.03314654f, 0.02582300f, -0.03809125f, 0.01242457f, 
    0.02077510f, 0.00451638f, -0.01966971f, 0.01726139f, -0.03790164f, -0.00381133f, 0.03885295f, -0.04102150f, 
    0.03613723f, -0.03634237f, -0.05132125f, 0.03817825f, 0.04144704f, 0.02696885f, -0.00850152f, 0.01724580f, 
    0.01578752f, -0.00387809f, 0.00883630f, 0.02208075f, 0.03167703f, -0.03061444f, -0.03684956f, -0.02493446f, 
    -0.01103603f, 0.03772541f, -0.05294562f, -0.02041024f, 0.01231944f, 0.02050489f, -0.00525481f, -0.01627509f, 
    -0.03951879f, -0.01526682f, -0.04137068f, 0.01495740f, 0.01455941f, 0.00849914f, -0.03407842f, -0.01352822f, 
    0.02444953f, -0.00992664f, -0.00963764f, -0.00478156f, 0.01601889f, 0.02058425f, 0.01441244f, 0.01333996f, 
    0.03094444f, 0.02847789f, 0.04367336f, 0.02179790f, -0.00033005f, -0.05176258f, 0.00265009f, -0.03430188f, 
    0.01330133f, -0.05441433f, -0.04472499f, 0.01171796f, -0.00310464f, -0.05261796f, -0.01833360f, 0.02950602f, 
    -0.05555275f, 0.03986326f, -0.04340613f, 0.02755565f, -0.04143737f, -0.02372691f, -0.00882926f, 0.03773130f, 
    -0.05639291f, -0.03548231f, -0.00548185f, -0.03393024f, 0.01424237f, 0.02445533f, -0.04130456f, 0.03983890f, 
    0.02982386f, 0.01826359f, -0.05433873f, -0.00359262f, 0.04439501f, 0.02362929f, -0.04799014f, 0.03772768f, 
    -0.03330593f, -0.00130281f, -0.04598831f, 0.02751903f, 0.01124091f, -0.04523696f, -0.04746067f, -0.01646734f, 
    -0.03905537f, 0.00377695f, -0.01754235f, -0.05243462f, 0.02738597f, -0.00493227f, -0.03479838f, -0.02615073f, 
    -0.02783529f, 0.04446978f, 0.03327922f, 0.04382621f, -0.03843724f, -0.00535142f, -0.01361813f, -0.00334180f, 
    0.01363343f, -0.02993461f, 0.03311243f, 0.02016893f, -0.03512293f, 0.02789759f, 0.00738463f, -0.04679502f, 
    0.03118318f, -0.03571701f, 0.02053962f, 0.04203581f, -0.05218457f, -0.04680086f, -0.01332319f, -0.03422775f, 
    -0.04793705f, -0.02120418f, -0.01106872f, 0.02278104f, 0.03216632f, -0.01773006f, -0.04784296f, -0.05544027f, 
    0.02425143f, 0.00880094f, -0.05485823f, -0.03367053f, 0.02470042f, -0.00265396f, 0.04384470f, 0.02930146f, 
    -0.04483714f, 0.04323443f, -0.37650499f, -0.27826113f, -0.05447927f, 0.07479385f, -0.00980142f, 0.15485622f, 
    -0.06863746f, -0.03592679f, 0.06341282f, -0.12573220f, 0.11801226f, 0.15664327f, -0.26437777f, -0.18762143f, 
    -0.00611198f, 0.00462789f, 0.24332277f, 0.21640675f, 0.01963244f, -0.10280392f, 0.10102650f, 0.04174981f, 
    -0.53722107f, -0.29215804f, 0.22647052f, -0.06078932f, 0.32538477f, -0.00269660f, -0.01456911f, 0.16683051f, 
    0.03450664f, -0.04893085f, -0.03104794f, 0.01432427f, -0.04886622f, 0.11039754f, 0.04328194f, 0.03008659f, 
    -0.06594896f, -0.06244947f, 0.05623955f, 0.02550066f, 0.13731222f, -0.00629134f, 0.03214710f, -0.12363306f, 
    -0.04775957f, -0.39407477f, -0.21702980f, -0.60188842f, -0.27962965f, -0.00621610f, 0.10056048f, 0.11309273f, 
    0.18557119f, 0.00960784f, 0.03677006f, -0.04028482f, 0.12712350f, 0.22843403f, -0.01197053f, -0.11966894f, 
    0.00586864f, -0.06216409f, -0.09825171f, -0.04673515f, -0.05457037f, -0.00497049f, 0.01364045f, 0.07057185f, 
    -0.05098867f, -0.23903219f, -0.41573822f, -0.12359883f, 0.12782423f, -0.03132216f, 0.05298653f, 0.18081443f, 
    -0.07334968f, 0.01829271f, 0.06702534f, 0.12027946f, 0.16045834f, 0.00637462f, 0.11627970f, -0.10742778f, 
    -0.18281046f, 0.08859628f, 0.00911666f, -0.07988531f, 0.15448491f, 0.02171584f, -0.10491888f, -0.10602293f, 
    -0.18883838f, -0.11676124f, -0.35057747f, -0.24339254f, 0.05500720f, -0.06811482f, -0.10040472f, 0.07511548f, 
    -0.11615086f, 0.01584072f, 0.00444461f, -0.01653030f, 0.30737975f, -0.04026954f, 0.29338881f, 0.29961264f, 
    0.23771894f, 0.17602949f, -0.16203578f, 0.00575521f, 0.08748917f, 0.03107324f, 0.07106926f, 0.05156571f, 
    0.26944187f, 0.05028445f, -0.18297926f, -0.11308222f, 0.04044192f, -0.07486083f, 0.25018230f, 0.07695591f, 
    -0.06264348f, -0.05818639f, -0.13550299f, 0.19594708f, 0.46858215f, -0.13181949f, 0.19025885f, -0.17491986f, 
    -0.00134186f, 0.02310836f, -0.03081054f, -0.01483208f, 0.14074141f, 0.05875020f, 0.13852790f, -0.04675626f, 
    0.52669251f, -0.18320429f, -0.11951712f, -0.10211691f, 0.20638531f, 0.16214101f, -0.13283795f, 0.09503715f, 
    -0.01910705f, 0.03194975f, 0.11041849f, 0.11760059f, -0.02309044f, 0.30129656f, 0.23528694f, -0.15926301f, 
    -0.00222879f, -0.18258628f, -0.06807803f, -0.05898433f, 0.11600883f, 0.26934868f, -0.05106910f, -0.00685441f, 
    0.35719290f, -0.05931989f, -0.24709196f, 0.12343433f, -0.02321097f, 0.05585328f, 0.03006541f, -0.07975753f, 
    0.04811360f, -0.01756262f, -0.02214688f, 0.04276343f, 0.09804530f, 0.17470680f, 0.08658285f, 0.08076441f, 
    -0.01205543f, -0.02240567f, 0.03816570f, -0.01477393f, -0.01741677f, 0.01003831f, 0.06924382f, -0.00641183f, 
    0.09458609f, -0.29464608f, -0.07043639f, -0.38525340f, 0.00757400f, -0.12782884f, -0.15976872f, -0.03382090f, 
    -0.06811199f, 0.02642661f, -0.02173198f, 0.03925245f, 0.06603496f, -0.36223063f, -0.20448117f, -0.34010157f, 
    0.07311291f, -0.08621030f, 0.10382792f, 0.06408026f, -0.11127639f, -0.04177311f, -0.11795232f, -0.01512652f, 
    0.04168976f, -0.07718004f, 0.06731832f, 0.06297635f, 0.01267087f, 0.15454276f, -0.03906158f, 0.08828598f, 
    0.11878046f, 0.18379216f, -0.10931692f, 0.01853650f, -0.10617632f, 0.18598843f, 0.15647474f, -0.03722439f, 
    -0.10435575f, -0.00594246f, -0.16567694f, 0.08246170f, -0.06425010f, -0.09935156f, -0.05805801f, -0.04110676f, 
    -0.54522038f, -0.33551380f, 0.05280930f, -0.09426446f, 0.11287428f, -0.00644623f, 0.04279865f, 0.14337499f, 
    0.08277041f, 0.03788760f, 0.02828134f, -0.02874995f, 0.05282373f, 0.04310925f, 0.19088060f, 0.13057409f, 
    0.05478492f, -0.06658348f, -0.11098830f, -0.09406311f, -0.04025754f, 0.03243620f, -0.01683819f, 0.03509174f, 
    -0.21441515f, 0.10838103f, 0.11684369f, -0.26451460f, 0.09884366f, -0.11221054f, 0.11733676f, 0.03514930f, 
    -0.01433858f, -0.07019529f, 0.04135282f, -0.07957888f, -0.17896187f, -0.43835315f, 0.21354209f, -0.31110674f, 
    -0.08439373f, -0.22213092f, 0.01146880f, 0.03671946f, -0.04356896f, -0.04535760f, -0.11521891f, 0.01944690f, 
    -0.16036944f, 0.10543505f, 0.22705883f, 0.10309273f, -0.02976123f, -0.04014121f, -0.06624971f, 0.06198253f, 
    -0.01206583f, -0.02213887f, -0.06737510f, 0.03035722f, 0.13661022f, 0.13468236f, 0.00959829f, 0.11203236f, 
    -0.09304956f, 0.03092591f, 0.06367973f, 0.02429718f, 0.16741346f, 0.10741509f, 0.32932645f, 0.37537283f, 
    0.17089857f, 0.07064592f, 0.06141691f, 0.16512863f, -0.05285129f, 0.10672296f, -0.07101429f, -0.11983730f, 
    0.10799269f, 0.01412735f, -0.03675038f, 0.05703907f, 0.21299906f, 0.16056055f, -0.11196005f, -0.18941426f, 
    0.07566223f, -0.03576154f, 0.15695533f, 0.12041115f, 0.11011177f, -0.12800519f, 0.06950951f, 0.00897089f, 
    0.01978071f, 0.05703146f, -0.11887727f, 0.01972698f, 0.05734052f, -0.00061325f, 0.08134655f, -0.11519716f, 
    -0.15649584f, -0.08851180f, -0.10749186f, -0.11567842f, 0.19381790f, -0.05302149f, -0.05630050f, 0.13194212f, 
    0.02131909f, -0.02617929f, 0.09258481f, -0.04092212f, 0.22424303f, 0.13608608f, 0.02095497f, 0.14423978f, 
    -0.08348987f, -0.00464594f, 0.16680582f, 0.14907239f, -0.05886813f, -0.00019738f, 0.07027285f, -0.02915448f, 
    0.06725600f, -0.07114729f, -0.04998961f, 0.17179760f, -0.04250930f, -0.26195735f, -0.26876095f, 0.06850889f, 
    0.00258612f, -0.00288202f, 0.11991750f, 0.16322543f, 0.07012869f, 0.06519982f, -0.10087472f, 0.08155938f, 
    -0.02066910f, -0.02035865f, 0.01400504f, 0.00802113f, -0.03631177f, -0.03737912f, -0.04132514f, -0.05028978f, 
    -0.04099850f, -0.01897266f, 0.01288829f, 0.00738278f, -0.03655918f, 0.04625182f, 0.02704280f, -0.01236752f, 
    -0.04787086f, 0.00565954f, -0.04455531f, -0.04849582f, -0.04408806f, -0.03022570f, 0.02465977f, -0.03636359f, 
    -0.00069159f, 0.02912934f, 0.00778717f, 0.00181047f, -0.04736422f, -0.04785578f, 0.03044163f, -0.02562708f, 
    0.04358339f, -0.02441120f, -0.03286929f, -0.03391370f, 0.00846974f, -0.02714772f, 0.03403063f, -0.05523856f, 
    -0.02885612f, 0.04085123f, 0.04309839f, -0.03609532f, -0.02945661f, -0.03733369f, -0.03603829f, 0.02446605f, 
    0.02330985f, 0.03813965f, 0.01429954f, -0.03901989f, 0.01266252f, -0.01098974f, -0.05388805f, 0.04888463f, 
    -0.04567742f, 0.01272706f, -0.02295586f, 0.00928068f, 0.01868633f, 0.01588383f, -0.04882393f, 0.02674255f, 
    0.01322142f, 0.02041152f, -0.05161686f, 0.03673557f, -0.02387185f, 0.01006357f, -0.04017330f, 0.03338251f, 
    0.01391103f, -0.03233639f, -0.01450338f, 0.04861265f, 0.00110962f, -0.03687768f, -0.03385973f, -0.03470435f, 
    0.03841753f, 0.00035750f, 0.03474863f, 0.02143171f, 0.02341373f, -0.03560645f, 0.04328973f, -0.02140566f, 
    0.01142756f, 0.02270089f, 0.00441650f, -0.01603661f, 0.01824609f, -0.01286524f, 0.04434980f, -0.04734149f, 
    0.04772578f, 0.02143667f, -0.04353906f, 0.02526188f, 0.02649750f, -0.01186662f, 0.04337710f, -0.04386184f, 
    -0.04681616f, 0.02159597f, 0.00822593f, -0.01447273f, 0.04389389f, -0.03040256f, 0.03421409f, -0.02660623f, 
    -0.03935291f, -0.03031978f, -0.01325096f, 0.01741963f, -0.05576110f, -0.03819722f, -0.01455529f, 0.00891446f, 
    0.04088638f, 0.01442365f, 0.04012722f, 0.03173244f, -0.01847289f, -0.05120225f, -0.05599266f, 0.04812998f, 
    0.00940390f, -0.04521813f, 0.03284501f, -0.02764770f, 0.01383807f, 0.03559121f, -0.00409864f, 0.03473958f, 
    -0.02648154f, -0.02454905f, 0.02001353f, -0.04184810f, -0.04885676f, -0.03336754f, -0.00434108f, 0.02082314f, 
    0.03442917f, -0.05021182f, -0.01293685f, 0.00780052f, 0.02715340f, -0.04691826f, -0.03739910f, -0.02211186f, 
    0.03568766f, 0.01021211f, 0.01412987f, 0.00352471f, -0.04023285f, 0.03550354f, 0.02564621f, -0.00810309f, 
    -0.02948843f, -0.05477580f, -0.01134423f, 0.00641777f, -0.00795295f, -0.04864687f, -0.03942644f, -0.00810789f, 
    -0.00372547f, -0.01356551f, -0.04153801f, 0.01457180f, -0.02311536f, 0.02023913f, 0.03382075f, 0.02566882f, 
    -0.00453570f, -0.01125156f, -0.04437242f, 0.01394714f, 0.03858041f, 0.00898574f, -0.03125510f, 0.03798602f, 
    0.03543664f, -0.05542363f, -0.03867053f, -0.00540802f, -0.04008076f, 0.03390533f, 0.01204682f, 0.00425831f, 
    -0.00584482f, 0.03952944f, 0.05070265f, -0.01067334f, -0.04812051f, -0.02765420f, -0.04486677f, -0.01421346f, 
    -0.03455093f, -0.00329202f, -0.04100074f, -0.02241330f, -0.04831610f, -0.01330576f, 0.01742046f, 0.00322586f, 
    0.01197696f, -0.00112640f, 0.02873417f, -0.03055016f, -0.04828788f, 0.01894692f, 0.02943452f, -0.05063489f, 
    -0.01374053f, -0.01536005f, -0.05028946f, 0.00089786f, -0.01525144f, 0.00360596f, 0.04083864f, 0.04533584f, 
    -0.00798891f, 0.00705669f, -0.00891882f, 0.00049406f, -0.00415639f, -0.03478716f, -0.04483903f, -0.03937875f, 
    0.03978777f, -0.03633238f, -0.01746908f, -0.03513519f, -0.00234520f, 0.04030013f, 0.04519203f, 0.00660683f, 
    0.03365646f, -0.04094482f, -0.00488360f, 0.00916609f, 0.05101635f, -0.00348987f, -0.00022824f, 0.02580783f, 
    -0.00228100f, -0.05053749f, -0.04729033f, 0.00575643f, -0.00843628f, 0.00667588f, 0.01944797f, -0.01959543f, 
    -0.03472601f, -0.01800698f, -0.00123171f, -0.00968133f, 0.01170023f, 0.01013371f, 0.00238925f, -0.01197589f, 
    0.02600869f, -0.04799123f, -0.02455002f, -0.03968981f, 0.04404711f, -0.01362746f, 0.04298577f, -0.00400529f, 
    -0.03410240f, -0.05065046f, 0.04034119f, -0.04457597f, -0.03335818f, -0.01066839f, -0.02019705f, 0.04702801f, 
    0.00684822f, -0.04555722f, 0.01052064f, -0.00466909f, -0.01781755f, 0.00966848f, -0.00708710f, -0.01577674f, 
    -0.01942205f, 0.03664548f, -0.04370150f, 0.04982559f, 0.02231825f, -0.04846098f, -0.02855668f, 0.03391193f, 
    -0.01948131f, -0.03910638f, -0.03468599f, 0.02866854f, 0.01097013f, -0.01857572f, 0.02092155f, -0.00506673f, 
    0.02103964f, -0.01076027f, -0.05585173f, -0.00760486f, 0.02708340f, 0.00185696f, -0.02020792f, -0.00222768f, 
    0.03582551f, 0.04420437f, -0.01913172f, -0.00423397f, -0.02443062f, -0.01515470f, -0.00987316f, 0.03851707f, 
    0.01822979f, -0.04322730f, 0.03934823f, -0.02253933f, -0.00597641f, -0.02340592f, 0.04528261f, 0.02089063f, 
    -0.01540516f, -0.03464252f, -0.04770600f, 0.04285210f, 0.03386002f, -0.03200492f, 0.02290369f, -0.02343365f, 
    0.00195437f, 0.01487532f, 0.03967507f, 0.03763772f, 0.02635021f, 0.03781397f, -0.03404276f, -0.05042387f, 
    -0.02542362f, 0.01883752f, -0.05452108f, -0.04001794f, -0.05279461f, -0.05504964f, -0.00789424f, 0.01352040f, 
    0.00149748f, 0.04200741f, -0.05241584f, -0.04271010f, -0.05463868f, -0.00241766f, 0.02036665f, -0.04141824f, 
    -0.04377819f, 0.03007795f, 0.02720514f, 0.03041126f, 0.01106272f, -0.01267660f, -0.03573369f, -0.00322108f, 
    -0.03320626f, -0.03358398f, -0.05235206f, -0.05129128f, -0.01316720f, 0.00019418f, 0.05046777f, 0.03608156f, 
    -0.03739982f, -0.02668144f, -0.00783312f, -0.04767257f, 0.03622203f, -0.03691774f, -0.05148603f, 0.03707771f, 
    0.32974961f, 0.25174215f, 0.10939766f, 0.32807222f, 0.03880492f, 0.20974697f, 0.07307054f, -0.01151631f, 
    0.01705276f, -0.08003398f, -0.14530218f, -0.10120263f, -0.11184379f, -0.05054415f, 0.05607058f, 0.12319338f, 
    0.04883885f, -0.04844234f, -0.20571461f, -0.07866295f, -0.03721701f, 0.00599877f, 0.00124070f, 0.04585587f, 
    0.14673753f, 0.22215728f, -0.02653468f, -0.17506263f, -0.09924316f, 0.17954570f, -0.06345165f, -0.04058759f, 
    -0.07130570f, -0.05159128f, -0.04510450f, -0.00548065f, -0.12797005f, -0.12069780f, -0.08120672f, -0.06557185f, 
    0.01394220f, -0.05630606f, -0.06595569f, 0.00395696f, -0.05579898f, 0.18736814f, 0.15858355f, 0.19936912f, 
    -0.19301045f, 0.12704787f, 0.04499065f, 0.27831796f, 0.23102333f, 0.05690193f, 0.15369768f, 0.03490834f, 
    -0.14230256f, -0.02918465f, -0.02539944f, 0.14043374f, -0.28484091f, -0.25205252f, -0.03645435f, -0.03552254f, 
    0.00047738f, 0.03833559f, 0.02125756f, 0.03559737f, -0.04799119f, -0.06698962f, -0.03701930f, 0.02204871f, 
    -0.17569882f, 0.03561859f, -0.02149534f, 0.02743197f, -0.08436176f, 0.02532724f, -0.01292935f, -0.00740866f, 
    0.13885605f, 0.06650744f, 0.06747116f, -0.01193527f, 0.00570476f, 0.34976998f, -0.22028308f, 0.07045868f, 
    0.20839560f, -0.14627425f, -0.10668354f, 0.04058858f, -0.02043904f, 0.12509543f, 0.09213506f, 0.11563827f, 
    0.07508751f, -0.00165425f, 0.16055983f, 0.30101588f, -0.03927401f, 0.22455998f, 0.07069819f, 0.14176279f, 
    0.07514186f, 0.02262558f, 0.07924145f, 0.06013129f, -0.03547025f, 0.23061891f, -0.26590419f, -0.22353142f, 
    -0.03007827f, -0.06446686f, -0.08619993f, 0.03855657f, 0.02711416f, 0.12186472f, -0.11817081f, -0.06085575f, 
    -0.04000309f, 0.16532415f, 0.07779347f, 0.43785679f, 0.01790222f, 0.14363757f, -0.21761735f, 0.07266925f, 
    0.00253215f, -0.11293923f, 0.07692183f, -0.22489251f, -0.26418465f, 0.15956488f, -0.03719048f, -0.04931009f, 
    0.01724314f, -0.06292073f, -0.09933375f, -0.02406152f, -0.06175679f, -0.04144863f, -0.10342240f, 0.01077309f, 
    -0.29464644f, 0.11693612f, 0.13177128f, 0.20616396f, -0.09645613f, 0.17790323f, 0.09289800f, 0.03512424f, 
    0.04602920f, -0.07250513f, -0.02553043f, -0.00894455f, 0.00594381f, -0.31417772f, -0.03135581f, 0.17303151f, 
    -0.09179614f, 0.03518663f, -0.01060514f, 0.05846922f, 0.17204700f, -0.12093336f, -0.04341347f, -0.11947279f, 
    -0.34186396f, 0.11216303f, 0.18527515f, 0.06105040f, 0.03773046f, -0.05337626f, -0.10675629f, 0.04527291f, 
    0.00702648f, -0.02985129f, 0.04232807f, -0.05033235f, -0.04729622f, -0.04304196f, -0.04285456f, 0.17891744f, 
    -0.02776420f, -0.07412450f, -0.13295329f, -0.03572083f, 0.12226734f, -0.01961185f, 0.00228661f, 0.20721158f, 
    -0.13980827f, 0.08848128f, 0.15895398f, 0.25357935f, 0.02013419f, 0.05036172f, 0.15436311f, 0.07473150f, 
    0.09845178f, 0.02297783f, 0.05098264f, -0.00957905f, 0.08551545f, 0.15781371f, 0.18613254f, 0.40207714f, 
    -0.02073167f, 0.05623312f, -0.09648513f, 0.02262677f, -0.02080083f, -0.12073094f, 0.07863520f, -0.04438588f, 
    -0.02788949f, -0.05590664f, -0.07306174f, -0.12629610f, 0.06177116f, -0.02160048f, 0.10317290f, 0.01707298f, 
    -0.04698415f, 0.06908765f, 0.03034509f, 0.03396344f, -0.03241142f, -0.03831581f, 0.01982245f, 0.19575489f, 
    0.02121851f, -0.10625362f, 0.02431648f, -0.01977121f, -0.04458324f, -0.04003607f, -0.05729074f, -0.06955544f, 
    0.01269861f, 0.16523172f, 0.00553151f, -0.06285404f, 0.00479711f, 0.09732576f, -0.08733274f, 0.06688955f, 
    -0.03158114f, 0.00001144f, 0.03506644f, 0.06058599f, -0.03203961f, -0.06825519f, -0.16872141f, -0.05231679f, 
    -0.05215795f, 0.00013533f, 0.05528263f, 0.01810764f, 0.11272471f, 0.10869568f, 0.28385711f, 0.12556632f, 
    0.44417378f, 0.00329489f, 0.10718909f, 0.16511217f, 0.11004310f, 0.11647524f, -0.12648970f, 0.08793727f, 
    0.04949591f, 0.05819431f, -0.06309765f, 0.02562680f, -0.19269429f, -0.11144322f, -0.17272598f, 0.06724243f, 
    -0.07322530f, 0.08720157f, 0.01072193f, -0.05198548f, -0.05021246f, 0.02389538f, 0.07480191f, -0.00535599f, 
    0.23264021f, -0.16740212f, -0.13105099f, -0.05220740f, -0.05107670f, -0.01145423f, -0.00042076f, -0.03241132f, 
    0.01362126f, 0.04626434f, 0.05057423f, 0.07014742f, -0.21188839f, -0.07101670f, -0.09156208f, -0.09583192f, 
    0.03782992f, 0.04117275f, -0.01292760f, -0.14219910f, 0.11290907f, -0.02410623f, -0.14178747f, -0.24150665f, 
    -0.12668301f, -0.09261908f, -0.21953653f, 0.04605667f, 0.12910821f, -0.04447537f, 0.07827475f, -0.06683588f, 
    -0.02562500f, 0.07341823f, 0.09734847f, 0.11601302f, -0.19782524f, 0.08229971f, 0.10477951f, 0.06104435f, 
    -0.01139607f, 0.05140013f, -0.07856502f, -0.03107186f, 0.05947841f, 0.17729656f, 0.00188463f, 0.13645893f, 
    -0.06582342f, -0.03501408f, 0.12712361f, -0.00555221f, 0.03442883f, 0.09570226f, -0.05099948f, 0.08213106f, 
    0.04513305f, 0.08439834f, 0.02623543f, 0.02609587f, -0.12863973f, 0.00911176f, -0.03892271f, -0.05049735f, 
    -0.05482170f, 0.02300086f, -0.08316387f, 0.10616327f, 0.16764513f, -0.10514565f, -0.14287156f, -0.06798431f, 
    0.01219200f, -0.09257253f, -0.10030086f, -0.04863217f, 0.03695473f, -0.07644269f, 0.00790410f, 0.14305060f, 
    0.02042718f, 0.12140740f, -0.04702321f, -0.07646135f, -0.04074019f, 0.16658908f, 0.09438178f, -0.08010236f, 
    -0.01999672f, 0.08466277f, -0.13054855f, 0.07841223f, -0.06620469f, -0.16322111f, 0.08783147f, -0.08973977f, 
    -0.03515235f, 0.16404127f, -0.14676200f, -0.19227120f, -0.06307687f, -0.07540233f, 0.19176318f, 0.21341223f, 
    0.10467093f, -0.17636679f, 0.19535565f, 0.07888578f, -0.32373205f, 0.08994593f, 0.14817846f, -0.06832869f, 
    0.25903544f, 0.05313534f, -0.04469378f, 0.13031802f, 0.08890352f, 0.03452978f, -0.01753419f, -0.07666472f, 
    0.33580726f, -0.12871054f, 0.10726618f, -0.22175063f, -0.15789522f, 0.08420389f, 0.32675049f, 0.07914878f, 
    -0.08782727f, 0.02280387f, -0.16786289f, -0.02955382f, -0.16727409f, -0.03068148f, 0.01701944f, -0.05949486f, 
    -0.10847186f, 0.04603993f, -0.16541313f, -0.16697948f, 0.23268077f, 0.13362369f, 0.06868909f, 0.06370949f, 
    -0.00175995f, 0.19380608f, -0.03487568f, -0.36042547f, -0.12282458f, 0.12659307f, -0.04755792f, 0.15509619f, 
    0.12188835f, 0.10757635f, 0.01433739f, 0.05695026f, 0.13165659f, -0.12958705f, -0.43462256f, 0.04195395f, 
    -0.04731870f, -0.12364645f, -0.14679797f, -0.34899279f, 0.01868065f, -0.01423092f, 0.07210271f, -0.02892065f, 
    0.20293008f, 0.30916888f, 0.21250105f, -0.01364066f, 0.12833185f, -0.04447394f, 0.03267505f, -0.02685616f, 
    0.01231794f, 0.05765819f, -0.05245694f, 0.02720587f, -0.20511772f, 0.13421124f, 0.47380570f, 0.05230788f, 
    0.10585207f, 0.09774258f, -0.19540715f, -0.01571929f, 0.16043384f, -0.17488639f, 0.17649107f, 0.08923370f, 
    0.04313817f, 0.19776982f, 0.02970883f, -0.26218051f, 0.09821279f, -0.12257592f, -0.06292742f, 0.10317370f, 
    -0.03078786f, 0.04914057f, 0.08150696f, 0.12770100f, 0.41163966f, -0.32244968f, 0.16987589f, -0.02831868f, 
    -0.13317455f, 0.06887037f, 0.03004338f, 0.22757196f, 0.07131261f, 0.23380587f, 0.02378900f, 0.21650784f, 
    0.22957462f, -0.04734709f, 0.07129806f, -0.16083187f, 0.01743773f, 0.03248770f, -0.15688276f, -0.02270893f, 
    -0.01387678f, -0.01080830f, 0.03324347f, 0.16783360f, 0.27095082f, -0.33083177f, 0.20096974f, 0.21471781f, 
    -0.18125086f, -0.02976279f, -0.03204595f, -0.04285999f, -0.01972281f, -0.09481944f, 0.06901678f, 0.02577443f, 
    0.29741102f, -0.51696855f, -0.06465362f, -0.04036211f, 0.14169084f, -0.08726618f, 0.04882357f, 0.13083270f, 
    -0.17254844f, -0.06001149f, 0.06691172f, -0.07983813f, -0.08999428f, -0.14590013f, -0.19555612f, -0.20793237f, 
    -0.07166571f, 0.09602319f, -0.12090512f, 0.03893398f, -0.15297054f, 0.08430406f, -0.19485596f, 0.00126398f, 
    0.36952856f, 0.24456508f, 0.04977507f, 0.31436554f, 0.09705147f, 0.01272014f, -0.03583094f, 0.01333261f, 
    -0.08857436f, -0.02601961f, 0.07869782f, 0.01534133f, 0.10120450f, 0.23981167f, 0.20334274f, 0.26411849f, 
    -0.00542699f, 0.00418246f, 0.05393847f, -0.10952388f, -0.06234599f, 0.10536680f, -0.00232376f, -0.04182864f, 
    0.22206639f, -0.20043962f, -0.24566296f, -0.35292611f, -0.06377254f, -0.00880934f, -0.07964350f, 0.00745788f, 
    -0.02549892f, 0.05132253f, 0.04257689f, -0.03942067f, 0.24067727f, 0.12775452f, 0.11222265f, -0.21823736f, 
    0.14063282f, -0.05488678f, 0.07099391f, 0.07913093f, -0.11232059f, -0.04533044f, -0.00234035f, 0.03188746f, 
    -0.06454133f, -0.14613470f, 0.04812002f, 0.02205354f, -0.13687097f, 0.20368385f, -0.11213467f, -0.01578752f, 
    0.11032581f, -0.19650203f, 0.10595970f, -0.06125917f, 0.27093622f, 0.29357147f, 0.12213162f, -0.15444297f, 
    -0.10314412f, 0.00304989f, 0.04546078f, 0.14551046f, -0.05302524f, 0.02275020f, -0.05881154f, -0.07760187f, 
    0.21547879f, 0.01373785f, 0.04302575f, -0.13377774f, -0.06498446f, -0.11481402f, 0.06161620f, 0.02206418f, 
    0.12957251f, -0.00626071f, 0.06606532f, -0.02568543f, 0.04217137f, -0.08232230f, -0.11950215f, 0.17459837f, 
    -0.10421629f, 0.00937895f, -0.17201914f, -0.07972919f, 0.16883476f, -0.11830423f, -0.03141484f, 0.00992380f, 
    0.38242182f, -0.33701527f, 0.21098930f, 0.10334337f, 0.19878721f, -0.19546990f, 0.03717135f, -0.19029024f, 
    0.05891113f, -0.01600722f, -0.12743406f, -0.04869742f, 0.42880797f, 0.22828883f, 0.07038879f, -0.31082538f, 
    0.00772222f, -0.00829529f, 0.13522530f, 0.06230925f, 0.03488498f, 0.01182807f, -0.00070143f, -0.05524478f, 
    -0.30240467f, 0.16209190f, -0.01185599f, 0.10078819f, 0.17250688f, 0.09768677f, -0.01993012f, -0.05308915f, 
    0.01828180f, 0.02966219f, 0.04692747f, 0.00490981f, 0.05268182f, 0.04639590f, 0.08974854f, 0.23196131f, 
    0.09902599f, 0.05811192f, -0.03176242f, -0.02919924f, -0.09055304f, -0.01246287f, 0.08396882f, 0.05988000f, 
    0.04768502f, 0.06789263f, 0.00676298f, 0.27028224f, -0.28969410f, -0.00977873f, -0.02239704f, 0.03687664f, 
    -0.03656870f, 0.18139243f, -0.03452754f, -0.03508507f, 0.02758937f, 0.08933236f, -0.18050751f, 0.02500414f, 
    0.03465019f, -0.03064098f, 0.15699024f, 0.08468054f, -0.02573435f, 0.07147737f, -0.16993523f, 0.03600619f, 
    0.06591389f, 0.09089913f, -0.11081167f, 0.11393677f, 0.06638761f, -0.16402027f, -0.01684836f, -0.03567270f, 
    -0.04467810f, -0.08037785f, 0.04911865f, -0.02056413f, -0.09233581f, 0.02378403f, 0.06063645f, 0.14978853f, 
    -0.06164475f, -0.04319470f, 0.06999858f, -0.00343919f, -0.07447132f, -0.01392658f, 0.03884535f, 0.06149322f, 
    0.04289789f, -0.01320949f, 0.18046282f, 0.12098888f, 0.13221876f, -0.04132797f, 0.07030779f, -0.24849391f, 
    0.19836876f, 0.07306234f, 0.00690296f, 0.02119319f, 0.26300326f, 0.03028302f, -0.05702540f, -0.08215259f, 
    0.08256357f, -0.04283357f, 0.06167036f, 0.04287324f, -0.02081700f, 0.00784996f, -0.06728352f, -0.13397415f, 
    -0.32925293f, 0.14939572f, 0.25707752f, 0.47862753f, 0.16148452f, -0.10446125f, 0.05031702f, -0.05998094f, 
    -0.06794023f, -0.08362179f, 0.00195488f, 0.07032841f, 0.55440277f, -0.03373725f, 0.14206304f, -0.31030378f, 
    0.08817846f, -0.00519392f, 0.12774594f, 0.07899013f, 0.18780181f, 0.12235909f, -0.10813105f, 0.05476252f, 
    -0.68340272f, -0.20418413f, -0.07122561f, 0.35156125f, -0.19865116f, 0.09302671f, -0.01920110f, 0.13447478f, 
    0.15315810f, -0.09496277f, 0.18116058f, -0.03819119f, 0.01799555f, -0.05060898f, 0.00837550f, -0.04462137f, 
    -0.01821692f, -0.04661483f, 0.07595599f, -0.06914045f, 0.14011437f, 0.07762624f, 0.06292640f, -0.00696196f, 
    0.07516378f, 0.23116083f, 0.13992882f, -0.01335107f, 0.10639391f, -0.02543087f, 0.10926609f, 0.07103109f, 
    0.10406631f, 0.03993043f, 0.13115527f, 0.01202821f, -0.46788263f, 0.04655665f, 0.12594883f, -0.12134121f, 
    -0.01392205f, -0.18132891f, -0.10477019f, -0.14651540f, -0.18534566f, 0.05819459f, 0.02101863f, 0.07859274f, 
    -0.10501336f, 0.02646792f, 0.08363140f, 0.11027221f, -0.06830890f, -0.01965353f, -0.04338206f, -0.10109413f, 
    -0.01012836f, 0.02545105f, 0.07405069f, 0.06806906f, -0.01764346f, 0.08492475f, -0.01343714f, 0.03257605f, 
    -0.22796369f, -0.01458325f, 0.11780089f, -0.11556587f, 0.22329311f, 0.08756612f, -0.05397980f, -0.03127782f, 
    -0.16040412f, 0.05623099f, -0.10921399f, 0.05040497f, -0.20103197f, -0.06324620f, 0.15380679f, 0.05113938f, 
    -0.00076578f, -0.04566692f, -0.09824836f, -0.05618046f, 0.32759282f, 0.12017166f, -0.01542455f, 0.14602965f, 
    0.11406015f, 0.20245419f, -0.01897340f, -0.00944030f, 0.02496612f, 0.08054421f, 0.06090690f, 0.11579639f, 
    0.27968097f, -0.13664839f, -0.00431805f, -0.28303844f, -0.23410620f, 0.02060091f, 0.00535524f, -0.07626716f, 
    -0.01985798f, 0.03984475f, 0.04350101f, 0.05477435f, 0.29114440f, 0.32926169f, -0.04730999f, 0.16139421f, 
    0.03069351f, -0.02702103f, -0.02243025f, 0.01812908f, -0.00873040f, 0.03224860f, 0.19484068f, -0.07101811f, 
    -0.10660467f, 0.53304547f, 0.21927342f, 0.25232986f, 0.14173663f, -0.03087689f, 0.02596316f, 0.21396329f, 
    -0.00948669f, 0.02246549f, 0.07314118f, -0.10811596f, -0.00133269f, 0.15126438f, 0.37741372f, -0.15313874f, 
    -0.15323868f, -0.11103110f, 0.02815866f, 0.06127523f, -0.05129582f, 0.02652455f, -0.10039330f, -0.03362979f, 
    0.37157777f, 0.00293493f, -0.09452300f, -0.02328512f, -0.12558031f, -0.01812857f, 0.04327489f, -0.03370770f, 
    0.01974514f, 0.04485191f, -0.05795326f, 0.01519020f, 0.30174500f, -0.03732092f, 0.13598789f, 0.05096322f, 
    -0.11021142f, 0.02488053f, -0.03760873f, 0.01455318f, -0.01162588f, 0.09219259f, 0.14681171f, -0.00887518f, 
    -0.20198704f, 0.28725314f, 0.19220653f, -0.16884159f, -0.02758982f, -0.22125104f, -0.10668892f, -0.08180322f, 
    -0.04235289f, 0.13870318f, -0.06209633f, -0.05521383f, -0.14755556f, -0.07342242f, -0.06591082f, -0.10933815f, 
    0.02750475f, -0.06870905f, -0.00843270f, -0.29873201f, -0.04057135f, -0.00655017f, 0.02316530f, 0.11766686f, 
    -0.15960884f, -0.03209806f, -0.05725297f, 0.09630127f, -0.05302343f, 0.16472240f, 0.05215195f, 0.06653146f, 
    0.28227314f, 0.13778746f, 0.01014996f, -0.05651971f, -0.35341451f, -0.26927000f, -0.02931238f, -0.04598585f, 
    -0.15484436f, -0.05217147f, -0.09840428f, -0.19235279f, -0.09075255f, -0.01438395f, -0.03255672f, 0.01142133f, 
    -0.48563173f, -0.06319141f, -0.08969682f, 0.30620471f, -0.11074115f, -0.05764181f, -0.13975717f, 0.07418326f, 
    -0.00688173f, 0.13426022f, -0.04631622f, 0.09107881f, -0.20789707f, -0.08059458f, 0.13661468f, 0.19269146f, 
    0.01012996f, -0.06720164f, -0.08895858f, 0.15955231f, 0.10986088f, 0.03600490f, 0.08869352f, 0.11901446f, 
    -0.64177066f, 0.58943456f, -0.12417962f, 0.41416803f, 0.03383771f, 0.10869765f, -0.03357462f, 0.28750944f, 
    -0.00390492f, 0.02875185f, 0.09160587f, 0.14795955f, -0.07048705f, 0.07846461f, 0.20215201f, 0.11840869f, 
    0.01472117f, -0.02481273f, 0.03287719f, 0.02530164f, -0.05793004f, 0.05449997f, 0.00944277f, 0.07448552f, 
    -0.47455347f, 0.04185107f, -0.15652211f, 0.10534920f, -0.03458217f, -0.08929063f, 0.07056854f, 0.27055699f, 
    -0.08125073f, -0.02189175f, -0.03948797f, -0.13467070f, 0.19702597f, 0.08962543f, -0.05879384f, -0.01723484f, 
    -0.09017316f, -0.05753114f, 0.02615091f, 0.00825787f, 0.09562245f, 0.05108492f, 0.16666129f, -0.00389334f, 
    -0.32775676f, -0.01237038f, 0.06977487f, 0.35100228f, 0.08525046f, -0.05153231f, -0.01016935f, -0.13095453f, 
    0.00645241f, 0.21757980f, 0.07301906f, -0.00884377f, 0.41703248f, 0.12734976f, 0.16100532f, 0.11036737f, 
    0.19917807f, 0.03776160f, -0.02969376f, 0.11615534f, 0.07870387f, 0.01284593f, 0.04451086f, 0.12723306f, 
    0.20883551f, 0.00392724f, -0.02568980f, -0.06750338f, 0.03264984f, 0.07373017f, 0.10765669f, -0.02906607f, 
    -0.14845848f, 0.01695775f, -0.00643792f, -0.08617733f, 0.38906416f, -0.04755580f, -0.00562796f, -0.14634910f, 
    -0.03902293f, -0.06139779f, 0.15148537f, -0.01996551f, 0.19802164f, 0.27733669f, 0.07303630f, -0.01619938f, 
    -0.52962255f, 0.00655497f, -0.04298256f, 0.29226598f, 0.00068176f, -0.01314374f, 0.04537737f, 0.21046405f, 
    0.04516900f, -0.01257814f, 0.09382846f, -0.11554713f, -0.08442890f, 0.20329472f, 0.09569917f, 0.06758982f, 
    -0.01534120f, -0.05582719f, -0.02919534f, 0.02339016f, 0.09084491f, 0.10340756f, -0.00109793f, 0.01924978f, 
    -0.05363702f, 0.04204345f, -0.01816867f, -0.00701461f, -0.02195450f, 0.01391786f, -0.02852329f, 0.04344878f, 
    0.02038663f, -0.05305015f, -0.01151850f, 0.04263645f, 0.03494370f, -0.02733549f, 0.00254166f, -0.03602362f, 
    -0.04934505f, 0.00341825f, 0.03097917f, -0.01272767f, 0.02979120f, -0.03638711f, 0.03399840f, -0.04042479f, 
    -0.05280423f, 0.02372689f, 0.02181725f, 0.00691896f, 0.03917251f, 0.02824513f, 0.03017174f, -0.03516653f, 
    0.01095322f, -0.03083230f, -0.04975485f, -0.01299677f, 0.02822732f, -0.04781360f, 0.00174946f, 0.03382877f, 
    -0.04521447f, 0.03808626f, -0.03195089f, -0.02304367f, 0.03918695f, 0.03673074f, 0.02211354f, -0.04131366f, 
    -0.01230102f, -0.04939843f, -0.00981695f, 0.03605569f, -0.01894393f, -0.00975152f, -0.01559593f, -0.04038169f, 
    -0.01668199f, -0.04517158f, -0.01575841f, 0.01315758f, 0.01251959f, -0.03482117f, -0.04145247f, 0.03178508f, 
    -0.00253364f, 0.02374864f, 0.02479465f, -0.03130424f, -0.04431023f, -0.03558419f, -0.04629441f, 0.04269793f, 
    0.00716662f, -0.04183926f, -0.00244510f, -0.00479200f, 0.02566931f, -0.00080438f, -0.04567076f, -0.03575995f, 
    -0.00642242f, 0.01205139f, 0.01158059f, -0.05091791f, -0.03358419f, -0.00080078f, -0.01476385f, -0.00167590f, 
    0.02226586f, -0.00789424f, -0.00532264f, 0.04408434f, -0.05465591f, 0.01108327f, 0.04314706f, -0.01386451f, 
    -0.02591854f, -0.04444597f, -0.04240394f, 0.03819668f, 0.03725520f, 0.00970682f, -0.00515981f, -0.01005364f, 
    -0.04216821f, 0.01362805f, -0.01081741f, 0.01831257f, 0.02436611f, -0.05286806f, -0.04136983f, 0.00252349f, 
    0.00016624f, -0.02437490f, 0.02560575f, -0.01185411f, 0.00977035f, 0.02000745f, 0.00649531f, 0.03757872f, 
    0.00062971f, -0.03359548f, -0.01188446f, -0.02341504f, -0.01097304f, -0.01581482f, 0.01512786f, -0.05329482f, 
    -0.04367582f, 0.03810958f, -0.03972476f, 0.04397476f, 0.00765708f, -0.03624278f, 0.01425024f, 0.03724847f, 
    0.01249551f, -0.01375936f, -0.02106800f, -0.00247675f, 0.04167312f, 0.04130427f, -0.03601738f, 0.01609219f, 
    0.01731080f, -0.05167587f, 0.03219825f, -0.01566505f, -0.05467132f, -0.03096728f, 0.03807523f, -0.01892080f, 
    -0.00897764f, -0.01778007f, 0.02866674f, -0.02972405f, 0.02449889f, 0.02237293f, 0.00049806f, -0.03890040f, 
    -0.03053067f, -0.04848785f, -0.02172492f, -0.05510672f, -0.04684060f, 0.00486069f, 0.01791714f, -0.02239574f, 
    -0.03786462f, -0.03618470f, -0.00611653f, -0.04101534f, 0.02521487f, 0.00649820f, -0.03698174f, -0.04494407f, 
    -0.01735125f, 0.00121238f, -0.05326131f, -0.04126370f, -0.05480497f, 0.01555405f, -0.03290594f, 0.04097596f, 
    0.01956682f, -0.01447945f, 0.00856071f, -0.01759720f, -0.05227798f, -0.00363358f, -0.02981190f, -0.01173895f, 
    0.04081040f, 0.02122322f, -0.00850860f, -0.04825483f, -0.03908370f, 0.03290666f, 0.04062914f, -0.05205151f, 
    -0.03139882f, -0.00028209f, -0.01140818f, -0.02749074f, -0.04705950f, -0.00370661f, -0.02242455f, 0.01981649f, 
    -0.04414795f, -0.00163574f, -0.02044984f, 0.03871088f, -0.02328175f, 0.00832567f, 0.03605090f, -0.01400171f, 
    0.01555971f, -0.04937862f, -0.01873701f, 0.03216925f, -0.00925925f, 0.04095400f, -0.01117538f, 0.04033030f, 
    -0.01868039f, -0.00380970f, -0.03303104f, -0.05165682f, -0.04024992f, 0.01654104f, -0.02876979f, 0.02658635f, 
    0.00962058f, -0.02973706f, -0.05056343f, -0.00068704f, -0.05341071f, 0.01484785f, 0.00780133f, -0.04210843f, 
    0.03277124f, 0.04315146f, -0.01460041f, 0.01878937f, 0.03016077f, 0.02371954f, -0.02869236f, -0.02659630f, 
    -0.02191300f, -0.05344176f, -0.03404404f, 0.03481884f, 0.00889502f, -0.04746840f, 0.01053633f, 0.02891583f, 
    -0.05384319f, -0.04531338f, -0.03240607f, 0.00642718f, -0.01650758f, 0.00425112f, -0.04625501f, -0.00441473f, 
    0.02244179f, -0.05353137f, -0.00460818f, 0.00969607f, 0.01961410f, -0.01376694f, 0.01580844f, -0.04182678f, 
    0.03511768f, -0.05387335f, 0.03254491f, -0.01601456f, 0.00593311f, -0.01651511f, -0.01450405f, -0.02376921f, 
    -0.03621613f, 0.00223663f, -0.00554202f, -0.02494583f, 0.02411755f, 0.03672078f, 0.03277662f, -0.03389738f, 
    0.01338896f, -0.03749850f, -0.00840089f, -0.04851858f, 0.04514840f, -0.03929752f, -0.04313111f, -0.04616918f, 
    0.03364105f, 0.00483324f, -0.03716434f, 0.03790883f, -0.02288822f, 0.04102954f, -0.01980550f, 0.00483713f, 
    -0.01293341f, -0.05009437f, -0.01973496f, 0.03513732f, -0.04185368f, 0.00242522f, 0.00137331f, -0.05459038f, 
    -0.03741689f, 0.01671289f, -0.02306469f, -0.02882274f, 0.04348235f, 0.01756487f, -0.00567412f, -0.00073243f, 
    -0.04713814f, -0.04980125f, 0.00032541f, 0.00681902f, -0.05198400f, 0.04433891f, 0.00137672f, -0.03522877f, 
    0.00709828f, -0.03914748f, -0.00818669f, 0.03810440f, -0.01871119f, 0.01977034f, -0.00424302f, 0.04142219f, 
    0.01817471f, 0.01548105f, -0.00519451f, 0.01834999f, 0.04536757f, 0.01381110f, 0.00170962f, 0.00890893f, 
    -0.00526111f, 0.00056598f, 0.01487320f, 0.01787889f, 0.02361908f, 0.01370691f, -0.04367741f, 0.00092706f, 
    0.03815728f, 0.04070804f, -0.01041101f, -0.01668998f, 0.03477344f, -0.05337178f, 0.02031178f, 0.02238274f, 
    -0.04590558f, -0.01946413f, -0.04835366f, 0.00724643f, -0.04011792f, 0.01933110f, -0.03231617f, 0.00626878f, 
    -0.02377132f, 0.03566637f, -0.01882477f, -0.05113159f, -0.04087580f, 0.02006828f, 0.00982449f, 0.02547455f, 
    -0.01618102f, -0.02885902f, -0.02734654f, 0.02050036f, -0.05173365f, 0.00289967f, -0.04308248f, -0.00963882f, 
    0.06782218f, 0.32005909f, 0.22371647f, 0.01236777f, 0.02406797f, -0.04507187f, 0.07457633f, -0.03811664f, 
    0.05229087f, -0.15249166f, 0.00102409f, -0.10507280f, 0.00522609f, 0.07987051f, 0.04211821f, 0.08700953f, 
    0.14692682f, -0.10145123f, -0.04179155f, -0.08401912f, 0.09667296f, 0.01278920f, -0.00188970f, -0.10743984f, 
    0.06506291f, -0.05383053f, 0.38773173f, -0.06235098f, -0.22887112f, -0.00086294f, 0.11732494f, 0.07210868f, 
    -0.06983197f, -0.02319952f, -0.06151997f, 0.06485058f, -0.11818739f, -0.06602297f, -0.10425767f, -0.06578536f, 
    -0.03089592f, 0.04056933f, -0.12168106f, 0.04272531f, 0.12357923f, -0.01930577f, 0.02683026f, 0.09854634f, 
    0.01695835f, 0.30070060f, -0.05644497f, -0.18952557f, 0.00666223f, 0.00216765f, -0.04531150f, 0.03262743f, 
    -0.03406446f, -0.14074647f, 0.03073782f, -0.04969082f, -0.08852975f, 0.11426843f, -0.12513216f, -0.03386828f, 
    0.01845850f, -0.00967196f, -0.06500883f, -0.05108873f, 0.07624871f, 0.00574562f, 0.02227223f, 0.06287604f, 
    -0.01563146f, 0.34725940f, 0.28714067f, 0.03932140f, 0.08534916f, 0.01441017f, -0.02525713f, 0.08241706f, 
    -0.08994293f, -0.00397595f, 0.05889123f, -0.09227792f, -0.19086933f, -0.24196890f, 0.12010290f, 0.13228603f, 
    -0.03348327f, 0.00801420f, -0.05425286f, 0.16923322f, 0.12087734f, -0.07978235f, -0.11305330f, -0.15796718f, 
    0.15124075f, 0.28027824f, 0.37162137f, 0.20491070f, 0.12388370f, 0.01040569f, -0.01694880f, 0.15463442f, 
    0.02997280f, -0.02573940f, 0.03254829f, 0.01938438f, 0.03505322f, -0.29375842f, -0.37843889f, -0.16240880f, 
    0.03267168f, 0.03408589f, -0.04279957f, 0.00570215f, 0.00647073f, 0.13343190f, -0.04535319f, 0.00733170f, 
    0.39444304f, 0.20415244f, -0.09128057f, -0.20478524f, -0.01155349f, -0.14287911f, -0.14527975f, -0.05181304f, 
    -0.10655606f, -0.03511356f, 0.15234539f, -0.09473380f, 0.24570471f, -0.30006835f, -0.15521842f, -0.20708582f, 
    -0.04264640f, -0.05717701f, -0.02719184f, 0.03451424f, -0.11271448f, -0.25620204f, 0.01331867f, -0.07745538f, 
    0.24146560f, -0.08598842f, 0.23897210f, -0.00735876f, -0.03056359f, 0.05630814f, 0.16144565f, 0.03790475f, 
    0.07754397f, 0.05484332f, 0.05600549f, -0.05608461f, 0.31940615f, 0.14077918f, 0.17456254f, -0.13072921f, 
    -0.05093952f, 0.07269967f, 0.02050948f, 0.09085357f, 0.02111502f, 0.08311468f, -0.00760952f, -0.07229759f, 
    0.06189648f, -0.23762952f, -0.22298016f, -0.16674787f, -0.06330960f, -0.09595205f, -0.07377838f, -0.06112219f, 
    0.00717371f, -0.01685639f, 0.01875699f, 0.02249997f, 0.04009851f, -0.32590204f, -0.29158548f, 0.02128361f, 
    0.01338718f, -0.06326395f, 0.01838928f, 0.02913496f, 0.12713376f, 0.02678445f, -0.03822237f, -0.15152654f, 
    0.03830473f, 0.16246593f, 0.02489645f, -0.13109322f, 0.03318314f, 0.04797599f, -0.05008554f, -0.07605877f, 
    0.01303177f, -0.06597812f, -0.01570619f, -0.09851781f, 0.19593886f, 0.28345135f, 0.13455176f, 0.13676292f, 
    0.04633465f, -0.14778459f, -0.04394938f, -0.09522155f, -0.09376592f, 0.00093257f, -0.00205463f, 0.07334261f, 
    -0.16790013f, -0.02885384f, -0.14856386f, -0.01461432f, -0.06469914f, -0.03199517f, 0.12613022f, 0.05037290f, 
    0.04655175f, -0.06012564f, 0.03427362f, -0.10850640f, 0.13931575f, 0.32372099f, 0.33103812f, 0.20513062f, 
    -0.05428616f, 0.04269964f, -0.06037235f, 0.04333723f, -0.06461945f, -0.07596376f, 0.03136362f, 0.00961982f, 
    0.20204988f, 0.08723140f, 0.38941792f, 0.04798725f, -0.12424169f, -0.01858187f, -0.03183152f, 0.03667004f, 
    0.08527285f, -0.16459237f, 0.02188360f, 0.07745550f, -0.04385002f, -0.20119904f, -0.11127493f, 0.07265882f, 
    0.04948648f, 0.04413563f, 0.00181300f, -0.00143333f, 0.10932539f, 0.00687185f, 0.02933465f, -0.09256514f, 
    0.23837005f, -0.49264586f, 0.08428402f, -0.09618805f, 0.02630042f, -0.00158095f, -0.05169732f, -0.08829269f, 
    -0.00952374f, -0.07235045f, -0.03667189f, 0.08763489f, 0.10331710f, 0.23004848f, 0.16062421f, 0.04242502f, 
    0.00658394f, 0.16928299f, -0.03527718f, 0.10030273f, -0.09140331f, -0.06001386f, -0.16271070f, 0.14903218f, 
    -0.15562797f, 0.08336312f, 0.14639850f, 0.28588188f, 0.12841797f, 0.18292090f, 0.20737812f, -0.04351316f, 
    0.12056783f, 0.07909307f, 0.09283952f, -0.03677524f, -0.06462184f, -0.30635712f, -0.25958583f, -0.13959698f, 
    0.06677624f, 0.03237355f, -0.00415611f, -0.09091147f, -0.26798102f, -0.14261112f, -0.21537898f, -0.16754071f, 
    -0.24586657f, -0.01148386f, -0.07613314f, 0.07113631f, -0.06039114f, -0.02809790f, -0.00336851f, 0.04667920f, 
    0.17115487f, 0.06202301f, 0.03811293f, -0.05400785f, 0.10388034f, -0.00573599f, -0.15152292f, 0.01933485f, 
    0.07176336f, -0.05245466f, -0.01967700f, 0.13821292f, -0.01995003f, 0.07602870f, 0.12356691f, -0.02268714f, 
    0.04863359f, -0.09015130f, -0.11057909f, 0.00531054f, -0.01624978f, 0.02218876f, 0.05527806f, 0.00559595f, 
    0.07077708f, 0.02629614f, 0.04264453f, 0.05638235f, 0.26955101f, -0.04226981f, -0.14451291f, -0.10797665f, 
    -0.10285148f, -0.10252689f, 0.07714010f, -0.01345366f, -0.01870942f, -0.03391011f, -0.05228995f, -0.10046104f, 
    -0.25763530f, -0.13351902f, 0.03186639f, 0.15672967f, 0.01511158f, -0.02775671f, -0.02644089f, 0.01813960f, 
    -0.00820653f, -0.02960241f, -0.22308655f, -0.00268936f, 0.16636877f, 0.14217637f, 0.19439116f, 0.05101937f, 
    -0.06770130f, 0.05592264f, -0.00235685f, -0.00783306f, -0.13103984f, -0.13815355f, -0.05467328f, -0.16190232f, 
    0.04168629f, 0.16370665f, 0.11414196f, 0.32119763f, 0.01885981f, 0.20460927f, -0.00297119f, 0.01157098f, 
    0.01390040f, 0.06531831f, 0.01642299f, 0.04928009f, 0.15899535f, 0.11570779f, -0.05956580f, 0.05702064f, 
    0.10523882f, -0.02967100f, 0.31854871f, 0.05618375f, 0.06832434f, -0.10886598f, -0.06036216f, -0.08708709f, 
    -0.29758129f, -0.41137257f, 0.17606299f, 0.02290369f, 0.14801961f, 0.22450581f, 0.07400055f, 0.01058471f, 
    0.21440080f, -0.00042706f, 0.02102192f, 0.01749446f, -0.02510961f, -0.02091013f, -0.05798581f, -0.05672175f, 
    -0.11393700f, -0.05886271f, -0.02738223f, -0.04007712f, 0.01930530f, 0.12114277f, 0.18720278f, 0.28657511f, 
    -0.00533138f, -0.07820249f, 0.30956545f, 0.13782942f, 0.17867331f, 0.13624765f, 0.12029891f, 0.25800759f, 
    0.10911688f, 0.09904207f, -0.05620415f, -0.12830308f, 0.01762525f, -0.04935484f, 0.12356415f, -0.09533009f, 
    -0.11278645f, -0.15905765f, -0.09540761f, 0.00337198f, 0.12506439f, 0.03641829f, -0.04910691f, -0.02904612f, 
    -0.19807808f, -0.01283234f, -0.14522965f, 0.08151250f, -0.00261152f, -0.01426945f, -0.00909419f, -0.01953261f, 
    0.09988597f, 0.04345822f, 0.08242188f, -0.01414634f, 0.33723718f, 0.16259779f, -0.44260147f, 0.15390614f, 
    0.09674512f, 0.03611239f, 0.01147350f, -0.08321065f, 0.17151059f, 0.03722922f, 0.20945667f, 0.14408557f, 
    -0.18308520f, -0.19167933f, -0.15506434f, 0.12589617f, -0.11502133f, 0.07126109f, -0.02505811f, 0.17503268f, 
    0.11910192f, 0.08213369f, 0.06209606f, 0.03014702f, -0.10999639f, 0.08652976f, 0.49345350f, 0.09114803f, 
    -0.00618478f, 0.02640235f, 0.04505811f, 0.07144056f, 0.12981707f, -0.02441916f, -0.07714029f, -0.08795956f, 
    -0.13389686f, -0.09061838f, 0.01890451f, 0.23190826f, 0.01156891f, 0.07465272f, 0.02061030f, 0.10492796f, 
    0.04276672f, -0.08747996f, 0.03451819f, 0.00677091f, 0.09616145f, 0.27997801f, 0.32629746f, -0.03962912f, 
    -0.00998983f, -0.01944867f, -0.01166233f, -0.04503438f, 0.00083255f, -0.02233928f, 0.08576825f, -0.07148669f, 
    -0.18100581f, 0.06406380f, 0.45686761f, -0.02613040f, -0.15816186f, 0.21056861f, 0.07515164f, 0.32305017f, 
    0.15457778f, 0.09776608f, 0.05503211f, -0.00417453f, -0.19135922f, -0.06409343f, 0.40999278f, -0.04582230f, 
    -0.04669738f, -0.15432596f, 0.01388017f, 0.04200479f, -0.08609161f, -0.07185722f, -0.01085356f, 0.09692219f, 
    -0.19474313f, 0.05615930f, -0.04717658f, -0.15769500f, -0.10514540f, 0.01032346f, 0.00996961f, 0.00178873f, 
    0.00710552f, -0.02838497f, 0.02805963f, -0.06761403f, -0.09282876f, 0.07829394f, 0.12795481f, 0.09080502f, 
    -0.12527667f, -0.10124353f, -0.08737779f, -0.05036217f, 0.10226205f, -0.02583650f, 0.09321441f, 0.02120362f, 
    -0.14365532f, 0.05435439f, 0.28932205f, 0.04992309f, -0.15629257f, -0.10245334f, -0.07227297f, 0.16041119f, 
    0.09963182f, 0.06270265f, 0.14594689f, -0.00252397f, -0.33117053f, 0.00258399f, -0.02697092f, 0.15386803f, 
    0.18366894f, -0.05367083f, -0.01400949f, -0.03179850f, 0.07288253f, 0.02169310f, 0.06487347f, -0.00563551f, 
    0.07743964f, -0.03193033f, 0.10156883f, -0.10353671f, -0.07367365f, 0.01449621f, 0.01198824f, 0.10876040f, 
    0.01630058f, -0.03312973f, 0.06350634f, 0.00224850f, -0.36711964f, -0.26062599f, -0.02930303f, -0.03569096f, 
    -0.01767227f, -0.04708898f, -0.14379679f, 0.04109054f, 0.01135446f, 0.00597865f, -0.05162994f, -0.04424035f, 
    -0.24385774f, -0.18103908f, 0.10603347f, -0.01741748f, -0.12823646f, -0.01130538f, -0.07647879f, 0.21047808f, 
    0.04384345f, -0.01284410f, 0.13235210f, 0.05534654f, 0.15594088f, 0.06435402f, 0.15016788f, -0.08312324f, 
    -0.12068192f, -0.06876797f, -0.00629592f, 0.03188612f, 0.07823044f, 0.07947121f, 0.36013958f, 0.11685155f, 
    0.40651941f, 0.04489235f, -0.20065708f, 0.11367688f, 0.07752605f, 0.00698932f, 0.02696846f, 0.06272031f, 
    0.08183727f, 0.07060059f, 0.08326399f, 0.01613063f, -0.27875051f, -0.21450508f, 0.11677905f, 0.08104099f, 
    -0.03828351f, 0.06228477f, 0.05881403f, -0.04272252f, -0.02706999f, 0.12360041f, -0.05288547f, 0.06220994f, 
    0.19463968f, -0.22488791f, -0.09650090f, 0.13384643f, -0.04285041f, -0.11434670f, -0.00609351f, 0.06163497f, 
    0.05077075f, 0.07025110f, 0.09598406f, 0.18323049f, 0.20280831f, 0.07012026f, -0.09600581f, -0.09425545f, 
    -0.05940302f, -0.00849639f, -0.02728384f, -0.07034365f, 0.06953801f, -0.09431324f, -0.10175450f, -0.17615356f, 
    -0.05069389f, 0.08473061f, 0.13999124f, 0.16961309f, -0.04582197f, -0.11709852f, -0.01171563f, -0.01082431f, 
    0.15959276f, 0.03020770f, 0.10205270f, 0.14313303f, -0.12152867f, -0.08199216f, 0.25881639f, -0.12942588f, 
    0.18105026f, -0.00342572f, 0.04332633f, 0.03897417f, 0.03451164f, 0.09781432f, 0.15238218f, 0.14856187f, 
    -0.21267104f, 0.01523985f, 0.00196236f, -0.05353757f, 0.00663633f, -0.00758983f, 0.10159265f, -0.02389794f, 
    -0.00160758f, 0.04800941f, 0.07777835f, 0.06936010f, 0.03687976f, 0.11030819f, -0.07875352f, 0.01476962f, 
    0.06008693f, -0.02640233f, -0.04745717f, 0.05865717f, -0.06322098f, -0.00319979f, 0.00770768f, -0.01775640f, 
    0.04731578f, -0.03916454f, -0.01329364f, 0.15982378f, 0.10840548f, 0.09513433f, 0.06074518f, 0.13505326f, 
    0.12592570f, 0.10324473f, 0.06676397f, -0.14170663f, -0.21042953f, 0.07123495f, 0.00281523f, -0.14822561f, 
    0.02682598f, 0.11884965f, 0.07633488f, 0.07179804f, 0.10415618f, -0.00516923f, 0.02064831f, -0.24023654f, 
    0.03224235f, 0.01121988f, -0.09447365f, 0.19162180f, 0.10674608f, 0.22318786f, 0.16036865f, 0.12072518f, 
    -0.22825547f, -0.06130917f, -0.12138686f, -0.02492923f, 0.09934323f, -0.17298235f, 0.07443023f, -0.07472187f, 
    0.12766312f, -0.04958902f, 0.28244466f, 0.33614859f, 0.02107966f, -0.07737990f, 0.10188785f, -0.21751316f, 
    -0.21430279f, -0.03612580f, -0.14943328f, 0.06223746f, 0.10042080f, 0.15477389f, 0.01342552f, 0.00755204f, 
    0.12884608f, -0.03520311f, 0.05271933f, 0.05794692f, -0.22618435f, -0.19258580f, -0.07051893f, -0.04381691f, 
    -0.07502989f, -0.11191303f, 0.01474211f, -0.04973419f, 0.15024856f, 0.09623513f, 0.12628511f, 0.23041059f, 
    -0.10960578f, -0.32278621f, 0.24896467f, 0.01202492f, 0.13246270f, 0.08869620f, 0.31457609f, 0.35390076f, 
    0.03968073f, 0.04814226f, -0.10598013f, -0.09145874f, -0.53574020f, -0.20479971f, 0.10089593f, -0.28442088f, 
    -0.08363774f, 0.02591463f, -0.25194991f, -0.04365063f, -0.06087027f, 0.04863815f, -0.03031865f, -0.11485904f, 
    -0.01601141f, 0.01789975f, -0.15053315f, 0.07599072f, 0.00981889f, -0.12297622f, 0.00638135f, 0.10213407f, 
    0.08692094f, 0.19484794f, 0.03368586f, 0.10317251f, 0.86884731f, 0.41755790f, -0.63482416f, 0.13687269f, 
    0.02571671f, -0.18227859f, 0.04336252f, -0.28281146f, 0.13181140f, 0.11930881f, -0.06101921f, 0.02056966f, 
    -0.05782501f, -0.08446611f, -0.10987243f, 0.05519614f, -0.09266157f, -0.01583984f, 0.05027247f, 0.19082610f, 
    0.07725948f, 0.16744441f, 0.06741167f, 0.22997917f, 0.16296481f, 0.07580042f, 0.31386298f, 0.10531173f, 
    -0.16376169f, 0.03025177f, -0.19512442f, 0.08211626f, 0.08135341f, 0.05521825f, -0.01571854f, -0.07044700f, 
    0.02002111f, -0.19011705f, -0.10262314f, 0.47099584f, -0.17914681f, 0.13063325f, 0.03330231f, 0.01817065f, 
    -0.05241679f, 0.01389710f, 0.08787962f, 0.09146653f, 0.06267234f, 0.38480142f, 0.18048665f, 0.08556475f, 
    -0.05369576f, -0.02608973f, -0.13158852f, -0.10518156f, 0.01560710f, 0.00934722f, 0.13728561f, -0.27185810f, 
    -0.24392574f, 0.39492673f, 0.08264700f, 0.08146546f, 0.03062561f, 0.19257477f, 0.03983293f, 0.21997751f, 
    0.08312211f, 0.08011311f, -0.02067399f, 0.05759398f, -0.26461715f, -0.00784300f, 0.16546147f, -0.15065643f, 
    -0.05365546f, -0.15003037f, -0.03620320f, 0.17143019f, -0.10040656f, 0.08750427f, 0.01782292f, 0.00427491f, 
    -0.17907557f, 0.09192963f, -0.14993627f, 0.00316625f, -0.03702893f, -0.00343710f, -0.01771510f, -0.14392811f, 
    -0.01094176f, 0.05834661f, -0.05860608f, 0.04642171f, -0.09262148f, 0.33257392f, 0.25600439f, 0.14390337f, 
    -0.13239719f, -0.13088527f, -0.13235542f, -0.08559149f, 0.10249903f, 0.21957207f, 0.00625001f, 0.33382854f, 
    -0.20237103f, -0.17266981f, 0.04143433f, 0.15371376f, -0.04447906f, 0.02695482f, -0.00745037f, 0.10869069f, 
    0.08444216f, 0.06432706f, 0.12887104f, 0.08367798f, -0.20070304f, -0.29158720f, -0.05656825f, 0.09128816f, 
    0.24455257f, -0.01343140f, -0.02330469f, 0.04004910f, -0.01945342f, -0.08929783f, 0.03109137f, 0.10306393f, 
    -0.04343488f, -0.07354395f, 0.17549953f, -0.20428453f, 0.05788592f, 0.26313600f, 0.01182469f, 0.09874735f, 
    0.13405441f, 0.05284724f, 0.21245375f, -0.16346850f, -0.22383100f, -0.29766032f, -0.07075109f, -0.03875091f, 
    0.03259794f, 0.06189363f, 0.00476648f, -0.09071025f, -0.10408615f, -0.01562967f, -0.07748896f, -0.00558051f, 
    -0.21420369f, 0.08807688f, -0.08344089f, 0.05262985f, -0.09794416f, 0.05128069f, -0.00967221f, 0.09543411f, 
    0.04403843f, 0.06986190f, 0.13580905f, 0.10411137f, -0.16070394f, -0.03453156f, 0.18785913f, 0.02014022f, 
    -0.12996159f, -0.11246312f, -0.12622216f, 0.00710083f, 0.24768965f, 0.16433817f, 0.39557299f, 0.38595438f, 
    0.05930832f, 0.43703043f, -0.02987144f, 0.26483119f, 0.24277925f, -0.01783947f, -0.08808328f, 0.20120174f, 
    0.14449082f, -0.02269321f, 0.09402207f, -0.08117632f, -0.14547087f, -0.25105861f, 0.11184975f, 0.15539633f, 
    0.06124773f, 0.06370768f, 0.12726836f, 0.06974065f, 0.03656649f, -0.07515223f, 0.08656899f, 0.17315854f, 
    0.09044692f, -0.21250741f, -0.32927421f, 0.04768367f, -0.00637840f, -0.12720610f, -0.02489634f, 0.07133391f, 
    0.04013344f, 0.23507157f, 0.07857106f, 0.25139317f, -0.16389139f, 0.06475212f, -0.02592034f, -0.08056846f, 
    -0.04837974f, 0.06937344f, 0.07032861f, 0.02638995f, 0.01810193f, -0.17090257f, -0.11395589f, -0.46022901f, 
    0.00147389f, -0.13996126f, -0.10533750f, 0.35297289f, -0.16185537f, -0.02104973f, -0.09903017f, -0.08663640f, 
    0.27290580f, 0.32043308f, 0.24163221f, 0.18370581f, -0.08677181f, 0.01880898f, 0.25954115f, -0.24050239f, 
    0.06466614f, -0.00802001f, 0.05524841f, -0.05382684f, 0.01693724f, 0.21960765f, -0.02755625f, 0.11604850f, 
    -0.19252092f, -0.02587407f, -0.06136605f, -0.14504427f, 0.20094894f, 0.02145354f, 0.03972281f, -0.10482580f, 
    0.10372978f, 0.23364760f, 0.12799212f, 0.18448135f, -0.03058456f, 0.00605163f, -0.00273616f, -0.06370975f, 
    -0.00014383f, 0.00191394f, 0.04010814f, 0.02259819f, -0.07270613f, -0.02843650f, 0.02401809f, -0.06933127f, 
    0.17783128f, 0.15568413f, 0.05303159f, 0.03985531f, 0.19593804f, -0.09854421f, 0.08934218f, 0.19952148f, 
    0.16146293f, 0.07809465f, -0.07825446f, -0.03319389f, 0.01713143f, 0.00382174f, -0.08668140f, 0.07839490f, 
    0.01319869f, 0.04267027f, 0.11663379f, 0.06168232f, -0.05370915f, -0.07527505f, -0.02047960f, -0.31760177f, 
    -0.02568258f, -0.03400274f, 0.02198911f, -0.03978052f, -0.03676043f, -0.01837147f, -0.03016135f, 0.03602605f, 
    0.00412631f, -0.03305253f, -0.05593688f, -0.02734581f, -0.02602553f, -0.05373919f, -0.02161705f, -0.03859647f, 
    0.01660854f, -0.03582076f, -0.02208315f, 0.00886888f, 0.01237645f, -0.04906396f, 0.03791436f, 0.04315979f, 
    -0.00326708f, -0.01409781f, 0.01505385f, 0.03177052f, 0.03918138f, 0.03212025f, 0.01000485f, 0.00036336f, 
    0.03295064f, -0.02226190f, -0.04351605f, 0.00489669f, -0.04830963f, 0.02591387f, -0.01581778f, 0.03398216f, 
    0.01189584f, -0.05392993f, 0.01244890f, -0.00438131f, 0.04224746f, 0.04149273f, -0.01396567f, -0.01486194f, 
    0.04135679f, 0.01074090f, -0.03751364f, 0.01067265f, 0.00189013f, 0.00884989f, -0.04705689f, -0.01090203f, 
    0.00104228f, 0.03080469f, -0.05524857f, -0.03159836f, -0.02589173f, -0.02423238f, -0.01995224f, 0.04307225f, 
    0.00681252f, -0.02028126f, -0.02189435f, -0.00242553f, -0.03029147f, 0.00162391f, -0.00048499f, -0.02570436f, 
    -0.05141757f, -0.05036993f, -0.02431123f, 0.00913070f, -0.00507410f, -0.00392991f, -0.03795209f, 0.03090827f, 
    -0.02355449f, -0.04820221f, 0.02946004f, 0.00321285f, -0.04975622f, -0.05177341f, -0.05904327f, 0.03196425f, 
    -0.03738445f, 0.03437145f, 0.03780854f, -0.03626911f, -0.04630151f, -0.05106108f, -0.05036698f, -0.04608627f, 
    -0.02689197f, -0.01950726f, 0.03465077f, 0.00419033f, 0.00340184f, 0.03396852f, 0.03772465f, -0.05941857f, 
    -0.00180370f, -0.05209971f, -0.02978721f, -0.01613532f, -0.02356746f, -0.03029275f, -0.05465115f, -0.03876311f, 
    -0.00758854f, -0.01304470f, -0.01511000f, -0.05677780f, 0.04440353f, -0.03463718f, 0.02264384f, -0.01885122f, 
    0.01250747f, -0.02895603f, -0.00653641f, -0.05590108f, -0.03232396f, 0.00515068f, -0.04530441f, -0.03015028f, 
    0.01187408f, -0.02897355f, 0.03776163f, -0.01886091f, -0.00152429f, -0.03421814f, 0.01121936f, 0.02893160f, 
    0.00558985f, -0.04077446f, -0.04671155f, 0.02736334f, -0.03831370f, -0.05299089f, 0.02657850f, -0.05258052f, 
    -0.01900477f, -0.01263495f, 0.02086742f, -0.04213315f, 0.02451246f, 0.02071876f, 0.03822042f, 0.02731624f, 
    -0.05013683f, 0.03853916f, 0.03413885f, 0.02895071f, -0.00133074f, -0.01968239f, 0.00134697f, 0.01228946f, 
    0.02478323f, -0.04532888f, -0.00453523f, -0.03397550f, -0.01090273f, -0.05705558f, -0.04158696f, 0.02861834f, 
    0.03621701f, -0.00010463f, 0.00820922f, 0.01360888f, 0.03768055f, 0.01949404f, -0.05613492f, -0.05527399f, 
    -0.05831407f, 0.01031095f, -0.02346011f, -0.01989524f, -0.03777266f, 0.02883327f, -0.04774458f, 0.02652301f, 
    0.02921002f, -0.00803928f, -0.01296019f, -0.03857583f, 0.03176245f, -0.04422360f, -0.01710389f, -0.00622802f, 
    0.01217947f, 0.00553510f, 0.03356956f, -0.05859426f, -0.03951813f, 0.01717560f, 0.02847696f, -0.05003502f, 
    0.02358012f, -0.05483108f, -0.04025100f, -0.00294891f, -0.01470107f, 0.02934822f, -0.04729861f, 0.01748117f, 
    -0.01567855f, -0.04028072f, 0.03578809f, -0.04725804f, 0.00695683f, 0.01307492f, 0.01339499f, -0.02322005f, 
    -0.02743748f, -0.01193003f, 0.01794413f, -0.04306369f, 0.01836623f, -0.04468071f, -0.03013855f, 0.04088907f, 
    -0.01308600f, -0.05618265f, 0.01245389f, 0.03695371f, -0.02211460f, -0.01029080f, 0.04023114f, 0.02342103f, 
    -0.03066379f, 0.04691422f, -0.04404234f, -0.01906882f, 0.03076866f, 0.04059975f, -0.03958433f, 0.00192162f, 
    0.04025056f, 0.03643735f, -0.01107947f, -0.02389158f, -0.03301459f, -0.04836092f, -0.01431819f, -0.04785391f, 
    -0.05262088f, 0.01117367f, 0.02945608f, -0.00895489f, 0.01317605f, 0.03099370f, -0.03493031f, -0.04865246f, 
    -0.05478875f, -0.00488328f, 0.00580536f, -0.00176335f, -0.02615308f, -0.05506451f, -0.01733254f, -0.04871672f, 
    0.03058822f, 0.03412755f, 0.04252436f, 0.03659375f, -0.05762387f, -0.04641896f, -0.05596370f, 0.00381937f, 
    -0.01277003f, -0.00845256f, -0.03264348f, 0.02094179f, -0.02800979f, 0.02114511f, -0.00589713f, -0.04218666f, 
    -0.02771129f, 0.03910849f, -0.03132949f, 0.00092592f, -0.00610720f, 0.00238887f, 0.04033893f, -0.01553928f, 
    -0.04191142f, 0.02993649f, -0.02948212f, -0.01677049f, -0.00754658f, -0.00990404f, 0.04364451f, 0.02511965f, 
    -0.05657790f, -0.05079559f, -0.04088144f, 0.03714238f, 0.01972168f, -0.02455426f, 0.03884479f, -0.03972762f, 
    0.00690025f, -0.04762100f, -0.04961371f, 0.02680126f, 0.04242835f, 0.02627272f, 0.01978149f, -0.01869326f, 
    0.01533255f, -0.01270094f, -0.02816518f, -0.02050791f, -0.01501330f, 0.03111335f, -0.04016355f, 0.04307659f, 
    0.01403240f, -0.00290293f, -0.00562146f, -0.02063251f, 0.01979287f, 0.04002854f, -0.01570107f, -0.02602962f, 
    0.02802821f, 0.02410833f, 0.02609709f, 0.03606499f, 0.03484363f, 0.03871622f, 0.02494987f, 0.03197240f, 
    -0.04179859f, -0.03223161f, 0.03224229f, -0.05377786f, 0.00520028f, 0.02663198f, -0.05499862f, -0.04068294f, 
    -0.02954962f, 0.01394498f, -0.01414257f, 0.01028827f, -0.02429238f, 0.03641843f, -0.02635566f, -0.04707952f, 
    -0.00697754f, -0.05425458f, 0.01143751f, -0.05793135f, -0.02143090f, -0.04379815f, -0.05558557f, 0.03635452f, 
    -0.02018555f, 0.00448155f, -0.05093161f, -0.05828889f, 0.00800285f, 0.01347383f, -0.00543598f, 0.01326803f, 
    0.04313788f, 0.03987748f, -0.02191886f, 0.03143559f, -0.05136923f, -0.01557508f, 0.00801117f, 0.01407778f, 
    0.00984274f, -0.02164442f, -0.02084326f, 0.03080663f, -0.05033344f, 0.02615217f, 0.01970459f, -0.05079543f, 
    -0.41158971f, -0.29552376f, 0.14189968f, -0.13466643f, 0.23967966f, -0.21948236f, 0.14794531f, 0.00978800f, 
    0.00973420f, -0.02552256f, 0.10388765f, 0.09615672f, 0.19113113f, -0.31962228f, 0.35398063f, -0.03697631f, 
    0.12904510f, 0.15298313f, -0.18312666f, 0.26724711f, -0.05588813f, 0.17597102f, -0.05557803f, -0.07010732f, 
    0.21863097f, 0.18605499f, -0.49448621f, 0.62812823f, -0.18754524f, 0.08218036f, 0.19567174f, -0.03192837f, 
    -0.16408715f, 0.09750193f, 0.14395131f, 0.06897404f, -0.00830874f, 0.01146049f, 0.03709422f, 0.11990200f, 
    0.00834653f, -0.03098177f, -0.03424544f, -0.01710406f, 0.19328040f, -0.04587604f, 0.01072421f, -0.27052709f, 
    -0.06628724f, 0.11730376f, 0.10359587f, 0.30605882f, 0.24484120f, 0.10675296f, 0.01655634f, -0.06788090f, 
    -0.17966533f, 0.10389695f, 0.14023736f, -0.01161024f, -0.12703368f, 0.08563253f, -0.12948672f, -0.06619237f, 
    0.04045130f, 0.10610259f, 0.14070876f, 0.02793022f, -0.12554444f, 0.10748442f, 0.07611137f, -0.02726403f, 
    0.30631542f, -0.05742164f, 0.06886966f, -0.05739748f, -0.02778646f, 0.12741679f, 0.10991664f, 0.02224305f, 
    -0.01344121f, 0.03309470f, -0.06576579f, 0.00135876f, -0.07893551f, -0.02097604f, 0.43066770f, -0.23592253f, 
    0.01117841f, 0.07228170f, -0.13127001f, 0.20140180f, 0.01361118f, -0.06051597f, -0.01576703f, -0.13982399f, 
    0.06443340f, 0.10819969f, -0.04697068f, 0.00420822f, 0.06089081f, 0.11665103f, 0.13008206f, -0.22829972f, 
    -0.12125794f, 0.05251951f, -0.01452983f, -0.02334343f, 0.28406644f, 0.04530143f, -0.14756861f, 0.37266299f, 
    -0.00678281f, -0.20117258f, 0.01773271f, 0.02819303f, -0.05010040f, 0.02967779f, 0.05877735f, 0.12179350f, 
    0.28884244f, -0.32822588f, 0.18064879f, -0.03415766f, -0.18174402f, 0.21784069f, 0.00387270f, -0.13436131f, 
    -0.08785535f, 0.08736026f, -0.04156635f, 0.04753528f, 0.01765129f, 0.21437499f, -0.11150435f, 0.12794247f, 
    -0.02111342f, -0.03672801f, -0.03424306f, -0.06996332f, -0.00819026f, 0.08737278f, 0.06013656f, 0.02376347f, 
    -0.07428279f, 0.35143155f, 0.02880750f, 0.16746286f, 0.11325423f, -0.06186832f, 0.27465343f, 0.12423369f, 
    -0.03043632f, -0.05751505f, 0.05472275f, -0.12411182f, -0.00185156f, -0.11910431f, -0.38280848f, 0.19896105f, 
    -0.10767838f, 0.05601221f, 0.02876432f, 0.06842566f, 0.03239584f, 0.07549913f, -0.03508295f, -0.06690069f, 
    0.09345748f, 0.15274590f, 0.19273433f, -0.16052602f, -0.06911411f, -0.09397633f, -0.08113583f, -0.06152628f, 
    -0.07940533f, 0.04738711f, -0.06403788f, 0.08337440f, 0.32058349f, 0.06551483f, 0.12019508f, -0.08802725f, 
    -0.09450341f, 0.02963148f, -0.03189104f, 0.10586403f, -0.13062085f, 0.13283443f, -0.08917473f, 0.09503306f, 
    -0.11485444f, 0.09173089f, -0.21304969f, 0.04650849f, 0.15419780f, 0.12266381f, 0.10017744f, -0.06780382f, 
    0.00815692f, 0.23967177f, -0.16866566f, -0.04484387f, -0.00159239f, -0.05464926f, -0.21038291f, -0.10385676f, 
    -0.22364703f, 0.16466443f, 0.09000067f, -0.14799787f, 0.02647864f, 0.04523151f, -0.00034143f, 0.02211512f, 
    0.04441681f, 0.02762249f, -0.00426529f, -0.02574939f, -0.05699092f, 0.02158814f, 0.10849559f, 0.09026891f, 
    0.10981064f, 0.14190260f, -0.20499797f, 0.27887553f, 0.22877537f, -0.05096309f, -0.17360915f, 0.04057068f, 
    -0.00723576f, 0.08622873f, 0.05718844f, -0.23258215f, -0.08055996f, -0.03312026f, -0.06220163f, 0.07720482f, 
    0.02284916f, 0.14289445f, -0.45560440f, 0.34491783f, -0.00480555f, 0.13091823f, 0.00238693f, -0.19822419f, 
    0.13408147f, 0.00494110f, -0.12851129f, 0.11844983f, -0.20048688f, 0.05633529f, -0.09624377f, -0.02001347f, 
    -0.04992517f, -0.04278044f, 0.08197115f, 0.11918809f, 0.13666889f, 0.08729105f, -0.11366655f, -0.01281799f, 
    -0.03121565f, 0.72369492f, -0.15398389f, 0.01026854f, -0.13896224f, 0.18333544f, -0.04822315f, -0.01745149f, 
    -0.02007027f, -0.02571106f, -0.17963377f, 0.15402420f, 0.29773527f, 0.25847343f, -0.24389026f, 0.28843457f, 
    0.22048406f, 0.06962375f, 0.03922263f, 0.15394925f, 0.04686071f, -0.02643917f, 0.00287842f, -0.19230746f, 
    -0.39700034f, 0.10629310f, -0.07765777f, -0.03660840f, -0.00919572f, 0.07295232f, -0.11659372f, 0.20586935f, 
    -0.20684952f, 0.16624019f, -0.00830946f, -0.09438159f, -0.07677371f, 0.11658111f, 0.05887689f, 0.01232085f, 
    -0.08461374f, -0.04490621f, -0.11989655f, 0.07008682f, -0.29475078f, 0.02006802f, 0.08590344f, -0.01053825f, 
    -0.21598153f, 0.15834628f, -0.00587789f, -0.02091987f, -0.05221332f, -0.14634737f, 0.08376089f, 0.17172965f, 
    0.17763643f, 0.27535385f, 0.10410406f, 0.00609258f, 0.08134817f, -0.00196174f, -0.07255970f, 0.20759423f, 
    -0.02153272f, 0.00873864f, -0.06827708f, 0.28921479f, -0.12087431f, -0.08497875f, -0.01857407f, -0.06149048f, 
    0.01322491f, 0.04469746f, 0.07486117f, -0.03905991f, -0.00763404f, -0.09123809f, -0.07236188f, -0.03596684f, 
    -0.08443690f, -0.06456198f, 0.01955453f, 0.05925234f, -0.00787574f, -0.09562702f, 0.27277711f, -0.11613981f, 
    -0.08069245f, -0.06052518f, 0.02994967f, -0.07390670f, 0.07191208f, 0.04354911f, -0.04445871f, 0.09741447f, 
    -0.01306481f, 0.42372444f, -0.30986607f, -0.13218740f, -0.02375106f, 0.23749213f, 0.02650377f, 0.11644534f, 
    0.08049929f, 0.07839474f, 0.17916755f, 0.15751298f, 0.25951692f, -0.14902724f, 0.00774349f, 0.18480967f, 
    -0.02992003f, 0.11227661f, 0.19512643f, -0.14039560f, 0.00788236f, -0.05885092f, 0.14637695f, -0.01709519f, 
    0.16578755f, 0.41943219f, -0.24950519f, -0.16407660f, -0.06827651f, 0.06151924f, 0.07394088f, -0.02321968f, 
    0.14089060f, 0.12520708f, -0.01519495f, 0.00447793f, 0.04975764f, 0.09690600f, 0.11689035f, -0.16338101f, 
    0.15899082f, 0.02266498f, -0.04334128f, 0.13852187f, 0.05781011f, 0.12992269f, 0.22367628f, 0.09734330f, 
    0.13108647f, 0.10758721f, 0.13349022f, -0.09813341f, -0.09214501f, -0.04115582f, -0.19654000f, 0.03879238f, 
    0.02207230f, -0.05370578f, 0.01375459f, 0.09272750f, -0.07350381f, -0.09864365f, -0.02411544f, 0.02096100f, 
    -0.02314834f, -0.00418125f, 0.07971815f, -0.00164193f, 0.13453497f, 0.36392748f, 0.09798671f, 0.09855445f, 
    -0.15182096f, 0.31646201f, -0.53657991f, -0.10137051f, -0.20726493f, -0.06406473f, 0.10741455f, -0.07076339f, 
    0.08446927f, -0.05615097f, 0.05289453f, 0.07855460f, -0.28718427f, 0.04104304f, -0.15216205f, 0.02017571f, 
    -0.02964650f, -0.05326378f, -0.08903472f, -0.05580880f, 0.01764985f, -0.02715135f, -0.01711649f, 0.07119182f, 
    0.09256266f, 0.04024898f, 0.01765462f, -0.15860753f, 0.03697511f, 0.09152124f, -0.07203585f, -0.06753186f, 
    0.01511103f, 0.17625982f, 0.10058911f, 0.05657089f, 0.09248042f, 0.02210602f, 0.17607577f, 0.02534614f, 
    -0.04763407f, -0.03397885f, 0.14938708f, 0.00181203f, -0.03612131f, 0.03301362f, -0.16065785f, -0.08333092f, 
    0.27995515f, 0.27984050f, 0.22040954f, -0.04575281f, 0.03806267f, -0.03575409f, 0.08613577f, 0.16035300f, 
    0.02906462f, 0.03420682f, 0.09898615f, 0.09519197f, -0.03344440f, -0.09963506f, -0.24242875f, 0.04038585f, 
    0.00948397f, 0.28002915f, -0.11390973f, -0.07778639f, -0.09604350f, 0.03652157f, -0.02886261f, 0.09032483f, 
    0.08934917f, 0.09239785f, 0.07713880f, -0.07171577f, 0.11615741f, 0.00568125f, -0.01431654f, 0.01079562f, 
    -0.03732036f, 0.11043609f, -0.01855487f, -0.08924121f, 0.04456022f, -0.03153571f, -0.14879729f, 0.11969934f, 
    0.00887385f, -0.01693319f, 0.00989720f, 0.14211930f, -0.00884778f, -0.03240526f, 0.02531666f, 0.03973577f, 
    0.20797370f, 0.00738096f, -0.73056370f, 0.12282977f, 0.20174715f, -0.08917677f, -0.20461528f, 0.02660357f, 
    -0.12107666f, -0.10995732f, -0.10149323f, 0.06827290f, 0.45702425f, 0.19024909f, -0.08925246f, -0.17230305f, 
    -0.04544377f, -0.02225715f, -0.08705308f, -0.03888459f, 0.13049823f, -0.07930567f, -0.01078452f, -0.13001625f, 
    0.17618805f, 0.03599522f, -0.03386287f, 0.24560739f, 0.12455972f, 0.06117802f, 0.04928314f, -0.01219557f, 
    -0.06030418f, -0.04463980f, 0.00171308f, -0.03011161f, 0.09610628f, 0.06210601f, -0.07819096f, -0.00244511f, 
    0.02242994f, 0.03588660f, -0.06505205f, -0.00768178f, -0.09064143f, -0.01684232f, 0.09003430f, 0.07303081f, 
    -0.12316819f, -0.02299959f, -0.08672724f, -0.24032146f, 0.09654368f, 0.04205444f, -0.05201152f, -0.02055213f, 
    -0.07171567f, -0.11829653f, 0.06143683f, -0.10993984f, 0.46824282f, 0.24377942f, 0.38034871f, -0.10524485f, 
    -0.03711291f, 0.06863751f, -0.01182433f, 0.13477609f, 0.02957676f, 0.00216252f, 0.06364781f, 0.10694883f, 
    -0.16256770f, -0.00896430f, -0.03497702f, 0.06540582f, 0.02184355f, 0.02648331f, -0.05891807f, -0.02409248f, 
    0.13794790f, 0.08947636f, 0.02935989f, -0.15185401f, 0.33630481f, 0.34014866f, 0.20053358f, 0.14891224f, 
    -0.05548424f, 0.01235048f, 0.09515342f, 0.02711311f, 0.01516191f, 0.10231034f, 0.09374546f, 0.01724003f, 
    0.16358690f, 0.04799446f, -0.03568127f, -0.06354973f, 0.12097955f, -0.00379401f, 0.04718464f, -0.08765531f, 
    0.04160915f, 0.20322944f, 0.07491412f, 0.05954028f, -0.05516862f, 0.02165979f, -0.01757585f, 0.21949318f, 
    0.00991237f, -0.09274991f, -0.07077444f, -0.09501664f, 0.05690190f, 0.01957963f, 0.17698488f, 0.10516332f, 
    -0.37184629f, -0.32380167f, 0.46792445f, -0.01266827f, 0.19535267f, 0.08522663f, 0.01243696f, 0.17989969f, 
    -0.04613082f, -0.11697493f, 0.01413699f, 0.00633643f, 0.17816325f, 0.13141459f, -0.08255265f, -0.31056938f, 
    -0.03836374f, -0.07484025f, 0.06734870f, -0.09568899f, 0.01488618f, 0.02955886f, 0.03665521f, 0.08569077f, 
    -0.15461054f, 0.15905754f, 0.13802694f, -0.08644924f, 0.15278611f, 0.04366061f, 0.19811489f, 0.02197709f, 
    0.02228923f, -0.12180494f, -0.03930798f, -0.13058488f, 0.01087716f, -0.05745347f, 0.00345639f, 0.03474626f, 
    -0.00970291f, 0.07983918f, -0.01125076f, 0.02048398f, 0.16085033f, 0.14173499f, 0.06005398f, 0.18349953f, 
    -0.07384044f, 0.03388260f, 0.00254013f, 0.32916960f, 0.01416144f, -0.00147704f, -0.03114465f, -0.11973158f, 
    -0.23009172f, 0.12113769f, -0.08616042f, 0.19890489f, 0.02110569f, 0.28069946f, -0.20821135f, 0.10961677f, 
    0.00219970f, 0.13913874f, 0.13151556f, -0.06463026f, 0.01369771f, 0.01500365f, 0.07275752f, 0.00902288f, 
    0.06979032f, -0.06239378f, -0.00208595f, 0.06326024f, 0.19847377f, 0.14893214f, -0.10352620f, 0.03928350f, 
    0.00986691f, -0.07352034f, -0.04514964f, -0.02926173f, 0.11488771f, -0.07993523f, -0.12674029f, 0.03412571f, 
    -0.03562059f, 0.02225433f, -0.01324200f, 0.04266930f, 0.07783411f, 0.13066196f, 0.02272202f, -0.08488913f, 
    -0.29444760f, 0.02983253f, 0.32388622f, 0.07964004f, -0.02139188f, 0.01984927f, 0.22307116f, 0.02882059f, 
    0.12242238f, 0.09076346f, 0.04765246f, 0.04977108f, 0.25789267f, 0.15326430f, 0.03846331f, -0.05428440f, 
    0.12230890f, 0.07954584f, -0.14882964f, 0.11893522f, 0.11331245f, 0.13177346f, -0.01280837f, 0.23529951f, 
    0.09635228f, 0.07238845f, 0.13679573f, 0.39631212f, -0.04434805f, 0.04598066f, -0.03972417f, -0.05474850f, 
    0.19748442f, 0.16009760f, -0.13327213f, -0.08735038f, 0.12338662f, 0.20847698f, -0.29096469f, 0.12422971f, 
    -0.13791163f, 0.16007078f, 0.21185780f, 0.01456935f, 0.19150329f, -0.02770871f, 0.26734996f, 0.31103802f, 
    -0.17903742f, 0.12633686f, 0.62644947f, 0.21647777f, 0.21671973f, -0.01770041f, -0.31452057f, 0.13273111f, 
    0.12777328f, -0.02892466f, 0.11360749f, 0.10259920f, 0.22355147f, 0.02085287f, -0.17809987f, -0.20396708f, 
    0.11488095f, 0.05655080f, 0.06552929f, 0.29941398f, -0.04365789f, -0.01018794f, -0.14013034f, 0.01035597f, 
    -0.06795361f, 0.06589168f, -0.18954696f, 0.24202958f, -0.17486122f, -0.00271463f, 0.14699648f, -0.04225849f, 
    0.03276279f, -0.02635809f, 0.02439275f, 0.03766874f, 0.16856486f, 0.07478858f, 0.23632763f, 0.16312443f, 
    -0.13398004f, -0.11960040f, 0.01936475f, 0.23820929f, 0.19219886f, 0.03636349f, 0.02162566f, 0.22384229f, 
    -0.23951012f, -0.22281015f, -0.00539204f, 0.01957911f, -0.01396640f, 0.06174458f, -0.03187270f, 0.18265845f, 
    0.06527998f, -0.03637390f, 0.18162696f, 0.12881497f, 0.43059030f, -0.23952498f, -0.20868441f, 0.26968667f, 
    -0.17605792f, -0.05426025f, 0.24329263f, 0.00411047f, 0.03571445f, 0.37340215f, -0.22534715f, -0.06336179f, 
    -0.05517728f, -0.10072565f, 0.03806730f, 0.25847432f, 0.02105865f, -0.12358651f, -0.11895589f, 0.03354141f, 
    -0.12713248f, -0.13990699f, -0.02104909f, -0.25267899f, -0.55569327f, 0.55670154f, 0.06972954f, -0.10084339f, 
    0.13907722f, 0.11533453f, 0.03313085f, -0.22399946f, -0.13105594f, 0.02025564f, 0.11215464f, -0.14885253f, 
    -0.26406685f, 0.40737209f, 0.05046556f, 0.09491087f, 0.22844030f, -0.12250970f, 0.38432059f, 0.21927443f, 
    0.00005624f, 0.05784404f, -0.08943222f, -0.20103499f, -0.18137757f, -0.00072727f, 0.06537347f, -0.09210351f, 
    -0.04699911f, 0.15873790f, 0.20733185f, 0.24645922f, 0.04465851f, 0.31325144f, 0.10744045f, 0.34233120f, 
    -0.23889512f, -0.00536925f, 0.01987341f, 0.07543573f, 0.04833928f, -0.04717472f, -0.02180943f, -0.10248430f, 
    -0.10989425f, -0.12803002f, -0.20762576f, 0.04653269f, 0.01739662f, 0.28857887f, 0.22867209f, 0.25990549f, 
    -0.12012089f, -0.30933759f, 0.05169477f, -0.05999154f, 0.24253987f, 0.02308006f, 0.02142002f, -0.05147762f, 
    0.15275286f, -0.25359467f, 0.08492462f, -0.07549998f, 0.18125543f, 0.11050786f, 0.00859293f, -0.05140302f, 
    -0.09171090f, -0.14677945f, -0.01210674f, -0.17924424f, 0.07859685f, -0.13352282f, -0.24310720f, -0.22164646f, 
    -0.00954616f, 0.06063654f, -0.19796026f, -0.11519149f, -0.08045405f, -0.05747414f, 0.17445372f, 0.03832525f, 
    -0.00002000f, 0.21316151f, 0.29622650f, 0.17959604f, -0.05367067f, -0.16386031f, -0.08756008f, -0.01020471f, 
    0.00526712f, 0.06561366f, -0.05409277f, 0.05031077f, -0.00631526f, -0.02333212f, 0.07300717f, 0.25048289f, 
    -0.11234835f, -0.10318970f, -0.00361025f, 0.19306187f, 0.03902876f, -0.12469987f, -0.15920149f, -0.09079666f, 
    -0.08032637f, 0.15504959f, -0.34577683f, -0.16343750f, 0.02882692f, -0.04347102f, -0.01615002f, 0.00859052f, 
    0.12569188f, 0.23252173f, -0.06732208f, 0.01839820f, -0.14808165f, -0.09446785f, 0.13272202f, 0.18545529f, 
    0.03595439f, -0.00742755f, 0.03945276f, 0.08886635f, 0.12819253f, -0.10344175f, 0.12987940f, 0.04203621f, 
    -0.04401839f, -0.09537655f, 0.30933326f, 0.08831387f, 0.01280544f, 0.10034633f, 0.05977879f, 0.16392107f, 
    -0.04556988f, 0.15013437f, -0.10919377f, 0.04939006f, 0.05153531f, 0.06463812f, -0.04590677f, -0.16979398f, 
    0.00792099f, -0.15107112f, -0.02138498f, -0.11944734f, -0.11373434f, 0.00747438f, -0.05968904f, -0.28181183f, 
    -0.12051545f, -0.18223414f, -0.07770117f, -0.28260031f, 0.22432272f, 0.10001098f, 0.05401556f, 0.09065536f, 
    -0.05059071f, -0.16497423f, 0.05427838f, 0.25913543f, -0.37073234f, -0.13913751f, 0.07515649f, 0.18252400f, 
    -0.00760612f, -0.10408578f, -0.22432658f, 0.09857452f, -0.00618375f, -0.03569788f, -0.06364024f, 0.11054220f, 
    0.24494694f, -0.25169700f, 0.19205149f, 0.02499542f, -0.02036068f, -0.05023404f, -0.15118985f, -0.18045293f, 
    -0.07206863f, -0.34668365f, -0.24261180f, -0.46276507f, 0.15388985f, -0.15511838f, -0.13399890f, -0.04495179f, 
    -0.14825366f, -0.20850302f, -0.01208250f, 0.10600926f, 0.39858413f, 0.26740816f, 0.29979271f, 0.54527372f, 
    0.06150823f, -0.07813434f, 0.27861711f, -0.23197421f, -0.02385017f, 0.09164609f, -0.29180443f, -0.26693296f, 
    -0.09156544f, -0.22195397f, 0.05227762f, 0.00000014f, -0.06844135f, -0.05206876f, 0.17967911f, -0.01671711f, 
    0.06306628f, 0.19313556f, -0.16851453f, -0.01863168f, -0.04537507f, -0.19151010f, 0.09609579f, 0.02056865f, 
    0.01160394f, -0.03504753f, 0.15673909f, 0.03864476f, 0.24154061f, 0.21019417f, -0.24060062f, -0.03524530f, 
    -0.28467804f, -0.32713118f, -0.28501225f, -0.56064916f, 0.17847933f, 0.03794809f, -0.04826996f, -0.08881911f, 
    -0.05056468f, 0.11357249f, 0.07675339f, 0.22105721f, 0.19066741f, 0.30517331f, 0.04163602f, -0.04736269f, 
    0.21735828f, -0.26711613f, -0.12953289f, -0.01568653f, 0.07414914f, 0.05103909f, -0.02871677f, 0.11100510f, 
    0.18850590f, 0.10954044f, 0.09768888f, 0.27868119f, -0.30027065f, 0.02933674f, 0.13408944f, 0.15216359f, 
    0.05609340f, 0.17617312f, 0.10691258f, 0.23889580f, 0.25510603f, 0.15426600f, 0.17917034f, 0.60136509f, 
    -0.05385249f, 0.02120837f, -0.01890504f, 0.00161919f, -0.00162670f, -0.05325389f, -0.01014804f, -0.04723386f, 
    -0.01392203f, -0.05228757f, 0.04668284f, 0.03636196f, 0.04118509f, 0.01705084f, -0.01764381f, -0.00879208f, 
    -0.01335514f, 0.02352422f, 0.04184520f, -0.04841130f, -0.00692868f, -0.03428582f, 0.02686881f, 0.03983652f, 
    -0.00896579f, -0.04780187f, 0.01920186f, 0.03711906f, -0.04898195f, -0.04638468f, 0.04294961f, -0.00044884f, 
    0.01840263f, 0.04655607f, -0.03183644f, -0.00315936f, 0.01648349f, -0.05779888f, 0.03986023f, -0.05406996f, 
    -0.01493721f, 0.00369672f, -0.03208655f, -0.01178581f, -0.04122322f, 0.02341179f, -0.05318991f, 0.04156053f, 
    0.02986839f, -0.02002900f, 0.01202279f, 0.04342119f, -0.05026973f, -0.02678449f, 0.03437057f, -0.02764298f, 
    0.02293034f, 0.04737410f, -0.01720935f, -0.00732461f, -0.03937814f, -0.01438212f, -0.05637899f, 0.02627203f, 
    -0.01808979f, 0.00800986f, 0.01967160f, -0.04316076f, 0.03661238f, 0.00263535f, 0.02071508f, 0.00777187f, 
    -0.02933274f, 0.03502573f, 0.01883266f, 0.01800993f, 0.05044437f, 0.00155781f, -0.04552244f, 0.00624992f, 
    0.04372185f, 0.01850329f, -0.04658819f, -0.02573518f, -0.04668805f, -0.04347678f, -0.02785929f, -0.03796033f, 
    -0.00709828f, -0.03891326f, 0.04064566f, -0.04861838f, 0.03481548f, -0.04359217f, -0.03337780f, -0.02867187f, 
    -0.03958678f, -0.01935680f, -0.00226355f, -0.05292013f, 0.01080290f, 0.03408781f, -0.01652345f, -0.03406446f, 
    -0.04127076f, 0.02700648f, -0.00576685f, -0.02475825f, -0.03911838f, 0.03004654f, -0.01893319f, -0.01962188f, 
    -0.04661911f, -0.00994987f, 0.00459870f, 0.01468666f, 0.03674905f, -0.02014666f, -0.04515739f, 0.00547728f, 
    -0.02036955f, 0.02125686f, -0.02744432f, -0.04143231f, -0.03325586f, 0.04395701f, -0.03316129f, -0.00701419f, 
    -0.00104146f, -0.03985530f, 0.04318199f, -0.03795407f, 0.01101744f, -0.04382241f, -0.00883715f, -0.02829052f, 
    -0.03463288f, -0.05115918f, 0.04291914f, 0.04186245f, 0.00532853f, -0.01885143f, 0.02947493f, -0.00227727f, 
    -0.03681283f, 0.03811502f, -0.02856790f, -0.03104000f, 0.00259297f, 0.03428510f, -0.02041833f, 0.02526143f, 
    -0.04804311f, 0.03744082f, 0.02473745f, -0.04020218f, -0.03974532f, -0.04247174f, 0.02441938f, -0.04799639f, 
    -0.03311743f, -0.02353361f, -0.00999907f, -0.01624786f, 0.00715410f, -0.03838691f, -0.04754432f, 0.00569079f, 
    -0.02747837f, -0.01527668f, -0.03986070f, 0.02944144f, -0.01124110f, -0.05120455f, 0.02724089f, -0.04931387f, 
    -0.00568915f, 0.03552550f, -0.04547639f, 0.02453580f, -0.04681296f, -0.05390180f, -0.02627256f, -0.03709511f, 
    -0.01224762f, 0.00863049f, 0.00869317f, -0.04680175f, 0.03863250f, -0.05875123f, -0.01932250f, -0.01440674f, 
    -0.03350388f, -0.03867181f, 0.02341196f, -0.02130438f, -0.04037939f, 0.01081744f, 0.04109102f, -0.01124901f, 
    -0.02279390f, -0.02927634f, -0.01494372f, 0.00590618f, -0.02910095f, -0.00344887f, 0.04292243f, 0.02015708f, 
    0.00226344f, 0.01618939f, -0.03318747f, -0.05115905f, -0.04543315f, -0.04821514f, 0.03602710f, 0.03580123f, 
    -0.04928802f, -0.00409437f, 0.03720631f, -0.04547430f, -0.01819701f, 0.02997554f, 0.00625513f, -0.01172811f, 
    -0.02597929f, -0.04423448f, 0.03628876f, 0.00178219f, 0.03124885f, 0.02746601f, -0.00697050f, 0.02499213f, 
    -0.03974925f, -0.02306112f, -0.02294715f, -0.01361993f, -0.00009719f, 0.00976313f, -0.04109897f, -0.00891348f, 
    0.00519892f, -0.00801395f, -0.02539193f, 0.01563581f, -0.03585192f, 0.03383972f, 0.02963087f, 0.01438819f, 
    -0.02772393f, -0.01956283f, -0.02395699f, -0.00190476f, -0.02288850f, 0.03029775f, 0.03722130f, 0.01711131f, 
    -0.00399594f, -0.00962142f, 0.02348386f, -0.03901280f, -0.03506022f, 0.01491506f, 0.03002953f, 0.00411800f, 
    -0.03046852f, 0.03661998f, -0.03545967f, 0.02494875f, 0.03783277f, 0.00219358f, 0.03170655f, -0.00405617f, 
    -0.00168929f, -0.00583434f, -0.03981384f, 0.00889645f, -0.02546452f, -0.02652705f, -0.03362715f, 0.03910774f, 
    0.02673725f, 0.00082456f, -0.00664371f, 0.02626667f, -0.02948407f, -0.01283079f, -0.00442630f, -0.01441217f, 
    -0.04099330f, 0.03202996f, -0.04649940f, -0.02563150f, -0.02602406f, 0.03608747f, 0.02731344f, -0.04829738f, 
    0.01045200f, -0.04482979f, -0.01772311f, 0.04237083f, 0.04325807f, -0.01304028f, 0.04106649f, -0.05102671f, 
    -0.04567525f, -0.01850642f, 0.03244435f, -0.04373955f, 0.00357739f, -0.04262875f, -0.04882720f, 0.03729862f, 
    -0.02820808f, -0.04668934f, -0.03728699f, -0.02654180f, 0.00720569f, 0.00885067f, 0.00777205f, 0.01851797f, 
    0.04832711f, 0.02216862f, 0.03129128f, 0.01882317f, -0.03108033f, 0.03103855f, -0.01129477f, -0.02788317f, 
    0.03702462f, 0.02736302f, 0.00770319f, 0.01393015f, 0.03419222f, -0.01353781f, -0.04381379f, 0.03303699f, 
    -0.04956071f, 0.00617125f, 0.04312163f, 0.01688555f, -0.03958040f, -0.00848189f, -0.02349072f, 0.01549813f, 
    0.01427818f, -0.01539608f, -0.02753235f, 0.04147116f, -0.01895411f, -0.03099103f, 0.00999803f, -0.02293228f, 
    0.02989365f, -0.03857012f, 0.04324354f, 0.02846130f, -0.02432915f, -0.04441552f, 0.02994701f, 0.02837245f, 
    -0.03838175f, -0.04170759f, -0.03573705f, -0.03536699f, -0.02184949f, -0.03159350f, -0.03758382f, 0.02022862f, 
    0.00745832f, -0.03240178f, -0.03996424f, 0.02659421f, -0.03452772f, 0.00841398f, -0.01037377f, 0.04317701f, 
    0.02521111f, -0.03036673f, 0.01811360f, 0.04187070f, -0.02673955f, -0.05020852f, -0.00314283f, 0.01191586f, 
    -0.08695018f, 0.13691734f, -0.03043471f, 0.24998830f, -0.01313818f, -0.07316392f, -0.02408058f, 0.09570679f, 
    0.00944813f, 0.12871383f, -0.01527895f, 0.09482458f, -0.06297947f, 0.11755805f, 0.21455185f, -0.18347767f, 
    0.00186805f, -0.06748039f, 0.00746970f, -0.01636635f, -0.17864564f, 0.13700444f, -0.04640986f, 0.20370394f, 
    0.10285049f, 0.00196676f, -0.04556317f, 0.30788848f, -0.07203866f, 0.06119774f, -0.18077880f, 0.08324964f, 
    -0.06418369f, -0.03712932f, 0.15078007f, -0.04022044f, -0.01861634f, 0.04960700f, 0.01554845f, 0.04619598f, 
    0.08580934f, 0.09699626f, 0.13257065f, -0.01668923f, 0.17184980f, 0.02855597f, 0.03885983f, -0.15960719f, 
    0.28382081f, 0.27064595f, -0.26030445f, 0.39482394f, -0.09479421f, -0.13044468f, -0.03425455f, -0.23588096f, 
    -0.03335077f, -0.05199174f, -0.04300201f, 0.18607153f, -0.00417709f, 0.25262284f, 0.06763399f, 0.09356214f, 
    0.12736508f, -0.00995485f, 0.11891896f, 0.01574424f, -0.16372895f, 0.04121137f, 0.04063091f, 0.12165494f, 
    0.17058240f, -0.20201324f, 0.02979978f, 0.08089150f, 0.11700525f, 0.10215017f, -0.03678233f, -0.05580610f, 
    -0.07116166f, -0.08110043f, -0.01397081f, -0.03151583f, -0.68639702f, 0.14434351f, 0.27961102f, -0.40962645f, 
    -0.06793799f, 0.21195896f, 0.05327218f, -0.06587402f, 0.15877436f, 0.00597873f, 0.10772895f, 0.13634707f, 
    0.06109230f, 0.15729943f, 0.02257273f, 0.09157524f, -0.05198064f, -0.01731138f, 0.07917787f, -0.02980722f, 
    -0.09144315f, -0.03880852f, 0.01765650f, -0.07900029f, -0.09284709f, -0.16680014f, 0.03626029f, 0.24384278f, 
    -0.05476699f, 0.03491857f, -0.02546408f, -0.06594290f, -0.18755470f, 0.06715909f, 0.10108913f, -0.05069873f, 
    -0.05060836f, 0.16079758f, 0.35715449f, -0.03452793f, -0.15947372f, -0.05200251f, -0.06969041f, -0.01524949f, 
    -0.00370433f, 0.06280802f, -0.08395834f, -0.01152703f, -0.20329933f, -0.01382415f, -0.25421187f, 0.03876813f, 
    -0.06704115f, 0.05127767f, 0.01248415f, 0.14196397f, -0.08023430f, 0.17438146f, -0.05001090f, 0.16681623f, 
    0.23529427f, 0.49425745f, 0.01484258f, 0.29450923f, 0.16519251f, 0.08954242f, -0.11645089f, -0.21050234f, 
    -0.29435667f, -0.03315036f, 0.02127103f, 0.04916630f, 0.14188212f, 0.17257392f, 0.01034203f, 0.26726994f, 
    0.11028853f, 0.07823554f, 0.05251675f, 0.09032353f, 0.10548567f, 0.06842685f, 0.01802360f, -0.01107001f, 
    -0.06815454f, -0.03112557f, -0.13261652f, -0.11244978f, -0.02813288f, 0.03769737f, 0.04613784f, 0.09164646f, 
    0.07672711f, 0.09271407f, 0.00675087f, 0.02123613f, -0.06485712f, -0.22834477f, -0.14862937f, -0.37280309f, 
    -0.00849066f, -0.01284247f, 0.05081074f, 0.04768482f, -0.01184138f, 0.05730445f, -0.07804846f, -0.09213893f, 
    0.49277231f, 0.33943117f, 0.27131760f, -0.00158330f, 0.10602839f, 0.02247276f, 0.06984466f, 0.04144587f, 
    0.02737173f, 0.10684010f, 0.00866575f, 0.05507699f, 0.21901824f, 0.10125212f, 0.06040540f, -0.03013702f, 
    -0.29330426f, -0.04938579f, 0.02058107f, 0.00245076f, -0.11832511f, 0.11161929f, -0.04375516f, -0.09966306f, 
    -0.04123888f, -0.08483809f, -0.10916290f, 0.07800590f, -0.09215366f, 0.07382452f, 0.00155551f, -0.19587290f, 
    0.09177365f, 0.08761067f, -0.05595859f, 0.20622621f, 0.18099368f, -0.05472535f, 0.05166509f, 0.14974247f, 
    0.04014084f, -0.14981364f, 0.09647798f, 0.02751055f, 0.06784563f, 0.04421075f, -0.03882544f, 0.01098789f, 
    -0.02073754f, 0.13201614f, -0.18291354f, 0.25300914f, 0.10080586f, -0.01171395f, -0.09658499f, -0.09468292f, 
    -0.01740541f, 0.07196527f, -0.09961552f, -0.02016408f, -0.05436233f, 0.05634173f, -0.05325339f, -0.05815374f, 
    0.12109751f, 0.04586192f, 0.05784354f, -0.00441870f, -0.12522873f, 0.02841057f, -0.13628657f, -0.21620411f, 
    -0.94959331f, 0.45022205f, -0.02146859f, -0.01427645f, -0.22132900f, -0.01631158f, 0.02537105f, 0.21170029f, 
    -0.08352986f, 0.02211770f, 0.02589105f, -0.07465159f, 0.31545532f, 0.23596954f, -0.11585400f, 0.11053051f, 
    0.03617053f, -0.09437689f, -0.00842317f, -0.08073200f, 0.00047030f, -0.00110044f, 0.04686741f, -0.01502722f, 
    0.06855041f, 0.28236604f, 0.16120425f, -0.03190513f, 0.08791545f, 0.05642423f, 0.02927721f, 0.16359159f, 
    -0.06110649f, -0.21379970f, -0.10581782f, -0.06433985f, -0.20905964f, -0.09220640f, -0.08981759f, -0.05805331f, 
    -0.04074347f, -0.03950806f, -0.03374964f, 0.04586170f, -0.03017332f, 0.19527513f, 0.21216109f, 0.40669882f, 
    -0.01787700f, 0.01393515f, -0.05362326f, -0.10494844f, 0.16852596f, 0.16454999f, 0.09838776f, -0.10788067f, 
    -0.15976951f, -0.00699889f, -0.16483814f, -0.03139358f, -0.06355900f, 0.08352277f, -0.15716559f, 0.05581063f, 
    -0.03815025f, -0.03580020f, -0.06466546f, -0.22807339f, -0.15624745f, 0.06590892f, -0.05734971f, -0.04178949f, 
    0.15488254f, -0.01005185f, 0.04867924f, 0.10404944f, -0.10176151f, -0.16263750f, 0.07357336f, 0.05659600f, 
    -0.10339933f, 0.01155074f, 0.00313057f, -0.05086311f, -0.17524754f, -0.15742229f, -0.00780210f, -0.00534817f, 
    -0.10160470f, 0.04370059f, 0.05936819f, -0.03561023f, -0.01712826f, 0.11867433f, -0.04883296f, -0.00062041f, 
    -0.11856280f, 0.23875812f, -0.03457147f, -0.12672347f, 0.01447790f, 0.01761082f, 0.05033477f, -0.10163292f, 
    -0.14503062f, -0.05174543f, 0.08670483f, -0.08291736f, 0.14271225f, 0.03176325f, -0.04833541f, 0.15641053f, 
    0.19898370f, -0.05195548f, -0.06997601f, 0.11032614f, -0.06647865f, 0.17715365f, 0.14986534f, 0.23720162f, 
    -0.02342602f, -0.02005902f, 0.02016545f, -0.06018085f, 0.02162476f, -0.01561108f, 0.03807750f, 0.02817313f, 
    0.01257776f, -0.05512365f, 0.00686664f, -0.00772650f, -0.00409942f, -0.00033865f, -0.00357248f, 0.04310039f, 
    -0.03040821f, 0.02119984f, -0.01132427f, -0.02395584f, -0.04553132f, -0.00228063f, 0.02700108f, -0.02853214f, 
    0.02256493f, 0.00725549f, 0.02677293f, 0.01637108f, 0.00806025f, 0.02084389f, 0.02766967f, -0.03473242f, 
    0.01042584f, -0.04928137f, 0.02986160f, 0.00915364f, -0.03157352f, 0.02255604f, 0.03171328f, -0.00394377f, 
    -0.01602674f, -0.01882142f, 0.00825607f, -0.00395218f, -0.05371424f, 0.00658295f, 0.02490368f, 0.02071952f, 
    -0.04256583f, -0.05644036f, -0.02213082f, 0.00156735f, 0.01288541f, 0.00948452f, -0.03565527f, -0.02438128f, 
    0.01395867f, 0.02343115f, -0.02486215f, -0.04604965f, -0.04663739f, 0.02217859f, 0.03537775f, -0.04260937f, 
    -0.05031518f, -0.01277518f, 0.03331061f, -0.05183514f, 0.03936261f, 0.03534109f, 0.04054721f, 0.01454463f, 
    -0.05933651f, -0.05871988f, -0.03122558f, -0.04226385f, -0.02039190f, -0.05404635f, -0.00377843f, -0.03830831f, 
    0.01772804f, -0.01796901f, -0.05619233f, 0.02125175f, 0.00622056f, -0.02763367f, 0.03036779f, -0.05543137f, 
    -0.05074845f, -0.02624761f, 0.03165217f, -0.03093126f, 0.01669725f, -0.05724816f, -0.04799755f, 0.03659913f, 
    -0.01025545f, 0.01710521f, -0.04529141f, 0.01025920f, -0.03097202f, -0.01901689f, 0.00923745f, 0.00597849f, 
    -0.01843755f, 0.01735668f, -0.04671584f, 0.00134975f, -0.05541118f, -0.02482680f, -0.03525289f, 0.00914107f, 
    -0.02413247f, 0.03872604f, -0.04471760f, -0.03738406f, -0.00381648f, -0.04832284f, -0.06085130f, -0.02234884f, 
    -0.05287997f, -0.03692777f, -0.05905486f, -0.04017480f, 0.02995352f, 0.01888434f, -0.01981610f, -0.02731234f, 
    0.02605477f, -0.03221640f, -0.03793029f, -0.00685904f, -0.04728465f, 0.02869737f, 0.03021320f, 0.02930579f, 
    -0.03109388f, -0.01233196f, 0.02570120f, -0.00125387f, 0.00305164f, -0.00292591f, 0.02371000f, 0.03881130f, 
    0.02919354f, -0.06206807f, -0.01988446f, 0.00682381f, -0.02733867f, -0.01677605f, -0.01425835f, 0.00324505f, 
    0.02004174f, -0.03795661f, -0.04768001f, 0.02199879f, -0.01846333f, 0.02797004f, -0.05395311f, -0.02545565f, 
    0.03027263f, 0.01849170f, -0.04661399f, -0.00485826f, 0.01033550f, 0.01359643f, -0.03146016f, 0.00956542f, 
    0.04252103f, -0.06157534f, -0.04498248f, -0.01181483f, -0.04517838f, -0.01543918f, 0.00792972f, 0.01488417f, 
    0.00548439f, -0.02506253f, 0.02710239f, 0.03494930f, -0.02216550f, -0.01599375f, -0.03639283f, -0.01650232f, 
    0.03358097f, -0.05420949f, 0.01257100f, -0.04974584f, 0.02855081f, 0.03278045f, 0.03536986f, 0.00586622f, 
    0.02480797f, -0.02681119f, 0.03726048f, -0.01451139f, -0.04301344f, -0.05812649f, 0.03872603f, 0.03835198f, 
    -0.00237927f, -0.00568295f, 0.01735781f, 0.01738283f, -0.01032285f, 0.00236605f, -0.02768457f, 0.01534471f, 
    0.00803190f, 0.01297396f, -0.03706779f, -0.04895454f, -0.03271098f, -0.01131394f, -0.04719609f, 0.03466095f, 
    0.02805001f, 0.05031665f, 0.01174952f, 0.02146859f, 0.03834058f, -0.05876734f, 0.03711617f, -0.02060930f, 
    0.02101967f, 0.03240111f, 0.00714194f, -0.02615344f, -0.00495764f, -0.05185078f, -0.00112844f, -0.03223001f, 
    0.02193513f, -0.03536242f, 0.03878596f, 0.00966551f, -0.05878236f, 0.03571613f, -0.01487511f, -0.04776908f, 
    -0.02782005f, -0.03394562f, -0.00092063f, -0.02131789f, 0.02846927f, 0.02720269f, 0.02349178f, -0.00710307f, 
    0.00013020f, -0.03083120f, -0.00655860f, -0.00738377f, 0.00874261f, 0.03767482f, -0.00653887f, -0.02893819f, 
    -0.00493096f, 0.01268345f, 0.02749288f, -0.03172696f, -0.01599356f, -0.04254206f, -0.04013973f, -0.00487910f, 
    0.00621183f, -0.05180432f, 0.01057672f, 0.02185195f, 0.01662564f, -0.05478627f, -0.00332965f, -0.00576078f, 
    -0.03788975f, -0.05021878f, -0.04346310f, -0.01509443f, -0.04998119f, -0.01962406f, -0.05199888f, 0.00614442f, 
    0.00715445f, 0.02384088f, -0.04947685f, -0.04346886f, 0.03135095f, -0.05083305f, 0.02817199f, -0.03519763f, 
    -0.02327444f, 0.02576297f, 0.02956148f, 0.01493125f, -0.05711885f, -0.04331655f, -0.03166389f, 0.00534962f, 
    0.00897376f, -0.00656279f, -0.01633189f, -0.05236638f, -0.00048284f, 0.01605681f, -0.03294896f, -0.03323580f, 
    0.01991763f, -0.05242138f, -0.03101411f, -0.00764401f, 0.01971576f, -0.01731100f, 0.02030966f, 0.01916150f, 
    -0.03609114f, -0.03896650f, -0.05025428f, -0.05455301f, 0.00999754f, -0.02194374f, -0.03243510f, -0.05751032f, 
    0.00214026f, 0.01664983f, -0.00442039f, -0.04982344f, -0.03213304f, 0.03892864f, -0.05762008f, 0.02328232f, 
    -0.03953596f, -0.02542474f, -0.02669448f, 0.01561629f, 0.03928120f, 0.03368533f, 0.03683380f, 0.03506266f, 
    -0.01893553f, -0.01675955f, -0.02789434f, -0.03857815f, -0.02857241f, 0.00601530f, 0.00202209f, -0.03550313f, 
    -0.00170108f, 0.01073807f, 0.00297181f, -0.01120268f, 0.02371139f, 0.00701162f, -0.04905830f, -0.03640451f, 
    0.01906588f, 0.02513868f, -0.03866802f, 0.01023419f, 0.00479919f, 0.01560637f, 0.01834052f, -0.00045383f, 
    -0.03320594f, -0.01556018f, -0.00812817f, -0.05666716f, 0.02071371f, -0.01924912f, -0.03437716f, 0.03834058f, 
    0.00408861f, -0.04287608f, -0.03749663f, 0.02850480f, 0.01324780f, 0.03098664f, 0.00979533f, -0.05621408f, 
    0.02017166f, 0.01599411f, 0.04147504f, -0.02782097f, 0.02725047f, 0.01588862f, 0.03917766f, -0.04311238f, 
    0.21537262f, 0.11831164f, 0.15943943f, -0.02817740f, 0.09006475f, 0.10928874f, 0.08626892f, 0.10638664f, 
    0.17001708f, -0.02037296f, -0.09056565f, -0.05057372f, -0.31906033f, -0.18428497f, 0.12955734f, 0.32103023f, 
    0.11452062f, 0.06227634f, 0.09228123f, -0.05627348f, 0.07787216f, -0.05905944f, -0.03007600f, -0.27911597f, 
    0.24159309f, 0.51012617f, 0.23504739f, -0.10788228f, 0.11074201f, 0.17990835f, 0.22364219f, -0.06995457f, 
    0.05734964f, -0.06966124f, -0.16140971f, 0.14828825f, -0.04659173f, -0.07893718f, -0.07075268f, -0.01689923f, 
    -0.04360105f, 0.00880210f, -0.03257609f, -0.04240471f, -0.16074140f, -0.01274094f, 0.03333539f, 0.12385740f, 
    -0.40980804f, 0.24150412f, 0.11100373f, -0.28865367f, 0.22192734f, 0.22598098f, 0.16771275f, 0.12871483f, 
    0.01349277f, -0.13221388f, -0.08549365f, -0.02061765f, -0.02028284f, -0.31112698f, -0.39477858f, -0.27257675f, 
    0.04035713f, -0.00987357f, -0.02167475f, 0.06553446f, 0.09310115f, 0.09245182f, -0.02733098f, -0.13601087f, 
    0.06865119f, 0.23341836f, 0.06794883f, -0.04616232f, 0.04656513f, -0.07327052f, 0.10436238f, 0.07812826f, 
    0.03934480f, 0.00815812f, -0.02329633f, 0.04045502f, 0.42543045f, -0.27933550f, 0.02114292f, 0.25306806f, 
    0.04594703f, -0.13399850f, -0.21899499f, 0.07153924f, -0.12068022f, -0.13681252f, 0.12641403f, 0.02789053f, 
    0.11849609f, 0.14902945f, 0.18303807f, 0.05494809f, 0.18236488f, 0.35433680f, 0.07845116f, 0.06413040f, 
    0.05795070f, -0.02327936f, 0.05941736f, 0.07526811f, -0.12123680f, 0.45174363f, -0.28041953f, 0.22232962f, 
    -0.10070960f, 0.03639937f, -0.03016960f, -0.00412548f, 0.09243338f, -0.08305737f, -0.05171538f, 0.03143326f, 
    0.12467786f, -0.05080496f, -0.07831218f, 0.49010801f, 0.28533998f, 0.18029377f, -0.06846195f, 0.16528991f, 
    -0.07145087f, -0.07960540f, 0.10407475f, -0.09406879f, -0.09391738f, 0.01718132f, -0.07069599f, -0.07920425f, 
    -0.07634587f, -0.07302990f, 0.03308069f, -0.00531580f, 0.02663892f, -0.26066694f, -0.07948654f, -0.18835549f, 
    -0.10921909f, -0.05278563f, -0.22944140f, -0.04306091f, 0.07072891f, 0.20732304f, 0.13678773f, 0.03655661f, 
    0.23674440f, 0.06380752f, -0.10112592f, 0.05867078f, 0.08645973f, -0.32257611f, -0.38806185f, -0.12914740f, 
    0.01847818f, 0.02340487f, 0.11977202f, 0.01917545f, 0.03990560f, -0.02557140f, -0.02371141f, -0.14647718f, 
    -0.01139824f, 0.04353270f, 0.15870979f, 0.10602762f, 0.04792071f, -0.11044628f, -0.10717768f, -0.04095427f, 
    -0.04843509f, -0.03811499f, 0.04247800f, -0.07067240f, 0.06217778f, 0.15258534f, 0.07641412f, 0.20961195f, 
    -0.03088976f, -0.00746841f, -0.10028582f, -0.04879918f, 0.03152930f, -0.02972419f, 0.18341070f, 0.15430330f, 
    -0.31682506f, -0.48593456f, -0.43061870f, -0.13284451f, 0.01305444f, 0.21344465f, 0.04279427f, -0.00417388f, 
    0.09614659f, -0.02343627f, 0.24309532f, -0.17449978f, 0.07779592f, 0.21227205f, 0.17198667f, 0.20404013f, 
    0.26714402f, 0.20408103f, -0.04593635f, 0.25538355f, -0.01851225f, 0.02778930f, 0.07363719f, 0.03346363f, 
    -0.04171314f, 0.15110821f, -0.04085597f, -0.06914950f, 0.05858065f, -0.15429522f, 0.07570708f, 0.06469008f, 
    -0.21773961f, -0.12069176f, 0.21629547f, -0.00972678f, 0.30215508f, 0.11724724f, -0.00645402f, 0.01690638f, 
    0.27110294f, 0.12987310f, 0.20729935f, 0.11954963f, -0.09019427f, -0.04601857f, -0.04448804f, -0.00484326f, 
    0.31988990f, 0.29483509f, 0.26752499f, -0.26739037f, 0.11216469f, 0.10038913f, 0.04266011f, 0.10216122f, 
    0.01971043f, -0.09854246f, 0.12399782f, 0.07074336f, 0.10290680f, 0.07741945f, -0.22942013f, -0.15725549f, 
    -0.17104118f, 0.02137437f, 0.06786413f, -0.04820910f, 0.08735372f, 0.00375318f, 0.31270432f, 0.04456224f, 
    0.78397226f, -0.45802259f, 0.44705597f, 0.04774668f, 0.14004011f, 0.12766215f, -0.02023914f, -0.09535405f, 
    0.04914521f, 0.06595527f, -0.04990551f, 0.01160046f, -0.01360820f, -0.01240298f, -0.24369301f, -0.17156522f, 
    0.11062348f, 0.26452637f, 0.08592371f, -0.03083675f, -0.00957875f, 0.01775858f, -0.01377461f, 0.08933339f, 
    0.21173470f, -0.02328258f, 0.20073797f, -0.01588362f, -0.02449878f, 0.21638909f, 0.31933326f, -0.25197655f, 
    0.03516467f, 0.03391609f, 0.11578157f, 0.04265167f, -0.09930070f, -0.11202054f, 0.04139015f, -0.04196435f, 
    0.01011169f, -0.03675877f, -0.08171674f, -0.05730334f, 0.11723349f, -0.09362138f, -0.41056940f, -0.46995458f, 
    0.03379441f, 0.11433085f, 0.06342655f, -0.05067755f, -0.06267457f, 0.02150141f, -0.07096646f, 0.01078693f, 
    0.20761450f, 0.08529554f, 0.12675922f, 0.08528654f, -0.25476667f, 0.09752332f, 0.05500440f, 0.01166793f, 
    -0.06070313f, -0.07416859f, 0.15535484f, 0.12222499f, -0.05437539f, 0.11786313f, 0.14741896f, -0.00369488f, 
    -0.10389346f, 0.03575919f, 0.05532990f, 0.02938345f, -0.01271755f, 0.04878544f, -0.20417280f, -0.02920087f, 
    -0.01287524f, 0.08644969f, 0.09409167f, 0.05340825f, 0.02625000f, 0.11100482f, -0.10161055f, 0.05363680f, 
    0.05590477f, -0.03251213f, -0.23037025f, 0.09299932f, -0.02668511f, -0.13753453f, 0.01507676f, -0.03481099f, 
    0.05043691f, -0.07885331f, 0.26947951f, -0.24912193f, -0.07895887f, -0.13298100f, 0.05850038f, 0.12046523f, 
    0.06314242f, 0.05115256f, -0.22467966f, -0.05532655f, 0.10210405f, 0.06599345f, -0.08732088f, -0.19189331f, 
    -0.06342668f, -0.07716131f, 0.01693456f, 0.10186684f, -0.07584673f, -0.12625591f, -0.09167093f, -0.20608601f, 
    0.26779008f, 0.37042320f, 0.07175062f, 0.00871290f, -0.05280660f, 0.07361920f, 0.09489856f, 0.12941037f, 
    0.07336501f, -0.05682827f, -0.05724886f, -0.09056059f, -0.01559184f, 0.09107587f, 0.00686604f, 0.05637184f, 
    0.22059026f, -0.08627062f, -0.11801385f, -0.03756411f, 0.08525949f, 0.02441810f, -0.00061686f, 0.01078993f, 
    0.06404503f, -0.13687526f, 0.43315348f, -0.23482367f, -0.04760557f, -0.05165035f, 0.19868900f, 0.15929687f, 
    -0.00727544f, -0.02805102f, -0.06510347f, 0.14600700f, -0.11859986f, -0.10401239f, -0.15939872f, -0.09765997f, 
    -0.05653108f, -0.00349085f, -0.15989819f, -0.09879824f, 0.10320438f, 0.08840387f, 0.05885554f, 0.13503911f, 
    0.10587718f, 0.12978534f, -0.11362854f, -0.07697567f, 0.06453392f, 0.01980625f, 0.05821983f, 0.04991340f, 
    0.08538147f, 0.00630813f, 0.04613913f, -0.05342390f, 0.10912488f, -0.00256105f, 0.00130827f, -0.07084484f, 
    0.01089140f, -0.02786756f, -0.10697588f, -0.00988987f, 0.04970261f, 0.09348045f, 0.07116046f, 0.09029083f, 
    -0.01619088f, 0.22521867f, 0.18949670f, 0.12280479f, 0.10662576f, 0.00008150f, 0.01953719f, 0.09695760f, 
    -0.00033183f, 0.03044867f, 0.03660662f, -0.00646542f, -0.36997321f, 0.12474431f, 0.17662482f, -0.21823783f, 
    -0.00733490f, 0.05889213f, -0.17333758f, 0.02217592f, 0.11339780f, 0.01760001f, 0.17579305f, -0.02187987f, 
    0.14869419f, 0.22256631f, 0.26630253f, 0.27071682f, 0.18481378f, 0.07470907f, 0.03092569f, 0.09485014f, 
    0.05017650f, -0.03150047f, 0.04429256f, 0.03256812f, 0.13775036f, -0.27435538f, -0.07837866f, -0.17405339f, 
    0.06888823f, -0.03348156f, -0.00752062f, -0.01113199f, -0.07967158f, -0.00540763f, -0.11219015f, 0.10240272f, 
    0.33156818f, 0.22330976f, -0.05313766f, -0.11422414f, 0.09732866f, -0.04644977f, -0.03684536f, 0.00902414f, 
    0.03105423f, -0.08080760f, 0.06608544f, -0.05168806f, 0.27780107f, -0.34320247f, -0.05266681f, -0.17677613f, 
    -0.06802955f, -0.11631553f, -0.07411109f, -0.00816553f, -0.00867326f, -0.15774088f, 0.04832945f, -0.05478494f, 
    0.42361012f, 0.03157317f, 0.17907576f, -0.04719869f, -0.13526274f, 0.05258415f, 0.18188421f, 0.21224622f, 
    0.03925464f, -0.00857776f, 0.10477786f, -0.13158423f, 0.25728342f, 0.10437375f, 0.29037029f, -0.04492338f, 
    -0.06564323f, 0.05720084f, 0.00437927f, 0.14339902f, -0.00176412f, 0.10260297f, -0.00920633f, 0.01070407f, 
    -0.30076101f, -0.45227003f, -0.47047266f, 0.05228061f, 0.00553785f, 0.08939967f, 0.02029344f, -0.00714903f, 
    0.01705671f, 0.00780864f, 0.06193827f, -0.05588746f, -0.30261728f, -0.45184267f, -0.30417275f, -0.07799657f, 
    -0.00229520f, -0.01398036f, -0.01644929f, -0.08528800f, 0.07838140f, 0.01918198f, -0.05438782f, -0.11416474f, 
    0.30975980f, 0.07148457f, -0.00832506f, -0.05773314f, 0.04527386f, 0.03010407f, 0.03975388f, 0.03290284f, 
    0.06847871f, -0.09860756f, 0.03548299f, 0.02207513f, 0.16387472f, 0.29493070f, 0.22650412f, 0.11552330f, 
    0.06818921f, 0.05451701f, 0.08878412f, 0.00844278f, -0.01187705f, 0.05796450f, -0.05467881f, 0.05500060f, 
    -0.27276942f, -0.14790852f, -0.02184721f, -0.05285851f, -0.04139991f, -0.09194762f, 0.06997214f, 0.03751745f, 
    -0.00462573f, -0.09290581f, 0.00334453f, -0.07135462f, 0.08083242f, 0.31779087f, 0.32619658f, 0.21883175f, 
    0.03963944f, 0.01608256f, 0.01500403f, 0.20008010f, -0.05427814f, 0.01622083f, 0.05624696f, -0.01168386f, 
    0.12602192f, 0.01798727f, 0.41853490f, 0.01516694f, -0.00403979f, 0.09348734f, 0.06265520f, 0.12522642f, 
    0.06952079f, -0.07435437f, 0.03749163f, 0.05900922f, 0.09241480f, -0.24393858f, -0.07944419f, -0.05555507f, 
    0.00216883f, -0.01454557f, -0.05504207f, 0.00358840f, 0.00477072f, -0.08347335f, 0.01404979f, -0.04039360f, 
    -0.13071455f, -0.39578298f, 0.08405661f, -0.10008353f, 0.05904301f, 0.08810849f, -0.05986476f, -0.01325576f, 
    0.05206363f, -0.04999777f, -0.05209026f, 0.08757211f, 0.16371895f, 0.22693786f, 0.13120621f, -0.03507977f, 
    -0.02260576f, 0.15845823f, 0.03153398f, 0.20661221f, -0.04724571f, 0.03058078f, -0.13306029f, 0.01845644f, 
    -0.20702238f, 0.15080453f, 0.18237835f, 0.18903042f, -0.04482989f, 0.07556293f, 0.05776691f, 0.05484313f, 
    0.02467490f, 0.10602933f, -0.07115059f, 0.07242858f, -0.17396425f, -0.17980565f, -0.20263194f, -0.04182784f, 
    0.08403561f, -0.01821463f, 0.00232530f, -0.01123190f, -0.14161590f, -0.11677168f, -0.11532711f, -0.02707248f, 
    0.00810801f, 0.11368766f, -0.09782454f, -0.10977267f, -0.07142640f, -0.22354676f, 0.03788383f, -0.02899234f, 
    -0.03258635f, -0.01153409f, -0.14467548f, 0.05491829f, 0.18281448f, -0.01287660f, -0.13531645f, -0.05428423f, 
    -0.03372005f, -0.03321736f, -0.00758565f, -0.00362865f, -0.11474753f, 0.11515633f, 0.03102197f, 0.05899208f, 
    -0.07687991f, -0.05181668f, -0.22642663f, -0.03729457f, 0.03681839f, -0.01371384f, 0.04082358f, -0.06266552f, 
    0.05160186f, 0.00074607f, 0.06483193f, 0.06711883f, 0.04143304f, -0.12061038f, -0.22731514f, -0.08975273f, 
    -0.01551774f, -0.05071339f, -0.02469901f, 0.01189106f, -0.04416272f, -0.21092218f, -0.02386709f, -0.01487402f, 
    -0.34822771f, -0.04026239f, 0.06870787f, 0.19309075f, 0.05519022f, -0.04579171f, -0.11411735f, 0.06724656f, 
    0.08881535f, 0.02374932f, -0.04724720f, 0.06835619f, 0.21820424f, 0.13853878f, 0.21266295f, -0.00594747f, 
    0.01251642f, 0.01977926f, -0.04122103f, 0.10977139f, 0.07449162f, -0.04671489f, -0.06704424f, -0.03554396f, 
    -0.09115081f, 0.28017125f, 0.09767554f, -0.05263681f, 0.01181274f, -0.02147187f, 0.02514048f, -0.06432664f, 
    -0.06870979f, -0.06910047f, 0.08302680f, -0.05285128f, -0.13111563f, 0.06214191f, -0.12196923f, -0.00531099f, 
    0.20711337f, -0.00570037f, 0.10391960f, -0.05749521f, -0.05054382f, -0.00734174f, -0.22703984f, -0.07490937f, 
    -0.05925797f, -0.42735088f, 0.38701680f, 0.04215911f, -0.19408922f, 0.09191526f, 0.15844515f, -0.02077713f, 
    0.00381735f, -0.06950596f, -0.01146584f, 0.16406617f, 0.05091233f, 0.05883325f, 0.11953045f, 0.06308851f, 
    -0.03186774f, 0.08199044f, -0.03573562f, 0.06586800f, 0.09649822f, -0.06001430f, 0.01154152f, -0.14213838f, 
    0.02853164f, 0.10500170f, -0.12204528f, 0.05671602f, 0.13683711f, -0.03141191f, -0.13591368f, -0.10830078f, 
    -0.03008955f, 0.00754184f, 0.02807008f, -0.13595529f, 0.20963807f, 0.06061735f, -0.10017162f, -0.16245890f, 
    -0.17518625f, -0.12169559f, -0.00684798f, 0.04302425f, -0.01978252f, 0.07754873f, -0.05557650f, -0.10800566f, 
    -0.09554898f, 0.07884783f, 0.08166759f, 0.12812221f, 0.04222887f, 0.03546903f, 0.05109502f, 0.13341643f, 
    0.01871799f, -0.03945652f, -0.05339020f, 0.03983764f, -0.71732599f, 0.04977508f, 0.04072639f, -0.27080613f, 
    0.00451802f, 0.24473208f, -0.04995027f, 0.02210711f, 0.17677565f, -0.18291770f, 0.16974173f, 0.00393139f, 
    -0.01878507f, 0.11852584f, 0.06761650f, 0.15606655f, 0.17668681f, 0.28743219f, 0.12663257f, -0.01315727f, 
    -0.03037688f, 0.01930425f, 0.05496716f, 0.13395847f, 0.41724199f, -0.18850084f, 0.11554756f, 0.21880603f, 
    0.15712996f, -0.07953724f, -0.10158199f, 0.03559647f, -0.06372537f, 0.03605382f, -0.03349859f, 0.00886016f, 
    0.14590353f, 0.05428484f, 0.08257504f, -0.10845299f, 0.17942938f, 0.04618784f, -0.11711677f, -0.02693274f, 
    -0.05598258f, -0.05664198f, 0.06844298f, 0.01860650f, 0.37936512f, 0.08275243f, -0.01003582f, -0.05763569f, 
    0.02314144f, -0.01721406f, -0.07447680f, -0.01611979f, 0.06297036f, -0.11273190f, -0.07132829f, 0.03284379f, 
    0.21439122f, -0.12727529f, 0.32810390f, -0.01032450f, -0.15484999f, 0.01665124f, 0.08221371f, 0.14224818f, 
    0.03820306f, 0.08205880f, 0.06230938f, -0.02974088f, 0.23310430f, -0.12886903f, 0.12327078f, -0.24343020f, 
    -0.11727595f, 0.03508500f, -0.01240485f, 0.04440471f, 0.05214828f, 0.05494140f, -0.05317780f, 0.01092495f, 
    0.14385983f, 0.20507038f, 0.07285051f, 0.06620249f, -0.09171364f, -0.03865424f, -0.03452986f, -0.02076764f, 
    0.02567149f, 0.07152972f, 0.07439893f, 0.10535093f, 0.35603559f, -0.02713194f, 0.08128712f, -0.02691316f, 
    0.01870949f, -0.09490834f, 0.09233684f, 0.05806847f, 0.09102600f, 0.13326551f, 0.01893201f, -0.01520964f, 
    0.12083276f, 0.15564586f, -0.00194050f, -0.18245435f, -0.19806184f, -0.11545487f, -0.12179841f, -0.07851499f, 
    -0.00109977f, -0.05969164f, -0.17747809f, -0.18100888f, -0.04685127f, 0.26929018f, -0.03034703f, 0.10412921f, 
    0.10705350f, 0.13267066f, 0.07953636f, -0.08242175f, -0.11687618f, 0.04970460f, -0.04027396f, 0.01947948f, 
    -0.02234411f, -0.02822684f, 0.06159578f, 0.08317478f, -0.09468134f, -0.10720321f, 0.02741258f, 0.15486237f, 
    -0.08403201f, -0.01749411f, -0.11858970f, 0.13751046f, -0.06564403f, 0.02082558f, 0.19534342f, 0.05404052f, 
    0.03014945f, -0.10271865f, -0.06229843f, 0.04889662f, -0.06594971f, -0.03861790f, 0.00836620f, 0.01602744f, 
    0.06075025f, -0.10207614f, 0.13297060f, 0.01783574f, 0.00808482f, 0.15358394f, -0.13613823f, 0.04169953f, 
    0.08836416f, -0.02397073f, 0.07824103f, 0.10201497f, 0.26160514f, 0.07942048f, 0.13397114f, -0.01210381f, 
    -0.09478389f, 0.03765101f, 0.01047831f, -0.02595440f, 0.05724182f, -0.03953878f, 0.05125646f, -0.21489134f, 
    0.11166785f, 0.00127954f, -0.00980982f, -0.10163458f, -0.16061401f, 0.07830567f, 0.09417907f, 0.02545112f, 
    -0.00849475f, 0.04161328f, -0.02987432f, 0.00042203f, -0.02487519f, 0.22186854f, 0.00070030f, 0.18809934f, 
    -0.15155329f, 0.09461562f, 0.05336674f, -0.00298896f, -0.08047560f, -0.02218248f, -0.09414845f, -0.15676548f, 
    -0.21420224f, 0.09164861f, 0.01557071f, 0.01162899f, -0.05825862f, 0.06594886f, 0.06236719f, 0.01268800f, 
    -0.15349159f, -0.10126554f, 0.08384045f, 0.11995402f, 0.18291213f, 0.05504096f, -0.06868550f, -0.01259642f, 
    0.00649532f, -0.08401956f, -0.02534661f, 0.02205926f, 0.02153561f, 0.09109624f, -0.09361961f, 0.01862786f, 
    0.16622089f, 0.39168143f, -0.01527059f, 0.10785160f, -0.03863941f, -0.13400021f, 0.11286891f, 0.02346577f, 
    -0.03703232f, -0.17027926f, -0.04155951f, 0.00818868f, 0.01249861f, -0.02436969f, -0.08080176f, 0.05499154f, 
    0.11501673f, -0.01465746f, 0.11926650f, 0.14593092f, -0.20162918f, 0.01542522f, 0.10833393f, 0.10468945f, 
    0.00783798f, 0.13282868f, -0.01129477f, 0.12759018f, -0.06668407f, -0.07079878f, 0.01817831f, -0.05671681f, 
    -0.08618062f, 0.01561258f, 0.03320112f, 0.11700065f, 0.29585761f, 0.10819110f, 0.07018799f, 0.07315725f, 
    -0.04195051f, 0.01743848f, -0.05750885f, -0.08010625f, 0.17173401f, -0.01174508f, 0.08321144f, 0.13083503f, 
    -0.42710617f, -0.03873177f, -0.11338522f, -0.02914879f, -0.07373232f, 0.11450028f, -0.16415468f, -0.07281335f, 
    -0.00332682f, -0.09617443f, -0.06461466f, -0.03141906f, -0.03415552f, 0.12533261f, 0.05615110f, -0.01272476f, 
    -0.00154690f, -0.02530244f, -0.02219343f, -0.02966216f, -0.03353901f, -0.10391097f, -0.10282806f, -0.11149292f, 
    -0.12308224f, -0.04018398f, 0.39024010f, 0.24381813f, 0.03126565f, -0.15331067f, -0.00898866f, -0.19610719f, 
    0.33016822f, 0.02384175f, 0.03103589f, 0.05140831f, 0.26825243f, 0.21287972f, -0.25009125f, -0.12114965f, 
    -0.11832380f, 0.22255464f, -0.03085378f, -0.07765789f, 0.35578626f, 0.15748855f, 0.11852818f, 0.23031397f, 
    -0.29878163f, 0.03784395f, 0.41542867f, -0.07844469f, -0.20835614f, -0.11773122f, -0.06396331f, 0.14026989f, 
    0.07992324f, 0.02025450f, -0.05401073f, -0.04497636f, 0.07122184f, 0.01609129f, -0.08606052f, -0.02745578f, 
    -0.00463079f, -0.03330908f, -0.08054909f, 0.00822139f, -0.02460124f, 0.04808641f, -0.02513031f, 0.19839948f, 
    -0.21323100f, 0.31537628f, 0.07171587f, -0.13435924f, -0.02772096f, -0.04269972f, -0.02742651f, 0.03998410f, 
    0.19174881f, 0.08699058f, 0.00316135f, -0.12616600f, -0.07619203f, -0.15600538f, -0.08654556f, 0.09289656f, 
    -0.06808648f, -0.04963112f, -0.01939660f, -0.06936288f, 0.11770094f, -0.09014232f, 0.11572130f, 0.08839334f, 
    -0.26539287f, 0.03397616f, 0.24940033f, -0.16682538f, -0.04244116f, -0.05195638f, -0.11271291f, -0.07418077f, 
    0.00175704f, 0.00675286f, 0.18066725f, 0.01453014f, 0.22649117f, -0.25592616f, 0.07828809f, 0.50379342f, 
    0.06860837f, -0.16089332f, 0.16401246f, 0.18622537f, 0.02998424f, 0.21422921f, 0.03312717f, -0.14222479f, 
    -0.00196493f, -0.10920893f, 0.07837176f, -0.01590260f, -0.12890805f, -0.18767826f, -0.12836978f, -0.02251775f, 
    0.02009116f, -0.04812753f, -0.02067594f, -0.21173035f, -0.26574567f, 0.21702087f, -0.12728800f, -0.24575543f, 
    0.24173908f, 0.16842939f, 0.26672229f, 0.10369524f, 0.13824822f, 0.10403644f, 0.04223092f, 0.13779594f, 
    0.13663293f, 0.46911097f, -0.15840797f, -0.40535489f, 0.08003582f, -0.14109987f, -0.03978028f, -0.00395484f, 
    0.05444269f, -0.04107206f, 0.06488630f, -0.07500955f, 0.11625563f, -0.02903621f, 0.17607944f, 0.06161521f, 
    -0.00875734f, -0.00393368f, 0.16347966f, 0.01818566f, 0.02571965f, 0.01028861f, 0.06020383f, 0.29233143f, 
    -0.31896675f, -0.48833567f, 0.07274237f, -0.03716231f, -0.14088194f, -0.04195942f, 0.13068217f, 0.15529630f, 
    0.08611578f, -0.00344291f, -0.01217649f, -0.03465781f, -0.27662599f, 0.00763774f, 0.29168665f, 0.01430697f, 
    -0.07685743f, -0.04440458f, -0.05527774f, 0.24690619f, 0.02357607f, -0.07250035f, 0.12543899f, 0.02316171f, 
    0.49029058f, 0.07869992f, 0.24428482f, 0.13522153f, 0.07975770f, -0.08681529f, 0.06599696f, 0.08063560f, 
    0.08209396f, -0.06808366f, -0.00846891f, -0.14553207f, 0.17814292f, 0.14458747f, 0.06780544f, 0.12207480f, 
    0.05414835f, 0.02431678f, -0.12613131f, -0.08788569f, 0.02373840f, -0.01745698f, 0.04909645f, -0.28843302f, 
    -0.18717235f, 0.04779931f, -0.13313980f, -0.14856797f, -0.08688346f, -0.13720788f, -0.02234113f, 0.15715098f, 
    -0.03397848f, -0.06722315f, 0.09200662f, 0.02404041f, 0.12369216f, 0.12616600f, 0.12740761f, 0.06072094f, 
    0.02141727f, -0.33110657f, -0.00888823f, -0.10342239f, 0.00778190f, -0.09156694f, -0.07537407f, 0.00399676f, 
    0.10105871f, 0.06541474f, -0.14084582f, -0.01917086f, 0.03858525f, -0.17333654f, 0.07380217f, 0.01207147f, 
    0.07145467f, 0.06959742f, 0.15691739f, -0.10665527f, -0.12265706f, 0.25318062f, 0.14876553f, -0.12565427f, 
    -0.18372688f, 0.02890707f, 0.01813703f, -0.19966902f, 0.07975093f, 0.03162315f, -0.00198588f, -0.06488474f, 
    -0.07705506f, -0.24282259f, 0.34727457f, -0.09649979f, -0.14065975f, -0.08063674f, 0.05021099f, -0.00377719f, 
    -0.07006758f, -0.00273596f, 0.00071735f, 0.02256019f, 0.17846781f, 0.05196872f, -0.09970207f, 0.06498394f, 
    0.10028420f, 0.10355560f, -0.05807989f, 0.04245275f, 0.07754504f, -0.06137928f, -0.16432865f, -0.06183828f, 
    0.42312005f, -0.43616879f, 0.00163545f, 0.10273466f, 0.13050184f, 0.07830814f, -0.17576978f, -0.15056464f, 
    0.05983773f, 0.04311503f, 0.04751226f, 0.09662841f, -0.16391011f, -0.03506044f, 0.25702894f, -0.13200068f, 
    -0.13260368f, 0.02118120f, -0.10734885f, -0.01320255f, -0.02658741f, -0.01828381f, 0.05853106f, 0.03955405f, 
    0.05884602f, -0.22831389f, -0.00973569f, 0.15460584f, 0.13643356f, -0.05670813f, 0.13025425f, 0.11822711f, 
    0.03286347f, -0.11063106f, 0.07772957f, -0.20449430f, 0.46275923f, 0.09994988f, 0.12263426f, 0.04105322f, 
    0.05656724f, -0.07234184f, -0.01487684f, -0.02311951f, 0.28314817f, 0.09315948f, 0.15076813f, 0.15561688f, 
    -0.14233653f, -0.03560697f, 0.26442656f, 0.04232223f, 0.17604357f, 0.13092098f, -0.05393702f, 0.02989839f, 
    -0.05975283f, -0.23056427f, 0.11897991f, -0.12463231f, 0.29618388f, 0.03352094f, 0.04325948f, 0.11803164f, 
    0.01045276f, 0.29684076f, -0.03141879f, 0.27141035f, 0.25895441f, 0.09687756f, -0.05047951f, 0.01442296f, 
    0.15793070f, -0.00605688f, 0.10646742f, -0.04018837f, 0.11870391f, 0.27869099f, 0.05212862f, 0.06652495f, 
    -0.02346101f, -0.14669439f, -0.07087322f, -0.10744425f, 0.34195331f, 0.24341674f, 0.21451010f, 0.05518545f, 
    0.02859655f, 0.04743195f, 0.01481711f, 0.20041810f, 0.06914967f, 0.16673055f, 0.06386598f, 0.08255794f, 
    -0.05127183f, -0.37485123f, -0.08239155f, 0.28066358f, 0.11026188f, -0.12119765f, -0.08191964f, 0.17383157f, 
    -0.00430210f, 0.00895533f, 0.16303210f, 0.09022772f, -0.28737918f, -0.09716361f, 0.24299744f, -0.09895670f, 
    -0.08116637f, 0.01112867f, 0.07513346f, -0.03690296f, 0.04132441f, 0.10392425f, 0.19525498f, 0.38545465f, 
    0.19100411f, -0.14266901f, -0.05508532f, -0.28898764f, 0.00867201f, 0.18464318f, -0.00868898f, 0.21515374f, 
    -0.03501431f, -0.02935147f, -0.06198404f, -0.10506635f, -0.18378632f, -0.19282553f, -0.09043628f, 0.19274783f, 
    0.05367649f, 0.13052776f, -0.00120129f, 0.00501087f, 0.04124152f, -0.10056907f, 0.19471920f, -0.07575355f, 
    0.30196097f, 0.53554702f, -0.13605039f, -0.30557686f, 0.30297464f, -0.06301764f, 0.22740853f, -0.07314217f, 
    0.03660076f, 0.03360271f, -0.12818690f, 0.08917037f, -0.04081052f, -0.07942300f, -0.06912410f, 0.02625091f, 
    0.03788512f, 0.03136333f, -0.13282678f, 0.01646508f, -0.21664228f, -0.13403910f, -0.11403987f, 0.02585378f, 
    -0.04429309f, -0.28431842f, 0.27630252f, -0.35203984f, -0.05558487f, 0.19288166f, -0.03990378f, 0.20598957f, 
    0.09905608f, -0.12919252f, -0.10566108f, -0.08829494f, 0.16839553f, -0.29291072f, -0.07622910f, -0.02331855f, 
    0.12961268f, 0.23201503f, -0.11021550f, 0.00176720f, 0.01827937f, 0.02231097f, 0.10489609f, -0.02888328f, 
    0.30698761f, 0.22665673f, -0.03576844f, 0.08450755f, 0.03564544f, -0.01953261f, 0.07794172f, 0.18837030f, 
    0.03736854f, 0.06030252f, -0.11265288f, 0.11303914f, 0.53609872f, -0.08980153f, -0.05931721f, 0.00549221f, 
    0.00637945f, -0.25192505f, -0.18782040f, 0.08047090f, -0.09577820f, 0.00862336f, -0.09830409f, -0.05013745f, 
    0.17895757f, -0.01883569f, 0.10491455f, -0.10467011f, 0.04941125f, -0.03761524f, -0.09572440f, 0.02025941f, 
    0.10113919f, 0.03813352f, 0.03996523f, 0.00693877f, -0.02361225f, 0.17173621f, 0.07619470f, -0.09946128f, 
    -0.12729809f, 0.00728084f, -0.15660502f, 0.02015924f, 0.15975237f, 0.00171503f, 0.03167883f, -0.00974833f, 
    0.05657405f, 0.04896555f, -0.29698628f, 0.30959913f, 0.19251548f, -0.10719743f, 0.11557399f, 0.11552119f, 
    -0.02165205f, 0.00219491f, -0.03226246f, 0.04276445f, 0.05092182f, -0.15183423f, 0.18445784f, -0.18430878f, 
    -0.04624817f, 0.02948422f, 0.06219638f, -0.03224663f, 0.10329069f, -0.01784439f, 0.00318985f, -0.20451356f, 
    0.19764079f, -0.18781240f, -0.18508771f, -0.20915024f, 0.08134463f, 0.06319610f, 0.09044737f, -0.03642161f, 
    0.25092372f, 0.11321863f, -0.03195792f, 0.06936415f, 0.01321881f, 0.07993253f, -0.11285615f, -0.07260588f, 
    0.13722308f, 0.11496779f, 0.01730562f, 0.00906748f, 0.06016669f, 0.22533569f, 0.07322533f, 0.05365711f, 
    -0.18144332f, -0.23016408f, -0.00678884f, 0.10256121f, 0.07735651f, 0.00223180f, -0.14194712f, -0.15631449f, 
    0.07594139f, -0.03252788f, -0.02648929f, 0.04594974f, -0.28908363f, 0.17048444f, 0.00666166f, 0.15177970f, 
    0.10973264f, 0.01291890f, -0.08929469f, -0.02878325f, 0.10981727f, 0.00562613f, -0.00456347f, 0.19785893f, 
    0.03365874f, -0.42821985f, -0.14557727f, 0.21536601f, 0.14496060f, 0.18848112f, -0.02671250f, -0.04964747f, 
    0.03089202f, -0.07549884f, 0.21004577f, 0.13871962f, 0.08720834f, -0.23387696f, -0.03435011f, 0.02362381f, 
    0.16283965f, 0.05831034f, 0.00750568f, 0.15482241f, 0.05505693f, -0.07005962f, -0.02823471f, 0.10750054f, 
    0.02637993f, 0.12459056f, 0.07188645f, -0.12904845f, 0.07923193f, -0.00797937f, -0.01443229f, 0.07155254f, 
    0.01907162f, -0.05839913f, 0.17127807f, -0.11808573f, 0.17687710f, 0.18337657f, 0.03229885f, 0.03837401f, 
    0.18895790f, 0.19251154f, 0.03781057f, 0.14998546f, 0.02114665f, 0.00707870f, 0.02557255f, 0.08735751f, 
    0.22275616f, 0.24487227f, 0.09790353f, -0.09922510f, 0.09220778f, -0.02725489f, 0.14739969f, 0.04783070f, 
    0.02452572f, -0.10460880f, -0.08921463f, -0.04241513f, 0.19535443f, -0.08586285f, 0.01734721f, -0.08110007f, 
    -0.01067489f, 0.03227970f, 0.02527848f, -0.03559932f, -0.03909682f, 0.03391345f, -0.03788817f, 0.11435734f, 
    0.43057421f, -0.29546639f, 0.08329527f, -0.15386479f, 0.19963484f, -0.10582887f, -0.23436347f, -0.29910612f, 
    0.14349890f, 0.00362871f, -0.02749498f, -0.11402637f, 0.09832443f, -0.25557908f, 0.09476604f, -0.08876403f, 
    0.09701727f, 0.02201765f, 0.05275995f, -0.02322959f, 0.03358564f, -0.07478828f, 0.06413777f, 0.02265495f, 
    0.33341005f, 0.01040991f, 0.10607009f, -0.08037934f, 0.00921908f, 0.02253635f, 0.20885666f, -0.10297027f, 
    0.22155310f, 0.28327224f, 0.00975568f, 0.10295879f, -0.16970034f, -0.10229829f, 0.10556719f, 0.03637817f, 
    0.09029077f, 0.07158604f, 0.02490100f, 0.05571656f, 0.02640034f, -0.05456677f, -0.06739506f, -0.24089807f, 
    0.29362640f, -0.03704782f, -0.08106045f, -0.22792552f, -0.07960419f, 0.06664114f, -0.00523039f, 0.10127357f, 
    0.22440700f, 0.05233043f, 0.07430377f, -0.07872936f, -0.15540037f, -0.07166886f, 0.02427332f, -0.32954434f, 
    -0.14956242f, 0.03930604f, 0.03910403f, 0.05114901f, 0.11198470f, -0.09109111f, -0.04664993f, -0.01729065f, 
    -0.19592544f, -0.06353739f, -0.01971292f, -0.08492538f, -0.04025567f, -0.14847766f, -0.09000235f, -0.04379248f, 
    0.05912161f, -0.02952326f, 0.02732101f, 0.09039451f, -0.10186805f, 0.12834811f, 0.03674067f, 0.03197617f, 
    0.08671732f, 0.06633140f, -0.03365139f, 0.02165374f, 0.04877577f, -0.05662016f, 0.12744604f, 0.09170514f, 
    0.42085823f, 0.07969408f, 0.20344135f, -0.07091825f, 0.05440816f, -0.12808970f, 0.00810417f, -0.00398602f, 
    0.10654720f, -0.01260292f, -0.17299047f, 0.07574874f, 0.19951679f, -0.12681386f, -0.08765754f, 0.06666116f, 
    -0.13169831f, 0.01543275f, 0.13477205f, 0.00075516f, -0.08400070f, -0.22034919f, -0.06059654f, -0.10634097f, 
    0.01029025f, -0.01397593f, 0.03884741f, -0.01618179f, -0.03494922f, -0.05289128f, -0.00066475f, -0.02379413f, 
    0.00038546f, 0.02216318f, 0.03025106f, 0.04251079f, -0.04503185f, -0.02364673f, -0.02326321f, 0.01473776f, 
    -0.05258359f, 0.00626465f, 0.00704767f, 0.01527512f, -0.00334168f, -0.01315405f, 0.00489142f, -0.02607693f, 
    -0.04128146f, 0.04046485f, 0.00361070f, 0.02905095f, -0.02378262f, -0.04630047f, 0.04500709f, 0.03346588f, 
    -0.04173610f, 0.03479331f, -0.02835019f, 0.02141692f, 0.02723939f, -0.03219020f, 0.00484540f, -0.05155150f, 
    0.04213641f, -0.02205627f, 0.03358173f, -0.04982802f, 0.02157554f, 0.02069368f, 0.02472298f, 0.03573172f, 
    0.02320814f, 0.02495144f, 0.00743359f, -0.04842394f, 0.00336950f, -0.04053547f, 0.00990625f, 0.01780241f, 
    0.03804269f, 0.02107244f, 0.02914899f, -0.03871746f, 0.01537771f, 0.03176280f, 0.00579881f, 0.04146137f, 
    -0.03693960f, 0.01708324f, -0.03516455f, -0.04405210f, -0.00303833f, -0.05043911f, -0.04314926f, 0.04572994f, 
    -0.00787685f, -0.01173042f, -0.00423644f, -0.02674581f, 0.03734372f, 0.01618929f, -0.00614516f, -0.02624355f, 
    0.03682428f, 0.03795788f, -0.02410712f, -0.04594371f, -0.04925437f, -0.04809861f, 0.02382736f, 0.02648178f, 
    -0.02916862f, -0.01894978f, 0.04198789f, -0.00187843f, -0.00338468f, -0.02863898f, 0.01558347f, -0.05398929f, 
    0.03351706f, -0.00988082f, -0.03694247f, -0.00894773f, -0.02724089f, -0.02962069f, -0.04692112f, 0.01782768f, 
    0.02877929f, 0.02845496f, -0.02355923f, -0.04220925f, 0.03964925f, 0.03987395f, -0.02189710f, 0.03489186f, 
    -0.04205776f, 0.00042047f, -0.03200461f, -0.03737594f, -0.03954937f, -0.00546631f, -0.03210506f, -0.04962885f, 
    0.03958014f, 0.02402082f, 0.00269069f, 0.00999098f, 0.01219620f, 0.04407851f, -0.02832737f, -0.02623398f, 
    0.00394190f, -0.00108540f, 0.00046239f, -0.02016411f, -0.05247833f, 0.04101984f, 0.00909253f, 0.02268334f, 
    0.02535291f, -0.01959584f, -0.01879906f, 0.03973227f, 0.03589989f, -0.01427988f, -0.00975187f, 0.01915973f, 
    -0.00802968f, 0.03249379f, 0.01514121f, 0.00935659f, 0.01943068f, -0.03071007f, 0.02643145f, 0.00733341f, 
    -0.03492599f, -0.04452877f, -0.02286258f, -0.02022270f, 0.02783157f, -0.01353006f, -0.03640281f, 0.04659196f, 
    0.04306540f, 0.02806244f, 0.02871316f, -0.03429586f, -0.00250315f, -0.03511293f, -0.01898534f, 0.01795895f, 
    -0.02754596f, -0.02285832f, 0.02293722f, 0.02216705f, 0.01536235f, -0.04964091f, 0.00228794f, -0.02999979f, 
    -0.02748968f, -0.00907546f, -0.04803657f, -0.04149358f, 0.04158251f, 0.00363732f, -0.02022962f, -0.03773217f, 
    -0.02930825f, -0.04125827f, -0.00898110f, -0.04959744f, -0.00293995f, -0.02731354f, -0.02631202f, 0.02406795f, 
    -0.00212036f, -0.03540317f, -0.04376251f, -0.02020606f, -0.03655159f, -0.04869044f, 0.01736571f, -0.03449955f, 
    0.03015285f, -0.05296230f, 0.00352513f, -0.03597668f, -0.04837594f, -0.03104153f, -0.05518784f, 0.02340237f, 
    0.03168730f, 0.02921582f, -0.03231230f, -0.04455612f, -0.04185192f, -0.03689692f, -0.03470860f, 0.02808410f, 
    -0.03663108f, 0.00439496f, -0.01871279f, -0.02602701f, 0.02962388f, 0.03148121f, 0.04432713f, -0.00694968f, 
    0.02593812f, -0.00603193f, -0.00240451f, -0.04430676f, -0.02138460f, -0.00882522f, -0.02523293f, -0.00252961f, 
    -0.01721772f, -0.03588573f, -0.03741607f, 0.02879980f, 0.00557996f, -0.02927785f, -0.04906043f, -0.02661446f, 
    0.01582853f, 0.02024685f, -0.04234355f, -0.00489619f, -0.04882295f, -0.05186211f, 0.00014644f, -0.05076931f, 
    0.04374311f, -0.03439228f, -0.05187348f, 0.00807122f, -0.04235152f, -0.02770202f, 0.00095854f, 0.04008840f, 
    -0.01095650f, -0.04672285f, 0.02120875f, -0.04493451f, -0.04187092f, -0.04682033f, 0.02788551f, 0.02475760f, 
    -0.01879369f, 0.03926192f, -0.01466640f, -0.02852399f, -0.01902922f, 0.00304262f, 0.00829358f, -0.02244994f, 
    -0.01033789f, -0.02209981f, -0.00841034f, -0.03033233f, -0.00406680f, 0.00170863f, 0.00927935f, -0.04794045f, 
    0.01514385f, -0.02965335f, 0.02834454f, -0.04470533f, -0.02621087f, 0.01224543f, 0.00169831f, -0.00889032f, 
    -0.02361894f, 0.02264562f, -0.04494904f, -0.03690806f, -0.04624358f, 0.03192198f, -0.03249452f, 0.00194498f, 
    0.02799092f, -0.03161469f, -0.01181679f, -0.03523539f, 0.01151439f, 0.00278352f, 0.02800187f, 0.01250933f, 
    -0.03265498f, -0.04361823f, -0.00748180f, 0.01112348f, -0.02150919f, -0.01503490f, -0.05048700f, -0.03658658f, 
    -0.00897579f, 0.01971678f, 0.01264550f, -0.00634694f, 0.02121696f, 0.03750169f, -0.00271678f, -0.03656654f, 
    -0.04144342f, 0.00912938f, 0.00982481f, 0.01129600f, -0.04031887f, 0.01750982f, -0.01289108f, -0.02734684f, 
    -0.00213026f, -0.05046408f, -0.00132596f, 0.00076578f, -0.03805332f, -0.03692118f, 0.04292627f, -0.00077270f, 
    -0.02922102f, 0.04696077f, -0.05285017f, 0.02621015f, 0.02395825f, -0.04787190f, 0.01968280f, 0.02834434f, 
    0.00276142f, -0.02604985f, 0.01640577f, 0.01304088f, -0.01562027f, -0.03750706f, 0.03817865f, 0.03185986f, 
    -0.02715585f, -0.04294752f, -0.03684543f, -0.02754959f, -0.02560377f, -0.02772170f, 0.00942176f, 0.01360643f, 
    0.02365201f, 0.04349810f, 0.00454463f, -0.04449391f, -0.03857232f, 0.03055883f, -0.03893088f, 0.01767257f, 
    0.03598206f, -0.00751926f, -0.03660213f, 0.03639805f, -0.05551316f, 0.03696503f, 0.03407252f, -0.03360603f, 
    -0.03451348f, -0.04344788f, -0.04199230f, -0.00605420f, 0.01918986f, -0.02680369f, 0.00370205f, 0.02758607f, 
    0.16618636f, 0.12322353f, 0.18229325f, 0.04477282f, 0.11912356f, 0.11875425f, -0.03237057f, 0.18185605f, 
    -0.04406801f, 0.05581161f, -0.02867840f, 0.02046432f, 0.02792578f, 0.12927346f, -0.04826367f, 0.29285124f, 
    -0.01398625f, 0.01953643f, 0.05076905f, -0.20123444f, 0.06704112f, 0.13187078f, -0.08867865f, 0.27590406f, 
    -0.15185919f, 0.05435082f, 0.02515876f, -0.03675410f, 0.10366480f, 0.00671337f, 0.16516571f, 0.23335949f, 
    0.05511324f, -0.19612217f, 0.17806707f, 0.09526720f, 0.28369096f, 0.04627197f, -0.05969208f, -0.08685055f, 
    -0.05166612f, -0.06671222f, -0.23043987f, 0.02197562f, 0.10467316f, -0.01851909f, 0.11345331f, -0.07871922f, 
    0.34539148f, -0.06906430f, 0.32064188f, 0.13251364f, 0.14653471f, 0.08368763f, -0.15532136f, -0.12451068f, 
    0.08664822f, -0.01368664f, 0.12439463f, 0.28437603f, 0.43595496f, -0.04450618f, 0.35011590f, 0.11112358f, 
    -0.05847984f, -0.13660161f, 0.05898771f, 0.11199538f, 0.06657671f, -0.01407724f, 0.10249514f, 0.12363745f, 
    -0.23781531f, -0.03443814f, 0.05070736f, 0.10241736f, -0.01120661f, 0.05223292f, 0.02031768f, 0.10749558f, 
    0.06493596f, -0.07359426f, -0.02865270f, 0.05342331f, -0.73398751f, 0.14405748f, -0.06745832f, -0.34633195f, 
    -0.29658526f, 0.18195559f, -0.22997335f, -0.07124615f, 0.14831619f, 0.04415244f, 0.10334714f, 0.11601768f, 
    -0.09238983f, 0.05180491f, 0.09061097f, 0.28539124f, 0.07819428f, 0.45000246f, 0.10155985f, 0.00794789f, 
    -0.07653783f, -0.11211758f, -0.06003819f, -0.01519871f, 0.35822633f, 0.09056531f, -0.00832433f, -0.02716485f, 
    0.14080545f, -0.18774576f, -0.09278752f, 0.07175382f, 0.03496061f, -0.02523004f, -0.07558022f, 0.03883087f, 
    -0.01274888f, 0.22285812f, -0.08916874f, -0.14193098f, 0.05229817f, 0.07259485f, -0.08261204f, 0.21997540f, 
    0.00269797f, -0.03303438f, 0.09893432f, -0.13866280f, 0.24256392f, 0.27619231f, 0.06079863f, -0.17089173f, 
    0.03040391f, -0.04385329f, -0.20114540f, 0.01808579f, 0.16093032f, 0.02723414f, -0.03540766f, 0.06824227f, 
    0.34725851f, 0.12763532f, 0.46815616f, -0.05219344f, -0.04383714f, 0.02233892f, 0.17995495f, -0.13210385f, 
    0.11714546f, 0.00414232f, 0.03073062f, -0.11229707f, 0.29241028f, 0.08340412f, 0.10898099f, -0.09912574f, 
    -0.00086270f, 0.01512750f, 0.09091538f, 0.13192905f, 0.15052694f, 0.00415950f, -0.05071913f, -0.06188400f, 
    -0.48493129f, -0.23215380f, -0.13537782f, -0.00509291f, -0.28096032f, -0.17669894f, -0.11626306f, -0.05417422f, 
    0.07310555f, 0.00580546f, 0.01639434f, 0.00687849f, 0.11921699f, -0.20087279f, 0.01904412f, 0.03374126f, 
    -0.11057366f, -0.12885724f, -0.06997525f, -0.10228777f, 0.06320915f, -0.09591997f, -0.02723763f, -0.01862813f, 
    0.26524761f, 0.32560277f, 0.29850584f, 0.17765325f, -0.13369982f, -0.06110552f, 0.06761231f, -0.09978430f, 
    -0.00001991f, -0.10225037f, -0.05531470f, 0.02875091f, -0.15905567f, 0.10787179f, 0.01554339f, 0.22679090f, 
    0.08738845f, 0.16570243f, 0.02792919f, -0.16299962f, -0.08045787f, 0.11209688f, 0.01098749f, -0.05652272f, 
    -0.00917644f, -0.15407388f, 0.10902919f, 0.06342406f, -0.02392843f, -0.14066748f, 0.02326358f, -0.12656577f, 
    0.05638115f, 0.12012424f, 0.00374237f, 0.13591315f, -0.15555811f, -0.10409214f, 0.06889683f, 0.10823697f, 
    0.13423382f, -0.11515872f, -0.02947877f, 0.17291656f, 0.06926742f, 0.05740160f, 0.14686272f, 0.12344210f, 
    -0.11785835f, 0.01799445f, 0.15434258f, 0.12270600f, 0.12760454f, 0.16590360f, -0.08025041f, 0.15879922f, 
    0.03429772f, 0.03390921f, -0.00967489f, 0.08205779f, 0.31135589f, -0.05135505f, 0.05171531f, -0.21014814f, 
    0.03265879f, -0.04632791f, -0.09198347f, 0.00594191f, -0.03717899f, -0.02929379f, -0.06775146f, -0.14341614f, 
    -0.42361775f, 0.27115873f, -0.20349257f, 0.04371178f, -0.38946742f, 0.03360584f, -0.06295235f, -0.12929240f, 
    0.07583496f, 0.17134878f, -0.10586005f, -0.08121011f, -0.39458558f, 0.13704501f, 0.09207243f, 0.23266105f, 
    -0.05110101f, 0.13176900f, -0.09064194f, -0.01605178f, -0.02749591f, -0.05652292f, -0.08288177f, -0.03255318f, 
    -0.12401823f, 0.06477265f, -0.03570259f, -0.08396512f, 0.04846305f, 0.10118003f, 0.17719817f, 0.05954444f, 
    -0.18338361f, -0.22131447f, -0.10653312f, 0.04188784f, 0.09759142f, 0.04562476f, 0.03588294f, 0.11923814f, 
    -0.12669496f, -0.14425731f, -0.02916830f, -0.07659540f, 0.06277053f, 0.12489340f, 0.05026599f, 0.08539688f, 
    0.12960781f, 0.15927222f, -0.13017541f, -0.24896757f, 0.19548617f, -0.00401388f, 0.03950068f, -0.17462265f, 
    0.04197399f, -0.09393957f, 0.05566861f, -0.00411929f, -0.04328646f, -0.12924373f, -0.00454941f, -0.15469988f, 
    -0.00720717f, -0.04413578f, -0.13170564f, -0.00393339f, 0.07039122f, 0.02489297f, 0.00004660f, 0.21675959f, 
    -0.05568536f, -0.10231610f, -0.18844669f, 0.03200002f, -0.06249624f, 0.06789823f, 0.07440946f, -0.07794783f, 
    -0.08807561f, -0.11349494f, -0.16032037f, -0.22757453f, 0.05879879f, 0.08768087f, -0.02398877f, -0.02320023f, 
    0.01489113f, -0.08597959f, -0.00731671f, -0.00283170f, 0.21641137f, -0.03145998f, 0.04055339f, 0.04600760f, 
    -0.38606238f, -0.00242021f, -0.08752772f, 0.06055764f, -0.01831501f, 0.02503076f, -0.19080707f, 0.00834948f, 
    -0.01961471f, 0.00194560f, -0.11285124f, -0.09147467f, -0.22867239f, 0.05569359f, 0.12583585f, 0.04399279f, 
    -0.05006959f, 0.03275873f, -0.05360625f, 0.08579123f, 0.11735911f, -0.03618214f, 0.02502559f, 0.13934943f, 
    0.24421264f, 0.01495077f, -0.13537735f, -0.34347677f, -0.01107699f, 0.08860108f, 0.06365209f, -0.18665630f, 
    -0.01766000f, -0.13907686f, 0.04506375f, -0.12254789f, 0.12649684f, 0.13772397f, -0.28978312f, -0.07552185f, 
    0.12217102f, -0.06789390f, -0.00875214f, -0.12926891f, 0.10541265f, 0.01435052f, 0.07867055f, 0.13430725f, 
    0.14685176f, -0.52331048f, 0.13860305f, -0.34613499f, -0.04836001f, -0.06791917f, 0.02406135f, -0.00338287f, 
    -0.01331456f, 0.06696890f, 0.07908036f, -0.05834536f, 0.06727257f, -0.05704546f, 0.06770529f, 0.06057107f, 
    0.03257169f, -0.05356887f, 0.02666476f, 0.01356947f, 0.03973705f, 0.19549949f, 0.07797740f, 0.10419039f, 
    0.19045906f, -0.22136971f, -0.04400123f, -0.16811875f, 0.14722720f, 0.03060849f, -0.03072194f, 0.15482527f, 
    0.06666236f, 0.13695739f, 0.00602806f, 0.14589667f, -0.00075079f, 0.16854766f, 0.37649277f, 0.28526342f, 
    -0.20344968f, -0.01392312f, 0.00051864f, 0.08171193f, 0.17207243f, 0.03368985f, 0.10756704f, 0.02417840f, 
    -0.19570892f, 0.16724475f, 0.11235191f, -0.07258972f, -0.03340695f, 0.01070861f, -0.04297930f, -0.05666242f, 
    0.03983797f, 0.00928092f, 0.10812561f, -0.06474721f, -0.09408460f, 0.29580149f, -0.18295224f, 0.18745677f, 
    0.04951134f, 0.03874522f, 0.15403461f, 0.20649754f, 0.26190838f, 0.07834334f, 0.07742101f, 0.05234023f, 
    0.00287155f, -0.06799757f, 0.08357260f, -0.22349264f, 0.11807304f, -0.08283380f, -0.02594877f, 0.13489123f, 
    0.06533384f, -0.02910992f, 0.03271392f, -0.01217974f, 0.24008866f, -0.61323375f, 0.17121275f, -0.44467029f, 
    0.16742255f, -0.15262848f, -0.10650361f, -0.03480965f, 0.01048429f, 0.11698126f, -0.10508503f, 0.17779928f, 
    0.03278932f, 0.04522108f, -0.17736524f, -0.52554011f, 0.20751502f, -0.01687951f, 0.01024882f, -0.14079110f, 
    0.08848145f, -0.06809306f, -0.00044990f, 0.08898877f, 0.27887186f, -0.30904001f, 0.03646808f, -0.17501980f, 
    -0.02433387f, 0.00218414f, -0.02470851f, 0.02676531f, 0.10035776f, -0.00825787f, 0.00509726f, 0.17867348f, 
    0.25057933f, -0.56069863f, 0.20149955f, -0.14675730f, -0.19817431f, -0.15001000f, -0.02797373f, -0.14874181f, 
    0.20916934f, -0.11202237f, 0.18868080f, -0.10916331f, 0.21939841f, 0.15379035f, 0.22181058f, -0.39621919f, 
    -0.02315709f, -0.02508708f, -0.11994380f, -0.07497866f, 0.02781309f, 0.02941468f, -0.08685891f, 0.00931981f, 
    -0.16257033f, -0.01107683f, -0.20019770f, 0.03926097f, 0.06809108f, 0.06589220f, 0.12346823f, 0.03368718f, 
    0.04587777f, -0.06715064f, 0.01681113f, 0.00812028f, 0.18350197f, -0.14063424f, -0.21903218f, 0.22489046f, 
    0.07006932f, 0.00996428f, 0.03734310f, 0.01097661f, 0.10179995f, 0.04727058f, 0.04420183f, 0.11722950f, 
    -0.12402240f, 0.42962316f, 0.32996401f, 0.22075939f, -0.12936462f, -0.02896310f, 0.05774494f, -0.04444592f, 
    0.12110601f, -0.06097598f, -0.10227799f, 0.11040808f, -0.09349693f, 0.08078134f, -0.09608205f, -0.04576399f, 
    0.16034465f, 0.10672923f, 0.13964513f, -0.06427284f, -0.00765256f, -0.12928696f, 0.09807372f, 0.03155054f, 
    0.08176284f, -0.20464014f, 0.03772799f, 0.14508028f, 0.11091527f, 0.04894089f, -0.09000911f, 0.27009681f, 
    0.11951505f, 0.04061672f, -0.00727696f, -0.13143973f, -0.15062329f, 0.15576482f, 0.14076994f, -0.12217337f, 
    -0.01429159f, 0.04900705f, -0.12436637f, 0.04117822f, -0.00990344f, -0.02948805f, 0.09018238f, 0.00685017f, 
    0.10831378f, -0.27439582f, 0.07911367f, -0.24721134f, 0.03068094f, -0.05764957f, 0.06059592f, 0.06623462f, 
    0.04686739f, -0.01810352f, 0.10151048f, 0.07668651f, -0.15322764f, -0.29777065f, 0.28367710f, 0.28773358f, 
    0.07069168f, 0.03277093f, 0.01280521f, 0.07016316f, 0.05239042f, -0.01743750f, 0.00925539f, 0.03076415f, 
    0.43196896f, -0.47138208f, -0.11140705f, 0.02275445f, 0.05418827f, -0.17302473f, 0.18806866f, -0.04065536f, 
    0.12490425f, -0.08745243f, 0.11145427f, 0.09766168f, -0.02008863f, 0.07823063f, 0.31198522f, -0.04267570f, 
    -0.13626678f, 0.07387852f, -0.03629293f, 0.12508376f, -0.04604172f, -0.01262186f, 0.04662779f, 0.08600906f, 
    -0.36364326f, 0.03068078f, -0.23366848f, 0.18730748f, 0.08537877f, 0.00623368f, -0.17007969f, -0.10759815f, 
    0.01122487f, -0.06644618f, -0.16917408f, 0.04360575f, 0.00863475f, -0.02833485f, -0.19556597f, -0.01656625f, 
    0.01747764f, 0.05414382f, 0.11086457f, 0.00539273f, -0.21397503f, 0.01393113f, 0.03760009f, 0.14235073f, 
    -0.07776133f, -0.24389948f, -0.09304044f, 0.06870057f, -0.16703597f, -0.32075009f, -0.03223945f, 0.07707223f, 
    0.11411437f, -0.01818195f, 0.11371490f, 0.23303036f, 0.32948628f, -0.08331795f, -0.17548724f, -0.05854398f, 
    0.10876220f, 0.08536702f, 0.15099227f, 0.01897704f, 0.07964687f, 0.05332178f, -0.05048484f, 0.13012375f, 
    -0.08303244f, -0.00699822f, -0.20978418f, -0.04616446f, 0.04621604f, 0.13013107f, 0.04685149f, 0.03721704f, 
    0.05308000f, -0.04143193f, -0.01587859f, 0.04519864f, 0.02939850f, 0.03747934f, -0.15852459f, -0.10038716f, 
    0.16391599f, 0.02899194f, 0.14205092f, 0.07250368f, 0.05135333f, -0.04405420f, -0.04195802f, 0.00204073f, 
    -0.16000508f, -0.16853167f, 0.08056290f, 0.51242602f, -0.09055815f, 0.01265549f, 0.07318805f, 0.16574325f, 
    0.19928582f, -0.10165110f, 0.07095180f, 0.07141111f, -0.02348234f, 0.01087737f, 0.20991117f, -0.14472526f, 
    -0.03134099f, 0.05508321f, -0.00835511f, -0.16596924f, 0.05998781f, 0.03534583f, -0.01676035f, 0.01672354f, 
    -0.33239374f, -0.34325910f, 0.24769457f, 0.22495970f, 0.20240244f, -0.13221233f, 0.12955792f, 0.04496166f, 
    -0.05572100f, 0.04283313f, 0.11876923f, 0.02606495f, 0.21361543f, -0.34256187f, 0.28021762f, -0.05090576f, 
    0.15604691f, 0.17642708f, 0.01959531f, 0.20375425f, -0.00360192f, 0.12722005f, -0.04658720f, 0.07903745f, 
    -0.02806778f, -0.06315666f, -0.50251335f, 0.33258909f, -0.20471437f, 0.04200745f, 0.16647181f, 0.04345022f, 
    -0.09974962f, 0.05762737f, 0.18212070f, -0.14622498f, -0.01037214f, 0.02672017f, -0.01746156f, -0.01869175f, 
    -0.04708245f, 0.06716860f, -0.11879957f, 0.03012516f, 0.18456109f, 0.00696745f, 0.08707469f, 0.02563682f, 
    0.04213744f, -0.08766588f, 0.40040591f, 0.45834106f, 0.27897459f, 0.14960569f, 0.10677820f, 0.06759682f, 
    -0.11688937f, 0.12418716f, 0.03790034f, -0.00220620f, -0.14226428f, -0.18851447f, 0.02559704f, -0.05419489f, 
    -0.05020758f, 0.03638119f, 0.06529016f, -0.07472740f, -0.15383849f, -0.05967841f, 0.06155122f, -0.02499826f, 
    0.03876886f, -0.15885857f, 0.05488040f, 0.01935257f, 0.02508255f, 0.06099778f, 0.05674867f, -0.07394874f, 
    -0.04211741f, 0.07036443f, -0.07435159f, -0.02898939f, 0.06075465f, 0.29402944f, -0.00328313f, -0.11819900f, 
    0.15261938f, -0.15632091f, 0.05612041f, -0.05320301f, 0.11603298f, 0.17929392f, 0.08726004f, 0.09543935f, 
    -0.16945469f, -0.25147921f, -0.19752651f, 0.04303448f, -0.11837517f, -0.10546220f, 0.08359632f, -0.25081080f, 
    -0.02706189f, -0.03180559f, -0.13956079f, -0.00434244f, 0.21236171f, 0.06481180f, 0.12762198f, 0.04766117f, 
    -0.12783095f, -0.11380079f, -0.06685404f, 0.12920256f, -0.02834012f, 0.07125156f, 0.13608086f, -0.00123074f, 
    0.11207743f, -0.08143973f, 0.13145600f, 0.06218336f, -0.23165216f, 0.11231784f, -0.07756700f, -0.13418044f, 
    -0.08244295f, -0.02531972f, -0.06169006f, 0.01662020f, -0.00017433f, 0.59687561f, 0.10292114f, 0.18412659f, 
    -0.03500567f, -0.00093796f, -0.08183005f, -0.26134035f, 0.07015269f, 0.18622574f, 0.10103524f, 0.09988256f, 
    -0.24325559f, 0.11972238f, 0.21802007f, 0.18264125f, 0.03221499f, 0.00327623f, 0.26879582f, 0.02100872f, 
    0.11704121f, -0.08676247f, 0.10071618f, -0.04744443f, -0.43304420f, -0.30767569f, -0.11363088f, 0.05873694f, 
    -0.16379964f, -0.00639343f, 0.02970030f, 0.23472786f, -0.02084416f, 0.12009805f, -0.07036757f, -0.07923520f, 
    0.11305680f, 0.41145986f, 0.45755985f, -0.17586029f, -0.17550710f, -0.16557056f, -0.07677773f, -0.09614592f, 
    -0.04823981f, 0.12161721f, -0.11076651f, 0.18937273f, 0.24040624f, 0.32179165f, 0.43803203f, -0.17579272f, 
    -0.15580431f, -0.03404569f, -0.11765683f, 0.04285743f, -0.10816893f, 0.16767579f, -0.10374443f, 0.09523623f, 
    -0.01740465f, 0.16961232f, 0.00799783f, 0.30142215f, -0.00361654f, 0.00439764f, 0.16728869f, 0.16433053f, 
    -0.04394383f, 0.11453286f, -0.02042191f, 0.06012894f, -0.08352263f, -0.19211002f, -0.10140832f, 0.07568163f, 
    -0.19181533f, 0.04182861f, 0.06924423f, -0.22852178f, 0.10440601f, -0.16552284f, -0.10503989f, -0.01234945f, 
    0.14268370f, 0.08337162f, -0.01204198f, -0.08215518f, -0.11839565f, 0.08438158f, -0.01398384f, -0.11398402f, 
    0.30026442f, 0.13280241f, 0.04624099f, 0.02808075f, -0.15103577f, -0.16500096f, -0.22359106f, -0.06057578f, 
    -0.16532820f, 0.01513438f, -0.08338043f, -0.30847546f, -0.06800303f, -0.10353487f, -0.17335309f, -0.12394188f, 
    -0.22582895f, 0.03745139f, -0.32431161f, 0.24059658f, -0.12475272f, 0.09095832f, -0.01291240f, -0.11014193f, 
    0.00256157f, -0.04608866f, -0.06080375f, 0.08626328f, -0.14940737f, -0.02580925f, -0.18470691f, -0.12059823f, 
    0.04637205f, 0.01026911f, 0.12415460f, 0.18273883f, 0.10414623f, -0.00223883f, -0.03845657f, 0.21838222f, 
    0.15044676f, 0.89645702f, -0.34659374f, 0.30391979f, -0.27096155f, 0.15507586f, -0.23489143f, -0.16495581f, 
    -0.03290401f, 0.12053549f, -0.01596314f, 0.11516137f, 0.08951456f, -0.04499298f, -0.10821504f, 0.22607517f, 
    0.11639471f, 0.04718975f, 0.15871131f, -0.02033251f, -0.04680403f, -0.08487607f, 0.17603926f, -0.15443598f, 
    -0.01301646f, -0.15731382f, -0.50800741f, -0.16048212f, -0.03393963f, -0.10082173f, -0.01617455f, 0.14006725f, 
    -0.12324670f, 0.25612691f, 0.01604263f, 0.08337536f, -0.11812261f, 0.22701068f, 0.15012728f, -0.16859671f, 
    -0.07448068f, -0.18461241f, -0.20297690f, -0.08082166f, 0.02784399f, 0.16975084f, 0.18038154f, -0.06968260f, 
    -0.16733693f, -0.07373451f, -0.10336886f, -0.02213729f, 0.10101078f, -0.07690281f, 0.08859646f, 0.09043099f, 
    0.04566842f, 0.21128897f, 0.17939076f, -0.03898297f, -0.03136580f, -0.16337048f, 0.18574265f, 0.16397138f, 
    0.06697715f, 0.07817113f, -0.13290048f, 0.12696543f, 0.13279317f, 0.01626536f, -0.17647651f, 0.07441125f, 
    0.08867893f, -0.03818734f, 0.22550382f, -0.14686111f, 0.05933066f, -0.14516509f, -0.09331208f, -0.11650724f, 
    -0.06231291f, -0.03015016f, -0.09049456f, 0.09713554f, -0.02370038f, 0.11324100f, 0.37780464f, -0.06980975f, 
    -0.14662148f, -0.02601305f, 0.03567318f, -0.11932670f, 0.04940662f, 0.16031209f, -0.10112302f, 0.04351231f, 
    0.30246192f, 0.24917458f, -0.50751674f, -0.10225453f, 0.15144093f, 0.09573667f, 0.11455364f, 0.19587304f, 
    0.04830122f, 0.08261739f, 0.35220391f, 0.01960753f, -0.05660320f, -0.10974922f, 0.03606552f, 0.18132520f, 
    0.02731060f, 0.11314531f, 0.15090577f, -0.03361838f, -0.02884929f, -0.09526769f, 0.08600556f, -0.08492698f, 
    -0.03385958f, -0.02516516f, -0.03689866f, -0.05377683f, -0.02753638f, 0.00734951f, -0.04982543f, 0.03138681f, 
    0.01794025f, -0.01551602f, 0.02198715f, -0.03729565f, 0.02612843f, 0.01695392f, -0.03842065f, 0.00117029f, 
    0.01169465f, 0.01084002f, 0.01602373f, -0.00687343f, -0.02173682f, 0.01274097f, -0.05542619f, -0.01767933f, 
    -0.05017453f, -0.01445101f, -0.05629493f, 0.01411007f, -0.03382130f, -0.04633930f, -0.05117425f, 0.02714574f, 
    0.04121340f, -0.00033657f, 0.02470181f, 0.03626538f, -0.04633659f, 0.01989268f, 0.01374422f, -0.00212727f, 
    0.00348073f, 0.02395292f, 0.01625954f, -0.00925791f, -0.00533000f, 0.00771724f, -0.04222872f, -0.03123602f, 
    0.02461558f, -0.00242031f, -0.05664133f, -0.05284294f, 0.00844837f, 0.03239745f, 0.00383033f, -0.01351103f, 
    0.01017853f, 0.04123458f, -0.02528315f, -0.00849357f, 0.02168890f, 0.03133340f, 0.02848014f, 0.01239579f, 
    -0.03984262f, -0.00220394f, -0.03855061f, -0.04864025f, 0.01588777f, -0.01469050f, 0.02866521f, -0.03056787f, 
    -0.03042508f, 0.02775425f, -0.03921778f, 0.02989565f, 0.02844211f, 0.00035462f, -0.00655893f, 0.02102185f, 
    0.03569921f, 0.02482978f, 0.04007145f, 0.02996819f, 0.03979753f, 0.04036506f, -0.00907706f, -0.04887261f, 
    -0.04794636f, -0.05079782f, -0.01734981f, 0.00012493f, -0.04949139f, -0.03901544f, -0.00871758f, 0.01037218f, 
    -0.04322838f, 0.01294748f, 0.02124444f, -0.03402404f, -0.05272439f, 0.00222652f, -0.05197884f, 0.00691991f, 
    0.01599249f, -0.02816397f, 0.03918012f, -0.05287486f, -0.01269205f, -0.03973707f, -0.04765863f, -0.01045797f, 
    -0.01292380f, -0.04839836f, 0.00717952f, 0.00074376f, -0.01893095f, 0.04140171f, 0.01965297f, -0.02764426f, 
    -0.05438811f, 0.03924923f, -0.02428851f, -0.04781022f, 0.03830295f, 0.00825156f, -0.01198081f, 0.00050256f, 
    -0.05733564f, -0.04530819f, -0.04497145f, 0.04257959f, -0.00669274f, -0.01839788f, -0.02271217f, -0.03782569f, 
    0.00526573f, 0.02089341f, 0.01256711f, 0.01059752f, -0.03729115f, -0.00101383f, -0.00163237f, 0.00302266f, 
    -0.00241999f, -0.02903903f, 0.03810154f, 0.00461208f, 0.00296356f, -0.01123136f, 0.01665447f, -0.00788825f, 
    -0.00003705f, 0.03135775f, -0.03542535f, 0.03617623f, -0.03477094f, 0.02317868f, -0.01536663f, -0.00542057f, 
    -0.03961048f, -0.00504656f, 0.01394958f, -0.01552198f, -0.04832430f, -0.02482474f, 0.01117674f, -0.02009823f, 
    -0.04040247f, -0.00933866f, 0.03708218f, 0.00360344f, -0.05680264f, 0.00994469f, -0.05280657f, 0.04074314f, 
    -0.00199067f, -0.02401592f, -0.02922362f, 0.02063745f, -0.05398167f, -0.01759213f, 0.01094568f, -0.01993471f, 
    0.04031964f, -0.03180047f, 0.00488008f, -0.00973372f, -0.00799754f, -0.00456882f, -0.05492875f, 0.03791724f, 
    0.01357491f, -0.04514969f, -0.04558764f, -0.02028402f, -0.00001233f, 0.00729780f, 0.01956011f, -0.03116919f, 
    0.02477275f, 0.03625854f, -0.05766825f, 0.03921707f, 0.00098915f, -0.03967925f, 0.03438652f, -0.01536844f, 
    -0.01618663f, -0.00498851f, -0.00433676f, -0.03581257f, -0.03487222f, -0.03851338f, -0.03763369f, 0.02449051f, 
    -0.00797345f, 0.02305232f, -0.00440245f, -0.01786041f, 0.02720928f, -0.00093656f, -0.01178944f, -0.01359126f, 
    0.00208331f, 0.02008223f, -0.00782651f, -0.05842842f, -0.01345349f, 0.00748392f, 0.02226457f, -0.05611124f, 
    0.02249123f, -0.00693847f, 0.03592649f, -0.03320877f, -0.01228454f, 0.00847952f, -0.00816365f, -0.02602953f, 
    -0.02446428f, 0.01019901f, -0.01799976f, -0.00518365f, 0.03669243f, -0.02196170f, 0.01997500f, -0.05641066f, 
    -0.00859235f, -0.03559061f, -0.04312238f, -0.05683823f, -0.04633315f, 0.04004557f, 0.04360701f, 0.00211110f, 
    -0.05652411f, -0.01138319f, -0.01863628f, 0.02389710f, -0.02838468f, 0.02864606f, 0.01167146f, 0.02967618f, 
    0.02967651f, -0.02066583f, 0.00215383f, -0.04718783f, -0.01074689f, -0.03047864f, -0.03682248f, -0.03851682f, 
    -0.03179940f, -0.02769936f, -0.00542241f, 0.00935600f, 0.03502217f, -0.01153084f, -0.00726558f, 0.02106394f, 
    0.01465145f, -0.01162929f, 0.02467036f, -0.01443587f, 0.00827020f, -0.05132221f, -0.01483423f, -0.05693187f, 
    -0.05727805f, -0.00728341f, -0.05907643f, 0.00668084f, -0.03601145f, -0.02106922f, 0.00542638f, -0.02993731f, 
    -0.03314580f, 0.01683241f, -0.02158010f, 0.03882331f, -0.00162309f, 0.03815443f, 0.00720124f, -0.03689694f, 
    0.00643140f, 0.04396250f, 0.02596186f, -0.00374272f, 0.02686756f, -0.04906538f, -0.00903250f, 0.01435278f, 
    0.00207979f, -0.01931183f, 0.02755892f, -0.04673507f, -0.03568769f, -0.02658383f, -0.03600792f, 0.02612801f, 
    -0.04426381f, -0.03289161f, -0.00814910f, -0.00502463f, 0.01849875f, -0.02904041f, -0.05446800f, -0.04878821f, 
    -0.02360356f, -0.00467982f, -0.05625023f, 0.00191430f, -0.02828152f, -0.03983899f, -0.00084090f, -0.01992780f, 
    -0.03205556f, -0.01675121f, 0.02807435f, 0.03059548f, -0.02900954f, -0.00104529f, -0.05627926f, -0.02417704f, 
    -0.01464661f, 0.01760497f, 0.00743826f, -0.03430573f, -0.02813971f, 0.02409465f, 0.03460489f, 0.00907008f, 
    0.03517929f, -0.05049150f, -0.00390164f, 0.02997318f, -0.05765093f, 0.03134901f, 0.01918897f, 0.01622286f, 
    -0.00731986f, 0.02694859f, 0.01851781f, -0.00756596f, -0.04458593f, 0.03743724f, -0.05362477f, 0.00683357f, 
    -0.03064511f, 0.03871826f, 0.02281269f, 0.02463529f, -0.04679073f, 0.00844354f, -0.04642207f, 0.02133727f, 
    -0.05172358f, -0.05411363f, 0.02796987f, 0.02658839f, 0.00337992f, -0.05330830f, 0.01832683f, -0.00316688f, 
    0.03475821f, -0.07945533f, 0.16101566f, 0.13878652f, -0.01307501f, -0.01219555f, 0.02391563f, 0.29167354f, 
    0.07557635f, 0.01180136f, 0.10590782f, 0.01968555f, -0.29383740f, 0.06749122f, 0.10094427f, 0.03016226f, 
    0.05447657f, 0.09287873f, -0.06201724f, -0.07285039f, 0.05877971f, 0.09754153f, -0.07023049f, 0.21481450f, 
    0.08438712f, 0.14025623f, -0.09523420f, -0.22520478f, 0.01058068f, -0.01083980f, 0.28478843f, 0.22549133f, 
    -0.04180866f, -0.09036378f, -0.04833600f, -0.17664765f, 0.03345525f, 0.06307744f, -0.02213471f, -0.24305645f, 
    -0.05233239f, 0.33149686f, -0.37001258f, -0.22666097f, 0.11050154f, 0.01512819f, 0.17357615f, -0.04537893f, 
    0.33438316f, -0.14956778f, 0.46874532f, -0.13562226f, -0.19779108f, 0.25466090f, -0.20457102f, -0.11796986f, 
    0.05441729f, 0.04051512f, 0.03651906f, 0.14772782f, 0.69356042f, -0.16750903f, -0.00364568f, 0.38213846f, 
    0.07020159f, 0.01016411f, 0.00927870f, -0.37697807f, -0.07026175f, -0.07596856f, 0.12854801f, 0.09787639f, 
    0.23365931f, 0.10494537f, 0.16068070f, 0.25546122f, 0.17416570f, -0.04049922f, 0.05715482f, 0.05030696f, 
    0.03313048f, -0.02103924f, -0.01428631f, 0.08204436f, -0.62021458f, 0.15681814f, 0.41025963f, -0.09251508f, 
    -0.13814110f, 0.13492839f, -0.37349200f, -0.30036801f, 0.17883374f, 0.03453452f, 0.08969148f, 0.19030479f, 
    -0.02135507f, 0.03134165f, 0.12515378f, 0.25012353f, 0.02521166f, 0.07516690f, -0.07091487f, -0.09576096f, 
    -0.08176117f, -0.00136599f, 0.04684757f, -0.12509401f, 0.28266627f, -0.05772979f, 0.18147933f, -0.37203148f, 
    -0.07949378f, 0.01462569f, -0.02515453f, 0.27343580f, 0.09969922f, 0.17342706f, 0.05936322f, 0.05410736f, 
    0.04407276f, 0.42679927f, 0.07660469f, -0.16667058f, -0.00071913f, -0.06889773f, -0.07876907f, 0.12522317f, 
    -0.00430891f, 0.08758881f, -0.04392675f, 0.05658335f, 0.16965011f, 0.01498462f, 0.37282923f, -0.02252903f, 
    -0.17167878f, 0.03573987f, -0.09264127f, -0.07086252f, 0.04886876f, 0.20509978f, -0.00230398f, 0.17367861f, 
    0.39814076f, -0.26199508f, 0.49211794f, -0.07907037f, 0.12428661f, -0.03592784f, 0.06294369f, -0.12847404f, 
    -0.11136069f, -0.03806070f, -0.00831357f, -0.10039715f, -0.31839806f, -0.16973338f, 0.09966757f, 0.03461644f, 
    0.10035960f, 0.07202443f, -0.07333524f, -0.00224903f, 0.03538201f, 0.02743400f, -0.15954775f, 0.03891040f, 
    -0.15343355f, -0.02441012f, 0.01407276f, 0.14129277f, -0.18933655f, -0.17471930f, -0.14076413f, 0.09581368f, 
    0.05792543f, -0.08539494f, 0.01648089f, -0.01056276f, -0.07813594f, 0.00955650f, 0.07055255f, -0.00905796f, 
    0.13597347f, -0.08450045f, 0.04161559f, -0.14926347f, 0.11679219f, -0.01236288f, -0.11621768f, -0.02608787f, 
    0.57514894f, 0.03746444f, 0.07923611f, -0.08929340f, 0.02110272f, -0.02583209f, 0.13222252f, -0.11039478f, 
    0.05396961f, -0.03922884f, 0.02564872f, 0.08515248f, 0.08401109f, -0.08115184f, 0.06933729f, 0.07037158f, 
    0.02785476f, -0.05949217f, 0.15010767f, -0.01438506f, -0.12235041f, -0.02713623f, -0.11797502f, -0.09705894f, 
    0.16062838f, -0.08897003f, 0.06939782f, 0.11220989f, -0.17684101f, 0.13773264f, 0.13523725f, -0.25042188f, 
    0.11783237f, -0.02176976f, -0.05627984f, 0.08891764f, -0.02020243f, 0.12152665f, 0.00097873f, -0.03657076f, 
    -0.01633213f, -0.00742126f, 0.10246721f, 0.19979540f, 0.07334778f, -0.02479914f, -0.05274078f, -0.05161457f, 
    -0.01672872f, 0.06094594f, 0.07950635f, 0.18193825f, 0.05348619f, 0.08762066f, 0.08629272f, 0.11100484f, 
    -0.01520038f, 0.04921741f, -0.10807346f, -0.00126888f, 0.31368726f, -0.03797586f, -0.08888885f, -0.18401293f, 
    0.10702887f, 0.08632736f, -0.17302525f, 0.00755349f, -0.04491175f, -0.04821523f, -0.28658339f, -0.20466432f, 
    -0.27910253f, 0.20133059f, -0.31987476f, 0.22404002f, -0.15201297f, -0.15848942f, -0.17844433f, -0.49457979f, 
    -0.04939281f, 0.21532388f, -0.28036350f, -0.14037062f, 0.17884471f, 0.17915167f, 0.19576263f, -0.05072905f, 
    -0.05362064f, -0.05561629f, 0.13494213f, 0.01884599f, 0.04716246f, 0.02512880f, 0.13285224f, -0.18141761f, 
    0.04797405f, -0.08440993f, -0.20755175f, -0.00485236f, 0.13094965f, -0.05744088f, 0.09366863f, 0.07982970f, 
    -0.13565798f, 0.05683303f, -0.18253638f, -0.02465769f, 0.06804071f, 0.06577608f, 0.10346221f, 0.17327911f, 
    -0.00769697f, -0.03344345f, 0.05077875f, -0.06225466f, 0.08268117f, 0.22860177f, 0.31178948f, 0.16516145f, 
    0.11176666f, 0.09857774f, -0.22677296f, -0.35928887f, 0.05817972f, 0.14182234f, 0.07701162f, -0.09452631f, 
    -0.09439307f, 0.02535084f, 0.00218252f, -0.17096660f, -0.21451031f, -0.17207423f, 0.07746614f, -0.31675258f, 
    -0.00107907f, -0.03340968f, -0.06105059f, -0.07825352f, 0.21718344f, -0.05493277f, -0.30816799f, -0.02970934f, 
    -0.01002744f, -0.18424077f, -0.06012756f, 0.09480152f, 0.03541914f, -0.26526263f, 0.05059200f, -0.14510590f, 
    -0.16945370f, -0.22800951f, -0.11387626f, -0.27083960f, -0.20289424f, 0.22786130f, 0.16282710f, -0.01743495f, 
    -0.04868389f, 0.01550205f, 0.16309889f, -0.02343365f, -0.00990607f, 0.01655192f, 0.05215188f, 0.18914182f, 
    0.05887010f, 0.00923894f, -0.14109097f, 0.09728492f, 0.22272961f, -0.00286248f, -0.06211108f, -0.09242502f, 
    -0.04052794f, 0.05363823f, 0.05092993f, -0.05887505f, -0.03515043f, -0.02471236f, 0.01438967f, 0.08757249f, 
    0.03843963f, -0.09598120f, -0.01473542f, 0.18039864f, 0.03230512f, -0.03442045f, 0.08049238f, 0.17024736f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02072359f, -0.01989006f, -0.01771053f, -0.10396788f, 0.03881871f, 0.05445015f, 0.00996646f, 0.10135831f, 
    0.02269333f, 0.19708258f, 0.00836243f, 0.02178905f, 0.16708198f, 0.19418645f, 0.02811720f, 0.02246402f, 
    0.00474378f, -0.06402230f, -0.03241489f, -0.09987523f, -0.04357815f, 0.04576717f, 0.06050636f, 0.04901724f, 
    0.08278599f, 0.09327267f, -0.02357632f, 0.08507491f, 0.20098110f, 0.11616475f, -0.04019655f, -0.05963503f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14891884f, 0.36834028f, 0.33431238f, 0.20233704f, 0.02572839f, -0.11261538f, 0.00774175f, -0.17075157f, 
    0.43030813f, -0.48329946f, 0.10808306f, 0.06058868f, -0.56695843f, -0.66905963f, 0.08550287f, 0.12591599f, 
    0.14527911f, -0.14024836f, -0.16856878f, 0.21935360f, 0.07973229f, 0.09308762f, 0.00788986f, -0.12628902f, 
    -0.28612930f, 0.20294118f, -0.05805210f, -0.09088410f, -0.02340453f, -0.61031640f, 0.14955275f, 0.03010865f, 
    -0.12414123f, -0.50198072f, -0.39113471f, -0.33674866f, 0.04814897f, 0.43284518f, -0.00855725f, -0.12497994f, 
    0.36803362f, 0.18637246f, 0.03133149f, 0.34802806f, -0.08453085f, -0.04929811f, -0.15859754f, 0.39787042f, 
    -0.03503045f, -0.75557923f, 0.12216086f, -0.00265828f, -0.13252756f, -0.06078475f, 0.23937221f, 0.28657925f, 
    -0.03619523f, 0.02790440f, 0.04302013f, 0.06984161f, 0.03721547f, 0.23703741f, 0.02814705f, 0.23691003f, 
    -0.07989922f, -0.19671533f, 0.25918832f, -0.33738288f, -0.16234210f, -0.68911827f, 0.02157710f, 0.19923609f, 
    -0.26001042f, 0.13813561f, -0.12386257f, -0.46475491f, 0.16400917f, -0.04530516f, 0.16750066f, -0.05525105f, 
    -0.30756375f, 0.07962564f, -0.13791536f, 0.00295890f, -0.10349569f, -0.27298480f, -0.28010872f, -0.01153818f, 
    0.01957624f, -0.12850453f, -0.17590907f, 0.47004250f, 0.39271694f, 0.43835875f, -0.06690746f, 0.41148525f, 
    0.04390967f, -0.05765186f, 0.13038042f, 0.29591104f, -0.10674311f, -0.14131683f, 0.09074479f, 0.18970895f, 
    -0.53321898f, -0.00994176f, -0.16272330f, -0.21948171f, -0.12759252f, 0.13150387f, 0.11847948f, 0.15575935f, 
    0.02466305f, 0.26345250f, 0.06187786f, 0.22897589f, 0.06035371f, -0.04331119f, -0.18582362f, -0.41283256f, 
    -0.19805492f, 0.27325121f, -0.05263734f, 0.11428057f, -0.99555558f, 0.24086383f, -0.02006886f, 0.18942538f, 
    -0.03189771f, -0.37253535f, 0.04014669f, 0.09853628f, 0.16887018f, -0.15063597f, -0.08858535f, 0.17961206f, 
    -0.28655124f, -0.17349015f, -0.05388789f, 0.12331246f, -0.08968283f, -0.46966517f, 0.16004196f, -0.27476203f, 
    0.14978953f, 0.50754273f, -0.02904883f, 0.05538129f, -0.17229681f, -0.00629518f, 0.16359037f, 0.30049568f, 
    0.21885386f, -0.04710532f, 0.09153074f, 0.16125011f, 0.12228640f, -0.44902474f, 0.03940526f, -0.08618896f, 
    0.07193428f, 0.19958211f, -0.10938623f, -0.02618206f, 0.06698730f, -0.07846914f, -0.02561841f, 0.18911417f, 
    0.08621433f, 0.02083596f, -0.04232910f, 0.31059676f, 0.03653922f, 0.20087822f, 0.03050518f, -0.29674360f, 
    0.08537473f, -0.12617755f, -0.10260190f, -0.43708140f, 0.00343401f, 0.35387892f, 0.15334857f, -0.07120989f, 
    0.06874875f, 0.29653990f, -0.08377884f, -0.08539543f, 0.18730792f, -0.53120416f, 0.10373803f, -0.31142852f, 
    0.03705477f, 0.15603875f, 0.39451087f, -0.04946716f, -0.06252789f, 0.23667036f, -0.05205941f, -0.58777571f, 
    -0.59748369f, 0.33097813f, -0.04221879f, -0.49199694f, 0.08556242f, 0.21747297f, 0.15758446f, 0.10735849f, 
    -0.21352062f, 0.30361417f, 0.05000925f, -0.34866729f, 0.03653214f, -0.65479994f, -0.95303726f, -0.19324398f, 
    0.12562993f, -0.06335577f, -0.05267306f, -0.25778112f, 0.29240099f, 0.22794384f, -0.01742744f, -0.76830590f, 
    -0.08254676f, 0.38918075f, -0.46507522f, -0.46950871f, -0.04148619f, 0.17977528f, -0.01712077f, -0.29483309f, 
    -0.02334948f, -0.16686244f, -0.12892367f, -0.20897350f, 0.22851682f, -0.13342099f, -0.02240751f, -0.23705594f, 
    -0.52869087f, 0.38784593f, -0.06822153f, -0.12273331f, 0.00656540f, 0.21786621f, -0.33576125f, 0.21367949f, 
    0.27592361f, 0.25290272f, 0.00138511f, 0.03673106f, -0.34746274f, -0.09763583f, -0.00012082f, 0.47331563f, 
    0.10929962f, 0.04517528f, -0.31935573f, -0.09165467f, 0.02834407f, -0.35564995f, -0.16309221f, 0.37349907f, 
    0.17392288f, -0.40561101f, -0.11911397f, -0.57425040f, 0.19349571f, 0.44308639f, 0.12233019f, 0.07508701f, 
    -0.12184043f, -0.32804707f, -0.09991071f, -0.49141216f, 0.07004020f, 0.19661896f, -0.35850704f, -0.18033223f, 
    -0.16916819f, 0.30109775f, 0.07836021f, -0.69309539f, 0.05242896f, 0.43189490f, -0.09808179f, -0.27964121f, 
    -0.16139413f, -0.35058510f, 0.16631562f, 0.08015509f, -0.01775778f, 0.44183356f, -0.12965877f, -0.28214869f, 
    0.38066024f, 0.15683651f, -0.11862349f, -0.21264939f, 0.11189017f, 0.07880596f, -0.05364433f, -0.93869513f, 
    0.12150111f, 0.14180115f, 0.15505329f, 0.01023929f, -0.06072707f, -0.69821453f, 0.11464317f, -0.23126292f, 
    0.03944853f, 0.05885591f, -0.13133959f, -0.09391358f, 0.30160671f, -0.38047844f, -0.08633278f, 0.33559978f, 
    -0.07816217f, 0.01368557f, -0.45594865f, 0.20871678f, -0.16190898f, -0.09349239f, -0.00194328f, 0.14582102f, 
    -0.26106682f, 0.41792247f, 0.16806328f, -0.26717457f, 0.35204980f, 0.32872695f, -0.10421701f, 0.06572201f, 
    0.09455305f, -0.30044612f, 0.11586226f, 0.28545812f, -0.10010275f, 0.00482402f, 0.00007043f, 0.40038353f, 
    -0.65022153f, -0.56156933f, -0.10166471f, 0.10911211f, -0.45948482f, -0.14395542f, -0.13680036f, -0.66469789f, 
    -0.04784425f, 0.34158826f, -0.54073435f, 0.22649091f, 0.05697823f, -0.19686934f, 0.17061582f, 0.00670296f, 
    0.22181256f, 0.37473032f, -0.16118790f, -0.07991201f, -0.05728986f, -0.08608641f, -0.08611827f, 0.19860297f, 
    0.22504903f, 0.26565686f, 0.02469175f, 0.06993217f, 0.04690605f, -0.07506768f, -0.64135349f, -0.45363450f, 
    0.37727526f, -0.60266024f, -0.03499399f, -0.71372706f, -0.43675068f, 0.29167649f, -0.17206748f, -0.26346317f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14223340f, -0.00735661f, -0.03095438f, -0.08971797f, -0.16914228f, 0.03518127f, 0.06759160f, 0.05951764f, 
    0.09423519f, 0.07029320f, 0.17839892f, 0.06388660f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
