#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.74011427f, 0.20558602f, -0.57141191f, 0.75265354f, 0.07979848f, -0.08352657f, -0.01578774f, 0.10313704f, 
    -0.17170291f, -0.54301399f, -0.84047389f, -0.44615915f, -0.49372920f, -0.17275429f, 0.00094349f, 0.26056349f, 
    -0.19825509f, 0.01552196f, -0.04781706f, -0.20218724f, -0.41594368f, -0.45306769f, 0.43586120f, 0.68284208f, 
    -0.04486254f, -0.01691037f, 0.21358326f, -0.77556366f, 0.23893644f, 0.46609160f, -0.38727951f, -0.07335190f, 
    0.56443667f, 0.18621711f, -0.27468637f, 0.14084592f, 0.30667984f, -0.15516374f, -0.31703797f, 0.26853549f, 
    -0.45663777f, 0.26973277f, 0.31160945f, 0.13170059f, 0.53696835f, 0.70535332f, -0.35558596f, -0.38700995f, 
    -0.39655077f, -0.19060196f, -0.02590889f, -0.22020994f, -0.27529207f, -0.01026762f, 0.32456025f, 0.48299560f, 
    0.57584631f, -0.74784350f, 0.47760737f, -0.28355667f, 0.28452855f, -0.10622589f, 0.31751725f, 0.58955109f, 
    -0.57393777f, 0.50226140f, -0.16063099f, 0.21515262f, -0.37675351f, -0.42592463f, -0.39850804f, -0.20505106f, 
    0.44446033f, 0.14619796f, 0.50935173f, 0.53485864f, -0.44979650f, 0.27555120f, 0.15243384f, -0.21700101f, 
    -0.08132882f, -0.54320788f, -0.10910524f, 0.15256287f, 0.43426821f, 0.68424153f, 0.25860161f, -0.06576719f, 
    -0.15287158f, -0.25141731f, 0.58371764f, -0.29535627f, -0.09074028f, -0.64278173f, -0.70314187f, -0.68946505f, 
    0.43925890f, -0.00976000f, 0.15119530f, 0.63765866f, 0.29148251f, 0.54030663f, 0.44900739f, 0.47350642f, 
    0.47296238f, -0.41595805f, -0.05340732f, 0.17101477f, 0.17544374f, 0.19194923f, 0.79525208f, 0.49431470f, 
    0.05437106f, -0.15682752f, 0.47468445f, 0.54581046f, 0.01534735f, -0.33843732f, -0.53581721f, 0.47207862f, 
    -0.60755736f, -0.27748579f, -0.43961003f, 0.03649865f, 0.27742317f, 0.06361304f, -0.73033494f, 0.42585009f, 
    -0.46574968f, 0.06479887f, -0.01137815f, -0.27216268f, -0.25692958f, 0.08425027f, 0.25682068f, 0.66030687f, 
    0.21499202f, 0.38423505f, 0.11508857f, -0.12749699f, 0.18684284f, 0.06922397f, 0.53735548f, -0.03995762f, 
    -0.52432561f, 0.72957289f, -0.60082167f, -0.39017618f, 0.51735115f, -0.32019651f, -0.23648971f, -0.14599228f, 
    -0.14441088f, -0.65955645f, -0.61497778f, -0.59634483f, 0.29690415f, 0.57845140f, 0.23475578f, -0.05230212f, 
    0.11742909f, -0.24327117f, 0.41164488f, 0.60390699f, 0.51174104f, -0.43586257f, -0.31661728f, 0.52407491f, 
    0.23609346f, 0.02475704f, -0.10640955f, 0.38834968f, 0.09704199f, 0.42751205f, -0.47992393f, -0.87759531f, 
    -0.59235680f, -0.12451128f, 0.08591161f, 0.39987370f, 0.55744374f, 0.80253983f, 0.70969117f, 0.02835110f, 
    -0.68016279f, -0.40909475f, -0.35930392f, -0.23086028f, 0.00225298f, 0.04060061f, -0.59878314f, -0.45334592f, 
    -0.06635461f, -0.68946600f, -0.29585743f, -0.08459821f, -0.28540948f, -0.06634131f, -0.96222657f, 0.64724773f, 
    0.35347807f, 0.66126448f, 0.26193759f, -0.20031010f, 0.14343120f, -0.17028002f, 0.01411300f, -0.24837859f, 
    -0.53975379f, -0.54731071f, 0.62230825f, 0.24088740f, 0.55979604f, 0.19756357f, 0.11163406f, -0.14845984f, 
    -0.60863745f, -0.67865306f, -0.66723961f, 0.37884319f, -0.21109818f, 0.01953440f, 0.16507538f, 0.05854729f, 
    0.46251455f, -0.53782701f, -0.43346366f, -0.60654896f, -0.85388589f, 0.27800947f, 0.53716588f, 0.45169583f, 
    -0.01922307f, 0.24707359f, 0.07733627f, 0.26805857f, -0.61675584f, 0.06788347f, -0.54014486f, 0.09997458f, 
    -0.40669635f, -0.29797384f, 0.38949645f, -0.32359427f, -0.23233902f, -0.46496570f, 0.36633822f, 0.00356872f, 
    -0.62308443f, 0.13875245f, -0.08924168f, -0.42123941f, -0.53860366f, 0.06237744f, 0.51747125f, 0.35884595f, 
    0.58214998f, -0.36193535f, 0.05215058f, 0.09698863f, 0.56812119f, -0.06546221f, 0.86326665f, -0.54381222f, 
    0.54060405f, -0.14394182f, -0.20340036f, 0.22455707f, -0.02296046f, -0.01422801f, 0.51170218f, 0.49111235f, 
    0.45385757f, -0.17090991f, 0.62615460f, 0.02459911f, -0.24015331f, 0.11647020f, 0.39961931f, -0.31297740f, 
    -0.29798168f, -0.30564132f, 0.09906196f, 0.86032170f, -0.28315297f, -0.08084682f, -0.38701913f, 0.24561290f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.24527942f, 0.05986004f, -0.18142860f, -0.07403430f, 0.23914111f, -0.17117526f, -0.08102739f, -0.02619075f, 
    0.30359772f, -0.21471168f, -0.05920324f, -0.11756177f, -0.26524243f, 0.21152119f, 0.13122165f, 0.07946858f, 
    0.00741766f, -0.16287905f, 0.25062355f, -0.09811154f, 0.12359550f, 0.02252936f, -0.05760835f, 0.23029691f, 
    0.13707468f, -0.07876399f, -0.10983291f, 0.13203827f, -0.32735974f, 0.11192329f, 0.21935159f, -0.14424302f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04517623f, -0.00725183f, -0.05728825f, -0.02442632f, 0.02529875f, 0.00847937f, 0.04540606f, -0.04562248f, 
    -0.05715710f, -0.03968239f, -0.01806583f, 0.02728596f, 0.04654591f, 0.03092802f, -0.05398484f, -0.00590270f, 
    0.00115832f, 0.02450740f, -0.04460045f, -0.00888278f, -0.01704856f, -0.00201913f, -0.05582508f, 0.03655681f, 
    -0.00209766f, 0.00407552f, -0.02655991f, -0.00029427f, 0.00604769f, 0.05336867f, -0.04276217f, -0.00553867f, 
    -0.05160928f, -0.02288942f, 0.04930859f, -0.05733715f, -0.03440752f, -0.04972382f, -0.02766409f, -0.03253937f, 
    -0.01098849f, -0.05137455f, -0.03288453f, -0.05183167f, -0.04274869f, -0.05235744f, -0.02156141f, -0.04799093f, 
    0.03665289f, 0.01888418f, -0.00155603f, -0.02420195f, 0.03728237f, -0.01053847f, -0.03335881f, 0.01177179f, 
    0.01281473f, -0.00525121f, -0.00419216f, -0.03077069f, 0.05559482f, -0.05669666f, 0.02021727f, -0.01966276f, 
    0.01582404f, -0.04756695f, 0.05310838f, 0.02257180f, 0.02717557f, 0.00041247f, 0.03762416f, -0.06872649f, 
    -0.00989624f, -0.02963219f, 0.04155279f, 0.05359226f, -0.00032734f, 0.03859465f, -0.00126638f, -0.02244557f, 
    -0.06755996f, -0.01825927f, 0.04528287f, 0.02276716f, 0.02145261f, 0.01034433f, 0.01162355f, -0.01380347f, 
    0.01698409f, -0.03631102f, 0.01457320f, 0.00952288f, -0.05749599f, -0.02965423f, 0.03021703f, 0.02966155f, 
    0.00174098f, 0.00402028f, -0.05092429f, -0.03580460f, 0.00150948f, 0.01732679f, 0.00965640f, 0.03077648f, 
    0.03737958f, 0.05165730f, -0.02357215f, -0.06329605f, -0.03463870f, -0.00616867f, 0.02599638f, -0.03806276f, 
    -0.00812384f, 0.03600130f, 0.05116366f, 0.03257081f, 0.00353729f, 0.01100565f, 0.04121528f, 0.00626268f, 
    0.00845388f, 0.02174165f, 0.01907294f, 0.03277959f, 0.03082944f, 0.04408742f, -0.00785184f, -0.05709748f, 
    -0.05408978f, 0.02298608f, -0.01629265f, 0.01972840f, -0.04707582f, -0.00369988f, -0.03254186f, -0.03017416f, 
    0.03456236f, -0.03387426f, -0.06498402f, 0.03893731f, -0.02917874f, -0.06630344f, -0.02383664f, -0.04342466f, 
    0.02989030f, -0.05985035f, 0.03485986f, 0.01868278f, -0.02289337f, -0.01076739f, -0.05447942f, -0.03134758f, 
    -0.05378828f, 0.04095914f, -0.03789625f, -0.01950495f, 0.01753593f, -0.01141645f, -0.05944828f, -0.03482243f, 
    0.02889219f, 0.03464728f, -0.02117701f, 0.03127844f, 0.03484465f, -0.00876874f, -0.03044062f, 0.03310753f, 
    0.00852872f, 0.03577203f, 0.00929736f, 0.03979255f, 0.00571109f, 0.01569679f, 0.00189727f, 0.04198079f, 
    -0.00172884f, -0.00272797f, -0.00549252f, -0.00958263f, -0.00176290f, 0.00938667f, -0.05953933f, -0.05202556f, 
    -0.00234743f, 0.00837650f, 0.02402275f, 0.02941283f, -0.05820685f, 0.00510291f, 0.03359344f, -0.02905559f, 
    -0.03173538f, 0.04978747f, -0.01370770f, 0.00124301f, -0.05534866f, -0.01485536f, -0.00382286f, -0.04960530f, 
    0.02016930f, 0.04798818f, -0.01720932f, -0.03706329f, -0.05653126f, -0.05845241f, 0.00340880f, 0.03702449f, 
    -0.06755077f, 0.01007324f, 0.03983892f, 0.02243409f, -0.04805437f, -0.06399887f, -0.03360196f, 0.02028717f, 
    0.01511439f, -0.05408868f, -0.04474407f, -0.01780229f, 0.01501981f, -0.05320090f, -0.05681296f, -0.00507865f, 
    -0.02001784f, -0.03135515f, 0.01888968f, 0.01578119f, -0.03095748f, 0.04399964f, 0.01613678f, 0.03644084f, 
    0.04529278f, -0.01114436f, 0.04715349f, 0.00698811f, -0.01188505f, -0.06568886f, 0.01844483f, -0.01337282f, 
    -0.04773478f, 0.02472017f, 0.02907086f, -0.01740213f, -0.05223532f, 0.01053843f, -0.05909092f, 0.04657887f, 
    0.00186327f, 0.03414521f, -0.00008816f, 0.02090345f, -0.04038206f, 0.00402477f, 0.02397208f, -0.03732784f, 
    -0.01813914f, 0.03281894f, -0.06037154f, -0.05987332f, 0.00637119f, -0.03926905f, -0.02761462f, 0.01344886f, 
    -0.04655230f, -0.06786714f, -0.00634193f, -0.06044390f, -0.06824094f, 0.00151787f, -0.02640126f, -0.03051180f, 
    -0.02407778f, -0.00518309f, 0.01816267f, 0.02806759f, 0.02846865f, -0.01023122f, -0.00878570f, 0.02816067f, 
    -0.04911760f, -0.06370287f, -0.00589508f, 0.04488652f, -0.00334911f, -0.01673728f, -0.05832784f, -0.00605377f, 
    0.05648583f, 0.11996806f, 0.02955051f, 0.02509150f, 0.05596618f, -0.01345791f, -0.06393217f, -0.05613854f, 
    -0.01740002f, -0.13958126f, 0.11433112f, -0.17954749f, -0.13006160f, -0.01646980f, 0.03859398f, -0.04493881f, 
    0.13089111f, 0.07747768f, -0.15073150f, 0.03134247f, 0.05910657f, 0.05063739f, 0.00901707f, -0.07259307f, 
    0.08837485f, -0.00513048f, -0.06009223f, -0.24101664f, 0.14251655f, 0.01130426f, 0.01144646f, 0.01343213f, 
    -0.04129031f, 0.06844189f, 0.09334884f, -0.01828747f, -0.01203690f, -0.10008910f, -0.02173413f, 0.12433331f, 
    -0.02099972f, -0.03688550f, -0.02480063f, 0.09632558f, -0.04307605f, -0.11512896f, 0.29838654f, -0.06720140f, 
    0.08487177f, 0.15552603f, 0.07188627f, 0.19403113f, -0.06280088f, -0.07418492f, 0.12521930f, -0.04338437f, 
    0.05388911f, 0.13074479f, 0.07961385f, -0.00158292f, 0.01110617f, 0.09887595f, 0.03289797f, -0.37791845f, 
    0.12375940f, -0.09389646f, -0.11207804f, 0.14496557f, 0.14571570f, 0.03318206f, -0.00381543f, -0.02269104f, 
    0.04050418f, -0.31838000f, 0.06009093f, 0.07460328f, 0.02866188f, 0.01696278f, -0.03273001f, 0.08640110f, 
    -0.02106686f, -0.20500799f, -0.01802327f, 0.02470297f, -0.11286377f, -0.15158720f, 0.08908125f, -0.08197192f, 
    -0.00992270f, -0.08790279f, 0.20377420f, 0.13897678f, -0.04868493f, 0.11192790f, -0.15512867f, -0.02467800f, 
    0.00692135f, 0.08602187f, 0.07392551f, -0.31398040f, -0.11978585f, -0.09689879f, -0.00630457f, 0.14388041f, 
    0.06780736f, 0.09104147f, -0.05554814f, -0.18770619f, 0.20200817f, -0.04160375f, -0.14810486f, -0.03347182f, 
    0.06836902f, -0.00530617f, 0.00358093f, 0.04851855f, -0.01278016f, 0.09257957f, 0.04326494f, -0.17242827f, 
    0.08683226f, 0.03457257f, 0.05857246f, 0.13859035f, 0.03308285f, -0.01939053f, 0.05225845f, -0.08683697f, 
    -0.06793079f, -0.13531110f, -0.03423958f, 0.00666115f, 0.04927984f, -0.03544598f, 0.02072989f, -0.05806799f, 
    -0.19946986f, -0.04653742f, 0.05685417f, 0.07433172f, -0.08395478f, 0.10812019f, 0.08998284f, 0.08703421f, 
    0.05167096f, -0.05666855f, -0.03279402f, -0.10115453f, 0.04430163f, -0.03824639f, 0.05771565f, 0.08295429f, 
    -0.00101026f, 0.00953009f, 0.07680914f, 0.01671505f, -0.14629909f, -0.14236796f, 0.01974490f, -0.12831534f, 
    0.03887894f, 0.02495096f, 0.32871747f, 0.04929619f, -0.08727026f, 0.08648824f, 0.03460713f, 0.02257629f, 
    0.02841686f, -0.06323057f, -0.07423672f, 0.10130786f, 0.19651061f, 0.00086952f, -0.02501902f, -0.02545026f, 
    0.05471748f, 0.09234543f, 0.01348885f, -0.10676517f, 0.43829057f, 0.09138447f, -0.03941626f, -0.08395412f, 
    0.02583998f, -0.03962224f, 0.11752333f, -0.03213901f, 0.08152400f, 0.10792126f, 0.03963494f, -0.07513711f, 
    -0.04514703f, 0.00524853f, 0.03645829f, -0.02325884f, -0.04191898f, -0.01255840f, -0.07144699f, -0.13665035f, 
    -0.20111316f, 0.03798408f, -0.00495103f, -0.06972577f, 0.00717581f, -0.02200367f, 0.00656601f, 0.02613360f, 
    0.06092212f, -0.07199840f, -0.08548729f, 0.06133494f, 0.04912421f, -0.09874720f, 0.03900209f, -0.00986556f, 
    0.08818024f, -0.03761716f, -0.09829921f, -0.18713681f, -0.10053581f, 0.04579449f, 0.10346879f, 0.03701100f, 
    -0.00692346f, -0.17232671f, 0.05917318f, -0.00321659f, -0.09074044f, 0.12370313f, -0.02482191f, 0.06989501f, 
    0.09254747f, 0.14030552f, 0.08954323f, 0.04595092f, -0.05393256f, 0.04245014f, 0.08560867f, -0.08065511f, 
    0.04220206f, 0.06193210f, -0.10100895f, 0.03252089f, -0.09752093f, -0.01966863f, -0.15419608f, -0.12736936f, 
    -0.01760074f, -0.11206190f, 0.04489988f, 0.07301757f, 0.00548609f, 0.11617568f, -0.04939157f, -0.00869389f, 
    -0.03065400f, 0.03834072f, 0.08389349f, -0.01851689f, -0.06601844f, 0.12475730f, -0.26216590f, -0.08545934f, 
    0.04277053f, 0.12225001f, -0.00758094f, 0.08593286f, -0.10365313f, -0.08292781f, -0.05819870f, -0.00915130f, 
    -0.01692892f, 0.13979377f, 0.06109473f, 0.07465713f, 0.09514605f, -0.04651722f, -0.14412917f, 0.08724070f, 
    -0.10414112f, 0.00998422f, -0.12169421f, -0.01041101f, 0.18348606f, -0.09015162f, 0.15652153f, 0.03729425f, 
    0.00348728f, -0.05949141f, -0.06140986f, 0.05532408f, -0.04859492f, -0.00340654f, 0.01160990f, -0.04146050f, 
    -0.04714777f, 0.04677891f, 0.02518037f, 0.04800400f, -0.04228694f, -0.04985455f, -0.06417801f, -0.03993712f, 
    0.04689562f, -0.04484962f, -0.05436412f, 0.03644377f, 0.02072709f, 0.04313004f, -0.02682489f, -0.03573010f, 
    0.04878747f, 0.05192181f, -0.01633510f, 0.05247368f, 0.00243046f, -0.01081828f, 0.00591441f, -0.05475346f, 
    0.03969547f, -0.01569705f, 0.00163245f, 0.03427223f, -0.00919397f, -0.04462003f, -0.00806935f, 0.02075207f, 
    -0.00794343f, -0.03334542f, -0.05640466f, -0.01175092f, 0.04274587f, 0.03803698f, 0.01119499f, 0.00984857f, 
    0.01726558f, -0.02879137f, 0.04001864f, -0.02620513f, -0.06435496f, -0.03754092f, 0.01579217f, 0.01507339f, 
    -0.04952142f, -0.03022316f, -0.00883048f, -0.03677398f, -0.06382789f, -0.05418352f, 0.02742973f, -0.05888147f, 
    -0.02791481f, 0.02965001f, 0.03228504f, -0.03339211f, -0.03592671f, 0.00629007f, -0.00818936f, 0.02605236f, 
    -0.00711246f, 0.04991088f, 0.03522052f, -0.00135119f, 0.02859148f, 0.01551755f, -0.00413249f, 0.04158830f, 
    -0.05694404f, 0.02442321f, -0.02004919f, -0.06467764f, 0.00835660f, 0.00692979f, 0.05257739f, 0.00389665f, 
    -0.06345476f, 0.05368490f, 0.01103045f, 0.04465142f, 0.03783148f, -0.06081761f, 0.03235888f, 0.00738317f, 
    0.01050263f, 0.03695502f, 0.01852888f, 0.05390457f, -0.03043428f, 0.00687552f, -0.03774475f, -0.02326374f, 
    0.00324803f, 0.02820154f, -0.00703155f, -0.06120027f, -0.01797437f, -0.06004484f, -0.01890340f, -0.04731124f, 
    -0.02393087f, -0.06301627f, -0.05019163f, 0.05216375f, -0.03325582f, -0.01275566f, 0.03856252f, -0.03437391f, 
    0.02985395f, -0.05618338f, -0.02781371f, 0.05014284f, -0.04300805f, -0.04914189f, -0.06064139f, -0.00034347f, 
    -0.01462931f, -0.00505529f, 0.02886159f, 0.01345846f, 0.00018203f, -0.03588213f, -0.01417576f, -0.00523588f, 
    0.01650515f, 0.04109576f, 0.01820992f, 0.04882734f, 0.04257716f, -0.02619876f, 0.02761605f, -0.04624462f, 
    -0.04401871f, -0.02776841f, 0.05236369f, 0.02761518f, 0.05364909f, -0.03601530f, -0.03673307f, -0.01496104f, 
    0.00509016f, -0.04970394f, 0.02783923f, -0.02594277f, 0.00882908f, -0.04196254f, -0.05090764f, 0.01718057f, 
    -0.03280000f, 0.04302533f, -0.06264969f, 0.04142326f, -0.01115519f, 0.03885354f, -0.02859087f, 0.04546711f, 
    -0.04225499f, -0.01464989f, 0.00787877f, -0.01609769f, -0.03455067f, -0.05351949f, 0.03728152f, -0.04533055f, 
    0.03457922f, -0.02787387f, -0.05963242f, -0.01813186f, 0.03995371f, 0.01914709f, -0.05754825f, -0.06180152f, 
    -0.02643801f, -0.06242365f, -0.01215977f, 0.01451823f, -0.06118701f, 0.04412507f, -0.00736195f, -0.04597852f, 
    -0.04536337f, 0.04316008f, 0.00049620f, 0.03098253f, 0.04278916f, -0.05596520f, -0.04043931f, -0.03419999f, 
    0.03090593f, -0.01784075f, 0.03567671f, 0.03830807f, 0.04494043f, 0.04833325f, 0.04996385f, -0.00972322f, 
    -0.01544981f, 0.03133464f, 0.01596534f, 0.01286533f, -0.00699067f, -0.03723699f, -0.03044634f, -0.06505432f, 
    -0.06313089f, -0.04980443f, -0.00498765f, 0.02469936f, -0.03476226f, -0.03429418f, 0.01320090f, -0.05444749f, 
    0.04263996f, -0.00841633f, -0.04549103f, 0.01482524f, -0.01941747f, -0.03259544f, 0.01165883f, -0.03856068f, 
    -0.00658217f, 0.03163766f, -0.01129128f, -0.02478918f, -0.02619859f, -0.00861984f, 0.03998091f, 0.01107922f, 
    0.04194670f, 0.02103007f, -0.00599883f, -0.00864667f, -0.02146220f, -0.06383151f, -0.03992106f, -0.04583848f, 
    -0.04833230f, -0.05305125f, 0.03925950f, 0.02168570f, -0.04474931f, 0.04744960f, -0.00576371f, -0.02550180f, 
    0.01467808f, -0.02236522f, 0.05266991f, -0.00625096f, -0.02381707f, 0.02013207f, -0.01484132f, -0.03443588f, 
    -0.00494637f, 0.05366284f, 0.01557759f, 0.01698034f, -0.03984037f, -0.06144692f, 0.02322517f, -0.05535726f, 
    0.04736058f, -0.00378607f, 0.03838218f, -0.03937371f, -0.03313929f, 0.04419833f, 0.03264340f, 0.04550755f, 
    0.03321718f, -0.05019620f, 0.03639777f, -0.02839312f, -0.02313204f, -0.05290916f, -0.03845825f, 0.01996231f, 
    0.06020794f, 0.08653113f, 0.08983466f, 0.08047348f, -0.06363834f, 0.02984113f, -0.03047466f, 0.02373379f, 
    -0.04468764f, -0.06717460f, -0.09713495f, 0.06471447f, -0.10935606f, 0.04028811f, -0.13857472f, -0.23057905f, 
    0.06587982f, 0.11528322f, 0.00341821f, 0.00926183f, -0.02746424f, -0.04654164f, 0.00861093f, -0.00796358f, 
    0.13854635f, -0.10730721f, -0.09397135f, 0.26239994f, 0.11777836f, -0.20903623f, -0.08623509f, -0.07844167f, 
    -0.11513452f, 0.03288371f, -0.14883077f, -0.23316419f, 0.05565216f, -0.03157909f, -0.07054324f, -0.07200689f, 
    0.03423906f, -0.06652407f, -0.06763702f, 0.16062675f, -0.03330129f, -0.20493904f, -0.12358364f, 0.14299700f, 
    -0.05710922f, 0.08968492f, -0.02079076f, 0.09585223f, -0.06780630f, -0.03900436f, -0.32293499f, 0.15764952f, 
    0.05066443f, 0.11086233f, 0.00051794f, 0.09509894f, -0.03333349f, -0.02663175f, 0.01942694f, -0.05479334f, 
    -0.10322348f, 0.04150002f, 0.07321695f, 0.17369910f, -0.04116964f, -0.10697669f, 0.05703264f, -0.07985990f, 
    -0.13967445f, -0.02729282f, -0.02883323f, 0.03283150f, 0.00845321f, -0.00295777f, -0.06777845f, 0.08273517f, 
    -0.17874488f, 0.30188364f, 0.14561152f, -0.13124414f, 0.01778841f, -0.15445036f, 0.10060127f, 0.03802558f, 
    0.12465171f, -0.02483920f, 0.15047540f, -0.03374434f, 0.13244490f, 0.08378058f, 0.04582579f, -0.09603064f, 
    -0.04297714f, 0.07169729f, 0.11512122f, -0.35739276f, -0.07869991f, -0.11689849f, -0.03804065f, 0.18175834f, 
    0.03592506f, 0.15569204f, 0.05673375f, -0.22956470f, -0.16528895f, -0.07960027f, 0.01671250f, 0.04442593f, 
    0.10746581f, -0.01970311f, -0.07324496f, -0.07644583f, -0.00246732f, 0.26756218f, -0.06593297f, 0.05222937f, 
    0.09582941f, -0.01382541f, -0.13840424f, -0.03327643f, 0.02255924f, 0.05999267f, 0.17857939f, 0.01097826f, 
    -0.06717788f, -0.01403322f, -0.04132550f, 0.04614450f, -0.07953572f, -0.05910457f, 0.05887552f, -0.38838589f, 
    -0.03493245f, 0.02212470f, 0.13695318f, 0.02269518f, -0.01315448f, -0.14773938f, 0.12879649f, 0.00456168f, 
    0.18159313f, 0.12206940f, 0.07109893f, 0.08929031f, 0.09369650f, -0.11198334f, -0.07307609f, -0.09985981f, 
    0.04673639f, 0.07154185f, 0.00694483f, -0.00037628f, -0.03642719f, -0.06585950f, 0.05925102f, -0.03229091f, 
    0.08200106f, 0.06986687f, -0.26824105f, -0.01187988f, 0.04863733f, 0.05260707f, 0.10660572f, 0.02041625f, 
    0.04198306f, -0.08605287f, -0.23160724f, 0.14509727f, 0.06945221f, 0.16084236f, 0.18458286f, 0.08540452f, 
    -0.24771193f, -0.01431577f, 0.10142040f, -0.16420858f, -0.19234294f, -0.03124742f, -0.00735762f, 0.04724527f, 
    0.11437675f, 0.00855627f, -0.10946332f, 0.13902342f, -0.01453927f, -0.09499207f, -0.07924498f, 0.16359344f, 
    -0.06467105f, -0.08644307f, 0.03132346f, -0.00372740f, -0.03172711f, 0.13508332f, 0.30092853f, 0.05226240f, 
    -0.19738632f, -0.05122266f, 0.05469115f, 0.10971984f, -0.06183667f, 0.09411602f, -0.02603323f, 0.00482678f, 
    -0.01863272f, 0.00991582f, -0.07555450f, 0.12638390f, 0.08512296f, 0.02732117f, 0.09374096f, -0.02424991f, 
    -0.00185237f, -0.09485852f, 0.08303443f, -0.06895337f, 0.00497769f, -0.02591360f, -0.07360984f, 0.01247753f, 
    -0.00535548f, 0.01532582f, -0.00124810f, -0.00262390f, 0.00220907f, 0.11931998f, -0.10385177f, -0.14094239f, 
    -0.06610787f, 0.10670008f, -0.09060518f, 0.06740654f, 0.06604579f, 0.02881273f, 0.06566589f, -0.02090828f, 
    0.04390582f, 0.05916000f, 0.03882173f, 0.11582749f, -0.05962902f, 0.03951590f, 0.03822109f, -0.04272843f, 
    0.04960371f, -0.07606459f, 0.12784238f, 0.18956813f, 0.05773487f, 0.00964386f, -0.11309791f, -0.02871023f, 
    0.03507370f, 0.05481447f, 0.01925745f, 0.04319070f, -0.10938013f, 0.13986279f, 0.03079614f, 0.03417693f, 
    -0.01461274f, 0.02911553f, 0.10109305f, -0.05087933f, -0.02130718f, -0.00747102f, -0.38596916f, 0.09909122f, 
    -0.00843122f, 0.02426542f, 0.11769547f, 0.02192198f, 0.05908242f, -0.00013529f, -0.01096802f, 0.02485290f, 
    -0.05576992f, -0.01559887f, -0.15144311f, -0.09350380f, 0.03203077f, 0.06746354f, 0.07540313f, 0.15204526f, 
    -0.05652960f, -0.05064086f, -0.03230348f, 0.00436342f, 0.01624338f, -0.00040371f, -0.02400497f, -0.02717545f, 
    -0.03269752f, 0.02466127f, 0.00462594f, 0.00668545f, 0.04418211f, -0.01788782f, -0.03623357f, 0.03046814f, 
    0.05271559f, 0.00202786f, -0.05618867f, -0.01553956f, -0.04521957f, -0.05899418f, -0.03572576f, -0.01400614f, 
    0.01862037f, -0.01866899f, -0.05081363f, -0.03697728f, -0.02240141f, -0.04580526f, 0.00810208f, 0.04543333f, 
    -0.03707735f, -0.01737907f, 0.03777977f, -0.02808359f, -0.02360727f, -0.05273370f, 0.01729442f, -0.06345058f, 
    -0.01368089f, -0.03490037f, -0.00930093f, 0.05268077f, -0.06015060f, -0.03697501f, -0.01222542f, 0.02363495f, 
    -0.04932475f, 0.03228789f, -0.00879396f, -0.00203578f, 0.00055002f, -0.00853969f, 0.01941331f, -0.01718688f, 
    0.01208257f, -0.03528931f, -0.06175467f, 0.03941277f, 0.02804929f, 0.01374974f, 0.04773364f, -0.01908072f, 
    -0.00675400f, -0.05461562f, -0.01692730f, -0.03593860f, -0.04820639f, -0.03784309f, -0.00205847f, -0.05622876f, 
    0.02071633f, 0.05007978f, 0.05131186f, 0.03622120f, 0.00700473f, -0.03717476f, -0.04494299f, 0.01017369f, 
    0.01514773f, 0.03394906f, -0.01850283f, -0.00183113f, 0.03475034f, 0.02047578f, -0.03947117f, -0.03968040f, 
    0.04693095f, -0.05662673f, -0.04489815f, -0.00511777f, -0.04078797f, 0.03371520f, -0.01657330f, -0.01138948f, 
    -0.06348269f, 0.05326744f, -0.00833521f, -0.05401296f, -0.01787926f, 0.00830153f, 0.00312016f, -0.03226272f, 
    -0.05533292f, -0.00317977f, -0.05366383f, -0.03684693f, -0.01262163f, 0.00789604f, 0.04626292f, -0.01513523f, 
    0.03588818f, -0.03224532f, -0.06202417f, -0.01221324f, 0.02777435f, -0.01940578f, -0.03363933f, 0.04652188f, 
    0.05203031f, -0.05122075f, -0.00099111f, -0.04623455f, -0.05495159f, 0.00076860f, 0.01430844f, -0.02578007f, 
    -0.03514132f, 0.03103377f, -0.05426149f, 0.02835985f, -0.04863440f, 0.03059255f, -0.03768705f, -0.04895104f, 
    -0.02592292f, -0.05424841f, 0.01779238f, -0.04851772f, 0.01801874f, 0.00107395f, 0.00719310f, -0.00350969f, 
    -0.01934573f, -0.01917290f, 0.02945081f, -0.01852817f, 0.02348159f, 0.00522498f, 0.00933525f, 0.02083301f, 
    -0.02641686f, -0.04499797f, 0.00093206f, -0.05602704f, -0.00405118f, -0.04210932f, 0.04704489f, -0.03171617f, 
    -0.04643761f, -0.01134025f, 0.00725341f, -0.01874240f, -0.02944591f, 0.00400341f, -0.01835178f, -0.06072741f, 
    -0.05846528f, 0.01383295f, -0.05877946f, 0.01455612f, -0.04271815f, -0.01311586f, 0.04616871f, 0.04693824f, 
    0.00371087f, 0.03600788f, -0.00208622f, -0.02326108f, -0.06203936f, -0.04448351f, 0.03777776f, 0.03017554f, 
    -0.04458690f, -0.04688888f, -0.04406240f, 0.01307041f, 0.04550985f, -0.05139639f, -0.03963156f, -0.03801916f, 
    -0.06324568f, -0.05130694f, 0.00489506f, -0.03859711f, 0.03191960f, 0.00634373f, -0.01306528f, -0.01291545f, 
    -0.00430253f, 0.02229305f, -0.00807945f, 0.00878556f, -0.01303095f, 0.03007122f, -0.00460647f, 0.02423352f, 
    0.01640136f, 0.05216203f, -0.05603211f, -0.04240686f, -0.03839446f, -0.02726341f, -0.03600688f, -0.01784585f, 
    0.04884300f, -0.02945901f, 0.04557820f, 0.04200767f, -0.01241410f, 0.00534294f, 0.04969114f, -0.01281950f, 
    -0.00247812f, -0.03292204f, 0.02104667f, 0.01058314f, -0.01008475f, 0.01777515f, -0.03402848f, -0.02845681f, 
    0.05326938f, 0.04539310f, -0.04860917f, -0.02214873f, -0.04998804f, 0.01843496f, 0.05140036f, -0.04522617f, 
    0.00363609f, 0.03217253f, -0.01932607f, 0.04088915f, -0.05008009f, -0.00048248f, -0.01298726f, 0.01041836f, 
    -0.05778435f, -0.01145813f, -0.03750755f, 0.04465951f, -0.04224676f, -0.00639698f, 0.00897637f, -0.04032309f, 
    -0.04913761f, -0.04517622f, -0.04245245f, -0.01867747f, -0.01879070f, 0.02186545f, -0.03160596f, -0.03039652f, 
    0.00156551f, -0.00737647f, -0.01733799f, -0.06287154f, 0.00109376f, -0.02830710f, -0.03755651f, -0.03166561f, 
    0.03805663f, -0.04781872f, -0.00148088f, 0.05256583f, -0.04720626f, 0.01077526f, 0.04169541f, 0.03419909f, 
    0.01059351f, -0.06263719f, 0.01941474f, 0.04987102f, -0.01626987f, 0.00170865f, -0.01597590f, 0.00117979f, 
    -0.02801004f, 0.04373245f, -0.00575274f, -0.00278776f, -0.04381638f, -0.00516648f, -0.05038086f, 0.05145159f, 
    0.00616902f, -0.00314983f, 0.01753749f, -0.01451455f, 0.00525492f, -0.01855590f, -0.06316441f, -0.05425751f, 
    0.02457591f, 0.05354880f, -0.00546745f, -0.05327488f, -0.03822868f, -0.00495312f, 0.00263672f, -0.00154372f, 
    -0.02038772f, 0.02702511f, -0.06261369f, -0.01187033f, 0.03081365f, 0.01078472f, -0.01711205f, 0.03526117f, 
    0.03375741f, -0.03429983f, -0.04404626f, -0.06320038f, -0.07034265f, -0.04577706f, 0.01759462f, -0.02575485f, 
    0.04031968f, -0.00056911f, -0.02918982f, -0.06155690f, -0.03993675f, -0.05393365f, -0.05080446f, 0.06003079f, 
    0.02803319f, -0.04866169f, -0.03086673f, -0.04328407f, -0.05687523f, 0.00527691f, 0.03671963f, 0.01971537f, 
    -0.04394739f, -0.07390548f, -0.01116020f, -0.03953924f, 0.01589464f, -0.00035779f, -0.04688381f, 0.03198496f, 
    0.02785973f, -0.06303738f, 0.04070719f, 0.00605972f, -0.03834768f, 0.01939096f, 0.00573093f, 0.04021065f, 
    -0.02844247f, 0.04229507f, 0.03951554f, 0.03061766f, 0.04564890f, 0.01052819f, -0.06096429f, 0.02969260f, 
    -0.00374892f, -0.03216952f, -0.04576553f, -0.00766248f, 0.05093872f, 0.01828623f, -0.00776238f, -0.03825761f, 
    -0.01102798f, 0.04374382f, 0.03536306f, -0.05371060f, -0.04586535f, 0.00730562f, 0.04865433f, -0.00304900f, 
    -0.00725277f, -0.02230232f, -0.03309927f, 0.02347865f, -0.02120090f, 0.02296017f, 0.02558668f, -0.02609753f, 
    0.02897970f, 0.00646764f, 0.00082651f, 0.04192812f, -0.04641391f, -0.04093773f, -0.03694744f, 0.01389429f, 
    0.01336135f, -0.04927041f, -0.02723495f, -0.02055237f, -0.02998434f, 0.01299726f, 0.04332610f, -0.02102648f, 
    -0.01238654f, -0.01417923f, -0.03980948f, -0.06169150f, -0.04392168f, 0.01134387f, -0.02439499f, -0.01716839f, 
    -0.00565657f, 0.05273999f, -0.02757523f, 0.01052908f, 0.00974697f, 0.03712323f, -0.04936830f, -0.05867350f, 
    0.00832605f, -0.01886515f, -0.03699072f, -0.01669060f, 0.02771166f, 0.03405167f, -0.01309570f, 0.03579503f, 
    -0.02559568f, 0.03656333f, -0.04303103f, -0.05797837f, -0.03617236f, 0.03571109f, -0.01200228f, 0.04252407f, 
    0.04276008f, 0.03872089f, -0.03707959f, -0.03787084f, -0.06389499f, 0.00643583f, 0.01537022f, -0.04724696f, 
    0.05057131f, -0.05839677f, -0.03425501f, 0.00511137f, 0.02356891f, 0.02698145f, -0.05142786f, -0.00692144f, 
    0.03093993f, -0.04036038f, 0.01603872f, -0.05119965f, 0.04828833f, -0.05714023f, 0.00411226f, 0.03216364f, 
    0.00538294f, -0.03953939f, 0.00094208f, -0.03248998f, -0.02270500f, -0.04667521f, 0.00673255f, -0.05509187f, 
    -0.01648657f, -0.04092011f, 0.04436021f, -0.05670210f, -0.00432819f, 0.02292896f, 0.02128037f, -0.02350295f, 
    0.00434759f, -0.00997597f, -0.01161232f, 0.00184502f, -0.01618597f, 0.04779596f, 0.00554413f, -0.02093906f, 
    0.03051245f, -0.04912004f, 0.00387890f, -0.00507205f, 0.03099035f, 0.01297987f, -0.05021961f, 0.04462383f, 
    0.02927825f, -0.02260653f, 0.03218082f, -0.04619234f, -0.03183418f, -0.02463982f, 0.01047778f, 0.03757309f, 
    0.04213192f, 0.01053335f, -0.01262082f, -0.02604570f, -0.03482472f, -0.04303876f, -0.00497550f, -0.00148256f, 
    -0.01426813f, 0.01733110f, 0.04965180f, -0.06221933f, 0.03031439f, -0.05577354f, 0.03227279f, -0.05569211f, 
    -0.05506451f, 0.00530276f, 0.01619841f, 0.03100609f, -0.04226685f, 0.02675222f, 0.03114537f, -0.00885483f, 
    0.03015996f, 0.01215722f, -0.04619408f, 0.03011116f, 0.01634309f, 0.00872115f, -0.00484480f, 0.04390507f, 
    -0.02388285f, 0.04702976f, -0.06360687f, -0.04377604f, -0.01843623f, 0.00107626f, 0.00694235f, -0.00054678f, 
    -0.06141331f, 0.04039899f, -0.06415804f, -0.06679454f, 0.04053426f, -0.00241101f, -0.01561988f, 0.00617779f, 
    0.01774104f, 0.04161026f, 0.00587228f, -0.03865545f, 0.01674863f, 0.03308633f, -0.06707383f, 0.01348199f, 
    0.01519227f, -0.01145763f, 0.01916958f, 0.01093931f, -0.03002139f, 0.00727834f, -0.03823499f, 0.01632926f, 
    -0.01352147f, -0.01462579f, -0.00726711f, -0.00845944f, -0.02159571f, 0.01852521f, 0.02538064f, 0.01419551f, 
    -0.02317844f, 0.01494730f, 0.03845422f, -0.00377519f, -0.02934625f, 0.00331319f, 0.01738145f, -0.04101975f, 
    -0.02700515f, 0.04306877f, 0.04847235f, 0.04017362f, 0.02513538f, 0.00641430f, -0.00507801f, 0.02734389f, 
    0.03825979f, 0.00555117f, 0.00797878f, -0.00031940f, 0.05110855f, -0.04428428f, -0.01933068f, -0.03955993f, 
    0.00560395f, -0.02100791f, 0.00947335f, 0.03993085f, -0.03593173f, 0.04998326f, -0.00037289f, -0.03825883f, 
    -0.01270313f, -0.02575488f, -0.01277476f, -0.04215704f, -0.04154594f, -0.03178946f, 0.02236327f, -0.04061006f, 
    -0.04529028f, 0.02290852f, 0.02562947f, 0.02856154f, 0.03381285f, -0.02735642f, 0.00076303f, 0.02900114f, 
    0.01342129f, -0.04346335f, 0.02541756f, -0.06086895f, 0.01158994f, -0.02958924f, -0.01232443f, -0.06622251f, 
    0.04441110f, -0.06270862f, -0.05315962f, -0.05255172f, -0.06124434f, 0.00070033f, 0.03956581f, 0.05994237f, 
    -0.03298222f, 0.03038127f, 0.04619309f, -0.03722810f, -0.01040797f, 0.03973309f, -0.01503611f, 0.04806884f, 
    -0.00195731f, -0.01016536f, 0.05175183f, -0.01739771f, -0.04831241f, -0.02077439f, 0.00907484f, -0.00124431f, 
    -0.04944228f, -0.00115746f, -0.02253522f, 0.02193864f, 0.02739989f, 0.05334544f, -0.03647604f, 0.04404953f, 
    -0.01803487f, 0.04831162f, -0.04163216f, -0.05852944f, -0.02160249f, -0.05022392f, -0.03504751f, -0.00745133f, 
    -0.04786103f, -0.00560079f, -0.05887415f, 0.03931140f, -0.00790914f, -0.02786312f, 0.04162654f, 0.02977515f, 
    -0.02012149f, 0.03710112f, -0.05149016f, -0.01617933f, -0.04053640f, 0.01209857f, 0.04821114f, -0.03809546f, 
    -0.02372057f, -0.03365792f, -0.04508187f, -0.01204144f, 0.04414017f, 0.01815240f, -0.04077439f, -0.03357828f, 
    0.00423400f, 0.00055053f, -0.00574924f, -0.04773536f, -0.02982589f, 0.00785807f, -0.00755806f, 0.03506672f, 
    0.01802729f, 0.00945990f, -0.03890345f, 0.02897364f, -0.03299185f, -0.01540214f, -0.05976303f, -0.04394046f, 
    0.00928106f, -0.01567560f, -0.00451791f, -0.00521214f, -0.00652137f, 0.03260607f, 0.00984245f, -0.01367865f, 
    -0.05332172f, -0.01375576f, -0.04846475f, -0.01327208f, 0.02304211f, -0.03737123f, -0.06063617f, 0.01739525f, 
    -0.03451374f, -0.06847562f, -0.03935125f, 0.06032724f, -0.01163698f, 0.02120688f, -0.02170171f, -0.04775333f, 
    -0.04771943f, -0.01520399f, 0.00335027f, 0.04701073f, -0.05466725f, 0.02849388f, -0.04392003f, -0.02218307f, 
    -0.05785370f, -0.03035670f, 0.02574087f, 0.03617189f, -0.04619560f, -0.02407008f, 0.01294673f, -0.03161329f, 
    -0.03550671f, 0.03817546f, 0.02246071f, 0.03071085f, -0.03129664f, -0.04050831f, -0.00115236f, 0.02857045f, 
    -0.00203868f, 0.00538445f, 0.00531738f, -0.04633197f, 0.02493075f, -0.00203948f, 0.00959166f, 0.00888839f, 
    -0.02383447f, 0.03917946f, -0.06111485f, -0.02718621f, -0.02201036f, 0.01727121f, -0.05196550f, 0.04568739f, 
    0.00073017f, 0.01008154f, 0.00267282f, -0.04213358f, 0.01647174f, 0.02232547f, 0.01934545f, 0.03082618f, 
    -0.05369586f, -0.02002381f, -0.02819563f, -0.03256962f, -0.02637873f, -0.03220650f, -0.00917236f, 0.01346648f, 
    0.03317575f, -0.03052984f, -0.02169117f, -0.00032326f, -0.00107599f, -0.04051227f, -0.06003723f, -0.01102144f, 
    0.01042593f, -0.04744536f, -0.06232414f, 0.04541096f, 0.01902443f, -0.04575986f, -0.00657535f, -0.03423487f, 
    0.02987655f, 0.00295161f, -0.05098723f, 0.00575133f, -0.06795838f, 0.00938046f, 0.03601710f, 0.03456416f, 
    -0.01315346f, 0.04807493f, -0.05664323f, 0.03963958f, -0.00219785f, -0.05346486f, 0.01651515f, -0.00656809f, 
    0.03480399f, 0.04271736f, 0.01991085f, -0.00809048f, 0.03007703f, -0.05495065f, 0.02286890f, 0.03983725f, 
    -0.03148889f, 0.03523627f, -0.01167878f, -0.03309982f, -0.02279397f, -0.02885375f, -0.00978383f, -0.03827644f, 
    -0.02013989f, 0.03379374f, -0.05760301f, 0.05405469f, -0.02415468f, -0.02403971f, 0.03435729f, -0.00339538f, 
    -0.03864012f, 0.02369633f, -0.02666050f, 0.02697540f, -0.01859809f, -0.00486539f, 0.00977319f, 0.04116631f, 
    -0.05193280f, -0.05355042f, -0.01229532f, 0.02575270f, -0.02257109f, 0.00083269f, 0.04504274f, -0.02139791f, 
    -0.05989840f, -0.67048073f, -0.01322975f, -0.18050656f, 0.13691415f, -0.13643359f, -0.04055933f, -0.04329231f, 
    -0.01283677f, 0.06104653f, 0.04489664f, 0.02451466f, -0.05744057f, -0.02913754f, -0.09563480f, 0.11072208f, 
    -0.00374031f, -0.21461831f, 0.06945121f, -0.00718754f, -0.21851793f, 0.05212468f, -0.11957350f, 0.13275842f, 
    0.04855704f, -0.01111754f, 0.00227756f, -0.35437807f, 0.00533351f, -0.27867118f, 0.02577368f, 0.03350705f, 
    -0.01529791f, -0.02207483f, -0.11210494f, -0.09329163f, -0.08378622f, -0.03459940f, -0.06377187f, 0.04022248f, 
    -0.02548001f, 0.00298038f, -0.03263584f, 0.05270835f, -0.13455676f, -0.00182946f, -0.09714507f, -0.10472975f, 
    -0.07213847f, 0.14474426f, 0.02596034f, 0.06613832f, -0.08362324f, 0.11956719f, 0.06447827f, 0.16786566f, 
    -0.03895979f, -0.04422374f, 0.00085958f, 0.00262697f, -0.02258838f, -0.05441724f, -0.07341564f, -0.02442113f, 
    -0.10824323f, 0.06039571f, 0.02452779f, 0.02828490f, -0.15316819f, 0.10537031f, -0.02974929f, 0.02682600f, 
    -0.07504769f, 0.07876162f, 0.14845504f, -0.07234975f, 0.11143410f, -0.02029728f, -0.03056466f, 0.12771674f, 
    -0.15005621f, 0.00576862f, 0.15201209f, -0.05517523f, -0.06163321f, 0.03427237f, 0.07393502f, 0.05390995f, 
    0.04049835f, -0.00118748f, -0.02158139f, 0.10200831f, -0.02227168f, 0.03785777f, 0.10843246f, 0.00102733f, 
    0.18353643f, -0.08398978f, 0.08035602f, -0.01959744f, 0.12982281f, 0.10085207f, -0.01520561f, 0.03365820f, 
    0.01633271f, -0.01358270f, 0.05082319f, -0.08202169f, -0.20957546f, -0.06053392f, 0.16356900f, -0.01858171f, 
    0.00541988f, -0.08538723f, 0.05501469f, -0.01633727f, -0.18647401f, -0.32406697f, -0.09774674f, -0.05012781f, 
    0.01954742f, 0.10770255f, -0.07642257f, -0.09701926f, -0.07104676f, 0.07284587f, -0.04798862f, -0.04761541f, 
    -0.16561592f, 0.12752479f, 0.06263629f, 0.06493811f, 0.06800529f, -0.03862820f, 0.12125444f, 0.11073989f, 
    0.05316979f, 0.07961992f, -0.03721631f, -0.08204861f, 0.10798495f, -0.00975822f, 0.03217780f, 0.00512362f, 
    0.02544750f, -0.06195200f, -0.18958122f, -0.02768704f, 0.13970345f, 0.01990161f, 0.04815750f, -0.06741542f, 
    -0.09958199f, 0.13634412f, -0.07572658f, -0.24320340f, 0.04961577f, 0.17159697f, 0.02377415f, 0.11896723f, 
    0.02312377f, 0.09584861f, 0.02191150f, 0.13465558f, 0.12363335f, -0.02274852f, -0.11514398f, 0.07160045f, 
    0.03187402f, 0.09343703f, 0.08208223f, -0.01060435f, 0.20702852f, 0.05732857f, -0.00646981f, -0.05202293f, 
    0.12608701f, -0.00108204f, 0.00351570f, 0.24087405f, 0.19529678f, 0.10411471f, 0.18555330f, -0.10046685f, 
    -0.10730106f, -0.02757244f, -0.00040876f, 0.06664060f, 0.05096915f, -0.33416075f, 0.06112460f, -0.15391040f, 
    -0.13168976f, 0.15490182f, -0.02956371f, 0.01402702f, -0.06318031f, -0.13112625f, -0.08311765f, 0.16294353f, 
    0.19148044f, -0.03765674f, 0.00315350f, -0.06522584f, -0.01092568f, 0.06085472f, -0.01321439f, 0.08154571f, 
    -0.03941770f, -0.20500989f, 0.04118293f, 0.07250772f, 0.01352559f, 0.02237401f, -0.14380176f, 0.02870585f, 
    0.00088662f, 0.18645117f, -0.23002252f, 0.02431270f, 0.06697857f, -0.05636462f, 0.09147607f, -0.05303646f, 
    -0.02930265f, 0.25545120f, 0.06564019f, -0.15090506f, 0.00141602f, 0.13203172f, 0.03004250f, 0.03640915f, 
    -0.03724075f, -0.03203596f, -0.02100541f, -0.05228717f, 0.02144330f, -0.01877788f, -0.06451933f, -0.00509649f, 
    0.01506069f, -0.06707080f, 0.13922518f, 0.06529386f, -0.11720618f, -0.20287982f, 0.05844704f, 0.11571033f, 
    0.04301018f, 0.10767975f, -0.10621189f, -0.02799086f, -0.17011286f, 0.00265705f, 0.22560306f, -0.03922601f, 
    0.02821724f, 0.03967021f, 0.04428342f, -0.11239278f, -0.01015483f, 0.05119602f, -0.16742642f, -0.01448095f, 
    -0.04805762f, -0.04477576f, -0.05968377f, -0.07251187f, -0.00988194f, -0.00747631f, 0.05138625f, 0.18650007f, 
    -0.03422505f, -0.01692212f, -0.12593637f, -0.04661333f, -0.04436074f, 0.00917781f, -0.04428884f, 0.10488242f, 
    -0.18320233f, -0.17593955f, -0.06171104f, 0.03493815f, 0.11529049f, 0.03491189f, 0.05032928f, -0.03689106f, 
    -0.06059226f, -0.00378811f, -0.00222065f, -0.03876079f, 0.00556674f, 0.04559540f, -0.01497642f, 0.04186473f, 
    -0.03158400f, -0.06908142f, -0.05981949f, -0.04743199f, -0.03431047f, -0.07561277f, 0.01485944f, 0.05998943f, 
    -0.06888139f, 0.03335355f, -0.04501155f, -0.01741314f, 0.04348943f, 0.02970524f, -0.02143969f, -0.00042191f, 
    0.02819696f, 0.02396888f, 0.02204667f, 0.03645862f, -0.06047024f, -0.02316599f, -0.07348527f, 0.03454179f, 
    0.03047806f, 0.03398679f, -0.00178754f, -0.04974858f, -0.00991936f, 0.03222105f, -0.00184173f, -0.04959141f, 
    -0.04226224f, -0.01224936f, -0.08801534f, -0.06268382f, 0.01162138f, -0.02306080f, -0.00670112f, -0.02195557f, 
    0.02917094f, -0.00078046f, -0.03647847f, 0.03993253f, 0.02039265f, 0.01113511f, -0.00696228f, -0.03886275f, 
    -0.01692536f, 0.03432028f, -0.06672171f, -0.06272946f, -0.01722811f, 0.04428843f, -0.07826161f, -0.02123306f, 
    -0.04815894f, -0.03778092f, -0.04393837f, 0.03175277f, 0.04089669f, 0.06683163f, 0.04105790f, -0.02067381f, 
    -0.01113332f, -0.06140746f, -0.01669656f, -0.05805501f, 0.02751367f, -0.06484592f, -0.07893578f, -0.06198953f, 
    0.02170821f, -0.04498938f, -0.02117369f, -0.07095586f, -0.05141600f, 0.01030958f, -0.04958270f, 0.00209968f, 
    -0.04533542f, -0.02206791f, -0.04626881f, -0.06829351f, -0.05163874f, -0.00119873f, -0.06035268f, -0.01421254f, 
    -0.01484523f, -0.02201844f, -0.02499361f, 0.03169853f, -0.02291304f, -0.03293304f, -0.03736620f, -0.06350387f, 
    -0.06880164f, -0.03450378f, 0.01938119f, -0.03137381f, 0.02686421f, -0.02658886f, 0.04943859f, 0.02808041f, 
    0.03576878f, -0.08167534f, -0.10717091f, -0.04954004f, -0.03206531f, 0.03618345f, -0.03978543f, -0.00141131f, 
    -0.05212369f, -0.04563622f, -0.05948624f, 0.05661916f, -0.01918913f, -0.00753341f, -0.07191317f, -0.02850917f, 
    0.00449390f, -0.04008526f, 0.00460502f, -0.03279938f, 0.03046485f, 0.03186460f, -0.05291758f, -0.01032730f, 
    0.03006762f, -0.07184596f, -0.02097823f, -0.03112826f, -0.07527582f, -0.01012569f, -0.05745412f, -0.06568980f, 
    -0.01148347f, 0.00018665f, -0.03861170f, 0.00552529f, -0.01306486f, 0.05497899f, -0.06125763f, 0.02609666f, 
    -0.01295239f, 0.01871239f, 0.00268144f, 0.04145892f, 0.01470981f, -0.01697941f, 0.00083091f, 0.03013512f, 
    -0.04637331f, -0.07192104f, -0.05577887f, -0.00159812f, -0.01781766f, 0.01020083f, -0.02821450f, -0.02815756f, 
    0.03893659f, -0.05184369f, -0.05381085f, 0.03496179f, 0.02673502f, 0.02631722f, 0.02181765f, 0.01592153f, 
    -0.03168796f, -0.01526494f, -0.03414750f, -0.07971457f, 0.01825547f, -0.01803229f, -0.00396796f, 0.00888076f, 
    -0.04949925f, 0.00419542f, 0.06314756f, 0.04296752f, -0.03860052f, -0.03324291f, -0.04516611f, -0.01125790f, 
    -0.07557402f, -0.07120335f, -0.02359480f, 0.05225394f, 0.01148270f, -0.02476191f, -0.02296689f, -0.02401445f, 
    -0.04869235f, -0.06211496f, -0.04410977f, -0.00626148f, 0.02051495f, -0.08210233f, 0.02022710f, 0.04079156f, 
    -0.08465577f, -0.00700189f, 0.01589029f, -0.06282119f, 0.01236871f, -0.08451563f, 0.00713754f, -0.05342815f, 
    -0.05134691f, 0.00850153f, -0.05059149f, 0.00020204f, -0.06153716f, -0.05668437f, -0.01402717f, -0.00264378f, 
    0.04786485f, -0.01252698f, -0.02904225f, 0.02060711f, -0.01709912f, 0.02176083f, -0.04359321f, -0.02541171f, 
    -0.00950633f, 0.01098137f, -0.05010948f, -0.06481938f, -0.00309673f, -0.03389466f, -0.01535909f, 0.00515217f, 
    -0.02828691f, -0.02470657f, -0.04697952f, 0.04333023f, 0.00591216f, 0.00532449f, -0.03996243f, 0.02272486f, 
    -0.03496945f, -0.04082259f, 0.01421134f, 0.00102617f, 0.01116875f, 0.02956415f, -0.07610375f, 0.01500645f, 
    0.03561321f, 0.01857770f, -0.01330651f, -0.06617955f, -0.05956304f, -0.02330086f, 0.02442782f, -0.07389142f, 
    -0.01320512f, -0.07345115f, -0.03140277f, -0.00435438f, -0.04923132f, -0.04345423f, -0.02668595f, -0.01441806f, 
    0.02707379f, 0.02851017f, -0.06603293f, 0.04925410f, -0.02368206f, -0.06063371f, 0.00641275f, 0.01858089f, 
    0.00335457f, -0.08145031f, -0.07016863f, -0.03415820f, 0.00282755f, -0.02690291f, -0.00759866f, 0.00674554f, 
    0.10433920f, 0.16589791f, 0.08697956f, -0.00609496f, -0.13147411f, -0.01036357f, -0.01995771f, 0.14883694f, 
    -0.10314241f, 0.05580352f, 0.14817122f, 0.14580175f, 0.09028165f, 0.10230047f, -0.06628868f, -0.07920507f, 
    0.08728469f, 0.02178283f, 0.18843047f, -0.17815697f, 0.12199996f, 0.02912665f, 0.00485335f, 0.08554105f, 
    -0.00812194f, 0.01747872f, -0.09103858f, 0.04141603f, -0.15404418f, -0.02683225f, 0.04808139f, -0.01098786f, 
    -0.05669206f, -0.00327572f, -0.02400625f, -0.16628011f, -0.05931433f, -0.06443309f, -0.00819383f, -0.02788149f, 
    0.03302993f, 0.01175583f, 0.08486778f, -0.04351710f, -0.10130860f, 0.22184139f, 0.19694880f, -0.10910162f, 
    -0.09022290f, -0.07996496f, 0.04359350f, 0.02773618f, 0.02512897f, 0.06242400f, 0.22813246f, -0.06283225f, 
    -0.03535294f, -0.05484604f, -0.03040732f, 0.04767758f, 0.09581757f, -0.01340583f, -0.01143516f, 0.23535019f, 
    -0.03057685f, 0.03641878f, -0.23404495f, 0.00828789f, 0.09023099f, -0.08872520f, -0.01389530f, 0.01908745f, 
    0.03354049f, -0.03123393f, -0.21114053f, -0.02007236f, 0.07731406f, -0.01958774f, -0.07434803f, -0.09854158f, 
    -0.13711753f, 0.05671129f, 0.22522575f, -0.03949533f, 0.15486190f, 0.08670694f, 0.10416214f, -0.03937484f, 
    0.08903686f, 0.13205208f, 0.18905874f, 0.09568884f, -0.17114119f, -0.16773096f, -0.16440718f, -0.13870017f, 
    0.15977997f, -0.06716934f, 0.06183313f, -0.20738822f, -0.08532777f, -0.24021281f, 0.07409590f, 0.20480892f, 
    0.09164628f, -0.03667297f, -0.06908323f, 0.01408912f, 0.15401743f, -0.26172727f, -0.18653154f, 0.03340235f, 
    0.01948071f, 0.25793511f, -0.01660055f, -0.09249449f, -0.14980009f, 0.00130641f, -0.12483968f, -0.06201604f, 
    0.02581175f, -0.17020652f, 0.00293800f, 0.06910314f, 0.01012438f, -0.00611372f, -0.11072401f, 0.07554875f, 
    0.09714345f, 0.10153476f, 0.07684016f, -0.04951155f, 0.08697616f, 0.00220358f, 0.06932956f, -0.13955745f, 
    0.12568331f, -0.16376241f, 0.08593167f, -0.00353157f, -0.01419496f, -0.01782469f, -0.03079272f, -0.10363356f, 
    -0.09291793f, 0.07634439f, 0.05881725f, 0.06504782f, 0.01156066f, -0.13012473f, -0.05614355f, -0.00808507f, 
    -0.00090413f, -0.02006693f, 0.03851039f, 0.14594181f, 0.26763058f, 0.10717876f, 0.14537525f, -0.00129327f, 
    0.12501699f, 0.20553108f, -0.06419577f, 0.03664929f, -0.25050956f, -0.00946580f, -0.02183174f, -0.07480431f, 
    0.02715902f, -0.01639067f, 0.05933567f, -0.00504535f, -0.00726219f, -0.11813595f, 0.00278654f, -0.11317170f, 
    -0.24916759f, 0.11540592f, -0.01677524f, 0.00091478f, 0.25653905f, 0.06399490f, -0.03373666f, 0.00705681f, 
    -0.06614435f, -0.02994452f, -0.14229749f, 0.08272678f, 0.03751365f, 0.15808800f, 0.11651439f, 0.14551951f, 
    -0.07179295f, -0.04690387f, 0.01757914f, 0.01715622f, 0.07984028f, -0.03994380f, 0.06774551f, 0.05071433f, 
    -0.06477948f, 0.05858925f, 0.05542564f, 0.13134024f, -0.09765327f, 0.01303275f, -0.10297778f, 0.01238580f, 
    -0.11909910f, 0.08288012f, 0.04219697f, 0.09538465f, 0.08472554f, 0.06978499f, 0.02802077f, 0.06940108f, 
    -0.08313831f, 0.03864675f, 0.14148694f, 0.12137438f, 0.08851770f, -0.02704854f, 0.03166965f, -0.00913020f, 
    0.01840909f, 0.06580865f, -0.08909154f, 0.09975364f, 0.00119505f, 0.04088971f, -0.01750553f, 0.00313689f, 
    -0.00125096f, -0.01114501f, 0.41516179f, 0.10112824f, 0.07759240f, 0.00190823f, -0.01649619f, 0.06688120f, 
    -0.05514171f, -0.10745886f, -0.05621076f, -0.23531918f, 0.06814419f, 0.17747723f, -0.06737955f, 0.04799059f, 
    -0.02579712f, -0.10995297f, 0.02966001f, -0.07655488f, 0.17398426f, -0.04221844f, 0.07489575f, 0.12241964f, 
    0.07920346f, 0.02443366f, -0.12021590f, 0.02417260f, -0.10815008f, -0.09242027f, 0.06664000f, 0.09215951f, 
    0.01590800f, 0.03731824f, -0.06681335f, -0.08436302f, -0.04389663f, -0.01358342f, 0.09770197f, -0.01331199f, 
    -0.09918413f, -0.10666987f, 0.08425405f, 0.00437692f, -0.01478035f, -0.06772887f, -0.01350372f, -0.22907503f, 
    0.04495818f, 0.23940548f, 0.09648340f, 0.03544015f, 0.09382414f, -0.04702247f, 0.01131553f, 0.12754661f, 
    -0.35543019f, -0.17387228f, -0.15755866f, 0.04688530f, 0.02063366f, -0.11890263f, -0.12917589f, 0.02196966f, 
    -0.02121581f, -0.11920473f, -0.11651444f, -0.15773968f, 0.30660626f, -0.03081159f, 0.05810150f, -0.01616627f, 
    0.06434669f, -0.07582369f, -0.12170687f, 0.03242753f, -0.23171832f, 0.09324270f, 0.05580943f, -0.02510162f, 
    -0.03662469f, -0.11218639f, 0.03168180f, -0.02833579f, -0.13835125f, -0.15444481f, -0.16458707f, -0.01293796f, 
    -0.06015627f, 0.06602177f, 0.00647558f, -0.00424156f, 0.16793041f, 0.05424704f, -0.19055201f, 0.07362371f, 
    0.07624600f, 0.10869742f, 0.01457319f, 0.02520047f, -0.12259458f, 0.08082633f, -0.43248907f, -0.23317613f, 
    0.09640705f, -0.09968990f, 0.02893491f, -0.11987801f, 0.05324588f, 0.05301214f, -0.21133000f, 0.12069128f, 
    0.20685209f, -0.06532533f, 0.10703064f, 0.11317341f, -0.03357623f, 0.06349519f, -0.04272317f, -0.20261069f, 
    0.01366644f, -0.04548764f, -0.01374058f, 0.19010073f, -0.06666948f, 0.07449684f, 0.13407557f, 0.05995891f, 
    -0.06145184f, 0.10452297f, 0.14833070f, 0.15007865f, 0.08050288f, 0.01441478f, 0.08203370f, 0.02143260f, 
    0.03242318f, -0.15910158f, 0.01998536f, -0.12728716f, 0.06694102f, 0.02335314f, -0.00816967f, 0.06805671f, 
    0.00832820f, 0.01608343f, -0.10729371f, 0.00827787f, -0.05473841f, -0.02383397f, -0.06371454f, 0.09485311f, 
    0.05469761f, 0.07422619f, -0.00505672f, 0.04557630f, 0.01397505f, 0.13030554f, 0.11839978f, 0.02327621f, 
    -0.14614861f, 0.07130537f, -0.04937299f, 0.07752094f, -0.19149640f, -0.13131419f, 0.13217050f, 0.03153181f, 
    -0.12493587f, -0.01250801f, -0.03787238f, 0.15381379f, 0.08094603f, 0.05078581f, -0.12465529f, 0.00171469f, 
    0.08747640f, 0.03598295f, 0.00285907f, -0.00327562f, -0.01114659f, 0.02606507f, -0.20646183f, -0.10233744f, 
    -0.04166787f, 0.12527363f, 0.02187991f, -0.02409697f, 0.03634655f, 0.07164046f, -0.01862537f, -0.27555615f, 
    -0.09584731f, 0.08013965f, 0.10844588f, 0.05087443f, 0.02990564f, 0.10889950f, 0.06909700f, 0.01741379f, 
    -0.41610676f, -0.07244506f, -0.04778079f, 0.04397358f, 0.17308238f, 0.11918484f, -0.05497023f, -0.05961076f, 
    -0.06601804f, -0.31705302f, 0.15618011f, -0.30538705f, 0.11139894f, 0.03084295f, 0.06239916f, 0.01132786f, 
    -0.10776989f, -0.04436722f, -0.00141433f, -0.05379491f, 0.14726757f, -0.01099443f, -0.05265339f, -0.17627212f, 
    0.02916804f, 0.08530915f, 0.10166846f, 0.05247012f, -0.08618153f, 0.05269466f, -0.17349443f, -0.18262394f, 
    0.00680852f, 0.01225047f, 0.01813194f, 0.15475199f, -0.05612833f, 0.00267834f, 0.24212389f, 0.00787815f, 
    0.08197444f, 0.05508145f, 0.06779902f, 0.02035799f, 0.16306546f, 0.13002370f, -0.00952900f, -0.20748810f, 
    0.07841778f, 0.02676990f, -0.00959489f, 0.09402960f, 0.10013966f, 0.10712544f, 0.17429979f, 0.18558672f, 
    0.06380231f, 0.01345273f, 0.07138144f, -0.00518570f, -0.00091978f, -0.04225716f, 0.05002229f, -0.22437035f, 
    0.13622397f, -0.10316563f, 0.06841131f, -0.07511576f, -0.01093614f, 0.12649477f, 0.09635579f, 0.05376450f, 
    -0.10176355f, 0.10702351f, -0.13239782f, 0.20786393f, 0.03557281f, -0.01770863f, 0.03453955f, 0.12949374f, 
    -0.02096077f, -0.14930342f, 0.09576211f, -0.33567840f, 0.11945186f, 0.02507871f, 0.09051964f, 0.02319246f, 
    -0.05797692f, 0.01172619f, 0.10729349f, -0.23711383f, -0.07081309f, 0.07319088f, -0.00090080f, 0.03430870f, 
    0.04150345f, -0.04684487f, 0.08223173f, 0.08815440f, 0.03172151f, -0.07753392f, 0.08840388f, 0.04769968f, 
    0.00961854f, 0.09346453f, 0.10442486f, 0.07479320f, -0.34827796f, 0.08201792f, -0.00116670f, -0.09420136f, 
    0.04734678f, -0.15051204f, -0.01290157f, 0.05622637f, 0.04860350f, -0.14964874f, -0.05288585f, -0.05222752f, 
    0.04974072f, 0.08467903f, -0.10813532f, -0.06509108f, -0.13867307f, 0.00400721f, -0.13039580f, 0.15376072f, 
    0.10746367f, 0.16681291f, 0.17257136f, -0.03528485f, 0.07557199f, -0.02067126f, -0.01913552f, -0.50706947f, 
    -0.16992465f, -0.11184376f, -0.08379163f, -0.00854886f, -0.01552147f, 0.06148983f, 0.00831851f, -0.04079671f, 
    0.02305011f, 0.04114948f, 0.02336478f, 0.05382541f, -0.05719072f, -0.02526904f, -0.02833721f, -0.00918522f, 
    -0.05231645f, -0.01395786f, -0.03133653f, -0.06119691f, -0.03457619f, 0.04706384f, 0.02772710f, 0.04001551f, 
    -0.04032063f, -0.05544295f, 0.04262024f, -0.00878451f, -0.03835182f, 0.00697894f, 0.04889583f, -0.05066011f, 
    -0.04051735f, 0.01064402f, -0.00171867f, -0.05221444f, 0.02705451f, 0.04797228f, -0.00421093f, -0.00310887f, 
    -0.01564467f, 0.00476912f, 0.05213283f, 0.00214203f, 0.00796069f, 0.02898134f, 0.00674314f, -0.03360472f, 
    -0.05998796f, -0.00915585f, 0.03983659f, 0.02188971f, -0.02699399f, -0.03776562f, -0.03614972f, -0.02807147f, 
    0.01525343f, 0.02418300f, 0.04264561f, 0.04381991f, -0.03360695f, -0.02117508f, -0.00706330f, -0.06713609f, 
    -0.01668130f, -0.03696711f, -0.01841043f, -0.06377696f, -0.02942300f, -0.03766524f, -0.01732497f, 0.03769353f, 
    -0.02551130f, -0.04127651f, -0.05346132f, -0.00229193f, -0.06553911f, 0.02980707f, -0.03922996f, 0.04664898f, 
    -0.01747221f, 0.03019279f, -0.05970600f, -0.01993890f, -0.03802179f, 0.04643668f, 0.04402084f, 0.01905739f, 
    -0.05116604f, 0.02490505f, -0.05877971f, 0.01955420f, 0.04230114f, -0.00259665f, 0.05036815f, 0.01449823f, 
    -0.03479227f, -0.02362994f, 0.00714806f, -0.06172904f, -0.05854146f, -0.05215875f, 0.01185920f, 0.02322498f, 
    0.01380056f, 0.01891205f, 0.00178222f, -0.00023436f, 0.00277649f, -0.04155115f, 0.00869323f, -0.04885525f, 
    -0.01181817f, -0.01565723f, 0.01736957f, -0.00232339f, -0.03951143f, 0.00765250f, 0.04326173f, 0.03079231f, 
    0.01794414f, -0.04551785f, -0.00690323f, -0.01681002f, -0.03752781f, -0.06488651f, -0.02417346f, 0.01417490f, 
    -0.03272751f, 0.03177996f, 0.03878392f, 0.04565224f, -0.05240522f, -0.05274194f, 0.02545652f, -0.00052542f, 
    -0.01371255f, -0.01075019f, 0.02353365f, -0.03464127f, -0.04710560f, 0.00875095f, 0.01834885f, 0.03345446f, 
    -0.02997482f, -0.04931751f, 0.00373351f, 0.01170249f, -0.03131190f, 0.00163533f, -0.00784378f, -0.00107996f, 
    0.01984051f, -0.06006706f, -0.02914265f, -0.06331850f, -0.00861539f, 0.00565032f, -0.03576420f, 0.02292627f, 
    -0.03829784f, -0.02237166f, 0.03963329f, 0.02123281f, 0.04874255f, -0.02194344f, -0.01181911f, 0.00179567f, 
    -0.03966788f, -0.04554344f, 0.02062081f, -0.03968765f, 0.02614047f, -0.00840625f, -0.03422643f, -0.03044233f, 
    0.01225081f, 0.02982211f, 0.03663332f, 0.01127295f, -0.03649491f, 0.03459049f, -0.05815606f, 0.01493990f, 
    -0.04109045f, -0.05850555f, -0.06509718f, 0.01856963f, 0.04140344f, -0.04389367f, 0.00136367f, -0.04678821f, 
    -0.03027631f, 0.04513475f, -0.04995593f, -0.03940356f, -0.04674006f, 0.04265169f, -0.04384104f, 0.02447521f, 
    0.03132792f, -0.04114113f, -0.01376315f, -0.03598053f, -0.02383195f, -0.05441763f, -0.04106013f, -0.04478680f, 
    0.02186905f, 0.03686469f, -0.00863683f, -0.00155984f, -0.00684538f, -0.03543849f, 0.04476262f, 0.00723861f, 
    -0.03834685f, 0.02864172f, 0.01315613f, -0.02041670f, -0.00344458f, 0.04023382f, -0.01407486f, -0.04131658f, 
    0.00720682f, -0.06604502f, 0.01775049f, -0.04267053f, 0.02546432f, -0.00794991f, 0.01682233f, 0.03001935f, 
    -0.02838559f, 0.02462153f, 0.00404877f, -0.05820632f, -0.01109375f, 0.02299007f, -0.02769680f, -0.01305707f, 
    0.02402005f, -0.00082886f, -0.02236790f, -0.05913329f, -0.05133202f, -0.00961064f, 0.02232710f, -0.02200316f, 
    0.00043814f, 0.02297267f, -0.05293347f, -0.02026326f, 0.00205998f, -0.04673306f, -0.05497402f, 0.04940741f, 
    0.03849269f, -0.04577667f, -0.01505596f, -0.04468020f, 0.03038456f, 0.01815850f, 0.01501398f, -0.00378878f, 
    0.01701975f, -0.04129240f, -0.04572763f, 0.03959607f, -0.03728823f, 0.04546380f, 0.04645892f, -0.03681477f, 
    0.03327612f, -0.01442758f, 0.01565598f, 0.02071238f, -0.06242277f, 0.03827888f, -0.05043051f, -0.04286432f, 
    -0.04348976f, 0.01530658f, -0.02524929f, 0.02452619f, -0.00107968f, -0.05146577f, 0.03389296f, -0.04459901f, 
    0.01926051f, -0.00276868f, -0.04670122f, 0.01796876f, -0.05520191f, -0.03875529f, -0.01201011f, -0.00978042f, 
    0.00617108f, -0.00724845f, 0.04173281f, -0.06625763f, -0.09941143f, -0.07031436f, -0.04401311f, -0.07320061f, 
    0.09276756f, -0.11562475f, 0.03320959f, -0.15573825f, -0.11374720f, -0.03144800f, 0.06290882f, -0.08460350f, 
    -0.02031791f, 0.10480626f, -0.00676086f, 0.05528507f, -0.07628164f, -0.01237709f, -0.07038411f, 0.06972553f, 
    0.16737400f, 0.03119281f, -0.04817028f, -0.27554947f, 0.00033215f, 0.00913467f, -0.03997639f, -0.00138785f, 
    -0.17852947f, -0.00707500f, 0.01104283f, 0.11724911f, 0.13517728f, 0.03185430f, -0.01716972f, -0.08798580f, 
    -0.02263696f, -0.05123311f, -0.13477471f, 0.05801918f, 0.04497599f, 0.06618068f, 0.35272303f, -0.21786313f, 
    0.03266015f, 0.05187579f, -0.11679100f, 0.15468268f, 0.02707553f, 0.08426549f, -0.25049621f, -0.10670859f, 
    0.18396552f, 0.08191286f, 0.00201773f, 0.01930798f, -0.02298870f, 0.00490644f, 0.07157211f, -0.10052455f, 
    -0.04067223f, -0.00680391f, 0.07968818f, 0.06360553f, 0.00554345f, 0.10686834f, 0.04597604f, -0.01042879f, 
    -0.23274183f, -0.24971017f, -0.19048689f, 0.03882861f, 0.07125974f, 0.01231158f, 0.02313196f, -0.10746665f, 
    -0.00775082f, -0.28041121f, 0.06516683f, 0.09917549f, -0.08753332f, 0.04225827f, -0.00685315f, 0.06479676f, 
    0.08497975f, 0.10113356f, 0.16285966f, 0.06011103f, -0.13341430f, -0.10013586f, 0.06518558f, -0.09100344f, 
    -0.02298439f, 0.00852509f, 0.04010739f, -0.53544164f, 0.14519113f, -0.05433611f, -0.01041834f, 0.14464730f, 
    0.04418788f, 0.02481226f, 0.17021297f, -0.00829658f, -0.16936363f, -0.06898268f, -0.02834522f, 0.09604795f, 
    -0.05543745f, 0.18164676f, 0.02826569f, -0.02065673f, -0.09106269f, -0.09353566f, 0.14542696f, 0.16061378f, 
    -0.04704149f, -0.04517658f, 0.04417773f, -0.04746114f, -0.03412477f, 0.08430863f, 0.05822864f, 0.06486781f, 
    0.02932176f, -0.02170264f, -0.07834447f, -0.09410284f, 0.02538097f, -0.07604960f, 0.12533957f, -0.38626486f, 
    -0.24171968f, -0.09057525f, -0.07040642f, 0.08948065f, 0.02167729f, -0.03381464f, -0.00159716f, -0.00142676f, 
    0.24756242f, 0.06085146f, -0.05829731f, -0.06602100f, -0.09843393f, 0.00955775f, -0.05375944f, -0.01410754f, 
    -0.08408578f, -0.04020739f, 0.01746566f, 0.04945970f, 0.02446123f, 0.14047709f, -0.03670307f, 0.09276467f, 
    0.11387401f, 0.11782359f, -0.43438652f, -0.35713449f, 0.00105552f, -0.06383642f, 0.11626232f, 0.01634855f, 
    0.09819128f, -0.01351655f, -0.07833833f, 0.14193831f, -0.05248984f, 0.06448664f, 0.03197087f, 0.07639629f, 
    0.08191489f, 0.12961975f, -0.02570307f, 0.03686262f, 0.09197696f, -0.37351292f, -0.16569129f, 0.03652516f, 
    0.01673460f, 0.03675221f, 0.02296217f, 0.06068549f, 0.08280993f, 0.16210571f, 0.09374543f, -0.16276070f, 
    -0.00296065f, -0.10744213f, 0.03247825f, -0.01434198f, -0.13584267f, 0.00920316f, 0.28010702f, -0.01909553f, 
    0.01075491f, 0.03573469f, -0.13903806f, -0.02909977f, 0.01380498f, -0.09084210f, -0.03115567f, 0.03719259f, 
    -0.00238840f, -0.09654883f, -0.01132273f, 0.08639228f, 0.05054491f, -0.02305453f, 0.02612703f, 0.14083187f, 
    0.04876623f, 0.03408483f, -0.13007373f, 0.01209993f, -0.01150691f, 0.15772422f, 0.02189131f, -0.01092690f, 
    0.03863537f, -0.13318215f, 0.07746907f, -0.08906063f, -0.09773942f, -0.13445735f, 0.05874691f, 0.13227756f, 
    -0.01477582f, 0.04309682f, 0.16129756f, 0.03276390f, -0.06539799f, -0.10600699f, 0.00710444f, -0.02198006f, 
    0.04153495f, 0.05725183f, 0.00604584f, 0.02570082f, 0.03584190f, 0.00664109f, 0.03800744f, 0.14817397f, 
    -0.02006164f, -0.05159680f, 0.01907772f, -0.10077585f, -0.04483686f, 0.10242590f, 0.19554771f, 0.02544806f, 
    -0.08380569f, -0.01634729f, -0.00612049f, 0.02446406f, -0.02320762f, 0.29515669f, -0.06301542f, 0.03816788f, 
    0.05578134f, -0.05250661f, 0.06345656f, 0.04106278f, -0.01830745f, -0.03054519f, -0.00181585f, -0.16806164f, 
    0.08165286f, 0.06410001f, 0.04522969f, -0.00994274f, -0.00118628f, -0.00849326f, -0.02048198f, -0.01059655f, 
    0.06324778f, 0.17635466f, 0.07031162f, 0.12127542f, 0.02380743f, -0.06446284f, 0.01962175f, 0.00729268f, 
    -0.03096733f, -0.01259496f, 0.06541120f, -0.16406117f, 0.06662946f, -0.09583239f, 0.12631142f, -0.05732796f, 
    0.04982910f, -0.17290443f, 0.04412180f, 0.30062020f, 0.30503902f, -0.03024226f, -0.02374426f, -0.09405839f, 
    -0.01222713f, -0.01546192f, 0.04654327f, 0.11354565f, 0.15627186f, -0.11209316f, 0.04578881f, 0.08980285f, 
    -0.05975995f, -0.08015205f, 0.06262386f, 0.10904074f, -0.00566683f, 0.38491219f, -0.00427518f, -0.09545804f, 
    -0.06567104f, -0.01482396f, -0.01790285f, 0.04340961f, -0.05161291f, 0.18468820f, -0.00255505f, 0.06533918f, 
    0.01913146f, 0.06338581f, 0.01158749f, -0.00427330f, 0.11778633f, 0.02956279f, 0.09062963f, -0.16153160f, 
    -0.01792905f, 0.09318366f, -0.02852473f, -0.01997288f, 0.03648391f, -0.09823925f, 0.08421186f, -0.17393902f, 
    -0.10354138f, 0.11760335f, 0.06546080f, 0.00461218f, 0.08583456f, 0.02619333f, 0.02552783f, -0.06772307f, 
    -0.07538196f, 0.10411016f, -0.14825267f, -0.01337423f, -0.11167316f, -0.04270875f, -0.03918249f, 0.01956899f, 
    -0.01550160f, 0.10903203f, 0.00533352f, -0.01500683f, -0.07124881f, -0.05423144f, -0.03741915f, 0.01482841f, 
    -0.11958248f, 0.21843596f, -0.05863554f, 0.10400223f, -0.06839710f, 0.00285066f, 0.09100816f, 0.01482983f, 
    -0.01996338f, -0.07286908f, -0.15393490f, 0.05212349f, -0.39696220f, 0.04163406f, -0.03645962f, -0.01594081f, 
    -0.10792715f, 0.05011792f, -0.00415982f, 0.16405106f, 0.05518728f, 0.08341133f, 0.04131236f, 0.06483229f, 
    -0.11832764f, 0.07365443f, 0.13454534f, -0.05838804f, 0.26582992f, 0.00670196f, 0.12615794f, 0.04392189f, 
    -0.06456931f, -0.00556815f, -0.10403114f, -0.26042351f, -0.02451676f, -0.20965953f, -0.29098752f, -0.06995447f, 
    -0.04256863f, -0.02560592f, -0.03593140f, 0.02315265f, -0.12125175f, 0.01478813f, -0.26305115f, -0.07592294f, 
    -0.07736497f, 0.28041977f, 0.02514506f, -0.06878541f, -0.00673472f, -0.02574648f, 0.09117016f, -0.05996183f, 
    0.09027227f, -0.01908433f, 0.11248590f, -0.11332554f, -0.01537434f, 0.13652182f, -0.05014606f, -0.02226689f, 
    -0.02991181f, 0.13760713f, -0.60151577f, 0.16286090f, 0.00077432f, -0.07683381f, 0.05556650f, -0.06313611f, 
    -0.13022001f, 0.09670552f, 0.06063354f, 0.33527699f, -0.05625167f, 0.05918535f, -0.00071462f, -0.02781338f, 
    0.05356833f, -0.01445402f, -0.05806570f, 0.03421672f, -0.03210668f, 0.15697160f, -0.03995530f, -0.08056691f, 
    -0.00826150f, 0.06046809f, -0.05584809f, -0.22884040f, -0.25672463f, -0.29007816f, 0.08748773f, -0.14124078f, 
    -0.03034519f, 0.06828497f, -0.00375775f, 0.05464702f, -0.30597371f, -0.11788448f, -0.06988151f, 0.12437487f, 
    0.03549783f, -0.04345310f, 0.04821012f, 0.04225475f, -0.01927604f, -0.08502276f, 0.16926003f, 0.17548521f, 
    -0.00314110f, -0.05733779f, -0.10030898f, 0.03189741f, 0.03011831f, -0.05322736f, 0.07568708f, -0.07210970f, 
    -0.02079975f, 0.08935728f, -0.02488356f, 0.04250725f, 0.05312175f, -0.10461441f, 0.04130730f, 0.08248822f, 
    0.14177068f, 0.14044233f, -0.08160813f, 0.04795360f, 0.01029723f, -0.00754890f, 0.01616538f, -0.01614245f, 
    -0.05573900f, 0.15018532f, 0.23728260f, 0.08476815f, 0.04162318f, -0.03163601f, 0.01508484f, -0.04310738f, 
    0.02523426f, 0.06942096f, 0.01270631f, 0.23407716f, -0.14165053f, 0.04663265f, -0.04356651f, -0.00522070f, 
    -0.04553121f, 0.17318113f, -0.09916729f, 0.08612802f, -0.05938968f, -0.04171779f, 0.21145165f, -0.03122050f, 
    -0.06096704f, 0.00756283f, 0.01752561f, -0.07918340f, -0.05960919f, 0.19835813f, 0.02169696f, -0.00737143f, 
    0.03668035f, 0.09798243f, -0.03513717f, 0.03622273f, 0.20787033f, -0.25392759f, -0.05145076f, -0.06973305f, 
    0.10700709f, 0.04604592f, -0.03881541f, -0.08547642f, 0.10406908f, -0.20611015f, 0.13606085f, -0.08256526f, 
    -0.02345506f, -0.03803908f, -0.12004375f, 0.03353685f, -0.00618056f, 0.08576682f, -0.03928759f, -0.16012724f, 
    -0.06339714f, 0.05909497f, 0.00236569f, 0.00363849f, -0.01906346f, -0.03585283f, 0.05818853f, -0.02967854f, 
    0.02494961f, 0.10888550f, -0.06203108f, -0.03436177f, 0.08715524f, -0.01446136f, 0.06063696f, 0.01483526f, 
    -0.04257599f, -0.00677099f, 0.00912319f, -0.02214338f, -0.01098386f, -0.02288996f, 0.05566125f, -0.03769975f, 
    0.02253782f, 0.03481288f, -0.00563804f, -0.00627912f, -0.04234258f, 0.03324557f, 0.00381213f, -0.04035859f, 
    -0.05952705f, 0.04729579f, 0.04592673f, 0.01898314f, -0.06332269f, 0.02606973f, -0.03142914f, -0.03701001f, 
    0.02524794f, -0.04717905f, -0.00418248f, 0.01229931f, -0.04302191f, -0.02963328f, 0.03833769f, -0.05322323f, 
    -0.02038652f, 0.04619703f, -0.00546467f, -0.00679956f, 0.00294077f, -0.01861290f, 0.03074231f, -0.03544904f, 
    -0.05258114f, 0.03077874f, -0.00367715f, -0.03312368f, -0.06568531f, 0.02214789f, 0.05827120f, 0.01500920f, 
    0.02916476f, -0.01732042f, -0.06857837f, -0.04600368f, -0.06159191f, -0.01939143f, -0.02705604f, -0.06137513f, 
    -0.00651825f, -0.00649683f, 0.02608584f, -0.01257420f, 0.04262007f, -0.00705528f, -0.03400268f, -0.04335925f, 
    -0.02025451f, 0.01462821f, -0.04323409f, 0.04951401f, -0.00567249f, -0.01180843f, -0.03642515f, -0.01707119f, 
    -0.02857887f, 0.04056223f, -0.01069610f, 0.04860020f, 0.00699767f, -0.02917829f, -0.01483761f, -0.04388401f, 
    -0.03221557f, -0.01264114f, 0.01916675f, 0.02767184f, -0.00988329f, -0.02968562f, -0.00247882f, -0.01700793f, 
    0.01020033f, -0.03879866f, -0.02121447f, 0.03707776f, -0.02876385f, 0.00086102f, -0.03046330f, -0.05988934f, 
    0.02142782f, 0.04634008f, 0.04268730f, 0.04077711f, -0.04777386f, -0.03594313f, 0.00027410f, 0.00356358f, 
    -0.04155940f, 0.02093971f, -0.05220834f, -0.00723949f, -0.04712720f, 0.00398194f, -0.05575261f, -0.01725572f, 
    0.00643665f, -0.02432730f, -0.02921368f, 0.00631148f, 0.01445444f, 0.04607137f, -0.04113784f, 0.03999301f, 
    -0.03766607f, -0.02898254f, 0.04230470f, -0.05298230f, 0.02664020f, 0.01222797f, 0.04343737f, -0.00719727f, 
    0.05054994f, -0.02969368f, 0.04248272f, 0.01743718f, -0.04921529f, 0.00772680f, 0.04471854f, -0.00378348f, 
    -0.04401794f, -0.06745116f, 0.01158097f, -0.05439427f, 0.03466570f, -0.06060995f, 0.02584999f, -0.03420264f, 
    0.00088090f, 0.03257416f, -0.03039392f, 0.01018783f, 0.01637007f, -0.04994652f, -0.05101358f, 0.01086888f, 
    -0.05808796f, 0.00258403f, 0.00793028f, 0.02671785f, -0.04970855f, 0.01274470f, -0.04929709f, -0.02975626f, 
    0.01935314f, -0.04667162f, 0.00822997f, -0.01946045f, -0.02129536f, 0.01710060f, 0.04532656f, 0.04787573f, 
    0.01469926f, -0.05490174f, 0.02745454f, -0.04318158f, 0.06243100f, -0.00631530f, 0.00563513f, -0.04142296f, 
    0.05369088f, 0.00450902f, -0.02834659f, -0.03275011f, -0.04106912f, -0.04178192f, -0.04347924f, 0.02119385f, 
    -0.03321084f, 0.01993458f, -0.04399447f, 0.01053147f, 0.03660347f, -0.02720695f, -0.04492271f, 0.00164734f, 
    -0.06068459f, -0.00895776f, -0.03988801f, -0.01701810f, -0.00606445f, 0.03409994f, -0.01651528f, 0.04500152f, 
    -0.03177240f, 0.00388892f, -0.03075094f, -0.05490755f, 0.01293998f, -0.02708746f, 0.05575881f, -0.04735439f, 
    -0.04065825f, 0.05033932f, 0.00311056f, -0.00832489f, 0.02247442f, -0.00946063f, -0.06570180f, -0.05603879f, 
    -0.00499620f, -0.01886333f, 0.02801042f, -0.05278776f, -0.01366257f, -0.01075708f, 0.03975354f, 0.00763419f, 
    0.04022016f, 0.03818269f, -0.04897724f, 0.00962421f, -0.01059414f, 0.02653627f, 0.00593423f, -0.02092424f, 
    0.03813652f, -0.03372093f, -0.06331692f, 0.01078842f, 0.00352409f, 0.00111969f, 0.02741189f, -0.05058525f, 
    -0.04219574f, -0.00225732f, 0.00551605f, -0.03346102f, 0.02897991f, -0.03375918f, 0.01142927f, -0.05795892f, 
    0.02285060f, -0.01531097f, 0.03513663f, -0.00577847f, -0.05698980f, -0.00255219f, -0.00055938f, -0.05469083f, 
    -0.00944836f, 0.00491471f, -0.05154420f, 0.04951327f, -0.00606971f, 0.02960660f, 0.01828046f, 0.02258109f, 
    -0.02043255f, -0.02686824f, -0.03330370f, -0.00304783f, 0.03267978f, 0.01643228f, -0.01711650f, 0.01811404f, 
    0.04313370f, 0.01403518f, -0.01759683f, -0.03653480f, 0.02297177f, -0.03632312f, -0.00507309f, -0.02437640f, 
    0.05086381f, -0.05907787f, -0.01418625f, 0.00164206f, -0.02867769f, -0.04836686f, 0.01170838f, 0.04641755f, 
    0.06607466f, -0.02283119f, -0.09139998f, -0.10645384f, 0.04610669f, 0.03567008f, -0.00598062f, 0.01201159f, 
    0.03876849f, -0.22987880f, -0.02820197f, -0.08586475f, -0.02183553f, 0.17866196f, -0.04867709f, 0.06312800f, 
    -0.00348799f, 0.01712494f, -0.29693928f, -0.03685666f, -0.10671163f, -0.10779946f, 0.06698669f, -0.02119738f, 
    -0.01613145f, -0.11079916f, 0.03114038f, -0.37960607f, -0.15730922f, 0.05350824f, -0.10756382f, 0.01035595f, 
    0.03103360f, 0.09003732f, 0.00068900f, 0.06421424f, -0.01533909f, 0.02953543f, -0.07458633f, -0.08683413f, 
    0.12820990f, -0.00171332f, -0.10723376f, -0.01477980f, 0.17915410f, -0.03472844f, -0.04289818f, -0.10826539f, 
    0.04602477f, 0.00176639f, 0.00759635f, 0.19285113f, 0.02442037f, 0.04643003f, 0.12167266f, 0.17128526f, 
    0.12502943f, -0.00686718f, -0.13096042f, 0.13464867f, -0.04694391f, -0.06007788f, -0.01386892f, 0.01942744f, 
    -0.02287392f, -0.11857925f, -0.01958738f, 0.12466434f, 0.18949756f, 0.11586501f, 0.00746775f, 0.05619919f, 
    0.14315678f, 0.03169680f, 0.16280808f, 0.05060374f, 0.00407875f, -0.00425756f, 0.18374881f, 0.03592795f, 
    -0.06474365f, -0.37074640f, -0.10857607f, 0.06514911f, -0.02867972f, -0.05394429f, 0.17174806f, -0.04141596f, 
    -0.10649195f, -0.02246232f, -0.00697874f, -0.01463130f, -0.05498883f, -0.02799012f, 0.14209142f, -0.04216857f, 
    0.09965359f, -0.09371745f, 0.10587810f, 0.08435520f, 0.09714811f, 0.20339543f, 0.14651765f, 0.01878422f, 
    0.04546442f, -0.02953077f, 0.01602105f, -0.07038754f, -0.00673471f, -0.05940940f, 0.00446479f, -0.03061811f, 
    -0.03372297f, -0.06560960f, -0.04702175f, 0.01344278f, 0.04437201f, 0.03718436f, -0.06058853f, -0.05705075f, 
    0.07155006f, -0.02353445f, 0.02772499f, -0.08488282f, 0.05871099f, 0.06676572f, -0.18129669f, 0.08898395f, 
    0.01543537f, -0.02480754f, -0.01012535f, -0.12232038f, 0.04963859f, 0.11536130f, 0.14333561f, 0.12227568f, 
    0.20794240f, 0.03482131f, -0.08449570f, 0.04755938f, 0.06041672f, -0.11830908f, -0.03024868f, 0.04874799f, 
    -0.10519370f, -0.07923435f, 0.08561509f, -0.05103459f, -0.07254398f, 0.00659386f, -0.02279633f, 0.01154288f, 
    0.04917900f, -0.26742861f, -0.07627024f, -0.15437421f, 0.00317371f, -0.03179990f, 0.10996535f, -0.09315492f, 
    -0.04376250f, 0.08512912f, 0.07984591f, 0.11930554f, 0.17665718f, 0.12320232f, 0.03015591f, 0.05414173f, 
    0.06507179f, 0.00266001f, -0.04911402f, 0.09665706f, 0.05085050f, 0.13792586f, 0.02606990f, 0.03076922f, 
    -0.11497031f, -0.11192524f, 0.04053593f, 0.27933022f, 0.08622257f, 0.12419719f, 0.14004424f, -0.06318437f, 
    -0.03237193f, 0.02555393f, 0.11323607f, 0.12230652f, 0.09694515f, -0.04095540f, -0.00965176f, -0.24660452f, 
    0.05568150f, 0.03252246f, -0.16931291f, 0.14269117f, 0.17776987f, 0.08638056f, -0.16022334f, 0.03028310f, 
    0.15333852f, -0.00340778f, -0.04888860f, 0.09456144f, 0.11612777f, -0.05381420f, -0.09750514f, 0.03764812f, 
    0.12692745f, -0.03859536f, -0.00712669f, -0.00603333f, 0.10460556f, 0.00285158f, -0.02975194f, -0.09178334f, 
    -0.29711694f, -0.06035583f, -0.18546920f, -0.04435014f, 0.10014910f, -0.10622360f, -0.11456122f, 0.05636596f, 
    0.06338789f, -0.25128582f, -0.02595005f, -0.09669445f, -0.05584343f, 0.06666845f, -0.03679369f, 0.13441476f, 
    -0.26439524f, 0.07109151f, -0.04679798f, -0.05517974f, -0.01686990f, -0.01258237f, -0.01045316f, 0.03569456f, 
    -0.03596559f, 0.02902625f, 0.11667258f, 0.02671998f, -0.07219953f, -0.14327900f, 0.07368316f, -0.08227257f, 
    -0.04583676f, 0.18707912f, 0.03811936f, -0.10009716f, -0.14423251f, 0.11448238f, -0.01193854f, 0.04117843f, 
    -0.05026054f, 0.01074025f, 0.05656636f, -0.12866183f, 0.00478360f, 0.05308291f, 0.04800669f, 0.07414692f, 
    0.00839399f, 0.11021531f, 0.07530603f, -0.14876275f, -0.00675984f, -0.04668314f, 0.18762025f, 0.08222075f, 
    0.11683130f, 0.09898625f, 0.01006844f, 0.19055349f, -0.06959828f, 0.06442364f, 0.01576908f, -0.30985409f, 
    -0.18903457f, -0.12233451f, 0.06561875f, -0.02839120f, 0.13977188f, 0.07067379f, -0.20010205f, -0.01035733f, 
    -0.02160391f, -0.03662345f, -0.00306935f, -0.13908969f, -0.10146018f, -0.01115604f, -0.10509614f, 0.10093663f, 
    0.05870046f, -0.44492179f, -0.04128836f, 0.24163739f, 0.22353928f, 0.21356381f, -0.02297268f, 0.10606586f, 
    0.00701048f, -0.03972726f, -0.00035231f, -0.25216311f, -0.16485065f, -0.07903051f, -0.00663771f, 0.00533349f, 
    0.00942774f, 0.00604308f, 0.00274442f, -0.08819899f, -0.33681244f, -0.28995240f, -0.24466743f, -0.14366625f, 
    -0.10004401f, -0.05988932f, -0.04571792f, 0.15182620f, -0.14488856f, 0.03247487f, 0.08314191f, -0.00729897f, 
    0.04387042f, -0.04866964f, -0.01194519f, -0.06279889f, 0.01112383f, 0.03889607f, -0.14295118f, 0.03606108f, 
    -0.25896183f, 0.06068642f, 0.04651633f, -0.09026159f, 0.04635144f, -0.05741939f, -0.11766738f, 0.06021222f, 
    0.01326933f, -0.09452825f, -0.08104038f, 0.06449968f, 0.05031870f, 0.02732762f, -0.00795256f, 0.04564722f, 
    0.15024595f, -0.12168769f, -0.14010197f, 0.11141413f, 0.04660935f, -0.06908785f, 0.15446532f, -0.03828292f, 
    -0.02740411f, 0.00188013f, 0.07660794f, -0.05801859f, 0.05098451f, 0.03754161f, 0.07496782f, 0.05982094f, 
    -0.01545345f, 0.27499276f, 0.04113854f, -0.01302589f, -0.10215894f, -0.06230748f, -0.04143739f, 0.09327377f, 
    -0.04344488f, 0.11122803f, -0.05472682f, 0.05762113f, 0.25304192f, -0.11942534f, 0.00158254f, 0.00488805f, 
    -0.12748858f, 0.02296218f, 0.03821249f, 0.10202127f, -0.05443231f, -0.28910702f, -0.12178806f, -0.10358173f, 
    -0.01491202f, 0.10850266f, 0.22452147f, -0.00530410f, -0.03982150f, 0.11201117f, 0.00381986f, -0.01789759f, 
    -0.07634738f, -0.01198502f, -0.05574089f, 0.04658373f, 0.02558919f, -0.15558307f, -0.02802581f, -0.05030874f, 
    0.06562730f, 0.08245734f, -0.07777117f, -0.07590766f, -0.09310194f, -0.04169156f, -0.19856624f, -0.17248650f, 
    0.12273873f, 0.16826995f, 0.12629420f, 0.12955755f, 0.03026807f, -0.01283501f, 0.03275203f, 0.02441206f, 
    0.23747535f, 0.10243388f, -0.06394865f, 0.00776107f, -0.04608009f, -0.00857076f, 0.00578995f, 0.03573090f, 
    0.10536812f, -0.09665846f, -0.03790351f, 0.07572374f, 0.03469199f, 0.07054935f, 0.07476795f, -0.17123842f, 
    -0.08132379f, -0.08756362f, 0.02508806f, 0.03680139f, 0.11096805f, 0.16868706f, 0.02009135f, -0.11933734f, 
    -0.00449145f, 0.04158307f, 0.01628586f, -0.08703267f, 0.11609365f, -0.10862629f, -0.00244306f, -0.03356649f, 
    0.11884123f, 0.09056388f, 0.03859627f, -0.04197598f, 0.16732097f, 0.06439494f, -0.04804340f, -0.00116680f, 
    -0.17061204f, 0.01576877f, -0.05705534f, 0.04936145f, -0.00181441f, 0.06312831f, 0.18674834f, 0.06657519f, 
    0.08066837f, -0.07732842f, 0.07217263f, 0.08853649f, 0.00194091f, -0.19138116f, -0.01858123f, 0.19146140f, 
    0.10367361f, -0.05833223f, -0.00055505f, -0.01010777f, 0.03120371f, 0.07377959f, 0.16817635f, 0.24062078f, 
    0.22509737f, -0.05420071f, 0.00029691f, 0.01187444f, -0.01710921f, 0.08389360f, 0.06211810f, 0.10654211f, 
    0.10899429f, 0.01226887f, 0.13360228f, 0.06392631f, 0.09344032f, 0.00487145f, 0.07235717f, 0.09282965f, 
    -0.48861653f, -0.06230430f, 0.20454255f, 0.25904080f, 0.01077785f, 0.02816893f, 0.05971278f, -0.01044483f, 
    0.05485727f, -0.24884520f, -0.24919888f, -0.02526824f, 0.05419662f, 0.10772582f, 0.08170882f, 0.10979297f, 
    0.03852907f, -0.04100886f, -0.11888245f, 0.00607720f, 0.01130820f, 0.01819455f, -0.00637197f, -0.06332932f, 
    0.09425221f, 0.03403239f, 0.00466310f, -0.28186911f, 0.10131720f, 0.23164029f, 0.10407200f, 0.09236838f, 
    0.04011214f, -0.01476655f, 0.13759449f, 0.07981759f, 0.00523782f, -0.09757905f, -0.19507526f, 0.02907128f, 
    0.05963583f, -0.06360370f, 0.14173160f, 0.01563861f, -0.06081976f, -0.01186787f, -0.04236025f, 0.07322795f, 
    -0.02006823f, 0.12132069f, 0.13017432f, 0.00542749f, 0.00557629f, 0.02737043f, 0.00949783f, -0.09266654f, 
    -0.08257852f, -0.03268537f, 0.04868098f, 0.01983265f, 0.11826438f, 0.11686124f, 0.04352338f, -0.24376407f, 
    -0.01397201f, 0.06063937f, -0.11145705f, 0.08496962f, 0.06282270f, 0.06067439f, -0.07092713f, 0.07281404f, 
    -0.18635561f, 0.13145176f, -0.18658632f, -0.02269860f, 0.06176409f, 0.00230753f, 0.04482167f, -0.06167921f, 
    -0.02123244f, 0.07049351f, 0.08017587f, 0.08208936f, 0.07619245f, -0.07972050f, -0.04082645f, -0.00332229f, 
    -0.00624958f, -0.01711208f, 0.11430559f, -0.07342339f, 0.03649923f, -0.05088028f, 0.03691551f, -0.23868184f, 
    0.02314834f, 0.16468602f, 0.14695016f, -0.03676974f, 0.09386393f, -0.04048746f, -0.03165662f, 0.12127680f, 
    0.03594096f, -0.05498802f, 0.07697158f, 0.03998888f, -0.03781907f, 0.08809430f, 0.02271820f, 0.04456798f, 
    0.07948650f, 0.04656473f, 0.11838910f, 0.12579040f, 0.03094284f, -0.19228603f, 0.03424636f, 0.05250430f, 
    0.13173461f, 0.00469434f, 0.00594253f, -0.12211210f, -0.26799631f, -0.18171500f, -0.21813954f, -0.31910655f, 
    -0.00922446f, 0.15224776f, -0.03482451f, 0.05489410f, -0.03265840f, -0.05577275f, -0.08130334f, -0.15853553f, 
    0.12565602f, 0.12635589f, -0.03256165f, 0.08464707f, 0.03500407f, -0.05795493f, -0.10954409f, -0.12296816f, 
    -0.30170614f, -0.28611070f, 0.03724717f, 0.22101711f, -0.01626331f, 0.08498664f, 0.10998227f, -0.04837200f, 
    0.04459546f, 0.19106531f, 0.05642699f, -0.08828545f, 0.06824202f, 0.08134485f, -0.22946829f, 0.12030297f, 
    -0.02982453f, -0.02584353f, 0.18359928f, 0.14079276f, 0.01703839f, 0.07690913f, 0.10520335f, 0.10463782f, 
    -0.05268716f, 0.01761197f, -0.13408284f, -0.36808175f, -0.29286176f, 0.12625971f, 0.12190346f, 0.06305701f, 
    -0.08911517f, -0.02590344f, 0.00992982f, 0.17487629f, -0.35478628f, -0.04455601f, -0.16100931f, -0.01394223f, 
    0.02095045f, -0.13625552f, 0.04753682f, 0.13141164f, 0.05848528f, 0.09034359f, 0.28851330f, 0.03372620f, 
    -0.02039604f, -0.01769713f, 0.03192807f, -0.10976879f, 0.03279329f, -0.07103873f, 0.10001481f, 0.09166638f, 
    0.02400222f, 0.02121586f, -0.02401613f, 0.05019220f, -0.09888466f, 0.00009178f, 0.00648959f, -0.36186662f, 
    -0.19876447f, -0.01729800f, 0.06578094f, 0.05598519f, -0.06152529f, 0.16058059f, 0.01161054f, 0.11781173f, 
    -0.01692957f, -0.10998626f, -0.07714500f, 0.09286994f, 0.05065591f, 0.07538187f, -0.09275226f, -0.05788299f, 
    0.00971627f, 0.28112161f, 0.20448013f, 0.10600875f, -0.04008842f, -0.02510079f, -0.14678776f, 0.06450989f, 
    0.11803846f, 0.10567025f, -0.08878876f, -0.19611792f, -0.00457899f, 0.03961904f, -0.11518511f, 0.01512953f, 
    0.06501919f, 0.01751889f, 0.10295012f, 0.00033942f, -0.00488606f, 0.06898388f, 0.01426682f, 0.06526993f, 
    0.05908291f, -0.12110864f, -0.00081342f, -0.02250396f, -0.19673575f, -0.20139210f, 0.10951229f, 0.07469404f, 
    0.05474500f, 0.09956390f, -0.14266500f, -0.01111010f, -0.08326710f, 0.06432942f, 0.02930701f, -0.06766716f, 
    0.09916883f, 0.06026618f, 0.07522464f, -0.10880733f, 0.04751625f, -0.05495383f, -0.20401625f, -0.00262302f, 
    -0.23618308f, 0.08530406f, -0.05927027f, -0.09801829f, 0.04642852f, -0.05588870f, 0.02452193f, 0.21088070f, 
    0.15010643f, 0.06446229f, 0.18185274f, 0.08900218f, -0.02156280f, 0.23093437f, 0.08868014f, 0.00447567f, 
    0.19081359f, 0.21813607f, 0.11344378f, -0.07217924f, -0.03620390f, 0.09826844f, -0.07526198f, 0.14393435f, 
    0.07396340f, -0.02331062f, 0.08686832f, 0.00276664f, 0.14943971f, 0.04251561f, -0.04263543f, 0.01878450f, 
    0.04000746f, -0.08080329f, 0.06037098f, -0.18922392f, 0.02026579f, 0.02284370f, 0.24276331f, 0.11569487f, 
    -0.02890645f, 0.07762568f, -0.10227995f, 0.08803000f, -0.01571850f, 0.05371033f, -0.01975249f, -0.02081065f, 
    0.15352543f, 0.07386860f, 0.06547920f, -0.05581007f, -0.06022809f, 0.01686451f, -0.09754246f, -0.09404838f, 
    -0.16474701f, -0.00259867f, 0.06400351f, 0.00132121f, 0.02899961f, 0.02278624f, -0.12342844f, -0.02396076f, 
    0.10469928f, 0.02665548f, -0.06562172f, 0.15257676f, -0.12366652f, -0.10722665f, -0.41350070f, -0.33571056f, 
    0.02886882f, 0.01092127f, 0.12763090f, -0.01559347f, -0.04750565f, 0.04235426f, 0.24760911f, 0.22020485f, 
    0.04034835f, -0.07156964f, -0.01135662f, 0.01348719f, 0.06956536f, 0.06202182f, 0.01882964f, -0.13442872f, 
    0.15506962f, -0.48687994f, 0.03979729f, -0.17477080f, -0.01138079f, 0.07816938f, 0.07287668f, 0.08099168f, 
    -0.01858188f, -0.31532681f, -0.15930079f, -0.07118756f, -0.05299113f, 0.14562616f, 0.01734543f, -0.04878918f, 
    -0.02504716f, -0.06387901f, -0.42248508f, 0.19255209f, -0.40498367f, 0.08136763f, -0.03397433f, -0.12104493f, 
    0.03933660f, 0.11229042f, 0.01416025f, -0.17319161f, -0.17943908f, 0.16883457f, -0.15508361f, -0.10603876f, 
    0.07914036f, 0.07400683f, -0.06495561f, 0.04485304f, -0.00113816f, -0.29003581f, -0.02951416f, -0.07535584f, 
    0.09766788f, -0.11392216f, 0.13699362f, -0.04036253f, 0.04063518f, 0.03841022f, -0.35195172f, 0.02167341f, 
    -0.24202976f, 0.03350146f, -0.03856872f, -0.04916733f, -0.09608230f, 0.15659703f, 0.15117936f, 0.07772800f, 
    -0.23820083f, -0.15880261f, 0.01589838f, -0.03970762f, -0.07412463f, -0.02806320f, 0.05203938f, 0.18590690f, 
    -0.05901514f, -0.16751152f, -0.07627521f, -0.04414104f, 0.08361380f, 0.15502779f, 0.21273677f, 0.15929174f, 
    -0.13240233f, -0.02747712f, 0.15060012f, 0.00585546f, 0.16340832f, 0.11649887f, 0.02387621f, 0.07185264f, 
    0.05396291f, 0.27250689f, 0.25894764f, 0.30952713f, 0.00185396f, 0.09563730f, -0.06768958f, 0.06105059f, 
    -0.16144018f, 0.10751892f, 0.18456791f, -0.14058442f, 0.03481285f, 0.04420500f, 0.00929453f, -0.03972997f, 
    0.14181450f, 0.02641228f, 0.09240183f, 0.07611974f, 0.07109808f, -0.07106931f, -0.07833130f, 0.07658343f, 
    0.14443372f, 0.19871417f, 0.08470675f, 0.07564737f, -0.19062580f, 0.07646055f, 0.00380692f, 0.01481735f, 
    0.14014484f, 0.10340630f, -0.08265816f, 0.10402472f, -0.01393229f, 0.01878620f, -0.20632669f, -0.16819297f, 
    0.01375429f, 0.06636173f, -0.10320685f, 0.10710920f, -0.08149495f, -0.04096846f, 0.56801283f, -0.09928378f, 
    -0.23671041f, 0.13336062f, -0.13706855f, -0.00803220f, 0.13326849f, 0.01630503f, -0.09461840f, 0.14710259f, 
    0.12301354f, -0.18293044f, 0.03328196f, 0.04118582f, 0.02312593f, 0.05716068f, 0.05537049f, -0.16828397f, 
    0.39339948f, -0.00710125f, 0.10033520f, -0.10948954f, 0.06151670f, -0.13886857f, -0.01523352f, 0.03377453f, 
    -0.11518182f, 0.05562252f, 0.29360572f, -0.11036725f, 0.08225553f, 0.02199668f, 0.06217692f, 0.05310054f, 
    -0.09714825f, -0.10084602f, 0.00679902f, 0.21069212f, -0.06503203f, -0.08470167f, 0.03873583f, -0.05868831f, 
    -0.08063380f, -0.03884786f, 0.15684780f, 0.13332610f, 0.12958051f, 0.10956487f, 0.00686524f, -0.01982540f, 
    0.04501181f, -0.12688930f, 0.05893736f, -0.01858173f, 0.04101032f, 0.03243543f, 0.05392563f, -0.04588919f, 
    -0.02679052f, -0.01789141f, 0.10708381f, 0.02388938f, -0.03672640f, -0.09975576f, -0.35310823f, 0.02934789f, 
    0.01343178f, 0.11690241f, -0.01665640f, 0.05089335f, 0.00036671f, 0.08775841f, 0.56584030f, -0.25237912f, 
    0.35954109f, -0.15663679f, -0.07179320f, -0.02147665f, -0.19875970f, 0.00356824f, 0.11553390f, 0.01870376f, 
    0.12942272f, -0.36010519f, 0.06756128f, 0.09375490f, 0.12873679f, -0.04636120f, -0.00340283f, 0.05308876f, 
    -0.10654921f, 0.04417853f, -0.34209085f, -0.07856144f, 0.14690875f, -0.05866188f, 0.06178736f, 0.06846523f, 
    -0.03396286f, -0.19103946f, 0.22507758f, -0.13040330f, 0.02195792f, 0.04636203f, -0.00693914f, -0.03660537f, 
    0.01375100f, 0.06753008f, -0.09822132f, -0.03234288f, 0.00379129f, -0.03453223f, 0.03779179f, 0.05542273f, 
    0.10629013f, 0.20489435f, 0.06934553f, 0.07889964f, -0.06890860f, -0.11867154f, -0.00133036f, 0.08788589f, 
    0.11005216f, 0.10326488f, 0.12808564f, -0.08332931f, 0.08639271f, -0.11967960f, 0.29805714f, -0.14736131f, 
    -0.07163470f, -0.10975813f, -0.06622147f, -0.01349791f, 0.10845892f, 0.09558463f, -0.08053438f, 0.18239586f, 
    -0.09960204f, 0.04428479f, -0.07722259f, 0.10566355f, 0.07490331f, -0.11848752f, -0.07907609f, 0.16500954f, 
    -0.17992933f, -0.00831625f, 0.01357322f, 0.00994775f, -0.06952634f, -0.04656968f, 0.00813065f, 0.16341767f, 
    0.26475716f, -0.04161477f, 0.08702315f, -0.03101652f, 0.04250022f, -0.01468520f, -0.09159219f, -0.18993959f, 
    0.23737532f, -0.59913534f, 0.07029686f, -0.04677930f, -0.19636078f, -0.00384867f, -0.04896379f, -0.01404260f, 
    -0.00129613f, 0.33742002f, -0.04511171f, 0.12200252f, 0.03514589f, 0.05187671f, 0.06679278f, 0.03598884f, 
    0.06272691f, 0.03575408f, 0.35950691f, 0.04856020f, -0.14611831f, 0.01640451f, -0.00919647f, -0.00509943f, 
    0.00536986f, -0.05452174f, 0.18709390f, 0.09591854f, 0.12455416f, -0.44873178f, 0.13994655f, -0.01010211f, 
    0.13296472f, -0.01114817f, -0.00891942f, -0.02974013f, -0.19733056f, 0.05341053f, 0.08494946f, 0.00894617f, 
    -0.05229903f, -0.02389833f, 0.07056358f, -0.06360330f, -0.09885984f, -0.22753648f, -0.24129237f, -0.05514259f, 
    0.01234119f, -0.04557772f, 0.14248638f, -0.09669919f, -0.00984154f, -0.03698107f, 0.10218391f, 0.15902750f, 
    -0.18358047f, -0.01352842f, 0.02115444f, 0.05719094f, -0.09952264f, -0.03904518f, -0.14515465f, -0.35390770f, 
    -0.10401118f, -0.24237211f, -0.02561129f, 0.12929706f, -0.01297659f, 0.05721286f, 0.02753449f, 0.07513480f, 
    -0.11869024f, 0.09091572f, 0.00341220f, -0.02451058f, -0.00644077f, -0.02961917f, -0.08431862f, 0.04818741f, 
    0.07179973f, 0.25494337f, 0.04365035f, 0.00943563f, 0.05977358f, -0.11647734f, 0.00820707f, 0.00672338f, 
    0.03460079f, -0.05853078f, -0.18104228f, -0.05280781f, -0.09048712f, 0.10390308f, 0.06084307f, 0.21747109f, 
    -0.07430923f, 0.00610071f, 0.02862304f, -0.17034335f, -0.11348641f, 0.03468731f, 0.03031256f, 0.04278749f, 
    -0.05648165f, -0.00349823f, 0.07986482f, 0.23774667f, -0.03674135f, 0.00692012f, 0.10626631f, -0.09074792f, 
    0.10900091f, -0.11835845f, 0.10913290f, 0.01303920f, 0.01486774f, -0.01307813f, -0.17601575f, -0.22548217f, 
    0.09394109f, 0.00988222f, 0.06959856f, -0.04714242f, 0.02470026f, -0.00396088f, -0.06429588f, 0.00502406f, 
    -0.18235916f, 0.17967841f, 0.01952252f, 0.09717350f, -0.06720912f, 0.07108811f, -0.01006417f, -0.21496762f, 
    0.17553894f, -0.01207426f, 0.00735403f, 0.03526360f, 0.02041821f, -0.07069320f, 0.03449310f, 0.07294361f, 
    0.04044964f, -0.16712427f, -0.39056146f, 0.13177969f, 0.03499843f, 0.00788165f, -0.04581764f, -0.11975206f, 
    -0.02020057f, 0.18403865f, 0.00044758f, 0.01841353f, -0.00374213f, 0.07886293f, -0.13903481f, 0.11798809f, 
    -0.02027796f, 0.00121517f, -0.19177483f, 0.06325545f, -0.14062664f, -0.06771173f, -0.04264593f, 0.12475911f, 
    0.02806354f, 0.00156768f, 0.10728362f, -0.23701939f, 0.10389461f, -0.35604122f, 0.03616374f, 0.07856796f, 
    0.05310148f, -0.18831956f, 0.07245149f, 0.00037517f, 0.06501580f, -0.06756148f, -0.04867337f, -0.02158566f, 
    0.10370722f, 0.03570786f, -0.09944754f, 0.05462664f, 0.00612732f, -0.34531328f, -0.03486085f, -0.08743006f, 
    0.04994682f, 0.12788936f, 0.15952657f, -0.03475616f, -0.00909459f, 0.09930789f, 0.01467951f, 0.12340534f, 
    -0.08287697f, -0.13403094f, 0.07196655f, 0.02288832f, -0.10621668f, 0.11723179f, 0.07604184f, 0.06467006f, 
    0.14731461f, 0.13427982f, 0.16653167f, 0.02996342f, -0.03145315f, 0.10435583f, 0.02223107f, -0.06617153f, 
    0.01668555f, 0.23442732f, 0.11337060f, -0.10952839f, -0.01125680f, -0.20224287f, -0.00356152f, 0.14004467f, 
    -0.06259880f, 0.51146686f, -0.00841597f, 0.01951601f, 0.01151598f, 0.08872297f, -0.03970191f, -0.04555356f, 
    -0.07993967f, 0.07648402f, -0.21070525f, -0.19504943f, -0.00815497f, 0.06551389f, 0.06430238f, -0.13976417f, 
    -0.09033261f, -0.05701703f, 0.12577493f, 0.06268907f, -0.08391827f, 0.07316071f, 0.04404382f, 0.04559631f, 
    -0.02102709f, 0.00939642f, 0.05801388f, -0.01045515f, -0.06539235f, -0.09698419f, -0.04748200f, -0.00584420f, 
    0.03228955f, 0.08030044f, -0.01683733f, 0.06450626f, 0.01968143f, 0.04955242f, -0.09166420f, -0.12639742f, 
    0.06132398f, 0.00788085f, -0.13213509f, 0.05680452f, 0.09254582f, 0.01962985f, -0.01557900f, 0.07961646f, 
    -0.15393047f, -0.00276273f, 0.04501536f, 0.01361948f, -0.06622278f, -0.00764385f, 0.09271212f, 0.10647435f, 
    -0.00035234f, -0.05993877f, 0.10333205f, 0.05797068f, -0.04968609f, 0.10932720f, -0.01514828f, -0.01318200f, 
    0.03334533f, 0.04900648f, -0.11206436f, -0.00918064f, 0.08824916f, -0.18744725f, -0.08609611f, 0.09849385f, 
    0.03243896f, 0.06028549f, 0.26609895f, -0.11847761f, 0.01386144f, 0.10266086f, -0.00056495f, -0.06754062f, 
    0.04509749f, 0.01843692f, -0.42870072f, -0.05564527f, 0.09694608f, 0.03952399f, -0.03137869f, 0.11227096f, 
    0.07253538f, -0.01017621f, -0.14288682f, -0.47610092f, 0.07660093f, 0.03293705f, -0.01864561f, 0.12544014f, 
    -0.04867361f, 0.01623611f, -0.05945566f, 0.12561771f, 0.00011322f, 0.08388995f, 0.02169427f, 0.09153671f, 
    0.09947865f, -0.02183498f, -0.03387309f, 0.12920144f, -0.02993749f, -0.00763766f, 0.11494070f, -0.17383063f, 
    -0.02614659f, 0.00281544f, -0.03620782f, -0.04521601f, -0.01652261f, 0.00367824f, 0.29085454f, 0.10047348f, 
    0.03446224f, 0.03289014f, 0.15961742f, -0.10779973f, 0.08875442f, 0.05006821f, 0.05704001f, -0.17501925f, 
    0.06043304f, -0.06657597f, 0.03581501f, -0.07097769f, 0.06991658f, -0.12361684f, -0.10468272f, 0.06474336f, 
    0.20774485f, -0.21527979f, 0.00821984f, 0.06716496f, 0.08865101f, 0.13049318f, -0.08786115f, 0.02634695f, 
    0.06768838f, -0.45202902f, -0.25540349f, -0.15443279f, 0.07036740f, 0.12510893f, -0.02326003f, -0.12453854f, 
    0.01965865f, 0.00698168f, 0.06488609f, 0.00394401f, -0.22220778f, 0.14039047f, -0.07239968f, 0.16833083f, 
    0.03637443f, 0.01736590f, 0.05523299f, -0.09087460f, -0.06810317f, 0.10824227f, 0.16195446f, 0.14574361f, 
    0.08637698f, -0.05069175f, 0.02377625f, 0.13353184f, 0.37318602f, -0.22919896f, -0.04257858f, -0.01772708f, 
    -0.04632701f, 0.11277277f, 0.13049331f, 0.05328731f, -0.03855082f, 0.00779642f, -0.01980159f, -0.23071332f, 
    -0.10717455f, 0.06036390f, 0.10076971f, 0.00166717f, 0.06438930f, -0.04385378f, -0.06337517f, 0.01680510f, 
    -0.05449734f, -0.10689649f, -0.04264236f, -0.00967357f, 0.01582327f, -0.10699540f, -0.02527926f, 0.19210918f, 
    0.09889523f, 0.12832105f, -0.01717480f, -0.10489813f, 0.05497501f, 0.16970506f, 0.08534231f, 0.10539749f, 
    -0.19466698f, -0.18724303f, 0.17176713f, -0.11718212f, 0.05993441f, -0.04944467f, -0.12504180f, -0.08804417f, 
    0.01726097f, -0.00407076f, 0.04527406f, -0.19935368f, 0.09096024f, 0.05716490f, 0.00882052f, -0.09094701f, 
    -0.04758631f, -0.03586677f, 0.31197771f, 0.03953670f, 0.09163569f, 0.05509118f, 0.13833626f, -0.09927014f, 
    0.08792274f, 0.01097736f, 0.13401021f, 0.14446206f, 0.01737134f, -0.09307770f, 0.07765650f, 0.09552921f, 
    0.18388465f, 0.09812307f, -0.04870807f, -0.03131226f, 0.35657501f, 0.16736332f, -0.07221715f, 0.04969444f, 
    0.06927387f, 0.02019105f, 0.10588323f, -0.01270506f, 0.11001271f, 0.08443229f, -0.04017106f, -0.11046712f, 
    -0.03153045f, 0.03762574f, -0.00336071f, -0.01794484f, 0.03385071f, -0.04791337f, -0.23055612f, -0.21805508f, 
    -0.03908865f, -0.08072329f, -0.07496797f, -0.06967612f, -0.02893543f, 0.00785843f, 0.07178570f, -0.12496781f, 
    0.03580745f, 0.02256393f, 0.07966929f, 0.01070002f, -0.06034058f, -0.02036580f, 0.02581604f, -0.05965519f, 
    -0.02546076f, -0.04631663f, -0.07918544f, 0.02206234f, 0.06163083f, -0.02059824f, 0.12635635f, -0.06462998f, 
    0.06736313f, -0.23926477f, 0.12258266f, 0.02414959f, 0.06977875f, 0.05064206f, -0.04483543f, -0.11767945f, 
    0.05866298f, -0.00565357f, 0.00657139f, 0.06783506f, 0.00168946f, -0.01439570f, 0.07475755f, 0.05017142f, 
    0.02267663f, -0.23818010f, -0.02207681f, 0.08111750f, -0.07196842f, -0.01775469f, 0.07386907f, -0.03915463f, 
    -0.06273085f, -0.00573330f, -0.11081936f, 0.02368222f, -0.11128177f, -0.14263748f, 0.00323475f, -0.12299394f, 
    0.03839697f, 0.17941500f, 0.12864015f, 0.02805774f, 0.00804526f, -0.03487593f, -0.09924941f, 0.15125786f, 
    0.10950986f, -0.11047784f, -0.05687420f, 0.14023107f, 0.07434066f, 0.05014768f, 0.18461080f, 0.12972699f, 
    -0.01769263f, 0.07016411f, 0.05123971f, -0.08293794f, -0.00556331f, -0.04662813f, 0.08594909f, 0.04443381f, 
    -0.00893506f, -0.05637581f, -0.01891850f, 0.09441590f, 0.00906638f, -0.11000825f, -0.13486622f, -0.02362184f, 
    -0.19858705f, 0.29832500f, 0.25742900f, 0.07416645f, 0.01819170f, 0.01306278f, 0.00148231f, 0.09506793f, 
    0.08177629f, -0.14354530f, -0.01434892f, 0.01389931f, 0.14494860f, 0.09057590f, -0.01883306f, 0.06422207f, 
    0.06635646f, -0.01632353f, -0.23081245f, -0.21853037f, -0.12082435f, 0.03657659f, -0.02626072f, -0.04290083f, 
    -0.20915738f, -0.04772056f, -0.15773860f, 0.06678902f, -0.36444104f, -0.04594745f, -0.02330184f, -0.06527918f, 
    -0.11322858f, -0.09572716f, 0.06076118f, 0.04258035f, -0.11836959f, -0.04557132f, -0.12881829f, -0.03564300f, 
    0.00951068f, -0.19987816f, 0.00477566f, -0.07477783f, 0.04086644f, -0.01498458f, 0.05791408f, -0.10096590f, 
    -0.07137532f, -0.01206184f, -0.02804794f, -0.13913517f, -0.00858987f, 0.10746155f, -0.01135023f, 0.05525295f, 
    0.12462604f, -0.08873880f, 0.04992728f, -0.07146121f, -0.07265414f, -0.02981888f, -0.10603709f, 0.23697801f, 
    0.02417814f, -0.03823940f, -0.12092055f, -0.07495966f, -0.05822198f, 0.05342154f, 0.13646114f, 0.09407416f, 
    0.09775745f, 0.00362427f, -0.00533372f, -0.02112170f, 0.08537669f, 0.08439823f, 0.12639299f, -0.07016189f, 
    -0.03187587f, 0.07729124f, -0.34046966f, -0.05110128f, 0.10319516f, 0.19807225f, 0.05341946f, -0.04387598f, 
    -0.09421396f, -0.00657102f, 0.15709163f, 0.05356725f, -0.09758046f, -0.16992860f, 0.05128145f, 0.03969469f, 
    0.12416268f, 0.16375311f, 0.07333767f, -0.14768375f, 0.02200228f, 0.07319890f, 0.10266585f, 0.04823527f, 
    -0.09838422f, 0.09728344f, -0.02316208f, -0.19704980f, 0.11461817f, -0.06980608f, -0.00397393f, -0.10275705f, 
    0.11779666f, -0.11717080f, 0.04379672f, -0.05026723f, 0.15638636f, 0.06121749f, 0.00556403f, -0.10230314f, 
    0.02846893f, 0.06569406f, -0.09622797f, -0.00693681f, 0.06750093f, 0.01562771f, 0.13550703f, -0.17480625f, 
    0.05069274f, -0.05465086f, -0.05207599f, -0.08740655f, -0.07463369f, 0.04905652f, 0.01343005f, -0.00075023f, 
    0.19409360f, 0.12191723f, -0.06888159f, -0.02027871f, -0.03005606f, 0.05260124f, 0.07134395f, -0.08638155f, 
    0.07136303f, -0.19111980f, 0.17638251f, -0.18863827f, 0.09113435f, -0.06268451f, 0.04255711f, 0.05430184f, 
    0.09829893f, -0.05762250f, -0.03485888f, -0.23444287f, 0.17905182f, 0.09561371f, 0.03401786f, -0.03029347f, 
    -0.08790591f, -0.06897962f, -0.05529100f, 0.05308979f, 0.16934121f, 0.08654402f, -0.05456404f, 0.04319705f, 
    -0.10090147f, 0.02487970f, 0.00191205f, 0.11947624f, 0.11613318f, 0.01513267f, -0.07338343f, 0.01672130f, 
    0.06514435f, 0.14937954f, 0.01591567f, 0.07231939f, 0.13454728f, 0.06598702f, 0.12634340f, 0.07654642f, 
    0.05869721f, -0.13602702f, -0.01623567f, -0.06027555f, -0.00441608f, 0.02321767f, 0.03300847f, -0.05425214f, 
    -0.00549376f, 0.08734792f, 0.04007040f, 0.09971215f, -0.00729724f, 0.03825570f, 0.12834337f, -0.28069618f, 
    -0.07709578f, -0.13065958f, 0.02241111f, -0.01017796f, 0.07622132f, -0.05018209f, -0.11886609f, 0.13857137f, 
    0.06071373f, -0.08612927f, 0.17329173f, 0.08640237f, 0.08233283f, -0.06872930f, -0.05866211f, -0.03817700f, 
    -0.28142142f, 0.01054962f, -0.06041806f, 0.14087442f, 0.01864161f, 0.05770245f, -0.07023606f, 0.00795965f, 
    -0.16900723f, -0.16634946f, -0.20186250f, -0.10300428f, 0.02079206f, 0.18015486f, 0.03242078f, -0.16183956f, 
    -0.05533674f, 0.06494200f, 0.03545012f, -0.26112115f, 0.05005677f, -0.08471576f, 0.04085018f, -0.05963431f, 
    0.05987448f, -0.08838599f, 0.00911386f, -0.15251234f, 0.07072990f, -0.09997912f, 0.20064548f, 0.06212189f, 
    -0.01867189f, 0.14784266f, -0.02696639f, -0.00365466f, 0.26329443f, -0.32585415f, -0.08156924f, 0.00682452f, 
    -0.04333414f, -0.09788052f, -0.00026043f, 0.01590689f, -0.20445259f, -0.18522014f, 0.02371562f, 0.30444589f, 
    -0.07946286f, -0.02476364f, -0.02219633f, 0.11521986f, 0.01621753f, 0.10002032f, 0.01084387f, 0.13531652f, 
    0.13658762f, 0.14033106f, -0.04651185f, -0.00606309f, 0.01824715f, 0.05430311f, -0.16705878f, 0.03161647f, 
    -0.15515240f, -0.16311270f, 0.09965939f, 0.01253963f, 0.01673783f, -0.04837460f, 0.09272546f, -0.05187039f, 
    0.32766202f, -0.10490117f, -0.04502308f, 0.05570640f, -0.12124267f, 0.00621696f, -0.01535313f, -0.01427062f, 
    0.02735654f, 0.04745525f, -0.16624992f, -0.04145003f, 0.03104778f, -0.05314839f, -0.00468440f, 0.05432302f, 
    0.00813159f, 0.09280372f, 0.03222091f, 0.14162841f, 0.10385799f, -0.12044304f, -0.06122735f, -0.04919135f, 
    -0.04487380f, 0.07836712f, 0.13779515f, 0.18371752f, 0.11872458f, 0.01107542f, -0.09851174f, -0.09425311f, 
    -0.03431770f, 0.02557735f, 0.07032454f, -0.03666103f, -0.10904194f, 0.17673391f, 0.02008706f, -0.02743222f, 
    0.05729336f, -0.02127246f, 0.04340203f, 0.03589702f, 0.14208879f, -0.01044107f, 0.13557884f, -0.06921136f, 
    0.11869525f, -0.00762381f, 0.04476932f, 0.05024011f, -0.17772850f, -0.09682854f, 0.05167017f, 0.00278478f, 
    -0.04815477f, -0.01760508f, 0.03982825f, 0.03914539f, -0.01527911f, 0.09586527f, -0.03154426f, -0.28872353f, 
    0.06829049f, -0.09474061f, 0.07992791f, -0.08309399f, 0.13270569f, -0.09773322f, -0.14138651f, 0.12003461f, 
    0.00439899f, -0.10169156f, -0.02770587f, 0.04652802f, 0.08271824f, -0.06666768f, -0.07802492f, -0.01245500f, 
    -0.05044524f, 0.32745835f, -0.06744759f, -0.01254436f, -0.06049854f, -0.05173020f, 0.03746723f, 0.03931896f, 
    0.11357518f, 0.01634942f, 0.21741906f, 0.13386659f, -0.03425853f, -0.08615001f, 0.17885922f, 0.00707680f, 
    0.02166727f, -0.04893927f, -0.17273673f, -0.07582851f, -0.10590497f, -0.11194536f, 0.19787239f, -0.00792823f, 
    0.05896104f, 0.08381557f, -0.05246473f, 0.14959097f, 0.21817110f, -0.04004241f, 0.08605745f, -0.16810483f, 
    -0.00811995f, 0.09090924f, -0.05395587f, -0.01979683f, 0.04018967f, 0.03200736f, -0.01984107f, -0.10904776f, 
    -0.04984548f, 0.06008007f, 0.02062614f, -0.06390709f, -0.04246665f, -0.07435612f, -0.18862985f, -0.24072534f, 
    -0.18589555f, 0.09166328f, 0.05989884f, -0.09144731f, -0.05482331f, -0.01179653f, 0.05890313f, -0.06621984f, 
    0.01264378f, 0.08694808f, -0.02597754f, -0.01709695f, 0.14954489f, 0.03033733f, -0.06502619f, -0.13928922f, 
    0.12824306f, -0.19290094f, -0.17033905f, 0.00595754f, 0.06267086f, -0.00393705f, -0.02484864f, 0.03135043f, 
    -0.04259089f, -0.06194888f, 0.04357880f, 0.23871934f, -0.14149843f, 0.02288407f, -0.09243988f, 0.15217350f, 
    0.00404313f, -0.10621448f, -0.13227817f, -0.02829220f, 0.06198003f, -0.02134579f, 0.00616168f, 0.03090399f, 
    -0.01457655f, -0.10596741f, -0.01661786f, 0.03215301f, 0.15042341f, 0.09496819f, -0.03463673f, 0.08946376f, 
    -0.06187654f, 0.09050081f, -0.03772082f, -0.08616099f, 0.03745672f, -0.13917714f, 0.03625111f, 0.13793905f, 
    0.24633524f, 0.01917743f, -0.10452269f, -0.10103153f, -0.07712980f, -0.17325331f, -0.09875777f, -0.06074426f, 
    -0.11052984f, 0.05012135f, -0.05754585f, 0.13963994f, 0.04586075f, 0.09219596f, 0.27101579f, -0.04346392f, 
    -0.06847072f, 0.00952426f, -0.03124559f, 0.01583069f, -0.02586219f, -0.08495327f, 0.04239600f, -0.05351086f, 
    0.06986486f, 0.15843560f, -0.13200621f, -0.07194587f, -0.01133715f, -0.04700568f, 0.00344343f, 0.02511545f, 
    -0.16809225f, -0.02294517f, 0.18083771f, -0.12935054f, -0.16114111f, -0.18412945f, 0.04432878f, -0.00800680f, 
    -0.03273942f, 0.08296825f, 0.05256274f, -0.03102356f, -0.06654797f, 0.04402263f, 0.01219574f, -0.02395717f, 
    0.03581967f, 0.15220034f, -0.22502945f, 0.06368195f, -0.14295484f, 0.03007662f, 0.11937039f, -0.01828652f, 
    -0.04643793f, -0.08876064f, 0.02021658f, -0.04009031f, -0.22141090f, 0.06558353f, 0.06625822f, -0.10660624f, 
    -0.07806320f, 0.03315657f, -0.04794400f, 0.01216630f, 0.19222605f, -0.03072247f, 0.03630081f, 0.01827793f, 
    -0.06296676f, -0.05011611f, 0.01953663f, -0.01523990f, 0.16449849f, 0.07696239f, 0.02652602f, -0.09177472f, 
    -0.03983279f, 0.06655806f, 0.07999709f, -0.14708003f, -0.14150123f, 0.10927337f, -0.02278488f, -0.00265485f, 
    -0.04202228f, 0.00841061f, -0.01701004f, 0.11901993f, -0.05418711f, -0.13006179f, 0.05592621f, -0.10769220f, 
    0.03329607f, 0.19097389f, 0.00451056f, -0.20303145f, -0.04240513f, 0.17379248f, 0.02050885f, 0.09144438f, 
    -0.00239756f, 0.02909523f, 0.02194655f, -0.04784438f, 0.00504235f, -0.03473444f, 0.05261450f, -0.05747253f, 
    -0.02449195f, -0.04330225f, 0.01845017f, 0.00178907f, 0.01766563f, -0.04532874f, -0.02955143f, -0.00382596f, 
    0.02266803f, -0.02755486f, -0.04703860f, -0.03032997f, -0.02106182f, 0.03060289f, 0.01341153f, 0.00253951f, 
    0.04717500f, 0.00440573f, 0.00300876f, -0.02990193f, 0.02242516f, 0.01177596f, 0.02452109f, 0.00834896f, 
    -0.04554787f, -0.05209897f, -0.02194160f, -0.04318719f, 0.00136548f, -0.06752318f, -0.02075935f, 0.00062984f, 
    0.03697683f, -0.05654432f, -0.05152849f, -0.02489785f, 0.04880548f, 0.04613309f, 0.03539484f, -0.03154202f, 
    -0.02351143f, -0.05705610f, 0.04206938f, -0.04376400f, -0.05296933f, 0.03310551f, 0.01103465f, 0.02226537f, 
    -0.00586211f, -0.05789115f, 0.00410387f, -0.04293838f, 0.03606329f, 0.01869150f, -0.03180500f, -0.02862705f, 
    -0.05564335f, -0.06010880f, -0.02881308f, -0.02597769f, -0.02483209f, 0.00822546f, -0.05513975f, -0.05993871f, 
    0.05225531f, 0.03654383f, -0.05785728f, -0.00014425f, 0.00551025f, 0.00390873f, -0.00448901f, -0.00242503f, 
    -0.02694732f, 0.03542152f, 0.01486001f, 0.02557928f, -0.03677828f, -0.04597782f, -0.04493359f, 0.02127625f, 
    0.03599069f, 0.00681397f, -0.01548512f, -0.00765910f, -0.03292781f, -0.01132619f, -0.01841145f, -0.02016235f, 
    -0.03809219f, -0.06357826f, -0.01807821f, 0.05046339f, -0.03386151f, 0.01109772f, -0.00797506f, 0.00781399f, 
    -0.06537201f, -0.03809441f, 0.00983286f, 0.00893151f, 0.02126235f, -0.05291397f, -0.04425000f, -0.04172426f, 
    -0.00114584f, 0.00109215f, -0.04293257f, 0.03731328f, -0.03829646f, 0.00616921f, -0.05658019f, -0.02345402f, 
    0.00454752f, 0.02341282f, -0.00861357f, 0.02094190f, -0.00764349f, 0.02705105f, 0.03289535f, -0.00305994f, 
    0.05113957f, 0.03910473f, 0.03053266f, -0.02825372f, 0.02861908f, 0.00126028f, 0.01770882f, 0.01901056f, 
    0.01805285f, -0.05146843f, -0.06142008f, 0.01295049f, -0.05671508f, -0.03012570f, 0.02882145f, -0.05819874f, 
    -0.02742127f, 0.04435415f, 0.01458855f, 0.04447869f, 0.03008466f, -0.04754131f, -0.04828556f, 0.00414980f, 
    0.04018413f, 0.04866807f, -0.04727465f, 0.02605675f, 0.01518631f, -0.02443920f, -0.03376465f, 0.02941394f, 
    0.00186875f, 0.04754891f, -0.05605012f, -0.04187993f, 0.01001960f, -0.00747288f, -0.01528129f, -0.01550223f, 
    0.01041455f, -0.04819106f, 0.00124049f, -0.04525989f, -0.06896445f, 0.02779813f, -0.04954798f, 0.04261288f, 
    -0.05066182f, 0.02451025f, -0.04964909f, -0.01405787f, -0.06050762f, -0.04486169f, 0.02458108f, 0.01007237f, 
    -0.05086153f, 0.03984244f, 0.04146655f, 0.00991917f, 0.01366309f, -0.05960931f, -0.03923472f, 0.05167172f, 
    0.04144279f, 0.01093925f, 0.01974292f, 0.04168211f, 0.05065531f, 0.01982430f, -0.03485738f, 0.04022541f, 
    -0.05380541f, 0.02905011f, 0.02234709f, -0.04713590f, -0.00930607f, -0.02843904f, -0.05921459f, 0.03658013f, 
    0.04585609f, -0.02181398f, 0.00502689f, 0.00331708f, 0.03134961f, -0.04869001f, -0.02837297f, 0.02480904f, 
    0.03786779f, -0.06360457f, 0.02291638f, -0.04006546f, 0.04105960f, 0.01365081f, -0.01155378f, 0.02909212f, 
    -0.05259121f, -0.02736934f, -0.02566311f, -0.02574589f, 0.02123379f, -0.04252786f, 0.02509984f, -0.02481472f, 
    -0.02809359f, -0.00381415f, -0.01463427f, 0.03956652f, -0.03009606f, 0.00158032f, -0.03674440f, -0.02788595f, 
    0.02667986f, -0.02056327f, 0.00070250f, -0.03635902f, -0.05286248f, -0.05082690f, 0.04482846f, -0.00234436f, 
    -0.03078343f, -0.01276726f, -0.04093131f, -0.04519503f, -0.06122390f, 0.00868616f, 0.01431709f, 0.00322806f, 
    -0.04446530f, 0.02665031f, -0.01500018f, 0.01676777f, -0.01993766f, 0.03650197f, -0.01526215f, -0.05964974f, 
    0.00573142f, 0.04278066f, -0.03779067f, 0.01728216f, -0.05544714f, -0.04294686f, 0.02283157f, -0.02043039f, 
    0.01132211f, -0.01366697f, -0.00583081f, 0.04157251f, -0.06229769f, 0.04557803f, 0.03172450f, 0.02447868f, 
    -0.00950754f, -0.03554169f, -0.01555709f, -0.04126367f, -0.05394533f, -0.01092205f, -0.03861861f, -0.04937902f, 
    0.18305667f, 0.21663630f, 0.03958660f, 0.02352240f, -0.07869839f, -0.05509119f, -0.00534352f, 0.10891134f, 
    0.01996106f, 0.09638543f, -0.01733056f, 0.11808123f, 0.18205598f, -0.02971405f, -0.05916586f, -0.06856702f, 
    -0.07393777f, 0.09574188f, 0.09660353f, -0.15521610f, -0.01734679f, 0.10450583f, -0.14573446f, -0.06231312f, 
    0.08248730f, 0.06476571f, -0.09096534f, 0.02773236f, -0.15544251f, -0.04979837f, -0.00444928f, -0.07002477f, 
    -0.04247352f, 0.06542075f, -0.10415494f, 0.05093737f, 0.11127882f, -0.01656750f, -0.09855482f, -0.04581404f, 
    0.00628878f, 0.03420373f, -0.08315016f, -0.03624571f, -0.04263185f, 0.26318353f, 0.05010443f, 0.05179254f, 
    0.03174990f, 0.01829626f, -0.19879541f, -0.13587306f, -0.01806051f, -0.00384474f, -0.10405790f, -0.02721007f, 
    0.02210237f, -0.17817257f, 0.08985261f, 0.01303187f, -0.03414126f, -0.15574826f, 0.03654318f, 0.10389196f, 
    -0.00441309f, -0.06694525f, -0.00677986f, 0.11076151f, 0.01289394f, -0.05146541f, -0.04998437f, -0.04404860f, 
    0.01378501f, -0.09808065f, -0.16285709f, -0.06082762f, 0.01957830f, -0.05079203f, 0.05729005f, 0.07137655f, 
    0.02288781f, -0.12795815f, 0.19439052f, 0.04125110f, 0.10433994f, 0.04025968f, 0.00651279f, 0.03031192f, 
    0.09693681f, 0.04742442f, 0.26170886f, 0.00119144f, 0.01478330f, -0.13768154f, 0.08758701f, -0.07691038f, 
    -0.06807109f, -0.08766565f, -0.08684314f, -0.03527490f, -0.14961590f, -0.04965185f, 0.10211393f, -0.03715699f, 
    0.04148116f, 0.05514229f, 0.22085588f, 0.03654516f, -0.04999734f, -0.16620393f, -0.10646880f, 0.04936080f, 
    -0.08791614f, -0.02125204f, 0.01148403f, 0.02604273f, -0.14185657f, -0.11579305f, 0.06519634f, 0.03649330f, 
    0.10040724f, -0.09763402f, 0.06518351f, -0.07377075f, -0.05997175f, -0.01188517f, 0.09642105f, 0.00025644f, 
    0.08989362f, 0.05493185f, -0.15310031f, 0.06273140f, 0.02333451f, 0.09361113f, -0.00182037f, 0.07340748f, 
    0.01743993f, 0.03958058f, -0.15904267f, -0.08232091f, -0.07347372f, -0.06519834f, 0.06584305f, -0.25073537f, 
    0.03978604f, 0.13624083f, 0.05506506f, -0.09081852f, 0.02482958f, 0.00226873f, -0.06910046f, -0.05843596f, 
    0.04147400f, 0.05192607f, 0.17310001f, 0.11795000f, 0.03472511f, -0.02665130f, 0.08766510f, 0.05297465f, 
    0.13498993f, 0.11578817f, -0.13840809f, -0.20804818f, -0.00942723f, -0.21392088f, 0.01128458f, -0.00746671f, 
    0.08549212f, -0.01203012f, -0.02100776f, 0.21970311f, -0.22932805f, -0.02527956f, -0.08358555f, -0.07643220f, 
    -0.02235350f, -0.10965607f, -0.02843640f, -0.09225889f, 0.07274757f, -0.28367937f, -0.17618613f, -0.03081555f, 
    -0.10423750f, -0.03253570f, -0.16253662f, 0.02761803f, -0.06868615f, 0.26645285f, 0.13370354f, 0.10192933f, 
    0.10680436f, -0.09517093f, -0.09825312f, 0.04517097f, -0.00104702f, 0.07724176f, 0.20443648f, 0.08510821f, 
    -0.00186250f, 0.08052957f, -0.04432930f, -0.06851829f, -0.06267358f, 0.03835145f, 0.04333352f, 0.07222680f, 
    0.04108253f, -0.03701115f, -0.00384315f, 0.00083636f, 0.08467565f, 0.08055704f, 0.02223727f, 0.17102894f, 
    0.11178916f, 0.15928227f, 0.06220583f, 0.09938169f, -0.06624895f, 0.07018023f, 0.07128491f, 0.07356684f, 
    -0.07769611f, -0.01707098f, -0.14621751f, 0.05984545f, 0.07003832f, -0.06952205f, -0.03051728f, 0.08956573f, 
    0.02743180f, -0.03326202f, 0.27094668f, 0.00502201f, -0.04995713f, -0.01071569f, -0.08779401f, 0.12424778f, 
    -0.05548915f, 0.06594495f, -0.07624298f, 0.04385146f, 0.14711231f, 0.17209683f, -0.01958033f, 0.09230108f, 
    0.07572863f, -0.03599461f, 0.09560291f, -0.02302024f, -0.08831074f, 0.11645278f, 0.07467132f, 0.11175287f, 
    -0.13794065f, 0.06515245f, 0.05676019f, -0.05518105f, -0.20945980f, 0.17003535f, 0.14452475f, 0.13896576f, 
    0.12256581f, 0.01133840f, 0.02168947f, 0.01105793f, 0.02617588f, -0.10628577f, 0.04370550f, -0.03678071f, 
    0.04594805f, -0.08986859f, 0.03093950f, 0.03295186f, -0.12849802f, 0.13034019f, 0.03199955f, -0.10452361f, 
    0.23089685f, 0.18570675f, 0.09857113f, -0.03170263f, 0.14080945f, -0.05848546f, 0.07581265f, -0.14331932f, 
    0.00873557f, 0.05094646f, 0.16950221f, -0.06474387f, 0.03976185f, 0.04722662f, 0.15487291f, -0.08382870f, 
    0.04029789f, 0.02849144f, -0.08701257f, 0.15741061f, -0.01544358f, 0.04929429f, -0.12463135f, 0.03548856f, 
    0.00233637f, -0.00829736f, 0.08075199f, -0.24014382f, 0.24572617f, -0.05521835f, 0.15535295f, -0.09011789f, 
    0.08946633f, 0.07956700f, -0.12360995f, -0.01908618f, -0.14640418f, -0.10239989f, -0.09508040f, 0.03001416f, 
    0.07091159f, 0.01553027f, 0.04176917f, 0.02705035f, 0.01008160f, -0.02953726f, 0.12655886f, -0.06321358f, 
    -0.02560942f, 0.02558110f, -0.00882924f, -0.00823512f, 0.09933538f, 0.08183289f, -0.07415033f, 0.21905944f, 
    -0.09150293f, 0.07651572f, -0.14488909f, 0.02334526f, -0.03981812f, 0.02372669f, -0.03024651f, -0.06392126f, 
    0.09869110f, -0.01413028f, 0.07096927f, 0.02528151f, -0.11358288f, -0.08931219f, -0.07447989f, 0.18701075f, 
    -0.15070553f, -0.04790162f, -0.00756686f, -0.03936601f, -0.02554239f, -0.11245365f, 0.02682303f, -0.09120613f, 
    0.04232554f, -0.06572412f, -0.23019460f, -0.01765135f, -0.10454491f, 0.09291509f, -0.02672232f, 0.05609312f, 
    -0.11829834f, 0.23259388f, 0.19160971f, 0.12560649f, 0.04029728f, 0.01381123f, -0.03057890f, -0.11323539f, 
    0.06102316f, -0.01225315f, 0.16084550f, 0.01829409f, -0.15404747f, -0.05137398f, 0.08339997f, -0.01393829f, 
    0.05880800f, -0.08511630f, 0.02685912f, 0.01498589f, 0.01579560f, 0.08205217f, -0.00850086f, -0.00028267f, 
    0.07243585f, 0.09041748f, -0.00461663f, 0.01051210f, -0.08347038f, 0.03900148f, -0.02093791f, -0.11324340f, 
    0.06259615f, 0.21441455f, -0.06957363f, 0.11944344f, -0.06957223f, 0.02257560f, -0.04730073f, -0.01451829f, 
    -0.11509708f, 0.06014524f, -0.03295821f, -0.18446164f, 0.03606624f, -0.04984231f, -0.02031509f, -0.16040081f, 
    0.06020319f, -0.04277509f, -0.02019140f, -0.09786402f, -0.02799513f, 0.13457941f, 0.07035144f, -0.16284311f, 
    0.05648660f, -0.09636556f, -0.03457392f, -0.10201432f, -0.00667507f, -0.01456262f, -0.03825526f, 0.08175940f, 
    -0.28278241f, 0.08549082f, 0.05538327f, 0.14754044f, -0.11330483f, -0.07897714f, 0.08417786f, -0.02726030f, 
    -0.05538513f, 0.18904625f, -0.03752767f, 0.31728300f, 0.01838506f, 0.00210000f, 0.08302315f, -0.08902095f, 
    0.12772545f, 0.03452875f, -0.16169143f, -0.05259898f, 0.01952522f, -0.01244363f, -0.03191015f, 0.11231101f, 
    -0.06432755f, -0.10577010f, -0.06975663f, -0.13639535f, 0.00217353f, -0.19846493f, -0.03048344f, 0.01513310f, 
    0.03768528f, -0.07259555f, 0.06240155f, 0.10204370f, -0.18939081f, 0.12437204f, -0.19087732f, 0.00892223f, 
    -0.14668860f, 0.09116206f, -0.03667138f, -0.07154145f, 0.00335481f, 0.09476781f, -0.03115391f, 0.02770868f, 
    -0.01891025f, -0.02851427f, -0.00881213f, -0.12038492f, -0.05822127f, -0.04343974f, 0.00240520f, 0.09782308f, 
    -0.14286168f, 0.02357982f, -0.08609378f, 0.06269511f, 0.02033949f, 0.00499028f, 0.08440939f, 0.06745101f, 
    -0.10585910f, 0.20758888f, 0.01697124f, -0.02542106f, 0.10023886f, -0.02394407f, 0.06822188f, -0.01778504f, 
    -0.00286741f, 0.00757122f, 0.20141868f, 0.01040545f, -0.18070163f, 0.00911256f, -0.04325365f, 0.05630272f, 
    0.05565425f, -0.04842244f, -0.15477194f, 0.07745918f, -0.06917857f, -0.14319654f, -0.06048606f, 0.01929815f, 
    0.01205190f, 0.05832453f, 0.12395142f, 0.06171985f, 0.24366023f, -0.11987954f, 0.05269289f, 0.10744699f, 
    0.00219160f, 0.21690707f, -0.06532504f, -0.03815559f, -0.05066606f, 0.20335327f, -0.05099842f, 0.04377864f, 
    0.00655018f, 0.01078542f, -0.01786251f, 0.11722921f, 0.13084491f, 0.05989052f, -0.06043700f, -0.06309961f, 
    0.00999889f, -0.03137921f, 0.03193922f, 0.04903335f, -0.02008574f, -0.24854350f, 0.07680692f, 0.07021517f, 
    0.15662308f, -0.01668142f, -0.11253026f, 0.04909546f, 0.05827864f, 0.09084554f, -0.14488143f, -0.09651355f, 
    0.07413258f, -0.02244723f, 0.10280135f, 0.09457065f, -0.05247544f, 0.01892911f, 0.15736274f, -0.00293112f, 
    0.04907867f, 0.22881179f, -0.02296570f, 0.08274494f, -0.03186800f, -0.05934728f, 0.16869964f, -0.04865047f, 
    -0.23630427f, 0.05875458f, -0.27654475f, 0.04265589f, 0.00287817f, 0.07280079f, -0.13339375f, -0.12398275f, 
    0.07745393f, 0.09630723f, 0.05399000f, -0.06833270f, 0.10192142f, -0.12868822f, 0.00238589f, 0.13521007f, 
    0.05807060f, 0.10883115f, 0.14116134f, -0.03259853f, -0.15103205f, -0.04919127f, -0.00169717f, -0.06067435f, 
    0.06833111f, -0.06572711f, -0.04068169f, 0.08889320f, -0.09590339f, 0.12310001f, 0.10587316f, -0.17112203f, 
    0.03006277f, 0.10047241f, -0.05592124f, -0.10277735f, -0.12218571f, 0.08215928f, -0.06539413f, -0.02387648f, 
    0.05128304f, 0.05456975f, 0.03630820f, -0.06206334f, -0.02168420f, -0.29143313f, -0.12006269f, -0.18881482f, 
    -0.08817524f, 0.16807234f, -0.03339428f, -0.02969744f, -0.04028394f, -0.12331368f, 0.01482823f, 0.03040684f, 
    -0.12377170f, -0.06714500f, 0.00602784f, -0.02849075f, 0.08185492f, 0.06435008f, -0.12855333f, -0.23991928f, 
    -0.09552008f, 0.06510947f, 0.04771915f, 0.01379429f, -0.06437914f, 0.26588300f, -0.07114900f, 0.02572793f, 
    0.07384688f, 0.17011385f, -0.03329423f, -0.00547880f, 0.03112391f, 0.10101046f, 0.07152821f, 0.10645434f, 
    0.04016483f, 0.01142892f, 0.11817810f, 0.05762216f, 0.04301747f, 0.07370103f, -0.11077926f, 0.06889866f, 
    0.04597180f, 0.04774687f, -0.30804056f, -0.21788497f, -0.11376339f, 0.01548899f, 0.11280114f, 0.03534602f, 
    0.00693962f, 0.10454024f, 0.17004305f, 0.16665198f, 0.09110688f, -0.02370086f, -0.03057245f, 0.00184889f, 
    -0.02071243f, 0.09207424f, 0.20344257f, 0.02275461f, -0.08023139f, 0.17166148f, -0.02633919f, 0.07441721f, 
    -0.10191406f, -0.12450397f, 0.07255074f, -0.06451992f, -0.06628960f, -0.34503052f, -0.41284016f, 0.27778587f, 
    0.17539714f, -0.14248067f, 0.02047837f, 0.14928254f, 0.10996863f, 0.18147758f, -0.04162392f, -0.15525770f, 
    -0.41826943f, 0.04852831f, -0.02443345f, 0.16265005f, -0.05721289f, 0.02053915f, 0.03857376f, -0.01938297f, 
    0.00482251f, -0.08505794f, 0.11830856f, -0.08531684f, -0.04207277f, -0.06538022f, -0.06789140f, 0.06699894f, 
    -0.09360025f, -0.12343079f, -0.36159006f, 0.10621407f, 0.05547825f, 0.12541628f, -0.01250721f, -0.17601714f, 
    -0.02755799f, 0.11216020f, 0.11376581f, -0.18896231f, -0.14221761f, 0.06356440f, 0.01101400f, 0.08198293f, 
    0.10972264f, -0.01128992f, 0.14022350f, -0.07488886f, 0.00791242f, -0.14340949f, 0.05512905f, -0.00672538f, 
    0.09808656f, 0.03035261f, -0.01150951f, -0.18460684f, -0.37154767f, -0.05165974f, 0.01155339f, 0.04391269f, 
    -0.12542450f, -0.10934089f, 0.06183984f, 0.14338133f, -0.02903047f, -0.00097001f, -0.02479218f, -0.00987438f, 
    0.02570688f, 0.00908153f, 0.08335237f, 0.09081368f, -0.00047637f, -0.09364884f, -0.06443084f, -0.10051481f, 
    0.01861309f, 0.04078077f, 0.09332289f, 0.07168280f, 0.05255761f, 0.04711433f, -0.15975751f, 0.10447717f, 
    0.13523978f, 0.00880141f, 0.09889199f, -0.07084576f, -0.10572850f, 0.03467647f, 0.00893215f, 0.17812905f, 
    0.15263179f, -0.06874561f, 0.13532609f, 0.06843568f, 0.01775667f, 0.08795255f, 0.12377798f, -0.05167266f, 
    0.24265359f, 0.10593021f, 0.03235419f, -0.02183805f, 0.01471284f, 0.01763182f, 0.07637868f, -0.01385098f, 
    -0.00364139f, 0.10579818f, -0.07641879f, -0.16453844f, 0.00332990f, -0.08321721f, 0.07041828f, -0.04013190f, 
    -0.07626795f, 0.00938912f, -0.03850025f, -0.11430170f, -0.19622293f, 0.04913531f, 0.11303846f, 0.17917441f, 
    0.06667845f, -0.06638282f, -0.06742282f, 0.14681101f, -0.12663463f, -0.08898960f, 0.01648032f, 0.05661472f, 
    0.11036319f, 0.02744360f, -0.03243301f, 0.07106464f, -0.41915312f, 0.12790160f, 0.08055599f, -0.02239343f, 
    0.10065804f, -0.10664754f, -0.06158723f, 0.05672146f, 0.00154673f, -0.15083066f, -0.14049271f, -0.22304288f, 
    -0.08044497f, 0.01987404f, 0.06573601f, 0.18754555f, -0.08539576f, -0.02713428f, 0.20899169f, 0.14076751f, 
    -0.03159237f, -0.14027700f, -0.00460168f, -0.00706012f, 0.07998755f, 0.00187442f, -0.04229043f, 0.01517716f, 
    -0.09388719f, -0.07025306f, 0.03249623f, 0.04741370f, 0.05949465f, 0.18191570f, 0.02120262f, -0.04326944f, 
    -0.13986930f, -0.41037986f, -0.12925208f, -0.11048039f, 0.06251393f, 0.05620094f, -0.05573715f, -0.11438094f, 
    -0.22286163f, 0.11459719f, 0.12139934f, 0.24663949f, 0.05219313f, -0.18166713f, 0.08420062f, -0.01137539f, 
    -0.10245504f, 0.04863837f, 0.04147061f, -0.20250314f, 0.08516268f, -0.01360822f, 0.00329560f, 0.12904668f, 
    0.03934313f, -0.12865415f, 0.05038710f, 0.12220425f, -0.09672143f, -0.28453147f, -0.04387408f, -0.00961777f, 
    -0.06102242f, -0.04763366f, -0.00639239f, -0.05787433f, 0.09709259f, -0.14622633f, -0.19313571f, 0.07098306f, 
    0.00803925f, 0.10774962f, 0.08606160f, -0.02059518f, -0.20256655f, -0.18401237f, -0.09576957f, 0.06881882f, 
    0.02864732f, 0.12778617f, -0.03211270f, -0.10498475f, 0.07579929f, -0.05422274f, -0.17377481f, 0.05201024f, 
    0.18442984f, -0.05322470f, -0.09528276f, -0.10704439f, 0.00063849f, -0.05086840f, 0.00228109f, 0.17029738f, 
    0.12748343f, -0.00285160f, 0.07360947f, -0.07144478f, -0.07442156f, 0.12823686f, 0.06323715f, -0.08241925f, 
    -0.10290787f, 0.11461285f, 0.21326630f, -0.12680094f, 0.13648616f, 0.09561439f, 0.03950003f, 0.06799630f, 
    0.04488288f, 0.01767953f, -0.28032848f, -0.33473438f, 0.06868343f, -0.01696091f, 0.11722047f, -0.12317123f, 
    -0.00898110f, -0.05988959f, -0.06662206f, 0.07760081f, 0.00157043f, -0.07770075f, 0.01123968f, -0.09147121f, 
    -0.04982366f, -0.04465589f, -0.07311806f, -0.18077561f, 0.06914179f, 0.14351490f, -0.02196853f, 0.00168360f, 
    0.13084219f, -0.05075043f, -0.02426845f, -0.03059202f, -0.19828969f, -0.13286237f, -0.05091732f, -0.03386966f, 
    -0.12416833f, -0.10427885f, -0.12202820f, 0.04181262f, -0.05885186f, -0.02342469f, -0.04624195f, 0.14486596f, 
    0.06401905f, -0.03172473f, 0.07877160f, 0.07099234f, 0.03070443f, -0.11032898f, 0.16107836f, 0.07411359f, 
    -0.06014094f, -0.03838487f, 0.12052060f, 0.02538609f, 0.10728186f, 0.10387920f, -0.05266830f, -0.03042031f, 
    0.08238444f, -0.00556044f, -0.03141420f, -0.05615075f, -0.16355793f, -0.12254102f, 0.11334360f, 0.00898821f, 
    0.18217702f, 0.00047837f, 0.00142131f, 0.11687638f, 0.08571560f, -0.00123828f, -0.03005069f, 0.12845440f, 
    0.15419421f, -0.06583947f, -0.31267273f, -0.01264695f, -0.00131589f, 0.11540093f, 0.03494294f, -0.00472247f, 
    0.02850484f, 0.04324673f, -0.21721460f, 0.09969001f, 0.18889600f, 0.05825925f, 0.07246833f, -0.10366722f, 
    0.02351754f, 0.04106848f, 0.06946217f, -0.00299624f, 0.04920574f, 0.23003648f, 0.04162691f, -0.02250283f, 
    -0.35360584f, 0.06065604f, -0.03451355f, 0.10625920f, 0.03379129f, 0.17695186f, 0.37469617f, -0.17290443f, 
    -0.09363085f, -0.25496522f, 0.06021439f, -0.02628743f, 0.05875609f, -0.17375155f, 0.13987619f, 0.19622315f, 
    -0.15839417f, -0.02180205f, 0.02955475f, -0.01229301f, -0.02640964f, -0.04227285f, 0.46141186f, 0.04037403f, 
    -0.11873579f, 0.03677615f, -0.01703962f, 0.13088569f, 0.16800632f, 0.00587276f, -0.04839120f, 0.07547496f, 
    -0.22580539f, -0.16950230f, 0.00960167f, 0.10929834f, 0.01298028f, -0.04992494f, 0.00278395f, -0.07075310f, 
    0.24944957f, 0.11579110f, -0.06438295f, 0.03044228f, -0.02542222f, 0.10446066f, -0.09293232f, -0.03742791f, 
    -0.09925387f, 0.17575842f, 0.04075292f, -0.05212911f, 0.03021372f, 0.09640920f, 0.21531612f, 0.01807046f, 
    -0.10423195f, 0.01721139f, -0.16919537f, -0.13024609f, 0.01929408f, -0.10605100f, 0.00421688f, -0.07966524f, 
    0.08694831f, 0.07577216f, 0.10217790f, 0.07523286f, 0.13230026f, 0.03226298f, 0.05909320f, 0.00009830f, 
    -0.00022527f, 0.01895476f, 0.03674741f, 0.07698934f, 0.10091533f, -0.01878004f, -0.15903705f, -0.04713379f, 
    0.03701974f, -0.03056405f, 0.00331764f, -0.04544182f, -0.10924878f, 0.16334748f, -0.14584243f, -0.12777330f, 
    -0.04128866f, 0.01881148f, -0.05483088f, 0.04135407f, 0.00090531f, -0.01345403f, -0.14458625f, 0.22494750f, 
    0.15600546f, 0.01833413f, 0.03480790f, 0.05895211f, 0.04278017f, 0.03634330f, -0.02367480f, 0.01945983f, 
    -0.06744562f, -0.04251638f, 0.01700358f, -0.07769782f, 0.02631436f, 0.05154838f, 0.03477887f, 0.10933751f, 
    0.20717879f, 0.09656986f, -0.09452594f, 0.04355914f, 0.03281602f, -0.03003010f, -0.02035354f, -0.03966141f, 
    -0.03829430f, 0.17429577f, -0.11749528f, -0.25554329f, 0.13688998f, 0.11983100f, 0.09576660f, -0.01614681f, 
    0.04542750f, 0.05219986f, 0.26422083f, 0.02210347f, -0.12127689f, 0.00480600f, -0.03303667f, 0.06074674f, 
    -0.09658879f, 0.00857229f, -0.05574677f, 0.21434025f, 0.15615933f, -0.09689093f, -0.17090790f, 0.03282192f, 
    0.14760499f, -0.03800809f, 0.08122867f, 0.01675496f, -0.03648675f, -0.01415268f, 0.03454472f, 0.03214955f, 
    0.00111822f, 0.00052692f, 0.01077292f, 0.03034605f, -0.03503472f, -0.12257443f, -0.21094920f, -0.26422334f, 
    0.07833859f, 0.07299493f, 0.02259840f, 0.18408018f, -0.06307729f, -0.14719065f, 0.18047126f, 0.30055296f, 
    -0.00197115f, 0.18286057f, 0.00719997f, -0.02095507f, 0.10036282f, 0.03795953f, -0.00940201f, -0.23248546f, 
    0.15065485f, -0.02167946f, 0.13894618f, -0.09852307f, 0.03236979f, 0.06378596f, -0.08557227f, -0.06214983f, 
    -0.04784672f, 0.03286979f, 0.00580351f, 0.08015320f, -0.11154474f, -0.01202146f, 0.04814362f, 0.03380445f, 
    0.08504896f, 0.33783010f, -0.04402317f, -0.07188033f, -0.15487218f, -0.01135217f, 0.14611372f, -0.17194864f, 
    -0.00295678f, -0.18489487f, 0.13474657f, 0.10621058f, -0.01746674f, -0.00332130f, 0.04659436f, -0.09426424f, 
    0.00900092f, 0.11603815f, 0.01355582f, -0.15196474f, 0.03518878f, 0.04823959f, 0.14992288f, -0.03682074f, 
    0.06159370f, -0.02363575f, -0.05648889f, 0.01160269f, 0.08399527f, -0.06359839f, -0.02550377f, 0.01710447f, 
    0.11353166f, -0.02983277f, 0.01029495f, -0.05314364f, -0.17145926f, 0.20351639f, -0.01499612f, -0.14528286f, 
    0.02886634f, 0.04398051f, 0.07288555f, 0.02505939f, -0.06273235f, 0.01959924f, -0.05983778f, -0.00002028f, 
    -0.04041232f, -0.08458500f, -0.04076980f, 0.11157060f, 0.06396221f, 0.01196177f, -0.03664577f, -0.14276193f, 
    0.11593085f, 0.04709110f, 0.17611943f, 0.14907014f, 0.05545132f, -0.01786747f, 0.00354930f, -0.18802840f, 
    -0.09307130f, 0.08055479f, -0.00704502f, -0.09513221f, 0.07639121f, -0.13291167f, 0.01825716f, 0.10359049f, 
    0.05779763f, 0.04884009f, -0.07566278f, -0.01665805f, -0.23947605f, -0.08373040f, 0.06655686f, -0.05398560f, 
    -0.05271962f, -0.11887198f, -0.13167089f, 0.06611440f, -0.01868973f, 0.09347415f, 0.02359501f, 0.03426975f, 
    -0.04763559f, 0.09803106f, -0.00384843f, -0.06927194f, 0.15680915f, 0.02055900f, 0.02896224f, 0.00560533f, 
    -0.10740174f, 0.09785001f, -0.02312973f, -0.19210179f, 0.05379343f, 0.04611806f, -0.01487232f, 0.08203118f, 
    0.15286477f, -0.05789075f, 0.01508448f, 0.05418375f, -0.04186239f, -0.26894265f, -0.09446796f, -0.16413698f, 
    0.03746385f, 0.03777342f, -0.00548110f, 0.12323991f, -0.00885912f, 0.09836926f, 0.36967555f, 0.10550155f, 
    -0.11852456f, -0.06987101f, 0.00873380f, 0.10178018f, 0.07467085f, -0.12109888f, 0.01440191f, 0.10755182f, 
    -0.03753249f, 0.07802331f, -0.12660338f, -0.01536199f, 0.14517614f, -0.00395657f, -0.02947755f, -0.08364361f, 
    0.02255304f, -0.04041252f, 0.08429206f, -0.06826293f, 0.01910443f, -0.06807200f, -0.00431601f, 0.02892300f, 
    0.09851427f, 0.28008908f, 0.06142974f, -0.14232509f, 0.04149052f, 0.04078940f, 0.01543330f, -0.15077163f, 
    0.05422591f, -0.10018490f, -0.07602668f, 0.03172752f, 0.06407798f, -0.11154946f, 0.00356764f, -0.09478659f, 
    -0.02991231f, 0.08491243f, -0.15204589f, -0.00223710f, -0.12526456f, -0.03106596f, 0.03271624f, 0.03715814f, 
    -0.17061912f, -0.02274809f, -0.03412551f, 0.14601921f, 0.26897401f, 0.03562729f, -0.12962842f, -0.09442995f, 
    0.02047612f, 0.02340852f, 0.03439831f, 0.01455796f, -0.07134014f, 0.28169125f, 0.05021844f, 0.08241898f, 
    0.13261946f, 0.15741602f, 0.02403582f, -0.13775989f, -0.07836246f, -0.01661832f, -0.12540339f, 0.22889782f, 
    0.06586007f, 0.13130139f, -0.00094615f, 0.12703738f, 0.11271610f, -0.01940103f, 0.04231938f, -0.07237105f, 
    -0.02229336f, 0.08146571f, -0.03603042f, -0.20348035f, -0.05164321f, -0.00750763f, 0.05834690f, 0.05265583f, 
    0.31337863f, 0.28659350f, 0.34682769f, -0.16336033f, -0.05269530f, -0.08853214f, 0.14234544f, 0.10531592f, 
    0.08834299f, -0.23813069f, 0.01160000f, 0.14018595f, 0.09114373f, 0.09271856f, -0.13183713f, -0.07847650f, 
    0.01163010f, 0.08201486f, -0.04398631f, -0.31066883f, 0.21959707f, -0.10936122f, -0.08892038f, 0.03941591f, 
    0.02759579f, 0.04972682f, 0.06400026f, -0.03869274f, 0.18197505f, 0.02353773f, -0.01341297f, 0.11610144f, 
    0.08461181f, 0.08262229f, -0.02731074f, 0.07729944f, 0.12430337f, 0.05759164f, 0.01649627f, 0.14793168f, 
    0.09022100f, 0.09931415f, 0.08009700f, 0.01170996f, -0.02054222f, 0.16179956f, -0.11031808f, 0.21768947f, 
    -0.11314771f, -0.07541115f, -0.09590035f, 0.02875402f, 0.04896555f, 0.11990050f, -0.20958772f, 0.18803409f, 
    -0.28911659f, 0.10299117f, -0.18374343f, -0.00604747f, 0.00083577f, 0.07933659f, -0.10432786f, -0.08559929f, 
    -0.19387384f, 0.07558510f, -0.00885960f, 0.10583781f, -0.01572296f, 0.01238713f, 0.11847872f, 0.23533088f, 
    0.12057123f, 0.08349831f, -0.05692794f, 0.05225252f, 0.00588691f, 0.06434812f, -0.02335240f, 0.11450685f, 
    0.06465754f, -0.12805820f, -0.31052461f, 0.02001976f, -0.19259648f, -0.24440740f, 0.09554570f, -0.08245977f, 
    0.14851269f, -0.01547389f, -0.04591552f, -0.09294864f, -0.16751517f, 0.02454907f, 0.04999888f, -0.05653299f, 
    0.10438793f, -0.03892171f, 0.00962484f, 0.01229007f, 0.06890923f, 0.19308957f, 0.02006094f, 0.12019321f, 
    0.05672556f, 0.01056441f, -0.11838447f, 0.09644008f, 0.25737277f, 0.13547802f, -0.42346230f, -0.10652000f, 
    -0.12654398f, 0.05214648f, 0.17790361f, 0.04604509f, 0.00958786f, -0.21369721f, -0.04112902f, -0.15989864f, 
    0.24508069f, 0.03115041f, 0.08108846f, -0.00241424f, -0.06385273f, 0.09380911f, -0.43912092f, -0.13383114f, 
    0.18666813f, 0.02781314f, 0.04105503f, 0.04207271f, -0.00434315f, -0.01869217f, 0.00368914f, 0.19110917f, 
    0.18006097f, -0.01399057f, 0.09637378f, 0.11431116f, -0.13428932f, 0.09926994f, 0.04163303f, -0.02392853f, 
    -0.07775020f, 0.07604468f, -0.07591014f, 0.10452068f, 0.13499829f, -0.02883351f, -0.00387751f, 0.05478739f, 
    -0.01030421f, -0.25184295f, -0.29459170f, 0.15345497f, -0.10380557f, -0.19345517f, -0.05720077f, -0.13692597f, 
    0.04793394f, -0.05139092f, 0.15424107f, 0.13885927f, 0.02085831f, 0.06453093f, 0.10303028f, -0.02773159f, 
    0.04921724f, 0.25472954f, 0.03472278f, -0.03265506f, 0.16217017f, -0.27905646f, 0.13026842f, -0.07384594f, 
    0.06648687f, 0.20446022f, 0.05307295f, 0.06470817f, -0.04508654f, 0.13766655f, -0.23677619f, 0.09441683f, 
    -0.11457338f, 0.04906349f, -0.00433987f, 0.01623892f, 0.00785843f, 0.13323374f, 0.04200783f, 0.09726178f, 
    0.01122251f, -0.01816374f, 0.18052231f, -0.07247216f, 0.15402523f, 0.10226791f, -0.13288319f, -0.09175345f, 
    -0.31816137f, -0.03855892f, -0.18239319f, 0.11104578f, -0.04677069f, -0.12299775f, 0.00977243f, 0.03574888f, 
    -0.07907299f, 0.11887864f, 0.01710804f, 0.07263890f, 0.09822892f, -0.05315235f, 0.09511933f, 0.01805443f, 
    -0.03563188f, 0.02366421f, 0.21804766f, -0.01465307f, 0.02310632f, 0.03836659f, -0.11415941f, 0.03174625f, 
    -0.02495160f, -0.35469422f, -0.07674445f, 0.10404900f, -0.10582262f, -0.07015394f, 0.08007106f, -0.02044557f, 
    0.12480730f, -0.06342911f, -0.05950185f, -0.00601031f, -0.00638357f, 0.13190609f, 0.09654308f, 0.13933174f, 
    0.13341792f, -0.13598476f, 0.20818831f, -0.02256039f, -0.10300594f, -0.00066238f, 0.04163361f, -0.08070752f, 
    -0.01018912f, 0.05598678f, -0.00949324f, -0.03664736f, -0.10598249f, -0.02282330f, 0.16078486f, -0.02959828f, 
    0.03899779f, 0.04376084f, -0.01633250f, -0.19687212f, 0.03822836f, -0.05423519f, 0.26111355f, -0.32843614f, 
    -0.00790922f, 0.04976893f, 0.02594708f, 0.01889997f, 0.04551355f, 0.07500674f, -0.04742916f, 0.04742378f, 
    -0.12741952f, 0.12451183f, -0.06529342f, -0.01134475f, -0.00703734f, -0.11671455f, 0.00388984f, -0.00935392f, 
    -0.22230075f, 0.05350085f, -0.04990256f, -0.16783085f, -0.01279449f, -0.06066504f, -0.06055140f, 0.00424218f, 
    -0.01880127f, -0.05539469f, 0.03718159f, -0.06172858f, 0.00110026f, 0.02343674f, -0.01561026f, -0.05105997f, 
    -0.02207379f, 0.04820564f, 0.05172640f, 0.01254530f, -0.05807261f, -0.04146060f, -0.04177765f, 0.04060142f, 
    -0.01665505f, 0.01930105f, 0.01572721f, 0.01375769f, -0.04341919f, -0.03803202f, -0.04792973f, -0.02146891f, 
    -0.05612437f, -0.02258285f, -0.05150172f, 0.01441113f, -0.01090992f, 0.04472343f, -0.00043265f, 0.03854689f, 
    -0.06194656f, -0.05856535f, -0.00338979f, -0.05009172f, -0.01232912f, 0.03472952f, 0.01345358f, -0.05241708f, 
    0.01783738f, -0.06345671f, -0.00261229f, -0.01548566f, 0.04781668f, -0.03243949f, -0.00673171f, -0.01491193f, 
    -0.02688261f, -0.05651016f, -0.00331450f, 0.00071465f, -0.03565895f, -0.00306593f, 0.01994929f, 0.03082857f, 
    0.00365544f, -0.05320236f, 0.00865082f, -0.03584995f, 0.03066763f, 0.00123526f, -0.04868203f, -0.01085068f, 
    -0.04310854f, -0.01643701f, 0.01235171f, 0.01236734f, 0.04788956f, 0.04958986f, 0.02856957f, -0.05579048f, 
    0.03142648f, -0.03010052f, 0.00677754f, -0.00282950f, 0.01063758f, -0.06374027f, -0.02266069f, 0.01012675f, 
    -0.01761927f, -0.04350513f, 0.01734342f, -0.00315148f, 0.05097219f, 0.00632364f, -0.05900856f, -0.05028557f, 
    0.03729989f, -0.02098291f, 0.01381015f, 0.01329827f, -0.02887474f, 0.03527733f, 0.00567125f, -0.04596494f, 
    -0.05641403f, -0.04892067f, -0.02265926f, -0.00125732f, -0.03098000f, -0.05631438f, -0.03461529f, -0.04958906f, 
    0.00888260f, 0.01278724f, 0.00987388f, 0.02232675f, -0.05826690f, -0.02981115f, -0.04224352f, 0.04212958f, 
    -0.00156846f, -0.00310416f, -0.02100593f, 0.03798091f, -0.05769901f, 0.05178118f, -0.02954834f, -0.06437746f, 
    0.02751756f, -0.01332369f, -0.00350573f, 0.03537269f, 0.04751034f, -0.02098367f, -0.04453614f, 0.04171383f, 
    0.02372982f, 0.02987045f, -0.04549216f, -0.01606091f, -0.05132392f, -0.02901675f, 0.03035706f, -0.05138150f, 
    0.04510262f, 0.01965629f, 0.01913431f, -0.06252651f, -0.01235778f, -0.03983444f, -0.05723746f, -0.02134284f, 
    0.03928206f, -0.06507867f, 0.00008517f, 0.04867152f, -0.04639450f, -0.03963307f, -0.01263780f, 0.01003854f, 
    0.03908852f, -0.03857997f, -0.01118317f, 0.01712412f, -0.04061924f, 0.03935885f, -0.00000921f, 0.00323206f, 
    0.02964603f, -0.04095455f, -0.03100485f, -0.02528170f, -0.02017876f, -0.01674771f, -0.03716662f, -0.03162098f, 
    -0.01944853f, -0.04301873f, -0.00351389f, -0.04788106f, 0.01387230f, 0.01887908f, -0.04076532f, 0.02061209f, 
    -0.00163647f, -0.03304953f, -0.00102099f, 0.04723834f, -0.04004990f, 0.04477084f, 0.04316437f, 0.02905086f, 
    -0.06389603f, 0.00486225f, -0.02751312f, 0.04019217f, -0.00732702f, 0.03152670f, 0.03059889f, 0.01138138f, 
    -0.04143576f, 0.01604226f, -0.03427778f, -0.03279398f, -0.06167080f, -0.05914923f, -0.04108423f, -0.02256958f, 
    0.04720703f, -0.04404694f, -0.05275596f, -0.05788713f, 0.05319840f, -0.04455334f, 0.03702027f, 0.01513082f, 
    0.04689153f, 0.02705594f, -0.00678986f, -0.00940102f, -0.01738353f, -0.01668248f, -0.01861884f, -0.03874497f, 
    0.04836414f, -0.05766848f, 0.03888416f, 0.03165478f, -0.00047133f, -0.04171847f, 0.01181551f, -0.04151880f, 
    -0.03095964f, -0.03431183f, -0.02288494f, 0.01434032f, -0.01212678f, -0.01816470f, -0.02457495f, 0.04062459f, 
    -0.04720263f, -0.05546471f, 0.02593622f, -0.01173344f, 0.04028480f, -0.00493562f, 0.00208690f, 0.00341155f, 
    0.04929353f, -0.05616837f, -0.03173418f, -0.04402093f, 0.03667122f, -0.01679601f, 0.04160906f, -0.04962226f, 
    -0.00256384f, -0.02110362f, 0.03310177f, -0.00212544f, -0.04040034f, -0.05660761f, -0.02440568f, 0.03250238f, 
    -0.04405916f, -0.03153451f, 0.01006909f, 0.02263436f, 0.04048526f, 0.00293774f, -0.06421448f, -0.01092572f, 
    -0.06058277f, -0.06195940f, 0.00489483f, 0.02100110f, 0.00114233f, -0.02886479f, 0.00240668f, -0.04779144f, 
    -0.02500644f, 0.01750894f, -0.03976802f, -0.02004716f, 0.03617997f, -0.03672807f, -0.05671598f, 0.04430047f, 
    0.01008238f, -0.06360427f, 0.02392145f, -0.00152583f, 0.04603589f, -0.03929096f, 0.03053373f, 0.04264298f, 
    -0.14086521f, 0.08557370f, -0.14524326f, 0.10167760f, -0.26966840f, 0.01080504f, -0.18011315f, 0.00933707f, 
    -0.10756708f, -0.30531183f, -0.02038546f, 0.04255292f, 0.00053841f, -0.02083503f, 0.17258298f, 0.09439459f, 
    0.05732235f, 0.00029804f, -0.06763549f, -0.11324096f, -0.04946374f, 0.04161659f, 0.00084082f, -0.01568441f, 
    -0.00490233f, 0.09844517f, 0.04018780f, 0.00314439f, -0.21189049f, -0.10003393f, -0.09530544f, -0.08048220f, 
    0.05549619f, 0.01874053f, 0.03143682f, -0.01111030f, 0.05536555f, 0.07317459f, 0.06048717f, -0.04372134f, 
    -0.03193393f, -0.11071483f, 0.15125236f, 0.05977965f, 0.09814617f, -0.10574213f, -0.02497143f, -0.29338494f, 
    0.17591140f, 0.00469309f, 0.08311275f, -0.13593005f, -0.07399205f, -0.19207317f, 0.23763908f, 0.07799616f, 
    -0.07750596f, 0.09697409f, -0.08132429f, 0.01462734f, -0.07960805f, 0.14895524f, 0.13823625f, -0.08021092f, 
    -0.04744771f, 0.14252576f, 0.06360626f, 0.23127440f, 0.09907517f, -0.00689728f, -0.01517281f, -0.12972103f, 
    0.04133018f, 0.19147778f, 0.15807903f, 0.00798532f, -0.07522448f, 0.01950123f, 0.08113173f, -0.03431365f, 
    0.08943856f, -0.07284986f, -0.14140569f, -0.12865688f, 0.02969550f, -0.09402126f, -0.30108082f, 0.12160144f, 
    -0.15801761f, -0.11767519f, 0.00135277f, 0.04056035f, -0.06879325f, 0.10479006f, -0.01629224f, 0.18570638f, 
    0.04623736f, -0.00214642f, -0.06212649f, 0.07836910f, 0.10168490f, -0.00722161f, -0.10468397f, -0.19316399f, 
    -0.20671482f, -0.00034867f, 0.16148560f, 0.01180278f, 0.05522598f, 0.14301617f, -0.00289714f, 0.06117957f, 
    -0.09075306f, -0.04818857f, 0.01972781f, 0.12501709f, 0.10034131f, -0.07526292f, -0.12581539f, 0.07023069f, 
    0.10230163f, 0.14261748f, 0.01571584f, 0.02103021f, -0.01081444f, 0.02705197f, -0.32684845f, -0.11798248f, 
    0.12876213f, 0.19659282f, 0.05695245f, 0.09583777f, 0.04410429f, -0.00050365f, 0.09733747f, 0.21457613f, 
    0.11556539f, 0.01919988f, 0.04364857f, 0.12885264f, -0.00755242f, 0.04006454f, -0.01558108f, 0.14087223f, 
    -0.03422599f, -0.07142730f, -0.16969939f, 0.13380450f, 0.02743647f, 0.12387244f, 0.12459900f, -0.03451648f, 
    0.07030150f, -0.09148718f, -0.09870757f, -0.26739576f, -0.07976010f, -0.01060110f, -0.09620330f, 0.02544769f, 
    -0.12944932f, -0.18833929f, 0.25531217f, 0.06623488f, 0.05170222f, -0.00421404f, 0.00364136f, 0.03858136f, 
    -0.04197543f, 0.05938918f, 0.09145635f, 0.02729724f, 0.11432792f, -0.10392696f, 0.03363173f, 0.07629737f, 
    0.03748404f, -0.00094349f, 0.04639547f, -0.03557796f, -0.07416785f, 0.00367569f, -0.08991384f, 0.02342615f, 
    -0.01117458f, 0.06473050f, -0.07738095f, 0.10608084f, -0.03227242f, -0.03146145f, 0.01704998f, 0.08275934f, 
    0.09445646f, -0.02013187f, 0.07010207f, 0.07270259f, -0.09633829f, -0.02486656f, -0.15959400f, -0.04021320f, 
    0.09893092f, 0.09451690f, 0.06769276f, -0.14143479f, 0.07138893f, -0.09047823f, 0.03128072f, 0.00336612f, 
    0.00386908f, -0.14195687f, -0.06488074f, -0.10829207f, -0.02325779f, -0.01781037f, -0.01588484f, -0.04391591f, 
    -0.28727731f, -0.01221956f, 0.06968383f, 0.05170022f, -0.02910758f, 0.05849480f, -0.03618733f, 0.10509299f, 
    0.09051041f, -0.25704834f, -0.02026353f, -0.03683722f, -0.05937244f, 0.04220400f, 0.06984027f, -0.00218437f, 
    0.05400362f, 0.09423190f, -0.16640830f, 0.12351226f, -0.09482544f, 0.09366565f, -0.09577115f, 0.07641844f, 
    -0.05620624f, 0.07798290f, -0.01580468f, -0.07030266f, -0.17503606f, -0.05387727f, 0.08988392f, -0.02025965f, 
    0.01552709f, 0.07507440f, -0.12381201f, -0.07411754f, 0.01429651f, -0.07903163f, -0.03784074f, 0.08670020f, 
    0.05546482f, -0.02129340f, -0.02943566f, 0.13351561f, 0.09002902f, -0.15556817f, -0.10405882f, 0.02312893f, 
    0.11095309f, 0.14029139f, -0.01825176f, 0.01712220f, -0.04496943f, 0.03411248f, 0.10866117f, 0.00304417f, 
    -0.06108306f, 0.07295182f, -0.01770721f, -0.14855160f, 0.01835193f, 0.13322864f, 0.09122545f, -0.14276983f, 
    -0.12656032f, -0.17435700f, 0.07873590f, -0.01785770f, -0.08245490f, -0.02045637f, -0.01041965f, -0.14739901f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02384132f, 0.04075813f, 0.01725431f, 0.01476577f, 0.04398314f, -0.04820396f, -0.01650845f, -0.00769793f, 
    0.03655989f, -0.07349882f, 0.13946216f, 0.01368448f, -0.06574032f, 0.00541756f, -0.04217190f, -0.00439611f, 
    0.16018154f, 0.13352025f, -0.00605029f, 0.02318211f, -0.02085624f, 0.05971242f, 0.00338536f, 0.00368881f, 
    0.02040499f, -0.03492205f, 0.17473945f, 0.03145293f, 0.11776774f, 0.08395082f, -0.01815205f, 0.03001616f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16788767f, 0.15578803f, 0.07661603f, 0.10056908f, 0.15172583f, -0.13541020f, 0.04256146f, -0.00162452f, 
    0.05561518f, 0.07389349f, 0.27262342f, 0.13785547f, -0.02484930f, 0.33833322f, -0.14672975f, -0.08714442f, 
    0.17697003f, -0.12306285f, -0.03635094f, -0.07035246f, 0.04716838f, -0.26592734f, 0.23410285f, 0.09935031f, 
    -0.14756447f, -0.31312311f, 0.05605882f, 0.23022297f, 0.22349834f, 0.01198642f, 0.16335620f, -0.32779986f, 
    0.05185707f, 0.23708887f, -0.06213913f, 0.18113229f, 0.14419745f, 0.04454454f, 0.11896861f, 0.05683368f, 
    0.07386045f, -0.17785712f, 0.07551271f, -0.12905474f, 0.33856505f, 0.42066061f, -0.08957962f, -0.03753564f, 
    -0.06473322f, -0.11549413f, -0.03653511f, -0.03829728f, -0.25699645f, -0.30035141f, 0.30453148f, -0.02314335f, 
    0.24668537f, 0.17429751f, 0.41446716f, 0.29027870f, 0.08632390f, -0.15038152f, -0.07359044f, -0.00945946f, 
    -0.05820721f, 0.27183974f, -0.04787587f, -0.13200986f, 0.03732654f, -0.05583871f, -0.06608765f, 0.09175929f, 
    0.08408621f, -0.20565808f, -0.25413901f, 0.06467985f, -0.12129107f, 0.23424298f, 0.15968835f, -0.09114529f, 
    0.07009326f, 0.47251543f, 0.04432343f, 0.45477310f, 0.00293994f, -0.26399472f, 0.13375422f, 0.01148350f, 
    -0.03514057f, -0.26895535f, 0.16917025f, -0.02090462f, 0.18627383f, -0.13129699f, -0.17321301f, 0.07823130f, 
    -0.05166883f, 0.40654430f, 0.17969505f, -0.21276388f, -0.13401757f, -0.06296392f, 0.13717118f, -0.01365666f, 
    -0.02074563f, 0.10022912f, 0.17730217f, -0.13491029f, 0.16266672f, 0.10015811f, -0.09551504f, 0.13027449f, 
    0.00100660f, 0.05614958f, 0.18149181f, -0.21004586f, 0.54149091f, -0.17495395f, -0.02354049f, -0.15741201f, 
    -0.15083894f, -0.42450559f, -0.23593658f, -0.05423528f, 0.01790158f, 0.04764820f, 0.07445490f, -0.02750910f, 
    0.08027966f, 0.10738675f, -0.14606455f, -0.25697505f, 0.07586498f, 0.13136013f, 0.11208356f, -0.27094653f, 
    -0.02517290f, -0.34353909f, 0.38865763f, 0.12893051f, -0.28750190f, 0.32396811f, -0.03028653f, 0.04008566f, 
    -0.04325403f, -0.22525449f, 0.01196370f, -0.18039681f, -0.02134865f, -0.09135883f, 0.27286434f, 0.00928116f, 
    -0.25326383f, -0.21043335f, 0.31193611f, -0.15282400f, 0.05152831f, 0.50862640f, -0.01972978f, 0.12428829f, 
    -0.08182385f, -0.16338904f, 0.02768481f, -0.09944464f, 0.01389889f, -0.02377940f, 0.14510353f, -0.16065007f, 
    -0.07543624f, -0.04474092f, -0.01833492f, -0.04323417f, -0.06950580f, -0.15965042f, -0.12731937f, -0.07132182f, 
    -0.05955527f, 0.01853453f, -0.01861673f, 0.05770124f, 0.09047759f, -0.04541516f, -0.05358194f, -0.11576833f, 
    0.00902255f, -0.06115600f, 0.07794956f, 0.03447623f, -0.08068451f, -0.02088544f, -0.16185042f, 0.05271769f, 
    -0.03955078f, 0.25854364f, 0.00871667f, 0.15630023f, -0.04570824f, 0.15291947f, -0.15439358f, -0.15854745f, 
    0.13420495f, 0.37598798f, 0.15239042f, -0.12354985f, 0.21426286f, 0.41620198f, -0.05051773f, -0.16503733f, 
    -0.13542287f, -0.32000884f, -0.09907697f, -0.20686653f, 0.22668076f, 0.16015908f, -0.00570834f, -0.14475317f, 
    0.00845741f, 0.04830341f, -0.20723687f, 0.30627921f, 0.11327112f, 0.00288355f, -0.04784873f, -0.17249700f, 
    0.03258421f, 0.27627662f, 0.04177742f, 0.35566741f, -0.05730726f, 0.05424997f, -0.16809836f, -0.28454623f, 
    -0.08360075f, -0.02731036f, 0.36183250f, -0.16624412f, 0.22063741f, 0.01932736f, 0.00114959f, 0.03763457f, 
    0.10502245f, 0.10420159f, -0.27875149f, -0.20956062f, 0.06501780f, 0.14244136f, -0.09920593f, 0.03986393f, 
    -0.11609492f, 0.29205525f, -0.20281711f, 0.22812244f, 0.08243757f, -0.07233848f, -0.03739187f, 0.07649769f, 
    -0.06454109f, -0.03012147f, -0.10246488f, -0.14795727f, 0.00873097f, -0.16873915f, -0.10946072f, -0.08378796f, 
    0.10693091f, -0.14179887f, -0.18931173f, 0.00239443f, -0.03618046f, -0.10565351f, 0.07563047f, -0.04292414f, 
    0.05092483f, -0.03590490f, -0.07675200f, 0.05394041f, -0.00618612f, -0.03112454f, -0.14552301f, -0.02113890f, 
    -0.18941261f, 0.02083593f, -0.04744490f, -0.10590512f, 0.05827769f, 0.01663750f, 0.04179676f, -0.11002234f, 
    -0.09293585f, -0.00244698f, -0.01550028f, 0.16596535f, 0.14973485f, -0.10662860f, 0.04297398f, -0.16859528f, 
    0.15200754f, 0.14425333f, 0.18900821f, -0.04820468f, 0.23302265f, -0.20157391f, 0.02833173f, 0.14033428f, 
    0.10746991f, 0.01286458f, 0.14458655f, -0.40945545f, -0.10030490f, -0.12594071f, -0.16315719f, -0.00802551f, 
    0.04365259f, 0.24327558f, -0.00181266f, 0.28300577f, 0.08417172f, -0.02081523f, -0.14365838f, -0.07820523f, 
    -0.05427255f, 0.11937860f, 0.14699668f, -0.02104889f, 0.01269743f, -0.07134467f, 0.06184412f, 0.02707457f, 
    0.00659791f, 0.36489710f, -0.22100835f, -0.07678932f, -0.06432875f, 0.24536043f, -0.13385539f, 0.12580048f, 
    0.07123459f, -0.02466614f, -0.34420013f, 0.36344010f, 0.17981510f, -0.04695813f, 0.13755476f, -0.10690671f, 
    -0.05651562f, -0.01700067f, -0.03619926f, 0.01567335f, 0.19455650f, -0.02696593f, 0.10482603f, -0.13167517f, 
    -0.06075488f, -0.33826408f, -0.08821704f, 0.10683916f, 0.02423251f, -0.06335483f, -0.14284232f, 0.16712895f, 
    -0.03045283f, 0.11154938f, 0.11745489f, -0.11800383f, 0.20403785f, -0.19981839f, -0.16232179f, 0.24289198f, 
    0.25897825f, -0.33705345f, 0.25965300f, 0.03933415f, -0.30155766f, 0.39445531f, -0.19802910f, -0.05022841f, 
    0.30837503f, 0.15899441f, 0.05187701f, 0.16600429f, -0.18668431f, 0.23306200f, -0.08064859f, -0.16639665f, 
    -0.00048779f, -0.16168392f, -0.15354778f, 0.14425910f, 0.00538843f, -0.06972705f, 0.08903477f, -0.10638220f, 
    -0.06886864f, -0.10376836f, -0.16927736f, -0.09156818f, -0.07451192f, -0.04852178f, -0.00051761f, -0.06827283f, 
    -0.10352567f, -0.18393472f, -0.02471036f, 0.07625223f, -0.16564359f, -0.02068323f, -0.01054363f, -0.04736688f, 
    -0.17227599f, 0.09798828f, 0.01779089f, -0.00573155f, -0.02847948f, -0.16750325f, 0.01954512f, -0.14457920f, 
    0.13407739f, -0.37614515f, 0.07620889f, -0.05275144f, 0.06241744f, -0.15941168f, -0.16265434f, 0.10130081f, 
    -0.08983985f, -0.17371285f, -0.01246184f, 0.15292631f, -0.08341385f, -0.15368825f, -0.06030998f, 0.15090324f, 
    0.27289972f, -0.07180710f, 0.30240190f, 0.23694895f, -0.14741519f, 0.12933220f, -0.24345993f, 0.16665527f, 
    0.08066837f, -0.14948493f, 0.25530452f, 0.10890767f, -0.08029331f, 0.18998966f, 0.06820721f, 0.24958916f, 
    0.15659121f, 0.44894022f, -0.07633215f, -0.16632187f, -0.06498192f, 0.05552842f, -0.03937517f, -0.19290712f, 
    -0.01413373f, 0.32169390f, 0.13054116f, -0.01943133f, -0.08228566f, 0.45337620f, -0.16103569f, -0.29664710f, 
    -0.19856562f, -0.02364543f, -0.14766626f, -0.20776440f, 0.24331889f, 0.30254167f, 0.19107863f, 0.11515208f, 
    0.16912457f, -0.06728051f, -0.16290370f, -0.05526894f, 0.05495353f, 0.31023464f, 0.15795940f, -0.01151516f, 
    0.01391059f, 0.06226597f, -0.01888040f, 0.14319946f, 0.04294168f, -0.11584081f, -0.12504789f, 0.33893698f, 
    0.00452495f, -0.00527240f, 0.06951717f, -0.03745113f, 0.17954373f, -0.34260902f, -0.06142444f, 0.03326730f, 
    -0.14547975f, 0.04939211f, 0.37703964f, 0.06677406f, -0.06591204f, -0.13277297f, -0.14254071f, 0.15098074f, 
    -0.05071222f, 0.27844161f, 0.34595174f, 0.27283505f, -0.07132401f, -0.19486326f, -0.14068344f, 0.14193039f, 
    0.03940469f, 0.19705519f, 0.08388232f, 0.35944894f, 0.03393654f, -0.15678765f, -0.01617082f, 0.08330459f, 
    0.11851945f, -0.02347854f, -0.19138856f, -0.06404639f, 0.27991810f, -0.02902912f, 0.16296686f, -0.20386481f, 
    -0.14899357f, 0.21383373f, 0.04312287f, -0.18808560f, -0.31842011f, -0.10601272f, 0.01310903f, 0.14928490f, 
    0.21944125f, 0.38735491f, 0.35938939f, 0.23030168f, 0.10061984f, 0.31208834f, -0.02904542f, -0.00418306f, 
    -0.05352240f, -0.16800034f, -0.12174307f, -0.02908698f, 0.12525305f, -0.15155353f, -0.10297940f, -0.04559653f, 
    -0.04641906f, -0.22583953f, 0.24289791f, -0.04666954f, -0.25505859f, 0.21678674f, 0.07554665f, 0.06658939f, 
    0.33383054f, 0.10431464f, 0.23735403f, 0.32197538f, -0.21526107f, -0.14531058f, 0.20903189f, 0.00266064f, 
    -0.02337863f, -0.24246378f, 0.22214760f, 0.13660131f, 0.26849139f, -0.16714253f, 0.10948177f, -0.13807926f, 
    0.12041089f, 0.06540751f, -0.08112011f, 0.01818023f, 0.05448895f, 0.04623743f, -0.01087132f, 0.10794964f, 
    0.14630605f, -0.20035411f, -0.04797138f, -0.17871743f, 0.07504328f, 0.02926069f, -0.10079045f, -0.03912899f, 
    -0.02716383f, -0.03631307f, -0.04473586f, -0.01761187f, 0.06598274f, 0.03732117f, -0.10684932f, -0.16128959f, 
    0.00062974f, -0.11009780f, -0.04587394f, -0.20655806f, -0.07711881f, -0.02390639f, -0.05414812f, -0.04378932f, 
    -0.16781127f, -0.04164115f, 0.12954672f, -0.08013102f, 0.00595588f, -0.05146845f, -0.10762553f, -0.01837689f, 
    0.12575622f, 0.03809376f, -0.09260256f, -0.13361397f, 0.04609142f, 0.08651260f, 0.01210302f, -0.05249351f, 
    0.01013258f, -0.09182382f, -0.16476035f, 0.06219477f, -0.11659630f, -0.05715374f, -0.14376797f, -0.15209807f, 
    -0.12913664f, -0.11012647f, 0.05045908f, -0.16064180f, 0.03167007f, -0.17772444f, -0.09397560f, -0.00742593f, 
    0.07020598f, -0.09417830f, 0.10550495f, 0.16631529f, -0.02761000f, -0.00391169f, -0.13151446f, 0.18613406f, 
    0.10709688f, 0.19328244f, 0.06064341f, -0.16130960f, -0.19995499f, -0.06734511f, 0.07416178f, 0.08374006f, 
    0.09319928f, -0.13377991f, -0.31813252f, 0.17269464f, 0.16100961f, 0.03793590f, 0.01241665f, 0.15672083f, 
    -0.09066340f, -0.05034206f, 0.25186601f, -0.02078931f, 0.27703303f, 0.06952015f, 0.15689020f, -0.06531541f, 
    0.04091585f, -0.07192364f, -0.13550624f, 0.18455385f, 0.16281505f, 0.13968223f, 0.08902205f, 0.14781353f, 
    0.15264177f, 0.05850185f, -0.06783148f, -0.11737250f, -0.21724142f, 0.36597350f, 0.15667307f, 0.08785431f, 
    0.03761477f, -0.32541400f, 0.11136236f, 0.27989978f, 0.16683447f, 0.25610161f, 0.13104516f, -0.13767365f, 
    -0.18779361f, -0.29976246f, -0.08275653f, 0.25019881f, 0.20376322f, -0.09745054f, 0.09117693f, -0.04192789f, 
    -0.14842646f, -0.24926247f, 0.16463231f, -0.03849047f, -0.12064569f, 0.07893257f, -0.06536070f, 0.10582703f, 
    0.09853863f, -0.11898875f, 0.27139974f, 0.08008223f, -0.06537016f, -0.20800237f, 0.05047578f, 0.04065356f, 
    0.14227398f, -0.06854138f, 0.43261844f, -0.17186587f, 0.12546445f, -0.13873592f, -0.32434031f, -0.01617382f, 
    0.13170849f, -0.10244921f, 0.33798870f, 0.23393942f, 0.05345295f, -0.15352431f, 0.08001094f, 0.06080067f, 
    -0.02259329f, -0.08688293f, 0.11797504f, -0.11449396f, -0.12262399f, 0.01050804f, 0.13514350f, 0.23299564f, 
    -0.16427505f, -0.15857770f, 0.11780050f, 0.16520181f, -0.11624663f, 0.12670717f, -0.09339078f, 0.13339184f, 
    -0.06042235f, 0.47996163f, -0.19295125f, 0.32568154f, 0.19339101f, -0.14136809f, -0.08662491f, -0.06738645f, 
    -0.10358122f, -0.06318085f, 0.27269399f, -0.22726426f, -0.03641945f, -0.13839823f, 0.15755379f, 0.50054395f, 
    0.11221796f, -0.13775671f, -0.04872351f, -0.25181058f, -0.08288266f, 0.17842008f, -0.15027282f, 0.14878339f, 
    -0.17016296f, -0.27230832f, 0.28829458f, -0.16403933f, 0.02199865f, 0.40287423f, -0.08822417f, 0.27250698f, 
    0.13326894f, 0.20530112f, 0.01181127f, -0.09937588f, 0.09139306f, -0.11633848f, 0.04365999f, 0.06468108f, 
    0.13935427f, 0.07920636f, 0.13798958f, 0.14083195f, -0.03186928f, -0.37790594f, 0.11967789f, 0.23146059f, 
    0.09360870f, 0.11990789f, -0.02544331f, 0.01614359f, 0.14264253f, -0.14681871f, 0.07014614f, -0.53401423f, 
    0.12886028f, -0.00382914f, 0.08300216f, -0.02876689f, -0.34714547f, 0.05451297f, -0.05429591f, -0.11624704f, 
    0.00961130f, 0.16405971f, -0.13783668f, 0.26019004f, -0.15404242f, 0.00743979f, 0.12064283f, 0.03027983f, 
    -0.13180391f, -0.07127611f, 0.00014914f, -0.19456352f, 0.11258933f, 0.49307722f, 0.12021075f, 0.26558155f, 
    -0.15585846f, 0.21020079f, 0.05379761f, 0.33101875f, 0.06155733f, 0.07781062f, -0.05250561f, -0.03670505f, 
    -0.12047493f, -0.04835922f, -0.37951872f, -0.05925350f, 0.07035328f, -0.43095917f, -0.09087738f, 0.17550647f, 
    -0.03389511f, 0.13757208f, 0.23421964f, 0.36023611f, 0.12607232f, 0.14361651f, 0.17687580f, 0.05324987f, 
    -0.19789343f, -0.10404550f, -0.22485963f, -0.08762020f, 0.09600735f, 0.19553870f, -0.09022157f, -0.11084162f, 
    -0.01311066f, -0.26732123f, 0.14060691f, 0.02628270f, -0.02857159f, 0.16243584f, 0.15290180f, 0.22707494f, 
    0.11705308f, -0.21083389f, 0.00514389f, 0.12278727f, 0.07355732f, -0.01905858f, 0.07931419f, -0.15992390f, 
    0.21737562f, 0.03171735f, 0.20693335f, 0.09370768f, -0.25670427f, -0.00257487f, -0.20844185f, 0.08628912f, 
    0.06673320f, -0.09791224f, 0.54692823f, 0.20465359f, 0.14897664f, -0.07702737f, -0.04667132f, -0.04488375f, 
    0.02561201f, 0.17543875f, 0.10754593f, -0.16439666f, -0.01658261f, -0.15354854f, 0.14718686f, 0.30095112f, 
    -0.19043197f, 0.31210214f, 0.15609197f, -0.02052638f, 0.06600550f, 0.34039819f, -0.06007064f, -0.09589381f, 
    -0.12018598f, 0.17855449f, -0.10077769f, 0.15284635f, 0.20154989f, 0.10226318f, -0.23364881f, 0.08707898f, 
    0.33988225f, 0.11962793f, 0.12872078f, -0.24588116f, -0.18350948f, -0.31392053f, 0.08060706f, 0.05477349f, 
    0.05337323f, 0.26797694f, -0.03985194f, -0.00575714f, 0.04190918f, 0.07714916f, -0.12122925f, -0.11665272f, 
    0.12452930f, 0.00373053f, -0.10241783f, -0.14342871f, 0.25341666f, -0.25558847f, 0.14252698f, 0.24852309f, 
    -0.29352555f, 0.20983738f, 0.06720540f, -0.22453368f, 0.03810542f, 0.24785936f, 0.22249459f, -0.03946603f, 
    -0.00720253f, 0.22735634f, -0.15007554f, -0.12356821f, 0.11298247f, 0.09862643f, -0.03101506f, 0.10511836f, 
    0.04034539f, 0.10616701f, -0.13867044f, 0.03287006f, 0.12595725f, 0.13809669f, -0.12323538f, -0.00784347f, 
    0.01264380f, -0.17453328f, -0.18149434f, 0.16390814f, 0.04062020f, 0.05496069f, 0.11284336f, -0.11907899f, 
    -0.11104407f, -0.13508633f, -0.11407916f, -0.09566381f, -0.07992318f, 0.01554138f, -0.08219461f, 0.15451083f, 
    -0.13298605f, 0.02557500f, 0.14094339f, -0.05981304f, 0.11353992f, -0.07760118f, 0.03597788f, 0.13595369f, 
    -0.15670727f, 0.02528450f, 0.01482800f, 0.02290168f, 0.11290437f, 0.09473562f, 0.01037219f, -0.31213537f, 
    0.09355677f, 0.31999961f, -0.22375041f, 0.14640571f, -0.11451109f, 0.11371191f, -0.05240086f, -0.14083262f, 
    0.20033193f, 0.05859303f, -0.09259623f, -0.19358911f, 0.07143164f, 0.16343589f, 0.01859796f, -0.07626133f, 
    0.07390210f, 0.24216177f, 0.14205456f, -0.21752119f, 0.08763959f, -0.43920901f, -0.11685203f, 0.22380450f, 
    -0.03234516f, 0.11790335f, -0.05932280f, 0.13516757f, 0.12377711f, -0.17587417f, 0.00257368f, -0.30788693f, 
    0.11528873f, 0.36460549f, -0.03129632f, 0.15352368f, 0.32628062f, -0.18028393f, 0.15971251f, 0.29343817f, 
    -0.09279477f, -0.19777787f, -0.23085836f, -0.08446074f, -0.02261383f, 0.25344142f, 0.21802659f, 0.00651505f, 
    0.12228166f, -0.06971558f, 0.05593757f, 0.00003131f, 0.33058086f, 0.16383357f, 0.07799105f, -0.44295430f, 
    -0.12734832f, 0.47800413f, 0.16045529f, -0.08037237f, 0.04278927f, -0.16741230f, 0.13472541f, -0.04710215f, 
    -0.05838897f, -0.12868401f, 0.05732258f, 0.02043578f, -0.05032106f, 0.11958038f, 0.15400851f, 0.00511087f, 
    -0.20272914f, 0.35141054f, -0.17710662f, -0.16385517f, 0.40789625f, 0.01038057f, 0.20607254f, -0.01199231f, 
    0.15280597f, -0.14647333f, 0.04582265f, -0.06842583f, 0.13992839f, 0.23631765f, -0.05302145f, 0.03561525f, 
    0.15705900f, -0.13100307f, -0.00609037f, -0.01624721f, -0.14222515f, -0.02836628f, -0.11875781f, -0.10863978f, 
    -0.15670078f, -0.12274589f, 0.14547235f, -0.14295486f, -0.19257189f, 0.22776093f, 0.17075887f, 0.29898700f, 
    0.32171845f, 0.00215539f, -0.33137330f, -0.07684051f, -0.08233692f, 0.03746624f, -0.06498856f, -0.02926018f, 
    0.16289979f, -0.22042707f, 0.12691693f, 0.18569158f, 0.25118655f, 0.13607170f, -0.11657830f, 0.20233828f, 
    -0.10068239f, 0.18397385f, -0.04989173f, -0.27028638f, 0.17112355f, -0.10455818f, 0.10205360f, -0.17473897f, 
    -0.08526286f, 0.36776859f, -0.11796544f, -0.05312486f, -0.22213306f, 0.07594658f, -0.11122867f, -0.08336646f, 
    -0.10598528f, 0.02162754f, 0.26349655f, -0.27927986f, 0.26349229f, 0.44642714f, -0.06707989f, -0.13019584f, 
    0.16031151f, 0.06953355f, -0.03272125f, -0.34509411f, 0.05816606f, 0.15277545f, 0.04271779f, -0.04335137f, 
    0.04906485f, 0.34341443f, 0.16725610f, 0.20678237f, 0.15326798f, -0.04517196f, -0.08011922f, -0.20150198f, 
    -0.06840207f, 0.16734684f, -0.21602345f, -0.13556276f, 0.06207292f, 0.10885099f, 0.06220936f, -0.22342674f, 
    -0.11740874f, 0.11060243f, 0.09636228f, -0.10552350f, -0.15922651f, -0.05486463f, 0.42965102f, -0.12007039f, 
    0.18638873f, 0.40203589f, -0.05134248f, -0.15398003f, 0.09195965f, 0.20184390f, 0.07862857f, -0.01549257f, 
    -0.14657012f, -0.01677889f, -0.10800441f, 0.08361252f, 0.08225711f, 0.08377887f, -0.14856920f, -0.16756824f, 
    -0.07599970f, 0.02146774f, -0.05321262f, 0.03019607f, -0.19341722f, 0.00049804f, 0.10919150f, -0.23708278f, 
    -0.15391457f, 0.02902884f, 0.09216373f, 0.02454204f, -0.10631085f, -0.16059448f, 0.16200891f, -0.05747140f, 
    0.04370284f, -0.28687522f, -0.32913226f, -0.10446899f, 0.07888906f, 0.06036125f, -0.13444780f, 0.06773221f, 
    -0.01118851f, 0.14364828f, 0.06738433f, 0.05623503f, 0.11754847f, 0.12722726f, 0.08837392f, -0.41635635f, 
    -0.09430129f, 0.28870717f, 0.20516989f, -0.16126214f, -0.05181443f, 0.15631329f, -0.14480402f, -0.04221314f, 
    0.20824279f, 0.02570576f, -0.07357932f, -0.07379160f, 0.10309952f, 0.28264979f, 0.08828342f, -0.00714738f, 
    -0.25781056f, 0.20447683f, -0.34469071f, -0.21411873f, 0.11002924f, 0.31446633f, -0.02438375f, -0.08261778f, 
    0.10335051f, -0.06258921f, 0.02138354f, -0.18297845f, 0.11440182f, -0.15349321f, -0.11874864f, 0.08495213f, 
    -0.07114428f, -0.11014188f, 0.06506020f, 0.16360435f, -0.09727961f, -0.10278086f, -0.12086727f, -0.16972519f, 
    0.09721188f, -0.14698738f, -0.21259081f, -0.17581065f, -0.18496238f, 0.04838840f, 0.05456526f, -0.08565308f, 
    -0.10342574f, -0.00584752f, 0.10783691f, 0.00005781f, 0.04172086f, -0.04529049f, 0.07521448f, 0.03800633f, 
    0.13260004f, 0.29390499f, -0.07456595f, 0.37194246f, -0.17052945f, -0.15734078f, 0.14471893f, -0.04873390f, 
    0.06027129f, 0.02137746f, -0.31229115f, -0.17041740f, 0.16573046f, -0.29399905f, 0.15614085f, -0.11434712f, 
    -0.19216001f, 0.15344563f, -0.06261181f, -0.00630172f, -0.03260357f, -0.16539229f, 0.13358316f, -0.06733515f, 
    0.05463824f, 0.12852363f, 0.25568917f, 0.33799025f, 0.29675239f, 0.30484155f, 0.11437964f, -0.07602476f, 
    -0.00089830f, -0.05180452f, 0.07482229f, -0.08752336f, 0.14203818f, 0.16160022f, -0.12943421f, 0.28728127f, 
    0.07499602f, 0.01850496f, -0.04128747f, -0.00154666f, -0.06124377f, -0.13802628f, -0.03655074f, -0.02112002f, 
    0.00546569f, -0.02872951f, -0.09161221f, -0.22806489f, 0.11108818f, 0.43004784f, 0.06816857f, 0.17042929f, 
    -0.00022721f, -0.05127110f, -0.04577596f, -0.09073132f, -0.08813079f, 0.23709328f, 0.08783335f, 0.24357797f, 
    -0.08213226f, -0.12619518f, -0.11767030f, -0.23708294f, -0.16876718f, -0.03948445f, -0.14513028f, 0.34468743f, 
    0.07841252f, 0.10609355f, -0.10216503f, -0.00406066f, 0.01708290f, -0.08185422f, 0.03282932f, 0.29391310f, 
    0.16833459f, -0.32786965f, 0.41202047f, -0.35576409f, 0.44281062f, 0.32588494f, -0.14651771f, -0.07199496f, 
    0.13613613f, -0.27647051f, 0.11315530f, 0.10566329f, -0.09151212f, 0.06297344f, -0.12009755f, 0.22358680f, 
    -0.16318850f, -0.15148558f, 0.15434764f, -0.03888708f, -0.03109237f, 0.04064427f, 0.11045999f, -0.01443303f, 
    0.10300435f, -0.18297088f, 0.14101940f, -0.02412059f, 0.22583839f, 0.34079796f, -0.11740927f, 0.03485061f, 
    0.31935212f, 0.14857157f, 0.14626545f, -0.05580823f, -0.33451664f, -0.28839254f, 0.14153755f, -0.09153672f, 
    0.03989372f, -0.04711919f, 0.27902722f, 0.32215399f, -0.22014356f, 0.17173278f, -0.00138011f, 0.03795555f, 
    -0.10607345f, 0.03248537f, 0.07541891f, 0.13869816f, -0.12534350f, 0.08446508f, -0.04262451f, -0.35189354f, 
    0.12171266f, 0.03627075f, -0.06727723f, 0.05852321f, -0.02568900f, -0.08171719f, 0.05294866f, 0.06258058f, 
    0.18114215f, 0.20456886f, -0.15716635f, 0.38825279f, -0.41252884f, -0.02038561f, 0.20596781f, -0.16429578f, 
    0.10755949f, 0.27712086f, 0.18738590f, -0.02218990f, 0.05237329f, 0.10025746f, -0.13492315f, 0.07638811f, 
    -0.07152823f, -0.13982488f, -0.13908772f, -0.16207469f, 0.14911759f, -0.15405107f, 0.11092886f, -0.03496261f, 
    -0.10633623f, -0.24121237f, 0.33127555f, 0.03575366f, -0.03902905f, 0.07710254f, -0.11263771f, 0.31852520f, 
    0.20744996f, 0.22780684f, 0.17719533f, -0.16300008f, -0.05727756f, 0.28351119f, -0.08748908f, 0.12057587f, 
    0.16719793f, -0.04718456f, -0.08919413f, 0.02020340f, -0.20571092f, -0.05801963f, -0.08235200f, 0.35059589f, 
    0.10237967f, 0.14186171f, 0.03023394f, 0.30002210f, -0.00392169f, 0.14631428f, -0.03530062f, -0.28850862f, 
    0.14851224f, 0.13043769f, -0.27591220f, -0.13664652f, 0.06059276f, -0.17241925f, 0.04822989f, -0.00493132f, 
    0.08944532f, -0.06554534f, 0.11976894f, 0.04919329f, -0.24573927f, 0.08237997f, -0.01512583f, 0.13639052f, 
    0.07966097f, 0.09266077f, 0.19276614f, 0.27562129f, -0.05243338f, 0.39104587f, 0.00299984f, -0.35323200f, 
    -0.05320603f, 0.03260864f, 0.07340595f, -0.21744744f, -0.12542275f, 0.09858397f, -0.03318812f, 0.41434455f, 
    -0.05517159f, 0.13142508f, -0.02488658f, -0.05661935f, -0.08501150f, 0.43499869f, -0.09531311f, -0.15557356f, 
    0.19272989f, 0.01656628f, 0.11452259f, 0.13099973f, -0.01548302f, -0.04544244f, -0.26124001f, 0.06900732f, 
    0.19735783f, 0.35981736f, 0.24953026f, -0.11781298f, -0.14170572f, -0.28043607f, 0.00315223f, 0.25798768f, 
    0.14719132f, 0.16993380f, -0.10402607f, -0.08366059f, -0.03088355f, -0.15376937f, -0.05069926f, 0.45451441f, 
    0.07790025f, -0.05790069f, -0.25043815f, 0.04008043f, -0.16538708f, 0.05439970f, -0.01211286f, -0.05858575f, 
    -0.18383412f, -0.35195023f, 0.03362391f, 0.21171702f, -0.02541767f, -0.00070290f, 0.12866409f, -0.09051982f, 
    0.16190034f, 0.04350339f, 0.19930296f, 0.24011642f, 0.19793987f, 0.13965100f, 0.16387568f, -0.04202771f, 
    -0.00147194f, 0.10781511f, -0.04666977f, 0.27609339f, -0.00338966f, -0.12454246f, 0.08838294f, 0.05830508f, 
    0.02882747f, 0.06855713f, 0.08905466f, -0.03104264f, 0.06387457f, -0.26163021f, 0.05591489f, -0.01688404f, 
    -0.16199008f, 0.24178623f, -0.03237101f, -0.03404389f, -0.10708231f, -0.13271780f, 0.10773738f, 0.13709059f, 
    0.08888925f, 0.35172582f, 0.19627838f, 0.16267411f, -0.11415357f, 0.15955909f, -0.10991038f, -0.14687540f, 
    0.08745132f, 0.28535259f, 0.13891229f, 0.39108849f, -0.14889468f, 0.02759924f, -0.00509773f, -0.26547053f, 
    0.11066002f, 0.25910354f, 0.10545351f, 0.15291685f, 0.32914120f, -0.07833894f, -0.07933801f, -0.14091752f, 
    0.08226997f, -0.02518047f, -0.17025390f, -0.19185859f, -0.10899280f, -0.16099085f, 0.29109129f, -0.07947320f, 
    0.08869261f, 0.03279955f, 0.21797340f, 0.13234438f, 0.17570044f, -0.11535172f, 0.16371772f, -0.29584682f, 
    -0.06650325f, -0.13609184f, 0.14862347f, -0.00095205f, -0.15936126f, -0.12238535f, 0.07658457f, -0.44299632f, 
    -0.09980850f, 0.20762351f, 0.09344683f, -0.01612715f, 0.32833961f, 0.12498870f, 0.09724601f, -0.13985278f, 
    0.12801637f, 0.07454150f, -0.26201004f, -0.13649035f, -0.23754379f, 0.13725454f, 0.15517031f, 0.02258601f, 
    0.19072507f, 0.09474838f, 0.04842542f, 0.15933321f, -0.08458095f, 0.24783614f, -0.13098696f, -0.07944624f, 
    -0.05441334f, 0.16142230f, 0.07386925f, -0.02292666f, 0.15864885f, -0.10072644f, 0.10885892f, 0.02364280f, 
    -0.14316261f, -0.09275267f, -0.09481524f, -0.12786545f, 0.19605257f, -0.05279780f, -0.04167270f, 0.14929034f, 
    0.04195002f, -0.27445653f, 0.19926195f, -0.12214421f, 0.18931949f, 0.04658296f, 0.10952999f, -0.02070406f, 
    -0.06447060f, -0.25209317f, 0.09580272f, 0.20583762f, 0.09398531f, 0.42715690f, 0.01275331f, -0.03141005f, 
    -0.00495374f, -0.20534562f, 0.08749548f, 0.34967977f, -0.00143362f, -0.13861896f, -0.06393716f, 0.01235328f, 
    -0.10177636f, 0.43255454f, 0.00976970f, 0.02011409f, 0.12734939f, -0.03018828f, -0.12747005f, 0.21772350f, 
    0.03426847f, -0.46229324f, 0.12475640f, 0.01404320f, 0.04031723f, 0.28438330f, 0.01020281f, 0.02119853f, 
    -0.10238434f, 0.13196209f, -0.12468635f, 0.12646520f, 0.23100734f, -0.10337890f, -0.05445231f, -0.35371295f, 
    0.15560263f, 0.13601136f, -0.05055882f, -0.09813824f, 0.06224290f, -0.02203003f, -0.13335796f, -0.23092556f, 
    0.10154340f, 0.12242918f, 0.30408913f, 0.12577800f, -0.09529377f, -0.07912846f, 0.07446864f, 0.13117367f, 
    0.33593604f, 0.15539406f, -0.18214710f, 0.23898207f, -0.08315138f, -0.12202360f, -0.19494209f, 0.13072440f, 
    0.02378646f, -0.09553681f, 0.04323874f, -0.31044960f, 0.22758104f, -0.31780979f, 0.07750207f, 0.10247654f, 
    -0.15621418f, -0.21620020f, -0.14881738f, -0.19324157f, 0.06048073f, -0.10248708f, 0.12086134f, -0.11937396f, 
    0.04081948f, 0.12800452f, 0.32039431f, -0.13334447f, -0.04211635f, 0.04200326f, 0.06858361f, 0.15926905f, 
    0.21852627f, -0.32192338f, -0.09047212f, 0.03958537f, -0.05026794f, 0.45021722f, 0.12928997f, 0.07171177f, 
    0.15401211f, 0.14881788f, -0.18977967f, -0.00195134f, -0.09608448f, 0.42495424f, 0.15510240f, -0.03180437f, 
    0.02266526f, 0.28318828f, 0.10297497f, -0.07967769f, 0.11187071f, 0.03623521f, -0.15605928f, -0.18989752f, 
    0.16187939f, 0.17529835f, -0.22664198f, -0.16229573f, -0.03778772f, -0.17201617f, -0.11742799f, -0.34043998f, 
    -0.19729984f, 0.35176748f, -0.15748119f, 0.00265636f, 0.30722949f, -0.45840305f, -0.09980174f, 0.03325117f, 
    0.29394928f, 0.15949962f, 0.13031089f, 0.09048162f, 0.21312290f, -0.07121462f, -0.14862959f, -0.26568890f, 
    -0.00815375f, -0.06751520f, 0.01352178f, 0.05716841f, 0.02639383f, 0.16072156f, -0.13446286f, 0.05803729f, 
    0.08860275f, -0.14518037f, 0.02635717f, -0.16026621f, 0.11515822f, -0.07980967f, 0.09882211f, -0.03462315f, 
    0.07779762f, -0.04151643f, -0.03434880f, -0.18117382f, 0.14118968f, -0.10531362f, -0.11217278f, -0.03092396f, 
    -0.11523342f, -0.01839668f, -0.19131167f, -0.10666736f, -0.18896854f, -0.09309135f, 0.08986501f, 0.08938432f, 
    0.16920088f, -0.32556954f, -0.09055052f, 0.09349587f, -0.06585232f, 0.03527181f, 0.14314495f, 0.17775400f, 
    0.22241344f, 0.09110634f, 0.03920834f, -0.12138344f, -0.17655911f, -0.09623843f, -0.07470914f, 0.02240747f, 
    0.05998245f, -0.12732060f, -0.19282135f, 0.15976328f, -0.31419146f, 0.26898864f, -0.15110716f, 0.11655283f, 
    -0.07092795f, 0.22736284f, 0.17933628f, 0.29505187f, 0.09305109f, 0.34054524f, -0.09135987f, 0.15539160f, 
    -0.09290809f, -0.14976227f, -0.15304783f, -0.06764371f, 0.16280071f, 0.00472601f, -0.00884108f, 0.05021777f, 
    0.17505449f, -0.04416804f, 0.00549518f, -0.13428435f, 0.13824289f, -0.13361238f, 0.09798677f, 0.07645083f, 
    -0.16414823f, 0.01317154f, -0.14307579f, 0.08607537f, -0.15827383f, -0.08545512f, -0.01081951f, 0.14258713f, 
    -0.03158433f, 0.09937403f, -0.06669743f, 0.07016617f, -0.12238220f, -0.03915765f, 0.17188971f, -0.18621789f, 
    0.05232449f, 0.47882268f, 0.16621745f, 0.32945701f, 0.03385440f, -0.04003143f, -0.02379239f, -0.25796178f, 
    -0.03407485f, -0.04975654f, -0.11030813f, -0.13344944f, 0.10273649f, -0.02264455f, 0.05844113f, -0.12710410f, 
    0.10604536f, 0.16767240f, -0.05002690f, 0.09109545f, -0.11976898f, -0.17158450f, 0.37770444f, 0.04424110f, 
    -0.03989250f, 0.18009771f, 0.03966774f, -0.09120723f, 0.24424249f, 0.07864940f, -0.06257476f, -0.22390711f, 
    0.08085858f, -0.03402205f, -0.01987647f, 0.01706107f, -0.00321384f, 0.09409347f, 0.14478664f, 0.03582431f, 
    -0.10068115f, -0.09018873f, -0.14606793f, 0.13852450f, 0.02909152f, -0.09304157f, 0.08976672f, -0.08344164f, 
    -0.07003436f, -0.00705300f, -0.17414984f, 0.15009235f, 0.02106571f, 0.00194598f, -0.01188937f, -0.00581026f, 
    -0.14101377f, -0.12742838f, -0.03683247f, -0.12003713f, -0.01859622f, 0.08605796f, 0.03024079f, -0.06521396f, 
    0.02492446f, 0.42282069f, 0.14851993f, 0.01360126f, 0.00323290f, -0.07698175f, 0.08464312f, -0.07426175f, 
    0.07918916f, 0.06573410f, 0.05922234f, -0.11529206f, 0.25590929f, -0.35612440f, 0.06306074f, -0.01969812f, 
    -0.02391028f, -0.02174107f, 0.25243908f, -0.19303325f, 0.35114452f, 0.34724876f, 0.05893465f, 0.11462823f, 
    -0.05039392f, -0.17745763f, -0.27325630f, 0.00932013f, -0.13664423f, 0.17697614f, 0.08212661f, -0.15097514f, 
    0.03428295f, 0.18717827f, 0.04264794f, -0.12152843f, 0.09971074f, -0.13997757f, -0.14107560f, -0.30089825f, 
    0.16668253f, 0.27390292f, 0.23417817f, 0.17049497f, -0.28802776f, -0.17300712f, 0.10196795f, 0.17603257f, 
    0.23760116f, 0.23678128f, -0.05354077f, -0.18583024f, 0.00538750f, 0.08488556f, -0.21737781f, -0.00312258f, 
    -0.08169298f, 0.10919016f, -0.00308585f, -0.08832397f, 0.26394984f, -0.48199055f, -0.08841334f, 0.04650143f, 
    0.13217446f, -0.17784743f, 0.12073959f, 0.10092618f, 0.14901103f, -0.10612541f, -0.10943242f, 0.22397833f, 
    -0.12980042f, 0.13640562f, 0.09557255f, 0.09815893f, -0.00744269f, -0.12789361f, -0.07681800f, 0.36013457f, 
    0.05778828f, -0.41451997f, 0.18808201f, -0.12546133f, 0.24793537f, 0.31820437f, -0.21651897f, -0.12791653f, 
    -0.01403550f, -0.29196131f, -0.11996668f, 0.29649556f, 0.17334016f, 0.08553172f, 0.08199900f, -0.09697746f, 
    0.06524309f, -0.10878526f, -0.16410241f, 0.23454228f, 0.05981387f, 0.12737574f, -0.15649784f, 0.33944780f, 
    0.13413978f, -0.36003438f, -0.06826522f, -0.13930579f, -0.09862036f, 0.04443724f, -0.04553216f, 0.26166433f, 
    0.02139728f, 0.01972567f, 0.27312198f, 0.27425292f, -0.03886381f, 0.09603421f, -0.21845162f, -0.08801405f, 
    -0.19784284f, -0.08896560f, 0.35908625f, 0.11470958f, 0.12843616f, -0.34649432f, 0.04553033f, 0.24706140f, 
    0.02051519f, -0.04828127f, -0.09206054f, -0.05901231f, -0.08622743f, -0.16539468f, 0.00328077f, 0.02803212f, 
    0.01931013f, 0.30813718f, -0.45066074f, 0.03931818f, 0.27863988f, 0.07377476f, 0.05030161f, 0.04209445f, 
    -0.05141519f, -0.06461117f, 0.46910423f, -0.31315246f, -0.14823213f, 0.05637949f, 0.07192973f, 0.13748220f, 
    0.38717076f, 0.01979298f, 0.11807787f, -0.26185498f, -0.07112253f, 0.04406899f, -0.16263227f, -0.05541874f, 
    -0.01887205f, -0.24378029f, -0.00126698f, -0.07518478f, -0.13430506f, 0.14872797f, 0.03718044f, 0.02144735f, 
    0.04976203f, 0.06442485f, 0.35041970f, -0.00541324f, -0.08453082f, 0.51516187f, 0.03142865f, -0.06952211f, 
    0.03098559f, 0.04796818f, -0.31070024f, -0.00294118f, -0.02631465f, -0.04709471f, 0.01656115f, 0.17501709f, 
    0.02923503f, 0.12821040f, 0.25724837f, 0.18957983f, 0.09180516f, -0.01283741f, -0.01265050f, 0.15324441f, 
    -0.15417324f, -0.01822256f, 0.13028720f, -0.15545371f, 0.16097042f, -0.04909042f, 0.04858248f, -0.08526728f, 
    -0.13978335f, 0.14209163f, -0.03493319f, -0.17307377f, -0.28669545f, 0.04653825f, -0.01609050f, -0.25887388f, 
    0.22578451f, 0.20070130f, 0.13763416f, 0.44185194f, 0.12476311f, -0.18048984f, -0.07823108f, -0.00668081f, 
    -0.02825173f, 0.19361813f, 0.31237072f, -0.02569942f, -0.00107045f, -0.27007058f, -0.10713036f, 0.34622714f, 
    -0.10743017f, 0.13994008f, 0.05653682f, 0.07062087f, 0.15258557f, -0.04751246f, 0.15312804f, -0.02533075f, 
    -0.10260157f, -0.08671818f, -0.10715777f, 0.06541540f, 0.21461342f, 0.35595796f, 0.08378708f, -0.03367408f, 
    0.00626642f, 0.07811478f, 0.49886519f, -0.42161667f, 0.03894679f, -0.22826189f, 0.10299107f, -0.16538632f, 
    0.02451308f, -0.28195632f, 0.15207171f, -0.00925640f, -0.09034506f, -0.13085890f, -0.09416042f, -0.04740996f, 
    0.04450903f, 0.04510394f, 0.14629182f, -0.03351637f, 0.01778597f, 0.15704545f, 0.02028407f, 0.03983534f, 
    -0.08726694f, -0.00856679f, 0.22577663f, -0.06329986f, 0.10232479f, -0.28349522f, -0.14144456f, 0.45310107f, 
    -0.15633494f, -0.09542288f, -0.00195464f, 0.11680327f, 0.02021515f, 0.16631605f, -0.13420095f, 0.14783788f, 
    0.16966723f, -0.21171886f, 0.26688600f, -0.08792470f, 0.25859332f, -0.03167184f, 0.14749727f, -0.14095119f, 
    0.13660841f, 0.36412665f, 0.00524072f, 0.17527100f, 0.04779647f, 0.07062174f, 0.02539921f, -0.13729362f, 
    -0.14656051f, 0.13260505f, -0.16858828f, 0.09892475f, 0.11997985f, -0.28728017f, -0.14580284f, 0.34454304f, 
    -0.11928195f, -0.06528520f, -0.05007094f, -0.42797476f, 0.26369435f, -0.18028980f, -0.12200286f, -0.06094497f, 
    0.11178485f, -0.54492122f, 0.01669015f, 0.25300419f, 0.03066921f, 0.02527212f, -0.12637384f, -0.22403474f, 
    -0.03346269f, -0.09920955f, -0.18406957f, 0.09532037f, 0.12683602f, 0.02873445f, -0.06815356f, -0.25609931f, 
    0.12580888f, 0.26961225f, 0.18496338f, -0.15012060f, 0.01916879f, 0.02698283f, 0.12879883f, -0.16657184f, 
    0.25863579f, 0.26847023f, -0.01803463f, -0.25342235f, -0.32683477f, -0.09416710f, -0.10884118f, -0.04317917f, 
    0.29365367f, 0.41815594f, 0.34558323f, 0.04020314f, 0.01564454f, -0.04364977f, 0.04342630f, -0.30838680f, 
    0.13397051f, 0.37756586f, 0.03732245f, -0.23063178f, 0.03186050f, -0.07773919f, 0.01780763f, -0.14316662f, 
    -0.06902149f, 0.20265527f, -0.15057963f, -0.09611189f, 0.01669570f, 0.46965736f, 0.00585962f, -0.13572650f, 
    -0.20529298f, 0.15508844f, 0.00804101f, 0.13792963f, 0.24299780f, -0.10451520f, 0.21857080f, -0.01409313f, 
    0.01664209f, 0.05263831f, -0.01707268f, 0.00642694f, -0.12461245f, 0.16903439f, 0.01055194f, 0.02218010f, 
    -0.00794949f, -0.11970389f, -0.03287566f, -0.02281227f, -0.01089019f, 0.12146220f, 0.08636583f, -0.05392045f, 
    0.14813147f, -0.04021528f, -0.08991042f, -0.03197717f, 0.14884402f, 0.37485448f, 0.07657690f, -0.34309021f, 
    0.22583188f, -0.02579316f, 0.23534222f, -0.10227970f, -0.24042042f, -0.02831496f, 0.21921490f, -0.03648677f, 
    0.10039724f, 0.03078680f, 0.35439438f, -0.02043639f, -0.16486761f, 0.34744337f, -0.14323290f, 0.15270630f, 
    0.10168816f, -0.01370444f, -0.05768396f, -0.37910393f, 0.12830208f, 0.16337007f, -0.16043591f, 0.12277406f, 
    0.04455354f, 0.15058845f, 0.00413408f, 0.11730038f, -0.24817553f, 0.10264216f, 0.05637125f, 0.03292551f, 
    0.03067486f, 0.13809782f, -0.13853644f, 0.21885452f, 0.01278278f, 0.00301623f, 0.37616000f, 0.09498214f, 
    -0.11054716f, -0.14309748f, 0.32549536f, -0.23246482f, -0.17297323f, 0.24931182f, 0.10114129f, 0.29112041f, 
    -0.05336415f, 0.32870603f, 0.10651358f, 0.17923272f, -0.14406101f, 0.03161360f, -0.04027738f, 0.00182233f, 
    -0.02116990f, -0.21833529f, -0.07668085f, 0.04156837f, -0.14956273f, 0.02411849f, -0.14802036f, -0.09297122f, 
    0.00910280f, 0.04320736f, 0.19359863f, 0.37030795f, 0.37536901f, -0.24892728f, 0.06828412f, -0.17797256f, 
    -0.24522389f, -0.00115610f, -0.07703990f, 0.14145033f, 0.29576868f, -0.13664682f, 0.15548509f, 0.18242869f, 
    -0.05715398f, -0.03332282f, -0.15401909f, 0.09423587f, 0.02315390f, 0.13919666f, 0.09789944f, -0.16180028f, 
    -0.03214633f, 0.21428294f, -0.33532298f, 0.08631321f, 0.24017590f, 0.19375256f, -0.15472670f, -0.15752001f, 
    -0.13435820f, 0.06741920f, 0.21394597f, 0.07806698f, 0.08924966f, -0.20080952f, -0.21368571f, 0.11821708f, 
    0.33688897f, 0.37808076f, 0.02513308f, 0.03450244f, 0.04174614f, -0.13634078f, 0.10217889f, -0.45319563f, 
    0.05295047f, -0.05747206f, -0.04359978f, 0.00307832f, 0.12822463f, -0.01373553f, -0.15740904f, 0.19813049f, 
    -0.13113905f, -0.25315019f, 0.39215368f, 0.14901556f, 0.06711468f, 0.18856148f, -0.07586192f, 0.07672475f, 
    0.15888907f, 0.03796585f, -0.21588132f, 0.06342895f, 0.13971692f, -0.21301092f, 0.11834498f, 0.14378488f, 
    -0.02440953f, 0.15209162f, 0.20231080f, -0.28016505f, -0.00692975f, -0.03095115f, -0.02125444f, 0.19922477f, 
    0.13691746f, -0.12628910f, -0.06154846f, 0.22622252f, -0.14209887f, -0.00082683f, -0.03915244f, -0.16866499f, 
    -0.00592814f, 0.01646611f, -0.02107953f, 0.06138177f, -0.26820225f, 0.06104801f, 0.01862285f, 0.19711630f, 
    0.14737314f, 0.25099489f, -0.17061447f, 0.29174715f, 0.22555442f, -0.17690249f, 0.00625172f, 0.08736213f, 
    -0.23615356f, -0.16524938f, -0.08765847f, -0.04865954f, 0.31031826f, -0.05837187f, -0.13613178f, 0.19122396f, 
    -0.14148203f, 0.19428158f, -0.11003938f, 0.00288410f, -0.17990105f, 0.08937317f, 0.03843380f, -0.13737248f, 
    -0.12448844f, -0.12889019f, -0.24107262f, -0.05577577f, -0.35711846f, -0.28301588f, 0.15241621f, -0.30325925f, 
    0.05612143f, 0.38551036f, -0.01111905f, 0.40937191f, 0.12898292f, -0.26581851f, 0.09107703f, -0.06167458f, 
    -0.19899583f, 0.22685875f, 0.30276096f, -0.09925403f, 0.10265286f, 0.20435183f, 0.15615867f, 0.22464748f, 
    0.08219425f, -0.04578964f, 0.02272609f, -0.30498236f, -0.06586689f, 0.10395025f, 0.09892576f, 0.28869069f, 
    0.19136150f, -0.00127682f, -0.08202289f, 0.08056945f, -0.26397330f, 0.09578504f, -0.02275759f, 0.00033932f, 
    0.24994245f, -0.16825102f, 0.34609452f, 0.30026153f, 0.29367852f, 0.20954408f, -0.27664492f, 0.07644455f, 
    -0.05125295f, -0.09831052f, 0.15410081f, 0.13386168f, -0.06644993f, 0.10939599f, -0.18080185f, 0.22193038f, 
    0.06937282f, 0.05744430f, -0.17478923f, -0.36885217f, -0.12929426f, -0.01149003f, -0.00120169f, 0.25228044f, 
    -0.04296988f, 0.19779208f, 0.28956670f, 0.08681145f, -0.30095857f, 0.38283166f, 0.08150893f, -0.04909772f, 
    0.19564739f, -0.05878768f, 0.25949255f, 0.08227041f, 0.24757187f, 0.19640298f, -0.25854635f, 0.14439544f, 
    -0.07478544f, -0.05962332f, 0.06410687f, 0.17645282f, -0.00602491f, -0.23762190f, -0.03776053f, 0.14446813f, 
    -0.07512728f, 0.06955625f, -0.00935308f, 0.25952083f, 0.17418647f, 0.02416801f, 0.07619238f, -0.00806004f, 
    -0.10302853f, 0.27599564f, -0.27343753f, -0.02367498f, 0.30047950f, -0.20281316f, 0.04032783f, -0.20499745f, 
    -0.15218490f, -0.16565177f, 0.25769937f, 0.17113163f, -0.00306853f, 0.19369613f, 0.27221039f, 0.08325186f, 
    -0.03022094f, 0.32065058f, -0.02186853f, -0.14235865f, 0.21652234f, 0.24836785f, 0.04170001f, -0.28832361f, 
    -0.08402762f, -0.21173981f, -0.11876343f, -0.29807785f, 0.04197019f, 0.14506783f, -0.07892945f, 0.22528674f, 
    -0.17275465f, 0.36183459f, 0.24977246f, 0.13415350f, -0.08981050f, -0.05135040f, -0.10613202f, 0.29712188f, 
    0.04404985f, -0.33179122f, 0.15029499f, -0.13625593f, 0.28230467f, 0.26956272f, -0.26151663f, -0.07607702f, 
    0.27606788f, -0.06076032f, 0.05331433f, -0.02768427f, 0.19909762f, -0.05955158f, -0.16054854f, 0.10567123f, 
    0.12900500f, -0.08908004f, -0.15262368f, 0.11132363f, 0.04284352f, 0.08190591f, 0.00400801f, 0.23676044f, 
    -0.16748354f, 0.00972757f, 0.02761496f, -0.09162559f, 0.17701763f, 0.30894926f, -0.11684619f, 0.20833962f, 
    0.15163699f, -0.17714015f, 0.43786439f, 0.16282690f, -0.03116315f, -0.06382031f, 0.25609332f, -0.16316064f, 
    0.19056113f, -0.30651981f, -0.25831580f, -0.11888962f, -0.11692838f, -0.00269099f, -0.03292388f, -0.17058842f, 
    -0.02607651f, -0.13436659f, 0.13856539f, -0.08863670f, 0.08586002f, 0.01203421f, 0.14254005f, -0.18195349f, 
    -0.10367606f, -0.18807004f, 0.04703187f, 0.06929772f, 0.13571367f, -0.14889698f, 0.03652604f, -0.11038086f, 
    -0.14918303f, -0.06869574f, -0.05760825f, -0.04510484f, -0.02892054f, 0.13436483f, -0.09609123f, -0.14186373f, 
    0.05822420f, -0.05037013f, 0.08106296f, -0.12457068f, 0.01302889f, 0.07006559f, 0.05786299f, -0.06453386f, 
    -0.10814863f, -0.02867183f, -0.04614239f, -0.12213381f, -0.14644483f, 0.04174979f, 0.03061852f, 0.26835182f, 
    -0.09914888f, -0.21870978f, -0.20264263f, 0.14290184f, 0.09189960f, -0.18839599f, 0.06859624f, 0.21118550f, 
    -0.07341370f, 0.36988330f, -0.09947418f, 0.39599910f, 0.17554504f, 0.05639624f, 0.09531517f, 0.13526514f, 
    0.09223063f, -0.26717311f, 0.00667091f, -0.07893991f, 0.22502333f, -0.22727187f, 0.02658312f, 0.34660721f, 
    -0.11594635f, 0.10091583f, -0.14932916f, -0.34512842f, 0.04738563f, -0.05093310f, -0.05971898f, 0.05624205f, 
    -0.13484125f, -0.01183660f, -0.18956564f, -0.15506458f, -0.24487613f, 0.35998702f, 0.12562233f, 0.04512827f, 
    0.26665878f, -0.02356732f, 0.19470458f, 0.21668254f, -0.27499822f, -0.14404958f, 0.23857497f, -0.16461354f, 
    0.02510492f, -0.01715576f, 0.26120189f, -0.23278208f, 0.13213655f, 0.11723048f, 0.01289079f, 0.16112417f, 
    -0.15679470f, 0.07109208f, 0.13659494f, -0.16242170f, 0.08433679f, -0.00805346f, -0.01611672f, 0.20176385f, 
    -0.04447088f, 0.27282608f, -0.18708129f, -0.12068699f, -0.34245777f, -0.18430035f, -0.01370245f, 0.00484853f, 
    0.15539266f, -0.24468793f, -0.13147233f, 0.15795673f, 0.15657468f, 0.42330387f, -0.01875093f, -0.01512574f, 
    -0.12856130f, 0.03422739f, 0.26635706f, 0.09179494f, 0.11978893f, 0.39045352f, -0.11928559f, 0.13757247f, 
    0.04194729f, -0.03883776f, 0.04972147f, -0.04132842f, -0.02986953f, 0.11115971f, -0.09773783f, 0.07953729f, 
    -0.04195018f, -0.22576195f, -0.05421828f, 0.17451541f, 0.00607159f, 0.37501335f, 0.12244882f, -0.13324648f, 
    -0.12164379f, 0.20368418f, -0.05116620f, 0.08183860f, 0.23813319f, -0.51942647f, -0.04150937f, 0.07535026f, 
    0.25617501f, 0.18889685f, -0.02343766f, 0.04033414f, 0.05847481f, -0.14533879f, -0.05779528f, -0.31050599f, 
    0.06742798f, -0.22380722f, 0.03852462f, -0.04617866f, -0.03646889f, -0.10315958f, 0.05915620f, -0.06418508f, 
    0.08706271f, 0.33157611f, 0.28106397f, 0.08263233f, 0.17691578f, 0.16542499f, -0.05818747f, 0.10057474f, 
    0.21955085f, 0.07586190f, -0.23691568f, 0.09791145f, -0.35335466f, 0.05991477f, 0.02871278f, 0.15769567f, 
    0.16791627f, 0.09771229f, 0.10243542f, 0.08811783f, -0.08501835f, -0.20054193f, 0.10965139f, -0.25982159f, 
    -0.10430049f, -0.11137731f, -0.11251421f, 0.05439699f, -0.10624161f, -0.12117325f, 0.10989839f, 0.07092765f, 
    0.00466324f, 0.07489839f, -0.02672189f, -0.15639943f, -0.10016080f, 0.46532580f, 0.06367643f, -0.21872833f, 
    0.07560357f, 0.25385144f, 0.12882578f, 0.31955612f, -0.14610855f, 0.07966697f, 0.07176759f, 0.17283522f, 
    -0.13417980f, 0.20020112f, -0.12678373f, -0.18970951f, 0.09814426f, 0.08091430f, -0.13732289f, 0.20935027f, 
    0.07346296f, 0.43381888f, 0.16947171f, 0.28651485f, -0.10816678f, 0.01775937f, -0.04082302f, -0.31364143f, 
    0.16004214f, 0.17862874f, -0.13595094f, 0.09142271f, 0.05192071f, 0.25211030f, 0.08258219f, -0.01963096f, 
    0.02153505f, -0.17197846f, 0.04149592f, -0.21370472f, 0.16604206f, 0.40172353f, 0.29882580f, -0.04282883f, 
    0.02204637f, -0.18759163f, -0.35599747f, 0.00099053f, 0.21617238f, 0.32448536f, 0.01034375f, -0.24531233f, 
    -0.16875185f, 0.01674917f, 0.06989343f, 0.18252976f, 0.15984131f, -0.02072223f, 0.09299210f, -0.01660573f, 
    0.04693561f, 0.23349839f, 0.00055614f, 0.09317813f, 0.26190504f, -0.42359081f, 0.14912306f, -0.03039197f, 
    0.00438348f, -0.18049468f, 0.32975775f, 0.00346414f, 0.14801118f, 0.21195947f, -0.19039458f, 0.08673495f, 
    -0.03348569f, 0.26411209f, 0.07481096f, 0.09195664f, 0.14402646f, -0.06865510f, 0.03823306f, -0.21688432f, 
    0.09110795f, -0.15739170f, 0.08409239f, 0.04277601f, -0.15217502f, -0.07143151f, 0.15640905f, 0.00225711f, 
    0.05951625f, 0.13342525f, 0.36995661f, -0.02696009f, -0.31988883f, 0.31217787f, 0.04546923f, 0.20608570f, 
    0.16391999f, -0.05636164f, -0.10792711f, 0.25853685f, -0.08629555f, 0.30689991f, 0.12843297f, -0.02168858f, 
    -0.01894595f, -0.30328798f, -0.24939059f, 0.06549566f, 0.18842305f, -0.08219679f, -0.08993106f, -0.13419922f, 
    -0.05660365f, 0.06664200f, -0.03097637f, 0.07663889f, 0.03671854f, 0.14139742f, 0.16016546f, 0.04179423f, 
    -0.02611769f, -0.05590865f, -0.18167427f, -0.13598876f, -0.18302408f, -0.02299096f, 0.07209979f, 0.06277677f, 
    -0.04505406f, -0.09814162f, -0.18614733f, -0.00284871f, -0.14524905f, 0.13377830f, -0.16361956f, 0.02177492f, 
    -0.04648718f, -0.16673905f, 0.02379004f, -0.05321437f, -0.01830135f, -0.04548718f, 0.11874994f, -0.14060262f, 
    -0.11832962f, -0.30761340f, 0.14542025f, 0.35126671f, 0.05086643f, 0.16897491f, -0.03779102f, 0.08751638f, 
    0.11805959f, -0.10301875f, -0.19089852f, 0.15816045f, -0.04283573f, -0.02522448f, -0.09084074f, 0.27035484f, 
    0.27775267f, -0.40293041f, 0.25714394f, 0.00122106f, -0.11051109f, -0.05395680f, 0.18748862f, 0.07224204f, 
    -0.04258454f, -0.31518510f, 0.10064318f, 0.36243281f, 0.19446582f, 0.08334879f, 0.00524941f, 0.06014149f, 
    -0.04185931f, 0.10908713f, 0.03014439f, 0.28679350f, 0.02295228f, 0.01476486f, -0.14131647f, -0.17643391f, 
    0.11314036f, 0.14003012f, 0.23304540f, 0.01390390f, 0.32619721f, 0.05721225f, 0.13030194f, -0.24162206f, 
    0.18680787f, -0.11240564f, 0.22063458f, -0.05688958f, -0.19757561f, -0.20541874f, 0.00092550f, -0.05535032f, 
    0.08088102f, 0.22045599f, 0.06632315f, 0.18952848f, -0.02683376f, -0.25171021f, 0.07913625f, -0.16521443f, 
    -0.02618337f, -0.06456975f, -0.02914469f, 0.10844096f, 0.04332310f, -0.08837067f, 0.00268255f, 0.04418018f, 
    0.04127547f, -0.02002009f, -0.26617724f, -0.08629899f, 0.21534966f, 0.41585165f, -0.09116116f, -0.17242788f, 
    0.00970678f, 0.21244061f, 0.35738492f, -0.14062287f, -0.15397196f, -0.11850735f, 0.06035352f, 0.04567256f, 
    0.11082478f, -0.09226441f, 0.04667143f, 0.09945241f, -0.14706887f, 0.23067340f, 0.06986794f, 0.10104233f, 
    0.00457176f, -0.20017700f, -0.07870132f, 0.19905162f, 0.16001976f, -0.07836404f, -0.17715266f, 0.10277882f, 
    -0.15197854f, -0.03755335f, 0.05022074f, 0.06351763f, 0.16356826f, 0.15827496f, 0.12985326f, -0.06397823f, 
    0.10121530f, 0.14484932f, 0.34074351f, -0.01090122f, -0.34710315f, -0.21617721f, 0.04180776f, -0.04506081f, 
    0.30308917f, 0.15380515f, 0.18016888f, 0.18744278f, -0.16550921f, -0.13468750f, 0.11402113f, -0.26687136f, 
    -0.06664658f, -0.11288486f, -0.07635177f, -0.02071482f, 0.11339917f, -0.02949064f, -0.02964390f, 0.02353563f, 
    0.04890956f, -0.00435975f, -0.22437321f, -0.17456628f, -0.01991093f, -0.41696993f, 0.02420082f, 0.29619357f, 
    -0.10358938f, -0.06499601f, 0.21181689f, 0.27406058f, 0.06677552f, 0.29949903f, 0.18394335f, 0.15510418f, 
    -0.10577458f, -0.21900533f, 0.21872157f, 0.07574564f, 0.07699291f, -0.02023142f, -0.17694257f, 0.21186310f, 
    -0.12608276f, 0.24275103f, 0.10129251f, 0.09226184f, 0.05990143f, 0.14243521f, -0.02487415f, 0.24056408f, 
    0.13530673f, 0.05727435f, -0.21332528f, 0.08979663f, 0.21268092f, -0.30091736f, -0.17008989f, 0.05745525f, 
    -0.21799335f, 0.12347590f, -0.02169941f, 0.13635495f, -0.01956550f, -0.28999057f, 0.05194389f, 0.05792764f, 
    -0.07986844f, 0.09878349f, 0.10055134f, 0.26988885f, 0.14710028f, 0.16207857f, 0.17979786f, -0.01817893f, 
    -0.02007724f, 0.33376399f, 0.07882244f, 0.37708673f, 0.15808265f, -0.04657368f, 0.01559613f, -0.10040037f, 
    -0.10234717f, 0.02965937f, -0.10581662f, 0.15948474f, 0.13560516f, 0.07197200f, 0.05095467f, 0.13302360f, 
    -0.17657211f, 0.07166824f, -0.34939280f, -0.11218305f, 0.26656395f, -0.02280898f, -0.00269950f, 0.10802123f, 
    0.02545058f, 0.00612085f, 0.07994297f, 0.11751865f, 0.10574418f, 0.25014311f, -0.15358503f, -0.05856340f, 
    0.14022835f, 0.23632114f, -0.12373887f, -0.12938230f, 0.17822133f, -0.13397647f, 0.15601204f, -0.21126854f, 
    0.00169797f, -0.04968186f, 0.34319496f, -0.01129012f, -0.19265005f, -0.02244951f, 0.08131094f, -0.21591380f, 
    0.23878802f, 0.43623415f, 0.03574230f, -0.20516919f, 0.25361621f, -0.07627665f, 0.03633940f, -0.10349663f, 
    -0.10558905f, -0.28461096f, -0.02490370f, -0.10807936f, 0.10207009f, 0.05819270f, -0.11713906f, -0.03250838f, 
    0.10788751f, -0.01624461f, -0.00885767f, 0.01693885f, 0.14763369f, 0.02736979f, 0.12430397f, 0.35241169f, 
    0.07814220f, 0.09895404f, 0.23943518f, -0.04280894f, 0.09184562f, -0.28226739f, -0.16999312f, 0.16932960f, 
    0.06083166f, -0.07858020f, 0.18413460f, -0.21793954f, -0.00077683f, 0.01374349f, -0.27289808f, -0.14505297f, 
    0.30025247f, 0.28983548f, 0.36929429f, 0.15543780f, -0.06164413f, -0.26376843f, -0.03633951f, 0.09650545f, 
    0.03213863f, -0.08980203f, -0.15170212f, -0.15419410f, 0.10427035f, -0.14251690f, -0.11038074f, 0.19332233f, 
    -0.07012711f, -0.11994470f, 0.07686684f, 0.02560200f, -0.08357424f, -0.32618541f, 0.02109915f, 0.17657034f, 
    0.12563182f, 0.09682381f, -0.07715826f, -0.13518286f, 0.33681855f, 0.07267144f, -0.21972571f, 0.06762759f, 
    0.19402871f, -0.17538482f, 0.26418549f, 0.25033244f, 0.21603020f, -0.27494633f, -0.11690161f, 0.21039709f, 
    -0.10880430f, 0.24224101f, 0.02750349f, 0.30619702f, 0.04372128f, 0.13011451f, 0.00139900f, 0.06687308f, 
    -0.07368322f, 0.13868278f, -0.00755756f, -0.06809063f, 0.34178761f, 0.49877757f, -0.08911610f, -0.21050805f, 
    -0.16248217f, -0.01279210f, 0.03685832f, 0.14300683f, 0.05178547f, -0.23984881f, 0.23455285f, -0.01850187f, 
    -0.02900625f, 0.19827618f, 0.07341395f, 0.27523506f, -0.00626426f, 0.05268697f, 0.07357190f, -0.08451044f, 
    0.02444665f, 0.15792359f, -0.00072989f, -0.04074730f, -0.00945668f, 0.08054823f, 0.01631831f, -0.18723388f, 
    0.12968704f, -0.11480776f, 0.25637791f, -0.06789387f, 0.24138050f, -0.18004939f, -0.10490807f, 0.17096786f, 
    0.28388667f, 0.00800198f, 0.09603824f, -0.39777380f, 0.25636500f, 0.38070315f, -0.13427223f, 0.02509708f, 
    -0.05495666f, -0.19171044f, -0.43817455f, 0.11582785f, -0.08067518f, 0.19446118f, -0.15677609f, -0.06263762f, 
    -0.04633398f, 0.43118709f, 0.01497611f, -0.00806160f, -0.04785434f, -0.04768123f, -0.04661593f, -0.23151305f, 
    0.08904060f, 0.00139669f, -0.06861760f, 0.08003393f, 0.19756351f, -0.26152363f, -0.07821281f, -0.06481909f, 
    -0.18586671f, 0.18099514f, 0.19865960f, -0.14254230f, 0.36031204f, 0.30627194f, -0.15822157f, -0.06922389f, 
    -0.05544328f, 0.08235560f, -0.34026608f, 0.09477419f, -0.12190176f, 0.27340755f, -0.06612378f, 0.09095124f, 
    -0.01994066f, 0.34242508f, -0.17118266f, -0.17080833f, 0.04275140f, -0.15220092f, -0.14418095f, -0.50179702f, 
    -0.17191805f, 0.32938680f, -0.21681939f, 0.11192647f, -0.02814157f, -0.28732535f, 0.11565510f, -0.11857790f, 
    0.00414602f, -0.07405148f, 0.09287485f, 0.07385882f, 0.00485129f, -0.04894233f, 0.28993750f, 0.16762760f, 
    0.12764311f, 0.03007040f, 0.25787950f, -0.29008988f, 0.30228835f, 0.25071576f, 0.00499177f, -0.21905781f, 
    -0.17040339f, -0.05750272f, -0.16264798f, 0.04248179f, 0.09492514f, -0.05876621f, -0.15127619f, 0.17636439f, 
    0.11554158f, 0.21876203f, -0.43781593f, 0.11388122f, -0.23284103f, -0.12217288f, 0.05648344f, -0.11159845f, 
    0.10970049f, -0.16529243f, 0.11225817f, 0.39436579f, -0.18629640f, 0.10924792f, 0.12274354f, 0.08359844f, 
    -0.12927064f, -0.08201742f, 0.39577782f, -0.11026483f, 0.19169396f, 0.14150029f, 0.10910386f, 0.03089711f, 
    0.16282517f, -0.30909106f, -0.16615671f, -0.04222783f, -0.11023945f, 0.07357700f, 0.01838926f, -0.13169037f, 
    0.05897247f, 0.23394759f, 0.00892750f, 0.07175656f, -0.16832104f, 0.28366476f, 0.07385219f, 0.12096027f, 
    0.35436946f, -0.16283174f, 0.09411281f, 0.24937880f, -0.15343006f, 0.35153103f, -0.02479965f, -0.04880714f, 
    0.11496431f, 0.17102771f, 0.14808214f, -0.15305850f, -0.17049174f, 0.14058249f, -0.12652038f, 0.08314156f, 
    -0.15535967f, 0.33482549f, 0.06254726f, 0.15278505f, 0.12490975f, -0.07699368f, 0.00188131f, -0.05802473f, 
    -0.01121387f, -0.13338599f, 0.01708111f, -0.05324255f, 0.37131009f, 0.07151145f, 0.14112802f, -0.15341504f, 
    0.01470981f, -0.14613941f, 0.49666414f, -0.19685258f, -0.12985760f, -0.16727161f, 0.28825584f, 0.15930606f, 
    0.07833511f, -0.21592309f, 0.36157066f, 0.10598557f, -0.14258674f, -0.00608369f, 0.14864632f, -0.21680231f, 
    0.02669326f, -0.06849472f, 0.07672302f, -0.34504229f, -0.04666901f, 0.02055321f, -0.11042000f, 0.29489884f, 
    0.11248984f, -0.24644716f, 0.25402734f, 0.09344314f, -0.10586274f, -0.29862845f, -0.04515811f, -0.01320708f, 
    0.04593742f, 0.11290810f, -0.13235216f, 0.02966054f, 0.09259433f, 0.03897639f, 0.19558878f, -0.05075587f, 
    0.00197177f, -0.24830396f, 0.33066264f, -0.20433132f, -0.11136984f, 0.20746626f, -0.11536235f, 0.44514504f, 
    0.17654705f, -0.00494023f, 0.03844391f, 0.30956072f, -0.10090457f, -0.13613307f, -0.13750823f, -0.26131761f, 
    -0.07449536f, -0.17144220f, 0.20146540f, 0.17309950f, -0.02512746f, -0.12334046f, -0.15496302f, -0.17330022f, 
    0.30401111f, 0.17337187f, 0.07610563f, 0.14803305f, -0.26537424f, -0.31773281f, 0.22664087f, -0.02873732f, 
    0.07516600f, -0.11935302f, 0.24183415f, 0.13427138f, 0.28594422f, -0.10555332f, 0.14572860f, -0.33002284f, 
    -0.05752699f, -0.35326317f, 0.09462413f, -0.11742174f, 0.00574595f, -0.11021718f, -0.12048015f, 0.17002596f, 
    -0.10633124f, -0.31289822f, -0.14736629f, 0.00408079f, 0.08743498f, -0.39239490f, 0.04718446f, 0.17863265f, 
    0.20114864f, 0.24915709f, 0.42464975f, 0.26393369f, 0.14698011f, 0.00745232f, -0.17508546f, -0.14605615f, 
    -0.04183896f, 0.06905869f, 0.16262671f, -0.18931474f, -0.06291997f, -0.16831653f, 0.03192014f, 0.32056847f, 
    0.07367954f, -0.00079672f, 0.02779027f, 0.06604983f, -0.11838668f, 0.08782448f, -0.12390553f, -0.03462262f, 
    0.13997422f, -0.11676988f, -0.03363610f, -0.11080489f, -0.06915247f, -0.23356129f, -0.12155852f, 0.37126511f, 
    0.17582607f, -0.16065584f, 0.14934830f, -0.17536321f, 0.27066821f, 0.49745676f, -0.15635742f, 0.10745899f, 
    0.16597462f, -0.17347814f, -0.46398690f, 0.04731966f, -0.21551092f, 0.07251395f, 0.12832716f, 0.11820617f, 
    0.09426235f, 0.22430979f, -0.15645884f, 0.06592660f, -0.09453032f, -0.01177109f, 0.10677063f, 0.17820820f, 
    0.00044167f, -0.10471630f, -0.35141087f, -0.05787540f, 0.26325843f, 0.10119636f, -0.00467988f, -0.18219174f, 
    -0.12925091f, 0.22907405f, 0.17039955f, 0.26612476f, 0.14819701f, -0.35156181f, 0.12212393f, 0.08915654f, 
    0.11480474f, -0.09890364f, 0.26401612f, -0.15774739f, 0.09345753f, 0.05152952f, 0.03397984f, 0.20785546f, 
    0.02703419f, 0.12085355f, -0.13367701f, 0.01725179f, -0.17422931f, -0.03309078f, -0.08739627f, -0.31875110f, 
    -0.01137116f, 0.41518429f, -0.59830087f, -0.03632921f, 0.17876771f, 0.29210070f, 0.03022503f, -0.37827435f, 
    0.09178591f, 0.10165416f, -0.02959161f, -0.19219221f, -0.03791486f, 0.00269808f, -0.30141565f, -0.09194873f, 
    0.18973455f, 0.22294725f, -0.04415208f, -0.27864036f, 0.13065033f, -0.12950672f, 0.01004452f, -0.36101231f, 
    0.10943258f, 0.04385715f, -0.11460416f, -0.06530516f, 0.11778782f, -0.01775631f, -0.03655746f, 0.07519499f, 
    0.12803745f, -0.02544300f, -0.08265850f, -0.15616849f, 0.10804249f, -0.00900898f, 0.15769273f, -0.16961020f, 
    -0.07601573f, -0.10987952f, -0.05877654f, -0.17142126f, -0.02243738f, -0.12227873f, 0.02202984f, 0.12645182f, 
    -0.15863453f, 0.06961980f, 0.07490063f, -0.18128601f, -0.04789731f, 0.08182874f, 0.07154804f, -0.05637071f, 
    0.10904490f, -0.27551255f, -0.13051872f, 0.20347883f, -0.02536632f, -0.14729258f, -0.10893536f, 0.00366523f, 
    -0.16620182f, 0.06302763f, 0.04109574f, -0.03591099f, 0.38568324f, -0.10426147f, -0.04217646f, 0.07939740f, 
    0.17624564f, 0.32165521f, -0.11231947f, -0.01007800f, -0.29706222f, -0.14528894f, -0.03903628f, 0.13683644f, 
    0.41461012f, 0.05838837f, -0.05532898f, 0.01498654f, -0.08396558f, -0.23446165f, 0.16391464f, 0.14357847f, 
    0.15844183f, -0.30438951f, 0.05880240f, 0.11277027f, 0.15376946f, 0.17921305f, 0.17407241f, 0.17081331f, 
    -0.08198331f, 0.36232665f, -0.04334237f, 0.02951171f, 0.42986080f, 0.30822283f, 0.17143933f, 0.27386308f, 
    0.10453840f, 0.18505587f, -0.13953634f, -0.12075390f, -0.06286865f, 0.21744858f, -0.13521253f, -0.01032892f, 
    0.24116005f, 0.03175646f, -0.08205766f, 0.00770790f, -0.20306128f, -0.55864447f, 0.16198982f, -0.25662526f, 
    -0.09197473f, 0.10631608f, 0.02774080f, 0.16827920f, 0.06161866f, -0.16744661f, -0.02306912f, -0.31085351f, 
    0.05048126f, 0.21532795f, 0.25430295f, -0.13872865f, -0.08853266f, -0.51027793f, 0.12130355f, 0.23098777f, 
    0.05419956f, -0.01226758f, -0.01281699f, -0.14133593f, 0.30346945f, 0.37906724f, -0.18194753f, 0.05684683f, 
    -0.08453702f, -0.00531866f, -0.15942965f, 0.04570515f, -0.03241674f, 0.19580646f, -0.07598970f, -0.22003503f, 
    -0.12618667f, -0.11181416f, -0.02815709f, -0.17286712f, 0.02788407f, 0.13319281f, 0.14697623f, -0.02325114f, 
    -0.05196747f, 0.26280868f, 0.34758505f, 0.15937777f, 0.10522991f, 0.16858557f, -0.09979077f, 0.20533322f, 
    0.22361428f, -0.16990185f, 0.18753238f, -0.17167188f, -0.13576710f, -0.07251579f, -0.00493427f, 0.12196768f, 
    0.36255166f, 0.21714959f, 0.32031211f, 0.07085131f, -0.03214552f, -0.34029889f, 0.01670343f, -0.16683152f, 
    -0.02322827f, 0.58145195f, -0.13161737f, 0.36791760f, -0.01262214f, 0.14656629f, 0.06802354f, -0.09729370f, 
    0.12975344f, 0.00607510f, -0.22402032f, 0.02452723f, 0.02023422f, -0.00433261f, 0.04903360f, -0.12411647f, 
    -0.30405280f, 0.25035557f, -0.12247334f, 0.08413317f, 0.27054757f, -0.06339823f, 0.20290278f, -0.01350331f, 
    -0.17797214f, 0.05849602f, 0.11508375f, 0.27409977f, 0.20898135f, 0.03290853f, 0.13737696f, -0.01139888f, 
    0.12219395f, 0.04704067f, -0.13511124f, 0.16406833f, -0.11987581f, -0.04385630f, -0.16054380f, -0.39512977f, 
    -0.06762627f, 0.37901238f, 0.25896090f, 0.12872395f, 0.19085465f, 0.07771021f, 0.10006153f, 0.14736904f, 
    0.23276311f, -0.24619523f, 0.34977090f, -0.37432241f, -0.11732478f, 0.35362807f, -0.05821620f, -0.12414809f, 
    0.27493036f, -0.23929399f, 0.10162554f, -0.19998226f, -0.09807879f, -0.06733823f, 0.11873154f, -0.23719999f, 
    0.04343319f, 0.05836948f, -0.07791618f, -0.15283991f, -0.16019876f, 0.00348700f, 0.08203081f, -0.01881930f, 
    0.06917495f, -0.03804149f, -0.14795661f, -0.01708151f, -0.07029433f, -0.10003331f, -0.13280699f, 0.09163138f, 
    -0.01881667f, -0.15113597f, 0.00531575f, -0.02399174f, 0.00441905f, 0.01198715f, -0.17370299f, -0.04120099f, 
    0.00968090f, -0.04330523f, -0.04158767f, -0.16201469f, -0.13682799f, 0.09520914f, -0.07358555f, -0.04070996f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04986561f, -0.00222787f, 0.15675434f, 0.21909700f, -0.02721554f, 0.03715500f, 0.09403664f, 0.20818380f, 
    -0.11250324f, 0.12248500f, -0.09866382f, -0.05848778f, 0.13164534f, 0.14759023f, -0.06924530f, 0.16478354f, 
    -0.02723271f, 0.14587423f, -0.03949680f, 0.05942492f, 0.25761646f, 0.04620062f, 0.14441408f, 0.19854210f, 
    -0.06176531f, 0.26666030f, 0.05642933f, 0.26412183f, -0.13479573f, -0.09189262f, -0.00978043f, -0.18078075f, 
    0.05380192f, 0.14431211f, 0.15630428f, 0.08948413f, 0.11135008f, -0.07547763f, -0.03185583f, -0.16217496f, 
    0.00355080f, -0.10962848f, 0.22752091f, 0.05936529f, 0.04756522f, 0.03782391f, -0.04200059f, 0.09995461f, 
    0.04376204f, 0.14470543f, 0.15515353f, 0.00722100f, 0.05787047f, 0.04616698f, -0.00479253f, 0.05910593f, 
    0.13047661f, -0.06036375f, 0.32554185f, -0.13407262f, -0.07858774f, 0.02758992f, -0.02616305f, 0.01831739f, 
    0.26713559f, 0.05655700f, -0.11320988f, 0.18169422f, -0.05392026f, 0.06609747f, 0.11609197f, 0.07484796f, 
    0.29485774f, -0.16289356f, 0.08445181f, 0.02963572f, -0.09002843f, 0.12904149f, -0.16197707f, 0.10023393f, 
    0.20147032f, -0.02280742f, 0.26890013f, -0.20690353f, 0.20559329f, -0.26025242f, 0.03670992f, 0.18244003f, 
    -0.02185969f, 0.05888591f, 0.20262311f, 0.03170456f, -0.14428328f, 0.07283870f, 0.06259661f, -0.14940399f, 
    -0.04603407f, 0.07745752f, -0.13187419f, 0.05214207f, 0.19288120f, 0.23167251f, 0.09132265f, 0.21356787f, 
    0.21802917f, -0.04731930f, 0.29779130f, -0.05127013f, 0.02209456f, 0.01249849f, -0.08478100f, -0.05403743f, 
    0.08221981f, -0.06515639f, -0.03284716f, -0.03567068f, 0.19760275f, 0.03041852f, -0.15600546f, -0.02773039f, 
    0.05392846f, 0.02990371f, -0.13098069f, 0.10642913f, 0.07871304f, 0.12443189f, 0.21591587f, -0.15152392f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05621862f, 0.04373590f, -0.05384941f, -0.12750258f, -0.33739659f, 0.02441311f, -0.15738207f, -0.27193883f, 
    -0.04823668f, 0.04043315f, -0.51912260f, 0.17473519f, -0.03492786f, 0.17790334f, -0.28085801f, 0.22113220f, 
    0.05545224f, 0.10062540f, -0.05807542f, -0.03914306f, -0.28145903f, -0.02120735f, 0.28437504f, -0.32926291f, 
    -0.11465550f, -0.32900706f, 0.07061274f, 0.35792509f, -0.43057606f, -0.16706882f, -0.01061911f, -0.31836459f, 
    -0.41600433f, -0.42861924f, -0.28583479f, 0.05323587f, 0.02928547f, -0.15628603f, -0.22719125f, -0.07068755f, 
    -0.04656098f, -0.19648951f, 0.12654541f, 0.18816826f, -0.10535166f, -0.03229506f, 0.19402064f, 0.09951034f, 
    0.08498963f, -0.01555952f, -0.06071767f, -0.15339771f, 0.05546723f, 0.03161269f, -0.28724721f, -0.19599263f, 
    -0.31515488f, 0.03941747f, -0.04901322f, 0.03879111f, -0.08350953f, 0.01228633f, 0.07142545f, -0.21473639f, 
    -0.02076321f, 0.21975364f, 0.46082953f, -0.36352739f, 0.09040648f, 0.48788202f, -0.13142213f, -0.10248334f, 
    0.07869504f, -0.14847951f, 0.27692968f, -0.25279254f, 0.02390840f, 0.02680956f, -0.33870450f, -0.23803543f, 
    0.06683619f, 0.13433807f, 0.10785211f, 0.10599599f, -0.08888179f, 0.19703321f, -0.07663916f, -0.28072602f, 
    0.13248515f, -0.28287265f, -0.13679963f, -0.26628482f, -0.00250703f, -0.16922742f, 0.14747183f, -0.20625851f, 
    0.04796818f, 0.15955143f, 0.19071551f, 0.34253639f, 0.39634794f, 0.05611081f, -0.03588033f, -0.59728765f, 
    -0.04864974f, 0.10132547f, -0.08353395f, -0.02271953f, -0.01641015f, -0.02700344f, -0.09278450f, 0.19303294f, 
    0.05461890f, 0.60426885f, -0.31274974f, 0.23153891f, 0.24845323f, -0.01918272f, 0.06405360f, -0.34224415f, 
    0.03258535f, -0.04569948f, -0.28280848f, -0.06216837f, 0.07212486f, -0.22205099f, 0.26907521f, 0.03324863f, 
    -0.11457210f, 0.01975364f, 0.13453129f, -0.19330548f, -0.13504946f, -0.02310383f, -0.27424580f, -0.23861010f, 
    -0.01565599f, -0.12899846f, 0.05069403f, 0.02310533f, 0.00177106f, 0.19386472f, -0.33097154f, 0.15484089f, 
    0.02158788f, 0.08510902f, -0.05515116f, -0.00678634f, 0.11607314f, -0.03987116f, 0.13274299f, 0.27900180f, 
    0.16301595f, -0.13847712f, -0.10715783f, 0.33421561f, 0.10902908f, -0.31064740f, 0.01575680f, -0.54893398f, 
    -0.55011582f, -0.05729049f, 0.15052107f, -0.48292431f, -0.22105542f, -0.07110920f, -0.49686632f, -0.04450938f, 
    0.01909704f, -0.01458259f, 0.10355167f, 0.10918972f, -0.00180770f, 0.02601765f, -0.17106034f, 0.25385660f, 
    0.27360716f, 0.03146205f, -0.25617069f, 0.18079112f, 0.02887718f, -0.21098886f, -0.16790916f, -0.08360609f, 
    0.13936928f, -0.02826798f, 0.19499753f, -0.04830501f, -0.29917863f, -0.07493210f, -0.38614410f, -0.44111350f, 
    -0.01352915f, 0.31234217f, -0.21452063f, 0.14406158f, 0.16108912f, -0.21979712f, 0.06751856f, -0.35868660f, 
    -0.00907135f, -0.06926218f, 0.06910648f, 0.09611099f, 0.01989821f, 0.15746975f, -0.06277298f, 0.01825901f, 
    0.15527536f, 0.14171934f, 0.08828029f, -0.31156370f, 0.04387221f, -0.14283571f, -0.04166556f, 0.23127364f, 
    0.08422662f, 0.12318792f, 0.13024360f, 0.06198374f, -0.04263637f, -0.61351603f, -0.11939862f, -0.09169037f, 
    -0.03132897f, 0.05509455f, -0.21448840f, 0.18850891f, 0.06913764f, 0.16083162f, 0.15221113f, -0.10928198f, 
    -0.08255690f, 0.13292544f, 0.21162729f, -0.08739519f, -0.33514622f, -0.27592862f, -0.54967529f, 0.13184720f, 
    0.05871806f, -0.23397174f, 0.36369696f, -0.09546871f, 0.13998806f, -0.22736187f, 0.08011084f, -0.14812203f, 
    0.01749516f, 0.08262420f, -0.03721069f, -0.22190824f, 0.01538220f, -0.09214234f, -0.69770527f, 0.05528253f, 
    0.06860344f, -0.14182408f, 0.19456886f, -0.12761593f, -0.31239149f, -0.06873170f, -0.13574791f, -0.30342621f, 
    -0.00261249f, -0.35316670f, 0.37436658f, -0.03787982f, 0.04027599f, 0.02327943f, -0.19720423f, -0.14177537f, 
    -0.26269093f, 0.13857944f, -0.06863729f, -0.05611650f, 0.22168599f, 0.25603467f, -0.22608276f, -0.02134858f, 
    -0.31042743f, 0.10953848f, 0.33928022f, -0.04861672f, -0.54809088f, -0.09437090f, 0.03641466f, -0.27393639f, 
    0.23888674f, -0.18372338f, 0.01867687f, -0.26331556f, -0.00740807f, -0.08574300f, 0.01280486f, -0.01830391f, 
    0.09595027f, -0.61602938f, -0.22713159f, -0.32577133f, 0.20119174f, -0.37157997f, 0.15850018f, -0.38717118f, 
    0.13311099f, -0.17725298f, -0.03015241f, -0.53103447f, -0.02524954f, 0.24134225f, 0.14666152f, -0.08963509f, 
    -0.24286126f, 0.03454337f, 0.01202248f, -0.07433253f, 0.22005707f, 0.04410629f, -0.10710051f, -0.26838213f, 
    -0.03672613f, 0.02241816f, -0.41005832f, -0.19197260f, 0.05382165f, -0.49634725f, 0.06877108f, 0.03022628f, 
    -0.59249949f, -0.06566495f, -0.25213853f, 0.05147843f, 0.16980290f, -0.38516271f, -0.07766916f, 0.23283274f, 
    0.16388966f, -0.00284946f, -0.13034396f, 0.22750974f, -0.11366823f, 0.18991636f, -0.02266604f, 0.26921549f, 
    0.15647230f, 0.01526167f, -0.17418434f, -0.01565461f, 0.13215321f, 0.12948434f, -0.03697602f, 0.17971736f, 
    -0.07318142f, 0.14402965f, -0.27490136f, -0.42975014f, -0.38650709f, 0.19610277f, 0.11243255f, -0.08774354f, 
    -0.18457916f, -0.30688405f, -0.18010537f, -0.04339010f, -0.31562528f, -0.26190385f, 0.21346115f, 0.45049781f, 
    0.05752695f, -0.29495630f, -0.33716732f, 0.21411793f, -0.08257084f, -0.04973220f, 0.03430013f, -0.41867226f, 
    -0.01800957f, -0.41345391f, -0.70675224f, -0.05238291f, -0.27835658f, 0.12639385f, -0.32278976f, 0.06770705f, 
    -0.08311467f, 0.30062231f, -0.02682240f, -0.02646525f, -0.24882762f, -0.04325838f, 0.00935768f, 0.00700069f, 
    0.02879734f, 0.13322687f, -0.15312873f, 0.07622582f, 0.01595417f, -0.07111285f, -0.14109604f, 0.10678778f, 
    0.16192177f, -0.07940540f, 0.01971431f, 0.05558401f, -0.27761075f, -0.54740417f, -0.12294417f, -0.02866952f, 
    0.04355871f, -0.45207006f, 0.14236781f, -0.00256615f, -0.34824702f, 0.22694080f, -0.01113793f, -0.49755809f, 
    0.22518462f, 0.07443800f, -0.04264938f, -0.42225331f, 0.15231809f, -0.07733107f, -0.18710467f, -0.05498199f, 
    0.25069445f, -0.04228122f, -0.19899841f, 0.17507522f, 0.07002695f, -0.03787059f, 0.17803498f, -0.37729177f, 
    -0.23976921f, 0.08001148f, 0.19764735f, 0.12010310f, 0.05985835f, -0.12670870f, -0.33526656f, -0.12767701f, 
    0.06032120f, -0.02730216f, -0.24217620f, 0.05192294f, 0.13504601f, -0.01851909f, 0.13605000f, -0.52393425f, 
    -0.26887077f, -0.07202377f, 0.18697897f, -0.24735098f, -0.44452286f, 0.22808990f, 0.05279351f, 0.27867377f, 
    0.03315083f, -0.07055649f, 0.10925893f, 0.03575326f, -0.12366739f, 0.15244216f, 0.23105615f, -0.12505926f, 
    -0.24750431f, -0.56320250f, -0.56079513f, 0.02196119f, -0.38810831f, 0.11319411f, -0.04544798f, 0.11027036f, 
    -0.26409516f, -0.93861973f, -0.07451785f, -0.08346588f, -0.23794155f, 0.00698814f, 0.02225610f, -0.36285287f, 
    -0.01010143f, -0.00869219f, 0.11655332f, 0.20094302f, 0.25278899f, -0.04040744f, 0.17762521f, 0.12386093f, 
    -0.03122279f, -0.01113382f, -0.10499567f, 0.11596086f, 0.08873825f, 0.11087136f, -0.01887944f, -0.17178617f, 
    -0.39630643f, 0.41632608f, 0.41455951f, 0.15156288f, -0.04811903f, -0.05600527f, 0.17391904f, -0.00226855f, 
    -0.04251266f, 0.20100404f, 0.09023829f, -0.10373994f, -0.02660843f, 0.10784670f, 0.13273598f, -0.00478474f, 
    0.28105214f, 0.16992801f, -0.24502711f, -0.12783478f, 0.30978480f, 0.05390612f, 0.20121281f, 0.23352720f, 
    -0.05565690f, 0.18188286f, 0.03912444f, 0.05884295f, 0.04556775f, -0.06949431f, -0.05765004f, -0.04862010f, 
    -0.05351538f, 0.14529175f, 0.06153897f, -0.01408162f, 0.13471036f, -0.07635877f, 0.09537191f, -0.25895819f, 
    0.06019625f, 0.01611725f, -0.31777152f, 0.16148798f, -0.24906816f, -0.31693584f, 0.01268681f, -0.13950339f, 
    0.18921332f, -0.12598462f, 0.23724952f, -0.32235867f, -0.05545000f, 0.02576635f, 0.13675375f, -0.07026924f, 
    -0.00106860f, -0.50307870f, -0.12792331f, 0.16875629f, 0.06650800f, -0.02097860f, 0.10566358f, -0.06727102f, 
    -0.10872927f, 0.03030484f, 0.29886591f, 0.18942216f, -0.00495594f, 0.14964969f, 0.22181392f, 0.12421746f, 
    -0.23678812f, 0.06880706f, 0.18519174f, -0.05426848f, 0.05279588f, -0.02548514f, -0.17422391f, 0.13801043f, 
    -0.00033843f, -0.29408604f, -0.56968373f, 0.26794237f, -0.11463009f, -0.11631786f, 0.04185003f, -0.24493393f, 
    0.31345952f, -0.30216736f, 0.02163000f, -0.39518860f, -0.11845002f, -0.35340196f, -0.03936784f, 0.04039709f, 
    -0.27559185f, -0.15798099f, 0.07916324f, -0.23624666f, -0.01776671f, -0.16637444f, 0.05551621f, -0.42064312f, 
    -0.07702393f, -0.18666038f, -0.55711991f, 0.35870439f, -0.13895477f, 0.06839253f, -0.02403186f, 0.10633960f, 
    0.00943764f, 0.12008084f, 0.22243057f, -0.22589774f, 0.07697336f, -0.27347600f, -0.06110334f, 0.00334911f, 
    0.10618679f, 0.10300004f, 0.06006275f, -0.02717882f, 0.04241510f, -0.24407211f, -0.09898920f, -0.30985284f, 
    0.05507409f, 0.12342040f, -0.44864011f, 0.34093451f, -0.41652328f, -0.21855485f, -0.44297272f, -0.79453415f, 
    -0.10076922f, 0.01665563f, 0.00792280f, 0.05408359f, 0.22853981f, -0.07411931f, 0.24638696f, 0.07574017f, 
    -0.17257006f, -0.45880795f, -0.06801269f, 0.07248951f, 0.48047858f, -0.08208976f, -0.40574124f, -0.07764873f, 
    0.02463279f, 0.01007277f, -0.16260815f, 0.09576270f, -0.03811037f, 0.09158096f, -0.35960257f, 0.00509655f, 
    -0.50039238f, 0.07895265f, -0.00295328f, 0.00462742f, -0.02069573f, -0.18904766f, 0.18765716f, 0.21260880f, 
    0.25206128f, 0.22672826f, -0.05062792f, -0.04200343f, 0.23682377f, -0.01404858f, -0.10690758f, 0.28709289f, 
    -0.18312593f, -0.06049675f, 0.10928827f, 0.04530507f, -0.35341778f, -0.06813034f, 0.06171605f, 0.02634973f, 
    -0.49526227f, -0.04939514f, 0.14391795f, -0.10089968f, -0.06346776f, 0.22692358f, -0.47038469f, 0.08834647f, 
    -0.49331459f, -0.14898923f, -0.17814201f, -0.32152241f, -0.08418524f, -0.08877511f, 0.40064609f, 0.10015356f, 
    0.14428164f, -0.03234365f, -0.14289770f, -0.01090121f, -0.28492635f, 0.03432404f, 0.05724113f, 0.30791730f, 
    -0.00388972f, -0.06210566f, 0.01110708f, -0.07596390f, 0.04717521f, -0.20977533f, 0.15137096f, -0.49362409f, 
    -0.01514562f, -0.32984886f, -0.23157594f, 0.08705755f, -0.08025964f, 0.30187765f, 0.10560188f, 0.07198118f, 
    -0.01505970f, 0.03089503f, 0.14183840f, -0.34738097f, 0.21582210f, 0.08068052f, 0.00236377f, 0.16586316f, 
    0.09142705f, -0.14357458f, 0.31206498f, 0.14990872f, -0.08783346f, -0.33526605f, -0.02733177f, 0.09050189f, 
    -0.02182061f, -0.10623035f, -0.00862967f, -0.31903157f, 0.10427255f, 0.09305046f, -0.26785284f, -0.37468243f, 
    0.18085963f, 0.13408460f, 0.18736404f, -0.48421896f, 0.17931712f, -0.04465230f, 0.09450439f, -0.09036068f, 
    0.08995158f, -0.35447121f, 0.24067205f, 0.01577361f, 0.24744618f, 0.25298682f, -0.19330609f, 0.25649202f, 
    0.02862102f, 0.29451668f, 0.50282818f, 0.11023476f, 0.18794988f, -0.46820009f, 0.18246350f, -0.03321872f, 
    0.02971732f, -0.26222697f, -0.35662785f, 0.18772766f, -0.70642096f, -0.00395894f, 0.24294937f, 0.12472461f, 
    -0.04828449f, 0.10302091f, -0.04531021f, 0.09368658f, 0.00334439f, 0.05249127f, -0.09415849f, 0.14338785f, 
    -0.25802258f, -0.05221607f, 0.06377124f, 0.01531683f, 0.02606287f, 0.18197906f, 0.16840647f, -0.15779245f, 
    0.02984910f, -0.46327272f, 0.10026935f, -0.11230507f, -0.26985919f, 0.02890678f, -0.09912635f, -0.51022565f, 
    -0.01783882f, -0.02507213f, 0.08193143f, -0.09796252f, -0.46130258f, -0.06997585f, -0.03440461f, -0.00856273f, 
    -0.05944318f, -0.04933928f, 0.26740342f, -0.22193523f, -0.42870551f, 0.05567253f, -0.13093247f, -0.21488416f, 
    0.04684168f, -0.07891716f, -0.11734817f, -0.24230157f, 0.11128961f, 0.22653851f, -0.29558682f, 0.02877066f, 
    -0.49126014f, 0.00852956f, -0.00907470f, -0.05757015f, -0.38497642f, 0.05653786f, 0.22485057f, -0.08700029f, 
    0.27839461f, 0.12608258f, -0.48138094f, -0.10553337f, -0.23241435f, 0.12920776f, 0.07391847f, 0.36160299f, 
    -0.39936897f, -0.17276643f, -0.45718506f, -0.78430384f, 0.09381445f, -0.55315620f, -0.39686140f, 0.09259680f, 
    -0.44058353f, 0.06623471f, 0.10799518f, -0.26427719f, 0.20064299f, 0.04893168f, 0.01685423f, 0.06618312f, 
    -0.46320578f, -0.06424177f, -0.26433027f, -0.47887966f, -0.22961013f, 0.13899158f, 0.12798057f, 0.04100623f, 
    -0.05402394f, 0.19285761f, -0.17596237f, -0.09896846f, -0.44747385f, 0.05347173f, 0.05022935f, 0.13998325f, 
    -0.07775422f, 0.11590398f, 0.24809998f, -0.05294849f, 0.28074732f, 0.18560860f, -0.69414967f, -0.34950614f, 
    -0.09704743f, -0.11056273f, -0.72683698f, -0.29558653f, -0.00021492f, 0.33711487f, -0.32398713f, -0.24839075f, 
    -0.00503761f, -0.14506897f, -0.09717685f, 0.20865153f, -0.07567237f, 0.08136965f, 0.03983840f, -0.03044297f, 
    -0.25669357f, 0.14956208f, -0.32104287f, -0.48991793f, -0.11358750f, 0.05101714f, 0.17274551f, 0.06670009f, 
    0.03654006f, 0.01433238f, 0.06672254f, 0.08047687f, -0.06303875f, -0.25838685f, 0.04304251f, 0.09674700f, 
    0.13411653f, -0.26828116f, -0.01926812f, -0.03443190f, -0.12970142f, -0.08918110f, -0.27167499f, -0.02854293f, 
    0.13354319f, -0.31826469f, -0.36686093f, -0.32405591f, 0.18752308f, 0.06355619f, -0.00537127f, 0.47439554f, 
    -0.03486207f, -0.28585857f, -0.26663530f, 0.22266065f, 0.19509205f, -0.10323166f, 0.00778703f, 0.06366608f, 
    -0.13345085f, 0.11650561f, -0.20692249f, -0.12160462f, 0.06309611f, -0.01415044f, -0.19445689f, 0.37521005f, 
    -0.10656824f, 0.03833850f, 0.06949485f, 0.12283634f, -0.32384509f, 0.11520340f, -0.03592744f, 0.03587311f, 
    0.02418690f, 0.00653918f, -0.07137089f, 0.00579594f, -0.05461387f, -0.06530208f, -0.25681946f, 0.19257884f, 
    -0.29248002f, 0.03892787f, 0.32174903f, 0.06000683f, 0.07419807f, -0.00819914f, -0.30358973f, 0.00412916f, 
    0.13334449f, 0.06667709f, 0.09291283f, -0.15661819f, -0.13495637f, 0.15038162f, 0.19320659f, -0.24215494f, 
    -0.24239019f, -0.19484109f, 0.00297209f, 0.11822426f, -0.03415440f, -0.01400212f, 0.04421502f, -0.25273195f, 
    0.03272379f, -0.12063905f, -0.06510822f, 0.26713973f, 0.21250351f, -0.28921998f, 0.01259312f, -0.05256512f, 
    -0.03720566f, -0.35817567f, 0.14755929f, -0.05384070f, 0.07057096f, -0.43363205f, -0.03800256f, -0.12541677f, 
    -0.41597417f, 0.13533808f, -0.33249867f, 0.20118354f, -0.39038461f, -0.11857928f, 0.00008319f, -0.15138774f, 
    0.16943260f, -0.27148142f, -0.09785053f, -0.34133998f, -0.19096410f, -0.21426167f, -0.08129711f, 0.54816347f, 
    0.03908589f, 0.08312532f, 0.28786337f, -0.22508049f, 0.16285673f, -0.16304876f, 0.21674888f, -0.02660873f, 
    0.20356597f, 0.01405018f, 0.22954863f, 0.26194862f, 0.14854023f, 0.03789875f, 0.11660252f, -0.17754786f, 
    -0.00099796f, -0.37129959f, 0.07972266f, -0.25146231f, 0.00516194f, -0.05781386f, 0.32638103f, -0.37527624f, 
    -0.38957042f, 0.13647757f, -0.03317653f, 0.05871865f, -0.11932137f, 0.11170912f, -0.15543716f, 0.17209625f, 
    0.24280149f, 0.12124248f, -0.13111027f, -0.39585647f, 0.19285892f, -0.30164573f, -0.00712884f, -0.10211354f, 
    -0.38171017f, 0.12999406f, 0.12918013f, 0.19455859f, -0.02841857f, 0.05552573f, 0.19676609f, -0.06397408f, 
    -0.40819231f, 0.04881744f, 0.04387214f, 0.16922627f, -0.20643635f, 0.07753955f, -0.30887121f, 0.14389792f, 
    -0.10117354f, -0.34952202f, -0.25857106f, 0.01446603f, 0.02696886f, -0.30632213f, -0.09824519f, 0.03132117f, 
    -0.32858863f, 0.05037238f, -0.23704942f, -0.03595483f, -0.10800878f, -0.06649289f, -0.02264151f, -0.51043451f, 
    -0.14073177f, -0.24964209f, -0.05212361f, 0.19301243f, 0.05999802f, 0.39845628f, -0.29119003f, -0.37764117f, 
    -0.38268274f, 0.33351585f, 0.23330554f, 0.26090789f, 0.00839963f, -0.40086317f, 0.12763160f, 0.05671220f, 
    -0.06343543f, 0.12898511f, 0.18189557f, -0.33249792f, -0.11896031f, 0.24689464f, -0.02587798f, -0.00499321f, 
    0.22953942f, -0.26709047f, 0.14807361f, 0.01095608f, 0.22060794f, 0.19031018f, -0.49062535f, 0.11851860f, 
    0.00376763f, -0.04406121f, -0.15223920f, 0.26500145f, -0.13174503f, -0.27343386f, -0.29414061f, -0.16381098f, 
    0.21205945f, -0.30518156f, -0.22531982f, 0.09570868f, 0.10895727f, -0.02901965f, -0.06501886f, -0.15051726f, 
    0.12463047f, 0.07557373f, -0.07808127f, -0.26746902f, -0.19292466f, 0.03723819f, 0.09851674f, -0.25178516f, 
    0.04812751f, -0.10495729f, -0.08261509f, -0.25962591f, -0.09664007f, -0.10101437f, -0.01571024f, 0.01136894f, 
    -0.20705768f, -0.43153822f, -0.50080591f, -0.14233275f, 0.01481255f, 0.07839042f, 0.01877254f, -0.06962416f, 
    -0.00898682f, -0.02822135f, -0.03140545f, 0.22904168f, -0.03857381f, 0.05440857f, 0.16715923f, -0.16045007f, 
    -0.02985760f, -0.14290556f, -0.00472213f, -0.05654882f, 0.01735880f, -0.10530484f, -0.15884253f, -0.44234729f, 
    -0.54072797f, 0.27341849f, 0.08518901f, -0.27138391f, -0.08251654f, 0.16212662f, -0.11073846f, -0.18084960f, 
    0.18297586f, -0.02602221f, 0.02180083f, 0.28637537f, 0.12232470f, -0.13825716f, 0.27946681f, 0.01804532f, 
    -0.00177682f, 0.39016956f, 0.09318352f, -0.15195836f, 0.05153989f, 0.00875637f, 0.30056658f, -0.23810335f, 
    0.11361646f, -0.01780610f, -0.06107610f, 0.12020104f, 0.10314438f, 0.11616161f, -0.41863912f, 0.37918183f, 
    -0.46693638f, -0.04517901f, 0.26246652f, -0.02172194f, -0.11951411f, -0.05034294f, 0.20002082f, -0.38001835f, 
    0.03113072f, -0.84196508f, 0.10599255f, -0.16248536f, -0.27889207f, -0.52776420f, -0.00861768f, -0.28703198f, 
    0.02905413f, -0.04589264f, 0.14849739f, 0.04647937f, -0.22360136f, -0.07201218f, -0.56126618f, -0.15827666f, 
    -0.04155483f, 0.05899105f, -0.08866464f, 0.09734717f, 0.05806936f, -0.11594806f, 0.05604044f, -0.35957658f, 
    0.02187154f, 0.32320443f, -0.01026150f, 0.02150735f, -0.08638579f, 0.23695114f, 0.03251988f, -0.04694777f, 
    0.05634907f, 0.00007813f, -0.17668922f, -0.00848097f, -0.20143867f, 0.07531764f, -0.07640397f, 0.00891811f, 
    -0.09283622f, -0.07003023f, -0.19384883f, -0.25951922f, 0.20422342f, 0.17693464f, 0.20062946f, 0.21985163f, 
    0.23207298f, -0.20779222f, -0.13579136f, -0.41283169f, -0.18887775f, 0.18901023f, -0.31512254f, -0.27462000f, 
    -0.08329841f, -0.07000320f, 0.09962592f, 0.19093156f, -0.07463513f, -0.17784274f, 0.15471831f, -0.05499056f, 
    -0.12263580f, -0.16647366f, 0.19437514f, -0.05891409f, -0.40863633f, 0.00698728f, -0.19112705f, 0.23301601f, 
    -0.04262275f, -0.02152704f, -0.03886912f, -0.55320954f, 0.04193599f, -0.10544845f, -0.00236183f, 0.03073520f, 
    0.05502527f, 0.01593652f, 0.02022729f, -0.06916954f, -0.08055624f, -0.32888389f, -0.17233853f, 0.34206823f, 
    -0.07751058f, 0.32543951f, 0.18022957f, -0.13751562f, -0.23010449f, 0.15700220f, -0.00067863f, 0.04417652f, 
    -0.25517067f, 0.23653030f, 0.01044063f, -0.09215260f, 0.16129820f, -0.03888475f, 0.16482393f, -0.03121065f, 
    0.15859950f, -0.23695935f, -0.66038507f, -0.04866341f, 0.21027763f, 0.00933378f, 0.01007527f, -0.16873729f, 
    -0.50486964f, 0.10917089f, 0.06917438f, 0.01271380f, -0.12124348f, -0.51488858f, 0.19887435f, -0.36089167f, 
    0.23704314f, 0.02450445f, 0.07226035f, -0.00636758f, 0.26102018f, -0.08730367f, 0.02811399f, 0.27962264f, 
    -0.59449518f, 0.18501337f, -0.53357774f, -0.06344652f, 0.22478114f, -0.17434959f, -0.22442208f, -0.28556728f, 
    0.05897598f, 0.04899956f, -0.02735876f, -0.19900441f, 0.18563128f, 0.03740722f, 0.07001550f, 0.25523227f, 
    0.52496403f, -0.18935117f, -0.09792474f, -0.12928130f, -0.68166459f, -0.63270390f, -0.07112140f, 0.20707485f, 
    -0.21207014f, -0.35845089f, 0.20643084f, -0.22599755f, 0.16401288f, -0.07717054f, -0.06954347f, -0.18883443f, 
    -0.06753159f, -0.23976848f, -0.06002706f, -0.03703654f, -0.16540463f, -0.06993321f, 0.10741399f, 0.19115847f, 
    0.27852646f, -0.15624252f, -0.00683846f, -0.00129658f, -0.00527740f, 0.20734052f, 0.03227848f, -0.14929649f, 
    -0.23902249f, -0.28688428f, -0.12479679f, 0.19394495f, 0.18395205f, -0.34489104f, 0.11999729f, 0.19168974f, 
    -0.03161788f, 0.03130238f, -0.47404775f, 0.09102543f, -0.34950343f, 0.30595353f, -0.52445227f, 0.07721943f, 
    0.04074199f, -0.02158906f, -0.02249163f, 0.23459105f, -0.35168096f, -0.01333518f, 0.16233461f, -0.11512178f, 
    0.02597335f, -0.03741485f, 0.11853793f, -0.38397095f, 0.08349837f, -0.34790224f, 0.23702395f, 0.01336860f, 
    -0.08761462f, -0.12600464f, 0.03907488f, 0.07304638f, 0.05535829f, -0.21717477f, 0.00575761f, 0.00595421f, 
    -0.15962258f, -0.26536182f, 0.01042891f, -0.31594193f, 0.10143213f, 0.09968272f, -0.02425304f, -0.03009169f, 
    0.13637055f, 0.18244559f, -0.20313215f, 0.34192604f, 0.11695157f, -0.03153175f, 0.04488293f, 0.05377597f, 
    0.12952860f, -0.06491852f, 0.05982395f, -0.44968048f, -0.32710934f, -0.27152386f, -0.10531245f, 0.02036192f, 
    0.17621049f, -0.03657690f, 0.12443446f, -0.47209501f, 0.04049246f, 0.01124884f, -0.15277696f, -0.40014100f, 
    0.23678467f, 0.07899938f, -0.39869049f, -0.00571649f, 0.02352382f, 0.01554895f, 0.22618417f, 0.09730954f, 
    -0.03861747f, -0.37732518f, 0.04691933f, -0.17615525f, -0.01899397f, 0.00237111f, 0.11094185f, 0.28779906f, 
    -0.15212330f, 0.17878896f, -0.18831472f, 0.18354364f, 0.08194654f, 0.07108781f, -0.04205834f, -0.10260390f, 
    0.08171279f, -0.00469230f, 0.08675635f, 0.11617460f, 0.09999402f, -0.23270099f, 0.04865016f, 0.02002988f, 
    -0.09215310f, -0.15131187f, -0.37953317f, -0.50961101f, -0.19165230f, 0.09338281f, 0.08887640f, -0.22953665f, 
    -0.02221205f, -0.27918699f, -0.09492011f, -0.24902210f, -0.31631315f, -0.00502432f, 0.15184575f, 0.04107619f, 
    0.10775565f, 0.07557720f, 0.06044595f, 0.02197076f, -0.09141733f, 0.20826030f, 0.32844731f, -0.10923137f, 
    -0.36254150f, 0.09085879f, -0.14492884f, -0.26777649f, -0.22806463f, -0.17330638f, 0.16471021f, -0.17268300f, 
    0.00578858f, -0.43732607f, -0.48119566f, 0.08077367f, 0.01280800f, 0.20909697f, -0.05676274f, 0.08633149f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06916479f, 0.10907128f, -0.13054186f, -0.10126179f, 0.02391340f, -0.03266132f, 0.00143064f, -0.20734805f, 
    0.02055698f, 0.09569230f, 0.05219803f, 0.06116006f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
