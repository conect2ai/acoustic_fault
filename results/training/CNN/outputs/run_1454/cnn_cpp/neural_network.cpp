#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.29411021f, 0.11250374f, 0.05866557f, 0.54340249f, 0.55214548f, -0.02606453f, 0.10771237f, -0.03945639f, 
    0.30621433f, -0.37361622f, -0.03736621f, -0.20143792f, 0.12872700f, -0.18590426f, 0.00879377f, 0.22259444f, 
    0.41471761f, 0.13646472f, -0.73778582f, 0.83399159f, -0.20656700f, -0.41744715f, -0.05749129f, -0.17709264f, 
    0.30422908f, -0.04348459f, 0.03991110f, -0.72136694f, -0.32220155f, 0.81821531f, -0.24927941f, -0.01212341f, 
    0.23139681f, -0.31387669f, -0.06765406f, 0.30345428f, 0.05135046f, -0.16698530f, -0.11620271f, -0.28272113f, 
    0.18365598f, 0.12743953f, -0.22215310f, -0.19773537f, -0.54480457f, 0.62867725f, 0.67488420f, -0.70935237f, 
    -0.07980929f, -0.07063881f, -0.34130803f, -0.19292150f, 0.12381168f, 0.06816823f, -0.00492707f, 0.38707605f, 
    -0.09772220f, -0.33754918f, -0.36058745f, -0.23180005f, -0.06789593f, -0.26275292f, 0.60125822f, 0.61722124f, 
    0.40738347f, -0.57999802f, -0.57894534f, 0.37506968f, 0.41811886f, -0.24892767f, -0.40606567f, 0.28451136f, 
    -0.26470378f, -0.68208349f, 0.62022865f, -0.11420181f, -0.11153460f, -0.49454844f, -0.21284722f, -0.08775406f, 
    -0.26668164f, -0.22518371f, 0.40431637f, 0.50045162f, -0.30872351f, -0.04416979f, 0.43342277f, -0.31460613f, 
    -0.31899077f, 0.16759767f, -0.66839731f, -0.29036859f, -0.61550266f, 0.26957169f, 0.31795129f, 0.36521539f, 
    -0.05856948f, -0.12465704f, 0.45441985f, 0.24459268f, -0.23668617f, -0.45945635f, -0.25050539f, -0.25483394f, 
    -0.25318161f, -0.17422229f, -0.27532649f, -0.03729250f, 1.11236084f, -0.84775949f, -0.33516389f, 0.05951920f, 
    0.17058051f, -0.17063828f, -0.26583302f, 0.25186720f, 0.38374743f, -0.08682843f, 0.29440957f, -0.17322771f, 
    0.14307155f, -0.31367454f, -0.25160012f, -0.19756398f, 0.78844666f, -0.58899260f, -0.35468936f, 0.03456926f, 
    0.20321950f, -0.01452041f, 0.02839582f, 0.40232608f, 0.41255626f, -0.55460894f, -0.14179052f, 0.10908961f, 
    0.10438201f, 0.08167589f, -0.13769881f, -0.46781501f, -0.69497496f, -0.21941645f, -0.18187158f, -0.12983926f, 
    0.50128126f, -0.36105984f, -0.29456523f, -0.26919883f, -0.20497395f, 0.05785875f, -0.10670886f, 0.07403185f, 
    -0.24026868f, 0.41826016f, 0.22458203f, -0.17942509f, 0.39698777f, -0.10947727f, -0.41015282f, 0.36688545f, 
    0.17889397f, -0.06906348f, 0.38283601f, 0.46928182f, -0.14878114f, 0.10687664f, 0.57877547f, -0.43764895f, 
    0.06623030f, -0.19351400f, 0.08344018f, 0.36245835f, -0.19846626f, -0.58748126f, -0.08360184f, 0.71673387f, 
    0.28534549f, -0.27993646f, -0.18914832f, -0.33646187f, -0.13449204f, 0.29851216f, 0.30760854f, 0.36737463f, 
    -0.46622473f, -0.15233324f, 0.14468072f, -0.13995951f, -0.09863446f, -0.54291081f, 0.19612199f, -0.47308469f, 
    0.87997127f, -0.21867181f, -0.40343148f, -0.17131633f, -0.18456860f, -0.08664199f, 0.20127346f, 0.22720177f, 
    0.13025805f, 0.52554220f, -0.64849538f, -0.05751277f, -0.43924731f, -0.17818621f, 0.43969053f, -0.35998932f, 
    -0.34790236f, 0.56374079f, 0.38246864f, 0.05456316f, 0.60618788f, 0.16006809f, 0.15945326f, -0.12560059f, 
    -0.44467768f, 0.16873704f, -0.33805364f, -0.10952747f, 0.54716605f, 0.19203469f, 0.17180212f, 0.45845658f, 
    0.27288023f, -0.05830394f, -0.24355090f, -0.21235290f, 0.07550880f, -0.46343914f, -0.29007372f, -0.07786976f, 
    0.62930828f, 0.17879742f, -0.51313841f, -0.63729823f, -0.60771716f, -0.01251854f, 0.07123828f, 0.11521874f, 
    0.47225401f, -0.31890035f, -0.04723880f, -0.33461717f, 0.33653551f, 0.16261145f, 0.31215793f, -0.14144593f, 
    0.45921350f, 0.08206005f, -0.23549403f, -0.17968604f, -0.23087859f, 0.29929751f, -0.14264765f, -0.28081208f, 
    -0.58060163f, -0.32998651f, 0.10398315f, 0.41390064f, 0.52339405f, 0.30865234f, 0.36237520f, 0.05328950f, 
    -0.09687690f, 0.17965864f, -0.07405037f, 0.16206615f, 0.07028401f, 0.41426191f, 0.39400154f, 0.34418303f, 
    0.56281829f, -0.11683097f, -0.65436262f, -0.13784115f, 0.14766534f, 0.24155042f, 0.18343538f, 0.08517327f, 
    0.08591606f, 0.51557159f, 0.05737126f, 0.12724039f, -0.29034773f, -0.01572562f, -0.34185186f, -0.02661897f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02010740f, 0.27494437f, -0.18251260f, -0.13832158f, -0.31706706f, -0.05349085f, -0.07352697f, -0.16153572f, 
    -0.42861977f, -0.09924522f, 0.23993158f, -0.29814202f, -0.20332378f, -0.02695680f, 0.23315369f, -0.02675063f, 
    0.18484108f, 0.21396421f, -0.19001979f, -0.21089955f, 0.20645449f, -0.27417383f, -0.31775862f, -0.04260535f, 
    0.09903993f, 0.03513040f, 0.13538587f, 0.24827600f, 0.12969545f, 0.17685665f, -0.18089129f, 0.06856915f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.02318837f, 0.05337971f, -0.06149867f, 0.11334647f, -0.06243999f, 0.16120677f, 0.02965037f, 0.03267336f, 
    0.04395518f, 0.06942349f, 0.12958403f, 0.04196475f, -0.02088921f, 0.00407377f, 0.01965391f, 0.01322624f, 
    -0.01071779f, 0.06179552f, 0.01692435f, 0.44927186f, 0.40435907f, 0.10799885f, 0.12584399f, 0.05569863f, 
    0.01256336f, 0.29288155f, 0.09762990f, -0.11228649f, 0.20345230f, 0.05830030f, 0.05791015f, 0.12928678f, 
    0.01838724f, 0.10365646f, 0.00151278f, 0.02913717f, 0.00161845f, -0.04035661f, -0.17358473f, -0.04446549f, 
    0.05124317f, -0.02050218f, -0.23589483f, 0.10233422f, 0.07658367f, 0.04810355f, 0.19203857f, 0.10402688f, 
    0.00259448f, 0.06126282f, 0.00084778f, 0.04109893f, 0.29059097f, -0.05496364f, 0.20348340f, -0.03369319f, 
    -0.10500649f, 0.06867350f, 0.09603675f, 0.00341420f, 0.05972362f, -0.03919794f, 0.04601627f, 0.26902252f, 
    0.20200711f, 0.03923276f, -0.03841096f, 0.02783614f, 0.12300501f, -0.13113317f, -0.08323118f, -0.27368104f, 
    -0.09133641f, 0.27378270f, 0.05614752f, 0.03319034f, 0.09552908f, 0.24758956f, -0.00637991f, 0.08722974f, 
    -0.13043247f, 0.04116486f, 0.07907358f, 0.03244433f, 0.16568625f, -0.10850778f, 0.05621198f, -0.05883160f, 
    -0.02334983f, -0.18503779f, -0.04103733f, -0.10534708f, 0.03831113f, 0.00547036f, 0.05681270f, -0.19953083f, 
    -0.00225083f, -0.14010674f, -0.17180233f, -0.04234411f, -0.06850185f, -0.05826237f, 0.07089674f, -0.11867721f, 
    0.08734179f, -0.02319203f, 0.04734287f, 0.07672991f, 0.02559139f, -0.06085732f, 0.56576908f, -0.24189742f, 
    0.04801866f, -0.02538419f, -0.08232190f, -0.19609095f, 0.15599079f, -0.01107411f, -0.03866079f, -0.09577074f, 
    -0.16405803f, 0.36924824f, -0.06919364f, -0.17870156f, 0.10434773f, -0.06327396f, -0.01193599f, -0.03498071f, 
    -0.11237843f, -0.10580181f, -0.13966733f, 0.02244757f, -0.24623306f, 0.06898104f, -0.27612379f, -0.00837020f, 
    -0.21239954f, -0.30731678f, -0.01688595f, 0.06516802f, 0.17260063f, 0.04291483f, -0.12590654f, -0.07444714f, 
    0.05982476f, -0.21499501f, 0.10329093f, 0.00385166f, 0.00084466f, 0.10740290f, -0.05431829f, -0.02826818f, 
    -0.17305450f, 0.00598895f, 0.03766415f, -0.08658983f, 0.03185794f, 0.18833439f, -0.00479979f, 0.03435849f, 
    0.07058832f, -0.07383102f, 0.07464159f, 0.22753353f, -0.21863763f, 0.13926028f, -0.10263284f, 0.08108035f, 
    0.00407251f, 0.18657789f, -0.14852294f, 0.23826964f, -0.04507604f, -0.26367429f, -0.02108931f, -0.04301088f, 
    0.06606299f, -0.11198708f, -0.07401276f, -0.18599808f, -0.11038858f, -0.11808696f, -0.18617840f, -0.07404254f, 
    0.03388781f, -0.12618878f, 0.01773829f, 0.14141163f, -0.10220669f, -0.00893642f, 0.14912771f, 0.04386090f, 
    0.06970403f, 0.12202160f, -0.01679699f, -0.08578136f, 0.06787268f, -0.13710544f, -0.03486817f, -0.02200793f, 
    -0.05317374f, 0.08109677f, 0.16018383f, 0.09056228f, 0.10032611f, -0.26726854f, 0.29220885f, -0.05131396f, 
    0.24084768f, -0.00756017f, 0.14378904f, -0.02160439f, -0.06186921f, -0.12110057f, -0.03517367f, -0.07115483f, 
    0.12757653f, 0.06242478f, 0.08974466f, -0.02092096f, -0.22975060f, 0.00438929f, 0.02717806f, -0.04908369f, 
    0.13019677f, 0.02364962f, 0.02476290f, -0.16451429f, 0.08292533f, 0.13414380f, 0.03464432f, 0.03891552f, 
    -0.16559832f, 0.04702907f, -0.13980275f, -0.17095698f, 0.03279351f, -0.02632163f, 0.01775457f, -0.11858481f, 
    -0.07244840f, -0.06553160f, -0.03202481f, -0.04469405f, -0.04393228f, -0.06425184f, -0.00054898f, -0.16924758f, 
    0.01889272f, -0.24157937f, -0.06726537f, -0.08584216f, 0.07599895f, 0.08331195f, -0.04397986f, -0.07321716f, 
    0.17316675f, -0.05383150f, 0.04697866f, 0.03840638f, 0.21694504f, 0.07702924f, 0.04953985f, -0.01291081f, 
    0.01007757f, 0.04722039f, -0.01194470f, -0.02562193f, 0.11542913f, 0.26706523f, -0.06967691f, 0.00524435f, 
    0.05760693f, 0.07673671f, 0.30810207f, 0.05814132f, -0.11183196f, 0.06379256f, 0.11875211f, -0.10758784f, 
    0.04098561f, 0.03873741f, 0.11131482f, -0.07923546f, 0.06763068f, 0.01357903f, -0.13731286f, 0.01876266f, 
    -0.14539059f, 0.00869753f, -0.17781349f, -0.09737982f, 0.13580573f, -0.09897757f, 0.01025055f, 0.03666960f, 
    -0.05426633f, -0.14496575f, -0.02257975f, -0.12656766f, -0.00631606f, 0.06082499f, 0.04002143f, 0.09780107f, 
    0.03929072f, 0.03870222f, -0.20373379f, -0.71711665f, -0.28964758f, -0.09156162f, -0.23703429f, -0.24547072f, 
    0.18604308f, 0.03403997f, -0.07928455f, -0.01457449f, -0.51501298f, -0.31348258f, 0.02024847f, 0.01366285f, 
    0.09285232f, -0.07563288f, 0.10972484f, 0.06672210f, 0.13490540f, -0.20547524f, -0.20547152f, -0.16246024f, 
    0.05905900f, -0.03672701f, 0.04705106f, -0.08352484f, 0.02847855f, 0.11811212f, 0.00668756f, -0.10000715f, 
    -0.06832224f, -0.04775804f, -0.15326975f, -0.07457525f, 0.08805963f, 0.05247219f, 0.17428495f, -0.10352565f, 
    0.22210747f, 0.09707329f, -0.06087726f, 0.01543076f, -0.05865372f, 0.06969988f, 0.05931124f, 0.24372968f, 
    -0.26759452f, 0.26471728f, -0.13557605f, 0.23905720f, -0.16849537f, -0.01005961f, 0.07116619f, 0.11596181f, 
    0.09893127f, -0.31030732f, -0.60451496f, -0.03037383f, -0.00649211f, 0.21630533f, 0.15847717f, -0.12351726f, 
    -0.11069039f, 0.22999723f, 0.00871418f, 0.22563294f, -0.09493469f, 0.04082913f, -0.15385112f, -0.00963752f, 
    0.17050551f, 0.01102853f, 0.07784416f, -0.19384949f, -0.18435049f, -0.05251713f, 0.05032082f, 0.04981652f, 
    -0.03200003f, -0.05304168f, 0.04386265f, -0.17889211f, -0.22548218f, -0.31661397f, -0.05071132f, -0.08208448f, 
    -0.21309990f, 0.00413220f, -0.00326135f, 0.01627739f, -0.34800452f, 0.10188895f, -0.32010758f, 0.09122963f, 
    0.13866879f, -0.05593609f, 0.08979590f, 0.13667703f, -0.10781065f, 0.04790554f, 0.08620885f, -0.38244492f, 
    -0.02859852f, -0.14596905f, -0.20317139f, 0.04489172f, -0.03394780f, 0.00673181f, 0.12115409f, 0.17425914f, 
    -0.21077172f, 0.06362696f, 0.10762145f, -0.02131997f, 0.11791825f, -0.00768798f, 0.07857911f, 0.43065056f, 
    0.04642347f, -0.02676452f, 0.07627922f, -0.10727318f, -0.04060407f, 0.00811877f, -0.00369990f, 0.07421467f, 
    0.21429199f, -0.04500877f, -0.15893935f, 0.19969645f, 0.10606340f, -0.04297340f, -0.01390493f, -0.04923830f, 
    0.05557953f, -0.05426766f, 0.00484340f, 0.02252656f, -0.08130269f, 0.17083114f, 0.11934377f, 0.06097906f, 
    0.10681289f, 0.08474059f, 0.08348958f, 0.12099602f, 0.08288401f, -0.18743202f, 0.05673853f, -0.14290801f, 
    -0.06394200f, 0.10160732f, 0.03582163f, -0.41045910f, -0.31316349f, -0.26298675f, 0.06811573f, 0.21972330f, 
    -0.12383072f, -0.15453476f, -0.19643211f, 0.08679651f, 0.22775784f, 0.11175359f, 0.12185616f, -0.04568268f, 
    0.00528153f, 0.14075957f, 0.13587998f, 0.11131395f, 0.10006148f, -0.28622597f, -0.24844792f, -0.28641284f, 
    -0.20148841f, 0.08753056f, 0.17601989f, -0.05568002f, -0.07830361f, -0.04744982f, -0.02831497f, -0.00042091f, 
    -0.04661965f, 0.05395027f, -0.13422520f, 0.05087167f, 0.07521789f, 0.20269336f, -0.07617082f, -0.14564708f, 
    -0.03752548f, -0.23816739f, 0.04377399f, 0.11265559f, -0.00289949f, -0.03382561f, -0.05514844f, 0.05642409f, 
    -0.16861720f, -0.13015400f, -0.26114392f, -0.03253709f, 0.10624313f, -0.06053142f, -0.01161841f, 0.17165790f, 
    0.07505750f, -0.30932975f, -0.03270640f, -0.23202959f, -0.04241675f, -0.12347985f, -0.13560995f, 0.10545293f, 
    -0.06504197f, -0.04932597f, 0.16496944f, -0.02685494f, -0.09294290f, -0.14254899f, 0.12390216f, -0.00505920f, 
    0.01412546f, -0.02073652f, 0.07169537f, 0.02220694f, 0.10854138f, -0.04966726f, 0.10040740f, 0.08635148f, 
    -0.03910016f, 0.08261634f, 0.00835298f, 0.13873641f, -0.33761343f, -0.14897867f, 0.04174944f, -0.05245294f, 
    0.00770974f, -0.00223825f, 0.08215513f, 0.09957171f, 0.00793903f, 0.27188101f, 0.12200836f, 0.22514728f, 
    0.09124054f, 0.06413700f, -0.00307434f, 0.01202068f, 0.03630708f, -0.01769408f, 0.39277032f, 0.07601428f, 
    0.08240904f, -0.11475284f, 0.02368176f, 0.01765010f, -0.03721402f, 0.08148418f, -0.00976306f, 0.16540134f, 
    0.02457676f, 0.03430111f, -0.02502028f, -0.10790205f, 0.01125492f, 0.06843092f, 0.06050587f, 0.13522384f, 
    0.12044514f, 0.10277975f, 0.12185302f, -0.07831629f, -0.01108167f, -0.06788083f, 0.00671560f, 0.06258241f, 
    -0.03774980f, 0.12002902f, 0.07970023f, 0.14805925f, 0.09522499f, -0.05786918f, -0.04147759f, 0.11848824f, 
    -0.04588912f, 0.06913128f, -0.07046228f, 0.02168632f, -0.06447317f, 0.15428650f, -0.17541288f, -0.03348677f, 
    0.09805042f, -0.08701885f, -0.12018643f, -0.63928509f, -0.36428213f, -0.33273211f, -0.00995997f, -0.20835638f, 
    0.02497912f, -0.03680497f, -0.01617726f, -0.06714964f, -0.20517406f, -0.01655382f, -0.15583239f, -0.10046034f, 
    -0.06609304f, 0.18547662f, 0.23329411f, -0.06384248f, 0.07826038f, -0.09539893f, 0.09535074f, -0.23844671f, 
    0.09116943f, -0.12374226f, 0.02445936f, 0.06982785f, 0.10294317f, -0.16558553f, -0.18025950f, 0.07369575f, 
    0.03283691f, 0.14505629f, -0.02257696f, 0.01355969f, 0.05501753f, -0.22306602f, 0.05574724f, -0.14119269f, 
    -0.06416385f, -0.35800576f, 0.01357708f, -0.05463704f, -0.02118800f, 0.02017451f, 0.11435431f, 0.12560458f, 
    -0.30676562f, -0.02455766f, -0.02413830f, -0.02695632f, -0.22539233f, 0.01939003f, 0.01107007f, 0.04335830f, 
    0.03970920f, -0.12714651f, -0.19370560f, -0.26781014f, 0.02809918f, 0.01224919f, 0.09440873f, -0.07151192f, 
    -0.02423881f, 0.03139563f, 0.15516357f, 0.08459391f, 0.15563646f, -0.03764915f, 0.01388714f, -0.14508279f, 
    -0.00352989f, -0.00483605f, 0.10719194f, 0.03332989f, 0.17291138f, 0.22326291f, -0.03393868f, -0.05622913f, 
    -0.12473679f, -0.11586913f, 0.02142606f, 0.00111439f, -0.34189463f, -0.04534288f, 0.04154848f, -0.02817954f, 
    -0.12865062f, -0.14067678f, -0.03642176f, -0.23193125f, -0.07302018f, -0.19456777f, -0.08963718f, 0.25617483f, 
    -0.03293499f, 0.29461607f, -0.01720848f, 0.06585769f, -0.10851461f, 0.18592311f, 0.06488314f, 0.00413829f, 
    0.08564070f, 0.04812851f, 0.02434881f, -0.00863534f, 0.18105876f, 0.16504073f, 0.13224250f, 0.07874691f, 
    0.04534547f, 0.14113557f, 0.14762837f, 0.09646706f, -0.09837832f, -0.00465647f, 0.07622351f, 0.01922470f, 
    -0.13421194f, 0.04612316f, -0.03990203f, 0.07582461f, 0.05276043f, 0.05980876f, 0.03054376f, 0.02167089f, 
    0.09899902f, 0.18777604f, -0.10387094f, -0.05467504f, 0.10777476f, 0.03687295f, 0.10829109f, 0.09925164f, 
    -0.11375758f, -0.06816065f, -0.01667531f, -0.09418106f, 0.16032015f, 0.07506755f, -0.06055748f, 0.01838223f, 
    -0.04275331f, 0.04135684f, 0.13944629f, -0.32331204f, -0.18117207f, -0.06182981f, -0.17214392f, -0.23569107f, 
    -0.18416379f, 0.07595251f, 0.14795476f, 0.16896401f, -0.00065350f, -0.15493652f, -0.23142976f, 0.07322813f, 
    0.03766977f, -0.02847460f, 0.14832109f, 0.08878096f, 0.03349094f, -0.40299621f, -0.36883089f, -0.06556854f, 
    -0.37414834f, -0.02109838f, -0.13290407f, 0.06708076f, -0.00825691f, 0.26287386f, -0.57948405f, -0.57632011f, 
    0.00614572f, -0.20817016f, -0.16449478f, -0.03763459f, 0.11346663f, -0.01733378f, 0.01275757f, 0.10677394f, 
    0.24066064f, 0.04066842f, -0.22292122f, -0.07988961f, 0.05899298f, -0.07556240f, 0.01348731f, -0.00694677f, 
    0.00719824f, 0.14682159f, 0.23491973f, -0.07628743f, -0.07694542f, -0.11671806f, 0.03503133f, 0.01612362f, 
    0.02121532f, 0.05012750f, 0.14436691f, 0.29724291f, 0.09180987f, -0.04779021f, -0.04038740f, 0.11955989f, 
    -0.00167287f, -0.03951220f, 0.05723601f, -0.01707456f, 0.37939075f, 0.23646340f, 0.10101818f, -0.08930920f, 
    -0.02151250f, -0.02017361f, -0.00072091f, 0.12684028f, 0.12086219f, -0.06728724f, -0.02402228f, 0.02035210f, 
    0.08582357f, 0.04682978f, 0.06523677f, -0.00633112f, 0.07678791f, 0.18098342f, 0.07668234f, 0.14003505f, 
    -0.09733336f, 0.04600623f, 0.18849583f, -0.10855962f, -0.21260311f, -0.00449571f, 0.06729216f, -0.05162260f, 
    0.06960722f, 0.12384956f, 0.01598070f, 0.03575447f, -0.05134089f, -0.15805258f, 0.07914365f, -0.00588245f, 
    -0.21004982f, 0.12954649f, -0.00500354f, -0.01688369f, -0.02479357f, -0.06342512f, -0.28976420f, -0.03313672f, 
    -0.29057142f, -0.06871855f, 0.09303153f, 0.02566649f, -0.08610064f, 0.01101867f, 0.12425585f, -0.00416236f, 
    -0.12502196f, -0.22011386f, -0.06782973f, 0.03959389f, 0.14314830f, 0.02935836f, -0.04800814f, 0.10335215f, 
    0.04800353f, 0.22166139f, 0.05121833f, 0.19813529f, 0.07939160f, -0.03088730f, 0.05410601f, 0.15056704f, 
    0.01331264f, 0.01880256f, 0.12405124f, 0.09178253f, 0.24479495f, -0.10677046f, -0.05213767f, 0.01795172f, 
    0.01545839f, -0.05078087f, -0.03306661f, -0.10103611f, 0.05477434f, 0.00771451f, 0.08272713f, 0.02225332f, 
    -0.09249926f, 0.01274972f, 0.11301562f, 0.06349211f, -0.02690966f, -0.10589337f, 0.02515832f, -0.07518336f, 
    0.08922016f, 0.07711013f, 0.04367735f, -0.11714274f, -0.03138183f, -0.38831398f, -0.30503756f, -0.17038180f, 
    0.11085371f, -0.04186355f, -0.06771891f, -0.05230401f, 0.13124683f, -0.14098945f, 0.01411172f, 0.12188423f, 
    0.10099801f, 0.01100130f, 0.00452371f, 0.05222784f, -0.15732652f, 0.03065156f, -0.03631417f, -0.08685321f, 
    -0.11643433f, -0.14256239f, 0.12806638f, -0.07744898f, 0.08080884f, 0.04520760f, 0.03353430f, 0.10756587f, 
    0.24569552f, -0.00692571f, -0.01802659f, -0.10603866f, -0.07599844f, -0.04517599f, 0.08745212f, 0.03569901f, 
    -0.13407080f, -0.14007418f, -0.21072800f, -0.13260247f, 0.08717155f, -0.04249213f, -0.12870321f, 0.01114857f, 
    0.09569095f, 0.03752129f, 0.12563635f, 0.02129214f, -0.02518827f, 0.02894942f, 0.05143542f, 0.07029168f, 
    0.04392010f, 0.08022706f, 0.03190919f, 0.11492235f, 0.07155269f, 0.20449951f, 0.00460219f, 0.07776211f, 
    -0.00730818f, 0.00475448f, -0.09190287f, -0.09530054f, -0.20683226f, 0.09806055f, -0.14342193f, 0.01117084f, 
    0.05284197f, -0.07918029f, 0.00355889f, 0.03114269f, 0.03898172f, -0.01768891f, -0.06573398f, 0.10857040f, 
    0.05240954f, 0.24192533f, -0.09340395f, -0.13459940f, 0.04420095f, 0.06612157f, -0.17189585f, -0.02951842f, 
    -0.02228166f, 0.03851086f, 0.03273600f, -0.09311370f, 0.04530284f, 0.10810397f, 0.07306989f, -0.07626382f, 
    -0.01467246f, 0.03365580f, 0.04382905f, 0.08385102f, -0.00371632f, -0.00954654f, -0.00087494f, -0.05837023f, 
    -0.00292113f, 0.04263109f, 0.12954545f, -0.02695855f, 0.07413579f, 0.03667840f, 0.05585811f, -0.04550552f, 
    -0.17850521f, -0.10437269f, -0.24905467f, 0.04288278f, 0.09835567f, 0.01710161f, 0.03961071f, 0.04447366f, 
    0.06880642f, 0.17091526f, -0.10296322f, -0.42197770f, -0.09742010f, 0.09334476f, -0.05386485f, -0.09838063f, 
    -0.07134538f, 0.06447545f, 0.10459280f, 0.11235036f, -0.16665080f, 0.05790636f, 0.01206128f, -0.09198032f, 
    0.15328543f, -0.02837206f, 0.03377630f, 0.00595244f, -0.02902201f, -0.10177918f, -0.08085876f, -0.04537306f, 
    0.05007891f, -0.02295469f, 0.02364391f, 0.01180697f, 0.03989151f, 0.09582208f, 0.20912699f, 0.08512998f, 
    -0.14958224f, 0.00354295f, -0.08166733f, -0.07223209f, 0.08439132f, 0.02193637f, -0.30885842f, -0.21476246f, 
    -0.21344095f, -0.04790779f, 0.08807269f, -0.00160243f, -0.09270407f, 0.06546450f, -0.06252771f, -0.26147515f, 
    -0.04261579f, 0.04155678f, -0.03196019f, 0.06612910f, 0.01186535f, 0.07602428f, 0.00906122f, 0.05240960f, 
    0.08911967f, -0.03235226f, 0.02870320f, -0.08408857f, -0.03651089f, 0.14709495f, 0.03194214f, 0.01880611f, 
    0.13446295f, 0.08515100f, 0.16475190f, 0.25246158f, 0.02278359f, 0.07885321f, -0.00825096f, 0.00634718f, 
    -0.03044360f, 0.07490679f, 0.15117936f, 0.12242054f, 0.04349601f, -0.00408343f, -0.05582317f, 0.01565090f, 
    -0.06089341f, 0.13931413f, 0.07260755f, -0.08351197f, -0.18653481f, 0.03708608f, 0.01070550f, 0.00374232f, 
    0.02896932f, -0.02526264f, 0.06134744f, 0.04788186f, 0.12683244f, 0.10990918f, 0.15373982f, -0.03485016f, 
    0.03952207f, -0.00511447f, -0.05678963f, 0.02286223f, 0.07373053f, -0.12022713f, -0.13795695f, -0.08449257f, 
    0.03788961f, -0.05078919f, 0.09407332f, -0.01665388f, -0.01372481f, 0.09450570f, -0.20470537f, -0.17737482f, 
    0.06711448f, 0.07350130f, 0.09598683f, -0.00179108f, -0.01949251f, -0.03865720f, 0.01390439f, -0.11780342f, 
    -0.22945298f, 0.12151363f, 0.10026772f, -0.05036803f, -0.08835556f, 0.04033664f, -0.07041160f, -0.01795886f, 
    -0.07926217f, 0.00832557f, 0.05651653f, -0.07417952f, -0.02712695f, 0.01294056f, 0.04578897f, 0.06085796f, 
    -0.01146323f, -0.25224262f, 0.16451421f, 0.23016953f, -0.02852606f, 0.02725924f, 0.05568203f, 0.05274491f, 
    0.04481991f, -0.00086701f, -0.77214319f, -0.27014440f, -0.64358181f, -0.07178882f, 0.01568970f, -0.06399309f, 
    -0.01072879f, -0.05713401f, -0.03548846f, -0.01134834f, -0.18132120f, -0.27082196f, -0.02814368f, 0.06397501f, 
    0.26352715f, -0.00636031f, 0.09999874f, -0.03117780f, 0.18062223f, 0.18567804f, -0.08116183f, -0.07976287f, 
    0.06039639f, 0.02199964f, 0.07906040f, 0.03287169f, 0.18527719f, 0.37549949f, -0.01440311f, -0.32338902f, 
    0.03696641f, -0.06393386f, 0.02261965f, -0.01806252f, 0.12479202f, -0.05483203f, -0.16092557f, -0.35478944f, 
    -0.47527418f, 0.04907537f, -0.03500714f, -0.06635913f, 0.10168288f, -0.12075762f, -0.08227558f, -0.19797561f, 
    -0.03270521f, 0.00118673f, -0.08985468f, -0.05492045f, 0.01751470f, 0.02745248f, 0.16972709f, 0.00346733f, 
    0.04291945f, -0.35755667f, -0.42016694f, -0.02819448f, 0.02618060f, 0.04577915f, -0.00141731f, -0.08292254f, 
    -0.07009912f, -0.06833883f, 0.08646285f, -0.07960431f, -0.01584393f, 0.15412685f, 0.20169124f, -0.17860760f, 
    0.08416246f, 0.09716018f, -0.13011706f, 0.20836483f, 0.24973904f, 0.00135003f, 0.19245732f, -0.00640968f, 
    -0.04327464f, -0.03670567f, 0.15138967f, -0.27246636f, -0.21489350f, -0.12008790f, 0.01071374f, -0.11627607f, 
    -0.15615594f, 0.00532009f, -0.08371235f, 0.05606076f, 0.04262785f, 0.39989719f, -0.58670658f, -0.02946724f, 
    0.04072420f, -0.02711480f, -0.10084157f, 0.02092659f, -0.17255017f, -0.04825385f, -0.34333605f, -0.25230578f, 
    0.01067264f, -0.03763476f, -0.06131466f, 0.03344675f, -0.12287472f, 0.17919882f, 0.10744434f, 0.12792644f, 
    0.13552839f, 0.04510666f, 0.00380690f, -0.01198727f, -0.03183978f, 0.02034656f, 0.23366117f, -0.13546884f, 
    -0.28792003f, -0.53168708f, 0.07680379f, 0.02939839f, -0.01474485f, 0.11708733f, 0.05229642f, 0.05438112f, 
    0.08428279f, 0.00463990f, -0.24677388f, 0.01464602f, -0.07435487f, -0.00228743f, 0.10863150f, -0.02713387f, 
    0.03570733f, 0.23462094f, 0.00513822f, 0.02315770f, -0.02516384f, 0.06223420f, 0.05868458f, -0.00357102f, 
    0.01203588f, 0.03984204f, 0.00808187f, -0.28656346f, 0.12518162f, 0.00103921f, 0.06864007f, 0.08031866f, 
    -0.04774635f, 0.06934913f, 0.09122768f, -0.28617615f, -0.07542522f, -0.02196214f, -0.17308354f, 0.19777040f, 
    -0.07680298f, 0.09552001f, -0.00550976f, 0.12927850f, -0.02820945f, -0.20536463f, -0.06527480f, 0.01204077f, 
    0.13232358f, -0.04480393f, 0.16150090f, -0.00023859f, 0.14505284f, -0.16410504f, -0.51848632f, -0.26759142f, 
    -0.00140908f, -0.24315333f, -0.10614914f, 0.06428952f, 0.14880799f, 0.05932323f, -0.19822223f, -0.26626876f, 
    0.07439009f, 0.06544078f, 0.02347630f, 0.02563095f, 0.04555744f, 0.12968984f, -0.16132411f, 0.00761033f, 
    0.05407528f, 0.00900062f, 0.04996753f, 0.04676666f, -0.11817514f, 0.08361579f, 0.12566976f, 0.20699330f, 
    -0.28363785f, 0.25397938f, 0.25155890f, -0.11053703f, 0.00794465f, 0.06365233f, 0.08607210f, 0.06606694f, 
    0.09995323f, -0.34212539f, -0.06979494f, -0.16373347f, 0.11153962f, -0.00096359f, -0.14375307f, 0.00965418f, 
    -0.10781262f, -0.12083536f, -0.17349212f, 0.13538037f, 0.41036126f, 0.11934316f, 0.09393797f, 0.05334818f, 
    0.03562694f, 0.03735921f, 0.07330421f, 0.04260533f, 0.11548430f, -0.00923519f, 0.12537886f, -0.01498798f, 
    -0.07081742f, 0.06068196f, 0.02978977f, 0.13089478f, -0.11294578f, -0.12274443f, -0.27330798f, -0.04727513f, 
    0.12899539f, -0.01961074f, -0.00417058f, -0.02475236f, -0.16643530f, 0.25014594f, 0.05480564f, -0.00311633f, 
    -0.04986439f, 0.05986920f, 0.07650696f, -0.00069043f, 0.05493150f, 0.03035654f, 0.38769585f, -0.42094633f, 
    -0.01162309f, 0.05721439f, 0.22708660f, 0.07563591f, 0.01908382f, 0.06021183f, 0.01706933f, 0.00121163f, 
    -0.02298111f, -0.09159697f, -0.02135075f, 0.03450665f, 0.07151718f, 0.09418451f, -0.00617296f, 0.10449324f, 
    0.06374744f, -0.00144999f, -0.07490640f, -0.33294240f, 0.01885592f, 0.08032790f, 0.01525877f, -0.16155265f, 
    -0.02433743f, 0.23863715f, -0.06823461f, -0.08909943f, 0.05212612f, 0.01525140f, 0.05024740f, -0.04304677f, 
    0.00743184f, -0.01420638f, 0.69816077f, -0.58090836f, -0.54976296f, -0.04310181f, 0.02463901f, -0.01447647f, 
    0.07330512f, -0.04126295f, 0.00241814f, 0.66477561f, 0.00147894f, -0.30026177f, -0.01659825f, 0.16464280f, 
    0.04896837f, 0.01293435f, 0.02368080f, 0.07462952f, -0.03482332f, 0.08505081f, 0.13159668f, -0.05003754f, 
    -0.26107550f, -0.07082182f, -0.01498740f, -0.00094128f, 0.06095513f, -0.75148237f, -0.13093807f, 0.02004784f, 
    -0.24731369f, -0.23449777f, 0.10869524f, 0.16722567f, 0.08183853f, 0.13884608f, -0.40147337f, -0.34759790f, 
    0.02000500f, -0.07547340f, 0.13347563f, 0.10183436f, 0.02827374f, 0.08692631f, 0.04106683f, -0.40076688f, 
    0.05449752f, -0.08292538f, 0.15322274f, 0.01726138f, 0.12236419f, -0.02369016f, 0.06018822f, 0.03223752f, 
    0.37636480f, -0.12991518f, -0.01413130f, 0.03345472f, -0.23113838f, -0.19063844f, -0.00081540f, 0.07888882f, 
    -0.26707724f, 0.09086360f, 0.14071609f, -0.09582240f, -0.07970770f, 0.07428697f, 0.04484904f, -0.03833796f, 
    -0.07476539f, 0.01669957f, 0.38243422f, -0.05551655f, -0.50773937f, 0.01277520f, 0.13131486f, 0.10428911f, 
    0.16894150f, -0.01717664f, 0.04958934f, 0.06967215f, -0.16816673f, -0.46820542f, 0.00513927f, -0.24295345f, 
    0.04636054f, -0.00393883f, 0.05093910f, -0.02633009f, 0.48115924f, -0.33417842f, -0.21713278f, -0.12539989f, 
    0.04305301f, 0.01693063f, 0.13065527f, 0.13708565f, 0.02014247f, 0.17697455f, -0.05606283f, 0.33783019f, 
    -0.00922391f, 0.04606836f, -0.03453246f, -0.08226191f, 0.05874944f, 0.08777793f, 0.00545440f, 0.05433140f, 
    0.13902374f, -0.05784868f, 0.09543538f, 0.01139256f, 0.02676171f, 0.05214992f, -0.00054605f, -0.16530429f, 
    -0.26834184f, 0.14698356f, -0.02504352f, 0.03636336f, -0.07394801f, -0.00589838f, 0.05194462f, 0.04424670f, 
    0.11512650f, -0.13606368f, -0.24309161f, 0.10491583f, -0.00857619f, 0.05231702f, -0.03272100f, 0.02385312f, 
    0.14673939f, -0.23664168f, -0.01075373f, 0.08226606f, -0.04639054f, -0.02365695f, 0.04048323f, 0.09465379f, 
    -0.03303993f, -0.02992925f, -0.22693522f, 0.08569426f, 0.25844321f, -0.09960281f, 0.03740869f, 0.05390982f, 
    0.01993120f, 0.09569479f, -0.13635118f, -0.17100322f, -0.03480058f, 0.02115106f, 0.10248698f, -0.00945348f, 
    0.06128015f, -0.01280759f, 0.10682260f, -0.08989804f, 0.02753636f, 0.00775074f, 0.19185580f, -0.08283992f, 
    0.02294549f, 0.00611972f, 0.06420869f, 0.11509056f, -0.05953860f, 0.24153815f, -0.13682508f, -0.20079345f, 
    -0.03726538f, -0.03541122f, 0.12325218f, -0.03272395f, 0.02008779f, 0.10967463f, -0.33966234f, -0.12018270f, 
    0.22907969f, -0.23505317f, 0.12179087f, 0.04623546f, 0.10081568f, 0.03474703f, 0.09584676f, -0.04913539f, 
    -0.00460989f, -0.00242894f, -0.21635886f, 0.04512158f, -0.02409151f, 0.13460276f, -0.04457266f, 0.07172093f, 
    0.13137627f, -0.00723166f, -0.29510874f, -0.05789275f, -0.01055386f, 0.02411422f, 0.06309313f, -0.09167721f, 
    -0.03387173f, -0.07051305f, -0.25138769f, 0.07132326f, 0.13419916f, 0.09172678f, -0.11111210f, -0.00326327f, 
    -0.06641081f, 0.03267049f, 0.47456783f, 0.03782985f, -0.50406539f, -0.00903276f, 0.08009304f, 0.11692782f, 
    -0.07332812f, -0.13675064f, -0.08818469f, 0.10380691f, -0.00956854f, 0.17571484f, -0.06384175f, -0.00584298f, 
    -0.01544830f, -0.06870015f, 0.02321772f, 0.01293418f, 0.02021362f, -0.47254437f, 0.06987543f, 0.07113732f, 
    0.04026164f, -0.10349121f, -0.07113497f, -0.04500736f, 0.12767561f, -0.18472247f, 0.10542571f, 0.06511518f, 
    0.03322184f, 0.01271493f, -0.05785555f, 0.03711844f, -0.06917692f, -0.02922161f, -0.25246999f, -0.02719621f, 
    -0.01047431f, 0.03203985f, -0.06949981f, -0.04614617f, 0.16911310f, -0.05016061f, -0.01105423f, 0.00459482f, 
    -0.03558460f, -0.07571395f, -0.09937083f, 0.02150590f, 0.00592017f, -0.02181659f, 0.08041787f, -0.04067547f, 
    0.04124615f, -0.10861064f, -0.12163748f, 0.15208663f, 0.07296514f, -0.01399435f, 0.09517011f, -0.08570024f, 
    0.18894956f, -0.02375270f, 0.03314090f, 0.08236377f, 0.01507113f, 0.01912381f, -0.00816178f, 0.13134445f, 
    0.07594088f, 0.08274222f, -0.10306170f, -0.33038834f, -0.13817598f, 0.02344954f, -0.11345790f, 0.02784887f, 
    0.12381583f, 0.10323048f, 0.11078276f, 0.48934126f, -0.13746884f, -0.21007530f, -0.10323439f, -0.02881971f, 
    -0.05753339f, -0.05896018f, -0.03658262f, 0.16603413f, -0.12479392f, -0.15813386f, 0.05405809f, -0.04104433f, 
    -0.02514988f, 0.06037191f, -0.05426901f, -0.05581535f, -0.08289851f, 0.16610272f, 0.16346931f, 0.26026380f, 
    0.13280107f, 0.03175345f, -0.21267259f, -0.04459953f, -0.02526097f, 0.08233546f, -0.33783668f, -0.19097742f, 
    -0.03164078f, 0.11696414f, -0.07816241f, 0.11778235f, -0.02302619f, 0.21084575f, 0.06553300f, 0.05144583f, 
    -0.05353768f, -0.29423910f, -0.04196944f, 0.11933765f, -0.08661937f, -0.06975465f, -0.01406426f, 0.03731896f, 
    -0.21102306f, -0.20332688f, -0.10459135f, 0.00284121f, 0.05103884f, -0.23331659f, -0.13815480f, 0.01661849f, 
    0.09558716f, -0.07552620f, 0.07200237f, -0.36131728f, -0.22261223f, -0.02547462f, -0.00052220f, -0.00329384f, 
    0.00220637f, 0.00199414f, 0.05921979f, 0.32072625f, 0.34134007f, 0.06489513f, 0.11668586f, 0.08338783f, 
    -0.02789063f, -0.12137122f, 0.12982056f, -0.18692936f, -0.27333385f, -0.13304177f, -0.13518761f, -0.08976361f, 
    -0.09305016f, 0.11048923f, 0.12988995f, 0.10615177f, 0.26214361f, -0.09062863f, -0.40946704f, 0.14307392f, 
    -0.05522094f, -0.09401052f, 0.04891798f, -0.15272881f, 0.13080999f, 0.01442408f, -0.08000220f, 0.02911750f, 
    0.17629784f, -0.04969463f, -0.04508797f, 0.29396561f, 0.12904166f, 0.02216921f, 0.08456401f, -0.00907391f, 
    -0.00504109f, 0.09887679f, 0.05481701f, 0.04789275f, 0.06045160f, -0.02824210f, -0.01343748f, -0.32150778f, 
    -0.07595215f, -0.04976778f, 0.06909095f, -0.05652259f, 0.01058495f, 0.02751292f, 0.04706849f, 0.02359564f, 
    0.05613256f, 0.05435183f, 0.08600868f, 0.03777465f, 0.01383639f, -0.00688705f, -0.06606904f, 0.03582772f, 
    0.13778584f, -0.09254912f, 0.14992504f, -0.05681110f, 0.06038178f, 0.13210168f, -0.10952252f, 0.09872959f, 
    0.12757954f, 0.13282853f, -0.01951372f, -0.16601752f, -0.01913890f, 0.09309395f, -0.03893000f, -0.13024454f, 
    -0.08675262f, 0.13020621f, -0.08623780f, -0.02348447f, -0.15751109f, 0.06667280f, 0.08308192f, -0.15695877f, 
    0.04260417f, -0.01833102f, -0.05331817f, 0.00651925f, -0.16722108f, 0.13551940f, -0.09579670f, 0.15166523f, 
    0.05874201f, 0.04359490f, 0.03419823f, 0.07640842f, -0.07654992f, -0.07391933f, -0.03181648f, 0.19154391f, 
    -0.06236020f, -0.19446442f, -0.06182780f, -0.04907252f, 0.06656427f, -0.04924396f, -0.04640586f, -0.00689791f, 
    0.08062361f, 0.06953286f, -0.18183614f, 0.00354007f, -0.08328420f, -0.11557923f, 0.04599205f, 0.07318364f, 
    -0.06669084f, -0.30650851f, 0.12537408f, -0.04411303f, 0.10624555f, 0.00908179f, -0.01171147f, 0.07436167f, 
    0.03061199f, 0.05793808f, 0.06166010f, -0.08800113f, 0.00085212f, -0.00084502f, 0.14859764f, 0.04949148f, 
    0.22627871f, -0.24024415f, -0.16875243f, -0.11780751f, 0.06811346f, 0.06396311f, -0.07011379f, 0.23283415f, 
    0.01812807f, 0.01148809f, 0.02989242f, 0.21916503f, 0.14348593f, -0.03681120f, 0.02712343f, 0.10584273f, 
    -0.04768218f, -0.02018008f, 0.09003815f, 0.07410716f, -0.02948839f, -0.24304219f, 0.06718774f, -0.10760087f, 
    0.11558510f, 0.07125730f, 0.10994773f, -0.05861542f, -0.17846407f, -0.14911219f, 0.06200039f, 0.11925358f, 
    -0.01603789f, 0.00226498f, 0.15148939f, 0.14231710f, 0.02896724f, -0.00576136f, -0.10974204f, 0.03704011f, 
    -0.10964178f, 0.10699863f, -0.10767356f, 0.09025672f, 0.13751034f, 0.04060873f, -0.25032437f, -0.13311031f, 
    -0.02774901f, -0.02348962f, -0.05460772f, 0.08348377f, 0.14664847f, 0.15178575f, -0.01010451f, -0.03744629f, 
    0.07882659f, -0.08648793f, -0.06111168f, -0.15003976f, 0.12378342f, -0.08521455f, 0.14549391f, -0.07807151f, 
    -0.11577755f, -0.48885557f, 0.07386794f, -0.28246492f, 0.02229775f, 0.04044756f, 0.12497900f, 0.03945317f, 
    0.09981184f, -0.01098767f, 0.03891409f, 0.07796139f, -0.01550024f, 0.03698189f, 0.04600792f, 0.09154700f, 
    0.08642259f, 0.13914503f, -0.28833041f, -0.05212077f, 0.22886376f, -0.30697393f, -0.19659880f, 0.06744102f, 
    0.18083130f, 0.03677608f, 0.01555032f, -0.46367079f, -0.09039474f, 0.02076236f, -0.12147281f, 0.23323742f, 
    0.21447754f, 0.06324559f, 0.07296399f, 0.04432040f, 0.04608614f, 0.16551501f, 0.29017627f, 0.03584142f, 
    -0.01222412f, -0.06952822f, -0.04670231f, 0.11455365f, -0.11571051f, -0.29643738f, -0.72493106f, -1.12041497f, 
    0.11614592f, -0.04430313f, 0.06158661f, 0.02045550f, -0.01241113f, -0.12377347f, -0.08374097f, 0.15802476f, 
    0.07765099f, -0.05569047f, -0.09235583f, -0.15214969f, -0.04204500f, 0.09820088f, 0.07408544f, -0.19270027f, 
    0.08591905f, 0.38216227f, -0.04982071f, -0.33267564f, 0.10099367f, -0.00422710f, -0.03442968f, 0.12058727f, 
    0.29567033f, 0.01030182f, -0.26033819f, 0.00696313f, -0.11694741f, -0.00491445f, 0.02298769f, -0.13868105f, 
    0.01978208f, -0.80531853f, -0.09707237f, 0.03146260f, 0.13042265f, -0.05828279f, -0.12950076f, -0.08374969f, 
    0.09883651f, -0.14655937f, 0.11917785f, 0.03127022f, -0.03478409f, -0.03491824f, 0.06742200f, 0.02279116f, 
    -0.01859760f, -0.06487097f, 0.08098833f, 0.20482890f, 0.10558074f, 0.21138619f, 0.09835052f, 0.17130764f, 
    -0.01607318f, -0.00416944f, -0.11045835f, -0.00887414f, 0.26290482f, -0.11199075f, -0.34262866f, 0.11905293f, 
    0.05487799f, -0.10581516f, 0.03944109f, 0.00545846f, 0.07760256f, -0.09355777f, -0.07701196f, -0.02469389f, 
    -0.00597108f, 0.03432898f, -0.13874888f, 0.16906963f, 0.06385287f, -0.05107262f, -0.09170052f, -0.20787229f, 
    0.08363207f, 0.00285980f, 0.05247153f, -0.02510108f, -0.00340242f, -0.00934436f, -0.15300778f, -0.10719280f, 
    0.14461049f, -0.05429001f, 0.05095750f, -0.01604128f, -0.20539834f, -0.08617645f, 0.08161075f, 0.09775225f, 
    0.16640006f, 0.15463968f, -0.00771403f, 0.06914654f, 0.03922309f, -0.04289435f, 0.08858784f, 0.11698251f, 
    0.02947632f, 0.05165682f, -0.22278070f, 0.35366911f, 0.11495594f, -0.00411887f, 0.06353458f, 0.05994889f, 
    0.10863029f, -0.03652610f, -0.19693522f, -0.25930828f, -0.32738692f, 0.02938681f, 0.01268890f, -0.34874681f, 
    -0.06961547f, -0.08068164f, -0.03206383f, 0.13363902f, -0.16054678f, 0.19381166f, -0.01146694f, -0.09758131f, 
    -0.02361562f, 0.04483245f, 0.15097740f, -0.04167956f, -0.10563052f, -0.06360991f, -0.16739437f, 0.04064441f, 
    -0.13105908f, -0.12981403f, -0.02419248f, 0.06465945f, 0.08518503f, -0.06406812f, 0.35809278f, -0.00165418f, 
    -0.16807932f, -0.00011881f, 0.07122699f, 0.20235918f, 0.11567290f, 0.09283356f, 0.11524901f, -0.05689517f, 
    -0.10849759f, -0.19190750f, 0.05169950f, -0.11311721f, -0.06097881f, -0.01397575f, -0.05686333f, -0.43032524f, 
    -0.36935979f, 0.07241066f, -0.28055912f, 0.07911664f, 0.06830848f, 0.00516389f, -0.05123618f, 0.04430878f, 
    -0.12411034f, -0.53016317f, -0.18129571f, -0.07000395f, 0.04952814f, 0.04807553f, -0.01125114f, 0.09142652f, 
    0.05753365f, 0.03030583f, 0.16216683f, 0.11951867f, -0.05641389f, -0.02194290f, -0.12587801f, 0.05758866f, 
    -0.00170119f, 0.07205709f, 0.21795022f, 0.05135910f, -0.10685582f, 0.06212766f, 0.10915305f, 0.08193341f, 
    -0.09493686f, -0.00250755f, -0.02196330f, -0.34096441f, 0.03380287f, 0.04416875f, -0.17960370f, -0.15869676f, 
    -0.08949299f, 0.01801420f, 0.02152955f, -0.05048239f, -0.12480418f, 0.06031775f, -0.00749763f, -0.11921428f, 
    -0.06216654f, -0.07147421f, 0.08565714f, 0.01184678f, 0.02310344f, -0.10754074f, 0.00202297f, -0.10887086f, 
    0.09951439f, -0.01378053f, 0.08633231f, 0.06434124f, -0.00180276f, 0.05212761f, -0.35360757f, -0.11496938f, 
    0.18658403f, -0.16932712f, 0.03059001f, -0.08888101f, 0.12721816f, 0.03699661f, 0.02234425f, 0.09034839f, 
    -0.13219939f, -0.37855765f, -0.13717334f, -0.17007971f, -0.11129633f, 0.09938650f, -0.01388325f, -0.13925758f, 
    -0.00826096f, 0.04295749f, 0.07900295f, -0.01619712f, -0.05165715f, -0.00382446f, 0.09371965f, -0.08945901f, 
    0.00002215f, -0.14124675f, -0.06112880f, 0.04788223f, -0.05167293f, -0.08241326f, 0.01607883f, -0.01906501f, 
    0.03393636f, -0.24971196f, -0.52368903f, -0.58170390f, -0.53765589f, -0.19246711f, -0.06128682f, 0.16247320f, 
    -0.01656285f, -0.06255576f, 0.10044666f, -0.10594322f, -0.11471014f, -0.64742488f, 0.05575098f, 0.26501229f, 
    -0.17893450f, -0.00072917f, -0.13438055f, -0.07212908f, -0.11286262f, -0.19356512f, 0.13385779f, -0.02507314f, 
    0.08820479f, -0.01055166f, -0.02364216f, 0.09394579f, 0.19546726f, 0.21257818f, -0.16749170f, 0.04021611f, 
    0.09807950f, -0.16690649f, 0.15305330f, -0.05562231f, -0.10678622f, -0.01744362f, 0.01181454f, 0.00335210f, 
    -0.01672502f, 0.06229088f, -0.10257924f, 0.09875868f, -0.12726338f, -0.03007673f, 0.10999995f, 0.02341699f, 
    0.11107204f, 0.18788950f, 0.11810603f, -0.14175475f, 0.02838506f, -0.00715627f, -0.04401702f, 0.12900731f, 
    0.11869273f, -0.45254278f, 0.24991457f, -0.25305346f, 0.18856579f, -0.19432221f, 0.17414698f, -0.12132824f, 
    0.05296296f, 0.17797822f, 0.18138070f, 0.01781732f, 0.03526104f, 0.01507415f, 0.01160628f, -0.03412847f, 
    -0.08156181f, 0.08373502f, -0.10117377f, -0.11878224f, -0.25860763f, 0.01176900f, 0.04854354f, 0.11016543f, 
    -0.02223958f, -0.03560427f, -0.03106629f, -0.22060384f, -0.43119624f, -0.40475240f, -0.13777764f, -0.05848769f, 
    0.07013891f, 0.05743313f, -0.03068647f, 0.05974666f, 0.17197488f, -0.16751455f, -0.13662432f, 0.04507986f, 
    -0.11027403f, 0.14118515f, -0.01511026f, -0.01097540f, -0.23987961f, 0.11917943f, -0.05688103f, 0.21966767f, 
    -0.05352467f, -0.07214870f, -0.30648074f, 0.17150493f, -0.00570529f, 0.10145252f, 0.07087597f, 0.08649972f, 
    0.16771168f, 0.02888893f, -0.03384012f, 0.08415714f, -0.08121768f, 0.14013261f, -0.01051970f, -0.00099430f, 
    0.09300356f, 0.07777952f, -0.11041170f, 0.05382977f, -0.00167117f, 0.06514857f, -0.04824634f, 0.03035846f, 
    -0.03782948f, -0.21444389f, -0.01462993f, -0.06891497f, 0.12108028f, 0.13490701f, 0.03601098f, 0.01703283f, 
    0.14645882f, 0.17067398f, 0.01394528f, 0.00831865f, -0.01556628f, -0.04442970f, -0.09780578f, -0.01138704f, 
    -0.04275020f, -0.07611096f, 0.10913844f, 0.04923632f, 0.29479012f, -0.10738301f, -0.09800953f, 0.10776058f, 
    -0.05778963f, 0.05741768f, -0.15296252f, -0.25443313f, -0.27938449f, 0.09634753f, 0.02640778f, -0.04251450f, 
    -0.01227167f, 0.02152852f, 0.16527246f, 0.21908124f, 0.13908665f, 0.14406507f, 0.15099329f, -0.11589488f, 
    0.00774532f, 0.09966390f, 0.03655843f, -0.05809787f, 0.07471597f, -0.20204353f, 0.12761126f, -0.01155642f, 
    -0.13345535f, 0.01756065f, -0.01189258f, -0.19818684f, 0.04921287f, 0.21890821f, -0.01901645f, 0.32247847f, 
    0.25001919f, -0.04461733f, -0.02292271f, 0.09748057f, 0.07023065f, -0.00802879f, -0.17910963f, -0.03571441f, 
    0.03790797f, -0.00175529f, 0.08160037f, 0.06220490f, 0.00466394f, 0.05511307f, 0.05101410f, 0.03076127f, 
    -0.10559947f, -0.09579258f, -0.04103659f, 0.01542898f, -0.02998105f, 0.10175290f, 0.10272621f, 0.03541314f, 
    -0.19981624f, -0.14603412f, -0.18056303f, 0.24770947f, 0.04310723f, -0.10267741f, -0.08553571f, -0.10959687f, 
    -0.07449965f, -0.06282260f, -0.04117915f, -0.00590798f, -0.26239258f, -0.13364063f, 0.08907245f, 0.05068243f, 
    -0.01177375f, 0.07142226f, -0.03117703f, 0.04319745f, 0.18864121f, 0.06587826f, 0.06002188f, 0.02927994f, 
    0.07323055f, -0.01066271f, 0.04769115f, 0.07569231f, -0.26987171f, -0.12447669f, -0.08351139f, 0.08992954f, 
    -0.11463267f, -0.04315692f, -0.08358330f, -0.10108870f, 0.07271851f, 0.33933708f, 0.17669497f, 0.01601381f, 
    0.00539494f, -0.07113862f, 0.06957301f, -0.06669108f, -0.06438695f, -0.01465543f, 0.42041266f, 0.04521821f, 
    -0.03523968f, -0.03154710f, -0.01447107f, -0.04441515f, -0.00959245f, -0.13712463f, -0.01193924f, 0.20004839f, 
    0.09540761f, 0.03296356f, -0.10189027f, 0.05291303f, -0.06498612f, 0.11252858f, 0.03107697f, 0.10285909f, 
    0.00499714f, -0.00097958f, 0.02196184f, -0.05419447f, 0.05140299f, 0.05233293f, 0.02312599f, 0.03580573f, 
    0.00892322f, 0.02377130f, -0.00083823f, -0.02259704f, -0.01571849f, -0.05590910f, 0.02806959f, -0.01152200f, 
    -0.04299124f, -0.02330680f, 0.03843208f, -0.02684291f, 0.04759364f, -0.00118674f, -0.05529847f, -0.01783598f, 
    0.04146228f, 0.00872358f, 0.03060797f, -0.00534293f, 0.00383594f, 0.03153859f, 0.04878901f, -0.02728737f, 
    -0.02462077f, 0.00739730f, -0.04885595f, 0.04050398f, -0.05192673f, 0.03781734f, 0.02579604f, 0.04218905f, 
    0.00293231f, -0.00644016f, 0.02790825f, 0.03336990f, 0.00643758f, 0.04422582f, 0.03172529f, 0.03399489f, 
    -0.04342218f, 0.00504422f, -0.03823161f, -0.01913537f, 0.05127881f, -0.04697522f, 0.01092151f, -0.02152760f, 
    0.00436816f, -0.00326325f, -0.05513153f, 0.04966822f, -0.01781423f, -0.01986044f, -0.03852220f, 0.00703000f, 
    -0.02715132f, -0.04278847f, -0.04444813f, 0.02255328f, -0.01067988f, 0.00793768f, -0.05356144f, 0.03822683f, 
    -0.05099118f, -0.04656085f, -0.02102244f, -0.01018830f, -0.00373283f, -0.02548087f, -0.02185423f, 0.02825196f, 
    -0.03582179f, -0.02322488f, -0.00560710f, -0.04895989f, -0.03152768f, -0.03435235f, 0.00943660f, -0.03525793f, 
    0.03547119f, 0.00037802f, -0.04586281f, 0.04786024f, -0.00659072f, 0.01149624f, -0.00937150f, 0.02494492f, 
    -0.01897381f, -0.05140405f, -0.04709420f, 0.04682394f, -0.03353953f, -0.05947249f, -0.03405470f, -0.01414335f, 
    -0.02567749f, -0.04888101f, -0.03454080f, -0.02646503f, -0.02056431f, -0.00078031f, -0.02675986f, -0.05552865f, 
    0.01980276f, -0.04731971f, 0.04146855f, -0.04832613f, 0.00566600f, -0.04788530f, -0.04205070f, -0.04843088f, 
    0.01831303f, -0.00251094f, 0.03902512f, -0.02009174f, 0.01289446f, -0.06236372f, 0.00370199f, 0.02136298f, 
    0.05070574f, -0.02234525f, 0.00643403f, -0.05973439f, -0.03608146f, 0.03172984f, 0.04969595f, 0.02541389f, 
    -0.00738883f, 0.05235483f, -0.00154041f, -0.01042020f, 0.00833879f, -0.06105182f, 0.02177774f, 0.01481009f, 
    -0.02696465f, -0.05068867f, -0.00401734f, -0.04144185f, -0.02292655f, 0.01512342f, -0.06314037f, -0.00450089f, 
    -0.04573410f, -0.00280951f, -0.00618636f, -0.03429757f, -0.06035277f, -0.00354362f, 0.02049719f, 0.02638359f, 
    -0.04028532f, 0.05306492f, -0.02269466f, 0.03790466f, 0.01535357f, -0.05682299f, -0.01467091f, -0.06654029f, 
    -0.05844380f, -0.00655921f, 0.05582156f, 0.04126362f, -0.04489023f, 0.00980165f, 0.04066015f, 0.01290702f, 
    0.00817037f, -0.02561290f, -0.01686970f, 0.02176992f, -0.01552598f, 0.05270473f, 0.01782391f, 0.02417479f, 
    -0.00975951f, -0.05731890f, 0.03972946f, 0.02793801f, -0.03330395f, -0.01005465f, 0.00097268f, -0.01704683f, 
    0.01048533f, -0.03270942f, -0.01729011f, 0.03477509f, -0.05600306f, 0.02998018f, 0.05448218f, 0.02348288f, 
    -0.04199667f, -0.04872588f, 0.03615678f, -0.05818092f, 0.03618122f, -0.03957273f, -0.04690188f, 0.01831780f, 
    -0.00550160f, -0.04159831f, -0.04199477f, -0.04838984f, -0.04372526f, -0.04181843f, -0.03678624f, -0.01602378f, 
    0.00672530f, 0.03206532f, 0.02658060f, 0.01092869f, 0.02786581f, -0.03792274f, 0.01119885f, -0.03663831f, 
    0.03358010f, 0.03187861f, -0.03650634f, -0.00421028f, -0.03258613f, -0.05291009f, -0.01463802f, -0.03196925f, 
    0.00728835f, 0.01656695f, -0.02707490f, 0.00239924f, -0.04803197f, -0.01628918f, -0.00145841f, -0.02646220f, 
    0.04366635f, -0.01919342f, 0.00467507f, 0.03556207f, 0.05196874f, -0.00393253f, 0.04305786f, 0.01657936f, 
    0.04659133f, -0.04512741f, 0.00373519f, 0.05226926f, 0.05134416f, -0.01878081f, 0.01470071f, -0.02775606f, 
    -0.06287290f, -0.01869955f, -0.04574536f, 0.05355167f, 0.04618974f, -0.00137719f, -0.02063425f, -0.05070885f, 
    -0.00448733f, -0.04991679f, -0.04377104f, 0.02533845f, -0.01507409f, -0.00223006f, -0.02374117f, -0.03510486f, 
    -0.03719005f, -0.01254334f, 0.00966418f, -0.02069417f, -0.04044746f, 0.02983570f, 0.04680912f, -0.05263444f, 
    -0.04488626f, -0.05078590f, -0.01069747f, -0.01447262f, -0.05039653f, -0.05252469f, 0.03562579f, -0.04507544f, 
    -0.48199275f, -0.44585833f, -0.28863937f, -0.05234450f, 0.02797273f, 0.04368955f, 0.05897164f, 0.03894218f, 
    0.13547099f, 0.03854810f, 0.02071995f, -0.02566180f, -0.09465343f, 0.04948913f, 0.06794528f, -0.06181448f, 
    -0.05946534f, -0.02355050f, -0.27297333f, -0.04457853f, 0.07448014f, -0.15722939f, -0.35387719f, -0.10980237f, 
    -0.10699514f, -0.03438191f, -0.16075923f, -0.27713141f, -0.14004727f, -0.16025722f, 0.04884580f, -0.11237983f, 
    0.08113952f, 0.18706703f, 0.19189841f, 0.08457746f, -0.04041443f, -0.01102077f, 0.21332574f, 0.09685583f, 
    -0.00613406f, -0.13962378f, 0.01200482f, 0.05297301f, 0.05428911f, 0.17146383f, 0.05054739f, -0.24048056f, 
    -0.02082374f, -0.01598974f, 0.12673970f, -0.07495798f, 0.02682062f, 0.00543886f, 0.18300775f, -0.02564752f, 
    -0.00034362f, -0.02805984f, -0.05357868f, 0.03226662f, 0.02770051f, 0.04571953f, 0.08642223f, 0.21785645f, 
    -0.04954070f, -0.09148318f, -0.23525046f, 0.09085312f, 0.06376598f, -0.13604210f, 0.09894253f, 0.06744646f, 
    0.36632374f, 0.02132203f, -0.14423734f, -0.14698729f, -0.22268622f, 0.07148782f, 0.15763552f, 0.02951306f, 
    -0.08235886f, -0.09946454f, -0.23823240f, 0.06207836f, 0.05283292f, 0.03469876f, -0.12735657f, 0.09930155f, 
    0.05066077f, -0.08542183f, -0.31441793f, 0.01588614f, -0.06726676f, 0.12249160f, 0.03354415f, 0.05383210f, 
    0.22845306f, 0.14285859f, 0.10523725f, -0.05684725f, 0.07976877f, -0.00760693f, 0.02130274f, -0.03337500f, 
    -0.02011637f, 0.12279917f, 0.06041950f, 0.00452939f, 0.54998171f, 0.22313307f, -0.44797418f, -0.00594182f, 
    0.22006397f, 0.05781453f, 0.11587659f, -0.01270523f, 0.02178939f, 0.03468765f, -0.06293738f, -0.20069660f, 
    0.01008282f, 0.15150177f, -0.14130263f, 0.02736005f, 0.10535096f, -0.01781725f, -0.20006891f, -0.07486115f, 
    0.01786341f, 0.15453334f, 0.07564169f, 0.10216177f, 0.12242702f, 0.07952242f, -0.06819168f, -0.04125178f, 
    0.07183215f, -0.10803563f, -0.04126391f, -0.00262839f, -0.03923205f, 0.00534218f, 0.04089081f, 0.13305895f, 
    0.20228735f, 0.13300657f, -0.07027324f, 0.17711163f, -0.02413480f, -0.00651460f, 0.09661397f, 0.07881433f, 
    0.04098767f, 0.07589786f, 0.05830594f, -0.00233570f, 0.13271916f, -0.07750606f, 0.03955422f, 0.04978835f, 
    0.04244019f, 0.00209821f, -0.03373872f, -0.23716667f, -0.18300898f, -0.12816967f, -0.05761448f, -0.09600687f, 
    0.11143258f, 0.01033013f, -0.05635381f, 0.47845212f, 0.14655651f, 0.09336776f, 0.03371080f, -0.13351645f, 
    -0.07698056f, 0.11412065f, 0.12134714f, -0.04444948f, -0.16645133f, 0.18351765f, -0.12946954f, 0.08231796f, 
    0.06766111f, 0.11590999f, 0.02004440f, 0.08822882f, 0.15072581f, -0.40938517f, 0.54968637f, 0.02262317f, 
    -0.00848323f, 0.12895989f, 0.11447901f, -0.05954672f, 0.07578145f, 0.04522131f, 0.21885544f, -0.18413641f, 
    -0.16363116f, -0.06945626f, 0.14023577f, -0.11845414f, -0.04364848f, 0.08589581f, 0.07164317f, -0.34802714f, 
    -0.30744442f, -0.12715974f, -0.05000234f, -0.02654747f, 0.08218957f, -0.03000869f, 0.12517458f, 0.11003349f, 
    -0.30165628f, -0.21409157f, -0.04446740f, -0.05797784f, 0.04939273f, 0.04714814f, 0.09231555f, -0.00968353f, 
    -0.06475861f, 0.16458316f, 0.05921333f, -0.06738584f, -0.10103665f, 0.02041745f, -0.04911266f, 0.06086018f, 
    -0.07938553f, 0.01456161f, 0.03322255f, 0.01398193f, -0.14259686f, 0.11190186f, 0.06721771f, 0.14788775f, 
    0.13710295f, 0.11715095f, -0.00919709f, -0.26678434f, -0.01464997f, -0.01698403f, 0.00174726f, -0.16742431f, 
    0.11023559f, 0.14551397f, -0.06535275f, 0.10070290f, 0.17032149f, -0.01220047f, -0.02270043f, -0.09563550f, 
    -0.13918579f, -0.06161044f, -0.11339366f, -0.13273032f, -0.01504464f, 0.00556552f, -0.11349306f, -0.11426547f, 
    0.06961146f, 0.04458908f, 0.17282225f, 0.06492282f, 0.05858240f, -0.05855445f, -0.15901868f, -0.30795494f, 
    -0.18022092f, 0.07869753f, 0.04689866f, -0.03899048f, -0.04532222f, 0.04558134f, -0.04569422f, 0.08022512f, 
    -0.09103531f, -0.10276990f, -0.02917446f, 0.10170949f, 0.03231105f, -0.00720347f, 0.06021202f, 0.09726309f, 
    0.15047526f, 0.06851722f, -0.02636744f, -0.07661491f, -0.07381754f, -0.16709378f, 0.07701033f, 0.02170678f, 
    -0.07333648f, -0.05950377f, 0.04288051f, 0.04506651f, -0.01819385f, -0.00462684f, -0.09635897f, 0.06580644f, 
    -0.15020430f, 0.00169334f, 0.10542184f, -0.13146460f, -0.08556969f, -0.22334078f, 0.12732568f, 0.06539142f, 
    0.01796499f, -0.03637094f, -0.21547836f, -0.38198182f, 0.13663679f, -0.25639755f, -0.04603793f, -0.06190175f, 
    -0.08256917f, -0.02738015f, 0.07789858f, -0.02094155f, 0.13560607f, -0.21895763f, -0.13667560f, 0.16543959f, 
    -0.02720943f, 0.07666154f, 0.11450559f, -0.00945926f, 0.07062099f, 0.31352893f, 0.32101965f, 0.22071514f, 
    -0.16040528f, 0.01789996f, 0.00466156f, 0.05499779f, 0.12212570f, -0.10212596f, -0.07755439f, 0.26122272f, 
    -0.02945905f, -0.14035565f, -0.01862677f, -0.05356657f, 0.12406471f, 0.04266364f, 0.04320324f, -0.16655356f, 
    -0.09118225f, -0.13334157f, 0.16909046f, -0.24215916f, -0.11682938f, -0.01778425f, 0.03914783f, 0.06025285f, 
    0.07568943f, 0.03797096f, 0.68253756f, 0.09981183f, 0.09135495f, -0.04247119f, 0.06474849f, 0.06377422f, 
    0.05031013f, -0.16984181f, -0.01411164f, -0.25983799f, -0.03969175f, -0.05851709f, 0.19432436f, -0.04059003f, 
    -0.06014632f, 0.08731556f, -0.01966321f, 0.07777692f, 0.09415706f, -0.05651092f, -0.11197928f, -0.14394075f, 
    0.04131250f, 0.04727681f, 0.02334711f, 0.27385989f, -0.02366869f, 0.34934920f, 0.05161195f, -0.11530055f, 
    0.02777258f, 0.04206640f, -0.07210876f, 0.04313375f, -0.06683559f, -0.18783925f, 0.11300511f, 0.01115544f, 
    -0.18758059f, 0.32286826f, -0.16367514f, -0.21259280f, -0.11229301f, -0.07184127f, 0.36594284f, 0.24644969f, 
    -0.03620347f, 0.00946790f, -0.12521413f, -0.12637794f, 0.16010445f, 0.18904221f, -0.04173471f, 0.05630288f, 
    0.16351885f, -0.08618300f, -0.05267819f, 0.05533509f, 0.00806999f, 0.05239292f, 0.13097706f, 0.11649422f, 
    0.24956505f, 0.29992703f, -0.17003553f, 0.02725902f, -0.06728394f, 0.19172691f, 0.02184010f, -0.14002502f, 
    0.05717310f, -0.01662113f, 0.25242409f, 0.00888837f, -0.10515456f, 0.09736872f, -0.00673704f, -0.01512310f, 
    0.01759749f, 0.08725359f, -0.21112272f, 0.04307149f, -0.17258658f, 0.05150214f, -0.09182455f, -0.03784147f, 
    0.19922650f, -0.10388980f, 0.15335043f, 0.33979374f, 0.20737258f, 0.01651364f, -0.09880686f, 0.05454634f, 
    0.02280897f, 0.18556549f, 0.07321648f, -0.16080163f, -0.38083372f, -0.09631361f, 0.05926458f, -0.08778632f, 
    0.06931541f, -0.03786220f, 0.06710821f, 0.09051137f, -0.00623282f, 0.11848489f, 0.08691989f, -0.08682215f, 
    0.14486881f, -0.06394697f, -0.01333067f, 0.08739281f, -0.09682143f, -0.18087003f, -0.44573367f, 0.04743893f, 
    -0.07879163f, -0.09705779f, -0.11131461f, 0.03283332f, -0.11177195f, 0.09742502f, -0.26067883f, 0.27488518f, 
    -0.04257280f, -0.19088891f, -0.11907461f, -0.03093752f, -0.04143435f, 0.11177743f, -0.12448310f, -0.07473879f, 
    0.19382453f, 0.10697207f, -0.16435216f, 0.13514243f, -0.25034171f, 0.11525120f, -0.01178929f, -0.05133760f, 
    -0.07744814f, 0.10664035f, 0.22314349f, -0.09109720f, 0.04975665f, 0.04057501f, 0.16160290f, -0.18464290f, 
    0.08475373f, -0.03330154f, 0.14153811f, 0.29205567f, -0.04459435f, -0.00023807f, -0.03999285f, 0.08589598f, 
    -0.14308766f, 0.06100235f, 0.00470708f, -0.06717498f, 0.48910975f, 0.00491403f, -0.15748653f, -0.18559934f, 
    0.16215301f, 0.15716428f, 0.00408315f, -0.21383210f, 0.10315780f, 0.03329592f, 0.00098518f, 0.03681999f, 
    0.12924430f, 0.01583338f, -0.02521113f, 0.01923342f, -0.12653765f, 0.14753650f, 0.01395953f, -0.07593858f, 
    0.09538031f, -0.01451728f, 0.06946937f, -0.10491110f, -0.03038985f, -0.02678152f, 0.13561220f, -0.05575388f, 
    0.04062240f, 0.06645583f, -0.10833272f, -0.05525536f, 0.05523496f, -0.00211608f, 0.22907272f, 0.06196656f, 
    -0.25961334f, -0.27162597f, 0.00537760f, -0.03290509f, -0.04264460f, 0.11378943f, -0.02962833f, -0.11877660f, 
    0.15546897f, -0.19006687f, -0.17365637f, 0.06315529f, -0.04887440f, 0.06106938f, 0.01634005f, -0.04369375f, 
    0.01420623f, -0.00261960f, -0.02652957f, 0.25767303f, 0.16013426f, 0.13371742f, 0.03603763f, -0.03807185f, 
    0.17514186f, -0.12517861f, 0.01475044f, 0.10191454f, -0.02528505f, 0.01313483f, 0.09007739f, 0.06339714f, 
    0.09951463f, 0.06176763f, -0.31691352f, -0.20632303f, 0.04785985f, 0.04623571f, -0.14791349f, 0.17543203f, 
    0.09298323f, 0.13179411f, 0.03855275f, 0.31754559f, -0.14034587f, -0.17939974f, 0.08288633f, 0.02325980f, 
    -0.04002965f, 0.03675637f, -0.01792648f, 0.05571383f, -0.11415794f, -0.12821600f, -0.08626867f, -0.09933862f, 
    -0.06954786f, 0.02556214f, -0.17627417f, -0.15243798f, -0.13775550f, 0.02499828f, -0.02107202f, 0.17320243f, 
    0.13816461f, 0.10428242f, 0.03137369f, -0.08043054f, -0.00739579f, -0.06931115f, -0.14527360f, -0.11927914f, 
    -0.21979992f, 0.01185581f, 0.08603977f, 0.05217425f, 0.06038370f, 0.02503217f, 0.01192128f, 0.00548888f, 
    0.06430709f, 0.09799159f, -0.13848929f, 0.03919525f, 0.09377168f, 0.09455456f, -0.06186089f, -0.20417581f, 
    -0.26929918f, -0.22769770f, -0.16170125f, -0.01288581f, 0.16565301f, 0.01792366f, -0.06401469f, -0.00776239f, 
    -0.17888469f, 0.12857357f, 0.12635699f, 0.03021156f, -0.08835550f, -0.11933295f, -0.07555990f, -0.01154995f, 
    -0.02297068f, -0.12625827f, -0.21687116f, 0.17002042f, 0.21469872f, 0.10890912f, 0.05398957f, 0.03578031f, 
    -0.09937623f, -0.05629596f, 0.04385252f, -0.14873618f, -0.25856531f, -0.12881197f, 0.12138047f, 0.09186255f, 
    -0.11648374f, -0.05020831f, 0.03070026f, -0.00171747f, 0.14545591f, 0.07096894f, -0.50460529f, -0.00954914f, 
    -0.05079406f, 0.12885883f, 0.01870837f, -0.11398924f, 0.13902418f, 0.14123465f, -0.05369710f, 0.14334233f, 
    -0.00681138f, 0.00308518f, 0.20665345f, 0.13916203f, -0.16630018f, 0.13141121f, 0.06442820f, 0.00850998f, 
    0.03920496f, 0.00256679f, 0.10744208f, 0.07732221f, 0.00191703f, -0.03652338f, -0.02029594f, -0.28203532f, 
    -0.13310932f, -0.14372413f, 0.02680876f, 0.00641218f, 0.00393262f, 0.12043825f, -0.12204927f, -0.03146719f, 
    0.07340612f, 0.12856223f, 0.02648325f, 0.17033176f, -0.01003636f, -0.01772258f, -0.16384655f, 0.05416767f, 
    0.06756353f, -0.04605062f, 0.06971515f, 0.07231319f, 0.12874740f, 0.13574305f, 0.16152067f, 0.02818136f, 
    0.16642167f, 0.06356350f, -0.22153080f, -0.03945966f, 0.12684628f, 0.02073908f, -0.11709076f, -0.03361452f, 
    0.01493433f, 0.01079466f, -0.06632913f, -0.19399053f, -0.05171874f, 0.11660536f, 0.05481396f, -0.06288452f, 
    -0.07331546f, -0.01274950f, -0.26324293f, -0.16310260f, -0.00621353f, 0.07150682f, 0.18424670f, 0.12035474f, 
    -0.06650775f, 0.03371613f, 0.08269142f, 0.10648215f, -0.12537496f, -0.21141018f, 0.08838873f, 0.20571259f, 
    -0.09789525f, -0.04938145f, -0.09269969f, 0.01610845f, -0.01047289f, -0.03288968f, -0.09801954f, -0.07481816f, 
    -0.01171477f, 0.08353933f, -0.02713859f, -0.09979861f, -0.15742849f, -0.02245907f, -0.04824631f, 0.03896040f, 
    -0.04153230f, -0.09069349f, 0.09249910f, 0.02740580f, 0.10101761f, -0.06628182f, -0.05268373f, 0.12223174f, 
    0.03004542f, -0.01684306f, 0.08893866f, 0.10237009f, -0.05241871f, -0.01829084f, -0.03595472f, 0.03723408f, 
    0.13938600f, -0.12433023f, -0.12345899f, -0.08922534f, -0.08690911f, -0.03897385f, -0.03132366f, -0.01202761f, 
    -0.01176539f, 0.11954210f, -0.12911643f, 0.19485570f, 0.16101742f, -0.08904921f, -0.00473613f, -0.02793752f, 
    -0.07474261f, -0.00451084f, 0.03248100f, -0.00143645f, 0.04288288f, -0.02775695f, -0.03911847f, 0.00886298f, 
    0.01139772f, -0.01967593f, -0.07006031f, -0.08772703f, -0.19565445f, -0.20822942f, -0.18592450f, 0.04729560f, 
    -0.06483395f, -0.01952648f, 0.08797491f, 0.07320467f, 0.17505321f, 0.04109051f, 0.03980576f, -0.01643017f, 
    0.11213831f, 0.07112849f, 0.07880457f, -0.12746893f, 0.08582255f, 0.15025564f, 0.04819415f, 0.04306826f, 
    0.08602663f, 0.05242399f, -0.03960641f, -0.16208237f, 0.03720798f, 0.08065695f, -0.09012790f, 0.09099863f, 
    0.01259685f, 0.15771703f, -0.01580629f, -0.03099112f, -0.11005307f, -0.01188671f, 0.00103113f, 0.00492523f, 
    -0.05557385f, -0.00281014f, -0.03754098f, -0.05333641f, 0.02757767f, -0.05490137f, 0.00957361f, -0.04231172f, 
    -0.01782648f, 0.02596131f, -0.01799663f, 0.01958734f, 0.04313016f, -0.02066875f, -0.01441930f, -0.04363735f, 
    -0.05192246f, -0.04604394f, -0.03083673f, 0.00603133f, -0.05389113f, 0.04031278f, 0.05137727f, -0.02770692f, 
    0.02818451f, -0.03184285f, 0.00591224f, -0.05382844f, 0.04794264f, 0.04792354f, -0.00216544f, -0.04792203f, 
    0.05351382f, -0.02872869f, -0.00737629f, -0.03846698f, -0.04973357f, 0.05157714f, -0.03524299f, -0.03846255f, 
    -0.01891482f, 0.01438115f, 0.00008127f, -0.03303044f, -0.01678072f, 0.00321585f, 0.04344064f, -0.02017134f, 
    0.00328660f, -0.03361113f, -0.04296927f, 0.01212775f, -0.05147112f, -0.04528369f, -0.01002002f, 0.03335943f, 
    -0.04772544f, 0.00911388f, -0.05295986f, -0.04827675f, -0.01075619f, -0.00087264f, 0.03406178f, 0.03266711f, 
    -0.01301602f, -0.05438600f, 0.03845799f, -0.00836746f, -0.00108002f, -0.05458855f, 0.02725498f, -0.03988302f, 
    0.04217632f, -0.05690077f, -0.03201746f, -0.00482702f, 0.04998899f, -0.02178835f, -0.03251778f, 0.04539353f, 
    -0.03970576f, -0.00672185f, -0.01185358f, -0.00592513f, -0.01203961f, -0.03926032f, -0.04259754f, -0.02924854f, 
    -0.05397585f, -0.03104761f, -0.02017808f, 0.01781238f, -0.02222677f, -0.03710889f, 0.00326026f, 0.00908688f, 
    0.00581764f, 0.01019758f, -0.03945807f, 0.05080557f, 0.01726324f, -0.03116307f, -0.04800842f, 0.00318091f, 
    -0.03262213f, -0.05424303f, 0.05276382f, 0.05389605f, 0.03236334f, -0.03556666f, 0.02756254f, -0.00725186f, 
    -0.01946707f, -0.00070498f, -0.02955702f, 0.00529893f, -0.05795731f, 0.04269999f, -0.03646754f, -0.01181246f, 
    0.01153467f, 0.04844722f, -0.03351597f, 0.00916289f, 0.00670740f, 0.04381698f, -0.00974203f, 0.02289948f, 
    -0.04832491f, -0.05369863f, -0.01563994f, 0.03687656f, -0.03637766f, 0.00185246f, 0.04387544f, 0.01272033f, 
    0.02241744f, -0.05259483f, 0.05798135f, -0.03294545f, -0.00619201f, -0.02719238f, 0.03783455f, -0.05166016f, 
    -0.03214823f, -0.03513398f, -0.04075959f, 0.03432510f, -0.02379475f, -0.05115376f, -0.05126930f, -0.05061354f, 
    -0.02905898f, -0.02235615f, 0.04632524f, -0.04111000f, 0.02190915f, 0.01381633f, 0.00275155f, -0.04257190f, 
    0.03825990f, -0.03073448f, -0.04020078f, -0.02424874f, -0.00010903f, 0.00023494f, -0.02317506f, -0.00270971f, 
    -0.02877917f, 0.00364884f, -0.03702532f, 0.04342148f, 0.00333919f, -0.01771697f, -0.04373878f, -0.03309778f, 
    -0.05683891f, 0.02657931f, 0.03536490f, 0.03655124f, 0.04767575f, 0.05519170f, 0.02912472f, -0.03528566f, 
    -0.04095012f, 0.04730166f, -0.00643561f, -0.03753858f, -0.01136745f, 0.02402127f, 0.05175161f, 0.01703356f, 
    0.02214931f, 0.03582161f, -0.03587389f, -0.04280189f, -0.03826206f, 0.02996262f, 0.00033421f, -0.04488266f, 
    -0.02891838f, -0.04665093f, 0.04787299f, 0.00765658f, -0.02984272f, -0.04946251f, 0.01487379f, -0.04678866f, 
    0.04967274f, -0.02142055f, 0.03313239f, 0.00580652f, 0.05336579f, 0.01012024f, -0.03198205f, 0.05355167f, 
    0.00129556f, -0.05145331f, -0.02100747f, 0.00190632f, 0.02685635f, 0.02082787f, -0.00090123f, 0.01535243f, 
    0.05512675f, -0.02554221f, 0.00886448f, -0.05222956f, -0.04323614f, -0.01408170f, -0.05341378f, -0.05628270f, 
    -0.03821132f, 0.03425447f, 0.01926097f, 0.03554615f, -0.00746002f, -0.00877613f, 0.02287713f, -0.02724888f, 
    0.01341048f, -0.04419692f, -0.00984814f, 0.04834433f, -0.01148235f, -0.03810942f, -0.05624764f, -0.03107907f, 
    -0.01248473f, 0.01664958f, 0.00124931f, 0.02944186f, 0.04567816f, -0.03844884f, -0.03888027f, 0.00490955f, 
    0.05764447f, 0.04557736f, -0.00096339f, -0.02720352f, 0.01480841f, 0.03239167f, 0.00932090f, -0.01078007f, 
    0.04761863f, -0.01041345f, -0.03826025f, -0.01953256f, -0.05428496f, -0.04626630f, -0.04673047f, -0.03027578f, 
    -0.04479012f, 0.01594603f, -0.03182010f, 0.03771675f, -0.01203388f, 0.04858042f, 0.01632503f, -0.02313229f, 
    0.00795607f, -0.04035098f, -0.05395579f, 0.02098195f, -0.04402063f, 0.03333539f, -0.03424600f, -0.05409246f, 
    0.02791173f, 0.03076714f, 0.05242439f, 0.01578228f, -0.02927534f, 0.03852142f, -0.03718484f, -0.02150264f, 
    -0.00895383f, -0.00876804f, 0.03498034f, 0.02950012f, 0.02216114f, -0.05150393f, 0.02075098f, 0.00390113f, 
    -0.04343268f, 0.00911149f, -0.06437530f, -0.04143050f, 0.02691422f, 0.00385629f, 0.04568986f, -0.01326257f, 
    0.01184372f, -0.00976099f, 0.03638079f, -0.03563066f, -0.00552489f, 0.03934698f, -0.05866050f, 0.04017675f, 
    -0.03215967f, 0.05263046f, 0.04880248f, -0.05590746f, -0.02363532f, 0.01602889f, -0.01097220f, -0.02832644f, 
    -0.04214523f, 0.01582253f, 0.01133513f, -0.03552321f, -0.03126857f, 0.02124489f, -0.06690466f, 0.02747388f, 
    -0.02427871f, -0.01257827f, 0.02191349f, -0.04878357f, -0.06419179f, -0.06075612f, -0.00384306f, 0.01013659f, 
    -0.02272095f, 0.03568670f, 0.01789618f, -0.03024887f, -0.03392189f, -0.01878918f, -0.05833134f, -0.06293558f, 
    -0.01889186f, -0.03797039f, -0.06308935f, 0.03077591f, 0.02885123f, 0.03930818f, -0.00794489f, 0.01084600f, 
    -0.00922003f, -0.05378338f, -0.05690525f, -0.05014141f, 0.01200688f, -0.03326556f, 0.03723329f, -0.04685768f, 
    -0.00671004f, -0.02188201f, 0.04601429f, -0.04320078f, 0.01546723f, -0.02058821f, 0.01926049f, 0.01386386f, 
    -0.05584149f, 0.00100547f, 0.01086884f, 0.04771287f, -0.02937946f, 0.01556410f, 0.02096314f, -0.06705786f, 
    -0.03698222f, -0.05272913f, 0.04272978f, -0.02926564f, 0.01983462f, 0.00308491f, 0.01621375f, 0.03993294f, 
    -0.01151752f, -0.02034649f, 0.00659099f, 0.02603110f, -0.02636621f, 0.02885732f, -0.02221948f, 0.00422577f, 
    0.05047021f, 0.00754601f, -0.05698024f, 0.03162490f, -0.01062596f, -0.06486268f, 0.03920525f, 0.01807942f, 
    -0.02823565f, -0.06598023f, -0.01847998f, 0.03310918f, -0.07042934f, 0.02096682f, -0.06577193f, 0.02707727f, 
    -0.06040752f, 0.01139439f, -0.00417452f, 0.02704024f, 0.04270943f, -0.04722976f, -0.00530373f, -0.05730141f, 
    -0.06099994f, 0.00601676f, 0.01306935f, -0.06536666f, -0.00700753f, -0.05744021f, 0.00628188f, 0.04669621f, 
    -0.04166041f, 0.02946838f, -0.06188356f, -0.01593394f, -0.03250908f, -0.00697328f, 0.00118844f, 0.03072448f, 
    0.01035646f, 0.01709290f, 0.02758286f, -0.05415972f, -0.00590212f, -0.05164791f, 0.00861616f, -0.06441738f, 
    -0.01534414f, -0.05922981f, -0.01043896f, 0.02792977f, 0.01331387f, -0.04584853f, -0.04096074f, 0.02115375f, 
    -0.04290235f, 0.04276920f, -0.04659011f, -0.01356430f, 0.04977951f, -0.03857752f, -0.04989370f, -0.00249836f, 
    -0.01166254f, 0.01497835f, 0.02913573f, 0.00821219f, 0.00312912f, -0.06674989f, 0.02708270f, 0.00995314f, 
    -0.05002895f, -0.04155236f, 0.02783825f, -0.00586638f, -0.04940739f, 0.04943222f, -0.06275049f, 0.04362063f, 
    0.02850124f, 0.03960991f, 0.00585442f, -0.00567751f, -0.00448836f, -0.03548278f, -0.01142451f, -0.06331873f, 
    -0.03764995f, 0.02751521f, -0.01889391f, 0.04477834f, -0.04598529f, 0.02851060f, 0.02587477f, -0.06179509f, 
    -0.01938399f, -0.03220584f, 0.04937099f, -0.00073059f, 0.01566491f, 0.02743472f, 0.02870906f, -0.00995318f, 
    0.00566877f, -0.05937007f, -0.05668868f, 0.03640196f, -0.02404127f, -0.05805916f, 0.05649879f, -0.01075816f, 
    -0.02750826f, -0.01717337f, -0.01947015f, 0.04474765f, -0.00330564f, 0.04663020f, 0.04535866f, -0.03246439f, 
    0.00524657f, 0.02229941f, -0.01238849f, -0.00451549f, -0.03804468f, -0.02054868f, -0.05760377f, -0.06606966f, 
    -0.05938138f, -0.03093149f, 0.03186009f, -0.03829106f, 0.01216471f, -0.03916760f, -0.00556644f, -0.03287955f, 
    0.01010067f, 0.01920829f, -0.05432231f, 0.05050996f, -0.00355236f, 0.01417723f, -0.03926129f, 0.02119607f, 
    0.02715611f, -0.02987942f, -0.05739658f, 0.00080448f, -0.05788564f, -0.03042918f, -0.00120698f, 0.03930911f, 
    0.04379989f, -0.01726848f, -0.01468615f, -0.06191973f, 0.02622130f, -0.04807362f, -0.00075128f, 0.00674613f, 
    -0.04104318f, 0.03221767f, 0.03437280f, -0.05482702f, -0.01524495f, -0.01807888f, -0.00108362f, 0.02181608f, 
    -0.05279013f, 0.00585553f, -0.02469733f, 0.04697128f, -0.04267297f, 0.03421854f, 0.00138477f, 0.04594023f, 
    0.22906515f, 0.18394811f, 0.11969914f, -0.06913089f, -0.10593626f, -0.09371471f, 0.02797760f, 0.00528087f, 
    -0.05120935f, 0.29742888f, -0.01583361f, -0.13519725f, 0.01077317f, 0.01636149f, -0.02394725f, -0.13950574f, 
    0.02383778f, -0.00553784f, 0.05920762f, 0.15497188f, -0.03764973f, -0.02625390f, 0.08667856f, -0.21008705f, 
    0.02354731f, -0.11376429f, -0.00326561f, -0.00405126f, 0.12769020f, 0.08564649f, 0.02518675f, 0.08125945f, 
    0.09299739f, 0.04344207f, 0.05044136f, -0.12210662f, 0.18805858f, -0.11129487f, 0.09064185f, 0.16011280f, 
    -0.03895180f, 0.17658715f, -0.09346001f, -0.12724951f, 0.15396157f, 0.07704608f, -0.03344742f, 0.15618570f, 
    0.07062878f, -0.09288805f, 0.17870890f, 0.09499170f, 0.09043064f, 0.09102303f, -0.26564559f, 0.00731953f, 
    0.08385326f, -0.00604695f, 0.01835102f, 0.05091280f, -0.05454897f, 0.00789802f, 0.09916740f, 0.06812537f, 
    -0.13182451f, 0.07241388f, 0.06557836f, -0.15743981f, 0.14426346f, 0.00149068f, 0.08349173f, -0.10625737f, 
    0.00776440f, 0.29020375f, -0.00051042f, 0.12331238f, -0.04418294f, 0.20468038f, 0.11874690f, -0.04138080f, 
    0.03577534f, -0.16402072f, -0.05025943f, 0.24148849f, -0.05681247f, -0.05102883f, 0.09626257f, -0.01797639f, 
    0.23469779f, -0.04630882f, 0.33550152f, -0.10627522f, -0.26880106f, -0.02347818f, -0.11370187f, -0.27372181f, 
    0.01031377f, 0.14024799f, -0.11567407f, 0.19689889f, 0.11071364f, -0.02043842f, 0.07255507f, -0.06830987f, 
    0.19679576f, -0.05109499f, -0.12313589f, -0.07829809f, -0.23583582f, -0.04291377f, 0.18945344f, -0.03272476f, 
    0.04627900f, 0.12516971f, -0.03312415f, -0.02496262f, -0.13807924f, -0.12676159f, -0.07658010f, 0.11335953f, 
    0.05162011f, -0.05956092f, -0.27549428f, -0.17968975f, -0.04015149f, -0.13484424f, -0.02939063f, 0.08353649f, 
    0.18682246f, -0.06903836f, -0.12577437f, -0.10570363f, -0.01038801f, 0.02027510f, 0.01128900f, 0.12640943f, 
    -0.01862512f, -0.00242043f, -0.01054004f, 0.02912257f, -0.00328767f, -0.06361085f, -0.01769264f, -0.00735578f, 
    -0.18606667f, -0.32220396f, 0.06161825f, 0.05519055f, -0.11275017f, 0.15200843f, -0.06711109f, -0.03571881f, 
    -0.13420279f, 0.16080260f, 0.06445632f, 0.14930268f, -0.03520406f, -0.03203986f, -0.01568702f, -0.07506429f, 
    0.02236923f, -0.03664991f, 0.27714628f, 0.15236907f, 0.25007236f, 0.04060300f, -0.09022900f, 0.07728332f, 
    0.17454062f, 0.14049678f, 0.07722126f, 0.17937177f, -0.32110325f, 0.04081170f, 0.08679160f, -0.06697606f, 
    0.10804486f, 0.03081798f, 0.08063809f, 0.03089276f, -0.01220185f, 0.15859948f, -0.01218145f, -0.02943782f, 
    -0.03050759f, -0.12261321f, -0.03961043f, 0.03504166f, 0.01370426f, 0.06186647f, 0.08110884f, -0.00525999f, 
    -0.05938159f, 0.16917841f, 0.14744829f, 0.16496544f, -0.08876403f, -0.02975434f, 0.29070577f, 0.11675064f, 
    0.34918422f, 0.03717366f, 0.17626283f, -0.00329224f, 0.09707974f, 0.04227828f, 0.15674841f, 0.03267935f, 
    0.23504293f, 0.15866971f, 0.01384221f, -0.04178801f, 0.01847015f, 0.00172909f, -0.08529232f, -0.26508078f, 
    0.24137218f, 0.09779828f, -0.18665183f, 0.16952337f, -0.05508027f, 0.02764513f, -0.08414320f, -0.03073435f, 
    -0.11613603f, -0.09204093f, -0.14913298f, -0.05964287f, -0.09317938f, 0.02544840f, -0.08972679f, -0.11173907f, 
    -0.03825498f, 0.12710865f, 0.34294641f, -0.26902595f, -0.28886291f, 0.02350599f, -0.07790385f, -0.09124143f, 
    0.03090471f, 0.01464806f, -0.06785981f, -0.01159823f, 0.09065795f, 0.14616814f, -0.19464993f, -0.01201086f, 
    -0.01537134f, 0.10622965f, 0.04044427f, -0.03546408f, -0.16459604f, -0.00382574f, 0.14402354f, -0.03984952f, 
    0.01977082f, -0.08722913f, -0.17301866f, -0.10728554f, 0.02042050f, 0.05875158f, 0.21705262f, 0.12444538f, 
    0.02013789f, 0.02881831f, 0.04638727f, -0.05917889f, 0.01221753f, -0.15964243f, 0.09595338f, 0.17519949f, 
    0.07684776f, 0.08954684f, 0.10441225f, 0.02062912f, -0.00713057f, 0.05778942f, 0.04981530f, 0.10194023f, 
    0.09905069f, 0.04512398f, 0.00557140f, 0.03600587f, -0.13224220f, -0.00529379f, 0.07095886f, 0.16527694f, 
    -0.11949779f, -0.26401100f, -0.44636080f, 0.10981762f, -0.17414896f, 0.13008377f, -0.04362335f, 0.00329074f, 
    0.00989011f, 0.01401135f, 0.13555863f, 0.08440749f, -0.06906222f, -0.03155121f, 0.03857129f, 0.06198245f, 
    0.12486427f, -0.07298029f, -0.05903894f, 0.06609636f, 0.20963983f, -0.16889741f, -0.16469744f, -0.23563088f, 
    0.13746272f, 0.12909333f, -0.01779241f, 0.07291009f, 0.27811456f, -0.18072337f, 0.01121317f, -0.00783380f, 
    -0.06227945f, 0.08877634f, 0.14001225f, -0.05858932f, 0.13895531f, 0.03070168f, 0.34552866f, 0.03081474f, 
    0.04383290f, 0.16900244f, 0.00679319f, -0.00165026f, 0.11453711f, -0.43536568f, -0.20893013f, -0.43219531f, 
    0.04032637f, -0.11730906f, 0.03669690f, -0.03453606f, 0.04251733f, -0.17764026f, 0.13516167f, -0.01187280f, 
    0.11987232f, 0.03494542f, -0.02456729f, -0.05882363f, 0.01217715f, 0.06902425f, 0.01410985f, -0.08889563f, 
    -0.15874219f, -0.12463485f, -0.08059465f, -0.19000405f, 0.11812723f, 0.06662519f, -0.20278151f, -0.02171490f, 
    0.46305656f, 0.18679112f, -0.12993439f, 0.04680140f, -0.23894706f, 0.12208011f, 0.16177259f, 0.02650466f, 
    -0.08544686f, 0.06816018f, -0.17822243f, 0.06307431f, -0.01441030f, -0.02073833f, -0.16344053f, 0.07787863f, 
    0.02859006f, -0.14408572f, 0.19224560f, 0.03983392f, -0.14133410f, 0.02633404f, 0.06622630f, 0.12249883f, 
    -0.02134622f, -0.00918668f, 0.10344321f, 0.08694660f, 0.13241248f, 0.25852323f, 0.02882723f, 0.04506193f, 
    -0.00047163f, 0.12545292f, -0.00037218f, 0.01266266f, 0.32269815f, 0.05757101f, -0.25037244f, 0.12256658f, 
    -0.07831752f, 0.03564925f, -0.08604363f, -0.00257503f, -0.11528537f, 0.05822273f, -0.10984164f, -0.05501875f, 
    -0.02083454f, 0.07518041f, -0.17158732f, -0.03316227f, -0.08431058f, -0.02814565f, -0.00519746f, -0.39175695f, 
    0.00242479f, -0.01655196f, 0.07024657f, -0.07170928f, 0.03941680f, -0.02206043f, 0.01938894f, -0.05371132f, 
    0.06564075f, 0.04759606f, -0.10794482f, -0.03342753f, -0.19549313f, 0.13820827f, -0.10100224f, 0.02997830f, 
    0.00526699f, 0.09001553f, 0.13042003f, 0.00783520f, -0.05734204f, 0.02092143f, -0.00247491f, -0.01619220f, 
    -0.03224590f, 0.03068907f, -0.19900179f, 0.26183537f, -0.06262732f, -0.08882636f, -0.03869916f, 0.08889868f, 
    0.10952263f, -0.01858274f, -0.21877639f, -0.31864864f, -0.35062486f, 0.01672712f, 0.04721468f, -0.29751539f, 
    -0.05197203f, 0.12920089f, -0.08219502f, 0.53247136f, -0.16694085f, 0.09321035f, 0.08150668f, -0.04974505f, 
    0.23087424f, 0.17591158f, 0.03912282f, 0.09690776f, -0.11375598f, 0.20540056f, -0.07237431f, 0.03041130f, 
    -0.04327768f, -0.01705172f, -0.08757493f, 0.05566150f, -0.06862867f, 0.08367497f, 0.39960957f, -0.20196137f, 
    -0.15956268f, 0.15886027f, 0.02493617f, 0.03608336f, 0.04841307f, 0.09269816f, -0.06021124f, -0.21205720f, 
    -0.10805941f, -0.02114414f, 0.19045499f, 0.00696879f, -0.09273829f, 0.03107194f, -0.02189713f, -0.02707871f, 
    -0.06741866f, -0.14805122f, -0.09294933f, -0.00628173f, 0.19002068f, -0.01163933f, 0.01681233f, -0.07868074f, 
    -0.20058951f, -0.05895225f, -0.31129852f, 0.00688496f, -0.08296107f, 0.10572700f, 0.02451324f, 0.05975947f, 
    -0.07813181f, 0.14325553f, 0.17649406f, 0.01597770f, -0.06952052f, 0.06641520f, 0.06655498f, -0.03469950f, 
    -0.12638076f, -0.03383306f, 0.23385994f, 0.09131885f, -0.02464453f, 0.05274076f, 0.04012247f, 0.20458604f, 
    -0.00875114f, -0.00607590f, 0.10382560f, -0.08402293f, -0.04696735f, 0.02395675f, -0.04133813f, -0.06505267f, 
    0.12534775f, -0.05051440f, 0.00271128f, -0.03830534f, 0.07357794f, 0.16044316f, 0.03235893f, -0.04024426f, 
    -0.04755409f, -0.09139685f, 0.06125094f, 0.09484165f, 0.00295967f, 0.12398065f, -0.03909354f, -0.05000909f, 
    0.08803646f, -0.08429822f, -0.14467506f, 0.03928758f, 0.10645711f, -0.10334013f, 0.09992745f, -0.47512051f, 
    0.17504980f, -0.05902392f, -0.08532894f, -0.08838285f, 0.02066820f, -0.04269507f, 0.04012573f, 0.05869911f, 
    -0.01575419f, 0.02089719f, -0.02956477f, 0.20773228f, -0.09434201f, -0.04979911f, -0.05401924f, -0.12952447f, 
    -0.18613048f, -0.03099136f, -0.06395262f, 0.13274904f, 0.01550574f, 0.17315936f, -0.06934869f, 0.12260547f, 
    0.04330879f, 0.05641374f, 0.04112456f, 0.10697626f, -0.03169264f, 0.05158613f, 0.09799232f, 0.09805477f, 
    0.02764560f, 0.00921080f, -0.18947102f, -0.23662925f, 0.44357938f, 0.09659330f, -0.10171847f, 0.03959526f, 
    -0.04867256f, 0.12297375f, 0.04104034f, 0.08858834f, 0.21410593f, 0.32683194f, 0.12582694f, 0.07360175f, 
    -0.03698937f, 0.10997927f, -0.06710780f, -0.00251211f, -0.15148994f, 0.00908180f, 0.04528372f, -0.00925969f, 
    -0.06401467f, 0.08253188f, -0.04684731f, -0.01637514f, -0.15092146f, -0.02438278f, -0.09817661f, -0.21296328f, 
    0.07137443f, 0.09459775f, 0.25943753f, 0.03735617f, -0.01747870f, 0.03300297f, -0.04565337f, 0.14675468f, 
    0.09684079f, 0.04627701f, 0.06302103f, 0.11177370f, 0.10881492f, -0.00076015f, -0.12265858f, 0.20847026f, 
    -0.14782639f, -0.03057408f, -0.05916090f, 0.18196304f, 0.04692320f, -0.02225703f, -0.00425246f, 0.00220894f, 
    -0.37910658f, 0.26264784f, 0.21277671f, 0.07189324f, 0.23021632f, 0.04915384f, -0.07270896f, -0.01160625f, 
    -0.07421374f, -0.08633490f, -0.16485792f, -0.06389073f, -0.03385225f, -0.04190743f, -0.08428697f, 0.08638408f, 
    -0.17921159f, -0.12571214f, -0.03482919f, 0.28845406f, 0.04752674f, 0.02920318f, -0.13440202f, 0.06084248f, 
    0.08357288f, -0.04289871f, 0.05594527f, -0.08421759f, -0.00196639f, -0.06507076f, 0.09400447f, -0.00349645f, 
    0.06842224f, 0.05932406f, 0.10596953f, -0.01620171f, 0.11411025f, -0.18164939f, 0.28820989f, -0.07147551f, 
    0.09517685f, 0.22053595f, -0.06054812f, -0.16700259f, 0.07631425f, 0.08551051f, 0.12422924f, 0.23112059f, 
    0.09774224f, 0.06377939f, 0.04664838f, -0.11042059f, 0.07010502f, 0.24098967f, -0.07256424f, 0.00863245f, 
    -0.12406610f, -0.02596555f, 0.03763183f, -0.03676797f, 0.01848068f, -0.01669544f, 0.05929483f, -0.13832568f, 
    -0.15979970f, -0.01109654f, -0.03781344f, 0.01117669f, 0.04957126f, 0.16438574f, -0.09854125f, -0.13770293f, 
    0.18116482f, 0.08197989f, 0.04538025f, 0.10648972f, -0.00352002f, 0.17162979f, -0.01125107f, -0.08532554f, 
    0.02033798f, -0.24875510f, 0.02083613f, 0.00641946f, 0.03320855f, 0.08095524f, 0.19706051f, -0.15750857f, 
    0.18761078f, 0.12385313f, -0.07730526f, -0.11380966f, -0.30389744f, -0.12196107f, -0.01637470f, 0.06119897f, 
    0.10318293f, -0.05526400f, -0.04920885f, 0.04319881f, 0.23667808f, -0.08353644f, 0.00938129f, -0.15030308f, 
    -0.04325051f, -0.18354210f, -0.05345071f, -0.00330775f, -0.02221108f, -0.14956595f, 0.13454311f, 0.04862284f, 
    0.06330281f, 0.10410222f, -0.04934076f, 0.02696105f, -0.01623735f, -0.03309713f, 0.08199527f, 0.41626060f, 
    0.18014586f, -0.04854547f, 0.06825195f, -0.06580451f, -0.24232613f, -0.02978321f, 0.14077848f, -0.08743959f, 
    0.03436834f, 0.10690888f, 0.09823649f, -0.16376285f, 0.06165225f, -0.08402959f, -0.18746366f, -0.12967531f, 
    -0.06322767f, -0.07231444f, 0.09010229f, 0.09784527f, 0.11072657f, -0.19007823f, 0.03239415f, -0.13862622f, 
    0.01673641f, 0.10483222f, -0.04868629f, -0.00749610f, -0.12056799f, 0.04980049f, 0.09825341f, 0.07148949f, 
    -0.14412314f, 0.10239281f, 0.06509928f, 0.17739627f, -0.00691078f, 0.03349324f, -0.04371335f, 0.11902113f, 
    0.00028279f, 0.06462105f, -0.03720608f, 0.14723821f, -0.01633292f, -0.06181583f, -0.11910338f, -0.00403922f, 
    0.03543229f, 0.11521763f, -0.06067270f, -0.18691012f, -0.08394378f, -0.13762186f, 0.11907191f, -0.18665250f, 
    0.11157162f, -0.06155349f, -0.02351990f, -0.00409302f, -0.01271627f, 0.07069090f, 0.11120623f, 0.06662638f, 
    -0.00266010f, 0.04393651f, 0.07729346f, 0.14134730f, -0.01570383f, -0.18773621f, -0.07205990f, -0.01938578f, 
    0.17015503f, 0.04818915f, 0.10150219f, -0.02840302f, 0.06225371f, 0.11394773f, -0.14919920f, -0.29507786f, 
    -0.04579716f, -0.11940540f, 0.05104147f, 0.07216826f, -0.07185639f, 0.02411648f, 0.03455653f, -0.18930233f, 
    -0.17348310f, -0.02047137f, -0.09617233f, 0.01145402f, 0.01637830f, -0.05790152f, -0.09801547f, -0.06638526f, 
    0.05790908f, -0.05962826f, -0.13855709f, -0.03899471f, -0.02916291f, 0.00188440f, -0.00530174f, 0.02421166f, 
    0.08944255f, -0.05870586f, -0.12744726f, -0.02742741f, 0.04678168f, 0.03602088f, 0.07309733f, -0.04353780f, 
    0.02533756f, 0.13045804f, 0.22179948f, 0.35808268f, 0.02856767f, -0.01918735f, 0.12083368f, 0.05727734f, 
    0.04724468f, -0.02027513f, 0.18672702f, 0.03008369f, -0.08849099f, -0.01403428f, 0.01267956f, -0.09328534f, 
    -0.07460255f, -0.05362515f, 0.01994117f, 0.00760890f, 0.09942897f, -0.16363667f, -0.02032921f, -0.05686150f, 
    -0.07668339f, 0.00105885f, 0.28407887f, 0.16166469f, -0.04426145f, 0.26205164f, 0.39676577f, 0.08904719f, 
    -0.13518082f, 0.09263996f, -0.05807259f, 0.13089661f, -0.05869155f, -0.00357420f, 0.01574188f, 0.10695541f, 
    0.01726772f, 0.11349851f, -0.02134598f, 0.09290315f, -0.00810980f, -0.01744898f, -0.02763805f, 0.01874184f, 
    -0.12190698f, -0.16420308f, -0.02473246f, 0.15061405f, 0.04005022f, 0.15876335f, 0.10275804f, -0.19564721f, 
    -0.07132552f, 0.10669886f, 0.52684540f, -0.06094943f, 0.01889975f, -0.05627275f, 0.07389802f, -0.04111743f, 
    0.09393233f, -0.04526462f, 0.08113886f, -0.06566203f, -0.11643257f, -0.22845371f, 0.03177612f, -0.06837846f, 
    0.19865882f, -0.06177587f, -0.09180411f, -0.09094775f, 0.30579823f, 0.17087683f, 0.23460624f, 0.10151388f, 
    0.01611095f, -0.01343153f, -0.09885741f, -0.08240648f, -0.00377352f, 0.23099959f, 0.03402330f, 0.03499987f, 
    0.07245875f, 0.04740512f, -0.32976180f, 0.05707083f, -0.27884644f, -0.03094133f, 0.45222399f, -0.02658199f, 
    -0.01811916f, -0.02969511f, 0.05610207f, 0.04329450f, -0.00885636f, 0.20251638f, 0.14969198f, 0.15174638f, 
    0.18851824f, 0.21245214f, 0.10157959f, 0.09269339f, -0.05910001f, 0.20928088f, -0.01150087f, 0.05709537f, 
    -0.09790935f, 0.16827656f, -0.17150269f, 0.25217813f, -0.09878948f, 0.15997018f, -0.00706946f, 0.10189497f, 
    0.01709061f, 0.22230458f, 0.08098117f, 0.10700694f, 0.02813390f, -0.05389974f, -0.01268002f, -0.10626153f, 
    0.07245555f, 0.07049480f, 0.27905241f, 0.02291483f, 0.02596460f, 0.08066110f, 0.16754876f, -0.19409508f, 
    -0.00055660f, -0.10172340f, 0.04672723f, -0.01514390f, 0.14368856f, 0.03617597f, -0.10366010f, -0.00410329f, 
    0.07787612f, 0.06876858f, -0.08380958f, 0.11579537f, 0.11088937f, 0.16898143f, -0.04738206f, -0.12621972f, 
    -0.00595836f, 0.04232647f, 0.05171250f, -0.13939027f, -0.11852601f, 0.03777348f, 0.06286791f, -0.01326199f, 
    0.20040682f, 0.15959856f, 0.04289638f, -0.01315807f, 0.20920213f, 0.15710965f, 0.03208943f, 0.02031450f, 
    0.15574752f, -0.15393436f, -0.02576513f, -0.10743453f, 0.09175526f, -0.13144848f, -0.02689725f, 0.16026698f, 
    0.06802544f, -0.20027976f, -0.14301193f, 0.19056854f, 0.06203805f, 0.17364962f, -0.12341502f, 0.12280999f, 
    0.05628478f, -0.06864974f, 0.02486908f, -0.09208942f, 0.02789919f, -0.24083440f, -0.01613243f, -0.12422998f, 
    0.05779755f, -0.30749425f, 0.06565962f, 0.00375251f, -0.05351966f, -0.02795822f, 0.00563970f, 0.12479500f, 
    0.03214031f, -0.12967819f, 0.01689530f, -0.10587563f, 0.06760678f, -0.04596786f, 0.03725990f, 0.02811460f, 
    0.03859934f, -0.08519849f, -0.08312305f, 0.12956198f, 0.09229620f, 0.11001559f, 0.11450182f, 0.13413604f, 
    -0.15742412f, 0.08350958f, -0.04671952f, -0.07157975f, 0.16640569f, -0.03623755f, 0.04264893f, 0.03701423f, 
    0.00021948f, -0.07599901f, -0.01438292f, -0.00255996f, 0.03762304f, -0.15776981f, 0.20705706f, -0.01598619f, 
    -0.02902083f, -0.05692365f, 0.11982172f, 0.11427491f, 0.07896726f, 0.08845244f, 0.10703133f, 0.13237832f, 
    0.01085806f, 0.02619479f, 0.08892728f, 0.03636489f, -0.02525767f, -0.08071988f, -0.00179967f, -0.04379713f, 
    -0.09939887f, -0.06516462f, -0.22190478f, -0.03894364f, 0.12849037f, -0.02045752f, -0.13406505f, 0.10420533f, 
    -0.18161441f, -0.06984727f, -0.01194899f, -0.11127301f, 0.04026187f, -0.05057912f, -0.11185834f, -0.00088152f, 
    0.10642760f, 0.07791263f, 0.07070021f, -0.10456825f, -0.05291098f, 0.02071127f, -0.05898067f, 0.03940522f, 
    -0.04869479f, -0.09888624f, 0.02780252f, 0.13420936f, 0.01935786f, -0.06102040f, 0.03924188f, -0.01938810f, 
    0.07601306f, 0.12983200f, 0.20964989f, 0.09148011f, -0.05716464f, -0.07489815f, 0.00162263f, 0.19796601f, 
    0.12338807f, 0.08987232f, -0.20665413f, 0.06595566f, 0.44715905f, 0.00676110f, 0.11036924f, 0.06471583f, 
    0.10294335f, 0.30357525f, 0.11006260f, -0.34731555f, -0.27963769f, 0.14186133f, 0.12274690f, 0.07586244f, 
    -0.10849350f, -0.06709928f, 0.03406044f, 0.11543043f, -0.17133641f, -0.12274181f, -0.13041551f, -0.04573610f, 
    -0.15148617f, -0.30170226f, 0.13830331f, -0.00237912f, -0.18963461f, 0.13388672f, -0.32236829f, -0.35751653f, 
    -0.06337948f, 0.00095217f, 0.17980884f, -0.13350548f, 0.03137981f, -0.00180596f, 0.17774540f, 0.04120639f, 
    0.20784354f, 0.05547926f, 0.01831789f, 0.09360527f, 0.12165115f, 0.06118384f, -0.00543850f, 0.11182497f, 
    -0.00019458f, 0.15434708f, 0.12118467f, 0.04573805f, 0.23318288f, 0.06686439f, -0.31037501f, 0.08018180f, 
    -0.08242832f, -0.10021503f, -0.19033234f, 0.02397559f, 0.03698193f, 0.14451335f, -0.02745106f, -0.01282273f, 
    -0.08121778f, -0.15360959f, -0.15419081f, -0.05662757f, -0.03962648f, -0.20351040f, 0.05191074f, 0.00130939f, 
    -0.43286896f, 0.08970480f, 0.01892328f, 0.02832623f, -0.02514769f, 0.01342642f, 0.00547804f, -0.11524820f, 
    0.05341058f, -0.06981238f, 0.02711685f, 0.13616739f, 0.28112909f, -0.12126277f, 0.08663587f, 0.01103424f, 
    -0.09012283f, 0.10105804f, -0.01761098f, -0.17371312f, 0.20323998f, -0.21912700f, -0.32305753f, -0.08664098f, 
    0.04048913f, 0.18141071f, 0.00646072f, -0.11527357f, -0.12645388f, -0.03166396f, 0.32007354f, 0.24621974f, 
    -0.13896345f, 0.14985292f, 0.18105270f, -0.00772645f, 0.05375893f, 0.05289228f, -0.06042140f, -0.05491567f, 
    0.14222147f, -0.03203395f, -0.09345858f, -0.07569692f, -0.04421058f, -0.22264005f, -0.02102918f, 0.16603933f, 
    -0.10881449f, -0.07412306f, 0.00479037f, -0.04094933f, 0.04083881f, 0.06950112f, 0.04771130f, -0.05478992f, 
    0.03378575f, 0.10109700f, -0.15600169f, 0.10797369f, 0.00607186f, 0.00580548f, 0.06389508f, -0.01539245f, 
    -0.17213970f, -0.05382564f, -0.15185876f, -0.04084942f, -0.09357023f, -0.08712481f, -0.11742601f, -0.03115305f, 
    0.09133022f, -0.04554126f, -0.03032130f, 0.03640245f, 0.19406326f, -0.05753408f, 0.05263175f, -0.03732895f, 
    0.02099854f, -0.29178607f, 0.01420539f, -0.22094761f, 0.01952835f, 0.11344003f, 0.09832876f, -0.11262050f, 
    -0.20980246f, -0.08742262f, -0.09561229f, 0.14213227f, 0.01846854f, -0.45427066f, -0.07950979f, -0.02483251f, 
    0.06954496f, -0.06445455f, -0.08173200f, 0.00584185f, -0.06669056f, -0.20227045f, 0.06306782f, 0.15891442f, 
    0.04605867f, -0.03543706f, 0.00014964f, 0.04690641f, -0.29507157f, -0.22270788f, 0.31154272f, -0.38709462f, 
    0.05418970f, -0.09969873f, -0.10714130f, -0.01006002f, 0.10070986f, -0.10673497f, -0.23601022f, -0.25354332f, 
    -0.01442391f, 0.13116854f, 0.15586890f, -0.12493899f, 0.00632181f, -0.02681176f, -0.05995103f, 0.07219654f, 
    0.03158382f, 0.04383173f, -0.05433640f, -0.07540405f, -0.13661882f, -0.01812613f, 0.20867628f, 0.15803291f, 
    0.11364413f, 0.08356945f, 0.31436488f, 0.19449905f, -0.16932780f, 0.07035504f, 0.17960341f, 0.21123351f, 
    0.03652477f, -0.02212992f, 0.02968903f, 0.07658232f, -0.03649483f, -0.06510051f, -0.12015213f, -0.13611096f, 
    -0.10403338f, 0.07412992f, 0.01081668f, -0.23272899f, -0.13044359f, 0.07590111f, 0.12886560f, -0.02199634f, 
    -0.13505442f, -0.16124742f, -0.11249687f, 0.03777768f, 0.09799404f, 0.03622672f, 0.28750402f, -0.05878185f, 
    -0.01351142f, -0.02542721f, 0.22062293f, 0.17845188f, 0.05700851f, -0.08703332f, -0.06895430f, -0.06865435f, 
    0.02596791f, 0.00104125f, 0.05331219f, 0.01136543f, -0.01488838f, 0.09975248f, -0.01483231f, 0.00798035f, 
    0.07505275f, 0.03587134f, -0.12999801f, -0.00877432f, -0.14982882f, 0.03648528f, 0.13683777f, -0.04866514f, 
    -0.38167524f, -0.14173149f, -0.09810054f, 0.03237389f, -0.03725679f, 0.04711883f, -0.22167255f, -0.17251964f, 
    0.23991624f, 0.08401633f, 0.15566675f, -0.21367526f, -0.09532993f, -0.14833784f, 0.12433967f, -0.06051393f, 
    -0.04231802f, 0.23738933f, 0.03477037f, 0.03908091f, -0.08305719f, -0.03711919f, 0.03040632f, 0.03256350f, 
    0.07885209f, -0.00117459f, -0.21241884f, -0.04960083f, 0.35394302f, 0.05842214f, 0.11368788f, 0.10010775f, 
    0.01121883f, 0.03795819f, 0.06996433f, -0.25333193f, 0.26251560f, 0.03205362f, -0.00367859f, -0.10082731f, 
    -0.08260239f, 0.15626574f, -0.03992358f, -0.12221260f, -0.32254729f, -0.26545286f, -0.24173264f, -0.11926747f, 
    -0.05819400f, -0.03776932f, -0.23179124f, 0.32996503f, 0.15333739f, 0.14510517f, -0.08033855f, -0.18593071f, 
    -0.06659158f, -0.04499410f, 0.19035356f, 0.00079075f, -0.29673275f, 0.03350521f, -0.21781351f, -0.21932907f, 
    -0.00553147f, 0.09891907f, 0.02343360f, -0.07424676f, -0.08870273f, 0.06416999f, -0.02537186f, -0.02929220f, 
    0.09489305f, 0.02381072f, -0.01656721f, -0.07623041f, -0.12915960f, -0.25937504f, -0.14130266f, 0.28907749f, 
    -0.28443629f, 0.11751447f, -0.05424662f, -0.05159416f, 0.08309279f, -0.13673273f, 0.08001468f, 0.10280839f, 
    -0.17401958f, 0.03427073f, 0.06051432f, 0.09992000f, 0.10604282f, -0.04725660f, 0.02400555f, 0.00931359f, 
    0.05839618f, -0.01950263f, 0.10843898f, -0.23985189f, -0.35495269f, -0.21791592f, -0.07661414f, -0.01532446f, 
    0.12982683f, 0.03306158f, -0.05936448f, -0.03269964f, -0.00114801f, -0.15245150f, -0.01623952f, 0.04861718f, 
    0.07010397f, -0.00843915f, 0.16127445f, 0.01555320f, 0.28703594f, -0.05128771f, -0.00815927f, 0.14779846f, 
    -0.07677140f, 0.11681214f, 0.17676316f, 0.04839064f, 0.11386686f, -0.09646802f, -0.03789100f, 0.28332600f, 
    0.05553619f, -0.02097837f, 0.02411541f, -0.08463095f, 0.01755312f, 0.08293033f, 0.09753675f, -0.01235504f, 
    0.13569690f, -0.12868108f, 0.01251374f, -0.13458486f, -0.04699244f, 0.09858996f, 0.03759027f, 0.10543147f, 
    -0.10385977f, -0.03145064f, 0.07495135f, 0.05266129f, 0.11898691f, -0.16611931f, -0.02583233f, -0.12210391f, 
    -0.21090193f, -0.12604885f, -0.35741538f, 0.03592487f, 0.06476864f, 0.13044836f, -0.07423040f, 0.07421438f, 
    -0.16762985f, 0.10366902f, 0.01883831f, 0.06116094f, -0.09818651f, 0.02492864f, -0.07815419f, 0.21345797f, 
    0.01963595f, 0.08152063f, 0.23371081f, 0.03981512f, 0.16361231f, 0.10894344f, 0.00734021f, 0.09453684f, 
    -0.06438896f, -0.33413446f, -0.09396481f, -0.07467806f, -0.08536431f, -0.06102613f, -0.00419023f, -0.15009296f, 
    -0.24381334f, -0.04182549f, 0.05441293f, 0.05677696f, -0.13785805f, -0.03466303f, 0.05009509f, 0.04264307f, 
    0.08959317f, 0.06885139f, -0.07534330f, -0.10171895f, 0.20347883f, 0.08728591f, 0.06913313f, -0.09569159f, 
    -0.09418809f, 0.10600420f, 0.00454718f, 0.08402725f, -0.00729172f, -0.29757854f, 0.11386742f, -0.33827245f, 
    0.02356596f, 0.15251760f, 0.03709566f, 0.09354389f, 0.01006231f, 0.03643284f, 0.09691159f, 0.16782440f, 
    0.01632095f, 0.14003389f, -0.11444400f, -0.16405211f, -0.14397012f, -0.00639907f, -0.07196700f, -0.14722081f, 
    0.12450198f, 0.04756504f, 0.04500480f, -0.09499357f, -0.11772739f, -0.12208901f, 0.17739746f, 0.04181485f, 
    -0.07177476f, -0.07792635f, 0.14586374f, 0.00114699f, -0.07292517f, 0.02918866f, 0.10385917f, -0.02274637f, 
    0.02690938f, 0.15245056f, -0.02068033f, -0.24262743f, -0.53449708f, -0.15982041f, -0.07032272f, -0.02444122f, 
    -0.00153271f, -0.01640459f, 0.00808572f, 0.09553453f, 0.07251006f, 0.10237072f, -0.06861395f, 0.07490678f, 
    -0.15604191f, -0.08736103f, -0.09904310f, -0.01040531f, -0.15104696f, -0.06451416f, 0.22119744f, 0.08311012f, 
    0.10989138f, 0.11413632f, 0.06149039f, 0.10574256f, 0.08637512f, -0.02866264f, 0.04778763f, 0.14058864f, 
    0.08326571f, 0.12948936f, -0.01508588f, 0.09689390f, -0.01900433f, -0.01509854f, -0.07337790f, -0.01494935f, 
    0.14157088f, 0.19153474f, 0.04725938f, 0.15446445f, -0.01323898f, -0.04935792f, 0.09805336f, 0.17529866f, 
    0.00966408f, -0.00344351f, 0.13088109f, 0.16609563f, 0.03337560f, -0.00545078f, -0.08088324f, 0.03258197f, 
    -0.03566840f, -0.03532062f, 0.02190590f, -0.05095166f, 0.00434879f, 0.04263590f, -0.00599402f, -0.04457286f, 
    -0.01660892f, 0.04208358f, -0.01428807f, 0.00309902f, -0.06063427f, 0.01284866f, 0.01323606f, 0.01352607f, 
    0.00005739f, 0.04006095f, -0.03732546f, -0.03434312f, 0.02775552f, -0.00761715f, -0.00170113f, 0.01313079f, 
    -0.02992848f, 0.00543195f, -0.03191904f, 0.04202246f, 0.04135410f, 0.02145071f, 0.01362956f, -0.06843241f, 
    -0.03444416f, -0.02793995f, 0.01567818f, 0.01343077f, -0.04162249f, -0.02316429f, -0.01803179f, 0.00596693f, 
    0.03766794f, 0.02267796f, 0.04166806f, 0.03281549f, -0.05538852f, 0.02605156f, 0.04942974f, 0.02873265f, 
    0.04364046f, -0.04949934f, -0.00498787f, -0.03520457f, -0.03012170f, -0.00597745f, -0.06453719f, 0.02487738f, 
    -0.01107658f, 0.02332589f, 0.00086018f, -0.05552830f, -0.05326361f, -0.06031888f, -0.01144782f, -0.06191023f, 
    0.02899195f, -0.05032082f, -0.00306952f, 0.00211945f, 0.04514583f, -0.00330107f, -0.03158645f, 0.04468045f, 
    -0.01221304f, 0.02045074f, 0.04187442f, 0.01145255f, 0.03846956f, -0.00359684f, -0.03034907f, -0.01326135f, 
    0.04176741f, 0.03852507f, -0.03061671f, -0.01024664f, -0.04328435f, -0.00097390f, 0.02028359f, 0.04653335f, 
    -0.01940813f, 0.04744084f, 0.03107247f, -0.03455686f, -0.05880149f, -0.02144083f, -0.03402174f, -0.01209675f, 
    0.01130613f, 0.04793042f, -0.01614670f, -0.05873560f, -0.04597310f, -0.01431001f, -0.01478531f, 0.00900350f, 
    0.03701324f, 0.01251848f, -0.00862956f, 0.03074080f, 0.00271912f, 0.02971965f, 0.03346980f, -0.04159555f, 
    -0.02741235f, -0.03227442f, -0.02801758f, -0.03765508f, -0.02143390f, 0.03395969f, -0.01723986f, 0.02497459f, 
    -0.05407173f, 0.00445476f, -0.04203174f, -0.05841807f, -0.04199141f, -0.02965910f, -0.04047767f, -0.00732242f, 
    0.04818016f, 0.04500105f, -0.03311181f, 0.01754519f, -0.05179184f, 0.04820931f, 0.00795987f, -0.05593549f, 
    -0.02573198f, 0.00686330f, 0.01299786f, -0.05687729f, 0.01433122f, -0.06597631f, -0.00447688f, 0.03075763f, 
    -0.05213574f, -0.01220531f, 0.02759252f, 0.00874805f, -0.06322615f, -0.03247569f, 0.03508206f, -0.04474470f, 
    -0.02720174f, 0.03953851f, 0.01118609f, -0.02754664f, 0.04504688f, -0.05072342f, 0.00146293f, -0.01811178f, 
    0.02715576f, -0.06580507f, -0.03870292f, 0.04106370f, -0.01311436f, 0.03858387f, 0.01592878f, -0.04850713f, 
    -0.01230765f, -0.00639309f, -0.05887807f, -0.06265817f, -0.00059267f, -0.02390102f, -0.02761525f, 0.00517685f, 
    -0.00424134f, 0.04762444f, 0.02808969f, -0.04850189f, -0.02318293f, 0.02008384f, 0.03944396f, -0.05102647f, 
    0.03615688f, -0.00946341f, 0.00109536f, -0.01406928f, -0.04585967f, 0.01263701f, -0.05040303f, 0.03583840f, 
    -0.04967508f, 0.01847802f, 0.04477955f, 0.03920072f, -0.03539324f, -0.00596354f, -0.03804998f, -0.01389167f, 
    0.04489031f, 0.03834742f, -0.06576212f, -0.06311601f, -0.00523844f, -0.02514840f, -0.05792889f, -0.00387198f, 
    -0.02244511f, 0.04061284f, -0.02916587f, -0.00833310f, -0.06599563f, -0.01156913f, -0.05738495f, -0.05731379f, 
    0.03517706f, 0.03158396f, 0.04339158f, 0.00774657f, -0.00650433f, -0.01385839f, 0.03917876f, -0.01207056f, 
    -0.04604702f, -0.06763308f, 0.03111364f, 0.02057958f, -0.01319231f, -0.04317006f, 0.04099220f, 0.01319284f, 
    -0.02397535f, -0.00895807f, -0.05142035f, -0.02506065f, 0.00336533f, 0.01697213f, 0.01937273f, -0.02565214f, 
    -0.05388814f, 0.00550835f, 0.02412749f, -0.05789375f, 0.02080966f, -0.01359589f, -0.02595354f, -0.02231712f, 
    -0.04424759f, -0.03111720f, -0.02341993f, -0.02491653f, 0.02068119f, -0.01651289f, 0.00161526f, -0.05882302f, 
    -0.02080385f, -0.06837667f, 0.00830115f, -0.00009874f, 0.02244518f, -0.02449310f, -0.03478047f, -0.05266125f, 
    -0.04767133f, 0.04434012f, -0.02988579f, -0.03922222f, 0.00055199f, -0.03654746f, -0.04664597f, -0.01703898f, 
    0.03245099f, 0.02530222f, -0.02995742f, 0.01579728f, -0.06261292f, 0.03516501f, -0.06066420f, -0.03484816f, 
    -0.01481138f, -0.02236218f, -0.03507612f, -0.01842573f, 0.00597415f, -0.00268905f, 0.00225687f, 0.02702777f, 
    0.28461722f, 0.08542018f, 0.04512681f, -0.09092440f, -0.21991584f, -0.11348578f, 0.07165166f, 0.07472370f, 
    -0.00552253f, 0.11093675f, 0.07500696f, -0.01353428f, -0.01176507f, -0.03559801f, -0.00513289f, 0.10217359f, 
    -0.01902880f, -0.10402787f, 0.15325534f, 0.16418144f, -0.10145006f, -0.20250627f, -0.15236287f, -0.19061469f, 
    0.00564075f, 0.09071980f, -0.03107168f, 0.06940652f, 0.07674381f, -0.19893940f, 0.13071840f, 0.07685845f, 
    0.02083162f, -0.03307219f, 0.28162178f, -0.33550605f, 0.11967541f, -0.04055167f, 0.03889474f, 0.04273433f, 
    0.05650675f, 0.04216162f, -0.02933109f, 0.03774446f, 0.21129416f, -0.46815285f, -0.00558214f, -0.28036499f, 
    -0.09068592f, 0.06865956f, -0.05852967f, 0.01122570f, 0.14796066f, -0.01013562f, 0.08543917f, 0.07960860f, 
    0.04402137f, -0.06980017f, 0.12271684f, -0.08136508f, -0.15357311f, -0.05567623f, 0.06362560f, 0.00727146f, 
    -0.07778136f, -0.42936188f, -0.03524433f, 0.02805899f, -0.12751959f, 0.13632751f, 0.04809796f, -0.08325241f, 
    0.35627380f, 0.00810752f, -0.08224615f, 0.02033519f, -0.28329468f, 0.16802444f, 0.01639443f, 0.12800939f, 
    0.14230987f, -0.01041212f, -0.19145295f, -0.00395242f, 0.05110573f, -0.04827128f, 0.06221911f, 0.15542421f, 
    0.07947429f, 0.08466654f, 0.31041989f, -0.02509894f, 0.00281053f, 0.00075517f, 0.04245023f, 0.05111772f, 
    -0.01863676f, 0.00114077f, -0.06934194f, 0.14670891f, 0.11494873f, -0.00418447f, -0.07617386f, 0.06789418f, 
    -0.12025818f, -0.04362055f, 0.01622648f, 0.09420266f, -0.14930944f, 0.28553340f, -0.11979374f, 0.09075121f, 
    0.00191218f, -0.22722599f, 0.01200803f, 0.04509300f, -0.07951909f, -0.21796733f, -0.12407677f, -0.10236725f, 
    0.03639377f, 0.11656795f, -0.15820995f, 0.03139573f, -0.04590770f, -0.02094424f, 0.14708649f, -0.05200937f, 
    0.02265570f, -0.01695004f, -0.10976111f, 0.06210176f, 0.03226147f, 0.00300910f, -0.03304657f, -0.05698613f, 
    -0.01814123f, 0.13531034f, -0.00820166f, 0.16815245f, 0.00152971f, -0.13130650f, -0.05282023f, 0.11460795f, 
    -0.28911299f, 0.03482036f, -0.04963755f, -0.09921057f, 0.04029607f, -0.04995017f, 0.00888802f, 0.07262821f, 
    0.05047274f, -0.07929610f, -0.05923533f, -0.01188642f, 0.01088973f, 0.07587385f, 0.07840150f, -0.05124864f, 
    0.02973649f, -0.13224226f, -0.14703712f, 0.04474817f, -0.30729783f, -0.02553858f, -0.00015868f, -0.05512064f, 
    0.00553772f, 0.17704965f, 0.07704744f, 0.20633681f, -0.02604265f, -0.08255332f, -0.12073777f, -0.21203023f, 
    0.12895870f, 0.06610221f, 0.04408710f, 0.04663406f, -0.15184003f, 0.07520378f, 0.03518628f, 0.11386336f, 
    0.01653397f, -0.07836573f, 0.02938690f, 0.01374972f, 0.06961468f, 0.29638827f, 0.02703939f, -0.29194883f, 
    -0.00461040f, -0.03149729f, 0.01346993f, -0.01959794f, -0.07996062f, 0.03879538f, -0.09841668f, -0.11603143f, 
    -0.20100005f, -0.07322425f, -0.03379994f, 0.08273109f, -0.06292068f, -0.04917560f, -0.13170703f, 0.23125742f, 
    0.17284298f, 0.00844993f, -0.14749104f, -0.21017268f, 0.03634586f, 0.07386182f, 0.09368291f, 0.01416229f, 
    0.05140632f, -0.07348762f, -0.05488250f, -0.05775398f, -0.08058944f, 0.00752817f, 0.01121337f, 0.06371545f, 
    -0.02383702f, 0.13083877f, 0.14991727f, -0.07351599f, 0.02113222f, 0.04462217f, 0.00554194f, 0.06498339f, 
    -0.13774577f, -0.18876101f, 0.20175926f, 0.15982489f, 0.02990788f, 0.03884066f, 0.00738412f, 0.02378434f, 
    -0.06126885f, 0.08517081f, 0.04160134f, 0.18985276f, 0.04859144f, 0.03494608f, -0.09017544f, -0.03387454f, 
    -0.04994037f, -0.00230950f, 0.05730876f, 0.14314550f, 0.16965593f, 0.04637907f, -0.03347488f, 0.04569561f, 
    0.00496710f, -0.02816421f, -0.04150271f, -0.08818450f, -0.08467378f, -0.00267167f, -0.00524013f, -0.10185602f, 
    0.06660361f, 0.01965204f, 0.02316012f, -0.04899203f, -0.06630141f, -0.06660203f, 0.03665494f, -0.18745326f, 
    -0.02693307f, 0.15188465f, 0.06565010f, 0.03528625f, -0.00594319f, -0.02407782f, -0.03024838f, -0.25142452f, 
    -0.17093003f, -0.01329533f, 0.15040809f, -0.00065001f, -0.04734858f, -0.00658540f, 0.02836111f, 0.03150723f, 
    -0.05955563f, -0.29936540f, -0.15577017f, 0.21330144f, 0.09207302f, 0.10033207f, -0.06098903f, -0.11558233f, 
    -0.07475875f, 0.07077382f, 0.05518534f, 0.06013110f, 0.11778920f, -0.06422507f, 0.00409301f, -0.01689068f, 
    -0.23521365f, -0.32577252f, 0.22278352f, 0.30331224f, -0.11766652f, -0.30558878f, -0.09553432f, 0.06762481f, 
    -0.00240739f, -0.03016555f, 0.11298328f, 0.33785325f, -0.25085732f, -0.29948738f, 0.37248459f, -0.18112712f, 
    -0.05734778f, -0.02891547f, 0.07959837f, -0.03869499f, -0.03277683f, -0.12471666f, 0.15182620f, 0.02335979f, 
    -0.03527723f, 0.03026875f, -0.16100115f, -0.03937502f, -0.15074994f, 0.22800180f, 0.06966162f, 0.01720004f, 
    -0.04188195f, 0.20861290f, -0.14889246f, -0.00532548f, -0.11750343f, -0.01193209f, 0.22343048f, 0.09089383f, 
    -0.16080530f, 0.04675557f, 0.03964115f, 0.05926089f, -0.04534210f, 0.12216833f, -0.11797338f, 0.21810940f, 
    -0.02964422f, -0.17896873f, 0.03625683f, -0.05344555f, 0.04913805f, -0.04548529f, 0.10183603f, 0.12707420f, 
    0.14276534f, 0.10868002f, 0.00171290f, 0.08521499f, -0.10412163f, -0.07829446f, 0.03324266f, -0.02798636f, 
    -0.01057057f, 0.24666736f, 0.08568642f, -0.10084482f, 0.08724645f, -0.03435194f, -0.05060262f, -0.02009755f, 
    0.04675353f, 0.24169640f, -0.25299034f, -0.25811034f, -0.04740496f, 0.22486962f, -0.00250340f, 0.06303692f, 
    -0.03946299f, 0.12638691f, 0.15151304f, 0.18346971f, 0.12088317f, 0.00990614f, 0.14237025f, -0.03071340f, 
    0.11834386f, -0.01573727f, -0.04742347f, -0.17771502f, -0.18968439f, 0.28136930f, -0.35881558f, 0.26828265f, 
    0.05630117f, 0.13704810f, 0.15637258f, -0.04239172f, -0.14539634f, -0.10634571f, -0.18504874f, 0.08479094f, 
    0.14274999f, -0.02303776f, 0.17295708f, 0.19277978f, 0.00259213f, -0.10496256f, -0.01799568f, -0.08491451f, 
    -0.07967808f, 0.27503145f, 0.13281168f, 0.14703231f, 0.16617411f, 0.15437268f, 0.10223645f, 0.18235220f, 
    -0.00541543f, 0.15312999f, 0.03044467f, -0.00081348f, 0.13230185f, -0.04683408f, 0.06704619f, -0.04992639f, 
    -0.04416015f, 0.11272269f, -0.04741837f, 0.18917815f, -0.00128882f, -0.12769243f, -0.05434507f, 0.07991868f, 
    -0.05184421f, 0.08135059f, 0.10029527f, -0.10109523f, 0.06111731f, 0.01715289f, -0.05390126f, -0.01691336f, 
    0.01888449f, -0.12090384f, -0.02129398f, -0.06893811f, -0.24109861f, 0.17780261f, -0.08513829f, 0.10374882f, 
    -0.10940416f, -0.03046168f, 0.02485798f, 0.02535886f, 0.08370642f, -0.07531136f, -0.04259438f, 0.03396417f, 
    0.04883027f, 0.03362105f, 0.25644812f, 0.17114663f, -0.01127967f, 0.03750266f, 0.08110134f, 0.05814014f, 
    0.10299923f, 0.09560215f, 0.09805072f, 0.07681730f, 0.05257680f, -0.22317906f, -0.29940963f, -0.13496968f, 
    0.00412996f, -0.03951548f, 0.23013492f, -0.06637434f, -0.11919956f, 0.06190085f, 0.17717540f, -0.06306068f, 
    -0.20663810f, 0.04358005f, -0.00898013f, 0.05016665f, 0.11403928f, 0.11746058f, -0.13792150f, 0.09507250f, 
    -0.18771112f, -0.30779147f, 0.03385625f, -0.07443342f, 0.00812544f, 0.07323620f, 0.06954330f, 0.16415085f, 
    -0.03724572f, 0.00100518f, -0.02879687f, 0.03799748f, -0.06684349f, 0.06066163f, -0.04783235f, -0.20208186f, 
    -0.26732683f, 0.15242416f, 0.10430693f, 0.19407173f, 0.03774484f, 0.03582056f, -0.03975123f, 0.04787664f, 
    -0.10231995f, -0.15051909f, -0.23067217f, -0.04929714f, 0.03814466f, 0.12158970f, -0.03925550f, 0.20315263f, 
    0.06992933f, 0.16004896f, -0.03030391f, 0.01270610f, 0.12006471f, -0.09878792f, 0.00114778f, 0.15694171f, 
    0.02589604f, -0.02809702f, 0.04739078f, 0.16833217f, 0.21507244f, 0.07750534f, -0.05144984f, 0.03496188f, 
    -0.00932795f, -0.03247504f, -0.02903631f, -0.06295097f, -0.13641012f, -0.13453543f, -0.06689349f, -0.15458296f, 
    0.00978198f, 0.08702946f, 0.14513199f, -0.05496291f, -0.06836051f, -0.09071352f, 0.00831036f, -0.28854385f, 
    -0.34496856f, -0.02053547f, 0.10337524f, 0.00714343f, 0.07389852f, 0.04153097f, 0.06452989f, 0.16360191f, 
    -0.07212889f, -0.04608359f, -0.09898424f, 0.06350330f, 0.02432293f, 0.02819152f, -0.07929921f, 0.00880845f, 
    0.10635795f, 0.00107902f, -0.08235725f, -0.20267367f, -0.00330435f, -0.09039196f, -0.01820246f, -0.00724625f, 
    0.08514055f, 0.11951503f, 0.14858007f, 0.12401701f, -0.00571165f, -0.02170969f, 0.05672138f, 0.08136447f, 
    0.14349248f, 0.13473576f, -0.13689636f, 0.21506289f, 0.21397683f, -0.10194284f, -0.12219127f, -0.11109902f, 
    0.00836292f, -0.12009040f, 0.13617799f, -0.37490565f, 0.08294000f, -0.08627921f, -0.11949719f, -0.00144208f, 
    0.09118791f, -0.08331521f, -0.02374249f, 0.08298723f, -0.13158797f, -0.03119379f, 0.04111155f, -0.13280155f, 
    0.03099903f, -0.17278054f, 0.05382527f, -0.13903758f, -0.00265935f, -0.50106639f, -0.08703785f, -0.58245969f, 
    0.03526718f, -0.03151927f, 0.05924670f, -0.10048836f, 0.07118689f, -0.11395826f, -0.07577669f, 0.11918741f, 
    0.14753719f, -0.03065066f, -0.03128227f, 0.06645531f, 0.06315957f, 0.06187296f, -0.03265279f, -0.16820855f, 
    0.14808883f, -0.06473393f, 0.05030783f, -0.00850081f, 0.05106745f, -0.12641811f, -0.12337344f, 0.12068815f, 
    0.15917896f, -0.10575885f, -0.04627524f, -0.12463846f, -0.00750540f, 0.00710213f, -0.05146204f, -0.06340653f, 
    -0.09291494f, -0.15049507f, -0.06634816f, -0.08080025f, -0.04922024f, 0.00157957f, -0.13128738f, -0.05583935f, 
    0.08643947f, 0.06783266f, 0.02243941f, -0.08180255f, -0.08630034f, -0.08561218f, 0.00147672f, 0.06892458f, 
    0.05930260f, 0.06990907f, -0.06194957f, 0.08916124f, 0.24741992f, 0.30736426f, -0.07112510f, -0.01166553f, 
    -0.05680285f, 0.09160367f, -0.04956114f, -0.15001054f, -0.08198630f, 0.09883804f, 0.09906486f, -0.04096919f, 
    0.08733309f, -0.17603876f, 0.07345308f, -0.01012965f, 0.14827000f, -0.10520985f, -0.02930111f, 0.17406976f, 
    -0.06961299f, -0.07092657f, 0.07264457f, -0.08122263f, 0.05737134f, -0.08867000f, -0.03628812f, -0.04646978f, 
    0.12389909f, 0.00423832f, -0.03948742f, -0.06399766f, 0.05514756f, 0.00928726f, 0.12201387f, -0.00908072f, 
    0.03988196f, 0.11443313f, 0.03271314f, 0.01977482f, 0.01018093f, 0.00275478f, 0.01714082f, 0.00467553f, 
    -0.01679310f, 0.17344752f, 0.08003855f, 0.02814350f, 0.03900753f, -0.08968470f, -0.01299076f, -0.01830993f, 
    -0.14045079f, 0.03462465f, -0.17095126f, 0.05199104f, 0.03813736f, -0.02175157f, 0.05143444f, 0.23559462f, 
    0.00359809f, 0.11103620f, 0.00079645f, 0.00447562f, -0.09369560f, -0.13993867f, -0.26851869f, -0.04311259f, 
    0.01717509f, 0.10224991f, -0.00017066f, -0.09023378f, -0.22304095f, 0.08723473f, -0.00657547f, -0.05884132f, 
    -0.12347203f, 0.01325709f, -0.01542521f, -0.05885613f, 0.06653404f, -0.02499075f, -0.22520505f, 0.03139156f, 
    -0.07851873f, -0.04232555f, 0.10716111f, -0.09605052f, 0.04226791f, -0.05736195f, 0.17658091f, -0.05820528f, 
    -0.12694596f, -0.11298952f, -0.00516981f, 0.05509828f, -0.08184931f, 0.03221335f, -0.11503981f, -0.18146153f, 
    -0.13922010f, -0.24350607f, -0.16875903f, 0.07422519f, -0.02242271f, 0.06596573f, -0.03112062f, -0.00487296f, 
    -0.00123984f, 0.07723613f, -0.24014500f, 0.07025486f, -0.08720840f, 0.00989459f, 0.09368616f, 0.15274347f, 
    0.05148437f, -0.02615982f, -0.02153050f, -0.10649659f, 0.00576664f, 0.13254884f, 0.09022202f, -0.02989933f, 
    0.03939988f, 0.09038705f, 0.23671800f, 0.18683718f, -0.00195492f, -0.01920577f, -0.00380964f, 0.07444669f, 
    0.10119700f, 0.10859156f, 0.23099941f, 0.02372382f, 0.12466004f, -0.00333390f, -0.01325415f, 0.07083496f, 
    -0.02504388f, 0.09376875f, 0.02152568f, -0.06243360f, -0.01014996f, -0.02001509f, -0.14609706f, -0.01185318f, 
    -0.12389392f, 0.12308745f, 0.01566065f, 0.08432900f, 0.05355206f, 0.20949505f, 0.02108923f, -0.07782517f, 
    -0.00379964f, 0.00159431f, 0.02543107f, 0.13396536f, 0.14747016f, -0.04125796f, -0.09638547f, -0.06004880f, 
    0.04491087f, 0.04298239f, 0.01739705f, 0.06207919f, 0.03440261f, 0.02030456f, 0.08248612f, -0.15995267f, 
    0.04038678f, -0.08019057f, 0.08426703f, -0.08761992f, -0.08985948f, 0.02374676f, 0.04345499f, 0.03615186f, 
    -0.12997384f, -0.05446314f, 0.07097931f, 0.00095359f, -0.05192809f, 0.11248396f, -0.04978764f, -0.04516501f, 
    -0.05322578f, -0.04076049f, -0.15114422f, 0.06373615f, -0.03003740f, 0.12217018f, -0.11785582f, -0.14570279f, 
    -0.09108695f, 0.06076077f, -0.08561450f, -0.10974331f, 0.06611755f, -0.04252688f, -0.05400812f, -0.16678369f, 
    -0.08070952f, -0.12134854f, 0.07303940f, -0.12362776f, -0.05899535f, 0.26128858f, -0.01617789f, 0.12910445f, 
    -0.12394412f, -0.00162057f, 0.06457464f, 0.28328821f, -0.08235777f, 0.08117739f, 0.10844300f, 0.04984274f, 
    0.07324982f, 0.19210476f, -0.16974588f, -0.03715951f, -0.00770579f, 0.00552983f, 0.00331790f, 0.04327956f, 
    0.07891501f, 0.18333365f, 0.15389799f, 0.11652882f, 0.10149977f, -0.00018429f, 0.16183005f, 0.25318676f, 
    0.02791515f, 0.04241080f, 0.05789471f, 0.04458354f, 0.06530675f, 0.12073842f, -0.11816944f, 0.07151593f, 
    0.09183811f, 0.25168031f, -0.01801884f, -0.01903679f, -0.12639530f, -0.23446241f, -0.07937881f, 0.14140560f, 
    0.04561090f, 0.09931452f, 0.07114474f, 0.12008175f, -0.03224516f, 0.12629308f, 0.10537860f, 0.05093281f, 
    0.13285662f, 0.14885801f, -0.03504830f, -0.00515345f, -0.04455858f, 0.02382240f, 0.09538131f, -0.07477222f, 
    0.10406229f, 0.02643110f, 0.00706869f, -0.05754704f, 0.01474758f, 0.09644684f, 0.02949203f, 0.07421574f, 
    0.09804430f, -0.00994903f, 0.14533152f, -0.06097060f, -0.01386577f, -0.03998068f, -0.07121607f, 0.05206389f, 
    -0.17927213f, -0.03956696f, -0.04796927f, 0.01773304f, -0.12086152f, 0.08437528f, 0.00025192f, 0.10126437f, 
    0.01790017f, -0.16714671f, -0.03380558f, 0.23707357f, -0.11246728f, 0.16841155f, 0.11857773f, 0.09572058f, 
    0.06007611f, 0.01805988f, -0.15667923f, -0.01697990f, -0.13400960f, 0.11956073f, -0.00197237f, -0.25123629f, 
    -0.03429879f, -0.12896188f, -0.01561871f, 0.07306547f, 0.11674980f, 0.09811724f, -0.00039880f, -0.04475401f, 
    -0.11736573f, 0.07842742f, 0.12907073f, 0.18529043f, -0.06439947f, -0.11133896f, -0.21174888f, 0.22470450f, 
    0.16485514f, 0.11468770f, 0.08327502f, 0.11499655f, -0.01448018f, 0.00062778f, 0.01204645f, 0.08799849f, 
    -0.07352942f, -0.04728873f, 0.09370539f, -0.00182549f, 0.03344668f, -0.00386207f, 0.02488790f, 0.02584283f, 
    0.17922442f, 0.07216133f, 0.10212798f, -0.16711932f, 0.09835113f, 0.00420162f, -0.05764969f, -0.12444789f, 
    0.09370241f, -0.09217303f, 0.17048493f, 0.18654037f, 0.00227935f, 0.00861530f, 0.00748095f, -0.08245826f, 
    0.09769379f, 0.11211487f, 0.19019555f, -0.07287475f, 0.01909006f, 0.18135861f, -0.00968971f, 0.25793299f, 
    0.09373923f, 0.00007744f, 0.19304691f, 0.14730905f, 0.19868830f, 0.08491216f, 0.00630246f, -0.01727167f, 
    -0.01346868f, 0.04255815f, 0.01078454f, 0.07487694f, 0.00479125f, 0.10906902f, -0.19393454f, -0.07500602f, 
    0.00581502f, -0.04962849f, 0.11019098f, 0.13353814f, 0.07872000f, 0.29624820f, 0.29443336f, -0.02850253f, 
    0.15101810f, 0.07138312f, -0.07565977f, 0.03305643f, 0.02258702f, -0.07489374f, 0.05916753f, 0.01825384f, 
    -0.08444866f, 0.07387339f, 0.00757870f, 0.09925463f, 0.07638063f, -0.07959793f, -0.02806935f, -0.17815109f, 
    -0.07749964f, -0.08710070f, -0.01828726f, 0.02581247f, 0.02385924f, 0.03616924f, -0.20922887f, -0.16325909f, 
    -0.14383128f, -0.16352244f, -0.08086485f, 0.00855172f, 0.08567499f, -0.00158868f, 0.07211383f, 0.10142645f, 
    -0.12491994f, -0.05220262f, 0.16440874f, -0.26613003f, 0.01065449f, -0.04981745f, 0.06337316f, 0.01466610f, 
    -0.07159466f, -0.00578438f, -0.07937985f, 0.09909293f, 0.24203013f, -0.14836641f, 0.12941983f, 0.09153827f, 
    0.14368135f, 0.04972280f, -0.04347383f, -0.14077364f, -0.13848197f, -0.00101959f, 0.08766109f, 0.19197296f, 
    0.09915332f, 0.06728964f, -0.20531406f, -0.27910444f, -0.17894791f, 0.01250110f, 0.05929343f, -0.04341268f, 
    0.03494132f, -0.00750295f, 0.00056357f, -0.09390394f, -0.03722515f, -0.20086090f, 0.11606004f, 0.03121747f, 
    -0.16328606f, -0.08047595f, -0.01608172f, 0.12718004f, -0.03138844f, 0.03218042f, -0.02291459f, 0.10018364f, 
    -0.03980260f, -0.13389573f, -0.12244878f, 0.02730549f, -0.02073490f, 0.02650886f, 0.01209474f, 0.04605408f, 
    0.15761587f, 0.03460196f, -0.10516288f, -0.04120406f, -0.12775819f, -0.10275926f, -0.08768842f, -0.12446803f, 
    -0.07345678f, 0.03931763f, -0.08615791f, -0.00381757f, 0.03128890f, 0.06724761f, 0.13013457f, 0.20049179f, 
    -0.09885762f, 0.10006927f, -0.08678842f, 0.32187706f, 0.29309857f, 0.11026176f, -0.13549630f, -0.06077950f, 
    0.03282746f, -0.05048803f, 0.04988521f, 0.17043075f, 0.25479904f, -0.24533600f, 0.03831248f, 0.06206753f, 
    -0.11362750f, 0.26415598f, 0.03651822f, -0.21030791f, 0.29324558f, -0.04589536f, 0.10676862f, 0.06163455f, 
    -0.04698221f, -0.15906154f, -0.18235959f, 0.06526829f, -0.20395829f, -0.54529768f, 0.03768063f, 0.36102432f, 
    -0.19814327f, -0.16558097f, -0.01222231f, 0.03630624f, -0.01384572f, 0.17100130f, 0.09112412f, 0.18138379f, 
    -0.04311706f, 0.02554405f, 0.18967110f, 0.06477538f, 0.13914467f, 0.04810243f, -0.15199718f, 0.05615166f, 
    -0.21324977f, 0.04324048f, 0.02820958f, -0.16904292f, 0.04462177f, -0.07682341f, -0.00186597f, 0.19249102f, 
    0.17902415f, 0.27766189f, -0.00760575f, 0.13461120f, 0.13019320f, 0.03894891f, -0.17363808f, -0.01235825f, 
    -0.42352355f, -0.18612412f, 0.01217204f, -0.05215398f, 0.08938173f, -0.00806218f, 0.07930283f, 0.04253928f, 
    0.06471638f, 0.04472529f, 0.00137424f, -0.10329110f, -0.09139879f, -0.02600407f, 0.07481129f, -0.08514038f, 
    0.00424055f, 0.02310474f, -0.08540107f, 0.00247800f, 0.00900706f, -0.10771657f, -0.01259488f, 0.01858039f, 
    -0.17662168f, -0.03765340f, 0.13544837f, -0.30622616f, -0.26182401f, -0.03349866f, 0.38173792f, -0.19150653f, 
    0.15367125f, -0.02991030f, 0.16269705f, -0.15224889f, 0.19936004f, 0.28809217f, -0.00266816f, -0.03571875f, 
    0.07712439f, -0.11205522f, -0.01118811f, -0.09202856f, 0.09934440f, 0.23859684f, 0.07471421f, 0.07282759f, 
    -0.10742192f, 0.13441475f, 0.08680876f, -0.04567297f, -0.11293701f, 0.28017983f, -0.09843161f, -0.00230386f, 
    0.01961812f, -0.08401681f, -0.11406484f, 0.07387266f, 0.06404655f, -0.05149348f, -0.04297577f, 0.00271574f, 
    -0.07141770f, 0.02953571f, 0.10987880f, -0.14017393f, -0.11487131f, -0.01394516f, 0.03246398f, 0.13394570f, 
    -0.23683988f, -0.25291088f, -0.06127229f, 0.01652900f, -0.02693565f, 0.03472891f, 0.06077604f, -0.00638326f, 
    0.03007819f, 0.08698927f, -0.06044289f, -0.16630051f, -0.06100252f, 0.01768066f, -0.00530818f, 0.06148657f, 
    -0.01729761f, -0.00920196f, 0.08262321f, 0.43632701f, -0.07007287f, 0.11626987f, -0.23429994f, -0.20939347f, 
    -0.33064479f, 0.09521094f, -0.16111228f, -0.11692194f, -0.24022777f, 0.31224826f, 0.01518174f, -0.08155405f, 
    -0.00905846f, 0.10639735f, 0.09019946f, 0.19289213f, -0.06057379f, 0.35685089f, 0.16801341f, 0.04255348f, 
    -0.09766964f, -0.09145073f, -0.39697650f, 0.07269364f, 0.01524912f, -0.21038748f, -0.48299623f, -0.16767341f, 
    -0.11262988f, -0.06422420f, 0.14228052f, 0.02066994f, 0.29504773f, -0.03566644f, -0.01459541f, -0.05567993f, 
    0.08524175f, -0.10953008f, -0.02814993f, -0.01962980f, -0.16397721f, 0.03333091f, 0.04747202f, -0.02495331f, 
    0.02207661f, -0.15978883f, -0.01755573f, 0.02738705f, -0.03415819f, -0.10517927f, 0.08803146f, -0.08289190f, 
    0.18834639f, 0.04251285f, -0.14457938f, 0.21821257f, -0.06268715f, 0.09759209f, 0.07517462f, 0.17987396f, 
    -0.11727887f, 0.01786626f, -0.00610528f, -0.07842671f, -0.00285617f, -0.02521408f, 0.03639709f, 0.05101334f, 
    -0.06771963f, -0.09191139f, -0.21912606f, -0.12063868f, 0.07562729f, 0.02471145f, 0.08850285f, 0.00182940f, 
    0.05810796f, -0.09603635f, 0.00469274f, 0.01547532f, 0.10387009f, 0.19818956f, 0.20877960f, -0.06128258f, 
    0.09694671f, 0.06514572f, 0.24619147f, -0.07483476f, 0.24219863f, -0.10971297f, -0.02293114f, -0.08385636f, 
    0.12745111f, 0.05397182f, 0.04713266f, -0.02649028f, 0.11906292f, 0.13712372f, -0.15572385f, 0.15005124f, 
    0.02021792f, 0.05164441f, 0.04880343f, 0.03734450f, 0.13832729f, 0.07356720f, 0.08537276f, -0.11558286f, 
    0.14089161f, 0.15586558f, 0.01691163f, 0.10837927f, -0.03969875f, 0.05580550f, 0.04129884f, -0.05892872f, 
    -0.01929110f, -0.02983174f, 0.05044140f, -0.03978140f, 0.00093893f, -0.01090983f, 0.02348697f, 0.00731261f, 
    0.04857669f, 0.01887748f, -0.04733110f, -0.02780300f, 0.00013392f, -0.05609977f, -0.05369940f, -0.04438946f, 
    -0.05674930f, -0.03675505f, 0.03825999f, -0.04242725f, 0.02717311f, -0.06453270f, 0.04302426f, 0.02789510f, 
    -0.01443489f, 0.03801793f, -0.01599470f, -0.00857413f, 0.03129447f, -0.00682417f, -0.04010788f, 0.02699669f, 
    -0.00362838f, 0.02799038f, -0.05582290f, -0.01811491f, -0.00548615f, -0.05023449f, -0.05553673f, -0.05040589f, 
    -0.00216364f, -0.00177606f, -0.05477834f, -0.02285195f, -0.01886909f, 0.02312738f, 0.01728085f, 0.01759087f, 
    -0.01275565f, -0.03035619f, -0.00653984f, -0.04566889f, -0.03524822f, 0.04911651f, -0.03125878f, 0.02091216f, 
    -0.04846945f, 0.02447626f, -0.01011720f, -0.00178315f, -0.03760670f, -0.04588630f, -0.00868992f, -0.03425462f, 
    0.02519401f, 0.04934621f, 0.00314664f, 0.03362467f, -0.01711874f, -0.00662976f, 0.03616100f, -0.00981415f, 
    0.02918205f, 0.02709223f, -0.02122484f, 0.05822908f, 0.02342326f, -0.00483405f, -0.04564139f, 0.02115146f, 
    -0.04215559f, -0.02768491f, 0.01152499f, -0.04011618f, -0.00183486f, 0.03902794f, -0.02644885f, -0.04923202f, 
    -0.02950345f, 0.01762086f, -0.05596431f, 0.04919551f, -0.00657634f, 0.02253941f, 0.03802088f, -0.02948094f, 
    -0.06230088f, -0.00051376f, -0.01181243f, -0.04306641f, 0.05431878f, 0.05036064f, -0.05513706f, -0.00400895f, 
    0.00052421f, -0.00603399f, 0.02173038f, -0.03715720f, -0.00582446f, -0.01373687f, 0.00651975f, -0.05372836f, 
    -0.02081267f, -0.01813089f, 0.04979702f, 0.00353820f, -0.04084645f, -0.01825563f, 0.01955775f, 0.04417173f, 
    -0.00234322f, 0.03858819f, 0.04937085f, 0.00899460f, -0.04075326f, 0.04368578f, -0.03090772f, 0.05018692f, 
    0.03693685f, -0.03634387f, 0.04489680f, -0.04247768f, -0.03257061f, -0.03617170f, 0.03026114f, 0.04187343f, 
    -0.02858159f, 0.00919831f, -0.06122704f, 0.01519242f, 0.01854745f, -0.03918649f, -0.02189251f, 0.02713856f, 
    -0.02327958f, -0.01354418f, -0.02394935f, 0.01057616f, 0.03051253f, 0.01228208f, -0.05677615f, 0.02452193f, 
    -0.03604362f, -0.06422042f, 0.01297483f, 0.01169625f, -0.01577965f, 0.02457367f, -0.06240183f, 0.01464719f, 
    -0.00622733f, -0.06151169f, 0.01602980f, -0.01776281f, -0.04036002f, 0.02182377f, -0.01661230f, -0.02328865f, 
    -0.00581088f, -0.01389169f, -0.04842413f, -0.05246066f, 0.01014269f, -0.04857143f, 0.01142355f, -0.05993237f, 
    -0.00995636f, -0.06424196f, -0.01917456f, 0.04873311f, 0.02851638f, -0.04828383f, 0.01803545f, 0.04064837f, 
    0.03534752f, -0.04037187f, 0.04368275f, -0.02002834f, -0.00059362f, 0.02193193f, -0.00797158f, -0.04232286f, 
    0.02973639f, 0.04135349f, -0.06171700f, -0.00537543f, 0.02792791f, -0.05700684f, 0.02653946f, 0.04072823f, 
    0.04578010f, -0.06314681f, 0.00777914f, 0.00850746f, -0.05711479f, 0.01119422f, 0.01128142f, 0.04515082f, 
    0.04534609f, 0.02777658f, -0.01033837f, 0.04674448f, 0.02346922f, -0.05054432f, -0.06262922f, -0.06027909f, 
    0.04367811f, -0.04874543f, -0.01215204f, -0.00964908f, -0.00649450f, -0.03465292f, 0.03959239f, 0.03769273f, 
    -0.05652948f, -0.01051829f, -0.06059161f, 0.01791017f, -0.02813983f, 0.02567215f, 0.04851183f, -0.02993807f, 
    -0.01553419f, -0.02407277f, -0.05036808f, -0.03939699f, -0.05809707f, -0.00127606f, 0.00217226f, -0.03668984f, 
    0.01759533f, 0.04486556f, -0.05379356f, -0.01325248f, 0.03665314f, -0.00955535f, 0.00762416f, 0.01107396f, 
    0.02316712f, -0.06242803f, -0.00547344f, 0.01522409f, -0.03215157f, -0.03482989f, 0.01998064f, 0.01566689f, 
    -0.00959135f, -0.05657594f, 0.04378467f, -0.01108872f, -0.06440128f, 0.01222619f, -0.00144247f, -0.06073837f, 
    -0.01826892f, -0.05326823f, -0.06382693f, -0.04856451f, -0.02031519f, 0.00611325f, 0.00015835f, -0.03851912f, 
    0.01505369f, 0.04139343f, -0.00586602f, 0.02742775f, -0.04674609f, 0.01717824f, -0.01373336f, 0.00381480f, 
    0.01497210f, 0.04508364f, 0.02095445f, -0.03014252f, 0.02291200f, 0.03923241f, -0.00224464f, 0.04216370f, 
    -0.04337125f, -0.03621240f, -0.05053853f, -0.02992866f, 0.02055864f, 0.01226914f, 0.04602478f, -0.03825640f, 
    -0.01036733f, -0.05371498f, -0.04861721f, -0.05963278f, -0.02394863f, -0.02690782f, -0.00007750f, 0.03297738f, 
    -0.03338488f, -0.02233257f, 0.04918457f, 0.02895849f, -0.00030283f, 0.04450902f, 0.00557513f, 0.01681733f, 
    0.01577981f, 0.06345198f, -0.04716927f, -0.03628709f, -0.03908101f, -0.02653957f, 0.04870758f, -0.04832666f, 
    0.04520187f, 0.01520012f, 0.00102333f, 0.01045456f, -0.01969735f, 0.04260762f, 0.01174755f, 0.04413151f, 
    0.01900203f, -0.04672282f, -0.03246712f, 0.02130168f, -0.05508596f, 0.02118940f, 0.01138653f, 0.03978933f, 
    0.02698663f, -0.03926267f, -0.03132023f, 0.01216816f, 0.02769203f, -0.00838331f, 0.02300715f, -0.05842058f, 
    -0.01747973f, -0.02857763f, -0.01275380f, 0.01182905f, -0.05856533f, 0.03835175f, 0.00572502f, -0.01588490f, 
    -0.01075035f, 0.03983419f, -0.03783475f, -0.01285949f, -0.03641696f, 0.02510386f, 0.04387026f, 0.02312936f, 
    -0.00266068f, -0.02829888f, -0.04609974f, 0.01544402f, -0.03590554f, -0.05809875f, 0.05305304f, 0.01072762f, 
    0.01671578f, -0.05657642f, 0.01345864f, 0.01647202f, 0.03162176f, 0.04452500f, -0.00265715f, -0.04083645f, 
    0.01002996f, 0.02546318f, -0.04241061f, -0.06076440f, 0.02840734f, -0.05432193f, -0.03549881f, 0.04293556f, 
    -0.02437760f, 0.03689307f, -0.05174159f, -0.06133664f, 0.03107776f, -0.05598902f, -0.05248159f, 0.01298648f, 
    0.04612301f, 0.02375573f, 0.04506744f, -0.04406111f, -0.06366439f, 0.03830348f, -0.02777985f, 0.03059559f, 
    -0.04619886f, 0.01838114f, 0.02375482f, -0.04690957f, 0.01821726f, -0.03217919f, -0.01795914f, 0.03647093f, 
    -0.03139862f, 0.02784131f, 0.00792955f, -0.02363417f, 0.04462602f, 0.01265860f, 0.04925254f, 0.02251778f, 
    -0.05657503f, -0.01700706f, 0.04520111f, -0.05213672f, 0.00287690f, 0.05267604f, -0.01625135f, 0.03801950f, 
    -0.04651283f, -0.00862417f, 0.03539181f, -0.01277122f, 0.00883808f, -0.05013425f, -0.04852691f, -0.04536236f, 
    -0.01360623f, -0.06318940f, -0.00195494f, -0.04054345f, -0.01786150f, 0.01221570f, 0.03152678f, -0.03310218f, 
    -0.00797500f, -0.05881969f, 0.00159287f, -0.00364607f, 0.03587266f, 0.00529940f, -0.04636581f, -0.01005807f, 
    -0.01289542f, 0.03768510f, -0.05521659f, 0.01627079f, 0.03135000f, -0.04846057f, 0.03035666f, 0.00811097f, 
    -0.04711720f, 0.03006223f, -0.05069176f, 0.02195860f, 0.04225929f, -0.01144435f, 0.00679386f, 0.02015662f, 
    0.05151849f, -0.01042055f, -0.00781569f, -0.04907604f, 0.01288487f, -0.00684943f, 0.03550074f, 0.00254067f, 
    -0.04488385f, 0.00328572f, 0.01898313f, 0.01281786f, 0.03922807f, -0.05791314f, -0.00673194f, -0.03125697f, 
    0.04127241f, -0.05298326f, -0.05688222f, 0.02083336f, -0.02549251f, 0.04479704f, 0.05914671f, 0.02111199f, 
    -0.06330033f, -0.02041583f, -0.01371160f, -0.03214339f, 0.03056874f, -0.04308506f, -0.04125967f, -0.02398269f, 
    -0.01153188f, 0.01176102f, -0.03973435f, 0.06166198f, -0.02440518f, -0.03506821f, 0.02519419f, 0.01188681f, 
    0.03445489f, -0.00347427f, -0.03835327f, -0.02978229f, 0.02964304f, 0.01891221f, 0.00516234f, 0.02333072f, 
    0.02871133f, -0.00120723f, 0.01824821f, -0.03162134f, -0.06350909f, 0.04603601f, -0.03859760f, -0.00663687f, 
    0.04219038f, 0.01368702f, -0.03190329f, -0.01198713f, -0.05233143f, -0.06193612f, 0.01913115f, -0.02796722f, 
    -0.02024102f, -0.02577583f, -0.02309660f, -0.00565300f, -0.01949078f, -0.04290912f, -0.00635297f, 0.02043180f, 
    0.04426608f, -0.04044067f, -0.00125222f, -0.03995973f, -0.02212900f, 0.05018943f, -0.02309296f, -0.02897200f, 
    -0.00202130f, -0.04792474f, -0.02375608f, -0.06324856f, 0.01877552f, 0.03070341f, 0.04885938f, -0.05737053f, 
    -0.02582627f, -0.05029299f, -0.03208713f, -0.02350423f, 0.01952624f, -0.03892481f, -0.06091904f, 0.00238572f, 
    0.04606211f, 0.04031589f, -0.02991184f, -0.04774127f, -0.00988957f, -0.03982214f, -0.06417332f, -0.03258303f, 
    -0.01699408f, -0.04992804f, 0.00193884f, 0.03307996f, 0.00233238f, -0.04737520f, 0.02374479f, -0.05428004f, 
    0.02185315f, -0.01469658f, 0.01563641f, 0.02538246f, 0.08776148f, 0.19390056f, 0.01498499f, 0.11765633f, 
    -0.09652202f, 0.09154014f, 0.08315088f, 0.03765972f, 0.06503330f, 0.05282502f, 0.03721091f, 0.12090903f, 
    0.11946113f, 0.07281458f, 0.15801056f, 0.18770786f, 0.17991762f, 0.08526886f, -0.08323416f, 0.22922291f, 
    0.13849857f, 0.14537935f, -0.05180220f, 0.10803488f, -0.11832295f, 0.08266257f, 0.11624030f, -0.14117964f, 
    -0.24017720f, 0.02108771f, 0.07629847f, -0.07486244f, -0.27051842f, -0.09216900f, -0.06204842f, -0.06183121f, 
    -0.19438332f, -0.01431364f, 0.19237766f, 0.11999752f, -0.08565153f, -0.15520762f, -0.01957794f, -0.25753945f, 
    0.08684802f, 0.08041832f, 0.04280078f, 0.02378676f, -0.15571408f, -0.23519090f, -0.10947793f, 0.00564437f, 
    0.21652822f, 0.10045658f, 0.09788594f, 0.01513149f, 0.12398209f, -0.20549306f, -0.04546314f, 0.29338038f, 
    -0.11064910f, 0.09912069f, 0.04576876f, 0.22324508f, -0.02484194f, 0.17084646f, -0.19090097f, -0.16057457f, 
    -0.07536868f, 0.00101395f, -0.20482340f, -0.04146913f, 0.05021674f, -0.05117919f, 0.04596282f, -0.01422671f, 
    -0.29857033f, 0.11575998f, -0.14169583f, -0.02114742f, 0.09084632f, -0.04762210f, -0.06264102f, -0.04269710f, 
    -0.23792218f, -0.26179442f, 0.08802696f, 0.14546782f, 0.06659038f, 0.12534949f, -0.01881571f, -0.14245200f, 
    -0.01284868f, -0.03142721f, 0.04318848f, -0.12758690f, 0.13763613f, -0.10286543f, 0.10934787f, 0.02168572f, 
    0.13939896f, 0.24109244f, 0.05853831f, -0.09912994f, 0.04454379f, -0.07588759f, -0.24967971f, 0.17642155f, 
    0.07436292f, -0.02239314f, 0.13411161f, -0.19639333f, -0.04448614f, 0.18753640f, 0.17099980f, 0.05914028f, 
    0.00806198f, 0.02065246f, 0.03055316f, 0.00182319f, -0.05211439f, 0.17675611f, 0.00371297f, -0.14807600f, 
    0.01235211f, -0.05726682f, 0.05610286f, 0.04639714f, -0.09260596f, -0.19421999f, -0.17608255f, -0.25212425f, 
    0.01654004f, 0.07169040f, 0.06335682f, 0.03548687f, 0.08353734f, 0.08716688f, 0.06165912f, -0.26683831f, 
    -0.00683322f, 0.01473849f, 0.02541895f, 0.16676010f, 0.01415409f, -0.00875330f, 0.16783413f, 0.07387824f, 
    -0.16083735f, -0.07856689f, -0.01762594f, -0.13501424f, 0.07838584f, -0.18456890f, 0.07734586f, 0.01153293f, 
    0.19705214f, 0.12819271f, -0.05630409f, -0.07130337f, 0.00857572f, -0.08988116f, -0.02982786f, 0.10204649f, 
    -0.00197997f, -0.10695168f, -0.10646237f, 0.17585170f, 0.05500286f, 0.03129924f, -0.07300254f, -0.04034533f, 
    -0.05542185f, -0.09996765f, -0.09846596f, -0.18478866f, -0.07541228f, -0.11569266f, -0.03144072f, 0.11805630f, 
    -0.06796203f, 0.02268317f, -0.05472842f, -0.01261195f, -0.12313204f, -0.33905208f, 0.35816100f, 0.01722215f, 
    0.02760372f, -0.02327188f, 0.11170077f, -0.00758938f, -0.09149221f, -0.20381215f, 0.07281284f, -0.28006014f, 
    -0.22330868f, 0.13190007f, -0.01377833f, -0.11764901f, 0.09999489f, -0.24145582f, -0.31743816f, 0.10376664f, 
    -0.12237562f, 0.04160799f, 0.13252328f, 0.07297434f, -0.01490274f, -0.07220123f, -0.00541229f, -0.04627677f, 
    0.12120310f, -0.09266106f, 0.10867753f, -0.08875871f, 0.05869671f, -0.06746660f, 0.14424154f, 0.15932448f, 
    0.10205446f, 0.08354133f, -0.14651373f, 0.00342195f, -0.01732913f, 0.16653781f, 0.09128428f, 0.16732568f, 
    -0.01693346f, 0.06634845f, 0.03896315f, -0.11130039f, -0.14216278f, -0.04664824f, -0.12073709f, 0.01869845f, 
    -0.01284262f, 0.08881633f, -0.05009486f, -0.09734546f, -0.13846849f, -0.02478475f, 0.02074012f, -0.13362356f, 
    0.11248849f, -0.14037210f, -0.16000795f, -0.09478149f, 0.14372531f, -0.05286408f, 0.07438080f, 0.04117264f, 
    -0.03075470f, 0.06649708f, 0.12475260f, 0.06766299f, 0.03937596f, -0.13250916f, -0.06135594f, 0.01612650f, 
    -0.11803657f, -0.01717396f, 0.02679996f, 0.15309246f, 0.06901976f, 0.28689182f, -0.12169119f, -0.00362578f, 
    0.05698847f, -0.02304784f, -0.02146604f, -0.13610239f, -0.09003907f, -0.00766109f, 0.16898564f, -0.08291618f, 
    -0.06112503f, -0.06387761f, 0.01844557f, -0.08057578f, 0.03313260f, -0.08971792f, -0.21696301f, -0.39307171f, 
    -0.01131853f, 0.03062879f, 0.15494284f, 0.04710105f, 0.04703739f, 0.03181711f, -0.03191848f, -0.00845160f, 
    0.07113415f, -0.08876019f, -0.05593302f, -0.04659238f, 0.10994302f, 0.02761815f, -0.00852007f, 0.08245112f, 
    0.11090127f, 0.08080412f, -0.56871420f, -0.19560869f, -0.05674071f, -0.00563014f, -0.14581846f, 0.04315128f, 
    0.16421089f, 0.08759785f, -0.03933324f, 0.10542648f, -0.10473235f, 0.03261913f, 0.05242377f, -0.01626691f, 
    0.22422300f, 0.00548438f, 0.06285953f, -0.01113760f, -0.15224141f, -0.20325917f, -0.18551795f, -0.24503256f, 
    -0.12420925f, -0.06056876f, 0.00308470f, -0.09449480f, -0.02983975f, 0.11810999f, -0.04171074f, -0.01441770f, 
    0.08806755f, 0.02988758f, 0.01196126f, -0.07190189f, -0.10656919f, 0.00877411f, -0.08695612f, -0.01952727f, 
    -0.03456938f, 0.08208498f, -0.01789879f, 0.10851315f, 0.09750954f, -0.05543514f, 0.03324075f, -0.05924872f, 
    0.13060927f, 0.03663235f, 0.10907450f, 0.07594999f, -0.09813615f, -0.02714816f, -0.03140763f, -0.15800010f, 
    -0.28189191f, -0.24960600f, 0.00085185f, -0.05894504f, -0.01607066f, 0.04537267f, 0.05991991f, -0.15338148f, 
    -0.10416173f, 0.19632946f, 0.10553873f, -0.00355621f, -0.03460142f, -0.14367853f, 0.05609253f, 0.00803411f, 
    0.04888711f, -0.04493957f, -0.23991671f, 0.00481350f, -0.06459610f, 0.16621615f, 0.07834398f, -0.04996420f, 
    -0.06278101f, -0.01125158f, -0.02830850f, -0.30473626f, -0.14945617f, -0.17559022f, -0.05295184f, 0.04194938f, 
    -0.10586023f, -0.01780643f, 0.15631317f, 0.07259825f, 0.30839634f, -0.10126232f, -0.40836483f, -0.07139728f, 
    -0.16037115f, -0.10919153f, -0.01571605f, -0.00018007f, 0.13093570f, 0.21199921f, 0.15047053f, 0.06119803f, 
    0.01683688f, -0.03394993f, 0.00948248f, 0.07591929f, 0.00150731f, 0.11985504f, 0.03539602f, -0.02680657f, 
    0.01368829f, 0.05463491f, 0.15338196f, 0.01066214f, -0.01924723f, 0.04057586f, 0.02657182f, -0.05481434f, 
    0.12504071f, -0.16133884f, 0.11866236f, -0.04895085f, 0.19035931f, 0.07259253f, -0.06224757f, 0.08196174f, 
    0.10364114f, 0.05537173f, -0.20694306f, 0.13085376f, 0.08519936f, 0.04368152f, 0.00328094f, 0.11255351f, 
    0.01814632f, -0.04515054f, 0.09049074f, 0.09557667f, -0.00452203f, 0.03857590f, 0.14286326f, 0.04952954f, 
    0.00455842f, 0.22984162f, -0.03148543f, -0.08877365f, 0.04214475f, -0.06273039f, 0.06861655f, -0.17516623f, 
    -0.09169775f, -0.14753006f, 0.01293064f, -0.22841316f, 0.13403171f, -0.06271904f, -0.03856285f, -0.02017217f, 
    -0.11294399f, -0.16627346f, -0.29178923f, -0.24361880f, -0.10859849f, 0.02599948f, 0.16823253f, -0.05200874f, 
    0.03131138f, 0.18704772f, 0.09994853f, 0.15827546f, 0.04615932f, 0.15998568f, 0.21793707f, -0.02886780f, 
    -0.19558740f, -0.15743388f, -0.11823383f, 0.06803328f, -0.11638117f, -0.11432640f, -0.09381790f, -0.02271073f, 
    0.26583982f, -0.16791417f, -0.03403019f, -0.00327444f, 0.09859200f, 0.06406110f, -0.18324095f, 0.00736684f, 
    -0.04006020f, -0.03118190f, 0.11355469f, 0.01155076f, 0.04333043f, -0.02568810f, -0.13071872f, 0.21548028f, 
    -0.22228338f, -0.03321774f, -0.09745330f, 0.09324426f, 0.09413549f, 0.06703375f, 0.03320548f, 0.04614801f, 
    0.00057508f, -0.01681253f, -0.08485363f, -0.04317121f, -0.06062643f, -0.04079850f, -0.13595951f, 0.06917673f, 
    0.01868473f, 0.14198285f, -0.19661294f, -0.00554474f, -0.08590870f, 0.05874598f, -0.08865391f, -0.11088884f, 
    0.00216118f, 0.00606675f, -0.04930174f, 0.00897422f, 0.03865381f, 0.14819637f, 0.08676365f, 0.08227599f, 
    0.01558093f, -0.01546215f, 0.00052746f, 0.04936691f, -0.22054331f, -0.14764841f, -0.03899126f, 0.14841726f, 
    -0.14102806f, 0.07286067f, 0.17386506f, 0.14272004f, 0.17428564f, 0.17898168f, 0.07284188f, 0.19936965f, 
    -0.03532557f, -0.03492186f, 0.15087329f, -0.06228450f, -0.05296060f, 0.12443642f, 0.29888207f, 0.06365074f, 
    0.05444756f, -0.07261334f, -0.25690052f, 0.00613822f, -0.07509514f, -0.03134062f, -0.03946515f, 0.14982076f, 
    0.04551442f, 0.08223118f, -0.04540363f, 0.03519184f, 0.01983571f, 0.03135753f, 0.02992668f, 0.12719586f, 
    0.03350443f, -0.04646124f, -0.02174495f, -0.05872596f, 0.01236979f, -0.00755101f, 0.02700526f, -0.01428755f, 
    -0.00653477f, -0.00901435f, -0.04049953f, -0.02021771f, -0.06062906f, 0.03094404f, -0.05519655f, 0.01692989f, 
    -0.01689687f, 0.04781206f, 0.00692081f, 0.02877305f, 0.01255176f, -0.04869108f, 0.03835050f, -0.01100210f, 
    -0.03155343f, -0.00121941f, 0.00189931f, -0.00799764f, 0.00062676f, -0.01523770f, -0.02330043f, 0.01826092f, 
    0.01070114f, -0.01467349f, 0.00960655f, -0.01489104f, -0.02456485f, -0.00376297f, -0.03098438f, -0.01865924f, 
    -0.01261523f, -0.05858988f, -0.00262042f, 0.00450973f, 0.00313887f, -0.02687724f, -0.06139576f, 0.02652485f, 
    0.02952450f, -0.00246387f, -0.00913961f, 0.02716801f, -0.02227738f, -0.03276777f, -0.00780504f, -0.06438370f, 
    -0.05778777f, -0.02780624f, 0.00213245f, -0.04217235f, -0.03886769f, -0.05493821f, -0.04362308f, 0.05207611f, 
    -0.04768793f, -0.02964973f, -0.06255271f, -0.02271130f, -0.06455074f, -0.00339193f, -0.01000697f, 0.00611707f, 
    -0.02057986f, -0.00710239f, -0.04772015f, 0.05134850f, -0.02567694f, 0.00688580f, -0.03080181f, 0.00455039f, 
    0.00531674f, 0.00911653f, 0.00721063f, -0.04314964f, -0.03201702f, -0.04061785f, -0.05668695f, -0.03349937f, 
    -0.01817518f, -0.03366285f, 0.02638237f, 0.02561880f, -0.03575714f, 0.01114109f, 0.00056743f, -0.07626855f, 
    -0.06196458f, -0.00176449f, -0.02519212f, 0.00476529f, -0.04712256f, -0.01449085f, 0.01089431f, 0.00264631f, 
    -0.02591790f, -0.03537350f, -0.07241026f, 0.01330121f, -0.02048782f, -0.02604624f, -0.03659552f, -0.00422556f, 
    0.03966419f, 0.03618844f, -0.00315545f, 0.00440664f, -0.07044702f, 0.01583834f, -0.04127277f, -0.07949821f, 
    -0.01360813f, 0.00177399f, -0.01705962f, -0.06847735f, -0.05591786f, -0.05384628f, -0.06418476f, 0.01423607f, 
    0.02071371f, -0.04059121f, -0.04983309f, -0.06103458f, -0.00373240f, -0.06354968f, 0.01414702f, 0.03547771f, 
    -0.05673634f, -0.03668639f, -0.04507191f, 0.00957566f, -0.01121233f, -0.03405638f, -0.05063465f, -0.01709978f, 
    0.03428842f, -0.02006652f, 0.02901747f, 0.03701934f, 0.04498450f, -0.05458774f, 0.03786066f, -0.02553711f, 
    0.00696978f, 0.04004087f, -0.02210158f, -0.02474439f, -0.06173488f, -0.03777023f, 0.00391816f, -0.02961157f, 
    0.04423295f, -0.05277080f, -0.00836628f, 0.03391487f, -0.06710628f, -0.01482567f, 0.01613407f, 0.01714188f, 
    -0.07560240f, -0.05028111f, 0.00448709f, 0.02744817f, -0.00541728f, 0.03687542f, -0.04965354f, -0.01084811f, 
    0.03734692f, 0.01877097f, -0.04265420f, -0.00523501f, -0.01368672f, -0.03006816f, -0.01862332f, 0.04146510f, 
    -0.05738050f, -0.00610035f, -0.00619581f, -0.06280609f, -0.06729285f, -0.02930363f, -0.01643185f, 0.06172104f, 
    -0.00107080f, -0.03617203f, 0.02886819f, 0.01792657f, -0.01438106f, -0.04216930f, -0.04669522f, -0.01562663f, 
    0.03018212f, 0.04540213f, -0.06673747f, -0.00669891f, 0.00575989f, 0.00348049f, -0.07118887f, -0.06420867f, 
    -0.00255023f, -0.04032487f, -0.06917387f, 0.02363306f, -0.05244776f, 0.01573047f, 0.03726196f, 0.00063710f, 
    -0.03230529f, -0.02601009f, 0.02928835f, -0.07527985f, -0.04139284f, -0.04711527f, -0.05708248f, 0.02007309f, 
    0.01159168f, -0.05201378f, -0.00432552f, -0.00372429f, -0.04040790f, -0.07795411f, -0.04428980f, 0.01058235f, 
    -0.00573064f, -0.05294214f, -0.04458020f, 0.03407420f, -0.02880887f, -0.06258371f, -0.02756345f, 0.01223065f, 
    0.01801919f, -0.02130239f, -0.04152473f, 0.04992441f, -0.05133618f, -0.06587055f, 0.00799326f, -0.06264111f, 
    0.00411924f, -0.01980952f, -0.03470105f, -0.05607520f, -0.05064721f, -0.02736237f, 0.01347361f, -0.05446333f, 
    -0.04940294f, -0.04890819f, 0.01896195f, 0.02674422f, 0.04551074f, -0.05720280f, -0.05770606f, -0.01829801f, 
    -0.02655137f, -0.03228075f, -0.00542985f, -0.00045872f, 0.00076994f, 0.04179825f, -0.03809213f, -0.05785783f, 
    0.03622070f, 0.00867110f, 0.00435204f, -0.04853059f, 0.01473111f, -0.08056870f, -0.00091954f, -0.02506006f, 
    0.03586051f, -0.04795489f, 0.03628574f, -0.04731918f, -0.02478504f, 0.03830966f, -0.00364766f, -0.00998402f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.12278581f, 0.08306561f, 0.20568936f, 0.04543740f, 0.08379576f, 0.07871714f, 0.14060874f, 0.09237579f, 
    0.07504173f, 0.02716514f, 0.17091946f, 0.04742746f, 0.16876240f, 0.00487315f, 0.01655541f, -0.10652518f, 
    0.03791643f, 0.20035222f, 0.15454827f, 0.04243111f, 0.03809949f, -0.02499782f, -0.10550945f, 0.01742355f, 
    0.05662316f, -0.10626190f, 0.09193344f, -0.02519856f, -0.00868851f, 0.06532943f, 0.21116623f, -0.00491142f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19375870f, 0.13469906f, -0.21564695f, -0.03615226f, -0.04887187f, 0.23168856f, 0.19988032f, 0.08341904f, 
    0.09745207f, -0.13856864f, -0.04096771f, 0.12366755f, 0.21547739f, -0.08957828f, -0.10077026f, -0.20326281f, 
    -0.03644771f, 0.24867749f, -0.04893271f, -0.09418925f, -0.20363474f, 0.04852754f, -0.07178730f, -0.15625729f, 
    -0.19981350f, -0.14572117f, 0.19908859f, -0.08905652f, -0.06279937f, 0.11834502f, 0.00927123f, 0.11368804f, 
    -0.06546853f, -0.39095578f, 0.24687293f, 0.24482508f, -0.19603106f, -0.10413996f, -0.05513323f, 0.33510751f, 
    -0.27993116f, 0.08370392f, 0.29567176f, -0.16541664f, -0.18432501f, 0.00003199f, 0.02277692f, 0.05867205f, 
    0.22639011f, 0.25523871f, 0.13209663f, 0.29403669f, 0.17312799f, -0.16871816f, 0.06455240f, -0.00726205f, 
    0.26911378f, -0.15559669f, -0.09959496f, -0.14505745f, -0.11440670f, 0.31140834f, -0.04079216f, 0.01467896f, 
    -0.10048242f, 0.46998245f, -0.25269687f, 0.18181749f, -0.04034474f, 0.35728481f, -0.13332449f, -0.31997922f, 
    0.42587656f, 0.11782151f, 0.13171464f, 0.11985198f, 0.11455034f, -0.17550346f, -0.04124670f, -0.16232179f, 
    -0.09880119f, 0.09623598f, 0.07325698f, 0.06040582f, -0.01303709f, 0.14319570f, -0.34366420f, -0.26923186f, 
    0.02951598f, 0.06453472f, 0.23217013f, -0.16669887f, 0.08979551f, 0.04556779f, 0.21446882f, -0.04773846f, 
    -0.27314472f, 0.23537253f, -0.01185386f, -0.05994543f, 0.12750925f, 0.27324316f, -0.10157002f, -0.27771047f, 
    0.11045640f, 0.13216177f, 0.01128174f, -0.02214643f, -0.11072928f, -0.04941627f, 0.15636456f, 0.16471714f, 
    0.09112384f, -0.11869191f, 0.13065585f, -0.15142982f, -0.12332404f, -0.01485566f, 0.26504487f, 0.17712133f, 
    0.02887837f, 0.28472701f, 0.00488453f, -0.08345323f, -0.14673190f, -0.16853048f, -0.00415656f, -0.11030814f, 
    -0.12688737f, -0.07641418f, 0.18260367f, 0.16231373f, -0.31175411f, 0.42757931f, -0.03459125f, 0.23463836f, 
    0.22267258f, -0.02039786f, 0.16296631f, 0.05184783f, -0.31340566f, -0.16009793f, -0.15501159f, 0.33330381f, 
    0.41533127f, -0.04816590f, -0.12160764f, -0.03476637f, 0.08638556f, 0.07560637f, 0.18228550f, 0.00801569f, 
    0.21970412f, -0.03271578f, -0.05440183f, -0.02098138f, -0.13105242f, 0.03461559f, -0.23421651f, -0.08196230f, 
    -0.05061181f, -0.17717119f, 0.12554033f, -0.06646668f, -0.02263410f, 0.01464377f, -0.01845424f, 0.12382399f, 
    0.14364868f, 0.00832251f, 0.05873093f, 0.05179856f, -0.04323395f, 0.05398760f, -0.04314370f, -0.03152847f, 
    -0.17339125f, 0.02881055f, 0.03883216f, -0.18423125f, -0.17570893f, 0.13170977f, -0.16771641f, -0.17867373f, 
    -0.00857081f, -0.13346162f, -0.06599130f, -0.14221878f, -0.15828495f, -0.13698900f, -0.08449781f, 0.08652192f, 
    0.21160078f, -0.11384197f, 0.41740927f, -0.06327742f, 0.23951726f, -0.28545538f, 0.13711914f, -0.14863791f, 
    0.14025131f, 0.14293441f, -0.26891357f, 0.30707708f, 0.14876020f, -0.14011176f, 0.01916967f, -0.09393789f, 
    -0.04946354f, -0.06611505f, 0.26157272f, 0.00826310f, -0.26562127f, 0.16310263f, 0.00608513f, -0.13106234f, 
    -0.11403119f, 0.20438404f, -0.00308961f, 0.13273792f, 0.15774177f, 0.03598300f, -0.12233276f, 0.00926183f, 
    -0.09372750f, -0.05675313f, 0.18914984f, 0.07768013f, -0.29862183f, -0.43243483f, -0.18387538f, -0.21372218f, 
    -0.22373134f, -0.01365965f, -0.03405064f, 0.17606273f, -0.04908387f, -0.17566897f, -0.16990070f, 0.10459991f, 
    0.11508100f, 0.08144317f, 0.22431132f, -0.23164529f, 0.11451219f, -0.10852883f, 0.29533318f, 0.26261607f, 
    -0.05094383f, 0.13210987f, 0.24226598f, 0.07315477f, -0.12630463f, 0.12219568f, -0.20176709f, 0.04598027f, 
    0.20185137f, 0.12114625f, -0.05736480f, 0.10536974f, -0.45224628f, 0.13740470f, 0.12319706f, 0.22511384f, 
    -0.17374192f, 0.14207754f, 0.06420106f, 0.17443766f, -0.13621350f, 0.06435969f, 0.05386747f, -0.25595039f, 
    0.16659124f, 0.08528356f, 0.22377548f, 0.30268437f, -0.05069813f, 0.06825583f, 0.00663469f, 0.01941189f, 
    0.17064624f, -0.17968141f, -0.11695410f, 0.12148768f, -0.11221615f, 0.28748667f, 0.08886600f, 0.01734954f, 
    0.06454696f, 0.05424671f, 0.05291210f, -0.09339087f, -0.14213748f, -0.04822386f, 0.02124031f, -0.20932505f, 
    -0.09225976f, 0.01626150f, 0.05341025f, -0.21647359f, -0.09510727f, 0.05529331f, -0.15965955f, -0.09559863f, 
    -0.09746516f, -0.05792973f, -0.05835026f, -0.18959481f, 0.14461698f, -0.15648733f, -0.01011489f, 0.03600675f, 
    -0.01438260f, -0.13785210f, -0.05501259f, 0.15125251f, 0.15414619f, 0.09764004f, -0.15636656f, -0.07852181f, 
    -0.14106694f, -0.32930964f, 0.06827766f, 0.10069507f, -0.28481826f, -0.09071223f, 0.11588929f, -0.16797608f, 
    -0.35337758f, -0.10990159f, 0.18367845f, 0.15469503f, 0.08226887f, -0.03410411f, 0.15058762f, -0.26626709f, 
    -0.25696862f, 0.08396202f, 0.03402166f, 0.18813530f, -0.10483751f, -0.08282135f, -0.17258888f, 0.26696542f, 
    0.06357443f, 0.00017581f, 0.08329264f, -0.00800121f, 0.06674623f, 0.16838264f, -0.14100260f, 0.00062736f, 
    -0.09752124f, -0.13245699f, 0.19706947f, 0.16010922f, -0.30447826f, 0.66787660f, -0.19523409f, 0.16628891f, 
    0.14405991f, -0.08806766f, 0.02923179f, -0.20373644f, -0.03833863f, -0.03257852f, 0.08053894f, 0.15379219f, 
    0.13133681f, 0.09149582f, -0.18273990f, -0.15157866f, 0.23992731f, -0.11229138f, 0.16765800f, 0.07004674f, 
    0.29255947f, 0.01600845f, 0.09609699f, 0.17401540f, 0.10853443f, -0.11267450f, 0.09139250f, -0.12826619f, 
    -0.24680327f, -0.01580356f, 0.46206164f, 0.14039646f, 0.10494063f, -0.34826347f, -0.14979084f, 0.19671872f, 
    -0.17107040f, -0.17193958f, 0.06242668f, -0.20681006f, 0.03022174f, -0.02223897f, 0.13140519f, 0.23333478f, 
    0.32848281f, 0.13375618f, -0.09821249f, 0.05824539f, 0.23265861f, -0.10749206f, 0.37709317f, 0.17131841f, 
    0.33508760f, -0.03198216f, -0.06939691f, 0.08404803f, 0.04726394f, -0.11995514f, -0.11952378f, -0.02463968f, 
    -0.01778098f, -0.10950863f, 0.20872134f, 0.03779358f, -0.17770025f, -0.07953031f, -0.22901130f, 0.43638673f, 
    0.18432868f, 0.16400884f, 0.12174807f, -0.09365522f, -0.03157191f, 0.01432795f, -0.13378564f, -0.18322760f, 
    0.04516678f, 0.00714043f, 0.00108905f, 0.30825064f, 0.13426255f, -0.17009193f, 0.12034743f, 0.05375859f, 
    0.30187762f, -0.22095360f, -0.17268762f, -0.14686546f, -0.08884330f, 0.19279645f, 0.05226392f, 0.08819295f, 
    0.14889953f, -0.00491581f, -0.03614472f, 0.09515154f, 0.13261554f, -0.56027055f, -0.06096440f, 0.00685246f, 
    0.30572629f, -0.06474661f, -0.07377707f, 0.42746091f, 0.06983580f, 0.11365764f, -0.07690657f, -0.04980648f, 
    -0.21275140f, 0.17451400f, 0.23845214f, -0.10836224f, -0.20486452f, -0.07436296f, -0.28463289f, 0.03651397f, 
    -0.17158777f, -0.11514381f, 0.17272697f, 0.09891511f, 0.01686588f, -0.26754391f, 0.19763166f, -0.09910487f, 
    0.23263706f, 0.22432584f, 0.39092582f, -0.11468079f, 0.20691282f, -0.47961968f, -0.05433427f, -0.38338882f, 
    0.07511561f, -0.01125565f, -0.09623945f, 0.45451415f, -0.01476264f, 0.08059002f, 0.09065400f, 0.16487314f, 
    -0.32069540f, 0.08862381f, 0.26695418f, 0.07970298f, -0.31548589f, -0.10615608f, -0.05302907f, -0.26230139f, 
    0.21444725f, 0.20845971f, -0.11676488f, -0.17551158f, -0.05141557f, -0.25913656f, -0.13725376f, 0.04632267f, 
    -0.13595775f, 0.12453774f, 0.01759234f, -0.15925413f, -0.22999527f, -0.03868674f, -0.07337627f, -0.12776472f, 
    -0.07282601f, -0.03584248f, -0.06970329f, 0.14796378f, -0.03942309f, 0.07235076f, 0.06313334f, 0.03159623f, 
    -0.26977453f, -0.06813726f, -0.04304869f, -0.18498184f, 0.08753078f, -0.07661277f, 0.01288548f, 0.19751212f, 
    -0.08075194f, -0.10795037f, 0.05354937f, -0.16293550f, 0.13673851f, -0.13322826f, -0.05835062f, -0.02546848f, 
    0.17063057f, -0.33141682f, 0.28446004f, 0.08497727f, 0.09286320f, -0.04264069f, -0.00835124f, -0.10125047f, 
    -0.15042369f, 0.16749945f, -0.12073256f, 0.12891790f, -0.07271284f, 0.14495675f, -0.06480148f, -0.10201953f, 
    -0.43675923f, -0.18172781f, 0.28726617f, 0.06435948f, 0.29822072f, -0.16050266f, -0.27589244f, -0.10173947f, 
    -0.04800404f, -0.26124513f, 0.26049438f, -0.06952804f, 0.12505698f, 0.05804136f, 0.10394418f, -0.08345354f, 
    -0.31221119f, -0.14893052f, 0.03903367f, 0.09898819f, -0.27515233f, 0.02612962f, -0.06460232f, 0.05507428f, 
    -0.28504679f, -0.06890306f, -0.02319656f, 0.37908706f, -0.25285044f, -0.15965125f, 0.07032320f, 0.29678565f, 
    0.27955741f, -0.10138884f, -0.00341725f, -0.12114089f, -0.12069395f, 0.15226355f, 0.26863950f, 0.10687896f, 
    0.09438519f, 0.05974350f, -0.03388512f, 0.08914316f, -0.14303683f, -0.19885392f, -0.41756845f, 0.09365287f, 
    -0.00541766f, -0.25350598f, 0.33638811f, 0.25119287f, 0.07280244f, 0.10459957f, -0.33253941f, 0.19057427f, 
    -0.00189403f, -0.14214551f, 0.07399453f, 0.13017696f, -0.10933656f, -0.03094038f, -0.15583959f, 0.12445357f, 
    0.00644684f, -0.15657559f, -0.07589117f, 0.10309155f, -0.37307686f, 0.06479064f, 0.02580677f, -0.18176663f, 
    0.41895434f, 0.24729723f, -0.13398349f, -0.05575387f, 0.00205993f, 0.07824064f, 0.03107463f, 0.14817534f, 
    0.02037250f, 0.26057747f, -0.18550816f, -0.04020343f, 0.02077009f, -0.03289696f, -0.10906687f, 0.30799133f, 
    0.00898130f, 0.11491660f, 0.36566705f, -0.12308837f, 0.02787657f, 0.17336912f, -0.03987222f, 0.17148557f, 
    0.28319880f, 0.01519550f, -0.24821040f, 0.11733858f, 0.15415591f, 0.17324755f, 0.05397194f, 0.18841501f, 
    0.11611746f, -0.01642638f, -0.14284755f, -0.16897570f, 0.05061238f, -0.10715317f, 0.25056899f, 0.01227913f, 
    -0.15001215f, 0.04790832f, -0.11963598f, -0.16431385f, 0.18611945f, 0.50011325f, 0.17825580f, -0.22711395f, 
    0.13560602f, -0.11196379f, 0.23097077f, -0.16593118f, 0.00380354f, -0.06402001f, 0.11273492f, -0.30260354f, 
    -0.18609077f, 0.12526020f, 0.07663117f, -0.05153287f, -0.11101212f, 0.15514089f, -0.20377968f, 0.06030759f, 
    -0.18518479f, 0.18281353f, 0.12174693f, 0.08029455f, 0.06848530f, 0.14277561f, 0.02506517f, -0.06798856f, 
    -0.08092880f, 0.08402083f, -0.11528331f, 0.01900833f, -0.09074191f, 0.39058980f, 0.29804316f, 0.09690436f, 
    0.15935370f, -0.00195437f, 0.17400564f, -0.19623271f, 0.23358954f, -0.06319077f, -0.00158093f, -0.49170789f, 
    -0.24308366f, 0.13818644f, -0.02808676f, 0.16470090f, 0.07711353f, 0.04829464f, -0.26368740f, 0.14866099f, 
    -0.06631211f, -0.13915950f, -0.08007891f, -0.00618262f, 0.00520341f, 0.15999606f, 0.32873866f, -0.09635849f, 
    -0.23446567f, 0.07226983f, 0.08575832f, -0.02907277f, 0.28149953f, 0.50510049f, -0.16793291f, -0.36880735f, 
    -0.08932838f, 0.13374567f, 0.11421945f, 0.03882884f, -0.21448718f, 0.11306695f, -0.06613918f, 0.06033430f, 
    0.07984699f, -0.12869145f, -0.08490293f, -0.03464948f, 0.10968915f, -0.13959651f, 0.33136287f, 0.03815104f, 
    0.33379900f, 0.28494343f, 0.25925556f, -0.08654468f, 0.04471572f, -0.17469236f, -0.15539275f, 0.16262984f, 
    -0.08935677f, 0.03108053f, 0.49843949f, -0.06189403f, 0.28009862f, 0.02277967f, 0.31890807f, -0.25134841f, 
    -0.20106019f, 0.12383008f, -0.23070700f, 0.11773837f, -0.02745268f, 0.09138149f, -0.02370593f, 0.01403627f, 
    -0.27283424f, -0.04477088f, 0.31044364f, 0.20726153f, -0.20087953f, -0.04243911f, -0.03099784f, 0.07173590f, 
    0.11600348f, 0.08072069f, -0.26382115f, 0.02717085f, 0.14661740f, -0.09497105f, -0.00996139f, -0.04352884f, 
    -0.15970980f, 0.15329821f, -0.14966321f, -0.19138330f, -0.14064151f, 0.09444318f, -0.18219785f, -0.02303331f, 
    0.01027512f, 0.15845810f, -0.17927583f, 0.00185837f, -0.15015554f, -0.02292011f, 0.17166828f, 0.13176736f, 
    0.04601347f, -0.30978516f, 0.05531513f, -0.15092386f, 0.15615183f, 0.09811993f, -0.20420852f, -0.18257861f, 
    -0.09998478f, 0.00805675f, -0.08514661f, 0.16157807f, 0.12740590f, -0.13545653f, -0.05095977f, -0.04572733f, 
    -0.01559847f, 0.07542264f, 0.20893733f, 0.12330850f, -0.20735931f, 0.10985822f, 0.23776828f, -0.21956241f, 
    -0.09481195f, 0.06717165f, -0.01340341f, 0.02947888f, -0.08567430f, 0.15481189f, 0.03069122f, 0.10112114f, 
    -0.29103607f, -0.12983783f, 0.17245522f, 0.27848297f, -0.10455511f, -0.13508877f, -0.07267261f, 0.06535399f, 
    0.03062347f, 0.00697921f, -0.00146802f, 0.10991382f, 0.11253978f, 0.15347447f, -0.18253647f, 0.04812495f, 
    0.01924636f, 0.00430930f, 0.22709258f, 0.18572788f, 0.09425543f, -0.39519903f, -0.17042792f, 0.53474325f, 
    -0.27727097f, 0.13955766f, 0.40387389f, -0.34787300f, 0.01073787f, 0.12908714f, 0.11180452f, -0.09724707f, 
    0.31909251f, 0.17161684f, -0.11980642f, 0.14378695f, 0.03235009f, 0.08604121f, 0.08468855f, -0.17665106f, 
    0.15047717f, -0.34986064f, 0.13487160f, 0.06226366f, -0.09955411f, -0.06086436f, 0.11591082f, 0.13157968f, 
    -0.09681321f, 0.18861988f, 0.04561016f, -0.09569832f, -0.16149600f, -0.08800305f, -0.30122814f, -0.12916748f, 
    0.02698718f, 0.02275110f, -0.07788736f, 0.15334721f, 0.10915259f, -0.02470425f, 0.17310809f, 0.05746474f, 
    0.12196723f, -0.10679711f, -0.08494116f, -0.13297227f, 0.13183577f, -0.12897024f, -0.07704717f, -0.12337992f, 
    -0.29146022f, -0.07548356f, 0.22519282f, -0.02572052f, 0.10248134f, -0.33830908f, 0.03146742f, 0.05515015f, 
    -0.08577815f, -0.14915547f, -0.22908612f, -0.10229939f, -0.11222201f, -0.14117266f, -0.18487877f, -0.15697417f, 
    0.07640484f, -0.01109037f, -0.21079478f, 0.10444588f, -0.15997991f, 0.17068997f, -0.06092487f, 0.07790743f, 
    -0.15336800f, -0.13133802f, 0.03911565f, -0.15307425f, -0.18311173f, 0.03128904f, 0.05553864f, -0.08411549f, 
    0.05107964f, 0.00577301f, 0.04180827f, 0.08451515f, 0.16873014f, 0.01786446f, -0.11283756f, -0.16946198f, 
    -0.16422223f, -0.06809468f, 0.10463195f, -0.34452447f, 0.00383854f, -0.10427154f, -0.16571324f, -0.09730438f, 
    0.25683358f, -0.17271392f, -0.30907539f, 0.37888566f, -0.03410361f, 0.09706636f, -0.02109184f, 0.24280502f, 
    -0.25497296f, -0.09920631f, -0.16801673f, -0.02008108f, 0.12389693f, 0.05628459f, -0.23296453f, -0.58244187f, 
    -0.42151785f, 0.07681999f, 0.20972733f, -0.00442080f, -0.06590526f, -0.23412690f, -0.08262213f, 0.01010696f, 
    0.16197206f, -0.15124775f, -0.00968897f, 0.25897202f, 0.02991528f, -0.28829303f, -0.18542831f, 0.01770311f, 
    0.11316181f, -0.15410253f, -0.12357847f, -0.39699039f, 0.16503890f, -0.15147364f, 0.17381535f, 0.09817687f, 
    -0.01746213f, -0.01321941f, 0.00773251f, -0.16722186f, 0.19263057f, -0.05155162f, 0.23976627f, 0.16053380f, 
    -0.26589149f, -0.04898417f, -0.01867566f, -0.00114016f, 0.00006396f, 0.02845266f, 0.00436020f, 0.01752974f, 
    -0.15002885f, -0.14862019f, -0.12704805f, -0.08835638f, -0.03238028f, -0.14349744f, -0.14394702f, -0.03827932f, 
    0.02480818f, 0.17221519f, -0.01750507f, -0.00834988f, 0.07693472f, -0.10037335f, 0.09488799f, 0.07191667f, 
    -0.12310947f, 0.01617365f, -0.02662890f, 0.00758428f, -0.06700975f, 0.11745302f, 0.14750928f, -0.10635694f, 
    0.11319486f, -0.12034614f, -0.02278193f, 0.11821771f, -0.02626571f, 0.05472440f, -0.00084093f, 0.09468988f, 
    0.10079517f, -0.05321878f, 0.46923617f, -0.29152617f, 0.08897928f, -0.19557732f, -0.08875743f, -0.06036656f, 
    0.32144168f, 0.09822824f, -0.29374793f, -0.20469698f, 0.00423194f, -0.17091744f, -0.15023409f, 0.22448187f, 
    -0.12778309f, -0.16850090f, -0.26121438f, -0.21743686f, -0.06388962f, 0.11321586f, -0.08116876f, -0.28572315f, 
    0.02657398f, -0.06148638f, 0.27813587f, 0.11158837f, -0.15716860f, -0.53791529f, -0.10715480f, -0.17640308f, 
    0.27725437f, -0.09964807f, 0.27571237f, 0.30041900f, -0.25539201f, -0.02155355f, -0.04155727f, -0.15942466f, 
    -0.28613222f, 0.16339727f, -0.24763596f, 0.38919798f, -0.11290754f, 0.04589967f, -0.02830386f, -0.27062485f, 
    -0.33136061f, 0.19693924f, 0.21614978f, 0.11348493f, -0.10698439f, 0.12850636f, -0.12703902f, -0.17098799f, 
    0.24568759f, -0.10475812f, 0.19903515f, -0.00303342f, 0.11882383f, 0.28361169f, -0.16299421f, -0.14441392f, 
    0.05001163f, -0.28244525f, -0.00974915f, 0.21905510f, -0.38470796f, 0.08118407f, -0.00872134f, 0.36015800f, 
    -0.04110594f, 0.04973480f, 0.35998988f, -0.25045905f, 0.22495684f, -0.16208681f, 0.01149704f, -0.09356111f, 
    -0.11186187f, 0.23287174f, -0.08058502f, 0.07272551f, -0.24900265f, -0.09326176f, -0.30534184f, 0.24262598f, 
    0.12470441f, -0.25007787f, 0.02366496f, -0.07468057f, 0.05517333f, 0.22668990f, 0.19668885f, 0.08150348f, 
    -0.23616259f, -0.28348643f, 0.33307764f, -0.00263061f, 0.27647480f, -0.23971833f, 0.10105941f, -0.24954580f, 
    0.07990421f, -0.08609626f, -0.02463079f, 0.09355073f, 0.16569245f, -0.13418216f, -0.10802847f, -0.05405129f, 
    -0.02632597f, -0.01433582f, 0.05585223f, 0.08461100f, -0.11642332f, -0.13054851f, -0.11496358f, 0.27007571f, 
    -0.17000638f, 0.23780376f, -0.32723320f, -0.11558054f, -0.10502616f, 0.01427212f, -0.03154341f, 0.08925379f, 
    -0.35269973f, -0.27928287f, -0.13273245f, 0.03065916f, 0.31233275f, -0.02944498f, 0.05873521f, -0.21708587f, 
    -0.07605272f, 0.03628910f, 0.15007555f, 0.08825260f, 0.12183200f, 0.14430174f, -0.04516306f, -0.10572755f, 
    -0.04526110f, 0.03173563f, 0.16793755f, -0.18711762f, -0.21081024f, -0.00933218f, -0.13104437f, 0.30825099f, 
    -0.04263178f, 0.12062496f, -0.25638461f, -0.02388432f, -0.01365945f, 0.02497518f, -0.13808325f, 0.13054648f, 
    -0.09130163f, -0.08859167f, -0.21334879f, 0.01587267f, -0.02175310f, 0.02307017f, 0.10579415f, -0.08953828f, 
    -0.12275833f, -0.13629864f, -0.14254311f, 0.10722047f, -0.05459577f, 0.01294416f, -0.17081328f, 0.08770761f, 
    -0.18112689f, -0.03978441f, -0.09414560f, -0.16550814f, -0.06736345f, -0.10794701f, -0.07250305f, -0.14144595f, 
    -0.07409246f, 0.12759042f, -0.14541711f, 0.08168036f, -0.05766154f, -0.03159892f, 0.04910557f, 0.03722481f, 
    -0.29373685f, 0.41655102f, 0.19650333f, 0.04295427f, -0.21943469f, 0.39863336f, -0.04990071f, -0.09075046f, 
    0.15357007f, -0.06041458f, -0.05635001f, 0.20660135f, -0.02471509f, 0.05289897f, -0.05670553f, 0.22920762f, 
    0.38033456f, -0.04250301f, -0.16626920f, 0.20846932f, -0.17418534f, -0.10098057f, 0.28204948f, 0.34593821f, 
    0.18700068f, 0.24756587f, -0.11118434f, 0.04352646f, 0.01374518f, -0.04921782f, -0.37710831f, -0.00665839f, 
    0.18128546f, 0.42184666f, 0.13885249f, 0.32185641f, -0.16215274f, -0.63914025f, -0.08639526f, -0.55547273f, 
    -0.00936416f, -0.00704613f, 0.04682412f, 0.18433018f, -0.14915411f, 0.04811889f, -0.05833006f, 0.10176267f, 
    -0.07014085f, 0.10878540f, 0.04949701f, 0.07852619f, -0.10511093f, -0.12289689f, 0.29803577f, 0.10656857f, 
    -0.04324557f, 0.00478606f, 0.35645702f, -0.12638986f, 0.13340598f, -0.03308680f, 0.03676904f, 0.15830185f, 
    0.15119661f, -0.35845542f, 0.27360341f, 0.01852546f, 0.21076065f, 0.29338628f, 0.05489098f, -0.01139469f, 
    -0.37555945f, 0.05487369f, -0.10073645f, 0.06026870f, -0.10159159f, -0.17549695f, -0.10504387f, 0.13146240f, 
    0.16178747f, -0.24426681f, 0.16485977f, 0.04884074f, 0.23636872f, -0.01807679f, 0.26252237f, -0.01279748f, 
    -0.01201109f, -0.22592641f, 0.08192328f, -0.11604042f, 0.06134719f, 0.07392152f, -0.13619645f, 0.04618398f, 
    0.31791750f, -0.07931476f, 0.07092691f, -0.04938444f, -0.20117533f, -0.19676220f, -0.00223622f, 0.18547530f, 
    -0.05976316f, 0.09011796f, -0.15832992f, -0.07332008f, 0.24770394f, -0.06989277f, 0.09883143f, -0.04016560f, 
    -0.24279450f, 0.24693017f, 0.19610158f, 0.24124630f, -0.15885195f, 0.10170399f, -0.05480946f, 0.08602298f, 
    -0.07517718f, -0.18163487f, -0.11353978f, -0.02896182f, 0.03432835f, 0.34235349f, 0.10225768f, -0.07063710f, 
    0.47933620f, -0.38033187f, 0.37305722f, 0.05040665f, -0.17423049f, -0.47121117f, -0.01973317f, 0.54556197f, 
    -0.08300202f, 0.11424635f, 0.12107566f, -0.00339330f, 0.08484299f, 0.09331228f, 0.14817725f, 0.10497758f, 
    -0.01176564f, -0.06396191f, -0.05291278f, 0.25628853f, -0.61695671f, 0.09394922f, 0.11068924f, 0.00320151f, 
    0.32099301f, 0.04790128f, -0.43526238f, 0.10526704f, -0.13162786f, -0.03586083f, 0.09108664f, -0.05951666f, 
    0.06822072f, 0.00353129f, 0.03251048f, 0.14616619f, -0.06556584f, -0.01015434f, 0.10969178f, -0.09774183f, 
    -0.11531666f, 0.00103858f, -0.05373982f, -0.13129462f, -0.05084404f, 0.02277198f, 0.10189641f, -0.11245505f, 
    0.03881121f, -0.11859840f, -0.07898688f, -0.06845650f, -0.11430565f, -0.11874891f, 0.05900542f, -0.14470167f, 
    -0.20364316f, -0.12692049f, 0.13161989f, 0.12648079f, 0.01761466f, -0.10787622f, -0.14294238f, -0.09139302f, 
    -0.00133947f, -0.04373728f, -0.26209280f, 0.13194510f, -0.04145554f, 0.38576046f, 0.19720277f, 0.08409177f, 
    0.18492791f, -0.06775616f, 0.19245610f, -0.43438378f, 0.19369003f, -0.01220836f, 0.10084379f, -0.24376108f, 
    0.31144986f, -0.13548942f, 0.02092741f, -0.04944430f, 0.06862733f, 0.06633350f, 0.10504132f, -0.01704905f, 
    -0.10683637f, -0.26217028f, 0.23312449f, 0.02303503f, 0.07620607f, 0.23025589f, 0.08163822f, -0.13444069f, 
    0.00797247f, -0.00536441f, -0.18819351f, 0.04238529f, 0.12667371f, -0.19336060f, -0.20241559f, 0.31739569f, 
    0.00278237f, -0.04176836f, 0.33611676f, -0.20263013f, 0.07066428f, 0.10539262f, -0.13586633f, 0.04545306f, 
    0.37255988f, 0.01806488f, -0.08340003f, 0.04397044f, 0.17983367f, 0.14427778f, -0.15250942f, -0.06474590f, 
    0.14771776f, -0.32103071f, 0.28511116f, -0.08004519f, 0.04074489f, -0.18398772f, 0.19053523f, -0.15884539f, 
    -0.02175156f, -0.01087026f, -0.16538468f, 0.12004010f, -0.03069009f, 0.09816476f, 0.19012365f, 0.26761752f, 
    -0.13767388f, -0.10934249f, 0.22728682f, -0.01305010f, 0.17257656f, -0.12923121f, -0.09300589f, -0.41416842f, 
    -0.24276660f, 0.14911516f, 0.09573954f, -0.26573721f, -0.36577657f, 0.05152421f, -0.34397396f, 0.02603987f, 
    0.02223152f, -0.12205558f, -0.08582728f, -0.10372428f, -0.01170867f, 0.04892550f, 0.16550539f, -0.05422280f, 
    -0.22176243f, 0.18549988f, 0.13551918f, -0.16224714f, 0.10433823f, -0.09832244f, 0.30334011f, 0.03787159f, 
    0.09118300f, -0.06053286f, 0.30625135f, 0.12247377f, 0.17857404f, -0.15284972f, -0.15816225f, -0.39572904f, 
    -0.17751472f, 0.06165283f, 0.25796264f, -0.28967428f, -0.16625379f, 0.01056338f, -0.02888471f, -0.01105448f, 
    -0.25501198f, -0.08961236f, -0.00162156f, 0.16395162f, -0.00619927f, -0.00739429f, 0.10705762f, -0.17431903f, 
    0.01852538f, -0.11781732f, -0.04917165f, -0.10209823f, -0.00468816f, 0.06733946f, 0.06515463f, -0.00847881f, 
    0.04852324f, 0.14933729f, -0.05410041f, 0.05792596f, -0.00294281f, 0.04681037f, 0.00841567f, -0.08039394f, 
    0.16874582f, -0.17382556f, -0.20302881f, -0.05175203f, -0.14907447f, -0.02537246f, -0.16717841f, 0.01296616f, 
    -0.13718989f, -0.18441698f, 0.04269098f, -0.02796816f, -0.16495861f, 0.00187337f, -0.03641009f, -0.16313592f, 
    -0.63184911f, -0.52881503f, 0.16046503f, -0.10313337f, 0.24652332f, -0.15702739f, 0.36289150f, -0.42847636f, 
    -0.20776847f, 0.15532427f, -0.00921167f, 0.19345868f, 0.06615999f, -0.10635201f, -0.16365395f, -0.36386982f, 
    -0.20176934f, -0.07627822f, 0.27733675f, -0.27774069f, -0.35592768f, 0.07635423f, 0.12276691f, 0.21385849f, 
    0.00705172f, 0.32620221f, 0.10544039f, 0.07748865f, -0.02203262f, 0.05200562f, -0.33854219f, 0.00310659f, 
    -0.10658130f, 0.39846534f, 0.15199675f, 0.21922703f, -0.31133088f, -0.12389822f, 0.11155307f, -0.14200595f, 
    -0.06327503f, 0.07139116f, -0.16982950f, 0.00351208f, -0.26099604f, 0.08576072f, 0.07598148f, 0.12876846f, 
    0.12619260f, 0.05813361f, 0.18453790f, -0.19793218f, -0.32874489f, -0.03819855f, 0.35044393f, 0.10627503f, 
    -0.04603178f, 0.31009039f, 0.14184092f, 0.11747608f, 0.13445011f, 0.11488494f, -0.36037859f, -0.10245692f, 
    0.08834540f, -0.14999971f, -0.05481334f, 0.08574352f, -0.02398655f, -0.02550150f, -0.15808123f, -0.05799088f, 
    -0.08358458f, -0.08468016f, -0.07897093f, -0.05187221f, -0.04301299f, 0.00754899f, 0.13977760f, 0.14613041f, 
    -0.01684633f, -0.11607088f, 0.06306024f, 0.13063945f, -0.11777031f, 0.07790615f, -0.12707856f, 0.01023235f, 
    -0.06491291f, -0.12202296f, -0.16492896f, -0.16787893f, -0.14814569f, 0.00586372f, -0.04744662f, -0.03771492f, 
    0.06570556f, 0.09191377f, -0.20212077f, 0.00032147f, 0.03921773f, -0.01614001f, -0.15691665f, 0.07279503f, 
    0.04693187f, 0.10499367f, -0.00353334f, -0.18771699f, -0.18685278f, -0.04564046f, 0.12059604f, -0.22822444f, 
    0.09879785f, -0.25864282f, -0.00088999f, 0.04491457f, 0.00905966f, -0.12001622f, -0.17658754f, -0.05821063f, 
    -0.01844055f, 0.07173514f, -0.21373393f, -0.00398741f, 0.09612644f, 0.07337217f, -0.00731458f, -0.10005539f, 
    0.15779606f, 0.17908387f, 0.02209698f, 0.21628885f, -0.35472587f, 0.04207319f, -0.10462455f, -0.22931510f, 
    -0.01484765f, -0.02803879f, -0.03477109f, 0.44577804f, -0.15550201f, -0.11044550f, -0.01907644f, 0.24910372f, 
    0.05935626f, -0.00410019f, 0.09851909f, -0.34172845f, -0.11307538f, 0.13081546f, 0.30398750f, -0.01444389f, 
    0.01089092f, 0.23207277f, 0.24071911f, 0.14002328f, 0.13683762f, -0.31446114f, -0.22805427f, 0.04361269f, 
    -0.40102512f, 0.31211597f, 0.16984931f, 0.02597025f, 0.01994713f, -0.54923981f, 0.07202090f, -0.07911879f, 
    0.26783165f, 0.11649080f, 0.14878301f, 0.17400454f, 0.10487571f, -0.04751469f, -0.03769876f, -0.02194140f, 
    -0.38518056f, 0.14507428f, -0.03769316f, 0.11293909f, -0.22854736f, 0.16502219f, -0.16548775f, 0.45006785f, 
    0.07228883f, 0.11825114f, -0.28792098f, -0.14406711f, -0.06196442f, 0.02352348f, 0.25187033f, 0.08581964f, 
    0.11298838f, -0.15646170f, -0.02639467f, 0.25973740f, -0.34446424f, 0.27754867f, 0.30946839f, 0.04139000f, 
    -0.10104545f, -0.10268151f, 0.21103922f, -0.07400968f, 0.25142184f, -0.09323309f, -0.03757311f, -0.39231455f, 
    -0.15419783f, 0.30548519f, 0.00643406f, -0.12140023f, -0.30987182f, 0.01464356f, -0.30561164f, -0.04874532f, 
    0.06517938f, -0.25593165f, 0.24698953f, -0.15206300f, -0.00444316f, -0.11426659f, 0.06848043f, 0.08152141f, 
    0.01917388f, 0.20205423f, 0.12287244f, 0.28314716f, -0.11609139f, -0.35637319f, -0.15257674f, 0.58488959f, 
    -0.06257484f, 0.08715416f, -0.10862292f, -0.02317595f, -0.12815060f, -0.17587145f, -0.09940500f, 0.17378941f, 
    0.05412300f, -0.15245324f, -0.12711531f, -0.08503723f, 0.14855430f, -0.16820520f, -0.09567279f, 0.25525537f, 
    0.08148840f, 0.15460554f, -0.28008825f, 0.06760703f, -0.05868828f, 0.09007329f, 0.17360036f, -0.00934996f, 
    0.10582313f, -0.00485510f, -0.29489410f, 0.18853493f, 0.00592079f, 0.16966535f, -0.00039810f, 0.31981009f, 
    0.04594586f, 0.06622558f, -0.00319633f, -0.11139561f, -0.10079736f, 0.16116357f, -0.05408397f, 0.05453390f, 
    0.32355875f, -0.15870216f, -0.08834437f, -0.18140964f, 0.20059888f, -0.03596491f, 0.14999351f, -0.12010589f, 
    0.10573203f, -0.16620576f, 0.47947642f, -0.01807339f, -0.13960002f, -0.17612359f, 0.04893500f, 0.15777409f, 
    -0.37821335f, 0.38736477f, -0.22809744f, -0.13301419f, -0.05452496f, 0.26403528f, 0.00665645f, -0.13593756f, 
    0.45388296f, 0.05554111f, 0.35251319f, 0.20801559f, 0.08164054f, 0.08502077f, 0.03585501f, -0.12287928f, 
    0.09971708f, 0.04926782f, 0.18574809f, -0.24723782f, -0.07017372f, 0.12361766f, 0.21674262f, 0.38128725f, 
    -0.23186986f, 0.20893452f, -0.06858869f, 0.15647095f, -0.01027836f, -0.12334724f, 0.06592828f, 0.13331994f, 
    0.25478601f, 0.42841703f, -0.33189958f, 0.00137199f, -0.28702229f, 0.79386765f, 0.05815483f, -0.30451733f, 
    0.22004808f, 0.16100349f, 0.03412296f, 0.09647096f, -0.11708836f, -0.05432392f, -0.13112599f, -0.07607208f, 
    0.02007645f, 0.08882461f, 0.07627230f, 0.14871499f, -0.01620251f, 0.07968117f, -0.07621340f, -0.01981169f, 
    -0.13320149f, -0.21072644f, 0.23452823f, 0.16307016f, -0.08016538f, 0.27957901f, 0.14720699f, 0.09576795f, 
    -0.08386374f, -0.07866686f, 0.13544871f, 0.07439046f, -0.16499868f, -0.58728397f, -0.06881442f, 0.39456326f, 
    -0.38628295f, -0.05245051f, 0.20985758f, 0.03645587f, -0.04835081f, -0.06418601f, -0.11071807f, 0.10601573f, 
    0.30590266f, -0.02864418f, 0.18074873f, -0.03225381f, 0.14016341f, 0.02151694f, 0.08144883f, 0.37955144f, 
    0.19781433f, -0.19851436f, 0.28758937f, -0.16419071f, 0.04802821f, -0.09196672f, 0.12102345f, -0.09830336f, 
    0.26591024f, -0.27440906f, 0.02636182f, -0.02238614f, 0.19283573f, 0.01536782f, 0.23486227f, 0.15333870f, 
    0.26078963f, 0.04500395f, 0.16126435f, 0.01780577f, 0.11513858f, -0.00711479f, -0.14685729f, -0.28531834f, 
    -0.22736970f, 0.23009647f, -0.03360561f, 0.12938888f, -0.16601348f, 0.10104112f, -0.08864617f, 0.14967710f, 
    -0.09056319f, -0.23089719f, -0.26137459f, -0.00610991f, -0.15277037f, 0.02121203f, 0.30205297f, -0.09314009f, 
    -0.06850275f, -0.21863018f, 0.06064836f, 0.20916671f, -0.12933943f, -0.32158586f, -0.02608631f, 0.35208952f, 
    -0.36788827f, 0.14313819f, -0.04151059f, 0.18008538f, 0.04029574f, -0.16366656f, -0.09540886f, 0.02868951f, 
    0.40364176f, -0.10223077f, 0.13961057f, 0.25496238f, 0.15984316f, 0.08218735f, 0.22442503f, 0.27769524f, 
    0.20697048f, -0.25416902f, 0.11403423f, -0.08569618f, -0.12961508f, 0.20459463f, -0.22968148f, 0.01834952f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14038236f, 0.22991890f, 0.01288476f, 0.04166966f, -0.03896891f, -0.08753841f, -0.03429193f, 0.05085707f, 
    0.04375278f, 0.10098909f, 0.09935135f, 0.00749681f, 0.04995581f, 0.17191115f, 0.04216972f, 0.14121014f, 
    0.00553061f, -0.06899476f, -0.01119107f, -0.18248399f, -0.09756580f, 0.15487431f, 0.16305533f, 0.09550703f, 
    0.26347703f, -0.18856284f, 0.18093897f, -0.01735507f, 0.12924922f, -0.06827488f, 0.18442914f, -0.27772117f, 
    0.13997747f, 0.37871447f, 0.23532188f, 0.04148476f, 0.25772363f, 0.16037789f, -0.06968614f, 0.02844255f, 
    -0.02720006f, -0.04818324f, 0.04069743f, -0.11685435f, -0.16934279f, 0.00712482f, 0.10937998f, 0.14909101f, 
    0.41731399f, 0.00553928f, 0.30938828f, -0.11139117f, -0.14410959f, 0.09647525f, -0.05229410f, 0.24805570f, 
    0.20161755f, -0.08043491f, -0.06663451f, 0.20703451f, 0.14289731f, 0.13335599f, 0.03375920f, -0.11545812f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16470999f, -0.09687416f, -0.01427455f, 0.05263129f, -0.02530007f, -0.04212083f, -0.08178356f, -0.04211712f, 
    -0.08283772f, 0.14458004f, -0.07006346f, 0.21905273f, -0.07900823f, -0.16180506f, -0.16763085f, 0.00582216f, 
    0.16548097f, 0.01063415f, 0.22274943f, -0.11369190f, -0.12130953f, 0.14884339f, 0.01134003f, 0.36801007f, 
    0.15213151f, -0.20129502f, 0.18277213f, -0.22072807f, -0.05688083f, 0.09982597f, -0.31884173f, -0.12295815f, 
    -0.02533051f, -0.18072866f, 0.13519427f, -0.03047068f, 0.07489908f, -0.14902915f, 0.07790815f, 0.25197759f, 
    0.13795087f, 0.18777974f, -0.05403277f, -0.43899468f, 0.09907158f, -0.04267498f, -0.17402500f, -0.06475914f, 
    -0.27686772f, -0.00115375f, 0.18001540f, 0.03793782f, 0.03224309f, 0.05280047f, 0.15137714f, -0.06259393f, 
    -0.00223034f, -0.11041511f, -0.03164442f, 0.00581754f, 0.22637646f, -0.03155929f, -0.34487307f, 0.08069358f, 
    -0.14112303f, 0.33906767f, -0.00529934f, -0.08786490f, 0.25218889f, -0.08436883f, 0.20421840f, 0.46644258f, 
    0.14011617f, 0.01045511f, 0.15190278f, 0.08288017f, 0.28896418f, 0.03427133f, 0.05721207f, 0.08281254f, 
    -0.08653615f, 0.16906475f, -0.11452823f, 0.14056112f, -0.24824411f, -0.19808865f, -0.38401550f, 0.03765427f, 
    -0.07170581f, 0.14811501f, 0.06097083f, 0.30527976f, 0.18721926f, 0.02747212f, 0.02851549f, 0.01501784f, 
    0.05105309f, 0.02273572f, 0.26500627f, 0.03706421f, -0.13676934f, -0.03750321f, 0.06730655f, -0.03916807f, 
    0.37455988f, 0.23484634f, 0.05645654f, -0.31982172f, 0.07280730f, -0.01435815f, -0.01250111f, -0.21897833f, 
    -0.15722814f, -0.03819801f, 0.00582975f, 0.16896528f, 0.04872432f, 0.02070593f, 0.30494359f, -0.01251540f, 
    0.03507049f, -0.08322660f, 0.09388737f, -0.14140375f, -0.20378049f, 0.50601059f, -0.24579610f, 0.37537134f, 
    -0.19923782f, 0.21087931f, -0.09190554f, 0.08879135f, -0.03161727f, -0.00906934f, -0.29195750f, 0.19570485f, 
    0.04452671f, 0.20691837f, 0.21771039f, -0.00110416f, 0.00468295f, 0.14975433f, 0.05152128f, 0.05027595f, 
    -0.02439775f, 0.04075512f, -0.09892908f, -0.11572357f, 0.04470292f, 0.03049433f, -0.08301636f, -0.08529851f, 
    0.01102123f, -0.00784875f, -0.03704837f, 0.21920080f, 0.13148910f, 0.06253880f, 0.14296503f, 0.01658894f, 
    -0.06180760f, 0.25639129f, 0.01632992f, 0.20712517f, -0.05640939f, 0.15975082f, -0.02846717f, -0.11347677f, 
    0.09301716f, -0.18172969f, -0.07802837f, 0.04780916f, -0.09397728f, -0.10828468f, 0.07107465f, 0.14799500f, 
    0.17331301f, 0.11670119f, 0.18019788f, -0.06223764f, -0.01229100f, 0.02228818f, -0.00379191f, 0.29668242f, 
    0.03378463f, 0.05068853f, 0.04419937f, 0.08171014f, -0.11823802f, 0.36126694f, -0.06810198f, 0.12345262f, 
    -0.13845314f, -0.13113506f, -0.01297812f, 0.16512243f, 0.11318418f, -0.05868934f, -0.26437834f, 0.06901862f, 
    -0.14805047f, -0.02111246f, -0.08831828f, 0.34171498f, -0.01297594f, -0.03404178f, -0.09559885f, -0.09919550f, 
    0.05174921f, -0.10574205f, -0.02231258f, 0.20800371f, -0.00193065f, -0.02037890f, -0.00063261f, -0.02236309f, 
    0.01808960f, 0.00136899f, 0.02462330f, 0.08793285f, -0.12042910f, -0.10382286f, -0.09883489f, 0.02346538f, 
    0.08830321f, -0.23454127f, -0.24432023f, 0.05278667f, -0.06459989f, -0.08261396f, -0.07589790f, 0.00575919f, 
    -0.03087492f, 0.06745528f, -0.08531976f, 0.19632304f, 0.06320114f, -0.13122882f, 0.15326500f, -0.28340009f, 
    -0.21090990f, -0.05384254f, -0.47618529f, 0.26967958f, 0.01582658f, 0.02785596f, 0.13491282f, -0.09332118f, 
    -0.12175526f, 0.12826230f, 0.05332347f, 0.13622732f, 0.10142345f, 0.04467909f, -0.09289062f, 0.07123446f, 
    0.23762767f, 0.00945402f, 0.22379763f, -0.11245759f, -0.03483193f, 0.08646844f, -0.10468835f, 0.04926737f, 
    0.00707445f, 0.07782741f, -0.09742638f, -0.00826613f, -0.26059106f, -0.10536411f, 0.18069439f, 0.16745925f, 
    -0.08831035f, -0.17449786f, -0.71625966f, -0.29534793f, -0.03653331f, -0.00862401f, -0.07117843f, -0.04687288f, 
    -0.20554282f, 0.32994241f, -0.05945404f, 0.43609563f, 0.37918320f, 0.02315014f, 0.44677967f, -0.18061152f, 
    0.07191456f, 0.40454248f, 0.20424458f, 0.09090884f, -0.16433337f, -0.21527587f, 0.00296332f, 0.02056626f, 
    0.24746968f, -0.38355088f, 0.03060208f, -0.34405559f, 0.03206506f, -0.03673200f, 0.18899257f, 0.13695288f, 
    0.18391286f, -0.03298548f, -0.51534069f, -0.11060989f, 0.08470735f, -0.04955152f, 0.24357440f, 0.02547794f, 
    0.20532379f, -0.11768395f, 0.16471846f, 0.03972180f, 0.18708126f, 0.07236947f, 0.08386356f, 0.07478007f, 
    0.01004930f, 0.00992710f, 0.10216001f, 0.23268694f, -0.22522041f, -0.00529353f, 0.07115144f, 0.12123173f, 
    -0.17121513f, 0.07094125f, 0.13061607f, 0.21424012f, 0.04379512f, -0.10021124f, -0.10139001f, -0.08271001f, 
    0.08285453f, -0.00874200f, -0.06150350f, -0.41436285f, -0.05596429f, 0.25937611f, 0.24855213f, 0.22028096f, 
    0.28604829f, -0.13192084f, 0.02960844f, -0.29684064f, -0.06118147f, -0.08850311f, -0.09888180f, 0.06183930f, 
    0.11196075f, 0.18944196f, -0.20103946f, -0.00589624f, 0.12306831f, 0.13455757f, 0.00345443f, 0.17131741f, 
    -0.05444126f, 0.08909910f, -0.06260559f, -0.59120423f, 0.03559751f, 0.28380698f, -0.05915248f, -0.11549724f, 
    0.12157592f, -0.02787245f, 0.58302772f, 0.12123773f, 0.11739227f, 0.06181288f, -0.05515435f, 0.03077408f, 
    -0.15627207f, -0.15633233f, 0.14357173f, 0.21490966f, 0.13810165f, -0.02637943f, 0.16959849f, -0.08588770f, 
    -0.07626832f, 0.20712292f, -0.19831729f, -0.12256396f, -0.04286519f, -0.11821648f, 0.05629831f, 0.25435022f, 
    0.17728980f, -0.02069788f, 0.35971496f, -0.12397746f, 0.18952988f, 0.07083973f, -0.10607857f, -0.00708251f, 
    0.04273590f, -0.36340603f, 0.12350207f, -0.04939710f, -0.32721716f, -0.11147667f, -0.06941078f, -0.34141928f, 
    0.14957117f, 0.03145003f, 0.09206665f, -0.23623614f, 0.10171528f, -0.10926914f, 0.05806702f, 0.12007145f, 
    0.10611384f, -0.06617897f, 0.05268114f, 0.12072320f, -0.05959209f, -0.05748291f, -0.03969983f, 0.10508935f, 
    0.26553097f, -0.19079080f, 0.10707941f, 0.02527199f, -0.05114143f, -0.27640226f, -0.35979977f, 0.09428862f, 
    0.27677330f, -0.05088450f, 0.25986508f, 0.44931129f, 0.11611821f, -0.03159861f, 0.22379850f, 0.03974137f, 
    0.13241863f, 0.07245863f, -0.26127398f, 0.00765558f, -0.25467935f, 0.17180537f, -0.11066382f, 0.03423713f, 
    -0.17621094f, -0.00052523f, -0.08187987f, 0.22073546f, 0.19638768f, 0.03337036f, 0.26514539f, 0.11238302f, 
    -0.07989924f, -0.12500633f, -0.06644607f, -0.11335105f, 0.03954491f, -0.04841990f, 0.05914021f, 0.29925328f, 
    0.20726945f, -0.47932735f, 0.26073375f, 0.37282437f, -0.17976497f, -0.13569339f, -0.32963261f, 0.22366805f, 
    0.06508022f, -0.01884426f, 0.04001060f, -0.19668657f, -0.03724925f, -0.09524397f, -0.28522828f, -0.33056465f, 
    -0.09772128f, 0.06530873f, 0.05601678f, -0.26965183f, 0.07558081f, 0.03258430f, 0.05315494f, 0.41333458f, 
    0.15452985f, -0.18577996f, -0.09982538f, -0.16962577f, -0.05216138f, -0.38331953f, -0.24034561f, -0.12248150f, 
    0.13783801f, -0.03479847f, 0.23924676f, 0.44333977f, -0.08998874f, 0.09665382f, 0.19616808f, 0.16274485f, 
    -0.16633767f, -0.24070835f, -0.22809143f, 0.23082581f, -0.10663715f, -0.09307419f, -0.33125862f, 0.05198548f, 
    -0.06889097f, -0.10122292f, 0.00677379f, 0.06230787f, -0.25716624f, 0.04792738f, 0.31793797f, -0.03882871f, 
    -0.48917601f, 0.05738106f, 0.00246458f, -0.19125287f, 0.30912605f, 0.13970104f, 0.08699749f, 0.09371440f, 
    0.10807607f, 0.15078233f, -0.52844381f, 0.08346426f, -0.11587743f, 0.12243965f, 0.00676993f, 0.31304014f, 
    0.24807188f, -0.23268418f, -0.07083900f, 0.12954527f, 0.02476310f, 0.06731600f, -0.19984369f, -0.08127005f, 
    -0.07576058f, 0.32349840f, -0.24852973f, -0.04088076f, 0.21393472f, 0.34145051f, -0.07909203f, -0.13453823f, 
    -0.20426060f, 0.30389041f, -0.15548949f, 0.23225434f, 0.01443724f, -0.04821117f, -0.06019149f, 0.18603772f, 
    0.34827143f, 0.05129634f, 0.48093793f, -0.36103937f, 0.03033061f, 0.07464691f, -0.22805211f, 0.21936482f, 
    -0.34447712f, -0.05621841f, -0.14155015f, 0.21717402f, -0.22896971f, -0.00800088f, 0.30738699f, -0.11320483f, 
    -0.14762408f, -0.15172519f, -0.15079446f, -0.04816893f, -0.08550516f, -0.03429775f, 0.02528591f, 0.06494183f, 
    0.09204018f, 0.07080786f, -0.06624258f, 0.18565631f, 0.10783246f, 0.02183432f, -0.06152076f, -0.06215754f, 
    -0.10243750f, 0.05669867f, 0.01659572f, -0.01243289f, -0.05905890f, -0.08662180f, -0.14568748f, 0.08321887f, 
    -0.10498148f, 0.02911101f, -0.03672313f, -0.12709014f, 0.00041762f, 0.06530295f, 0.04154595f, 0.14186005f, 
    -0.00381738f, -0.00421689f, -0.15292470f, -0.07716236f, -0.10301308f, -0.11097424f, 0.06940979f, -0.11855908f, 
    0.13908134f, -0.10705177f, 0.04698125f, -0.05691318f, -0.02519581f, 0.03704155f, -0.04787748f, -0.00081652f, 
    -0.12743074f, -0.09689413f, 0.03224791f, -0.09834254f, -0.03172362f, -0.08584869f, 0.01677848f, -0.08629063f, 
    -0.00329297f, -0.03420888f, 0.09037226f, -0.02105121f, -0.10801144f, 0.06688213f, 0.01117974f, 0.02003544f, 
    -0.16618335f, -0.36241645f, 0.17981231f, 0.27020925f, -0.19670929f, -0.08206884f, 0.15202147f, -0.11029727f, 
    -0.20634222f, 0.04313915f, -0.16810472f, -0.38388953f, -0.11095592f, -0.13834426f, 0.17664152f, 0.28630531f, 
    -0.02438553f, 0.08860892f, -0.42834592f, -0.05217828f, 0.12346899f, 0.01130927f, -0.08598442f, 0.16774082f, 
    0.19733424f, -0.05140951f, -0.05866725f, -0.00246965f, 0.04754794f, -0.02019428f, -0.25697464f, -0.11852297f, 
    0.01281370f, 0.20284878f, -0.27620044f, -0.25860402f, 0.17594327f, 0.09457985f, 0.04881516f, 0.26130307f, 
    0.24083608f, -0.00878747f, -0.03201397f, 0.30923405f, -0.08779043f, -0.24010266f, -0.06644341f, -0.26503885f, 
    0.00181823f, 0.04800389f, -0.28278062f, -0.02702714f, -0.09842941f, -0.05859772f, 0.22842920f, 0.19494802f, 
    -0.58384579f, 0.12022759f, -0.01154105f, 0.20466457f, -0.02613868f, 0.01247466f, -0.00955486f, -0.05988166f, 
    -0.12018044f, 0.01325234f, -0.02952282f, -0.17252721f, 0.14830874f, 0.09012519f, -0.24979395f, 0.24627668f, 
    0.14378548f, 0.09775789f, 0.06475864f, 0.05991668f, 0.09950375f, 0.12707749f, 0.01324998f, -0.17698407f, 
    0.00024405f, -0.09781749f, 0.06823199f, -0.16072117f, -0.08518217f, -0.05343379f, -0.05767561f, -0.13364013f, 
    -0.21311809f, 0.12800813f, -0.02943968f, 0.20191683f, 0.08631402f, -0.04317864f, -0.06113052f, 0.02486180f, 
    0.01289621f, 0.07396396f, 0.13151141f, 0.09826927f, -0.20918372f, 0.15139683f, -0.04462360f, 0.09179460f, 
    -0.05508211f, 0.19218425f, -0.04390683f, 0.04461127f, 0.05959294f, -0.05722721f, 0.06502783f, 0.06867677f, 
    0.11146372f, 0.06040304f, 0.08738361f, 0.07453281f, -0.01018324f, 0.04389869f, 0.06077990f, -0.01167532f, 
    0.18481070f, -0.19979584f, -0.42332020f, 0.16467926f, 0.00743060f, 0.15769534f, -0.05452263f, 0.22336291f, 
    -0.15270509f, -0.13479333f, -0.02213209f, -0.07244007f, 0.02513309f, -0.09398770f, -0.14400390f, 0.18831739f, 
    -0.08786615f, 0.05719692f, -0.04969977f, -0.04741911f, -0.11291739f, 0.09403275f, -0.15131223f, 0.00793548f, 
    -0.03930441f, -0.11468350f, 0.01001197f, -0.10955895f, -0.15420759f, 0.09532774f, -0.13272780f, 0.05926071f, 
    0.02109046f, 0.11716405f, -0.12896527f, -0.05758111f, -0.08176246f, -0.09796596f, -0.04630447f, -0.02513798f, 
    0.05777511f, 0.12856211f, -0.03944999f, 0.04119739f, 0.08079793f, 0.10311446f, 0.05993162f, -0.10557697f, 
    -0.13653807f, 0.02633188f, -0.12240323f, -0.04851770f, -0.06201689f, 0.00892642f, -0.04878907f, 0.02152325f, 
    -0.03096999f, -0.02533227f, -0.06682049f, -0.04832678f, -0.03045344f, 0.05605411f, -0.02306477f, 0.07884890f, 
    0.04993539f, 0.06844611f, -0.01801376f, -0.07031389f, -0.15234447f, -0.07703579f, -0.10985918f, -0.06358034f, 
    0.15604831f, -0.42445886f, 0.25745893f, 0.17058171f, -0.13476267f, 0.00859945f, 0.01916670f, -0.13002980f, 
    -0.21989530f, -0.02191786f, -0.31006336f, -0.26361364f, -0.08878829f, -0.12727164f, 0.22459280f, 0.08585589f, 
    -0.12510745f, -0.04170721f, -0.07411772f, -0.49453318f, 0.12520361f, 0.13275462f, 0.02420831f, 0.18219811f, 
    -0.09173375f, 0.03433587f, -0.10440333f, 0.46130651f, 0.14932247f, -0.08514822f, 0.21615739f, -0.01456087f, 
    0.11730877f, 0.13426822f, -0.19647764f, -0.23327078f, -0.07628867f, -0.18211709f, -0.02708497f, 0.20659328f, 
    0.23846796f, -0.19577728f, -0.02998107f, -0.05153502f, 0.10576487f, 0.05831953f, 0.15716793f, -0.09022760f, 
    0.06957340f, -0.06571054f, -0.36679313f, -0.03280138f, 0.06991382f, 0.03871796f, 0.09103435f, 0.25353044f, 
    -0.05406986f, -0.04357975f, 0.11620694f, 0.32262859f, 0.23493113f, -0.12442903f, 0.12283063f, -0.15855451f, 
    0.21101220f, 0.13458322f, 0.09099638f, -0.03592116f, -0.08217029f, 0.02886504f, 0.08446655f, -0.06955916f, 
    0.10693252f, -0.11988059f, 0.02551396f, -0.15130757f, -0.05637587f, 0.00938135f, 0.14820705f, 0.30084848f, 
    -0.08293336f, 0.00109648f, -0.04285156f, 0.01711640f, -0.14446676f, 0.04960863f, -0.03342764f, -0.24289675f, 
    0.10920099f, -0.12896194f, 0.20562927f, -0.25697815f, -0.13269636f, -0.12928927f, 0.03915255f, 0.06817531f, 
    0.05372173f, -0.14800063f, 0.27905717f, 0.16631365f, -0.23008636f, 0.01484231f, -0.07709329f, -0.10670187f, 
    0.17299311f, 0.00165312f, 0.29453611f, 0.09098575f, 0.07297520f, -0.27249113f, -0.12495923f, 0.12815669f, 
    0.03673905f, -0.04859506f, -0.18449473f, 0.03495690f, -0.10890889f, 0.12395541f, 0.21931671f, 0.00498710f, 
    0.15374763f, 0.11607288f, -0.11046079f, -0.12902404f, 0.20638539f, 0.01806918f, 0.17399861f, -0.06685054f, 
    0.06102015f, 0.16499129f, 0.14259817f, 0.08995417f, -0.08901528f, 0.04243469f, 0.05824967f, 0.26903552f, 
    -0.07251451f, -0.00999544f, 0.02860570f, -0.17012267f, -0.00229023f, 0.08200724f, 0.22485977f, 0.17908747f, 
    0.00556061f, -0.01701199f, -0.11463189f, -0.18883076f, -0.06352586f, -0.08798023f, 0.04377039f, 0.16737983f, 
    -0.16033626f, 0.02609165f, 0.01503285f, 0.28439647f, 0.16636163f, -0.05338002f, -0.02907415f, -0.01854653f, 
    -0.10187549f, -0.31051147f, 0.27891344f, -0.08332062f, -0.25476682f, -0.03545079f, -0.05361753f, -0.14316861f, 
    0.36748347f, -0.05852785f, -0.11032052f, -0.51697981f, 0.01360972f, 0.00823321f, 0.03891168f, -0.14037324f, 
    -0.06431498f, -0.07032616f, -0.25734925f, 0.14312786f, -0.08407883f, 0.03339567f, 0.35012138f, -0.02609064f, 
    -0.03783676f, 0.07452372f, 0.18798828f, 0.10539132f, 0.12792136f, 0.30425841f, -0.25384003f, 0.22279194f, 
    -0.12599453f, 0.09742524f, -0.04887483f, 0.23012075f, 0.31266201f, -0.10072242f, -0.06078310f, 0.05766934f, 
    -0.02541914f, 0.03777907f, 0.02835886f, 0.33272624f, 0.07441308f, 0.05765170f, -0.18383774f, -0.04160073f, 
    0.13575681f, -0.14284767f, 0.46787170f, 0.29210082f, -0.21387024f, -0.12673789f, -0.45977390f, 0.24156566f, 
    0.02420978f, -0.16410790f, 0.09990918f, -0.15789242f, -0.40233412f, 0.05363845f, -0.22672185f, -0.23012321f, 
    0.03244437f, -0.20599125f, 0.02509116f, -0.09369317f, 0.01621244f, -0.06379284f, -0.19214830f, 0.42285454f, 
    -0.08151297f, -0.04399544f, -0.10938907f, 0.14311305f, 0.07534343f, -0.40377015f, -0.39968657f, -0.12839925f, 
    -0.33331603f, -0.04988537f, 0.02750062f, 0.24616779f, -0.05488124f, -0.02044191f, 0.24376738f, -0.04459725f, 
    -0.20225784f, 0.02475987f, -0.14150976f, 0.22777583f, 0.10232029f, 0.13409507f, -0.47090459f, -0.00476002f, 
    0.02594173f, -0.03484578f, -0.14050856f, -0.14307800f, -0.03519944f, 0.10789439f, -0.01460240f, -0.11211789f, 
    -0.09921697f, 0.09531826f, 0.07677902f, 0.01105768f, -0.12893474f, 0.10725380f, 0.05067681f, 0.04797189f, 
    0.06631666f, -0.01767957f, -0.04551003f, 0.06547038f, 0.03954517f, -0.01965492f, -0.11426177f, 0.06054706f, 
    -0.10966177f, 0.02741095f, -0.17112531f, -0.00002132f, 0.10175990f, 0.12234123f, -0.12138759f, -0.07415613f, 
    0.02622502f, 0.03726368f, 0.01230672f, -0.12091453f, -0.11816806f, 0.02000466f, -0.01264058f, -0.08861954f, 
    0.05925415f, 0.07821865f, -0.08869712f, -0.04842604f, 0.00205536f, -0.01456623f, -0.12668039f, 0.02615417f, 
    0.05203528f, 0.00084917f, -0.01150360f, 0.00372690f, 0.12023696f, 0.05796660f, -0.06903534f, 0.00387459f, 
    -0.00059283f, 0.07477385f, -0.01914945f, -0.12078524f, -0.14368686f, -0.10001892f, 0.05699707f, -0.13577910f, 
    0.05536173f, -0.00155455f, -0.17650181f, -0.04331583f, -0.21793012f, -0.02846634f, 0.48820350f, 0.13860084f, 
    0.01326716f, 0.14846666f, 0.03586594f, -0.24666233f, 0.00194890f, 0.00505045f, 0.26696122f, 0.40867311f, 
    -0.07700777f, 0.05147347f, -0.02623116f, 0.12127750f, -0.10253596f, -0.09937233f, -0.01769852f, -0.29161716f, 
    0.37052932f, -0.10378482f, 0.20835955f, -0.35610726f, 0.15058608f, -0.02967711f, -0.11507071f, -0.01498065f, 
    0.04325200f, 0.02521574f, 0.25677556f, -0.05071415f, 0.27775431f, 0.02792670f, -0.06813741f, 0.03808389f, 
    0.25830483f, -0.01015487f, 0.30183280f, 0.30800879f, -0.03410340f, -0.25466597f, -0.20267487f, -0.08851785f, 
    0.01979988f, -0.05556853f, 0.17952257f, 0.02340967f, 0.06171888f, 0.00128992f, 0.02957086f, 0.11004183f, 
    -0.06830101f, -0.00414130f, -0.10728632f, -0.06474399f, -0.06007380f, -0.04546959f, 0.17358872f, 0.19836822f, 
    0.08641617f, -0.13508649f, 0.11152444f, 0.02744237f, 0.01478853f, -0.03346561f, 0.10473210f, 0.02928382f, 
    -0.04637633f, -0.06242998f, -0.03548013f, -0.25276461f, 0.06641559f, 0.08572002f, 0.18236141f, 0.10478839f, 
    0.02038429f, -0.43213284f, -0.24615364f, -0.00109064f, 0.09206013f, 0.01075538f, -0.00502358f, -0.10960265f, 
    0.12076669f, 0.11173277f, 0.03774433f, 0.13977456f, 0.03964914f, -0.11246387f, 0.05964699f, -0.14878522f, 
    -0.00620658f, 0.10103237f, -0.03561090f, 0.10803198f, 0.34366053f, 0.13252479f, 0.12154567f, 0.10702738f, 
    -0.00636226f, -0.30102864f, 0.02413984f, 0.24609423f, 0.05516819f, -0.20161530f, -0.13485765f, 0.22829871f, 
    0.18018052f, 0.02648909f, -0.10881627f, -0.00070869f, 0.11322305f, 0.06979946f, -0.04882275f, 0.31393793f, 
    -0.02280676f, -0.07798956f, -0.32494763f, 0.30225933f, -0.10622662f, 0.04789119f, 0.26653886f, -0.07199430f, 
    0.03683777f, 0.07396587f, 0.12724224f, -0.00079719f, -0.08787058f, -0.02938598f, -0.25781003f, 0.07719076f, 
    0.09432499f, -0.04281735f, 0.11549578f, -0.05865854f, -0.18488815f, -0.16473131f, 0.11410584f, -0.26786816f, 
    -0.10793629f, -0.21523467f, -0.02719786f, -0.31870297f, -0.07742584f, 0.22476812f, 0.36548662f, -0.05060386f, 
    -0.12211496f, 0.21168230f, -0.03573577f, -0.06633368f, 0.17259498f, 0.02040097f, 0.35455200f, 0.12861075f, 
    -0.02445602f, 0.58400691f, -0.08426378f, 0.25030401f, 0.04572254f, 0.23058626f, -0.09799521f, -0.10507081f, 
    0.11445175f, -0.05079759f, -0.05875883f, -0.20693512f, -0.07220778f, 0.17796241f, 0.05148613f, 0.34442571f, 
    0.39168069f, -0.10301036f, 0.27428943f, -0.11170094f, -0.01893742f, 0.11078586f, 0.03277322f, 0.14789909f, 
    0.37035057f, -0.14703870f, 0.09342571f, 0.31672165f, 0.15385680f, 0.06929734f, 0.05317521f, -0.02338919f, 
    0.19405299f, -0.23405842f, 0.13949953f, 0.21763118f, 0.11717204f, 0.08131012f, -0.08898979f, -0.07725526f, 
    -0.33986551f, -0.12616986f, 0.00190948f, 0.18804643f, 0.05569141f, -0.12885621f, 0.09175206f, -0.06026261f, 
    -0.12792966f, -0.05356759f, 0.08089808f, -0.23193373f, 0.12373188f, -0.15877800f, -0.20436418f, 0.06021519f, 
    -0.21973479f, 0.06486021f, -0.14569618f, 0.07684358f, 0.26186812f, -0.06823352f, 0.50689369f, 0.13033229f, 
    -0.05477788f, 0.43049979f, -0.02241495f, 0.01128382f, -0.13192591f, -0.12618251f, 0.05638566f, 0.04403888f, 
    0.03449029f, -0.11422089f, -0.31435135f, -0.05957550f, -0.01378195f, 0.05612893f, 0.05799718f, 0.32543987f, 
    0.11852225f, 0.15648733f, -0.08336210f, -0.29410043f, -0.07332848f, -0.03289204f, -0.14876939f, -0.15374060f, 
    0.12158543f, 0.02203142f, 0.22897764f, 0.02991864f, -0.02358980f, -0.10351541f, 0.02673335f, -0.13107635f, 
    -0.08200902f, -0.08293822f, -0.34000793f, -0.08445313f, 0.17703477f, 0.00842502f, -0.12079936f, 0.10099236f, 
    0.08825385f, 0.03997785f, -0.00542390f, 0.06817388f, 0.11247871f, -0.09508950f, -0.08085277f, -0.41656080f, 
    -0.12101804f, -0.18656920f, 0.10431395f, 0.15005140f, -0.04457190f, -0.38315690f, -0.43262154f, -0.04586326f, 
    -0.43062845f, -0.15074986f, -0.10169233f, 0.08820337f, -0.16845275f, -0.08570184f, -0.26767078f, 0.07755250f, 
    -0.02468110f, -0.16178750f, -0.07150690f, 0.07360763f, -0.44382313f, -0.05604168f, -0.05792277f, 0.04354155f, 
    -0.00258788f, 0.24233760f, -0.12608473f, 0.11920869f, -0.06418502f, 0.25974214f, 0.24485928f, -0.11462521f, 
    -0.04507326f, 0.05629277f, -0.17595938f, 0.10385606f, 0.07033631f, -0.06599925f, 0.14526333f, -0.19400281f, 
    -0.08205663f, 0.02145542f, 0.54917479f, -0.03017779f, -0.32603806f, 0.20926556f, -0.40771949f, 0.20431171f, 
    0.05924230f, -0.01000513f, 0.07873005f, 0.01084013f, -0.17897521f, 0.00869094f, 0.42104688f, 0.01249391f, 
    -0.03771114f, -0.14727479f, 0.16814297f, -0.15865570f, -0.01893758f, -0.01779035f, 0.34860611f, 0.46158671f, 
    0.02783025f, -0.14457962f, -0.13969326f, -0.00899744f, -0.30166256f, 0.09808090f, -0.06217212f, -0.07646161f, 
    0.30340162f, 0.05152310f, 0.09891969f, 0.00468713f, 0.13887422f, 0.10777479f, 0.24962275f, -0.24771124f, 
    0.03826194f, 0.13541794f, 0.32208106f, -0.04150586f, 0.15575811f, 0.07115923f, 0.00503122f, -0.08798660f, 
    -0.04181064f, -0.15116918f, 0.12797320f, 0.02838043f, 0.09302162f, -0.25394055f, -0.15654545f, 0.29965043f, 
    0.49721614f, 0.01420372f, 0.44296122f, 0.02468660f, -0.04126199f, -0.01024058f, -0.03524606f, 0.29217085f, 
    0.28401726f, -0.10906728f, -0.27438694f, 0.03131004f, -0.04485851f, 0.01880855f, 0.19235128f, 0.00650157f, 
    0.20666668f, -0.13165830f, 0.01819921f, 0.08956883f, 0.23633642f, 0.04641546f, -0.19659345f, 0.31772149f, 
    0.07612260f, 0.06030370f, -0.12181416f, 0.10567718f, -0.23295408f, -0.28442711f, -0.05000456f, -0.11456811f, 
    0.06298900f, -0.44086292f, 0.30636945f, -0.17257977f, -0.05828506f, 0.07886290f, -0.00405944f, 0.07201228f, 
    -0.29788616f, -0.07455458f, 0.09198119f, -0.36455879f, -0.04280715f, 0.05477750f, -0.16364759f, -0.29434058f, 
    -0.10069457f, 0.06718597f, 0.00469733f, -0.19760703f, -0.14192007f, 0.15637463f, 0.10691839f, 0.14146523f, 
    0.08609742f, -0.16859950f, -0.16044024f, -0.61266547f, -0.12236026f, 0.37375134f, -0.28080964f, -0.05764831f, 
    0.14123702f, -0.02960722f, 0.19940314f, 0.40650213f, 0.05572484f, -0.09435226f, 0.24090739f, -0.05535229f, 
    -0.06869512f, -0.25916827f, 0.00835355f, 0.26035038f, 0.38990965f, -0.04616117f, -0.14885962f, -0.04008210f, 
    0.08534367f, 0.04064975f, 0.01646772f, 0.01631053f, 0.05817860f, -0.07297161f, -0.28988245f, -0.10788628f, 
    0.10494716f, 0.07887365f, -0.13172469f, 0.11640558f, 0.12099658f, 0.14984857f, -0.19661301f, -0.40250543f, 
    0.07254616f, 0.19474550f, -0.44033369f, -0.20159693f, -0.08693288f, 0.06659548f, 0.19072352f, 0.09058759f, 
    -0.25347048f, -0.02150711f, 0.03525360f, 0.39888355f, -0.06290516f, 0.10879639f, -0.23960993f, -0.08097507f, 
    -0.03953277f, -0.15640569f, 0.10862555f, 0.07966958f, -0.28326172f, -0.29340899f, 0.06316952f, -0.16938555f, 
    0.10408383f, 0.05075157f, -0.06229465f, -0.04262748f, 0.07502025f, 0.24580918f, 0.24769546f, -0.00147373f, 
    -0.05097970f, -0.00568704f, -0.42903337f, 0.00207027f, -0.02973759f, -0.14123133f, -0.07223789f, -0.26009846f, 
    0.00678450f, -0.24605714f, 0.15425080f, -0.16757216f, 0.16427134f, 0.11082660f, 0.09381416f, 0.07849701f, 
    -0.04748024f, 0.05501555f, -0.04742738f, -0.00740035f, -0.04801389f, -0.00029154f, -0.13428195f, 0.07604776f, 
    0.09546235f, 0.09507748f, 0.07533091f, 0.02290686f, -0.11141960f, 0.18368296f, 0.06098584f, -0.27468684f, 
    -0.00352482f, 0.05579136f, 0.03667206f, -0.09750009f, 0.13977440f, 0.02108519f, 0.25007328f, -0.05987520f, 
    -0.23789594f, 0.16782865f, 0.09677153f, 0.12208887f, -0.02188716f, 0.00309615f, -0.14649613f, 0.04172822f, 
    -0.03615445f, 0.66780990f, 0.12193944f, 0.29929066f, -0.14460963f, 0.00544035f, 0.01771257f, -0.03473876f, 
    -0.07063557f, 0.00965667f, 0.28291714f, 0.14303765f, -0.06669422f, 0.27951732f, 0.16777606f, 0.21418382f, 
    0.13669917f, 0.08070766f, -0.19240981f, -0.09573366f, -0.00757754f, -0.11382218f, -0.22942400f, 0.14348347f, 
    0.25708312f, 0.08682648f, -0.11553998f, 0.01260058f, 0.11965819f, 0.12397506f, 0.15598013f, 0.19703351f, 
    0.05733478f, -0.12087573f, -0.02750930f, -0.04253062f, 0.04035731f, -0.00700413f, 0.01526608f, 0.01546763f, 
    -0.06205412f, 0.07656190f, 0.04087804f, 0.09294748f, -0.00780833f, 0.00128151f, -0.10000837f, 0.05131969f, 
    0.02776046f, -0.07485549f, 0.09669302f, 0.11251351f, -0.14600147f, -0.03458463f, -0.00657825f, -0.13529691f, 
    -0.00864222f, -0.09832422f, 0.08171944f, 0.01749188f, -0.12388244f, 0.03536274f, -0.11773014f, -0.04951770f, 
    -0.01207089f, -0.12709233f, -0.08489318f, -0.05778922f, -0.06896280f, -0.07495458f, -0.07588951f, -0.09629250f, 
    -0.06988613f, 0.04743882f, 0.00527852f, 0.03262070f, 0.11538149f, 0.08189979f, -0.12626435f, -0.08164192f, 
    0.03777042f, 0.05183664f, -0.12386122f, 0.00641231f, 0.08342327f, 0.02391729f, -0.02739714f, -0.00787079f, 
    -0.03208582f, -0.01570769f, -0.07574860f, -0.10762523f, 0.07952406f, -0.14745532f, 0.00514208f, -0.09294232f, 
    0.33171228f, 0.10606506f, 0.19998735f, -0.00147202f, -0.13419887f, 0.14382666f, 0.10900934f, -0.08941239f, 
    0.04300074f, -0.05400344f, 0.16810344f, -0.12736340f, -0.35148534f, -0.13065477f, 0.15328151f, 0.13961543f, 
    0.02110086f, 0.15129161f, 0.01955062f, -0.35553578f, -0.15688577f, 0.12660685f, 0.13153437f, -0.08980981f, 
    0.04665251f, -0.10135224f, 0.19649588f, -0.01595471f, -0.03559429f, -0.07105919f, 0.13296682f, -0.21576747f, 
    0.11566063f, 0.44103518f, 0.22774801f, 0.03152923f, -0.17019613f, 0.04218195f, -0.09999889f, -0.08580422f, 
    -0.02122066f, 0.03516692f, 0.12089288f, -0.12039932f, -0.04771197f, 0.32846579f, 0.07277750f, 0.19929521f, 
    0.12849244f, 0.09640748f, 0.01001389f, 0.08209805f, -0.05754277f, -0.03215497f, 0.24354042f, -0.20513487f, 
    0.14044736f, -0.35935873f, -0.03761036f, 0.26070026f, 0.33554003f, -0.12138069f, -0.00923979f, -0.01975237f, 
    -0.23107618f, 0.25352755f, -0.10589538f, 0.00250438f, 0.30801910f, 0.09764418f, -0.12249989f, 0.30272171f, 
    -0.04094292f, -0.04883052f, -0.00223663f, 0.00432596f, 0.12577485f, 0.14523351f, -0.06749793f, 0.05709625f, 
    0.17611066f, -0.09226183f, 0.13041419f, 0.15233833f, 0.10265269f, -0.06251459f, -0.16020864f, -0.11116131f, 
    -0.00486684f, 0.00611021f, 0.16924252f, 0.11606821f, -0.18289690f, -0.11765813f, -0.30942905f, -0.08916460f, 
    -0.01747668f, -0.16475469f, -0.03298746f, -0.15025815f, 0.01667584f, -0.01954577f, 0.03024393f, 0.16466148f, 
    0.19477542f, 0.04541428f, 0.08019745f, 0.23536389f, -0.02740897f, -0.13124727f, -0.06047930f, -0.21337439f, 
    -0.21216714f, -0.02241389f, -0.04236153f, 0.20673671f, -0.09483147f, 0.05119596f, 0.18757941f, 0.00704678f, 
    -0.24960619f, 0.12768473f, -0.16332521f, 0.10408951f, -0.04116243f, 0.30653045f, -0.02989591f, 0.17487551f, 
    -0.05682486f, -0.12861547f, -0.08424160f, -0.04141754f, 0.03282629f, -0.04135916f, 0.03890021f, 0.06281919f, 
    0.02986779f, -0.09507670f, 0.01427741f, -0.07231158f, 0.08186172f, -0.09075282f, 0.08718804f, -0.02177669f, 
    -0.09025879f, -0.08351208f, 0.01462346f, -0.10078035f, -0.12515715f, 0.03161940f, -0.11318377f, -0.07801053f, 
    0.02500148f, 0.10152461f, -0.01375126f, -0.01310634f, -0.10763384f, 0.02349451f, 0.00506783f, -0.11518576f, 
    0.10662705f, 0.05043092f, 0.06193313f, 0.05935473f, 0.09395174f, -0.10274018f, 0.08211696f, -0.07520794f, 
    -0.02688698f, -0.12756664f, 0.05282743f, 0.00377865f, 0.01313764f, -0.01563785f, -0.06051329f, -0.12795416f, 
    -0.01030060f, -0.03172071f, -0.00580068f, 0.02414685f, -0.08863094f, -0.08481897f, -0.10297617f, -0.13727002f, 
    -0.03558216f, 0.07835511f, -0.10940837f, 0.04665907f, -0.03773431f, 0.02198398f, -0.12558366f, -0.04698187f, 
    0.18996540f, -0.07681489f, 0.15014850f, -0.23045598f, -0.21724597f, -0.06274014f, 0.12126470f, 0.06534207f, 
    0.22667125f, 0.03168685f, 0.13385069f, -0.07445003f, -0.12069371f, -0.08675695f, 0.00859375f, -0.07159307f, 
    -0.00772624f, -0.33822021f, -0.02288562f, -0.06026118f, -0.27869251f, 0.13020523f, 0.20363563f, -0.25536120f, 
    0.00587142f, -0.11312677f, -0.01737035f, -0.20213999f, -0.10155140f, 0.15155792f, -0.07342809f, -0.18200395f, 
    0.11396377f, -0.07168192f, 0.27136189f, 0.23979411f, -0.00913642f, 0.06911514f, 0.06197004f, 0.04005003f, 
    -0.06648936f, -0.11302250f, 0.12732460f, -0.07472237f, -0.00949205f, 0.11523975f, -0.35415107f, 0.38389730f, 
    0.14899628f, 0.08806574f, 0.18579756f, 0.06854494f, 0.03863229f, -0.08423619f, 0.08531254f, -0.06949829f, 
    0.41100651f, -0.10791882f, -0.10378234f, -0.02748120f, 0.23927574f, -0.15075405f, 0.07850235f, 0.08357701f, 
    -0.02192982f, -0.09106313f, 0.07402031f, 0.09778951f, 0.34077394f, 0.12370422f, -0.02703688f, -0.05978170f, 
    -0.10505696f, -0.03995918f, -0.21486267f, 0.24507752f, 0.14696316f, 0.08503185f, -0.17145607f, 0.10497539f, 
    0.01176318f, -0.00065435f, 0.22595118f, 0.16629839f, 0.14723980f, 0.07817546f, 0.06212708f, 0.11948128f, 
    0.28866449f, 0.02501935f, 0.13322479f, 0.02989340f, -0.25786018f, -0.06682347f, -0.06355084f, -0.05300402f, 
    0.00909880f, -0.21340139f, -0.08842060f, -0.03150472f, 0.02030809f, -0.03376554f, -0.08945350f, 0.30046985f, 
    0.10891583f, 0.13796526f, 0.00879500f, 0.04392176f, 0.08034923f, 0.17343868f, -0.07986300f, -0.33951902f, 
    -0.29974869f, -0.02672659f, 0.00786357f, 0.08622012f, 0.08627008f, 0.10184010f, -0.06059399f, -0.03263394f, 
    -0.36743534f, -0.14595534f, -0.06826078f, 0.08383883f, 0.17762303f, -0.00898347f, -0.03167441f, 0.15205266f, 
    0.01605649f, 0.17398374f, 0.24005701f, 0.06749357f, 0.01461568f, -0.06062713f, -0.13582730f, 0.04804528f, 
    0.06233102f, 0.10668091f, 0.17688183f, 0.14351676f, 0.04404944f, -0.05243515f, -0.05603351f, -0.05377528f, 
    0.05873923f, 0.03603648f, 0.00922866f, -0.09679684f, 0.04248607f, 0.20211467f, 0.08134817f, 0.06182767f, 
    0.01218334f, 0.13695531f, 0.13213667f, -0.00873053f, -0.05090071f, 0.13972062f, -0.05299658f, -0.11183681f, 
    -0.11804991f, 0.14649679f, 0.29032707f, -0.07469243f, 0.01477967f, -0.05989699f, -0.07276308f, -0.14111178f, 
    0.07544324f, -0.11906043f, 0.08286681f, -0.45896184f, 0.05531462f, 0.18850316f, 0.03871286f, -0.14798197f, 
    -0.12474138f, 0.15182143f, -0.05325964f, 0.14457613f, -0.01340656f, 0.05233953f, 0.22247247f, 0.10990369f, 
    0.10281647f, -0.03171648f, 0.12360222f, -0.04356233f, 0.23700011f, 0.05286369f, -0.15872617f, 0.08014425f, 
    -0.18820809f, -0.07119214f, 0.21892503f, 0.21294832f, -0.11861068f, 0.02322060f, 0.17365670f, 0.24921472f, 
    -0.05332211f, 0.15799181f, -0.04589598f, -0.15372832f, -0.09517767f, -0.09379682f, 0.13959743f, 0.20410925f, 
    0.08389805f, 0.05405537f, 0.01485125f, -0.02431418f, -0.03805206f, 0.00365745f, 0.08454999f, 0.19812670f, 
    -0.07288855f, 0.10702832f, 0.01635350f, -0.15649779f, 0.09848274f, 0.08705876f, 0.08092857f, -0.22589535f, 
    -0.09545421f, 0.19530453f, -0.06920659f, -0.44063666f, 0.05842240f, 0.11858001f, 0.07913116f, 0.14908504f, 
    0.17559910f, -0.11167516f, -0.23536447f, -0.10776158f, -0.06106655f, -0.22722287f, -0.01689054f, -0.35741115f, 
    0.08977804f, -0.11073713f, -0.22770172f, -0.09038971f, -0.00488776f, -0.08561363f, 0.28800693f, 0.07145129f, 
    -0.46885329f, -0.07397503f, -0.12149509f, 0.15363452f, 0.09445335f, 0.12512314f, -0.22075190f, 0.09144831f, 
    -0.04814245f, 0.18003374f, 0.13902558f, -0.05421204f, -0.11162604f, 0.14302151f, 0.01674544f, -0.13085259f, 
    0.12837477f, 0.13343664f, 0.00186031f, -0.01269682f, -0.03984175f, 0.17093080f, 0.09656719f, 0.13716215f, 
    0.04820409f, 0.00121142f, -0.00426220f, 0.29537457f, 0.08401268f, -0.12268172f, 0.09643618f, -0.17278901f, 
    0.07123050f, 0.15285259f, -0.01515344f, 0.30446592f, 0.14359494f, 0.00355905f, 0.14862019f, 0.02132557f, 
    0.01842408f, 0.27527043f, 0.00207527f, 0.30024558f, 0.02446005f, 0.09530207f, 0.09319029f, 0.05175933f, 
    0.00150829f, -0.04611041f, 0.29266053f, 0.54408193f, -0.06128124f, -0.22576177f, 0.06727637f, 0.23636706f, 
    0.12497045f, -0.11268184f, -0.34128490f, -0.27402908f, -0.09216669f, -0.11735662f, -0.21865019f, 0.18330602f, 
    0.05281300f, 0.15440318f, -0.36482367f, 0.04861782f, 0.09480879f, 0.10215428f, 0.50070232f, -0.02328777f, 
    -0.03528455f, -0.00918690f, 0.16177021f, 0.08939417f, 0.25678787f, 0.03882629f, -0.31745884f, 0.07284234f, 
    0.01937514f, 0.07063282f, 0.02181495f, 0.15733734f, -0.01811017f, 0.26258633f, -0.06403124f, -0.12431733f, 
    -0.01268971f, -0.17295256f, 0.03740438f, 0.05211489f, 0.23507737f, -0.06622759f, 0.06581838f, 0.18654734f, 
    0.06604532f, -0.13864657f, 0.13788174f, 0.32487148f, -0.01193876f, 0.00583330f, -0.25222155f, 0.10458414f, 
    -0.00775556f, -0.13053395f, -0.16531006f, 0.22271387f, -0.13855411f, 0.00237654f, 0.00888266f, 0.23656300f, 
    0.07650574f, -0.06371472f, 0.11284839f, 0.44165006f, -0.07644808f, 0.14948615f, -0.02242151f, -0.16274032f, 
    -0.09547397f, -0.05665519f, -0.49647075f, -0.12161624f, 0.05731037f, -0.03073541f, 0.03001651f, 0.13773918f, 
    0.00472799f, 0.07255323f, -0.00991464f, 0.10305051f, 0.16785668f, 0.19664295f, 0.07578782f, 0.09482831f, 
    -0.12976247f, -0.08966773f, -0.00856964f, 0.04392888f, 0.01289475f, 0.06657983f, -0.14221621f, 0.15268379f, 
    0.05531491f, 0.07619492f, 0.25521395f, 0.15348077f, 0.10317645f, -0.02905735f, -0.03618030f, -0.04674792f, 
    -0.08385480f, 0.09996659f, 0.20302483f, 0.11931375f, 0.05374645f, -0.13749255f, -0.00485159f, -0.19759870f, 
    -0.02681251f, 0.05782292f, 0.04359888f, -0.08761181f, 0.09274776f, -0.12790221f, 0.12951063f, 0.15092678f, 
    0.02845279f, -0.26492643f, 0.08507054f, 0.00388587f, 0.04515715f, 0.16016583f, -0.01887072f, -0.05059029f, 
    0.09201655f, 0.01152405f, 0.00795510f, 0.28511089f, 0.08004767f, -0.03059090f, -0.07446497f, 0.21496977f, 
    0.12084740f, 0.07785156f, 0.21781109f, 0.25953788f, -0.00522606f, 0.02865364f, 0.11872901f, 0.15252613f, 
    -0.03600961f, 0.25235069f, 0.12518792f, 0.02017122f, 0.03548796f, 0.45055452f, -0.10237450f, 0.19256875f, 
    -0.13541755f, 0.00267277f, -0.07652122f, -0.05161735f, -0.05462808f, -0.07651795f, 0.21893923f, 0.21606804f, 
    -0.00341904f, -0.11598464f, 0.07195737f, -0.28706878f, -0.04939834f, 0.01956676f, 0.17494363f, 0.39666414f, 
    -0.12954354f, 0.02492115f, 0.23526967f, -0.10632413f, -0.28961161f, 0.03163104f, -0.06550835f, -0.09235968f, 
    0.20096588f, -0.07688741f, 0.06312148f, -0.29307434f, 0.11129855f, -0.02177998f, 0.02248177f, 0.25708565f, 
    -0.10075787f, -0.14372383f, 0.13422720f, -0.15227532f, 0.27413458f, 0.28192234f, 0.06344640f, -0.10209575f, 
    0.12988335f, 0.05042107f, 0.10108611f, -0.06647226f, -0.03766027f, -0.23821941f, -0.43986478f, 0.17138371f, 
    0.25264832f, -0.07706152f, 0.54556501f, 0.13820168f, 0.01430778f, 0.01058147f, 0.04346588f, 0.26811591f, 
    0.05877670f, 0.14077924f, -0.45760837f, 0.04401634f, -0.30631408f, 0.16553764f, 0.03215030f, 0.11696635f, 
    -0.13888961f, 0.29917747f, -0.29301712f, -0.19407223f, 0.23963518f, -0.02408720f, -0.38839969f, 0.23050900f, 
    0.25814170f, 0.04063814f, 0.16853552f, 0.02851923f, 0.33375257f, 0.29178312f, -0.04364673f, -0.30411050f, 
    -0.11347182f, -0.20676903f, 0.02950571f, 0.04579623f, 0.04122565f, -0.06994662f, -0.01797914f, -0.22309771f, 
    -0.13439280f, -0.01159676f, 0.10382414f, 0.47789094f, -0.10901241f, -0.07979023f, -0.11634554f, -0.44420406f, 
    -0.02526221f, 0.06948946f, -0.05898806f, 0.24092649f, -0.29049706f, -0.07012074f, 0.08997379f, 0.20230962f, 
    0.23923728f, 0.05002275f, 0.12369006f, 0.32778966f, 0.15333079f, 0.16316649f, 0.22720566f, 0.12887357f, 
    -0.11126985f, -0.09788874f, -0.23535407f, 0.00843961f, 0.11485589f, 0.03515667f, 0.11270794f, 0.06484688f, 
    -0.00728398f, -0.17905897f, -0.24988864f, -0.05765754f, -0.03716659f, 0.16915417f, -0.04324771f, 0.27742085f, 
    -0.10778771f, -0.05398794f, -0.13849880f, 0.17434774f, -0.11194639f, 0.11489259f, -0.07417662f, 0.03621762f, 
    -0.05348342f, 0.10954386f, 0.05943083f, 0.25024030f, -0.04488071f, 0.10132854f, -0.09541544f, -0.01055305f, 
    0.00713453f, 0.17930673f, 0.10893057f, -0.28713870f, -0.10057578f, 0.12762831f, 0.17470586f, 0.10142545f, 
    0.05493673f, -0.08962236f, -0.00833311f, -0.14790112f, -0.12694137f, -0.09985487f, -0.09440362f, 0.09463568f, 
    0.01131871f, 0.25475159f, 0.06366343f, 0.07741003f, 0.14117949f, 0.07396270f, -0.05463236f, 0.06023533f, 
    -0.20784344f, 0.30325246f, -0.03997752f, -0.10415230f, -0.00755440f, 0.09685505f, 0.05069155f, 0.03402487f, 
    0.10782616f, -0.08603682f, 0.48670384f, -0.12401235f, 0.11241035f, 0.05076376f, -0.13326128f, 0.00566199f, 
    -0.03149581f, -0.07202706f, -0.12593025f, 0.13074689f, -0.05049314f, 0.01493584f, 0.17896563f, -0.02100851f, 
    0.13390446f, 0.12733459f, 0.10816150f, -0.14109589f, -0.15072238f, 0.02937276f, 0.17530668f, -0.11359302f, 
    0.14313607f, 0.03439554f, 0.18853216f, -0.06044792f, -0.05729099f, 0.27508324f, 0.26347208f, -0.12990837f, 
    0.00659069f, 0.06988680f, -0.15847652f, 0.01742489f, -0.03488963f, 0.02750414f, 0.30553633f, -0.11200477f, 
    0.08991665f, -0.03236834f, 0.07145569f, 0.06156137f, 0.11569237f, 0.03379996f, -0.10514240f, 0.07248995f, 
    0.01211745f, 0.10497007f, 0.11111131f, 0.21841915f, 0.21583085f, -0.01652782f, -0.10733467f, -0.20431718f, 
    -0.05565684f, -0.15963627f, 0.20851003f, 0.28371033f, -0.07979066f, 0.13687198f, 0.01735318f, 0.33269668f, 
    0.19120285f, -0.02536273f, 0.26538041f, -0.34012032f, -0.11063801f, 0.11536728f, -0.14182979f, 0.22290000f, 
    0.36483350f, -0.01451794f, -0.04136470f, 0.01914364f, -0.02637616f, -0.08115723f, 0.46669307f, -0.16676070f, 
    0.09059151f, -0.05104284f, -0.01181170f, -0.01167317f, -0.04236205f, 0.05891659f, 0.13581342f, 0.03518206f, 
    0.03806217f, 0.12940964f, -0.02704692f, 0.09480947f, -0.17073442f, 0.01970606f, 0.26704213f, 0.15773423f, 
    0.03183679f, 0.18706597f, -0.04805414f, 0.31136876f, -0.11329036f, -0.12711371f, -0.04601125f, 0.12710623f, 
    0.06523764f, -0.15947348f, 0.16674392f, -0.41729352f, -0.19511813f, -0.00572059f, -0.03620611f, -0.10054497f, 
    0.01415847f, -0.30019906f, 0.29867950f, -0.05089542f, -0.23129559f, -0.25538599f, -0.00895867f, 0.00424070f, 
    0.07116644f, 0.06318291f, 0.04434713f, 0.10890161f, 0.02170862f, -0.37425464f, -0.19384824f, -0.08358851f, 
    -0.21660858f, -0.05445952f, -0.29232064f, 0.13211651f, 0.05484541f, 0.09759434f, 0.25794521f, 0.05300304f, 
    0.01804362f, 0.08274154f, 0.05494515f, -0.20902099f, 0.30699879f, 0.02431601f, -0.03845444f, -0.04370755f, 
    0.11507465f, 0.14945707f, 0.10399390f, -0.03887243f, 0.05161614f, -0.10614908f, -0.33758789f, -0.03809153f, 
    0.32150212f, -0.11786994f, 0.20814405f, 0.18968655f, -0.06797900f, 0.20710063f, -0.02445633f, -0.23795135f, 
    -0.07496344f, -0.39658934f, -0.02617460f, -0.51109111f, 0.03926004f, 0.15995292f, 0.30290583f, -0.18433259f, 
    0.05645163f, -0.02587167f, 0.15450624f, 0.30474874f, 0.05347718f, 0.09536139f, -0.05132582f, -0.12916620f, 
    0.04074086f, -0.10943294f, 0.20219040f, 0.40699661f, -0.05015455f, -0.02849435f, 0.09609857f, 0.02837081f, 
    0.09294592f, -0.21474239f, 0.21070455f, -0.22165722f, 0.08018310f, 0.22332595f, -0.05820727f, 0.43118054f, 
    0.05636859f, -0.10260976f, 0.13762270f, -0.01070865f, -0.10355052f, -0.10416773f, -0.10996330f, 0.17512622f, 
    0.57655591f, -0.19828381f, -0.06584674f, 0.06149160f, 0.15422970f, 0.09743422f, 0.16312677f, 0.07789790f, 
    0.10276362f, 0.21842019f, 0.06813573f, 0.11393877f, 0.32289687f, -0.05920520f, -0.13138779f, 0.13664471f, 
    0.32833755f, -0.00452092f, 0.11496583f, 0.18463913f, -0.10162438f, 0.26135671f, 0.21979430f, -0.13297118f, 
    0.04324077f, -0.17803286f, -0.03800468f, 0.09362623f, -0.04879011f, 0.04795602f, 0.04024775f, -0.17139965f, 
    -0.19019225f, 0.14125136f, -0.02595871f, 0.68935347f, 0.14409663f, -0.14058739f, 0.25138488f, -0.01682287f, 
    -0.12827826f, 0.45685053f, 0.25146508f, 0.29484957f, -0.09934255f, -0.13659772f, -0.08175381f, -0.04390098f, 
    0.16353148f, -0.31878173f, 0.00748272f, 0.21652122f, 0.10092219f, 0.12464396f, 0.18406731f, 0.17467041f, 
    0.00906658f, 0.07060536f, -0.69071275f, -0.09068178f, 0.00978920f, 0.01229677f, -0.06060304f, 0.09339488f, 
    0.32911599f, -0.13397233f, 0.01330949f, 0.30560526f, 0.19057481f, 0.14365214f, 0.11463539f, 0.12510075f, 
    -0.20502508f, 0.01602243f, -0.29826385f, 0.06496006f, 0.08479575f, -0.04787405f, -0.03779176f, 0.00579143f, 
    -0.03361490f, 0.10988676f, -0.05981048f, 0.05753367f, 0.02825142f, 0.04576690f, -0.22895639f, -0.12602632f, 
    -0.02808691f, -0.37606874f, 0.31031916f, 0.35392377f, 0.06065853f, -0.28775981f, -0.56447423f, 0.13373174f, 
    -0.29029441f, -0.13182031f, 0.08645615f, 0.08525015f, -0.17393671f, -0.04115272f, 0.03938965f, -0.18407461f, 
    -0.09001068f, 0.02899718f, 0.01983752f, 0.04107408f, -0.24013995f, 0.09114011f, -0.04153548f, 0.27003700f, 
    -0.11162709f, 0.09808224f, -0.11713539f, 0.23207088f, -0.03252663f, -0.01240919f, 0.08257914f, 0.07170183f, 
    -0.24011275f, 0.02884877f, -0.15309070f, 0.18531170f, -0.11288553f, 0.07840718f, 0.12534474f, -0.04661532f, 
    0.08235221f, 0.18737435f, 0.05047431f, 0.05598924f, -0.57316774f, 0.10728113f, -0.45086196f, 0.20798135f, 
    0.02436380f, -0.03368773f, -0.03477965f, 0.06322968f, 0.01571226f, -0.00480381f, -0.10220820f, -0.01345698f, 
    0.04446146f, 0.09892911f, -0.14939140f, 0.13842514f, 0.21332061f, -0.05081524f, 0.10507979f, -0.04883589f, 
    0.00816034f, 0.14686349f, 0.14006655f, 0.16504851f, 0.10445610f, -0.04962661f, 0.03878207f, -0.01522257f, 
    -0.10271794f, 0.05317813f, -0.07064780f, 0.03099329f, -0.23470995f, 0.04997121f, -0.04116862f, -0.02701038f, 
    0.12837707f, -0.39873040f, 0.05976371f, -0.05929637f, 0.12599759f, 0.10666823f, -0.11832085f, -0.02945651f, 
    0.12448169f, 0.11804871f, 0.13696179f, 0.24193271f, 0.01530135f, -0.20271927f, -0.01328027f, 0.04316830f, 
    -0.33379215f, 0.00425573f, -0.16647536f, -0.08816838f, 0.07439081f, -0.05343966f, 0.14600149f, -0.01328081f, 
    -0.15474956f, 0.08836086f, -0.06493644f, -0.35048431f, -0.19538678f, 0.22999614f, -0.03930727f, 0.01990822f, 
    -0.33965066f, 0.10110798f, -0.06684864f, 0.14085107f, 0.14131771f, -0.07636447f, 0.06721319f, 0.17977609f, 
    0.00909827f, -0.07381003f, 0.02586381f, 0.27785081f, 0.19115083f, -0.01467747f, -0.02147044f, 0.17392419f, 
    0.14551042f, -0.09509942f, 0.19099967f, 0.38022181f, -0.08555715f, -0.06233203f, -0.36575761f, 0.18442096f, 
    0.16146845f, -0.09755517f, -0.02806483f, -0.17696428f, -0.21777661f, 0.03483257f, -0.32726747f, -0.24542505f, 
    0.04924672f, -0.05753593f, -0.06328861f, -0.12940621f, -0.02830440f, -0.02009719f, -0.09720181f, 0.29071259f, 
    -0.09062602f, 0.05660814f, -0.20528176f, 0.11909946f, 0.01840360f, -0.54689127f, -0.34297723f, -0.22372004f, 
    -0.33542451f, -0.05847508f, 0.12270067f, 0.08856350f, -0.07510781f, 0.01892743f, 0.16774639f, 0.15414481f, 
    -0.25004017f, -0.14151523f, -0.17429717f, 0.07351425f, -0.08023456f, 0.09003262f, -0.43858087f, 0.09185390f, 
    -0.07439664f, 0.06679504f, 0.05030996f, -0.08987569f, -0.02236842f, -0.11616810f, -0.08867446f, 0.07475707f, 
    -0.06328741f, 0.06250758f, -0.11049497f, -0.06187096f, -0.07574509f, 0.08273555f, -0.11669771f, -0.10074884f, 
    -0.02054435f, -0.07140968f, 0.07046989f, 0.03856166f, -0.04160312f, 0.00162108f, 0.01924349f, 0.09504636f, 
    -0.04793220f, -0.04844747f, 0.02754468f, 0.05369176f, -0.07050000f, -0.10851218f, -0.05368313f, 0.02366441f, 
    -0.06217834f, 0.07115112f, -0.13889892f, -0.07061572f, -0.11832030f, -0.11072946f, 0.05098653f, -0.09872002f, 
    -0.06015604f, -0.12165371f, -0.06147740f, 0.01621789f, -0.06447388f, -0.12894993f, 0.01304815f, -0.02778769f, 
    -0.11162040f, -0.02936856f, -0.09557405f, -0.05546264f, -0.10003552f, 0.04879983f, -0.05503467f, 0.05647256f, 
    -0.13243112f, -0.07929613f, -0.09083788f, -0.08658408f, 0.00993032f, -0.01153805f, 0.01013647f, 0.00418213f, 
    0.12118772f, 0.24699749f, -0.02023260f, 0.02769466f, 0.03368453f, -0.01601418f, 0.12310266f, 0.20506582f, 
    0.13220483f, 0.21794344f, 0.16818072f, 0.11970746f, 0.08829220f, 0.04876740f, -0.09234255f, 0.02635462f, 
    -0.02916157f, 0.20944718f, 0.21365245f, 0.20652935f, -0.23060434f, -0.00130342f, 0.14735971f, 0.01882272f, 
    0.11878223f, -0.17064001f, 0.26078701f, -0.30136397f, -0.07416299f, 0.03869551f, -0.13449909f, -0.07518462f, 
    0.11156171f, 0.07423329f, 0.27273816f, -0.06211049f, 0.03196431f, -0.12857458f, 0.11330076f, 0.12046959f, 
    0.12847504f, 0.02291557f, 0.21999440f, -0.04030662f, 0.08670478f, 0.03091361f, -0.14263169f, 0.00389933f, 
    -0.21886860f, 0.08115534f, 0.03664952f, 0.29120269f, 0.05130111f, 0.06759369f, 0.05557026f, 0.03754901f, 
    -0.06133796f, -0.10639187f, -0.26069212f, -0.29438096f, -0.09234207f, 0.04673199f, 0.00257125f, 0.18184060f, 
    0.05925167f, -0.16285290f, 0.04922892f, 0.09356230f, -0.04528957f, -0.03084737f, 0.09558988f, -0.14606017f, 
    -0.25563893f, -0.03794799f, -0.27859476f, -0.12695193f, -0.12950526f, -0.13085978f, 0.06981800f, 0.11836522f, 
    -0.03948298f, 0.12426650f, -0.02527012f, -0.22292159f, 0.02526890f, 0.10117596f, -0.03255754f, 0.04292989f, 
    0.08938352f, -0.11520755f, -0.12432234f, -0.37577882f, 0.22860101f, -0.11065096f, 0.10576067f, -0.10757580f, 
    -0.00522292f, 0.01481081f, -0.01945653f, -0.16123089f, -0.00620420f, -0.09523755f, 0.04250671f, -0.14228168f, 
    0.06732877f, 0.09847890f, 0.17366889f, -0.03100482f, 0.07336901f, 0.00524652f, -0.14301205f, -0.00623211f, 
    -0.16105630f, 0.12465837f, -0.03639771f, -0.25869361f, -0.01304543f, 0.07213743f, 0.14113599f, -0.12312873f, 
    -0.04666151f, -0.15758738f, -0.00210279f, 0.00705942f, 0.10065805f, -0.00882399f, 0.00577939f, -0.17390028f, 
    0.15543745f, 0.06474857f, 0.16677602f, -0.11529922f, 0.28830761f, -0.00631190f, -0.16651367f, -0.22455391f, 
    0.13519602f, -0.04266719f, 0.13566275f, 0.14199692f, 0.05413913f, 0.15551861f, -0.11977559f, -0.28156763f, 
    -0.10020864f, -0.13654992f, -0.19801335f, 0.00715014f, -0.02811165f, 0.13961947f, 0.27325052f, -0.09867690f, 
    -0.19905427f, 0.01281240f, -0.01007109f, 0.40409103f, -0.05426168f, -0.11246990f, 0.11326179f, -0.10445962f, 
    0.07743732f, 0.10004600f, 0.00939323f, 0.22800930f, -0.02835396f, -0.10979238f, 0.12549135f, 0.08299705f, 
    -0.08183806f, -0.25830618f, 0.05800702f, 0.12944546f, 0.11352383f, 0.25437027f, 0.08482074f, 0.07778231f, 
    0.08242745f, 0.13048407f, -0.32071587f, -0.19543013f, -0.03228901f, -0.00095345f, -0.13505316f, 0.13416624f, 
    0.23870735f, -0.13398957f, -0.06592715f, 0.13664272f, 0.11406861f, -0.00662366f, 0.05693675f, 0.08811933f, 
    -0.06284312f, -0.12599866f, -0.06805211f, 0.20368686f, 0.10590968f, -0.08548126f, 0.38440639f, 0.12076820f, 
    0.16582608f, -0.07129876f, 0.01804999f, -0.16393386f, -0.10798030f, -0.25758016f, 0.00460177f, 0.32079980f, 
    -0.09476996f, -0.05731883f, 0.27995574f, 0.11986741f, -0.32439107f, 0.03240669f, -0.15064245f, 0.10988288f, 
    0.34570283f, -0.10718828f, 0.13164206f, -0.22864808f, -0.12434018f, -0.01072262f, 0.12197725f, -0.27786112f, 
    0.04346635f, 0.40556979f, 0.15277191f, -0.12136499f, 0.09059941f, 0.27180940f, 0.10426731f, 0.15594581f, 
    0.14508890f, 0.13160625f, -0.15308861f, -0.20549318f, 0.06364600f, -0.40184328f, -0.26409802f, 0.10377069f, 
    0.08765257f, 0.09955898f, 0.55684918f, 0.31330043f, 0.07348810f, 0.06802152f, 0.27583563f, -0.02933259f, 
    -0.01419499f, -0.43386355f, -0.15766524f, 0.17551599f, -0.19186200f, -0.06476488f, -0.04410090f, -0.01727440f, 
    0.15506232f, -0.33951393f, 0.24835055f, 0.20263901f, -0.11559899f, 0.14476627f, 0.10366430f, -0.03751711f, 
    -0.15636416f, 0.13451950f, -0.15253021f, 0.09025842f, -0.09578913f, -0.27419043f, 0.00878012f, 0.20454910f, 
    0.05908470f, -0.04318751f, -0.33245260f, -0.39099169f, -0.03656693f, 0.28340042f, 0.24287592f, 0.19325662f, 
    0.07910993f, 0.10834523f, 0.08599832f, -0.40372416f, 0.12251958f, -0.12195104f, 0.26261041f, -0.25689167f, 
    -0.03866578f, 0.01141354f, -0.25261292f, -0.13697538f, 0.16692631f, 0.15183927f, -0.03346654f, 0.19966917f, 
    -0.03493556f, -0.30007064f, -0.28394452f, -0.00368699f, 0.10402140f, 0.06421705f, -0.00959209f, 0.18074523f, 
    0.40441748f, -0.00425455f, 0.01345044f, -0.10820302f, -0.07716146f, 0.09875418f, 0.13394558f, 0.31934223f, 
    -0.07475714f, -0.26468992f, -0.06494470f, 0.35669768f, -0.00074107f, -0.16955025f, 0.04539228f, -0.51106799f, 
    0.07635114f, -0.14938961f, -0.03415347f, 0.12820469f, -0.04545297f, -0.01868783f, 0.03764417f, -0.07978284f, 
    -0.11949601f, 0.09262423f, 0.07694590f, -0.05772427f, -0.08872873f, -0.12573667f, 0.07215698f, 0.06905769f, 
    -0.02780690f, 0.00775929f, -0.09356891f, -0.15507585f, 0.09652452f, 0.10178648f, 0.15803930f, -0.07674076f, 
    0.11893304f, 0.03183407f, 0.10186768f, -0.04985542f, 0.01230077f, 0.06496834f, 0.12287632f, 0.13566713f, 
    0.13572705f, 0.11195473f, -0.00706571f, -0.03344605f, 0.31019923f, 0.32507208f, -0.01209108f, 0.21972093f, 
    -0.03201026f, -0.14505078f, 0.01313515f, -0.14777085f, -0.00333886f, -0.02271108f, -0.07851941f, 0.15083827f, 
    0.38096145f, -0.09920350f, 0.58784270f, 0.07065488f, 0.02947584f, -0.03389592f, 0.06722333f, 0.10465505f, 
    -0.01180680f, -0.04807673f, 0.03744921f, 0.38518932f, -0.12767112f, 0.03376997f, 0.00693178f, 0.01917222f, 
    0.12152335f, -0.11640146f, 0.10499296f, -0.10990325f, -0.09906179f, -0.06942941f, -0.04229967f, -0.07926940f, 
    -0.15450326f, -0.03261760f, -0.06183112f, -0.09122771f, -0.06687529f, -0.08806827f, 0.23556186f, -0.02810239f, 
    -0.12757944f, -0.04473558f, -0.02093798f, -0.20942447f, -0.04771367f, 0.15586415f, 0.13573946f, -0.07258272f, 
    -0.06209861f, 0.02838098f, -0.05192952f, 0.10030919f, 0.21509758f, 0.03450051f, 0.21962908f, -0.14755240f, 
    -0.10295951f, 0.39978698f, 0.03117774f, 0.01312513f, 0.01444515f, 0.12532161f, -0.01851675f, -0.13244393f, 
    -0.00996600f, -0.09975176f, -0.00173277f, -0.27500629f, -0.02640735f, -0.08089513f, 0.14257292f, 0.08467592f, 
    0.40237185f, 0.04116084f, 0.17930183f, -0.14872319f, 0.05348651f, 0.09707409f, 0.10800710f, -0.17892924f, 
    0.21929386f, -0.09141144f, 0.11649244f, 0.11642499f, -0.11529365f, -0.09520137f, -0.00779005f, -0.11243349f, 
    0.12096468f, -0.07091561f, 0.13997512f, -0.01668909f, -0.09057518f, 0.12215992f, 0.43849999f, 0.03500379f, 
    0.12455916f, -0.00909499f, 0.05876389f, -0.19568378f, -0.15030918f, 0.11725295f, 0.29601970f, 0.34709686f, 
    -0.13296565f, 0.19771478f, 0.16079880f, 0.07665145f, -0.10878474f, -0.06070007f, -0.15327519f, -0.01139333f, 
    0.14568828f, -0.06546201f, 0.02900980f, -0.20446539f, -0.09950569f, 0.02202504f, -0.01351428f, 0.06961868f, 
    -0.11235744f, -0.23442848f, 0.30193183f, -0.19430681f, -0.06571702f, -0.04170872f, -0.12894551f, -0.06127844f, 
    0.25208774f, 0.13130927f, 0.16423610f, -0.20229073f, 0.02130368f, -0.13339719f, -0.17528071f, -0.11392359f, 
    -0.04718144f, -0.06382316f, 0.24625555f, 0.14582786f, 0.02845819f, -0.05214367f, 0.24510963f, 0.01065687f, 
    -0.06595474f, -0.05195166f, -0.05491192f, -0.21752413f, 0.26992324f, 0.03873996f, 0.06829117f, 0.07350901f, 
    0.00162934f, 0.20576264f, -0.00547499f, 0.01640849f, 0.16333640f, 0.10017921f, -0.24994138f, 0.13739461f, 
    -0.07889541f, -0.05984746f, -0.07561114f, 0.16952735f, 0.23367335f, -0.00006562f, -0.22369857f, -0.04924116f, 
    0.06641483f, -0.09192216f, -0.13831241f, -0.02790586f, 0.22236444f, 0.11544216f, 0.00617253f, 0.38521868f, 
    -0.10144832f, -0.12778223f, 0.00188157f, 0.27608198f, 0.09653936f, 0.03876320f, -0.02231694f, 0.02999800f, 
    -0.03675601f, -0.03454634f, -0.16819860f, 0.15815344f, -0.05479563f, 0.10527629f, -0.07351106f, 0.18446961f, 
    0.17532262f, 0.07732611f, -0.11683208f, -0.17958026f, -0.02206738f, 0.08165487f, 0.21189174f, 0.01809889f, 
    0.06003890f, -0.11763557f, -0.11964288f, 0.00126296f, 0.00103319f, -0.02895445f, 0.12179154f, 0.00705410f, 
    -0.01165811f, -0.01144851f, 0.10545292f, 0.14895338f, -0.10461279f, 0.20457074f, -0.23050688f, 0.14058949f, 
    0.06229178f, 0.07122962f, 0.03135014f, -0.03575242f, 0.03981403f, 0.09162898f, 0.00465647f, -0.09955904f, 
    -0.06822096f, -0.11922026f, 0.04819706f, -0.14912140f, 0.07934070f, 0.00591136f, -0.02581820f, -0.05699742f, 
    -0.05844815f, -0.04773955f, -0.00686900f, 0.04368347f, -0.12263492f, 0.00512290f, -0.02560837f, -0.07773715f, 
    -0.07671716f, -0.10140620f, -0.09558277f, -0.04971255f, 0.08749285f, -0.05056997f, -0.04659804f, 0.07779519f, 
    -0.11275916f, -0.10575505f, -0.05450405f, -0.03330960f, -0.02768186f, -0.00810876f, -0.05862847f, -0.03122844f, 
    -0.04343571f, -0.03678692f, -0.12218080f, 0.09851275f, 0.03311931f, -0.09501471f, -0.09381913f, -0.01389452f, 
    0.06176567f, 0.11393011f, -0.06239657f, -0.12140653f, -0.09698896f, 0.00448763f, 0.03860189f, -0.02719999f, 
    -0.06400777f, 0.04973954f, -0.09364191f, 0.03713832f, -0.10037076f, -0.03913508f, -0.02868049f, -0.03179093f, 
    0.02965472f, -0.19411777f, 0.01611477f, 0.16374193f, -0.14427517f, -0.01907131f, 0.03334306f, -0.01597185f, 
    -0.29640847f, -0.00936336f, -0.21834961f, 0.08088178f, 0.04888332f, -0.13029222f, 0.29462314f, 0.17302690f, 
    0.02198135f, 0.02267061f, -0.31583872f, -0.21274260f, -0.02838812f, 0.00971327f, 0.08124169f, 0.20840259f, 
    0.12339591f, 0.09922577f, -0.16027854f, 0.26049837f, 0.13049617f, 0.02332006f, 0.09094273f, 0.02488659f, 
    -0.13487267f, -0.00282871f, -0.32853970f, -0.08308044f, 0.12207456f, 0.34545437f, 0.04933499f, -0.16259049f, 
    0.20353638f, -0.08276270f, -0.12251452f, 0.17871442f, -0.11970936f, -0.12330151f, 0.16145822f, 0.18423766f, 
    0.25867426f, 0.01952778f, 0.18749627f, -0.11787150f, 0.05421838f, -0.01717436f, 0.01830151f, 0.19996421f, 
    0.04494709f, -0.03177016f, 0.02671923f, 0.14678283f, -0.08864545f, 0.08045922f, 0.14576104f, -0.19387202f, 
    0.12354663f, -0.03906792f, 0.22152290f, 0.14303701f, -0.14991744f, -0.14628896f, -0.06813206f, 0.12841141f, 
    0.00632657f, -0.06681299f, -0.18644004f, -0.06301945f, -0.19774981f, -0.19695884f, 0.20898183f, -0.00053853f, 
    0.03115292f, -0.25464898f, 0.17468177f, -0.20853223f, -0.01857255f, -0.05543743f, -0.01145511f, -0.09441511f, 
    -0.10241035f, 0.10963982f, -0.02349803f, -0.17286630f, -0.02648578f, -0.04597308f, 0.14145945f, -0.10198024f, 
    0.07539341f, -0.12837316f, -0.07202026f, -0.06673861f, -0.13526677f, -0.21456505f, 0.07763600f, 0.19271305f, 
    0.32485530f, -0.30646971f, 0.01976717f, -0.26775420f, -0.00660422f, -0.00420497f, -0.00611736f, -0.04072790f, 
    -0.00626771f, -0.02602861f, -0.40487754f, 0.44835269f, 0.12002429f, -0.03652347f, 0.31236562f, 0.22114237f, 
    0.05631300f, -0.01835280f, 0.00328225f, 0.22586225f, 0.29348326f, 0.05663380f, -0.03688203f, -0.18022542f, 
    0.19861896f, -0.00154236f, -0.14298970f, 0.06804222f, -0.26322249f, -0.01015368f, 0.32530215f, -0.16870615f, 
    0.20514628f, -0.12863922f, 0.15096582f, -0.32299453f, -0.15685540f, 0.00150308f, -0.17203352f, -0.01710966f, 
    -0.09424223f, -0.36215001f, -0.38434738f, -0.50531709f, -0.03154871f, 0.14574775f, 0.12790447f, -0.15320948f, 
    0.11743189f, -0.02816667f, 0.17001611f, -0.23595531f, 0.06934929f, 0.15001522f, 0.01275885f, 0.05304078f, 
    0.02499131f, -0.11097876f, 0.03190517f, 0.12870523f, 0.22046745f, -0.00638714f, -0.04444443f, 0.28242460f, 
    0.07152807f, -0.36581588f, 0.26761395f, -0.09128886f, -0.11963376f, -0.03922511f, -0.29220816f, 0.17129938f, 
    0.12358674f, 0.06679213f, 0.03489079f, 0.31582704f, 0.09021248f, -0.04174719f, -0.12478481f, 0.20027459f, 
    0.10310959f, -0.15662181f, -0.20460096f, 0.22079171f, 0.15975666f, -0.31869867f, 0.15099472f, 0.05130350f, 
    0.10412282f, -0.17533721f, 0.16006942f, 0.14567372f, -0.36321408f, -0.09862284f, 0.28728688f, -0.15053196f, 
    -0.13060772f, -0.00139633f, -0.02711358f, 0.08844377f, -0.24529025f, -0.35184246f, -0.00795874f, 0.17954126f, 
    -0.06783025f, -0.22881021f, -0.34157479f, -0.17714429f, -0.21320902f, 0.26827317f, 0.17425425f, 0.04535634f, 
    0.24041508f, 0.06705598f, 0.18895182f, -0.66917777f, -0.03832776f, -0.07813223f, -0.12068871f, -0.04555220f, 
    -0.03739522f, 0.08109233f, 0.02723610f, -0.05824420f, 0.05644516f, 0.26908228f, 0.06188256f, 0.17837515f, 
    0.10232911f, -0.18237358f, 0.04418662f, -0.09168468f, -0.00953382f, -0.10383877f, -0.36436814f, 0.16956072f, 
    0.10528778f, 0.05265921f, 0.25278449f, 0.02611893f, -0.05284908f, -0.04659426f, 0.24100338f, 0.15826008f, 
    0.25163710f, -0.14650558f, -0.22430393f, -0.01500733f, 0.16438197f, -0.46272647f, 0.07101138f, -0.30731010f, 
    0.00310131f, -0.06360403f, -0.08985646f, 0.09193367f, -0.07420781f, 0.12359287f, -0.10727309f, 0.01633883f, 
    -0.03168238f, 0.01333488f, 0.05375251f, 0.05119709f, -0.08537159f, -0.04078632f, 0.02225130f, 0.01259458f, 
    0.05294117f, -0.08651216f, 0.10496502f, 0.10145504f, 0.03460060f, 0.07037254f, 0.06456850f, -0.11751706f, 
    -0.13980256f, -0.09105034f, -0.13106020f, -0.14580071f, 0.07972403f, -0.10867868f, 0.00596810f, -0.07620922f, 
    -0.00467859f, -0.00510069f, 0.03866790f, 0.04904820f, -0.07942800f, -0.05421219f, 0.11692931f, -0.04698484f, 
    0.03363469f, 0.01559677f, -0.12598211f, 0.06320914f, 0.07631257f, 0.08678073f, -0.15661633f, 0.07431756f, 
    0.06589330f, 0.10858670f, -0.04038623f, -0.05108133f, 0.11457382f, 0.04851478f, -0.04648425f, 0.02396382f, 
    -0.08707082f, -0.07008118f, 0.03363883f, -0.06299685f, -0.11933863f, -0.11513282f, 0.04446939f, 0.06558587f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04219379f, 0.16896738f, 0.33563855f, -0.22927386f, 0.10061026f, 0.13059296f, 0.22331880f, 0.02807656f, 
    0.17017415f, 0.03483963f, 0.15849344f, 0.03924339f, -0.02253576f, 0.05827610f, -0.06011656f, -0.01939612f, 
    -0.00856306f, -0.16862914f, -0.01107380f, 0.21576047f, 0.20593695f, 0.18095019f, -0.15693595f, 0.29407987f, 
    -0.03848473f, 0.07645073f, 0.13007809f, -0.11954321f, -0.04629867f, -0.07280298f, -0.13216330f, 0.07327800f, 
    -0.08301844f, 0.08431143f, 0.17876880f, 0.06440366f, -0.07189593f, 0.17077406f, 0.17134647f, -0.07675970f, 
    -0.09349777f, 0.10170614f, 0.05780644f, 0.17214081f, 0.09194722f, -0.17283773f, -0.19914329f, 0.06883844f, 
    -0.00809821f, 0.10713913f, -0.04875506f, 0.17148003f, 0.17939351f, 0.24399689f, 0.12343132f, 0.17775084f, 
    -0.11764942f, 0.19543473f, -0.04221922f, 0.13650651f, -0.05898762f, 0.05282076f, 0.20566726f, -0.02845258f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.06550913f, 0.18177429f, -0.03705142f, 0.11908429f, -0.14086901f, -0.08202279f, 0.09174053f, 0.04575485f, 
    -0.15390068f, 0.10169947f, -0.16092539f, 0.10286820f, -0.03668541f, -0.29279491f, -0.24314857f, 0.02109135f, 
    0.24088955f, 0.06107099f, -0.40522942f, -0.33320963f, -0.24332312f, -0.47650176f, 0.43362522f, -0.68652499f, 
    0.12154098f, -0.06191035f, 0.01634851f, -0.03981825f, -0.42436597f, 0.13863255f, -0.08248482f, -0.44723058f, 
    0.06768527f, -0.05958061f, -0.28961539f, -0.03630644f, 0.09578583f, 0.08662742f, -0.30681440f, 0.20959698f, 
    0.00898027f, -0.12757160f, 0.00811114f, -0.02431872f, 0.07303176f, 0.21961215f, 0.06418297f, 0.09417691f, 
    -0.03084656f, 0.05308131f, -0.20683853f, 0.05847592f, -0.22149362f, -0.04053658f, -0.26882803f, -0.28442523f, 
    -0.25004220f, 0.04668737f, 0.09374996f, 0.01088121f, -0.09833623f, -0.14126143f, -0.22716099f, 0.07736775f, 
    -0.37761119f, 0.16926436f, 0.16397884f, -0.07674567f, 0.19394854f, -0.15061434f, -0.05918617f, -0.69959605f, 
    0.21973409f, -0.06718112f, 0.10261365f, 0.19403751f, -0.06010760f, 0.10787468f, -0.10022783f, 0.05876281f, 
    -0.54314435f, 0.03459935f, -0.54147601f, 0.10509603f, 0.20994629f, -0.05106100f, -0.31650805f, -0.07070394f, 
    -0.25060254f, 0.13773781f, 0.12060069f, -0.12338001f, -0.10214593f, 0.01286219f, -0.15424679f, -0.09746065f, 
    -0.12164699f, 0.00909424f, 0.23863986f, 0.12766671f, 0.06749225f, -0.07904443f, -0.63407892f, 0.28185374f, 
    0.03309109f, 0.08172973f, -0.23960033f, 0.19598927f, 0.26253614f, -0.56558162f, -0.09626937f, -0.55072773f, 
    0.02418294f, -0.19971713f, -0.14807360f, 0.24120913f, -0.85083532f, 0.29736811f, -0.02904633f, 0.13732609f, 
    -0.28105363f, 0.19756421f, -0.02457689f, 0.18130517f, 0.07329033f, -0.41727287f, -0.23805340f, -0.06520918f, 
    -0.10145123f, -0.20342362f, 0.10350290f, 0.08821604f, -0.43851820f, 0.17763066f, 0.22171849f, -0.09232195f, 
    0.05488056f, 0.11067622f, -0.56197000f, -0.07389657f, 0.03335527f, -0.35563737f, 0.01364518f, -0.30097601f, 
    -0.33682317f, -0.10051104f, -0.05314542f, -0.03594564f, 0.22391304f, 0.20264800f, 0.15012269f, 0.15427141f, 
    0.00384009f, 0.18081428f, -0.01782765f, 0.04131398f, -0.07561977f, -0.38023680f, -0.04767340f, 0.15559120f, 
    -0.24253234f, -0.08624119f, -0.82824242f, -0.02444926f, -0.25519812f, 0.15069556f, 0.17070542f, -0.78186631f, 
    0.19226925f, 0.19456357f, -0.19647920f, 0.17270987f, -0.30328327f, -0.22330241f, 0.13071106f, -0.46094081f, 
    0.05172981f, 0.00315595f, -0.20038466f, -0.56020832f, 0.09460173f, -0.01919272f, 0.20223704f, 0.11790982f, 
    -0.19280621f, 0.00770509f, 0.00163246f, 0.09110509f, -0.24913619f, 0.01813695f, 0.20717053f, -0.06628474f, 
    0.23662403f, 0.14911342f, 0.04499174f, -0.03259474f, -0.23073755f, 0.33715022f, 0.08252570f, 0.07356563f, 
    -1.11014795f, -0.14737348f, -0.59093958f, 0.08924598f, 0.02980409f, -0.30925041f, -0.09528422f, 0.10299570f, 
    0.08868845f, -0.05241301f, -0.11537470f, -0.22421017f, 0.16027693f, -1.38765037f, 0.12177265f, -0.12261569f, 
    0.39447841f, 0.42364243f, -0.11350393f, -0.00368467f, -0.02134026f, -0.00521577f, -0.03769866f, -0.04536073f, 
    0.00855214f, 0.13319144f, -0.10450385f, -0.51578498f, -0.12612379f, -0.01867442f, 0.17537171f, -0.05048376f, 
    0.09310966f, -0.09341384f, -0.03709848f, 0.02742971f, -0.06400446f, -0.15636876f, -0.35690999f, 0.01042208f, 
    -0.01804944f, 0.06468782f, -0.25901669f, -0.17081825f, 0.21551915f, -0.62175465f, 0.08398009f, 0.05881509f, 
    0.14246738f, 0.06729709f, -0.10647742f, -0.76035184f, 0.14149608f, -0.14377171f, -0.14889069f, 0.00478420f, 
    -0.05192799f, 0.14673820f, 0.10523282f, 0.01866885f, -0.21104456f, -0.32748237f, 0.07160652f, 0.07476895f, 
    -0.24720992f, -0.06319068f, -0.19235612f, 0.08429390f, -0.09342609f, 0.10656031f, 0.05600842f, 0.04756014f, 
    0.21639542f, -0.12762152f, 0.18593837f, -0.08582836f, -0.32255676f, 0.17935134f, -0.45442796f, -0.06356280f, 
    -0.50738603f, -0.39728382f, -0.10210356f, 0.04753974f, -0.47157505f, 0.06355191f, 0.06459406f, -0.16731293f, 
    0.10262088f, 0.09088558f, -0.43003604f, 0.14746988f, 0.06645706f, 0.03608475f, 0.16480918f, 0.03666051f, 
    -0.07747981f, 0.01205768f, 0.12037589f, -0.02523273f, 0.04243164f, -0.06497942f, 0.00781523f, 0.18240370f, 
    -0.05152337f, 0.17511825f, -0.10156432f, -0.17770869f, 0.06974015f, -0.54353184f, -0.15619363f, -0.16011277f, 
    0.09522427f, 0.06166146f, 0.09029412f, 0.14035471f, -0.09882797f, -0.48907673f, -0.39733553f, -0.06023888f, 
    -0.27836385f, -0.00368518f, 0.13540411f, -0.00374890f, -0.23194692f, 0.00309671f, 0.21584436f, -0.40395829f, 
    -0.33546993f, -0.11680780f, 0.15326805f, 0.12830295f, 0.09940224f, 0.07061566f, 0.09051491f, -0.06457347f, 
    -0.16243370f, -0.12138580f, 0.10224387f, 0.15230522f, 0.18971287f, -0.55171782f, 0.22222361f, 0.02121588f, 
    -0.29554430f, -0.43411312f, 0.15843497f, 0.09554479f, -0.05924588f, 0.04556958f, 0.07382739f, 0.14279512f, 
    -0.09499093f, -0.00773135f, 0.12867513f, 0.20183937f, 0.08065438f, 0.13139506f, 0.07928701f, 0.14528094f, 
    0.10164696f, 0.13467328f, -0.08236439f, 0.14696553f, 0.07056765f, -0.06742270f, -0.08870700f, -0.23230296f, 
    -0.09552286f, -0.06300999f, 0.03457749f, 0.03871363f, -0.36781520f, -0.54404992f, 0.13936469f, 0.02061204f, 
    -0.02845887f, -0.03576454f, -0.13905635f, -0.14545269f, 0.08721811f, 0.21486720f, -0.58473235f, -0.00918035f, 
    -0.02779899f, -0.87634242f, -0.36625218f, -0.21223713f, -0.35117552f, 0.25889596f, -0.80528778f, 0.06702621f, 
    0.28343594f, -0.09310593f, 0.14231324f, -0.21627751f, 0.07470322f, -0.05021163f, -0.11780205f, -0.55437773f, 
    -0.18669158f, 0.08571614f, 0.07923586f, 0.17586367f, -0.00752035f, 0.05985561f, 0.00890159f, 0.15502851f, 
    -0.44331494f, 0.12449203f, -0.20478624f, -0.03017012f, -0.00090096f, -0.61327106f, 0.07252445f, -0.25250593f, 
    0.07253068f, -0.57004857f, -0.02479307f, 0.07052875f, -0.41625035f, -0.38649502f, -0.02706238f, -0.03178599f, 
    0.20838976f, 0.01798279f, -0.29985562f, -0.80629349f, -0.67405409f, -0.12742542f, -0.10216319f, -0.11032356f, 
    0.01907991f, -0.58018303f, 0.00678242f, -0.14187907f, 0.29751870f, 0.20874090f, 0.23491538f, 0.09982406f, 
    0.12887910f, -0.18812962f, 0.07028233f, 0.12857880f, -0.71583998f, 0.04315034f, 0.16791692f, -0.05641874f, 
    0.25659972f, -0.37807828f, -0.03094194f, 0.17234150f, -0.00094673f, -0.01602648f, -0.47211006f, 0.15450534f, 
    -0.55093318f, -0.06843916f, 0.13339990f, -0.01398042f, 0.03132021f, 0.06780636f, 0.15723403f, 0.07769047f, 
    0.43660891f, 0.01430172f, -0.35405692f, -0.19611639f, -0.19093825f, 0.04361927f, 0.09088340f, -0.38200641f, 
    0.33859625f, 0.25190875f, -0.04564432f, 0.10413134f, 0.10147963f, 0.10091440f, -0.02685839f, -0.10159513f, 
    0.19456193f, 0.04743390f, 0.14166410f, -0.10393535f, 0.18441860f, -0.11945564f, -0.47913992f, -0.33932608f, 
    0.00621850f, -0.41550156f, 0.14308132f, -0.38830054f, -0.16868035f, -0.20784971f, 0.02206621f, 0.28170171f, 
    0.08979300f, -0.36262327f, 0.10389379f, 0.04539336f, 0.03626616f, 0.06803638f, -0.09587429f, -0.06117595f, 
    -0.13999306f, 0.21786897f, -0.14063343f, -0.05161614f, 0.09937763f, -0.26707473f, 0.07520821f, -0.16142002f, 
    0.16992901f, -0.58316493f, -0.54609030f, -0.19205654f, 0.15626450f, 0.11805536f, -0.34644890f, -0.35771263f, 
    -0.13586362f, -0.05183550f, -0.08236228f, -0.28059003f, 0.06630735f, 0.04640437f, 0.10022666f, -0.33650914f, 
    -0.10072221f, -0.11543970f, -0.11660602f, 0.08291075f, 0.11455971f, 0.15102232f, -0.23156844f, 0.04164254f, 
    0.03846091f, 0.06642633f, 0.12507185f, -0.04025490f, 0.20569518f, -0.36735693f, -0.03220042f, 0.30567807f, 
    0.04754019f, 0.09080625f, -0.23026209f, 0.12498160f, -0.04650166f, -0.64412796f, -1.00145268f, -0.33722690f, 
    0.05519158f, 0.16986549f, -0.11787470f, 0.23318239f, 0.13842176f, -0.06746313f, -0.00633463f, 0.08278320f, 
    -0.08734556f, 0.11197003f, -0.02069731f, 0.42201492f, -0.47807464f, 0.06057514f, -0.06186644f, 0.04430324f, 
    -0.05212383f, -0.21897310f, -0.09154227f, -0.22296797f, 0.11850211f, 0.28206956f, 0.33554527f, 0.04551400f, 
    0.11574478f, 0.15058425f, 0.09624095f, -0.07446611f, -0.41428360f, 0.09844601f, 0.15544388f, 0.25811538f, 
    0.07114150f, -0.00015568f, 0.13115300f, -0.51938319f, -0.03376826f, -0.16796663f, -0.03468635f, -0.06624031f, 
    -0.05853472f, 0.05087999f, 0.16856290f, 0.10429173f, -0.30913559f, -0.33792043f, -0.45100039f, 0.07759766f, 
    -0.68382454f, 0.05526706f, -0.40263817f, -0.03001630f, -0.24765152f, 0.11194292f, -0.02595959f, -0.16395295f, 
    0.01620383f, -0.11886238f, 0.13549609f, -0.24698800f, -0.27733904f, -0.02602935f, 0.13254428f, -0.51000130f, 
    0.03294744f, -0.05063237f, -0.08296923f, -0.38938516f, -0.47688869f, -0.50132173f, -0.27771598f, 0.22486243f, 
    -0.05015045f, -0.00053979f, -0.23561135f, -0.19769146f, 0.16934018f, -0.15445945f, 0.10031650f, -0.03127275f, 
    0.13206893f, 0.02735630f, 0.08655538f, -0.15398647f, -0.16503313f, -0.08120877f, -0.06181665f, 0.02766070f, 
    -0.00883651f, 0.15446685f, -0.10280099f, -0.27461323f, 0.26963851f, -0.42829651f, -0.09296385f, -0.63331592f, 
    -0.24141325f, -0.28491712f, -0.52928513f, -0.11421745f, -0.06330992f, -0.61789727f, 0.34598130f, 0.25696865f, 
    -0.55032629f, -0.09244145f, 0.22933894f, -0.24615642f, -0.06236964f, -0.47982398f, -0.12673534f, 0.18982032f, 
    -0.40622765f, -0.03890862f, 0.06332214f, -0.09131376f, 0.34597707f, -0.29083997f, -0.07617373f, 0.22406048f, 
    -0.43130651f, 0.09727175f, -0.05102186f, 0.11898988f, -0.29579514f, -0.11276855f, -0.13784193f, -0.22152676f, 
    0.04459176f, 0.14405826f, 0.42453325f, -0.08208679f, 0.04651349f, -0.35906869f, -0.07937954f, -0.47599316f, 
    0.11064514f, 0.18721363f, -0.12750912f, -0.14003359f, 0.04025578f, -0.25838098f, -0.30621064f, 0.12483616f, 
    0.45899871f, -0.57186049f, 0.05060868f, -0.46046734f, -0.39039826f, -0.31153661f, 0.03934309f, -0.07641236f, 
    -0.16215909f, -0.27462623f, -0.27039996f, -0.23102716f, 0.36051670f, -0.21401657f, 0.13227944f, 0.18203245f, 
    -0.52186400f, -0.26866582f, 0.18026185f, -0.09785833f, 0.01775894f, 0.15372171f, 0.22738114f, 0.13181208f, 
    -0.57534885f, 0.02131132f, 0.07219382f, 0.18926720f, -0.08761863f, -0.31141326f, -0.21124165f, 0.16946925f, 
    0.11939571f, -0.11863283f, -0.54169554f, 0.02624180f, 0.08885351f, -0.21386439f, -0.09504493f, 0.04759358f, 
    -0.27159706f, -0.19772069f, 0.15004146f, -0.03474703f, -0.29163480f, -0.17817238f, -0.05424151f, -0.21187676f, 
    -0.35348782f, -0.07626172f, 0.06538042f, -0.11830685f, -0.04188808f, -0.17532317f, 0.30652714f, -0.62982321f, 
    0.04846307f, -0.18716520f, 0.05838174f, -0.47679523f, 0.02459335f, 0.16317868f, 0.08276716f, 0.06703842f, 
    0.12929070f, -0.21076028f, -0.01607683f, -0.04770925f, 0.26992753f, 0.18786421f, 0.12335745f, 0.00664209f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18064925f, 0.34481069f, 0.23417677f, 0.00980226f, -0.03318065f, -0.20024261f, 0.07296584f, -0.25466177f, 
    -0.11870755f, 0.16746938f, 0.07902191f, -0.06030382f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
