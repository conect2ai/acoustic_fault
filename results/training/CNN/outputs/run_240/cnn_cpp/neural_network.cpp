#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20598519f, 0.47280431f, 0.75086725f, -0.08710008f, 0.10230071f, 0.34534508f, 0.37238750f, 0.18354936f, 
    -0.13195609f, 0.07169133f, -0.54724407f, -0.27000430f, -0.16157737f, 0.17973027f, 0.13678908f, 0.03798684f, 
    0.00227509f, 0.27358466f, 0.18929705f, 0.10857788f, -0.39573517f, -0.17370452f, -0.39183193f, -0.35310468f, 
    -0.15514527f, 0.95612037f, 0.76163167f, 0.30649674f, 0.87452269f, 1.27995837f, 0.13470532f, 0.13046631f, 
    -0.25864661f, 0.56027788f, -0.13281842f, 0.07979542f, 0.02582711f, 0.00424808f, 0.05463485f, -0.23697478f, 
    -0.03160371f, -0.06045654f, 0.22116382f, 0.01452126f, -0.11597915f, 0.36853611f, -0.06957722f, 0.30796295f, 
    0.07182993f, 0.19177291f, -0.20354697f, -0.44864297f, -1.00822175f, -0.59411478f, -0.74473405f, 0.52063167f, 
    1.06361353f, 0.03375125f, 0.34974223f, 0.50705373f, 0.31029794f, -0.28252572f, -0.22160719f, -0.20621815f, 
    -0.10583016f, 0.04655363f, 0.05036414f, -0.05046814f, 0.01732495f, -0.11821720f, -0.26142007f, -0.36376047f, 
    -0.19799832f, -0.47156224f, -0.03360868f, -1.02561545f, -0.45519307f, -0.41838607f, -0.68453783f, -0.19027162f, 
    -0.69044691f, -0.40024656f, -0.05151199f, -0.45871812f, -0.25669295f, -0.29422846f, 0.32777950f, -0.11036519f, 
    0.19768798f, -0.36468098f, -0.19190241f, -0.05284857f, -0.05845543f, 0.10081010f, 0.13621685f, 0.16915782f, 
    -0.07087009f, 0.23536438f, 0.27990973f, 0.35095322f, 0.24257512f, 1.24819946f, 0.17692323f, -0.08030242f, 
    0.32798943f, 0.09976799f, -0.65572935f, -1.00234950f, -0.79290974f, -0.24812016f, 0.05005144f, 0.35805956f, 
    0.25888515f, 0.31115606f, 0.09332688f, 0.13536036f, -0.17312643f, 0.04621256f, 0.03351169f, 0.48760968f, 
    -0.31867832f, 0.15597343f, 0.27236861f, -0.40475670f, -0.06820056f, 0.79578149f, 0.86545449f, 1.12758732f, 
    0.29099128f, 0.48637673f, -0.98379600f, 0.26743907f, -0.47108579f, -0.33746099f, -0.26378012f, 0.35643837f, 
    0.05432556f, -0.12718523f, -0.01220271f, 0.48473904f, -0.17625953f, 0.02916404f, -0.16178969f, -0.10771696f, 
    -0.10212350f, -0.14096640f, 0.00827758f, 0.28726611f, -0.02967550f, 0.07966021f, -0.08381205f, -0.18208352f, 
    -0.89907134f, -0.18662977f, -0.28844434f, 0.23005658f, -0.57815236f, -0.60518664f, 0.39163733f, -0.17224111f, 
    -0.59647697f, -0.13709585f, -0.42998236f, 0.37141153f, -0.28000966f, -0.21042742f, 0.43988064f, -0.29534018f, 
    -0.18129808f, -0.03028606f, 0.02382330f, 0.23705080f, 0.32922232f, 0.66371417f, -0.14941694f, -1.28477991f, 
    0.32534617f, 0.78414208f, 0.22841159f, -1.19729578f, 0.52883619f, 0.57232243f, -0.60114342f, 0.23268302f, 
    0.46244735f, 0.18939419f, 0.05649191f, 0.36749417f, -0.17293300f, -0.04001558f, 0.01618075f, 0.11533713f, 
    0.22766639f, -0.16550624f, -0.21577398f, -0.12221898f, -0.10676491f, 0.12834300f, 0.06454082f, -0.15389295f, 
    0.54566747f, -0.41489244f, -0.45929900f, 0.33897594f, -0.46056533f, 0.18512984f, 0.61835092f, 0.48553845f, 
    0.70630938f, 0.04147376f, 0.46305832f, 0.48919603f, -0.04594546f, -0.06511754f, -0.10627032f, -0.08141408f, 
    -0.79316539f, -0.23571548f, 0.42176068f, -0.22565396f, 0.35704222f, 0.23363481f, 0.04209068f, 0.40681028f, 
    -0.29478729f, 1.02327883f, 0.61328262f, -0.42144963f, -1.34054995f, -0.39048719f, -0.12326638f, 0.49354070f, 
    0.11453315f, -0.60060006f, -0.36557573f, 0.30090910f, 0.32282016f, 0.20689531f, 0.15674180f, -0.18953103f, 
    0.15503965f, 0.06697066f, -0.00449679f, 0.09871339f, 0.15182079f, 0.23079039f, 0.16945550f, 0.31699631f, 
    0.28723943f, 0.06771463f, 1.19183993f, -0.02911566f, -0.73172075f, 0.66827613f, 0.82404691f, 0.77122462f, 
    0.15480442f, -0.86050481f, 0.14572951f, 0.19750704f, -0.32009682f, 0.00178428f, -0.23025055f, -0.04103352f, 
    0.04974625f, -0.13871746f, 0.02456574f, -0.07018737f, -0.04339565f, -0.02282416f, -0.00912232f, 0.22322118f, 
    -0.11517478f, -0.14446440f, 0.13561031f, 0.90344769f, -0.00715123f, 0.43770710f, -0.66753721f, -0.00338491f, 
    -0.83342057f, -0.38214743f, 0.42026713f, -0.07794207f, -0.45404893f, -0.20334722f, -0.19742565f, 0.17826375f, 
    -0.11118840f, 0.43479353f, 0.16825198f, 0.19882660f, 0.24099939f, -0.00282244f, -0.03981614f, 0.33236963f, 
    0.38749841f, -0.33104759f, -0.09515531f, -0.04097968f, -0.77589762f, -0.40998569f, 0.33760944f, 0.57457113f, 
    0.62631977f, -1.32580793f, 0.42528340f, -0.43346655f, -1.08725798f, -0.02483417f, 0.55347097f, 0.50476438f, 
    -0.17847547f, -0.06422827f, -0.19664989f, 0.19918348f, -0.01686041f, -0.03995826f, -0.07789327f, 0.23854457f, 
    -0.05958980f, 0.07350254f, 0.35496545f, 0.18865174f, -0.15954819f, -0.12720835f, 0.43526873f, -1.06449997f, 
    -1.16167772f, -0.72662461f, 0.89816427f, -0.23222785f, 0.21316764f, 0.60762978f, 0.54087657f, -0.18414859f, 
    -0.27253556f, -0.19829407f, 0.15063812f, 0.03739283f, 0.30884549f, -0.17512318f, -0.06267747f, 0.13845018f, 
    0.25007838f, 0.36880431f, 0.05114972f, -0.21628566f, 0.06449846f, 0.40388450f, -0.27940294f, 0.22159085f, 
    -0.70994729f, -0.49741247f, 0.07382832f, -0.40718377f, -0.56865805f, 0.40112895f, 0.46783140f, -0.64201146f, 
    -0.42878696f, -0.07651401f, 0.00460452f, -0.46009499f, -0.43249547f, 0.10711011f, 0.24299978f, -0.30480045f, 
    -0.21620403f, -0.66257107f, -0.06963407f, 0.08543550f, 0.28875703f, 0.06343804f, 0.05924702f, 0.57592249f, 
    0.10990395f, 1.21187329f, 0.09049382f, 0.67497134f, 0.96085519f, -0.15485071f, 0.39587927f, -0.28145543f, 
    -0.23958185f, 0.59339893f, 0.08227856f, -0.29197145f, 0.11865859f, -0.33376679f, -0.17295025f, 0.35250449f, 
    -0.02318784f, -0.21538596f, 0.03333550f, -0.21387194f, 0.11052421f, 0.16602829f, -0.16130720f, 0.17311488f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03562450f, 0.22097589f, 0.30747041f, 0.41699058f, 0.35696387f, -0.01720536f, 0.34088355f, 0.04232812f, 
    0.09583646f, 0.00578601f, 0.11113378f, 0.37583733f, 0.13829803f, 0.24683857f, -0.15348743f, 0.19215624f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26844946f, 0.03009839f, 0.13650505f, 0.09023083f, 0.01613392f, 0.05251140f, 0.00041966f, -0.15136479f, 
    -0.11930283f, -0.07729409f, 0.21048208f, -0.02132531f, -0.46701059f, -0.07772195f, 0.05039195f, -0.60534662f, 
    0.06670645f, 0.08055132f, -0.02089080f, -0.04240229f, 0.05992956f, 0.02206932f, 0.25904500f, -0.01283933f, 
    -0.23014019f, 0.22299302f, -0.39470536f, 0.23388980f, -0.23266737f, 0.15718684f, -0.13449456f, -0.05070708f, 
    -0.06505433f, 0.01318981f, 0.03057762f, 0.02273199f, 0.31620523f, 0.27114481f, 0.30121890f, 0.23466671f, 
    0.08977615f, 0.06647320f, -0.07866528f, -0.15543023f, 0.08265154f, 0.13735825f, -0.05275451f, 0.02685610f, 
    0.03412452f, 0.01223049f, 0.13013983f, 0.37986985f, 0.12095153f, -0.09500208f, 0.00524541f, 0.17443688f, 
    -0.19912931f, -0.05864341f, 0.18978764f, 0.07698867f, -0.44852754f, 0.01234758f, 0.19650161f, -0.07400455f, 
    0.02642918f, 0.15774900f, -0.00756916f, 0.09922963f, -0.24180286f, -0.09642414f, -0.06021244f, 0.00187245f, 
    0.16113502f, 0.35132024f, 0.11890486f, 0.29418024f, -0.00463718f, 0.08148760f, 0.21429351f, -0.07281970f, 
    0.38510853f, 0.13852119f, 0.01263269f, -0.10253111f, 0.04005362f, 0.18792851f, -0.01155664f, 0.19876078f, 
    0.16646221f, 0.06742745f, -0.04461340f, 0.00813000f, 0.06420702f, 0.06492785f, 0.05261563f, -0.00574524f, 
    0.30189353f, -0.05476802f, 0.05613163f, -0.15695575f, -0.27547988f, 0.13082117f, 0.11691283f, 0.11955914f, 
    -0.01321741f, -0.02140061f, 0.16944510f, -0.17059226f, -0.02084744f, -0.49558190f, -0.29721040f, 0.24085586f, 
    -0.17905939f, 0.03357720f, -0.06976984f, 0.11387210f, 0.36015549f, 0.14627258f, -0.11179578f, -0.05706649f, 
    -0.13781205f, -0.06274735f, -0.04676553f, -0.30602068f, -0.07261164f, 0.09319295f, 0.06236316f, 0.07318916f, 
    -0.00688846f, -0.14709564f, -0.06635917f, -0.04545136f, 0.00160303f, -0.06820006f, 0.29028419f, 0.03453363f, 
    0.14048469f, 0.08213975f, -0.04205386f, 0.00768909f, -0.11691250f, -0.01154677f, 0.13623561f, 0.19847919f, 
    0.17949496f, 0.10296120f, 0.48279434f, -0.05533779f, 0.04020385f, -0.02782868f, -0.00028312f, -0.08829812f, 
    -0.00567155f, 0.02647844f, -0.17754520f, 0.12997575f, 0.00963456f, 0.34435380f, -0.44319713f, 0.33931318f, 
    0.11103443f, 0.15774857f, -0.10622378f, -0.06181057f, -0.00888856f, 0.03820002f, 0.05858930f, -0.07276701f, 
    0.25553578f, -0.08411102f, 0.34840742f, 0.51074368f, 0.23682524f, 0.23926401f, 0.04278218f, -0.12857322f, 
    -0.06942246f, 0.00872976f, -0.03726956f, 0.02928573f, -0.50252932f, -0.08549944f, 0.06060603f, 0.13441119f, 
    0.02557812f, -0.08412894f, -0.00405643f, -0.02658817f, 0.07016796f, -0.12045412f, 0.04498113f, 0.06546070f, 
    0.30878010f, 0.13575448f, -0.13311400f, 0.19286866f, -0.09016298f, -0.01382357f, 0.22301000f, 0.03458119f, 
    -0.03050952f, 0.04042087f, -0.20534383f, 0.06609091f, -0.37181717f, 0.45809281f, -0.01863403f, -0.07127523f, 
    -0.04710565f, 0.21435243f, -0.10552373f, -0.20398955f, -0.31511030f, -0.06611584f, -0.04585831f, -0.13346130f, 
    0.06174655f, 0.08113210f, 0.01870109f, 0.05438334f, 0.18251662f, -0.03484784f, 0.05655947f, 0.07853240f, 
    0.07873376f, 0.07582269f, 0.03248592f, -0.02828834f, 0.22341488f, 0.03678909f, 0.13320884f, 0.22482567f, 
    -0.01965174f, -0.02550544f, -0.08420976f, -0.17157793f, -0.14345442f, 0.02847342f, 0.04912339f, 0.02356205f, 
    0.06767695f, 0.11641634f, -0.24082784f, -0.11267997f, -0.04759438f, 0.00070251f, -0.08587179f, 0.10040121f, 
    0.02986285f, 0.00358321f, -0.13582270f, -0.03589924f, 0.55636150f, -0.20587172f, -0.15163957f, -0.23794319f, 
    0.08680709f, -0.01366942f, -0.05157052f, -0.13022606f, 0.04502966f, 0.10847838f, 0.06782250f, 0.08844095f, 
    0.18931337f, 0.28055477f, 0.11941662f, 0.08148499f, -0.05719111f, 0.02635539f, -0.15906309f, 0.00793698f, 
    -0.10063962f, -0.05982824f, 0.01408938f, 0.13655417f, -0.11753451f, 0.04017803f, 0.07862729f, 0.14988676f, 
    0.04895430f, 0.07850870f, 0.21720211f, 0.11176611f, -0.11308948f, 0.10566536f, -0.12783930f, -0.00229148f, 
    -0.04979688f, -0.05371188f, 0.31459245f, 0.19173886f, -0.05628051f, 0.06622434f, 0.07888825f, -0.13586110f, 
    -0.02216692f, 0.08720101f, -0.10198651f, 0.01222610f, 0.51035941f, -0.06940521f, -0.11926777f, 0.25104582f, 
    0.22553071f, 0.19746079f, -0.14287852f, -0.10270827f, -0.14070891f, -0.03554722f, -0.09444471f, -0.13412595f, 
    -0.39224195f, 0.57162881f, -0.21884030f, -0.13748179f, 0.00268720f, 0.03123423f, -0.01191390f, -0.00841847f, 
    -0.15341990f, -0.00637212f, 0.09996633f, -0.01758005f, 0.22345169f, -0.02690139f, -0.21402687f, 0.24245733f, 
    0.05686809f, -0.02201731f, 0.01387606f, 0.08713446f, -0.03086421f, -0.21789016f, -0.07665315f, -0.12716459f, 
    -0.13782182f, -0.13848229f, -0.23852734f, -0.09658886f, -0.01484507f, 0.03711105f, -0.01106444f, 0.09751447f, 
    -0.14951524f, 0.12413871f, 0.15809816f, -0.25789884f, -0.16985847f, 0.16374040f, 0.28493902f, 0.00461152f, 
    -0.01541513f, 0.02890891f, 0.10101001f, 0.11591926f, -0.00190526f, -0.15717903f, 0.10543460f, -0.09097201f, 
    -0.02428375f, 0.28045961f, 0.01725515f, -0.01444892f, -0.19156148f, -0.15843147f, -0.15266153f, 0.18494435f, 
    0.08977659f, 0.18150036f, 0.17149988f, 0.05240156f, 0.41511247f, 0.00834548f, -0.27103037f, -0.17644900f, 
    -0.00211652f, 0.03298514f, 0.04378232f, 0.12319738f, -0.08744086f, 0.08633798f, -0.01017969f, 0.03114037f, 
    -0.01624938f, 0.02903916f, -0.03509084f, -0.03123006f, -0.06305422f, 0.02457270f, -0.05056821f, 0.01627352f, 
    0.05155403f, 0.01363866f, -0.06072564f, 0.03782240f, -0.00927463f, 0.00558902f, -0.02346330f, 0.05557052f, 
    -0.05441196f, -0.02467278f, 0.00928254f, -0.00478903f, -0.06825630f, -0.04619965f, 0.05354895f, 0.04191765f, 
    -0.07272717f, 0.00817259f, -0.01727368f, -0.03546055f, 0.04349649f, -0.05887970f, 0.00338352f, -0.07443354f, 
    0.03730490f, 0.06235906f, -0.07019836f, -0.04074091f, 0.04118586f, 0.04301756f, -0.03784700f, -0.03470514f, 
    -0.02384065f, -0.02898795f, -0.06026758f, -0.06003051f, -0.02281358f, 0.03836890f, -0.02353422f, 0.03214935f, 
    0.01576844f, -0.01555192f, -0.02979338f, 0.03533729f, -0.00495781f, -0.01690319f, -0.00489504f, -0.01788638f, 
    0.03629069f, 0.01097054f, 0.02348378f, 0.03133090f, -0.00290553f, 0.05126149f, -0.01744720f, 0.00359158f, 
    0.04023037f, -0.06790762f, -0.07067998f, -0.00945708f, -0.04512914f, -0.05881159f, -0.04252122f, -0.03608584f, 
    -0.05605614f, 0.05663749f, 0.02812883f, -0.02077576f, 0.02006794f, -0.00057705f, 0.04547180f, -0.07156799f, 
    0.03666098f, 0.00626150f, 0.01527959f, -0.05452511f, 0.04291416f, -0.05624683f, -0.00551875f, 0.01140273f, 
    0.03652657f, -0.07628111f, -0.06477372f, -0.07005737f, -0.00568261f, -0.06605215f, -0.06209179f, 0.03350311f, 
    0.02372136f, -0.06185238f, -0.05209823f, 0.05967742f, 0.05404676f, -0.02243064f, -0.04611387f, 0.04910387f, 
    -0.05935802f, -0.06682198f, -0.06506380f, 0.03006983f, -0.01696092f, 0.06720216f, 0.06006848f, -0.05737428f, 
    -0.00388535f, -0.07575334f, -0.00942103f, 0.02100755f, -0.06459183f, -0.08028831f, 0.04026816f, -0.06529739f, 
    -0.04189137f, -0.03083376f, 0.04585595f, -0.03120617f, 0.00522187f, -0.05293615f, -0.05538094f, -0.02744637f, 
    0.06409230f, 0.00398778f, 0.02462788f, -0.04470229f, -0.07440069f, -0.04046336f, -0.03214582f, -0.00356208f, 
    -0.07303353f, -0.01751279f, -0.00016218f, 0.03434425f, -0.03807787f, 0.04359924f, 0.04564113f, -0.07654247f, 
    -0.00114116f, -0.03015449f, 0.01636226f, -0.08000857f, -0.02687712f, 0.00015699f, -0.00747973f, -0.04000078f, 
    -0.00059841f, 0.02645575f, 0.06134710f, 0.04768949f, -0.07485773f, 0.03600422f, -0.04123256f, -0.00441761f, 
    0.04442970f, 0.03978551f, -0.05417699f, -0.01667118f, 0.03832718f, -0.05607934f, -0.02500005f, -0.02449370f, 
    -0.05879267f, -0.02871753f, -0.07585321f, -0.05859254f, 0.00549409f, -0.02744226f, 0.00982706f, 0.04894984f, 
    0.05439781f, 0.02558263f, 0.01268952f, 0.03625852f, -0.07130279f, 0.03386448f, -0.00363041f, 0.03979804f, 
    0.00015421f, 0.05419783f, 0.04328036f, 0.00929932f, -0.00496158f, -0.04210152f, -0.07131831f, -0.01582289f, 
    0.34633824f, -0.20778982f, 0.00012094f, -0.12550278f, -0.25579047f, -0.17725717f, 0.04425232f, -0.14128453f, 
    0.14378674f, 0.09369916f, 0.01000948f, 0.10656149f, -0.05314739f, -0.08031013f, -0.07859883f, -0.02279212f, 
    0.07931443f, -0.00814902f, -0.07387988f, -0.10797483f, 0.06513549f, -0.11549935f, 0.05423828f, -0.10904348f, 
    0.32662287f, 0.24502313f, 0.03697300f, -0.24323301f, 0.16066669f, 0.29720679f, 0.09755886f, -0.08693397f, 
    0.00079338f, -0.05712671f, -0.12348574f, -0.08297677f, -0.12822305f, -0.04748797f, -0.06455830f, 0.43869153f, 
    0.08614346f, -0.01414225f, -0.01079483f, -0.03551948f, 0.03706453f, -0.24563533f, -0.09001130f, -0.01509857f, 
    0.12415742f, -0.00857368f, 0.27544630f, 0.32789335f, -0.16543984f, -0.11211526f, -0.02313515f, 0.02475778f, 
    0.09958284f, -0.09537315f, -0.01390560f, 0.16998716f, 0.52848691f, -0.19267410f, -0.31334883f, 0.11310524f, 
    -0.18234628f, -0.06606948f, -0.05101650f, 0.09983085f, -0.04525476f, -0.26421666f, 0.17517136f, -0.08211413f, 
    0.29588830f, 0.11061180f, -0.00638009f, 0.29013905f, 0.20094778f, 0.13354658f, -0.03321698f, -0.06690051f, 
    -0.15565144f, 0.12867081f, 0.22706077f, -0.04445651f, 0.35894954f, 0.08364639f, -0.03858861f, 0.26698464f, 
    0.09399622f, 0.06441924f, -0.06381592f, -0.11239652f, -0.02456245f, 0.02478621f, -0.15764877f, -0.08673459f, 
    -0.53134161f, 0.32474586f, -0.50263643f, -0.10794926f, 0.32553858f, -0.18677549f, -0.04240369f, -0.05918233f, 
    0.06881990f, 0.03240298f, -0.04130821f, -0.20360075f, -0.29265279f, 0.07764575f, 0.44679126f, 0.22032523f, 
    -0.15969819f, -0.00467866f, -0.23786926f, 0.10741794f, -0.03174377f, -0.05724260f, -0.04813406f, 0.06502388f, 
    -0.06892920f, 0.15740788f, 0.06457721f, 0.29854789f, -0.00457740f, -0.24363184f, 0.08711582f, -0.33196303f, 
    -0.11452552f, 0.06050205f, 0.04163204f, -0.08053382f, 0.35078195f, 0.29064938f, 0.22954509f, -0.10968436f, 
    -0.07225377f, -0.06908695f, -0.00497581f, -0.21851552f, 0.04329352f, -0.05718568f, -0.00233466f, -0.03792236f, 
    0.01505953f, -0.18253756f, -0.29164076f, 0.12326343f, -0.07923484f, -0.30709222f, -0.03376957f, 0.16954781f, 
    -0.01772019f, 0.01254513f, 0.07753224f, 0.05767343f, 0.72543991f, -0.19853520f, -0.23870625f, -0.34067798f, 
    0.24990429f, 0.40024588f, -0.02166480f, -0.26308951f, 0.17416285f, 0.24711123f, 0.06348062f, 0.21776365f, 
    0.30284569f, 0.50327361f, -0.04385238f, 0.23910071f, 0.14086261f, 0.18555786f, -0.02906737f, -0.08902555f, 
    -0.17047749f, 0.06093621f, 0.13961497f, -0.12698784f, 0.05830672f, -0.30832407f, 0.12983921f, -0.19791707f, 
    -0.18797649f, 0.04472912f, 0.09603727f, -0.22668901f, -0.00885984f, 0.07956727f, -0.01994891f, 0.12679392f, 
    0.28336450f, 0.00497752f, 0.18614914f, 0.03191160f, 0.19350304f, -0.04525715f, -0.09525284f, -0.11387528f, 
    -0.04774091f, -0.04705705f, -0.08793366f, -0.13653642f, 0.06270636f, -0.19135867f, 0.25652802f, 0.52251160f, 
    0.06899363f, -0.09631998f, 0.06507528f, 0.15755890f, 0.18190500f, 0.14384888f, 0.05464355f, 0.13073276f, 
    0.51695246f, 0.26538035f, 0.32436851f, -0.23577055f, -0.00053716f, -0.17128588f, -0.05877011f, -0.03412022f, 
    0.01536750f, -0.15910660f, -0.20154665f, -0.09554023f, 0.07732140f, -0.31297874f, -0.13394846f, 0.04298149f, 
    0.13878717f, 0.11236811f, 0.20495863f, 0.31738815f, 0.04138095f, 0.18378763f, -0.07470246f, 0.00774286f, 
    -0.13739590f, 0.10431518f, 0.11984876f, -0.43938744f, -0.00815642f, -0.00066888f, 0.13280803f, -0.17901827f, 
    -0.02364115f, 0.26177508f, 0.01587283f, 0.12025356f, -0.01483878f, 0.24205871f, -0.05200977f, 0.08388259f, 
    0.08098456f, 0.08485678f, 0.12340618f, -0.01110857f, 0.07598501f, -0.02812868f, -0.01952618f, 0.15946466f, 
    -0.63897169f, -0.19072026f, 0.06512142f, -0.13766561f, 0.21225363f, -0.09636924f, 0.08330523f, -0.10225870f, 
    -0.10197836f, -0.06615309f, -0.09152196f, -0.01950175f, -0.22185093f, 0.05082243f, 0.02776501f, 0.04276564f, 
    -0.00831441f, -0.02576114f, -0.01631001f, -0.26700076f, -0.01197572f, -0.16091123f, 0.20609269f, -0.05664836f, 
    0.21362358f, -0.07901646f, -0.01105721f, 0.22897665f, -0.28700989f, -0.12295121f, 0.18652456f, 0.10853098f, 
    -0.12904446f, -0.21098235f, -0.07636507f, 0.19427772f, 0.01239870f, 0.58380193f, 0.14479947f, -0.65129840f, 
    -0.15366279f, -0.09950045f, 0.20878221f, -0.04866868f, 0.02740809f, 0.04716375f, 0.23156801f, 0.05511364f, 
    0.15069106f, -0.39793989f, 0.19532703f, -0.01462107f, -0.03140124f, -0.08634235f, -0.16907398f, 0.05084421f, 
    0.05709985f, 0.15774211f, -0.00277753f, -0.06706530f, -0.03611483f, -0.22166273f, -0.23091434f, -0.15362801f, 
    0.11377500f, -0.01513105f, -0.15518963f, 0.19997442f, -0.00657854f, -0.01527318f, -0.12066825f, 0.10350507f, 
    0.53462929f, -0.37331435f, -0.24500556f, -0.07649548f, 0.00353248f, 0.10397149f, 0.00923562f, -0.05933081f, 
    0.23382314f, 0.08887913f, 0.23325311f, 0.27030489f, 0.19900890f, 0.05534188f, 0.34484750f, -0.24413982f, 
    0.08658329f, 0.03273084f, 0.10737579f, 0.21128321f, 0.03561803f, 0.10259393f, 0.03825046f, 0.13183534f, 
    -0.34929359f, -0.26274928f, -0.04692407f, -0.26463968f, 0.21578242f, 0.14012153f, -0.01040294f, 0.06897586f, 
    -0.01085599f, -0.30443701f, -0.05274083f, -0.04726756f, -0.01714743f, 0.48732936f, 0.44626054f, 0.12435228f, 
    -0.00751012f, 0.11256927f, -0.04193347f, -0.04516363f, 0.07641818f, -0.04660732f, 0.06796578f, 0.10544997f, 
    0.03130344f, 0.04084190f, 0.05367406f, -0.00902065f, 0.02620900f, 0.06116436f, -0.04513538f, -0.04590116f, 
    -0.05128039f, -0.03708584f, 0.03752257f, -0.05020531f, -0.06269728f, 0.02794082f, 0.04745601f, 0.04239231f, 
    0.03838089f, 0.03502937f, 0.01168754f, 0.04719912f, -0.02543502f, -0.07831816f, 0.03080256f, 0.03889884f, 
    -0.03102470f, 0.00692921f, -0.01806661f, -0.07895420f, 0.04075329f, -0.00200531f, -0.07590799f, -0.03295748f, 
    -0.00142991f, 0.01836991f, -0.07676006f, -0.03758328f, -0.07955963f, -0.02539274f, 0.03115896f, -0.01159396f, 
    -0.05621716f, 0.04799346f, -0.01654893f, -0.03215891f, -0.07030972f, -0.02059716f, -0.04361508f, -0.02944344f, 
    -0.08282465f, 0.01709786f, 0.00862290f, 0.04697960f, -0.01151633f, -0.02025410f, -0.00595778f, 0.04002124f, 
    -0.00316114f, -0.08270830f, 0.01410705f, 0.00449113f, -0.01506226f, 0.02325032f, -0.04105419f, 0.00771494f, 
    -0.07552974f, -0.01877469f, -0.08272086f, -0.00768527f, 0.00679975f, -0.06012440f, -0.06054556f, -0.08499957f, 
    0.07112736f, 0.06270422f, 0.04079986f, 0.05060787f, -0.00122100f, 0.00256186f, -0.07676032f, 0.03205536f, 
    0.00801603f, 0.04201757f, 0.03753094f, 0.05758008f, -0.00036854f, -0.02093747f, 0.01409105f, -0.01786889f, 
    0.04621776f, -0.03300533f, 0.00785522f, -0.05478368f, 0.03321608f, 0.06373648f, -0.01158777f, -0.06741562f, 
    0.05060695f, 0.00490436f, 0.02657182f, -0.05833187f, -0.05232429f, 0.04094799f, 0.00062055f, 0.01687020f, 
    0.00424802f, 0.05412587f, 0.04571483f, 0.02173789f, -0.05427022f, 0.06395935f, -0.04204819f, 0.03560350f, 
    -0.03089077f, 0.02519638f, -0.03043572f, -0.06786020f, 0.02081977f, -0.01631913f, 0.04879529f, 0.01986646f, 
    -0.03618700f, -0.05002276f, -0.04910253f, 0.03860198f, -0.05873333f, -0.03216916f, 0.01798991f, -0.06984839f, 
    -0.02064464f, 0.03953515f, 0.04073916f, 0.02873547f, -0.03746581f, -0.07788823f, 0.01424710f, 0.01380925f, 
    -0.00566353f, 0.00811115f, 0.03120341f, -0.01971162f, -0.03915844f, 0.03018316f, -0.05524583f, 0.00113428f, 
    -0.00609744f, -0.00450426f, -0.07331938f, -0.00359217f, 0.00477156f, 0.02414446f, 0.00953392f, 0.03694984f, 
    -0.03582704f, -0.02472057f, 0.03342583f, 0.03713119f, 0.06812642f, 0.01688410f, 0.02220077f, -0.04890126f, 
    -0.05853349f, -0.00359224f, -0.06440243f, 0.05043346f, -0.02038684f, -0.07139348f, 0.01273638f, -0.07692415f, 
    -0.04566981f, -0.02951425f, -0.01251835f, -0.05556050f, 0.01671557f, -0.06915788f, -0.00080902f, -0.04197074f, 
    0.03716828f, -0.00818883f, -0.04607426f, -0.03171691f, -0.06119302f, 0.02548010f, 0.03731351f, -0.05174752f, 
    -0.08395145f, 0.00078932f, 0.03836521f, -0.01215601f, 0.04491768f, -0.04099427f, -0.04715401f, -0.07228472f, 
    -0.80105239f, -0.11358637f, -0.17284310f, -0.06114693f, -0.05261578f, -0.06111073f, 0.18257000f, 0.06998345f, 
    -0.07710402f, -0.13173327f, -0.17970249f, -0.00368274f, -0.24201429f, 0.25970054f, -0.24466017f, -0.40572968f, 
    -0.00638356f, 0.03957055f, -0.02375750f, -0.11610472f, -0.19322212f, -0.01704650f, -0.00106000f, -0.13360158f, 
    0.02456861f, -0.07198204f, 0.21737455f, 0.09457949f, -0.02317595f, 0.00894572f, 0.23573951f, 0.27486300f, 
    0.06838700f, 0.00872442f, 0.23180887f, 0.06435267f, 0.25361338f, 0.39165702f, -0.10098793f, -0.14202054f, 
    -0.03447433f, -0.10495339f, -0.11620483f, -0.29968548f, 0.07708917f, -0.00484839f, -0.01048888f, 0.12129771f, 
    0.11306437f, 0.10766805f, -0.03703852f, 0.03548035f, 0.21584953f, 0.09965635f, -0.13304250f, 0.16556953f, 
    0.08337959f, -0.00340944f, -0.05262448f, -0.23188680f, -0.06976039f, -0.04549553f, -0.17917387f, -0.14105189f, 
    0.10542018f, 0.17984264f, -0.10404301f, -0.08174142f, -0.03655781f, 0.06681499f, 0.02364318f, -0.06916820f, 
    0.25108376f, 0.24645627f, 0.01224274f, 0.24225968f, -0.09867254f, 0.11945196f, -0.30425182f, 0.05980670f, 
    -0.02218478f, 0.03267110f, 0.24677628f, 0.08945366f, 0.72734356f, 0.21031545f, -0.08460017f, 0.05723260f, 
    -0.09665734f, 0.22004251f, 0.03998142f, 0.15484281f, -0.21789554f, 0.24806274f, 0.12863125f, 0.07588004f, 
    -0.05540961f, 0.10021642f, 0.19135636f, 0.02931225f, 0.08498178f, 0.31692803f, 0.05775554f, 0.06104181f, 
    0.01356440f, 0.22401848f, 0.19232741f, -0.09484342f, -0.41131565f, -0.40848437f, -0.24190550f, 0.35372457f, 
    0.07369084f, -0.01684269f, -0.09791401f, -0.10361893f, -0.10112407f, -0.18746351f, -0.18227799f, -0.00034821f, 
    -0.23831499f, 0.14295326f, -0.02634683f, 0.00972769f, 0.15181030f, 0.14779644f, 0.16649784f, -0.02727836f, 
    0.06479543f, -0.01906840f, 0.06892505f, -0.05182323f, -0.10814463f, 0.27464110f, -0.02763791f, 0.20220301f, 
    -0.03343072f, -0.00817485f, 0.31603396f, 0.11909223f, -0.04477755f, -0.13160668f, 0.04421314f, -0.06651827f, 
    0.28423947f, 0.32738680f, -0.01017124f, 0.20718935f, 0.14837351f, 0.15334210f, -0.13755712f, 0.10398249f, 
    -0.11868598f, 0.02138377f, 0.02224992f, -0.32145590f, -0.22807938f, 0.20846449f, 0.07063168f, 0.25807416f, 
    -0.32280934f, -0.03988407f, 0.31961611f, -0.03257657f, -0.03910857f, -0.14682986f, -0.05919544f, 0.02064760f, 
    0.04763311f, 0.36692253f, 0.00320964f, 0.18996474f, -0.15739593f, -0.15061945f, -0.18606167f, -0.03984692f, 
    -0.05061857f, 0.47825384f, 0.23767109f, 0.05289581f, -0.08524905f, -0.25543901f, -0.28961134f, -0.38027477f, 
    0.08274175f, -0.07863765f, -0.03492299f, 0.13664542f, 0.03122458f, 0.16241936f, 0.06330495f, 0.05584738f, 
    0.20944841f, 0.38223734f, 0.34915146f, 0.09078675f, 0.13377450f, -0.08600131f, -0.10347900f, -0.11223320f, 
    -0.07772245f, 0.00559287f, 0.04805938f, 0.07661860f, 0.50738424f, 0.07301393f, 0.28812513f, 0.08417394f, 
    -0.03890253f, -0.08475251f, -0.00566471f, -0.08099458f, 0.26401183f, 0.07914912f, 0.10443479f, 0.05415373f, 
    -0.46433914f, -0.44180965f, -0.21374679f, 0.09169324f, 0.14650968f, -0.00815773f, 0.18748164f, 0.04804325f, 
    -0.10111184f, 0.01067472f, 0.04371564f, -0.11107093f, -0.33059415f, -0.15440778f, -0.04873829f, -0.07952500f, 
    0.10071489f, 0.05858288f, -0.12474459f, 0.03660060f, -0.11338085f, 0.06173303f, -0.03349356f, -0.07159054f, 
    -0.10617366f, 0.16383466f, 0.17366369f, 0.25929645f, -0.20070204f, -0.09015244f, 0.29204804f, -0.12846866f, 
    -0.01719354f, -0.12433773f, 0.24273837f, 0.07903046f, 0.26830149f, 0.56218940f, 0.48460582f, 0.10863592f, 
    -0.12598655f, -0.10059390f, 0.07127441f, 0.00296490f, -0.01286807f, 0.13692741f, -0.05047869f, 0.24373648f, 
    0.05661263f, -0.10117144f, -0.16556846f, -0.19464387f, 0.09248019f, 0.00448737f, 0.11933456f, 0.04006673f, 
    0.04501871f, -0.10009053f, -0.09761053f, -0.05141009f, 0.11629096f, -0.16400798f, 0.13576068f, -0.02740773f, 
    0.08279471f, 0.13219337f, 0.11502936f, -0.01677335f, -0.06092218f, 0.01280551f, -0.00003649f, 0.01576312f, 
    -0.11985407f, -0.13668235f, -0.03271657f, -0.15383518f, 0.07442495f, 0.11568242f, 0.04105775f, 0.12007407f, 
    -0.09974471f, 0.03708221f, 0.03290903f, 0.08267346f, 0.05777579f, 0.07280390f, -0.14333613f, -0.09873645f, 
    -0.01355812f, 0.04382128f, 0.04230456f, 0.02479901f, 0.16345443f, -0.05156926f, 0.01767708f, -0.13296470f, 
    0.52557635f, -0.51721585f, 0.12111759f, -0.24577697f, -0.19192086f, 0.07752799f, 0.02853415f, 0.00076427f, 
    0.11313852f, -0.05533230f, -0.09911179f, -0.11766408f, -0.04642711f, 0.11665312f, 0.09307130f, 0.23735677f, 
    -0.10743467f, -0.05719861f, -0.04719543f, -0.07937448f, 0.10976192f, -0.02468616f, 0.04034569f, 0.10297998f, 
    0.23410054f, -0.16890910f, 0.15696166f, 0.14667562f, 0.02703729f, 0.02246300f, -0.07269482f, -0.12866397f, 
    -0.11556005f, -0.05166497f, -0.08612832f, 0.04739093f, 0.01221767f, -0.25828570f, -0.32202214f, 0.22977300f, 
    0.26986453f, -0.03033223f, -0.08911466f, -0.13047156f, -0.10146700f, -0.05051510f, 0.05303333f, -0.16098738f, 
    -0.20337680f, -0.28973418f, 0.06065610f, 0.04001127f, 0.15318745f, 0.15623993f, -0.01488117f, -0.00482144f, 
    -0.05477794f, -0.10563961f, -0.02053137f, 0.09326860f, -0.14750457f, 0.09244160f, 0.40359941f, 0.29464492f, 
    -0.10111187f, 0.05460063f, -0.01156292f, -0.19662298f, 0.17395151f, -0.03927917f, -0.08148985f, -0.07203469f, 
    -0.18343726f, -0.35033298f, 0.12893662f, -0.27805594f, 0.04358624f, 0.14826162f, -0.07364600f, -0.06983032f, 
    0.06861042f, 0.04072908f, 0.19786103f, 0.09587774f, 0.51230460f, -0.31995612f, -0.23578651f, -0.08935062f, 
    -0.11685885f, 0.00819243f, 0.07333184f, 0.00750156f, 0.17536949f, 0.03463931f, 0.05634901f, 0.15889639f, 
    -0.07020602f, -0.20136374f, -0.07039121f, 0.13419637f, -0.20052814f, -0.15278758f, 0.16377322f, 0.04788665f, 
    0.04166748f, 0.07783249f, 0.10055885f, 0.01517197f, 0.16204888f, 0.21933183f, 0.02262990f, -0.07157831f, 
    -0.03975048f, -0.15751682f, -0.01374177f, 0.17172638f, 0.07016023f, 0.11461414f, 0.19763540f, 0.12091672f, 
    0.00095029f, -0.09903549f, 0.23916699f, 0.36358678f, 0.23077330f, 0.06674982f, 0.15932736f, -0.12768413f, 
    -0.00989577f, -0.08821578f, 0.22334951f, 0.17943566f, -0.43670365f, 0.21307693f, 0.20079875f, 0.08661941f, 
    -0.05091701f, -0.03369496f, 0.04682111f, 0.10020114f, 0.02281050f, 0.03534003f, -0.04287451f, 0.08588263f, 
    0.22646984f, -0.04159881f, -0.07926258f, 0.35160163f, -0.17299694f, -0.12778924f, 0.12924473f, 0.09423657f, 
    0.23060925f, 0.19114459f, -0.04954910f, 0.11415938f, -0.80793852f, 0.03034738f, 0.05792179f, -0.07543121f, 
    0.05776544f, 0.09390277f, 0.00846266f, 0.00669000f, 0.15884577f, 0.09599655f, -0.16499387f, -0.01110693f, 
    -0.18761103f, 0.06574084f, -0.02023123f, -0.24935155f, 0.07743245f, 0.02502434f, -0.02022602f, 0.07532419f, 
    0.05953915f, 0.17708372f, -0.14071251f, -0.00101871f, 0.17713761f, -0.43154132f, 0.28524989f, 0.10803047f, 
    0.01258728f, 0.06887241f, 0.01365237f, 0.16368809f, 0.07783053f, 0.19675240f, 0.01342692f, -0.00413927f, 
    0.18026952f, -0.15530117f, -0.07055714f, -0.07682447f, 0.15572545f, -0.06143727f, 0.20168249f, -0.03286638f, 
    0.03006468f, 0.00745538f, 0.01118398f, 0.16254480f, 0.00821474f, 0.07023260f, 0.39445567f, 0.22574294f, 
    0.15234916f, 0.21908750f, 0.23245203f, -0.17959575f, 0.04454116f, 0.23719826f, -0.06350172f, 0.18668319f, 
    -0.11951253f, 0.29351437f, 0.36467755f, 0.11300602f, -0.01911165f, -0.07712984f, -0.04888053f, 0.14629789f, 
    -0.10331227f, -0.01221873f, -0.07045937f, 0.04474332f, 0.02242519f, -0.55575162f, -0.10145156f, 0.04601746f, 
    0.04026348f, 0.01740340f, -0.10126026f, -0.08856767f, 0.03320653f, 0.27767289f, -0.03356272f, -0.16787836f, 
    0.28200361f, -0.14004402f, -0.04268192f, -0.17412846f, -0.13672805f, 0.27526137f, 0.30292895f, 0.05859106f, 
    -0.07857066f, -0.06402688f, -0.07732282f, -0.06546478f, -0.21134453f, -0.25105968f, 0.01842161f, -0.27848718f, 
    0.14461048f, 0.15043798f, -0.12591815f, 0.02817311f, -0.09591380f, -0.01487867f, 0.09926254f, 0.08275662f, 
    -0.01315881f, 0.18331969f, -0.16262171f, 0.14993957f, -0.07148704f, -0.11521102f, 0.02771521f, 0.06010297f, 
    0.01219083f, 0.02283472f, -0.26305798f, -0.09855502f, -0.06042958f, 0.20483096f, 0.05732757f, 0.11325137f, 
    0.14101812f, 0.01015832f, 0.01479834f, 0.07844538f, -0.01802471f, 0.06762387f, 0.00915066f, -0.02864068f, 
    0.55267709f, -0.13521516f, 0.19487408f, -0.24473873f, 0.14225282f, -0.04652390f, -0.00039191f, 0.10450359f, 
    0.02440666f, -0.07018098f, -0.01671253f, -0.01801126f, -0.25203437f, -0.10487486f, -0.15105198f, -0.28908104f, 
    -0.23944584f, -0.01844580f, -0.02930805f, -0.08104812f, 0.01067623f, 0.07966955f, -0.07061765f, -0.06979474f, 
    0.23023926f, 0.28552377f, -0.15773842f, -0.43055591f, 0.07127545f, 0.13310823f, -0.00518369f, 0.08441824f, 
    0.15211233f, 0.07450614f, -0.05861462f, -0.09742093f, 0.51345891f, 0.08467441f, -0.12716986f, -0.16842571f, 
    0.19764291f, 0.11227304f, -0.04710353f, -0.01373449f, 0.06476060f, 0.07799505f, -0.13787618f, 0.01764898f, 
    -0.26828921f, -0.17140430f, 0.06956460f, -0.20637323f, 0.04668738f, 0.07243558f, 0.08313315f, -0.02337234f, 
    -0.08939622f, -0.07910888f, 0.13504350f, 0.06248855f, 0.87018532f, -0.18255338f, 0.03697398f, 0.10554512f, 
    -0.25023732f, 0.09028640f, 0.15516856f, 0.00332273f, -0.01937777f, 0.11790916f, 0.12443981f, -0.00807477f, 
    0.08427958f, -0.25545785f, -0.03648252f, 0.33520409f, 0.15010464f, 0.07660286f, 0.06829035f, 0.04243413f, 
    -0.02031548f, 0.01979555f, 0.06259993f, 0.10900536f, -0.13303973f, 0.40627256f, -0.31572199f, 0.04181900f, 
    0.02006170f, 0.10596129f, -0.04392515f, -0.25468621f, 0.06217987f, -0.15250853f, 0.04071062f, -0.09669448f, 
    0.01859897f, -0.07961891f, 0.09417692f, 0.21431895f, -0.04419968f, 0.06056032f, 0.00743532f, 0.03776392f, 
    0.25593820f, 0.12862073f, 0.08106466f, -0.02344529f, -0.06036443f, -0.00552413f, -0.30182639f, 0.04914643f, 
    -0.01686769f, 0.06966940f, -0.02352109f, 0.29191527f, 0.04655674f, -0.07043906f, -0.05760378f, -0.08064448f, 
    0.27117711f, -0.07792943f, -0.57423639f, -0.02668566f, 0.27176178f, 0.06257278f, 0.03046107f, 0.08301351f, 
    0.07144077f, 0.01318211f, 0.14020556f, -0.02091582f, -0.14549442f, 0.17338689f, 0.18022148f, -0.21477753f, 
    -0.26144716f, 0.03893268f, 0.19482456f, 0.04565299f, 0.04083003f, -0.06128543f, 0.03748722f, 0.06667319f, 
    -0.59131402f, 0.01653543f, 0.06573576f, -0.12152631f, -0.03630515f, -0.29261962f, -0.24730109f, -0.01029286f, 
    0.16366377f, 0.09812780f, -0.00203791f, 0.05335992f, 0.20040326f, 0.30501878f, 0.08281922f, -0.05098318f, 
    -0.01950062f, 0.01664285f, 0.04307330f, 0.09992890f, 0.19107907f, 0.21300724f, 0.09330165f, 0.10135178f, 
    -0.00590110f, -0.07670786f, 0.03979689f, 0.00947464f, 0.03528186f, 0.06343893f, 0.03522548f, -0.00933187f, 
    -0.04415807f, 0.05995797f, -0.01690242f, 0.05546224f, -0.02969118f, 0.00989123f, -0.03451258f, -0.07791897f, 
    -0.05592799f, -0.06074813f, -0.06975746f, -0.01320760f, 0.05293756f, 0.00269777f, 0.06485366f, 0.02399122f, 
    -0.02432425f, -0.00346584f, -0.07601366f, -0.05610088f, -0.00463163f, -0.03614764f, -0.02977672f, -0.05194234f, 
    0.01079706f, -0.06769131f, -0.07164838f, -0.07362270f, 0.00025868f, -0.04535940f, -0.07312314f, -0.06837631f, 
    0.05402150f, 0.02071355f, -0.04883263f, 0.02729457f, 0.03284926f, -0.03878699f, 0.00355124f, 0.03075712f, 
    -0.06800986f, -0.06446234f, -0.07855304f, -0.01863731f, -0.03205554f, -0.03347891f, -0.04828903f, 0.04812415f, 
    -0.00875405f, 0.05566820f, 0.03485378f, -0.08086329f, -0.01687544f, 0.04400410f, -0.06516392f, -0.04069286f, 
    -0.01980990f, 0.03893396f, 0.05454047f, 0.04332394f, -0.01574659f, 0.03344631f, -0.02054066f, -0.00266965f, 
    0.03934373f, 0.03279996f, 0.02394840f, -0.03553302f, 0.03358677f, -0.06168361f, -0.01910571f, -0.05935231f, 
    -0.07196947f, -0.02354234f, -0.06701913f, 0.03448171f, -0.02308445f, -0.02728597f, -0.06625005f, -0.04260966f, 
    -0.03109508f, 0.00140460f, -0.04789357f, -0.05473339f, -0.00793052f, -0.06255087f, -0.03028660f, 0.02708916f, 
    -0.01014832f, 0.03341449f, 0.03427186f, 0.04073124f, 0.05499344f, 0.06375577f, 0.04590163f, -0.04885116f, 
    -0.06895887f, -0.02209730f, -0.04158362f, -0.00425361f, -0.04620769f, -0.04245246f, -0.02026139f, 0.02824897f, 
    0.05305690f, -0.01206100f, 0.04414184f, 0.00254947f, -0.06656200f, -0.03108328f, 0.00821321f, -0.07230873f, 
    0.04240670f, -0.03474207f, -0.01491092f, -0.04970599f, 0.02531854f, 0.06153060f, 0.01281327f, -0.04435153f, 
    -0.05878324f, -0.05702285f, -0.04181729f, -0.03852750f, -0.06488356f, -0.02199080f, 0.03966366f, 0.06101172f, 
    -0.06507634f, 0.05979962f, 0.00060397f, -0.00879912f, 0.03591647f, -0.01135316f, 0.05701128f, 0.00651818f, 
    -0.02970473f, 0.06306386f, 0.01824764f, -0.02896612f, -0.01664391f, -0.03794867f, -0.04060684f, -0.07655515f, 
    0.00791784f, -0.02592703f, 0.03919786f, -0.06018242f, 0.05337090f, -0.07404611f, -0.02132246f, 0.06364820f, 
    -0.01783800f, 0.06328461f, -0.04433556f, -0.06159938f, 0.05476037f, -0.02774226f, -0.04031784f, -0.04197977f, 
    0.02193346f, 0.03179193f, 0.00243457f, 0.06350455f, 0.02591067f, -0.04005259f, 0.05047112f, -0.05727940f, 
    0.03057503f, 0.01182852f, -0.02262360f, 0.05856303f, 0.04760160f, 0.02962770f, 0.01982115f, -0.01933191f, 
    -0.02139758f, 0.01047805f, 0.05819186f, 0.02956393f, -0.00376235f, -0.03459140f, -0.03859986f, 0.05727683f, 
    -0.07219246f, -0.01802912f, -0.00131763f, -0.05181918f, -0.02722284f, -0.07789650f, 0.03970196f, 0.05610163f, 
    0.04209437f, -0.05242303f, 0.00930184f, 0.03898476f, -0.06291076f, -0.08105846f, 0.05971890f, 0.04694442f, 
    0.05313207f, -0.07762378f, -0.03187632f, 0.01781398f, -0.01487052f, 0.03138689f, 0.02475200f, 0.01887329f, 
    0.00135305f, 0.04050732f, 0.03728950f, 0.00264506f, 0.03118199f, -0.06852401f, 0.03309144f, -0.01213178f, 
    0.00880229f, 0.01204789f, 0.03185842f, 0.03696159f, 0.06942116f, 0.02496159f, -0.04512309f, -0.03505737f, 
    -0.06146385f, -0.06504643f, -0.06476294f, -0.07802171f, -0.01616474f, -0.03176243f, -0.00818343f, -0.01007702f, 
    0.01223010f, 0.00243690f, -0.06977005f, 0.05372841f, -0.03220957f, 0.00452233f, -0.02463093f, 0.05745309f, 
    -0.03197474f, -0.00193135f, 0.04351138f, -0.04434908f, -0.06727418f, 0.02541894f, -0.01751404f, 0.02697203f, 
    -0.05024987f, -0.06230435f, -0.00559178f, 0.04898288f, -0.02395159f, 0.02214511f, -0.00593761f, -0.07779355f, 
    -0.04282963f, -0.05397163f, -0.00072334f, 0.01354647f, 0.01629934f, 0.01719293f, -0.02364914f, -0.02425357f, 
    -0.01663467f, -0.01956815f, 0.02404975f, -0.01658365f, -0.02293416f, -0.06937669f, 0.01754818f, -0.03410319f, 
    0.00778805f, 0.06142801f, -0.06427321f, 0.01609351f, -0.04860526f, -0.00611137f, -0.05459046f, 0.02945805f, 
    0.00314286f, -0.01093319f, -0.02605486f, 0.01366183f, -0.03540849f, 0.04461903f, -0.07667674f, -0.00121994f, 
    -0.05429436f, 0.00397744f, 0.04542070f, -0.04579806f, -0.01341113f, -0.04899843f, 0.04514699f, -0.05472266f, 
    -0.03216769f, -0.03833349f, -0.05201314f, 0.06660807f, 0.00178473f, 0.03139237f, 0.00857838f, 0.04959032f, 
    0.01253522f, -0.03095791f, 0.04173277f, 0.02374183f, -0.07529217f, -0.05856640f, 0.02333381f, -0.00073627f, 
    0.02469148f, -0.04679599f, 0.06277052f, -0.02951991f, -0.00722336f, 0.00973542f, 0.02261903f, -0.01441711f, 
    -0.01374530f, -0.04593445f, 0.01183546f, -0.00845120f, -0.06311667f, -0.00434250f, -0.00887203f, 0.03147858f, 
    0.01367273f, 0.03279410f, -0.02968975f, 0.02417596f, -0.07915348f, 0.04722060f, -0.05668115f, -0.00662504f, 
    -0.07511400f, 0.03844414f, 0.04745736f, 0.05251487f, -0.07804090f, 0.02659906f, 0.01105795f, 0.03073399f, 
    -0.02579140f, -0.07606069f, 0.04653397f, 0.04930678f, 0.00716111f, 0.05788124f, -0.07241131f, 0.02733655f, 
    -0.06538919f, 0.06890173f, 0.01910581f, 0.03548662f, 0.01547623f, -0.06757926f, 0.02967928f, -0.00606778f, 
    0.03446546f, 0.02728046f, 0.01943769f, 0.00330047f, -0.04552807f, -0.04160805f, -0.02338987f, -0.04280126f, 
    -0.07225338f, -0.08080277f, 0.04290129f, 0.01750810f, 0.00062086f, -0.01287755f, -0.07760747f, -0.03916462f, 
    0.00552932f, -0.01834612f, 0.01452020f, -0.02925751f, 0.06511684f, 0.06101335f, 0.07089112f, -0.05634085f, 
    0.02737574f, 0.02304289f, -0.02843354f, -0.00651337f, 0.05565524f, -0.00173041f, 0.03031939f, 0.03670581f, 
    0.05189902f, -0.00009424f, 0.00266732f, -0.02311613f, 0.05047613f, -0.00118696f, -0.05546055f, -0.06709457f, 
    -0.01318910f, -0.05721952f, 0.02452970f, -0.01816007f, 0.02843216f, 0.01749463f, -0.01390464f, 0.03269935f, 
    -0.06651759f, -0.04988451f, -0.04140516f, -0.01795537f, 0.03762083f, -0.00665092f, 0.02981561f, 0.05028075f, 
    0.06093536f, -0.04115642f, -0.01744995f, -0.07204673f, 0.04423716f, -0.00743464f, 0.05568753f, -0.03233584f, 
    -0.03422348f, 0.02435991f, -0.05575448f, -0.07078574f, 0.01519602f, 0.02629634f, -0.04327674f, -0.06292173f, 
    -0.05193859f, -0.06740139f, -0.05876366f, -0.00057939f, -0.01614945f, 0.02141134f, 0.02721866f, -0.02414904f, 
    0.01669077f, 0.02278261f, -0.05491365f, -0.01736143f, 0.00101479f, -0.04302689f, -0.07058369f, -0.06874775f, 
    -0.01426603f, -0.05363593f, -0.04959051f, -0.07037999f, 0.00353988f, -0.01472343f, -0.02596957f, 0.03400665f, 
    0.04302782f, -0.01836395f, 0.05857859f, -0.05620931f, -0.04681665f, -0.04526651f, -0.04959987f, 0.03512681f, 
    -0.00514915f, -0.04027518f, 0.05313466f, 0.05787006f, -0.00586313f, -0.06544566f, -0.03990684f, 0.02613188f, 
    0.06185701f, 0.06984608f, 0.01859248f, 0.04945784f, 0.04699488f, 0.03353726f, 0.00424967f, 0.02403143f, 
    0.02249262f, -0.06568885f, 0.02560994f, -0.01857752f, -0.03962248f, -0.00786411f, -0.02464572f, 0.02819996f, 
    0.06184504f, -0.05955666f, -0.04125873f, -0.00010329f, -0.03949168f, 0.04997255f, 0.01979565f, -0.00226153f, 
    -0.06898950f, -0.07214249f, -0.04314259f, -0.01561828f, -0.01052079f, -0.07148445f, -0.05473201f, -0.06625962f, 
    -0.05802144f, 0.06771985f, 0.00668818f, -0.01885537f, -0.01086809f, 0.04987789f, 0.01215579f, -0.03917855f, 
    0.04706133f, 0.00609428f, -0.04503545f, -0.04327356f, -0.06703044f, -0.00387556f, 0.03972915f, -0.04423340f, 
    0.02317363f, 0.03258579f, -0.04245054f, -0.04221136f, -0.00062623f, -0.01597222f, -0.04630451f, -0.05356805f, 
    0.03304341f, 0.05548939f, 0.04322413f, -0.04556503f, -0.06918281f, 0.04483348f, -0.05392471f, 0.06861058f, 
    -0.03330541f, -0.06062530f, 0.03499470f, 0.04191203f, 0.03639495f, 0.04002723f, 0.02632795f, -0.01594394f, 
    -0.03287223f, 0.06356614f, -0.00774274f, -0.06470930f, 0.02551011f, -0.05159459f, 0.02336951f, 0.06554441f, 
    -0.04205284f, -0.06707913f, -0.00411279f, -0.00158788f, -0.03699022f, -0.06368212f, -0.06685001f, 0.01116008f, 
    -0.06493179f, 0.04231190f, -0.03023589f, -0.04140222f, 0.03164211f, -0.07168522f, -0.00666768f, -0.01713755f, 
    -0.13542318f, 0.25116289f, 0.24292290f, 0.05268687f, 0.00212316f, 0.03360890f, 0.21153958f, -0.04624832f, 
    0.07807719f, 0.01562286f, -0.00568421f, 0.01001088f, -0.34448579f, 0.41511002f, 0.04583126f, -0.63310993f, 
    0.22089930f, -0.05636649f, 0.05063745f, -0.06188210f, 0.15816794f, -0.11737674f, 0.06668329f, 0.08557158f, 
    -0.17967218f, 0.09174314f, -0.22893201f, 0.25874472f, 0.03013663f, 0.16466784f, -0.11302827f, 0.07197200f, 
    0.03855512f, 0.05588710f, 0.05614731f, -0.04346111f, 0.34315026f, -0.15244932f, -0.26501006f, 0.17854071f, 
    0.24517514f, 0.16114144f, -0.12371220f, -0.05485874f, -0.08346543f, 0.05603436f, -0.01525358f, 0.17956963f, 
    -0.24753775f, 0.04624261f, 0.05515613f, 0.07053526f, 0.05231802f, 0.07528221f, -0.01301353f, 0.09618225f, 
    -0.17793648f, -0.06471967f, 0.02177966f, 0.07865325f, 0.09103151f, 0.01043222f, 0.08194188f, -0.32454798f, 
    0.10625578f, 0.15656354f, -0.04814281f, 0.01576890f, -0.25244728f, -0.02802893f, 0.06930751f, 0.08153711f, 
    -0.42057067f, 0.15524164f, 0.01521293f, 0.19797853f, -0.09958993f, 0.12444061f, -0.05066247f, -0.01103173f, 
    0.14195655f, 0.19009157f, 0.06043712f, 0.02472312f, -0.04227882f, 0.25869870f, 0.02606352f, 0.22184564f, 
    0.02725783f, 0.05663610f, -0.01279444f, -0.13008346f, -0.08520886f, 0.10871080f, 0.00234922f, -0.14261204f, 
    0.00237071f, 0.31262523f, 0.16920620f, -0.23852827f, -0.27150178f, 0.06432806f, 0.19171363f, -0.01218697f, 
    0.01235944f, 0.06467060f, -0.08373343f, -0.12852590f, -0.11079697f, -0.24026194f, 0.07329617f, 0.29231212f, 
    -0.01978954f, 0.16958700f, 0.16374718f, -0.04533263f, 0.15845758f, 0.07981443f, -0.10483239f, -0.13121279f, 
    -0.29136464f, 0.38876480f, -0.11516891f, -0.64918464f, 0.05979395f, 0.01777492f, -0.07326634f, 0.10916263f, 
    -0.02451800f, 0.00808148f, 0.07038610f, -0.02730548f, 0.05421636f, -0.25376597f, 0.04581357f, 0.26823065f, 
    0.18184224f, -0.04365960f, 0.09720988f, 0.08582282f, -0.06791914f, -0.15114203f, 0.13947186f, 0.10276418f, 
    0.67051834f, -0.18735044f, 0.14798962f, -0.18400683f, -0.07623389f, 0.03216198f, -0.00686719f, -0.11029216f, 
    0.07558739f, -0.14780352f, 0.03868599f, 0.00649085f, -0.06566411f, 0.12836291f, -0.15545289f, 0.21275930f, 
    0.11581697f, 0.03863462f, -0.05012532f, -0.06285229f, 0.03068817f, -0.01333967f, 0.14070499f, 0.02365104f, 
    0.04947593f, -0.14283569f, 0.14025912f, 0.44563496f, 0.17555600f, 0.07278989f, -0.05869655f, 0.15257241f, 
    0.07121921f, 0.03070995f, 0.00859621f, 0.03570295f, -0.14887473f, 0.15943198f, 0.06170499f, -0.00740659f, 
    -0.02062130f, -0.01988533f, 0.11801238f, -0.07544901f, 0.03963771f, -0.01027747f, 0.03306267f, 0.10549690f, 
    -0.07431178f, 0.06891026f, -0.04357949f, 0.04833739f, -0.07793114f, 0.00337728f, -0.04986692f, 0.06422475f, 
    0.01950559f, -0.00431325f, -0.03283563f, -0.02299336f, -0.06686546f, 0.01764347f, -0.07181643f, -0.01542785f, 
    -0.04984489f, 0.02880883f, -0.03884211f, 0.03249891f, -0.07672590f, -0.02037315f, 0.03224941f, 0.03254357f, 
    0.00021482f, -0.03593010f, -0.06889159f, -0.06706324f, 0.01442012f, -0.05755175f, -0.04420647f, 0.02413484f, 
    -0.07197319f, -0.02366846f, 0.02310902f, -0.04123162f, -0.00576857f, 0.04791123f, -0.03054201f, -0.04161132f, 
    0.03711672f, -0.01542630f, -0.02087704f, 0.00677499f, -0.02105786f, 0.03498309f, 0.06456546f, -0.00537795f, 
    -0.00845831f, -0.01048497f, 0.02675554f, 0.01484447f, 0.02238864f, 0.00962990f, -0.05985142f, 0.03893322f, 
    -0.05412044f, -0.00206512f, -0.02931080f, -0.03435349f, 0.02753812f, 0.01767776f, -0.03011046f, -0.00345783f, 
    -0.03715577f, -0.02667137f, -0.04047019f, -0.02659297f, 0.06346669f, -0.02393526f, -0.00361536f, -0.00369055f, 
    -0.03900401f, -0.08243284f, -0.04347162f, -0.05277462f, 0.00585695f, -0.06552535f, -0.07112665f, -0.01745612f, 
    -0.04684843f, -0.04787697f, 0.03460174f, -0.03899045f, -0.01917663f, -0.01302297f, 0.02321655f, 0.02617122f, 
    0.01402850f, 0.04774824f, -0.03583720f, -0.07437831f, 0.06590626f, 0.00854885f, -0.05159890f, 0.02840667f, 
    0.04846964f, 0.01262837f, -0.04234004f, -0.00731568f, -0.02316747f, -0.02344634f, -0.07273441f, -0.07494572f, 
    -0.07519279f, -0.01306415f, -0.00564810f, 0.05783287f, -0.00465307f, -0.03194370f, 0.01505574f, 0.03713743f, 
    0.06291892f, -0.01284594f, 0.06355467f, 0.02405112f, -0.02385046f, -0.05007514f, -0.01591794f, 0.01743728f, 
    0.03073613f, 0.03072083f, -0.00322952f, -0.05590588f, -0.06624098f, 0.05323561f, 0.02094826f, -0.05240886f, 
    -0.04550733f, -0.03444896f, 0.00404676f, 0.03823771f, -0.07870150f, -0.06313851f, -0.01557710f, 0.01557817f, 
    0.02115587f, 0.04387398f, -0.02946607f, -0.03347629f, -0.01474623f, 0.03036206f, 0.03371421f, -0.07219206f, 
    0.01252461f, -0.00950092f, 0.04338514f, -0.00938758f, 0.04406954f, -0.06171286f, -0.01653008f, -0.03719551f, 
    0.05163974f, 0.05582062f, 0.05679716f, -0.00242142f, 0.01120106f, 0.04403081f, 0.01173959f, 0.04960451f, 
    0.02723348f, -0.05761142f, 0.02132904f, -0.07352251f, 0.04226466f, -0.00223723f, 0.05049243f, -0.01214930f, 
    -0.01534416f, 0.04430762f, -0.04770490f, 0.04604931f, 0.04325725f, -0.07758253f, 0.04427290f, 0.05767106f, 
    -0.01497071f, 0.00711488f, 0.03331226f, 0.03819842f, -0.05868475f, 0.04290811f, -0.00951782f, -0.07193856f, 
    -0.01978829f, 0.00978910f, -0.05801348f, 0.00684805f, 0.05743499f, -0.05008189f, -0.02591798f, 0.05842035f, 
    -0.08779889f, 0.06297698f, -0.01786652f, -0.15103394f, 0.04854493f, 0.16794044f, 0.01709687f, 0.24092142f, 
    0.08780378f, 0.12309841f, -0.08884040f, -0.00980355f, 0.16699480f, -0.00783463f, 0.06922847f, 0.15859188f, 
    -0.30598366f, 0.03427574f, -0.04312618f, -0.05887239f, -0.23012054f, -0.00560241f, 0.00214609f, -0.14628123f, 
    -0.33623317f, -0.01473567f, 0.16596404f, 0.07254618f, 0.00221627f, 0.13406044f, 0.20234562f, 0.21371469f, 
    0.09010153f, 0.13911276f, 0.13368212f, 0.29943663f, 0.08544100f, 0.26560387f, 0.37563947f, -0.09227820f, 
    0.01963446f, -0.12933791f, 0.06246238f, 0.15422826f, 0.10643095f, -0.03743760f, 0.02171807f, -0.08484161f, 
    -0.13150629f, -0.00178375f, 0.20436670f, -0.04516534f, 0.03737498f, -0.01757491f, -0.08025575f, 0.18091494f, 
    0.08749302f, -0.03571159f, -0.04022097f, -0.13491973f, -0.38150817f, -0.13502511f, 0.25110903f, 0.01375851f, 
    -0.11686835f, -0.17504072f, -0.20670125f, 0.03147786f, 0.11448976f, 0.12493417f, -0.00242163f, 0.03212520f, 
    0.36141232f, 0.15241905f, 0.08150373f, 0.08846777f, -0.09838641f, -0.00260784f, -0.04079094f, 0.08003069f, 
    0.04032655f, 0.03593337f, -0.03725875f, 0.20588818f, 0.25628775f, 0.18710220f, -0.00130961f, -0.11376929f, 
    -0.06001185f, -0.08108313f, -0.16561384f, 0.17346175f, 0.00742822f, 0.29762912f, -0.00593873f, 0.09568577f, 
    -0.14868520f, 0.07092259f, -0.08640932f, 0.10480972f, 0.07234461f, 0.27592731f, -0.02003768f, -0.01296738f, 
    -0.04956330f, 0.23201670f, 0.10338548f, 0.02758363f, -0.25799143f, -0.39483595f, -0.01671991f, -0.02101167f, 
    0.09655205f, -0.05809110f, -0.11094557f, -0.10752287f, -0.08449186f, 0.01022088f, -0.10592508f, -0.18607651f, 
    0.14948365f, 0.18094398f, 0.05933345f, 0.48088723f, -0.01806169f, 0.06789964f, 0.10784546f, 0.12273785f, 
    -0.15960358f, -0.07460064f, 0.00588081f, 0.05193980f, 0.14701656f, -0.00197773f, 0.18451741f, 0.00045750f, 
    -0.14757563f, 0.18715352f, 0.01622057f, -0.22061948f, 0.01350118f, 0.24949834f, 0.06328620f, -0.16376238f, 
    -0.78867531f, 0.02526122f, 0.37021706f, 0.25004441f, 0.07708864f, 0.06140120f, -0.20857565f, 0.03088700f, 
    -0.05966863f, 0.13633980f, -0.17467654f, -0.06256617f, 0.17225455f, -0.32729611f, -0.03418326f, -0.01044645f, 
    -0.09047175f, 0.02288277f, 0.25159645f, 0.03438487f, 0.01888875f, -0.10780870f, -0.01751831f, -0.05971167f, 
    0.51405001f, 0.04203931f, -0.04529816f, -0.11548796f, -0.09860291f, -0.17692123f, 0.08394612f, 0.03540481f, 
    -0.08933195f, 0.11327896f, 0.22639824f, 0.05986625f, 0.18124242f, 0.00585324f, -0.30571696f, -0.53556979f, 
    0.13112041f, 0.02063064f, -0.05023756f, 0.20697799f, -0.12227902f, 0.10009832f, 0.09304431f, -0.10080887f, 
    0.29483059f, 0.21045640f, 0.04849242f, 0.20053703f, 0.12874442f, 0.21128856f, -0.02319601f, 0.01070424f, 
    0.10154297f, 0.15233786f, 0.12858516f, 0.09955328f, -0.20669620f, -0.01335517f, -0.03544194f, -0.08171292f, 
    0.10734917f, 0.07048892f, 0.04312222f, 0.04633794f, 0.10236686f, -0.11496174f, 0.04995831f, -0.13803464f, 
    -0.46220219f, 0.22708958f, 0.03276252f, 0.21730714f, 0.02906576f, 0.28003287f, -0.18151215f, 0.04841177f, 
    0.01907218f, 0.04152963f, 0.04727022f, 0.04058627f, -0.33168647f, -0.31315026f, -0.00285164f, 0.25319475f, 
    0.22592135f, 0.05833872f, 0.00862760f, 0.05342731f, -0.12635715f, -0.22854613f, -0.14225517f, -0.05254228f, 
    -0.05987291f, -0.02431243f, -0.02930443f, 0.11698585f, -0.18223035f, -0.14668494f, -0.10096650f, 0.05730923f, 
    -0.08581197f, 0.00218076f, 0.07320385f, 0.01642858f, -0.01928754f, -0.22243190f, 0.18396711f, 0.22305441f, 
    0.05887436f, 0.00206093f, -0.01609455f, 0.06210687f, -0.05724348f, -0.04322679f, 0.11471787f, -0.03419189f, 
    -0.17352374f, 0.09900048f, 0.20995378f, -0.05428573f, -0.05862968f, 0.14265299f, 0.11357486f, 0.02947158f, 
    -0.01745777f, -0.03524449f, -0.15840662f, -0.02548104f, 0.12163728f, -0.06782526f, 0.06136059f, -0.10040233f, 
    0.13949971f, 0.00214735f, -0.08439395f, -0.04429647f, 0.06886822f, -0.11656740f, -0.02231583f, 0.13430932f, 
    -0.04433133f, 0.28281549f, -0.16018614f, -0.10022419f, 0.01425885f, -0.13215671f, -0.01486103f, 0.19139220f, 
    0.05180465f, -0.05887805f, 0.31268531f, -0.17529650f, -0.04212042f, 0.23135129f, -0.07713576f, 0.19194058f, 
    -0.15913004f, -0.02672936f, 0.06248914f, 0.05425883f, 0.15462540f, -0.05748646f, 0.04603059f, 0.07193906f, 
    -0.32254559f, 0.56770289f, 0.05344465f, 0.15937148f, 0.01580442f, -0.12431055f, -0.00574933f, -0.03128303f, 
    0.10687146f, -0.04998875f, 0.05863940f, -0.00371828f, 0.18734577f, -0.02487136f, 0.18361905f, -0.33565709f, 
    -0.18683790f, 0.01299022f, -0.16576338f, -0.16190827f, 0.11216142f, -0.01019440f, 0.17383613f, -0.01417398f, 
    -0.34359044f, -0.18839374f, 0.27206171f, -0.14915311f, -0.05435539f, -0.16632329f, 0.09321111f, -0.13393395f, 
    0.20859963f, 0.16873306f, -0.15430242f, 0.23032503f, 0.14771371f, 0.31417024f, -0.06903194f, 0.14110957f, 
    0.18083987f, -0.01580168f, -0.04867939f, 0.10031042f, 0.00538349f, -0.15264064f, -0.07218254f, 0.12750930f, 
    0.19179083f, -0.11338999f, -0.18643710f, 0.38574156f, 0.24438471f, 0.07709139f, 0.11643846f, 0.12971359f, 
    0.00648556f, -0.02259788f, 0.00825834f, 0.14235342f, 0.18673527f, 0.22429249f, -0.09595037f, 0.15494731f, 
    0.14930259f, -0.03492889f, 0.01522965f, -0.13803706f, 0.12537305f, -0.17141502f, 0.05111820f, -0.00202957f, 
    -0.13930970f, 0.00967623f, 0.14589086f, 0.23395266f, -0.01783255f, -0.00991759f, -0.24511284f, -0.10220767f, 
    0.10231188f, -0.03095983f, -0.09533407f, -0.05827311f, -0.43242428f, 0.13015680f, 0.15358259f, -0.13604107f, 
    -0.00376164f, -0.10070685f, 0.03183492f, 0.19521146f, 0.37347716f, 0.05219859f, 0.13823767f, 0.24153228f, 
    0.02232793f, -0.30131426f, -0.20442894f, -0.10297961f, 0.19977309f, 0.07708384f, -0.13650803f, -0.10514604f, 
    0.01271369f, 0.09253950f, -0.01187308f, 0.01032636f, 0.04124215f, -0.10426587f, -0.22765444f, -0.05110541f, 
    0.05096291f, 0.19184777f, 0.13846511f, -0.01930127f, 0.05072603f, 0.08988952f, 0.07097735f, 0.05172645f, 
    0.21900506f, -0.02764097f, -0.09003922f, -0.03938442f, 0.03948840f, -0.01360832f, -0.00684861f, -0.09355787f, 
    0.17662580f, 0.09162927f, 0.17976041f, 0.27609175f, -0.27622271f, 0.28935984f, 0.07353572f, -0.21578842f, 
    -0.06057246f, -0.02647439f, -0.01236134f, 0.10029890f, 0.12773196f, -0.04260043f, -0.11642563f, 0.27145162f, 
    -0.23721252f, -0.08818281f, 0.15097636f, -0.05869632f, -0.04209698f, 0.01360211f, 0.31204471f, -0.06239641f, 
    0.23378319f, 0.07420596f, -0.08846077f, -0.01181694f, -0.46524546f, -0.14240411f, 0.06327931f, 0.32883364f, 
    -0.04182315f, 0.13849200f, 0.06470642f, -0.26650199f, 0.05515390f, 0.02703719f, 0.04336666f, -0.02572029f, 
    -0.22433855f, -0.15752089f, -0.10802679f, 0.02754033f, 0.22340505f, -0.13462053f, 0.11628035f, 0.01513039f, 
    0.16804183f, 0.00090534f, -0.30536690f, 0.29913628f, 0.37949839f, -0.09113647f, 0.10015193f, 0.30716217f, 
    -0.06192823f, 0.11906565f, -0.04534648f, 0.07852760f, 0.17454538f, 0.13261753f, -0.05582993f, -0.15905762f, 
    -0.21066487f, -0.03299069f, -0.10747085f, -0.22984345f, 0.05354078f, -0.04295487f, -0.01981268f, 0.20081724f, 
    0.15824534f, -0.00207760f, 0.15251453f, 0.14560615f, -0.05558657f, -0.19824103f, 0.34905714f, 0.41883117f, 
    0.31009358f, 0.12411565f, -0.03698849f, 0.22668099f, 0.00639145f, 0.15355860f, 0.03859381f, 0.16354753f, 
    0.28700215f, 0.34563234f, -0.16099037f, -0.23324437f, 0.10403135f, -0.02418072f, 0.20332466f, 0.12208559f, 
    0.08345335f, -0.07825735f, 0.00368804f, 0.19647716f, -0.02217408f, -0.36643586f, 0.11520157f, -0.43199629f, 
    -0.13825744f, 0.06415448f, -0.05240346f, 0.07044835f, 0.15720858f, 0.18440522f, 0.13359828f, 0.14675689f, 
    -0.17934787f, -0.17448601f, 0.20215373f, -0.24344577f, -0.00360919f, 0.05377936f, 0.14664660f, 0.04087116f, 
    -0.01697402f, -0.28094143f, -0.01282765f, -0.06149069f, 0.01475833f, 0.25348148f, 0.06780558f, -0.08912919f, 
    -0.05275283f, 0.10790522f, -0.00929632f, -0.10748529f, 0.16945773f, 0.12999666f, 0.23352760f, 0.08234365f, 
    0.53637201f, -0.12948480f, -0.02438579f, -0.12049109f, 0.30370888f, 0.27163801f, -0.02231388f, -0.13635810f, 
    0.08844486f, 0.02619043f, 0.22615637f, 0.07411475f, 0.36911595f, -0.26437351f, -0.08975024f, 0.38437131f, 
    0.22166708f, 0.07357363f, 0.00093193f, -0.14800660f, -0.03709976f, -0.06990701f, -0.07868215f, 0.14914811f, 
    -0.09556584f, 0.04700856f, -0.02157657f, 0.05572272f, -0.00158042f, -0.02750703f, -0.10331563f, 0.05762419f, 
    -0.05880039f, 0.10286982f, -0.06067324f, -0.08515946f, 0.09505376f, -0.30708614f, 0.15430996f, 0.24930154f, 
    0.13544385f, -0.20490010f, 0.03526872f, 0.05240578f, 0.02581658f, -0.02943686f, 0.15333426f, 0.14442398f, 
    0.13612466f, -0.06066562f, -0.08798511f, 0.34760007f, -0.07592504f, -0.01540366f, 0.14006642f, -0.10494232f, 
    -0.02669732f, 0.14123686f, 0.08965537f, 0.10734409f, 0.22276987f, -0.18747759f, -0.03911736f, 0.30493870f, 
    0.15827052f, 0.14264561f, 0.16601352f, -0.07398975f, 0.15750779f, -0.05789707f, 0.23794797f, 0.06322128f, 
    -0.27931923f, 0.01321693f, 0.03028380f, 0.15199605f, 0.01980173f, -0.10331364f, 0.00311740f, 0.10274412f, 
    0.05980050f, 0.02693567f, -0.11897776f, 0.02211360f, -1.28291750f, -0.14211729f, -0.00130937f, -0.24003123f, 
    0.27403235f, -0.06518170f, -0.00845880f, 0.12335212f, -0.00290865f, -0.20676421f, -0.07437921f, 0.04246873f, 
    -0.08097272f, 0.02306141f, 0.08480846f, -0.15277493f, 0.01565233f, -0.26064664f, -0.18530515f, 0.02777338f, 
    0.05567335f, -0.15587589f, -0.23554051f, 0.08445404f, 0.78605759f, 0.49094853f, 0.37876675f, -0.12742852f, 
    0.09823847f, -0.20784310f, 0.04776812f, 0.12803112f, -0.08802211f, 0.31385911f, 0.24170306f, 0.21894513f, 
    -0.05412467f, 0.38365254f, -0.00633029f, -0.07345764f, 0.29627275f, 0.02232811f, -0.09213375f, -0.07605160f, 
    0.02126540f, 0.00034251f, -0.00229131f, 0.18999076f, 0.14896095f, 0.06716827f, -0.01474372f, -0.15267248f, 
    -0.00243712f, -0.05927804f, 0.08337860f, -0.02683523f, 0.08248681f, 0.19359030f, -0.13200463f, 0.20138474f, 
    -0.33006582f, -0.03414969f, 0.03524425f, -0.19499934f, -0.05561840f, -0.16365036f, 0.00679912f, -0.01589096f, 
    0.15659246f, 0.27075154f, 0.08810941f, 0.05948886f, -0.27594334f, -0.02524275f, 0.49612498f, -0.09308484f, 
    0.29239351f, 0.04544024f, -0.19847460f, 0.18051243f, 0.11056805f, 0.05475115f, -0.04355670f, -0.04568841f, 
    0.20049229f, 0.03081241f, -0.20085800f, -0.10778116f, 0.01141823f, 0.16421288f, 0.16959544f, 0.16199926f, 
    -0.03628492f, -0.23017114f, -0.15541835f, 0.03847205f, 0.21608646f, 0.11857121f, 0.06354234f, 0.13204551f, 
    0.23938864f, 0.14102630f, -0.15242831f, -0.08767635f, -0.14708306f, -0.15958710f, 0.04041699f, 0.01306006f, 
    -0.54755139f, -0.40670156f, -0.22392501f, -0.07989596f, -0.07471591f, 0.04675293f, 0.05891846f, -0.04483328f, 
    0.03794928f, 0.01377195f, 0.14199558f, 0.11497848f, 0.06129942f, -0.15346542f, -0.25090072f, -0.15374272f, 
    0.18762277f, 0.04950761f, 0.04220224f, -0.00699115f, -0.03678794f, 0.08435883f, 0.13446838f, 0.01756291f, 
    0.22146940f, 0.18247050f, 0.18112576f, 0.06030659f, -0.23015039f, -0.04688226f, 0.07266009f, 0.04142003f, 
    0.07820659f, -0.10523199f, 0.03719550f, -0.02581127f, 0.06537188f, 0.27820626f, -0.04446576f, -0.13223286f, 
    -0.25774601f, -0.06550522f, -0.05046657f, -0.11428401f, 0.06689326f, -0.02862449f, -0.00776532f, -0.10091244f, 
    0.25174165f, -0.06881983f, -0.01458128f, 0.40421045f, 0.10630173f, -0.09378730f, -0.03894162f, 0.11912696f, 
    0.24679762f, 0.00145754f, 0.09462030f, -0.01099578f, -0.01695164f, -0.10429366f, -0.28199542f, 0.08210374f, 
    0.04799276f, 0.12103655f, -0.02825872f, 0.04262513f, -0.00481606f, 0.06018089f, -0.05278431f, -0.19126120f, 
    0.42691919f, 0.03966242f, -0.03959671f, 0.26408550f, -0.03691701f, 0.08617255f, -0.08972480f, 0.00691250f, 
    0.00868015f, 0.14171615f, 0.16338399f, -0.01545641f, 0.81219357f, 0.06366277f, -0.02410721f, -0.01057137f, 
    -0.03209122f, 0.16596666f, -0.01011412f, 0.11504810f, -0.00435179f, -0.05079011f, 0.00106168f, 0.03594851f, 
    0.01497198f, 0.08018607f, -0.21224317f, -0.13999049f, 0.13088425f, 0.09328902f, -0.02670881f, 0.15685761f, 
    0.06379516f, 0.06775356f, 0.22464631f, -0.17023034f, -0.39460334f, -0.00795481f, -0.15889078f, 0.18542156f, 
    0.01356849f, -0.03486883f, -0.03283743f, -0.03056047f, 0.02328932f, -0.09437983f, -0.01260603f, 0.10677239f, 
    -0.02083245f, -0.25668836f, 0.09857387f, 0.31129760f, 0.20063879f, -0.10927311f, 0.18488970f, -0.09160017f, 
    0.28491691f, 0.07952649f, -0.00886282f, -0.00262490f, -0.26374999f, 0.40044656f, 0.07114124f, -0.23153587f, 
    -0.04817753f, -0.08766272f, 0.00542877f, -0.04023614f, -0.09284740f, 0.05131456f, -0.01406367f, 0.15304776f, 
    0.20260850f, 0.32416329f, -0.03556836f, 0.23977420f, 0.12589018f, -0.05133900f, -0.09177355f, 0.15207464f, 
    -0.13247234f, -0.01274122f, 0.03101530f, 0.05759666f, 0.12765439f, 0.30919299f, -0.01041028f, 0.27010912f, 
    -0.05293107f, 0.08263125f, 0.10070825f, 0.00532281f, -0.11441637f, 0.06697345f, -0.14239377f, -0.07175832f, 
    -0.03427033f, 0.25712225f, 0.04124458f, 0.21334909f, -0.02959503f, 0.09633297f, 0.04782727f, -0.31497309f, 
    -0.12526909f, 0.13310564f, -0.01941370f, -0.01159463f, -0.32621202f, -0.33361465f, -0.03574402f, -0.13150465f, 
    0.07093990f, -0.00971562f, -0.01434186f, 0.00440056f, 0.13189235f, 0.09834941f, 0.00791117f, 0.16268358f, 
    -0.53841799f, -0.16783985f, -0.10722169f, -0.01268426f, 0.00034316f, 0.09941383f, -0.09426907f, -0.15324797f, 
    -0.02712971f, -0.10245862f, 0.13270220f, -0.10663877f, 0.03520888f, -0.24266574f, -0.17148320f, -0.02271875f, 
    0.20980152f, -0.02684372f, -0.02332201f, 0.03147728f, -0.06937951f, 0.13484871f, 0.07246707f, 0.00547095f, 
    0.06421119f, -0.14032403f, 0.09607584f, 0.20061406f, -0.13564934f, -0.17951979f, 0.00044524f, 0.07123685f, 
    -0.00387183f, 0.00110379f, 0.12612401f, 0.04511104f, -0.08123771f, 0.37219086f, 0.02459720f, -0.47081342f, 
    -0.18495114f, 0.03867523f, -0.07460490f, -0.30533162f, 0.11828110f, -0.00570599f, 0.19662836f, 0.04199135f, 
    0.32635608f, 0.02007164f, -0.40958089f, 0.25092119f, 0.33620387f, 0.03985547f, -0.16923887f, -0.02710108f, 
    0.12534061f, 0.04742339f, 0.01835520f, -0.13953660f, 0.01098811f, -0.02351953f, -0.23533960f, -0.00078778f, 
    0.21447302f, 0.14140102f, -0.06800210f, -0.08027473f, -0.02381868f, 0.14655727f, -0.23681425f, 0.05782921f, 
    0.23315874f, 0.07027753f, 0.18080580f, 0.00192777f, -0.09606502f, -0.02719016f, 0.02924492f, 0.09747298f, 
    0.03901685f, 0.09924885f, 0.04232027f, -0.04746782f, 0.45139799f, -0.35050601f, 0.03953516f, -0.09958139f, 
    -0.22137195f, 0.07276204f, 0.13013710f, 0.19253600f, -0.08719116f, 0.09430171f, 0.07692924f, 0.21602139f, 
    0.18925574f, -0.21547939f, 0.08223367f, 0.03122006f, 0.16380459f, 0.13580304f, -0.08491501f, 0.24095939f, 
    0.03611640f, -0.04180608f, 0.07033392f, -0.07264396f, 0.05786365f, 0.15457852f, -0.40053329f, 0.10150164f, 
    0.06127937f, 0.03945929f, -0.14004721f, -0.07147748f, 0.13565493f, -0.02378147f, -0.06626268f, -0.00155871f, 
    0.02440515f, -0.26975101f, 0.05107700f, 0.06828360f, 0.21483313f, -0.00447461f, 0.12018570f, -0.02245871f, 
    0.38406512f, -0.04843266f, 0.08315145f, 0.05618811f, -0.49110061f, 0.27026066f, 0.07534861f, -0.07522966f, 
    0.07800613f, 0.11775842f, -0.00585119f, 0.11065409f, 0.11237638f, -0.05154308f, -0.01444290f, 0.05061961f, 
    0.11533828f, 0.60591078f, -0.22355814f, -0.02667943f, 0.23462956f, 0.10734439f, 0.07443460f, 0.08507513f, 
    -0.23876314f, 0.04654144f, 0.08593122f, -0.01641440f, -0.33100358f, 0.20466121f, 0.06423961f, 0.37631500f, 
    -0.30265185f, 0.05949348f, -0.08501622f, 0.06539464f, -0.08119762f, -0.00140200f, -0.14310476f, -0.19761108f, 
    -0.24521227f, 0.22976054f, 0.09658153f, -0.10944671f, -0.02867403f, 0.04364163f, -0.11487310f, -0.11594617f, 
    0.07285199f, 0.21722968f, 0.07033166f, 0.16841225f, 0.02392212f, -0.09590645f, -0.13272704f, 0.10154779f, 
    0.15054229f, -0.14555155f, -0.07059902f, 0.04733898f, 0.22643557f, 0.19552386f, 0.06001526f, 0.04581744f, 
    -0.02778212f, 0.02070029f, -0.05152982f, 0.03928723f, 0.05028147f, -0.00846694f, -0.05479658f, 0.00750699f, 
    0.00523936f, -0.07153909f, -0.02527192f, 0.04259373f, -0.01401191f, 0.01843357f, 0.00959898f, 0.02759481f, 
    -0.00515684f, -0.02042924f, 0.00753490f, 0.00466913f, -0.01327973f, -0.06873570f, -0.01225278f, -0.04748460f, 
    -0.08012686f, -0.06381334f, 0.01606705f, -0.01515322f, 0.06580949f, -0.00595417f, -0.04441429f, 0.01108134f, 
    -0.06256296f, 0.00600387f, 0.03268974f, -0.07040424f, -0.05018673f, -0.06488241f, -0.03812300f, 0.06059709f, 
    0.05512073f, 0.00139265f, -0.07441746f, 0.04944744f, -0.03792436f, -0.04522083f, -0.07110827f, -0.00197057f, 
    0.00993641f, -0.02377238f, 0.03827578f, 0.00115597f, -0.05230780f, -0.02421114f, -0.07197678f, 0.03572952f, 
    0.01410570f, -0.04368832f, -0.00282167f, -0.02028552f, -0.06623382f, -0.00498113f, -0.02068397f, 0.05307122f, 
    -0.02902594f, -0.00993559f, -0.00309783f, 0.05481352f, -0.05406948f, 0.04304717f, -0.06842421f, 0.02114492f, 
    -0.01152331f, -0.06875699f, -0.06003874f, -0.00131518f, -0.02859449f, -0.01647136f, -0.00373531f, 0.01946496f, 
    0.05148575f, 0.00745334f, -0.02267191f, 0.02025117f, 0.00986973f, -0.01110601f, -0.02019378f, 0.02428016f, 
    0.00814246f, -0.03296876f, -0.01995087f, -0.07767127f, 0.03119164f, 0.05439438f, -0.00516902f, -0.06158634f, 
    -0.03401694f, -0.02507353f, -0.07038187f, 0.05828117f, 0.02194834f, -0.00888027f, 0.03808660f, 0.03352515f, 
    -0.04251656f, 0.00161386f, 0.03761522f, -0.07830942f, 0.03398497f, -0.04327578f, 0.06134596f, -0.06236429f, 
    0.05767826f, -0.00342029f, 0.03548017f, 0.06001928f, 0.02551098f, 0.05466324f, 0.00581155f, 0.05548235f, 
    0.04985205f, -0.01561603f, -0.06852275f, -0.05883000f, -0.01362810f, 0.01582005f, -0.05285126f, 0.03519947f, 
    0.03306387f, 0.01836865f, 0.00600117f, -0.05717685f, 0.01611240f, -0.06178738f, -0.05888324f, -0.06947119f, 
    0.01783612f, -0.02727940f, 0.04499928f, -0.05541283f, 0.04114521f, -0.01725555f, -0.02166024f, 0.02838036f, 
    -0.05856510f, -0.00889614f, -0.02784144f, -0.02810368f, 0.03802783f, -0.07561710f, -0.07247373f, -0.04081925f, 
    -0.06572367f, -0.04251340f, -0.05849071f, 0.00297644f, -0.02645160f, -0.07696343f, -0.06391110f, -0.01704022f, 
    -0.08123267f, -0.02493335f, 0.00931891f, 0.06153147f, 0.05927306f, -0.05002775f, 0.04053384f, 0.04876909f, 
    0.02956969f, -0.06650749f, 0.03907645f, -0.06796741f, -0.02817516f, 0.05897348f, 0.03353003f, 0.04477332f, 
    -0.05950516f, -0.04970115f, 0.03763826f, 0.04259975f, 0.02967569f, 0.02922609f, -0.00726381f, -0.06319645f, 
    -0.05227397f, 0.06095831f, -0.05182485f, -0.04833877f, 0.00219240f, -0.03186517f, -0.05086440f, -0.03522060f, 
    0.04656752f, -0.03298699f, 0.05022803f, -0.00406907f, -0.04557927f, 0.01215705f, -0.01635147f, 0.05912751f, 
    -0.07038768f, -0.05266377f, -0.01298431f, 0.01065089f, -0.07991969f, -0.00303704f, 0.02199038f, -0.00026198f, 
    -0.07746501f, 0.05732196f, -0.02023089f, 0.04589299f, 0.04646811f, 0.03566287f, 0.06548427f, 0.03863168f, 
    -0.02933286f, -0.02234275f, -0.02452921f, -0.03692449f, -0.01845594f, 0.04190131f, 0.01236896f, 0.04593685f, 
    -0.04483142f, -0.01300808f, 0.03973891f, 0.00194281f, -0.00211760f, 0.00259664f, 0.01204256f, 0.05095351f, 
    -0.03951061f, -0.01931890f, -0.03688540f, 0.02763797f, 0.06262165f, -0.00920627f, -0.06729721f, 0.03411709f, 
    0.00221456f, -0.06139803f, -0.00121613f, -0.05570059f, 0.05881173f, -0.07135338f, -0.03043518f, -0.05351712f, 
    -0.03569994f, 0.01722242f, -0.04255083f, 0.06655331f, -0.02387215f, -0.07346565f, -0.00724808f, -0.01427373f, 
    -0.00915851f, -0.03968521f, -0.04164480f, -0.01497743f, 0.03106343f, 0.06923507f, 0.01965558f, -0.07772522f, 
    -0.03051012f, 0.05133700f, 0.01890026f, -0.03098753f, -0.06707590f, -0.02028243f, 0.03438159f, -0.05627000f, 
    -0.08311035f, -0.06793458f, 0.03996691f, 0.00065189f, 0.06801033f, -0.05944053f, -0.03916939f, -0.06560123f, 
    0.00863618f, -0.07771237f, 0.03189656f, 0.01016147f, -0.07373884f, 0.04519845f, 0.06587894f, -0.02694530f, 
    0.01713511f, 0.00691387f, -0.07531226f, -0.05579943f, -0.06016843f, -0.06472491f, 0.04197369f, 0.00793003f, 
    -0.05329934f, 0.01804658f, 0.06620906f, -0.07150652f, 0.00257524f, 0.02057740f, 0.01620039f, -0.07614613f, 
    -0.00007009f, 0.00831833f, 0.02294543f, -0.03896564f, -0.04611460f, -0.07849412f, -0.01638568f, -0.02214509f, 
    -0.03616343f, 0.02352960f, 0.00385004f, -0.01100169f, 0.03101749f, -0.06832218f, -0.02361700f, 0.03319548f, 
    -0.04767684f, -0.01609388f, 0.06962814f, -0.05787930f, -0.04571065f, 0.01303797f, -0.02512345f, 0.04816220f, 
    -0.02882895f, -0.04295699f, -0.06449873f, -0.07285517f, 0.00299801f, -0.01251725f, -0.01235943f, -0.04402988f, 
    0.00221687f, 0.00584987f, -0.07798930f, -0.01149246f, -0.02823060f, 0.05393582f, -0.02131425f, -0.06195513f, 
    0.03269437f, -0.05886490f, 0.05971394f, 0.02809329f, -0.05044940f, 0.02924431f, 0.04121580f, 0.00143556f, 
    0.02953901f, 0.02017459f, -0.07038795f, -0.01838711f, 0.03094281f, 0.00049862f, -0.00897532f, 0.02272583f, 
    0.02128712f, 0.03256466f, -0.00074387f, 0.04418552f, -0.07736898f, 0.05457383f, 0.05709931f, -0.01917362f, 
    0.05434577f, 0.00298803f, -0.01440963f, -0.04419628f, 0.05271843f, 0.01946755f, -0.00478856f, 0.03304768f, 
    -0.01485529f, -0.01214240f, 0.00979371f, 0.03944454f, 0.03771167f, -0.03756888f, -0.05904452f, -0.01478071f, 
    -0.13189137f, -0.01768733f, 0.02606212f, -0.05968237f, -0.06098009f, -0.02746831f, 0.06298454f, 0.31385195f, 
    0.15303759f, 0.13045628f, -0.14634660f, 0.05328641f, -0.29328570f, 0.17460270f, 0.11639669f, -0.04026850f, 
    -0.16352013f, -0.05776015f, -0.05890878f, 0.01351784f, -0.05498245f, 0.01301231f, 0.01983970f, -0.06955892f, 
    -0.09435833f, 0.16087732f, 0.31723645f, -0.10796525f, 0.24945779f, 0.08010209f, 0.06374241f, 0.14958952f, 
    0.04278307f, 0.03964385f, 0.07714340f, 0.10257600f, 0.08852914f, -0.05463465f, 0.16116439f, 0.17807820f, 
    0.13332720f, 0.02919738f, 0.14553845f, 0.23902318f, -0.10234786f, -0.04868248f, -0.07404318f, -0.07459728f, 
    -0.40787533f, 0.03887598f, 0.34621382f, -0.37306634f, 0.01055793f, 0.09733002f, 0.00042051f, 0.18390952f, 
    0.04753216f, 0.07088142f, -0.17493294f, -0.01539042f, -0.38764673f, -0.04205698f, 0.26744035f, 0.00302825f, 
    -0.08664990f, -0.16912590f, -0.15823254f, 0.07894763f, 0.03617888f, 0.09043236f, 0.12680256f, -0.05219040f, 
    -0.02310736f, 0.09846468f, 0.11056083f, 0.06055530f, -0.04827109f, 0.12550183f, -0.06604042f, 0.05753466f, 
    -0.05040178f, -0.03446579f, 0.01205507f, 0.08419029f, 0.30264449f, 0.37595442f, -0.10722818f, 0.12037607f, 
    0.02173791f, -0.02256042f, -0.10970279f, 0.03477650f, 0.04520101f, 0.29808235f, 0.07314067f, -0.01669658f, 
    -0.10125305f, 0.22928219f, -0.12239333f, 0.09593841f, 0.07488795f, 0.11847305f, 0.12403855f, -0.16385007f, 
    -0.00432851f, 0.16773590f, 0.06774321f, 0.07813852f, -0.56190705f, -0.34139836f, 0.18248773f, 0.05883723f, 
    -0.02945377f, 0.08082576f, 0.03982511f, 0.04754839f, -0.13477497f, -0.00264726f, -0.13373537f, -0.02010060f, 
    -0.10846462f, 0.39884794f, 0.00278357f, 0.29924116f, 0.02340233f, 0.06466092f, 0.11842889f, 0.16360185f, 
    -0.26614067f, 0.05803026f, 0.14841338f, -0.08037053f, 0.28402883f, -0.12667847f, 0.17577280f, 0.09825041f, 
    -0.02908995f, -0.01361600f, 0.06482916f, -0.00982627f, -0.12278562f, 0.14847213f, 0.03920282f, -0.10759275f, 
    -0.33144203f, -0.16731279f, 0.36358815f, 0.23973967f, -0.10933443f, -0.05009248f, -0.23774645f, -0.07046793f, 
    0.14805859f, 0.04721199f, -0.03529018f, 0.05038199f, 0.42253906f, -0.25985247f, -0.05791333f, -0.20287381f, 
    -0.04166464f, -0.04338095f, 0.36333832f, -0.03249078f, 0.02505011f, 0.01833105f, -0.00248933f, 0.05865713f, 
    0.37735593f, -0.12592064f, 0.08781914f, -0.01781052f, -0.14105205f, -0.17794450f, 0.04100500f, 0.12618037f, 
    -0.12593640f, -0.01688531f, 0.12924331f, -0.04493671f, 0.11979643f, 0.06036479f, -0.23930803f, -0.60540915f, 
    -0.08953629f, 0.05848084f, 0.07622641f, 0.15042061f, -0.07661083f, 0.06982867f, 0.00935493f, -0.07168625f, 
    0.02699068f, 0.02398024f, 0.01055270f, -0.05039128f, -0.03925625f, 0.00826589f, -0.07742465f, -0.05647134f, 
    0.00438343f, -0.07441219f, 0.05088934f, 0.02372866f, -0.07062826f, 0.01373858f, -0.04928906f, 0.04304974f, 
    -0.06199354f, -0.00740549f, 0.02970105f, -0.05659443f, 0.02664473f, 0.05107413f, 0.02880286f, -0.01578896f, 
    -0.00092391f, -0.05837546f, 0.06203185f, -0.06037687f, -0.03909089f, 0.04933623f, -0.03182844f, -0.03625406f, 
    -0.05371808f, -0.06244957f, 0.06327036f, -0.06084562f, -0.00973554f, -0.00874209f, 0.01530994f, 0.02467298f, 
    -0.03638387f, 0.05630354f, 0.00347088f, 0.04617647f, 0.01279282f, -0.04442502f, -0.01620522f, -0.04152354f, 
    -0.00989700f, 0.06025843f, 0.04179449f, 0.01797928f, -0.07796706f, -0.07660265f, -0.05506935f, 0.02246062f, 
    -0.07400355f, -0.03001609f, -0.00830346f, -0.04575626f, 0.03419961f, -0.05138677f, -0.06800304f, 0.04697274f, 
    -0.02722197f, -0.00031079f, -0.04749414f, 0.06685807f, -0.00679700f, -0.06734576f, 0.01126169f, -0.05139049f, 
    0.02624527f, -0.06619303f, -0.05027231f, -0.02531521f, -0.00605984f, 0.00675984f, -0.02026906f, -0.00907569f, 
    -0.06704096f, -0.03848165f, -0.05695669f, 0.01776211f, -0.03865388f, -0.06757908f, -0.06379534f, 0.06187205f, 
    0.00375178f, 0.02930455f, -0.05597001f, -0.04275452f, 0.02751714f, -0.01221882f, 0.00091211f, 0.05624780f, 
    -0.03246183f, 0.03915004f, -0.05522099f, 0.03697508f, 0.03424549f, 0.03700048f, 0.01433961f, -0.06464228f, 
    0.04249501f, -0.03175445f, -0.01214604f, 0.02188169f, -0.03239965f, -0.01617706f, -0.05108994f, 0.03551118f, 
    -0.00654473f, 0.04910112f, 0.05013359f, -0.04110645f, 0.03053577f, -0.03391648f, -0.02983328f, 0.01851887f, 
    0.01884935f, -0.01092268f, 0.02256788f, 0.00735357f, 0.00580765f, -0.00801125f, -0.00963522f, -0.01092998f, 
    0.02488251f, -0.04046362f, -0.06531790f, -0.01146042f, 0.02779377f, -0.04341892f, -0.01098783f, 0.05978879f, 
    -0.05072867f, -0.04160491f, -0.00402718f, 0.01201962f, 0.01330783f, -0.01607540f, -0.05400294f, 0.03952602f, 
    -0.04181039f, 0.06630294f, 0.03710876f, 0.02082993f, -0.01652612f, 0.06053436f, -0.00906345f, 0.03137307f, 
    -0.05879496f, 0.02470554f, 0.06128760f, 0.06249966f, 0.02700889f, -0.06361435f, -0.02672846f, -0.03419778f, 
    -0.03981223f, -0.01304998f, 0.01325041f, -0.07187141f, -0.02608095f, -0.05581155f, 0.03532273f, -0.02256441f, 
    -0.03546906f, -0.07365064f, -0.06262631f, 0.03122595f, 0.01860045f, 0.06771163f, -0.00767490f, 0.03810462f, 
    -0.04681349f, -0.05210972f, -0.03896812f, -0.07060581f, -0.04048126f, 0.00579622f, 0.06098108f, -0.05840837f, 
    0.05764962f, 0.05456873f, 0.06599446f, 0.06341400f, -0.06995086f, -0.02225668f, -0.07392798f, 0.04090240f, 
    0.24607933f, -0.25894663f, -0.04750930f, -0.21775457f, -0.00109992f, -0.08126797f, 0.05530967f, 0.04710192f, 
    -0.01944222f, -0.00042896f, 0.10466647f, 0.11140992f, 0.56841093f, -0.34904474f, 0.09577255f, 0.63289469f, 
    -0.11299008f, -0.03245801f, -0.00110032f, 0.02785964f, -0.07768923f, 0.13063790f, -0.02610113f, 0.10646604f, 
    0.39955786f, 0.20555122f, 0.07454201f, -0.10813615f, -0.10565130f, -0.13090746f, 0.11699366f, -0.05903668f, 
    -0.09543748f, -0.01496434f, -0.07526789f, 0.02554964f, 0.23606288f, 0.24588415f, 0.52123040f, -0.01296440f, 
    -0.12025774f, -0.13117433f, 0.13347410f, 0.20647572f, 0.13544054f, 0.22449647f, 0.00706016f, -0.03880044f, 
    0.10406557f, -0.15683682f, 0.18174011f, 0.18636218f, -0.03191309f, -0.14281327f, 0.18311094f, -0.10350636f, 
    0.00555961f, 0.02094568f, 0.20993561f, 0.09135373f, 0.00279617f, 0.09408284f, 0.02821953f, 0.23995170f, 
    -0.17403334f, 0.00601488f, 0.24794029f, 0.10165526f, 0.12909795f, 0.05405431f, -0.04217372f, -0.04595276f, 
    0.43009830f, -0.06276823f, -0.30214813f, 0.13053831f, 0.12883443f, -0.17273793f, 0.14872256f, 0.00125171f, 
    -0.00494442f, -0.04503277f, 0.01406229f, 0.01507156f, -0.53943253f, 0.03548479f, 0.02763493f, 0.02182935f, 
    0.11636154f, -0.07656469f, -0.02036726f, 0.04707139f, 0.04313145f, -0.13112839f, -0.03332273f, -0.05608488f, 
    0.11536935f, -0.12778156f, -0.01908894f, 0.08465976f, -0.07933043f, 0.06094622f, -0.09762578f, -0.01243237f, 
    -0.00389437f, -0.01108582f, -0.03253309f, 0.18347915f, 0.28675494f, -0.04824929f, 0.21612412f, -0.41908243f, 
    0.06940057f, -0.16992418f, 0.02803422f, 0.13776478f, -0.12510018f, 0.06813481f, 0.24268022f, 0.06444588f, 
    0.56524557f, -0.57646787f, 0.19349994f, 0.22250375f, 0.02627833f, 0.08372371f, -0.04689338f, 0.00135612f, 
    -0.12477488f, 0.03363556f, -0.10902078f, 0.01417491f, 0.01568216f, 0.21964319f, -0.01642398f, -0.09781301f, 
    -0.04016016f, 0.02856344f, 0.04797266f, -0.09290753f, 0.04934993f, 0.19661623f, -0.02619616f, 0.12462036f, 
    -0.20670465f, -0.15422086f, 0.01410927f, 0.23729402f, -0.05107063f, 0.04676845f, -0.00125731f, 0.03379250f, 
    -0.08084919f, 0.07036692f, 0.10492454f, 0.03876037f, 0.28900808f, -0.20971325f, -0.09491502f, 0.04816382f, 
    0.21861157f, -0.01252559f, 0.00256370f, -0.12086932f, -0.01645213f, 0.13876179f, 0.06869589f, -0.09960853f, 
    0.26809904f, 0.06335487f, 0.12770635f, -0.20280090f, -0.04101759f, 0.16548301f, 0.14077756f, -0.03945440f, 
    -0.07941878f, -0.15764026f, -0.11225657f, -0.08111694f, -0.19962513f, -0.20236854f, 0.13899544f, 0.02165812f, 
    -0.11317963f, 0.10202505f, -0.05628929f, 0.05297621f, -0.15692410f, 0.01160684f, -0.04847175f, -0.09615666f, 
    0.20914070f, 0.18607628f, 0.07800832f, 0.42888039f, -0.18390110f, -0.14954074f, 0.18498699f, 0.17284711f, 
    0.18892466f, 0.14970829f, -0.01530994f, 0.16815594f, -0.07271835f, 0.16494882f, 0.16473870f, -0.27808997f, 
    -0.13867362f, 0.00930377f, 0.03785600f, -0.15033939f, 0.13336419f, -0.15669328f, -0.07330377f, 0.14772135f, 
    -0.22421935f, -0.37280113f, -0.45676601f, -0.48217067f, 0.06578793f, 0.14146219f, -0.16320039f, 0.06266595f, 
    0.15181619f, 0.05146502f, 0.05492716f, 0.02530318f, -0.33091938f, -0.09808926f, -0.14238796f, 0.35188925f, 
    0.00971702f, 0.03084763f, 0.08209420f, 0.04865893f, -0.15961510f, -0.19129543f, -0.02258311f, 0.19127785f, 
    0.48006621f, 0.09607323f, 0.32342058f, -0.02154496f, -0.14255382f, 0.12640141f, -0.00196348f, 0.30583620f, 
    0.06283940f, -0.08306723f, -0.19766910f, 0.17681491f, 0.01156389f, 0.08360135f, -0.11957055f, 0.12672722f, 
    0.04867049f, 0.15362656f, 0.06669939f, 0.02500955f, -0.05914271f, -0.24536236f, 0.19160895f, -0.11212157f, 
    0.07003357f, -0.13486025f, 0.02316848f, -0.20307443f, 0.12066030f, 0.02783926f, 0.11301237f, 0.03548376f, 
    0.11120481f, -0.14807573f, 0.21597226f, 0.22821729f, -0.56726342f, 0.01216458f, 0.05055111f, -0.00511263f, 
    0.10961806f, 0.00203105f, 0.03475560f, 0.12431404f, 0.12946247f, -0.16066203f, -0.02283894f, 0.02025146f, 
    0.39319703f, -0.05423074f, 0.02957962f, -0.13746056f, 0.13397688f, -0.18169367f, -0.05889540f, -0.19478866f, 
    0.23433502f, -0.06355046f, 0.01937982f, 0.07572144f, -0.03835064f, 0.06009373f, 0.09472595f, 0.10058596f, 
    0.09486414f, 0.00201778f, 0.00954528f, 0.31958044f, -0.10981165f, 0.18039896f, -0.07149282f, 0.09176258f, 
    -0.02284721f, 0.23844077f, 0.06061895f, 0.07370658f, -0.04425780f, 0.07702754f, -0.09531334f, -0.12295839f, 
    -0.00271070f, 0.05673382f, 0.18390806f, -0.02225468f, 0.40303719f, 0.13664569f, 0.07478392f, 0.10131569f, 
    0.22241351f, 0.02179275f, 0.13721512f, 0.18345365f, -0.04219708f, -0.02886294f, 0.09893301f, -0.10566607f, 
    -0.30336121f, 0.15386134f, 0.35534850f, 0.13774054f, 0.05289138f, -0.00277889f, -0.03373487f, 0.02743960f, 
    0.16691540f, 0.01583424f, -0.14741436f, -0.08347068f, -0.17994009f, -0.10007902f, -0.06470536f, -0.61280012f, 
    0.03856637f, 0.05477315f, 0.05843597f, 0.10437207f, -0.00240688f, -0.10136037f, 0.06487101f, 0.12109289f, 
    -0.12430211f, -0.13645811f, 0.04458398f, 0.39870334f, -0.10544594f, -0.02583592f, 0.07108834f, -0.05714263f, 
    0.16470291f, 0.27750996f, -0.08384665f, 0.21428195f, -0.05892584f, -0.21429951f, 0.18776363f, 0.48316330f, 
    -0.21064979f, -0.10535153f, 0.15109327f, 0.01975726f, -0.08676594f, -0.18870482f, 0.03225075f, -0.13566762f, 
    0.19188711f, 0.24529417f, 0.13828346f, -0.20217815f, -0.03615356f, 0.04208624f, 0.11122948f, 0.22901931f, 
    0.15374520f, 0.12869883f, -0.05437782f, 0.20640919f, 0.32045776f, 0.34829018f, -0.19502322f, -0.26308015f, 
    -0.01961580f, -0.03464227f, 0.03474462f, 0.00826690f, 0.09550426f, -0.03784082f, -0.17633151f, -0.08614201f, 
    -0.27103266f, -0.43673265f, 0.15133420f, 0.21384242f, 0.22187908f, 0.06616231f, 0.16692865f, 0.22819521f, 
    0.18695514f, 0.16839911f, 0.21653557f, 0.07013652f, -0.48564658f, -0.07708046f, -0.44602442f, 0.04544974f, 
    -0.07709137f, -0.04684998f, -0.07899527f, -0.06743649f, 0.05553922f, -0.08056322f, 0.11097106f, -0.01372019f, 
    -0.11033580f, 0.12498125f, 0.07128745f, -0.02978732f, 0.00980320f, 0.18808344f, 0.25032133f, -0.00363966f, 
    0.02670695f, -0.15927382f, -0.03812899f, -0.04917679f, 0.77903908f, 0.18729709f, 0.10855353f, -0.19188292f, 
    -0.04949593f, -0.13811567f, -0.16525082f, -0.12838677f, 0.00022636f, 0.12921752f, 0.14484045f, 0.11481281f, 
    -0.03713832f, -0.09611579f, -0.12909409f, 0.04660857f, -0.04619634f, 0.24420767f, -0.17148133f, -0.00807304f, 
    -0.24982868f, 0.09188962f, 0.18543574f, 0.16635692f, 0.42339599f, -0.21676007f, 0.08115806f, -0.28822705f, 
    -0.22719300f, 0.26192853f, -0.09553069f, -0.00452684f, 0.01067222f, 0.22282772f, -0.21170394f, 0.06779928f, 
    -0.46156478f, 0.47803915f, 0.09515867f, -0.12108080f, 0.14394863f, 0.05805892f, -0.05153738f, 0.10390381f, 
    0.07068852f, 0.10688803f, 0.10897631f, -0.22418997f, -0.00906994f, -0.13031164f, 0.23376501f, 0.33219302f, 
    -0.03242446f, 0.05247936f, 0.02397095f, -0.07297437f, -0.14142683f, -0.29839072f, -0.12813225f, 0.03663178f, 
    -0.14100702f, 0.15275960f, -0.16472283f, -0.08432118f, 0.20365648f, 0.04877150f, 0.06562312f, 0.01239292f, 
    0.13351126f, 0.08453048f, 0.01178029f, 0.01033151f, 0.31187129f, 0.18807456f, -0.06598027f, 0.18250331f, 
    -0.04759097f, -0.07042750f, 0.27578294f, -0.10092124f, 0.11076111f, -0.11036305f, 0.03760557f, -0.18795638f, 
    0.17960921f, 0.03714535f, -0.09263997f, 0.12555614f, -0.11184925f, -0.02265402f, -0.09164109f, -0.01999034f, 
    0.04766736f, -0.13119449f, 0.08528688f, -0.26465178f, 0.05478784f, -0.26640484f, -0.10366207f, 0.38409421f, 
    -0.02549308f, 0.02130261f, 0.06243442f, -0.10438227f, -0.06326764f, -0.12547956f, -0.01477350f, 0.02016421f, 
    -0.12067190f, 0.12225790f, -0.29245588f, 0.15213388f, 0.05567561f, 0.05149325f, -0.04262560f, 0.18921201f, 
    0.04999144f, 0.28690931f, 0.08592863f, -0.13116412f, 0.34554115f, 0.02050282f, -0.10408959f, -0.16116145f, 
    0.16193625f, -0.01163265f, 0.14578037f, 0.13693607f, 0.03226887f, 0.17224565f, 0.05535035f, 0.01342715f, 
    0.39561376f, 0.15803798f, -0.07770124f, 0.10819697f, -0.07964379f, -0.04062967f, 0.07106110f, -0.20625319f, 
    -0.08602765f, -0.04237007f, -0.01432084f, -0.05366410f, -0.06084862f, 0.14818223f, 0.07817116f, -0.01552652f, 
    0.02856800f, 0.11402839f, -0.00884975f, 0.07941791f, -0.09492417f, 0.03280634f, 0.01074223f, -0.00490021f, 
    -0.16155376f, -0.22649308f, -0.36650297f, 0.07965241f, 0.12527822f, 0.14201973f, 0.08227396f, -0.11675348f, 
    -0.05117156f, 0.00052553f, 0.07395225f, 0.02517969f, -0.13090190f, 0.12802905f, 0.15369491f, 0.02475942f, 
    -0.17667335f, 0.06129561f, -0.06011551f, -0.28822386f, 0.15627865f, 0.07188216f, 0.07966073f, -0.10029994f, 
    0.32954890f, -0.01581463f, -0.19375077f, 0.23601134f, 0.01900159f, -0.03843179f, 0.06164329f, 0.05786204f, 
    0.15029383f, -0.05777520f, 0.09864359f, 0.02830063f, 0.56485790f, 0.07181267f, -0.01184367f, -0.10554089f, 
    -0.03941408f, 0.07390378f, 0.09647970f, -0.01675909f, 0.12815855f, 0.09699974f, -0.15820022f, 0.27549154f, 
    0.47801059f, 0.07979133f, -0.04466637f, -0.19807720f, -0.04619804f, -0.11358443f, 0.23635259f, 0.02896251f, 
    -0.01768203f, 0.11066461f, -0.03871219f, -0.10693453f, -0.02554633f, -0.36748290f, 0.15578070f, 0.24087791f, 
    -0.04364945f, -0.00084924f, 0.06916100f, -0.10676764f, 0.03673211f, 0.13943191f, -0.02437281f, -0.00621196f, 
    -0.03214995f, -0.20895964f, 0.14206338f, 0.18462856f, 0.10976201f, 0.10097139f, -0.08931358f, 0.05202474f, 
    0.06821776f, 0.03242557f, -0.20605960f, 0.08561167f, 0.60170352f, -0.10596785f, -0.37336004f, 0.31190190f, 
    0.01262489f, 0.15487666f, -0.12864447f, -0.01367543f, 0.06404886f, 0.05368126f, -0.02666129f, -0.14888865f, 
    0.11894608f, -0.16067816f, -0.05145683f, -0.07570264f, -0.14764926f, 0.05287021f, 0.06025483f, 0.08646689f, 
    0.04256876f, -0.06907636f, -0.15479118f, -0.03413638f, -0.14195582f, 0.18867500f, -0.13473900f, 0.12645876f, 
    0.17514996f, 0.01954346f, -0.00364632f, 0.03080676f, 0.09016726f, -0.07816045f, 0.04908135f, 0.04018139f, 
    -0.10465329f, 0.01649760f, -0.45704317f, -0.12841158f, 0.04494977f, -0.08044560f, 0.10100131f, 0.13567439f, 
    -0.01964223f, 0.00380465f, 0.09343530f, 0.06540516f, -0.20030002f, -0.00292709f, -0.21166006f, -0.01372315f, 
    -0.10959964f, 0.21563132f, -0.19817981f, -0.18586880f, -0.01858732f, 0.13755839f, 0.05986745f, -0.06650577f, 
    -0.32433912f, 0.36257884f, 0.15519764f, -0.14386624f, -0.00402240f, -0.07964663f, -0.10123862f, -0.14444385f, 
    0.15077078f, 0.02979640f, 0.17823063f, 0.06961618f, 0.25502408f, -0.08281761f, 0.10365202f, 0.31090665f, 
    -0.09623373f, -0.11237288f, -0.01785149f, 0.08958058f, -0.01247232f, 0.04596385f, 0.11119231f, 0.02895154f, 
    -0.10956326f, 0.05014866f, -0.02060914f, -0.11554576f, 0.06925693f, -0.17681919f, -0.05773137f, 0.12423958f, 
    -0.03810030f, -0.13046159f, -0.22331232f, -0.04591475f, 0.23990616f, -0.02462788f, 0.13513857f, 0.27168831f, 
    -0.12683089f, -0.05666215f, 0.02888528f, 0.04132796f, -0.03383708f, 0.04668174f, -0.02087947f, 0.16445415f, 
    0.33211055f, -0.25441971f, 0.14338304f, -0.30507302f, 0.04901735f, -0.17014429f, 0.08404808f, 0.05729312f, 
    0.04380117f, -0.00293302f, 0.06802895f, 0.04554439f, 0.23052618f, 0.14705244f, -0.10339355f, -0.12967329f, 
    0.11323576f, 0.05711613f, 0.16097307f, 0.12266543f, 0.07330864f, 0.14689697f, 0.11246350f, 0.14246123f, 
    -0.06580310f, 0.09793204f, 0.11805675f, -0.52705568f, 0.13914280f, 0.17705590f, 0.10538054f, -0.09775572f, 
    0.13692360f, 0.04170448f, -0.12303336f, 0.11912265f, 0.00379591f, 0.34972003f, -0.10325926f, -0.12284476f, 
    0.05604524f, -0.06763290f, -0.05080540f, -0.02276800f, 0.18549977f, 0.00725448f, -0.03890118f, 0.08340350f, 
    -0.26319671f, -0.11938971f, 0.11276090f, -0.12890384f, 0.09806101f, -0.06569642f, -0.01351348f, -0.02433429f, 
    0.00734809f, -0.06396892f, 0.19740300f, 0.10764159f, -0.16368954f, -0.04000919f, 0.11644167f, -0.00235844f, 
    -0.08271547f, 0.04657686f, 0.16032586f, 0.01830247f, 0.00521925f, 0.11202779f, -0.01548106f, 0.02871692f, 
    0.26209390f, -0.21558635f, 0.07853986f, 0.17503479f, 0.08671478f, 0.09405376f, 0.05298604f, -0.21750404f, 
    0.05824248f, -0.02211398f, -0.17545836f, 0.26946270f, 0.13362616f, 0.20770866f, 0.07119961f, -0.35121104f, 
    0.13451897f, -0.08160390f, -0.01826633f, 0.08490630f, -0.22292021f, -0.02570046f, 0.10678666f, -0.02122225f, 
    0.35048711f, -0.43080035f, 0.14078932f, -0.17189890f, 0.05249037f, 0.02731323f, 0.01722017f, 0.08260355f, 
    -0.09755526f, 0.13947950f, 0.00380671f, -0.02880888f, -0.01056756f, -0.08369192f, -0.24536575f, 0.24257596f, 
    0.18446696f, 0.04366944f, 0.05983961f, 0.06617783f, -0.05809823f, -0.05869286f, -0.15313764f, -0.13901681f, 
    0.36833039f, 0.00954393f, -0.15007940f, 0.13733934f, 0.04985783f, 0.17505598f, 0.02378836f, 0.09585047f, 
    -0.02981441f, -0.18832849f, 0.13491572f, -0.20911777f, -0.06544828f, -0.24880880f, 0.27526411f, -0.16741261f, 
    -0.07280630f, -0.06390686f, 0.17310339f, 0.00402580f, -0.00168479f, 0.04036971f, 0.00947565f, -0.07294028f, 
    -0.20325674f, -0.11737350f, 0.12147603f, -0.22950371f, -0.10687214f, -0.08935455f, -0.04168419f, 0.06051032f, 
    -0.00327976f, 0.05922121f, 0.01593371f, -0.04869558f, 0.05458779f, 0.10952680f, 0.05698363f, -0.12313050f, 
    -0.14338398f, 0.08466767f, 0.04670590f, 0.04734797f, -0.03650274f, 0.18176895f, 0.05903334f, 0.03982967f, 
    -0.09181742f, 0.21115302f, 0.03374621f, -0.07438285f, 0.18343210f, 0.17567146f, 0.02734672f, 0.25950271f, 
    -0.04502188f, 0.11606485f, -0.09345220f, 0.12986720f, 0.28721857f, 0.03647004f, -0.04606319f, 0.37459555f, 
    0.07011127f, -0.02552406f, 0.00252169f, 0.00195862f, -0.26680565f, 0.01664381f, -0.00727912f, -0.14545652f, 
    -0.32267702f, -0.03665293f, 0.46431026f, 0.21280314f, 0.04570349f, 0.05757839f, 0.11895002f, 0.20431381f, 
    0.02058729f, 0.11430810f, 0.21938355f, 0.09832111f, -0.00502930f, 0.06873740f, 0.18817477f, -0.31762516f, 
    0.10288639f, 0.02169614f, -0.05247746f, 0.18248960f, 0.05112434f, -0.02363269f, 0.10693718f, 0.11117204f, 
    -0.34146866f, 0.12681237f, -0.04146501f, -0.39003035f, 0.12505999f, 0.13181077f, -0.09545224f, -0.03295422f, 
    -0.00416098f, -0.05245398f, -0.17002629f, -0.17675155f, -0.26258713f, 0.11062597f, 0.24053529f, 0.18609367f, 
    0.14996560f, -0.11728720f, -0.14242552f, -0.12480427f, -0.00579450f, 0.18903214f, 0.00502937f, 0.05944458f, 
    -0.14457275f, 0.13641690f, 0.11075781f, 0.00419834f, -0.12108538f, 0.06907535f, -0.19498326f, 0.11403139f, 
    -0.09016237f, 0.01850893f, -0.01470940f, 0.09555997f, 0.27308029f, -0.05890634f, 0.07422642f, -0.40244141f, 
    -0.03382630f, -0.05140899f, -0.12933037f, 0.19666813f, -0.08470715f, 0.16164683f, 0.05417241f, 0.21083654f, 
    0.04385328f, 0.04623273f, 0.19173715f, 0.10365210f, -0.06431543f, 0.24538539f, -0.10604455f, -0.03542270f, 
    0.00342156f, 0.13853194f, 0.18513297f, -0.07308856f, 0.02204325f, 0.19165751f, -0.08879346f, -0.26636997f, 
    0.03551161f, -0.02883757f, -0.05190502f, -0.08500203f, -0.03706065f, -0.09947509f, 0.02975251f, 0.01324890f, 
    0.18245456f, 0.30341911f, 0.20523456f, 0.14918911f, 0.12300799f, 0.13549919f, 0.06301725f, 0.12251978f, 
    -0.10142139f, -0.07957446f, 0.00771153f, -0.00608429f, 0.06855179f, -0.22613309f, -0.04611379f, -0.09159971f, 
    -0.20419991f, 0.26151291f, -0.01154129f, -0.22672273f, 0.16669965f, 0.10867830f, -0.00744006f, -0.16321330f, 
    -0.40653452f, 0.02791823f, 0.21951099f, 0.02754740f, -0.01191857f, 0.24648522f, -0.16484931f, -0.19879207f, 
    -0.04788339f, 0.10959177f, -0.02255733f, -0.20149088f, -0.17229280f, 0.02040553f, 0.23363167f, 0.32138813f, 
    -0.03082305f, -0.12690990f, 0.16191213f, 0.06321164f, -0.04063365f, -0.32882825f, -0.04411911f, -0.16023879f, 
    0.25465572f, -0.31254619f, -0.39859831f, -0.19617969f, -0.03640241f, -0.09273572f, -0.02938086f, 0.30227566f, 
    0.01291111f, 0.12908944f, 0.22589070f, 0.21555182f, 0.38899514f, 0.35991544f, -0.36305398f, -0.25624380f, 
    0.24573168f, -0.04785011f, -0.13429488f, 0.15598603f, 0.05793785f, -0.01087045f, -0.08427823f, -0.16723076f, 
    0.48082566f, 0.17679684f, 0.08246978f, 0.05731989f, -0.08758400f, -0.00381199f, 0.09488100f, 0.19293869f, 
    -0.11271259f, 0.02913236f, 0.13965678f, 0.04396367f, 0.53682268f, -0.02944060f, 0.22515191f, 0.09207416f, 
    0.00563088f, -0.05561849f, 0.02709284f, 0.04948924f, 0.08002239f, 0.22997542f, 0.00032444f, -0.01728962f, 
    -0.05817281f, 0.04345272f, -0.04735086f, 0.05152918f, -0.06618349f, 0.11590762f, 0.01718800f, -0.09219610f, 
    0.00222313f, 0.03106738f, 0.02334644f, 0.03431337f, -0.29077619f, 0.16226196f, 0.27217767f, 0.04534007f, 
    -0.19330776f, 0.01889019f, 0.00134910f, 0.01688055f, 0.08645010f, -0.00443754f, 0.04632281f, -0.12818164f, 
    -0.00425697f, 0.00656505f, 0.09385232f, 0.18911381f, -0.03399670f, -0.00930522f, 0.15433484f, -0.00701514f, 
    -0.03016465f, -0.13992879f, 0.09915768f, -0.01240472f, 0.33300340f, 0.27425602f, 0.14185402f, 0.21044610f, 
    -0.02056065f, -0.13281386f, 0.19142143f, 0.19622633f, -0.03583274f, 0.02950278f, -0.17262946f, 0.08245178f, 
    0.36113358f, -0.05695608f, -0.18868184f, -0.14915422f, 0.17157207f, -0.10085382f, 0.25738299f, -0.01701635f, 
    -0.01621908f, -0.16833489f, 0.10857891f, 0.03328334f, 0.50062418f, -0.16583242f, 0.22301933f, -0.07169976f, 
    -0.05404688f, -0.12361417f, 0.07043263f, 0.02120750f, 0.02951362f, -0.08489074f, 0.01247914f, -0.02939430f, 
    0.28383043f, -0.11256232f, -0.15465948f, 0.06229271f, 0.05981628f, -0.03500279f, -0.09109467f, -0.03235445f, 
    -0.06578742f, 0.04187762f, 0.19060269f, -0.04774841f, 0.14464416f, 0.12943958f, -0.28950676f, -0.20883422f, 
    -0.00977628f, -0.01286064f, -0.01912647f, 0.04942726f, 0.06977368f, -0.11828484f, 0.04632730f, -0.01693648f, 
    0.64991784f, -0.51095289f, 0.14498238f, 0.16839212f, -0.28328577f, 0.08418216f, -0.05991396f, -0.11292837f, 
    -0.00411431f, -0.06256632f, -0.09677348f, -0.01307648f, 0.03761660f, 0.03640637f, -0.02518381f, -0.18609433f, 
    -0.04015802f, 0.06270488f, -0.15590590f, -0.18476577f, 0.08985719f, -0.10203275f, 0.07003171f, 0.00920502f, 
    -0.11034771f, -0.28916788f, -0.01424127f, 0.03533366f, 0.09777825f, 0.00868868f, 0.03512808f, 0.00995766f, 
    -0.06946950f, -0.08564007f, -0.08095788f, 0.01357135f, 0.32646766f, 0.15242048f, -0.44562823f, 0.21387275f, 
    0.13901517f, 0.02749532f, -0.15788732f, -0.24705583f, -0.00814375f, -0.04924759f, 0.05287299f, -0.10092421f, 
    -0.15307079f, 0.16224356f, -0.07624222f, 0.21948618f, 0.12579031f, 0.08051784f, 0.09198178f, -0.21771529f, 
    0.05067477f, 0.06440875f, -0.03033062f, 0.10167128f, -0.04256602f, -0.12847207f, 0.23382200f, 0.59833533f, 
    -0.23321484f, -0.08532820f, 0.12423567f, -0.01967003f, 0.07176745f, -0.05749988f, -0.04694293f, -0.12828147f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07819076f, -0.00066535f, -0.05524069f, -0.03347388f, -0.06800450f, 0.04841514f, 0.10039091f, 0.06305769f, 
    0.24601817f, -0.01230226f, 0.02109866f, -0.05615089f, -0.01143140f, 0.04623720f, 0.02696972f, 0.08949047f, 
    -0.08818348f, 0.26098058f, 0.06636161f, -0.05002301f, 0.13769664f, -0.08357053f, -0.04592620f, -0.06019017f, 
    0.03398419f, 0.05305666f, -0.02160684f, 0.08692203f, -0.04978504f, 0.08702967f, 0.02929864f, -0.19523045f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.38389406f, -0.51126182f, -0.08147726f, 0.61820459f, 0.27729699f, 0.13692661f, -0.29956684f, 0.01637885f, 
    -0.24249424f, 0.32807350f, 0.14221454f, 0.11939158f, 0.03859730f, -0.54998726f, 0.14832307f, 0.12421010f, 
    -0.00458525f, -0.06290549f, -0.46137655f, 0.09349256f, -0.45698401f, 0.01074919f, 0.04275420f, 0.41204253f, 
    -0.04057812f, 0.20482628f, 0.07674891f, 0.00193225f, -0.15700118f, 0.09181213f, -0.22294854f, 0.39419967f, 
    -0.35379770f, 0.32688069f, -0.07041837f, -0.52739847f, 0.34340593f, 0.17901322f, -0.70048386f, 0.28779194f, 
    0.13202412f, -0.06899263f, -0.00363541f, -0.05795811f, 0.04964338f, -0.29914704f, 0.00551077f, -0.23226666f, 
    -0.38537565f, 0.12937184f, 0.34651250f, -0.52296513f, -0.36332849f, 0.02277462f, 0.10160612f, -0.26381958f, 
    0.13452186f, 0.44314486f, 0.06878471f, -0.17554237f, 0.15111154f, 0.37150395f, -0.02871156f, 0.13289496f, 
    -0.18977381f, -0.38918370f, 0.00086148f, -0.52990144f, 0.36980280f, 0.01359003f, 0.37670365f, 0.13089250f, 
    -0.23617923f, 0.33857834f, 0.02654904f, 0.10170948f, 0.11162365f, 0.23649532f, 0.12687138f, -0.79882735f, 
    -0.30164212f, -0.48002750f, -0.18312064f, 0.28905267f, 0.25255361f, 0.04357958f, -0.05110602f, -0.41693339f, 
    -0.06009854f, -0.05905045f, -0.55130792f, 0.34069368f, -0.65414906f, 0.37086347f, 0.32936516f, 0.16633759f, 
    0.24076903f, -0.31268653f, -0.15668644f, -0.22671452f, -0.58878630f, 0.00657444f, 0.26427612f, -1.02132845f, 
    0.29921347f, -0.72050917f, 0.08728850f, -0.03338400f, -0.02120688f, -0.37588516f, -0.11765888f, 0.21723789f, 
    -0.09046786f, -0.23988013f, 0.06302858f, 0.33059031f, 0.18205990f, -0.04757498f, -0.05766730f, -0.05432049f, 
    -0.17637357f, 0.23048748f, 0.73576301f, -0.67404449f, -0.15938663f, -0.19772191f, -0.02078498f, 0.13824804f, 
    0.01451916f, -0.27770880f, 0.00538775f, -0.13570014f, -0.24171387f, 0.15363190f, -0.21529256f, 0.18912524f, 
    0.31710184f, -0.63299346f, 0.17524354f, 0.08348180f, -0.12615959f, -0.07811601f, -0.13022435f, 0.52516901f, 
    0.26914015f, -0.12239953f, 0.06302504f, -0.19932349f, -0.31034222f, 0.05108672f, 0.02944994f, 0.29017010f, 
    -0.03557650f, 0.09574588f, -0.26365140f, 0.25013304f, -0.23503126f, -0.24855933f, 0.48766303f, 0.06914133f, 
    0.21729064f, -0.46458092f, 0.10492717f, 0.27647713f, 0.09745077f, -0.09878075f, -0.77443385f, 0.22814868f, 
    0.13529836f, -0.39119372f, 0.05702650f, -0.02591351f, -0.09921324f, 0.34904563f, 0.03381793f, -0.67639470f, 
    0.37353101f, 0.22353622f, 0.21429142f, -0.17436028f, -0.38103631f, 0.04567432f, -0.15509214f, -0.31552544f, 
    0.04418737f, -0.07259419f, 0.32866350f, 0.06482497f, 0.01822807f, -0.32066268f, -0.53815514f, 0.17905416f, 
    0.17404331f, 0.22217701f, -0.17976511f, -0.57751119f, -0.32669607f, -0.13749799f, 0.20900083f, 0.33845052f, 
    -0.12704016f, 0.25229320f, -0.12278665f, -0.00122410f, -0.17676908f, 0.30717701f, 0.01704193f, -0.11309693f, 
    -0.21070234f, 0.22516026f, -0.62344313f, -0.22616903f, 0.08833271f, 0.08715378f, 0.14950998f, -0.10092466f, 
    0.09958260f, -0.54332405f, 0.08666313f, 0.21851860f, 0.38868228f, 0.00002338f, -0.08796261f, 0.18536872f, 
    0.34091425f, 0.47288185f, 0.14199065f, 0.43551031f, -0.20380232f, 0.08303771f, 0.24581136f, -0.31622300f, 
    -0.23951806f, -0.06814019f, -0.00208941f, 0.10765307f, -0.11482415f, 0.36011901f, -0.09529974f, 0.04604118f, 
    0.23848268f, -0.46452671f, -0.04531569f, 0.09684474f, -0.36592323f, 0.05896783f, 0.00384135f, 0.18610504f, 
    0.08365206f, 0.03238460f, -0.45703295f, -0.41789055f, 0.06402716f, -0.70286787f, -0.18996195f, -0.03363021f, 
    -0.11516935f, 0.00288374f, 0.12496314f, -0.81429958f, 0.26510477f, -0.07336058f, -0.41043693f, -0.06708409f, 
    -0.44235530f, 0.40631279f, 0.09169439f, -0.02646020f, -0.02083180f, -0.64141631f, 0.05771800f, -0.18985771f, 
    0.52769971f, -0.00926095f, 0.19500397f, -0.03530063f, 0.42035630f, -0.08107933f, 0.09343197f, -0.59587145f, 
    -0.15070426f, -0.09800651f, -0.35346258f, -0.57504618f, 0.18285677f, -0.29097593f, 0.39100599f, 0.24629216f, 
    -0.31573620f, 0.57165635f, 0.02122524f, 0.00310276f, -0.06681250f, -0.09584671f, 0.18955795f, -0.50632954f, 
    -0.13759698f, 0.17444521f, -0.08917835f, -0.10408740f, -0.03576957f, 0.22642635f, -0.02644731f, 0.06120289f, 
    0.23131768f, 0.19475283f, 0.15156995f, -0.33917549f, -0.31473055f, 0.10151607f, -0.00015930f, 0.39435855f, 
    -0.15214650f, -0.70415068f, 0.36208653f, 0.34149653f, -0.28054902f, -0.00506952f, 0.24517049f, -0.88356274f, 
    0.27011114f, -0.75200576f, -0.08143228f, -0.13347487f, 0.22226661f, 0.13693446f, 0.22747804f, -0.81615728f, 
    0.46552736f, -0.01176948f, 0.00336058f, 0.12102509f, 0.15944125f, 0.17093831f, -0.16987902f, -0.11072266f, 
    -0.43770069f, 0.56653380f, -0.15795368f, 0.34236038f, 0.27223498f, -0.05940629f, -0.11634278f, 0.09971408f, 
    0.12801547f, 0.08138073f, -0.72311753f, -0.95124418f, -0.35898840f, 0.13294539f, -0.29115736f, -0.84979528f, 
    -0.32546264f, 0.24667852f, 0.01944085f, 0.39265049f, -0.54504037f, 0.17248334f, 0.19808842f, -0.19298083f, 
    0.20482951f, 0.02682338f, -0.04518284f, -0.11323380f, 0.06910170f, -0.41851845f, 0.06019413f, -0.15523179f, 
    -0.30326241f, -0.03370462f, 0.11856868f, 0.34670129f, 0.35100973f, 0.07732793f, 0.13645016f, -0.57063812f, 
    0.15080899f, 0.10209108f, -0.29912958f, 0.44572467f, 0.44013077f, -0.24927893f, -0.34694415f, 0.04293176f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06637421f, 0.00098137f, 0.00552784f, 0.06894258f, 0.10280615f, 0.07399094f, -0.05640721f, -0.11169893f, 
    -0.02179889f, -0.05933352f, 0.21505100f, -0.07802408f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
