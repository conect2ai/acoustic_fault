#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71483839f, -1.00498796f, -1.16250229f, 1.14981914f, 0.16422524f, -0.44962820f, -0.34120530f, -0.26844013f, 
    -0.01570174f, 0.59970099f, -0.66156512f, -0.82927352f, -0.24870686f, -0.49299666f, -0.68190807f, 0.04785100f, 
    -0.69105631f, -0.25352117f, 1.02632344f, 0.32505041f, 0.06938288f, -1.05818236f, -0.36922687f, 0.35933673f, 
    -0.24723367f, 0.43515280f, 0.21485612f, -0.85018891f, -0.23189245f, 0.23882230f, -0.16879189f, -1.17585158f, 
    -0.76225019f, -0.30821139f, -0.21944506f, -0.79619873f, -0.17632914f, -0.11342759f, -0.21730600f, 0.43919411f, 
    0.83400667f, 1.00890899f, 0.43050352f, 0.37248677f, 0.37172869f, -0.90331852f, -0.32242152f, -0.30364141f, 
    0.44476709f, 0.12399898f, -0.32715994f, 0.52655411f, 0.15195851f, 0.85908514f, 0.05733785f, 0.05525389f, 
    -0.08700950f, 0.59933776f, 1.03439212f, -0.85953736f, -0.40436688f, 0.25841665f, -0.15169570f, -0.38469160f, 
    -0.62166846f, 0.04940557f, 0.23780397f, -0.60207790f, -0.39553103f, 0.80262995f, 0.98026878f, 0.06133151f, 
    -1.56969285f, 0.23373637f, 0.83400077f, -0.21347055f, 0.50140673f, 1.10506642f, -0.35734338f, -0.51289624f, 
    0.23286493f, -0.70742613f, -0.39545774f, 1.00848496f, 0.65767473f, -0.32675633f, -0.60696298f, -0.06119589f, 
    0.72809249f, -0.35628766f, 0.46383047f, -0.19141026f, -0.16475226f, -0.81079072f, -1.21126521f, -1.52899802f, 
    0.87666363f, -0.27011803f, 0.55822963f, 0.56336802f, -0.72888291f, -0.70790452f, -0.73121065f, 0.50606722f, 
    -0.49107480f, -0.37353355f, -0.41562617f, -0.20119330f, 0.26576036f, 0.84458327f, 0.81249678f, 0.09445685f, 
    0.19897291f, 0.50580066f, -0.30093035f, -0.83967274f, -0.31462833f, 0.85148430f, -0.26176351f, 0.54258835f, 
    -0.01750610f, -0.00492025f, 0.19766222f, -0.46009743f, 0.39871269f, 0.16486730f, -1.15179801f, 0.25454199f, 
    0.61229229f, 0.05935259f, 0.05195544f, -0.97525012f, -0.45583615f, -0.57223910f, -0.56753218f, -0.37854463f, 
    0.08498466f, 1.03264439f, -0.62132031f, 0.53997582f, -0.23833641f, 0.64192855f, -0.00456746f, -0.62837821f, 
    -0.08476851f, -0.17014478f, 0.49786547f, -0.29851356f, -0.11743249f, -0.49706930f, 1.03007591f, 0.18679090f, 
    0.24589631f, 0.42038354f, 0.25239444f, 0.95227343f, 0.64211529f, -0.37184808f, -0.00532583f, -0.25303805f, 
    -0.28452963f, 0.50320846f, -0.21416034f, -0.56517029f, 0.99895751f, -0.21450451f, 0.50553942f, -0.45762557f, 
    0.50669992f, -0.72135246f, -0.01526513f, 0.46926910f, 0.29598099f, -0.42022049f, 0.03909587f, 0.93891144f, 
    -0.42187625f, 0.15491468f, -0.59207588f, -0.36318344f, -0.10034492f, -0.83315152f, -1.18619502f, 0.93891364f, 
    0.60646993f, 0.62922704f, -0.37051889f, -0.20610441f, -0.31646284f, -1.05261564f, 0.10285467f, -0.26866609f, 
    -0.57564968f, -0.39222988f, -1.09374082f, -0.15020947f, 0.84273237f, 0.00512145f, -0.46718758f, 0.70718348f, 
    0.19766593f, -1.54218972f, -0.49275941f, -0.15191193f, -0.37555569f, -0.79805219f, 0.06240220f, -0.08986253f, 
    -0.15263610f, -1.16966319f, -0.44713119f, 0.19786441f, 0.15747833f, 0.56000751f, 0.24219447f, 0.63667351f, 
    0.78525037f, 0.62674540f, 0.42581400f, -0.75422901f, 0.38937345f, -0.55067635f, -0.25839895f, 0.30232209f, 
    0.63121891f, -0.31523269f, 1.16061985f, -0.78211373f, -0.82938999f, 0.85903591f, -0.02849844f, 0.26606458f, 
    -0.06623871f, 0.45009637f, 1.01160991f, -1.07992685f, 0.25575733f, 0.31406531f, -0.39782873f, 0.13304836f, 
    -0.21365632f, -0.28479490f, 0.65478516f, 0.55786777f, 0.58384681f, 0.03343002f, -0.62869066f, -0.97533876f, 
    0.99667442f, 0.58922535f, 0.20660101f, -0.05789918f, -0.40461174f, 0.47838208f, -0.34381229f, 0.46527818f, 
    0.74282110f, -0.31908855f, -0.24375725f, 0.59433377f, -0.33866018f, 1.52346706f, -0.70063716f, -0.62569672f, 
    0.57571048f, -0.04139027f, 0.30291817f, -0.12737365f, -0.08784939f, -0.72610277f, -0.99935633f, -0.75986671f, 
    -0.34102598f, -0.09858076f, 0.54975522f, -0.16643281f, -0.36342567f, -0.52328730f, -0.54840451f, -1.20910549f, 
    -0.94760942f, 0.38569179f, 0.02600537f, -0.97047234f, 1.10978460f, 0.36231512f, -0.39322165f, -0.54278678f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44943300f, -0.22098008f, 0.49235526f, -0.19611885f, 0.14329489f, -0.06924670f, -0.09212733f, 0.35476285f, 
    0.30160981f, -0.16066794f, 0.27046859f, 0.41318548f, -0.24126187f, 0.73716372f, 0.22976479f, 0.01194177f, 
    -0.18728746f, 0.63295531f, -0.15488312f, 0.15539642f, 0.05740100f, -0.06784751f, 0.00652972f, 0.50236022f, 
    0.09169716f, 0.26888669f, 0.35404202f, 0.30793905f, 0.59253842f, -0.02113443f, -0.34070900f, 0.45397758f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.15346354f, 0.38148934f, 0.32629567f, 0.00387563f, 0.21328455f, 0.02799088f, 0.08524287f, -0.08879685f, 
    -0.06856612f, -0.20190771f, 0.15293695f, -0.06494527f, 0.06822164f, 0.16866276f, -0.10973724f, -0.08107132f, 
    -0.14182125f, -0.15890953f, -0.14130999f, 0.10394879f, -0.11180949f, 0.06682332f, -0.13687854f, -0.29419488f, 
    0.05785557f, 0.05733764f, 0.08875595f, 0.03901437f, 0.07060623f, -0.16082212f, 0.09354445f, -0.11628528f, 
    -0.00741541f, 0.01982279f, 0.06175150f, -0.15041319f, -0.17248634f, -0.07584865f, -0.12112878f, 0.01235421f, 
    0.21183637f, 0.16544400f, -0.02523351f, 0.00867340f, -0.20741159f, 0.04562780f, -0.20377368f, 0.03744689f, 
    0.19047864f, 0.21356975f, 0.30894595f, -0.03086301f, 0.19343539f, 0.11868852f, -0.16455597f, -0.12383129f, 
    -0.10287238f, 0.02165147f, 0.12902400f, -0.00197028f, -0.20484434f, -0.23096547f, -0.05100995f, 0.16352439f, 
    0.05939138f, -0.15523738f, 0.00081844f, 0.15816399f, 0.15368597f, -0.03620011f, -0.02689453f, 0.03538701f, 
    -0.26303843f, -0.33938187f, 0.00112519f, 0.10347205f, -0.03691744f, -0.08018081f, -0.01745934f, 0.03517897f, 
    0.12582242f, 0.24015795f, -0.17873830f, -0.05015712f, -0.33803290f, 0.20842324f, 0.04779357f, -0.20946863f, 
    -0.04755936f, 0.28027061f, -0.06444345f, 0.28576681f, -0.12999663f, 0.02650857f, -0.30738664f, 0.00012143f, 
    -0.20420289f, -0.03325956f, 0.13426407f, -0.01238981f, 0.13182768f, -0.04072323f, -0.12909476f, -0.02796532f, 
    0.06772806f, -0.00548900f, -0.04883320f, -0.23556969f, -0.28110456f, -0.20345011f, -0.11366471f, 0.00647652f, 
    0.04442142f, 0.00584299f, 0.16343519f, -0.02255403f, 0.05002588f, -0.08107015f, -0.11515037f, -0.33479106f, 
    -0.01471941f, 0.01285393f, 0.04186033f, 0.07708158f, 0.07246090f, 0.03518588f, 0.26634410f, 0.16667272f, 
    0.06015811f, 0.17952594f, -0.35481665f, -0.02630755f, -0.01237558f, 0.03297508f, 0.01522487f, 0.25653675f, 
    -0.22726300f, 0.01754184f, -0.11927034f, 0.06109203f, -0.29253751f, -0.07070886f, -0.00882669f, 0.00634739f, 
    -0.00743694f, 0.08156087f, 0.06210315f, -0.00508431f, -0.08230282f, -0.06006655f, -0.15560868f, -0.02126289f, 
    0.01295179f, -0.13892624f, -0.18729025f, -0.34828600f, -0.03915397f, 0.08031897f, 0.01304711f, 0.17162971f, 
    0.13268001f, 0.01865105f, 0.26003101f, 0.21375626f, -0.20634878f, -0.21914724f, 0.01189918f, -0.28102076f, 
    -0.08842248f, 0.10469812f, 0.24597518f, -0.18526688f, 0.09120149f, -0.27935764f, -0.04925705f, -0.07359868f, 
    -0.01852110f, 0.14007917f, 0.05626053f, 0.05165314f, 0.24300864f, 0.52918017f, 0.36722147f, 0.17094114f, 
    -0.01661286f, -0.07358423f, 0.16715600f, 0.14172857f, -0.03446992f, 0.09375983f, -0.14269912f, -0.00642519f, 
    -0.12864482f, -0.26922521f, -0.06689328f, 0.03553181f, 0.10908152f, 0.10041826f, -0.22481349f, -0.21715322f, 
    0.07827928f, 0.24320483f, -0.07553145f, -0.17182440f, 0.00281032f, -0.06224700f, 0.02070684f, 0.14022698f, 
    -0.03252253f, -0.03446217f, 0.09833801f, 0.24665326f, 0.07379781f, 0.17314194f, 0.13763149f, 0.02848134f, 
    -0.35368094f, -0.23589897f, -0.17600164f, -0.08714724f, -0.27206346f, -0.07817857f, 0.15637340f, 0.05987991f, 
    0.00670624f, -0.23449513f, -0.23611404f, -0.25291842f, 0.03784731f, -0.07619974f, 0.16897328f, 0.10787991f, 
    -0.01569625f, 0.04556971f, 0.38303828f, 0.06386635f, -0.60893846f, -0.17504965f, 0.11414458f, -0.09941414f, 
    0.10913028f, 0.17089432f, 0.11038528f, -0.19523595f, -0.07499558f, 0.01761324f, -0.05409728f, 0.06264741f, 
    -0.14263104f, -0.01883455f, -0.02285098f, 0.08603503f, -0.25485465f, -0.44480997f, 0.10721418f, -0.13234177f, 
    0.09253610f, 0.05540018f, 0.08335075f, -0.13817675f, 0.01770926f, 0.84849185f, 0.21053015f, -0.18257789f, 
    0.05164508f, -0.13493340f, -0.07101261f, -0.10698465f, 0.03019068f, 0.22067736f, 0.33698523f, 0.13739476f, 
    0.39021188f, 0.03859543f, -0.17947736f, -0.10391136f, 0.04369840f, -0.06223632f, -0.11407895f, 0.14806409f, 
    0.00918179f, -0.03197445f, -0.07618991f, 0.16546319f, 0.03864851f, 0.18190701f, 0.08651339f, -0.17589357f, 
    0.18581326f, -0.29515761f, -0.39734855f, -0.09195451f, 0.08681989f, -0.16013207f, 0.00133295f, -0.12333029f, 
    0.05397680f, -0.29966202f, -0.26740298f, -0.41234449f, 0.04906705f, 0.02058110f, 0.00295405f, 0.16985594f, 
    0.07520803f, -0.01612962f, 0.30916283f, -0.13960660f, -0.01272941f, 0.09010646f, 0.13831988f, 0.20228158f, 
    0.09655105f, -0.01946572f, 0.12843423f, -0.06681328f, -0.14180450f, 0.04609109f, 0.10920683f, 0.09432336f, 
    0.01333039f, -0.03933815f, 0.15616843f, -0.16656730f, -0.07668712f, -0.03069033f, -0.17138368f, -0.01814457f, 
    -0.00840505f, -0.13807260f, -0.10025392f, -0.12815309f, -0.04535442f, -0.11591139f, 0.04715927f, 0.00578656f, 
    -0.18892838f, -0.02195762f, -0.00535150f, 0.01896155f, 0.02509232f, -0.07318404f, -0.08334008f, 0.08308813f, 
    0.19792230f, -0.10380293f, -0.13398503f, -0.19849499f, -0.14294669f, -0.00233434f, 0.03018121f, -0.01793318f, 
    0.02068289f, 0.34490848f, -0.00932494f, 0.06312781f, -0.05589688f, -0.05878951f, 0.06150964f, 0.00161523f, 
    0.10236221f, 0.30651709f, -0.16523363f, 0.10498473f, 0.02623761f, 0.02364185f, 0.22394024f, -0.12192844f, 
    -0.06136991f, -0.03892695f, 0.18931232f, 0.39649692f, 0.18907811f, 0.30720147f, -0.18846230f, -0.18638764f, 
    0.03476887f, -0.07427655f, -0.17272024f, -0.41771802f, -0.14117131f, -0.03445285f, 0.16172196f, 0.05102278f, 
    -0.04274951f, 0.27040240f, 0.15205449f, -0.10253984f, -0.24967618f, 0.32381877f, 0.00712846f, -0.04960258f, 
    -0.15749024f, -0.14701551f, 0.03262964f, -0.02538718f, -0.14397259f, -0.07723834f, -0.16548862f, -0.09634122f, 
    0.00203922f, -0.05049164f, -0.06362005f, -0.35127121f, -0.09118830f, -0.10477377f, -0.01068034f, 0.03692652f, 
    -0.20936482f, 0.09409119f, 0.17061676f, 0.00302022f, -0.07495345f, 0.03137602f, 0.08051152f, -0.08009706f, 
    -0.01181416f, 0.15954600f, 0.12403943f, 0.08118244f, -0.12314107f, -0.16726950f, -0.13380420f, -0.03716500f, 
    0.08045588f, 0.30119848f, -0.17076908f, 0.21661268f, -0.14628835f, -0.07097136f, 0.10347635f, 0.11740983f, 
    -0.10842179f, 0.12056385f, 0.11816719f, 0.00372925f, 0.14578961f, 0.03502288f, -0.10067476f, 0.17707922f, 
    0.30093363f, -0.20395675f, -0.00457830f, -0.02141935f, -0.03448738f, 0.07141303f, -0.11841653f, 0.18613225f, 
    -0.05699466f, -0.08852308f, -0.11781348f, 0.08523218f, 0.23723240f, -0.12413713f, 0.32162872f, -0.19199993f, 
    0.41798747f, 0.29393747f, -0.06320246f, -0.05120812f, 0.10323626f, 0.12824900f, -0.10756787f, 0.04807705f, 
    0.01694749f, -0.19772576f, 0.14479776f, -0.06209155f, 0.20727937f, -0.08636528f, -0.22524166f, -0.20050338f, 
    0.14272650f, 0.03760094f, -0.10961014f, -0.26619589f, 0.07816289f, 0.16210191f, 0.01224676f, 0.15069701f, 
    0.08654927f, -0.04016395f, 0.04445853f, 0.10813244f, 0.00888689f, 0.09503093f, -0.19745950f, -0.34455416f, 
    -0.34990379f, 0.13203605f, 0.07816220f, 0.00798585f, -0.01888929f, 0.07076836f, -0.15169065f, -0.19704632f, 
    0.05609555f, -0.07477110f, 0.04339064f, -0.04484912f, 0.04329441f, -0.02081801f, -0.00567260f, 0.05327652f, 
    -0.01705979f, 0.08509926f, 0.00208247f, 0.05184147f, 0.12440517f, 0.13439102f, 0.13033548f, 0.01016943f, 
    0.16754155f, -0.07641950f, 0.26654360f, 0.07227851f, 0.16113181f, 0.04771774f, 0.03776343f, 0.13357468f, 
    -0.01761839f, 0.18951517f, 0.13886335f, 0.06790499f, 0.08542962f, -0.00913170f, 0.05750741f, 0.06916504f, 
    0.09299020f, 0.11600088f, -0.06764633f, 0.17227554f, 0.02518653f, 0.00735911f, 0.00808247f, -0.01781769f, 
    0.10498953f, 0.01372935f, 0.12786002f, -0.05260381f, 0.07960124f, 0.02468664f, 0.05575578f, -0.13122317f, 
    0.00643936f, -0.12021489f, 0.04913190f, -0.15349850f, -0.03146464f, -0.07989641f, -0.02707272f, -0.00906173f, 
    -0.08859151f, 0.04025294f, 0.24772741f, -0.28906941f, 0.19062451f, -0.09634075f, 0.45250612f, -0.21466962f, 
    -0.14600480f, -0.00831512f, -0.07635434f, -0.15581669f, 0.15299979f, -0.04476631f, -0.01551300f, 0.38746616f, 
    0.17413756f, 0.01159498f, 0.07981203f, 0.03454069f, -0.16274466f, 0.07002746f, 0.19051616f, -0.08208133f, 
    0.12461010f, -0.08135821f, -0.51900566f, 0.09194961f, 0.00079015f, 0.07885374f, -0.04648602f, -0.10219510f, 
    0.01280378f, 0.19135834f, -0.18528180f, -0.06118758f, 0.07877579f, -0.00771886f, 0.13091128f, 0.22169244f, 
    -0.10102989f, 0.04955471f, -0.19899532f, 0.02269814f, -0.01150502f, 0.04675491f, 0.12522915f, -0.09735428f, 
    -0.02048104f, 0.15829854f, 0.14602296f, 0.13735379f, 0.21751468f, -0.09675363f, 0.10236228f, -0.02229186f, 
    0.18153021f, 0.00983952f, 0.06702267f, -0.17597696f, 0.06808332f, -0.06543962f, -0.06537475f, 0.08446237f, 
    0.05431852f, 0.11571675f, -0.02356099f, 0.19425100f, 0.07021236f, -0.05078071f, -0.01550333f, -0.04295518f, 
    -0.04699088f, -0.00432429f, -0.25923255f, 0.18396547f, 0.24034055f, 0.07407580f, -0.15701026f, -0.08957496f, 
    -0.02724821f, 0.16749011f, 0.16811672f, 0.20719509f, -0.00344848f, -0.05666487f, 0.07077242f, 0.20889716f, 
    0.16871817f, -0.17906068f, -0.04617726f, 0.14867711f, -0.17184418f, 0.14898124f, 0.19032562f, 0.07140107f, 
    0.10946145f, -0.12217917f, 0.09722227f, 0.20833798f, 0.04859470f, 0.07810653f, -0.08871099f, -0.08890986f, 
    -0.25189197f, -0.05452547f, 0.36657721f, -0.39722779f, 0.39860964f, -0.06390963f, -0.13451749f, 0.12375636f, 
    0.02830934f, -0.16351777f, 0.41193309f, 0.09694020f, 0.07072954f, 0.10132838f, 0.13640705f, 0.15638378f, 
    0.06167501f, 0.04162369f, 0.18489245f, 0.03816048f, -0.16639258f, -0.09834841f, 0.15936951f, 0.08137933f, 
    0.01478482f, 0.05212334f, 0.01226805f, 0.07217724f, -0.15746507f, 0.02106254f, 0.02004775f, 0.07275704f, 
    -0.05671994f, 0.15641262f, -0.28433105f, -0.29903883f, -0.07606491f, -0.08735211f, 0.10188042f, 0.12997162f, 
    0.16460474f, 0.02926953f, -0.05825868f, -0.10060775f, 0.04177359f, -0.25357664f, 0.01640193f, 0.24029204f, 
    -0.08738444f, -0.01529509f, -0.00743945f, 0.09775145f, -0.15205073f, -0.14953493f, -0.21310772f, 0.21598227f, 
    0.07341018f, 0.03273856f, 0.20971166f, 0.23235863f, 0.06565423f, 0.16602847f, 0.51947194f, -0.16897008f, 
    0.02349697f, -0.12272240f, 0.05237157f, -0.08411150f, 0.12796214f, -0.17651914f, 0.14491822f, 0.32173365f, 
    0.05308566f, -0.16907111f, 0.04395053f, 0.05172027f, 0.01527706f, -0.07916129f, 0.09983741f, -0.03754463f, 
    -0.17558464f, -0.50195938f, 0.12285915f, 0.09368449f, 0.05343219f, 0.18451223f, 0.03965783f, -0.01670521f, 
    -0.26647100f, 0.28563148f, -0.24478053f, -0.15615128f, -0.07602909f, 0.15885752f, 0.30269268f, -0.02879335f, 
    0.08802625f, -0.17579646f, -0.25597888f, -0.19281408f, -0.04997952f, -0.15808679f, -0.33134758f, 0.03132645f, 
    0.03786627f, 0.10774735f, -0.16807756f, -0.23729993f, -0.31608483f, 0.16893457f, 0.41009915f, 0.16065034f, 
    0.03793019f, 0.05236885f, 0.02038214f, 0.01021919f, 0.01910390f, 0.18043612f, 0.08660198f, 0.07324487f, 
    0.08787370f, 0.05907711f, 0.13668185f, -0.01754128f, 0.07687815f, 0.14318271f, -0.19002250f, 0.07914447f, 
    0.04130712f, -0.14608629f, -0.25894517f, -0.20393248f, -0.07914431f, 0.10935135f, 0.09726071f, 0.16204372f, 
    -0.23718032f, 0.07598959f, 0.27430999f, -0.02799170f, -0.01959571f, -0.13170120f, 0.12197243f, 0.14228536f, 
    0.08677595f, -0.02335226f, 0.03251834f, 0.11278670f, -0.03688834f, 0.12525305f, -0.01304609f, 0.07979804f, 
    0.37356448f, 0.10457406f, -0.03664668f, 0.02555993f, -0.07697107f, 0.32373229f, -0.23259826f, -0.14560394f, 
    0.15185833f, -0.27076367f, -0.38123420f, -0.11423848f, -0.17899521f, -0.12530829f, -0.08020753f, -0.00218273f, 
    -0.12975375f, -0.27268088f, 0.10679781f, 0.04226227f, -0.08314683f, 0.06284633f, 0.04189240f, 0.17352130f, 
    0.27550712f, 0.19050966f, 0.05543022f, 0.16365694f, 0.17177109f, -0.30184188f, -0.14231323f, 0.07263360f, 
    0.36431873f, 0.08660786f, 0.10033336f, 0.13008511f, -0.16566421f, -0.43640637f, 0.03966059f, -0.35187182f, 
    -0.35965505f, -0.06001928f, -0.02015128f, 0.10651147f, -0.28028736f, -0.12513733f, -0.14373441f, 0.11419779f, 
    0.17055917f, -0.13163514f, 0.03338904f, 0.16730607f, 0.10685805f, -0.01591491f, -0.33875725f, -0.04977037f, 
    -0.27526999f, 0.01319160f, 0.24690883f, -0.13109392f, 0.11655863f, 0.02762422f, 0.04184421f, -0.17051589f, 
    0.07396086f, 0.16828784f, -0.03039313f, -0.05626689f, 0.06763057f, -0.06137801f, 0.23280540f, 0.00523694f, 
    -0.00227392f, 0.02737275f, 0.35309592f, -0.34445742f, 0.12002479f, -0.20450738f, 0.00573032f, 0.03566471f, 
    0.06805888f, 0.11308838f, -0.03322596f, -0.24203278f, -0.20319371f, 0.13332547f, 0.00518432f, 0.05284171f, 
    0.07265635f, 0.16769561f, -0.05878446f, 0.08308043f, -0.23503554f, -0.00821400f, -0.20173715f, -0.16713886f, 
    -0.05608251f, 0.11993976f, 0.16249472f, 0.02299974f, 0.03350579f, -0.06971439f, -0.07779112f, 0.08165480f, 
    -0.19945791f, -0.12854190f, -0.16853248f, 0.18266535f, -0.03445597f, -0.04816550f, -0.39516440f, 0.15698436f, 
    -0.00939541f, 0.19718835f, -0.10927518f, -0.13717401f, 0.20093213f, -0.07125898f, -0.01907349f, 0.06074341f, 
    0.04280782f, 0.08718842f, -0.04265908f, 0.02402660f, 0.04437094f, 0.13071281f, -0.04430755f, 0.16051035f, 
    -0.67828864f, 0.22732656f, -0.13753112f, -0.09554195f, 0.20349909f, -0.00473024f, 0.08393118f, 0.04880169f, 
    0.01417181f, -0.52648848f, -0.10498726f, 0.13596022f, -0.11334410f, 0.32338992f, -0.14295016f, -0.06393363f, 
    -0.15592787f, 0.35517231f, -0.10185018f, 0.08439576f, 0.17100018f, -0.07821479f, -0.14215784f, -0.08021981f, 
    0.15193465f, 0.18178168f, 0.06883556f, 0.11896648f, 0.04645608f, 0.09323870f, 0.15286197f, 0.08163563f, 
    0.15902978f, -0.18483368f, -0.06382024f, 0.34197056f, -0.09350614f, -0.02015348f, -0.13790900f, -0.12360717f, 
    -0.35588309f, -0.17940520f, -0.04613788f, 0.07061083f, -0.04081653f, 0.01527430f, -0.24708498f, 0.01048703f, 
    -0.15050909f, -0.06733080f, 0.15406430f, 0.09609077f, -0.04245051f, 0.03040686f, -0.51943249f, -0.18488356f, 
    0.22318055f, 0.09598792f, -0.04929566f, 0.02281565f, 0.07244133f, -0.05419002f, -0.12984572f, 0.00393925f, 
    0.27975002f, -0.02624457f, -0.16795419f, 0.13364795f, -0.05358706f, -0.05143258f, 0.21185108f, -0.02709707f, 
    -0.21005300f, -0.13781497f, -0.04169076f, -0.18221612f, 0.02081406f, -0.11603194f, -0.01335241f, 0.12731032f, 
    0.02742718f, -0.09464011f, -0.09403880f, 0.19826330f, -0.20407499f, -0.12857918f, 0.00188904f, 0.21604866f, 
    0.20186934f, -0.05127836f, -0.54215330f, 0.34333375f, 0.38073775f, -0.22769088f, 0.14768161f, 0.24194446f, 
    -0.03804709f, 0.02106171f, 0.10800806f, 0.00981233f, 0.12731442f, -0.08594709f, 0.01743529f, -0.06203695f, 
    -0.01681422f, 0.01686453f, -0.04187200f, -0.11118901f, -0.46115196f, 0.06912518f, 0.17116418f, -0.01927548f, 
    -0.04034264f, -0.16484949f, 0.07193556f, -0.13288739f, -0.03586647f, -0.20282315f, 0.16166712f, 0.27471066f, 
    -0.08930835f, 0.09821954f, 0.03587416f, 0.03087573f, -0.05992888f, 0.18383801f, -0.08228134f, -0.00502583f, 
    0.06818496f, 0.07556438f, 0.13569285f, -0.06887614f, 0.18503091f, -0.03276934f, 0.13235858f, -0.11567951f, 
    0.02437934f, 0.19853637f, -0.06970075f, 0.05035465f, -0.07366557f, 0.18007395f, 0.12433509f, 0.03536971f, 
    -0.26199701f, 0.03745758f, 0.12320870f, -0.11715750f, -0.09846981f, -0.10418919f, -0.15207301f, 0.07221585f, 
    -0.12877767f, -0.27148587f, 0.09939235f, 0.14298552f, 0.18978299f, 0.32574609f, 0.11437868f, -0.06273427f, 
    -0.05540548f, 0.05969852f, 0.27358410f, -0.16809726f, 0.18547964f, -0.11729445f, 0.00661889f, 0.39242959f, 
    -0.08310522f, -0.05379173f, -0.12945560f, -0.14379318f, -0.03819773f, -0.17052452f, -0.25567266f, -0.15616873f, 
    0.02950335f, -0.00572851f, 0.00629418f, 0.26423824f, -0.24248491f, 0.17066142f, 0.07981800f, 0.16035573f, 
    0.29463264f, 0.11536295f, 0.09091590f, 0.20076276f, 0.14014715f, 0.26339951f, -0.24322949f, -0.06888863f, 
    0.14789489f, -0.08850215f, 0.32765451f, -0.16662358f, 0.00989762f, -0.13949440f, -0.48317462f, -0.04983864f, 
    0.13489155f, -0.11354754f, -0.02686147f, 0.02503771f, 0.05860504f, -0.08844592f, -0.13293840f, -0.08742351f, 
    0.20074083f, 0.28988144f, -0.23247845f, 0.04908027f, 0.12280717f, 0.06414777f, 0.00994815f, 0.03296923f, 
    0.03102522f, 0.01214105f, -0.04009035f, -0.02293173f, -0.02909588f, -0.04546975f, 0.04288794f, -0.05154585f, 
    -0.02732345f, -0.02328795f, 0.03313596f, -0.01246603f, -0.05020891f, -0.00299291f, -0.00601516f, -0.00783968f, 
    0.02938043f, 0.02119866f, 0.03950055f, 0.02718167f, 0.03442884f, -0.06137138f, 0.00625217f, 0.02297488f, 
    0.02196888f, 0.01779762f, -0.02680996f, 0.01037950f, 0.03009051f, -0.04846615f, 0.00047586f, 0.00968718f, 
    -0.05635389f, 0.03374888f, -0.03886520f, -0.02478057f, -0.05466333f, -0.05634909f, 0.04612433f, 0.03842762f, 
    -0.03997996f, -0.02360946f, 0.00548085f, 0.01034205f, -0.00394489f, -0.03523608f, -0.01208230f, -0.02180599f, 
    -0.01557008f, -0.03498486f, 0.02021252f, 0.03425403f, -0.05598038f, 0.03315638f, 0.00519390f, 0.04360116f, 
    -0.01757164f, 0.02042466f, -0.05767140f, 0.00549053f, 0.03321197f, -0.01645046f, -0.01729309f, 0.02388802f, 
    -0.05478512f, 0.00882363f, -0.05211550f, -0.04356398f, -0.04995678f, 0.01060292f, -0.03490956f, 0.00103260f, 
    0.00584576f, -0.05516983f, -0.03419413f, 0.03895542f, 0.03379409f, -0.03591661f, 0.00069309f, 0.00051815f, 
    0.00816328f, -0.05821405f, -0.04116812f, -0.04333403f, -0.04996240f, -0.06117524f, -0.06014620f, -0.05902201f, 
    0.01191856f, -0.04061076f, 0.04993166f, -0.00036034f, 0.01185506f, -0.00382628f, 0.00752436f, 0.03497542f, 
    -0.03023064f, -0.02122767f, 0.02345560f, 0.03969405f, 0.01516053f, 0.02434258f, -0.06221076f, -0.01117606f, 
    0.01100610f, -0.06249085f, -0.06340358f, 0.04390413f, -0.03748944f, -0.02993011f, -0.02361945f, -0.03152852f, 
    0.03943549f, 0.01302795f, -0.00528666f, -0.02773527f, 0.01191633f, -0.03218161f, 0.02111576f, -0.00312272f, 
    0.01874555f, 0.04564842f, -0.02900157f, 0.05472479f, 0.01425785f, -0.00205691f, 0.02239146f, 0.00317594f, 
    0.05624694f, -0.01630846f, -0.05450462f, 0.00785360f, -0.01347918f, -0.03256728f, -0.05396114f, 0.00848032f, 
    0.04605189f, -0.00871000f, -0.02545901f, -0.02564680f, -0.05401900f, -0.02958541f, 0.05174559f, 0.03788118f, 
    0.01493484f, -0.04036889f, -0.04675214f, -0.05959360f, 0.03021622f, -0.04733222f, 0.02297471f, 0.03986484f, 
    -0.03733140f, -0.02501698f, 0.04289126f, -0.05971225f, -0.00911569f, -0.03631630f, -0.00812873f, -0.04594253f, 
    0.02218208f, 0.03658916f, -0.03970230f, -0.03515368f, 0.00684749f, -0.01587960f, -0.06619123f, -0.03061184f, 
    -0.00175207f, -0.05724249f, 0.00556893f, 0.00870414f, -0.04517607f, -0.03152200f, -0.04002268f, -0.06130918f, 
    -0.04598525f, -0.02884143f, -0.01136922f, -0.01659974f, 0.01262909f, 0.01029369f, 0.02770061f, 0.00750981f, 
    -0.01226765f, 0.01322810f, -0.01322953f, -0.05970229f, -0.03575101f, -0.02596739f, 0.02239056f, 0.00285640f, 
    0.03618883f, 0.00532552f, 0.03796622f, -0.02969811f, 0.05264236f, 0.00969024f, -0.00807484f, -0.04308751f, 
    -0.06095578f, -0.01032326f, -0.00017283f, 0.00998057f, -0.06094278f, 0.01647736f, 0.04727196f, -0.03003422f, 
    -0.03581046f, 0.01169183f, -0.01612824f, 0.00060148f, 0.05341808f, -0.04178667f, 0.03839273f, -0.05977257f, 
    0.02882501f, -0.03764663f, -0.05838890f, -0.03092319f, 0.01797643f, 0.04404796f, -0.05452535f, 0.04964302f, 
    -0.00198553f, -0.06032661f, -0.04397295f, 0.03177238f, -0.00168437f, 0.02349363f, -0.05160558f, 0.04631334f, 
    0.04641212f, -0.03783300f, 0.01120477f, 0.04384778f, 0.01073308f, 0.04953893f, 0.01992593f, 0.04680416f, 
    0.01920167f, 0.01165323f, -0.03862900f, -0.03113117f, 0.05307547f, -0.00518187f, -0.00643182f, 0.04292135f, 
    -0.02385149f, 0.01316939f, 0.03312559f, -0.04505169f, 0.00451682f, 0.00994484f, -0.05526191f, -0.00237283f, 
    0.04427242f, -0.00405179f, -0.01552422f, -0.03259133f, 0.00308381f, -0.06087865f, 0.03859572f, 0.02598779f, 
    -0.06271687f, -0.04264501f, 0.01006500f, -0.03435393f, -0.03482150f, 0.00922723f, -0.04681421f, -0.04727433f, 
    -0.04136514f, -0.05754487f, 0.04031176f, -0.01171387f, 0.01824164f, 0.04134871f, 0.03550699f, 0.00881036f, 
    -0.04755928f, -0.03281595f, -0.03773670f, -0.05046360f, -0.05757932f, 0.01800482f, -0.02612238f, 0.04530737f, 
    0.06223333f, -0.26659405f, -0.06361254f, -0.01506853f, -0.18055065f, -0.22281843f, -0.04212945f, 0.06602329f, 
    -0.01857185f, 0.25194848f, 0.10043313f, 0.25980821f, 0.10153978f, -0.18469763f, 0.05370246f, 0.08536631f, 
    -0.13017185f, 0.10701170f, -0.42036232f, 0.00826244f, -0.15310845f, -0.09189229f, 0.08074740f, -0.10444397f, 
    -0.12642990f, -0.00145870f, -0.20694326f, 0.26212463f, 0.06859420f, 0.07380769f, -0.15658778f, 0.10686544f, 
    -0.22029875f, 0.15127625f, -0.13515657f, 0.27584735f, 0.14842522f, 0.15999092f, -0.15175889f, -0.17722459f, 
    -0.19109973f, -0.04019915f, 0.01337882f, -0.02056685f, 0.03734726f, 0.51749510f, 0.15455562f, -0.07623901f, 
    0.03806540f, 0.09419124f, -0.15225497f, 0.28564334f, -0.05190198f, 0.17237687f, 0.05649908f, 0.42066512f, 
    0.33836320f, -0.42612645f, -0.44765747f, -0.17646787f, 0.01731742f, 0.27852088f, 0.29717177f, 0.50046134f, 
    0.04242758f, 0.11789111f, 0.08528859f, 0.00124833f, -0.20843174f, 0.27693012f, -0.02570352f, -0.19026594f, 
    0.12906188f, 0.39107129f, -0.28533366f, -0.07160661f, 0.04897960f, -0.03313175f, -0.11661511f, -0.15619960f, 
    -0.00373541f, 0.51457769f, 0.10874266f, -0.01220873f, 0.04457558f, 0.39351910f, -0.27836871f, 0.12023927f, 
    0.25892559f, -0.01519898f, 0.07902302f, 0.30497274f, 0.27346200f, 0.08433920f, -0.06123543f, -0.13799597f, 
    -0.09216712f, 0.08654914f, -0.16498315f, -0.14052097f, -0.07721890f, 0.02554633f, -0.07116546f, -0.11411922f, 
    0.26278770f, -0.10048646f, 0.10190199f, 0.05303266f, 0.09177859f, 0.01788275f, -0.07048829f, -0.03442351f, 
    -0.14565125f, -0.11941873f, 0.18670128f, 0.12562738f, 0.22861311f, -0.31595990f, -0.15186557f, -0.03599080f, 
    -0.14018774f, -0.06630692f, 0.18912086f, -0.06833942f, -0.04125136f, -0.22143993f, -0.00119749f, 0.00634198f, 
    -0.03448152f, -0.16947056f, 0.07133549f, -0.29797509f, 0.13382515f, -0.21676677f, 0.22833206f, -0.35090652f, 
    0.48831654f, 0.12476796f, -0.27750334f, 0.07068720f, -0.31998259f, 0.04037696f, 0.13086240f, 0.04609715f, 
    -0.21344954f, 0.16217573f, 0.12091646f, 0.16050850f, 0.14269406f, -0.05916943f, 0.20529030f, 0.26042324f, 
    -0.20580484f, -0.08924928f, -0.04022751f, 0.06232461f, -0.13349906f, -0.18001555f, 0.00513772f, 0.05347890f, 
    0.04748094f, -0.15618554f, -0.17570899f, 0.39421025f, 0.10333084f, 0.02032893f, -0.09840276f, -0.33131295f, 
    -0.10669342f, -0.30298617f, 0.18738244f, -0.21460721f, 0.24795851f, 0.20469193f, -0.56341714f, -0.35184550f, 
    -0.16367266f, -0.00662570f, 0.13986915f, 0.28114262f, 0.22067477f, -0.04418902f, 0.17569579f, -0.02194914f, 
    -0.10586058f, -0.00589419f, -0.12418114f, 0.04512805f, 0.12563670f, 0.19408219f, 0.26728353f, 0.31020802f, 
    -0.25776908f, 0.03799638f, -0.20859353f, -0.01756615f, 0.11653538f, 0.02527832f, 0.11267658f, 0.47283852f, 
    0.12288545f, 0.02815553f, -0.01683182f, -0.04375300f, -0.22984435f, -0.03573461f, 0.17882675f, 0.25950378f, 
    0.15052029f, -0.04211847f, 0.15444200f, -0.03239639f, -0.11867560f, -0.03633056f, -0.01885857f, -0.01325028f, 
    -0.11957415f, 0.37294170f, 0.16660537f, 0.14943741f, -0.05403809f, 0.08465362f, -0.12940691f, -0.10879296f, 
    -0.01508850f, -0.30064470f, 0.36588714f, 0.08176919f, 0.05510132f, 0.16439146f, -0.09988541f, -0.13270113f, 
    -0.07368889f, 0.01734659f, -0.49260715f, -0.15548551f, 0.12301594f, -0.17351311f, -0.00346111f, 0.07904512f, 
    0.15590538f, -0.17977431f, -0.13649298f, -0.22146282f, -0.06988170f, -0.15107624f, -0.09621450f, -0.13503003f, 
    -0.19035411f, 0.26321614f, 0.15252993f, 0.09365334f, -0.15755612f, 0.21782874f, 0.05771771f, -0.19898269f, 
    -0.03602438f, 0.07593443f, -0.13630940f, 0.02649181f, 0.08088936f, -0.23240374f, -0.05079652f, 0.04098438f, 
    -0.12148780f, -0.23925290f, 0.25564140f, 0.02709745f, -0.10058427f, 0.26050052f, 0.29618773f, -0.12820059f, 
    0.03977056f, 0.06156445f, 0.00576505f, -0.01071286f, -0.10135000f, 0.07935376f, 0.24257584f, 0.20433016f, 
    0.06951417f, 0.00772293f, -0.12099637f, 0.15179417f, -0.08248167f, -0.11870869f, -0.18068221f, 0.02074984f, 
    0.02790718f, 0.00489915f, 0.03131460f, 0.02421756f, -0.02873966f, -0.00329212f, 0.04362299f, 0.04724094f, 
    0.03887688f, -0.00411143f, -0.06187348f, 0.00076700f, 0.00825745f, -0.02655405f, 0.05162165f, -0.00059663f, 
    -0.04820929f, -0.04389867f, 0.00426517f, -0.03772316f, -0.03162054f, 0.00429272f, -0.01434152f, -0.05497989f, 
    -0.03925144f, -0.05957147f, -0.00898388f, 0.05151442f, -0.05107871f, -0.00377624f, -0.06361505f, 0.01819200f, 
    -0.00498768f, 0.02918054f, -0.05479825f, -0.03648786f, -0.03382289f, 0.03885198f, 0.04725548f, -0.05637247f, 
    -0.02638613f, -0.02520094f, -0.05666819f, 0.01336531f, 0.00956553f, -0.04178079f, 0.04750312f, -0.06442217f, 
    0.03183906f, -0.05723872f, -0.05696220f, -0.04751354f, 0.01518045f, -0.04841987f, -0.02547367f, -0.02641321f, 
    -0.01524439f, -0.01315922f, 0.05458488f, 0.03570594f, 0.02923504f, -0.04880266f, -0.01657682f, 0.00832140f, 
    0.01246451f, -0.02171787f, 0.00972960f, -0.01236369f, -0.03391707f, -0.04694727f, -0.06184410f, 0.00616497f, 
    0.04006888f, -0.01497841f, 0.00580890f, 0.03449034f, -0.05278766f, 0.04520712f, -0.01436457f, -0.04625160f, 
    0.01648176f, -0.05593802f, 0.02679461f, 0.02460321f, -0.01578000f, 0.00028383f, 0.03914857f, -0.01495322f, 
    -0.00176832f, -0.02667555f, 0.04531846f, -0.05666377f, -0.00219890f, 0.02551761f, -0.00061948f, 0.01327533f, 
    -0.03373853f, 0.05474765f, -0.05084494f, 0.00790331f, 0.04904420f, -0.05859917f, -0.05957791f, -0.02506634f, 
    -0.05842220f, -0.05699041f, 0.03649525f, 0.03138797f, -0.03747921f, -0.01951612f, -0.04254882f, -0.01173296f, 
    -0.03550774f, 0.03646741f, -0.04076572f, 0.03236771f, -0.03169337f, 0.03400932f, -0.05806077f, -0.00288485f, 
    0.03820036f, -0.04998334f, 0.04746265f, -0.00275654f, 0.03077217f, -0.03686031f, 0.02339583f, 0.03906696f, 
    -0.03599532f, -0.05527767f, -0.04783301f, -0.04054663f, -0.01986692f, -0.01710102f, 0.03150069f, -0.00795730f, 
    0.03508873f, -0.02643788f, 0.02916129f, -0.02821316f, -0.02188571f, 0.03915769f, -0.06067072f, 0.05123144f, 
    0.00996498f, -0.04875645f, 0.04306286f, 0.01475605f, -0.04091597f, -0.02047238f, -0.03148117f, 0.00908306f, 
    -0.04649048f, 0.03361936f, 0.00269669f, 0.04091118f, -0.05154003f, 0.02862267f, 0.03023177f, -0.03212388f, 
    -0.03470116f, 0.02184235f, -0.04615524f, -0.03180983f, 0.01804865f, 0.04748739f, 0.05598629f, 0.00947586f, 
    -0.00374504f, 0.00766545f, 0.00037140f, -0.02867953f, 0.00499395f, -0.01131578f, -0.04673515f, 0.05472588f, 
    0.02396763f, -0.00382328f, -0.04209614f, 0.00906950f, 0.01660859f, -0.01117336f, -0.05456602f, -0.02177928f, 
    0.00403979f, -0.03718505f, -0.02216666f, 0.00697807f, 0.02164853f, -0.01421139f, -0.03817132f, -0.00833310f, 
    0.03724546f, 0.04117372f, 0.04696322f, 0.01979000f, 0.01093345f, -0.02371119f, -0.05272558f, 0.01722659f, 
    -0.00646732f, -0.03276302f, -0.05408610f, -0.01461988f, -0.01177627f, 0.01836712f, 0.03071356f, 0.04533992f, 
    -0.00867407f, -0.01535000f, 0.04754461f, 0.01285153f, -0.05142925f, -0.04530703f, -0.02439219f, -0.05619516f, 
    -0.04563800f, -0.03039651f, 0.04428378f, -0.01023033f, -0.03743507f, 0.03670765f, 0.04976765f, 0.00010027f, 
    -0.01412291f, -0.01641149f, -0.00520450f, -0.04188288f, 0.02222992f, -0.00294787f, -0.05274689f, -0.01505390f, 
    -0.03723786f, -0.03653954f, 0.05373751f, -0.05408926f, -0.03191542f, -0.05034964f, -0.06580774f, 0.04017707f, 
    -0.06000061f, -0.01714666f, 0.04050251f, -0.00776468f, 0.00511699f, 0.01399789f, -0.01987439f, -0.01693122f, 
    -0.00441760f, -0.03474512f, -0.00901565f, 0.01749807f, 0.02874585f, -0.05531574f, 0.00354811f, 0.04550288f, 
    -0.03302382f, 0.05151615f, -0.05471792f, -0.01936753f, 0.03546366f, 0.03827062f, -0.00955087f, -0.04528597f, 
    0.04650353f, -0.05031479f, -0.04939979f, -0.01249324f, -0.02624880f, 0.00689300f, 0.00997275f, -0.03703428f, 
    -0.06526572f, -0.03433807f, -0.05463196f, 0.03802417f, 0.00230115f, -0.06295136f, -0.03162651f, 0.02911442f, 
    0.04459888f, -0.00564880f, -0.01272215f, 0.04862499f, 0.03353782f, -0.00565518f, -0.03615728f, -0.00405375f, 
    0.18171537f, -0.02749733f, 0.25963089f, 0.05992716f, 0.00536555f, -0.14403073f, -0.05327715f, 0.02689436f, 
    -0.09095915f, 0.19361731f, -0.17100544f, -0.04478167f, -0.07559463f, 0.08647357f, 0.00597369f, -0.13721353f, 
    0.08793240f, -0.01134557f, -0.46239722f, 0.03169621f, -0.10345612f, -0.03448152f, -0.18476866f, 0.09732437f, 
    0.07740741f, 0.00950097f, 0.25051269f, 0.43083236f, -0.12726277f, 0.16735552f, -0.09315973f, -0.00526135f, 
    0.03796351f, 0.07066771f, 0.08384369f, 0.16871142f, -0.08430079f, 0.01037508f, -0.02944580f, -0.02023619f, 
    -0.10422634f, -0.08104287f, 0.05449830f, -0.17830753f, -0.12334045f, 0.04182478f, 0.10683517f, 0.19421871f, 
    0.23648657f, 0.00084627f, -0.06041770f, 0.15484224f, 0.31890249f, 0.17643887f, -0.07586371f, 0.25146505f, 
    0.25417346f, -0.10841134f, -0.10680226f, 0.01791554f, -0.12797724f, -0.02794375f, -0.04923427f, 0.18931071f, 
    -0.05004272f, 0.07046618f, -0.09397046f, 0.05035057f, 0.04042466f, 0.27870533f, 0.11262995f, 0.21863481f, 
    -0.12387262f, -0.03840380f, -0.34507337f, -0.09686783f, -0.04673887f, -0.18485883f, 0.07183519f, -0.21580403f, 
    0.02593766f, 0.31830314f, 0.18298741f, 0.32493868f, -0.34974059f, 0.41514999f, -0.11067812f, 0.09993832f, 
    0.16500182f, 0.02002194f, 0.06833953f, -0.20135731f, 0.56817639f, -0.10570636f, 0.01705141f, 0.28898466f, 
    0.09835296f, 0.07077872f, 0.32992023f, 0.06360786f, 0.23388980f, 0.06963411f, 0.05904456f, -0.05764602f, 
    -0.04351612f, -0.15967317f, 0.03323790f, -0.21220160f, -0.41945067f, -0.22062145f, 0.12039549f, 0.03594714f, 
    -0.04375419f, -0.05884307f, -0.08247062f, 0.02031785f, -0.21384083f, -0.39754230f, -0.26331764f, -0.45458308f, 
    -0.13827537f, 0.05370602f, 0.00110494f, 0.15665686f, -0.11381298f, -0.14264789f, 0.38814735f, -0.25412753f, 
    -0.13363229f, -0.05439243f, -0.14858082f, -0.06842069f, 0.00936442f, -0.05797017f, -0.05585499f, -0.21095991f, 
    0.20045418f, -0.34970272f, 0.09111468f, -0.09472817f, 0.06511171f, -0.06072923f, 0.11930018f, -0.02251800f, 
    -0.08486333f, 0.19132344f, 0.16078131f, 0.19683972f, 0.06109450f, 0.25085673f, 0.21300370f, 0.04268702f, 
    0.42118880f, -0.51455611f, -0.17943615f, -0.19932857f, -0.14343232f, 0.02915953f, -0.11086173f, -0.01786639f, 
    0.04187889f, 0.03374261f, -0.10242099f, 0.34185871f, 0.02037095f, -0.06395899f, 0.15184768f, 0.14603139f, 
    -0.08961888f, 0.15815184f, -0.27591008f, -0.43080625f, 0.26923072f, 0.27249211f, -0.08409850f, -0.07019866f, 
    0.02007326f, 0.14216951f, 0.01581957f, 0.01268054f, 0.01561273f, 0.14871408f, 0.36933479f, 0.10473682f, 
    0.08542977f, -0.11526351f, -0.04405158f, -0.05019180f, 0.06221640f, 0.43052629f, 0.24485527f, 0.44407299f, 
    -0.01153523f, -0.02032666f, 0.08855977f, 0.07637402f, 0.13196810f, 0.06315097f, 0.31444442f, 0.13781901f, 
    0.23267290f, 0.16222849f, -0.05952968f, -0.12432730f, 0.13778719f, 0.03940586f, 0.09575122f, -0.06735239f, 
    -0.07925078f, 0.27375424f, 0.16475004f, -0.16951823f, 0.04313201f, 0.16544241f, 0.07161930f, 0.24357070f, 
    -0.60627401f, -0.07693095f, -0.13310471f, -0.17972215f, -0.10246783f, 0.11469997f, 0.04127638f, 0.02943711f, 
    0.08655255f, -0.47840211f, 0.09559230f, -0.09786361f, 0.24939796f, 0.04556523f, -0.10940699f, 0.08938074f, 
    0.09342758f, 0.15445039f, -0.13374023f, 0.09196531f, -0.26844120f, -0.05068501f, 0.31975219f, -0.10775135f, 
    -0.10491802f, 0.13977398f, 0.05696553f, -0.67148602f, 0.19258316f, -0.06120998f, -0.00457174f, -0.15025176f, 
    -0.09964165f, -0.00248173f, 0.00022903f, -0.02461632f, -0.29223716f, 0.02191613f, 0.07253292f, -0.05338212f, 
    -0.02625625f, -0.08144633f, -0.25780636f, -0.15620443f, -0.19125505f, -0.00286396f, -0.31651336f, 0.18879214f, 
    0.14782636f, -0.05489236f, -0.05217196f, 0.16162601f, -0.04193127f, -0.07853145f, 0.26489645f, 0.22455144f, 
    -0.00033598f, 0.13630132f, 0.01530578f, -0.12301655f, -0.02973674f, 0.00980278f, 0.01236381f, 0.06838854f, 
    0.16288820f, -0.30558738f, 0.01725000f, 0.06641466f, -0.07452669f, -0.02740734f, -0.11951178f, 0.00947206f, 
    0.00458736f, -0.02210980f, -0.01847590f, -0.02487026f, 0.02841944f, 0.04304741f, -0.02710297f, 0.01350450f, 
    -0.02807218f, -0.01809020f, 0.04084431f, -0.04148577f, -0.06427722f, -0.05222133f, -0.00825107f, 0.01573647f, 
    -0.04807445f, -0.02487635f, 0.00410768f, -0.01891758f, 0.04578000f, -0.04150948f, 0.03001084f, 0.05248867f, 
    -0.04339992f, 0.00359088f, -0.05661182f, 0.04795271f, -0.00953034f, -0.05905101f, -0.05013327f, -0.05507131f, 
    -0.03646279f, -0.05336070f, 0.02080087f, -0.03227166f, 0.03580463f, -0.01870196f, -0.00699930f, 0.03751264f, 
    0.02192030f, 0.03063950f, 0.01428011f, -0.01757127f, 0.04015088f, 0.01279014f, 0.00989150f, -0.04295057f, 
    -0.02051656f, 0.04486195f, 0.03349081f, -0.03385124f, 0.00784922f, -0.01193543f, -0.05479683f, 0.02239324f, 
    -0.03373945f, 0.01576109f, 0.05238930f, -0.02784317f, 0.04519401f, -0.06013791f, 0.03087843f, -0.04301481f, 
    -0.00584795f, 0.01826185f, -0.06038439f, 0.03944546f, -0.06450867f, 0.00258463f, 0.01723440f, 0.02339299f, 
    0.02122300f, 0.05036419f, -0.05373283f, -0.02138975f, -0.05456203f, 0.02965573f, -0.01617823f, -0.04075332f, 
    0.02824110f, -0.04476931f, 0.00623980f, -0.04249620f, 0.02065078f, -0.05759101f, -0.04127003f, -0.01024926f, 
    -0.05889573f, -0.06037388f, -0.04030330f, -0.04314259f, -0.06182271f, 0.04120684f, -0.03187794f, -0.00223427f, 
    -0.05925889f, -0.00639467f, 0.03896402f, 0.04170839f, -0.02953404f, 0.03770692f, 0.00163983f, -0.04770618f, 
    0.01610690f, -0.01201575f, 0.04601892f, -0.05594476f, -0.06021836f, 0.01599864f, -0.06381464f, -0.05979606f, 
    -0.05617727f, 0.03398855f, -0.00451372f, -0.04924635f, -0.05315357f, -0.01871898f, 0.02568778f, 0.01495386f, 
    -0.01867793f, 0.00429486f, 0.01851063f, -0.00544100f, -0.05136391f, 0.01150181f, -0.05729256f, 0.04259268f, 
    0.01218821f, 0.00913163f, 0.01042717f, 0.02785500f, 0.04331351f, 0.02288529f, 0.02262680f, 0.02760211f, 
    -0.04925813f, 0.05072154f, -0.04925268f, -0.06168662f, -0.00709429f, -0.06181085f, -0.04924914f, 0.01656049f, 
    -0.01848448f, -0.02891426f, 0.01904198f, 0.03549377f, -0.06081364f, -0.05185080f, 0.00089703f, -0.01749385f, 
    0.02835790f, 0.00117911f, -0.00741841f, 0.02742915f, -0.02198171f, -0.02792071f, -0.04935774f, -0.01363390f, 
    -0.00278179f, -0.06071375f, 0.04237567f, 0.02335400f, -0.02765211f, -0.03677789f, -0.03692060f, -0.00291286f, 
    -0.00848683f, -0.06037400f, 0.03869613f, 0.01252583f, -0.01023190f, 0.01962657f, -0.04320835f, -0.00687753f, 
    -0.00144244f, -0.02857695f, -0.05521474f, 0.01897448f, -0.01026614f, 0.01548476f, -0.01550607f, -0.05637846f, 
    0.02668532f, -0.06043223f, -0.00195845f, 0.04295171f, -0.02595249f, -0.02943014f, 0.02036935f, -0.05814897f, 
    -0.05492767f, -0.05010268f, -0.06255272f, -0.04016401f, 0.02994687f, 0.03942039f, -0.04420657f, 0.04071539f, 
    0.02653206f, 0.01414734f, 0.02845893f, 0.04129814f, -0.05032496f, 0.01295895f, -0.00713680f, 0.00099264f, 
    0.01075369f, -0.01735327f, 0.03602571f, -0.00302561f, -0.01987316f, 0.02701490f, -0.01763602f, -0.03782546f, 
    -0.00095148f, -0.06419823f, -0.01894240f, 0.02484725f, -0.02541178f, 0.00093107f, -0.06359900f, 0.02443609f, 
    0.01400607f, 0.00042500f, -0.00427225f, -0.05957377f, -0.02941066f, -0.03756054f, -0.05278911f, -0.01828131f, 
    -0.02121237f, 0.02312814f, 0.01276348f, -0.03607687f, 0.00677191f, 0.03086275f, -0.03360915f, 0.01317704f, 
    -0.01740322f, 0.00993331f, 0.00932607f, 0.01391349f, 0.01310017f, 0.01870218f, -0.01833867f, -0.03859380f, 
    -0.01571678f, -0.04034267f, -0.01759486f, -0.01001108f, 0.00246395f, -0.00860776f, 0.03164488f, -0.04571847f, 
    -0.03511694f, -0.04574932f, -0.01382025f, -0.02861470f, -0.03495587f, -0.04986108f, 0.04010552f, 0.05014174f, 
    -0.01658556f, -0.02036959f, -0.06260492f, 0.01002232f, -0.02517133f, -0.06118225f, 0.02982244f, 0.05140831f, 
    -0.03501631f, -0.01278582f, -0.02383625f, 0.03996270f, -0.00306594f, 0.00932686f, -0.01866907f, -0.00813620f, 
    0.02878053f, -0.05885056f, -0.02514354f, -0.06076597f, -0.01355121f, 0.01218645f, 0.04624854f, -0.02305230f, 
    0.28876215f, -0.22371314f, -0.15290013f, -0.15048648f, -0.17075545f, 0.27060947f, 0.08383740f, 0.03715088f, 
    0.05083758f, 0.04847893f, -0.08243400f, -0.14406548f, 0.02725714f, -0.02189862f, -0.23343644f, -0.09156956f, 
    0.10203693f, -0.15573654f, -0.63659662f, 0.04876446f, -0.01528671f, 0.03028714f, -0.03219416f, -0.09640017f, 
    0.02436797f, -0.01736252f, 0.18703684f, 0.16859062f, 0.17556907f, 0.13041727f, -0.05695786f, -0.00149253f, 
    -0.06356833f, 0.19870232f, 0.11287864f, 0.00277791f, 0.18519402f, 0.06404763f, 0.04171331f, -0.13269946f, 
    -0.15679631f, -0.30659977f, -0.01098837f, -0.17366189f, -0.01049777f, 0.26825345f, -0.20527337f, -0.12111551f, 
    0.07099249f, 0.12212836f, 0.19650413f, 0.18677554f, 0.15415299f, 0.06138705f, -0.23016205f, -0.00478886f, 
    0.22514552f, 0.03834723f, -0.05857832f, 0.14380942f, 0.10151026f, -0.02418088f, -0.00395333f, -0.00312231f, 
    -0.18098316f, -0.09011903f, 0.04476289f, -0.08195685f, 0.31794414f, -0.04607156f, 0.04845466f, -0.07481724f, 
    0.41057837f, -0.09034929f, -0.09160084f, -0.37148538f, -0.00486018f, -0.19177270f, 0.21247928f, 0.05252097f, 
    0.09199099f, 0.33421594f, 0.33460575f, -0.07609093f, 0.05871354f, -0.21091013f, 0.32013890f, -0.01247821f, 
    0.06505923f, -0.10531088f, -0.23939623f, 0.12330781f, 0.01246930f, -0.11534128f, -0.07308739f, 0.02654869f, 
    -0.07477144f, 0.05330817f, -0.08825099f, -0.10578845f, 0.02368912f, -0.32250944f, -0.02876980f, 0.04769543f, 
    0.04208943f, 0.06791721f, -0.05727292f, -0.21541144f, -0.01081109f, 0.29889902f, 0.23164169f, -0.05571301f, 
    0.09988395f, -0.09388398f, 0.05354371f, -0.43261480f, -0.06174511f, 0.03060487f, 0.10811424f, 0.12141210f, 
    0.04546631f, -0.08184703f, 0.08011916f, 0.02049373f, 0.10992172f, -0.01138287f, 0.09070423f, -0.01873438f, 
    0.01610925f, -0.00388733f, -0.07629909f, -0.07987129f, -0.09635559f, -0.07161493f, 0.00229591f, 0.14207709f, 
    -0.07608236f, 0.09155704f, -0.01819424f, 0.03287918f, 0.09357821f, -0.16524746f, 0.01852141f, 0.01438291f, 
    -0.04049684f, -0.15980756f, -0.03286426f, 0.00168119f, -0.17813258f, 0.25624776f, -0.09506597f, 0.13292703f, 
    0.08562112f, 0.05302271f, -0.00257770f, 0.05743830f, -0.04550637f, 0.06327818f, -0.07437998f, 0.28729522f, 
    0.13966140f, 0.11030273f, 0.20133871f, 0.10983615f, -0.44230103f, -0.19597417f, -0.12849690f, -0.23565507f, 
    0.19623964f, 0.12539905f, -0.53732967f, -0.18759085f, 0.13877174f, 0.23154923f, 0.03303873f, 0.16951588f, 
    0.08864078f, 0.10216916f, 0.03347833f, -0.08973067f, 0.02703151f, -0.23089825f, -0.02047948f, -0.17271091f, 
    0.14625567f, 0.13379766f, 0.10419593f, 0.05744239f, 0.05314301f, 0.43791950f, -0.28828964f, -0.10335410f, 
    -0.21360031f, -0.10404620f, 0.12606047f, 0.00313370f, -0.08411369f, 0.00574261f, -0.29104823f, 0.01646538f, 
    -0.04005969f, -0.11418059f, -0.02393453f, -0.09641444f, -0.00031922f, 0.20373560f, 0.20560265f, -0.07433330f, 
    -0.27570865f, -0.53578156f, 0.07239565f, 0.17282358f, 0.14905031f, 0.03555870f, -0.10160380f, 0.13524163f, 
    -0.31863955f, -0.01321349f, -0.04480603f, 0.02842724f, -0.16428278f, 0.10745441f, -0.00244902f, -0.03632348f, 
    0.19951679f, 0.04508687f, -0.04125475f, -0.39540851f, -0.18874198f, 0.25701123f, 0.15496083f, 0.06384603f, 
    -0.11290245f, 0.20060299f, 0.32210040f, 0.09412099f, -0.38162309f, 0.16338436f, 0.29491186f, 0.01746996f, 
    0.04452129f, 0.21158700f, 0.08937526f, -0.44613370f, 0.05350774f, 0.25159860f, -0.02313741f, 0.24583243f, 
    -0.09463613f, 0.00608082f, -0.22296739f, 0.24186364f, 0.09160793f, 0.14117692f, 0.09610268f, -0.02265546f, 
    -0.13701513f, 0.09457752f, 0.06837634f, -0.16114601f, -0.07045173f, -0.04141477f, 0.15326712f, -0.11787191f, 
    -0.14794540f, 0.20164678f, -0.12880474f, -0.06520224f, 0.16748907f, -0.26610190f, 0.44496498f, -0.03611502f, 
    0.17270543f, -0.15757990f, -0.17920598f, -0.14997993f, 0.09569445f, -0.10999509f, 0.04762103f, 0.52764571f, 
    -0.16732293f, -0.48330584f, -0.20290363f, -0.06903440f, -0.07468127f, 0.22870483f, 0.24601637f, -0.15661235f, 
    -0.07287610f, 0.07804751f, 0.11426562f, 0.06726291f, 0.01298204f, 0.13828112f, 0.13377081f, 0.34818465f, 
    0.35238856f, 0.12227526f, 0.06668640f, 0.37308943f, 0.11947756f, 0.19637866f, -0.12222743f, -0.09323837f, 
    0.19566648f, 0.27949962f, -0.06493451f, 0.04022447f, 0.05938137f, -0.13249105f, 0.02159388f, -0.18139571f, 
    0.03572734f, 0.03311016f, -0.13423145f, 0.06367078f, 0.17947891f, 0.18731216f, 0.18168597f, -0.03751197f, 
    -0.07128926f, -0.07135495f, 0.06438359f, 0.09966014f, 0.07956613f, 0.15524147f, 0.14206624f, -0.01969658f, 
    0.14997943f, -0.04172920f, -0.22504820f, -0.41714719f, -0.39358830f, -0.07072797f, 0.02142585f, -0.04040537f, 
    0.14011042f, -0.01346165f, -0.11550758f, -0.13039425f, -0.29674599f, -0.36249080f, 0.21982597f, 0.00759450f, 
    -0.11749258f, 0.22421332f, 0.08767743f, 0.04538983f, 0.08495948f, 0.06420124f, 0.31305814f, -0.09636121f, 
    -0.13912392f, 0.08770235f, 0.34626663f, 0.03221560f, -0.25810221f, -0.24743949f, -0.07564661f, -0.30920103f, 
    0.43532455f, 0.32346267f, -0.28129724f, 0.18328704f, 0.28512427f, -0.01948804f, 0.11320771f, 0.00466559f, 
    -0.15870905f, 0.14467232f, 0.12565550f, -0.18474719f, 0.20175053f, -0.16239336f, -0.01577241f, -0.01957030f, 
    0.03409572f, 0.17043105f, -0.31392410f, -0.03350339f, 0.01879447f, 0.26385698f, 0.14941639f, -0.12230498f, 
    -0.11232791f, 0.07610193f, -0.22058982f, -0.12992950f, -0.03729640f, 0.22008486f, 0.05631851f, 0.13847044f, 
    0.08990879f, 0.05290638f, 0.28682470f, 0.25334445f, -0.07538132f, -0.25952065f, -0.20414014f, 0.01581275f, 
    0.23648624f, -0.03831875f, 0.27021700f, 0.04346581f, -0.15157026f, -0.06822518f, 0.10018627f, -0.02072672f, 
    -0.08739410f, -0.04193353f, 0.05430430f, 0.11351083f, 0.21005538f, -0.06411593f, 0.00937461f, 0.31647494f, 
    0.08441543f, 0.08378252f, 0.28978178f, 0.20421508f, 0.08546863f, 0.08850870f, 0.18698031f, -0.06787091f, 
    0.09776326f, -0.30132729f, -0.04536696f, 0.09787777f, 0.00437949f, 0.22408375f, 0.08458110f, 0.06191929f, 
    -0.10483734f, -0.08588742f, -0.04189342f, 0.24129374f, 0.04562528f, -0.14242768f, -0.11457664f, -0.29212001f, 
    -0.83015031f, 0.18920086f, 0.07116899f, -0.04965326f, 0.02566033f, 0.10495008f, 0.01561248f, 0.16706385f, 
    0.02635325f, -0.20521288f, 0.04812048f, 0.18579949f, -0.46708143f, -0.06623394f, 0.47131047f, 0.24649017f, 
    0.22866692f, 0.27301124f, 0.08575296f, -0.09273269f, -0.25666538f, 0.02295509f, 0.15226166f, 0.26805580f, 
    0.02926938f, 0.12469236f, 0.09806839f, 0.13120623f, 0.10356249f, 0.20913036f, 0.41415536f, 0.08735577f, 
    0.11145680f, 0.14154848f, 0.04253125f, 0.45013148f, 0.23420092f, 0.00227421f, -0.19542961f, -0.37405148f, 
    0.20105962f, -0.02750327f, -0.10509975f, 0.03680365f, -0.02676540f, 0.04270132f, -0.00898849f, 0.16318315f, 
    0.33191827f, 0.03919984f, 0.19094248f, -0.04310918f, 0.09995512f, -0.04258487f, 0.05097813f, 0.00549816f, 
    0.01776545f, 0.22606952f, 0.05184506f, 0.28704193f, -0.43513784f, -0.04007085f, -0.27496141f, -0.31468102f, 
    0.03339826f, 0.12111612f, -0.01090263f, 0.06999212f, -0.08835461f, 0.05677989f, 0.06045505f, -0.03062734f, 
    -0.05836590f, -0.03660491f, -0.04135213f, 0.35386127f, 0.01410454f, 0.19178157f, -0.27118826f, -0.15216759f, 
    -0.47734693f, -0.02473201f, -0.21942557f, -0.05850739f, 0.21302134f, 0.13872647f, 0.09126033f, -0.15668328f, 
    0.13583606f, 0.25309756f, -0.03172190f, 0.16054815f, 0.10177145f, -0.03224672f, -0.02709374f, 0.07781146f, 
    -0.22901472f, 0.03873835f, 0.15703742f, -0.15365258f, 0.17860787f, -0.12846798f, 0.17181206f, 0.09091525f, 
    0.00551079f, 0.10431112f, -0.12900063f, -0.15517558f, 0.15680885f, -0.23760587f, 0.15011548f, 0.36902711f, 
    0.10793071f, 0.09187870f, 0.42520168f, 0.01436034f, 0.28035372f, 0.41677028f, 0.05309277f, 0.16940682f, 
    -0.17739522f, 0.06302486f, 0.17273442f, 0.21802273f, 0.02464804f, 0.07904375f, 0.18484266f, -0.02993800f, 
    0.17468679f, 0.05357098f, 0.13832767f, -0.08052220f, 0.17941229f, 0.23270248f, 0.26714659f, 0.38516834f, 
    -0.04289208f, -0.16048782f, -0.32065487f, 0.02305882f, 0.02962299f, 0.03871553f, 0.11622618f, 0.14044908f, 
    -0.09020064f, -0.05484571f, -0.25865221f, -0.08568223f, 0.05646389f, 0.07840019f, 0.08517028f, 0.12414978f, 
    -0.03073570f, -0.08239133f, 0.32993552f, -0.66690695f, -0.18159673f, 0.00024036f, 0.15013598f, -0.01611978f, 
    0.03991327f, 0.06774008f, -0.10340934f, -0.05563785f, -0.17826763f, 0.05034415f, -0.02269134f, -0.05657184f, 
    0.08647271f, 0.11502627f, -0.05025360f, 0.09119998f, 0.07994310f, 0.00346855f, -0.12661852f, 0.00893449f, 
    -0.10900935f, -0.10013806f, 0.09990544f, 0.08812577f, 0.03581704f, -0.10736200f, 0.24618268f, -0.30819371f, 
    0.18007205f, 0.14903499f, -0.11643743f, 0.11884975f, 0.10322879f, 0.01823579f, -0.08509809f, 0.22811857f, 
    0.32662669f, -0.26666009f, 0.06838354f, -0.28855506f, 0.05313272f, 0.03263858f, 0.04956829f, -0.11221129f, 
    0.50454116f, 0.07192589f, -0.08730201f, 0.13717531f, -0.04226363f, -0.06226664f, 0.07652418f, 0.16286469f, 
    -0.03312918f, 0.15644085f, 0.14807023f, -0.18496786f, 0.05535690f, 0.11905558f, -0.02700783f, 0.03494497f, 
    0.00263478f, -0.88710672f, 0.04317628f, 0.02280000f, 0.17717813f, 0.20322025f, -0.60081005f, -0.12789731f, 
    0.07386106f, -0.04473380f, -0.01417864f, -0.27847436f, 0.18738343f, 0.03878197f, 0.13490187f, 0.03456291f, 
    0.09574536f, -0.12172347f, -0.05930898f, -0.11789249f, -0.08489855f, -0.11761407f, 0.06515481f, 0.10715111f, 
    0.15284468f, 0.02461578f, -0.11721306f, -0.10762615f, -0.03682202f, -0.01477266f, -0.18889818f, -0.08923877f, 
    -0.13775225f, -0.21116467f, 0.09117585f, 0.04880261f, 0.10862906f, -0.07394512f, -0.11283034f, -0.10026349f, 
    0.00054968f, 0.09390048f, -0.02616619f, 0.08255912f, 0.00184633f, -0.05284421f, -0.22100873f, 0.01062082f, 
    0.12231952f, 0.04863417f, -0.09840752f, 0.03198281f, 0.03419926f, -0.25612116f, 0.09003309f, -0.64410454f, 
    -0.20423888f, -0.25441152f, 0.07550506f, -0.10151421f, -0.18172668f, -0.15899354f, 0.14471531f, -0.01962840f, 
    -0.09431260f, -0.01400525f, -0.24526599f, 0.01353249f, -0.06353776f, -0.02962062f, -0.06856220f, 0.02806196f, 
    0.01054301f, -0.22180928f, 0.02206518f, 0.15294673f, -0.04855788f, -0.11974411f, -0.03547591f, -0.13073152f, 
    -0.13256179f, 0.10304563f, -0.73363107f, 0.53074849f, 0.17075680f, 0.12800714f, -0.23186882f, -0.01709352f, 
    -0.15280561f, -0.09830992f, -0.32208467f, -0.01468048f, 0.27781439f, -0.04491767f, -0.11995929f, 0.00372884f, 
    0.05758667f, -0.09690771f, 0.18825227f, -0.02796241f, 0.16733037f, -0.05782513f, -0.29353818f, -0.03938736f, 
    -0.04028362f, 0.17413124f, 0.14003387f, 0.18978485f, -0.02243792f, -0.57256246f, 0.11346456f, 0.04217633f, 
    -0.05284353f, 0.02761532f, 0.03474836f, 0.06406721f, 0.01631617f, 0.16854098f, 0.11384030f, -0.17338255f, 
    -0.07241103f, 0.04086032f, 0.05569573f, 0.01461406f, 0.27341765f, -0.13590674f, 0.08981013f, 0.35278288f, 
    0.18689014f, -0.22551283f, 0.16089442f, -0.18350498f, -0.01136644f, -0.04466353f, -0.03948278f, 0.05841992f, 
    0.03667032f, -0.31548658f, -0.09455325f, -0.02896743f, 0.10907631f, -0.15988746f, 0.01723023f, -0.00552797f, 
    -0.04264348f, -0.01780848f, 0.14344491f, -0.13876197f, 0.11739234f, 0.28519630f, 0.17948601f, 0.07790285f, 
    0.01697728f, -0.15483370f, 0.32791373f, -0.20862086f, 0.27223834f, -0.13730463f, -0.00114145f, 0.53454530f, 
    0.13932489f, -0.33085072f, 0.02398118f, 0.17584024f, -0.30935258f, -0.32197040f, -0.11424021f, 0.09079210f, 
    0.10204276f, 0.04064874f, 0.24542959f, -0.28840780f, -0.16123588f, 0.29908878f, 0.31509838f, 0.02877721f, 
    0.21966478f, 0.05476554f, 0.12839074f, 0.26024613f, 0.07004747f, 0.09327555f, 0.04282203f, -0.35375917f, 
    -0.09848657f, 0.20807882f, 0.30332384f, -0.05172954f, 0.07211637f, -0.27599326f, 0.07986553f, -0.35271373f, 
    -0.25739735f, 0.01716784f, -0.01741455f, -0.04238459f, 0.13985816f, 0.09546465f, -0.14931858f, -0.14056133f, 
    0.33329728f, 0.08037575f, -0.15911888f, -0.08999465f, 0.00249700f, 0.06247876f, 0.15013181f, 0.07863243f, 
    -0.47470137f, -0.16405967f, -0.66200560f, 0.07838325f, -0.03035341f, 0.10484727f, -0.08715540f, 0.19619253f, 
    -0.08049375f, -0.08767369f, -0.00133650f, -0.21145394f, -0.07538064f, 0.10890877f, -0.04142206f, -0.15701707f, 
    0.17390166f, -0.07291403f, 0.24208134f, 0.02626985f, 0.32067055f, 0.17924187f, 0.11322566f, -0.06194887f, 
    0.19782199f, -0.08084071f, 0.01047004f, -0.20398028f, 0.14306933f, 0.24332331f, 0.07524922f, -0.04484898f, 
    -0.02794070f, -0.00677756f, 0.11031550f, -0.12461755f, 0.23762169f, -0.10143655f, -0.19059439f, -0.50520402f, 
    -0.28777763f, -0.45370504f, 0.02439362f, -0.01208350f, 0.06626151f, -0.15573142f, -0.11071827f, -0.27011722f, 
    0.04490342f, -0.04668388f, -0.14863834f, -0.01344058f, -0.02455640f, -0.06054899f, 0.17563696f, 0.20136742f, 
    -0.09472714f, -0.16243514f, -0.38449311f, 0.01545159f, 0.01326728f, -0.06540523f, -0.13013424f, -0.00069483f, 
    0.12417698f, 0.10106301f, 0.05724398f, 0.01802657f, 0.18904902f, -0.04100960f, -0.03713792f, -0.05905140f, 
    0.11311265f, -0.07873690f, 0.40953189f, -0.00581363f, -0.24917297f, -0.09297474f, 0.08805748f, -0.14307009f, 
    -0.03513360f, 0.08110412f, 0.12676704f, 0.07878307f, 0.19926977f, 0.02704016f, 0.16716141f, 0.12936357f, 
    0.01683058f, 0.20028968f, 0.03208545f, 0.20573179f, 0.16995688f, -0.04670933f, 0.02111118f, -0.02415507f, 
    -0.08638631f, 0.06254928f, -0.02288673f, 0.03509839f, -0.04175636f, -0.50602669f, -0.04262150f, 0.10635057f, 
    -0.00963338f, -0.07411603f, -0.05655850f, 0.03519330f, 0.18942590f, 0.19751181f, 0.12972416f, 0.12454183f, 
    -0.06778590f, -0.25849286f, -0.23754708f, 0.33052340f, 0.29818794f, 0.09911425f, 0.11494172f, 0.13423990f, 
    -0.05793516f, -0.02036880f, -0.04530059f, 0.04657041f, -0.04981370f, -0.03093849f, -0.24983546f, -0.17332174f, 
    0.27339500f, 0.05505257f, 0.13413420f, 0.13054748f, 0.14652409f, -0.02524597f, -0.07723394f, 0.18654111f, 
    0.04561692f, 0.41752335f, 0.06808430f, -0.01379045f, -0.24634302f, -0.08879794f, 0.01052027f, 0.09578953f, 
    0.09881844f, -0.13140085f, 0.09839292f, 0.01283620f, 0.00890310f, -0.13539140f, -0.09062606f, -0.06257793f, 
    0.10960231f, 0.20371784f, 0.10501640f, 0.11982300f, -0.11282039f, -0.05063653f, -0.23834881f, 0.02500688f, 
    0.08494720f, 0.05036537f, 0.06878907f, 0.09372909f, -0.07629213f, 0.34459919f, -0.13996425f, 0.17955849f, 
    0.31548426f, -0.46508816f, 0.18226478f, 0.22183906f, 0.13863145f, -0.05730793f, 0.03849247f, 0.09667776f, 
    0.16245356f, 0.02365196f, 0.00086289f, 0.11061598f, -0.05265380f, -0.17905563f, -0.30102956f, -0.17003028f, 
    0.04909230f, 0.20997256f, -0.04610735f, 0.01638671f, 0.00128065f, -0.39953610f, -0.06952438f, -0.18683401f, 
    -0.01756058f, -0.06717936f, -0.01565193f, -0.00852690f, -0.08886307f, -0.11891213f, 0.27170962f, -0.24929117f, 
    0.49136642f, 0.12361093f, -0.03056503f, -0.18508019f, 0.02040651f, 0.09775885f, 0.16795422f, -0.07319856f, 
    -0.24110974f, -0.49083453f, -0.10451549f, -0.07025684f, -0.01258038f, -0.01384516f, -0.04871447f, -0.13315374f, 
    0.20368548f, 0.35044608f, -0.14624418f, -0.05987667f, -0.15457976f, 0.04955414f, 0.03563524f, -0.13026533f, 
    0.00496856f, 0.29686984f, -0.15583445f, -0.24305876f, -0.05943433f, -0.36946884f, -0.09925107f, -0.03541701f, 
    -0.00256913f, 0.07765628f, -0.11006837f, 0.14748026f, -0.09247076f, -0.02222119f, -0.00147443f, -0.05681681f, 
    0.24706365f, 0.10916883f, 0.14533612f, 0.28074789f, 0.08465525f, 0.45334417f, 0.29970774f, 0.09651684f, 
    -0.04690210f, 0.01088224f, -0.03430676f, 0.03248223f, 0.20898134f, 0.25894177f, -0.18811218f, -0.05491855f, 
    -0.19191422f, -0.08525915f, 0.02427636f, -0.03982655f, 0.09107671f, 0.13817436f, 0.14040785f, -0.06549556f, 
    -0.13055153f, 0.18007761f, -0.15608078f, 0.05129841f, -0.29971740f, 0.20028646f, -0.12233867f, -0.44830585f, 
    -0.23527552f, -0.01013513f, -0.07560133f, 0.18785919f, 0.07086182f, -0.08826855f, -0.22133440f, -0.14863560f, 
    0.11795750f, 0.25044751f, 0.16293256f, 0.04745546f, 0.08965548f, 0.12926196f, 0.10223471f, -0.08265951f, 
    -0.06997066f, -0.08441069f, -0.30139524f, -0.28126568f, -0.28460971f, -0.08341739f, -0.05874843f, -0.03557759f, 
    0.10578061f, -0.17262131f, -0.34810406f, 0.02741328f, -0.11695576f, -0.09172285f, -0.25733492f, 0.08631821f, 
    0.06981529f, 0.06904892f, 0.08664469f, 0.14506899f, 0.23122187f, 0.16017874f, -0.06308998f, 0.07724948f, 
    0.00818927f, -0.04486478f, -0.08676659f, -0.13991335f, -0.03587198f, -0.50928164f, 0.13723135f, -0.08055441f, 
    0.17303815f, -0.03738375f, 0.10244148f, 0.12153479f, 0.19273555f, 0.02354395f, 0.10185384f, 0.02695207f, 
    -0.07555167f, -0.11680414f, -0.04940622f, 0.09876774f, -0.23737641f, 0.09557297f, 0.03042093f, -0.12808414f, 
    -0.19434422f, -0.09754255f, 0.01347842f, 0.24653064f, -0.24154676f, -0.18986547f, 0.21509720f, -0.20356613f, 
    -0.07820378f, 0.14464100f, 0.04582601f, 0.04537009f, 0.08658462f, 0.04621348f, -0.00504767f, 0.11624473f, 
    -0.08612736f, -0.03248328f, 0.11192486f, 0.08389352f, -0.04483240f, 0.01060889f, -0.22371095f, -0.08740756f, 
    -0.06855185f, 0.10351175f, 0.23505592f, 0.07352586f, 0.03566278f, -0.05877557f, 0.16068618f, -0.21954308f, 
    -0.39433342f, 0.00412692f, -0.15553929f, 0.30552188f, -0.26933905f, 0.28382289f, -0.00119532f, 0.05604482f, 
    -0.40170035f, -0.00186237f, -0.05096078f, -0.08916172f, -0.12546737f, -0.02588889f, -0.14498053f, 0.00978245f, 
    -0.19476391f, -0.40779105f, 0.00481183f, 0.06093481f, -0.29832888f, -0.12187207f, -0.14513014f, -0.10156675f, 
    -0.02664975f, 0.00140367f, 0.08985146f, 0.10573928f, 0.21350604f, 0.06660773f, 0.06424276f, 0.04927193f, 
    0.02231615f, 0.01623037f, 0.14080583f, -0.01189224f, -0.01488569f, 0.13152042f, 0.11930587f, 0.15243721f, 
    0.09056916f, -0.00331307f, 0.01778382f, 0.06837472f, 0.05638618f, -0.01766410f, -0.49463853f, -0.12814881f, 
    -0.14669372f, 0.25556064f, 0.33325344f, 0.02412540f, 0.00627806f, -0.06352904f, 0.13272388f, 0.18905109f, 
    0.07048394f, -0.00488147f, -0.18914069f, -0.06868707f, -0.06782162f, 0.01989286f, -0.02879097f, -0.06996768f, 
    0.10965421f, 0.03128721f, 0.08409645f, 0.04955404f, 0.06636307f, -0.01938699f, -0.17204681f, -0.07291280f, 
    -0.26213071f, 0.17681584f, 0.07555373f, 0.07918257f, 0.01236796f, 0.21750927f, -0.02781903f, 0.07495340f, 
    0.08139291f, -0.01901374f, -0.31394443f, 0.10262043f, 0.51645267f, 0.00676830f, 0.26236030f, -0.02748509f, 
    0.03262976f, 0.10216721f, 0.31754315f, 0.24894939f, 0.06739209f, 0.11046930f, 0.14506651f, -0.10590156f, 
    -0.03316144f, 0.07963500f, 0.04579885f, 0.09082605f, 0.41538003f, 0.07627075f, -0.03537031f, -0.14876771f, 
    -0.22391959f, -0.34993261f, -0.20403334f, -0.02016018f, 0.03726902f, -0.22446351f, 0.24048038f, 0.06081023f, 
    -0.14834999f, -0.07318761f, -0.26130962f, 0.03919630f, -0.10389022f, -0.02327476f, -0.13963091f, 0.16333628f, 
    -0.34986725f, 0.26799092f, 0.05703452f, -0.17792673f, 0.09883893f, -0.11865602f, 0.02250270f, -0.07407369f, 
    -0.01322559f, 0.04336828f, 0.13233881f, 0.02532661f, 0.05256606f, 0.23663571f, -0.16170929f, -0.11750408f, 
    0.27280071f, 0.19101505f, -0.03339411f, 0.18178368f, -0.06764858f, 0.03803756f, 0.07823878f, 0.06184141f, 
    -0.14913389f, -0.23680520f, 0.05357659f, -0.04601590f, 0.15548009f, 0.09355034f, 0.00850389f, 0.17275696f, 
    0.06759136f, -0.28446472f, 0.19530441f, 0.35425124f, -0.04084269f, -0.09451114f, 0.02221850f, 0.19953687f, 
    0.02249677f, 0.10755529f, 0.16065246f, 0.15886353f, 0.01374853f, 0.24514127f, 0.12476683f, 0.10243923f, 
    -0.09186594f, -0.03120944f, -0.03905541f, -0.19357845f, 0.13492766f, 0.11662706f, 0.00468233f, 0.04215157f, 
    -0.22697222f, -0.07755923f, 0.13818726f, -0.13627970f, 0.03200032f, 0.51735616f, -0.11540107f, 0.14634882f, 
    0.05015625f, -0.06245694f, 0.07049251f, 0.05231847f, 0.14025924f, 0.20102602f, 0.15716535f, 0.19089766f, 
    -0.05257497f, -0.08316755f, -0.06208263f, -0.24518229f, 0.06969753f, 0.15025760f, 0.08904455f, -0.67035401f, 
    0.52751327f, 0.06548332f, -0.08912513f, -0.12731922f, -0.03399811f, 0.01358685f, 0.00968814f, 0.12347786f, 
    -0.01328249f, -0.08273916f, 0.39178038f, -0.11514210f, 0.04503915f, -0.02363793f, 0.05670401f, 0.05456391f, 
    0.16504858f, -0.06181417f, -0.36260375f, 0.17705913f, -0.17955428f, -0.11755905f, 0.04163321f, 0.09190965f, 
    0.00320028f, -0.23143837f, -0.52305359f, 0.53747725f, 0.41383576f, 0.22446221f, 0.18782648f, -0.02905980f, 
    0.03181573f, -0.00512157f, 0.13743389f, -0.07532433f, -0.00114023f, -0.08934192f, -0.04111899f, -0.08395700f, 
    0.08942834f, 0.02773044f, 0.09094809f, 0.07383065f, 0.03964023f, -0.11770300f, 0.15039921f, -0.15689555f, 
    -0.09243553f, -0.34577867f, 0.12805019f, 0.09575590f, 0.11201218f, -0.07742518f, -0.63517100f, 0.12333463f, 
    0.04167238f, -0.01658102f, -0.21247700f, -0.16295211f, 0.06087875f, 0.01976314f, -0.27487126f, -0.43399695f, 
    0.01430575f, -0.20495331f, 0.00081333f, -0.12550113f, -0.03914508f, 0.00806538f, 0.02294831f, 0.12365700f, 
    -0.48531806f, 0.11845633f, -0.03765748f, -0.16894627f, 0.02895800f, 0.12314045f, 0.04889085f, 0.01455240f, 
    -0.02021017f, -0.11372122f, -0.17830573f, -0.12167666f, -0.40724215f, -0.15977581f, -0.06094135f, 0.17755172f, 
    0.09789599f, 0.25109968f, -0.50187886f, -0.37796679f, -0.42792156f, -0.06207953f, -0.00663579f, 0.02521100f, 
    -0.13466461f, -0.02018544f, 0.14004935f, -0.15010539f, 0.17841402f, -0.08414782f, -0.06441094f, 0.03588253f, 
    -0.09438897f, 0.06054255f, 0.13266928f, 0.28838223f, -0.20778906f, 0.19287361f, 0.10651518f, -0.02139449f, 
    0.14675884f, 0.17139149f, 0.02010079f, -0.11218721f, -0.44777074f, -0.39487895f, -0.08310232f, -0.18540627f, 
    -0.13971095f, 0.13490264f, 0.00988161f, -0.03157664f, 0.03717621f, -0.12961024f, 0.08471568f, 0.04022751f, 
    0.16876230f, -0.00763005f, -0.01207620f, 0.17453727f, 0.04744601f, 0.33084291f, -0.03385949f, 0.37286782f, 
    -0.14819586f, 0.12056367f, 0.11972952f, 0.04491801f, -0.02646644f, 0.13835892f, 0.04048520f, -0.30233380f, 
    -0.48411357f, -0.26473069f, 0.05758769f, 0.09794684f, -0.23563586f, 0.08238005f, 0.20151517f, -0.13879396f, 
    -0.08473455f, -0.30260995f, -0.33838066f, 0.00848076f, 0.07039990f, -0.04672557f, 0.11193650f, -0.02738991f, 
    -0.15368730f, -0.20930217f, -0.14600839f, -0.15244426f, 0.17664580f, -0.13728356f, 0.28767845f, 0.18540184f, 
    0.20669279f, -0.10074760f, -0.04808624f, -0.41244641f, -0.26677433f, -0.06182490f, -0.24181253f, -0.17278409f, 
    0.03126679f, 0.16094927f, -0.15123779f, 0.27711013f, -0.32682911f, 0.11985103f, -0.21794172f, 0.05449941f, 
    0.02397449f, 0.24407874f, 0.11466146f, 0.07157624f, 0.47334459f, -0.00449337f, 0.54603654f, -0.11803248f, 
    -0.23197976f, -0.06596941f, 0.04402718f, 0.04265244f, -0.03816480f, -0.31434599f, -0.41784117f, -0.20915391f, 
    -0.23970713f, -0.22162580f, 0.00834054f, -0.00328011f, -0.09688313f, -0.05528673f, -0.24009310f, -0.07307044f, 
    -0.32984674f, -0.19255075f, -0.02916841f, 0.04030528f, -0.01732570f, 0.03166893f, 0.08554383f, -0.15363963f, 
    0.20168538f, 0.70594525f, 0.30900097f, -0.08690257f, -0.01460170f, 0.01080494f, 0.12941283f, 0.17975128f, 
    -0.53993374f, -0.03511341f, -0.10764723f, 0.14899540f, 0.11376058f, -0.01763165f, 0.05284751f, -0.06542263f, 
    0.03236998f, -0.24435566f, 0.17405267f, -0.20104671f, 0.21062687f, 0.21717466f, 0.24064779f, 0.12327605f, 
    0.11772526f, 0.07140891f, 0.02080847f, -0.28879306f, -0.04408403f, -0.04816227f, 0.09610480f, 0.06074741f, 
    0.22746624f, -0.05888546f, 0.07383316f, -0.81679803f, 0.18836473f, -0.03680271f, 0.12041426f, 0.24849366f, 
    0.25820336f, 0.03771611f, 0.13022770f, 0.08112688f, 0.11238896f, 0.01659017f, 0.23472877f, -0.10610261f, 
    0.11050535f, 0.01658750f, 0.02969847f, -0.00832220f, 0.04478017f, 0.50772929f, -0.27328721f, -0.13443136f, 
    -0.44448772f, -0.39460340f, -0.21064396f, -0.14198525f, 0.21106368f, 0.02849364f, -0.07295053f, 0.19000694f, 
    0.41022027f, 0.02999656f, -0.28102821f, -0.28772837f, 0.06439636f, 0.01400710f, -0.05180324f, -0.13032064f, 
    -0.09106050f, 0.17003623f, 0.05821868f, -0.06153020f, 0.08025169f, 0.11093437f, 0.09656613f, 0.11901952f, 
    -0.37740320f, -1.16375887f, -0.32005221f, -0.07353613f, 0.30237922f, 0.19446541f, -0.20681690f, -0.02294170f, 
    -0.05977579f, -0.46310088f, -0.66142559f, -1.01799178f, -0.32618293f, 0.13393612f, -0.03839383f, 0.06818982f, 
    -0.05482692f, 0.09972292f, 0.33237308f, -0.13219850f, 0.17951308f, -0.00527366f, 0.11149476f, 0.14074707f, 
    0.09816927f, 0.04572055f, 0.11295269f, 0.20013720f, 0.38654846f, -0.13923544f, -0.40974241f, -0.14503856f, 
    -0.00292991f, 0.13381641f, 0.02673438f, 0.08264251f, -0.06168704f, -0.13108630f, -0.28852800f, -0.04388288f, 
    0.01758648f, -0.01809135f, 0.06584152f, -0.07649367f, -0.06372382f, -0.26110464f, -0.28697291f, -0.19596335f, 
    -0.14035331f, 0.13017535f, -0.05625012f, 0.28986916f, -0.07517098f, -0.12979452f, -0.31228000f, 0.25849757f, 
    0.00413816f, -0.08722682f, -0.00156785f, 0.00011094f, -0.16955109f, -0.01405162f, -0.20421866f, -0.37752855f, 
    -0.23825951f, -0.05709979f, 0.02682680f, 0.06981608f, 0.08405112f, 0.06372891f, 0.13693248f, -0.02901788f, 
    0.30824023f, -0.21764039f, -0.41600692f, -0.00477443f, 0.02767342f, 0.18687433f, 0.25915527f, -0.00827903f, 
    0.01905602f, -0.14887612f, 0.10202565f, -0.67981929f, -0.09611564f, -0.02077922f, 0.04862181f, 0.27666062f, 
    -0.06562004f, -0.10120208f, -0.46031019f, 0.28545097f, 0.20361695f, -0.05683605f, -0.14689456f, -0.12044936f, 
    -0.03323112f, 0.09735359f, 0.10177935f, -0.26517591f, 0.17937207f, -0.15166423f, -0.09620395f, 0.18726966f, 
    0.02426885f, 0.07191560f, -0.02152416f, 0.09480718f, 0.15236704f, 0.25015569f, 0.03119750f, -0.11474254f, 
    -0.15124394f, -0.23402812f, -0.01717949f, -0.00990012f, 0.16798124f, 0.26666969f, 0.13496174f, 0.10174022f, 
    0.02152067f, 0.06478987f, 0.11194697f, 0.16247675f, 0.12493055f, 0.02049528f, 0.12068554f, 0.14133489f, 
    -0.37858218f, -0.02015584f, 0.07485300f, 0.10203478f, 0.17354919f, 0.07627712f, 0.21144764f, 0.17145298f, 
    0.07288670f, -0.20699963f, -0.02561226f, 0.14223619f, 0.01121120f, 0.13845861f, 0.10032270f, 0.06843998f, 
    -0.00004518f, -0.16985805f, -0.01266493f, -0.10602628f, -0.19854566f, -0.05601440f, -0.00249450f, 0.18770239f, 
    -0.31169280f, 0.22661383f, 0.18272279f, 0.10876891f, 0.05139612f, -0.03391142f, -0.02314653f, 0.14900176f, 
    0.06358400f, 0.07403387f, -0.08679894f, -0.48506764f, -0.22430541f, -0.17030916f, 0.10900545f, -0.07387009f, 
    0.04494349f, 0.17246456f, -0.19677193f, -0.25660595f, 0.35171920f, 0.10736369f, -0.01217426f, 0.02280866f, 
    -0.09490667f, -0.00981655f, 0.10625623f, 0.17022009f, -0.80130857f, -0.75135785f, -0.03080523f, -0.07764383f, 
    -0.00510601f, 0.00093329f, -0.17843451f, -0.06196019f, -0.24016756f, 0.09834165f, -0.50749701f, -0.23339446f, 
    -0.02511868f, -0.08157258f, -0.01392571f, -0.00371341f, -0.02093806f, 0.03935387f, -0.15462154f, -0.15562089f, 
    0.29930246f, -0.07679901f, -0.01813005f, 0.03028071f, 0.01721208f, -0.00269281f, 0.11124912f, -0.63783944f, 
    -0.48155490f, -0.36638674f, 0.08418485f, 0.11921401f, 0.11564659f, 0.20531835f, 0.10447609f, -0.04460560f, 
    0.30682316f, 0.29244325f, -0.02185830f, 0.02278402f, -0.12127158f, -0.02354386f, 0.00280871f, 0.07466651f, 
    0.03614808f, -0.00046826f, -0.10360941f, -0.15153846f, 0.09139079f, 0.37865502f, 0.10425816f, 0.19642851f, 
    0.13183524f, -0.08519237f, 0.08258573f, 0.02604050f, 0.18270931f, 0.01169605f, 0.29970977f, 0.23264505f, 
    -0.03955034f, 0.12649480f, 0.11328437f, 0.07448603f, 0.22561634f, 0.05779463f, 0.05689428f, 0.03824572f, 
    -0.17760739f, -0.02488984f, -0.11021902f, 0.13741043f, 0.10489777f, 0.12412315f, 0.01777471f, -0.09959231f, 
    0.17594337f, 0.07867844f, 0.17060542f, -0.10631360f, 0.08073734f, -0.31919390f, 0.24770622f, 0.07008670f, 
    -0.04271252f, 0.21695419f, -0.21325979f, -0.11605202f, 0.11608540f, 0.21812125f, 0.51775491f, -0.92420030f, 
    -1.05625808f, -0.06939142f, 0.03433353f, 0.14770760f, -0.02795142f, -0.06924579f, -0.14859225f, 0.08272684f, 
    -0.60866815f, -0.33897299f, -0.02439206f, -0.02424396f, 0.47814429f, 0.14547354f, 0.08887301f, 0.06686324f, 
    -0.18864346f, 0.01254587f, 0.14671250f, 0.08324811f, -0.06561846f, 0.06659987f, -0.02824769f, 0.06348880f, 
    0.12003049f, -0.06672816f, -0.16899307f, 0.00370282f, -0.11023385f, -0.21898292f, -0.01828786f, 0.03429540f, 
    0.18795130f, -0.12623878f, 0.21922694f, -0.33326578f, -0.23932524f, 0.00429948f, -0.02838284f, 0.05368855f, 
    -0.04665296f, 0.00674867f, 0.05467425f, -0.15587768f, 0.06216907f, 0.24314350f, -0.21983197f, -0.19598827f, 
    -0.21654649f, 0.15498814f, -0.07812652f, 0.13231876f, -0.08584388f, -0.00895122f, -0.22138885f, -0.10880476f, 
    -0.01206166f, 0.01097312f, 0.03391237f, 0.11018644f, 0.19087456f, -0.27623364f, 0.09920514f, -0.03884643f, 
    -0.27827692f, -0.03075781f, -0.25287023f, 0.11913754f, -0.00402040f, 0.16762492f, -0.02886321f, 0.08843216f, 
    0.04013513f, 0.03787841f, -0.04814780f, -0.17919044f, 0.10236816f, 0.26648352f, 0.11104061f, -0.47271425f, 
    0.05338499f, 0.03411332f, 0.04244598f, 0.06301755f, -0.09932434f, 0.13619773f, 0.08016399f, 0.21527658f, 
    0.20239633f, -0.09706366f, 0.06159557f, 0.04331742f, 0.09104995f, -0.10251720f, 0.06815178f, -0.01704798f, 
    0.06197142f, -0.23671804f, -0.14178978f, 0.06051983f, 0.09090038f, 0.24234216f, -0.25090310f, 0.02841135f, 
    0.33452490f, 0.08750355f, -0.45513931f, -0.61375362f, -0.01166264f, 0.01314026f, -0.07254402f, -0.31505641f, 
    0.08793667f, -0.05499549f, -0.11502563f, -0.19211128f, -0.14501154f, 0.37940162f, -0.01948474f, -0.07290305f, 
    0.20206782f, 0.05507616f, 0.25063491f, 0.16076159f, -0.05760476f, -0.15388434f, -0.18284270f, -0.16885111f, 
    -0.20807090f, -0.23397458f, -0.00783246f, 0.04971638f, 0.22563735f, 0.03842683f, 0.03004341f, -0.07856750f, 
    -0.17171228f, 0.06846235f, 0.12304279f, 0.08292082f, 0.02469798f, 0.25938043f, -0.04879110f, 0.18221506f, 
    0.40490699f, -0.11355056f, -0.03362455f, -0.08101360f, -0.02494871f, 0.17673156f, 0.22636774f, -0.27493325f, 
    -0.08437046f, 0.04238401f, -0.03593406f, -0.06343667f, -0.15714405f, 0.24614234f, 0.20785391f, 0.05295243f, 
    -0.30771637f, -0.22295637f, -0.23056570f, -0.09480800f, -0.13669144f, -0.00428456f, 0.31478840f, -0.04416391f, 
    0.09417538f, 0.05643224f, 0.01840776f, 0.05031770f, -0.10435183f, -0.06031283f, -0.09558998f, 0.09695623f, 
    0.12668316f, 0.18965435f, -0.32632804f, -0.09010229f, 0.16218705f, 0.26588035f, -0.40406555f, -0.04576646f, 
    -0.11125325f, 0.04769667f, 0.04953178f, 0.01955504f, 0.02095076f, 0.03107823f, -0.26474687f, -0.04452571f, 
    -0.07312559f, 0.10103033f, 0.25488672f, -0.01471488f, -0.24433132f, 0.07293037f, 0.03429596f, 0.00552813f, 
    -0.07274417f, 0.24216765f, -0.12529953f, -0.02298948f, 0.15693657f, -0.31615934f, -0.17823982f, 0.06998666f, 
    0.11504675f, 0.01506148f, -0.07776731f, -0.07917447f, -0.13958699f, 0.16568555f, -0.69239134f, -0.38770208f, 
    -0.01825581f, -0.07577537f, 0.07692555f, 0.03140198f, 0.09232035f, -0.03427214f, 0.22726516f, -0.03479521f, 
    0.00300299f, -0.06998092f, -0.03634143f, -0.06777702f, -0.11403012f, 0.13064139f, 0.15416887f, -0.00392897f, 
    -0.13833396f, -0.18241721f, -0.00562603f, 0.00719909f, 0.07100081f, -0.18085349f, -0.09595353f, -0.09401213f, 
    0.18556848f, 0.11678727f, -0.14289173f, 0.05689067f, -0.11090969f, 0.08487826f, 0.30295685f, 0.23849465f, 
    0.25415653f, 0.08102246f, 0.15715972f, 0.07908860f, 0.00885748f, -0.12630072f, -0.05026270f, 0.09284668f, 
    0.15668854f, -0.23196337f, 0.27641228f, 0.10891800f, -0.17847344f, -0.12312912f, -0.05004533f, -0.00920723f, 
    0.21259686f, 0.17236932f, 0.23260188f, 0.09529775f, 0.04969523f, 0.19772847f, 0.09603447f, 0.16456059f, 
    0.21941365f, 0.17420484f, 0.17172195f, 0.35197496f, 0.08182498f, -0.18876997f, 0.06444059f, -0.05872408f, 
    -0.18060815f, 0.07841886f, 0.09129357f, -0.07258385f, 0.14057441f, 0.30860439f, -0.42441872f, -0.34128696f, 
    -0.18704641f, -0.03225184f, -0.11472807f, 0.09012000f, -0.16361044f, -0.10849010f, 0.05944036f, 0.18676740f, 
    -0.06966409f, 0.28220081f, 0.09895463f, 0.07962516f, 0.00420843f, -0.05014498f, -0.00520847f, 0.14673150f, 
    0.02921801f, -0.01951764f, 0.28613541f, 0.15701230f, -0.18673764f, -0.04370717f, -0.00331117f, 0.00565339f, 
    0.11833404f, -0.01611501f, 0.31452051f, 0.46054348f, -0.08812926f, 0.05245657f, 0.08527771f, 0.23340505f, 
    -0.17536123f, -0.12394053f, 0.11361462f, -0.04704229f, -0.06853005f, 0.02998521f, 0.05878783f, -0.23556459f, 
    0.06258966f, 0.04641851f, -0.10891500f, 0.16657932f, 0.04263500f, 0.44367656f, 0.03340558f, 0.09889441f, 
    0.09350438f, 0.02083902f, 0.09863679f, 0.07560701f, -0.02943520f, -0.59983861f, -0.32413155f, -0.00166110f, 
    -0.20658498f, 0.18827085f, -0.10020921f, 0.26556087f, 0.13108113f, -0.06369709f, -0.19016308f, -0.02192306f, 
    0.12768136f, -0.16644463f, 0.08064041f, -0.12696971f, 0.20509398f, 0.04231765f, -0.07303854f, -0.46907336f, 
    -0.40156227f, 0.14172629f, 0.24076249f, -0.03860005f, -0.02099107f, -0.18004343f, -0.05897861f, 0.21411510f, 
    -0.11505979f, 0.20479108f, -0.04915586f, 0.13331448f, 0.14853516f, -0.05447059f, 0.00511084f, -0.08172501f, 
    -0.24651048f, -0.18586834f, -0.35052082f, 0.06712076f, -0.03557069f, 0.02593560f, -0.01408493f, 0.04032969f, 
    -0.15766166f, -0.30647391f, -0.16747424f, -0.24179243f, 0.04529661f, -0.02108403f, 0.03343661f, 0.09113186f, 
    0.09555061f, -0.04562159f, 0.16592874f, 0.33488226f, 0.31793275f, -0.07500084f, 0.01103423f, 0.00068694f, 
    -0.06462294f, -0.20416604f, -0.13846494f, 0.13217834f, 0.04221052f, 0.13629991f, -0.05282402f, -0.03807921f, 
    0.10727417f, 0.17814893f, -0.03460799f, -0.01979175f, -0.27264458f, -0.15451357f, -0.04933239f, 0.17237729f, 
    -0.15297508f, 0.28197992f, -0.16239898f, -0.05002011f, 0.08928679f, 0.07571495f, -0.21365778f, -0.41694981f, 
    0.01325068f, 0.15187344f, -0.11642997f, -0.01038942f, 0.03721330f, -0.15072742f, 0.18956615f, 0.16150713f, 
    0.29191509f, -0.17975493f, 0.01599360f, 0.22321913f, -0.00874148f, 0.07627711f, 0.05865777f, 0.04680240f, 
    -0.10773608f, -0.14994428f, 0.00725571f, -0.03914744f, -0.21847315f, -0.07352299f, -0.07396300f, -0.49751490f, 
    0.39185488f, -0.15053955f, -0.14889348f, -0.00818082f, -0.19475973f, -0.18891788f, 0.00130380f, -0.03421553f, 
    -0.43604368f, -0.26977420f, -0.26381776f, -0.24140705f, 0.01534974f, 0.14404732f, 0.15041775f, 0.00638535f, 
    -0.00406600f, -0.01721552f, 0.02588238f, 0.29776341f, -0.05415850f, -0.17898899f, -0.27283651f, -0.19756317f, 
    0.33848092f, -0.11487963f, -0.00055648f, -0.05136192f, -0.28913826f, -0.19696622f, 0.19316630f, -0.01675431f, 
    -0.00614446f, 0.00328853f, 0.14492273f, 0.26080877f, -0.02735000f, -0.09002281f, 0.07882602f, 0.08983300f, 
    -0.02924730f, -0.01667743f, 0.07276843f, 0.04291685f, 0.03845173f, 0.06731229f, -0.08883582f, 0.57835019f, 
    -0.05804142f, 0.07741772f, -0.00803349f, 0.16949551f, 0.08995067f, 0.07106373f, 0.34897304f, 0.02350152f, 
    -0.00965203f, 0.00456929f, -0.14219059f, 0.01498019f, -0.03123440f, -0.06162845f, 0.03184911f, 0.15487732f, 
    -0.05261297f, 0.24341470f, -0.23013021f, -0.04134306f, 0.23985249f, 0.03406112f, 0.17023849f, 0.03400400f, 
    -0.16122384f, -0.42032599f, -0.07775106f, -0.21475340f, -0.04439444f, -0.40060014f, 0.14430456f, -0.23741138f, 
    0.00688284f, -0.14698707f, -0.26854563f, -0.58719546f, -0.29102087f, 0.10105685f, 0.18514679f, 0.08248640f, 
    0.10225095f, -0.06912875f, 0.06603190f, -0.06876016f, -0.29781079f, -0.05862769f, 0.33354360f, 0.07251974f, 
    0.15937918f, -0.15897556f, 0.03236739f, -0.00144987f, -0.38850886f, 0.00261783f, 0.14494728f, -0.16560793f, 
    -0.11040538f, -0.00933147f, 0.09734469f, -0.05422302f, -0.36489379f, -0.34536579f, -0.34147888f, 0.01075873f, 
    0.08442012f, -0.05846361f, 0.11127911f, -0.03951731f, 0.09055670f, 0.11773745f, -0.01446500f, -0.16119981f, 
    -0.02694944f, 0.16115551f, 0.01496415f, -0.11210094f, 0.16264488f, 0.09622994f, 0.17631897f, -0.17403878f, 
    0.31509024f, 0.16246258f, 0.01410704f, 0.01081642f, 0.12682897f, 0.11910659f, 0.09579849f, -0.03680656f, 
    -0.10610044f, -0.08822563f, 0.08550001f, 0.37378138f, -0.20399098f, 0.25032422f, -0.05449568f, -0.20380262f, 
    0.03840373f, 0.24983665f, 0.10087645f, -0.04185923f, 0.09989624f, 0.22734402f, -0.05216863f, -0.06098799f, 
    0.07092673f, -0.20136887f, -0.17899835f, -0.06914154f, -0.04649980f, 0.08064575f, 0.16109852f, 0.03685630f, 
    0.02999011f, 0.09572750f, 0.53005487f, 0.02678968f, 0.16319397f, -0.08268260f, 0.03823694f, -0.00960550f, 
    0.19554080f, 0.12289155f, 0.00127552f, -0.15425396f, -0.15735479f, 0.14795406f, 0.17290430f, 0.13761386f, 
    0.17788045f, 0.04664527f, 0.08769552f, -0.07668667f, -0.08070073f, -0.06818157f, -0.17871226f, 0.22302525f, 
    0.14112374f, 0.22113463f, 0.02612888f, 0.09366314f, 0.04756370f, -0.33666331f, -0.17391932f, 0.07051840f, 
    -0.02993837f, -0.11828890f, -0.07108199f, 0.01009501f, 0.22798243f, -0.01821227f, -0.17164704f, -0.16236226f, 
    -0.27087259f, 0.10827120f, -0.09580822f, 0.08367589f, 0.30746177f, 0.03988535f, -0.14250778f, -0.12442914f, 
    -0.16023152f, -0.04566702f, 0.05618963f, -0.01403540f, 0.04254822f, -0.00499359f, 0.18572518f, 0.12848590f, 
    0.11946476f, -0.07646631f, -0.20738140f, 0.34708062f, -0.04936141f, -0.17870796f, 0.13266611f, -0.15572852f, 
    0.01480657f, -0.43718547f, -0.32838142f, -0.24120001f, 0.14075588f, -0.12161221f, -0.33272031f, 0.14829583f, 
    -0.05724351f, 0.02181806f, 0.01654395f, -0.17631206f, 0.22515573f, -0.02215078f, 0.07638826f, 0.15737331f, 
    -0.10466835f, 0.05254908f, 0.21982782f, 0.17438148f, -0.04898372f, -0.04810745f, 0.12818961f, 0.05912200f, 
    0.20116737f, -0.05913650f, 0.06234005f, 0.13904454f, -0.19248138f, -0.19590752f, -0.17385969f, -0.22217725f, 
    -0.05458808f, 0.07260108f, -0.22433668f, -0.03412253f, -0.35323724f, 0.11545108f, 0.03456748f, -0.20146905f, 
    -0.05234045f, -0.01854823f, 0.08993683f, 0.32702458f, 0.04551166f, 0.03361257f, 0.02798141f, 0.09822963f, 
    0.39831921f, 0.23161094f, 0.10836910f, 0.07745367f, -0.09292995f, -0.08476038f, -0.15159272f, 0.48806593f, 
    -0.40964365f, -0.10278811f, 0.01256951f, 0.07563883f, 0.29041925f, 0.00438912f, -0.05677381f, 0.18177408f, 
    -0.14410762f, -0.25912064f, -0.18986085f, 0.04702544f, -0.03549769f, -0.05197073f, 0.07616510f, 0.15073600f, 
    0.08790495f, -0.07547569f, 0.01988515f, -0.04728242f, -0.02446042f, -0.12761055f, 0.13697937f, 0.17677461f, 
    0.15274850f, 0.00266340f, 0.12940471f, -0.26272565f, 0.20560393f, 0.07912627f, 0.11491819f, 0.12115771f, 
    0.06701136f, 0.36243331f, 0.26953277f, 0.06303432f, -0.03987152f, -0.10002159f, -0.05722025f, -0.20223886f, 
    0.01774457f, 0.16115440f, -0.06287859f, -0.26572365f, -0.00000382f, 0.15576759f, -0.02217168f, -0.02377364f, 
    -0.19198695f, 0.20960286f, -0.12528738f, -0.18516098f, -0.20373923f, 0.47107619f, -0.34520385f, -0.00866855f, 
    0.24055073f, -0.08604377f, 0.07211989f, -0.02115698f, -0.02428226f, -0.00539472f, 0.01795710f, -0.34961581f, 
    -0.09251402f, -0.03569281f, 0.13472025f, 0.10395340f, 0.10435130f, 0.07129751f, -0.18245210f, 0.02368834f, 
    0.04031344f, 0.30615804f, 0.03333307f, -0.00886120f, 0.11040848f, 0.26952335f, 0.21804683f, 0.12089682f, 
    -0.08833775f, -0.05866279f, -0.29867837f, -0.26306027f, -0.14089751f, -0.02069549f, 0.39184731f, 0.19126274f, 
    0.00686167f, -0.06240992f, -0.15104422f, -0.19303048f, 0.29532585f, 0.05736772f, 0.07917174f, 0.30099058f, 
    0.18833549f, 0.18869938f, 0.09040377f, -0.20388237f, -0.24075729f, 0.06336418f, -0.02747473f, -0.05247828f, 
    0.05950705f, -0.02373067f, -0.07133506f, 0.18169898f, -0.17725883f, -0.05401579f, -0.23224230f, -0.06237889f, 
    -0.11118120f, -0.03119645f, 0.16951260f, -0.05262204f, 0.10093675f, -0.01222231f, -0.21788107f, 0.32043123f, 
    0.02091097f, 0.22788395f, 0.24166845f, 0.14833884f, -0.01314749f, 0.00569788f, -0.18294714f, -0.14778249f, 
    -0.19903529f, -0.12735090f, -0.07902011f, -0.26901180f, 0.04731097f, -0.18283145f, -0.40356657f, -0.02024761f, 
    0.14790146f, 0.07816242f, -0.09482010f, -0.04481978f, -0.16476016f, -0.20535892f, -0.15129966f, -0.06721810f, 
    0.11258616f, -0.12157175f, 0.25586140f, 0.24617510f, 0.23356938f, 0.05297486f, 0.08642200f, 0.02528435f, 
    -0.04117214f, -0.03333737f, 0.00250986f, -0.00426245f, 0.00141224f, -0.01577234f, -0.02397326f, -0.02722106f, 
    0.00327341f, 0.03700736f, 0.03675630f, -0.01856417f, -0.06097599f, -0.02481655f, 0.03378695f, 0.04189076f, 
    0.04590087f, 0.05000574f, -0.06180111f, -0.01526370f, 0.02653090f, -0.00086098f, -0.00631328f, -0.00114113f, 
    -0.04795741f, -0.02347995f, -0.00128109f, -0.05798210f, -0.04244457f, -0.02552576f, 0.01368887f, -0.00320249f, 
    0.01842117f, 0.01919515f, -0.04779576f, 0.00308247f, -0.05654697f, -0.00095332f, 0.03634930f, 0.01891121f, 
    0.02829402f, -0.04359853f, 0.03731975f, 0.05266870f, 0.02172161f, -0.01333829f, -0.01160776f, 0.05154901f, 
    -0.02235068f, -0.02988858f, -0.04099323f, -0.04016584f, -0.05333179f, 0.00513089f, -0.04169632f, -0.05818209f, 
    0.03961914f, 0.04523913f, -0.01301643f, -0.06098437f, -0.05531669f, 0.03094809f, -0.00994704f, -0.05610916f, 
    0.02031783f, -0.04817140f, 0.05173030f, -0.01395822f, -0.03569257f, -0.00689976f, -0.01304327f, 0.02151773f, 
    -0.05671745f, 0.04298882f, -0.02437019f, 0.01772599f, -0.01380287f, 0.03714978f, -0.06497945f, 0.05105415f, 
    -0.01703628f, -0.00353537f, 0.01332316f, 0.02415983f, -0.01681606f, -0.02386188f, -0.04631915f, -0.02531191f, 
    0.01053878f, -0.02191311f, 0.00333709f, 0.02094145f, -0.05910346f, 0.02900102f, -0.03406962f, -0.02994983f, 
    -0.01506133f, -0.03666471f, -0.06537733f, -0.00196964f, -0.03608642f, -0.06146179f, -0.04454786f, 0.03451947f, 
    0.04059535f, 0.03653284f, -0.03687533f, -0.05547696f, -0.03959798f, -0.04612345f, 0.03142443f, 0.04570729f, 
    0.02336877f, -0.01145198f, -0.03502462f, -0.05117348f, 0.04429691f, -0.03446386f, 0.01571358f, 0.04781928f, 
    -0.00885731f, 0.02128049f, 0.00124142f, -0.01861065f, 0.02666535f, -0.02246168f, -0.03715496f, -0.02420522f, 
    -0.03725854f, 0.01198404f, 0.01308923f, 0.03671547f, -0.02694303f, 0.05376626f, 0.00185809f, -0.01357731f, 
    0.00227406f, -0.03415037f, -0.02954610f, 0.00420606f, 0.04257989f, -0.04737696f, 0.04818025f, 0.04800317f, 
    -0.00329472f, -0.01298159f, 0.03102555f, -0.05679397f, 0.00990521f, -0.02054333f, 0.00449448f, 0.00206422f, 
    0.02279572f, -0.04241125f, 0.00320093f, -0.02290461f, 0.01195276f, -0.02862415f, -0.03093817f, -0.04319421f, 
    0.00548104f, -0.06064929f, 0.02307924f, -0.02208563f, 0.05017392f, -0.03573682f, -0.06022254f, 0.00835449f, 
    0.01562516f, 0.01783436f, 0.00916338f, 0.04565373f, 0.00287863f, -0.02279008f, -0.05475507f, 0.02607610f, 
    0.02778706f, 0.01001853f, -0.02298625f, 0.05297307f, 0.02833926f, 0.00297315f, -0.04068362f, -0.03862668f, 
    -0.05573326f, -0.01007481f, -0.03357327f, -0.00413005f, 0.00859914f, -0.01902049f, 0.03398538f, 0.01283691f, 
    -0.05578598f, 0.01248652f, -0.03564702f, -0.00366575f, -0.00004175f, -0.00015726f, -0.03059814f, -0.06323981f, 
    -0.02647785f, -0.02737750f, 0.01846622f, -0.05656578f, 0.00634856f, 0.05178881f, -0.00374965f, -0.00619467f, 
    -0.06300984f, -0.06143190f, 0.01496174f, 0.01162490f, 0.03341740f, -0.05125496f, 0.01136970f, -0.07095421f, 
    0.04390156f, 0.02979997f, 0.01322892f, -0.01263406f, 0.03476254f, 0.00465168f, -0.00555234f, 0.04962084f, 
    -0.01820684f, -0.04416417f, 0.04987156f, -0.06916898f, -0.03205978f, -0.03383202f, 0.00632143f, -0.02374280f, 
    -0.06034782f, 0.01507459f, -0.00104970f, -0.01633226f, 0.02384288f, 0.03604066f, -0.02325972f, 0.01145863f, 
    0.00628692f, 0.00914876f, 0.01736930f, 0.01192158f, -0.02803277f, -0.05573330f, -0.01603745f, -0.03132821f, 
    -0.05426530f, 0.04994493f, -0.00330984f, -0.04234315f, 0.03073962f, 0.03176615f, -0.04322502f, -0.00639553f, 
    -0.05167773f, 0.03846196f, 0.02627044f, 0.00468844f, 0.01098263f, 0.00350386f, -0.02563024f, 0.03567689f, 
    -0.03636064f, -0.03602349f, 0.02128454f, 0.04516144f, -0.00640279f, 0.05439026f, -0.04842710f, 0.00053940f, 
    -0.01532481f, -0.03080411f, 0.02844904f, -0.00741286f, -0.01215253f, 0.04053366f, 0.02901927f, 0.00577076f, 
    0.01289180f, 0.04753513f, -0.04309310f, 0.00920961f, -0.03015012f, 0.03859552f, -0.01118010f, 0.02085515f, 
    0.13534954f, 0.17066798f, -0.28769374f, -0.07117127f, 0.07537246f, -0.14716476f, 0.05514785f, -0.02365141f, 
    0.07168330f, 0.11848139f, 0.13021673f, -0.38023442f, 0.03652341f, 0.03575481f, 0.03274282f, -0.11419045f, 
    0.14669718f, 0.11695405f, -0.32827336f, -0.13024427f, 0.15042041f, -0.18535104f, 0.20784332f, -0.04252102f, 
    -0.14063430f, -0.24841426f, 0.24758092f, 0.36542946f, 0.19956803f, -0.40321916f, 0.09345470f, -0.01976395f, 
    0.04224782f, 0.00432924f, -0.09721481f, -0.26199472f, 0.07661444f, -0.00963926f, 0.16779326f, -0.24885945f, 
    -0.04628158f, -0.46155068f, -0.12404621f, 0.02635160f, -0.07949134f, 0.15006125f, 0.16627920f, 0.42369863f, 
    -0.31665722f, -0.10009418f, -0.03476727f, 0.03325249f, 0.04134497f, 0.03608505f, 0.08234163f, -0.09245311f, 
    0.10559238f, 0.01994198f, 0.06467923f, -0.27268937f, -0.31210238f, 0.17485279f, 0.19765839f, 0.07874846f, 
    0.45774004f, -0.14162344f, 0.01891434f, -0.19450960f, 0.05501546f, 0.02284640f, 0.02250764f, -0.03364761f, 
    0.04888465f, -0.00191553f, 0.25804010f, -0.20551404f, -0.00979260f, -0.25977674f, -0.01978588f, 0.17253962f, 
    -0.02629483f, 0.41060799f, 0.72273791f, 0.09370442f, -0.06119764f, -0.17595796f, 0.27383673f, -0.08294013f, 
    0.10420757f, 0.00065736f, 0.02543989f, 0.33002520f, -0.33988509f, -0.03192744f, 0.09748282f, -0.00351921f, 
    -0.09524149f, -0.11068831f, 0.16150130f, 0.02850778f, 0.17203306f, 0.19560058f, 0.01676557f, 0.02613150f, 
    -0.22149767f, 0.03422715f, -0.06809946f, -0.00303688f, -0.01321997f, -0.12166224f, 0.02285089f, -0.00769061f, 
    0.02699850f, 0.05522843f, -0.15998475f, -0.20382333f, -0.38115725f, -0.06150757f, 0.00724220f, 0.18684015f, 
    0.00885251f, 0.09198214f, 0.07802249f, -0.20118608f, -0.07008358f, 0.06712237f, 0.17760420f, 0.27237484f, 
    -0.27624071f, 0.08327103f, -0.07529423f, 0.00345500f, -0.15079205f, -0.00421765f, -0.26641154f, -0.03146886f, 
    0.13163926f, 0.41877249f, -0.06664471f, -0.19900061f, 0.32409000f, -0.25119448f, 0.30086014f, -0.02166304f, 
    -0.01844393f, 0.19959231f, 0.22035368f, -0.41048431f, 0.13689826f, 0.03660640f, -0.10810743f, 0.13269202f, 
    -0.13525118f, -0.10298122f, -0.08738973f, 0.05422391f, 0.06389715f, 0.03878192f, 0.13368796f, -0.18722926f, 
    0.18950111f, -0.02203965f, -0.07286007f, 0.04994895f, 0.39177918f, 0.09705546f, -0.43998066f, 0.20787686f, 
    -0.07480311f, 0.26355991f, -0.15656777f, 0.02856107f, -0.08458097f, 0.21721189f, 0.06179396f, -0.00574562f, 
    -0.07870194f, -0.12503529f, -0.02380834f, -0.13853066f, 0.14843743f, 0.14452371f, -0.39545250f, 0.06902397f, 
    0.21517792f, -0.40285102f, -0.00235253f, 0.01083958f, -0.22015469f, 0.21833333f, 0.27983183f, -0.05215627f, 
    0.04952135f, -0.00058337f, 0.21112928f, 0.09605858f, -0.02367625f, -0.18583652f, -0.06670631f, 0.08511176f, 
    0.22356254f, 0.06756402f, 0.05644257f, 0.09367162f, -0.06453203f, -0.21468443f, -0.03482362f, 0.03274590f, 
    0.26041567f, 0.09945123f, -0.08226452f, 0.01435526f, -0.05384024f, 0.08064333f, 0.04958521f, 0.08795690f, 
    -0.29351246f, -0.31021699f, 0.13461509f, -0.23362316f, 0.10515895f, 0.08783520f, -0.13347524f, -0.32782519f, 
    0.06693779f, -0.19390136f, -0.04916621f, 0.38261580f, -0.44929725f, -0.04651255f, 0.30486974f, 0.00322887f, 
    0.17138806f, 0.03158042f, -0.10563665f, -0.00317510f, 0.02012623f, 0.13376610f, 0.00969182f, -0.12932885f, 
    0.12150116f, -0.05781002f, 0.55335838f, -0.27651832f, -0.14487168f, 0.15183359f, -0.10779553f, -0.14515109f, 
    -0.04256401f, 0.01157935f, -0.10301233f, 0.12750120f, 0.16072790f, -0.17448837f, 0.17663138f, -0.04486849f, 
    0.05272280f, 0.19662322f, -0.30077949f, 0.12964901f, 0.10139644f, 0.06058371f, -0.11087757f, 0.11847980f, 
    0.28295490f, -0.22850533f, -0.14436154f, 0.04840626f, -0.36552495f, -0.34165284f, 0.12709168f, 0.15384153f, 
    0.10978669f, 0.06216519f, 0.10051176f, -0.20923176f, -0.15496182f, 0.07061306f, 0.01856391f, 0.22887200f, 
    0.00507623f, 0.18845519f, 0.18673271f, -0.03612641f, -0.06438062f, 0.04849807f, 0.11466818f, -0.24259099f, 
    0.03493670f, -0.01735548f, -0.00253532f, -0.03986364f, 0.04745824f, -0.02144190f, -0.04429148f, -0.05053681f, 
    -0.03352341f, 0.03490861f, -0.02103081f, -0.04274690f, -0.04700726f, 0.04254945f, -0.00765699f, 0.03864475f, 
    -0.01812042f, 0.00986765f, 0.01460587f, 0.01774671f, -0.04278554f, -0.04424766f, 0.04546062f, 0.03923881f, 
    0.01700819f, -0.03647775f, 0.00881469f, 0.03315992f, 0.03568204f, 0.01105239f, -0.01079983f, 0.00742234f, 
    -0.01542201f, -0.05883365f, 0.00796018f, 0.04523748f, -0.02234993f, 0.00078456f, -0.05124221f, -0.00327696f, 
    -0.05213562f, -0.00748909f, 0.03090666f, -0.01229788f, -0.04079724f, 0.01906524f, 0.04617330f, -0.04904094f, 
    0.00104657f, -0.00127258f, -0.02571108f, -0.01356373f, 0.00207620f, -0.01023264f, 0.01963142f, -0.03655575f, 
    0.00903774f, 0.00153990f, -0.02267971f, 0.00040396f, -0.03613772f, 0.00682706f, 0.00412851f, -0.05488062f, 
    -0.02628870f, 0.03620930f, 0.00311614f, 0.02942319f, 0.04451301f, -0.05083523f, -0.04759820f, -0.03854418f, 
    0.01602406f, 0.01659946f, -0.02437695f, 0.05141795f, 0.03230168f, 0.02577491f, -0.06014370f, 0.02716289f, 
    -0.02935743f, -0.02287324f, -0.02352403f, 0.04032532f, -0.04435654f, -0.05352507f, -0.05399974f, -0.00626951f, 
    0.04226712f, 0.00383567f, -0.01253105f, 0.03237209f, -0.00170181f, 0.01783593f, 0.01647103f, -0.00214680f, 
    -0.04026639f, 0.01519581f, 0.02000224f, -0.01956996f, -0.04495893f, -0.05711001f, -0.04694177f, -0.06170737f, 
    -0.03477735f, 0.00301867f, 0.02464728f, 0.00341702f, -0.04222899f, 0.04075706f, -0.01108796f, 0.05276811f, 
    -0.04985100f, 0.03421530f, 0.02248004f, -0.01965262f, 0.03865222f, 0.00852436f, -0.04950259f, -0.04605139f, 
    -0.03442527f, -0.01480322f, -0.06316704f, 0.00078242f, 0.05107826f, -0.04748912f, -0.03525566f, -0.00705044f, 
    -0.03914889f, -0.01383711f, -0.00330246f, 0.05154695f, -0.04282940f, -0.02705438f, -0.03672598f, 0.01119886f, 
    -0.04085784f, -0.03758681f, -0.02116026f, 0.01216558f, 0.03370299f, -0.00974462f, 0.01405798f, -0.01981646f, 
    0.04745240f, 0.01669591f, -0.00223143f, 0.01193127f, 0.01222377f, -0.03386015f, -0.05672958f, 0.04469620f, 
    -0.00202826f, -0.04541627f, 0.01719228f, -0.00471083f, 0.03958635f, -0.04226226f, -0.01413301f, 0.05218535f, 
    -0.02567782f, -0.05930964f, 0.03690850f, -0.05806484f, 0.03382502f, -0.04109224f, 0.01131058f, 0.03651711f, 
    0.05248579f, -0.01414771f, -0.05014267f, 0.03989644f, -0.05383294f, -0.04357910f, 0.04643317f, 0.03291952f, 
    0.02139258f, -0.06274163f, -0.05212171f, -0.02503983f, 0.04458122f, -0.05383385f, -0.04369394f, -0.05900500f, 
    -0.05434054f, 0.00736923f, 0.04452898f, -0.01352845f, -0.03405663f, -0.00335380f, 0.03055687f, 0.01170828f, 
    -0.04405696f, 0.00218921f, -0.01367699f, 0.00533741f, -0.03839867f, -0.03460723f, 0.03146959f, 0.02059319f, 
    0.00231337f, -0.06066534f, 0.04936186f, -0.03812942f, 0.04756286f, 0.00067790f, 0.02066261f, 0.02609323f, 
    0.00265957f, 0.02769350f, 0.03012936f, -0.03125573f, -0.00588014f, -0.01780313f, -0.00410673f, -0.00026044f, 
    -0.05967036f, -0.03751778f, -0.01434885f, 0.01076309f, 0.03802745f, 0.04927140f, 0.03007248f, -0.05770700f, 
    0.04008794f, -0.04348354f, -0.04885375f, 0.01439631f, -0.05070037f, -0.02376808f, -0.04496646f, -0.05225289f, 
    -0.03412693f, -0.03007846f, 0.05183310f, -0.02270200f, 0.01026762f, -0.04065358f, -0.04513999f, -0.00416292f, 
    -0.01814055f, 0.04938843f, -0.02997126f, -0.03016179f, -0.02303264f, -0.03119531f, -0.00450929f, -0.01412219f, 
    -0.00417074f, -0.03857775f, -0.03305900f, -0.03451950f, -0.02565224f, 0.02741103f, 0.01814178f, -0.03118304f, 
    0.04030227f, -0.00050135f, -0.03251012f, 0.02712115f, 0.03386329f, -0.01823527f, 0.01317696f, 0.05304216f, 
    0.02576939f, -0.03191518f, -0.02684362f, 0.03574313f, 0.03979823f, -0.05115932f, -0.05302259f, -0.03253413f, 
    0.01157992f, 0.01735030f, -0.02915870f, -0.03211573f, -0.06307851f, -0.05387010f, 0.00824148f, -0.05028656f, 
    -0.05663138f, -0.01857435f, 0.03833542f, 0.00655899f, 0.03001605f, 0.03405284f, -0.03059838f, -0.01891233f, 
    0.23836362f, -0.04249525f, -0.18129033f, 0.14602062f, 0.09404334f, 0.20234032f, 0.08122960f, 0.10628659f, 
    -0.11001293f, 0.35358107f, 0.20545015f, 0.16139419f, 0.01551768f, 0.10922878f, 0.15211080f, 0.14137270f, 
    -0.11799650f, 0.03277228f, 0.02254122f, -0.36733091f, -0.57638067f, -0.07947315f, 0.10842617f, -0.17508458f, 
    0.11698416f, 0.05318996f, 0.19294898f, 0.15428846f, 0.20546114f, 0.08624958f, -0.06542976f, 0.05750221f, 
    -0.05582513f, 0.13674572f, -0.10352647f, 0.17689978f, -0.04858738f, -0.92878807f, -0.22971514f, -0.30342674f, 
    0.00606733f, -0.05509723f, 0.17424551f, 0.14156592f, 0.35224718f, 0.02993326f, 0.04146630f, -0.10266193f, 
    -0.23636846f, -0.30648908f, 0.12505579f, -0.11835878f, 0.06632525f, 0.05335424f, -0.56141096f, -0.76087838f, 
    -0.05939799f, -0.02375907f, -0.60176343f, -0.28975809f, 0.16859400f, 0.28385890f, 0.00921666f, 0.24182141f, 
    0.12692495f, 0.36544824f, -0.21298307f, 0.17476273f, 0.08296574f, 0.07912574f, 0.09229628f, 0.05096793f, 
    -1.39816844f, -0.48665649f, 0.11147334f, -0.04870528f, -0.05832972f, 0.14962888f, 0.10959769f, 0.17002054f, 
    0.14025505f, -0.20294105f, -0.77600467f, 0.43196276f, -0.04463958f, -0.04439460f, 0.30685988f, 0.10946786f, 
    -0.02598977f, 0.49435347f, 0.08959948f, 0.22465435f, 0.04740597f, -0.14444275f, -0.00995088f, -0.27194893f, 
    -0.00707187f, -0.06638303f, 0.17909376f, 0.31817275f, 0.05226067f, 0.31445903f, 0.20281355f, 0.14229497f, 
    0.06411558f, 0.07879080f, 0.00473115f, 0.00761759f, -0.01341873f, -0.05734154f, -0.29863226f, 0.05161784f, 
    -0.47934729f, -0.33059648f, -0.01222266f, -0.04383461f, -0.35796580f, 0.24980693f, -0.34805113f, -0.13565788f, 
    0.12545413f, 0.06072831f, 0.11195231f, 0.35633212f, 0.06990440f, 0.11618648f, -0.31085554f, 0.02090997f, 
    -0.24942023f, -0.16966602f, -0.10655335f, 0.09947072f, 0.22120745f, 0.15578645f, -0.23461211f, -0.65196860f, 
    -0.71509725f, 0.18640533f, -0.21374252f, 0.11128315f, -0.08326776f, -0.16283904f, 0.01883481f, -0.23487456f, 
    0.11419579f, 0.28014794f, 0.04201589f, -0.05795000f, 0.07424881f, -0.00265343f, -0.21253762f, 0.36121601f, 
    0.07932512f, -0.24409516f, -0.62648767f, -0.23469929f, -0.04920093f, -0.15478253f, 0.10362374f, 0.23705085f, 
    0.03667900f, 0.02004719f, 0.41507325f, -1.01058114f, -0.55663705f, -0.18880647f, -0.38679078f, 0.47784176f, 
    -0.08558908f, 0.07067674f, -0.32717222f, 0.05055495f, -0.47950670f, 0.19656056f, -0.09382820f, -0.31805280f, 
    -0.19164743f, 0.09306183f, 0.09063677f, -0.05901274f, 0.20178658f, -0.51304299f, -0.51664925f, 0.07647468f, 
    0.02407895f, 0.04588693f, 0.14108668f, 0.03089702f, -0.00898125f, 0.01415867f, 0.15981092f, 0.40887380f, 
    -0.48601320f, -0.00614676f, -0.03058419f, -0.15085018f, 0.18688944f, 0.06201926f, -0.58468539f, 0.01239911f, 
    -0.03251000f, 0.03688950f, -0.07330421f, 0.03562812f, 0.08086403f, -0.00043552f, 0.24936019f, -0.01355906f, 
    -0.11109395f, -0.18533924f, -0.05784249f, 0.03475384f, 0.15060422f, 0.11476077f, -0.15561216f, -0.01238731f, 
    -0.11901824f, -1.16099894f, -0.43601328f, 0.04964693f, 0.09152688f, -0.08810348f, 0.05073524f, -0.00096279f, 
    0.19707137f, -0.40179169f, -1.03681242f, -0.24316660f, -0.01184950f, 0.20794846f, 0.09204129f, 0.12043604f, 
    -0.06321922f, 0.05180053f, 0.47276109f, -0.37256861f, 0.16002399f, -0.06619802f, 0.15594432f, 0.21161950f, 
    0.17597829f, 0.10032114f, 0.33978158f, -0.00761413f, -0.82805932f, 0.30726936f, -0.27354118f, 0.00758068f, 
    0.06837735f, 0.06368317f, 0.26913974f, -0.00719779f, -0.54210633f, -0.10995900f, -0.13857378f, 0.12979238f, 
    -0.28059188f, 0.03600262f, 0.06179722f, 0.29170874f, 0.18798403f, 1.02751040f, -0.54221499f, -0.39597288f, 
    -0.07968399f, -0.12831277f, -0.47684139f, 0.22912376f, -0.05430499f, -0.25730881f, 0.35292083f, 0.06559348f, 
    0.27873230f, -0.03463556f, 0.05597292f, -0.00977529f, 0.11746799f, 0.03705318f, -0.10909023f, 0.14903200f, 
    0.05496627f, 0.24611458f, -0.22679839f, -0.01405898f, 0.04148226f, 0.15093946f, 0.00353528f, -0.03242463f, 
    0.38569003f, 0.13614646f, -0.38162479f, 0.09191804f, 0.02071179f, 0.39523095f, -0.08306844f, -0.04027074f, 
    0.00189346f, 0.27067080f, 0.12020232f, -0.00877126f, 0.02254415f, 0.11114337f, 0.25478461f, 0.00730549f, 
    -0.00953959f, 0.10119022f, -0.32265162f, -0.47382829f, 0.15580907f, -0.19994029f, -0.14604695f, -0.17781344f, 
    0.00575337f, 0.22930911f, 0.03052808f, 0.30627304f, 0.42468315f, -0.09689391f, 0.03335956f, -0.07533927f, 
    0.06301208f, 0.03296596f, 0.01311731f, -0.04896110f, -0.01433482f, 0.00579036f, -0.61172038f, 0.16492693f, 
    -0.24597007f, -0.36398488f, 0.09506617f, 0.13869900f, -0.00119348f, -0.29658070f, 0.24426097f, -0.27044705f, 
    0.27366033f, 0.03043772f, 0.16029596f, 0.09525336f, 0.14060718f, 0.06845069f, 0.20523936f, 0.02575463f, 
    -0.20986493f, -0.21233419f, -0.32239690f, -0.06145013f, 0.08026574f, -0.03440377f, 0.17340980f, -0.00709125f, 
    -0.01299350f, 0.00992804f, 0.12370503f, 0.14364572f, 0.16744736f, 0.03833677f, -0.00054309f, -0.06772021f, 
    0.43269083f, -0.30345291f, 0.69394767f, 0.00977058f, -0.26568231f, -0.08323335f, -0.15210369f, -0.06796247f, 
    -0.02400106f, 0.08502819f, 0.35878447f, -0.08921248f, -0.02018602f, -0.03033287f, 0.07061507f, -0.02801453f, 
    0.01762024f, 0.10887454f, 0.14925392f, 0.17128600f, -0.14347993f, -0.21811457f, 0.08982427f, -0.30859751f, 
    0.00186910f, 0.03241973f, 0.25905561f, 0.27749527f, -0.04311999f, 0.04439644f, 0.01920200f, 0.01670309f, 
    0.34890410f, -0.12782416f, 0.02366264f, -0.12996325f, 0.21935649f, -0.32761553f, -0.00136282f, 0.42700654f, 
    0.14000861f, -0.21241684f, 0.09080236f, 0.12028708f, -0.04165758f, -0.45979443f, -0.19922796f, 0.34152299f, 
    0.00126590f, 0.15143748f, -0.07780896f, 0.00327434f, -0.00458354f, 0.02736072f, 0.29554141f, 0.40094891f, 
    -0.12729289f, -0.07795043f, 0.02301061f, -0.06662000f, -0.14286901f, 0.03924514f, -0.04053495f, -0.10595634f, 
    -0.64725333f, 0.37451613f, 0.11820390f, 0.26215526f, -0.08920851f, -0.19815528f, -0.20711729f, -0.08228724f, 
    0.00760044f, -0.32804734f, 0.67200160f, -0.21707352f, 0.18450548f, -0.03755083f, -0.11888910f, 0.20538585f, 
    0.19183885f, -0.19315095f, -0.28670061f, 0.04791569f, 0.05035730f, -0.04634142f, -0.10198204f, 0.17748216f, 
    -0.01125125f, 0.00368753f, 0.89129376f, -0.60914832f, -0.09518520f, 0.12949790f, -0.22457699f, 0.00765303f, 
    -0.06313937f, 0.05362419f, -0.10423062f, -0.09306659f, -0.48355898f, -0.09525916f, -0.01254839f, 0.08500914f, 
    0.07334054f, -0.15300077f, 0.03669475f, -0.26666927f, 0.46514434f, -0.11751027f, -0.58969599f, 0.01990850f, 
    0.06764252f, 0.19916169f, -0.07474706f, 0.05305998f, 0.00698965f, 0.27064589f, 0.23261590f, -0.10239148f, 
    0.12526241f, 0.02020589f, 0.13315570f, 0.13605347f, 0.06844166f, 0.03039376f, -0.32302871f, -0.13316537f, 
    0.20896281f, -0.13466600f, 0.01002071f, -0.10287099f, 0.07976660f, -0.09540959f, 0.07837310f, 0.02386991f, 
    0.20596732f, -0.40055391f, 0.11048808f, -0.03664354f, -0.01884058f, -0.12147720f, 0.14327377f, -0.21012001f, 
    -0.41510484f, -0.78319412f, -0.12280798f, -0.14495195f, -0.22913815f, 0.00919838f, -0.00341553f, 0.16801378f, 
    0.05611596f, -0.29253533f, -0.04435536f, -0.25776002f, -0.13797927f, -0.25400624f, 0.13695842f, 0.16216786f, 
    0.12341575f, -0.14916599f, -0.68301070f, 0.17466958f, -0.19912630f, 0.06525151f, 0.18132761f, -0.09238883f, 
    0.03915062f, 0.15744287f, 0.00702670f, 0.22973628f, -0.03733765f, 0.07108179f, -0.10739438f, -0.16945495f, 
    -0.01976825f, 0.00200668f, 0.17642172f, -0.11343338f, -0.12206705f, 0.03219426f, -0.80517405f, 0.06159275f, 
    -0.08189423f, -0.25573018f, -0.13609689f, 0.00358254f, -0.09332438f, 0.25969532f, -0.15196322f, 0.43470871f, 
    -0.16969594f, -0.20792274f, -0.03923799f, 0.08210891f, 0.08142235f, -0.37043145f, 0.66824853f, 0.22088386f, 
    0.04312516f, 0.13567479f, 0.01526670f, 0.33203179f, -0.04829120f, 0.01134207f, -0.03218056f, 0.58471215f, 
    0.04391610f, 0.21037622f, 0.10234082f, -0.04057775f, 0.04911565f, -0.09521664f, -0.09396104f, -0.11262530f, 
    -0.29753047f, 0.20239106f, 0.55141306f, 0.05144295f, -0.06701852f, -0.26885396f, -0.05830073f, -0.13821533f, 
    -0.08551682f, -0.03861419f, -0.20329349f, -0.38969871f, 0.05057411f, -0.01448883f, -0.21751881f, -0.02778556f, 
    0.06433559f, 0.07329919f, 0.55660325f, -0.10106683f, 0.03982575f, 0.13525744f, 0.20295863f, 0.18033043f, 
    0.21516959f, 0.11478977f, 0.26390365f, -0.37795916f, -0.29513997f, -0.49167252f, 0.06048057f, 0.07535789f, 
    0.08825610f, 0.04000573f, 0.13720469f, -0.09708685f, -0.13461781f, -0.07996696f, 0.08509769f, 0.01805995f, 
    0.05824581f, 0.06635094f, -0.09819110f, -0.03703701f, -0.00256046f, -0.37780094f, 0.17358305f, 0.17888597f, 
    -0.02458536f, 0.00663914f, -0.07912082f, 0.07643652f, -0.14336520f, -0.04767358f, -0.16021115f, -0.16174385f, 
    0.02909633f, 0.20153774f, -0.06405135f, -0.04095373f, 0.15611929f, 0.01703294f, -0.11712126f, -0.07254377f, 
    0.16547091f, -0.16154531f, -0.18310748f, 0.31146067f, 0.08582672f, 0.16497961f, 0.12039447f, 0.03426990f, 
    -0.17056938f, 0.04599983f, 0.04871737f, 0.06739543f, -0.00541411f, 0.04311687f, 0.07206797f, -0.08592651f, 
    0.12955533f, -0.05296027f, -0.15527891f, 0.21817982f, -0.06930534f, 0.05022881f, 0.12182090f, -0.02063679f, 
    -0.22156176f, 0.13530889f, -0.21824113f, -0.24235277f, -0.79773718f, 0.06175213f, 0.09707570f, 0.20498896f, 
    0.26776600f, 0.28941333f, 0.09946339f, 0.00518236f, -0.06610756f, 0.07528803f, 0.15395184f, 0.12602909f, 
    -0.20630857f, -0.09618668f, 0.02128649f, 0.14763808f, 0.06279301f, 0.03513176f, 0.00308579f, -0.06441081f, 
    -0.17730638f, -0.20597416f, -0.00453680f, -0.00215014f, -0.04186153f, 0.33789900f, 0.12860489f, 0.03759995f, 
    0.01734930f, 0.20215701f, 0.18580715f, -0.00426893f, 0.10188262f, -0.04810359f, -0.10214467f, -0.08663213f, 
    -0.04388186f, 0.17817618f, 0.08481004f, 0.25441059f, 0.16595194f, 0.16250037f, -0.20330952f, 0.16155100f, 
    -0.02061309f, 0.20752034f, 0.01366757f, -0.16547702f, -0.06645512f, 0.20246692f, -0.07435813f, 0.22523557f, 
    0.02812644f, -0.07799613f, -0.19039772f, -0.11838010f, 0.10061046f, -0.02161033f, -0.03316167f, 0.03451998f, 
    0.06800859f, 0.11598171f, -0.03468894f, 0.29706225f, 0.00500126f, 0.13155790f, -0.02312332f, 0.13971537f, 
    0.28877598f, 0.03470697f, -0.09774579f, 0.30226558f, -0.01099679f, 0.12302615f, -0.21941952f, 0.20200372f, 
    0.23164816f, 0.17482391f, 0.08088008f, 0.08643517f, 0.02308878f, -0.06266535f, -0.03139035f, -0.02790708f, 
    -0.07643400f, 0.08702224f, -0.01334219f, -0.07807098f, -0.35300377f, -0.16485822f, 0.05524045f, -0.04115858f, 
    -0.00902279f, -0.35016549f, -0.08454201f, -0.25639236f, -0.14303090f, -0.22617947f, -0.32879749f, -0.11875513f, 
    0.06923966f, 0.01172933f, -0.01438863f, 0.10075811f, 0.08112440f, -0.03779245f, -0.35229018f, -0.45169839f, 
    -0.20696025f, -0.03959973f, 0.14013346f, 0.15666926f, 0.09547691f, 0.19051294f, -0.13111980f, -0.00203693f, 
    0.17696160f, 0.12081479f, 0.02626347f, 0.19969469f, -0.01702140f, 0.22921327f, 0.13053612f, 0.08427867f, 
    0.17697844f, -0.40019816f, -0.02585177f, 0.02139697f, -0.00686931f, 0.02082971f, 0.02409885f, 0.25661504f, 
    0.05233686f, 0.06826601f, -0.30822739f, 0.18170971f, 0.14090198f, -0.06313862f, 0.18801574f, 0.19899273f, 
    0.12574852f, 0.08611289f, 0.35721299f, 0.41364643f, 0.02126614f, 0.12735064f, 0.07617100f, 0.03479891f, 
    -0.03680943f, 0.07368477f, 0.06801444f, 0.25154385f, 0.03367464f, 0.19351131f, -0.03190749f, 0.00172601f, 
    0.06607411f, 0.05480343f, 0.16825478f, 0.25481212f, -0.07867511f, -0.14922269f, 0.16501234f, 0.30748585f, 
    -0.02474665f, 0.19901493f, 0.22107741f, 0.12870747f, -0.05823676f, 0.17435703f, 0.20223634f, -0.10619400f, 
    -0.01822912f, -0.05503643f, -0.06593387f, -0.04750068f, -0.26152912f, -0.01006767f, -0.34364027f, -0.26934204f, 
    0.26607162f, -0.21038638f, -0.11248019f, -0.30463290f, -0.36665666f, -0.20803221f, 0.00705385f, -0.49551579f, 
    0.15678777f, -0.10142138f, -0.16367683f, 0.35313931f, 0.27257007f, -0.36882767f, 0.02805029f, 0.00636519f, 
    -0.03984924f, -0.04729531f, 0.02561850f, -0.03664774f, 0.03283106f, 0.01900174f, 0.01834885f, -0.04207477f, 
    -0.01300980f, -0.01854606f, 0.02064058f, 0.05042181f, -0.01376904f, 0.00476132f, -0.00956891f, 0.03194947f, 
    -0.03934835f, -0.02455870f, -0.00351752f, -0.00899157f, -0.04949825f, -0.01927501f, 0.03718713f, -0.02110359f, 
    -0.05712413f, 0.04647973f, 0.04959902f, 0.02298916f, -0.01944300f, -0.00086429f, -0.00015496f, -0.02572492f, 
    -0.02678714f, 0.04209718f, -0.03073927f, 0.03883981f, -0.04001224f, 0.02230707f, 0.01582904f, 0.04421530f, 
    0.02611337f, 0.01243638f, 0.02524797f, 0.03615386f, -0.06221291f, 0.03870751f, -0.05172051f, -0.03820788f, 
    -0.01364614f, 0.04140810f, 0.03574525f, -0.05248093f, -0.02940338f, -0.04139028f, -0.02707586f, 0.02908252f, 
    0.00531179f, -0.06092090f, -0.00930375f, -0.01052371f, -0.01241911f, 0.00486397f, -0.03049616f, 0.00692330f, 
    0.00075195f, 0.01825244f, -0.02912155f, 0.03132683f, -0.00584044f, 0.01599259f, 0.01103577f, -0.02901804f, 
    0.00693447f, 0.04695854f, 0.03989057f, 0.04375188f, 0.00161035f, -0.04897181f, 0.03169890f, 0.02708833f, 
    -0.04794596f, -0.03634247f, -0.05198667f, -0.01808375f, -0.03089637f, -0.04004524f, -0.01660725f, -0.00878980f, 
    -0.03592447f, 0.00806706f, -0.00389027f, -0.00766456f, -0.04971135f, -0.01573529f, -0.00025769f, -0.06036863f, 
    0.04319232f, 0.00644699f, 0.00743261f, 0.02071313f, -0.00655399f, -0.02243790f, 0.03422678f, 0.01582529f, 
    -0.05878146f, -0.00730359f, 0.06289767f, -0.04649828f, -0.05115339f, -0.05407168f, 0.02134802f, 0.04650228f, 
    0.00210887f, -0.04265339f, 0.04131339f, 0.02258874f, -0.00275776f, -0.05663516f, 0.00259428f, 0.04371747f, 
    0.02649075f, -0.06604711f, 0.00438441f, -0.06061223f, -0.00777222f, 0.00129173f, -0.04971777f, 0.03930052f, 
    -0.03048177f, 0.02763059f, -0.05577828f, -0.04428364f, 0.05131382f, -0.03003656f, -0.05012612f, -0.02806803f, 
    -0.01269708f, 0.04687632f, 0.03002478f, 0.04280723f, 0.01719848f, -0.04531059f, -0.00126109f, 0.03032303f, 
    -0.02942198f, 0.03971970f, 0.00460221f, -0.05718087f, -0.06694149f, -0.05908678f, 0.00290080f, -0.06996626f, 
    -0.01603733f, -0.04727748f, 0.00317390f, 0.00433141f, -0.03237988f, 0.00532895f, -0.04284318f, 0.03157363f, 
    0.02711557f, -0.06199605f, 0.00652034f, 0.02183788f, -0.00239786f, 0.02745202f, -0.04724785f, -0.05185814f, 
    0.00383732f, -0.01341869f, 0.03574221f, -0.03551372f, 0.02788676f, 0.01539290f, -0.05805274f, -0.01635494f, 
    0.02639162f, -0.03078949f, -0.06333892f, -0.04994696f, -0.04723353f, 0.01928925f, -0.05479111f, 0.00129186f, 
    -0.02123773f, 0.01209172f, -0.06766703f, 0.02057388f, 0.03306291f, -0.03639075f, 0.04539758f, -0.03362519f, 
    0.00338180f, -0.02474413f, -0.03194843f, -0.03656723f, 0.02333800f, -0.05654127f, -0.03841373f, -0.02365849f, 
    -0.01308731f, -0.03593501f, 0.04926016f, 0.01350983f, 0.04711939f, 0.00320213f, -0.03305621f, -0.02726221f, 
    0.00014320f, -0.01424919f, -0.05669132f, -0.05341953f, -0.05862775f, -0.02008937f, -0.00013348f, 0.04244051f, 
    -0.00493567f, -0.02264994f, 0.00413860f, 0.00151037f, -0.02475102f, -0.02109459f, -0.06700372f, 0.01405549f, 
    -0.01079251f, -0.04712643f, -0.05864593f, 0.03226957f, -0.01651035f, 0.00435084f, 0.00431603f, 0.01642386f, 
    -0.05455687f, -0.01618130f, -0.01971278f, 0.03339553f, -0.05895399f, -0.06682996f, -0.01638990f, -0.00794148f, 
    0.02411833f, 0.00181283f, -0.01417430f, -0.02049651f, -0.05600239f, 0.00578927f, 0.00354094f, -0.00943531f, 
    0.04953595f, 0.03863303f, -0.01458231f, 0.02620153f, 0.02173396f, -0.01633359f, -0.03135819f, -0.06217019f, 
    -0.04878278f, 0.00833368f, 0.02634401f, -0.00351965f, -0.03716419f, -0.01212096f, -0.05460539f, 0.01874449f, 
    -0.00602029f, -0.04715478f, -0.03744409f, 0.04551890f, 0.02989802f, 0.00614528f, 0.03677344f, 0.05236703f, 
    -0.00642885f, -0.02300388f, -0.04492795f, -0.04457376f, -0.03050187f, 0.00686178f, -0.05017188f, -0.04706396f, 
    0.04998478f, 0.03978647f, -0.05803132f, 0.04397246f, 0.04580520f, -0.00660547f, -0.01672191f, 0.00984387f, 
    -0.04064938f, -0.05293624f, -0.05144520f, -0.03476248f, -0.05393215f, -0.02112126f, -0.03664649f, -0.02799765f, 
    0.02282088f, 0.01245279f, 0.02857672f, -0.00224726f, 0.03136259f, -0.06326175f, -0.05006859f, 0.05267642f, 
    0.00811460f, -0.04810665f, -0.00458011f, -0.00151693f, -0.05691032f, -0.02787906f, -0.00346645f, -0.03704286f, 
    0.02196786f, -0.01212710f, -0.06463078f, 0.03652849f, 0.04867541f, -0.02336750f, 0.04252653f, -0.06429855f, 
    -0.00824424f, -0.06364395f, -0.00725975f, 0.00000723f, 0.04435601f, -0.04209639f, 0.04253933f, 0.04553791f, 
    -0.05794407f, -0.02592197f, -0.02856636f, 0.01121104f, -0.00022838f, -0.04425062f, 0.00604743f, -0.05607548f, 
    0.04804716f, -0.05158963f, -0.04312817f, 0.01267434f, -0.04261510f, 0.02501437f, 0.01885854f, 0.03779528f, 
    0.00448229f, -0.04513950f, 0.01821567f, 0.04558127f, -0.03109463f, 0.01246574f, -0.03434211f, -0.00901432f, 
    -0.05552629f, -0.03150488f, -0.00695042f, 0.02868460f, 0.04601594f, 0.00159502f, -0.05433946f, -0.02702206f, 
    -0.01583812f, 0.02352387f, -0.02278634f, -0.03969612f, 0.03324395f, 0.02604998f, -0.06484412f, 0.02876605f, 
    0.00117053f, -0.06329063f, -0.04944723f, -0.05419746f, 0.04535079f, -0.04406208f, 0.04431153f, -0.06168893f, 
    -0.00423359f, 0.04649694f, -0.02045861f, -0.00828348f, 0.03275283f, 0.01334666f, -0.03945174f, -0.00401729f, 
    -0.06190232f, -0.01699296f, -0.03376755f, -0.01341546f, -0.04059818f, -0.02559981f, -0.01704717f, -0.01756822f, 
    -0.00180152f, 0.00287373f, -0.04553508f, 0.02441006f, -0.04036092f, 0.01660048f, -0.01275172f, -0.01851542f, 
    0.04896352f, 0.02665742f, -0.03883468f, 0.01867082f, -0.05466590f, -0.00261924f, 0.04564749f, 0.05023392f, 
    0.04902004f, -0.04964612f, 0.00295264f, 0.04570467f, -0.05656229f, 0.02180174f, 0.04755743f, 0.02446073f, 
    -0.00723642f, 0.02145089f, 0.01599963f, -0.01908677f, 0.04240977f, -0.00815086f, 0.01766261f, -0.06424616f, 
    0.03682929f, -0.04581918f, -0.03915666f, -0.01897645f, -0.01564941f, -0.01273710f, 0.02800220f, 0.03973536f, 
    0.02861298f, -0.00123849f, -0.00995716f, 0.01453258f, -0.01136795f, -0.05487292f, 0.04522560f, -0.00122468f, 
    -0.01069869f, 0.00454642f, 0.03948669f, -0.06295063f, -0.04548056f, 0.02975177f, 0.01441216f, -0.04045381f, 
    -0.01927918f, -0.02658618f, 0.02676339f, 0.03092065f, -0.00514633f, 0.04168232f, -0.03350659f, -0.05869355f, 
    0.03397445f, -0.01704989f, 0.03062078f, -0.05399244f, -0.03056507f, 0.02556197f, 0.03699302f, -0.04244998f, 
    -0.02919818f, -0.02509319f, 0.04575850f, -0.00964631f, -0.04588094f, -0.05070432f, 0.02841730f, 0.00396445f, 
    -0.00794833f, 0.04888827f, 0.04109510f, -0.04396777f, -0.03081663f, 0.01862036f, 0.00463084f, -0.02174077f, 
    0.00024723f, -0.05557799f, -0.00818624f, -0.03932339f, 0.03501584f, 0.03305364f, -0.06403779f, 0.01082417f, 
    0.04731733f, -0.04595179f, 0.04009596f, -0.01093833f, -0.01725266f, 0.01154016f, -0.05473901f, 0.01627117f, 
    0.01190639f, 0.01343432f, -0.03249599f, -0.00178939f, 0.01621748f, -0.03464808f, 0.04175679f, -0.00192664f, 
    -0.04239173f, 0.04343747f, -0.05788011f, 0.05166508f, -0.05736842f, -0.01251189f, 0.02025845f, 0.00095245f, 
    0.01575018f, 0.00849707f, -0.02503979f, -0.00103662f, -0.02334038f, -0.01059933f, -0.05067384f, -0.03995021f, 
    -0.06181625f, -0.03076875f, -0.04504635f, 0.03423714f, -0.00627561f, -0.00088213f, 0.02873152f, -0.02640239f, 
    -0.05566756f, -0.03808247f, 0.02541143f, -0.04440861f, 0.02432469f, -0.06013936f, -0.05246275f, -0.04074774f, 
    -0.03159018f, 0.03587791f, 0.00742924f, -0.04091018f, 0.02989376f, -0.00609749f, -0.02618553f, -0.05976272f, 
    0.03448545f, 0.02267081f, 0.05100036f, -0.00994737f, -0.04991997f, 0.01177179f, -0.04697782f, -0.01037574f, 
    0.03178392f, -0.05469552f, -0.01573598f, 0.02881636f, -0.05947891f, 0.03834650f, -0.00009662f, 0.04357979f, 
    -0.01998885f, 0.03205886f, 0.00893751f, 0.03946766f, -0.02232763f, -0.01519491f, -0.04422396f, -0.04897122f, 
    -0.05163275f, 0.04539976f, -0.05773831f, -0.04763379f, 0.00678990f, -0.03884072f, -0.03899273f, -0.04536441f, 
    -0.30413935f, 0.01114578f, 0.23009801f, 0.11298590f, 0.05696668f, -0.10913920f, -0.09460481f, 0.00575092f, 
    0.04155704f, 0.09822180f, 0.24418488f, 0.45462874f, -0.01498890f, -0.03324674f, 0.08486109f, 0.14537530f, 
    -0.34250277f, -0.08097172f, -0.34485769f, -0.05119385f, -0.32597023f, 0.21840888f, 0.05484065f, 0.03872585f, 
    -0.22094703f, 0.03310441f, -0.17571643f, 0.03314167f, 0.18502937f, 0.37059399f, -0.00243965f, -0.04904077f, 
    -0.00008095f, 0.14160712f, -0.31031093f, -0.21981263f, 0.20674646f, 0.17313935f, 0.16197841f, -0.25527990f, 
    -0.24183588f, -0.25316614f, 0.18832941f, 0.14124148f, 0.15549366f, 0.47477156f, -0.03576193f, 0.19774207f, 
    0.07660464f, -0.19700658f, -0.07975083f, 0.12710275f, 0.01828984f, 0.15918826f, 0.12512042f, -0.07898391f, 
    0.07250769f, -0.11857514f, 0.05550294f, -0.05813234f, 0.07301404f, -0.08738545f, -0.15501848f, 0.58492434f, 
    -0.26703376f, 0.21311881f, 0.22225533f, 0.05307898f, -0.04634506f, 0.00821566f, -0.06182044f, -0.02124776f, 
    0.05815036f, 0.13587905f, -0.02336394f, -0.19281860f, 0.02115626f, -0.19919555f, -0.09927760f, -0.01512612f, 
    -0.08640439f, 0.41032797f, -0.46871403f, 0.13739763f, -0.33859399f, 0.14582407f, -0.24582548f, 0.16964269f, 
    0.14967909f, -0.12398716f, 0.29304272f, 0.19180556f, 0.36799794f, 0.04335803f, 0.14851148f, 0.09210271f, 
    -0.10599697f, -0.16312845f, -0.20925145f, 0.13602985f, 0.06220929f, 0.07997727f, -0.02669414f, -0.06861478f, 
    -0.03141256f, 0.10154416f, -0.00186811f, 0.08222651f, 0.10800642f, 0.00276229f, 0.15893900f, 0.16161434f, 
    0.04501568f, 0.14896303f, -0.32847714f, -0.11653423f, -0.02553151f, -0.05115225f, -0.10108101f, -0.06155660f, 
    0.23458980f, -0.12537247f, -0.02976200f, -0.06495448f, 0.03649360f, -0.03755759f, -0.24277414f, -0.02634414f, 
    0.05406251f, -0.10514987f, -0.04201542f, -0.04448327f, 0.31725523f, 0.00626384f, -0.16024999f, 0.14787838f, 
    -0.05238844f, 0.22982837f, -0.02107413f, 0.04237173f, 0.09754314f, 0.18036641f, -0.11329289f, -0.04477112f, 
    0.21914685f, -0.12895198f, 0.07357867f, 0.10963523f, 0.16096716f, 0.07080308f, 0.12096617f, -0.03957293f, 
    -0.01094014f, -0.10062494f, -0.10532369f, -0.07199883f, 0.05875222f, 0.08605248f, 0.07625169f, -0.20795169f, 
    0.03902960f, -0.04089691f, 0.01386558f, -0.15472591f, 0.16814592f, -0.22698456f, -0.08633813f, -0.02497004f, 
    0.26606598f, -0.20322832f, -0.15019313f, 0.08110283f, 0.02575621f, 0.07145900f, 0.09731595f, 0.01528378f, 
    -0.10749084f, -0.25786930f, -0.27475438f, -0.07301619f, -0.10925885f, 0.14077622f, 0.04197575f, 0.11530516f, 
    0.03629238f, -0.20714505f, -0.05273094f, -0.07747187f, 0.02170511f, 0.39786679f, 0.01527427f, 0.53042740f, 
    0.02731630f, 0.01482640f, -0.00706854f, -0.07048105f, -0.18954423f, -0.30578128f, 0.34806103f, 0.01118319f, 
    0.31955644f, 0.06544256f, -0.08022548f, 0.04156943f, 0.03713509f, -0.09332354f, -0.05120367f, 0.25178593f, 
    0.13098362f, 0.20065564f, -0.21447046f, -0.14372198f, -0.06406305f, 0.01954894f, 0.15860283f, 0.01775791f, 
    -0.23476830f, 0.05800589f, -0.12341708f, 0.28943962f, -0.03346541f, 0.23984630f, -0.11193725f, 0.01529902f, 
    -0.03043753f, 0.08467946f, 0.12636982f, -0.08916014f, -0.04549969f, -0.09749731f, -0.04734241f, -0.17505406f, 
    0.14388961f, 0.02725862f, -0.17457947f, -0.06171625f, -0.26249456f, 0.19969687f, -0.00142610f, -0.20378685f, 
    -0.02103698f, 0.15867078f, -0.18068692f, -0.11101986f, -0.13323604f, -0.38336524f, -0.03073807f, -0.10765136f, 
    0.07180828f, -0.05621719f, 0.20552939f, 0.05093516f, -0.02646007f, 0.03651799f, 0.06820573f, -0.14068381f, 
    0.05805608f, 0.01440425f, 0.09403785f, 0.05317959f, 0.02238658f, -0.08561572f, -0.11530991f, -0.12345745f, 
    0.08403134f, 0.01130858f, -0.01285237f, 0.30132818f, 0.06656653f, 0.00414277f, -0.31594878f, -0.04127020f, 
    0.29254407f, 0.11232883f, -0.03616872f, -0.13287796f, 0.10666373f, 0.27532163f, 0.00430943f, 0.18294638f, 
    -0.07657999f, 0.08686300f, 0.16030522f, -0.05679793f, 0.00402427f, -0.06502949f, 0.00617975f, 0.06111060f, 
    0.19348778f, -0.13140975f, -0.16084285f, 0.02138514f, -0.05154982f, -0.24479240f, 0.06877796f, -0.01200415f, 
    -0.33226776f, -0.05491426f, -0.21458133f, 0.00861548f, 0.14220452f, -0.00737391f, 0.20090428f, 0.10567925f, 
    0.06910202f, -0.23146453f, -0.16600271f, -0.11354889f, 0.40538120f, -0.00795322f, -0.23119833f, 0.00083598f, 
    0.22418340f, 0.21286385f, 0.26016739f, -0.19829564f, 0.03611409f, 0.51495409f, 0.02968072f, 0.03455907f, 
    -0.13159208f, -0.04287956f, 0.05592167f, -0.13019073f, 0.04054657f, -0.09827624f, -0.30027395f, 0.05025095f, 
    -0.09693540f, -0.11673575f, 0.02644065f, -0.02261012f, -0.04519339f, -0.01185476f, -0.17848748f, -0.18264054f, 
    0.01563411f, 0.12826605f, -0.04261842f, -0.00473845f, 0.16020158f, -0.04883873f, 0.04483525f, -0.26438126f, 
    0.24273807f, -0.02556638f, -0.13933028f, -0.21999414f, -0.06590376f, -0.20528056f, 0.00652928f, 0.01387215f, 
    -0.36460072f, 0.08287951f, 0.10899513f, 0.34712940f, 0.06053961f, 0.05101097f, 0.15317322f, 0.18520069f, 
    0.01763785f, 0.19085282f, -0.42344069f, 0.11198419f, 0.11036291f, -0.13298646f, 0.09133814f, -0.08242384f, 
    -0.05038057f, -0.09532764f, 0.02286633f, 0.41295519f, -0.14091936f, 0.51017219f, -0.31831494f, -0.33399665f, 
    0.26750454f, 0.06484996f, -0.63436073f, 0.12042318f, 0.45244491f, -0.38141960f, -0.02804820f, -0.17963575f, 
    -0.00671245f, 0.19234802f, 0.29642814f, -0.08909400f, -0.19994511f, 0.28689501f, 0.06956352f, 0.01327920f, 
    0.35038814f, -0.01544654f, -0.14738950f, -0.32003343f, -0.06979609f, 0.17328021f, 0.10278457f, -0.00687514f, 
    -0.15725048f, -0.21055420f, 0.06335221f, 0.05467179f, -0.00997950f, 0.18274714f, -0.11100385f, 0.27402282f, 
    -0.18775290f, 0.05720168f, 0.04093780f, 0.12096850f, 0.00355781f, 0.18223588f, -0.45289046f, -0.15488578f, 
    -0.12337577f, -0.05700450f, 0.15693787f, -0.02560043f, 0.05884666f, -0.13270696f, -0.11697097f, -0.16759045f, 
    0.42905968f, 0.27331004f, -0.16753173f, 0.04937189f, -0.15682314f, -0.09945257f, 0.12770745f, -0.07933836f, 
    -0.18834108f, -0.05305675f, 0.01020181f, 0.14726146f, 0.21832831f, 0.05290380f, 0.07014065f, 0.24398270f, 
    0.14021835f, -0.08037701f, 0.20872748f, 0.06697636f, -0.12559655f, 0.04431192f, -0.13853788f, 0.22143285f, 
    0.11658172f, 0.08761932f, -0.68572193f, -0.04904602f, 0.38715059f, -0.31855205f, 0.61125338f, -0.28809571f, 
    0.00191043f, 0.05988329f, 0.02669555f, 0.15078415f, -0.14733277f, 0.22548279f, 0.09485905f, -0.11940919f, 
    -0.10205166f, -0.11424329f, 0.13760370f, -0.03426832f, 0.11231454f, -0.62126034f, -0.65351045f, 0.07638371f, 
    0.04619640f, -0.17972562f, -0.06398671f, -0.19955617f, -0.11962716f, -0.00721929f, 0.10394522f, 0.46104875f, 
    -0.06798132f, -0.11205745f, -0.11614891f, 0.03121622f, 0.06158370f, 0.05938457f, -0.57937825f, -0.15749107f, 
    0.25836030f, -0.16395898f, -0.06867222f, -0.02963409f, 0.07563099f, 0.02030163f, -0.14781882f, -0.35443920f, 
    -0.31174842f, -0.06066431f, 0.03340049f, 0.12948942f, 0.14797722f, 0.12800494f, 0.03369141f, 0.11785163f, 
    0.11299372f, 0.20120388f, 0.12027334f, -0.06765371f, -0.13902058f, -0.08006611f, 0.22808391f, 0.22019760f, 
    0.17368057f, -0.40996537f, 0.19216514f, 0.22702806f, 0.07900908f, -0.10942020f, 0.28282547f, 0.09987346f, 
    0.04591495f, 0.16857155f, -0.08354314f, 0.05917283f, -0.02929589f, -0.20619172f, 0.07611991f, 0.20615819f, 
    -0.11821228f, 0.26776832f, -0.13738284f, -0.32939050f, 0.11247541f, 0.11450543f, -0.11161456f, -0.22946930f, 
    -0.18964498f, 0.03559796f, 0.12249495f, 0.06847907f, 0.17081720f, -0.05150677f, 0.08492738f, 0.03330063f, 
    -0.15220536f, -0.18833616f, -0.10808846f, 0.01330446f, 0.01305573f, 0.22311436f, -0.54782134f, 0.26822695f, 
    0.06776886f, 0.07825665f, 0.28931347f, -0.09515265f, 0.07133646f, 0.21829918f, 0.31749225f, -0.12413452f, 
    -0.14517705f, 0.07172655f, -0.08646554f, -0.14247984f, 0.08077131f, 0.06141935f, 0.08875537f, -0.25585228f, 
    0.59234083f, -0.06973230f, -0.15193997f, -0.15895227f, -0.05348319f, 0.00754112f, 0.07916327f, 0.06530488f, 
    -0.07585628f, -0.09839373f, -0.13825005f, -0.05075843f, -0.20641944f, -0.08251070f, -0.07975403f, -0.13723445f, 
    0.08513027f, 0.09391825f, 0.18076538f, 0.00732815f, 0.20248093f, -0.16257086f, 0.39356196f, 0.15076783f, 
    -0.12859441f, 0.00912988f, 0.41307011f, -0.25286928f, -0.26584285f, -0.06816405f, 0.14607914f, 0.06817520f, 
    -0.08328941f, 0.11330611f, 0.08506094f, -0.20117851f, 0.26616964f, 0.13372560f, -0.04501025f, 0.06270326f, 
    0.06140326f, 0.22500885f, -0.04429312f, 0.10981818f, 0.05259310f, 0.01738581f, 0.02764622f, 0.07821003f, 
    -0.20122020f, -0.03770637f, 0.13121167f, 0.17821522f, 0.23879112f, 0.06532379f, 0.11511058f, 0.01931692f, 
    0.05187954f, -0.12573187f, -0.23530398f, 0.27534702f, 0.04841083f, 0.06956933f, -0.64446706f, 0.59071726f, 
    0.01724098f, -0.01304307f, -0.09728190f, -0.35238242f, -0.01171731f, 0.08501406f, -0.06172984f, 0.03583971f, 
    0.24841082f, 0.15074177f, 0.10277801f, 0.12935330f, -0.19671199f, 0.13015471f, -0.09130952f, -0.01314926f, 
    0.13943090f, 0.26294369f, 0.17063947f, -0.02409763f, -0.05075412f, 0.10059430f, -0.17510784f, -0.03856505f, 
    -0.11460631f, -0.93736440f, 0.09063759f, -0.10421793f, 0.21331559f, 0.16332333f, -0.28783992f, 0.15690045f, 
    0.09005693f, -0.30360061f, 0.34861338f, 0.26693001f, 0.29059899f, -0.10822919f, 0.10027456f, 0.00450041f, 
    0.06280093f, 0.04919787f, -0.00720024f, 0.13249512f, -0.06213428f, -0.13989002f, 0.28689575f, -0.06813384f, 
    0.07390166f, -0.03316680f, 0.00874496f, 0.07104971f, -0.33040237f, 0.02789859f, 0.41767064f, -0.10874959f, 
    -0.02024527f, -0.12185655f, -0.04505784f, -0.14522587f, 0.34420300f, -0.47281274f, -0.53438002f, -0.06453475f, 
    -0.05681937f, 0.04721002f, 0.08236171f, 0.01944906f, 0.03183758f, 0.23921151f, -0.37094036f, -0.15795571f, 
    0.00026270f, 0.18212356f, 0.14493968f, 0.12446801f, 0.09433264f, 0.09101955f, -0.09490474f, -0.47953159f, 
    -0.36115822f, 0.19797613f, -0.11024376f, -0.02393332f, 0.13449043f, 0.14847977f, 0.14972824f, -0.13293591f, 
    -0.15183178f, -0.18056682f, -0.03996480f, 0.03499779f, 0.12412223f, -0.06448402f, 0.14869234f, -0.13253467f, 
    -0.09819984f, -0.59810305f, -0.27699026f, 0.20492186f, 0.05165793f, 0.15547797f, 0.12143510f, 0.11203032f, 
    -0.10115018f, 0.10830848f, -0.64917344f, 0.01517991f, -0.00098494f, 0.07796223f, 0.09311711f, 0.01423520f, 
    -0.25867182f, -0.12685446f, -0.25369218f, -0.08448350f, 0.01202234f, -0.18290251f, 0.04939062f, 0.00018591f, 
    -0.26781696f, 0.06223782f, 0.04404036f, -0.11889070f, 0.02552760f, -0.15407981f, -0.06382316f, -0.05629159f, 
    -0.25591984f, -0.11202013f, -0.23935504f, -0.11554976f, 0.00246614f, -0.09266587f, 0.55120093f, 0.26424348f, 
    -0.19032267f, 0.17852709f, 0.08771313f, -0.00010432f, 0.10942338f, 0.08615039f, 0.28409022f, 0.08685395f, 
    0.21800269f, -0.26342264f, 0.17691605f, -0.04289824f, 0.02776681f, 0.04683347f, -0.01421343f, 0.10420320f, 
    0.25233719f, 0.21963108f, -0.22624882f, -0.13536271f, -0.14883360f, -0.02293828f, 0.08996463f, 0.13437885f, 
    0.12853752f, -0.20340256f, -0.16752487f, -0.05669294f, 0.10803819f, 0.11410992f, 0.07465090f, 0.06131862f, 
    0.11221634f, 0.27469677f, 0.13114437f, 0.06717828f, -0.13357247f, 0.12373567f, -0.14853466f, 0.07775887f, 
    0.04363964f, 0.05362525f, -0.35287502f, -0.08178813f, -0.37329999f, -0.21407887f, 0.01708161f, 0.14380796f, 
    0.09392837f, -0.32247362f, 0.03579215f, 0.01671600f, -0.36757582f, -0.03634788f, -0.03937883f, -0.04414551f, 
    -0.11586379f, -0.07298526f, 0.18085739f, 0.17747216f, -0.14257194f, 0.34806392f, -0.06819136f, -0.11465333f, 
    0.22612162f, -0.14990960f, 0.04309539f, 0.25525078f, 0.10482804f, -0.59814543f, -0.37450421f, -0.89396667f, 
    -0.03249131f, 0.03932369f, 0.09172032f, 0.01051670f, 0.20109881f, -0.27668211f, 0.07813197f, -0.09531663f, 
    0.14651968f, 0.06062233f, -0.28262177f, -0.02298936f, -0.02731954f, 0.09728562f, -0.09704258f, -0.14271489f, 
    0.50509393f, 0.26821050f, -0.03144931f, -0.01394814f, 0.05495107f, 0.00755271f, -0.25635180f, -0.01674746f, 
    -0.07785220f, -0.20358488f, 0.04959325f, -0.07462687f, -0.05381452f, -0.12158331f, 0.10768811f, 0.15893555f, 
    0.01122517f, 0.20926587f, -0.27688041f, 0.05526717f, -0.15484281f, -0.02742092f, -0.07966861f, 0.05888392f, 
    0.14354040f, 0.03985329f, 0.15355270f, -0.12447488f, -0.79458570f, 0.15330029f, -0.04410487f, 0.14296800f, 
    0.04086861f, 0.01607231f, -0.06891158f, -0.43875313f, 0.08611582f, -0.21357895f, -0.16363101f, -0.11420842f, 
    -0.14304890f, 0.12212550f, 0.20930070f, 0.22080866f, 0.01877943f, 0.10265681f, 0.13775858f, -0.19880772f, 
    -0.13624108f, -0.61919802f, 0.24108846f, 0.14190052f, 0.10258494f, -0.07448459f, 0.08870715f, 0.23084989f, 
    -0.22006914f, 0.09354240f, -0.06875453f, 0.12553735f, 0.03930239f, 0.08007329f, -0.11112954f, -0.19275342f, 
    0.42849389f, -0.21214762f, 0.14825679f, -0.09994323f, -0.05638077f, 0.07422907f, 0.11070472f, -0.10009047f, 
    0.06109945f, 0.36815858f, -0.10800599f, -0.05222826f, -0.07532654f, 0.02545430f, 0.05286383f, 0.11682694f, 
    -0.09132882f, 0.27065974f, 0.13633309f, -0.39758295f, -0.24784033f, -0.11933315f, 0.02037949f, 0.15541695f, 
    0.27208191f, -0.67556322f, -0.46931034f, -0.00029815f, -0.29454017f, 0.12065777f, -0.39506114f, 0.24430104f, 
    0.07583637f, -0.12212113f, 0.71390909f, -0.20900734f, -0.58536637f, -0.02808963f, 0.07195269f, 0.15738632f, 
    0.05544474f, -0.10651875f, -0.05481441f, -0.31230944f, -0.31335628f, -0.35600406f, 0.08087961f, -0.05331467f, 
    0.01428586f, 0.06478895f, 0.08941647f, 0.01039841f, -0.14328398f, 0.02469798f, -0.02870748f, -0.13537580f, 
    -0.01275499f, -0.05832115f, 0.11986344f, 0.06851140f, 0.38910472f, -0.03387617f, -0.08558692f, -0.03953130f, 
    0.15170951f, 0.02645067f, 0.02772869f, 0.12013243f, 0.03065312f, 0.04400081f, -0.49939924f, -0.18744569f, 
    -0.22472703f, -0.02795235f, 0.05153180f, -0.04827624f, 0.13316923f, -0.02476722f, 0.26571789f, -0.15073881f, 
    -0.66098553f, -0.44870222f, -0.05590872f, -0.11982872f, -0.04198695f, -0.03940708f, 0.23408748f, 0.22441860f, 
    0.22056291f, -0.42015967f, -0.33073458f, 0.06243495f, -0.15251952f, 0.00774849f, 0.00817236f, 0.01752537f, 
    -0.08393016f, -0.00323162f, -0.12141448f, 0.05431331f, 0.13898747f, -0.03941786f, 0.05224707f, 0.05208581f, 
    0.04367742f, 0.10822077f, -0.55247408f, -0.34533444f, -0.08611901f, -0.18442170f, -0.34751245f, -0.33851564f, 
    0.22440501f, -0.11015352f, 0.06268679f, 0.08816645f, -0.14432603f, 0.28725672f, -0.05832284f, 0.03557057f, 
    0.12253515f, 0.12517029f, -0.06589245f, 0.38777554f, 0.15937854f, 0.01591012f, 0.17624269f, -0.09649239f, 
    0.03118896f, -0.02909783f, 0.05124922f, 0.09553294f, 0.17761862f, -1.08314204f, 0.10007865f, -0.31930166f, 
    -0.08817703f, -0.12990573f, -0.13095087f, -0.06671648f, -0.00940441f, 0.16336654f, -0.77859288f, -0.14219385f, 
    -1.26899743f, 0.04332030f, 0.04040890f, 0.06981223f, 0.07774368f, 0.01459431f, 0.15019070f, 0.05068506f, 
    0.49802667f, 0.26022658f, 0.13755971f, -0.15726618f, 0.02727323f, 0.10245574f, 0.01018467f, -0.04350948f, 
    0.18635449f, -0.36937466f, -0.31516588f, 0.07703917f, 0.09046131f, 0.05625858f, 0.06757306f, 0.07053971f, 
    -0.29760388f, -0.08143930f, 0.03809055f, -0.14324129f, 0.03423075f, 0.14915831f, 0.20384991f, 0.16426085f, 
    -0.05470607f, -0.08159282f, 0.19030225f, 0.01438378f, -0.01468843f, 0.26358745f, -0.22127414f, -0.06367020f, 
    0.19006449f, -0.12989311f, 0.08324305f, 0.18826748f, -0.14568438f, -0.49088690f, 0.15816475f, 0.06808487f, 
    0.19774698f, 0.02934932f, 0.15966909f, -0.17509365f, -0.00483836f, -0.03456578f, 0.47312072f, 0.06657688f, 
    0.16103563f, -0.05181238f, 0.18259349f, 0.15783115f, -0.00070196f, 0.01304269f, -0.06797891f, -0.20599520f, 
    0.12416436f, -0.09748545f, -0.02064346f, 0.05443420f, -0.11535054f, 0.32376227f, 0.27359357f, 0.08837251f, 
    0.09581934f, 0.00853374f, -0.12234586f, -0.08742167f, 0.09239062f, -0.03926607f, 0.01533896f, 0.22225878f, 
    -0.23568173f, 0.23161437f, -0.20070441f, -0.13667357f, -0.21621647f, 0.10038376f, 0.15788622f, 0.16867915f, 
    -0.03388973f, -0.02352809f, 0.05228516f, 0.04613024f, 0.05068223f, 0.00577257f, -0.02440427f, -0.03908776f, 
    -0.02963512f, 0.00452613f, 0.01567867f, -0.04519102f, 0.01724333f, -0.04326962f, 0.00626376f, -0.04953942f, 
    0.03741572f, 0.01884902f, 0.05195492f, -0.04626127f, 0.00455763f, 0.04374260f, 0.02284994f, 0.05422387f, 
    -0.02108382f, -0.02950828f, 0.02162768f, -0.03994977f, -0.03048360f, -0.06461249f, -0.05605787f, 0.01138046f, 
    -0.05155103f, 0.01364350f, 0.01757789f, -0.02748661f, -0.02008052f, 0.03623971f, -0.02035133f, -0.03915795f, 
    -0.03698491f, -0.00137266f, -0.00317409f, 0.01523614f, 0.00261065f, -0.05709548f, 0.03990836f, 0.00194310f, 
    0.00522642f, 0.02700387f, -0.01821297f, -0.03962715f, 0.03107709f, -0.04476208f, 0.01735190f, 0.02271394f, 
    -0.05135559f, -0.05673787f, 0.04973617f, -0.03715387f, -0.04332775f, -0.05524785f, -0.01648280f, 0.03363092f, 
    0.01956524f, 0.03934682f, -0.03406478f, -0.01865650f, 0.03272462f, 0.03590020f, -0.00679132f, -0.01925615f, 
    -0.06073412f, -0.00305025f, 0.04807994f, 0.01081684f, -0.05167630f, 0.01896431f, 0.04757929f, -0.04140225f, 
    -0.01331215f, 0.03144332f, 0.04876164f, -0.01164961f, 0.00994976f, 0.04096474f, 0.03804201f, -0.03430967f, 
    -0.05382399f, -0.00503635f, -0.01162068f, 0.00515277f, 0.00945483f, -0.06525882f, -0.02036083f, -0.01787365f, 
    0.04819889f, -0.02905753f, -0.05479120f, -0.00139248f, -0.03606447f, 0.04040020f, -0.01714107f, 0.03044987f, 
    -0.06480625f, -0.04282198f, -0.02568723f, -0.02113170f, 0.02933542f, -0.03169284f, 0.02133671f, -0.00087527f, 
    0.00375824f, 0.05209102f, -0.06613383f, 0.02463822f, 0.02353149f, 0.04653639f, -0.05943953f, -0.06054385f, 
    -0.02898210f, -0.02346450f, -0.00249700f, -0.03633675f, -0.05522241f, -0.05623236f, 0.01798331f, -0.00222469f, 
    -0.05707682f, 0.03194035f, -0.01678408f, -0.06395198f, 0.00850966f, 0.00470130f, -0.04510209f, -0.06095532f, 
    -0.01877609f, -0.02476064f, -0.04195317f, 0.03536485f, -0.03476261f, -0.02986627f, -0.02252088f, -0.02742176f, 
    0.04481613f, -0.02722714f, -0.00520371f, 0.02338065f, -0.00308421f, 0.03936228f, 0.00489498f, 0.03474605f, 
    0.01722403f, 0.03712692f, 0.03739677f, -0.03141630f, 0.03451909f, 0.00535823f, -0.02346125f, 0.04857676f, 
    0.00853706f, 0.02288485f, -0.05144427f, 0.00758535f, -0.04691846f, 0.03189883f, -0.01461127f, 0.01200840f, 
    -0.01954935f, -0.03310961f, -0.03626350f, -0.01558938f, -0.00789415f, 0.04539910f, -0.02840452f, 0.00728432f, 
    0.03906389f, -0.06450447f, -0.05344906f, -0.01889404f, -0.01037287f, -0.04808787f, -0.02748859f, -0.01782055f, 
    -0.00197218f, 0.03570855f, 0.03200029f, 0.04524605f, 0.00233049f, -0.01003024f, -0.00749486f, 0.01214736f, 
    -0.06290444f, -0.06297794f, -0.03835046f, -0.02848477f, -0.05026164f, -0.05655369f, -0.02033307f, -0.02852251f, 
    -0.05894876f, -0.04264332f, 0.02372413f, 0.01688914f, 0.04157652f, 0.03766251f, -0.06387509f, 0.03906356f, 
    -0.05207388f, -0.06638814f, -0.02346941f, -0.05276507f, -0.02355290f, 0.00506038f, -0.00879174f, -0.01794365f, 
    0.02465344f, -0.01105201f, -0.00635028f, -0.04767885f, -0.04918022f, -0.03499883f, -0.01724700f, 0.01602958f, 
    -0.03769214f, -0.04366380f, 0.05181511f, 0.03692322f, 0.01271927f, -0.03014748f, 0.03958552f, -0.03404712f, 
    0.02887690f, 0.04728915f, 0.01290492f, -0.05780622f, -0.05808421f, 0.00376754f, -0.00360686f, -0.03595600f, 
    0.03806574f, 0.03231952f, -0.03285878f, 0.00560311f, -0.03442950f, 0.04287579f, 0.04123278f, -0.04621780f, 
    -0.03078957f, -0.00161857f, -0.06067010f, 0.05082873f, -0.05429203f, 0.04311329f, -0.04787081f, -0.04662242f, 
    0.00609976f, 0.03486390f, -0.04353676f, 0.00113726f, 0.03274846f, 0.00387761f, -0.02736446f, -0.04364951f, 
    0.02665720f, 0.03212880f, -0.01156073f, -0.01562675f, -0.00095511f, -0.05227064f, -0.01716232f, -0.06074244f, 
    0.00286360f, 0.01395524f, -0.02994931f, 0.02483588f, 0.01739560f, 0.03309463f, -0.02655281f, -0.02621691f, 
    -0.03738047f, -0.01400612f, -0.06119767f, 0.02943082f, 0.05354588f, 0.01453929f, -0.01869055f, 0.03746180f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09577632f, -0.02593669f, -0.00079937f, 0.15184404f, 0.01504260f, -0.16004983f, 0.04835608f, -0.13077535f, 
    0.03706891f, 0.20015128f, -0.12511620f, 0.18762584f, 0.10360520f, 0.13081157f, 0.35610461f, 0.29733539f, 
    0.23728453f, 0.04931564f, 0.40656248f, 0.01007802f, 0.10540927f, -0.03230003f, 0.18703605f, -0.10168129f, 
    0.39433607f, -0.02347361f, 0.03184430f, -0.06482247f, 0.07865038f, 0.05718303f, 0.22557558f, -0.04036593f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14948829f, -0.18355590f, 0.21037492f, -0.62864262f, 0.07177450f, 0.30212745f, 0.16302010f, -0.01389041f, 
    -0.17101046f, 0.10230042f, -0.21331321f, 0.09587865f, 0.09971428f, -0.09420501f, -0.54034221f, -0.25253081f, 
    -0.56813633f, -0.16300200f, -0.44409958f, 0.12197768f, 0.36470401f, 0.09501506f, 0.52806985f, 0.74589235f, 
    -0.05914611f, -0.05537590f, -0.11188965f, 0.01904553f, -0.18918529f, -0.17643736f, 0.29494590f, -0.12775989f, 
    0.51712364f, 0.25214201f, -0.18974732f, 0.01310603f, 0.15306227f, -0.79493028f, 0.02676546f, 0.36875737f, 
    -0.09339774f, 0.24284761f, -0.36285901f, -0.03819662f, 0.03738810f, 0.30839202f, 0.18372877f, 0.32000589f, 
    -0.42973936f, 0.27417931f, 0.07386141f, -0.13011672f, 0.08801864f, -0.17260446f, 0.47136530f, -0.07580348f, 
    0.24984773f, -0.05947357f, -0.15383883f, -0.16096769f, 0.22493464f, -0.56641757f, -0.02861462f, -0.05110996f, 
    0.26968071f, -0.44856766f, -0.32141370f, 0.23408592f, 0.15413894f, -0.49687582f, -0.08981356f, -0.29895267f, 
    0.01479874f, 0.25975868f, 0.27732456f, -0.40429068f, -0.07939518f, -0.25621593f, 0.64743751f, -0.61065584f, 
    0.22703531f, -0.13875028f, 0.12102351f, -0.06343396f, 0.02457473f, -0.07540511f, -0.51464909f, -0.28875461f, 
    0.27759522f, -0.06307290f, -0.10933158f, 0.16664565f, -0.57211262f, -0.73361844f, -0.14991720f, 0.10629482f, 
    0.26636660f, 0.20000689f, 0.04354829f, -0.70638967f, -0.15203160f, 0.19467452f, -0.15470545f, 0.32700258f, 
    -0.06762156f, 0.43415606f, 0.22086397f, -0.59083241f, -0.68618172f, 0.25278839f, 0.29076317f, 0.02945640f, 
    -0.03763512f, 0.31376868f, 0.11198463f, -0.07204427f, -0.00991401f, -0.04218699f, -0.82428187f, 0.01813696f, 
    -0.63709831f, -0.04902752f, -0.13555001f, 0.15245539f, 0.21363163f, -0.34024847f, -0.21610445f, 0.14194447f, 
    0.15350510f, -0.42971793f, -0.08179411f, 0.32652846f, -0.16082020f, 0.36178795f, 0.05917261f, 0.18173574f, 
    -0.01160304f, 0.13234042f, 0.05850803f, 0.03220195f, -0.00890637f, 0.37866661f, -0.28460750f, 0.02565960f, 
    -0.43947378f, 0.22728364f, -0.36555463f, 0.08639660f, -0.26987723f, 0.14075388f, 0.21380132f, -0.66991991f, 
    -0.21614909f, 0.06215637f, 0.11240742f, 0.35532904f, -0.06422491f, 0.47221988f, 0.11842415f, -0.08794972f, 
    -0.01301827f, -0.08002160f, 0.42943266f, 0.15292917f, -0.09019058f, -0.28596881f, 0.05596079f, -0.57489616f, 
    0.13708013f, -0.27699304f, -0.24440947f, 0.07578013f, 0.33829874f, -0.10136348f, -0.40883404f, -0.31189293f, 
    0.24267229f, 0.19712779f, 0.15114668f, -0.15494491f, -0.07692606f, 0.13758262f, 0.40281627f, 0.03734959f, 
    0.12858407f, -0.13819735f, -0.03115452f, 0.22334684f, 0.14623608f, 0.54168695f, -0.26466402f, 0.10900415f, 
    -0.70988643f, -0.06054552f, -0.05384267f, 0.13803597f, 0.02571654f, 0.05395195f, 0.15006860f, -0.64089870f, 
    -0.14683296f, -0.15395783f, 0.31440771f, 0.52938539f, -0.10110886f, -0.10305004f, -0.59480399f, -0.29099396f, 
    0.57064962f, -0.54212767f, -0.20385262f, 0.13986523f, -0.31792620f, 0.01498233f, -0.74289376f, -0.37129819f, 
    0.21418296f, -0.17197579f, 0.06025628f, -0.49282190f, -0.61956573f, -0.74664849f, 0.66922981f, 0.15586798f, 
    -0.07579675f, 0.36027637f, -0.22095652f, -0.05821990f, -0.03753505f, 0.34021771f, 0.10150629f, -0.03784470f, 
    -0.02654557f, 0.37197459f, 0.04390287f, 0.11905147f, 0.45739862f, -0.20872766f, -1.00955689f, 0.44210660f, 
    0.02646369f, 0.23958927f, -0.52383935f, 0.10602047f, -0.29295796f, 0.15599553f, -0.37242675f, -0.03867457f, 
    -0.30331573f, -0.00223531f, 0.01548016f, 0.06314672f, 0.30955732f, -0.11998756f, 0.16165942f, 0.14627211f, 
    0.06723000f, 0.18535888f, 0.57022166f, 0.10301144f, -0.00063355f, -0.97112864f, 0.13909560f, 0.19944522f, 
    0.16139251f, 0.19136794f, -0.29786095f, -0.08095351f, -0.42934203f, -0.43661749f, -0.19284047f, 0.84828722f, 
    -0.08433352f, -0.66404027f, 0.41699213f, -0.06626799f, -0.22883263f, -0.15935181f, -0.78778422f, -0.19701399f, 
    0.18011206f, -0.07297337f, -0.09266259f, -0.07122146f, -0.21103688f, 0.20405537f, -0.24028179f, -0.09073054f, 
    -0.60124159f, -0.08023640f, -0.28156558f, -0.18860266f, -0.17637777f, 0.12690230f, 0.01273170f, -0.63904291f, 
    -0.14656539f, 0.06544580f, 0.07131885f, 0.22947687f, 0.54394794f, 0.28723723f, 0.90694344f, -0.23736118f, 
    -0.07391039f, 0.35412329f, -0.00494473f, -0.07173332f, -0.36912042f, 0.08193661f, -0.19745661f, 0.08325911f, 
    -0.27854145f, 0.08891134f, 0.10557390f, 0.00324148f, -0.55148113f, 0.65986049f, 0.56240958f, -0.05283249f, 
    -0.49351886f, 0.15347677f, 0.16269033f, 0.62353230f, -0.04578969f, 0.36892107f, -0.08173686f, 0.47756967f, 
    -0.01729672f, -0.25792944f, -0.41791534f, 0.30525637f, -0.55147016f, -0.09601086f, -0.05123536f, -1.01846850f, 
    0.28861335f, -1.11196327f, -0.14107621f, 0.04505578f, 0.49589247f, 0.02422083f, -0.10933046f, -0.31497857f, 
    -0.00250000f, -0.09568419f, -0.00006263f, 0.12972030f, 0.56504691f, -0.10728975f, 0.04415500f, -0.02439195f, 
    -0.65136135f, 0.33034018f, -0.26775160f, 0.23711993f, 0.09103058f, -0.18254210f, 0.03359454f, -0.58438575f, 
    -0.09321244f, -1.03853643f, 0.41213754f, -0.35796750f, -0.16944425f, 0.19001319f, -0.25747147f, -0.00849221f, 
    0.18802212f, -0.51479948f, 0.19126771f, -0.07676005f, -0.34587246f, -0.02572830f, -0.62066972f, -0.19872646f, 
    0.17518853f, 0.12117340f, 0.07451624f, -0.24527149f, 0.70059562f, 0.01906249f, -0.72157693f, -0.03331662f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22147077f, -0.07204591f, 0.38280064f, -0.05693884f, -0.02011539f, 0.02412024f, 0.03223844f, -0.47368523f, 
    0.18602601f, 0.00253898f, -0.11556949f, -0.01443625f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
