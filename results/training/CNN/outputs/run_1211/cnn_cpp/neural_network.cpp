#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38588202f, 0.79957289f, 0.55999923f, -0.06805130f, 0.42631942f, -0.28202006f, -0.48036286f, 0.21014708f, 
    0.28798810f, 0.30267632f, 0.04612178f, -0.32406321f, 0.16889220f, 0.67977798f, -0.16908623f, 0.22343473f, 
    -0.13391040f, -0.05566734f, 0.23132557f, -0.40107235f, 0.09171802f, 0.21303220f, 0.12479392f, -0.25086313f, 
    -0.19203840f, 1.47454822f, 0.66131610f, 0.19827056f, 0.13075107f, -0.29631352f, 0.40887666f, 0.17732191f, 
    0.03525368f, -0.19806013f, 0.11723413f, -0.19300666f, 0.25356227f, 0.07283830f, -0.53765035f, -0.55908984f, 
    -0.02033910f, -0.11154943f, -0.40274081f, -0.16732897f, -0.15260401f, -0.39328656f, -0.13998759f, -0.15770307f, 
    -0.12838298f, 0.30545583f, 0.75804508f, -0.50033259f, -0.88278931f, -0.49053735f, -0.14771266f, 0.87952870f, 
    0.00910975f, 0.31717288f, 0.58417100f, 0.47675440f, -0.10470998f, -0.07144681f, -0.35759309f, -0.02257771f, 
    -0.14322186f, -0.66070658f, -0.33462560f, 0.43271428f, 0.19244733f, -0.65026283f, 0.16726452f, 0.04317792f, 
    0.14479238f, 0.39513952f, 0.52786982f, -0.75212449f, -0.59743190f, -0.85856193f, -0.49681312f, -0.07047395f, 
    0.49866194f, 0.32527179f, 0.20043613f, 0.93505055f, 0.57883281f, -0.19905081f, -0.27518314f, -0.10806136f, 
    -0.05146233f, 0.25482619f, -0.02895075f, -0.06341263f, -0.39223599f, -0.24331345f, -0.47460246f, -0.23133789f, 
    -0.46274009f, -0.63345462f, -0.45344672f, -0.54103643f, 0.65293092f, 0.61630780f, 0.85443825f, -0.92965615f, 
    -0.74449766f, 0.08947309f, 0.07108452f, -0.63709199f, -0.47024900f, -0.21651120f, 0.10238422f, 0.45753568f, 
    -0.33110946f, 0.02285730f, 0.80040765f, -0.41816834f, 0.42932513f, 0.16362426f, 0.13716598f, 0.08378043f, 
    0.09339985f, 0.06146369f, -0.22660694f, -0.27801663f, -0.43713510f, -0.23946396f, 0.55670857f, -0.85238880f, 
    -0.56484479f, -0.09702012f, 0.61467373f, 0.00957857f, -1.19383895f, -0.76109260f, -1.06196332f, -0.08536656f, 
    0.50133771f, -0.42706376f, -0.13599491f, -0.20776704f, -0.63258713f, -0.56259209f, -0.17301115f, 0.01005013f, 
    -0.27649358f, 0.24625592f, -0.09580249f, 0.16972427f, 0.24814183f, -0.04791494f, -1.08844590f, -0.38931417f, 
    -0.50591940f, -0.63117969f, -0.82976949f, -0.39600104f, -0.23390870f, -0.26352152f, 0.03094789f, 0.35729101f, 
    0.10709375f, -0.51103944f, -0.59201491f, -0.65799773f, -0.36407745f, 0.46093979f, 0.01038526f, -0.01074328f, 
    0.13186090f, -0.09816710f, -0.32702300f, -0.47101519f, -0.46595383f, -0.31147081f, -0.27886146f, -0.05926799f, 
    -0.58612210f, -0.28342724f, 0.67610508f, -0.78221774f, -1.06419766f, -1.15105212f, -0.56971616f, 0.17385297f, 
    -0.16825099f, 1.11431134f, -0.59442115f, -0.10970733f, 0.24813202f, 0.35392988f, -0.20138273f, 0.30380678f, 
    0.14499970f, -0.17268360f, -0.14545242f, -0.40196288f, -0.25555092f, 0.11274905f, 0.11878590f, -0.23920345f, 
    -1.00846589f, -0.64208192f, -1.12090576f, -1.26886606f, -0.47178605f, 0.33645815f, -0.58669198f, -0.68479311f, 
    -0.51748157f, -0.07034470f, -0.30494687f, -0.46602616f, -0.05651074f, 0.48475707f, -0.39488974f, -0.08429258f, 
    -0.17779550f, -0.19868603f, 0.08729898f, -0.41308656f, -0.39191261f, 0.25962666f, 0.21546851f, 0.03172991f, 
    0.15861699f, 0.30794248f, 0.36996281f, -0.56621575f, -0.26916906f, 0.72915030f, -0.26052386f, -0.07483086f, 
    -0.14261952f, -0.76264495f, -0.19712950f, -0.14640048f, 0.12999398f, -0.07024736f, 0.45145282f, -0.23793718f, 
    0.14907987f, -0.06270380f, -0.54010659f, 0.18944998f, -0.32666785f, -0.13040029f, 0.18179685f, 0.54078341f, 
    0.41920823f, 0.36609355f, -1.12765276f, -0.29191273f, 0.09165672f, 0.79963243f, 0.48323578f, -0.34826866f, 
    -0.84530324f, -0.10010877f, 0.86689150f, 0.94122040f, -0.01492095f, -0.25782469f, -0.03872062f, -0.00466237f, 
    0.54967135f, -0.10282357f, -0.01313807f, -0.09579290f, -0.13281620f, -0.00676709f, 0.02252638f, -0.59464443f, 
    0.24237175f, 0.36783686f, -0.16549927f, 1.49053383f, 0.28278938f, 0.11026589f, 0.58568299f, 0.11402656f, 
    -0.25987837f, -0.66516089f, -0.37302274f, -0.44678319f, -0.71705210f, 0.11508194f, -0.02469093f, 0.08474552f, 
    0.12333512f, -0.29732844f, -0.09213315f, 0.19251527f, 0.57249177f, -0.14495839f, -0.05549177f, -0.12681566f, 
    0.00984581f, 0.03262119f, 0.41720626f, -0.13594173f, -1.78742433f, -0.85109961f, 0.11507064f, -0.45032039f, 
    -0.86124349f, 0.47037417f, 0.48231936f, 0.22741744f, 0.19058570f, 0.25784379f, 0.03154962f, 0.05069840f, 
    0.31779948f, 0.50896245f, -0.05533810f, -0.04650071f, -0.18850996f, -0.50482130f, 0.12137829f, 0.22204275f, 
    0.13460976f, 0.17256640f, 0.65944988f, -0.00284244f, -0.27007771f, -1.34771562f, -1.21255970f, -0.45473143f, 
    0.52078313f, 0.40250522f, -0.69695836f, -0.14352226f, -1.06339037f, -1.02555883f, -1.31235111f, -0.41538933f, 
    -0.31316578f, 0.27134958f, -0.55530071f, -0.52859831f, -0.04685436f, -0.11094370f, 0.20205472f, -0.09237831f, 
    0.49279752f, 0.12175526f, -0.26355907f, 0.17455287f, -0.18766320f, 0.35265827f, -0.57484728f, -0.87863070f, 
    -0.23921472f, 0.75212401f, 0.68137079f, 0.78918070f, 0.28649142f, -0.29111776f, 0.15132323f, 0.67945534f, 
    0.55279034f, 0.02451811f, -0.31416109f, -0.48370203f, 0.48398605f, -0.57300949f, 0.45509267f, 0.35837364f, 
    -0.13595422f, -0.65307528f, 0.31000167f, 0.12103279f, 0.48641106f, -0.08082321f, -0.10713624f, 1.29217374f, 
    -0.40856189f, -0.83427626f, -1.11395860f, -1.46310771f, 0.22474183f, 0.19455896f, 0.50304359f, 0.16335794f, 
    0.39940295f, 0.30969888f, 0.25485358f, 0.35763246f, -0.17748412f, -0.09480844f, 0.15946786f, -0.12988260f, 
    0.22252348f, -0.32282597f, -0.23107713f, 0.08489706f, -0.32499734f, -0.34852305f, 0.11657605f, -0.06379813f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07875577f, 0.70775115f, 0.06180531f, 0.18656433f, 0.46464229f, 0.54669785f, -0.09477440f, 0.20185843f, 
    -0.66802812f, 0.48003006f, 0.78738648f, 0.50712216f, 0.52863812f, -0.21046412f, 0.72227699f, 0.61428571f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20912328f, -0.12148216f, 0.03782294f, 0.11015754f, 0.10412105f, 0.05564434f, 0.09957737f, 0.00394929f, 
    -0.00317537f, -0.04674269f, -0.08942215f, -0.00142620f, -0.91161108f, -0.67568535f, -0.78177804f, 0.35462499f, 
    0.05929987f, 0.14645429f, 0.04892837f, 0.09070811f, 0.01917145f, -0.03377012f, 0.00355534f, 0.15901823f, 
    -0.05786670f, -0.40159577f, -0.40360382f, 0.03910431f, 0.13554053f, 0.29104683f, -0.05173481f, -0.00292235f, 
    0.08632078f, -0.13022834f, -0.41382882f, -0.21962373f, 0.09362816f, -0.13312563f, 0.00309356f, -0.08169974f, 
    0.04896739f, 0.13832015f, 0.09994318f, 0.04832519f, 0.04020365f, 0.11248163f, 0.15377082f, 0.16187565f, 
    0.18355747f, -0.11979137f, -0.09613828f, 0.00943717f, -0.23149511f, 0.01105226f, -0.31814092f, -0.25898963f, 
    -0.26594403f, -0.09827743f, 0.01509410f, -0.09164602f, 0.20521319f, 0.19750914f, -0.78999203f, 0.04306871f, 
    -0.09203852f, -0.16756250f, -0.11923502f, -0.15835273f, -0.15804733f, -0.18721698f, -0.23290738f, -0.31177372f, 
    0.33809981f, 0.45837358f, 0.10059596f, -0.21381108f, 0.05391090f, 0.24382053f, 0.09388077f, 0.26896745f, 
    -0.13598022f, -0.00934389f, -0.11579508f, -0.08126057f, 0.34272975f, 0.23986131f, 0.41827700f, -0.64385033f, 
    0.13056403f, 0.05567702f, -0.22986750f, 0.15709074f, -0.00190552f, 0.06916165f, -0.09711795f, 0.04273507f, 
    0.52403170f, 0.20098497f, -0.12244883f, -0.23479600f, 0.06203933f, 0.30509964f, 0.06866889f, 0.05919487f, 
    -0.11798447f, -0.12563914f, 0.05634113f, -0.04684965f, -0.10517195f, 0.50782341f, -0.35340554f, 0.00353414f, 
    0.30466992f, -0.08600675f, -0.11602066f, -0.18377014f, -0.15644994f, -0.06387730f, -0.01984173f, -0.07496171f, 
    -0.57320112f, 0.29863977f, 0.45374084f, -0.52120250f, -0.12230393f, -0.00769047f, -0.02122219f, 0.11170253f, 
    -0.21947008f, -0.52195555f, -0.23587136f, -0.40309390f, -0.20495227f, -0.25947618f, -0.07143317f, -0.06072026f, 
    -0.02247255f, -0.01397761f, -0.42285359f, -0.08810706f, -0.01706411f, 0.04193008f, 0.02400518f, 0.00035662f, 
    0.22765251f, -0.07494048f, -0.10481761f, -0.20039020f, 0.16005920f, 0.15887654f, -0.11437102f, -0.08838698f, 
    -0.13087866f, -0.08745340f, -0.05673604f, 0.07790790f, 0.85196292f, 0.27012315f, -0.10642483f, -0.36734873f, 
    0.28767061f, -0.04373544f, 0.26534626f, 0.08055232f, 0.00661661f, -0.06633781f, 0.02973347f, -0.12330439f, 
    0.00503579f, -0.01150391f, -0.05742295f, -0.04979547f, -0.10197025f, 0.00299311f, -0.03701473f, -0.19312590f, 
    0.04826926f, -0.00246364f, -0.27230933f, -0.20888068f, -0.05028977f, -0.24229345f, -0.16395600f, 0.14315751f, 
    0.13714340f, 0.08342130f, -0.27499685f, -0.07735039f, -0.23471265f, -0.05111348f, -0.10633877f, 0.13572595f, 
    0.08452271f, 0.27722508f, 0.02721642f, 0.07308722f, -0.08274926f, -0.06592807f, -0.01756490f, 0.09675234f, 
    -0.01560954f, -0.00185439f, 0.03965678f, 0.06623109f, 0.88087362f, 0.26291180f, 0.41373166f, 0.05869967f, 
    -0.16924839f, -0.02748086f, -0.03718121f, -0.03086281f, 0.00767182f, -0.08022010f, -0.05703609f, -0.01038383f, 
    0.48070425f, 0.45185658f, 0.07761789f, -0.54466414f, -0.08105721f, -0.05352049f, 0.01847762f, -0.01483896f, 
    0.13875300f, 0.08219674f, 0.16656515f, -0.16307145f, -0.19324005f, -0.04601594f, 0.00589681f, -0.01241770f, 
    0.01612949f, 0.00326577f, -0.06455192f, -0.26151207f, -0.15302952f, -0.26857775f, -0.12106945f, -0.38272789f, 
    -0.00777607f, -0.20045760f, 0.11832944f, -0.36312455f, 0.21393673f, 0.07109995f, -0.18383332f, 0.26326886f, 
    0.00212998f, 0.33535624f, 0.03139147f, 0.09061803f, 0.07536151f, -0.34862176f, -0.18818069f, 0.13452697f, 
    -0.14788015f, -0.17206687f, 0.13758263f, 0.41772217f, -0.06035410f, -0.14529595f, -0.05836412f, 0.31215668f, 
    0.24061468f, 0.35129550f, 0.05521433f, -0.13131930f, 0.00552332f, -0.01035562f, -0.42959973f, -0.43330866f, 
    0.10811887f, 0.00439077f, -0.22128358f, -0.18331824f, -0.32559410f, 0.40897131f, 0.07446982f, -0.47530806f, 
    -0.06390154f, -0.40696234f, 0.04026389f, -0.13578461f, 0.17210132f, -0.03266333f, -0.02081021f, 0.05246505f, 
    0.35225663f, 0.33391234f, 0.46871433f, 0.48716357f, 0.18181323f, -0.00080882f, -0.05109554f, -0.14233913f, 
    -0.08305351f, 0.02339221f, 0.10267765f, -0.18034872f, 0.25315568f, -0.16780637f, -0.36166200f, 0.12559794f, 
    -0.16659962f, -0.21407276f, 0.21019015f, 0.16573921f, -0.07489159f, 0.02748089f, -0.04062394f, 0.15112625f, 
    -0.71150237f, 0.29070753f, 0.04403221f, 0.06767565f, 0.01006858f, 0.03251612f, 0.01060715f, 0.03858074f, 
    -0.01678532f, -0.00022625f, 0.09560929f, 0.04996648f, 0.02806718f, 0.29139075f, -0.17063196f, -0.28117377f, 
    -0.05652831f, -0.35555011f, -0.18069807f, -0.08742934f, -0.07265077f, -0.06358326f, -0.03481203f, 0.18171924f, 
    -0.27378470f, -0.24217214f, 0.02221887f, -0.14124650f, 0.04507545f, 0.06698969f, 0.28444558f, 0.05119642f, 
    -0.11377884f, -0.05162298f, 0.12753530f, -0.07099469f, -0.22873400f, -0.04132129f, -0.01144626f, 0.03954895f, 
    -0.07269985f, -0.32912225f, 0.21131025f, -0.18598159f, 0.06194307f, -0.02641337f, -0.00961192f, 0.08394303f, 
    0.00031534f, 0.00475720f, -0.07927094f, 0.12810576f, -0.16679657f, -0.08030251f, 0.07339374f, 0.34121883f, 
    -0.09434791f, 0.02818612f, -0.10592856f, 0.03879213f, 0.51057255f, -0.81482893f, -0.03802462f, -0.53833950f, 
    -0.09807041f, 0.04007294f, -0.03610636f, -0.07228010f, 0.26254231f, -0.04833773f, 0.12407176f, 0.00272978f, 
    -0.19665235f, -0.15813473f, 0.04908210f, 0.14336282f, -0.06176059f, -0.02991178f, -0.03707227f, 0.10834658f, 
    -0.03233616f, -0.12280027f, 0.11804839f, 0.05670379f, -0.79659492f, 0.18965177f, 0.37406659f, -0.80699700f, 
    -0.08037959f, 0.01360825f, -0.03907319f, 0.04659627f, 0.00643501f, -0.05783449f, 0.08317552f, -0.02764752f, 
    -0.92628616f, 0.39422217f, 0.32630309f, -0.34812614f, -0.10790998f, 0.00068105f, -0.09443478f, -0.00216841f, 
    -0.23458429f, -0.20528187f, 0.08107868f, -0.40620098f, -0.00354770f, 0.24510673f, 0.25405490f, 0.37444350f, 
    -0.05194296f, 0.05764744f, 0.09560727f, 0.02478008f, 0.14995803f, 0.01954696f, -0.12683418f, 0.26242837f, 
    0.08083135f, 0.02780239f, 0.15956472f, -0.29610652f, 0.12363559f, -0.32789835f, -0.34939948f, -0.03672718f, 
    0.26892844f, 0.17430517f, -0.22687936f, 0.09312887f, 0.25571364f, -0.25736251f, 0.16597061f, -0.71507853f, 
    0.35497209f, -0.18053991f, -0.03388730f, -0.04765833f, 0.04523120f, -0.03015133f, -0.07332125f, -0.06821413f, 
    0.06200668f, 0.22518140f, 0.16891935f, 0.26325521f, 0.13368565f, -0.08712278f, -0.05336021f, 0.02610261f, 
    -0.06145803f, 0.01282141f, -0.08337024f, -0.10394708f, -0.66454154f, 0.06117732f, -0.35881865f, -0.24598970f, 
    0.03553530f, 0.06904706f, 0.20248362f, -0.03960795f, -0.10797704f, -0.00967162f, -0.03198255f, 0.10582548f, 
    -1.03220606f, -0.03027851f, 0.51601022f, 0.23913532f, -0.10101643f, -0.01333275f, -0.13227981f, 0.02237869f, 
    -0.05000231f, -0.17834064f, 0.04990647f, -0.21556942f, 0.03610947f, -0.59137225f, 0.01117904f, -0.11712009f, 
    0.06975987f, 0.05402597f, 0.15720572f, -0.07432432f, -0.04371147f, -0.05511355f, 0.07896197f, -0.06166811f, 
    0.35444155f, -0.16495505f, -0.24291976f, 0.20999897f, -0.04898879f, 0.12220216f, -0.01711074f, 0.07366806f, 
    -0.03651667f, 0.04034054f, -0.31877556f, 0.17431931f, -0.93105131f, 0.04496868f, 0.39723250f, -0.09983136f, 
    -0.06701172f, -0.18496062f, 0.07609281f, -0.10181663f, 0.00162591f, -0.12754697f, 0.08531075f, -0.10177174f, 
    0.55320299f, 0.04793357f, 0.55447060f, 0.41272900f, -0.06159606f, -0.08984212f, 0.28378245f, 0.05639659f, 
    0.10352893f, -0.09403177f, 0.02008182f, -0.03299037f, -0.72922915f, -0.42084879f, -0.72109765f, 0.01711562f, 
    0.01537303f, -0.14361355f, 0.10980152f, 0.05423381f, 0.00850431f, -0.03774644f, -0.00514030f, -0.15556468f, 
    -0.05739482f, -0.24488297f, 0.07009301f, 0.13926165f, 0.08558764f, 0.00879375f, 0.10301418f, 0.05530939f, 
    -0.10549475f, -0.07603531f, -0.26404792f, 0.12477360f, -0.11693426f, 0.69161433f, 0.09041846f, 0.04120120f, 
    -0.02207699f, 0.05371698f, 0.17737456f, -0.08618211f, 0.07065120f, 0.26037651f, -0.00825958f, 0.27763829f, 
    -0.19997005f, -0.26079705f, -0.25859681f, -0.33499816f, -0.55627328f, 0.00988881f, -0.51755935f, 0.05457690f, 
    0.04307418f, -0.17353700f, 0.44527435f, -0.41524363f, -0.80581397f, 0.32549661f, 0.51143056f, 0.11708383f, 
    0.02413401f, 0.00356397f, -0.25246075f, 0.01391130f, 0.04490288f, 0.08365724f, -0.01625874f, 0.05436400f, 
    0.27302641f, 0.18187641f, 0.05747127f, 0.33332041f, 0.45067975f, -0.00031263f, 0.20911220f, -0.22820413f, 
    0.05025130f, -0.08157377f, 0.25902984f, 0.12116090f, 0.30957225f, -0.02324766f, -0.24481930f, 0.12008162f, 
    0.39700904f, 0.36589095f, 0.29470420f, -0.16210584f, -0.26835242f, 0.01693562f, -0.18229009f, -0.05047398f, 
    -0.28730097f, -0.47374135f, 0.51804549f, 0.51219463f, -0.08316381f, -0.03221409f, -0.27374917f, -0.12029151f, 
    0.06741855f, -0.31067392f, -0.46319076f, 0.15821928f, -0.09205283f, -0.01012024f, 0.00759108f, 0.22701542f, 
    0.10371395f, 0.08040312f, -0.01879842f, 0.06899484f, -0.17203867f, -0.16662122f, 0.16258647f, -0.07699540f, 
    0.17774668f, -0.33222052f, 0.05753806f, 0.15310381f, 0.09018648f, -0.05777834f, 0.10053484f, -0.17098342f, 
    -0.06732021f, 0.24518739f, 0.27825397f, 0.21089755f, 0.16834269f, -0.10429128f, -0.06901382f, -0.08031265f, 
    -0.01688901f, 0.14609739f, -0.08436415f, -0.04254428f, -0.14942268f, -0.13447571f, -0.10135598f, -0.11557166f, 
    0.00295613f, -0.39374182f, -0.09003888f, 0.36446765f, 0.10748333f, 0.15826000f, -0.14861152f, -0.00792213f, 
    0.01520086f, 0.13406584f, -0.03584755f, 0.06223726f, 0.23812528f, -0.02555657f, -0.02263672f, 0.42072853f, 
    0.04653490f, -0.18205664f, -0.32706088f, -0.26416957f, -0.07200308f, -0.50698459f, 0.14634714f, -0.15381974f, 
    0.15561892f, 0.15154018f, -0.01045484f, -0.89412642f, -0.09235208f, -0.15276930f, -0.32334566f, -0.30894399f, 
    -0.02632161f, -0.11312826f, -0.32206085f, -0.04830078f, -0.12624325f, -0.28512421f, 0.40961683f, 0.55459166f, 
    -0.34804925f, -0.18455030f, 0.18101101f, -0.11788401f, 0.00691063f, 0.26264679f, -0.09760634f, -0.09729210f, 
    0.28447321f, -0.08729411f, 0.32281429f, 0.26038983f, 0.11764898f, 0.16246402f, -0.14193453f, -0.06681547f, 
    -0.21042274f, 0.03680971f, 0.12049647f, -0.00090753f, -0.34315610f, 0.20644595f, -0.39450389f, 0.27740687f, 
    0.08465351f, 0.18582526f, 0.06660701f, 0.20210931f, -0.29672736f, -0.00715250f, -0.20892034f, 0.00489392f, 
    -0.13531603f, 0.31062040f, -0.03961623f, -1.07166088f, 0.15263048f, 0.21812290f, 0.12206005f, -0.11798652f, 
    -0.30908784f, 0.07623140f, -0.02867370f, -0.02620308f, -0.39046839f, 0.00967157f, -0.14013980f, 0.63729608f, 
    0.01141462f, 0.15745001f, 0.05515497f, -0.22747971f, -0.00676058f, 0.10577112f, 0.07274141f, 0.00273506f, 
    -0.14046277f, -0.04667834f, -0.09893388f, 0.14544919f, 0.16131952f, 0.12135644f, 0.16388002f, -0.09523254f, 
    0.10996272f, -0.01173044f, 0.05184869f, 0.14482167f, -0.16935003f, -0.98472363f, -1.06982303f, -0.52823937f, 
    0.12066469f, -0.00567017f, 0.15394039f, 0.02222688f, -0.00088258f, 0.07517618f, 0.04884927f, -0.08996637f, 
    -0.12102213f, 0.17090169f, -0.02594117f, 0.21064745f, 0.10129037f, 0.15551002f, -0.12523051f, 0.12440576f, 
    -0.10946058f, -0.36327988f, -0.56017458f, -0.02350243f, -0.09091642f, 0.04131739f, -0.07010633f, 0.04048320f, 
    -0.25264430f, -0.05722398f, -0.09041347f, 0.18313462f, 0.23556259f, 0.07469542f, 0.11390238f, 0.28196016f, 
    0.00754809f, 0.44230965f, -0.22679575f, 0.39067623f, 0.18856928f, 0.12056058f, -0.03858724f, -0.13324606f, 
    0.12495452f, -0.00626636f, 0.19597009f, -0.05813821f, 0.07149616f, 0.00404571f, 0.10118606f, 0.04540390f, 
    0.33517879f, -0.21490616f, 0.02957194f, -0.06461038f, -0.06470737f, -0.08847853f, -0.11400726f, -0.07644301f, 
    -0.18824857f, 0.04976284f, -0.00186861f, 0.15985008f, 0.06342620f, -0.05133850f, -0.00967677f, 0.16085994f, 
    0.06988277f, 0.04008289f, 0.11841697f, 0.24438925f, -0.00375005f, 0.16431256f, 0.34200132f, 0.31811363f, 
    -0.14860810f, -0.20083658f, -0.10303350f, 0.09315056f, 0.03981758f, 0.03558444f, 0.01159178f, -0.04766576f, 
    -0.11776235f, 0.22019021f, 0.30698794f, 0.07820875f, -0.07488991f, -0.08526121f, 0.09509973f, 0.14790334f, 
    0.00590746f, 0.00090840f, 0.04251310f, 0.00507868f, -0.12823686f, -0.01492972f, 0.13346423f, 0.15073928f, 
    -0.21210232f, 0.18824726f, -0.23549077f, 0.18290018f, 0.01684156f, -0.15142190f, -0.20854720f, -0.35741121f, 
    -0.36091304f, -0.10664528f, -0.48558134f, 0.03346820f, -0.27592361f, -0.16467996f, 0.15486245f, -0.16724448f, 
    -0.42629668f, -0.01686546f, -0.17646891f, 0.21103016f, 0.41647726f, 0.31523776f, 0.26554930f, 0.18697798f, 
    0.19250536f, 0.00443713f, 0.19930832f, 0.17123947f, 0.09466542f, -0.06853224f, -0.04965902f, -0.12519358f, 
    0.28054243f, 0.38761699f, -0.02531851f, 0.03380274f, -0.31848893f, -0.27588147f, -0.08848548f, -0.23144290f, 
    0.08252302f, -0.17775540f, -0.10113518f, 0.06982239f, -0.01212216f, -0.23609857f, 0.39372218f, -0.03024690f, 
    -0.09874760f, 0.23110081f, -0.04354944f, -0.12146476f, -0.05915201f, 0.02259690f, -0.03746971f, -0.07284801f, 
    0.35471463f, -0.02543656f, 0.01019435f, -0.17175223f, 0.10947075f, -0.11612954f, -0.00095059f, -0.08656228f, 
    0.10402323f, -0.22715484f, -0.33587870f, -0.34255719f, -0.36037812f, -0.13045350f, 0.14516474f, -0.03205938f, 
    0.13132879f, -0.19339465f, -0.07710315f, -0.12933172f, -0.05511994f, -0.09210365f, -0.15508857f, -0.06089457f, 
    -0.30846533f, -0.37690803f, 0.16814438f, 0.03056765f, 0.10518531f, -0.04305194f, 0.02509902f, -0.01616764f, 
    -0.08948231f, 0.19969115f, -0.06806350f, -0.11639022f, 0.34046403f, -0.52635884f, -0.50088519f, 0.51221967f, 
    0.06251735f, 0.15436617f, 0.08043396f, 0.00126278f, 0.23362422f, -0.10607768f, -0.11318447f, -0.06447561f, 
    -0.11688380f, -0.50462472f, -0.00547395f, -0.27733952f, -0.35703242f, -0.07592767f, -0.21451615f, -0.13870072f, 
    0.19387528f, 0.06947340f, 0.16672373f, 0.17081673f, -0.49131754f, -0.26209271f, 0.08454747f, -0.19011030f, 
    -0.02425257f, -0.18958965f, -0.07047309f, 0.10970250f, -0.02653597f, -0.29754907f, -0.06292723f, -0.23543651f, 
    -0.14957009f, 0.18285030f, -0.20037441f, 0.20384543f, -0.10008208f, -0.14176407f, 0.14665343f, 0.19547042f, 
    0.14462055f, 0.03945935f, 0.25705391f, -0.19275415f, 0.05698867f, 0.72247857f, 0.09869360f, -0.30893454f, 
    -0.08818945f, 0.27024433f, 0.15703920f, -0.15875956f, 0.06197576f, 0.14499950f, -0.05425715f, -0.24215567f, 
    -0.14632210f, 0.05680387f, 0.17577481f, 0.07284752f, -0.11341895f, -0.04547859f, -0.10380764f, 0.03526891f, 
    -0.02902896f, -0.32100821f, -0.18905845f, -0.00352439f, 0.31311846f, -0.05350855f, 0.08190577f, 0.18733890f, 
    0.15130635f, 0.11689614f, -0.22273195f, -0.09359633f, -0.11218192f, -0.07985196f, 0.07752931f, -0.05816121f, 
    -0.22922938f, 0.00806938f, -0.01974169f, -0.53346258f, -0.01169438f, 0.05894533f, 0.21933953f, -0.09463900f, 
    0.12139956f, -0.01355237f, 0.00165054f, 0.10728171f, -0.25185087f, 0.17530301f, 0.12952101f, -0.35610250f, 
    -0.09608197f, 0.11783477f, 0.04368467f, -0.14064519f, 0.08666016f, -0.00454533f, -0.09904395f, 0.16838843f, 
    -0.18053304f, -0.59631139f, 0.40864012f, 0.41832203f, -0.08046344f, -0.17199393f, -0.04483244f, 0.13802271f, 
    0.15803277f, 0.10389247f, 0.16292238f, -0.10302632f, 0.07433119f, -0.52058417f, -0.44896153f, -0.06485464f, 
    0.15812039f, 0.35251129f, -0.02840299f, -0.08542238f, 0.15428358f, -0.09273180f, 0.07834641f, -0.07699895f, 
    -0.65516496f, -0.35690480f, -0.44581234f, 0.01022857f, 0.22578476f, 0.03018514f, 0.04986549f, 0.09661935f, 
    0.22729115f, 0.23696925f, -0.10137951f, -0.09032635f, 0.32679215f, 0.32420877f, 0.44700095f, -0.03437870f, 
    0.13753435f, 0.18817931f, 0.03935388f, -0.10402422f, 0.11570429f, 0.01619532f, 0.13346331f, 0.17478508f, 
    0.13058822f, -0.14245693f, 0.30410033f, 0.16264784f, -0.20748170f, -0.12566955f, 0.05240456f, -0.07824231f, 
    0.06785017f, 0.17651579f, 0.22057530f, 0.15191011f, 0.06162766f, -0.11154270f, -0.49654800f, -0.19639812f, 
    -0.04960208f, -0.02432670f, -0.10087973f, 0.20198494f, -0.04934441f, -0.26986057f, -0.04430938f, -0.25018311f, 
    0.13005342f, -0.08339532f, -0.33796555f, -0.11375427f, -0.03158646f, 0.08728375f, 0.05174395f, 0.11868013f, 
    -0.19706400f, 0.04612979f, -0.08692514f, -0.19585831f, -0.01978165f, -0.17116825f, -0.07781503f, -0.32819602f, 
    0.02652758f, 0.03053849f, 0.14598657f, -0.08387247f, -0.08870588f, 0.11334254f, -0.09913512f, -0.01687420f, 
    -0.54176581f, 0.18757997f, -0.28732210f, 0.19070809f, 0.03923589f, -0.32737336f, 0.06245287f, 0.13527043f, 
    0.15749140f, 0.04999418f, 0.15243420f, 0.15318857f, -0.21719182f, 0.25556019f, 0.21200740f, 0.14854537f, 
    -0.05204893f, 0.00665162f, 0.07456765f, 0.10209363f, 0.13975908f, 0.05859073f, 0.13419716f, 0.27017465f, 
    0.46195966f, -0.57091689f, -0.14290129f, -0.01858789f, 0.08384425f, -0.11263762f, 0.39260316f, -0.05805266f, 
    0.13645098f, -0.16659550f, 0.16281199f, 0.06732237f, -1.52167833f, -1.07977760f, 0.31714597f, 0.09869314f, 
    0.36625138f, 0.17523965f, -0.16679814f, -0.23717995f, 0.03350511f, 0.08334959f, 0.23440047f, 0.08864829f, 
    -0.31956017f, -0.64413148f, -0.02920429f, 0.30798501f, -0.26655498f, 0.09769008f, 0.25391012f, 0.04560549f, 
    -0.04740425f, 0.14664394f, 0.08911322f, -0.17153595f, -0.92608923f, -0.84293360f, -0.77720964f, -0.15587552f, 
    -0.00378549f, 0.17022538f, 0.31506473f, -0.27273482f, 0.21773081f, -0.02456858f, -0.01216675f, -0.08767258f, 
    -0.16447367f, -1.06781113f, -0.36499596f, -0.61171436f, -0.08463044f, -0.26164654f, -0.24744284f, -0.29356322f, 
    -0.13041390f, -0.02710215f, -0.12737580f, 0.00456438f, -0.28151181f, -0.37766498f, -0.10260811f, 0.04918597f, 
    0.15363501f, -0.14690414f, -0.06126169f, 0.24442510f, -0.03723554f, 0.03146421f, -0.03990146f, -0.11302037f, 
    0.16881059f, -0.13615340f, -0.37635991f, 0.56438112f, 0.07253291f, 0.13385116f, 0.00694651f, 0.35314053f, 
    0.09377182f, -0.07556754f, 0.14602038f, 0.11727815f, 0.22732954f, -0.41547886f, -0.16439077f, -0.08186206f, 
    0.06304171f, 0.27695960f, 0.43717104f, -0.14451227f, 0.04531303f, 0.04955766f, -0.25792158f, -0.01510753f, 
    -0.94764078f, 0.44685456f, 0.62998611f, 0.02894329f, -0.36288959f, 0.02206368f, -0.46868703f, -0.32686597f, 
    -0.20570570f, -0.02984359f, 0.00852426f, -0.00688417f, -1.11958623f, -1.30304348f, -0.99340165f, 0.61280966f, 
    -0.30014211f, -0.47079492f, -0.18516625f, -0.40823042f, -0.12808093f, -0.01454214f, -0.05387423f, -0.00079213f, 
    -0.15846460f, 0.05451633f, 0.07020666f, 0.18112285f, 0.09409011f, 0.10675614f, -0.28354302f, 0.11713240f, 
    -0.05958607f, -0.00177502f, -0.12537082f, -0.28193095f, 0.88465822f, 0.76551914f, -0.17066665f, 0.31909773f, 
    -0.02378195f, -0.10706211f, 0.04211705f, 0.28460842f, 0.26207924f, 0.27704430f, -0.07552012f, -0.07533915f, 
    0.01366660f, 0.04632793f, 0.09174296f, -0.05188217f, -0.07831576f, -0.05412877f, -0.01052105f, -0.06829836f, 
    -0.02007276f, 0.00616639f, -0.11205798f, -0.01577264f, 0.02612976f, 0.17922752f, -0.03895365f, -0.15815699f, 
    0.21638077f, 0.04601265f, -0.01540974f, -0.02441463f, 0.08860070f, 0.05195032f, 0.06469348f, -0.09881972f, 
    0.29058287f, -0.56534177f, 0.09339622f, -0.55647206f, 0.03591565f, 0.16623333f, 0.16567606f, -0.01103650f, 
    -0.02184891f, 0.19768208f, -0.10049452f, -0.18994792f, 0.72614634f, -0.80224764f, -0.34171888f, -0.17051464f, 
    0.00894753f, -0.00943747f, 0.02933798f, -0.06254876f, 0.37838462f, 0.02128636f, -0.24418083f, 0.08022776f, 
    -0.17193711f, 0.17300470f, -0.05168930f, -0.08540706f, 0.04950466f, 0.00017032f, 0.26625785f, 0.00626399f, 
    -0.10508995f, -0.04865846f, 0.16713686f, -0.16126156f, -0.41001225f, 0.54289436f, 0.51744598f, 0.21467005f, 
    -0.13861877f, -0.27877167f, 0.02255963f, 0.02029872f, 0.00928443f, -0.05361912f, 0.03634654f, -0.12570404f, 
    -0.16548476f, -0.74549460f, -0.43392372f, -0.15429294f, -0.21307307f, 0.13512166f, 0.13242210f, 0.39472952f, 
    -0.04956323f, -0.04057795f, -0.16331932f, 0.10084030f, -0.13954835f, -1.17059255f, 0.09664653f, 1.05734944f, 
    -0.11033713f, 0.33507141f, 0.15082182f, -0.06150555f, -0.21137203f, 0.09874551f, -0.00068069f, -0.01913171f, 
    -0.79252803f, -0.67817116f, -0.19380803f, 0.01782387f, -0.02616940f, 0.17419563f, 0.04600257f, 0.15339081f, 
    -0.00843867f, 0.03919598f, -0.07785735f, 0.00339178f, -0.60075694f, 0.30436853f, 0.28906322f, 0.19963744f, 
    -0.12614053f, -0.29481331f, 0.16299430f, -0.17641824f, 0.07172784f, 0.05182652f, -0.11035170f, -0.11974361f, 
    0.81319743f, -0.79747432f, 0.01970644f, -0.38746065f, -0.02831787f, 0.17913382f, -0.16008149f, -0.12367863f, 
    -0.26739439f, 0.18154106f, -0.09715943f, -0.26919740f, -0.21234436f, 0.09906665f, 0.11208399f, -0.18288603f, 
    0.11250405f, -0.01397298f, -0.19311613f, 0.10410150f, 0.03854166f, 0.02671636f, 0.08099958f, -0.00270839f, 
    0.88084704f, -0.62568563f, -0.60199124f, -1.25932872f, -0.11036517f, -0.22938550f, -0.34591174f, 0.06891068f, 
    0.00951669f, 0.07886090f, 0.12808499f, 0.03864892f, -0.15817381f, -0.93612736f, 0.51178110f, -0.39458218f, 
    0.05239442f, -0.17595062f, -0.11217135f, 0.41372031f, 0.01772228f, -0.05811632f, -0.05148951f, -0.10173114f, 
    0.43121496f, -0.19418955f, 0.14988184f, -0.51157701f, -0.09443679f, 0.00838224f, -0.03255992f, 0.06748291f, 
    0.16595823f, 0.00146856f, 0.05480291f, -0.36349463f, -0.82198125f, -0.39202404f, -0.26384383f, 0.09794080f, 
    -0.16281691f, -0.03000682f, 0.06942889f, -0.03582325f, -0.12465306f, 0.04336642f, -0.01111862f, 0.05326863f, 
    -0.22758082f, 0.27619123f, -0.06394686f, -0.13744649f, 0.05205361f, -0.15204929f, 0.02824649f, -0.02965659f, 
    -0.34787738f, -0.16364639f, -0.07411847f, -0.04638063f, -0.74945992f, 0.19983883f, 0.19220649f, 0.09378366f, 
    -0.22109836f, -0.15107864f, -0.21346983f, -0.17778006f, -0.14840013f, -0.13775896f, 0.03334617f, 0.02676191f, 
    -0.35286486f, -0.41366723f, -0.16212678f, 0.13095497f, -0.08132424f, -0.24473965f, -0.02883634f, -0.16400667f, 
    0.12424042f, 0.00914111f, 0.19571921f, 0.36095378f, 0.00314183f, -0.40262872f, -0.07447117f, 0.12751670f, 
    0.03987398f, 0.18525118f, 0.06673695f, -0.00879186f, -0.16177537f, 0.03137596f, -0.13479380f, -0.67093593f, 
    -0.56630701f, -0.11718911f, 0.22672519f, 0.11135158f, -0.01899750f, 0.17725049f, -0.51406479f, 0.05113979f, 
    -0.05941177f, -0.15767066f, -0.23431285f, -0.04165570f, -0.13485160f, 0.04858448f, -0.14579232f, -0.14209495f, 
    -0.14549270f, 0.19364138f, 0.18152586f, -0.05260591f, 0.10675163f, 0.29371846f, 0.14968827f, 0.10568240f, 
    -0.16804619f, -0.40337053f, -0.58910346f, -0.02837721f, 0.06669460f, 0.04469141f, 0.21185175f, -0.19882756f, 
    -0.16658133f, -0.20703477f, -0.24458972f, -0.50250733f, 0.36027077f, 0.23742187f, -0.20848230f, -0.28131229f, 
    0.33275717f, -0.12844899f, 0.13663015f, 0.24292131f, -0.09380741f, -0.03165740f, -0.01116062f, -0.12153108f, 
    -0.40420905f, -1.15910947f, -0.90765691f, -0.23140590f, -0.02500231f, 0.09571993f, -0.03292548f, 0.03888143f, 
    -0.05482209f, 0.02159726f, 0.00821027f, 0.12208329f, 0.04302045f, -0.02746235f, -0.04659730f, -0.10826256f, 
    0.10506209f, -0.07641602f, -0.05901745f, -0.07819838f, 0.10125603f, 0.32335222f, 0.26540846f, 0.26413086f, 
    1.09818494f, 0.12860130f, -0.36492527f, -0.59941155f, 0.29287791f, 0.05107269f, 0.06765825f, -0.04917281f, 
    0.39833862f, 0.00997824f, 0.48573926f, 0.19784623f, -0.51409036f, 0.21933202f, 0.13212788f, 0.11320701f, 
    0.06785475f, -0.06290285f, -0.17298797f, -0.16995236f, 0.14518397f, 0.05296493f, 0.04863065f, 0.10103305f, 
    -0.27298424f, -0.98944736f, -0.76364636f, -0.14554912f, -0.18411477f, 0.51078862f, 0.35365188f, 0.37670842f, 
    0.18620116f, 0.03520068f, 0.10919929f, 0.00433262f, 0.47750360f, 0.34973776f, -0.80955005f, -0.22034881f, 
    -0.03594241f, -0.10273152f, -0.20613413f, -0.29612485f, 0.02514107f, -0.04453132f, 0.05933626f, 0.14379379f, 
    -0.18002634f, -0.08659340f, -0.08630291f, -0.32814085f, -0.30569592f, -0.04287088f, 0.09421467f, 0.09036765f, 
    0.12697224f, 0.16847555f, 0.05500314f, 0.39179805f, -0.84163898f, -0.20461001f, 0.03163906f, 0.34011710f, 
    0.03481263f, 0.27168363f, 0.14826883f, 0.20819668f, -0.11855946f, -0.07090995f, 0.05473598f, 0.03389310f, 
    -0.14129730f, 0.08894472f, -0.57723194f, 0.06193517f, 0.09955712f, -0.02102290f, 0.34822908f, -0.05733628f, 
    0.29650959f, 0.00740793f, -0.10027055f, 0.14408103f, -0.29576007f, -0.34310508f, -0.15957038f, -0.03792352f, 
    0.16158701f, 0.09914845f, 0.14636989f, 0.20937331f, 0.00050809f, 0.11011396f, 0.06014218f, -0.02090994f, 
    0.62593323f, -0.51374561f, 0.54830039f, -0.46832821f, 0.03770787f, -0.21109273f, 0.01339969f, -0.19617358f, 
    -0.34648591f, 0.11721840f, -0.33918849f, -0.15212403f, 0.45066711f, 0.22357830f, 0.18078466f, 0.32806978f, 
    -0.08015597f, -0.18409576f, -0.13570827f, -0.16883497f, -0.12263490f, 0.17738017f, 0.15360717f, 0.24909541f, 
    0.09701297f, 0.40009755f, -0.24369399f, -0.45106834f, -0.21689525f, 0.28093556f, -0.15665734f, -0.04619771f, 
    -0.18054885f, -0.18459216f, -0.21075225f, 0.25894338f, 0.07091590f, -0.27897123f, 0.19562848f, -0.14737472f, 
    -0.27590653f, 0.01165689f, -0.24397144f, -0.02106210f, 0.11075902f, -0.00944784f, -0.06545445f, 0.06347206f, 
    -0.19227178f, 0.13350599f, 0.23906139f, 0.02626082f, -0.02422725f, -0.15618104f, -0.02290966f, 0.02476989f, 
    0.12867913f, 0.12477582f, 0.12358721f, 0.07301936f, 0.50067919f, -0.44948548f, -0.08023185f, -0.16027912f, 
    0.02557344f, -0.12381582f, -0.15016939f, 0.37082863f, -0.08326694f, 0.10539594f, 0.06167291f, 0.06525567f, 
    -0.01710854f, -0.06379353f, 0.32094255f, -0.33495420f, -0.38288328f, 0.20832171f, 0.10884515f, 0.20679529f, 
    0.02861169f, -0.03605808f, 0.06741912f, -0.04637818f, -0.02706080f, -0.38186014f, -0.02347961f, -0.23990573f, 
    0.18727860f, -0.23172221f, -0.05550204f, -0.06012431f, 0.04236796f, -0.29544541f, -0.13666226f, -0.27934214f, 
    -0.04006979f, 0.16201495f, 0.48281020f, 0.34719351f, -0.17580706f, 0.11578959f, -0.14921135f, -0.40084866f, 
    0.25380817f, -0.03120454f, -0.14940757f, 0.12650409f, 0.41822696f, -0.39865276f, -0.55328339f, 0.07248486f, 
    0.16331659f, 0.37666735f, 0.15942626f, 0.08011882f, 0.09094615f, -0.15829152f, -0.19801943f, -0.15922938f, 
    -0.40411872f, 0.45778418f, -0.27501464f, -0.05791318f, -0.01144892f, -0.21175292f, -0.52362335f, 0.02547874f, 
    -0.03195883f, -0.35315400f, -0.00536376f, -0.02648770f, -0.98393917f, -0.67725509f, 0.39641613f, -0.21525195f, 
    -0.15705541f, -0.00225255f, -0.31149173f, 0.27198818f, 0.03180409f, -0.06505106f, 0.01979300f, 0.01499426f, 
    0.39219680f, -0.46463534f, 0.41444591f, 0.34130573f, 0.34864798f, -0.03944508f, -0.17770115f, 0.06063743f, 
    -0.07398356f, 0.01350118f, 0.07512803f, -0.05335834f, -0.17226768f, 0.37721661f, 0.96754092f, -1.14994574f, 
    0.06951194f, -0.20985460f, -0.05171848f, -0.17101929f, -0.23569739f, -0.05216770f, 0.09536774f, 0.08142641f, 
    -0.10360498f, -0.07652177f, -0.47530103f, -0.46767643f, -0.63577282f, -0.34211811f, 0.06323441f, -0.17840451f, 
    -0.11512685f, 0.38903180f, -0.47533205f, -0.03809839f, -0.15619527f, 0.08661816f, -0.30833325f, -0.10777298f, 
    -0.20289671f, -0.22505681f, -0.21267003f, 0.18477589f, -0.37252331f, -0.13025221f, -0.01650858f, -0.04664317f, 
    -0.00982398f, 0.40607652f, -0.74952793f, 0.40357751f, -0.13910760f, -0.18132395f, 0.09777919f, -0.02856735f, 
    0.15051566f, 0.17412230f, 0.14253649f, 0.04117993f, -0.22444116f, 0.48458672f, -0.28946269f, -0.34979931f, 
    0.00236006f, -0.19951816f, -0.37292764f, -0.02865493f, -0.17206334f, -0.28409487f, -0.12938908f, -0.64600879f, 
    0.14052391f, 0.10380388f, 0.52032185f, 0.07700157f, -0.13048339f, -0.32557684f, 0.40858671f, 0.11010469f, 
    -0.57807273f, 0.12094396f, 0.12567744f, -0.22054422f, 0.10709418f, -0.46993336f, 0.59051013f, 0.21035933f, 
    0.07629988f, -0.05259266f, 0.20882945f, 0.26717955f, 0.14229593f, 0.14264071f, 0.18751144f, 0.05575597f, 
    -0.09287854f, -0.30839074f, -0.17582087f, -0.00556435f, 0.05740318f, -0.05402363f, -0.41821310f, -0.06824768f, 
    -0.09822016f, -0.11752071f, -0.31417042f, -0.53924692f, -0.42172650f, 0.00334200f, -0.60053301f, 0.60644150f, 
    0.09176872f, 0.16727009f, 0.42766649f, -0.17056997f, -0.35169098f, -0.06461531f, -0.40371543f, -0.07426957f, 
    -0.16900863f, 0.26182079f, -0.78422499f, 0.11622441f, -0.08067100f, -0.42515621f, 0.13876812f, 0.15931754f, 
    0.12196839f, 0.50309557f, -0.08582703f, 0.04031345f, -0.04986367f, 0.02818449f, 0.20384040f, 0.00965730f, 
    -0.09948508f, 0.20052366f, 0.07511006f, 0.11333755f, 0.26935765f, 0.29758164f, 0.33982614f, 0.29132870f, 
    -1.10569668f, 0.30001125f, -0.07033250f, -0.36504927f, -0.20284991f, 0.35533592f, -0.06446812f, 0.22513664f, 
    -0.17286110f, -0.18926911f, 0.17527288f, -0.12807678f, -0.19317043f, -0.40383419f, -0.34450245f, 0.09741941f, 
    0.02130928f, 0.05419602f, -0.23627542f, 0.35928351f, -0.03565023f, 0.30761954f, 0.02329962f, -0.09034454f, 
    0.50466323f, 0.40214145f, 0.28859609f, -0.30081001f, 0.23972020f, -0.13055301f, 0.08584568f, 0.35611743f, 
    -0.32861799f, 0.10626627f, -0.02962539f, 0.09284422f, -0.59482807f, -0.08725665f, -0.49137247f, 0.41509831f, 
    -0.26394409f, 0.34672660f, -0.26917788f, 0.26771393f, -0.04121621f, 0.10388728f, 0.22618695f, 0.04783366f, 
    -0.43476757f, 0.57447672f, -0.50818080f, 0.19830942f, 0.10357923f, 0.08912671f, 0.05584925f, -0.03137460f, 
    -0.06164816f, 0.09620466f, 0.12146372f, 0.34961817f, -0.22585674f, 0.15522738f, -0.00332083f, 0.36356637f, 
    -0.06798792f, -0.15915728f, -0.19705674f, 0.11423869f, -0.14603557f, -0.31674519f, 0.00776325f, -0.08541544f, 
    0.55291945f, -0.06466231f, 0.61795682f, -0.38438863f, 0.00602734f, 0.19652767f, -0.09331661f, 0.12754336f, 
    0.04527293f, -0.19389096f, 0.23091784f, -0.20214351f, 0.23958564f, 0.20510559f, 0.30283207f, -0.04470328f, 
    -0.13360728f, -0.10228996f, -0.01957485f, 0.18471965f, -0.18238464f, 0.13325360f, 0.07540520f, -0.03741768f, 
    -0.62611443f, 0.00302457f, -0.35337800f, 0.46159396f, 0.01569736f, -0.05266399f, -0.24569997f, 0.15728775f, 
    -0.30774304f, 0.02938919f, 0.02724193f, -0.07270698f, -0.42847240f, -0.26297799f, 0.22863205f, -0.31669760f, 
    0.13758644f, -0.13408867f, -0.04218762f, 0.00333761f, 0.14625250f, 0.07852603f, 0.09880632f, 0.01511998f, 
    -0.29595000f, 0.45476085f, 0.11913250f, 0.17703006f, -0.10634150f, -0.00655714f, 0.04372576f, -0.20115474f, 
    0.17959695f, 0.01067520f, -0.01956690f, 0.27998438f, -0.59898055f, -0.19636935f, -0.25420147f, 0.34051722f, 
    -0.65365499f, 0.22015898f, -0.09183098f, 0.02544989f, 0.03840775f, 0.17603132f, -0.10025204f, 0.22188294f, 
    -0.06426126f, 0.02984324f, -0.12184160f, -0.49214557f, 0.04219753f, -0.18738703f, 0.35139447f, 0.03548228f, 
    0.07699332f, 0.19860540f, 0.33788663f, 0.09917380f, 0.38394198f, -0.49523523f, -0.02974285f, 1.06652975f, 
    -0.35816139f, -0.12713039f, 0.08951997f, -0.00845814f, 0.27494657f, -0.04624447f, 0.15924162f, 0.07814708f, 
    0.38801217f, -0.11879725f, -0.01378010f, -0.49006069f, 0.11394363f, -0.30634931f, -0.04356636f, -0.19895963f, 
    0.04613388f, -0.02843366f, -0.02772542f, -0.14503396f, 0.34843555f, 0.22561926f, -0.03151465f, -0.22581287f, 
    0.16307282f, 0.57298660f, -0.36594680f, 0.15575072f, -0.18752433f, -0.03016925f, -0.06124082f, 0.12085219f, 
    -0.19120611f, -0.09285118f, -0.36245227f, -0.04274340f, 0.35322106f, -0.09880169f, 0.30275881f, -0.03530979f, 
    -0.06449016f, 0.23404221f, -0.01120491f, 0.02157714f, 0.64180177f, 0.28172827f, 0.41230097f, 0.05031824f, 
    -0.02579195f, -0.27690053f, -0.01657144f, 0.02320943f, -0.16417372f, 0.01771075f, 0.00390715f, -0.07054719f, 
    -0.40658581f, -0.16164626f, 0.13992617f, 0.16748784f, 0.06912626f, 0.02135423f, -0.03794299f, -0.35105598f, 
    -0.15009090f, -0.10379273f, -0.33198804f, -0.16040488f, -0.46032739f, -0.51584393f, -0.00466591f, 0.32164487f, 
    -0.04356727f, 0.03293595f, -0.16569747f, -0.19053473f, -0.15773556f, -0.01160950f, -0.11995503f, -0.27210286f, 
    -0.91114211f, 0.29875508f, -0.67902428f, 0.23108296f, 0.08100636f, -0.19007595f, 0.30595106f, -0.12607013f, 
    -0.17180853f, -0.03902481f, 0.24695475f, -0.16700009f, -0.37786102f, -0.15655413f, 0.24553400f, -0.02260200f, 
    -0.00505950f, -0.13608296f, 0.12788555f, 0.06300847f, -0.05742873f, 0.19718391f, -0.02756427f, -0.08169960f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36236870f, 0.15074174f, 0.26053494f, -0.24227659f, -0.20327646f, 0.14404066f, 0.11192641f, -0.31097817f, 
    0.11388779f, -0.00605856f, 0.14572830f, -0.04352374f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
