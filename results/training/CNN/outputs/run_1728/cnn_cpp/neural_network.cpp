#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49070388f, -0.74234957f, -0.65666568f, -0.19589172f, -0.11198820f, -0.45864624f, 1.18652976f, 0.05546959f, 
    0.71807754f, -0.47259101f, 1.49976277f, -1.72855282f, -0.10815176f, -0.31576398f, -0.10362320f, -0.19270299f, 
    0.81164151f, -0.22172861f, -0.90527385f, -0.55445999f, 0.33169577f, -0.33660334f, -0.95473754f, -0.95618474f, 
    -0.18265466f, 0.84540945f, 0.38805339f, 0.33744523f, -0.22456157f, 1.32626271f, 0.00848310f, 0.23904288f, 
    1.26739228f, 0.34035853f, -0.18565504f, -0.24297756f, 0.73027956f, 1.07166624f, 0.16062124f, -1.05696857f, 
    0.74626595f, -0.49394482f, 0.48333800f, -0.41235721f, 1.15328884f, 0.89764065f, 1.13015020f, 0.28536519f, 
    -0.85890597f, -0.49435908f, 0.30552962f, -0.39609227f, 0.52187753f, -0.20410901f, -0.28763193f, -0.66576010f, 
    -0.92740875f, 0.67415255f, 0.94850594f, 0.56328428f, 0.18966025f, 0.65112710f, 0.21811423f, -0.98825103f, 
    -0.91473806f, -0.48067901f, -0.88583237f, -0.62440556f, -0.84534341f, -0.24569592f, -0.62309897f, -0.73556745f, 
    0.50450218f, 0.23930617f, -0.79767597f, -1.47777295f, -0.44734484f, -0.68410879f, 0.35473615f, 0.78669804f, 
    0.69694793f, -1.52850223f, 0.07989980f, 0.12677915f, -0.02781704f, -0.51830810f, 0.26907969f, 0.17768405f, 
    -0.31376532f, 0.27697894f, -0.40622669f, 0.34036466f, 0.41751680f, -0.85701621f, 0.36692125f, 0.91749138f, 
    0.38628811f, 0.76970023f, 0.25499931f, 0.18536365f, 0.64280581f, 0.10512129f, 1.02747822f, 0.51323915f, 
    0.40294218f, 0.62156767f, -0.24695195f, 0.29748189f, -0.41731906f, -1.64765108f, -1.53927875f, -0.49177477f, 
    0.61491030f, 0.83749700f, -0.02553418f, -0.25574970f, -0.63511086f, -0.94296390f, 0.39381731f, -1.15190196f, 
    0.30477768f, -0.37723652f, -0.70196009f, -0.46018770f, -0.71745181f, -0.77697897f, 0.05421193f, 0.34127706f, 
    0.66339576f, 0.34576294f, -0.63675261f, -1.03692102f, -0.67798680f, -0.50811338f, -0.90708482f, 0.90649617f, 
    0.43801787f, -0.64777702f, -0.25073594f, -0.26482898f, 0.78619635f, 0.80953896f, -0.17628302f, -0.22444014f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24087223f, -0.04653221f, -0.03441637f, 0.57288396f, -0.02250791f, 0.46423000f, -0.30680141f, -0.40829358f, 
    0.06590971f, 1.28638172f, 0.48106295f, 0.10693765f, -0.03054325f, 0.52156818f, 0.62973011f, 0.89518255f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.20188618f, 0.08118401f, 0.58431941f, 0.28149599f, 0.00177002f, -0.17844298f, 0.04842136f, -0.19604529f, 
    0.07589832f, 0.05286084f, 0.68571466f, 0.11445978f, -0.06513942f, 0.18086912f, 0.18324098f, -0.12057216f, 
    0.13604161f, -0.13850129f, 0.08734439f, 0.02836795f, 0.09723753f, -0.17186610f, -0.05167367f, 0.01543326f, 
    0.22162327f, -0.03882106f, -0.03188168f, -0.36762300f, 0.17204806f, -0.04078666f, -0.27215347f, -0.00361941f, 
    0.00120632f, 0.40400308f, 0.04510728f, 0.02604664f, -0.13621885f, 0.36222756f, 0.20350493f, 0.09664118f, 
    -0.03642946f, 0.04875142f, -0.01162602f, 0.19981730f, -0.00117274f, -0.45916876f, 0.24687751f, -0.51371372f, 
    0.07317285f, 0.01179329f, 0.00960999f, 0.05969600f, 0.36351565f, -0.08014053f, 0.05550388f, -0.30109486f, 
    0.23307782f, -0.47009897f, -0.53653198f, -0.35576421f, 0.01322155f, -0.07070871f, 0.23621264f, -0.17983010f, 
    -0.17868598f, 0.49151072f, 0.17169453f, 0.01320139f, -0.09344325f, 0.05786378f, 0.05161945f, 0.08112536f, 
    0.30992758f, 0.82437629f, 0.70638531f, -0.19708107f, -0.10256334f, 0.08333945f, -0.01719451f, -0.06189915f, 
    -0.08857736f, -0.00440339f, -0.02205707f, -0.15049115f, -0.13522667f, 0.01975082f, 0.00325498f, 0.04755643f, 
    -0.04262991f, 0.19048059f, -0.34828556f, 0.12682590f, -0.40666434f, -0.37549514f, -0.09814352f, 0.07551854f, 
    0.15576796f, -0.14301901f, 0.06187543f, 0.01243418f, 0.02168806f, 0.42776245f, -0.01459173f, -0.19431366f, 
    -0.14950541f, 0.03150517f, 0.09681829f, 0.07364512f, -0.11744026f, -0.21980456f, 0.32639340f, 0.13510448f, 
    -0.40119630f, -0.15260367f, -0.20871159f, -0.08736249f, -0.02344516f, -0.13434353f, -0.47393185f, -0.00009575f, 
    0.00818553f, 0.11248005f, -0.01708667f, 0.01668375f, 0.00828725f, -0.03668274f, -0.33694023f, 0.12425265f, 
    0.34058401f, -0.01688265f, 0.22106199f, -0.10610358f, 0.11608516f, 0.11911760f, -0.08622319f, -0.07121811f, 
    -0.39001051f, -0.10959540f, -0.03798517f, -0.01754651f, -0.07897460f, 0.08426785f, 0.18067847f, 0.10883226f, 
    -0.22513977f, 0.37320173f, -0.03126999f, 0.22914134f, 0.12400711f, -0.03031688f, -0.22651680f, 0.02185931f, 
    0.20130403f, -0.45754358f, -0.51831371f, -1.63948321f, -0.02102031f, 0.28269643f, -0.05190371f, -0.14609882f, 
    -0.11615618f, -0.30958328f, -0.97635269f, -0.33902857f, -0.52037644f, -0.27995941f, -0.20153987f, -0.05012357f, 
    0.11359421f, 0.07161323f, -0.00539354f, -0.17175500f, 0.18313052f, -0.08206796f, -0.15588401f, 0.04981219f, 
    -0.08026760f, 0.30955645f, 0.03622731f, 0.09876183f, 0.04790858f, -0.76622295f, -0.59973931f, -0.18741053f, 
    -0.15063642f, -0.01888343f, 0.30997568f, -0.21412295f, -0.12272592f, 0.01526448f, -0.71990728f, -0.48927546f, 
    -0.02502070f, 0.12104169f, -0.02161186f, 0.01938684f, 0.11830580f, 0.09650889f, -0.17990166f, 0.31470028f, 
    0.45898658f, -0.30091745f, -0.18174386f, -0.20451868f, 0.18529789f, -0.17191045f, 0.16645834f, 0.23656403f, 
    0.44616187f, 0.22780922f, -0.19061384f, -0.26203099f, -0.07607045f, 0.00289710f, 0.15300700f, -0.01204600f, 
    0.27659711f, 0.09755569f, -0.92760164f, -0.07587889f, -0.00941226f, -0.20643112f, -0.13872400f, -0.10052601f, 
    0.13179134f, -0.51231915f, 0.27184987f, 0.58583486f, 0.16462934f, 0.23558205f, 0.21513709f, 0.26022854f, 
    0.08912098f, 0.17414652f, -0.18570304f, -0.00174954f, -0.09427169f, -0.10513877f, -0.13097574f, 0.17567664f, 
    0.18477370f, 0.03699518f, 0.20595999f, -0.01899145f, 0.21373510f, 0.39719382f, -0.29208121f, -0.12645088f, 
    -0.04495495f, 0.06165129f, -0.17932749f, -0.12215725f, -0.16619599f, 0.16894630f, 0.55895811f, -0.13892141f, 
    -0.07664116f, -0.22568345f, 0.13642521f, -0.04875772f, -0.22454920f, -0.09231286f, 0.13957822f, -0.30831388f, 
    -0.03377404f, 0.11549520f, 0.23374940f, 0.07964975f, 0.15602282f, -0.07567155f, -0.33260417f, -0.37664214f, 
    0.17505458f, 0.30157584f, 0.13452411f, -0.05510055f, 0.10341889f, 0.06873199f, 0.29388797f, 0.26417774f, 
    0.34676397f, 0.03717780f, 0.06394830f, -0.12317701f, 0.29369426f, 0.49252608f, 0.06758618f, 0.11385542f, 
    -0.43551233f, 0.00942582f, 0.37097454f, -0.07842338f, 0.25156406f, -0.06477477f, -0.06908562f, 0.30962312f, 
    0.00709138f, 0.69434673f, -0.81810683f, 0.69346106f, 0.05650634f, -0.02943965f, 0.13092652f, 0.08637066f, 
    -0.08221216f, 0.51216608f, -0.30075264f, -0.59262019f, -0.16506375f, -0.07009041f, -0.29644719f, -0.26246914f, 
    -0.03064814f, 0.06594684f, 0.11069299f, -0.26030698f, -0.38717827f, -0.04410767f, 0.01611888f, -0.50478518f, 
    -0.16785055f, 0.13909389f, -0.10173596f, 0.20608315f, -0.96078235f, -0.78919452f, -0.10076904f, -0.09967890f, 
    0.24925509f, -0.01098299f, -0.17401679f, 0.27072027f, 0.25091600f, -0.56636333f, -0.13419087f, -0.01423755f, 
    -0.24414894f, 0.04569054f, 0.21823038f, 0.03853112f, 0.00841932f, 0.22910279f, -0.09039012f, -0.02810909f, 
    0.22194019f, -0.30339274f, -0.12535472f, -0.18445645f, -0.09048022f, -0.00024689f, -0.03454277f, -0.66763359f, 
    -0.29397526f, -0.01094870f, -0.00890182f, 0.00597345f, -0.06590101f, -0.04081363f, -0.02196340f, -0.18656051f, 
    -0.41180477f, -0.42561385f, 0.04427627f, -0.02783376f, 0.18574657f, -0.20095922f, 0.02477064f, 0.11227875f, 
    0.23129277f, 0.67977780f, 0.18579654f, -0.00868652f, 0.13790897f, 0.33954287f, 0.31473538f, 0.16463810f, 
    0.25578305f, 0.38925326f, -0.01624295f, -0.25311998f, -0.01498393f, -0.06386942f, -0.06777394f, 0.17631152f, 
    0.31716436f, 0.15494253f, 0.11607981f, -0.12564498f, -0.36877248f, -0.25327602f, 0.16118525f, 0.00296518f, 
    -0.16481499f, 0.03616118f, 0.03929397f, 0.23186482f, -0.22721186f, 0.53361809f, 0.14696731f, -0.07162511f, 
    -0.29739463f, -0.04664894f, -0.16267124f, -0.34892905f, -0.17017561f, -0.07567443f, 0.09294383f, 0.42587885f, 
    0.23112060f, 0.22511086f, 0.23337618f, 0.10545713f, 0.23030314f, -0.52325088f, -0.03657234f, 0.23602638f, 
    0.35014823f, -0.12453684f, 0.14788996f, 0.11150521f, 0.45227244f, 0.16638729f, 0.05621751f, 0.30797967f, 
    0.24235085f, 0.13651541f, -0.14854902f, -0.12228364f, 0.15655585f, 0.07311694f, 0.18778820f, 0.44152766f, 
    0.31904587f, 0.21370189f, 0.36311018f, -0.15793292f, 0.25382170f, 0.10147873f, 0.03712893f, 0.19692384f, 
    0.22764552f, -0.55713373f, -0.76435453f, -0.30950087f, -0.31596375f, -0.01251214f, -0.34433666f, 0.34536806f, 
    -0.07213958f, -0.05043078f, 0.54805028f, 0.29324496f, 0.43187600f, -0.13911448f, 0.03760997f, 0.08936818f, 
    -0.01539126f, 0.11056979f, 0.12741539f, -0.09411784f, -0.06001962f, -0.08233694f, 0.14522336f, 0.05858734f, 
    -0.17448287f, -0.12448817f, -0.05887139f, -0.18010429f, -0.31753501f, -0.14291377f, -0.53824830f, -0.28732711f, 
    -0.16550478f, 0.12313914f, 0.20499988f, 0.42567134f, -0.03317040f, -0.44318032f, -0.05994913f, -0.15275860f, 
    0.07163739f, -0.43185130f, 0.07947725f, 0.08660331f, -0.00342701f, 0.21706343f, 0.11099480f, -0.05288077f, 
    -0.14408265f, 0.14331922f, 0.06423377f, 0.05318880f, -0.10961570f, 0.00839412f, 0.06036179f, 0.38377425f, 
    0.15220745f, -0.41921508f, 0.15870000f, 0.26293880f, 0.21254294f, -0.05531238f, 0.09255853f, 0.05162273f, 
    0.28119284f, -0.24786255f, 0.23595193f, -0.36209816f, 0.06624341f, 0.21310692f, 0.23062688f, 0.11690359f, 
    0.32418221f, 0.25844175f, 0.10455992f, -0.16302118f, 0.10468442f, 0.25509831f, -0.03982325f, 0.04689621f, 
    -0.08093780f, -0.00196126f, -0.04380597f, -0.19284542f, -0.09809650f, 0.17662175f, 0.07045936f, -0.01085040f, 
    0.35774064f, 0.01421229f, 0.26163593f, -0.20651880f, -0.11411661f, -0.16520162f, 0.11823608f, 0.04538017f, 
    0.05165577f, 0.10346449f, -0.07837916f, -0.17012997f, 0.49321041f, 0.01844559f, 0.06015754f, -0.08492553f, 
    -0.15741058f, -0.04606447f, -0.17370054f, -0.15814671f, -0.12074330f, 0.53706294f, 0.06733213f, -0.31104785f, 
    0.02629824f, 0.24173714f, 0.14883323f, 0.00987106f, 0.02068686f, -0.14164531f, -0.20773849f, -0.29645541f, 
    -0.44425625f, -0.10501889f, -0.08620396f, 0.07056753f, -0.03228036f, -0.01905814f, -0.08505983f, -0.22213939f, 
    -0.03443294f, -0.19008614f, 0.06596446f, -0.18664876f, 0.16522083f, -0.11011712f, -0.04271694f, -0.15246631f, 
    0.37156805f, -0.07460176f, 0.13462132f, 0.24033915f, -0.09127237f, -0.34094587f, 0.41435900f, 0.16513076f, 
    -0.66932189f, -0.16087207f, -0.18129721f, 0.50024068f, 0.18161507f, -0.02571042f, -0.02073479f, 0.18769722f, 
    -0.19741753f, 0.49767613f, -0.21828540f, -0.11391186f, -0.16961598f, -0.00074233f, 0.07440322f, 0.07540112f, 
    0.23237824f, 0.02273023f, -0.15256645f, 0.16695575f, 0.09849681f, -0.35946417f, 0.07276219f, 0.19113244f, 
    0.12983418f, 0.15195087f, 0.12416472f, -0.59074676f, 0.12418246f, 0.20972003f, 0.09137034f, 0.36165243f, 
    -0.08589846f, 0.01118447f, 0.33348227f, -0.10734221f, 0.24545798f, 0.36092198f, 0.25033897f, -0.31101155f, 
    -0.12158664f, -0.13859817f, 0.04724103f, 0.26057026f, 0.14028820f, 0.03576629f, 0.15707748f, 0.20285553f, 
    0.39384040f, -0.01333084f, -0.06129904f, -0.04307972f, 0.02383781f, -0.17583925f, -0.18287173f, -0.06250820f, 
    0.28986064f, 0.24763647f, 0.19098222f, 0.17120144f, -0.02051271f, -0.00526176f, -0.17110759f, 0.15367024f, 
    -0.08715805f, 0.07712800f, 0.14242487f, 0.36246189f, 0.30901578f, 0.04636569f, -0.06796236f, -0.33513135f, 
    -0.32058966f, 0.16332188f, 0.03641708f, -0.00682206f, -0.04056969f, -0.07033665f, 0.16104944f, 0.25342843f, 
    -0.04622607f, 0.00622969f, -0.12718481f, -0.04248455f, -0.14282948f, 0.07515327f, 0.20636500f, 0.03358467f, 
    -0.34776759f, -0.24514031f, -0.64510155f, 0.09495758f, -0.00757293f, -0.06823944f, 0.12800156f, 0.14311706f, 
    0.19852351f, 0.01625455f, -0.20454666f, -0.11420927f, 0.08314826f, -0.19331719f, 0.04076001f, -0.18331435f, 
    0.29585388f, 0.17012239f, 0.16431749f, 0.11880537f, 0.28341159f, -0.21403426f, -0.08952890f, 0.07824596f, 
    -0.16202319f, -0.01280947f, 0.03869536f, -0.02618914f, 0.01370568f, 0.49683970f, 0.30569309f, 0.27588379f, 
    -0.09706277f, 0.14359321f, -0.03027471f, 0.15154128f, 0.14461868f, 0.20492886f, 0.15203880f, 0.07484014f, 
    -0.20825240f, 0.11076897f, -0.05221030f, 0.26259330f, 0.05666268f, 0.23354897f, 0.29010293f, -0.07981905f, 
    0.01617248f, -0.05773506f, 0.01570888f, 0.06289356f, -0.06584381f, -0.06280239f, 0.00406301f, 0.05371778f, 
    0.05794707f, -0.02068389f, 0.06000590f, -0.07647662f, 0.04967152f, 0.04596544f, 0.00292684f, 0.01709672f, 
    0.06231702f, -0.02187785f, -0.01389873f, 0.02302819f, 0.06232205f, 0.01159967f, 0.06564822f, 0.02404581f, 
    0.05738389f, 0.05921166f, -0.06448221f, 0.03456401f, -0.00702131f, 0.05523199f, -0.02821440f, -0.07974332f, 
    -0.06403901f, 0.06960841f, 0.00931518f, -0.08862718f, -0.07712355f, 0.07472161f, -0.00309333f, -0.01804174f, 
    -0.06146147f, -0.02284951f, -0.07510075f, -0.06326966f, -0.00502069f, -0.00428565f, 0.03246373f, -0.06243172f, 
    0.07194468f, 0.00699637f, -0.03821786f, 0.01271279f, -0.08806261f, -0.00936933f, 0.01541309f, 0.03036985f, 
    0.07666567f, 0.01411216f, -0.00000553f, -0.01897880f, -0.06405179f, 0.05056740f, -0.07552830f, 0.05414589f, 
    0.01634174f, 0.05866148f, -0.03141169f, -0.09933154f, 0.04550207f, 0.05338643f, -0.08971735f, 0.05971792f, 
    -0.09029139f, 0.06434681f, -0.00976154f, -0.03882716f, -0.06229380f, -0.07980972f, 0.07348251f, 0.02703167f, 
    -0.09015430f, -0.06463452f, -0.02232473f, 0.02258771f, 0.05660686f, -0.02162605f, -0.04541793f, 0.01393880f, 
    0.07079116f, -0.07979210f, 0.05775464f, 0.06047995f, -0.02111788f, -0.01746865f, -0.03739208f, -0.05615458f, 
    0.02318025f, -0.05259624f, -0.05255215f, -0.04697391f, -0.07989802f, 0.05471819f, 0.07113748f, 0.05635127f, 
    -0.08256702f, -0.00252558f, -0.08517099f, 0.04176110f, -0.02481622f, -0.05050117f, -0.03760768f, -0.06494214f, 
    -0.08425652f, 0.04225779f, -0.07705980f, -0.05138747f, -0.03590398f, -0.03003158f, 0.00918058f, 0.02673375f, 
    -0.04100710f, -0.08968569f, -0.06500731f, 0.01757986f, -0.00596782f, -0.03694658f, 0.00800603f, 0.03270827f, 
    -0.07977943f, -0.04285482f, -0.03822310f, -0.06573101f, 0.00961121f, -0.05375675f, -0.00173074f, 0.04155908f, 
    -0.08244248f, -0.02276774f, -0.08001018f, -0.07609671f, -0.05926210f, 0.00296757f, -0.02279848f, -0.03674001f, 
    -0.34614062f, 0.39906940f, 0.49058282f, -0.17044577f, -0.02567779f, 0.09836888f, 0.13196144f, 0.01319504f, 
    -0.27878121f, 0.04702040f, -0.18922769f, 0.20352642f, 0.04565708f, -0.12245443f, 0.19455262f, 0.23668417f, 
    -0.05179737f, 0.09985051f, -0.30111328f, -0.17557697f, -0.08996935f, -0.09636956f, -0.11911020f, 0.01066519f, 
    0.03983939f, 0.03153574f, -0.00860194f, 0.09095919f, 0.24552242f, 0.02966347f, -0.20622838f, 0.07577809f, 
    0.11114305f, 0.13407958f, 0.08301031f, 0.08384795f, 0.29494768f, -0.32526973f, 0.27333698f, -0.07735564f, 
    -0.26086998f, 0.16997042f, -0.08536267f, 0.00379643f, 0.00903277f, 0.47461569f, -0.20970383f, -0.04955014f, 
    -0.11775713f, 0.09658703f, 0.08659303f, 0.05713835f, 0.22236554f, 0.29819575f, -0.52879882f, 0.16602370f, 
    0.16192652f, -0.26962358f, -0.14349717f, -0.09598693f, -0.12441569f, -0.03529022f, -0.02514326f, -0.28731203f, 
    0.12243596f, -0.52610445f, 0.00276916f, -0.04957984f, -0.15413587f, -0.16837317f, -0.03500605f, -0.26341647f, 
    -0.03846030f, -0.36045825f, -0.55417675f, 0.00740106f, 0.14694613f, 0.19216786f, -0.02414444f, 0.18898560f, 
    -0.02830584f, -0.12578133f, 0.32255456f, 0.63024157f, 0.07377075f, -0.09438657f, 0.26530996f, 0.09279989f, 
    0.22935143f, -0.06195221f, 0.02442768f, 0.23652731f, 0.06588402f, -0.05591185f, -0.09733521f, 0.27788639f, 
    0.07963169f, 0.12348054f, -0.17329742f, -0.16622321f, -0.07715888f, 0.02617718f, 0.25935712f, -0.13814458f, 
    0.00394964f, -0.17567873f, -0.15259968f, -0.01694251f, -0.75604635f, 0.36637756f, 0.09040149f, -0.12179345f, 
    0.21043530f, -0.43907651f, 0.11983278f, 0.02232068f, -0.05332309f, -0.17534581f, -0.34391797f, -0.28466615f, 
    0.03377884f, 0.08350196f, 0.15636884f, -0.21261506f, -0.11638018f, -0.03982329f, 0.31266266f, -0.29335448f, 
    -0.07635918f, 0.12737781f, 0.10551497f, 0.08985359f, 0.24094225f, -0.12085911f, 0.16884448f, 0.34193641f, 
    0.22007118f, 0.39886248f, 0.20895141f, 0.01243987f, 0.33372745f, 0.19542420f, 0.16587783f, 0.12925437f, 
    0.41392040f, -0.12251686f, -0.19181909f, 0.03076212f, 0.02366954f, 0.06681212f, -0.09228418f, 0.05568718f, 
    -0.09738445f, 0.53873694f, -0.86059213f, -0.86508948f, -0.04989660f, -0.18878284f, 0.50480276f, 0.10283517f, 
    -0.19230466f, 0.13427964f, 0.48999932f, -0.27705419f, 0.00743680f, -0.07577066f, 0.00766170f, -0.09219457f, 
    0.05643735f, -0.11575665f, 0.07886382f, 0.10238471f, 0.03121327f, -0.06487519f, 0.17555068f, 0.27821991f, 
    -0.01913386f, 0.10325863f, -0.17605338f, -0.00841103f, -0.56745088f, -0.00388937f, 0.17846408f, -0.01841088f, 
    0.07842737f, -0.01403428f, -0.20096901f, 0.16231026f, 0.19292988f, -0.67089224f, 0.28132653f, -0.03131668f, 
    0.02147234f, 0.08775719f, 0.06433585f, -0.04513830f, 0.14649777f, -0.11065602f, 0.17411856f, 0.10547544f, 
    0.03450390f, -0.15927735f, -0.04257121f, 0.01795539f, 0.11960840f, 0.12802994f, 0.07063433f, 0.55026114f, 
    -0.08781373f, -0.54458350f, -0.02590274f, -0.00113915f, -0.09623925f, -0.08190163f, 0.11769965f, -0.19911198f, 
    -0.74324495f, -0.47460642f, 0.17113835f, -0.26340020f, -0.25386426f, 0.01026509f, -0.00043553f, 0.03071747f, 
    0.06051419f, 1.34792662f, 0.10401056f, -0.34742501f, -0.03661030f, -0.12701887f, 0.02929915f, -0.01952207f, 
    -0.08217454f, -0.08794376f, 0.08039976f, -0.04634387f, -0.13933407f, -0.17882006f, -0.14160749f, -0.30216813f, 
    0.08749700f, -0.07717164f, 0.14821215f, 0.17735656f, 0.03830412f, -0.04768153f, -0.39821234f, -0.06619703f, 
    -0.20756954f, 0.07584861f, -0.04485261f, 0.16482987f, 0.72056037f, -0.15379235f, -0.33233044f, -0.00655762f, 
    0.18523851f, 0.35007381f, 0.14627877f, 0.01127260f, -0.05079110f, 0.12479348f, -0.27339041f, -0.13488926f, 
    0.05780943f, -0.02275264f, -0.07093410f, 0.07899912f, 0.06518616f, 0.08292465f, -0.22675376f, 0.07709811f, 
    0.08144087f, 0.00707585f, -0.18166095f, -0.04364661f, -0.23488463f, 0.37238806f, 0.11106354f, -0.04606789f, 
    0.10359140f, -0.09980473f, 0.16119805f, 0.01254917f, -0.04536162f, 0.25462431f, 0.17894073f, 0.05927103f, 
    -0.02137201f, -0.08729099f, 0.35735980f, -0.05094572f, 0.17929208f, 0.20145510f, -0.05252606f, 0.18317306f, 
    -0.16000323f, -0.65322292f, -0.32545343f, 0.22608665f, 0.28307152f, -0.45853740f, 0.21169369f, 0.21789898f, 
    0.01640202f, -0.18691713f, -0.08446036f, 0.28877467f, 1.01729083f, 0.14733030f, -0.06698978f, -0.17908189f, 
    0.02228568f, -0.02344124f, 0.02639899f, -0.09613925f, 0.28437632f, 0.19763787f, -0.24589027f, 0.14811896f, 
    -0.50525230f, -0.15418670f, -0.12922896f, -0.16016312f, 0.24819466f, 0.70695871f, -0.01272491f, 0.04099231f, 
    -0.35455933f, -0.05241858f, -0.07321674f, 0.03455430f, -0.09677695f, 0.12910122f, 0.00272436f, 0.47894609f, 
    0.04952260f, -0.15071738f, 0.03610480f, 0.25891307f, -0.02538714f, 0.14058077f, -0.13148887f, -0.71626687f, 
    -0.42742440f, -0.22874703f, -0.06079123f, -0.03080314f, -0.02300649f, -0.19114433f, -0.03000217f, -0.27124298f, 
    0.17076412f, -0.03973418f, -0.12584326f, -0.03051754f, -0.01779545f, 0.00301512f, 0.07879383f, -0.01986039f, 
    -0.21453926f, -0.49375781f, -0.11760314f, -0.09245180f, 0.11782380f, 0.27591622f, 0.12394605f, 0.07243658f, 
    0.29985473f, -0.28468874f, 0.24064070f, 0.02569261f, 0.05685956f, -0.09105165f, 0.08107430f, 0.08913773f, 
    0.30402637f, -0.01787570f, -0.13480702f, 0.19049488f, -0.25693166f, 0.29909328f, -0.22051096f, -0.10408617f, 
    0.40413105f, 0.18799612f, 0.20110756f, -0.08495732f, 0.09144382f, -0.14407834f, 0.01162465f, -0.22747253f, 
    -0.21694675f, 0.08200371f, -0.12723775f, -0.00628308f, -0.09267122f, -0.10448901f, -0.35288876f, -0.19753033f, 
    -0.40972161f, 0.20011720f, -0.26078409f, -0.02170797f, -0.01659419f, -0.16878560f, 0.09414850f, -0.28586897f, 
    0.03315898f, -0.01740782f, -0.20015757f, 0.05527607f, -0.10356059f, -0.14842762f, -0.14820072f, -0.01940508f, 
    0.29105967f, 0.10169790f, 0.09957695f, 0.03967097f, 0.00295265f, 0.04780693f, 0.02355562f, -0.20075075f, 
    0.10692707f, 0.37870121f, 0.18379951f, 0.30698642f, 0.17154747f, -0.23698325f, 0.17259094f, 0.21208601f, 
    0.07845788f, -0.01219889f, -0.00387598f, -0.08114163f, -0.10856984f, -0.01853522f, 0.18668735f, 0.29988059f, 
    0.13955469f, -0.35298210f, 0.57580519f, 0.20288090f, -0.23360558f, 0.02648634f, 0.17390047f, 0.28997433f, 
    -0.06480159f, 0.14106674f, 0.16362138f, -0.15223370f, -0.09089658f, 0.09482054f, 0.13345550f, 0.26117125f, 
    0.19783729f, 0.11961969f, 0.23977575f, -0.18252690f, 0.07242192f, 0.31173235f, 0.07079901f, 0.17990501f, 
    0.06071717f, -0.09929528f, -0.18670754f, -0.19571482f, -0.20071864f, -0.08944582f, 0.01611181f, 0.16200644f, 
    -0.04133473f, 0.20187388f, 0.25927156f, 0.24711066f, 0.34545550f, -0.01835204f, -0.10107960f, 0.13481866f, 
    0.12171189f, 0.20504330f, 0.13439184f, 0.13126813f, 0.04574582f, 0.06755920f, 0.26565459f, -0.28535810f, 
    -0.22238146f, 0.27660167f, 0.20099820f, 0.20605610f, -0.08159140f, -0.06926722f, -0.17197526f, 0.15714051f, 
    -0.16000581f, 0.12410170f, 0.21436159f, -0.01020309f, -0.06453451f, 0.14264540f, 0.37497088f, 0.17872044f, 
    -0.14643884f, -0.23579705f, 0.08815551f, 0.02277397f, 0.31988886f, 0.25706550f, 0.09059498f, 0.23766850f, 
    0.06493392f, -0.07498022f, 0.13305990f, 0.18250307f, 0.24671955f, -0.03015879f, -0.10871804f, 0.28650987f, 
    -0.01260195f, 0.12240962f, 0.15309933f, 0.14470084f, 0.14919120f, 0.38964990f, 0.07413784f, -0.02731496f, 
    0.02611153f, 0.38494229f, 0.29935429f, 0.06533477f, 0.05426926f, 0.13583457f, 0.43532470f, 0.20715994f, 
    -0.08331042f, -0.07795060f, 0.15120675f, -0.03746734f, -0.13538821f, -0.17555876f, 0.13681769f, -0.29296091f, 
    -0.46654823f, -0.16546510f, -0.23143369f, -0.14195246f, -0.05003657f, -0.02392794f, 0.30039826f, -0.00162165f, 
    0.08852364f, -0.06877023f, -0.15972126f, -0.17471406f, -0.32153609f, -0.47374973f, -0.34555650f, -0.45873407f, 
    -0.04381613f, 0.24865001f, 0.06243665f, 0.19713353f, -0.13889125f, -0.36779046f, -0.40673378f, -0.50845420f, 
    -0.04871932f, 0.03912480f, -0.01606874f, 0.09116831f, -0.05385757f, -0.40457675f, -0.24334295f, 0.07495416f, 
    0.45749366f, 0.10765697f, 0.27389118f, 0.08656253f, -0.12385217f, -0.09848570f, 0.00168148f, 0.19352798f, 
    0.13012366f, 0.04054032f, 0.04877726f, 0.14907272f, -0.26871026f, 0.19515947f, -0.07278482f, -0.17333549f, 
    0.12861726f, -0.13571036f, 0.21705723f, 0.82266194f, 0.39647889f, 0.25549281f, -0.05343318f, 0.14852475f, 
    -0.06968135f, 0.11405250f, -0.19766581f, 0.38848239f, -0.06019722f, -0.15365694f, -0.29902256f, 0.07937767f, 
    -0.27050206f, 0.25913721f, -0.09781004f, 0.06137311f, 0.12414657f, -0.05054886f, 0.33119512f, 0.23694095f, 
    0.00163358f, -0.17595601f, -0.02713307f, -0.29793942f, 0.01138571f, 0.00521626f, -0.39863437f, -0.22099775f, 
    -0.00243409f, -0.03787405f, -0.00774364f, 0.01933398f, -0.09740075f, -0.08037908f, -0.16483350f, 0.34380591f, 
    0.37842187f, -0.05051390f, -0.14165042f, -0.08192584f, 0.12731992f, 0.13276012f, 0.02237885f, 0.31488281f, 
    0.37566221f, 0.18031289f, -0.04859950f, -0.12913665f, 0.11228619f, 0.07367641f, 0.01459082f, 0.13760474f, 
    -0.46395501f, -0.07154307f, -0.38666981f, 0.13762298f, 0.05057766f, -0.08279810f, -0.09042782f, 0.12037886f, 
    0.03234592f, -0.07325588f, -0.11688662f, 0.24624413f, -0.29112464f, -0.13691016f, -0.15673926f, -0.03687865f, 
    -0.01549280f, -0.10054955f, -0.01911440f, 0.42880401f, -0.08876539f, -0.18447149f, 0.28933668f, 0.08737738f, 
    0.01685738f, -0.00602776f, 0.05083945f, 0.41271898f, 0.03132171f, 0.05433059f, 0.08730505f, -0.05308658f, 
    -0.23243132f, 0.07111508f, -0.10190033f, 0.10524634f, -0.28767890f, 0.61844176f, 0.01874807f, -0.05267737f, 
    -0.28195107f, 0.13517740f, 0.13227957f, -0.14837143f, 0.13630643f, -0.10641091f, 0.14461572f, 0.16488732f, 
    -0.01489272f, -0.08245441f, 0.09003215f, 0.16699949f, 0.05587308f, -0.11638919f, 0.04536361f, -0.55773938f, 
    -0.18683219f, 0.04071543f, -0.09896097f, -0.17135894f, 0.15169774f, -0.08060476f, -0.09502294f, -0.40705752f, 
    0.25718361f, -0.65242273f, -0.17438929f, -0.09342191f, -0.00645355f, -0.14129487f, -0.15194114f, 0.16709743f, 
    -0.74561501f, 0.00540474f, 0.15459089f, 0.23725946f, 0.20500731f, 0.12925191f, 0.16725254f, -0.03572261f, 
    -0.02545373f, 0.13499549f, -1.18644154f, -0.65499127f, -0.02270211f, 0.33294302f, 0.11654561f, 0.08583723f, 
    -0.01927330f, 0.02411106f, -0.05129546f, -0.61472118f, -0.20678225f, -0.26665628f, -0.27610895f, -0.10147306f, 
    -0.03319484f, 0.00418435f, 0.24204385f, 0.32466894f, 0.24306555f, 0.02704351f, -0.06060931f, -0.11190285f, 
    -0.08771341f, -0.05068915f, -0.04790733f, 0.06654774f, 0.13942546f, -0.09455484f, -0.21288823f, 0.12639658f, 
    -0.15272824f, 0.17228951f, -0.02679580f, 0.13191684f, -0.21382098f, 0.15618356f, 0.11401235f, -0.22053030f, 
    0.07395619f, 0.01573713f, 0.15334436f, 0.18844205f, -0.07548514f, 0.16608998f, -0.51156521f, -0.28401938f, 
    -0.37728748f, -0.19386107f, -0.01701021f, 0.04177367f, -0.05078324f, -0.03760801f, 0.02144589f, 0.14220576f, 
    -0.55668128f, -0.85471272f, -0.51375264f, -0.14875060f, -0.06933068f, 0.01724015f, -0.05863189f, 0.03618952f, 
    -0.24905762f, -0.18486477f, -0.20734935f, 0.05470475f, -0.19946215f, -0.15818673f, 0.13521220f, -0.13247876f, 
    0.11595331f, 0.38499615f, 0.00450595f, -0.05716742f, 0.17773974f, 0.24848531f, 0.40096632f, 0.24501710f, 
    0.35531762f, -0.09861974f, -0.00129532f, 0.11883400f, -0.02581969f, -0.18264000f, 0.05764262f, 0.13877779f, 
    0.23529208f, -0.07811466f, 0.15055504f, 0.08078504f, 0.02344575f, -0.01144101f, -0.16106883f, -0.08542577f, 
    -0.06873225f, 0.01427482f, -0.21994366f, -0.15582521f, -0.71132594f, -1.28195763f, -1.13267851f, -0.42742786f, 
    0.11772776f, 0.22643547f, -0.25635684f, -0.22610594f, -0.10121443f, -0.23287280f, -0.44664848f, -0.48253897f, 
    0.03687360f, 0.06342812f, 0.15838447f, 0.05097201f, -0.00013174f, -0.04212155f, 0.27680930f, 0.27082434f, 
    -0.11009912f, -0.07918243f, 0.03787780f, -0.07378174f, 0.05597963f, -0.01649592f, 0.37103736f, 0.42909339f, 
    0.23326726f, 0.16682652f, 0.26578715f, 0.02402093f, 0.10261046f, 0.25838259f, 0.42307481f, -0.02045302f, 
    -0.16093434f, 0.47045359f, -0.05980072f, -0.08110496f, 0.02887238f, 0.13193996f, -0.05700921f, -0.10511881f, 
    -0.22040814f, -0.25910437f, -0.35792655f, -1.18495309f, -0.12135495f, -0.42879906f, 0.16294332f, 0.03800085f, 
    0.04415909f, -0.01328869f, -0.05162668f, 0.39933661f, 0.51442736f, -0.18416949f, 0.07187013f, -0.44673887f, 
    0.14059521f, -0.10732804f, 0.02890708f, 0.22641417f, -0.22476111f, -0.35740674f, 0.12429897f, 0.06839649f, 
    -0.30402571f, 0.25262755f, 0.14793013f, 0.27387133f, 0.22510429f, -0.45916450f, -0.07679755f, -0.14459437f, 
    -0.27645403f, 0.39058274f, -0.24626014f, -0.13116294f, 0.06391120f, 0.07443608f, -0.60100943f, -0.37850088f, 
    0.02392911f, -0.13609283f, -0.20547900f, 0.11306785f, 0.00300950f, 0.04631405f, -0.55507237f, -0.61163694f, 
    -0.79704672f, 0.01881400f, -0.31484318f, 0.20371336f, 0.04767490f, 0.15363057f, 0.07389148f, 0.65066701f, 
    0.17463730f, 0.24700516f, -0.02497020f, -0.16622043f, 0.22426370f, -0.02439174f, -0.38634318f, -0.11036517f, 
    0.56905246f, 0.31244966f, -0.28355399f, -0.26059368f, -0.11241899f, 0.00128846f, -0.08826338f, -0.21262710f, 
    -0.02646450f, -0.00023578f, 0.15890510f, 0.54783547f, -0.02158508f, -0.00362963f, 0.14688897f, 0.14718331f, 
    0.24804130f, 0.15566355f, 0.39905271f, -0.32590863f, 0.24121004f, -0.31465590f, 0.19038273f, 0.01864471f, 
    -0.41458586f, -0.22678678f, -0.17099565f, -0.27107894f, 0.10278242f, -0.09384322f, 0.10581029f, -0.11701108f, 
    0.14680785f, 0.03280863f, 0.23020655f, 0.24120235f, 0.53685051f, -0.11478554f, 0.28068963f, 0.28596333f, 
    0.26109773f, -0.17826432f, 0.21261708f, 0.24339588f, 0.05179542f, 0.24519381f, 0.20667690f, 0.18181039f, 
    -0.01994084f, 0.12551041f, 0.12061131f, -0.05244276f, 0.15190288f, 0.02870169f, -0.33957922f, 0.03632155f, 
    -0.11516573f, -0.05091710f, 0.16078670f, 0.05676140f, 0.06073979f, -0.10628764f, 0.02316859f, 0.30094755f, 
    -0.24461517f, -0.44183192f, 0.06517167f, -0.15236226f, 0.03145280f, 0.44845322f, 0.26578048f, 0.04538530f, 
    0.22628522f, 0.09255399f, 0.32362986f, 0.18489492f, -0.15979578f, 0.04755164f, 0.06504967f, 0.41758057f, 
    0.23235238f, 0.64195657f, 0.73493189f, 0.16167133f, -0.42881215f, 0.59213984f, 0.63930613f, -0.05258120f, 
    0.45073217f, 0.22495520f, 0.71306658f, 0.74066365f, 0.64497876f, -0.15251350f, 0.23159759f, -0.15580560f, 
    0.28323433f, 0.26382858f, 0.31197545f, -0.25944036f, 0.06533284f, -0.32772323f, -0.26314431f, -0.28656104f, 
    0.02140279f, -0.24123473f, -0.26986483f, 0.03478160f, -0.32961696f, 0.00571150f, 0.36579233f, 0.07033640f, 
    -0.02425067f, 0.05290451f, -0.07505324f, 0.12609631f, 0.53938043f, -0.56903368f, -0.50154603f, -0.27523330f, 
    -0.29921329f, 0.15027845f, -0.15710808f, -0.09406175f, 0.08405305f, 0.26357618f, -0.32753697f, -0.28204778f, 
    -0.34156170f, 0.28771034f, 0.24252978f, 0.05209944f, 0.22881792f, 0.00805087f, -0.04347656f, 0.58086878f, 
    0.23539414f, 0.41774601f, 0.23118885f, -0.15682091f, -0.00013596f, 0.00909226f, 0.22076119f, 0.17915228f, 
    0.05060283f, 0.15819135f, 0.30302107f, -0.04470359f, 0.08351532f, 0.04149215f, 0.07395284f, 0.14535967f, 
    0.22058572f, 0.22430064f, 0.11628138f, 0.02601879f, 0.16908976f, -0.09979422f, -0.20230931f, -0.01546266f, 
    0.00813899f, 0.00940690f, -0.08910234f, -0.05170357f, -0.04345996f, 0.15271260f, -0.21226737f, -0.01321003f, 
    0.30465263f, 0.06110099f, 0.03507223f, -0.17174938f, -0.26219225f, -0.09723394f, 0.20942292f, -0.29072642f, 
    -0.34178349f, -0.29364142f, 0.21496265f, -0.05573833f, -0.19069079f, -0.29032096f, -0.33084106f, 0.08915227f, 
    0.00683945f, -0.20664364f, -0.16997871f, -0.19280668f, -0.29151973f, 0.24497029f, 0.08155157f, -0.01482329f, 
    -0.05969721f, 0.02238230f, -0.06983867f, -0.22456028f, -0.32132033f, -0.23049957f, -0.18835934f, -0.13812536f, 
    -0.02723510f, -0.09001491f, 0.07152396f, -0.26323804f, 0.05327586f, -0.26123261f, -0.25387487f, -0.33015022f, 
    -0.29984510f, -0.18999800f, 0.12870356f, -0.08217499f, -0.10259371f, -0.29952687f, 0.17174560f, -0.14465883f, 
    0.03304268f, -0.31070703f, -0.03372366f, 0.17695719f, -0.09481282f, -0.07286994f, 0.01567160f, 0.22235091f, 
    -0.22778042f, 0.40236044f, -0.33557385f, -0.36994365f, -0.25760037f, -0.34713224f, 0.13498539f, -0.00210707f, 
    -0.13762307f, -0.07037853f, 0.32280141f, -0.51266044f, 0.05617498f, 0.19759938f, 0.14600866f, -0.04315449f, 
    -0.03576002f, -0.08959426f, -0.16272502f, 0.26436165f, -0.33866718f, -0.64855337f, 0.17317414f, -0.36822537f, 
    -0.04062390f, -0.05574054f, 0.23520163f, -0.15871647f, -0.11734274f, -0.09026831f, -0.58361161f, 0.18704684f, 
    0.05668540f, 0.14258517f, 0.11016924f, -0.06426023f, 0.08832584f, 0.48559195f, 0.51632935f, -0.17434987f, 
    0.04681489f, 0.09465023f, -0.40947548f, -0.01470836f, -0.11926400f, 0.13353612f, -0.38847297f, -0.03703456f, 
    0.44781059f, -0.03670546f, 0.10442608f, 0.22039205f, -0.14962965f, -0.04500163f, 0.34946314f, -0.11165555f, 
    -0.05278740f, 0.27457380f, 0.05394331f, -0.04581416f, -0.03204274f, -0.11483844f, 0.20435418f, -0.03015850f, 
    0.13543297f, 0.24134161f, 0.42062768f, 0.03936286f, -0.02140663f, 0.06459174f, -0.21122223f, 0.20891923f, 
    -0.11499371f, 0.26309669f, -0.05973562f, -0.28249845f, 0.36434418f, -0.00322497f, 0.04713196f, 0.06450220f, 
    -0.03874546f, 0.00392698f, 0.01819396f, 0.00488490f, -0.54537398f, -0.24420726f, -0.17361975f, -0.11373208f, 
    -0.19659412f, -0.20966005f, 0.04635535f, 0.48850378f, 0.09862403f, 0.20118362f, -0.08767792f, 0.19539799f, 
    0.13574389f, 0.21140043f, 0.07202411f, 0.05131024f, -0.26843113f, 0.21868499f, 0.18654770f, 0.03433004f, 
    0.06552584f, -0.03213192f, -0.24907237f, 0.07897927f, 0.12010913f, 0.04867452f, -0.19077638f, 0.28969356f, 
    0.05640437f, -0.16879185f, -0.00021468f, -0.06183004f, -0.15846373f, 0.02065039f, 0.13303842f, 0.13945492f, 
    0.23398505f, -0.12000506f, -0.08915737f, -0.09871526f, 0.20856576f, 0.14561698f, 0.12873551f, 0.54066688f, 
    0.21914610f, -0.56480968f, 0.24024338f, 0.30905601f, -0.35319269f, 0.09693461f, 0.05981638f, -0.25173938f, 
    0.16295642f, -0.39137223f, 0.11254596f, -0.07595800f, -0.15024363f, -0.18325470f, -0.01277741f, -0.04721162f, 
    -0.29728130f, -0.53180254f, -0.11957833f, -0.28207034f, 0.08316880f, -0.06248878f, 0.16145551f, 0.32272556f, 
    0.05178113f, -0.12369354f, -0.00274158f, -0.38159686f, 0.05599206f, -0.03537965f, -0.11034194f, -0.31409365f, 
    0.27586046f, -0.07061183f, 0.17635456f, -0.11875390f, 0.07489805f, 0.16715875f, -0.14889510f, -0.09132025f, 
    0.05392459f, -0.07674682f, 0.25731954f, 0.04081832f, -0.05032862f, 0.12942341f, 0.00929474f, 0.09378684f, 
    -0.36589721f, -0.17722902f, 0.07231580f, 0.06719337f, -0.01180673f, 0.26616421f, 0.12673236f, -0.02380825f, 
    0.09545657f, 0.19983843f, -0.15581772f, -0.15568882f, 0.27848074f, -0.05587056f, -0.46962386f, -0.12259066f, 
    -0.19058344f, -0.31539190f, -0.09706177f, 0.14398524f, -0.09235595f, -0.03704280f, 0.07299217f, -0.12409963f, 
    -0.35923070f, -0.15657124f, -0.26939106f, -0.05155721f, -0.15202308f, 0.01679012f, -0.12604333f, 0.02386742f, 
    -0.25550842f, -0.44072187f, -0.06833895f, -0.32762334f, 0.13194235f, 0.03276506f, 0.12764746f, 0.44658393f, 
    -0.33362645f, 0.44251493f, 0.03354980f, 0.45781910f, 0.26644573f, 0.21821548f, 0.34941897f, 0.07641020f, 
    0.00442954f, 0.14780505f, 0.24360436f, -0.03361859f, -0.17109704f, -0.03672386f, 0.16637990f, -0.08729222f, 
    -0.02877908f, 0.10787672f, -0.10108633f, -0.48219123f, 0.11876335f, -0.31960362f, -0.18245378f, -0.04177223f, 
    0.18957052f, 0.10834794f, 0.10687854f, 0.04885188f, -0.21608046f, -0.82695484f, -0.43568936f, 0.03179811f, 
    0.18627214f, 0.16503254f, -0.14494787f, 0.02791867f, 0.20302983f, -0.13389762f, -0.05366522f, 0.11685124f, 
    -0.14716664f, 0.14658798f, 0.17534813f, 0.06546640f, 0.05034000f, 0.38475102f, -0.02006894f, 0.31059942f, 
    0.50291777f, -0.05134952f, 0.00083077f, -0.14096680f, 0.14255154f, -0.16929609f, 0.16230798f, -0.14142001f, 
    -0.01787204f, 0.00493404f, -0.03248448f, 0.35385409f, -0.11548815f, 0.20217814f, 0.17040794f, 0.12765196f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19872490f, 0.59509933f, 0.58451712f, 0.09448666f, 0.01036004f, -0.07216919f, 0.32405925f, -0.18492015f, 
    0.31487495f, 0.10490431f, -0.05074703f, 0.37997535f, 0.07877991f, -0.02682765f, 0.05170362f, 0.28064340f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.72928244f, -0.41436613f, -0.74054980f, 0.53773415f, -0.06507185f, 0.09475998f, -0.12564585f, 0.43980950f, 
    0.18502793f, -0.00872239f, 0.23017909f, -0.30638817f, 0.63271368f, 0.25231311f, -0.78206205f, -0.68517488f, 
    -0.78152603f, 0.14044020f, 0.01743069f, 0.52010483f, -0.39282781f, -0.03161886f, 0.25106257f, -0.46807748f, 
    0.54177284f, 0.26772296f, -0.02998965f, 0.77125746f, 0.32035011f, 0.18273027f, -0.25615695f, -0.90079224f, 
    -0.54954046f, 0.26368436f, 0.94333959f, -0.56485599f, 0.12209012f, -0.00599331f, 0.06279334f, 0.45550895f, 
    -0.82376271f, -0.17437875f, 0.26696271f, -0.77530211f, -0.00394575f, -1.07158828f, 0.27054715f, -0.07452756f, 
    0.65006703f, -1.12315786f, 0.10765739f, 0.10647509f, 0.33628264f, -0.04080856f, -0.85229474f, 0.92681462f, 
    -0.25935888f, -0.08587126f, -0.57572758f, -0.53685117f, -0.12603118f, -0.00864019f, 0.56194353f, -0.31985295f, 
    0.15836908f, -0.14036638f, -0.38864258f, -0.21084224f, 0.36832121f, -0.05844735f, -0.15203109f, -0.04838926f, 
    -0.41741276f, -0.36862290f, 0.82568246f, 0.00100565f, -0.13966860f, 0.38782403f, -0.10540154f, -0.26035720f, 
    -0.30825603f, 0.07026658f, -0.09131543f, -0.12555963f, -0.11581320f, -0.24104954f, -0.28698751f, -0.35200593f, 
    0.09468003f, 0.50209349f, -0.23715985f, -0.10406121f, 0.23639996f, 0.32928133f, 0.49777931f, 0.12382096f, 
    -0.30270839f, 1.01352334f, -0.16667621f, -0.50096691f, 0.35671428f, 0.22228207f, 0.67171669f, 0.02022479f, 
    -0.90404373f, -0.55771840f, -0.73107809f, -0.02503453f, -0.81655747f, -0.59034431f, 0.16827349f, 0.09589699f, 
    -0.05203171f, -0.46764436f, -0.89598632f, -0.95204800f, -0.06568433f, 0.07877694f, -0.16854246f, 0.90084970f, 
    0.31021911f, -0.15122187f, 0.47983816f, 0.62119818f, -0.05349889f, 0.50009441f, 0.08219060f, 0.33767217f, 
    -0.55789518f, -0.35276651f, 0.07882722f, 0.60893673f, -0.61764032f, -0.21797082f, -0.17637920f, 0.33477372f, 
    0.01102294f, 0.45630947f, 0.02712504f, 0.65712023f, -0.88530296f, 0.24495409f, 0.28734705f, 0.58282286f, 
    0.76711446f, 0.93302417f, -0.66497493f, -0.30630940f, 0.34852576f, 0.05051755f, -0.43187696f, -0.47795892f, 
    0.05459080f, 0.15765209f, -0.92734313f, -0.49108896f, 0.34915346f, -0.65880871f, 0.21560211f, 0.38821533f, 
    0.90079623f, -0.00128414f, 0.39897448f, -0.37144014f, -0.40579879f, -0.14745118f, -0.05491880f, -0.13073495f, 
    0.01037158f, 0.36242241f, -0.70895189f, -0.48979804f, -0.65975803f, 0.69192189f, -1.16983950f, -0.02027962f, 
    -0.14502278f, -0.97694862f, -0.04742831f, 0.24600072f, 0.33979678f, 0.06439197f, 0.13891172f, -0.95012599f, 
    0.91952294f, -0.05968007f, -0.42956546f, -0.47125012f, -0.11237453f, -1.07151222f, -0.39635083f, 0.59621525f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.78859293f, 0.21542186f, 0.30996364f, 0.17429939f, 0.20778415f, -0.26729411f, 0.16335236f, -0.57081246f, 
    -0.05488193f, 0.19167480f, 0.08502869f, 0.37181899f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
