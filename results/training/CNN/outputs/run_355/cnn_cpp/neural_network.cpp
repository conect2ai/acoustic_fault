#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.10104024f, 0.43757308f, 0.77342588f, 0.10689094f, -0.49571672f, 0.14344263f, 0.06618115f, -0.27230060f, 
    -0.14505567f, -0.31035313f, 0.09308919f, 0.09680640f, -0.19938508f, 0.12884800f, 0.04998794f, -0.27452546f, 
    -0.14749037f, -0.27751067f, -0.17153794f, 0.01802298f, 0.17662258f, 0.22665069f, 0.21455401f, 0.11155868f, 
    0.05245434f, 0.73364615f, 0.18497021f, -0.09480115f, 0.64477271f, 0.50435668f, -0.26509768f, -1.04442716f, 
    0.27308685f, -0.26563874f, -0.33248273f, 0.14368986f, 0.12598501f, 0.20046319f, -0.16085003f, -0.33495066f, 
    0.04551787f, -0.11819737f, -0.19925569f, -0.18853337f, -0.23838317f, -0.24449818f, -0.07645991f, 0.15512393f, 
    -0.45326826f, -0.17856841f, -0.39507064f, 0.53309381f, 0.80254638f, 0.56075454f, -0.46506351f, -0.31067550f, 
    0.10981491f, -0.23452160f, 0.01108481f, -0.23535991f, 0.11404768f, 0.44630313f, 0.15079036f, 0.01280933f, 
    0.33842310f, 0.24086055f, 0.26900405f, 0.24865426f, 0.03077825f, -0.23818704f, 0.10382916f, 0.04018077f, 
    -0.45603934f, 0.02837293f, 0.02916040f, -0.20959759f, -0.29485267f, -0.41433421f, -0.37200695f, 0.54432279f, 
    -0.64113456f, -0.47106311f, -0.16598028f, -0.68709356f, -0.16626346f, 0.12406502f, 0.35555729f, 0.07158709f, 
    0.15285146f, 0.29704562f, 0.10949504f, 0.17858224f, 0.02559118f, 0.21105595f, 0.32340515f, 0.12049022f, 
    -0.00254242f, -0.03038809f, 0.26657337f, 0.50797844f, 0.85326767f, -0.07769039f, -0.67083794f, -1.15651906f, 
    -0.04042841f, 0.19663328f, -0.06100437f, 0.45203567f, 0.12678944f, -0.07194630f, -0.38725209f, -0.02139674f, 
    -0.16041766f, -0.12760563f, -0.11213392f, -0.13746639f, -0.05840718f, -0.05974379f, -0.00305415f, -0.09674365f, 
    0.08115580f, 0.24505296f, -0.10356998f, -0.08948550f, 0.13342597f, -0.53521734f, 0.50175107f, 0.39867729f, 
    -0.12674698f, 0.32154661f, -0.69228268f, 0.02202383f, 0.00436140f, -0.77046400f, -0.44087711f, 0.12382587f, 
    0.19658747f, 0.13460186f, 0.37154967f, -0.20954002f, -0.15186253f, -0.29869765f, 0.14519201f, -0.05730966f, 
    0.32908496f, -0.21635711f, -0.06168733f, 0.21188232f, 0.12372847f, -0.05464803f, -0.80506855f, -0.48979014f, 
    0.27132237f, 0.93990034f, 0.19468580f, 0.82235318f, 0.80982167f, 0.30031943f, 0.58258986f, 0.12300430f, 
    -0.06486849f, 0.07738180f, 0.12725249f, 0.40144348f, 0.01158773f, -0.03299288f, 0.05506271f, -0.04760313f, 
    -0.32651129f, -0.04377518f, -0.10482147f, -0.02977522f, -0.06047618f, 0.03443530f, -0.03969707f, 0.57911998f, 
    0.58921951f, 0.80050731f, 0.38038781f, -0.06776640f, -0.56144220f, 0.16717312f, -0.77872348f, -0.58431685f, 
    0.15193261f, 0.26128042f, 0.14700165f, -0.32590121f, 0.06079303f, -0.13269880f, 0.10443418f, -0.23080224f, 
    -0.18928023f, -0.11211627f, -0.28691676f, 0.06796508f, 0.35909456f, 0.37262231f, -0.06343709f, 0.09876678f, 
    0.68222529f, -0.41374967f, -0.59121537f, -0.27995569f, 0.49193606f, 1.00659680f, -0.15849084f, -0.74863529f, 
    0.09079342f, -0.14156583f, -0.52547282f, 0.53262311f, -0.01764941f, 0.29655367f, 0.29070222f, -0.10595703f, 
    -0.21061131f, -0.12983224f, 0.14731041f, 0.13030472f, 0.20928837f, -0.15714227f, -0.11577374f, 0.04812643f, 
    -0.07293833f, -0.62310952f, -0.88099784f, -0.53375787f, -0.17300273f, -0.33271402f, -0.01990882f, 0.81222630f, 
    0.44355500f, -0.16837692f, 0.27630278f, -0.11639021f, 0.05942639f, -0.08934507f, -0.02193912f, 0.02848116f, 
    -0.05452287f, -0.03409973f, -0.22427705f, 0.05060859f, -0.05532417f, 0.31560466f, 0.31632942f, -0.15326488f, 
    0.28718919f, 0.03778502f, 0.98294246f, 0.45861092f, 0.59515804f, 0.90000981f, 0.69142205f, 0.00186220f, 
    0.38466030f, 0.03622457f, -0.19466101f, -0.05736861f, -0.00791974f, -0.06288879f, -0.06137346f, 0.12454751f, 
    -0.00131407f, -0.13371997f, -0.06637936f, 0.09863978f, 0.32349166f, 0.07700916f, 0.15288945f, 0.00618357f, 
    -0.15045030f, 0.01236620f, 0.07232411f, -0.41742021f, -0.23932336f, -0.41513017f, -0.53604943f, -0.16421063f, 
    -0.36756250f, 0.36706790f, -0.13174449f, 0.62255198f, 0.30138850f, 0.18490988f, 0.17534323f, -0.21790576f, 
    -0.43671483f, -0.10655157f, 0.13100111f, -0.05541941f, -0.13968515f, 0.08263409f, -0.05547452f, -0.39154726f, 
    -0.32308787f, -0.21829683f, -0.11872306f, -0.45801991f, -0.64164072f, -0.64084446f, -0.87838376f, -0.59422326f, 
    -0.41986257f, -0.17010316f, -0.39783412f, -0.15171942f, 0.03293092f, 0.03648715f, -0.22835009f, -0.02971041f, 
    0.20249084f, 0.29044643f, -0.18890786f, -0.15170114f, 0.24130952f, 0.06432049f, -0.13146487f, 0.49892026f, 
    -0.05617531f, 0.34021458f, -0.12263355f, 0.05326197f, -0.16695112f, 0.47691727f, 0.85707432f, 0.61175096f, 
    0.23113067f, -0.06303566f, -0.17834970f, 0.03810780f, 0.23668511f, -0.11265966f, 0.47319272f, 0.13415581f, 
    0.20663977f, 0.30485758f, 0.15623224f, 0.15564169f, -0.08472852f, 0.03675225f, -0.00761493f, 0.16700450f, 
    -0.08309120f, -0.14846207f, -0.01012223f, 0.04499727f, 0.22669208f, 0.20014831f, 0.52120364f, -0.25751597f, 
    -0.56769580f, 0.78269923f, 0.09903616f, -0.17931224f, -0.51843458f, 0.01328918f, 0.37036651f, 0.39282289f, 
    -0.02767244f, -0.15988658f, 0.13877110f, 0.04123436f, 0.14112976f, 0.12437653f, 0.14151682f, -0.14004669f, 
    0.07961811f, 0.61687708f, -0.26454684f, 0.11997338f, -0.17435086f, -0.01637669f, -0.54058582f, -0.17169616f, 
    -0.85698140f, -0.18866038f, 0.48746231f, 0.19816846f, -0.30838418f, 0.17052145f, 0.37752965f, -0.82025337f, 
    0.27577171f, 0.42432356f, 0.26624176f, 0.11756878f, 0.00844228f, 0.07270537f, -0.43579751f, -0.04939561f, 
    0.05881009f, 0.09113187f, -0.19168803f, -0.23062530f, -0.24309911f, -0.01025561f, 0.01215881f, -0.14464955f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15472679f, -0.06752862f, -0.02615888f, 0.42889178f, 0.13967744f, 0.07211413f, 0.08429513f, 0.34738642f, 
    0.29275709f, 0.15027329f, 0.01473517f, -0.00574604f, 0.38631308f, 0.21310456f, 0.19079620f, 0.25749183f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.46572471f, -0.03280009f, -0.11261037f, 0.06949598f, 0.11586241f, -0.01372719f, -0.03489434f, -0.19891854f, 
    0.03735133f, -0.06591753f, 0.27242625f, 0.22539544f, -0.14283931f, 0.24904165f, -0.22395182f, -0.26305705f, 
    -0.02571370f, 0.01467807f, -0.10599392f, 0.03958213f, 0.00214914f, 0.12114102f, 0.12445895f, 0.02621842f, 
    0.32509506f, 0.23233907f, 0.29402405f, -0.05408960f, -0.03785145f, -0.03887245f, 0.11076324f, -0.10587369f, 
    0.05326949f, 0.06213912f, -0.01441673f, -0.19023770f, 0.15950656f, -0.07325661f, -0.23603238f, 0.12984234f, 
    0.05753591f, -0.05186115f, 0.16404952f, 0.06596049f, 0.08962815f, -0.04056407f, 0.03723541f, -0.14372599f, 
    -0.40431139f, 0.50837213f, -0.01737489f, 0.49428025f, -0.01957186f, 0.05775249f, 0.09008577f, 0.02391410f, 
    0.05047618f, 0.00579274f, -0.02059267f, 0.13665906f, 0.25274423f, -0.10081486f, -0.14117129f, 0.25103328f, 
    0.03683973f, 0.08486876f, 0.02890104f, 0.03321008f, -0.04042189f, 0.00295774f, -0.02303988f, -0.07625291f, 
    0.19886550f, -0.23431641f, -0.06694379f, 0.01065231f, 0.04226165f, 0.00908271f, 0.00078536f, 0.12143686f, 
    -0.02667715f, 0.12974402f, -0.04170773f, 0.09663323f, 0.29795355f, 0.18780915f, 0.20074400f, -0.22425227f, 
    0.01438095f, 0.07053753f, -0.10328833f, -0.00793657f, -0.00345377f, 0.09994877f, 0.14748843f, 0.20811473f, 
    -0.21741338f, 0.02049992f, 0.09119570f, 0.02795364f, 0.07706411f, 0.10895796f, 0.05971437f, 0.12179056f, 
    0.16262415f, -0.05023956f, 0.10593903f, -0.00334650f, -0.12062212f, 0.07108139f, 0.08898406f, 0.11513748f, 
    0.01255926f, 0.18857281f, 0.01668671f, 0.05505398f, 0.09368834f, -0.02033038f, 0.07510173f, 0.05196071f, 
    0.08032322f, 0.28653467f, -0.04700293f, -0.30218124f, 0.18718164f, -0.05212982f, 0.02278787f, 0.00626587f, 
    -0.03446316f, 0.04582840f, -0.12916663f, -0.03475288f, -0.19204009f, -0.22805779f, -0.01665075f, 0.16624214f, 
    0.10036151f, 0.04059051f, 0.25795820f, 0.18252368f, -0.02238541f, 0.22600864f, 0.18459946f, -0.07432287f, 
    0.03482458f, -0.02347878f, 0.12179154f, 0.29359618f, 0.01594731f, 0.15380974f, -0.00666056f, -0.16801396f, 
    0.05969652f, 0.01722092f, -0.09013277f, 0.01389351f, 0.15160219f, 0.30952707f, 0.09061090f, -0.16973692f, 
    0.06511248f, 0.07958532f, 0.06698178f, -0.03469092f, -0.02997000f, 0.08782133f, -0.01300240f, -0.01385965f, 
    -0.15657623f, 0.03146419f, -0.02097685f, -0.10139158f, 0.08165656f, 0.25016835f, 0.07473560f, 0.13250999f, 
    0.08731665f, -0.04883875f, -0.02485989f, -0.04782155f, 0.32335839f, 0.07145814f, -0.25542191f, -0.07909139f, 
    0.07255660f, 0.04642300f, 0.16074648f, 0.09642528f, 0.13004608f, 0.13528323f, -0.01324141f, 0.05836141f, 
    -0.09125348f, 0.02626656f, -0.15617155f, -0.16915660f, 0.20444536f, -0.12045399f, -0.03182119f, -0.13187610f, 
    -0.01174638f, -0.07557869f, -0.02853613f, 0.07916596f, -0.19085345f, -0.01349536f, -0.06655006f, 0.07191443f, 
    -0.20136173f, 0.08000875f, 0.13843781f, 0.08761926f, -0.03250125f, -0.04913897f, 0.06541470f, 0.12479404f, 
    0.28414232f, -0.06135059f, 0.17832585f, -0.11638528f, 0.06787895f, 0.04625754f, 0.00724978f, 0.12088337f, 
    0.08242530f, -0.07683224f, 0.02894628f, -0.09472261f, -0.07768942f, -0.13693206f, -0.09129774f, -0.06231000f, 
    0.03799586f, 0.04607922f, 0.16088538f, 0.01314553f, 0.23516078f, 0.03327513f, 0.10752299f, -0.04282144f, 
    -0.12488457f, 0.34654206f, 0.24942522f, 0.32249388f, -0.12903543f, 0.20574111f, -0.04606354f, 0.24236426f, 
    0.14429228f, 0.02204441f, 0.01336908f, 0.00494580f, 0.27787265f, -0.51704723f, -0.09122448f, -0.17656805f, 
    -0.07681865f, -0.18740086f, 0.03783130f, 0.08165130f, -0.09065210f, 0.04564376f, -0.04988906f, 0.10240650f, 
    0.13209702f, 0.10221010f, -0.09103718f, 0.26128542f, 0.02783704f, -0.10238180f, -0.07597143f, 0.00693170f, 
    0.09127442f, 0.02624830f, 0.04591507f, 0.11402012f, -0.57072127f, 0.09040176f, 0.48778790f, -0.18254338f, 
    0.08553337f, -0.00208287f, 0.02652228f, -0.05374702f, 0.11125401f, -0.03480434f, 0.12617554f, 0.08058214f, 
    -0.42240456f, 0.68417937f, -0.33015779f, 0.12616237f, 0.08931958f, 0.01871099f, 0.09185071f, 0.06468832f, 
    0.04594574f, 0.06133955f, 0.14007571f, 0.12576529f, -0.22788158f, -0.11823527f, 0.02413696f, 0.01730030f, 
    0.13253365f, 0.09709583f, -0.15050374f, -0.01825793f, -0.11250314f, 0.05934568f, 0.01474898f, 0.00499170f, 
    -0.29546836f, 0.26887468f, -0.11719334f, -0.16358292f, 0.20378387f, -0.09334367f, 0.11808002f, -0.16851403f, 
    0.04245906f, -0.06582871f, -0.03628471f, -0.17937724f, -0.31959191f, -0.28668758f, 0.07069926f, 0.25845313f, 
    0.12825002f, 0.12952453f, 0.05893020f, 0.09199965f, -0.02838822f, 0.04882498f, 0.09768093f, 0.06814367f, 
    -0.31084460f, -0.37644491f, 0.35192019f, 0.18011561f, 0.19788036f, 0.09896423f, 0.05008622f, 0.20296934f, 
    -0.05531886f, 0.11443514f, -0.09171686f, 0.11927025f, 0.12034222f, -0.05543938f, 0.24245860f, -0.00626590f, 
    0.07478844f, 0.12376098f, 0.09036238f, -0.07500516f, 0.00434114f, -0.00873172f, 0.03079432f, -0.05086846f, 
    -0.32840115f, -0.06469321f, 0.25696880f, 0.02735582f, 0.09845634f, 0.13549188f, 0.01412489f, -0.01620818f, 
    0.07965854f, -0.00684907f, 0.02028445f, 0.06578995f, -0.23015687f, 0.01318095f, -0.17160034f, -0.22591014f, 
    0.10441956f, -0.02159056f, 0.10067103f, -0.07687949f, 0.02377431f, 0.00671363f, 0.20660141f, -0.05986846f, 
    -0.18442817f, 0.09591506f, 0.28289557f, 0.04494273f, 0.01981265f, 0.03329754f, 0.08934123f, 0.07353331f, 
    0.06687026f, 0.02698396f, 0.02466793f, 0.03950948f, 0.17160681f, -0.07613257f, 0.15650125f, 0.37834200f, 
    -0.03887491f, 0.00708300f, -0.11702713f, 0.13576633f, 0.08483877f, 0.06733336f, -0.01175834f, -0.14171150f, 
    -0.24131329f, 0.14914729f, -0.11784814f, 0.11378887f, 0.05178165f, 0.08850626f, 0.10362506f, -0.09666270f, 
    0.07483221f, 0.19436121f, -0.11378285f, 0.05072269f, -0.32732883f, -0.03716529f, 0.14354458f, -0.21022131f, 
    -0.08062649f, -0.02929667f, -0.01434899f, 0.10498167f, 0.02619285f, 0.03576376f, -0.06080932f, -0.00782763f, 
    0.35683012f, -0.08218601f, 0.02915471f, -0.73689222f, 0.07359513f, -0.00909046f, -0.00065479f, -0.00760010f, 
    -0.02456909f, 0.01164576f, 0.13355801f, 0.06074465f, -0.32810122f, 0.13059080f, 0.15085499f, -0.27800038f, 
    0.05279443f, 0.03575484f, -0.03037599f, -0.03341317f, -0.04781731f, -0.03360845f, 0.05599018f, -0.02023780f, 
    -0.08076569f, 0.32919049f, -0.12521939f, 0.23588672f, 0.03377168f, -0.06210735f, -0.01734874f, -0.06215290f, 
    0.07015175f, -0.04410358f, 0.07452065f, -0.08611212f, 0.08785440f, 0.07555193f, -0.14617749f, 0.27935475f, 
    -0.03784041f, -0.03454237f, -0.01123241f, 0.00998467f, 0.02659435f, 0.00611091f, -0.09834248f, 0.10945553f, 
    0.10835961f, 0.15433082f, 0.13900886f, -0.03579297f, -0.13968599f, 0.03224656f, 0.07414718f, -0.14271782f, 
    -0.10135984f, 0.06575682f, -0.03496439f, 0.06008694f, -0.21509464f, 0.12603225f, 0.00509631f, -0.06643660f, 
    0.03273329f, 0.02277134f, 0.13992779f, 0.17004131f, 0.10684955f, -0.03805726f, -0.00078600f, -0.02942271f, 
    0.45593184f, -0.05570506f, -0.08262108f, 0.68240488f, -0.02024720f, -0.01368867f, -0.02354998f, -0.13386692f, 
    0.03715726f, -0.00157524f, 0.25823501f, -0.01867648f, 0.18636389f, 0.30185959f, -0.09977399f, -0.19863269f, 
    0.10794868f, 0.10152992f, -0.07390910f, 0.09710100f, 0.08256212f, -0.07506189f, -0.09297208f, 0.02892097f, 
    -0.37882236f, -0.27589631f, 0.03032395f, -0.26068112f, -0.03225058f, -0.02570278f, 0.11292640f, 0.17488250f, 
    -0.07291011f, -0.12213622f, -0.06271612f, -0.02676007f, 0.25897813f, 0.00758547f, -0.13072221f, 0.03804413f, 
    0.09665141f, 0.00893299f, 0.01412481f, -0.08047615f, 0.00165919f, 0.03183430f, 0.12496854f, -0.00982293f, 
    0.14660117f, -0.12876721f, 0.06759357f, 0.47106245f, 0.01277363f, -0.02141439f, -0.07626893f, 0.00580820f, 
    -0.22139847f, 0.02997421f, 0.06677086f, 0.12661952f, -0.39934498f, -0.18939491f, 0.03379182f, 0.14115046f, 
    -0.05735193f, -0.06223525f, -0.02590723f, -0.05162588f, 0.09336352f, 0.01790656f, -0.00817061f, -0.08639197f, 
    -0.00045840f, -0.02365077f, 0.06124594f, -0.08143934f, -0.00548313f, 0.00230095f, -0.05482404f, 0.03198797f, 
    0.03632084f, 0.02690713f, 0.05641873f, 0.04460902f, -0.07044866f, 0.00754568f, 0.06970801f, -0.05093024f, 
    -0.00943181f, -0.06393599f, 0.02835101f, 0.03934536f, -0.05098916f, -0.06465392f, -0.03694669f, 0.04649617f, 
    0.04075846f, -0.06085449f, -0.05211392f, -0.04457836f, -0.07441344f, -0.05894078f, -0.04402296f, -0.07002578f, 
    0.03108892f, -0.03170629f, 0.04785222f, -0.06594791f, -0.04002905f, -0.02025658f, -0.02610254f, -0.09057525f, 
    -0.09685694f, -0.03607617f, -0.05008618f, 0.02178269f, -0.02042786f, -0.04320061f, 0.02485563f, -0.07467724f, 
    -0.07429565f, 0.05458031f, -0.06859713f, -0.02301353f, -0.00824435f, 0.05864052f, 0.04625008f, 0.03419641f, 
    -0.09154063f, 0.00210495f, -0.02177602f, 0.01213721f, 0.04815133f, -0.07263947f, 0.01378501f, -0.06228661f, 
    -0.03272905f, 0.00023102f, 0.00869190f, -0.10060868f, -0.00107391f, -0.00259286f, 0.02737528f, -0.00227418f, 
    0.05869326f, -0.04278152f, -0.03747176f, -0.07296343f, 0.03118260f, -0.05390113f, 0.02410766f, -0.09232065f, 
    -0.06892192f, -0.06114442f, 0.01781273f, 0.00449456f, 0.02327429f, 0.02980657f, 0.02786048f, -0.01572001f, 
    0.05526625f, 0.03134400f, -0.03941227f, -0.01741210f, 0.02328930f, -0.00104225f, 0.03158923f, -0.06445073f, 
    0.04177007f, 0.05723053f, -0.03056912f, 0.08048820f, -0.03598478f, -0.08683447f, -0.05000281f, -0.04564903f, 
    -0.07712255f, -0.03804519f, -0.10349756f, 0.03257537f, -0.05243937f, -0.06313911f, -0.09224312f, -0.01660539f, 
    0.06873710f, -0.05318001f, -0.04746051f, -0.00751672f, 0.02115878f, -0.05310876f, -0.06103761f, -0.07994737f, 
    0.05079082f, 0.02740093f, 0.00327656f, 0.01507571f, -0.02422166f, 0.02610889f, 0.01022261f, -0.07682290f, 
    0.00693279f, -0.00452775f, -0.08414386f, -0.05927386f, -0.10489579f, -0.05347669f, -0.01633533f, 0.00856137f, 
    -0.01062432f, -0.09101269f, -0.07980168f, -0.00597353f, 0.01714726f, -0.00948576f, -0.06619935f, 0.07014450f, 
    0.02706193f, -0.02288389f, -0.04194798f, 0.01403531f, -0.06883620f, -0.05770836f, -0.07554585f, 0.00534256f, 
    0.01435967f, -0.01218960f, -0.08446971f, 0.02061376f, -0.03244334f, 0.01852576f, 0.03303596f, 0.00256692f, 
    0.01102974f, 0.04951275f, 0.04541384f, -0.01612300f, -0.04353642f, -0.05783260f, -0.03245248f, -0.08410329f, 
    0.02612498f, -0.06207059f, 0.02689324f, -0.06874707f, -0.01050165f, 0.01811225f, -0.08001760f, 0.03057141f, 
    -0.00742263f, 0.00389599f, -0.08051628f, -0.02637137f, -0.04014291f, 0.02630551f, -0.05125950f, -0.08158484f, 
    0.04900606f, -0.07755062f, -0.05683000f, 0.05291905f, 0.02708505f, -0.04475656f, -0.06880893f, -0.08575203f, 
    -0.11872252f, -0.07312475f, 0.09546581f, -0.15077183f, -0.10764387f, 0.16482310f, -0.01289176f, 0.07015830f, 
    -0.13384849f, -0.05143254f, 0.04935439f, 0.01191833f, -0.03866206f, 0.02749090f, 0.03548102f, 0.18719999f, 
    -0.09092846f, -0.11359234f, 0.02372025f, 0.16125621f, 0.10213443f, 0.12864578f, 0.04177051f, 0.14853388f, 
    0.10476688f, -0.11871924f, 0.10309880f, -0.18642959f, -0.14909467f, 0.16782027f, -0.02063105f, -0.09290920f, 
    0.02839468f, 0.06701961f, -0.18412063f, 0.23132578f, -0.28055468f, -0.20199236f, 0.11690906f, 0.29740348f, 
    0.09091999f, -0.02220193f, 0.09745432f, 0.04151456f, -0.07478460f, -0.02661644f, 0.11506129f, 0.03589194f, 
    0.35512552f, -0.43787897f, 0.03129184f, -0.38313714f, 0.10804151f, -0.09181929f, 0.09875159f, -0.06471416f, 
    -0.12222243f, 0.06790719f, 0.19850841f, 0.14942989f, -0.47287619f, -0.08505940f, -0.10287999f, 0.10608290f, 
    -0.09950548f, -0.09393586f, 0.00313348f, -0.13186184f, -0.15670396f, -0.04104953f, 0.01819465f, 0.05087530f, 
    -0.32649019f, 0.39018121f, -0.14587571f, -0.01289945f, 0.20466679f, 0.07063074f, 0.08165260f, 0.16917191f, 
    -0.02581694f, 0.11364542f, 0.14113209f, 0.04236256f, 0.26298928f, 0.15207683f, 0.05502455f, 0.15571874f, 
    -0.10382655f, -0.06046315f, 0.05077688f, 0.07589406f, 0.17559275f, 0.01333420f, 0.02604916f, -0.01383418f, 
    0.23516487f, -0.22385827f, -0.08713181f, 0.02579711f, -0.06796179f, -0.01368519f, -0.01649313f, 0.06341960f, 
    -0.00653068f, 0.06211616f, -0.03490093f, 0.07556760f, -0.38434950f, 0.08985488f, -0.25394252f, 0.19899581f, 
    0.12341841f, -0.10961454f, -0.04186636f, 0.00221999f, -0.05126357f, -0.05489162f, -0.10906230f, -0.04080417f, 
    0.68127590f, 0.09097032f, 0.27593976f, 0.26328757f, 0.05903589f, 0.00467913f, 0.08046971f, 0.16820516f, 
    0.19421974f, 0.13201831f, -0.09164626f, -0.08024757f, 0.07971553f, -0.05197142f, -0.10004645f, 0.26003370f, 
    -0.11149374f, -0.15932389f, 0.10639208f, 0.18346408f, -0.00610180f, 0.12558943f, 0.12309241f, -0.02530483f, 
    0.01798964f, -0.06991903f, -0.05881590f, 0.04139330f, 0.05002706f, 0.18623941f, 0.04364814f, 0.22479850f, 
    0.06077115f, 0.04207955f, 0.03326897f, 0.12842929f, 0.40783742f, 0.26266864f, 0.07785138f, 0.11558393f, 
    0.01977606f, -0.19856893f, 0.09907207f, 0.05452706f, 0.08582246f, 0.07984187f, 0.06086086f, -0.13654494f, 
    0.23189966f, 0.01988290f, -0.01459727f, 0.18357798f, -0.01450552f, -0.01285714f, 0.05764307f, -0.10227302f, 
    0.16399392f, -0.00240705f, 0.02976849f, -0.02412491f, -0.55495942f, 0.11268350f, -0.02739049f, 0.19336948f, 
    0.20620166f, -0.09879218f, -0.04010743f, 0.05987335f, -0.13310869f, -0.13058098f, 0.01179064f, -0.00100468f, 
    -0.04347795f, -0.02417314f, -0.05610532f, -0.06638344f, -0.04683716f, 0.03747784f, 0.01143528f, -0.04417549f, 
    0.01599600f, -0.03331959f, 0.02934779f, 0.03906775f, 0.02296768f, -0.03085245f, 0.06203699f, -0.07736958f, 
    0.03186987f, -0.01536234f, 0.02068154f, 0.05717415f, 0.05373461f, 0.01192738f, -0.06779514f, 0.03761995f, 
    0.03798838f, -0.00735008f, -0.00825241f, -0.05587566f, 0.04946867f, 0.03278676f, -0.02334880f, -0.03362057f, 
    -0.04327162f, -0.07088970f, -0.00107527f, 0.03427064f, -0.06687140f, -0.06830034f, -0.03068017f, 0.03065014f, 
    -0.03725601f, 0.00560927f, -0.04467780f, 0.03315582f, -0.01388681f, 0.01394331f, 0.02562741f, 0.03542850f, 
    -0.00371429f, -0.00895325f, 0.05974568f, -0.07317433f, -0.08076347f, -0.00521543f, 0.04199373f, 0.02566162f, 
    0.05245701f, 0.05260225f, 0.03256684f, -0.04075756f, 0.03344274f, -0.04883235f, -0.05669959f, -0.03235481f, 
    -0.04207364f, -0.05468549f, 0.05605070f, -0.00611631f, 0.03159799f, -0.02141058f, 0.00618824f, -0.00274752f, 
    -0.03862756f, 0.02253800f, 0.00896940f, -0.06880918f, -0.06667073f, 0.00608681f, -0.07915782f, -0.03869587f, 
    -0.03917538f, -0.00307201f, -0.06105160f, 0.00184040f, 0.04875042f, -0.04852558f, 0.03450807f, -0.00932882f, 
    -0.04020245f, -0.01037965f, -0.02808023f, -0.03639714f, -0.03037018f, -0.00411174f, -0.05736237f, 0.03203073f, 
    0.02115618f, 0.04570877f, -0.06639572f, -0.05784492f, -0.03395110f, -0.07284758f, 0.02963609f, 0.06202124f, 
    0.03521759f, -0.05412030f, -0.00828706f, -0.07300321f, -0.04549431f, -0.01952153f, -0.01818337f, -0.05625867f, 
    -0.07114408f, -0.07285633f, -0.05296105f, -0.04166245f, 0.05224496f, 0.02509883f, 0.00680170f, 0.00506924f, 
    -0.03773427f, -0.06263467f, -0.03100118f, 0.02639665f, 0.03656598f, 0.02247471f, -0.01347421f, -0.00981590f, 
    -0.00740355f, -0.02607295f, 0.03864227f, 0.03921906f, 0.05675888f, -0.04885394f, -0.05607125f, -0.01587408f, 
    -0.00820499f, 0.00432302f, 0.03581868f, 0.00491518f, -0.00672110f, -0.00537348f, -0.01176443f, -0.08399293f, 
    0.05416599f, 0.05882753f, 0.04701103f, -0.00246645f, 0.04599834f, -0.00025915f, 0.00241974f, -0.03413088f, 
    -0.06542342f, 0.03423574f, 0.05085684f, -0.04810143f, -0.05715498f, 0.00644894f, 0.02327864f, 0.04376334f, 
    -0.05142520f, 0.04218387f, 0.03396771f, -0.04401514f, -0.04436339f, -0.02928769f, -0.07609836f, -0.05357543f, 
    -0.03416512f, -0.01995243f, 0.00399708f, 0.04817076f, -0.03856904f, 0.01459617f, 0.02418881f, 0.01214401f, 
    -0.03366683f, 0.04446708f, -0.06564087f, 0.05999956f, -0.04691214f, -0.03559077f, -0.00412420f, -0.04473184f, 
    0.02212626f, -0.03946199f, -0.00655765f, 0.01543327f, -0.01498969f, -0.03373405f, -0.04177044f, 0.05497025f, 
    0.14828809f, 0.11294506f, -0.14787984f, -0.26395041f, -0.07802170f, 0.04709772f, 0.02748316f, 0.02575492f, 
    0.08346215f, -0.06495149f, 0.15414146f, 0.08718767f, 0.28049496f, 0.07667916f, -0.00354040f, 0.13906485f, 
    0.11024930f, 0.14588116f, -0.01991571f, 0.06587989f, 0.05364665f, 0.11063761f, 0.09962132f, -0.19204429f, 
    -0.19458403f, 0.15051511f, -0.23712586f, 0.11073261f, -0.13746732f, 0.15873848f, 0.14657265f, -0.03215371f, 
    -0.14296702f, 0.02415634f, -0.08052445f, -0.12127521f, 0.25195941f, 0.03002910f, -0.01018072f, -0.09472238f, 
    0.14576301f, 0.13115174f, 0.07902704f, -0.00614732f, 0.16723262f, 0.02490176f, 0.05332040f, -0.18370986f, 
    -0.33205503f, 0.06773403f, 0.06753057f, -0.00553996f, 0.01965874f, -0.12710659f, 0.27498618f, 0.06380740f, 
    -0.10036466f, -0.02268099f, -0.01931915f, 0.16998115f, -0.23750861f, 0.43618846f, -0.09564507f, -0.24523132f, 
    0.15729670f, 0.02900038f, -0.05982447f, 0.14175034f, 0.07144410f, 0.01862688f, 0.08746552f, -0.08324023f, 
    0.36056814f, 0.35297018f, -0.33679444f, 0.13234615f, -0.04398258f, 0.11273167f, -0.15419725f, 0.02775788f, 
    0.05215307f, -0.00009564f, 0.03395960f, 0.05646837f, -0.26712745f, 0.18162093f, 0.05523973f, -0.00638878f, 
    -0.04373487f, 0.25085366f, -0.06493202f, -0.05102069f, 0.01979817f, -0.06141606f, 0.10128855f, 0.02622388f, 
    -0.20310006f, -0.00200680f, 0.13186044f, -0.02162871f, 0.13325955f, 0.16470160f, 0.11455643f, -0.06130835f, 
    -0.10477062f, -0.00237163f, -0.03752345f, -0.05033232f, 0.33093357f, -0.04522363f, 0.08824627f, 0.12552853f, 
    -0.17400131f, -0.15192614f, -0.06118652f, 0.01826817f, 0.00496456f, 0.01772130f, 0.04591279f, 0.07782473f, 
    -0.06162456f, 0.06367593f, -0.12049706f, 0.05688684f, 0.02916951f, 0.00370113f, 0.04659783f, 0.00703177f, 
    0.03908636f, -0.02170761f, -0.10744686f, -0.03756730f, -0.06841682f, -0.16482969f, -0.06186096f, 0.11009806f, 
    0.00338151f, 0.25151652f, 0.05989743f, 0.23078470f, 0.05246507f, -0.01922634f, 0.14204708f, -0.07941390f, 
    -0.14961128f, -0.06716120f, -0.11562990f, -0.20135151f, -0.26506716f, -0.08818024f, -0.03396983f, 0.15916835f, 
    0.01351057f, 0.10865510f, 0.05949314f, 0.02664509f, -0.24005392f, 0.04616099f, -0.01943948f, 0.21254209f, 
    -0.08072271f, 0.09654550f, 0.20823218f, 0.03631515f, -0.08709769f, 0.08475722f, -0.04417142f, 0.04335171f, 
    -0.07214405f, 0.04787734f, 0.05100585f, 0.16592926f, 0.08495934f, 0.20945999f, 0.18008171f, 0.05659849f, 
    -0.01227997f, -0.16793829f, 0.10291432f, 0.16588613f, 0.16698919f, -0.09893873f, 0.10087513f, 0.19924620f, 
    -0.01880810f, 0.06477316f, -0.15075548f, 0.06248995f, 0.00757540f, 0.19511719f, -0.03450321f, -0.03049391f, 
    0.15704982f, -0.04494810f, 0.23895900f, 0.19456843f, 0.04136444f, 0.02352527f, 0.00488538f, 0.09498751f, 
    0.07333015f, 0.11751855f, 0.12109786f, 0.00411628f, 0.05862745f, 0.18322942f, 0.19865060f, -0.18694636f, 
    0.05054207f, -0.08171017f, 0.10472389f, -0.03789671f, 0.06252294f, 0.08494291f, 0.04557106f, 0.04856085f, 
    0.43487006f, -0.01234169f, 0.29236701f, 0.03278150f, 0.15358701f, -0.04636484f, -0.09933105f, 0.08478799f, 
    0.05201629f, 0.04274137f, 0.01299387f, 0.08107871f, -0.16793074f, 0.29169083f, -0.11340377f, -0.02489974f, 
    0.01795240f, 0.09984210f, -0.05758570f, -0.03050467f, -0.05958257f, 0.03782307f, -0.00711387f, 0.08069998f, 
    0.08535890f, 0.02384515f, -0.33170378f, -0.09194352f, 0.15560576f, -0.03652057f, -0.11910976f, 0.07850926f, 
    0.16018771f, 0.02894613f, -0.01910352f, 0.17907929f, 0.08828956f, 0.06834155f, -0.01276656f, 0.16574301f, 
    -0.00312584f, 0.28108102f, -0.00245938f, 0.09592535f, 0.10777321f, 0.16546229f, 0.09189232f, 0.04328575f, 
    -0.00810904f, -0.47197574f, 0.43663874f, 0.02154745f, 0.00493476f, -0.08755004f, 0.09196661f, -0.06926615f, 
    -0.10948335f, -0.08666258f, 0.11597481f, -0.07685179f, 0.47400215f, 0.12179013f, -0.19715130f, 0.15124045f, 
    0.10935929f, 0.04751762f, 0.14543782f, 0.19578898f, 0.02265215f, 0.22866029f, -0.06293039f, 0.06970624f, 
    0.20478415f, -0.23656705f, 0.16761848f, 0.07490244f, -0.04946946f, 0.13321450f, 0.00121945f, -0.06973266f, 
    0.15196253f, 0.01144198f, 0.19964230f, 0.02953297f, -0.15415536f, -0.05035017f, -0.18961293f, -0.09949029f, 
    0.05888447f, 0.04374158f, 0.18594563f, 0.11854494f, 0.06114049f, 0.03633348f, 0.04341526f, 0.04787607f, 
    0.27530640f, -0.01273069f, 0.30845475f, 0.20383802f, 0.03309292f, 0.06611443f, -0.01757699f, 0.11877509f, 
    -0.01989168f, 0.07146198f, 0.17957963f, 0.20942296f, -0.11148559f, -0.17448412f, -0.07838366f, -0.37290764f, 
    -0.00073415f, -0.04846812f, -0.08524822f, -0.06679790f, 0.07764905f, 0.07684740f, -0.08745099f, 0.09621795f, 
    -0.30248526f, -0.08241848f, -0.21522012f, -0.31836811f, 0.05237662f, -0.05478388f, 0.12033190f, -0.24570915f, 
    0.10038228f, -0.02559411f, 0.03575415f, 0.15687077f, 0.49022150f, 0.28026578f, 0.04862278f, 0.29638633f, 
    0.19985324f, 0.08232361f, -0.01376625f, 0.00247515f, -0.00940482f, 0.09023219f, 0.06494698f, 0.00712458f, 
    0.03658810f, 0.16554618f, 0.09449080f, -0.05031031f, -0.00180037f, -0.18956932f, 0.16326927f, 0.06727286f, 
    -0.01248721f, 0.17500679f, 0.03941534f, -0.02671964f, 0.02949122f, 0.13148387f, 0.12821931f, -0.04534992f, 
    0.01272304f, 0.05506003f, 0.22991437f, 0.06789398f, -0.01140759f, -0.03706109f, 0.12717099f, 0.06731877f, 
    -0.36436149f, 0.13134450f, 0.19507502f, 0.12873754f, -0.09154370f, 0.14074585f, -0.01118114f, 0.07858105f, 
    0.01336947f, 0.12991875f, -0.14235978f, 0.02861342f, 0.09123848f, 0.06611231f, 0.02403170f, 0.10245644f, 
    0.04982502f, 0.05523193f, 0.07626751f, -0.06748933f, 0.00828947f, -0.07324798f, -0.06491247f, 0.09259715f, 
    -0.16777748f, 0.22136316f, 0.01682294f, -0.01037426f, -0.14769965f, 0.19823150f, -0.11646993f, 0.04001335f, 
    0.07857580f, 0.10663059f, 0.08267435f, 0.09484737f, -0.02164716f, -0.03370814f, 0.13227718f, 0.12562801f, 
    0.10309533f, -0.13093601f, -0.07208721f, 0.06604817f, -0.02913891f, 0.04542389f, 0.15019286f, 0.19523242f, 
    0.24243720f, 0.06541003f, 0.28575954f, -0.19857384f, -0.07644244f, 0.04695075f, -0.02013809f, -0.06185670f, 
    0.01645779f, -0.04962685f, 0.09986512f, -0.07446393f, -0.03592537f, -0.05637303f, -0.04607182f, 0.11861595f, 
    0.00785271f, -0.11464376f, 0.01745628f, 0.02518221f, -0.06233268f, -0.08479533f, 0.07183883f, 0.15169260f, 
    -0.50720024f, 0.44552675f, -0.11698408f, -0.05301233f, 0.02338433f, 0.02336145f, 0.11720084f, 0.07119068f, 
    0.00279283f, -0.10253128f, -0.02905404f, 0.07372344f, 0.07159745f, 0.14711145f, 0.23240505f, 0.10754566f, 
    -0.08730740f, -0.11605979f, -0.02386669f, 0.03909484f, 0.05888778f, -0.09807624f, -0.07959525f, 0.03321254f, 
    -0.16745088f, 0.21142434f, 0.02440099f, 0.16896611f, 0.15559970f, -0.08070828f, 0.00853395f, 0.01612456f, 
    0.07254542f, 0.15855853f, 0.08223821f, 0.20675556f, -0.35564759f, 0.15031117f, -0.27750835f, -0.14204423f, 
    0.17664067f, 0.01417461f, -0.02581256f, 0.17312783f, 0.01807505f, 0.01728606f, -0.00780927f, -0.11998404f, 
    -0.05575086f, -0.12856798f, -0.00817200f, -0.02012544f, -0.07543784f, 0.08920257f, 0.01778053f, -0.05084845f, 
    0.07453375f, -0.03231022f, 0.02201773f, -0.08517121f, 0.41704583f, -0.02923500f, 0.05336153f, 0.03185826f, 
    0.05511441f, -0.03700806f, -0.00163118f, -0.08868701f, 0.07494197f, -0.03865747f, -0.15703146f, 0.00935046f, 
    0.20220026f, -0.29317579f, 0.05848214f, 0.22774960f, 0.23910122f, 0.06626083f, -0.06783883f, 0.04639906f, 
    0.08363387f, 0.05592603f, -0.01257323f, -0.06910421f, 0.13208638f, -0.10505117f, -0.03943415f, -0.09449615f, 
    -0.01774512f, 0.07340480f, -0.03453037f, 0.00671745f, -0.04207804f, -0.13820153f, 0.10213750f, -0.00192375f, 
    0.04531321f, -0.16055220f, 0.02127901f, 0.15556559f, 0.07314245f, -0.12579350f, -0.19987758f, -0.06155069f, 
    0.00546207f, -0.02547821f, 0.00851882f, 0.07869533f, -0.48389164f, 0.07479431f, -0.09107780f, -0.00246872f, 
    0.21291940f, 0.12336493f, -0.06446625f, -0.12157248f, -0.07101984f, -0.14569932f, 0.01455348f, -0.00400204f, 
    0.22742328f, 0.15713519f, 0.28736189f, 0.06388269f, 0.29800650f, -0.08485408f, -0.02312176f, 0.07208234f, 
    0.01843305f, 0.00925298f, 0.07840884f, 0.01843353f, 0.64450645f, -0.01934854f, 0.11009789f, 0.31959304f, 
    -0.08174317f, 0.30194902f, -0.00502593f, -0.02970132f, -0.06067044f, -0.00397670f, 0.03208653f, 0.03192368f, 
    0.00109926f, 0.12775663f, 0.10059208f, 0.20111565f, 0.19107433f, 0.08799237f, 0.11435302f, 0.16854174f, 
    -0.03419659f, 0.15196110f, 0.00231106f, -0.08702675f, -0.22269185f, 0.07109413f, 0.20502751f, 0.33327121f, 
    -0.04547277f, -0.11556866f, -0.00068546f, 0.01390520f, 0.18981843f, -0.11764534f, -0.16566052f, -0.13718157f, 
    0.07815126f, -0.00917203f, 0.05685768f, 0.04501306f, -0.07090561f, 0.13097173f, 0.21763422f, -0.01751219f, 
    0.04246144f, 0.15732889f, 0.02972728f, 0.24286501f, -0.07791062f, -0.13214400f, 0.40301451f, 0.07933790f, 
    0.09725147f, 0.09286240f, 0.01168230f, 0.27980161f, 0.07341778f, -0.02733498f, -0.00626731f, 0.12896761f, 
    -0.20784199f, -0.01440386f, -0.04105498f, -0.02196365f, 0.12327910f, -0.11600863f, 0.02360465f, 0.09389055f, 
    0.19399233f, -0.02700634f, -0.03224459f, -0.02717148f, -0.59420812f, 0.09783932f, 0.10866201f, 0.27146360f, 
    -0.00271047f, 0.06672567f, -0.07284073f, -0.01167987f, -0.01267995f, 0.07233472f, 0.05400502f, 0.09737361f, 
    -0.14463109f, 0.32220882f, -0.12879796f, 0.02172923f, 0.04412580f, 0.08315767f, 0.19469023f, -0.10277042f, 
    -0.00749878f, 0.00577441f, 0.15950225f, 0.17438209f, -0.09076013f, 0.11902130f, 0.15115723f, -0.37883037f, 
    0.10649935f, 0.00798207f, -0.00032504f, 0.06976230f, -0.02808702f, 0.00055397f, 0.09703915f, 0.16214201f, 
    -0.06405880f, -0.05179514f, 0.04233764f, -0.08688769f, -0.06993105f, -0.02904300f, 0.01609934f, -0.15056624f, 
    0.00744379f, -0.09305860f, 0.06699672f, -0.08136386f, -0.08105681f, 0.01830873f, 0.16224582f, 0.18355413f, 
    0.14175905f, 0.34605172f, 0.13112916f, 0.06603096f, 0.08697120f, 0.18320639f, 0.26655626f, 0.17505959f, 
    0.02867945f, -0.10240285f, -0.14682831f, 0.12454158f, 0.00686088f, -0.02746038f, 0.04399740f, 0.13402729f, 
    0.06601917f, 0.02102938f, -0.03082906f, 0.02603436f, -0.28878900f, -0.08717825f, -0.05797611f, 0.01664024f, 
    -0.09806877f, 0.11773911f, 0.07316130f, -0.00281128f, -0.04278540f, 0.01937253f, -0.04915344f, -0.11267328f, 
    0.17099510f, 0.19540048f, 0.07578216f, 0.15556586f, -0.09165701f, 0.24156511f, 0.17194396f, 0.09981060f, 
    -0.05598449f, -0.18003218f, 0.09365034f, -0.09886637f, -0.11841228f, 0.01544827f, 0.24070975f, -0.25527826f, 
    0.11197798f, 0.00143382f, -0.10640549f, 0.02935037f, 0.07697958f, 0.15881383f, 0.01594393f, -0.00616086f, 
    0.18341109f, 0.03715787f, 0.06529284f, 0.19583820f, 0.10107974f, 0.03494106f, -0.04359674f, -0.13020627f, 
    0.02372045f, 0.00559761f, 0.12674494f, 0.16246118f, 0.07365907f, -0.04057338f, -0.15771046f, 0.18336467f, 
    0.02549918f, -0.02374846f, -0.13922113f, -0.02735251f, -0.10009997f, 0.05378597f, -0.00746910f, 0.06646241f, 
    0.03865956f, 0.11379090f, 0.05168261f, 0.02530727f, 0.08038273f, 0.02227479f, 0.05700289f, -0.06155154f, 
    0.10459872f, 0.20842175f, 0.13770236f, -0.00751683f, -0.20885397f, -0.04638422f, 0.01031024f, 0.28016576f, 
    -0.03628327f, -0.17731005f, 0.06417662f, 0.17871007f, -0.01455608f, 0.04173654f, -0.07528155f, 0.03892895f, 
    0.02312965f, 0.03077311f, -0.06799103f, 0.05873378f, 0.01943031f, 0.01568676f, 0.11862731f, -0.25128642f, 
    -0.10896809f, -0.01649245f, -0.02919308f, -0.04841243f, -0.09982730f, -0.12430939f, 0.15378499f, 0.31901357f, 
    -0.01888083f, -0.01813650f, 0.08700705f, -0.00197865f, -0.08269442f, -0.08612847f, -0.02751540f, -0.06940759f, 
    -0.36789805f, 0.00370044f, 0.08032212f, -0.13990404f, 0.01262442f, -0.00717504f, 0.06138075f, 0.04643559f, 
    0.02104757f, -0.07272128f, -0.00256176f, 0.06008566f, 0.17013730f, 0.02925213f, 0.00192547f, 0.09977596f, 
    -0.03865595f, -0.17591040f, -0.17146787f, -0.03931961f, -0.01071310f, 0.08534078f, -0.01580782f, 0.05467724f, 
    0.08856648f, 0.02024621f, -0.20313172f, 0.12539850f, 0.09687027f, -0.15957765f, 0.07576303f, 0.13912803f, 
    0.15455212f, -0.07159271f, -0.04020813f, 0.18965597f, -0.36306453f, 0.24544396f, 0.15067828f, -0.07440332f, 
    0.07251217f, 0.23257507f, 0.03965592f, 0.06760577f, -0.01108910f, -0.05696506f, 0.05446186f, -0.03786035f, 
    0.17330527f, 0.00423681f, -0.10120788f, -0.10084990f, -0.00779870f, -0.09404377f, -0.05806835f, -0.07291743f, 
    -0.09510408f, -0.02391004f, -0.04264949f, -0.03273837f, 0.16625138f, 0.15816322f, 0.25717264f, 0.07073243f, 
    0.12176913f, -0.01339706f, 0.17489515f, -0.07434095f, -0.08249058f, 0.08663671f, -0.00710868f, -0.00740403f, 
    0.25781718f, 0.16060175f, -0.00934344f, 0.22303718f, 0.08162258f, 0.13506380f, 0.02104122f, -0.15744300f, 
    0.20804775f, -0.02104090f, -0.02251993f, 0.00782690f, -0.00933661f, -0.14636877f, -0.12710819f, -0.29303646f, 
    0.00304961f, -0.05826688f, -0.08281583f, -0.06720913f, 0.09178867f, 0.00824227f, -0.07675022f, 0.05674476f, 
    0.30130619f, -0.06626263f, -0.15275471f, 0.02973437f, -0.03703232f, 0.13065356f, -0.00825086f, 0.11621201f, 
    0.10441823f, -0.06279716f, -0.16055799f, -0.11431525f, -0.18214342f, 0.11965991f, -0.02874450f, -0.11040149f, 
    0.18670493f, 0.02401593f, -0.01930689f, -0.02425823f, -0.03628607f, 0.02877655f, -0.03624168f, -0.02527868f, 
    0.20294514f, 0.15669560f, 0.23766217f, 0.27666140f, 0.27842957f, -0.03879425f, 0.01110366f, 0.14432336f, 
    -0.01902744f, 0.06940188f, 0.06567814f, 0.01840829f, 0.35630214f, -0.14305589f, -0.11336451f, 0.14000712f, 
    0.07577166f, -0.01643657f, 0.05626070f, 0.01378887f, -0.00395451f, 0.02206820f, 0.00573693f, 0.08112343f, 
    -0.14646208f, -0.04492325f, 0.10156747f, 0.11676071f, 0.17355818f, -0.18727629f, 0.06111936f, 0.06805300f, 
    0.00101175f, -0.00499934f, -0.05849617f, 0.00124350f, -0.07012968f, 0.04454079f, 0.06043012f, 0.37021473f, 
    -0.03381483f, 0.06403384f, -0.00101077f, 0.08260047f, 0.07534757f, 0.05158009f, -0.15321875f, 0.01691649f, 
    0.01752319f, -0.03802297f, -0.01383841f, 0.24046062f, -0.08065232f, 0.08046674f, -0.01657835f, -0.11560442f, 
    -0.03090068f, 0.13833849f, -0.06967679f, 0.05769158f, 0.03468483f, -0.06441573f, 0.22336532f, 0.28023374f, 
    0.14484094f, 0.06281496f, 0.04098154f, 0.13979408f, 0.02552487f, -0.07014167f, -0.16358347f, 0.01713565f, 
    -0.24470045f, -0.37218928f, 0.09523536f, -0.14071757f, -0.01449859f, -0.09370688f, 0.08476288f, 0.04820651f, 
    0.08958681f, -0.03602769f, -0.03565006f, -0.01170301f, 0.12787971f, -0.09189326f, -0.15160775f, 0.09572560f, 
    0.03819871f, -0.03531941f, -0.03553411f, -0.04428796f, -0.08413807f, 0.10549941f, 0.08883216f, 0.04407933f, 
    0.32690987f, -0.03037028f, -0.13276803f, 0.09541447f, 0.09386534f, 0.00194468f, 0.05612532f, 0.01360357f, 
    0.13924174f, -0.08142343f, 0.04648422f, 0.03766508f, 0.14086092f, 0.22488275f, 0.12928475f, -0.06553040f, 
    0.04784238f, 0.17148069f, 0.09670714f, 0.08027993f, -0.12669221f, 0.00786346f, 0.07850952f, -0.00842657f, 
    -0.27714989f, -0.28883550f, 0.11466686f, -0.35067379f, -0.09965526f, -0.03163493f, -0.00533228f, 0.00454119f, 
    0.04009333f, -0.10292956f, 0.10429591f, -0.07185391f, -0.02623536f, 0.21565531f, 0.16667536f, -0.10047448f, 
    0.02968075f, 0.14918354f, 0.20252690f, 0.10116328f, -0.02410262f, 0.07123686f, 0.21134168f, -0.05979177f, 
    0.48602560f, 0.27072516f, -0.08141725f, 0.03600920f, -0.16867030f, 0.08455001f, -0.00901841f, -0.10327026f, 
    0.12553976f, -0.05870672f, -0.01477130f, 0.10722968f, -0.18780848f, -0.27852681f, -0.32844818f, -0.17227858f, 
    0.06893686f, -0.07382481f, -0.09617151f, 0.03704255f, 0.11304028f, 0.04653743f, -0.07209191f, 0.05397836f, 
    0.32347393f, 0.24717076f, -0.01935269f, -0.18137278f, -0.10176368f, 0.10200063f, 0.07677192f, 0.00820394f, 
    0.17512664f, 0.04269523f, -0.09235772f, -0.05109039f, 0.11233842f, -0.01966683f, 0.15228958f, -0.10693605f, 
    0.24209607f, 0.04706913f, 0.11460613f, 0.03362459f, 0.06820583f, 0.07099745f, -0.09472027f, 0.06218519f, 
    -0.33995435f, 0.27150449f, 0.10074440f, 0.09791078f, -0.00993922f, -0.06111874f, 0.01855029f, 0.07795635f, 
    -0.00466859f, 0.09696409f, 0.08892042f, 0.08604879f, -0.04975257f, 0.13790736f, 0.06228376f, -0.04087966f, 
    -0.02869632f, -0.04109116f, 0.02841800f, 0.07524519f, 0.11514442f, 0.13129461f, -0.02324565f, -0.09528757f, 
    -0.16930605f, 0.21674900f, -0.39192614f, 0.07001358f, -0.13249722f, 0.00724746f, -0.07962931f, -0.15820961f, 
    -0.09464118f, 0.09595622f, -0.01423962f, -0.05509774f, 0.31251168f, -0.00472735f, 0.03365719f, -0.24493204f, 
    -0.03595668f, 0.18417121f, -0.17312850f, 0.01782953f, -0.01079789f, 0.13856751f, -0.03059963f, 0.10620096f, 
    0.03709353f, 0.09014805f, 0.21886942f, -0.16341797f, 0.05764211f, 0.00883016f, 0.09704727f, 0.02052643f, 
    0.01792709f, -0.12145027f, 0.00412336f, 0.04195564f, -0.00922627f, 0.36314026f, -0.02711723f, -0.19412515f, 
    0.19578303f, -0.08228160f, 0.01651243f, 0.02996834f, -0.02060356f, 0.10325857f, 0.02588582f, 0.00489850f, 
    0.41693401f, 0.22959933f, -0.39270556f, -0.03274495f, -0.07814157f, 0.05997079f, -0.10128605f, -0.01196119f, 
    -0.08070254f, -0.12269104f, 0.12574552f, 0.03647586f, 0.08618703f, 0.10705348f, 0.04013635f, 0.02665912f, 
    0.00607328f, 0.09016376f, 0.06654305f, -0.00154000f, -0.09240831f, 0.03700448f, 0.00847913f, 0.08268593f, 
    -0.02576525f, 0.00086278f, 0.14018413f, -0.02000737f, -0.00673637f, 0.01510062f, 0.11813553f, 0.07566404f, 
    -0.03757275f, -0.01310314f, -0.08955029f, -0.03680254f, 0.43575647f, -0.16596343f, -0.16703899f, -0.05261149f, 
    -0.04976645f, -0.06102166f, 0.05296341f, -0.06658643f, 0.12539971f, 0.04690684f, -0.05341819f, 0.07611224f, 
    -0.09519479f, -0.07585045f, -0.40893877f, -0.00802164f, -0.06731728f, -0.06946101f, -0.04092567f, -0.07007787f, 
    -0.00417530f, 0.07581758f, 0.04045225f, 0.14487679f, 0.23074818f, -0.06992952f, -0.07847569f, -0.23916277f, 
    0.09105583f, -0.13795812f, -0.14230897f, 0.13626517f, 0.08203199f, -0.08335782f, -0.09196062f, -0.16426763f, 
    -0.00555573f, -0.10719354f, 0.11053234f, -0.13381034f, -0.03118891f, -0.01136510f, 0.03025216f, 0.07810663f, 
    -0.02670564f, 0.03651221f, 0.03314712f, -0.08946352f, -0.01636208f, 0.03389224f, 0.00569730f, -0.01397890f, 
    0.02182655f, -0.00372892f, -0.01068953f, -0.10075989f, 0.00240340f, 0.07838079f, 0.08961090f, 0.08786786f, 
    -0.13630293f, -0.31698513f, -0.08862376f, 0.10672274f, 0.02429979f, -0.06246237f, 0.03299588f, 0.02616987f, 
    0.03792122f, -0.03657061f, 0.13122365f, 0.28299674f, 0.15366735f, -0.09280360f, -0.04817558f, 0.36135986f, 
    -0.13621454f, 0.02288814f, -0.00860910f, 0.10404713f, 0.02281505f, 0.06666543f, 0.07226777f, 0.02480961f, 
    -0.33687428f, -0.01623335f, 0.21923076f, 0.12785760f, -0.01232516f, 0.17072612f, 0.06178568f, 0.10860179f, 
    0.05156313f, 0.20110321f, 0.05547123f, -0.11865518f, 0.06395146f, -0.00109709f, 0.27028108f, -0.23633184f, 
    -0.08604474f, -0.05742485f, 0.01967853f, 0.03894645f, -0.03419079f, -0.00897164f, -0.07544149f, 0.10998014f, 
    -0.20762740f, 0.16547456f, -0.01596065f, 0.04056119f, -0.05144221f, -0.04975426f, 0.01203826f, -0.09465621f, 
    -0.05546523f, 0.02382775f, 0.06647073f, 0.20733255f, 0.14251430f, 0.14710782f, 0.20795451f, 0.00194140f, 
    0.03471968f, 0.19181350f, -0.00603049f, 0.08491414f, -0.15265110f, 0.10892924f, -0.03059046f, 0.22345306f, 
    0.24269614f, -0.35297823f, 0.05681442f, -0.33689281f, 0.05399016f, 0.01962488f, -0.01803800f, 0.00952279f, 
    0.01502161f, -0.13247751f, 0.14622414f, 0.00689114f, -0.08948525f, 0.04313602f, 0.01025260f, -0.19446546f, 
    0.04983611f, 0.01805658f, 0.11381841f, -0.05451337f, 0.04732696f, 0.10336854f, 0.15779009f, 0.08138854f, 
    -0.20269749f, -0.10846941f, -0.03870768f, 0.04491425f, 0.06660318f, 0.11295819f, 0.04162476f, 0.11387482f, 
    0.03278021f, -0.11443590f, 0.08620476f, 0.05526185f, 0.21554790f, 0.26406360f, 0.11282991f, -0.00189470f, 
    0.00853119f, -0.03394981f, 0.01099213f, 0.09764023f, 0.07536358f, 0.10134406f, -0.14833021f, 0.02997044f, 
    0.09955692f, -0.34727544f, -0.07855728f, -0.07142572f, 0.00370142f, -0.11465685f, 0.13550231f, -0.01837430f, 
    0.09705127f, -0.01075053f, 0.06679949f, 0.08096802f, 0.01585109f, 0.09196465f, -0.24877869f, -0.10042387f, 
    0.03814818f, -0.07152943f, 0.08363426f, -0.04787573f, 0.07937559f, 0.11307333f, 0.03337938f, 0.08561877f, 
    0.21532351f, -0.16525269f, 0.20671912f, -0.09303686f, -0.22284083f, -0.02228634f, -0.03481387f, 0.09044889f, 
    0.09229682f, 0.19536240f, -0.00422940f, 0.18954489f, 0.18489540f, -0.03403462f, -0.10075135f, -0.13816366f, 
    0.03122205f, -0.24087280f, -0.16226514f, -0.15705237f, 0.02069645f, -0.12084325f, -0.15449439f, 0.03315716f, 
    0.04774179f, 0.00254472f, -0.12000126f, -0.11525783f, 0.00265463f, 0.05744847f, 0.28094140f, -0.07006758f, 
    -0.04111636f, -0.05419973f, 0.02118829f, -0.05267400f, -0.18323675f, 0.05575626f, 0.01216884f, 0.05613082f, 
    0.03104899f, -0.06205941f, -0.04246639f, 0.11869097f, 0.21690226f, 0.05618203f, 0.12906386f, -0.02493196f, 
    -0.04401159f, -0.27252272f, 0.00363374f, 0.10541910f, 0.01046858f, -0.13862364f, -0.15877399f, -0.05441026f, 
    0.05105836f, 0.06021680f, -0.02184987f, 0.11398952f, -0.19090506f, 0.12770550f, -0.02985474f, 0.27442628f, 
    0.05769828f, 0.08540402f, -0.09438083f, 0.21015000f, 0.11637354f, -0.13292493f, -0.04049306f, 0.05660236f, 
    -0.01330748f, -0.03188483f, 0.02684117f, -0.00588520f, -0.06057520f, 0.05350306f, 0.05030302f, -0.07260011f, 
    0.04211429f, 0.04143426f, 0.03045068f, -0.06278381f, -0.02236014f, 0.05164805f, -0.01125767f, -0.07572266f, 
    -0.02593069f, 0.05592645f, -0.08049329f, 0.00148794f, -0.00737613f, -0.01377721f, -0.06420605f, 0.00909323f, 
    0.04525185f, 0.02623708f, -0.02196586f, -0.00405876f, 0.01567462f, 0.05929162f, 0.02617094f, 0.02264807f, 
    -0.00115140f, 0.04750706f, -0.07591464f, -0.08091343f, -0.05673482f, 0.02795540f, -0.00317392f, 0.04617161f, 
    0.00756597f, 0.03577683f, -0.01679338f, -0.00138583f, -0.02842750f, 0.03968447f, -0.02807079f, 0.03568381f, 
    -0.01728511f, -0.07101310f, 0.00883463f, 0.00217635f, 0.02346297f, 0.02006037f, -0.00579406f, 0.00719603f, 
    -0.05364691f, 0.01991582f, 0.05889722f, -0.06814451f, -0.00290069f, -0.02692875f, 0.05198007f, -0.06870194f, 
    0.00985661f, 0.01018383f, -0.02596791f, -0.06121380f, 0.05816184f, 0.03247424f, -0.04462471f, -0.07202128f, 
    -0.00301188f, -0.04381663f, -0.04983693f, -0.07101812f, 0.02885915f, 0.03414118f, 0.00079756f, -0.07400255f, 
    0.00563366f, 0.02027511f, 0.02981868f, 0.00561436f, -0.03756543f, 0.03220612f, -0.05113316f, 0.03940916f, 
    -0.01445347f, 0.05822279f, -0.04816889f, -0.02904271f, -0.05747058f, -0.02593347f, -0.04189054f, -0.06750926f, 
    0.02254724f, -0.04737057f, -0.00136620f, -0.02547961f, -0.05050826f, -0.03010084f, -0.00605357f, -0.06940618f, 
    -0.00310496f, 0.00460024f, -0.00660337f, -0.01400313f, 0.04003374f, -0.07621846f, -0.00908169f, 0.05890625f, 
    0.01004847f, -0.04248154f, -0.03246203f, -0.03621498f, 0.01228581f, 0.04878184f, 0.01934363f, -0.02766905f, 
    -0.07105342f, -0.04324347f, 0.03982346f, 0.04458776f, 0.03392253f, -0.03929786f, 0.03828479f, 0.05709716f, 
    -0.02046806f, 0.05558111f, -0.07045309f, 0.03843677f, -0.01720717f, -0.07658252f, -0.00471790f, -0.06597454f, 
    -0.04399679f, -0.04524959f, 0.05050300f, -0.00872241f, -0.01198704f, -0.01406191f, 0.04947902f, 0.01052447f, 
    -0.02906246f, 0.06375837f, 0.02723225f, 0.05481312f, -0.04751277f, -0.01636404f, -0.05559633f, -0.01981348f, 
    -0.01719333f, 0.00844004f, 0.03337268f, -0.04365668f, 0.01715172f, 0.01507229f, 0.00898090f, -0.01060626f, 
    -0.06430987f, -0.06808083f, 0.03452856f, -0.08235376f, -0.05983131f, -0.03434770f, -0.00005584f, 0.05093732f, 
    0.02733804f, -0.04135619f, 0.01000988f, 0.04373332f, 0.03583020f, -0.04458502f, 0.05412965f, -0.04658868f, 
    -0.05196259f, -0.04769534f, -0.05435163f, -0.02515047f, -0.02821272f, 0.03738969f, -0.01009707f, 0.00524615f, 
    -0.01458023f, -0.04282714f, -0.00881283f, -0.08061147f, -0.05714202f, -0.06339651f, -0.07783643f, 0.04297927f, 
    -0.03899937f, 0.03723046f, -0.05203912f, 0.00585849f, -0.02196555f, -0.03573933f, 0.06177604f, 0.06371319f, 
    -0.04279411f, -0.02288787f, -0.01221765f, -0.03816788f, 0.03066471f, -0.05189542f, 0.05626764f, -0.04332557f, 
    -0.06911985f, -0.07080629f, -0.07148419f, -0.01413236f, 0.02581818f, -0.06089400f, -0.04384940f, -0.02839208f, 
    -0.01246506f, -0.05758274f, 0.01088280f, -0.05387262f, 0.05540721f, -0.03649288f, 0.04854821f, 0.04826760f, 
    -0.03037159f, 0.05060720f, 0.01752876f, -0.03446836f, 0.04467265f, -0.01128798f, 0.05208262f, 0.03610978f, 
    0.00831339f, 0.04347789f, 0.03218877f, -0.07051267f, -0.06486087f, 0.04141320f, 0.04859920f, -0.03194594f, 
    -0.02895832f, 0.06172904f, 0.03392109f, -0.02590918f, -0.02263303f, -0.00405206f, -0.01508705f, 0.04093634f, 
    0.01790342f, 0.03703813f, -0.03093666f, -0.06674753f, -0.05122282f, -0.02368443f, -0.00981723f, -0.06310983f, 
    0.06453699f, -0.07955813f, 0.02736475f, -0.04717827f, 0.00822376f, -0.06859074f, 0.04971381f, 0.01658081f, 
    -0.00631222f, -0.02509255f, -0.07060862f, 0.01436896f, -0.02974428f, -0.07728931f, -0.06568507f, -0.00532242f, 
    0.00060020f, 0.05433514f, 0.03144179f, 0.03157491f, -0.06796516f, -0.03801684f, -0.03377169f, -0.05172660f, 
    -0.07000829f, -0.00587736f, 0.06559464f, 0.05224376f, -0.02742873f, -0.03269131f, 0.03261660f, 0.01566158f, 
    0.01993784f, -0.04424633f, 0.05926207f, -0.05054462f, 0.02304499f, -0.01980888f, -0.05485459f, -0.04261936f, 
    -0.03528687f, -0.03466399f, 0.00541272f, -0.00098469f, -0.03712507f, 0.02264252f, -0.06765535f, 0.00750827f, 
    0.04121822f, -0.00811459f, 0.05904071f, 0.02788991f, -0.01409359f, 0.03778236f, -0.01761241f, -0.00470076f, 
    -0.04150178f, 0.05746884f, 0.01455955f, -0.05664596f, 0.01990498f, -0.01256123f, 0.02704719f, -0.01371138f, 
    -0.05846780f, 0.04976582f, -0.05469745f, 0.01024931f, -0.04902703f, -0.06167287f, -0.07430007f, -0.06402628f, 
    0.03557076f, 0.00664601f, 0.05021335f, -0.07133155f, 0.02227329f, 0.04617631f, 0.01830447f, -0.01096904f, 
    -0.02797186f, -0.06776264f, -0.06489839f, 0.01960176f, -0.06338901f, -0.05082618f, 0.03949881f, 0.04182543f, 
    -0.00215971f, 0.01828837f, 0.05271405f, -0.05531909f, 0.05733516f, 0.00320044f, -0.01407616f, 0.05465395f, 
    0.04821219f, 0.04836615f, -0.07278143f, -0.02766172f, 0.03957793f, 0.06088391f, -0.01266838f, -0.04846804f, 
    -0.01204663f, 0.03479203f, 0.00102332f, 0.04577328f, -0.01583060f, -0.02424516f, -0.06755923f, -0.02426885f, 
    -0.02933536f, -0.04775953f, -0.00082926f, 0.00282916f, 0.03926709f, -0.01007351f, -0.06280755f, -0.05869592f, 
    -0.01107289f, 0.03431783f, -0.01972738f, -0.06040439f, -0.07619617f, -0.03577689f, 0.05691496f, 0.02146538f, 
    -0.14337958f, 0.13723449f, -0.14210555f, -0.03503894f, -0.11467270f, 0.11484481f, -0.15747769f, 0.01734109f, 
    0.06369519f, 0.05975261f, -0.04217134f, 0.05101811f, -0.48169214f, 0.05199461f, -0.14936505f, 0.04907003f, 
    0.40627614f, -0.20825124f, 0.12480251f, -0.08716033f, 0.09525891f, 0.04791762f, 0.06358903f, 0.16843556f, 
    -0.07836027f, -0.22858773f, -0.11561085f, -0.11403698f, -0.11223320f, 0.03530160f, -0.16279684f, 0.07532083f, 
    0.02369190f, -0.15878157f, 0.03377018f, 0.14491460f, 0.20852019f, 0.18491079f, -0.08404972f, -0.12446007f, 
    0.07779616f, -0.10453522f, 0.08117279f, 0.01563930f, 0.02837155f, 0.31746536f, 0.21809578f, 0.20214199f, 
    -0.49827099f, -0.00131495f, 0.04624530f, 0.35256493f, -0.07038986f, 0.03589991f, -0.15953849f, -0.04678848f, 
    0.10420957f, 0.02749704f, 0.08102726f, -0.17706794f, 0.03259398f, 0.34544849f, -0.06892766f, 0.18001096f, 
    0.07498436f, -0.11679804f, 0.04218131f, 0.02562056f, -0.02991888f, -0.01741774f, -0.09807233f, 0.04968977f, 
    0.16371772f, 0.09740911f, 0.01458027f, -0.34007215f, -0.04705440f, -0.16239265f, 0.01476946f, 0.20025961f, 
    -0.06542145f, 0.15185270f, -0.09576933f, -0.04761575f, 0.11456276f, -0.01054437f, 0.04612339f, 0.02125455f, 
    0.29896688f, 0.08963361f, -0.03027075f, -0.04512264f, 0.19875024f, 0.02393293f, 0.20185506f, -0.03021435f, 
    0.23238713f, 0.06104214f, -0.16439904f, 0.31087801f, 0.15281875f, 0.07638522f, 0.01468546f, 0.07633623f, 
    0.07572503f, 0.06958549f, -0.02112266f, -0.01333643f, 0.21631601f, 0.01336842f, -0.03850396f, 0.18094200f, 
    -0.17343886f, -0.06685069f, 0.00244882f, 0.16023181f, -0.15920097f, 0.05327572f, 0.05892184f, -0.04472743f, 
    -0.45444202f, -0.17465702f, -0.12303415f, -0.10185660f, 0.22942685f, -0.03199399f, -0.09808155f, -0.08601689f, 
    0.18636242f, 0.11917251f, 0.07991830f, 0.07968246f, -0.00240455f, 0.12730256f, 0.10899988f, 0.13596486f, 
    -0.16268957f, -0.28628445f, 0.19491498f, 0.01156647f, -0.13806175f, -0.07162792f, -0.10701550f, -0.01364948f, 
    0.52790636f, 0.29741761f, 0.14195639f, 0.13129176f, -0.15018693f, 0.08334538f, -0.13683276f, -0.15919653f, 
    0.12723531f, -0.03396188f, 0.17738377f, 0.03065703f, -0.17201586f, -0.25446835f, -0.07085127f, 0.02417661f, 
    0.15510648f, 0.10176136f, -0.00660201f, -0.01262280f, 0.07294111f, 0.10438944f, 0.11775735f, 0.23477964f, 
    -0.12533790f, -0.14586031f, 0.09947739f, -0.05776601f, 0.17787084f, -0.19468319f, 0.08622162f, -0.07407061f, 
    0.36237612f, 0.24995337f, 0.05761686f, 0.05208256f, 0.01888628f, 0.11304709f, 0.03487424f, -0.05854758f, 
    0.15948278f, -0.07201684f, 0.11229509f, 0.05058981f, -0.06868754f, -0.06560634f, 0.16752099f, -0.02372603f, 
    0.02848314f, -0.04908995f, -0.18452276f, -0.35484871f, -0.10413079f, 0.12195209f, 0.05681152f, 0.08511382f, 
    -0.01018834f, 0.11374228f, -0.07635635f, -0.06367201f, -0.02877851f, 0.04711157f, 0.23563783f, 0.22060518f, 
    0.05501544f, 0.04365453f, -0.05108948f, -0.00088783f, -0.04357764f, 0.08490445f, -0.00374326f, -0.01847445f, 
    -0.18473333f, -0.38554966f, -0.34096220f, -0.15116271f, -0.05792931f, 0.13421205f, 0.01951387f, -0.09909485f, 
    -0.03738045f, 0.07993092f, 0.00052345f, 0.08504149f, 0.15343462f, -0.05304473f, 0.16488509f, 0.04656633f, 
    0.04766667f, 0.06641229f, 0.02527356f, 0.17066976f, 0.02327943f, 0.02745910f, 0.01034278f, -0.08308300f, 
    0.20051859f, -0.49729100f, -0.05273637f, -0.28515404f, 0.20245135f, -0.04541040f, 0.08441330f, -0.13224506f, 
    -0.01133794f, -0.14400868f, 0.16455603f, -0.02385633f, -0.29150024f, 0.31575054f, 0.03797206f, -0.06462742f, 
    0.07863966f, -0.07978208f, 0.12248037f, -0.15702944f, 0.00839315f, 0.07116430f, 0.10782507f, 0.07971402f, 
    0.17039578f, 0.20342667f, -0.03263232f, 0.09381347f, -0.02577055f, 0.06129677f, -0.01585494f, 0.19827616f, 
    -0.02295835f, 0.03543871f, -0.04782019f, -0.08064405f, -0.35544991f, 0.04006015f, 0.01935409f, 0.07436863f, 
    -0.01453756f, -0.04565707f, 0.04417527f, 0.08490936f, 0.04732907f, 0.02661024f, -0.04790457f, -0.01299834f, 
    0.04773076f, -0.36800000f, 0.09012379f, -0.25251243f, -0.12926883f, 0.04070383f, -0.03907766f, -0.04925713f, 
    -0.15606122f, -0.14550163f, -0.23674624f, -0.02872542f, 0.19648524f, 0.12623191f, 0.23447692f, 0.24057747f, 
    -0.04409477f, -0.13370180f, -0.00080707f, 0.05292530f, -0.03687782f, 0.10939948f, 0.03968940f, -0.01668352f, 
    0.46434793f, 0.13937278f, 0.18654123f, 0.31960654f, -0.10833386f, 0.06608269f, 0.04451232f, 0.18942377f, 
    0.04281346f, 0.16481538f, -0.01713748f, 0.13638033f, -0.04041843f, 0.07366963f, 0.22151400f, 0.38372526f, 
    0.00925195f, 0.01843060f, 0.01212279f, 0.02686284f, 0.03339474f, -0.00795770f, 0.09313422f, 0.01747440f, 
    0.07354749f, 0.23760705f, 0.17725562f, 0.00548548f, 0.07607249f, -0.02308994f, 0.17171195f, 0.31408229f, 
    0.03032283f, -0.00708420f, 0.07455973f, -0.11475850f, -0.28016537f, 0.13037500f, 0.03043927f, 0.13430665f, 
    -0.13100040f, -0.24156098f, 0.12612465f, 0.12059191f, -0.00604017f, -0.01246072f, 0.01416844f, -0.13303684f, 
    0.25950059f, 0.00743678f, -0.18944518f, 0.24176772f, -0.02785387f, 0.19737922f, 0.05996827f, 0.14092404f, 
    0.06184939f, 0.01640240f, -0.08646568f, -0.00447160f, 0.25435880f, -0.24499951f, 0.23687299f, 0.16874339f, 
    -0.11157805f, -0.09330065f, -0.21260127f, 0.06250483f, -0.02639124f, -0.00121806f, -0.09018941f, 0.05640793f, 
    -0.19484858f, 0.10500687f, 0.09911519f, -0.09581739f, 0.13638771f, -0.11008962f, -0.07268511f, 0.16265799f, 
    -0.01024630f, 0.10869434f, -0.10258528f, -0.00973499f, 0.28885511f, -0.25633451f, 0.03369053f, 0.20938568f, 
    0.16069491f, 0.03952493f, -0.00403056f, -0.12170684f, 0.11405010f, -0.04877345f, 0.03216157f, -0.16169429f, 
    -0.35290247f, -0.25839517f, -0.39195073f, 0.04210500f, 0.03732736f, -0.05200521f, -0.03284920f, 0.15645786f, 
    0.01874837f, -0.02667124f, 0.04604521f, 0.05904569f, 0.14860094f, 0.16869272f, 0.14927092f, 0.02129577f, 
    0.09607942f, 0.05684977f, -0.07104825f, -0.01470307f, 0.14709719f, 0.19254157f, 0.01058408f, 0.13630717f, 
    -0.06817199f, -0.16454011f, 0.17807825f, 0.07623852f, -0.09163333f, 0.10245523f, -0.12083757f, 0.12402549f, 
    0.14719667f, 0.06114644f, 0.09336517f, -0.00832481f, 0.00365187f, 0.10031391f, 0.18520649f, -0.11647496f, 
    -0.01284062f, -0.05289268f, 0.04208307f, 0.02053513f, 0.04204350f, -0.02619618f, -0.03970577f, -0.05667511f, 
    -0.07136001f, 0.10013821f, -0.19915974f, -0.12764284f, -0.06620573f, -0.15977831f, -0.00733550f, 0.05437057f, 
    0.12167779f, 0.05542884f, -0.08601113f, -0.06976768f, -0.33441287f, -0.10234518f, -0.13391049f, 0.21838726f, 
    0.12713146f, 0.06687175f, -0.03200097f, -0.06823753f, 0.05893935f, 0.03894759f, 0.24638084f, -0.09658546f, 
    0.12429498f, 0.28390390f, -0.27333641f, 0.23806246f, 0.10220451f, 0.06638725f, -0.00259468f, -0.05425207f, 
    -0.12608068f, 0.09218727f, 0.05727789f, -0.06567725f, 0.36684078f, -0.12051166f, 0.24438936f, -0.06122808f, 
    -0.01120796f, -0.01540795f, -0.01487218f, 0.17467754f, -0.04934983f, 0.14408091f, -0.20508370f, -0.01758183f, 
    -0.38936415f, -0.33796787f, -0.09227797f, -0.06538015f, -0.06530475f, -0.13153763f, -0.01183931f, -0.28011295f, 
    0.05107312f, -0.04912125f, 0.22856541f, -0.05455099f, -0.09521452f, 0.18388107f, 0.12485625f, -0.00371175f, 
    0.04128249f, 0.13500400f, -0.01688840f, -0.08857687f, -0.02013442f, -0.16596109f, 0.04805097f, 0.00714422f, 
    0.19625570f, 0.26947716f, 0.11786156f, 0.12266875f, 0.11787739f, 0.06613757f, -0.10267920f, 0.17130953f, 
    -0.06689621f, -0.02021604f, -0.01765656f, -0.02988946f, -0.36945522f, -0.53835225f, -0.21299098f, 0.05195170f, 
    0.01302753f, 0.10099739f, -0.05817464f, -0.06842076f, 0.07920395f, 0.06023274f, 0.06044674f, 0.12591289f, 
    0.07719661f, 0.09303336f, -0.00818226f, -0.17679667f, 0.05848045f, -0.07045019f, 0.12616885f, 0.04561753f, 
    0.18278912f, 0.14981613f, 0.07498074f, 0.09251568f, -0.11141521f, -0.09990682f, 0.32593057f, -0.15649123f, 
    0.16222568f, 0.03289867f, 0.08972713f, -0.01052568f, -0.02470330f, 0.08699363f, 0.06406740f, -0.04424005f, 
    0.08827472f, 0.08289282f, -0.12663944f, 0.14513506f, 0.06881960f, -0.05586676f, 0.12158635f, 0.15359601f, 
    0.09950957f, 0.08937690f, -0.11122388f, -0.05248392f, -0.07368238f, -0.06496616f, -0.51316637f, -0.02674909f, 
    0.02423230f, -0.05285919f, 0.14289428f, -0.00482194f, -0.00998142f, 0.03561731f, -0.15470041f, 0.22462532f, 
    -0.02159654f, 0.13233973f, -0.05488513f, 0.07296973f, -0.07929383f, -0.11515841f, 0.07490214f, 0.20789388f, 
    0.01959657f, 0.20867655f, 0.13897115f, 0.12156050f, -0.00196121f, -0.15414459f, 0.03258152f, 0.03828055f, 
    -0.02902771f, 0.02602724f, 0.06035286f, 0.08768027f, 0.06014908f, 0.05364713f, -0.14510499f, 0.12046348f, 
    -0.06933067f, 0.16596486f, 0.06044924f, 0.09834530f, 0.02330008f, -0.14823751f, -0.00433423f, 0.22836581f, 
    0.09583876f, -0.12353179f, -0.46714166f, 0.03689056f, 0.03300562f, 0.00619219f, -0.01723769f, 0.28914896f, 
    -0.11182239f, -0.21601067f, 0.05078441f, 0.16896418f, -0.09725072f, 0.07360940f, -0.04846955f, 0.11797754f, 
    0.12012508f, 0.04385327f, 0.15686169f, 0.10795388f, 0.05776701f, -0.06328161f, -0.04443635f, 0.16629575f, 
    0.00147624f, 0.23519820f, -0.11289719f, -0.06791323f, -0.37995845f, 0.07762944f, 0.30917892f, 0.20796511f, 
    0.07027622f, -0.14162570f, 0.07271188f, 0.09441856f, 0.06365497f, 0.10755276f, 0.09934812f, -0.15279722f, 
    -0.08588260f, 0.09674625f, 0.07583586f, 0.12352062f, 0.01915537f, 0.09407440f, -0.25660798f, 0.08347104f, 
    -0.07552820f, 0.00801594f, 0.14282496f, 0.03467626f, -0.09467020f, 0.10177664f, 0.00871298f, -0.03806528f, 
    -0.11893955f, -0.28959572f, -0.23869553f, 0.09755430f, 0.08720767f, 0.03154271f, -0.21236721f, -0.29893044f, 
    -0.23155282f, 0.16267812f, 0.14766783f, -0.16757737f, -0.00569280f, -0.04170727f, 0.12080757f, 0.09179707f, 
    0.04496441f, 0.00487715f, 0.18238977f, 0.02151611f, 0.01638783f, -0.00425295f, 0.11210983f, -0.05742258f, 
    -0.15107712f, -0.36408198f, -0.12556133f, 0.05682122f, 0.01626581f, -0.19127500f, -0.24798605f, -0.02785795f, 
    0.06680709f, -0.06255353f, -0.12937810f, -0.36087486f, -0.25273693f, -0.22870782f, -0.14245199f, -0.02478498f, 
    -0.03382824f, -0.02984738f, -0.01663639f, -0.13236044f, -0.11467849f, 0.05189198f, 0.06050384f, -0.00745409f, 
    -0.02349729f, 0.02628733f, 0.10709931f, 0.13665567f, 0.01674410f, 0.15377265f, 0.07668968f, -0.04258131f, 
    -0.07608845f, 0.14941747f, -0.14566483f, -0.01729454f, -0.12809192f, 0.09299912f, -0.08784577f, -0.00848632f, 
    0.00177471f, -0.18720834f, 0.03352160f, 0.10630926f, -0.09554502f, 0.15159559f, -0.03833123f, -0.02666135f, 
    -0.13243011f, 0.11654499f, -0.04511115f, 0.04334040f, 0.05770105f, 0.05453115f, -0.08871678f, 0.12144611f, 
    -0.03393152f, 0.02381819f, -0.00888104f, -0.01977282f, 0.00710007f, -0.06065251f, 0.03021796f, -0.03128070f, 
    0.03043887f, -0.00191069f, -0.07158441f, 0.00617858f, 0.06798887f, -0.07707429f, 0.01843160f, 0.02159207f, 
    0.00374579f, 0.00209599f, -0.05060903f, 0.00426451f, 0.07497426f, -0.05928963f, -0.06445533f, 0.00704269f, 
    -0.06966780f, -0.09455056f, -0.08276258f, -0.00231994f, 0.07535423f, 0.04649810f, 0.01592630f, 0.08390591f, 
    -0.06485935f, -0.02984119f, 0.00191582f, 0.04259640f, -0.05403221f, -0.00560463f, -0.05892163f, 0.01152206f, 
    -0.09440637f, -0.04755402f, 0.00368176f, -0.07390171f, 0.05637906f, 0.04900185f, 0.02599108f, 0.00212170f, 
    0.05367641f, -0.04250762f, -0.05898497f, -0.07510294f, -0.07634606f, 0.03181582f, 0.06416702f, 0.02750245f, 
    0.02699465f, -0.00803017f, -0.09792742f, -0.03589791f, 0.03240500f, 0.02474711f, 0.06480332f, -0.05755441f, 
    -0.05645075f, -0.08255552f, -0.00360965f, 0.01113824f, 0.06255528f, 0.03844830f, 0.05176267f, -0.01492283f, 
    0.03290199f, 0.04832149f, 0.01675384f, -0.06455585f, -0.03925776f, -0.03490219f, 0.03538942f, -0.00028965f, 
    0.01647990f, -0.02659735f, 0.03667241f, -0.06104102f, -0.08338708f, 0.01235467f, 0.00336291f, -0.01876825f, 
    -0.07508776f, -0.02562851f, -0.06066329f, -0.06065119f, -0.00959648f, -0.03145974f, -0.07279289f, -0.01566056f, 
    0.03604747f, -0.03964512f, 0.03751202f, 0.00948250f, -0.09290589f, 0.05643279f, -0.06127362f, -0.10024795f, 
    -0.02601678f, 0.04947561f, -0.02621849f, 0.04162116f, -0.03822448f, -0.06453352f, 0.05816645f, -0.01926431f, 
    -0.02910031f, 0.00647448f, 0.02515634f, 0.03041083f, -0.00880552f, -0.02199930f, -0.06643856f, -0.00421500f, 
    0.01284010f, -0.07057607f, -0.07626880f, -0.07769521f, 0.05350178f, 0.00552101f, -0.05088931f, -0.02132681f, 
    -0.02059291f, 0.04233535f, 0.01618431f, -0.03587842f, 0.04166437f, -0.03660189f, -0.01065650f, -0.04501835f, 
    0.03000842f, -0.09027624f, 0.05231220f, -0.07624651f, -0.02002970f, -0.01286278f, 0.06382369f, -0.03820202f, 
    0.00961424f, -0.06619839f, -0.02914983f, -0.04035134f, -0.01893353f, -0.02042952f, 0.05852585f, -0.09062381f, 
    -0.07657214f, -0.03782253f, -0.07138469f, -0.03532165f, -0.01808772f, 0.02963295f, -0.05525628f, 0.04116086f, 
    -0.03003800f, 0.04404811f, 0.04575729f, -0.01604688f, -0.00133823f, 0.00835017f, 0.00515722f, -0.05460110f, 
    -0.05955242f, 0.06307280f, -0.02217576f, 0.05959663f, 0.03979393f, -0.00456678f, 0.01749917f, 0.01603905f, 
    -0.02938183f, 0.00852322f, 0.04730802f, -0.01550650f, -0.00254025f, 0.04657172f, 0.04433248f, 0.02271357f, 
    -0.02361535f, -0.04242963f, -0.05625346f, -0.02959708f, -0.05274784f, -0.02267508f, 0.04937118f, -0.09384386f, 
    -0.46306983f, 0.02348314f, -0.05947128f, 0.10962060f, -0.04426147f, 0.08111810f, 0.12600155f, 0.12174243f, 
    -0.02572439f, 0.13396613f, -0.10587214f, -0.06158207f, -0.06924024f, 0.06931882f, 0.17792857f, 0.34496388f, 
    -0.00925065f, 0.01307066f, 0.17351592f, -0.05582020f, 0.13470025f, -0.30316260f, -0.00404460f, 0.21198909f, 
    0.08052793f, 0.03600597f, -0.09474198f, -0.07678334f, 0.05935415f, 0.10320709f, -0.11297622f, -0.03638974f, 
    0.03351165f, -0.04379808f, 0.18066356f, 0.11522455f, -0.28495216f, -0.25674421f, 0.22539289f, -0.06238299f, 
    -0.07648818f, -0.09937488f, -0.10505812f, -0.00241432f, -0.02884908f, 0.25983405f, 0.13197245f, 0.21640714f, 
    -0.20845187f, -0.27845189f, 0.18578084f, -0.25681466f, 0.13822100f, -0.00830212f, -0.07921710f, -0.00781181f, 
    0.09480712f, -0.08947857f, 0.04268246f, -0.05217833f, 0.08818119f, 0.00759870f, 0.06403516f, -0.00829375f, 
    0.01746735f, -0.07282469f, 0.21081246f, -0.10561027f, -0.03707883f, 0.16457649f, 0.13168249f, 0.14118394f, 
    -0.32989341f, 0.22781081f, 0.05007852f, -0.23555969f, -0.13106070f, -0.06783201f, 0.01425247f, -0.07178606f, 
    -0.08529288f, -0.08895899f, 0.04374697f, -0.05548073f, 0.06658999f, 0.03502931f, 0.12301997f, 0.19093524f, 
    0.06316888f, -0.01460443f, 0.11733370f, -0.02732177f, -0.00714271f, 0.00015954f, 0.04874668f, 0.06489745f, 
    -0.10411248f, -0.02328585f, 0.18364355f, 0.11427607f, 0.01137775f, 0.07602561f, -0.10541172f, -0.15765063f, 
    0.09520410f, 0.18279365f, -0.13336869f, 0.06316549f, -0.48106992f, -0.17929718f, -0.38863871f, -0.00562043f, 
    0.10493373f, 0.05189872f, 0.15345038f, 0.18183784f, -0.00157298f, 0.17681752f, -0.06666158f, -0.10641528f, 
    0.23156834f, 0.10174711f, 0.20565161f, 0.11469398f, -0.04196170f, 0.08171566f, -0.07464753f, -0.10631122f, 
    -0.09161464f, -0.01282080f, 0.06800804f, 0.07250829f, -0.05329870f, -0.10814021f, 0.01546132f, 0.03427290f, 
    0.03778562f, -0.08774263f, -0.11924438f, -0.13652168f, 0.07496185f, 0.03378320f, -0.24238317f, 0.13592559f, 
    -0.72625005f, -0.36297438f, -0.10986837f, 0.31573784f, 0.20534174f, 0.08225639f, 0.00593483f, -0.02609580f, 
    0.04114656f, 0.10053609f, 0.08105908f, 0.07999364f, 0.28437608f, 0.19200674f, 0.02660242f, 0.01265648f, 
    0.03848384f, 0.00916005f, -0.00601742f, -0.02598017f, -0.02321687f, -0.14339286f, 0.22336599f, 0.01104254f, 
    -0.07339165f, -0.14931367f, -0.03422188f, -0.11548144f, -0.10432177f, -0.15580843f, -0.16539523f, -0.03824490f, 
    0.10450888f, 0.21519685f, 0.10271298f, 0.01912419f, -0.17888761f, -0.02479057f, 0.05796301f, -0.05453600f, 
    0.07114445f, 0.08390421f, 0.04365520f, 0.01134334f, -0.01338265f, -0.05698811f, 0.13825697f, -0.11517031f, 
    0.08239080f, -0.14555535f, -0.00348349f, -0.21130347f, 0.02822384f, -0.06740687f, -0.09234168f, 0.00466406f, 
    -0.09733465f, 0.06274763f, -0.08707578f, -0.18691278f, -0.04953734f, 0.04850630f, 0.25720367f, 0.11593426f, 
    -0.12758841f, 0.00470955f, 0.12346709f, -0.18066801f, -0.01857459f, -0.10243764f, 0.01986739f, 0.22692998f, 
    0.28801775f, -0.35228407f, 0.09952226f, -0.07610363f, 0.16088593f, 0.08738697f, -0.02611955f, 0.18460439f, 
    0.02768971f, -0.00733046f, 0.06660884f, 0.13327439f, -0.08477109f, 0.07466216f, 0.06290607f, -0.06471450f, 
    -0.06360748f, 0.01718188f, -0.01813342f, -0.05208053f, -0.08899634f, 0.02632776f, 0.04626323f, 0.11596432f, 
    -0.00890859f, -0.45235074f, -0.01662749f, 0.08710535f, -0.00594155f, 0.07671577f, 0.07634256f, 0.05043004f, 
    0.14205526f, -0.04190147f, 0.10255114f, -0.05914290f, 0.09186606f, -0.04471835f, -0.01926563f, -0.04108681f, 
    -0.14699200f, -0.02901634f, 0.06309741f, -0.10890725f, -0.12452246f, 0.04769883f, 0.07745245f, 0.29309371f, 
    0.03265057f, -0.23609383f, 0.08920364f, -0.15557641f, -0.08056924f, -0.01213551f, 0.08574379f, 0.05353771f, 
    0.02131329f, 0.13656369f, -0.04893291f, -0.06085263f, -0.51478761f, 0.12528716f, 0.19668764f, 0.10898063f, 
    0.03279899f, 0.10214826f, 0.00823982f, 0.02138585f, 0.12293720f, 0.15056267f, 0.10375741f, -0.06871957f, 
    -0.17357484f, -0.17287001f, -0.17652635f, -0.29961300f, -0.03581491f, 0.12852402f, 0.07115717f, 0.02587684f, 
    0.13164473f, -0.16434842f, 0.05575607f, -0.00778684f, -0.33523813f, 0.01458558f, -0.16186590f, -0.05365323f, 
    0.05211921f, -0.04102420f, 0.11669420f, -0.00465201f, -0.20127152f, 0.04402996f, 0.04450297f, -0.05126956f, 
    0.22555530f, 0.22371075f, 0.53364086f, 0.06724881f, 0.04386782f, 0.08148318f, -0.11734559f, 0.08934928f, 
    0.08588699f, 0.04385620f, 0.09052287f, 0.11230580f, -0.29973614f, -0.27507848f, -0.03532649f, 0.40924680f, 
    0.06020263f, 0.12271394f, 0.08483517f, 0.00232951f, -0.01325855f, 0.18340118f, 0.09234729f, 0.07918789f, 
    -0.20965348f, -0.10781279f, -0.26630470f, -0.08424737f, 0.26837823f, 0.17098585f, 0.21906756f, 0.14220506f, 
    -0.06239815f, -0.04270925f, -0.06544401f, 0.08371233f, -0.34115854f, 0.31587753f, 0.29962888f, 0.32657653f, 
    -0.04482381f, -0.15605444f, 0.05749733f, 0.00545174f, 0.07848645f, 0.10637593f, 0.07532755f, -0.08383094f, 
    0.15291207f, -0.00828749f, 0.11232073f, -0.03652476f, -0.11348714f, 0.13943131f, 0.10401724f, 0.10643902f, 
    0.09012436f, 0.10162573f, -0.10984462f, -0.11766923f, 0.12804443f, 0.08898830f, 0.27287212f, -0.18365507f, 
    0.04505441f, 0.08014526f, -0.03891141f, 0.17668627f, 0.01771999f, -0.07261197f, 0.01142437f, -0.01778796f, 
    -0.02329283f, 0.05783934f, 0.05257751f, -0.05321188f, -0.02520001f, 0.05636680f, -0.05637092f, 0.02437655f, 
    -0.02017457f, -0.06188684f, -0.00392196f, 0.03957249f, 0.05007296f, -0.07470234f, -0.05272265f, 0.05077036f, 
    -0.07195702f, -0.04699066f, -0.04497587f, 0.04299579f, 0.04968830f, -0.07461613f, 0.01103732f, -0.07285012f, 
    0.03528675f, 0.02612504f, 0.06572086f, 0.01012671f, -0.05495140f, -0.03347567f, -0.02329112f, 0.03508316f, 
    -0.02226668f, 0.04089591f, -0.05679362f, 0.04288976f, 0.02859740f, 0.03427024f, 0.03856284f, 0.00275602f, 
    -0.05580233f, 0.02269565f, 0.01260504f, -0.03095055f, 0.03204249f, -0.01032138f, 0.03586777f, -0.07314344f, 
    0.04102552f, -0.03117413f, -0.01395022f, -0.05097984f, 0.00422215f, 0.04445916f, -0.02636066f, -0.03874386f, 
    0.00014738f, -0.04352286f, -0.04953997f, -0.00634597f, -0.00600633f, -0.04598927f, -0.01366506f, -0.02898242f, 
    0.03953476f, 0.02579009f, -0.03611439f, -0.00686837f, 0.06076917f, -0.00714074f, -0.03963925f, 0.00444165f, 
    -0.06738900f, -0.05124139f, -0.02404341f, -0.00794627f, -0.07422964f, -0.03169029f, 0.03536015f, 0.02145346f, 
    0.05081514f, 0.06437937f, -0.00126058f, -0.04072682f, -0.07852042f, 0.05630162f, -0.05959388f, 0.01374267f, 
    -0.05923717f, -0.05873575f, 0.01768932f, 0.03954625f, 0.04254360f, -0.06916407f, -0.03524940f, -0.01086665f, 
    0.05828303f, 0.05547150f, -0.01230465f, -0.03372853f, 0.02420512f, -0.04129191f, -0.03794928f, -0.05461339f, 
    -0.00688287f, -0.01268491f, -0.02369078f, 0.04090548f, -0.02941327f, -0.03049437f, -0.06388041f, -0.01820238f, 
    -0.00945813f, -0.03750519f, -0.04461435f, -0.05937681f, 0.05809588f, -0.05901392f, -0.07431778f, 0.04540266f, 
    0.05320245f, -0.04620682f, 0.03312421f, -0.04925167f, 0.05919277f, -0.00187074f, -0.00178073f, -0.00875727f, 
    -0.02611186f, 0.03492824f, 0.01602475f, 0.04889509f, -0.05732266f, 0.03093702f, -0.01651321f, 0.03624206f, 
    -0.04877972f, -0.02426662f, -0.02120871f, -0.01985291f, 0.02965687f, 0.01172245f, 0.05405853f, 0.04110849f, 
    -0.01491208f, 0.04929417f, -0.05363362f, -0.02309936f, -0.07812947f, -0.04232245f, -0.01974406f, 0.05275580f, 
    -0.05667984f, 0.02684147f, -0.06518961f, -0.02182165f, -0.05920001f, 0.00184290f, 0.02256058f, -0.04168529f, 
    -0.01908533f, 0.01876619f, 0.04141000f, 0.04651313f, -0.03199010f, -0.01589677f, -0.00412461f, -0.06540558f, 
    -0.03486557f, 0.01629323f, 0.04539818f, -0.06806534f, -0.03171797f, 0.03010955f, 0.05450359f, 0.00007413f, 
    -0.02272867f, -0.06199517f, 0.05853213f, -0.01521080f, -0.03234575f, -0.05078870f, 0.02208690f, -0.02647026f, 
    -0.04726926f, -0.03926271f, -0.04526394f, 0.00083775f, -0.06522055f, -0.05608027f, 0.02469328f, 0.04850458f, 
    0.00040309f, -0.00730895f, 0.04865842f, -0.02764681f, 0.03668657f, 0.02420809f, -0.06946161f, -0.05660600f, 
    -0.02962145f, 0.06451982f, 0.05025316f, 0.03382872f, 0.04207362f, -0.05261935f, 0.01633359f, 0.04069408f, 
    0.00481324f, -0.01930317f, -0.07652550f, -0.05859999f, -0.01045134f, -0.07031158f, 0.00683529f, 0.01101926f, 
    -0.07155914f, -0.05086996f, 0.06319451f, -0.00636746f, 0.01628773f, -0.02337255f, -0.02107904f, -0.03714496f, 
    -0.05935900f, -0.07399432f, 0.01169675f, 0.00812944f, -0.00252219f, 0.02000644f, 0.02463865f, -0.07057044f, 
    -0.05521803f, 0.02292801f, -0.02606918f, -0.02533586f, -0.05655883f, 0.05640796f, -0.00254122f, -0.02969110f, 
    0.04257872f, 0.03028901f, 0.01360346f, 0.00529909f, 0.06491557f, -0.02597941f, -0.03405572f, 0.00458893f, 
    0.02363315f, 0.00942009f, 0.02422423f, 0.02273787f, 0.06342033f, -0.06350861f, 0.01516113f, -0.00711552f, 
    0.02265020f, -0.02268312f, 0.04730333f, -0.02457875f, -0.01634799f, 0.04652528f, -0.06880409f, -0.07075392f, 
    -0.06777932f, -0.03739505f, 0.02711632f, -0.00760717f, -0.05301167f, -0.04995899f, -0.06399124f, 0.02911449f, 
    -0.01083498f, -0.01938783f, -0.05762990f, 0.01688084f, 0.01354125f, -0.02752645f, -0.06572699f, 0.04924588f, 
    -0.06179922f, 0.01462841f, -0.05738639f, -0.04147591f, -0.07303090f, 0.06423111f, -0.07473216f, -0.05614844f, 
    0.01483642f, -0.06869042f, 0.03092466f, -0.02458041f, -0.06387060f, 0.00371129f, 0.02093307f, -0.03251024f, 
    -0.01697325f, 0.00444974f, -0.07100846f, 0.02541931f, -0.03639220f, 0.06330603f, 0.01304483f, -0.04413584f, 
    -0.03798508f, 0.03308039f, -0.06014727f, 0.00807488f, 0.03895889f, 0.06597903f, -0.01294939f, 0.01394927f, 
    0.02065602f, -0.02871714f, 0.03682201f, -0.00646397f, 0.00595730f, -0.00838137f, -0.00706097f, 0.06164205f, 
    0.00793777f, 0.05491960f, 0.01284832f, -0.07316444f, -0.07222030f, 0.03327411f, -0.01516417f, 0.04422684f, 
    -0.05195970f, -0.00241396f, 0.04403767f, -0.01187358f, -0.06453905f, -0.02897867f, 0.03923995f, -0.05223116f, 
    0.04069766f, -0.02457503f, -0.05671060f, 0.03883532f, 0.04310784f, 0.06195275f, -0.01198572f, 0.02955241f, 
    -0.02532566f, 0.06384404f, -0.05842519f, -0.03418465f, -0.03881060f, -0.07385285f, 0.00609842f, -0.05303260f, 
    -0.00564937f, -0.05739995f, 0.01288002f, -0.04549360f, -0.01114234f, 0.05032379f, 0.05591963f, -0.00375829f, 
    -0.02249597f, -0.05259076f, 0.05130536f, 0.01686914f, -0.00559623f, -0.01195465f, 0.00946455f, -0.01616720f, 
    0.01500075f, -0.01472601f, -0.03911758f, -0.02945216f, 0.06156836f, -0.01881077f, -0.06036590f, -0.02879121f, 
    -0.00765893f, -0.01575055f, -0.03901635f, -0.07292324f, -0.07396262f, -0.06550220f, -0.03899501f, -0.03740157f, 
    0.01394283f, -0.07129226f, -0.13162655f, -0.20663470f, -0.06521244f, 0.09426174f, 0.11221431f, -0.02564189f, 
    0.07739750f, -0.08228482f, 0.09347256f, 0.07410890f, -0.57879490f, -0.00240551f, -0.15762097f, 0.20873144f, 
    0.20568107f, -0.10774177f, -0.05272815f, 0.04999982f, 0.16531983f, 0.15148504f, 0.06195267f, -0.08135966f, 
    0.23799887f, -0.28786564f, 0.01374165f, -0.01309253f, 0.01442945f, -0.09492019f, -0.03805626f, -0.01321566f, 
    0.03991907f, -0.13812748f, -0.05557117f, -0.11902259f, 0.00658117f, -0.05503252f, -0.17602551f, -0.27158886f, 
    0.00294744f, -0.06716688f, 0.07031328f, -0.01411573f, 0.12916735f, 0.03514137f, 0.02719717f, -0.03584585f, 
    -0.11693369f, 0.29479825f, -0.06913083f, 0.16626592f, 0.10057019f, -0.09685837f, -0.20316231f, 0.06392121f, 
    0.00519647f, 0.23501508f, 0.05536906f, -0.04283336f, 0.03916585f, 0.04842183f, -0.14313152f, 0.06632881f, 
    0.07013659f, -0.04135619f, 0.00439496f, -0.09214079f, -0.02784220f, -0.00516818f, -0.03262933f, -0.11504171f, 
    0.27782539f, 0.10364999f, 0.12878868f, 0.10470293f, 0.04847423f, -0.11010342f, -0.08510403f, -0.04487043f, 
    -0.07063644f, 0.11352245f, 0.00391213f, 0.00912544f, 0.33846146f, -0.14919360f, -0.17093059f, -0.06909291f, 
    0.10528822f, -0.11796401f, 0.06077427f, -0.15169059f, -0.00665537f, 0.01678467f, -0.01621915f, 0.05205683f, 
    0.08491562f, 0.03104600f, 0.08539490f, 0.05469300f, -0.05452106f, 0.12119165f, -0.06457240f, 0.09302961f, 
    0.00359443f, 0.04667487f, -0.11818521f, -0.12163980f, 0.22300926f, 0.06364601f, 0.21594514f, 0.48353612f, 
    0.01572195f, 0.08856940f, 0.07404783f, 0.08240535f, 0.01400774f, -0.01413412f, -0.05145927f, -0.12658319f, 
    0.03627497f, 0.11072341f, -0.27706105f, 0.46912938f, 0.26162118f, -0.04965356f, -0.00033624f, -0.08401499f, 
    0.00498857f, 0.01535909f, 0.04127633f, -0.08939549f, -0.14252068f, 0.22091568f, 0.08164120f, 0.16436881f, 
    -0.04878049f, -0.02675495f, 0.06875583f, 0.16384251f, 0.11038220f, 0.02403793f, -0.03709649f, -0.05127952f, 
    -0.19607337f, 0.24955936f, 0.32648322f, -0.02052459f, 0.10076320f, -0.02923813f, -0.18978956f, 0.10797343f, 
    -0.04390998f, 0.02568462f, 0.02445003f, 0.00885019f, 0.39266512f, -0.00877645f, -0.01259463f, 0.04345405f, 
    0.13279364f, 0.02543357f, -0.01752933f, -0.07561509f, -0.15042895f, -0.01323424f, 0.05792547f, 0.06595486f, 
    -0.21139917f, 0.02401035f, 0.07904796f, 0.02696505f, 0.11448873f, -0.02726047f, 0.06640954f, 0.07564469f, 
    -0.00792786f, 0.17840931f, 0.17169628f, 0.14347386f, 0.21802461f, -0.12837288f, -0.14771539f, 0.03023937f, 
    -0.08147012f, -0.07118474f, 0.14198163f, -0.02171555f, -0.15651093f, 0.10964592f, 0.20075387f, 0.07313662f, 
    -0.04128047f, -0.06680662f, -0.01727803f, -0.05533831f, -0.06814974f, -0.00994461f, -0.04745237f, -0.03648924f, 
    0.02355817f, -0.05667340f, -0.04017147f, 0.03325184f, 0.07037034f, -0.01319071f, -0.02303664f, -0.04380284f, 
    -0.00065737f, -0.07421913f, 0.03150710f, -0.07922885f, -0.01929585f, 0.00002552f, -0.00526223f, 0.02402771f, 
    -0.05383777f, 0.02820556f, -0.06553839f, 0.00241272f, -0.02871198f, -0.06158686f, 0.04650215f, -0.02668380f, 
    0.01158629f, -0.05405296f, -0.06375077f, 0.03833190f, -0.07311451f, -0.06995393f, -0.00763337f, 0.01101364f, 
    -0.07911482f, 0.06520391f, -0.00853513f, 0.03842292f, 0.05392315f, -0.06082033f, -0.05132648f, -0.03853841f, 
    -0.02965282f, -0.06830196f, 0.00239256f, -0.05144258f, 0.03485741f, -0.04754027f, -0.03968006f, 0.01240056f, 
    -0.07250307f, -0.07104747f, 0.04270374f, 0.02146989f, 0.05289147f, 0.00171579f, -0.06183635f, 0.06551591f, 
    -0.01794526f, 0.04190368f, -0.01835435f, -0.05013613f, 0.02391943f, -0.02253509f, 0.04656712f, 0.02519347f, 
    0.03348205f, -0.01033912f, -0.07394925f, -0.00833059f, 0.02257243f, -0.07756887f, 0.04146734f, 0.05927971f, 
    -0.04306174f, -0.02147568f, 0.06248599f, -0.03344547f, -0.01244665f, -0.02945690f, -0.04637231f, -0.00741482f, 
    -0.03811845f, -0.07472810f, 0.02736968f, -0.06756525f, -0.01164327f, -0.01574853f, -0.05897895f, 0.02168493f, 
    -0.02817277f, -0.01199070f, -0.05744522f, 0.01125497f, 0.04082817f, 0.04096605f, -0.06177242f, 0.00405554f, 
    0.00482798f, 0.04436557f, -0.01233207f, -0.05564489f, 0.05570958f, -0.03324521f, 0.03490443f, 0.05091152f, 
    0.00935199f, -0.04210484f, 0.00252146f, -0.06482314f, -0.07747043f, -0.01354032f, 0.07010233f, 0.05588755f, 
    -0.04421612f, -0.04083820f, 0.02611117f, 0.04085377f, 0.04499218f, -0.08006403f, -0.07163766f, 0.00329685f, 
    0.02249625f, 0.01248952f, 0.02494541f, -0.04826105f, 0.05532312f, 0.05614935f, 0.06750636f, -0.03298643f, 
    0.01437101f, -0.02135752f, -0.00669770f, 0.05391744f, 0.04370301f, 0.05611415f, 0.03392391f, -0.02189866f, 
    0.05468914f, 0.00432180f, -0.02068045f, 0.05467189f, -0.03786751f, 0.05545055f, -0.06157698f, -0.04903028f, 
    0.02078936f, -0.01718901f, 0.06268624f, -0.07499021f, 0.00930580f, -0.00726190f, -0.04474266f, -0.06659830f, 
    -0.06475504f, 0.03805942f, -0.07203179f, -0.03568708f, -0.01350411f, 0.02939157f, 0.02008452f, 0.00408347f, 
    -0.04225915f, -0.02097437f, -0.00090016f, -0.00312992f, -0.05733420f, -0.06456356f, 0.02552723f, 0.02921433f, 
    -0.01455622f, -0.03441105f, -0.04871547f, 0.06002337f, -0.02819066f, -0.04617261f, 0.01626506f, 0.05807427f, 
    0.02870128f, 0.04569665f, 0.02569294f, 0.04063669f, 0.00013917f, 0.01421885f, -0.03610039f, -0.06484898f, 
    -0.04809920f, -0.03652968f, -0.07422592f, 0.04916508f, -0.04389612f, -0.00647733f, 0.02716372f, 0.04661250f, 
    -0.06889857f, -0.04511681f, 0.01649060f, 0.03376963f, 0.04261726f, -0.04935777f, -0.06826231f, -0.01858860f, 
    -0.06851804f, -0.08285045f, 0.01557746f, -0.05590732f, -0.06956999f, 0.06351615f, 0.04364570f, 0.00629111f, 
    -0.03081207f, 0.01340992f, -0.03869811f, 0.04194456f, 0.06027149f, 0.03071903f, -0.03608261f, 0.02394719f, 
    0.06367652f, 0.00940063f, 0.05708873f, -0.04504592f, 0.05751975f, 0.03841992f, 0.01126932f, 0.04591543f, 
    0.04213051f, -0.06846566f, 0.03423825f, 0.06013298f, 0.05307828f, -0.03589806f, -0.05269516f, -0.04841961f, 
    0.02156376f, -0.03198089f, -0.05306526f, -0.06313261f, -0.06595634f, 0.04090670f, -0.07053372f, 0.03664023f, 
    0.05008383f, 0.03828492f, 0.01717487f, 0.00414168f, 0.00481499f, -0.04477531f, -0.05242984f, -0.04798952f, 
    -0.00076544f, -0.05080208f, -0.00596158f, 0.03924464f, -0.01664729f, -0.05692104f, -0.00614162f, 0.05912939f, 
    0.03097213f, -0.03196958f, -0.05020526f, 0.00596654f, 0.06110107f, -0.02918300f, 0.04853231f, -0.00843039f, 
    0.01340400f, 0.02276093f, 0.04886488f, 0.01510789f, -0.02728365f, -0.05887114f, -0.05600800f, -0.08273068f, 
    0.03116407f, -0.05347868f, 0.04226502f, 0.03362066f, -0.03507088f, -0.07354515f, -0.01714130f, 0.02426417f, 
    0.04041445f, -0.03673393f, 0.00123732f, -0.02001552f, -0.02844604f, -0.04917781f, 0.01058427f, -0.06154845f, 
    0.01302646f, -0.07463816f, 0.01629946f, -0.06943799f, 0.01156469f, 0.06493697f, 0.01948466f, 0.01623240f, 
    0.01893442f, 0.04597640f, -0.07860113f, -0.04012398f, 0.03888165f, 0.00455288f, -0.03852160f, -0.00555845f, 
    0.04831406f, -0.02716468f, 0.03363279f, 0.05892001f, -0.01439464f, 0.03843359f, -0.06968013f, -0.02266151f, 
    -0.05574816f, -0.05221118f, -0.04329391f, 0.05295381f, 0.01863423f, -0.05333607f, -0.06086697f, 0.04954336f, 
    -0.01586374f, 0.03242728f, -0.08154509f, -0.01295748f, -0.06377130f, 0.04492098f, 0.04047541f, -0.00801409f, 
    0.02438292f, -0.00916083f, -0.04319356f, -0.05639683f, -0.04846977f, -0.02260929f, -0.01583441f, 0.02240435f, 
    -0.06523439f, -0.04247269f, 0.01505032f, 0.00860276f, 0.04246483f, -0.04108280f, -0.02091318f, -0.03799763f, 
    -0.02806196f, -0.00337024f, 0.01568034f, -0.01493484f, -0.05694110f, 0.00969525f, 0.01611682f, -0.06429219f, 
    0.04661511f, -0.07711862f, 0.03195329f, -0.07150576f, -0.03206202f, -0.04138166f, 0.00402247f, -0.06129965f, 
    -0.00347289f, 0.01062001f, 0.03454249f, 0.02941877f, -0.00272633f, 0.03589034f, -0.06215451f, -0.00153958f, 
    -0.04540849f, 0.02056724f, 0.01302996f, 0.03900531f, -0.05877093f, -0.03467476f, -0.00715282f, 0.02055315f, 
    -0.03244676f, 0.00723802f, 0.01593475f, -0.00696493f, 0.06005864f, -0.01426665f, -0.04832283f, -0.02495572f, 
    -0.04989897f, -0.02106651f, 0.01761090f, -0.01179629f, -0.05883026f, -0.05112650f, -0.03505993f, 0.00771510f, 
    -0.04270583f, -0.03201399f, 0.03468515f, 0.01720899f, -0.01264991f, 0.01958198f, 0.01680319f, 0.06552985f, 
    0.02614716f, 0.03660558f, 0.06113688f, -0.04797281f, -0.01588380f, -0.06672869f, 0.04841856f, -0.04802236f, 
    0.05933387f, 0.03850710f, 0.05758142f, 0.05739681f, -0.06700063f, 0.02034424f, -0.01141380f, 0.05658236f, 
    -0.05811458f, -0.07074852f, 0.03984251f, 0.05860311f, 0.01293578f, 0.01379875f, -0.03886356f, 0.00286512f, 
    -0.03743981f, -0.02107162f, 0.05962177f, -0.06032781f, 0.03895578f, 0.03771307f, -0.00527200f, -0.05234103f, 
    0.03611906f, 0.01427739f, 0.01754797f, -0.02138618f, -0.06347989f, 0.05737776f, 0.03978845f, 0.04053210f, 
    0.05566289f, -0.02277443f, -0.07416841f, 0.01078392f, -0.04279787f, -0.02329525f, -0.06160624f, -0.07462112f, 
    -0.06490695f, -0.01191673f, 0.05552516f, -0.05563848f, -0.07136825f, -0.02384426f, 0.03848634f, 0.01283415f, 
    0.06147772f, 0.06248133f, -0.04497807f, 0.01222499f, -0.00546843f, -0.06668513f, -0.02069734f, -0.02611405f, 
    -0.06346938f, 0.05238907f, -0.03728150f, -0.03329206f, 0.01812843f, 0.05999893f, -0.04523340f, -0.05448887f, 
    -0.00944460f, -0.07442828f, -0.04922550f, 0.00469251f, 0.04876224f, 0.02665756f, -0.01937856f, -0.05964287f, 
    -0.04129628f, -0.01914886f, -0.06113480f, -0.00998897f, -0.03378582f, -0.01308172f, -0.04627632f, 0.02455967f, 
    -0.03373021f, 0.04964708f, 0.01765298f, -0.05164432f, 0.04488626f, 0.02197386f, -0.01906251f, -0.06400555f, 
    0.01189399f, 0.03647092f, 0.00440587f, -0.07690368f, -0.05428633f, -0.04203276f, -0.04840505f, -0.06712296f, 
    0.05336616f, -0.05109150f, 0.04636537f, -0.06750497f, 0.06549332f, 0.02933076f, -0.02949191f, 0.04617516f, 
    0.04089936f, 0.03202491f, -0.00153634f, -0.03204457f, -0.05099534f, -0.00586232f, -0.02918311f, -0.06843311f, 
    0.05540461f, 0.05183412f, 0.00410422f, -0.07952693f, -0.06509396f, 0.00480260f, -0.04647656f, -0.06115102f, 
    0.03329616f, -0.03346845f, 0.02864695f, -0.06984752f, 0.05096921f, 0.01765008f, -0.05379980f, -0.04617469f, 
    0.04749741f, 0.04304949f, -0.05764509f, 0.06345246f, 0.01693986f, 0.03942569f, 0.06488483f, 0.03339435f, 
    -0.03914791f, -0.00907881f, -0.06645659f, 0.04191536f, -0.00574377f, -0.03657300f, -0.04214078f, 0.04718937f, 
    -0.07172187f, -0.07005329f, -0.03000661f, -0.03839063f, -0.01625804f, 0.05979028f, 0.05214107f, -0.00021128f, 
    -0.02359045f, -0.07775541f, 0.02175891f, 0.00536358f, -0.00133765f, -0.03182626f, 0.00532595f, -0.00440536f, 
    0.19495246f, 0.15341349f, 0.05313728f, -0.15455730f, -0.06335852f, -0.00710823f, -0.14315318f, 0.00740738f, 
    0.06089637f, -0.00225045f, 0.14630619f, 0.13969548f, 0.24211657f, -0.00442964f, -0.03646665f, 0.08363590f, 
    -0.02549445f, -0.10266652f, -0.00762647f, 0.07589953f, 0.08093118f, 0.18914224f, 0.03653512f, -0.15282498f, 
    -0.21631549f, 0.09024952f, -0.12318286f, 0.02042680f, -0.15220886f, 0.05863078f, 0.21726930f, -0.09273179f, 
    -0.05225412f, 0.15932095f, -0.14516680f, -0.09159788f, -0.11139650f, -0.06542005f, 0.06717132f, 0.41266423f, 
    0.03061894f, -0.09042116f, 0.18734242f, 0.06652939f, 0.08306825f, -0.02185585f, -0.04193166f, -0.07956934f, 
    -0.05161141f, -0.06464002f, -0.11581186f, -0.00022869f, -0.05741940f, 0.04252945f, 0.12963296f, -0.23304266f, 
    -0.24312431f, 0.06001547f, -0.03670030f, 0.00356215f, -0.47538561f, 0.17114767f, 0.22324552f, 0.02971130f, 
    -0.01240161f, -0.10916859f, 0.02683445f, 0.12500149f, 0.02047836f, -0.14169005f, 0.04054250f, -0.14107201f, 
    -0.21946844f, 0.23637047f, -0.23880909f, -0.08816527f, 0.24333617f, -0.01230252f, 0.00520412f, 0.20728597f, 
    0.03904461f, 0.00209322f, 0.02067737f, 0.12975933f, -0.03503828f, 0.15547533f, 0.08104095f, 0.08232941f, 
    0.01246309f, -0.06108994f, -0.13062158f, -0.06864946f, 0.16225266f, 0.04622598f, -0.00156560f, -0.01228774f, 
    0.09019554f, -0.02604816f, -0.24070674f, 0.20688777f, 0.10591770f, 0.08025069f, 0.13593420f, 0.03882496f, 
    0.01292961f, -0.05075091f, -0.05075020f, 0.14482149f, -0.42458779f, 0.20817320f, -0.00511552f, 0.02332470f, 
    -0.00397317f, -0.03497640f, -0.03677152f, -0.08622999f, -0.03709717f, -0.11167064f, 0.08910903f, 0.00578233f, 
    0.26553404f, -0.05393657f, -0.18841173f, 0.06062429f, -0.04647838f, -0.09256022f, 0.04351624f, 0.04419902f, 
    0.09563427f, 0.00205514f, -0.00919759f, -0.13554786f, 0.07629340f, 0.14798383f, 0.12455024f, 0.19645739f, 
    -0.05351793f, 0.01656612f, 0.21252392f, 0.09415061f, -0.10458001f, 0.11638022f, 0.19372296f, -0.12420928f, 
    0.44039300f, -0.01247495f, -0.07580779f, 0.16295230f, -0.26657188f, 0.03097253f, -0.10255678f, 0.07325800f, 
    0.04997579f, -0.04091744f, -0.05920576f, -0.06590678f, -0.02736652f, -0.23818189f, -0.14794718f, -0.06286328f, 
    0.08573427f, -0.07045808f, -0.05510134f, 0.10537809f, 0.08017951f, 0.00116107f, -0.12349369f, -0.08807195f, 
    0.30328241f, -0.05246960f, -0.09750613f, 0.22382906f, 0.05816673f, 0.12449472f, 0.17333506f, -0.01553751f, 
    0.18892226f, -0.02887362f, -0.00981164f, 0.06802534f, -0.39244542f, -0.03072957f, -0.08519413f, -0.00798698f, 
    0.25071782f, -0.06053390f, -0.00474402f, -0.15600532f, -0.07774340f, 0.11332121f, -0.10306033f, 0.00513611f, 
    -0.24531600f, 0.12163993f, -0.04219030f, 0.15748504f, -0.12560244f, 0.02312774f, 0.08570818f, 0.01664376f, 
    0.00577662f, 0.03030770f, 0.22647840f, 0.00200461f, -0.04245027f, 0.19277841f, 0.01195341f, -0.30965307f, 
    0.03955675f, 0.03740477f, -0.01492563f, 0.06500403f, -0.01309155f, 0.08709362f, -0.06113625f, 0.00430179f, 
    -0.20854373f, 0.41221288f, 0.14884511f, 0.09679759f, -0.11811316f, 0.01488996f, 0.03947429f, -0.03509890f, 
    0.01153002f, -0.09477564f, 0.03976666f, -0.06556463f, 0.36029872f, 0.11717453f, -0.05380464f, -0.15698631f, 
    0.11472306f, 0.14206484f, 0.04148859f, -0.11915250f, -0.10229097f, 0.03822682f, 0.12582842f, 0.03335238f, 
    -0.22541264f, -0.10844540f, 0.08929393f, 0.03458615f, 0.08709482f, 0.04782858f, 0.14691980f, 0.12889124f, 
    0.04767109f, -0.16839011f, -0.07314752f, -0.00370195f, 0.10931992f, 0.18967009f, -0.12908596f, -0.17336266f, 
    0.09989934f, 0.12601671f, -0.00107988f, 0.14314549f, 0.10626782f, 0.02683707f, 0.07486423f, 0.09114785f, 
    0.36379766f, 0.11766435f, -0.23796593f, -0.08031286f, 0.12244534f, 0.11665679f, 0.00252467f, 0.07884439f, 
    -0.00709572f, 0.02084246f, 0.05742399f, 0.05444921f, 0.09478975f, 0.30088755f, 0.29194623f, -0.14050256f, 
    0.03332704f, 0.20170118f, 0.08036589f, 0.10444109f, -0.00438757f, 0.00261559f, 0.02518913f, 0.11798652f, 
    -0.14093289f, -0.07947511f, 0.08044764f, 0.01231199f, 0.20489341f, 0.02457663f, 0.13001955f, 0.17236893f, 
    0.19737843f, 0.13906270f, 0.08761115f, 0.03496085f, 0.18464960f, -0.27629796f, -0.24449177f, -0.15654898f, 
    -0.05173917f, -0.06045968f, -0.00346523f, -0.11537085f, 0.11324407f, 0.06491871f, 0.07138766f, 0.12832125f, 
    -0.32607436f, 0.05847973f, 0.02722276f, -0.48343059f, -0.13435845f, -0.02447437f, 0.01710576f, 0.07283834f, 
    0.07349903f, 0.08696271f, -0.19300868f, 0.18994287f, 0.03914230f, -0.31143853f, -0.24552698f, -0.18043935f, 
    0.06842403f, -0.08586088f, -0.03327820f, 0.06566292f, -0.00763899f, 0.00834924f, -0.07434566f, -0.06029683f, 
    -0.04099172f, -0.20673588f, -0.09527720f, -0.06297090f, -0.13853088f, 0.07480066f, 0.17148708f, -0.05600551f, 
    0.05007008f, 0.09812506f, 0.00793883f, 0.01121126f, -0.18499874f, 0.05146055f, 0.26639676f, 0.15954502f, 
    0.03240915f, 0.06986398f, 0.06795467f, -0.03029999f, 0.05421233f, 0.05766158f, 0.05090092f, 0.12698306f, 
    -0.27881166f, -0.19411361f, 0.07204580f, -0.04103339f, 0.07857665f, -0.07328708f, 0.02616071f, -0.05333769f, 
    -0.07482825f, -0.12039813f, 0.03071664f, 0.18015116f, 0.15469950f, 0.10437477f, -0.00298010f, 0.16612652f, 
    -0.05170006f, 0.16712351f, -0.03210898f, 0.19148743f, 0.15310748f, 0.03734899f, 0.09518588f, -0.04834930f, 
    -0.29592103f, -0.11787029f, -0.08360692f, 0.04935120f, 0.03173514f, 0.17106943f, 0.09161112f, -0.00388365f, 
    0.01350690f, -0.00440905f, -0.16708809f, -0.00892762f, -0.60797411f, 0.04361282f, 0.13817509f, 0.04648874f, 
    0.09198737f, -0.13145870f, 0.13090587f, -0.02096747f, 0.08284862f, -0.09815352f, -0.02936661f, 0.11708299f, 
    0.12036496f, -0.39492103f, -0.06010363f, -0.16991894f, 0.02448131f, -0.00601162f, -0.13280229f, -0.05598086f, 
    0.12593549f, -0.08015747f, 0.13288251f, 0.09643836f, 0.15613486f, 0.02418079f, 0.00466612f, -0.27566111f, 
    0.08226435f, 0.13581367f, -0.10773461f, 0.00459442f, -0.04378401f, 0.23987770f, 0.17586038f, 0.21131657f, 
    0.05832726f, -0.01674918f, 0.10541934f, -0.10240795f, 0.17459062f, -0.01222383f, -0.27764294f, 0.04327330f, 
    0.14944187f, -0.07724402f, 0.15014347f, -0.20100422f, 0.24691467f, -0.00230101f, -0.25358653f, -0.12556313f, 
    -0.01345380f, -0.05329983f, 0.07584461f, -0.16275194f, -0.01238282f, 0.15915741f, 0.12092545f, 0.06236845f, 
    0.22899456f, -0.01798197f, 0.21746449f, 0.06026094f, -0.06911806f, -0.05252210f, -0.02614956f, -0.17993984f, 
    -0.03408797f, 0.04696443f, 0.10548264f, -0.08210070f, 0.13275369f, -0.22983597f, -0.07879317f, -0.05427889f, 
    0.10213964f, 0.02394669f, 0.22340073f, 0.05808732f, -0.04875405f, -0.04879846f, -0.00962832f, 0.06274910f, 
    0.09915161f, 0.00249254f, 0.08195138f, -0.06650284f, -0.09053524f, -0.05186871f, -0.11843417f, 0.00833528f, 
    -0.08193652f, 0.12213033f, -0.10286395f, 0.02497065f, 0.32621834f, -0.16141579f, -0.04039296f, 0.27986258f, 
    0.09116067f, -0.10443856f, -0.01748761f, 0.12147131f, 0.01144201f, 0.14888252f, -0.05616618f, 0.02395460f, 
    0.07049008f, 0.01975395f, -0.04824372f, 0.23920383f, 0.03387983f, 0.08929060f, 0.00754334f, 0.07419409f, 
    0.04298713f, 0.09644048f, 0.09621117f, 0.22376709f, 0.05563333f, 0.01389049f, 0.04054870f, -0.02587822f, 
    0.05313921f, -0.28179994f, -0.25565401f, -0.10412437f, 0.06413092f, -0.14026570f, -0.22937052f, 0.04114045f, 
    -0.07660730f, 0.17997859f, 0.37106395f, -0.10753641f, 0.17436954f, -0.10185409f, 0.05692250f, 0.00038559f, 
    0.02566502f, 0.04935830f, 0.09503340f, 0.01991603f, 0.22955471f, 0.13177387f, 0.11512351f, 0.00343998f, 
    0.10429793f, 0.11552139f, -0.06831238f, -0.00754205f, 0.00991576f, 0.01062199f, 0.11689353f, 0.16134338f, 
    -0.19436328f, -0.16614285f, 0.11359939f, 0.01006161f, 0.05491029f, -0.20124917f, -0.14078359f, 0.02136749f, 
    -0.07684787f, 0.27237585f, 0.05740818f, 0.07113653f, 0.25119457f, 0.06079128f, 0.00521899f, 0.00888108f, 
    -0.08854443f, 0.02597648f, 0.07200615f, 0.11759858f, -0.04148624f, -0.17626560f, 0.12644950f, -0.03109291f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05538892f, 0.05610528f, -0.00824344f, -0.00351231f, 0.11136954f, 0.05849840f, 0.00081866f, 0.04852789f, 
    -0.04064673f, -0.01085978f, -0.07308985f, 0.06943141f, -0.00482085f, 0.04984647f, 0.04338381f, -0.00364216f, 
    0.11695424f, 0.00753513f, 0.14153311f, 0.01911359f, 0.01720745f, 0.07709590f, 0.08746863f, 0.00199045f, 
    -0.03756498f, -0.01889362f, 0.00276257f, -0.01029956f, -0.07366411f, 0.07256272f, 0.16498664f, 0.08301967f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14344674f, -0.31541625f, 0.46042162f, 0.07167596f, 0.36133131f, 0.11955205f, -0.23966266f, 0.32303244f, 
    0.29213375f, -0.06863885f, 0.13080457f, 0.03212780f, 0.32836685f, 0.32878658f, -0.14202021f, -0.15921818f, 
    -0.06601880f, -0.30480811f, -0.26002610f, -0.14179777f, 0.04882118f, 0.22945763f, -0.51355922f, -0.02020751f, 
    0.06282589f, 0.27904117f, -0.17530510f, 0.12186040f, -0.14175780f, 0.09917602f, 0.11320002f, 0.33785176f, 
    -0.08747243f, -0.00904676f, -0.00383583f, -0.13486598f, -0.04052018f, 0.11000588f, -0.10530972f, -0.15556253f, 
    0.11992864f, 0.00715124f, -0.14634061f, 0.06201464f, -0.10818278f, -0.13990618f, 0.16272074f, -0.11012194f, 
    -0.14446975f, 0.04832136f, -0.10717908f, 0.12988572f, -0.03551904f, 0.13586193f, 0.05643386f, 0.03364104f, 
    -0.08530819f, 0.03896123f, -0.04357293f, 0.07921136f, 0.01972281f, -0.13314532f, 0.09546459f, -0.05733709f, 
    0.36698633f, -0.23045282f, -0.01850469f, -0.10290044f, -0.10730239f, 0.11725488f, 0.54013497f, -0.08253470f, 
    -0.27139622f, 0.22126684f, -0.00136639f, 0.20649107f, 0.27889144f, -0.19292693f, 0.10818221f, 0.15632105f, 
    0.01246498f, -0.01963508f, -0.07735573f, 0.01810083f, 0.08829065f, -0.69672430f, -0.23228292f, -0.10118269f, 
    0.15497510f, 0.19601463f, -0.03437265f, -0.17603578f, -0.02648367f, 0.11155278f, 0.14179005f, -0.11374526f, 
    0.04513330f, 0.32481027f, 0.35097095f, -0.00809208f, 0.29200959f, -0.02822344f, -0.10845245f, -0.02071892f, 
    0.69095379f, 0.08810934f, 0.28148976f, 0.03936447f, 0.29780102f, 0.45467439f, -0.12121452f, -0.05639586f, 
    -0.04010922f, -0.26399776f, -0.18304431f, 0.19416279f, 0.02570023f, -0.01947342f, -0.08356460f, -0.17141584f, 
    0.09894910f, -0.33578444f, -0.06019044f, 0.03890133f, -0.02322368f, 0.34296605f, 0.34632069f, -0.34345922f, 
    -0.12820692f, -0.43455997f, -0.18830577f, 0.10490899f, 0.02087004f, 0.07247892f, 0.30881616f, 0.23530483f, 
    -0.50710088f, -0.01057639f, -0.23966175f, 0.34657565f, 0.07026321f, 0.00254731f, 0.17127532f, -0.16667849f, 
    0.32595843f, 0.00922296f, 0.42194158f, -0.18896562f, -0.04096621f, -0.35664374f, 0.12223189f, 0.07440664f, 
    -0.15132162f, 0.02600821f, -0.02428169f, 0.06901766f, 0.09433468f, -0.02698003f, 0.23398221f, -0.04240927f, 
    0.13761644f, 0.25559646f, 0.35592407f, 0.09712707f, 0.04184706f, 0.06144134f, 0.31473020f, 0.01685684f, 
    0.35331714f, 0.38690636f, -0.04199837f, -0.02633671f, -0.10766638f, -0.33529478f, -0.09715746f, -0.03419686f, 
    -0.27056149f, 0.02944459f, 0.16203989f, 0.56687742f, 0.11243331f, -0.14704311f, 0.00646351f, 0.06490026f, 
    -0.07019433f, -0.21940845f, 0.18375881f, 0.08442217f, -0.07466829f, 0.32287544f, -0.20982915f, -0.31662947f, 
    0.29070821f, 0.51425743f, 0.21426642f, -0.09842089f, 0.20230339f, -0.00852995f, 0.37814638f, 0.13139381f, 
    -0.25947827f, 0.17235339f, -0.27971435f, -0.21889508f, 0.05506422f, 0.02583824f, -0.07620709f, 0.01527428f, 
    -0.48883927f, 0.27296716f, -0.43106359f, -0.39182132f, -0.10019822f, -0.12627099f, 0.32985550f, 0.04788437f, 
    -0.02659369f, -0.15188600f, 0.13614248f, -0.15722844f, -0.15401390f, -0.19536626f, 0.21503443f, 0.07675174f, 
    -0.04348248f, 0.10757932f, 0.17591919f, 0.11875877f, 0.27710822f, 0.04741725f, -0.16877249f, -0.15557484f, 
    0.62093484f, -0.16147964f, 0.41691449f, -0.09727334f, 0.07328942f, 0.25806484f, -0.10324156f, 0.07626814f, 
    0.21584006f, 0.10198776f, 0.07814822f, -0.07154506f, -0.13662481f, 0.42865935f, 0.03851852f, 0.07737797f, 
    0.07874606f, -0.12088531f, -0.12102019f, -0.05418472f, 0.04274637f, 0.29886162f, -0.06825479f, 0.15899190f, 
    -0.14040965f, 0.27965689f, 0.58266270f, 0.11952172f, 0.16669200f, 0.03642285f, -0.23496555f, 0.18389212f, 
    0.28226706f, 0.25945532f, 0.33235940f, -0.03519485f, -0.13901448f, 0.21758854f, 0.07158157f, -0.03663155f, 
    0.07105141f, -0.11467233f, 0.19272497f, 0.26947638f, 0.14288419f, 0.20666017f, 0.01621675f, 0.09450398f, 
    0.10937209f, -0.22166236f, 0.17210741f, 0.15643951f, -0.12289647f, 0.48019135f, -0.13695148f, -0.25903091f, 
    -0.19907475f, 0.18670493f, 0.47578534f, 0.06188517f, 0.31607312f, -0.15232411f, 0.00974189f, -0.12502514f, 
    0.09732676f, -0.22776914f, -0.33937579f, -0.22353302f, 0.35901266f, -0.14461364f, -0.03231003f, -0.02642290f, 
    0.29211920f, 0.43996239f, 0.27865884f, 0.01043747f, 0.06719204f, 0.57952344f, 0.22926658f, -0.04541252f, 
    0.08448264f, 0.29238757f, -0.11405193f, -0.01800266f, -0.14700507f, 0.16532470f, -0.20604371f, 0.42176229f, 
    -0.01532899f, 0.15228109f, -0.03741052f, -0.15414345f, 0.30603987f, 0.15051712f, -0.13716754f, -0.11608420f, 
    -0.22730817f, 0.05442451f, 0.26337612f, 0.23354790f, -0.64626616f, -0.19127867f, -0.03387090f, -0.03222067f, 
    0.28137103f, 0.27079174f, 0.33185041f, 0.04963681f, 0.13522956f, -0.14283213f, 0.36807027f, -0.13336740f, 
    0.11364093f, 0.26311964f, 0.03106350f, 0.02048058f, -0.14803056f, 0.30722103f, -0.52543122f, -0.19588700f, 
    0.29722574f, 0.65468502f, 0.00755703f, 0.17800862f, 0.11098050f, -0.12236807f, -0.25808650f, 0.40595943f, 
    -0.27338895f, -0.09548076f, -0.20800136f, 0.06936101f, -0.11408942f, -0.01250107f, -0.00450929f, 0.07000060f, 
    -0.13157004f, -0.60110790f, -0.32598442f, -0.59169924f, -0.11349121f, 0.36554614f, 0.17137651f, -0.00450941f, 
    0.11480013f, 0.33206737f, 0.03479177f, -0.10613713f, -0.12311538f, -0.20447922f, 0.21446681f, 0.04260319f, 
    -0.18451899f, -0.26190880f, 0.43565792f, 0.05775076f, 0.19678551f, 0.13491786f, -0.28200862f, 0.34585884f, 
    0.24513337f, 0.08725347f, 0.00274678f, 0.15293784f, -0.16524345f, 0.04112852f, 0.05170792f, 0.08798323f, 
    0.07485064f, -0.01877226f, 0.10098195f, -0.09863313f, 0.07681017f, 0.63205659f, 0.09202820f, 0.02549560f, 
    0.17271334f, 0.11789636f, 0.05517023f, -0.15664549f, 0.08301435f, -0.19647403f, -0.30110291f, 0.33110377f, 
    0.29578364f, 0.06078888f, -0.53627080f, 0.06441735f, -0.19977961f, -0.08633789f, -0.34036240f, 0.34702003f, 
    0.07753916f, 0.02754266f, -0.10137808f, 0.06690861f, -0.07369430f, 0.23637332f, 0.14409652f, -0.15663677f, 
    0.11419859f, 0.01054873f, -0.09077613f, -0.16600122f, -0.07859960f, 0.14244214f, 0.29020196f, -0.04909954f, 
    -0.14892334f, -0.15836328f, 0.05056334f, -0.09997900f, -0.02649098f, -0.46301407f, 0.22160256f, 0.32036114f, 
    0.25415263f, 0.42255315f, 0.01673469f, 0.17152272f, -0.01609142f, 0.04724934f, 0.19039257f, 0.13360460f, 
    -0.41402754f, -0.25383189f, -0.61316603f, -0.43185619f, 0.36543870f, -0.26156533f, -0.14800248f, -0.16916414f, 
    0.20234257f, 0.12653568f, -0.01563316f, -0.39005247f, -0.08064021f, 0.02461672f, 0.07959764f, 0.08371886f, 
    0.03401639f, 0.42435783f, -0.06672540f, 0.11608513f, 0.05807550f, -0.45422062f, 0.27822572f, 0.47444177f, 
    -0.17222475f, 0.06248764f, 0.02724311f, 0.13998564f, 0.11180554f, 0.00714872f, 0.40442547f, 0.04012007f, 
    0.43013149f, 0.20538294f, -0.28982332f, -0.13445376f, 0.04541691f, -0.13263153f, -0.02951953f, 0.16883615f, 
    0.15383343f, -0.12809695f, 0.19656385f, 0.19777437f, 0.01656298f, 0.43970826f, 0.02793113f, -0.13943218f, 
    0.01145781f, -0.20526385f, 0.13061358f, 0.14583096f, 0.13658114f, 0.13422410f, 0.31391180f, -0.16954879f, 
    -0.12655436f, 0.39256841f, -0.30793142f, -0.11041289f, 0.03068598f, 0.13795894f, 0.34346631f, -0.10932744f, 
    0.09020665f, 0.22293068f, -0.22820081f, -0.02444221f, 0.21840891f, 0.33186331f, 0.03738947f, 0.05910495f, 
    -0.01525981f, 0.33617187f, -0.13435371f, -0.13559651f, 0.14451021f, 0.07530125f, 0.52913231f, -0.05634707f, 
    0.01419385f, -0.42729616f, 0.04360118f, -0.01227800f, 0.12094679f, -0.02000289f, 0.40451297f, 0.05716880f, 
    0.01166332f, -0.18609540f, 0.34924436f, 0.04341671f, 0.49243054f, -0.00416184f, -0.26093796f, 0.27705735f, 
    0.24222796f, 0.10021029f, -0.16807441f, -0.03661643f, -0.21275175f, 0.10373043f, 0.12154201f, -0.00984409f, 
    -0.25639641f, 0.39229187f, -0.32991987f, -0.27254668f, -0.07977512f, 0.78230155f, 0.38876382f, -0.06358352f, 
    -0.12931353f, 0.14872578f, -0.04192485f, -0.02840692f, 0.04132817f, -0.10737428f, -0.21175298f, 0.30409271f, 
    -0.10033012f, 0.67868602f, 0.02229566f, -0.06661162f, -0.28271684f, 0.17306148f, 0.34944323f, -0.11756629f, 
    0.11035465f, 0.27170324f, -0.18482274f, 0.03486096f, 0.03663055f, -0.24317347f, 0.05180507f, -0.08849049f, 
    0.38297799f, -0.15158907f, 0.67718202f, 0.34985447f, 0.12232248f, 0.02023998f, 0.01970928f, 0.05154083f, 
    0.12653092f, 0.36833930f, 0.00431032f, -0.01194010f, -0.08356896f, -0.26503259f, 0.00979792f, 0.29516771f, 
    0.17512113f, 0.00229710f, 0.25216967f, -0.17671743f, 0.20549348f, 0.11750793f, 0.08134103f, -0.09571747f, 
    -0.16435912f, 0.40325072f, 0.39873543f, 0.16899659f, -0.34008390f, -0.20555802f, -0.14312693f, -0.04304271f, 
    -0.25555485f, 0.27280831f, -0.05049562f, 0.23317491f, -0.13848227f, -0.10227244f, 0.24928662f, -0.08066169f, 
    -0.11127560f, 0.04411731f, 0.08490848f, 0.04362098f, 0.00020914f, 0.33533499f, -0.20575561f, -0.37449473f, 
    0.06541780f, -0.27093491f, -0.07852134f, 0.01457887f, -0.11701687f, 0.16590437f, -0.26892644f, 0.02549168f, 
    0.30902389f, 0.22360915f, 0.50006843f, 0.35927391f, -0.01656450f, 0.16298857f, -0.00467047f, 0.08879899f, 
    0.08241149f, 0.14659382f, 0.05228486f, 0.32596758f, 0.12069851f, 0.35233423f, 0.05430868f, -0.05506094f, 
    -0.05906444f, -0.32426995f, 0.03902658f, 0.12939362f, -0.02463372f, -0.20468581f, -0.05604836f, 0.18790053f, 
    0.21473314f, -0.54682201f, 0.42825475f, 0.12866752f, 0.01969223f, 0.07120826f, 0.13809852f, 0.37588227f, 
    -0.04763892f, -0.27208987f, -0.09573164f, -0.07864731f, 0.28209555f, 0.00406658f, -0.10517787f, 0.00060318f, 
    0.27271295f, 0.24702981f, -0.30182925f, -0.20799682f, -0.06393027f, -0.28563949f, -0.23739691f, -0.00145255f, 
    -0.07134736f, 0.46710166f, -0.14816360f, 0.12614384f, -0.09738372f, 0.05691009f, -0.11366414f, 0.22646999f, 
    0.42367768f, 0.18974811f, -0.40667975f, 0.12137753f, -0.16126244f, -0.04683489f, -0.05651158f, 0.20645562f, 
    -0.42208052f, 0.11666420f, 0.33727384f, 0.11516456f, -0.42709142f, -0.35255751f, 0.09857032f, 0.14551885f, 
    0.37798840f, -0.02860819f, -0.23281716f, 0.19516079f, -0.05570266f, -0.27501529f, 0.27475929f, 0.02367952f, 
    -0.13616998f, 0.32477987f, -0.07860773f, 0.12613541f, -0.06644700f, 0.17623605f, -0.12904592f, 0.07758101f, 
    0.25804266f, 0.00314523f, -0.27282313f, 0.03086195f, -0.00840185f, -0.01553160f, -0.05380199f, -0.33961838f, 
    0.37287381f, -0.13399100f, 0.18328953f, 0.27819070f, 0.09954972f, -0.11269639f, -0.12108704f, -0.09815791f, 
    0.51731652f, -0.19752637f, 0.45451820f, 0.09870146f, 0.10322437f, -0.20106825f, -0.40028501f, -0.15774982f, 
    0.00387544f, 0.21383810f, 0.08324864f, -0.02721557f, 0.06179266f, 0.26287946f, 0.13677393f, 0.09963587f, 
    0.15749444f, -0.20220231f, 0.23812242f, 0.01419806f, 0.12543900f, -0.01697721f, 0.55634224f, -0.18447690f, 
    -0.11303660f, -0.07875795f, -0.07872781f, -0.12658136f, 0.40387473f, 0.23769537f, -0.08961247f, -0.15759340f, 
    -0.02789736f, 0.46337163f, -0.01480007f, -0.22129934f, 0.03332192f, -0.30784002f, -0.05890992f, -0.02454715f, 
    0.04814195f, 0.03812644f, 0.12090601f, 0.12716402f, 0.02265313f, 0.33642146f, 0.26512989f, -0.17992137f, 
    0.19486429f, 0.22680011f, -0.49050152f, 0.06182118f, 0.04162508f, 0.11465599f, -0.01162776f, -0.08255714f, 
    -0.14049551f, 0.07982364f, -0.01980898f, 0.40399188f, -0.06646745f, -0.22624901f, -0.09992108f, 0.08971246f, 
    0.34074274f, -0.13047476f, 0.50724912f, -0.17314374f, -0.16379589f, -0.49756107f, -0.18863773f, 0.15164562f, 
    0.05144224f, -0.19297656f, 0.01136881f, 0.04507596f, -0.00994870f, 0.29783863f, 0.11606792f, -0.03170742f, 
    -0.37137318f, -0.32711932f, 0.45739874f, 0.05766759f, -0.19225305f, 0.06705195f, 0.29614854f, 0.29237649f, 
    -0.19843511f, 0.22071454f, -0.39922416f, 0.10677744f, 0.36849385f, 0.33752015f, -0.12943180f, -0.05861662f, 
    -0.10814226f, 0.05687834f, 0.41251290f, -0.33439997f, 0.16244838f, -0.15936385f, -0.06792656f, 0.00139147f, 
    0.13655247f, -0.14454503f, 0.12714255f, -0.13643026f, -0.15503091f, -0.04926775f, 0.22157758f, 0.04334005f, 
    0.15820928f, -0.08132779f, -0.11278346f, 0.07126527f, -0.04382023f, 0.00011009f, 0.07332064f, -0.14572421f, 
    -0.12660301f, -0.02643030f, 0.03721088f, -0.07561423f, -0.11898701f, 0.05111062f, -0.11479588f, -0.13715166f, 
    -0.03254349f, 0.06516884f, -0.06924948f, 0.01232448f, 0.05678289f, -0.10349813f, -0.03001683f, -0.17330605f, 
    0.16748957f, -0.09062644f, -0.15644898f, 0.06605384f, -0.00210239f, 0.04802233f, -0.13710491f, -0.15284951f, 
    -0.12062373f, -0.51416749f, -0.27140388f, -0.08122190f, 0.26224726f, 0.05430822f, 0.20348747f, 0.24719222f, 
    -0.19791061f, -0.04855631f, -0.02473706f, 0.02221920f, -0.13250694f, 0.37130591f, -0.03047239f, -0.12922795f, 
    0.13822748f, 0.40818968f, -0.21188278f, -0.30712900f, 0.07495841f, 0.15162537f, 0.30392528f, 0.16295235f, 
    0.08992085f, -0.15465222f, 0.06874625f, 0.15336186f, 0.10054437f, 0.30126593f, 0.20797478f, 0.05757996f, 
    0.37363681f, 0.25746942f, -0.41406548f, 0.17229098f, 0.10525823f, -0.03571047f, 0.05527143f, 0.13944352f, 
    0.23795921f, -0.17458844f, -0.12145667f, -0.20771779f, 0.26271406f, 0.15961580f, -0.08927651f, 0.08704905f, 
    0.38492349f, -0.35142678f, -0.25228375f, -0.04107319f, -0.10645034f, 0.31447291f, 0.10124843f, -0.14753951f, 
    -0.11658750f, -0.09435645f, -0.07454988f, 0.10864010f, 0.17908919f, -0.07302347f, 0.62140709f, 0.03188351f, 
    0.26816693f, 0.02097105f, -0.15112817f, 0.10669877f, 0.08732709f, -0.07953485f, -0.19346382f, 0.29228836f, 
    0.01074488f, 0.25766081f, 0.37142643f, 0.27334237f, -0.56848687f, -0.08450997f, -0.00068371f, -0.08269669f, 
    0.03841227f, -0.31324068f, -0.18372647f, 0.19888051f, 0.11830156f, 0.05700715f, 0.19385710f, -0.10903120f, 
    0.02771172f, -0.36675626f, -0.05385326f, 0.08155124f, -0.09713890f, 0.28900963f, -0.08142965f, -0.32457584f, 
    -0.27709255f, -0.18558936f, 0.30931479f, 0.03848514f, 0.00126968f, -0.09679373f, -0.01973173f, -0.14835344f, 
    -0.13442692f, 0.11250879f, -0.02958607f, 0.16650777f, 0.22517909f, 0.44125798f, 0.12289758f, 0.06251957f, 
    0.21294673f, 0.37780899f, 0.50211346f, 0.03608801f, -0.06375211f, 0.43301332f, 0.13555247f, 0.02413069f, 
    0.09858771f, -0.26798427f, -0.02528198f, -0.14483218f, -0.09729487f, 0.16995865f, 0.00230792f, 0.19286487f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11524728f, -0.02241066f, 0.13275963f, 0.17468344f, 0.28208452f, -0.15138718f, -0.15222262f, 0.02493408f, 
    -0.01734328f, 0.10632535f, -0.06216601f, 0.24667932f, -0.00245889f, 0.18740357f, 0.18839777f, 0.17146629f, 
    0.07764655f, 0.04821594f, -0.09506292f, 0.13174172f, 0.00820261f, 0.09856737f, 0.08421688f, 0.06678317f, 
    0.05943714f, 0.18301962f, 0.17775829f, -0.13973549f, -0.09494454f, 0.22053799f, -0.03582453f, 0.00666236f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.32382709f, 0.10533209f, 0.09523728f, 0.31360835f, -0.58668381f, 0.34156913f, 0.10726657f, 0.07752144f, 
    0.34431636f, -0.01066686f, -1.16748071f, -0.22349416f, 0.00429259f, -0.43650317f, -0.56488562f, -0.04460665f, 
    0.05573553f, 0.03298961f, -0.48116696f, 0.23464260f, 0.06255127f, 0.15731452f, -0.53575748f, -0.52395087f, 
    0.31698292f, -0.65499675f, 0.32363242f, -0.06098071f, -0.04533661f, -0.16319251f, -0.11811906f, 0.05388524f, 
    0.22708750f, 0.11381597f, -0.40202436f, -0.18661548f, -0.05379236f, -0.34903935f, 0.07559746f, 0.18592750f, 
    -0.08641690f, 0.43937609f, 0.36556771f, -0.01629816f, 0.19970509f, -0.20394571f, 0.21580429f, 0.04732746f, 
    0.14952548f, 0.32936195f, -0.27155599f, -0.21775122f, -0.16847332f, 0.01645035f, -0.56791514f, -0.01141428f, 
    0.10298775f, 0.02460730f, 0.22447205f, 0.10369338f, 0.33252066f, -0.04733365f, -0.53404129f, 0.12189582f, 
    -0.28621200f, 0.10943916f, 0.40613914f, -0.45479077f, 0.07323990f, 0.02625196f, 0.23344672f, -0.59242052f, 
    -0.71166211f, -0.02102660f, -0.39871335f, -0.28971207f, -0.45458281f, 0.00517345f, 0.30146369f, -0.00758071f, 
    0.15046342f, -0.14505403f, 0.13710502f, -0.06079705f, -0.43051741f, 0.38091877f, 0.21394397f, -0.01978031f, 
    0.44019285f, -0.07943697f, -0.18791768f, -0.06646681f, 0.09388409f, 0.18810391f, -0.52157331f, -0.57518405f, 
    -0.21600537f, 0.02221264f, 0.13073276f, -0.12500350f, 0.39514020f, 0.39500925f, -0.57243043f, -0.37040868f, 
    0.20284624f, -0.18532966f, 0.05877389f, -0.72422922f, 0.05544326f, -0.49025920f, -0.53795415f, 0.42003173f, 
    0.03219419f, -0.63397527f, 0.31228268f, 0.12959823f, 0.03844269f, -0.13643549f, -0.17895918f, -0.13960607f, 
    -0.06929453f, 0.24828444f, 0.47276852f, -0.04515408f, -0.05392317f, -0.41964504f, 0.10702765f, 0.12877585f, 
    -0.39871371f, -0.15805028f, -0.28301030f, 0.04667515f, -0.47004792f, 0.27057204f, -0.02758125f, 0.21822631f, 
    0.23496744f, 0.30596513f, 0.32296160f, -0.22482660f, -0.25876263f, -0.24821436f, -0.46316400f, 0.10689019f, 
    0.23116335f, -0.00259398f, 0.12220505f, 0.34667847f, -0.10998642f, -0.28847763f, 0.13579057f, -0.14679652f, 
    0.07563639f, -0.02400111f, -0.56214154f, -0.14274096f, 0.07184468f, -0.00374720f, 0.11424364f, -0.05519712f, 
    0.12914078f, 0.16376387f, -0.66299200f, 0.09022062f, -0.39754632f, -0.01380349f, -0.15892090f, 0.14065529f, 
    0.10581869f, -0.05846703f, -0.38194171f, 0.07881995f, 0.33540335f, 0.39052418f, -0.35053203f, 0.25083515f, 
    0.16484450f, 0.23520418f, 0.00714402f, -0.07452488f, 0.35938126f, -0.24609897f, -0.19749674f, -0.34837982f, 
    -0.59824401f, -0.58412325f, -0.24116141f, 0.08443028f, -0.03246051f, 0.22884645f, 0.20722131f, -0.11499143f, 
    -0.26617011f, 0.09678833f, 0.05149770f, -0.15051022f, 0.24010876f, -0.25460100f, 0.36563796f, -0.67880493f, 
    -0.10270664f, -0.84296399f, -0.17023860f, 0.30828628f, -0.31111506f, 0.41916493f, -0.11618590f, -0.27191240f, 
    0.26698369f, 0.02113014f, -0.34152091f, 0.02241392f, -0.09738524f, -0.14748721f, 0.25033838f, -0.86619657f, 
    -0.09844194f, 0.12279084f, 0.23391013f, -0.14037867f, 0.20479026f, 0.13246468f, 0.16992101f, -0.18974738f, 
    -0.14566761f, 0.16668706f, 0.26450288f, -0.48183215f, -0.00640148f, 0.02238977f, -0.18918025f, -0.19751972f, 
    -0.02486781f, -0.04972447f, 0.31580609f, -0.16239174f, 0.01540978f, -0.03514919f, -0.11812162f, -0.84340030f, 
    -0.44989440f, -0.19670402f, 0.12416850f, 0.33405346f, 0.40031144f, -0.04464229f, 0.38086015f, 0.17367893f, 
    -0.33260688f, 0.24451543f, -0.47194195f, -0.08874683f, -0.50332803f, -0.73172808f, 0.17504327f, 0.04590771f, 
    0.13130298f, -0.18461445f, -0.40444294f, -0.60257709f, -0.14731380f, -0.21519358f, -0.11690116f, -0.23135622f, 
    0.12164080f, 0.44599289f, 0.09984609f, 0.30522108f, 0.46806258f, 0.08818465f, 0.41165155f, -0.32407278f, 
    -0.39978826f, 0.13861953f, 0.47287941f, -0.33683348f, -0.27461362f, 0.34180686f, 0.12035088f, -0.28887174f, 
    -0.63348520f, -0.37367767f, 0.15459247f, -0.01510117f, -0.39765811f, -0.19764377f, -0.46545979f, -0.04237415f, 
    0.02665063f, 0.02781577f, 0.10401074f, 0.15968329f, -0.49230734f, 0.27618814f, 0.16628663f, -0.11814874f, 
    0.05327512f, -0.19092444f, -0.42902076f, 0.29211694f, -0.58322531f, -0.10818484f, 0.22614539f, 0.25400445f, 
    0.16469529f, -0.30282286f, 0.46205813f, -0.06779951f, -0.40494165f, -0.36367065f, 0.00593376f, 0.18023649f, 
    -0.09012213f, 0.28205311f, -0.17952704f, -0.07300733f, -0.72400117f, 0.27084571f, -0.06112231f, -0.62987721f, 
    -0.04393914f, -0.03045383f, 0.01134725f, 0.06205865f, 0.17814173f, -0.57967669f, -0.58912015f, 0.15098697f, 
    -0.10207289f, -0.00155916f, -0.54996365f, -0.70589447f, -0.43663448f, 0.24707323f, 0.12591811f, 0.04924828f, 
    0.22097765f, -0.77967918f, 0.31242883f, -0.60197634f, 0.21145941f, -0.01044495f, -0.13454896f, 0.30335152f, 
    0.19468252f, 0.23849294f, 0.27988437f, 0.07728951f, 0.03182938f, 0.33664650f, -0.32886469f, 0.32714936f, 
    0.45340860f, -0.03995353f, 0.20975703f, 0.09042722f, 0.10716122f, -0.28070319f, -0.61042500f, 0.01750377f, 
    0.09036393f, -0.37338084f, -0.06034135f, 0.07391451f, -0.01559728f, -0.09824170f, -0.37363046f, -0.08624546f, 
    -0.46103352f, -0.13304639f, -0.45522365f, -0.13350403f, -0.18032470f, 0.41446450f, 0.29467547f, 0.17984852f, 
    -0.15722625f, 0.24282843f, -0.23225205f, 0.12835807f, 0.23718910f, 0.27265328f, 0.33731076f, -0.41218421f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05494897f, -0.00292216f, -0.18977991f, 0.11781583f, -0.10475529f, 0.03820813f, -0.13047168f, 0.09758034f, 
    -0.07474453f, 0.03484323f, -0.03955126f, 0.09221034f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
