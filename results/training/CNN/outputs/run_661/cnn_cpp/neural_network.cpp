#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73048651f, -0.32392734f, -0.33424073f, 0.99586922f, 0.46571401f, 0.48919371f, -0.61520445f, -0.42258978f, 
    0.10276493f, 0.32531148f, 0.72941577f, 0.21233499f, -0.07695351f, 0.92750347f, 0.34324175f, 0.49557927f, 
    0.08452500f, -0.49159139f, -0.54937994f, 0.52468020f, 0.70800811f, 0.48950782f, 0.54069799f, 0.54753852f, 
    0.01456058f, -0.11457392f, 0.33313796f, -1.12828732f, 1.02279484f, -0.20429827f, 0.12408321f, 0.99743861f, 
    0.01666077f, -0.08907447f, -0.19886816f, 0.23640050f, -0.92215604f, -0.95995665f, 0.69269532f, 0.50659072f, 
    0.44714549f, -0.39486706f, -0.20390558f, 0.14212745f, -0.46585721f, 0.87812775f, 0.73186457f, 1.00691223f, 
    -0.86916602f, 0.11412925f, -0.55057627f, 0.10807788f, -0.13554291f, -0.23533957f, 1.07951009f, 0.85846102f, 
    -0.49323052f, -0.66851789f, 0.44656083f, 0.66164070f, 0.07162688f, -0.22931439f, -0.05663940f, 0.06633071f, 
    -0.15675168f, -0.94589430f, -0.53364563f, -0.90694779f, -0.29729977f, -0.41494128f, -0.21806125f, -0.17099035f, 
    1.16700399f, -0.46596369f, -0.33203009f, 0.50587964f, 0.55634302f, -0.65735137f, -0.17536633f, 0.54975224f, 
    -0.12933181f, -0.88731819f, -1.07415521f, -0.76651692f, -0.32314381f, 0.77350003f, 1.10397041f, -0.10481548f, 
    0.00750403f, 0.21738936f, -0.61853600f, -0.68712974f, -1.24112034f, -0.07074378f, 0.62673187f, 0.06219505f, 
    0.32578737f, -0.17312212f, -0.02112302f, 0.75600618f, 0.58130860f, -0.63219750f, -0.28321475f, 0.54755825f, 
    -0.17555392f, 0.41794422f, 0.55165941f, 0.46192303f, -0.47040460f, -0.40698996f, -0.69021040f, 0.97048873f, 
    0.64653391f, -0.65121907f, -0.11375140f, 0.25572494f, 0.02714366f, 0.84274167f, -0.41565287f, -0.01916209f, 
    -0.64724368f, -0.98486519f, -0.76624513f, 0.20082781f, 0.52571505f, 0.15090077f, 0.86610109f, 1.16436720f, 
    0.68604755f, -0.20786567f, -0.51505268f, -0.22129132f, -0.26096919f, 0.60078436f, -0.01685137f, 0.21254252f, 
    -0.00163966f, -0.45473868f, 0.85000718f, -0.63012874f, -0.78759205f, -0.31245333f, -0.35008356f, 0.16614075f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03756253f, -0.02139843f, 0.27111706f, 0.15688622f, -0.06296486f, 0.14276978f, 0.37040007f, 0.35098150f, 
    -0.07660126f, 0.02859887f, 0.14524430f, -0.27663401f, 0.18134117f, 0.07639270f, -0.00516641f, -0.07157858f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04156563f, 0.02242643f, -0.00285265f, 0.02706693f, 0.02082102f, -0.03082654f, -0.04176514f, 0.01626446f, 
    0.01203213f, -0.04940782f, -0.02664045f, -0.05988430f, -0.05713086f, 0.00250136f, -0.04915211f, 0.01719375f, 
    -0.00016428f, -0.00719857f, -0.03987277f, -0.02117743f, -0.02552555f, -0.05839442f, 0.04362153f, -0.04621081f, 
    -0.04282777f, -0.03905865f, -0.02104248f, 0.02824817f, 0.03198341f, -0.04600374f, 0.00383857f, -0.03318021f, 
    0.03254567f, -0.05812683f, -0.02757577f, -0.02298049f, 0.01197812f, -0.02653353f, 0.02936328f, -0.00690684f, 
    -0.04834902f, -0.02543765f, 0.03677535f, 0.03249083f, -0.03346134f, 0.02058263f, -0.00558157f, 0.00902244f, 
    -0.03064825f, 0.04553590f, -0.00804401f, 0.02662540f, 0.02373682f, -0.03910311f, -0.01462112f, -0.04193360f, 
    -0.00272512f, 0.03137045f, -0.03416239f, -0.05046647f, -0.05029392f, -0.01440817f, 0.02892576f, -0.01266319f, 
    -0.01020713f, -0.02827342f, 0.00351213f, 0.03428810f, 0.02434948f, 0.03866383f, -0.02879960f, 0.04222306f, 
    -0.01642504f, 0.01213938f, -0.02283241f, 0.00742473f, -0.05461489f, 0.01172932f, -0.03097865f, -0.03787901f, 
    -0.04814547f, -0.00972604f, -0.01121278f, -0.02219324f, -0.01239325f, -0.00727785f, 0.03741580f, 0.02303606f, 
    -0.03130339f, -0.02804783f, 0.02317634f, -0.03432834f, 0.00620101f, 0.00139077f, -0.05538647f, 0.04314617f, 
    0.04573644f, 0.01258927f, 0.00212554f, 0.04233680f, 0.04677195f, -0.05872238f, -0.02443290f, -0.01327907f, 
    0.04150721f, -0.05505358f, 0.00391180f, -0.04966820f, 0.02892006f, 0.02163844f, 0.04017825f, 0.01498078f, 
    0.00231530f, -0.06169439f, -0.03132555f, 0.00832211f, 0.02672129f, 0.03427425f, 0.02337260f, 0.01319094f, 
    -0.01516640f, 0.02859949f, 0.03182193f, -0.00358258f, -0.02505683f, 0.00683869f, 0.00141084f, -0.02047009f, 
    0.00802645f, -0.05413407f, -0.04121419f, -0.05123885f, -0.00494940f, -0.00569106f, 0.00388943f, 0.02292261f, 
    -0.03750725f, -0.04152684f, -0.03007102f, -0.00060165f, -0.02043867f, 0.00876500f, -0.00455705f, -0.00623254f, 
    0.00526203f, 0.00042079f, 0.02260607f, -0.04260175f, 0.01456661f, 0.03405961f, 0.02571664f, 0.04240010f, 
    0.04309972f, -0.04433012f, -0.01838878f, -0.05662124f, -0.04779777f, 0.02243069f, -0.02357474f, -0.03435658f, 
    0.01732003f, 0.03763746f, -0.04015567f, -0.00526773f, -0.02182302f, -0.04932127f, -0.00587354f, -0.03653615f, 
    -0.04608612f, 0.03215238f, 0.00050448f, -0.05662708f, 0.02793275f, 0.00608798f, 0.04488215f, -0.04028387f, 
    -0.02759067f, 0.03892621f, 0.01641069f, 0.03861176f, 0.02225390f, -0.00398020f, 0.02079275f, -0.04687680f, 
    0.03263906f, 0.01963775f, 0.02657373f, 0.02312715f, -0.00673306f, 0.00480485f, -0.02802290f, -0.04554919f, 
    0.03110774f, 0.04132049f, 0.02628721f, 0.05402273f, -0.04758177f, 0.02817877f, 0.00487672f, -0.00876383f, 
    -0.03348009f, -0.03004724f, -0.03373341f, -0.01324693f, -0.01012704f, 0.02066250f, -0.03308295f, -0.05232048f, 
    0.00495927f, -0.00017208f, -0.02633845f, -0.05412350f, -0.01866025f, 0.01284098f, 0.02079217f, 0.01041081f, 
    -0.03449668f, 0.04137472f, 0.01341612f, -0.02809090f, 0.01188609f, 0.04169377f, 0.00841497f, -0.04378363f, 
    -0.03689577f, -0.05767129f, 0.02048185f, -0.04608865f, 0.02900642f, -0.01879324f, -0.01269361f, 0.02416520f, 
    0.02109140f, -0.01089375f, 0.02386057f, 0.03639229f, 0.03275879f, 0.04728563f, 0.03275464f, -0.03477047f, 
    0.01012177f, -0.02136704f, -0.05003607f, -0.02406194f, -0.02950836f, 0.01553168f, -0.01284325f, 0.02202216f, 
    0.04568950f, -0.01005942f, -0.05673215f, -0.02033004f, -0.00993810f, 0.02408346f, -0.05838330f, -0.01539875f, 
    0.03323269f, 0.02027805f, 0.04806818f, 0.02421658f, -0.03135707f, 0.02659816f, -0.01850761f, -0.00089507f, 
    -0.05991540f, 0.02577656f, 0.00181153f, 0.04363945f, 0.04168081f, 0.00366391f, -0.05559901f, 0.02085361f, 
    -0.04759048f, -0.00628717f, -0.04109389f, -0.04138986f, 0.00337759f, 0.04749382f, -0.02315495f, -0.01475892f, 
    -0.04907523f, -0.03643463f, -0.01571776f, -0.03654531f, 0.01689493f, -0.06220916f, 0.00484748f, 0.00045881f, 
    0.03179404f, 0.03500125f, 0.01333689f, -0.00725073f, 0.03093300f, -0.00841685f, -0.03681260f, -0.00272568f, 
    0.01440674f, -0.03691019f, -0.05018814f, -0.03293672f, -0.02763483f, -0.01029416f, -0.06118608f, -0.03342209f, 
    0.02670209f, 0.01549706f, -0.00216773f, 0.00192306f, -0.00902505f, -0.03622258f, -0.00955877f, 0.01185887f, 
    0.03039663f, -0.02994147f, -0.01790937f, -0.04754724f, -0.05357843f, 0.02386766f, -0.00807945f, 0.00942913f, 
    0.22879632f, 0.18180136f, 0.03353952f, 0.08290967f, -0.04833180f, 0.10579641f, 0.04319017f, 0.00086603f, 
    -0.01211752f, -0.13498934f, 0.11756169f, 0.16809149f, -0.03223912f, -0.08396354f, 0.04205708f, 0.11490143f, 
    0.10659891f, 0.09355564f, 0.01081988f, 0.09093240f, -0.03747565f, 0.09144286f, -0.08722885f, -0.36962289f, 
    0.28316206f, -0.06699404f, 0.08762503f, 0.01033046f, -0.10584991f, 0.07503270f, -0.17234027f, 0.04169886f, 
    -0.05185871f, -0.11486080f, 0.02830653f, -0.05878736f, 0.02573329f, 0.03533289f, -0.00982281f, 0.12088729f, 
    -0.35011944f, 0.23845506f, 0.11221838f, -0.23116547f, 0.26456535f, 0.05134198f, 0.19283563f, -0.09424768f, 
    -0.01319789f, -0.08702928f, 0.10389601f, -0.07215329f, 0.14375867f, -0.02058574f, 0.02989936f, -0.09885886f, 
    -0.06806391f, 0.20231764f, 0.11605293f, 0.24705863f, 0.17609282f, 0.31248420f, 0.13237236f, -0.31062695f, 
    0.26737970f, -0.13468030f, 0.13610339f, -0.03028850f, -0.00760856f, -0.04840660f, 0.18471669f, -0.00130812f, 
    -0.07311695f, -0.05120979f, 0.13788424f, -0.01201586f, -0.06314289f, -0.00105561f, -0.00308815f, -0.07878233f, 
    -0.64716351f, 0.03893620f, 0.09657499f, 0.30523574f, -0.54207975f, 0.10504331f, -0.00611881f, 0.05575357f, 
    0.07600189f, 0.09185077f, -0.00109489f, 0.06710805f, 0.00921052f, -0.13927434f, -0.05962449f, -0.05130294f, 
    -0.05942244f, 0.00352136f, -0.06331641f, -0.08102570f, 0.17158626f, 0.04788364f, -0.04862770f, 0.03389263f, 
    0.22250925f, -0.11609073f, -0.05085696f, -0.13252223f, 0.07142683f, 0.07413673f, -0.06982028f, 0.04907080f, 
    -0.07443727f, 0.02875920f, 0.07608198f, -0.07159038f, 0.16030121f, 0.07756371f, 0.00901892f, -0.00477613f, 
    0.03790149f, 0.01773872f, 0.07823599f, -0.04474089f, 0.45420131f, -0.18011664f, 0.06591792f, -0.18004547f, 
    -0.00388704f, -0.03736198f, 0.04503510f, 0.02169551f, 0.09354835f, 0.10885118f, 0.09443963f, -0.07477614f, 
    0.02371555f, 0.08882082f, 0.05478171f, -0.03312618f, -0.05433032f, -0.38999704f, 0.18319495f, 0.09495476f, 
    0.05519119f, 0.08809564f, -0.04543709f, 0.12131904f, 0.06662305f, 0.11478741f, -0.09947009f, -0.01290447f, 
    0.15517792f, 0.18641949f, 0.08890635f, 0.02338452f, 0.09866031f, -0.14852285f, -0.10830339f, -0.18582907f, 
    -0.01429713f, -0.39190522f, 0.23523331f, -0.04801111f, 0.19362149f, 0.07671739f, -0.16265389f, -0.01608565f, 
    0.04094133f, 0.15598425f, 0.06075256f, 0.07609539f, 0.11433230f, 0.04276614f, -0.01003739f, -0.07817704f, 
    0.10969165f, -0.01538949f, 0.16790728f, 0.07644678f, -0.17933106f, 0.37514922f, -0.35984108f, -0.12636393f, 
    -0.47855949f, 0.00788816f, -0.01419569f, -0.00000464f, 0.10833021f, -0.17715870f, 0.04476991f, -0.05028716f, 
    -0.02819876f, -0.04768288f, -0.03162831f, 0.07267461f, 0.00208356f, 0.01935247f, -0.00811898f, 0.19555648f, 
    0.27303979f, 0.16873451f, -0.23630185f, -0.04203553f, -0.48796472f, 0.06403290f, -0.06872581f, -0.01337271f, 
    0.09337354f, 0.01710613f, -0.02903334f, 0.09230594f, -0.11803094f, 0.00478875f, 0.10576417f, 0.05687975f, 
    0.09887679f, -0.07932462f, -0.25859973f, -0.12861916f, -0.28301638f, 0.01903632f, -0.03839862f, -0.18659639f, 
    0.09519779f, 0.02007759f, -0.08665806f, 0.15965934f, 0.12489860f, 0.24195252f, 0.08201461f, 0.04118114f, 
    -0.11203337f, 0.03685353f, 0.12049538f, 0.30620930f, -0.02914721f, 0.08485119f, 0.13774998f, 0.11998319f, 
    0.47340557f, 0.14170964f, -0.14971298f, 0.02637827f, -0.14851242f, 0.10597201f, -0.08556913f, 0.11536852f, 
    0.07482067f, -0.17604458f, 0.00292242f, -0.06959040f, 0.15156877f, -0.09288500f, -0.04632255f, 0.03945731f, 
    0.05651633f, 0.02150315f, -0.00078539f, -0.10913149f, 0.08071921f, -0.28012538f, 0.53110921f, 0.18643972f, 
    0.10703791f, 0.07545500f, -0.09847854f, 0.16404490f, 0.13691382f, 0.01522745f, 0.12433311f, 0.07915087f, 
    0.13147524f, 0.11197945f, 0.06173346f, -0.02613831f, 0.07121742f, -0.07163849f, 0.10019635f, -0.12839696f, 
    0.36759445f, 0.12194281f, 0.34382027f, -0.19823675f, 0.37867978f, -0.01075136f, -0.01739603f, -0.21053346f, 
    -0.05608828f, -0.03694149f, -0.00434905f, -0.12313542f, -0.07034011f, 0.09207468f, 0.07627450f, 0.17785804f, 
    -0.05488769f, 0.10979183f, -0.03697390f, -0.01314530f, -0.00829411f, -0.33628780f, 0.14961348f, 0.05145215f, 
    0.09471335f, 0.24071138f, -0.25593945f, -0.01437257f, -0.03314036f, 0.16500440f, 0.10233194f, 0.07398015f, 
    -0.06276789f, 0.10100162f, -0.02468867f, 0.11280286f, -0.14453392f, -0.25052503f, -0.07012403f, -0.13217938f, 
    -0.18328609f, 0.09666149f, -0.21470664f, 0.21171263f, 0.00612626f, 0.13524291f, -0.04303356f, 0.19919945f, 
    0.00090451f, 0.05803574f, -0.07706209f, -0.03814496f, 0.12768625f, 0.08071683f, 0.15508227f, -0.00267219f, 
    0.04646271f, 0.00421284f, -0.23591383f, 0.05523531f, -0.42716968f, -0.29079139f, -0.09708229f, -0.24032156f, 
    -0.12087711f, 0.19122036f, 0.09198611f, 0.03692688f, 0.11103699f, 0.08462176f, 0.04594970f, 0.09026280f, 
    0.00294546f, -0.07448646f, 0.05672899f, -0.02434085f, -0.10175264f, -0.09941268f, -0.05451705f, -0.01096583f, 
    0.13962327f, -0.22463308f, -0.30655909f, -0.07371450f, 0.08474143f, 0.22253500f, -0.04730894f, 0.08940388f, 
    0.10963147f, 0.15270261f, 0.03735890f, 0.05810712f, 0.01844567f, 0.17390837f, 0.17184636f, -0.05748398f, 
    0.14581403f, -0.17983270f, -0.07724673f, -0.03812488f, 0.43784827f, -0.10871792f, -0.09310640f, -0.02142715f, 
    0.05136034f, 0.14265876f, 0.04393471f, 0.04244615f, 0.14337714f, -0.06368268f, -0.10491353f, -0.02404956f, 
    -0.00521790f, 0.10756689f, 0.12523040f, -0.05174056f, 0.07390805f, -0.03127103f, -0.04408799f, 0.02391649f, 
    0.10966560f, 0.24791923f, 0.31047711f, -0.03375231f, 0.31346235f, -0.09543603f, -0.11732718f, 0.01804044f, 
    0.17773017f, -0.10358568f, 0.03907503f, 0.07359109f, -0.04369057f, 0.04309161f, 0.06060664f, 0.08771664f, 
    -0.06466354f, -0.08250686f, -0.02914980f, 0.01520728f, -0.33381215f, -0.01638928f, 0.18150257f, -0.16149399f, 
    -0.15094689f, 0.08604528f, 0.06681932f, -0.11978313f, 0.01954173f, -0.00389986f, 0.05390169f, 0.13835725f, 
    0.04554575f, -0.05450022f, -0.02572985f, 0.11357707f, 0.01557895f, -0.08174919f, -0.01049891f, 0.07107326f, 
    -0.26890647f, -0.14758240f, -0.06590059f, -0.08554726f, -0.03212171f, 0.07144537f, 0.08728313f, 0.12306935f, 
    0.02463811f, 0.14479083f, -0.00687587f, -0.07592051f, 0.11569059f, -0.06266096f, 0.11378899f, 0.03237601f, 
    0.17061031f, -0.13747005f, -0.04759818f, 0.00250375f, 0.51040733f, 0.05510221f, 0.14064737f, 0.37555015f, 
    0.07664211f, 0.02666542f, 0.09704234f, -0.01439307f, -0.14764243f, -0.04688699f, 0.12892796f, 0.15742387f, 
    0.02442759f, -0.09560415f, 0.02482970f, 0.06089987f, 0.02186728f, 0.05566065f, 0.06156131f, 0.06327697f, 
    -0.38203570f, 0.32725656f, -0.09270967f, 0.15797099f, -0.16280405f, 0.09895977f, 0.15068579f, 0.00936211f, 
    0.07400633f, 0.01753836f, 0.00076385f, 0.10338490f, 0.14472970f, 0.05950656f, 0.05069473f, 0.10542014f, 
    0.05611259f, 0.07760021f, -0.12261180f, 0.12080141f, 0.06623406f, 0.12345574f, 0.16278850f, 0.09914338f, 
    0.19983004f, -0.02249371f, -0.02232498f, -0.03248956f, 0.07281076f, 0.06450225f, -0.06445809f, -0.00939678f, 
    -0.00606224f, 0.02076995f, 0.00197571f, -0.08926596f, 0.03766134f, 0.01682204f, 0.06715556f, -0.08152378f, 
    0.23340295f, 0.12271964f, 0.15451716f, 0.07445031f, 0.14315203f, -0.12915063f, 0.01957964f, 0.07076655f, 
    0.11817423f, 0.01682120f, -0.12742475f, -0.02352882f, 0.15613420f, 0.06306505f, -0.02398491f, -0.08643680f, 
    -0.05395654f, 0.02823179f, 0.15198164f, 0.04477454f, -0.53372967f, -0.27577904f, -0.17761017f, -0.05705326f, 
    0.10771663f, 0.13845353f, 0.15431844f, -0.10949611f, -0.03000336f, -0.13966879f, -0.01924896f, -0.05769550f, 
    0.04126732f, -0.01783217f, 0.03199648f, -0.13427122f, 0.07552597f, 0.22858290f, 0.04915516f, -0.13868217f, 
    0.26520967f, 0.31858003f, 0.21169576f, 0.17188664f, 0.03114796f, -0.09928006f, 0.00520898f, 0.16898234f, 
    0.03880476f, -0.06986050f, 0.03174891f, -0.00693958f, -0.07039978f, 0.06994765f, -0.03002609f, -0.10169926f, 
    0.00791664f, 0.08687200f, 0.12174668f, 0.09447619f, 0.10363934f, -0.00637160f, 0.15686896f, 0.08584745f, 
    0.00900057f, 0.03737833f, 0.16773963f, -0.10067009f, 0.02903359f, 0.09723388f, 0.05054485f, -0.00389914f, 
    -0.12702665f, -0.17536435f, -0.03118979f, -0.05848374f, 0.09536740f, 0.17723137f, 0.12967274f, -0.02287130f, 
    -0.36346033f, -0.24413463f, 0.14362027f, -0.04019818f, -0.12276880f, 0.05021067f, 0.08411904f, -0.00900995f, 
    -0.08701702f, -0.01480221f, 0.09741867f, 0.06954459f, 0.13043296f, -0.06834142f, -0.06225148f, 0.07099225f, 
    0.03482122f, -0.01466630f, -0.00594456f, 0.11326449f, 0.27624485f, 0.23517530f, 0.19392753f, 0.34691796f, 
    -0.06506573f, 0.00742403f, 0.11848313f, -0.01773160f, 0.10127580f, -0.04013931f, -0.05346389f, 0.02183294f, 
    -0.04513723f, 0.16023596f, 0.08928078f, 0.09045518f, 0.04104491f, 0.20702434f, -0.05211700f, 0.12705024f, 
    0.20851614f, -0.05283005f, -0.11673406f, 0.05894553f, 0.21987182f, -0.03853124f, 0.04071253f, -0.07533322f, 
    -0.00558880f, -0.15140472f, 0.13010770f, 0.04509555f, -0.01083308f, -0.05357580f, -0.00740490f, 0.01956593f, 
    0.11412419f, 0.01332744f, 0.09969008f, -0.04034687f, -0.04314181f, 0.35365540f, 0.04980405f, 0.03625742f, 
    0.39763901f, -0.08581122f, -0.09144884f, -0.02013797f, -0.06209564f, -0.08583611f, -0.04171972f, -0.08493540f, 
    -0.07739972f, 0.05168286f, -0.00185715f, -0.00926617f, 0.19054540f, -0.01727780f, 0.10368714f, -0.02501243f, 
    0.27612922f, 0.18088353f, 0.06106151f, 0.15298626f, 0.21949507f, -0.03301536f, -0.10641700f, -0.02911240f, 
    0.00551295f, -0.04112204f, 0.10342652f, -0.10418489f, -0.01755319f, -0.05663505f, 0.05073910f, -0.06584619f, 
    0.03833306f, 0.05507305f, 0.05420601f, 0.07267496f, 0.24723738f, 0.40577605f, -0.10316642f, 0.01305623f, 
    0.21433020f, -0.05395972f, 0.02199318f, -0.01876734f, -0.07076804f, -0.05241035f, 0.11132024f, -0.10683020f, 
    -0.07208737f, -0.08863688f, 0.05093738f, 0.00574536f, 0.13344410f, -0.04886070f, 0.20162712f, 0.01502169f, 
    -0.08815367f, -0.19028230f, 0.16702007f, -0.12456385f, -0.57833296f, 0.02627965f, -0.06441847f, 0.07153226f, 
    0.11317028f, 0.00242841f, 0.01071017f, 0.09277698f, -0.01328755f, 0.05983995f, -0.03340826f, -0.14668301f, 
    -0.10744730f, 0.09901375f, 0.06353422f, 0.12385686f, -0.39096174f, 0.13848160f, 0.06565771f, 0.13225840f, 
    0.01774953f, 0.00344444f, -0.04448985f, -0.05306317f, -0.04779255f, -0.02926889f, 0.05923407f, 0.03972507f, 
    -0.00949888f, -0.10137521f, -0.00579900f, 0.05497677f, 0.11558716f, -0.01301512f, -0.05701514f, -0.01707959f, 
    0.12743238f, -0.05759204f, -0.14743613f, 0.02645873f, 0.26099101f, -0.10842840f, -0.18754390f, -0.18423399f, 
    -0.00646607f, -0.06517533f, -0.00191184f, 0.06414647f, 0.07259049f, 0.02332718f, 0.00686416f, -0.05293174f, 
    -0.07211775f, -0.06225898f, 0.06269209f, -0.13226441f, 0.03424209f, -0.17003006f, 0.16798821f, -0.01767528f, 
    -0.17261696f, 0.06666331f, 0.09477011f, 0.05319895f, 0.15716781f, 0.03389944f, -0.03927782f, -0.08672565f, 
    0.07682319f, 0.07063629f, -0.03743621f, -0.02520974f, -0.02228154f, -0.10036322f, 0.02225436f, -0.09998112f, 
    0.27208802f, -0.14670394f, 0.35463884f, -0.23572226f, 0.09145032f, -0.21174595f, -0.06738808f, -0.02310816f, 
    0.03092947f, -0.04622188f, -0.02522879f, -0.00648889f, 0.13437305f, 0.01701517f, -0.09049742f, -0.02618391f, 
    -0.04546767f, -0.13412797f, -0.02331102f, 0.15351921f, 0.15879017f, 0.11169204f, 0.19950037f, 0.03836152f, 
    -0.04862531f, -0.11628649f, 0.03878472f, -0.01343101f, 0.01857060f, 0.11912088f, -0.03711902f, -0.06074848f, 
    -0.00977851f, 0.13821252f, 0.01094173f, -0.01533342f, 0.06271114f, -0.00181405f, 0.02827996f, 0.06182040f, 
    0.03495064f, 0.30554885f, 0.07530491f, -0.02317809f, -0.05150819f, 0.03696754f, 0.00840175f, 0.04381818f, 
    0.16431087f, 0.03632036f, 0.04058248f, -0.07134596f, -0.16539785f, 0.10211285f, 0.12696862f, 0.03855710f, 
    -0.07706495f, 0.08881828f, -0.08278923f, 0.04885878f, 0.09436242f, -0.00925235f, -0.24639042f, 0.07255460f, 
    -0.10536144f, -0.05933584f, -0.01887786f, -0.02839788f, 0.01893562f, -0.00830985f, 0.11861122f, 0.17063235f, 
    0.04353176f, -0.05006919f, 0.10527205f, 0.17533906f, 0.11130582f, 0.03244036f, 0.05546010f, -0.05637245f, 
    0.21873130f, 0.10340105f, -0.22745550f, 0.01089223f, -0.03338565f, 0.07095084f, -0.03001816f, -0.05516917f, 
    0.11289186f, 0.00750095f, 0.15816973f, 0.01843663f, -0.01367372f, -0.03084226f, 0.18083081f, 0.06668150f, 
    0.08489618f, 0.03672311f, 0.10596775f, -0.01447081f, -0.05131209f, -0.08092771f, 0.35314628f, -0.05862322f, 
    -0.18137775f, -0.00328753f, 0.06876725f, 0.02387903f, -0.01478250f, -0.00630897f, -0.00337388f, 0.07313636f, 
    0.09617190f, 0.10952289f, -0.03679889f, 0.03099054f, 0.10059364f, -0.13346924f, -0.01577883f, 0.00319766f, 
    -0.31560421f, -0.02377567f, 0.06233332f, -0.04622645f, 0.35821608f, -0.03377009f, -0.15098783f, -0.12118261f, 
    0.07297292f, -0.02154832f, 0.05162103f, 0.05077844f, 0.01674505f, 0.10027378f, 0.03240999f, -0.03783932f, 
    0.12818937f, -0.00066217f, -0.02648833f, -0.05197737f, -0.20891549f, -0.03450660f, 0.09711558f, 0.11529277f, 
    0.02644532f, -0.03970878f, -0.10470211f, 0.07426594f, -0.01661357f, -0.04958274f, -0.04599902f, 0.02711779f, 
    0.14014708f, 0.12351884f, 0.15784736f, -0.07390375f, -0.08444153f, 0.02175912f, 0.02598655f, -0.01719208f, 
    -0.20686038f, -0.38980484f, -0.03455050f, 0.08440991f, 0.13147032f, -0.03729320f, -0.00854005f, 0.08909708f, 
    -0.00410399f, 0.05120723f, -0.08444213f, -0.09674676f, 0.02595587f, 0.14391862f, -0.09024626f, -0.08531543f, 
    0.07652245f, -0.03461376f, -0.06143539f, -0.05104231f, -0.07581583f, 0.10847435f, -0.01886724f, 0.07847865f, 
    -0.00542943f, 0.06993085f, -0.07919826f, -0.03463535f, 0.10968358f, -0.06187380f, 0.09615603f, -0.08519781f, 
    0.06687778f, 0.12888141f, 0.05321104f, 0.03142016f, 0.05297269f, -0.10794040f, 0.01918220f, -0.08004805f, 
    0.34934554f, -0.07677608f, -0.15372853f, 0.19171558f, 0.11670274f, -0.10016288f, -0.04756150f, 0.09669967f, 
    0.05918579f, 0.23462573f, -0.09231465f, 0.06531164f, -0.06368817f, -0.07546661f, 0.09871826f, 0.03020418f, 
    0.04887489f, -0.19993877f, -0.00472650f, -0.06043640f, 0.19950980f, 0.17117560f, -0.11946625f, 0.16826272f, 
    0.17524081f, 0.01414165f, 0.03849348f, -0.06472796f, 0.05220871f, 0.08897823f, -0.12841721f, -0.06452068f, 
    0.02192082f, 0.01696400f, 0.04223648f, 0.00949380f, 0.03524949f, 0.04594417f, 0.01664286f, 0.06740706f, 
    0.37848505f, -0.36619553f, 0.14752357f, -0.30692059f, -0.19375342f, -0.17773125f, -0.02665525f, -0.07921927f, 
    0.08307724f, -0.11088783f, 0.02807903f, 0.09402366f, 0.03251372f, 0.12189364f, 0.06475803f, 0.11865110f, 
    -0.16714019f, 0.07618770f, -0.06648340f, 0.15753523f, -0.19840591f, 0.37243292f, -0.03372295f, 0.07969868f, 
    0.03733130f, 0.22549696f, -0.00767403f, -0.01672010f, 0.01695541f, -0.09498864f, 0.07460190f, 0.02677685f, 
    -0.03959736f, -0.03514352f, -0.13348605f, 0.23923877f, 0.00061689f, -0.07220356f, 0.00403769f, 0.07266273f, 
    -0.23590790f, 0.12545927f, -0.28081656f, 0.06274669f, 0.10391102f, 0.01037601f, 0.07409727f, 0.13388719f, 
    0.13197249f, -0.03590030f, 0.08501319f, 0.07573372f, 0.04413506f, 0.04575709f, -0.01834381f, 0.03965409f, 
    0.01273429f, -0.13579713f, -0.02222786f, -0.00836821f, 0.23841178f, 0.33740318f, -0.12765260f, -0.03102885f, 
    -0.08735216f, 0.00880982f, 0.04870837f, 0.07317532f, 0.06819278f, -0.03061662f, 0.08382463f, -0.02428139f, 
    -0.09406016f, -0.08128220f, -0.07938549f, 0.08091865f, -0.02397891f, -0.00670384f, 0.18134804f, -0.03055122f, 
    -0.04448439f, -0.24399395f, 0.10202729f, -0.15975764f, 0.05789326f, -0.18406385f, 0.10216745f, 0.04224874f, 
    0.01821399f, -0.05562649f, 0.03191082f, 0.04682470f, -0.06219966f, 0.01286181f, -0.08904496f, 0.07812224f, 
    -0.04677182f, -0.00546770f, 0.02542744f, 0.11505529f, 0.17199281f, -0.15539648f, 0.45595109f, -0.10841418f, 
    0.16189350f, -0.01751353f, -0.04724779f, -0.04547196f, -0.04877173f, 0.08687104f, -0.05014353f, -0.07263650f, 
    0.10151590f, 0.16982354f, -0.00605760f, -0.02412793f, 0.06508781f, -0.04948658f, 0.06823344f, 0.05378799f, 
    0.41154888f, 0.17410764f, 0.06955800f, -0.09487767f, 0.00582472f, -0.08640867f, -0.08199598f, 0.03728343f, 
    0.01139300f, -0.04922147f, -0.08165341f, -0.00370283f, 0.03478320f, 0.02322816f, 0.16564353f, 0.01594036f, 
    -0.02590064f, 0.00634539f, 0.19461122f, 0.20273030f, -0.14896764f, -0.13679194f, -0.24507700f, 0.10687255f, 
    0.03247114f, 0.07887204f, 0.06859118f, -0.12676969f, -0.01303073f, -0.12197819f, 0.03642785f, -0.03492385f, 
    0.14331663f, 0.00946480f, -0.05035830f, -0.10415936f, 0.00903478f, 0.14909054f, 0.04769028f, -0.11774495f, 
    0.68876851f, -0.03655477f, -0.03633154f, -0.02342044f, 0.05203862f, -0.11816859f, 0.02959133f, -0.00656509f, 
    0.04498244f, 0.00181500f, 0.04020099f, 0.00281782f, -0.07833577f, 0.00768584f, 0.26951852f, -0.03926595f, 
    -0.01379887f, 0.04751889f, 0.02224065f, 0.06029170f, 0.02752950f, 0.17506950f, 0.05905608f, -0.21791697f, 
    0.02301225f, 0.05562872f, 0.12719767f, -0.00044757f, -0.00225858f, -0.03745488f, 0.03675251f, 0.09618594f, 
    -0.04448561f, -0.00550636f, -0.06000112f, 0.13613540f, 0.06451476f, 0.20146763f, 0.10652199f, -0.02883101f, 
    -0.37692454f, 0.13418043f, -0.22273074f, 0.07913264f, 0.09697741f, 0.09165158f, -0.02897766f, 0.06988771f, 
    0.04234797f, 0.02124871f, 0.25721139f, 0.10555641f, 0.09363315f, 0.03534361f, -0.16289982f, 0.11139487f, 
    0.04946524f, -0.04016269f, -0.08476211f, 0.00644564f, 0.26429787f, -0.00989384f, -0.07044458f, 0.37603384f, 
    -0.03732161f, 0.01175993f, 0.06682406f, -0.03184195f, -0.03731840f, -0.16527240f, -0.08907209f, -0.02219431f, 
    0.00074313f, 0.02578287f, 0.11535089f, -0.09409704f, 0.06021408f, 0.21664391f, 0.07509495f, 0.10052086f, 
    0.07390341f, 0.18166867f, 0.00984746f, -0.25669029f, -0.01638176f, 0.01201657f, 0.12916638f, -0.05034844f, 
    -0.07173336f, 0.00497913f, 0.07351501f, 0.01958722f, -0.04389823f, 0.06172081f, 0.13484111f, 0.12147369f, 
    0.04073222f, 0.08798819f, 0.03450353f, -0.00028911f, -0.02280102f, 0.17648683f, 0.04345879f, 0.12785372f, 
    -0.09570870f, -0.08052928f, 0.02014515f, 0.00908912f, 0.04403713f, -0.05435494f, 0.15851426f, 0.07759932f, 
    0.07701200f, 0.01611438f, -0.00268769f, 0.14269581f, 0.02554601f, -0.01438442f, 0.09436053f, -0.01690878f, 
    -0.11233136f, 0.05781269f, 0.04831895f, 0.08287400f, -0.19017012f, 0.07536060f, -0.04543658f, 0.01939581f, 
    0.02001935f, -0.05993116f, 0.10541809f, 0.02049331f, -0.01985004f, -0.03698795f, -0.02623029f, 0.10995512f, 
    0.03309672f, 0.08828720f, -0.00729005f, 0.01855285f, -0.42262450f, 0.20750092f, 0.16104557f, 0.09627500f, 
    -0.23812842f, 0.12324694f, -0.05886875f, 0.04008153f, -0.00889554f, -0.01076347f, 0.08482649f, 0.12040368f, 
    0.02936136f, 0.03631895f, -0.21385691f, 0.03569523f, 0.12524880f, -0.04772428f, 0.03002070f, -0.00796880f, 
    0.02389619f, 0.17529674f, -0.03343484f, -0.12755136f, 0.14757270f, 0.11089931f, -0.00125020f, -0.05405935f, 
    -0.04909356f, -0.09342425f, 0.00134393f, -0.00821766f, 0.09705608f, -0.05119249f, 0.04033780f, 0.08114146f, 
    0.00646474f, -0.02237295f, 0.13390960f, -0.02209974f, 0.13689502f, 0.04415207f, 0.07974398f, 0.44545931f, 
    0.30914471f, -0.11708876f, 0.08498557f, 0.06792900f, -0.04085030f, 0.04176072f, 0.01961631f, -0.00945675f, 
    0.16323391f, 0.01126944f, 0.15883332f, 0.01421512f, 0.05782518f, -0.10302840f, 0.04522470f, 0.07449271f, 
    0.22088911f, 0.05674988f, 0.08939408f, 0.07045014f, -0.06888508f, 0.05125766f, 0.04794284f, 0.06199616f, 
    -0.05403759f, 0.06643333f, 0.03971499f, 0.01218223f, 0.06210418f, -0.03781561f, -0.01142639f, 0.00965105f, 
    -0.05637396f, 0.00297734f, 0.01268982f, 0.03939991f, 0.06063268f, 0.17418161f, 0.01481304f, 0.11459910f, 
    0.01229327f, 0.09288709f, -0.03140317f, -0.01377453f, -0.06344479f, 0.08340924f, 0.11103500f, 0.10691742f, 
    0.09859864f, -0.03828147f, 0.04771348f, 0.03977589f, 0.07642809f, 0.20166375f, 0.15731958f, 0.21583277f, 
    0.11278392f, 0.35207272f, 0.02630435f, 0.17653152f, 0.12163192f, 0.00355153f, 0.00705360f, 0.02010689f, 
    0.01078744f, -0.03922162f, 0.07762469f, -0.13156375f, -0.10238217f, 0.04935076f, 0.04943359f, -0.02095249f, 
    -0.06951036f, -0.05752763f, -0.04883477f, -0.13441017f, -0.46431470f, -0.27033529f, -0.02854836f, -0.15377331f, 
    0.14481458f, 0.16683902f, 0.07608956f, 0.14794897f, 0.06074137f, -0.02350338f, -0.02590856f, 0.14206569f, 
    -0.03854393f, -0.00471974f, -0.07046703f, -0.02722954f, 0.02006342f, 0.06106155f, 0.12146615f, -0.09569580f, 
    -0.62774611f, 0.01961632f, 0.02581236f, -0.17478253f, 0.26008239f, 0.10872164f, 0.02892908f, 0.08688755f, 
    0.00239453f, -0.01846495f, 0.04129235f, 0.00745187f, 0.04579317f, -0.04658877f, -0.06720258f, 0.06451529f, 
    -0.01163474f, 0.08778515f, 0.15368134f, -0.06829394f, 0.21968701f, 0.10032546f, 0.03661398f, 0.00499015f, 
    -0.06122564f, -0.05694310f, -0.07792469f, 0.06318805f, -0.07052326f, 0.09299517f, 0.13419327f, 0.08278888f, 
    -0.04467821f, 0.06927466f, -0.07515522f, -0.04765084f, 0.07823563f, -0.19587620f, -0.03027401f, 0.10866803f, 
    -0.40166733f, -0.01930976f, 0.07035933f, -0.26773557f, 0.06098693f, 0.02716510f, 0.12660021f, -0.00360697f, 
    0.01934451f, 0.09016267f, -0.05142598f, 0.05272189f, 0.04870613f, 0.05021722f, 0.11650140f, 0.09192477f, 
    0.06887512f, -0.05619903f, -0.06397721f, 0.00379990f, -0.09123395f, 0.04440111f, -0.16524193f, 0.34450921f, 
    0.22799005f, -0.07856482f, -0.09412731f, 0.05645924f, -0.04589686f, -0.02797887f, 0.04578912f, -0.13552925f, 
    -0.00252139f, 0.00513044f, 0.11844999f, -0.02928859f, -0.09806497f, 0.22092268f, -0.01522843f, 0.13431823f, 
    0.19043559f, 0.17705658f, -0.00784786f, 0.41340244f, 0.17431352f, -0.09743799f, 0.03141700f, 0.07277030f, 
    -0.01756051f, -0.03836720f, -0.13688046f, -0.06825487f, 0.00604716f, 0.02776875f, 0.14539728f, -0.03867867f, 
    0.07869358f, -0.01115780f, 0.02493723f, -0.08868157f, 0.12203039f, 0.39258426f, -0.10976432f, 0.06655861f, 
    -0.02644803f, -0.10133330f, -0.00165021f, -0.02928600f, 0.21903101f, 0.08690444f, 0.01153926f, 0.06364681f, 
    -0.05802551f, 0.05565069f, -0.02598961f, 0.04728780f, 0.00031023f, 0.11908949f, 0.12077036f, 0.12614518f, 
    0.02449882f, 0.01745520f, -0.05441118f, 0.05023878f, -0.00346987f, -0.01135132f, 0.02360579f, -0.00806110f, 
    -0.04290103f, -0.04056159f, -0.00544525f, 0.04233884f, -0.06283957f, 0.01153312f, -0.04596232f, -0.02975732f, 
    -0.05156622f, 0.02326263f, 0.01087501f, -0.06039971f, -0.04180797f, -0.05592664f, 0.03468627f, -0.00343406f, 
    -0.00160607f, 0.05144571f, -0.02379500f, 0.02721754f, -0.05920992f, 0.02064784f, 0.02199720f, 0.00462627f, 
    -0.05358722f, 0.04534641f, -0.04453027f, -0.00373888f, 0.05014191f, 0.00543906f, 0.02265992f, -0.04199387f, 
    0.01863580f, -0.04234666f, 0.01140498f, 0.03756587f, 0.04344305f, -0.01065390f, 0.02565052f, 0.00305553f, 
    0.02845885f, -0.01055010f, 0.00700267f, -0.04563522f, 0.00549803f, -0.05052502f, -0.04120779f, -0.02306927f, 
    0.01200955f, 0.00833370f, -0.05840016f, -0.03420173f, -0.00684347f, -0.04886873f, -0.05703222f, -0.01296674f, 
    -0.01126198f, -0.03120915f, -0.02739160f, 0.03385103f, -0.06457114f, -0.03513923f, -0.05305644f, -0.06049060f, 
    -0.03547835f, -0.01488512f, 0.03840194f, -0.05401770f, -0.02299836f, -0.04079700f, -0.04620260f, 0.02366043f, 
    -0.00133873f, 0.02574828f, -0.04913670f, -0.01656105f, 0.03293392f, 0.02727954f, 0.03978868f, -0.01235613f, 
    -0.03329838f, 0.04815217f, -0.04994844f, 0.02735265f, -0.05607244f, 0.01276122f, 0.03963813f, 0.04590617f, 
    -0.05915849f, 0.04002626f, 0.00884981f, 0.03348052f, -0.00354346f, -0.01796575f, 0.03860651f, 0.01848081f, 
    -0.02600387f, 0.04403780f, 0.03170852f, 0.04609413f, 0.03668139f, -0.02252343f, -0.02164797f, 0.00216110f, 
    -0.03414839f, 0.02894694f, 0.01484893f, -0.03822086f, 0.04090632f, -0.05970787f, 0.02540606f, -0.02749037f, 
    0.01082785f, -0.03380035f, -0.00811854f, -0.02185918f, -0.05441479f, -0.01498078f, -0.03449362f, 0.01537534f, 
    -0.03266083f, 0.00551813f, -0.01919304f, 0.03417064f, -0.01629918f, -0.01311421f, 0.00308678f, 0.03700547f, 
    -0.00365322f, -0.04355241f, 0.02378949f, -0.04410075f, -0.04685798f, 0.03230630f, -0.02310401f, -0.05013916f, 
    0.04371135f, -0.01679898f, -0.05516499f, 0.00617728f, -0.06019165f, -0.04774308f, 0.03431412f, -0.04773917f, 
    0.00100017f, 0.04777575f, -0.03181477f, 0.03371174f, -0.01022884f, 0.02119241f, 0.00298439f, -0.00312170f, 
    -0.04619755f, 0.03781007f, 0.02593787f, 0.00335169f, -0.04848960f, -0.01300309f, 0.04775967f, -0.02986810f, 
    -0.06068984f, -0.06519969f, -0.02529782f, 0.03370292f, -0.03022528f, -0.02309779f, 0.04523358f, -0.00975952f, 
    0.03071347f, -0.05333486f, 0.03146669f, 0.01139288f, 0.04030859f, -0.00637896f, 0.03177046f, 0.00160872f, 
    0.00743508f, -0.00884777f, -0.00339017f, -0.05039955f, 0.01666652f, -0.00424227f, 0.02408211f, -0.03036754f, 
    -0.05504994f, 0.02403314f, -0.02344608f, -0.02700338f, 0.03992861f, -0.05511447f, -0.03390748f, 0.04160123f, 
    0.00367933f, -0.00155871f, -0.04384957f, 0.03854336f, 0.02265479f, -0.05112363f, -0.04898157f, 0.01402730f, 
    -0.06063749f, -0.02999964f, -0.03435723f, 0.00832141f, -0.06454284f, -0.05755707f, 0.02966319f, 0.00768602f, 
    0.02414799f, -0.04111378f, -0.05155795f, -0.01057333f, -0.01535112f, -0.00880614f, 0.01818585f, 0.00254747f, 
    0.01530190f, -0.02724748f, 0.05270541f, -0.05615493f, 0.00018807f, 0.01753549f, -0.00487925f, 0.00050468f, 
    0.00362263f, -0.01721808f, -0.00002774f, -0.02644662f, -0.00985025f, -0.02913809f, 0.00140536f, 0.00243636f, 
    0.03170961f, -0.03939135f, 0.02760637f, 0.02555136f, -0.06382336f, -0.05450005f, -0.03026827f, 0.02752381f, 
    0.01705445f, -0.02019673f, 0.04116207f, 0.04520280f, -0.00020235f, -0.02793742f, -0.04199936f, 0.00806540f, 
    0.01909783f, -0.04364578f, 0.00976578f, -0.05506869f, -0.01567902f, -0.05124008f, -0.00600887f, -0.02058298f, 
    -0.02668964f, -0.01396789f, -0.01275008f, -0.02957110f, -0.05200716f, -0.03872349f, 0.03330915f, 0.01780322f, 
    -0.06271206f, 0.04292008f, 0.04398927f, -0.02311168f, -0.05593097f, -0.00066003f, -0.03105292f, -0.03166809f, 
    -0.03735521f, -0.05321727f, 0.03230477f, -0.01830877f, -0.03325842f, -0.00533781f, 0.02067348f, -0.00100371f, 
    0.05128599f, 0.02787690f, 0.02713139f, -0.06147106f, -0.04879015f, 0.04617010f, -0.00743076f, -0.04010254f, 
    0.01716113f, 0.03210782f, -0.04330206f, -0.00458190f, 0.01145492f, -0.00988649f, -0.06208460f, -0.04004739f, 
    0.01677463f, -0.04112974f, 0.03667565f, 0.01843842f, -0.02653179f, -0.05445648f, -0.00246406f, 0.03670314f, 
    0.02051272f, -0.02973772f, -0.01875406f, -0.03653927f, 0.02783316f, 0.01738266f, 0.02930633f, 0.02622029f, 
    -0.11854137f, -0.21522450f, 0.16676259f, 0.03691202f, 0.12219814f, -0.14941292f, -0.06052174f, -0.07096878f, 
    0.01435394f, 0.03707875f, 0.07730645f, -0.15831850f, 0.00381814f, 0.02660812f, -0.07797885f, -0.09767239f, 
    -0.02709476f, 0.00708455f, 0.20862861f, -0.12867573f, 0.02742819f, 0.28060210f, 0.01561950f, 0.05284024f, 
    0.03742290f, -0.03525237f, -0.04592811f, -0.09004712f, -0.00353459f, -0.05668585f, -0.01861046f, -0.08388016f, 
    0.03926212f, 0.15418382f, 0.04969995f, -0.00919126f, 0.11340720f, 0.08256463f, 0.10941096f, 0.01348495f, 
    0.19354135f, 0.22571713f, -0.05836617f, 0.05106314f, -0.09280253f, -0.18628030f, -0.00271774f, -0.08211318f, 
    0.08821236f, 0.11015416f, -0.05544690f, 0.02083609f, -0.04860124f, -0.13246235f, 0.10984451f, 0.02996955f, 
    -0.04865611f, 0.18924794f, 0.10438035f, 0.04008134f, -0.24356388f, 0.29059494f, -0.06920788f, 0.02364387f, 
    0.00509798f, -0.04107629f, 0.06942072f, -0.10812732f, -0.06746010f, 0.16641974f, 0.01015216f, 0.04331431f, 
    -0.00306269f, -0.09971707f, -0.00961746f, 0.05609586f, 0.05677348f, 0.18143673f, 0.04015634f, 0.07988764f, 
    0.40253875f, -0.29188904f, -0.26474056f, -0.25929242f, -0.30231503f, -0.05318230f, 0.02909346f, -0.05143206f, 
    -0.06299940f, 0.02167300f, 0.11407433f, 0.01309112f, -0.06695790f, -0.00767739f, -0.02190314f, -0.09745101f, 
    -0.07873239f, 0.03364230f, -0.00148362f, 0.12730122f, -0.38147900f, 0.33490649f, 0.08894847f, 0.26260698f, 
    0.09693442f, 0.06098763f, 0.10170700f, 0.05586499f, -0.04022516f, -0.08099319f, 0.00084353f, 0.02213204f, 
    0.03318147f, -0.01307840f, -0.03760415f, 0.08882328f, 0.06639809f, 0.04164591f, -0.07237584f, -0.08012549f, 
    -0.03955370f, 0.06656585f, -0.15211290f, 0.11543879f, 0.06122883f, 0.01845024f, 0.01298952f, 0.09747622f, 
    0.04990520f, -0.10135806f, 0.04599034f, 0.02095619f, 0.00284542f, 0.07814664f, -0.05163387f, 0.01833280f, 
    -0.01621900f, 0.05370082f, 0.09131335f, 0.06289000f, -0.04867617f, -0.05214795f, -0.15571895f, -0.19215824f, 
    -0.08779734f, 0.24630259f, 0.16505036f, 0.06768273f, 0.15456277f, -0.12248265f, 0.02422384f, 0.00002317f, 
    -0.03672833f, -0.10219245f, -0.10888374f, -0.00953872f, -0.07390369f, -0.02459296f, 0.02809551f, -0.08335077f, 
    -0.04483167f, -0.40934998f, 0.33007404f, -0.27208701f, 0.04238980f, -0.13253564f, 0.01899867f, -0.00373207f, 
    0.03342008f, 0.02487232f, 0.08900148f, -0.06083281f, 0.01566250f, -0.03128396f, -0.03252460f, 0.10764318f, 
    -0.05671911f, -0.09379111f, 0.11471733f, 0.04539080f, 0.26554373f, -0.12857655f, 0.13949032f, -0.00392924f, 
    0.15699466f, -0.13911350f, 0.01048786f, -0.03821620f, -0.12228784f, 0.16734651f, 0.04448364f, 0.04825006f, 
    0.06919760f, 0.05697473f, -0.08651676f, -0.06694802f, 0.09205978f, -0.06253748f, -0.10899398f, 0.11726760f, 
    0.12892219f, -0.08623797f, -0.18878020f, 0.09468364f, 0.15813811f, 0.00201208f, 0.00789070f, 0.02822223f, 
    0.04371133f, 0.07305031f, -0.01250584f, -0.00838589f, -0.02027951f, 0.01496364f, 0.06079853f, 0.04270271f, 
    -0.07198263f, -0.03759652f, -0.00027079f, 0.09179033f, 0.17372775f, 0.03011917f, -0.16953230f, 0.03344092f, 
    -0.07917899f, -0.07415161f, -0.01520928f, 0.03354611f, -0.03691159f, -0.02201237f, 0.06733372f, 0.02939366f, 
    0.19978541f, -0.05068437f, -0.03236905f, -0.01577467f, 0.05692128f, 0.05448842f, 0.09138406f, -0.01191685f, 
    0.33325213f, -0.17018570f, -0.20586860f, -0.10851525f, 0.00779917f, 0.03412290f, -0.03509828f, -0.03227200f, 
    0.04206844f, 0.07112622f, 0.01835833f, 0.02640031f, -0.06398707f, -0.12675861f, 0.10523131f, 0.05824022f, 
    -0.03249861f, -0.03738094f, 0.07246304f, -0.00805237f, -0.16664971f, 0.18985537f, 0.24188955f, -0.03747378f, 
    0.02494925f, 0.14482953f, 0.07561018f, -0.04845730f, -0.12252563f, -0.05471982f, 0.03336169f, 0.04566401f, 
    0.10452218f, 0.11531181f, -0.08177960f, 0.05830499f, 0.01087524f, 0.00717462f, -0.15759933f, -0.02217099f, 
    -0.49605027f, 0.12739509f, -0.00143429f, 0.26519814f, 0.13507172f, -0.04850928f, -0.02909737f, 0.13399908f, 
    -0.08835379f, -0.06609585f, 0.05082505f, 0.07866048f, 0.08322219f, 0.11221485f, 0.03490112f, 0.01942358f, 
    -0.03110948f, 0.00294635f, -0.02758997f, -0.06157545f, -0.11040338f, -0.16421555f, -0.08019304f, 0.13512765f, 
    0.13673720f, 0.09825179f, -0.03675629f, 0.10765418f, -0.11472297f, -0.16102196f, -0.03032301f, -0.08242076f, 
    0.10089013f, -0.07499673f, 0.04367039f, -0.13909230f, -0.07005531f, -0.02358966f, 0.15659617f, 0.03604346f, 
    -0.08891825f, 0.38024724f, 0.14365508f, 0.14663979f, 0.10971735f, 0.03162898f, -0.23814824f, 0.03815673f, 
    0.05854560f, 0.05635500f, 0.04950570f, -0.04480223f, 0.00371807f, 0.08563365f, 0.04095913f, -0.17112729f, 
    -0.01659923f, -0.09226879f, 0.05559085f, -0.22362094f, 0.22799349f, -0.05565054f, -0.06174465f, 0.07888739f, 
    0.16838387f, 0.30782086f, -0.04311467f, -0.07712460f, -0.03166744f, 0.08829322f, -0.03707761f, -0.02069381f, 
    0.01287641f, 0.03034742f, -0.00640403f, 0.10263739f, -0.01419591f, 0.01769082f, 0.00266067f, 0.14171179f, 
    0.35326409f, 0.21302360f, -0.00299402f, 0.02170176f, 0.14050949f, 0.11934629f, -0.01543391f, -0.00312432f, 
    0.12165281f, 0.03119154f, -0.06077431f, 0.03102541f, -0.02479947f, -0.01214147f, 0.01564294f, -0.03402746f, 
    0.05112427f, -0.11893089f, 0.07670706f, -0.05168843f, 0.23047037f, -0.15535429f, -0.15829098f, 0.01636413f, 
    0.10189669f, -0.05456625f, 0.03440230f, -0.04547338f, 0.07933684f, 0.01736803f, -0.01550567f, 0.01836901f, 
    0.09428193f, 0.10635164f, 0.07160848f, 0.08119571f, 0.07349370f, -0.03973564f, 0.03660779f, 0.02529802f, 
    0.32277796f, -0.23015660f, -0.11137725f, -0.20092639f, 0.17301081f, -0.06056198f, -0.11119675f, -0.00950739f, 
    0.02908706f, 0.06427651f, 0.03665544f, -0.05300858f, -0.03328359f, 0.18308020f, 0.07715733f, 0.01838064f, 
    0.06419541f, -0.10949474f, 0.17426755f, -0.04070458f, -0.45829290f, -0.33128381f, 0.14632227f, -0.16167085f, 
    -0.15004371f, 0.14489447f, 0.13874011f, -0.00765701f, -0.05922257f, -0.05635272f, -0.01482506f, 0.00340787f, 
    0.05273003f, -0.00502010f, -0.09200440f, -0.05613437f, 0.03988368f, 0.12315512f, -0.08193237f, -0.05270515f, 
    0.14372012f, -0.05199949f, -0.13069415f, 0.02064656f, -0.32810307f, 0.15386270f, -0.11810299f, 0.12833215f, 
    -0.09892412f, 0.08005089f, 0.04275911f, -0.02748260f, 0.00377728f, 0.07076675f, 0.06283617f, 0.05693978f, 
    -0.03981349f, 0.14745276f, -0.00022945f, -0.06504697f, -0.22713606f, -0.16192119f, 0.03319353f, -0.12828845f, 
    -0.41851148f, 0.02819859f, 0.06421431f, -0.02937688f, 0.07818344f, -0.20746869f, -0.02324152f, 0.20347649f, 
    0.05122032f, 0.02563014f, 0.05410851f, -0.00338723f, -0.04743684f, 0.01327319f, -0.02072806f, 0.11546611f, 
    -0.13695057f, 0.42751405f, -0.09940025f, -0.10674100f, -0.26682314f, 0.11154974f, 0.02458115f, 0.08583995f, 
    -0.09924375f, -0.11780566f, 0.08248759f, 0.04179956f, 0.11257553f, -0.03728158f, 0.10234568f, 0.15246466f, 
    0.00741508f, 0.01080605f, 0.00953420f, 0.00027860f, 0.36986002f, -0.03670511f, 0.07982899f, 0.36180118f, 
    0.36984974f, -0.06072936f, 0.01794933f, -0.08066647f, 0.08388635f, 0.16938041f, 0.04526604f, 0.02291504f, 
    -0.07109392f, 0.06694884f, 0.14059101f, 0.02001659f, -0.07698695f, 0.04913271f, 0.02578622f, 0.02751292f, 
    0.01632450f, -0.22854124f, 0.16152072f, 0.20489556f, 0.12983927f, 0.01305491f, 0.10233632f, -0.07821462f, 
    0.09863773f, 0.21104071f, -0.04333764f, -0.04083860f, -0.01540191f, 0.09431519f, 0.08097257f, -0.18371102f, 
    -0.03524265f, 0.00932525f, 0.01213219f, 0.02375097f, -0.06070920f, 0.33628672f, -0.05632460f, -0.16552396f, 
    -0.20519221f, 0.04609642f, 0.04633096f, -0.03817649f, -0.10292637f, -0.11027653f, 0.11930372f, -0.05470133f, 
    0.00554381f, -0.02622837f, -0.04172155f, -0.04588655f, 0.10036556f, 0.04246866f, 0.14406328f, 0.09258781f, 
    -0.18488061f, -0.04368566f, 0.12695369f, 0.27452120f, 0.06380352f, 0.14412123f, -0.12823364f, -0.00605076f, 
    0.06021515f, 0.25275496f, 0.07728351f, -0.00541379f, -0.09553038f, 0.02830434f, -0.06973927f, 0.08757091f, 
    -0.01717471f, -0.08385611f, 0.16292219f, 0.07011957f, -0.04683690f, 0.26225060f, -0.08799515f, -0.39554569f, 
    -0.35916832f, 0.00313471f, 0.20457755f, -0.06691337f, -0.05302330f, -0.05431349f, -0.00030044f, 0.10498648f, 
    0.08722266f, -0.09002428f, 0.00700123f, -0.06575409f, 0.10229605f, -0.10664231f, 0.00667348f, 0.14266698f, 
    -0.28752208f, -0.18738960f, 0.12559798f, -0.10334133f, 0.03050398f, 0.14736022f, 0.17187582f, 0.01967625f, 
    -0.14319138f, -0.02698191f, 0.05191813f, 0.12097606f, 0.05147439f, 0.01461476f, 0.03560637f, -0.08562147f, 
    0.03524813f, -0.00536357f, -0.01890241f, -0.01398638f, -0.56752169f, -0.01139235f, 0.34498653f, -0.34582224f, 
    -0.31035295f, 0.09019568f, 0.21813715f, 0.08908288f, 0.05155981f, -0.10299280f, 0.06114201f, 0.00436608f, 
    0.04728607f, 0.00012101f, 0.18946135f, -0.12223391f, -0.01978669f, -0.04183733f, 0.10713799f, 0.08022350f, 
    0.00857665f, -0.01951443f, 0.05042361f, 0.04025533f, -0.05312030f, 0.04864144f, -0.04580905f, -0.05876251f, 
    0.02210956f, -0.01554270f, -0.01834921f, -0.04306572f, -0.00314984f, 0.02576180f, -0.05555984f, 0.04630008f, 
    0.02967355f, -0.00781376f, 0.03176789f, 0.01611132f, -0.04984672f, -0.02622077f, 0.00902558f, -0.03190915f, 
    0.04304620f, 0.04459799f, -0.03090541f, 0.04653529f, 0.00871359f, -0.04559233f, 0.04638375f, 0.00645771f, 
    -0.02499581f, 0.05124250f, 0.00871290f, 0.02433236f, -0.03382016f, -0.01448058f, -0.01546902f, -0.04076186f, 
    -0.01542297f, -0.03996962f, -0.00290917f, -0.02005189f, 0.02819641f, -0.05496776f, -0.05469533f, -0.03171254f, 
    0.01010392f, 0.00548030f, 0.02593525f, -0.03978007f, 0.03673265f, -0.04495582f, -0.01488354f, -0.02233635f, 
    -0.03494273f, -0.00645838f, -0.00394333f, -0.04943202f, -0.04964025f, -0.05657388f, 0.00418405f, -0.01234924f, 
    -0.02546507f, -0.01523013f, -0.00323689f, -0.01040372f, 0.04255293f, 0.00317468f, 0.04354706f, 0.02929953f, 
    0.00983188f, -0.03186498f, 0.04170410f, -0.05113868f, 0.01752068f, 0.00255210f, -0.00265379f, -0.05624730f, 
    0.00942075f, 0.05538145f, -0.03626532f, -0.00670444f, -0.02035435f, 0.00799027f, 0.02618676f, -0.00222585f, 
    0.01901702f, 0.01546542f, 0.00427335f, -0.00816748f, 0.02304712f, 0.00392889f, -0.03046615f, -0.05978683f, 
    -0.00676647f, -0.00502740f, -0.01691331f, -0.02144894f, -0.04406045f, -0.00879166f, -0.02845595f, 0.00555806f, 
    -0.01435666f, -0.03737682f, 0.04927684f, -0.02912255f, 0.01306353f, 0.00319502f, 0.02244530f, -0.03547062f, 
    0.04478084f, -0.01950951f, -0.04168262f, 0.04613097f, 0.00883991f, -0.04690807f, -0.00128097f, -0.00424780f, 
    0.03642852f, 0.01827960f, 0.00997087f, 0.02954883f, 0.02579875f, -0.05252297f, 0.02066571f, 0.00061511f, 
    0.01803983f, -0.00793563f, -0.03384691f, -0.02222582f, 0.04032838f, 0.01110688f, 0.02525917f, 0.04831332f, 
    -0.05074232f, 0.03566162f, -0.01201194f, 0.01901131f, 0.05346721f, -0.00107346f, -0.01725946f, -0.03376559f, 
    -0.01052268f, -0.04315397f, 0.04826106f, 0.01412763f, -0.02492271f, 0.00418185f, -0.02967662f, -0.02234185f, 
    -0.05342028f, -0.01579592f, -0.04147746f, -0.05606185f, -0.01592990f, -0.04442167f, -0.00729686f, -0.00104712f, 
    0.01442463f, 0.04136502f, -0.04650002f, 0.01764086f, -0.02811327f, -0.00528338f, 0.03931542f, -0.05316793f, 
    -0.03830096f, -0.05914027f, -0.04954448f, -0.03281314f, 0.03078949f, -0.05277964f, 0.03340901f, 0.04185841f, 
    -0.01763657f, 0.02551345f, 0.00403429f, -0.02136151f, -0.04536488f, -0.05806280f, -0.00904736f, 0.03867770f, 
    -0.00268296f, 0.03051264f, 0.01189789f, 0.04166925f, -0.02030362f, -0.02948668f, -0.05063710f, 0.02562468f, 
    -0.02768536f, -0.05155707f, 0.04751967f, 0.04765509f, -0.06027923f, 0.01458786f, 0.00352098f, 0.01992954f, 
    -0.04114030f, 0.04215174f, 0.01727700f, -0.02555139f, -0.01362159f, 0.00809142f, -0.01994888f, 0.01930451f, 
    0.04983407f, -0.02212363f, -0.04728347f, -0.01408912f, -0.03217979f, 0.03049977f, 0.03961201f, -0.04307498f, 
    -0.05868105f, 0.03617410f, 0.00192865f, -0.01529035f, -0.02324136f, 0.00467066f, 0.01218043f, -0.02946672f, 
    -0.03102328f, -0.00760569f, -0.05205080f, 0.03742792f, 0.01403700f, -0.04564721f, -0.05393608f, 0.01601120f, 
    -0.01238971f, 0.04220949f, 0.04830828f, -0.03357556f, 0.03197255f, 0.05013916f, -0.05328451f, -0.01824978f, 
    -0.04745631f, -0.05758376f, -0.05647471f, 0.01828933f, 0.02577009f, -0.04372504f, 0.00394437f, -0.03815981f, 
    -0.04777607f, -0.02247944f, -0.01753843f, -0.01890907f, 0.04259869f, -0.02201630f, 0.02952122f, -0.00997395f, 
    0.02565957f, 0.04451148f, 0.00332259f, 0.01544177f, -0.05347077f, -0.00635454f, 0.00816751f, 0.02046026f, 
    -0.02797052f, -0.05425847f, 0.02692983f, -0.05705399f, -0.01333399f, 0.00821468f, 0.01499707f, -0.01177736f, 
    -0.05394736f, -0.00319392f, -0.02598091f, 0.03885511f, -0.02921569f, 0.00694985f, -0.01265841f, 0.02470897f, 
    -0.01019283f, 0.04692779f, 0.01061080f, -0.02021821f, -0.01783566f, 0.03812066f, 0.03455149f, -0.05840955f, 
    -0.02703126f, -0.03863367f, -0.04031083f, -0.05431971f, -0.04286078f, 0.01338335f, 0.03681180f, 0.04346734f, 
    0.02231809f, 0.00805992f, -0.04208835f, -0.04619585f, -0.04544688f, 0.02142382f, 0.04229461f, 0.03261243f, 
    -0.03185735f, 0.02967024f, 0.04146018f, 0.05425221f, 0.05057415f, -0.04308771f, 0.01682144f, 0.01009376f, 
    -0.02591768f, -0.04936080f, 0.00896846f, -0.02700377f, -0.01475116f, -0.04198194f, -0.00787198f, 0.02006026f, 
    -0.05879899f, -0.17082500f, -0.10623675f, -0.09226642f, 0.12526368f, -0.07694349f, 0.12413401f, -0.05485814f, 
    -0.03975363f, 0.07738931f, -0.07292581f, -0.00401306f, 0.10720318f, 0.05412526f, 0.06963476f, 0.13426599f, 
    -0.05410104f, 0.05450628f, 0.06350532f, -0.02501282f, -0.29070336f, -0.12156276f, 0.01986499f, 0.20806505f, 
    -0.25287539f, -0.02909199f, -0.11548546f, 0.00172658f, 0.21733147f, -0.10253947f, 0.12747869f, 0.07012199f, 
    0.04374690f, 0.00421386f, 0.05312147f, 0.06399262f, 0.06163341f, 0.01585029f, 0.03043559f, -0.11650349f, 
    0.02793860f, -0.25590497f, -0.09383897f, 0.13928275f, -0.21458769f, 0.01972484f, -0.01731777f, 0.13469933f, 
    0.01452056f, 0.11177853f, 0.04416430f, 0.06216951f, -0.09620132f, 0.03229032f, -0.00830911f, -0.03135584f, 
    0.10354325f, 0.00037314f, -0.01500246f, -0.01928815f, -0.18535320f, -0.16908160f, 0.07231327f, 0.19365992f, 
    -0.12970509f, 0.03226116f, -0.06598334f, 0.16205661f, 0.07248013f, -0.04175817f, 0.06499707f, 0.08165675f, 
    -0.07107536f, -0.00394233f, -0.05678057f, -0.09166638f, 0.01989346f, 0.10237410f, 0.07248990f, 0.13583288f, 
    0.00069329f, 0.36056536f, -0.32441157f, 0.03038709f, 0.23768212f, 0.08778826f, -0.07594490f, -0.07549313f, 
    -0.05914527f, -0.12968510f, 0.04710925f, 0.05707845f, 0.00974507f, -0.07688401f, -0.09002075f, 0.19034761f, 
    -0.02243607f, 0.03821022f, -0.13385125f, -0.03901033f, 0.12817296f, 0.23041388f, 0.33832452f, 0.14403579f, 
    -0.15775284f, -0.00954904f, -0.01121286f, 0.04051179f, 0.08437040f, 0.10376314f, -0.00532940f, -0.00334121f, 
    0.07722234f, 0.07627130f, 0.01042742f, 0.04034579f, -0.12239436f, -0.00412836f, 0.12660238f, 0.09794550f, 
    -0.04656360f, 0.02180187f, 0.20468119f, 0.13903497f, 0.03475173f, 0.11656316f, 0.11557936f, 0.04524748f, 
    0.00490093f, 0.07771243f, 0.03485507f, 0.02267771f, -0.04319401f, -0.07253463f, -0.03928621f, 0.09785191f, 
    0.10034267f, -0.05889670f, 0.09483513f, 0.04243200f, 0.10446753f, 0.10195789f, -0.05240785f, 0.21181215f, 
    0.12735178f, 0.00775745f, 0.10148077f, 0.08996310f, -0.08217699f, 0.21088646f, -0.01749222f, -0.02909228f, 
    0.09617458f, -0.02284758f, 0.19044892f, 0.06406722f, 0.05084516f, 0.04243337f, 0.06221614f, 0.19601537f, 
    -0.06077546f, 0.09752992f, -0.09235647f, 0.17545176f, 0.02680331f, 0.06681926f, 0.11870425f, -0.12002502f, 
    0.06652243f, -0.04881924f, 0.11242044f, -0.07494944f, -0.01856806f, -0.00300152f, -0.04143439f, -0.08763519f, 
    -0.03371958f, 0.05441746f, 0.06092827f, 0.03199356f, -0.37472656f, -0.14559607f, -0.30270889f, -0.28968024f, 
    0.08054171f, 0.06976344f, 0.02124585f, 0.10374222f, -0.05211934f, -0.08157255f, -0.02903918f, 0.08031414f, 
    0.09759218f, -0.06676925f, -0.01091683f, -0.06378982f, 0.06895056f, -0.00439812f, -0.01247449f, -0.04957835f, 
    -0.42719805f, 0.10765879f, -0.20663466f, -0.19369221f, 0.13854490f, 0.01298645f, 0.08510130f, 0.03137019f, 
    -0.06178436f, -0.08321527f, 0.07595119f, 0.05845002f, 0.17123121f, 0.01737428f, -0.00754169f, 0.01653482f, 
    0.07100362f, 0.05815641f, 0.08782087f, 0.06681141f, -0.04142132f, -0.36821982f, 0.09204017f, 0.11616598f, 
    0.08069346f, 0.02886291f, 0.12997080f, -0.05380058f, 0.10490411f, -0.03427058f, -0.00913674f, -0.13401778f, 
    -0.01664636f, 0.06209818f, -0.05233111f, -0.14530492f, 0.03065447f, -0.04863555f, -0.07560703f, -0.12133890f, 
    -0.22187756f, 0.00415007f, -0.15059914f, -0.06339992f, 0.07240593f, -0.07095569f, 0.23600665f, -0.06999195f, 
    -0.10404383f, 0.01408119f, -0.00231596f, 0.05530586f, 0.00444253f, 0.07318319f, 0.13752884f, 0.02112663f, 
    0.10382874f, 0.06901870f, -0.02260977f, 0.07504560f, 0.01410648f, -0.09390579f, -0.14424066f, 0.28591371f, 
    0.06133618f, -0.02613739f, 0.01749481f, 0.03645419f, -0.01730492f, 0.14326482f, -0.04143883f, -0.18895534f, 
    0.02671826f, 0.02854514f, 0.08779214f, 0.04278431f, -0.01098817f, 0.09201601f, 0.05989747f, 0.03052194f, 
    0.07524845f, 0.14342871f, 0.11896744f, 0.19427499f, -0.23053381f, -0.04416291f, -0.01986546f, 0.13158466f, 
    0.15706542f, 0.08241101f, -0.03069144f, 0.03843148f, 0.06020819f, -0.03819318f, -0.05644613f, -0.02791394f, 
    0.00879088f, -0.06102934f, 0.07150827f, -0.01877192f, 0.16390550f, 0.21905854f, -0.22887042f, 0.06559403f, 
    0.08861277f, -0.17481257f, 0.13828570f, 0.13146271f, 0.20489024f, 0.06032678f, 0.00421606f, 0.11669708f, 
    0.00829510f, -0.06760115f, 0.02084602f, 0.01896597f, 0.13587798f, 0.16853930f, -0.02588869f, 0.22780319f, 
    -0.02638181f, -0.04988185f, 0.02375280f, -0.03434496f, -0.04733831f, 0.04727393f, -0.04356747f, 0.04966578f, 
    -0.00335147f, -0.03827561f, 0.02161536f, -0.00232454f, -0.03253891f, -0.03404915f, -0.02147092f, 0.00413995f, 
    0.04608161f, -0.03168687f, -0.00701886f, -0.00234243f, -0.03041340f, 0.03050834f, -0.03300171f, 0.01410769f, 
    0.00224864f, -0.00178070f, 0.03995599f, 0.04403786f, -0.00425239f, 0.01745323f, 0.03838003f, 0.01159313f, 
    0.03519632f, 0.04834731f, 0.02967393f, -0.00763393f, -0.01792615f, -0.02710944f, -0.05104137f, 0.03964241f, 
    -0.02315786f, -0.00924505f, 0.02619641f, 0.00073261f, 0.02598563f, -0.05335887f, -0.05459927f, -0.04579083f, 
    -0.01053871f, -0.05307015f, 0.00411150f, -0.03189166f, -0.05175404f, -0.00721472f, 0.02248984f, -0.00490645f, 
    -0.01069104f, -0.00490890f, -0.00821509f, -0.00864599f, 0.01033528f, -0.03086886f, -0.05643575f, 0.03601151f, 
    -0.02096763f, 0.03841254f, 0.04384407f, -0.05117417f, -0.02035133f, -0.04085514f, -0.03522841f, -0.05580695f, 
    -0.05648758f, 0.04123563f, 0.01835900f, -0.04144457f, -0.00380647f, -0.00032163f, -0.04470361f, 0.01958144f, 
    -0.02763188f, 0.02512539f, -0.04437589f, 0.00553795f, -0.04196126f, 0.03971649f, -0.00293353f, 0.02133491f, 
    -0.01235874f, -0.00289279f, 0.00819109f, 0.03875396f, 0.02043479f, -0.02925604f, 0.01202693f, 0.00356560f, 
    0.03839269f, 0.00820731f, -0.05762078f, 0.00462146f, 0.02780250f, -0.04186127f, -0.02825797f, -0.05352099f, 
    -0.03742141f, -0.01158729f, 0.03209608f, -0.05874480f, 0.03714153f, -0.02558616f, -0.03800676f, -0.02358763f, 
    0.02216888f, 0.03589847f, -0.00605242f, -0.00013767f, 0.04459539f, -0.01866190f, 0.03190575f, 0.04680778f, 
    -0.00630205f, -0.03893427f, 0.00791413f, -0.04677850f, 0.03411541f, -0.00022985f, 0.03899450f, -0.01664297f, 
    0.04378491f, 0.01950572f, -0.00500432f, 0.00576650f, 0.01625980f, 0.04856823f, -0.01275568f, 0.01433204f, 
    -0.04189184f, -0.04373930f, -0.04405250f, 0.03280174f, -0.05393014f, -0.01039308f, -0.00094503f, -0.04648137f, 
    -0.04831129f, -0.01284141f, 0.03583821f, -0.04771876f, -0.05860977f, -0.06013680f, -0.06018222f, 0.01464421f, 
    -0.05306834f, 0.04589166f, -0.04835106f, -0.01203588f, -0.04150562f, -0.00492622f, 0.03229245f, -0.04761545f, 
    -0.02545332f, -0.03221435f, 0.00986210f, 0.00911959f, 0.02826737f, 0.01204484f, 0.03599726f, 0.01385580f, 
    0.02705445f, 0.03974959f, -0.00593535f, -0.03114069f, -0.03477008f, -0.03164335f, 0.03898874f, -0.03642249f, 
    -0.00697373f, -0.03847637f, -0.00623601f, -0.04211512f, -0.00617549f, -0.02577427f, 0.03244333f, -0.00545137f, 
    -0.00816073f, -0.00399152f, 0.02664345f, -0.01534484f, 0.01485328f, 0.02779565f, 0.02733364f, 0.00377034f, 
    0.01940507f, -0.00314211f, 0.04206586f, -0.01326683f, -0.02714185f, -0.02774569f, -0.01650088f, -0.05667749f, 
    0.04315961f, -0.03293389f, -0.02531680f, 0.01802791f, -0.02455071f, -0.02563062f, 0.03402390f, -0.00863339f, 
    0.04482911f, -0.02772370f, 0.03446805f, -0.02940266f, -0.00758007f, -0.06057987f, -0.00070655f, 0.00166416f, 
    -0.01608150f, -0.05967995f, 0.01104170f, -0.04006488f, 0.03102179f, -0.00324316f, -0.04487734f, -0.02332938f, 
    -0.05363265f, 0.01905160f, -0.03679621f, 0.01692736f, -0.00055323f, 0.04242441f, -0.04992984f, 0.01920173f, 
    0.02199221f, -0.05593032f, 0.00250114f, -0.04741543f, -0.06028246f, -0.04176709f, -0.01260410f, 0.00230353f, 
    -0.03942047f, 0.00839926f, 0.01097419f, -0.03442714f, -0.06106581f, 0.04096789f, -0.04462394f, 0.00607801f, 
    0.00629015f, -0.05331055f, -0.03703561f, -0.00760774f, -0.04561078f, -0.04877366f, 0.00766660f, -0.02518390f, 
    -0.04789447f, 0.04171102f, 0.03712189f, -0.02397162f, 0.00136148f, -0.03385112f, -0.03136812f, -0.03047916f, 
    -0.03418278f, 0.04113099f, 0.01187500f, -0.04876196f, 0.02261858f, 0.04468625f, -0.02978926f, -0.05782553f, 
    0.02915444f, -0.04730358f, 0.04091916f, -0.03441262f, 0.03515178f, 0.04233764f, -0.00833016f, -0.03662515f, 
    -0.04892781f, 0.03761808f, -0.01130060f, -0.01940537f, -0.05650843f, -0.01675964f, -0.04672062f, 0.00790397f, 
    0.03669192f, -0.01099153f, -0.01122805f, -0.04582093f, -0.04556294f, 0.04454061f, -0.00513219f, -0.00457969f, 
    0.00712565f, -0.04786291f, -0.01270439f, 0.01290560f, 0.03903906f, 0.00581565f, 0.02029258f, -0.04297838f, 
    -0.00600460f, 0.04220407f, -0.02286357f, -0.05647749f, 0.04845512f, -0.03560195f, -0.02437490f, -0.02460394f, 
    -0.00525094f, -0.00867795f, 0.00614804f, -0.04570717f, 0.04474012f, -0.05107938f, 0.04363817f, -0.05892245f, 
    -0.05765953f, 0.01511316f, 0.01026671f, 0.03200063f, -0.00373127f, -0.01163965f, -0.01138336f, 0.03566688f, 
    0.02183002f, 0.00993049f, -0.02486564f, -0.03139626f, -0.00658299f, 0.00910909f, -0.01697439f, -0.04606966f, 
    -0.04507050f, 0.02147808f, 0.02033978f, -0.03562098f, 0.00626503f, -0.01637138f, 0.01199129f, -0.04738178f, 
    -0.00815668f, 0.01575493f, 0.01325737f, -0.02971310f, -0.01605096f, -0.02423755f, 0.01777553f, -0.05781860f, 
    -0.01395708f, -0.01575946f, 0.05617088f, -0.02263888f, 0.01945862f, -0.01382692f, -0.01654436f, -0.00928325f, 
    0.03895369f, -0.02822396f, 0.03520271f, 0.00976845f, -0.00926161f, 0.02808037f, -0.02851791f, -0.01915877f, 
    -0.01476633f, 0.03044624f, -0.03448487f, -0.01326400f, 0.02803324f, 0.02702174f, -0.04627225f, 0.00212095f, 
    0.02580469f, -0.02509395f, 0.02674422f, 0.04152375f, 0.01145369f, -0.04046885f, -0.05728374f, 0.00133832f, 
    0.02850366f, 0.01151425f, -0.05168000f, -0.03850473f, -0.05676008f, 0.01814750f, -0.04793025f, 0.02568571f, 
    -0.04518399f, -0.00640033f, -0.03146238f, -0.04589456f, -0.05322194f, -0.01440310f, -0.02914915f, -0.01708225f, 
    -0.03907863f, -0.02842659f, -0.05492663f, 0.02042071f, 0.00254370f, 0.02692121f, -0.04041089f, -0.05605393f, 
    0.01676194f, -0.00380604f, 0.02011741f, -0.01876678f, -0.04022232f, -0.02884504f, 0.04024491f, -0.02023646f, 
    -0.00668887f, -0.04318059f, -0.01157811f, -0.02027778f, -0.00329196f, 0.01807967f, -0.00558542f, -0.01228441f, 
    0.00664573f, -0.04788031f, 0.04421182f, -0.00639946f, -0.06099678f, 0.04734786f, -0.04277582f, 0.04150729f, 
    -0.03307253f, -0.05391456f, 0.02802932f, -0.00313738f, -0.00186691f, -0.00666206f, -0.06124991f, 0.02321633f, 
    0.01428469f, 0.03502445f, -0.04087223f, -0.04112672f, -0.02425347f, -0.03736789f, -0.03660570f, -0.00546316f, 
    -0.02030437f, 0.02053990f, 0.03146539f, -0.03651397f, -0.02777806f, -0.05200106f, 0.01446754f, -0.06292409f, 
    -0.03970562f, 0.03094031f, -0.02913029f, 0.03659735f, 0.00174187f, -0.02659266f, 0.03461671f, -0.01402416f, 
    -0.05993694f, 0.02434859f, -0.05056638f, 0.04536184f, 0.04218635f, -0.05698311f, -0.02245923f, 0.01454841f, 
    -0.04059476f, 0.03075205f, -0.02244225f, 0.01084675f, -0.02074036f, -0.06128278f, -0.02674588f, -0.00500509f, 
    -0.00097777f, 0.04586934f, 0.00898895f, -0.02447756f, 0.02797522f, 0.02910101f, 0.01151364f, 0.04028219f, 
    -0.01075563f, -0.01881622f, -0.00609230f, 0.02151739f, -0.02447195f, 0.01510042f, -0.03193769f, 0.01696360f, 
    -0.04740316f, 0.00886955f, -0.00370659f, -0.03284544f, -0.01616362f, -0.01911957f, 0.03910198f, -0.03631138f, 
    0.03163733f, 0.02806787f, -0.02804236f, -0.01163078f, -0.00626935f, -0.04519051f, -0.02200525f, 0.00708803f, 
    0.01164287f, -0.04551041f, -0.04646556f, -0.03808422f, 0.00073626f, -0.03133717f, -0.01637872f, -0.05202099f, 
    -0.05104692f, 0.02204592f, 0.05340036f, -0.00055351f, 0.04274432f, 0.02206342f, -0.02116475f, 0.04309402f, 
    -0.01292352f, -0.03665373f, 0.03396683f, 0.04380888f, -0.04017311f, 0.02658336f, 0.00702940f, 0.01724719f, 
    0.02596531f, -0.04956032f, 0.04608044f, 0.02036076f, -0.03574748f, 0.04082328f, 0.03577960f, 0.02197820f, 
    -0.03587757f, -0.03664508f, 0.02651590f, -0.01188643f, 0.00740899f, 0.03971912f, -0.01442510f, -0.03231342f, 
    0.00622640f, -0.03372485f, -0.04782753f, 0.04329443f, -0.05272228f, -0.01569993f, -0.04298741f, 0.03122920f, 
    -0.02004246f, 0.02361693f, 0.02043642f, 0.03452339f, -0.03498133f, -0.00672560f, 0.02481280f, 0.00373914f, 
    -0.04718203f, -0.01563778f, 0.00433274f, -0.01026930f, 0.01825659f, 0.02038190f, 0.02986506f, 0.01563736f, 
    -0.05567160f, 0.03422358f, 0.01814985f, 0.02490795f, 0.02482544f, -0.00086582f, 0.03793038f, 0.03005443f, 
    -0.01734265f, 0.03288598f, -0.04032876f, 0.03692423f, -0.00119816f, 0.03537099f, 0.01525036f, 0.03306222f, 
    -0.01860039f, 0.00058680f, -0.05429269f, -0.06320895f, -0.00436193f, 0.01084898f, 0.02748998f, 0.00542168f, 
    -0.03881285f, 0.00545436f, -0.00701936f, -0.01998214f, 0.01073374f, -0.01352971f, -0.01897817f, 0.02891653f, 
    0.00514189f, -0.05629691f, 0.00542414f, -0.00698544f, 0.03322514f, -0.01953480f, 0.03332829f, 0.01123095f, 
    -0.00854253f, -0.00927671f, 0.00233697f, 0.03725414f, 0.01003343f, 0.04267507f, 0.04805796f, -0.02273243f, 
    -0.04752329f, -0.00074572f, 0.02139186f, -0.03336274f, -0.01252020f, 0.00400669f, -0.03918929f, -0.00752373f, 
    -0.03484456f, -0.06368766f, 0.05892683f, -0.00995819f, -0.03693181f, 0.03036844f, 0.00411889f, -0.02229284f, 
    0.01477115f, -0.09674937f, 0.13593332f, -0.03161157f, -0.22708322f, -0.06216916f, 0.10865325f, 0.01914501f, 
    0.01243075f, -0.01983427f, 0.12513851f, 0.14369293f, -0.05001061f, -0.14651626f, -0.08781078f, 0.00372228f, 
    -0.01302960f, 0.04508299f, 0.06516234f, 0.08570792f, -0.07559524f, 0.17983858f, 0.01772416f, -0.04063553f, 
    0.22933745f, -0.10787559f, 0.08784190f, -0.17164280f, -0.00597162f, -0.03889999f, -0.00913110f, -0.01678935f, 
    -0.02661616f, 0.14348434f, 0.00946542f, 0.01717775f, 0.11784678f, 0.00855523f, 0.02965484f, 0.13927831f, 
    -0.18700548f, 0.26271960f, 0.19085516f, -0.19093429f, -0.00437679f, -0.05331506f, 0.05628700f, -0.16194454f, 
    -0.00049217f, -0.20585221f, 0.03427809f, 0.00662727f, 0.05219992f, -0.13014388f, -0.12594487f, 0.14054118f, 
    0.02788360f, 0.16109525f, 0.03905914f, -0.03432591f, -0.20959044f, 0.46903929f, -0.11786027f, -0.30307272f, 
    0.01321985f, -0.10894753f, 0.07163782f, -0.20287098f, 0.10194558f, -0.00735657f, 0.13492344f, -0.00438376f, 
    0.07469188f, -0.00708130f, 0.00027528f, 0.14015290f, 0.01916285f, -0.01723954f, 0.15047768f, -0.07970831f, 
    0.13542940f, -0.28190532f, 0.01392054f, -0.00535733f, -0.28281149f, -0.07452863f, -0.14116293f, -0.09220695f, 
    -0.02697231f, 0.08179324f, 0.01227199f, 0.01988733f, 0.13044329f, 0.11760298f, 0.03797585f, -0.19536418f, 
    0.03887090f, -0.00221649f, 0.14254838f, 0.20660803f, -0.22512853f, 0.04441966f, -0.40993470f, 0.00504663f, 
    0.23156139f, 0.07335794f, 0.15576391f, 0.06513646f, -0.04994523f, 0.00258389f, 0.08040057f, -0.02909200f, 
    -0.06966981f, 0.08188304f, -0.01452820f, 0.00587317f, 0.12243009f, 0.05004792f, -0.13604704f, -0.00204476f, 
    0.21875891f, -0.16890618f, -0.05784114f, 0.06433921f, 0.11166868f, -0.14646044f, 0.09125256f, -0.07536395f, 
    0.06168382f, -0.09239326f, 0.02842765f, 0.06028532f, -0.04271929f, 0.18330248f, -0.02331459f, 0.03548255f, 
    -0.07068498f, 0.11296018f, -0.05408499f, 0.06195707f, 0.03510217f, -0.00760845f, 0.15347186f, -0.16064702f, 
    -0.14504035f, -0.02249068f, -0.05843545f, 0.07055786f, 0.06907678f, 0.04528856f, -0.06258813f, -0.04707884f, 
    0.03425959f, 0.04962470f, -0.01056667f, 0.05678563f, -0.01129904f, 0.06815802f, 0.16034354f, -0.00862285f, 
    0.34484729f, -0.22522675f, 0.17347077f, -0.07136950f, 0.00397685f, 0.02716182f, -0.00930193f, 0.01412006f, 
    0.01923828f, 0.02634376f, -0.02800566f, 0.12532598f, 0.03118834f, 0.07385284f, 0.02680864f, 0.03031009f, 
    0.10064027f, -0.04500859f, 0.08992890f, 0.00637695f, 0.37522477f, -0.08912738f, 0.03753690f, 0.14593713f, 
    -0.38980117f, -0.17517848f, -0.15816675f, 0.06759804f, -0.07983784f, 0.03792334f, 0.00236541f, -0.00097962f, 
    0.01413618f, 0.00817014f, 0.02115600f, 0.04019712f, -0.01292030f, -0.00393330f, 0.01103523f, 0.04914186f, 
    0.43156818f, 0.06974626f, -0.25623319f, 0.06377284f, -0.29987380f, -0.03989861f, -0.17459115f, 0.07188503f, 
    0.04144520f, 0.19759311f, 0.06734275f, 0.01961097f, -0.17939149f, 0.07223257f, 0.13008489f, 0.03998385f, 
    0.04810911f, 0.05737308f, -0.05848376f, -0.04812039f, 0.42370385f, 0.05489976f, -0.06804737f, -0.08397130f, 
    -0.20824884f, -0.22412145f, -0.12183972f, 0.08240516f, 0.03775711f, 0.08675750f, 0.00368099f, 0.14523281f, 
    -0.01426493f, 0.07254358f, 0.12802589f, 0.09282188f, -0.06580499f, -0.00826710f, 0.01031486f, 0.08284514f, 
    0.21250226f, -0.06770536f, -0.32308331f, -0.01739428f, 0.07972708f, 0.13796219f, -0.14825962f, -0.04702524f, 
    0.10039034f, -0.00695428f, -0.03213711f, -0.03781993f, 0.08275235f, 0.02653165f, 0.01012506f, 0.12415924f, 
    -0.04237982f, 0.04048574f, 0.00600221f, 0.01227855f, 0.04032658f, 0.14389643f, 0.19034843f, -0.14220963f, 
    -0.04118706f, 0.15073813f, 0.17459904f, 0.11515305f, 0.00713318f, 0.02526673f, -0.01288646f, 0.18304563f, 
    -0.05779221f, -0.06922375f, 0.04444404f, 0.09050030f, -0.02015322f, 0.00108198f, -0.06537823f, -0.00310727f, 
    0.02338145f, -0.13930680f, -0.25751752f, 0.02778175f, 0.31693718f, 0.10539376f, 0.06467728f, -0.03441887f, 
    -0.04471708f, -0.05517729f, 0.09002853f, 0.04913496f, -0.16927059f, 0.07593788f, 0.10267101f, 0.04965729f, 
    0.00210209f, 0.02561023f, -0.11103271f, -0.08544806f, 0.06482952f, 0.08026730f, -0.09031199f, -0.04701669f, 
    0.11247039f, 0.10436202f, -0.10651749f, 0.11505730f, -0.09717307f, 0.13116498f, -0.00648682f, -0.10073368f, 
    0.05409856f, -0.12894595f, 0.09077916f, -0.04675078f, 0.05079957f, -0.16587204f, 0.10043500f, -0.05748548f, 
    0.04508167f, 0.01320841f, -0.05198343f, -0.02482632f, -0.02354744f, -0.01867917f, 0.01580968f, 0.04447216f, 
    -0.04221061f, -0.05183868f, -0.00877111f, 0.01123371f, -0.03755411f, -0.01484283f, -0.04825324f, -0.01727028f, 
    -0.05728200f, -0.02688758f, -0.02536337f, -0.01581786f, 0.02335992f, -0.01626801f, 0.02148816f, -0.05259619f, 
    -0.05218494f, -0.01993110f, -0.05606723f, 0.04813090f, 0.03561160f, 0.00037376f, -0.00178001f, -0.00015802f, 
    -0.04272075f, 0.01166793f, 0.03278384f, 0.03548929f, 0.03577182f, -0.00134195f, 0.04777078f, -0.01036777f, 
    -0.01639370f, -0.04508034f, 0.02495930f, -0.04206688f, -0.01516546f, -0.04683491f, -0.04481624f, -0.02050296f, 
    -0.00269083f, -0.04005383f, 0.01596721f, -0.04691663f, 0.03658329f, -0.01629730f, -0.04188159f, 0.04688992f, 
    -0.03712927f, 0.02189587f, 0.02644112f, -0.00022033f, 0.01197342f, 0.04452946f, 0.03146372f, -0.00591861f, 
    0.00017063f, -0.00882784f, -0.05128241f, 0.03263519f, 0.00553928f, -0.01176516f, -0.04016250f, -0.02702253f, 
    0.02915668f, 0.01165971f, -0.00158483f, -0.04053001f, 0.01549720f, -0.00271995f, 0.00417133f, -0.01996709f, 
    -0.02455748f, 0.00569845f, -0.05882183f, -0.03249653f, -0.02392066f, -0.02614286f, -0.03611478f, -0.01605642f, 
    -0.02346182f, 0.04296118f, 0.00942081f, -0.04373706f, -0.04723296f, -0.01391707f, -0.00080740f, -0.02391313f, 
    -0.06052062f, -0.04324267f, -0.00423729f, -0.02414048f, 0.01597404f, -0.01895887f, -0.00607003f, 0.05039969f, 
    -0.03618307f, 0.01618926f, 0.04195661f, -0.05400403f, -0.01929281f, -0.04220300f, -0.01070238f, -0.02251330f, 
    0.02769015f, 0.01731957f, 0.03384219f, 0.04029459f, 0.02856888f, -0.02731568f, 0.00147525f, 0.04260276f, 
    0.02324897f, 0.04783275f, -0.02896316f, 0.01677537f, -0.06103632f, 0.00089033f, 0.02132799f, -0.03524446f, 
    0.01573755f, -0.03644181f, -0.01635725f, 0.04078233f, -0.05857478f, -0.02565570f, -0.00788833f, -0.04723811f, 
    -0.02213435f, -0.02175793f, -0.01006258f, -0.05247964f, 0.04230881f, -0.03355115f, -0.05913160f, -0.05734496f, 
    0.03641701f, -0.05951958f, -0.04730368f, 0.03357331f, -0.01547350f, 0.00064106f, -0.02945559f, 0.01901705f, 
    -0.06106864f, -0.00884057f, 0.01041931f, 0.00148281f, -0.03440445f, -0.03744840f, -0.05725447f, 0.02473042f, 
    -0.05043701f, 0.05518171f, -0.04997619f, 0.03456475f, 0.03008438f, 0.03182963f, 0.00602557f, -0.05387903f, 
    0.04863009f, -0.00337199f, 0.03339429f, -0.05945668f, 0.00036758f, -0.05630054f, 0.02893680f, -0.00661895f, 
    0.04178375f, 0.03744030f, 0.00904708f, 0.04584254f, -0.02959730f, 0.00607223f, 0.04011668f, -0.02781791f, 
    -0.03540494f, -0.05163480f, -0.00932748f, -0.03920485f, -0.04193883f, 0.01011597f, -0.04490545f, -0.04091109f, 
    -0.01414310f, -0.00997470f, 0.03193474f, 0.01117583f, -0.05284315f, -0.05212036f, -0.02011118f, 0.05495051f, 
    -0.03505354f, -0.00866176f, -0.00752634f, 0.01699425f, 0.03692641f, -0.02902027f, -0.01493770f, 0.05050117f, 
    -0.00375197f, -0.03297227f, -0.00432906f, -0.04134209f, -0.00216763f, 0.03803477f, 0.04545969f, -0.01395825f, 
    -0.05157217f, 0.04583296f, -0.03403913f, 0.03440600f, 0.02411456f, -0.02315209f, -0.03318816f, -0.02480731f, 
    0.02969310f, 0.01188270f, -0.04764698f, -0.03026124f, 0.00470276f, 0.00539905f, -0.00196797f, 0.03129511f, 
    -0.03987317f, 0.03924976f, 0.02235101f, -0.03095024f, -0.04284121f, 0.01545449f, 0.03956932f, 0.04761507f, 
    0.00097268f, 0.02219341f, 0.03079365f, -0.02413895f, -0.01627714f, -0.03899871f, 0.00345679f, 0.04138472f, 
    0.03778736f, -0.02516570f, -0.04709449f, -0.05774195f, 0.00055407f, -0.04599703f, -0.05494162f, 0.02361384f, 
    -0.01256457f, 0.04913047f, 0.01649256f, 0.02230890f, -0.02544397f, -0.02816132f, 0.04789271f, 0.00550252f, 
    -0.04761970f, -0.05169346f, -0.05366743f, -0.01052120f, -0.04391523f, -0.04206574f, 0.04901122f, -0.02725531f, 
    0.00136350f, 0.02338554f, 0.05025805f, 0.05034453f, 0.04720422f, -0.06060861f, 0.03831255f, 0.00070737f, 
    -0.00148507f, 0.03468400f, -0.00703950f, 0.01150288f, -0.00666140f, -0.01127420f, 0.04545015f, -0.03923673f, 
    0.04518032f, -0.04338953f, -0.04510453f, -0.03786521f, -0.03492026f, 0.04693647f, -0.02173376f, -0.03611980f, 
    -0.04597572f, -0.02786051f, -0.03524346f, -0.01727256f, -0.01081084f, 0.02990081f, -0.03816466f, -0.02580625f, 
    0.04907332f, 0.03625061f, 0.01747732f, -0.05046633f, 0.02058835f, -0.00106697f, 0.01908163f, -0.03642160f, 
    -0.01407492f, -0.01385780f, 0.04240417f, 0.00989177f, 0.02214950f, -0.04248379f, -0.03111123f, 0.03925916f, 
    -0.12470023f, -0.26466441f, 0.08866725f, 0.15457301f, 0.11502133f, 0.06555089f, -0.01561199f, 0.08566040f, 
    0.11984796f, 0.12028989f, 0.00888108f, -0.02366481f, 0.01993869f, 0.05712972f, -0.09313692f, -0.07861653f, 
    -0.03188976f, -0.04325370f, -0.05242509f, -0.02098647f, 0.27781966f, -0.08569268f, 0.01677926f, -0.03251092f, 
    -0.19315073f, 0.20938246f, 0.14467730f, 0.04815490f, -0.02843100f, 0.16456436f, -0.04436996f, 0.04329484f, 
    0.01704795f, -0.04850613f, 0.02874256f, 0.08398943f, 0.02899158f, 0.07880487f, -0.25370353f, 0.06098701f, 
    0.08820128f, 0.02425296f, -0.01830585f, 0.00980693f, -0.09232048f, 0.07925966f, 0.33884650f, 0.02927933f, 
    0.00523554f, 0.31769502f, -0.00548766f, 0.06880660f, 0.13029252f, 0.05717511f, 0.20715234f, -0.00197128f, 
    -0.00443000f, -0.08162867f, -0.05955980f, -0.00623957f, 0.21477860f, -0.38838091f, -0.10071453f, -0.09880224f, 
    0.19383235f, -0.08478405f, 0.16310446f, 0.03372301f, -0.03479479f, 0.16349798f, -0.02885579f, 0.09555087f, 
    0.10546053f, 0.01539453f, 0.25722927f, 0.13608584f, -0.00180563f, 0.13508250f, -0.11459825f, -0.01807258f, 
    0.08493429f, -0.25609633f, -0.26159438f, 0.09729502f, 0.00989027f, 0.08597720f, 0.08907668f, -0.02290621f, 
    -0.07052936f, 0.16034982f, -0.03637042f, 0.02694269f, -0.06390813f, 0.10052026f, -0.04053065f, 0.13865355f, 
    0.08502456f, 0.05784855f, -0.10594734f, 0.01915416f, 0.31779855f, 0.20253895f, 0.32688990f, -0.20379312f, 
    -0.17972177f, 0.09650316f, -0.03715671f, -0.05271957f, 0.06112617f, -0.00243197f, 0.06958925f, 0.07696774f, 
    -0.00545384f, 0.13858642f, -0.09624046f, 0.14296344f, -0.02731734f, 0.04084766f, -0.08425397f, -0.00781084f, 
    -0.18239373f, 0.27000725f, 0.20473722f, 0.26749220f, -0.10457957f, 0.06542066f, 0.04512736f, 0.14744724f, 
    0.01876434f, -0.05461514f, 0.14178059f, -0.03088254f, 0.02543923f, 0.18205874f, 0.09236625f, 0.06152143f, 
    0.09549602f, 0.06731929f, -0.07266262f, 0.03749515f, -0.16165304f, -0.11875439f, -0.12870401f, -0.03161595f, 
    0.04250311f, 0.00810596f, -0.02660054f, 0.15025094f, 0.04513497f, -0.02604928f, 0.01412052f, 0.10139451f, 
    -0.00125487f, 0.08460058f, 0.06908859f, 0.09487736f, -0.02270137f, 0.00492239f, -0.00711028f, -0.01371763f, 
    -0.11601736f, -0.38633931f, -0.00722329f, -0.22465113f, -0.22552186f, 0.25916511f, 0.10080078f, 0.14709380f, 
    -0.02133299f, 0.01418815f, 0.14945973f, 0.10452252f, 0.06520321f, -0.12936039f, 0.06874470f, 0.12602402f, 
    0.19539919f, 0.09438030f, 0.07916003f, 0.09772351f, 0.21358448f, 0.14723247f, -0.35199153f, -0.06710733f, 
    0.00546858f, 0.03759706f, -0.06777833f, -0.11345470f, 0.11362646f, 0.05113759f, -0.04044355f, -0.08719207f, 
    0.13957824f, -0.01573212f, 0.07803591f, 0.01013817f, 0.02157912f, -0.16128226f, -0.12372967f, 0.07930236f, 
    0.35144719f, -0.21967936f, -0.20462409f, 0.17820470f, -0.11538795f, 0.01847960f, -0.07984600f, -0.11760920f, 
    0.10442799f, -0.02795942f, 0.01560269f, 0.01921052f, -0.05028639f, -0.05379190f, -0.01667320f, 0.00955063f, 
    0.00736147f, -0.15300252f, -0.06200245f, 0.13671373f, -0.07505228f, 0.00463347f, 0.09899132f, 0.02064071f, 
    0.02554600f, 0.14156657f, 0.20362970f, 0.08346163f, 0.03609401f, -0.10324572f, -0.02031592f, -0.12024727f, 
    -0.02999946f, -0.10278173f, 0.00441701f, 0.04225444f, -0.01949144f, 0.05774659f, 0.00643049f, 0.01983468f, 
    0.17660905f, -0.20336552f, -0.01799891f, 0.18378897f, -0.09065895f, 0.14042273f, -0.00794507f, 0.01759290f, 
    -0.03261556f, 0.18978770f, -0.00968919f, 0.09034994f, -0.10161022f, -0.06150587f, -0.09790902f, 0.06610133f, 
    -0.09363777f, 0.12342006f, -0.05708264f, 0.01385474f, 0.12935232f, 0.07810961f, 0.08094107f, -0.18072750f, 
    -0.11831272f, 0.22505917f, 0.02561687f, 0.08474274f, -0.00834643f, -0.03593505f, -0.01316851f, 0.15481839f, 
    0.01904324f, 0.09186226f, 0.07563248f, 0.01466651f, 0.11256780f, -0.06681279f, -0.05577417f, 0.08541284f, 
    0.22642663f, 0.31886196f, 0.33797604f, -0.15446110f, -0.35665628f, 0.03035486f, 0.14200515f, -0.02309540f, 
    -0.09154576f, 0.11391513f, 0.08776733f, 0.04483411f, 0.16318582f, 0.08297952f, 0.02278327f, 0.10738673f, 
    0.00855811f, -0.03141388f, -0.14859742f, 0.01959025f, -0.12637690f, -0.41149208f, 0.12313668f, -0.29241347f, 
    0.03072858f, 0.19819075f, 0.00529158f, 0.02820088f, -0.07902197f, -0.04530714f, 0.00992288f, -0.01051632f, 
    0.09981619f, -0.06420972f, 0.01759992f, 0.00842314f, 0.07903179f, 0.01214113f, 0.02758086f, 0.05202130f, 
    0.11478902f, 0.37002510f, -0.11842166f, -0.12955478f, -0.02584701f, -0.02616334f, 0.09266381f, 0.13086671f, 
    0.03092869f, -0.08277474f, 0.09329430f, 0.02833533f, -0.01425860f, -0.27593216f, 0.18591721f, 0.10642213f, 
    -0.01953606f, 0.13335501f, 0.15618216f, -0.12195858f, -0.07596147f, -0.04693864f, -0.23385780f, 0.14489105f, 
    -0.24841847f, 0.14966109f, 0.05678102f, -0.09034698f, -0.02985865f, 0.07497390f, 0.04735669f, 0.12719437f, 
    -0.09403779f, -0.12829676f, 0.06471621f, 0.10021334f, 0.08210304f, 0.06891850f, 0.28433940f, 0.09758788f, 
    -0.19670880f, 0.05481724f, -0.08576112f, -0.12419350f, -0.06353592f, 0.11050286f, 0.06170101f, -0.14670722f, 
    0.06723655f, -0.00564472f, 0.10896568f, 0.01038520f, 0.00010066f, -0.06554819f, 0.03317470f, 0.01332007f, 
    0.08858613f, 0.33268833f, 0.10485742f, 0.17315149f, -0.31808573f, 0.09826415f, -0.02552819f, 0.12446897f, 
    -0.15645848f, -0.01801059f, -0.01094150f, 0.02143136f, -0.05534115f, 0.08394063f, 0.06017967f, 0.10424991f, 
    -0.01381276f, -0.03337334f, -0.05198865f, -0.05594018f, 0.04153728f, -0.01040906f, 0.03704660f, 0.03146235f, 
    -0.24370119f, 0.46832681f, -0.17631671f, -0.01265839f, 0.11729563f, -0.00297210f, -0.03753153f, -0.07983233f, 
    -0.00862458f, -0.16412824f, 0.08242036f, 0.08477142f, -0.01312197f, -0.13530631f, 0.07502931f, 0.01394487f, 
    -0.10561227f, -0.13862531f, -0.03463014f, -0.09388123f, -0.20823936f, -0.21821673f, 0.19849080f, 0.14481111f, 
    0.03850893f, 0.09500726f, 0.09126581f, 0.01018752f, -0.09986403f, 0.12389290f, -0.04229996f, -0.01481684f, 
    0.13003190f, 0.08655851f, 0.28596577f, -0.03876974f, -0.02485879f, 0.05321822f, 0.05390640f, 0.00394706f, 
    -0.13568161f, -0.08192579f, -0.08898729f, 0.12801774f, 0.02020786f, 0.15151891f, 0.10133089f, 0.04969997f, 
    -0.15398666f, 0.15645602f, 0.09903431f, -0.01536694f, -0.04886032f, 0.06144375f, 0.07348397f, -0.01570861f, 
    0.04313585f, 0.13631956f, 0.19326872f, 0.12349433f, 0.10991610f, -0.03876675f, 0.14435372f, 0.20138986f, 
    0.17644706f, 0.11189057f, 0.06741611f, 0.01153823f, -0.02205024f, 0.10985354f, 0.04126759f, 0.18396468f, 
    0.07641318f, 0.04457260f, 0.10368992f, 0.01945291f, 0.08621772f, -0.13053642f, -0.08691320f, 0.23012279f, 
    -0.30789059f, 0.15293127f, -0.07682019f, 0.38006717f, 0.04982773f, 0.15900888f, 0.11053120f, -0.01185605f, 
    -0.08313147f, 0.05034247f, 0.24009727f, -0.13456850f, 0.01547975f, 0.05263722f, 0.00183878f, -0.08755633f, 
    0.10145181f, -0.09872172f, 0.12448635f, -0.06694866f, -0.43241096f, -0.14680666f, -0.10620909f, -0.15427876f, 
    0.16675699f, -0.04372774f, 0.09115311f, 0.19019446f, -0.03856105f, -0.10115584f, -0.06378412f, 0.02246430f, 
    0.03293126f, -0.06734987f, -0.08109072f, -0.07410558f, 0.11800183f, 0.01572763f, 0.00562760f, 0.05573509f, 
    -0.33289495f, -0.04874462f, 0.08134339f, -0.13061294f, 0.05677745f, -0.00455367f, 0.01846875f, 0.07328068f, 
    -0.07690576f, -0.07790910f, 0.10943995f, -0.00881544f, 0.04371526f, 0.02790455f, -0.03513914f, 0.01513402f, 
    0.04903010f, -0.08289914f, -0.09323523f, -0.03338620f, -0.25709760f, 0.02345660f, -0.08671612f, 0.02333597f, 
    0.09290919f, -0.00122036f, -0.09292922f, 0.06398665f, 0.03406142f, 0.07260764f, 0.11015192f, -0.05908837f, 
    -0.00955713f, 0.04757309f, -0.01589713f, 0.16200370f, 0.16878721f, -0.12466884f, 0.09414113f, 0.14792003f, 
    -0.00602779f, 0.26242277f, -0.16803469f, -0.00200304f, -0.10303088f, -0.13515204f, 0.02281398f, 0.15186267f, 
    -0.01508133f, -0.06136807f, -0.01098803f, -0.01167692f, 0.14253145f, 0.02342385f, 0.09477163f, 0.04628257f, 
    0.10235353f, -0.16009410f, 0.07045222f, -0.05940442f, -0.11416478f, 0.00962240f, 0.05635923f, 0.28394493f, 
    0.24748531f, 0.01626818f, -0.17997390f, -0.03946155f, 0.02643486f, 0.01535153f, 0.15765016f, -0.12102519f, 
    0.13197893f, 0.13765526f, 0.15066460f, 0.04805495f, 0.09791306f, -0.04975946f, -0.12295147f, -0.00095133f, 
    -0.14646295f, -0.25262105f, 0.01996120f, 0.18889658f, -0.01093304f, 0.12201081f, 0.01320658f, 0.01321499f, 
    -0.04249845f, 0.05782583f, -0.05270282f, 0.03944991f, -0.08875963f, 0.04653541f, 0.09601273f, 0.03527708f, 
    -0.02539097f, -0.01835024f, 0.04356540f, -0.04836328f, -0.04997702f, 0.14955282f, -0.10376335f, 0.07131328f, 
    -0.03255418f, 0.08395576f, 0.10275944f, 0.09335149f, 0.18246122f, 0.08722876f, 0.29140511f, 0.07386607f, 
    -0.13160461f, 0.05159084f, 0.04434257f, -0.10887115f, -0.10022759f, -0.08851811f, 0.25764558f, -0.09713060f, 
    0.05183936f, 0.30811027f, 0.09723595f, 0.01386564f, 0.15778741f, -0.03086117f, 0.00648999f, 0.01070067f, 
    0.08546265f, -0.04949211f, -0.11198913f, 0.02306913f, -0.00308922f, 0.09276541f, 0.00768060f, 0.22763334f, 
    0.02423071f, 0.03354461f, -0.16658410f, 0.23526014f, -0.24988328f, 0.10636255f, 0.25234920f, -0.13143258f, 
    0.19873852f, -0.05986958f, -0.21101692f, 0.11670684f, -0.01152373f, -0.17110203f, -0.10548580f, -0.00309554f, 
    0.08920650f, 0.01306408f, 0.06824909f, -0.00031177f, -0.04569079f, -0.13654132f, 0.11370626f, -0.04324166f, 
    0.40739778f, -0.12132049f, 0.17530884f, 0.08239401f, -0.07593565f, 0.00821014f, -0.14324951f, 0.12737188f, 
    -0.07988329f, -0.02893303f, 0.13644032f, -0.14821973f, 0.05290002f, 0.21291278f, -0.03081658f, -0.02821611f, 
    0.02886936f, -0.10477713f, 0.17446746f, 0.00451660f, 0.71588004f, 0.08276010f, 0.21996509f, -0.09381724f, 
    -0.01767803f, 0.04358491f, -0.07589331f, 0.10998085f, -0.03048336f, -0.02343934f, 0.04559941f, -0.18013905f, 
    -0.04257484f, 0.02690342f, 0.00976790f, -0.00663619f, 0.01783527f, -0.07219810f, 0.06041787f, 0.13069560f, 
    0.07107629f, -0.21194080f, 0.26978910f, 0.01779457f, -0.17634964f, 0.15802783f, 0.00187903f, 0.17706224f, 
    0.01106337f, 0.04902179f, 0.04343353f, -0.04067666f, 0.15568608f, -0.09143746f, -0.16968757f, -0.04664658f, 
    -0.02768543f, 0.05945398f, 0.03134164f, -0.06204172f, -0.14600341f, 0.05872126f, 0.12275285f, 0.11668392f, 
    -0.07947201f, -0.16532893f, 0.00149783f, -0.11636865f, 0.04758822f, -0.03534708f, -0.10362039f, -0.02380869f, 
    0.02956443f, -0.18705772f, 0.03486170f, -0.05261480f, -0.04447433f, -0.07015069f, 0.12840389f, -0.02791249f, 
    -0.00869117f, -0.05255681f, 0.26317772f, -0.20586960f, 0.25257230f, -0.10611182f, -0.30279663f, 0.00988010f, 
    0.04149612f, 0.05608817f, -0.10616772f, -0.07522099f, 0.19839530f, -0.11664348f, -0.03076377f, 0.00951107f, 
    -0.06249243f, -0.12000896f, -0.00632821f, -0.09250991f, 0.05097521f, -0.41152453f, 0.25798675f, 0.19761339f, 
    -0.13900997f, -0.00192597f, 0.01873782f, -0.07875980f, -0.04394401f, 0.03992716f, -0.05189901f, 0.00046416f, 
    0.08204623f, -0.01879752f, 0.08479673f, -0.04744352f, 0.02101365f, 0.10834142f, -0.03940323f, 0.00817603f, 
    -0.18848214f, 0.37281555f, 0.16508290f, -0.05831330f, 0.28958970f, -0.14043361f, -0.07197872f, 0.02328053f, 
    0.21350634f, -0.01544636f, -0.11424831f, 0.03719953f, 0.18064152f, 0.08761396f, 0.02893548f, -0.09434761f, 
    -0.20859708f, 0.06035965f, -0.13209641f, 0.02831483f, -0.05369902f, 0.04153300f, -0.17294583f, -0.02433157f, 
    -0.18073051f, 0.10927001f, 0.09622326f, -0.01895249f, 0.13231225f, -0.04524285f, 0.11647379f, 0.05662175f, 
    -0.09220243f, 0.15467815f, 0.00260483f, -0.09421050f, -0.10273574f, 0.01870697f, 0.20305206f, -0.02061253f, 
    -0.32486120f, 0.02679758f, 0.03032768f, -0.14857021f, 0.08088162f, 0.09103289f, 0.04046281f, -0.14126264f, 
    0.08476633f, 0.08890642f, -0.02643324f, 0.06653809f, -0.00671746f, 0.12426578f, 0.09551845f, -0.04603747f, 
    -0.05613750f, 0.08776335f, 0.08744281f, 0.00833115f, -0.30846620f, 0.08342417f, 0.13988641f, -0.02956394f, 
    0.01478480f, -0.09605441f, -0.06568859f, 0.04691618f, 0.13415885f, -0.04395629f, 0.00314592f, 0.01592590f, 
    0.03740574f, 0.00569955f, 0.00436625f, 0.21892971f, 0.02374263f, 0.04852935f, 0.03707480f, -0.11597169f, 
    -0.06797153f, -0.02200268f, 0.14479841f, -0.09869329f, 0.22530454f, 0.18939182f, 0.02676425f, -0.06965270f, 
    0.00308744f, 0.02654634f, 0.16747624f, 0.08719856f, 0.04212792f, -0.05148550f, 0.09635264f, 0.07079935f, 
    0.08200420f, 0.14786744f, 0.08484109f, 0.08134189f, -0.03591155f, -0.07989015f, 0.12845881f, 0.12936714f, 
    -0.22481054f, -0.10041537f, 0.07348603f, 0.04228344f, 0.05281027f, 0.02353717f, 0.01864749f, -0.07272647f, 
    -0.11105351f, -0.05810441f, -0.03431145f, -0.12365183f, -0.01728309f, -0.07141933f, 0.27246666f, -0.07780227f, 
    -0.09998827f, 0.21564643f, 0.36076522f, -0.16158675f, 0.17819349f, -0.08708995f, -0.08173369f, -0.00470107f, 
    0.12002847f, -0.14602819f, -0.17013426f, -0.01561813f, -0.02649545f, -0.05871261f, 0.04004924f, -0.16423082f, 
    0.11744329f, 0.05918223f, 0.11671061f, -0.09337593f, -0.10501105f, 0.17113645f, 0.14853115f, 0.13889077f, 
    0.11207177f, -0.00259783f, -0.03283432f, 0.01156472f, 0.04529568f, 0.03406803f, 0.06184372f, 0.08275829f, 
    -0.04552422f, 0.10938279f, 0.09314029f, 0.13055761f, 0.05864623f, 0.16255035f, -0.21295430f, 0.06695773f, 
    -0.04272145f, 0.03538462f, -0.00624139f, 0.00731927f, -0.04912445f, 0.00262792f, 0.03330558f, 0.00701082f, 
    -0.04292085f, 0.01677295f, 0.03169062f, -0.01650381f, -0.06261104f, -0.00668275f, -0.02155183f, 0.02562733f, 
    -0.02060463f, -0.05809991f, -0.02566619f, -0.05088935f, -0.04726595f, 0.04253691f, -0.05592755f, 0.01912122f, 
    -0.02683078f, 0.02331175f, 0.02004374f, -0.04246803f, -0.01419328f, 0.02708297f, -0.02740878f, -0.07650673f, 
    -0.01524347f, -0.04594153f, -0.04417824f, 0.03504292f, -0.03979403f, -0.04858543f, -0.03777230f, -0.00326429f, 
    0.02357843f, 0.00322222f, -0.01094555f, -0.03409541f, -0.02224058f, 0.00207077f, 0.03710502f, -0.02358143f, 
    0.00965970f, -0.04086722f, -0.00233602f, -0.03392591f, -0.02378049f, -0.00602395f, -0.02681023f, -0.06187621f, 
    -0.06097410f, 0.02472405f, -0.01539025f, 0.02299068f, -0.03679686f, -0.00734573f, -0.02356442f, -0.04621752f, 
    -0.00692058f, -0.04069512f, 0.01469854f, 0.00414357f, 0.01827018f, -0.04760963f, -0.06014116f, 0.03470537f, 
    -0.06043966f, 0.02866635f, 0.00600655f, -0.01106669f, -0.03994412f, -0.02047378f, -0.01418679f, -0.05320386f, 
    -0.02732670f, 0.00913859f, -0.01173360f, -0.00442114f, -0.02166110f, 0.01281792f, -0.01652921f, 0.00094037f, 
    -0.04840465f, -0.00704048f, 0.01526996f, -0.03042124f, -0.03315065f, -0.05863727f, 0.02777328f, 0.01022697f, 
    -0.03664723f, 0.01071479f, 0.04600065f, -0.00585613f, 0.01740927f, -0.00894341f, 0.01880925f, 0.03712235f, 
    -0.01202644f, 0.01944298f, -0.01398578f, -0.05225542f, 0.05445533f, 0.00849541f, -0.02034704f, 0.00568574f, 
    -0.06210130f, 0.02151395f, 0.03633589f, -0.03420325f, -0.02922843f, -0.04904062f, 0.00655603f, 0.04072439f, 
    -0.01918942f, -0.01641206f, -0.02681575f, -0.01891215f, -0.01254317f, 0.00821604f, 0.02524071f, -0.05270346f, 
    0.04205694f, 0.00280947f, 0.00014179f, -0.00614469f, -0.01310689f, -0.04231209f, -0.02739760f, 0.03262116f, 
    -0.05949037f, -0.02984415f, -0.00139982f, 0.02774458f, -0.01415177f, 0.04629286f, 0.02183930f, -0.05620719f, 
    -0.05309404f, -0.03091807f, 0.02731539f, -0.02812816f, 0.04928422f, 0.04856708f, -0.03276058f, -0.04529633f, 
    -0.05290672f, 0.01581848f, 0.01953685f, 0.01342246f, 0.00954217f, -0.04531275f, 0.01267229f, 0.02653268f, 
    -0.04376399f, 0.04579795f, -0.03527275f, -0.02717924f, 0.03647747f, 0.03945899f, -0.00687187f, 0.01581396f, 
    0.01609346f, 0.03344834f, -0.04441799f, -0.02782719f, 0.03544274f, 0.04404246f, 0.00027388f, 0.01313880f, 
    -0.05920609f, 0.02291530f, 0.00191295f, -0.02198133f, 0.00101192f, 0.02769382f, 0.04224770f, 0.00608773f, 
    -0.01416544f, -0.00249277f, -0.01168693f, 0.00099481f, -0.00029346f, -0.03478016f, -0.00503053f, -0.03394689f, 
    0.04759349f, 0.00738846f, -0.02442062f, -0.03734023f, 0.02015118f, 0.04422826f, 0.01445033f, -0.03659690f, 
    0.00991901f, 0.00433304f, 0.02706362f, -0.05842460f, 0.00883080f, 0.00642012f, 0.03754744f, -0.02508859f, 
    -0.05099507f, 0.00183033f, -0.04043344f, 0.01629617f, 0.03264876f, 0.02340719f, 0.00500502f, 0.00673179f, 
    0.04925474f, -0.00663442f, 0.00338224f, 0.00852683f, 0.01820843f, -0.05374030f, -0.06016274f, 0.01381676f, 
    0.01517847f, 0.01234501f, 0.02461663f, -0.03726914f, 0.03753235f, 0.01403052f, 0.00157221f, -0.04939552f, 
    0.00347782f, -0.06193683f, -0.00340854f, -0.02917322f, -0.03648311f, -0.01507908f, -0.04981693f, -0.00170557f, 
    0.01293775f, -0.01565765f, -0.04272656f, -0.01039955f, 0.05049605f, 0.01179898f, 0.01420270f, 0.00986989f, 
    0.01734456f, -0.00023201f, 0.00030204f, -0.02494057f, -0.05969468f, -0.06032343f, 0.04552210f, 0.03724793f, 
    -0.05284078f, -0.00004251f, -0.03758879f, 0.00482835f, 0.02478280f, -0.04619092f, -0.00947174f, 0.02918608f, 
    -0.02943800f, 0.00765855f, -0.05653841f, 0.02011424f, 0.00575040f, 0.04988400f, -0.03139443f, 0.04387465f, 
    0.03932195f, 0.01011640f, -0.06106485f, -0.00040471f, 0.03792546f, -0.01687952f, -0.04929229f, 0.02797745f, 
    -0.04092379f, -0.00689515f, -0.01481717f, 0.03910410f, 0.01871290f, -0.05261957f, 0.02744226f, -0.01938499f, 
    -0.02085876f, -0.01075276f, -0.00443406f, 0.04696193f, -0.01916396f, 0.00153055f, 0.03903526f, -0.02102863f, 
    0.02653823f, -0.05465725f, 0.03770311f, -0.00822907f, 0.01319248f, -0.04160291f, -0.03968580f, 0.04049867f, 
    0.04297416f, -0.01669222f, 0.03805198f, 0.03953984f, 0.00567171f, 0.01826510f, -0.04126423f, -0.03971438f, 
    0.01577242f, 0.02527865f, 0.02061995f, -0.02736851f, -0.04029074f, -0.04814927f, 0.02933788f, -0.03722584f, 
    0.22674659f, 0.07392738f, 0.07620834f, -0.06736655f, -0.09293047f, -0.05875003f, 0.06571331f, 0.16388030f, 
    -0.11914325f, 0.02286112f, 0.09827204f, -0.05812764f, -0.01145712f, -0.06617070f, 0.00746171f, -0.21831048f, 
    0.11244048f, -0.09594577f, 0.11357308f, -0.00362661f, 0.51459861f, -0.16770716f, -0.32539445f, 0.06368069f, 
    -0.18308112f, 0.20334955f, 0.09973876f, -0.03460848f, -0.11070711f, 0.12978356f, 0.02163967f, -0.00060974f, 
    0.01911621f, -0.10486649f, -0.08328052f, -0.15084767f, -0.00972608f, 0.08788095f, 0.02317170f, 0.01635381f, 
    -0.15443477f, -0.24329059f, 0.06387857f, -0.16514441f, 0.08825476f, 0.02205556f, 0.03165747f, -0.14714719f, 
    0.02363581f, -0.08910242f, -0.02120068f, -0.02480305f, 0.08063547f, 0.08224960f, -0.06364408f, -0.00225753f, 
    -0.07220319f, 0.07564719f, -0.06547341f, -0.02709295f, -0.22644150f, -0.34531918f, -0.10028908f, 0.13989022f, 
    -0.00411661f, -0.05902087f, -0.05206811f, -0.23120265f, 0.09631763f, 0.02455513f, -0.07339302f, 0.05424794f, 
    0.03530494f, 0.07218793f, -0.09803268f, 0.14140320f, 0.03136191f, 0.07409354f, -0.05471126f, -0.03906615f, 
    0.06646517f, 0.16436215f, 0.18685749f, 0.15752536f, 0.34530103f, 0.02687549f, 0.07151158f, 0.07872736f, 
    -0.00781760f, 0.03046872f, 0.09599590f, -0.02355307f, 0.11085492f, 0.21130355f, 0.18966666f, -0.04547992f, 
    -0.02457537f, -0.08670054f, 0.05765073f, 0.11543382f, 0.15324166f, -0.43516451f, -0.28474790f, -0.33956647f, 
    -0.05343686f, 0.11085576f, 0.04375047f, -0.02977689f, 0.04514830f, -0.03092688f, 0.02770220f, -0.04355683f, 
    0.00098388f, 0.13189697f, -0.01093892f, 0.03031709f, 0.04804129f, 0.08426092f, -0.13346262f, -0.08574586f, 
    -0.08894495f, 0.08597369f, -0.29349166f, 0.02365201f, -0.18371654f, 0.20373292f, 0.03771735f, -0.07004609f, 
    -0.01183116f, -0.06486145f, 0.02273784f, 0.07091583f, -0.08730949f, 0.03194012f, -0.02185245f, 0.01888781f, 
    0.07768968f, 0.16629207f, 0.03488456f, 0.07787649f, 0.00332562f, 0.29745156f, 0.09723502f, -0.12159962f, 
    0.17721054f, -0.08891788f, -0.04312053f, 0.02125784f, 0.11320285f, -0.09006867f, 0.02215831f, -0.01090106f, 
    -0.10485590f, 0.08115330f, 0.01411781f, 0.08366695f, 0.07251723f, -0.10105537f, -0.05201400f, 0.03364639f, 
    0.17969431f, 0.12116544f, -0.37103051f, 0.04318985f, -0.16483371f, 0.03373313f, 0.10939556f, 0.03703824f, 
    -0.05545227f, 0.07160043f, 0.01230418f, 0.06409238f, -0.11808319f, -0.03941521f, 0.05451314f, 0.00573078f, 
    0.20624194f, 0.04784623f, 0.04688510f, -0.05520388f, 0.50638181f, 0.05423930f, 0.41353774f, 0.29058561f, 
    0.06693394f, -0.09532513f, 0.03693226f, 0.15266189f, -0.04395171f, 0.02739132f, 0.02150473f, 0.03041912f, 
    -0.07967325f, -0.07697184f, 0.01386774f, 0.00846608f, -0.03467054f, 0.02855305f, -0.06949886f, 0.08951239f, 
    0.40154657f, 0.11958791f, 0.49401364f, 0.18904461f, 0.05444706f, -0.07018521f, 0.00474150f, 0.09501337f, 
    -0.08469180f, 0.11859541f, 0.00641911f, 0.05389771f, 0.01785870f, 0.01985432f, -0.00750751f, 0.00739958f, 
    0.01436736f, -0.08644234f, -0.04040803f, -0.03686315f, 0.12242097f, 0.33148018f, -0.11269628f, -0.03662541f, 
    -0.06962431f, 0.16483901f, 0.07458580f, -0.10846417f, -0.06195748f, 0.04871216f, -0.05374965f, 0.10440306f, 
    0.05154869f, 0.03789929f, -0.09922013f, -0.06248866f, -0.04783509f, 0.03757087f, 0.01216027f, 0.19044176f, 
    0.14053686f, 0.23271576f, 0.19178560f, 0.26535204f, -0.09680332f, -0.16603011f, -0.03344103f, 0.16221094f, 
    0.07875504f, 0.02848170f, -0.10736381f, -0.09450012f, 0.02864691f, -0.00516093f, -0.06842754f, -0.10223175f, 
    -0.00192517f, -0.10850484f, 0.01801075f, -0.01704881f, 0.08236130f, 0.18165341f, -0.31471094f, -0.32502964f, 
    0.06235645f, 0.14272627f, -0.00422215f, -0.05977434f, -0.00132190f, 0.04087617f, -0.04485621f, 0.07756045f, 
    0.04306800f, -0.02661839f, -0.06872132f, 0.13391298f, 0.07012026f, -0.02596758f, -0.15089306f, 0.05575723f, 
    0.13077365f, -0.22494541f, -0.47703737f, -0.19249614f, -0.26601171f, 0.18745862f, 0.03109865f, -0.16047743f, 
    -0.05093545f, 0.03586593f, 0.04529506f, 0.04168190f, -0.05912652f, 0.05857935f, -0.00581177f, 0.06730415f, 
    -0.03104170f, -0.04275825f, 0.01395082f, 0.04609677f, 0.09715242f, 0.14936988f, 0.00778167f, -0.17656310f, 
    -0.07657114f, -0.11901136f, 0.09736370f, 0.01314421f, 0.02916271f, 0.10817215f, 0.02278570f, -0.02068538f, 
    0.00484167f, -0.12480107f, 0.05115391f, 0.00666264f, 0.02714597f, -0.03479087f, 0.19748151f, -0.10571548f, 
    0.03508762f, -0.00764523f, -0.00331793f, 0.02822036f, -0.04807593f, -0.05158557f, 0.00117433f, -0.04111619f, 
    0.03955553f, 0.00203974f, -0.05545073f, -0.02216923f, 0.02913338f, -0.03992468f, -0.02806096f, -0.00000212f, 
    -0.00345808f, -0.00568138f, 0.02629384f, 0.01596346f, -0.01573192f, -0.01840097f, -0.03912324f, -0.02155785f, 
    -0.04406706f, 0.00524321f, -0.03496176f, 0.05011281f, 0.02212033f, -0.03711963f, -0.02356004f, 0.01904826f, 
    0.03478279f, 0.01003768f, 0.01607553f, -0.04447294f, 0.04307158f, -0.01087198f, -0.05180765f, 0.01690701f, 
    0.02796437f, -0.01495940f, -0.00411450f, -0.03556952f, 0.03598154f, 0.03322831f, -0.04822362f, 0.02269867f, 
    -0.00663008f, -0.02908509f, 0.05362900f, -0.00173553f, -0.05064834f, -0.04547499f, 0.01507273f, -0.02824246f, 
    0.00664947f, -0.03757491f, -0.01644300f, 0.01250062f, 0.00973773f, 0.00455293f, 0.03487485f, 0.03556718f, 
    -0.05547320f, -0.00771386f, -0.02039507f, 0.02140768f, -0.02683849f, 0.00847510f, -0.05252494f, 0.03320078f, 
    -0.05403753f, -0.04788389f, 0.04675988f, -0.00299424f, -0.00848302f, -0.00702594f, 0.01224399f, 0.01473416f, 
    -0.04128858f, -0.02314836f, 0.05038869f, -0.01503409f, -0.01537973f, -0.05182212f, 0.03890153f, -0.02348999f, 
    -0.04364445f, 0.01652061f, 0.03961714f, -0.01630975f, 0.01925500f, 0.03869101f, 0.02535180f, -0.01230333f, 
    -0.00290099f, 0.03364611f, 0.01301544f, 0.02754062f, -0.00751779f, -0.00873246f, 0.03130133f, -0.04479230f, 
    -0.05295990f, 0.04433926f, 0.02793670f, 0.00540069f, -0.02271951f, 0.03054200f, -0.02068290f, 0.04340013f, 
    -0.04875355f, 0.00500447f, -0.01533812f, 0.03813801f, -0.05312671f, -0.05241482f, -0.00513738f, 0.01271290f, 
    -0.02734755f, -0.01959528f, -0.03915784f, 0.01464418f, -0.03498324f, -0.03129119f, 0.02978724f, -0.02159832f, 
    -0.01829655f, 0.01464480f, -0.04305561f, 0.00487756f, -0.03771586f, -0.02873825f, 0.01589177f, -0.02882730f, 
    -0.03918310f, 0.03017097f, -0.00251251f, 0.00034714f, -0.00938857f, 0.04517630f, 0.04061252f, -0.03120017f, 
    -0.03726797f, 0.01620577f, -0.05354217f, 0.01131408f, -0.04552668f, 0.01460634f, 0.01603993f, -0.02183726f, 
    -0.02289333f, -0.00958104f, 0.02993304f, -0.01074897f, -0.03671883f, -0.03353161f, 0.03755451f, -0.00625436f, 
    -0.02336010f, -0.02272322f, 0.01032761f, 0.03449310f, 0.00649579f, 0.04901548f, -0.04964682f, -0.00760822f, 
    0.04143846f, -0.01698062f, -0.03971129f, -0.03828618f, -0.04897508f, 0.01022920f, 0.01633717f, 0.01639492f, 
    0.05228751f, 0.02356572f, 0.01547578f, -0.02116131f, 0.01349736f, 0.00687362f, -0.01841987f, -0.00964779f, 
    0.00909536f, -0.04904758f, 0.00349501f, -0.02546707f, -0.00241197f, -0.02276434f, -0.01715797f, -0.03120909f, 
    0.03468356f, 0.03361072f, -0.00355075f, 0.04220290f, 0.02767798f, 0.02467808f, 0.03707946f, 0.04254331f, 
    -0.02046176f, -0.02349631f, 0.00843497f, -0.03618409f, -0.04028398f, -0.03774936f, 0.02743273f, 0.02593369f, 
    -0.03084039f, -0.00111989f, 0.03224365f, 0.01762718f, -0.03398600f, -0.01492555f, -0.05575927f, -0.04137098f, 
    -0.03401060f, 0.04076549f, -0.03171993f, 0.03456362f, -0.02037754f, -0.02845246f, 0.00862988f, -0.04494133f, 
    -0.00133414f, 0.02251503f, 0.01730170f, -0.05372305f, -0.03614100f, 0.03770694f, 0.03872355f, -0.03660484f, 
    0.00601157f, -0.05087967f, -0.00187156f, 0.02609770f, 0.02717002f, 0.00604166f, 0.01221581f, -0.04335175f, 
    -0.00676344f, 0.02759688f, -0.05442770f, -0.04674844f, -0.01837858f, 0.01756373f, -0.01010217f, 0.01611011f, 
    -0.04882845f, 0.00357969f, 0.04256686f, 0.03908831f, -0.01448345f, -0.04142034f, 0.05339176f, -0.02478128f, 
    0.00330208f, -0.03909944f, -0.04070190f, -0.04160085f, -0.04840884f, 0.00015051f, 0.02579004f, 0.01264669f, 
    0.04719944f, -0.02911674f, 0.04107245f, -0.03315544f, -0.04577118f, -0.03134531f, -0.02610445f, 0.02274285f, 
    -0.04246172f, 0.02802786f, -0.01398204f, 0.05423560f, 0.00823458f, -0.04353860f, 0.02556964f, -0.05347545f, 
    -0.04491456f, 0.05586008f, -0.00833337f, 0.00801630f, 0.01593252f, -0.05091826f, -0.01117371f, -0.00582816f, 
    0.01333077f, -0.00403254f, 0.00202039f, -0.02908600f, 0.05308289f, 0.04911817f, -0.04557225f, -0.05558490f, 
    0.04899818f, 0.05459402f, 0.05057650f, 0.01806773f, 0.05361495f, 0.03471922f, 0.02134980f, -0.02660795f, 
    0.00403112f, 0.03014740f, -0.04416448f, 0.03540237f, -0.05285751f, -0.03930895f, -0.04289927f, 0.00443576f, 
    -0.03977209f, 0.04598276f, 0.02176892f, -0.03480357f, 0.03940342f, -0.02620251f, 0.01668648f, -0.02161003f, 
    -0.00048678f, 0.01177052f, -0.02322325f, 0.00053667f, -0.04460413f, -0.03897928f, -0.03263649f, 0.01478074f, 
    0.04292906f, -0.01740421f, -0.03637740f, -0.02916790f, -0.00134665f, 0.01749993f, -0.05322779f, 0.03780838f, 
    0.03052037f, -0.05279627f, 0.00246842f, -0.04543500f, -0.00887250f, 0.04993666f, 0.03636402f, 0.05369272f, 
    -0.03509086f, 0.01806892f, 0.02215903f, -0.00735196f, -0.01931530f, 0.03755975f, 0.01985369f, 0.05698273f, 
    -0.00080845f, 0.04203122f, 0.01455099f, -0.05669183f, 0.04322877f, 0.00004686f, 0.00519066f, -0.04151348f, 
    0.04778308f, -0.00886403f, -0.02376794f, 0.00894422f, 0.00293442f, 0.02724937f, 0.00560159f, 0.00129861f, 
    -0.05015385f, -0.02362841f, -0.01062986f, 0.03427048f, -0.04657853f, 0.04138422f, 0.01650510f, -0.05748527f, 
    -0.00555802f, 0.01230350f, -0.05283754f, -0.04235726f, -0.02060413f, -0.02257999f, -0.00154591f, 0.01064087f, 
    0.03019883f, -0.00910084f, -0.01535790f, 0.01302644f, -0.03906256f, -0.04670375f, 0.02150470f, -0.06043196f, 
    -0.02308913f, -0.04990894f, -0.05865255f, -0.00808872f, -0.00676856f, 0.01528605f, -0.02695146f, 0.04549764f, 
    -0.04611629f, -0.03963839f, -0.04698126f, -0.01345255f, 0.04873521f, 0.02933549f, -0.02048646f, -0.03903433f, 
    -0.00174760f, 0.02903713f, -0.00875971f, -0.05913819f, 0.00057188f, 0.02851984f, -0.01193715f, 0.01812449f, 
    0.01646352f, -0.01254083f, -0.00590082f, 0.01851011f, 0.01483706f, 0.02877393f, -0.01707562f, 0.03088134f, 
    0.02083686f, 0.00237010f, 0.02207197f, -0.03534831f, 0.02644583f, -0.03669783f, -0.00509429f, -0.00941623f, 
    -0.02283732f, -0.00821933f, 0.02282182f, 0.01678572f, 0.02026144f, -0.01106594f, -0.05620862f, 0.05014350f, 
    -0.00371648f, -0.01455881f, -0.02209307f, -0.00140202f, 0.00866649f, 0.02310805f, -0.01644853f, 0.04890365f, 
    -0.05256952f, -0.04187498f, 0.03229714f, -0.02494835f, -0.03149108f, -0.02938351f, 0.00463359f, -0.01112888f, 
    0.01441448f, -0.06036784f, 0.02057264f, 0.01156755f, 0.00430357f, -0.05536480f, -0.05752249f, 0.02744602f, 
    0.02509405f, -0.05402762f, -0.02925093f, 0.01811885f, -0.05038725f, -0.03045611f, -0.05997462f, -0.00502463f, 
    -0.03730615f, -0.04498224f, 0.01573838f, 0.01689657f, 0.04415093f, -0.02684374f, -0.00182809f, -0.02356037f, 
    -0.04706027f, 0.00215698f, 0.02721638f, -0.01891861f, -0.02398501f, 0.00534024f, 0.00726732f, 0.01578402f, 
    -0.00042468f, 0.02185726f, -0.03691240f, -0.06078720f, 0.04474992f, 0.03218626f, 0.04209599f, -0.05331412f, 
    -0.05650450f, -0.04287738f, -0.05452742f, 0.01120355f, 0.03362135f, 0.00239212f, -0.03712741f, -0.04439002f, 
    -0.03296819f, -0.03044357f, 0.02047280f, 0.02718475f, -0.01331572f, -0.05952748f, -0.00994674f, -0.00424928f, 
    -0.01841166f, 0.02662949f, -0.03088036f, 0.01272792f, -0.01150812f, -0.01394021f, -0.03363456f, -0.03804228f, 
    0.04825586f, -0.03310873f, -0.02480977f, 0.01601947f, 0.03049215f, -0.04514546f, -0.00955939f, -0.01031875f, 
    -0.03959653f, 0.01875333f, -0.04733113f, -0.04448596f, 0.03167265f, 0.04731939f, -0.05383783f, -0.05927538f, 
    -0.05663853f, -0.02197704f, 0.03264720f, 0.01545521f, 0.03014398f, -0.02443718f, -0.02452159f, 0.00819406f, 
    0.04272532f, -0.05261257f, -0.05799072f, 0.01621302f, 0.02314716f, 0.03466455f, -0.06136689f, 0.02968820f, 
    0.04256626f, -0.04929671f, -0.05090591f, 0.03844279f, -0.03919563f, -0.05817712f, 0.02303266f, 0.00403232f, 
    -0.03189108f, 0.04974136f, -0.03379430f, 0.00637373f, 0.02757828f, -0.00910256f, -0.01377156f, -0.03231560f, 
    0.03855162f, 0.02469563f, 0.04127272f, 0.02366407f, -0.04661667f, -0.04738999f, -0.04199614f, -0.04574382f, 
    0.03511662f, 0.02665702f, 0.04475826f, -0.01518036f, -0.02585793f, 0.01886065f, 0.02880623f, 0.00127199f, 
    -0.05745415f, 0.02209882f, 0.04479213f, 0.02848131f, 0.04011429f, 0.04237303f, -0.03934060f, -0.01785008f, 
    -0.02974327f, -0.00659667f, -0.01769194f, -0.01806811f, 0.04126541f, 0.02699074f, 0.03368029f, 0.01428942f, 
    -0.02936710f, 0.01786501f, -0.04917040f, -0.05146006f, 0.00327374f, 0.03409144f, 0.03378768f, 0.00803972f, 
    0.00019562f, -0.05551768f, -0.04092895f, -0.04288010f, -0.05707786f, 0.01467165f, 0.00134457f, 0.05022545f, 
    0.06014811f, -0.02414428f, -0.04217703f, -0.01331148f, 0.01734553f, -0.01013567f, 0.00226946f, 0.01905260f, 
    -0.00062097f, -0.00773206f, -0.01455693f, 0.04088563f, 0.00853165f, 0.05005090f, -0.01400955f, -0.03000010f, 
    -0.04617144f, -0.00643090f, 0.04567653f, -0.02225289f, 0.03197709f, -0.04534534f, -0.04766201f, -0.03135233f, 
    -0.10877467f, -0.30410016f, -0.13059764f, 0.09973164f, -0.16702071f, 0.15276574f, 0.04826313f, -0.02366730f, 
    -0.03122494f, 0.01239813f, 0.09611617f, 0.08343654f, 0.12540974f, -0.10220315f, 0.01318381f, -0.02131602f, 
    -0.07309143f, 0.01031326f, -0.10005254f, 0.00109268f, -0.16091973f, -0.14397286f, 0.01909450f, -0.08792453f, 
    0.00220214f, -0.14662765f, 0.23788363f, 0.11154562f, 0.08873288f, 0.06732102f, -0.00126041f, 0.03965420f, 
    -0.04367163f, -0.00109727f, -0.01714546f, -0.00142196f, 0.02197888f, -0.01618315f, -0.12163192f, 0.04171865f, 
    -0.49371725f, 0.11816085f, -0.23449698f, -0.02131727f, 0.13975443f, -0.01933674f, 0.13011637f, 0.11184680f, 
    0.12561323f, 0.02283224f, -0.12476455f, 0.13461147f, 0.03790917f, -0.08641235f, 0.02043618f, 0.08204494f, 
    0.10524993f, 0.08917181f, -0.00126482f, 0.02057168f, -0.34783947f, 0.34312326f, -0.03857497f, -0.04505237f, 
    -0.04377918f, 0.00947907f, 0.14360707f, 0.01569874f, 0.07939774f, 0.02517395f, 0.00640338f, 0.09578496f, 
    -0.00397633f, -0.01938033f, 0.01040797f, -0.01840508f, -0.03824010f, 0.04530149f, -0.01645304f, -0.01725635f, 
    -0.14540438f, 0.26152322f, -0.02744530f, -0.02971487f, 0.10750508f, -0.15603060f, -0.01008642f, -0.10430580f, 
    0.04722347f, -0.09198719f, -0.03168254f, 0.10387260f, -0.10195316f, 0.02377821f, 0.07858166f, 0.08292365f, 
    -0.08773766f, 0.00371976f, 0.04656554f, 0.05387693f, 0.38071293f, 0.22347036f, -0.40225300f, -0.04261263f, 
    0.05123233f, 0.01507850f, -0.02777517f, 0.14088145f, 0.03393675f, 0.11922003f, 0.13408886f, 0.00455022f, 
    -0.02030256f, -0.00070082f, 0.01392444f, 0.12631054f, 0.08390995f, -0.05203623f, -0.03805413f, 0.14310311f, 
    0.25087538f, -0.13066941f, -0.03376580f, -0.12056883f, 0.02637855f, -0.07879034f, 0.24655850f, 0.02864103f, 
    0.11669247f, 0.02218822f, 0.04271141f, -0.02109252f, -0.15995131f, 0.04581091f, 0.05322550f, 0.01962521f, 
    0.00924144f, -0.00756556f, 0.07152941f, 0.01890017f, 0.38789555f, 0.37942579f, -0.20185271f, 0.10724451f, 
    0.26862523f, 0.07123929f, 0.02248492f, 0.19694649f, 0.02545915f, 0.00834520f, 0.04131573f, -0.02135348f, 
    0.00288479f, 0.02057886f, -0.04823483f, 0.07512496f, -0.05071105f, -0.04053876f, 0.10564129f, -0.11946329f, 
    0.30550402f, -0.38096330f, 0.04259425f, 0.02565631f, -0.12521595f, 0.08306215f, -0.02770787f, -0.04207189f, 
    0.08697426f, 0.03349932f, 0.00047636f, 0.09112720f, -0.15592769f, 0.08130926f, -0.07584152f, 0.00475109f, 
    0.14664243f, -0.12155116f, 0.03945191f, 0.10095590f, -0.25251120f, 0.24572100f, 0.11196918f, 0.08677918f, 
    -0.09758885f, 0.02008318f, -0.09478962f, 0.01430547f, -0.08582807f, 0.07547293f, -0.15581593f, 0.01969132f, 
    0.13521247f, 0.02885498f, -0.09876525f, 0.02312222f, 0.06676678f, 0.00965773f, -0.05865845f, -0.14302562f, 
    0.49705958f, 0.18504821f, -0.12352312f, 0.05762393f, -0.08399978f, -0.02433060f, -0.03953639f, 0.09399781f, 
    0.00971336f, -0.00969897f, 0.03061494f, 0.01288869f, 0.18021342f, -0.18665075f, -0.08987924f, 0.00246863f, 
    0.01234916f, 0.03047505f, 0.04633109f, -0.07132747f, 0.22895600f, -0.41431066f, -0.10647228f, 0.13265750f, 
    0.08257894f, 0.05543001f, 0.00489172f, 0.04028901f, 0.04488001f, -0.00386118f, -0.03750074f, 0.06942956f, 
    -0.07684641f, -0.03057281f, 0.20679699f, -0.12120561f, -0.03398359f, 0.05714597f, -0.05373646f, -0.02689926f, 
    0.32976669f, 0.13467585f, -0.11748803f, -0.00666395f, -0.03612902f, -0.14899638f, 0.02058387f, 0.11564495f, 
    -0.05118646f, -0.15544564f, -0.17414130f, -0.05744484f, 0.11186472f, 0.06108575f, 0.02465892f, -0.13195562f, 
    -0.03690099f, 0.03667305f, -0.06774524f, 0.02194271f, 0.07165784f, -0.28103530f, 0.25192702f, 0.27476329f, 
    0.26178250f, 0.14254479f, -0.02843873f, 0.01921329f, 0.07575808f, 0.04928547f, 0.12175676f, 0.08338170f, 
    -0.06942565f, -0.00688863f, 0.05263003f, -0.03332910f, -0.05406232f, 0.18419392f, -0.04438024f, -0.02911161f, 
    0.15152235f, -0.15439649f, -0.24445581f, 0.13875143f, 0.08054448f, 0.06522959f, -0.00686360f, 0.08338905f, 
    0.01351889f, 0.07966305f, 0.23336089f, 0.03121074f, 0.04710867f, 0.00228223f, -0.03945486f, 0.18525597f, 
    -0.12150139f, 0.03154954f, -0.00918007f, 0.15157680f, 0.42549098f, 0.03874046f, -0.17375831f, 0.30523038f, 
    0.09977588f, 0.07272182f, -0.07625209f, 0.03674747f, -0.03645045f, 0.03072948f, -0.16394940f, -0.09079476f, 
    -0.05382976f, 0.08681611f, -0.08629021f, 0.03094503f, 0.09951767f, 0.00117087f, -0.08423832f, -0.00045754f, 
    -0.16897504f, -0.23329258f, 0.02567612f, 0.22691907f, -0.06624593f, 0.16117640f, -0.14044118f, -0.13338947f, 
    0.11746814f, 0.01185846f, 0.05023519f, 0.02163000f, 0.10928813f, 0.06269877f, -0.12776613f, -0.11605881f, 
    -0.03969745f, -0.11698020f, -0.10292190f, -0.02159373f, -0.05023967f, 0.02781368f, 0.17126937f, -0.06708947f, 
    0.31736520f, -0.12559044f, 0.09214787f, 0.08684005f, 0.04251254f, 0.05486493f, -0.03761682f, -0.00075240f, 
    0.08711032f, 0.08729811f, -0.08756686f, -0.04487427f, -0.13650306f, -0.10879607f, -0.22194380f, 0.06626142f, 
    0.14371945f, 0.26781517f, 0.01970105f, 0.05128802f, 0.11023486f, -0.03681483f, 0.01763462f, 0.13501047f, 
    0.07930243f, 0.04567954f, -0.09396710f, 0.09952179f, 0.02880316f, -0.08742595f, 0.01868204f, 0.10416495f, 
    0.01794815f, -0.13813578f, -0.04155457f, -0.16555957f, 0.15435228f, 0.15006576f, -0.13800186f, -0.23123737f, 
    0.04865210f, 0.02101876f, 0.18364388f, 0.09381259f, 0.03348300f, -0.04589902f, 0.02787575f, 0.04212190f, 
    0.08324175f, 0.11923447f, 0.05923961f, 0.10306831f, -0.03242980f, -0.02176089f, -0.01798150f, -0.00039571f, 
    0.29859859f, -0.37442979f, -0.09564291f, -0.23484735f, -0.10104954f, -0.18888113f, -0.06039218f, -0.03168148f, 
    0.02744385f, 0.19899726f, -0.09700216f, -0.13796730f, -0.08806082f, 0.15528779f, 0.00494313f, 0.06942009f, 
    0.03988098f, 0.02442794f, 0.08370552f, 0.11655812f, 0.00916594f, 0.17448533f, -0.21739075f, -0.02808610f, 
    0.12636329f, -0.01096479f, -0.04752091f, 0.07439201f, -0.03142837f, -0.04068372f, 0.11110947f, 0.02090771f, 
    -0.01385546f, -0.06876263f, -0.21810962f, 0.03027034f, 0.12339332f, -0.03526654f, -0.00304596f, 0.05989518f, 
    0.39248037f, -0.14189906f, 0.05154366f, -0.12855962f, -0.05424565f, -0.17044701f, -0.02424227f, 0.06718603f, 
    0.10959230f, -0.07809077f, -0.05149895f, 0.06592949f, 0.01286959f, -0.01238071f, -0.03462365f, 0.07705402f, 
    -0.10881305f, 0.01915056f, -0.07737674f, -0.05575590f, 0.01219267f, -0.01551344f, -0.17216659f, -0.12302905f, 
    -0.27375180f, 0.02201190f, 0.03627415f, 0.11295294f, 0.15568870f, -0.08002219f, 0.09071033f, 0.03358801f, 
    -0.05895514f, -0.11629096f, -0.03011649f, 0.15555270f, -0.05346996f, 0.05147586f, 0.19629070f, -0.11541938f, 
    0.44967756f, -0.13215934f, 0.12937778f, -0.31756023f, -0.18292789f, -0.11693441f, -0.10430652f, -0.05061817f, 
    0.07974645f, -0.16848169f, -0.03191327f, 0.09443749f, -0.03193341f, 0.11316065f, -0.03410704f, 0.17250378f, 
    -0.03583714f, -0.04646252f, -0.08434830f, 0.17212982f, 0.35809240f, 0.24499094f, 0.10281771f, 0.29679987f, 
    0.01482699f, -0.06030831f, -0.09679679f, -0.18387677f, 0.02335303f, 0.27055055f, -0.12087166f, -0.04643909f, 
    0.07955795f, 0.04801325f, 0.04683365f, 0.08010960f, 0.02316705f, 0.01069684f, -0.02627883f, -0.12378854f, 
    0.42862803f, -0.01483800f, -0.15430449f, 0.25793010f, 0.03142577f, -0.03638073f, -0.03653097f, -0.05559977f, 
    0.13934068f, 0.11765215f, 0.00991150f, -0.06824616f, -0.05743056f, 0.00352263f, 0.04138530f, -0.07776885f, 
    -0.10839427f, 0.09029648f, 0.15531324f, 0.10616077f, 0.46244240f, -0.11725886f, 0.04316081f, 0.04096556f, 
    -0.17915241f, -0.04919739f, 0.02429169f, 0.01062375f, -0.03075898f, -0.15175654f, -0.11312161f, -0.02286570f, 
    0.05402815f, -0.08736026f, 0.05665458f, -0.19740798f, -0.12364684f, 0.04449386f, -0.01189539f, -0.02585518f, 
    0.09830652f, -0.17473231f, -0.03341764f, 0.12323631f, 0.11856075f, 0.11021636f, -0.07970046f, -0.15481620f, 
    0.02613109f, 0.22489391f, -0.14711116f, -0.03756502f, -0.01473601f, 0.04237241f, -0.07156951f, 0.03478406f, 
    -0.14416672f, 0.18206954f, -0.01773815f, 0.03318501f, 0.01316461f, -0.14140771f, 0.20338163f, -0.13329256f, 
    -0.21184647f, 0.05680744f, 0.18585074f, -0.04139397f, -0.11886596f, -0.04543332f, -0.01402998f, 0.09094253f, 
    -0.05070658f, -0.07910140f, -0.07231235f, 0.00078403f, -0.13139461f, 0.06997880f, 0.09929441f, 0.04462861f, 
    -0.06746668f, -0.01064825f, 0.07086177f, 0.05353281f, 0.28525236f, -0.10449418f, 0.04114517f, 0.04718016f, 
    0.00924899f, -0.07374682f, 0.12922208f, 0.12710360f, 0.11033361f, -0.11352019f, 0.01337964f, 0.07130109f, 
    -0.01141665f, 0.09437510f, -0.06489212f, 0.09047907f, 0.00268352f, -0.03134856f, 0.14946298f, 0.05852133f, 
    -0.04510208f, 0.06080302f, -0.09921893f, -0.00355424f, -0.09143239f, -0.21123613f, -0.16294904f, -0.07097084f, 
    0.02272812f, 0.05961161f, 0.06681840f, 0.04884085f, 0.10005462f, 0.02106256f, -0.15800288f, 0.07575887f, 
    0.02178317f, 0.04419136f, 0.01980228f, 0.01828782f, -0.01127130f, 0.00355333f, -0.02058536f, 0.02947965f, 
    0.05461159f, -0.03783147f, 0.03240822f, 0.02726652f, -0.05242529f, -0.01528584f, -0.05772725f, -0.05170977f, 
    -0.03545667f, 0.00219498f, -0.04612959f, -0.04479691f, 0.01532874f, 0.03126436f, 0.01029276f, 0.02995810f, 
    -0.01688904f, -0.06178538f, -0.02845574f, 0.00535563f, 0.03992861f, 0.03838580f, -0.04493456f, 0.05449471f, 
    0.00680958f, 0.01992749f, 0.01252835f, 0.02491477f, -0.01776649f, -0.05915152f, 0.02170498f, -0.03598620f, 
    -0.03594300f, -0.00432457f, 0.03714466f, -0.05254845f, -0.04308187f, 0.03549600f, 0.04813899f, 0.00732194f, 
    -0.04121310f, -0.01737812f, -0.00265138f, 0.01469081f, -0.02882763f, -0.03962622f, -0.01264300f, 0.04300573f, 
    0.04094628f, -0.04118525f, -0.05442324f, 0.02667208f, 0.01005042f, -0.01015495f, -0.05633614f, -0.03572100f, 
    0.00840317f, -0.02192654f, -0.02041298f, -0.05582332f, -0.00109015f, -0.05760767f, -0.02063050f, 0.02528052f, 
    0.02098787f, -0.04493448f, 0.00726886f, -0.05921083f, -0.04566769f, 0.04063437f, 0.02275181f, -0.06137861f, 
    0.04625973f, -0.05756738f, -0.03650264f, -0.02756259f, 0.04774295f, -0.03453132f, 0.00383354f, 0.02203211f, 
    0.00024648f, 0.04876207f, 0.01988357f, -0.00398080f, -0.00254301f, 0.02953376f, 0.04368963f, -0.01398682f, 
    -0.01762407f, -0.04318689f, -0.04397237f, 0.00583680f, -0.03204805f, -0.03906397f, 0.02272572f, -0.06495199f, 
    -0.01874106f, -0.06152091f, 0.01241806f, 0.03844917f, 0.03815302f, -0.05644133f, 0.02155575f, 0.03879382f, 
    -0.04761149f, -0.00303163f, 0.02194602f, -0.01487296f, 0.01842240f, -0.05984051f, 0.03210825f, 0.03448247f, 
    0.03109984f, -0.05540176f, -0.02554663f, -0.00206438f, 0.00233427f, 0.02201290f, 0.01362604f, -0.00422166f, 
    -0.04901515f, 0.02498760f, -0.00796535f, 0.01205011f, 0.05238923f, 0.01005659f, 0.02633540f, 0.01838415f, 
    -0.03052614f, -0.04230785f, -0.04218080f, -0.01284573f, 0.04248164f, 0.01416746f, -0.00510695f, 0.04589016f, 
    -0.04401670f, 0.04886917f, -0.01774969f, -0.06062272f, -0.02211586f, -0.04893560f, -0.03421296f, -0.04652260f, 
    0.04946820f, -0.04499119f, -0.04715099f, 0.00332097f, 0.04802985f, -0.00321608f, -0.00541921f, -0.05189760f, 
    0.00243024f, 0.03087295f, -0.05551540f, -0.02476971f, -0.00327551f, 0.00818127f, 0.03989051f, 0.01092990f, 
    -0.05991234f, 0.02378702f, -0.00546168f, 0.03093831f, 0.00960444f, 0.05481255f, -0.03621985f, 0.03977177f, 
    0.04520186f, -0.02797869f, -0.05691044f, 0.01971541f, 0.00095789f, 0.03128408f, -0.01589761f, -0.01248393f, 
    0.03912120f, -0.05963768f, 0.02492398f, -0.04662663f, 0.04441297f, -0.02808488f, -0.01919838f, -0.05629357f, 
    0.02490531f, -0.00351141f, -0.00273588f, 0.02499370f, -0.01945640f, 0.03366418f, -0.05256983f, 0.00415024f, 
    -0.01093821f, 0.01832021f, -0.04969666f, -0.05505206f, -0.03602583f, 0.00630745f, -0.05350289f, 0.01311058f, 
    -0.01056889f, -0.00109460f, 0.03314127f, -0.00031796f, -0.02288171f, -0.01061397f, 0.01847276f, -0.00873981f, 
    -0.00936107f, 0.03309019f, 0.02547808f, -0.00715007f, -0.06659339f, 0.03854755f, 0.02374948f, -0.05767153f, 
    0.03183232f, 0.04444245f, 0.02256439f, 0.01346775f, 0.03933865f, -0.01568990f, 0.02745170f, -0.03707094f, 
    -0.00406288f, -0.03906806f, -0.04799553f, -0.00827326f, 0.00660437f, 0.02716975f, 0.04622579f, 0.03421514f, 
    -0.04316115f, -0.05242725f, 0.04363428f, 0.00632866f, -0.02000331f, 0.03086530f, -0.04603274f, -0.03904068f, 
    -0.05200224f, 0.01184965f, 0.01985383f, -0.05353303f, -0.03833522f, -0.02952640f, -0.05701079f, 0.02407533f, 
    0.02889391f, 0.00239191f, 0.00022187f, -0.02712226f, 0.00369286f, 0.02084686f, -0.00619908f, -0.01141495f, 
    -0.03342062f, -0.00811290f, 0.02724260f, 0.02810083f, -0.03221784f, -0.01799072f, -0.00171172f, -0.05205256f, 
    -0.00947256f, -0.05583020f, -0.02458015f, -0.04685308f, 0.04423203f, -0.01934636f, 0.01825948f, 0.02080127f, 
    -0.05148343f, -0.02020948f, 0.02378702f, 0.02739277f, -0.03869879f, 0.00447788f, -0.02310617f, -0.02075226f, 
    0.03353794f, -0.04946050f, -0.04557418f, 0.02081108f, -0.00176302f, 0.00620440f, 0.03339788f, -0.01967042f, 
    0.05369476f, 0.03332489f, -0.06007838f, 0.00827149f, -0.02813509f, 0.00133809f, -0.00465725f, 0.00865783f, 
    0.02348607f, -0.00458074f, 0.03710598f, 0.01820327f, 0.00528425f, -0.00889612f, 0.00315897f, -0.01395853f, 
    0.00733249f, 0.04725141f, -0.04086708f, -0.04992570f, -0.00562616f, 0.02722412f, -0.04561916f, -0.01245614f, 
    0.21825027f, 0.01013237f, 0.02832443f, 0.09682177f, 0.09788907f, 0.09479006f, 0.12476557f, -0.15592234f, 
    -0.01010674f, 0.05653481f, 0.09371030f, 0.15552987f, 0.01222325f, -0.04305857f, -0.05661827f, 0.02354286f, 
    0.00478656f, -0.06454208f, 0.05448907f, -0.03188718f, 0.17904383f, 0.16248970f, 0.11783018f, 0.20385978f, 
    0.21136558f, -0.08502702f, 0.03523133f, 0.04147216f, -0.01340570f, 0.03400616f, 0.09690998f, 0.07747144f, 
    0.00824936f, -0.06529860f, -0.03210909f, 0.12445790f, 0.06601422f, 0.08859923f, -0.07075100f, 0.00495665f, 
    -0.08278982f, 0.37653986f, 0.07997613f, 0.12828912f, 0.04016691f, 0.05869792f, 0.07548527f, 0.08113726f, 
    -0.02999955f, 0.03101547f, -0.00825129f, 0.07616173f, 0.07589613f, 0.00889798f, -0.03726862f, 0.06098491f, 
    0.05120716f, 0.09112829f, 0.03182206f, 0.01974404f, -0.34536797f, 0.02850346f, 0.08824009f, 0.00660390f, 
    0.07461447f, 0.05954611f, 0.07521191f, 0.20334807f, -0.03168846f, 0.01273964f, 0.09746072f, 0.14245240f, 
    0.09122387f, -0.01784356f, -0.05066912f, 0.05226508f, 0.10099694f, -0.00241466f, 0.04602293f, -0.02447819f, 
    -0.16183586f, 0.09594235f, -0.44302988f, -0.07544011f, -0.10467721f, 0.17793770f, -0.09274997f, -0.10882886f, 
    -0.04185478f, 0.09435844f, -0.04603123f, -0.01451898f, -0.04313283f, -0.00711076f, -0.07737891f, 0.13920608f, 
    0.15632337f, 0.00497123f, 0.11632167f, -0.02788560f, 0.23176095f, 0.01188069f, 0.25390124f, 0.33362445f, 
    0.08831087f, -0.04631396f, -0.11753282f, 0.02837262f, 0.03619937f, 0.15388235f, 0.11074486f, -0.05289242f, 
    0.15728284f, 0.04653343f, 0.07525733f, -0.00648009f, 0.13719529f, 0.03696537f, 0.08061048f, 0.06787632f, 
    0.58993804f, -0.01543108f, 0.34890172f, 0.10742555f, -0.11004149f, 0.01179333f, -0.01869277f, -0.02753494f, 
    -0.02192777f, 0.11582491f, 0.04761247f, 0.05759303f, -0.10740493f, 0.06415363f, -0.02256127f, 0.09590859f, 
    -0.04025632f, 0.04104620f, 0.01431446f, -0.05394334f, -0.37508613f, -0.16993655f, -0.02529081f, -0.03703009f, 
    -0.23485412f, 0.03164465f, -0.00136986f, 0.16924436f, 0.19806117f, 0.14230120f, -0.03333605f, 0.01852334f, 
    0.23255555f, 0.10918053f, 0.15405789f, 0.04338596f, 0.03457829f, 0.13486940f, 0.04676383f, 0.13186377f, 
    0.48285866f, 0.19988255f, 0.16787064f, -0.08643320f, -0.11918181f, 0.12921467f, -0.06508259f, -0.05546473f, 
    -0.05404169f, -0.03029084f, 0.01442892f, 0.01309914f, -0.05864942f, -0.00412341f, 0.08971853f, -0.07018552f, 
    -0.04073441f, -0.02500006f, -0.07167913f, 0.05218162f, -0.46279693f, 0.06037199f, -0.30054554f, -0.00928881f, 
    0.10146844f, 0.14880675f, 0.09327244f, 0.10477579f, 0.15583627f, 0.06689122f, -0.05822121f, -0.03739712f, 
    0.02863329f, 0.01518394f, -0.02024986f, 0.07839411f, 0.08361825f, 0.01463742f, 0.02229973f, -0.00643118f, 
    -0.41757357f, 0.04311124f, -0.32715505f, 0.13586804f, 0.09374224f, 0.23575971f, 0.12356173f, -0.01552687f, 
    0.16372195f, 0.11575980f, 0.09439715f, 0.03679284f, 0.03311981f, -0.03299370f, 0.02503148f, 0.13585116f, 
    0.00635410f, -0.02197036f, -0.04993501f, 0.02597765f, 0.57588291f, -0.04922174f, 0.08602999f, 0.12660445f, 
    -0.03040685f, -0.14128925f, -0.00756476f, 0.08999281f, -0.10347359f, 0.01182355f, 0.05401259f, 0.06728107f, 
    -0.05920152f, 0.00763930f, 0.05303214f, -0.12891130f, -0.07676258f, -0.24274291f, -0.05733797f, 0.10238362f, 
    -0.60254031f, -0.19105680f, -0.22783501f, -0.10396563f, -0.02129660f, 0.16236950f, 0.14229336f, -0.07530813f, 
    -0.07468820f, 0.17119077f, -0.10099338f, 0.12230940f, 0.02593482f, -0.02813993f, -0.05274674f, 0.08118940f, 
    0.04338214f, -0.01280413f, -0.07079671f, -0.03315694f, -0.21001241f, -0.30141091f, 0.13856898f, 0.26322761f, 
    -0.22622092f, -0.06271552f, -0.07473387f, 0.05035335f, -0.08307312f, -0.03065253f, -0.03972008f, 0.02625495f, 
    0.03832622f, 0.21831354f, 0.29444161f, -0.10698739f, -0.01153826f, -0.01098480f, -0.08708077f, 0.12519234f, 
    0.32077777f, 0.19562647f, 0.41002506f, 0.22650938f, 0.15548143f, -0.18007100f, 0.04836782f, 0.11215962f, 
    0.09643958f, 0.11873908f, -0.00928640f, 0.00153841f, 0.04257083f, 0.04836113f, 0.17065802f, -0.01902321f, 
    -0.06510317f, 0.06852773f, 0.02038992f, -0.01824708f, -0.28706822f, -0.04276216f, -0.08177181f, -0.35641277f, 
    -0.13554040f, 0.00708079f, -0.05080402f, 0.07323834f, 0.22511202f, 0.01274272f, -0.01016964f, 0.02173223f, 
    0.12088119f, 0.00365157f, 0.06251577f, -0.06173363f, 0.01629826f, 0.02724013f, -0.03149947f, 0.11833260f, 
    0.35297686f, -0.04583336f, 0.20754476f, -0.20393135f, -0.06586526f, -0.05259496f, 0.16118202f, 0.00444051f, 
    -0.08027856f, -0.03967554f, 0.10803758f, -0.04591060f, -0.08044006f, -0.01336365f, -0.00473957f, 0.00728550f, 
    0.05802665f, 0.01183182f, 0.23670538f, 0.01123354f, 0.58039176f, 0.22529627f, -0.03618852f, 0.14834516f, 
    0.11337738f, -0.14633919f, 0.05523072f, 0.08472607f, -0.05817438f, 0.01663986f, 0.09691540f, 0.01563795f, 
    0.00400798f, 0.00879793f, -0.00098675f, 0.01248865f, -0.03663956f, 0.12799655f, 0.04532822f, -0.09462037f, 
    -0.11634865f, 0.14181283f, 0.20004784f, 0.06883974f, 0.19571391f, -0.12867032f, 0.03812766f, -0.01680693f, 
    -0.06471713f, -0.04451622f, 0.00136272f, -0.02155701f, 0.02299857f, -0.11368486f, -0.09810050f, -0.03479489f, 
    -0.09614442f, 0.19276114f, -0.00681144f, 0.10788129f, -0.48990366f, 0.21114156f, 0.15289988f, 0.05622884f, 
    0.09706774f, -0.10076952f, -0.03062404f, -0.06861687f, -0.09857450f, 0.15688159f, -0.00205809f, 0.00263904f, 
    0.01043011f, -0.06899756f, -0.07074732f, 0.01042284f, 0.03674517f, 0.04572058f, 0.06376075f, -0.00883029f, 
    -0.30055952f, 0.12489608f, 0.24634631f, 0.16354720f, -0.07303625f, -0.04437224f, 0.19349541f, 0.10266349f, 
    0.02227080f, -0.08557510f, -0.04114635f, 0.03662957f, -0.02355748f, -0.06940171f, 0.09266308f, -0.04827413f, 
    -0.04970162f, 0.03447358f, 0.01809273f, 0.04688185f, 0.44372717f, 0.10529578f, -0.31744674f, 0.12823533f, 
    0.35033950f, -0.12126661f, -0.07691398f, 0.04207405f, -0.00669664f, 0.04576248f, 0.04106911f, -0.03366907f, 
    0.05798643f, -0.01036168f, 0.06466503f, 0.01771264f, -0.01562289f, -0.00671059f, 0.02990792f, -0.08164911f, 
    0.26298526f, 0.19446126f, -0.16812721f, 0.06402982f, 0.13671501f, 0.02443421f, 0.07920513f, -0.16069575f, 
    0.05413789f, -0.06603201f, -0.01700242f, 0.05236322f, 0.01615712f, 0.05356440f, -0.01443015f, -0.11445181f, 
    -0.10051259f, -0.00539600f, 0.03025781f, 0.03954232f, -0.27995309f, 0.19272898f, -0.04207074f, -0.21272163f, 
    0.13486713f, 0.04821249f, -0.09851886f, -0.08833211f, 0.15218185f, -0.02928456f, 0.04077147f, -0.08024430f, 
    -0.02303513f, 0.07931060f, -0.06193580f, -0.02275513f, 0.07340322f, -0.03471039f, -0.06425248f, -0.11429278f, 
    0.51547641f, -0.17035162f, 0.13129507f, -0.02827617f, 0.30951729f, -0.14855050f, -0.15625168f, 0.04541264f, 
    -0.08199762f, 0.10982736f, 0.01936878f, -0.07568857f, -0.17013794f, 0.02833550f, -0.05323167f, -0.04424293f, 
    0.02416749f, -0.12276325f, 0.07103060f, 0.02352221f, -0.29073495f, 0.22880161f, 0.24210726f, -0.08508414f, 
    0.06987169f, 0.05148088f, 0.22266769f, 0.19307727f, -0.05585701f, -0.15662552f, 0.09173200f, -0.00686356f, 
    -0.00061838f, 0.01040920f, -0.06988526f, 0.03759008f, -0.02826581f, 0.05847661f, -0.02010605f, 0.04957593f, 
    -0.16741440f, 0.37234488f, 0.31656897f, -0.16087709f, 0.08313651f, 0.16938895f, 0.14399999f, 0.16430214f, 
    -0.10926800f, -0.03741238f, 0.07788917f, -0.00482178f, -0.07339891f, -0.01317745f, -0.03761148f, 0.15265456f, 
    0.06575523f, 0.02040964f, -0.07467865f, -0.03544432f, 0.46993080f, 0.24237961f, 0.04973724f, 0.10009878f, 
    0.00911711f, 0.09431098f, -0.06556086f, 0.15983993f, 0.02042831f, 0.28001350f, 0.00454858f, 0.16851620f, 
    -0.00812185f, 0.02937956f, -0.01291982f, 0.10993956f, -0.12007917f, -0.09278665f, -0.01883360f, 0.16763891f, 
    -0.01113105f, -0.03966379f, 0.12228934f, -0.18420556f, -0.05745095f, -0.08453787f, 0.11198295f, 0.16387396f, 
    -0.04858460f, -0.04936260f, -0.00410084f, -0.07829194f, 0.02798939f, 0.02508630f, 0.11335830f, 0.00533580f, 
    0.13363151f, -0.08495163f, -0.05265505f, -0.11451174f, -0.19673914f, -0.00092839f, -0.13500491f, 0.09285051f, 
    0.33414757f, -0.09508950f, -0.25925228f, -0.01082423f, 0.04376834f, -0.07648147f, -0.00064275f, 0.09346476f, 
    0.11263866f, 0.16470477f, 0.09122719f, 0.12602593f, -0.02857809f, 0.02114744f, -0.07226121f, 0.03361692f, 
    0.42102036f, 0.24701652f, -0.32867953f, 0.11520445f, 0.20033634f, 0.00270157f, -0.17853856f, 0.00104637f, 
    0.06704111f, -0.00362022f, -0.02049020f, -0.07760129f, 0.06624473f, 0.11911902f, 0.04640922f, 0.02816930f, 
    -0.01020183f, 0.06070737f, 0.16596866f, 0.02061493f, 0.06468016f, -0.07581822f, -0.05768608f, -0.02269129f, 
    -0.04190246f, -0.05592989f, -0.11376627f, -0.07070678f, 0.00938273f, 0.07294137f, 0.11310446f, 0.03566275f, 
    0.12075911f, 0.01921446f, -0.10643621f, -0.03126045f, -0.05592385f, -0.11116647f, 0.03592759f, -0.24629825f, 
    0.04330984f, 0.36627659f, 0.18646841f, -0.04906231f, -0.12192701f, 0.02463142f, -0.05717522f, 0.15850596f, 
    0.00178454f, -0.09364483f, 0.07505517f, -0.01306705f, 0.03797558f, -0.07738065f, 0.08376644f, 0.06274832f, 
    0.03030905f, 0.13076636f, -0.03130902f, 0.11428205f, -0.17670074f, -0.06799763f, 0.16060252f, -0.03310742f, 
    -0.01851098f, -0.02524027f, -0.04225935f, -0.07342653f, -0.06206774f, 0.02185556f, 0.06055992f, -0.00516726f, 
    0.07133009f, -0.02456846f, 0.07078905f, -0.03850088f, -0.00789300f, -0.01578284f, 0.07645497f, 0.27546415f, 
    -0.11337958f, -0.03524353f, 0.12256426f, -0.10615005f, -0.14247671f, 0.04276362f, -0.05951028f, -0.04378955f, 
    -0.04842646f, -0.33339885f, -0.00441626f, 0.01289832f, 0.04245770f, 0.09535819f, -0.17495763f, 0.00187073f, 
    0.03792251f, 0.03494020f, 0.12795588f, 0.09054321f, 0.10029586f, -0.13508561f, 0.10387854f, -0.16833363f, 
    -0.24024671f, 0.09762487f, -0.15945606f, -0.02804684f, 0.11337602f, -0.19693866f, 0.04938225f, -0.04836968f, 
    0.02278537f, 0.07190344f, -0.12200446f, 0.03408362f, 0.04063515f, -0.07901830f, 0.13549617f, 0.01148323f, 
    0.09719654f, 0.22500946f, 0.20434172f, 0.07294096f, 0.33810428f, 0.14314312f, 0.00100453f, 0.17869118f, 
    0.03299879f, 0.13631603f, 0.03443906f, -0.06952514f, 0.03259312f, 0.10477304f, 0.00531771f, -0.09274519f, 
    0.16970056f, 0.06145158f, 0.13247363f, 0.01833886f, -0.18412487f, -0.46019223f, -0.18479584f, -0.17361015f, 
    -0.16910623f, -0.07487879f, 0.02734411f, -0.01472335f, 0.10231965f, 0.09165063f, -0.10767981f, -0.01650303f, 
    0.05745598f, -0.00498448f, 0.01567288f, -0.13226017f, 0.04050924f, 0.01667443f, -0.00134643f, 0.00087160f, 
    0.21938789f, -0.41800028f, 0.08469476f, -0.18403271f, -0.12242654f, -0.08839112f, -0.12528767f, -0.06287569f, 
    -0.06010932f, 0.13793728f, -0.06685941f, -0.04083704f, 0.03176537f, -0.07598790f, 0.05037872f, 0.12738065f, 
    0.03768343f, 0.06908505f, -0.04553843f, -0.02415750f, 0.28398493f, 0.10539607f, 0.37496957f, 0.08654903f, 
    0.14412300f, -0.02614310f, 0.05535797f, -0.08262163f, -0.07904000f, -0.06575690f, -0.00657456f, 0.01214777f, 
    -0.02264609f, 0.07058872f, 0.02528492f, 0.03360838f, -0.00176926f, -0.01288990f, -0.01617105f, -0.07932659f, 
    -0.10099506f, 0.38217977f, -0.20415887f, 0.31713048f, -0.12505147f, -0.01388707f, -0.10092775f, -0.02757350f, 
    0.06936876f, -0.02801723f, -0.05898546f, 0.01168156f, 0.07031767f, 0.05190915f, 0.08448473f, 0.06586613f, 
    -0.08474492f, 0.02527088f, 0.01981026f, -0.11775967f, 0.42358229f, -0.06530390f, 0.21903364f, 0.30771199f, 
    -0.12867308f, -0.02395149f, 0.16350436f, 0.01900656f, -0.03108348f, 0.09775392f, 0.03152567f, 0.12355416f, 
    -0.13100632f, 0.01169851f, 0.10727165f, 0.02084032f, 0.02125135f, 0.16730410f, 0.15209132f, -0.01399240f, 
    0.19667986f, 0.01722515f, 0.16676156f, 0.12898660f, 0.06538044f, -0.08943640f, 0.10345586f, -0.00346623f, 
    0.08452117f, 0.17608470f, 0.03023659f, 0.09301507f, -0.01286781f, 0.07966080f, 0.03301854f, -0.04527880f, 
    -0.00901603f, 0.08281382f, 0.04677029f, -0.15793508f, -0.03229667f, -0.09992698f, 0.16372341f, -0.11692578f, 
    -0.12958883f, -0.20658994f, -0.10655617f, -0.01432014f, 0.09861053f, -0.00996323f, 0.04914815f, 0.03229485f, 
    -0.04536650f, 0.00488405f, 0.07881264f, -0.03906391f, 0.06339294f, 0.07375114f, 0.12254823f, 0.04490732f, 
    -0.43582180f, 0.27022216f, 0.17159449f, 0.21645570f, 0.13736363f, 0.16040656f, -0.11533044f, 0.10987543f, 
    0.04937815f, 0.06663852f, -0.01585082f, -0.02949141f, 0.09772011f, 0.09269568f, -0.20725806f, 0.05109864f, 
    -0.03271845f, 0.04257809f, 0.16051635f, 0.02711268f, 0.11985946f, 0.05444368f, -0.07235089f, 0.06087172f, 
    -0.09596824f, -0.03560816f, 0.14416660f, -0.07686721f, 0.04431310f, 0.02048175f, -0.13165128f, 0.00069762f, 
    -0.09540784f, -0.12678407f, -0.07079201f, -0.00206065f, -0.14808516f, -0.05052941f, 0.00468551f, -0.01371968f, 
    -0.22600751f, -0.32163990f, -0.11891469f, -0.17866109f, -0.02351321f, 0.02053958f, 0.01736280f, -0.09018211f, 
    -0.04218366f, -0.00581159f, -0.20309895f, 0.03374540f, -0.17753114f, -0.10370032f, -0.01021696f, -0.04703814f, 
    0.04477144f, -0.09483243f, 0.04769004f, -0.05964076f, 0.06451514f, 0.50288105f, 0.11130629f, 0.00540273f, 
    0.20643635f, -0.01484944f, -0.01618396f, -0.01544819f, 0.02221954f, 0.10052919f, -0.09443080f, -0.07289153f, 
    0.05179772f, 0.02829691f, -0.01708388f, 0.21489477f, -0.02863292f, 0.03116194f, -0.11073306f, -0.11847141f, 
    -0.05168812f, -0.02344548f, -0.00026301f, -0.02831733f, 0.00545976f, 0.01708547f, -0.00279010f, 0.00513009f, 
    -0.03354709f, -0.01348711f, -0.03448543f, 0.04819461f, 0.00818065f, -0.00668840f, -0.01436757f, 0.00904895f, 
    0.04595785f, -0.02647205f, -0.02893817f, -0.01552562f, -0.00892172f, -0.02988863f, 0.00525315f, -0.00578728f, 
    0.00679279f, -0.00352071f, -0.05039597f, 0.00942552f, -0.02961210f, 0.04303322f, 0.03613580f, -0.00269038f, 
    -0.01091822f, -0.01088315f, -0.04624249f, 0.03264620f, -0.03436793f, -0.02651152f, 0.00356169f, -0.02424297f, 
    0.01029506f, -0.05093807f, -0.00093157f, -0.05348825f, -0.06163644f, -0.00505605f, -0.04455578f, 0.02857337f, 
    0.00157803f, 0.04548172f, 0.01008578f, 0.03361157f, -0.06150324f, 0.00845107f, 0.01398190f, -0.05201909f, 
    0.03961804f, 0.00512526f, -0.00169399f, -0.06064438f, 0.03603891f, -0.04271653f, 0.02213877f, -0.03095426f, 
    0.04003717f, 0.01945239f, 0.02714492f, 0.01081354f, -0.05520534f, -0.01040474f, 0.03154065f, 0.03899557f, 
    -0.04423951f, -0.00499329f, 0.01294617f, -0.02983165f, 0.02294624f, -0.00979414f, 0.01142291f, 0.04001270f, 
    -0.00177039f, 0.03513255f, -0.01602108f, -0.04173123f, -0.03857763f, -0.02754765f, -0.03912074f, 0.01930114f, 
    0.00409824f, -0.01832504f, -0.00455431f, 0.03949082f, 0.01990959f, 0.03087517f, 0.01036038f, 0.00672648f, 
    0.00169296f, -0.01184086f, -0.00777929f, -0.02088761f, -0.01473783f, 0.00709837f, 0.02312162f, -0.02747411f, 
    -0.02161734f, -0.01330987f, -0.05947535f, -0.03297911f, 0.03926910f, -0.00740835f, -0.02269096f, 0.01925583f, 
    0.01256158f, 0.01546903f, 0.00876152f, 0.03283507f, -0.02411792f, -0.05853595f, 0.00668579f, -0.04623033f, 
    -0.04398193f, 0.01848070f, -0.02096158f, -0.05328009f, -0.00093255f, 0.01805141f, -0.03669662f, -0.03355367f, 
    -0.04479820f, 0.04148511f, -0.02897003f, 0.03950794f, 0.00896890f, 0.03394785f, 0.04299968f, -0.00359586f, 
    0.00052953f, 0.04837174f, -0.04644367f, 0.01809703f, -0.02078961f, 0.00131506f, -0.05211935f, 0.01874248f, 
    -0.00626083f, 0.02600614f, -0.03458898f, 0.03268863f, -0.01915943f, 0.02507901f, 0.01372271f, 0.03302039f, 
    0.04529627f, 0.04679174f, -0.05715160f, -0.03434339f, 0.00628062f, -0.03673455f, -0.03555499f, -0.00130416f, 
    0.00304451f, -0.03976019f, -0.03402391f, -0.02722170f, -0.02656698f, -0.00807547f, -0.01502634f, -0.03169300f, 
    0.03177575f, -0.03429992f, -0.01447958f, -0.02862221f, 0.03603627f, -0.05160582f, -0.03536014f, 0.00634730f, 
    -0.01750493f, -0.04816740f, 0.03378464f, -0.00987872f, -0.00842634f, 0.05303446f, 0.02296473f, -0.03212686f, 
    -0.04741037f, 0.02028910f, -0.05575111f, -0.05078785f, -0.01994434f, 0.04860910f, -0.04444056f, 0.02669163f, 
    0.02952735f, 0.00753981f, 0.03253408f, -0.01211831f, -0.01284755f, 0.02290067f, 0.03751263f, -0.04137325f, 
    -0.05543923f, 0.02289515f, -0.00257000f, -0.02021460f, -0.03502994f, -0.03848813f, 0.00451601f, -0.02364153f, 
    -0.01332854f, -0.04675278f, 0.01345533f, -0.03009119f, -0.03360589f, 0.03258576f, -0.05305569f, -0.01338806f, 
    -0.03777779f, -0.01493049f, 0.04717387f, 0.01606435f, -0.01711087f, -0.01529277f, -0.00966740f, 0.04684957f, 
    0.01665349f, -0.04641547f, -0.02815311f, 0.01324830f, 0.00921779f, -0.03437810f, 0.04603571f, 0.02736454f, 
    0.03422338f, 0.00216892f, 0.04238157f, -0.05585447f, -0.02698511f, -0.05260745f, -0.02425495f, 0.02112986f, 
    0.01236044f, 0.02730794f, -0.00781352f, 0.02428931f, 0.04101905f, 0.01589101f, -0.04406622f, -0.04446252f, 
    -0.05087367f, -0.00619549f, -0.01492819f, -0.05156967f, -0.03769300f, 0.01517865f, -0.04876407f, 0.03372142f, 
    0.04472589f, -0.00908178f, 0.00613827f, 0.02261133f, -0.04867121f, -0.02664734f, -0.04082247f, -0.03029560f, 
    0.02621584f, -0.05439118f, -0.02107274f, 0.03451222f, -0.00914140f, -0.00790979f, -0.00431317f, -0.01917041f, 
    -0.00073797f, -0.03032364f, -0.01123375f, -0.04746152f, -0.00583243f, 0.03932877f, 0.04809107f, 0.00769104f, 
    -0.04857655f, -0.00703892f, 0.04642695f, -0.04253784f, 0.01002931f, 0.01005865f, 0.03148878f, -0.03463631f, 
    -0.03600002f, 0.02469371f, -0.05580892f, -0.04137914f, 0.00140628f, 0.01463049f, -0.01690857f, 0.04144337f, 
    -0.00374541f, -0.02310183f, 0.01536420f, 0.01070369f, 0.03347668f, 0.00979184f, 0.01052222f, -0.04705767f, 
    0.02573998f, 0.02323734f, 0.01010271f, -0.01393821f, 0.00077015f, 0.04782990f, -0.05167282f, -0.02614230f, 
    -0.03318207f, -0.00107745f, 0.03771621f, -0.00089067f, -0.02902853f, -0.00530584f, -0.04357145f, 0.01685678f, 
    0.07640695f, 0.03896255f, -0.23384924f, -0.16530380f, -0.21722150f, 0.25715628f, -0.01416538f, 0.21528700f, 
    -0.04884104f, 0.09789803f, 0.10327502f, 0.06813529f, 0.03746169f, 0.04328610f, 0.14844179f, 0.05146687f, 
    0.07168487f, 0.06898638f, -0.36928397f, -0.02547865f, -0.07160566f, -0.00428406f, 0.17337884f, -0.34779111f, 
    0.08635440f, -0.06005026f, 0.12339790f, 0.08708434f, -0.20577383f, 0.06381351f, 0.08976484f, 0.09595197f, 
    0.14070652f, -0.09660480f, 0.06593197f, 0.09410124f, 0.01550312f, -0.26916814f, -0.14878808f, -0.09504513f, 
    -0.04441119f, -0.00211497f, -0.20861675f, -0.01919316f, 0.01983917f, 0.08564560f, -0.02987125f, -0.01327468f, 
    -0.02525983f, -0.10281071f, 0.03907115f, -0.05812680f, -0.04392562f, 0.20291521f, -0.00264546f, 0.04736900f, 
    0.19363345f, -0.40553033f, -0.25672486f, -0.04469021f, 0.08259438f, -0.07225339f, 0.02924713f, -0.13558820f, 
    -0.22610247f, 0.23695903f, 0.00266364f, 0.11084791f, 0.06737781f, -0.07759685f, 0.15089141f, -0.00283615f, 
    -0.13083819f, 0.14978454f, 0.00450494f, -0.00570115f, 0.12147582f, -0.15037599f, -0.14618300f, -0.08660623f, 
    -0.23632997f, 0.20972529f, 0.28145114f, -0.08847824f, 0.18019116f, -0.03181447f, 0.02449968f, 0.01534700f, 
    0.10549413f, 0.00714145f, 0.04506278f, -0.09121949f, -0.07650270f, 0.18254653f, 0.03007554f, 0.12584445f, 
    0.10174566f, 0.00997137f, 0.10467897f, 0.00265614f, 0.30238983f, -0.12710893f, -0.12443568f, 0.00266698f, 
    0.03048746f, -0.02247551f, 0.02917868f, -0.14810775f, -0.22230826f, -0.07038070f, -0.04888978f, -0.06450655f, 
    0.01482118f, -0.07252384f, 0.05260599f, -0.06743983f, 0.01604804f, -0.10703475f, -0.00169338f, -0.09783863f, 
    0.37037587f, 0.01066333f, -0.01401733f, -0.35582790f, -0.04329514f, -0.04982821f, 0.08098190f, 0.04786711f, 
    -0.12875584f, 0.26565647f, 0.04105694f, -0.06502979f, 0.05639403f, -0.15387812f, 0.21246795f, 0.13749459f, 
    0.09100480f, 0.03579009f, -0.00994221f, -0.12112807f, 0.28263551f, 0.15015419f, -0.05095681f, 0.20977333f, 
    0.10420951f, -0.06766467f, -0.01864159f, -0.07602645f, -0.05594902f, -0.07099916f, 0.01258494f, 0.20775443f, 
    0.11046359f, -0.00673981f, 0.19551694f, 0.07932419f, 0.06595609f, 0.10577781f, 0.07229937f, 0.14262812f, 
    0.15156947f, 0.32983235f, -0.27282578f, 0.15834622f, -0.07867080f, 0.08164582f, -0.01328638f, -0.02655887f, 
    -0.06905996f, -0.24907535f, 0.01331843f, 0.07394084f, -0.16653802f, 0.01151984f, 0.14010027f, -0.11779440f, 
    -0.00931590f, -0.10036562f, -0.20853908f, -0.01935956f, -0.24598928f, 0.16880724f, 0.21597975f, -0.08918269f, 
    0.03441890f, 0.12604839f, 0.02708716f, 0.05813804f, 0.10353355f, 0.11857539f, 0.01340574f, 0.02451295f, 
    0.09248183f, 0.09944696f, 0.09816756f, 0.03079400f, 0.03414176f, -0.03040127f, 0.07159767f, -0.20534228f, 
    -0.22596885f, 0.09572486f, 0.14863259f, -0.14532056f, 0.04163821f, 0.09861963f, 0.01963709f, 0.03423693f, 
    0.04843049f, 0.03206968f, 0.05729485f, -0.10716157f, 0.12164837f, 0.15416706f, -0.03734187f, -0.09834325f, 
    -0.05210849f, 0.10747616f, 0.17715602f, -0.06678006f, -0.04229290f, -0.18638460f, -0.14850366f, -0.24039122f, 
    -0.04347095f, 0.13299206f, 0.00794610f, -0.07873150f, 0.08856072f, -0.11162566f, -0.06733969f, 0.01634058f, 
    -0.05419004f, -0.18254022f, -0.11564429f, -0.19520769f, -0.12830810f, 0.04614208f, -0.08539809f, -0.10326615f, 
    -0.23465008f, 0.20822307f, 0.35699940f, 0.01763129f, -0.08985320f, -0.02718079f, -0.08371437f, 0.13657363f, 
    0.08059442f, 0.09597604f, 0.06477506f, -0.01777571f, -0.15771437f, 0.24574697f, -0.04924522f, -0.03364182f, 
    -0.05916519f, 0.13119471f, 0.13364270f, -0.03293108f, 0.10065356f, -0.24222825f, -0.24345098f, 0.09248821f, 
    0.03169158f, -0.14513499f, -0.08563641f, -0.09799910f, -0.03440261f, -0.04366445f, 0.05210792f, 0.08114298f, 
    -0.07339620f, -0.04854961f, 0.05418180f, -0.14815904f, -0.15677878f, 0.12035875f, 0.07881506f, 0.09246085f, 
    0.25567967f, -0.19306882f, 0.11607875f, 0.05652995f, 0.10873678f, -0.05854055f, 0.04046366f, -0.04954333f, 
    -0.09902043f, -0.07077304f, 0.12353262f, 0.02889887f, -0.04035782f, -0.13946094f, 0.09139132f, -0.01855057f, 
    0.06575050f, 0.01701181f, -0.01690389f, -0.06355882f, 0.21573375f, 0.16398077f, 0.12401890f, 0.15590321f, 
    -0.09617455f, -0.18990262f, 0.04330850f, -0.03654845f, 0.07862271f, -0.03940932f, -0.00595902f, 0.09809390f, 
    -0.01272521f, 0.25773376f, 0.16275035f, 0.16931032f, 0.13500586f, 0.19269936f, -0.02647803f, 0.07275750f, 
    -0.00917786f, 0.03491574f, -0.02212099f, 0.01051195f, -0.04693723f, -0.05764231f, -0.04767445f, -0.00213406f, 
    0.01046570f, -0.01121117f, -0.05793038f, 0.02800237f, 0.00554711f, -0.03644309f, 0.00346123f, 0.02371433f, 
    -0.04731275f, -0.02992887f, -0.00322328f, 0.02991592f, 0.01133973f, -0.04172553f, -0.04808655f, -0.05086174f, 
    0.00117793f, -0.03160125f, 0.01775255f, -0.03419209f, -0.05324984f, -0.04559876f, 0.04598725f, 0.00132125f, 
    -0.04412015f, 0.01688264f, 0.00107489f, -0.02356409f, 0.00312356f, -0.02686534f, 0.00448354f, 0.02984085f, 
    0.00656089f, 0.02296974f, -0.02675047f, -0.00318968f, -0.03648264f, 0.04287992f, 0.03185950f, -0.03244982f, 
    0.04942292f, 0.02585509f, -0.04382670f, -0.00392902f, 0.01469715f, 0.00367795f, -0.01145209f, -0.01682794f, 
    0.03493445f, 0.01143226f, -0.04798583f, -0.00287993f, 0.00964093f, 0.01808431f, 0.03264378f, -0.00846982f, 
    -0.05337474f, -0.01632857f, 0.02889599f, -0.00043499f, -0.03324187f, 0.01169829f, 0.02871570f, 0.05527254f, 
    -0.01119422f, -0.04222824f, 0.00416979f, 0.04239976f, -0.02234290f, -0.04475201f, -0.01854029f, -0.04239248f, 
    0.00011636f, -0.00992371f, -0.00905524f, -0.01575702f, 0.00699572f, 0.03959579f, -0.03474447f, -0.01907922f, 
    0.04013867f, 0.03139972f, 0.00024139f, 0.01185307f, -0.02618633f, 0.00687377f, -0.03669804f, -0.04849187f, 
    -0.02684163f, 0.04867295f, 0.00693751f, 0.01876314f, -0.00806402f, -0.02072201f, -0.01506115f, 0.02914015f, 
    0.00627217f, 0.03928151f, 0.01809754f, -0.04218907f, 0.00840676f, 0.04891908f, 0.00813042f, -0.05840918f, 
    -0.01394700f, -0.06102671f, 0.00968058f, -0.05192365f, -0.00048975f, 0.01608502f, 0.01622087f, 0.00880488f, 
    0.00828547f, 0.00274900f, -0.00659404f, 0.03324986f, -0.01353118f, -0.05944769f, -0.02194039f, 0.00363966f, 
    -0.05020843f, -0.05768020f, -0.00738731f, -0.01247668f, -0.02139255f, -0.05749939f, -0.02650375f, -0.05517105f, 
    0.03384366f, -0.01195593f, 0.03229501f, -0.03488772f, -0.02051840f, -0.01652196f, -0.03602566f, 0.03166436f, 
    -0.05723755f, -0.00785881f, 0.02724574f, -0.02943701f, -0.01695081f, 0.02762767f, 0.04693144f, 0.04404688f, 
    -0.02612572f, -0.06084426f, -0.04423619f, -0.05350154f, -0.02095176f, 0.02435859f, -0.05289365f, -0.01000434f, 
    -0.05009029f, 0.04777680f, 0.04864817f, 0.00438433f, -0.04023294f, -0.04454537f, 0.02783348f, 0.00989865f, 
    -0.05480670f, 0.01290766f, -0.04785345f, -0.04239585f, -0.04902946f, 0.04083520f, -0.05508399f, 0.00279090f, 
    0.03770394f, -0.00741196f, -0.04916501f, -0.05058048f, -0.04927032f, -0.05720378f, 0.04736568f, 0.03694838f, 
    0.02172332f, -0.00673709f, -0.00503024f, -0.04420221f, 0.00307981f, -0.04035560f, -0.03342324f, 0.02164898f, 
    -0.03323124f, -0.03018504f, -0.00355961f, -0.00885252f, -0.03630617f, -0.06165281f, 0.04697703f, 0.05231532f, 
    -0.00450566f, -0.01815974f, -0.05333837f, -0.02301330f, -0.02964473f, 0.03016662f, 0.02913809f, -0.05609784f, 
    -0.02404829f, -0.00534314f, -0.03813662f, -0.04732841f, -0.01866118f, -0.02282031f, 0.04863034f, -0.02593776f, 
    0.03458335f, 0.03978097f, -0.03998810f, 0.00951871f, 0.02918421f, -0.00680418f, -0.04204261f, -0.02580102f, 
    -0.04770635f, -0.03210948f, -0.00602978f, -0.00375545f, -0.02090902f, 0.01640973f, -0.00429570f, 0.04332876f, 
    -0.01651519f, 0.00832810f, -0.03755586f, 0.04249635f, 0.01192251f, -0.01196158f, 0.02905584f, -0.01474425f, 
    -0.04118415f, -0.03839957f, 0.01136518f, 0.01363348f, -0.01108734f, -0.04861263f, 0.01280324f, 0.04492388f, 
    -0.02862019f, 0.04154530f, -0.02389110f, 0.03504087f, -0.05549688f, 0.00981898f, -0.02184629f, -0.02051384f, 
    -0.03606760f, 0.04853822f, -0.03129016f, 0.03901153f, -0.01198282f, -0.05077739f, -0.00526654f, -0.02845268f, 
    0.00672233f, -0.03667164f, -0.04013306f, 0.04323232f, -0.04509507f, 0.01226348f, -0.04965568f, 0.03655597f, 
    -0.02094333f, -0.03021993f, 0.02262047f, -0.05660290f, -0.00500086f, 0.01901952f, 0.03149784f, 0.03355222f, 
    0.03148504f, -0.04886509f, -0.03173978f, -0.00728621f, -0.00940240f, -0.05099816f, 0.02042541f, -0.03707326f, 
    -0.05874851f, -0.02108351f, 0.04353032f, 0.04288565f, -0.02031584f, -0.01052007f, -0.05524449f, 0.02111642f, 
    -0.01297634f, -0.02159730f, -0.02924717f, -0.06040747f, 0.03369525f, 0.01847082f, -0.00851841f, -0.04284625f, 
    0.00280076f, -0.05815042f, 0.04850854f, -0.03618052f, -0.05591740f, -0.03149571f, -0.03781779f, -0.04281364f, 
    -0.03117826f, 0.02049955f, -0.04135181f, 0.03841043f, 0.00423519f, -0.03413904f, 0.02908278f, -0.01235679f, 
    0.05771638f, -0.12351879f, 0.23039573f, -0.07117837f, 0.19696747f, -0.08629034f, 0.00041860f, 0.10269619f, 
    0.00188469f, 0.05222407f, 0.00611452f, 0.05003999f, -0.10380387f, 0.21935080f, -0.05429506f, 0.05314402f, 
    0.04986475f, -0.11435909f, 0.03896391f, 0.07838483f, 0.57540786f, 0.06275830f, 0.05076402f, 0.02984337f, 
    -0.18310247f, 0.13172618f, -0.15131393f, -0.02546890f, 0.06301091f, -0.01631334f, -0.08484229f, -0.02146662f, 
    0.12108611f, 0.03976974f, 0.01092403f, -0.06218885f, 0.02653130f, 0.03501603f, -0.18717913f, -0.17927906f, 
    0.32140717f, -0.33917290f, 0.26605842f, 0.08045161f, -0.17726597f, -0.04078415f, 0.06085712f, 0.06759236f, 
    -0.11011754f, 0.04354116f, 0.06848623f, 0.04289487f, 0.06149446f, 0.11015952f, -0.01930960f, -0.01563031f, 
    -0.13888338f, -0.13406610f, -0.04006701f, -0.02498420f, 0.41759068f, -0.59866202f, 0.13771717f, 0.09625860f, 
    0.08144535f, -0.04958320f, -0.01040984f, -0.09616440f, -0.06625780f, 0.09573140f, -0.11073697f, -0.00224309f, 
    0.04257556f, 0.06337555f, 0.07856128f, 0.17637005f, 0.01796772f, 0.12712395f, -0.14117150f, 0.01292045f, 
    0.05908921f, -0.36131802f, 0.02960865f, 0.36969724f, -0.01811654f, 0.15703693f, 0.19818175f, 0.22291550f, 
    -0.00687629f, 0.18887363f, -0.01111548f, 0.02920535f, 0.18135786f, 0.04859429f, 0.04291707f, 0.07927068f, 
    0.05330325f, 0.06406962f, -0.04729646f, 0.02072801f, 0.42123207f, 0.15025786f, 0.14161086f, -0.27516487f, 
    -0.13570748f, 0.07370402f, 0.03728472f, -0.09022686f, 0.03317055f, -0.12755223f, -0.04716723f, 0.06337505f, 
    -0.09508903f, 0.17881659f, -0.10193746f, 0.09720010f, -0.03734916f, 0.08072954f, -0.00169897f, -0.03931818f, 
    -0.36830223f, 0.49428537f, 0.04982124f, 0.24988638f, -0.08228175f, 0.04132058f, -0.05468027f, 0.05217514f, 
    0.20523299f, -0.13477294f, 0.06594769f, 0.06422170f, 0.07907377f, 0.07949908f, -0.00824914f, 0.02822277f, 
    0.14848301f, 0.08242114f, -0.16764452f, 0.02935986f, -0.29306361f, -0.03533464f, 0.00871724f, -0.14966549f, 
    0.07876413f, -0.10010980f, -0.08942378f, -0.02848436f, -0.02670364f, 0.03937596f, -0.02711374f, -0.14022493f, 
    -0.03623878f, 0.16792770f, 0.06472762f, 0.07518037f, 0.05266330f, 0.07682136f, 0.04241063f, 0.07612650f, 
    -0.06021010f, -0.00643773f, -0.17786939f, -0.15899454f, 0.22015046f, 0.06868411f, 0.06260292f, 0.08085094f, 
    0.09616001f, 0.11470427f, -0.03627608f, 0.06574745f, 0.05173497f, -0.12150800f, 0.07256638f, 0.09268034f, 
    0.07438978f, 0.27531680f, 0.11341920f, 0.05597822f, 0.53428680f, -0.01988666f, -0.21702482f, -0.11504238f, 
    -0.13315228f, 0.03184858f, 0.00937715f, -0.05688541f, 0.08241548f, -0.06271255f, 0.11540701f, -0.04722357f, 
    0.07912204f, -0.02752896f, 0.14652580f, 0.01129083f, -0.02079833f, -0.03291989f, -0.03996121f, 0.14197361f, 
    0.16562450f, -0.09921508f, 0.03843617f, -0.10897839f, -0.00131037f, 0.04984503f, 0.11269866f, -0.02286161f, 
    0.00606601f, -0.02180965f, -0.05800873f, 0.09124489f, -0.09216885f, 0.08154080f, 0.15453880f, 0.08999829f, 
    0.02424989f, -0.05964443f, 0.04728447f, 0.12435307f, -0.28238836f, 0.38265386f, 0.16449383f, -0.00366608f, 
    -0.08053273f, 0.09141196f, 0.16870758f, -0.07391920f, 0.08018677f, -0.02727077f, -0.02193062f, 0.05429962f, 
    0.07906199f, -0.01372181f, -0.08867536f, 0.05285555f, -0.04614138f, 0.05183908f, -0.08758613f, -0.00891621f, 
    0.14754397f, -0.13514553f, 0.24409349f, 0.16777198f, 0.07250464f, 0.10703079f, 0.09656332f, -0.01916651f, 
    0.02916421f, 0.14071923f, 0.18591414f, 0.08583156f, -0.09345401f, -0.04300083f, -0.01225775f, 0.02204480f, 
    -0.04537340f, 0.05610115f, 0.03578379f, -0.00624029f, 0.07584903f, 0.32416421f, -0.30375260f, -0.47143137f, 
    -0.08368260f, 0.06646580f, 0.06324700f, 0.07945961f, 0.05969284f, 0.11744054f, -0.05699947f, 0.01479406f, 
    0.07634141f, -0.00580582f, -0.05361599f, 0.18767089f, 0.05378628f, -0.06908165f, -0.00525565f, 0.02294091f, 
    0.27402407f, 0.50774556f, 0.00508717f, -0.37036076f, -0.28388479f, 0.12118281f, 0.03710118f, -0.13394907f, 
    0.06212673f, -0.04177651f, -0.07491550f, -0.08336286f, 0.05502222f, 0.09767757f, -0.00487132f, 0.07216036f, 
    0.08435424f, 0.04555380f, -0.03253506f, -0.03877625f, -0.15067270f, -0.31064367f, 0.14462024f, -0.30926597f, 
    0.15290262f, -0.00638099f, 0.04486804f, 0.06692562f, -0.03271556f, 0.07596985f, 0.13179210f, 0.06153185f, 
    0.13888845f, -0.00118140f, 0.08833480f, 0.18359484f, 0.09615283f, 0.02569593f, 0.07859451f, -0.02119857f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04692146f, 0.11409777f, 0.06890149f, -0.04560734f, 0.06699395f, 0.04345328f, 0.01165099f, 0.00815835f, 
    -0.04239732f, 0.04889023f, 0.05267104f, 0.04793631f, -0.03834582f, -0.01479432f, 0.03199632f, 0.16830362f, 
    0.05001662f, -0.04717970f, 0.02307868f, 0.03206583f, -0.01452628f, -0.02537771f, 0.07325859f, -0.01409642f, 
    -0.02636619f, 0.07015474f, -0.03621305f, -0.13184740f, 0.00137587f, 0.00936522f, 0.04031231f, 0.08085406f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04636043f, 0.33170074f, 0.19888471f, 0.44287580f, 0.04867788f, -0.09023429f, -0.13130844f, 0.33616537f, 
    0.00109826f, 0.15637326f, 0.25623542f, -0.07860482f, -0.07739970f, 0.03191614f, 0.02397418f, -0.15959786f, 
    0.51800549f, 0.22298652f, 0.10270683f, -0.21993704f, -0.09908806f, 0.00083887f, -0.05505573f, -0.22343762f, 
    -0.15015922f, 0.17673825f, -0.04009486f, -0.09536009f, -0.15954386f, -0.27034092f, -0.02425112f, -0.21877600f, 
    0.09528462f, 0.23092175f, 0.22114526f, 0.19334744f, -0.12745804f, 0.22186953f, 0.06680238f, -0.06208616f, 
    -0.28701249f, 0.09557800f, -0.10841282f, -0.11844206f, -0.13106102f, -0.05805682f, -0.16221485f, -0.11115067f, 
    -0.05681251f, 0.39972964f, -0.00118002f, -0.44918454f, 0.02216890f, -0.10988591f, 0.31598601f, 0.40377751f, 
    0.07812703f, 0.07896954f, -0.15204731f, 0.24120644f, 0.03421506f, 0.66035461f, 0.05046586f, -0.24152216f, 
    0.16538139f, -0.09050648f, 0.07019273f, -0.14344953f, 0.08195987f, 0.03255766f, -0.07833999f, -0.12471387f, 
    0.02449587f, -0.12848441f, -0.09442984f, -0.01121296f, 0.07261061f, 0.10903653f, 0.05058463f, -0.09701659f, 
    0.04039343f, 0.02312465f, 0.11803821f, 0.04106728f, 0.11584377f, 0.03213141f, -0.06457386f, -0.12382933f, 
    0.06318748f, -0.10885692f, -0.17529470f, -0.17588779f, 0.08985212f, -0.10126193f, 0.06978521f, -0.14705527f, 
    0.13425550f, -0.32394567f, 0.22057547f, -0.08231191f, -0.16075434f, 0.30662221f, 0.14272341f, -0.19743513f, 
    -0.19346282f, -0.04613564f, 0.43990305f, -0.02680961f, 0.11329564f, -0.16017878f, 0.01184520f, -0.24850568f, 
    0.12676831f, 0.00649445f, -0.08421843f, 0.24067076f, -0.13835590f, -0.08650663f, 0.07520700f, -0.00713395f, 
    -0.01964161f, 0.20241497f, 0.10083187f, 0.49213588f, 0.11077883f, 0.22660546f, 0.05355307f, -0.00842612f, 
    -0.10299559f, 0.19732465f, 0.19857548f, -0.11150584f, -0.17016970f, -0.13691987f, -0.07665507f, -0.08796648f, 
    0.23856734f, -0.15553918f, 0.26655355f, -0.05642761f, 0.05163618f, -0.47678068f, -0.12594679f, 0.46474999f, 
    0.03117034f, 0.25068122f, -0.13346721f, -0.02251259f, 0.10271987f, 0.08703870f, -0.23476896f, 0.04426201f, 
    0.01701386f, 0.15606594f, -0.18734999f, -0.06672258f, 0.08407873f, -0.22320384f, 0.03006558f, 0.31550083f, 
    -0.09606989f, -0.36841476f, 0.32427728f, 0.05274650f, 0.33543265f, 0.07570171f, 0.13995816f, -0.10929573f, 
    0.23165382f, -0.08840308f, 0.17026334f, 0.14866515f, 0.17610522f, -0.18692265f, 0.15208557f, 0.20564374f, 
    -0.37444487f, 0.07404436f, -0.11778505f, -0.31460136f, -0.10310403f, 0.00415633f, -0.42788264f, 0.20434417f, 
    0.04294113f, 0.17184609f, -0.37550810f, -0.35690790f, -0.08731759f, 0.06966390f, 0.09806398f, 0.11216347f, 
    -0.06970441f, -0.16714494f, -0.17556843f, 0.02394308f, -0.01817767f, -0.10262240f, -0.16279344f, 0.08113817f, 
    -0.18445560f, 0.10637186f, -0.12341472f, 0.15028745f, 0.12242930f, -0.08323428f, -0.13932303f, 0.01515953f, 
    0.07817096f, 0.05769070f, 0.15308338f, -0.03032594f, -0.10143954f, 0.13412164f, 0.00352220f, -0.08491050f, 
    0.04409032f, -0.20435971f, 0.07711352f, 0.12458222f, 0.16130310f, 0.09988196f, 0.03939071f, 0.00795246f, 
    0.03887499f, -0.24609822f, 0.05204016f, -0.05750671f, 0.03215818f, -0.15360050f, 0.10843062f, -0.13729569f, 
    0.03692479f, 0.03817780f, -0.18099681f, -0.11334809f, 0.02785226f, -0.10943574f, 0.16618396f, -0.00783827f, 
    -0.04115178f, -0.12236422f, 0.02581169f, -0.12142356f, -0.08418085f, -0.05199022f, -0.21875586f, -0.04989186f, 
    -0.07889777f, 0.00138260f, -0.17207195f, 0.03038495f, -0.05090583f, -0.03174692f, -0.15289821f, 0.03225834f, 
    0.10351965f, 0.18188795f, 0.35406834f, -0.28932816f, 0.13366938f, 0.15884385f, -0.14847015f, -0.54909986f, 
    -0.52672887f, 0.14728326f, 0.33505076f, -0.07521644f, 0.13278355f, -0.05445217f, 0.12887561f, -0.07607031f, 
    0.11007417f, 0.17995168f, 0.14266340f, -0.03042396f, -0.09544937f, -0.02081388f, 0.04011814f, -0.25537503f, 
    0.00537595f, -0.10986199f, 0.06960747f, -0.00731053f, 0.00393442f, 0.54184687f, -0.04297351f, 0.27528101f, 
    0.15092149f, 0.01387992f, -0.15462957f, 0.05929888f, 0.01097338f, -0.06954671f, -0.11765001f, 0.00866799f, 
    0.09284151f, 0.14235029f, -0.02376118f, -0.14119112f, -0.03699584f, 0.10608884f, -0.05083355f, -0.13751371f, 
    -0.18537253f, -0.10955273f, 0.00002203f, 0.14789501f, -0.11473124f, 0.14962426f, -0.03981165f, -0.11227511f, 
    0.02493748f, -0.09355492f, -0.17313114f, 0.02754745f, -0.09693285f, -0.09294881f, -0.15159507f, -0.17072189f, 
    0.02473270f, -0.08614296f, -0.38396060f, -0.14037687f, 0.01009174f, 0.24751803f, 0.15493308f, 0.53883982f, 
    -0.32444513f, -0.09204075f, 0.31518969f, -0.16294996f, 0.08285359f, -0.08214891f, -0.11780709f, 0.28156963f, 
    0.18384071f, 0.13148533f, -0.14104573f, -0.42618823f, 0.06036301f, -0.06339692f, -0.37862116f, -0.25696862f, 
    -0.07638536f, 0.14820318f, -0.17346412f, -0.49069446f, -0.15596204f, -0.39346099f, 0.01828629f, 0.21650170f, 
    0.08400350f, -0.43210468f, 0.30381617f, 0.09865722f, 0.25344804f, 0.18578433f, 0.16540733f, 0.45939028f, 
    0.72319525f, -0.11649945f, -0.08620416f, -0.09600023f, 0.14905965f, 0.33174738f, -0.10389517f, -0.15310068f, 
    -0.01596800f, 0.28118351f, -0.12251229f, -0.04901574f, 0.02435631f, -0.10260992f, -0.22420843f, 0.24599813f, 
    -0.13217266f, -0.03355332f, -0.23002119f, 0.43988773f, 0.11384965f, 0.10559530f, -0.02960382f, -0.01474201f, 
    0.07488276f, -0.21517435f, -0.14910616f, 0.16847478f, -0.03807598f, 0.10153776f, 0.13997853f, -0.38779888f, 
    -0.05855488f, -0.04971678f, 0.02806412f, 0.07714103f, -0.10505225f, 0.07011569f, -0.00169610f, -0.10234423f, 
    -0.32501966f, 0.10998875f, 0.15676172f, 0.19544487f, 0.01237809f, 0.01766686f, -0.01198574f, 0.26167673f, 
    0.04622544f, 0.34804758f, 0.37904075f, 0.00684646f, 0.07715654f, 0.16357930f, -0.02562055f, 0.18041985f, 
    -0.03399250f, -0.01517115f, 0.45162910f, -0.05762819f, 0.03865838f, -0.01422253f, 0.05021272f, -0.19176881f, 
    0.61971051f, -0.08350932f, -0.11350359f, -0.01385803f, 0.02592417f, -0.35783011f, 0.04751066f, 0.32134718f, 
    0.41018373f, -0.03134552f, 0.10449560f, 0.16730051f, 0.00382204f, 0.04389776f, -0.35559526f, -0.19312473f, 
    0.03840637f, -0.07647859f, -0.33780950f, -0.21572283f, 0.10658341f, 0.26183292f, 0.10184055f, 0.27820426f, 
    0.05513732f, -0.24326403f, -0.09914835f, 0.10192313f, -0.01345897f, 0.25068042f, -0.09872419f, 0.16741778f, 
    -0.20781243f, 0.12673670f, 0.43649763f, -0.11388416f, 0.04070318f, -0.12207672f, -0.15559924f, -0.01343352f, 
    0.18124771f, -0.23537371f, -0.03169488f, -0.32907489f, 0.02859516f, 0.14746863f, 0.08351563f, -0.03469976f, 
    0.01817151f, 0.32813260f, 0.06386194f, -0.29011399f, 0.02690791f, -0.12179241f, 0.15219828f, -0.08094338f, 
    -0.16345887f, -0.22967932f, -0.13962024f, -0.13515878f, -0.19084728f, 0.13993458f, -0.03559008f, -0.22253446f, 
    0.14110601f, 0.06472202f, 0.13174625f, -0.05535664f, -0.15532894f, -0.32571873f, -0.06173337f, 0.19179681f, 
    0.20852178f, -0.30237424f, -0.07721986f, 0.57525426f, 0.02548633f, 0.13528726f, 0.03778981f, -0.31955677f, 
    0.00907488f, 0.06458064f, 0.27553785f, 0.14638992f, -0.01939863f, 0.15206291f, -0.13068312f, 0.24533108f, 
    0.00232883f, -0.08694270f, 0.31311411f, 0.19196108f, 0.41184521f, -0.04264079f, 0.07395282f, 0.12487900f, 
    -0.12190933f, -0.12174227f, 0.10979388f, -0.02208996f, -0.03512196f, -0.06315695f, -0.13202333f, 0.17436306f, 
    -0.13791360f, 0.33561081f, 0.16826476f, -0.31007254f, -0.01348103f, -0.03870668f, 0.16589125f, 0.06476153f, 
    -0.17329267f, -0.31309277f, -0.25593081f, -0.28451791f, 0.08396900f, 0.12458298f, -0.05430882f, 0.08716023f, 
    -0.07040855f, 0.42430869f, 0.07285150f, -0.15941706f, -0.02446602f, 0.23027754f, -0.06874214f, 0.09877692f, 
    -0.27728406f, -0.13062422f, -0.10000613f, -0.00323764f, -0.12840724f, 0.01153698f, -0.04939120f, 0.11233547f, 
    0.47333682f, -0.39682916f, -0.02608024f, 0.02103161f, -0.11964931f, -0.08202287f, 0.36667395f, -0.22512218f, 
    0.03518536f, 0.11979997f, 0.38789469f, -0.44734627f, 0.06389368f, 0.01653674f, 0.08684792f, -0.23326093f, 
    0.16552675f, 0.45697758f, -0.26413202f, 0.07826938f, -0.31803334f, 0.26927122f, 0.09399174f, 0.05589305f, 
    -0.06180862f, 0.09473176f, -0.14646518f, -0.16866158f, 0.16676491f, 0.05241231f, 0.00466738f, 0.19545875f, 
    -0.14758432f, 0.37061405f, 0.15875658f, -0.39831939f, 0.00293216f, 0.02135506f, -0.09452246f, 0.03908183f, 
    -0.11134669f, 0.41865072f, 0.32047141f, -0.21385837f, -0.09706043f, 0.10456280f, -0.10287814f, 0.06813800f, 
    -0.11114690f, -0.21404876f, -0.05698284f, -0.20143583f, 0.01140378f, 0.27609336f, -0.15821071f, -0.01506131f, 
    0.35645869f, -0.13966684f, 0.22592889f, 0.08555346f, -0.11014893f, 0.14126983f, 0.16710846f, 0.00205566f, 
    0.29093069f, -0.12775294f, 0.14842060f, -0.01613280f, 0.16010085f, 0.07156719f, 0.18636519f, 0.16129275f, 
    -0.06260573f, 0.30969763f, -0.13786741f, -0.22232337f, -0.14299251f, 0.25148878f, 0.12089411f, -0.31782004f, 
    0.13314301f, 0.02609477f, -0.05126252f, -0.09424168f, 0.04905000f, -0.09806078f, 0.00332357f, 0.11404656f, 
    -0.05805428f, 0.11276928f, 0.03544605f, 0.15724382f, -0.16167213f, -0.10689049f, -0.00860858f, -0.09148882f, 
    -0.06499797f, -0.05143571f, 0.14115205f, -0.05474802f, -0.01934190f, 0.06957783f, -0.16413136f, -0.07171442f, 
    -0.06481083f, 0.08617622f, -0.01878388f, -0.10617800f, -0.11353801f, -0.05703101f, 0.06832767f, 0.03130946f, 
    0.16314627f, 0.18864752f, -0.16368166f, 0.05988853f, 0.07930677f, 0.20504117f, -0.14633135f, -0.11796612f, 
    -0.19462043f, 0.07876161f, 0.05350359f, -0.08995838f, 0.08141001f, 0.06442987f, 0.16397326f, -0.06949207f, 
    0.12154151f, 0.34784281f, -0.02685031f, 0.11833530f, 0.03183882f, 0.00998060f, -0.31150901f, -0.40746114f, 
    -0.07629149f, -0.06770517f, 0.24234311f, -0.17690310f, -0.02430323f, -0.39728442f, 0.15123428f, 0.38892472f, 
    0.17195509f, -0.04313802f, -0.14848116f, -0.13534415f, -0.14063135f, 0.01351879f, 0.01908319f, -0.06304789f, 
    0.17462027f, 0.14337716f, -0.01592422f, 0.04413957f, -0.10680121f, 0.04724141f, 0.01004425f, -0.04589358f, 
    -0.04029744f, 0.01650744f, -0.03970711f, -0.17175053f, -0.02113502f, 0.05479537f, 0.06650014f, -0.15024027f, 
    -0.15876684f, 0.06360415f, -0.03783141f, -0.00271535f, 0.08753603f, -0.01238614f, -0.00731596f, -0.14903282f, 
    -0.09613613f, -0.13336000f, 0.08487039f, -0.02066576f, -0.12085836f, 0.10456160f, -0.01672821f, 0.10081684f, 
    -0.09170359f, -0.01702827f, -0.14939037f, 0.07184457f, -0.01625741f, -0.02514864f, 0.10452560f, 0.00725294f, 
    -0.04345280f, -0.14818422f, 0.08492413f, -0.08307828f, 0.10997556f, -0.10494433f, -0.15423422f, -0.08574694f, 
    -0.01625712f, -0.17851427f, 0.08832128f, 0.10030220f, 0.08508794f, 0.05252872f, 0.12381570f, -0.11158207f, 
    0.10222817f, 0.02001418f, -0.09522020f, 0.26255620f, 0.43699729f, 0.12145005f, 0.08457561f, 0.43818632f, 
    -0.21295020f, 0.02034987f, -0.07390687f, 0.12275308f, 0.15224284f, 0.53282261f, -0.12627698f, 0.07151207f, 
    0.07481010f, -0.42934725f, -0.15964647f, 0.35702023f, -0.01147442f, 0.06796838f, 0.37898895f, 0.25897241f, 
    -0.04246616f, -0.08977406f, 0.29241645f, -0.24618122f, -0.07649171f, -0.41485113f, 0.05092274f, 0.09099757f, 
    0.15135844f, -0.07745767f, 0.08111735f, 0.13537510f, 0.26495662f, 0.31474191f, -0.06313138f, 0.05256482f, 
    -0.20224635f, -0.07295566f, 0.15447040f, 0.02797521f, 0.18159388f, -0.22765958f, 0.04696402f, -0.34810665f, 
    0.13503137f, 0.22557423f, 0.14061147f, -0.16340342f, 0.13183707f, 0.09642927f, 0.02728217f, -0.01991228f, 
    -0.10652569f, 0.07992402f, 0.21333840f, 0.01411107f, 0.09753804f, 0.46095395f, 0.12853990f, -0.26691142f, 
    -0.08924002f, 0.08083917f, -0.18026352f, -0.18425116f, -0.04892708f, 0.04013460f, -0.11779717f, -0.11643738f, 
    0.04340147f, 0.13200942f, -0.20499215f, 0.12871696f, 0.08541624f, 0.02542336f, -0.13093951f, 0.09212992f, 
    0.01441125f, 0.01114616f, 0.14091471f, -0.14623991f, -0.12087185f, 0.08063449f, 0.03923658f, -0.15864359f, 
    -0.07046584f, -0.08768672f, -0.00295938f, -0.15437272f, -0.11480395f, 0.04344143f, -0.01347525f, -0.21147645f, 
    -0.02788293f, -0.04423032f, -0.20273966f, 0.08475815f, 0.25927106f, 0.01800294f, 0.10153249f, 0.20835055f, 
    0.00786330f, -0.11674795f, 0.21218926f, 0.09396404f, 0.11665627f, -0.33414549f, 0.16540948f, 0.30309632f, 
    -0.33291537f, 0.02710922f, 0.08595664f, -0.33091706f, 0.13862401f, 0.08595578f, 0.01260411f, 0.35109782f, 
    -0.00820215f, 0.34930170f, 0.31372598f, -0.47862792f, 0.12104901f, -0.00003386f, 0.03879045f, 0.27602682f, 
    0.12370286f, -0.16098656f, 0.30705199f, -0.13025536f, 0.50622070f, -0.21985668f, -0.01162337f, 0.19757743f, 
    -0.15883718f, -0.14502412f, 0.05586625f, -0.14861014f, 0.08047985f, -0.17502582f, 0.14358190f, 0.22424111f, 
    -0.20749818f, -0.29493052f, 0.15516041f, 0.16955003f, 0.12796859f, -0.17440742f, 0.41449615f, 0.14935617f, 
    0.11929544f, -0.00001863f, 0.07262528f, -0.22628127f, 0.08569871f, -0.04392065f, -0.01676839f, 0.09085472f, 
    0.16385472f, 0.53400314f, 0.06166076f, -0.11694155f, -0.08363263f, -0.07664938f, 0.10964879f, -0.22820339f, 
    -0.34057191f, -0.14465548f, 0.33931664f, -0.09093923f, 0.05808480f, 0.42474478f, -0.08555318f, 0.42751262f, 
    -0.07195250f, -0.06032848f, -0.09562053f, -0.18616162f, 0.08390015f, 0.13132335f, 0.48769999f, 0.11520748f, 
    -0.03517497f, 0.25590876f, -0.34154966f, 0.09631160f, 0.01388999f, -0.01673600f, -0.05548137f, 0.03004290f, 
    -0.11451078f, -0.13440952f, -0.16733314f, 0.00025726f, -0.02673624f, 0.05111336f, 0.14785042f, -0.14848006f, 
    -0.03400651f, -0.02985276f, -0.15305492f, 0.04951539f, 0.08947793f, -0.05894123f, -0.11442070f, -0.08945993f, 
    -0.05135286f, 0.11097254f, -0.08842100f, -0.00439439f, 0.04972567f, 0.14456730f, -0.01107302f, -0.02370645f, 
    0.11135546f, 0.09269161f, -0.17962500f, 0.09647656f, -0.09541446f, 0.12912734f, 0.03563004f, -0.20398472f, 
    -0.16390367f, 0.46327454f, -0.08746304f, 0.40196922f, 0.15340088f, -0.20387466f, -0.12612054f, 0.09706169f, 
    0.28247505f, -0.09350295f, -0.35391560f, 0.11403225f, 0.01503300f, 0.37543702f, 0.13385893f, 0.15960564f, 
    -0.26317060f, 0.15296350f, -0.03731107f, 0.19267593f, -0.04923601f, 0.16381243f, -0.30155450f, 0.27458370f, 
    -0.00398285f, 0.22152573f, -0.01879460f, 0.17966144f, 0.09268640f, -0.30901134f, 0.01519575f, 0.23728876f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05586014f, 0.01598833f, -0.12758915f, -0.08381415f, 0.05892480f, 0.12337185f, -0.12394178f, -0.08058520f, 
    0.16837557f, 0.07329343f, 0.13830820f, -0.00755997f, -0.03871872f, 0.23447119f, 0.14523904f, 0.21075946f, 
    -0.04523380f, 0.16358168f, 0.01481088f, 0.23525330f, -0.06912386f, -0.01233923f, -0.12459753f, -0.01799307f, 
    0.27016836f, 0.10639548f, 0.00317305f, -0.13172787f, 0.12440690f, 0.29528233f, -0.01992185f, 0.08416130f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.13305002f, 0.29825124f, 0.06543636f, -0.30500701f, 0.03736430f, -0.44368553f, 0.09667926f, -0.07820635f, 
    0.23831585f, 0.10321197f, -0.49467403f, -0.53307712f, 0.03511601f, -0.06188130f, -0.31256214f, -0.50173527f, 
    0.13882083f, -0.01551310f, 0.33916679f, -0.61329424f, -0.17621423f, 0.19605152f, -0.00096381f, 0.04248476f, 
    -0.21617666f, 0.05909605f, -0.07814173f, 0.13584413f, -0.13962100f, 0.18478622f, 0.03360276f, 0.16485386f, 
    -0.14825507f, -0.08085419f, -0.16273586f, -0.11884967f, -0.14559087f, -0.24187596f, -0.03886673f, 0.08482886f, 
    -0.54452735f, 0.09566663f, 0.43136230f, -0.18938115f, 0.18934889f, -0.63051158f, 0.10979824f, -0.00923592f, 
    -0.44230622f, 0.00930856f, 0.32863131f, -0.04592290f, 0.11456021f, 0.01156632f, -0.15268798f, -0.03156319f, 
    0.32649794f, -0.47512463f, -0.08365663f, 0.17405376f, 0.07456736f, 0.22998066f, -0.09768398f, 0.22486880f, 
    -0.29516470f, -0.07924952f, 0.03825480f, -0.49902934f, 0.19605061f, 0.13705243f, 0.01849515f, -0.09343155f, 
    -0.57807189f, -0.12802084f, -0.24090882f, 0.45072857f, -0.06743088f, 0.04109114f, -0.74150890f, -0.39529938f, 
    0.28966734f, -0.38608378f, 0.16193046f, -0.33411106f, 0.00789691f, -0.12286096f, -0.15218045f, -0.10891156f, 
    0.09901929f, -0.51180148f, 0.02282174f, 0.33215436f, 0.27476224f, -0.27013364f, 0.10184333f, 0.28750384f, 
    0.07478114f, 0.29352006f, -0.06293570f, 0.14030208f, -0.73422784f, -0.48186189f, 0.09327728f, 0.04052880f, 
    0.20055099f, -0.07290018f, -0.27176008f, 0.23926616f, -0.27395883f, -0.25858933f, -0.07262221f, -0.45238596f, 
    0.25755802f, 0.04939221f, -0.52616978f, 0.32115746f, -0.05744275f, 0.11148179f, -0.02770317f, 0.12445617f, 
    0.20127565f, 0.21748671f, 0.05207804f, -0.70780599f, 0.02348340f, 0.34350842f, 0.07276904f, -0.17143784f, 
    0.19572073f, 0.30238268f, 0.11428469f, 0.07168206f, 0.02760251f, 0.09820946f, 0.13935927f, -0.02941940f, 
    -0.23511222f, 0.11574972f, -0.51318592f, 0.04064776f, -0.04061133f, 0.15300749f, 0.34098151f, -0.08631395f, 
    -0.08243055f, 0.04008073f, 0.05685883f, 0.43478680f, -0.09230219f, -0.89874154f, 0.14233707f, 0.06297831f, 
    -0.38924474f, 0.35073635f, -0.06357830f, 0.07560379f, -0.01969289f, -0.02249499f, 0.10330538f, -0.31870082f, 
    0.15512572f, -0.17229033f, 0.02741840f, 0.15695848f, 0.09537736f, -0.43221059f, 0.02195288f, 0.02143228f, 
    0.00632973f, -0.16406307f, 0.51464176f, -0.35527205f, 0.00693314f, -0.09356822f, 0.28439811f, 0.23110013f, 
    -0.67754388f, 0.23315805f, 0.29884851f, 0.13698125f, 0.08573139f, 0.38536844f, 0.15676279f, -0.01095877f, 
    -0.25540799f, 0.01892857f, 0.01667296f, -0.03467693f, -0.61986363f, 0.02537345f, 0.15166795f, -0.28222653f, 
    0.01134797f, -0.35609660f, -0.06748547f, 0.00520036f, 0.06220618f, 0.29362470f, 0.05088323f, -0.06098699f, 
    0.00532736f, 0.11099108f, 0.51233137f, -0.18032369f, 0.00492822f, 0.03549115f, 0.32532629f, 0.02452877f, 
    0.40629265f, -0.37150824f, -0.26220700f, -0.10522000f, -0.15635532f, 0.22559357f, -0.16448553f, 0.08861801f, 
    0.04871007f, 0.02646169f, 0.11532836f, 0.21829052f, 0.41673288f, -0.08869773f, 0.03250729f, -0.27666715f, 
    -0.58107603f, 0.13016719f, 0.13746327f, 0.44306538f, -0.53452057f, -0.47111782f, -0.07461930f, 0.01795475f, 
    0.36885673f, 0.01643213f, -0.27990261f, 0.22572093f, 0.06289623f, -0.04479693f, -0.04478612f, 0.38789719f, 
    0.05749756f, -0.23286749f, -0.51184338f, -0.16810673f, 0.00623064f, 0.09416241f, 0.09866469f, -0.14026096f, 
    -0.17490305f, 0.38830814f, 0.14769861f, -0.44679299f, 0.07829731f, -0.46211925f, -0.01704706f, -0.16798668f, 
    0.17088826f, -0.61963904f, 0.02325332f, -0.35690489f, -0.39890802f, -0.16433534f, -0.11023281f, -0.13531521f, 
    -0.49399742f, 0.15717849f, -0.23005712f, 0.16686374f, 0.12919511f, 0.24429406f, -0.11804805f, 0.10906343f, 
    -0.65896362f, 0.12921791f, 0.06010816f, 0.04673672f, -0.06575439f, 0.47731569f, 0.12688962f, 0.00228227f, 
    0.33105698f, 0.19032407f, -0.06893387f, 0.11599060f, -0.28988868f, -0.85000032f, -0.01835715f, 0.33891094f, 
    -0.21515748f, -0.02537525f, 0.05727647f, 0.06103940f, 0.38864920f, 0.22136867f, -0.02343987f, -0.12122876f, 
    0.02598668f, 0.01689362f, -0.06141265f, 0.14417696f, 0.01092061f, 0.48203972f, -0.24894768f, 0.17205806f, 
    -0.11691321f, -0.57108504f, -0.08415974f, 0.12076354f, -0.13447239f, -0.10003331f, -0.01303299f, -0.07195556f, 
    -0.53462303f, -0.47921211f, -0.10446289f, -0.09877747f, -0.23152977f, 0.20211086f, -0.01364418f, 0.09752551f, 
    0.47933879f, -0.10296822f, -0.00869148f, -0.15861860f, 0.16512807f, -0.69141644f, -0.16394433f, -0.03251198f, 
    -0.12076131f, 0.14148334f, -0.24918771f, -0.06762614f, -1.04019225f, 0.47376710f, -0.15211828f, -0.00560135f, 
    0.19139014f, 0.35901615f, -0.87933826f, -0.24242334f, 0.12936273f, -0.28524062f, 0.05572104f, 0.14522277f, 
    0.27466390f, -0.27991089f, 0.14285409f, -0.65629721f, 0.34143701f, 0.18187371f, -0.01281613f, 0.11399475f, 
    -0.62966746f, -0.12622923f, -0.10917806f, -0.05002234f, 0.01069177f, -0.23978965f, -0.01336758f, 0.13388409f, 
    0.23113975f, 0.15523694f, -0.38730344f, -0.68542576f, -0.03855047f, 0.11498694f, -0.02959660f, 0.25388080f, 
    -0.04870614f, 0.41224995f, -0.18207790f, 0.09123996f, 0.00620996f, -0.17717016f, -0.07191445f, 0.14854780f, 
    0.19010177f, -0.18497229f, 0.13544598f, 0.17447364f, 0.50849956f, 0.17129731f, -0.01850610f, -0.39692506f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.04442389f, -0.11444889f, -0.11100633f, 0.14904705f, -0.09067450f, 0.01220724f, -0.25629434f, -0.14985330f, 
    -0.04825254f, 0.09105932f, 0.31461835f, -0.05941347f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
