#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.33808681f, 0.23968157f, -0.29399782f, -0.55729306f, 0.03324398f, -0.56519979f, 0.25235975f, 0.26518464f, 
    0.22451754f, -0.31966829f, 0.84346914f, -0.36654782f, 0.29646379f, 0.34590673f, -0.49872315f, -0.00602208f, 
    0.12333788f, 0.16083458f, -0.01665081f, 0.49056140f, -0.01567888f, -0.47847271f, -0.69311559f, -0.44354269f, 
    0.01542194f, 0.30098847f, -0.14863391f, 0.82125509f, -0.31762341f, -0.57327861f, 0.14337164f, 0.39724171f, 
    0.32722640f, 0.29452744f, 0.03000020f, -0.07271855f, 0.53117657f, 0.58517313f, -0.65988266f, 0.14661752f, 
    0.20113780f, -0.22862072f, 0.14995746f, -0.24930449f, 0.07950893f, -0.50476050f, -0.19453689f, 0.42976275f, 
    0.54245549f, 0.64892608f, 0.34496507f, 0.12069628f, 0.14397830f, 0.09878661f, -0.78869510f, -0.11993845f, 
    0.20840685f, 0.23054814f, 0.03078192f, -0.61006331f, 0.16457129f, -0.04983888f, -0.25292549f, -0.14298519f, 
    0.12024938f, -0.42696127f, 0.42761254f, -0.34361860f, -0.07964882f, -0.33365440f, -0.48162386f, -0.16011339f, 
    -0.34843448f, -0.36779362f, -0.51646304f, 0.14372927f, 0.44997430f, 0.49868104f, 0.16343959f, -0.32553774f, 
    0.12822008f, -0.55336678f, 0.49454778f, -0.37296337f, -0.12705730f, -0.28584373f, -0.30325422f, -0.10721225f, 
    -0.06175458f, -0.21654293f, 0.61334324f, 0.34239483f, 0.07190730f, -0.40506274f, 0.35542077f, -0.33738694f, 
    0.29029661f, 0.28506947f, 0.15111232f, 0.24074000f, -0.18194725f, -0.44824263f, -0.62401193f, 0.02346216f, 
    0.46631655f, -0.21892312f, -0.33157131f, -0.08146252f, -0.62070996f, 0.64899832f, 0.28964904f, 0.32960457f, 
    0.32423183f, 0.36276183f, 0.07000639f, 0.00696739f, -0.30225128f, 0.31714854f, -0.67612100f, -0.54354423f, 
    -0.59716028f, -0.10080814f, -0.13633299f, 0.01451026f, 0.40484732f, 0.20098525f, 0.08493932f, 0.15635683f, 
    0.37637931f, 0.22978488f, 0.42717665f, -0.14965102f, -0.12019060f, 0.12321803f, 0.37656966f, 0.14422759f, 
    0.48896620f, 0.43132097f, -0.51612383f, 0.41989985f, -0.12926717f, -0.14911737f, -0.26898968f, -0.06202108f, 
    -0.47442782f, -0.44612837f, 0.25380296f, 0.34606764f, -0.54844701f, 0.41212365f, 0.29444873f, 0.13300762f, 
    0.41127804f, -0.14302190f, -0.65462178f, -0.36308926f, -0.46887085f, 0.25248724f, -0.37950483f, -0.07189167f, 
    -0.12137991f, 0.11998697f, 0.31806284f, 0.26363683f, 0.26413423f, -0.50802004f, 0.09884334f, 0.53293395f, 
    -0.22996420f, 0.42596990f, 0.46515146f, -0.54698724f, 0.03270992f, -0.44974729f, -0.34052306f, 0.59578311f, 
    -0.02306620f, -0.07141982f, -0.02540410f, -0.14268936f, -0.11810619f, -0.20689857f, 0.42719531f, 0.03009167f, 
    -0.10414110f, -0.29194140f, -0.52360469f, -0.37710622f, -0.27838314f, 0.33948895f, 0.18661404f, 0.18970306f, 
    0.21556903f, -0.60106784f, -0.07085861f, 0.13592753f, 0.26528692f, 0.14048178f, -0.14845075f, -0.32213980f, 
    -0.40513375f, 0.52198225f, 0.24556927f, 0.05576367f, -0.33957216f, 0.07792974f, -0.34060910f, 0.42395288f, 
    -0.55386847f, -0.13057972f, 0.62635612f, -0.57073945f, -0.18183734f, -0.42319331f, -0.44024277f, 0.32535931f, 
    0.41526055f, 0.43171567f, 0.72615302f, 0.06680200f, -0.00192387f, -0.11379633f, 0.08353826f, -0.15624484f, 
    0.04013070f, 0.43062836f, 0.53919011f, -0.10754790f, 0.50266230f, 0.54726470f, 0.45945507f, -0.28426361f, 
    0.24465159f, 0.25548637f, -0.49860457f, -0.48659024f, -0.27150774f, 0.41447085f, 0.23687902f, -0.02699464f, 
    0.32539898f, -0.12668376f, 0.04605474f, 0.51129466f, 0.39157665f, 0.27021381f, -0.25703266f, -0.45021254f, 
    0.13767286f, 0.39934587f, 0.09432127f, -0.34492025f, -0.04097239f, -0.10526516f, -0.51389974f, 0.07465825f, 
    -0.38502643f, -0.27393463f, 0.03960142f, 0.09631535f, 0.50641143f, -0.07175141f, -0.04166010f, 0.61298358f, 
    0.43998083f, 0.67278701f, -0.42022777f, 0.25556588f, 0.24557669f, -0.17227037f, -0.58596945f, -0.69925511f, 
    -0.42831093f, -0.12080799f, -0.29051259f, 0.38906145f, -0.01778196f, 0.13063341f, 0.08219562f, 0.44707197f, 
    -0.18520726f, 0.54077184f, 0.30651179f, 0.08162574f, 0.46716088f, -0.22548607f, -0.34670076f, -0.14219356f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10148946f, 0.04207901f, 0.09436624f, 0.03667885f, -0.02254653f, -0.13223822f, -0.00023716f, -0.21532863f, 
    -0.24144377f, 0.23057790f, -0.20673777f, -0.30756116f, -0.26720899f, 0.23676665f, 0.09982277f, 0.20596658f, 
    -0.21537623f, 0.09924193f, -0.05017380f, -0.01239822f, 0.06722453f, -0.23064834f, -0.14533593f, -0.40444264f, 
    0.10123992f, -0.44184560f, -0.20478944f, 0.07816399f, -0.12930165f, -0.21510984f, 0.22279941f, -0.06326925f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00116956f, -0.03897864f, 0.00825716f, -0.01855366f, -0.01528134f, 0.04630645f, -0.04310090f, -0.02809382f, 
    -0.04867572f, 0.01989212f, -0.02678802f, -0.02180817f, -0.05284923f, 0.01859954f, -0.02881552f, 0.03348312f, 
    0.03261367f, -0.04801908f, -0.05098499f, 0.00590150f, -0.03553345f, 0.00220794f, -0.04407427f, -0.00768644f, 
    -0.00422929f, -0.02427900f, -0.04604890f, -0.05930731f, 0.03963164f, -0.03686776f, -0.01870124f, 0.02962295f, 
    -0.00654266f, -0.02610294f, 0.03976815f, 0.02548690f, 0.04621108f, -0.00305029f, 0.01120277f, 0.01863741f, 
    -0.01128138f, -0.02093494f, -0.01892115f, 0.00414659f, 0.01871579f, -0.00704907f, 0.05402314f, 0.02806326f, 
    0.00467233f, -0.01313199f, 0.00895994f, -0.00990587f, 0.04478973f, -0.03509649f, -0.04980118f, -0.04643110f, 
    0.01441446f, 0.02003276f, 0.03517342f, -0.05044913f, -0.05303052f, -0.02755813f, 0.00555395f, 0.05227676f, 
    0.03231354f, -0.00379654f, -0.02493205f, -0.03406245f, 0.00168002f, -0.02051252f, -0.04819240f, -0.04841378f, 
    -0.05182585f, 0.05635497f, -0.01661989f, 0.02591253f, 0.00691859f, 0.04654350f, -0.01736748f, -0.00796423f, 
    0.01123221f, -0.01968841f, 0.04842953f, -0.04688606f, 0.04719948f, 0.03504322f, 0.05243770f, 0.02234582f, 
    0.02595405f, -0.03114558f, -0.04525586f, 0.03105306f, 0.03671272f, 0.03168874f, -0.00043981f, 0.03535979f, 
    -0.03158088f, 0.01320449f, -0.04943525f, -0.00997072f, -0.05786552f, -0.03216256f, 0.03692485f, 0.01744467f, 
    -0.03141421f, 0.04564731f, 0.00538635f, -0.02496479f, 0.00354907f, 0.02355790f, 0.03174786f, 0.01250307f, 
    0.02880837f, 0.00656234f, 0.02239350f, -0.00554795f, -0.06835551f, -0.03065912f, 0.00676150f, 0.04411937f, 
    -0.00034714f, -0.02532890f, 0.03979086f, -0.03600972f, -0.02402208f, 0.02851764f, -0.03410097f, -0.01677690f, 
    -0.05997153f, 0.02761170f, -0.05998451f, -0.02156622f, 0.02912377f, -0.00536982f, -0.05686041f, -0.06739856f, 
    0.01501852f, 0.02653465f, -0.00342429f, -0.05436686f, 0.00457536f, 0.02504341f, -0.01117632f, -0.06542768f, 
    -0.00198869f, 0.00092959f, -0.03950812f, 0.00146488f, -0.04496089f, -0.00165831f, 0.04001310f, 0.02751986f, 
    0.03838591f, -0.01275765f, 0.00093785f, -0.00499433f, -0.03577283f, 0.01923200f, -0.00060110f, -0.01565085f, 
    -0.04799920f, -0.03035936f, 0.00648115f, 0.00291125f, -0.05127548f, -0.01130518f, -0.04038129f, -0.06394486f, 
    -0.05551883f, 0.00636485f, 0.02445506f, -0.03233586f, -0.02693481f, 0.01012340f, 0.02281517f, -0.03208226f, 
    0.03189599f, -0.03287534f, -0.06332052f, 0.02776154f, 0.03932443f, -0.05917409f, -0.01993538f, 0.01445939f, 
    -0.02742689f, 0.01463468f, -0.03604840f, -0.05017473f, -0.04186903f, -0.06963754f, 0.03193793f, -0.02492178f, 
    -0.01490780f, -0.00633800f, 0.02267923f, -0.01818183f, -0.02332830f, 0.01002168f, -0.05876111f, 0.00203444f, 
    -0.05817453f, 0.00562438f, 0.04157137f, 0.04356378f, 0.04931650f, -0.04192557f, -0.00921600f, -0.04214649f, 
    -0.00345197f, 0.04923052f, 0.03257424f, 0.02348574f, -0.00356514f, -0.01520506f, 0.01366567f, -0.05842210f, 
    0.01336611f, -0.00099644f, -0.03412708f, 0.02549614f, 0.03474405f, 0.01965004f, -0.04487539f, -0.00735165f, 
    -0.03344906f, -0.05978835f, -0.02990235f, 0.03070961f, -0.03505434f, 0.04655836f, 0.03484283f, 0.02299105f, 
    -0.05253416f, -0.04777192f, -0.01552000f, 0.01649338f, 0.00890973f, 0.02823305f, -0.01703550f, -0.02322197f, 
    0.04229876f, -0.02308077f, 0.04202970f, -0.00997145f, 0.03408926f, -0.03747653f, 0.03319131f, -0.04261743f, 
    -0.04443473f, 0.01088421f, -0.02009824f, 0.02715010f, -0.01835114f, -0.06168720f, -0.01893212f, 0.03227537f, 
    0.03192205f, -0.04570817f, 0.03232412f, -0.02024645f, -0.05638151f, 0.04301319f, -0.05818567f, 0.04239139f, 
    0.04131321f, 0.02569552f, 0.01823912f, -0.05577154f, 0.00521898f, -0.04748218f, 0.00510128f, -0.05330223f, 
    0.04873569f, 0.00006246f, 0.04787876f, 0.03437746f, -0.00028999f, -0.02572770f, 0.04562843f, 0.02589430f, 
    0.04276303f, -0.01357979f, -0.01037985f, -0.00764432f, 0.02328833f, 0.02797501f, 0.03799457f, -0.03898354f, 
    -0.00351616f, -0.02267634f, -0.07670883f, -0.07356189f, 0.04832931f, 0.17354709f, 0.14120720f, -0.08569415f, 
    -0.07050347f, -0.23020525f, -0.13917397f, 0.01888658f, -0.05443979f, 0.03986282f, -0.03612313f, 0.00941490f, 
    -0.01826895f, 0.06190624f, -0.07065461f, -0.27363369f, -0.12770329f, 0.05942824f, -0.07166889f, 0.20444854f, 
    -0.06617671f, -0.10580255f, -0.23909760f, 0.05585743f, -0.13334420f, 0.19322267f, 0.12037117f, -0.13560328f, 
    -0.12790440f, 0.22068518f, -0.07261971f, -0.04021467f, 0.11157607f, -0.11216097f, 0.04243812f, 0.05434541f, 
    0.01935149f, 0.09132720f, -0.01689915f, 0.12521119f, -0.14082770f, -0.05515257f, -0.11342505f, 0.05219742f, 
    -0.05575231f, 0.05311702f, -0.07127302f, 0.03842500f, 0.00682152f, 0.04824340f, -0.24637035f, 0.01137064f, 
    0.07970142f, -0.00124526f, 0.07492715f, 0.10287187f, -0.05699921f, 0.01330212f, 0.04245804f, 0.02292236f, 
    0.09694596f, -0.11501057f, -0.00790840f, -0.06484534f, 0.01632150f, 0.05375633f, 0.23317857f, -0.03588508f, 
    0.22215855f, 0.12282591f, -0.02645403f, 0.03690377f, 0.10420269f, -0.17520750f, 0.05739545f, -0.03389579f, 
    -0.00762723f, 0.01556473f, -0.00928223f, 0.06513780f, 0.05521729f, 0.10201427f, 0.03344361f, -0.14537208f, 
    0.02031299f, -0.18727106f, 0.05723646f, -0.24598619f, -0.02862291f, -0.06355114f, 0.06560281f, 0.00141472f, 
    0.06749081f, 0.05759525f, 0.24352670f, -0.06494602f, 0.06447791f, 0.08068769f, 0.17015432f, -0.03639799f, 
    -0.06320038f, -0.08352860f, 0.07993203f, 0.04185344f, -0.16691926f, -0.13200885f, -0.04497849f, 0.01456614f, 
    0.02261548f, -0.26142305f, 0.01283522f, 0.05206856f, 0.15832280f, 0.16791542f, -0.05792465f, 0.06563263f, 
    0.08956863f, -0.13625811f, 0.07174172f, -0.14701360f, -0.10690107f, 0.01523184f, -0.08249823f, 0.04881687f, 
    -0.03364953f, 0.03010634f, -0.08304909f, -0.08480885f, -0.05749247f, -0.07148977f, 0.09771951f, -0.12507124f, 
    -0.04638815f, -0.06524127f, 0.02608513f, -0.02036177f, 0.10804181f, -0.05259353f, -0.03726019f, 0.05807899f, 
    -0.15762082f, -0.02713870f, 0.03233896f, -0.00311601f, 0.12278304f, 0.16255473f, 0.30408806f, -0.01413534f, 
    -0.01526140f, 0.14528203f, 0.12779321f, -0.10523702f, 0.13755116f, -0.01665816f, 0.00556852f, -0.06104295f, 
    0.00843072f, -0.00654848f, 0.25804862f, -0.04304796f, -0.09073143f, -0.04331850f, -0.20556495f, -0.05513825f, 
    0.04289417f, 0.04119646f, 0.15375446f, 0.14731915f, 0.03716461f, 0.10549525f, 0.13317092f, -0.04867354f, 
    -0.00279109f, 0.05396216f, -0.03161036f, -0.13415356f, 0.03887717f, 0.07163309f, -0.01797012f, -0.00702510f, 
    0.14290871f, 0.09678496f, -0.13864690f, 0.09039499f, -0.17890714f, -0.03610799f, -0.04844830f, -0.02515695f, 
    0.05791608f, -0.08494568f, 0.07218152f, 0.12180059f, 0.01315113f, 0.05891265f, 0.21968786f, 0.06421497f, 
    -0.07186349f, 0.05019063f, 0.04950466f, -0.04368138f, 0.02897326f, 0.12292568f, -0.14427093f, -0.09306213f, 
    -0.01787418f, -0.21413848f, -0.08807893f, -0.01162446f, 0.05071342f, 0.04400349f, 0.09642871f, 0.04515644f, 
    -0.02669610f, -0.04825908f, -0.09129580f, -0.08954866f, -0.06836757f, -0.10106186f, -0.08372486f, 0.03703831f, 
    0.01673609f, 0.11839190f, -0.05752986f, -0.11149171f, -0.09095704f, -0.14252762f, -0.11253526f, -0.01412357f, 
    -0.01905406f, 0.11643762f, 0.25589463f, 0.29030183f, 0.09650663f, 0.06116172f, 0.09934731f, 0.02987922f, 
    0.15970832f, 0.04477153f, 0.04936157f, 0.10969456f, -0.07062089f, -0.01833634f, -0.01678884f, -0.13439251f, 
    0.06688021f, -0.04079819f, 0.00525652f, 0.14528911f, -0.00520855f, -0.10511440f, 0.00239221f, -0.02425621f, 
    0.07260016f, 0.17961141f, 0.03768687f, 0.09195277f, -0.24025486f, -0.02303878f, 0.00423545f, -0.00903025f, 
    -0.12510288f, 0.02457470f, -0.00980814f, 0.04352723f, -0.07906778f, 0.19110513f, 0.02426691f, 0.25327307f, 
    0.05482641f, 0.08729659f, 0.10101445f, -0.01973126f, -0.01230099f, 0.12540890f, -0.10538991f, 0.18772313f, 
    -0.00394253f, 0.00603231f, 0.12066086f, -0.00525652f, -0.06974947f, -0.06030714f, 0.02773555f, 0.01261952f, 
    -0.21935515f, -0.03261402f, -0.01371443f, -0.14547926f, 0.01563030f, 0.02791485f, 0.04019919f, 0.04438772f, 
    -0.03704168f, 0.00967143f, -0.11527498f, -0.05657712f, -0.01107903f, 0.00694712f, 0.02249359f, 0.17916451f, 
    -0.00498451f, -0.01326454f, -0.00233173f, 0.02793820f, 0.14972115f, -0.25397214f, -0.05333773f, -0.01450441f, 
    -0.17367670f, -0.11737716f, 0.04634399f, 0.11836553f, -0.05181218f, -0.06316044f, -0.03378835f, 0.12157930f, 
    -0.04350627f, 0.07889012f, 0.00859364f, -0.02179100f, -0.16290478f, -0.03846803f, 0.01066734f, -0.02548549f, 
    -0.11115322f, -0.12557924f, -0.05757116f, -0.08663504f, -0.14925966f, 0.01704964f, 0.15160181f, 0.09204761f, 
    0.11911988f, -0.03434087f, -0.00301444f, 0.13952515f, -0.13763551f, 0.04257610f, -0.12310400f, 0.09619947f, 
    -0.06327081f, 0.03114837f, -0.05251191f, 0.05636203f, -0.10481550f, 0.02187963f, 0.08276301f, 0.10991570f, 
    -0.03583471f, 0.20441003f, 0.11650293f, -0.13153414f, 0.01552305f, 0.14851183f, -0.04099562f, -0.06149339f, 
    0.14931604f, 0.09455241f, -0.13547812f, 0.07156281f, 0.11527793f, -0.01280230f, 0.12820815f, 0.04432105f, 
    0.00235196f, 0.18593071f, -0.15641858f, 0.06196875f, 0.00929424f, -0.03410232f, -0.00659280f, -0.11136501f, 
    -0.02285189f, -0.11199053f, -0.30708483f, 0.04799918f, 0.08472303f, -0.14889571f, -0.10453527f, -0.00804575f, 
    -0.16458271f, -0.02240891f, 0.03873434f, 0.09479591f, -0.18673512f, -0.20380445f, -0.21013153f, 0.06016519f, 
    0.02158940f, -0.15465951f, 0.04402784f, 0.00762029f, 0.24536565f, 0.15648670f, 0.03295013f, -0.07292613f, 
    0.15281823f, -0.07616095f, 0.01785079f, -0.00558729f, 0.18525246f, -0.12124975f, -0.05909626f, 0.10150115f, 
    -0.02227581f, 0.15977424f, 0.13104083f, 0.01199727f, -0.06908375f, 0.08897564f, -0.25720039f, -0.01331472f, 
    0.09286645f, 0.10326479f, -0.03412851f, 0.03704283f, 0.16544746f, 0.14774951f, 0.08970051f, -0.15519676f, 
    0.11599381f, 0.14917415f, -0.00460781f, 0.06459044f, -0.08270232f, 0.06433672f, 0.07134961f, 0.15920851f, 
    -0.09602384f, -0.03659211f, -0.22324356f, 0.18852845f, -0.00582381f, 0.04518319f, 0.02233836f, 0.11982313f, 
    0.08261614f, -0.21226987f, 0.00716298f, 0.01741329f, 0.06386235f, 0.07021471f, 0.06519012f, 0.00322124f, 
    -0.03024988f, -0.03861963f, -0.17616707f, -0.12682974f, -0.00382767f, -0.05067776f, 0.02757283f, -0.14228304f, 
    -0.11695217f, 0.00620977f, 0.05735229f, -0.05461085f, 0.12224147f, 0.08920716f, 0.02860418f, 0.05660172f, 
    0.03111327f, -0.05769718f, -0.15896668f, 0.00428703f, 0.06857684f, 0.16075103f, 0.02609535f, 0.04273894f, 
    0.01178686f, -0.01915177f, 0.08789219f, 0.04592270f, 0.03187534f, -0.14315371f, 0.01456654f, 0.12004373f, 
    -0.26821515f, -0.03929889f, -0.13741085f, 0.00324946f, -0.03121853f, -0.00208832f, 0.12927985f, 0.11437707f, 
    -0.09487571f, 0.02374379f, 0.07184051f, -0.08573556f, -0.03405294f, -0.08961792f, 0.07601173f, 0.07817475f, 
    -0.01344122f, 0.01185926f, -0.09777232f, -0.06300931f, -0.03156194f, -0.07455724f, 0.07769671f, -0.01377462f, 
    -0.18854819f, 0.02894192f, 0.19759560f, 0.05555853f, 0.05638497f, -0.07596991f, 0.03455478f, 0.09465107f, 
    0.04426453f, -0.13867457f, -0.12016055f, -0.07062342f, 0.04562521f, 0.05477505f, 0.04291717f, 0.21013080f, 
    -0.00125637f, 0.02000983f, -0.17471439f, 0.14559291f, -0.05822122f, 0.15796195f, 0.01783101f, 0.05713194f, 
    0.18873070f, 0.05662507f, -0.00725996f, -0.07148433f, 0.05940752f, 0.17856170f, -0.21113467f, -0.04031710f, 
    -0.12571546f, -0.06856693f, 0.03829204f, 0.08815422f, -0.23817284f, 0.17109874f, 0.12850314f, -0.07214807f, 
    0.10071920f, -0.11648840f, 0.04860684f, 0.05000794f, -0.01820338f, -0.28572980f, -0.02598868f, -0.00736478f, 
    0.04385081f, -0.01545807f, -0.05854078f, 0.13602486f, 0.11382006f, 0.00109496f, -0.29276043f, 0.00873283f, 
    0.02366375f, 0.17698692f, 0.15781802f, 0.03297051f, -0.07000159f, 0.06785905f, 0.01666532f, 0.18336104f, 
    0.02328232f, 0.02559353f, 0.00426205f, 0.05291394f, -0.05017426f, 0.14420085f, 0.00838310f, 0.05671998f, 
    0.06797925f, 0.09889621f, 0.05583837f, -0.06837275f, -0.00366940f, -0.28958765f, -0.01452119f, 0.04090092f, 
    0.01378789f, 0.10508293f, 0.10753647f, 0.12746751f, 0.00633572f, 0.04648152f, -0.03123752f, -0.01014993f, 
    -0.01161107f, -0.07523640f, 0.08502977f, 0.02260783f, 0.10959524f, 0.04517682f, -0.05150085f, -0.14273968f, 
    0.19732279f, 0.08810348f, 0.09013866f, -0.09904595f, 0.04336555f, 0.10787003f, 0.06901138f, 0.03172389f, 
    0.12704238f, -0.07761028f, 0.03715460f, -0.10788451f, 0.21514906f, 0.13292637f, 0.10389700f, -0.03806874f, 
    0.10415458f, 0.07250214f, 0.09544242f, -0.00566423f, -0.12975217f, -0.14573945f, -0.07436433f, -0.03154824f, 
    0.18008646f, 0.06815522f, 0.24294472f, 0.07913359f, 0.10932767f, -0.19972149f, 0.05949303f, 0.08816733f, 
    -0.02788564f, -0.07647737f, -0.11104634f, -0.00257268f, 0.02675826f, -0.06719204f, -0.03595725f, 0.06094944f, 
    -0.00997091f, 0.03681032f, 0.00006177f, -0.02960486f, 0.19315118f, 0.03381394f, 0.08842809f, -0.07082459f, 
    -0.32376471f, -0.07481406f, 0.15540212f, 0.16667192f, 0.16313097f, 0.02837351f, -0.17939942f, -0.03596547f, 
    0.08008605f, 0.09183786f, 0.09091916f, 0.16559611f, -0.17399088f, 0.03614622f, -0.01405643f, -0.02532206f, 
    0.04645656f, 0.04626972f, 0.06354789f, 0.09886723f, 0.04213174f, -0.01341020f, 0.00974745f, -0.00978098f, 
    0.06773537f, 0.13079678f, 0.00386963f, -0.18999645f, 0.14214283f, -0.09721613f, -0.06656101f, 0.07111554f, 
    0.08586049f, 0.19115539f, -0.00915988f, -0.10649571f, 0.03554707f, -0.13047662f, -0.06366052f, -0.04992605f, 
    -0.03572954f, 0.21983480f, 0.05586630f, 0.03863466f, -0.21760447f, 0.05835333f, 0.07782757f, -0.03008136f, 
    0.05809019f, -0.06203826f, -0.10517036f, 0.11701450f, 0.09024239f, -0.05164646f, -0.04030216f, 0.04835751f, 
    -0.00031573f, 0.05853487f, -0.01732472f, 0.15498701f, -0.00270242f, 0.09274554f, -0.07361124f, 0.14579171f, 
    0.12713122f, 0.01746059f, 0.02690444f, 0.06639896f, 0.02404012f, 0.10351123f, 0.05004480f, 0.12706278f, 
    -0.02083612f, 0.01698217f, -0.07969709f, -0.07993993f, 0.17177042f, 0.07414434f, 0.12302285f, -0.15811819f, 
    -0.24480119f, -0.01486310f, 0.14390741f, 0.14572522f, -0.02829272f, -0.18564413f, -0.07162301f, -0.03258026f, 
    0.07378871f, 0.17856604f, -0.22758047f, -0.02082230f, -0.03176936f, 0.07476691f, 0.21006194f, 0.17087451f, 
    0.11457748f, 0.00024514f, -0.27248177f, -0.09631585f, 0.05629263f, 0.02777754f, -0.10396470f, -0.07286368f, 
    -0.00878380f, -0.15019158f, 0.06180260f, 0.20525992f, -0.00443078f, -0.03732487f, -0.03864258f, -0.04099314f, 
    -0.06605612f, 0.09095553f, -0.01352295f, 0.00857133f, -0.02111710f, 0.02134209f, -0.13545898f, 0.03405807f, 
    -0.01436116f, -0.11096954f, -0.03156765f, 0.21397868f, -0.04267528f, -0.00458006f, -0.18500027f, 0.05275067f, 
    0.17391674f, 0.08475967f, 0.12464274f, -0.01710925f, -0.13582154f, 0.07070761f, 0.08682147f, -0.02675508f, 
    -0.02930458f, -0.15473051f, -0.01408457f, -0.08287616f, 0.18380836f, -0.09455863f, 0.09685554f, -0.01815378f, 
    0.18807021f, 0.03685674f, -0.04739950f, 0.06520008f, 0.02883354f, 0.07767756f, 0.06082637f, 0.06662591f, 
    0.05795921f, -0.23445107f, -0.02455263f, -0.00135392f, 0.25242436f, 0.14169422f, 0.05898073f, -0.03081717f, 
    -0.07710956f, -0.29230762f, -0.11586681f, 0.03031962f, 0.04252595f, 0.07370491f, 0.12363856f, -0.07441515f, 
    -0.07958770f, -0.02827346f, 0.00697529f, 0.08311728f, -0.04744848f, -0.05418083f, 0.09626826f, 0.06197463f, 
    -0.01327100f, 0.07912236f, 0.05323787f, 0.00897403f, 0.06815670f, -0.06055241f, 0.14829877f, 0.18778208f, 
    -0.02937885f, -0.06663702f, 0.12857698f, -0.15091990f, -0.10766339f, 0.10862314f, -0.14683853f, -0.08165734f, 
    0.27826068f, -0.02811388f, 0.04610300f, -0.07829595f, 0.13472979f, 0.02944545f, 0.09112861f, 0.06806917f, 
    0.06967612f, 0.01585332f, -0.02952996f, -0.15372849f, 0.09897876f, -0.13469872f, 0.09976053f, -0.20441364f, 
    -0.03600507f, -0.29718760f, 0.05270713f, 0.17988595f, 0.21627426f, 0.08114696f, -0.02155004f, -0.18111636f, 
    -0.05882199f, -0.09639174f, 0.04517800f, 0.02234629f, -0.03863541f, -0.05476956f, -0.05796172f, -0.01615893f, 
    -0.01079189f, 0.22714758f, 0.08809882f, -0.11593650f, -0.05107728f, 0.01530758f, 0.00544774f, 0.01407421f, 
    0.06995176f, -0.03539361f, -0.03092676f, -0.22060814f, -0.17292495f, -0.07418136f, 0.00802491f, 0.01572559f, 
    -0.03922443f, 0.04823960f, -0.02892307f, 0.13593026f, -0.03581244f, -0.00419017f, -0.04121058f, -0.03088636f, 
    -0.00385740f, 0.02122046f, -0.02585639f, 0.05702687f, -0.16197103f, 0.01102875f, -0.17386451f, 0.00409382f, 
    -0.08391933f, 0.04817663f, -0.05584846f, 0.07962339f, -0.06190718f, 0.07933769f, 0.12644957f, 0.02026478f, 
    -0.12856647f, -0.16843830f, -0.08714136f, 0.13223866f, -0.05431356f, 0.13331214f, 0.08529715f, 0.07277934f, 
    -0.03490383f, 0.07132985f, 0.04506302f, 0.04729753f, -0.04116177f, 0.09685118f, 0.05409086f, 0.20629236f, 
    0.14042588f, -0.10909630f, 0.07231960f, 0.07244230f, 0.15668806f, -0.01976064f, -0.01339337f, -0.14338914f, 
    0.16282818f, 0.06901202f, -0.09054458f, 0.01232350f, -0.07717738f, 0.03068779f, -0.02990291f, 0.00023951f, 
    0.10033968f, 0.28945580f, -0.01552736f, -0.06510268f, 0.10748288f, 0.04685665f, 0.00882322f, -0.08301256f, 
    0.09294549f, -0.05665604f, -0.19129859f, -0.18766794f, 0.09950581f, -0.03751986f, -0.02590682f, 0.01503094f, 
    0.01137911f, 0.00188645f, -0.15603589f, 0.06010672f, -0.01323370f, -0.26241699f, 0.00081312f, -0.02624380f, 
    0.01305303f, 0.05871220f, -0.06755702f, 0.02445700f, -0.04213807f, 0.14649957f, -0.07623701f, -0.03556041f, 
    0.08123374f, -0.17622405f, 0.06585555f, 0.03725371f, 0.04129485f, -0.04473937f, 0.02831776f, 0.04697072f, 
    0.00619126f, -0.02120852f, 0.12594864f, -0.02186222f, -0.03644466f, 0.10218400f, -0.18580627f, 0.03703385f, 
    0.02326616f, 0.08687394f, 0.06155895f, 0.01680661f, 0.10967968f, -0.03527831f, 0.03027355f, -0.12230416f, 
    0.00894683f, 0.05060454f, -0.03267605f, 0.01241019f, -0.02529577f, 0.11393403f, -0.07085947f, -0.03338907f, 
    0.11749601f, -0.03520192f, 0.10663520f, -0.08912622f, 0.11417021f, -0.01124343f, -0.01241422f, -0.07670964f, 
    0.01072659f, 0.03699997f, -0.00823612f, -0.01312249f, 0.03118484f, -0.05084400f, 0.13464107f, -0.11396725f, 
    0.00534081f, -0.12237087f, 0.02962848f, 0.00756382f, -0.17677085f, 0.08563775f, -0.06486843f, 0.10625717f, 
    0.00039829f, 0.07735001f, 0.09888965f, 0.03206009f, 0.10964290f, -0.01785746f, 0.03083949f, -0.22544695f, 
    0.11731350f, 0.00974534f, 0.02274009f, 0.00139765f, 0.17071027f, -0.01245139f, -0.06400088f, 0.00619541f, 
    0.01438836f, -0.00697372f, 0.01070816f, 0.00412760f, 0.09158556f, -0.07195755f, -0.23708716f, -0.15515561f, 
    -0.01356003f, 0.06088237f, 0.10477526f, 0.01145540f, 0.07994179f, -0.08460422f, 0.12941447f, 0.05689396f, 
    0.00473146f, 0.20180950f, 0.05982216f, -0.02371410f, 0.21681985f, 0.02184600f, -0.00871274f, 0.13324808f, 
    0.13556269f, -0.09489052f, 0.08769814f, -0.05424633f, -0.02236989f, 0.09476574f, 0.07451981f, 0.04329458f, 
    -0.14256182f, -0.06897961f, 0.16169132f, -0.01030036f, 0.09328038f, 0.08173475f, -0.05684257f, -0.03369307f, 
    0.00677197f, -0.17868152f, 0.14187258f, 0.02614332f, 0.06453231f, 0.01068977f, -0.09502075f, -0.17130087f, 
    -0.05996614f, 0.12763222f, 0.08589388f, 0.22713588f, -0.00650728f, -0.05508304f, 0.02732495f, -0.00724521f, 
    0.14343864f, 0.17611203f, -0.17493242f, -0.16696158f, -0.15908355f, -0.17827988f, 0.01892619f, -0.04454072f, 
    0.06581645f, -0.01551065f, 0.00110330f, -0.03243956f, 0.10889851f, 0.05289849f, -0.09157979f, -0.18298893f, 
    0.09917267f, 0.06039838f, 0.10566641f, 0.05750859f, 0.07554572f, -0.22057424f, 0.06737727f, -0.06552380f, 
    -0.01908940f, -0.04372519f, -0.13298148f, -0.00343330f, -0.04372055f, 0.05399505f, 0.17472084f, 0.01920328f, 
    0.16852151f, -0.00867459f, 0.04011708f, -0.06650659f, 0.01887566f, 0.04337617f, 0.05742400f, 0.03806812f, 
    -0.08476026f, -0.02890735f, -0.05913274f, 0.17422229f, -0.12356127f, 0.03379432f, 0.06546638f, 0.12168841f, 
    -0.23391107f, -0.06528074f, -0.10481979f, -0.00150512f, -0.06510638f, 0.05359220f, -0.20422314f, -0.00372953f, 
    -0.06727239f, 0.17915370f, 0.13960290f, -0.02446738f, 0.03267674f, -0.08827960f, -0.07584570f, -0.03888430f, 
    0.09660098f, -0.15066242f, -0.02735941f, -0.13288160f, -0.20888604f, -0.28371665f, 0.06071175f, -0.08554574f, 
    -0.04982938f, 0.02964245f, 0.07563355f, 0.22909911f, -0.09684206f, -0.01262088f, -0.14802150f, 0.07090216f, 
    0.01060819f, -0.02888173f, 0.03356736f, 0.06510770f, 0.06162311f, -0.02519295f, -0.16747251f, -0.06238501f, 
    -0.10327918f, -0.08599156f, -0.00077182f, 0.07324275f, -0.00812772f, 0.04758582f, 0.00326798f, 0.01099899f, 
    0.09619830f, -0.06028267f, -0.01669465f, 0.00462209f, -0.08205682f, 0.13018841f, 0.23215200f, 0.11042387f, 
    0.12297697f, 0.02418983f, -0.04274231f, -0.11994006f, 0.02515953f, -0.05675389f, 0.03849003f, 0.35529280f, 
    0.22047469f, 0.05877023f, -0.11383223f, -0.03987585f, 0.04655857f, 0.03718010f, -0.08041667f, -0.03489867f, 
    0.22975899f, -0.00748684f, 0.07317428f, 0.23061864f, 0.07221473f, 0.06472149f, 0.04315958f, 0.14033277f, 
    0.13661014f, -0.04414909f, 0.02623052f, 0.01926654f, 0.05334940f, 0.00959248f, -0.01150413f, 0.03176168f, 
    0.04260774f, 0.04075445f, -0.00640364f, -0.19046833f, 0.00377051f, -0.00656400f, 0.04077216f, 0.07530874f, 
    -0.11090962f, -0.02129649f, -0.14819463f, 0.18270901f, 0.02203035f, -0.03365923f, -0.10479847f, 0.04026259f, 
    -0.00774701f, -0.01757852f, 0.03424330f, 0.01247953f, -0.09281804f, -0.24735738f, 0.17685159f, 0.01495652f, 
    0.04826265f, -0.02444957f, 0.04615676f, 0.01756462f, 0.17319262f, 0.18611352f, 0.18470272f, -0.01513630f, 
    -0.10097589f, -0.00115502f, -0.13215758f, 0.02354869f, 0.01527302f, -0.08320965f, -0.14795220f, 0.02547243f, 
    0.03879107f, -0.01003751f, 0.04241500f, -0.05689652f, -0.08395652f, -0.01885698f, -0.22215131f, -0.12562412f, 
    -0.24618573f, -0.05661620f, 0.10537322f, 0.05832614f, -0.04902811f, -0.09507338f, -0.04594092f, 0.04355317f, 
    0.07123232f, -0.14450896f, -0.04555740f, -0.05435108f, 0.00493255f, 0.01030448f, 0.07945884f, -0.00445439f, 
    -0.00928597f, 0.03609036f, 0.15012662f, 0.04536089f, 0.02404525f, 0.12744886f, 0.02388213f, -0.06453213f, 
    -0.01424585f, -0.15217488f, -0.14718542f, 0.05265276f, -0.10457592f, -0.18706562f, 0.01463922f, -0.07220205f, 
    0.03535108f, 0.03664453f, -0.01196704f, -0.06786406f, 0.13752939f, 0.03709789f, 0.16391048f, -0.09698237f, 
    0.05346212f, 0.05334935f, 0.05848888f, 0.08960816f, 0.05643937f, -0.04920532f, 0.01303431f, -0.14567848f, 
    0.03607558f, 0.00543272f, -0.05378857f, 0.07602520f, -0.09133850f, 0.17225665f, -0.00549609f, -0.42919141f, 
    0.07033751f, 0.03098537f, -0.12040364f, -0.03334732f, 0.06137608f, -0.07723128f, 0.12612571f, 0.16139425f, 
    0.01621621f, 0.07742183f, -0.04722572f, -0.00789233f, -0.09520312f, -0.03281795f, 0.10825134f, 0.32373267f, 
    0.02465305f, -0.08646860f, -0.01061614f, -0.10500158f, -0.05940992f, 0.05133873f, -0.05789037f, 0.03875500f, 
    -0.16410413f, -0.02733756f, 0.00390168f, -0.05681637f, -0.00051038f, -0.05843119f, -0.08952698f, 0.11668821f, 
    -0.01293105f, -0.01604391f, 0.07829146f, 0.00155986f, 0.10460327f, -0.14695229f, -0.15615961f, 0.07615691f, 
    0.08769814f, -0.07356103f, 0.06834742f, 0.18324493f, 0.14257799f, 0.26789692f, -0.11464074f, 0.00024506f, 
    0.06027666f, 0.07925842f, 0.05732257f, -0.02565653f, -0.10663966f, -0.06318913f, -0.28467387f, 0.07882927f, 
    -0.01254310f, -0.01395892f, -0.00496647f, -0.02286985f, 0.01917276f, 0.15863943f, 0.08610769f, -0.03728040f, 
    -0.11960784f, -0.05545646f, -0.08323181f, 0.01697283f, -0.08175891f, -0.03528636f, 0.08666721f, 0.14621542f, 
    0.07168316f, -0.06154939f, 0.05743610f, 0.00625354f, 0.03633871f, -0.08289368f, 0.04442937f, 0.00828186f, 
    0.13391110f, -0.03539442f, -0.03409715f, -0.03545573f, -0.00330232f, -0.02721867f, -0.03560516f, 0.12244037f, 
    -0.10569246f, -0.27692944f, -0.07581411f, -0.08884870f, -0.02933853f, 0.07421207f, 0.03820093f, 0.07147807f, 
    0.19215438f, 0.05230842f, -0.04495967f, 0.14092453f, -0.04845448f, -0.15271740f, 0.08882682f, 0.06518908f, 
    0.08213547f, 0.25416246f, -0.00052555f, 0.07047571f, -0.00980393f, 0.04448291f, 0.01557901f, -0.06883281f, 
    -0.03588449f, -0.05927050f, 0.34583944f, 0.29482594f, 0.05057200f, 0.00708924f, 0.01856877f, -0.04531539f, 
    0.09076982f, 0.07774865f, 0.09534014f, 0.05677769f, 0.07531071f, -0.12247246f, -0.09559740f, 0.05080846f, 
    -0.03442246f, -0.08073711f, -0.02006140f, -0.00073058f, -0.00670382f, 0.06784107f, 0.07155084f, 0.11717545f, 
    -0.09069658f, -0.01952567f, -0.03992008f, -0.03659112f, -0.02102288f, 0.30339700f, 0.04160152f, -0.27061301f, 
    -0.04800604f, -0.03807938f, 0.01159675f, 0.07912821f, -0.02575126f, 0.00939078f, 0.21042763f, 0.03519090f, 
    -0.06649642f, 0.03880930f, -0.09026273f, 0.02342659f, 0.01224686f, -0.01932343f, 0.08190367f, 0.02091708f, 
    0.01553711f, -0.05491332f, 0.10811997f, -0.01864738f, 0.13116674f, -0.08028923f, 0.04900015f, 0.05314845f, 
    0.08352120f, -0.21850061f, -0.07627285f, 0.00325244f, 0.12595862f, 0.05956477f, -0.00561627f, -0.03715365f, 
    -0.04916527f, 0.14554602f, 0.03493832f, 0.05037452f, 0.04659577f, 0.07251434f, -0.00412203f, 0.09594334f, 
    0.07271486f, 0.14135128f, -0.30802765f, 0.02761406f, -0.03178003f, 0.17864662f, 0.03015035f, -0.13940744f, 
    -0.00101496f, -0.01714880f, -0.06144192f, -0.06440534f, -0.13454214f, -0.07347053f, -0.10804378f, 0.10533843f, 
    -0.08028524f, 0.09549812f, 0.08140084f, -0.09425263f, 0.08604657f, -0.06924878f, -0.01572425f, -0.04314790f, 
    -0.02076989f, -0.06861071f, 0.10935788f, -0.01572463f, -0.02757148f, 0.13579476f, -0.11320240f, 0.10756798f, 
    0.01895926f, 0.09217831f, -0.02901837f, 0.06795040f, 0.03064511f, 0.04152516f, -0.09214346f, -0.09420493f, 
    0.01914428f, 0.02499043f, 0.06056407f, 0.07098955f, -0.06727405f, -0.03217308f, -0.02168455f, -0.09378273f, 
    0.05012846f, 0.07608269f, 0.15438013f, -0.00156742f, -0.03055128f, 0.10892370f, -0.06580485f, -0.05070814f, 
    0.28469062f, -0.20047075f, -0.15224937f, -0.11307401f, -0.04457769f, -0.02612876f, -0.11998194f, -0.17563196f, 
    -0.01621063f, -0.04395928f, -0.12108666f, 0.19011596f, -0.07748029f, 0.02245435f, 0.11089070f, 0.02123006f, 
    -0.00273644f, 0.04423695f, -0.22737271f, -0.08497391f, -0.06542871f, 0.01347727f, 0.05119498f, 0.04286606f, 
    -0.06208247f, 0.07033727f, -0.26938930f, 0.09047991f, -0.01519213f, -0.13923562f, -0.14346978f, 0.01010358f, 
    -0.06005595f, 0.07848318f, 0.10695179f, 0.11634947f, 0.07655750f, -0.09782108f, 0.08892413f, 0.07615425f, 
    -0.03378197f, 0.09608945f, -0.04464414f, 0.00994071f, 0.07470363f, -0.07048811f, -0.19246045f, -0.10028344f, 
    0.05433359f, -0.02910611f, -0.14990406f, -0.07571784f, 0.10719526f, -0.03262183f, 0.12296506f, -0.00250844f, 
    0.01804988f, 0.07690990f, -0.07724947f, 0.16898324f, -0.13695918f, -0.07696638f, 0.11890860f, -0.26401860f, 
    0.19584480f, 0.03730926f, -0.03586715f, -0.07299255f, 0.01350295f, 0.10489868f, 0.01302304f, 0.05877388f, 
    -0.27509612f, -0.08231244f, 0.05465622f, 0.18474767f, -0.06072528f, 0.07509035f, -0.06496873f, -0.06143512f, 
    -0.14499225f, -0.08545431f, 0.05562116f, -0.07639600f, 0.03825607f, -0.02182816f, -0.00556728f, -0.05972968f, 
    -0.13615501f, -0.12752374f, 0.08698731f, 0.10745174f, -0.35078993f, -0.00007858f, -0.00900370f, -0.00358730f, 
    -0.03132886f, 0.00515149f, -0.09943432f, -0.11559522f, 0.09239488f, -0.04238630f, 0.11854354f, 0.10203328f, 
    -0.05818115f, -0.02210123f, 0.02772100f, -0.03338008f, 0.09586295f, 0.01443958f, 0.18885930f, -0.15271196f, 
    -0.01509250f, -0.06466562f, 0.10676760f, 0.06564497f, 0.03300013f, -0.05280669f, -0.02724094f, -0.13037422f, 
    0.06987461f, 0.06223809f, 0.12660952f, -0.08964722f, -0.02149330f, 0.06046557f, 0.05533960f, -0.05730761f, 
    0.08636457f, 0.08468124f, 0.00629865f, 0.03720026f, 0.04298946f, 0.10269236f, 0.01964376f, -0.13864136f, 
    -0.18327297f, 0.02171903f, -0.00167058f, 0.05905309f, 0.06007980f, 0.02858803f, 0.05341375f, -0.17154661f, 
    -0.00854598f, -0.02135865f, -0.04526581f, 0.04135257f, -0.05472443f, -0.03320180f, -0.00346254f, -0.04836792f, 
    -0.00470429f, 0.01659619f, -0.00162515f, 0.01691996f, -0.04234254f, -0.06620268f, 0.04089484f, -0.03165848f, 
    -0.02462285f, 0.04516362f, -0.02320471f, 0.02739634f, -0.04780436f, 0.00266181f, -0.02051991f, -0.06427438f, 
    -0.07393219f, -0.05253824f, 0.00198476f, 0.02005967f, -0.05251042f, 0.03134501f, -0.04735056f, -0.06985427f, 
    -0.01740940f, -0.00982691f, 0.00773256f, -0.06697591f, 0.00709684f, 0.01765448f, -0.00861919f, 0.00678132f, 
    0.01636735f, -0.01662356f, -0.03522399f, -0.01627589f, 0.01265718f, 0.00735660f, -0.06243059f, -0.04253961f, 
    0.03016718f, -0.00427418f, -0.02334203f, 0.03773240f, -0.04158404f, -0.00040795f, -0.00759110f, -0.04270687f, 
    -0.04045085f, -0.05975298f, 0.04004756f, 0.03145583f, -0.06075189f, -0.02329163f, -0.07375301f, -0.00590652f, 
    0.01263785f, 0.00687469f, -0.03206056f, -0.04744182f, -0.04242729f, -0.06428121f, -0.01804551f, -0.02421148f, 
    0.04215328f, 0.01705314f, 0.07053974f, 0.00420852f, -0.04974278f, -0.04343615f, -0.06278583f, -0.02701436f, 
    -0.01875761f, 0.01823080f, 0.02448323f, -0.06380128f, 0.00848441f, 0.04211932f, -0.03556635f, 0.03831397f, 
    -0.03262131f, 0.04244523f, 0.00962101f, -0.06149048f, -0.00129239f, -0.03851264f, -0.03730025f, -0.05526973f, 
    0.04344537f, -0.05525528f, 0.05170025f, 0.00352922f, 0.00457094f, -0.03610121f, 0.01813833f, -0.05889210f, 
    0.03933600f, -0.02131300f, -0.00604981f, 0.03180261f, 0.02917082f, -0.05951843f, -0.01907834f, -0.04030663f, 
    -0.04284119f, -0.01135039f, 0.01172137f, -0.01935571f, -0.06190563f, -0.05422758f, 0.05405460f, -0.03096792f, 
    0.04267343f, -0.02500106f, 0.01354652f, 0.02965384f, -0.06874716f, -0.03767153f, 0.03187326f, -0.00620987f, 
    -0.01671393f, 0.00654966f, -0.05981812f, -0.04681682f, 0.04261689f, 0.04531483f, -0.06079838f, 0.03926590f, 
    0.02590360f, -0.03649395f, -0.00609116f, 0.05183979f, -0.01705863f, 0.03393640f, 0.02931953f, -0.01719928f, 
    0.03221425f, 0.00585422f, -0.00624923f, 0.00648774f, -0.05482635f, -0.00897645f, 0.04125457f, 0.01328929f, 
    0.04550653f, -0.04609288f, -0.04250904f, -0.00088604f, 0.03893709f, -0.01967688f, -0.04659881f, -0.04784643f, 
    0.02364201f, 0.02887338f, 0.01761842f, -0.06657374f, 0.02077483f, 0.02547319f, 0.00787833f, -0.03366750f, 
    0.04441413f, 0.03453616f, 0.00946312f, -0.02528227f, -0.01497315f, -0.02961106f, -0.07298056f, -0.04572425f, 
    0.01594629f, 0.02529261f, -0.06838544f, -0.01413943f, -0.02453117f, 0.03272697f, -0.02300380f, 0.02467939f, 
    0.04190675f, -0.07409497f, -0.03612432f, -0.01814917f, -0.04989766f, -0.05142877f, 0.04096828f, 0.02792427f, 
    -0.04565197f, -0.06936643f, -0.03062194f, -0.03133516f, -0.03753460f, -0.04898293f, 0.01910156f, -0.00033903f, 
    0.04501359f, -0.03799468f, -0.00742743f, -0.00976063f, 0.00509181f, -0.03927730f, 0.02732828f, 0.00691493f, 
    0.01604983f, -0.02119580f, 0.02838247f, 0.03633631f, -0.05212380f, -0.04134279f, 0.00693409f, -0.05237888f, 
    -0.02750466f, 0.02077738f, -0.00165938f, -0.01438855f, -0.01534619f, 0.04472545f, 0.04500762f, -0.00366253f, 
    -0.05965689f, -0.03085163f, 0.00605448f, 0.01934205f, 0.00526892f, 0.01076118f, 0.02755632f, -0.05371632f, 
    -0.01141487f, 0.03863587f, -0.05688589f, 0.02971337f, 0.01581172f, -0.06288654f, 0.02429820f, -0.02178083f, 
    0.00711610f, 0.03157508f, 0.00788759f, -0.01723415f, -0.02739747f, 0.01721266f, 0.03760753f, -0.06054874f, 
    -0.02848124f, 0.02707968f, -0.05775610f, -0.00645027f, 0.01587909f, -0.02479722f, -0.00606828f, -0.00027498f, 
    -0.02442110f, -0.00586659f, -0.05813936f, 0.02134548f, -0.05094583f, -0.00966281f, 0.04567373f, -0.00746880f, 
    -0.06067185f, -0.05732261f, -0.06531210f, 0.01869444f, -0.06090137f, -0.01350318f, 0.01092510f, 0.00148278f, 
    0.02582367f, -0.05376115f, -0.02145060f, -0.01407965f, -0.02169936f, 0.05207499f, 0.01615998f, -0.01151994f, 
    -0.02871457f, 0.02116104f, -0.02576100f, -0.03505824f, -0.02720076f, -0.00613438f, 0.01678457f, 0.02684877f, 
    0.04448819f, -0.03921360f, -0.05420807f, -0.09216992f, -0.04549831f, 0.02707669f, -0.02112449f, -0.01430932f, 
    0.01246049f, -0.05348169f, -0.00974683f, -0.03460621f, -0.04542590f, -0.01820099f, -0.00084700f, -0.04267133f, 
    -0.03334794f, 0.04932972f, 0.02861929f, 0.02763089f, -0.07024816f, -0.00055655f, -0.00507206f, -0.03163316f, 
    0.00974285f, -0.01630732f, 0.02693380f, 0.04085942f, -0.03675131f, -0.03757863f, -0.05802608f, -0.00738780f, 
    -0.05873200f, -0.01225375f, -0.00449129f, 0.02930820f, -0.02357469f, -0.03058565f, 0.01164964f, 0.00889443f, 
    -0.00005603f, -0.07361736f, 0.00107000f, -0.04287584f, 0.03074537f, -0.05261647f, 0.03124306f, 0.05668329f, 
    -0.04531674f, -0.08733032f, -0.00593358f, 0.02072397f, -0.02172370f, 0.00113176f, -0.05598340f, -0.03010516f, 
    -0.05996799f, 0.00200889f, -0.07784462f, 0.03119500f, -0.06884563f, 0.01637442f, -0.00690401f, -0.01883400f, 
    -0.00557717f, -0.05129664f, 0.00883714f, -0.04082730f, -0.03118045f, -0.01462913f, -0.02568327f, 0.04867719f, 
    0.01960330f, 0.02645065f, 0.03319842f, 0.02186991f, -0.04590923f, 0.03411844f, 0.01055126f, -0.05233080f, 
    0.00593453f, -0.03740565f, -0.06951908f, 0.01751807f, -0.07862497f, 0.03132254f, -0.02386024f, 0.00182717f, 
    -0.00480337f, -0.01079896f, -0.05428463f, 0.01284040f, 0.03978390f, 0.01214645f, 0.01315553f, 0.04588493f, 
    0.02931555f, -0.02901646f, 0.03233586f, 0.01234985f, -0.00132295f, -0.05326112f, -0.00142329f, 0.00892800f, 
    -0.02582273f, 0.05017207f, -0.04612395f, -0.04367686f, 0.00161308f, -0.06962992f, 0.05806578f, -0.01309534f, 
    0.00160421f, -0.05079806f, 0.04253942f, 0.05091278f, 0.01784029f, -0.01299439f, -0.07085518f, 0.04655329f, 
    -0.02690315f, -0.06825829f, -0.04307845f, 0.02504819f, -0.04528210f, -0.05697173f, -0.01249760f, 0.00432856f, 
    0.05733506f, -0.00335601f, -0.05347214f, -0.03555785f, -0.04318568f, -0.03716310f, 0.03832979f, -0.05348831f, 
    -0.02187619f, -0.00834200f, -0.00984388f, -0.05930059f, 0.03723392f, -0.06903321f, 0.04625297f, 0.02684232f, 
    -0.02874085f, -0.03863894f, -0.03945540f, -0.00650301f, 0.05927923f, -0.00101840f, -0.05170810f, -0.05378308f, 
    0.04615171f, -0.00188727f, -0.03557469f, -0.01339651f, -0.07723659f, -0.06962165f, -0.03159463f, -0.05596829f, 
    0.02488246f, 0.04409514f, -0.03330371f, 0.00323364f, 0.03566184f, -0.00871931f, -0.01301202f, 0.01011107f, 
    -0.07404193f, -0.00329080f, -0.01840638f, -0.04567834f, -0.00936363f, 0.00344860f, 0.00801233f, -0.03064948f, 
    -0.05113347f, -0.00598552f, -0.04266399f, -0.00352881f, -0.04351771f, 0.00521938f, -0.06121787f, -0.04537597f, 
    0.02573603f, 0.00914147f, -0.05758337f, 0.00676140f, -0.06062147f, 0.00857033f, 0.02672451f, -0.06214175f, 
    0.02467741f, -0.01392737f, 0.03014356f, -0.00856916f, 0.03050898f, 0.01379881f, -0.02992740f, -0.03585254f, 
    0.02258905f, -0.04166216f, 0.00272432f, -0.07299909f, -0.00074756f, 0.02613032f, 0.00936423f, -0.03366286f, 
    0.00478073f, -0.05794805f, 0.01546939f, 0.03565452f, -0.04840848f, 0.00012575f, -0.04382099f, 0.05189535f, 
    0.03461034f, -0.08563487f, -0.00411915f, -0.07672030f, -0.05067170f, 0.01657737f, -0.07184061f, -0.02838088f, 
    -0.00777739f, -0.05599077f, -0.03785849f, -0.05033889f, 0.05327744f, -0.02432027f, -0.01370981f, 0.02289262f, 
    -0.04083453f, 0.02961457f, 0.01023236f, 0.07277459f, -0.00751584f, -0.03007532f, 0.01000546f, -0.02211056f, 
    -0.04377104f, 0.00709165f, -0.01575937f, 0.02113554f, -0.01791175f, -0.03338454f, -0.00322772f, -0.07156311f, 
    -0.02852509f, -0.07463930f, -0.04706420f, 0.03114083f, 0.00946098f, -0.05450452f, 0.02316933f, 0.02475035f, 
    -0.04516347f, 0.00375631f, 0.02988595f, 0.01264737f, 0.03712815f, 0.03405805f, -0.08236714f, -0.00150488f, 
    -0.07094716f, 0.00721698f, -0.06185931f, 0.00775144f, -0.02349845f, -0.00330437f, 0.00302284f, 0.03758699f, 
    0.02847501f, 0.01847919f, -0.01556070f, -0.01688066f, -0.02042968f, -0.01813222f, 0.03299235f, -0.00222001f, 
    -0.08210333f, 0.00063696f, -0.06103431f, -0.06777938f, -0.04217049f, -0.04023768f, -0.03901737f, 0.01083376f, 
    -0.05956814f, -0.05309132f, -0.03884407f, 0.04345064f, -0.04064992f, -0.02729816f, -0.02812531f, -0.06593692f, 
    -0.01289455f, -0.00382975f, -0.05476343f, -0.00276825f, -0.06218588f, -0.00521083f, 0.05087008f, -0.00620933f, 
    -0.02967265f, 0.03498514f, 0.02575056f, 0.04674707f, -0.02294344f, -0.06060617f, 0.03596348f, 0.04245245f, 
    -0.05370601f, -0.01072180f, -0.04495546f, -0.04183191f, -0.04023887f, -0.02247559f, -0.04701341f, 0.01792119f, 
    -0.03895530f, -0.04631818f, 0.04328867f, -0.04354664f, 0.01503035f, -0.05055289f, -0.05752601f, 0.04256830f, 
    0.05420632f, -0.02005376f, -0.03763802f, -0.05416569f, -0.02682597f, -0.00361831f, 0.03594532f, 0.03840949f, 
    0.01884961f, 0.04546523f, 0.01387267f, 0.04546220f, -0.04462216f, -0.07043801f, 0.01843623f, -0.03131618f, 
    -0.05348797f, 0.00016506f, -0.04096125f, 0.04487538f, -0.00859346f, -0.01504324f, 0.00211925f, 0.00850759f, 
    0.02393246f, 0.01183810f, 0.03028736f, 0.04174009f, -0.05367167f, -0.06281032f, 0.02575180f, -0.03842953f, 
    0.02130065f, 0.01776765f, 0.04530824f, -0.04900752f, -0.03525937f, -0.06315222f, -0.00853325f, 0.02720428f, 
    -0.03505098f, 0.04875630f, 0.04772518f, -0.03730533f, -0.02997648f, 0.02507801f, 0.05306583f, -0.06127185f, 
    -0.03602354f, -0.02552246f, -0.06155381f, -0.02741615f, -0.01624874f, 0.04234439f, -0.00806555f, -0.01137810f, 
    0.03695797f, -0.02024277f, 0.01958140f, -0.04187676f, -0.00206542f, -0.05653178f, 0.03500993f, -0.04035449f, 
    -0.01343676f, 0.00808822f, -0.05405085f, 0.02148951f, -0.06255727f, -0.04344515f, -0.04062014f, -0.03463870f, 
    -0.01133638f, 0.00330405f, -0.02367484f, -0.02085193f, -0.05529196f, -0.05539486f, 0.03553887f, -0.03833639f, 
    -0.06037971f, 0.03476721f, 0.03783195f, -0.04105228f, 0.04391805f, 0.05338664f, -0.02653606f, -0.00081551f, 
    0.02104931f, 0.01492064f, 0.02141326f, 0.04790949f, 0.04826835f, 0.03013713f, 0.01726405f, -0.00366392f, 
    0.02756583f, -0.06119992f, 0.02908172f, -0.00579720f, -0.00338195f, -0.00045489f, 0.01876519f, 0.03921661f, 
    0.02728391f, -0.00663094f, -0.04277730f, -0.04815767f, -0.00081506f, -0.00242130f, -0.01218716f, 0.03636479f, 
    -0.04631473f, -0.01751371f, 0.06070189f, -0.05628551f, -0.06316806f, -0.05122283f, 0.03607036f, 0.01128380f, 
    0.01256072f, -0.00195086f, -0.02677033f, -0.05907138f, 0.01806392f, 0.00417047f, 0.00044931f, -0.00851716f, 
    0.02647789f, -0.06044997f, -0.00559442f, 0.03636225f, -0.00069342f, 0.00878210f, -0.05663288f, 0.01780684f, 
    -0.05343121f, 0.03102570f, 0.04579346f, 0.01716399f, 0.00296313f, 0.02453841f, -0.04221080f, -0.01837445f, 
    -0.06208099f, 0.05398177f, -0.02178858f, -0.04609738f, 0.03083546f, -0.03804731f, 0.01448641f, 0.04216127f, 
    0.01343186f, -0.02725418f, 0.02513306f, -0.03606952f, -0.00557087f, -0.04142436f, -0.02987310f, 0.03476093f, 
    0.05570775f, 0.02524588f, 0.02900594f, -0.00191341f, 0.00089386f, -0.03387372f, -0.02122452f, -0.04433823f, 
    0.02585194f, -0.02354158f, 0.00984124f, -0.03693632f, 0.04673087f, -0.05982248f, -0.01278661f, 0.02195676f, 
    -0.04233757f, 0.00668201f, -0.04479744f, 0.03476665f, -0.02671934f, -0.06049901f, 0.04818346f, 0.01391907f, 
    0.00367256f, -0.05952239f, 0.03383798f, -0.03818140f, -0.03709246f, 0.03477171f, -0.02305878f, -0.02399002f, 
    -0.02940133f, 0.04733794f, 0.01304050f, 0.03959942f, -0.04654065f, 0.02819338f, -0.07137182f, 0.02845875f, 
    -0.01937792f, -0.02720664f, 0.02086139f, 0.00502376f, 0.02329751f, 0.03616166f, 0.00046461f, -0.02193493f, 
    -0.03879874f, -0.05731975f, -0.04397499f, -0.03461507f, 0.01262148f, 0.00948789f, -0.05064040f, 0.02996362f, 
    -0.00139417f, 0.04088435f, -0.04980964f, 0.01224762f, -0.01907807f, 0.04189859f, 0.03142665f, -0.00151644f, 
    -0.03652643f, 0.02030716f, -0.00676880f, -0.03309715f, 0.05177398f, -0.01671610f, 0.05363645f, 0.02998769f, 
    -0.05500615f, -0.03279814f, -0.05212472f, -0.00461952f, -0.06771297f, -0.01696215f, -0.04446148f, 0.01275680f, 
    -0.02034557f, -0.01358420f, -0.01465035f, 0.04150877f, 0.00569113f, -0.03349159f, -0.00356131f, -0.02610231f, 
    -0.10640918f, -0.08712330f, 0.02373400f, -0.05600329f, -0.03248370f, 0.01271886f, 0.05263946f, 0.06365129f, 
    0.04864430f, -0.26308140f, -0.02767889f, 0.14278649f, 0.01387095f, -0.09628692f, 0.02779387f, -0.06241795f, 
    0.04057435f, -0.01797136f, -0.04178647f, 0.07404823f, -0.24153017f, -0.16018043f, -0.05296433f, -0.04053727f, 
    -0.01623533f, -0.01049868f, 0.09492554f, 0.03991381f, -0.02483111f, 0.13600157f, -0.08854458f, 0.06224268f, 
    -0.03568728f, -0.06624985f, 0.02187517f, -0.01376784f, -0.30319399f, 0.31258062f, 0.21676683f, -0.05287883f, 
    0.00616565f, -0.06288972f, -0.04782238f, -0.10023083f, -0.16615619f, 0.18821664f, 0.06485161f, -0.03250206f, 
    0.03905082f, 0.11883070f, -0.16684254f, 0.00948106f, -0.08373228f, -0.04906251f, -0.02687007f, -0.05438688f, 
    0.07696520f, 0.00333663f, -0.05433200f, 0.11233068f, -0.08561349f, 0.09326927f, 0.00432688f, 0.10010020f, 
    0.24544221f, 0.02238862f, -0.03252770f, -0.01935368f, 0.08773209f, -0.02912568f, -0.02048380f, -0.02346155f, 
    0.03943592f, -0.08476917f, 0.18495737f, -0.01199631f, 0.14914526f, 0.00580477f, 0.06497940f, 0.00896890f, 
    0.08045693f, -0.06499886f, -0.04818343f, -0.03968694f, 0.02859216f, -0.03601687f, -0.04848456f, -0.05088587f, 
    0.01525586f, -0.06235170f, 0.02066479f, -0.07368777f, -0.07154914f, -0.04962553f, 0.00544489f, -0.10258123f, 
    -0.11661021f, -0.09769057f, -0.11607634f, 0.18384787f, -0.07089721f, 0.21861170f, 0.09844855f, -0.03520946f, 
    -0.08611348f, 0.02174279f, 0.10163587f, 0.13807200f, -0.11577220f, 0.00868225f, -0.06044669f, -0.03574552f, 
    -0.11020698f, 0.05661638f, -0.03323127f, 0.03687012f, -0.10920539f, 0.19244838f, -0.07541719f, 0.19337755f, 
    -0.03694735f, -0.01712785f, -0.09837017f, -0.03761998f, -0.05111144f, -0.06452230f, -0.07413899f, 0.00870016f, 
    0.03646995f, 0.05868352f, 0.00807974f, -0.10321890f, 0.00487007f, 0.00557053f, -0.09096263f, 0.00374433f, 
    -0.22679451f, 0.15146685f, -0.05620963f, 0.04295659f, -0.12203361f, 0.11513633f, -0.04368143f, -0.01991948f, 
    -0.01951686f, -0.21304508f, -0.06130081f, 0.05705971f, 0.06617561f, 0.00545937f, -0.00265378f, 0.07923439f, 
    -0.10629034f, 0.06193894f, -0.01967218f, 0.19382587f, 0.05094763f, 0.09048412f, -0.15336594f, -0.02177720f, 
    0.00547093f, -0.09722041f, -0.12197457f, 0.15948658f, -0.06410743f, 0.10021615f, -0.09617544f, 0.00895239f, 
    0.05931139f, -0.02238405f, -0.07084481f, 0.08540336f, -0.09171926f, 0.23588932f, 0.08765858f, 0.08650298f, 
    0.04090239f, 0.02791015f, -0.02130672f, -0.00491856f, 0.04893389f, 0.11261104f, -0.06458400f, -0.16242093f, 
    0.02216572f, -0.09052492f, -0.00442864f, 0.11240369f, 0.06352616f, -0.01959831f, 0.11444423f, -0.22642799f, 
    0.12350214f, -0.18129113f, -0.01149919f, -0.10827000f, -0.00678828f, -0.09421128f, 0.04999781f, 0.07142347f, 
    0.09743743f, 0.01971768f, 0.06532450f, -0.00900323f, -0.04208354f, -0.10269022f, -0.11818597f, 0.35470203f, 
    0.21039891f, 0.01649783f, -0.04687206f, -0.00996560f, 0.02016515f, -0.06220186f, -0.06030203f, -0.14207271f, 
    -0.07621539f, -0.00279817f, -0.16668186f, -0.13624142f, -0.05022977f, 0.01674946f, -0.10510235f, -0.08595915f, 
    0.09150912f, -0.05160226f, 0.08740855f, 0.18259548f, -0.01000289f, 0.05278402f, -0.03205452f, 0.17480752f, 
    0.01931261f, 0.07902769f, -0.20752738f, -0.04530741f, 0.25569582f, 0.08421401f, 0.04970926f, 0.10600346f, 
    0.04384077f, 0.12779723f, 0.11404371f, -0.10517394f, 0.09896588f, -0.07089783f, 0.00616630f, -0.07130671f, 
    -0.08722260f, -0.01680188f, 0.08186557f, -0.05764654f, -0.17576917f, 0.00342173f, 0.09141352f, -0.04971129f, 
    0.04129772f, -0.13909748f, -0.12136683f, -0.06397208f, 0.03298311f, 0.03897561f, 0.10807604f, -0.00219976f, 
    0.04377354f, 0.08768061f, 0.00996676f, -0.04539362f, 0.00234043f, 0.03649113f, -0.01590169f, -0.08617919f, 
    0.25674722f, -0.03582644f, -0.05866345f, 0.04348583f, -0.03995082f, 0.01907755f, 0.02829679f, 0.12481321f, 
    0.02957665f, -0.02134610f, -0.08983403f, -0.12992938f, -0.03667053f, 0.01674620f, 0.04810776f, 0.05551836f, 
    -0.01413887f, -0.05793821f, -0.07037414f, -0.01215646f, 0.02600120f, -0.05392342f, 0.02029883f, -0.04390674f, 
    -0.00343532f, 0.02295935f, -0.01844963f, -0.00989062f, -0.03632412f, 0.03948342f, 0.03243337f, -0.04223542f, 
    -0.00189268f, 0.02336527f, -0.05693438f, -0.03691301f, -0.00095326f, 0.03154703f, -0.03852207f, 0.04588314f, 
    -0.06357848f, -0.00002415f, -0.04842534f, 0.04536065f, 0.05014479f, -0.00699488f, -0.04980328f, -0.00499425f, 
    -0.00872567f, -0.04220245f, 0.01113823f, 0.00437877f, -0.03911221f, -0.05777952f, -0.04756200f, -0.00845545f, 
    0.00792940f, 0.04561292f, -0.03356438f, -0.00106716f, -0.03944662f, 0.01028309f, -0.05206466f, 0.02901595f, 
    -0.03616018f, 0.02570671f, 0.02114538f, 0.01122887f, -0.02944124f, -0.04134092f, 0.03259723f, -0.05791100f, 
    -0.03121225f, -0.03648192f, 0.01843608f, -0.01874271f, -0.06504372f, 0.03295952f, -0.02953099f, 0.03079023f, 
    -0.03735339f, -0.00172083f, -0.03698454f, 0.00202686f, -0.03520543f, 0.02961441f, 0.02419364f, -0.05640576f, 
    -0.02211267f, 0.00788297f, -0.04177855f, -0.01053897f, -0.04211375f, 0.02838333f, -0.02976165f, -0.01782283f, 
    0.02945373f, 0.04122379f, -0.03436165f, 0.01053390f, -0.01815961f, 0.01088407f, -0.05051325f, 0.00702441f, 
    0.04306078f, 0.00159307f, -0.00185326f, -0.05178842f, 0.04195606f, -0.01509243f, 0.02336704f, 0.02258168f, 
    0.04221615f, -0.00121996f, -0.01498391f, 0.02880689f, 0.05560923f, 0.00942983f, 0.01002593f, -0.04369471f, 
    -0.06219947f, -0.04305072f, -0.06677805f, -0.05518416f, 0.02071532f, -0.04052405f, 0.04431768f, 0.03449319f, 
    0.04445038f, 0.03080990f, -0.00326832f, 0.03188336f, -0.00780185f, 0.03619708f, 0.00984712f, -0.03811843f, 
    0.00826486f, 0.01447635f, 0.02843064f, 0.02981774f, -0.00920281f, -0.00055076f, 0.04025101f, 0.04378106f, 
    -0.00627204f, -0.01271671f, -0.00512455f, 0.01209811f, -0.05855725f, -0.00063355f, -0.00819581f, -0.05728211f, 
    0.02285690f, 0.00837315f, 0.02741725f, -0.03390129f, -0.00018066f, -0.05518332f, 0.02673542f, 0.03021355f, 
    -0.05238395f, -0.01535113f, 0.04295555f, -0.03108537f, 0.04305088f, -0.02766724f, -0.04011129f, -0.05531988f, 
    0.00113357f, 0.03600282f, -0.01916045f, -0.02093835f, 0.00466766f, 0.02875532f, 0.04560850f, -0.01411891f, 
    -0.00421179f, -0.02897992f, -0.03471483f, 0.03491712f, -0.06232604f, -0.01902795f, -0.06114381f, 0.00044630f, 
    0.00387524f, 0.04067869f, -0.05676319f, -0.02979789f, -0.04859306f, 0.00674980f, -0.03369140f, -0.02818109f, 
    0.00014778f, 0.02724304f, -0.02083077f, 0.04548171f, -0.02310685f, -0.03509244f, 0.04292645f, 0.00849975f, 
    0.01368029f, 0.03144927f, -0.02258001f, 0.01558103f, -0.03582801f, 0.02473117f, 0.03883050f, -0.00334286f, 
    0.02040899f, -0.01853876f, -0.00594702f, -0.00582980f, -0.00748438f, -0.00189803f, 0.02962075f, -0.04940997f, 
    -0.00487064f, -0.03947748f, 0.02435158f, -0.00649552f, -0.02646326f, 0.01161836f, 0.04623231f, -0.01414394f, 
    -0.01245419f, 0.06478341f, -0.06456371f, 0.00414306f, 0.01982656f, -0.03203830f, 0.01708870f, -0.04784696f, 
    -0.05796901f, -0.00776541f, -0.00598635f, -0.01917946f, 0.01808837f, -0.04838781f, -0.05964299f, 0.00962639f, 
    -0.00281895f, -0.05385704f, 0.03249767f, -0.04618198f, 0.03724334f, -0.00163628f, 0.04264972f, 0.01008509f, 
    -0.03968314f, 0.04243600f, -0.04779648f, -0.04051447f, -0.05077204f, 0.04781460f, 0.00867808f, -0.06164781f, 
    0.01654997f, -0.00376099f, -0.01181726f, -0.05717997f, 0.05434836f, -0.03329421f, 0.03903366f, 0.02490282f, 
    -0.01088930f, 0.04205942f, 0.01502042f, -0.05056386f, 0.03939993f, -0.05464247f, -0.00460771f, -0.03754821f, 
    0.04108712f, -0.00608203f, 0.02936200f, 0.04343990f, 0.02689881f, 0.01222283f, -0.04646044f, -0.01120337f, 
    -0.01282095f, -0.02981981f, -0.05015618f, -0.00689898f, -0.03711081f, 0.00782953f, -0.01152906f, 0.00440447f, 
    -0.00364045f, 0.03091191f, -0.06712821f, -0.04898585f, -0.04716760f, -0.01288025f, -0.00861331f, 0.02566112f, 
    -0.03134477f, 0.01337839f, -0.02384325f, -0.01181945f, -0.01619616f, -0.02327253f, 0.04698400f, -0.00564844f, 
    0.04063924f, -0.06799749f, 0.05491882f, -0.00810372f, -0.03676515f, -0.03184869f, 0.06039628f, -0.13534176f, 
    0.10801253f, 0.08319210f, -0.04328750f, -0.09233683f, -0.12279633f, -0.13369040f, 0.08360377f, 0.08746229f, 
    -0.06290022f, -0.04178870f, 0.17478618f, -0.18743746f, 0.13390215f, 0.01558772f, 0.07973699f, -0.03797617f, 
    0.05592415f, -0.01414722f, -0.03824921f, -0.06977951f, -0.02205287f, 0.13024785f, -0.05961244f, -0.03332169f, 
    0.02516103f, 0.07994156f, -0.01882694f, -0.04621308f, -0.02437180f, 0.01964635f, 0.05671401f, -0.02763158f, 
    -0.04604500f, 0.14763303f, -0.12568246f, 0.04472492f, -0.14287655f, 0.15945916f, 0.16410366f, 0.09024980f, 
    0.03919453f, 0.02241517f, -0.12581307f, -0.11229631f, -0.03764112f, 0.06022835f, -0.10015500f, 0.01153524f, 
    0.10982158f, -0.07132354f, -0.09996592f, 0.01077435f, -0.03035736f, 0.01182117f, -0.02998714f, 0.07185099f, 
    -0.03701537f, -0.10524633f, -0.06083825f, 0.15935870f, -0.03028135f, -0.00093176f, -0.01497242f, -0.11926238f, 
    0.35080856f, 0.20946236f, -0.05491933f, -0.06425961f, 0.07736035f, -0.15377128f, -0.09876276f, 0.13718016f, 
    -0.03635873f, 0.10695473f, -0.06464400f, 0.04887197f, 0.02764335f, 0.06282397f, 0.09125517f, 0.06712725f, 
    -0.01069585f, 0.00870738f, -0.15424943f, -0.14934266f, -0.04787323f, 0.12202502f, -0.00403807f, 0.13965951f, 
    0.08673202f, -0.13985035f, -0.11210047f, -0.13178782f, -0.03276081f, 0.00777840f, 0.01841471f, -0.00094933f, 
    0.02186217f, 0.02073180f, -0.04014816f, -0.06965224f, -0.18174978f, 0.10251500f, -0.03346531f, 0.01441430f, 
    0.02822947f, -0.16698122f, 0.13671689f, -0.01594822f, 0.09846140f, -0.01968823f, -0.14322035f, 0.03154812f, 
    0.05220503f, -0.06286442f, 0.04380869f, 0.06062153f, -0.06755832f, 0.02199938f, -0.06152973f, 0.13070375f, 
    0.03299901f, -0.02509516f, 0.04171680f, -0.05582954f, 0.05079569f, -0.06835307f, -0.04231073f, -0.15279548f, 
    -0.09241188f, 0.00224438f, 0.16445370f, 0.03263962f, 0.14274344f, -0.09710875f, -0.04779755f, 0.09344119f, 
    -0.10804112f, -0.05169801f, -0.02674634f, -0.02786822f, 0.02054059f, 0.03577696f, 0.03439682f, -0.03129606f, 
    0.21096615f, -0.01954239f, 0.07566057f, 0.00514052f, 0.07762519f, -0.01877433f, 0.09035582f, 0.03032046f, 
    0.05327675f, -0.09750567f, -0.16321351f, 0.01910430f, -0.08174755f, -0.02924162f, 0.05350825f, 0.08304792f, 
    0.11047684f, -0.01064059f, -0.01379332f, 0.11850704f, 0.03396087f, -0.02211915f, -0.01039198f, 0.02523893f, 
    -0.02606420f, 0.02766912f, 0.11483148f, -0.14114265f, -0.21859805f, -0.06427594f, 0.04493321f, 0.00388155f, 
    0.10907204f, 0.07580744f, -0.12092235f, -0.04022152f, 0.05366131f, 0.01591212f, -0.26825720f, -0.09815523f, 
    0.10546948f, -0.00487022f, 0.14974217f, 0.07869660f, -0.01484452f, 0.00769375f, 0.26219290f, 0.09432131f, 
    0.01657482f, 0.03097723f, 0.02573201f, 0.09821815f, 0.08294775f, 0.01569202f, -0.01922468f, -0.11011711f, 
    -0.00178933f, -0.05262307f, -0.01249510f, -0.04559890f, -0.00364485f, -0.07359993f, 0.03973025f, 0.04795357f, 
    -0.09499401f, -0.09958227f, -0.02894015f, 0.05342449f, 0.06556074f, 0.04755614f, -0.06661278f, -0.09172729f, 
    -0.02170426f, -0.13106069f, 0.04757187f, 0.01679662f, 0.02689675f, 0.06983370f, -0.01902349f, -0.16797222f, 
    -0.03770159f, 0.10068402f, 0.12267217f, 0.23305000f, 0.02664049f, -0.10683515f, -0.14092526f, 0.13269505f, 
    0.05680678f, 0.10414159f, -0.03792023f, -0.06563156f, -0.18517685f, -0.03234403f, 0.00127656f, -0.03324272f, 
    0.09259413f, -0.07698882f, 0.05983434f, -0.03695917f, 0.17743088f, -0.04662992f, -0.04943451f, -0.12246457f, 
    -0.03497535f, -0.08204894f, -0.02280540f, -0.02676235f, 0.06289072f, -0.05721540f, 0.06455849f, -0.09229764f, 
    -0.07902767f, 0.05010045f, 0.03732654f, 0.04927973f, -0.01610927f, -0.02820101f, 0.05724694f, -0.03226917f, 
    0.00615476f, -0.06926588f, 0.02541421f, 0.05265171f, 0.01819150f, 0.10124208f, -0.00370112f, -0.22016838f, 
    -0.11469162f, -0.00687037f, 0.11138351f, 0.16757502f, -0.08950445f, 0.01192093f, -0.09228865f, 0.20935695f, 
    0.01207206f, 0.02556058f, -0.06194405f, -0.03799594f, -0.04863252f, 0.04343002f, 0.04688273f, -0.03706966f, 
    0.00932780f, -0.00677009f, -0.04338744f, -0.04102413f, 0.02940175f, 0.00119292f, -0.00205248f, -0.02819962f, 
    0.02649724f, -0.06613304f, -0.04643260f, -0.03029516f, -0.02459818f, 0.02962568f, -0.05223604f, 0.01061286f, 
    -0.00447010f, -0.01825862f, -0.00077992f, -0.03131095f, 0.01932372f, -0.02088386f, -0.04526531f, -0.01027610f, 
    -0.01931941f, 0.00927409f, 0.05303449f, 0.03800254f, -0.02945721f, -0.04880079f, 0.01844679f, -0.04045419f, 
    0.03567734f, -0.01557795f, -0.00865802f, 0.02574677f, -0.02507169f, -0.06108963f, -0.02728577f, 0.04448245f, 
    0.03655341f, -0.01060843f, 0.01541170f, -0.03270535f, -0.03123715f, 0.01420372f, -0.00045211f, -0.00927356f, 
    -0.04114163f, -0.02115683f, -0.06663298f, 0.04907425f, 0.02377311f, -0.01107298f, -0.04062506f, 0.01552938f, 
    -0.03610084f, -0.02507026f, -0.01868284f, -0.03517615f, 0.04470921f, -0.05308324f, 0.03525805f, 0.03756031f, 
    -0.01978199f, -0.02524970f, 0.02857930f, -0.04383883f, -0.01905890f, -0.00328984f, 0.00092773f, 0.00462134f, 
    0.04183440f, 0.00930139f, -0.03792126f, 0.02864094f, -0.00318750f, 0.04318227f, 0.00594736f, 0.03908907f, 
    -0.03031955f, 0.01023566f, -0.02965160f, -0.01653196f, 0.05027083f, 0.02272735f, -0.06333669f, -0.01081701f, 
    0.04678705f, -0.02747764f, -0.03416884f, -0.00037741f, 0.06332994f, 0.05915935f, -0.00624785f, -0.04034450f, 
    -0.04282230f, -0.03633079f, 0.05285288f, -0.05691044f, -0.05215918f, -0.04502359f, -0.02226232f, 0.04453768f, 
    0.01309389f, -0.06423107f, -0.05708744f, 0.03288423f, -0.04849992f, 0.02053560f, 0.03452509f, -0.04625446f, 
    0.00154188f, 0.02019892f, -0.02968923f, 0.01120665f, 0.00452877f, 0.03710628f, 0.02426222f, 0.04167657f, 
    -0.04543530f, -0.02527987f, 0.04287296f, 0.03657924f, -0.03255587f, -0.05801184f, 0.00995795f, -0.06428079f, 
    0.01517975f, 0.03616047f, -0.03057656f, -0.06509414f, -0.02454100f, -0.05268480f, 0.05467677f, -0.00367658f, 
    0.02765836f, -0.05679094f, 0.00597141f, -0.00446000f, -0.04297489f, -0.04760694f, -0.02392797f, -0.04466246f, 
    -0.06320059f, -0.03040748f, 0.00023517f, -0.02933939f, 0.02801999f, 0.04224641f, 0.02547088f, -0.06262530f, 
    0.03353180f, 0.03015463f, -0.05354444f, -0.04698926f, -0.00379582f, 0.05379120f, -0.00687974f, -0.02835711f, 
    0.03991711f, -0.01572044f, -0.05405733f, -0.00969289f, 0.05183017f, -0.06299361f, -0.02367663f, 0.03342864f, 
    -0.05513497f, 0.01260404f, -0.05865883f, -0.03235483f, -0.03469511f, 0.00259447f, 0.03684382f, -0.05538941f, 
    0.00063830f, 0.02199675f, 0.04598294f, 0.00889746f, 0.00221909f, 0.00395805f, 0.04261121f, 0.02970989f, 
    0.01364273f, 0.01788624f, 0.04634354f, -0.01824066f, -0.04576096f, -0.00093438f, -0.05728757f, -0.05656078f, 
    0.02081585f, -0.04607213f, -0.06250238f, -0.04094785f, -0.05436623f, 0.00596329f, 0.03633248f, 0.00469459f, 
    0.03004207f, -0.00694584f, -0.02302844f, -0.02202480f, 0.01716802f, 0.03679557f, 0.00663220f, 0.00598589f, 
    -0.07112263f, 0.02488603f, -0.06935704f, 0.02539207f, -0.03448246f, -0.00244551f, -0.00890592f, -0.05060858f, 
    -0.05769482f, 0.00920556f, 0.03868265f, -0.04283743f, 0.00864441f, -0.00015146f, -0.02531067f, -0.04436030f, 
    -0.00703857f, 0.04177422f, -0.00728742f, 0.03326236f, 0.01637086f, -0.00513881f, -0.01763467f, -0.03474713f, 
    0.04211430f, -0.05459047f, -0.01838260f, -0.04481867f, -0.00000277f, -0.05254387f, -0.06836423f, -0.05134248f, 
    0.01046295f, 0.02278295f, 0.01168685f, -0.05492525f, -0.03983226f, 0.04476669f, -0.04786252f, -0.02858522f, 
    0.03732956f, -0.05463348f, -0.00450688f, 0.04861903f, 0.00047949f, 0.00092205f, -0.05158445f, 0.01891360f, 
    -0.05188698f, 0.02638248f, -0.01491714f, -0.05519151f, -0.00114776f, 0.03178344f, -0.04201788f, 0.00727911f, 
    0.04791377f, 0.02688608f, 0.03136279f, -0.02427754f, 0.03750271f, -0.02355807f, -0.01405112f, -0.02725733f, 
    0.00449707f, -0.01912469f, -0.00169650f, 0.02000965f, 0.03367085f, -0.01524656f, -0.04237151f, -0.00233586f, 
    -0.07394648f, 0.06208939f, -0.31584868f, 0.12180488f, 0.01844328f, -0.04817504f, 0.04543041f, 0.04132536f, 
    -0.08860472f, -0.10194924f, 0.15531597f, -0.22349694f, 0.03056536f, -0.18779884f, 0.03381669f, -0.09545824f, 
    -0.09245822f, 0.09040362f, 0.07924929f, 0.10673031f, -0.33163956f, 0.08327828f, -0.00529803f, -0.01594532f, 
    0.10490043f, 0.08771660f, -0.13011445f, 0.06404179f, 0.10586123f, 0.28094730f, -0.08740053f, 0.12729417f, 
    -0.04327768f, -0.04983404f, -0.02033103f, 0.02011942f, 0.16239810f, 0.19515006f, -0.03178635f, -0.01470654f, 
    0.05399387f, -0.07430688f, -0.12523027f, 0.08716632f, 0.04505433f, 0.10728879f, 0.03328570f, 0.14824565f, 
    -0.20759466f, 0.01434814f, -0.00317684f, -0.00004046f, -0.02633244f, 0.13027862f, -0.36160135f, -0.25113350f, 
    0.03498898f, -0.04948517f, -0.17574918f, 0.01434055f, 0.08487496f, 0.10847475f, 0.13734722f, -0.01006255f, 
    -0.05471010f, -0.09686815f, 0.18716086f, -0.02600319f, -0.02508815f, -0.02833962f, -0.06660483f, 0.06412420f, 
    -0.03862188f, -0.22629651f, 0.22450806f, -0.16473396f, -0.11390650f, 0.15469579f, -0.12429105f, -0.01148846f, 
    0.10441642f, -0.46595332f, -0.04064352f, 0.12036633f, 0.22581469f, -0.06743772f, -0.00048366f, -0.03864427f, 
    0.08867990f, 0.05902534f, 0.23543805f, -0.03163770f, -0.25145480f, 0.05048293f, -0.05330612f, 0.03755294f, 
    -0.13326070f, -0.13274269f, -0.00861947f, 0.00301512f, 0.07075321f, -0.08038754f, -0.06720185f, -0.05129570f, 
    0.06787061f, 0.14720590f, 0.04278973f, 0.05407236f, -0.26339450f, 0.00295942f, -0.08048099f, -0.07129592f, 
    -0.03558698f, 0.01989464f, 0.05543154f, -0.08945917f, 0.02307305f, -0.00873729f, 0.16126934f, 0.05009504f, 
    0.09992647f, -0.04214441f, -0.14416879f, 0.03108647f, 0.04732995f, -0.16229369f, 0.00708037f, -0.02117990f, 
    -0.17812108f, -0.00910625f, -0.13518447f, 0.07271032f, 0.09256144f, -0.04335480f, 0.13955998f, -0.22651727f, 
    0.04913156f, -0.39040679f, 0.05483325f, 0.02411604f, 0.01057409f, 0.01469705f, 0.11352620f, 0.02332783f, 
    0.10588840f, 0.03710666f, 0.05429825f, -0.10005213f, 0.11368475f, 0.07616749f, -0.09516721f, -0.02556354f, 
    -0.00764854f, -0.04527329f, 0.01805658f, 0.10556470f, 0.02836180f, -0.01282278f, 0.03320353f, -0.01022853f, 
    -0.10330793f, 0.11307302f, 0.04476930f, 0.15634109f, 0.05027507f, 0.11963823f, 0.02881369f, 0.00568033f, 
    0.10415921f, -0.11973342f, -0.05221581f, -0.29643643f, -0.07325498f, 0.16669409f, -0.03556209f, -0.07449666f, 
    0.09656324f, 0.04418555f, 0.13823259f, 0.07578024f, -0.12814674f, -0.02649183f, -0.32439741f, -0.06748957f, 
    0.00316118f, 0.07734665f, 0.03091663f, 0.19174565f, 0.16045509f, 0.16445585f, -0.00004970f, -0.34275016f, 
    0.02340764f, 0.10674153f, -0.02851836f, 0.10511239f, 0.00597197f, -0.07871343f, 0.29393730f, -0.06648750f, 
    0.13115911f, -0.03353453f, -0.12020092f, 0.01399172f, -0.13929684f, -0.14726751f, 0.00450002f, 0.22993930f, 
    -0.00925985f, -0.04797119f, -0.17495149f, 0.11359089f, 0.08240803f, 0.09249241f, -0.01804272f, 0.09651071f, 
    0.03048810f, 0.13473685f, -0.21799691f, 0.14105730f, 0.06169595f, -0.00851599f, -0.05071495f, -0.07607295f, 
    0.00423101f, 0.01903342f, -0.04278693f, 0.05819360f, 0.01429804f, 0.04497706f, 0.02079669f, 0.07371047f, 
    0.01451221f, 0.11682206f, -0.20998967f, -0.19296171f, 0.23560821f, -0.06239208f, -0.08608865f, -0.02615244f, 
    -0.12226082f, -0.04092623f, 0.22191888f, 0.08601691f, 0.24097738f, -0.14567004f, 0.07348026f, 0.10270823f, 
    -0.04024709f, 0.01361373f, 0.08931061f, -0.12223147f, -0.11623376f, 0.17140876f, -0.03749407f, -0.00335044f, 
    -0.01305378f, -0.03086294f, -0.08061931f, -0.03841683f, 0.06299794f, 0.11938382f, -0.11200805f, -0.30458769f, 
    0.03736618f, -0.04575449f, -0.03359625f, 0.09181397f, 0.02512294f, 0.02973669f, -0.13011858f, -0.18079144f, 
    0.17404467f, 0.01172460f, 0.18302618f, -0.09804475f, -0.07050705f, 0.06608623f, 0.06689642f, -0.02265218f, 
    0.05491426f, -0.06089404f, 0.07277817f, 0.09154458f, -0.07235055f, 0.04218489f, 0.06079520f, -0.00570843f, 
    -0.03253871f, -0.05003862f, -0.05761679f, -0.00225863f, -0.05162892f, 0.01887751f, -0.02028100f, 0.01751301f, 
    0.00916107f, -0.05341763f, -0.01334064f, 0.04095962f, -0.02171365f, -0.00209039f, -0.04879272f, 0.05270912f, 
    -0.05677428f, -0.04263421f, -0.02472762f, 0.04458877f, -0.05952496f, 0.01562474f, -0.00886299f, 0.00581434f, 
    -0.05734127f, -0.00029232f, 0.03683014f, -0.00440091f, -0.05820450f, -0.06178359f, -0.06354074f, -0.03812524f, 
    -0.03083098f, -0.02336021f, -0.04865205f, -0.01269308f, 0.01302160f, 0.03585115f, 0.02773174f, -0.00782568f, 
    0.04862634f, -0.06447488f, -0.00226061f, -0.04744646f, 0.00436869f, -0.05078463f, -0.05367960f, -0.02949088f, 
    0.03677607f, 0.02216245f, 0.05185803f, 0.01858205f, -0.06382576f, 0.05039106f, -0.05370851f, 0.02633997f, 
    -0.04377520f, 0.03220739f, -0.06156002f, 0.01321873f, -0.02199273f, -0.03906444f, 0.03097163f, 0.00692044f, 
    -0.01821298f, 0.00637793f, -0.01799759f, -0.04540656f, 0.00774422f, -0.00809359f, -0.04795838f, -0.04171214f, 
    0.00586304f, 0.04188024f, -0.04410907f, 0.01775803f, -0.03344397f, -0.02155596f, -0.00305797f, 0.00778705f, 
    -0.00610348f, -0.02107641f, -0.05486165f, 0.02523605f, -0.05225966f, 0.03759721f, 0.04374936f, -0.05539585f, 
    -0.04285858f, -0.00844121f, 0.03404948f, 0.01860996f, -0.01636166f, 0.00711125f, -0.00341173f, 0.03163872f, 
    0.00000657f, -0.04477442f, 0.03123415f, -0.03173209f, 0.00455161f, 0.00057611f, 0.00128008f, -0.04682228f, 
    0.03429239f, -0.05142161f, -0.03342481f, -0.04122151f, 0.02547416f, -0.02795448f, 0.00610212f, 0.05031550f, 
    -0.03263861f, 0.02205359f, -0.05355116f, 0.04590124f, -0.00695416f, -0.01619318f, -0.03301699f, 0.01804584f, 
    -0.03993032f, -0.06360456f, 0.01753901f, 0.04209137f, 0.02173251f, 0.02881902f, 0.04328235f, 0.03875349f, 
    -0.02001570f, 0.04617725f, -0.04649676f, 0.04258218f, -0.05668748f, 0.00565556f, -0.02593997f, 0.02717665f, 
    -0.00968653f, 0.01787664f, 0.04276876f, -0.04247738f, -0.04667434f, -0.01560653f, -0.02715094f, 0.02123461f, 
    -0.06006553f, 0.00906989f, 0.01169180f, -0.02047723f, 0.00913800f, -0.01326616f, -0.03728338f, 0.03278242f, 
    -0.04414837f, 0.01896053f, -0.02810136f, -0.00705302f, -0.06010241f, 0.00200474f, -0.05263815f, -0.03336516f, 
    -0.05311513f, 0.05038303f, 0.01099927f, -0.00811203f, 0.04797971f, 0.03972701f, 0.01109070f, -0.04472063f, 
    0.03421753f, 0.01809124f, 0.03955097f, -0.02881712f, -0.02145947f, 0.00582165f, -0.05144850f, 0.04424741f, 
    0.00652603f, -0.03910640f, -0.01527747f, -0.03675702f, 0.01898845f, 0.01763919f, -0.04511786f, -0.06185259f, 
    0.05314330f, -0.00261926f, -0.03449549f, -0.00270590f, -0.04410578f, 0.03334032f, -0.05483352f, -0.04037701f, 
    -0.00932741f, 0.04534227f, -0.04644619f, -0.06194620f, -0.06103643f, 0.05186010f, -0.03142966f, 0.05358400f, 
    0.05207761f, -0.04520093f, 0.00350181f, 0.00602361f, 0.00278084f, 0.00670745f, -0.02079257f, -0.04712990f, 
    -0.05198652f, -0.02304679f, 0.01880833f, -0.03380364f, -0.03071390f, -0.03724858f, -0.01149550f, 0.03800465f, 
    -0.03769901f, -0.02115929f, 0.00546064f, -0.01217823f, -0.02506378f, -0.03999543f, 0.03965726f, 0.00022665f, 
    0.00181261f, 0.03478277f, 0.04626942f, 0.05150291f, 0.01394920f, -0.01954488f, -0.03065052f, -0.05546826f, 
    0.02683940f, 0.00816411f, -0.01282498f, -0.05602438f, -0.05275428f, 0.05211984f, -0.03941223f, -0.04427705f, 
    0.05324563f, -0.02693865f, 0.00811841f, -0.04169758f, -0.01757506f, -0.03533613f, 0.01746406f, 0.02864149f, 
    -0.03417354f, 0.03895072f, 0.03825437f, 0.04494976f, -0.05174349f, -0.04581423f, -0.04722604f, -0.00021405f, 
    0.04500224f, -0.02859036f, 0.01828731f, -0.04669724f, -0.03680862f, -0.00071877f, 0.00433992f, -0.04469633f, 
    0.04496058f, -0.02886831f, -0.05779562f, 0.04565456f, 0.03688139f, 0.03495557f, -0.01776515f, 0.02151365f, 
    -0.02882404f, 0.00678429f, 0.03623924f, -0.04617282f, -0.00126507f, -0.00418011f, -0.04412472f, 0.04492637f, 
    -0.05955396f, 0.00150170f, -0.02499701f, -0.00165155f, 0.05170678f, -0.02770966f, 0.02867478f, 0.02778573f, 
    0.16423589f, 0.08470931f, -0.05928870f, 0.00718805f, 0.04274373f, 0.09456567f, 0.15012607f, -0.05032622f, 
    0.24046014f, 0.09759471f, -0.01489030f, -0.02351321f, -0.03534232f, 0.04772393f, 0.14009473f, -0.06433828f, 
    0.07968497f, -0.03190830f, 0.13398416f, -0.19180770f, 0.03130392f, 0.05288582f, 0.12749904f, 0.10278098f, 
    0.05605669f, 0.12238408f, 0.11641833f, -0.15206499f, 0.00414108f, -0.08423617f, 0.01526941f, -0.06818206f, 
    -0.12600900f, -0.02075617f, -0.03119454f, 0.03225049f, -0.29541570f, 0.14303622f, 0.00902646f, 0.04136628f, 
    -0.07085971f, 0.00464709f, 0.04612578f, 0.04787765f, -0.00258681f, 0.02185839f, -0.06626499f, -0.10378182f, 
    0.15956733f, -0.11085845f, -0.08615898f, -0.13951491f, 0.06578214f, -0.18501842f, -0.23305258f, -0.34597969f, 
    0.14011805f, -0.06269813f, 0.08236206f, -0.18224724f, 0.06547294f, 0.05309486f, 0.10473188f, -0.17131335f, 
    0.15605025f, -0.05462635f, 0.06809989f, 0.07761364f, 0.17172112f, 0.15328716f, 0.09307315f, -0.06274659f, 
    -0.09675872f, -0.06833715f, -0.38287362f, -0.07915362f, -0.08405281f, -0.03713062f, -0.01859631f, -0.11940379f, 
    0.03776162f, -0.16428041f, -0.25753951f, 0.15436485f, 0.02846949f, 0.06461401f, 0.03106436f, 0.05531469f, 
    0.07216647f, 0.06907464f, 0.13314226f, 0.11095866f, -0.05042248f, -0.08552674f, 0.08865132f, 0.14533430f, 
    -0.00962601f, -0.17116541f, 0.05706212f, -0.18788281f, 0.06140331f, -0.34648976f, 0.06823416f, -0.12786125f, 
    -0.04387430f, 0.00137971f, -0.02343137f, -0.09028554f, 0.01323006f, -0.12825872f, 0.01927674f, -0.04677025f, 
    -0.13556732f, -0.05704186f, 0.05196372f, -0.15521468f, 0.07147983f, -0.36549813f, -0.01078616f, 0.09278470f, 
    -0.05920778f, 0.05316994f, 0.02860206f, -0.03354567f, 0.04561143f, 0.10356933f, 0.19485387f, 0.09959823f, 
    0.06567980f, 0.14917642f, 0.04049397f, -0.00886653f, 0.02751005f, 0.13048810f, -0.07509904f, 0.11463310f, 
    -0.07083803f, 0.06576239f, 0.12716278f, 0.06207251f, 0.05342210f, 0.13596141f, 0.07757619f, 0.01794010f, 
    -0.24953634f, -0.22565414f, -0.09094448f, 0.01815468f, 0.01742976f, 0.04903960f, -0.13293602f, -0.09993871f, 
    0.14112297f, -0.31614345f, 0.03941013f, -0.12361868f, 0.01534587f, -0.01428971f, 0.08359380f, -0.00174708f, 
    0.11110512f, -0.03524389f, 0.05998150f, -0.07435501f, -0.21857296f, 0.01157951f, 0.10393883f, -0.09134793f, 
    -0.06876838f, 0.07061196f, 0.01608946f, -0.01794934f, -0.13697992f, -0.21652162f, -0.00644130f, 0.04734952f, 
    -0.05806662f, -0.00327632f, -0.01030235f, -0.05724638f, -0.09220696f, -0.08629201f, -0.04108378f, -0.01857407f, 
    0.09684316f, -0.00950376f, 0.33076918f, 0.15377328f, -0.05056653f, 0.11350461f, 0.15798202f, 0.01740004f, 
    0.04635827f, 0.00662045f, 0.01919987f, -0.07213811f, 0.06159185f, 0.14789340f, 0.02014222f, 0.08551615f, 
    -0.28232726f, 0.12272829f, -0.15945856f, -0.10423331f, 0.09172433f, -0.01644091f, -0.09325406f, -0.10987902f, 
    -0.03684101f, -0.04481762f, -0.09422033f, -0.12121865f, 0.02366083f, 0.20014349f, 0.05239469f, 0.01072858f, 
    -0.04322121f, 0.08141865f, 0.10490496f, 0.12201991f, 0.13341483f, -0.00109922f, -0.06433128f, 0.02497060f, 
    -0.02318933f, -0.00945686f, 0.05594551f, -0.22881532f, 0.00355920f, -0.17694958f, -0.07918483f, 0.01829370f, 
    0.02554162f, -0.00564401f, -0.29458696f, -0.42994392f, -0.02927760f, -0.14053489f, -0.00034470f, -0.19551523f, 
    -0.09523691f, -0.03422086f, -0.00473365f, 0.16353537f, 0.13082838f, 0.03140266f, -0.02457021f, 0.01312760f, 
    0.21414682f, 0.05069007f, -0.01625344f, 0.01459433f, -0.38360676f, 0.04754591f, 0.10809415f, 0.06731515f, 
    -0.00973688f, 0.04696347f, -0.06953168f, -0.03170769f, -0.10142058f, -0.04607700f, 0.08010007f, -0.00804950f, 
    0.24207363f, -0.04013865f, -0.03925537f, 0.02372853f, 0.01729053f, -0.00123387f, -0.34936264f, -0.21951213f, 
    0.07758778f, -0.02378370f, 0.14900646f, 0.05855240f, 0.10751669f, -0.05133650f, 0.02140776f, 0.14535634f, 
    0.14840041f, 0.00696957f, 0.02772922f, -0.10424536f, -0.03286288f, 0.08341967f, 0.00438214f, 0.07276859f, 
    0.16109633f, -0.03611210f, -0.16147925f, -0.08226369f, -0.02569772f, 0.11103711f, -0.00547387f, 0.10038726f, 
    0.12030049f, -0.17885056f, -0.11577445f, -0.11572336f, -0.06992032f, 0.01350190f, 0.03923983f, -0.07765845f, 
    -0.04180635f, 0.11087892f, 0.04623510f, 0.04348058f, -0.06283715f, 0.14633457f, -0.03984749f, 0.11310549f, 
    -0.01940238f, -0.07069259f, -0.00111546f, 0.08998773f, 0.01059472f, 0.19363852f, 0.16277103f, -0.02613332f, 
    -0.05870586f, 0.05411297f, -0.02045397f, -0.01850755f, 0.12118699f, -0.01311365f, -0.12684146f, 0.15091233f, 
    0.02830875f, -0.07029053f, 0.04543936f, -0.00991961f, -0.03584445f, -0.05194673f, 0.17406404f, 0.08804176f, 
    0.09321750f, 0.04561665f, -0.03777080f, 0.01240297f, -0.03692039f, -0.11981890f, -0.36727995f, 0.12788647f, 
    -0.11933053f, -0.05646065f, -0.01565841f, -0.01939887f, -0.10290772f, 0.08250654f, 0.06997760f, 0.13042323f, 
    -0.20713662f, -0.10266777f, 0.00835045f, 0.00015014f, 0.04497342f, 0.00032189f, 0.01961589f, -0.07839222f, 
    -0.08491250f, 0.13752988f, -0.00361683f, -0.09996613f, 0.11877014f, -0.11514398f, -0.06324016f, -0.12700589f, 
    -0.12976104f, -0.19828105f, -0.11121336f, -0.11476258f, -0.01470268f, 0.06178820f, 0.05591803f, -0.02634756f, 
    -0.06049501f, -0.02132590f, 0.12210155f, -0.26647964f, 0.05328855f, 0.12855712f, 0.09567368f, 0.09148869f, 
    0.02704911f, 0.02745856f, 0.12035320f, -0.01914726f, 0.02735301f, 0.02260234f, 0.03103139f, 0.00033664f, 
    -0.20531097f, -0.16053563f, -0.07170578f, -0.00990035f, -0.26838624f, -0.04736802f, -0.06107811f, -0.06897597f, 
    -0.10261101f, -0.14498466f, -0.03374352f, 0.13640989f, -0.06718386f, 0.25563887f, 0.08950622f, -0.15840799f, 
    0.13228568f, -0.16557483f, 0.11531352f, 0.17331561f, 0.00912394f, 0.09752715f, -0.08031957f, -0.05424959f, 
    -0.02848915f, -0.01030354f, 0.01353741f, -0.06503319f, 0.07332640f, 0.04929263f, -0.09499391f, 0.12017028f, 
    -0.09424615f, -0.01461926f, -0.00170683f, 0.05053454f, -0.02852569f, -0.07035820f, 0.01443006f, 0.04734852f, 
    -0.06362844f, 0.20694733f, 0.00565688f, 0.03969227f, -0.09283101f, 0.03565677f, 0.00767969f, 0.02629171f, 
    -0.01590540f, 0.15192094f, 0.06554160f, -0.14029817f, 0.06672692f, 0.03437021f, -0.02037384f, 0.09701677f, 
    0.10514177f, -0.08918621f, -0.23382251f, -0.06481655f, 0.01788200f, -0.00158990f, -0.01992585f, -0.02671374f, 
    0.01837176f, -0.02008913f, 0.04873138f, -0.12766843f, -0.11991389f, 0.08367500f, -0.13968900f, 0.07356581f, 
    -0.20221758f, -0.15336815f, -0.06330383f, -0.10758654f, -0.15652430f, 0.06420258f, -0.04252319f, -0.03918239f, 
    0.05994987f, 0.10507064f, -0.14848861f, -0.06549696f, -0.04000502f, 0.13829798f, -0.09941180f, 0.19344169f, 
    0.11696910f, 0.04941566f, -0.04259117f, 0.01416098f, 0.06307966f, 0.13128339f, 0.10592835f, -0.00663369f, 
    -0.12658006f, -0.11444339f, 0.01686030f, -0.03806635f, -0.10853348f, -0.03886693f, 0.06598087f, 0.04404335f, 
    -0.15485536f, 0.16259202f, 0.07305405f, -0.15112056f, -0.09467927f, 0.01321123f, 0.04353280f, 0.04437077f, 
    0.33179495f, -0.10524388f, -0.00291324f, 0.15561776f, 0.06117174f, -0.09487083f, -0.01633266f, 0.01380570f, 
    -0.09727091f, -0.15237503f, -0.31340384f, -0.09447235f, -0.04498316f, -0.03408806f, -0.05889575f, -0.06808819f, 
    0.03570184f, -0.05472919f, -0.24450868f, 0.21913356f, -0.00213466f, -0.04226402f, 0.15693110f, 0.04894405f, 
    -0.05379992f, -0.04290418f, 0.09428386f, 0.35113037f, -0.17470610f, 0.10035676f, 0.13825205f, -0.04447366f, 
    0.00411673f, -0.00073524f, -0.05798756f, 0.00298185f, 0.26966304f, 0.04357678f, -0.21518156f, 0.14648114f, 
    0.01788300f, -0.00951497f, 0.07133447f, 0.14203164f, 0.03904846f, 0.21608934f, -0.04341569f, -0.10267697f, 
    -0.05629143f, -0.05372588f, 0.01882861f, 0.06988233f, 0.03206890f, 0.09981703f, -0.04078075f, 0.33458647f, 
    -0.10066020f, 0.24614301f, -0.01582997f, 0.05617243f, 0.00556647f, 0.06079211f, 0.11419641f, -0.10280354f, 
    0.07496746f, 0.03689935f, 0.03012502f, -0.04550592f, -0.09373738f, -0.02772510f, -0.00388634f, -0.02303739f, 
    -0.05357644f, -0.04630645f, -0.06303758f, 0.03324595f, -0.04095295f, -0.03174765f, 0.04071821f, 0.01916933f, 
    -0.03128064f, 0.02072945f, 0.03941761f, 0.01409836f, 0.00375600f, -0.05578071f, 0.02073608f, 0.03985852f, 
    -0.03370065f, 0.03838235f, 0.01733253f, 0.04618849f, -0.04099224f, 0.03813171f, -0.03270224f, -0.00835652f, 
    -0.04442262f, -0.03647318f, 0.01170092f, -0.06558963f, 0.01858564f, -0.06018349f, -0.03378952f, 0.01213825f, 
    -0.02998046f, 0.02061716f, 0.01187412f, -0.02783090f, -0.00461020f, 0.01903895f, 0.00296485f, 0.04411369f, 
    0.00791128f, -0.03868785f, 0.01179278f, 0.01392802f, -0.03470889f, -0.03706175f, -0.06340368f, 0.04415512f, 
    0.03453979f, -0.00657355f, 0.00548380f, 0.03991748f, -0.01317238f, 0.01433755f, -0.03656946f, -0.04558037f, 
    0.03311821f, -0.03808157f, -0.06118896f, -0.05608591f, 0.04778532f, 0.04249753f, -0.02015902f, -0.02761334f, 
    -0.01940190f, -0.00002908f, -0.03924491f, -0.00882698f, -0.03679707f, -0.05376438f, -0.02400924f, 0.02385611f, 
    0.01279987f, 0.02157574f, -0.00778783f, -0.05789785f, -0.05451483f, 0.02791172f, 0.01454672f, -0.04025056f, 
    0.02567777f, 0.00516760f, -0.05821131f, -0.00498318f, -0.04262770f, 0.03141393f, -0.03250339f, 0.02847574f, 
    0.01698391f, -0.00028135f, 0.00001091f, 0.00425637f, -0.04798514f, -0.04665758f, 0.02548983f, 0.04046740f, 
    0.03413539f, 0.04921389f, 0.01317726f, -0.01884575f, 0.01110343f, -0.00757166f, 0.01479907f, -0.05216843f, 
    0.00287372f, 0.03839203f, -0.06283423f, -0.00791944f, 0.03615440f, -0.04668513f, 0.02363159f, 0.01733223f, 
    -0.02514471f, -0.05164278f, -0.03455485f, 0.01715845f, -0.06562679f, -0.00618309f, -0.03397051f, -0.01779980f, 
    0.02121667f, -0.03669191f, -0.04529691f, -0.07093968f, -0.00188415f, -0.05638188f, 0.02279228f, 0.00339768f, 
    -0.05022932f, 0.03875448f, -0.01773351f, -0.06160348f, 0.00594305f, 0.00970130f, 0.02579600f, -0.05485440f, 
    -0.06185824f, 0.04419262f, 0.01993598f, 0.02171409f, -0.03026538f, 0.03147148f, -0.05133574f, -0.00412175f, 
    -0.04145026f, -0.03874576f, 0.04827563f, -0.00640628f, 0.00729877f, 0.00327012f, 0.02433792f, -0.04718090f, 
    0.02884326f, 0.02954085f, -0.03252670f, -0.02275324f, -0.03937408f, -0.05056623f, 0.01586789f, 0.00025073f, 
    -0.02333748f, -0.03207743f, -0.07193444f, 0.04142052f, 0.02946548f, -0.06012870f, -0.06378702f, 0.03126007f, 
    -0.06179253f, 0.02790339f, -0.06055223f, 0.04029811f, 0.03349651f, -0.01903349f, -0.06542509f, 0.04680964f, 
    -0.00772638f, 0.00108165f, -0.00437595f, 0.00335765f, -0.03024877f, 0.00940984f, -0.01168667f, -0.02978223f, 
    -0.04595054f, -0.05181796f, 0.01305225f, -0.05521673f, 0.03379709f, -0.02922981f, -0.03757171f, -0.06432480f, 
    -0.06590087f, 0.02842424f, -0.03051239f, 0.03950499f, -0.00179876f, -0.05323089f, -0.05986584f, 0.04214031f, 
    -0.05628476f, 0.03023125f, 0.02546884f, 0.02832997f, 0.02185977f, -0.04226126f, 0.02980458f, -0.03761100f, 
    0.03529931f, 0.04017107f, 0.03958869f, -0.04054044f, 0.02424053f, -0.00037708f, -0.04193903f, 0.00144592f, 
    0.04301869f, -0.00126158f, 0.03439560f, -0.04618620f, -0.01491799f, -0.01638791f, 0.04003938f, -0.04691316f, 
    0.01281670f, -0.01823364f, 0.03643470f, -0.05542402f, -0.05927019f, 0.03879463f, -0.01968007f, -0.00451859f, 
    0.01384848f, 0.01634498f, -0.01190670f, 0.02125490f, -0.03524680f, -0.00188690f, 0.00805598f, 0.00000839f, 
    -0.06235913f, -0.03551610f, -0.04681199f, -0.05808095f, 0.00233836f, -0.01226134f, -0.06177665f, -0.03098575f, 
    -0.02365777f, -0.00973727f, -0.01425364f, 0.04312321f, -0.03274724f, -0.00129069f, 0.01345041f, -0.01097930f, 
    0.04614143f, -0.05443301f, -0.00771398f, -0.00210649f, 0.01513971f, -0.01630167f, -0.04677666f, 0.03496269f, 
    0.01653579f, 0.03380613f, -0.01775064f, -0.00677330f, -0.05637589f, -0.04577131f, -0.01308777f, 0.03503052f, 
    0.04852000f, -0.04819312f, 0.01143146f, 0.00991914f, 0.02385213f, -0.04380801f, 0.00304380f, 0.03187555f, 
    -0.02350016f, 0.00870205f, -0.00148814f, -0.06082309f, -0.04161001f, -0.02699056f, -0.01327716f, 0.01400462f, 
    -0.07550367f, -0.03544950f, -0.11941748f, -0.03710463f, 0.17199640f, 0.05967669f, -0.07825620f, -0.05590435f, 
    -0.01417367f, -0.01428888f, -0.13006994f, 0.02785778f, 0.05539262f, -0.04939860f, 0.08726574f, -0.05854040f, 
    0.09146301f, 0.00282051f, 0.07589251f, 0.06055616f, 0.01167011f, 0.10612880f, 0.11313503f, -0.01225643f, 
    0.08077793f, 0.03266221f, 0.19841410f, -0.06259850f, -0.11378446f, -0.02597320f, 0.07511666f, -0.03998704f, 
    -0.03150688f, -0.14235844f, 0.03316431f, 0.05443123f, -0.01007209f, 0.08715700f, 0.12886083f, 0.10243533f, 
    -0.15768288f, 0.05775315f, 0.04795957f, 0.00780413f, 0.00593799f, -0.00567011f, -0.35551873f, -0.05364606f, 
    0.04828305f, 0.10163458f, 0.01494198f, -0.07671244f, -0.02753935f, -0.13728827f, -0.04708966f, -0.11987537f, 
    0.03422322f, 0.11132327f, -0.07542334f, -0.09843677f, 0.06461525f, -0.09186400f, -0.05338173f, -0.14648893f, 
    -0.02519626f, 0.09457266f, 0.19917381f, -0.04434209f, -0.06204118f, 0.09319934f, -0.10453098f, 0.03036236f, 
    -0.15314758f, 0.04023095f, -0.18391578f, 0.14079410f, 0.07913375f, 0.03607346f, -0.05287213f, -0.07383490f, 
    0.01216203f, -0.05181867f, -0.08247475f, 0.11727592f, 0.05279844f, 0.00945039f, 0.09839160f, -0.04653475f, 
    0.09097606f, -0.01438172f, 0.20821574f, 0.13192689f, -0.07177751f, -0.19240001f, -0.08694005f, -0.16246980f, 
    -0.03396035f, -0.01361395f, 0.20579258f, -0.06173675f, 0.10614941f, 0.06624646f, -0.04122972f, -0.17257926f, 
    0.05996842f, 0.01752022f, 0.01678190f, -0.04145875f, 0.11287424f, -0.42112744f, -0.04410614f, -0.32983175f, 
    0.10175006f, 0.11124504f, 0.00333555f, -0.18484862f, -0.07373556f, 0.09178314f, 0.17545666f, -0.07684608f, 
    0.03837366f, 0.03686635f, -0.00630512f, 0.06471574f, 0.00118240f, 0.02141234f, -0.00747537f, 0.01119477f, 
    -0.02048850f, -0.07552896f, 0.04706351f, -0.00770561f, -0.03911274f, 0.00215522f, 0.04865548f, 0.21564792f, 
    0.03008058f, 0.11665574f, -0.16002893f, -0.10680807f, -0.06186357f, 0.12378857f, 0.03151704f, -0.01427373f, 
    -0.05782432f, -0.10941267f, -0.10802946f, 0.08212086f, -0.04057190f, -0.00606259f, 0.04082761f, 0.02789306f, 
    0.02023297f, -0.02907487f, 0.09936953f, -0.09274610f, -0.00459140f, -0.00921398f, 0.15205263f, -0.03994424f, 
    -0.06152978f, -0.00297214f, -0.04200244f, -0.13145943f, 0.22714224f, -0.02681809f, 0.01498055f, -0.18818615f, 
    0.14524102f, 0.02944965f, 0.04410111f, -0.04716132f, -0.21332392f, -0.04577978f, -0.05612957f, 0.12380417f, 
    0.03596139f, -0.07667426f, -0.08361137f, -0.04303276f, 0.06223945f, -0.10090332f, 0.03743207f, 0.09660795f, 
    -0.01073600f, 0.04800643f, 0.01963616f, 0.10209471f, 0.13000409f, 0.20736806f, 0.13848023f, 0.03662131f, 
    -0.08223494f, -0.05198129f, -0.01513356f, 0.17895895f, 0.00517838f, 0.10691429f, -0.23044486f, 0.00202948f, 
    -0.02348150f, 0.12628517f, 0.00345704f, 0.05462223f, -0.06282789f, -0.07241230f, -0.02851917f, 0.05510900f, 
    0.16779041f, -0.13503519f, 0.18689324f, 0.01525289f, -0.11156708f, -0.03240744f, -0.06155054f, -0.06607125f, 
    0.27343401f, 0.26849508f, 0.13011485f, 0.01545046f, -0.24816991f, -0.08478607f, 0.05675564f, 0.05177294f, 
    -0.06814942f, -0.10316166f, -0.00155955f, 0.18235616f, -0.01583156f, 0.09978753f, -0.02193957f, -0.24875753f, 
    0.05659308f, -0.06538671f, -0.02391724f, -0.04621290f, -0.18071991f, 0.17506456f, 0.05278464f, -0.02526960f, 
    -0.01299713f, -0.09732375f, -0.02854684f, 0.18105395f, 0.11757595f, 0.03460833f, -0.06688172f, 0.00611691f, 
    0.05134582f, 0.01632195f, -0.01171956f, 0.01530565f, -0.12853421f, -0.02038014f, -0.03089594f, 0.18730791f, 
    -0.05369129f, -0.10918080f, -0.07139554f, 0.03983075f, 0.10992563f, -0.01970761f, -0.19498274f, -0.19849019f, 
    -0.15086259f, 0.03243625f, 0.08824785f, -0.01617944f, -0.05589947f, 0.01634579f, -0.02863451f, 0.10506722f, 
    -0.04000844f, 0.02629318f, 0.04651850f, -0.08377078f, 0.02408192f, 0.11519651f, 0.01649410f, 0.17940527f, 
    -0.02941325f, -0.00310776f, -0.03489238f, -0.22117242f, 0.08232144f, 0.05440288f, -0.02953423f, 0.00806279f, 
    0.00242432f, 0.02594381f, 0.04089956f, 0.00539914f, 0.00390604f, -0.01241833f, 0.01436976f, 0.02145173f, 
    0.04035370f, -0.02902157f, -0.04285534f, -0.03931095f, -0.06346532f, 0.00619833f, -0.05996211f, -0.00515656f, 
    0.05121396f, -0.00268436f, -0.00245407f, -0.05164714f, 0.06358049f, 0.04632603f, 0.02920845f, 0.04113835f, 
    0.00949695f, 0.01553539f, -0.00048278f, -0.03613596f, -0.04417526f, -0.04399480f, -0.04539990f, 0.02419236f, 
    0.03970315f, 0.00431287f, 0.02069723f, 0.02338965f, 0.02045175f, -0.03857620f, 0.02680075f, -0.02000103f, 
    0.02627407f, -0.04432632f, -0.05047315f, -0.02678795f, -0.04866827f, 0.04762832f, -0.00181652f, 0.04941727f, 
    0.00923856f, -0.05484190f, -0.01297559f, -0.00133888f, 0.04666829f, -0.01668321f, -0.06330292f, -0.04307827f, 
    -0.03765086f, -0.05891879f, -0.02935221f, -0.01517292f, 0.04730971f, -0.04626951f, -0.01468306f, 0.03012449f, 
    -0.00803968f, -0.01542762f, -0.04931450f, 0.02891311f, -0.04604087f, -0.04924699f, -0.02472549f, -0.00414340f, 
    0.02591252f, 0.04202330f, 0.00889270f, 0.06124779f, -0.01015805f, 0.02684765f, 0.04698938f, -0.05744077f, 
    0.02262674f, 0.01141242f, 0.02752280f, -0.00867566f, -0.06119614f, -0.02922520f, 0.03299188f, 0.02839768f, 
    -0.02753006f, 0.00008023f, -0.00045122f, 0.05148357f, -0.03870020f, 0.03682584f, -0.01029620f, -0.00572498f, 
    0.01057175f, 0.02826120f, -0.01349254f, 0.01561738f, 0.01357330f, 0.00089202f, 0.02845743f, -0.04875517f, 
    -0.00895966f, -0.02949166f, -0.04778039f, -0.01556092f, 0.02798209f, 0.00202765f, 0.00255527f, -0.05475758f, 
    -0.03108255f, -0.05044888f, -0.05091952f, -0.05964530f, 0.03102937f, 0.00113410f, -0.05402627f, 0.02982606f, 
    -0.03702188f, 0.02202689f, 0.01949918f, -0.05751654f, -0.04561038f, -0.04237573f, 0.04060458f, 0.04694243f, 
    0.00411577f, -0.04110132f, -0.03073715f, 0.04411758f, -0.04005872f, -0.03874898f, 0.04997448f, -0.03651969f, 
    -0.04285679f, -0.05778885f, -0.02230070f, 0.03331927f, -0.00286253f, -0.02573744f, 0.03028461f, 0.03321688f, 
    0.05259368f, 0.04039614f, -0.00529209f, -0.04716628f, 0.01762614f, -0.01824890f, -0.03392801f, -0.04106004f, 
    -0.02549960f, -0.01502207f, -0.00313628f, -0.02566613f, -0.04377978f, 0.04982498f, -0.06203950f, 0.00798599f, 
    -0.02183066f, 0.01582376f, -0.01860489f, -0.05429127f, -0.01308995f, -0.03619512f, -0.03049560f, 0.02701664f, 
    0.02476642f, -0.03025740f, -0.05419787f, -0.04824126f, 0.04994183f, -0.03418425f, -0.03157043f, 0.05021977f, 
    0.04578382f, 0.00067544f, -0.04987530f, -0.04955912f, 0.02302766f, -0.00295894f, 0.02954862f, 0.01350639f, 
    0.00572870f, -0.06320902f, 0.02246362f, 0.04776697f, -0.05691161f, -0.00862414f, 0.03293131f, -0.04079682f, 
    0.01536759f, -0.04368981f, -0.05896433f, -0.01656633f, -0.01976430f, -0.06243661f, -0.03600231f, 0.04024312f, 
    -0.03030748f, 0.04431280f, 0.00697542f, -0.06039796f, -0.00704067f, -0.05189382f, 0.02517052f, 0.02369830f, 
    0.04222332f, -0.00317767f, -0.05776137f, 0.01464372f, -0.03669520f, 0.04875188f, 0.04423396f, 0.04152598f, 
    -0.06260880f, -0.02492641f, 0.01089182f, 0.04048816f, 0.01426198f, -0.00111482f, -0.00249527f, -0.05244846f, 
    -0.00719226f, -0.02533741f, 0.00761389f, -0.02424686f, 0.04300241f, -0.02867506f, -0.02437432f, 0.02274252f, 
    -0.04609632f, -0.01612284f, 0.04949971f, -0.04725581f, 0.06367712f, 0.00336165f, 0.03921119f, 0.02791463f, 
    -0.05034107f, 0.01527317f, 0.04367447f, 0.01861982f, 0.04365308f, -0.03826720f, -0.02272191f, 0.04678936f, 
    -0.01102765f, -0.05267889f, -0.03032805f, 0.05114023f, 0.00693649f, -0.03034445f, -0.04845643f, 0.03762404f, 
    0.04291624f, -0.00491172f, 0.00708142f, -0.03729530f, 0.05160724f, -0.00744634f, 0.00887740f, 0.01821096f, 
    -0.04321642f, 0.01244748f, -0.00428331f, 0.00200070f, 0.03821195f, 0.05131425f, 0.02008756f, -0.01177760f, 
    -0.02988517f, -0.04167863f, -0.05074401f, 0.01780731f, -0.04473142f, 0.03127209f, -0.04284197f, -0.05938517f, 
    -0.03587571f, 0.00690053f, -0.05308281f, -0.02529315f, -0.06197165f, -0.03952225f, 0.02724227f, -0.01956489f, 
    0.09229956f, 0.08125748f, 0.00962551f, -0.01872243f, -0.01564119f, 0.02796264f, -0.10380337f, -0.10185902f, 
    0.00469191f, -0.01036552f, 0.02157373f, -0.07280249f, -0.08099540f, -0.01976650f, -0.04962903f, -0.05111685f, 
    0.07032561f, 0.00639428f, 0.08444674f, -0.03225408f, -0.01957428f, -0.02524998f, -0.19475499f, 0.00780572f, 
    -0.12019555f, 0.00381476f, 0.03820075f, 0.09399682f, -0.12674968f, -0.07545445f, -0.17070924f, 0.01477404f, 
    -0.09294704f, 0.03818627f, 0.06174010f, 0.08735113f, -0.16894467f, -0.13248073f, -0.03013708f, -0.13485707f, 
    0.13224684f, -0.01513716f, 0.01918894f, -0.03189908f, -0.05047965f, 0.14809576f, 0.07469021f, -0.01492370f, 
    0.00030355f, 0.01706262f, -0.15660255f, 0.06270518f, 0.04625082f, -0.00516106f, -0.02451156f, 0.08955351f, 
    -0.06796248f, 0.01883147f, -0.05444202f, 0.04416318f, -0.09273276f, -0.03812470f, 0.19941236f, 0.22171713f, 
    0.05571944f, 0.05021730f, -0.13940431f, 0.04029602f, 0.03474787f, -0.02731744f, -0.05655254f, -0.18812293f, 
    0.27493787f, 0.08510071f, -0.03453752f, -0.03840418f, 0.03491771f, -0.09257528f, -0.06999833f, -0.02846070f, 
    0.02874715f, 0.07411512f, -0.04061991f, 0.06197807f, 0.05384731f, 0.01848007f, 0.09471020f, -0.01501717f, 
    0.02960334f, -0.11989243f, -0.38992819f, -0.25781256f, 0.16241360f, 0.08394086f, -0.07280601f, -0.11918731f, 
    0.04461075f, -0.05389896f, 0.06870373f, -0.15192781f, -0.12540394f, 0.08501344f, 0.07425170f, 0.02106480f, 
    -0.03280554f, 0.00086684f, 0.03673186f, -0.06038116f, -0.18094023f, -0.06812985f, -0.07349055f, 0.17565148f, 
    -0.08101930f, -0.08328100f, 0.08022363f, 0.03311256f, -0.01182938f, 0.04157205f, 0.07586407f, 0.03654486f, 
    0.03249404f, 0.03718321f, 0.05111395f, -0.05325547f, 0.00991596f, -0.06138583f, -0.14142005f, -0.25492358f, 
    -0.15623094f, -0.01406141f, 0.04284292f, -0.00330567f, 0.11239904f, 0.02267770f, 0.13540989f, -0.17091838f, 
    -0.07273505f, 0.08222429f, 0.06049794f, 0.13543437f, -0.02388075f, -0.19722734f, -0.01633398f, -0.03673824f, 
    0.05540675f, 0.06816818f, -0.07491057f, 0.00840265f, 0.06587943f, 0.08919151f, -0.16352119f, -0.01630661f, 
    0.04525554f, -0.05640424f, 0.04723587f, 0.05216494f, 0.07274034f, 0.02379778f, 0.10672271f, -0.07087296f, 
    0.07334071f, -0.16233698f, -0.25737402f, -0.12869063f, 0.05040485f, -0.03999568f, 0.05080309f, -0.10536546f, 
    0.02589281f, 0.05678833f, 0.20923175f, 0.01773467f, -0.03625949f, 0.21896882f, 0.11309990f, 0.04564600f, 
    0.01066502f, 0.06121841f, -0.03810941f, -0.01485771f, -0.07612828f, 0.10285001f, 0.01630213f, -0.02000847f, 
    0.08785791f, 0.02604380f, -0.11391138f, -0.03491411f, -0.04803440f, -0.12317117f, -0.10703736f, -0.04307770f, 
    0.16350096f, -0.18891002f, 0.04663007f, -0.11642531f, 0.08039941f, 0.15115735f, 0.21283567f, 0.19647445f, 
    -0.11853521f, -0.00348521f, 0.03026465f, -0.05409685f, 0.05289754f, -0.04107091f, -0.12301181f, 0.09217916f, 
    -0.03823026f, -0.01225380f, 0.08508787f, -0.18626031f, -0.09461617f, 0.15955234f, 0.00824515f, -0.01302723f, 
    -0.57195520f, -0.14264755f, -0.03771007f, 0.11333468f, 0.17528455f, -0.02045960f, -0.09899792f, 0.07584746f, 
    -0.04637713f, -0.06037736f, -0.03362957f, -0.16758828f, -0.05780106f, -0.02203692f, -0.13698925f, -0.04834363f, 
    0.03951593f, 0.13318457f, 0.08171193f, 0.22744240f, 0.11020841f, -0.07698309f, 0.06441895f, 0.17764416f, 
    -0.00037501f, 0.04289484f, -0.01428606f, -0.29721954f, -0.00608653f, 0.05076006f, 0.05073745f, -0.07797732f, 
    -0.04823915f, -0.01973948f, 0.04970285f, 0.14261188f, 0.23188014f, 0.06601373f, 0.17115156f, 0.01929015f, 
    -0.08582871f, 0.00204150f, -0.10531548f, 0.11343437f, -0.03317472f, -0.19875577f, 0.01082225f, -0.08276935f, 
    -0.04611281f, 0.03905773f, -0.00042776f, 0.14447458f, 0.06450449f, 0.01766565f, 0.01282882f, 0.15540056f, 
    0.18432748f, 0.06359789f, 0.05372465f, -0.09930161f, -0.10733003f, 0.08307604f, -0.07726272f, -0.16611780f, 
    -0.14198075f, 0.04759973f, 0.04006772f, 0.07144982f, -0.11153119f, 0.03906864f, 0.00458980f, -0.01496741f, 
    -0.01723934f, 0.10074250f, 0.03330264f, -0.06051560f, 0.03732958f, 0.04053804f, -0.04306401f, -0.06466149f, 
    -0.00332127f, 0.33511782f, -0.07875976f, 0.03559775f, -0.15461227f, -0.00968644f, -0.05260081f, -0.00780007f, 
    -0.05586027f, -0.05760578f, 0.27639920f, 0.02878879f, 0.01589549f, -0.08430303f, 0.11349639f, 0.05557114f, 
    0.04805508f, 0.08949877f, -0.09347431f, 0.03243465f, 0.02942541f, -0.16938841f, -0.01643242f, -0.05236948f, 
    0.06791631f, 0.06811173f, 0.09093430f, 0.03955799f, 0.19970274f, 0.02671923f, -0.18106332f, 0.03400425f, 
    -0.03352139f, 0.05150540f, -0.08107587f, 0.04214435f, -0.05734837f, 0.00027638f, 0.11952156f, -0.02342506f, 
    0.05995177f, -0.03046013f, 0.07635777f, 0.01550606f, 0.04728543f, 0.01688039f, 0.06335670f, 0.05427269f, 
    0.01074472f, -0.03951598f, -0.07046647f, -0.00067762f, 0.00886202f, -0.03835069f, 0.12572445f, 0.24067570f, 
    -0.06493359f, -0.08175328f, -0.08549552f, 0.15925334f, 0.04797345f, -0.13538961f, -0.11082262f, -0.01757878f, 
    0.08013525f, -0.03745227f, -0.23424272f, -0.00470904f, -0.16784286f, -0.00739177f, 0.07569625f, 0.12699586f, 
    -0.01184260f, 0.27177459f, 0.00641248f, 0.02039807f, 0.05610532f, 0.07914958f, 0.03023399f, 0.00729349f, 
    0.01332193f, 0.02458396f, -0.03366050f, -0.22430515f, 0.10617331f, -0.08328293f, 0.04778623f, 0.00575470f, 
    -0.12346356f, -0.03009432f, 0.04490456f, 0.01391683f, 0.00598594f, -0.21842510f, -0.05065782f, -0.09814572f, 
    -0.06687460f, 0.12054384f, 0.12038708f, -0.02388830f, -0.10908303f, 0.04885956f, 0.00744652f, 0.05332036f, 
    -0.05607696f, 0.01064359f, 0.04667730f, 0.00167346f, 0.07266452f, -0.05732963f, 0.07717766f, -0.14268865f, 
    -0.09329663f, -0.17202051f, 0.01452776f, 0.01479068f, 0.13050579f, 0.09615730f, -0.09841590f, -0.17071141f, 
    -0.03203524f, -0.03932102f, -0.04559219f, 0.08781326f, 0.02986348f, 0.00619231f, 0.02471394f, 0.12044529f, 
    -0.29704103f, 0.00220522f, 0.12081088f, 0.01293053f, 0.09580430f, -0.04720077f, 0.02647123f, -0.01377061f, 
    -0.02072710f, 0.04603535f, -0.17964797f, 0.08701725f, 0.00748513f, 0.07137096f, -0.11159573f, 0.03585433f, 
    0.01809251f, -0.09885920f, 0.15345372f, 0.00269694f, -0.01861110f, -0.02009793f, 0.02623023f, 0.03639565f, 
    0.09473535f, -0.10098286f, -0.15807110f, -0.15345374f, 0.08274595f, -0.02424562f, -0.02805822f, 0.09305038f, 
    -0.01203916f, -0.00839877f, 0.10182562f, -0.06449915f, 0.06006401f, 0.07941407f, -0.06975215f, -0.10920823f, 
    0.03718918f, 0.02755469f, 0.02611645f, -0.10494610f, -0.10257635f, -0.07283095f, -0.05473343f, -0.08354439f, 
    0.02668383f, 0.05596814f, -0.08112542f, -0.01428204f, 0.04082058f, 0.07033140f, -0.42126733f, -0.08498591f, 
    0.08618823f, -0.08293585f, 0.09431724f, -0.09106322f, 0.03049641f, 0.01819780f, 0.05212837f, 0.04714321f, 
    -0.05859896f, -0.05980734f, 0.11360833f, -0.10567228f, 0.00445268f, 0.04770723f, 0.04011121f, -0.01143163f, 
    -0.04830544f, -0.16153070f, -0.01209335f, 0.02489409f, -0.04246858f, 0.18528160f, -0.06665434f, 0.01387516f, 
    -0.08789448f, -0.36980724f, 0.12005415f, 0.07390998f, 0.04247861f, 0.02515038f, 0.00110109f, 0.00383412f, 
    -0.06295726f, -0.16511792f, -0.01412011f, -0.17143266f, 0.00250233f, -0.03925717f, -0.09760492f, -0.09199780f, 
    0.10546570f, -0.04166184f, -0.08912420f, 0.18376958f, -0.11041602f, -0.06692190f, -0.15360102f, 0.00413760f, 
    -0.04725160f, 0.06679436f, -0.03272618f, 0.14596120f, -0.27498129f, -0.07166412f, 0.02078633f, 0.00345126f, 
    0.12308247f, 0.05852648f, -0.01786681f, -0.12217983f, 0.32854924f, -0.00865484f, -0.03455163f, 0.07698609f, 
    -0.01200114f, -0.01695997f, -0.05733928f, -0.00870498f, 0.03087952f, -0.00413300f, -0.01353846f, -0.13353316f, 
    -0.04183579f, 0.09764269f, 0.09049713f, 0.14177017f, 0.06542845f, 0.06561770f, 0.05322035f, 0.13333930f, 
    -0.00268779f, 0.04160112f, 0.02187046f, -0.00845169f, 0.02693826f, 0.11997404f, 0.03253542f, -0.33279020f, 
    -0.33625078f, -0.04768260f, 0.11002712f, 0.13616136f, -0.01298613f, 0.13142659f, 0.21374875f, -0.03379470f, 
    -0.08357819f, 0.08318193f, 0.01993611f, -0.08150984f, 0.01991178f, -0.04651686f, -0.06692851f, -0.10707278f, 
    -0.02515943f, 0.08166573f, 0.24509329f, 0.12841776f, -0.11192471f, -0.02968642f, 0.06553139f, -0.06761809f, 
    -0.02727901f, 0.15744120f, -0.07933248f, 0.09657538f, -0.03767919f, -0.00400974f, 0.10133511f, -0.20585541f, 
    -0.00127289f, 0.10150813f, 0.03600765f, -0.04397103f, 0.17488563f, 0.00782768f, -0.17732294f, 0.01210621f, 
    0.09364954f, 0.01147998f, 0.13127510f, 0.02002482f, 0.07897481f, 0.07613444f, -0.05102871f, -0.12453729f, 
    -0.10376791f, 0.05438795f, 0.03551609f, 0.08897632f, 0.00182245f, 0.27298212f, -0.05915581f, -0.02141136f, 
    -0.08123426f, -0.01197247f, 0.01447603f, 0.17100281f, -0.06042955f, -0.08058581f, 0.12560138f, -0.00808075f, 
    -0.09026423f, 0.14199492f, -0.05846295f, 0.05046916f, -0.10115588f, 0.08558746f, -0.07060869f, 0.06644277f, 
    0.15237834f, 0.25899065f, 0.13330911f, -0.00478908f, 0.00471153f, 0.01529475f, -0.09456437f, 0.03350095f, 
    0.02490280f, 0.00078394f, 0.11918608f, 0.00697727f, 0.03650521f, 0.03666002f, 0.08991855f, -0.11585313f, 
    0.14233357f, -0.03596716f, 0.05116540f, -0.08976639f, -0.02800886f, 0.02156394f, -0.13307549f, -0.06478892f, 
    -0.00508001f, 0.14610133f, -0.24693236f, 0.00741082f, 0.14052942f, -0.18282302f, -0.03230076f, 0.04478512f, 
    -0.12908325f, 0.02904083f, -0.07661667f, -0.07617176f, 0.13461635f, 0.05372353f, 0.08605044f, 0.03832939f, 
    0.03429863f, 0.01843470f, 0.11938538f, -0.13175884f, 0.12736052f, 0.09011971f, 0.05359230f, -0.14351238f, 
    -0.05021798f, 0.04735159f, -0.00870578f, -0.09012950f, -0.07358883f, 0.05444279f, -0.15253575f, 0.01462344f, 
    0.05352040f, 0.04674568f, -0.11358433f, 0.00395563f, -0.01224259f, 0.00569433f, 0.01877205f, -0.04182005f, 
    0.06649356f, 0.02508645f, 0.02995113f, 0.08458138f, 0.05622151f, 0.04519714f, -0.05605644f, -0.11119854f, 
    0.08834902f, -0.08195286f, -0.00045744f, -0.01885523f, 0.04518908f, 0.07535231f, 0.03072412f, 0.02081394f, 
    0.15219012f, -0.15765749f, -0.08041457f, -0.03207199f, -0.08487167f, -0.04100550f, -0.01528646f, 0.03707734f, 
    -0.10149577f, 0.01344503f, -0.17592148f, 0.08201844f, 0.08794673f, -0.06000696f, 0.03896595f, 0.02607482f, 
    0.01276742f, -0.00601102f, -0.10005055f, -0.01898776f, -0.05263046f, 0.03249759f, 0.04087203f, -0.01994231f, 
    -0.00998407f, 0.00332734f, 0.04025051f, 0.09436383f, 0.11976633f, 0.09437346f, -0.12841828f, -0.10726248f, 
    0.09650874f, -0.03068737f, -0.04994839f, 0.06978285f, 0.10897587f, -0.04170472f, 0.06053358f, 0.09618916f, 
    0.00541844f, 0.04434275f, 0.01841662f, -0.10190258f, -0.01899300f, -0.16215719f, 0.08041353f, -0.03265671f, 
    -0.06589705f, -0.03341052f, -0.11874200f, -0.05181451f, -0.05446712f, -0.00260509f, 0.04417429f, 0.08438767f, 
    0.39851472f, -0.03060535f, -0.01291102f, 0.05921084f, -0.00894614f, -0.07180806f, 0.00698754f, 0.05680783f, 
    0.11047286f, 0.00233617f, -0.10913008f, 0.03534937f, -0.11227296f, 0.14314879f, 0.09475160f, -0.06197941f, 
    0.12654389f, 0.02577416f, -0.02450716f, 0.01265722f, 0.03840028f, 0.07023073f, 0.01375919f, -0.03073113f, 
    0.11795881f, -0.06287383f, 0.00613200f, 0.09148613f, 0.00951847f, 0.03314140f, 0.05906055f, 0.02168154f, 
    0.01255985f, -0.22785118f, 0.11659528f, -0.13015997f, 0.02613949f, 0.09506301f, -0.05192121f, -0.00829946f, 
    0.05455185f, 0.05319367f, -0.10358818f, -0.23171045f, 0.04366759f, -0.16825303f, -0.10254192f, 0.11369506f, 
    -0.02838832f, 0.00418176f, -0.05488545f, -0.15129605f, -0.05372368f, 0.02264801f, 0.04374819f, 0.07995310f, 
    0.02914175f, 0.08159302f, 0.00253239f, 0.03266348f, 0.16832632f, -0.16097142f, 0.07443371f, -0.13334024f, 
    0.03965084f, -0.00378843f, 0.05375938f, -0.05369547f, 0.03297488f, -0.10678201f, 0.15984865f, -0.03643925f, 
    0.17062305f, 0.05713162f, 0.07076441f, 0.02593533f, 0.00031935f, -0.08289903f, 0.06295489f, -0.03900960f, 
    -0.11231104f, -0.19574495f, -0.07891503f, 0.10245860f, 0.17069401f, 0.13195318f, -0.11706768f, -0.04154574f, 
    0.00573959f, 0.05263853f, -0.01273430f, -0.01266729f, 0.04864096f, 0.04379998f, -0.04470538f, 0.00875018f, 
    -0.05821523f, -0.00547281f, 0.01857541f, -0.05071418f, -0.02933409f, 0.04527051f, 0.05144150f, -0.06214315f, 
    -0.05249167f, -0.01358978f, -0.05519934f, -0.03441932f, -0.00659411f, -0.05480711f, -0.04211482f, 0.01648137f, 
    -0.03403871f, 0.01613217f, 0.03759604f, -0.02840308f, 0.02468225f, -0.02648741f, 0.04206554f, -0.03782040f, 
    0.03565353f, 0.01345228f, -0.05781622f, -0.02517161f, -0.05929036f, 0.04406349f, 0.02952077f, 0.01474024f, 
    -0.04318110f, 0.00933296f, 0.04979976f, -0.03736419f, -0.05134901f, -0.00504187f, 0.00743481f, 0.00286022f, 
    -0.04512142f, 0.04666545f, -0.05134856f, 0.00163006f, 0.02386872f, -0.06047480f, -0.04176870f, -0.05887556f, 
    -0.05663827f, -0.01648074f, -0.00451252f, -0.05431116f, 0.00614117f, -0.03210941f, 0.02878218f, 0.01046733f, 
    -0.00184480f, 0.03141455f, 0.04474944f, 0.03477505f, 0.04787072f, 0.04409335f, 0.02805880f, -0.02764495f, 
    -0.06185203f, 0.04936889f, -0.02219175f, -0.01070260f, -0.02191027f, -0.03822956f, 0.02002028f, 0.03983513f, 
    -0.02479255f, -0.05307586f, 0.00244230f, 0.03810209f, 0.03317171f, -0.00641967f, 0.00732219f, 0.02998749f, 
    -0.05062434f, -0.01778171f, 0.00546068f, -0.02254795f, -0.04573966f, -0.00205606f, 0.00921293f, 0.01698032f, 
    0.02902407f, -0.04377953f, -0.03838309f, 0.03384572f, -0.00664801f, -0.02728891f, -0.06422605f, 0.00167939f, 
    -0.04095633f, -0.04713337f, 0.04176838f, 0.01465158f, -0.01091973f, -0.00446230f, -0.04077182f, -0.04832210f, 
    -0.03513541f, 0.02030462f, -0.02870291f, 0.01751916f, 0.00262904f, -0.05989392f, -0.01540243f, 0.04047003f, 
    -0.05506839f, -0.06372741f, 0.05041194f, 0.00815155f, -0.02041129f, -0.03724090f, 0.01986393f, 0.00562278f, 
    0.01107200f, -0.06336294f, 0.03484631f, -0.00950570f, 0.02517175f, 0.04526678f, -0.05478966f, -0.06472057f, 
    -0.03603608f, -0.01743182f, -0.03766365f, -0.02789170f, -0.05151291f, -0.00520887f, 0.01638743f, -0.05661086f, 
    0.00392010f, 0.01949473f, 0.03349994f, 0.04430829f, -0.00516188f, 0.04542296f, -0.05233153f, -0.00348163f, 
    -0.01596688f, -0.01169237f, 0.04687375f, -0.04985876f, 0.04309431f, -0.01052785f, 0.01501472f, -0.00191728f, 
    -0.02820863f, 0.02638327f, 0.04665607f, 0.04535067f, 0.03007122f, 0.04687337f, 0.03576259f, -0.04729185f, 
    -0.03640772f, -0.04552179f, -0.05750612f, -0.01449549f, 0.05504593f, -0.00842346f, 0.02582004f, 0.00874839f, 
    -0.04338732f, 0.00261401f, -0.06120953f, -0.03399996f, 0.02129861f, 0.02375608f, 0.01180070f, -0.03482078f, 
    0.00898271f, -0.00118263f, -0.01710059f, -0.03582047f, 0.04394342f, -0.02986368f, -0.01279920f, 0.04746942f, 
    0.03146619f, 0.03741125f, -0.05850669f, 0.00552053f, 0.03661129f, 0.02116235f, 0.01417260f, 0.01339590f, 
    0.01771168f, -0.03513115f, 0.03569556f, 0.00417814f, 0.04308096f, 0.04820910f, 0.03945385f, -0.00653866f, 
    -0.01488391f, 0.02347092f, 0.00657959f, 0.02958847f, -0.00061469f, 0.01722247f, -0.02662399f, -0.04904111f, 
    0.00375213f, -0.03319698f, -0.04229369f, -0.02752585f, 0.01736793f, -0.02105301f, -0.01858973f, -0.01387036f, 
    -0.02003527f, -0.00930529f, -0.00218914f, 0.02698203f, 0.00437842f, 0.04267620f, -0.02115482f, -0.01207562f, 
    -0.05808635f, 0.01827039f, -0.01414590f, 0.02443387f, 0.02970675f, 0.02043521f, -0.03349016f, 0.04369676f, 
    0.05294546f, -0.05296675f, -0.02045770f, 0.03101739f, -0.00762148f, 0.02950217f, -0.04812109f, 0.02837944f, 
    -0.04327717f, -0.01926619f, -0.06252959f, -0.01460454f, 0.05760050f, 0.04672874f, 0.03186010f, -0.02196294f, 
    0.04750074f, -0.03070891f, 0.04024617f, -0.04648768f, 0.04931430f, 0.03025188f, 0.04918751f, -0.03487695f, 
    -0.05383067f, 0.00025246f, -0.04149679f, -0.04546952f, -0.03888631f, 0.04361311f, -0.02444083f, 0.03726992f, 
    0.03846280f, 0.01959150f, 0.05070385f, -0.05744153f, -0.06286570f, -0.00578612f, 0.05314039f, -0.04729079f, 
    -0.06643653f, -0.00101949f, 0.03746909f, -0.06689925f, 0.02074226f, -0.01189268f, -0.06481563f, -0.06100918f, 
    -0.04097219f, 0.09469780f, -0.05334781f, 0.10457835f, 0.05469370f, 0.07373422f, -0.12817074f, 0.02964543f, 
    -0.04738244f, -0.15628952f, -0.10604790f, -0.11702119f, 0.03480723f, 0.09020604f, -0.15667205f, -0.15450783f, 
    0.05778263f, 0.13372768f, -0.14212833f, 0.06505786f, -0.03598084f, 0.11010712f, 0.06208809f, -0.02003764f, 
    0.01212462f, 0.04636405f, 0.08882321f, -0.08937628f, -0.40484133f, -0.19772637f, -0.08571937f, -0.03679975f, 
    -0.08889212f, 0.01486877f, 0.08154812f, -0.10717642f, 0.14591572f, -0.36493796f, 0.13868703f, 0.00402729f, 
    -0.16657799f, -0.00220242f, -0.08179298f, 0.08352438f, 0.05217063f, -0.12197685f, -0.03841759f, 0.16533197f, 
    0.00291078f, -0.03789766f, -0.05633253f, 0.03522921f, -0.13503879f, -0.05400139f, -0.07565521f, -0.08602836f, 
    -0.23092246f, 0.12593366f, 0.07258344f, 0.12579888f, 0.03593130f, 0.02004429f, 0.07545704f, -0.20744535f, 
    0.03440501f, -0.19917576f, -0.01833341f, -0.03184526f, 0.02973505f, 0.09667760f, -0.04725958f, -0.10445237f, 
    0.47354338f, -0.01974713f, -0.14997271f, 0.02106339f, -0.06975469f, 0.06590681f, 0.02303458f, -0.10895081f, 
    -0.01079584f, -0.05589965f, 0.15050551f, -0.10350804f, 0.06909066f, 0.07665989f, 0.15973420f, -0.08759629f, 
    0.06784943f, 0.03482957f, 0.30734625f, 0.11623108f, 0.02298311f, -0.04073687f, -0.22942281f, 0.01409817f, 
    0.06130210f, 0.00809583f, -0.08817787f, -0.13576597f, -0.13662983f, -0.04679370f, 0.05191892f, -0.07365970f, 
    0.03648848f, 0.07909720f, -0.06014924f, 0.25969872f, -0.02860102f, 0.03179509f, -0.04757145f, -0.12604438f, 
    0.13347104f, 0.07005195f, 0.08008470f, 0.02343144f, -0.00453290f, -0.16485907f, -0.07182884f, 0.05130709f, 
    0.08462676f, 0.16168807f, -0.04228666f, 0.02280916f, 0.10552993f, 0.09706981f, -0.06281635f, 0.14775874f, 
    0.10403809f, -0.12123512f, 0.04293758f, 0.09629981f, 0.00405608f, -0.02405924f, -0.00422751f, 0.18203193f, 
    0.19571449f, -0.02863520f, -0.11780738f, 0.06629044f, 0.04333952f, -0.02656446f, -0.04802683f, -0.00502756f, 
    -0.10597800f, 0.18995589f, -0.00753764f, 0.15261316f, -0.06568589f, -0.02307471f, 0.05775308f, -0.10807369f, 
    -0.34636024f, 0.24187391f, -0.15451421f, 0.03480687f, -0.14199910f, 0.13416988f, 0.18160501f, -0.05873309f, 
    -0.01126050f, -0.09330697f, -0.08514332f, 0.10400180f, -0.17973658f, -0.02219866f, -0.16637532f, -0.11738360f, 
    0.00950439f, -0.00136805f, -0.03007984f, 0.21267335f, -0.11007366f, -0.19944693f, 0.05125600f, 0.06756331f, 
    0.08968981f, -0.01871311f, -0.11043089f, 0.07003492f, 0.11104623f, -0.05543227f, 0.02238514f, 0.04833360f, 
    0.02124838f, 0.07891789f, 0.16928619f, 0.11055700f, -0.07045137f, -0.02644921f, 0.07022087f, 0.09793253f, 
    -0.12509163f, 0.05999907f, -0.03900347f, 0.08853961f, 0.06007829f, 0.08698557f, -0.09812821f, -0.33217651f, 
    -0.12270785f, 0.11382645f, -0.07897185f, -0.22890466f, 0.10785350f, -0.01287891f, -0.05272128f, -0.48413071f, 
    -0.06744706f, -0.13951600f, -0.00070726f, 0.08826935f, -0.09214853f, 0.05972745f, 0.06879611f, -0.00141466f, 
    0.21989183f, 0.17311390f, 0.22595285f, -0.12782003f, -0.00303374f, 0.12100513f, -0.05071449f, 0.07438566f, 
    -0.08180049f, -0.19087616f, 0.13308519f, -0.01594147f, -0.04118252f, 0.11199559f, -0.06422355f, -0.04830551f, 
    -0.09168343f, -0.13286141f, 0.33310843f, 0.17439622f, -0.03924481f, -0.00478158f, 0.01017019f, -0.15703557f, 
    0.08811268f, -0.03333388f, -0.04302553f, 0.05224303f, 0.07475220f, 0.11921116f, 0.00647893f, -0.10093056f, 
    0.10288564f, 0.10620913f, 0.08134809f, -0.01248627f, -0.13036649f, 0.17055780f, 0.00168457f, 0.08958776f, 
    0.19211170f, -0.14571780f, -0.00100608f, -0.07371966f, 0.07057650f, -0.10068462f, -0.18526843f, -0.03858470f, 
    -0.01495120f, 0.00951279f, 0.18108010f, -0.01198542f, 0.00820343f, -0.00419574f, 0.07790066f, 0.03679599f, 
    -0.02706047f, 0.10614904f, -0.08043860f, 0.14845315f, -0.14122356f, 0.02465205f, 0.06967895f, 0.01770587f, 
    0.16608368f, 0.16119429f, -0.08200184f, 0.02870996f, -0.03810158f, 0.06635967f, 0.01632562f, -0.07071328f, 
    -0.04532588f, -0.01513609f, 0.18014118f, -0.00118428f, -0.05840725f, -0.00253251f, -0.04665267f, -0.04899898f, 
    0.01512299f, -0.32057649f, -0.05758113f, 0.10008387f, 0.08629310f, 0.03012749f, 0.01098209f, 0.05214998f, 
    -0.07965142f, -0.00589304f, -0.08071597f, 0.01323345f, -0.09525334f, 0.04966413f, 0.00837268f, 0.07218135f, 
    0.06009216f, 0.11280923f, 0.04758180f, 0.27037081f, 0.10548159f, 0.21488070f, -0.03527969f, -0.07183144f, 
    0.07801451f, 0.00288318f, 0.01305185f, 0.10860041f, 0.12075865f, 0.04986097f, 0.27482030f, -0.05121239f, 
    0.03071652f, 0.01847074f, 0.07577590f, 0.01052549f, 0.07346368f, -0.28679648f, -0.13287124f, -0.13094185f, 
    -0.02584715f, 0.04375714f, -0.03651778f, -0.02660160f, -0.13336077f, -0.07803482f, -0.17795858f, -0.04620227f, 
    -0.14727864f, 0.10394590f, 0.15392230f, -0.06202981f, 0.11629222f, 0.02228774f, -0.09580489f, -0.07188980f, 
    0.09842888f, -0.03002755f, -0.00326745f, -0.04452416f, 0.00082248f, -0.02090183f, 0.03697785f, 0.08109719f, 
    -0.26970559f, -0.13010262f, -0.03022812f, 0.11148977f, 0.05790986f, 0.10301384f, -0.05271737f, -0.04942581f, 
    0.03523793f, -0.15828009f, 0.03552794f, 0.19620511f, -0.00588321f, -0.03316638f, 0.01400127f, -0.02795846f, 
    0.07093556f, 0.17360142f, 0.24077824f, 0.09325217f, -0.11590886f, -0.15875867f, -0.16241898f, -0.04353600f, 
    -0.03420514f, 0.02675370f, -0.01626146f, 0.02859421f, -0.11285263f, 0.02801159f, -0.01712725f, -0.01235944f, 
    0.02379288f, 0.07438887f, 0.00922634f, 0.05410597f, -0.20702961f, -0.15332505f, 0.04927419f, -0.04880472f, 
    -0.14314120f, 0.07666215f, -0.09863790f, 0.00314274f, -0.00083958f, 0.14658910f, 0.13247849f, -0.14276761f, 
    -0.07698251f, -0.07832798f, -0.00428666f, -0.05752754f, -0.10365468f, 0.03125046f, -0.08815593f, 0.05790819f, 
    -0.19902076f, 0.10214993f, 0.02932642f, -0.02073535f, 0.03026763f, -0.07510734f, -0.02801760f, 0.07895980f, 
    0.20832235f, 0.08516262f, 0.03346174f, 0.02968891f, 0.06375078f, 0.03493049f, -0.01029485f, 0.07468671f, 
    -0.18546380f, -0.23923326f, -0.06848817f, -0.10566631f, -0.01480267f, 0.05477099f, 0.11283473f, -0.02129297f, 
    -0.06736679f, -0.08080859f, -0.05834588f, -0.08225650f, -0.03326527f, -0.05234547f, 0.01948030f, 0.03630138f, 
    -0.05355207f, -0.02329234f, -0.06300763f, 0.23711771f, 0.04039589f, -0.15089840f, -0.09236514f, 0.15604915f, 
    0.04503375f, -0.00432215f, -0.09244739f, -0.44507188f, -0.19917035f, 0.10617673f, 0.11888766f, 0.01581043f, 
    0.02788894f, -0.07204928f, -0.00428164f, 0.01971052f, 0.16342287f, 0.03442549f, -0.23393098f, -0.02529168f, 
    0.05888636f, 0.09779126f, 0.03740916f, 0.12700194f, 0.18539321f, 0.10630739f, -0.03287415f, -0.13028580f, 
    -0.03282356f, 0.14631996f, -0.04257916f, 0.15697958f, -0.01781097f, -0.04242755f, 0.00968121f, 0.09706558f, 
    0.04259240f, 0.00542298f, 0.03252452f, 0.03925624f, 0.13286316f, 0.05287755f, -0.14837568f, 0.03584306f, 
    -0.09928984f, -0.18165119f, -0.11388563f, -0.08081995f, -0.01217095f, -0.08236472f, 0.08493560f, 0.20567229f, 
    0.18941832f, 0.26986039f, 0.16124526f, 0.15422089f, -0.04937801f, -0.03292877f, -0.03346082f, 0.01489850f, 
    -0.03337948f, 0.12312281f, 0.17542176f, 0.11661536f, -0.00008480f, 0.08855430f, -0.06336087f, -0.01139777f, 
    -0.19395126f, -0.18683392f, -0.43843991f, -0.03227426f, -0.00630803f, 0.05945439f, 0.13950197f, -0.04409333f, 
    -0.04782289f, 0.12735640f, -0.13228939f, 0.12394411f, 0.00580050f, 0.07555103f, -0.01582773f, 0.08679534f, 
    -0.05612891f, 0.14310725f, -0.04776520f, -0.06369848f, 0.06237216f, 0.02666407f, -0.13639247f, 0.17431080f, 
    0.07535361f, -0.10265323f, -0.11526667f, -0.06910332f, 0.03737797f, -0.25801042f, -0.21320017f, -0.25741729f, 
    -0.02472146f, 0.01254374f, 0.03838780f, 0.06610510f, -0.09361767f, 0.00348180f, -0.15506025f, -0.11453391f, 
    -0.13519853f, 0.08551774f, 0.03754842f, -0.02228818f, -0.03509894f, -0.06693141f, -0.00806669f, 0.27936295f, 
    0.05526534f, 0.07638133f, 0.07117537f, -0.07372829f, 0.00319447f, 0.04813519f, -0.01144997f, 0.10759406f, 
    0.01676913f, -0.03402727f, -0.04461736f, 0.04995782f, 0.06510958f, 0.11662945f, 0.13626093f, -0.14966010f, 
    0.01501440f, -0.29659587f, -0.04022739f, -0.00133096f, 0.09204943f, 0.12843412f, 0.02182862f, 0.00542863f, 
    0.01801015f, 0.13343567f, 0.09339603f, -0.07313389f, -0.36144859f, 0.05172841f, -0.08175790f, 0.12239704f, 
    0.02648418f, -0.14442796f, -0.14245509f, 0.10794042f, -0.09604111f, -0.02858859f, 0.06830914f, -0.06602965f, 
    -0.04379170f, -0.03359373f, 0.14499223f, -0.00424918f, 0.14920613f, -0.16425700f, 0.19968855f, 0.11893137f, 
    0.08034074f, -0.10794456f, -0.00787066f, -0.02576916f, 0.02665626f, -0.20803413f, -0.03714040f, 0.02232857f, 
    0.05123896f, -0.04599418f, -0.03737795f, 0.11904120f, -0.02079251f, 0.11128436f, 0.00483857f, 0.01166748f, 
    -0.08870357f, 0.07968805f, 0.09421393f, -0.04222529f, 0.01870749f, -0.00119220f, -0.00398968f, -0.14877690f, 
    0.10132470f, 0.07105974f, -0.00937131f, -0.02073612f, 0.01039393f, -0.06394729f, -0.13307886f, -0.17340256f, 
    -0.20563766f, 0.00293362f, -0.17834079f, -0.08460728f, -0.12317940f, 0.22650570f, 0.05525900f, 0.04553484f, 
    -0.15160659f, -0.13362767f, 0.08584449f, -0.03923091f, 0.06313202f, -0.02879040f, -0.10868772f, -0.09606125f, 
    -0.13476682f, -0.13454092f, 0.26613739f, 0.12731285f, 0.03929550f, 0.12864047f, -0.11139315f, 0.00892446f, 
    -0.01501911f, 0.09179097f, 0.13231483f, 0.03548102f, -0.11586495f, -0.05341495f, 0.00612736f, -0.00969786f, 
    0.03827795f, 0.00327711f, 0.07099240f, -0.07618959f, -0.12654886f, -0.11920789f, 0.07077689f, 0.08655324f, 
    0.06935733f, -0.08783538f, 0.06074481f, 0.05874688f, 0.03666632f, 0.02198924f, -0.05560684f, -0.06002817f, 
    -0.01187451f, 0.00084641f, 0.06370764f, -0.01346555f, -0.05258116f, 0.02438080f, 0.03183910f, 0.07905832f, 
    0.18712507f, 0.08116232f, 0.11234897f, 0.03940701f, 0.03797832f, 0.02275139f, -0.00967937f, 0.15358853f, 
    0.07896772f, 0.06326280f, 0.03912209f, 0.16427584f, 0.01515393f, -0.01192651f, -0.11653726f, 0.03360722f, 
    -0.17433244f, 0.00240099f, 0.09739456f, -0.06757998f, 0.04957691f, 0.04529702f, 0.10262226f, -0.01880391f, 
    0.11926836f, -0.02092696f, -0.01818565f, -0.19822715f, 0.04036086f, 0.09029531f, 0.09499504f, -0.08290694f, 
    0.02209081f, -0.01082044f, 0.23458356f, 0.18217468f, 0.02597816f, 0.16195752f, -0.12049161f, -0.05052131f, 
    0.17353809f, 0.06508914f, 0.09531624f, -0.03646135f, -0.08315212f, -0.18654421f, 0.05676005f, 0.12577231f, 
    0.03873979f, 0.02972402f, -0.05749408f, -0.21101323f, 0.06916378f, -0.02720531f, -0.07572452f, 0.00046593f, 
    0.14611983f, 0.02031311f, -0.03452769f, 0.07957352f, -0.12452056f, 0.00611109f, 0.12832889f, 0.04314451f, 
    -0.16822226f, -0.06406260f, 0.06657187f, -0.03435728f, -0.03682657f, 0.23783654f, 0.00419995f, 0.00582573f, 
    -0.23417267f, -0.03216108f, -0.05100526f, -0.03443544f, -0.04597059f, -0.02609646f, -0.22428440f, -0.33569169f, 
    0.05515555f, 0.01991538f, -0.04831302f, 0.03597851f, -0.07831092f, 0.10988091f, -0.05852688f, 0.16055880f, 
    0.23361690f, 0.07283949f, 0.13491011f, 0.02585591f, -0.11030667f, 0.09317058f, -0.04765579f, 0.06475747f, 
    0.00524363f, 0.17604527f, 0.01687425f, 0.04586724f, -0.10918803f, 0.18060972f, -0.13742611f, 0.09803705f, 
    0.06963883f, 0.08920189f, -0.14153446f, 0.24198051f, -0.14979124f, -0.18396845f, -0.00319796f, -0.00981332f, 
    -0.06738856f, 0.13578776f, -0.04882485f, 0.10426295f, 0.03194743f, -0.09007903f, 0.02569661f, -0.01082812f, 
    0.13265046f, 0.01303880f, 0.01551466f, 0.02324020f, 0.05451580f, -0.04790491f, 0.06173132f, 0.08929393f, 
    0.03725809f, -0.01727691f, -0.01447616f, -0.16863546f, -0.17516121f, 0.01018663f, -0.10600772f, 0.06508072f, 
    0.01991848f, 0.09561498f, 0.07363745f, -0.07123649f, -0.13678965f, 0.14282595f, -0.29564497f, 0.24782412f, 
    -0.18968311f, -0.00451565f, 0.02025438f, 0.03130693f, 0.03722282f, -0.01044783f, -0.03894613f, 0.09613930f, 
    0.12887777f, 0.10879905f, -0.12132718f, 0.01984586f, 0.06029606f, -0.00975395f, 0.02213875f, -0.08757903f, 
    -0.04161573f, 0.00037452f, 0.05252644f, -0.02978305f, 0.01198353f, 0.01079375f, 0.01263161f, -0.06210630f, 
    0.01805504f, -0.02231176f, 0.03624692f, 0.00606875f, -0.04730194f, -0.02559169f, 0.03489915f, 0.05328312f, 
    -0.00115001f, 0.03417645f, -0.03572092f, -0.02843911f, -0.04875130f, 0.03050570f, -0.02257838f, -0.06257990f, 
    0.01495999f, 0.03221097f, 0.04843971f, -0.01445230f, -0.03118084f, -0.06348512f, 0.01293160f, 0.03170089f, 
    -0.05988172f, -0.05566548f, -0.01038303f, 0.00838676f, 0.02779504f, 0.03833309f, -0.02377833f, 0.01795098f, 
    -0.04397487f, -0.00289252f, 0.03531513f, -0.04022147f, 0.03247103f, -0.03328288f, -0.02865427f, -0.03695101f, 
    -0.01266344f, 0.04219009f, -0.00372132f, -0.05468610f, -0.05830910f, -0.00310123f, -0.06217643f, -0.01702484f, 
    -0.03243400f, -0.04461864f, 0.03683304f, 0.03170105f, -0.04229995f, -0.05547357f, 0.00024653f, -0.04636298f, 
    -0.01837882f, 0.04754379f, -0.05416175f, 0.01187133f, 0.04410200f, 0.03694699f, -0.01696153f, -0.01943267f, 
    0.02995388f, 0.02917613f, 0.00024086f, -0.00530006f, -0.05554682f, -0.02406020f, 0.02382051f, 0.01270702f, 
    -0.03045644f, -0.01934391f, -0.02506637f, -0.01206473f, -0.00804147f, -0.03759228f, -0.05123413f, -0.00326676f, 
    -0.05931071f, -0.04106430f, -0.06137293f, -0.03861796f, -0.01277361f, -0.01408124f, -0.05476905f, 0.04597816f, 
    0.04704776f, -0.05342855f, 0.00360372f, -0.04862018f, 0.00418942f, 0.05112685f, 0.04906132f, -0.03745569f, 
    -0.00315179f, 0.00327179f, 0.02725321f, 0.02443601f, 0.02211132f, 0.03542620f, -0.05588496f, -0.03956784f, 
    -0.02356576f, -0.01353824f, 0.05039098f, -0.06455715f, 0.02979795f, -0.01610542f, -0.02203743f, -0.01493433f, 
    0.02624520f, 0.03486482f, -0.01794989f, -0.00058435f, -0.05687785f, 0.01604572f, 0.01909699f, -0.04187322f, 
    -0.06396385f, 0.04140668f, -0.04416441f, 0.03564515f, 0.01524829f, -0.06450741f, 0.00486389f, -0.06025282f, 
    -0.06244260f, -0.02247775f, -0.04967748f, 0.04210410f, -0.00379748f, 0.03009567f, 0.02717904f, 0.02924884f, 
    0.03544505f, 0.04684603f, -0.04205602f, 0.05299509f, -0.01394114f, -0.03853022f, -0.05697796f, -0.03351298f, 
    -0.05443349f, -0.06335291f, -0.04913334f, 0.03700718f, 0.03566385f, -0.02778593f, 0.04990659f, -0.05461710f, 
    0.03119844f, -0.04238668f, 0.03542061f, -0.05051036f, -0.02977483f, 0.01421621f, -0.05048373f, 0.00296474f, 
    0.02665774f, -0.05095399f, 0.02493614f, -0.02817566f, 0.03530196f, -0.02813442f, 0.02974922f, -0.00372317f, 
    0.02078718f, -0.05699834f, 0.03808183f, 0.03864219f, -0.01318422f, 0.03591980f, 0.04809173f, -0.02377214f, 
    -0.02298572f, 0.04449853f, 0.00661687f, -0.01508022f, -0.04207904f, -0.03556179f, 0.02473404f, 0.01008350f, 
    -0.05019953f, -0.05497959f, -0.03871716f, -0.02226227f, 0.04680122f, -0.04211375f, -0.04212746f, 0.00106414f, 
    -0.04039798f, 0.00713681f, 0.00069359f, 0.00651120f, 0.04721847f, -0.03539521f, 0.02096181f, -0.06188160f, 
    -0.01046092f, 0.03015425f, -0.06095094f, 0.03626273f, -0.03456967f, -0.04580598f, 0.02844105f, -0.00463109f, 
    -0.00869166f, -0.00387189f, 0.02703042f, 0.04263730f, -0.05180588f, 0.02738220f, -0.05420712f, 0.00478138f, 
    0.04111731f, -0.03139967f, -0.04683887f, -0.03736061f, -0.03562732f, 0.00643161f, -0.04537520f, -0.02322461f, 
    0.03686984f, -0.03962119f, 0.00617006f, -0.00248510f, -0.05264392f, 0.02397326f, -0.06374947f, 0.03751639f, 
    -0.06237632f, -0.00688056f, 0.04228178f, -0.00745652f, 0.04708857f, -0.06173768f, -0.06153156f, 0.05291174f, 
    0.03452231f, -0.01087632f, -0.00228601f, -0.04200964f, -0.04586573f, -0.04327434f, 0.01432574f, -0.01326135f, 
    -0.04353678f, 0.00882037f, -0.01621700f, 0.02913142f, -0.01226597f, -0.03266079f, -0.02690968f, -0.00541941f, 
    -0.04747888f, -0.04511208f, -0.04290784f, 0.01782361f, 0.02046527f, 0.04806897f, -0.01789692f, 0.00459008f, 
    -0.00309135f, -0.00239245f, 0.00466508f, -0.04853017f, -0.05428446f, 0.04872764f, 0.02620306f, -0.04652307f, 
    0.04213047f, 0.01068725f, 0.03095255f, 0.02954875f, -0.01452032f, -0.00381944f, 0.02148330f, -0.05876843f, 
    -0.02295997f, 0.00909299f, 0.00335270f, 0.01983294f, -0.00579859f, -0.06438481f, -0.02692856f, 0.05019076f, 
    0.04329754f, 0.01404931f, 0.00342472f, -0.01160158f, -0.04141226f, -0.03696079f, -0.00806470f, -0.05216685f, 
    0.03801933f, 0.00137010f, 0.00770088f, 0.04317262f, 0.02266531f, -0.00572968f, -0.03622280f, -0.00296126f, 
    0.02658454f, -0.04765030f, -0.04109766f, -0.01142366f, -0.01835064f, -0.03427648f, -0.04159206f, -0.06177872f, 
    0.05096033f, 0.03714955f, 0.00370620f, 0.02927390f, -0.06187872f, -0.04278680f, 0.04686471f, 0.03756126f, 
    -0.02094495f, -0.01009243f, 0.02112905f, -0.03309475f, -0.00494789f, -0.06506066f, -0.00189595f, -0.00486943f, 
    -0.03881596f, 0.02865058f, 0.02257519f, 0.02802047f, -0.01582165f, 0.03578103f, 0.03358276f, 0.00541433f, 
    0.02527297f, 0.00450301f, 0.03655722f, -0.02197704f, 0.00823119f, -0.00430234f, -0.03731229f, 0.00933710f, 
    0.03722036f, 0.04572814f, -0.05004025f, -0.06379934f, 0.00357641f, 0.03011123f, 0.03009445f, -0.03577890f, 
    -0.06611137f, -0.04562505f, -0.05169038f, -0.06379230f, -0.02047941f, 0.00086803f, -0.06258111f, -0.06153694f, 
    0.01839905f, -0.03010469f, -0.01894329f, 0.01360374f, -0.00725924f, -0.02128458f, -0.02793736f, 0.00867092f, 
    -0.02715697f, -0.02516975f, -0.00400465f, -0.02004497f, -0.02434848f, -0.04767232f, 0.01269791f, 0.02113025f, 
    -0.03202746f, -0.03037949f, 0.01813198f, -0.05950718f, -0.03938755f, 0.03817977f, -0.02448731f, 0.03716154f, 
    0.00484981f, -0.04443866f, -0.01777386f, -0.02693137f, 0.04472616f, -0.05943062f, -0.05927847f, 0.04388268f, 
    -0.03708912f, -0.00992741f, -0.01943928f, -0.00988409f, 0.03980516f, 0.02262841f, -0.00845563f, -0.02033976f, 
    -0.06364778f, -0.04161228f, 0.02783024f, -0.02763561f, -0.01103287f, 0.01379825f, 0.04030041f, 0.02700804f, 
    0.02599337f, -0.03067334f, -0.03326125f, -0.01830980f, -0.01677626f, 0.02707591f, 0.00624565f, 0.04378241f, 
    -0.03625574f, -0.01668380f, 0.03512596f, 0.01588795f, -0.03408429f, -0.00704842f, 0.02622494f, 0.01069486f, 
    0.04345341f, -0.03744707f, -0.00958657f, -0.01479353f, 0.04080167f, -0.02043658f, -0.06486201f, -0.05085982f, 
    -0.00314112f, -0.04145774f, -0.02250830f, -0.05056713f, -0.06623613f, -0.02252111f, 0.02407049f, -0.05678038f, 
    -0.02278820f, -0.01544084f, -0.06198665f, -0.03265883f, -0.01187292f, -0.05051031f, -0.00906206f, -0.01552118f, 
    -0.01744731f, -0.04421974f, 0.00305316f, 0.04764649f, 0.00724029f, -0.02627989f, -0.04457545f, 0.04389522f, 
    0.02402200f, 0.01127325f, 0.03561692f, 0.03174015f, 0.03989479f, 0.00902536f, 0.01063185f, -0.01050987f, 
    -0.04794223f, 0.04253263f, 0.03861096f, -0.04435040f, 0.01399048f, 0.02206058f, -0.06338648f, -0.06130862f, 
    -0.01261787f, 0.02796089f, 0.01060210f, -0.01535154f, 0.02289692f, -0.03359270f, -0.04068818f, -0.06044818f, 
    -0.00129544f, -0.01319847f, 0.01357723f, -0.00301770f, -0.01315974f, 0.01540779f, -0.04291062f, -0.06462366f, 
    -0.03285916f, -0.05227243f, 0.00424509f, -0.00948769f, 0.02466885f, -0.01743269f, -0.01019947f, 0.01524240f, 
    -0.00017650f, 0.04577862f, -0.00324254f, -0.01730046f, -0.02219296f, -0.05587121f, -0.00282550f, -0.02786080f, 
    0.00836533f, 0.00988070f, -0.02771482f, -0.00929828f, -0.04135798f, 0.01991409f, -0.04467084f, 0.00954265f, 
    0.01524169f, -0.06176099f, -0.03583757f, -0.04461715f, -0.06358892f, -0.02742067f, 0.02366721f, -0.00868769f, 
    -0.01894986f, -0.05879983f, 0.02467276f, 0.02520754f, -0.02272602f, 0.01644710f, -0.01202754f, 0.01649372f, 
    -0.02618215f, 0.01919700f, -0.05652709f, -0.03606054f, 0.00454608f, 0.03732361f, -0.03616422f, -0.00187788f, 
    -0.03485303f, 0.03432753f, -0.01815871f, -0.00622069f, 0.03848016f, -0.00947972f, 0.04720067f, -0.02459259f, 
    0.01225667f, -0.01412349f, -0.04112670f, -0.06163772f, -0.02464862f, 0.04397992f, -0.02450594f, -0.02980010f, 
    -0.05174951f, -0.02307811f, -0.06217110f, -0.00594776f, -0.02259347f, -0.05433908f, 0.04848304f, -0.05002127f, 
    0.03577621f, 0.03132759f, 0.01650290f, -0.00962799f, 0.02657400f, -0.06117474f, -0.04179259f, -0.04736304f, 
    -0.22171047f, -0.29532909f, -0.07407639f, 0.01160910f, 0.03297919f, 0.11755139f, 0.09607480f, -0.10521477f, 
    0.03667890f, 0.00189772f, -0.02759946f, -0.54613382f, -0.08745250f, 0.03264609f, -0.04858674f, -0.04392574f, 
    -0.10397734f, 0.03075237f, -0.11528507f, 0.03867323f, 0.02991411f, 0.04036304f, -0.03396790f, -0.00134430f, 
    0.05333795f, 0.16823532f, -0.01259616f, -0.05254955f, -0.06303171f, 0.03375794f, 0.06326117f, 0.09873637f, 
    -0.06567491f, 0.04380390f, -0.07246472f, -0.04312520f, -0.19890918f, 0.09826288f, -0.18245374f, 0.05957395f, 
    -0.01753707f, 0.11719690f, -0.02319724f, 0.03658989f, 0.14714597f, 0.27926064f, 0.23342548f, 0.16114946f, 
    0.05940229f, -0.00674700f, -0.07072131f, -0.07554851f, 0.09447018f, 0.02114061f, -0.52106178f, -0.01470870f, 
    0.23293908f, 0.03423946f, -0.03366657f, 0.12954512f, -0.06097445f, 0.07174047f, 0.14660859f, -0.15585476f, 
    -0.14906739f, -0.12507530f, 0.05626968f, -0.01813293f, 0.04251172f, 0.09654137f, -0.01710295f, 0.06085603f, 
    0.34628502f, 0.00589366f, 0.02845779f, 0.07859502f, -0.04329195f, -0.04092433f, 0.10445479f, 0.13851385f, 
    -0.15777403f, -0.15689515f, -0.12118574f, -0.03794422f, 0.02235709f, 0.05554191f, 0.05060792f, 0.02764550f, 
    0.09328240f, -0.01078309f, 0.17235261f, -0.09754166f, -0.13024278f, 0.01954987f, 0.05452326f, -0.05537993f, 
    -0.00399978f, -0.15880221f, -0.12658191f, -0.05465079f, -0.12974888f, -0.12822652f, -0.09518243f, -0.03100666f, 
    -0.16075383f, -0.00406328f, 0.15237583f, 0.04409933f, -0.00773316f, 0.01563051f, -0.18754484f, -0.17933074f, 
    0.10270568f, -0.12916228f, -0.09598383f, 0.03668379f, -0.03228269f, -0.44557697f, 0.03299333f, -0.08031820f, 
    0.00816884f, 0.00625039f, -0.06359767f, 0.05371572f, 0.05636612f, -0.02306105f, 0.15248780f, 0.15507016f, 
    -0.18444972f, -0.00852255f, 0.09701481f, -0.08153879f, 0.17882432f, 0.09364575f, 0.01498846f, 0.15379970f, 
    -0.19918120f, -0.07034144f, 0.00477897f, -0.01034360f, 0.12837526f, 0.09480371f, 0.06125496f, 0.01595142f, 
    0.05779899f, -0.13175231f, -0.05611254f, 0.12620831f, 0.08263667f, 0.12960319f, 0.03988135f, 0.03739615f, 
    -0.17825718f, -0.18032469f, -0.03464013f, -0.14140663f, 0.01106782f, 0.00844012f, 0.05724253f, 0.03690721f, 
    -0.10111301f, 0.11149441f, 0.25233501f, -0.21236257f, -0.14718285f, -0.06712090f, -0.01486587f, 0.15103494f, 
    -0.09575755f, 0.09401920f, -0.10320189f, 0.27909178f, 0.13670471f, -0.26457193f, 0.02263111f, 0.04044326f, 
    -0.13255291f, -0.11417846f, -0.13108300f, -0.03835899f, -0.26453489f, 0.02082160f, 0.23558491f, 0.07658927f, 
    0.00974120f, 0.04447827f, 0.04232213f, 0.01388479f, 0.21060297f, 0.07242791f, 0.16989756f, -0.09615749f, 
    -0.04777977f, -0.14866684f, -0.02345552f, 0.08168665f, 0.00699397f, 0.13163765f, -0.08837201f, -0.16524276f, 
    -0.23050478f, 0.10806531f, -0.01675729f, 0.05866542f, 0.08567451f, -0.04925616f, 0.08026517f, -0.13496782f, 
    0.12221105f, -0.04514457f, -0.01501649f, -0.04553857f, -0.07688757f, 0.07535839f, -0.27247325f, -0.15657948f, 
    0.06560995f, 0.02097654f, 0.05418794f, -0.11981525f, -0.03279508f, 0.10192414f, 0.11966134f, 0.07872561f, 
    -0.14406180f, 0.14844030f, -0.00612654f, -0.43407053f, -0.11421242f, -0.04816715f, 0.04323467f, 0.01798018f, 
    -0.07133541f, -0.19517583f, 0.19822063f, 0.11560196f, -0.14229897f, 0.04720097f, -0.01516462f, 0.09308092f, 
    0.01715907f, -0.05783911f, -0.04859209f, 0.14789328f, 0.13596538f, -0.08765824f, -0.05043496f, -0.02669761f, 
    0.09001883f, 0.09796280f, -0.03826446f, 0.11262763f, -0.27496219f, -0.17868251f, -0.09659602f, -0.07830472f, 
    -0.10507601f, -0.06340168f, -0.03700307f, 0.09179591f, 0.08145925f, -0.12163059f, 0.24231485f, -0.17748985f, 
    0.06198657f, -0.10981156f, 0.08254696f, 0.00024181f, 0.03703631f, 0.03872880f, 0.16697069f, 0.01368500f, 
    -0.05886518f, 0.09469362f, 0.06275694f, 0.19390106f, 0.03929453f, -0.01775909f, -0.09803902f, 0.06781661f, 
    -0.11526898f, 0.19493693f, -0.02881273f, 0.01549383f, 0.09275574f, 0.20608768f, 0.15332647f, -0.06459651f, 
    0.09648120f, 0.02699898f, -0.27451667f, 0.01001974f, -0.03130330f, 0.04248937f, -0.05509563f, 0.01912814f, 
    -0.01664265f, -0.06462347f, -0.08675127f, -0.28938454f, 0.00543309f, -0.01972765f, 0.09026699f, -0.06385078f, 
    0.04130386f, 0.04065306f, -0.12697841f, 0.10628607f, -0.24231857f, 0.02751711f, 0.04283411f, -0.00206509f, 
    0.00223903f, 0.04057782f, -0.02244202f, -0.00305990f, -0.09307222f, 0.02655701f, -0.01269394f, -0.12760656f, 
    0.06443144f, 0.09652437f, -0.12602925f, 0.02979184f, 0.26582631f, -0.24960539f, -0.17903256f, -0.04767292f, 
    -0.04593344f, 0.01754469f, 0.01650036f, 0.05019423f, 0.01399136f, 0.32111248f, -0.04373703f, -0.00381419f, 
    -0.08893283f, -0.06586359f, -0.03632304f, -0.06525964f, 0.06919514f, -0.05409034f, 0.11868434f, -0.36921552f, 
    -0.13036677f, 0.08344276f, -0.01153861f, -0.00821768f, 0.13218427f, -0.01645450f, -0.02723346f, -0.03578852f, 
    -0.13943969f, 0.13178547f, -0.00974138f, -0.01032843f, -0.08123271f, -0.06309075f, -0.04764460f, 0.13183753f, 
    0.15851772f, 0.05458893f, -0.04409333f, -0.08610561f, -0.20330192f, -0.04694339f, 0.02668530f, -0.02802542f, 
    0.04597015f, -0.08229663f, -0.21892878f, -0.24103841f, 0.09082472f, 0.06202837f, 0.09220899f, 0.01698959f, 
    0.04709345f, 0.00924055f, 0.12838009f, 0.29315379f, -0.09505298f, 0.12658148f, 0.10068117f, 0.10684423f, 
    -0.03669636f, -0.09617912f, -0.10066439f, 0.29679012f, -0.14470357f, -0.17103273f, -0.08730188f, -0.28642365f, 
    -0.01313241f, 0.06630582f, -0.10658677f, -0.03744429f, 0.35344136f, -0.03557223f, -0.22591625f, -0.17657115f, 
    0.01636022f, 0.03552803f, 0.02060855f, 0.17024389f, 0.07619575f, 0.38066429f, 0.15113933f, 0.11176866f, 
    0.08949599f, 0.06462672f, 0.04520300f, -0.05219742f, -0.08633047f, -0.00865249f, 0.05146144f, 0.11182039f, 
    -0.00027722f, -0.12549083f, 0.08811532f, -0.04284198f, -0.02640125f, -0.01787367f, 0.07300858f, -0.12470847f, 
    0.01895501f, -0.05162888f, 0.08017883f, -0.00133955f, 0.14561847f, 0.00243691f, -0.03515053f, -0.11116498f, 
    -0.05896657f, 0.14618628f, 0.03441093f, -0.07592221f, -0.01688390f, -0.04295676f, -0.01735966f, 0.02971473f, 
    0.01906012f, 0.39262238f, -0.13107215f, -0.05074350f, -0.04540992f, -0.05689898f, -0.05788901f, 0.09550367f, 
    -0.09239145f, 0.09696047f, -0.05104094f, 0.17854965f, -0.01558343f, -0.00497144f, -0.01461624f, -0.02088301f, 
    -0.04461602f, -0.06913567f, -0.11908175f, -0.03140115f, -0.08348601f, -0.14706741f, -0.12151237f, 0.07559057f, 
    0.01653965f, -0.02094328f, -0.05260930f, 0.01686631f, -0.08593640f, -0.07579437f, -0.11477010f, -0.01689064f, 
    0.07643471f, 0.07958683f, 0.04916505f, 0.03373329f, 0.01329829f, -0.22732085f, 0.20644140f, 0.04176871f, 
    0.07991016f, 0.11827469f, 0.05836344f, -0.11489394f, 0.10463613f, -0.18052700f, 0.13945787f, -0.14131613f, 
    0.10251508f, 0.07238758f, -0.01984828f, 0.08188306f, -0.01932347f, 0.04415251f, -0.04412143f, -0.24135815f, 
    0.00223990f, 0.17894797f, -0.10968808f, 0.07745606f, -0.13801467f, -0.17078403f, 0.08984688f, 0.10538989f, 
    -0.07340616f, -0.01769743f, 0.00805254f, 0.12046011f, 0.06735121f, 0.03923292f, -0.08350333f, -0.03559669f, 
    -0.05318960f, 0.05438875f, 0.04028459f, 0.13776682f, 0.00215169f, -0.10119707f, -0.02217306f, -0.00889640f, 
    -0.01446185f, 0.15214455f, 0.09842480f, -0.03176510f, 0.14001477f, -0.02678230f, -0.07089648f, -0.12136135f, 
    -0.02577785f, 0.11501250f, 0.08694403f, -0.20652361f, 0.09216708f, 0.00580336f, -0.00993050f, 0.08787558f, 
    -0.04202373f, -0.04112095f, 0.09422041f, 0.12598497f, -0.27566987f, 0.06790876f, -0.06095567f, 0.04478084f, 
    0.01252471f, -0.02939303f, -0.03451411f, 0.15091449f, -0.10195607f, 0.09606580f, -0.22889243f, 0.02105027f, 
    -0.02398079f, 0.13798130f, 0.06055519f, 0.06557667f, 0.02567424f, -0.05146244f, -0.05155244f, 0.04656390f, 
    0.17295754f, -0.00816160f, -0.08382293f, -0.01496286f, 0.02247810f, -0.02995966f, 0.12756817f, -0.27081710f, 
    0.21370608f, -0.07623371f, 0.15208527f, -0.04250626f, 0.00349655f, 0.04602815f, -0.02321051f, 0.09693976f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05302227f, -0.03255570f, 0.04415437f, 0.08863457f, 0.05864690f, -0.17580435f, 0.16033287f, 0.03272796f, 
    -0.06293942f, 0.00569822f, -0.12889403f, -0.06961993f, 0.09601550f, -0.04208491f, 0.06522676f, -0.05765478f, 
    0.09420244f, 0.02417841f, 0.03599000f, -0.01786128f, 0.05312718f, -0.00394758f, 0.10269610f, 0.00683491f, 
    -0.04164641f, -0.01868856f, 0.08120291f, -0.00585638f, 0.00396034f, 0.01865794f, 0.16088474f, 0.07413216f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14899139f, -0.18716891f, 0.20745772f, 0.00606632f, 0.13713720f, 0.27948618f, -0.02092340f, -0.15469311f, 
    0.10075738f, -0.04664816f, 0.47985786f, 0.00257264f, -0.00149445f, 0.03081931f, 0.35030609f, 0.13892956f, 
    0.26808575f, -0.33966297f, -0.05215080f, 0.09311844f, -0.09550335f, 0.00244106f, 0.19954298f, -0.02017720f, 
    0.16532759f, -0.20357656f, 0.27132487f, -0.04197145f, -0.14757997f, 0.13669249f, 0.41306496f, -0.04062960f, 
    0.03477493f, -0.17623618f, -0.07893580f, 0.14065087f, 0.20959617f, 0.45497686f, -0.04204385f, -0.01690876f, 
    -0.14594151f, 0.08210624f, 0.43768993f, 0.04116248f, 0.00596045f, -0.05593849f, 0.18876725f, 0.16512766f, 
    -0.03907032f, -0.06294168f, 0.10539249f, 0.01162119f, -0.03030559f, -0.22778672f, -0.20089996f, 0.37446845f, 
    0.10819507f, 0.24535663f, -0.04175085f, -0.23221788f, -0.06041690f, 0.10003250f, 0.33117628f, -0.01415471f, 
    0.01138151f, -0.02988488f, 0.11295324f, 0.16201162f, -0.11614447f, -0.15995497f, -0.08127283f, -0.08527321f, 
    0.03395841f, 0.14801070f, -0.36084560f, 0.04012273f, -0.20615157f, 0.12325680f, -0.03054172f, -0.03711323f, 
    0.08987599f, 0.24924879f, 0.08614106f, 0.30373466f, 0.02587905f, -0.09128942f, -0.01399714f, 0.06652843f, 
    -0.17419906f, 0.47906253f, 0.07947496f, 0.06695807f, -0.01546960f, 0.04183296f, -0.02853549f, 0.32810178f, 
    -0.08848999f, -0.08563078f, -0.10656687f, 0.03215605f, -0.17620380f, -0.08667204f, 0.04623549f, 0.04171402f, 
    -0.09289271f, -0.09430233f, 0.29274797f, -0.16877283f, -0.02755221f, 0.02110267f, 0.54383785f, 0.00980736f, 
    0.11890283f, 0.13469930f, -0.06891058f, 0.20058388f, 0.02535095f, -0.27905208f, -0.27434820f, -0.06261802f, 
    -0.13913532f, 0.12183654f, -0.09926122f, -0.16320315f, 0.15956144f, 0.15956435f, 0.06181069f, 0.04947575f, 
    0.04075144f, -0.15241468f, 0.35400376f, 0.27790651f, 0.18660851f, 0.08037034f, 0.06463261f, 0.04517628f, 
    0.15916103f, 0.10937458f, 0.10173102f, -0.14620860f, -0.14026830f, -0.10098737f, 0.21056369f, -0.06927852f, 
    -0.25381523f, -0.20521338f, -0.11879357f, -0.02340370f, 0.15288246f, -0.04554601f, -0.01705668f, 0.33972514f, 
    0.11222447f, 0.02501227f, -0.04724675f, -0.27832904f, 0.05331933f, 0.15163395f, 0.23134841f, -0.28173929f, 
    -0.07887718f, 0.23351848f, -0.10565354f, 0.17944951f, -0.20329045f, 0.75874239f, -0.21795443f, 0.04175454f, 
    0.09547784f, -0.14225627f, 0.26607883f, -0.15986517f, 0.09601530f, 0.17475778f, 0.29645985f, -0.04535189f, 
    0.28428102f, 0.01758450f, 0.15014026f, 0.21541800f, 0.16508935f, -0.19462115f, -0.03229062f, 0.06092963f, 
    0.05715197f, 0.06126023f, 0.21394964f, -0.12118906f, -0.00483291f, -0.07234558f, 0.10293746f, -0.14035980f, 
    0.16507243f, 0.01426301f, -0.22768438f, 0.07164750f, 0.14603515f, -0.47374108f, 0.31794152f, 0.05459931f, 
    0.10424586f, -0.15940875f, -0.17594732f, 0.09970910f, 0.31306487f, 0.07800051f, -0.31844234f, -0.05612072f, 
    -0.09719798f, 0.18506254f, -0.01083256f, 0.00546574f, 0.07005626f, 0.10362434f, 0.28273761f, 0.04742685f, 
    0.03418172f, -0.17526121f, -0.08191868f, 0.25490549f, -0.08057346f, 0.00775078f, 0.04041703f, -0.18371190f, 
    0.01201071f, 0.13059655f, 0.11592519f, 0.00312652f, 0.01489966f, 0.18446976f, -0.21859840f, 0.14295597f, 
    -0.05691471f, 0.10701330f, -0.29822597f, 0.14750232f, -0.10109214f, 0.02945570f, 0.22655019f, 0.09361983f, 
    0.13908464f, 0.30170783f, 0.07200808f, 0.22377796f, -0.05069408f, 0.01997119f, 0.06583530f, -0.16411397f, 
    0.16437021f, -0.24607384f, 0.23642483f, -0.01520487f, -0.06735910f, 0.04477938f, 0.01295085f, -0.14198956f, 
    0.17479882f, 0.02093952f, 0.21930036f, 0.07889599f, 0.09153373f, 0.45740825f, -0.07183272f, -0.13869214f, 
    0.15385330f, -0.17666464f, 0.48253566f, -0.01916926f, 0.06476398f, 0.16883148f, 0.20284779f, 0.04086840f, 
    0.26485118f, -0.09545047f, -0.02289438f, 0.02969708f, -0.10173562f, -0.29635999f, -0.06630774f, 0.17861983f, 
    -0.16371657f, 0.15532555f, -0.04400255f, -0.14352082f, 0.10564982f, -0.10233584f, 0.41668326f, -0.30595458f, 
    -0.00299205f, -0.04825480f, -0.12044652f, 0.16685641f, 0.00858434f, -0.14571843f, 0.18776149f, -0.06916720f, 
    0.03706472f, -0.12133780f, -0.31929925f, -0.07922998f, -0.03724138f, -0.17147160f, 0.16871840f, -0.06918110f, 
    -0.25121656f, 0.37847623f, 0.04373082f, 0.14868219f, -0.00607635f, -0.20826478f, 0.12972529f, -0.06382529f, 
    -0.06919234f, -0.14950770f, 0.29487365f, 0.17047809f, -0.09363434f, 0.10292546f, -0.28857452f, 0.06558514f, 
    0.00985716f, 0.25909114f, 0.10284568f, 0.12207019f, -0.16660261f, -0.00532603f, -0.08386880f, 0.11910354f, 
    -0.10067076f, 0.04279486f, -0.24288544f, 0.01819402f, -0.03633017f, 0.10955875f, 0.20810071f, 0.07347574f, 
    0.00352110f, 0.35388541f, 0.06181728f, 0.29751793f, -0.03387838f, -0.15373895f, 0.01091398f, -0.09400047f, 
    0.03824167f, 0.40231180f, 0.01120816f, 0.11069628f, -0.00864651f, 0.16061328f, -0.32674962f, -0.28735542f, 
    -0.09086140f, 0.01924492f, 0.04519036f, 0.20034395f, 0.15067461f, -0.12492696f, 0.42106408f, 0.05457362f, 
    0.10117626f, -0.16378982f, -0.12132752f, 0.02151848f, 0.08058298f, 0.11313358f, -0.22533615f, 0.09299231f, 
    0.29788181f, -0.28906009f, 0.14077567f, -0.08333102f, 0.14945118f, 0.30233839f, 0.23040609f, 0.28937390f, 
    0.01862819f, 0.21937354f, 0.03576170f, -0.05222199f, 0.13796614f, -0.03672256f, -0.17656751f, -0.32909334f, 
    0.11923847f, -0.33790565f, -0.18084995f, 0.10657414f, 0.22799556f, 0.00140654f, 0.39978045f, -0.05668352f, 
    -0.08070943f, 0.04516672f, -0.42637458f, 0.04328337f, -0.11938173f, 0.04639977f, -0.05228220f, -0.11070862f, 
    -0.22541338f, -0.23596585f, -0.17200582f, 0.10718600f, 0.15059607f, -0.14043526f, 0.18822289f, 0.37250733f, 
    0.03025962f, -0.02991486f, 0.33953649f, -0.18242991f, -0.02114912f, 0.04309024f, -0.10114317f, 0.26914325f, 
    0.07371168f, -0.00162904f, -0.08026364f, -0.12521932f, -0.07334255f, 0.14300089f, -0.00216700f, -0.08122441f, 
    0.07179701f, -0.00830166f, -0.10574421f, 0.11204944f, -0.11908209f, 0.12673254f, -0.15516829f, -0.16198601f, 
    -0.07747874f, 0.03427188f, 0.16213578f, 0.03143379f, 0.01911387f, -0.04174951f, -0.12751718f, -0.04028518f, 
    0.08109102f, 0.07803620f, -0.13158238f, -0.01250389f, -0.06741884f, -0.05414346f, -0.03266602f, -0.03101003f, 
    0.14743364f, -0.10208167f, 0.24384648f, 0.14964664f, -0.00023105f, 0.32939315f, 0.08356828f, -0.07718774f, 
    0.16257252f, 0.10515436f, -0.23828100f, 0.15349711f, -0.15445559f, 0.00280158f, -0.27295229f, -0.07645715f, 
    0.49359995f, -0.18570550f, 0.01907181f, -0.03915763f, 0.10797901f, -0.12932649f, -0.29389462f, 0.15065113f, 
    0.06342279f, 0.01979684f, 0.23769471f, 0.24984947f, 0.02727722f, 0.01358806f, -0.06231226f, -0.44786203f, 
    -0.05637011f, 0.13470531f, 0.02895165f, 0.09874482f, 0.04185254f, -0.14130458f, 0.14713693f, 0.07831345f, 
    0.04340558f, -0.14059870f, -0.21163583f, -0.06877521f, -0.20195727f, 0.16337332f, -0.20366804f, 0.16921826f, 
    0.15381330f, 0.11752810f, -0.12469184f, 0.37894568f, 0.06590844f, -0.18641295f, -0.25025713f, -0.14477806f, 
    0.07114259f, 0.43529657f, 0.17462775f, 0.32286581f, 0.08204237f, -0.01815180f, 0.03003398f, 0.06977705f, 
    0.11801929f, -0.25829726f, 0.05879052f, 0.23272443f, 0.06403925f, -0.23186405f, 0.08514439f, 0.13322715f, 
    0.07016143f, -0.14860159f, -0.34679994f, -0.11561884f, -0.34328327f, 0.13538593f, 0.19080277f, -0.02303810f, 
    -0.16336580f, 0.12278924f, -0.03787948f, 0.26308382f, -0.08694606f, -0.16366234f, 0.06096268f, 0.10615923f, 
    0.01601615f, 0.16447136f, 0.17379020f, 0.11217071f, 0.11009394f, -0.12100606f, -0.35307288f, 0.15925920f, 
    -0.03074377f, 0.15935707f, 0.11018527f, -0.01546269f, -0.07716355f, 0.12948015f, -0.12105178f, -0.15093958f, 
    0.05717772f, -0.06380250f, 0.08934496f, -0.12512447f, -0.30496004f, -0.00775917f, 0.16006894f, 0.06628008f, 
    0.35685259f, -0.04618809f, -0.12996417f, 0.33107528f, -0.12270322f, 0.07302441f, -0.08459445f, 0.02500818f, 
    -0.03849182f, 0.00029533f, 0.29561684f, 0.17296293f, 0.15171990f, -0.06419913f, 0.14439060f, -0.26250625f, 
    0.11296067f, 0.31011596f, -0.12642832f, 0.05995316f, -0.06947061f, -0.50939393f, -0.01360393f, 0.03807779f, 
    0.05445240f, -0.03075350f, 0.16068213f, 0.06399694f, 0.23030815f, 0.06960011f, 0.23115033f, 0.16286305f, 
    0.16660918f, 0.31313285f, 0.03516987f, -0.06589909f, -0.18140551f, 0.42127493f, -0.02815267f, -0.17938578f, 
    -0.15893818f, -0.25382909f, -0.03500764f, 0.11992483f, 0.04819600f, -0.14661983f, 0.02616090f, 0.22055313f, 
    -0.13673997f, 0.22449422f, 0.01784864f, 0.20093380f, -0.03451728f, 0.02911968f, -0.42543161f, -0.12501442f, 
    0.00027501f, -0.07874205f, -0.10757297f, -0.16017142f, -0.30819160f, 0.15499552f, 0.24973565f, -0.09930674f, 
    0.12603004f, -0.20035821f, -0.17439972f, 0.05929508f, -0.07668600f, -0.04788934f, -0.20362227f, -0.13431871f, 
    0.03087655f, -0.18497841f, 0.03755106f, 0.18646856f, 0.01659376f, -0.14432274f, -0.12695639f, -0.16346455f, 
    -0.10387269f, 0.11393993f, -0.08094264f, 0.06094079f, -0.04742144f, -0.16938810f, -0.01557027f, -0.06622064f, 
    0.00791452f, 0.05715496f, 0.02910606f, 0.17392612f, 0.01383362f, 0.14818728f, -0.07781617f, 0.05173660f, 
    0.08724932f, -0.00333278f, -0.02086391f, -0.12196901f, 0.17629768f, -0.17260636f, -0.01550147f, -0.18104844f, 
    -0.08778982f, -0.06798998f, -0.07167692f, -0.15608332f, 0.08532197f, -0.09446841f, -0.12509885f, -0.09938707f, 
    0.07290383f, 0.17114566f, -0.20042975f, 0.23500358f, -0.21536039f, 0.34256801f, -0.14557873f, -0.01258793f, 
    -0.17714588f, -0.08464918f, -0.49260971f, 0.12078066f, -0.16540159f, -0.13314188f, -0.03740522f, 0.14103460f, 
    -0.03225260f, 0.42403162f, 0.04837045f, 0.33922088f, -0.12607025f, -0.41223913f, 0.25512552f, 0.09812842f, 
    -0.06085071f, 0.11516547f, 0.24761567f, 0.12662831f, -0.02789920f, -0.05079227f, 0.15367474f, 0.05913512f, 
    0.07010342f, -0.13931249f, 0.16084985f, 0.19445603f, 0.04143538f, 0.14940977f, -0.27755865f, -0.10843709f, 
    -0.05081932f, -0.10066853f, -0.35304755f, -0.02560093f, -0.19865292f, -0.09147017f, -0.04363188f, -0.06913941f, 
    -0.01708406f, 0.12196614f, 0.05105573f, -0.03560945f, -0.12902613f, -0.15300551f, 0.00462029f, 0.22636048f, 
    0.07437927f, 0.44665164f, 0.26452506f, 0.19421171f, -0.02890904f, -0.04127653f, -0.08158580f, 0.19709642f, 
    -0.00082899f, -0.10013167f, -0.30538440f, 0.30662623f, -0.11385112f, -0.00032580f, 0.43258202f, 0.08528984f, 
    0.07341646f, 0.07379613f, 0.02882350f, 0.12915252f, -0.06905378f, -0.09797077f, 0.16515966f, 0.09075164f, 
    -0.35576278f, -0.15535495f, 0.05812101f, 0.05113955f, 0.15548529f, -0.08115852f, -0.12543821f, 0.18836470f, 
    0.16344701f, -0.18024842f, 0.28282782f, -0.09135979f, 0.01300799f, -0.08219217f, -0.12820058f, 0.26773006f, 
    -0.17050324f, 0.14469163f, -0.41833168f, 0.33428639f, -0.23147808f, 0.11739700f, -0.05288240f, 0.00793743f, 
    0.10580083f, -0.06559733f, -0.30347812f, 0.12872171f, -0.06821543f, 0.04504777f, 0.11460920f, -0.03371137f, 
    0.34454849f, 0.38449356f, -0.11221592f, 0.08563946f, 0.13697664f, -0.61670649f, 0.00154484f, -0.02729389f, 
    0.00311590f, -0.16031688f, 0.00347825f, 0.07174537f, -0.06896834f, -0.03628962f, -0.08049913f, -0.17121710f, 
    -0.08055095f, 0.33345610f, -0.11165496f, 0.13239478f, -0.02529386f, 0.22824709f, -0.19361256f, 0.00375566f, 
    0.12948342f, -0.02302957f, 0.53378373f, -0.03413971f, 0.27145684f, 0.08892293f, 0.29079688f, 0.12398461f, 
    -0.32182077f, 0.43977606f, 0.07569882f, -0.15020251f, 0.12139492f, 0.25677732f, 0.13714395f, -0.22372243f, 
    -0.01663479f, -0.23615865f, 0.08915940f, -0.07057540f, 0.14648543f, 0.08918951f, -0.13927893f, 0.31793988f, 
    0.10863360f, 0.20437811f, 0.32117778f, -0.07460621f, 0.11587439f, -0.67076051f, -0.32519519f, -0.13551983f, 
    0.11707766f, 0.10312853f, -0.15712224f, -0.11423201f, 0.03043361f, 0.15491854f, 0.24737169f, 0.07716180f, 
    0.01076813f, 0.18912126f, 0.14651036f, -0.12620354f, 0.12336511f, -0.14177126f, -0.08051006f, 0.16965766f, 
    -0.00871224f, -0.05563478f, -0.10984753f, 0.05291905f, 0.06946260f, -0.06012692f, -0.08203597f, 0.25873238f, 
    -0.01598367f, 0.17228185f, -0.13355128f, 0.05067325f, -0.20689937f, -0.17713307f, 0.08165703f, 0.13198507f, 
    -0.15447260f, -0.10995606f, -0.46216947f, 0.07159808f, 0.02042104f, 0.02603065f, 0.40487146f, -0.10289608f, 
    0.14441288f, 0.34408000f, -0.08049650f, 0.17163664f, 0.15801914f, 0.09306596f, 0.29156968f, -0.14499995f, 
    -0.08031502f, -0.01688570f, 0.23486626f, 0.08061773f, 0.09840114f, -0.03589495f, -0.24331440f, -0.17344508f, 
    0.05169142f, -0.14993136f, -0.08144598f, 0.19501686f, -0.27361301f, -0.11048170f, -0.02110756f, -0.16354895f, 
    0.07042073f, 0.15327312f, 0.02909955f, -0.05665256f, -0.08836773f, -0.06673171f, 0.14865798f, -0.00453118f, 
    -0.11262941f, -0.07557577f, 0.07660811f, 0.44765654f, -0.18061975f, -0.45810193f, 0.09746128f, -0.06883853f, 
    0.00874985f, 0.32875571f, 0.24167159f, 0.18407898f, 0.04936862f, -0.00907994f, 0.27508724f, 0.22459084f, 
    0.16038255f, -0.14450747f, -0.34355071f, 0.01476393f, 0.21667443f, 0.48694891f, 0.20194086f, -0.00270931f, 
    -0.14891778f, -0.05108204f, -0.19340363f, -0.09811158f, -0.07659357f, 0.10254043f, -0.02903867f, -0.00499257f, 
    -0.11947394f, 0.15638036f, -0.04396113f, -0.21317458f, 0.02034456f, -0.20690453f, 0.49103534f, 0.05035271f, 
    -0.05226062f, -0.07858207f, 0.07243610f, -0.37659916f, 0.15916277f, 0.11777966f, -0.16864429f, 0.10449985f, 
    0.01926956f, 0.08603722f, -0.37624136f, 0.24413195f, -0.24620843f, -0.56825668f, 0.18742602f, 0.06358049f, 
    -0.05090172f, -0.11773382f, -0.18831488f, 0.16025676f, 0.22176144f, -0.01710844f, 0.04906457f, -0.05131567f, 
    -0.21284863f, 0.34671590f, 0.11224100f, -0.10126185f, -0.06904423f, 0.08851252f, 0.32010242f, 0.03579762f, 
    0.00636139f, 0.05042798f, -0.24061871f, 0.04193394f, 0.04389829f, 0.10525769f, 0.06112503f, 0.35187495f, 
    -0.08634806f, 0.01972220f, 0.34501392f, 0.18398835f, 0.06344459f, 0.17810042f, -0.24559481f, 0.10196614f, 
    -0.03424061f, -0.11139148f, 0.49687093f, -0.15174131f, -0.31181887f, -0.09110223f, -0.02896895f, 0.17097728f, 
    0.38419300f, -0.13783996f, -0.07587159f, 0.11861671f, -0.06723046f, 0.17785114f, -0.06158253f, 0.19191840f, 
    -0.10669247f, -0.16438600f, 0.35277912f, 0.16778347f, 0.12614399f, -0.02907920f, -0.30255330f, -0.32003137f, 
    0.08765615f, -0.09696861f, -0.01311480f, -0.07763901f, 0.33280718f, 0.16257618f, 0.09489417f, 0.01594605f, 
    -0.00534289f, -0.05811584f, 0.05725182f, -0.02515351f, -0.05852558f, 0.09695172f, -0.20745453f, 0.07359228f, 
    0.25568420f, -0.18346363f, 0.05536715f, 0.04621811f, -0.03631682f, 0.38504040f, 0.11737589f, 0.17276752f, 
    -0.10904647f, -0.04434647f, 0.12192342f, 0.07797842f, 0.01730326f, -0.00719603f, -0.37686864f, 0.00464789f, 
    0.16146041f, 0.21684828f, -0.07507367f, 0.16740443f, 0.20410745f, 0.14583836f, 0.24256490f, 0.15318285f, 
    0.12166394f, -0.07929539f, 0.13560537f, -0.11998528f, 0.23414351f, -0.05806759f, 0.24221024f, 0.01096100f, 
    -0.05377800f, 0.36835909f, 0.05390932f, -0.05506774f, -0.02660037f, 0.30528829f, 0.21172409f, -0.10912582f, 
    0.01565815f, -0.26276726f, -0.23243821f, -0.23497500f, -0.06319723f, -0.08957653f, 0.13822471f, -0.13846892f, 
    0.11844808f, 0.17348382f, 0.28084388f, -0.06210871f, 0.23109896f, 0.30648538f, -0.13700107f, -0.16082633f, 
    0.10815166f, -0.09957790f, 0.45886680f, 0.02511678f, -0.10338853f, -0.10872129f, -0.28681430f, -0.08025040f, 
    0.10249121f, -0.28188685f, -0.07885494f, -0.06330188f, 0.00669942f, -0.25743762f, -0.16291207f, 0.23789723f, 
    0.11381204f, 0.38077298f, -0.15000221f, -0.10269824f, 0.01628879f, -0.14966592f, 0.55366230f, 0.31472820f, 
    0.06510694f, -0.01728929f, 0.03248575f, 0.20942585f, 0.21289304f, -0.29820737f, 0.35572881f, -0.04711638f, 
    -0.01944352f, 0.02253758f, 0.27206987f, -0.06341804f, -0.06899055f, 0.14174469f, 0.28137439f, -0.01769145f, 
    -0.43166167f, 0.01359593f, -0.08759925f, -0.01792119f, -0.16816141f, 0.36104432f, -0.04912312f, 0.27427840f, 
    0.08721907f, -0.28085443f, 0.06444355f, -0.06887354f, -0.07721218f, 0.10094721f, -0.06194550f, 0.10313995f, 
    -0.14001629f, 0.16796708f, 0.15257958f, -0.10298243f, 0.09358903f, 0.21046537f, 0.02487898f, -0.00172818f, 
    0.03006975f, 0.15470994f, 0.50825727f, -0.16798265f, 0.04704295f, -0.10464340f, 0.25385535f, 0.04974588f, 
    0.34273836f, 0.19505887f, -0.06040590f, -0.15712406f, -0.07022862f, 0.45737314f, 0.10774802f, 0.00375726f, 
    -0.16744542f, -0.38237992f, 0.13600837f, 0.14655299f, -0.13519000f, 0.05245546f, -0.06734176f, -0.22491051f, 
    -0.12472391f, -0.27666235f, 0.30435336f, 0.18596290f, -0.07769343f, 0.20632647f, 0.04821137f, -0.01540656f, 
    0.17708592f, -0.15180050f, -0.24567768f, 0.13967986f, -0.17182116f, -0.05846023f, 0.09290518f, 0.12017533f, 
    0.13757531f, -0.00965900f, 0.02330481f, -0.15287475f, -0.14625458f, 0.11090371f, 0.25367099f, 0.31197637f, 
    0.06118498f, -0.16816217f, 0.31861314f, -0.24045140f, -0.16879529f, 0.15587947f, 0.04431612f, -0.29220811f, 
    0.06246031f, -0.27523845f, 0.09409487f, 0.19797164f, -0.04471514f, -0.24886851f, 0.33007553f, -0.08798021f, 
    0.03651552f, -0.03920019f, -0.49241912f, -0.12766218f, -0.27932158f, -0.10114506f, -0.00237468f, 0.15075383f, 
    -0.07077053f, 0.15924369f, -0.08163181f, 0.08297095f, -0.04665262f, 0.16895786f, 0.12869029f, 0.18728456f, 
    -0.01299528f, -0.04281012f, 0.35719830f, 0.20222747f, -0.05244758f, 0.05299052f, -0.56248164f, 0.01542530f, 
    0.05280785f, 0.12098345f, 0.16409877f, -0.08795448f, -0.08510967f, 0.43962854f, -0.21937862f, 0.08340637f, 
    0.07606173f, 0.03042698f, 0.16488014f, -0.10498346f, -0.16545732f, -0.17826568f, -0.01496227f, 0.00291674f, 
    0.53638381f, -0.01134297f, -0.08807757f, 0.25583273f, 0.07844625f, 0.04194541f, -0.14500855f, -0.10887092f, 
    -0.08738383f, 0.27986789f, 0.14873987f, 0.15159865f, -0.10015134f, -0.01369083f, 0.23508190f, 0.08709954f, 
    -0.11464191f, -0.30571622f, 0.15000065f, 0.02985152f, 0.15705188f, 0.35579339f, 0.15938842f, -0.08701143f, 
    -0.06008761f, -0.05406726f, -0.17561400f, 0.05546329f, -0.20001598f, 0.06693789f, 0.21978967f, -0.03522632f, 
    0.03171855f, -0.03715935f, -0.15220156f, 0.05948075f, -0.08243664f, -0.23090920f, 0.19414282f, 0.29302472f, 
    0.03701718f, -0.13598518f, 0.04077644f, -0.16421141f, -0.01703628f, 0.06000483f, 0.11754916f, -0.25389701f, 
    0.04271600f, -0.03278264f, 0.20942836f, 0.10343590f, 0.22766675f, 0.12415726f, 0.03666529f, 0.15439627f, 
    0.17489509f, 0.16219130f, 0.22287016f, -0.03056070f, 0.24036278f, 0.09010556f, 0.20153120f, -0.11179991f, 
    -0.24556042f, -0.20487399f, 0.00274507f, -0.11502843f, 0.16024335f, 0.23964661f, 0.08075272f, 0.29513931f, 
    0.09580189f, -0.15987818f, -0.17670302f, -0.19324762f, 0.16501869f, 0.10994843f, -0.00093119f, -0.08299935f, 
    0.14483592f, 0.03136260f, -0.03766297f, 0.26892477f, 0.06892069f, 0.31596553f, 0.14985208f, -0.04769615f, 
    -0.13425514f, 0.08903398f, 0.24227923f, -0.17613061f, 0.09322780f, 0.09770979f, -0.30708531f, 0.16580915f, 
    -0.07673542f, 0.00085571f, -0.10125220f, -0.00070853f, 0.00134615f, 0.03867618f, 0.23476616f, 0.25936636f, 
    -0.05252975f, 0.13063002f, -0.27237037f, -0.19471239f, -0.07324392f, 0.02411316f, 0.35482019f, -0.28434119f, 
    -0.11501601f, 0.02251702f, -0.02344903f, -0.10977522f, -0.11323565f, 0.17312430f, 0.00746588f, 0.11728948f, 
    0.04684124f, -0.10857961f, -0.06427747f, 0.11638370f, -0.04774128f, 0.15415683f, 0.08764253f, 0.16716991f, 
    -0.15577017f, 0.08023355f, 0.10466861f, 0.03769025f, -0.15722419f, -0.10313462f, 0.04538855f, -0.08410624f, 
    0.10975145f, -0.01348379f, -0.07379539f, -0.10264795f, -0.14896749f, 0.02896630f, 0.02764010f, -0.10184835f, 
    0.00548250f, 0.09122994f, 0.18164825f, -0.30538139f, 0.26933357f, -0.14757623f, 0.07836075f, -0.16002579f, 
    -0.15059808f, -0.10120362f, -0.18881524f, 0.02362022f, 0.10291664f, 0.15107240f, 0.20940500f, 0.04758769f, 
    0.42882347f, 0.30101377f, 0.02989290f, -0.24990265f, -0.03459847f, 0.31624866f, 0.30058983f, -0.20899092f, 
    0.10153907f, -0.04249729f, -0.08183708f, 0.12383141f, -0.12588672f, 0.06707718f, -0.00775519f, 0.14487493f, 
    -0.09666347f, -0.06956779f, 0.04350799f, 0.07740337f, 0.12912914f, -0.00951923f, 0.13329072f, 0.11179856f, 
    0.06144661f, -0.17497084f, 0.24829681f, -0.07761277f, 0.11033450f, -0.12210278f, 0.45690513f, 0.17131284f, 
    -0.19098708f, 0.00581478f, 0.10627404f, -0.14855500f, -0.10440345f, 0.21349449f, 0.21101087f, 0.37097031f, 
    -0.15489988f, -0.18948533f, -0.22936195f, -0.19698884f, -0.01923567f, 0.07446811f, 0.28253785f, 0.32478291f, 
    0.03900758f, -0.12171466f, -0.10394757f, -0.15484270f, -0.01075489f, -0.15998617f, -0.02313277f, 0.11940790f, 
    -0.14013302f, -0.08313013f, -0.13549489f, 0.15208347f, -0.12299108f, 0.09579768f, 0.04680906f, 0.03460366f, 
    0.05765087f, 0.07330044f, 0.02332695f, -0.04456187f, 0.07974829f, -0.02546942f, -0.05026486f, -0.17913061f, 
    0.08132856f, -0.08257548f, 0.09826944f, -0.19734670f, -0.14453122f, 0.01057707f, 0.09275406f, -0.18900973f, 
    -0.06963100f, 0.32549596f, -0.00821808f, -0.13722397f, 0.23036835f, 0.22181450f, -0.17564750f, 0.04637856f, 
    -0.01218695f, -0.03249358f, 0.22385879f, -0.10549020f, 0.09158320f, -0.06759381f, 0.14922777f, -0.07462451f, 
    0.33609435f, 0.18388565f, -0.06137134f, 0.04280076f, -0.13887899f, 0.09476879f, -0.11264046f, 0.07388721f, 
    -0.01075258f, 0.18376586f, -0.21328790f, 0.09818401f, 0.14635281f, 0.08852177f, 0.08436439f, 0.12400728f, 
    0.14181086f, -0.15484822f, -0.01760661f, 0.28805774f, -0.01127115f, -0.19326316f, 0.31009954f, -0.09606279f, 
    -0.09798270f, -0.00702747f, -0.28579581f, 0.14931792f, -0.01789892f, 0.13479538f, 0.42137167f, 0.12606373f, 
    -0.29997590f, 0.08162592f, -0.06560709f, 0.16032083f, 0.01230477f, 0.09207404f, 0.09958662f, -0.01826216f, 
    -0.15926014f, -0.05417313f, -0.21788792f, -0.28471079f, -0.12900101f, -0.00533513f, 0.24015719f, -0.19822189f, 
    -0.16687253f, -0.16470906f, 0.08882503f, -0.01859744f, 0.14035898f, 0.16029872f, -0.10014439f, -0.13382520f, 
    0.13755374f, 0.00330813f, 0.29903495f, 0.14374812f, -0.24837409f, 0.10584034f, 0.44604573f, 0.11826614f, 
    0.24211805f, -0.11697558f, -0.17616330f, 0.35536838f, -0.08602405f, -0.04565436f, -0.20045950f, -0.11341141f, 
    0.09426460f, -0.14863414f, 0.47070026f, 0.05955799f, 0.01977992f, 0.02306815f, 0.03764477f, 0.27810070f, 
    -0.12666540f, -0.04734614f, -0.07402508f, -0.14928542f, -0.16523746f, -0.09470666f, -0.10365109f, 0.06643159f, 
    0.05034083f, -0.00770615f, -0.04256454f, 0.00947101f, 0.08333745f, -0.03283041f, -0.15842627f, -0.02509482f, 
    0.07046340f, 0.02428586f, -0.09932543f, -0.12319379f, 0.01919962f, -0.09328140f, 0.02832477f, 0.14111736f, 
    0.11841368f, -0.05896437f, -0.02753515f, -0.15853748f, -0.16739458f, -0.08193716f, -0.03533476f, -0.11444694f, 
    0.03015297f, 0.13379003f, -0.20520790f, 0.15672404f, 0.08474553f, 0.30538437f, -0.03060947f, -0.00854289f, 
    0.01185520f, 0.09838410f, 0.51671451f, -0.12814160f, 0.10652436f, -0.05927994f, 0.20178163f, -0.14445707f, 
    -0.20190077f, 0.28281459f, 0.09133234f, -0.32220167f, -0.02352614f, -0.03858687f, 0.27280217f, -0.09147175f, 
    -0.01743681f, -0.33330774f, 0.00414437f, 0.01541260f, -0.11441243f, 0.07956824f, -0.06859712f, -0.23018272f, 
    -0.07711993f, 0.20042773f, -0.17753702f, 0.11517628f, 0.05948756f, -0.15738501f, 0.00208023f, 0.11816178f, 
    -0.19077887f, 0.14611866f, -0.34899211f, 0.00596972f, -0.26082492f, -0.04414058f, -0.04913835f, 0.15020753f, 
    0.23851819f, 0.32125250f, -0.00473246f, 0.29590833f, 0.10377719f, -0.03185763f, -0.16163990f, -0.02092560f, 
    0.03324129f, 0.26389262f, 0.33386481f, 0.03941903f, 0.00140271f, -0.03715169f, -0.30765170f, 0.30124414f, 
    -0.04705362f, -0.07238535f, -0.10471043f, 0.14923112f, -0.00063339f, -0.35975471f, 0.20504262f, -0.07569478f, 
    -0.07130021f, -0.11361135f, -0.10163984f, 0.15423600f, 0.25937322f, 0.09871498f, -0.35162252f, -0.15755819f, 
    0.28423095f, -0.07124272f, -0.11526963f, 0.04601661f, -0.02730682f, -0.30466846f, 0.15041536f, -0.10612634f, 
    0.01333444f, 0.27189711f, -0.24979356f, 0.21530083f, -0.17599523f, -0.03867880f, 0.52000386f, -0.04075752f, 
    0.04251408f, 0.00697646f, 0.11189462f, 0.16217527f, 0.23725963f, 0.29103124f, 0.05252325f, -0.15126620f, 
    0.05280361f, 0.00284413f, -0.07801817f, 0.07523483f, 0.16350204f, -0.01724604f, -0.20105208f, -0.09630500f, 
    0.18842444f, 0.22050914f, 0.16639094f, -0.18865739f, -0.08628975f, 0.04543867f, 0.35515824f, 0.01480426f, 
    0.10314943f, -0.01839387f, 0.00102294f, 0.25711027f, -0.03539138f, 0.07655156f, -0.07859654f, -0.35915953f, 
    -0.02074972f, 0.15931275f, -0.00518460f, 0.12050970f, 0.18397650f, -0.15452829f, 0.17400388f, -0.15695541f, 
    -0.03406692f, 0.01073755f, -0.21445103f, 0.11147861f, 0.19188856f, 0.04408301f, -0.36166537f, -0.03036371f, 
    0.26374772f, 0.26083532f, -0.06989351f, -0.23541991f, -0.12040328f, 0.34528753f, 0.15247622f, -0.10922883f, 
    -0.11569613f, 0.22551091f, -0.10775732f, 0.21698132f, -0.15247510f, -0.11871436f, -0.26846078f, -0.22798280f, 
    -0.16762523f, 0.05215526f, -0.24195795f, -0.05812950f, -0.16622989f, -0.01679817f, 0.20380187f, -0.00490125f, 
    -0.04727099f, 0.01818087f, 0.39349669f, 0.00394368f, 0.00991326f, -0.05675622f, 0.30467641f, 0.11650489f, 
    0.08798499f, 0.07171283f, -0.01441455f, 0.27524775f, -0.05422911f, 0.08395051f, -0.19731097f, -0.11517797f, 
    0.09721076f, -0.15169135f, 0.39262176f, 0.14751822f, 0.16718477f, 0.14474054f, -0.08901920f, 0.35977986f, 
    0.14266485f, -0.27975008f, -0.15859610f, 0.07128160f, -0.11515020f, 0.13997701f, 0.19475694f, -0.04610036f, 
    -0.06134593f, 0.15758649f, 0.08038060f, -0.05335204f, -0.09436406f, -0.13636035f, -0.12485811f, 0.13734904f, 
    0.18374370f, 0.14208244f, 0.11131814f, -0.46411943f, 0.05247038f, 0.13973549f, 0.33964542f, 0.19326697f, 
    0.14331743f, -0.42128134f, 0.17439041f, 0.27090132f, -0.05911234f, 0.14497457f, 0.13667947f, 0.17094624f, 
    -0.08885592f, 0.39499751f, 0.29702449f, -0.16700895f, 0.20825416f, -0.07131874f, -0.06916995f, -0.11563263f, 
    0.10322186f, 0.11652473f, -0.19917393f, -0.01412707f, -0.05378459f, -0.16395719f, 0.17525254f, 0.10230453f, 
    0.33859023f, 0.09823849f, 0.13039139f, -0.06533105f, 0.06308608f, 0.26081491f, -0.15548031f, -0.06164316f, 
    0.05688429f, 0.04271117f, -0.07464368f, -0.06802376f, -0.01783746f, -0.05833324f, 0.23378618f, 0.41155058f, 
    0.15456221f, -0.12679780f, -0.12174007f, -0.13893266f, -0.14519124f, -0.12886120f, -0.10990390f, -0.15563914f, 
    -0.08382846f, 0.15098611f, -0.04171452f, 0.01816460f, -0.10480282f, 0.06805232f, 0.11731591f, -0.09952961f, 
    -0.17257269f, -0.08547539f, 0.12740891f, -0.03824491f, 0.12713687f, 0.15967542f, 0.12827721f, 0.05385185f, 
    0.02744095f, 0.08775370f, -0.03566634f, -0.08327176f, -0.06881841f, -0.13552745f, 0.06506550f, -0.01465513f, 
    -0.08265932f, 0.08087599f, 0.40086448f, 0.10014338f, 0.16251901f, -0.60569918f, 0.22547790f, -0.04077610f, 
    -0.12648958f, -0.01223250f, -0.37954789f, 0.17470978f, -0.13085671f, -0.14818244f, -0.17340139f, 0.01464891f, 
    0.20336826f, -0.25760183f, 0.15813702f, -0.01991814f, -0.14221846f, 0.21457739f, -0.12894298f, 0.27132410f, 
    -0.07313665f, -0.13164048f, 0.04448286f, -0.01955745f, 0.06564417f, -0.06638653f, 0.22528608f, -0.11420660f, 
    -0.07263409f, -0.15368845f, -0.02314796f, -0.03820138f, -0.03552254f, 0.05052638f, -0.12081683f, -0.02516293f, 
    -0.02683167f, -0.16577673f, 0.11354009f, 0.03537143f, -0.15531823f, 0.03856641f, 0.00533446f, -0.00640843f, 
    0.01528485f, -0.11548175f, 0.07891665f, -0.08996091f, -0.11833358f, -0.00784142f, -0.12352541f, -0.09678018f, 
    -0.08761057f, -0.12115661f, 0.13839369f, -0.11392543f, -0.06334341f, 0.04771019f, 0.05829765f, -0.02360809f, 
    0.15589286f, 0.24848367f, -0.10761669f, -0.17079718f, 0.24186698f, 0.28065267f, -0.16298045f, -0.02250616f, 
    0.07753135f, -0.06261955f, 0.42586657f, 0.13211752f, 0.33481458f, -0.07858469f, -0.04239030f, -0.03358419f, 
    0.39242664f, 0.09633064f, -0.05442974f, -0.26523405f, 0.00001880f, 0.26358005f, 0.05249120f, 0.01262805f, 
    -0.14740756f, 0.14772269f, -0.13712251f, 0.16963534f, 0.16215435f, -0.10200873f, 0.26621646f, -0.13720067f, 
    0.14648633f, 0.05895583f, -0.13033965f, -0.12535110f, 0.21914469f, -0.00608003f, 0.05665609f, -0.02624509f, 
    -0.04874893f, 0.03397490f, 0.39717969f, -0.10651881f, 0.21681729f, -0.14042735f, -0.29749760f, 0.03524258f, 
    0.13447621f, -0.12094076f, -0.09786031f, -0.09895022f, 0.15140262f, 0.26527205f, 0.16885753f, 0.20474321f, 
    -0.07507221f, 0.06157206f, -0.16763240f, 0.14098912f, 0.10359258f, 0.02380866f, 0.27859822f, 0.20323807f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00237327f, 0.08245992f, -0.09926058f, 0.16605145f, -0.02146798f, 0.07313017f, 0.04399340f, 0.02662458f, 
    0.20581236f, -0.04128953f, 0.20133676f, 0.15135212f, -0.00532532f, 0.06845329f, 0.09293180f, 0.14477971f, 
    0.05292301f, 0.18698232f, -0.07405078f, 0.04722001f, -0.01200637f, -0.00208622f, 0.10550870f, 0.04984917f, 
    0.07752734f, -0.15397945f, -0.22830237f, 0.18691641f, 0.17117648f, -0.03732366f, 0.21194072f, -0.09875285f, 
    0.06386074f, 0.18524766f, -0.06083165f, 0.01858677f, -0.01577118f, 0.08496193f, 0.25291768f, 0.23217988f, 
    0.10150322f, 0.15633592f, 0.05807411f, -0.17225800f, 0.11763684f, 0.02319522f, -0.01441469f, -0.07952478f, 
    0.27752155f, 0.08982407f, -0.10809800f, -0.13412371f, 0.20192952f, 0.11612611f, 0.04040752f, 0.09680551f, 
    0.14557551f, -0.13454075f, 0.24557550f, -0.06616134f, 0.43036276f, -0.03675281f, -0.00460395f, 0.08379366f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03778037f, 0.00790288f, -0.13225739f, -0.27393776f, 0.14772166f, -0.05308360f, 0.38209915f, 0.04059119f, 
    -0.12358885f, -0.01623881f, -0.17683917f, 0.28088173f, 0.27332804f, -0.05590512f, 0.26254156f, -0.02199247f, 
    0.04465145f, -0.12647259f, 0.01325151f, -0.15274498f, 0.02747252f, 0.06071373f, -0.08678280f, 0.15475330f, 
    0.29531741f, 0.11091238f, -0.12977928f, 0.06306790f, -0.26247418f, 0.48984984f, 0.21310169f, 0.12775636f, 
    0.35019609f, 0.22792147f, -0.10108595f, -0.02519438f, 0.10917520f, 0.44341353f, 0.26601195f, -0.14642797f, 
    0.25084388f, 0.16951273f, 0.14389870f, 0.06788834f, 0.08967704f, 0.07014683f, 0.00572630f, -0.16949593f, 
    -0.04680192f, -0.31275260f, -0.10350105f, -0.06502079f, -0.03884178f, 0.12736368f, 0.35957271f, 0.34784412f, 
    -0.16682138f, 0.44258845f, -0.15865986f, 0.00804436f, 0.03559987f, -0.02070911f, -0.04325091f, 0.24812019f, 
    0.35119835f, 0.39070535f, 0.06928786f, 0.51178640f, 0.16000128f, 0.37848845f, -0.18475881f, -0.07990241f, 
    0.28672928f, -0.22586952f, 0.08025990f, -0.13035394f, -0.15644760f, -0.05767873f, -0.19726142f, 0.07782479f, 
    -0.02912783f, 0.03793228f, -0.16931015f, -0.05955652f, 0.07034872f, 0.20670472f, 0.09454546f, 0.03693592f, 
    0.09698407f, 0.18093790f, 0.33208466f, -0.10669802f, 0.21785176f, 0.36937830f, -0.02611308f, 0.12278906f, 
    -0.12431211f, 0.16096401f, 0.61168790f, -0.01605766f, -0.09450721f, 0.05973139f, -0.28393561f, 0.15383661f, 
    0.27408776f, 0.19664723f, 0.17355661f, 0.11990292f, -0.21228987f, 0.13636985f, 0.04425524f, 0.05489590f, 
    0.07765593f, 0.08299722f, 0.00525472f, 0.14694643f, -0.22239707f, 0.18570302f, -0.05747275f, -0.20821023f, 
    -0.07854319f, -0.16831411f, -0.01569510f, 0.00531214f, -0.19587116f, -0.09964710f, 0.28461564f, 0.11145451f, 
    0.28792000f, 0.31585765f, 0.00337135f, 0.01113673f, 0.39716583f, -0.13399425f, 0.12628898f, -0.10560791f, 
    0.28482041f, -0.20483375f, -0.05382000f, 0.14683130f, 0.03625154f, 0.01564872f, 0.07985393f, -0.05895188f, 
    -0.11684616f, -0.05085860f, -0.24624702f, -0.34943724f, 0.08815829f, -0.16226751f, 0.07673694f, 0.04222020f, 
    -0.33899000f, -0.15523808f, 0.02873698f, -0.08335572f, -0.05637684f, 0.38487989f, -0.02107887f, -0.13494110f, 
    -0.03922858f, 0.10251138f, 0.23065858f, 0.18800209f, -0.06078424f, 0.32433325f, -0.03188216f, -0.02499846f, 
    0.35113034f, 0.18597057f, 0.08396516f, 0.07190512f, 0.10488330f, 0.35801342f, 0.12896161f, 0.06788187f, 
    0.23668075f, -0.10062189f, 0.01995865f, -0.19775401f, -0.23402777f, 0.31515861f, 0.12658536f, 0.07324392f, 
    -0.37727740f, 0.02135538f, 0.04196540f, 0.02174161f, 0.26852757f, -0.04275438f, 0.30240175f, 0.14047734f, 
    0.05830758f, 0.02388854f, -0.08678404f, -0.01242619f, -0.15448484f, 0.13454889f, 0.22254868f, -0.17038286f, 
    0.15235820f, 0.16046375f, -0.03102485f, 0.11390210f, -0.13947849f, 0.08968650f, -0.21741539f, -0.15142769f, 
    -0.24954298f, -0.14490081f, 0.04631871f, 0.14317217f, -0.14729008f, 0.08658612f, -0.04656575f, 0.05074324f, 
    -0.23890275f, 0.15451892f, -0.27385789f, 0.27585796f, 0.08717120f, 0.67549336f, 0.39748883f, -0.27816665f, 
    0.06995714f, 0.26942930f, -0.02471456f, -0.15151934f, -0.02123460f, -0.18172200f, -0.22255798f, 0.06831629f, 
    -0.01346679f, -0.07689577f, 0.23181294f, 0.14992720f, 0.16452600f, 0.20921521f, -0.05387904f, 0.09369130f, 
    0.08200097f, -0.26790765f, -0.10090767f, 0.38774270f, -0.09428382f, 0.37023923f, 0.08869044f, 0.20369080f, 
    -0.07142202f, 0.10282540f, -0.18454055f, 0.01959069f, -0.36795998f, -0.05930324f, 0.39132947f, 0.23368092f, 
    -0.05608247f, 0.10815986f, -0.25182000f, 0.30408782f, 0.05477811f, 0.24580655f, -0.12117882f, -0.08437520f, 
    0.16960484f, -0.23514809f, -0.09109472f, 0.11110950f, 0.07977454f, 0.10574503f, -0.28829753f, -0.25367931f, 
    -0.18743883f, -0.20040499f, 0.11409100f, -0.21729048f, -0.08324112f, -0.29187563f, -0.15584469f, 0.35031638f, 
    -0.27707338f, 0.38833404f, -0.10266328f, -0.19517042f, -0.36018619f, -0.24717732f, -0.20264554f, 0.15693322f, 
    0.15276127f, 0.12952542f, 0.13172300f, 0.08949926f, 0.33553785f, -0.08143968f, -0.04949474f, -0.00260556f, 
    -0.19021255f, 0.17818558f, 0.09412056f, 0.02504804f, -0.05313564f, 0.24478437f, 0.09319580f, 0.21015580f, 
    -0.08148254f, -0.07556578f, 0.05206951f, 0.15972207f, 0.00456340f, -0.60248435f, 0.03554252f, 0.08173136f, 
    0.25637168f, -0.13543150f, 0.06557450f, -0.02944830f, -0.20484166f, 0.04066603f, 0.37804255f, 0.11144286f, 
    0.04806955f, -0.14275181f, -0.17014575f, -0.27085164f, 0.00577585f, -0.11880992f, 0.21178633f, 0.04983610f, 
    0.01238748f, 0.04094706f, -0.16280182f, 0.19864376f, 0.18906046f, -0.03114423f, 0.19159321f, -0.06595370f, 
    0.05467361f, 0.07865765f, -0.16846211f, -0.00530636f, 0.01411468f, -0.02021296f, 0.06094986f, 0.20462660f, 
    0.08883328f, -0.13620186f, -0.15169163f, -0.01252517f, -0.11534762f, 0.53393471f, 0.01941389f, 0.09029143f, 
    0.36458424f, 0.21525274f, -0.36169618f, 0.23777632f, 0.23697737f, 0.37933123f, 0.33473012f, -0.24350189f, 
    0.42685592f, 0.17435698f, 0.21640301f, 0.02481130f, 0.13469797f, -0.05321136f, 0.07643054f, -0.15151113f, 
    0.06418219f, -0.04287117f, -0.00397553f, -0.01989535f, -0.15017223f, 0.15362789f, 0.39080322f, 0.23602141f, 
    0.06740206f, 0.35541606f, -0.20445912f, -0.09220552f, 0.24524568f, 0.00976384f, 0.15330942f, 0.29652798f, 
    -0.01077504f, 0.21203254f, 0.19234446f, -0.19402760f, 0.16532391f, -0.04674954f, -0.17748602f, -0.15779600f, 
    0.20058209f, -0.21056947f, 0.12906890f, 0.17858969f, -0.11305274f, 0.10666645f, 0.42796257f, 0.11620914f, 
    -0.02398560f, 0.08161429f, -0.14781885f, -0.01322573f, -0.02620436f, -0.01779104f, 0.18177849f, -0.31392285f, 
    0.12586647f, -0.06181154f, 0.01889325f, -0.13196196f, -0.17302081f, 0.01218351f, -0.27421275f, 0.28600243f, 
    0.42478138f, 0.01489047f, 0.27497238f, 0.00280124f, 0.02822106f, 0.18971866f, 0.05223650f, 0.26985323f, 
    0.13863385f, 0.12201911f, -0.05038292f, 0.09264540f, 0.14708242f, -0.15395947f, -0.12448596f, 0.21373270f, 
    -0.33189583f, -0.10526533f, 0.09888372f, -0.25384051f, 0.08975053f, -0.01953286f, 0.24415487f, 0.25607684f, 
    -0.03591699f, -0.12575977f, 0.08552349f, -0.07393915f, 0.10305122f, 0.02449353f, 0.36774763f, 0.17293401f, 
    0.09456985f, 0.17006928f, 0.01708950f, 0.31743130f, 0.12442572f, 0.35556298f, -0.12951666f, 0.03465287f, 
    0.22270280f, -0.29974291f, 0.24635127f, -0.03696375f, -0.25080770f, -0.03672935f, 0.10962706f, 0.15605390f, 
    -0.03363221f, 0.14372487f, -0.05600873f, 0.08302063f, 0.10024487f, -0.07636580f, 0.09969375f, -0.36930087f, 
    0.07625502f, -0.07075809f, -0.00048609f, -0.06116801f, 0.24723886f, -0.18333307f, -0.18202433f, -0.02121051f, 
    -0.10427349f, 0.05582398f, 0.25443372f, -0.22229324f, -0.14337574f, -0.10430638f, -0.14618941f, 0.43339717f, 
    -0.06939166f, -0.05131311f, 0.13104755f, 0.10197707f, 0.01862162f, -0.02611662f, -0.08027390f, 0.10348549f, 
    -0.04092056f, 0.16302638f, -0.00857493f, -0.06983151f, -0.01376069f, 0.14991769f, 0.07218939f, -0.02783970f, 
    -0.16587253f, -0.58528107f, 0.21139254f, 0.12107033f, -0.10378883f, 0.12278704f, 0.17443089f, -0.06997205f, 
    -0.33390215f, 0.11541943f, 0.30413848f, -0.39686385f, 0.06558561f, -0.13249454f, 0.20958336f, -0.29487121f, 
    -0.15572877f, 0.40223286f, 0.15434165f, 0.08422633f, 0.39324179f, 0.10072920f, -0.09299415f, 0.22536732f, 
    0.38589379f, -0.09787913f, -0.19542143f, -0.27533510f, -0.07564422f, 0.21684457f, 0.09607601f, 0.45377791f, 
    -0.15859255f, -0.01941949f, 0.08022980f, 0.00684797f, 0.21571594f, 0.29985261f, 0.40878412f, -0.20680536f, 
    0.12494256f, -0.11037759f, -0.05007332f, 0.18106049f, -0.41546488f, -0.13066861f, 0.38620502f, -0.25027162f, 
    -0.04906926f, -0.15781231f, -0.05625927f, -0.07378177f, -0.49053267f, 0.05933584f, 0.01194715f, -0.05728640f, 
    0.16709940f, -0.17667265f, 0.08250576f, 0.28069514f, 0.34867087f, 0.03336009f, -0.03173974f, -0.02100428f, 
    0.00043917f, 0.32972419f, -0.23703089f, 0.07865991f, -0.07832440f, -0.04598793f, -0.37558800f, -0.06366757f, 
    -0.27907431f, 0.15739831f, 0.30479309f, -0.51880044f, -0.13327709f, 0.00402108f, 0.17717481f, -0.35538587f, 
    0.05589837f, 0.14883658f, 0.24863309f, 0.13840331f, 0.06373487f, -0.09625331f, 0.09030603f, 0.39012396f, 
    0.24591002f, 0.01718669f, -0.29153186f, -0.49439996f, 0.08461837f, 0.29031053f, 0.29395658f, 0.09338111f, 
    0.11011200f, -0.15661931f, -0.08380323f, -0.16248979f, 0.28159618f, -0.04166497f, 0.27859950f, -0.16460343f, 
    -0.07054845f, -0.15813875f, 0.32318562f, -0.17222805f, -0.40562180f, -0.35245913f, -0.03466825f, 0.01193434f, 
    -0.28622574f, -0.16158792f, 0.27977553f, -0.05275453f, -0.38531640f, -0.27289191f, 0.09195291f, 0.10275482f, 
    -0.01280250f, -0.10046683f, -0.01516080f, 0.17732596f, 0.19006926f, 0.49504298f, 0.06217701f, 0.21149041f, 
    -0.09807364f, -0.22970024f, -0.25145113f, -0.03473789f, 0.05433780f, -0.06777856f, 0.02430886f, 0.14094348f, 
    -0.02618936f, -0.12967755f, 0.00286805f, -0.03886114f, 0.05049109f, -0.09584640f, -0.08815895f, -0.01764910f, 
    -0.10647230f, -0.00462815f, 0.04283949f, 0.02925694f, 0.00723238f, -0.04095958f, -0.03195243f, -0.07139705f, 
    -0.12896264f, 0.08129243f, 0.01140158f, 0.05580330f, 0.11863990f, -0.01552780f, -0.14095539f, -0.13702960f, 
    -0.07653745f, -0.06460565f, 0.08856989f, -0.01314859f, -0.13404544f, -0.01661664f, 0.01724024f, -0.04511500f, 
    0.07564291f, 0.04304468f, -0.15161578f, -0.05492754f, 0.10205392f, 0.02498087f, 0.03944271f, -0.11644974f, 
    -0.14251886f, 0.06189694f, -0.07304420f, -0.09326795f, 0.08191955f, -0.08346209f, 0.11545777f, -0.09642432f, 
    0.00323881f, 0.01927043f, 0.08600993f, 0.05863012f, -0.11576564f, -0.06547029f, -0.04090833f, -0.03571738f, 
    -0.01119397f, -0.06823460f, -0.01757649f, -0.07893725f, -0.12691155f, -0.02261551f, 0.00766593f, -0.04252097f, 
    0.25423941f, 0.29959545f, 0.08612221f, 0.44792551f, 0.23194389f, 0.32452878f, -0.17696895f, 0.09642342f, 
    0.09686721f, 0.12386110f, -0.03757952f, 0.03955599f, 0.34928286f, -0.09665456f, -0.13411079f, -0.21517062f, 
    0.14217064f, 0.04123525f, -0.22457978f, 0.20938809f, -0.04988954f, 0.04563146f, 0.10060109f, 0.21749732f, 
    0.05637857f, 0.13605468f, -0.24529271f, 0.17457579f, 0.21120812f, 0.31507960f, 0.09976382f, -0.16125946f, 
    -0.03243130f, -0.01876627f, 0.04509773f, 0.14247733f, 0.00092045f, 0.35361713f, 0.01061228f, -0.15835056f, 
    0.42064679f, 0.14121366f, -0.03861315f, 0.04639939f, -0.27231088f, 0.18602610f, -0.00406478f, -0.10225121f, 
    0.29509839f, 0.18995252f, 0.01646613f, 0.11951102f, -0.09433271f, -0.13012680f, -0.20543805f, -0.24426001f, 
    0.03814169f, 0.01386687f, -0.15113555f, 0.05595136f, -0.18965596f, -0.07999642f, -0.35857573f, -0.14861135f, 
    0.14388902f, 0.05804245f, 0.13290317f, 0.12207557f, 0.01617645f, -0.07339394f, -0.21751598f, -0.10670007f, 
    0.07565986f, 0.18449101f, 0.03989900f, -0.26278460f, -0.06221131f, -0.05784552f, -0.24443813f, -0.05945151f, 
    0.20919749f, 0.05227334f, 0.07249332f, 0.17081283f, -0.10973303f, 0.01559043f, 0.18957116f, 0.11344571f, 
    0.05275054f, 0.07868489f, 0.19796088f, -0.06358960f, 0.02068827f, -0.19985637f, 0.12011907f, 0.03517696f, 
    -0.13724136f, -0.06036448f, 0.13821128f, -0.02129261f, 0.08263715f, -0.26387593f, -0.01293012f, 0.11993937f, 
    -0.16755457f, 0.13613334f, -0.23219769f, 0.08705243f, -0.12825021f, 0.15869869f, -0.08240013f, 0.09615102f, 
    0.04761651f, 0.24383904f, 0.06805201f, 0.11378458f, -0.03922873f, -0.07291418f, -0.07198374f, -0.31616706f, 
    0.16960262f, -0.10184971f, -0.13569422f, -0.12109396f, 0.00899435f, 0.00432624f, 0.02827595f, 0.10292540f, 
    -0.05521061f, -0.03628270f, -0.00821766f, -0.46732467f, -0.07584316f, -0.15836729f, 0.24673185f, -0.21025711f, 
    -0.00118882f, -0.14175253f, -0.14623000f, 0.26960132f, 0.00723123f, 0.00725833f, 0.32908115f, 0.07775092f, 
    -0.06264162f, 0.15107323f, 0.14276898f, 0.00312576f, -0.04490796f, -0.10882267f, 0.04355201f, -0.18530120f, 
    -0.12040219f, -0.04221306f, -0.29886150f, -0.14059655f, 0.02822819f, -0.02238134f, -0.00132440f, 0.04462357f, 
    0.31437832f, -0.07571104f, 0.22370732f, -0.09707075f, 0.24429990f, -0.23943055f, -0.03074440f, 0.30326352f, 
    -0.15678580f, 0.03315240f, 0.17863511f, 0.05484406f, 0.23582585f, -0.14556274f, 0.05522431f, 0.10662279f, 
    -0.20678526f, -0.03562221f, 0.10135175f, -0.06991380f, 0.08536184f, 0.40638340f, 0.17102517f, 0.30771041f, 
    -0.07683143f, -0.04235732f, 0.05764119f, -0.10844383f, 0.08190045f, -0.03698817f, 0.30220538f, 0.22246420f, 
    0.01376842f, 0.05169794f, 0.08906581f, 0.08327375f, 0.03621182f, 0.05785130f, -0.04789491f, 0.07023752f, 
    -0.12875816f, -0.01922577f, -0.05088662f, -0.05548691f, -0.05019642f, 0.03923067f, -0.11453430f, -0.05393293f, 
    -0.06421389f, -0.08255924f, 0.05359592f, -0.06462686f, -0.06781955f, -0.02875760f, -0.06708953f, -0.06741749f, 
    0.09248924f, -0.00472570f, -0.05459276f, -0.11234409f, -0.15861911f, 0.09447996f, -0.08398043f, 0.04914384f, 
    0.00114203f, -0.12983012f, -0.10042639f, 0.01628414f, -0.06324630f, 0.08908121f, 0.01516583f, -0.04658424f, 
    0.03753459f, 0.01279413f, -0.05900800f, -0.05227697f, -0.08475856f, 0.06716032f, 0.04167423f, -0.05128223f, 
    -0.02528541f, 0.03844160f, -0.07404558f, -0.04194043f, -0.08299591f, -0.04724348f, -0.01664320f, -0.02756562f, 
    -0.14910918f, -0.00009686f, -0.11081734f, -0.10984178f, -0.00984916f, 0.00979763f, 0.02362293f, 0.01631145f, 
    -0.10023037f, 0.24670057f, 0.27949411f, 0.13754471f, 0.05429040f, 0.18249962f, -0.26293570f, -0.21879052f, 
    0.14750260f, 0.09487280f, 0.09499304f, -0.02102023f, 0.24915956f, -0.04642396f, 0.00299523f, 0.21973850f, 
    0.20227158f, 0.01713699f, 0.00075848f, -0.47079346f, 0.07763165f, 0.11462449f, 0.02589669f, 0.33813262f, 
    0.45566902f, -0.09821980f, -0.02596938f, 0.02014766f, 0.21332037f, -0.34847382f, 0.12168249f, -0.11944931f, 
    -0.16506495f, -0.20104052f, 0.38004774f, 0.05564125f, -0.25401577f, -0.09853783f, 0.13609579f, 0.18482667f, 
    -0.18290001f, -0.13153861f, 0.04375551f, -0.15806448f, -0.25929421f, -0.00112086f, 0.03688788f, -0.10320365f, 
    0.08987173f, 0.28132102f, -0.11567540f, -0.10160508f, 0.27336776f, 0.06810590f, -0.32805037f, -0.12803599f, 
    0.19752385f, 0.25395930f, 0.07100517f, -0.07086384f, 0.13490710f, 0.01526496f, -0.19286138f, -0.07502192f, 
    0.37967703f, 0.31060177f, 0.00425236f, -0.06005990f, 0.31436071f, 0.22429098f, -0.15954617f, -0.09965383f, 
    0.24567395f, -0.14410274f, -0.21478644f, 0.18201031f, 0.31033427f, -0.06574692f, 0.21995127f, 0.10708576f, 
    -0.08562586f, 0.02372832f, -0.16004194f, -0.23581804f, -0.09873067f, 0.14923684f, -0.02858526f, 0.07966183f, 
    0.16510312f, -0.29249254f, 0.04583594f, -0.15232220f, 0.17124613f, 0.54654336f, -0.16080657f, -0.10761285f, 
    0.06349454f, -0.17339267f, 0.52045810f, 0.03964091f, -0.05876268f, 0.32182780f, -0.03359145f, 0.10905176f, 
    0.54550195f, 0.06821910f, 0.23383981f, -0.08806185f, -0.23023222f, -0.01112583f, 0.11767005f, 0.11987603f, 
    0.14473805f, 0.07874843f, -0.06664848f, -0.34119654f, -0.08746448f, 0.20391189f, 0.13157174f, -0.13287120f, 
    -0.07841783f, 0.13537672f, -0.17282934f, -0.08871645f, 0.10627169f, -0.12326236f, -0.07390539f, -0.04684320f, 
    0.09244438f, 0.25011081f, -0.14311995f, 0.42641458f, 0.02649701f, 0.29616466f, -0.19873634f, -0.09676966f, 
    0.14031211f, -0.08069208f, -0.13707523f, -0.09396341f, -0.18190670f, 0.05098082f, -0.20018730f, -0.29301059f, 
    -0.28368711f, 0.01358162f, 0.07670140f, -0.21452269f, 0.02962524f, -0.19335298f, -0.04046487f, -0.09195773f, 
    0.17615493f, 0.22182935f, 0.09587075f, -0.30785376f, -0.08300114f, -0.12473053f, -0.33314326f, 0.24453209f, 
    0.07303423f, 0.02828032f, 0.23896904f, 0.08644584f, 0.21238750f, -0.29167718f, -0.35057446f, 0.12572671f, 
    0.09411953f, 0.05075938f, 0.08762304f, 0.02532127f, 0.02438637f, 0.12804165f, -0.01568002f, 0.22956422f, 
    -0.14231631f, 0.24925296f, -0.07066481f, 0.23880617f, -0.10922216f, -0.24122988f, 0.01346515f, 0.04359911f, 
    0.30143496f, -0.10118632f, -0.00632891f, 0.09507082f, -0.34026086f, -0.08651766f, 0.18802959f, 0.14648698f, 
    0.21560752f, -0.01101917f, 0.04973641f, 0.30277550f, -0.18247190f, 0.17268616f, -0.30501783f, 0.16125496f, 
    0.08589114f, -0.06580435f, -0.23073921f, -0.31511450f, -0.17635688f, 0.00789824f, -0.17825444f, 0.12538840f, 
    0.05681434f, 0.15231921f, 0.25319064f, 0.54783940f, 0.07232179f, 0.15548727f, 0.19532818f, 0.01649352f, 
    0.10748806f, 0.13700184f, 0.26587072f, -0.06545818f, 0.04689713f, -0.01663403f, 0.09408823f, -0.04242150f, 
    -0.23076238f, -0.20683597f, 0.23070636f, 0.10357493f, 0.25295720f, -0.18155366f, 0.04295623f, 0.31200743f, 
    -0.34891242f, -0.07322516f, -0.35135344f, 0.09773411f, 0.22051390f, 0.18175857f, 0.04254119f, 0.18058638f, 
    -0.31477225f, 0.45277095f, 0.00088048f, -0.14956559f, 0.15040493f, -0.24182130f, -0.24609505f, -0.18015459f, 
    0.36777630f, 0.44656691f, 0.47910887f, -0.03255573f, 0.05564497f, 0.09478228f, 0.17425177f, 0.09207767f, 
    0.09402621f, 0.09017868f, -0.07898985f, 0.09762540f, -0.12886550f, -0.12110449f, 0.11288345f, -0.10923195f, 
    0.11036249f, 0.09017961f, -0.07662579f, 0.05341247f, 0.04152015f, -0.09060754f, 0.00872134f, 0.00341785f, 
    -0.01284090f, -0.13538282f, -0.04039691f, -0.00337037f, 0.06604207f, 0.05624717f, -0.11647429f, -0.07830459f, 
    -0.01545516f, -0.07205911f, -0.02697957f, -0.03640661f, -0.12854525f, -0.07093666f, -0.10352679f, -0.11558259f, 
    -0.09144764f, 0.04261868f, -0.07366809f, 0.05678087f, 0.03134164f, -0.03759018f, -0.06945641f, 0.03450415f, 
    0.07854211f, 0.06908564f, -0.12376822f, 0.00557902f, -0.10816516f, -0.01637764f, -0.09851694f, 0.07212370f, 
    -0.04870491f, -0.04507577f, -0.08759587f, -0.06686017f, 0.00137051f, -0.11185293f, -0.12770587f, -0.04733935f, 
    -0.05558121f, 0.06895836f, -0.06382608f, 0.08560131f, 0.04586498f, 0.06418714f, 0.06871661f, 0.11250322f, 
    0.21048775f, 0.01614891f, -0.36243105f, -0.16895609f, -0.05590053f, -0.00404935f, 0.18148689f, 0.00204979f, 
    0.11642670f, -0.04243657f, -0.12594582f, -0.03068672f, 0.04781184f, 0.02318946f, -0.51559353f, -0.24230139f, 
    -0.23710681f, 0.03962184f, 0.33891517f, 0.22251101f, 0.00659331f, -0.30250013f, -0.27192163f, 0.18182722f, 
    -0.13771078f, 0.40123495f, -0.33382228f, -0.06823011f, -0.11901369f, -0.14237668f, 0.05336538f, 0.03934156f, 
    0.20802262f, 0.13954179f, -0.17718598f, 0.24506311f, 0.37540901f, -0.13617790f, -0.20933476f, -0.18655118f, 
    -0.05500926f, 0.27151528f, 0.12857558f, 0.14924784f, 0.03147733f, 0.23119313f, -0.00100790f, 0.17395274f, 
    0.05848456f, 0.24303444f, -0.11437033f, 0.37404403f, -0.15568188f, -0.20224161f, 0.18003294f, 0.04708013f, 
    0.35984647f, -0.18751441f, -0.13231196f, -0.09469704f, -0.27910957f, 0.03897977f, 0.10971875f, 0.09514909f, 
    0.17576037f, 0.15450995f, 0.07865600f, 0.02423144f, -0.06904045f, -0.00664576f, -0.01965290f, -0.00447496f, 
    0.12801495f, -0.07780273f, -0.18993062f, 0.03710273f, -0.16180931f, -0.01190598f, -0.13177171f, -0.11467758f, 
    -0.12721267f, -0.00856220f, -0.02034679f, 0.07516062f, -0.09689082f, -0.04233985f, -0.04411790f, -0.07688046f, 
    0.15220940f, -0.03216559f, -0.02021456f, -0.13215266f, 0.06573877f, 0.04388446f, 0.01864454f, 0.09690400f, 
    -0.01829411f, -0.00687311f, 0.07379321f, -0.05490401f, 0.06936533f, -0.08871878f, -0.17386676f, 0.02078915f, 
    0.14923491f, 0.06615788f, 0.13954465f, 0.13369858f, -0.10154907f, 0.03835081f, -0.11686210f, 0.00603287f, 
    0.08635518f, 0.05377023f, -0.09575203f, 0.13679783f, -0.18566960f, 0.14447039f, -0.08995473f, -0.00305255f, 
    -0.01799638f, 0.04789222f, -0.07110485f, -0.02038950f, 0.01731653f, -0.04425232f, 0.14432283f, -0.03014451f, 
    0.05779221f, -0.03511078f, -0.08941108f, -0.17116782f, 0.37946844f, -0.32148772f, 0.14636427f, -0.17871508f, 
    0.06863276f, -0.20885605f, -0.07140850f, 0.06453766f, -0.07420907f, -0.04671507f, 0.02432648f, -0.00688485f, 
    0.05621149f, 0.09778876f, 0.18212172f, 0.26168838f, -0.06582520f, -0.28868139f, 0.03379545f, -0.21573026f, 
    -0.16180283f, -0.20230448f, -0.05792141f, 0.00112895f, -0.33340663f, -0.36780596f, -0.08281379f, 0.23271045f, 
    0.11713879f, 0.25894701f, 0.03639346f, 0.17281927f, 0.29841161f, 0.41211823f, 0.15562068f, -0.20080058f, 
    0.15063952f, 0.32709396f, 0.00717473f, 0.05560600f, 0.37470406f, 0.31151974f, 0.11141080f, 0.12650302f, 
    0.23194955f, -0.00616909f, 0.10733224f, -0.46916994f, -0.08899733f, -0.15775357f, 0.01619053f, 0.06838001f, 
    -0.16747180f, 0.05248590f, 0.34041417f, -0.01680021f, 0.42734730f, -0.07247438f, 0.13654625f, 0.08939913f, 
    -0.04820390f, -0.03134082f, -0.00182029f, 0.03908982f, -0.00020090f, 0.06204076f, -0.05771002f, -0.02556442f, 
    -0.02256721f, -0.00641852f, -0.00178669f, 0.01362085f, 0.04490511f, 0.07225643f, 0.05251621f, -0.02690505f, 
    0.02897823f, -0.12700361f, 0.05420082f, -0.10325196f, 0.02395491f, 0.00838500f, -0.10162395f, 0.01370207f, 
    -0.10725276f, 0.00936405f, 0.07235555f, -0.04352413f, -0.07623529f, 0.10456287f, -0.12948398f, 0.04903365f, 
    -0.02811478f, -0.04135716f, 0.09849477f, -0.11581581f, -0.06220881f, -0.14539921f, -0.02376065f, -0.02461294f, 
    -0.11667211f, 0.03872099f, -0.13125344f, 0.10390271f, -0.11699931f, 0.07888056f, 0.03353335f, -0.10068418f, 
    -0.07719209f, 0.00380100f, -0.06608313f, 0.04383180f, -0.08584863f, 0.06387332f, 0.09261134f, -0.06209892f, 
    0.05607990f, 0.00629669f, -0.12970911f, -0.05190875f, -0.13714609f, 0.10855299f, 0.04562985f, -0.10570066f, 
    0.04684211f, -0.02828511f, 0.00201784f, 0.04194229f, 0.01769524f, 0.00300047f, -0.08831238f, 0.09842720f, 
    0.07570932f, -0.02539822f, 0.00295402f, -0.10878206f, -0.05554347f, 0.12128401f, 0.06059490f, -0.08175856f, 
    0.03383064f, 0.10826170f, -0.12286679f, -0.09067516f, 0.05183879f, -0.04096577f, -0.14659818f, -0.00574118f, 
    -0.08950183f, -0.05308900f, -0.03011450f, -0.10341224f, 0.09345452f, -0.02442292f, -0.01455982f, -0.04212515f, 
    0.06350812f, 0.02113967f, -0.07192193f, -0.06200873f, -0.10154737f, 0.10327529f, -0.13148898f, -0.11777648f, 
    -0.11583251f, 0.08221771f, -0.14737388f, -0.11053253f, 0.04189510f, 0.06398509f, 0.08721067f, -0.02634402f, 
    -0.08273981f, -0.05772753f, -0.02353919f, -0.10689149f, -0.10098024f, 0.09329333f, 0.11924078f, -0.01062577f, 
    -0.06323891f, -0.12274950f, 0.05152319f, 0.05508432f, -0.03024110f, 0.11186868f, 0.09004184f, -0.02940411f, 
    0.02826970f, -0.01221302f, 0.05075183f, -0.01449048f, -0.16123477f, 0.01720352f, -0.07376212f, 0.06267546f, 
    0.08413896f, 0.06238893f, -0.11797237f, -0.12349113f, -0.04651834f, 0.04856214f, -0.02428287f, -0.14120333f, 
    -0.12577811f, -0.04815582f, 0.02157053f, 0.07700805f, -0.06642720f, 0.05573503f, -0.13841280f, -0.09029091f, 
    0.01375717f, -0.12004220f, 0.01549307f, 0.09249617f, -0.02531727f, 0.03055991f, 0.06401693f, -0.07123584f, 
    0.03506093f, -0.04092805f, 0.08407903f, -0.09837373f, -0.12767726f, -0.12095411f, -0.11113553f, -0.16184978f, 
    0.00579904f, -0.13043834f, 0.03693572f, 0.09939793f, -0.08558172f, 0.00290335f, -0.02165790f, -0.02413409f, 
    -0.04492240f, -0.03746796f, -0.04943641f, -0.02997322f, -0.13491289f, -0.01409292f, 0.00649874f, -0.07408004f, 
    0.02482863f, 0.05713043f, 0.01170717f, -0.00805786f, -0.00545330f, 0.02411379f, 0.05215878f, 0.09563928f, 
    0.08153066f, 0.07700526f, 0.06665506f, -0.08497395f, 0.29409087f, 0.05126338f, -0.09797085f, -0.17442308f, 
    -0.07519693f, -0.08635899f, -0.22771198f, 0.17289226f, 0.39601773f, -0.04907751f, 0.28855282f, 0.00052369f, 
    0.13801467f, 0.18028934f, -0.12841015f, -0.14027999f, 0.03341821f, -0.08478440f, 0.15663561f, 0.11495112f, 
    0.00521402f, -0.24286200f, -0.04047481f, -0.17160955f, -0.06163058f, -0.00772831f, -0.24278392f, 0.44595811f, 
    0.28251600f, -0.22854690f, 0.12598649f, 0.12067461f, -0.03615833f, 0.39510936f, 0.26305681f, 0.18565220f, 
    0.30820453f, 0.06447793f, 0.15434998f, -0.00726838f, -0.28168508f, -0.04141468f, -0.11492651f, -0.02936848f, 
    -0.23666421f, 0.22245713f, 0.11678341f, -0.29432341f, 0.09617710f, -0.28680301f, 0.11362777f, -0.03661706f, 
    0.01546759f, 0.43522829f, 0.00098160f, -0.02944730f, 0.24511333f, 0.10301957f, -0.05084099f, 0.14769550f, 
    -0.13374825f, -0.08623234f, 0.06415434f, -0.02221581f, 0.06504725f, 0.06922049f, -0.06123430f, -0.14562993f, 
    -0.12285110f, 0.04436972f, 0.02982002f, -0.14849533f, -0.14122331f, 0.06945984f, 0.05536348f, -0.13238861f, 
    -0.11338172f, -0.11288556f, -0.13229497f, -0.05467312f, -0.05940439f, -0.10921398f, -0.08421813f, -0.04584587f, 
    0.05020843f, -0.10987858f, -0.11830306f, 0.06887820f, 0.03845561f, 0.07099622f, -0.06326203f, 0.06850143f, 
    -0.13033217f, -0.12159518f, -0.15190803f, -0.12182375f, -0.02551707f, 0.02528682f, 0.07538851f, 0.01987834f, 
    -0.15862064f, -0.01887102f, -0.10892946f, 0.11096230f, 0.04802560f, 0.05257110f, -0.09443517f, -0.09017276f, 
    0.02523380f, -0.10891347f, 0.04579462f, 0.04127266f, -0.09331314f, -0.12636565f, 0.00934888f, 0.04493828f, 
    0.09938133f, 0.01229108f, 0.06268629f, -0.02364124f, 0.02308469f, -0.02803843f, 0.04626161f, 0.04361828f, 
    0.00790826f, -0.02158591f, 0.01935394f, 0.01356356f, 0.09529856f, -0.00056149f, 0.00993856f, 0.07505766f, 
    -0.09450924f, -0.08182136f, -0.15402621f, 0.09864254f, -0.06476326f, -0.01588120f, -0.00323912f, -0.10656726f, 
    0.07924014f, 0.07124875f, -0.09640764f, 0.11957124f, 0.04703698f, -0.13714397f, -0.00576103f, 0.00452229f, 
    0.03404824f, -0.10333396f, 0.06382005f, -0.12375925f, -0.06481858f, -0.06659080f, -0.05334210f, 0.07868215f, 
    -0.01376065f, 0.00720981f, 0.01436765f, -0.01397563f, -0.11460623f, -0.05108031f, -0.12807608f, 0.01440850f, 
    0.07027327f, 0.07038742f, -0.10979105f, 0.07324955f, -0.07215402f, -0.06496930f, 0.01477034f, -0.13731579f, 
    0.02335021f, 0.08055657f, 0.03746074f, -0.00204763f, -0.01158180f, -0.02939664f, 0.06540933f, -0.01222071f, 
    -0.09397943f, -0.05297694f, -0.12560356f, -0.10319412f, -0.04692029f, -0.00802617f, -0.09254599f, -0.09496003f, 
    0.36625201f, -0.11904379f, 0.14245844f, 0.37814206f, -0.21013565f, 0.36750120f, -0.19297165f, 0.29560712f, 
    -0.01570687f, 0.03781063f, 0.23916654f, 0.02469137f, -0.27013087f, -0.02033912f, 0.26303262f, 0.18928929f, 
    0.05179425f, 0.19658665f, 0.25220826f, 0.34851405f, -0.07941979f, 0.16203772f, 0.00886753f, -0.11843951f, 
    0.02958843f, 0.28512478f, -0.00632291f, 0.32415050f, 0.13754667f, -0.08559825f, -0.05149161f, 0.26816773f, 
    -0.00705390f, 0.02805933f, -0.19296519f, -0.16695377f, 0.31641206f, -0.00369331f, -0.06009712f, 0.31911859f, 
    -0.17376731f, -0.25760624f, -0.31416810f, 0.12923171f, 0.33795026f, -0.30363113f, 0.06844948f, 0.16427889f, 
    -0.29852906f, 0.48377204f, 0.07751557f, 0.09532482f, 0.20738702f, -0.07191566f, -0.02291779f, -0.05869165f, 
    0.52905792f, -0.19278982f, 0.25437140f, 0.08200809f, -0.01671897f, 0.09622349f, 0.13039103f, -0.13835926f, 
    -0.40488681f, -0.11150535f, 0.11949008f, -0.11519031f, -0.12425692f, 0.03309950f, 0.37297881f, 0.30783480f, 
    -0.15812673f, 0.46271744f, 0.16841821f, -0.00888065f, 0.00405896f, -0.02651230f, -0.04268079f, -0.08663876f, 
    0.08405714f, -0.06767488f, 0.36494270f, 0.15241763f, 0.06467820f, 0.26471195f, 0.14196958f, -0.04925850f, 
    0.53185999f, 0.24775538f, 0.07699455f, 0.23098612f, -0.11603340f, 0.45312604f, 0.37042621f, -0.05072619f, 
    0.06267874f, 0.22433516f, -0.19838658f, 0.10556914f, 0.15991649f, 0.15883528f, 0.25954753f, -0.14317840f, 
    -0.10659805f, -0.09078257f, 0.16349097f, -0.00007476f, 0.32061410f, -0.08307741f, 0.05955101f, -0.00073988f, 
    -0.09433497f, -0.15021743f, -0.11841103f, 0.35565874f, 0.16119039f, -0.04326041f, 0.33937699f, 0.34930021f, 
    -0.08909244f, 0.67668635f, -0.12655440f, 0.08645900f, 0.00143049f, 0.01806547f, 0.09587815f, 0.05967985f, 
    -0.23033753f, 0.03002513f, 0.17724875f, 0.28088364f, 0.14710811f, 0.01365762f, 0.02548348f, 0.26453122f, 
    -0.08418862f, 0.16378294f, 0.26001063f, -0.01350336f, 0.04757194f, 0.05029914f, -0.02591485f, 0.06594133f, 
    0.20047042f, -0.16007461f, 0.17930242f, 0.02984591f, -0.00313783f, 0.05162468f, 0.14768325f, 0.17422798f, 
    0.24221756f, 0.09687560f, 0.18990067f, 0.13827910f, -0.03302408f, 0.04837795f, 0.22837088f, 0.08765309f, 
    -0.06227298f, 0.22801556f, -0.29921424f, 0.04550870f, 0.03950769f, 0.24368586f, 0.06401435f, -0.20432144f, 
    0.25350633f, 0.09213752f, 0.11346192f, -0.06539283f, 0.12803520f, 0.15343046f, -0.03583228f, 0.12321521f, 
    0.30483302f, -0.20674589f, -0.04474227f, 0.00883042f, 0.04061265f, -0.27574596f, 0.03797502f, -0.04271509f, 
    -0.16708487f, 0.31211704f, 0.07363060f, -0.11992563f, -0.08742727f, -0.02919890f, -0.21813324f, -0.23043501f, 
    0.08501513f, 0.04848552f, -0.08561892f, -0.08745597f, 0.03686700f, -0.08350298f, -0.15037696f, -0.05571099f, 
    -0.04665842f, 0.03833928f, -0.00244972f, -0.15063256f, 0.09231630f, -0.05482717f, 0.05074540f, -0.11643092f, 
    -0.05607156f, -0.14233395f, -0.02934237f, -0.06349152f, 0.01372498f, -0.11796877f, -0.02487735f, 0.09987409f, 
    0.02441555f, -0.05992233f, 0.09329119f, 0.07002100f, -0.15251991f, -0.10554321f, 0.03694128f, -0.10325041f, 
    -0.04809244f, -0.12963793f, 0.02690433f, -0.10950931f, 0.01442143f, 0.05616298f, -0.03395338f, -0.09386516f, 
    -0.07356265f, -0.04322119f, -0.08572485f, -0.09786439f, 0.05945402f, 0.00448919f, -0.06892544f, 0.00548281f, 
    -0.07114430f, -0.00410765f, 0.07262699f, -0.04903170f, -0.09113228f, -0.06379928f, 0.07051111f, -0.09298154f, 
    -0.13264775f, 0.05870906f, -0.12828615f, -0.01735714f, -0.11373994f, 0.03412457f, 0.06233231f, -0.12577847f, 
    -0.05509024f, -0.01495963f, -0.15553519f, 0.09087981f, -0.08316208f, -0.09512372f, -0.01359388f, -0.02139689f, 
    -0.02055390f, -0.01147607f, 0.03768362f, -0.03936690f, 0.01660910f, -0.00441164f, 0.06380357f, -0.09173713f, 
    -0.06147317f, 0.07289558f, -0.11331225f, 0.00921075f, -0.02224642f, 0.01339245f, 0.07643992f, 0.00944724f, 
    0.11529183f, -0.09330651f, 0.05095255f, -0.09308234f, -0.00029536f, 0.08274148f, -0.04624787f, -0.11149008f, 
    -0.06591722f, 0.10249565f, -0.05014439f, -0.08782607f, -0.01595849f, -0.07258706f, 0.04769334f, 0.05153891f, 
    -0.03869666f, 0.09792630f, -0.07829496f, 0.05499734f, -0.00246392f, -0.03976581f, 0.06838585f, -0.10483678f, 
    -0.05381143f, -0.01006577f, 0.02240197f, -0.04705950f, -0.09767758f, 0.04487228f, -0.07103641f, -0.08409192f, 
    -0.02860551f, -0.09643031f, 0.07642660f, 0.09543017f, 0.01596446f, -0.01140375f, -0.12049039f, 0.08376182f, 
    0.00016858f, -0.13500142f, -0.09986446f, -0.12161320f, -0.14630769f, 0.04196990f, -0.04583401f, 0.05344275f, 
    0.07153677f, 0.02700527f, -0.10675979f, -0.03381728f, -0.11796792f, -0.09617038f, 0.06612357f, -0.03783354f, 
    -0.14098485f, -0.00209713f, -0.06632733f, 0.00390299f, 0.10874139f, 0.07820053f, -0.14434706f, -0.05416954f, 
    -0.08071719f, 0.04691373f, -0.01540130f, -0.00662305f, -0.05432076f, 0.02063189f, -0.09394602f, 0.03948442f, 
    -0.03690303f, -0.08441691f, -0.14446074f, -0.04572964f, -0.01842444f, 0.09403858f, -0.06239681f, -0.09431627f, 
    0.03962859f, -0.10804872f, -0.07444675f, -0.05111480f, -0.01998162f, -0.08432166f, 0.09200862f, -0.11422765f, 
    0.03153183f, -0.02007557f, -0.04909863f, 0.01597074f, -0.01310972f, -0.06020935f, -0.06910649f, -0.10276528f, 
    -0.05701376f, 0.12040125f, 0.04473508f, 0.11604431f, -0.11355820f, -0.03430088f, -0.04134076f, -0.05908249f, 
    -0.00575748f, 0.04726687f, 0.11266512f, -0.24311729f, 0.11641879f, 0.09900580f, 0.08308239f, -0.23870593f, 
    0.18338084f, -0.06681319f, 0.13125359f, 0.09102704f, 0.09090609f, 0.11788996f, 0.52772677f, 0.29908317f, 
    0.07641829f, 0.03410077f, -0.28055125f, -0.10034586f, -0.07072811f, -0.14832513f, 0.02185717f, 0.04852077f, 
    0.13236305f, -0.35713211f, -0.26822260f, -0.10008294f, 0.08615863f, -0.39735717f, -0.10203928f, 0.22934619f, 
    0.32093048f, -0.16863786f, 0.30128959f, -0.06479637f, -0.08086304f, 0.12468816f, 0.15952063f, 0.29526183f, 
    0.12666310f, -0.08521961f, 0.08258573f, -0.13395770f, -0.05265994f, -0.15677388f, 0.00991981f, -0.03332877f, 
    -0.02164620f, -0.00532087f, 0.05622065f, -0.27181616f, 0.10612211f, 0.16619121f, 0.01754595f, 0.21454342f, 
    -0.07675607f, -0.28895488f, 0.08094285f, 0.11129060f, 0.21855703f, 0.09418164f, -0.13118666f, 0.01163211f, 
    0.32786268f, -0.02219051f, -0.18471442f, 0.20348807f, 0.28658494f, 0.09399854f, 0.08024466f, 0.25329432f, 
    0.17074722f, -0.01348432f, 0.01984540f, 0.24818356f, 0.20968206f, -0.01739326f, 0.35477963f, -0.10838062f, 
    0.04188570f, 0.08816099f, -0.08335004f, 0.31561697f, -0.03151570f, -0.03279158f, -0.03188619f, -0.04040958f, 
    0.08026715f, -0.22877447f, 0.15057863f, 0.14562483f, -0.15030040f, 0.33811641f, -0.13960622f, 0.32055512f, 
    0.18885340f, 0.11482770f, -0.22584771f, 0.19650871f, 0.15734909f, 0.60350770f, 0.16146880f, -0.22528380f, 
    0.70223600f, 0.33437714f, 0.14712997f, -0.01088784f, 0.03346661f, 0.22778347f, -0.00423018f, -0.03691996f, 
    0.29530326f, 0.04344355f, 0.01195233f, -0.30985004f, -0.15035163f, -0.32693321f, 0.27544972f, -0.02796284f, 
    -0.22665131f, 0.34759414f, -0.14282662f, -0.01066183f, 0.26787996f, 0.11248408f, -0.15445644f, -0.15004258f, 
    0.18633422f, 0.18482639f, -0.01229213f, -0.06802250f, 0.18850140f, -0.12501360f, 0.09488371f, -0.18543833f, 
    0.14182755f, -0.12243079f, -0.17716929f, 0.11109697f, 0.50567561f, 0.06614804f, 0.04185344f, -0.02795965f, 
    -0.07006764f, -0.11296052f, -0.06842069f, -0.39192393f, 0.06533707f, 0.01649677f, 0.02395743f, 0.41682938f, 
    -0.08594774f, -0.12118098f, 0.07881225f, -0.15462634f, -0.03214987f, 0.55856854f, 0.18593985f, -0.04401491f, 
    0.01231598f, 0.04120402f, 0.39065453f, 0.21048856f, -0.18406643f, 0.20534113f, 0.04390647f, -0.02656095f, 
    0.26115867f, 0.23990561f, 0.14596754f, 0.05850898f, -0.27672136f, 0.43105033f, 0.07938346f, -0.14125873f, 
    0.22259931f, -0.04612757f, 0.03241959f, -0.10976727f, 0.00556057f, 0.05032620f, -0.05291959f, -0.07097234f, 
    0.07774151f, 0.44190249f, 0.07551253f, 0.03095791f, 0.18262708f, -0.09658489f, -0.20502822f, 0.05459126f, 
    0.24963976f, 0.06476487f, 0.03222999f, 0.43493482f, -0.12899922f, 0.11445422f, -0.28869027f, 0.24350049f, 
    -0.05183472f, 0.22710089f, -0.14099976f, -0.11812999f, 0.26441875f, 0.03906406f, -0.15977575f, 0.04624614f, 
    0.12349422f, 0.17319541f, -0.02982008f, 0.24796066f, 0.04483342f, 0.00935871f, 0.00728342f, 0.30953223f, 
    -0.22742632f, 0.17773037f, 0.05104978f, 0.05682932f, 0.11736449f, 0.17137927f, -0.04358185f, -0.00421897f, 
    0.08700138f, -0.02356778f, 0.14079590f, -0.05733910f, 0.05285323f, 0.13721836f, 0.10704810f, 0.27558511f, 
    0.20357060f, -0.08893871f, -0.12540184f, 0.06215386f, 0.15342334f, 0.25023377f, 0.13504562f, 0.05008780f, 
    -0.12414532f, 0.32887772f, 0.04320639f, -0.06121128f, 0.14249292f, -0.34671387f, -0.25375408f, -0.12621167f, 
    0.45108858f, 0.06464025f, 0.13245209f, -0.02795975f, -0.07867014f, 0.04003315f, -0.17488316f, 0.05424273f, 
    0.10887535f, -0.02898319f, 0.21432619f, 0.31518900f, 0.07116238f, 0.34288362f, -0.06185885f, 0.43793714f, 
    0.10570616f, 0.31664863f, 0.39809215f, 0.00410362f, 0.02477397f, 0.09454113f, 0.23574394f, 0.06712535f, 
    0.28239700f, 0.16664211f, -0.24851511f, 0.21681207f, 0.04814804f, 0.23480746f, 0.16022830f, -0.11658075f, 
    0.49653971f, -0.05445177f, -0.09018654f, 0.31115377f, 0.11978889f, -0.07621782f, -0.04642097f, 0.35436365f, 
    0.06060487f, -0.11253331f, -0.34677491f, -0.17024221f, -0.01547193f, 0.18559325f, 0.25062183f, 0.25623745f, 
    0.27184439f, -0.08871793f, -0.02132849f, -0.10555336f, -0.23981819f, -0.24896884f, 0.03663027f, -0.12243599f, 
    -0.00646082f, 0.06471352f, 0.04327741f, 0.11277145f, 0.25040820f, -0.12894478f, 0.18214495f, -0.03890962f, 
    0.03882084f, -0.08793824f, -0.32185444f, -0.01260155f, -0.03032165f, 0.00452237f, -0.25915480f, -0.38848111f, 
    -0.13408656f, 0.06540711f, 0.00654584f, -0.08644895f, 0.13532628f, 0.09672027f, 0.16583890f, -0.24108009f, 
    0.19876613f, -0.06562871f, 0.04747400f, 0.01217321f, -0.05432978f, -0.05733588f, -0.05234795f, 0.01501936f, 
    -0.05114373f, 0.10368625f, -0.02430713f, -0.30795574f, -0.12201755f, 0.09820668f, -0.15808026f, -0.17355269f, 
    0.11127045f, -0.11266617f, -0.19744459f, 0.12477080f, 0.14876880f, 0.27168286f, 0.30538183f, -0.35580099f, 
    -0.33099264f, 0.28269914f, 0.25066367f, -0.14436671f, -0.19413021f, -0.18559504f, -0.27226546f, 0.02667732f, 
    -0.00493915f, -0.13102750f, 0.34076247f, -0.08308776f, 0.12993734f, -0.00625885f, 0.08386201f, 0.01882605f, 
    0.45105734f, -0.45419791f, -0.08183770f, 0.05094688f, -0.01423368f, 0.57417941f, 0.14572181f, 0.11719842f, 
    -0.44211924f, -0.44345063f, 0.02592837f, 0.12065327f, 0.05979015f, -0.05465634f, 0.25602990f, 0.08113765f, 
    -0.11013870f, -0.03520075f, 0.12739938f, -0.21507536f, -0.10421910f, 0.21239807f, 0.01963903f, -0.16442274f, 
    0.12039155f, -0.20484874f, 0.28185371f, 0.17408952f, -0.14120562f, 0.01584370f, 0.25573859f, 0.24019061f, 
    -0.05716715f, 0.21506751f, -0.03159573f, 0.17004733f, 0.08150993f, -0.00546731f, 0.08783826f, -0.17323710f, 
    0.59614521f, 0.00219387f, -0.21162061f, -0.05270773f, 0.09630657f, -0.48387706f, -0.09694585f, 0.17411985f, 
    0.12643230f, 0.08427897f, 0.10304990f, 0.09209568f, -0.12192203f, 0.00282665f, 0.01903212f, 0.28166774f, 
    -0.11135165f, -0.11954935f, -0.04469663f, 0.04252430f, -0.13421239f, -0.29799742f, 0.10941360f, 0.03378815f, 
    -0.11332152f, 0.02940136f, -0.12378348f, 0.00221361f, 0.29768780f, 0.07454283f, 0.04719669f, 0.23816662f, 
    0.00121128f, -0.26597998f, 0.29203850f, -0.08171586f, 0.17253341f, -0.12383905f, 0.10344378f, -0.01356471f, 
    0.10985454f, 0.10551912f, 0.02766082f, 0.52877039f, 0.17391039f, 0.34165922f, -0.17976065f, 0.31157815f, 
    0.21966608f, 0.10290851f, 0.26073158f, -0.16921113f, -0.47451705f, 0.03103912f, 0.10529850f, -0.06038845f, 
    -0.14029925f, 0.08343281f, 0.16467100f, 0.51251227f, 0.01192906f, 0.08562650f, 0.07948065f, -0.32027876f, 
    0.54287314f, 0.20796166f, 0.26087433f, 0.18437979f, -0.09798360f, -0.02483929f, -0.07104589f, 0.27408087f, 
    -0.31413272f, 0.03943789f, -0.13122873f, -0.04245850f, 0.22856936f, 0.16339549f, -0.10566178f, 0.20346025f, 
    0.04638825f, 0.06991754f, -0.10354785f, 0.07139269f, 0.10189623f, 0.03903685f, -0.03355901f, 0.11005726f, 
    -0.06504585f, 0.10802240f, 0.07722968f, 0.25673056f, -0.04185195f, -0.27320337f, -0.01187704f, -0.14904810f, 
    0.01459326f, -0.19867504f, 0.07838226f, 0.05937496f, -0.14417912f, 0.03862858f, 0.27121559f, -0.37724015f, 
    0.32514018f, -0.04735966f, 0.19719064f, 0.10038371f, -0.30440688f, 0.27157170f, -0.11910651f, 0.08768460f, 
    0.00944922f, -0.05620591f, 0.05740230f, 0.01874623f, 0.05706643f, -0.05610563f, 0.08272515f, 0.27543893f, 
    0.10968167f, 0.16449058f, -0.15758853f, 0.23937227f, -0.00024035f, 0.07987419f, 0.10825019f, -0.05606766f, 
    0.18677503f, 0.07817920f, -0.15012933f, 0.21258454f, 0.27353278f, 0.00081254f, -0.23005563f, 0.16437487f, 
    0.16324341f, -0.09965698f, 0.01003171f, -0.12949412f, -0.06890386f, -0.16463016f, 0.17059483f, 0.37015417f, 
    -0.27720663f, -0.20907050f, -0.18848790f, -0.07171316f, -0.06609295f, -0.20917434f, 0.02159666f, 0.08021672f, 
    -0.43967974f, 0.35227010f, 0.03134985f, 0.07189892f, 0.25786012f, 0.15609147f, -0.05762826f, -0.10675767f, 
    0.31876561f, -0.26400086f, -0.01754953f, -0.02288187f, -0.02975959f, 0.06705800f, 0.15991122f, -0.06912781f, 
    0.01450884f, -0.04945114f, 0.18060137f, 0.15345193f, -0.36000991f, 0.18460062f, 0.02346190f, -0.01590507f, 
    0.02762584f, -0.14786808f, 0.12485602f, 0.00543932f, -0.36303055f, -0.10283878f, -0.09572744f, -0.01322356f, 
    -0.14157148f, 0.14382359f, 0.35685366f, 0.24174905f, -0.07826455f, 0.05778233f, 0.11589707f, -0.24818006f, 
    0.10828516f, 0.36594480f, -0.02747957f, 0.14229415f, -0.10779341f, -0.46529880f, 0.20085467f, -0.18091503f, 
    -0.04102241f, 0.18379694f, 0.01332254f, -0.10019968f, 0.09477544f, -0.37282035f, -0.15293734f, 0.27022347f, 
    -0.42878711f, -0.00288933f, -0.12321670f, -0.11746185f, 0.40390572f, -0.10275061f, -0.00356181f, 0.29514846f, 
    -0.12518191f, 0.13140489f, 0.04220647f, 0.16336824f, 0.18181348f, 0.04849140f, -0.04740734f, 0.03906338f, 
    0.18646318f, -0.17283426f, 0.39586979f, 0.08000718f, 0.02609183f, 0.09037161f, 0.38170537f, 0.11218584f, 
    -0.05655895f, -0.23422249f, -0.04247604f, 0.05359381f, -0.21242246f, -0.13029051f, 0.36975852f, 0.28203556f, 
    -0.22487085f, 0.28531098f, -0.00989237f, -0.01078882f, 0.13537933f, -0.00081100f, -0.55290985f, 0.00761480f, 
    0.05563850f, -0.08469638f, 0.46818143f, 0.08187639f, -0.01509637f, 0.08664173f, -0.05974953f, 0.20750038f, 
    -0.08113753f, 0.23370850f, -0.05627690f, 0.30112273f, 0.15834357f, -0.13510932f, 0.52305686f, -0.37918881f, 
    -0.07782212f, 0.10749575f, -0.37899962f, 0.20428890f, 0.15227918f, -0.35796335f, 0.15544099f, -0.05841608f, 
    -0.49037448f, 0.00579679f, -0.00458096f, -0.03878950f, 0.44615754f, 0.19451369f, -0.06649978f, 0.06973721f, 
    0.26996195f, 0.07463762f, 0.02026701f, 0.32739919f, 0.13092583f, 0.05532546f, -0.04436782f, 0.12088787f, 
    0.34226814f, 0.19275275f, 0.12875454f, 0.07130864f, 0.09967221f, 0.05446585f, 0.01903240f, -0.00814342f, 
    -0.38106826f, -0.08019319f, 0.29310623f, -0.12864533f, -0.08046788f, -0.20467882f, 0.00503390f, 0.04734525f, 
    -0.16737305f, 0.30447236f, 0.33268192f, 0.09237530f, 0.26652622f, -0.08798996f, -0.40021262f, 0.16791698f, 
    0.28431609f, -0.04318446f, 0.30435041f, -0.20439598f, 0.07278542f, -0.00520999f, 0.17576002f, 0.18440443f, 
    -0.20625566f, 0.18734585f, 0.05016039f, 0.23848972f, 0.22990000f, -0.27098233f, 0.51719147f, -0.26992902f, 
    -0.08859020f, 0.17664027f, -0.10204826f, 0.29214227f, -0.14475040f, -0.06138674f, 0.18998449f, -0.21174058f, 
    -0.30665705f, 0.00680998f, -0.14071085f, -0.00839504f, 0.16645457f, 0.21020000f, -0.05282269f, 0.14034155f, 
    0.17649458f, -0.01986970f, 0.01057711f, 0.19707495f, 0.22576775f, -0.13635482f, -0.03147808f, 0.16365938f, 
    0.39011395f, 0.09202589f, 0.24611959f, -0.10134401f, -0.03549104f, -0.06926356f, -0.05759882f, -0.11402649f, 
    0.01402673f, -0.02970846f, -0.26352936f, -0.02551542f, 0.15470311f, 0.07866140f, 0.13000305f, -0.08775759f, 
    -0.00822782f, -0.32513162f, -0.12273362f, 0.10169984f, 0.08743260f, -0.01645142f, 0.14835523f, -0.16421001f, 
    -0.29467309f, 0.08608312f, -0.01404748f, 0.11907188f, 0.02602004f, 0.03154361f, -0.08028483f, 0.04646709f, 
    -0.13449547f, 0.03525534f, -0.05840203f, -0.14575967f, -0.22196448f, -0.24147931f, -0.14540444f, 0.28859022f, 
    0.07743216f, 0.03122511f, -0.00522888f, 0.04942584f, 0.05472978f, 0.12549856f, -0.08883211f, -0.05924188f, 
    -0.07133347f, 0.06150671f, 0.21034552f, -0.06826065f, -0.43685740f, 0.13594310f, -0.11290209f, -0.07278148f, 
    -0.14642063f, -0.02121128f, 0.02017774f, 0.22406119f, -0.06509892f, -0.31857079f, 0.13932545f, -0.05879073f, 
    0.14875400f, -0.03895346f, -0.20209551f, 0.05082423f, 0.18235244f, 0.01087074f, -0.04066977f, 0.05848894f, 
    0.17767769f, 0.07541753f, 0.16308495f, 0.45578983f, 0.28512257f, -0.03724879f, -0.09080550f, 0.18182500f, 
    0.08782489f, 0.16668260f, 0.06694925f, 0.04611991f, 0.18341973f, -0.11732262f, 0.09238227f, 0.09996340f, 
    0.27761766f, 0.06660486f, -0.17385210f, 0.13498953f, -0.00485243f, -0.04194386f, 0.15515833f, 0.21466646f, 
    -0.16136126f, -0.13833898f, 0.02494479f, -0.10075103f, 0.22585276f, -0.58641988f, -0.30473545f, 0.21915102f, 
    0.11752316f, -0.16600363f, 0.21655968f, 0.05732257f, 0.01766077f, 0.21130295f, 0.25105014f, 0.09807628f, 
    0.29264846f, -0.08407450f, -0.08746184f, -0.02220741f, -0.03502493f, -0.04873793f, 0.08933099f, -0.05007985f, 
    0.20104933f, 0.39544249f, 0.08062878f, -0.34970611f, 0.17249167f, -0.36052454f, -0.29794091f, -0.07717609f, 
    0.22716255f, -0.23213021f, 0.01289034f, 0.08241972f, 0.15780501f, 0.05465063f, -0.44656149f, -0.20562665f, 
    0.13628590f, -0.01348820f, 0.16626422f, 0.17754249f, 0.25518230f, -0.18870689f, 0.05066380f, -0.04169383f, 
    0.11196604f, 0.17472914f, 0.08795622f, 0.00738764f, 0.00124239f, -0.04180200f, -0.36728349f, 0.09646737f, 
    0.03655862f, 0.07015844f, 0.23600204f, -0.05651169f, 0.03139298f, -0.12207490f, -0.15108715f, 0.33833781f, 
    -0.22396705f, -0.00713415f, -0.04722303f, 0.12906949f, 0.07056715f, -0.62036020f, 0.32919744f, -0.23324920f, 
    -0.17479776f, 0.16048166f, 0.09749327f, 0.15543146f, -0.12347251f, -0.07138921f, -0.02206922f, -0.22029185f, 
    -0.08546019f, 0.02161168f, 0.07848959f, -0.00023854f, -0.11144277f, 0.28758782f, -0.03703611f, 0.00440728f, 
    0.47081143f, 0.16669369f, -0.10828404f, -0.20628339f, -0.02034574f, 0.17437813f, -0.13003913f, -0.19722493f, 
    0.26803535f, -0.41759190f, 0.15721013f, 0.02546862f, 0.29386362f, -0.00497897f, -0.23761611f, 0.03281809f, 
    0.16901118f, -0.07155034f, -0.21455786f, 0.11181164f, 0.17290007f, 0.16593197f, 0.17984483f, 0.28140214f, 
    0.05550669f, -0.00398029f, 0.11471336f, 0.15819751f, -0.26039514f, 0.01442435f, 0.14405927f, -0.03516303f, 
    -0.20759873f, 0.15393041f, 0.19314244f, 0.40763527f, 0.01445819f, 0.06625037f, -0.17327313f, -0.20816551f, 
    0.61572105f, 0.10849063f, -0.15685476f, 0.19317673f, -0.05597028f, -0.10074455f, -0.05762031f, 0.15561241f, 
    0.08009057f, 0.24716839f, -0.11202997f, 0.05404687f, 0.39675432f, 0.01253113f, -0.05027077f, -0.01131636f, 
    -0.01965928f, 0.00582092f, 0.22184359f, 0.02542905f, 0.02832544f, -0.01787657f, 0.08239714f, 0.10084175f, 
    0.03953485f, -0.19988491f, -0.02424672f, 0.20308113f, 0.03322648f, 0.06446087f, 0.33715662f, 0.15846357f, 
    0.02264296f, -0.02110402f, -0.17402539f, -0.03390791f, 0.04672121f, 0.10169214f, 0.40239564f, 0.05219872f, 
    0.01818632f, 0.02169844f, 0.12384766f, -0.03103176f, -0.03853376f, -0.02311402f, 0.00011408f, 0.00195361f, 
    0.01916794f, 0.03956803f, -0.00460693f, -0.10076378f, 0.02081709f, 0.00656728f, -0.04414250f, -0.05939333f, 
    0.11271500f, 0.04620252f, -0.12547196f, -0.03308429f, -0.08986861f, -0.04867220f, -0.09129417f, -0.07355430f, 
    -0.04361370f, -0.04477681f, -0.10437861f, -0.07461301f, -0.13373388f, -0.05196773f, -0.09974788f, 0.10432220f, 
    0.07359488f, 0.09362776f, 0.01481026f, -0.11842801f, -0.10057259f, 0.09566423f, -0.00880132f, -0.03510305f, 
    -0.06952105f, 0.04430909f, 0.07199876f, 0.03731371f, 0.03351178f, -0.03903738f, 0.03174248f, -0.05127398f, 
    -0.11767290f, -0.07549977f, 0.01788992f, 0.03313051f, -0.05984743f, -0.05754669f, -0.07890787f, -0.06634784f, 
    0.09751315f, -0.04916329f, -0.06461418f, -0.07165205f, 0.02205309f, -0.03122261f, -0.01537408f, -0.08646240f, 
    0.03790454f, 0.12158311f, 0.02506098f, -0.07369595f, 0.00800508f, 0.02686487f, 0.17177540f, -0.40542358f, 
    0.12104063f, -0.02602247f, -0.17818131f, -0.00208500f, 0.00906375f, -0.00183223f, -0.31032807f, 0.02760969f, 
    -0.09625768f, -0.11566362f, 0.45949060f, -0.05817048f, 0.00787361f, -0.07347640f, -0.08157539f, 0.16523764f, 
    0.04227148f, 0.26128966f, -0.02415303f, -0.08693369f, -0.02164383f, -0.02330450f, 0.44229299f, 0.00212913f, 
    -0.04404128f, 0.25498763f, 0.09644637f, 0.01809551f, 0.10105428f, -0.24293482f, -0.09332348f, -0.01594176f, 
    -0.17657244f, 0.16934437f, 0.22978367f, 0.02204017f, -0.07244386f, 0.30612466f, 0.12371983f, 0.02834932f, 
    0.22322863f, -0.16853608f, -0.10112120f, 0.06840178f, -0.07577068f, 0.39922616f, -0.05884508f, 0.17896567f, 
    0.07389533f, 0.21124510f, 0.17014365f, -0.09988192f, -0.01644299f, 0.11343729f, 0.17709658f, 0.25358430f, 
    0.14773592f, 0.25499871f, 0.11576428f, 0.10133670f, 0.36123121f, -0.02599300f, -0.19204131f, -0.13046560f, 
    0.27243048f, -0.31278533f, 0.11224248f, 0.02068777f, -0.08027851f, 0.12289007f, -0.16096139f, -0.06761214f, 
    0.08488194f, -0.02965318f, -0.14345157f, -0.32971713f, -0.05751735f, -0.07983331f, 0.05756459f, -0.21659744f, 
    -0.35491598f, -0.10202421f, 0.35740113f, -0.35419789f, 0.04275725f, -0.15338258f, -0.10476262f, -0.06689855f, 
    -0.03363475f, -0.05315817f, 0.57321441f, -0.02335625f, -0.08645703f, -0.13696788f, -0.20269778f, 0.18796130f, 
    0.14890999f, 0.15195596f, 0.10638480f, 0.07732861f, -0.01108711f, 0.20285283f, 0.05054301f, 0.22237766f, 
    0.33341619f, -0.13402340f, 0.10127035f, -0.38091201f, -0.06741950f, 0.23873822f, 0.05407651f, 0.01201941f, 
    -0.45908645f, -0.23736209f, 0.40170282f, 0.00577293f, 0.18041417f, -0.08826511f, 0.15062198f, 0.24946618f, 
    -0.09332382f, -0.03649782f, 0.09842071f, 0.09343708f, -0.19120976f, -0.00910094f, 0.12927255f, 0.21691892f, 
    0.01766534f, 0.41649261f, 0.14003472f, -0.01102267f, -0.08007672f, 0.11948828f, 0.14395480f, 0.25635809f, 
    0.19455421f, 0.17530546f, 0.40321344f, 0.09891280f, 0.01346708f, 0.15457934f, -0.09803919f, 0.30126876f, 
    0.54522598f, 0.10410302f, -0.52198333f, 0.35523671f, 0.17652228f, -0.60948044f, 0.25597069f, 0.21463303f, 
    0.00050378f, 0.05993927f, -0.58181334f, 0.20623201f, 0.12919194f, -0.15654825f, 0.37927917f, -0.05511038f, 
    -0.36662647f, -0.17510074f, -0.18094482f, 0.03131188f, -0.17082714f, -0.04414143f, -0.07491022f, 0.01337268f, 
    0.17371993f, 0.18897274f, 0.00775914f, 0.18260282f, 0.19393802f, 0.05951610f, -0.02650659f, 0.04510821f, 
    0.62654531f, -0.01287972f, -0.10450880f, -0.01393243f, 0.04196049f, 0.11676222f, -0.38357729f, -0.18069121f, 
    0.04799408f, -0.03935399f, -0.11750853f, -0.13645184f, 0.09957579f, 0.07023186f, -0.11670592f, -0.04195173f, 
    -0.07573243f, 0.01553686f, -0.03647490f, -0.13892139f, -0.07605422f, 0.11147040f, 0.01073703f, -0.03180761f, 
    0.07764754f, -0.05401517f, -0.09392945f, -0.12221529f, -0.09101026f, -0.06757198f, -0.11314306f, 0.05265009f, 
    0.11603461f, 0.08992051f, -0.04175003f, -0.14312087f, 0.06985337f, 0.09873010f, -0.09127727f, -0.00594658f, 
    -0.08131883f, -0.10048796f, 0.01356532f, -0.14186087f, -0.09392917f, 0.09962568f, -0.02877766f, 0.09016044f, 
    0.03592427f, 0.11000928f, 0.10551970f, -0.02804825f, -0.01882000f, 0.06546798f, -0.02096206f, -0.11275103f, 
    -0.07266311f, 0.04592137f, -0.03182329f, -0.00453572f, 0.00707278f, 0.00070442f, -0.03654520f, -0.01678928f, 
    0.03660914f, 0.10845068f, -0.01152242f, -0.02911043f, -0.00154573f, 0.03815028f, -0.08095126f, -0.12280285f, 
    0.13231131f, 0.24203956f, -0.03506120f, 0.41248864f, 0.38128382f, 0.22530311f, -0.11537947f, 0.06949103f, 
    0.11759068f, 0.14513668f, -0.00036219f, -0.03101154f, 0.33766761f, 0.08781554f, -0.04683635f, -0.00791346f, 
    0.23938395f, 0.14929552f, -0.26241565f, -0.16068184f, 0.06312957f, 0.26389799f, 0.13495992f, 0.42477503f, 
    0.22169189f, -0.13784190f, -0.44867522f, 0.14835069f, 0.21273345f, 0.05666919f, -0.05601842f, 0.05513318f, 
    -0.16321313f, 0.08383137f, -0.20710202f, 0.20782110f, -0.07690185f, 0.39664131f, 0.11902539f, -0.19184187f, 
    0.46865025f, 0.13152753f, 0.14476278f, 0.06145160f, -0.49533024f, 0.19539061f, 0.14191031f, -0.22229591f, 
    0.48722798f, 0.19088709f, -0.09482810f, 0.07565321f, 0.11142536f, -0.14045911f, -0.13128434f, -0.22292063f, 
    0.08466717f, 0.12304983f, -0.32192311f, 0.01043210f, -0.06651536f, 0.05670431f, -0.47812814f, -0.17895789f, 
    0.03136881f, 0.07864288f, 0.01454380f, -0.13567002f, -0.09836595f, -0.00664244f, -0.03414089f, 0.04631526f, 
    -0.11149181f, -0.06316720f, 0.12745544f, -0.11817586f, -0.06773517f, 0.05779301f, -0.14087330f, -0.14984676f, 
    -0.09326723f, -0.08506787f, -0.17142272f, 0.04396413f, -0.08921549f, 0.00103568f, -0.13215038f, -0.01731604f, 
    0.03887074f, -0.00643310f, -0.05323914f, -0.12244297f, -0.04096619f, 0.02960275f, -0.08262105f, 0.01701062f, 
    -0.11325938f, 0.02491058f, -0.09046659f, -0.05213366f, -0.13595843f, -0.11915081f, 0.03815319f, -0.05130420f, 
    -0.00161958f, -0.10287976f, 0.12924370f, 0.11298246f, 0.02901925f, 0.08850024f, -0.05268390f, 0.04725227f, 
    0.13452101f, -0.06542693f, -0.05100356f, -0.06856269f, -0.06061409f, -0.03699265f, 0.03446327f, 0.00209989f, 
    0.04738458f, -0.10011315f, 0.02786957f, -0.04352127f, 0.01154883f, 0.02031860f, 0.04652697f, -0.06758898f, 
    0.20964782f, 0.33421904f, -0.13609955f, 0.39521500f, 0.31932732f, 0.19454551f, 0.04679447f, -0.08326810f, 
    0.25586012f, -0.12325795f, -0.21838050f, 0.20269911f, 0.15670088f, 0.07089528f, -0.18716522f, -0.25706100f, 
    -0.16944484f, -0.02347731f, 0.00950619f, -0.08733312f, 0.01686437f, -0.11771680f, -0.07133296f, 0.21879372f, 
    -0.06216949f, 0.10495251f, 0.21374252f, -0.11639147f, -0.11763455f, 0.26477101f, 0.18423790f, -0.04771760f, 
    -0.04459414f, 0.26855141f, 0.02394902f, 0.13779262f, 0.15766633f, 0.20858075f, -0.06147347f, -0.21512520f, 
    0.41151187f, 0.46795335f, 0.10862016f, 0.08023334f, -0.05839400f, 0.47054201f, 0.03651864f, 0.10671588f, 
    0.45154157f, -0.02887167f, -0.07377641f, -0.17346145f, -0.08246107f, 0.03725450f, -0.09255048f, -0.11042944f, 
    0.07081505f, -0.01372559f, 0.04931296f, 0.12448075f, 0.18128155f, -0.10352491f, 0.10964581f, 0.14368024f, 
    0.06015145f, 0.01743309f, 0.03929074f, 0.36210993f, -0.03909250f, 0.31297702f, -0.13514441f, 0.60837305f, 
    0.12244309f, 0.18372680f, 0.27365097f, -0.21095558f, -0.19737066f, 0.09090355f, 0.04731649f, -0.07592633f, 
    0.00987431f, 0.05463924f, -0.01518403f, 0.54347962f, 0.06749620f, 0.24224548f, 0.00443324f, 0.02871942f, 
    0.55820709f, 0.11171822f, 0.14896232f, 0.18118796f, -0.02787981f, 0.01243748f, -0.06717382f, 0.01785173f, 
    -0.40574917f, 0.02001593f, -0.37192646f, 0.03948370f, 0.23301207f, -0.01967309f, -0.02141190f, 0.03938010f, 
    0.14413615f, -0.08465908f, -0.04808542f, 0.03910508f, -0.12120893f, -0.16694409f, 0.08106689f, 0.00883777f, 
    0.10527856f, 0.11526489f, -0.03003646f, 0.44796500f, 0.05351341f, -0.05525246f, 0.10601895f, -0.13823214f, 
    0.15951627f, -0.02881415f, -0.04090459f, 0.09127633f, -0.12563717f, -0.06770489f, -0.10466962f, -0.17719507f, 
    0.10412202f, -0.01624706f, -0.04084694f, -0.10347996f, -0.04033392f, 0.04080920f, 0.07779935f, 0.12551542f, 
    -0.12891260f, -0.13881069f, 0.04233666f, -0.00349991f, -0.02969323f, -0.06292979f, -0.05383447f, 0.02301437f, 
    -0.10413890f, -0.07326067f, -0.13992973f, 0.04098920f, -0.00990328f, 0.01892664f, 0.04745498f, 0.07047788f, 
    0.05019910f, 0.02834191f, 0.01818823f, -0.15882981f, 0.00150065f, -0.00472450f, -0.14547862f, -0.04194931f, 
    0.09141420f, 0.10279053f, -0.02833751f, -0.13565288f, 0.09184700f, 0.04387942f, 0.06312939f, -0.16283169f, 
    0.09729753f, 0.07584082f, -0.10849993f, -0.05645689f, 0.05182776f, -0.04972814f, 0.10140888f, -0.07801262f, 
    0.04381275f, -0.01565936f, -0.05239110f, 0.07431176f, -0.11466502f, -0.13489446f, -0.09978557f, -0.08617507f, 
    0.07229627f, -0.07822535f, -0.09408038f, 0.01895307f, -0.08291912f, 0.10776724f, -0.06676296f, -0.12861477f, 
    0.09708721f, -0.00767028f, 0.03519630f, -0.11456344f, 0.13266720f, 0.00713206f, 0.02074843f, 0.20656382f, 
    0.18746343f, 0.19965181f, 0.21471755f, 0.20827906f, -0.00524309f, -0.02449927f, 0.42361972f, 0.30217797f, 
    0.22868025f, 0.08098381f, -0.42251512f, 0.08388688f, -0.04501260f, 0.07510994f, 0.08182967f, -0.03920177f, 
    0.26322868f, -0.35899499f, -0.18218377f, 0.07950281f, 0.21203141f, -0.36973447f, -0.32178903f, 0.39985329f, 
    0.22684273f, -0.20644678f, -0.28791004f, -0.07330050f, 0.04085207f, 0.15805030f, 0.23592299f, 0.04512972f, 
    0.18094535f, -0.18027507f, -0.01804232f, -0.05052302f, -0.26029313f, -0.45446482f, 0.09059290f, 0.03128350f, 
    0.05725057f, 0.21419024f, 0.07511729f, -0.14713515f, 0.03601729f, 0.00223061f, 0.15827659f, 0.14494942f, 
    0.02688210f, -0.30519429f, -0.25554517f, -0.07250747f, 0.01418577f, 0.10160756f, -0.25958341f, -0.21115050f, 
    0.08848982f, 0.15457834f, 0.20139872f, -0.15153253f, -0.12970075f, -0.06621617f, 0.02822269f, -0.32169467f, 
    0.12306340f, -0.31969142f, -0.22502671f, 0.03760000f, 0.18588191f, 0.05964306f, 0.00689490f, 0.17383394f, 
    -0.12761000f, 0.01229104f, 0.04676729f, -0.17592460f, -0.03483915f, 0.07247792f, 0.19508998f, -0.16112904f, 
    -0.18836896f, 0.04189915f, 0.00572165f, -0.35869280f, 0.01814279f, 0.10963365f, 0.01461434f, -0.07223090f, 
    0.04308124f, 0.07025523f, 0.65516216f, 0.09696335f, -0.15089810f, -0.12202512f, -0.19524798f, 0.23957852f, 
    -0.23044942f, 0.01837177f, 0.17937768f, 0.02329363f, 0.09684762f, 0.04832033f, 0.04434367f, 0.24139178f, 
    -0.17749688f, 0.07256189f, -0.09513715f, -0.02141708f, -0.00364324f, 0.36501378f, -0.10145108f, -0.04293241f, 
    0.02284610f, -0.05467038f, 0.19420120f, 0.01566557f, 0.15320347f, -0.11801340f, 0.26161724f, 0.37650812f, 
    -0.21245442f, 0.01411782f, 0.02610876f, 0.38668945f, -0.06482137f, 0.42149195f, -0.06155609f, 0.39307854f, 
    0.19475365f, -0.07740079f, 0.48353341f, 0.01297998f, -0.44081008f, 0.03329243f, 0.14844295f, 0.21321090f, 
    0.00124428f, 0.16150847f, -0.06377757f, 0.30324969f, 0.14396161f, 0.31825557f, 0.02286323f, -0.29908276f, 
    0.56095201f, 0.17073473f, -0.08883297f, 0.25828880f, 0.14427231f, -0.30593625f, 0.00247453f, 0.02813256f, 
    -0.10495152f, 0.05413262f, 0.00115031f, -0.18476474f, 0.00983722f, -0.00547545f, 0.06683900f, 0.24037230f, 
    -0.13958588f, -0.14202121f, 0.07253496f, -0.00871146f, -0.07315656f, -0.20700668f, 0.06722338f, 0.19668393f, 
    0.02007085f, -0.09344713f, 0.01556163f, 0.06169781f, 0.10516610f, 0.04971527f, 0.18371400f, 0.22365364f, 
    -0.29111752f, -0.35200620f, 0.16163573f, -0.01939463f, -0.06272675f, 0.10916917f, 0.07286597f, -0.16119140f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05485182f, -0.05988374f, -0.02264123f, 0.05116180f, -0.20157135f, 0.20032281f, 0.04091594f, 0.13629369f, 
    0.04618206f, 0.02313360f, 0.10546333f, 0.02591030f, 0.12357064f, 0.18689539f, 0.03239091f, 0.02712305f, 
    0.07643668f, -0.19476205f, 0.09174459f, -0.04954957f, -0.09512369f, -0.07333058f, 0.09864590f, -0.04542662f, 
    -0.01400969f, 0.07536656f, 0.09207123f, -0.16695088f, -0.03786078f, -0.08072869f, -0.05772490f, -0.08971226f, 
    -0.05812426f, 0.11915655f, -0.02593447f, 0.19164704f, 0.02612548f, -0.07626452f, 0.01363775f, 0.06344520f, 
    0.18636675f, 0.25939530f, 0.16577701f, -0.09524582f, 0.01450436f, 0.00842510f, 0.01883303f, 0.07012092f, 
    0.12476616f, 0.20212542f, 0.03434419f, 0.06932045f, 0.08599183f, -0.02919548f, 0.14934121f, -0.04362665f, 
    0.12024164f, -0.00633670f, 0.09520065f, 0.01369495f, -0.08717101f, -0.06594959f, 0.03243920f, 0.09586491f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.11481221f, 0.33602041f, 0.26725838f, 0.09284139f, -0.82917595f, -0.07034361f, -0.03080934f, 0.21294102f, 
    -0.23171632f, 0.09848522f, -0.07657590f, -0.00195056f, 0.07666094f, 0.05444806f, 0.03939318f, -0.22685874f, 
    0.15778919f, -0.33488631f, -0.19235440f, 0.02056048f, -0.36008111f, -0.09884352f, 0.20276509f, -0.05477666f, 
    0.07790200f, -0.02069387f, -0.05915492f, -0.06482447f, 0.07632799f, -0.51452875f, -0.35294768f, -0.19092266f, 
    -0.07952867f, 0.00893942f, -0.11156520f, 0.13188508f, 0.05768993f, 0.12679642f, -0.26250759f, -0.25854164f, 
    0.45214725f, -0.02961481f, 0.02381512f, -0.27929497f, -0.31554469f, -0.35553965f, -0.25303864f, -0.18003686f, 
    0.02409992f, 0.15437008f, 0.03095539f, -0.03468092f, -0.01145116f, 0.42166495f, -0.56561220f, -0.00150025f, 
    0.05725687f, 0.09206593f, 0.16471936f, -0.23693155f, -0.05914007f, -0.08740211f, 0.25632083f, 0.01812004f, 
    -0.25865117f, 0.21871561f, -0.01899447f, 0.26353049f, 0.31028399f, -0.30902258f, 0.14284250f, 0.31804055f, 
    0.09960320f, 0.33002755f, 0.02067024f, -0.29481402f, -0.01480618f, 0.15988742f, 0.07905311f, 0.12105147f, 
    0.03822175f, 0.21651353f, 0.05774401f, -0.02410250f, 0.21489112f, -0.08948579f, -0.17796442f, 0.05961806f, 
    -0.01723941f, 0.09478562f, -0.23549093f, -0.09506643f, -0.00113705f, 0.13141195f, -0.22438739f, -0.29902437f, 
    -0.12007499f, -0.13381535f, 0.06955723f, 0.15364383f, -0.65881592f, -0.15887029f, -0.04969958f, -0.07282676f, 
    0.30703640f, 0.15148757f, -0.06281863f, 0.21133855f, 0.20574364f, -0.18128680f, -0.02988512f, -0.29041648f, 
    -0.05000761f, -0.13433290f, -0.08627116f, -0.07693820f, 0.02240075f, 0.09248483f, -0.21471931f, 0.06792454f, 
    -0.56927222f, 0.02246509f, -0.10765719f, -0.35397655f, 0.06357209f, -0.10121804f, 0.27914995f, 0.15552305f, 
    -0.32901925f, 0.08809027f, -0.33821040f, -0.12466274f, -0.19500026f, -0.36317760f, -0.44778532f, 0.01089184f, 
    0.30249020f, 0.13179351f, 0.10087593f, 0.23030236f, 0.10530438f, -0.28620988f, -0.13124867f, 0.37464359f, 
    0.00620481f, 0.11180983f, 0.32091820f, 0.03967052f, -0.35483846f, 0.03120729f, -0.16536403f, 0.04613776f, 
    0.05466395f, 0.01418848f, -0.00214803f, -0.11795892f, 0.09153943f, -0.02054643f, -0.19352596f, -0.22393820f, 
    -0.07186173f, 0.05413505f, -0.10459822f, -0.08187190f, -0.63339001f, 0.19659542f, 0.29484335f, -0.25290591f, 
    -0.16549498f, -0.00284181f, -0.40058663f, 0.16420689f, 0.00523622f, 0.20554538f, 0.16546373f, -0.17963523f, 
    0.12639530f, 0.24893567f, -0.54268348f, 0.10334300f, 0.09580620f, 0.09754550f, 0.06543151f, 0.03245303f, 
    0.10476083f, 0.08669364f, -0.13994491f, -0.22780475f, -0.08396519f, -0.52039236f, 0.32219782f, -0.20568636f, 
    0.27845314f, -0.19276311f, 0.13910733f, 0.23492479f, -0.16015226f, 0.26733229f, -0.09719282f, -0.07593163f, 
    0.08755830f, -0.29480386f, -0.05293730f, 0.17173234f, -0.02622377f, 0.00238275f, 0.08975725f, -0.85177553f, 
    0.15654443f, -0.50746733f, 0.08672876f, -0.07088564f, -0.10811591f, -0.10322919f, -0.00857582f, -0.01642914f, 
    0.10705427f, -0.01918432f, 0.02807247f, -0.12238811f, 0.07110589f, -0.05475064f, 0.26036566f, 0.04624318f, 
    0.09789757f, 0.11963566f, 0.05263891f, -0.15090165f, 0.25984383f, 0.17626432f, -0.01131389f, -0.17351392f, 
    0.07292490f, -0.38973731f, -0.09202173f, -0.41737014f, -0.18913418f, 0.01560357f, -0.09592833f, -0.17503881f, 
    -0.34412736f, -0.25329190f, 0.03086221f, -0.01776913f, 0.02561519f, -0.30288866f, -0.34293044f, -0.10436999f, 
    -0.04460200f, -0.06068445f, 0.11936656f, -0.17097847f, -0.07668453f, -0.41571021f, -0.09177025f, -0.32316291f, 
    0.06335938f, -0.11041923f, 0.12663347f, -0.51647907f, -0.15713246f, 0.02604362f, 0.06904964f, -0.31408089f, 
    0.20892459f, -0.14958607f, -0.02529669f, 0.13921870f, -0.26885742f, -0.16512267f, -0.10284632f, 0.03709881f, 
    0.05761226f, -0.19848886f, -0.13520008f, -0.01740203f, -0.49530107f, -0.21042147f, 0.27116504f, 0.06436613f, 
    0.03169573f, 0.03416682f, 0.26316777f, -0.13600381f, -0.10012972f, -0.31735951f, -0.06334412f, 0.18900697f, 
    -0.09857120f, -0.09157691f, -0.04176078f, 0.12415627f, 0.21798608f, 0.17144500f, 0.00447310f, -0.00684330f, 
    -0.47705728f, -0.08275083f, -0.40135118f, -0.34933516f, -0.13944861f, -0.25913289f, 0.12429398f, -0.03933960f, 
    0.22333375f, 0.05170185f, -0.17311795f, 0.10237774f, -0.11333881f, 0.10467236f, -0.03659758f, 0.05936813f, 
    0.22517590f, -0.13156314f, 0.09114887f, -0.42412308f, -0.07331620f, 0.00892782f, -0.05348280f, -0.26036277f, 
    0.18455316f, -0.14454985f, -0.13240010f, -0.19294441f, 0.21876076f, 0.08719807f, 0.20300007f, 0.07500006f, 
    -0.48197994f, -0.00400522f, 0.09534675f, -0.60447961f, -0.42969581f, 0.22226316f, 0.04635056f, -0.12367905f, 
    -0.05366458f, -0.05762858f, 0.07718350f, -0.01745073f, -0.11682999f, -0.20599033f, 0.15041187f, 0.08326540f, 
    0.02444167f, 0.09146570f, 0.16899303f, -0.00484064f, 0.06713241f, 0.14917363f, 0.12395729f, -0.22664073f, 
    -0.10781433f, 0.00402790f, 0.01550252f, 0.19947320f, 0.03359664f, -0.15775171f, -0.12584862f, 0.10185941f, 
    -0.26926017f, 0.21713786f, 0.23110567f, 0.12913354f, 0.06463464f, -0.34099042f, -0.31613854f, 0.30583477f, 
    -0.04605655f, -0.46423084f, 0.21857718f, 0.04184496f, -0.21564732f, -0.24680957f, -0.00872024f, -0.03195243f, 
    -0.45760617f, -0.03307334f, -0.20895222f, 0.19982149f, -0.04477756f, 0.14738679f, 0.02015507f, 0.18313250f, 
    -0.04104783f, -0.24273172f, -0.25152954f, -0.24843112f, -0.54497290f, 0.05757670f, -0.01439990f, -0.05388006f, 
    0.39772505f, 0.35597900f, -0.04395869f, -0.19524950f, -0.23181456f, -0.00807251f, -0.12223363f, 0.00975662f, 
    -0.02343552f, -0.12064566f, -0.31682047f, 0.02491528f, -0.40985051f, 0.02557239f, -0.18980873f, 0.01761498f, 
    0.08851308f, 0.08888969f, 0.20060845f, 0.06186386f, -0.03743575f, 0.05081128f, -0.02935867f, -0.13405594f, 
    -0.00569167f, -0.04619657f, -0.12639418f, 0.30183551f, -0.15136565f, -0.08662296f, 0.02703443f, 0.25606292f, 
    -0.17978327f, 0.06086579f, -0.44072518f, 0.23460403f, -0.33844170f, -0.18626149f, 0.06770647f, -0.11919291f, 
    0.28167579f, -0.08804917f, -0.20652892f, 0.01412960f, -0.51203936f, -0.55850345f, 0.25016865f, -0.09307547f, 
    0.10328238f, -0.08920104f, -0.65531290f, -0.03488932f, -0.08383068f, 0.40855211f, -0.17280237f, -0.02932947f, 
    0.03499743f, 0.30451608f, 0.05697336f, 0.11607492f, 0.26271001f, 0.06009986f, 0.01967532f, -0.24055390f, 
    -0.58659500f, -0.16774799f, -0.01963837f, 0.07752854f, -0.16614662f, 0.08217024f, -0.08572166f, -0.13025211f, 
    -0.00253352f, 0.35690925f, -0.00937174f, 0.00093009f, 0.34736481f, 0.10652951f, -0.10675497f, 0.06281555f, 
    0.05951320f, 0.05285999f, 0.10816343f, 0.09239775f, -0.05143909f, 0.04733599f, -0.07467823f, -0.33631665f, 
    -0.13584143f, -0.11868163f, -0.10340404f, -0.30827212f, -0.11894767f, 0.04760891f, -0.15764421f, -0.16285874f, 
    -0.37745920f, -0.30663732f, -0.00976627f, -0.02696584f, -0.19571854f, -0.33776981f, -0.46659660f, 0.34352261f, 
    -0.28105932f, -0.45016328f, 0.14196794f, -0.02598475f, 0.14803459f, -0.12751794f, -0.33764374f, -0.06819680f, 
    -0.02037428f, -0.05148020f, 0.16506380f, -0.12112205f, 0.06614994f, -0.11617237f, 0.15005191f, -0.43827134f, 
    -0.40481326f, -0.02977570f, -0.29854462f, 0.07912233f, -0.05752161f, -0.36247614f, -0.12715392f, 0.06054538f, 
    -0.10434616f, -0.28766093f, -0.00741803f, 0.05687069f, 0.14442702f, -0.30638066f, -0.01425153f, -0.25078636f, 
    -0.62928903f, 0.19244702f, 0.28287423f, 0.07313877f, 0.10781861f, -0.19271749f, 0.03602974f, -0.06473231f, 
    -0.06025324f, 0.13182199f, -0.57822382f, 0.05473152f, -0.01608848f, 0.34651715f, 0.20375127f, 0.14712223f, 
    -0.07061539f, 0.10117190f, 0.05251565f, -0.45742074f, -0.18617664f, -0.51498324f, 0.18484205f, 0.10873654f, 
    -0.22117108f, -0.06962401f, 0.40349084f, 0.03418935f, 0.24502589f, 0.26354173f, 0.21890362f, -0.09761713f, 
    0.08259043f, -0.00698599f, -0.01438587f, 0.01894063f, -0.21421669f, -0.05332628f, 0.08058701f, 0.02032454f, 
    -0.16375123f, -0.09263284f, -0.26932478f, 0.29675612f, 0.03603932f, -0.20591809f, -0.24659242f, 0.17400476f, 
    -0.10484831f, 0.17950541f, -0.07868194f, -0.37689978f, 0.18936697f, -0.04180045f, -0.17082514f, 0.12667356f, 
    -0.42389569f, -0.41762489f, -0.01761254f, 0.28487402f, 0.10049094f, -0.42832190f, -0.14857781f, -0.04061643f, 
    0.10253581f, -0.01838038f, -0.01619198f, 0.06497695f, 0.18065354f, -0.19830820f, -0.01698263f, 0.08260190f, 
    -0.01475318f, 0.02562668f, 0.01032093f, -0.10588781f, 0.06986768f, 0.22545485f, -0.35422456f, -0.08078956f, 
    -0.05851622f, 0.04756235f, 0.04066860f, 0.02883340f, 0.19956185f, -0.03416215f, 0.18733478f, 0.16479118f, 
    -0.28340229f, -0.02996761f, 0.29200557f, 0.12788823f, -0.22210293f, -0.28345385f, -0.23736984f, -0.02895261f, 
    0.23702972f, 0.06292840f, 0.01946542f, -0.00229020f, -0.26744401f, -0.19922946f, 0.12113246f, -0.11373588f, 
    0.30966711f, 0.05129991f, 0.09202394f, 0.16574694f, -0.00840810f, 0.10996137f, -0.41342607f, 0.03555791f, 
    0.12752150f, -0.80616164f, -0.05636875f, 0.13153800f, 0.08740741f, 0.17490916f, -0.21568786f, -0.27403557f, 
    0.01654351f, -0.22319353f, 0.09892951f, -0.39890814f, -0.08916234f, 0.18582962f, -0.07611391f, -0.56191480f, 
    -0.47173262f, -0.36036026f, -0.19616236f, -0.02011291f, 0.29338530f, -0.04043702f, 0.19654018f, -0.10241503f, 
    0.10268535f, 0.06589737f, -0.37018758f, 0.05881187f, -0.09660675f, -0.01023071f, 0.16600254f, -0.02674131f, 
    0.03817070f, 0.09144714f, 0.09483737f, -0.11291968f, -0.11078034f, -0.08224802f, -0.15471222f, -0.49130967f, 
    0.08084983f, -0.05260906f, -0.45922285f, 0.10818149f, 0.14481078f, 0.46225289f, 0.23449373f, 0.11649007f, 
    -0.20874088f, 0.26826337f, 0.12842122f, -0.12648676f, 0.21854335f, -0.51493925f, 0.27951670f, 0.03223056f, 
    -0.35588962f, 0.05622225f, 0.07973556f, -0.62399542f, 0.01079781f, -0.32719094f, -0.12260439f, -0.18083820f, 
    0.07047734f, -0.05383323f, -0.19650920f, 0.00883955f, -0.07282187f, -0.04836950f, -0.35120580f, -0.23944053f, 
    0.30511957f, 0.29309243f, -0.00290238f, 0.00892867f, -0.34032139f, -0.36109570f, -0.06494164f, -0.06301525f, 
    -0.11189830f, 0.03324645f, -0.63749588f, -0.03197772f, -0.18294466f, -0.08565556f, -0.26229671f, 0.06405585f, 
    0.04905024f, 0.01958169f, -0.37358913f, 0.03624179f, 0.03908570f, -0.20216420f, 0.27450901f, 0.25200444f, 
    -0.01041404f, 0.03522328f, 0.05239307f, -0.17606427f, -0.13956022f, -0.02280973f, -0.30907762f, 0.11544503f, 
    0.21612008f, -0.02647319f, 0.13734624f, -0.21874924f, -0.10939934f, 0.14075781f, 0.15816048f, -0.07619692f, 
    -0.24508953f, 0.07522460f, 0.08650243f, 0.12320173f, 0.08763640f, -0.15760788f, 0.20331895f, 0.08300326f, 
    0.20379864f, 0.01585231f, -0.10605934f, 0.14835347f, -0.15716261f, -0.04449431f, -0.48351073f, 0.22036877f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.15896453f, 0.00859224f, -0.03855061f, -0.02743393f, 0.00004369f, 0.15428349f, 0.05243333f, -0.26777911f, 
    -0.02032722f, -0.12019286f, 0.24175031f, 0.05452163f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
