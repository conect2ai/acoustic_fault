#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.35522181f, -0.76802862f, -0.81644094f, -0.50326812f, -0.37434408f, 0.56689590f, -0.05600827f, 0.20682889f, 
    0.20377594f, -0.09080867f, 0.26637405f, -0.34844521f, -0.25291666f, 0.12941177f, -0.21225649f, -0.46071479f, 
    -0.28156453f, 0.18679287f, -0.17959772f, -0.62788695f, -0.44353563f, -0.26195791f, -0.02472519f, 0.00039808f, 
    -0.15326919f, -0.16843423f, -0.35962540f, -0.70949835f, -0.63637865f, -0.57762873f, -0.66471094f, -0.59089214f, 
    -0.56179446f, -0.40379152f, -0.59912318f, 0.35375351f, 0.10469472f, 0.09627473f, -0.06932455f, 0.50383914f, 
    -0.05017092f, 0.30979267f, 0.06060821f, 0.11804913f, 0.16809027f, -0.19600342f, 0.05494875f, -0.10651957f, 
    -0.05791170f, -0.07357081f, 0.40765312f, -1.20286560f, -1.06672311f, -0.19498678f, 0.42226323f, -0.60463220f, 
    -0.08324193f, -0.27857497f, -0.17261927f, -0.31009030f, 0.62550640f, 0.26396129f, 0.13439637f, -0.20492460f, 
    0.23424332f, 0.07104178f, -0.01077668f, -0.45645103f, -0.53703636f, -0.33242854f, -0.42879021f, 0.29659534f, 
    0.00296106f, 0.31267092f, -0.23924808f, -0.16287841f, -0.18276967f, -0.25103030f, 0.28691578f, 0.22203472f, 
    0.26857364f, -0.26567155f, -0.11464933f, 0.32040685f, 0.63999242f, -0.06860760f, 0.38079885f, -0.64387912f, 
    -0.11238870f, 0.66843897f, -0.00378001f, -0.26037037f, -0.40531704f, -0.13375409f, -0.09235653f, 0.19283198f, 
    -0.29212025f, 0.21677783f, 0.35414797f, 0.08054999f, -0.24464801f, 0.86739844f, 0.46104044f, -0.44802368f, 
    -0.37005636f, -0.45827085f, -0.24487565f, 0.14485477f, 0.72173667f, 0.44306260f, -0.38624305f, -0.44100091f, 
    -0.05856259f, -0.52698249f, -0.23366462f, 0.40472007f, -0.22251157f, -0.26355475f, 0.07854979f, 0.31739166f, 
    -0.16479634f, -0.17727347f, 0.21614984f, -0.32010555f, 0.02478428f, 1.03143132f, 0.81726283f, -0.23120320f, 
    -0.64694065f, -0.66042560f, -0.23752798f, -0.29236275f, 0.20894086f, -0.46400017f, -0.56277579f, -0.02229731f, 
    0.74741924f, -0.26492101f, -0.23205042f, 0.24380055f, 0.23858178f, 0.13402867f, 0.43667984f, 0.06966096f, 
    -0.30832601f, 0.16396460f, -0.39718539f, -0.25595334f, -0.00871147f, 0.03447048f, 0.78644860f, 0.38940674f, 
    0.81440067f, 0.00650847f, -0.27304938f, -0.85307395f, -0.65806442f, -0.49203834f, -0.26110417f, -0.78325677f, 
    -0.13581505f, -0.33224359f, -0.43045196f, 0.36793393f, -0.06476050f, 0.01739310f, -0.37184468f, -0.11947856f, 
    -0.09435593f, 0.09119957f, -0.17776249f, -0.12813061f, -0.26730409f, -0.28265950f, -0.40993053f, -1.43810892f, 
    -0.04489420f, -0.48733643f, -1.27795947f, -0.62860650f, 0.33677912f, 0.05624815f, -0.31566533f, 0.09450738f, 
    0.77570623f, -0.04236334f, -0.55133444f, -0.33556506f, -0.35756433f, -0.12654509f, 0.29160294f, 0.22818327f, 
    -0.00565269f, 0.00003340f, -0.05792900f, -0.19737434f, -0.26624399f, -0.10013893f, -0.21450356f, -0.02967868f, 
    0.23675714f, -0.41907552f, 0.06291559f, 0.43855375f, 0.59521455f, -0.63815796f, -0.47307596f, -0.34814140f, 
    0.02578745f, 0.01734676f, -0.06739598f, -0.08475593f, 0.11083015f, 0.11646149f, -0.29554787f, 0.07926611f, 
    -0.02846716f, 0.38510567f, 0.03508840f, -0.41199693f, -0.07553196f, 0.08249924f, 0.03004651f, 0.31228924f, 
    0.29115680f, -0.01187345f, -0.43630165f, -1.03186917f, 0.27987820f, 0.99205005f, 0.79077190f, 0.95869988f, 
    -0.19582598f, -0.61960620f, -0.80303890f, -0.23571996f, -0.47030738f, 0.12671098f, -0.10167843f, -0.10063093f, 
    -0.30091581f, -0.03079296f, 0.25220793f, 0.29076836f, -0.09003882f, 0.06740062f, 0.01442673f, -0.01607579f, 
    -0.13205229f, 0.13013633f, -0.17015873f, -0.39037797f, 0.20404623f, -0.00592179f, -0.08776271f, -0.63204396f, 
    -0.17560460f, -0.03864653f, -0.85646045f, -0.99947685f, -0.12749860f, 0.43032423f, 0.04564233f, 0.15330938f, 
    0.18394075f, 0.02665821f, -0.72943246f, -0.00392937f, 0.19180366f, 0.09709178f, -0.37601012f, -0.07775599f, 
    -0.22226506f, 0.24918215f, -0.02858414f, -0.36605632f, -0.76299518f, -0.64484447f, -0.28646532f, -0.11134784f, 
    0.87050414f, 0.42863616f, -0.05338614f, 0.48652539f, 0.37248355f, 0.12117536f, 0.29109576f, 0.02859776f, 
    0.16392666f, -0.40385109f, 0.06016276f, 0.03965221f, -0.15565699f, -0.20905526f, -0.03657392f, -0.01510565f, 
    -0.07704440f, 0.10455813f, 0.16653551f, 0.08783789f, 0.57183683f, 0.20570201f, 0.19159552f, 0.00355761f, 
    -0.25857869f, 0.22607325f, 0.36429167f, 0.28729638f, -0.26207229f, -0.28626290f, 0.00827757f, 0.07097555f, 
    -0.15390532f, -0.26156712f, -0.05807959f, -0.13543493f, 0.11754323f, 0.04104569f, -0.24232097f, -0.03760340f, 
    -0.14994223f, -0.36793065f, -0.29815033f, -0.21262361f, -0.23401389f, -0.28885341f, 0.13390109f, 0.37725571f, 
    -0.29879245f, 0.40339434f, 0.00466241f, 0.54206449f, -0.29029527f, -0.02863017f, -0.12771474f, -0.05458203f, 
    -0.08117019f, 0.38294214f, -0.04865649f, -0.09911695f, 0.66400868f, -0.31141892f, -0.46613631f, -0.12033324f, 
    -0.17960280f, -0.03114921f, 0.17843144f, 0.08159343f, 0.26520720f, 0.07655615f, -0.29918167f, -0.54563969f, 
    0.21251279f, -0.29108772f, -0.52231294f, -0.52474803f, -0.56437254f, -0.32207578f, -0.77081913f, -0.64329439f, 
    -0.22426714f, -0.39733443f, -0.47494999f, -0.07741453f, 0.06072627f, -0.09543797f, -0.09064799f, -0.11683565f, 
    -0.61583710f, -0.53131431f, 0.13020426f, 0.50397682f, -0.13651794f, -0.10613919f, -0.22013451f, -1.09244311f, 
    -0.39780098f, -0.43491176f, -0.28222513f, 0.25928211f, -0.43169537f, -0.47617024f, -0.32120308f, -0.62705725f, 
    -0.71919256f, 0.29457387f, -0.23049174f, -0.15167060f, -0.48975652f, -0.44371423f, 0.20952795f, -0.24475706f, 
    -0.24661839f, 0.26091254f, 0.09595376f, 0.17245412f, -0.06024732f, 0.26965252f, 0.00707657f, -0.15606213f, 
    -1.72231722f, 0.01290917f, 0.17609847f, -1.15526128f, -0.48830765f, 0.24695612f, 0.16548342f, 0.29794189f, 
    0.68625379f, 0.40052104f, 0.14883637f, 0.43946686f, 0.09401889f, -0.16566245f, -0.16672038f, -0.22572470f, 
    -0.24552810f, -0.09066959f, -0.18438086f, -0.35186869f, 0.08467329f, 0.24787487f, 0.36751100f, -0.19284697f, 
    -0.18078883f, -0.89673358f, -0.10090511f, -0.06130888f, -0.01367705f, 0.26927400f, -0.02709925f, -0.23582606f, 
    0.37879434f, 0.13065973f, 0.40767738f, -0.08551572f, -0.13192837f, 0.20569037f, -0.38082576f, 0.21326716f, 
    -0.02623824f, -0.05695341f, -0.52125716f, -0.21220498f, -0.07031669f, 0.40453878f, -0.08143585f, 0.30565816f, 
    0.16391248f, 0.37842143f, 0.50161129f, 0.30709141f, 0.29503149f, 0.27421156f, 0.25078544f, 0.14410779f, 
    0.19511695f, 0.31397986f, -0.30168119f, -0.37009487f, 0.02244626f, 0.19512464f, 0.32490385f, -0.14455341f, 
    -0.32904947f, 0.10611720f, 0.16897994f, -0.16993335f, -0.07297140f, -0.00647710f, 0.03562025f, 0.08345163f, 
    -0.07363076f, -0.14355080f, 0.15484327f, 0.10375647f, 1.12683082f, -0.25411239f, -0.34108138f, -0.21639757f, 
    -0.38046315f, 0.72803575f, -0.50822341f, -0.26195079f, -0.23912992f, 0.06784540f, 0.12657472f, -0.08622248f, 
    -0.39989910f, -0.08164896f, -0.00605110f, 0.31017911f, 0.38660139f, 0.22965609f, -0.34874436f, -0.03438720f, 
    0.03749882f, 0.01817137f, -0.35535434f, -0.15334716f, 0.37509644f, -0.03728529f, -0.21959987f, -0.31788698f, 
    -0.24562450f, -0.12773487f, -0.34431830f, -0.01564607f, -0.05311387f, 0.09569848f, 0.42869842f, 0.71465725f, 
    0.02625779f, 0.03527225f, -0.00562430f, -0.20417234f, 0.09119754f, 0.02229215f, -0.16849916f, -0.32206941f, 
    0.24988016f, 0.21121232f, 0.09389904f, 0.22638991f, 0.28680012f, 0.34231389f, 0.78654003f, -0.52576458f, 
    -0.56766659f, 0.55901998f, -0.33469576f, 0.27013540f, -0.28374839f, -0.34807217f, 0.30160257f, -0.23682010f, 
    -0.04535253f, -0.15831985f, 0.23866862f, -0.18618898f, 0.22132473f, -0.10979458f, 0.26446536f, -0.16765261f, 
    -0.07048618f, -0.27389312f, 0.24981646f, 0.02469674f, 0.30431396f, -0.12134937f, -0.09693783f, 0.75315684f, 
    0.80879045f, -0.18811111f, -0.43443447f, -0.56448847f, -0.09527374f, 0.51162970f, 0.03114056f, -0.22396629f, 
    -0.19617617f, 0.28456193f, 0.06394254f, 0.19939809f, -0.26237181f, -0.21521774f, -0.01290296f, -0.15415278f, 
    -0.34633797f, 0.18578081f, 0.01329810f, 0.01345000f, 0.16919765f, -0.21241184f, -0.09434009f, -0.62534034f, 
    -0.14324012f, 0.18759969f, -0.02649439f, 0.11654856f, -0.15952937f, 0.32166561f, -0.21993217f, -0.05109634f, 
    0.47365609f, -0.06675144f, -0.37366039f, 0.17899543f, 0.18272124f, 0.11534969f, 0.13911435f, -0.25460011f, 
    0.19570644f, -0.19205260f, -0.37572178f, -0.18475473f, 0.54739243f, 0.31588015f, 0.26501909f, -0.34578577f, 
    1.50320601f, -0.15678686f, -0.00676868f, -0.66358924f, -1.19639456f, 0.60351342f, 0.59166211f, -0.04772145f, 
    -0.22878373f, 0.08240274f, 0.01161166f, -0.05951510f, -0.46180594f, -0.35910025f, 0.21467587f, -0.02760411f, 
    -0.19867407f, -0.10985897f, -0.20700644f, -0.45340550f, -0.40526623f, -0.25097874f, -0.17202075f, 0.00659309f, 
    -0.12718765f, -1.02038240f, -1.24692261f, -0.62396747f, 0.38077080f, 0.85612392f, 0.03348172f, 0.78940105f, 
    -0.56118000f, 0.29789853f, -0.29760045f, 0.30691656f, 0.44540763f, 0.27869469f, -0.30948970f, -0.00698422f, 
    -0.24383284f, 0.12771660f, 0.13346519f, -0.14698684f, 0.18483080f, 0.25322074f, -0.29895481f, 0.06613571f, 
    -0.07872349f, 0.11757365f, 0.16412920f, 0.06504562f, 0.62185305f, 0.22606023f, -0.61274058f, 0.31680945f, 
    0.15191539f, -0.49682158f, -0.17336279f, -0.32681045f, 0.13660797f, -0.17060265f, -0.17091832f, -0.22576036f, 
    -0.15096736f, 0.20600224f, 0.32352820f, 0.25149935f, 0.06504435f, -0.27366713f, -0.43150002f, -0.22064710f, 
    0.10438146f, 0.25076780f, 0.22155961f, 0.64310497f, -0.07172471f, -0.90047103f, -0.66456008f, -0.93411094f, 
    0.90309274f, 0.65536046f, 0.71595687f, -0.28783613f, -0.36623898f, 0.31794015f, 0.20643076f, 0.08768727f, 
    -0.25088662f, 0.00850349f, -0.44963568f, -0.33380795f, -0.20445599f, 0.33916470f, 0.31415343f, 0.19507706f, 
    0.08950604f, -0.30963829f, 0.22015081f, 0.00187070f, -0.12530005f, 0.73889911f, -0.52387881f, 0.07227759f, 
    -0.86996764f, -0.11229931f, -0.43337983f, -0.30502522f, 0.23608749f, 0.61184150f, -0.11648507f, 0.25762337f, 
    -0.04101402f, 0.44889128f, -0.00444394f, -0.30921835f, -0.01507681f, -0.12894420f, 0.23606017f, -0.06974507f, 
    0.15211065f, -0.24224493f, -0.04833449f, -0.12013153f, -0.13023330f, 0.53228474f, 0.08434724f, -0.06749511f, 
    -0.08713089f, 0.10183790f, -0.16756980f, -0.27499735f, 0.03571938f, 0.37743822f, -0.03016913f, 0.14691839f, 
    0.44140333f, -0.27480483f, -0.49132025f, -0.24908370f, 0.14050259f, 0.21003072f, -0.25210223f, -0.20528233f, 
    -0.00909316f, 0.17161518f, 0.11713289f, 0.30559409f, 0.01312336f, -0.53592825f, 0.67971772f, 0.61336786f, 
    -0.61962998f, 0.21927634f, -0.92173731f, 0.16775224f, -0.70187724f, 0.42427158f, 0.41832575f, -0.03679527f, 
    -0.16074534f, -0.27635634f, -0.07931610f, 0.09543385f, -0.24147086f, 0.08924916f, 0.16461584f, 0.06996574f, 
    -0.04765207f, -0.04278719f, -0.23599337f, 0.07910523f, 0.04010427f, -0.00253228f, 0.03290477f, 0.32788628f, 
    0.04520806f, -0.02092617f, 0.11238412f, 0.47354227f, 0.28182343f, 0.27519968f, 0.46224171f, 0.35871899f, 
    0.25403383f, 0.13393803f, 0.10809771f, -0.23021658f, -0.06484279f, 0.13704854f, -0.23978835f, 0.07775242f, 
    -0.22938597f, -0.20666233f, 0.00158831f, 0.00927096f, 0.19679914f, -0.06092154f, -0.22309719f, 0.02278522f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.08873761f, -0.31430757f, 0.46003583f, 0.52540475f, 0.35426241f, 0.30800122f, 0.13738874f, -0.28387940f, 
    0.27334207f, 0.32509831f, 0.00945858f, 0.29929757f, 0.12310925f, 0.06612755f, -0.19704564f, -0.24879196f, 
    0.24729644f, 0.11157891f, -0.13645020f, 0.29527122f, 0.09556061f, 0.15498275f, 0.53126287f, 0.34307477f, 
    0.15504576f, 0.29991728f, 0.10235476f, 0.59288299f, 0.20227936f, 0.50529206f, 0.29556897f, -0.17310677f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36808425f, -0.02810169f, 0.01906996f, -0.04120685f, 0.14800596f, 0.11327663f, -0.11080525f, -0.09789670f, 
    0.01703411f, 0.08227891f, -0.05232707f, 0.15821441f, 0.54763359f, 0.31376117f, -0.20569257f, -0.28316849f, 
    0.12268146f, 0.12368046f, -0.03981230f, 0.05263204f, 0.03920768f, 0.04034586f, 0.06853131f, 0.01614320f, 
    0.43926424f, 0.40596095f, -0.17647341f, -0.16813388f, -0.02187304f, -0.07918298f, -0.09916634f, -0.26403573f, 
    -0.28502306f, -0.05807899f, -0.30218959f, -0.06128585f, -0.26224101f, 0.00461131f, -0.07173935f, -0.18117402f, 
    -0.05077215f, -0.03298520f, 0.04985005f, 0.02182042f, 0.01877459f, 0.00844112f, -0.17290558f, -0.26440439f, 
    -1.36501265f, 0.34688944f, 0.04315033f, -0.12604293f, 0.06164842f, 0.07798374f, -0.00557838f, 0.08541472f, 
    0.05027216f, -0.06872379f, -0.01903542f, -0.00948494f, 0.19092613f, -0.07077033f, -0.29796755f, 0.01966545f, 
    0.01281697f, -0.05509254f, -0.05988019f, -0.21299595f, 0.04622567f, 0.12333670f, 0.04764676f, -0.06200321f, 
    0.05572600f, 0.10031624f, 0.12990554f, -0.05028004f, -0.19627623f, -0.10893405f, 0.03680108f, -0.07910299f, 
    -0.05808752f, -0.00610406f, 0.00075738f, 0.04717669f, 0.28846893f, 0.31557915f, 0.03771575f, -0.13563575f, 
    0.13863909f, 0.45233336f, 0.10041003f, 0.25574562f, 0.03066243f, 0.04194027f, 0.08430360f, -0.12767524f, 
    0.02533319f, 0.27099121f, 0.14227863f, -0.22882909f, 0.22312902f, -0.16571653f, -0.09602346f, -0.04159708f, 
    -0.00739943f, -0.13534966f, -0.04922024f, -0.01156074f, 0.54218769f, -0.50212699f, -0.51146138f, -0.16081609f, 
    -0.19601195f, -0.10141212f, 0.17045219f, 0.02008476f, -0.08426011f, -0.08643844f, 0.03146584f, 0.10541955f, 
    0.39120439f, 0.06011758f, -0.14463569f, -0.16883504f, 0.03299719f, -0.09651802f, 0.09070936f, 0.09322570f, 
    -0.02241870f, 0.01185159f, -0.03190587f, -0.03589089f, -0.03709220f, 0.03758440f, -0.29408941f, 0.07072259f, 
    0.07960861f, 0.05274362f, 0.05259985f, -0.02612963f, 0.05465891f, 0.20081790f, -0.06879824f, -0.07107895f, 
    -0.42505750f, -0.45377094f, -0.27533117f, 0.14119014f, -0.04346145f, 0.05496786f, -0.00003372f, 0.06541198f, 
    -0.06311258f, 0.08791574f, 0.11752617f, 0.06161294f, -0.41235512f, 0.11661030f, -0.06911820f, -0.10658130f, 
    -0.06273924f, -0.01653393f, 0.08133324f, 0.02781000f, -0.06377839f, 0.15867598f, -0.11252796f, 0.04147917f, 
    0.38214546f, 0.07830561f, -0.13573553f, -0.20314544f, 0.02607853f, 0.16015828f, -0.06484342f, -0.04129409f, 
    -0.06540167f, -0.07104194f, -0.09367174f, -0.01927703f, 0.51866740f, 0.27889293f, -0.04287974f, -0.28316721f, 
    0.10272001f, 0.17855540f, 0.10160734f, 0.21943153f, -0.07498149f, -0.00878242f, -0.05182843f, -0.05761657f, 
    0.02068499f, -0.06714824f, 0.05357844f, -0.16364922f, 0.13146485f, 0.19327827f, 0.06822560f, -0.00538781f, 
    0.02336665f, 0.04023978f, -0.11270796f, 0.04371452f, -0.01253954f, 0.16919342f, 0.14881854f, -0.13889392f, 
    0.00507499f, 0.01601664f, 0.09238780f, -0.01068349f, -0.12918912f, -0.10324506f, -0.22583304f, -0.33262956f, 
    -0.09849204f, -0.05289520f, 0.02174351f, 0.10144604f, 0.00299761f, 0.07451624f, -0.00785877f, 0.05034095f, 
    0.01637102f, 0.06393957f, 0.02759068f, -0.00323990f, -0.18449633f, -0.18955381f, -0.67424625f, 0.28837734f, 
    -0.08623374f, -0.12652867f, -0.05646786f, -0.09481535f, -0.08530793f, 0.11834583f, 0.01100542f, -0.01387478f, 
    0.13056469f, 0.06624424f, 0.04022813f, 0.05267021f, -0.14658919f, 0.09229220f, -0.12598051f, -0.37598187f, 
    -0.14656061f, -0.07512947f, -0.03346560f, -0.07830372f, -0.27418905f, 0.27859333f, -0.14490455f, 0.18176824f, 
    -0.12756953f, 0.13017274f, -0.12729886f, -0.05948578f, -0.09762322f, -0.02898708f, -0.09887348f, 0.00325910f, 
    -0.60376519f, -0.65242290f, 0.21792108f, 0.10472208f, -0.04042332f, 0.06991324f, -0.02523753f, 0.04452024f, 
    -0.01806996f, 0.00267715f, -0.05962803f, 0.01988401f, -0.13743708f, 0.13309819f, -0.05151217f, -0.12948412f, 
    -0.01065448f, -0.10545598f, 0.01047991f, -0.13270970f, -0.09023938f, -0.02110310f, 0.02579415f, -0.06997860f, 
    -0.04512656f, -0.26559269f, -0.11851496f, 0.15634204f, -0.00790243f, 0.04638025f, -0.07744287f, -0.13647176f, 
    -0.17496826f, -0.04885906f, -0.08309087f, 0.12208234f, 0.37333110f, 0.49730870f, -0.24714187f, -0.11458062f, 
    0.12977780f, 0.05976610f, 0.12062301f, -0.24564417f, -0.00380443f, -0.16212967f, 0.03894975f, -0.06288126f, 
    0.17161824f, 0.02207850f, -0.35786852f, -0.78280348f, -0.04042340f, 0.00880288f, 0.01181693f, 0.00485998f, 
    -0.13164768f, -0.11592417f, -0.00084364f, 0.11043853f, 0.05821928f, -0.45011064f, -0.72943252f, 0.07551965f, 
    0.12148339f, -0.04426369f, -0.33141768f, -0.08621997f, -0.03608696f, -0.16029581f, -0.27355963f, 0.05235480f, 
    0.15703250f, -0.07746004f, 0.07388481f, -0.00366768f, 0.06379487f, -0.08397999f, -0.08832701f, -0.01044388f, 
    -0.01563688f, -0.19823268f, -0.06758211f, 0.01450658f, -0.58373576f, -0.32859442f, -0.22599167f, -0.06645574f, 
    -0.07849778f, -0.10960280f, -0.02475369f, 0.00349859f, -0.00757397f, -0.06883388f, 0.03975381f, 0.08141204f, 
    -0.31326109f, -0.16607305f, -0.16389810f, -0.02646788f, -0.05342913f, 0.04432647f, -0.05078241f, -0.04390277f, 
    -0.08522616f, 0.04391856f, -0.09217801f, -0.04177755f, -0.16601253f, -0.05860846f, -0.00897757f, 0.02678695f, 
    0.08965203f, 0.01670737f, 0.09221850f, 0.00687187f, -0.03571382f, 0.02497721f, -0.24293099f, -0.19981195f, 
    0.07713489f, 0.07696015f, -0.06857121f, -0.18823181f, 0.09671925f, 0.04897834f, 0.03446025f, -0.10874694f, 
    0.04335411f, -0.18434304f, -0.23348355f, -0.16305862f, 0.05844587f, 0.19036770f, 0.28673002f, 0.08064048f, 
    -0.12302221f, 0.04721215f, -0.08906616f, -0.21926211f, -0.08998679f, 0.02871526f, -0.07501578f, 0.05818624f, 
    -0.36461094f, 0.00473746f, -0.08550184f, -0.03424193f, 0.00113124f, 0.23215187f, 0.10284001f, 0.31877121f, 
    0.11136985f, -0.00107505f, 0.05435411f, 0.07235317f, 0.07450739f, 0.15832072f, 0.05419891f, 0.05351038f, 
    0.00069018f, -0.01207052f, 0.03270856f, 0.11692912f, 0.05118895f, -0.01660664f, 0.06047551f, -0.02518342f, 
    0.08348434f, 0.31546500f, 0.46029887f, -0.08875394f, -0.03598225f, 0.07384914f, -0.01407315f, -0.09410575f, 
    0.04733053f, 0.00731184f, -0.06727541f, -0.02290429f, 0.29718241f, -0.25634643f, 0.06663223f, -0.28391027f, 
    -0.11390864f, -0.00033482f, 0.17764370f, -0.21868497f, -0.00901539f, -0.01801221f, -0.22523749f, 0.19753310f, 
    0.15816684f, -0.19571522f, -0.22129883f, -0.55694890f, 0.05120870f, -0.22246803f, -0.31665486f, -0.02476280f, 
    -0.04421058f, 0.05839697f, 0.00882773f, -0.05073107f, 0.46394295f, 0.30936536f, 0.10991812f, 0.02654812f, 
    0.08771010f, -0.02710043f, -0.38354591f, -0.42585909f, -0.02533178f, -0.00479077f, -0.27568227f, -0.31332082f, 
    -0.20913160f, 0.15597749f, -0.01693001f, -0.06047288f, -0.13517013f, 0.04176642f, -0.05877499f, -0.22258873f, 
    -0.05604055f, 0.01677792f, 0.01823263f, 0.05889631f, 0.27308589f, -0.37863451f, 0.42484206f, 0.22419088f, 
    -0.00755336f, -0.12629962f, 0.05603040f, -0.07529563f, 0.24297681f, 0.12295120f, 0.00352453f, -0.17010142f, 
    0.00353015f, -0.22574557f, -0.02393914f, -0.23864253f, -0.25947696f, 0.24807149f, -0.18452342f, 0.20563775f, 
    0.01327278f, 0.01503612f, 0.10678791f, 0.07824858f, 0.57546306f, -0.05980761f, -0.37419206f, -0.13923748f, 
    -0.04029201f, -0.04213403f, 0.08508138f, -0.05416952f, -0.00389608f, 0.09445386f, 0.12060330f, 0.01350636f, 
    0.26638851f, 0.00792143f, 0.13561177f, 0.05390547f, -0.05677477f, -0.04739024f, 0.01527080f, -0.01310227f, 
    0.04855451f, -0.37526119f, -0.12654355f, 0.18051212f, 0.15698545f, -0.30396780f, 0.01099518f, 0.21364847f, 
    -0.11381389f, -0.09765603f, 0.17517637f, 0.06939552f, -0.07323811f, -0.08150310f, 0.09308144f, 0.02636395f, 
    -0.20200226f, 0.04338479f, 0.20420493f, -0.07556060f, -0.10523112f, -0.03517563f, -0.18770242f, 0.45257807f, 
    -0.01876106f, 0.07386280f, 0.06322733f, 0.05225175f, 0.02009684f, 0.00279310f, 0.10822353f, 0.10067742f, 
    -0.01406181f, -0.00982022f, 0.11055273f, -0.23152161f, -0.07395913f, 0.02323747f, -0.03160696f, -0.00288106f, 
    -0.48031631f, -0.06919131f, -0.44689026f, -0.31890854f, -0.03413083f, 0.12070093f, -0.12811188f, 0.12808573f, 
    -0.27642813f, -0.03106092f, -0.02548920f, -0.00193251f, -0.32226127f, 0.13355349f, 0.00082633f, 0.16195175f, 
    0.06598832f, 0.11267740f, 0.04436503f, 0.03367750f, 0.02404181f, 0.05536416f, -0.01947706f, 0.00503643f, 
    0.18871804f, 0.04287895f, 0.09216128f, 0.01771313f, -0.07605718f, 0.00962915f, 0.03073031f, -0.06939365f, 
    -0.01277747f, -0.00135905f, 0.00285539f, 0.05494653f, 0.05250581f, -0.37324318f, 0.23852938f, -0.35950282f, 
    -0.18807583f, 0.17610486f, -0.26842037f, 0.00751504f, -0.07660918f, -0.02211107f, -0.07873049f, 0.09689503f, 
    -0.03738408f, -0.07130626f, -0.09127244f, -0.07729641f, 0.15816955f, 0.08987324f, -0.04534485f, 0.01337727f, 
    -0.16152315f, -0.00157482f, -0.11003799f, 0.08171598f, 0.08007705f, -0.23833226f, 0.13167980f, -0.08226091f, 
    -0.04824420f, -0.31209236f, 0.04935061f, 0.06794523f, -0.05294867f, 0.09439627f, -0.05243571f, -0.00970272f, 
    0.40160027f, 0.02886339f, 0.26338854f, -0.30132228f, -0.02581470f, -0.03707989f, 0.05664467f, 0.00428373f, 
    0.02374444f, 0.01265621f, -0.01615906f, 0.04844010f, -0.19601505f, -0.03560567f, 0.23246053f, -0.13522378f, 
    -0.02552086f, 0.09527560f, 0.00278118f, 0.19820267f, -0.20040029f, 0.00886313f, 0.18833685f, -0.29056752f, 
    0.88477951f, -0.25043860f, 0.33369854f, -0.14353123f, -0.02464486f, 0.00295117f, 0.00754427f, -0.04619747f, 
    -0.19663897f, -0.17982881f, -0.24618015f, -0.26398247f, -0.17818761f, -0.28453982f, -0.16297691f, 0.13207974f, 
    -0.06727407f, 0.05132410f, 0.12426881f, 0.00398643f, 0.03206040f, -0.15586734f, -0.04557705f, 0.07300793f, 
    0.32611284f, -0.28000656f, -0.02418406f, -0.12832892f, -0.10835936f, -0.12697203f, 0.03548600f, -0.04326394f, 
    0.11197105f, 0.20113608f, -0.11580016f, -0.02525419f, 0.68892568f, -0.46600580f, -0.49640444f, -0.09518111f, 
    0.06685926f, 0.00017347f, -0.10573510f, 0.05212377f, 0.03361123f, 0.27529219f, 0.09548861f, -0.00412491f, 
    -0.46179390f, 0.02732450f, 0.13354257f, -0.31876314f, 0.06795478f, 0.08688635f, -0.11716888f, 0.05979866f, 
    0.08176797f, -0.02853348f, 0.05082271f, -0.00103566f, 0.11180553f, 0.02836187f, 0.12666790f, 0.31869537f, 
    0.04205764f, -0.05191580f, 0.00601137f, 0.04855696f, -0.00675536f, 0.03311963f, -0.14928040f, 0.05181115f, 
    0.14820722f, 0.13827312f, 0.25821704f, -0.27313533f, 0.01312810f, -0.08740240f, -0.03267986f, -0.08540948f, 
    -0.11592064f, 0.12661643f, 0.00182658f, 0.03018652f, 0.18418087f, 0.16013506f, 0.12804930f, 0.20028253f, 
    -0.01442791f, -0.06951594f, -0.08169641f, 0.01202757f, 0.12006200f, 0.15604354f, -0.10975621f, 0.04224861f, 
    -0.44476604f, 0.51296216f, 0.49620253f, -0.09931009f, -0.08978217f, -0.08961880f, 0.15791374f, 0.16602303f, 
    -0.09290024f, -0.04673455f, 0.08881178f, -0.15337166f, -0.62802863f, -0.29809448f, -0.01263941f, -0.32521808f, 
    -0.19158082f, -0.08163133f, -0.05838434f, -0.17558728f, 0.09082276f, 0.12363930f, -0.00380802f, 0.03998519f, 
    0.00285648f, 0.04534072f, 0.18767613f, 0.19429834f, -0.06037721f, -0.08527981f, 0.09655131f, -0.02947936f, 
    -0.03209026f, -0.04756606f, -0.02137249f, 0.04548248f, -0.11259783f, -0.31028834f, -0.14574386f, 0.00585068f, 
    0.04879247f, 0.08665282f, 0.04305507f, 0.02495388f, -0.04982182f, 0.08112808f, -0.36067918f, 0.22576691f, 
    0.13926628f, -0.02711620f, 0.15277150f, -0.19346499f, -0.02803496f, 0.04076433f, -0.05820952f, 0.08156383f, 
    -0.10263328f, 0.10807298f, 0.00572905f, 0.00673316f, -0.31547830f, -0.02692423f, 0.25852579f, -0.26599967f, 
    -0.04550270f, 0.03146838f, -0.22938380f, -0.15391628f, 0.04114455f, 0.07636686f, -0.07137649f, 0.08339380f, 
    -0.81319034f, 0.03048815f, 0.42912728f, -0.12685607f, -0.00919474f, -0.08739375f, -0.34347820f, -0.44203246f, 
    0.03237960f, 0.03988781f, -0.01560399f, 0.03002978f, 0.17433205f, 0.44077700f, 0.55080557f, 0.71831477f, 
    0.01053427f, -0.15126997f, -0.09731460f, 0.00716337f, 0.04156081f, 0.07826188f, -0.09413412f, 0.14687452f, 
    -0.19161627f, -0.01346838f, -0.01862199f, 0.09469281f, -0.37534836f, 0.12863150f, 0.11898462f, 0.04380080f, 
    0.03734565f, -0.01273557f, 0.03969821f, -0.10087796f, -0.16355112f, 0.18514760f, -0.30597898f, -0.10739992f, 
    0.13329056f, -0.07273152f, 0.01709640f, 0.03710883f, 0.11029451f, 0.00817071f, 0.05398598f, -0.30861464f, 
    -0.67059267f, -0.11786877f, -0.37619811f, -0.26387939f, 0.14896201f, 0.01642065f, 0.06407055f, -0.02032725f, 
    -0.05221497f, 0.01271404f, -0.05408940f, -0.07216812f, -0.22899327f, 0.16114587f, 0.20917246f, 0.23247625f, 
    -0.03066004f, -0.01491528f, 0.10766551f, 0.07495552f, 0.04235742f, -0.28932506f, 0.06196374f, 0.08291730f, 
    -0.00572937f, -0.14951602f, -0.08337809f, -0.15704469f, 0.06007019f, -0.05898735f, 0.06006128f, 0.02390089f, 
    0.02430722f, 0.10114639f, -0.00396664f, 0.26893967f, 0.29486409f, -0.61219376f, -0.36924133f, 0.01312493f, 
    -0.06039616f, -0.04944431f, 0.06159079f, -0.00185488f, -0.00866156f, -0.03634055f, 0.15972789f, 0.01615034f, 
    -0.52360576f, -0.44458327f, -0.19523305f, -0.37812170f, 0.10225300f, -0.17856134f, -0.16893531f, 0.01034048f, 
    0.01989482f, -0.11290526f, -0.04096308f, -0.02637629f, -1.00128508f, -0.43945980f, -0.22846077f, -0.28859305f, 
    0.29653847f, -0.15856659f, 0.33069497f, 0.14654359f, -0.02917599f, 0.03264823f, -0.03127792f, -0.03575706f, 
    0.37825999f, 0.61831963f, 0.07416934f, 0.52335799f, -0.00196235f, -0.01336217f, 0.12747607f, -0.06319928f, 
    -0.20846166f, -0.00216870f, 0.09030908f, 0.16534072f, 0.06152194f, -0.27051839f, -0.20259070f, 0.02246139f, 
    0.05360362f, 0.02160894f, 0.04700971f, -0.02777803f, 0.01717416f, -0.02153867f, -0.41806901f, -0.03314266f, 
    -0.13269177f, -0.13661836f, -0.17695874f, -0.06289711f, -0.14299075f, -0.04221017f, 0.11123258f, 0.03155844f, 
    -0.00389780f, -0.13669139f, 0.05712252f, -0.03659565f, 0.22100121f, -0.39979920f, 0.28771898f, -0.66753286f, 
    0.20401737f, -0.04427603f, -0.29992142f, -0.11131196f, 0.10071014f, -0.02743310f, 0.05779070f, -0.01574357f, 
    -0.22258849f, -0.06428711f, -0.14525616f, 0.01300941f, -0.11550213f, 0.05746426f, -0.10564853f, 0.01030695f, 
    0.13929489f, 0.00071959f, -0.07476109f, 0.08557113f, 0.23825659f, -0.65360844f, 0.34490880f, -0.10242870f, 
    0.08550116f, -0.14827813f, 0.00915834f, 0.10265189f, -0.04987889f, 0.01063464f, 0.00591055f, -0.01695739f, 
    0.11102083f, -0.14238203f, -0.03728266f, -0.41643399f, -0.00437438f, -0.02417570f, -0.05734639f, 0.00370808f, 
    0.05357798f, 0.00038726f, 0.00898841f, 0.08814454f, 0.03516517f, -0.18078776f, 0.18463972f, 0.19685838f, 
    0.21545909f, 0.07536980f, 0.02186862f, -0.04050643f, 0.01490546f, -0.35754248f, 0.10769151f, 0.00869318f, 
    -0.38614345f, 0.51594067f, 0.12768394f, -0.50350994f, -0.05278154f, -0.11271075f, -0.05043619f, -0.11789960f, 
    0.03537690f, 0.15240641f, -0.11937594f, 0.20342232f, 0.19577697f, -0.15085201f, 0.04042330f, 0.02713853f, 
    0.05134850f, -0.08553894f, -0.02805439f, 0.49942747f, 0.09180269f, 0.09224220f, -0.00644337f, 0.03421632f, 
    -0.36028412f, 0.03961945f, 0.11432681f, -0.37311101f, -0.00771164f, -0.00500158f, 0.04706246f, 0.05106375f, 
    -0.02873346f, 0.00202237f, 0.10181854f, -0.04925907f, -0.25425532f, 0.29558569f, 0.50405836f, 0.02333598f, 
    0.01870717f, -0.11828984f, 0.10036805f, -0.01986542f, 0.07224429f, -0.01539540f, -0.23280260f, -0.10947396f, 
    0.33839390f, 0.05582166f, 0.01285614f, 0.23069791f, 0.05830262f, 0.05817174f, -0.31336343f, -0.24158707f, 
    0.10035163f, -0.05163311f, 0.02842499f, 0.14673385f, -0.14326400f, -0.11635379f, -0.03555015f, 0.26865655f, 
    0.02889071f, 0.07889654f, 0.05048956f, -0.02865848f, 0.07608937f, 0.04026363f, -0.25163874f, 0.16537488f, 
    -0.24473062f, 0.33494681f, 0.00679753f, -0.08845057f, -0.02490401f, -0.00356522f, -0.02718618f, 0.08855850f, 
    -0.08406977f, 0.04752292f, -0.06915767f, 0.03242799f, -0.07125807f, -0.25088665f, -0.01145533f, 0.01952649f, 
    -0.00022692f, -0.04672436f, 0.08278809f, 0.05208026f, -0.03832571f, 0.05271737f, -0.17276126f, 0.27748796f, 
    -0.09808709f, -0.20284623f, -0.04104155f, 0.13144748f, 0.11320142f, -0.03606338f, -0.13484205f, -0.12380087f, 
    0.01305815f, -0.00187431f, 0.13096327f, 0.11240055f, 0.01702640f, -0.34406286f, -0.09401345f, 0.07428806f, 
    0.03676470f, 0.07745790f, 0.06564078f, 0.03588402f, 0.16095155f, -0.01960454f, 0.01801587f, 0.03310649f, 
    -0.12930316f, 0.06715073f, -0.08202023f, 0.17185663f, -0.08140082f, 0.00258850f, 0.07652529f, 0.04923356f, 
    -0.19044343f, 0.18232134f, -0.01222098f, -0.11768302f, -0.17586513f, -0.05444317f, -0.06741544f, -0.41958821f, 
    0.07417838f, -0.14793181f, 0.01806890f, -0.18085836f, 0.02387992f, 0.11620884f, -0.05742894f, 0.00534498f, 
    0.86228824f, -0.40014604f, 0.13069151f, -0.23511371f, -0.26998040f, 0.10550131f, 0.02019141f, 0.01920389f, 
    -0.12093471f, -0.15553883f, 0.14130017f, -0.03346302f, -0.21068081f, -0.20004204f, 0.40115327f, 0.21511841f, 
    -0.03581688f, -0.10224317f, -0.03426322f, 0.04753143f, -0.01882710f, -0.21618596f, 0.04560252f, -0.10789346f, 
    -0.22173744f, -0.27584779f, 0.27248263f, 0.15032969f, -0.10112523f, 0.06434226f, 0.05832128f, 0.10659280f, 
    0.07658695f, -0.02525429f, 0.21118729f, 0.05896004f, 0.64331675f, -0.37211564f, 0.01427885f, 0.23142616f, 
    0.19037235f, -0.05507397f, 0.06032667f, -0.24339738f, -0.01353191f, 0.01267272f, 0.06918486f, 0.17656355f, 
    0.02034605f, 0.18298681f, -0.10628674f, 0.31710371f, -0.25774586f, -0.23264414f, -0.08178857f, -0.29467753f, 
    -0.18934810f, 0.23896225f, 0.05277801f, -0.13156123f, 0.39232489f, 0.85590613f, -0.73537016f, 0.06898063f, 
    0.42190427f, -0.05861771f, -0.22240105f, -0.18945561f, -0.09163312f, -0.10858785f, 0.03911343f, -0.01701652f, 
    -0.09793544f, -0.16514234f, 0.07806779f, 0.27260086f, -0.05020120f, 0.17699549f, 0.17342597f, -0.01738592f, 
    0.00784573f, -0.13400245f, 0.11615107f, -0.04653025f, -0.16928658f, -0.23686036f, -0.18682820f, -0.09167208f, 
    0.27833053f, 0.27252114f, 0.10178930f, 0.04640228f, -0.12766965f, -0.00436672f, -0.16367082f, -0.04144680f, 
    -0.24436811f, 0.10531496f, 0.06581743f, 0.13417183f, 0.04084877f, 0.05780813f, 0.07059569f, -0.00083356f, 
    0.07231832f, 0.05890836f, -0.04511373f, 0.14210790f, 0.34254876f, 0.45311272f, -0.21338071f, -0.40388098f, 
    -0.13329555f, 0.02425494f, -0.12803546f, 0.05645793f, -0.33124360f, -0.25241631f, 0.01249049f, -0.28211859f, 
    -0.02188190f, -0.12230361f, 0.07909658f, 0.24126881f, -0.06576382f, -0.04143805f, 0.13602164f, 0.17236935f, 
    -0.13591319f, 0.04245384f, -0.26743186f, -0.11046898f, -0.01465504f, -0.12667106f, -0.07818443f, 0.06661095f, 
    0.06429970f, 0.10421996f, 0.02014658f, -0.03103334f, -0.02304740f, 0.06790048f, 0.03813336f, 0.00379440f, 
    0.76394087f, -0.11944436f, 0.13105099f, 0.22583072f, 0.11889040f, -0.08524018f, -0.10673602f, 0.02986302f, 
    -0.16098797f, 0.03840782f, -0.12596305f, 0.12536278f, 0.28078830f, 0.18851024f, -0.05733181f, -0.07291907f, 
    0.07076412f, -0.03224998f, -0.12755540f, -0.03316333f, 0.08210897f, 0.29812557f, -0.03547006f, 0.35942784f, 
    0.04326641f, -0.54511601f, -0.05508084f, -0.07109970f, 0.01446951f, -0.25032100f, -0.22189754f, -0.03346263f, 
    0.07045937f, 0.03440463f, 0.08341277f, 0.04329003f, 0.13857405f, -0.11227152f, 0.23317863f, 0.10109112f, 
    -0.15305066f, -0.11910509f, -0.42946658f, -0.00937417f, -0.13610660f, 0.13376465f, -0.12797466f, 0.04865026f, 
    -0.03446290f, 0.10859440f, -0.08578399f, 0.19716419f, 0.09906980f, 0.00314459f, 0.10245094f, 0.06971169f, 
    0.09937377f, 0.29008663f, 0.01406030f, -0.07985315f, 0.12869903f, -0.09844435f, 0.18729579f, 0.06254064f, 
    -0.14863229f, -0.46162114f, -0.25977296f, -0.23588097f, -0.10899306f, -0.18201406f, 0.10890367f, -0.03787047f, 
    0.21729863f, 0.11459943f, 0.22421835f, -0.52192235f, -0.00465693f, -0.17161946f, -0.27820224f, -0.08093920f, 
    -0.04624463f, 0.01866408f, 0.05310305f, -0.09903517f, 0.42210877f, 0.13457392f, -0.02457478f, -0.11626842f, 
    -0.04986996f, 0.00796773f, -0.15670978f, -0.25442374f, 0.07725728f, -0.21795571f, -0.08250874f, -0.07499164f, 
    -0.74753594f, 0.04410330f, 0.04164255f, 0.36360595f, -0.03812998f, 0.09274401f, -0.01955030f, -0.07925478f, 
    0.18444766f, 0.08682638f, 0.07595504f, 0.04584551f, -0.29372808f, 0.40178946f, -0.38472325f, -0.68484735f, 
    0.23515920f, -0.04842985f, 0.10497779f, -0.09984062f, -0.19403599f, 0.23796339f, -0.21829879f, -0.04828189f, 
    -0.16922078f, 0.16234694f, 0.55362529f, 0.79779178f, -0.11171613f, -0.10429412f, -0.08773607f, -0.11635276f, 
    -0.08362097f, -0.01765537f, 0.00737259f, 0.08210649f, -0.13444191f, 0.11099964f, -0.03750299f, 0.51571828f, 
    0.15571654f, -0.12028059f, -0.10798074f, -0.13295868f, -0.04005986f, -0.09833923f, 0.15563968f, 0.00028550f, 
    -0.53201586f, -0.06722268f, -0.21621123f, 0.34860185f, 0.00124738f, 0.20529345f, -0.24277668f, -0.15265210f, 
    -0.08640537f, -0.23099902f, -0.10919359f, 0.09832532f, -0.23747143f, -0.08798909f, -0.11362794f, -0.38745606f, 
    -0.03648693f, 0.15101843f, -0.00554727f, 0.07399677f, -0.11961872f, 0.13697836f, -0.13457394f, 0.05494548f, 
    -0.51575613f, -0.15418221f, 0.20405704f, -0.25718987f, -0.21250701f, 0.08676852f, -0.28560039f, -0.05556944f, 
    -0.16806549f, -0.00924384f, -0.08966530f, -0.11349066f, -0.25959641f, -0.47342783f, -0.38493130f, 0.01352813f, 
    0.13858938f, 0.23985641f, 0.11656896f, 0.08477150f, -0.19149940f, 0.09737538f, -0.03981986f, -0.11938931f, 
    -0.07833449f, 0.12795699f, 0.09251209f, 0.23428752f, -0.19216079f, -0.08769882f, 0.02733166f, 0.01738505f, 
    0.09148900f, 0.16962153f, -0.05610902f, 0.10158036f, 0.08061884f, 0.20808919f, 0.38715425f, 0.23278455f, 
    -0.12888786f, 0.00254028f, 0.04744620f, 0.22107053f, 0.15388753f, -0.02648898f, 0.03705485f, 0.04075442f, 
    0.13034324f, -0.07507455f, 0.34365344f, 0.11986940f, -0.02293902f, -0.00809018f, -0.20745069f, -0.16528274f, 
    0.01232726f, -0.07203271f, 0.11408832f, -0.09649666f, 0.04307182f, -0.08591079f, -0.17769198f, 0.14256988f, 
    -0.00263947f, 0.09749562f, 0.01004286f, 0.02074094f, -0.26541051f, -0.47519997f, -0.37791571f, 0.02314650f, 
    0.17154866f, -0.55907536f, -0.43311554f, -0.25200251f, 0.09350008f, -0.10110015f, 0.08241028f, 0.14628498f, 
    -0.00147083f, -0.08090435f, 0.06300210f, -0.01452077f, 0.14454779f, 0.33187538f, -0.08648744f, 0.18898253f, 
    0.12572795f, 0.07104727f, 0.15683891f, -0.02613267f, 0.03244340f, -0.04996596f, 0.04931162f, -0.13267775f, 
    0.15931541f, 0.40330389f, 0.03744459f, 0.19577962f, -0.06678287f, 0.15751070f, -0.01533062f, -0.05374792f, 
    -0.01286130f, 0.06204729f, -0.05443719f, -0.01576778f, -0.35683227f, -0.18446369f, 0.04472175f, 0.20339245f, 
    -0.10873307f, -0.11310887f, -0.00401282f, 0.03043101f, -0.01231300f, -0.04574062f, 0.01402207f, 0.11647855f, 
    -0.04372301f, -0.11427793f, 0.27873787f, 0.13502668f, 0.01637898f, 0.08024874f, 0.04627452f, 0.17300022f, 
    -0.01456154f, -0.14458600f, -0.08054896f, -0.06488422f, -0.54251069f, -0.65079117f, 0.38845369f, -0.08960547f, 
    0.10119133f, 0.30206046f, -0.28560141f, 0.00020867f, -0.04804926f, -0.01246986f, -0.01594931f, -0.16818498f, 
    0.01916089f, 0.30065915f, 0.11538891f, 0.14857437f, -0.00397818f, -0.15495373f, 0.05083240f, 0.32016352f, 
    -0.08789417f, -0.06152303f, -0.04591410f, -0.04561852f, 0.36020318f, -0.03706159f, -0.05065469f, 0.04926049f, 
    -0.05718184f, 0.02656251f, 0.00203778f, 0.09009988f, 0.06519853f, -0.19538333f, -0.04796627f, 0.05723706f, 
    0.15026195f, 0.07006798f, -0.20124108f, -0.08510673f, 0.05489679f, -0.02438228f, 0.01597612f, -0.02368660f, 
    0.05216661f, 0.08582961f, 0.13898028f, 0.05922942f, -0.03171518f, 0.00468055f, 0.10695840f, 0.17799154f, 
    0.13238664f, 0.17587706f, -0.05094283f, -0.07431798f, 0.14404969f, -0.05282668f, -0.32705531f, -0.15207560f, 
    -0.08983195f, 0.13264461f, 0.06960346f, 0.03955179f, 0.07467746f, 0.05764787f, -0.00433792f, -0.10738977f, 
    -0.04498346f, -0.08664040f, 0.13103490f, 0.09030461f, 0.00785815f, 0.08347591f, 0.06045609f, 0.10382031f, 
    -0.00040017f, -0.17310739f, -0.14468360f, 0.09326496f, 0.03312301f, 0.03231829f, -0.02962775f, 0.00869742f, 
    0.09143990f, 0.15184349f, 0.02229249f, 0.11055502f, 0.00204233f, -0.12258092f, 0.06524318f, -0.13489954f, 
    0.18718547f, -0.26564577f, -0.03792094f, -0.10798094f, 0.20297141f, -0.10207261f, -0.08909080f, 0.10299431f, 
    -0.16170402f, -0.03215411f, 0.02847412f, 0.08061888f, -0.16397132f, -0.11892059f, -0.00945607f, -0.45311093f, 
    0.07776409f, 0.11788632f, 0.10737634f, 0.15548669f, 0.17633811f, 0.11084655f, 0.07621916f, 0.02264965f, 
    0.12827325f, 0.03305671f, -0.02811184f, 0.01367848f, 0.23875600f, 0.35753426f, -0.37881097f, 0.18495566f, 
    0.14868839f, -0.15237585f, 0.15342572f, -0.19894005f, 0.00003803f, -0.16914436f, 0.02470767f, -0.17818457f, 
    0.06903481f, 0.08259142f, 0.15970901f, 0.07590245f, -0.01159494f, -0.05244657f, 0.12001348f, -0.03315218f, 
    -0.02396275f, -0.08651305f, -0.03063459f, -0.13616644f, -0.10127320f, 0.28184915f, -0.31961635f, 0.25018135f, 
    -0.08780293f, 0.30254266f, -0.15123148f, 0.05541193f, 0.06520871f, -0.01663504f, -0.07452299f, -0.14764068f, 
    -0.14499734f, -0.63514245f, -0.54484665f, 0.20796427f, 0.02927712f, 0.06217081f, -0.00243639f, -0.09329577f, 
    0.03432634f, -0.10976695f, 0.04778824f, -0.07286832f, 0.08452260f, -0.07935890f, -0.16821827f, 0.10260968f, 
    -0.08322847f, -0.09041183f, 0.08143473f, -0.15380181f, -0.01740487f, -0.19238771f, -0.09146423f, -0.08694927f, 
    -0.03154311f, 0.11335101f, -0.39441419f, -0.03174647f, 0.12482066f, -0.05950129f, -0.04089443f, -0.09311022f, 
    -0.07723647f, 0.12525715f, 0.01619065f, 0.30679962f, 0.18027864f, -0.47160047f, -0.03117733f, 0.12583463f, 
    -0.13160484f, -0.07260437f, -0.19339532f, -0.12270091f, -0.07043357f, 0.03608606f, -0.13269679f, -0.04164308f, 
    -0.05983062f, 0.07148612f, -0.23751569f, 0.07340364f, 0.05386529f, 0.02366669f, 0.06042478f, 0.20439164f, 
    -0.02211264f, 0.07152869f, 0.00602439f, -0.09904513f, -0.18444951f, 0.14134893f, 0.18602121f, -0.09885429f, 
    0.01525733f, -0.07689819f, -0.08189158f, -0.11637556f, -0.18422714f, -0.18133737f, -0.21873929f, -0.02181965f, 
    -0.11828443f, 0.09225951f, -0.15084490f, 0.13390441f, -0.03078523f, -0.01622563f, 0.01742510f, 0.04655994f, 
    0.03688880f, 0.01134961f, -0.02145489f, -0.06258658f, -0.00004162f, 0.08737163f, -0.30179021f, -0.41124013f, 
    0.00265620f, -0.14984740f, -0.00597199f, -0.07758460f, 0.07711254f, -0.07683299f, 0.03749471f, -0.10114127f, 
    -0.34064856f, -0.11947834f, -0.22136395f, 0.17186183f, 0.07682668f, -0.14105549f, 0.15061443f, 0.03798102f, 
    0.17310089f, -0.15858805f, -0.04756027f, -0.04003666f, 0.07983431f, 0.00680727f, -0.15666182f, -0.11231443f, 
    0.12332672f, 0.07976700f, 0.05918621f, 0.09167004f, 0.11749955f, -0.06333161f, 0.08645495f, 0.06425624f, 
    0.07295484f, 0.01289334f, -0.12782931f, -0.37627655f, -0.11516918f, -0.00061196f, 0.02845222f, -0.13759196f, 
    -0.11454205f, -0.39552507f, -0.06969382f, -0.10226271f, -0.04909647f, 0.06609671f, -0.00065452f, 0.02824513f, 
    0.29322511f, -0.01013310f, -0.00349325f, -0.09034456f, -0.06872885f, -0.02852092f, 0.13226290f, -0.00073292f, 
    0.23692107f, -0.04393942f, 0.10677213f, -0.13724741f, 0.05704769f, -0.03586522f, 0.13536178f, -0.11627693f, 
    0.01820949f, -0.07906912f, -0.10413892f, 0.01407587f, -0.30816332f, -0.06602922f, 0.32245868f, 0.03796496f, 
    -0.05491220f, -0.11653523f, -0.02583320f, 0.02923292f, 0.28506523f, 0.20414394f, 0.11926665f, 0.04288129f, 
    0.00358489f, -0.02643127f, -0.35621911f, 0.39285743f, 0.08255453f, -0.05226135f, 0.03082609f, 0.05440118f, 
    -0.01082098f, 0.02815852f, -0.11194587f, 0.11284845f, -0.00138506f, 0.15089461f, -0.29143053f, -0.04344362f, 
    0.15816104f, 0.05547684f, -0.18809533f, 0.22933671f, -0.10385936f, -0.02973620f, 0.21440068f, -0.03131460f, 
    -0.04492535f, -0.07502764f, -0.12535809f, 0.19966528f, 0.08681953f, 0.15570220f, 0.08836427f, 0.10687814f, 
    -0.04087700f, 0.05733906f, -0.12077608f, -0.04081078f, -0.58955777f, 0.06048072f, -0.10726394f, -0.45161220f, 
    -0.11247349f, -0.12433510f, 0.07191717f, 0.18573156f, -0.15184548f, -0.25737944f, -0.11519133f, 0.05939627f, 
    0.13677211f, -0.22543383f, 0.10058350f, -0.09099319f, 0.13093625f, -0.03420604f, 0.00436275f, -0.02388712f, 
    0.11950853f, 0.11227441f, 0.02981018f, 0.05876404f, -0.18455902f, 0.62242711f, -0.54590493f, -0.42531914f, 
    -0.36675489f, -0.21507081f, 0.10013393f, 0.09218102f, -0.01064650f, -0.04468567f, -0.26017350f, 0.12624606f, 
    0.25436857f, 0.23965187f, -0.06036878f, 0.07409895f, 0.40160298f, -0.01411759f, -0.15583135f, -0.45787641f, 
    0.02601305f, 0.07793666f, -0.06781741f, 0.09096552f, -0.69209689f, -0.36336833f, 0.02254018f, -0.23291336f, 
    0.00342358f, -0.01682200f, -0.11946978f, -0.06007346f, 0.06502064f, -0.03113351f, 0.07423457f, 0.00700260f, 
    -0.10798383f, -0.08397276f, -0.29358181f, 0.06452342f, 0.11064626f, 0.04136474f, 0.07331421f, -0.02328942f, 
    -0.10134371f, -0.06521385f, -0.23827864f, -0.37548876f, -0.28256038f, 0.10076870f, -0.11912504f, -0.20384949f, 
    0.14519565f, -0.11892119f, -0.14449097f, 0.01170242f, 0.16597955f, -0.01116180f, 0.08130034f, 0.40737888f, 
    0.38244763f, 0.26329097f, 0.05739434f, -0.01437132f, 0.15367632f, -0.09384555f, 0.21744274f, 0.07572532f, 
    0.04801285f, 0.08106592f, 0.01266940f, 0.01922623f, -0.11620655f, 0.33326697f, 0.24207112f, 0.03463412f, 
    -0.00052206f, 0.08586257f, 0.27368593f, 0.07691789f, 0.07546277f, 0.00498776f, 0.04735340f, 0.09842033f, 
    -0.73227000f, -0.13173355f, -0.12225949f, -0.13527060f, -0.05940998f, -0.10717961f, 0.14404906f, -0.01716029f, 
    0.22797921f, 0.04141144f, 0.13062976f, -0.17905459f, -0.14270595f, 0.02958719f, 0.17831106f, 0.04355053f, 
    -0.09771869f, -0.12007788f, -0.11615345f, 0.01451574f, 0.00845754f, 0.03589283f, -0.04247799f, 0.33376411f, 
    -0.09663064f, -0.14384675f, -0.16040063f, 0.14604408f, 0.07794852f, -0.00097594f, 0.01407014f, 0.02747770f, 
    0.00255263f, 0.01984456f, 0.06158860f, -0.07769044f, 0.02277479f, 0.44963640f, -0.44409072f, -0.07803763f, 
    0.11031101f, 0.02356038f, 0.29747590f, 0.24597569f, 0.06474233f, -0.02740285f, 0.08466338f, -0.07695223f, 
    0.12162381f, -0.02936633f, -0.14216740f, -0.16166753f, -0.10630637f, 0.16377151f, -0.12246571f, 0.16713339f, 
    0.03874103f, -0.07020921f, 0.13878660f, -0.00595172f, -0.00518016f, 0.16179220f, -0.19831218f, -0.17791614f, 
    0.22279175f, 0.21854183f, 0.02707450f, -0.00877225f, -0.02136283f, -0.03622704f, -0.03682543f, 0.13223200f, 
    -0.67430550f, -0.11178643f, -0.18014073f, 0.68372875f, 0.11173981f, -0.05686758f, 0.06766858f, -0.05968703f, 
    -0.04193907f, 0.13185585f, -0.01274793f, 0.04414674f, -0.21525396f, -0.09938733f, 0.03079169f, 0.06045422f, 
    0.03067379f, -0.09212051f, -0.01841638f, -0.02983821f, 0.29458079f, 0.11570504f, -0.18872990f, 0.16744073f, 
    0.11849672f, -0.23282447f, -0.53343439f, -0.49051270f, 0.00171938f, 0.05583135f, 0.04518854f, 0.12272760f, 
    0.22832081f, -0.11100710f, -0.35856426f, -0.40496296f, 0.13777287f, 0.16074502f, 0.31791180f, -0.15559371f, 
    -0.03625219f, -0.05081969f, 0.03109483f, 0.10963222f, 0.07429063f, -0.04274969f, 0.19038847f, -0.03716720f, 
    0.14413974f, 0.11108746f, -0.33854148f, -0.37177715f, 0.20021942f, -0.01864754f, -0.05738322f, -0.15811412f, 
    0.11343745f, -0.18248829f, 0.09972660f, 0.03375341f, -0.38599214f, 0.06511147f, -0.25643024f, -0.33341664f, 
    -0.10055188f, 0.17178766f, 0.05615938f, -0.07658470f, 0.19003692f, 0.11471063f, 0.17621166f, -0.03840926f, 
    0.26511851f, -0.21181372f, -0.00469854f, 0.10642260f, -0.08847801f, -0.07347070f, 0.09797091f, 0.09322734f, 
    -0.18812905f, -0.03902402f, 0.03850162f, -0.36502546f, 0.19064052f, 0.05940786f, -0.04140433f, -0.24511482f, 
    -0.03511746f, 0.08977586f, -0.14573029f, -0.00113893f, 0.02321879f, -0.07950337f, 0.16391657f, -0.17691314f, 
    0.78567791f, -0.07625418f, -0.27042848f, 0.03984471f, 0.07055677f, 0.14631544f, -0.18412946f, 0.10167269f, 
    0.18948704f, -0.26043326f, 0.11041076f, 0.04003352f, -0.11744893f, -0.11153946f, -0.07404157f, 0.06042603f, 
    0.05984705f, -0.03420584f, -0.10488030f, -0.08969783f, -0.08521472f, -0.28729689f, 0.05663853f, 0.00793910f, 
    -0.52716577f, 0.26906931f, 0.09683120f, -0.11303865f, -0.10132829f, 0.00583524f, 0.03349148f, 0.02317475f, 
    0.00885964f, 0.25253290f, -0.01066989f, 0.06826913f, -0.58988452f, -0.48725101f, -0.69298434f, -0.34582898f, 
    -0.42505783f, 0.00952112f, -0.14873929f, -0.39879012f, 0.09429266f, -0.01005737f, 0.01365485f, 0.03030024f, 
    -0.88726556f, 0.75104201f, -0.55545443f, -0.20839965f, -0.12765121f, 0.10186031f, -0.39728704f, 0.10618965f, 
    -0.08056391f, -0.15665863f, 0.26141354f, -0.06967843f, 0.14451218f, -0.15105346f, -0.14994659f, 0.28751063f, 
    0.10599144f, -0.03421722f, -0.03863648f, 0.16396926f, 0.07919436f, -0.08774596f, 0.20672561f, -0.09087285f, 
    0.24189174f, 0.01020498f, -0.18386838f, 0.23079367f, -0.08959211f, -0.03059674f, 0.03824842f, -0.00218662f, 
    -0.11406176f, 0.00901240f, 0.13407873f, -0.00226499f, 0.51057518f, -0.08127379f, -0.27259538f, -0.68148518f, 
    -0.04559644f, -0.02615777f, 0.23436630f, -0.01505055f, 0.24573795f, -0.10064467f, 0.01279736f, -0.01855545f, 
    -0.17073445f, -0.49215052f, -0.38022780f, -0.42328900f, 0.00813619f, 0.23181376f, 0.31372461f, -0.21786194f, 
    0.01023385f, 0.00943549f, 0.05670449f, 0.12103620f, -0.91931772f, -0.96880144f, 0.11547696f, 0.30104598f, 
    -0.09095312f, -0.04307205f, 0.00716720f, 0.19451472f, -0.07349824f, 0.00606422f, 0.20654470f, -0.08685055f, 
    -0.15815803f, -0.27006915f, -0.41396165f, -0.03412480f, -0.08555400f, 0.09688873f, 0.02956537f, 0.09263118f, 
    -0.01981103f, 0.00250200f, -0.14318663f, 0.00992606f, -0.69301170f, -0.43735421f, 0.16534396f, 0.52899998f, 
    0.24454153f, -0.04382963f, -0.09735578f, 0.02501926f, -0.01492241f, 0.03373041f, 0.08299500f, 0.16937040f, 
    -0.97417706f, -1.10587668f, -0.31156188f, 0.18779054f, 0.01004114f, -0.13108815f, -0.20290247f, -0.44232488f, 
    -0.02889348f, -0.06600910f, -0.04713095f, 0.09278752f, -0.50721306f, 0.26726708f, 0.41872832f, 0.07940708f, 
    -0.04725222f, -0.00605296f, -0.01876162f, 0.00765817f, -0.00422088f, 0.12297744f, 0.01055924f, 0.02541101f, 
    -0.01194187f, 0.04170116f, 0.11560974f, -0.04877704f, 0.05021400f, -0.05601098f, -0.01989478f, 0.02668795f, 
    -0.07154424f, -0.02816371f, 0.18408021f, 0.17631981f, -0.06734125f, -0.26569057f, -0.06942978f, 0.17678317f, 
    0.15580967f, -0.03515096f, -0.05160743f, -0.07180403f, 0.04018542f, 0.07693131f, 0.05950690f, -0.07602801f, 
    -1.14761567f, -1.04273832f, -0.12176558f, -0.29820147f, -0.01719955f, 0.02546719f, 0.00828171f, -0.66518438f, 
    0.01989515f, -0.02838996f, 0.02143802f, -0.04701711f, -0.52834439f, -0.83065343f, -0.41300264f, 0.16370262f, 
    -0.17317882f, -0.08364622f, -0.26070544f, -0.51219404f, -0.07443826f, -0.01892374f, -0.01136259f, -0.08331157f, 
    -0.30791920f, 0.11122434f, 0.44809335f, 0.22546244f, -0.02839644f, 0.04828828f, -0.06157620f, 0.00536975f, 
    0.02815596f, 0.01541502f, -0.03312246f, 0.21394388f, -0.02381422f, -0.28088543f, -0.04814650f, 0.26130769f, 
    0.03801305f, -0.20300592f, -0.00345333f, 0.09639534f, -0.07963136f, -0.07853323f, 0.21449974f, -0.05169091f, 
    -0.05200932f, -0.07267338f, 0.04854460f, -0.17159340f, 0.09643151f, -0.04295860f, 0.02167599f, -0.09855615f, 
    -0.08440448f, -0.05329460f, -0.20008405f, -0.11907208f, 0.06280636f, -0.52572328f, 0.24781510f, 0.08484300f, 
    -0.00367981f, 0.20939545f, 0.12801091f, 0.10114343f, 0.09978849f, -0.02779697f, 0.00022122f, 0.01790709f, 
    0.19931801f, -0.03465042f, -0.02350752f, 0.01295596f, -0.24727663f, -0.29503086f, -0.02464090f, -0.16320021f, 
    0.00897417f, 0.00082114f, -0.10178340f, -0.17499907f, -0.03720027f, -0.27915785f, -0.32882103f, -0.05696147f, 
    -0.07325716f, -0.01414147f, -0.06305756f, 0.16348401f, 0.07480673f, 0.05124700f, 0.04346881f, -0.00084883f, 
    0.12361576f, 0.13032663f, -0.04080169f, -0.32066867f, 0.03344804f, 0.16980590f, 0.00326011f, -0.01639173f, 
    -0.00605645f, -0.11424222f, -0.03770865f, -0.10160736f, 0.00905460f, -0.10191761f, -0.07832929f, -0.19179261f, 
    -0.10440101f, 0.00180485f, -0.11680140f, 0.12247031f, 0.12321425f, 0.23047872f, -0.00981715f, 0.19033819f, 
    0.44075936f, 0.19198865f, -0.11930937f, 0.08821970f, 0.03581867f, -0.00039646f, 0.16899954f, -0.01610474f, 
    0.19248286f, 0.07690156f, 0.46025512f, 0.16437642f, -0.57883197f, 0.15760179f, 0.41746324f, 0.16689683f, 
    -0.14313836f, 0.05122915f, -0.16742952f, -0.13719973f, -0.09789451f, 0.20853655f, 0.02470453f, -0.00599807f, 
    -0.03500738f, -0.17919309f, 0.16297957f, -0.29200777f, 0.11712297f, 0.06706262f, 0.02415448f, -0.05599540f, 
    -0.06819092f, 0.01416338f, -0.14876956f, 0.14913054f, 0.02398031f, 0.39791131f, 0.19197983f, 0.08414818f, 
    -0.13673705f, -0.10487615f, 0.06145585f, -0.15566462f, 0.12063204f, -0.00469890f, 0.06695223f, 0.13956037f, 
    0.25161159f, 0.10555098f, -0.01563426f, 0.21003759f, -0.06097498f, -0.05377401f, -0.05215465f, 0.23229474f, 
    0.12662371f, -0.15122598f, -0.05079935f, 0.11066976f, 0.23791379f, -0.10740364f, -0.23470220f, -0.30536029f, 
    0.06562772f, 0.03919455f, -0.00025341f, -0.04230032f, -0.02800360f, -0.02380141f, 0.10853864f, -0.19974792f, 
    0.26239085f, 0.18911824f, 0.08607943f, -0.16400765f, -0.07076079f, -0.02377377f, 0.08930819f, 0.17010935f, 
    0.20408723f, 0.04480197f, -0.12816754f, -0.04492423f, 0.03768115f, 0.13150913f, -0.06136511f, -0.12611106f, 
    0.00861744f, -0.01441654f, 0.05272590f, 0.02388354f, -0.16099763f, -0.26637310f, 0.09312327f, 0.02090701f, 
    0.07407911f, -0.91352957f, -0.59032053f, -0.57575142f, -0.05844222f, -0.23206739f, -0.04663910f, 0.19539826f, 
    0.16960292f, 0.22417319f, -0.01295622f, -0.00483363f, -0.57041311f, -0.41775024f, -0.43355620f, -0.04167885f, 
    0.33432674f, 0.16964605f, 0.07240658f, 0.02580715f, -0.04038681f, 0.01585279f, -0.03375596f, -0.01895900f, 
    -0.37434566f, -0.58509660f, 0.07905471f, -0.00077744f, 0.08279973f, -0.12587228f, 0.28400335f, -0.15856789f, 
    -0.07801501f, 0.05390758f, 0.08234195f, -0.04223215f, 0.28552479f, -0.26534313f, 0.03365150f, -0.33493006f, 
    0.02745182f, 0.00074036f, 0.06970942f, -0.01971517f, -0.02583049f, -0.09388208f, -0.11631988f, -0.32194665f, 
    -0.15444236f, 0.22917140f, 0.04104793f, 0.01683668f, 0.10067960f, 0.14864063f, 0.02956125f, -0.07734641f, 
    0.02794118f, 0.14277487f, 0.02070297f, 0.05218545f, -0.41108674f, 0.34164184f, -0.18912829f, 0.07571071f, 
    -0.08320922f, -0.24328396f, -0.04211240f, 0.07711612f, -0.15213336f, 0.06988565f, 0.08210099f, 0.05814607f, 
    -0.46737012f, 0.35623261f, -0.61102349f, -0.09288856f, -0.24040502f, -0.09989230f, 0.08776145f, -0.05272554f, 
    0.02727761f, -0.00019418f, 0.00703707f, 0.01070800f, -0.04379103f, -0.84189808f, -0.57449400f, -0.53884071f, 
    -0.10741598f, 0.14088297f, 0.04096100f, 0.21138367f, 0.17355740f, -0.05991446f, -0.09436742f, -0.02786890f, 
    0.13536921f, -0.13210583f, 0.13955754f, -0.07074356f, 0.10583795f, -0.18868251f, -0.14303473f, -0.01044238f, 
    -0.00169908f, 0.04524122f, -0.08285943f, 0.02767508f, 0.23140153f, -0.07705089f, 0.37447459f, -0.16344833f, 
    0.07288402f, -0.11558101f, 0.18208659f, 0.10092655f, 0.06301855f, 0.00643987f, -0.03314212f, -0.15083450f, 
    -0.78592533f, 0.77185100f, -0.15801366f, 0.28779358f, 0.00038466f, -0.18308717f, 0.00600947f, 0.17590587f, 
    -0.05664865f, -0.08082759f, -0.08710063f, -0.00515073f, 0.29167768f, -0.15891370f, -0.12575698f, -0.28352246f, 
    -0.06138039f, -0.04402733f, 0.03611508f, 0.00301347f, 0.05796198f, -0.01231034f, -0.11158454f, 0.02819682f, 
    0.02281311f, 0.20448723f, 0.12897719f, 0.09950907f, -0.03629360f, -0.01451053f, 0.04403768f, -0.04016466f, 
    0.12817203f, 0.05299736f, -0.06785485f, -0.34128329f, 0.01708804f, 0.19145522f, 0.02427276f, -0.03182918f, 
    -0.15878797f, 0.15302210f, -0.00706703f, 0.02170560f, 0.03186255f, 0.02961065f, -0.07880881f, -0.13819532f, 
    -0.70318860f, 0.19575368f, -0.04496314f, 0.75107002f, 0.20376310f, -0.09692182f, -0.05776067f, 0.01852356f, 
    0.01904593f, -0.11176681f, -0.14107108f, -0.07902276f, -0.26524267f, -0.47670972f, -0.45764732f, 0.24424842f, 
    0.02822224f, -0.07713936f, -0.26668891f, 0.26331404f, -0.01012213f, -0.10070041f, -0.06777038f, -0.07242402f, 
    0.68400711f, -0.56272185f, -0.70214003f, -0.68816191f, -0.11529435f, 0.07930805f, -0.15754993f, -0.06134712f, 
    0.12323891f, -0.06946485f, 0.08446725f, -0.00456548f, 0.46271285f, -0.03317480f, -0.08092554f, -0.06495101f, 
    0.00708931f, 0.05933691f, 0.09804338f, 0.05889656f, -0.05305059f, 0.11695070f, 0.05670302f, -0.01865868f, 
    0.02932272f, 0.13391915f, -0.05398012f, -0.00330726f, 0.01064258f, -0.10857613f, 0.07466933f, 0.00168197f, 
    -0.00631287f, 0.08463890f, -0.01029643f, -0.00937769f, -0.13928619f, 0.29862970f, 0.11727085f, 0.04307551f, 
    -0.04921802f, -0.27603167f, 0.03492067f, -0.13335481f, -0.09391592f, -0.22281572f, 0.18587306f, 0.14735344f, 
    -0.06266353f, -0.09185974f, 0.06926855f, 0.10141921f, 0.04549544f, -0.16303065f, 0.03725838f, -0.00011759f, 
    0.04120085f, -0.02542227f, 0.13400266f, 0.10334521f, -0.52217662f, 0.13082239f, 0.10467925f, 0.00183065f, 
    -0.20473893f, -0.01731195f, 0.13870637f, -0.07313326f, 0.18363354f, -0.13260368f, 0.05570574f, -0.00753612f, 
    -0.12482592f, 0.14372648f, -0.26030588f, 0.02900476f, -0.03823881f, 0.01621645f, -0.04393291f, -0.02885180f, 
    0.05931176f, 0.07477727f, -0.00134985f, -0.15059480f, 0.30841649f, 0.02265018f, -0.11390406f, -0.07621975f, 
    -0.04244078f, -0.00915831f, 0.08028518f, -0.13255773f, -0.12655276f, 0.06526328f, 0.05994130f, -0.15029448f, 
    0.04109965f, 0.04480846f, 0.30304456f, 0.44868737f, -0.01641532f, 0.08742348f, 0.01882384f, 0.10746135f, 
    -0.00106375f, 0.04713919f, 0.13897604f, 0.03409873f, 0.58184600f, -0.18343602f, 0.03804489f, -0.37166888f, 
    -0.01843379f, 0.14363916f, -0.06860761f, -0.00238631f, -0.11388604f, 0.07040036f, 0.03373281f, -0.02979889f, 
    0.10180602f, 0.20349659f, -0.07540552f, -0.13062660f, -0.03705667f, 0.11499624f, -0.05441333f, 0.13079958f, 
    -0.10765093f, -0.00564556f, 0.04280289f, 0.00812453f, -0.42007810f, 0.37405926f, -0.62836415f, 0.06572429f, 
    -0.11945818f, -0.15475550f, 0.22712998f, 0.09659420f, -0.29620931f, -0.20793436f, 0.01089616f, 0.06560194f, 
    0.16462384f, -0.27979034f, -0.06270212f, -0.11987761f, -0.04831799f, -0.03764169f, -0.05142802f, 0.07693971f, 
    -0.03446710f, 0.18718663f, 0.09938353f, 0.02427979f, -0.17250748f, -0.20122871f, 0.17785829f, -0.18197806f, 
    0.00844840f, -0.11285429f, -0.05607209f, -0.12626916f, 0.10399666f, -0.03052851f, 0.03350073f, -0.04517727f, 
    -0.11553992f, 0.11350604f, 0.07842690f, 0.06806716f, 0.01069697f, 0.09450743f, 0.07274819f, -0.13983071f, 
    -0.09146489f, -0.09907702f, 0.12350638f, 0.04670158f, 0.05995497f, -0.00522904f, 0.01949625f, -0.10746839f, 
    0.02122366f, 0.03291448f, -0.00645820f, -0.06581602f, 0.04129995f, -0.08193187f, -0.02812878f, -0.43402424f, 
    -0.13926041f, -0.48479646f, -0.01705136f, -0.03949128f, 0.15967281f, 0.02931697f, 0.14948064f, 0.11207082f, 
    -0.14901017f, -0.29041383f, -0.08691286f, -0.36747509f, -0.23823352f, -0.32353702f, -0.22863677f, -0.17523007f, 
    -0.04255719f, 0.13604201f, 0.01074130f, 0.09600798f, -0.07461354f, -0.17473160f, -0.07710349f, 0.00589779f, 
    0.54256868f, -0.80338490f, -0.73805702f, -0.24042717f, 0.12079418f, 0.20962600f, -0.06215270f, -0.05028813f, 
    0.25520298f, 0.13833517f, -0.09662001f, 0.16193938f, 0.03375278f, -0.26423889f, 0.01111144f, -0.34804583f, 
    0.04014028f, 0.12902980f, 0.05509430f, -0.00668540f, 0.01445287f, 0.09912253f, 0.18788752f, 0.02764953f, 
    -0.05736656f, 0.39782950f, 0.10956188f, 0.08529582f, -0.07408962f, -0.21554092f, -0.14440462f, -0.03283444f, 
    0.01480426f, -0.03092509f, 0.07390775f, -0.06555904f, -0.68379891f, -0.17073648f, 0.18691376f, 0.31180388f, 
    -0.18343125f, 0.14575508f, -0.20865677f, -0.02121484f, 0.05651224f, -0.17018332f, -0.05739433f, 0.02459859f, 
    -0.21489999f, -0.02304247f, 0.24243134f, 0.08512809f, 0.38178778f, -0.10888664f, -0.28352481f, -0.22816029f, 
    -0.12524442f, -0.12103881f, -0.04054591f, -0.10621323f, -0.17604385f, -0.44739312f, -0.60091847f, 0.05046796f, 
    0.00336918f, 0.13297109f, 0.12350236f, 0.10847633f, -0.05170699f, -0.05811506f, -0.17675982f, -0.27965051f, 
    0.42379141f, 0.06907954f, 0.04714341f, -0.04730652f, 0.16750030f, -0.10008761f, -0.15334553f, -0.07012485f, 
    0.16652660f, 0.24301217f, 0.17067184f, 0.18606520f, 0.26629856f, 0.16640928f, -0.05125588f, -0.00094088f, 
    -0.20559840f, -0.16947745f, -0.11052325f, -0.13562860f, -0.08116234f, -0.02153146f, 0.18267062f, 0.35064051f, 
    0.27828732f, -0.24604876f, -0.11466325f, 0.19968128f, -0.17122273f, -0.00508821f, -0.05402479f, -0.02674207f, 
    0.19001649f, 0.03437428f, 0.04644256f, 0.14407998f, -0.24004231f, -0.31140763f, -0.19205298f, -0.02880990f, 
    -0.10979038f, 0.11612736f, 0.08999316f, -0.04170986f, 0.15174215f, 0.18101968f, 0.00367723f, -0.03021675f, 
    -0.52128577f, -0.10921673f, -0.04982639f, -0.00933278f, -0.00614615f, -0.08868032f, -0.17279279f, -0.04176364f, 
    -0.17949510f, -0.19682916f, -0.27733472f, -0.25172976f, -0.02585549f, 0.11241447f, -0.18355098f, -0.18888208f, 
    -0.04317854f, 0.04527873f, -0.09784383f, -0.00003208f, 0.07294015f, 0.28338170f, -0.00710583f, -0.07021531f, 
    -0.00062792f, -0.47319734f, -0.20898704f, -0.58036262f, -0.08436985f, -0.16768214f, -0.28778800f, -0.00662165f, 
    0.08792815f, 0.19454274f, 0.00976364f, 0.18042883f, 0.37567604f, -0.13896689f, -0.49442431f, -0.04317946f, 
    -0.15234385f, -0.00788235f, 0.05141329f, -0.26551005f, 0.11934625f, 0.05629865f, 0.09891526f, 0.03387893f, 
    -0.40749028f, -0.43885058f, -0.30612758f, 0.32563731f, 0.00296380f, 0.17355621f, 0.11318809f, 0.12221374f, 
    0.05226273f, 0.26943293f, 0.01841591f, -0.05720692f, 0.16269015f, -0.17054150f, -0.29773819f, -0.13137268f, 
    0.10023163f, 0.03727751f, 0.00930618f, -0.10455156f, 0.22339682f, 0.08533120f, 0.28921038f, 0.19542651f, 
    -0.27894551f, 0.02147128f, 0.08793411f, 0.02168396f, -0.06116664f, -0.05264148f, 0.01752915f, -0.05092427f, 
    -0.11648817f, -0.01257672f, -0.02226897f, 0.02759384f, -0.71221793f, -0.03598952f, 0.07691627f, 0.25551862f, 
    -0.09560369f, 0.14356463f, 0.11931389f, -0.03725121f, -0.05175325f, 0.07196904f, -0.29149312f, 0.13773367f, 
    -0.08022363f, -0.15341765f, -0.14279215f, 0.02874210f, 0.06234097f, 0.01202363f, 0.01273700f, 0.02047255f, 
    0.08198150f, 0.06168316f, 0.12933926f, 0.15085061f, -0.73791093f, -0.17177849f, 0.40137026f, 0.04908241f, 
    0.03745943f, -0.07681316f, 0.09985866f, -0.12931253f, 0.03189220f, 0.15046205f, 0.03241198f, 0.11178356f, 
    0.08856732f, 0.25683400f, -0.02037308f, -0.06215545f, 0.07125788f, -0.00048298f, -0.08915353f, 0.06533206f, 
    -0.12385160f, 0.00696597f, 0.04128035f, 0.06694119f, 0.04648353f, -0.01649154f, 0.03089567f, -0.14962025f, 
    -0.02137752f, 0.17737132f, -0.01799327f, 0.11088890f, 0.11012224f, 0.22065377f, -0.03575645f, 0.26601952f, 
    -1.12489045f, -0.18685448f, 0.19932806f, 0.52227432f, -0.00669791f, 0.01661696f, -0.18715885f, 0.15514825f, 
    0.06517396f, -0.08493727f, -0.08887338f, -0.12114857f, 0.06195821f, -0.09878524f, -0.49747843f, -0.21509497f, 
    -0.18949157f, -0.00647366f, 0.10399029f, -0.06816357f, 0.08225948f, -0.06320709f, 0.05757963f, -0.00298148f, 
    -0.42983651f, 0.35774106f, 0.28401330f, 0.39801031f, -0.04162881f, -0.20447767f, -0.16508606f, 0.17800210f, 
    0.04477452f, 0.04920719f, -0.01729694f, 0.04432158f, -0.25980130f, -0.57663274f, 0.33919004f, 0.33197165f, 
    -0.19065310f, 0.26845136f, 0.24344458f, 0.10213616f, 0.13344809f, 0.04589123f, 0.16453925f, 0.01972176f, 
    0.07125678f, -0.16788992f, -0.15873474f, 0.03977336f, 0.11791924f, 0.05243390f, 0.08379314f, 0.01388432f, 
    -0.22709888f, -0.32149711f, -0.16951551f, -0.10054038f, -0.17908765f, 0.36721936f, 0.21999684f, 0.00280888f, 
    0.00912495f, -0.00608974f, -0.00407741f, -0.02126281f, -0.18622978f, 0.11264565f, -0.20679848f, 0.02427207f, 
    -0.77849227f, 0.09014665f, 0.07204114f, 0.16969177f, -0.00673478f, -0.05273205f, -0.18205050f, -0.13358077f, 
    0.10559198f, 0.08245786f, 0.02963252f, 0.04683262f, -0.33663753f, 0.07443761f, 0.11203449f, -0.36758402f, 
    -0.09080964f, -0.09123537f, 0.04301821f, -0.08460874f, -0.15904918f, 0.07112040f, -0.03203183f, 0.14236994f, 
    0.40544760f, -0.23151977f, 0.34847921f, 0.11705333f, 0.03016795f, 0.01206091f, -0.03425773f, -0.05830146f, 
    -0.09247687f, -0.03026561f, 0.07116063f, 0.08324267f, -0.00440235f, 0.11403705f, 0.11873279f, -0.27926105f, 
    0.04297053f, -0.14682731f, 0.29974028f, 0.27517891f, -0.02332528f, 0.02292044f, 0.08011381f, 0.02431945f, 
    -0.07169038f, -0.38880593f, 0.47384164f, -0.20233893f, 0.23259331f, -0.25200248f, -0.01567007f, 0.10983105f, 
    0.04076831f, -0.02059977f, -0.04040087f, 0.02888444f, 0.11095046f, 0.12151267f, 0.26598114f, -0.05298446f, 
    -0.08566259f, -0.08649164f, -0.09635847f, -0.17465913f, -0.19273552f, 0.04369854f, 0.14395511f, -0.22879566f, 
    -0.80874276f, -0.10666001f, -0.61589193f, 0.11729112f, 0.08263909f, -0.07722297f, 0.15399887f, -0.09815187f, 
    -0.08887610f, -0.00305053f, -0.07201907f, 0.05267278f, -0.10014293f, 0.25318500f, 0.01903044f, -0.25966662f, 
    -0.07079162f, -0.00615368f, 0.14062563f, 0.16284311f, -0.18528640f, -0.00385823f, -0.08664433f, -0.09279316f, 
    0.36061829f, 0.11408824f, -0.76986766f, 0.20404741f, 0.06693441f, 0.07292725f, 0.20734449f, 0.20078330f, 
    0.04541417f, 0.02669168f, 0.00536207f, -0.03372817f, -0.32042128f, -0.24876653f, 0.16542657f, -0.47605240f, 
    -0.17328471f, 0.01040357f, 0.04179158f, -0.20964040f, 0.20049898f, 0.05476990f, 0.16191128f, 0.10269798f, 
    0.02570272f, -0.50891095f, -0.13545699f, 0.12554002f, 0.22864711f, -0.00241222f, 0.30481464f, 0.07178700f, 
    -0.05363989f, -0.13177806f, -0.15977521f, -0.15420263f, 0.07216454f, -0.53272456f, 0.42784184f, -0.26979315f, 
    0.09502277f, 0.07443863f, -0.12991142f, 0.19027998f, -0.00656225f, 0.03745953f, -0.02014524f, 0.05833527f, 
    -0.40859264f, 0.13278592f, 0.12280275f, -0.49905530f, -0.16005503f, -0.11313336f, 0.06986325f, 0.22703795f, 
    0.04178872f, -0.03394526f, 0.09288277f, -0.06959958f, 0.54997486f, 0.31111419f, 0.36859563f, 0.13399638f, 
    -0.03832227f, -0.09651552f, -0.22402246f, -0.15933223f, -0.22797616f, 0.12890998f, -0.02245759f, 0.22296911f, 
    0.06517033f, -0.06441629f, 0.03560771f, 0.05920459f, 0.04442094f, 0.17628652f, 0.08637102f, 0.13857919f, 
    0.17774740f, 0.16491239f, 0.20344785f, 0.17104250f, -0.60961688f, 0.13827512f, 0.14980954f, 0.01168470f, 
    0.00880637f, 0.13855070f, -0.17214440f, -0.07734931f, -0.06533489f, 0.03696387f, -0.14952531f, -0.52698606f, 
    0.01686118f, 0.24398750f, -0.38682285f, 0.08659067f, -0.12465099f, 0.27274308f, 0.03299403f, 0.02001676f, 
    0.07487081f, 0.11515681f, 0.06914609f, -0.08628863f, -0.82250321f, -0.38284791f, 0.25893506f, -0.29361802f, 
    -0.18289670f, -0.15802991f, -0.13896157f, 0.16642119f, 0.02643870f, 0.02544905f, 0.06413051f, -0.03086840f, 
    -0.40549940f, 0.19879158f, 0.24879648f, -0.08794902f, -0.00661254f, -0.18134376f, -0.23841956f, -0.12395062f, 
    -0.00914567f, -0.02350827f, -0.06136274f, 0.17663817f, -0.08924591f, 0.11261698f, 0.08787344f, 0.23923062f, 
    -0.04012119f, 0.06898941f, -0.04386916f, -0.13275604f, 0.07940900f, -0.11271673f, -0.22700410f, -0.37344357f, 
    -0.20635659f, -0.27923384f, -0.17509273f, -0.01785228f, 0.24603459f, 0.15688719f, 0.03889040f, 0.10995290f, 
    0.13056348f, -0.03132274f, -0.10309562f, -0.02817281f, -0.20910564f, 0.27365822f, -0.37993798f, -0.56727087f, 
    0.11588701f, -0.09780148f, -0.02829872f, 0.04746563f, 0.11843386f, 0.22363864f, -0.08054106f, -0.01393566f, 
    0.13061258f, 0.24540755f, 0.31716305f, -0.13249575f, 0.21153733f, -0.28366750f, -0.04122188f, -0.06495643f, 
    0.20385382f, 0.09402765f, -0.04041071f, 0.04637569f, -0.15145195f, -0.19246186f, -0.17104326f, -0.50074083f, 
    0.30312517f, -0.31933603f, 0.13721588f, -0.23432031f, 0.01852156f, -0.08335111f, -0.10151412f, 0.00917919f, 
    -0.19897437f, 0.23672062f, -0.74325800f, 0.47313270f, 0.05390218f, 0.03563729f, 0.09104302f, -0.04399549f, 
    0.16789903f, -0.06008970f, -0.03101239f, -0.03612960f, -0.05700760f, -0.08549515f, -0.06769174f, 0.27272892f, 
    0.05278662f, 0.12081114f, -0.14875004f, -0.11576285f, 0.06058251f, -0.34051025f, -0.09691718f, -0.06725422f, 
    0.09483792f, -0.30449998f, 0.18699932f, -0.63276547f, 0.04006655f, 0.03080976f, -0.09659048f, 0.08895528f, 
    -0.14514829f, -0.03003775f, 0.25483054f, 0.03955109f, -0.10251208f, -0.25318986f, 0.24477291f, 0.29477897f, 
    0.26688057f, -0.26997748f, -0.34888420f, -0.05433837f, 0.09430846f, -0.14641900f, 0.00109498f, 0.07781140f, 
    -0.28360683f, -0.32170531f, -0.32738441f, 0.06256499f, 0.00265980f, 0.06384867f, 0.18058637f, 0.21381593f, 
    0.07862689f, -0.01454812f, 0.04721789f, -0.07882217f, 0.08281203f, 0.19196613f, 0.39733866f, -0.80641210f, 
    0.13231668f, -0.13144004f, -0.13604839f, 0.23168644f, -0.15482725f, -0.09549800f, 0.07433417f, 0.05388078f, 
    0.01790545f, 0.54580861f, -0.05890638f, -0.50874305f, -0.17313522f, -0.13651638f, -0.03446443f, -0.12228740f, 
    0.07731398f, 0.08409906f, 0.16022792f, 0.17599912f, -0.01433317f, -0.20529717f, -0.25199366f, 0.05848769f, 
    0.11130019f, 0.14109489f, 0.23618057f, -0.04423323f, 0.09773739f, -0.04694946f, 0.02503763f, -0.01533550f, 
    -0.25746319f, -0.23260321f, -0.58042783f, -0.09254819f, 0.11021987f, -0.17401299f, 0.08573762f, -0.10759315f, 
    -0.11377328f, 0.02597691f, 0.01176034f, -0.13285495f, -0.04541728f, -0.02900101f, 0.20742954f, 0.06729041f, 
    -0.00081560f, -0.03991496f, 0.06190777f, -0.09220953f, 0.18255217f, 0.06123227f, 0.03707908f, -0.11168041f, 
    -0.19901481f, 0.12599477f, -0.68947685f, 0.18498446f, 0.04804857f, -0.10501943f, -0.03233064f, 0.11043992f, 
    0.12075634f, -0.03483653f, -0.33216777f, -0.44871405f, -0.29827186f, 0.17191108f, -0.17342602f, 0.26377749f, 
    0.03007878f, -0.11022485f, -0.22691225f, -0.06672688f, -0.15459041f, 0.13533239f, -0.11896768f, -0.06032168f, 
    -0.43064588f, 0.51083112f, -0.26950797f, 0.36154053f, -0.05586504f, 0.10904662f, -0.09605775f, 0.13408636f, 
    -0.00935900f, 0.00745775f, -0.08970046f, 0.11624189f, -0.24205604f, 0.37543985f, 0.10879861f, -0.17016521f, 
    -0.05683945f, 0.02399800f, -0.07420439f, -0.00797020f, 0.09520813f, 0.05874363f, 0.23508300f, -0.03267995f, 
    0.23642847f, 0.03554176f, -0.05914901f, -0.08446255f, -0.29366702f, 0.02223509f, 0.16567026f, 0.00726723f, 
    0.06082760f, -0.04513396f, -0.17996769f, -0.02883221f, -0.14083514f, -0.47700903f, 0.19229034f, -0.17518874f, 
    0.13953380f, -0.12268024f, -0.06984316f, 0.06493760f, -0.24227618f, 0.07383475f, 0.02155127f, -0.04404769f, 
    0.02279729f, -0.03084098f, -0.07651486f, -0.05899081f, -0.27014506f, -0.30605000f, -0.02606525f, 0.06422793f, 
    -0.04123617f, 0.11397300f, -0.11358424f, -0.14539924f, 0.11832904f, -0.14576247f, -0.11822005f, 0.16469957f, 
    0.09089932f, -0.11958454f, 0.09895001f, 0.07399317f, -0.14956017f, 0.17474380f, -0.06242761f, -0.46662304f, 
    -0.50658643f, 0.01760183f, -0.36738583f, 0.21123362f, -0.10543015f, 0.24614386f, -0.00423804f, 0.08303122f, 
    -0.00876664f, 0.20266061f, 0.19541277f, 0.24150908f, -0.19742666f, -0.01892814f, -0.08344932f, 0.13842474f, 
    -0.23331250f, -0.03406656f, 0.04149285f, -0.15331176f, 0.04473745f, -0.09702053f, 0.05417447f, 0.23115037f, 
    -0.25268644f, -0.34612304f, 0.16915356f, 0.17933567f, -0.16352853f, -0.02754008f, 0.04612048f, 0.03682561f, 
    0.07264304f, 0.08972169f, 0.05906351f, 0.01535408f, -0.16453892f, 0.25669947f, 0.05016194f, -0.08456534f, 
    0.16373588f, -0.05579857f, -0.08594952f, -0.11183225f, -0.09311828f, 0.02004762f, 0.14044195f, -0.06166822f, 
    -0.10270747f, 0.01492247f, 0.04876300f, -0.07944576f, -0.00234171f, -0.15524155f, -0.17996256f, -0.00978581f, 
    -0.22278835f, -0.26120496f, -0.12067622f, -0.41282701f, 0.14125893f, -0.22884583f, 0.29920506f, -0.36389381f, 
    -0.25107035f, 0.24175180f, 0.07308406f, 0.11696404f, 0.18689816f, 0.14930677f, 0.02514300f, 0.25026774f, 
    -0.09887916f, -0.15667947f, -0.42569932f, 0.17987408f, -0.01670541f, 0.03838605f, -0.13922516f, -0.03430429f, 
    0.05937635f, 0.07269641f, -0.09768741f, 0.13375323f, -0.16027790f, -0.64627421f, -0.41879740f, 0.02460356f, 
    -0.12535140f, 0.05243189f, -0.37988928f, 0.23411770f, -0.11485408f, 0.07421248f, 0.12534517f, 0.10271518f, 
    0.75039452f, -0.14203803f, 0.21780305f, -0.27337763f, -0.04566963f, -0.16182899f, 0.11786477f, 0.02460239f, 
    -0.17950791f, 0.02232944f, -0.07748156f, -0.01845164f, -0.04905699f, 0.14456780f, 0.42677191f, -0.15597494f, 
    -0.32278180f, 0.01915141f, 0.07876676f, 0.18322068f, 0.12557231f, -0.09856518f, 0.34132028f, 0.12573870f, 
    -0.25082004f, -0.49883434f, -0.43300831f, -0.41587973f, -0.20257516f, -0.21500798f, -0.16379601f, 0.01294489f, 
    0.16350923f, -0.03823514f, 0.08933345f, -0.07971987f, 0.15658379f, -0.46697333f, 0.57034588f, 0.28963074f, 
    0.11206092f, -0.19676860f, 0.23286609f, 0.02958465f, -0.10280455f, -0.23676181f, -0.08597897f, 0.02863648f, 
    -0.06786691f, -0.07005069f, 0.24719493f, -0.07353894f, -0.11021686f, 0.10490941f, -0.03744032f, -0.10225014f, 
    -0.12901917f, 0.02761561f, 0.25515720f, 0.19012024f, 0.32870004f, 0.36641940f, -0.22604631f, 0.06324182f, 
    -0.22437568f, 0.30919713f, 0.31228116f, 0.00398821f, -0.04066105f, 0.10275753f, 0.11277177f, 0.29172689f, 
    -0.05971000f, -0.24836437f, 0.24008198f, -0.22620577f, -0.11519841f, -0.10697674f, 0.18786056f, 0.01787450f, 
    -0.10036258f, 0.02086012f, 0.09657948f, -0.04764755f, 0.02182560f, 0.21757747f, 0.15447514f, -0.21668206f, 
    -0.05896024f, -0.12078817f, 0.01844271f, -0.07254311f, -0.19652742f, 0.21442720f, -0.07573678f, 0.14789808f, 
    -0.21579471f, 0.25166640f, -0.07249292f, 0.20831484f, 0.17044382f, -0.11357086f, -0.15371057f, 0.09764231f, 
    -0.27090788f, -0.27390271f, -0.33637416f, -0.40899625f, -0.59044963f, 0.36324048f, 0.25987285f, 0.14837269f, 
    -0.10291614f, -0.04971991f, -0.15019321f, 0.06708883f, -0.04478519f, -0.01397896f, 0.14633903f, 0.01569520f, 
    0.19815807f, -0.09841991f, 0.31267092f, -0.13519245f, -0.06104274f, 0.03903117f, -0.02803870f, -0.10741486f, 
    0.07188834f, -0.25251982f, 0.03694365f, -0.05400831f, 0.37761337f, -0.25577340f, 0.33050627f, 0.35635859f, 
    0.00200404f, 0.16215152f, -0.02850403f, -0.00594390f, 0.04542505f, 0.04367232f, -0.25603992f, -0.13723348f, 
    -0.23331445f, 0.26541775f, -0.04456340f, -0.24284279f, 0.02879574f, 0.18838593f, 0.52565211f, -0.01174055f, 
    -0.02420927f, 0.09049276f, -0.04708699f, 0.04913858f, -0.13620029f, 0.12439295f, 0.15543471f, -0.00245713f, 
    -0.14036623f, -0.38939857f, -0.10040171f, 0.05032707f, -0.24261251f, -0.00978424f, 0.12491496f, 0.10268059f, 
    -0.14782840f, -0.05833845f, -0.29004326f, 0.47115487f, -0.01672615f, 0.12380755f, 0.20304768f, -0.39171547f, 
    0.08082808f, 0.15670100f, -0.02913242f, 0.13606580f, -0.25625873f, -0.30524549f, -0.38857558f, -0.50988638f, 
    -0.18257004f, -0.13380042f, -0.00555986f, -0.05258041f, 0.03319421f, -0.00545532f, 0.04475710f, -0.21589735f, 
    -0.24143061f, -0.36286375f, -0.02074001f, 0.09611838f, -0.04011387f, -0.13177420f, -0.09097774f, 0.05177987f, 
    -0.09370787f, 0.10191346f, 0.14529437f, 0.22110492f, -0.01191541f, -0.33204746f, -0.28431469f, -0.44482312f, 
    -0.23007575f, -0.38537526f, -0.15414403f, -0.19862354f, 0.02214018f, 0.01210116f, -0.22676526f, -0.11217138f, 
    -0.53203136f, -0.32661581f, -0.16266580f, 0.16176058f, -0.30371308f, -0.11107611f, -0.01053630f, 0.15773785f, 
    0.01400405f, 0.11431883f, 0.05616766f, -0.03651987f, -0.07938839f, 0.22458065f, -0.31183335f, 0.45568421f, 
    0.21025550f, -0.11638967f, 0.09217672f, 0.02521149f, -0.06599529f, -0.04662442f, -0.19266365f, 0.33062062f, 
    0.31026101f, -0.59357494f, 0.42970389f, -0.20913734f, 0.14247841f, -0.16986871f, -0.10206819f, -0.16343814f, 
    -0.11299793f, -0.01231218f, -0.01087553f, -0.00785130f, -0.10661528f, -0.18288378f, 0.23436768f, 0.53799576f, 
    -0.05102048f, 0.14055343f, -0.20598511f, 0.19273840f, -0.18174580f, 0.07981807f, -0.13935795f, 0.04599909f, 
    0.59398681f, -0.19196847f, 0.67338753f, -0.23209360f, 0.07989177f, -0.00336386f, -0.00428116f, 0.09036466f, 
    0.09063581f, 0.08612879f, 0.03734444f, 0.11823490f, -0.23654471f, 0.61600727f, -0.39333019f, -0.53075778f, 
    -0.00301908f, 0.10536825f, 0.23890300f, 0.00360426f, 0.10685416f, 0.14149356f, 0.19282177f, 0.04986038f, 
    0.36748788f, 0.23107520f, 0.01360854f, 0.00016177f, 0.04425563f, -0.03812537f, -0.17459600f, 0.29085234f, 
    -0.18075484f, -0.00657742f, -0.09035119f, -0.31860754f, -0.80527955f, 0.31903303f, -0.43872741f, 0.23071261f, 
    0.07268167f, 0.26680773f, 0.03361489f, -0.11141732f, -0.10762013f, -0.04387452f, 0.17855696f, 0.03954187f, 
    -0.06182056f, -0.37602851f, 0.35746443f, 0.11343104f, -0.15384872f, -0.08301335f, 0.04259849f, -0.09000377f, 
    0.02279281f, 0.08895151f, -0.00083040f, 0.04833402f, -0.59325665f, 0.01302338f, -0.06409085f, 0.28087351f, 
    0.02666180f, -0.01527641f, -0.11403514f, 0.05475236f, -0.11565929f, -0.14461175f, -0.15753822f, -0.06216125f, 
    -0.03350724f, 0.09137527f, -0.06996046f, -0.19145605f, -0.10454853f, -0.06032592f, 0.03701711f, 0.02756788f, 
    0.04046945f, 0.30945483f, 0.14032684f, 0.15229598f, 0.00373890f, 0.07748227f, 0.04624658f, -0.04214007f, 
    -0.12793788f, 0.08263815f, 0.06704438f, -0.00935234f, -0.01246326f, -0.13780019f, 0.13791674f, 0.25875863f, 
    -0.55986863f, -0.13703087f, 0.04245501f, -0.29191840f, -0.32490081f, -0.22100869f, -0.03892102f, -0.63155544f, 
    0.12669857f, 0.07002075f, -0.01543482f, -0.07150681f, 0.25946641f, -0.41706648f, 0.31244150f, -0.10612136f, 
    -0.04007406f, 0.11428668f, -0.03986804f, -0.15997724f, 0.07326641f, -0.02448346f, -0.06391311f, -0.09933104f, 
    -0.12752755f, -0.45664456f, -0.13956180f, -0.44193506f, -0.02891745f, -0.14826645f, 0.08146932f, -0.16339670f, 
    -0.10987612f, -0.00233360f, -0.04572591f, -0.14667025f, -0.36478528f, -0.12936276f, 0.07999206f, -0.43554747f, 
    0.29648480f, -0.07623908f, -0.10587966f, 0.16388059f, -0.16567910f, -0.08974697f, -0.16837423f, -0.27016088f, 
    0.27271631f, 0.29486594f, -0.00518576f, -0.41724333f, -0.10425436f, 0.06615645f, -0.17781998f, 0.27731392f, 
    -0.23727509f, 0.09895772f, 0.09580263f, -0.02197248f, 0.05422442f, 0.21551937f, -0.01799427f, 0.31010619f, 
    -0.13231191f, 0.13430803f, -0.23040897f, 0.09555891f, -0.06470727f, 0.02979730f, 0.02839411f, -0.11709526f, 
    0.03166351f, 0.02152888f, -0.05284223f, 0.15228099f, -0.16309196f, 0.07227539f, 0.19157627f, 0.14397731f, 
    -0.13835417f, -0.05925994f, -0.18628094f, -0.21074490f, 0.72100228f, 0.14607833f, 0.28866294f, 0.27656585f, 
    0.07649466f, 0.40378711f, -0.33122540f, 0.23013917f, -0.18739545f, 0.08468785f, 0.04119001f, -0.14308162f, 
    0.26704994f, -0.07013578f, 0.48726857f, -0.32682219f, 0.04262131f, 0.04563161f, 0.12515010f, 0.03541373f, 
    -0.14099708f, 0.03958011f, -0.00916866f, 0.02077871f, -0.23131329f, 0.12668513f, -0.50295663f, 0.34500039f, 
    0.02066322f, -0.04284668f, 0.23723844f, -0.06058579f, 0.00721592f, 0.17420085f, 0.02845612f, -0.03537400f, 
    -0.65484017f, 0.20796515f, -0.16678289f, -0.01026993f, 0.08132537f, -0.00649615f, 0.10629529f, 0.07116226f, 
    -0.19667329f, 0.04364819f, 0.11154377f, 0.23175573f, -0.56435204f, -0.14973985f, -0.05964813f, 0.52566737f, 
    0.22887845f, 0.06740377f, -0.02595665f, -0.13868608f, 0.18480062f, 0.08272876f, 0.05365119f, -0.22011204f, 
    -0.25065455f, 0.10772175f, 0.10967987f, 0.24450220f, -0.03590990f, -0.09458192f, 0.03615748f, -0.30931556f, 
    -0.02309694f, -0.00235383f, 0.01644712f, -0.09019082f, -0.32324600f, 0.12643503f, 0.38593233f, -0.06781901f, 
    -0.18015885f, 0.16547364f, 0.13274586f, 0.10837453f, -0.08988138f, -0.02340283f, -0.06133853f, -0.00835757f, 
    -0.07369059f, -0.41288364f, 0.22704956f, 0.00184692f, 0.12723446f, -0.23329119f, 0.02795174f, -0.00758959f, 
    0.11362705f, 0.37407967f, -0.13643290f, 0.20625651f, 0.26961371f, 0.08917926f, 0.16921970f, 0.41211531f, 
    -0.09931651f, 0.12620948f, -0.11822920f, 0.16148898f, -0.21238942f, -0.04738320f, 0.08186796f, 0.03771905f, 
    0.21521308f, -0.49529409f, 0.29148459f, 0.32960677f, 0.03649307f, -0.13614935f, 0.01211230f, 0.13068841f, 
    -0.11741019f, -0.11635124f, -0.08348466f, -0.07806008f, -0.21277647f, -0.06725363f, -0.24529263f, 0.03351798f, 
    -0.05365689f, 0.21720241f, 0.00185029f, 0.06945996f, -0.04951555f, -0.03048972f, 0.05695973f, 0.00024182f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22333996f, 0.12831002f, 0.11868455f, -0.09727310f, -0.18561521f, 0.05898423f, 0.05520716f, -0.21763401f, 
    0.08672031f, 0.06701294f, -0.04664148f, 0.07150564f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
