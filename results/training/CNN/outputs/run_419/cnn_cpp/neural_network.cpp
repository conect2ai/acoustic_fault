#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.41751188f, -0.28237784f, -0.41900417f, 0.47259432f, 0.62977636f, 0.10908440f, 0.49870962f, 0.59313869f, 
    0.07735983f, 0.10465115f, 0.37635180f, -0.36411947f, -0.03042702f, -0.39876407f, 0.35967138f, 0.14704664f, 
    -0.19155468f, -0.40912545f, -0.22400732f, 0.11084447f, 0.23375285f, 0.20499748f, -0.24858060f, 0.43064427f, 
    -0.02099924f, -0.57779819f, -0.17370079f, -0.01794139f, -0.51516038f, 0.50258893f, 0.13709025f, 0.04390136f, 
    -0.69357800f, -0.62950432f, -0.71456176f, -0.00023028f, 0.39888340f, 0.14069994f, -0.05325940f, 0.00814269f, 
    0.22043939f, -0.33741084f, -0.04480899f, -0.34607282f, 0.46001306f, -0.09518008f, 0.20942725f, 0.36656350f, 
    0.41560516f, -0.08624223f, 1.12617898f, 0.78626055f, 0.44325432f, -0.57671338f, -0.56098789f, 0.02756169f, 
    0.38745165f, -0.36446077f, 0.29692134f, 0.24432807f, 0.38015804f, -0.15880664f, -0.14317316f, -0.31654620f, 
    0.22537890f, 0.00928271f, 0.02162436f, -0.14338326f, 0.06321749f, -0.07823420f, -0.40207830f, -0.02465442f, 
    0.13223128f, -0.05592301f, 0.01432132f, 0.01336051f, 0.54055041f, 0.20659626f, 0.25660753f, 0.43599954f, 
    0.75201809f, 0.26494807f, -0.95606363f, -0.14223084f, -0.26646784f, 0.09250832f, -0.00280057f, -0.21989712f, 
    0.14912091f, -0.16609944f, 0.22704430f, 0.32539088f, -0.06931232f, -0.46582979f, 0.39881906f, -0.17306861f, 
    0.10282908f, -0.31940165f, -0.13835904f, -0.21183896f, 0.67024946f, -0.75273025f, -0.19676836f, -0.21032296f, 
    0.62574518f, 1.07833040f, -0.13262567f, 0.33589050f, -0.12301582f, -0.08487530f, -0.11831229f, 0.41491234f, 
    0.05429796f, 0.22406869f, 0.21397573f, -0.27108526f, -0.05313546f, 0.29889563f, 0.07339304f, 0.09097704f, 
    -0.02442152f, -0.04309228f, 0.18824679f, 0.00170944f, 0.02659898f, 0.17231706f, 0.28803650f, 0.44740170f, 
    0.57069415f, -0.10368168f, 0.27281392f, 0.36802959f, 0.42320824f, 0.39323819f, 0.47087628f, -0.34921935f, 
    0.10236065f, -0.50582540f, 0.07494379f, -0.08719515f, -0.07163425f, -0.25395697f, -0.39975846f, -0.33747420f, 
    -0.30193162f, -0.02663749f, 0.08518182f, -0.38863686f, 0.16635804f, -0.31991309f, 0.59158319f, -0.04081112f, 
    0.38542777f, -0.73808420f, 0.81910664f, 0.41094741f, -0.21504128f, 0.27352607f, 0.41629159f, 0.33217615f, 
    0.15360817f, 0.24886014f, -0.12610264f, 0.30095032f, 0.08065955f, -0.18148270f, -0.00962853f, -0.15751289f, 
    -0.42911509f, -0.00057439f, 0.07309943f, 0.06502035f, 0.30553928f, 0.22322856f, 0.00388201f, 0.47065371f, 
    0.56484765f, 0.54696971f, 0.41195849f, 0.34014228f, -0.05736341f, 0.05737337f, 0.23581070f, 0.44510788f, 
    0.17155504f, -0.46353978f, 0.41104290f, -0.20764554f, 0.18109183f, -0.00715813f, 0.42801014f, 0.03637660f, 
    -0.05932359f, 0.29229075f, 0.32383627f, -0.24977271f, -0.27442932f, 0.27378491f, 0.03808404f, 0.11224435f, 
    -0.53062791f, 0.98834479f, -0.00611028f, -0.70269805f, -0.61091250f, 0.80078834f, -0.33571222f, -0.17763233f, 
    0.42516017f, 0.46809804f, 0.33607262f, -0.33711192f, -0.24353026f, 0.42238882f, 0.21085344f, 0.11767026f, 
    -0.03352113f, -0.08331459f, -0.10894880f, -0.09501621f, -0.37008935f, 0.13533370f, -0.13253517f, 0.02377884f, 
    0.07298752f, 0.29296684f, -0.37277082f, -0.77761102f, -0.72894573f, -0.36648658f, 0.49420094f, -0.46080568f, 
    -0.05016802f, 0.11324929f, 0.27013722f, -0.20323297f, -0.38367265f, -0.10495879f, 0.09298883f, -0.34711507f, 
    -0.08835878f, -0.13550721f, -0.32708508f, 0.12254107f, 0.51625746f, 0.23636211f, 0.10343059f, -0.39113474f, 
    -0.06123744f, 0.16447729f, -0.18227768f, -0.42088595f, -0.38668719f, 0.61168766f, -0.02715996f, -0.82601523f, 
    -0.04604857f, 0.21755546f, -0.25140637f, -0.39128318f, -0.04114471f, 0.01534671f, -0.10884775f, 0.06766270f, 
    0.36467811f, -0.00209318f, 0.17167202f, 0.28325766f, -0.29105341f, -0.17726761f, 0.30279124f, 0.17292234f, 
    -0.19603679f, 0.19374670f, -0.14566122f, 0.66727966f, 0.33738467f, 0.44906396f, 0.57089257f, 0.50910443f, 
    -0.19434863f, 0.23302181f, -0.10148947f, -0.03641272f, 0.31902120f, 0.32609856f, 0.45928931f, -0.32596004f, 
    0.28260362f, -0.14940768f, 0.13706432f, -0.36963609f, -0.19614455f, 0.09420988f, 0.19426444f, 0.26360202f, 
    0.14180429f, 0.51673573f, -0.25043869f, -0.06349264f, 0.53098321f, 0.48561174f, 0.47896567f, -0.40432951f, 
    -0.77892071f, 0.28204331f, 0.13836221f, -0.42759192f, -0.03820873f, -0.57911235f, 0.10763195f, 0.34828225f, 
    -0.30180219f, 0.18598600f, 0.02110180f, 0.21904597f, 0.14555980f, -0.19056600f, 0.08756223f, 0.00381875f, 
    0.29277650f, -0.20501108f, 0.17705047f, -0.09981971f, 0.13703275f, -1.27515578f, 0.82404828f, -0.40147358f, 
    -0.75613809f, -0.24785656f, 0.50941741f, 0.42479274f, -0.41357389f, 0.22601956f, 0.36172044f, -0.30319154f, 
    0.11353578f, -0.05414288f, 0.02457335f, -0.04072228f, 0.26401463f, 0.26785442f, 0.24659401f, 0.05272871f, 
    -0.14029343f, -0.08177948f, -0.23260085f, 0.18249451f, -0.18014136f, 0.26133302f, 0.08509815f, 0.41363329f, 
    -0.40074497f, -0.32045585f, 0.39772752f, 0.66011685f, -0.39119756f, -0.88519853f, -0.37607157f, 0.09795276f, 
    -0.06366114f, -0.28311658f, 0.21564034f, 0.23102185f, -0.07290199f, -0.29183006f, -0.20816115f, -0.10123527f, 
    -0.03268268f, -0.10644241f, 0.40831912f, 0.17604549f, 0.21541217f, -0.43344435f, -0.27164689f, -1.20685267f, 
    0.30809993f, -0.56237346f, 0.58390313f, -0.09091690f, 0.11134832f, 0.43087098f, -0.33499154f, 0.47848451f, 
    -0.11885118f, -0.07684724f, -0.36892369f, -0.03170312f, -0.20271756f, 0.15990119f, -0.26206112f, -0.20831229f, 
    0.01139568f, -0.10340127f, -0.25339562f, 0.35992566f, -0.05575847f, 0.17766924f, -0.09531599f, -0.15257548f, 
    0.14681362f, -1.26207328f, -0.18188706f, 0.45564380f, 0.28083697f, -0.73860735f, 0.72324777f, 0.45348364f, 
    -0.16676842f, -0.21762368f, 0.36435026f, 0.19650798f, -0.14501622f, -0.25511819f, -0.27432075f, -0.36634904f, 
    -0.18338211f, -0.17267925f, 0.09998187f, 0.05358557f, 0.01982106f, 0.15587163f, 0.18179606f, -0.07882582f, 
    0.09185659f, -0.43032002f, 0.36395761f, 0.96162969f, 0.52446294f, 0.31998515f, -0.90743220f, 0.22626562f, 
    -0.55618328f, -0.49370605f, -0.15613970f, 0.27088216f, 0.13577740f, 0.22047709f, 0.26058060f, -0.01087546f, 
    0.21820259f, -0.10091818f, 0.25615287f, -0.12017784f, 0.15570305f, 0.12000120f, 0.10763594f, -0.06807334f, 
    0.09296448f, 0.00743528f, -0.27259278f, 0.12037864f, -0.58706927f, -0.61541188f, -0.24951403f, -0.34899577f, 
    -0.38443771f, -0.04253181f, -0.30163717f, -0.23808590f, 0.18744776f, 0.30662796f, 0.34512123f, 0.41947463f, 
    -0.45039684f, -0.25566611f, 0.39889088f, -0.00120647f, -0.27454922f, -0.40983206f, -0.19404161f, -0.27284080f, 
    0.26018384f, 0.11647676f, 0.30187154f, -0.71587425f, -0.25903711f, -0.50443405f, -0.24988699f, -0.26968277f, 
    0.71503466f, 0.04772522f, -0.24753159f, 0.10127266f, -0.41603404f, -0.38743645f, 0.41285053f, 0.30722865f, 
    0.27567548f, 0.09507404f, -0.13119629f, -0.07958753f, -0.34048080f, -0.11111864f, -0.17315786f, -0.10854524f, 
    -0.12386617f, 0.14760453f, -0.11998735f, -0.19782655f, -1.03566575f, 1.00020576f, 0.61162376f, -0.72234511f, 
    0.53367776f, -0.26581234f, 0.65456188f, 0.46051544f, -0.11960512f, -0.07494518f, -0.19112645f, 0.13772906f, 
    0.23711739f, -0.31240764f, -0.02911525f, -0.16515605f, -0.40494210f, -0.24868883f, -0.24485958f, -0.10508738f, 
    0.07893968f, 0.17350896f, 0.02752111f, 0.21075793f, -0.00937594f, -1.04236722f, 0.09491654f, 0.42650092f, 
    -0.65302289f, -0.73014838f, 0.22128622f, 0.33624417f, -0.18817924f, -0.03985277f, -0.15434809f, -0.03473267f, 
    0.32181633f, -0.13231362f, 0.18909469f, 0.26628593f, -0.12931737f, 0.15744010f, -0.05339630f, -0.15070078f, 
    -0.07755665f, -0.07618637f, -0.01744883f, 0.07514871f, -0.13268918f, -0.12216607f, 0.34145826f, -0.62602681f, 
    -0.55193931f, -0.35193419f, -0.81089264f, 0.05627680f, 0.87773210f, 0.69511867f, 0.57136059f, 0.11463152f, 
    -0.21430105f, -0.29292595f, -0.31024244f, -0.30454707f, -0.39199215f, 0.01977121f, 0.17189388f, -0.12252676f, 
    -0.04115928f, -0.30874455f, 0.21682605f, 0.25478753f, -0.24654746f, -0.12252815f, 0.04007848f, -0.60261083f, 
    -0.87537408f, -0.75135446f, -0.35472190f, 0.09254119f, 0.31723902f, 0.58245009f, 0.20854796f, 0.35827225f, 
    0.33844537f, 0.19459040f, -0.20696886f, 0.07718994f, -0.34493306f, 0.28736541f, -0.04388386f, -0.00488246f, 
    0.07785581f, -0.06926197f, 0.01740991f, -0.45064881f, -0.36756691f, -0.38531703f, -0.12448306f, -0.08636350f, 
    0.52483040f, -0.56110388f, 0.52121252f, -0.84561455f, -0.72203457f, 0.03305355f, -0.53863865f, -0.01104949f, 
    -0.35896584f, -0.05887116f, 0.06344413f, 0.31678692f, 0.11052935f, 0.14531361f, -0.26975042f, -0.35990793f, 
    0.22452214f, 0.18369426f, -0.06158011f, -0.05510393f, 0.07216715f, 0.39967859f, -0.10422749f, 0.08720347f, 
    0.07910500f, -0.70494479f, -0.73311466f, -0.11930273f, -0.11954451f, 0.00566492f, -0.28584647f, 0.78003192f, 
    -0.32632023f, 0.10432146f, 0.31217274f, 0.06435086f, 0.35468102f, -0.00056035f, 0.38124183f, -0.26639068f, 
    -0.39303729f, -0.35496187f, -0.13686468f, -0.25457674f, -0.16620675f, -0.07794893f, 0.30646390f, -0.36333278f, 
    -0.08576867f, -0.00635076f, 0.48360586f, -0.50330740f, -0.38968602f, -0.45267060f, -0.28307232f, 0.00886320f, 
    -0.25354686f, -0.11481714f, -0.07342466f, -0.03776207f, -0.17186046f, 0.37416974f, 0.17429668f, -0.16150157f, 
    0.28260285f, 0.14506908f, -0.24067138f, 0.35478297f, 0.22309569f, -0.23790027f, 0.45971096f, -0.32621509f, 
    0.09160650f, -0.08827260f, -0.13557929f, -0.88926268f, 0.13553910f, 0.56582677f, -0.34050140f, 0.61670500f, 
    -0.20127259f, 0.03108461f, 0.37945220f, -0.27917197f, 0.42669064f, -0.24748001f, 0.01295001f, 0.02921222f, 
    -0.32241586f, -0.43528357f, 0.10297212f, 0.03469793f, 0.06788740f, 0.07586832f, -0.16179505f, 0.21107343f, 
    -0.40427983f, -0.04086268f, -0.24672157f, 0.15118209f, 0.22135381f, 0.11661091f, -0.00508135f, 0.40599909f, 
    0.36608440f, -0.51640552f, -0.90781039f, -0.73070157f, -0.16874322f, -0.37324497f, -0.30664560f, 0.46840182f, 
    0.00613125f, -0.01426954f, -0.42135552f, -0.22859113f, 0.00462553f, 0.13134183f, -0.49197847f, 0.25454280f, 
    -0.09870318f, 0.20982452f, -0.09686971f, 0.01082181f, -0.17684242f, -0.24132095f, -0.61282253f, -0.82836175f, 
    -0.18875636f, 0.17809315f, -0.48727912f, 0.61577922f, 0.70878375f, 0.46953040f, -0.28156331f, -0.23421147f, 
    -0.32339063f, -0.08644448f, -0.29506630f, -0.32694015f, 0.37164155f, 0.12068330f, 0.09739370f, -0.28926402f, 
    -0.25425726f, -0.22378030f, 0.06650634f, 0.35324967f, 0.16478127f, 0.15581980f, 0.53474122f, 0.02429903f, 
    0.86511165f, 0.86975044f, -1.06698763f, 0.06242530f, -0.56571633f, -0.09796771f, 0.03703149f, 0.30911365f, 
    -0.00409239f, 0.25981170f, 0.17378001f, -0.08322220f, 0.10959861f, -0.35473967f, -0.26927570f, 0.05301603f, 
    0.00119639f, 0.06741727f, -0.20980796f, -0.11700846f, -0.16000201f, 0.07444824f, -0.03236130f, -0.14269564f, 
    -0.88437182f, -0.52718377f, -0.53970295f, -0.11855961f, 0.59214789f, -0.22325090f, 0.24387299f, 0.62098211f, 
    0.14928995f, -0.35795301f, 0.22264321f, -0.31410778f, 0.08136333f, 0.18663813f, 0.05009460f, 0.03187245f, 
    -0.00337260f, 0.13181643f, 0.33759034f, -0.00894522f, -0.20593943f, 0.02510745f, 0.17767629f, 0.09632188f, 
    -0.54062176f, -0.95242804f, -0.39765191f, 0.27640086f, -0.51893318f, 0.12738882f, 0.94068867f, -0.28298301f, 
    -0.00447655f, 0.27455449f, 0.12733629f, -0.03592394f, -0.04781826f, -0.01726247f, -0.08003190f, -0.31095299f, 
    -0.05404027f, 0.15441293f, -0.14742939f, -0.41836736f, 0.22261794f, -0.17641275f, 0.10156270f, 0.23599130f, 
    0.05085432f, 0.56991637f, -0.81234944f, -0.60542369f, -0.35651305f, 0.22310120f, 0.06838860f, -0.02700844f, 
    0.40886560f, 0.16111232f, 0.36911276f, -0.00392674f, -0.27815902f, -0.31387293f, 0.42403418f, 0.00273599f, 
    0.20358466f, 0.36422747f, 0.28798378f, 0.28242117f, 0.19943684f, 0.13452831f, -0.09603287f, -0.14161780f, 
    0.10263088f, -0.15515624f, -0.37974906f, 0.21501257f, 0.28113732f, 0.90293634f, -0.11503445f, 0.31187877f, 
    -0.12299776f, -0.72617316f, 0.16270225f, -0.26768413f, -0.10297292f, 0.09597275f, -0.23495577f, -0.17416018f, 
    -0.22687005f, -0.29239666f, 0.17616652f, 0.37122387f, 0.11260002f, -0.12143756f, -0.34009036f, -0.02110261f, 
    -0.46793228f, -0.10399457f, -0.11778645f, -0.25712383f, -0.90988678f, 0.58243001f, 1.00601387f, -0.57637250f, 
    -0.44314286f, -0.17597508f, 0.81484532f, -0.44276112f, -0.23283510f, 0.25535890f, -0.14427993f, 0.11813845f, 
    0.32244644f, 0.30264127f, 0.12121270f, 0.48014691f, 0.19858770f, -0.30061513f, -0.09776530f, 0.11860324f, 
    -0.15228377f, -0.11470774f, 0.06463508f, 0.16575041f, 1.01038074f, 0.55538511f, -0.04339099f, 0.60361737f, 
    0.95007902f, 0.71866459f, -0.00165795f, -0.34145772f, 0.63575286f, 0.35395840f, -0.53930146f, 0.04363155f, 
    -0.23371020f, 0.12129276f, -0.26200312f, 0.04756609f, -0.03960830f, 0.23900063f, 0.20757855f, -0.01646042f, 
    0.18433383f, 0.13181442f, 0.03721828f, -0.14375077f, 0.29389709f, -0.27708462f, -0.12042273f, 0.64758992f, 
    -0.67616242f, 0.56102926f, -0.55009264f, -0.34599879f, -0.74287915f, -0.14370729f, -0.16287065f, -0.20052043f, 
    0.60445356f, -0.03201278f, 0.05996487f, 0.06715769f, -0.05053491f, 0.26605290f, -0.34739262f, -0.15773641f, 
    -0.56250143f, -0.12840441f, -0.07222603f, 0.09250478f, 0.09366169f, 0.20546044f, 0.71707582f, 0.31558320f, 
    0.00147194f, 0.78742290f, 0.28545013f, 0.16258068f, 0.44416642f, 0.47509849f, 0.34780303f, -0.07897752f, 
    -0.39778131f, 0.15676335f, -0.08987840f, 0.26849413f, -0.19637932f, 0.14253540f, -0.21195188f, -0.13356651f, 
    -0.14127710f, 0.14795330f, -0.13161173f, -0.30101955f, -0.01385074f, 0.16556682f, -0.09225369f, 0.26686507f, 
    0.52040231f, -0.44332185f, 0.10370122f, -0.44511411f, -0.60153288f, -0.16868415f, -0.68887192f, -0.61506748f, 
    -0.59335476f, -0.06083418f, 0.06956306f, -0.07043239f, -0.11402826f, -0.44979554f, -0.15988709f, -0.27737820f, 
    0.14537536f, -0.40947518f, -0.04339928f, 0.26800591f, 0.33807415f, -0.10593802f, -0.03822342f, -0.13880242f, 
    0.61721963f, 0.01390822f, 0.13294877f, 0.58530140f, -0.12645163f, -0.03219956f, -0.76236206f, 0.21130209f, 
    -0.45743406f, 0.05947074f, -0.25755289f, -0.52130985f, -0.21087076f, -0.35446066f, -0.36674511f, 0.18042034f, 
    -0.31212845f, -0.25363308f, -0.03256235f, 0.07947311f, 0.41621023f, 0.12615561f, -0.03510446f, 0.24786423f, 
    0.04446350f, -0.50173503f, 0.44370970f, -0.23051304f, 0.45426899f, -0.20627908f, 0.38887486f, 0.19701463f, 
    0.02642033f, -0.32938838f, -0.63227814f, -0.37178564f, -0.48462117f, -0.04319379f, 0.29174578f, 0.58657289f, 
    0.20583402f, 0.01937488f, 0.13477477f, 0.23943187f, 0.28670889f, 0.15904342f, 0.30479500f, 0.00228851f, 
    0.00277528f, 0.42732394f, -0.00915108f, -0.55530584f, -0.55660582f, -0.29545820f, 0.25532812f, 0.80812836f, 
    0.79010242f, -0.27892756f, 0.26419145f, 0.34382194f, -0.04489946f, -0.30354935f, -0.01076647f, -0.36421415f, 
    -0.47698846f, -0.43307230f, -0.01546082f, -0.09065206f, 0.22363256f, -0.24900441f, -0.19487806f, -0.13424331f, 
    -0.33537376f, -0.36995688f, -0.01684788f, -0.49827576f, 0.27982941f, -0.05620486f, -0.62297428f, 0.42036203f, 
    0.31098530f, -0.57992446f, -0.05487667f, -0.55492866f, -0.64981508f, 0.35992587f, -0.09647426f, 0.26055545f, 
    0.24095446f, -0.32893735f, 0.28177282f, -0.06057164f, 0.44454589f, 0.39510807f, 0.41720650f, -0.12902538f, 
    -0.24882674f, -0.14353527f, -0.17905797f, 0.41093853f, 0.57644618f, 0.59448487f, 0.53038174f, 0.74250799f, 
    0.41083169f, 0.49459174f, -0.40348506f, -0.73701733f, -0.67432493f, -0.41389650f, 0.06351375f, 0.24275871f, 
    0.09786450f, 0.02034763f, 0.01190666f, 0.08726361f, -0.20747304f, 0.05990299f, -0.10109739f, 0.07662160f, 
    -0.26361144f, 0.21109460f, 0.19222781f, -0.05193674f, 0.34576660f, -0.58137041f, 0.07516896f, -0.62002879f, 
    -0.11860953f, 0.39625525f, -0.72438574f, 0.52163494f, 0.32448205f, -0.48719215f, -0.21970375f, -0.36496380f, 
    -0.30918238f, 0.13730779f, -0.37900546f, 0.36789718f, -0.12052371f, 0.25017843f, 0.14003289f, 0.46336424f, 
    0.25058353f, 0.11726230f, 0.14658082f, -0.06841721f, 0.15640597f, 0.30981088f, -0.86851728f, 0.39002874f, 
    0.87370759f, -0.42608279f, 0.12164892f, 0.37649199f, -0.32182834f, 0.20468329f, 0.22470595f, -0.37660214f, 
    -0.59502321f, -0.31012151f, -0.08762533f, 0.03143330f, -0.40861061f, -0.41164887f, 0.06473569f, -0.37719566f, 
    -0.48031825f, -0.17427064f, -0.08752543f, -0.09172808f, -0.28183633f, -0.14337343f, -0.20675610f, -0.62106764f, 
    -0.01539439f, 0.33345813f, 0.03098234f, 0.45397365f, -0.82462120f, 0.62020540f, -0.06640353f, -0.50590807f, 
    -0.62198603f, 0.34713870f, 0.23398685f, 0.17618336f, 0.20488381f, 0.12542950f, 0.05568104f, 0.35470685f, 
    0.03559341f, 0.15905289f, 0.08180315f, 0.05654786f, 0.11836771f, -0.29365921f, -0.12524368f, -0.13829333f, 
    0.75994349f, 0.70722431f, 0.59837556f, 0.79738003f, 0.25269207f, -0.27852765f, 0.21232457f, -0.60280597f, 
    0.33867928f, 0.18010630f, 0.11636461f, -0.25144386f, 0.08717476f, 0.12257906f, -0.35601240f, 0.17685261f, 
    0.19800293f, 0.17150961f, 0.15743934f, -0.21689293f, 0.35610488f, 0.11896940f, 0.11378209f, 0.28140336f, 
    0.33720621f, 1.20139515f, 0.37509775f, -0.01771321f, 0.85885823f, 0.31154096f, 0.19565810f, 0.20799229f, 
    -0.07879564f, -0.42936942f, -0.38115799f, -0.12233605f, 0.11276601f, 0.14021960f, -0.00797207f, -0.20980245f, 
    -0.07897680f, 0.01691460f, -0.01500455f, -0.18130599f, -0.06043398f, -0.38724640f, 0.11260017f, 0.01084338f, 
    -0.18455672f, -0.21629244f, 0.61239702f, 0.80614728f, 0.76592946f, 0.02592633f, 0.41956410f, -0.68257064f, 
    -0.20923750f, -0.27723500f, -0.42836407f, 0.12726396f, 0.19298269f, -0.09456860f, -0.13615440f, 0.09320243f, 
    0.44139257f, -0.36223960f, 0.14800610f, 0.24645306f, -0.00878648f, 0.37674633f, 0.24882145f, -0.23154619f, 
    -0.15753444f, 0.19651040f, 0.29486415f, 0.31736469f, -0.05146571f, 0.61504829f, 1.02337742f, 0.29058117f, 
    0.34943596f, 0.00919617f, 0.13254742f, 0.11667476f, 0.18259925f, -0.43757656f, -0.15772609f, -0.11315319f, 
    -0.06583446f, 0.08157372f, -0.14771384f, 0.35731983f, -0.18565322f, 0.29439124f, 0.23015997f, 0.22725312f, 
    -0.08225892f, -0.39014795f, -0.28769764f, -0.10761506f, -0.11086658f, -0.65616792f, 0.21418168f, 0.89112973f, 
    0.47263375f, -0.48873529f, -0.27601174f, -0.39759889f, -0.50818163f, 0.09792383f, 0.54030114f, 0.50027120f, 
    0.31049475f, -0.15752493f, 0.05514632f, -0.42964402f, 0.26056060f, 0.10621882f, 0.20198284f, 0.12378233f, 
    0.05549435f, 0.07178584f, 0.25921351f, 0.16425610f, -0.28148574f, 0.07637090f, 0.40012601f, 0.37540752f, 
    -0.72062993f, -0.54064941f, 0.87838364f, -0.56626803f, -0.03254371f, 0.02329960f, -0.35236806f, 0.58077312f, 
    0.10853074f, 0.29893345f, 0.06009805f, 0.02959205f, -0.10224222f, -0.16424596f, 0.03267128f, 0.22799292f, 
    -0.17741340f, 0.25569272f, 0.29641819f, -0.03963941f, 0.23206852f, 0.03862895f, 0.96668130f, -0.10211980f, 
    -0.79406172f, -0.57195324f, 0.29231498f, -0.52760154f, -0.13657962f, 0.32813498f, 0.09251960f, -0.35457107f, 
    -0.33986542f, -0.04093775f, 0.34636346f, 0.08677757f, 0.27276438f, -0.01050121f, -0.35202521f, -0.23093630f, 
    0.38584188f, 0.19110098f, 0.13630903f, -0.11187891f, 0.25721076f, -0.05325907f, -0.04775234f, 0.16137870f, 
    -0.50163096f, -0.91249651f, -0.42099863f, -0.59410989f, -0.61291194f, 0.24235217f, 0.25390673f, -0.37277597f, 
    0.47178617f, 0.59542668f, -0.07076544f, -0.23319960f, -0.08241673f, 0.18320897f, 0.02741219f, -0.21684073f, 
    0.00730782f, 0.12853867f, -0.14576480f, 0.11830975f, -0.06319253f, 0.41743755f, -0.01045469f, 0.31682515f, 
    -0.30568719f, 1.05076873f, 0.05588068f, -0.42349970f, -0.19296806f, 0.06495517f, 0.44616914f, -0.34940302f, 
    -0.32181615f, 0.44522795f, 0.11422669f, 0.22382329f, -0.29576674f, -0.39681756f, 0.13049723f, 0.14506508f, 
    -0.17868438f, -0.18427758f, -0.24885434f, -0.20250219f, 0.05578587f, 0.19431964f, -0.04587286f, -0.21925172f, 
    0.53337497f, -0.07962747f, 0.52707160f, 0.05125843f, 0.25321719f, -0.71622175f, 0.17796944f, -0.53150803f, 
    -0.71884435f, -0.06824361f, -0.33900261f, 0.11271282f, -0.34924048f, -0.10348287f, -0.28286302f, 0.30740017f, 
    -0.01136407f, 0.40301967f, -0.32536167f, -0.08442040f, -0.34704068f, 0.14411438f, 0.12776448f, -0.19938508f, 
    0.15595268f, -0.46887591f, 0.92708004f, 0.79723585f, 0.31201646f, -0.00867703f, 0.53203034f, -0.32568282f, 
    -0.10589025f, 0.19325130f, 0.04096567f, 0.48796311f, -0.22812438f, -0.16411570f, -0.02315417f, -0.43729165f, 
    -0.24310499f, -0.11563795f, -0.29658562f, -0.10317583f, 0.03964136f, -0.00458274f, 0.26391116f, 0.36376926f, 
    -0.12304378f, -0.11688341f, 0.24123630f, -0.76600218f, 0.61360115f, 0.07075962f, 0.33706498f, 0.31733117f, 
    -0.56991225f, 0.86552888f, 0.23119849f, -0.49849358f, -0.16599664f, 0.29999653f, -0.37009561f, 0.23337133f, 
    -0.22945346f, 0.43821278f, 0.03363584f, 0.24042453f, -0.18921046f, 0.23087025f, -0.27750978f, -0.08379184f, 
    -0.27869239f, 0.00512319f, -0.08604173f, -0.16777197f, -0.19834180f, 0.29890069f, 0.09718135f, 0.33365858f, 
    0.28536645f, -0.54169834f, 0.20882304f, 0.53596282f, 0.44906649f, 0.21502763f, -0.24522167f, -0.21141092f, 
    -0.41748416f, -0.40733838f, -0.46051332f, 0.24079084f, -0.45190290f, 0.16906877f, 0.11947051f, -0.11203860f, 
    -0.32063678f, -0.32457548f, 0.22130454f, -0.34290963f, -0.48625618f, 0.46479541f, 0.41915375f, 0.59316838f, 
    0.54131687f, 0.45526227f, -0.11321159f, 0.38909850f, 0.34581545f, -0.45022759f, 0.37495467f, 0.24858037f, 
    0.17990173f, 0.29075271f, 0.41357216f, -0.24769847f, 0.17838188f, -0.11822896f, 0.02832755f, -0.09981033f, 
    -0.56517798f, 0.00598996f, -0.38000399f, 0.03886707f, 0.03640130f, 0.03640934f, 0.65213424f, -0.50778228f, 
    0.75508469f, 0.42071036f, 0.02545766f, -0.25346631f, 0.26402447f, 0.15849939f, 0.04176683f, -0.57120144f, 
    0.03351428f, -0.24565986f, -0.41780868f, -0.13676406f, -0.53308612f, 0.15719469f, 0.40560701f, -0.21505824f, 
    -0.08408401f, 0.26060888f, -0.37535143f, 0.20662293f, 0.04758137f, 0.02905899f, -0.35301611f, -0.74431264f, 
    -0.82223845f, 0.60461706f, 0.46608979f, 0.25181183f, 0.62456232f, 0.60194570f, -0.47173810f, 0.03727382f, 
    -0.18149762f, -0.14525042f, 0.42264983f, -0.17002693f, -0.00935080f, 0.36820167f, 0.12919696f, -0.09584823f, 
    -0.16431344f, -0.24984989f, -0.05642235f, -0.16475131f, 0.26024947f, 0.24850771f, -0.15929472f, -0.22432107f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28304538f, 0.30303791f, 0.20746723f, -0.02173711f, 0.15202597f, 0.02322306f, 0.13692532f, 0.28633374f, 
    0.04193600f, 0.20327893f, 0.21080147f, 0.20662181f, 0.16164416f, 0.01699062f, 0.13508174f, 0.10570022f, 
    0.09377052f, 0.15342830f, 0.33855632f, 0.20331517f, 0.21437781f, 0.31877661f, 0.00465348f, 0.09431568f, 
    0.26595700f, 0.02440628f, 0.14644381f, 0.16526435f, 0.13953546f, -0.07636906f, 0.11166341f, 0.17669888f, 
    0.32162794f, 0.19572820f, 0.08924731f, 0.25729293f, -0.00811536f, 0.05239682f, 0.15018179f, 0.18813010f, 
    0.27564129f, 0.14420998f, -0.08058196f, 0.10657643f, 0.16736513f, 0.28280413f, 0.04235359f, 0.11281850f, 
    0.12045017f, 0.18213968f, 0.15386964f, 0.29022756f, 0.24669531f, 0.09676500f, 0.27117303f, 0.21178119f, 
    -0.08605219f, 0.10006908f, 0.25795138f, 0.00161120f, 0.17921610f, 0.20322865f, -0.02390247f, 0.18529344f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16650844f, 0.13753615f, 0.12246992f, 0.01848913f, -0.04044338f, 0.08786058f, -0.04964618f, -0.03658888f, 
    -0.04460749f, -0.07038391f, 0.01256022f, -0.01125981f, -0.34202135f, -0.19925645f, 0.07897837f, -0.18090279f, 
    0.08475950f, 0.02748752f, 0.04048851f, -0.02940169f, -0.00390680f, -0.10802755f, 0.03536865f, -0.13109505f, 
    -0.03359557f, 0.11855789f, 0.07806607f, -0.20408703f, -0.20795137f, -0.03184744f, 0.05190733f, 0.06157870f, 
    -0.04249445f, 0.04617936f, 0.00891036f, -0.02930830f, -0.15056187f, -0.00677481f, 0.02549602f, -0.02750270f, 
    -0.00411752f, -0.08043250f, 0.12875484f, 0.03501757f, 0.01716186f, 0.07319118f, -0.08374857f, 0.03804507f, 
    0.26854771f, -0.05980626f, 0.12724738f, -0.12165459f, 0.06459509f, 0.04726348f, 0.02338651f, -0.04548520f, 
    -0.10028759f, 0.05509325f, -0.00467645f, 0.02530476f, -0.00761306f, -0.05371488f, -0.13704060f, 0.21790533f, 
    -0.07107583f, 0.02688718f, -0.05370480f, -0.04645769f, -0.11352792f, -0.00377378f, 0.03485697f, -0.03403109f, 
    0.13726701f, -0.03455233f, 0.05933940f, -0.22692668f, -0.09318741f, 0.06855422f, 0.01708210f, -0.05381070f, 
    0.06719436f, 0.03740979f, 0.07727919f, 0.02913828f, 0.02600629f, -0.04716587f, -0.14471872f, 0.01119548f, 
    -0.05066518f, -0.10944594f, -0.08252027f, 0.05918075f, 0.07607657f, -0.07505462f, 0.02663203f, -0.05265102f, 
    0.27307987f, -0.08753555f, -0.14908047f, -0.24346910f, -0.14340623f, 0.05386597f, 0.09405293f, -0.12318280f, 
    0.01678182f, 0.08964660f, 0.00151545f, 0.04744409f, 0.09244931f, -0.28024036f, -0.18730226f, -0.31242862f, 
    0.12788731f, -0.10443287f, 0.16337176f, -0.04053595f, -0.06108770f, -0.01250015f, 0.04298458f, 0.05067294f, 
    -0.04636709f, 0.06557020f, -0.23578452f, 0.19368519f, -0.03128827f, 0.00238445f, -0.09326170f, -0.08256461f, 
    -0.02981910f, -0.01646824f, -0.08609023f, 0.01845027f, 0.09334781f, -0.01472147f, 0.02532122f, 0.10767958f, 
    -0.08892811f, -0.02327403f, -0.08544464f, 0.06304614f, 0.01339364f, 0.01939194f, 0.02217115f, -0.12419326f, 
    -0.27751261f, 0.22068460f, 0.02827154f, -0.13923773f, -0.05462745f, -0.04120474f, -0.01667916f, -0.02530301f, 
    0.04992304f, -0.03953707f, 0.04233347f, -0.10705154f, 0.59393793f, -0.09884755f, -0.00841098f, -0.17657967f, 
    0.08460639f, 0.03421265f, 0.04663532f, 0.01810973f, 0.05796982f, -0.10787254f, -0.05614705f, 0.06388900f, 
    -0.10179370f, -0.07536547f, 0.14812687f, -0.10601329f, -0.04081319f, -0.04247056f, -0.04920153f, -0.12997103f, 
    0.06746976f, 0.04029145f, 0.03033836f, -0.02933875f, 0.47661468f, 0.15436827f, -0.08900961f, 0.06919607f, 
    0.15173133f, 0.00357755f, 0.01585085f, -0.08804226f, -0.00022657f, -0.07625127f, 0.01022100f, -0.00030456f, 
    -0.07027312f, 0.06479238f, -0.13618802f, 0.20175721f, -0.05108338f, 0.07181078f, 0.06400958f, -0.01971444f, 
    0.03739653f, 0.08041027f, -0.15386198f, 0.02147646f, 0.01850175f, 0.00667719f, -0.12308941f, 0.14492524f, 
    -0.09601089f, 0.02577504f, 0.00926566f, -0.05088978f, 0.01552410f, -0.02043582f, 0.00787691f, -0.03857369f, 
    -0.33692676f, -0.10948323f, 0.03282976f, -0.15148558f, -0.01467650f, -0.01455988f, 0.04905833f, -0.03376124f, 
    -0.05138276f, 0.14398675f, -0.10884095f, -0.10242487f, -0.02651321f, -0.04286414f, 0.01759565f, -0.12383032f, 
    0.04365534f, -0.02041808f, -0.00151363f, -0.00343563f, 0.06786277f, -0.04490691f, -0.00408175f, -0.01393134f, 
    -0.11059772f, -0.01803697f, 0.17527120f, -0.11106623f, -0.03673426f, -0.10114558f, 0.04721836f, -0.05503088f, 
    0.01950472f, -0.07114031f, -0.06373546f, -0.01565686f, 0.12170620f, 0.06487573f, 0.18043555f, -0.01672619f, 
    -0.01547975f, 0.09443875f, -0.01919615f, -0.03787664f, -0.00312717f, -0.00723924f, 0.06709692f, -0.04194828f, 
    -0.05951840f, 0.20987445f, -0.06177321f, -0.27736035f, 0.08712100f, 0.10093416f, 0.09800312f, -0.04833060f, 
    -0.03075739f, 0.03032597f, 0.03604532f, 0.08054911f, 0.04451377f, 0.08901049f, 0.05644041f, -0.20677505f, 
    0.05819338f, 0.11965100f, 0.02822773f, 0.01398690f, -0.03801495f, 0.00550117f, -0.03933951f, 0.03570361f, 
    -0.29763138f, 0.00567094f, 0.18719456f, -0.11587721f, -0.02170274f, 0.04550114f, 0.01451507f, -0.18370543f, 
    -0.18614109f, -0.00274581f, -0.10896397f, 0.02069668f, -0.09372464f, -0.09844435f, 0.09128646f, 0.07902708f, 
    -0.07563510f, 0.02249117f, 0.06036688f, 0.07651991f, -0.03172757f, 0.06139944f, -0.11275481f, 0.03462372f, 
    -0.13480647f, -0.19461922f, 0.04533528f, -0.04376920f, 0.02274944f, -0.06003422f, 0.06839075f, -0.01564301f, 
    -0.08648564f, 0.02296714f, -0.08952889f, -0.00799410f, -0.24397768f, 0.02688197f, 0.11933263f, -0.06691752f, 
    -0.03302223f, -0.05066146f, -0.04622486f, -0.05044849f, 0.05827112f, -0.03004850f, -0.13083103f, 0.03956215f, 
    0.16079681f, -0.02660443f, 0.08006533f, 0.07560010f, 0.00841530f, -0.06042097f, -0.04624406f, 0.02081328f, 
    0.01216953f, -0.04584530f, -0.06379367f, 0.03943221f, -0.31003338f, 0.27447352f, -0.06131604f, -0.20938422f, 
    0.05378279f, 0.05794639f, 0.05671020f, -0.10287446f, -0.01410688f, 0.10107841f, 0.06439396f, -0.02241107f, 
    0.05830909f, 0.00779177f, -0.19577356f, 0.33602941f, -0.03666550f, -0.09648845f, 0.06583301f, -0.01377012f, 
    -0.07818720f, -0.00893619f, -0.08000591f, 0.06581982f, 0.17710242f, -0.01688953f, -0.04014990f, -0.29008707f, 
    0.01455912f, 0.00203514f, 0.05062137f, 0.08105448f, -0.05385557f, -0.05323239f, 0.02422475f, 0.06278642f, 
    0.09163294f, 0.06864124f, -0.01456898f, -0.11639921f, -0.00803336f, -0.00525673f, -0.01952619f, 0.01359481f, 
    0.01811293f, -0.01339552f, -0.02178919f, 0.03054213f, 0.09563578f, 0.11295434f, 0.06692451f, 0.00811434f, 
    0.06629802f, 0.04316109f, -0.06734387f, -0.11235556f, -0.05635194f, 0.01446229f, 0.03818815f, 0.00110340f, 
    -0.06853396f, 0.03403379f, -0.05770194f, 0.15657771f, -0.12594555f, 0.06089268f, 0.07469091f, -0.09748759f, 
    0.00262296f, 0.11437988f, -0.11504180f, 0.05243173f, -0.04395942f, 0.00554654f, -0.19003890f, 0.31797892f, 
    -0.00648740f, 0.08725169f, 0.04101740f, -0.08306241f, 0.00853409f, 0.06253977f, 0.00559381f, -0.03742657f, 
    0.14309828f, -0.13904612f, 0.06428110f, 0.26727366f, -0.05390153f, 0.00670925f, 0.01427316f, 0.04771895f, 
    0.03365518f, 0.11452758f, 0.00085706f, -0.04792424f, -0.36427113f, -0.10332223f, 0.09070094f, -0.10107555f, 
    0.02149428f, 0.02466302f, -0.02562250f, 0.00507123f, 0.00896425f, -0.02155482f, 0.03876920f, -0.01684246f, 
    0.06218280f, 0.05542230f, -0.20042725f, 0.08775932f, -0.03786499f, 0.08778863f, -0.06473807f, 0.02052519f, 
    -0.01574011f, -0.01204518f, 0.05528085f, -0.04020971f, -0.07943068f, 0.15127437f, 0.11381832f, 0.04933233f, 
    -0.08755662f, 0.03196934f, -0.13007133f, 0.02797872f, 0.00988270f, -0.04447104f, -0.06741177f, -0.05958587f, 
    0.05475378f, -0.11134056f, -0.04888396f, 0.11681660f, 0.07645838f, 0.00558004f, -0.14102322f, -0.03094899f, 
    -0.13786584f, -0.06669462f, 0.00796696f, 0.01665531f, 0.01159247f, 0.06573886f, 0.02056815f, -0.03760278f, 
    -0.10202082f, 0.00516991f, -0.02067412f, 0.05567408f, 0.03204485f, -0.09552325f, -0.02211537f, 0.04379481f, 
    0.06188786f, 0.09887072f, 0.14904851f, -0.01775303f, 0.07312036f, 0.08697945f, 0.05344336f, 0.01084504f, 
    -0.09443443f, 0.15694281f, -0.06502005f, 0.07300443f, -0.33231339f, -0.20203021f, 0.13020357f, -0.11408989f, 
    -0.10025661f, 0.00752340f, 0.00241941f, 0.01069364f, 0.13300017f, 0.07293148f, 0.06062553f, 0.04691928f, 
    0.15420324f, 0.07978075f, -0.00720546f, 0.01242953f, -0.15237136f, -0.08958618f, -0.04900549f, 0.11199109f, 
    -0.05751584f, 0.06946339f, -0.06496876f, 0.01917504f, -0.17081915f, 0.11603482f, 0.00202238f, 0.08608782f, 
    0.02459241f, -0.02858121f, -0.00337182f, 0.10743001f, 0.01135025f, -0.07562295f, 0.01685610f, 0.00830520f, 
    -0.32886672f, -0.00201505f, 0.03952380f, 0.18072927f, 0.00811310f, -0.03619514f, 0.04825045f, -0.01455142f, 
    0.05547061f, -0.11292488f, 0.00246442f, -0.05256207f, -0.15621819f, 0.03859935f, -0.04376224f, 0.07301252f, 
    -0.02639257f, 0.04169273f, 0.02315840f, 0.04948030f, -0.03381654f, -0.06242984f, 0.01285436f, -0.00957702f, 
    0.00446203f, 0.01646654f, -0.07334974f, 0.19351801f, -0.08131844f, -0.08087526f, 0.00331562f, 0.00535105f, 
    -0.03870170f, 0.01367108f, 0.02732911f, -0.01325923f, 0.21581766f, 0.10980617f, -0.10365468f, 0.09480347f, 
    -0.27004969f, 0.04223926f, -0.13058013f, 0.10977337f, -0.02908984f, 0.04931129f, -0.03608859f, -0.11691821f, 
    0.11933312f, 0.11563603f, 0.01931795f, -0.19207536f, -0.20877010f, -0.09614865f, 0.05367999f, 0.03064161f, 
    0.02145387f, -0.10687078f, -0.11086224f, -0.01861391f, 0.02643484f, -0.03722049f, -0.13325204f, 0.23281480f, 
    -0.01295182f, 0.03718415f, 0.06992055f, -0.00459972f, -0.02656187f, -0.12344355f, -0.02941868f, 0.02314830f, 
    0.06966139f, -0.12541324f, -0.18172783f, 0.22186612f, -0.03840370f, 0.03419841f, -0.05564512f, 0.00020427f, 
    0.00841959f, 0.00613000f, -0.03621513f, 0.05716382f, -0.22638200f, -0.02386508f, 0.03959993f, -0.05883741f, 
    -0.11902779f, 0.01653484f, 0.08572906f, -0.22755404f, -0.03997764f, -0.02595871f, 0.08465734f, 0.11637317f, 
    -0.11151195f, -0.01389999f, -0.01385911f, -0.25408021f, -0.06627195f, -0.07002623f, 0.03439960f, 0.01511952f, 
    -0.03399068f, -0.05110507f, -0.01675813f, -0.03557840f, -0.42696941f, -0.11518405f, 0.03338401f, -0.10623525f, 
    0.03431242f, -0.05532917f, 0.09048172f, -0.01745305f, -0.03048997f, -0.03406274f, -0.05118799f, -0.01502677f, 
    0.21805860f, 0.06820583f, 0.20567884f, -0.15815438f, -0.00157857f, -0.04235623f, 0.11987157f, -0.11634412f, 
    -0.02779491f, -0.04642082f, 0.01204868f, 0.04705797f, -0.14887887f, 0.08798520f, -0.09329411f, 0.00734897f, 
    0.02190305f, -0.00601876f, 0.03680687f, 0.07685790f, -0.06008000f, 0.13274722f, -0.05030325f, 0.03957228f, 
    0.15927140f, -0.00409403f, 0.08188848f, -0.04917848f, -0.09804213f, -0.02913633f, -0.00807915f, 0.07690568f, 
    -0.04372410f, 0.00907444f, -0.02168335f, -0.03480977f, -0.10318509f, 0.17412460f, 0.05218811f, -0.00384567f, 
    0.02567314f, -0.03230301f, 0.01530027f, -0.09446988f, -0.03858636f, 0.09153064f, 0.04432475f, 0.00198760f, 
    0.06473526f, 0.02248037f, 0.02600260f, 0.07750005f, -0.07797062f, 0.05760034f, 0.00813130f, -0.11701276f, 
    0.04350906f, -0.02755088f, 0.12022793f, -0.07425114f, 0.02894097f, 0.03953076f, -0.01410366f, -0.00439336f, 
    -0.13874780f, -0.01566772f, 0.03156344f, -0.05567125f, -0.06458689f, 0.10924422f, 0.09596433f, -0.06441264f, 
    0.23557892f, 0.03419000f, -0.09589075f, 0.29921463f, -0.09081692f, -0.09894545f, 0.07684936f, 0.00512131f, 
    0.01879377f, -0.03189798f, 0.01403000f, -0.20945901f, -0.41109371f, -0.04334851f, 0.17981839f, 0.15935023f, 
    -0.01071469f, 0.05465123f, 0.03182775f, -0.03071168f, -0.01926084f, 0.06008932f, 0.16682929f, 0.00604653f, 
    0.20980032f, 0.11819614f, -0.03798300f, 0.07808752f, -0.03321183f, 0.08850174f, -0.05001923f, -0.03044078f, 
    0.06932554f, 0.05895557f, -0.10876311f, 0.12819123f, 0.00473064f, 0.00291484f, -0.00833378f, -0.23881128f, 
    0.00461934f, -0.01434953f, 0.05354680f, -0.09496642f, 0.06594245f, 0.00900077f, 0.01745066f, -0.02392364f, 
    0.22941165f, 0.01734251f, -0.00954652f, -0.10202390f, 0.00298110f, -0.09616925f, -0.02910044f, -0.09035420f, 
    -0.01908251f, -0.03240313f, -0.07705311f, 0.07742233f, 0.17452998f, -0.19030318f, 0.04335806f, -0.12605287f, 
    -0.01338112f, 0.02657927f, -0.03849050f, -0.04030946f, -0.09038934f, -0.03283829f, 0.10952145f, -0.11636826f, 
    0.34821856f, -0.24496721f, 0.00994057f, -0.05553235f, -0.13421628f, -0.01883859f, -0.18707870f, 0.02946592f, 
    -0.04853242f, -0.11041111f, 0.07731046f, 0.00247506f, 0.17154203f, 0.08668471f, 0.09700946f, 0.14833537f, 
    0.03311524f, 0.05388906f, 0.00399287f, -0.07968348f, 0.01955215f, 0.02424576f, -0.06603550f, -0.04839081f, 
    0.04862776f, -0.00212693f, 0.12896572f, -0.06189987f, 0.06145426f, 0.03054261f, 0.04352626f, 0.00338045f, 
    -0.04770276f, -0.09853287f, -0.11885887f, -0.02749144f, 0.24632379f, 0.06740677f, 0.03441890f, 0.19530421f, 
    0.07002559f, -0.03011039f, 0.00281833f, -0.02567796f, -0.05194110f, -0.03168365f, -0.06914515f, 0.06513143f, 
    -0.44196460f, -0.04848063f, 0.00948986f, -0.16042832f, 0.01435451f, -0.11241713f, 0.01905636f, -0.02109695f, 
    -0.01298694f, 0.00339633f, 0.01336773f, -0.00689457f, 0.03008961f, -0.05868706f, 0.11239704f, -0.26945153f, 
    -0.19226097f, -0.00773852f, -0.09296601f, 0.07956623f, -0.10678130f, 0.09376948f, 0.03175095f, 0.02648061f, 
    -0.19895411f, 0.00557451f, -0.06340294f, 0.23003826f, 0.01421690f, 0.00990042f, -0.06301621f, 0.11391361f, 
    -0.02675696f, -0.01999025f, 0.10989600f, 0.16906630f, 0.17901978f, -0.07513819f, 0.13928844f, 0.17550191f, 
    -0.04348698f, -0.03538776f, 0.05114659f, -0.00334810f, 0.01569788f, -0.00060521f, -0.13223839f, 0.14373831f, 
    0.06394027f, -0.08840838f, -0.13362128f, -0.07076974f, -0.10826477f, -0.04878926f, 0.08127587f, 0.06342721f, 
    0.02851612f, 0.07528867f, -0.03804797f, 0.06682862f, -0.58574504f, -0.00679123f, -0.02650009f, -0.32279399f, 
    -0.09771346f, -0.03494906f, 0.04240458f, 0.03289953f, 0.17536427f, 0.07804627f, 0.03208551f, -0.06560249f, 
    -0.03709466f, -0.13407877f, 0.00342928f, -0.26005352f, -0.05238992f, -0.15916233f, 0.05598139f, -0.05473624f, 
    -0.11999643f, -0.00073201f, -0.04336261f, -0.05386430f, -0.32641450f, -0.01465437f, -0.18154131f, -0.07566522f, 
    0.17275169f, 0.00269184f, -0.07331152f, 0.12610987f, -0.05619656f, 0.03753321f, -0.04619078f, 0.01471177f, 
    0.14360675f, -0.14042734f, -0.00469332f, 0.15188146f, -0.16597664f, -0.00370227f, 0.01174408f, 0.05073128f, 
    0.03092563f, -0.09535103f, 0.06073033f, 0.00509220f, -0.21259488f, 0.01388459f, -0.01908600f, -0.13038014f, 
    -0.00673381f, 0.01683501f, 0.00680610f, -0.06372701f, -0.01486007f, 0.01474624f, 0.03233726f, -0.00578631f, 
    0.04814242f, -0.10209611f, 0.01227693f, -0.11646262f, -0.00235793f, -0.03928175f, 0.00038237f, 0.13397220f, 
    -0.00296403f, -0.11411987f, 0.08790828f, -0.06576249f, -0.06684865f, 0.04036680f, -0.00064879f, -0.03612945f, 
    -0.03556194f, -0.09624369f, 0.03337645f, -0.00712737f, -0.00751767f, -0.04011916f, -0.03150659f, -0.03133698f, 
    -0.17118385f, 0.24898568f, -0.12794128f, -0.23800445f, 0.07315726f, 0.04779583f, 0.08937934f, 0.04406017f, 
    -0.04081662f, -0.04083207f, 0.02595960f, -0.05837635f, -0.36462182f, 0.04857398f, -0.13239737f, -0.00056861f, 
    -0.06440370f, -0.02149170f, 0.07909257f, 0.04269059f, -0.02875170f, 0.08772623f, -0.09726433f, -0.05230614f, 
    0.14314722f, -0.32567504f, -0.02666420f, -0.02422186f, 0.06363709f, -0.15007152f, -0.10548715f, -0.02473848f, 
    0.18080442f, 0.04716421f, -0.08827381f, -0.06419474f, 0.25122687f, 0.07973441f, 0.06532878f, 0.01397855f, 
    0.11839020f, -0.02222891f, -0.12548435f, 0.02114354f, -0.02878596f, -0.00781332f, -0.11294109f, 0.04644991f, 
    0.10387195f, 0.05609021f, -0.09212865f, 0.01811876f, 0.04879942f, 0.07007778f, 0.01289061f, 0.15052699f, 
    0.15125047f, -0.05312111f, 0.12979794f, -0.01668479f, 0.10667586f, 0.09781062f, -0.12886716f, 0.00755757f, 
    -0.14791740f, 0.04882676f, 0.06132617f, 0.01686518f, 0.01294271f, -0.20363563f, -0.03408289f, -0.18865907f, 
    0.18685544f, -0.08821881f, 0.13563654f, -0.11609618f, -0.02450326f, 0.10625660f, 0.03539957f, 0.03639111f, 
    0.01335840f, -0.02039084f, 0.07419427f, 0.00536254f, 0.09705218f, 0.07273981f, -0.08145846f, -0.03315490f, 
    0.07235874f, 0.00408294f, 0.00989258f, 0.13497765f, -0.03936406f, 0.09471812f, -0.11654131f, -0.05719892f, 
    -0.00472643f, -0.20569398f, -0.02917465f, -0.08741083f, 0.06514660f, 0.05504876f, 0.09638431f, 0.05945209f, 
    0.02298030f, -0.03891829f, 0.10471608f, -0.13699619f, 0.07883717f, -0.10668609f, -0.00218517f, -0.10683426f, 
    -0.04996262f, 0.07695085f, -0.10751847f, 0.05386881f, 0.01264886f, -0.02587655f, -0.07146943f, 0.05874885f, 
    -0.23488180f, 0.10443325f, -0.10597531f, -0.00539806f, -0.13921356f, -0.04766842f, -0.00184606f, -0.04143161f, 
    0.08028812f, -0.06454757f, 0.01484815f, 0.02338900f, 0.12091702f, -0.10080536f, 0.11966049f, -0.15752703f, 
    0.09328657f, -0.00107433f, 0.02154991f, 0.07362205f, 0.09922879f, 0.09326845f, -0.01467352f, -0.00104506f, 
    0.10615598f, -0.12978271f, -0.26785773f, 0.10471221f, -0.01279151f, 0.02980692f, -0.02122632f, 0.09701099f, 
    0.00401566f, -0.09950418f, 0.00899800f, 0.10274873f, 0.22445552f, -0.25507393f, -0.01949362f, -0.25270340f, 
    -0.00468475f, 0.07314698f, 0.06851748f, 0.08865554f, 0.04967306f, 0.08198766f, 0.01903786f, 0.08763050f, 
    0.08311798f, -0.13143605f, -0.30070347f, 0.06746802f, 0.12977971f, 0.03216559f, -0.05167340f, 0.02846169f, 
    -0.05109943f, -0.08314703f, 0.10167114f, -0.10247707f, -0.46148944f, 0.13918807f, -0.04358725f, 0.24597229f, 
    -0.12961535f, 0.00822438f, -0.05985950f, -0.03258499f, 0.01400472f, 0.03901665f, 0.05761254f, 0.09632919f, 
    0.26060674f, -0.08671842f, 0.11705142f, 0.10316721f, -0.12073553f, -0.04791868f, -0.08379974f, 0.01064267f, 
    0.01600297f, -0.05542180f, -0.03388700f, -0.02355777f, -0.12581085f, 0.05796693f, 0.08830163f, 0.00180356f, 
    -0.02799129f, -0.05459425f, 0.04032778f, 0.12383842f, 0.17599060f, 0.01223480f, -0.14287435f, -0.07786299f, 
    0.20892283f, 0.07396393f, 0.08018205f, 0.21403962f, -0.02604340f, -0.04114095f, -0.02958956f, -0.00020655f, 
    0.01975572f, -0.00650896f, -0.03027923f, 0.07460656f, -0.01320992f, -0.28464720f, -0.17104156f, -0.31074107f, 
    -0.04233280f, 0.03293622f, -0.02407584f, 0.11690497f, -0.03311505f, -0.03844386f, 0.08511370f, 0.00791869f, 
    0.04629744f, 0.05884998f, 0.05944856f, 0.17607144f, -0.15947217f, 0.03320808f, 0.04406014f, 0.06068327f, 
    0.05409425f, 0.04778558f, -0.04753330f, 0.07296066f, -0.11851846f, 0.01722411f, -0.14037098f, 0.04357626f, 
    -0.04931358f, 0.00538624f, 0.01451161f, 0.05161269f, -0.04084063f, 0.13126791f, -0.00452867f, -0.05694124f, 
    0.13900571f, -0.21347669f, 0.03412717f, -0.05786249f, 0.14384790f, -0.08841232f, -0.23294859f, 0.01510222f, 
    -0.04256761f, -0.09345955f, -0.09328643f, -0.13882621f, 0.20242317f, 0.02568900f, -0.04647249f, -0.09010118f, 
    0.06068372f, 0.16181482f, 0.00665230f, -0.01988080f, -0.04966291f, 0.07355754f, -0.01672158f, 0.09254190f, 
    0.05552066f, -0.07683735f, 0.11206236f, 0.06596825f, 0.01993893f, 0.04295369f, 0.05250625f, -0.00226593f, 
    0.03916918f, 0.03358139f, 0.10812327f, -0.04153531f, 0.23873655f, 0.06715894f, -0.02550039f, -0.13232781f, 
    0.06681197f, 0.18346658f, -0.05668703f, -0.09269399f, 0.03744365f, 0.06806720f, 0.11278819f, -0.01582336f, 
    -0.11849807f, 0.02826470f, -0.07738960f, -0.06293663f, -0.06264480f, -0.06683705f, -0.04025931f, -0.12537025f, 
    -0.09242247f, -0.00075864f, -0.05905636f, -0.26523662f, -0.14950284f, 0.08923674f, -0.05580686f, -0.04890816f, 
    -0.02057359f, 0.04237170f, -0.09895194f, -0.06963122f, 0.05127267f, 0.05553387f, 0.03116529f, -0.03718716f, 
    0.27423736f, -0.06745289f, 0.11013446f, 0.18046652f, -0.10525618f, -0.07184209f, 0.00288550f, -0.00258127f, 
    0.05064068f, -0.02458337f, 0.01429630f, -0.08127541f, 0.16602150f, -0.15748480f, 0.17757459f, 0.09621213f, 
    0.08301669f, -0.07247925f, 0.03025156f, 0.00619712f, 0.00467345f, -0.01357688f, 0.00275215f, 0.03958662f, 
    0.04331324f, 0.01974883f, -0.08398019f, 0.11533623f, -0.02535818f, 0.01154345f, 0.01244109f, 0.02367427f, 
    0.05154818f, 0.08234112f, 0.05035454f, 0.06746022f, 0.14594811f, 0.04801723f, 0.02805932f, 0.12920798f, 
    -0.06461921f, 0.04200534f, -0.02596307f, -0.03076597f, -0.04157459f, 0.06440078f, 0.07834729f, -0.06556081f, 
    -0.16775803f, -0.14325954f, 0.00663600f, 0.05628621f, 0.09874291f, -0.07372352f, -0.05456826f, 0.04563187f, 
    0.01355995f, -0.02145612f, 0.08140919f, -0.00840841f, -0.12275502f, -0.17561246f, 0.01166516f, -0.09349024f, 
    0.00101093f, 0.02330524f, -0.04814110f, 0.01494643f, 0.09120772f, 0.06543376f, -0.00038702f, -0.04871081f, 
    0.16523884f, -0.29257533f, 0.17788133f, -0.09011533f, 0.02813421f, -0.06335057f, 0.02513212f, 0.05773906f, 
    -0.15696330f, 0.08225544f, -0.07138637f, 0.08208108f, 0.34042379f, -0.05662597f, -0.20867665f, -0.04690276f, 
    -0.15581438f, 0.08260867f, -0.03047922f, 0.09008253f, -0.04340569f, -0.08168418f, -0.07100987f, 0.09287511f, 
    -0.19390915f, 0.05544958f, -0.20653197f, -0.33301362f, -0.10323229f, -0.08528733f, 0.04976220f, 0.00780025f, 
    0.01710586f, -0.06541107f, 0.03245508f, -0.04319436f, -0.18737026f, -0.11737963f, -0.18966334f, -0.07163258f, 
    -0.02751801f, -0.12588637f, 0.03979475f, -0.05029250f, 0.05896118f, -0.17176183f, -0.12507632f, 0.01202678f, 
    0.15619662f, 0.01404185f, 0.09519029f, 0.18404450f, 0.03570200f, 0.02040850f, 0.06467018f, 0.06619270f, 
    0.01204745f, -0.03719367f, -0.09823322f, 0.00819118f, 0.22350699f, 0.00282077f, -0.11909261f, -0.12096761f, 
    0.02573673f, 0.04697404f, -0.02690225f, -0.10070449f, 0.02587630f, -0.03224000f, -0.05591799f, -0.01434221f, 
    0.03966348f, -0.05084541f, -0.03014687f, 0.02643446f, 0.12310930f, -0.01676300f, -0.00525242f, 0.08802237f, 
    0.02264267f, -0.10231326f, -0.09941676f, 0.07765635f, 0.09987284f, 0.15425374f, 0.11513299f, 0.15832253f, 
    0.00756234f, 0.03757049f, 0.00418974f, 0.03097970f, 0.08132839f, -0.08478747f, 0.03233932f, -0.00182015f, 
    0.08332600f, -0.09720256f, -0.05879182f, 0.04870176f, -0.01155652f, 0.02748559f, -0.04542154f, 0.00407663f, 
    0.07744004f, 0.03089624f, -0.13269839f, -0.03317744f, 0.18688032f, -0.05624566f, -0.15151885f, -0.05662341f, 
    -0.12009234f, 0.08284866f, 0.05322965f, -0.09858902f, -0.08122101f, -0.08541862f, -0.05534294f, 0.08303199f, 
    0.09160815f, -0.01967434f, 0.06761622f, 0.02696420f, -0.05827119f, 0.00724016f, -0.15176328f, -0.16377631f, 
    0.09479111f, 0.00685986f, 0.07726344f, -0.09055686f, 0.04756297f, -0.07786948f, -0.13313277f, -0.19796859f, 
    -0.01728991f, 0.03212029f, -0.04252636f, -0.02402675f, -0.00219763f, 0.04698959f, 0.03371178f, -0.07747494f, 
    0.02412129f, -0.02154510f, 0.01594595f, -0.20571567f, 0.02226624f, -0.02550507f, 0.01673254f, 0.07677995f, 
    -0.10088432f, 0.04195290f, 0.07123311f, -0.11871654f, 0.10356190f, -0.22511375f, 0.02099285f, 0.05601577f, 
    0.05702850f, -0.01498757f, 0.04188089f, -0.07465778f, 0.02905455f, -0.05135252f, -0.09616639f, 0.00573442f, 
    -0.33219603f, 0.09957539f, 0.14745374f, -0.06080038f, 0.02780004f, -0.00942487f, 0.00055457f, -0.01406829f, 
    -0.06648231f, -0.14592186f, -0.08404440f, 0.02175450f, 0.05252358f, 0.01418696f, -0.12226446f, -0.08133230f, 
    -0.00163813f, 0.07415277f, 0.03569782f, -0.06555555f, 0.01680840f, 0.05337256f, 0.14524268f, -0.10291971f, 
    -0.06111884f, 0.15605776f, 0.03372184f, 0.10554501f, 0.06169482f, 0.04838751f, 0.02767419f, -0.02459977f, 
    -0.06706283f, 0.06158675f, 0.03776535f, 0.02240224f, 0.07284576f, 0.00916263f, -0.12000109f, 0.04966913f, 
    0.03382200f, 0.02891183f, -0.01714076f, 0.04464556f, -0.06266785f, 0.03521243f, 0.01065355f, -0.02873763f, 
    0.12906031f, 0.17774346f, -0.03621625f, -0.03623663f, -0.00233181f, 0.00692086f, 0.08404757f, 0.01760331f, 
    -0.10187906f, 0.00209093f, -0.09085911f, -0.09168547f, -0.19939333f, 0.01103378f, 0.04223849f, 0.09165127f, 
    0.01716694f, -0.06943542f, -0.00742534f, 0.00308656f, 0.01032922f, -0.04472572f, -0.02319634f, 0.01749360f, 
    0.43097872f, -0.09407983f, -0.18619739f, -0.07412782f, 0.01088620f, 0.02407515f, 0.01623181f, 0.00510368f, 
    -0.01548327f, 0.01980090f, 0.07529373f, -0.07625014f, 0.03245592f, 0.01666724f, -0.01943202f, -0.03244384f, 
    0.05331461f, 0.06327048f, 0.01695607f, -0.01322611f, -0.05029169f, -0.06724162f, 0.11487412f, 0.03408844f, 
    -0.10124867f, -0.05360956f, -0.09342977f, -0.10013058f, 0.06248254f, 0.04521709f, 0.02975093f, -0.00149496f, 
    0.00359049f, -0.02553540f, -0.00395847f, -0.09467210f, 0.22149135f, 0.09205155f, -0.07949647f, 0.06318797f, 
    0.03420407f, -0.12373651f, -0.00092648f, 0.00880284f, -0.05338357f, 0.04088585f, -0.00539026f, 0.00008963f, 
    -0.05626525f, -0.15520312f, 0.07610317f, -0.19719875f, 0.01695174f, -0.05403223f, -0.00619408f, -0.02739348f, 
    0.01227552f, 0.02730111f, -0.06102895f, 0.00582033f, 0.07335995f, -0.05463405f, -0.19553529f, -0.14164817f, 
    -0.03353694f, -0.00083673f, -0.03625787f, -0.02709352f, 0.00690493f, 0.04121001f, -0.01242509f, 0.06648549f, 
    0.43092290f, -0.11140520f, 0.00692265f, 0.01086911f, -0.03890390f, 0.06530485f, 0.05325120f, -0.07998266f, 
    0.00604418f, 0.08579388f, 0.01025516f, -0.02224245f, 0.24391393f, 0.08689540f, -0.25122446f, 0.16687556f, 
    0.06056127f, 0.01612751f, 0.01122049f, -0.04458899f, -0.02829065f, -0.09045869f, -0.05345966f, -0.03505580f, 
    -0.23750022f, 0.07214428f, -0.03755186f, -0.16485377f, -0.01227870f, 0.03586528f, -0.06229008f, -0.00607325f, 
    -0.12361037f, 0.01831043f, 0.02030013f, -0.05736530f, 0.15776698f, 0.09008256f, 0.05740155f, -0.06753971f, 
    -0.04897542f, -0.12521118f, 0.00360574f, 0.06816954f, -0.05161646f, 0.00995115f, -0.03623024f, -0.02823365f, 
    0.35498941f, -0.01097210f, -0.24809612f, 0.02790491f, 0.02026730f, 0.07733018f, 0.01788813f, -0.04139927f, 
    0.01029945f, 0.12688434f, 0.05760703f, 0.03900396f, 0.28841764f, -0.00349815f, -0.07903936f, -0.31175014f, 
    -0.04371186f, -0.09429233f, -0.00511741f, 0.07508817f, -0.00444964f, -0.05796546f, -0.06849702f, -0.05842900f, 
    0.21434100f, 0.19099773f, 0.11406614f, 0.27925411f, -0.11623063f, -0.14317699f, 0.12398104f, 0.13535380f, 
    -0.00343827f, -0.02240455f, 0.02017026f, -0.03729853f, 0.19351406f, 0.09116558f, 0.12693265f, 0.07995901f, 
    -0.11986680f, -0.06355757f, 0.00085719f, 0.14235589f, 0.00261056f, -0.03998220f, -0.10229030f, 0.00299456f, 
    -0.56321454f, -0.05070666f, 0.05064385f, -0.25970238f, 0.02165841f, 0.03081186f, 0.00802909f, -0.01518357f, 
    -0.02391125f, -0.00473979f, -0.04423660f, 0.01518998f, 0.33547434f, -0.02976909f, 0.05761624f, -0.05305034f, 
    -0.05894180f, -0.06439277f, -0.02910787f, 0.02963440f, 0.06941611f, 0.05435827f, 0.08119413f, 0.03571798f, 
    -0.14281578f, -0.01899004f, 0.05610078f, 0.00288039f, -0.12474663f, 0.03638211f, -0.04684974f, -0.03457389f, 
    0.02010136f, 0.03971596f, -0.06925421f, -0.07009766f, 0.28132054f, -0.15714869f, -0.19289276f, 0.04169545f, 
    -0.06346871f, -0.04664135f, 0.11116271f, 0.05107544f, -0.06773560f, 0.02628924f, -0.01968559f, 0.04546915f, 
    -0.27400306f, -0.07789511f, -0.13220882f, 0.02876855f, -0.01231497f, -0.01664717f, 0.02047634f, -0.06048289f, 
    -0.03932464f, 0.12071345f, 0.05779079f, -0.04701680f, 0.13332734f, -0.01705771f, -0.10733654f, 0.17165139f, 
    -0.19654413f, 0.01388237f, -0.05792418f, 0.00571812f, 0.08796358f, 0.05433008f, -0.01057063f, 0.05749022f, 
    -0.24550094f, -0.03218200f, -0.02698638f, -0.13526128f, -0.03902625f, 0.11247282f, -0.01232102f, 0.08213596f, 
    -0.00718212f, 0.11886774f, 0.01792930f, -0.02822312f, -0.01794326f, 0.18720806f, 0.12205415f, 0.19263463f, 
    -0.05261669f, 0.00634918f, -0.04610667f, -0.00130322f, -0.03236751f, -0.02438366f, -0.03153001f, -0.06566616f, 
    0.26174113f, -0.14348702f, 0.14744611f, -0.00790478f, -0.14564602f, -0.06005792f, -0.10041800f, 0.01486687f, 
    0.03073147f, 0.06047299f, 0.09077069f, -0.01506284f, 0.01803402f, 0.02260966f, -0.00155367f, 0.16586283f, 
    -0.02766758f, -0.03717207f, 0.09995488f, 0.07130161f, -0.09783093f, -0.11045282f, -0.06710892f, 0.01453223f, 
    -0.01417054f, -0.25806969f, -0.00892220f, -0.00720694f, -0.02549555f, -0.05149080f, -0.01280727f, -0.05553804f, 
    -0.09271976f, 0.02186758f, -0.16467465f, -0.03679811f, 0.30152941f, -0.01033738f, -0.24751285f, -0.04474194f, 
    -0.13184842f, 0.10979947f, -0.09591722f, -0.02872759f, 0.05578740f, 0.00207841f, -0.02650497f, -0.07817911f, 
    0.15143460f, -0.16061498f, 0.01066965f, -0.02910600f, 0.13477968f, 0.05870381f, 0.01223009f, -0.00903498f, 
    0.02049854f, 0.02726287f, 0.01533986f, -0.03945775f, 0.18708451f, -0.14784314f, -0.14986004f, -0.21027994f, 
    0.05278773f, -0.02111456f, -0.06805269f, 0.07956740f, 0.02184149f, -0.05426230f, -0.02792021f, -0.08593602f, 
    0.05437695f, 0.00217101f, -0.09605681f, -0.00499151f, 0.00462907f, 0.06109986f, 0.02011985f, -0.00677129f, 
    -0.06686658f, 0.04210931f, 0.04457698f, -0.01435151f, -0.31307104f, 0.05229653f, -0.13050403f, -0.24284501f, 
    -0.02706643f, 0.01107796f, 0.01547381f, -0.09447398f, 0.06653444f, 0.02979901f, -0.08853825f, 0.00432680f, 
    -0.17266478f, -0.00173969f, -0.12167653f, -0.09451392f, 0.04045397f, 0.01535129f, -0.10738710f, -0.01010744f, 
    -0.01345730f, 0.03623484f, 0.00225646f, -0.02929486f, -0.11555625f, 0.05227410f, -0.08731291f, -0.11778943f, 
    -0.03565045f, -0.04709195f, 0.01335325f, 0.01321593f, 0.05141149f, -0.03729724f, -0.06122362f, 0.04237596f, 
    0.18477167f, -0.07098313f, 0.19590417f, 0.08237447f, -0.04925237f, -0.04377742f, 0.08604833f, 0.03728046f, 
    -0.10889679f, 0.02018015f, -0.05078322f, 0.09269594f, -0.15147126f, 0.02990632f, -0.09968004f, 0.02901225f, 
    -0.03785616f, -0.12300591f, 0.03479432f, -0.08366232f, -0.16855264f, -0.06227467f, -0.08109031f, -0.04740981f, 
    0.01125576f, -0.03504107f, 0.01553860f, -0.02715370f, 0.04407488f, -0.03031034f, -0.01717278f, -0.04079422f, 
    -0.02989026f, 0.07115525f, -0.11720984f, -0.02208653f, 0.17086372f, -0.03937832f, -0.15200359f, -0.00628637f, 
    0.07139801f, -0.00249714f, -0.08292626f, -0.01770876f, -0.00286091f, -0.05262928f, 0.04071971f, 0.12386171f, 
    0.09499779f, 0.00624429f, -0.34894773f, 0.09406947f, -0.01263409f, 0.05337794f, 0.09215950f, 0.03292029f, 
    0.04590963f, 0.09253900f, 0.04101445f, 0.04572532f, 0.32195133f, -0.05538248f, -0.11753336f, -0.02317511f, 
    0.05571020f, -0.01041119f, 0.02214334f, 0.01207199f, -0.02207461f, -0.09895059f, -0.06366623f, 0.00151502f, 
    0.09206846f, 0.03305931f, -0.03999583f, -0.01909808f, 0.07247276f, -0.01325602f, -0.01120819f, -0.04980337f, 
    -0.09888225f, 0.03555784f, -0.03056866f, -0.07809190f, -0.04630393f, -0.01263080f, -0.00662501f, -0.09154783f, 
    0.02544364f, -0.00014955f, -0.01940573f, 0.01504523f, -0.00250734f, 0.13797109f, 0.02830595f, -0.01823047f, 
    -0.11524775f, 0.01266014f, -0.08668798f, -0.00655157f, 0.10006510f, -0.02419622f, 0.03014740f, -0.03055886f, 
    0.02194652f, -0.00710543f, 0.01306906f, -0.03184887f, -0.18632305f, -0.01237488f, -0.02478403f, 0.05691336f, 
    -0.03003429f, 0.08537985f, 0.02617045f, -0.04102789f, 0.06419889f, -0.00892874f, -0.02899071f, -0.00170154f, 
    0.15157604f, -0.12374905f, 0.01207689f, 0.06315430f, -0.11132472f, 0.08491787f, -0.05147042f, -0.02248221f, 
    -0.09055369f, -0.03812697f, 0.05162838f, -0.00613944f, -0.27412510f, 0.04397874f, 0.02847840f, -0.08178210f, 
    -0.07387038f, 0.10030358f, -0.01738954f, 0.02663413f, -0.13800219f, 0.07240716f, -0.05431921f, -0.01101930f, 
    -0.13823804f, 0.02668034f, -0.15644386f, -0.11005747f, 0.03747474f, -0.01044760f, 0.07937540f, -0.04438141f, 
    0.04014926f, 0.01394735f, -0.00067810f, -0.02113135f, 0.21163446f, -0.07389184f, 0.25263077f, 0.14241162f, 
    -0.07847881f, -0.00408886f, -0.01608083f, -0.05799192f, 0.00082649f, -0.08652331f, 0.02533998f, -0.00239864f, 
    0.12668952f, -0.14640516f, 0.04011120f, -0.19173671f, 0.02994297f, 0.01883629f, -0.01829233f, 0.05029305f, 
    -0.02241958f, -0.01384555f, 0.05196796f, -0.05179349f, -0.20470393f, -0.20796274f, -0.05881713f, -0.16939291f, 
    -0.02891847f, 0.03963463f, -0.01718811f, -0.01953599f, -0.05169742f, -0.04380723f, -0.02747142f, 0.00377507f, 
    -0.04285157f, 0.13026732f, 0.03891498f, -0.05220545f, 0.14843103f, -0.08265022f, 0.03120337f, -0.03483268f, 
    -0.00770624f, 0.00851746f, 0.02522667f, 0.08749653f, 0.12563442f, 0.08420901f, -0.12812176f, 0.00768880f, 
    0.05071112f, 0.01643074f, -0.00475274f, -0.03843996f, -0.07943636f, 0.03452796f, 0.07131138f, -0.07752351f, 
    0.03493746f, -0.00614419f, -0.05650182f, 0.01102227f, -0.04353513f, 0.12069988f, 0.02811403f, 0.03741027f, 
    -0.05842775f, -0.03710289f, -0.03134285f, -0.04007067f, 0.06638377f, 0.05100000f, -0.05255464f, 0.00200354f, 
    0.06453051f, 0.12313469f, 0.07141807f, -0.01947179f, -0.17352585f, 0.07924639f, -0.07614118f, -0.05818264f, 
    -0.24348050f, 0.03799464f, -0.07423681f, -0.07822398f, 0.04018564f, -0.05500900f, 0.04932858f, 0.08645408f, 
    -0.04752886f, 0.00369217f, -0.03633183f, -0.08109447f, 0.30864450f, -0.29041734f, 0.06476713f, -0.04519740f, 
    -0.18088272f, -0.05155888f, -0.04196802f, -0.10344648f, 0.04068495f, 0.00714135f, -0.00371954f, -0.00456719f, 
    -0.10616055f, 0.06186649f, 0.04319541f, 0.01524313f, -0.15221795f, -0.09577583f, 0.01588641f, -0.07907660f, 
    -0.05214208f, 0.08218583f, 0.08625715f, -0.09939566f, 0.07788879f, 0.08912870f, 0.10804620f, 0.09025214f, 
    -0.03514531f, -0.02742977f, -0.06501919f, 0.03120767f, 0.02710091f, 0.00307667f, -0.02631651f, -0.09269241f, 
    -0.29996476f, -0.07207776f, -0.15342426f, 0.03270286f, -0.08810443f, 0.05705608f, 0.01522924f, 0.12795816f, 
    -0.03288290f, 0.02849842f, 0.06126214f, 0.02851667f, 0.51192743f, -0.11782875f, 0.08936483f, 0.24501301f, 
    -0.01765588f, -0.02817385f, 0.06197480f, 0.03704529f, -0.17713968f, 0.03312821f, -0.02414326f, -0.07252578f, 
    -0.12789470f, 0.24644771f, -0.23830009f, 0.13271029f, -0.01806070f, 0.13227887f, 0.02169528f, -0.06949142f, 
    0.02334616f, -0.09351397f, 0.03804453f, 0.02193216f, -0.42178863f, -0.18156509f, -0.19894971f, -0.10359374f, 
    -0.05752918f, 0.00516809f, 0.09662526f, -0.03057009f, 0.00291869f, 0.02466297f, 0.10915556f, 0.02495603f, 
    -0.23485090f, -0.06466879f, -0.22079645f, -0.10569678f, 0.06571336f, 0.00815545f, -0.08112648f, -0.09679814f, 
    -0.03869972f, 0.05471527f, 0.01222743f, -0.01387042f, -0.28581452f, -0.29987681f, -0.17207405f, -0.02113874f, 
    -0.09298236f, -0.06896056f, 0.03686592f, 0.04770336f, -0.05312956f, -0.04904056f, 0.00081591f, 0.04253893f, 
    0.10496809f, 0.26222733f, 0.09783857f, -0.20677248f, 0.04693031f, -0.01076346f, -0.11431904f, 0.18583618f, 
    0.01349905f, -0.00785547f, -0.02142178f, -0.01703010f, -0.01718587f, 0.02509334f, -0.13302982f, -0.02052137f, 
    -0.02043024f, 0.04233832f, 0.08432657f, -0.03498486f, -0.04783580f, -0.01615398f, 0.04558556f, -0.03574801f, 
    0.10542239f, -0.00007315f, 0.10897785f, 0.04980202f, -0.02937380f, -0.09568315f, 0.05376305f, -0.07033450f, 
    -0.00954817f, -0.03746891f, -0.03233565f, 0.05268992f, -0.47916973f, -0.23518197f, -0.05681947f, -0.04521678f, 
    -0.02728035f, 0.00442010f, -0.05602538f, -0.05484080f, -0.06379180f, -0.04599196f, 0.02461901f, -0.04832256f, 
    0.03741492f, 0.07387452f, 0.01940728f, -0.05252539f, -0.07312774f, -0.06667682f, -0.04516221f, 0.02571163f, 
    0.04072684f, 0.09722732f, -0.00862583f, -0.09671997f, 0.20455246f, 0.23362157f, -0.01040505f, -0.14536592f, 
    -0.10806687f, -0.02649137f, -0.04280378f, 0.09098157f, -0.00783620f, -0.16050842f, -0.08088513f, 0.05164178f, 
    0.40152338f, 0.14130569f, 0.09388350f, 0.16003856f, -0.08856872f, 0.00043240f, -0.03535715f, -0.07675457f, 
    0.03999175f, 0.02459960f, 0.05543353f, 0.04720906f, 0.02549837f, 0.28364629f, -0.04161687f, -0.08199882f, 
    -0.09629817f, -0.04664964f, 0.05241639f, 0.10884806f, 0.06045219f, -0.03628275f, 0.05011041f, -0.02679737f, 
    0.00362916f, 0.14505439f, 0.14917253f, 0.02809528f, -0.05688492f, 0.02904886f, -0.03258150f, 0.08490887f, 
    -0.07852441f, 0.11355334f, -0.04365387f, 0.05484311f, -0.56444985f, 0.13683075f, 0.14493763f, 0.13187516f, 
    0.11492186f, 0.05286217f, 0.07667592f, -0.05038373f, -0.02139466f, -0.03791520f, -0.11121008f, -0.05195384f, 
    0.05851509f, 0.00188083f, 0.05832041f, 0.04762942f, -0.07796913f, -0.07798711f, 0.07442610f, 0.02750322f, 
    0.03538126f, 0.15036583f, -0.01065476f, -0.00399328f, 0.13308945f, 0.03213044f, -0.06182279f, 0.01980796f, 
    -0.05815826f, 0.05010536f, -0.06947788f, 0.02336195f, -0.04921264f, -0.07041471f, 0.02826599f, 0.02472370f, 
    -0.17635451f, 0.21621528f, 0.13090430f, -0.15213752f, 0.09540796f, -0.00570023f, 0.02903266f, 0.07859078f, 
    0.03884144f, 0.06341220f, -0.03340723f, 0.03216052f, 0.01973304f, 0.12520614f, 0.12491973f, -0.07916190f, 
    -0.06953544f, 0.02408465f, -0.06913754f, -0.00184302f, 0.05500127f, -0.06462808f, -0.03776062f, 0.04965320f, 
    -0.03146613f, -0.19506556f, -0.06245428f, -0.05793481f, -0.09016639f, 0.03175018f, 0.01536913f, -0.02991106f, 
    -0.15272951f, 0.04576733f, -0.07891238f, -0.03438719f, -0.03998053f, -0.01567908f, -0.15913402f, -0.00709669f, 
    -0.08910099f, -0.10013901f, 0.04220623f, -0.00789070f, 0.01917884f, -0.04181954f, 0.01273432f, 0.07379140f, 
    0.02345150f, 0.06463365f, 0.01199324f, -0.05536289f, 0.01066279f, -0.01016692f, 0.03752185f, 0.06367390f, 
    -0.02349109f, 0.07666692f, -0.15203467f, 0.03115886f, -0.06917548f, 0.24022283f, -0.09339420f, 0.01253440f, 
    -0.03053493f, -0.00000042f, 0.03665359f, -0.06121921f, -0.06779328f, -0.04827692f, 0.08270717f, 0.09524847f, 
    0.06985851f, -0.05482418f, -0.03132267f, 0.04104041f, -0.03595060f, -0.00496694f, -0.07249328f, 0.00607476f, 
    0.07148899f, 0.08778444f, 0.05397093f, 0.04501187f, -0.11265163f, 0.08825150f, 0.10097663f, 0.02830682f, 
    0.00039653f, -0.10122839f, 0.01516161f, 0.01650893f, 0.07741082f, 0.04684076f, 0.01570254f, -0.06383520f, 
    0.18220536f, 0.05774556f, 0.00169866f, 0.19824342f, 0.05523883f, 0.09533557f, -0.07213833f, 0.00943863f, 
    0.00699809f, 0.08475678f, -0.11942437f, -0.06096100f, 0.09836712f, -0.04083386f, 0.02443380f, 0.13541889f, 
    -0.13297863f, -0.11522926f, 0.02391815f, -0.03216196f, -0.18211834f, 0.09972971f, -0.04406213f, -0.05640069f, 
    0.10781887f, -0.33710039f, -0.13462101f, 0.05857953f, 0.02360990f, 0.02333085f, 0.13949054f, 0.03150655f, 
    -0.03478092f, 0.00695249f, -0.09181630f, 0.00654355f, -0.01183921f, -0.07186506f, -0.09976485f, -0.13642053f, 
    -0.03661524f, -0.04527471f, -0.04856376f, -0.04880169f, -0.09075966f, -0.02428934f, 0.05690684f, -0.05361052f, 
    0.10996724f, 0.02777993f, -0.02268619f, 0.01370021f, -0.10621791f, -0.06041367f, 0.04618922f, -0.02937098f, 
    -0.01136268f, 0.07568107f, -0.03850270f, -0.00267699f, -0.02428937f, -0.07145809f, -0.05295867f, -0.15451947f, 
    -0.14661297f, 0.10350663f, -0.06164080f, -0.09500900f, -0.05753075f, -0.03411079f, -0.03324706f, 0.07093159f, 
    0.14714250f, -0.05556113f, -0.06707285f, 0.28626540f, 0.08401717f, 0.01476036f, 0.13303775f, 0.06090283f, 
    0.04389902f, 0.06457472f, -0.02283892f, 0.03085698f, 0.12150614f, -0.09562401f, 0.21835245f, -0.09482315f, 
    0.00827723f, -0.00938401f, 0.06583536f, 0.03822736f, -0.10459854f, -0.02978641f, 0.02524354f, -0.10512204f, 
    -0.07057965f, -0.16786739f, -0.37300265f, -0.02494542f, -0.04676471f, -0.07697992f, -0.02284512f, -0.09637217f, 
    0.01078844f, -0.11432762f, -0.01917665f, 0.05787621f, 0.09831978f, 0.23304437f, 0.02046516f, 0.17113054f, 
    -0.00884566f, 0.02302670f, 0.11183506f, -0.09784768f, -0.01037699f, 0.06761460f, -0.10202149f, 0.03653563f, 
    -0.03084202f, -0.23390234f, 0.01457897f, -0.14889546f, -0.08313102f, -0.16720007f, 0.01035078f, 0.02921259f, 
    0.00845389f, 0.04609948f, 0.12661730f, 0.03098552f, 0.13639332f, 0.04868151f, 0.00487176f, -0.00669005f, 
    0.00503365f, 0.07764447f, -0.08387168f, -0.01320112f, -0.01019790f, 0.12070724f, -0.07363881f, 0.02992957f, 
    0.28603071f, -0.32512596f, -0.04114045f, 0.14038053f, 0.01641851f, 0.03937044f, -0.03165955f, -0.02751861f, 
    0.07887932f, 0.02148810f, 0.05851912f, 0.03161621f, -0.00760443f, 0.12150478f, -0.08685479f, 0.03026498f, 
    0.06102895f, -0.01866307f, 0.04605776f, 0.12709436f, -0.02849963f, -0.07024468f, 0.03683008f, 0.05269532f, 
    -0.18673459f, 0.05760716f, -0.08401381f, -0.02567691f, -0.04283762f, -0.05476199f, 0.04051360f, 0.02066239f, 
    0.02556919f, -0.02782176f, 0.02151209f, 0.02962779f, 0.17655602f, 0.12387533f, 0.01694394f, -0.03008667f, 
    0.03627852f, -0.02255216f, -0.04757497f, 0.01126968f, 0.03396904f, -0.06005785f, -0.01662327f, -0.14301953f, 
    0.13507392f, -0.31072748f, -0.11751740f, 0.22539248f, 0.02472477f, -0.07037614f, -0.11699426f, 0.08245745f, 
    0.01024873f, -0.10418776f, -0.18584982f, -0.00786867f, -0.13991494f, -0.04229924f, 0.07314785f, -0.02031628f, 
    -0.05193573f, -0.11535826f, 0.10977703f, -0.00814431f, 0.02827760f, -0.05180583f, -0.05652409f, 0.15709801f, 
    0.12489928f, -0.10614883f, 0.03524616f, 0.02327364f, -0.01059027f, 0.00434288f, 0.02670936f, 0.08157524f, 
    -0.00032211f, 0.09384429f, 0.03882251f, 0.04464224f, -0.30784479f, 0.19280502f, 0.21448666f, 0.03625659f, 
    0.09658099f, 0.04906648f, 0.05139451f, -0.00456859f, -0.02825116f, -0.00252081f, -0.14104727f, 0.01351869f, 
    -0.27231970f, -0.33566120f, -0.32272038f, -0.00243451f, -0.01929473f, 0.01818934f, -0.02727236f, -0.10267157f, 
    -0.11405285f, -0.10451941f, -0.02668690f, 0.02007847f, 0.14233521f, -0.29936904f, 0.08889197f, 0.03533238f, 
    -0.04604562f, 0.04175589f, -0.01574401f, 0.07697535f, 0.04554035f, -0.06243569f, 0.00580043f, 0.01259438f, 
    -0.24349526f, -0.17754968f, -0.02872664f, 0.12387505f, -0.01010316f, -0.00506615f, -0.00062796f, -0.02793474f, 
    -0.07884786f, 0.00341933f, -0.02103638f, -0.06681856f, -0.26726398f, -0.26866588f, -0.15923201f, 0.15038832f, 
    -0.05077103f, -0.06014549f, 0.13788073f, -0.05654425f, -0.01236154f, 0.00303193f, 0.01041231f, 0.05970941f, 
    -0.21363533f, 0.06017359f, 0.09188605f, 0.11907481f, 0.01293737f, 0.06536037f, -0.01772372f, 0.01695118f, 
    -0.11266893f, 0.00371637f, -0.00674062f, -0.11799297f, 0.03658150f, -0.01486786f, 0.11025422f, 0.12098110f, 
    0.06603828f, 0.08781748f, -0.03233795f, -0.02187861f, -0.06722117f, -0.03919983f, -0.04315183f, -0.03874451f, 
    0.12493880f, 0.01581925f, 0.01632367f, 0.00701056f, -0.03880439f, 0.06137732f, 0.03224004f, 0.00601965f, 
    0.05358418f, 0.02722574f, 0.05316400f, -0.01946228f, 0.10577638f, -0.16227698f, 0.04725800f, -0.04875411f, 
    -0.06862663f, -0.01952662f, -0.01761519f, -0.03700133f, -0.01520327f, 0.00977826f, -0.04197299f, -0.01163566f, 
    -0.13958946f, 0.13711558f, 0.04413948f, -0.12754108f, -0.04827911f, 0.08665465f, -0.07088064f, 0.18917537f, 
    -0.01048754f, 0.00525680f, -0.07456778f, -0.00683620f, 0.21441387f, -0.10885011f, -0.10644042f, 0.09889090f, 
    0.00694851f, 0.11262880f, 0.08517844f, 0.01733371f, 0.05923934f, 0.02589374f, 0.09123047f, -0.00617065f, 
    -0.27991965f, -0.36875233f, -0.34329349f, 0.03649306f, 0.00172705f, -0.02948782f, -0.05697709f, -0.08619934f, 
    -0.09056662f, 0.13375749f, 0.02231006f, -0.03982165f, -0.48034737f, 0.22302461f, 0.12297324f, 0.00627133f, 
    0.09631079f, -0.00649828f, 0.05735670f, 0.10247017f, 0.02762376f, -0.02995573f, -0.14400166f, 0.01237562f, 
    -0.18644971f, 0.17459674f, 0.02369748f, -0.02906176f, -0.11563965f, 0.01795511f, -0.01415948f, 0.07632257f, 
    0.02470426f, 0.07495908f, 0.06546960f, -0.04849132f, -0.53264195f, -0.33845645f, 0.07927051f, 0.02642096f, 
    -0.10840314f, -0.00989452f, 0.04406529f, -0.03110065f, 0.07849259f, 0.02196168f, -0.07242642f, 0.02876294f, 
    -0.16552392f, -0.04182466f, 0.08449120f, -0.00611679f, -0.08265965f, -0.01389790f, -0.05915415f, 0.14922258f, 
    0.08428829f, 0.02915204f, 0.11445200f, 0.02553302f, -0.07707345f, 0.01193503f, -0.06654493f, 0.08864864f, 
    -0.07023861f, 0.04067356f, -0.13225800f, 0.05763591f, -0.05488265f, -0.05282226f, 0.10495733f, -0.02641165f, 
    0.07369994f, -0.05162654f, -0.27530888f, -0.03374185f, 0.05198123f, 0.06829780f, 0.05579882f, 0.00778998f, 
    -0.11587703f, -0.17406744f, 0.08788535f, -0.07453049f, -0.15662141f, 0.08801223f, 0.04900642f, -0.14869770f, 
    0.05625902f, -0.04298152f, 0.02179466f, 0.05973966f, -0.04493939f, -0.04081915f, 0.06267986f, 0.03886995f, 
    -0.22356457f, -0.03940488f, 0.15904585f, -0.22550975f, -0.03112649f, 0.05733632f, 0.06769045f, 0.01464903f, 
    0.06381108f, 0.06511835f, 0.11237945f, 0.07093500f, -0.16740638f, 0.22572634f, -0.09992264f, -0.28611806f, 
    0.02830535f, 0.02588110f, -0.02215281f, 0.03068838f, -0.04126487f, -0.09832904f, 0.01756656f, -0.04321311f, 
    -0.31398490f, -0.04030332f, -0.22817498f, -0.06879539f, 0.09397452f, -0.07758041f, 0.02143286f, -0.20171146f, 
    -0.07677796f, -0.02710874f, -0.08465560f, -0.02304789f, -0.13538621f, 0.03229617f, 0.11599004f, 0.07449064f, 
    0.08038468f, 0.05447179f, 0.10193612f, 0.18751813f, 0.02359080f, 0.03770303f, 0.10110544f, 0.07359526f, 
    -0.08848981f, -0.25551504f, -0.25302389f, -0.09427339f, 0.10745259f, 0.02414526f, -0.06274619f, 0.05373299f, 
    -0.03663335f, 0.02295860f, -0.06919254f, 0.03014141f, -0.04242749f, 0.05372804f, -0.00269625f, -0.08317406f, 
    -0.04006565f, -0.07899390f, 0.01637099f, 0.06394130f, 0.05196257f, 0.06489670f, 0.02446223f, -0.01666250f, 
    0.38038582f, -0.04329459f, 0.03886065f, 0.10179245f, 0.00352813f, -0.03974688f, -0.02653908f, 0.06848755f, 
    0.05831047f, -0.08090863f, 0.04176778f, -0.01685397f, -0.15037285f, -0.10960864f, 0.08588622f, 0.29705581f, 
    0.03018545f, -0.02289228f, 0.07667657f, 0.05947021f, -0.00846700f, -0.04432587f, -0.02478397f, -0.00741558f, 
    -0.03058655f, -0.05480933f, 0.03429070f, -0.10152466f, -0.02772449f, -0.02843489f, 0.00152493f, 0.01079548f, 
    -0.01850547f, -0.01807629f, -0.02676945f, -0.05949655f, -0.23332252f, 0.02016534f, 0.02136490f, 0.07118595f, 
    0.03220598f, -0.02473682f, 0.01215276f, -0.04297282f, -0.03114002f, 0.03453229f, 0.05558749f, -0.10799260f, 
    0.02197155f, 0.00813128f, 0.16497998f, -0.21113938f, -0.06290747f, 0.00811330f, 0.00181239f, -0.10377918f, 
    -0.06789669f, -0.00374904f, -0.04083702f, 0.01965185f, 0.10459806f, -0.05093498f, 0.13025561f, 0.09746911f, 
    0.00266090f, -0.04564188f, 0.07856637f, 0.02858126f, -0.01439670f, 0.14413479f, -0.08663601f, 0.12019158f, 
    -0.09309071f, -0.05765839f, -0.00458416f, 0.13445856f, -0.03172629f, 0.05350509f, 0.02741625f, 0.07360032f, 
    -0.14589339f, -0.01554996f, -0.03249916f, 0.07634948f, -0.05964034f, -0.03191254f, 0.10605257f, -0.20816232f, 
    0.02034017f, 0.15046436f, 0.07063936f, -0.06108341f, 0.00362686f, -0.01933049f, 0.02218008f, -0.03258097f, 
    -0.50544107f, 0.08962604f, -0.13979428f, -0.14722335f, 0.10240785f, 0.02336914f, 0.07672011f, 0.02764824f, 
    -0.11158144f, 0.01972796f, -0.00702312f, -0.06389547f, -0.42123511f, -0.01940577f, 0.13711180f, 0.10093329f, 
    -0.00381386f, 0.01283191f, 0.04457537f, 0.00199594f, 0.06602153f, -0.02374318f, -0.12784629f, -0.00193958f, 
    0.23552562f, 0.00621473f, 0.02396404f, 0.02698048f, 0.04782531f, 0.03097492f, 0.14176609f, 0.07332566f, 
    0.05527753f, 0.10479294f, 0.00802454f, 0.00246609f, 0.00772460f, 0.03994843f, -0.07365848f, -0.11795679f, 
    0.12742467f, -0.01967680f, 0.00704813f, 0.10064126f, 0.09066047f, 0.00046866f, -0.12587635f, 0.02741580f, 
    0.10733943f, 0.36482835f, -0.12024494f, -0.03392550f, -0.08372375f, -0.00309945f, 0.12037852f, -0.07795151f, 
    -0.09406614f, -0.02911632f, -0.05218445f, 0.08827827f, 0.23577507f, -0.01285514f, 0.08667829f, -0.15785238f, 
    0.00577699f, -0.08016203f, -0.00781072f, 0.00067606f, -0.03353974f, -0.00703342f, -0.10697458f, 0.09552773f, 
    -0.49342209f, 0.03970031f, 0.24367866f, 0.15329811f, -0.09724295f, 0.05974257f, 0.04481982f, 0.04177722f, 
    -0.06400662f, 0.02065626f, 0.20982052f, 0.07108365f, -0.26354593f, -0.03546429f, -0.07189949f, 0.21175398f, 
    -0.01183602f, -0.04175201f, 0.04206860f, 0.06295276f, 0.01423513f, -0.06389353f, 0.11738918f, 0.03524742f, 
    0.10550063f, -0.11377486f, 0.10910898f, -0.10602304f, -0.00656694f, 0.08312514f, -0.09074063f, 0.05355562f, 
    0.05600746f, 0.01600124f, 0.03849414f, -0.05745436f, -0.29799300f, 0.18562576f, 0.15116566f, -0.01011725f, 
    0.15136166f, 0.02239719f, -0.02683318f, -0.01021971f, 0.06240939f, -0.02587215f, 0.01140199f, 0.05198136f, 
    0.06255138f, 0.11308882f, 0.01945047f, -0.02297148f, 0.02335394f, 0.00758167f, 0.06713004f, -0.00013240f, 
    0.00846055f, -0.00598647f, -0.12732781f, -0.03131846f, 0.16200858f, 0.20973261f, -0.00462521f, -0.09563833f, 
    -0.05306588f, -0.02921637f, -0.03075676f, 0.03490258f, -0.11633736f, -0.00249225f, 0.08941158f, 0.05649336f, 
    -0.09387176f, -0.04667490f, 0.19637214f, 0.09821371f, -0.13282655f, -0.00512386f, -0.10199518f, 0.00841813f, 
    -0.02242358f, -0.09508116f, -0.04780380f, 0.03769646f, -0.12558015f, -0.07284769f, -0.13689974f, 0.02636816f, 
    -0.00707991f, -0.08384807f, -0.00042465f, 0.01276396f, 0.02920768f, -0.01965839f, -0.00734248f, 0.11037837f, 
    -0.33471808f, -0.17453583f, 0.14086376f, -0.24356316f, -0.05201750f, 0.00061651f, -0.05689381f, 0.00975500f, 
    0.04313926f, -0.11254340f, -0.01352458f, 0.02580142f, -0.24269392f, -0.03001414f, -0.05011059f, 0.23779593f, 
    0.07673185f, 0.00400458f, 0.01516437f, -0.01976676f, 0.06313735f, -0.11675934f, 0.06567471f, -0.04968870f, 
    -0.55471230f, 0.05985659f, 0.05614167f, 0.03061232f, 0.05990192f, -0.02727382f, -0.06988800f, 0.07162124f, 
    -0.02683716f, 0.01899564f, -0.01433478f, 0.00790197f, -0.22571583f, 0.07870463f, -0.01627586f, 0.17678332f, 
    0.08527344f, -0.16885121f, 0.06891279f, 0.02926613f, 0.08441486f, -0.01311499f, -0.03065007f, 0.01404296f, 
    -0.02269342f, 0.13813502f, -0.01909648f, -0.20001745f, -0.10938949f, 0.08677678f, -0.06896123f, 0.08887394f, 
    0.03962006f, -0.03308406f, -0.03842482f, 0.00737188f, -0.21842720f, -0.17987397f, -0.00105285f, -0.19983529f, 
    -0.04382803f, 0.03387545f, 0.01434551f, -0.02619666f, -0.11052166f, 0.02258629f, -0.09894688f, -0.01440991f, 
    0.17648110f, 0.01437489f, -0.20940407f, -0.00152061f, -0.08261507f, -0.02173505f, 0.09104837f, 0.08397789f, 
    -0.05808532f, 0.00196806f, -0.11195724f, 0.04323810f, 0.03367481f, -0.07065269f, 0.12064585f, 0.03192914f, 
    -0.11636075f, -0.17865364f, -0.11021091f, -0.10694886f, -0.03897044f, 0.13368592f, 0.02038341f, -0.02093180f, 
    0.14730385f, 0.03693382f, -0.06320041f, 0.09295832f, -0.00469990f, -0.07766717f, 0.13163154f, 0.03469614f, 
    -0.03993473f, 0.05250245f, -0.01169577f, 0.04218187f, -0.04974146f, -0.10481494f, 0.14211372f, 0.02446299f, 
    -0.05860795f, 0.01741887f, 0.03009184f, -0.02773481f, 0.02265088f, -0.05684591f, 0.02397651f, 0.11267564f, 
    0.02338571f, 0.08852401f, 0.10644307f, 0.13572885f, -0.07658390f, -0.02497636f, -0.06840461f, -0.08133119f, 
    0.01356510f, 0.06353905f, -0.00998477f, -0.10580658f, 0.00521520f, 0.05684802f, -0.00347452f, -0.20523623f, 
    0.20775123f, 0.00937968f, 0.00229781f, -0.02425405f, 0.07632264f, -0.05343024f, 0.01543334f, 0.06333598f, 
    -0.45926705f, 0.00482049f, -0.03649378f, 0.20495322f, -0.07073838f, -0.00181805f, 0.18261285f, -0.06046085f, 
    -0.02283829f, 0.04687659f, 0.04229273f, -0.02813321f, -0.12698956f, 0.22520302f, 0.01127482f, -0.03214121f, 
    0.10978602f, -0.05544288f, 0.01022235f, 0.09124941f, -0.10491767f, -0.06558594f, 0.10307378f, -0.11127499f, 
    -0.28382239f, 0.18998198f, 0.22554922f, 0.07219807f, 0.01278353f, -0.03638030f, -0.05629405f, 0.05507025f, 
    0.05494961f, -0.12562887f, 0.08052258f, 0.04579802f, 0.01094087f, 0.03009281f, 0.11962881f, -0.07685478f, 
    -0.09612112f, -0.12948124f, -0.06734420f, -0.00966600f, -0.03036606f, -0.07235647f, 0.06826004f, 0.03079857f, 
    0.42075261f, 0.19158079f, -0.10255463f, -0.18148573f, 0.00204959f, 0.04703020f, 0.04888443f, 0.08559423f, 
    -0.01754931f, 0.02619999f, -0.00690715f, 0.09548509f, -0.39644572f, 0.02114568f, 0.09179889f, 0.03284913f, 
    0.01268014f, -0.01525989f, 0.04876151f, -0.09596884f, 0.11100863f, -0.02204088f, -0.09934162f, 0.03984524f, 
    -0.07025418f, 0.14315294f, 0.04483725f, 0.14988071f, -0.09293532f, 0.00704582f, 0.01060102f, 0.07434376f, 
    0.06639666f, 0.04237130f, 0.00495452f, -0.09895669f, 0.26859036f, 0.15522820f, 0.06195744f, 0.02338050f, 
    -0.02261366f, -0.00983576f, -0.03307238f, 0.04628559f, -0.02690376f, -0.01907390f, 0.05823252f, 0.06363744f, 
    -0.24452575f, -0.15910412f, 0.13172835f, 0.13200943f, -0.14537612f, -0.07229746f, -0.06712060f, 0.00280751f, 
    0.14143082f, 0.04903350f, -0.01467435f, -0.12837458f, -0.04025845f, 0.16346198f, -0.03445164f, -0.10062095f, 
    0.01379194f, 0.09691643f, 0.09859640f, 0.07812104f, -0.05329568f, 0.08888461f, -0.03242341f, 0.04028083f, 
    -0.27036357f, -0.06803531f, 0.12379696f, 0.04127688f, 0.08428402f, -0.02386867f, -0.06950620f, -0.01094759f, 
    0.01434022f, -0.01730353f, -0.15933409f, 0.03211174f, 0.08074076f, 0.04073500f, 0.00187220f, -0.17218344f, 
    0.07179139f, 0.05917751f, 0.00994009f, -0.04734369f, -0.11730891f, -0.11762887f, -0.06680446f, 0.01284923f, 
    0.31998029f, -0.11944168f, -0.12935150f, -0.02742954f, -0.10013675f, 0.03175806f, -0.03298410f, -0.03545650f, 
    -0.00587195f, -0.03127367f, 0.03397735f, -0.09967245f, -0.16602187f, 0.00824069f, -0.07960501f, 0.11695585f, 
    0.09451828f, 0.05459362f, 0.10976093f, 0.12882726f, -0.07423365f, 0.05143907f, -0.01799429f, -0.03872338f, 
    -0.12646365f, 0.00568298f, 0.00610178f, 0.02777727f, -0.01763318f, -0.12318535f, 0.01522859f, -0.05636282f, 
    0.08777811f, -0.02513840f, 0.01193051f, 0.04777097f, 0.02030271f, -0.06965598f, 0.02591465f, -0.08683248f, 
    0.03058525f, 0.11178937f, 0.02581149f, -0.19978087f, 0.06334948f, 0.07808019f, 0.04330844f, 0.07254461f, 
    0.07448997f, -0.11461634f, 0.04849725f, 0.10132254f, -0.12541406f, -0.03173881f, 0.05085665f, 0.01681591f, 
    0.06821123f, 0.04216043f, 0.00726139f, -0.09161735f, -0.34889629f, -0.04841223f, 0.04346921f, 0.10066281f, 
    -0.06610782f, -0.12741667f, 0.13182177f, -0.03688040f, 0.00136104f, 0.05066840f, 0.08334178f, 0.01189806f, 
    -0.00861830f, -0.07175877f, 0.00865864f, 0.08561447f, -0.03560119f, 0.11193340f, 0.07463861f, -0.00799991f, 
    -0.00846926f, -0.00331134f, -0.04218861f, 0.07109289f, -0.06211046f, -0.05447269f, -0.03896945f, 0.10651140f, 
    0.06549545f, -0.16049257f, 0.04965136f, 0.12336263f, -0.02166376f, 0.04325315f, -0.07625891f, 0.05534162f, 
    -0.04302356f, 0.07988547f, 0.04823786f, -0.07530706f, 0.05938635f, 0.11483820f, -0.00697581f, 0.06614836f, 
    -0.00471627f, -0.10288876f, -0.00369024f, -0.00953614f, -0.24953626f, 0.23702633f, -0.08856401f, -0.42907733f, 
    0.00166548f, -0.08547924f, -0.07706183f, 0.07293154f, 0.07298720f, -0.00716964f, -0.07783120f, 0.00938840f, 
    -0.40579414f, 0.14767845f, 0.07964228f, -0.31438315f, 0.05478035f, 0.06851570f, 0.09581105f, 0.11016946f, 
    -0.06509005f, 0.04966671f, -0.12239379f, 0.08771662f, -0.00704729f, -0.09505202f, 0.14061932f, 0.20289989f, 
    -0.03902073f, -0.05041715f, -0.02310122f, 0.02697871f, -0.08252922f, 0.11807431f, -0.02021261f, 0.13321632f, 
    0.20628329f, -0.02262608f, -0.12857996f, 0.00170780f, 0.04105337f, -0.02693731f, 0.05850201f, -0.09157601f, 
    -0.10911218f, -0.00409322f, -0.03633392f, -0.07314964f, -0.02269708f, 0.00468730f, 0.21431677f, 0.20157422f, 
    -0.06404670f, -0.00511136f, -0.01064688f, -0.10781432f, -0.00991000f, 0.07397388f, -0.08879507f, 0.15494193f, 
    -0.29218328f, 0.07401891f, 0.12703499f, -0.00190002f, 0.00852520f, 0.01610573f, -0.01466904f, 0.04324508f, 
    0.18942632f, 0.09737167f, 0.09818439f, 0.04144052f, -0.03038521f, 0.08482821f, 0.03454553f, -0.11136454f, 
    -0.01339567f, -0.03463374f, -0.01499824f, 0.03927173f, -0.03235706f, -0.06405810f, -0.07964126f, -0.08792928f, 
    0.06664843f, 0.20742390f, 0.02939663f, -0.02143881f, -0.10902397f, -0.20728564f, 0.03651572f, 0.02980842f, 
    0.03095289f, -0.10315514f, -0.08430347f, -0.07424314f, 0.13058583f, 0.07506410f, 0.12277494f, -0.08788814f, 
    0.02103741f, 0.14308384f, 0.05092010f, -0.07005519f, -0.04041684f, 0.05420119f, 0.01114021f, 0.14730173f, 
    -0.00558629f, -0.05286205f, -0.04572095f, 0.06528080f, 0.01235305f, -0.06859551f, 0.02834316f, -0.20499955f, 
    0.00043286f, -0.03295360f, -0.05534091f, -0.04437401f, 0.13759285f, -0.13910510f, -0.09600982f, 0.07813341f, 
    0.10369720f, 0.03032093f, -0.12718211f, 0.04664753f, 0.16218522f, 0.04239743f, -0.05074469f, -0.09227022f, 
    -0.04072269f, -0.03706731f, 0.01655979f, -0.26502052f, 0.03352480f, 0.07734438f, -0.12811314f, 0.08061451f, 
    0.01843335f, 0.09373295f, -0.01783696f, -0.18603423f, -0.07182442f, -0.02756498f, 0.07114415f, -0.05118087f, 
    -0.01498686f, -0.04154949f, 0.00770319f, 0.05778138f, 0.11332645f, -0.02893374f, -0.13512442f, 0.04698628f, 
    -0.09548516f, 0.15207352f, -0.03552331f, 0.14028080f, 0.00174069f, -0.03693965f, -0.07914196f, 0.05960942f, 
    -0.09399621f, 0.01423558f, 0.02238073f, 0.01750875f, -0.13449794f, -0.16005342f, 0.15637486f, -0.03150644f, 
    0.01014711f, 0.15617637f, -0.00196930f, -0.15840264f, 0.04847063f, -0.14238180f, 0.19622196f, -0.02054838f, 
    -0.19811329f, -0.10386349f, 0.11590179f, 0.05421304f, 0.06534093f, 0.04454055f, 0.22107618f, 0.06999572f, 
    0.00814251f, 0.07636404f, 0.04306886f, -0.15406474f, -0.26668894f, 0.07022662f, 0.10234372f, -0.09252401f, 
    -0.14328438f, 0.00541365f, 0.03766354f, 0.10543548f, 0.07276922f, -0.01158641f, -0.03234118f, -0.26689926f, 
    -0.38259876f, -0.09027779f, 0.03230427f, -0.20309931f, 0.10458230f, -0.06464541f, -0.07685132f, -0.07281306f, 
    0.01612985f, -0.05176757f, 0.00939864f, -0.12929264f, 0.15571572f, 0.03497741f, -0.08468454f, 0.10206448f, 
    -0.00490065f, -0.05671860f, -0.09427670f, 0.03156161f, -0.10361825f, 0.12249928f, 0.08284029f, 0.16300757f, 
    -0.19693242f, 0.00039943f, 0.01412998f, 0.31224436f, 0.00089496f, 0.06846293f, -0.01191246f, 0.03296026f, 
    0.05740165f, -0.26742503f, 0.11019581f, 0.15123464f, -0.46120244f, -0.12741499f, -0.01296416f, -0.10267289f, 
    -0.08458246f, 0.09834086f, -0.00104921f, 0.04605970f, -0.07841836f, 0.01404481f, 0.16257282f, -0.00279817f, 
    -0.16224858f, -0.15051012f, 0.12884147f, 0.17979626f, -0.02696224f, -0.08047218f, -0.02995936f, 0.06439392f, 
    0.09606442f, 0.05868555f, 0.01093849f, -0.02888622f, -0.48320344f, -0.31136391f, -0.08774236f, 0.05847900f, 
    0.09008989f, -0.07125293f, -0.04123411f, 0.02603278f, 0.04429199f, -0.04086607f, 0.03702021f, 0.09353493f, 
    0.18789481f, 0.10081238f, -0.30213884f, -0.03860733f, 0.04654585f, 0.07335747f, -0.15761234f, 0.06525274f, 
    -0.04677828f, -0.08266756f, -0.17632471f, 0.02787711f, -0.26677257f, 0.06707457f, -0.30518904f, -0.16670170f, 
    0.09685645f, 0.04096290f, -0.06899330f, -0.27766863f, -0.02080959f, 0.04906678f, -0.09624746f, -0.03899147f, 
    -0.16891013f, -0.05242454f, 0.01527384f, 0.21428603f, 0.01949102f, -0.14368419f, -0.02476209f, 0.01217341f, 
    0.10357339f, -0.14476201f, 0.08038222f, -0.02278035f, -0.21997315f, -0.30769125f, -0.15268113f, -0.06457613f, 
    0.11534205f, -0.05938878f, -0.03019921f, 0.01375660f, -0.08167893f, 0.07807427f, 0.03630406f, -0.09051992f, 
    -0.04733079f, -0.12881131f, -0.08817191f, 0.09063967f, 0.04861790f, -0.14491351f, -0.14981231f, 0.05744186f, 
    0.07050554f, 0.01191624f, 0.10132269f, -0.00154404f, -0.02183698f, -0.09197443f, 0.06546161f, 0.00144060f, 
    -0.01017407f, 0.08790217f, -0.11135162f, -0.13821122f, -0.01957814f, -0.12298191f, 0.04094677f, -0.11943801f, 
    0.03020511f, -0.01470444f, -0.02311517f, 0.09302490f, -0.06543984f, -0.05601719f, 0.05414180f, -0.03526187f, 
    -0.15755489f, -0.05731162f, 0.06121133f, 0.22598481f, -0.03430877f, 0.10461958f, -0.13116197f, -0.12463130f, 
    0.07230058f, 0.21551880f, 0.09096107f, -0.12281213f, 0.14370298f, -0.09857183f, -0.15192665f, -0.02349448f, 
    0.19395103f, -0.02366884f, 0.00228683f, 0.07280169f, -0.08327027f, 0.03973791f, 0.06737978f, 0.06230698f, 
    -0.16272770f, -0.03578158f, 0.11442398f, -0.11928230f, -0.29822582f, -0.13079751f, -0.17460556f, 0.03810323f, 
    0.08868413f, 0.04662225f, 0.01746981f, -0.22637017f, -0.03594058f, 0.06301519f, -0.01122384f, 0.04310783f, 
    -0.47380710f, 0.12224775f, -0.09412515f, -0.05950001f, 0.12567364f, 0.05012281f, 0.06633441f, 0.01797703f, 
    0.01579665f, -0.20923734f, 0.13615425f, -0.17888017f, -0.13047086f, -0.00727722f, 0.01850558f, -0.16460349f, 
    -0.03203789f, -0.02976557f, -0.08058283f, -0.05975983f, 0.11022011f, 0.09794173f, 0.00265897f, 0.05236665f, 
    -0.01987245f, 0.07758692f, 0.18506871f, -0.09579135f, 0.04855791f, -0.03623728f, -0.04138681f, -0.00038563f, 
    0.01978716f, -0.03964268f, 0.16190006f, 0.01696517f, 0.04619593f, 0.00029832f, -0.09490930f, -0.17412743f, 
    0.13925926f, -0.11221535f, -0.07225370f, 0.11605013f, 0.03379884f, -0.08655122f, 0.06835034f, 0.09128843f, 
    0.06325238f, -0.01631701f, 0.06240794f, -0.30648738f, 0.08002657f, 0.07520279f, 0.01754283f, 0.02796769f, 
    0.06342014f, 0.08319816f, 0.08399498f, 0.08985961f, 0.15254596f, 0.09868305f, 0.08397482f, 0.04328525f, 
    0.17853878f, 0.06012347f, 0.03333569f, -0.04779686f, -0.31820157f, -0.22119825f, 0.02695121f, 0.11484752f, 
    -0.03703398f, 0.03671081f, 0.15236194f, -0.12797658f, 0.03007866f, 0.03047813f, 0.05415975f, -0.10786502f, 
    -0.03382760f, 0.01933769f, -0.11657114f, -0.02659659f, 0.08828539f, 0.18401180f, 0.13585673f, 0.12687771f, 
    0.08043668f, -0.01946987f, 0.01478380f, 0.00853143f, -0.02867449f, 0.02613398f, -0.03107681f, -0.13394929f, 
    0.07906012f, -0.03178322f, -0.03620839f, -0.14456056f, 0.08774472f, 0.01699040f, 0.04339935f, 0.08178537f, 
    0.04111746f, 0.06676606f, -0.11297171f, -0.13024987f, -0.01814028f, 0.09871738f, 0.08091439f, -0.02981220f, 
    -0.05296733f, 0.04932251f, 0.05496469f, 0.01693632f, 0.05053045f, 0.11485961f, 0.15111619f, 0.06192826f, 
    0.16877905f, 0.14563346f, -0.11297981f, -0.12103138f, 0.03324262f, 0.02816409f, -0.11293033f, -0.14508107f, 
    0.01066287f, -0.20052978f, 0.05903505f, -0.11310212f, -0.09338979f, -0.22413018f, 0.00919773f, 0.06208149f, 
    0.02131239f, -0.01710629f, 0.06174590f, -0.13449115f, 0.02539334f, 0.01062977f, 0.10685648f, 0.19037959f, 
    0.08575339f, -0.09436871f, 0.04476570f, 0.19041349f, -0.20517240f, 0.06495848f, 0.08930123f, -0.03156390f, 
    -0.17601761f, -0.01200882f, 0.06501953f, 0.07202929f, -0.20529583f, -0.02892572f, -0.07811727f, -0.09527470f, 
    0.04952940f, 0.03421342f, 0.02834400f, 0.04433130f, 0.05409847f, 0.08131549f, 0.03540148f, -0.00962943f, 
    -0.10777591f, -0.17197931f, 0.28711712f, 0.26925153f, 0.11457787f, -0.07667267f, 0.00090700f, -0.09589012f, 
    -0.12924796f, -0.10093694f, -0.10126285f, -0.11148683f, 0.04006888f, -0.15046759f, -0.08798978f, -0.08679800f, 
    0.08133908f, -0.02711599f, -0.00876227f, -0.02066880f, 0.02080962f, 0.06121735f, 0.03037934f, 0.09521459f, 
    -0.06986833f, -0.02582150f, 0.12765071f, -0.00950836f, 0.01729776f, 0.01329389f, 0.00436207f, -0.00453624f, 
    0.09676780f, -0.06155964f, 0.02470331f, 0.18958846f, -0.09901904f, 0.01147199f, 0.09649882f, 0.12069465f, 
    -0.09775937f, -0.00327446f, 0.12487715f, -0.08366868f, 0.02681299f, -0.04166743f, 0.05889386f, 0.09084836f, 
    0.14244141f, 0.01226682f, -0.00896910f, 0.04002368f, -0.12114283f, 0.03535389f, 0.00037644f, 0.00625459f, 
    -0.19424878f, -0.01488456f, 0.12284776f, 0.05664129f, -0.00110999f, 0.05886323f, 0.13626392f, -0.08424506f, 
    0.06442676f, -0.10032599f, -0.17588253f, 0.01997907f, -0.01149635f, 0.09574629f, -0.01495694f, 0.00010342f, 
    0.01531867f, 0.01118181f, 0.03185996f, -0.22295079f, -0.02004577f, 0.05389284f, 0.08616615f, 0.00836393f, 
    0.02992051f, 0.01597195f, 0.16465548f, 0.09177195f, -0.14717157f, -0.08276486f, -0.02951269f, 0.11438382f, 
    -0.00671811f, -0.02014312f, 0.08113974f, 0.11938059f, 0.12094663f, -0.14777364f, -0.03819671f, 0.03132323f, 
    0.05511685f, 0.02775460f, 0.13457446f, 0.06362937f, 0.07536956f, -0.06493714f, -0.04061670f, -0.02345380f, 
    0.04851521f, -0.00886757f, -0.00490866f, 0.02332451f, -0.31168717f, -0.14960805f, 0.00852313f, -0.02921621f, 
    0.14455755f, 0.02311028f, -0.09163968f, 0.06473074f, 0.14982329f, 0.02342381f, -0.13508223f, -0.09452555f, 
    -0.07915075f, -0.28826782f, -0.01710626f, 0.22535113f, 0.07012358f, 0.10112356f, -0.08751027f, -0.03372514f, 
    0.00560948f, 0.04218386f, -0.05155924f, 0.00233330f, 0.02751650f, 0.09259227f, 0.24907550f, 0.03965107f, 
    0.01544294f, -0.05620534f, -0.02487833f, 0.16142501f, 0.03368364f, 0.01680017f, -0.05731195f, -0.15131928f, 
    0.01384605f, -0.14662887f, 0.10777859f, -0.04694407f, -0.05417122f, 0.00786816f, -0.09580772f, 0.08733746f, 
    0.03045586f, 0.05109393f, 0.06937157f, -0.06643241f, -0.12092330f, 0.09831976f, 0.07883834f, 0.03181430f, 
    -0.04750163f, -0.06097537f, 0.00460131f, 0.04096524f, 0.16121180f, -0.11430494f, 0.06462463f, 0.04010550f, 
    0.13333862f, 0.18019418f, 0.00068043f, -0.03569816f, -0.06925504f, -0.09883119f, 0.03413552f, -0.19944902f, 
    0.02555784f, -0.00363784f, -0.09147968f, -0.02997312f, 0.00673761f, 0.04793880f, 0.19593513f, -0.02922384f, 
    -0.02229742f, 0.07488548f, 0.02768235f, -0.06175607f, -0.00425783f, -0.26606485f, -0.03725484f, 0.03700884f, 
    -0.16690525f, -0.01253071f, -0.01552598f, 0.14977698f, -0.08907679f, -0.07956113f, 0.07823052f, -0.08910089f, 
    0.00393775f, 0.07696927f, -0.00554608f, 0.12700422f, -0.36047775f, 0.20332050f, 0.03016473f, 0.07076519f, 
    0.00890129f, -0.00692172f, 0.02827698f, 0.03313000f, 0.02563510f, 0.00127272f, 0.02490538f, -0.00735866f, 
    0.02948522f, -0.33829087f, 0.02626655f, 0.07991154f, -0.00411135f, -0.02858987f, 0.06557913f, -0.08951152f, 
    -0.00122356f, -0.11346203f, 0.04447066f, -0.06871404f, 0.12742646f, 0.00093443f, -0.17047516f, -0.12340192f, 
    0.02036309f, 0.04158691f, 0.01451549f, -0.03685307f, 0.00324472f, -0.05740780f, -0.08156011f, -0.04575441f, 
    -0.29025218f, 0.10505614f, 0.00680170f, 0.29199091f, 0.01477875f, 0.07912739f, 0.00553779f, 0.09578141f, 
    0.06415856f, 0.04333878f, 0.04474331f, -0.10884182f, 0.06322525f, 0.00087717f, -0.07584214f, -0.08882592f, 
    -0.03352523f, 0.06450593f, -0.01421584f, 0.19033064f, 0.02011674f, -0.07416797f, 0.06826253f, -0.19226030f, 
    0.03984113f, -0.23596725f, -0.01152913f, -0.09776153f, -0.08093348f, 0.02222336f, 0.10922370f, 0.06447747f, 
    0.02127283f, -0.05604256f, -0.07217357f, -0.10207451f, 0.10768422f, -0.00906296f, 0.08093056f, 0.04309628f, 
    -0.10313128f, 0.02621590f, 0.05115755f, 0.02059583f, -0.02626221f, 0.00596769f, 0.11528092f, 0.10438707f, 
    -0.29455790f, 0.12539035f, 0.19606963f, 0.31085932f, -0.14577505f, -0.02166235f, 0.04678578f, -0.01541310f, 
    0.04363803f, 0.10980733f, 0.11262462f, 0.09541571f, -0.26319730f, 0.11347965f, 0.13234819f, -0.01092627f, 
    -0.09272981f, -0.05512046f, 0.09124450f, 0.01924150f, 0.01644316f, 0.08047940f, 0.00786024f, -0.13914479f, 
    -0.05838374f, 0.00932630f, -0.07900662f, 0.41287130f, -0.04904472f, 0.03873452f, 0.00076291f, 0.06545019f, 
    -0.14212672f, 0.13171478f, 0.11056478f, -0.09006157f, -0.28632367f, 0.05828120f, -0.26164714f, -0.08153487f, 
    -0.08891911f, -0.00914174f, 0.06781005f, -0.08228464f, -0.04823827f, -0.03249612f, 0.08608910f, 0.00589031f, 
    -0.12087054f, 0.05202299f, 0.01293242f, -0.02371250f, 0.05241597f, 0.01774127f, 0.18908180f, -0.12287930f, 
    -0.10431974f, -0.03960496f, 0.03090228f, 0.03078189f, 0.07846241f, 0.15498003f, 0.04561534f, -0.13249920f, 
    -0.04245344f, 0.03379524f, -0.15838449f, 0.04795509f, -0.07345851f, 0.04709845f, 0.03740628f, 0.03995059f, 
    -0.10736856f, -0.15131469f, -0.03456572f, 0.21751726f, 0.10904109f, 0.07520179f, -0.02935119f, -0.05477221f, 
    0.02980665f, -0.02035348f, -0.06524353f, -0.03724549f, -0.08279504f, -0.07776383f, -0.16587508f, 0.16197878f, 
    -0.19382106f, 0.02059499f, 0.05208032f, 0.04056962f, -0.08032521f, 0.12962128f, -0.15041241f, 0.03434077f, 
    0.11241691f, -0.02912521f, 0.00479226f, -0.00351129f, -0.01281164f, 0.05732464f, -0.08734173f, 0.02532594f, 
    -0.04510545f, 0.06214058f, 0.00948382f, 0.05901431f, 0.10820325f, -0.03173504f, 0.14959957f, 0.15863243f, 
    0.03779516f, 0.01325572f, -0.07891983f, -0.10647617f, -0.07826103f, 0.02689611f, 0.09496271f, 0.11954140f, 
    0.57388926f, -0.04073240f, 0.07778917f, -0.03955700f, 0.02206238f, -0.01436751f, 0.06519206f, 0.01204566f, 
    0.02766819f, -0.07154290f, 0.10940138f, 0.01005006f, 0.19897515f, 0.04271671f, 0.17837915f, -0.29994914f, 
    0.16251187f, 0.04392885f, 0.11128723f, 0.02382691f, 0.02193795f, -0.01394377f, -0.00816645f, -0.20884405f, 
    0.03408727f, -0.15047404f, -0.16720822f, 0.09604681f, -0.00055634f, -0.02462883f, -0.17428173f, -0.01280239f, 
    0.01050394f, 0.09335463f, -0.11509829f, -0.07391679f, 0.28481674f, -0.12907280f, -0.02224229f, -0.07847076f, 
    -0.10802602f, 0.01199719f, 0.00859431f, -0.05938654f, 0.03043433f, 0.06008755f, -0.11210480f, 0.05011555f, 
    -0.02210118f, -0.15738814f, -0.15680572f, 0.18110821f, 0.03618147f, -0.03897228f, -0.02935631f, -0.03289611f, 
    -0.00861271f, -0.06303429f, -0.03879160f, 0.04969003f, 0.26752356f, -0.07592945f, -0.08070590f, 0.00100424f, 
    -0.06450889f, 0.02130650f, -0.04310903f, -0.01208306f, -0.11881019f, 0.03332440f, 0.02455809f, -0.03016261f, 
    -0.13660826f, -0.18879654f, 0.06241037f, -0.03747132f, -0.01994093f, -0.01541085f, -0.02958794f, -0.15241209f, 
    -0.03864677f, 0.00243810f, 0.18954179f, 0.07763740f, -0.18047452f, -0.23550546f, -0.11657991f, -0.17114794f, 
    -0.00537745f, 0.07538699f, -0.10139597f, 0.08821717f, 0.01789774f, 0.09009131f, -0.02090023f, 0.09227727f, 
    -0.13399157f, -0.06960385f, -0.15834509f, 0.12546892f, -0.02141732f, -0.06651186f, -0.03019231f, -0.07694951f, 
    -0.09630721f, 0.00798497f, -0.04845403f, -0.01406824f, 0.08372070f, -0.09039876f, -0.06273708f, 0.03201710f, 
    -0.01896036f, 0.05693504f, -0.01130973f, -0.15062666f, -0.04662703f, -0.03038306f, 0.05525652f, 0.16764398f, 
    -0.12947488f, -0.03036129f, -0.03194895f, -0.08089734f, 0.02913672f, 0.02948945f, 0.15060824f, 0.01781787f, 
    -0.04554293f, -0.02586153f, 0.03393121f, 0.05429759f, -0.10195611f, -0.03767379f, -0.10863192f, 0.13176192f, 
    0.05275661f, -0.03099096f, 0.07878930f, -0.05383687f, -0.00127804f, -0.05517378f, -0.02432117f, 0.10225601f, 
    0.06692309f, 0.14865372f, -0.15301466f, -0.24739121f, 0.05660300f, 0.18939261f, 0.08984001f, -0.05398759f, 
    0.03418938f, -0.09015282f, -0.07405593f, 0.05150534f, -0.24331729f, -0.26749524f, -0.01079311f, -0.10406620f, 
    0.08831502f, -0.11167560f, -0.04194054f, 0.02323989f, -0.05544091f, -0.00156586f, 0.08165453f, 0.01503360f, 
    -0.09290822f, 0.01181782f, 0.27140740f, -0.10057300f, 0.02204853f, -0.03205643f, -0.03524056f, -0.01226545f, 
    -0.04896409f, 0.02916118f, -0.15387395f, 0.02242457f, -0.22783074f, -0.04821945f, -0.04109673f, -0.29586184f, 
    -0.11095802f, -0.04722766f, -0.00123501f, 0.00633287f, 0.01832940f, 0.06821826f, -0.09826448f, 0.01716864f, 
    0.31243959f, -0.13032286f, 0.06615087f, -0.23430037f, -0.04384245f, 0.05155379f, -0.00614595f, -0.08897401f, 
    0.01298271f, 0.05667469f, 0.04852064f, 0.13522559f, -0.11065128f, -0.00983762f, 0.11743154f, -0.03480856f, 
    0.05546032f, -0.06730124f, 0.05476644f, -0.00609562f, -0.04775643f, -0.02358614f, -0.03084290f, -0.03722930f, 
    0.26413023f, 0.00036874f, 0.10918303f, -0.22965404f, 0.01949969f, 0.03845132f, 0.09837767f, -0.03279295f, 
    0.14727791f, -0.00466040f, -0.03266383f, 0.14486971f, 0.13128181f, -0.22576095f, 0.27327594f, -0.26609924f, 
    0.06671628f, -0.01953457f, 0.18086641f, 0.03131542f, 0.10824361f, -0.02726722f, -0.14055985f, -0.05581832f, 
    -0.43873903f, 0.13688014f, 0.08942223f, -0.35024264f, -0.12790461f, 0.06246566f, 0.02209252f, 0.00497977f, 
    0.10187843f, 0.00437859f, -0.08026664f, -0.01143692f, -0.06755186f, -0.05007277f, -0.09293395f, 0.00603728f, 
    -0.08857445f, 0.00440970f, -0.09075788f, -0.08398841f, -0.00725261f, 0.04248162f, 0.12181915f, 0.12354136f, 
    -0.13919033f, 0.02082204f, 0.09180301f, -0.07922332f, -0.07757869f, 0.05490348f, 0.03603099f, -0.01182653f, 
    -0.01610595f, 0.03970794f, 0.02554547f, 0.04581099f, -0.10648135f, -0.08794271f, -0.23640332f, 0.06039976f, 
    0.07284071f, -0.06439786f, -0.01806953f, 0.05013489f, -0.03022635f, -0.02452742f, -0.03896767f, 0.05742782f, 
    -0.14739999f, 0.02225255f, 0.01545237f, -0.23351921f, 0.02706894f, 0.05765700f, -0.08428984f, 0.03841729f, 
    -0.11568812f, -0.10707479f, 0.03928528f, 0.04383227f, 0.07316733f, 0.11147790f, 0.05324597f, 0.13996895f, 
    0.05500506f, -0.11328227f, -0.17688598f, -0.03290106f, -0.00876696f, -0.09365215f, -0.02423016f, -0.18663712f, 
    0.05316403f, -0.24860509f, -0.29296583f, -0.19235177f, -0.15737353f, 0.04715287f, -0.01803220f, -0.00136413f, 
    -0.03712363f, 0.12136146f, 0.00442687f, 0.25183386f, 0.21639398f, -0.03753919f, -0.14587465f, 0.08344471f, 
    -0.09288824f, -0.00287778f, 0.02558999f, -0.12863390f, 0.01699053f, -0.15404071f, -0.18799655f, -0.08287074f, 
    -0.00437477f, 0.10830019f, -0.01074263f, -0.21416855f, -0.03285171f, 0.03266124f, 0.01054053f, -0.01976745f, 
    0.10754902f, -0.05297211f, -0.03166869f, -0.10399149f, -0.20535158f, -0.01685854f, -0.01984341f, 0.07907516f, 
    -0.00253511f, 0.02417554f, 0.05612919f, -0.02222783f, -0.07807557f, -0.03946303f, -0.13032652f, 0.00105432f, 
    0.07081330f, -0.12030999f, -0.13059674f, -0.02591820f, -0.06412770f, -0.00500996f, 0.01327288f, 0.08232976f, 
    0.06734193f, 0.14378038f, 0.08400051f, 0.07516052f, 0.22188888f, -0.09221054f, 0.07190883f, 0.02488082f, 
    -0.00136938f, 0.05300127f, 0.10525518f, 0.03739328f, -0.05699438f, 0.04040905f, 0.03145640f, -0.01196474f, 
    -0.07723781f, 0.18432967f, 0.17687498f, -0.21991615f, 0.08478179f, 0.05739010f, -0.01034310f, 0.04099863f, 
    0.00676373f, 0.09047638f, 0.05782521f, -0.11252757f, -0.03272185f, 0.08209275f, 0.00111019f, -0.15687513f, 
    -0.02036732f, 0.07140702f, -0.09585410f, 0.08011969f, -0.02044325f, 0.05574889f, 0.04398208f, -0.01760535f, 
    0.01252334f, 0.21901287f, 0.15948184f, -0.00683365f, 0.07920807f, -0.10777603f, 0.00178090f, 0.01653426f, 
    0.11876858f, -0.09338689f, -0.12481534f, 0.00329429f, 0.16556828f, 0.10717788f, 0.05331745f, -0.24799664f, 
    -0.10087419f, -0.02610296f, 0.05397375f, 0.06034883f, 0.04952092f, -0.08590180f, -0.02574040f, -0.10016498f, 
    0.23626631f, 0.02770438f, -0.02170307f, -0.08561765f, -0.01140255f, 0.06394505f, 0.01839962f, -0.04570961f, 
    0.03581623f, -0.04777056f, -0.18242416f, -0.13054967f, 0.06424364f, -0.07926790f, -0.22275095f, 0.32262543f, 
    -0.06944744f, -0.01314853f, -0.04603742f, 0.02147298f, -0.22019944f, 0.04665632f, -0.07147607f, -0.04719573f, 
    -0.11236235f, -0.18704116f, -0.09793425f, -0.03718768f, -0.04912477f, 0.03332008f, 0.08923947f, -0.02411566f, 
    0.01268280f, -0.11908082f, 0.07679284f, 0.04928477f, -0.17071366f, 0.06005993f, -0.18980505f, -0.12594733f, 
    0.07650644f, -0.01134851f, -0.03828965f, -0.15363935f, 0.08726667f, 0.03943582f, 0.14743330f, -0.06667757f, 
    -0.12219695f, 0.05015298f, -0.09416524f, 0.13920201f, 0.03671887f, -0.04079804f, 0.14363384f, 0.09942210f, 
    -0.09559564f, -0.03061910f, -0.00522945f, -0.03874611f, 0.11602389f, 0.01113156f, -0.00187487f, 0.22855513f, 
    0.06478404f, 0.01333688f, -0.06298845f, 0.08208141f, -0.03006234f, 0.06415656f, 0.10267427f, 0.02563133f, 
    -0.34871721f, 0.27482471f, 0.11988911f, -0.09018125f, -0.04808321f, 0.05529530f, 0.06383174f, 0.00806960f, 
    -0.10156851f, -0.04362200f, 0.09962685f, 0.05233375f, 0.01881022f, -0.10774896f, 0.16643259f, 0.02829112f, 
    -0.03967324f, -0.04129976f, 0.07659898f, 0.11950877f, -0.00589230f, 0.07070856f, -0.13322106f, -0.03413510f, 
    -0.21006612f, -0.07592417f, 0.07444831f, -0.11220101f, 0.10090197f, -0.00549488f, 0.02462837f, 0.15488298f, 
    -0.13698615f, 0.00475148f, 0.08638940f, -0.00125197f, 0.09612620f, 0.09455776f, 0.11737882f, -0.09631674f, 
    -0.06501169f, -0.09276448f, 0.02332016f, 0.09689054f, 0.08345725f, 0.14603589f, 0.00729314f, 0.06925253f, 
    0.17544003f, 0.02017978f, 0.08704320f, -0.22945394f, 0.08734086f, 0.10578090f, 0.00463969f, 0.01851729f, 
    -0.12096372f, -0.02481278f, 0.13935947f, 0.02592107f, 0.33539945f, -0.31724796f, 0.00647452f, 0.06820537f, 
    0.12382763f, 0.09247157f, 0.01775942f, 0.02485283f, 0.00332528f, 0.13105051f, 0.03975962f, -0.13626029f, 
    -0.12759028f, -0.22009969f, 0.05076493f, -0.09064390f, -0.07360940f, 0.01682551f, -0.01612739f, -0.01831861f, 
    -0.00214381f, 0.07184949f, 0.00836104f, -0.11368623f, 0.04296318f, -0.00080427f, 0.16486120f, 0.15155211f, 
    -0.03799721f, 0.02080140f, -0.01930855f, -0.03152863f, -0.04348128f, -0.04709103f, -0.00678578f, -0.06858018f, 
    -0.20951760f, -0.09871463f, -0.14511912f, -0.10606188f, -0.03437945f, -0.02689441f, -0.06321359f, -0.01976882f, 
    0.02047149f, -0.02368701f, -0.05564888f, -0.04201013f, -0.28673479f, 0.10501469f, -0.08043606f, 0.02771780f, 
    0.00222527f, 0.03745188f, 0.04310108f, -0.06738768f, 0.03105068f, -0.01036454f, 0.07343028f, 0.00635724f, 
    -0.06304012f, 0.00084756f, -0.14015229f, -0.07368260f, -0.10612234f, -0.03866008f, -0.07978773f, -0.03657215f, 
    -0.07137199f, 0.03098303f, -0.06701654f, -0.06475319f, -0.03610800f, -0.07564870f, -0.07872760f, -0.10111420f, 
    -0.00384064f, -0.04281979f, -0.04113342f, -0.06886390f, 0.01872419f, 0.03653045f, -0.02765188f, -0.03555757f, 
    -0.19476904f, -0.10487986f, -0.09196023f, -0.02131251f, -0.01552681f, -0.04762632f, 0.01412893f, -0.06440669f, 
    -0.06083034f, -0.01684976f, 0.04179671f, -0.12829685f, -0.08062731f, -0.02268009f, -0.04527915f, -0.08472419f, 
    -0.06959525f, -0.03767389f, -0.00932995f, -0.03492012f, -0.03260674f, -0.02638002f, 0.01273508f, -0.06386074f, 
    -0.08483444f, 0.13827579f, -0.14485876f, 0.14362864f, 0.08763301f, 0.00975196f, -0.00027105f, 0.01780631f, 
    0.01093931f, 0.03676036f, 0.00851600f, -0.07270972f, 0.09600070f, 0.14655665f, 0.00836442f, 0.23123586f, 
    0.02099089f, 0.00552552f, 0.02006569f, -0.05976666f, -0.01865627f, -0.00840738f, -0.02679210f, -0.03530111f, 
    0.21031684f, -0.02645452f, 0.12870425f, -0.09619820f, 0.04751125f, -0.00857733f, -0.00665613f, -0.07410432f, 
    0.03995978f, 0.05286656f, 0.03687311f, -0.07286248f, -0.04965381f, -0.05799532f, -0.13498853f, -0.12094375f, 
    -0.05989823f, 0.03471392f, -0.04590819f, -0.04570005f, -0.06860472f, -0.04362239f, 0.09879519f, -0.04892352f, 
    -0.16199560f, -0.07043441f, -0.11114449f, 0.14024357f, -0.03406187f, -0.03178464f, -0.00547341f, -0.03451719f, 
    0.02688795f, -0.06123625f, -0.03181884f, 0.01622767f, -0.02506944f, 0.08369932f, 0.08999900f, 0.18777180f, 
    0.19119522f, 0.00313081f, -0.00258579f, 0.04265107f, -0.01815170f, -0.02261221f, 0.05309934f, -0.03763016f, 
    -0.14155972f, 0.11367464f, -0.03340112f, 0.11587935f, -0.07384948f, -0.01987941f, -0.03184941f, -0.03245285f, 
    -0.06762471f, 0.02621422f, 0.05178191f, -0.00850569f, -0.19597299f, -0.05504250f, 0.08461511f, -0.06671799f, 
    0.09838542f, 0.00703030f, -0.01913017f, -0.07487101f, -0.05041340f, 0.00053128f, 0.03720880f, 0.03221954f, 
    0.26386201f, -0.13919756f, 0.15786281f, -0.04205511f, -0.02362393f, 0.02576593f, -0.06644996f, -0.03503731f, 
    -0.08872161f, 0.10363183f, -0.06294903f, 0.01929523f, 0.10658501f, -0.53310680f, 0.04143591f, 0.01585785f, 
    -0.01719492f, -0.07580015f, -0.01324798f, -0.02844221f, -0.03977863f, 0.06581224f, -0.04074439f, -0.05333139f, 
    0.09570268f, 0.13487467f, 0.10531180f, 0.12929697f, 0.07491002f, -0.00798028f, 0.00009419f, -0.01045795f, 
    -0.02646547f, 0.01045077f, -0.07958109f, -0.02937480f, 0.02908196f, 0.17212427f, 0.04986176f, 0.12157123f, 
    0.08232022f, 0.03355789f, 0.05436523f, -0.02365490f, 0.04625870f, 0.04099004f, -0.03594258f, 0.00181483f, 
    0.11403611f, -0.35416940f, 0.08820525f, 0.12527068f, 0.00759180f, -0.01405069f, 0.00493706f, -0.06751239f, 
    -0.04047647f, -0.02320290f, -0.07030465f, -0.01989966f, 0.22536539f, 0.14715055f, 0.10284709f, 0.15385868f, 
    0.13559335f, 0.03017632f, 0.00902159f, 0.00551997f, -0.04034777f, -0.07698707f, -0.07866891f, -0.10915678f, 
    0.09490962f, 0.21209235f, 0.12729393f, 0.02428406f, -0.04889895f, 0.01127600f, 0.03425543f, 0.00035622f, 
    -0.02710009f, 0.03242376f, 0.03408550f, 0.01879980f, -0.11162402f, 0.08395560f, 0.05013226f, 0.04859189f, 
    0.00097507f, 0.02536663f, 0.05396646f, -0.03435013f, 0.04516748f, 0.03257852f, 0.01930638f, -0.09757320f, 
    0.01989113f, 0.02927907f, 0.04173362f, 0.10365206f, -0.05219068f, -0.10260326f, 0.01280080f, -0.00812076f, 
    -0.08148450f, -0.00015113f, -0.00410931f, -0.10148525f, -0.03859676f, 0.11525445f, 0.13904215f, -0.00289845f, 
    0.04726402f, 0.06197536f, -0.03140638f, 0.01542959f, -0.06268127f, 0.01991543f, -0.06643105f, 0.02757071f, 
    0.06529440f, 0.08057251f, -0.03500320f, 0.06267472f, -0.08191410f, -0.03726532f, -0.07407017f, -0.05283773f, 
    -0.03710994f, -0.10073619f, -0.06176325f, -0.04249268f, 0.09446467f, -0.08324216f, 0.05775098f, 0.09695726f, 
    0.05844766f, -0.05045006f, -0.05525643f, -0.03038784f, 0.04770363f, -0.04197355f, 0.03212357f, -0.02533714f, 
    -0.03279167f, -0.00998633f, -0.06574135f, 0.01500865f, -0.05097865f, -0.07618466f, -0.13225819f, -0.04148768f, 
    -0.12952006f, 0.04001726f, -0.05316557f, -0.00238514f, 0.22231026f, -0.00003188f, 0.22623990f, 0.02293322f, 
    0.09754741f, 0.06203331f, 0.01584389f, 0.08030365f, -0.04185346f, 0.10733242f, 0.08118111f, 0.03841082f, 
    0.07549424f, 0.03058997f, -0.08574073f, -0.03129075f, -0.00096773f, -0.02407453f, -0.01763275f, 0.02492731f, 
    -0.03269058f, -0.01945486f, -0.01784878f, -0.09264116f, 0.13342319f, 0.16270980f, 0.04879904f, 0.20537882f, 
    0.08941469f, 0.03024551f, 0.01719735f, -0.02030543f, -0.02685279f, -0.07239547f, -0.03787326f, -0.07297545f, 
    0.05404914f, 0.10468930f, 0.22375728f, 0.04569038f, 0.00849055f, 0.04697890f, 0.00521924f, -0.01603420f, 
    -0.09948963f, 0.08574316f, -0.06452809f, -0.02795606f, -0.12711036f, 0.04440822f, 0.04904673f, -0.03256410f, 
    -0.01360821f, 0.02807126f, -0.03452177f, -0.09023162f, -0.05784137f, -0.00097845f, 0.00708784f, -0.04094246f, 
    -0.17646821f, 0.06048838f, 0.08580870f, -0.04554176f, 0.03063794f, 0.00939633f, -0.00374680f, -0.04961310f, 
    -0.01437562f, 0.00852791f, 0.09479946f, -0.06460293f, 0.33052406f, -0.00781069f, -0.03896556f, 0.03319673f, 
    -0.11712987f, -0.08730961f, 0.01802377f, -0.06397323f, 0.00432444f, 0.00689123f, -0.03853228f, -0.03055935f, 
    -0.00960126f, 0.13322097f, -0.05143374f, -0.05762571f, -0.12259177f, 0.03337034f, -0.01015104f, -0.08367833f, 
    -0.06960720f, 0.06061781f, 0.01005133f, -0.07085956f, 0.02668187f, -0.19895090f, 0.06404992f, 0.12015464f, 
    0.00019088f, -0.03026495f, -0.02424473f, 0.01140009f, -0.04133316f, 0.00821809f, 0.09094596f, 0.04212393f, 
    -0.07206047f, -0.01841698f, -0.00427658f, -0.15278323f, -0.01728223f, 0.00406633f, -0.01878239f, -0.05147287f, 
    -0.00105093f, -0.04149642f, -0.02922240f, -0.10575443f, 0.02379235f, 0.00260773f, -0.00375097f, 0.18133062f, 
    -0.10404689f, -0.08709239f, -0.07567873f, -0.01181897f, -0.06147158f, -0.05378816f, -0.00769957f, -0.03363867f, 
    -0.08749674f, 0.00509875f, -0.06562041f, -0.01160054f, -0.10632246f, 0.00285702f, -0.02886076f, -0.05706340f, 
    -0.04790640f, 0.02313698f, 0.01757162f, 0.05681810f, -0.04981669f, -0.06127078f, 0.01064685f, 0.02292051f, 
    -0.02133289f, -0.10049102f, 0.04245441f, -0.08605228f, -0.02085332f, -0.02156254f, 0.01802206f, -0.04281109f, 
    -0.10942777f, 0.16640095f, 0.05592161f, 0.00598395f, -0.01154540f, 0.01330276f, 0.00904343f, -0.00154654f, 
    0.05381455f, 0.10304017f, 0.01477960f, -0.05040752f, -0.04475835f, 0.06633942f, 0.03715947f, 0.20569980f, 
    0.07757927f, -0.06742325f, -0.08654406f, 0.06309126f, -0.00093931f, -0.07709212f, -0.00304534f, -0.06428903f, 
    -0.35202339f, 0.02078450f, -0.04480858f, 0.03649930f, -0.05476215f, -0.11689703f, 0.00799856f, 0.00126932f, 
    -0.12901765f, 0.11468375f, 0.01413271f, 0.01624230f, 0.15076977f, -0.06518973f, 0.18629366f, -0.03713155f, 
    0.03368431f, -0.02797451f, -0.03610361f, -0.01376340f, -0.05114528f, 0.03082057f, -0.03807746f, -0.02675940f, 
    0.10723741f, 0.15451784f, 0.06727557f, 0.08308594f, 0.10687178f, -0.00991971f, 0.00532069f, -0.03165008f, 
    -0.06929829f, 0.07050434f, -0.01859666f, 0.00783910f, 0.18573730f, -0.29838866f, 0.18017761f, 0.05726491f, 
    0.04549831f, -0.03273959f, -0.01867993f, -0.04221611f, 0.00881967f, 0.01126432f, -0.08478177f, -0.06516266f, 
    -0.28146926f, -0.01874313f, -0.21764509f, -0.19496994f, -0.02275639f, -0.04939200f, 0.00556030f, 0.01465178f, 
    -0.05867057f, 0.01288807f, -0.00488728f, 0.01740780f, -0.24939524f, 0.06239296f, 0.02362411f, 0.02124075f, 
    -0.07969603f, 0.01067113f, -0.03157247f, -0.02359013f, -0.03501161f, -0.01947227f, -0.02248820f, -0.05081738f, 
    -0.02926613f, -0.23764835f, -0.02877208f, -0.06099289f, -0.03866928f, -0.03141775f, 0.02268661f, 0.00267428f, 
    -0.07569455f, -0.00060070f, -0.00514356f, -0.01009741f, -0.07042588f, 0.00513922f, -0.07644390f, -0.20157078f, 
    -0.00777273f, 0.01911104f, 0.01256201f, -0.08205863f, 0.00282537f, 0.00237069f, -0.00987429f, -0.01394156f, 
    0.08866421f, -0.03534728f, -0.04091292f, -0.05352455f, -0.08247331f, 0.02037040f, -0.06288169f, -0.09021956f, 
    -0.04157716f, -0.05302632f, -0.07001427f, -0.01907141f, -0.00854299f, 0.15316609f, -0.11988839f, 0.13674000f, 
    -0.05033168f, -0.07130775f, -0.04732741f, 0.08647852f, -0.01696129f, -0.03760863f, -0.06314319f, -0.08033647f, 
    0.09150223f, 0.08545175f, -0.03287409f, 0.09463426f, -0.07389791f, -0.01499391f, -0.03474800f, -0.05078417f, 
    -0.04308302f, -0.04233769f, -0.02276698f, -0.08608636f, 0.18701245f, 0.17679439f, 0.25526574f, 0.05032364f, 
    -0.01278890f, -0.01334473f, 0.01650762f, -0.02962584f, 0.01046702f, 0.03536471f, -0.05087288f, -0.06843502f, 
    0.17762260f, -0.03923554f, 0.05512332f, -0.00236719f, 0.07433692f, -0.01920697f, -0.04638362f, -0.03482438f, 
    -0.03364570f, -0.01303169f, -0.01523156f, -0.04986227f, -0.00710162f, 0.03064067f, -0.10882828f, 0.27365294f, 
    0.01674416f, -0.03783353f, -0.07532922f, 0.00652825f, -0.05424234f, -0.01459333f, 0.05270189f, -0.01006209f, 
    -0.06603522f, -0.04972154f, -0.07964478f, -0.10606143f, -0.00502343f, -0.01190943f, -0.01220401f, 0.00462560f, 
    -0.06491238f, -0.03986725f, 0.03880293f, -0.07092674f, 0.19611752f, -0.27204981f, 0.16241314f, -0.02089234f, 
    -0.02848742f, 0.00467623f, -0.07705437f, -0.02688426f, -0.11898594f, -0.00697397f, -0.00055499f, -0.00784013f, 
    0.07955325f, -0.12333508f, -0.00721592f, -0.07114854f, -0.01937552f, -0.00111437f, -0.02151025f, -0.07757214f, 
    -0.00476582f, -0.00933685f, 0.08271719f, -0.02085869f, 0.00910651f, -0.08127977f, -0.02488441f, -0.10480890f, 
    -0.02813096f, -0.01594504f, -0.01157111f, -0.06986486f, -0.00251329f, -0.05377311f, -0.06860532f, 0.00591492f, 
    0.09947011f, -0.21409102f, 0.06854762f, -0.00417611f, -0.08301254f, -0.03026316f, -0.03184166f, -0.02563612f, 
    0.02560167f, 0.06768869f, -0.00390379f, -0.06800734f, -0.00848699f, -0.02112882f, 0.05765870f, -0.14136520f, 
    0.12271365f, 0.04827629f, 0.01819575f, -0.04317243f, -0.04514365f, 0.02181149f, -0.02500962f, 0.00537206f, 
    0.03866225f, -0.00622534f, 0.03033407f, 0.17366824f, -0.10073679f, -0.04510424f, 0.02597792f, 0.01825018f, 
    0.02516917f, 0.04971276f, -0.23963088f, -0.00524045f, -0.15558049f, 0.00537723f, -0.13762306f, -0.13052674f, 
    -0.02636514f, -0.11214298f, 0.09182696f, -0.08476262f, -0.02266941f, 0.01107114f, -0.03613381f, 0.01280282f, 
    0.21733649f, 0.14171422f, -0.29038775f, 0.04969438f, 0.05318290f, 0.03163801f, -0.00820420f, -0.05570212f, 
    -0.07386809f, -0.01954767f, -0.12403166f, 0.00397775f, 0.02525108f, -0.05142998f, 0.00816865f, 0.09022007f, 
    0.01194561f, -0.10829136f, -0.06442446f, 0.00508505f, 0.10618822f, 0.08879027f, 0.03728042f, 0.07143824f, 
    -0.06741218f, 0.14545651f, 0.02149075f, -0.02236003f, -0.02587302f, -0.00260087f, 0.02194679f, -0.11986162f, 
    0.05532826f, 0.07848649f, -0.00497352f, 0.05801368f, 0.22553776f, -0.09597624f, -0.02856571f, 0.06593638f, 
    0.01912699f, -0.08612574f, 0.00118015f, 0.00031389f, 0.08245414f, -0.05411906f, -0.13448344f, -0.12560326f, 
    0.05427162f, 0.02823889f, 0.04708652f, 0.06806202f, 0.01998149f, -0.02724459f, 0.04523427f, -0.10878967f, 
    -0.05989908f, 0.02920250f, -0.12535396f, 0.00723396f, 0.05791044f, -0.04502531f, -0.04025972f, 0.08679608f, 
    0.09892470f, -0.00897067f, -0.06055105f, -0.08415640f, -0.02167142f, 0.05816315f, 0.01896279f, 0.10823639f, 
    0.02391041f, 0.16792335f, -0.04994543f, -0.11800352f, 0.02354741f, -0.08306316f, -0.11947349f, 0.01136258f, 
    0.02081402f, 0.00068340f, -0.08557597f, 0.11236102f, -0.13020025f, 0.10931426f, 0.15089534f, -0.06797719f, 
    -0.07738677f, 0.04264930f, -0.10857897f, 0.10193146f, 0.06232015f, -0.01407477f, 0.04174456f, -0.11955100f, 
    -0.24711798f, -0.09570798f, 0.01960969f, -0.18415947f, 0.06623257f, -0.07445391f, -0.00560731f, 0.08529023f, 
    0.04814707f, 0.00200580f, -0.11173264f, 0.03277762f, 0.11559764f, -0.01569184f, -0.08469990f, 0.15011199f, 
    0.06599489f, 0.01924020f, 0.07711764f, -0.00161932f, -0.00313388f, 0.10409015f, 0.01632717f, 0.01649163f, 
    0.26199996f, 0.06333477f, -0.18514898f, -0.10787699f, -0.02020177f, -0.01015270f, -0.03459765f, 0.04784489f, 
    0.00760282f, -0.08135162f, -0.04635119f, 0.06776014f, -0.07333340f, 0.15824878f, -0.12058269f, 0.12877117f, 
    0.00150084f, -0.07635487f, -0.11734675f, -0.09028615f, -0.00646013f, -0.01737085f, 0.05157403f, 0.01096768f, 
    -0.05858647f, 0.06742536f, -0.05063644f, -0.08335816f, 0.00097403f, -0.08074003f, -0.08068947f, 0.06923746f, 
    0.10773353f, 0.05248198f, 0.04742852f, -0.21985587f, -0.02256620f, -0.16469675f, 0.03649172f, 0.06044434f, 
    0.00255802f, -0.05322616f, -0.17592922f, 0.02825166f, 0.08236605f, 0.04378321f, -0.07572153f, -0.14552388f, 
    -0.19747636f, -0.01465928f, 0.06733143f, -0.17265362f, 0.03519708f, -0.06035021f, -0.01557169f, 0.04515235f, 
    0.01543696f, -0.04739854f, -0.11131331f, 0.03176324f, 0.04376803f, -0.14918685f, -0.12578806f, 0.10117273f, 
    0.04189192f, -0.00207086f, 0.01781510f, 0.03930033f, 0.09550235f, 0.08915645f, 0.08130710f, 0.11322390f, 
    -0.12278277f, 0.23192115f, -0.05948076f, -0.17100918f, 0.01367302f, -0.01094810f, 0.00027344f, -0.07001423f, 
    -0.01829523f, -0.04197140f, 0.08756572f, 0.06400146f, -0.06428014f, -0.01543309f, 0.09060434f, -0.08417063f, 
    0.07140365f, -0.05544460f, -0.01188843f, -0.03997277f, -0.03032929f, -0.01712810f, 0.00605553f, -0.11159836f, 
    0.16133167f, 0.01594766f, 0.07632982f, 0.11576524f, -0.02283403f, -0.03054393f, -0.16273233f, -0.03437748f, 
    -0.04408647f, -0.01011059f, -0.08265499f, -0.10063462f, 0.10146371f, -0.08748809f, 0.04966588f, -0.16530387f, 
    -0.03164198f, -0.01115507f, 0.11178551f, -0.05145744f, -0.00041313f, 0.04443584f, -0.01619141f, 0.04072261f, 
    0.07039992f, 0.09392976f, 0.02862394f, 0.05652666f, -0.08082403f, 0.02134467f, -0.09729081f, 0.20849907f, 
    0.05291953f, -0.07062842f, -0.16009676f, -0.08369026f, -0.14669795f, 0.00492058f, 0.14230937f, 0.08156518f, 
    -0.11713897f, 0.01981148f, -0.09822218f, -0.15087014f, -0.02362271f, -0.01150177f, -0.01376595f, -0.12370137f, 
    0.19583717f, 0.09052788f, -0.02664398f, -0.23867314f, -0.05508384f, 0.03799815f, 0.04641076f, -0.00539841f, 
    0.11072394f, -0.02256200f, 0.08544072f, 0.05628740f, -0.01166497f, -0.16961916f, 0.14539415f, 0.02800351f, 
    0.07792701f, 0.03745940f, -0.17327459f, -0.03251110f, 0.09468736f, 0.01178500f, 0.04578541f, 0.01319626f, 
    -0.05675964f, 0.14752249f, 0.00197633f, -0.05094082f, -0.07034872f, 0.04807868f, 0.00218998f, 0.00831614f, 
    0.06572364f, -0.00221145f, 0.05362494f, -0.06667332f, 0.06513872f, 0.00743799f, 0.10842412f, 0.07997447f, 
    -0.06834885f, 0.05327500f, -0.04445313f, -0.13673574f, -0.02329128f, -0.03928395f, 0.05926556f, -0.03524197f, 
    -0.29792053f, -0.19193868f, -0.08963685f, -0.13343976f, 0.01174640f, 0.00415121f, -0.00688673f, 0.09087127f, 
    0.09355509f, 0.01875829f, 0.08766709f, -0.04521668f, -0.09311780f, -0.05197346f, 0.17354225f, -0.14592244f, 
    -0.13221435f, -0.00091881f, 0.06646713f, -0.10194924f, -0.01950083f, -0.11923794f, -0.04469644f, 0.00578228f, 
    0.16598266f, -0.13882199f, 0.00526290f, 0.02637485f, 0.09762638f, -0.09131511f, -0.03543489f, -0.08690433f, 
    -0.00548580f, 0.05613064f, 0.03369624f, -0.04211121f, -0.14152186f, 0.07628365f, 0.15010779f, 0.01245672f, 
    -0.08223930f, 0.03185791f, 0.07406804f, -0.11065949f, -0.08403031f, 0.03953100f, -0.02582716f, 0.07080916f, 
    0.03916321f, -0.09643465f, 0.11459821f, -0.01558552f, -0.03586512f, 0.01451938f, 0.05284563f, -0.03383677f, 
    -0.03407456f, -0.11695471f, -0.02938474f, 0.03823694f, -0.25368902f, 0.14150095f, 0.11825594f, 0.00027656f, 
    -0.10312205f, -0.00825943f, -0.08481850f, -0.04367347f, 0.03186895f, -0.02746451f, 0.09694644f, -0.00961772f, 
    -0.10941489f, -0.27766788f, 0.11051013f, 0.04072349f, 0.02068570f, -0.13180807f, -0.09716891f, 0.06754792f, 
    0.03473712f, -0.02588700f, 0.03380526f, -0.00285227f, 0.03465766f, -0.24632627f, 0.04172402f, -0.16473402f, 
    0.12093540f, -0.13809691f, -0.00363257f, -0.01001063f, -0.06259035f, 0.02220986f, 0.02059329f, 0.04947478f, 
    0.13429132f, 0.00753643f, 0.12916605f, 0.14283521f, 0.03679212f, 0.02476778f, -0.02556726f, -0.08582950f, 
    0.03350208f, -0.01676201f, 0.06496958f, -0.06864774f, -0.22883466f, -0.06006452f, -0.28580356f, -0.28858274f, 
    0.02227251f, 0.05586674f, 0.02009072f, -0.09214886f, 0.08309861f, 0.02363661f, 0.01574787f, 0.03823649f, 
    0.19181424f, -0.14977151f, 0.03461879f, 0.12107860f, 0.01716283f, -0.05162372f, -0.04436174f, -0.08102398f, 
    -0.03429496f, -0.01045478f, -0.03231977f, -0.04568626f, -0.08381137f, -0.06211665f, -0.23902933f, -0.16320387f, 
    -0.05555667f, -0.12089916f, 0.02589981f, 0.03435675f, 0.08405311f, 0.01657913f, 0.03908016f, -0.09703602f, 
    -0.08140754f, -0.07815436f, 0.00092106f, 0.01487203f, -0.02322257f, -0.01995058f, 0.06900728f, 0.00178111f, 
    0.08853770f, 0.02114330f, 0.00028012f, 0.01080126f, -0.00060381f, -0.11151462f, -0.06680090f, -0.10620049f, 
    0.01986297f, 0.01080603f, -0.07864219f, -0.01841874f, 0.04880202f, 0.08016183f, -0.00011895f, 0.05544643f, 
    0.01641571f, 0.09189420f, 0.04138050f, 0.12743601f, -0.05108553f, 0.02696692f, -0.14307305f, -0.11658969f, 
    0.01594461f, -0.14965998f, -0.02462141f, -0.06055921f, -0.16139549f, 0.09522265f, -0.13119070f, -0.20803207f, 
    -0.04119635f, 0.04464805f, -0.21731894f, -0.03507357f, -0.03786295f, 0.04792561f, 0.16002645f, 0.04792038f, 
    -0.02088157f, -0.13702890f, -0.08701243f, 0.17010714f, 0.10060493f, 0.11255477f, -0.03346503f, -0.09197173f, 
    0.05771816f, 0.03849020f, 0.02404750f, -0.01455750f, -0.10226383f, -0.01847267f, -0.12806106f, -0.17647678f, 
    -0.04267934f, -0.01853759f, 0.01184884f, -0.15210499f, 0.05696656f, 0.01746618f, -0.00346113f, 0.03175124f, 
    0.00511120f, -0.11364992f, 0.03314761f, -0.22373277f, 0.05780244f, -0.02777512f, -0.12184142f, 0.03710173f, 
    0.01447946f, -0.13992746f, 0.03105798f, -0.09982042f, 0.01761752f, -0.11345478f, -0.10578896f, -0.09009682f, 
    0.03934607f, -0.07239418f, -0.05179083f, -0.08632594f, 0.02301017f, 0.07704084f, 0.02079233f, 0.10791320f, 
    0.08695561f, -0.11108973f, -0.04574636f, 0.17718162f, 0.08786176f, 0.03066863f, 0.03388106f, -0.00637319f, 
    -0.01273698f, -0.00860608f, 0.10861785f, 0.09681202f, 0.01845896f, -0.01361461f, -0.02209714f, 0.14560084f, 
    -0.00333738f, 0.03256965f, 0.06167607f, -0.03898191f, 0.03834417f, 0.03169767f, 0.04423892f, -0.06229350f, 
    -0.06686522f, -0.09900647f, -0.10145754f, 0.05726133f, 0.09855565f, 0.01368312f, -0.07404657f, -0.03794001f, 
    0.06473086f, 0.02290626f, 0.07037247f, -0.03219446f, 0.08516404f, -0.04325465f, 0.09709910f, 0.13381037f, 
    0.05744044f, -0.12635881f, -0.03605779f, 0.00228513f, 0.00936570f, 0.08361520f, 0.05850641f, -0.09604735f, 
    -0.15420595f, -0.01847207f, -0.01119723f, -0.07386758f, -0.05537801f, -0.04424012f, 0.07263470f, 0.01165462f, 
    0.02141740f, 0.04861256f, 0.01616355f, 0.09357812f, 0.20290403f, 0.34082052f, -0.09468467f, -0.08385704f, 
    0.01262743f, -0.00126917f, 0.05997458f, 0.02054730f, 0.06637153f, 0.03100276f, 0.10613368f, 0.12015630f, 
    -0.26274723f, 0.10533877f, -0.20122840f, -0.24193634f, -0.07185542f, 0.02196362f, -0.06250425f, 0.01187659f, 
    0.08053444f, 0.05233627f, -0.01145790f, -0.02882017f, -0.05792160f, 0.11000566f, 0.08453345f, -0.04621292f, 
    0.00766338f, -0.04982589f, 0.00818152f, -0.03879536f, -0.03400287f, -0.00979173f, 0.00683830f, 0.11269138f, 
    0.09730171f, 0.23412682f, -0.21112218f, 0.07115460f, 0.07356675f, 0.02729333f, -0.02388966f, 0.05216694f, 
    -0.07112549f, 0.02632218f, -0.07442351f, 0.15423521f, 0.07632983f, -0.15579171f, -0.21969484f, -0.25712487f, 
    -0.00476855f, -0.16819468f, 0.02626034f, 0.05673449f, 0.09120955f, 0.05651557f, -0.12878069f, 0.04894173f, 
    0.06727505f, -0.03441282f, -0.08840419f, 0.07409377f, 0.09761980f, 0.01365261f, -0.03595198f, -0.03348785f, 
    -0.04752102f, 0.09230573f, 0.01268279f, -0.07105786f, 0.03422904f, -0.02612528f, 0.01085955f, -0.01473376f, 
    -0.00719231f, -0.02208625f, -0.02808973f, -0.12069036f, -0.05917691f, -0.04493977f, 0.04367791f, 0.02298643f, 
    0.07933231f, 0.00409133f, 0.04058198f, 0.09674583f, 0.08779628f, -0.09659777f, -0.03352689f, -0.10957363f, 
    -0.04291302f, 0.03642287f, -0.02095325f, -0.00171864f, 0.17035727f, -0.03991501f, -0.03493964f, 0.16220273f, 
    0.10143127f, 0.01171112f, -0.00749416f, -0.05647828f, 0.04637228f, -0.07119217f, 0.10415818f, -0.03624148f, 
    -0.01054595f, -0.12569495f, 0.10070524f, 0.01799135f, 0.05005639f, -0.13103744f, -0.01448986f, -0.10011016f, 
    0.04600931f, 0.03865190f, -0.02604160f, 0.10702629f, -0.12728998f, -0.11969185f, -0.08493363f, 0.08577441f, 
    -0.07245521f, -0.04873678f, 0.07365037f, -0.02369991f, 0.01444965f, 0.01019746f, -0.07249308f, 0.04188186f, 
    0.16466776f, 0.02978630f, -0.18644927f, -0.01250988f, 0.10298987f, -0.04401327f, -0.08868338f, 0.12954170f, 
    0.02499140f, -0.00571084f, 0.15799280f, -0.02218398f, -0.01624910f, -0.10868575f, -0.21021368f, 0.21269497f, 
    0.06285037f, 0.05446716f, -0.05208132f, 0.01880721f, 0.11659800f, 0.01513006f, 0.04801402f, 0.01282289f, 
    0.18111289f, 0.05543141f, 0.18448158f, 0.20200039f, 0.03269493f, -0.05187281f, -0.13745160f, 0.11648070f, 
    0.03138329f, -0.05280456f, 0.01613379f, -0.02031096f, -0.26596141f, 0.21173640f, -0.06022307f, -0.07152446f, 
    0.05223325f, 0.08374624f, -0.09779581f, 0.07383613f, 0.09815852f, -0.00188840f, -0.06913190f, 0.00669346f, 
    0.18184675f, 0.34867281f, -0.23379031f, 0.23803721f, 0.09940221f, -0.07442727f, 0.00624751f, 0.10317883f, 
    -0.00357218f, 0.00554714f, -0.07781674f, 0.00414259f, -0.00031496f, 0.02402176f, 0.14595300f, -0.14111833f, 
    0.09918134f, 0.00422827f, -0.03020918f, -0.11186605f, 0.17888562f, -0.04149058f, -0.02719446f, 0.12377508f, 
    0.11366444f, 0.09519737f, -0.14011545f, -0.13743274f, 0.03081337f, 0.11465413f, -0.23858698f, -0.00544779f, 
    0.13040718f, -0.03257333f, 0.13590321f, -0.11750356f, 0.02332332f, -0.07198041f, 0.15418227f, -0.02297098f, 
    0.04344655f, 0.08855700f, -0.03224680f, -0.01843395f, 0.07991362f, -0.00694978f, 0.10859012f, -0.02687722f, 
    -0.30959350f, -0.16570216f, 0.27918741f, -0.28951201f, -0.03282537f, 0.04475980f, 0.06493153f, 0.05604389f, 
    0.10459492f, -0.22658800f, 0.03396358f, 0.01264982f, -0.04965820f, 0.24730623f, 0.19203307f, -0.09666171f, 
    0.07184588f, 0.05821343f, -0.03744093f, 0.03662529f, -0.05105283f, -0.01945835f, -0.04723929f, 0.06332734f, 
    -0.01491497f, -0.06562174f, 0.00404858f, 0.07236885f, -0.09191891f, 0.00448743f, 0.08273561f, -0.11919184f, 
    0.09569632f, -0.04857612f, -0.05380195f, -0.03500811f, -0.20731622f, 0.12906833f, 0.05934751f, -0.26325026f, 
    0.03738317f, 0.00011470f, 0.05668313f, -0.08745473f, -0.08708398f, -0.09925863f, 0.02722602f, -0.01248024f, 
    0.08298784f, 0.04384524f, 0.17072168f, 0.02836697f, 0.02584407f, 0.08594446f, -0.06314241f, 0.10323726f, 
    -0.03642978f, 0.01744932f, 0.11136644f, 0.06976282f, -0.07315502f, -0.41581911f, 0.13808438f, -0.03739999f, 
    0.00738312f, 0.02878153f, -0.02325740f, 0.10058437f, -0.11020222f, -0.12789741f, 0.03721047f, 0.04521953f, 
    -0.36451495f, 0.22242461f, -0.01457631f, -0.11676198f, 0.04855760f, 0.08877297f, -0.08464564f, 0.02832745f, 
    -0.08465514f, -0.13106254f, -0.04949179f, 0.18505380f, 0.04341624f, -0.23593183f, -0.07288153f, 0.26784849f, 
    -0.14166270f, -0.04132397f, 0.07443599f, -0.06700218f, -0.03645220f, 0.04393623f, -0.07457946f, 0.16738933f, 
    -0.10494174f, 0.00102937f, -0.02647782f, 0.11739071f, 0.07098042f, 0.04838738f, -0.01111479f, 0.00254003f, 
    -0.09117179f, 0.05833318f, 0.03783795f, 0.09663331f, 0.00756007f, 0.02058662f, 0.05669996f, -0.25185013f, 
    -0.02028191f, -0.04919694f, -0.09003660f, 0.03282073f, -0.02784372f, -0.02318808f, -0.08256424f, -0.03069047f, 
    -0.09819677f, -0.25182834f, 0.10685431f, 0.04530380f, -0.06104844f, 0.01715409f, -0.14248355f, -0.01257922f, 
    -0.02336973f, 0.08289224f, -0.06574142f, -0.00517710f, -0.29818329f, -0.06220877f, 0.05124386f, 0.28198147f, 
    0.07187955f, -0.05892352f, -0.05133440f, 0.06935568f, 0.01491510f, 0.03989699f, 0.03502711f, -0.04346994f, 
    0.39818078f, -0.60752660f, 0.11226799f, -0.13419950f, 0.08185576f, 0.00931957f, -0.04000634f, 0.04884878f, 
    -0.10893141f, -0.00454287f, 0.17537275f, -0.02705479f, -0.33040833f, -0.11051036f, -0.03557296f, 0.06236402f, 
    0.08134374f, 0.04435805f, -0.04635126f, -0.01759795f, 0.00667904f, -0.08783563f, 0.11397082f, 0.07040814f, 
    -0.02500534f, 0.12118170f, -0.04918611f, 0.06548152f, 0.13847584f, 0.02732262f, -0.00014339f, 0.00671830f, 
    0.00426715f, 0.11959458f, 0.00313833f, -0.00399415f, 0.08907678f, -0.18282795f, -0.02719154f, 0.07801445f, 
    0.04392577f, -0.03639105f, 0.14786743f, 0.12870698f, 0.07699551f, -0.03246953f, 0.09757383f, 0.00456342f, 
    0.28180364f, 0.02058837f, -0.04778534f, 0.00440838f, 0.05188872f, 0.05773361f, 0.08125564f, -0.01646529f, 
    -0.17242046f, 0.11621620f, -0.11401785f, 0.10172199f, -0.05543543f, -0.34333989f, 0.00024226f, -0.06625708f, 
    -0.07655735f, 0.01765469f, -0.00018284f, -0.00210535f, 0.02430293f, 0.16299489f, -0.08378560f, -0.01134412f, 
    -0.09495910f, 0.06499593f, -0.01180294f, 0.13408218f, -0.00633567f, 0.00438884f, -0.02625233f, -0.01205756f, 
    0.03726150f, 0.06879848f, -0.00930938f, -0.07298113f, 0.11277486f, -0.25317383f, -0.02921443f, -0.02919073f, 
    0.04781186f, 0.00906460f, -0.02109106f, -0.08151127f, -0.02297634f, 0.02164275f, 0.03598966f, 0.02520456f, 
    -0.12649049f, 0.04034911f, 0.02734702f, -0.20670253f, -0.07269733f, -0.01931387f, -0.04133366f, -0.05650314f, 
    -0.00340132f, 0.06302080f, -0.03004893f, -0.02538472f, 0.23150992f, -0.00561210f, -0.14104903f, 0.26712722f, 
    -0.04250277f, -0.03107691f, -0.11054820f, 0.16733505f, -0.16059557f, 0.09677656f, 0.03003105f, -0.02292847f, 
    0.22757633f, 0.23240168f, -0.07977972f, -0.17013673f, -0.04960973f, 0.01211079f, 0.04985414f, 0.04579623f, 
    0.02857190f, -0.02339512f, 0.05188790f, 0.01709066f, 0.07169718f, -0.06402889f, -0.04455315f, 0.01799111f, 
    -0.00685199f, -0.12689692f, -0.03685496f, 0.14066969f, 0.12528330f, -0.07224776f, 0.10996796f, 0.01343406f, 
    -0.15068921f, -0.18777888f, -0.01794240f, 0.01826186f, 0.04069673f, 0.01125160f, 0.00052650f, -0.08910508f, 
    0.05335416f, 0.13273931f, -0.09135801f, 0.03713158f, 0.30848211f, 0.07024960f, -0.13116038f, 0.18598334f, 
    -0.02665799f, 0.10607320f, 0.00502765f, 0.02769525f, -0.07073358f, -0.11631541f, 0.07155248f, -0.03205625f, 
    -0.15080115f, 0.08273810f, -0.07202542f, 0.11915706f, -0.02298889f, -0.02268584f, 0.01064857f, -0.02489786f, 
    -0.12577918f, 0.02824965f, -0.02117456f, -0.15676756f, 0.28734264f, 0.17296728f, -0.18852979f, -0.00154629f, 
    0.01016149f, -0.06084106f, 0.04205903f, 0.04471320f, -0.06106635f, -0.00672299f, 0.02806174f, -0.08770355f, 
    -0.35033616f, 0.48865166f, -0.04219955f, -0.11661728f, 0.12764011f, 0.01223006f, -0.02386010f, -0.07482283f, 
    -0.02627099f, -0.04562518f, 0.01520296f, -0.07895383f, -0.16474099f, -0.01577799f, -0.01873707f, -0.19295889f, 
    0.02209848f, 0.07124928f, 0.02971680f, -0.09664829f, -0.03569776f, -0.09045164f, 0.11777934f, -0.08822781f, 
    -0.19580191f, 0.06019806f, -0.10875598f, -0.03789577f, 0.10693233f, 0.02688396f, -0.04171478f, 0.02267724f, 
    0.02115708f, -0.10703152f, 0.07125627f, 0.11490846f, -0.08092369f, 0.06780279f, 0.11245420f, -0.06736430f, 
    0.00598611f, -0.00243412f, 0.03852115f, -0.05448964f, -0.07670189f, 0.10274261f, 0.02666466f, 0.04159966f, 
    0.02043144f, -0.02705690f, -0.07205883f, -0.12788972f, -0.06505603f, -0.04588946f, -0.01271734f, -0.10486512f, 
    -0.04465501f, -0.04811409f, 0.06898586f, 0.04300419f, 0.14163582f, -0.00481822f, 0.00236107f, -0.06011461f, 
    0.04228835f, 0.00629343f, 0.16646846f, -0.05353187f, -0.08675541f, -0.22862668f, -0.18442143f, 0.01295725f, 
    -0.31598538f, 0.06646093f, 0.06069515f, 0.04902823f, 0.16388728f, 0.04706451f, 0.00363955f, 0.10614239f, 
    0.04256665f, 0.13561106f, -0.00671051f, -0.05029334f, -0.06573649f, -0.07464740f, -0.05717183f, -0.12763812f, 
    0.00457577f, 0.01168709f, 0.08766460f, 0.03366967f, 0.04203865f, 0.10065819f, -0.14421691f, -0.05842517f, 
    -0.14574340f, 0.15100443f, -0.25884631f, -0.39479330f, 0.14179771f, 0.00574180f, -0.05107352f, 0.08088567f, 
    -0.04843070f, 0.03218415f, -0.00097178f, -0.10709493f, 0.30726182f, -0.21256143f, -0.25421041f, -0.00950606f, 
    0.01835262f, 0.01473051f, 0.08558626f, -0.06050586f, 0.02240230f, -0.07196929f, -0.06232334f, -0.09442868f, 
    -0.07191295f, -0.08081452f, 0.01490137f, -0.16876864f, -0.04850054f, -0.02240598f, -0.03577682f, 0.02423289f, 
    0.08310285f, 0.03313573f, 0.16755314f, 0.16590738f, 0.19860156f, -0.05202444f, -0.22645958f, 0.03241298f, 
    -0.09430841f, 0.01744691f, 0.02095213f, 0.07148154f, 0.07293418f, -0.05893595f, 0.04285554f, -0.07280618f, 
    -0.19443175f, 0.01166267f, 0.12162768f, -0.31815931f, 0.05606012f, 0.02200747f, -0.16893530f, -0.00259098f, 
    -0.04688565f, -0.04734911f, -0.22918260f, -0.04367500f, -0.40717292f, 0.04943483f, -0.31444338f, -0.14730890f, 
    0.03321159f, -0.07263730f, 0.05137986f, 0.05037855f, -0.07721742f, 0.00342926f, -0.05959137f, 0.00313340f, 
    0.03841829f, -0.24464962f, -0.02577065f, -0.15958416f, 0.04644325f, 0.08552214f, -0.05319447f, -0.05991115f, 
    -0.07882091f, -0.14133331f, -0.01649217f, -0.11539742f, -0.00338363f, 0.03233282f, -0.01104223f, -0.03839014f, 
    0.12922020f, 0.00981859f, 0.04995461f, -0.05688799f, -0.04063905f, -0.08561678f, -0.07030566f, 0.02642858f, 
    -0.18930113f, 0.17459060f, -0.00899772f, -0.12980279f, 0.06985785f, -0.03569835f, 0.00567275f, 0.00574632f, 
    -0.01663761f, 0.02257859f, 0.00207559f, -0.09008025f, 0.13172296f, 0.13401783f, 0.29953900f, -0.18083639f, 
    -0.03081910f, -0.14631492f, 0.01105579f, -0.10879495f, 0.02901397f, 0.06278419f, 0.11011151f, -0.03006121f, 
    -0.27180111f, 0.13573991f, -0.08279486f, 0.20956112f, -0.00481350f, 0.05218302f, -0.11787295f, 0.04922320f, 
    0.01151180f, -0.04288060f, -0.04629625f, 0.03990216f, -0.18904665f, -0.09696820f, -0.00379386f, 0.02363567f, 
    -0.14136696f, -0.11043198f, -0.06732365f, -0.00597793f, -0.09364032f, -0.01959602f, 0.09293528f, 0.11786574f, 
    0.17885230f, -0.25956315f, 0.21397138f, -0.05438699f, -0.01448927f, -0.00097499f, -0.05274295f, -0.03631578f, 
    -0.03919277f, 0.03369065f, -0.04116184f, 0.05765885f, -0.04625363f, 0.18175580f, 0.07656668f, -0.08300179f, 
    -0.07515451f, 0.06754013f, 0.01490910f, 0.00191350f, -0.00490081f, -0.03803309f, 0.13241798f, -0.07830896f, 
    0.01337608f, -0.02976966f, -0.02724753f, 0.02957115f, -0.10607592f, 0.05305470f, 0.02201395f, -0.16630259f, 
    -0.12898888f, -0.00277737f, -0.07373529f, 0.00677554f, 0.42992833f, -0.27606544f, -0.23716338f, -0.14251202f, 
    -0.03766372f, 0.09160591f, -0.01017535f, 0.08443818f, 0.07475293f, -0.01001329f, 0.09740444f, -0.06743079f, 
    0.13941661f, -0.11999458f, 0.03297710f, 0.17218265f, 0.05678312f, -0.01102031f, -0.04867047f, 0.13907987f, 
    0.11437815f, -0.01980700f, 0.07442974f, -0.01080638f, -0.01801515f, 0.03807744f, -0.05892094f, -0.17518276f, 
    -0.00681003f, -0.00626135f, 0.04041385f, -0.11437976f, 0.02919508f, 0.09664769f, 0.04601214f, -0.02766666f, 
    0.25074947f, 0.07340588f, -0.04619798f, -0.03037446f, 0.01060199f, 0.02468737f, 0.01601493f, 0.06929780f, 
    0.06200497f, -0.07108188f, 0.04637027f, 0.05547991f, 0.01604026f, 0.08947860f, -0.01936953f, 0.09164553f, 
    0.09804133f, -0.05999484f, -0.01908938f, -0.11386798f, 0.01744094f, -0.06890421f, -0.00298529f, -0.01413034f, 
    0.34538573f, -0.05293071f, -0.09556213f, 0.13883695f, 0.01145788f, -0.07991882f, -0.02996206f, 0.15502355f, 
    0.02888749f, 0.09819414f, -0.10237096f, 0.19984111f, 0.31111783f, 0.11434583f, -0.05749447f, -0.07916329f, 
    0.02509810f, -0.00793043f, 0.07780790f, -0.03590412f, 0.09582033f, 0.03245833f, -0.01706140f, 0.04560139f, 
    -0.48604023f, -0.31369227f, 0.14073549f, 0.01117967f, 0.09923060f, 0.01987585f, 0.04086946f, -0.13472493f, 
    0.02612871f, -0.04653836f, -0.06691330f, 0.10222591f, -0.34031647f, -0.02111019f, -0.19623610f, -0.09129678f, 
    0.04721127f, -0.07879119f, -0.02694944f, -0.00362493f, 0.11302552f, -0.04378633f, 0.06103024f, 0.03283175f, 
    -0.05911259f, -0.04982366f, 0.14112180f, 0.02803406f, -0.01042821f, 0.04277685f, 0.06598914f, 0.12537116f, 
    0.02478452f, 0.13432761f, 0.10172873f, 0.03004008f, -0.10870955f, -0.01681279f, -0.04114902f, -0.12173740f, 
    -0.00889114f, -0.02683350f, -0.08399843f, -0.07642857f, -0.04757591f, -0.14753029f, -0.23760241f, -0.05828382f, 
    -0.12490061f, -0.07125029f, 0.09428052f, 0.01214612f, 0.04762198f, 0.00686602f, 0.08957963f, 0.03925868f, 
    0.11378332f, 0.02535138f, -0.00262406f, 0.03396181f, -0.37979001f, -0.19251217f, -0.02810139f, -0.08113170f, 
    0.04266194f, 0.03278704f, -0.00161316f, -0.03833676f, 0.01962834f, 0.00487959f, -0.02049496f, 0.05552672f, 
    -0.23764764f, -0.09994577f, -0.13403352f, -0.01220613f, 0.00654848f, -0.01535116f, 0.08809207f, -0.11369517f, 
    -0.07905427f, -0.00160061f, -0.00307910f, 0.00985066f, -0.02604678f, -0.06311193f, 0.03384203f, 0.04889138f, 
    0.00199366f, 0.02962637f, -0.00118117f, 0.04190543f, 0.08640705f, -0.02662092f, -0.00969421f, 0.02123288f, 
    0.00413394f, -0.00763963f, 0.04499913f, 0.16901708f, 0.05079236f, 0.06567565f, -0.00374626f, 0.11302172f, 
    -0.09199689f, 0.06600633f, 0.05473346f, 0.06633184f, -0.21583480f, -0.10956013f, -0.17152034f, -0.06179596f, 
    0.06840110f, -0.03459097f, 0.01506426f, -0.01337951f, 0.09055921f, 0.03741730f, -0.01414060f, 0.14425825f, 
    -0.36581981f, -0.06536987f, 0.04325466f, 0.01277538f, 0.12209255f, -0.08598046f, 0.01034804f, 0.02361719f, 
    -0.01370250f, -0.02256100f, 0.02056630f, 0.12411519f, -0.16265197f, 0.00526834f, -0.15443641f, 0.05819990f, 
    0.04376428f, -0.05143459f, -0.07161424f, -0.06576312f, -0.07054419f, -0.00879000f, 0.07125992f, -0.08050592f, 
    -0.06790785f, -0.02098968f, -0.12737469f, -0.06087856f, 0.16987215f, -0.08791331f, 0.07739634f, 0.04484483f, 
    0.15897828f, 0.01552092f, -0.00154472f, -0.06357429f, 0.23318736f, -0.05435186f, -0.04704464f, 0.15689343f, 
    -0.00981728f, -0.14676858f, -0.01731592f, 0.02533648f, 0.00967937f, 0.10794050f, -0.04995408f, -0.06191392f, 
    0.18952730f, 0.00832644f, -0.02625272f, -0.00429043f, 0.06182612f, 0.00165815f, -0.05981931f, -0.08130296f, 
    -0.04544295f, -0.08239546f, -0.09276787f, -0.02681307f, -0.02576317f, 0.17055014f, 0.00647270f, -0.15125197f, 
    -0.03666583f, -0.02241883f, -0.01599482f, 0.10185041f, 0.03613925f, -0.00602838f, 0.15480961f, 0.06942356f, 
    0.16289774f, 0.08756860f, 0.01403743f, -0.18693861f, 0.12223978f, 0.07769969f, 0.01847734f, -0.02114281f, 
    -0.02323192f, -0.08117379f, 0.11015423f, -0.02534679f, 0.06736749f, 0.04215868f, -0.04337877f, 0.00975085f, 
    -0.02912230f, -0.07259966f, 0.08108686f, -0.05061579f, -0.04811219f, -0.02040497f, 0.00883271f, -0.11005978f, 
    -0.26041520f, 0.12714934f, -0.18386604f, -0.14245494f, 0.00438247f, 0.10216614f, -0.11345244f, 0.05549713f, 
    0.15911473f, 0.05316724f, -0.07611088f, 0.01456841f, -0.08572575f, -0.00818858f, -0.16231860f, 0.01212138f, 
    -0.05001473f, -0.03968359f, 0.08867069f, 0.03228571f, 0.02391767f, -0.05305765f, 0.03923141f, -0.04053494f, 
    0.18429922f, -0.09466759f, -0.01325079f, -0.10397790f, -0.16778965f, 0.00670918f, -0.02675476f, -0.09894854f, 
    0.12089948f, -0.10199641f, -0.07511059f, -0.11074753f, 0.21748762f, 0.04019491f, 0.01471645f, 0.01595400f, 
    -0.04430648f, -0.13703217f, -0.04391217f, -0.08670327f, -0.04215072f, -0.06072769f, -0.16251643f, -0.06844202f, 
    -0.01805554f, 0.01453735f, 0.04411113f, 0.11161432f, 0.08312345f, 0.06270562f, -0.04367258f, 0.03733488f, 
    0.05691057f, 0.12650841f, 0.13858263f, -0.04223856f, 0.27349919f, -0.02618564f, -0.08018169f, 0.02847775f, 
    -0.09674828f, -0.16644861f, -0.14034197f, 0.03242222f, 0.01938027f, -0.00165042f, -0.12586404f, -0.15242983f, 
    -0.02572272f, -0.05372981f, -0.02958739f, 0.00316122f, 0.05137226f, 0.07584785f, -0.05980193f, 0.06181320f, 
    -0.04686447f, 0.01473629f, 0.04504398f, 0.02055317f, -0.11547283f, 0.14060174f, 0.05061083f, -0.03719265f, 
    0.02599549f, 0.07907598f, -0.03881639f, 0.09822118f, 0.02209663f, 0.04709880f, 0.05832170f, 0.02897857f, 
    0.24411699f, 0.11440712f, 0.14577849f, -0.08139500f, 0.06349916f, -0.02179026f, 0.06046695f, 0.06867497f, 
    -0.01068166f, 0.02734566f, 0.05732017f, -0.01431926f, 0.06804042f, -0.15391921f, 0.04977315f, -0.10899424f, 
    -0.09172036f, 0.04768623f, 0.11734318f, -0.04601570f, 0.03207888f, -0.05181999f, -0.01792425f, -0.07444897f, 
    -0.39450911f, -0.12010104f, 0.14523369f, 0.25814807f, 0.14868861f, -0.06283428f, -0.04726879f, -0.10077517f, 
    -0.00844954f, 0.09936382f, -0.04051870f, 0.03401157f, 0.12805115f, 0.08235650f, 0.03139581f, 0.01184441f, 
    -0.02912986f, 0.11330863f, 0.03471391f, -0.03190253f, 0.04082311f, 0.08863346f, -0.04307541f, 0.00355201f, 
    0.21501161f, 0.12013247f, -0.06291523f, 0.07418997f, -0.10928351f, -0.07785129f, -0.00579121f, 0.04612096f, 
    0.09142967f, -0.08682580f, 0.06806679f, -0.03960525f, 0.02740684f, -0.02681321f, 0.02175442f, 0.15651017f, 
    0.07108185f, -0.03138860f, 0.03957919f, 0.10468172f, -0.00882864f, 0.01718610f, 0.05182301f, -0.02759043f, 
    -0.10126902f, 0.13587777f, 0.12066973f, 0.03937609f, -0.00318376f, -0.12368998f, -0.06119214f, -0.00951287f, 
    -0.08235129f, -0.05913583f, -0.02490916f, 0.06351227f, -0.20756005f, -0.00987631f, -0.06139093f, 0.12977582f, 
    0.04868502f, 0.10373858f, 0.00737822f, -0.02811596f, -0.01324095f, 0.07488587f, 0.04968904f, 0.12661022f, 
    -0.49045661f, -0.34158003f, -0.06550419f, -0.05430376f, 0.05364667f, 0.02311493f, -0.04151225f, -0.02563788f, 
    0.01272673f, 0.06097152f, 0.05310735f, 0.09199607f, 0.20983191f, 0.04110137f, -0.08712237f, -0.16968155f, 
    0.05926938f, 0.11234933f, -0.02607983f, 0.07749273f, 0.02235762f, -0.12570013f, 0.00868929f, -0.07693037f, 
    -0.18869092f, -0.10620797f, -0.19802147f, -0.12904690f, 0.00904342f, 0.00408509f, 0.00114781f, -0.06230318f, 
    0.00029893f, -0.04072150f, -0.09513887f, 0.04488001f, 0.01496630f, 0.04171745f, 0.24004692f, 0.05623100f, 
    -0.01767134f, 0.04710505f, 0.00901372f, 0.08834677f, 0.06348645f, -0.09630758f, 0.03002234f, 0.03488402f, 
    -0.25203806f, 0.04095765f, 0.05422966f, -0.00621209f, 0.02593014f, -0.00567831f, 0.11238528f, 0.05322244f, 
    0.05731661f, -0.03733024f, -0.14179616f, 0.02831377f, -0.00313552f, -0.13895348f, -0.04935613f, 0.04555814f, 
    -0.05638699f, 0.04955422f, -0.04413977f, 0.03916910f, 0.07715242f, 0.12006704f, 0.00668294f, -0.04682622f, 
    0.27015698f, 0.17135489f, -0.08829086f, -0.00657482f, -0.10235689f, -0.12833634f, 0.00559110f, 0.00464110f, 
    0.01152240f, -0.19151811f, -0.10078678f, -0.12907335f, 0.10542563f, 0.03422573f, 0.04515190f, -0.13006157f, 
    0.02536664f, 0.02065543f, -0.03414417f, 0.08855414f, -0.02914899f, 0.10127543f, 0.06308685f, 0.05939764f, 
    -0.07489551f, -0.00290542f, -0.06292204f, -0.18956695f, 0.05074036f, -0.03794437f, 0.02597878f, -0.02821614f, 
    0.10207969f, 0.04668475f, 0.06072292f, -0.06780382f, 0.05348083f, -0.05857512f, 0.03356942f, 0.18018945f, 
    -0.03757327f, 0.18186413f, -0.07475839f, 0.05972384f, 0.05891194f, 0.23395339f, 0.07159213f, -0.04014592f, 
    -0.23904213f, 0.15576605f, -0.00992075f, -0.21114215f, 0.12452810f, 0.02437327f, -0.11620909f, -0.04328245f, 
    0.00262361f, -0.18870832f, -0.08338464f, -0.17926057f, -0.02850449f, 0.10301537f, -0.04552871f, -0.05594939f, 
    -0.06404835f, 0.06005672f, 0.00922111f, 0.04037691f, -0.06743879f, -0.00716743f, 0.07453974f, 0.00782673f, 
    -0.38584295f, -0.30999228f, -0.00673576f, -0.17842402f, 0.01046512f, 0.03275707f, 0.05521855f, 0.02646361f, 
    0.09658039f, 0.07111671f, 0.09715027f, 0.09394441f, -0.47718459f, -0.25524727f, -0.03608392f, -0.12397815f, 
    0.04930680f, -0.05484723f, -0.02721667f, -0.08062948f, 0.02717054f, 0.05268152f, -0.03127505f, -0.05529451f, 
    -0.29510507f, 0.08836459f, 0.01079670f, -0.08134484f, 0.00842901f, 0.05181919f, -0.04206903f, 0.00491493f, 
    -0.02505293f, 0.13435419f, 0.08536633f, 0.09349944f, -0.25744334f, -0.20601371f, -0.00898269f, -0.16161755f, 
    0.01933298f, -0.03566924f, -0.09108809f, -0.00827951f, -0.04960943f, -0.04435297f, 0.05004436f, 0.03566782f, 
    0.36372966f, 0.19978002f, 0.00744222f, -0.03199148f, -0.05636085f, -0.03146120f, 0.04006762f, 0.04181157f, 
    0.07617965f, 0.02395109f, 0.08351851f, 0.14777538f, -0.10333537f, -0.07801101f, -0.03526479f, -0.09120743f, 
    0.10947727f, -0.04385275f, -0.03158147f, 0.05516429f, 0.06317782f, 0.19323650f, 0.04027617f, 0.07943311f, 
    -0.12542357f, -0.19271854f, 0.13407701f, 0.00917109f, 0.04791987f, 0.08949717f, -0.02444440f, 0.08843976f, 
    -0.00116534f, 0.07017627f, -0.04301683f, -0.01824406f, 0.11409414f, 0.06694975f, -0.00017634f, -0.07468886f, 
    0.03838793f, 0.04863911f, 0.02245321f, 0.03196178f, 0.04769438f, -0.04391198f, 0.04733584f, 0.10263860f, 
    -0.31886476f, 0.03657314f, -0.15722392f, 0.15465519f, 0.01828953f, -0.04231029f, -0.05812364f, -0.08084069f, 
    0.12954909f, -0.01312985f, -0.12021479f, -0.02233816f, -0.14142162f, 0.12002626f, 0.11598677f, 0.08450823f, 
    0.18686183f, -0.09652697f, -0.03672770f, -0.09690913f, -0.06079770f, -0.03428924f, -0.01813990f, 0.00070212f, 
    -0.38810450f, -0.15211454f, -0.02877336f, -0.05231056f, 0.01271352f, 0.05615623f, -0.03613473f, 0.02166782f, 
    0.10607867f, -0.00930662f, -0.07921002f, 0.06817674f, -0.22924842f, 0.06090597f, -0.14897679f, 0.04495302f, 
    0.00871356f, 0.15423411f, -0.17964159f, -0.01325374f, 0.01300517f, -0.06669535f, -0.03959484f, 0.00939628f, 
    -0.08548448f, -0.02712628f, -0.02438764f, -0.07881015f, 0.13120151f, -0.02894087f, -0.01054019f, -0.04917674f, 
    0.01028147f, -0.07788432f, -0.10160765f, -0.00087039f, -0.41896746f, -0.17973398f, -0.21576342f, -0.10103981f, 
    0.10259878f, 0.05637350f, -0.14304864f, 0.01901095f, -0.05920317f, -0.12231500f, 0.07213742f, -0.02170070f, 
    -0.41402605f, -0.02127443f, 0.01161218f, -0.25074190f, 0.04366275f, 0.02229350f, 0.03698085f, -0.09006739f, 
    -0.04085398f, -0.03214801f, -0.07169017f, 0.03517577f, 0.09519425f, 0.10416811f, -0.06552399f, 0.09079186f, 
    0.05984519f, -0.07311526f, 0.07043298f, -0.00806601f, 0.07060038f, -0.02321705f, -0.02068142f, 0.00737135f, 
    -0.25919870f, -0.04711362f, 0.16014250f, -0.01941619f, -0.03040189f, 0.03060138f, 0.03808238f, -0.04835353f, 
    -0.09304609f, -0.01533869f, 0.05811225f, -0.12077928f, -0.03108502f, 0.04785548f, -0.19037126f, 0.29391560f, 
    -0.02899877f, -0.00948522f, -0.01402101f, 0.04361868f, -0.11456625f, -0.00079699f, 0.05147735f, 0.00305831f, 
    0.30307671f, -0.02954434f, -0.00308173f, 0.06401978f, 0.02991246f, -0.06808759f, -0.07191114f, -0.03203856f, 
    -0.00736918f, 0.07971969f, -0.02328260f, 0.10642492f, 0.10791358f, 0.02810658f, -0.01711049f, 0.07229792f, 
    -0.02542456f, -0.02637000f, 0.04242834f, -0.13622844f, -0.01964992f, -0.02967578f, -0.02706646f, -0.04551257f, 
    -0.01780651f, -0.30967176f, 0.07392243f, 0.12770604f, -0.03251206f, -0.00601953f, 0.00445098f, 0.00286004f, 
    -0.09187891f, 0.02097637f, -0.03046495f, 0.02450469f, -0.20078714f, -0.16718398f, -0.01645228f, -0.36947420f, 
    0.06518023f, -0.05060365f, 0.03596877f, 0.03215525f, -0.01687342f, 0.06051751f, 0.02431925f, 0.04047748f, 
    0.07285707f, -0.34157294f, -0.06544747f, 0.16385260f, -0.04882347f, 0.03673664f, 0.04530981f, 0.12823157f, 
    -0.08649638f, 0.02899210f, 0.06964032f, -0.04211496f, 0.01162084f, -0.02192304f, -0.12007642f, -0.04657622f, 
    -0.00119126f, 0.01774643f, -0.02253201f, 0.07585900f, 0.03505665f, -0.09644246f, -0.08322160f, -0.14753532f, 
    0.06649898f, -0.33209485f, -0.01510824f, 0.13218383f, -0.01995241f, 0.10221185f, -0.11651058f, 0.07849547f, 
    0.08749210f, 0.07358769f, -0.01237149f, 0.08743372f, 0.18054967f, -0.01823755f, -0.10981157f, 0.04294262f, 
    -0.09741975f, -0.11980848f, -0.10680136f, -0.12613359f, -0.02406568f, 0.02308379f, -0.02564331f, 0.00737259f, 
    -0.10025048f, 0.15396273f, 0.02696866f, -0.18611258f, -0.06771687f, 0.00868867f, -0.00415519f, -0.09785346f, 
    -0.01984804f, -0.11576703f, -0.03121478f, -0.00291678f, 0.35143432f, 0.01409380f, -0.18718940f, -0.02097709f, 
    0.03613401f, 0.02432831f, 0.02937512f, 0.07019469f, -0.01339484f, -0.07263403f, 0.06717195f, -0.08490360f, 
    0.27778056f, -0.18689540f, -0.10513289f, 0.00760301f, -0.00424481f, 0.01272028f, -0.02862801f, -0.04632269f, 
    0.03766865f, -0.03068358f, -0.04180167f, 0.00640515f, 0.06571873f, 0.05043615f, -0.17056081f, 0.09506734f, 
    -0.02181633f, 0.06449573f, 0.02563596f, 0.00821190f, -0.06004355f, 0.01128344f, 0.00332937f, -0.03326697f, 
    0.27192652f, -0.11100353f, -0.13107577f, 0.18533894f, 0.01435825f, 0.06760904f, -0.00499632f, -0.06358466f, 
    0.15459844f, -0.06752396f, 0.02004836f, 0.09631005f, -0.02392789f, -0.12086327f, -0.02265921f, -0.13904379f, 
    -0.09920698f, -0.00970830f, 0.02404395f, 0.00692036f, -0.04202610f, 0.02667974f, 0.07535192f, 0.10578071f, 
    -0.49197316f, 0.16208632f, -0.06190852f, -0.07451819f, 0.08903640f, -0.10244264f, 0.04032534f, -0.03770737f, 
    0.05258126f, -0.00695750f, 0.03436011f, -0.02775898f, 0.23920520f, 0.05264112f, -0.07731052f, 0.07910936f, 
    -0.07291652f, 0.01208583f, -0.13489807f, 0.02841426f, 0.01927056f, -0.00450069f, 0.01199429f, 0.01493250f, 
    0.07982097f, 0.04235901f, -0.10328663f, -0.01615387f, -0.01338219f, 0.03916895f, -0.04288696f, -0.12478190f, 
    0.05140603f, 0.03714450f, -0.07330221f, 0.03820479f, 0.13771646f, -0.10357270f, -0.05960041f, 0.01326982f, 
    0.04361518f, 0.06025559f, -0.04106081f, -0.01731646f, 0.01013244f, -0.08648752f, 0.03122725f, 0.14176756f, 
    -0.51574910f, -0.02625787f, 0.04604118f, 0.09145959f, -0.00497922f, 0.05737385f, -0.04093885f, 0.05847884f, 
    0.01396991f, -0.00314068f, 0.12493490f, -0.05649013f, -0.03626243f, 0.03573797f, -0.05159769f, 0.09958892f, 
    -0.06630443f, 0.05937233f, -0.04849295f, -0.02671826f, 0.02849931f, 0.07754207f, 0.09095933f, 0.04438371f, 
    -0.31149778f, 0.05673435f, -0.03901049f, -0.01808329f, 0.04128715f, -0.06431203f, 0.12442266f, -0.01420392f, 
    -0.04384641f, 0.02205444f, 0.01468706f, -0.05242371f, 0.04184030f, -0.08383983f, 0.12903845f, -0.00231355f, 
    -0.03884991f, -0.02582718f, 0.09555633f, 0.05489496f, -0.00973907f, -0.01502848f, 0.03175678f, -0.08098266f, 
    -0.01437894f, -0.05274940f, -0.16381791f, -0.05177671f, -0.00614404f, -0.09352469f, -0.03704488f, 0.02509796f, 
    -0.06597395f, -0.05849763f, 0.00836265f, -0.09779755f, 0.01441904f, 0.11315449f, -0.00365950f, -0.02106529f, 
    0.04319702f, 0.07229107f, 0.09552745f, 0.08611614f, 0.01299990f, -0.08878825f, 0.03850159f, 0.03533157f, 
    -0.00221539f, 0.15133347f, -0.10911506f, -0.04068390f, 0.06907332f, -0.05625357f, 0.00748432f, -0.08947305f, 
    -0.00118446f, -0.02090359f, -0.04953028f, 0.07834902f, -0.34921584f, 0.03609819f, -0.07125581f, -0.07888191f, 
    -0.10775340f, 0.04991454f, 0.11376731f, 0.10043120f, 0.01865779f, 0.09808367f, 0.03919932f, 0.00737277f, 
    0.01636842f, 0.06688387f, -0.19241543f, 0.05092986f, 0.11998275f, -0.06180019f, 0.03635963f, 0.10069421f, 
    0.10331490f, 0.06111872f, 0.04554214f, -0.10586023f, -0.20371369f, 0.08035443f, 0.15284984f, -0.04191582f, 
    0.03761864f, -0.16537397f, -0.02639765f, 0.01015989f, -0.01606675f, 0.01111417f, 0.08442368f, -0.10587969f, 
    0.31230271f, 0.02187234f, 0.10597236f, -0.07035556f, 0.23997420f, -0.03019433f, -0.16435310f, 0.01305936f, 
    0.10789642f, 0.01945336f, 0.11991239f, 0.08051456f, 0.06614348f, -0.03518593f, -0.03278710f, 0.00554383f, 
    -0.05854036f, -0.01720522f, -0.03777825f, 0.12579966f, -0.12152565f, 0.03245779f, -0.05401510f, -0.04121663f, 
    0.02137835f, -0.00102038f, -0.07497813f, 0.04100869f, 0.02878470f, 0.00679229f, 0.05962959f, -0.10238877f, 
    -0.00204455f, -0.04021166f, -0.03621877f, 0.02730968f, 0.02279415f, 0.07762317f, -0.11669478f, 0.04792985f, 
    -0.01598937f, -0.03139521f, 0.00864593f, -0.04770101f, -0.06297901f, -0.01840576f, -0.09384680f, -0.05514443f, 
    0.04564047f, -0.02375930f, 0.01062344f, -0.21258906f, 0.02469420f, -0.00928239f, 0.01075111f, -0.09093837f, 
    0.07065023f, 0.03944000f, -0.06122108f, 0.01093571f, -0.38947713f, 0.17175426f, 0.13581634f, -0.01428863f, 
    -0.04593232f, 0.06562804f, -0.04716906f, -0.02068052f, 0.00878725f, -0.07044476f, 0.05774839f, -0.04803266f, 
    -0.04407324f, -0.12771291f, -0.16721272f, -0.04202880f, 0.03377774f, 0.04253303f, 0.00178280f, 0.08140987f, 
    -0.02957152f, 0.00315631f, -0.06080075f, -0.11217990f, 0.04881494f, -0.07541338f, -0.23992155f, 0.25030446f, 
    -0.15343742f, -0.08812395f, 0.19391258f, 0.16648018f, 0.09706645f, 0.14121249f, -0.05744308f, -0.05563582f, 
    -0.31409252f, -0.21448579f, -0.02569366f, -0.19471681f, 0.02422692f, 0.03330985f, 0.04064247f, 0.00078752f, 
    0.02556675f, 0.03871247f, -0.01979009f, -0.05382094f, 0.20884803f, 0.05797595f, -0.18151924f, 0.00428148f, 
    0.03186834f, 0.01932036f, 0.07486448f, -0.08861257f, 0.04271832f, -0.00449501f, 0.00665001f, -0.01190240f, 
    0.05401503f, 0.08230694f, -0.06684870f, -0.05867327f, 0.09867660f, -0.17194317f, 0.03136405f, 0.06024071f, 
    0.03576709f, -0.04122052f, 0.04354189f, -0.00420026f, -0.09073190f, -0.22018574f, 0.05875338f, 0.07846052f, 
    -0.03870382f, 0.04546735f, 0.00407003f, -0.00799279f, -0.05082457f, 0.00434050f, 0.04815696f, -0.08414390f, 
    0.05758176f, -0.29739287f, -0.05991269f, -0.01666899f, -0.01571199f, 0.05508718f, 0.09683228f, 0.05873804f, 
    0.01370458f, -0.08045025f, -0.02234265f, 0.04665147f, -0.00688304f, -0.12823069f, 0.04686325f, 0.32853648f, 
    -0.03106493f, -0.02429533f, 0.08836966f, 0.00439008f, -0.12739354f, -0.00774651f, -0.10158066f, -0.17808796f, 
    0.30455863f, -0.21942084f, -0.16779776f, 0.10017201f, 0.06812175f, -0.08441706f, 0.01029598f, -0.10952882f, 
    0.04028261f, 0.03051029f, 0.01051915f, 0.06165693f, -0.14555648f, 0.13102384f, 0.04244500f, 0.20334153f, 
    -0.02253681f, -0.05114498f, -0.01075513f, -0.05962142f, -0.05136822f, -0.12199467f, -0.09680671f, -0.06593459f, 
    -0.31811571f, -0.00336067f, 0.04375352f, -0.06431822f, -0.05588157f, 0.11347385f, 0.01475771f, -0.01424736f, 
    0.08917208f, -0.05080025f, 0.02625722f, 0.14964575f, -0.05069041f, 0.14116940f, 0.09649404f, 0.04482533f, 
    0.00015306f, -0.09489407f, -0.01541420f, 0.06584165f, -0.06174403f, 0.06775915f, 0.07342730f, -0.04120712f, 
    0.32223475f, 0.07392835f, -0.26139164f, -0.19667239f, 0.00176184f, 0.03579093f, 0.04128555f, -0.00580094f, 
    -0.15580928f, -0.00179900f, -0.10577925f, -0.01283637f, -0.09243213f, -0.01212755f, -0.08174363f, -0.05845654f, 
    0.14120311f, 0.00365491f, 0.05036979f, -0.13270751f, 0.07990551f, 0.01392422f, -0.00125631f, 0.02698112f, 
    0.41160068f, 0.19832861f, -0.22015603f, 0.06417547f, 0.01564268f, -0.00359617f, 0.05052927f, 0.05324630f, 
    0.09063856f, -0.04462957f, -0.00592187f, 0.02160942f, -0.06112690f, -0.16578156f, 0.06725648f, -0.26428574f, 
    -0.06364942f, -0.01576011f, -0.02067056f, 0.03618104f, 0.06403276f, -0.03804703f, 0.01071459f, 0.01782651f, 
    -0.06237169f, -0.02663526f, -0.08556317f, 0.01751903f, 0.15124890f, -0.08213203f, 0.07280922f, 0.00478558f, 
    -0.01015534f, -0.05721837f, -0.03376009f, -0.03016382f, 0.10212577f, -0.28394783f, -0.10281295f, -0.02087395f, 
    0.01488582f, 0.04895751f, -0.06295042f, 0.00915026f, 0.08471532f, 0.00137885f, -0.08480480f, -0.09071732f, 
    -0.21891278f, 0.37148473f, -0.07666938f, 0.10954789f, 0.17053492f, -0.02689312f, -0.03385201f, -0.11383115f, 
    0.10271878f, -0.00362551f, -0.06474189f, 0.00324762f, 0.07693480f, 0.19762458f, -0.02929309f, 0.08237000f, 
    0.09172115f, -0.01526367f, -0.03911327f, -0.03179607f, -0.05300864f, 0.04817567f, -0.00168307f, -0.10038727f, 
    0.20674555f, 0.01369226f, 0.04564840f, 0.10313925f, 0.08346855f, 0.05098296f, 0.01707847f, 0.00339900f, 
    -0.03501842f, 0.06600995f, 0.12233773f, -0.03836317f, 0.22618440f, -0.08924446f, -0.06375846f, -0.17917682f, 
    -0.16325191f, 0.00591060f, -0.07433011f, -0.10407846f, -0.03923875f, -0.06843338f, -0.02379836f, -0.05192713f, 
    0.26761281f, 0.27414462f, -0.31862158f, -0.05337705f, 0.02651776f, -0.02227844f, -0.02116982f, -0.02733223f, 
    0.10447402f, 0.02801229f, 0.00181642f, 0.03596448f, -0.08171379f, -0.00125171f, -0.08018781f, -0.04330074f, 
    0.05252725f, 0.02270240f, 0.02033613f, 0.06110427f, -0.12743491f, 0.13965796f, -0.00980440f, 0.04195679f, 
    -0.27080444f, 0.03277854f, -0.05589373f, -0.21832740f, -0.02872681f, 0.01219763f, 0.00042821f, 0.01076786f, 
    0.06439035f, 0.05917999f, 0.01857505f, 0.00878638f, 0.09158919f, -0.00952624f, -0.21495490f, -0.05475300f, 
    0.03293166f, -0.01549582f, 0.00426250f, -0.05676532f, 0.03453726f, 0.12986514f, -0.06909586f, 0.05765643f, 
    -0.06675688f, 0.04505692f, -0.04137466f, -0.11225166f, 0.07738386f, -0.04817065f, -0.09315946f, -0.03437512f, 
    -0.05361845f, -0.00407303f, -0.09150509f, -0.09277074f, 0.07171375f, 0.03879189f, 0.09635740f, 0.08270307f, 
    -0.00076534f, -0.04938356f, 0.02822259f, 0.03808667f, -0.01027369f, 0.06693844f, 0.02500435f, 0.05075118f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03939741f, 0.00886759f, -0.03731145f, 0.00288957f, 0.03473119f, 0.04172064f, 0.00002382f, -0.05485921f, 
    0.00633289f, 0.03144560f, 0.05086253f, 0.03535533f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
