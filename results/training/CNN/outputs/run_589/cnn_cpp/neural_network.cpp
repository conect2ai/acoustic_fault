#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.15068206f, -0.55105478f, -0.24797438f, -0.57661086f, -0.52325696f, -0.61550987f, 0.08708671f, 0.58117133f, 
    0.45507929f, 0.48773214f, 0.15886870f, -0.02508307f, -0.46924224f, 0.25955343f, -0.41901365f, -0.15982622f, 
    0.27001804f, 0.26787359f, 0.36713272f, 0.28649375f, 0.40432066f, -0.29697376f, -0.30281731f, 0.55229467f, 
    0.05717949f, 0.06697232f, 0.32882926f, -0.26457131f, -0.40710568f, -0.92563164f, 0.34316427f, -0.19537368f, 
    -0.26445597f, 0.56547499f, 0.37344486f, 0.18383755f, 0.12638628f, -0.17631243f, 0.45962662f, -0.86531889f, 
    -0.83322084f, -0.41149083f, -0.14207044f, 0.13874295f, -0.10585050f, -0.73773104f, -0.56385916f, -0.52916819f, 
    -0.06199866f, 0.51353407f, -0.14114831f, 0.07668286f, 0.00902307f, 0.15648957f, -0.15808168f, -0.27702698f, 
    -0.08823468f, 0.50898486f, -0.22864832f, 0.41922751f, -0.45633966f, -0.70396221f, 0.53340596f, -0.46139982f, 
    0.25182518f, -0.63139778f, -0.19296695f, 0.72129476f, -0.84420574f, -0.19078122f, 0.32157400f, 0.17439096f, 
    0.08100671f, 0.39673686f, 0.53227687f, 0.59896904f, 0.73126948f, 0.10760390f, -0.27419940f, 0.23021403f, 
    -0.17674914f, -0.54519928f, -0.51478374f, -0.44128677f, 0.46757421f, -0.39130402f, -0.06754262f, -0.09200901f, 
    -0.33134300f, -0.15160972f, -0.60006320f, -0.23496340f, 0.08520072f, 0.55358630f, 0.77820504f, 0.24198037f, 
    0.01730170f, -0.19216700f, -0.17252564f, 0.60018939f, 0.47990671f, 0.42986810f, -0.31688574f, 0.06631167f, 
    -0.15931866f, -0.09412244f, 0.30016983f, 0.26418400f, -0.67232150f, 0.36810231f, -0.20827223f, 0.24262886f, 
    -0.06684981f, 0.05843183f, -0.27698237f, -0.29018563f, -0.57830173f, -0.74313253f, -0.20566925f, -0.32537484f, 
    0.00998455f, 0.52288884f, 0.82631242f, 0.47204065f, -0.14616659f, 0.34724778f, -0.28738910f, -0.46059114f, 
    0.02271919f, -0.67954189f, 0.22176985f, -0.31691852f, 0.61530787f, -0.06544813f, -0.14357853f, -0.45261160f, 
    -0.05434011f, 0.47166422f, -0.48186445f, 0.12922034f, -0.36803499f, 0.31088805f, -0.07113560f, -0.52878916f, 
    0.86283994f, -0.29918724f, -0.58240765f, -0.43993574f, -0.54982626f, 0.44526243f, -0.04015408f, -0.48653343f, 
    0.42843622f, 0.70161629f, -0.13846718f, 0.36621562f, 0.58210188f, 0.03648315f, -0.38641584f, -0.46040732f, 
    0.02916433f, 0.05451670f, 0.66762680f, 0.41588065f, 0.24448004f, -0.20789891f, -0.48847970f, 0.22369848f, 
    -0.02169777f, 0.26994073f, -0.45747474f, 0.44893146f, 0.28282627f, -0.61085707f, 0.83611631f, 0.30185801f, 
    -0.41393971f, -0.20399390f, -0.12006986f, -0.48881927f, 0.29905078f, 0.67536825f, 0.75979072f, -0.25201419f, 
    -0.18479349f, -0.37761840f, -0.15800548f, -0.39935505f, -0.25076917f, -0.39633131f, -0.77055043f, -0.37815720f, 
    -0.48729372f, 0.39399549f, -0.19311549f, 0.06899055f, -0.20494714f, 0.30425450f, 0.22355312f, 0.54038680f, 
    -0.50325084f, -0.40840811f, -0.68718374f, -0.56691754f, 0.42534149f, 0.08304803f, 0.24778511f, -0.69676799f, 
    0.17962970f, 0.46865597f, 0.83652276f, 0.32123575f, -0.74034017f, -0.02636547f, 0.23065031f, 0.28707096f, 
    -0.95533341f, 1.02835608f, -0.32136345f, -0.07512990f, 0.62158364f, 0.24179260f, 0.01940583f, 0.34361726f, 
    -0.12319501f, -0.18870538f, -0.29006234f, -0.13331473f, -0.54794878f, -0.08028920f, -0.45503470f, -0.39195779f, 
    0.33969277f, -0.27975395f, -0.38930491f, 0.78172737f, -0.20950514f, 0.31554580f, -0.29299793f, -0.65999806f, 
    -0.18750645f, -0.13720061f, -0.05658553f, -0.32544845f, -0.39439109f, -0.63386983f, -0.29339874f, 0.43473423f, 
    0.48178127f, -0.31869695f, -0.23978247f, -0.24773867f, -0.86316043f, -0.59175569f, 0.05185719f, -0.06830852f, 
    -0.11375456f, -0.45058808f, 0.27472460f, 0.24722026f, 0.00980769f, 0.46949220f, 0.43227148f, 0.54254901f, 
    0.64917123f, -0.11058640f, -0.14720474f, 0.33827364f, 0.33111304f, 0.21641088f, -0.30068359f, -0.15319628f, 
    0.65823257f, 0.62232023f, -0.44797286f, 0.64801115f, 0.18003571f, -0.20150174f, 0.03473162f, 0.14310396f, 
    0.38963205f, 0.28815854f, 0.46035874f, -0.32271120f, 0.27676010f, -0.48565936f, -0.31360587f, -0.47444296f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07939958f, 0.18598488f, 0.23137376f, -0.31439260f, 0.05878391f, 0.07209017f, -0.04920996f, -0.21863681f, 
    -0.19346949f, -0.27324843f, 0.02006685f, -0.38242641f, -0.23472285f, 0.08326938f, -0.20455718f, -0.12404520f, 
    -0.21602364f, 0.11786132f, -0.20126763f, -0.04792693f, -0.20843413f, -0.15685016f, 0.19974478f, -0.27461970f, 
    -0.10989574f, 0.18663037f, 0.16798212f, -0.10935027f, -0.18244375f, 0.12214501f, -0.01635925f, -0.01126252f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07866923f, -0.12780145f, 0.20485750f, 0.02225360f, 0.07841825f, 0.02795243f, 0.01646095f, -0.09671848f, 
    -0.00586222f, -0.04111146f, -0.20485640f, 0.19984354f, -0.02192357f, -0.07696395f, -0.01063621f, -0.14427938f, 
    -0.17879963f, 0.11238047f, -0.02155396f, -0.13023359f, -0.11714179f, -0.07026406f, -0.01481418f, -0.06728091f, 
    0.01982065f, -0.03278973f, 0.13942486f, 0.01414859f, -0.04036772f, 0.02731031f, 0.00894454f, 0.02370605f, 
    -0.04446494f, 0.23091762f, 0.12797779f, -0.16983986f, 0.10345598f, -0.17110164f, 0.07597665f, -0.08288703f, 
    -0.03119777f, -0.05665033f, 0.00684130f, 0.07121107f, -0.08622108f, 0.06329720f, 0.09275027f, -0.03504467f, 
    0.03696324f, 0.00611455f, 0.05264062f, 0.06269266f, 0.05469205f, -0.05455472f, 0.30084118f, -0.19053136f, 
    -0.03324746f, 0.02224554f, 0.12111450f, -0.15123585f, 0.11952911f, 0.01653747f, 0.07912102f, -0.10088634f, 
    0.01681363f, 0.14883019f, 0.07111402f, -0.06373476f, 0.02156524f, -0.04816071f, -0.05203247f, -0.01759456f, 
    -0.31744757f, 0.08138543f, 0.06600892f, 0.02979472f, -0.05108718f, 0.07777774f, 0.03051494f, 0.07108356f, 
    0.16416101f, 0.23361309f, -0.00995503f, 0.13340217f, 0.06583448f, 0.22541408f, 0.03703507f, -0.01236699f, 
    0.10719249f, -0.11073378f, 0.12012371f, 0.22464104f, 0.03094331f, 0.05272708f, 0.03919090f, -0.09491736f, 
    0.06416054f, 0.11524198f, 0.03812364f, -0.25045478f, -0.29661530f, 0.09578244f, -0.09584650f, 0.05944940f, 
    0.24949309f, 0.00337754f, -0.04599661f, -0.03415088f, 0.17591299f, -0.15585104f, 0.04553020f, 0.18889661f, 
    0.25972497f, 0.04298390f, -0.08829241f, 0.12809397f, 0.11994865f, 0.07122400f, -0.01699724f, 0.01850555f, 
    0.01056144f, -0.13255866f, -0.11191772f, 0.09167596f, -0.01957795f, 0.18159416f, -0.00304300f, -0.07205573f, 
    -0.03275800f, -0.02996405f, 0.15421288f, -0.06272387f, 0.06979187f, -0.01338732f, -0.24180208f, 0.05083005f, 
    0.21022092f, -0.01265825f, -0.10004263f, 0.10791016f, -0.07632896f, 0.05866786f, 0.03769468f, -0.04797098f, 
    0.22574882f, -0.02124915f, -0.10766875f, -0.02695474f, -0.09229759f, -0.18345636f, -0.05039825f, 0.07422703f, 
    -0.02238104f, 0.03398532f, 0.06274011f, 0.04260535f, -0.01241887f, 0.01790514f, 0.07438305f, -0.04202550f, 
    0.05764151f, 0.01772339f, 0.02970755f, -0.27261069f, 0.07349107f, -0.18367936f, 0.07693544f, 0.02814417f, 
    0.07528929f, -0.04241504f, -0.03169874f, 0.06549084f, 0.14599669f, -0.14155783f, 0.02941248f, 0.02640164f, 
    -0.06025692f, -0.06767459f, -0.01367617f, -0.09352131f, -0.19125213f, 0.00224185f, 0.07028805f, -0.14027718f, 
    -0.14038604f, 0.07295013f, 0.18719622f, -0.07035173f, 0.07703376f, -0.01261866f, 0.05651151f, -0.04053880f, 
    0.03117557f, -0.05999116f, 0.19634505f, 0.06634551f, 0.02665437f, -0.06436968f, -0.13533647f, -0.18727262f, 
    -0.03864355f, -0.17198531f, 0.18714325f, -0.01436716f, -0.02551894f, -0.04953129f, -0.16743205f, 0.07511860f, 
    0.07085206f, -0.02309993f, 0.06735075f, 0.03761031f, -0.01681694f, 0.10482977f, 0.00890522f, -0.05522561f, 
    -0.18869296f, 0.00572644f, 0.04987478f, 0.04021942f, -0.03030547f, -0.07251456f, 0.07100160f, 0.15199521f, 
    0.14157331f, -0.04551918f, 0.01743254f, 0.03517035f, 0.06051419f, -0.06592610f, -0.02871387f, -0.11532266f, 
    -0.01208721f, 0.03756548f, 0.11873436f, -0.04014190f, 0.12707815f, -0.02424123f, 0.05472466f, -0.01318114f, 
    0.01299105f, -0.00246970f, -0.21731658f, 0.00534587f, 0.01001287f, -0.05017605f, 0.25476864f, -0.06004902f, 
    -0.07402450f, 0.12909707f, 0.00609818f, 0.07089015f, -0.04749202f, 0.14999008f, 0.01670615f, 0.15901409f, 
    -0.11091699f, -0.02860812f, -0.01974265f, -0.10469292f, -0.05880132f, -0.23979583f, -0.03953146f, 0.05008607f, 
    -0.10661969f, -0.01378057f, 0.05015196f, 0.09508828f, 0.06419543f, -0.05319688f, 0.05917230f, 0.00569133f, 
    0.16073216f, -0.03092583f, 0.00560862f, 0.05000649f, -0.02268630f, -0.06899298f, 0.32054213f, 0.19017942f, 
    0.14886591f, 0.14726269f, -0.08682953f, 0.03940420f, 0.11879309f, 0.08727106f, -0.11421370f, 0.19854774f, 
    -0.23734376f, -0.08032057f, 0.11048059f, 0.04326879f, 0.04809422f, -0.03752864f, 0.04121646f, 0.03087194f, 
    0.03695940f, 0.07214925f, -0.00313017f, -0.21179509f, -0.01581179f, 0.02890010f, -0.02212700f, 0.04031220f, 
    -0.01488376f, 0.02041573f, -0.01175741f, -0.04629103f, -0.10639695f, -0.01455362f, -0.12113436f, -0.00156885f, 
    -0.00810981f, 0.04942538f, -0.01596692f, 0.07233983f, 0.08784228f, -0.09868849f, 0.05279803f, 0.09862539f, 
    -0.07455694f, -0.09247206f, -0.02979690f, 0.12917766f, -0.13951926f, -0.03978943f, -0.02101948f, -0.00414545f, 
    -0.06281049f, 0.01637648f, -0.03148551f, 0.06078248f, 0.12370331f, 0.31607711f, 0.08124766f, 0.01119121f, 
    0.00806937f, 0.16135502f, 0.04721740f, 0.07387780f, -0.08522848f, -0.06177425f, -0.06639928f, 0.12483946f, 
    -0.06886441f, 0.03673111f, 0.05623575f, -0.03930574f, 0.13968280f, 0.18204622f, 0.11957656f, 0.06736686f, 
    -0.19140048f, -0.44416055f, 0.19187309f, 0.15613784f, 0.07074831f, -0.00664389f, 0.04878059f, 0.08475211f, 
    0.20068529f, 0.13864091f, 0.21923171f, -0.11366484f, -0.18116660f, -0.11625334f, -0.00557954f, 0.08813634f, 
    -0.00988067f, -0.01055420f, 0.08005165f, -0.37541783f, 0.22070435f, 0.02588142f, -0.06085199f, 0.07370901f, 
    0.05759564f, -0.04560614f, 0.05055841f, 0.19776770f, 0.08550230f, -0.00238735f, 0.14919247f, -0.03922191f, 
    0.08339674f, -0.03816061f, -0.17229928f, -0.10053417f, 0.09732474f, -0.22972135f, 0.09553500f, -0.19633617f, 
    -0.04402343f, -0.01493351f, -0.00024375f, -0.22701001f, 0.15154895f, -0.08751705f, -0.09627219f, 0.00546872f, 
    -0.00860089f, -0.01651835f, 0.22962365f, 0.23343065f, -0.09463947f, 0.29682988f, 0.26557857f, -0.19003756f, 
    0.00619399f, 0.03943787f, 0.02274822f, -0.07777092f, -0.09265756f, -0.06647319f, -0.05677131f, -0.15126126f, 
    -0.08464918f, 0.14001209f, -0.11288682f, 0.10978968f, 0.06844031f, -0.03608331f, -0.06532594f, -0.23829836f, 
    -0.17250806f, -0.25282544f, -0.01385103f, 0.02744068f, 0.01560795f, -0.10936293f, -0.03975030f, 0.12605245f, 
    -0.08093059f, -0.27699953f, -0.13901524f, -0.08875737f, 0.08549775f, -0.03081988f, 0.07827979f, -0.14250749f, 
    0.06139950f, 0.19826607f, 0.03384340f, 0.14166701f, 0.01478968f, 0.00453993f, 0.04357260f, 0.04229363f, 
    -0.00170759f, 0.06480446f, 0.13305151f, 0.05658344f, 0.02526319f, -0.00303802f, -0.23366351f, 0.03498041f, 
    0.04445734f, -0.00906037f, -0.02669070f, 0.09836953f, -0.51641589f, 0.03718521f, -0.04680260f, -0.12317730f, 
    -0.01709143f, -0.06639718f, 0.11701881f, -0.20470217f, 0.08498864f, 0.02163475f, -0.11290096f, -0.08852853f, 
    0.00208644f, 0.03457834f, -0.03865450f, 0.02438818f, -0.01318681f, 0.12262712f, -0.06964750f, 0.08540294f, 
    -0.12373906f, 0.06537087f, 0.12800385f, 0.06367895f, 0.00673938f, -0.04518829f, -0.01371698f, -0.08942427f, 
    0.04506659f, 0.05184590f, -0.05251972f, -0.03815594f, 0.05084250f, 0.00420863f, 0.04717746f, -0.27435029f, 
    -0.00523710f, 0.21046944f, -0.04128183f, 0.01522778f, -0.09682151f, -0.15815295f, -0.03956732f, 0.24223831f, 
    0.05716212f, 0.02940379f, -0.31110498f, -0.06312961f, 0.03114790f, -0.00164001f, -0.09179186f, -0.05114992f, 
    -0.05736509f, -0.10936958f, -0.14328033f, -0.10160183f, 0.13086946f, 0.09913176f, 0.07731475f, -0.07807504f, 
    0.00532391f, 0.01560810f, 0.03344978f, -0.19031633f, -0.08792572f, 0.02226791f, -0.06785417f, -0.05053974f, 
    -0.01416972f, 0.04271184f, 0.06417344f, 0.07130347f, 0.00335741f, -0.27026519f, 0.09746097f, -0.10295577f, 
    0.02246529f, 0.11727645f, 0.02114371f, 0.18937841f, -0.33569643f, -0.18812659f, -0.05151086f, -0.03325389f, 
    0.02616561f, 0.08470501f, -0.09094691f, -0.11701882f, 0.02203933f, -0.04690527f, -0.12642814f, 0.17418361f, 
    -0.00142134f, -0.02610592f, -0.05863525f, 0.04489483f, 0.07033229f, -0.00648487f, -0.21995839f, 0.07907552f, 
    0.17355739f, 0.08791321f, 0.10706395f, 0.02019842f, -0.05159812f, -0.04267832f, -0.07308911f, 0.10797006f, 
    0.02562916f, 0.09122792f, -0.12248000f, 0.04751123f, 0.01446788f, 0.00577474f, 0.28286618f, -0.12183893f, 
    0.19056930f, -0.08511962f, 0.10917072f, 0.13496311f, -0.00943940f, -0.23488072f, 0.06060294f, 0.06434019f, 
    -0.00295484f, -0.02946895f, 0.11865390f, -0.06365730f, -0.03153826f, -0.13213614f, -0.00846068f, 0.00665705f, 
    -0.07286590f, 0.00077621f, -0.11007761f, -0.08319043f, -0.06176102f, -0.05779609f, 0.18459490f, 0.10280374f, 
    -0.04687199f, 0.07241698f, -0.13071564f, 0.04583674f, -0.21635333f, 0.23979814f, -0.03407706f, 0.02352065f, 
    -0.06107676f, -0.13905968f, 0.04812477f, 0.06049483f, 0.09080236f, -0.06023284f, 0.22823696f, 0.02762925f, 
    0.12727708f, -0.25683075f, 0.04318763f, -0.00362090f, 0.02199939f, 0.07306261f, -0.05376020f, 0.19304250f, 
    -0.12711950f, 0.06458167f, 0.00136203f, -0.02711396f, 0.14106181f, 0.11730325f, -0.18173948f, 0.03376863f, 
    0.06259815f, -0.09818195f, -0.09037401f, -0.01835717f, -0.04528983f, -0.01114679f, -0.12235838f, 0.20565078f, 
    0.01424957f, 0.13392638f, -0.00532874f, -0.16033606f, -0.01333616f, -0.03913144f, -0.04490190f, 0.06664290f, 
    -0.29992437f, 0.06774948f, 0.00488542f, 0.13368201f, 0.03759930f, 0.23425323f, 0.05076419f, 0.03629667f, 
    -0.17908749f, -0.08989953f, -0.16891134f, 0.14145820f, 0.02766049f, -0.04644019f, -0.00750164f, -0.02990102f, 
    0.04123659f, 0.23635952f, -0.07902262f, 0.03332030f, 0.16051422f, -0.04366038f, -0.04210711f, 0.05537118f, 
    -0.00386419f, 0.01793051f, -0.11148877f, -0.17265095f, -0.09422949f, 0.08728869f, 0.02652657f, 0.05134086f, 
    0.07933486f, -0.10222515f, 0.02711693f, 0.00482012f, 0.02234244f, 0.11381224f, -0.24453156f, -0.08725606f, 
    -0.00425588f, 0.00065540f, -0.04251213f, -0.13162574f, 0.07433952f, 0.11520770f, 0.05619241f, 0.04591860f, 
    -0.03373396f, 0.00821153f, -0.17476068f, 0.01358329f, -0.00969022f, 0.01006347f, -0.02541432f, 0.14574674f, 
    0.03082097f, 0.09034903f, 0.03756593f, -0.22839029f, 0.06307957f, -0.00384409f, 0.03579353f, 0.10479630f, 
    0.23056704f, 0.15738021f, 0.01157799f, 0.11284090f, -0.06547184f, -0.12132490f, -0.08586103f, -0.00854640f, 
    0.31498343f, 0.13888200f, 0.10084414f, -0.14555231f, 0.11770418f, -0.11271643f, -0.05850862f, 0.05164298f, 
    -0.14948215f, -0.09818684f, -0.12825659f, -0.05814731f, 0.04843345f, -0.03421621f, 0.11414197f, -0.03315628f, 
    0.02142658f, -0.05278768f, -0.06155576f, -0.05283977f, -0.08835144f, 0.16005638f, 0.16253693f, 0.10892504f, 
    0.05616564f, 0.03108299f, -0.14766648f, 0.03891795f, -0.05857659f, 0.33584204f, 0.10806169f, -0.04055002f, 
    0.08747877f, 0.01443343f, 0.04836481f, 0.12092019f, 0.05055182f, -0.14492986f, 0.12931125f, 0.15991645f, 
    0.06708363f, 0.09270864f, -0.09225544f, 0.06036087f, 0.03292048f, -0.03530176f, 0.04965834f, 0.14387187f, 
    -0.03723827f, 0.05991347f, -0.10383824f, -0.07166604f, 0.09258927f, -0.02843065f, 0.15202080f, -0.08158174f, 
    0.17056572f, 0.05080140f, -0.05010812f, -0.12983337f, -0.04796087f, 0.00156187f, 0.11878357f, 0.24082617f, 
    -0.04356164f, 0.13366807f, -0.00626230f, -0.04788669f, 0.00785632f, 0.01991805f, 0.00328526f, -0.13066305f, 
    0.25150871f, 0.02165118f, -0.04811453f, -0.14651498f, -0.07724374f, 0.06610647f, -0.05350403f, -0.09500856f, 
    0.13802125f, 0.15918201f, 0.11703597f, 0.10871565f, 0.10658146f, 0.06938887f, -0.13004860f, 0.09617499f, 
    -0.01113084f, 0.03762116f, 0.14572193f, -0.09736665f, 0.12764220f, 0.02789497f, -0.01975143f, 0.13180697f, 
    0.05847790f, -0.06702626f, 0.06666616f, -0.28238353f, 0.04184182f, 0.24276252f, -0.15384316f, 0.05330824f, 
    0.09804368f, -0.12132557f, 0.09003723f, 0.00900892f, 0.07398533f, -0.10235252f, 0.17636475f, -0.11378247f, 
    0.17645998f, -0.08698740f, -0.00410015f, -0.04502262f, -0.01168699f, -0.12723032f, 0.12076450f, 0.10628847f, 
    0.03547280f, 0.04111783f, 0.13596509f, -0.17036472f, -0.02539077f, -0.14145152f, -0.00238011f, 0.06028948f, 
    -0.09283009f, 0.06188793f, 0.09289275f, 0.07263481f, 0.05211051f, -0.07129084f, -0.33440444f, 0.04529161f, 
    0.13167411f, -0.01439082f, 0.07780136f, 0.09261162f, 0.20952007f, 0.00348562f, -0.12800378f, -0.08033159f, 
    0.25748831f, 0.03089590f, -0.02882461f, -0.03167688f, -0.12687431f, 0.03456663f, 0.03182026f, 0.03647516f, 
    -0.06097246f, -0.18133497f, -0.11496390f, 0.05484967f, 0.13638650f, 0.06337565f, -0.00535628f, -0.01987819f, 
    -0.04177347f, 0.12720974f, -0.17866035f, -0.14498246f, 0.01067571f, 0.04242957f, -0.09793369f, 0.00258292f, 
    0.10473011f, 0.02597841f, 0.01959691f, 0.07778183f, -0.05722019f, 0.02284158f, -0.08090161f, -0.06633548f, 
    0.01577595f, 0.07527237f, 0.08400938f, -0.07329648f, 0.22808963f, 0.10628534f, 0.19024985f, -0.08686247f, 
    -0.12956317f, 0.07885862f, 0.19082713f, 0.05334395f, -0.08225077f, 0.13828112f, 0.14915375f, 0.02866315f, 
    0.00502824f, 0.01708671f, 0.02344810f, 0.07530093f, 0.20282033f, -0.01881841f, 0.07020099f, -0.07552774f, 
    -0.05461192f, -0.05034298f, 0.14233811f, 0.09835434f, -0.09232273f, -0.01316511f, -0.00498517f, -0.06086273f, 
    -0.11720704f, -0.07356189f, 0.03620648f, -0.08287219f, 0.01927104f, 0.00567898f, 0.02927114f, -0.02625168f, 
    -0.27392018f, 0.05697340f, -0.24593638f, -0.00153614f, 0.07358988f, -0.10921315f, -0.07939851f, -0.00423588f, 
    -0.02163907f, 0.29800090f, 0.01530818f, -0.02773336f, 0.06625261f, 0.20439565f, 0.05217976f, 0.07239041f, 
    0.05338712f, 0.00641007f, 0.28374282f, 0.09899985f, -0.03379780f, 0.00267663f, 0.08987151f, -0.06931322f, 
    -0.04552063f, 0.15785238f, -0.00887619f, -0.48550496f, -0.13477761f, 0.01199559f, 0.03993778f, 0.04228692f, 
    0.02846418f, -0.05353940f, 0.03066258f, 0.07353857f, 0.31793439f, 0.04471421f, -0.06644560f, 0.02008243f, 
    0.01267389f, 0.04182177f, 0.00897164f, 0.01899190f, 0.03293759f, 0.12039387f, -0.05428524f, 0.15045035f, 
    -0.03187735f, 0.10867272f, -0.04315764f, -0.11581703f, 0.08546863f, 0.13094752f, -0.04581909f, 0.05522865f, 
    0.00165006f, 0.13656884f, -0.11532088f, 0.00510937f, -0.09131992f, 0.11221545f, 0.02487020f, 0.15133066f, 
    0.01709585f, 0.06063125f, 0.12395094f, -0.09096757f, -0.05072577f, 0.13022736f, 0.09994706f, -0.04578665f, 
    -0.18790227f, -0.16491604f, -0.13207453f, 0.02555092f, -0.02591765f, -0.13320147f, 0.16503327f, 0.10210396f, 
    -0.05161607f, -0.30475309f, -0.09632038f, -0.00926149f, -0.03094781f, 0.02973344f, -0.06536286f, 0.03720390f, 
    0.18857723f, 0.06860409f, -0.30927151f, -0.30003148f, 0.15155670f, 0.10348747f, -0.01462491f, -0.09032870f, 
    0.05112769f, 0.05664684f, -0.08489006f, 0.15710337f, -0.07212009f, -0.21662247f, -0.04576202f, -0.02490217f, 
    -0.06113969f, -0.01049551f, 0.02255255f, 0.00052772f, -0.02449597f, -0.07805791f, 0.13976993f, 0.02628852f, 
    0.05516505f, -0.01058490f, 0.19519714f, 0.16435736f, 0.02756444f, 0.06338821f, 0.01110758f, 0.00133652f, 
    0.11421346f, -0.02284958f, 0.08534946f, 0.01730816f, 0.04218151f, -0.03482451f, 0.13984571f, 0.01003483f, 
    -0.10477211f, 0.00317946f, -0.05632709f, -0.08648686f, -0.05267330f, 0.08842526f, 0.00691689f, 0.21812050f, 
    -0.22798932f, -0.21492282f, -0.04614107f, 0.00215915f, 0.03371109f, 0.07696571f, -0.08688311f, 0.01550076f, 
    -0.06232699f, -0.15698566f, -0.15531427f, 0.06987665f, 0.04568644f, -0.17712578f, 0.04433642f, -0.00810289f, 
    -0.15765277f, 0.16137037f, 0.13746190f, 0.07852069f, 0.17042603f, 0.03615033f, 0.13855217f, -0.05193252f, 
    -0.04475856f, -0.06002909f, 0.21356486f, -0.04925643f, 0.00676886f, 0.07155176f, -0.00602376f, -0.02734013f, 
    0.12037638f, 0.05960176f, -0.04208121f, 0.05377617f, -0.02885810f, 0.03501798f, 0.08285794f, 0.08898819f, 
    -0.01509646f, 0.06856684f, 0.11589772f, 0.00179955f, 0.08539548f, 0.17325254f, -0.10687084f, 0.06492632f, 
    -0.02119715f, -0.09248744f, -0.02463746f, 0.04917317f, -0.07853360f, -0.25581944f, -0.09904081f, -0.12489153f, 
    0.10157071f, -0.09927979f, 0.03204529f, -0.03272269f, -0.16124086f, 0.07299586f, -0.17422298f, -0.26221797f, 
    -0.10098512f, 0.09040408f, -0.01075149f, 0.10261378f, -0.09533425f, -0.01492691f, 0.09090137f, 0.05930076f, 
    -0.08146405f, 0.07117970f, 0.07729898f, -0.08575209f, 0.12175886f, -0.09786181f, -0.00026237f, -0.07903784f, 
    -0.27791640f, -0.16924481f, -0.01107633f, -0.11103662f, -0.03438620f, -0.02921201f, -0.00817727f, -0.04427919f, 
    0.06437363f, 0.03826108f, -0.05630111f, 0.02469784f, 0.05569913f, 0.00771565f, -0.05314725f, -0.09137331f, 
    -0.11787071f, 0.03901885f, 0.15906844f, 0.01003358f, -0.10667153f, -0.06924685f, -0.14266726f, -0.02396928f, 
    -0.05191309f, -0.12119067f, -0.00225317f, 0.15027553f, 0.11495423f, -0.08712381f, 0.04146602f, 0.06871708f, 
    0.00318672f, 0.05325288f, 0.06000311f, 0.02989492f, -0.51154214f, -0.37592810f, -0.23192312f, -0.04375503f, 
    -0.03331897f, -0.03194071f, -0.10612636f, 0.06127615f, 0.05231252f, 0.40964830f, 0.30560172f, 0.01202514f, 
    0.03097634f, 0.03583730f, 0.00937773f, 0.05449039f, -0.09254476f, -0.02143037f, -0.01469361f, -0.00784041f, 
    0.03246135f, 0.02682977f, -0.01230118f, -0.04079299f, 0.12383201f, -0.14175971f, 0.10849487f, 0.03860776f, 
    0.11927959f, -0.07378878f, 0.08789419f, 0.00870167f, -0.01725748f, 0.02812744f, -0.04605349f, -0.10649668f, 
    -0.04011708f, -0.09727548f, 0.06269073f, 0.12832633f, -0.01345459f, 0.02431933f, -0.08375049f, -0.08407281f, 
    0.10625212f, 0.43679327f, 0.27335024f, 0.24510460f, -0.10400011f, -0.01549616f, 0.08560455f, 0.06595617f, 
    0.11237070f, -0.07775884f, 0.20298257f, 0.20856605f, 0.10520243f, 0.13857245f, 0.16165362f, 0.00657897f, 
    -0.05625343f, -0.00481706f, 0.07279578f, -0.03245113f, 0.11911306f, -0.06855071f, 0.02953160f, -0.09100331f, 
    0.02348795f, -0.13706879f, -0.05072138f, 0.06713479f, 0.23657687f, 0.06287866f, 0.15053089f, 0.05571747f, 
    0.07770950f, 0.17864156f, 0.00938453f, -0.00072810f, -0.06807454f, 0.07502144f, 0.17995478f, 0.02829701f, 
    0.10621661f, 0.05332086f, -0.02018802f, 0.02950365f, -0.04324159f, -0.04160446f, 0.12707432f, 0.04728013f, 
    -0.15831907f, 0.03774504f, -0.07670375f, 0.10135485f, -0.14618315f, -0.00416377f, -0.03215164f, -0.06246564f, 
    0.07721040f, -0.14024816f, 0.00654798f, -0.09429047f, -0.02717089f, -0.01757106f, 0.05734670f, -0.05232785f, 
    0.05802168f, -0.16067377f, -0.10599168f, 0.02812376f, 0.09223345f, -0.01824696f, 0.04048231f, -0.03944848f, 
    -0.04935251f, 0.14378057f, -0.00272322f, -0.02680739f, 0.02075862f, 0.05952412f, -0.07789481f, -0.02994941f, 
    -0.02760703f, 0.08771770f, 0.07451032f, -0.03717246f, -0.03896185f, 0.06606252f, 0.03330782f, -0.14121619f, 
    0.12913068f, -0.03813156f, 0.07947916f, 0.11915775f, -0.12591462f, -0.06586489f, -0.06334487f, -0.00485617f, 
    0.06552605f, -0.00312102f, -0.05487084f, -0.02756887f, -0.10967945f, 0.13200200f, -0.18284042f, -0.01054748f, 
    -0.09570985f, -0.12441481f, -0.03590049f, 0.04097465f, -0.02677897f, 0.34143391f, 0.19714358f, -0.01137426f, 
    0.06970851f, -0.05839865f, 0.00900051f, 0.06572922f, -0.09753305f, -0.08702908f, -0.30839482f, -0.19292516f, 
    0.02531886f, -0.11068248f, -0.08609007f, 0.08077498f, -0.06921115f, 0.00156624f, -0.05618346f, -0.00222036f, 
    -0.14059551f, 0.08837295f, 0.04593315f, 0.17764080f, -0.01452813f, 0.00567498f, 0.12227454f, 0.15721102f, 
    -0.04539450f, 0.15254238f, 0.08618639f, 0.03957180f, -0.01283243f, -0.07188284f, -0.06101257f, -0.03190840f, 
    0.11160827f, -0.21494991f, -0.16483153f, -0.05689001f, 0.00129401f, -0.16831860f, -0.03457204f, -0.11686224f, 
    0.04182310f, -0.00408084f, -0.13032074f, -0.09821066f, 0.11463740f, -0.18254441f, 0.10212846f, -0.00460495f, 
    0.06722925f, -0.01249718f, 0.03098579f, 0.19210523f, 0.32279202f, -0.06074711f, 0.04422921f, 0.00195466f, 
    -0.07958267f, -0.04313434f, -0.00399745f, -0.03930808f, 0.24791487f, 0.21756318f, 0.03693897f, 0.12816709f, 
    -0.02589919f, -0.03557137f, -0.00106031f, 0.02902841f, 0.04738514f, 0.18865032f, 0.07238262f, -0.02718570f, 
    -0.14681096f, 0.04800807f, -0.06615892f, 0.01554000f, 0.01452723f, -0.05415439f, 0.01713469f, -0.17061840f, 
    0.05357799f, -0.13540725f, -0.11116927f, 0.10372644f, 0.11153697f, -0.00566029f, 0.06095095f, 0.01861338f, 
    -0.10442164f, -0.07427406f, 0.04448725f, -0.02509774f, 0.09583659f, 0.04920494f, -0.02548525f, 0.06410421f, 
    0.07382774f, -0.11076159f, 0.11640457f, 0.13511157f, 0.07922351f, -0.12051973f, -0.10180743f, 0.07854028f, 
    0.16446978f, -0.07611169f, 0.16423659f, 0.03366363f, 0.03187811f, -0.13792439f, 0.06400068f, -0.00409915f, 
    0.03450823f, 0.02421059f, -0.23571110f, 0.10149692f, 0.04392795f, 0.02119003f, 0.00675143f, -0.00289050f, 
    0.15708199f, 0.01384219f, -0.15902103f, 0.03592459f, -0.19524889f, 0.08855066f, 0.12073217f, 0.04311370f, 
    -0.11971813f, 0.03690307f, -0.20081602f, 0.01898136f, 0.07853018f, -0.00451971f, 0.07624821f, -0.16204731f, 
    -0.07999796f, -0.18433967f, 0.09830633f, 0.08266100f, 0.13095027f, 0.09387935f, -0.11180831f, 0.00582710f, 
    0.03372621f, 0.07377913f, 0.05080811f, -0.04987227f, -0.10602527f, -0.03498989f, -0.10260191f, -0.21131161f, 
    -0.02430687f, 0.15246387f, 0.07843574f, -0.22010367f, 0.17324603f, 0.07485131f, -0.03896971f, -0.08220506f, 
    -0.11485078f, -0.02084942f, 0.07874501f, -0.00339371f, 0.00260919f, -0.04906879f, -0.10394564f, 0.08625113f, 
    -0.15500343f, 0.03412011f, 0.20996276f, 0.03350335f, 0.05665252f, 0.22593628f, 0.08807125f, -0.02355016f, 
    -0.21290374f, -0.03851957f, -0.16706769f, -0.11817628f, 0.22310735f, -0.11704405f, -0.05186519f, 0.08495843f, 
    -0.00941195f, 0.13985632f, 0.14329882f, 0.00507348f, 0.14880432f, 0.22013822f, 0.02200196f, 0.10750320f, 
    -0.20697255f, -0.02574723f, -0.09086132f, -0.18609430f, 0.21847877f, 0.16894211f, -0.16389997f, -0.03017607f, 
    0.04931400f, -0.09154531f, -0.01341649f, -0.15484069f, 0.34417030f, 0.01966235f, 0.00068540f, 0.02909577f, 
    -0.09669963f, 0.09673761f, 0.00636909f, -0.00744334f, 0.13356610f, -0.06877703f, 0.15368482f, -0.12210332f, 
    0.06781238f, 0.00784523f, 0.05523587f, 0.08361003f, -0.09014156f, -0.23470321f, 0.23451743f, -0.32681069f, 
    -0.19983171f, -0.00698842f, 0.14916368f, -0.01568810f, 0.10629206f, 0.06327868f, 0.00898830f, 0.06838761f, 
    -0.09762456f, 0.02096981f, -0.15306006f, 0.01738016f, -0.12645344f, 0.09848758f, 0.03059374f, 0.01073211f, 
    0.15157966f, -0.36362571f, -0.04352825f, -0.01808489f, -0.16252391f, -0.09946267f, -0.05666946f, 0.15937349f, 
    -0.02148585f, 0.06132954f, 0.10749843f, 0.07312319f, 0.14851281f, -0.10410348f, 0.04609933f, 0.23282987f, 
    0.13016286f, -0.09149826f, -0.01381717f, 0.23902182f, 0.14041823f, -0.25146034f, 0.04600104f, 0.02908037f, 
    0.08317486f, 0.11496282f, 0.02074491f, -0.13854694f, -0.27222648f, 0.04665140f, 0.29892382f, -0.04685379f, 
    0.04958413f, -0.02754373f, 0.14153685f, 0.04558128f, 0.10320690f, 0.19794689f, 0.22375995f, -0.11957114f, 
    -0.25928655f, 0.09070253f, 0.23643157f, 0.02237240f, -0.08547276f, -0.02463018f, -0.28126395f, 0.07663651f, 
    0.10291837f, -0.04190232f, 0.01880391f, -0.15088579f, -0.12064023f, 0.04499257f, -0.05775379f, 0.06851467f, 
    0.11092132f, -0.00345926f, -0.03662932f, -0.19023156f, -0.13002579f, 0.11886553f, 0.13579664f, 0.03801529f, 
    -0.09403123f, -0.08632532f, -0.05051731f, -0.10249858f, 0.00858836f, 0.27462170f, 0.08964340f, -0.02674654f, 
    0.42390460f, -0.10963536f, 0.12224000f, -0.18693405f, 0.01743986f, 0.13099818f, -0.12212326f, 0.09471853f, 
    0.05951238f, 0.14567164f, 0.18232132f, -0.02518210f, -0.08906596f, -0.00534414f, -0.05118080f, 0.18461142f, 
    0.08029287f, 0.24082957f, 0.27348503f, 0.04495496f, -0.07239636f, -0.04222303f, -0.05136088f, 0.02147193f, 
    0.11828042f, 0.18618697f, 0.05893102f, 0.03027948f, -0.01071503f, -0.04438316f, -0.02016876f, 0.07649059f, 
    -0.05691947f, -0.09041769f, -0.06568123f, 0.19011147f, 0.00057421f, -0.20999576f, -0.02848644f, 0.08620430f, 
    0.02535716f, -0.08454568f, 0.12386307f, 0.11341512f, -0.12037566f, -0.14357182f, 0.09846525f, 0.23651230f, 
    -0.12048398f, 0.09716710f, 0.01351345f, -0.00807157f, -0.01457906f, -0.01099472f, -0.01448442f, -0.04090156f, 
    -0.05032964f, 0.19148712f, 0.02831814f, 0.11697040f, -0.03635421f, -0.02980694f, -0.21265075f, 0.05949647f, 
    0.06298184f, 0.14436539f, 0.06724494f, 0.06715070f, 0.13984978f, 0.21869685f, -0.05058939f, 0.01370178f, 
    0.07981322f, -0.04093672f, -0.39483765f, 0.04119776f, 0.02924870f, 0.00199144f, -0.16081929f, 0.00411418f, 
    -0.02428161f, 0.15836419f, 0.13293774f, 0.01225711f, 0.11532070f, 0.05045285f, 0.07377930f, -0.02575193f, 
    0.06650082f, 0.21109553f, 0.20450649f, 0.05927606f, 0.11645147f, 0.17775115f, 0.08094624f, 0.07447180f, 
    0.14157890f, 0.05682700f, 0.20358177f, -0.05069457f, 0.11202140f, -0.07938381f, 0.05854227f, -0.00688509f, 
    -0.25043276f, -0.04763127f, 0.07961715f, 0.14480801f, 0.09400539f, -0.08094548f, -0.23459776f, -0.03020444f, 
    0.18004927f, 0.16041142f, -0.07815597f, 0.04983710f, 0.01374128f, -0.18897216f, -0.07312739f, 0.01030323f, 
    0.02760989f, 0.08768005f, -0.08004925f, -0.06834900f, -0.09207445f, -0.10637780f, -0.09050255f, 0.00881356f, 
    0.03192271f, 0.10409610f, 0.11716715f, 0.06146683f, -0.04097008f, -0.12086135f, 0.15258504f, -0.07132808f, 
    -0.03821339f, 0.11667985f, -0.09724556f, 0.05436516f, 0.12581927f, -0.03614781f, -0.10854282f, 0.00929203f, 
    0.08123228f, -0.17652611f, -0.01579815f, 0.03227647f, 0.08664131f, -0.10530332f, -0.19886878f, 0.06675754f, 
    -0.01796077f, 0.01771931f, 0.17663975f, -0.26624331f, -0.02510367f, 0.03152367f, -0.01894904f, 0.02810376f, 
    0.16287403f, 0.01107258f, -0.31589374f, -0.25696072f, -0.12173666f, -0.01762799f, -0.06451543f, -0.07931103f, 
    0.09959391f, 0.07593016f, -0.04864468f, 0.37987089f, 0.01967777f, 0.07531682f, 0.04140010f, -0.10738757f, 
    -0.10344460f, 0.02673862f, 0.09494128f, 0.01148737f, -0.20693734f, -0.03405325f, 0.12223289f, -0.08545135f, 
    0.01015633f, -0.09670209f, -0.05979190f, -0.00081379f, -0.15439229f, -0.41626474f, 0.01122840f, 0.02383035f, 
    -0.01654680f, 0.04738421f, 0.06652002f, 0.00482647f, 0.10315721f, -0.11074597f, 0.15916720f, -0.00341556f, 
    -0.03040811f, -0.03995692f, 0.07981349f, 0.00314589f, 0.08947746f, 0.01403923f, 0.02303643f, 0.04968936f, 
    -0.03424493f, -0.14412044f, -0.18441558f, 0.05310720f, -0.01200631f, 0.05827373f, 0.06302464f, -0.05902153f, 
    -0.07552160f, 0.03923306f, -0.05077560f, 0.11722827f, -0.01286912f, 0.03343011f, 0.03764092f, -0.07128331f, 
    0.06796220f, 0.01668212f, 0.12864560f, 0.02444189f, 0.01326048f, 0.09027581f, 0.01919367f, -0.08942951f, 
    0.02828401f, 0.08781803f, 0.33297369f, 0.06308613f, 0.08679139f, 0.00424963f, 0.02171789f, 0.13835491f, 
    0.06045158f, 0.10173229f, 0.01504893f, 0.07912604f, -0.01078186f, 0.07970101f, 0.13188007f, 0.09761103f, 
    0.03426121f, 0.00646640f, -0.05224237f, 0.08520619f, 0.39741239f, 0.08991572f, -0.07685387f, -0.00900584f, 
    -0.08996066f, -0.00908652f, -0.08107375f, -0.06670113f, 0.01133850f, -0.04401698f, -0.01118157f, -0.07560358f, 
    0.08483323f, 0.12643610f, 0.00231106f, -0.14568140f, -0.03286566f, -0.12147538f, 0.09104942f, 0.09006327f, 
    -0.13398688f, 0.12574284f, 0.03481777f, -0.01857649f, 0.06350857f, 0.00094978f, -0.03660284f, -0.19475690f, 
    -0.14498541f, 0.04282954f, 0.07533173f, -0.01407952f, 0.11195255f, 0.06041169f, 0.01824045f, -0.18270896f, 
    -0.33611438f, -0.29319859f, 0.10790034f, -0.24890389f, 0.08099721f, 0.05437799f, -0.13092570f, 0.08478002f, 
    -0.01734515f, -0.09681159f, -0.02908080f, -0.31874573f, -0.00187745f, 0.01265667f, 0.14198855f, -0.13333540f, 
    0.02086493f, -0.15239637f, -0.05208124f, -0.02543066f, 0.03213276f, 0.07410793f, 0.00876439f, 0.06037394f, 
    0.11588765f, -0.06775278f, 0.01660307f, -0.06576595f, -0.02769629f, -0.11950385f, -0.05085180f, 0.03133646f, 
    0.12227256f, 0.01392494f, -0.08225536f, -0.05751749f, -0.00607797f, -0.17239965f, -0.02807603f, -0.02224315f, 
    0.02048237f, 0.12261822f, -0.09410892f, -0.13479790f, 0.08895634f, 0.41206354f, 0.02133927f, -0.00538513f, 
    0.05633880f, -0.07307129f, 0.08538053f, 0.04997674f, 0.01911611f, 0.07233119f, -0.11853103f, -0.09797692f, 
    0.05062950f, 0.09002446f, 0.06336142f, 0.02973197f, 0.10027674f, 0.08679279f, 0.03569350f, 0.19953832f, 
    -0.13056533f, -0.06786942f, 0.03236077f, 0.05711039f, -0.10180631f, 0.02561534f, -0.03026366f, 0.06173804f, 
    0.05838040f, -0.25184077f, 0.08282765f, 0.01906390f, 0.04280757f, 0.08719725f, 0.11595039f, -0.21832022f, 
    0.03825502f, 0.21238144f, -0.39598343f, 0.05879685f, -0.08298416f, -0.04130419f, -0.00970876f, -0.00464046f, 
    -0.17763427f, 0.02509928f, 0.07718925f, -0.30016693f, -0.08027586f, -0.02931889f, -0.08170275f, 0.07564896f, 
    0.09580112f, 0.00068601f, 0.02257849f, -0.13419418f, -0.01510995f, 0.03544480f, 0.19940428f, -0.10044568f, 
    -0.06120348f, 0.09317302f, -0.02996220f, 0.01567778f, 0.05782001f, -0.12530896f, -0.20312414f, -0.17297690f, 
    -0.14587553f, 0.05526222f, -0.10555913f, 0.05321391f, 0.06812278f, 0.12301756f, 0.10519423f, 0.12542965f, 
    -0.02514671f, -0.00165513f, -0.08958542f, 0.11512184f, 0.04874563f, 0.12522306f, -0.26131111f, -0.33483014f, 
    -0.01636995f, -0.05583463f, 0.10420340f, 0.07676258f, -0.14150402f, 0.14736740f, -0.06743754f, 0.12858622f, 
    -0.10411998f, 0.12943192f, 0.05123762f, 0.00173839f, 0.13206936f, -0.07506028f, 0.11173241f, -0.05686540f, 
    -0.20997223f, -0.05703593f, -0.06527977f, 0.12838693f, 0.05100482f, 0.05671895f, -0.05126375f, 0.11091342f, 
    0.00708579f, 0.00790020f, 0.07577066f, 0.09193665f, -0.03547691f, 0.04501000f, 0.00751895f, -0.04036983f, 
    -0.03677519f, 0.05048155f, -0.01520700f, 0.01280570f, 0.07103442f, 0.02195921f, 0.00498382f, -0.03844042f, 
    0.14352861f, 0.20500331f, 0.13890059f, 0.30301920f, -0.44782567f, 0.17177080f, -0.22097147f, -0.00225061f, 
    0.07979354f, 0.08873671f, -0.03939470f, 0.10682768f, 0.20491692f, -0.21083568f, 0.00645686f, 0.03329846f, 
    0.13109899f, 0.00307351f, -0.01057493f, -0.01370462f, 0.20159754f, 0.13457732f, -0.08657638f, -0.06154206f, 
    0.05014177f, -0.12164698f, -0.19962583f, 0.04030684f, 0.08359858f, -0.02803338f, 0.23114088f, -0.05304020f, 
    -0.36832654f, 0.21269313f, 0.07320999f, -0.08689950f, 0.10553420f, -0.02495357f, -0.10236313f, 0.18846895f, 
    0.02162895f, -0.04496977f, 0.05289033f, 0.03071530f, 0.01149133f, 0.10608790f, 0.10065342f, -0.08358569f, 
    0.45327157f, -0.02884079f, 0.15474883f, -0.22879452f, 0.03669849f, -0.22136551f, 0.03955000f, -0.02244885f, 
    0.18062140f, -0.23265137f, -0.22989528f, 0.00087992f, 0.08067148f, 0.03955502f, 0.04798351f, -0.03203149f, 
    -0.00950637f, 0.03489281f, -0.05350609f, -0.31963083f, -0.11600681f, -0.09168515f, 0.04969170f, -0.03517447f, 
    0.20276193f, 0.06264222f, -0.08140980f, -0.24839194f, -0.40284401f, 0.11172304f, 0.01351547f, 0.00341104f, 
    -0.19620949f, -0.07826313f, 0.16456507f, 0.04676265f, 0.43391192f, -0.23353027f, 0.02817440f, -0.01529632f, 
    -0.12606472f, 0.10799050f, 0.09554929f, 0.10286711f, 0.03921032f, 0.06753782f, 0.04201235f, 0.16031572f, 
    0.01771965f, -0.03628896f, 0.03500212f, -0.00439850f, 0.06468988f, -0.05508793f, 0.08804976f, -0.12956384f, 
    0.08040527f, -0.05579213f, 0.09970684f, 0.02676885f, -0.00658769f, -0.19454308f, 0.06441884f, -0.05713939f, 
    -0.07592677f, 0.20630664f, 0.04697750f, -0.07065819f, 0.09280091f, -0.02717553f, 0.02158677f, 0.14422026f, 
    -0.06503060f, -0.08439829f, 0.11499874f, -0.08765693f, -0.12491503f, 0.02291605f, 0.07132440f, 0.07169634f, 
    0.10854697f, 0.08256947f, 0.05888833f, -0.06702034f, -0.00094806f, 0.03942915f, -0.01023300f, -0.07673870f, 
    0.01479446f, -0.09655911f, -0.08923063f, -0.12510376f, 0.09845794f, 0.07278714f, -0.08488296f, 0.13067822f, 
    0.02471524f, 0.03192803f, 0.03900098f, -0.04397768f, -0.01434270f, 0.12075235f, -0.02230390f, -0.07060918f, 
    -0.01438639f, 0.02946221f, 0.10500448f, 0.00470646f, 0.06516726f, 0.04538058f, -0.02896005f, 0.08677517f, 
    0.23728907f, -0.02926649f, 0.07224896f, -0.07874136f, 0.04004608f, -0.44045722f, -0.00639493f, 0.13183498f, 
    0.00209853f, -0.00552415f, -0.02999330f, 0.05431709f, -0.08400445f, 0.02270355f, -0.30697748f, -0.06924721f, 
    -0.31203315f, 0.18214810f, 0.01806767f, 0.16300593f, -0.04495332f, -0.09262646f, 0.05992334f, -0.09675127f, 
    -0.05643149f, -0.09575533f, 0.15901682f, -0.00559180f, 0.16658585f, -0.07509091f, 0.07525453f, 0.18281385f, 
    0.05768451f, -0.08580276f, 0.03243871f, 0.12610784f, 0.09956674f, -0.05703015f, -0.06964738f, 0.02357283f, 
    -0.15574332f, 0.14904243f, 0.00647293f, -0.06838398f, 0.06163174f, 0.00252485f, 0.04372253f, -0.04492555f, 
    -0.04644436f, -0.05252215f, -0.10703567f, -0.01341443f, -0.14292660f, 0.02137758f, 0.02830891f, 0.10750777f, 
    0.04169993f, -0.03042307f, -0.02802275f, -0.03098683f, -0.41140509f, -0.00192700f, -0.10064533f, 0.04283122f, 
    -0.06357656f, -0.04866441f, -0.09909890f, -0.02383354f, 0.06384628f, -0.03056396f, 0.04148590f, 0.22991192f, 
    0.06416050f, -0.13896199f, 0.08776751f, -0.09071968f, 0.03847563f, 0.29918841f, 0.00529982f, -0.01016243f, 
    0.08958187f, 0.08300404f, 0.02134712f, 0.07099397f, -0.24171518f, 0.11816698f, -0.16938280f, 0.10140079f, 
    0.01949445f, 0.10195586f, -0.06530754f, 0.09136513f, 0.14081353f, -0.02051024f, -0.17520721f, 0.16172947f, 
    -0.15172464f, -0.30051199f, 0.00562533f, 0.01071168f, 0.08774319f, -0.05341134f, -0.03208537f, 0.03351723f, 
    0.21026345f, 0.01464195f, 0.08458555f, -0.01388976f, 0.11641061f, 0.01581135f, -0.18995415f, -0.09139951f, 
    0.10447416f, -0.21573834f, -0.01677009f, -0.01874665f, -0.14032173f, -0.02732519f, 0.04688141f, 0.13255623f, 
    -0.16658819f, -0.18443014f, 0.50110900f, 0.11830898f, 0.08378467f, -0.09699856f, 0.05496899f, 0.30220044f, 
    0.00679782f, -0.18672173f, 0.05786762f, 0.25726312f, 0.02043390f, -0.11744986f, 0.02498022f, -0.04809049f, 
    0.05784181f, -0.07780007f, -0.27013937f, -0.17582293f, 0.20173354f, -0.01946405f, 0.02932633f, -0.24723944f, 
    0.07016651f, 0.05904470f, 0.01982262f, 0.01044567f, 0.08634016f, 0.15796913f, 0.10075235f, -0.14250730f, 
    -0.09709287f, -0.00698666f, 0.07180043f, -0.11422233f, -0.13110520f, 0.14800343f, 0.08065241f, -0.14447016f, 
    -0.07811862f, 0.10151228f, 0.07611039f, 0.07248911f, -0.03232631f, 0.10982145f, 0.18658334f, -0.06419956f, 
    0.01589007f, -0.05009592f, 0.01795903f, 0.03183061f, 0.12317630f, 0.00551739f, -0.07604890f, 0.08894221f, 
    0.28920737f, -0.08711930f, -0.13905379f, 0.05231680f, 0.04983183f, 0.05981595f, -0.19038767f, 0.02102397f, 
    -0.17400828f, -0.08415100f, -0.16828898f, 0.03516233f, -0.01550953f, 0.01263770f, -0.10867060f, -0.06274039f, 
    0.08270480f, 0.09847713f, 0.20252730f, 0.15942322f, 0.03617644f, 0.14528270f, -0.06108437f, 0.08028626f, 
    -0.00898792f, -0.11183206f, 0.09843276f, 0.08024014f, -0.13908049f, -0.05465657f, -0.09906755f, 0.03671902f, 
    -0.00009288f, -0.04116302f, -0.04624778f, 0.11838111f, 0.20581347f, 0.05445695f, -0.00826085f, -0.20235123f, 
    0.02674743f, -0.04249245f, 0.22875875f, -0.05263701f, -0.00734128f, 0.33117238f, 0.03825367f, -0.15056521f, 
    -0.03683948f, 0.04201195f, 0.03860425f, -0.07490258f, -0.03519779f, -0.21225014f, 0.24809049f, -0.00246873f, 
    -0.08845729f, 0.15148565f, 0.08233022f, -0.04146343f, 0.06567564f, 0.04452198f, 0.01985152f, 0.36110204f, 
    0.01848505f, 0.17927298f, 0.01336416f, 0.03345548f, -0.02699181f, 0.00727366f, -0.03940079f, -0.14531279f, 
    0.33577445f, -0.10382001f, -0.02973727f, -0.15028295f, -0.15357579f, 0.29813644f, -0.22906335f, -0.12643352f, 
    0.06188079f, -0.06120279f, -0.10021677f, -0.06516214f, 0.12084162f, 0.13569288f, -0.16696131f, 0.18755652f, 
    0.08713169f, -0.18002369f, -0.03806958f, -0.27949297f, -0.02806262f, -0.03858145f, 0.09712221f, -0.09468447f, 
    0.14235105f, -0.01999021f, -0.05157536f, 0.09762751f, 0.14497720f, -0.18009584f, 0.07224850f, -0.05030530f, 
    0.04635363f, 0.11455479f, -0.04412796f, 0.00493108f, 0.14387496f, -0.27125680f, 0.07200246f, -0.02910023f, 
    0.02658588f, 0.05266577f, -0.00343292f, -0.22841008f, 0.01337041f, 0.11838627f, -0.11515171f, -0.01374447f, 
    0.01191382f, 0.02628468f, -0.05115243f, -0.05588331f, -0.05662536f, -0.12485503f, 0.00273450f, -0.01000017f, 
    0.05997317f, -0.06143960f, 0.02758902f, -0.00908171f, 0.17608994f, -0.21962878f, 0.07560417f, 0.01031058f, 
    -0.01173420f, 0.05814142f, 0.04538556f, -0.01892544f, -0.02076795f, -0.00021823f, 0.02562759f, 0.14261693f, 
    -0.06643250f, -0.00756151f, -0.05562630f, 0.08754035f, 0.05337931f, 0.02940434f, -0.03578528f, 0.07565708f, 
    -0.08655377f, 0.08944349f, -0.01456663f, -0.08847073f, -0.00498190f, 0.09219072f, 0.07792596f, 0.04666805f, 
    -0.00933408f, -0.01305249f, 0.12247892f, 0.15946977f, 0.21089120f, 0.07112033f, 0.11554226f, -0.03017784f, 
    -0.04204375f, 0.00284271f, 0.00075247f, -0.09324866f, 0.00809879f, 0.14724642f, -0.05848918f, 0.03331806f, 
    -0.04366818f, -0.02748655f, -0.08800603f, 0.12056648f, 0.06321993f, -0.29246223f, -0.03581856f, 0.14833586f, 
    -0.01864107f, -0.00366197f, 0.13437010f, 0.04531825f, 0.18337090f, -0.48899403f, -0.09266009f, 0.06820909f, 
    0.06949104f, -0.09114619f, 0.04687339f, 0.04839489f, -0.11324371f, 0.06981678f, 0.29711333f, 0.13020453f, 
    0.09257827f, -0.12214871f, 0.02153087f, -0.00705819f, 0.17248793f, 0.03390381f, 0.01422898f, 0.06426053f, 
    -0.08569743f, -0.49939147f, 0.00652340f, 0.03661025f, 0.04582600f, -0.09712733f, 0.13731843f, 0.11807461f, 
    0.16516502f, 0.09830884f, -0.04688951f, 0.09831531f, -0.06376812f, -0.10447589f, 0.05854170f, -0.00592728f, 
    0.02966573f, 0.06312653f, -0.25009152f, 0.30394208f, 0.10592100f, -0.09664167f, -0.00274889f, 0.16044554f, 
    -0.02071131f, -0.15460187f, -0.03101973f, -0.24341455f, 0.04240586f, 0.01487584f, -0.11137167f, -0.16310970f, 
    0.05424674f, -0.00853506f, -0.05051218f, 0.10712256f, -0.27874592f, 0.21612328f, 0.05218752f, -0.00685502f, 
    -0.07497226f, -0.02923046f, -0.02180953f, 0.07086043f, -0.25570732f, -0.09481671f, -0.11675277f, 0.11399601f, 
    -0.12943482f, -0.08062797f, -0.02696781f, 0.07746590f, 0.05462175f, 0.07250258f, -0.10827009f, 0.13163093f, 
    -0.15049948f, -0.09771950f, -0.08724841f, -0.12833983f, 0.04884247f, 0.00277868f, -0.28729922f, -0.21217728f, 
    -0.09969692f, 0.03035320f, -0.04372459f, -0.04701465f, 0.09006627f, 0.00423641f, 0.05854211f, -0.04630459f, 
    -0.33523515f, -0.06290619f, 0.15622078f, 0.05757857f, 0.04627484f, 0.06268421f, -0.06654787f, 0.00900153f, 
    -0.17832218f, -0.04813128f, -0.04406019f, -0.09449618f, -0.03636261f, 0.03199398f, -0.01100442f, 0.02458212f, 
    -0.00687595f, -0.02918950f, 0.03110082f, 0.07896009f, 0.07473463f, 0.07618697f, 0.02264986f, 0.06907378f, 
    0.02342449f, 0.05927464f, -0.06102467f, -0.05802570f, 0.11388638f, 0.05141758f, 0.13990138f, -0.02429046f, 
    0.10225233f, 0.01197894f, 0.00332791f, -0.09913472f, 0.05740327f, -0.22700745f, 0.01611447f, -0.12412838f, 
    -0.05152731f, -0.01176695f, 0.00801449f, -0.02745246f, -0.08013932f, -0.02987914f, 0.10638905f, 0.16088346f, 
    -0.07418421f, -0.19231784f, 0.07725611f, 0.07287439f, 0.06405678f, -0.75089663f, 0.18312900f, 0.05901003f, 
    -0.06561787f, -0.02929849f, -0.00545515f, 0.05645975f, -0.06116394f, -0.01438237f, -0.04933342f, 0.12419673f, 
    -0.17030817f, -0.00878869f, 0.07960203f, 0.01311595f, 0.01591907f, 0.04158996f, 0.08135650f, -0.13856156f, 
    -0.12117957f, -0.15311344f, -0.03550529f, -0.04425777f, -0.05495984f, -0.16721670f, 0.05445594f, 0.07897972f, 
    0.08900289f, -0.11647258f, -0.13059416f, -0.06456450f, 0.00043459f, 0.09392576f, 0.00285809f, 0.09575740f, 
    -0.02932703f, -0.20084487f, -0.09563426f, -0.00571766f, 0.05175853f, 0.09570797f, 0.03110347f, 0.04320978f, 
    0.02206997f, -0.02874907f, -0.30879545f, -0.21969905f, -0.07193634f, -0.04037865f, 0.05805311f, 0.10468099f, 
    0.12290181f, 0.07986441f, 0.02038493f, -0.27992287f, 0.13068588f, -0.07167044f, -0.04445556f, -0.09021618f, 
    -0.01979286f, -0.05679828f, 0.05033524f, -0.11456418f, -0.31428993f, -0.26604763f, 0.29198229f, 0.08022182f, 
    -0.03769842f, -0.06964239f, -0.10342964f, 0.09104662f, -0.02357071f, 0.07188857f, 0.23244134f, -0.01895272f, 
    0.10494447f, 0.08731875f, -0.04444003f, 0.00240448f, -0.04042891f, 0.04149050f, 0.08497645f, 0.08691578f, 
    0.06641011f, 0.16494447f, -0.01052714f, 0.03084468f, 0.02393795f, -0.06748080f, 0.01021520f, 0.05177626f, 
    -0.06967659f, 0.01146558f, -0.04378359f, -0.03897901f, -0.04781025f, 0.01827584f, -0.02932849f, 0.00296666f, 
    0.19477592f, 0.12901695f, 0.03229867f, -0.05719919f, -0.07439489f, 0.08942372f, 0.02617419f, 0.00693078f, 
    -0.05657471f, 0.10076860f, 0.13553829f, 0.03077370f, 0.09382606f, 0.11477309f, 0.13492876f, 0.17305326f, 
    -0.07454443f, 0.08130582f, 0.09703161f, 0.19832039f, 0.09638134f, 0.12897022f, 0.10544977f, -0.05822487f, 
    -0.01617944f, -0.04636170f, 0.22847599f, -0.02548423f, 0.03050875f, 0.21170239f, -0.05038730f, 0.11191752f, 
    -0.09375969f, 0.03548248f, 0.07254966f, -0.17831603f, 0.03501865f, -0.33610612f, -0.28289378f, 0.13525417f, 
    0.01635570f, 0.17432185f, -0.10435931f, 0.09201615f, 0.03366238f, -0.07284670f, -0.06805193f, 0.25148970f, 
    0.02783619f, -0.01272683f, 0.07191819f, -0.05345438f, -0.04690149f, -0.07544309f, 0.17955013f, 0.22383483f, 
    0.12611862f, -0.12318806f, -0.06220890f, -0.04395961f, 0.09512150f, 0.06139920f, 0.15484811f, 0.04902608f, 
    0.27075690f, -0.16132645f, -0.07523322f, 0.01983552f, 0.23069213f, 0.07602765f, 0.05815630f, 0.05338071f, 
    0.28260812f, 0.06409752f, 0.01863878f, -0.02519215f, -0.26128998f, -0.00122617f, -0.05519480f, 0.13475858f, 
    -0.07478896f, 0.06872855f, 0.12598397f, 0.16731642f, -0.00464060f, 0.01181079f, -0.12551014f, 0.04779885f, 
    0.04446887f, 0.13482329f, 0.08914284f, -0.21879978f, -0.04021866f, -0.15743341f, 0.05239923f, -0.08582516f, 
    -0.07480969f, -0.12865306f, -0.12407582f, 0.06526457f, -0.38397434f, -0.12792625f, 0.24027127f, -0.01053697f, 
    -0.04350595f, 0.10646864f, -0.25789896f, 0.07461734f, 0.03581387f, 0.02057732f, -0.14381324f, -0.03313132f, 
    0.16922678f, -0.13904417f, 0.03974498f, -0.09166653f, -0.09808972f, 0.15496249f, -0.03359944f, 0.18629272f, 
    -0.12168688f, 0.02089916f, -0.05867061f, -0.07611082f, 0.09986562f, 0.07259151f, 0.21050081f, -0.18803188f, 
    -0.27867615f, 0.18613940f, 0.05984929f, 0.11209735f, -0.08774500f, -0.03272329f, -0.01016528f, 0.04885787f, 
    -0.16502485f, -0.27530238f, 0.10653009f, 0.04120952f, 0.16219981f, -0.01690478f, 0.03319794f, -0.08290859f, 
    -0.26204777f, -0.13740169f, 0.15261716f, -0.09199481f, 0.03573579f, 0.07719999f, 0.05714983f, -0.12232625f, 
    -0.03931111f, -0.03148172f, 0.16012950f, 0.14412957f, 0.13437994f, 0.11127937f, -0.05008000f, 0.03624115f, 
    -0.03254414f, 0.15811983f, -0.10270787f, -0.07741271f, -0.16379452f, 0.16412972f, 0.08074950f, 0.04254352f, 
    -0.06749011f, 0.12884691f, 0.01566254f, 0.04299353f, -0.11614277f, -0.12491889f, -0.16679293f, 0.06554482f, 
    -0.06197271f, -0.01537675f, -0.11709525f, 0.05568814f, -0.11384848f, -0.13124643f, -0.14835164f, 0.06051151f, 
    0.05164571f, 0.03710972f, -0.09725991f, -0.15401471f, -0.15161218f, -0.07311620f, 0.05105002f, 0.00430617f, 
    0.10234545f, -0.05272137f, 0.07887670f, 0.10084337f, -0.00245433f, -0.01919379f, 0.20786382f, 0.03070128f, 
    -0.06896651f, 0.13970660f, 0.09091931f, 0.11921372f, 0.05554147f, -0.04810588f, -0.02862030f, -0.02044683f, 
    -0.18169861f, -0.20638315f, 0.05648639f, -0.06176973f, 0.09415030f, 0.02045337f, -0.15572253f, 0.14555220f, 
    0.02243711f, 0.07997254f, 0.08672611f, -0.16512127f, 0.00478140f, -0.09435000f, 0.19360496f, -0.10229231f, 
    0.14134024f, 0.01161743f, 0.05167568f, -0.27687210f, 0.03254963f, 0.06580577f, 0.29253939f, 0.17425056f, 
    0.02065760f, -0.10619570f, -0.23382220f, 0.03258635f, -0.28712380f, 0.21368793f, 0.09064768f, -0.02545215f, 
    0.10494835f, -0.08411890f, -0.00084573f, 0.00003074f, 0.09487616f, 0.21250798f, 0.09657193f, 0.04135668f, 
    -0.15553938f, -0.09578606f, 0.14375725f, 0.05411631f, -0.04963716f, -0.18154286f, 0.19022045f, -0.05997549f, 
    -0.02540367f, 0.19938484f, -0.03084555f, -0.01272573f, -0.01289076f, 0.12944730f, 0.05949488f, -0.12538356f, 
    0.17391251f, -0.10980526f, 0.01255529f, 0.00061953f, 0.09320230f, 0.05395380f, 0.07702289f, 0.19602381f, 
    0.16570346f, -0.06572896f, -0.14047198f, -0.10715558f, 0.12120148f, 0.11066695f, 0.08830778f, -0.02286549f, 
    0.06043456f, -0.15181446f, -0.11970808f, -0.01259586f, -0.08244871f, 0.00772941f, -0.01154695f, -0.04678128f, 
    0.13263367f, 0.08525098f, -0.06257962f, 0.06283050f, -0.03433261f, 0.12455571f, -0.07299884f, 0.03854270f, 
    -0.13538647f, 0.07063046f, 0.13428283f, 0.05810685f, 0.04742365f, 0.01818224f, 0.02102298f, -0.04805636f, 
    0.02612321f, 0.13673905f, 0.18664712f, 0.07016117f, -0.00404636f, -0.08617581f, 0.06230148f, -0.02929371f, 
    -0.03077381f, 0.06306098f, 0.15147945f, -0.06206135f, 0.06548233f, -0.11411918f, 0.00577428f, -0.02348315f, 
    0.01749743f, 0.08767792f, 0.18897010f, -0.04790120f, 0.05062386f, 0.04434632f, -0.07941474f, 0.01984684f, 
    0.13937032f, 0.11745681f, 0.03705997f, -0.01672911f, -0.26935056f, -0.11013277f, -0.02695072f, -0.14389980f, 
    -0.10953788f, 0.07378700f, -0.07333467f, 0.18404078f, -0.13571416f, 0.00378070f, 0.00269505f, 0.13689023f, 
    0.14257728f, 0.01899883f, 0.04239737f, -0.06060449f, -0.11337902f, 0.06302612f, -0.11550850f, 0.02939378f, 
    -0.10584693f, 0.02344247f, -0.09783608f, -0.08863093f, 0.23158219f, 0.00562194f, -0.15619509f, -0.10301432f, 
    0.11659583f, -0.24111329f, 0.05472884f, -0.00505937f, -0.12069660f, -0.18004322f, 0.03970048f, -0.01167716f, 
    0.01123881f, -0.01119741f, 0.19621806f, -0.00957377f, 0.02604253f, 0.05234983f, -0.09506197f, -0.02243823f, 
    0.18518250f, 0.04109117f, 0.02975329f, -0.19955787f, -0.06713166f, -0.07923742f, -0.04132988f, -0.26652381f, 
    0.13420071f, -0.10372267f, 0.02544731f, 0.12128513f, -0.07344255f, -0.03138644f, -0.00689586f, -0.02581982f, 
    -0.23394050f, -0.01560651f, 0.04232747f, 0.12710109f, -0.00007334f, 0.04033992f, 0.16996405f, -0.05718079f, 
    -0.00013375f, -0.16925812f, 0.08265947f, 0.01287106f, -0.28529435f, -0.14903575f, -0.06143750f, -0.02437047f, 
    -0.08232830f, 0.09694302f, -0.02643467f, 0.09190804f, -0.01990603f, 0.09691940f, 0.14753799f, 0.30019981f, 
    0.00560913f, 0.02981257f, 0.00145803f, -0.02749455f, 0.11061744f, -0.06117497f, -0.00634947f, 0.18752308f, 
    0.00894566f, -0.07267994f, -0.02722469f, 0.04689740f, 0.04072715f, 0.12261771f, -0.02762507f, -0.08075280f, 
    -0.12813184f, -0.05608381f, -0.11770546f, 0.12213559f, -0.01590056f, 0.05074494f, -0.07466440f, 0.01532140f, 
    0.11424614f, -0.19503184f, 0.13738087f, -0.00912473f, 0.04248622f, 0.02857833f, 0.06857307f, -0.05301464f, 
    -0.11150026f, 0.06370257f, 0.25919735f, 0.18517160f, -0.03589511f, -0.06846011f, -0.03851367f, 0.15224107f, 
    0.06312808f, -0.10601317f, 0.07185779f, -0.04688766f, -0.05018642f, -0.05800323f, 0.01229211f, -0.12653576f, 
    0.04849175f, 0.05436102f, 0.00253683f, -0.04437426f, 0.04748241f, 0.14541276f, 0.03816579f, 0.20359363f, 
    -0.05866886f, 0.09474996f, -0.28877723f, -0.05777642f, -0.20147468f, 0.09001185f, 0.02388725f, -0.04485042f, 
    0.04811076f, 0.01424571f, -0.00358056f, 0.15940921f, -0.04579569f, 0.05188831f, 0.01111370f, 0.06530408f, 
    -0.01957021f, 0.18999211f, -0.08200985f, 0.03623167f, -0.12671880f, -0.04492968f, -0.08626000f, -0.10170938f, 
    -0.15350154f, 0.01818366f, -0.05903489f, 0.07349414f, 0.04341593f, 0.06680360f, -0.14082018f, 0.14946978f, 
    -0.32263374f, -0.10203131f, 0.01509185f, -0.05399363f, 0.00278912f, -0.19566385f, 0.06821361f, 0.08678108f, 
    0.09293689f, 0.02563584f, 0.05297082f, -0.12252429f, -0.07455616f, 0.08270590f, 0.14361605f, 0.05138122f, 
    -0.12888710f, -0.11033523f, -0.01980060f, -0.02382539f, 0.06162056f, 0.05949645f, -0.08891727f, 0.00815223f, 
    -0.03277478f, -0.00795262f, -0.04890883f, 0.12891939f, 0.02709990f, -0.13812852f, 0.04996569f, -0.04351506f, 
    -0.16322656f, -0.00376258f, -0.00990027f, 0.02915946f, -0.04041521f, -0.14801016f, -0.15957133f, -0.02264069f, 
    0.07202815f, 0.06410936f, 0.02764623f, 0.06385544f, -0.03788567f, -0.01317585f, 0.02148679f, -0.05848915f, 
    -0.07261607f, 0.05379820f, -0.03080234f, 0.12766467f, -0.06081342f, 0.08927241f, -0.06384659f, 0.08345469f, 
    0.30420828f, 0.08747829f, -0.08459817f, 0.03856754f, -0.05460307f, 0.05336460f, -0.09186106f, -0.02300796f, 
    0.04362714f, 0.03423050f, 0.01806042f, -0.00015392f, 0.00571157f, -0.13476445f, 0.08935369f, -0.07660936f, 
    -0.05424343f, 0.22691943f, -0.02475356f, 0.04882632f, -0.00264227f, 0.04961330f, -0.06814941f, 0.04975885f, 
    -0.08742886f, -0.07791468f, 0.21486305f, -0.09701562f, 0.10739359f, 0.10404105f, 0.18418929f, -0.23002400f, 
    0.04608024f, -0.11040207f, -0.16114531f, 0.17217015f, -0.16517234f, 0.03808966f, 0.07826525f, 0.10401756f, 
    -0.00279744f, -0.13049743f, 0.12395577f, -0.17455953f, 0.10445373f, 0.30270618f, 0.03422327f, -0.00326787f, 
    0.16267984f, -0.23877062f, 0.02098599f, -0.01889850f, -0.23007753f, -0.01934368f, -0.22614074f, 0.04214204f, 
    0.07990813f, -0.02337788f, -0.06415963f, 0.00928269f, -0.01163623f, 0.20663789f, 0.06065730f, 0.19991918f, 
    -0.12596343f, 0.03279654f, -0.14477627f, 0.05838326f, -0.03877237f, 0.02495225f, -0.11077692f, 0.08163834f, 
    -0.06004451f, 0.01045727f, -0.03642872f, -0.10479972f, -0.06669609f, 0.08161621f, 0.18210098f, -0.08220252f, 
    -0.03432334f, -0.20766270f, -0.02113949f, 0.00392760f, -0.03438150f, -0.00110268f, -0.07277795f, -0.03653764f, 
    0.19202001f, -0.19874623f, 0.05242421f, 0.04222476f, -0.00320027f, 0.04708384f, -0.10094713f, 0.13636380f, 
    0.09427764f, -0.14723815f, 0.18784125f, 0.29164976f, -0.03606270f, 0.11234389f, -0.22210275f, -0.09706923f, 
    0.09137435f, 0.04322577f, 0.38201147f, 0.14060745f, -0.01846115f, 0.08345620f, -0.16025484f, -0.08765675f, 
    0.06395601f, -0.04587060f, -0.00496692f, -0.36186674f, 0.16978407f, -0.19587806f, -0.01915961f, 0.17705348f, 
    0.08348119f, -0.18631899f, -0.14092965f, -0.01968350f, 0.17699984f, -0.10899428f, -0.21371134f, 0.10701478f, 
    0.11056664f, 0.12931438f, 0.03113640f, 0.08668109f, -0.11949147f, 0.26078194f, 0.04332681f, 0.12862737f, 
    -0.01541018f, 0.06188270f, 0.04039272f, 0.04792550f, -0.13038430f, 0.18888268f, 0.24374019f, -0.14600852f, 
    0.05397991f, -0.03347638f, 0.13515373f, 0.05766284f, -0.12686473f, -0.09823497f, 0.14588770f, -0.01115172f, 
    -0.12034912f, -0.35023558f, -0.00296127f, 0.00387342f, 0.16408829f, -0.08522949f, -0.06901044f, 0.05520293f, 
    -0.08098233f, -0.06601828f, -0.30630696f, -0.14610358f, 0.03877933f, 0.08815431f, -0.00227065f, -0.04300721f, 
    -0.02781569f, -0.43559074f, -0.20224038f, 0.04029470f, -0.02554277f, 0.12329364f, -0.04702916f, -0.09064966f, 
    -0.07310429f, 0.12686451f, -0.38888714f, 0.08164191f, 0.00896708f, -0.09901392f, 0.20478337f, 0.12607788f, 
    -0.19339862f, 0.14523539f, -0.01597180f, 0.06749326f, -0.39128506f, 0.00907787f, -0.04432918f, 0.05115372f, 
    -0.12073714f, -0.06928944f, 0.06606515f, -0.06789263f, -0.25628909f, -0.05546386f, 0.01138309f, -0.05517590f, 
    0.10137508f, 0.09474438f, 0.02831849f, -0.24849282f, -0.07464938f, 0.59815264f, -0.02262865f, 0.03665433f, 
    -0.12777877f, 0.11495300f, -0.02810612f, -0.02220078f, 0.03003413f, -0.05057954f, -0.18596271f, 0.12534545f, 
    0.04773522f, 0.02970144f, 0.03645417f, 0.01692964f, -0.04688306f, 0.05064525f, 0.04715311f, 0.19867750f, 
    -0.17630459f, -0.19339511f, -0.13487968f, 0.04188146f, 0.03222656f, -0.15925895f, 0.16160238f, 0.08788905f, 
    0.07204450f, 0.09950771f, -0.22712946f, -0.05947381f, -0.00386661f, 0.02461210f, 0.07225496f, 0.10459750f, 
    0.18113287f, -0.13815202f, 0.17840664f, -0.23669411f, -0.00164576f, -0.00386897f, -0.01222930f, -0.08247119f, 
    -0.08881241f, 0.00923834f, -0.02346692f, -0.05445316f, -0.24534492f, 0.03964460f, 0.02296190f, -0.02274007f, 
    0.00196052f, 0.02720172f, 0.13540094f, 0.25107789f, 0.19050424f, -0.24596147f, 0.02595306f, -0.11424150f, 
    -0.00213113f, 0.12241070f, -0.05323998f, 0.04729720f, 0.21654253f, -0.22791897f, 0.16088757f, -0.13467740f, 
    -0.16409189f, -0.11087982f, -0.03840983f, -0.01011346f, -0.09895526f, -0.07221831f, 0.06999464f, 0.06460963f, 
    -0.09505925f, 0.09616655f, -0.02843885f, -0.03150936f, 0.01804392f, 0.00197096f, 0.04663610f, 0.13720454f, 
    -0.09255517f, -0.01942173f, 0.04580089f, 0.02385597f, -0.10563192f, 0.09173279f, 0.03333051f, -0.02727629f, 
    -0.12650794f, -0.22269081f, -0.02538328f, 0.08488236f, -0.00237304f, -0.10094012f, 0.05178889f, -0.03759065f, 
    0.09715437f, 0.08805953f, 0.04738833f, -0.05255706f, -0.01879838f, 0.04426166f, -0.10297301f, 0.00293719f, 
    -0.03365673f, -0.08057298f, 0.13891108f, -0.04665786f, -0.14624192f, -0.13977312f, -0.12071542f, -0.09698067f, 
    0.01708934f, 0.01361813f, -0.15910961f, -0.03296443f, -0.26454237f, -0.20172895f, -0.05989848f, -0.00881914f, 
    -0.01830686f, 0.02271737f, -0.06136425f, -0.43846032f, -0.06666330f, 0.05991602f, 0.10404214f, 0.16994146f, 
    -0.17088704f, 0.03656643f, 0.14815612f, 0.07499474f, 0.26084006f, -0.07125397f, 0.02042410f, -0.15875825f, 
    -0.09247242f, -0.01059407f, -0.03306669f, -0.15014222f, 0.02763591f, -0.03728523f, -0.12052579f, 0.23234895f, 
    0.07800772f, 0.05067651f, 0.02393371f, -0.06909826f, -0.07527780f, 0.07460257f, 0.37641901f, 0.06189805f, 
    -0.10759578f, -0.05839688f, -0.03230437f, -0.03069275f, 0.03666664f, 0.01420296f, -0.05088342f, -0.30682817f, 
    0.10135277f, 0.22899938f, 0.12659062f, -0.09309353f, -0.07405736f, 0.04956130f, -0.02447237f, -0.09245613f, 
    -0.26792443f, 0.03055271f, 0.02900807f, 0.23582265f, 0.00446397f, 0.07203727f, 0.17594557f, 0.16827665f, 
    -0.10934143f, -0.16343190f, 0.04291130f, 0.20949802f, 0.26633224f, 0.02425758f, 0.20183977f, -0.09133797f, 
    -0.00214210f, 0.20183431f, 0.21686502f, 0.19109994f, 0.06882069f, 0.07355872f, 0.01525647f, 0.07633784f, 
    -0.01919436f, -0.02513482f, 0.11328933f, -0.12785611f, 0.03918174f, -0.09019230f, -0.23442087f, 0.01662931f, 
    0.02909806f, -0.11999708f, 0.07357284f, 0.13474497f, 0.07936462f, 0.01020880f, -0.08713157f, 0.00913916f, 
    0.16451275f, 0.14639135f, -0.16075093f, -0.03737020f, -0.00947366f, 0.18036431f, -0.12145619f, -0.09162480f, 
    -0.00531243f, -0.07463731f, 0.09333228f, -0.00254080f, 0.07475933f, 0.03572377f, -0.19256632f, -0.03704826f, 
    0.15831347f, -0.01083223f, 0.07864385f, -0.05714782f, -0.04252525f, -0.23894432f, 0.07751070f, -0.01325738f, 
    0.04512253f, 0.18152590f, 0.06296811f, -0.10163546f, 0.06857712f, 0.04420720f, -0.10489402f, 0.01148438f, 
    0.20983803f, 0.06299531f, -0.08889146f, -0.20630276f, 0.03345480f, -0.04722868f, 0.01044921f, 0.01518850f, 
    0.04226778f, 0.15506037f, -0.10949816f, -0.06798929f, -0.30051053f, 0.06757836f, -0.02144158f, 0.01216279f, 
    0.12117937f, 0.02074256f, -0.18165192f, -0.08355471f, -0.02177982f, -0.14861612f, 0.06101456f, 0.02585916f, 
    0.00719198f, -0.05194372f, -0.12324455f, 0.11545283f, 0.25201964f, 0.11897561f, -0.05870054f, -0.04677665f, 
    -0.11000872f, 0.14138022f, 0.03331089f, 0.04792530f, -0.06256302f, -0.17170264f, -0.00848367f, -0.13325466f, 
    0.06604307f, 0.06493225f, 0.07161842f, 0.03739232f, 0.01149030f, 0.00808656f, -0.14539056f, 0.27676615f, 
    0.14133482f, -0.02684150f, -0.08845732f, -0.20367451f, -0.03341834f, 0.05143846f, -0.23174894f, 0.15235490f, 
    -0.04953227f, -0.19149852f, 0.05639657f, -0.04108015f, -0.08769108f, 0.02700007f, 0.01052956f, 0.11564875f, 
    0.09506372f, -0.13322920f, -0.11677808f, -0.10877203f, -0.09598666f, 0.08558462f, 0.13253628f, -0.02533461f, 
    0.21847501f, -0.03010149f, -0.15140033f, -0.04867728f, -0.08371783f, 0.08069422f, 0.01737029f, -0.03560686f, 
    0.05615873f, -0.01585019f, 0.02430144f, 0.13063250f, 0.00517906f, -0.01395958f, -0.01458288f, -0.13298084f, 
    -0.05594474f, -0.02442301f, 0.09281108f, 0.06411721f, 0.00593768f, -0.08725294f, 0.12933728f, -0.10183217f, 
    -0.02018402f, -0.09379743f, 0.11289210f, 0.27809301f, -0.12914513f, 0.08759642f, 0.04598428f, 0.05439701f, 
    0.06559131f, 0.09561047f, -0.02849147f, 0.04999312f, -0.18079017f, -0.09277194f, 0.18742616f, 0.17582788f, 
    0.00602813f, 0.14170560f, 0.12242386f, 0.08970976f, 0.07527800f, -0.27268898f, -0.08598243f, 0.07070938f, 
    -0.01638054f, 0.08788886f, -0.05723437f, 0.01323500f, 0.02203972f, -0.02196393f, 0.29092133f, 0.07305951f, 
    -0.04096077f, -0.06835812f, -0.04165462f, -0.12944855f, -0.13569582f, 0.15694098f, -0.19418253f, 0.13968715f, 
    0.16652064f, 0.14281316f, -0.21793617f, 0.05630192f, 0.02003131f, 0.06138082f, -0.02574619f, -0.04171860f, 
    0.20908709f, -0.07959753f, -0.00497488f, -0.04745608f, -0.03443952f, -0.05499935f, 0.11803329f, 0.06141168f, 
    -0.07225830f, -0.01024032f, 0.21644686f, 0.07382385f, 0.05630473f, -0.07441615f, -0.03928129f, -0.03155149f, 
    -0.02616385f, -0.10462587f, 0.00711836f, 0.06568690f, -0.12925304f, -0.00241558f, 0.03154724f, 0.14399056f, 
    -0.03457321f, 0.09238396f, -0.11620343f, 0.06944914f, -0.13719656f, 0.14978601f, -0.06462558f, -0.02276619f, 
    -0.06846343f, -0.02569104f, 0.12787740f, -0.04702680f, 0.27108997f, 0.00254956f, 0.02167613f, -0.00354357f, 
    0.06690362f, -0.08021018f, 0.03133952f, 0.05963267f, 0.07212277f, 0.17279479f, -0.04739704f, -0.02542495f, 
    -0.25095689f, -0.06035005f, -0.13134430f, -0.01788156f, 0.01717301f, -0.01483871f, -0.10743526f, 0.07484647f, 
    0.07501492f, -0.05798164f, -0.00314000f, 0.12259748f, 0.08041778f, -0.00835066f, -0.16085415f, 0.19037242f, 
    -0.20305072f, 0.01543083f, -0.12342082f, -0.06498405f, -0.18802637f, -0.11424392f, -0.00062613f, 0.06624064f, 
    0.16645396f, -0.08789159f, -0.05608962f, 0.28342181f, -0.13084406f, 0.05710137f, 0.04309465f, 0.04434500f, 
    0.03747151f, -0.10594769f, -0.06056319f, 0.05678196f, -0.19247268f, 0.17035165f, -0.07389296f, 0.04769674f, 
    -0.09250286f, -0.09705073f, 0.41098654f, 0.02581255f, 0.00551655f, -0.22121648f, -0.21396014f, 0.04632430f, 
    0.07725850f, 0.06577153f, -0.07289086f, -0.05709204f, 0.14740129f, -0.21118186f, 0.14353625f, -0.06545036f, 
    -0.04963794f, -0.18068358f, -0.10314757f, -0.01391383f, 0.14553864f, -0.25265041f, -0.00619610f, -0.16724056f, 
    0.02722279f, -0.06910203f, 0.14093462f, -0.04081352f, -0.11000696f, 0.18937048f, 0.14387153f, 0.12778619f, 
    -0.16800149f, -0.02308390f, 0.00357883f, 0.01618199f, 0.04245796f, 0.06668714f, 0.08083720f, -0.08526371f, 
    0.00990879f, 0.03910586f, 0.10245272f, -0.05527875f, -0.06172529f, 0.04266917f, 0.14574824f, 0.10074835f, 
    -0.10716978f, -0.10120285f, 0.02890634f, 0.12196797f, -0.11881633f, 0.04572722f, -0.07474415f, 0.13651897f, 
    -0.02589443f, 0.02919989f, -0.05475214f, -0.29128173f, 0.01040032f, 0.08540712f, 0.16247384f, 0.06967627f, 
    -0.19068831f, -0.30847314f, 0.01799363f, -0.21579729f, 0.19319834f, 0.10625725f, 0.09584013f, 0.02772892f, 
    -0.05099101f, -0.04063844f, 0.14995919f, 0.12365182f, -0.09665942f, 0.16786946f, 0.13157634f, 0.04566414f, 
    0.04129449f, -0.09439141f, 0.09917817f, 0.13866323f, -0.14612357f, 0.03171999f, 0.23545586f, -0.08164231f, 
    0.02215081f, 0.04622310f, -0.04477497f, -0.13268371f, 0.04572002f, 0.12449618f, -0.06863811f, 0.01135879f, 
    0.01360551f, 0.00601571f, 0.06095960f, 0.02434363f, 0.09680554f, 0.23590732f, 0.00180183f, -0.04022013f, 
    -0.16030504f, -0.03578705f, -0.27126387f, -0.03842516f, -0.00544041f, -0.01364135f, 0.25254992f, 0.02293505f, 
    0.06463436f, -0.04155045f, 0.00821675f, -0.03480630f, 0.02447124f, 0.08109722f, -0.02458805f, 0.32637602f, 
    -0.12460512f, -0.12767622f, 0.15392417f, -0.15016571f, -0.07812368f, -0.07738643f, 0.08917058f, -0.06465853f, 
    0.38041005f, 0.00487996f, -0.01513150f, -0.25324279f, -0.01394469f, 0.07769056f, -0.01337349f, 0.07551955f, 
    -0.03285693f, 0.12500164f, 0.03223402f, 0.15098156f, -0.00244177f, 0.02710970f, -0.04633585f, 0.03912251f, 
    -0.00076952f, 0.20446281f, 0.13100959f, -0.13326168f, -0.02725458f, -0.02788421f, -0.00997973f, 0.00397544f, 
    0.07737151f, 0.11088894f, -0.02354279f, 0.10151597f, 0.04472400f, 0.03033497f, -0.08603162f, -0.01811638f, 
    0.00645485f, 0.03600194f, 0.10557351f, -0.10574843f, 0.31953809f, -0.31684878f, 0.03389784f, -0.10118448f, 
    -0.10606983f, -0.12330157f, 0.11755954f, -0.03951456f, 0.14194182f, 0.05315116f, 0.06110486f, 0.00549882f, 
    -0.00835041f, 0.06541734f, 0.12187991f, -0.14714092f, -0.03732228f, -0.11199054f, 0.12601453f, -0.03052235f, 
    -0.25102606f, 0.04233890f, -0.07153768f, 0.13489169f, -0.06069484f, -0.06484425f, -0.07259881f, -0.10117815f, 
    0.05626084f, -0.14186302f, 0.20291647f, -0.00488385f, 0.03792879f, 0.05614768f, -0.04080984f, -0.06548531f, 
    0.16456856f, 0.08681766f, -0.03842086f, -0.18633112f, -0.14188413f, -0.15652509f, 0.10141426f, 0.03033819f, 
    -0.05224791f, -0.13632819f, -0.02919523f, 0.09718271f, 0.05963271f, -0.00354932f, -0.03885889f, -0.00062117f, 
    -0.02307022f, 0.05145430f, -0.06050051f, -0.09896632f, -0.07415305f, -0.02440953f, 0.00640384f, -0.03273526f, 
    -0.20531917f, -0.11926658f, 0.01789052f, -0.12384118f, 0.07131814f, 0.04278626f, -0.19203179f, -0.14642215f, 
    -0.01896297f, 0.13587959f, 0.10878629f, 0.06924104f, 0.13595766f, 0.20009606f, -0.18558915f, 0.04521877f, 
    0.10202056f, -0.09931491f, -0.03562323f, 0.01266958f, -0.01128918f, 0.05157881f, 0.09076566f, 0.27094167f, 
    -0.04031236f, -0.04757027f, 0.07611042f, -0.00051198f, 0.02552088f, 0.00763575f, 0.13700582f, 0.19379981f, 
    -0.10216223f, -0.04571183f, -0.01341932f, 0.11858836f, -0.13244896f, 0.08078678f, -0.07689870f, -0.07744383f, 
    -0.04092871f, 0.04093092f, 0.24764292f, 0.05578932f, -0.00452271f, -0.12195051f, 0.01698939f, 0.03459418f, 
    -0.13466083f, 0.05523511f, -0.07031552f, 0.19737317f, 0.06370635f, -0.13468885f, 0.04956174f, -0.03022509f, 
    -0.03957129f, -0.00134746f, 0.29824588f, 0.02335506f, -0.10725608f, -0.03676924f, 0.17090486f, 0.02061782f, 
    -0.01343310f, -0.19683462f, 0.24846508f, 0.24593112f, 0.21724981f, 0.03099231f, -0.06291890f, -0.16747041f, 
    0.03081030f, 0.08649135f, 0.12427938f, -0.25793722f, -0.13499352f, 0.05022569f, 0.12464741f, 0.05322114f, 
    0.02552524f, -0.11001319f, -0.06972227f, -0.00311876f, 0.01005697f, 0.00474049f, -0.19362958f, 0.10255886f, 
    -0.01150587f, 0.14164764f, -0.01187463f, -0.02810306f, 0.00217419f, 0.18718113f, 0.13226187f, -0.03131922f, 
    -0.05581568f, -0.03968028f, 0.07854228f, 0.10430317f, -0.07379932f, 0.10416788f, -0.13097450f, 0.04405268f, 
    -0.01234917f, -0.09524097f, -0.05546517f, -0.08386622f, 0.09449494f, 0.05354189f, 0.06783143f, 0.01989000f, 
    0.23881103f, 0.17031482f, 0.05881841f, 0.11665772f, -0.14535180f, -0.00888455f, 0.10259863f, 0.14402974f, 
    0.11623081f, -0.06237600f, -0.21897240f, 0.01987652f, 0.17285459f, -0.07906779f, -0.25457600f, 0.01558037f, 
    -0.15720975f, -0.24847564f, -0.16353868f, -0.01547569f, 0.14406134f, -0.06685954f, 0.04316764f, -0.00350644f, 
    -0.00880565f, 0.02421685f, -0.36549053f, -0.07872586f, -0.28109837f, -0.02175187f, 0.06922904f, -0.11134443f, 
    -0.17604518f, -0.14853393f, 0.04650327f, 0.02068592f, 0.14791994f, 0.11508907f, 0.02011609f, 0.00164819f, 
    -0.07951593f, 0.18027426f, -0.05260229f, 0.11702217f, -0.06019049f, -0.13057917f, 0.02628436f, -0.18325628f, 
    0.01096382f, -0.02854631f, -0.24900550f, -0.00229388f, 0.02819465f, -0.02485387f, -0.05297599f, 0.17071961f, 
    -0.02465714f, 0.04126116f, 0.09415090f, -0.02406429f, 0.01022317f, -0.16287144f, 0.07350554f, -0.06135046f, 
    -0.14142430f, -0.12362151f, 0.02910568f, 0.00049806f, -0.02261948f, 0.01416867f, -0.01872833f, 0.10990890f, 
    -0.15536693f, -0.12958279f, -0.00547725f, 0.01049400f, -0.02465215f, -0.04838357f, 0.08371288f, -0.09409678f, 
    0.04878269f, 0.10680542f, -0.17090002f, 0.11261397f, -0.20813176f, -0.06593771f, 0.13458267f, 0.03743798f, 
    0.16315411f, 0.17399409f, 0.02078040f, -0.00439625f, 0.10923746f, 0.01683462f, 0.01724120f, -0.09703483f, 
    -0.05276221f, -0.06536697f, 0.19971023f, -0.06802578f, -0.14136453f, 0.08230276f, -0.05138483f, 0.03242695f, 
    -0.09059202f, 0.17012672f, 0.01493254f, 0.19916162f, -0.05319456f, 0.32498178f, 0.11197033f, 0.09112747f, 
    0.17108847f, 0.04934590f, -0.02233235f, 0.01166949f, -0.05377539f, 0.06645707f, 0.24271528f, -0.13235721f, 
    0.09371897f, -0.02211499f, 0.03016601f, 0.03827422f, -0.00798825f, -0.21504745f, 0.02943538f, 0.00718300f, 
    -0.01319433f, -0.11718050f, 0.08225685f, -0.07922208f, 0.00471841f, -0.00585499f, 0.07487039f, -0.03380075f, 
    -0.08511653f, -0.12447511f, 0.16103458f, -0.03400750f, 0.01707001f, -0.12654768f, 0.07294986f, -0.01183258f, 
    -0.04707970f, -0.07152946f, -0.07070821f, 0.02488225f, 0.07538062f, -0.04267661f, 0.00066792f, 0.01950144f, 
    0.17324005f, 0.07892889f, -0.36023360f, 0.06194354f, -0.19407402f, 0.20649369f, 0.02024208f, 0.02968366f, 
    0.06347104f, -0.09361370f, -0.20136911f, 0.08115259f, 0.06092161f, 0.12320983f, 0.05045201f, 0.06663673f, 
    0.03667396f, 0.08310665f, 0.11761126f, 0.12851818f, -0.05636995f, 0.07461742f, -0.12662990f, 0.06379320f, 
    0.16023260f, 0.01900882f, 0.11488689f, 0.33512601f, 0.30710852f, -0.18219261f, -0.03811875f, -0.06564376f, 
    0.07499926f, 0.19002461f, 0.09638020f, -0.02062478f, -0.06284657f, -0.04160690f, -0.03200237f, 0.00614148f, 
    -0.05361070f, 0.14281014f, -0.12882312f, -0.05842686f, 0.00793201f, 0.02463937f, 0.32071990f, 0.08499245f, 
    -0.06798711f, 0.01143519f, -0.06538719f, 0.00933041f, 0.10057168f, -0.14009459f, 0.10428365f, 0.13202898f, 
    -0.01335318f, -0.08900186f, -0.03688972f, 0.06055041f, 0.00535603f, 0.00357809f, -0.01368922f, -0.11443558f, 
    -0.25662977f, -0.10732194f, -0.02935595f, -0.02627300f, 0.12960480f, -0.04338220f, -0.05217989f, -0.18299614f, 
    0.11840512f, -0.13756989f, -0.02907614f, -0.04636131f, 0.00438981f, -0.12755144f, 0.13373260f, 0.08644093f, 
    0.06831494f, 0.05983028f, 0.28757617f, -0.17439787f, -0.04689172f, 0.02048008f, 0.02407010f, -0.00245188f, 
    -0.04457637f, -0.00934962f, -0.06420028f, 0.13637705f, 0.09978479f, -0.07678682f, 0.11568751f, -0.05681897f, 
    -0.07454187f, -0.07317642f, 0.02693721f, -0.36530140f, -0.23787050f, 0.03751985f, 0.15880543f, -0.03130330f, 
    -0.07459658f, 0.00599715f, 0.00082993f, 0.13537700f, -0.19224131f, 0.03738671f, -0.19421236f, -0.10322949f, 
    0.11797096f, 0.05650917f, -0.16338040f, -0.08805773f, 0.02198377f, 0.16175234f, 0.27160954f, 0.14874090f, 
    -0.03045410f, 0.10727521f, -0.03023329f, -0.02711526f, -0.04772589f, -0.09374636f, 0.06676269f, 0.00251777f, 
    -0.30210632f, -0.05588014f, -0.13380679f, 0.15652558f, 0.17168678f, 0.05000298f, 0.08756482f, 0.16857123f, 
    0.03254135f, -0.12019630f, -0.09283260f, 0.01947153f, 0.08163527f, -0.02389717f, 0.08346333f, -0.00305914f, 
    -0.04704677f, -0.08529100f, -0.14350514f, 0.08834697f, -0.00743783f, 0.15032008f, 0.17946480f, -0.03875223f, 
    0.01200830f, -0.03821367f, -0.01964023f, 0.01211091f, 0.04696683f, 0.13532123f, 0.05899648f, -0.04220339f, 
    0.00016308f, 0.03829933f, -0.21032153f, -0.14107916f, 0.03840051f, 0.14046375f, -0.13601623f, -0.02582631f, 
    0.22974296f, -0.10465261f, 0.06934613f, 0.03102066f, -0.12559392f, -0.05764634f, 0.01853825f, -0.05121112f, 
    0.09732393f, 0.07441244f, 0.04255404f, -0.05675752f, 0.16775538f, 0.03712016f, 0.20868057f, 0.10738354f, 
    -0.00217968f, 0.07510500f, -0.15616407f, -0.07432699f, -0.11762785f, 0.07157858f, 0.14926098f, -0.28430489f, 
    0.00040836f, 0.09016217f, -0.08265111f, 0.12674251f, 0.06959572f, -0.11322653f, 0.20084554f, -0.26505893f, 
    -0.11724906f, 0.03873372f, 0.04613313f, 0.10234221f, -0.01250861f, -0.00236186f, 0.06751309f, -0.38182881f, 
    0.12263282f, -0.25511381f, -0.06402626f, -0.00955612f, -0.02494288f, 0.00091908f, 0.15042724f, 0.09792173f, 
    -0.25572804f, -0.05061805f, 0.21926266f, 0.00353081f, 0.05886791f, -0.11284027f, 0.02484342f, -0.12250581f, 
    0.19747083f, 0.12758064f, -0.10507932f, -0.17084500f, 0.08759543f, -0.08441871f, 0.11544507f, -0.05299779f, 
    -0.15639727f, -0.20540735f, -0.23692513f, -0.19141752f, -0.08929136f, 0.09436314f, 0.06073540f, 0.04501965f, 
    -0.16722377f, -0.07115766f, -0.04836039f, 0.13251631f, -0.00338848f, 0.19720608f, -0.00313501f, 0.02869391f, 
    -0.21149991f, -0.13102864f, -0.04528973f, -0.09729779f, -0.17335743f, 0.27430528f, -0.29678467f, -0.04110720f, 
    -0.07082863f, 0.00344697f, -0.00807335f, -0.07940635f, 0.07264577f, 0.09618383f, -0.27846104f, 0.16841745f, 
    0.10697379f, 0.07862490f, -0.08409948f, 0.05715661f, 0.07416917f, 0.16686796f, -0.12579243f, 0.09140977f, 
    0.12269998f, 0.21145332f, -0.05377024f, 0.02702328f, -0.02221377f, 0.10640355f, -0.04302641f, -0.01766581f, 
    0.01525236f, -0.07754371f, 0.09713245f, -0.11828259f, -0.03938628f, 0.01414362f, -0.06283162f, 0.02103726f, 
    -0.05714648f, -0.07602340f, 0.02303411f, -0.00608713f, 0.00259632f, -0.04245484f, 0.02004049f, -0.05253280f, 
    -0.07846379f, -0.00669004f, 0.00287007f, 0.01856688f, -0.04432565f, -0.00529366f, -0.05385335f, -0.04796267f, 
    -0.02656442f, 0.02101641f, -0.05780054f, -0.04155229f, 0.01079387f, -0.00280469f, -0.05082120f, -0.01170766f, 
    -0.03607482f, 0.00824205f, 0.01183462f, 0.02624444f, -0.03082839f, 0.00246582f, 0.02025571f, -0.01990204f, 
    -0.01543204f, 0.02488144f, 0.00458094f, -0.01836492f, -0.06324248f, 0.02805293f, 0.04175340f, -0.03400740f, 
    -0.06464960f, -0.06267419f, -0.02195898f, -0.01884950f, -0.04452743f, -0.04681021f, -0.03111356f, -0.06820805f, 
    -0.07295351f, -0.02495005f, -0.01084244f, 0.01896660f, 0.03193192f, 0.02067465f, -0.03902473f, -0.04945701f, 
    -0.03273436f, 0.02874909f, -0.03122030f, 0.04119731f, -0.04902605f, -0.05461407f, -0.07793444f, 0.05347716f, 
    -0.09247175f, -0.03091236f, 0.03567371f, 0.03165211f, 0.02418436f, 0.02542662f, -0.04670492f, -0.00363714f, 
    -0.06047404f, 0.03980652f, -0.02903070f, 0.04063777f, 0.02582131f, 0.00793842f, 0.01588598f, -0.05639049f, 
    0.00903145f, 0.00915283f, -0.02995505f, -0.00077371f, -0.06997961f, -0.01801476f, -0.08258710f, -0.02432136f, 
    -0.04841188f, -0.02804564f, 0.04052931f, 0.03963324f, 0.03214471f, 0.03353549f, -0.03551575f, -0.00872503f, 
    -0.00284739f, 0.03222743f, -0.02547739f, -0.07493779f, -0.03697684f, 0.00493103f, -0.03104533f, -0.00165276f, 
    -0.00814376f, 0.02885915f, -0.01231273f, 0.05119817f, -0.05879249f, -0.01066629f, 0.02250950f, -0.00748983f, 
    0.01372484f, 0.00031637f, -0.06211543f, -0.00520606f, 0.01008016f, -0.00617033f, -0.02584442f, -0.06812861f, 
    -0.00840028f, 0.02929260f, 0.01763938f, -0.04071638f, -0.03870907f, -0.03909787f, 0.03803921f, -0.04405033f, 
    -0.03794347f, 0.01223551f, -0.02714679f, -0.05720615f, 0.05521208f, 0.02465491f, -0.04089313f, -0.01441399f, 
    0.02064111f, -0.02615586f, 0.02221189f, -0.04724996f, -0.05171359f, 0.00551780f, 0.02662030f, 0.01022736f, 
    -0.04841453f, 0.02179345f, -0.02443879f, -0.04779608f, -0.04182286f, 0.00032218f, 0.00244805f, 0.06842007f, 
    -0.05510300f, -0.05916817f, -0.01660047f, -0.00833017f, -0.03134486f, 0.01834318f, 0.02496500f, -0.04825977f, 
    0.03805286f, 0.03268832f, -0.04630062f, -0.06057358f, 0.03949996f, -0.04920103f, -0.06785192f, 0.03359773f, 
    0.05460015f, -0.04642617f, 0.02129714f, -0.04935732f, -0.01213626f, -0.04128480f, 0.05694206f, -0.04482962f, 
    0.00086635f, -0.06101558f, 0.01445554f, -0.08680510f, -0.03862102f, 0.04091575f, 0.06175042f, -0.02293593f, 
    -0.04446287f, -0.04768155f, -0.00893636f, 0.02423885f, 0.03142449f, -0.02778347f, -0.01719292f, -0.05168647f, 
    0.00836146f, -0.08004320f, -0.04219299f, 0.01261421f, -0.03222414f, 0.00041879f, 0.02567095f, 0.01906810f, 
    -0.00738087f, -0.03230890f, -0.00638637f, -0.07252221f, 0.04874260f, 0.01588709f, 0.02616521f, -0.01405782f, 
    -0.06061371f, -0.06114034f, -0.06698819f, 0.01659462f, -0.04107922f, 0.00610641f, 0.05138576f, 0.03225297f, 
    -0.00600629f, 0.02008976f, -0.00153172f, -0.05368662f, -0.04906550f, -0.06383603f, -0.02034809f, 0.03762959f, 
    0.02154835f, -0.02074960f, -0.01692904f, -0.02113150f, -0.03247672f, -0.00723052f, -0.05420032f, -0.03956071f, 
    -0.07114992f, 0.01331816f, -0.01978857f, -0.04664536f, -0.01247223f, -0.03951371f, 0.01519405f, 0.00337473f, 
    0.00515785f, -0.03756532f, -0.03460554f, -0.03684801f, 0.04131849f, -0.00457871f, -0.05631645f, 0.05010631f, 
    0.04602084f, 0.00563063f, -0.01457201f, -0.08001965f, -0.03529857f, 0.00341455f, -0.03266130f, -0.05017631f, 
    0.01667184f, -0.10104948f, 0.07507604f, 0.02490718f, 0.00191833f, 0.00358118f, 0.03773576f, 0.03207684f, 
    -0.01588094f, -0.02163520f, -0.06245531f, -0.02315322f, -0.01560973f, -0.05828334f, 0.01892767f, 0.02514380f, 
    -0.07140947f, -0.02745330f, 0.01142335f, -0.04042765f, -0.00194952f, 0.00894571f, -0.02663973f, -0.06876208f, 
    -0.03178707f, -0.05924455f, 0.01257867f, -0.00527989f, -0.04612229f, -0.08224572f, 0.00367564f, -0.02665388f, 
    -0.14334065f, -0.10647497f, -0.01958117f, -0.08724916f, 0.15294839f, 0.07935108f, 0.10094495f, -0.00715841f, 
    -0.00228380f, 0.08517606f, 0.06764704f, 0.04565938f, -0.02967269f, 0.03931208f, 0.15278980f, 0.04525996f, 
    0.02172869f, 0.14127599f, -0.01114460f, 0.13205482f, -0.01313540f, 0.17414749f, -0.14569791f, 0.13498910f, 
    -0.01238574f, 0.03429117f, 0.02238673f, -0.20729131f, -0.11741240f, 0.01671340f, 0.01991472f, 0.12267841f, 
    -0.00696944f, -0.03002250f, -0.06700405f, -0.02116100f, 0.02481467f, -0.00084337f, -0.18346615f, 0.02534213f, 
    0.11345953f, 0.24160741f, -0.07880811f, -0.02324788f, 0.07868337f, -0.11468996f, -0.00721861f, -0.22696522f, 
    -0.00138206f, 0.02940810f, 0.06970115f, -0.11644758f, -0.03381830f, -0.16001724f, 0.01292539f, 0.10242922f, 
    -0.06633871f, -0.07118927f, 0.05841898f, -0.03799774f, 0.27546829f, 0.11584446f, 0.07794087f, -0.13158786f, 
    -0.11548893f, 0.07120432f, 0.01337405f, 0.17347936f, 0.11926997f, 0.00598959f, -0.16697586f, -0.04110768f, 
    0.15472047f, 0.11362766f, 0.18334799f, 0.00342180f, -0.15419108f, -0.21332689f, -0.03875841f, 0.07159104f, 
    0.08516654f, -0.27349392f, 0.23323028f, -0.20905520f, 0.16314252f, 0.06331507f, -0.07015087f, 0.00010135f, 
    0.02000543f, -0.10713217f, 0.03895840f, 0.13358276f, -0.11518855f, 0.08728590f, 0.05432428f, -0.11829470f, 
    0.02894491f, -0.13736008f, -0.02555080f, 0.01420570f, 0.00282451f, -0.11040260f, 0.00806515f, -0.18846406f, 
    0.03928024f, -0.11665016f, 0.12901320f, 0.03335873f, -0.13810471f, -0.00768176f, -0.06418728f, -0.12528820f, 
    -0.01894516f, -0.07489700f, 0.16518059f, 0.01126605f, 0.04344292f, -0.01571269f, 0.04794804f, -0.16678555f, 
    -0.00008291f, -0.06343670f, 0.09536989f, -0.06297569f, -0.08659863f, -0.13769780f, -0.06199422f, -0.15955158f, 
    -0.10053921f, 0.02717654f, -0.12209553f, 0.09022554f, -0.16569392f, 0.11182018f, -0.03548672f, -0.00377866f, 
    -0.16854601f, -0.14406569f, -0.03101091f, 0.05715544f, 0.00999516f, 0.02143370f, -0.01862936f, -0.06584994f, 
    -0.30184817f, -0.05658189f, -0.12326540f, 0.17566279f, -0.08231111f, 0.06937836f, 0.01887148f, -0.08283973f, 
    -0.02329841f, 0.00117230f, 0.04814983f, 0.12657867f, -0.13234605f, 0.05052809f, 0.02724358f, 0.09053613f, 
    0.17617615f, 0.10706039f, -0.00949809f, 0.16479760f, -0.08510691f, 0.07204186f, -0.30114043f, 0.10378595f, 
    0.03398407f, 0.11678365f, 0.05738685f, -0.01343588f, 0.01557217f, -0.06465451f, -0.13596629f, 0.04592729f, 
    -0.12120346f, 0.12182807f, 0.01759011f, -0.00474414f, 0.05458212f, -0.09675354f, -0.01127972f, 0.04595911f, 
    -0.14502044f, 0.00046125f, -0.02038802f, 0.08038382f, 0.11401804f, -0.21050709f, -0.10568932f, -0.17404173f, 
    -0.00488367f, -0.02699411f, -0.05182409f, -0.09572752f, 0.06454993f, -0.13180195f, -0.01639899f, 0.03864735f, 
    0.06832077f, 0.10575941f, 0.09443091f, 0.10432284f, 0.10216561f, -0.19255453f, 0.00710051f, -0.05681945f, 
    -0.04553911f, 0.08293319f, 0.09406669f, 0.24219975f, -0.00410980f, -0.11627571f, 0.01026583f, 0.13545525f, 
    0.05062842f, -0.17132223f, -0.23975176f, 0.00565718f, 0.07887608f, 0.00866133f, 0.15268910f, -0.12565611f, 
    -0.05680547f, -0.06190266f, 0.00874399f, -0.15205804f, -0.06277725f, 0.10445265f, 0.15482663f, 0.05468103f, 
    0.14222647f, 0.00359077f, 0.04199228f, -0.09832241f, 0.01799157f, 0.10295625f, 0.06855220f, -0.04039460f, 
    -0.01021399f, 0.05312386f, 0.00439658f, -0.10560158f, 0.07067096f, -0.30680966f, -0.01690056f, 0.10458913f, 
    -0.09056311f, -0.01622061f, -0.02789538f, -0.06080086f, -0.36405331f, -0.09594930f, -0.13102533f, 0.01820363f, 
    0.04192012f, 0.12749931f, 0.00122744f, 0.08734898f, -0.05279750f, 0.09315261f, 0.07155076f, 0.04324580f, 
    -0.02201141f, -0.04703192f, 0.02775434f, -0.02979177f, 0.07193834f, -0.04108096f, -0.18229142f, 0.00375299f, 
    0.10309554f, 0.08188734f, 0.05501030f, 0.14577544f, -0.10492126f, -0.03991020f, 0.02874844f, -0.11493388f, 
    -0.00358007f, 0.12580901f, -0.08383030f, -0.01330007f, -0.00293170f, 0.11228631f, 0.11810582f, 0.03450432f, 
    -0.00645885f, 0.01925200f, 0.00335103f, 0.00725275f, 0.04598536f, -0.00593055f, -0.04326574f, -0.00791366f, 
    -0.03147100f, 0.03911364f, -0.05195549f, 0.05426880f, 0.04985027f, 0.05474022f, -0.05527950f, -0.02775913f, 
    -0.04540243f, 0.00253450f, 0.05445454f, -0.06288662f, -0.02752576f, -0.04418469f, -0.05981576f, 0.02155002f, 
    0.01849531f, -0.06090663f, -0.01388376f, 0.01978391f, -0.05412036f, -0.02920577f, -0.02029627f, 0.05859562f, 
    -0.04268607f, -0.00256146f, 0.03079991f, -0.00871710f, 0.00479393f, 0.00288948f, -0.05690997f, -0.02573862f, 
    0.02638027f, -0.04433989f, -0.00778732f, -0.03245333f, -0.05240531f, -0.00644699f, -0.03274606f, -0.00814237f, 
    -0.03482517f, 0.01921214f, 0.04164135f, -0.02955942f, -0.04384625f, -0.04046056f, -0.04498776f, 0.01354390f, 
    0.04643210f, 0.05139810f, -0.00000185f, -0.02610015f, -0.02579720f, 0.01423742f, -0.04693775f, -0.01083291f, 
    -0.00715314f, -0.00168509f, -0.05247233f, 0.00222128f, -0.04891041f, 0.03118127f, -0.06468147f, 0.03079849f, 
    -0.01916704f, -0.01764089f, 0.00450497f, 0.00016143f, 0.02497669f, 0.00253082f, -0.03125591f, -0.02174400f, 
    -0.06195574f, 0.02845220f, -0.02851103f, 0.04901583f, -0.03482236f, 0.04940664f, 0.02320025f, -0.02976364f, 
    0.03967585f, -0.04274996f, 0.01961497f, 0.02696116f, -0.04580446f, -0.06052725f, 0.01611940f, -0.06129371f, 
    0.04103597f, -0.01581413f, -0.04319086f, -0.01429569f, 0.05473725f, -0.02821024f, 0.01362100f, 0.02385546f, 
    -0.06463601f, 0.00694453f, -0.05695214f, -0.01180581f, -0.06105125f, -0.01523134f, -0.05458359f, -0.03230884f, 
    0.00280462f, 0.01784200f, 0.02105051f, 0.01462582f, -0.05032903f, 0.04109489f, 0.03195397f, -0.05889175f, 
    -0.02384080f, 0.02021728f, 0.03416426f, 0.00523082f, -0.01173574f, -0.03428085f, -0.01596730f, 0.05191651f, 
    -0.05118242f, -0.00117076f, -0.03674820f, -0.03057187f, -0.05766492f, -0.00781005f, 0.05821012f, 0.04196932f, 
    0.00364863f, 0.02835961f, 0.04685595f, -0.01917299f, -0.01358496f, 0.05175725f, 0.04140244f, -0.02528427f, 
    0.04525132f, -0.02461134f, 0.04558935f, 0.00546575f, 0.02214338f, 0.02302044f, 0.00988651f, 0.01953153f, 
    0.05465501f, -0.05727990f, -0.01413498f, 0.02598420f, -0.02982279f, -0.02564508f, 0.03139730f, 0.03091865f, 
    -0.01001907f, -0.05958368f, -0.03354837f, 0.01224145f, 0.04129941f, -0.03256000f, 0.01671256f, -0.03236052f, 
    -0.00733381f, -0.01156565f, -0.03903296f, -0.05661605f, -0.03535277f, 0.02929234f, -0.01362234f, -0.03076320f, 
    0.02205796f, 0.03454835f, -0.03067734f, 0.00724885f, 0.04765240f, -0.05178986f, 0.04968419f, 0.05014956f, 
    -0.01825878f, 0.01822093f, -0.02007182f, -0.01215226f, -0.01263093f, 0.03364514f, -0.06015410f, -0.02246837f, 
    0.01165648f, 0.04814075f, 0.00960856f, 0.04832038f, -0.01078291f, -0.03337941f, -0.02622744f, -0.04077597f, 
    0.03215917f, 0.03806199f, 0.01992424f, -0.00771851f, 0.00878891f, -0.02287601f, -0.01989248f, -0.02133768f, 
    -0.02319359f, -0.05713869f, -0.02201277f, 0.04239420f, 0.03446176f, -0.04211853f, -0.06270578f, -0.02055431f, 
    0.00204741f, 0.05504636f, -0.00601195f, 0.03690490f, 0.03222703f, -0.03580613f, -0.00160948f, 0.02570073f, 
    0.04420938f, -0.01806015f, 0.03069089f, -0.00192334f, -0.05436486f, 0.00510498f, -0.04796576f, -0.00940813f, 
    -0.02494621f, -0.04728613f, -0.01914246f, 0.04919893f, 0.05007776f, -0.01406259f, 0.00931682f, -0.02921687f, 
    -0.03774064f, -0.03234322f, -0.03465634f, -0.00289110f, -0.03316726f, -0.01604057f, 0.03546355f, -0.02343849f, 
    -0.04605658f, 0.03545261f, -0.00946607f, 0.03395699f, -0.01315366f, 0.05169609f, -0.02350035f, -0.01801706f, 
    -0.04884588f, -0.03911283f, -0.01975992f, 0.04778900f, 0.04263616f, 0.04868221f, 0.05263618f, -0.06153293f, 
    -0.01822481f, -0.05290297f, -0.04801329f, -0.04873642f, 0.01886883f, -0.02587925f, -0.04848605f, -0.05280506f, 
    0.01496453f, 0.01712153f, -0.01521049f, -0.05387039f, -0.03201208f, -0.05682999f, 0.03530618f, 0.05485323f, 
    0.02748058f, -0.02643990f, -0.06079543f, -0.01116640f, -0.00865791f, -0.01052092f, 0.05011761f, 0.00341576f, 
    0.22585790f, -0.30461589f, -0.11284819f, 0.02341171f, 0.06505456f, 0.02038807f, -0.12858409f, -0.05478721f, 
    0.06962455f, 0.30498248f, 0.02868026f, -0.10042457f, 0.04433273f, 0.09791665f, 0.09716307f, 0.06292608f, 
    -0.00014910f, 0.00048387f, 0.05545245f, 0.18854548f, 0.03727912f, 0.14202608f, 0.13299185f, 0.03319602f, 
    0.03473571f, -0.01874449f, 0.07654113f, -0.08979236f, -0.07303736f, 0.20946008f, 0.10730463f, -0.12431558f, 
    0.06383540f, -0.11432346f, 0.00017253f, -0.16911875f, -0.17617081f, -0.01375788f, -0.48734063f, 0.04483203f, 
    0.03165070f, -0.04351711f, 0.03110308f, 0.13502131f, -0.05550413f, -0.42132100f, -0.27986407f, 0.34739918f, 
    0.08888406f, -0.10166908f, 0.02495088f, -0.06328296f, -0.03088752f, 0.01585345f, 0.03376318f, -0.12921230f, 
    -0.15491949f, -0.05405003f, 0.08863067f, 0.06752401f, -0.00661061f, -0.00818981f, 0.22487023f, -0.17436458f, 
    -0.20522821f, 0.26826024f, 0.03863790f, 0.04145627f, 0.06848087f, -0.06937138f, -0.06105075f, 0.02361354f, 
    -0.00118031f, 0.14055398f, -0.02406130f, 0.13177156f, -0.05081986f, 0.10167515f, 0.06009769f, -0.17520282f, 
    0.09761764f, -0.06827721f, -0.39570999f, 0.06984485f, -0.04156813f, 0.03074918f, -0.17783292f, 0.03839901f, 
    0.09665882f, 0.08381467f, -0.36472175f, -0.17275445f, 0.19583437f, 0.04469514f, -0.15368529f, -0.04002887f, 
    -0.08944199f, -0.07224187f, 0.01627967f, -0.02570058f, 0.36576718f, -0.10483424f, 0.01228470f, -0.09104907f, 
    0.02702514f, 0.05617747f, -0.08829708f, -0.03319198f, -0.25685209f, -0.10283829f, 0.15137821f, -0.02367539f, 
    0.00832520f, -0.17200945f, 0.08424548f, -0.00314562f, 0.03084968f, -0.33838567f, -0.07226129f, 0.10719465f, 
    -0.01568682f, -0.08921971f, 0.19937313f, 0.09895613f, 0.08071446f, -0.02051350f, -0.17549115f, -0.04614582f, 
    -0.15578224f, 0.06192777f, 0.02958442f, 0.05469519f, 0.10228123f, -0.01986112f, -0.06153920f, -0.47618440f, 
    0.06581573f, -0.15565822f, -0.02247144f, -0.01892228f, -0.06885523f, 0.07864372f, -0.08406291f, -0.24618222f, 
    0.06054530f, -0.11883215f, 0.20462047f, -0.07590320f, 0.06630112f, 0.27169383f, 0.03824241f, 0.06329629f, 
    -0.01059347f, 0.40822563f, 0.02972738f, -0.14278744f, 0.13324203f, -0.07155180f, 0.08103850f, -0.01032698f, 
    0.04725017f, 0.06943242f, 0.10089650f, 0.23205490f, 0.22652434f, 0.07577387f, -0.00005427f, -0.10127944f, 
    -0.04486464f, 0.02719438f, -0.09415511f, 0.52311194f, 0.19441952f, -0.05498557f, 0.03807036f, -0.10547256f, 
    0.03017532f, 0.04386151f, 0.07317191f, 0.11885434f, -0.34103599f, 0.18784553f, -0.30939037f, 0.14873827f, 
    -0.15456168f, 0.14040664f, -0.02279304f, 0.09957004f, -0.08387826f, -0.08788873f, -0.33575782f, 0.13587749f, 
    0.02310054f, -0.19459084f, 0.14799564f, 0.13622671f, -0.15304804f, 0.08614646f, 0.09915939f, 0.04918329f, 
    -0.06684807f, 0.01222058f, -0.00671262f, 0.03122376f, -0.14811131f, 0.09307297f, 0.04280088f, -0.05630111f, 
    -0.08878372f, -0.23528747f, -0.07149067f, -0.02929821f, 0.05510747f, -0.03415432f, -0.02652673f, 0.12670498f, 
    -0.73931348f, -0.00829372f, 0.28129852f, 0.09818842f, -0.10330313f, 0.02274291f, 0.03761083f, 0.13969423f, 
    -0.06858335f, -0.03190315f, -0.13330342f, -0.04574142f, 0.11251217f, 0.07414564f, 0.05813845f, -0.05228698f, 
    0.10898138f, 0.15773997f, -0.11540104f, 0.11822734f, -0.14133555f, -0.01692655f, 0.04050489f, 0.14353804f, 
    0.03641217f, -0.02519521f, 0.14989761f, -0.14357877f, -0.18174380f, 0.12778628f, 0.05813677f, 0.09640968f, 
    0.02820174f, -0.02381716f, -0.04026113f, 0.11246744f, -0.03111952f, -0.36160448f, 0.21671526f, 0.02049897f, 
    0.04670229f, -0.15853250f, 0.10950746f, 0.06592624f, -0.01376224f, 0.22691695f, 0.13658057f, -0.15968300f, 
    -0.04181052f, -0.01856006f, 0.03251939f, -0.09357186f, 0.02226565f, 0.06396617f, 0.02112051f, -0.12486102f, 
    -0.32602820f, -0.20043066f, 0.06828259f, 0.15303761f, 0.14439395f, -0.01059577f, 0.12931147f, 0.09448162f, 
    0.03997676f, -0.18624449f, 0.11097161f, -0.00949373f, 0.03545512f, -0.02120716f, -0.09429506f, 0.12340504f, 
    -0.03193117f, 0.05354906f, -0.07839947f, -0.01767345f, 0.05342964f, -0.04784753f, -0.04744602f, 0.05698778f, 
    0.16793686f, 0.17463002f, 0.06226141f, -0.01129638f, -0.04817197f, 0.00914155f, 0.08849952f, -0.11922276f, 
    -0.05530255f, 0.05987731f, 0.00781964f, 0.21719955f, 0.05187597f, -0.05384935f, 0.01207820f, 0.12395081f, 
    -0.15050402f, 0.04421451f, 0.04480016f, -0.21785860f, 0.05846195f, -0.20705108f, -0.12192968f, 0.01325245f, 
    -0.12414412f, 0.14860639f, 0.04558029f, -0.00507412f, 0.23906001f, 0.11117278f, -0.11927129f, -0.06542105f, 
    -0.02484914f, 0.12115780f, -0.09650657f, 0.03180530f, 0.16719809f, -0.27373245f, -0.09111121f, -0.35743916f, 
    -0.00515953f, 0.02958300f, 0.13534202f, 0.07222474f, 0.01547383f, -0.01860790f, 0.05551331f, 0.02627126f, 
    0.00783268f, -0.03994311f, 0.02585931f, -0.06766892f, -0.06165307f, 0.02969001f, 0.03061512f, -0.26479581f, 
    -0.12036527f, -0.26751560f, 0.12216655f, 0.00555715f, 0.00021177f, 0.04067982f, -0.03833115f, -0.13194455f, 
    0.12236293f, 0.00671289f, 0.35536930f, 0.00948189f, -0.04272140f, -0.07353232f, -0.06443881f, -0.07622051f, 
    -0.03279178f, 0.07749050f, 0.24066496f, -0.34857485f, 0.15632495f, 0.02584695f, -0.09419095f, 0.04104030f, 
    0.06392937f, -0.05903643f, -0.03599741f, 0.16706021f, -0.25507313f, 0.08487710f, 0.04444957f, 0.10879470f, 
    0.05586530f, -0.08947321f, -0.03130398f, 0.11579994f, 0.26640141f, 0.01306669f, 0.19130123f, 0.05438938f, 
    0.20879853f, -0.14613669f, 0.05573081f, 0.10399248f, 0.17693293f, 0.15250731f, -0.22637987f, 0.14929691f, 
    0.03483893f, -0.01878729f, 0.12513191f, -0.01837103f, -0.11427293f, -0.05525522f, -0.13788196f, -0.16191329f, 
    -0.01315026f, 0.05836259f, -0.04912714f, 0.06467255f, -0.08713911f, -0.04555787f, 0.03297881f, -0.03011022f, 
    -0.02004674f, 0.06553067f, -0.00008450f, -0.09860638f, 0.08753984f, -0.10034260f, -0.05411750f, 0.09945002f, 
    0.02220262f, -0.21527718f, -0.00606706f, -0.02376931f, -0.01575186f, 0.03124498f, 0.01162049f, -0.08542626f, 
    -0.14447832f, -0.07735960f, -0.18122256f, -0.16814017f, 0.03557819f, 0.03960624f, -0.16399299f, -0.15675183f, 
    0.09396972f, -0.15383033f, -0.02853091f, 0.06557437f, -0.04495451f, 0.07805842f, 0.03785276f, -0.09234050f, 
    0.03244894f, 0.05074009f, 0.07879761f, 0.12005553f, 0.06329226f, -0.03963484f, -0.05526276f, 0.10838765f, 
    0.08341194f, 0.09314505f, 0.04451280f, 0.11076880f, -0.18947567f, -0.14634052f, -0.18303338f, 0.08095063f, 
    -0.06652118f, 0.08887125f, -0.03372110f, -0.14646563f, -0.04006029f, 0.16384763f, 0.21670337f, 0.19298869f, 
    0.05978226f, -0.00884241f, -0.06779742f, 0.12434589f, 0.05188140f, -0.27436444f, -0.25438368f, -0.16168310f, 
    0.13842607f, -0.05024484f, -0.01940592f, -0.09200896f, 0.01072387f, 0.05226250f, -0.10388185f, -0.02987440f, 
    0.13480107f, -0.07635938f, -0.03895934f, -0.02309247f, -0.13304801f, -0.08926480f, 0.16767171f, -0.26296833f, 
    -0.02131246f, 0.23519306f, 0.05246168f, 0.21651170f, -0.00695057f, -0.03892532f, -0.02043077f, 0.08722667f, 
    -0.25195369f, -0.09690342f, -0.30886063f, 0.09308568f, -0.09087897f, -0.01856951f, 0.06586711f, -0.10533077f, 
    0.00706579f, 0.18444079f, -0.09070268f, -0.16444594f, -0.04250324f, -0.05007681f, 0.03753135f, 0.10776533f, 
    0.03091761f, -0.05332660f, 0.00231524f, 0.05547428f, -0.06562383f, 0.21196979f, 0.03574500f, -0.22088230f, 
    -0.08688384f, 0.09850219f, 0.04014400f, 0.08566075f, -0.11758021f, -0.27076027f, 0.20094238f, 0.02045523f, 
    0.04557674f, 0.03333819f, 0.08137813f, -0.04708451f, -0.31671435f, -0.12562355f, -0.27323630f, -0.02307779f, 
    -0.06713042f, 0.06755384f, 0.14377312f, 0.15450019f, -0.04989353f, -0.02990906f, 0.11771593f, 0.21001738f, 
    0.03639901f, 0.13431038f, -0.04316574f, 0.10962796f, -0.04067387f, 0.01320472f, -0.25966740f, -0.07583431f, 
    0.14290133f, -0.03342015f, 0.09111044f, 0.07661973f, -0.07831085f, -0.10788380f, 0.04883897f, -0.01533550f, 
    0.10823869f, 0.19941685f, -0.01501069f, 0.04757020f, 0.04023603f, 0.09253898f, 0.02327706f, -0.01040220f, 
    0.05610394f, 0.03285099f, -0.06116180f, 0.07499166f, -0.09596799f, -0.02382099f, -0.02481922f, -0.08289933f, 
    0.06826763f, 0.09436841f, 0.08440736f, 0.11681903f, -0.11047125f, 0.06198420f, 0.04707525f, 0.02872735f, 
    0.09946643f, 0.04854047f, 0.01518969f, 0.14327812f, 0.18789807f, 0.15473649f, 0.11381394f, 0.03348869f, 
    0.08417843f, -0.05922401f, 0.11828177f, -0.00986269f, 0.26645347f, 0.12151100f, -0.01732993f, 0.07639402f, 
    -0.22430408f, 0.08767758f, 0.08555943f, -0.22538513f, 0.05489815f, -0.01563664f, 0.13435408f, -0.08892381f, 
    0.01277092f, -0.03242745f, -0.06071202f, 0.02571024f, 0.12921168f, -0.15552571f, -0.14821531f, -0.07586803f, 
    0.03543775f, 0.06313375f, 0.09788515f, -0.01033411f, -0.00195185f, -0.12846097f, -0.16861415f, 0.03827410f, 
    -0.09406750f, 0.13452858f, -0.06785684f, 0.12259835f, 0.13689241f, -0.02204845f, 0.09389018f, -0.23635679f, 
    0.08175726f, 0.03424934f, 0.16470106f, -0.10851067f, -0.02081992f, 0.00753458f, 0.02613848f, -0.06296843f, 
    0.07896405f, 0.03663127f, 0.12446091f, 0.09580083f, 0.16021894f, 0.05339400f, 0.03840547f, -0.05292721f, 
    -0.06072270f, -0.32443899f, 0.13055508f, -0.02511978f, 0.05553502f, 0.03039832f, 0.00670147f, 0.07124995f, 
    0.06400175f, -0.02094243f, 0.08184889f, -0.29053503f, -0.14072260f, 0.08906758f, 0.07409964f, 0.00104387f, 
    0.01588320f, -0.05210986f, -0.00019977f, 0.11806374f, 0.12090461f, 0.11896148f, -0.02109748f, 0.06296804f, 
    0.04487882f, -0.09301051f, -0.08923092f, -0.01399537f, 0.04152597f, -0.18958023f, 0.03583138f, -0.06184611f, 
    0.05046065f, -0.23728104f, 0.10975116f, -0.10838181f, 0.10283267f, -0.24450316f, -0.19136542f, -0.24043369f, 
    0.12994148f, 0.02964711f, 0.11449990f, 0.03952710f, 0.01083175f, -0.02405267f, -0.21791515f, 0.02564874f, 
    -0.03445809f, -0.00081902f, 0.03089919f, 0.09747323f, -0.20644018f, 0.12605497f, -0.06226292f, -0.16529498f, 
    0.08594863f, 0.11927924f, -0.06806861f, -0.00764113f, -0.13992357f, -0.03326087f, 0.14580351f, 0.16326472f, 
    -0.15434575f, -0.15930927f, -0.17506042f, -0.04137165f, 0.01320458f, -0.00176667f, -0.10797014f, -0.04499782f, 
    -0.02254436f, -0.06115381f, 0.02965558f, -0.06057275f, -0.11561005f, 0.01010291f, 0.06370212f, -0.02284748f, 
    0.08407932f, -0.06924163f, 0.00791521f, 0.05078212f, 0.34548500f, -0.06907899f, 0.01207710f, -0.05438330f, 
    0.03531120f, 0.06635411f, 0.08779909f, -0.08076008f, -0.14502597f, 0.10300192f, -0.00112665f, -0.00025261f, 
    -0.01470885f, 0.19532321f, 0.12597005f, 0.02625660f, 0.10082632f, 0.25092387f, 0.24742521f, 0.00910889f, 
    0.00401236f, -0.15962587f, 0.05832694f, -0.04746998f, 0.08400145f, -0.26449853f, -0.04778761f, -0.11782023f, 
    0.01907739f, -0.06997437f, 0.06532969f, -0.00804385f, -0.02815324f, -0.09621575f, 0.01896055f, -0.05649417f, 
    0.13542041f, 0.00296737f, 0.00452969f, -0.02260307f, 0.07473759f, 0.01743627f, 0.07255108f, -0.34893870f, 
    -0.19070093f, -0.11510242f, 0.03350081f, -0.01807836f, 0.11514539f, -0.03944890f, 0.04597955f, -0.12380216f, 
    -0.14925899f, -0.27710629f, 0.02403222f, -0.08417545f, 0.06088753f, 0.00446406f, -0.14816219f, -0.00605336f, 
    0.15229882f, 0.02757190f, 0.12913239f, -0.14738007f, -0.07226796f, 0.08922957f, 0.10851556f, 0.00387182f, 
    0.16392232f, 0.05105719f, -0.02888503f, 0.11131547f, 0.10800811f, 0.01674333f, 0.05936037f, -0.20038335f, 
    0.08042496f, 0.15252151f, 0.13254237f, 0.01288327f, -0.07874969f, -0.22599104f, -0.00115389f, 0.17763831f, 
    -0.04397272f, -0.00531281f, -0.13825144f, 0.10363252f, -0.19590825f, -0.19756129f, 0.17212504f, 0.15002336f, 
    -0.09380269f, -0.10443504f, 0.00630645f, 0.08761256f, -0.10058144f, 0.08175687f, 0.08811213f, 0.10837159f, 
    -0.00217999f, 0.02411430f, 0.03855780f, 0.03087365f, 0.07488093f, -0.09602305f, -0.14193358f, -0.14915030f, 
    0.10588530f, 0.01813001f, 0.13186017f, 0.07844667f, 0.03952402f, -0.16293541f, -0.03061086f, 0.06906615f, 
    -0.09385748f, 0.18107955f, 0.13695633f, -0.04480981f, 0.10996258f, 0.11407585f, -0.05787866f, -0.04437990f, 
    0.18895888f, 0.10512750f, 0.00802765f, 0.37488651f, -0.15237300f, 0.08734593f, 0.22603314f, -0.07399664f, 
    0.15800872f, -0.02974107f, 0.20920630f, -0.00758950f, 0.12840164f, -0.00091442f, 0.03491509f, 0.07056792f, 
    0.14421566f, 0.11122672f, -0.08331919f, 0.22511712f, -0.01295240f, 0.26405871f, 0.12706192f, -0.01942517f, 
    0.05188325f, -0.05982922f, 0.06570832f, 0.39740151f, 0.17148125f, 0.05051029f, 0.09882428f, -0.01896832f, 
    -0.04264157f, 0.13036506f, 0.03886086f, 0.08619656f, 0.07695875f, 0.19196361f, 0.02935349f, -0.00210453f, 
    -0.10043639f, 0.06880842f, 0.07307293f, -0.00908918f, 0.33567730f, 0.18035507f, 0.03992345f, 0.07598338f, 
    -0.06745621f, 0.04737838f, 0.15834954f, 0.01364377f, 0.02591247f, 0.18643710f, -0.13732238f, -0.13883273f, 
    -0.02281758f, 0.08380466f, 0.18335438f, 0.29903889f, 0.12696066f, -0.00134127f, -0.07234127f, 0.06289977f, 
    -0.04051285f, -0.07262130f, -0.19120714f, 0.22073036f, -0.06936730f, -0.05345604f, -0.05479904f, 0.33671817f, 
    0.12203345f, -0.11037125f, -0.01706265f, 0.22730669f, 0.08490390f, -0.01224810f, 0.03479214f, 0.09051141f, 
    -0.02671778f, 0.12625208f, -0.04774670f, 0.01905188f, 0.02852278f, -0.16979143f, 0.10434536f, 0.06675296f, 
    -0.06375971f, 0.11997769f, 0.15400434f, -0.32174543f, -0.09697228f, 0.09390115f, 0.13474402f, 0.31330815f, 
    0.01018435f, 0.02131952f, -0.06488050f, 0.07938937f, 0.37315041f, -0.12129260f, 0.00131184f, -0.16826195f, 
    -0.10990860f, -0.03631342f, 0.03161525f, -0.05746821f, 0.02524717f, -0.02554090f, -0.01296873f, -0.19802429f, 
    -0.04075165f, 0.13826104f, 0.04892355f, -0.05506213f, -0.18462090f, -0.17915089f, 0.06330136f, -0.00305384f, 
    0.12962562f, 0.16584918f, 0.22958162f, 0.09019994f, 0.02799630f, -0.00101666f, 0.24923341f, 0.15956236f, 
    -0.06788729f, 0.03796818f, 0.10776154f, -0.06250604f, -0.10005692f, 0.25014740f, 0.26116237f, 0.41396847f, 
    -0.10028487f, -0.08740198f, -0.02310628f, -0.05818041f, -0.02296802f, -0.13158751f, 0.18090118f, 0.29442334f, 
    -0.11458927f, 0.09281459f, -0.11251915f, 0.37053496f, -0.04911261f, 0.11467835f, 0.08569124f, 0.11391378f, 
    0.15219095f, -0.04117248f, 0.27394822f, -0.02505377f, 0.14486808f, 0.04398495f, -0.01959076f, 0.21786056f, 
    0.14555086f, 0.05921784f, 0.07031648f, 0.41912079f, -0.07321733f, 0.29671198f, -0.10819750f, -0.04516931f, 
    -0.07589681f, 0.14949670f, 0.29045898f, 0.03138853f, -0.27382532f, 0.06852941f, 0.12790404f, 0.09733251f, 
    0.15466040f, -0.04959108f, 0.11113684f, 0.08920763f, 0.68176311f, 0.40490481f, -0.01462565f, -0.01971147f, 
    -0.16661528f, -0.16352573f, 0.14544046f, 0.05038639f, 0.35011014f, 0.24761452f, -0.01140066f, 0.00944181f, 
    -0.02346782f, 0.04758002f, 0.05953571f, 0.05409186f, -0.06799991f, 0.23437718f, 0.12934005f, 0.14236112f, 
    0.06501235f, 0.15606143f, -0.10620385f, 0.01264534f, 0.18901481f, 0.14989196f, 0.09330666f, 0.12242696f, 
    -0.26611403f, -0.23478824f, 0.01819169f, 0.15229514f, 0.09089503f, -0.04863177f, 0.04759394f, -0.08098686f, 
    0.07839824f, 0.02541846f, -0.01592235f, -0.10017473f, 0.17141749f, 0.08803294f, -0.11677581f, 0.04915846f, 
    -0.10037673f, -0.06397003f, 0.11986907f, 0.05020173f, 0.16875340f, -0.01365934f, 0.02118141f, 0.12627457f, 
    -0.02237716f, 0.31114838f, 0.09005442f, 0.01850744f, 0.00642496f, -0.00493535f, 0.11038790f, -0.15905093f, 
    0.14561795f, 0.04752432f, 0.22277947f, -0.05713233f, -0.07298981f, 0.00351488f, -0.08028737f, -0.08305088f, 
    0.24526119f, -0.04888865f, -0.07068399f, 0.02685550f, 0.10491431f, 0.00732143f, 0.04558640f, 0.01595474f, 
    0.14899537f, -0.06141920f, 0.00405781f, 0.02731734f, 0.21683727f, 0.15014596f, -0.10004146f, -0.01326475f, 
    0.10610673f, 0.01943035f, 0.12049697f, 0.11878341f, -0.02995636f, -0.00392785f, -0.16094191f, -0.06279334f, 
    -0.02269151f, 0.11102925f, 0.09491343f, 0.22903714f, -0.00490417f, -0.02959086f, 0.07132822f, 0.12250508f, 
    0.02450388f, 0.04126358f, 0.08261963f, 0.07957186f, 0.19285017f, 0.18902482f, -0.06712297f, 0.02966746f, 
    0.03629769f, 0.04285510f, -0.00079422f, -0.03565177f, 0.02423923f, 0.02116152f, -0.04913158f, -0.03672464f, 
    0.02868116f, -0.06142730f, -0.03386030f, 0.03137191f, -0.06311573f, 0.00753774f, -0.06338786f, 0.04275036f, 
    -0.02675097f, -0.06392206f, -0.02881291f, -0.00517225f, -0.00205504f, -0.02461496f, -0.02242978f, 0.01795213f, 
    -0.02129855f, 0.03835231f, -0.03933899f, -0.03446735f, -0.01331097f, 0.01255252f, -0.04287791f, 0.00010150f, 
    -0.03434931f, -0.02905748f, 0.00906649f, 0.03367565f, -0.05383005f, -0.05574678f, 0.04542520f, 0.04010190f, 
    0.03843761f, -0.00289153f, 0.03472083f, 0.04171235f, -0.04924822f, 0.01131683f, -0.05595721f, 0.00095814f, 
    0.04896808f, 0.00324392f, -0.04786211f, 0.03978390f, -0.06221681f, -0.04963045f, 0.02211014f, 0.03361637f, 
    -0.01888906f, -0.03691566f, -0.00471068f, -0.02709342f, 0.04108654f, 0.04186641f, -0.05595420f, -0.01999622f, 
    0.01591457f, -0.05078984f, -0.03986045f, 0.02503173f, -0.04824866f, 0.02219480f, 0.04675484f, -0.00695671f, 
    0.02034585f, 0.04510232f, -0.06274834f, 0.03048430f, 0.00313213f, -0.04882050f, -0.05005101f, 0.03361779f, 
    0.03777614f, 0.01463946f, -0.01437702f, 0.00725435f, -0.04765380f, -0.05661858f, 0.04302073f, 0.03261167f, 
    0.04401539f, -0.01838191f, -0.03930691f, -0.01218651f, 0.05050573f, -0.05052495f, 0.00589129f, 0.03262891f, 
    -0.03515494f, -0.02988570f, 0.00969162f, 0.02027030f, -0.01699509f, 0.01251228f, 0.02232774f, -0.01046073f, 
    -0.02876553f, -0.02732175f, 0.01481370f, 0.00153740f, 0.01379935f, -0.05887119f, 0.02155398f, -0.04025265f, 
    -0.05090919f, 0.01009480f, -0.01461026f, 0.03126076f, -0.03048687f, 0.02625961f, -0.04746664f, -0.01316135f, 
    -0.06124125f, 0.03344284f, 0.00594070f, 0.04774420f, -0.02682182f, -0.01729786f, 0.01208131f, 0.03828629f, 
    -0.04022551f, 0.02179848f, -0.02230682f, 0.02363120f, -0.02818055f, 0.04209084f, -0.02729974f, 0.04357224f, 
    -0.01746510f, 0.04973891f, -0.00329995f, -0.00700738f, -0.05456878f, 0.01513950f, 0.05156983f, 0.02059635f, 
    -0.05223931f, -0.03170667f, 0.00678156f, -0.04391877f, -0.04423703f, 0.01887929f, 0.00617428f, -0.05629138f, 
    -0.03938007f, -0.05599910f, -0.02707557f, 0.04140882f, -0.01532066f, 0.04466535f, -0.06270923f, -0.02981013f, 
    0.04310603f, 0.00458782f, -0.05583777f, -0.01097461f, -0.02617622f, 0.00968930f, 0.04752838f, -0.01999310f, 
    0.03608142f, 0.00464129f, -0.01467885f, -0.00522144f, 0.04776918f, -0.01933260f, -0.05868634f, 0.04868549f, 
    0.04736893f, 0.01700074f, -0.01009816f, 0.03985815f, 0.03370060f, -0.04408119f, 0.02948895f, -0.03039509f, 
    0.03809111f, -0.03618994f, 0.03217610f, 0.00697342f, 0.04484027f, -0.04305585f, 0.05483808f, -0.01437820f, 
    -0.04001029f, 0.00730417f, 0.03806570f, -0.01340542f, -0.06418606f, -0.03797868f, -0.04461142f, -0.02897798f, 
    0.03620103f, -0.04137612f, 0.02553901f, -0.01085953f, -0.02321514f, 0.03685155f, -0.05279765f, -0.05694934f, 
    -0.02548957f, 0.02622602f, 0.01319658f, 0.03739775f, -0.05779262f, -0.03835217f, -0.04410125f, 0.00464641f, 
    -0.00168924f, -0.01952517f, -0.02688567f, 0.03587868f, -0.04747339f, -0.03050748f, 0.00072813f, -0.06067044f, 
    -0.05451936f, -0.00628629f, 0.01739139f, -0.04977032f, -0.02993522f, 0.00989227f, -0.01762921f, 0.01444681f, 
    -0.04301066f, -0.05978683f, -0.05673178f, -0.03979589f, 0.05119431f, -0.05165138f, -0.05649657f, -0.03900165f, 
    0.00589844f, -0.06331762f, -0.01891980f, 0.03063174f, -0.01762640f, -0.04451603f, -0.04404806f, -0.02720705f, 
    -0.04675880f, -0.00815564f, -0.02953605f, -0.03667113f, -0.04423846f, -0.02222076f, -0.00230005f, 0.03635610f, 
    -0.04160270f, -0.01532878f, -0.05665103f, -0.01399878f, -0.04467616f, -0.02499734f, -0.04835671f, -0.03371495f, 
    0.02384753f, 0.04750178f, -0.01102824f, 0.02404060f, -0.00564020f, -0.01977316f, 0.03754677f, 0.04152457f, 
    -0.01109183f, -0.01744961f, -0.02400592f, -0.01338250f, -0.02393332f, -0.03118470f, -0.01849361f, -0.05802729f, 
    0.03160030f, 0.01338656f, -0.00106841f, -0.00940997f, 0.01385009f, 0.03811311f, -0.01328591f, -0.05089977f, 
    0.03436221f, 0.02133995f, -0.03633148f, -0.03640645f, -0.01047478f, 0.02377921f, -0.00656714f, 0.02305938f, 
    0.04918123f, -0.01111978f, 0.03315024f, 0.04516154f, -0.01599596f, -0.01808739f, -0.03982786f, 0.04035906f, 
    0.03081195f, -0.04477783f, -0.02411385f, -0.01034858f, -0.02738142f, 0.03662293f, -0.00764685f, -0.05913946f, 
    0.00600008f, -0.01850237f, -0.04059150f, -0.04752459f, 0.00668509f, -0.02434344f, -0.04673305f, -0.01369853f, 
    0.00335607f, -0.02268102f, 0.01514203f, 0.04960937f, 0.05213246f, 0.02860454f, 0.00842165f, 0.04116610f, 
    -0.02826435f, -0.05616131f, 0.04379185f, 0.04606052f, 0.04600260f, -0.04251689f, -0.01938087f, 0.03140970f, 
    0.00640492f, 0.00021414f, -0.04172328f, -0.02409339f, -0.05421249f, 0.03094036f, -0.01697434f, 0.01212257f, 
    -0.01650870f, -0.05655432f, -0.04762601f, -0.05630876f, -0.03362514f, 0.04399524f, -0.00475689f, -0.02691772f, 
    0.01075497f, 0.01898163f, -0.06768464f, 0.03119680f, 0.02118768f, -0.02546866f, 0.04169887f, 0.00252898f, 
    -0.05757070f, 0.01951408f, -0.03913024f, -0.00563959f, -0.03198974f, 0.02549655f, -0.04007856f, 0.01947008f, 
    -0.04948620f, -0.03706261f, 0.04780501f, 0.02444092f, 0.02559407f, -0.04080725f, 0.03072804f, -0.05574510f, 
    -0.04087130f, -0.04815138f, -0.04862423f, -0.03861810f, -0.00310921f, -0.01155246f, -0.01361069f, -0.02031685f, 
    -0.06365944f, -0.06658888f, -0.04122781f, 0.03686397f, -0.00831918f, 0.02344175f, 0.00266761f, -0.00172905f, 
    -0.04886010f, -0.00223982f, 0.02518519f, -0.02201145f, -0.05954934f, 0.00938935f, 0.02559482f, 0.01525686f, 
    0.04386646f, -0.06458332f, 0.00898684f, -0.00775567f, 0.04599641f, -0.00982068f, -0.03552457f, -0.04907013f, 
    -0.00772139f, 0.02570576f, 0.01308247f, -0.00398133f, -0.01047767f, -0.01806538f, 0.01349453f, -0.04863135f, 
    -0.05954580f, -0.04273444f, -0.00564206f, 0.03692748f, 0.01714650f, 0.01660507f, -0.01855272f, -0.03812671f, 
    -0.02867280f, -0.00242408f, -0.01234283f, -0.01411244f, -0.02860818f, -0.03490756f, -0.06026916f, -0.00370530f, 
    -0.05402607f, -0.03181825f, -0.06342260f, -0.01691922f, 0.01915175f, 0.01911793f, 0.02203228f, -0.03316015f, 
    -0.06165409f, 0.03058614f, -0.02713240f, 0.01839832f, 0.03089379f, -0.04665305f, 0.02217512f, -0.05508171f, 
    0.03764732f, -0.01543470f, -0.01174712f, 0.04486777f, 0.03583673f, -0.06375679f, 0.01331002f, 0.01492471f, 
    -0.03959209f, 0.02720382f, -0.00852528f, -0.01621971f, 0.01826158f, -0.03812075f, -0.01084880f, 0.04722079f, 
    -0.03309195f, 0.04936295f, 0.03398245f, -0.00135585f, 0.02884402f, -0.02214437f, 0.03383157f, 0.04605475f, 
    0.04029872f, -0.00042658f, 0.01050128f, 0.00579022f, -0.02686149f, -0.05643446f, 0.03002832f, 0.04232107f, 
    -0.03410862f, -0.00677058f, 0.03345684f, -0.05361320f, -0.02827038f, -0.04365280f, -0.05689546f, -0.02290555f, 
    -0.04403792f, -0.03305753f, -0.03013669f, 0.01096014f, 0.00911412f, 0.03070588f, -0.05249398f, 0.04445896f, 
    0.01849908f, -0.03707056f, -0.06196674f, 0.00096661f, -0.05493107f, -0.02089783f, -0.00364119f, 0.01341322f, 
    0.00607892f, -0.02241312f, -0.03927248f, 0.03694744f, -0.00827544f, 0.00734960f, 0.04397614f, 0.00059826f, 
    0.03656007f, -0.01348472f, -0.05731386f, -0.02596755f, -0.05010325f, 0.02769861f, -0.06200829f, 0.01352279f, 
    0.03685021f, 0.01698833f, -0.03421926f, -0.01162182f, -0.01685273f, -0.04211571f, 0.00225536f, 0.02702024f, 
    -0.02656251f, -0.03995320f, -0.03045973f, 0.01886988f, 0.01832867f, 0.00468136f, -0.05862512f, -0.05685508f, 
    -0.04212455f, -0.04585093f, -0.04044502f, 0.00514528f, 0.01093700f, -0.02981864f, -0.02399557f, -0.06816422f, 
    0.01067911f, -0.02179043f, -0.02777942f, -0.03349426f, 0.03253394f, 0.01895430f, 0.04757168f, 0.00544382f, 
    0.00977132f, 0.02024589f, -0.06536294f, -0.05016750f, 0.02948630f, 0.01121663f, -0.03853394f, -0.01136838f, 
    0.04697257f, -0.06041913f, 0.03997458f, 0.02077367f, 0.02545640f, 0.00722618f, 0.02701527f, -0.06232449f, 
    -0.03318587f, 0.03761839f, 0.01160218f, -0.06346619f, -0.00107913f, -0.00779349f, 0.02015444f, -0.06052258f, 
    -0.13024901f, 0.11461677f, -0.03054702f, 0.06065424f, 0.07765593f, 0.16787861f, -0.06878082f, -0.04936029f, 
    0.02085933f, 0.12734647f, 0.09751248f, -0.21412575f, 0.00847197f, 0.00463898f, 0.09994855f, 0.04551568f, 
    0.06223174f, -0.09037416f, 0.00772849f, 0.05395392f, 0.13105908f, 0.07940241f, -0.03409672f, 0.07484500f, 
    0.03162479f, -0.10805812f, 0.10959924f, 0.11954153f, 0.05739345f, 0.10907674f, -0.16963539f, -0.02585841f, 
    -0.01772727f, -0.04477324f, 0.10208301f, -0.02760711f, 0.08011372f, -0.24556018f, -0.08906069f, -0.04235505f, 
    0.00290661f, 0.01422395f, 0.16553104f, -0.00486287f, 0.06963804f, -0.15878558f, 0.10328052f, 0.19044368f, 
    -0.10280731f, -0.07811540f, 0.07644042f, 0.02760275f, 0.00983804f, 0.06468466f, 0.27561602f, -0.10762060f, 
    0.09607653f, -0.25441933f, 0.00258792f, 0.12407132f, 0.12746990f, -0.09542391f, 0.04140307f, -0.07024429f, 
    -0.01146883f, -0.38350418f, -0.10824136f, -0.17464299f, 0.13324082f, 0.01992174f, 0.07006495f, -0.07707270f, 
    0.34518683f, 0.09968649f, -0.01890825f, -0.04457751f, 0.00281397f, 0.04123495f, 0.11448009f, 0.18262427f, 
    -0.05508287f, 0.13320206f, -0.04783731f, 0.17836797f, -0.28273165f, 0.05338971f, 0.04007399f, 0.06845292f, 
    0.07588664f, -0.00028949f, 0.02305040f, -0.05986499f, 0.10371532f, -0.08747169f, 0.03384357f, -0.06159528f, 
    0.03000301f, -0.06060603f, 0.01260625f, 0.14395440f, -0.19801010f, 0.08854803f, -0.00261795f, 0.03000865f, 
    -0.01660083f, 0.12321783f, -0.10964910f, -0.09266548f, -0.13065025f, -0.26563275f, -0.08042336f, 0.06506573f, 
    0.09179570f, 0.02232593f, -0.06355411f, -0.00024736f, 0.07867939f, 0.11078738f, -0.12914285f, 0.23846613f, 
    -0.14944007f, -0.00395179f, -0.02887904f, -0.10604382f, 0.13423356f, 0.08673872f, -0.34519628f, -0.08211830f, 
    -0.06446389f, 0.00506091f, 0.14023326f, 0.07338092f, 0.03182130f, -0.08038843f, 0.03425783f, 0.00766331f, 
    -0.20278399f, -0.02789962f, 0.05423266f, 0.06429865f, 0.03998847f, 0.02443984f, -0.22247952f, 0.06302631f, 
    -0.31327704f, 0.26541087f, 0.07057648f, -0.03821757f, -0.03154226f, 0.02940009f, 0.06035561f, -0.07138574f, 
    -0.10566325f, 0.03212926f, 0.00678460f, -0.01648899f, 0.09881435f, -0.00719006f, -0.05893401f, 0.03964303f, 
    -0.05523345f, 0.16143005f, -0.06258596f, -0.15183829f, 0.15291639f, 0.10953190f, 0.06597160f, 0.00984491f, 
    0.05912667f, 0.03286374f, -0.08139272f, 0.00347093f, -0.07051881f, -0.10950603f, -0.09765337f, 0.10062543f, 
    0.02874579f, -0.04526343f, -0.02219184f, 0.02869476f, 0.09109845f, -0.18093410f, -0.04294109f, 0.05351899f, 
    0.12397196f, 0.11831761f, 0.07135211f, 0.10735978f, -0.00661661f, -0.21042056f, 0.16934052f, 0.05131343f, 
    -0.08802585f, -0.06028393f, -0.02360958f, 0.06473567f, -0.01500059f, 0.02575618f, 0.15513685f, 0.20414577f, 
    -0.23913480f, 0.05997222f, 0.14824225f, 0.03342390f, 0.01055710f, 0.06056864f, -0.01400976f, 0.11077024f, 
    -0.11170555f, -0.07120275f, -0.12452840f, 0.06037184f, -0.11182236f, 0.12517045f, -0.09947424f, 0.08594231f, 
    0.00178465f, -0.00335303f, -0.10769557f, -0.13569930f, -0.09076554f, -0.04846918f, 0.10736412f, -0.05779241f, 
    -0.12405622f, -0.17736128f, -0.10727406f, -0.01432498f, 0.03992832f, -0.00968854f, 0.01123415f, 0.06177418f, 
    -0.07058067f, 0.01029509f, -0.19771715f, -0.15567513f, -0.31208187f, 0.03433995f, 0.03078132f, 0.00130858f, 
    0.14682551f, -0.13741782f, -0.08496157f, -0.21629116f, -0.05284952f, 0.14322978f, -0.09769978f, 0.00794222f, 
    -0.04914154f, 0.02479029f, 0.11982960f, -0.02946592f, -0.31903130f, 0.00373582f, 0.26955634f, -0.05535303f, 
    -0.03808734f, -0.09811295f, 0.06670519f, 0.01274443f, 0.05438025f, 0.14611058f, 0.21294086f, 0.04311089f, 
    0.13599218f, 0.03751029f, -0.10745826f, 0.04708713f, -0.07681938f, -0.00821223f, 0.05733640f, 0.10138918f, 
    0.17846553f, 0.11786935f, -0.03777669f, -0.01049817f, -0.04187988f, 0.07771058f, 0.11935311f, 0.02071386f, 
    -0.11495882f, 0.06260624f, -0.03402544f, 0.08066964f, 0.09407845f, -0.09464616f, 0.01749549f, 0.03334506f, 
    0.19239046f, 0.12620820f, -0.03593288f, -0.17677964f, -0.03765887f, -0.11477258f, 0.17583086f, 0.02106223f, 
    0.06152720f, -0.02997136f, -0.00159312f, 0.06260648f, -0.01078909f, -0.03429516f, -0.07953018f, 0.07943626f, 
    -0.09158183f, 0.06235098f, -0.24061768f, -0.25873905f, 0.02267973f, -0.00657374f, 0.13781612f, 0.00372511f, 
    0.03619681f, 0.08027957f, -0.02143947f, 0.20264199f, -0.03700508f, -0.04292496f, -0.18505041f, -0.02668360f, 
    -0.07683145f, -0.10924011f, 0.13927916f, 0.09399451f, 0.09142632f, 0.09690621f, 0.08263087f, 0.02275769f, 
    0.04090499f, -0.01634946f, 0.14697890f, -0.15596107f, -0.00562927f, 0.06911629f, 0.12391444f, -0.02078994f, 
    -0.01292687f, 0.00257172f, -0.02361917f, 0.02716247f, 0.02382048f, -0.02133378f, -0.02212708f, -0.11198096f, 
    0.03821454f, -0.07049208f, 0.01368125f, 0.15771300f, 0.00100839f, -0.00790448f, -0.10253499f, 0.09971008f, 
    0.08136395f, 0.04333080f, -0.07848654f, 0.00074591f, 0.02158107f, -0.07489702f, -0.00100609f, -0.02491126f, 
    -0.35643807f, 0.09168176f, -0.18818463f, -0.03009071f, 0.00244692f, 0.03948805f, 0.00759350f, 0.11303642f, 
    0.00627483f, 0.18233339f, -0.03018317f, 0.00023379f, -0.10139002f, 0.06131993f, 0.03707611f, 0.01440287f, 
    -0.01986171f, -0.01710768f, 0.08868589f, 0.20811093f, 0.02339207f, -0.02912046f, 0.02373592f, -0.05959046f, 
    0.02517747f, 0.22440530f, 0.01568070f, -0.08191062f, -0.20170638f, -0.00392421f, 0.19860116f, 0.09149124f, 
    0.04619711f, -0.10411283f, 0.03213017f, 0.16466300f, 0.04802426f, 0.06926733f, -0.04208050f, -0.00019321f, 
    -0.07245965f, -0.05200672f, -0.05465244f, -0.05442497f, 0.04351706f, 0.12427783f, 0.03400273f, -0.10203789f, 
    0.08284249f, -0.03535987f, -0.09399684f, 0.03387500f, 0.02697170f, 0.17709357f, -0.19513737f, 0.10463687f, 
    -0.01217348f, -0.01985919f, 0.07777612f, 0.01670387f, -0.09179712f, 0.00415754f, 0.06125829f, -0.19069380f, 
    0.13151412f, 0.12912782f, 0.07027896f, 0.03114459f, 0.09913923f, -0.12599699f, -0.08357410f, 0.00025745f, 
    0.03709469f, -0.04984725f, -0.22795729f, -0.17463513f, 0.11089925f, -0.12127421f, 0.12909766f, 0.10577840f, 
    -0.04965774f, -0.20864853f, -0.14339086f, -0.13166745f, 0.03706386f, -0.00445712f, 0.10238596f, 0.04808117f, 
    0.05559960f, 0.13661483f, -0.38378614f, -0.42220330f, 0.02676207f, -0.00245899f, 0.11498585f, 0.04441710f, 
    0.08442558f, -0.06864004f, -0.08184807f, 0.20988651f, -0.00337200f, -0.12692085f, -0.03399239f, -0.00329132f, 
    -0.00932047f, -0.13561860f, 0.09669696f, 0.03103353f, -0.06216887f, -0.23337054f, -0.12936632f, 0.08817524f, 
    0.01379695f, 0.04850037f, -0.07356759f, 0.00367081f, 0.03450882f, -0.04736035f, 0.08026903f, 0.03557345f, 
    0.01691326f, -0.20739827f, 0.00088956f, 0.07237552f, -0.06472775f, 0.04427660f, 0.13869426f, 0.03532048f, 
    -0.11692664f, 0.00624232f, -0.00359732f, 0.03914773f, -0.07311942f, 0.12513554f, 0.06034870f, 0.35482720f, 
    -0.02788654f, 0.00861525f, -0.15169008f, -0.14686680f, 0.04653798f, 0.03217620f, 0.14754233f, 0.08042128f, 
    0.03178672f, 0.13923064f, -0.03773680f, -0.00735353f, -0.04688916f, -0.11747139f, 0.09648491f, -0.05402707f, 
    -0.02514625f, 0.01212642f, 0.18409279f, 0.11684557f, 0.05151029f, 0.00217052f, 0.04716157f, -0.03399818f, 
    -0.13592805f, -0.02011703f, 0.37088194f, -0.18708649f, -0.08222152f, 0.00642666f, -0.00341129f, 0.03231146f, 
    -0.08248135f, 0.00699663f, 0.01681114f, -0.00921266f, 0.07988032f, 0.05442752f, -0.03229351f, -0.03876816f, 
    -0.01869535f, 0.06976235f, 0.06229103f, 0.09060154f, -0.04673798f, 0.23062359f, -0.00720080f, -0.07944102f, 
    -0.06868690f, -0.10032650f, -0.12127514f, -0.11486866f, -0.00682977f, -0.15235148f, -0.01938170f, -0.13700540f, 
    0.02706375f, -0.01559500f, 0.02968109f, -0.06855711f, 0.03331026f, 0.00920727f, -0.15263976f, -0.13850087f, 
    0.06885828f, 0.08396989f, 0.11505169f, -0.03395564f, -0.02426339f, -0.03409104f, -0.03727511f, 0.05986150f, 
    -0.15288253f, 0.13335645f, 0.09249029f, 0.05461201f, 0.04800004f, -0.04571993f, 0.02074342f, 0.02434327f, 
    -0.04782883f, -0.02388444f, 0.03541964f, -0.03558391f, 0.03214068f, -0.06120484f, 0.03938269f, -0.02862223f, 
    0.05173861f, -0.00687031f, 0.02995085f, 0.04009550f, -0.06266930f, 0.03215550f, -0.02574380f, -0.02082381f, 
    0.02838851f, -0.04346970f, 0.00178785f, 0.03386453f, -0.03923871f, -0.03722068f, 0.00784923f, 0.03489541f, 
    -0.04676295f, -0.03241573f, -0.05477186f, 0.01428608f, 0.03982882f, 0.00543074f, 0.03471498f, -0.03013385f, 
    0.01412954f, 0.00405563f, 0.03595185f, -0.04052575f, 0.04717897f, -0.03242052f, 0.04331109f, -0.02908515f, 
    -0.01159700f, 0.03622646f, -0.00105166f, -0.01177895f, -0.01253690f, -0.04467520f, -0.01600526f, -0.05326692f, 
    -0.00932545f, -0.05314475f, -0.01573166f, 0.02900060f, -0.06209053f, 0.02771443f, 0.03283084f, -0.04333248f, 
    0.02011980f, -0.04020436f, 0.03618419f, 0.03435360f, -0.05694621f, 0.02280043f, 0.00184666f, 0.04365633f, 
    0.03647517f, -0.02738066f, -0.03535736f, 0.03448358f, 0.00378301f, 0.03743144f, -0.03026494f, -0.04518966f, 
    -0.04860065f, -0.02065699f, -0.06215809f, 0.00864095f, 0.02182302f, 0.02125539f, -0.05525739f, 0.04929165f, 
    -0.03395590f, 0.04825402f, 0.01207716f, 0.05150842f, -0.04886572f, -0.01181244f, 0.03010551f, -0.06219353f, 
    -0.01417492f, -0.04177292f, -0.00443049f, 0.02728150f, -0.02700301f, -0.04640599f, 0.03274751f, -0.06531832f, 
    -0.04489145f, 0.01405500f, -0.05289513f, 0.03087220f, 0.03033426f, 0.03536145f, 0.04655490f, -0.06432096f, 
    0.03138936f, 0.02400650f, 0.03020506f, 0.01276129f, -0.01792910f, -0.02253583f, 0.04327673f, 0.01955179f, 
    -0.00080490f, 0.03071666f, 0.05139600f, -0.02212188f, -0.02897077f, -0.00928395f, -0.02339518f, -0.00460900f, 
    -0.05285108f, 0.01737958f, -0.05531840f, 0.05031238f, 0.04091294f, 0.02105749f, -0.01884188f, -0.01404767f, 
    -0.01832242f, -0.00301553f, -0.02017477f, -0.01381932f, -0.02923071f, 0.00321228f, -0.03656671f, -0.06160431f, 
    0.04354713f, -0.01774696f, -0.05801775f, 0.00616564f, 0.00710825f, -0.02521314f, -0.05732758f, -0.03368898f, 
    -0.03343609f, -0.01423154f, 0.03934304f, -0.03832394f, -0.03443592f, -0.05585180f, 0.03077164f, -0.06333515f, 
    -0.00800268f, 0.01092132f, 0.01310840f, -0.03351985f, 0.00521980f, -0.01559572f, 0.00768292f, -0.04336763f, 
    0.02412124f, -0.02392314f, -0.01906414f, 0.01701810f, -0.03163799f, 0.01425666f, -0.05782156f, 0.04802322f, 
    -0.02166334f, -0.04303276f, -0.04321755f, 0.05333642f, -0.04038257f, -0.02633083f, -0.03371137f, -0.02379401f, 
    0.04081502f, -0.01291389f, 0.00757006f, 0.01862728f, -0.06578456f, -0.03179430f, -0.05045131f, 0.02735340f, 
    -0.01664545f, 0.02703088f, 0.02695037f, -0.02084310f, 0.05068240f, 0.04269825f, 0.03650961f, -0.03480902f, 
    0.00076810f, -0.00239685f, -0.00701504f, -0.03004130f, -0.06404237f, -0.05016755f, -0.04841921f, -0.00359218f, 
    0.02276393f, 0.01777649f, -0.00148130f, 0.01301362f, -0.03153594f, -0.01791728f, 0.01068752f, 0.05318675f, 
    0.04799302f, -0.02441739f, 0.03177420f, -0.02380147f, -0.02588563f, -0.00670682f, -0.05715327f, 0.00702748f, 
    0.00238512f, -0.05918008f, 0.03661931f, -0.01858299f, 0.00302041f, -0.00593558f, 0.03999725f, -0.03220936f, 
    -0.05015817f, -0.03606719f, -0.00808442f, 0.02931274f, 0.05109690f, -0.03944430f, 0.04682127f, 0.02039962f, 
    -0.03204473f, 0.00430243f, 0.04774608f, 0.03542941f, -0.02987659f, -0.05319203f, 0.00543075f, 0.02719504f, 
    0.05081325f, -0.05124401f, -0.01802704f, -0.02362132f, -0.00383289f, -0.03322584f, 0.00162769f, 0.04333190f, 
    0.02068051f, 0.01430625f, -0.04582827f, 0.05524961f, -0.03373855f, 0.02146076f, -0.06250478f, 0.01800461f, 
    -0.03294680f, 0.02384687f, 0.03327486f, -0.03697269f, 0.01016732f, -0.01054875f, 0.02430766f, 0.01465569f, 
    -0.03682205f, -0.06572606f, -0.00423610f, -0.03038007f, -0.02872236f, -0.05573541f, -0.03796240f, -0.05312678f, 
    0.04065453f, 0.03104136f, 0.01535837f, -0.04880751f, -0.01829330f, -0.03600674f, -0.04011454f, -0.02199386f, 
    -0.00640001f, 0.05463595f, 0.04087814f, -0.03564460f, 0.04511683f, 0.04777071f, 0.00158312f, -0.04537161f, 
    -0.20192975f, -0.02967049f, 0.28080440f, -0.04858449f, 0.11762589f, 0.13955574f, 0.08801981f, 0.17188410f, 
    -0.14853404f, -0.18512221f, -0.00137091f, 0.06465431f, 0.02501879f, 0.03683677f, 0.12873544f, -0.02628610f, 
    0.02742240f, 0.03784286f, -0.00169053f, -0.02218980f, -0.06543978f, 0.17845470f, -0.10822312f, -0.08751494f, 
    0.08517342f, 0.12729974f, 0.14617115f, -0.20493126f, -0.14622304f, 0.29999942f, -0.00569064f, 0.00186398f, 
    0.27424705f, 0.25055096f, 0.16450168f, -0.09998382f, -0.03066341f, 0.00175681f, 0.35826641f, -0.15730149f, 
    0.09750723f, -0.05160432f, -0.10307825f, 0.08137735f, 0.09304842f, -0.17103404f, 0.01207994f, 0.05548665f, 
    0.05927961f, 0.09257270f, 0.07101073f, 0.08570254f, -0.05741033f, -0.12579167f, 0.13594797f, 0.17088905f, 
    0.03549956f, -0.02276041f, 0.02515030f, -0.25567061f, 0.17155193f, 0.13123311f, 0.04211148f, -0.31597990f, 
    -0.09303511f, 0.30835807f, 0.08068790f, 0.10387757f, 0.21637316f, -0.00106098f, -0.19063413f, -0.13448022f, 
    0.10159295f, 0.16951688f, -0.08305339f, -0.02531593f, -0.16058244f, -0.26626012f, 0.08447901f, 0.34678188f, 
    0.10979640f, -0.34986454f, 0.28309751f, 0.15445188f, 0.01927846f, -0.02044432f, 0.12183236f, -0.04618752f, 
    -0.04389760f, -0.23058675f, -0.02559439f, 0.24659409f, -0.13330100f, -0.01482183f, -0.13379800f, -0.02559512f, 
    0.14612032f, 0.11987730f, 0.14485982f, -0.19370715f, -0.07174847f, -0.18637146f, 0.01524893f, -0.04691944f, 
    0.05460087f, -0.07488360f, 0.11203931f, 0.15528227f, 0.02157123f, -0.08099174f, 0.10331658f, 0.09264346f, 
    -0.06008475f, -0.12878837f, 0.06930984f, -0.07884567f, 0.11564806f, -0.00078297f, 0.06209137f, -0.22013803f, 
    -0.01575964f, 0.05848771f, -0.04077281f, 0.16662709f, 0.05763656f, 0.16935313f, -0.17819376f, -0.25198412f, 
    0.15569745f, -0.00034595f, 0.00456860f, 0.10793874f, -0.00358757f, -0.07780669f, -0.15222953f, -0.11674139f, 
    -0.23035499f, 0.18142152f, 0.11298881f, 0.04510304f, 0.08613983f, -0.02391851f, -0.07404041f, -0.05729721f, 
    -0.21299657f, -0.05003443f, -0.02508291f, 0.11419867f, 0.04479127f, -0.12430827f, 0.09791470f, 0.15337311f, 
    -0.10964455f, -0.03432366f, -0.07158925f, 0.03079046f, -0.00447895f, 0.11835895f, 0.03120806f, 0.05779117f, 
    0.19594838f, 0.16916502f, -0.08913516f, -0.01894371f, 0.06942564f, 0.15668111f, -0.34103373f, -0.09100375f, 
    0.00785836f, -0.02736985f, 0.28954476f, -0.01363714f, -0.01310369f, 0.04191219f, -0.00146760f, 0.10910257f, 
    0.08704080f, -0.05049723f, 0.11344858f, 0.12648152f, 0.00943117f, -0.09897603f, 0.23089470f, 0.07358526f, 
    0.06039731f, -0.12049504f, -0.05519856f, -0.16250221f, 0.05176344f, -0.30374977f, -0.08102194f, 0.04060528f, 
    0.15457667f, -0.18627973f, -0.00117907f, 0.03186011f, -0.23382580f, -0.02046045f, -0.23986661f, 0.10227519f, 
    0.25565928f, -0.03886423f, 0.08723722f, 0.18913074f, 0.17767076f, -0.07229168f, 0.06770855f, -0.13954595f, 
    -0.03215488f, -0.00048068f, 0.15614146f, -0.00446938f, 0.02939985f, -0.02412183f, 0.20952800f, 0.02006395f, 
    -0.18123049f, -0.30712023f, -0.26255006f, 0.07385698f, 0.15221539f, -0.03843984f, 0.08309302f, 0.05174101f, 
    0.09825695f, 0.06345725f, -0.00942940f, 0.27776760f, 0.02285502f, -0.09325780f, 0.10231806f, -0.10099754f, 
    -0.02211608f, 0.05442105f, 0.04258095f, -0.11488105f, 0.28115526f, 0.08563143f, 0.11084341f, -0.07833000f, 
    -0.00028813f, 0.13277107f, -0.05842693f, -0.02006370f, 0.14451751f, 0.05196003f, 0.14466043f, 0.05601579f, 
    -0.22274788f, 0.04705562f, -0.12752774f, 0.07743241f, -0.07413698f, -0.29637092f, 0.10213046f, 0.09215251f, 
    -0.05510051f, 0.11096875f, 0.12156568f, -0.07764597f, -0.10389280f, -0.04871720f, -0.00696798f, 0.07100668f, 
    0.03546649f, -0.06093432f, 0.03597444f, -0.04251793f, 0.18402912f, 0.19392458f, -0.19226117f, -0.05133081f, 
    0.12376121f, 0.07278246f, -0.12976836f, -0.11516400f, -0.11072680f, 0.10962044f, 0.11416815f, -0.08410797f, 
    -0.16310523f, 0.18238287f, -0.06037222f, -0.01139830f, -0.15582433f, 0.14695595f, 0.11798004f, 0.21928041f, 
    -0.08843216f, 0.00391177f, -0.00879393f, 0.15145233f, 0.11908364f, -0.02473535f, -0.03818532f, -0.05338754f, 
    -0.05386482f, 0.07421058f, -0.00251769f, 0.11582483f, -0.04846086f, -0.05949336f, 0.04573629f, -0.06968572f, 
    -0.04579374f, 0.07388831f, -0.00045370f, 0.06345117f, 0.12492876f, -0.05507887f, -0.04962739f, 0.01488787f, 
    -0.00332791f, 0.08835606f, 0.04086124f, 0.06587482f, -0.01001831f, -0.02615764f, 0.18717852f, -0.03996045f, 
    0.03104160f, -0.04820586f, -0.06667890f, 0.02766821f, 0.09961670f, -0.00164768f, 0.04992610f, -0.03614829f, 
    0.13114126f, 0.13025686f, 0.04101712f, 0.01494158f, 0.07505053f, -0.02468755f, -0.05936670f, 0.01380184f, 
    -0.00517988f, 0.09521412f, 0.02199449f, -0.15251583f, -0.18100327f, -0.02993241f, 0.25190046f, 0.03579978f, 
    -0.12475012f, 0.05319304f, 0.04018904f, -0.10309806f, 0.01615217f, 0.03064305f, 0.04999492f, 0.02511686f, 
    -0.23977540f, -0.19571170f, 0.14145389f, 0.03836938f, -0.05088672f, 0.06016341f, 0.00486545f, -0.11728920f, 
    0.05562205f, -0.02117539f, 0.03910087f, 0.03062725f, -0.01326280f, -0.09974897f, 0.05463278f, -0.01780474f, 
    -0.10651048f, 0.05399601f, 0.09869212f, 0.01464997f, 0.01634420f, 0.15077092f, -0.06187738f, -0.04768602f, 
    -0.15571171f, 0.04380878f, 0.10370097f, -0.08407628f, 0.09208550f, 0.11532433f, 0.20563692f, -0.10688060f, 
    -0.07883236f, -0.29475304f, -0.01992456f, 0.05180468f, -0.04762134f, 0.17597647f, -0.22566603f, -0.19483455f, 
    0.00800083f, -0.18211713f, 0.07461108f, -0.06059648f, -0.03138402f, -0.08988584f, 0.23336318f, -0.03009131f, 
    0.02499149f, 0.08411530f, 0.19501401f, -0.22672901f, 0.02571599f, 0.07588919f, -0.25739214f, 0.06319300f, 
    -0.04084066f, 0.07842600f, 0.03017770f, -0.15511271f, -0.06424978f, -0.09184986f, -0.09438245f, -0.06616573f, 
    -0.07142165f, 0.06575784f, 0.03864310f, 0.03991526f, 0.01555498f, -0.01674792f, 0.20698591f, -0.00356119f, 
    -0.19442557f, 0.02702459f, -0.07212397f, 0.18267441f, 0.09974310f, 0.00439592f, 0.07668701f, 0.02208219f, 
    -0.06367452f, -0.06977966f, -0.09943904f, 0.01156383f, -0.07013195f, 0.05454042f, -0.08327564f, -0.02836564f, 
    0.08930139f, 0.08287337f, 0.05371629f, -0.03672624f, 0.01126750f, -0.30111369f, -0.01496586f, 0.08708433f, 
    0.07402766f, -0.05635858f, 0.27108076f, 0.24866691f, 0.18612657f, -0.34812883f, -0.12040932f, 0.05446092f, 
    -0.04120634f, 0.14855704f, 0.02367709f, -0.00482471f, 0.04255322f, -0.14161418f, 0.01649497f, -0.01011491f, 
    0.00135444f, 0.23894987f, -0.18291923f, 0.08350015f, 0.10109781f, 0.04639383f, 0.09161647f, -0.11581914f, 
    -0.04262477f, 0.01239370f, 0.01093375f, 0.11069258f, -0.05936930f, -0.17066288f, -0.04891793f, 0.04273082f, 
    -0.03114690f, -0.13866431f, -0.05260768f, -0.05048009f, -0.11209369f, 0.03659391f, -0.08755008f, 0.03519940f, 
    0.07098346f, -0.03413042f, 0.08855672f, -0.04549941f, -0.01735868f, -0.07873601f, 0.10802885f, -0.11910398f, 
    0.04924688f, 0.08592951f, 0.05854714f, -0.07769527f, -0.09748883f, -0.04449128f, 0.00667501f, -0.04549403f, 
    0.24555221f, -0.45308700f, -0.01489422f, 0.06514991f, 0.07896890f, 0.01801787f, -0.15816295f, -0.06187270f, 
    -0.03289253f, -0.00475564f, 0.06615717f, -0.08505593f, 0.01688382f, 0.17149666f, 0.14397389f, 0.05771216f, 
    0.02800657f, 0.06936446f, -0.02845285f, 0.04037546f, 0.01270683f, 0.01632480f, 0.04059508f, 0.00130009f, 
    0.10495653f, 0.05486736f, 0.03451235f, 0.10709134f, 0.02400655f, -0.07245533f, 0.06566165f, -0.14238767f, 
    -0.04832569f, -0.09471470f, -0.00186452f, 0.01696797f, -0.29821920f, 0.03056264f, -0.02330124f, 0.08782579f, 
    0.14928105f, 0.09855583f, 0.00338313f, 0.01348907f, -0.02866589f, 0.05594381f, 0.11786225f, -0.08854636f, 
    -0.07085896f, -0.21767320f, -0.07833660f, 0.06163517f, 0.14410576f, -0.02303847f, 0.08847644f, -0.10820620f, 
    -0.07545505f, -0.08529036f, 0.01470086f, 0.04355370f, -0.00312032f, -0.08615759f, 0.05126811f, 0.01308613f, 
    -0.01963791f, 0.06996239f, 0.03237317f, -0.14644867f, -0.05630755f, 0.05843684f, -0.01294464f, 0.05567791f, 
    -0.35393491f, 0.13271762f, -0.03376620f, 0.19767421f, -0.03792765f, 0.02680637f, 0.09433130f, -0.00460611f, 
    -0.11001801f, 0.12279605f, -0.04053570f, -0.12481257f, 0.01918616f, -0.04588206f, -0.01356262f, -0.07458887f, 
    0.00062633f, -0.03989013f, 0.06154864f, 0.08406156f, 0.17092761f, -0.01270210f, 0.12734120f, 0.02857597f, 
    -0.02126926f, 0.10866259f, -0.12874533f, -0.19448796f, 0.11961032f, 0.04129755f, 0.00669899f, 0.12746844f, 
    -0.09084123f, -0.10157104f, -0.15170486f, 0.07302794f, 0.03587037f, -0.04649633f, 0.02761787f, 0.15097594f, 
    0.03696265f, -0.09862231f, 0.21049491f, 0.06741052f, 0.15901542f, 0.07571770f, 0.03981567f, 0.00036658f, 
    -0.02260671f, 0.02560440f, 0.03026799f, -0.03424641f, -0.05106146f, 0.01690952f, 0.23123734f, 0.09897556f, 
    -0.15393731f, -0.01687137f, -0.05076606f, 0.09364226f, 0.14962400f, -0.05299840f, -0.06240512f, -0.06085725f, 
    -0.18697861f, -0.31040466f, 0.15946501f, -0.05213253f, 0.20097592f, -0.01705962f, -0.03236056f, 0.10823164f, 
    0.02095538f, 0.08973887f, -0.36979648f, -0.11280356f, -0.08575439f, -0.08638164f, 0.06279832f, 0.15258789f, 
    0.10610016f, 0.14875011f, 0.06682374f, -0.05335701f, 0.00919251f, -0.08649772f, 0.08104986f, 0.17202617f, 
    -0.08499607f, 0.01235280f, 0.14473172f, 0.04094332f, -0.01479226f, -0.00483078f, -0.08083375f, -0.02438351f, 
    0.04397218f, 0.07199975f, 0.03100600f, 0.11593391f, -0.27551940f, 0.03230627f, -0.08993441f, -0.07717845f, 
    -0.02766723f, 0.00208653f, -0.02316457f, -0.10591477f, -0.14564921f, -0.16009699f, -0.10497529f, 0.23187371f, 
    0.06727017f, -0.00277808f, -0.00065924f, 0.00554461f, -0.00992753f, 0.15450956f, -0.13062406f, 0.12654985f, 
    -0.16180380f, -0.12490262f, 0.14154251f, 0.04352066f, 0.05445137f, -0.05771983f, -0.55766237f, -0.07717446f, 
    0.06365076f, 0.02159984f, 0.00652194f, -0.06562664f, 0.19021861f, -0.05396150f, 0.07964770f, -0.17162156f, 
    -0.21846080f, 0.07736881f, 0.02532194f, -0.03617958f, -0.06893516f, 0.06704731f, -0.04484438f, -0.02723123f, 
    -0.04923780f, 0.01694999f, 0.23097324f, -0.05464723f, 0.06956038f, -0.03165487f, 0.08004046f, 0.11635389f, 
    -0.07964503f, 0.00646497f, 0.04187664f, 0.02022688f, 0.02240305f, -0.02553771f, 0.04691004f, 0.04805794f, 
    0.06340547f, 0.04226698f, 0.27306661f, -0.10261702f, -0.02593749f, -0.02150183f, 0.08934262f, 0.08128811f, 
    0.08764239f, 0.00934066f, -0.00248313f, -0.16318077f, 0.13621998f, -0.10906103f, -0.04902725f, -0.16324660f, 
    0.05127871f, 0.18363720f, 0.05988086f, 0.16479458f, -0.09023260f, -0.05318311f, 0.06932785f, 0.03377079f, 
    -0.03730278f, 0.02621843f, -0.04007879f, 0.01876845f, -0.02242893f, -0.04325049f, 0.09133226f, -0.14587829f, 
    -0.04327105f, -0.06412198f, 0.00361656f, 0.05858440f, -0.15525234f, -0.05596058f, -0.11782914f, 0.15174115f, 
    -0.13807042f, -0.01155516f, 0.04484104f, -0.10998011f, -0.13785623f, 0.18625452f, -0.08690026f, -0.18987532f, 
    0.09210684f, -0.16814505f, -0.05696221f, -0.18944268f, 0.02582186f, 0.14188942f, -0.05268309f, 0.15999284f, 
    0.06255758f, -0.19545950f, -0.26569608f, -0.14629816f, 0.05879306f, -0.07446581f, -0.00352025f, -0.09553702f, 
    -0.10318349f, -0.22479612f, -0.01549806f, -0.01797164f, 0.13588215f, -0.07372570f, 0.03563150f, -0.15626663f, 
    -0.04219556f, -0.12544765f, -0.31859818f, 0.02072494f, -0.26154259f, 0.07417731f, -0.12951167f, -0.00693065f, 
    0.03425466f, 0.02016654f, 0.11058000f, 0.15133303f, -0.04224003f, 0.05589193f, -0.15770636f, -0.08263243f, 
    -0.04710320f, 0.05013301f, 0.11986670f, 0.03879927f, -0.43731263f, -0.07638247f, 0.21326256f, -0.06298851f, 
    0.22616793f, -0.04229183f, 0.15479381f, -0.05379488f, -0.10912379f, 0.06009888f, 0.21394703f, -0.18229266f, 
    0.06955775f, -0.03012269f, -0.04917729f, 0.18425019f, -0.01464406f, 0.06642026f, 0.14060017f, 0.16005252f, 
    -0.02229394f, 0.02341134f, 0.09461903f, 0.03244119f, -0.15649977f, 0.03879697f, -0.04800364f, -0.08441560f, 
    0.02482629f, -0.04011490f, 0.03475616f, -0.06637543f, 0.03261495f, 0.03927775f, -0.00232148f, 0.01379398f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02167885f, 0.01416768f, 0.06472725f, -0.00629758f, 0.00344719f, 0.00442229f, 0.08983766f, -0.00810927f, 
    0.02079715f, 0.02948760f, 0.02575067f, 0.05025660f, 0.00008729f, -0.11235084f, 0.05042701f, 0.01332767f, 
    0.12581956f, -0.07028273f, 0.18914308f, -0.03730479f, 0.05999165f, 0.00945430f, 0.03657139f, 0.23364885f, 
    -0.01138452f, 0.00292556f, 0.04911049f, 0.05289211f, -0.03978622f, 0.16908322f, 0.10893261f, 0.06489211f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19878881f, -0.01114742f, -0.04623594f, -0.13020627f, 0.06956359f, 0.11013143f, -0.16788644f, -0.19545332f, 
    -0.16860224f, -0.04467728f, 0.02712012f, -0.02183709f, -0.06085981f, -0.23622191f, -0.09045023f, -0.16975863f, 
    0.13433337f, -0.08607426f, 0.03834984f, -0.11589277f, 0.01407598f, 0.04882358f, -0.07243658f, 0.05294932f, 
    -0.14188586f, -0.14922644f, -0.05114936f, -0.12361557f, -0.12804943f, -0.06564635f, -0.07740767f, -0.01976254f, 
    -0.11892412f, -0.43481076f, 0.29285428f, -0.06653770f, -0.44428545f, 0.29908359f, -0.04956971f, 0.11204269f, 
    0.06358761f, -0.11255435f, 0.01967740f, -0.31092250f, -0.68080086f, -0.16717292f, 0.16412774f, -0.09807308f, 
    -0.05071685f, 0.11139257f, 0.11331440f, 0.00914175f, 0.22555363f, -0.07995512f, 0.38272700f, 0.08328675f, 
    -0.05605629f, 0.04838675f, -0.21413186f, 0.15932098f, 0.16208780f, 0.19162475f, -0.25821957f, -0.50616640f, 
    0.05747935f, 0.01256848f, 0.14582928f, -0.12784497f, -0.02747127f, -0.15429194f, -0.07920563f, 0.15636377f, 
    0.10993385f, 0.14704862f, -0.02650490f, 0.09227243f, -0.12037136f, 0.16184968f, -0.05009983f, 0.07455289f, 
    -0.16449234f, 0.09083305f, -0.07636911f, 0.06721969f, -0.10445057f, -0.10177558f, -0.00564314f, -0.15682511f, 
    -0.10578492f, 0.08546879f, -0.08731319f, -0.08637454f, 0.07052816f, -0.03973426f, -0.05890836f, -0.03611306f, 
    -0.18098430f, 0.11953391f, -0.05292184f, -0.10541597f, -0.09334843f, -0.04140493f, 0.05088643f, 0.14145117f, 
    -0.05714867f, 0.08325331f, 0.05631796f, -0.18852787f, -0.06849182f, 0.00259416f, 0.10077954f, -0.10021935f, 
    0.06998285f, -0.09161075f, 0.14276104f, -0.18078487f, -0.13145190f, -0.16517211f, -0.15061824f, -0.07250328f, 
    0.10554953f, 0.09870464f, -0.03691250f, -0.07859085f, -0.08739023f, 0.00637247f, 0.04371657f, 0.11969995f, 
    -0.26601198f, -0.12502360f, -0.09084447f, 0.03841992f, 0.13297318f, -0.14397548f, 0.36383104f, -0.20938298f, 
    0.19999620f, 0.01040753f, 0.24755269f, 0.39240584f, 0.37779650f, 0.02600523f, 0.15981494f, -0.19073260f, 
    -0.20566508f, 0.11168280f, 0.15868130f, -0.01426484f, 0.47813404f, -0.25922310f, -0.09978718f, 0.05089509f, 
    -0.06317002f, -0.14220968f, -0.02846698f, -0.24165247f, 0.03243131f, 0.07723545f, 0.31108141f, 0.51764172f, 
    0.41541952f, 0.30825800f, -0.12736787f, -0.00691982f, 0.64619255f, -0.05789255f, -0.46239021f, 0.07552305f, 
    -0.09556377f, 0.36648917f, -0.06366014f, -0.23768032f, 0.01892974f, 0.55239981f, -0.00835397f, 0.20226815f, 
    0.00854181f, 0.06350514f, 0.21456227f, -0.14645068f, -0.21224645f, 0.30325341f, -0.14093345f, -0.06282098f, 
    0.05793429f, -0.13530445f, 0.14837168f, -0.17011572f, -0.08809708f, 0.23879093f, 0.15472797f, 0.11071151f, 
    -0.15839154f, -0.04734500f, 0.24850065f, 0.07992402f, -0.32664961f, 0.00483793f, 0.06920268f, -0.18720265f, 
    0.02141395f, 0.29428285f, 0.13194345f, 0.10093395f, 0.25344759f, 0.19593228f, 0.08691297f, 0.33560973f, 
    -0.00476415f, 0.11981361f, 0.08272306f, -0.03947235f, 0.44729307f, -0.35042924f, -0.36042362f, -0.05295531f, 
    0.12599200f, 0.01344741f, 0.34597880f, 0.36804038f, 0.16891743f, 0.06381078f, 0.04490758f, 0.52593333f, 
    0.12254859f, 0.63680601f, 0.00788806f, -0.24932776f, 0.05164852f, -0.24087049f, -0.05946420f, 0.22129096f, 
    0.28511772f, 0.70004880f, 0.28839746f, -0.04638025f, 0.18358220f, -0.22363250f, -0.13556106f, 0.13235728f, 
    0.17681563f, -0.05886109f, 0.02451738f, -0.05408477f, -0.14601885f, -0.19098148f, -0.39097562f, 0.03208080f, 
    0.01515127f, -0.01961536f, 0.53304982f, -0.09558039f, 0.15924181f, 0.14582188f, 0.12498049f, 0.44127512f, 
    0.25964803f, -0.45087942f, 0.12873924f, 0.39107412f, 0.26714572f, -0.26766548f, -0.13428046f, 0.13050425f, 
    -0.19859584f, -0.22565946f, 0.18408237f, -0.28210199f, 0.07604603f, 0.41851065f, 0.17547230f, 0.46397290f, 
    0.12607683f, -0.13503534f, -0.25111595f, 0.04585184f, 0.09982559f, -0.21191335f, -0.31369692f, 0.15503952f, 
    0.09121505f, -0.08696295f, 0.08682770f, 0.25090268f, 0.13353565f, 0.12832199f, 0.00921009f, 0.06906670f, 
    -0.04812341f, -0.34315762f, 0.09276620f, -0.02083435f, -0.04127373f, 0.25464639f, -0.07424692f, -0.49844360f, 
    0.11064038f, -0.39135665f, 0.00785455f, 0.00357015f, 0.74740654f, 0.27469435f, 0.04117258f, 0.01603026f, 
    -0.46054825f, 0.10876159f, -0.09429827f, -0.05958535f, 0.36800793f, 0.25395653f, 0.29179582f, 0.10106397f, 
    -0.12772903f, -0.11483103f, -0.46910393f, 0.10737561f, 0.07681056f, 0.07195635f, 0.05530453f, 0.45989582f, 
    0.35642302f, 0.32862684f, 0.25347894f, 0.22936729f, 0.22854409f, -0.14405382f, -0.48551837f, 0.31186435f, 
    -0.10150391f, 0.17022440f, 0.18072619f, -0.67804682f, -0.41608319f, 0.33009946f, -0.15306896f, 0.33156970f, 
    -0.17857745f, 0.05647897f, -0.04348054f, 0.04450498f, -0.16426885f, -0.25006694f, 0.02926609f, 0.02769217f, 
    -0.09357480f, 0.12165120f, 0.44442490f, 0.12098496f, 0.10964930f, 0.26699495f, -0.30730230f, 0.00369060f, 
    0.28742182f, 0.33980763f, 0.09144832f, 0.02862792f, 0.21781187f, -0.09030832f, -0.22231418f, -0.04404162f, 
    -0.29535168f, 0.61341298f, 0.43294513f, 0.22338758f, 0.25499806f, -0.02364082f, -0.15592243f, 0.14601448f, 
    0.17236467f, 0.09077023f, 0.05862115f, -0.17092960f, -0.09699618f, 0.05824733f, 0.03723911f, -0.05596754f, 
    -0.12362193f, 0.12909126f, 0.07632735f, -0.13696495f, -0.14902595f, 0.07292921f, 0.09138350f, -0.10859659f, 
    -0.06414907f, -0.10500641f, 0.06464125f, -0.11341522f, 0.15801245f, 0.11176937f, -0.15951368f, 0.02502444f, 
    -0.11870412f, -0.13908358f, 0.13972583f, 0.05717186f, -0.07413491f, -0.13425772f, 0.15319082f, 0.12027805f, 
    0.10878505f, -0.14682385f, -0.07602946f, 0.14070038f, -0.19245538f, 0.14382793f, -0.05830411f, -0.15412188f, 
    -0.09762873f, -0.00577185f, -0.04831873f, -0.02770851f, -0.17690659f, -0.04817213f, 0.15310673f, -0.12713125f, 
    0.08802085f, -0.47671705f, 0.19446686f, -0.03946484f, 0.32268399f, 0.10721695f, -0.06306075f, -0.18114182f, 
    -0.20122269f, 0.28928831f, 0.10541465f, -0.31833944f, -0.37695840f, 0.28356263f, 0.20634042f, -0.12617174f, 
    0.01436522f, -0.02609786f, -0.20912832f, -0.06774075f, 0.69203740f, -0.32367125f, -0.05305018f, 0.01497608f, 
    -0.17455384f, -0.00288506f, -0.05503528f, -0.15435164f, -0.05209776f, -0.15497033f, 0.32746786f, -0.05959887f, 
    0.32051495f, 0.31241494f, 0.22600046f, -0.02070456f, -0.05912485f, 0.38042977f, -0.29642075f, -0.08388671f, 
    0.15564671f, -0.36960700f, -0.18473819f, -0.49407926f, -0.32206070f, 0.31505221f, 0.03039113f, 0.07234833f, 
    -0.28345776f, -0.16696192f, 0.17114031f, 0.04022155f, 0.20759439f, -0.04190046f, 0.00191333f, -0.05218148f, 
    -0.02201523f, 0.07087068f, 0.01306195f, 0.24988723f, 0.09505847f, 0.14117798f, -0.19055675f, 0.37064770f, 
    -0.00196432f, -0.21980974f, -0.18220082f, -0.51927024f, -0.47982937f, 0.03529720f, 0.08602446f, -0.10280474f, 
    -0.21014754f, 0.49894366f, -0.07599973f, -0.01956697f, -0.32712141f, -0.21211284f, -0.10606246f, -0.38709286f, 
    -0.40863872f, 0.04985960f, 0.49307084f, -0.11668232f, 0.39786565f, 0.00933032f, 0.06730103f, 0.10429735f, 
    -0.11323676f, 0.11634604f, -0.06521586f, -0.13350512f, -0.16114436f, 0.23434804f, 0.03176863f, 0.38799432f, 
    -0.14840923f, -0.13086674f, -0.07300679f, 0.09250458f, 0.11146204f, 0.07694917f, -0.11030158f, -0.11667547f, 
    -0.15734114f, 0.14786494f, 0.13745314f, -0.07628640f, 0.01592888f, -0.10729069f, -0.10041019f, 0.04978621f, 
    -0.12138419f, -0.03015727f, 0.08394457f, -0.11101718f, -0.15166318f, -0.18449965f, 0.14999305f, -0.07855590f, 
    0.09247504f, -0.14149776f, -0.07917961f, 0.08488474f, -0.05795023f, -0.15507291f, -0.14221761f, 0.12723483f, 
    -0.02062286f, 0.04814182f, 0.02419504f, -0.16054101f, 0.16727918f, 0.10824907f, 0.12010342f, -0.09140731f, 
    0.07892209f, 0.51296306f, -0.12163762f, -0.14036928f, 0.29832140f, 0.11593701f, -0.00169611f, -0.37711129f, 
    0.00234727f, -0.02869692f, 0.11912034f, 0.17350693f, 0.28695449f, -0.34481373f, -0.28612867f, 0.20299885f, 
    0.13273953f, -0.06725139f, 0.18977687f, -0.38617817f, -0.15742838f, -0.19401319f, 0.35830176f, 0.49970257f, 
    -0.14546685f, 0.22220646f, -0.07162967f, -0.02526334f, -0.17332867f, 0.15577208f, 0.01074820f, -0.19924536f, 
    -0.16357590f, -0.11380608f, -0.00576395f, 0.06385282f, -0.04957909f, 0.12317044f, 0.16940832f, 0.04699656f, 
    0.11941801f, -0.08577864f, -0.07435211f, 0.09311187f, -0.13258173f, 0.00395468f, -0.05116440f, -0.18728882f, 
    -0.04182341f, 0.13696033f, -0.15301336f, -0.04301510f, 0.14425983f, 0.13775079f, 0.03325510f, -0.15007769f, 
    0.11690870f, -0.06397247f, -0.26315093f, 0.20359898f, -0.34205824f, -0.03963213f, 0.39476022f, -0.24472566f, 
    -0.14467186f, -0.21536058f, 0.22728279f, 0.39487717f, -0.37465364f, -0.32657191f, -0.12118889f, -0.23055656f, 
    0.52919888f, -0.16926304f, 0.37972209f, -0.12355144f, 0.05216196f, 0.38416106f, 0.38080758f, 0.23777069f, 
    0.04488528f, -0.15509509f, -0.27529275f, -0.15335241f, -0.12439854f, 0.26434129f, -0.04471327f, -0.44085485f, 
    0.10295763f, -0.23731861f, 0.33896786f, 0.04771500f, -0.01028616f, -0.09923282f, 0.12505361f, 0.52800745f, 
    0.33914775f, -0.20148809f, 0.11209945f, -0.22682573f, -0.13903098f, -0.00496378f, -0.02644357f, 0.17190337f, 
    -0.04179185f, -0.01757873f, -0.34225065f, 0.11859821f, -0.12977624f, -0.15871388f, -0.31743672f, 0.07362520f, 
    0.16483660f, -0.08700568f, 0.36657768f, 0.26807883f, -0.12488969f, -0.11674453f, -0.38195986f, -0.17172813f, 
    0.01189998f, -0.32211411f, -0.20198734f, 0.31804323f, 0.06732905f, -0.29231906f, 0.08276498f, -0.13192248f, 
    -0.18098488f, 0.38643935f, 0.42899758f, 0.35401225f, 0.07743672f, -0.03063658f, 0.09073172f, 0.47127697f, 
    0.64264959f, -0.10398960f, 0.13764681f, 0.11034021f, -0.12952533f, 0.35281828f, -0.17803022f, -0.04928541f, 
    0.00595134f, -0.07133780f, 0.11369590f, 0.15985987f, -0.15186197f, 0.31306073f, -0.28958032f, -0.52352506f, 
    0.18364795f, 0.49562284f, -0.10068094f, -0.19877246f, 0.68604147f, -0.02683308f, -0.09121925f, 0.22786331f, 
    -0.00781449f, -0.17616026f, -0.21979487f, -0.01100298f, -0.03626623f, 0.40605980f, -0.19714935f, 0.13381594f, 
    -0.18773454f, -0.11092447f, 0.15396218f, 0.00199433f, -0.26127937f, 0.15483239f, 0.08431970f, 0.08224514f, 
    0.12772839f, -0.08299100f, -0.19523524f, -0.15491541f, -0.06363664f, 0.13783608f, 0.16438286f, 0.40190646f, 
    -0.15145354f, 0.01745809f, 0.00966221f, 0.08391033f, -0.07688506f, -0.12193924f, -0.08776398f, -0.08823225f, 
    -0.00352115f, -0.04406773f, -0.17260367f, 0.08236364f, 0.08347648f, -0.11101174f, -0.05607468f, 0.03008329f, 
    0.12008770f, -0.01928327f, -0.00099603f, -0.10658982f, 0.01418158f, -0.07348566f, 0.00893291f, 0.00609896f, 
    0.16152181f, 0.04049658f, -0.04929225f, 0.04535856f, -0.10573491f, -0.00173873f, -0.07801723f, -0.11083359f, 
    -0.18440524f, -0.16445293f, 0.09853212f, 0.08527268f, 0.00444155f, 0.02893180f, -0.12471042f, -0.13355869f, 
    0.06276204f, 0.02818186f, 0.03620283f, -0.13314402f, 0.05817993f, -0.18970968f, -0.14642724f, -0.01827255f, 
    0.10436802f, -0.00610774f, -0.01781517f, 0.10207383f, -0.20932601f, -0.14859819f, -0.00521364f, -0.14796405f, 
    0.12604000f, -0.01378415f, -0.16115308f, -0.10337314f, -0.14986306f, -0.07527991f, 0.03158138f, -0.00302759f, 
    0.13850190f, -0.10061213f, -0.03229902f, 0.00313829f, -0.13905972f, -0.06117263f, -0.05075109f, -0.06109855f, 
    -0.05418407f, 0.02697645f, -0.07975093f, 0.10690933f, -0.12372512f, -0.06998609f, -0.18590847f, -0.06936967f, 
    -0.14660527f, 0.00639977f, -0.14824992f, 0.03148787f, -0.13088600f, -0.10041376f, -0.08955988f, -0.00569240f, 
    -0.14237843f, 0.11193754f, -0.12545614f, -0.14078765f, -0.08046409f, 0.13638043f, 0.09614290f, -0.10487121f, 
    -0.15301272f, -0.49932754f, 0.04524861f, 0.32701701f, -0.37832791f, -0.02025344f, 0.11204405f, -0.07205207f, 
    -0.12649016f, -0.29858798f, -0.13164374f, -0.09675732f, 0.06713296f, 0.09419093f, 0.20344490f, -0.01620827f, 
    -0.14346795f, 0.12960972f, -0.22428469f, 0.05452453f, 0.44775710f, 0.09943688f, 0.23476736f, 0.22340180f, 
    -0.05413761f, -0.13055576f, -0.28972763f, 0.28458506f, -0.00415453f, 0.02333556f, -0.07841396f, -0.21288790f, 
    0.05787042f, 0.43240047f, -0.01724178f, -0.29422379f, 0.20851186f, 0.47001275f, 0.17891315f, -0.09046334f, 
    0.00675170f, -0.00276621f, 0.01715846f, 0.08551819f, -0.34135976f, -0.07670107f, -0.18592919f, -0.41297013f, 
    -0.11812539f, -0.09858604f, 0.48238480f, 0.12445096f, 0.18303239f, 0.55279875f, 0.37910134f, 0.17817849f, 
    -0.09870049f, -0.10541166f, -0.11594921f, -0.30510038f, 0.05136327f, 0.14531432f, 0.62308717f, 0.02345251f, 
    -0.28936723f, -0.21287312f, -0.07225736f, -0.04733882f, 0.33261496f, 0.14687742f, -0.14226755f, 0.06083227f, 
    0.19135182f, -0.04887694f, 0.08574188f, -0.15415004f, 0.52947158f, 0.31439131f, 0.43599924f, -0.20938875f, 
    -0.36470020f, -0.06016283f, -0.32464415f, -0.11867042f, 0.16448408f, -0.43490013f, 0.19412461f, 0.16952315f, 
    -0.02755754f, -0.15025754f, -0.18283051f, -0.35345232f, -0.02192065f, 0.16205613f, -0.06309764f, 0.15138716f, 
    0.18821517f, 0.78403306f, 0.12733106f, -0.21548344f, -0.01069685f, 0.36952773f, 0.21278420f, 0.44600242f, 
    0.45204949f, 0.19600524f, 0.18359081f, -0.01164631f, 0.34787828f, -0.19719958f, 0.28343299f, -0.11920009f, 
    0.02658970f, 0.05726361f, -0.10724506f, 0.12734874f, -0.33026570f, -0.03178946f, 0.16268072f, 0.32701364f, 
    -0.02238046f, 0.14342014f, 0.23829004f, -0.10084815f, 0.11821742f, 0.14537376f, 0.13117611f, 0.06514729f, 
    -0.36315802f, -0.23811710f, 0.07847278f, -0.15797713f, -0.32922897f, -0.20901801f, 0.54192758f, 0.25087553f, 
    0.14547648f, 0.12043837f, 0.18690589f, 0.11224782f, 0.04778245f, -0.47822988f, 0.25896251f, -0.39109725f, 
    0.21530679f, 0.03923276f, 0.01794532f, 0.10829198f, -0.14963157f, -0.32574344f, 0.27308658f, 0.32110262f, 
    0.04227796f, -0.12291957f, 0.24912567f, -0.00485418f, -0.09078570f, 0.02900780f, 0.07753717f, -0.36764884f, 
    -0.01382377f, -0.34365281f, 0.28009686f, 0.25649029f, -0.32183987f, 0.25643483f, -0.10207967f, 0.03745561f, 
    0.28639132f, -0.35848901f, -0.18764909f, -0.28695172f, -0.31395921f, 0.07515863f, 0.22490406f, 0.15970662f, 
    -0.00433655f, -0.03219561f, -0.08074129f, 0.05109210f, -0.08484288f, -0.25681505f, -0.17828825f, 0.16464236f, 
    0.05965123f, -0.17573701f, 0.09583981f, 0.30459571f, -0.04884829f, -0.12958832f, -0.30759686f, -0.04570905f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18241493f, 0.31577832f, -0.13132963f, -0.13231479f, -0.01912314f, 0.13301980f, -0.13857947f, 0.08941394f, 
    -0.10475753f, -0.13269277f, 0.24235731f, -0.09573714f, -0.13236803f, -0.04044091f, 0.01660690f, 0.01226909f, 
    -0.05051629f, 0.11830907f, -0.17756070f, 0.27970138f, 0.14576040f, 0.16223508f, -0.21102749f, -0.02017711f, 
    -0.10868994f, -0.06074119f, 0.25591683f, 0.23126583f, 0.21420652f, 0.36630946f, 0.29204974f, 0.02245595f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16442581f, 0.09242951f, 0.07548726f, 0.11513744f, 0.18909661f, 0.02595421f, 0.17114538f, 0.22609659f, 
    -0.12712319f, -0.07641111f, 0.23842296f, 0.16228189f, 0.47943297f, 0.48924422f, 0.17947713f, -0.00924173f, 
    -0.16837914f, 0.26633248f, 0.02747913f, 0.06157741f, -0.09272552f, 0.07515074f, -0.23001313f, -0.12577547f, 
    -0.09780553f, 0.03901822f, -0.14519773f, -0.14245658f, -0.02551867f, -0.16074574f, 0.00311284f, -0.06287884f, 
    -0.04070689f, 0.03940783f, -0.02145651f, 0.10245632f, -0.33468068f, 0.43399364f, -0.04304939f, 0.56689423f, 
    0.19487217f, -0.29189509f, 0.42744395f, -0.04343635f, -0.08291500f, -0.54511702f, 0.52758044f, -0.01595896f, 
    0.16346608f, -0.30245668f, 0.11262020f, -0.01935204f, 0.23548417f, 0.03215563f, 0.27046522f, -0.11849417f, 
    0.05500699f, -0.13829684f, -0.39313933f, 0.07552356f, -0.05096452f, 0.23018715f, -0.26528087f, 0.22102344f, 
    -0.07487687f, 0.05610206f, 0.11330150f, -0.13717584f, 0.16408990f, 0.05571716f, 0.30648324f, -0.16388080f, 
    0.24851927f, 0.10589848f, 0.19969104f, -0.45868966f, -0.05551741f, 0.16093421f, 0.42777473f, 0.02692812f, 
    0.05085102f, 0.45461103f, 0.01794674f, -0.37272716f, 0.30196133f, -0.55158758f, 0.33435392f, -0.08834001f, 
    0.10768101f, -0.08256517f, 0.09038419f, 0.02451790f, 0.18402906f, 0.06922928f, -0.14198789f, 0.49740839f, 
    0.05368666f, -0.15758860f, -0.01394519f, -0.07256031f, -0.01649511f, 0.05553421f, -0.19285834f, 0.07518496f, 
    -0.14518428f, 0.11613990f, -0.16616412f, 0.07400759f, 0.01067837f, 0.10354181f, -0.14480256f, -0.05181803f, 
    -0.00177352f, 0.05958700f, -0.14570661f, -0.13421017f, -0.00633348f, -0.08803153f, 0.05742952f, -0.01958798f, 
    -0.04467262f, 0.03481909f, 0.10097401f, -0.14956473f, -0.11118112f, -0.09599340f, -0.10235646f, 0.16394360f, 
    0.13288392f, 0.46593013f, 0.09238867f, -0.13761401f, -0.24101835f, 0.06168935f, -0.42252657f, -0.01758554f, 
    -0.10274141f, -0.05843306f, -0.07918438f, 0.00629476f, 0.00488400f, -0.28493580f, 0.29479083f, 0.27975193f, 
    0.00780493f, -0.08276337f, 0.09877545f, 0.00340155f, -0.23114763f, -0.35352418f, 0.38023159f, 0.03693124f, 
    0.09934272f, -0.18574831f, -0.05635677f, 0.40658209f, 0.10373581f, 0.27757403f, 0.14376315f, -0.00575142f, 
    0.00159957f, 0.08692268f, 0.14117698f, 0.03722864f, -0.35207170f, 0.60894418f, -0.24846989f, -0.30782327f, 
    0.21570377f, 0.02070889f, 0.46770635f, 0.11015948f, 0.08597553f, 0.44372553f, 0.20508674f, 0.00096964f, 
    0.16453627f, 0.03259331f, 0.02940957f, -0.21165971f, -0.02419712f, 0.06060433f, 0.11549094f, 0.04312529f, 
    0.01430931f, -0.03150313f, 0.19912410f, -0.06829570f, 0.13738473f, 0.05810752f, -0.30380780f, 0.01496572f, 
    -0.08299140f, -0.18132165f, 0.16086897f, 0.10084982f, 0.11351089f, -0.00961728f, 0.02238501f, 0.02910252f, 
    0.14884253f, -0.13821289f, -0.09759665f, 0.06820259f, 0.14986531f, -0.02104498f, -0.00121745f, 0.17417476f, 
    -0.01688574f, -0.07240276f, -0.00018943f, 0.01996557f, 0.09124734f, -0.14241908f, 0.05056765f, 0.12118449f, 
    0.08238754f, -0.15504317f, -0.04198132f, 0.04094925f, -0.03347374f, -0.11263583f, -0.09717280f, -0.04545425f, 
    -0.02074611f, -0.14314547f, -0.05123233f, -0.02682734f, 0.07501204f, 0.30712816f, 0.06375643f, -0.34854156f, 
    0.33660066f, 0.25409698f, -0.03652553f, 0.04826151f, -0.09968361f, 0.39497733f, 0.04685700f, -0.16249923f, 
    -0.03385995f, -0.15911321f, -0.11519707f, -0.25740477f, -0.08799072f, 0.44274017f, -0.07903425f, 0.13353454f, 
    -0.15707262f, 0.13365324f, 0.32324001f, -0.21527919f, 0.28413376f, -0.04934793f, -0.22602972f, 0.03956347f, 
    -0.04287337f, -0.15545487f, -0.14858717f, -0.07376710f, 0.48392981f, -0.10443132f, 0.00001357f, -0.05036836f, 
    0.13430919f, 0.38339549f, -0.28873992f, -0.00338865f, 0.04380737f, -0.12999208f, -0.33667338f, -0.21588159f, 
    0.02981433f, 0.13905868f, 0.13618778f, 0.37491840f, -0.53382158f, 0.17163841f, -0.10395040f, 0.04969550f, 
    0.08883307f, -0.05026020f, 0.29744139f, 0.24134302f, 0.41450772f, 0.23089693f, 0.22289011f, -0.29148468f, 
    -0.13498250f, 0.31999272f, -0.00945268f, -0.07654216f, 0.03456434f, 0.22518870f, -0.28894076f, -0.09613141f, 
    0.08945823f, -0.03798117f, 0.19435379f, -0.11914556f, -0.15183924f, -0.35557723f, 0.11710864f, 0.47789806f, 
    0.14386413f, -0.24951461f, -0.07753970f, 0.38731971f, -0.25295955f, 0.41667327f, 0.18625109f, -0.06770032f, 
    -0.03484315f, -0.09023690f, -0.00038035f, 0.21839046f, -0.13995901f, 0.16508292f, -0.13853690f, -0.03849255f, 
    -0.00971953f, -0.13703540f, 0.08457568f, 0.17727366f, -0.18164304f, 0.46577480f, -0.25228423f, 0.48292387f, 
    -0.06941093f, -0.16242197f, 0.37116781f, 0.65248591f, -0.17667538f, -0.13109331f, -0.07520574f, -0.41150796f, 
    0.03575623f, 0.10092219f, 0.09971812f, 0.11676171f, -0.07880389f, 0.13508312f, 0.26714358f, -0.04533213f, 
    -0.10751041f, 0.16348018f, -0.43114597f, 0.27203897f, 0.17182206f, 0.19397871f, 0.07397861f, -0.35257712f, 
    0.07943325f, 0.51862532f, -0.00629718f, 0.15539734f, -0.31615156f, 0.10991996f, -0.00258527f, -0.19528702f, 
    0.21846779f, -0.23619410f, 0.30122939f, -0.28052235f, -0.01371294f, 0.25277084f, 0.24166453f, -0.09991635f, 
    0.00567766f, -0.20141307f, 0.11974980f, 0.00362583f, 0.43970418f, -0.04021711f, 0.23168752f, -0.13361162f, 
    -0.19146846f, -0.10951567f, 0.06129391f, 0.19745201f, 0.06324581f, -0.06675606f, 0.08922504f, 0.47450009f, 
    0.07543245f, 0.06376265f, 0.04172169f, 0.04921114f, -0.03730289f, -0.06618024f, -0.13770166f, -0.08710825f, 
    -0.07057440f, -0.06930924f, -0.16056322f, -0.14343743f, 0.04720427f, -0.16863322f, 0.00362065f, -0.00894995f, 
    0.07337368f, -0.08266696f, -0.04459829f, 0.04662311f, 0.06190723f, 0.09531879f, -0.08396348f, -0.10810430f, 
    0.09753199f, 0.01094878f, 0.03722701f, -0.10050774f, -0.07184975f, 0.08044516f, -0.11663607f, -0.11016217f, 
    0.06107379f, 0.58904016f, -0.07060114f, -0.09778203f, 0.15000808f, -0.38402742f, -0.00349182f, -0.45535010f, 
    -0.11396815f, 0.47157285f, 0.03503982f, -0.23736039f, -0.06486665f, 0.25846249f, 0.11577593f, 0.11440908f, 
    -0.10645182f, 0.11546583f, -0.11819082f, 0.12908691f, -0.14049004f, -0.27791691f, -0.28857633f, -0.15811135f, 
    0.13452308f, -0.02958161f, 0.33977404f, 0.32329601f, 0.36507344f, 0.11314846f, 0.39614797f, 0.21146107f, 
    -0.03320783f, 0.59752244f, 0.11521035f, 0.09415683f, -0.25357443f, -0.12428316f, 0.08142520f, -0.24250871f, 
    0.07201084f, -0.02586531f, -0.06003752f, -0.14937957f, 0.08504741f, -0.11306781f, -0.02847663f, 0.33075804f, 
    -0.14517854f, -0.44497025f, -0.10927678f, 0.48659787f, 0.18848485f, 0.51227081f, -0.14849065f, 0.03740736f, 
    0.08608698f, -0.07774404f, 0.59296411f, -0.12244105f, 0.08803867f, 0.05509537f, 0.27140608f, 0.24393438f, 
    0.19109496f, -0.35055017f, -0.13931702f, 0.09898031f, -0.07782222f, 0.51834685f, -0.06407841f, 0.10240214f, 
    0.01396647f, -0.23842339f, 0.18846199f, 0.19793066f, 0.11384224f, -0.23310739f, -0.00531120f, 0.09926286f, 
    0.05563297f, 0.07460578f, 0.11608238f, 0.23541549f, 0.07383311f, 0.16069154f, 0.39919093f, 0.04449112f, 
    -0.08620980f, 0.14286973f, -0.39003414f, 0.37405464f, -0.23572081f, 0.06887301f, 0.11823664f, -0.31237748f, 
    -0.06428625f, 0.06025746f, -0.02613990f, -0.09112276f, -0.39043152f, 0.31726721f, 0.15005966f, -0.35849994f, 
    0.34441912f, 0.31621933f, 0.18094872f, 0.30273500f, -0.03428557f, 0.01625405f, 0.23994632f, -0.01584266f, 
    0.06421799f, -0.48235142f, -0.06195415f, 0.08479840f, -0.01597803f, 0.57325488f, -0.05569547f, 0.05636304f, 
    -0.21458142f, -0.06862108f, 0.06274157f, -0.19267282f, -0.00280906f, -0.12252013f, -0.38487330f, 0.21672988f, 
    -0.09616014f, 0.46332216f, -0.07340724f, -0.15016760f, -0.17511967f, -0.55728775f, -0.13227737f, -0.07167426f, 
    0.02164999f, 0.03763769f, -0.13581741f, -0.45299661f, 0.01932709f, 0.00465825f, -0.00899364f, -0.91164929f, 
    0.16397886f, 0.02319459f, 0.10132621f, 0.19823918f, 0.37850082f, -0.24091078f, -0.50973380f, -0.01569226f, 
    0.12750795f, -0.10062604f, 0.48511261f, -0.13169476f, 0.07636537f, 0.30863595f, 0.52240247f, 0.48124340f, 
    -0.02831136f, -0.11666098f, -0.12518553f, -0.08550016f, -0.13304688f, -0.13229264f, 0.19525747f, 0.47876522f, 
    0.10538423f, -0.42293084f, -0.00123223f, 0.24629824f, 0.04417266f, 0.03296012f, -0.30599001f, -0.19033873f, 
    -0.06913592f, 0.15630807f, -0.02649333f, -0.16599475f, 0.63805723f, -0.01432278f, -0.13434774f, -0.10915858f, 
    -0.03782637f, -0.01798856f, -0.16500558f, -0.16636571f, 0.16523486f, 0.28853872f, 0.34489933f, 0.18794951f, 
    -0.09203295f, 0.03261437f, -0.06318384f, 0.08441213f, 0.08122683f, -0.10652534f, 0.07450915f, -0.13624695f, 
    -0.09682129f, 0.01657732f, -0.08876289f, 0.00360063f, -0.17592162f, -0.05337888f, -0.06636660f, 0.09165575f, 
    -0.12205601f, -0.16878310f, 0.12785979f, 0.13593201f, 0.01907051f, -0.00618610f, -0.13128532f, 0.10372779f, 
    -0.04611371f, -0.02484516f, -0.16337915f, -0.09094643f, -0.10173282f, 0.06697272f, -0.14642105f, -0.02004274f, 
    -0.19299386f, -0.01123610f, 0.11089525f, 0.13588797f, 0.30258447f, 0.26647970f, 0.11720154f, 0.57840538f, 
    0.06355712f, -0.41612971f, 0.28406489f, 0.02129056f, 0.04044452f, 0.22569036f, -0.12012260f, 0.07005370f, 
    -0.00155755f, 0.26413745f, 0.04941679f, 0.05526376f, 0.17362984f, 0.17966200f, 0.01275634f, -0.18844865f, 
    -0.05871550f, -0.07558039f, -0.24198881f, -0.30999652f, 0.30442074f, 0.02417262f, 0.31181112f, -0.23965319f, 
    -0.12387506f, 0.33899012f, 0.13088109f, 0.04978995f, 0.31915820f, 0.13547207f, 0.12030568f, -0.37825689f, 
    -0.13781005f, 0.44226810f, -0.25458753f, -0.16112450f, 0.02091969f, 0.51190567f, 0.18226637f, 1.03311908f, 
    -0.04196243f, 0.31801653f, -0.13865282f, 0.18068260f, -0.47512415f, -0.29507545f, 0.17684200f, -0.05928037f, 
    0.07100418f, -0.06365388f, 0.26571515f, 0.49494532f, 0.27983409f, -0.08055827f, -0.03144529f, -0.25867286f, 
    0.12305919f, -0.10950205f, -0.00515580f, -0.17209920f, 0.28382769f, 0.11545505f, 0.20794542f, 0.34417048f, 
    0.28367764f, -0.24216600f, -0.10227656f, 0.08154949f, 0.14809807f, 0.40562248f, -0.58026415f, 0.41455975f, 
    -0.10846955f, 0.17604876f, -0.03223808f, -0.01609400f, 0.23206444f, 0.48955086f, -0.14632463f, 0.17415309f, 
    0.03596117f, 0.09962779f, 0.00319576f, 0.04072456f, -0.03659479f, -0.09075195f, 0.17777593f, -0.18917146f, 
    0.10424348f, -0.07082609f, 0.00238802f, 0.06250034f, -0.10194645f, -0.12070438f, 0.44786507f, 0.51098311f, 
    0.04429810f, 0.21466939f, 0.16996385f, 0.18878698f, 0.04053022f, -0.36080632f, 0.13638844f, -0.63949782f, 
    0.12574202f, -0.07432948f, 0.05941883f, -0.25097722f, 0.27197495f, 0.31457001f, -0.31521615f, 0.03483986f, 
    0.17641129f, 0.10599957f, 0.16759273f, -0.29654470f, -0.05603312f, 0.22511844f, 0.15034266f, 0.39204910f, 
    -0.15684734f, 0.12191157f, 0.02918393f, 0.04065460f, 0.08247138f, -0.17689857f, 0.38881776f, 0.09257894f, 
    -0.04142051f, 0.06354775f, -0.15083277f, 0.19063798f, 0.25189146f, 0.53517556f, 0.09466064f, 0.99161935f, 
    0.06182633f, 0.28246468f, -0.16687138f, 0.10717375f, -0.21006784f, 0.20711161f, -0.26872560f, 0.19367945f, 
    -0.09843405f, 0.20429339f, 0.08198802f, 0.21905297f, -0.15183765f, -0.23469029f, 0.02291486f, 0.02062570f, 
    -0.11503410f, -0.30825570f, 0.07550371f, 0.17047887f, 0.16669719f, 0.23024836f, -0.16867673f, 0.29628348f, 
    0.02023651f, 0.17116636f, -0.07291608f, 0.01447533f, -0.09330799f, 0.12769207f, -0.02700369f, 0.28999186f, 
    -0.06508593f, 0.66265631f, 0.00153801f, -0.23591618f, 0.07242974f, -0.26231956f, 0.53976291f, 0.00615674f, 
    0.20240621f, -0.03889962f, -0.25152630f, 0.19642116f, 0.20564120f, 0.28441581f, 0.02727800f, -0.22670458f, 
    0.13129139f, 0.36124051f, -0.01023106f, 0.17777728f, -0.08025979f, -0.09684304f, 0.20793165f, 0.24095263f, 
    -0.16602172f, -0.38098976f, 0.01343061f, 0.11658356f, 0.12760617f, 0.30081677f, -0.03998269f, 0.02181658f, 
    -0.15851009f, 0.24482331f, 0.06975912f, 0.13669005f, -0.36710081f, 0.17014381f, -0.33765370f, 0.05465359f, 
    -0.04981818f, 0.16650468f, -0.32712212f, 0.21125999f, -0.25068265f, 0.13627917f, 0.01697416f, -0.30997822f, 
    0.08907819f, -0.04124435f, -0.12286234f, -0.11444738f, -0.20575853f, 0.00119990f, -0.11928947f, 0.06447794f, 
    -0.17398335f, -0.13211600f, -0.11820662f, 0.09332223f, 0.06586858f, -0.16088846f, 0.09148201f, -0.06451075f, 
    -0.08485994f, 0.07573996f, -0.07601514f, -0.18451476f, -0.08064651f, -0.16933775f, -0.08867749f, -0.15659533f, 
    0.02834048f, -0.13434093f, 0.07535801f, -0.13809361f, -0.03978089f, 0.08464126f, -0.05761200f, -0.16578659f, 
    0.11872434f, -0.02241176f, -0.17750183f, -0.15496841f, 0.11877903f, 0.34438115f, 0.38134542f, 0.23487145f, 
    -0.02325010f, 0.42180440f, 0.17621195f, -0.09731124f, -0.05787179f, 0.31808838f, 0.52829444f, -0.01481656f, 
    -0.08480915f, 0.30865526f, 0.00047011f, -0.50472981f, 0.14620487f, -0.60091710f, 0.12920998f, -0.02926084f, 
    0.02890162f, -0.16102222f, 0.07463425f, -0.04086506f, 0.11087444f, 0.13003658f, -0.30667764f, 0.24296144f, 
    -0.00878287f, -0.35854289f, 0.07236207f, -0.17569983f, 0.32569829f, 0.04050662f, 0.15487736f, 0.19294015f, 
    0.03147706f, 0.42610186f, -0.09855708f, 0.25551674f, 0.03248410f, 0.22262442f, 0.16635618f, 0.26057816f, 
    -0.12766145f, 0.31732920f, -0.05255193f, -0.22026201f, -0.22077532f, -0.34623966f, 0.29050675f, -0.12507236f, 
    -0.11180344f, -0.17573211f, -0.06396578f, 0.21288805f, 0.29660448f, 0.11986722f, -0.23241259f, -0.35437393f, 
    0.11537074f, -0.15593995f, 0.02242084f, 0.03176276f, 0.27390948f, -0.11041354f, 0.27551001f, 0.21809572f, 
    0.01186588f, 0.04578503f, 0.14422497f, 0.32677644f, 0.12689085f, -0.20154768f, -0.01266720f, 0.12699319f, 
    -0.05275638f, 0.00117702f, 0.07521289f, 0.35353741f, -0.27233931f, 0.16240714f, 0.02552058f, -0.05999245f, 
    -0.02318090f, -0.07404672f, -0.15653741f, 0.15314618f, -0.19494323f, 0.10184858f, 0.10953539f, -0.42499113f, 
    -0.11871888f, 0.55359846f, -0.07891385f, 0.05162378f, -0.07697704f, -0.21422715f, 0.22865985f, -0.13108449f, 
    0.35057038f, -0.18064202f, 0.42826945f, 0.01866384f, -0.13632637f, 0.72252524f, 0.35006553f, 0.50677574f, 
    0.12639254f, -0.17772034f, -0.14405695f, 0.06588580f, 0.26732469f, -0.09600181f, -0.29463542f, -0.10471585f, 
    -0.12627213f, 0.11579832f, 0.50774693f, -0.16537635f, -0.01399591f, -0.05235300f, -0.00470590f, 0.33570683f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12248900f, 0.20815565f, -0.01643987f, 0.02818806f, 0.31296071f, -0.07312582f, -0.18888497f, 0.08798461f, 
    0.12144813f, 0.04320528f, 0.16531260f, 0.10583372f, 0.16447991f, 0.23371328f, 0.14634398f, 0.12295580f, 
    0.09490823f, 0.12640552f, -0.01741104f, -0.07694337f, 0.01074200f, -0.05249362f, 0.10435034f, -0.09069017f, 
    -0.08652238f, -0.11949386f, 0.16114666f, -0.00691292f, -0.23897217f, -0.08411631f, 0.00426483f, 0.10966346f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14575014f, 0.54916096f, 0.29601604f, -0.01778527f, 0.20441575f, -0.00071005f, -0.01134074f, -0.52615428f, 
    -0.00220696f, -0.04466074f, 0.04838954f, 0.05535582f, -0.11634590f, 0.00144588f, -0.29848722f, 0.15971465f, 
    -0.50328761f, -0.46571228f, -0.22908714f, 0.08708071f, 0.16099462f, -0.19679593f, -0.54061544f, 0.03000058f, 
    -0.85019517f, 0.18851781f, -1.05703592f, -0.05643490f, 0.25872973f, 0.02026514f, -0.05823270f, -0.16652296f, 
    -0.15906756f, 0.22307728f, -0.35800365f, 0.05012393f, 0.19083582f, -0.11222404f, -0.14795563f, -0.03186148f, 
    -0.08272437f, 0.02544450f, 0.37081042f, -0.30690652f, -0.03359082f, -0.28304887f, -0.36884734f, 0.28694981f, 
    -0.15747766f, -0.52896523f, 0.13525154f, 0.02787398f, 0.00270507f, -0.01148594f, -0.00054059f, -0.12889947f, 
    -0.22764422f, 0.21004465f, 0.31842047f, -0.05289483f, -0.20426990f, 0.19805090f, 0.32469770f, -0.41370782f, 
    -0.07924166f, -0.38855618f, 0.14353801f, -0.03840067f, -0.11157721f, -0.89280909f, -0.14509527f, 0.11025811f, 
    0.28425267f, -0.69556153f, -0.13324054f, -0.65683955f, -0.14615412f, 0.14980663f, -0.34853810f, -0.21454422f, 
    -0.50244921f, 0.21526134f, 0.17295834f, -0.06814697f, 0.07424171f, -0.00561832f, 0.00754846f, 0.31374988f, 
    -0.23549727f, 0.35464448f, -0.36879659f, -0.01005963f, 0.29963043f, 0.37778002f, -0.16605622f, -0.68617034f, 
    -0.22495760f, 0.26525524f, 0.11048378f, -0.13557547f, -0.18263119f, -0.05591972f, 0.11217499f, -0.08447857f, 
    -0.54142767f, -0.12903427f, -0.60312575f, 0.17464015f, 0.06643417f, -0.04582002f, 0.21925119f, -0.25844669f, 
    0.31507799f, 0.28018287f, 0.11612082f, 0.00549066f, -0.45008683f, -0.73869824f, -0.23927364f, 0.34660301f, 
    0.03496104f, -0.72445261f, 0.22514147f, -0.02359664f, 0.08289722f, -0.65339059f, -0.26468435f, 0.34072942f, 
    0.10016847f, -0.06409915f, -0.05638233f, -0.10647598f, 0.21538405f, 0.37300509f, -0.10172754f, -0.00790855f, 
    -0.07303590f, -0.04169524f, 0.15089940f, 0.13334572f, 0.16044341f, 0.18935853f, 0.05281884f, -0.12447673f, 
    -0.03494245f, 0.14125991f, -0.17181940f, 0.00983095f, 0.11382701f, -0.02263052f, -0.23118025f, -0.06909411f, 
    -0.18923137f, -0.10253872f, 0.35211873f, -0.07023755f, -0.04575523f, -0.21018682f, -0.30098864f, 0.14412479f, 
    -0.29786626f, 0.05717581f, -0.48739666f, 0.03238896f, 0.26661083f, 0.18998057f, 0.03239890f, 0.12188935f, 
    0.12101064f, 0.47994125f, 0.06231612f, -0.09965012f, 0.02262610f, 0.05887774f, 0.21321911f, 0.28626904f, 
    0.40226302f, -0.45045918f, -0.42214361f, 0.02890843f, -0.14406367f, 0.32383454f, -0.03986783f, -0.52759421f, 
    0.17824437f, 0.07233715f, 0.01573235f, 0.07787396f, -0.57287121f, -0.12393896f, 0.00075810f, -0.31631887f, 
    -0.47206545f, -0.40643579f, -0.07730167f, -0.07163002f, 0.19187768f, -0.58468544f, -0.08969762f, -0.77694887f, 
    0.38097733f, 0.13366020f, -0.25991032f, 0.02009890f, -0.09613050f, 0.35984167f, 0.22500940f, -0.04327445f, 
    -0.43196821f, 0.45182192f, -0.55798864f, 0.12283964f, -0.61594474f, 0.27262804f, -0.40022486f, -0.18838015f, 
    -0.15519953f, -0.13103086f, -0.19008905f, 0.08896593f, -0.42104840f, -0.14981192f, 0.12890874f, -0.05441798f, 
    -0.31282145f, 0.21318711f, 0.36302683f, -0.01755823f, -0.42192614f, 0.29586819f, -0.04831031f, 0.24710661f, 
    -0.48250905f, -0.00012988f, -0.15601791f, 0.18834271f, -0.16094424f, -0.78763396f, -0.19969238f, 0.05916356f, 
    0.26729158f, -0.63784611f, -0.15436283f, 0.08312820f, -0.17708634f, -0.61360461f, 0.14628050f, 0.23123528f, 
    -0.04926739f, 0.01169277f, 0.24784073f, 0.13298655f, 0.19550449f, -0.00231673f, -0.32997558f, 0.10979568f, 
    0.31718421f, 0.01614122f, -0.75062734f, -0.14413653f, -0.49419418f, -0.28786692f, 0.07666956f, -0.21197176f, 
    0.17859615f, -0.17003189f, 0.21819399f, -0.35336849f, -0.06995241f, -0.35579491f, -0.18632036f, 0.32213870f, 
    -0.24876460f, -0.37087980f, 0.20225298f, 0.13944742f, 0.33196694f, -0.46288380f, 0.58405823f, 0.06596313f, 
    0.36244807f, 0.04789292f, 0.46637383f, -0.19105341f, -0.79941422f, -0.23790094f, 0.20844774f, -0.38659585f, 
    0.13165855f, -0.51217425f, 0.22960341f, 0.11062668f, -0.03568951f, 0.02409069f, -0.04220165f, 0.31838626f, 
    0.04687463f, -0.28427044f, -0.34843582f, -0.11633413f, -0.02363653f, 0.15881424f, -0.17690170f, -0.29496849f, 
    -0.21102817f, -0.26221699f, -0.29859957f, 0.12474721f, -0.03073005f, 0.32923159f, 0.07006116f, -0.45241308f, 
    0.32820958f, 0.09956466f, -0.06185510f, 0.15827875f, 0.11497515f, 0.22441739f, 0.02597744f, 0.22905822f, 
    -0.25241306f, -0.04835311f, -0.31770039f, -0.00566319f, -0.44866875f, -0.07555191f, 0.04103138f, 0.16876993f, 
    0.25612229f, 0.05347586f, -0.26205617f, -0.11537655f, -0.15689300f, -0.01922640f, 0.36176905f, -0.30836096f, 
    0.05526538f, 0.07711097f, 0.05521861f, 0.13244171f, 0.34367213f, -0.84583259f, 0.27019751f, 0.37618002f, 
    -0.06405156f, -0.63214004f, -0.01904114f, -0.04381099f, -0.59805071f, -0.46759015f, 0.19195370f, 0.19469577f, 
    -0.28851610f, 0.06059756f, 0.12993950f, 0.03018814f, 0.11832277f, -0.30072623f, 0.13642669f, -0.54600996f, 
    -0.18076009f, -0.10073925f, -0.08510973f, 0.26260290f, -0.01660417f, 0.12347054f, 0.04111819f, 0.02632054f, 
    -0.86688089f, 0.55630356f, 0.54339272f, 0.10271049f, 0.24317530f, -0.66701216f, 0.13564298f, -0.02815179f, 
    -0.70715743f, 0.09237074f, -0.18613906f, 0.09435990f, -0.37903467f, -0.62241757f, -0.32156315f, 0.08300946f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09617408f, -0.16538109f, -0.08194992f, 0.07867293f, -0.07727470f, 0.19550163f, 0.23024435f, -0.21229012f, 
    -0.20849365f, 0.05040241f, -0.00940160f, 0.17114386f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
