#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21712181f, 1.80261028f, 1.15064418f, -0.87601733f, 1.33262026f, -0.17401192f, 0.16515858f, 0.48815158f, 
    0.04144686f, 1.14760220f, -1.98759627f, -0.49687400f, 1.45726979f, 0.77576470f, -0.04981410f, -0.45762771f, 
    0.14854069f, -0.52850360f, -0.92564428f, -1.77733314f, -1.20824718f, -0.37663564f, 0.40289778f, 0.21974136f, 
    -0.50597376f, 0.43310475f, -0.00784887f, -0.97843492f, -1.50363946f, -0.83365899f, -0.86565107f, 1.01582372f, 
    1.18436313f, 0.06951979f, -0.33255401f, -0.42493165f, -1.45046246f, -0.37010637f, 1.21066415f, 1.17788398f, 
    0.78411686f, 0.48744592f, -0.18827462f, 0.15032674f, 0.41805190f, 1.32409906f, 1.30453479f, -1.11977243f, 
    -0.38590840f, 0.32653007f, 0.02906772f, 0.55806702f, -0.12781678f, 0.24130431f, -0.64494252f, 1.31640649f, 
    -0.93261194f, 0.37219977f, -0.18280149f, -1.49462748f, 0.11943455f, -0.02950126f, -0.64457077f, 1.56467164f, 
    -1.25302637f, -0.05599760f, -0.77901036f, -1.18714607f, -1.11204302f, 0.23318386f, 0.51447767f, -0.03476688f, 
    1.58625340f, 0.33163831f, -1.64023674f, -0.08572385f, -0.68653005f, 0.34143808f, -0.85323364f, 0.20319794f, 
    0.21248901f, -1.43998265f, 0.55171245f, -0.62593156f, 0.79609746f, 1.83456159f, 0.47063708f, 0.21632212f, 
    -0.07957979f, -0.07582187f, -1.09425282f, -0.30527818f, -1.47090244f, -0.19730055f, -0.10307189f, -1.34505737f, 
    0.06688396f, 0.06121648f, 0.67517877f, 0.97991878f, 0.35744694f, 0.28468773f, 1.13670337f, -0.82139874f, 
    -1.19317174f, -0.49360099f, -0.43447134f, -0.51111704f, 1.48908865f, 0.53446245f, -0.09426680f, 0.19310008f, 
    0.95401531f, -0.06501370f, 0.32478291f, -0.24805337f, -0.52291870f, 1.26729453f, 0.60543126f, 0.98709077f, 
    0.30183601f, -0.77559185f, 1.05194712f, 0.21241114f, -0.30862921f, 0.54690486f, 1.25550044f, 1.07385325f, 
    0.17035885f, 1.04334116f, 0.92709804f, 0.20651937f, -0.52027470f, -0.16683671f, -0.15185234f, 1.54257762f, 
    1.15025210f, 1.11823821f, -0.91677511f, -0.32465142f, -1.03712535f, 0.29154459f, 0.06236184f, 0.00534993f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30625802f, 0.27950904f, 0.51266456f, 0.28223467f, 0.23645467f, 0.05896532f, 0.30877614f, 0.09884221f, 
    -0.02901153f, -0.19302796f, 0.16346340f, -0.00203853f, 0.28138408f, 0.16236459f, 0.53172249f, 0.18666185f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16243570f, -0.09080888f, 0.00070276f, -0.35549030f, 0.39415574f, -0.04655072f, -0.00538493f, -0.01822750f, 
    -0.15728168f, 0.02013003f, -0.19784105f, -0.07471102f, 0.02294756f, -0.11683842f, 0.14709543f, -0.09872036f, 
    -0.05068353f, 0.02307650f, -0.09051542f, -0.17712495f, 0.10406201f, 0.02209597f, 0.12712449f, -0.01228392f, 
    -0.16223796f, 0.10137875f, -0.08592980f, -0.04854509f, -0.04957256f, -0.16376635f, -0.17160238f, 0.09553311f, 
    0.10793823f, -0.00902229f, 0.00552560f, 0.13542660f, 0.05693757f, 0.08159725f, -0.20431745f, 0.07939353f, 
    -0.34236586f, 0.01489598f, -0.20686214f, -0.07809369f, -0.48036122f, 0.06952906f, -0.00024103f, 0.13240068f, 
    0.05523928f, -0.00868498f, 0.02771934f, -0.10349569f, -0.00830872f, -0.00184445f, 0.02618835f, -0.00983395f, 
    -0.17376190f, 0.06870204f, -0.17989191f, 0.09371176f, -0.60514015f, 0.45806247f, -0.11118412f, -0.15121645f, 
    -0.47767651f, -0.05851027f, 0.12674573f, -0.07142707f, 0.06989748f, -0.09202342f, 0.12129378f, -0.02178702f, 
    -0.01763933f, 0.12466476f, -0.03861350f, 0.02853679f, -0.21034023f, -0.03609108f, 0.01577500f, 0.04305991f, 
    -0.25789350f, 0.23546878f, 0.38786373f, -0.01047504f, -0.22120368f, -0.04411456f, 0.07890043f, 0.09747352f, 
    -0.05128366f, -0.12450138f, -0.04358420f, -0.03963048f, 0.04549948f, -0.05653639f, 0.02008406f, -0.01185594f, 
    -0.02935649f, 0.00166418f, 0.03509416f, 0.05157390f, -0.17553119f, 0.24350084f, 0.12717099f, -0.29483759f, 
    0.46047312f, -0.35012758f, -0.01657688f, 0.04985575f, 0.20315321f, -0.05517253f, 0.00691862f, -0.11252648f, 
    0.16384342f, 0.08267273f, 0.10199719f, 0.06265428f, -0.08056594f, 0.08562839f, -0.12809576f, -0.07393767f, 
    0.14235280f, 0.09283638f, 0.19276905f, 0.00846687f, 0.15579499f, -0.16119331f, 0.11908987f, 0.15199767f, 
    -0.15100892f, 0.03444734f, 0.07931330f, 0.09094132f, -0.21567243f, 0.09326445f, -0.07812756f, -0.10290548f, 
    -0.13083072f, 0.12948668f, -0.15454072f, -0.23649101f, 0.11241597f, -0.83600235f, 0.41605827f, 0.17614289f, 
    -0.19843177f, -0.12627637f, -0.04670715f, 0.04345858f, 0.09841415f, 0.00508694f, -0.22452274f, 0.24012318f, 
    -0.06355129f, 0.03968691f, 0.01228054f, -0.01628415f, -0.15927407f, 0.00712094f, 0.30529857f, 0.00708350f, 
    0.22723849f, -0.44152677f, 0.23835154f, -0.18790133f, 0.34345949f, -0.09246310f, -0.05774460f, -0.33985248f, 
    0.09004073f, 0.01712073f, -0.23571385f, 0.12319152f, -0.05270784f, 0.16600697f, 0.08215877f, -0.09009797f, 
    0.10681561f, -0.18852739f, -0.07172530f, 0.00332517f, 0.64153206f, 0.36931634f, 0.32445115f, -0.39873910f, 
    -0.28343472f, 0.22071055f, 0.12102760f, -0.12296226f, -0.06268279f, -0.08826195f, 0.03232904f, -0.08055222f, 
    -0.09668098f, 0.00664041f, 0.17921475f, 0.18217327f, 0.08730448f, -0.03554434f, 0.14885262f, -0.07056928f, 
    0.20705582f, -0.55679131f, 0.02868553f, 0.01552792f, -0.25703964f, -0.01310035f, -0.14314057f, 0.00128925f, 
    0.11082692f, -0.04412664f, 0.14997274f, -0.08543032f, -0.10495257f, -0.12468228f, -0.00972348f, 0.04026532f, 
    -0.12849769f, 0.08916868f, -0.17035408f, -0.14535691f, 0.25364226f, -0.21370886f, 0.17825407f, 0.27564093f, 
    0.21723649f, -0.03107303f, -0.45352602f, -0.04950489f, 0.02510186f, -0.04644494f, -0.05411192f, 0.10110570f, 
    0.00099083f, 0.12041774f, -0.08738361f, 0.19656251f, 0.11239338f, 0.01562065f, -0.05885286f, -0.06472370f, 
    -0.02014545f, 0.16413225f, 0.04378288f, -0.06802575f, 0.35036460f, -0.27685890f, -0.05785944f, 0.00616845f, 
    0.11975937f, 0.00498467f, -0.13047127f, 0.03917363f, -0.13573809f, -0.05303282f, -0.11143310f, -0.02596725f, 
    0.00046791f, -0.00576398f, -0.11196969f, 0.06108055f, 0.18094973f, -0.24861749f, 0.10751334f, -0.31204888f, 
    -0.13862301f, -0.15940888f, -0.17811260f, -0.19996670f, -0.02465121f, 0.10239941f, -0.01455086f, 0.00580416f, 
    0.06532524f, 0.04310804f, 0.10701858f, -0.00000389f, 0.04846593f, -0.11115175f, -0.04527555f, 0.27185705f, 
    0.18366157f, 0.02995577f, 0.08568203f, -0.14887315f, 0.35028177f, -0.22138432f, -0.38315874f, 0.13261567f, 
    0.08329316f, -0.02667070f, 0.11649886f, 0.09528493f, -0.07555538f, 0.01719639f, -0.10525199f, 0.00581840f, 
    0.02421958f, 0.01707833f, -0.13971697f, 0.12759794f, 0.15588926f, 0.14731817f, -0.14260256f, -0.26515028f, 
    0.12206578f, -0.19845852f, -0.20106733f, -0.15434065f, 0.04387764f, 0.01992599f, 0.17723200f, -0.01278065f, 
    -0.08256579f, -0.05480630f, -0.11745990f, 0.03842800f, -0.00650404f, 0.00898419f, 0.10387369f, -0.02597263f, 
    0.09689460f, 0.54194975f, -0.07144188f, -0.04095769f, 0.41480267f, -0.09467994f, 0.02564716f, 0.09638856f, 
    0.02407814f, 0.06700667f, 0.21707763f, -0.07026275f, 0.11325307f, 0.11987180f, -0.11520339f, -0.00262655f, 
    0.10233427f, 0.04876241f, -0.20969726f, 0.11037671f, 0.64006525f, -0.73224115f, -0.06384344f, -0.23331283f, 
    -0.24569449f, -0.02759762f, 0.22390327f, -0.05904298f, -0.11487798f, 0.01279315f, 0.27376285f, -0.08095509f, 
    0.00522999f, 0.14125118f, -0.15723503f, -0.04069378f, 0.02564694f, -0.11294041f, 0.10926483f, 0.10824614f, 
    0.34627256f, -0.39287677f, -0.18708971f, 0.06861027f, -0.24741735f, -0.06999358f, -0.01956780f, 0.14228106f, 
    0.10859131f, 0.16891693f, 0.00584940f, -0.06215058f, 0.04488841f, 0.10247218f, -0.14644939f, 0.08396574f, 
    0.21949515f, 0.00694169f, -0.08549968f, 0.01747874f, 0.33547601f, -0.26584995f, -0.13113308f, 0.08103888f, 
    -0.28938800f, -0.20928521f, 0.00606602f, -0.09429035f, 0.09751426f, 0.08956384f, -0.01035622f, -0.05585088f, 
    -0.07078114f, -0.09059529f, 0.12649582f, 0.12867120f, -0.09168902f, 0.12001288f, -0.21132657f, 0.01073248f, 
    -0.42670584f, 0.19370106f, -0.01172646f, 0.01604729f, -0.18149991f, -0.08380203f, -0.00374737f, 0.02612950f, 
    0.00502390f, 0.21920615f, -0.09397729f, 0.15887453f, -0.00226274f, 0.06985950f, 0.00836843f, 0.10818714f, 
    0.02834867f, -0.01154738f, -0.03482877f, 0.06712772f, 0.61160684f, -0.37718952f, 0.11731119f, -0.17580245f, 
    -0.17581064f, -0.15625614f, -0.11605712f, -0.11998996f, 0.12853180f, -0.15613082f, 0.01935226f, 0.10304689f, 
    -0.07245145f, 0.07776047f, 0.06876244f, -0.10204381f, -0.15519673f, -0.10889223f, -0.20990190f, -0.08602286f, 
    -0.37384501f, -0.34906250f, -0.68540478f, -0.38803187f, 0.02898678f, 0.08901276f, -0.15077010f, -0.03411452f, 
    -0.10443462f, 0.14631119f, 0.11135446f, 0.02390339f, 0.10392538f, -0.22580244f, 0.08036660f, -0.12386327f, 
    -0.10182810f, -0.10152391f, -0.05250816f, 0.01776337f, 0.06841266f, -0.37191910f, -0.03685859f, -0.09846805f, 
    -0.12979499f, 0.12615599f, 0.10824539f, 0.04758181f, -0.05059417f, -0.16108933f, -0.01599491f, 0.13939589f, 
    0.13473094f, 0.04275471f, -0.01177461f, -0.11786753f, -0.02840663f, -0.31875008f, -0.17576732f, -0.06584909f, 
    0.11649265f, -0.98225862f, 0.24239317f, -0.46487615f, -0.25236404f, -0.00774931f, -0.25235575f, 0.13430373f, 
    0.05344231f, -0.21055193f, -0.26983413f, -0.10374648f, -0.03258050f, 0.06184732f, -0.09133378f, -0.07266816f, 
    -0.10087654f, 0.03247305f, 0.14942844f, -0.37380460f, -0.71168393f, 0.13038637f, -0.15114847f, -0.02819234f, 
    -0.04301883f, -0.12700261f, 0.00742487f, -0.07256867f, -0.03267527f, -0.01821521f, 0.12299231f, 0.09429467f, 
    -0.00810368f, -0.10623328f, 0.05049253f, 0.06418657f, -0.14015687f, 0.01168979f, -0.07764277f, 0.01787207f, 
    -0.11557286f, 0.16518584f, -0.24539815f, 0.01271592f, 0.04754810f, 0.17023779f, -0.01287798f, 0.11871579f, 
    0.11289690f, 0.23300318f, -0.12854365f, -0.11313602f, -0.00539935f, -0.00720228f, 0.10312056f, 0.13506316f, 
    0.18015638f, -0.30890027f, -0.21209989f, -0.30017471f, -0.06570499f, -0.11173916f, -0.00817136f, -0.34061250f, 
    0.25120068f, -0.20285413f, -0.04464456f, 0.04889358f, -0.11083789f, -0.07439312f, -0.02138338f, -0.15158692f, 
    0.09658132f, -0.15145880f, 0.03025150f, -0.11634888f, -0.09363521f, -0.21807180f, 0.10173608f, 0.17549850f, 
    0.45480275f, -0.17430195f, 0.10221970f, 0.02986819f, 0.12799002f, -0.14677943f, -0.05781965f, -0.03827976f, 
    -0.06394385f, -0.14192480f, -0.02559144f, -0.09967848f, -0.13085201f, 0.07332345f, -0.15014620f, -0.05098850f, 
    0.05316445f, -0.04588310f, -0.00201566f, 0.09492303f, 0.01964104f, 0.38548002f, 0.17578414f, 0.34797901f, 
    0.38556144f, 0.11453564f, -0.13705781f, 0.15930384f, -0.01332419f, 0.15126555f, 0.04654628f, 0.03954150f, 
    -0.03538104f, 0.14665852f, -0.15136151f, 0.09910989f, -0.02114841f, 0.15620711f, 0.07833803f, 0.02571738f, 
    0.31148380f, 0.20106560f, 0.21724020f, 0.08544806f, 0.25711536f, -0.07083505f, -0.07841760f, -0.08968806f, 
    0.00076875f, -0.02549051f, -0.11703121f, -0.03395922f, -0.03285617f, 0.02138617f, 0.00277508f, 0.00797438f, 
    0.04657961f, 0.10671198f, 0.19248360f, 0.01668149f, 0.27606151f, -0.06901308f, 0.01917020f, 0.17982888f, 
    0.02909436f, 0.04588528f, -0.16325136f, 0.13296011f, -0.04534583f, -0.05291503f, 0.01634777f, -0.05367896f, 
    0.05652037f, 0.09436236f, 0.01914890f, 0.10403881f, 0.20860383f, -0.11416785f, -0.12607379f, -0.11837795f, 
    0.28457066f, 0.29640722f, -0.22990847f, -0.14142427f, -0.05081667f, -0.01991965f, 0.12535177f, -0.00235319f, 
    -0.17876694f, -0.26446345f, 0.05311646f, -0.08710290f, 0.02160654f, -0.13082246f, 0.02203349f, 0.05427191f, 
    -0.06990409f, -0.05504885f, -0.18991028f, -0.06579697f, -0.39455241f, -0.19953035f, 0.27315074f, -0.06095316f, 
    0.12636627f, -0.03486135f, -0.01985275f, -0.08079356f, 0.12526904f, 0.07781902f, 0.01810108f, -0.14244452f, 
    -0.05923105f, -0.05050664f, 0.08064463f, 0.05238849f, -0.04405972f, -0.17143051f, -0.02594935f, 0.05955753f, 
    0.68892920f, -0.29415753f, -0.05361114f, 0.12669590f, 0.19301721f, -0.40237966f, -0.03536073f, -0.13701729f, 
    -0.04963027f, -0.11045188f, 0.10345283f, -0.11235549f, -0.06004450f, 0.05365097f, -0.00732890f, -0.01044322f, 
    -0.05329221f, 0.12493823f, -0.05163040f, 0.02338125f, 0.64789706f, 0.00217768f, -0.06572241f, 0.46409920f, 
    0.02138968f, -0.19450980f, 0.05153210f, -0.08077107f, 0.02017016f, 0.08734626f, 0.00545817f, 0.06078641f, 
    0.09298008f, 0.15426551f, -0.02984321f, 0.03703709f, -0.20848881f, -0.13200286f, 0.02370257f, -0.01093338f, 
    0.55341750f, -0.05960421f, 0.11050478f, -0.04408136f, 0.18891016f, -0.14185420f, -0.07546976f, 0.04993898f, 
    0.04669967f, -0.08230318f, -0.02783588f, -0.01486658f, -0.07443037f, -0.07561123f, 0.08208207f, -0.16044705f, 
    -0.07708148f, -0.02211461f, 0.17309320f, 0.01104008f, 0.25257006f, 0.07196946f, -0.07629292f, -0.20583025f, 
    -0.11349748f, 0.06001341f, -0.15047829f, 0.20452672f, -0.08209100f, 0.04704008f, -0.15186195f, -0.00664192f, 
    0.09458125f, -0.05588664f, -0.02750544f, 0.02022752f, -0.07649339f, 0.23872125f, 0.14347605f, 0.07530855f, 
    0.13722791f, -0.53489143f, -0.26232570f, -0.34608620f, -0.26324719f, 0.01223726f, -0.06793481f, 0.13677695f, 
    -0.06791947f, -0.16468577f, -0.10964376f, -0.05333662f, 0.02466188f, -0.09030135f, -0.12177490f, 0.05015960f, 
    -0.21594895f, 0.01156086f, 0.00050652f, 0.00667879f, -0.53917950f, -0.03864160f, 0.02790935f, -0.69163066f, 
    -0.29697564f, 0.06004428f, 0.25537783f, 0.02405610f, -0.03212629f, -0.03859464f, 0.02349500f, 0.02893282f, 
    -0.03147342f, -0.21473812f, -0.07233348f, 0.11687052f, -0.09310873f, 0.11396159f, 0.20201457f, -0.00571893f, 
    -0.02790680f, -0.31168994f, -0.18547140f, -0.10997265f, -0.40021303f, -0.05271398f, 0.02338652f, 0.21952949f, 
    0.12941878f, 0.15940619f, 0.03851027f, -0.01725706f, -0.09316500f, -0.01172203f, -0.06715371f, 0.17961796f, 
    -0.10600524f, 0.18344133f, 0.04359971f, -0.03270682f, 0.63077056f, 0.12259001f, 0.16783442f, -0.00398579f, 
    0.28569657f, 0.12040852f, 0.01769476f, -0.24101384f, 0.04847532f, 0.18204165f, 0.06099852f, -0.06328885f, 
    -0.01220295f, -0.12393583f, -0.11496769f, 0.07173770f, -0.11193436f, -0.01622764f, -0.05769601f, -0.03683617f, 
    -0.00078197f, -0.63633984f, 0.00638364f, -0.47084400f, -0.42887849f, 0.19754036f, -0.22389454f, -0.31737724f, 
    0.00434085f, 0.10058347f, -0.11017003f, 0.03383145f, -0.10422024f, -0.07652727f, 0.01157961f, -0.12301435f, 
    -0.13783921f, 0.13234796f, -0.06023085f, 0.00966500f, -0.04656283f, -0.55980974f, 0.07145419f, -0.21800891f, 
    -0.02940979f, 0.24641609f, 0.19737886f, -0.02124510f, 0.05475879f, -0.05658749f, -0.11297948f, -0.05201492f, 
    -0.05944820f, -0.06027418f, -0.04876882f, -0.04486470f, -0.06390891f, -0.13689061f, -0.36248362f, -0.04493330f, 
    0.18800829f, -0.14810938f, 0.14544997f, -0.18746361f, 0.15245132f, 0.07303526f, -0.09046196f, 0.01617876f, 
    0.16861506f, -0.02338854f, -0.11107017f, -0.04726404f, 0.01824848f, 0.11184564f, -0.03658118f, 0.00382863f, 
    -0.02662365f, 0.04813881f, -0.01642573f, 0.00137647f, -0.66292781f, 0.27723396f, 0.04421429f, 0.03490121f, 
    0.12658450f, 0.03627590f, -0.01694397f, 0.17925566f, 0.14718707f, -0.13817430f, -0.06032109f, 0.03162175f, 
    0.07970470f, 0.10246032f, 0.05304050f, -0.06144192f, -0.09370399f, -0.08668528f, -0.16652995f, 0.04648134f, 
    0.20196089f, -0.33879706f, 0.22181331f, -0.20945847f, -0.03145336f, 0.07731828f, -0.08012696f, 0.07826506f, 
    0.08698262f, 0.03056346f, -0.20111883f, 0.05466655f, 0.01250387f, 0.05753972f, -0.02546181f, -0.15720934f, 
    -0.10965249f, 0.05480396f, -0.19084217f, -0.14911607f, -0.11788853f, 0.35561481f, -0.01132692f, -0.12526383f, 
    0.16250351f, 0.15164903f, 0.08037774f, 0.03397044f, 0.02663897f, -0.18996921f, 0.03832045f, 0.18156396f, 
    -0.11846524f, -0.12155764f, 0.01487047f, 0.05503614f, 0.05285798f, 0.00603102f, -0.04412192f, -0.04064400f, 
    -0.48374316f, 0.24331020f, -0.00068867f, -0.13248813f, 0.26712933f, -0.15502721f, -0.01288074f, -0.06044757f, 
    0.09721175f, -0.08661165f, -0.00366312f, -0.00535323f, -0.14110424f, 0.00538330f, -0.04581127f, -0.15796950f, 
    -0.06261060f, -0.21988231f, 0.15623154f, 0.03145263f, 0.10095609f, 0.07465264f, -0.16075495f, 0.09815804f, 
    -0.37381905f, -0.06143656f, 0.07810293f, -0.04424991f, -0.04337728f, 0.06641746f, -0.04619035f, 0.10351963f, 
    0.07056867f, 0.02342804f, -0.01019235f, 0.06005105f, -0.15995839f, 0.12422289f, -0.11385508f, 0.01926556f, 
    0.05165500f, -0.01061808f, -0.01687421f, 0.02308758f, -0.15471689f, -0.22527938f, -0.21288368f, -0.06171813f, 
    -0.08495854f, 0.06251281f, -0.05628180f, 0.01872119f, 0.03660579f, -0.12213904f, 0.08144552f, -0.13693912f, 
    0.06933764f, 0.09539247f, 0.06612994f, 0.01034762f, 0.01488828f, -0.19876678f, 0.11195032f, 0.12119991f, 
    -0.08157614f, -0.12438367f, -0.18847233f, 0.08299770f, -0.05243426f, -0.03032908f, -0.14298175f, 0.09798222f, 
    -0.10561554f, 0.00999427f, 0.02781595f, 0.00516798f, 0.08869171f, 0.14834602f, 0.19700730f, -0.06397214f, 
    0.00699610f, 0.00199447f, 0.14422463f, -0.12293166f, -0.24525341f, -0.01411395f, -0.13387126f, -0.15213059f, 
    -0.04873125f, -0.28728029f, 0.00882890f, -0.08600826f, -0.05262509f, -0.07715446f, 0.01162099f, -0.09487534f, 
    -0.02472191f, -0.08460632f, -0.02008282f, 0.00464570f, 0.11864500f, -0.60497785f, -0.29796878f, -0.08413851f, 
    0.24577269f, -0.09806683f, -0.01233179f, 0.02256292f, 0.11316217f, 0.08525584f, 0.16706941f, 0.07248875f, 
    0.04751525f, -0.13355616f, -0.02593203f, -0.17715181f, -0.05420257f, -0.07509516f, -0.02930677f, -0.13071382f, 
    0.87120426f, 0.43797290f, 0.07401685f, 0.19704466f, 0.06284229f, 0.11847851f, 0.00253040f, 0.03800526f, 
    0.03225221f, 0.00136872f, -0.13325958f, -0.07678381f, 0.01740900f, -0.01335972f, 0.00133350f, 0.00751593f, 
    0.11004198f, 0.10268424f, 0.16247241f, 0.00571349f, 0.06786535f, 0.23885185f, 0.27815625f, 0.31849223f, 
    0.13220988f, 0.12689881f, 0.14473642f, 0.04986183f, 0.11840936f, 0.06288119f, 0.10003051f, 0.01827005f, 
    -0.08496790f, -0.16565019f, -0.16115175f, 0.18237568f, -0.10269991f, 0.13928661f, 0.16106439f, 0.08923347f, 
    0.26777369f, -0.17327471f, 0.31134319f, 0.20722102f, 0.14931338f, 0.03692072f, 0.00388851f, -0.07728048f, 
    0.06540450f, 0.02898067f, -0.02930222f, 0.03654432f, -0.02268550f, 0.02769224f, 0.22124442f, 0.02978340f, 
    -0.14172855f, -0.00134095f, -0.02224161f, 0.20792495f, -0.61512375f, 0.43218011f, 0.03899289f, -0.19415808f, 
    -0.24152818f, -0.05673439f, -0.20075282f, 0.07130303f, -0.00641492f, -0.06050187f, 0.04714586f, -0.09736649f, 
    -0.18734507f, 0.13673410f, -0.07681355f, -0.07059027f, -0.02368637f, -0.09635178f, 0.22091782f, 0.11788829f, 
    0.17316368f, 0.32846704f, -0.03199599f, -0.10718270f, -0.15217604f, -0.14874645f, -0.03911569f, -0.09221701f, 
    -0.13008890f, -0.06708049f, -0.16964166f, -0.02446814f, -0.01248958f, -0.07989820f, 0.06920774f, 0.05334427f, 
    -0.11382877f, 0.16303420f, -0.02181632f, 0.00817210f, 0.21113022f, -0.11260146f, -0.10520770f, 0.27272856f, 
    0.09018946f, 0.05422656f, 0.03553122f, -0.03684406f, -0.07048027f, 0.00108080f, -0.05488227f, -0.04364163f, 
    -0.14067456f, 0.09741736f, -0.08724837f, 0.07742580f, 0.10982174f, 0.11458708f, 0.03031108f, -0.12245290f, 
    -0.48369035f, -0.29022676f, -0.54217923f, -0.19096161f, -0.07906700f, -0.19680278f, -0.03212495f, -0.10109719f, 
    0.02143450f, 0.05433674f, -0.07041609f, 0.00910161f, 0.10421543f, 0.02517539f, 0.15793723f, 0.02029255f, 
    -0.00394222f, -0.13483571f, 0.00719721f, 0.05128995f, 0.40031451f, -1.17268729f, -0.34289879f, 0.24556144f, 
    0.07874408f, -0.02945185f, 0.11741145f, 0.18611456f, -0.08222854f, -0.23569156f, 0.13167167f, -0.11169479f, 
    -0.06324016f, -0.03177669f, 0.14486732f, -0.01002837f, 0.08453691f, 0.09103832f, 0.00026545f, -0.14110699f, 
    -0.54008621f, -0.52814364f, -0.46291620f, -0.06053744f, -0.34782684f, -0.10129201f, -0.13264877f, -0.08682517f, 
    0.02834936f, 0.06618208f, -0.05604212f, -0.07122713f, 0.14304289f, 0.07308741f, -0.06801241f, 0.12631762f, 
    -0.04584965f, 0.00578172f, -0.07188699f, 0.19295070f, -0.44909775f, -0.48970476f, -0.41963086f, 0.12935844f, 
    0.38154545f, 0.00171705f, 0.09403788f, 0.12101879f, 0.03379664f, -0.09745333f, -0.02795896f, 0.01591741f, 
    0.02397141f, -0.23176470f, -0.12531781f, 0.05390394f, -0.02204815f, 0.13824631f, -0.02552346f, 0.07683929f, 
    -0.97583199f, 0.12867638f, 0.16277921f, 0.16440123f, 0.01121071f, -0.09699396f, 0.04037133f, 0.16515054f, 
    -0.01882142f, -0.08481174f, 0.02156756f, 0.06527726f, -0.15133470f, 0.02394913f, 0.00970112f, 0.05831430f, 
    0.01064571f, -0.12649219f, -0.07206409f, -0.04636809f, -0.86661023f, 0.35730857f, 0.08481923f, 0.19661477f, 
    -0.16071190f, 0.14149056f, -0.19824167f, -0.06094300f, -0.11775658f, -0.16361740f, -0.09569822f, 0.00881206f, 
    -0.14227673f, 0.06281289f, 0.07364190f, 0.10793146f, -0.15011071f, 0.03239406f, -0.02422783f, -0.03958853f, 
    -0.52855343f, 0.40254486f, 0.02445686f, 0.14769675f, 0.21653028f, 0.15015951f, -0.14103602f, -0.18235181f, 
    0.23274338f, 0.26969770f, -0.07460632f, 0.09111053f, 0.05173884f, -0.05791993f, 0.03245543f, -0.04769862f, 
    0.08821270f, 0.04452574f, 0.19151405f, -0.06927392f, -0.74255043f, -0.07938012f, 0.01149529f, 0.02938886f, 
    0.41806424f, 0.03947089f, 0.00253159f, -0.04202622f, 0.07195617f, 0.26641867f, -0.03561689f, -0.09266043f, 
    0.16140242f, 0.14864640f, -0.01610346f, -0.11551988f, 0.27955329f, 0.10176393f, 0.27561563f, -0.19685672f, 
    0.08818430f, 0.32858479f, -0.47327170f, -0.30507961f, 0.19139808f, 0.07229025f, -0.08927530f, 0.09072819f, 
    0.18121137f, -0.22314607f, 0.18116491f, 0.05161164f, -0.12930639f, 0.00612271f, 0.01804732f, 0.18935452f, 
    0.04397923f, -0.15621880f, -0.06733380f, -0.12940134f, 0.30946517f, -0.47819096f, -0.18473713f, -0.11816600f, 
    -0.19832991f, -0.20023373f, -0.05721746f, -0.04625872f, -0.30457646f, -0.05165053f, -0.05814303f, 0.06566983f, 
    -0.12832382f, -0.05658610f, 0.05963979f, -0.03824414f, -0.04315977f, 0.02302482f, -0.00527948f, 0.01471823f, 
    0.13557413f, 0.18271048f, 0.16935758f, -0.15833732f, -0.31825399f, 0.01750403f, 0.02001731f, -0.18128851f, 
    0.06664085f, -0.08631217f, -0.05878114f, -0.07291102f, 0.02042600f, 0.12958221f, 0.05940330f, -0.09441790f, 
    0.20559210f, 0.04690269f, -0.00806868f, 0.16907217f, -0.17943512f, -0.14940003f, -0.02592857f, 0.28750059f, 
    -0.15235199f, -0.21346521f, -0.04202855f, -0.06862439f, -0.07196243f, -0.07265891f, 0.19247168f, -0.01329556f, 
    -0.02322702f, 0.06958211f, 0.05378445f, -0.05482632f, 0.04080869f, 0.13380064f, -0.01302312f, 0.02006149f, 
    0.28316674f, 0.06773169f, -0.48349366f, 0.10943308f, -0.46041328f, -0.18556015f, 0.03926560f, 0.17867675f, 
    -0.18511364f, 0.01042491f, -0.10266666f, 0.14864065f, 0.09652338f, -0.14434236f, -0.03722506f, 0.09303174f, 
    -0.01466152f, -0.00303787f, 0.02951776f, -0.16245207f, -0.42952889f, -0.18846905f, -0.13725840f, 0.08423131f, 
    0.24780966f, 0.03622019f, 0.02077947f, 0.35839525f, -0.09702434f, 0.02308434f, -0.11342950f, 0.06743678f, 
    0.11869323f, 0.03957912f, -0.09366744f, -0.09953751f, 0.03788258f, 0.05654621f, 0.03149272f, -0.09681999f, 
    -0.07848898f, -0.10849344f, 0.22131453f, -0.05441918f, -0.09149662f, 0.20171911f, 0.20941991f, -0.12919942f, 
    0.15161648f, -0.02578627f, 0.25613815f, -0.15584999f, 0.10522614f, -0.02462777f, 0.05552348f, -0.01234105f, 
    -0.25701061f, -0.01571537f, 0.13567260f, -0.03297699f, -0.10271420f, 0.38314372f, 0.19053927f, 0.11351327f, 
    -0.13563077f, 0.02375553f, 0.02576015f, -0.12019670f, 0.07967394f, 0.03756669f, 0.07302387f, -0.16602345f, 
    0.00172596f, 0.15333185f, -0.06426688f, -0.17828479f, 0.05802622f, 0.09225017f, 0.03322000f, -0.02888092f, 
    0.06780384f, 0.02623748f, 0.27076977f, -0.23854783f, -0.22346199f, -0.07066777f, 0.08203069f, -0.01303559f, 
    0.04870010f, 0.15466039f, 0.09235910f, -0.17877297f, 0.07234900f, 0.06718232f, 0.05709153f, 0.08630336f, 
    -0.02166980f, -0.04660163f, 0.02551972f, -0.01898148f, 0.16737691f, -0.24892586f, 0.16076437f, -0.15893543f, 
    0.00488087f, -0.22184147f, -0.04607828f, -0.34846807f, -0.03061522f, 0.04171883f, -0.08589868f, 0.00329353f, 
    0.01883839f, 0.05082823f, -0.02024567f, -0.24154633f, 0.00354454f, -0.25877357f, 0.11021575f, -0.06409405f, 
    0.06212341f, 0.12097821f, 0.10010813f, 0.02445467f, -0.03932735f, 0.07504357f, -0.00812563f, -0.05512954f, 
    0.19474369f, 0.21039072f, -0.02658235f, 0.03104370f, 0.06475834f, -0.02153336f, 0.01031428f, -0.11525673f, 
    0.04071145f, -0.02157625f, 0.00597721f, -0.09737580f, -0.35768729f, -0.44510743f, 0.15391676f, 0.31990862f, 
    -0.06884756f, -0.24390960f, -0.07632613f, -0.01243585f, -0.01136675f, 0.10660157f, 0.06442684f, -0.00037664f, 
    -0.04374223f, -0.09997566f, 0.07903840f, -0.07625556f, 0.01039820f, -0.07292330f, 0.10337234f, 0.06976038f, 
    0.00543167f, -0.10495976f, 0.02281008f, 0.17941268f, -0.61911660f, -0.14412016f, 0.01305773f, -0.02606294f, 
    0.03147983f, 0.06746546f, 0.04840678f, 0.04480860f, 0.14678319f, 0.11715441f, 0.09819531f, -0.02728184f, 
    -0.07121697f, -0.01976003f, 0.15484138f, -0.05477376f, -0.40754789f, 0.18263164f, -0.28081226f, -0.02785499f, 
    0.09528116f, -0.04382660f, 0.12938990f, -0.06880514f, -0.03664860f, -0.08252890f, 0.17078885f, 0.03482925f, 
    0.09036855f, -0.06174230f, 0.05067376f, 0.00949800f, 0.11883423f, 0.00162720f, 0.08431317f, -0.10500915f, 
    -0.79772490f, -0.08552939f, -0.50099164f, -0.21094680f, 0.03461927f, 0.19646730f, 0.29154292f, 0.02255931f, 
    0.02164017f, -0.14829846f, -0.04858762f, 0.17646453f, -0.10887821f, -0.01879183f, -0.01069443f, -0.02874294f, 
    0.01615929f, 0.00800451f, -0.10722648f, -0.12530273f, -0.40533724f, 0.08171531f, -0.49714577f, -0.44881937f, 
    -0.15637699f, 0.31091574f, 0.11286704f, 0.03276295f, 0.01479932f, -0.25220129f, 0.00108913f, 0.03641178f, 
    -0.19919081f, -0.11276557f, -0.09781179f, 0.01989241f, -0.04268025f, -0.02100891f, -0.13036011f, 0.11490268f, 
    -0.78492558f, -0.18594109f, -0.00419321f, 0.12176618f, -0.38679108f, 0.07889230f, -0.00398834f, -0.03162683f, 
    -0.03271234f, -0.04048373f, 0.05610632f, -0.12225994f, 0.10041092f, -0.12713370f, -0.09399328f, 0.04452942f, 
    0.03344351f, 0.15903033f, 0.11624991f, -0.01649154f, -0.17243601f, 0.15282787f, 0.13625540f, 0.29753438f, 
    0.15502629f, -0.11243429f, -0.23529881f, -0.16614673f, -0.07348543f, 0.11909672f, -0.16479625f, -0.20626202f, 
    -0.06817809f, 0.01132637f, -0.05820241f, 0.20514627f, 0.04030918f, -0.18168153f, 0.19899017f, 0.04540443f, 
    0.03312991f, 0.07724537f, 0.22813146f, 0.17504807f, -0.29077908f, 0.01398964f, -0.14091270f, 0.06262307f, 
    0.11429998f, 0.03688001f, -0.09072571f, 0.09641805f, 0.08918123f, 0.01382424f, -0.08514228f, -0.00274960f, 
    -0.06090577f, -0.25606528f, -0.05191611f, 0.09707507f, 0.00612180f, -0.06076366f, -0.00992558f, 0.40072837f, 
    0.28845373f, -0.15904568f, -0.28556308f, 0.11837527f, 0.10989324f, 0.15884979f, 0.02137544f, -0.24625088f, 
    0.16324531f, 0.09843283f, 0.17452627f, -0.06108573f, 0.10424873f, -0.20947246f, -0.18833801f, -0.31544656f, 
    0.05979596f, 0.10970988f, 0.26664904f, -0.15449437f, 0.04378236f, -0.04991240f, -0.11019427f, -0.11950822f, 
    -0.13683623f, 0.17089520f, 0.05895438f, -0.05599683f, 0.02072102f, -0.13677865f, -0.12417731f, -0.11146470f, 
    -0.21963745f, 0.09720295f, -0.02728139f, 0.10084777f, -0.62488341f, 0.27439556f, 0.12564924f, -0.19009587f, 
    -0.09250949f, 0.04691944f, 0.02014047f, 0.25575325f, 0.02374281f, -0.16297789f, 0.21665777f, -0.01164244f, 
    -0.06044661f, -0.10024130f, -0.07524683f, 0.11367380f, 0.00073919f, 0.02987050f, -0.06775982f, 0.10478454f, 
    -0.60167313f, -0.14109494f, -0.13841766f, -0.00183492f, 0.02672541f, -0.15115723f, 0.16500899f, 0.07477608f, 
    -0.05462930f, 0.11445183f, -0.09283809f, 0.23167259f, 0.24995025f, 0.11913016f, -0.08868170f, -0.08052406f, 
    0.21915528f, -0.35726818f, -0.11020640f, 0.12401462f, -0.05778994f, -0.22914754f, -0.09527608f, 0.14194490f, 
    0.08922219f, 0.03220373f, -0.01876609f, 0.13391340f, 0.09680031f, -0.03177702f, 0.01797528f, 0.12572916f, 
    -0.00315770f, 0.03933354f, -0.00344774f, -0.04598466f, -0.11325194f, -0.09227993f, 0.05036832f, -0.02804255f, 
    0.21430737f, 0.07227575f, -0.02043440f, 0.09795199f, 0.24152045f, 0.05036055f, 0.05634436f, -0.06424210f, 
    -0.17167905f, -0.03387209f, -0.00989743f, 0.12599024f, 0.09643953f, -0.12765458f, 0.13694809f, -0.06546191f, 
    0.10816468f, 0.12059648f, 0.17307040f, -0.15496507f, 0.10381004f, 0.08839495f, 0.08768110f, 0.18032297f, 
    -0.09794189f, -0.09565277f, 0.00552537f, -0.02777810f, -0.02026859f, -0.01490018f, 0.12152266f, -0.23189232f, 
    -0.11736712f, -0.11215474f, -0.07483561f, 0.19130185f, -0.36959708f, 0.21252529f, -0.01911309f, 0.04351717f, 
    0.28909999f, -0.00932521f, 0.15490039f, -0.01712170f, 0.11185646f, 0.03469710f, 0.08922036f, -0.01026796f, 
    -0.07503332f, -0.05379876f, 0.05448358f, 0.02065931f, -0.00592587f, 0.07480375f, 0.05973178f, 0.00829737f, 
    -0.03941984f, -0.00545718f, 0.07256219f, 0.00211741f, 0.21510072f, 0.13782026f, 0.11310089f, 0.08711253f, 
    0.20908344f, -0.14597912f, 0.03035037f, 0.08326189f, 0.00955952f, 0.17654714f, -0.17660557f, -0.19775474f, 
    0.06066241f, 0.19111374f, 0.29745883f, -0.12239003f, -0.00966479f, -0.02805646f, 0.05739789f, 0.01768945f, 
    -0.04468684f, 0.25974885f, 0.17585649f, 0.05416275f, -0.18995184f, 0.34468988f, -0.17143561f, 0.01161769f, 
    0.05670651f, 0.06108040f, -0.17755570f, 0.06063363f, -0.00680059f, 0.06615335f, -0.18310961f, -0.04994060f, 
    0.01789416f, 0.03574618f, -0.07446209f, -0.20305984f, 0.11028126f, -0.51128221f, -0.02773767f, -0.39758155f, 
    0.59276932f, 0.02674618f, -0.02170016f, -0.00460552f, 0.14827031f, -0.01238930f, -0.13357808f, 0.04332917f, 
    -0.00381930f, -0.02347749f, 0.04090664f, -0.07842032f, -0.00111537f, 0.00378602f, -0.15296145f, 0.20030828f, 
    0.03144075f, 0.02143908f, -0.12535332f, -0.69036108f, 0.25978476f, -0.09784104f, -0.01612660f, -0.09126884f, 
    -0.08210217f, -0.15387453f, 0.12437731f, -0.08478682f, 0.07120928f, -0.09306987f, 0.08713376f, -0.02086500f, 
    0.01340174f, -0.10837525f, 0.05813394f, 0.18824218f, -0.10421243f, -0.33403572f, -0.21239682f, -0.49663049f, 
    0.20056997f, 0.08398665f, -0.00459590f, 0.09734379f, -0.18131314f, -0.04062961f, -0.05305153f, -0.18446623f, 
    0.26562557f, 0.12020256f, 0.06128706f, -0.07464907f, -0.01645365f, -0.09709865f, 0.01030609f, 0.07883413f, 
    0.54823518f, -1.11483359f, -0.38760370f, 0.26622295f, 0.08068629f, -0.13154209f, 0.09147159f, 0.01278896f, 
    -0.07801127f, 0.09261482f, 0.00970459f, 0.09289509f, -0.09761021f, 0.10686463f, 0.15087946f, -0.07490414f, 
    0.12823594f, -0.01731151f, -0.26461524f, -0.10082237f, -0.35127664f, 0.44031507f, -0.16333462f, 0.28760588f, 
    -0.47214216f, 0.12530325f, 0.08846457f, -0.05013730f, 0.09160963f, -0.04799090f, 0.01324554f, 0.08069942f, 
    0.07925745f, -0.10518168f, -0.15595573f, -0.07881852f, -0.00261719f, 0.03306700f, -0.00980745f, 0.06241477f, 
    0.24388680f, -0.22176163f, -0.00466951f, 0.23963617f, 0.31514692f, 0.00637611f, 0.27003843f, 0.03224192f, 
    0.04641191f, -0.09455316f, -0.00602482f, -0.01810668f, -0.04964481f, 0.00856611f, 0.01568246f, 0.11604463f, 
    -0.04070552f, 0.23757610f, 0.12529863f, 0.00009983f, -0.01690211f, 0.13160163f, -0.44181764f, -0.36152887f, 
    0.08767920f, 0.04965645f, 0.05008304f, -0.11308954f, -0.10917397f, 0.08078149f, -0.09816720f, -0.06576886f, 
    -0.17797574f, -0.05034759f, -0.13559344f, 0.10529907f, -0.05966054f, 0.29849181f, 0.22927000f, 0.26442933f, 
    0.31524056f, -0.25870764f, 0.01400920f, 0.07179337f, 0.05128940f, 0.04565888f, 0.00561294f, 0.03011278f, 
    0.01123569f, -0.05400129f, 0.05410295f, -0.15945724f, -0.11399516f, -0.01871121f, -0.17919789f, -0.07621939f, 
    0.09314522f, 0.06614410f, 0.01996428f, -0.03648189f, 0.06615546f, -0.57362700f, -0.15463997f, 0.28042236f, 
    -0.11569997f, -0.04700811f, -0.00696934f, -0.07664564f, 0.08183639f, -0.04852416f, -0.05579852f, 0.09065966f, 
    -0.00965211f, 0.11389104f, 0.09311713f, -0.17081757f, 0.01921033f, 0.19093716f, -0.08404350f, -0.10927404f, 
    -0.29240009f, -0.00459640f, 0.00812577f, -0.09713296f, 0.31648976f, -0.09011674f, 0.05518540f, -0.04278767f, 
    -0.32629675f, -0.26842958f, -0.01903695f, -0.07006914f, -0.23231779f, 0.10461731f, 0.14149460f, 0.10874039f, 
    0.03385204f, 0.17319846f, 0.05464301f, 0.00767748f, -0.15132858f, 0.27676716f, -0.34149739f, 0.19110978f, 
    -0.19674765f, -0.20165980f, 0.23062488f, 0.09152818f, 0.10466190f, -0.04782013f, 0.00348393f, 0.09032581f, 
    -0.02039435f, -0.02669406f, 0.07038771f, -0.04932334f, 0.15636715f, 0.16937447f, 0.01947222f, 0.31989589f, 
    -0.29139161f, 0.18860477f, -0.15581715f, 0.13937128f, -0.11584267f, 0.00765786f, -0.06005296f, -0.11448594f, 
    0.17856844f, -0.09012216f, -0.09144802f, -0.06883935f, -0.03344749f, 0.04988116f, -0.00673986f, 0.00650607f, 
    -0.11385920f, -0.17207603f, -0.11924759f, 0.02099716f, -0.56563848f, 0.38781363f, 0.07305421f, 0.18798533f, 
    -0.00074939f, 0.04052152f, 0.13092147f, -0.01828705f, 0.03881632f, -0.01428383f, -0.13448311f, 0.16344932f, 
    0.11468143f, -0.02386951f, 0.14291549f, 0.00862439f, 0.10987429f, -0.15191360f, 0.10167071f, -0.13079761f, 
    -0.48874223f, 0.03406108f, -0.13352217f, 0.21051890f, -0.23089567f, -0.21352294f, 0.08507642f, -0.04213207f, 
    0.07875786f, 0.13773426f, -0.19299524f, -0.06653692f, -0.00540115f, -0.01961541f, 0.08209635f, -0.05415383f, 
    0.00141458f, -0.11123144f, -0.20048754f, -0.07126046f, -0.22975516f, 0.56142646f, 0.18174270f, -0.01338933f, 
    -0.48120591f, 0.17449914f, -0.06180964f, -0.01098587f, 0.10232599f, -0.01975247f, 0.01230552f, 0.11269683f, 
    0.00243923f, 0.09189620f, -0.24572405f, 0.21538295f, -0.17158552f, -0.13140105f, -0.05076658f, -0.07205208f, 
    0.06918979f, -0.64058518f, 0.15703902f, 0.03901210f, -0.37881562f, 0.05846280f, 0.07609066f, -0.06904193f, 
    -0.01539214f, -0.10003524f, -0.12899128f, -0.06724685f, -0.05106859f, 0.05348044f, -0.21316344f, 0.05049883f, 
    0.16287053f, -0.03861722f, -0.07307325f, -0.01729469f, -0.13736987f, 0.05572044f, 0.14610213f, 0.02020168f, 
    0.24794756f, -0.24010672f, 0.11279456f, 0.05085697f, 0.00618134f, -0.02961710f, -0.06670532f, 0.08833415f, 
    -0.11445919f, -0.04344390f, -0.09586560f, -0.05278682f, -0.03402771f, 0.04518769f, -0.08031756f, -0.04898299f, 
    0.35425603f, 0.12584060f, 0.48712793f, 0.08295572f, 0.22489966f, 0.18575075f, 0.17415430f, -0.00061599f, 
    -0.03041771f, -0.05807091f, -0.10827454f, 0.03682496f, -0.15047635f, 0.02198247f, -0.05628090f, -0.04272987f, 
    -0.04335632f, -0.02111632f, 0.01904472f, -0.13068134f, 0.40664458f, 0.02540624f, 0.41748005f, 0.02828163f, 
    0.14280726f, 0.04906789f, 0.15472645f, -0.01114875f, -0.10286219f, -0.01821731f, -0.00512919f, 0.13917749f, 
    0.03342061f, -0.09066479f, -0.09615073f, -0.15071112f, -0.03527654f, -0.07536665f, -0.01666894f, -0.17796995f, 
    0.12298349f, -0.14502773f, 0.13062561f, 0.06616378f, 0.17999031f, 0.03166616f, 0.06614362f, -0.13126804f, 
    -0.02856530f, -0.13357815f, 0.05183470f, 0.03332397f, 0.07194568f, -0.03029094f, -0.05605051f, -0.11609230f, 
    -0.06786908f, 0.04002127f, 0.01428589f, 0.04295309f, -0.70430863f, 0.29329142f, 0.02089383f, -0.24584046f, 
    -0.26649907f, 0.13110983f, 0.05342677f, -0.11269242f, 0.04505615f, -0.02054298f, 0.00145881f, 0.06069072f, 
    0.05145149f, -0.01305393f, -0.14141440f, 0.02059662f, -0.08637467f, 0.00310038f, -0.01860456f, 0.07283577f, 
    -0.40770620f, 0.22217003f, 0.06303607f, 0.09545208f, 0.38444042f, 0.12424398f, -0.12958100f, -0.03377056f, 
    0.03286114f, -0.07707191f, -0.03606070f, -0.02377783f, -0.01152737f, -0.00574948f, -0.12247473f, -0.00240983f, 
    -0.13475423f, 0.02672462f, -0.05913141f, -0.14841338f, 0.13333417f, 0.39570290f, -0.39605916f, 0.15169489f, 
    0.24208918f, -0.28642157f, -0.08215895f, -0.22384706f, -0.04713612f, -0.08921282f, -0.11770149f, 0.05068714f, 
    -0.11328852f, -0.07213757f, -0.02432787f, -0.04015041f, -0.10273024f, 0.12537394f, -0.12370948f, -0.00445569f, 
    0.17054872f, 0.36140439f, 0.03711443f, 0.17886859f, 0.31631219f, -0.14594612f, 0.23654713f, -0.00514361f, 
    0.01397905f, 0.03778545f, -0.08071332f, 0.13830078f, -0.08208027f, -0.11301978f, 0.00900965f, 0.07025772f, 
    -0.04518287f, 0.06962684f, -0.13666359f, 0.01877845f, 0.17200428f, 0.08199938f, 0.22844134f, 0.05358086f, 
    -0.04478496f, 0.06628069f, -0.15866548f, 0.03868638f, -0.05223649f, -0.07663972f, 0.08639249f, 0.04313919f, 
    0.19799007f, 0.00878518f, -0.26898286f, 0.03766093f, 0.01310076f, 0.05837836f, 0.04037691f, -0.05159215f, 
    -0.06232064f, 0.23319450f, 0.37546507f, 0.10063870f, 0.29097298f, 0.16240466f, -0.05190000f, -0.08668656f, 
    0.09638231f, -0.00531355f, -0.00627058f, 0.05195047f, 0.00024470f, -0.18374689f, -0.13531530f, -0.08949222f, 
    -0.16559480f, 0.15544380f, 0.14324772f, -0.02400738f, 0.08706634f, 0.25443602f, -0.27829432f, 0.14419043f, 
    0.18375976f, -0.08572199f, -0.08064608f, -0.02197604f, -0.02717893f, -0.05591162f, -0.02853315f, 0.14124964f, 
    0.10461108f, 0.11597209f, -0.13484235f, -0.00503295f, -0.06353083f, -0.00453471f, 0.00792778f, -0.04071515f, 
    -0.34416205f, -0.18239233f, -0.08268309f, -0.08990429f, -0.25412956f, -0.12698549f, 0.01488340f, -0.00828569f, 
    -0.15461996f, -0.08759651f, -0.04436677f, -0.03466606f, -0.09027094f, -0.10171296f, -0.00100822f, -0.02692764f, 
    -0.05824059f, -0.07577632f, -0.10969486f, 0.01968712f, -0.38420331f, -0.10758050f, -0.55445111f, -0.33605278f, 
    -0.24088624f, 0.02247831f, -0.08251140f, -0.06090114f, -0.03073879f, -0.05476905f, -0.15314764f, -0.14367592f, 
    0.08216221f, -0.04161085f, -0.10735995f, -0.14080048f, -0.13485336f, 0.00573536f, 0.01578325f, 0.09151793f, 
    -0.16486299f, 0.15989234f, -0.08347160f, -0.15512404f, -0.20204756f, -0.09911632f, -0.10287142f, 0.05018315f, 
    -0.16053270f, -0.14137882f, 0.06277442f, 0.02160950f, -0.01290917f, 0.01774949f, -0.02071134f, -0.02542750f, 
    -0.09728015f, -0.08564344f, -0.08354492f, -0.03541128f, -0.36471805f, -0.26995701f, -0.44045070f, -0.09682552f, 
    -0.14700042f, -0.17291276f, -0.14729059f, -0.02276544f, 0.03619426f, -0.05138298f, -0.11563174f, -0.07625088f, 
    0.00002196f, -0.07302340f, -0.05199665f, -0.04256429f, -0.03821149f, -0.01737959f, 0.00315801f, -0.03894223f, 
    0.19938961f, 0.02852100f, -0.39799660f, 0.20453447f, 0.11378517f, 0.10662518f, -0.01822603f, -0.15694205f, 
    -0.00966662f, -0.04454103f, -0.03173881f, 0.00815525f, 0.06909560f, -0.01678030f, -0.02394387f, 0.14958225f, 
    0.00484211f, 0.01232828f, 0.13825703f, 0.05327640f, 0.07566600f, 0.27255282f, 0.32873452f, -0.08732585f, 
    -0.02316201f, -0.24882677f, -0.15212277f, 0.05288192f, -0.11752094f, -0.00846106f, 0.08563579f, -0.01283260f, 
    -0.00811608f, -0.06089418f, -0.07835245f, -0.00934470f, 0.08687024f, -0.04714395f, 0.20826776f, -0.14113526f, 
    -0.40141311f, -0.02266172f, 0.27371916f, -0.05969433f, 0.00691202f, 0.02888152f, 0.00964010f, 0.01229091f, 
    -0.06172865f, -0.16020766f, 0.13647020f, 0.03192929f, -0.17260486f, 0.11946607f, 0.00054136f, 0.00602714f, 
    0.01392601f, -0.06521571f, -0.06972514f, -0.00445168f, -0.36830488f, -0.03345690f, 0.26047590f, -0.10651457f, 
    0.32867685f, -0.07777811f, -0.14031793f, 0.05200858f, -0.08287542f, 0.13735631f, 0.11433864f, -0.07561994f, 
    -0.17416313f, -0.05445704f, 0.12882361f, -0.05153459f, -0.04045152f, 0.10015553f, -0.03977391f, 0.10295811f, 
    0.09271251f, -0.01654175f, 0.12319122f, 0.02038153f, 0.18552768f, -0.14387734f, -0.06890495f, -0.01065344f, 
    -0.06348608f, -0.02619939f, -0.05447303f, -0.09594311f, -0.00915295f, -0.15161794f, 0.02172055f, 0.09252696f, 
    -0.16165854f, 0.01817352f, 0.18458678f, 0.19628355f, -0.03964226f, 0.25767139f, -0.43950427f, 0.02984094f, 
    -0.11799064f, 0.20848474f, 0.06012334f, -0.09185807f, -0.11950903f, -0.07500239f, 0.08690174f, 0.00002432f, 
    0.08030844f, 0.00395478f, 0.09806474f, 0.05794733f, -0.13402642f, -0.04090628f, 0.15039861f, -0.13720538f, 
    -0.09266540f, -0.03854462f, -0.43811694f, -0.03939897f, -0.25138074f, 0.06257578f, 0.00671509f, -0.30816349f, 
    0.03866358f, -0.02668544f, 0.11481251f, -0.05167218f, -0.01958843f, -0.00182483f, 0.06029288f, 0.06604781f, 
    -0.00337616f, -0.28472021f, -0.01064424f, -0.07649151f, -0.17771128f, 0.23639384f, -0.07063245f, -0.52025604f, 
    -0.28398055f, -0.14127254f, -0.07792841f, -0.19735564f, -0.17866662f, -0.18286107f, 0.06187084f, 0.18330175f, 
    0.01798999f, 0.10515190f, -0.09886140f, 0.02988849f, 0.14643587f, -0.30468518f, -0.07670744f, 0.06039187f, 
    -0.18461384f, 0.16620556f, -0.29118049f, -0.22868489f, -0.48390284f, -0.07133930f, -0.03914163f, -0.21590026f, 
    -0.04549615f, -0.08470726f, 0.23050161f, -0.00263177f, -0.10562179f, -0.06932548f, 0.20055918f, -0.07906492f, 
    0.00499458f, -0.26494142f, 0.08231389f, 0.08464947f, 0.13567629f, -0.09886020f, -0.04424629f, 0.19660121f, 
    0.26880276f, -0.31968376f, -0.18064611f, -0.23313192f, -0.17523828f, 0.07276750f, -0.08485770f, -0.21988352f, 
    -0.14527234f, -0.00705715f, 0.14386627f, 0.16839816f, 0.11274297f, -0.01563770f, 0.13709977f, 0.02557787f, 
    -0.37868878f, 0.07398620f, -0.05970109f, -0.18138257f, -0.39228916f, -0.13964601f, -0.07583016f, -0.13316120f, 
    -0.23705134f, -0.03328347f, 0.10168273f, 0.03787073f, 0.11781597f, 0.08155561f, -0.07343827f, -0.00676575f, 
    -0.06655267f, -0.26174629f, -0.14722063f, 0.06199394f, -0.13123007f, -0.30306393f, 0.09162600f, 0.18429147f, 
    0.01633058f, 0.05598235f, 0.16350743f, -0.13368665f, -0.13330321f, -0.01152448f, 0.20000638f, 0.05241057f, 
    0.04809199f, -0.07881298f, 0.15282156f, -0.13380980f, 0.06552815f, 0.05421570f, 0.10277017f, -0.28305808f, 
    0.21705562f, 0.15471636f, -0.18875661f, 0.26843074f, 0.04395567f, 0.12651643f, -0.02151548f, -0.12324488f, 
    -0.18739596f, -0.17436370f, 0.13177492f, 0.04097365f, 0.06091477f, 0.04582128f, 0.06123429f, -0.01134883f, 
    -0.02605398f, 0.05339969f, 0.11100368f, -0.12901293f, 0.10418370f, 0.25304946f, -0.15599065f, -0.10447096f, 
    0.08721916f, 0.16886443f, 0.07841597f, -0.18559106f, -0.01598912f, -0.07076585f, 0.01949038f, 0.06346894f, 
    -0.00393623f, -0.14967223f, -0.13597471f, -0.20348236f, 0.06695207f, 0.16587037f, 0.06057703f, -0.03862554f, 
    0.31982395f, 0.20303984f, -0.02775642f, 0.21732694f, 0.13500983f, 0.01262178f, 0.07708556f, -0.22443724f, 
    -0.13555591f, -0.07719403f, -0.02019092f, -0.02812012f, -0.05485542f, -0.20115183f, 0.03198602f, -0.19348201f, 
    -0.05683840f, -0.00409408f, 0.17954111f, -0.04438501f, -0.00082167f, -0.18896851f, -0.31712550f, 0.07358234f, 
    0.14968756f, 0.17928953f, 0.09199917f, -0.04772464f, -0.13841613f, -0.09514322f, -0.06340367f, 0.01966628f, 
    0.06731645f, -0.03378911f, 0.02652773f, 0.01591942f, 0.17219166f, 0.02865287f, -0.00340988f, -0.15842895f, 
    0.39193371f, -0.84679073f, 0.49115732f, -0.30670145f, -0.01945442f, -0.00912274f, 0.08905140f, -0.04647540f, 
    0.00359070f, 0.01660681f, -0.05577455f, 0.07255965f, -0.05313494f, -0.09303984f, -0.01093475f, -0.11667477f, 
    -0.00595008f, 0.01450344f, 0.04873841f, 0.16271302f, 0.20697941f, 0.37072060f, -0.34993088f, 0.26575711f, 
    -0.04600705f, 0.17903221f, 0.04582082f, 0.07585421f, 0.17237550f, 0.16261928f, -0.14711462f, -0.05597736f, 
    0.07949626f, 0.06524078f, 0.14045613f, 0.05233868f, -0.04597753f, 0.16012120f, -0.11367548f, -0.16773027f, 
    -0.12463379f, -0.43076059f, 0.13219471f, 0.28770882f, 0.02556793f, 0.01137407f, -0.00976717f, 0.01995905f, 
    -0.20797330f, 0.10285347f, -0.00224715f, 0.03072286f, 0.01032677f, 0.16365895f, 0.12463793f, 0.04442992f, 
    -0.16310653f, 0.02805266f, 0.12275304f, 0.05531191f, 0.14318018f, -0.07558479f, -0.25761032f, 0.34165052f, 
    -0.12707648f, -0.02415805f, 0.02395750f, -0.13126254f, 0.05029423f, 0.02967237f, -0.03387462f, 0.09233921f, 
    0.03206926f, -0.10068741f, 0.04602007f, -0.00303959f, 0.07562196f, -0.15959096f, 0.04465425f, 0.00831102f, 
    0.11582583f, 0.01289750f, -0.07728422f, -0.11216293f, 0.10073602f, 0.30134806f, -0.13057195f, 0.03902724f, 
    -0.09270381f, 0.23787493f, -0.02143009f, -0.00990961f, 0.04223341f, 0.13778992f, 0.02750754f, -0.11049162f, 
    -0.05995709f, -0.21445176f, -0.03757550f, -0.26661068f, -0.41372734f, -0.19987293f, 0.64543885f, -0.15317143f, 
    -0.25635892f, -0.04414019f, 0.02737249f, 0.14629689f, 0.04688395f, -0.01524925f, -0.10322872f, -0.07718375f, 
    0.07514356f, -0.04239361f, -0.07426129f, 0.06255838f, 0.17522852f, 0.07760850f, -0.15010904f, -0.15415929f, 
    -0.78682965f, -0.24060896f, 0.18207842f, -0.22250625f, 0.33386695f, -0.24128950f, 0.05979554f, -0.08337020f, 
    0.06404836f, 0.07366084f, -0.03528670f, -0.04442189f, 0.02139399f, -0.07111917f, -0.04447640f, 0.10612778f, 
    0.16158992f, 0.01079958f, -0.08537686f, 0.10904058f, 0.13274218f, 0.16812284f, -0.36263463f, -0.36392224f, 
    -0.67243689f, 0.00802559f, 0.18342504f, 0.02013824f, -0.03316888f, -0.03957212f, -0.10182016f, -0.00489182f, 
    -0.11900609f, 0.00254273f, 0.17156154f, 0.00616287f, 0.13056394f, -0.02909735f, 0.12922433f, -0.01834568f, 
    -0.90991676f, 0.45109811f, -0.05003929f, 0.25367624f, 0.01371321f, 0.08660758f, -0.04811270f, -0.01076787f, 
    -0.12951148f, -0.05502071f, 0.00381543f, -0.05118278f, 0.12294472f, 0.17379436f, 0.25460264f, 0.13411000f, 
    0.09558639f, 0.11175057f, -0.05601392f, 0.19711891f, 0.24153028f, -0.66523403f, -0.20344521f, 0.08476450f, 
    0.06260367f, 0.09701572f, 0.08369756f, -0.30043855f, 0.05797678f, 0.05926520f, -0.08416461f, -0.00491191f, 
    0.17699969f, 0.06836525f, -0.03196144f, -0.15245107f, 0.09654973f, -0.02609408f, -0.08446129f, 0.18089102f, 
    -0.06893083f, -0.52436388f, 0.00739492f, 0.30167702f, 0.32562441f, -0.06909199f, -0.16148855f, 0.09661054f, 
    0.07844799f, -0.09531163f, -0.10029679f, 0.22948171f, -0.35237864f, -0.10467058f, -0.15657985f, -0.05539644f, 
    -0.05440084f, 0.24532270f, 0.18879792f, 0.22914033f, -0.12095340f, 0.33837411f, 0.23976941f, -0.45087770f, 
    -0.26585326f, -0.18619184f, 0.06010562f, -0.10517274f, -0.05180736f, 0.27686417f, -0.14905234f, -0.08208504f, 
    -0.08446149f, -0.24604779f, 0.08817033f, 0.12094619f, -0.04031760f, 0.06027735f, -0.02465806f, -0.12999384f, 
    -0.53316498f, 0.23655243f, -0.03738610f, 0.18202770f, -0.19817819f, 0.08490283f, 0.03097843f, 0.11026720f, 
    0.05758832f, -0.03113787f, -0.00828289f, -0.03719936f, 0.00551576f, -0.05237078f, 0.10226100f, 0.11044881f, 
    -0.06336009f, 0.07482682f, -0.21786958f, -0.02113343f, 0.47006756f, -0.20741642f, -0.01871601f, -0.12361339f, 
    -0.56589466f, -0.13953952f, 0.06476428f, 0.28571650f, -0.06212738f, -0.12624957f, -0.00422653f, -0.03206026f, 
    -0.10262734f, 0.00278155f, 0.07832091f, 0.08626787f, 0.01979051f, -0.27017090f, -0.12219356f, -0.07322446f, 
    -0.61928040f, 0.30727008f, -0.01122676f, 0.13194317f, -0.06427521f, 0.16563740f, -0.02001688f, 0.11635701f, 
    0.02475855f, -0.18947776f, 0.10678776f, 0.14195451f, -0.15842225f, 0.04898888f, 0.07562951f, 0.14886984f, 
    -0.00403552f, -0.07652615f, -0.03221491f, 0.14922790f, -0.21129829f, -0.15931050f, 0.19909215f, -0.37050822f, 
    -0.30956331f, -0.07979406f, 0.14508814f, -0.19211884f, 0.01656031f, -0.05528363f, -0.12280289f, 0.05548942f, 
    -0.12626326f, -0.19933146f, -0.18833232f, -0.20730565f, -0.15298419f, 0.17445205f, -0.11134683f, 0.05845420f, 
    -0.94514740f, -0.34743822f, -0.54557639f, -0.02191974f, -0.13555789f, 0.03365738f, 0.04862117f, -0.16133788f, 
    -0.02806643f, 0.24667421f, 0.05429487f, 0.02958252f, 0.03976819f, 0.03374847f, 0.07466872f, 0.16263483f, 
    -0.01802589f, 0.23570292f, -0.03951660f, 0.15668277f, 0.11742140f, 0.05460308f, 0.09585068f, 0.14083570f, 
    -0.01484796f, -0.08190402f, 0.01662682f, 0.17874226f, 0.10107099f, 0.01610999f, 0.05134556f, -0.02228453f, 
    -0.01238765f, -0.13851388f, -0.02853833f, -0.02197017f, -0.06461522f, 0.05548580f, 0.24179517f, -0.07493395f, 
    0.39032748f, 0.06894918f, 0.04072422f, -0.02332466f, -0.07157630f, -0.00703906f, -0.02147926f, 0.09685278f, 
    0.06637423f, 0.02255271f, 0.01120400f, 0.02637544f, -0.09929965f, 0.01111804f, -0.08227374f, 0.05213121f, 
    0.00369312f, -0.17163630f, -0.24178571f, -0.01594335f, 0.37612617f, 0.03227977f, -0.00069235f, -0.07613169f, 
    0.14260159f, -0.09837071f, 0.02978499f, -0.16194786f, 0.02445456f, -0.10754371f, 0.02411369f, 0.05789833f, 
    -0.10278742f, -0.00166617f, -0.14245354f, -0.15534075f, 0.06080446f, -0.06911711f, -0.32005435f, 0.17102034f, 
    -0.02072135f, 0.30962995f, -0.29494870f, 0.02520416f, -0.00196251f, -0.08513606f, -0.07443474f, 0.02225390f, 
    0.12368466f, 0.15830079f, 0.02878757f, -0.01698767f, 0.04013098f, -0.06186631f, 0.10516665f, -0.08458351f, 
    -0.01831366f, 0.31024835f, -0.06017762f, 0.17970642f, -0.85752726f, -0.58448654f, -0.24684650f, 0.12165496f, 
    0.16438811f, 0.15428251f, 0.07529067f, -0.03272051f, -0.05799470f, -0.20866323f, 0.09712925f, 0.06654356f, 
    0.00220781f, 0.13940585f, 0.06322037f, -0.03817273f, 0.12065645f, 0.22696579f, 0.02165108f, 0.08104412f, 
    -0.01661588f, 0.04230686f, -0.10873207f, 0.26578289f, 0.01176892f, 0.11712284f, 0.11115302f, 0.05871684f, 
    0.07352640f, 0.08001148f, 0.07167414f, 0.12270243f, 0.12055588f, -0.00702756f, 0.11915357f, 0.04370816f, 
    -0.07498816f, -0.37027252f, 0.05139106f, -0.01501314f, 0.14050478f, 0.02104569f, 0.46479559f, -0.11322759f, 
    -0.18547118f, 0.32224047f, 0.08124041f, -0.00189021f, -0.01660516f, 0.19813165f, -0.03581853f, 0.04906246f, 
    0.04321234f, 0.04790314f, -0.07804286f, -0.03635509f, 0.11974495f, -0.30459908f, -0.20355046f, -0.13783427f, 
    -0.61597621f, -0.56639749f, -0.08289464f, 0.04616081f, 0.46095979f, 0.04503777f, 0.13640325f, -0.02970346f, 
    -0.05014160f, -0.14802606f, 0.10491307f, -0.06246221f, 0.06374586f, -0.06337827f, -0.04923177f, 0.12979065f, 
    0.06590063f, -0.23427424f, 0.03184167f, -0.04017550f, 0.28259832f, 0.08324326f, -0.27088404f, 0.09341003f, 
    -0.07365999f, -0.18423162f, -0.06366996f, -0.12563515f, 0.09810001f, -0.07620563f, -0.08862520f, 0.09257281f, 
    -0.10030052f, -0.10925730f, 0.11653945f, -0.13182171f, 0.04622017f, 0.01251637f, -0.06227783f, -0.10072606f, 
    0.48053443f, 0.26117530f, -0.26544496f, 0.17535552f, -0.09836733f, 0.01926091f, 0.01194516f, 0.14063837f, 
    0.07379951f, 0.11887736f, -0.06620516f, -0.06719937f, 0.02710158f, 0.05923145f, 0.07225961f, 0.08027497f, 
    0.24188976f, -0.26243705f, 0.05666957f, -0.02173568f, -0.65870839f, -0.26482034f, 0.15424547f, -0.27925962f, 
    -0.32397765f, 0.04441694f, 0.10337099f, -0.00434843f, -0.30274585f, 0.10325883f, 0.17530859f, -0.07336660f, 
    0.04216278f, 0.14787923f, 0.08017263f, -0.08353557f, -0.29212677f, -0.19785967f, -0.00871699f, -0.07236584f, 
    -0.49325687f, -0.49926195f, -0.30656227f, -0.07806003f, -0.33428326f, 0.05230995f, 0.14884283f, 0.14670865f, 
    -0.14208506f, 0.05466167f, 0.12818174f, -0.06018002f, 0.04403251f, -0.08550660f, 0.04871489f, -0.03468308f, 
    0.12472321f, 0.18715344f, 0.10605495f, 0.05309835f, -0.88719052f, -0.54754698f, 0.02177236f, -0.13165756f, 
    0.00743335f, 0.16662121f, 0.02411153f, -0.02107926f, -0.15568331f, 0.02357568f, -0.06360864f, 0.04993545f, 
    -0.05751470f, 0.26374426f, 0.18708980f, 0.14841861f, -0.05011304f, 0.18379512f, -0.04345996f, 0.13823715f, 
    -0.68237185f, -0.55702263f, -0.29491392f, -0.30841628f, -0.23700075f, 0.04890648f, 0.11441746f, -0.04580341f, 
    -0.05191332f, -0.03544178f, 0.10668661f, -0.09086423f, 0.02418441f, -0.07382813f, 0.01635113f, -0.00016990f, 
    0.00183842f, 0.10430681f, 0.22048311f, 0.00026635f, -0.53815377f, -0.33126280f, 0.19085701f, -0.31275368f, 
    -0.37756732f, 0.17672232f, -0.10909121f, -0.12875387f, -0.00079352f, 0.07612090f, 0.09424787f, 0.07465560f, 
    0.00106687f, 0.22586598f, 0.05248709f, 0.05797042f, -0.00668594f, -0.04007372f, -0.13748775f, -0.12031120f, 
    0.64908952f, 0.03525016f, -0.40694860f, 0.14516312f, -0.40330645f, -0.16351560f, -0.06770674f, 0.08054646f, 
    -0.01317586f, -0.01605016f, -0.01574178f, -0.04249251f, 0.03967649f, -0.17800184f, 0.12247246f, 0.15014172f, 
    -0.04933899f, -0.06649492f, 0.00597776f, 0.07158230f, -0.10971538f, -0.68870723f, 0.13093528f, 0.16445127f, 
    -0.01007445f, -0.05566887f, -0.06805623f, 0.07372329f, -0.11021852f, 0.18671200f, -0.07888154f, 0.03611205f, 
    -0.06002610f, 0.00489696f, -0.09446085f, -0.08904286f, 0.00276191f, 0.05421067f, -0.15302196f, 0.03874258f, 
    0.08217271f, 0.31296691f, -0.10958071f, -0.00903718f, -0.06079822f, -0.08398379f, -0.19042693f, 0.13010488f, 
    -0.24298793f, -0.17203292f, -0.01487431f, -0.02938952f, 0.20502460f, -0.01169295f, 0.01949470f, 0.04912432f, 
    0.02092532f, 0.01972881f, -0.04149913f, -0.08968435f, -0.43149507f, 0.44430894f, 0.10973032f, 0.05280313f, 
    -0.08944385f, 0.03634882f, -0.08492924f, 0.09041958f, -0.23034054f, -0.04640580f, -0.16298087f, -0.00226165f, 
    0.05830226f, -0.11492665f, -0.02778913f, 0.03815950f, 0.00414384f, -0.15491021f, 0.10536855f, 0.02386755f, 
    -0.58218592f, -0.12725668f, -0.02574717f, 0.03584621f, 0.20426355f, -0.15629429f, 0.13300174f, 0.00759566f, 
    0.18621539f, -0.05677151f, 0.00387265f, -0.03345824f, 0.00815620f, 0.12545970f, -0.03440596f, -0.11672240f, 
    -0.16454530f, -0.00162736f, -0.31839529f, 0.04926487f, 0.26388416f, 0.22565198f, -0.02162204f, 0.24238472f, 
    0.07232970f, 0.28414765f, 0.34755468f, -0.00805472f, 0.02523825f, 0.13687098f, 0.09844624f, 0.07759786f, 
    -0.03714448f, 0.12916894f, 0.17443097f, 0.01950250f, -0.00797040f, 0.00091496f, -0.03892429f, 0.10658738f, 
    0.16402453f, -0.04976261f, -0.23269175f, 0.09834166f, -0.21912847f, -0.14960583f, -0.16370407f, 0.14883313f, 
    -0.05980143f, -0.05444339f, 0.09904599f, -0.01065030f, 0.09584656f, 0.12152668f, -0.15507564f, 0.14714779f, 
    0.06497139f, 0.02107498f, -0.11427546f, -0.30201533f, 0.06866065f, 0.00805358f, -0.33921292f, -0.27803671f, 
    0.56704825f, 0.22565559f, -0.24574524f, -0.05081023f, 0.13279873f, -0.03744364f, -0.04412415f, 0.03539269f, 
    0.07204159f, -0.15172035f, -0.04611616f, -0.07377336f, -0.01301273f, 0.11434286f, -0.05082026f, 0.06609157f, 
    -0.58893973f, 0.69035286f, -0.30555105f, 0.35743141f, 0.12191354f, 0.40299532f, 0.14178365f, 0.10336277f, 
    -0.09454123f, -0.04224281f, 0.14934893f, 0.17564358f, 0.00623153f, -0.00828122f, 0.15318328f, 0.06375080f, 
    0.11949022f, -0.09806076f, -0.07645269f, 0.01765931f, -0.29551435f, -0.38464469f, -0.06967129f, -0.02597126f, 
    -0.15558851f, -0.13593711f, 0.13695109f, -0.07806601f, 0.09503006f, 0.00034389f, -0.39072093f, 0.10731696f, 
    0.24327591f, -0.00038516f, -0.08320801f, -0.18347330f, -0.00784463f, 0.07796545f, -0.32714364f, -0.18641289f, 
    0.49012807f, -0.00942869f, -0.08031834f, -0.10634162f, -0.11059206f, -0.23983309f, 0.01986006f, 0.03325380f, 
    -0.13838485f, 0.02287477f, 0.07178771f, -0.13289754f, -0.06370143f, 0.10875548f, -0.30131134f, 0.03355167f, 
    -0.17155054f, 0.11868042f, 0.07952858f, -0.04179252f, 0.47562647f, -0.24124531f, -0.33508345f, -0.16091354f, 
    -0.08144650f, -0.06393255f, -0.04143380f, -0.12767938f, 0.01239108f, -0.01284952f, 0.03458953f, 0.08818390f, 
    -0.03690057f, 0.08383412f, 0.10309138f, -0.00590699f, 0.10749960f, -0.03300859f, 0.10763249f, -0.05082176f, 
    0.02609237f, -0.28841218f, 0.09056261f, 0.08418018f, -0.49549758f, 0.05586454f, 0.05044782f, 0.08056585f, 
    0.04946374f, 0.09187439f, 0.06076583f, 0.11210785f, -0.03833603f, -0.08929503f, -0.11912059f, -0.07078825f, 
    0.01025532f, -0.11359075f, -0.03876079f, -0.04637614f, 0.09593458f, -0.08629222f, -0.21975905f, -0.37189659f, 
    -0.02047148f, 0.05393007f, -0.13678341f, -0.11775125f, 0.19665098f, 0.03108233f, 0.04037410f, 0.06728571f, 
    0.09582163f, -0.30164090f, -0.03055107f, -0.08586448f, 0.03754230f, -0.08832667f, -0.27371845f, 0.02405879f, 
    -0.18035772f, -0.50745451f, -0.09942461f, -0.16711323f, -0.46649063f, 0.10945546f, 0.11629584f, 0.11860193f, 
    -0.05031284f, 0.18942828f, 0.13221635f, 0.01262977f, -0.06175286f, -0.02830430f, 0.05201617f, -0.03465081f, 
    0.07347380f, -0.00192739f, -0.06755268f, 0.00164490f, 0.66916960f, 0.27414349f, -0.42727393f, -0.26310965f, 
    0.11395064f, -0.13228464f, 0.04837883f, -0.09371855f, -0.05113563f, -0.01618780f, 0.17629941f, -0.00989410f, 
    0.02320418f, 0.04010560f, -0.07953074f, 0.05421268f, 0.00209327f, 0.12072908f, 0.03581615f, 0.18028124f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19242680f, 0.02641808f, -0.12024421f, -0.05476792f, -0.00950087f, 0.00671133f, -0.05511411f, -0.13887465f, 
    -0.03577890f, 0.03189205f, 0.19303127f, 0.05649082f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
