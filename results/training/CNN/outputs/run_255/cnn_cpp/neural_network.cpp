#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.03665578f, 0.61598450f, 1.18578088f, -0.33682421f, -0.70282042f, 0.70105135f, 0.29275146f, 0.20671020f, 
    0.62474000f, -0.70367295f, -1.51608479f, 0.92285538f, 0.35365266f, -0.95131707f, 0.89871579f, 0.48765033f, 
    -0.62875992f, 0.22835055f, -0.07653735f, -0.82728851f, 0.37647673f, 1.11386073f, 1.10683393f, 1.18409920f, 
    -0.45337683f, -0.08476380f, 0.22025593f, 0.98290426f, 1.39109910f, -0.54274583f, 0.05688651f, -0.14356509f, 
    -0.19876821f, 0.62863994f, -0.26990542f, -0.14205322f, 1.31465638f, 1.03347111f, 0.52811569f, -0.33744872f, 
    -0.76573741f, -0.43501982f, 0.08050960f, 0.95996231f, 0.42819339f, -1.25211990f, 0.33111748f, 1.18776679f, 
    0.79226625f, 0.45495144f, -0.68021637f, 0.09366708f, 0.18787810f, -0.14515834f, 1.22769392f, 0.89679956f, 
    0.85531521f, 0.47152391f, 0.56028509f, 0.51102728f, 0.23995745f, 0.42560706f, -0.01021765f, 0.62584102f, 
    1.11837721f, 0.13777536f, 0.48411307f, 0.92714036f, -0.75231057f, -0.23745792f, 0.33313692f, -0.56980830f, 
    -0.21900973f, 0.70207286f, -0.81298286f, -1.12897122f, -0.85310036f, -0.97863066f, 0.27635142f, 0.27349794f, 
    0.63488996f, 0.00341027f, 1.18189371f, -0.83593529f, 1.14394271f, -0.20864873f, -0.95925641f, 0.50780308f, 
    -0.08422771f, 0.09458432f, -0.82095098f, -0.52190143f, 0.23854385f, -1.04913056f, -0.32692370f, -0.77332217f, 
    0.02730678f, 0.68862706f, -0.22987275f, 0.70223832f, 0.69621617f, -0.14611349f, 0.01232537f, -0.81024033f, 
    0.06038058f, 1.04458082f, 0.24440372f, 0.61533862f, -1.13305151f, -1.15365720f, -0.42084444f, 0.06908657f, 
    -0.18121397f, -0.29281801f, 0.49631709f, 0.11290431f, 0.05071290f, 0.96074480f, 0.85771805f, 1.16748166f, 
    0.45154923f, -0.52031553f, 0.21231915f, 0.40513867f, -0.22804953f, 0.72012395f, 0.64675528f, 0.59090847f, 
    1.28022277f, -1.39588678f, -0.11536804f, -0.90623206f, 0.13126482f, -0.40960386f, -0.33660698f, 1.05948102f, 
    0.60226870f, -0.02976123f, 0.30894038f, -1.65893149f, 0.94645506f, -0.44062704f, -0.63968402f, -0.45856473f, 
    0.62288994f, -1.19417870f, -0.72328162f, -0.38242176f, -0.82082117f, -0.69786441f, -0.43241599f, 0.18522590f, 
    0.35772857f, -1.07915258f, 0.79551125f, -0.28204468f, 0.60959095f, 1.25230229f, 1.19675708f, -0.31128529f, 
    -0.15684524f, -0.42179424f, -1.32152700f, -0.48219573f, 0.46813536f, 0.30136028f, 1.05903673f, -0.01817748f, 
    -0.40754548f, -0.32271370f, -0.36407298f, -0.49470481f, -1.02211714f, -0.82757097f, -0.85432231f, 0.75835490f, 
    1.17134690f, -0.54770994f, -0.18727833f, -0.73991352f, -0.55623770f, -0.29490602f, -0.65613806f, 0.90146559f, 
    0.35448596f, -0.61218381f, -0.02897858f, -0.42498550f, -1.17716289f, -0.81391799f, -0.02795792f, -0.95359755f, 
    -0.08229807f, 1.10714030f, -1.20831704f, -0.41392717f, -0.27878433f, 0.19080018f, 1.03062308f, 0.79265189f, 
    0.88995057f, -0.43677458f, 0.75905699f, 0.14078835f, -0.76607192f, -0.00988442f, 0.54345524f, 1.32499325f, 
    -0.35074887f, 0.87188363f, 0.89403796f, 0.21910106f, 0.50361550f, -0.63250375f, -0.16182351f, -0.89315546f, 
    1.24613750f, 1.00672865f, -0.39788151f, -0.88468701f, -0.03117210f, 0.08199636f, 0.26987562f, 0.77652895f, 
    -0.28632903f, -0.91270757f, 0.87868136f, 0.55545145f, 0.91212255f, -0.87374681f, -0.95342374f, -0.38863036f, 
    -0.25141719f, -0.08636883f, 0.78700554f, -1.39382708f, -0.24345839f, -1.45624077f, -0.16320279f, 0.47250068f, 
    0.04594334f, 0.40351012f, 0.18740381f, -1.11736858f, -0.23590998f, 0.64275390f, 1.23516810f, 0.55717742f, 
    0.77621031f, 0.32370728f, -0.05339573f, 0.41289914f, -0.38910076f, -1.01769602f, -0.29219314f, 1.18867970f, 
    0.98787826f, -0.19553147f, 0.32772133f, 0.10584413f, -0.76299995f, -1.01606691f, -0.75079727f, -0.00198375f, 
    0.26240718f, -0.41626713f, -0.65152335f, 0.83799404f, 0.52384514f, 0.76015705f, -0.24270292f, -1.03587210f, 
    -0.71324021f, -0.47011408f, 1.08907270f, -0.85174704f, 0.53844917f, 0.40347970f, 0.07232887f, -1.08556688f, 
    -0.96147662f, -1.32537377f, -0.19258386f, -0.06444353f, 0.45235306f, -0.74558485f, 0.06783779f, 0.24913542f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10820057f, 0.39012945f, 0.21714279f, -0.14173633f, -0.34597921f, 0.00908721f, 0.56130284f, 0.11213989f, 
    -0.09502875f, -0.21965230f, 0.31452483f, 0.15422468f, -0.06716426f, 0.04540182f, 0.39725134f, 0.15883759f, 
    0.14634223f, 0.32432872f, -0.17321660f, -0.31770307f, -0.12420871f, -0.33339328f, 0.47719350f, 0.41935173f, 
    0.07186061f, 0.05983230f, -0.22403705f, 0.13362746f, -0.22662708f, 0.36792514f, 0.21835293f, -0.22679198f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.46209025f, -0.27855194f, -0.28557986f, 0.03476952f, -0.00297013f, 0.03385544f, 0.08620968f, -0.12568249f, 
    0.11513085f, -0.64882153f, -0.29663065f, -0.56262344f, -0.01867157f, 0.13891326f, 0.26785988f, 0.02877820f, 
    -0.03572756f, 0.06781843f, 0.19215812f, 0.02790372f, 0.06478003f, 0.09985154f, 0.25732324f, -0.01006580f, 
    -0.11847720f, -0.24163000f, -0.26931387f, -0.01232052f, 0.14129901f, 0.06345698f, 0.20170236f, -0.16267462f, 
    0.23111877f, -0.19909069f, 0.05871338f, 0.04446847f, 0.73715806f, 0.36496246f, -0.16732304f, 0.10273934f, 
    0.06001723f, 0.19720282f, -0.00455437f, -0.05115376f, 0.32808316f, -0.60314775f, -0.35208470f, 0.52879477f, 
    -0.07986367f, 0.07721256f, -0.29083017f, 0.08509084f, -0.08668832f, 0.14387423f, 0.19205867f, 0.46644288f, 
    0.44760987f, 0.18052387f, 0.09995326f, 0.15021770f, 0.14623718f, -0.01838928f, -0.13791096f, -0.09380173f, 
    0.09252955f, 0.22435887f, 0.00205877f, 0.06233827f, -0.07233701f, 0.08509087f, 0.15225525f, -0.00869624f, 
    0.17893876f, 0.06193024f, 0.05673454f, 0.05056284f, -0.12211149f, -0.13484168f, 0.15044218f, 0.02084184f, 
    0.41330019f, -0.34259924f, -0.35112426f, 0.02284033f, 0.05473885f, -0.23803431f, -0.05263108f, -0.10104944f, 
    0.11990912f, 0.05216010f, 0.21144080f, -0.32770663f, -0.28125721f, 0.11975432f, 0.26650435f, 0.28664839f, 
    0.03629557f, 0.15950303f, 0.10174301f, 0.05495135f, 0.29209077f, 0.00091310f, 0.19253656f, -0.19049035f, 
    0.09930044f, -0.02741442f, 0.19044293f, 0.12021315f, -0.21209964f, 0.13695452f, -0.09158757f, -0.03499952f, 
    0.33707115f, 0.07709281f, 0.25368580f, 0.00837078f, 0.15045790f, 0.22661468f, 0.17429550f, 0.20633347f, 
    0.10660096f, 0.04148266f, 0.07419165f, 0.18154243f, 0.09830455f, -0.18506406f, 0.30471477f, 0.07474147f, 
    -0.14462550f, -0.11544368f, 0.25787339f, 0.19893128f, 0.04295807f, -0.08554971f, 0.09504845f, -0.08083449f, 
    0.17659390f, 0.17266987f, 0.10805625f, -0.20606743f, 0.30246660f, 0.26514578f, 0.26890847f, 0.09120206f, 
    -0.24111530f, -0.24327925f, -0.43688017f, -0.03219851f, 0.05503821f, -0.03185281f, -0.16547444f, 0.12846774f, 
    -0.03701615f, 0.25127524f, 0.09810273f, -0.22402632f, 0.29614803f, -0.01256219f, -0.09114292f, 0.23276849f, 
    -0.29138735f, -0.12295797f, 0.27343446f, 0.13187011f, 0.05063334f, 0.22783139f, 0.12803847f, -0.24146283f, 
    0.17488123f, -0.18099217f, -0.09678657f, 0.46515396f, -0.10729076f, -1.02193606f, 0.16148967f, 0.07329050f, 
    -0.00166221f, 0.05110070f, -0.04025228f, -0.21690150f, -0.01737827f, -0.11171617f, -0.31904855f, 0.11085433f, 
    -0.11175007f, -0.08384278f, 0.31337544f, 0.22398609f, -0.30930832f, -0.06844027f, -0.26448804f, -0.66117382f, 
    0.12858999f, 0.14371198f, 0.06433704f, -0.02586392f, -0.24283215f, -0.01720316f, 0.10429324f, 0.25046742f, 
    0.08805692f, 0.10761922f, 0.12702313f, 0.05338784f, 0.02595593f, -0.04087446f, 0.07794835f, 0.16076279f, 
    0.04941437f, 0.23443438f, -0.24767424f, -0.02706414f, 0.09527879f, 0.22109260f, 0.23049511f, -0.21070530f, 
    0.35101858f, 0.39859608f, -0.04225464f, 0.05041851f, -0.10366746f, -0.05000228f, 0.06039971f, -0.11429520f, 
    0.30946583f, -0.31263247f, -0.06607177f, 0.18262872f, -0.00353385f, 0.12728132f, -0.21283334f, 0.09214912f, 
    0.36662117f, 0.23881187f, -0.00418263f, -0.15672080f, -0.24778269f, -0.07479641f, -0.03670215f, -0.18024628f, 
    0.10638051f, 0.16341151f, 0.01912988f, -0.32530996f, -0.21057446f, 0.33307537f, 0.08575387f, 0.24392675f, 
    0.02647451f, -0.06465343f, -0.20842841f, -0.02061415f, -0.03544109f, -0.30690455f, -0.67460060f, 0.24754658f, 
    0.18000418f, -0.00565745f, 0.19685739f, -0.20844737f, -0.17745079f, -0.22378750f, -0.12963298f, 0.03236229f, 
    0.09272157f, 0.28454289f, -0.10098176f, 0.11716881f, 0.13645214f, 0.35081783f, -0.07646602f, -0.26571840f, 
    -0.13426737f, 0.18948457f, 0.11654057f, 0.22302866f, -0.04133786f, -0.27144068f, 0.06070064f, -0.24936414f, 
    0.06553285f, -0.35598248f, 0.00005227f, 0.20802122f, 0.19694060f, -0.02899984f, 0.11537347f, 0.07489309f, 
    -0.04209334f, 0.04027343f, 0.02570467f, -0.01801034f, -0.06409006f, 0.03220481f, -0.04573424f, -0.01877509f, 
    -0.03099279f, -0.06637770f, -0.01130464f, 0.00340876f, -0.06402860f, -0.02589468f, 0.00917963f, -0.04284795f, 
    0.04404102f, 0.00047161f, 0.02464689f, 0.00533826f, -0.03369157f, -0.03243307f, -0.05314961f, -0.03263403f, 
    -0.03102390f, -0.01107351f, -0.05282629f, 0.02987682f, 0.04829023f, 0.00610303f, 0.02916249f, -0.00773695f, 
    -0.05976244f, -0.02786015f, -0.02324782f, 0.02538228f, -0.02693948f, -0.05314812f, -0.05523134f, -0.04235266f, 
    -0.00202030f, -0.00581164f, -0.02533790f, -0.06381031f, -0.01720315f, 0.03991842f, -0.03398674f, -0.03708321f, 
    -0.06771655f, 0.00498435f, -0.03663495f, 0.03420474f, 0.01052396f, 0.01590411f, -0.01550355f, -0.06294413f, 
    0.04046642f, 0.04375354f, -0.03628365f, 0.03139564f, -0.04255447f, -0.05220515f, -0.05413267f, 0.05402061f, 
    0.01900718f, -0.00043071f, 0.01466292f, 0.01469534f, -0.04694660f, 0.02196305f, -0.01037548f, 0.01608613f, 
    0.00048632f, -0.01362142f, -0.04654718f, -0.02877456f, -0.02619311f, -0.00354746f, 0.02036716f, 0.01904765f, 
    -0.02013811f, -0.02288181f, 0.00638601f, -0.04107776f, -0.02943698f, -0.02450994f, 0.04838583f, -0.04315515f, 
    0.00266605f, -0.00535804f, 0.01946807f, 0.03351966f, 0.01090474f, -0.04494108f, -0.03337900f, 0.03655607f, 
    0.00965109f, -0.06449292f, -0.04206778f, 0.04771673f, 0.04657155f, -0.06136701f, 0.02883276f, 0.01721814f, 
    -0.05869640f, -0.03156344f, 0.03221998f, -0.01884457f, -0.06318145f, -0.00105587f, -0.04403633f, -0.06762876f, 
    0.00022940f, -0.00001663f, -0.01797021f, 0.05185039f, 0.01098075f, -0.01329560f, 0.02888910f, -0.00113082f, 
    0.02452000f, -0.05168731f, -0.03067873f, 0.00570061f, -0.04047246f, -0.04350341f, -0.00469111f, -0.01892579f, 
    -0.04047899f, 0.00692452f, -0.00009072f, 0.00983888f, -0.06287240f, 0.01660031f, 0.04974918f, -0.00379161f, 
    0.01914114f, -0.00080547f, -0.05341051f, -0.01283960f, 0.00301889f, -0.04679662f, 0.01820685f, -0.00251124f, 
    0.04956513f, 0.01387589f, -0.00071985f, 0.04143925f, -0.01440778f, 0.01091603f, 0.00384189f, -0.01890034f, 
    0.03608130f, 0.03375997f, 0.00550601f, 0.03337369f, -0.06133622f, -0.01573673f, -0.06544999f, 0.03198209f, 
    -0.03817996f, -0.04608905f, -0.01673748f, -0.03443496f, -0.01163296f, 0.01491561f, 0.05224279f, -0.00650052f, 
    -0.00474008f, 0.02034350f, 0.01192436f, -0.00321756f, -0.02070428f, -0.05556288f, 0.03872258f, 0.04402890f, 
    -0.06527965f, 0.05426989f, -0.04811316f, 0.00434824f, -0.03185510f, 0.01624279f, 0.00527530f, 0.00872613f, 
    0.02840182f, 0.00884859f, 0.00350404f, -0.00573085f, -0.01799767f, 0.04313400f, 0.02997101f, 0.05708480f, 
    -0.03688588f, 0.01676591f, 0.00803317f, -0.05205238f, -0.02532263f, -0.01104384f, 0.02758556f, -0.02323455f, 
    -0.02792314f, 0.02695220f, 0.03096847f, 0.00171946f, -0.05460639f, 0.03594312f, -0.00872102f, -0.03752152f, 
    0.01644997f, -0.01033799f, -0.02254975f, -0.02966213f, 0.02044894f, -0.00934808f, -0.03270488f, -0.03741740f, 
    0.05155593f, 0.00176851f, -0.05141466f, 0.00771538f, -0.02935972f, 0.03138876f, -0.00842757f, -0.03610896f, 
    -0.03219599f, -0.05440632f, -0.04063356f, 0.01267268f, 0.03253688f, -0.04920485f, 0.00535710f, -0.01514525f, 
    -0.01155612f, 0.01780023f, 0.04376428f, 0.02266569f, -0.01034042f, 0.04000447f, -0.05118009f, 0.03833375f, 
    0.01486284f, -0.06604339f, 0.00660792f, 0.02592356f, -0.00033556f, -0.02132246f, 0.01830892f, 0.01812304f, 
    0.04086515f, 0.05069837f, 0.02447704f, 0.04266484f, -0.03400328f, 0.01238162f, 0.02511276f, -0.01143153f, 
    -0.05881663f, 0.04493816f, 0.00818849f, 0.03148073f, -0.00746729f, 0.00423431f, -0.00776343f, -0.01022294f, 
    0.03376971f, -0.05249941f, -0.02594845f, 0.03623489f, -0.05753301f, 0.02576601f, -0.03596383f, 0.04008039f, 
    -0.00077597f, 0.01125430f, 0.02534273f, 0.03202830f, -0.05834955f, -0.05695914f, 0.03139111f, -0.03702109f, 
    0.01982164f, 0.00483637f, -0.04416973f, -0.01017211f, -0.04732003f, 0.05114926f, 0.00033171f, 0.04529803f, 
    -0.03287239f, 0.04004249f, 0.00591920f, 0.00884274f, 0.03900159f, -0.03098847f, -0.04753946f, -0.00659515f, 
    0.00720691f, -0.05836420f, 0.04113200f, 0.02252482f, -0.03621776f, -0.05700519f, -0.00768049f, -0.05755994f, 
    -0.00690875f, 0.02704472f, -0.02468235f, 0.01121486f, 0.01388970f, -0.01100450f, -0.03387655f, -0.03130462f, 
    0.04771901f, -0.00463929f, 0.03335516f, 0.04670995f, 0.04515692f, -0.04110378f, -0.01321908f, -0.00341883f, 
    -0.06026587f, -0.01276325f, -0.04486256f, -0.05355798f, -0.05678847f, 0.01361373f, -0.01307949f, -0.03512986f, 
    0.00822029f, -0.01151342f, -0.06027311f, 0.04055363f, 0.00005064f, 0.02991484f, 0.04666105f, -0.05688448f, 
    0.04704532f, -0.04051369f, 0.01233566f, 0.01017233f, -0.03581478f, -0.03820988f, -0.03487982f, 0.03455949f, 
    0.02336645f, -0.02951868f, -0.05714334f, 0.04097316f, -0.01559409f, -0.04906956f, 0.03318532f, -0.04996483f, 
    -0.04107185f, -0.05443545f, -0.05881842f, -0.02688360f, 0.03402005f, 0.03154753f, -0.04594349f, 0.00530648f, 
    -0.02738593f, -0.03648881f, 0.01377976f, 0.05030628f, -0.05058786f, 0.00120143f, 0.04537171f, -0.03569527f, 
    -0.04427488f, -0.01164607f, -0.00901702f, -0.01519677f, 0.03004069f, -0.04964076f, 0.01195907f, -0.05363633f, 
    0.04672882f, -0.06237552f, 0.00612549f, 0.02293200f, -0.03897351f, -0.01632307f, -0.06352789f, -0.00493547f, 
    -0.04136677f, 0.00524303f, 0.02697712f, -0.02443629f, -0.04493932f, -0.04741407f, -0.05351454f, -0.05449168f, 
    -0.05913327f, -0.01406870f, -0.02775635f, 0.02950796f, 0.00237510f, -0.02768113f, 0.02568532f, -0.02578628f, 
    -0.00324972f, 0.05280631f, -0.05683491f, -0.04737479f, 0.05324703f, -0.01146607f, 0.04673683f, 0.00214329f, 
    -0.02520746f, 0.01182930f, -0.04020647f, -0.03068919f, -0.05742530f, -0.04736200f, 0.00984441f, 0.02687113f, 
    -0.05971815f, -0.00559775f, -0.00300436f, -0.05691892f, -0.01888869f, 0.04238875f, 0.03773348f, -0.00791978f, 
    -0.00770608f, 0.00088529f, -0.04384131f, 0.01033581f, -0.05505645f, -0.06141238f, -0.05993810f, 0.03797123f, 
    -0.02336685f, 0.00904259f, -0.03957017f, 0.04652133f, -0.01736407f, -0.02437228f, -0.03490464f, 0.00103943f, 
    -0.01157913f, -0.02238110f, -0.05569426f, -0.05136577f, -0.04640887f, -0.00094768f, -0.02744556f, 0.02693044f, 
    -0.01650739f, 0.02623158f, -0.00802352f, 0.03310550f, 0.00630180f, -0.02089055f, -0.01703979f, -0.01023118f, 
    -0.04197415f, -0.04183278f, -0.01397431f, -0.04485221f, 0.04659466f, -0.05113579f, -0.02199326f, 0.00390363f, 
    -0.03678752f, 0.01162976f, -0.00156396f, -0.02664846f, 0.04329696f, 0.00165478f, -0.03624054f, 0.05097483f, 
    -0.04279531f, -0.03680557f, -0.05616131f, 0.00295325f, -0.05054774f, -0.05195068f, 0.02037475f, 0.05832736f, 
    -0.01712815f, -0.02134682f, -0.02863257f, 0.04918366f, 0.02529360f, -0.00897034f, -0.04589249f, -0.02992127f, 
    0.04371329f, 0.03654848f, -0.02396172f, 0.00112985f, 0.04028626f, 0.02724889f, 0.00957106f, 0.05289503f, 
    0.03501868f, -0.05073080f, 0.00670016f, 0.00208609f, 0.03957282f, 0.03084575f, -0.01181533f, 0.04679713f, 
    -0.00639734f, -0.04970078f, -0.01781838f, 0.01489187f, 0.03218929f, -0.01167591f, 0.03784557f, -0.03734737f, 
    0.02075813f, -0.05950315f, 0.00028005f, -0.04574424f, 0.04802535f, 0.02174213f, -0.02979586f, -0.03529727f, 
    -0.03897634f, 0.03343516f, -0.02675921f, 0.02779715f, -0.01151958f, -0.03222821f, 0.04768172f, 0.03298033f, 
    0.03787467f, 0.00399717f, -0.01294418f, 0.02442387f, -0.04017001f, -0.04491587f, 0.01751180f, -0.04456849f, 
    0.03251357f, -0.01193198f, -0.01879035f, -0.05586188f, 0.03429889f, 0.04844884f, -0.03838701f, -0.02376544f, 
    -0.04386877f, -0.00760470f, -0.04803123f, 0.02179109f, -0.02053815f, 0.02841459f, -0.01125327f, -0.00466781f, 
    -0.03086877f, 0.02859505f, -0.05413719f, -0.00632441f, -0.04425276f, -0.04834952f, 0.01499281f, 0.00897493f, 
    0.03089482f, 0.02264031f, -0.01566297f, 0.01651905f, 0.01904356f, -0.03899303f, -0.04027772f, 0.02978017f, 
    0.04369793f, -0.03974092f, -0.05920869f, -0.01567993f, -0.01441901f, -0.03771585f, -0.04404345f, 0.03526427f, 
    -0.09635153f, 0.12560840f, 0.16930453f, -0.03051707f, -0.03464387f, 0.00705016f, 0.06437646f, -0.09382557f, 
    -0.17994697f, -0.09667245f, 0.13836446f, -0.03099756f, -0.17516066f, -0.00255725f, -0.02542032f, -0.13920851f, 
    0.00123176f, 0.14340162f, -0.10660140f, 0.23400445f, 0.10838982f, -0.23058189f, 0.04855780f, 0.09509126f, 
    -0.15388466f, 0.20042504f, -0.21325104f, 0.34907004f, -0.25006992f, -0.03912390f, 0.19840989f, 0.08023465f, 
    0.08835978f, 0.20626649f, -0.12090661f, 0.02448356f, 0.05681936f, -0.38509420f, 0.03975154f, 0.08055199f, 
    0.06369278f, -0.19303700f, 0.08746565f, 0.07326628f, 0.23662823f, -0.02286921f, 0.18563385f, -0.01155196f, 
    0.06450448f, -0.04108926f, 0.06429012f, 0.08175290f, -0.11012249f, -0.13753657f, 0.02925288f, -0.24640547f, 
    0.03582446f, 0.18023932f, 0.08675199f, -0.20907333f, 0.00716184f, -0.14004201f, -0.11608008f, 0.13580719f, 
    -0.15732419f, 0.29455912f, 0.15687773f, -0.15294729f, 0.00284439f, -0.04158765f, -0.01489530f, -0.18537810f, 
    0.29332229f, 0.15736039f, -0.29536387f, 0.02951612f, 0.10291132f, -0.08127301f, 0.12416184f, 0.07651751f, 
    0.18621698f, 0.40351185f, -0.18858610f, 0.29881200f, 0.17231648f, -0.30236092f, -0.16129701f, -0.12415008f, 
    0.01433445f, 0.15222412f, 0.16058549f, 0.09799174f, -0.02910213f, 0.24999045f, 0.02172614f, -0.04782383f, 
    0.10529274f, -0.07708795f, 0.01998210f, 0.11638724f, -0.04743349f, -0.18170244f, -0.13062172f, -0.01010023f, 
    -0.11636935f, 0.05087174f, 0.18161814f, -0.08398742f, -0.17757018f, 0.02972269f, -0.37181112f, 0.10928240f, 
    0.14274706f, -0.21569762f, 0.10121299f, 0.05620135f, 0.04113246f, 0.04342666f, -0.21998261f, -0.05690103f, 
    0.12749110f, -0.02248990f, -0.21906455f, 0.04681433f, 0.06896326f, 0.03819371f, -0.01189366f, -0.06964190f, 
    0.14024001f, 0.01309608f, 0.11181462f, -0.02346577f, -0.01678178f, -0.00597059f, 0.19170792f, 0.25029132f, 
    -0.11198027f, -0.09955661f, 0.26060385f, 0.07764226f, -0.13228913f, -0.05088566f, 0.11355698f, -0.01777883f, 
    0.35411429f, -0.08082359f, -0.15118170f, 0.10182503f, -0.15432192f, -0.07491242f, 0.36102024f, 0.31104723f, 
    0.26356745f, -0.10632104f, 0.09727345f, 0.09123682f, -0.15842278f, -0.11465623f, 0.22373430f, 0.08643302f, 
    -0.02115015f, 0.02506013f, -0.59279567f, -0.00548725f, 0.06003863f, -0.18498535f, -0.11005522f, 0.12472223f, 
    -0.02771771f, 0.04692883f, -0.12120783f, -0.32431850f, 0.16411506f, 0.08015997f, -0.09665386f, -0.05943831f, 
    0.39289820f, -0.04942233f, 0.08247572f, -0.12095760f, -0.16160175f, 0.18140554f, 0.26769206f, -0.10067252f, 
    0.11319661f, 0.31103763f, -0.02886039f, -0.21035357f, 0.04621478f, -0.00729705f, -0.22801617f, 0.01035012f, 
    -0.13460857f, -0.07652711f, 0.06196790f, -0.31239152f, -0.12461868f, 0.23055358f, -0.09864295f, -0.18016645f, 
    0.07325327f, 0.20917475f, 0.06263281f, -0.09556318f, -0.09540600f, -0.00770472f, -0.04400296f, -0.15551659f, 
    -0.09478446f, -0.06141644f, 0.14668779f, -0.24194637f, 0.22922848f, 0.10380712f, -0.09745330f, -0.03462088f, 
    -0.10367619f, -0.18081796f, -0.17667329f, 0.02623927f, -0.01853650f, -0.00601590f, -0.19186363f, -0.11904073f, 
    0.06943743f, -0.14064883f, 0.00399667f, -0.05723601f, 0.21098198f, -0.10162649f, 0.16317371f, -0.13096339f, 
    0.09366009f, -0.01845871f, -0.11967035f, 0.11533543f, -0.14134653f, -0.03688870f, 0.03974193f, -0.02844044f, 
    0.17018278f, -0.01847065f, 0.09284993f, 0.00434028f, 0.21432665f, 0.08769822f, 0.13004242f, 0.02968928f, 
    -0.00037994f, -0.11838974f, 0.15438606f, -0.10982779f, -0.55877918f, 0.18143363f, 0.33003736f, -0.14282446f, 
    0.18644837f, 0.10459346f, -0.15736005f, -0.25267574f, -0.00654222f, 0.02645148f, 0.15672046f, -0.18143855f, 
    0.25410295f, -0.01312440f, -0.04300524f, 0.07575927f, -0.02447529f, 0.01962618f, 0.03784316f, 0.15680948f, 
    0.20218951f, -0.13267036f, 0.12927750f, -0.00499531f, -0.25679085f, 0.03478097f, 0.05960381f, -0.17890860f, 
    -0.06368440f, 0.10814598f, 0.30530298f, 0.03066972f, 0.06990373f, 0.24734198f, -0.05017594f, 0.11237823f, 
    -0.14973457f, 0.29496601f, -0.22849391f, 0.05122840f, -0.19291370f, 0.06959369f, 0.08063507f, 0.15517019f, 
    -0.14963980f, 0.45211914f, 0.02526464f, -0.03732146f, -0.09683145f, 0.16702569f, -0.10291684f, 0.19486077f, 
    0.03784443f, 0.06711601f, 0.13943216f, -0.04815135f, -0.01009331f, 0.37280700f, -0.21964671f, 0.28542820f, 
    0.19595101f, -0.09185842f, -0.24455251f, 0.05696123f, 0.08390215f, -0.25827959f, -0.10278069f, -0.06817512f, 
    0.00131636f, 0.03528316f, 0.13852493f, -0.09022764f, -0.26292589f, -0.29369408f, -0.18157436f, 0.11661969f, 
    0.05345860f, -0.20126496f, -0.03558752f, 0.10867969f, -0.23320915f, 0.31661955f, 0.15794359f, 0.02634464f, 
    0.17321260f, 0.04702885f, 0.21047439f, -0.05552226f, 0.05437715f, -0.17625757f, -0.24430874f, -0.26936838f, 
    -0.28547984f, 0.00537291f, 0.10569029f, 0.08546849f, 0.07831360f, -0.04787616f, -0.24930911f, 0.12651828f, 
    0.28095844f, 0.12585972f, 0.24586523f, 0.03040542f, 0.03546005f, 0.38125268f, 0.10642227f, -0.23412398f, 
    -0.11949599f, 0.06887220f, 0.13957575f, -0.04806585f, 0.14927997f, -0.15134004f, 0.13488549f, 0.04956491f, 
    0.04515198f, 0.38634282f, 0.09900666f, -0.03503148f, 0.10697299f, -0.09585775f, 0.29479635f, -0.14267817f, 
    -0.12810224f, -0.23188907f, -0.08244307f, 0.23176432f, 0.08881873f, 0.13525970f, 0.12784541f, -0.11616302f, 
    0.13753897f, 0.07327782f, 0.23528767f, -0.06061035f, -0.24513325f, 0.10414838f, -0.18034308f, -0.19555815f, 
    -0.02494282f, -0.25205287f, 0.04810296f, -0.15438408f, 0.03830234f, -0.30598915f, 0.00115194f, 0.04855276f, 
    -0.00113631f, -0.15411371f, 0.04451567f, -0.13317133f, -0.03764215f, -0.22204815f, -0.42887345f, -0.33759889f, 
    -0.05858774f, -0.13780132f, -0.18616469f, -0.11873188f, 0.01660794f, -0.11668985f, -0.13997000f, 0.21532710f, 
    -0.19604006f, 0.06557113f, 0.06415723f, -0.08490772f, -0.05574405f, 0.04935277f, 0.21905355f, 0.05036628f, 
    0.21411352f, -0.24344045f, 0.00180700f, 0.03482300f, 0.25353152f, 0.02360491f, 0.12791371f, -0.20111926f, 
    0.06356030f, -0.05078354f, 0.11356562f, -0.16677524f, 0.09134683f, -0.00159590f, -0.01652071f, 0.01928668f, 
    0.08457339f, -0.20688790f, 0.30250683f, 0.32135588f, 0.17703827f, 0.19966891f, 0.25950915f, 0.04541969f, 
    0.14909104f, 0.13291937f, -0.19013613f, -0.07834202f, 0.07121188f, 0.27681914f, -0.18172799f, 0.06953258f, 
    0.05950677f, 0.12184166f, 0.07092667f, -0.32672322f, 0.03441763f, 0.14896245f, 0.00668506f, 0.00656074f, 
    0.20630769f, -0.11691365f, 0.06965044f, 0.12277541f, 0.04714409f, -0.26936105f, 0.21646768f, -0.15661851f, 
    -0.02684697f, 0.15227988f, -0.20366372f, 0.07302400f, 0.50491554f, -0.23480077f, -0.06178027f, 0.28244948f, 
    0.00587346f, -0.23563316f, -0.20449314f, 0.07045233f, 0.02156589f, 0.55469847f, -0.07222918f, 0.02508093f, 
    -0.16528383f, 0.22235335f, 0.15584643f, 0.07607810f, 0.01140559f, -0.04236099f, -0.49100518f, 0.00963732f, 
    -0.09653923f, -0.22281140f, -0.11988362f, 0.26483017f, 0.30155936f, -0.08954153f, -0.04835944f, -0.09250281f, 
    -0.05479376f, 0.19907537f, -0.08948447f, 0.00789138f, -0.03947870f, -0.20007409f, 0.21520117f, 0.16475956f, 
    -0.01942063f, 0.13253880f, 0.11917872f, -0.10476127f, -0.17354956f, -0.00394463f, 0.17553012f, 0.00895966f, 
    0.01129612f, -0.22340645f, -0.20144972f, -0.23091362f, -0.20064405f, -0.12046260f, 0.08993608f, 0.04979308f, 
    0.05316484f, -0.01665560f, -0.16611204f, 0.01439926f, -0.00115745f, -0.10714688f, 0.29882336f, 0.02066733f, 
    0.05674650f, 0.10873272f, -0.07083267f, -0.31140634f, -0.14095202f, -0.13687307f, -0.02247330f, 0.13338760f, 
    -0.04927950f, 0.08726095f, -0.00899002f, 0.05352848f, 0.11149195f, 0.13874756f, 0.05031527f, 0.12129346f, 
    0.00159147f, 0.04441648f, -0.00207143f, -0.02802220f, -0.14047933f, -0.00067789f, -0.00397912f, -0.12828568f, 
    0.14049646f, 0.12676698f, -0.03491903f, -0.06768263f, -0.13169463f, 0.22826903f, 0.11536437f, -0.14623912f, 
    -0.29458141f, 0.18233256f, 0.08073480f, 0.07654120f, 0.18710494f, -0.14054981f, 0.03498683f, 0.16037883f, 
    0.26276711f, 0.00106794f, 0.00450390f, -0.22954965f, -0.07790143f, -0.10465685f, 0.11309025f, -0.20011526f, 
    -0.19843549f, 0.06907967f, 0.07159622f, -0.32605872f, 0.00177408f, 0.08676194f, -0.09952179f, 0.14206967f, 
    0.00047051f, -0.27655217f, 0.19687328f, -0.12418929f, 0.03311367f, -0.17420974f, 0.18686564f, -0.00324194f, 
    0.14954294f, -0.02417509f, 0.18131447f, -0.53462857f, 0.19878666f, 0.13099308f, -0.18671185f, -0.15601686f, 
    -0.12751359f, 0.10139202f, 0.08317425f, -0.05196355f, -0.34051809f, 0.40294707f, 0.18279767f, 0.00361796f, 
    0.04194700f, -0.23982684f, -0.05232088f, 0.06085778f, 0.07067827f, -0.01276853f, -0.03899637f, -0.38336033f, 
    0.11841837f, 0.03281466f, 0.18420057f, 0.14722236f, -0.03028061f, -0.04473173f, -0.04363406f, -0.01168812f, 
    -0.11870394f, 0.03226820f, -0.06343292f, 0.04197618f, 0.02677738f, -0.06683059f, 0.02613254f, -0.06454396f, 
    0.17547925f, -0.40837789f, 0.02553435f, -0.16949043f, 0.03645919f, 0.07905820f, -0.15675941f, -0.41026545f, 
    -0.02834062f, 0.11908854f, -0.15200615f, 0.21611245f, 0.10025611f, -0.38065547f, -0.17446610f, -0.04381271f, 
    0.15586996f, 0.12656735f, 0.42849320f, -0.06911536f, -0.19649620f, 0.07141571f, -0.02912107f, 0.14781293f, 
    0.10108134f, 0.12781470f, -0.03505005f, 0.02315991f, -0.11319462f, 0.04529309f, 0.00693915f, -0.20062879f, 
    -0.13449442f, 0.13017096f, -0.16599804f, -0.22250769f, 0.19967613f, 0.11501760f, -0.22071658f, 0.06314395f, 
    -0.33255705f, -0.01808886f, 0.11313525f, 0.01565488f, -0.40807065f, -0.02985187f, 0.21060568f, 0.09241514f, 
    -0.10295980f, -0.12178659f, -0.07375484f, 0.19795597f, 0.08889327f, 0.14050451f, 0.07488758f, -0.10338867f, 
    0.25628033f, 0.00277777f, -0.01540718f, -0.06823164f, 0.01480138f, 0.11520110f, -0.15300748f, 0.05857339f, 
    -0.05938910f, -0.04722969f, 0.04466188f, 0.00623386f, -0.07196468f, 0.06896333f, -0.10515374f, 0.10420653f, 
    0.00502399f, 0.05067468f, -0.00409011f, 0.23073918f, -0.14529027f, -0.15232791f, -0.05922562f, -0.02288524f, 
    0.01143381f, -0.09796529f, 0.17482758f, -0.04380949f, -0.27547184f, -0.10209868f, -0.04226091f, -0.05067945f, 
    0.05447136f, -0.19338502f, 0.10119870f, 0.12166958f, 0.11295317f, -0.01389903f, -0.01501627f, 0.11346301f, 
    -0.04110862f, 0.04489104f, 0.17278652f, 0.05964305f, 0.18509322f, 0.15576866f, 0.09366351f, 0.14071545f, 
    0.00130225f, -0.04177465f, 0.00472649f, 0.15791878f, -0.01518734f, 0.66521561f, 0.14650321f, 0.08769071f, 
    0.00188997f, -0.03245480f, 0.11361921f, 0.00710526f, 0.08811134f, 0.23907563f, 0.26003537f, -0.08247254f, 
    0.07025620f, 0.25727832f, 0.02446775f, -0.08444594f, 0.08569974f, -0.14008264f, 0.14489190f, 0.21473473f, 
    0.01074123f, -0.11065196f, 0.06312472f, 0.07600316f, 0.06098090f, -0.35745451f, -0.07452355f, 0.06327254f, 
    -0.40329468f, 0.01246690f, 0.06199882f, 0.06184898f, -0.10242859f, -0.09597971f, 0.13784064f, 0.22062287f, 
    -0.07377533f, -0.31742507f, 0.03041804f, 0.06769859f, -0.04622490f, -0.05967751f, -0.05851518f, 0.06689689f, 
    -0.51674336f, 0.08037473f, -0.08630767f, -0.13382997f, -0.10547086f, -0.29589814f, 0.12439334f, 0.14873096f, 
    0.09172741f, -0.07222534f, 0.02845010f, -0.25102985f, 0.10761320f, 0.00785418f, 0.07292303f, 0.00025866f, 
    0.28968337f, -0.00314055f, -0.05431283f, -0.10806864f, -0.01514117f, -0.06810592f, -0.01196091f, -0.11004908f, 
    0.07930344f, 0.13167261f, 0.02142965f, 0.19671319f, -0.13629897f, -0.10268559f, 0.04572814f, 0.01699444f, 
    0.20668645f, 0.07667088f, -0.20406297f, -0.00074104f, -0.18163307f, 0.32332894f, 0.26633933f, -0.03186323f, 
    -0.08057886f, 0.06128476f, 0.15459466f, -0.15606464f, 0.11380698f, -0.18181032f, -0.00698382f, 0.08615626f, 
    -0.17084381f, -0.02114305f, -0.08241609f, -0.04705859f, 0.22556084f, -0.05409056f, -0.15220867f, 0.02576379f, 
    0.18380113f, 0.05474203f, -0.05100583f, 0.19829072f, -0.12161902f, -0.17130795f, -0.11590901f, 0.10807827f, 
    -0.01924817f, 0.37858534f, 0.36836639f, 0.08601526f, 0.07227022f, -0.10407268f, -0.16016826f, -0.09169878f, 
    -0.10846760f, -0.19915302f, -0.05313804f, 0.01630528f, 0.08066001f, -0.20497879f, 0.06803048f, -0.08342410f, 
    -0.15975983f, -0.45211112f, 0.14017110f, -0.25456098f, 0.08343562f, 0.03947124f, 0.01611329f, -0.10484879f, 
    -0.09516708f, -0.14563404f, -0.43723771f, -0.20923080f, -0.07476557f, 0.13421421f, 0.17952886f, 0.18915306f, 
    -0.04768342f, 0.02465515f, -0.02233637f, 0.79896462f, -0.38197342f, 0.03212335f, -0.01196112f, -0.00886910f, 
    -0.04355161f, 0.10330926f, 0.06593081f, -0.01674634f, 0.40695029f, 0.06284028f, 0.21308099f, 0.00113258f, 
    -0.01338426f, 0.16193815f, 0.09528976f, 0.13253680f, -0.04457906f, -0.15910262f, 0.14090131f, -0.15900911f, 
    -0.08893906f, 0.06584807f, -0.09755470f, -0.10505605f, 0.07947367f, 0.01279213f, 0.16662304f, -0.01786221f, 
    0.01059809f, -0.10111517f, -0.10503244f, -0.06407657f, 0.14163834f, 0.07233261f, 0.12218302f, 0.23172410f, 
    -0.03839947f, 0.01490292f, -0.27458712f, 0.13949105f, 0.20529634f, -0.15643685f, -0.08395620f, 0.02265828f, 
    0.09142599f, -0.09817691f, 0.06313543f, 0.03492659f, 0.00539703f, 0.03071678f, -0.05431857f, -0.00265223f, 
    -0.24188375f, 0.22308041f, -0.66764623f, 0.18710005f, 0.00615599f, 0.09695693f, -0.23887268f, 0.15171398f, 
    -0.09716329f, -0.08678931f, -0.15498391f, -0.15799546f, -0.25295946f, -0.06551470f, -0.29316357f, 0.17011495f, 
    -0.02355584f, -0.07906076f, -0.10313262f, -0.04656674f, -0.11999909f, 0.10830688f, 0.29103968f, -0.08759636f, 
    -0.04311161f, 0.10739146f, -0.03462043f, -0.19281019f, 0.12031275f, 0.13569278f, -0.16255520f, -0.21205826f, 
    -0.00731069f, 0.13940550f, 0.11006595f, 0.10763648f, -0.02772604f, 0.48896912f, 0.06459329f, 0.25074050f, 
    0.04413813f, -0.02787475f, 0.08309778f, 0.26139969f, 0.35581970f, 0.17630379f, 0.51085240f, -0.03114773f, 
    0.05043342f, 0.11420126f, -0.05245714f, 0.14702566f, 0.08277022f, -0.09218614f, 0.10157548f, 0.14457180f, 
    -0.10009798f, -0.08919849f, 0.03327326f, 0.18377875f, 0.14079916f, 0.04189169f, -0.23799109f, 0.24669833f, 
    0.22227751f, 0.18560243f, -0.37572810f, 0.05313499f, 0.04089749f, -0.17461723f, 0.00739498f, 0.06816227f, 
    -0.08226966f, -0.36262038f, 0.11779394f, -0.15188655f, 0.03231604f, 0.09786024f, -0.00299446f, -0.19077857f, 
    0.16684395f, -0.06012883f, -0.41042411f, 0.22103932f, 0.08496985f, -0.24912962f, -0.07161511f, 0.08598787f, 
    0.02205660f, 0.03300995f, 0.06717678f, -0.10502563f, 0.27275229f, -0.23630323f, 0.13365516f, 0.11954781f, 
    -0.02653802f, -0.10600135f, 0.09715781f, 0.11907516f, -0.02143166f, -0.03149803f, 0.05675297f, 0.00756103f, 
    0.26647136f, -0.04689278f, -0.38230032f, -0.03907410f, 0.03079925f, -0.17655188f, 0.28011340f, -0.01671238f, 
    -0.11960817f, 0.05089474f, -0.05370593f, -0.24980049f, -0.05478353f, -0.32922742f, 0.20621105f, 0.05397853f, 
    -0.06992526f, -0.13722447f, -0.03877247f, -0.07173034f, 0.13073614f, -0.09489260f, -0.02246105f, -0.54532796f, 
    -0.18068050f, -0.12129057f, 0.13144153f, 0.08576702f, -0.08723333f, -0.00356919f, 0.16901274f, -0.01446062f, 
    0.21493113f, -0.11614215f, 0.15263954f, 0.10686212f, -0.07539451f, 0.06460532f, 0.14339177f, -0.28661099f, 
    0.08677368f, 0.02266677f, -0.03309448f, 0.02577653f, 0.02722616f, 0.07602044f, 0.12759979f, 0.11051328f, 
    -0.13917552f, 0.13023734f, -0.30963030f, 0.23328081f, 0.01788180f, -0.02185623f, -0.22624937f, -0.07264297f, 
    0.18505332f, 0.19088884f, -0.06672215f, -0.41537309f, -0.04864634f, -0.04780597f, 0.14051196f, 0.15345807f, 
    0.18238485f, 0.19776127f, 0.05066982f, -0.12516618f, -0.19385605f, -0.17404214f, 0.03183376f, -0.16539837f, 
    0.11882441f, -0.04238435f, -0.19101040f, 0.17703992f, -0.00962708f, -0.12415385f, -0.02344490f, -0.21121788f, 
    -0.22236229f, 0.07153101f, 0.12545311f, 0.00757022f, -0.05510353f, -0.31459221f, 0.08790024f, -0.02135509f, 
    -0.19500890f, 0.00024858f, 0.12367672f, 0.09882630f, -0.06294805f, 0.11486141f, -0.25410286f, 0.15102726f, 
    0.24454848f, -0.00614635f, -0.06380042f, -0.19744945f, -0.10055444f, 0.42043108f, 0.20747212f, 0.21479845f, 
    -0.16562553f, 0.14181733f, -0.23331414f, -0.19671451f, -0.04117228f, -0.05156708f, 0.14753000f, 0.05587466f, 
    -0.00136796f, 0.44991195f, -0.16242647f, 0.02504238f, -0.25656050f, 0.18356109f, -0.17148529f, -0.06005334f, 
    0.00946432f, 0.24034567f, 0.08452555f, 0.09288924f, 0.04199664f, 0.12647766f, 0.18473861f, 0.19929487f, 
    0.07153694f, 0.22074810f, -0.11812200f, -0.25346977f, 0.05844885f, -0.05484564f, 0.19359006f, 0.18212116f, 
    -0.14461043f, -0.29207689f, 0.08228251f, 0.06489723f, -0.55788249f, -0.19074225f, 0.14021626f, 0.13169494f, 
    -0.04999409f, -0.20995480f, 0.05931853f, 0.03170619f, 0.13331662f, 0.09552713f, 0.13221963f, -0.47743505f, 
    0.11391673f, -0.02757419f, 0.03455986f, 0.03194148f, -0.05016917f, -0.09721903f, -0.46455571f, -0.17494135f, 
    -0.11067899f, -0.03974563f, -0.07994693f, 0.20187844f, 0.16290540f, -0.14859740f, 0.01425818f, -0.23142423f, 
    -0.08197165f, 0.02775769f, 0.09804378f, -0.01235668f, 0.02985203f, 0.06622996f, 0.05531031f, 0.09228083f, 
    0.56435442f, 0.08114642f, 0.04889711f, 0.08676520f, 0.18022321f, -0.16550559f, -0.21119906f, 0.16775624f, 
    0.01244781f, 0.18467931f, 0.05667714f, -0.34144789f, -0.07766783f, -0.25464132f, 0.17590462f, -0.07237409f, 
    0.07828800f, -0.22550888f, 0.31536570f, 0.09886923f, 0.13129403f, -0.17130935f, 0.06610058f, 0.01904938f, 
    -0.11716084f, -0.04465653f, 0.06151501f, -0.10896605f, -0.23540795f, -0.09918199f, 0.08427627f, 0.15977463f, 
    -0.14710318f, -0.34559742f, -0.01331663f, 0.32360342f, 0.01973815f, 0.03699400f, 0.09726055f, -0.02762176f, 
    -0.12998861f, 0.09388380f, -0.20233700f, -0.15660101f, 0.21460596f, -0.52881950f, 0.08092453f, -0.12114643f, 
    0.20021783f, -0.06967022f, 0.07720589f, -0.12506637f, 0.03447798f, 0.02546342f, -0.03724466f, 0.42296323f, 
    0.12182783f, 0.12299523f, -0.03383643f, -0.06068917f, 0.03403208f, -0.06861521f, 0.17567471f, -0.27152330f, 
    -0.04112991f, 0.22518791f, 0.02647729f, 0.04863397f, 0.01710607f, 0.04337863f, -0.01243429f, 0.01042058f, 
    0.10347308f, 0.08823624f, 0.33742166f, 0.09379382f, -0.06077100f, -0.05145816f, 0.09378323f, -0.03542716f, 
    0.22088940f, 0.08185184f, -0.03099294f, 0.31740668f, 0.02172593f, 0.15647025f, 0.16895381f, -0.06487320f, 
    0.06391308f, 0.04629643f, 0.05328630f, 0.11058119f, -0.14077301f, -0.04563608f, 0.06299104f, 0.15210578f, 
    -0.05807075f, 0.03071967f, -0.08520628f, 0.19523884f, -0.36329299f, 0.04673734f, 0.00144055f, -0.17498760f, 
    0.14497042f, 0.06180535f, 0.03301239f, 0.07853462f, 0.13887689f, -0.05591718f, 0.10662039f, -0.09352143f, 
    0.16180696f, 0.23438810f, -0.21136381f, -0.11472686f, 0.05159441f, 0.12053013f, 0.13992307f, 0.01537745f, 
    -0.37430653f, -0.43915623f, 0.28419441f, -0.07813862f, -0.01404831f, 0.13058671f, -0.46852884f, 0.03377659f, 
    0.05422940f, 0.08813150f, -0.04771703f, 0.29374254f, 0.18736418f, 0.00130170f, -0.01261745f, -0.32535505f, 
    -0.01200600f, 0.05346546f, 0.10076194f, 0.05896473f, 0.14381051f, -0.01103984f, 0.03038595f, -0.01566554f, 
    -0.30164954f, 0.03822491f, 0.06143807f, -0.21040341f, 0.14340241f, -0.25625348f, -0.08739764f, -0.01749701f, 
    0.10167588f, 0.23589498f, 0.16194130f, -0.51378018f, 0.16237910f, -0.41557473f, -0.06037374f, 0.01910082f, 
    0.04275602f, 0.04063773f, -0.05151765f, -0.18069282f, 0.00694762f, -0.29921523f, -0.00012021f, -0.00698819f, 
    0.02012881f, 0.07755270f, -0.30145410f, 0.03729195f, 0.03095430f, -0.09410985f, 0.11805262f, 0.01719010f, 
    0.03085185f, 0.03381805f, 0.16407058f, -0.11990240f, -0.07029558f, -0.14447826f, -0.23411275f, 0.01382532f, 
    0.09879833f, 0.14020789f, 0.05384073f, 0.19136269f, -0.00808202f, 0.21741900f, 0.11979242f, 0.07311200f, 
    -0.08980017f, -0.09559140f, 0.22351640f, -0.18863013f, -0.18349838f, 0.12024862f, -0.09526883f, 0.10402702f, 
    0.12938410f, 0.04813361f, -0.13208158f, 0.07636581f, 0.11776019f, 0.03361702f, 0.10884733f, 0.06249526f, 
    0.05289459f, 0.17966677f, 0.11442960f, -0.00198552f, 0.34714893f, 0.22943045f, -0.00189152f, -0.03759003f, 
    0.04159958f, -0.09341957f, -0.42643410f, -0.04864259f, 0.05168113f, -0.12955464f, 0.04470750f, 0.02105994f, 
    -0.12772134f, -0.14378223f, -0.07553999f, -0.13580751f, -0.02084596f, 0.13486905f, 0.11743843f, -0.16335346f, 
    -0.01117781f, 0.05247638f, -0.07818418f, -0.37318063f, 0.13788347f, 0.14712144f, -0.02459651f, 0.00413729f, 
    -0.12675551f, 0.09500273f, 0.04698978f, -0.14815316f, 0.34793669f, 0.19431901f, 0.19610488f, -0.18574329f, 
    -0.00301206f, -0.04983898f, 0.03980698f, 0.16217433f, 0.04407023f, -0.18002617f, -0.40431872f, 0.15633249f, 
    0.03678180f, -0.26513571f, 0.06670626f, 0.00232849f, 0.00645081f, 0.19034259f, 0.08198282f, -0.03139358f, 
    -0.00411207f, -0.01976028f, 0.09839653f, -0.08006874f, 0.01797395f, 0.36552590f, -0.01333963f, -0.01606356f, 
    0.28125325f, 0.03057226f, 0.00957137f, -0.14291662f, -0.13988598f, 0.03167646f, 0.00231949f, -0.12862216f, 
    0.10350672f, -0.07039046f, -0.08761834f, 0.16162308f, -0.06142253f, -0.01401658f, 0.07167373f, 0.21617614f, 
    -0.41008034f, 0.00239449f, -0.12986445f, -0.00108733f, -0.15449797f, -0.12730490f, -0.12721393f, 0.21787465f, 
    0.04886960f, -0.35163373f, 0.21178241f, -0.19731073f, -0.16190699f, -0.10003421f, 0.01629012f, 0.02185877f, 
    0.04416405f, 0.23331301f, 0.00473364f, -0.13053918f, -0.19792315f, -0.13481642f, -0.18799955f, 0.01464106f, 
    -0.21816577f, -0.29065683f, -0.21253838f, -0.11574328f, 0.08451039f, -0.01230309f, 0.12870818f, 0.00963220f, 
    0.10118702f, -0.08682819f, -0.01584724f, -0.16354418f, 0.25303176f, 0.24130136f, 0.35499278f, 0.23057462f, 
    0.08503641f, -0.06719410f, -0.12388963f, 0.00745161f, -0.02055510f, -0.14934893f, -0.22462642f, -0.33299011f, 
    0.04168892f, 0.07710068f, -0.00733341f, -0.15400840f, -0.14196689f, -0.03756374f, 0.05813744f, -0.26206025f, 
    -0.22838649f, -0.38577881f, -0.12037031f, 0.02778001f, -0.35074237f, 0.06279042f, 0.09649964f, 0.56073648f, 
    0.03783248f, -0.11091720f, -0.06966301f, -0.02962903f, -0.04946296f, -0.06808630f, 0.01028782f, -0.09823391f, 
    0.38605353f, -0.07311248f, 0.01623742f, -0.14044960f, -0.17116275f, -0.06897835f, -0.24141607f, -0.11654257f, 
    -0.16432776f, -0.12439130f, -0.15438527f, 0.09432131f, -0.07771908f, 0.02714449f, 0.14970420f, -0.16635934f, 
    0.15408207f, 0.07563614f, 0.10637451f, 0.17805991f, 0.32235146f, 0.10350198f, 0.16368696f, 0.08759326f, 
    -0.28524187f, -0.09570967f, 0.14577648f, 0.23004057f, -0.20448378f, 0.31835935f, -0.01925321f, 0.12227790f, 
    -0.12436752f, -0.00196573f, 0.14621253f, 0.23331162f, -0.21157879f, 0.20162420f, 0.08697307f, 0.09804228f, 
    0.07871495f, -0.27687597f, -0.00643234f, -0.02484245f, 0.05455453f, -0.31716758f, 0.16798179f, 0.32571885f, 
    0.13377483f, 0.10395567f, 0.09697084f, -0.23877147f, 0.32608029f, -0.24319676f, 0.02963761f, -0.21050623f, 
    0.16005492f, -0.12275251f, -0.18940577f, -0.22135228f, 0.18998577f, 0.06365243f, 0.02157969f, 0.32504877f, 
    0.28466472f, -0.13633583f, -0.12608126f, -0.04848465f, 0.00180868f, -0.26439092f, -0.04704070f, -0.07815281f, 
    0.13212512f, 0.16894627f, -0.08016823f, 0.27032244f, -0.14547616f, 0.08369356f, -0.06052608f, 0.04906281f, 
    -0.00589218f, -0.32277280f, 0.04960839f, -0.34145844f, -0.05674627f, -0.25961134f, 0.12595230f, -0.06381665f, 
    0.01114147f, 0.08455511f, 0.49987283f, 0.16148680f, 0.23113881f, -0.25939146f, -0.18008451f, 0.05626065f, 
    -0.08321613f, 0.01205129f, -0.00799606f, -0.15996644f, -0.14385167f, 0.13895719f, 0.11236793f, -0.09177921f, 
    -0.04335945f, -0.13192630f, 0.07250698f, 0.04138073f, 0.33894444f, 0.38684687f, 0.27393240f, -0.00443798f, 
    0.10940808f, 0.21247646f, 0.20688522f, -0.10523205f, 0.19701844f, 0.02042134f, 0.17962025f, 0.00634553f, 
    0.03328076f, -0.00650693f, -0.08944686f, -0.13796636f, -0.03601291f, 0.02225292f, 0.11161598f, 0.08970123f, 
    0.20927000f, -0.00785911f, 0.26676172f, -0.00873221f, -0.01609251f, 0.12681605f, -0.28289372f, -0.11238579f, 
    0.00444202f, 0.42759651f, 0.05792044f, 0.12392558f, -0.02741314f, 0.00143555f, -0.08861618f, 0.05705967f, 
    0.01481072f, 0.03668788f, -0.02314490f, -0.00042640f, 0.00316005f, 0.04155992f, 0.02217659f, 0.03124431f, 
    0.03784274f, 0.04841588f, -0.03529112f, -0.00921177f, -0.06564013f, -0.03332248f, 0.00693442f, -0.06716271f, 
    0.01556478f, -0.04520616f, -0.02733158f, -0.04030765f, 0.00508445f, 0.02773163f, -0.02597344f, -0.05338096f, 
    0.02191037f, -0.04307651f, -0.03617655f, -0.04499778f, 0.02689536f, 0.01136287f, -0.02697786f, 0.04369944f, 
    -0.04316055f, -0.06299981f, 0.02302221f, -0.06239941f, -0.00922062f, 0.01781694f, -0.00040894f, -0.00034076f, 
    0.01937891f, 0.05177981f, -0.04513809f, -0.02469162f, -0.04827756f, -0.04801821f, -0.01779563f, -0.00819559f, 
    -0.06080516f, 0.03448642f, 0.04581806f, -0.06102643f, 0.03008557f, -0.02444240f, 0.06114666f, -0.02670270f, 
    0.00878501f, 0.03601288f, -0.05189874f, -0.03087661f, -0.04169010f, 0.04983290f, 0.04388893f, -0.02413497f, 
    0.04475889f, 0.03710856f, -0.03218471f, 0.03159305f, -0.04397991f, -0.05756573f, -0.02625252f, 0.04312925f, 
    -0.05029251f, -0.01897602f, -0.01233751f, -0.00324427f, 0.01247403f, 0.04388874f, -0.03534671f, 0.01925353f, 
    0.04409053f, -0.01511515f, -0.02594370f, -0.04047465f, 0.04301751f, 0.01477660f, -0.05533481f, 0.03799134f, 
    -0.04493237f, 0.00411276f, -0.03031975f, 0.00546646f, -0.05262827f, -0.01460878f, -0.00528163f, -0.01803752f, 
    0.02078562f, 0.00695363f, 0.02968852f, 0.03717835f, 0.02625571f, -0.02902641f, -0.05874877f, 0.04070531f, 
    -0.03240377f, 0.04668575f, 0.03384558f, -0.06355684f, -0.06486589f, 0.01951689f, -0.03524204f, 0.01446380f, 
    0.04709465f, -0.02517959f, 0.01820066f, -0.05554358f, -0.04661812f, -0.03050853f, -0.01915481f, -0.00130729f, 
    -0.04139866f, 0.01803328f, 0.03112621f, -0.03685297f, 0.01563587f, -0.04975702f, -0.04159820f, 0.00683502f, 
    -0.04020788f, -0.02372404f, 0.02678992f, 0.03605279f, 0.03554482f, -0.00302255f, -0.03228079f, 0.00177446f, 
    -0.05865633f, -0.05785734f, 0.00229252f, -0.00683009f, 0.01430212f, -0.03893178f, -0.04362539f, 0.04672226f, 
    -0.05459209f, -0.02510783f, -0.02439326f, -0.05180435f, 0.02572434f, -0.05845381f, 0.02351372f, -0.00238476f, 
    -0.00315275f, -0.04332838f, -0.06347719f, 0.01169959f, 0.00296510f, -0.02093859f, 0.00618206f, -0.05612873f, 
    -0.02606723f, -0.04066228f, -0.05977269f, -0.00557463f, 0.00674382f, 0.01704118f, -0.03920106f, -0.02679613f, 
    -0.06157508f, -0.06878731f, 0.02547851f, -0.00337387f, 0.01262178f, 0.05094454f, -0.05754451f, -0.00362956f, 
    0.02572181f, -0.00461028f, 0.03427583f, 0.02357253f, -0.04597776f, 0.02643073f, -0.04470472f, -0.06664905f, 
    -0.06682353f, -0.01893568f, -0.04202895f, -0.01649835f, -0.00858022f, 0.03784546f, -0.03450735f, -0.02230077f, 
    -0.05322950f, 0.04412025f, 0.03978438f, 0.03016601f, 0.03773795f, 0.03119826f, -0.03073423f, -0.03326861f, 
    -0.02669424f, -0.01416069f, -0.00463739f, -0.01958489f, 0.02146041f, 0.00731365f, 0.04610240f, -0.01443008f, 
    -0.03501501f, 0.02931201f, 0.04428449f, 0.02358634f, -0.05683257f, 0.02881834f, -0.02666058f, 0.05297131f, 
    0.03841575f, -0.03721124f, -0.03071487f, 0.00217062f, 0.04774399f, 0.04125647f, 0.01673005f, -0.04956933f, 
    -0.02669744f, 0.01501205f, -0.00871186f, -0.05113827f, 0.02368433f, -0.03173643f, -0.03911988f, -0.01103881f, 
    0.04096966f, -0.01233319f, -0.00283121f, 0.00556304f, -0.05766939f, 0.01908188f, -0.05029667f, 0.04190233f, 
    0.00615450f, 0.04549684f, -0.05940109f, 0.04956611f, 0.00497306f, -0.05087040f, -0.00609828f, -0.00326260f, 
    -0.05512789f, 0.02891711f, 0.02683884f, -0.03241197f, -0.01626395f, 0.03200278f, -0.05157170f, 0.00789286f, 
    0.01822298f, -0.04988961f, -0.05019512f, 0.03916662f, -0.06595778f, 0.04348289f, -0.05523389f, -0.04429875f, 
    0.00984338f, 0.04779726f, -0.03179281f, -0.05632086f, -0.01025910f, -0.00961364f, 0.02705913f, -0.02301656f, 
    -0.06806020f, -0.06579094f, 0.02533752f, 0.03714308f, 0.02800964f, 0.03656784f, -0.03547002f, -0.06547130f, 
    -0.02908773f, 0.04921309f, -0.01706890f, 0.04113797f, -0.03317516f, -0.03367868f, 0.00301845f, 0.05029105f, 
    -0.05370719f, -0.07410709f, 0.03331423f, -0.00439584f, 0.01242571f, -0.00925453f, 0.03613488f, -0.02608235f, 
    -0.04804331f, 0.01357737f, -0.05220919f, 0.02019450f, -0.00914063f, -0.00898409f, -0.02415689f, -0.00456343f, 
    -0.03811682f, -0.05922505f, -0.00326212f, -0.04460998f, 0.03601407f, 0.03413845f, 0.02341529f, -0.02073212f, 
    -0.05647527f, -0.00969010f, 0.03819376f, 0.00972359f, -0.02466776f, 0.04449892f, -0.00549807f, 0.04174697f, 
    0.00707403f, -0.02181861f, -0.01638491f, 0.01467970f, -0.03600413f, 0.01894954f, -0.03855288f, 0.04600753f, 
    -0.02109226f, -0.03347468f, 0.00943244f, 0.03870115f, 0.01825091f, -0.04919344f, -0.02093846f, -0.02316010f, 
    0.02241194f, -0.07137705f, -0.05731290f, 0.02111129f, -0.01364475f, -0.05410677f, 0.00784444f, -0.00895143f, 
    0.00162570f, -0.02236925f, -0.04095279f, 0.04017602f, 0.03619003f, -0.03841658f, 0.04095325f, -0.02462424f, 
    0.04340914f, -0.00001074f, 0.00865964f, -0.00949322f, 0.02440654f, -0.03598453f, 0.04446597f, -0.06472736f, 
    0.00215258f, 0.01932211f, 0.02439053f, -0.05640751f, -0.06581053f, -0.00270577f, 0.02139531f, -0.02429356f, 
    -0.03385963f, -0.01979091f, -0.00935341f, 0.02249711f, -0.03539385f, 0.03524154f, 0.04747470f, 0.02378700f, 
    0.00710025f, -0.05839458f, 0.05223665f, 0.02030027f, 0.04629414f, -0.00705335f, -0.02244775f, -0.04666590f, 
    -0.05165559f, -0.05419680f, -0.03298414f, -0.03173710f, 0.00964394f, -0.00460516f, -0.06264893f, 0.03593327f, 
    0.03565529f, -0.01284853f, -0.05420297f, -0.03544110f, -0.03876344f, -0.01889931f, -0.05886101f, -0.05895303f, 
    -0.04903269f, 0.04212908f, -0.02802588f, 0.00089833f, -0.05762453f, 0.04805398f, 0.01316460f, 0.02434906f, 
    0.01225039f, 0.01446554f, -0.00878691f, 0.04542541f, 0.03461787f, -0.06105860f, -0.01791475f, -0.01023519f, 
    0.04317782f, -0.00650664f, 0.04024577f, -0.01281627f, 0.01304890f, 0.01841558f, -0.03408333f, 0.02567692f, 
    0.01635961f, -0.04650440f, 0.00181144f, -0.02192403f, -0.05983852f, -0.05187751f, 0.00756702f, 0.02940496f, 
    0.00230726f, 0.00950832f, -0.02428170f, 0.00098081f, -0.01299412f, 0.03829385f, -0.04252254f, -0.00919683f, 
    -0.01559718f, 0.03990866f, -0.03581721f, 0.01347333f, 0.03492803f, 0.01441793f, -0.04221188f, 0.00483808f, 
    -0.03586154f, 0.00204070f, -0.02615038f, 0.04081924f, -0.01349492f, -0.05684935f, 0.02492613f, 0.04524453f, 
    -0.04774408f, -0.05656930f, -0.01815121f, -0.02466249f, -0.02498922f, 0.04373940f, -0.04585864f, -0.04942871f, 
    0.04334660f, -0.06047997f, -0.02774432f, -0.01023659f, -0.00608500f, -0.03862420f, 0.00426621f, -0.03867345f, 
    -0.03256771f, 0.04847828f, 0.01521098f, -0.03810826f, 0.03252403f, -0.02753006f, 0.01993558f, 0.00684054f, 
    0.00353084f, -0.00682731f, -0.04362380f, -0.03248854f, -0.06690184f, -0.00118124f, 0.01876513f, 0.01080054f, 
    -0.04018056f, 0.02634775f, -0.06240757f, -0.00818188f, -0.00387119f, -0.02551040f, -0.02360267f, 0.02060983f, 
    -0.02689753f, -0.02138450f, -0.06157048f, 0.03313965f, 0.01213681f, 0.00087688f, 0.01265020f, 0.04443284f, 
    0.03517650f, -0.03419089f, 0.01305746f, -0.06263427f, 0.00457731f, -0.03653679f, -0.01905994f, -0.05901613f, 
    0.02055808f, 0.05229097f, 0.01692256f, 0.03416349f, -0.03639659f, 0.01653683f, -0.02589253f, -0.03316222f, 
    -0.05565960f, 0.01567562f, 0.01038237f, -0.03013874f, -0.02782532f, -0.01418492f, -0.00341374f, -0.01826198f, 
    -0.00324135f, 0.03604954f, 0.00835326f, -0.04079085f, -0.04559201f, -0.04480840f, 0.02701007f, -0.06789289f, 
    0.02354476f, 0.00357197f, -0.01336439f, -0.02788158f, 0.00812757f, 0.02074973f, 0.02509231f, 0.01411279f, 
    -0.02804856f, 0.03231521f, -0.00255593f, 0.01151208f, -0.01244964f, -0.00930206f, 0.03336374f, 0.02198509f, 
    -0.05112519f, 0.00409416f, 0.00842714f, -0.05350274f, -0.04854188f, -0.04321662f, -0.01611397f, 0.05385429f, 
    -0.01630152f, -0.04501037f, -0.04823586f, -0.00476017f, 0.01326855f, -0.00011508f, -0.05644653f, 0.02498660f, 
    0.03320476f, 0.01037735f, -0.00781133f, 0.04354534f, 0.04110593f, 0.01410823f, 0.00500272f, 0.01644929f, 
    0.32510504f, -0.16666068f, 0.21064988f, -0.10463730f, -0.20000213f, 0.10807823f, -0.06323142f, 0.10502071f, 
    -0.14105004f, -0.08858000f, -0.17432405f, -0.11226568f, 0.18730460f, -0.15248141f, -0.06873371f, -0.20659934f, 
    -0.02681584f, -0.07614008f, -0.06907506f, -0.57169491f, 0.02350289f, 0.13050348f, 0.10403628f, 0.08889567f, 
    0.09723783f, -0.06688414f, 0.20453055f, -0.40000340f, -0.23071069f, 0.09327994f, 0.00064246f, -0.19360979f, 
    -0.13298447f, 0.10628070f, -0.06503868f, -0.21733284f, 0.03823698f, 0.35798907f, 0.19408479f, -0.26102707f, 
    -0.06806178f, -0.03826127f, -0.07631187f, 0.11757499f, -0.19943406f, 0.52154201f, -0.36865368f, -0.75679529f, 
    -0.03638983f, 0.06731194f, -0.13831286f, 0.14031568f, -0.02088935f, 0.16235949f, -0.17947195f, 0.20496523f, 
    0.40730155f, 0.05852563f, 0.03917102f, 0.05054279f, 0.08367193f, 0.13951671f, 0.04926394f, -0.03316753f, 
    0.00577522f, 0.39142537f, 0.05049268f, 0.05987838f, 0.10582221f, -0.05918894f, -0.00934911f, 0.09370366f, 
    -0.23284929f, -0.05288772f, -0.07072837f, 0.26019087f, -0.00700445f, -0.17963336f, -0.04697842f, 0.01529864f, 
    0.04405084f, -0.03928633f, -0.14215374f, 0.20678008f, 0.29185730f, 0.08028586f, -0.26079753f, 0.07528881f, 
    -0.07911428f, 0.00620695f, 0.04836417f, 0.04839405f, -0.33775452f, 0.15501262f, 0.12556292f, -0.02923281f, 
    -0.07897418f, 0.15861680f, 0.01179794f, -0.02565878f, 0.10364003f, 0.11510360f, -0.12496450f, 0.08536503f, 
    -0.07090688f, 0.06883719f, 0.02122562f, -0.06181635f, -0.48221463f, -0.11896688f, -0.19976428f, 0.16727962f, 
    -0.12050860f, -0.19591869f, 0.01015819f, 0.03258329f, -0.07193155f, 0.23987754f, 0.29452041f, 0.45184475f, 
    0.13499017f, -0.05537599f, 0.06948377f, 0.00814370f, 0.14258166f, -0.04119008f, 0.15815970f, 0.53825444f, 
    0.31762841f, 0.16496845f, 0.13485581f, -0.04222575f, 0.04315306f, 0.13413468f, -0.08804449f, -0.25287548f, 
    0.10567290f, 0.43763101f, 0.10279989f, 0.10726338f, 0.02252703f, -0.05108508f, -0.02224903f, 0.18288018f, 
    0.20810974f, -0.17026998f, -0.35976505f, 0.00951215f, 0.11160962f, 0.07811736f, 0.11025841f, -0.15090801f, 
    -0.10629890f, 0.15969540f, -0.30657816f, -0.19345817f, 0.00635542f, 0.15393238f, 0.11719343f, 0.18564837f, 
    -0.03517818f, 0.13649657f, 0.05684865f, -0.60305613f, -0.59450966f, 0.00790763f, 0.05939444f, -0.12935579f, 
    -0.06296390f, -0.10915556f, 0.03016750f, -0.02724280f, -0.29864264f, -0.11756045f, -0.04264975f, -0.05741091f, 
    0.07766037f, -0.14311446f, -0.25660375f, 0.15229984f, 0.10256935f, 0.16274348f, 0.12516662f, 0.04342533f, 
    0.05383481f, -0.14926113f, 0.16188075f, 0.15032263f, -0.04468145f, -0.57482326f, 0.09059612f, -0.03288161f, 
    -0.14362597f, -0.06801762f, 0.08443543f, 0.12608552f, 0.03772281f, -0.05833538f, -0.10060579f, 0.34507072f, 
    0.22796966f, 0.06019697f, 0.22160307f, 0.01445148f, 0.06708438f, -0.15272425f, 0.11922094f, -0.06409242f, 
    0.14756332f, 0.11516432f, 0.37295568f, 0.03650422f, 0.23139413f, -0.01455594f, 0.01014490f, 0.18904664f, 
    -0.20758505f, 0.06432902f, 0.29346082f, -0.17964019f, 0.10769211f, -0.19400464f, 0.00979813f, 0.06327134f, 
    -0.02449619f, 0.38587499f, -0.20094420f, 0.15715212f, 0.07013926f, 0.04893136f, 0.19293396f, 0.17815539f, 
    0.21570428f, 0.22596493f, 0.25793412f, 0.32755697f, -0.48453954f, -0.20072153f, -0.27310878f, 0.04840058f, 
    0.18499073f, 0.03498447f, -0.04665135f, 0.29555246f, -0.81602263f, -0.29061198f, 0.01914875f, 0.11658730f, 
    0.03406540f, 0.04104213f, -0.06675985f, -0.08308025f, 0.04506589f, -0.61075020f, -0.28140834f, -0.06172819f, 
    -0.03707665f, 0.07488127f, -0.00841687f, 0.00619464f, -0.18113241f, 0.12183147f, 0.01722887f, -0.31695649f, 
    0.12738442f, -0.12758458f, -0.03888702f, 0.06164725f, -0.24479337f, -0.05236300f, -0.03318468f, 0.10467798f, 
    -0.51681602f, 0.14828445f, 0.01439640f, 0.28598496f, -0.00030263f, -0.01954282f, 0.00886867f, -0.35852033f, 
    -0.24529104f, 0.30096301f, -0.12267518f, 0.00166094f, -0.06331155f, -0.12637147f, 0.00215332f, 0.08345409f, 
    -0.00782315f, -0.05090830f, 0.01152977f, 0.01460296f, -0.05503711f, -0.05428432f, 0.03063374f, -0.01927942f, 
    0.01907370f, -0.04117107f, 0.00652587f, -0.03100160f, -0.06285368f, 0.00675183f, -0.02091060f, 0.01241710f, 
    0.01300053f, -0.06265642f, -0.05805223f, -0.00878760f, -0.05455212f, -0.04077961f, 0.01191226f, 0.03679766f, 
    0.02166597f, 0.03396847f, -0.00587776f, -0.03732601f, 0.00547732f, 0.01122761f, 0.01228685f, -0.02107312f, 
    0.01153582f, -0.00769458f, 0.04872628f, 0.02251568f, 0.03343824f, -0.05448730f, -0.02868673f, -0.06098088f, 
    -0.03673348f, -0.01400751f, -0.05124393f, 0.01021275f, -0.02414127f, -0.04847787f, -0.02734940f, 0.01233547f, 
    -0.01986091f, -0.03353748f, 0.01279662f, 0.05195105f, -0.00078286f, -0.05652351f, 0.02676123f, -0.01216134f, 
    0.03327665f, 0.04999987f, 0.04762744f, 0.02804083f, -0.04059055f, -0.03242378f, -0.04627474f, -0.01396781f, 
    0.01588048f, -0.00128021f, -0.01518579f, 0.01204178f, -0.04225876f, 0.00490249f, -0.00711125f, -0.03726867f, 
    -0.03828684f, 0.02263756f, 0.01117989f, 0.02639874f, -0.03775010f, -0.00386399f, -0.00150436f, -0.04092515f, 
    0.02288399f, -0.00411950f, 0.02599614f, -0.02928522f, -0.02825857f, 0.05518231f, -0.03163330f, -0.01699997f, 
    -0.05259407f, 0.03982001f, -0.03966048f, 0.04108394f, 0.03847729f, 0.05284580f, -0.06020110f, 0.00736029f, 
    0.01214741f, -0.03538965f, 0.00838367f, 0.00806028f, -0.01673336f, 0.04996353f, -0.03260720f, 0.04172290f, 
    0.02641286f, 0.04675273f, 0.02526638f, 0.03777466f, 0.02922814f, 0.02392370f, -0.03058468f, -0.06035342f, 
    -0.01798581f, 0.02190837f, -0.02771245f, -0.02004078f, 0.03108493f, -0.03927662f, -0.05261436f, 0.01300836f, 
    -0.01042166f, -0.04762820f, 0.03928673f, -0.02783519f, 0.00395665f, -0.06372759f, 0.02232999f, -0.04075618f, 
    -0.02608804f, -0.05924652f, 0.03955479f, -0.01630608f, -0.01808928f, -0.02665081f, -0.06475226f, -0.05844579f, 
    0.03057124f, -0.02491702f, 0.04279010f, 0.01662825f, -0.04637262f, 0.02552459f, -0.06243683f, -0.01179848f, 
    0.05238951f, 0.03534915f, 0.02849725f, 0.03165152f, -0.01540455f, 0.02538685f, -0.02686478f, 0.00247699f, 
    -0.03101329f, -0.02139247f, -0.01143229f, -0.02073989f, 0.00116531f, -0.05322075f, 0.04889300f, 0.03809626f, 
    -0.04869341f, 0.01275323f, -0.06432613f, -0.01626599f, 0.01552083f, -0.04294188f, 0.05291821f, -0.00618536f, 
    0.02373564f, -0.06246819f, -0.01906781f, -0.00039623f, -0.05381810f, -0.05673876f, 0.02039798f, -0.02080560f, 
    -0.01846715f, 0.02401820f, -0.06215293f, 0.02599488f, -0.01595569f, -0.05376431f, 0.00686493f, 0.04482602f, 
    0.05039977f, -0.06084430f, -0.02268773f, -0.05512497f, -0.06177818f, -0.00251348f, -0.05802909f, 0.01911397f, 
    0.00626866f, -0.01663553f, 0.00640291f, -0.02212896f, -0.05066660f, -0.06443806f, -0.05541868f, -0.04298307f, 
    0.04485014f, -0.01091724f, -0.02988875f, -0.03511015f, 0.04106337f, -0.05555679f, 0.03535811f, -0.02890464f, 
    0.02578080f, -0.03171974f, -0.00349851f, -0.05795728f, -0.03541170f, 0.03716151f, 0.02563512f, -0.00452391f, 
    -0.06237004f, 0.02555026f, -0.00963541f, -0.04938908f, 0.04368662f, 0.04929208f, -0.02666084f, 0.03883734f, 
    -0.06306925f, -0.01803964f, 0.00941486f, 0.03354730f, -0.05436474f, -0.05072519f, 0.00475372f, 0.03278237f, 
    -0.04488945f, -0.05946797f, 0.04675939f, -0.00462307f, -0.00989977f, -0.03155280f, -0.04573228f, 0.00154012f, 
    -0.01563915f, 0.02216740f, 0.04959752f, -0.03834552f, -0.05860366f, -0.00611559f, -0.02102800f, 0.01961664f, 
    -0.05143456f, 0.03863866f, -0.03090546f, 0.05823902f, 0.00560353f, 0.04033975f, 0.05434862f, 0.00365618f, 
    -0.05157182f, 0.04423581f, -0.03228769f, 0.02069170f, -0.01894936f, 0.01536842f, -0.06093577f, -0.00025809f, 
    0.00917017f, -0.05587893f, -0.00066735f, 0.00524486f, -0.04384808f, -0.01468284f, -0.00001113f, 0.02816393f, 
    0.02456854f, -0.02561911f, 0.02636933f, -0.01700904f, 0.00390322f, -0.00780028f, -0.02366585f, -0.03831327f, 
    -0.00687747f, 0.01164025f, -0.03348721f, -0.05408194f, -0.03653470f, 0.02880203f, -0.01816139f, 0.03402068f, 
    -0.40588990f, -0.09384333f, 0.25482979f, -0.00244398f, -0.02702759f, -0.16876832f, -0.33689228f, -0.09558190f, 
    0.17073201f, -0.25471136f, -0.08220482f, 0.43409458f, 0.18227318f, 0.03177678f, -0.11734352f, 0.12578179f, 
    -0.15257205f, 0.04534294f, 0.24534227f, 0.07460795f, -0.11157090f, 0.07472143f, -0.03792504f, 0.06986099f, 
    0.11650977f, 0.02774262f, 0.09155258f, -0.03661683f, 0.33890077f, 0.16918738f, -0.07301705f, -0.10418510f, 
    0.06435849f, -0.26613408f, 0.04634462f, -0.21703035f, 0.10276546f, 0.39768463f, -0.01318948f, -0.40234789f, 
    -0.30895409f, -0.03061418f, -0.05905861f, 0.10398637f, 0.08414110f, -0.41451702f, 0.28510943f, 0.24194935f, 
    0.15989572f, -0.03713253f, 0.13679449f, 0.09277344f, -0.02543338f, -0.03220836f, 0.21709065f, 0.10039747f, 
    -0.10660908f, -0.27205747f, -0.01098825f, -0.05789671f, -0.04535336f, 0.03987250f, -0.00977008f, -0.01297780f, 
    0.01441259f, -0.03505283f, 0.00977157f, -0.20990524f, -0.04088776f, 0.38261607f, 0.14915094f, 0.25496209f, 
    -0.38993624f, 0.16387944f, 0.04590201f, 0.00802668f, 0.04053202f, 0.26620686f, -0.12291325f, 0.13912545f, 
    0.11822540f, -0.40113458f, -0.19035588f, -0.28314325f, -0.11001544f, -0.07385535f, 0.06896695f, 0.07606665f, 
    -0.25126711f, -0.04645591f, -0.49484032f, -0.07705442f, 0.10765237f, -0.00344549f, 0.07137261f, 0.06068785f, 
    -0.01511261f, 0.10673968f, -0.13409249f, -0.20534617f, 0.18921620f, 0.05418792f, -0.12417030f, 0.12283891f, 
    0.11692318f, 0.03563629f, 0.04586571f, 0.13136321f, -0.03515685f, 0.24433266f, 0.22794990f, 0.12024373f, 
    -0.00515030f, 0.09521195f, 0.00636679f, -0.05686762f, -0.03579939f, -0.00627028f, 0.17364568f, 0.01283400f, 
    -0.30313715f, -0.05603429f, -0.10251827f, 0.18762043f, 0.06865514f, -0.03162922f, 0.00822122f, -0.25152150f, 
    0.05209307f, 0.10336321f, -0.25222284f, 0.02767800f, 0.09122900f, 0.21895786f, -0.03206538f, -0.08460019f, 
    0.00238001f, 0.24440329f, 0.04991063f, -0.04952580f, -0.27905372f, -0.00397375f, 0.23479699f, 0.01857615f, 
    -0.27216071f, 0.30990162f, 0.17353278f, -0.12329128f, 0.17922240f, 0.13255240f, 0.02569290f, -0.16012594f, 
    -0.01378477f, 0.33713406f, 0.18045351f, -0.71777028f, 0.09686280f, 0.14246230f, -0.24200243f, 0.04090255f, 
    0.00080700f, 0.22596924f, 0.28780577f, 0.62213379f, 0.35703599f, 0.11848271f, -0.15390442f, -0.02155449f, 
    0.06721292f, 0.01195021f, -0.08775056f, 0.36407569f, -0.04028341f, -0.38264015f, 0.14337218f, -0.05853038f, 
    -0.18067405f, -0.02172268f, -0.00066720f, -0.08589865f, -0.07851625f, 0.00666169f, -0.28817502f, -0.00797965f, 
    0.02413818f, 0.05042848f, 0.20998174f, -0.08304206f, 0.17217191f, 0.34958050f, -0.00669006f, -0.22460465f, 
    0.07623759f, -0.05740544f, 0.12078462f, -0.14770968f, -0.06965919f, -0.09304298f, 0.17711374f, -0.05984843f, 
    -0.01393345f, 0.08029632f, -0.03740679f, -0.23568873f, 0.04537250f, 0.07027777f, 0.16380282f, 0.02855584f, 
    -0.14058447f, 0.28301975f, 0.02589511f, -0.20413803f, -0.05166377f, 0.09510397f, -0.00871154f, 0.07585479f, 
    0.02601619f, 0.20643777f, 0.13845217f, -0.02593032f, -0.21386391f, -0.11310583f, -0.20603141f, 0.01665828f, 
    0.13523750f, -0.27632859f, 0.05345311f, -0.03421167f, -0.03527347f, -0.27794838f, -0.15980099f, 0.23914579f, 
    0.10303086f, -0.17510936f, -0.23085734f, -0.38023546f, 0.13031889f, -0.07154232f, 0.36204511f, -0.10661689f, 
    0.15011781f, 0.08138936f, -0.12220837f, 0.13989983f, 0.29720873f, -0.06947931f, 0.12708382f, 0.10811523f, 
    -0.02720654f, -0.00075621f, 0.10438388f, -0.04800829f, 0.15676861f, 0.03731849f, -0.20960389f, 0.20203550f, 
    0.22734970f, 0.13171373f, -0.18158177f, 0.01818494f, 0.22505376f, -0.37504977f, -0.24959886f, 0.02568083f, 
    0.07030248f, -0.12914637f, 0.02793226f, -0.03184354f, 0.04713364f, 0.02331000f, -0.19273418f, -0.16290621f, 
    0.09629136f, 0.03414415f, 0.33232030f, 0.06952138f, 0.12091871f, -0.32003573f, -0.03039747f, 0.24950561f, 
    -0.07686663f, -0.22596470f, 0.10750488f, 0.10819872f, -0.12113255f, -0.19903430f, 0.18773137f, 0.08288446f, 
    -0.00666228f, 0.00720889f, 0.00567582f, -0.02629969f, 0.03279996f, -0.03319054f, 0.04546286f, 0.04491837f, 
    0.05039251f, -0.01243434f, -0.05515480f, -0.00658232f, 0.01172673f, 0.04488047f, 0.03744908f, -0.04149918f, 
    -0.02536254f, -0.00056840f, 0.00834137f, -0.03696543f, -0.05159195f, -0.05981519f, 0.01696651f, -0.02407413f, 
    0.01650025f, -0.04130290f, -0.03987316f, -0.03917902f, -0.04380884f, -0.02619701f, 0.00420794f, -0.01593097f, 
    -0.03777592f, -0.06058668f, 0.00504728f, 0.03508342f, 0.02676865f, 0.03109623f, 0.04314477f, 0.00503088f, 
    -0.00681042f, 0.01383418f, 0.03973484f, -0.04820943f, -0.04294163f, -0.05449220f, -0.01041792f, -0.06483288f, 
    0.00433453f, 0.00436696f, 0.03670615f, -0.06625157f, -0.03890604f, 0.01843586f, 0.02898353f, -0.05562617f, 
    0.03662228f, -0.05967494f, 0.01488979f, 0.02781197f, -0.05776323f, 0.03624353f, 0.02389536f, 0.02128058f, 
    0.01700955f, -0.05544604f, -0.02127920f, -0.01891511f, 0.00809337f, 0.02645883f, -0.04493361f, 0.01535378f, 
    0.00846059f, -0.05419291f, -0.05314073f, 0.01744798f, -0.01505421f, -0.03565115f, -0.00878418f, -0.06257246f, 
    -0.04424880f, -0.04238870f, 0.04034165f, 0.03814999f, -0.06204065f, -0.05359677f, 0.02455265f, -0.01710866f, 
    -0.01751446f, -0.06773341f, -0.04704425f, -0.02043011f, 0.02161963f, -0.04394527f, -0.03350511f, 0.02147425f, 
    -0.01357154f, 0.04046325f, -0.04291630f, 0.02870550f, 0.00119310f, 0.03122805f, -0.06127270f, -0.02613814f, 
    0.04024502f, -0.03339552f, -0.02260925f, -0.01228666f, -0.04353156f, 0.00717331f, -0.00906271f, 0.00634789f, 
    -0.04207243f, 0.01955993f, -0.04922615f, 0.02649667f, 0.03704061f, -0.02561262f, -0.01336477f, -0.04951626f, 
    0.02064694f, -0.01002438f, -0.03711371f, 0.03185214f, 0.00401252f, 0.02546060f, -0.04585004f, -0.05027223f, 
    -0.00810788f, 0.03828710f, 0.01624558f, 0.04126220f, 0.01639398f, 0.04569358f, -0.00169244f, -0.02624871f, 
    0.00933756f, -0.01914260f, -0.02805214f, 0.00547350f, 0.02080207f, -0.02078570f, -0.05468333f, 0.00208712f, 
    0.00183602f, -0.01746053f, -0.05455071f, -0.05030113f, -0.02966871f, 0.01879475f, 0.04326524f, 0.03566250f, 
    -0.04433729f, -0.03547949f, -0.02465872f, 0.00104494f, 0.03938113f, -0.02449651f, -0.06220831f, -0.04877247f, 
    -0.03966233f, -0.04266630f, -0.01083064f, -0.05493200f, 0.03509939f, 0.00400710f, -0.02676544f, 0.01105494f, 
    -0.00403063f, 0.04010011f, 0.03707554f, -0.03303397f, -0.04786630f, -0.05582390f, 0.00958704f, 0.01764233f, 
    -0.02622971f, -0.04566893f, -0.03331124f, 0.01819824f, 0.03815389f, -0.02996291f, -0.04999388f, -0.06274530f, 
    -0.00460463f, 0.00756015f, -0.06660125f, -0.05524924f, 0.00524035f, 0.02146771f, 0.04501291f, -0.02789896f, 
    0.02855637f, -0.03488650f, -0.04949161f, -0.06565505f, -0.00082719f, -0.01697300f, -0.05494165f, -0.00718739f, 
    -0.02287551f, -0.00873456f, 0.01864821f, -0.01908930f, -0.05467633f, -0.03333234f, -0.06077334f, 0.02327912f, 
    0.02354419f, 0.03639037f, -0.02742554f, 0.02685494f, -0.04109612f, 0.02181911f, 0.02298791f, -0.02550436f, 
    0.02697941f, 0.03522471f, -0.01195509f, -0.01609154f, -0.04161404f, 0.03282602f, 0.02685208f, 0.00623089f, 
    -0.06445256f, 0.03138328f, -0.06841609f, -0.03911640f, -0.02589462f, 0.00313963f, -0.04321051f, 0.04796501f, 
    -0.06100925f, 0.01923785f, -0.06406813f, -0.00798355f, -0.00539058f, -0.06756403f, -0.03992319f, 0.00576318f, 
    -0.01019784f, -0.00562015f, -0.00008683f, 0.04662363f, -0.05718670f, 0.02170782f, -0.03094004f, 0.00346819f, 
    -0.01988772f, 0.03840571f, -0.07092791f, 0.01751652f, 0.04912985f, 0.04224264f, -0.05102924f, -0.00739340f, 
    0.01803164f, -0.01336725f, 0.00178824f, 0.01927674f, 0.00122438f, -0.03281223f, -0.05694174f, -0.05097053f, 
    0.02905447f, 0.04322935f, -0.04629734f, -0.02251225f, 0.04235400f, -0.04869115f, -0.02899111f, 0.00481266f, 
    -0.03678035f, -0.06770904f, -0.02734306f, -0.05790177f, -0.00512102f, 0.00041659f, 0.03908185f, 0.04264326f, 
    -0.01120579f, -0.00383713f, -0.06130257f, -0.01476735f, -0.01319133f, 0.03797576f, -0.05804772f, 0.03987725f, 
    -0.02527463f, -0.04712957f, 0.03572832f, -0.03202824f, 0.02753077f, 0.02515638f, -0.01057401f, 0.04943890f, 
    -0.05831068f, 0.05069245f, -0.00211724f, -0.01666182f, -0.01310433f, -0.02743165f, 0.04814906f, -0.04319704f, 
    -0.04710034f, -0.02962935f, -0.02975983f, 0.01385369f, -0.05940038f, -0.02738605f, -0.00477925f, -0.02344157f, 
    -0.01970916f, 0.00839774f, 0.05010351f, -0.02582716f, 0.02754612f, 0.04412628f, -0.00827906f, -0.01953308f, 
    0.01824746f, 0.00822190f, 0.00001137f, -0.02858052f, 0.03954495f, -0.02777126f, 0.04380568f, -0.05341486f, 
    0.03711402f, -0.00217222f, -0.01476401f, 0.00645754f, 0.04063288f, -0.00051424f, 0.03467178f, 0.01947922f, 
    -0.00614369f, -0.03704938f, -0.03917490f, -0.03858256f, -0.04363349f, -0.00588963f, -0.04398634f, 0.05784266f, 
    -0.05821098f, -0.02741128f, -0.01500697f, 0.04486694f, 0.00474819f, -0.05516386f, -0.02998971f, 0.02943673f, 
    0.00994695f, -0.01221667f, 0.00616636f, -0.00797085f, -0.00982725f, -0.00088672f, 0.01393238f, -0.05392519f, 
    0.01569100f, 0.02330864f, -0.04943308f, -0.04510440f, 0.03847207f, -0.02098869f, -0.04161942f, -0.05409920f, 
    -0.05095223f, -0.01465840f, -0.05853280f, 0.04742648f, -0.02431833f, 0.03566087f, 0.02322030f, 0.04611293f, 
    0.03355793f, 0.04366416f, 0.04636667f, 0.03062001f, -0.06193943f, 0.03963917f, 0.04638509f, 0.00361031f, 
    -0.06138802f, -0.02515409f, -0.04584718f, -0.00670628f, -0.02243956f, -0.00837690f, -0.05378629f, -0.05006183f, 
    -0.06126606f, -0.04417945f, 0.04147449f, -0.04255913f, 0.05248552f, -0.02997386f, 0.04150851f, -0.00864205f, 
    0.05162769f, 0.05221697f, -0.03511920f, 0.00372307f, 0.03928466f, -0.02984592f, -0.04350035f, -0.02016214f, 
    -0.02716739f, 0.00552796f, 0.05756548f, -0.04802351f, -0.00295168f, 0.02212233f, 0.03392235f, -0.01395489f, 
    -0.05324973f, 0.01685329f, 0.00563634f, 0.02045684f, -0.06009094f, 0.02203113f, -0.02440991f, -0.01324982f, 
    0.03526952f, -0.00923179f, -0.00911681f, -0.01359607f, -0.05436198f, -0.06486323f, 0.01421586f, 0.01673449f, 
    -0.01778978f, 0.04043949f, 0.00876019f, -0.00303622f, 0.02353857f, -0.02953857f, -0.05237878f, -0.01010271f, 
    -0.06240708f, -0.00817293f, -0.05907470f, -0.03067197f, -0.04864597f, -0.03607477f, -0.02275495f, -0.01629360f, 
    -0.05598462f, 0.01219531f, 0.02099593f, -0.00243031f, 0.03692598f, -0.01887567f, 0.03476002f, 0.03934228f, 
    0.03122954f, 0.03799818f, -0.05610377f, -0.01740721f, -0.04657175f, -0.06386766f, -0.02308122f, 0.00304651f, 
    -0.02912517f, 0.03383840f, 0.02558823f, 0.04883775f, -0.01610278f, 0.01882896f, -0.06279174f, 0.01334978f, 
    0.04329713f, -0.06261595f, 0.00064499f, -0.01222933f, -0.06127659f, -0.04821392f, -0.02810827f, 0.00635803f, 
    0.02878991f, 0.02950174f, 0.01186423f, -0.04746270f, 0.04170450f, -0.00589288f, -0.01804771f, -0.04199955f, 
    -0.05572722f, -0.04252276f, -0.04667847f, 0.03214826f, -0.02758140f, -0.05703114f, -0.01674754f, 0.02806975f, 
    -0.03828081f, -0.01268081f, -0.03647826f, -0.06390781f, 0.01274916f, 0.03971489f, -0.04827712f, 0.03423686f, 
    -0.00072262f, 0.00906284f, 0.00040957f, -0.04063075f, -0.01310760f, 0.02115124f, -0.00038079f, 0.00040822f, 
    0.01717732f, -0.00167535f, 0.04325819f, -0.04563554f, -0.00015123f, -0.03645239f, 0.00293158f, 0.03358985f, 
    -0.01273008f, 0.00214613f, 0.05032517f, -0.01787660f, -0.04378324f, -0.04635282f, -0.06427334f, 0.03494653f, 
    -0.01480631f, -0.05829126f, 0.00195024f, -0.03302666f, 0.05565815f, -0.01383059f, 0.02467744f, -0.05716383f, 
    -0.04449730f, 0.01860435f, 0.03633802f, -0.00077492f, 0.00274669f, 0.01783981f, 0.00477975f, 0.04619487f, 
    0.04532227f, 0.04400729f, -0.00014195f, -0.05031487f, 0.00654365f, 0.01321478f, 0.04388341f, -0.02425800f, 
    0.03153460f, -0.05386590f, -0.00674942f, -0.02440589f, -0.03678233f, 0.01599009f, -0.03962763f, -0.02829533f, 
    -0.04830324f, 0.01819177f, 0.04686306f, -0.03492538f, -0.00810717f, -0.02290095f, 0.02743877f, -0.03683444f, 
    -0.05021766f, -0.03666843f, 0.00182748f, 0.03292505f, -0.05612737f, 0.00681939f, -0.00970010f, 0.03512746f, 
    0.13899595f, -0.05065685f, -0.20285255f, 0.10426796f, -0.28101060f, -0.19115748f, 0.06444667f, 0.02235970f, 
    0.03369453f, 0.07742614f, -0.06780735f, -0.29543802f, 0.09447376f, -0.16661941f, 0.02817702f, 0.22834492f, 
    -0.18502958f, 0.07430966f, -0.34431463f, -0.16296096f, -0.15134646f, 0.12407688f, 0.08281282f, -0.05829704f, 
    0.00532524f, -0.22294883f, 0.15955654f, -0.17931856f, 0.02807173f, -0.19022982f, -0.14270130f, -0.22175623f, 
    0.03627811f, -0.07612047f, -0.05684137f, 0.11974259f, 0.09622025f, 0.27596849f, 0.11520824f, -0.42274874f, 
    0.17639847f, -0.22870228f, 0.08743843f, -0.10427406f, -0.02687774f, -0.05959252f, -0.06182116f, -0.52902967f, 
    0.20427364f, 0.15421154f, -0.06443662f, -0.30062449f, -0.01419321f, -0.23110424f, -0.12081680f, 0.25831529f, 
    0.05226877f, -0.13827685f, 0.01444747f, 0.09373339f, 0.17153786f, 0.07716998f, 0.01967081f, -0.04066160f, 
    0.17251149f, -0.10266658f, -0.01685627f, 0.01943170f, 0.14955069f, 0.35308182f, 0.24940169f, 0.01659693f, 
    -0.21850322f, 0.28848279f, 0.16783558f, 0.09461159f, -0.04635401f, 0.05392201f, 0.10249776f, -0.02361063f, 
    0.04054101f, -0.54559851f, -0.17004463f, -0.24305062f, 0.07624539f, 0.04597808f, -0.26861349f, -0.08216710f, 
    -0.17195036f, 0.04737630f, -0.05506777f, -0.09349166f, 0.06005676f, 0.08398762f, 0.12782183f, 0.15531082f, 
    -0.10237472f, -0.02611564f, 0.00369281f, -0.36843178f, -0.03306930f, 0.03484690f, -0.17325102f, -0.15172566f, 
    0.04193736f, -0.13874510f, -0.03353662f, -0.29996374f, 0.00841254f, 0.14872018f, 0.16035047f, 0.25020605f, 
    0.22313045f, -0.07212213f, 0.04994503f, -0.01610174f, -0.01177281f, -0.29638714f, 0.15932791f, -0.07621238f, 
    0.00071998f, -0.09774806f, 0.01215906f, -0.06845888f, -0.05397219f, -0.02686388f, 0.09135400f, -0.08993971f, 
    -0.24979271f, -0.08159155f, 0.11767143f, -0.05564513f, 0.09552164f, 0.19513853f, -0.06546942f, 0.15832965f, 
    -0.00465446f, 0.22750914f, -0.28477719f, -0.06137382f, 0.06390967f, -0.06996980f, 0.03269553f, 0.04202617f, 
    0.28083935f, -0.13557328f, 0.34217447f, 0.24666962f, 0.11178248f, -0.02094929f, 0.32356736f, -0.02387653f, 
    0.01896900f, -0.03889494f, -0.14431556f, 0.31855065f, 0.19578536f, 0.32097816f, -0.18830101f, -0.10894720f, 
    0.05475763f, 0.09913909f, 0.15529966f, 0.39705232f, -0.05622246f, -0.02780369f, 0.24923289f, -0.20860547f, 
    -0.05301658f, -0.13969907f, 0.03206036f, 0.17948529f, 0.17872296f, 0.43896380f, 0.21545668f, -0.07326112f, 
    0.10394153f, -0.33900526f, 0.16993231f, 0.10731559f, -0.20942275f, -0.12600750f, -0.09159981f, -0.10200496f, 
    -0.05003734f, -0.15336841f, -0.02353951f, 0.09584011f, 0.08919130f, -0.24459958f, -0.18693623f, -0.03759219f, 
    0.16000260f, -0.12622583f, 0.33596128f, 0.14999275f, -0.03355210f, -0.01098340f, 0.15591656f, 0.24357486f, 
    0.12960225f, -0.22409621f, -0.07215046f, 0.05244248f, 0.11243202f, -0.08086122f, 0.18955228f, 0.32125887f, 
    -0.04707278f, 0.02730102f, 0.02160560f, -0.14178912f, 0.01202149f, -0.08041368f, -0.03509721f, -0.05986445f, 
    0.10490454f, 0.25953975f, -0.08744057f, -0.10662251f, -0.05171428f, -0.06525932f, -0.03934949f, 0.02081297f, 
    0.11432362f, -0.08073933f, -0.01020295f, -0.28369698f, -0.01181172f, 0.22435710f, 0.01013447f, -0.09577349f, 
    -0.02413377f, 0.06437040f, 0.21373037f, 0.02396380f, -0.34724399f, -0.06973378f, 0.01814104f, 0.13153236f, 
    -0.06085823f, 0.02061329f, 0.11848496f, 0.00133193f, 0.06587097f, -0.12401634f, 0.28083158f, 0.23646575f, 
    -0.19285387f, -0.01781556f, -0.10909945f, 0.11861077f, -0.35442206f, 0.21214040f, 0.16780588f, -0.05105496f, 
    -0.00160844f, -0.12619291f, 0.07997319f, -0.14419450f, -0.20769422f, -0.06823730f, 0.00321746f, -0.02498948f, 
    0.30965343f, 0.10389905f, -0.02585664f, -0.23507708f, 0.03496149f, -0.07797781f, 0.01972026f, 0.07356646f, 
    0.26932192f, 0.14158639f, -0.07802095f, 0.11145870f, -0.06995199f, -0.03248259f, -0.16196689f, 0.28725296f, 
    0.07443555f, 0.52803749f, 0.39693770f, 0.04214761f, 0.09574047f, -0.08095165f, -0.09254411f, 0.19921306f, 
    -0.02299140f, -0.02570701f, 0.03775546f, -0.05853862f, -0.01715137f, -0.00799400f, 0.00543433f, -0.05563598f, 
    0.04215899f, -0.03037645f, 0.03016367f, 0.01836718f, -0.00409344f, 0.00181294f, 0.01095484f, -0.00867502f, 
    -0.00943045f, 0.03993622f, 0.01728312f, -0.06948904f, 0.03007586f, -0.00659299f, -0.04964777f, 0.03152787f, 
    -0.02980754f, -0.02307004f, -0.00934111f, 0.03448342f, 0.02029566f, 0.03106097f, -0.00747146f, 0.01422182f, 
    -0.03931689f, 0.02143033f, -0.04913746f, 0.03968719f, -0.01254798f, 0.01317524f, 0.03144509f, -0.05610327f, 
    -0.04550605f, -0.04133417f, -0.06851676f, 0.01416786f, 0.00437694f, 0.01164089f, -0.00573502f, -0.02219493f, 
    -0.05488905f, 0.04841640f, -0.03810098f, 0.04684108f, -0.04644752f, -0.06610840f, -0.02362616f, -0.03283240f, 
    -0.06276270f, -0.01276964f, -0.06516585f, -0.00284518f, 0.01545030f, 0.03254427f, 0.02902774f, 0.01279196f, 
    -0.02736348f, 0.03148811f, 0.04435683f, -0.06462440f, -0.00338032f, -0.04924698f, -0.05802491f, 0.02135880f, 
    -0.05865721f, -0.03170452f, -0.02002933f, -0.02781085f, -0.04342806f, 0.03046550f, -0.04682500f, -0.03426454f, 
    0.03892551f, 0.00207233f, -0.01145973f, -0.00868272f, 0.02736183f, -0.00846106f, 0.00205125f, -0.04950726f, 
    0.03088575f, -0.05915028f, 0.01508947f, 0.00253777f, 0.03282883f, 0.00065847f, 0.04864727f, 0.02079499f, 
    -0.04686074f, -0.05210009f, -0.01410161f, -0.04830544f, -0.05164662f, -0.01444554f, -0.03922537f, -0.00764177f, 
    -0.03645996f, -0.05810799f, 0.03594781f, -0.07017219f, 0.04106780f, 0.01876285f, -0.04542187f, -0.06268228f, 
    -0.02241713f, -0.01387658f, 0.00096917f, 0.03741693f, 0.02356217f, -0.05332610f, 0.03791833f, -0.01926471f, 
    -0.04130835f, -0.01669516f, 0.00998300f, 0.02713390f, -0.02008567f, -0.00959192f, -0.00463154f, 0.01500682f, 
    0.03693757f, -0.04060469f, -0.00420022f, 0.02719260f, -0.05666826f, 0.03520529f, -0.02268112f, -0.04495976f, 
    0.01963656f, -0.00014109f, 0.02293171f, 0.03293936f, -0.05383704f, 0.03921282f, 0.03306441f, -0.02670877f, 
    -0.04848886f, -0.00289756f, 0.03351204f, -0.00139881f, 0.02848613f, -0.02419908f, -0.03438411f, 0.01763695f, 
    -0.03638700f, 0.00119261f, -0.02095728f, -0.02175177f, 0.01808723f, -0.03873029f, -0.05700095f, -0.06535865f, 
    -0.04135033f, -0.02698251f, -0.02989135f, -0.04870607f, -0.02269124f, -0.01560631f, 0.01136037f, 0.02360936f, 
    0.04280203f, 0.04780651f, 0.04655779f, -0.03708684f, 0.01477979f, 0.00965594f, -0.03475038f, -0.04014574f, 
    -0.00704172f, 0.04107023f, -0.01751445f, 0.01376075f, 0.02125135f, 0.00915426f, -0.02309212f, 0.01515630f, 
    -0.01971768f, -0.01713463f, -0.00630466f, 0.01047798f, 0.04245266f, 0.04172168f, 0.00520323f, 0.04413731f, 
    0.03881627f, 0.01736970f, 0.01201072f, 0.02676767f, -0.01206381f, 0.00640262f, -0.03802659f, -0.03513313f, 
    -0.02054984f, -0.02717443f, 0.01744648f, -0.05506201f, -0.00168502f, -0.05202864f, 0.04072856f, 0.03580555f, 
    -0.00651971f, -0.05261990f, -0.06728292f, -0.00179844f, 0.02791847f, -0.04828145f, -0.03567398f, 0.02462758f, 
    0.03744892f, -0.03058294f, 0.01417687f, -0.04405245f, 0.03367641f, -0.03111525f, -0.02967015f, -0.02759567f, 
    0.03850482f, -0.03499683f, 0.00593355f, -0.03552934f, 0.03671983f, -0.03331644f, 0.03815566f, -0.01156823f, 
    -0.00408914f, 0.02048900f, 0.01291880f, 0.02056833f, 0.01231744f, -0.04364382f, -0.02761393f, -0.00173410f, 
    -0.04055783f, -0.04038074f, -0.02784385f, 0.04284580f, -0.03177975f, 0.00103622f, -0.04981399f, -0.05399869f, 
    0.02825422f, 0.03413230f, 0.03684490f, -0.05189272f, 0.00340516f, -0.01331731f, -0.02002512f, -0.00864654f, 
    -0.03566274f, 0.04635628f, -0.01845476f, 0.01708878f, -0.00362008f, -0.03607645f, 0.01366869f, -0.04010349f, 
    0.02751926f, -0.01140236f, -0.00670814f, 0.00609491f, -0.05290502f, -0.01818288f, -0.02801426f, 0.03611379f, 
    0.03396836f, -0.05342714f, -0.05345667f, 0.02209503f, -0.00465056f, -0.04739334f, 0.00333324f, -0.00225232f, 
    -0.00115302f, -0.00616146f, -0.03672688f, -0.01469492f, 0.03637072f, -0.06437434f, -0.02540403f, 0.02990060f, 
    0.00315735f, 0.47697040f, 0.13647397f, 0.11952866f, -0.09500624f, -0.10948901f, 0.00086058f, 0.06851287f, 
    0.29296008f, 0.02341778f, -0.19865078f, -0.09853220f, 0.04611965f, 0.15522313f, -0.00302451f, -0.05205157f, 
    0.13396090f, 0.14617953f, 0.16455238f, -0.24707551f, 0.12623981f, -0.03773994f, -0.06332973f, -0.09143221f, 
    0.01012688f, 0.00435865f, 0.03071426f, 0.06159662f, 0.62922746f, 0.00920392f, 0.00282941f, -0.13396728f, 
    -0.19989465f, -0.19492839f, 0.11072582f, -0.03562654f, 0.31698084f, 0.03928691f, -0.16122244f, -0.05402414f, 
    0.02697255f, -0.02903386f, 0.11373200f, 0.07652003f, -0.07375418f, -0.17050613f, 0.22658813f, -0.17552476f, 
    -0.13740918f, -0.25632820f, 0.09569456f, 0.03138062f, 0.03411053f, 0.23688835f, -0.04268807f, 0.27639204f, 
    0.18726803f, 0.16880803f, -0.02962625f, -0.20722485f, 0.04725650f, 0.04444746f, 0.13940515f, 0.30415243f, 
    -0.12229204f, -0.25957054f, 0.19608973f, -0.12079814f, -0.07387710f, -0.06187132f, 0.05983622f, 0.19857177f, 
    -0.01022369f, 0.04708931f, -0.71349943f, 0.08219457f, 0.13420610f, 0.04164812f, -0.02411179f, 0.11871584f, 
    -0.07464039f, 0.06432220f, 0.38651973f, -0.64343578f, -0.01733637f, -0.15799291f, 0.04451588f, 0.06883826f, 
    -0.00204054f, 0.07771652f, -0.42225644f, 0.04415800f, -0.10409614f, -0.00158500f, -0.06325778f, -0.04682644f, 
    -0.09293667f, -0.11046504f, -0.24307723f, 0.18201874f, 0.32891464f, -0.16432059f, -0.15064946f, 0.03194788f, 
    0.09914494f, 0.09053464f, 0.10933960f, -0.04729832f, -0.39025012f, -0.07948311f, 0.72958308f, 0.17256652f, 
    0.11775930f, -0.27239197f, -0.03158056f, 0.19481657f, 0.10260948f, -0.15815151f, 0.16865535f, -0.07478523f, 
    0.26359469f, 0.10217363f, -0.09748991f, 0.00521152f, -0.06874091f, -0.05188973f, -0.48465759f, 0.18383150f, 
    -0.66077811f, 0.17876454f, -0.06380720f, 0.14963974f, 0.07895840f, 0.04544020f, 0.12298130f, -0.14260174f, 
    -0.12956695f, -0.00302762f, -0.07461997f, 0.11050460f, 0.15494598f, -0.00026319f, 0.06859860f, -0.03489519f, 
    0.17659980f, 0.08841945f, 0.14222939f, -0.04484458f, -0.10013377f, -0.14495131f, 0.04409005f, 0.06997930f, 
    0.08454344f, -0.59856230f, 0.07159590f, 0.08490859f, -0.01021109f, -0.05482745f, 0.04317310f, -0.04670371f, 
    -0.06233404f, 0.23392211f, -0.24509342f, 0.15168731f, 0.13203901f, -0.12706824f, -0.02679724f, -0.02660850f, 
    -0.01742135f, 0.16206105f, 0.09432653f, -0.07166005f, -0.12035455f, 0.13204400f, 0.14352240f, -0.02285293f, 
    -0.03674193f, 0.01793472f, -0.08059387f, -0.22798079f, 0.05379683f, -0.15959279f, 0.04696028f, 0.01138435f, 
    -0.12715955f, -0.08566413f, 0.02528292f, 0.00181009f, 0.02851907f, -0.20392491f, -0.17320284f, 0.23783031f, 
    -0.05575146f, -0.14384079f, 0.22455995f, -0.04929477f, -0.13331768f, -0.02466734f, -0.38949522f, -0.00493791f, 
    -0.26470417f, 0.22149613f, 0.08181365f, 0.01211240f, 0.01029783f, -0.16714852f, 0.12121587f, 0.13639766f, 
    0.06023432f, 0.36580783f, -0.13788338f, 0.15342063f, 0.17293185f, 0.11484448f, 0.24608640f, 0.27342322f, 
    -0.20822151f, 0.11678842f, -0.10536049f, 0.05419580f, -0.01024059f, -0.16871060f, 0.02015117f, 0.00118003f, 
    -0.23545350f, -0.48828176f, -0.31068230f, -0.36599064f, -0.02513047f, -0.16398829f, -0.00318244f, 0.09612342f, 
    -0.07549208f, 0.10786983f, -0.22728057f, 0.22413471f, -0.03328194f, -0.05498459f, 0.19132529f, 0.13605265f, 
    0.10218035f, -0.10951596f, 0.05004647f, -0.09244689f, 0.06475157f, 0.04996286f, -0.11905555f, -0.08419483f, 
    -0.01238266f, -0.00188245f, 0.02237201f, 0.14305244f, 0.23535925f, -0.39507461f, 0.09301458f, 0.08318941f, 
    -0.31650028f, 0.05587849f, -0.12367697f, -0.02278328f, -0.01505728f, -0.07314043f, -0.14185706f, 0.46237212f, 
    -0.02880296f, 0.04277056f, 0.06846111f, -0.23068334f, 0.03116003f, 0.07865022f, -0.33195519f, 0.13552734f, 
    0.06131921f, -0.05250955f, -0.16709284f, 0.04576534f, -0.00337669f, -0.06769770f, -0.04350053f, -0.00884841f, 
    -0.14108661f, 0.52927309f, 0.04388117f, 0.03364415f, -0.09088591f, -0.02834743f, -0.18389754f, 0.23063497f, 
    0.17522860f, -0.16897076f, 0.29665151f, 0.00305898f, 0.12323292f, -0.01509890f, -0.07901755f, -0.05320972f, 
    -0.04435226f, 0.09440076f, -0.11749233f, 0.09228301f, -0.06361201f, 0.08922392f, -0.19504224f, -0.13178286f, 
    -0.15573427f, -0.01295303f, 0.03627515f, -0.07483154f, 0.11182979f, -0.12734900f, -0.06678226f, -0.10540722f, 
    -0.05710896f, 0.14585981f, 0.07439897f, 0.49411789f, 0.19902380f, -0.33848554f, 0.05313239f, 0.00756918f, 
    0.20580432f, 0.02724622f, -0.09651634f, 0.37464610f, 0.30145067f, 0.11282003f, 0.12815396f, 0.17584707f, 
    0.04077439f, 0.05551261f, 0.03258854f, 0.02057117f, -0.18206617f, 0.06465650f, -0.09502361f, 0.20287788f, 
    -0.03332166f, 0.08607959f, -0.30820656f, -0.10366299f, -0.13019909f, 0.05242896f, -0.11638023f, 0.01413125f, 
    0.11475091f, -0.19036910f, -0.08165484f, 0.05734693f, -0.11072506f, -0.01480109f, -0.12198173f, 0.32178822f, 
    0.08772528f, -0.20928393f, -0.12526408f, -0.15419975f, -0.09468933f, -0.08336885f, 0.09611004f, -0.05477088f, 
    0.10090607f, 0.02558510f, -0.37070626f, -0.04628793f, 0.02001886f, -0.03338237f, 0.04251178f, 0.16683969f, 
    0.14369570f, 0.27620608f, -0.30501631f, -0.27298304f, 0.15143274f, -0.14524963f, 0.05207102f, -0.08614803f, 
    -0.17006488f, 0.30332553f, -0.35193971f, 0.14718674f, -0.17746116f, 0.18549086f, -0.19153593f, -0.09931826f, 
    0.13197456f, -0.07626726f, -0.15324782f, 0.17812560f, 0.18708661f, 0.01058837f, 0.08688456f, -0.10381322f, 
    0.05247975f, -0.14080785f, -0.14726728f, -0.05857813f, -0.06060041f, 0.07306501f, 0.22286059f, 0.03961802f, 
    -0.12699142f, -0.15936098f, 0.02477490f, 0.10447612f, 0.06355240f, 0.12734076f, 0.17744066f, 0.02344428f, 
    0.13974057f, 0.13895705f, 0.04766174f, 0.03184303f, 0.05560371f, -0.13282636f, 0.20350821f, -0.14860988f, 
    0.10606392f, 0.29522577f, -0.09260857f, -0.03761189f, -0.15307406f, -0.27465114f, 0.18676957f, -0.04862104f, 
    -0.15719758f, 0.22775374f, -0.05146122f, 0.15128540f, 0.14871208f, -0.14424786f, 0.07839096f, -0.13585962f, 
    0.08453664f, 0.40432370f, -0.16557066f, 0.04317308f, -0.08262732f, -0.10609822f, 0.15487523f, -0.00010920f, 
    -0.17797859f, 0.01895330f, 0.09840433f, 0.12519823f, 0.05019084f, -0.06168314f, -0.23149550f, 0.02216158f, 
    -0.23624627f, 0.09390170f, -0.16019154f, 0.11831826f, 0.30402818f, -0.03096115f, -0.02287122f, -0.18553504f, 
    0.12694968f, 0.02372140f, -0.03786903f, 0.11595606f, 0.23341878f, 0.08721129f, 0.04346570f, 0.18647897f, 
    0.09294482f, 0.16959608f, -0.08228594f, 0.07675663f, 0.00735643f, -0.31219471f, -0.04703750f, -0.11837601f, 
    -0.02930008f, -0.01857198f, -0.02492930f, 0.04348830f, -0.12688084f, 0.33527282f, 0.17633441f, -0.40586042f, 
    0.17890288f, -0.10190094f, -0.03567904f, 0.21571040f, -0.12924340f, 0.00378237f, -0.00600968f, -0.08367679f, 
    -0.02386552f, -0.04128033f, -0.12423166f, 0.11315569f, 0.05587697f, -0.05634027f, -0.12845023f, -0.45491371f, 
    -0.17291090f, 0.08500224f, -0.02322846f, 0.20053512f, -0.02173992f, -0.17103019f, 0.17831194f, -0.00821629f, 
    0.39605597f, -0.20727719f, -0.00355034f, -0.09354425f, 0.02182993f, 0.00479044f, 0.08572066f, -0.08563365f, 
    -0.23681782f, 0.19632961f, -0.36416465f, -0.11591341f, -0.09400998f, -0.15697511f, 0.08088504f, 0.08075590f, 
    -0.13962303f, -0.00272755f, 0.02399986f, 0.12758929f, -0.09739151f, -0.01564004f, 0.11273491f, 0.08486423f, 
    -0.00150532f, 0.01762487f, -0.02853403f, 0.08871106f, -0.03514064f, 0.18678483f, -0.08798714f, -0.07895961f, 
    0.13046212f, -0.10111866f, -0.00052710f, 0.01070750f, -0.04692198f, -0.08388296f, 0.11578754f, 0.12614870f, 
    0.24312516f, -0.05789011f, -0.05919494f, -0.00833862f, -0.04851651f, 0.07404912f, -0.03763761f, 0.14300361f, 
    0.06182929f, -0.08485831f, 0.14317158f, -0.25072145f, 0.01340450f, 0.08996639f, 0.10434236f, 0.12902972f, 
    -0.10495902f, 0.04442485f, 0.23314409f, 0.00508977f, 0.13895147f, 0.08827499f, -0.07983577f, 0.01554799f, 
    0.17758378f, -0.16072883f, -0.28328410f, -0.17290042f, -0.07728059f, 0.05397633f, 0.09139930f, 0.31415206f, 
    0.03382075f, 0.01093856f, -0.05953078f, -0.00038378f, 0.04959134f, -0.04332037f, -0.04129635f, 0.01413399f, 
    -0.03256428f, -0.00729973f, -0.01176109f, 0.04296180f, -0.05436631f, -0.05378215f, -0.05500117f, -0.02911379f, 
    0.02799320f, -0.04790351f, -0.05492569f, -0.01949286f, -0.02062261f, -0.05895253f, 0.01995131f, 0.04276593f, 
    0.01434178f, -0.01983967f, -0.03404992f, -0.03053639f, 0.00085080f, -0.03932878f, -0.01011873f, -0.04460368f, 
    0.03225841f, 0.04990861f, 0.02873722f, -0.00957663f, -0.00042036f, 0.03926922f, -0.03354400f, -0.00912254f, 
    -0.03247852f, 0.04877978f, -0.04177367f, 0.04036130f, -0.05285425f, -0.06563767f, -0.02540796f, -0.03992822f, 
    -0.06290427f, 0.03692838f, -0.01007302f, 0.04622965f, 0.03249542f, 0.03394479f, -0.03766378f, 0.02057384f, 
    0.05074609f, -0.04620056f, -0.05013948f, 0.02114928f, -0.02453110f, -0.00496000f, -0.03282790f, -0.03906947f, 
    0.01614919f, -0.05144764f, 0.05006265f, -0.02175547f, -0.05572825f, -0.05815992f, -0.05528841f, -0.01116557f, 
    -0.05403551f, -0.00184595f, 0.03353738f, -0.01927360f, -0.05407994f, -0.04930588f, 0.01731418f, 0.02150939f, 
    0.00359398f, -0.02454981f, -0.06179501f, -0.06260536f, 0.03334330f, 0.05937591f, -0.05956066f, 0.01530983f, 
    -0.04250000f, -0.04736518f, -0.05834818f, 0.02718816f, -0.03028152f, 0.01687466f, 0.04681702f, -0.00449086f, 
    -0.04260356f, -0.02719703f, -0.06477683f, -0.00612286f, 0.03049640f, 0.04110028f, -0.01516676f, -0.01576056f, 
    -0.00066194f, -0.00820130f, 0.01627514f, 0.04564064f, -0.02509766f, 0.02941790f, -0.03487617f, -0.06083930f, 
    -0.02625363f, 0.02914607f, 0.00036291f, 0.02030281f, 0.01589400f, 0.00460975f, 0.05041503f, 0.05042706f, 
    -0.03394625f, -0.05308195f, -0.04689339f, -0.05031741f, -0.03098849f, 0.00994744f, -0.03348849f, -0.05873321f, 
    -0.00141206f, 0.01873563f, -0.01680293f, -0.03448450f, -0.01994950f, -0.04653144f, 0.03353729f, -0.03166168f, 
    -0.00454909f, -0.06316424f, 0.03922343f, -0.03238060f, 0.00697646f, -0.05151447f, -0.00513976f, -0.00841407f, 
    0.01464138f, -0.00966091f, -0.01299966f, -0.02978702f, 0.02903124f, 0.01069697f, 0.00553177f, -0.05334288f, 
    0.02042933f, 0.00750438f, 0.03549662f, -0.05614048f, -0.02854210f, 0.04690970f, 0.01894491f, 0.04020688f, 
    -0.01407203f, 0.01955389f, -0.05496221f, 0.02354203f, 0.01336086f, 0.03862960f, -0.05256576f, 0.00634862f, 
    0.02536353f, -0.00211299f, -0.00920365f, -0.04914980f, 0.04416726f, 0.04684328f, -0.02200883f, 0.03793473f, 
    -0.05820115f, 0.01373221f, 0.04533301f, -0.01869052f, 0.01913279f, 0.02580645f, 0.03808064f, 0.01039771f, 
    0.03234070f, -0.06772725f, 0.02678382f, -0.03759155f, -0.03516505f, -0.06228510f, -0.00098262f, -0.05877259f, 
    0.01907161f, -0.04112692f, -0.06500350f, -0.01231175f, 0.01849014f, 0.02487830f, -0.02569606f, -0.00659071f, 
    0.02334652f, -0.02071802f, 0.03527708f, 0.04921902f, 0.01358670f, -0.02600202f, 0.02063913f, -0.02925716f, 
    -0.00664306f, -0.04359018f, -0.01284074f, -0.02528261f, -0.04630830f, 0.03779363f, -0.03431468f, -0.06474424f, 
    -0.05697669f, 0.01898491f, -0.06434910f, -0.03484586f, -0.06398363f, -0.03067631f, 0.02943902f, 0.00931298f, 
    -0.05714339f, -0.03995957f, -0.06586642f, 0.04366371f, -0.06679033f, 0.01991178f, -0.00852607f, -0.04872599f, 
    0.04839107f, -0.00544842f, 0.00727934f, -0.02960144f, 0.00371318f, -0.04082460f, -0.05227720f, 0.02737438f, 
    -0.02466196f, -0.02042864f, -0.05302509f, -0.01870043f, 0.03944640f, 0.03861953f, 0.04307778f, -0.00007250f, 
    -0.00697913f, 0.03052647f, -0.00848867f, 0.05003318f, -0.02750217f, 0.00470207f, -0.01375958f, -0.00752912f, 
    0.03518795f, 0.03307045f, -0.02912142f, -0.01444601f, -0.05674609f, 0.03285749f, -0.01149462f, -0.03148513f, 
    -0.03772841f, -0.03459552f, -0.06370623f, 0.01560171f, 0.02361705f, 0.04953317f, -0.06719563f, -0.00062676f, 
    0.04034562f, 0.03953852f, -0.02644748f, -0.02762616f, -0.00462292f, -0.06314820f, 0.02181016f, 0.00938332f, 
    -0.02274257f, -0.06090556f, 0.01000527f, 0.04512095f, -0.01711821f, -0.00359557f, -0.03053075f, -0.01484356f, 
    -0.02429237f, -0.04839243f, 0.01913068f, 0.01846431f, -0.04673236f, -0.02648251f, 0.03100186f, -0.04834745f, 
    -0.05194993f, 0.02270724f, 0.04602498f, -0.05953599f, 0.02694531f, -0.04246808f, 0.03119900f, 0.04383997f, 
    -0.05160083f, 0.00926534f, -0.05307690f, 0.03296727f, -0.03835251f, -0.03119267f, -0.05819159f, 0.03250358f, 
    0.00199964f, -0.03468175f, -0.06673352f, 0.01335725f, -0.00297340f, 0.01319616f, -0.02574614f, 0.01611830f, 
    0.00189549f, -0.02167335f, -0.07019701f, 0.01495846f, 0.01597684f, -0.00280579f, -0.01464573f, 0.00117752f, 
    0.02017320f, -0.04924386f, 0.02460542f, 0.02147904f, -0.04721379f, 0.03904162f, -0.06781907f, 0.02263561f, 
    0.01809461f, 0.02352766f, -0.06354401f, -0.06604164f, 0.01374415f, 0.00238124f, -0.04513334f, -0.06420602f, 
    -0.02231936f, -0.02562526f, -0.03977601f, -0.00630331f, -0.04060316f, -0.00421780f, 0.03868439f, 0.03397921f, 
    -0.03487070f, -0.00724804f, -0.03735135f, -0.05093983f, -0.00614608f, -0.04080827f, -0.01904881f, 0.03119466f, 
    -0.05822067f, -0.03338867f, -0.05553865f, 0.00521242f, -0.00770865f, -0.03224939f, -0.00602178f, -0.02051308f, 
    -0.02085552f, 0.01975322f, 0.02326075f, 0.04434333f, 0.01109167f, -0.03242150f, -0.02883342f, -0.04210060f, 
    0.01874097f, 0.00640392f, 0.00597692f, 0.04249227f, -0.00404190f, -0.06110287f, 0.04467395f, 0.01798909f, 
    -0.03300691f, -0.00691808f, -0.01954723f, 0.03608296f, -0.01287562f, -0.05688531f, -0.01110323f, 0.04143449f, 
    0.04267633f, 0.03758751f, -0.02647359f, -0.03233895f, -0.03589340f, -0.06592479f, 0.01762839f, -0.05343168f, 
    0.04833457f, 0.00519330f, -0.00479053f, 0.04444217f, 0.01557884f, -0.04442477f, -0.06004091f, -0.05045043f, 
    -0.05496414f, -0.01417322f, -0.05514400f, 0.00369005f, 0.05087660f, -0.02757192f, 0.01363834f, -0.06142449f, 
    -0.02400184f, 0.03033058f, -0.05243416f, 0.04004785f, 0.00601590f, 0.02123076f, 0.04890103f, -0.01086808f, 
    0.03963362f, -0.00712312f, 0.01977869f, -0.02204713f, 0.03060874f, 0.00012413f, -0.04171138f, -0.05508331f, 
    0.04401123f, 0.00010740f, -0.01789771f, 0.00194434f, -0.01457739f, -0.00536973f, 0.00771970f, -0.01903383f, 
    0.03323353f, -0.03088963f, -0.03226960f, -0.01975953f, -0.05382307f, -0.04683962f, 0.04480141f, -0.04156237f, 
    0.04490974f, -0.02809743f, -0.04868861f, 0.04371832f, -0.01727296f, 0.01696394f, 0.00936967f, -0.06652076f, 
    -0.04977696f, 0.02005919f, -0.04856190f, -0.04117586f, 0.04577669f, -0.03229056f, -0.05578524f, -0.02278532f, 
    0.03585150f, 0.01608049f, 0.02362761f, 0.04624325f, 0.01710934f, 0.03077485f, 0.01871674f, -0.06129799f, 
    0.02765941f, -0.00514755f, 0.02271917f, 0.00339010f, 0.02842475f, 0.02184347f, 0.01315688f, 0.04682729f, 
    -0.05725604f, -0.03365723f, -0.02840783f, -0.04664576f, 0.00130832f, 0.04448266f, 0.01430159f, -0.05571614f, 
    0.01377384f, 0.02909729f, 0.02729142f, -0.02960985f, 0.04568573f, -0.04724090f, 0.04266948f, -0.03104934f, 
    0.03706365f, 0.02099103f, -0.06513522f, 0.03933481f, 0.04461186f, 0.04433660f, 0.03403040f, -0.05236348f, 
    -0.04266192f, 0.02020657f, -0.04082306f, -0.06329522f, -0.00788156f, 0.00683426f, -0.06802467f, 0.04244491f, 
    -0.02867985f, -0.03022157f, 0.01688542f, -0.04562707f, 0.02204230f, -0.00446325f, 0.01424090f, 0.01703331f, 
    -0.05033274f, 0.02416464f, 0.03623779f, 0.00331762f, -0.01160032f, -0.00024343f, 0.00357577f, 0.00668652f, 
    -0.04840328f, -0.05183762f, -0.05697344f, -0.00104163f, -0.05191483f, 0.04161589f, -0.05449793f, -0.00702807f, 
    0.04138755f, 0.04804219f, -0.04699825f, 0.00591299f, -0.06945677f, -0.02495435f, 0.01243501f, -0.03197923f, 
    0.04110294f, -0.03200784f, 0.00500933f, 0.04579922f, 0.00211870f, 0.03256765f, -0.02216466f, -0.00712092f, 
    -0.00044428f, -0.02543082f, 0.03675257f, -0.06045903f, -0.03813602f, -0.01560875f, 0.03589668f, 0.03320947f, 
    -0.03139897f, -0.05478559f, 0.04117230f, -0.02616619f, -0.00111667f, -0.05061573f, 0.03761866f, -0.04721694f, 
    0.02092805f, 0.00387780f, 0.04247923f, 0.04240726f, 0.03642726f, 0.04907703f, -0.02503611f, -0.05388992f, 
    -0.04676791f, -0.03724256f, -0.00318523f, -0.02281475f, 0.02947705f, 0.04566055f, -0.03892476f, -0.02537508f, 
    0.04021177f, -0.05544917f, -0.05437285f, -0.02421066f, -0.02698457f, -0.05075713f, 0.03180144f, -0.00719706f, 
    0.04071190f, -0.04654228f, 0.02343762f, 0.03339793f, -0.03276895f, 0.01087454f, -0.06445117f, -0.00635514f, 
    0.00511007f, -0.01647892f, 0.04948295f, -0.00432633f, -0.04031005f, -0.04169441f, -0.04233731f, -0.05823222f, 
    0.04039565f, 0.04848005f, -0.01207519f, -0.06455567f, -0.02728844f, 0.05353580f, 0.01090333f, -0.05382160f, 
    0.04274433f, 0.01773882f, 0.05037353f, 0.03565872f, -0.00196061f, 0.00123371f, 0.02139172f, -0.01543102f, 
    -0.03599295f, -0.00876308f, -0.03533152f, -0.01963858f, -0.00910679f, -0.03434411f, 0.00129912f, 0.03279403f, 
    0.03099328f, -0.04009178f, 0.01898000f, 0.01912526f, 0.01313109f, -0.03085076f, -0.04301916f, 0.03101546f, 
    -0.01279152f, -0.03134666f, 0.03679614f, -0.00589389f, 0.01939942f, -0.01769657f, -0.01390166f, 0.04335384f, 
    -0.01419062f, 0.05185987f, -0.01362023f, 0.04506471f, -0.00871254f, -0.02171793f, -0.01871926f, -0.02531961f, 
    -0.00708668f, -0.02099583f, 0.02365209f, 0.02466173f, 0.04293593f, 0.03131057f, -0.05484309f, -0.05829880f, 
    0.00257077f, 0.05429758f, 0.05061286f, -0.05421237f, 0.01204982f, -0.05292830f, -0.05106788f, -0.02503297f, 
    -0.01458409f, -0.02845295f, -0.03859825f, -0.00168133f, 0.02522404f, 0.01557066f, -0.00013851f, 0.04520778f, 
    0.00051268f, 0.01921736f, -0.01289365f, 0.01105784f, 0.04559554f, -0.03000497f, -0.00576458f, 0.01771652f, 
    0.05438500f, 0.05618972f, -0.02717015f, -0.00028243f, -0.00970017f, 0.03620886f, -0.01573328f, -0.00517045f, 
    0.01167963f, -0.05705187f, 0.01044983f, -0.01719679f, 0.01366980f, -0.04700507f, -0.00103974f, 0.00338119f, 
    0.01761710f, -0.04240288f, -0.02387899f, -0.05356974f, -0.00134898f, -0.03660403f, -0.03559887f, -0.02130522f, 
    -0.03676137f, 0.00790490f, -0.04750055f, -0.05449820f, 0.04484526f, -0.03794628f, -0.02799458f, -0.00243353f, 
    -0.03893591f, 0.03225987f, -0.04083314f, 0.04702952f, -0.00293007f, -0.01090860f, -0.06513570f, 0.01699602f, 
    0.02986972f, -0.00752225f, 0.03149452f, 0.01903944f, -0.03832724f, -0.04926971f, -0.02153483f, 0.04253659f, 
    0.04555589f, 0.01105529f, -0.05860617f, -0.04824046f, 0.01413155f, 0.00609633f, -0.03207365f, 0.04707664f, 
    -0.01932997f, 0.00886421f, -0.02116803f, 0.03868829f, 0.02047852f, 0.04199746f, -0.01669171f, -0.04544683f, 
    -0.00227295f, -0.05415655f, -0.00006508f, 0.02944467f, -0.05697308f, -0.00558187f, -0.05014539f, -0.01934493f, 
    0.01544939f, -0.04928659f, -0.03144762f, -0.00336171f, 0.03469146f, 0.01388340f, -0.02076197f, 0.00104279f, 
    0.00222437f, 0.02501442f, -0.05077825f, -0.04236117f, -0.03147008f, -0.04525665f, -0.01200157f, 0.02395248f, 
    0.03229729f, -0.01329375f, -0.05003474f, 0.00635556f, -0.03461029f, 0.00386648f, 0.03803793f, -0.00138788f, 
    -0.00610523f, -0.04851950f, -0.04503945f, -0.03036011f, 0.02147432f, 0.05279142f, 0.00346142f, -0.04471057f, 
    -0.00635865f, -0.04714449f, -0.06016394f, -0.03316573f, 0.00693112f, 0.04248585f, 0.00377157f, 0.04430862f, 
    0.00545726f, -0.04174029f, -0.00990993f, 0.02060485f, -0.02609284f, 0.02473375f, 0.00274759f, -0.05665834f, 
    -0.00803291f, 0.00294028f, 0.01428451f, -0.01469805f, -0.02478200f, -0.02064309f, 0.01580963f, -0.01112268f, 
    -0.00149217f, 0.02606850f, -0.01451108f, -0.02050348f, -0.03683833f, -0.03928183f, 0.02194243f, -0.00201158f, 
    -0.00290495f, 0.03078639f, -0.04192808f, 0.02962520f, 0.03398742f, -0.06097047f, 0.03265251f, -0.02483549f, 
    -0.01243899f, 0.01077114f, 0.01943558f, -0.05957295f, -0.05716324f, -0.01457159f, -0.00545163f, -0.05272794f, 
    0.00302738f, -0.01830993f, -0.04685543f, -0.05850724f, 0.00810001f, -0.00287183f, 0.03307748f, -0.02553586f, 
    0.05259879f, -0.03907899f, -0.00149191f, 0.00026697f, -0.03372551f, -0.01677423f, 0.04662493f, -0.04231264f, 
    -0.00816399f, -0.03579104f, -0.02757093f, -0.04660247f, 0.03623270f, 0.05623710f, -0.05924265f, -0.03279038f, 
    -0.02000256f, 0.04526860f, 0.01649878f, 0.04152658f, 0.01418781f, 0.04408181f, 0.02240527f, 0.02761449f, 
    -0.00980812f, -0.05926979f, 0.03751460f, -0.05030947f, -0.05865807f, 0.02758683f, 0.03501165f, 0.00729180f, 
    -0.05114758f, 0.00605540f, -0.00692271f, -0.01809501f, -0.01368591f, 0.01577577f, 0.03983425f, -0.02925479f, 
    -0.03538685f, 0.01356717f, -0.03881244f, 0.04844367f, 0.00325567f, 0.04640622f, 0.04041227f, 0.03543365f, 
    -0.03982108f, -0.05046467f, 0.05241635f, -0.00623106f, -0.02994400f, -0.02112278f, 0.02578649f, -0.00819379f, 
    0.02477590f, -0.00276277f, 0.04614411f, 0.04177654f, -0.00292892f, -0.03437937f, 0.01872064f, 0.00031817f, 
    0.02762938f, 0.03333866f, 0.00407030f, -0.02641195f, -0.05543958f, -0.01619900f, 0.00494746f, 0.03161678f, 
    -0.05767012f, -0.01482867f, 0.01256258f, 0.01080835f, -0.03062925f, -0.01759816f, -0.03147852f, -0.02895700f, 
    0.03032200f, 0.01974775f, 0.03017106f, 0.00341331f, -0.05560731f, -0.00881012f, 0.04599489f, -0.01776301f, 
    0.04891106f, -0.03443440f, -0.04482176f, 0.00489269f, -0.04187927f, 0.01267220f, -0.01685335f, -0.00417020f, 
    -0.00097566f, 0.02985048f, -0.05958534f, -0.04112896f, -0.02911606f, 0.02298246f, -0.03591318f, -0.03769273f, 
    0.04762660f, -0.06037952f, 0.02596407f, -0.00948082f, 0.03673564f, 0.01187903f, 0.00578013f, -0.06299224f, 
    0.04715266f, 0.01797027f, -0.03177383f, -0.06459264f, 0.04058340f, -0.00764178f, -0.02309534f, -0.06510862f, 
    0.02707705f, -0.03593701f, -0.01763587f, 0.02216280f, -0.01356995f, -0.00843344f, 0.00780048f, -0.02354481f, 
    -0.00622971f, -0.06006067f, -0.05683484f, 0.01565327f, -0.02447546f, -0.04553663f, -0.03029398f, 0.01975863f, 
    -0.00567329f, -0.01390866f, 0.00895167f, -0.05496748f, 0.03844881f, -0.03354603f, -0.01170437f, 0.00225700f, 
    -0.00018615f, 0.00958856f, -0.05342633f, 0.01962775f, -0.02915204f, -0.04409864f, 0.03941808f, 0.05108942f, 
    -0.01480966f, -0.04053573f, 0.02521090f, -0.01491459f, -0.01707238f, -0.04143896f, -0.01000170f, -0.04860450f, 
    0.04380251f, -0.00759348f, 0.01569301f, -0.04294242f, 0.02566478f, 0.02246477f, -0.02016128f, -0.00076991f, 
    -0.02536665f, 0.04095251f, -0.03069224f, 0.00593677f, 0.02874619f, -0.02523273f, -0.05404463f, -0.05379073f, 
    -0.03437280f, -0.02197045f, -0.03437040f, -0.02840639f, 0.03852014f, 0.02064966f, -0.02342835f, 0.05092786f, 
    -0.06027943f, 0.03700057f, 0.00415622f, -0.05632614f, -0.05529785f, 0.04553052f, -0.04892546f, 0.03619913f, 
    0.00630550f, -0.05327647f, 0.02076538f, 0.00387999f, 0.00836248f, -0.03338324f, -0.05507721f, 0.04069828f, 
    0.00958098f, -0.04585869f, -0.06363200f, -0.00933992f, -0.00821041f, -0.05421478f, -0.02016239f, 0.04599125f, 
    -0.00948456f, 0.04726976f, 0.00924090f, -0.06469779f, 0.04991329f, -0.05254019f, -0.00258501f, -0.01201631f, 
    -0.05652645f, -0.02327020f, 0.02286786f, -0.01341667f, -0.02148386f, -0.03357320f, 0.03934632f, -0.06311370f, 
    0.00027734f, -0.03945641f, -0.01665298f, -0.04622659f, -0.00655243f, 0.02378150f, -0.05261449f, -0.01508730f, 
    -0.04770274f, 0.01067550f, -0.06557483f, 0.04135867f, -0.03966257f, -0.01956369f, -0.00472582f, -0.03058568f, 
    0.03421142f, 0.00804403f, -0.01867523f, -0.04958830f, -0.00069363f, 0.02434147f, 0.01997815f, -0.05561502f, 
    0.03470354f, -0.04498644f, -0.04124139f, 0.00219880f, 0.00099367f, 0.03997481f, -0.01285542f, -0.03191276f, 
    -0.02292570f, -0.03166369f, -0.00188657f, 0.04070983f, 0.02311143f, 0.00854599f, -0.06450182f, -0.03646529f, 
    -0.05227371f, -0.06797709f, 0.00793215f, -0.00708073f, -0.00083615f, 0.04334715f, -0.02700117f, 0.02717766f, 
    0.00030979f, -0.00601176f, 0.00756617f, 0.02167434f, 0.02999967f, -0.05805996f, -0.01054002f, 0.01422713f, 
    0.00664147f, 0.03583132f, 0.00059995f, -0.01722769f, -0.00185483f, 0.02841115f, -0.02557088f, -0.05349107f, 
    -0.01382552f, -0.00907844f, -0.03885639f, -0.05393007f, 0.03365589f, 0.03320857f, 0.03007736f, -0.02547243f, 
    0.00721610f, 0.01934324f, 0.04098414f, 0.00251644f, 0.01365261f, -0.03707240f, -0.05503251f, 0.00386101f, 
    0.12548234f, -0.01880577f, -0.31498906f, -0.02473005f, 0.10920940f, -0.16324279f, -0.19796592f, -0.03968049f, 
    0.25509191f, -0.16739720f, -0.16180044f, 0.15954514f, 0.12705728f, 0.03896271f, -0.12851113f, 0.00917581f, 
    0.07230994f, 0.19137758f, 0.00789233f, 0.09243306f, 0.21834359f, 0.03358230f, 0.19885619f, -0.12247965f, 
    0.24594609f, 0.02199518f, 0.13404624f, -0.39380226f, -0.38340721f, -0.08015548f, -0.35663348f, -0.18160091f, 
    0.05135366f, -0.05623049f, -0.04533555f, -0.16885613f, -0.38399586f, -0.25002560f, 0.17121264f, -0.23110332f, 
    -0.08771148f, 0.15610811f, 0.02124886f, -0.06017194f, -0.07566779f, -0.14049122f, 0.11031280f, -0.16112168f, 
    0.18317798f, 0.08703404f, -0.21856536f, -0.02953780f, 0.13233688f, 0.15708672f, 0.00225754f, 0.13104215f, 
    0.12652981f, 0.08506805f, -0.06737233f, -0.09642112f, 0.18258715f, 0.06545424f, 0.25544241f, -0.17002834f, 
    0.03744991f, 0.02832984f, -0.06431770f, -0.00520764f, -0.10885453f, -0.04797424f, -0.14805497f, 0.18747912f, 
    0.06268850f, -0.22915657f, -0.00498504f, -0.21674466f, 0.18171361f, 0.32888460f, -0.10737398f, -0.22900338f, 
    -0.33064553f, -0.01788454f, 0.01658350f, -0.15227470f, -0.10719489f, -0.18444319f, -0.03376690f, 0.36886767f, 
    -0.04323422f, -0.27419615f, 0.13309923f, -0.07270168f, -0.24980138f, 0.08745956f, -0.04494430f, -0.01699158f, 
    0.02157244f, -0.02692123f, -0.07263194f, -0.11463456f, -0.29300582f, -0.23389170f, -0.11389451f, 0.05280025f, 
    0.02334788f, 0.31090930f, -0.12826225f, -0.05285347f, 0.19780035f, 0.13014725f, 0.37177727f, -0.16415884f, 
    -0.05585898f, 0.14654416f, -0.07746092f, 0.01949069f, 0.37498227f, -0.29185647f, 0.20044000f, 0.18734838f, 
    0.09172296f, 0.07562450f, 0.03792839f, -0.05745935f, -0.16155593f, 0.05274937f, -0.14728226f, 0.14107110f, 
    0.13183413f, 0.02108158f, 0.00369617f, 0.19065173f, -0.20530508f, 0.08742714f, 0.05071553f, -0.19748802f, 
    -0.01700806f, -0.07683811f, 0.26964098f, 0.02429636f, -0.01418400f, -0.32642087f, 0.05079381f, 0.03814877f, 
    0.02072560f, 0.22378038f, -0.10633139f, 0.06458017f, 0.26102313f, 0.29209185f, -0.19253978f, -0.08834734f, 
    -0.04703613f, 0.16587867f, -0.03431209f, 0.04007249f, 0.23022239f, 0.01956711f, -0.05015166f, 0.10201696f, 
    0.01766613f, 0.14301653f, -0.09418174f, 0.06441241f, -0.08142982f, 0.06434316f, -0.06951272f, 0.19504157f, 
    -0.00237373f, -0.01495240f, -0.08874805f, 0.03833167f, 0.04222112f, 0.38246849f, 0.26469156f, 0.04353017f, 
    -0.54022694f, -0.07435315f, -0.10504841f, 0.20158386f, 0.08853761f, 0.01419101f, -0.09581871f, 0.35008880f, 
    0.02534019f, 0.22511961f, 0.10603202f, -0.03697650f, -0.33848000f, -0.04153690f, 0.08694284f, -0.01835013f, 
    -0.04985107f, 0.11566198f, 0.35441083f, -0.29284927f, 0.19419764f, -0.29840386f, -0.07784384f, 0.02838029f, 
    0.09936486f, -0.02830760f, 0.03458299f, -0.03395639f, -0.08741724f, 0.02063195f, 0.32962871f, 0.02049035f, 
    0.03410412f, 0.09944178f, 0.07938012f, 0.06322315f, -0.05191621f, 0.05744256f, -0.05992905f, 0.05287183f, 
    -0.18825938f, -0.42433640f, -0.10790361f, -0.17426735f, -0.16636541f, -0.05997916f, 0.07913502f, -0.18620548f, 
    -0.19777493f, 0.26307720f, 0.03513895f, 0.09151846f, -0.00400367f, 0.13511559f, -0.03401549f, -0.03438064f, 
    0.19833519f, -0.19493313f, -0.15001960f, 0.12405694f, 0.07678802f, 0.04495324f, -0.13947842f, 0.02595123f, 
    -0.16392075f, -0.08753727f, -0.17091867f, 0.00906367f, 0.18363169f, 0.10968113f, -0.02302990f, -0.15509170f, 
    0.07730874f, 0.09300325f, 0.09803601f, 0.08793476f, 0.12977101f, 0.08258293f, 0.02910132f, -0.23226336f, 
    -0.28031701f, 0.09994150f, 0.22896123f, 0.18135148f, -0.00532856f, 0.15689570f, 0.08702859f, -0.02414997f, 
    -0.18317640f, -0.01196731f, 0.17154808f, 0.11574399f, -0.01835734f, 0.03369729f, 0.10384574f, -0.02389765f, 
    0.37330121f, -0.09674381f, -0.26681522f, 0.04113363f, 0.25646701f, 0.01131831f, -0.16385630f, 0.15519194f, 
    0.32271880f, 0.18090872f, 0.05422956f, 0.04761189f, -0.02784752f, 0.05480207f, 0.23551098f, -0.01838602f, 
    0.06470336f, -0.01689497f, -0.19298340f, -0.09486397f, 0.02056524f, -0.15188634f, -0.13766508f, -0.04974277f, 
    0.07565935f, 0.04204928f, 0.04512195f, 0.15851770f, -0.00024467f, -0.15933295f, -0.19570625f, 0.09005733f, 
    0.01611822f, -0.05095889f, 0.47195280f, 0.26740971f, 0.44150466f, -0.25095087f, -0.05580008f, 0.18184631f, 
    -0.04954809f, 0.00727456f, 0.07092924f, -0.23993120f, -0.10909857f, -0.27475941f, 0.17035641f, -0.02011175f, 
    -0.07973902f, 0.19338430f, 0.12716025f, -0.12660152f, -0.03409031f, -0.21862526f, -0.11396253f, 0.19570711f, 
    0.08367781f, -0.04276789f, -0.03550460f, 0.03400201f, 0.18877693f, -0.00077641f, -0.20947415f, -0.30635816f, 
    0.11768295f, -0.18941459f, 0.01883802f, 0.16162638f, -0.12759575f, 0.10584302f, 0.27079269f, -0.06846209f, 
    -0.07460417f, 0.21540102f, -0.10451298f, 0.13661285f, 0.19508018f, -0.10549696f, 0.16618443f, 0.06787446f, 
    0.15129033f, -0.19702426f, 0.04276051f, 0.15191412f, -0.09616812f, -0.05792798f, 0.03793357f, -0.12081732f, 
    -0.16490345f, -0.14232735f, -0.42573625f, 0.18451361f, 0.01720322f, -0.00894556f, -0.17721815f, -0.03696519f, 
    -0.21019414f, -0.36899096f, -0.18105850f, -0.45722160f, 0.03932312f, 0.04271095f, -0.15626211f, 0.15674643f, 
    0.05749653f, 0.18519014f, -0.10219860f, -0.10846451f, -0.17304198f, 0.02802616f, 0.05855727f, -0.00856385f, 
    -0.11077418f, -0.11333494f, -0.08130759f, 0.10491106f, 0.08472741f, 0.05396575f, 0.20195168f, 0.04557521f, 
    0.06807621f, 0.13098441f, 0.16224474f, 0.15708561f, 0.13952965f, 0.21359311f, 0.36903664f, 0.08824297f, 
    -0.20972189f, -0.04359310f, 0.07515413f, -0.14873984f, 0.31172422f, 0.14140436f, -0.06011279f, -0.23694864f, 
    0.23710258f, -0.07165628f, 0.03987337f, -0.09970505f, 0.00444971f, -0.14561772f, -0.25629702f, -0.25571600f, 
    -0.38007563f, 0.10933927f, 0.20263569f, 0.03116102f, 0.02797912f, 0.02395557f, -0.25454488f, -0.30003813f, 
    0.08642096f, -0.18294816f, 0.14423311f, 0.17394733f, 0.01271696f, 0.09428789f, -0.14192075f, -0.19841108f, 
    -0.01681772f, -0.09837707f, 0.09773090f, -0.07009374f, 0.01383131f, -0.05522476f, 0.18036261f, 0.08307612f, 
    -0.15981933f, 0.22440599f, 0.17272986f, 0.37633768f, -0.14139289f, -0.02942793f, 0.07363640f, -0.04668717f, 
    0.04480179f, 0.08981013f, 0.21533160f, 0.01126852f, -0.07597015f, 0.16241966f, -0.13163330f, -0.11452571f, 
    0.17919707f, -0.01147810f, -0.02515684f, 0.00896272f, 0.02394677f, 0.34765053f, -0.06673250f, 0.16215840f, 
    -0.14213529f, -0.07874967f, 0.07882892f, 0.09902845f, -0.17755857f, -0.14868960f, -0.05306735f, -0.17817630f, 
    0.03167310f, -0.01785121f, -0.05688744f, 0.02798438f, 0.03775288f, -0.18857370f, -0.34916335f, -0.13318089f, 
    -0.01134477f, -0.21279813f, 0.16534372f, 0.05205547f, -0.14538802f, 0.00064058f, 0.15601197f, -0.12432981f, 
    0.02956999f, 0.22382301f, 0.06382105f, 0.20883958f, -0.02425921f, 0.06449935f, 0.02948591f, 0.19766779f, 
    0.21651402f, -0.02066925f, 0.04885955f, -0.25466681f, -0.06081447f, 0.09462807f, -0.12489255f, -0.17062914f, 
    0.05928458f, -0.06024722f, -0.02784595f, 0.08184759f, -0.04256285f, -0.00496709f, -0.05242215f, -0.11223290f, 
    -0.26373050f, -0.32997188f, -0.16349766f, -0.39799193f, 0.09587528f, 0.07363693f, -0.08778141f, -0.02311491f, 
    -0.13376981f, -0.14450961f, 0.15269528f, 0.12919649f, -0.17590424f, 0.20007721f, 0.04121257f, 0.09053473f, 
    -0.03472986f, -0.14136614f, 0.37965763f, 0.43258205f, 0.19326161f, 0.33441982f, -0.10831030f, 0.00830806f, 
    0.06362828f, -0.00463254f, -0.01148113f, -0.02766293f, 0.16399680f, 0.05842016f, 0.36071479f, -0.14932841f, 
    0.08945484f, 0.02045533f, 0.08872344f, -0.05581205f, 0.19131483f, 0.31765375f, -0.12294292f, 0.12378161f, 
    0.02191957f, -0.11636992f, -0.15592967f, 0.07295255f, -0.06817821f, 0.13681825f, 0.28636581f, -0.05065782f, 
    0.16883795f, -0.01767284f, 0.05468105f, 0.02661706f, -0.01679636f, -0.20102999f, 0.02400311f, -0.02881420f, 
    -0.05766277f, 0.46923780f, 0.21154828f, -0.00126106f, -0.15332744f, 0.11792213f, 0.23195383f, -0.11473282f, 
    -0.01326744f, -0.52130955f, 0.02282699f, 0.07306287f, -0.06591135f, -0.06893732f, -0.28501272f, -0.02585682f, 
    0.05580235f, 0.40588602f, -0.05132969f, -0.06494557f, -0.19402289f, -0.08565065f, -0.08892060f, 0.14817289f, 
    0.17061861f, -0.02383260f, 0.37388763f, -0.27210826f, -0.14349550f, 0.06048351f, 0.09077682f, -0.14127028f, 
    0.18525054f, 0.10200276f, -0.16287178f, -0.24628639f, -0.10329331f, -0.47284478f, -0.08246148f, -0.17336778f, 
    -0.08023615f, -0.23561880f, 0.18805751f, -0.10917617f, -0.15334122f, -0.59291929f, 0.00050719f, -0.18985564f, 
    0.11090577f, 0.19075996f, 0.04594706f, 0.16094014f, 0.12039708f, 0.12612408f, 0.05108417f, 0.12564544f, 
    0.03004657f, -0.06138520f, -0.04659177f, -0.05772171f, 0.15443878f, 0.09458717f, -0.36767578f, -0.02147945f, 
    0.38210237f, 0.10814726f, -0.20962460f, 0.05624518f, 0.07368643f, 0.04904340f, -0.00845592f, 0.34685770f, 
    -0.27239716f, -0.49591872f, -0.11562197f, -0.17251459f, 0.04612668f, 0.07539546f, -0.11336860f, -0.02423371f, 
    0.02471946f, -0.07219984f, -0.17275855f, -0.10541887f, 0.15278147f, 0.09478647f, -0.00142571f, -0.12083305f, 
    0.10854832f, 0.33060375f, 0.19669130f, 0.32040322f, -0.20907080f, -0.13543628f, -0.01183721f, -0.02707966f, 
    0.07977092f, -0.06997038f, -0.05547560f, 0.09728242f, 0.00275253f, 0.03896832f, -0.15906508f, -0.05498802f, 
    -0.09686354f, -0.00939821f, 0.01686193f, 0.12732355f, -0.22692308f, -0.16987428f, -0.23552160f, -0.09283531f, 
    -0.03209795f, -0.23025315f, -0.03677920f, -0.15944768f, 0.00610063f, 0.05762693f, 0.07014398f, -0.04400689f, 
    -0.02338509f, -0.03832551f, 0.19839491f, 0.15714878f, -0.01787279f, -0.16657601f, -0.07289463f, 0.02788962f, 
    0.08879856f, -0.08531606f, 0.19308218f, 0.03459278f, -0.01406518f, 0.16611677f, -0.16298896f, -0.16479772f, 
    0.15987711f, -0.29312271f, -0.06109275f, 0.09511802f, -0.11296646f, -0.14846982f, -0.08011203f, 0.24870369f, 
    -0.27301052f, -0.02881548f, -0.05135430f, -0.06033624f, 0.15112951f, 0.12557901f, 0.01905009f, 0.05273044f, 
    0.38391876f, 0.26577494f, 0.05211341f, -0.00670841f, -0.22344781f, -0.02612586f, -0.12996860f, -0.01031351f, 
    0.12068971f, 0.09482066f, 0.15235595f, 0.14321522f, 0.33909068f, 0.01186472f, -0.07773031f, 0.17703238f, 
    -0.03741501f, 0.20438686f, -0.15123923f, 0.35381320f, 0.52598441f, 0.08692998f, -0.01847829f, 0.14356203f, 
    -0.11675213f, -0.04511716f, 0.13235509f, 0.50243509f, -0.02131944f, 0.16610815f, 0.21892537f, 0.06966840f, 
    -0.05258032f, 0.08096170f, -0.03745663f, -0.01389282f, 0.13512760f, 0.41231278f, -0.00027382f, -0.00659341f, 
    0.15379567f, 0.18247549f, -0.00932198f, -0.03755432f, 0.10623752f, 0.01954125f, 0.24131876f, -0.05002417f, 
    -0.09681086f, 0.14380817f, 0.03783346f, -0.21604915f, -0.02159288f, -0.10209658f, -0.32107779f, -0.20824425f, 
    -0.04733460f, -0.06448424f, -0.01074756f, 0.18070012f, -0.13497369f, -0.03547091f, 0.05188045f, -0.28498191f, 
    -0.13299713f, -0.10649664f, 0.11404666f, -0.17973652f, 0.00259750f, 0.10344896f, -0.18246163f, 0.08256640f, 
    -0.50967580f, -0.42726037f, -0.50891936f, -0.14254691f, -0.02899631f, -0.05567820f, -0.10023619f, -0.04121701f, 
    -0.01640391f, 0.61786121f, -0.08677562f, 0.04364329f, 0.15021147f, -0.15171373f, 0.01273994f, -0.05369633f, 
    -0.29200736f, 0.03110061f, 0.03497295f, 0.16201237f, 0.10064967f, -0.18944132f, -0.16989057f, -0.19361141f, 
    0.02047424f, -0.04286940f, -0.03724235f, 0.08562216f, 0.01732114f, -0.14756088f, -0.01376921f, 0.14320427f, 
    -0.02282638f, -0.12968576f, 0.15341961f, 0.08468489f, 0.05277392f, 0.30852914f, 0.00765598f, 0.01951057f, 
    0.20984614f, 0.06258117f, 0.03730771f, 0.22981369f, 0.33433747f, -0.15609410f, 0.04870228f, 0.07440948f, 
    0.00399344f, 0.03889694f, -0.09790783f, -0.01206046f, 0.01091924f, -0.12346905f, -0.16285910f, 0.04022451f, 
    0.16046220f, 0.03796533f, -0.10145728f, 0.06768294f, -0.28483534f, 0.07162513f, -0.16716537f, 0.20727722f, 
    0.20771942f, 0.04549944f, 0.15346944f, 0.12907015f, -0.00639957f, -0.21709879f, 0.06325139f, -0.23891836f, 
    0.01830084f, -0.00305666f, -0.04431798f, 0.03571007f, 0.06034018f, 0.01354819f, -0.03913135f, -0.00612083f, 
    0.03832120f, 0.00081596f, -0.05104246f, -0.02277969f, -0.05870092f, -0.01509998f, -0.03303892f, 0.03649646f, 
    0.00109073f, 0.00881037f, 0.01019103f, -0.02393869f, -0.04330776f, 0.00244987f, -0.03930733f, 0.03529831f, 
    -0.00235319f, 0.00662474f, -0.06297188f, -0.02200990f, 0.03055554f, 0.01942444f, -0.06109382f, 0.06094426f, 
    -0.04501330f, -0.04044870f, -0.00887490f, -0.05832614f, 0.04473137f, 0.02697779f, 0.04798974f, 0.00539645f, 
    -0.02466264f, -0.04754240f, -0.00534507f, -0.02625393f, -0.06377214f, -0.03401456f, -0.03952766f, -0.05987509f, 
    -0.06084588f, 0.04174601f, 0.03048858f, -0.00718492f, -0.05682940f, 0.02469584f, 0.04266478f, -0.05039174f, 
    -0.00202119f, 0.04655451f, 0.01344923f, -0.03807442f, 0.03496837f, -0.04297254f, -0.04802471f, -0.01672756f, 
    -0.05017270f, -0.00015504f, -0.00215565f, 0.03105528f, 0.04660814f, 0.02817243f, 0.01409679f, -0.05404313f, 
    0.00274975f, 0.01637865f, -0.00800323f, 0.04013970f, 0.03052352f, -0.06006525f, -0.01597080f, 0.03421389f, 
    0.00124263f, -0.02209859f, 0.03000459f, 0.02425000f, -0.01938560f, -0.01455045f, -0.03583484f, 0.00054845f, 
    -0.03743339f, 0.04265223f, 0.03432102f, -0.01717884f, -0.04375826f, 0.02512532f, 0.02086873f, -0.01192344f, 
    0.02766941f, -0.04769637f, 0.03265632f, -0.00774308f, 0.00115015f, 0.03122044f, -0.00466361f, -0.04260359f, 
    -0.01494338f, -0.02018235f, 0.02284207f, -0.02599520f, -0.01948792f, -0.05597560f, 0.05165452f, -0.02371914f, 
    -0.00658438f, 0.00538073f, -0.05251744f, -0.04319381f, -0.02179283f, -0.01800638f, -0.00428692f, -0.03587555f, 
    0.04061879f, -0.05436156f, -0.04275657f, -0.03523590f, -0.05973747f, 0.01081385f, -0.05643589f, -0.04228203f, 
    -0.03824301f, 0.04164785f, 0.00058586f, -0.06157091f, -0.01621149f, -0.05612079f, 0.02772681f, -0.03775981f, 
    0.05270462f, -0.03650429f, 0.04971928f, -0.04553436f, 0.03155985f, 0.03535162f, -0.05847438f, 0.04277542f, 
    0.00260886f, 0.00563835f, 0.01953619f, 0.04046748f, -0.01510007f, -0.00776241f, 0.03011604f, 0.01771564f, 
    -0.05259324f, -0.01308599f, -0.03767801f, 0.00784719f, -0.06336579f, -0.06226304f, 0.00662314f, -0.02515569f, 
    -0.04309413f, 0.04426619f, 0.04565915f, 0.02149764f, -0.00575359f, 0.05363744f, -0.01069702f, 0.02523307f, 
    -0.06331407f, -0.01009311f, 0.02280877f, 0.03507851f, -0.01783569f, -0.06130427f, 0.00697690f, 0.03520672f, 
    0.01780586f, -0.01755909f, 0.03002322f, -0.04563046f, -0.06110420f, -0.02840186f, 0.03730919f, 0.03153472f, 
    0.02539834f, -0.00430278f, -0.00118201f, 0.00234250f, -0.05918894f, 0.02118465f, -0.02174261f, -0.03735555f, 
    0.04734088f, -0.00514304f, 0.02589297f, -0.00770205f, 0.02789805f, -0.05903184f, -0.03485374f, -0.01046169f, 
    0.05185898f, -0.03026320f, 0.01099890f, 0.00424112f, -0.01730074f, 0.00861199f, 0.00087859f, -0.02270485f, 
    -0.01424733f, 0.01958550f, 0.03334078f, -0.04681257f, -0.01124123f, -0.00466778f, 0.02548364f, 0.02593127f, 
    -0.05440629f, -0.05033999f, 0.00791150f, -0.03609062f, -0.02744186f, -0.04139148f, -0.03323856f, -0.06398644f, 
    0.01005910f, -0.00053052f, 0.02463606f, -0.04951319f, -0.00756449f, 0.03395681f, 0.03332767f, -0.06029917f, 
    -0.06457240f, -0.01009085f, -0.05130627f, -0.00579040f, -0.00680942f, -0.01320501f, 0.04500163f, -0.01766359f, 
    -0.01673251f, 0.03252985f, -0.05812632f, 0.02399384f, 0.00387984f, -0.03778746f, -0.01634096f, -0.06484856f, 
    0.03866470f, 0.02955167f, 0.00274660f, -0.04023792f, 0.03362586f, -0.02559951f, 0.03711166f, 0.04098453f, 
    0.04868131f, 0.04850404f, 0.01570514f, -0.00670451f, 0.00892578f, -0.01173152f, -0.02806682f, -0.05728120f, 
    -0.05528558f, 0.01615783f, 0.00964977f, -0.04232581f, -0.00066546f, 0.02832805f, 0.02733871f, -0.00078792f, 
    -0.01045373f, 0.02927312f, -0.04826006f, -0.06034477f, -0.04386252f, 0.00770400f, 0.02133560f, 0.04882655f, 
    0.04228795f, -0.03489640f, 0.05086672f, 0.00714089f, -0.02930598f, 0.00567796f, -0.04880344f, 0.04522997f, 
    0.01130755f, 0.01739670f, 0.08732059f, -0.07319751f, 0.06375235f, -0.09266651f, -0.08375254f, -0.06365858f, 
    0.00791216f, 1.04121137f, 0.20870206f, 0.12236448f, -0.04480334f, 0.00827618f, 0.22133502f, -0.11664739f, 
    0.12413741f, -0.00471628f, 0.46372858f, -0.30238706f, 0.08252156f, -0.14252941f, -0.13275515f, 0.10163870f, 
    0.06284463f, 0.09320402f, -0.16925801f, -0.46298039f, 0.06664498f, -0.08021605f, -0.40435177f, -0.03004771f, 
    -0.39457160f, 0.05145583f, -0.00090417f, -0.02561998f, 0.06683399f, 0.29659054f, 0.20703976f, -0.20369093f, 
    -0.07174648f, -0.11067384f, -0.09735326f, 0.13124265f, -0.09006663f, -0.43249273f, -0.12271468f, -0.21229504f, 
    0.04823579f, -0.11703469f, -0.24445298f, -0.17878804f, 0.02071287f, 0.14673126f, 0.08549578f, 0.06387956f, 
    0.09499811f, -0.17653450f, -0.07525720f, 0.04217663f, -0.01908948f, -0.07515220f, -0.10233275f, 0.02244608f, 
    0.14174360f, 0.05804999f, -0.04268919f, 0.01864280f, -0.20066465f, -0.12940176f, 0.07167096f, -0.06076806f, 
    -0.52467394f, -0.37414205f, -0.36551863f, -0.04261342f, 0.15686722f, -0.05659774f, 0.11240151f, 0.21692434f, 
    -0.05944654f, -0.50976259f, 0.00604907f, -0.59033388f, -0.08968197f, -0.24032089f, 0.16928677f, 0.12883553f, 
    0.07512655f, 0.01978835f, -0.58391613f, -0.06688372f, 0.25980356f, 0.01698791f, -0.03285255f, -0.08259097f, 
    0.04806856f, 0.02708563f, -0.04873234f, 0.08014344f, 0.42014769f, 0.08563294f, -0.08474646f, 0.03927579f, 
    -0.14302364f, 0.09920894f, 0.08904241f, -0.01663683f, 0.09466151f, 0.28535661f, 0.21026257f, -0.01694623f, 
    0.00318521f, 0.20413774f, -0.08547518f, 0.05289615f, 0.11923572f, 0.10129611f, 0.13779357f, 0.06880251f, 
    -0.05075382f, 0.16431446f, -0.15209351f, -0.05883824f, -0.02379262f, -0.11369875f, -0.01795528f, -0.18019518f, 
    0.30273867f, -0.06557335f, 0.09764709f, -0.11586010f, 0.31232965f, 0.03856614f, 0.15978815f, 0.24481441f, 
    0.32856449f, -0.00077590f, -0.12473052f, 0.11287941f, -0.17203631f, -0.20647615f, 0.08228731f, 0.16103804f, 
    0.01949017f, 0.33397752f, -0.36355728f, 0.06287327f, 0.08570289f, -0.09667505f, 0.01921087f, -0.20530276f, 
    0.01523697f, 0.29043707f, -0.41297236f, 0.06922133f, 0.26041567f, -0.20121613f, -0.05442245f, 0.06057112f, 
    -0.04988274f, -0.02416469f, 0.13785531f, -0.39848283f, 0.08134306f, -0.00812846f, -0.06508472f, -0.33162582f, 
    0.03517988f, -0.11624309f, -0.06921890f, -0.50774074f, -0.04924713f, 0.31406179f, -0.12106532f, -0.11879025f, 
    0.10627513f, 0.07928526f, 0.11911578f, 0.18782863f, -0.34113643f, -0.15285482f, -0.34106129f, -0.09188624f, 
    -0.15459846f, 0.08665988f, 0.27293837f, -0.10890464f, 0.23814224f, -0.39132783f, -0.29524550f, -0.54623550f, 
    0.10041507f, -0.13199960f, 0.30382556f, 0.10665498f, 0.05366014f, -0.02463352f, 0.22996449f, -0.22985275f, 
    0.17305335f, 0.02070999f, 0.04633945f, 0.01609371f, -0.02084404f, 0.06515872f, -0.02617779f, 0.41561562f, 
    -0.05501664f, -0.01955770f, 0.13857593f, -0.23562469f, 0.02473278f, 0.24848691f, 0.04188492f, 0.03252524f, 
    -0.08220336f, 0.06311872f, 0.08395347f, -0.14947589f, 0.23331319f, 0.30059677f, -0.05468349f, 0.01266609f, 
    -0.03941824f, -0.11741254f, -0.13047947f, -0.13671827f, 0.12565415f, -0.12745273f, -0.04301021f, 0.25148359f, 
    0.13954866f, 0.14386350f, -0.74084902f, -0.05585616f, -0.06071981f, 0.19904718f, 0.16077492f, 0.13634630f, 
    0.12151220f, -0.04410922f, 0.07990585f, 0.68834817f, -0.19904710f, -0.03084406f, 0.17253682f, -0.01136833f, 
    0.15088093f, 0.17731678f, 0.08769938f, -0.08973984f, -0.31780803f, -0.13143134f, -0.05333976f, 0.08721815f, 
    -0.10550681f, 0.03905838f, 0.13381185f, 0.03619699f, 0.02324865f, 0.30154693f, -0.28973651f, 0.03008662f, 
    0.05702654f, 0.04481615f, 0.03957177f, 0.01159349f, -0.03538697f, 0.16547348f, -0.66705847f, -0.54255861f, 
    0.09989380f, 0.18266878f, 0.10436395f, 0.11974357f, 0.01703723f, 0.06990398f, 0.24722111f, 0.00969494f, 
    0.27041075f, 0.18549596f, -0.07571492f, -0.17622344f, 0.17814994f, -0.20977481f, -0.08793511f, -0.01306163f, 
    0.40143469f, 0.53835678f, -0.21251872f, -0.17979203f, -0.03623158f, 0.21515928f, -0.10880568f, 0.08190535f, 
    -0.02676696f, -0.27696559f, -0.04226637f, -0.22917086f, -0.16402173f, 0.14093541f, -0.03230906f, -0.06103715f, 
    0.04951840f, 0.04536445f, 0.11395141f, 0.09996265f, 0.12731276f, -0.23485172f, -0.13721420f, 0.02066576f, 
    0.13515262f, -0.01069453f, 0.15977243f, 0.36415979f, -0.08988518f, 0.02430233f, -0.03769783f, 0.07775636f, 
    0.07757524f, -0.03432808f, 0.04142313f, 0.00827095f, -0.29864195f, 0.32339087f, 0.13023521f, 0.08281931f, 
    0.15996934f, 0.13641144f, 0.01306019f, 0.13175499f, -0.14321788f, 0.44898903f, -0.38266212f, -0.44546673f, 
    -0.24093829f, 0.04449061f, -0.13779630f, -0.09813855f, 0.09339260f, -0.08407622f, -0.38774976f, -0.17427188f, 
    -0.05509531f, -0.11564836f, 0.03508440f, 0.08449680f, -0.09669098f, -0.04679948f, 0.11355624f, 0.17199904f, 
    -0.32624882f, -0.09394938f, 0.10020519f, -0.01812021f, 0.05468503f, -0.01407473f, -0.03613475f, -0.21131197f, 
    0.19495124f, 0.17770733f, -0.09212486f, 0.08956978f, 0.13848102f, 0.14414234f, 0.03637698f, 0.10733101f, 
    -0.05460391f, 0.03099963f, 0.02683849f, 0.05227022f, -0.01142812f, 0.27489045f, -0.23159313f, -0.09457137f, 
    -0.02749333f, 0.09129947f, 0.38154277f, 0.06419358f, 0.00778569f, 0.03465925f, -0.06571311f, -0.03493867f, 
    -0.30574736f, -0.04278578f, 0.03859346f, -0.22682957f, 0.03657631f, 0.00628739f, -0.04356995f, 0.00633024f, 
    0.04517253f, -0.07425828f, 0.07272279f, -0.13973902f, 0.00886217f, -0.14279607f, 0.27040434f, -0.25498566f, 
    -0.24825487f, -0.23095649f, -0.04762723f, -0.16584133f, -0.05592775f, -0.39440092f, 0.06597061f, -0.08182619f, 
    0.03125990f, 0.19476773f, 0.08992657f, 0.00579324f, 0.04628992f, -0.07072774f, 0.45369151f, 0.55929762f, 
    0.05821943f, 0.12182163f, 0.19374344f, 0.01870865f, -0.05594371f, -0.04020263f, -0.01749375f, -0.23594764f, 
    0.16326483f, 0.08740609f, 0.11743534f, 0.01760571f, 0.09310710f, -0.18952924f, -0.01645218f, 0.29595524f, 
    -0.27637789f, -0.48275772f, -0.10630916f, 0.13341774f, 0.18791498f, -0.13130413f, 0.06751497f, -0.08645870f, 
    0.12197343f, 0.40620247f, 0.11720019f, -0.18492323f, -0.15912466f, -0.20330842f, 0.04650604f, -0.17680554f, 
    -0.00440728f, 0.22763783f, 0.59796685f, -0.06962366f, -0.30623329f, -0.19586988f, -0.29875684f, 0.07007072f, 
    -0.06832264f, -0.01957195f, -0.30517587f, 0.35666323f, 0.13350505f, -0.10629084f, -0.17705879f, -0.53405094f, 
    -0.22983496f, -0.19217788f, 0.17756970f, 0.10730282f, 0.01008854f, -0.19668142f, 0.04009464f, 0.10553390f, 
    -0.11648230f, -0.03442749f, 0.00940736f, -0.15729062f, 0.05793988f, -0.44648838f, -0.22464105f, -0.20509617f, 
    0.07508062f, 0.03328310f, 0.03467651f, 0.23145142f, 0.14854416f, -0.01026083f, -0.48241201f, 0.05593693f, 
    -0.00217991f, 0.13429943f, 0.23999670f, 0.07515521f, -0.08627573f, 0.03504508f, 0.04871750f, -0.75361240f, 
    0.14645128f, -0.12391413f, 0.04468200f, 0.17088155f, -0.00413827f, 0.05512072f, -0.06107343f, 0.12886746f, 
    0.14984515f, 0.20977601f, -0.01636661f, 0.06866775f, -0.06687918f, 0.19467595f, -0.02016783f, 0.19736436f, 
    -0.06282666f, 0.24662960f, 0.13651983f, 0.10687818f, -0.13827795f, 0.08549024f, -0.17542638f, 0.05267982f, 
    0.02544193f, 0.10696031f, 0.86113805f, -0.12944344f, -0.24045634f, 0.02588542f, 0.24404438f, 0.19146645f, 
    -0.25531641f, -0.12452658f, 0.13812725f, 0.41627342f, 0.03774592f, 0.04095807f, -0.10657027f, 0.06694957f, 
    0.23638205f, 0.13228174f, 0.07435526f, 0.08438560f, 0.15233724f, -0.11365586f, 0.08023641f, -0.12422988f, 
    -0.15831089f, -0.13680878f, 0.04757234f, 0.00982505f, -0.06843117f, 0.29480726f, 0.13749477f, 0.22667700f, 
    -0.15977311f, -0.20743904f, -0.14862050f, -0.03270436f, 0.04949868f, 0.11820265f, 0.14271888f, 0.02828728f, 
    -0.01421791f, -0.07178981f, -0.04491901f, -0.02584626f, 0.01753303f, -0.10907394f, -0.03230816f, 0.10504228f, 
    -0.09472849f, -0.03046270f, -0.49338675f, 0.08759135f, 0.05669413f, 0.05922521f, -0.13845316f, 0.06365936f, 
    -0.02648843f, -0.16008402f, -0.01727929f, -0.02073359f, 0.03283394f, 0.08736906f, -0.11443751f, 0.05398728f, 
    -0.01338764f, 0.14861086f, 0.07941168f, 0.10447559f, 0.12188657f, 0.17809334f, 0.09979601f, 0.09630781f, 
    0.26878971f, -0.13550994f, -0.17726259f, -0.16257650f, -0.16970661f, 0.00679487f, 0.11039965f, 0.07591431f, 
    0.04996011f, 0.05248489f, -0.01918384f, 0.42588940f, -0.19868562f, -0.06157449f, 0.19094051f, -0.19941424f, 
    -0.27922723f, -0.04315763f, 0.13565743f, 0.21098927f, 0.39467761f, -0.13258791f, 0.02972670f, 0.03026561f, 
    -0.00552225f, -0.20370112f, 0.07559173f, -0.04201987f, 0.13163066f, 0.18077610f, 0.10040367f, 0.00229923f, 
    -0.00109721f, -0.12758182f, -0.08736531f, -0.04393940f, -0.23304337f, -0.05842142f, 0.12721293f, -0.04804775f, 
    -0.03724764f, 0.01514331f, 0.03346848f, 0.04149507f, 0.12125698f, 0.01071449f, 0.26979846f, 0.21707328f, 
    -0.21716580f, -0.46843022f, 0.32816371f, -0.11310799f, 0.03860294f, 0.01646933f, -0.19553550f, 0.09236729f, 
    0.15580446f, 0.42258081f, 0.24206387f, 0.04191530f, 0.08144426f, 0.03751626f, 0.08646681f, -0.10927910f, 
    -0.14945890f, 0.14595160f, -0.27624083f, 0.13072915f, 0.16528849f, -0.07769796f, -0.18324822f, 0.11273298f, 
    0.07260697f, -0.06455374f, 0.05501841f, 0.11249835f, -0.05108039f, -0.10819246f, -0.03455114f, 0.03651568f, 
    -0.01910165f, -0.11798403f, -0.08228230f, 0.05477808f, -0.07592519f, 0.07499128f, 0.30912954f, 0.04882117f, 
    -0.09747483f, 0.02025966f, 0.05738473f, -0.07697278f, -0.21512541f, 0.00862403f, -0.20162512f, -0.07623632f, 
    0.16673687f, -0.05892290f, -0.12591571f, 0.07765631f, 0.24103387f, 0.09581631f, -0.39004746f, 0.05056654f, 
    0.21487418f, -0.08073226f, -0.07117277f, 0.12627181f, -0.20584354f, -0.11771293f, 0.45125365f, -0.01110666f, 
    -0.02049163f, 0.12588647f, 0.12897959f, 0.25280786f, -0.10826496f, 0.14983203f, 0.13237995f, 0.15043706f, 
    -0.21617922f, -0.19622628f, 0.24636753f, -0.02837574f, 0.13906024f, -0.02508342f, -0.05034327f, -0.20951557f, 
    0.44034243f, -0.27956623f, -0.25195047f, 0.05425034f, -0.34925368f, 0.10249681f, -0.00831033f, 0.07425667f, 
    -0.27671888f, -0.04920508f, -0.00978238f, -0.05652752f, 0.24759841f, 0.00901640f, 0.03085157f, -0.08052397f, 
    0.12005258f, -0.00347941f, 0.00895608f, 0.12125006f, -0.01636344f, -0.13504967f, -0.06915530f, 0.06368063f, 
    -0.34508350f, 0.09006146f, 0.23194848f, 0.27165556f, 0.10011844f, 0.05098034f, -0.01004315f, -0.24364343f, 
    -0.44208649f, -0.12435026f, 0.02712122f, -0.07487004f, -0.01915260f, 0.03870077f, 0.08988683f, -0.05992549f, 
    0.16487336f, -0.20330967f, -0.36062348f, -0.20203793f, 0.06045345f, 0.03214987f, -0.07422128f, 0.08710840f, 
    -0.14927903f, 0.04387248f, 0.02356289f, -0.22665238f, 0.06717705f, 0.07581830f, -0.15306555f, 0.09118870f, 
    -0.18637006f, 0.08645003f, 0.13729404f, 0.14265479f, -0.13912828f, -0.09576417f, 0.17512451f, -0.20761286f, 
    -0.31293386f, -0.24962504f, 0.03258724f, 0.22886710f, 0.10526105f, 0.11680417f, -0.03494357f, -0.11108851f, 
    0.14326213f, 0.28776854f, -0.25541088f, 0.08800800f, -0.10796135f, -0.09521805f, 0.14246476f, -0.08126707f, 
    0.06830872f, -0.30960414f, -0.06738152f, 0.18143871f, -0.02498103f, 0.06140645f, 0.13632584f, 0.10453142f, 
    -0.04962735f, -0.15851466f, -0.51681697f, 0.29840666f, -0.12602657f, -0.18728977f, -0.37412271f, -0.04230478f, 
    0.13674909f, 0.09879255f, -0.11202284f, -0.28462180f, -0.21604295f, 0.07135029f, 0.27085412f, -0.10918172f, 
    0.03174904f, -0.02092648f, 0.06201837f, 0.08938038f, -0.06409306f, -0.09544225f, 0.11970194f, -0.02825794f, 
    0.13597086f, -0.01997625f, -0.13106513f, -0.17485225f, 0.18503314f, -0.19682261f, 0.14938013f, -0.03845542f, 
    -0.07394078f, 0.06844779f, 0.22393148f, -0.01588791f, 0.15312870f, -0.03533715f, -0.06067017f, 0.00522801f, 
    -0.09692729f, 0.08574027f, -0.16661775f, -0.05001883f, 0.08260830f, 0.06698798f, -0.23767720f, 0.42282233f, 
    0.27911893f, 0.05795190f, 0.05982858f, -0.11242295f, -0.28930199f, 0.02358780f, 0.17549963f, 0.15099938f, 
    -0.01322195f, 0.19509995f, -0.08212841f, -0.03307766f, -0.12111763f, -0.07995335f, 0.27930492f, 0.10500570f, 
    0.38696748f, -0.21573539f, 0.14669463f, 0.00593099f, 0.17366698f, -0.06792383f, 0.04301335f, 0.00196010f, 
    0.19658384f, 0.07639039f, 0.47479630f, 0.33543527f, -0.13208100f, 0.10165701f, 0.11465160f, 0.00823815f, 
    0.00744954f, 0.29097411f, -0.02448007f, -0.00531142f, -0.15714715f, -0.13958760f, 0.17169401f, 0.08339991f, 
    -0.12072933f, 0.04705391f, -0.27811676f, 0.06642329f, -0.13905446f, -0.33676314f, -0.07105717f, 0.13341752f, 
    0.02327096f, -0.17254651f, -0.17867152f, 0.00771908f, -0.04682594f, -0.35912439f, -0.00490822f, -0.09661122f, 
    0.13772593f, -0.24993019f, 0.16329190f, 0.11880538f, -0.08163719f, 0.23950651f, -1.18485808f, -0.64564079f, 
    -0.21346693f, -0.07629516f, 0.00790606f, -0.07794434f, 0.05051478f, 0.13015941f, 0.00932758f, -0.36117476f, 
    -0.14483273f, -0.35898927f, 0.05194043f, -0.06052005f, -0.09234805f, 0.02989225f, -0.11877761f, 0.10962626f, 
    0.24019851f, 0.18501812f, 0.26200840f, 0.16507621f, -0.07327551f, 0.18994747f, -0.21925431f, -0.00148388f, 
    0.25795695f, 0.11903805f, -0.45505822f, -0.38703927f, -0.01326357f, 0.01436316f, -0.17341433f, 0.07630486f, 
    0.09787250f, 0.17373891f, 0.34418878f, 0.31926623f, 0.03802618f, 0.28342545f, -0.13853663f, 0.21304475f, 
    0.03291545f, 0.15372588f, 0.02390863f, 0.26435366f, -0.17873879f, -0.08705601f, 0.11621660f, 0.06611950f, 
    0.07832089f, 0.00867893f, 0.09230059f, 0.30733231f, -0.13388918f, 0.26693204f, -0.10303368f, -0.20271206f, 
    -0.15895477f, -0.06564783f, -0.09551395f, 0.08116077f, -0.06866631f, -0.84899974f, -0.65772724f, 0.05870197f, 
    0.05578550f, 0.12488469f, 0.12093092f, 0.03271368f, -0.11573452f, 0.03971371f, 0.33934063f, 0.23824899f, 
    0.46968594f, 0.23034295f, 0.03212452f, 0.28261265f, -0.13280325f, -0.07730655f, -0.05970762f, -0.35837042f, 
    -0.29917455f, 0.04462367f, 0.24780050f, 0.10332885f, 0.15792437f, 0.04961227f, -0.29670462f, -0.03763109f, 
    0.37121966f, 0.29698589f, 0.11195827f, -0.00577341f, -0.04682250f, 0.14399798f, 0.16482468f, -0.05369562f, 
    0.26688465f, 0.18993960f, 0.02030308f, -0.08051014f, -0.02934577f, 0.21573696f, -0.04222323f, 0.15550229f, 
    0.19197766f, -0.14629532f, 0.10850817f, 0.17570487f, -0.18735111f, -0.27020234f, -0.14561810f, -0.18422411f, 
    0.10937202f, -0.02042032f, -0.12403028f, 0.14900978f, -0.15657723f, -0.19032739f, -0.16984765f, 0.03797976f, 
    -0.35213304f, -0.05559919f, 0.15712671f, -0.18050446f, 0.04681977f, -0.15146822f, 0.13111265f, -0.16997643f, 
    -0.00034759f, 0.06071654f, -0.06862222f, -0.16482252f, -0.15491462f, 0.06114240f, -0.15427189f, -0.23033589f, 
    -0.14172028f, -0.21842633f, 0.33067060f, 0.15341508f, 0.10554136f, -0.03432013f, -0.54409176f, -0.65297133f, 
    -0.23180962f, 0.04106344f, 0.06318856f, 0.02767740f, 0.11293316f, -0.06279562f, 0.03412863f, -0.04278035f, 
    0.06755561f, 0.18979238f, -0.03845825f, 0.14982693f, -0.00144403f, -0.11958475f, -0.04225344f, 0.02827941f, 
    -0.46614075f, 0.06163957f, 0.15768166f, 0.23417184f, 0.01105400f, -0.09437710f, 0.01564791f, -0.15432304f, 
    -0.08448371f, 0.04299400f, -0.18702838f, -0.41108528f, -0.03219204f, 0.06048222f, -0.06470437f, -0.01661263f, 
    -0.02700775f, 0.09744763f, -0.17742151f, 0.10149080f, 0.12386543f, 0.20012097f, 0.13803603f, 0.12347507f, 
    0.27813762f, 0.05677276f, 0.21061082f, 0.28317821f, 0.06923310f, -0.13323833f, -0.00961063f, 0.19072768f, 
    -0.12790820f, 0.24903180f, -0.07907008f, -0.10266887f, 0.15578999f, 0.12511706f, -0.13428642f, -0.03419418f, 
    -0.01209263f, 0.16350040f, -0.05762692f, -0.06350122f, 0.02013179f, 0.00788542f, 0.35622811f, -0.10384883f, 
    -0.06962966f, -0.13381413f, -0.20855579f, -0.11177031f, 0.26389012f, 0.07792635f, 0.05270509f, -0.06672643f, 
    -0.25682387f, 0.04938549f, 0.02878075f, -0.27644646f, -0.02382965f, 0.16096707f, 0.14503267f, -0.17243630f, 
    0.16751184f, 0.10454864f, 0.09205228f, -0.00584769f, 0.00282762f, 0.04712265f, 0.17505066f, -0.08319876f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.12587987f, 0.04731474f, -0.03612124f, 0.06866466f, 0.10125837f, 0.01917605f, -0.14245155f, 0.13276413f, 
    -0.19554342f, -0.03955298f, 0.00816402f, 0.11627326f, -0.03601046f, 0.10122105f, -0.05021537f, -0.05585288f, 
    -0.01247096f, -0.00602788f, 0.09908149f, -0.18553099f, 0.02430003f, 0.00006057f, 0.05028190f, 0.04129017f, 
    0.07581492f, 0.06335706f, -0.17797029f, -0.06173222f, 0.19501795f, -0.11692890f, 0.07946102f, 0.18515940f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25305912f, 0.12567146f, -0.04491049f, -0.02012929f, 0.18959513f, 0.02221381f, -0.43755594f, 0.34362766f, 
    -0.64616197f, 0.12475409f, -0.06409448f, -0.83649975f, 0.05817819f, 0.85465086f, 0.14758059f, 0.11428518f, 
    0.03406526f, 0.01671172f, -0.23496628f, 0.01893804f, -0.00796840f, -0.04288176f, -0.18406741f, 0.08549885f, 
    -0.24794047f, 0.00973810f, 0.21450919f, 0.03470523f, 0.05829079f, -0.41269910f, -0.52475005f, -0.41225892f, 
    0.18952690f, 0.05413770f, -0.10868390f, -0.63355595f, -0.43250856f, -0.70740050f, 0.22437175f, -0.06364012f, 
    0.68826526f, 0.15631570f, -0.06145866f, -0.12058039f, -0.03633327f, 0.23326567f, 0.14954521f, 0.03658000f, 
    0.18517037f, -0.07259597f, -0.53394699f, -0.04364298f, 0.06619544f, 0.05651663f, -0.14531423f, -0.04186568f, 
    0.43525383f, 0.08329601f, -0.35159269f, 0.13047533f, 0.86488152f, -0.30732989f, -0.41730416f, -0.20411894f, 
    0.02645289f, -0.11176769f, 0.11152628f, -0.02241064f, -0.07648997f, -0.15748473f, -0.37038061f, -0.18406834f, 
    0.04206974f, 0.03069368f, 0.11310439f, -0.32682243f, -0.02673187f, -0.42438570f, 0.14263961f, 0.08533962f, 
    0.23782803f, -0.08737854f, -0.22724634f, 0.35589305f, -0.00708031f, -0.09252154f, 0.16516717f, -0.02802938f, 
    -0.39386550f, 0.19989295f, -0.93237185f, -0.13867077f, 0.33329901f, 1.04270065f, -0.38907790f, -0.35531345f, 
    -0.41730234f, 0.00116055f, 0.12326695f, 0.26865837f, 0.18274428f, 0.10195672f, 0.24593943f, 0.19335504f, 
    -0.47358510f, -0.10918226f, 0.01031251f, 0.02689552f, -0.08795808f, -0.57304448f, 0.11568685f, -0.05088442f, 
    -0.69039285f, -0.06865348f, 0.12432614f, 0.52877963f, -0.16211998f, -0.00608681f, 0.07967982f, -0.02308567f, 
    0.08017176f, -0.52841735f, 0.77642328f, -0.12223372f, -0.14731912f, 0.12812637f, 0.18995477f, 0.41743881f, 
    -0.39243841f, -0.17974581f, -0.00954029f, 0.25920597f, 0.24117152f, 0.52278268f, -0.32941911f, 0.41681054f, 
    -0.72638398f, 0.03924305f, -0.08716652f, 0.34607249f, -0.10541328f, -0.18479685f, 0.01148008f, -0.00553279f, 
    0.31217372f, -0.05374105f, -0.48307130f, -0.49493805f, 0.10715285f, -0.00111665f, 0.02821665f, -0.07429698f, 
    0.04073582f, 0.40739146f, -0.35607949f, 0.14536060f, -0.14679992f, -0.05964488f, -0.14903912f, -0.19500338f, 
    0.56930929f, 0.13329887f, -0.05197738f, -0.02907397f, -0.35563612f, -0.03451631f, -0.27969006f, -0.15592049f, 
    -0.61550498f, -0.11005654f, -0.05334107f, 0.15888357f, 0.00240808f, 0.18752711f, -0.17423660f, 0.12392835f, 
    0.04130664f, -0.14202945f, -0.27918512f, -0.82264155f, -0.09727103f, 0.05283439f, 0.15372564f, -0.00709705f, 
    0.40186226f, -0.35860398f, 0.55166978f, -0.01037844f, -0.29211619f, -0.24328104f, 0.39930326f, -0.45630392f, 
    0.21980734f, -0.10476644f, 0.15360028f, 0.38575664f, 0.06500988f, -0.31460258f, 0.52639735f, 0.01803618f, 
    -0.36234152f, 0.10481036f, 0.02850762f, 0.95787275f, 0.13862078f, -0.03719759f, -0.01273033f, 0.15957433f, 
    -0.19096088f, 0.14622858f, -0.81684273f, -0.09304889f, 0.07040393f, 0.00369211f, 0.16412261f, -0.03868308f, 
    -0.56304830f, -0.62714791f, -0.18522400f, 0.03470628f, -0.37493929f, -0.08892620f, -0.49012983f, 0.04315116f, 
    -0.15039267f, 0.00461842f, -0.11336813f, -0.27970237f, -0.17812943f, 0.76748425f, -0.19242845f, -0.05296571f, 
    0.75982726f, -0.18115515f, 0.15015899f, -0.11233474f, 0.10768519f, -0.03359348f, -0.15666983f, -0.11948428f, 
    0.13611065f, 0.16298620f, 0.38079250f, 0.23610833f, -0.05079258f, -0.05618178f, -0.12123081f, 0.14744914f, 
    -0.04218819f, -0.03841362f, 0.45397699f, -0.03491079f, -0.39182985f, -0.33756766f, -0.38968655f, -0.16374144f, 
    -0.10152029f, 0.05755854f, 0.06072395f, 0.51651084f, -0.66812170f, -0.18009856f, 0.32280621f, -0.86645156f, 
    -0.31567663f, 0.14750491f, -0.15331060f, -0.26057735f, -0.08040966f, 0.02753735f, -0.08792157f, -0.00439661f, 
    -0.00345096f, -0.02274857f, 1.01328456f, 0.33985877f, 0.00158016f, -0.10813525f, -0.07937453f, -0.07785897f, 
    0.14743724f, 0.32707423f, -0.23267947f, 0.13552117f, 0.11678199f, -0.35762805f, 0.01764243f, 0.23656292f, 
    0.08451895f, -0.05765723f, 0.00768324f, -0.06992180f, 0.35055664f, -0.00693381f, -0.98281485f, -0.26145309f, 
    0.27783960f, -0.05674383f, -0.16489851f, 0.22403200f, 0.03393727f, 0.06114490f, -0.09856998f, 0.01862724f, 
    0.43015033f, 0.04583237f, 0.98328269f, -0.06294853f, 0.09851911f, -0.11010166f, -0.06459609f, -0.00948223f, 
    -0.66814399f, -0.14919026f, 0.03843384f, 0.05392645f, 0.14723250f, -0.36360684f, 0.10069391f, -0.11299337f, 
    -0.29223070f, -0.15586974f, -0.09905328f, -0.26370066f, -0.17716829f, 0.17272975f, -0.33151484f, 0.45015302f, 
    -0.19011700f, -0.02431700f, 0.07396697f, -0.38719314f, -0.03182421f, -0.26249886f, -0.06668556f, -0.05102335f, 
    -0.59823453f, 0.02322957f, 0.03462467f, -0.58854693f, 0.03619853f, -0.06877428f, 0.16888447f, 0.03359857f, 
    0.28384471f, 0.34783816f, -0.56767654f, 0.05447815f, -0.34701014f, 0.40724957f, 0.16469714f, 0.92786628f, 
    0.07525534f, -0.14490695f, -0.03685635f, 0.37212989f, 0.20744383f, -0.77212936f, 0.74509627f, -0.08608548f, 
    -0.06251750f, 0.08807594f, -0.01401041f, -0.34349746f, -0.09137368f, -0.34585035f, -0.02652555f, -0.08128149f, 
    0.16479746f, -0.03120865f, -0.14499938f, 0.22234002f, 0.04246292f, -0.11672338f, 0.11287516f, -0.05050899f, 
    -0.39536506f, -0.05582240f, -0.60712171f, 0.13907334f, -0.43057847f, -0.02055742f, 0.79490614f, -0.08113160f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21351069f, -0.06008184f, -0.03869466f, -0.23237599f, -0.09525003f, -0.00181993f, 0.17800066f, -0.49311835f, 
    -0.20125797f, 0.08162308f, 0.14162210f, -0.20357253f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
