#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78516006f, 0.01703966f, -0.28788489f, -0.76210529f, -0.47345245f, 0.06923360f, -0.23582943f, -0.11698034f, 
    -0.18752298f, 0.06747026f, 0.02292803f, 0.11488458f, -0.12723216f, -0.04276364f, -0.08309541f, -0.10820665f, 
    0.07629494f, 0.01452671f, 0.01616831f, -0.30887911f, 0.03372552f, 0.12904884f, 0.16716710f, 0.09488325f, 
    0.01332634f, -0.69335997f, -0.76409543f, -0.69806468f, 0.19166578f, 0.08690038f, -0.13925306f, 0.32495597f, 
    0.25734028f, -0.33889261f, -0.22336666f, 0.21191914f, 0.07000444f, 0.07374080f, 0.13580617f, 0.30266884f, 
    -0.17731734f, 0.18677227f, 0.18222262f, -0.17637263f, 0.04313400f, 0.01952817f, -0.08725125f, -0.03548468f, 
    0.00834346f, -0.10831339f, -0.57515591f, -0.31953302f, 0.74421805f, 0.53324574f, -0.02400788f, 0.56545210f, 
    0.58510506f, 0.34722221f, 0.12058274f, 0.08394238f, 0.01713689f, -0.13762753f, 0.25770974f, -0.01322271f, 
    -0.42465168f, 0.00838179f, 0.21556017f, 0.00974970f, -0.32932770f, -0.05909041f, 0.13320151f, -0.01912977f, 
    -0.07531761f, 0.08537279f, -0.16558646f, 0.11102767f, 0.60901052f, -0.61348540f, 0.11233018f, -0.52717495f, 
    0.70858330f, -0.23832047f, -0.23840320f, -0.48394302f, -0.23183331f, 0.02615396f, -0.11424625f, 0.24031885f, 
    -0.01709563f, -0.13240595f, -0.11907377f, -0.04308710f, 0.12507492f, 0.02968097f, -0.08657774f, -0.02966128f, 
    -0.06344581f, 0.03310202f, -0.01249328f, -0.01603012f, 0.06216957f, -0.41694707f, -0.68877226f, -0.56634849f, 
    -0.42203143f, 0.02029125f, 0.61696523f, 0.36162624f, -0.03236283f, 0.34623387f, -0.10540210f, -0.19163062f, 
    -0.10149645f, -0.12169094f, -0.07543049f, -0.09053140f, 0.31292015f, 0.05116948f, 0.09359509f, -0.01848105f, 
    0.00170858f, -0.01704714f, -0.04194121f, -0.27995339f, -0.00815294f, 0.24226716f, 0.83093786f, 0.53726339f, 
    0.62388539f, -0.54416484f, -0.24042991f, 0.30195111f, -0.13589023f, 0.02368676f, 0.20433272f, 0.00908772f, 
    0.08408895f, -0.02538796f, 0.30719152f, 0.22132756f, -0.16389425f, -0.15326230f, 0.16000135f, 0.06462297f, 
    -0.06865602f, -0.12234503f, 0.05188547f, 0.04746034f, -0.00289686f, 0.13047744f, -0.59918994f, -0.12953816f, 
    0.26071241f, -0.14783357f, -0.44132218f, -0.30129984f, 0.34612924f, 0.00096824f, 0.05895989f, -0.15616058f, 
    -0.30091423f, -0.04163470f, -0.02414915f, -0.17066038f, -0.28238219f, 0.11977028f, -0.35326880f, -0.07174286f, 
    -0.23300897f, -0.29409114f, -0.30133694f, -0.01585916f, -0.00394212f, 0.21191385f, 0.03636248f, -0.24930817f, 
    -0.49143898f, -0.29246017f, 0.34190077f, 0.33536530f, -0.45561707f, 0.09481208f, 0.36876416f, -0.03918941f, 
    0.27005607f, 0.47546443f, -0.25257272f, -0.06168096f, 0.11932939f, 0.02926229f, 0.35707635f, 0.00879574f, 
    -0.25465441f, 0.26058316f, -0.01947033f, -0.00246984f, -0.05516457f, 0.05553551f, 0.26183799f, -0.11633666f, 
    -0.10777704f, 0.69987398f, 0.70220524f, -0.65706033f, -0.05868730f, 0.61970425f, 0.23670636f, -0.19377536f, 
    -0.01762378f, -0.38810349f, 0.03732154f, 0.20255283f, -0.20746130f, 0.04527550f, -0.20143040f, -0.24564753f, 
    -0.07888513f, -0.01935233f, -0.36541268f, -0.02023391f, -0.03438670f, 0.00408117f, 0.24713887f, 0.08614719f, 
    0.05494756f, -0.61335117f, -0.36308795f, 0.08205216f, 0.36089644f, 0.13979165f, 0.29895288f, -0.08498354f, 
    -0.10013615f, -0.25969023f, 0.09557232f, -0.48423573f, 0.01550819f, -0.14271681f, -0.02854293f, -0.16699260f, 
    -0.53470439f, -0.37172139f, -0.16490860f, 0.03255722f, -0.31025994f, 0.09691708f, 0.08659885f, -0.17601156f, 
    -0.17353262f, -0.08985463f, -0.17268382f, 0.17863792f, -0.18081303f, -0.73489237f, -0.34321830f, 0.32869068f, 
    -0.43034595f, -0.00590143f, 0.49478623f, -0.21887320f, -0.37683603f, -0.30327967f, 0.16618842f, 0.00814255f, 
    -0.09237767f, -0.02303874f, 0.04451214f, 0.13839406f, 0.33108357f, 0.11137374f, -0.34723774f, -0.31986642f, 
    -0.25549814f, -0.25278670f, 0.15668629f, -0.12140281f, -0.16400027f, -0.38427192f, -0.42939866f, -0.12991913f, 
    -0.17030030f, -0.52368933f, -0.48404801f, -0.59560084f, -0.25930691f, 0.04743697f, 0.26896319f, 0.07092505f, 
    0.07458068f, -0.01518124f, -0.22347341f, 0.09606344f, -0.17968589f, -0.03493831f, 0.51762658f, 0.06626174f, 
    0.16657279f, -0.11699000f, 0.11168084f, 0.08905528f, -0.54003567f, -0.12548822f, -0.33658391f, -0.27574843f, 
    -0.17267172f, 0.59453773f, 0.90226537f, -0.22301818f, 0.38763171f, 0.40248176f, 0.09399214f, -0.06645906f, 
    -0.04755559f, -0.11823794f, 0.16753727f, 0.01114235f, -0.20128345f, -0.03481518f, -0.09993266f, -0.07526537f, 
    -0.04793872f, -0.10777716f, 0.05022234f, 0.09991867f, 0.00063786f, 0.63136101f, 0.47737658f, 0.40929654f, 
    0.59350896f, -0.10797711f, -0.22108400f, 0.01427881f, -0.36440679f, -0.16102003f, -0.21105216f, 0.11636335f, 
    0.22511253f, 0.25601041f, 0.15838613f, 0.01760040f, 0.34401044f, 0.28205985f, 0.02155202f, 0.10207144f, 
    0.17982090f, 0.25818706f, -0.11082676f, -0.06239070f, 0.24215493f, -0.00777527f, -0.25318372f, 0.14116618f, 
    0.64772201f, -0.14989392f, -0.53165483f, -0.82776034f, 0.08878890f, 0.04266457f, -0.11880171f, 0.02589371f, 
    0.20845343f, 0.01009728f, -0.50565332f, -0.16835989f, 0.01617225f, 0.19209296f, 0.07994752f, -0.05655221f, 
    -0.17431913f, 0.13615055f, -0.01386833f, 0.15037817f, 0.12551722f, -0.14819354f, -0.27577454f, 0.64433467f, 
    0.33087277f, 0.59728760f, 0.54410344f, 0.73809773f, 0.41963235f, -0.34201491f, -0.54644918f, -0.48381519f, 
    -0.18888320f, 0.36523560f, 0.26975930f, -0.04244813f, 0.12788397f, -0.28744555f, -0.02809716f, 0.14241891f, 
    -0.06510185f, 0.00513847f, -0.13550395f, 0.01820535f, 0.08795007f, 0.20748182f, -0.04012028f, -0.02947411f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15173714f, 0.22846867f, -0.02549750f, 0.01114408f, 0.18172756f, -0.03821617f, 0.15971659f, 0.04120244f, 
    0.21840003f, 0.03564492f, 0.06257215f, 0.24022435f, 0.26028779f, 0.01274019f, 0.18350764f, 0.07424828f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15265995f, -0.19207361f, 0.14809735f, 0.12514351f, 0.05424594f, 0.01558805f, -0.04510170f, 0.06253223f, 
    0.04745301f, -0.03353533f, 0.02389959f, -0.09321127f, 0.07379245f, -0.13094084f, -0.16695507f, 0.28644684f, 
    -0.10023972f, 0.03802670f, -0.10665244f, -0.00495105f, -0.04317917f, -0.04564745f, -0.02312537f, -0.08282322f, 
    0.25389162f, 0.07252687f, -0.05727114f, 0.13230225f, -0.10732054f, 0.05537900f, -0.02081961f, 0.00613253f, 
    -0.00806394f, -0.05492143f, -0.03668438f, 0.10578835f, -0.29679245f, 0.02810774f, 0.23875752f, -0.45116922f, 
    -0.03280814f, 0.17374048f, 0.09143855f, -0.00113460f, -0.00943445f, 0.02168776f, 0.00338689f, -0.08989599f, 
    -0.06909092f, 0.03903955f, 0.12396298f, 0.03244408f, 0.01576865f, -0.05495291f, -0.04170530f, 0.18139257f, 
    -0.12099590f, 0.00298517f, -0.02394325f, -0.02102022f, -0.08378715f, 0.09177754f, -0.01421197f, 0.00832289f, 
    0.05909673f, 0.10751716f, 0.02552612f, 0.05960220f, -0.20050476f, -0.01882751f, 0.07211705f, 0.04623307f, 
    0.08392543f, -0.21863349f, 0.03285059f, 0.10059634f, -0.04563394f, 0.03122295f, 0.06568553f, 0.15457942f, 
    0.03070778f, 0.17737515f, 0.06283300f, 0.05169582f, 0.20392193f, -0.15345956f, 0.03072207f, 0.25118706f, 
    -0.10950522f, 0.11639079f, -0.04003583f, -0.02662246f, 0.10394254f, 0.04101364f, 0.11413196f, 0.02043785f, 
    0.00621310f, -0.22999609f, 0.15697789f, -0.27972144f, 0.00757435f, 0.06459116f, -0.04476994f, -0.02229899f, 
    0.02618067f, -0.01259348f, 0.11696076f, -0.01175703f, -0.32084557f, -0.07313880f, 0.03817179f, 0.10708328f, 
    0.04432567f, -0.14928889f, 0.03410548f, -0.21001782f, 0.05709104f, 0.08905219f, 0.01564087f, 0.06413767f, 
    -0.14139058f, -0.07877539f, 0.14136930f, -0.09836520f, -0.03624189f, -0.11141919f, -0.03064032f, -0.00940648f, 
    -0.01573626f, 0.01022378f, 0.05639953f, 0.06064053f, -0.11752171f, -0.06061944f, 0.11983581f, 0.01282921f, 
    0.08703375f, -0.01704033f, 0.03168020f, 0.05257469f, -0.12374589f, 0.07979661f, -0.11243485f, -0.03130850f, 
    -0.03486049f, 0.01901250f, 0.24370992f, 0.06139805f, 0.01928261f, -0.07786115f, -0.03599798f, 0.07248414f, 
    0.11413594f, -0.00038703f, 0.10993710f, -0.02930405f, 0.00614779f, 0.24137726f, 0.02179912f, -0.06565700f, 
    0.12266666f, 0.07615144f, 0.05478656f, 0.04575550f, -0.04658284f, -0.01202104f, -0.00487977f, -0.10897766f, 
    0.02376156f, -0.12128309f, 0.04183497f, 0.11683234f, -0.06167836f, 0.01491853f, -0.04120771f, 0.07015195f, 
    0.02953665f, 0.09917105f, -0.05060434f, -0.06121000f, -0.10547612f, 0.26293147f, -0.15421623f, -0.25763160f, 
    0.10272577f, -0.00730480f, -0.01300283f, 0.01307181f, -0.10144112f, -0.04060883f, 0.06512959f, -0.02868814f, 
    0.32306385f, 0.20994295f, 0.18306538f, 0.02515594f, 0.01153873f, -0.07154863f, -0.00546734f, -0.02321966f, 
    -0.05712311f, 0.09851214f, -0.11308073f, 0.04300608f, -0.15526685f, 0.03306663f, 0.02027640f, -0.22665688f, 
    -0.00560720f, -0.01550188f, 0.10131362f, 0.06215247f, 0.02582297f, 0.03218016f, -0.05864414f, 0.02996458f, 
    -0.23278064f, -0.17522983f, 0.06092710f, -0.12397984f, -0.02793446f, -0.02317331f, 0.06221170f, 0.17410050f, 
    0.12048788f, -0.00441888f, 0.03620913f, -0.07885157f, 0.25145948f, 0.20614289f, -0.00715714f, 0.15123826f, 
    -0.07184654f, -0.06309974f, -0.02308497f, -0.07913594f, -0.15605438f, 0.04068294f, 0.07886054f, 0.12319142f, 
    -0.25769058f, 0.07038096f, 0.20479812f, 0.19419059f, -0.03877797f, -0.02610354f, 0.01573116f, -0.11362803f, 
    -0.03245749f, -0.00912726f, 0.04151497f, 0.16627790f, -0.09490696f, 0.09880327f, 0.02816529f, -0.08588228f, 
    0.04598156f, 0.06183828f, 0.07383718f, 0.11351348f, 0.07611797f, -0.06323801f, 0.04275453f, -0.01255786f, 
    0.11866651f, 0.14220037f, -0.12737584f, 0.05952068f, 0.14991152f, 0.03498575f, 0.00804460f, 0.02375172f, 
    -0.11301553f, 0.05750681f, 0.04758712f, -0.08336190f, -0.18887973f, 0.08404065f, -0.06248463f, -0.01430573f, 
    0.12597775f, -0.02848586f, 0.02175453f, -0.05316568f, 0.02139946f, -0.02888491f, -0.01215280f, -0.19722304f, 
    0.31878883f, 0.16256005f, -0.00462368f, 0.19165258f, -0.05276824f, -0.07088866f, -0.01160410f, -0.04555960f, 
    -0.07681291f, -0.01793272f, -0.13326448f, -0.01718924f, 0.01624567f, -0.06422216f, 0.00849343f, -0.14695922f, 
    0.09296816f, 0.08691274f, -0.00049505f, 0.16668347f, 0.02007383f, -0.02950037f, 0.01025938f, 0.17817375f, 
    0.23823896f, 0.19129051f, -0.13887361f, 0.25701469f, -0.00495648f, -0.14337100f, -0.07823891f, 0.05479187f, 
    -0.09716842f, 0.02912310f, -0.00966550f, 0.03176126f, -0.13907138f, 0.04787671f, 0.03654586f, 0.21987642f, 
    -0.06387357f, -0.03679790f, -0.05313633f, 0.09426938f, -0.06682590f, -0.02571388f, -0.06212742f, -0.02425765f, 
    -0.11981087f, 0.26272476f, 0.00712581f, 0.07986712f, -0.01282533f, 0.07154065f, 0.11222395f, -0.02798551f, 
    -0.06515913f, -0.04277771f, 0.02939557f, 0.12296654f, 0.12246803f, 0.01045877f, 0.04571534f, 0.07742005f, 
    -0.08938064f, -0.09917670f, 0.12273134f, 0.00354368f, -0.10283437f, -0.07131314f, 0.03826387f, -0.18782519f, 
    0.07786374f, -0.01338344f, -0.12837847f, -0.00427423f, -0.03040716f, 0.10533980f, 0.13071574f, -0.00474454f, 
    0.02522397f, 0.00438247f, -0.08032607f, -0.04281033f, 0.07919669f, -0.29887146f, 0.23415029f, 0.44555715f, 
    -0.00758690f, 0.04743456f, -0.03395291f, 0.06689582f, 0.09384692f, 0.02673644f, -0.09851878f, 0.09452652f, 
    0.02328661f, 0.04169331f, -0.13844261f, 0.05209624f, 0.02393657f, -0.04667770f, 0.06202818f, -0.06767170f, 
    0.01811286f, -0.22428934f, 0.01724391f, -0.03991532f, -0.19209835f, -0.07866251f, 0.01559210f, -0.08143967f, 
    -0.14258859f, 0.01747223f, 0.10821270f, 0.13543911f, -0.07107392f, 0.06595463f, -0.02902153f, 0.04056980f, 
    0.23166665f, 0.27494222f, 0.02646119f, -0.03473107f, -0.09052217f, -0.00658973f, -0.00392406f, 0.16146095f, 
    -0.07126851f, -0.16497347f, -0.00532211f, 0.07807932f, -0.17654413f, 0.16469441f, -0.13767542f, -0.14351363f, 
    -0.00371747f, -0.00573692f, 0.07777207f, -0.14432722f, 0.15987141f, 0.04751606f, 0.12598333f, 0.09386535f, 
    0.02804287f, 0.20498978f, -0.00774082f, 0.07034455f, -0.03285147f, 0.00043316f, -0.01548400f, 0.00396318f, 
    0.05242401f, -0.16312133f, -0.01141975f, -0.01474605f, -0.05517849f, -0.11891086f, 0.08200878f, 0.11467949f, 
    0.08482100f, 0.01780884f, -0.10841227f, -0.10565096f, -0.01878496f, 0.04033061f, 0.04710475f, -0.06669152f, 
    -0.04395121f, -0.20332657f, 0.00987417f, -0.07501782f, -0.04086430f, -0.07291134f, 0.13406818f, -0.19794853f, 
    -0.03536952f, -0.11935358f, -0.23059215f, -0.01777614f, -0.17258981f, 0.01789946f, 0.13546467f, 0.07724325f, 
    0.04518113f, -0.01630873f, 0.05125178f, 0.10274616f, 0.05395253f, -0.10296849f, 0.01334193f, 0.17190070f, 
    -0.02051259f, 0.27979085f, -0.03295234f, -0.34910315f, 0.04492122f, 0.01194762f, 0.04663126f, -0.01688000f, 
    0.23211163f, -0.03534876f, 0.02773413f, 0.13723519f, 0.03023292f, 0.03074193f, 0.07336689f, -0.07098810f, 
    0.02007476f, -0.06335975f, 0.07860390f, 0.07409845f, 0.18033281f, -0.02425820f, -0.14555342f, -0.21399230f, 
    -0.09900910f, 0.09412334f, -0.27035201f, -0.12231490f, 0.01570383f, 0.11730316f, -0.07144544f, 0.10670301f, 
    -0.03085952f, -0.01969528f, -0.03039948f, -0.04769455f, 0.11528519f, 0.09095047f, -0.05090141f, -0.20402533f, 
    -0.00762129f, -0.02534722f, 0.14280343f, 0.00481257f, 0.17262904f, 0.08241874f, -0.01806566f, 0.10626817f, 
    0.40005219f, 0.11194451f, 0.02266070f, 0.15940616f, -0.00726662f, -0.03548620f, 0.05884367f, -0.01143227f, 
    0.08679537f, -0.08114220f, 0.06273181f, 0.05075004f, 0.06988581f, 0.00994669f, 0.16982961f, 0.07238120f, 
    0.03007926f, -0.04379938f, -0.03523777f, -0.02574361f, 0.11500618f, 0.06911051f, 0.19323337f, 0.07776433f, 
    -0.14967941f, -0.03026121f, 0.09150521f, -0.16261923f, 0.14330611f, -0.12033136f, 0.13692059f, -0.08966126f, 
    -0.06671302f, 0.15727617f, -0.03095225f, 0.04288675f, -0.11342505f, 0.09786311f, -0.11781213f, -0.06240259f, 
    0.17496128f, -0.05799742f, 0.02296045f, -0.08402584f, 0.10654840f, 0.05694794f, 0.06820299f, 0.04719703f, 
    -0.03242842f, -0.04874380f, -0.16199817f, -0.17268983f, -0.06858767f, -0.04491496f, -0.01150926f, -0.00921810f, 
    0.02700455f, 0.11462817f, 0.12738451f, -0.02377438f, -0.10322173f, 0.06487243f, -0.14746393f, 0.01709332f, 
    0.09379893f, 0.02488049f, 0.04738447f, 0.10686412f, 0.06352784f, -0.02501566f, -0.02685549f, -0.01821877f, 
    0.26478994f, -0.09602392f, -0.12596263f, 0.07551002f, 0.05166740f, 0.07229101f, 0.19409426f, 0.07853901f, 
    0.03898381f, 0.14670281f, -0.03310557f, 0.04895821f, 0.32583743f, 0.08561418f, 0.18668623f, 0.08883321f, 
    0.02849612f, 0.15130176f, 0.00183699f, -0.02861772f, -0.07570826f, 0.06385016f, -0.06351495f, 0.07867786f, 
    -0.19631693f, -0.20330791f, -0.14637828f, -0.10262476f, 0.09911595f, -0.00016866f, 0.06101153f, -0.04081878f, 
    0.06524806f, -0.01276151f, 0.08786487f, 0.15283506f, -0.07119661f, 0.17501719f, 0.30138490f, 0.06068976f, 
    0.05076271f, 0.01422705f, 0.11073494f, -0.00848120f, -0.05450735f, 0.02739382f, -0.08295605f, 0.09054102f, 
    0.20120639f, 0.03768459f, -0.01904409f, 0.00563983f, -0.05078673f, 0.04704014f, -0.04382907f, 0.09034564f, 
    0.06800334f, 0.17222765f, 0.09303704f, 0.00252736f, 0.02412661f, 0.08360398f, 0.08341186f, 0.07039566f, 
    -0.05266184f, -0.05868263f, 0.02265764f, -0.04417421f, 0.08466796f, 0.01117531f, 0.12805799f, -0.04559416f, 
    0.01601876f, -0.09065712f, 0.10415341f, 0.25686339f, 0.06290469f, 0.08186793f, -0.00824976f, 0.02765450f, 
    -0.02044437f, -0.04338497f, 0.11441311f, 0.11425018f, 0.02123180f, 0.10328439f, 0.11291008f, 0.05873680f, 
    0.07719960f, 0.05034303f, 0.08415206f, -0.03947569f, 0.00959821f, -0.01116280f, 0.13193290f, 0.24023986f, 
    0.06979416f, -0.02858052f, -0.02262420f, 0.04476574f, -0.16876306f, 0.00303101f, -0.03110723f, 0.06883402f, 
    0.10737959f, 0.04172385f, -0.00225060f, 0.05515274f, -0.08527384f, -0.05632739f, -0.00375025f, 0.08470421f, 
    0.04804452f, 0.05865534f, 0.06144835f, -0.00712537f, -0.01088454f, -0.14979593f, -0.05318500f, 0.04862134f, 
    0.03637797f, -0.08900123f, 0.08202790f, -0.11280213f, 0.09613062f, 0.12351564f, 0.06664062f, -0.01997981f, 
    -0.03852257f, 0.07120241f, 0.05512829f, 0.02155021f, 0.00289855f, 0.10095807f, 0.00065826f, 0.02815283f, 
    0.10474119f, 0.09312131f, -0.01384871f, 0.10573922f, -0.00487192f, -0.11019388f, -0.05676994f, -0.20646615f, 
    0.06903378f, 0.12145224f, 0.03038902f, 0.13192259f, -0.06032969f, 0.16873902f, 0.05577338f, 0.01149419f, 
    0.05109471f, -0.03988911f, 0.03811698f, 0.01231017f, 0.23596619f, 0.15404087f, 0.01405410f, -0.16601212f, 
    -0.10035080f, -0.02138146f, 0.06585724f, 0.12287714f, 0.14946096f, 0.01298286f, 0.08636531f, -0.01829633f, 
    0.06152587f, 0.00268075f, -0.01443763f, 0.00636878f, 0.04270488f, -0.05143338f, -0.01327077f, 0.04155447f, 
    0.03487623f, 0.02737899f, -0.04351377f, -0.05417698f, 0.06669474f, -0.05275213f, -0.01851843f, -0.05173249f, 
    0.01825919f, 0.01854838f, 0.04067953f, -0.01067985f, 0.05445362f, -0.03285008f, -0.01158105f, -0.02485791f, 
    -0.05221023f, 0.02042749f, -0.05797153f, -0.06017159f, -0.02076915f, -0.03174942f, 0.06218890f, -0.02776545f, 
    -0.03822597f, -0.03186246f, 0.06024248f, -0.04275693f, 0.05363619f, 0.05799706f, -0.03057286f, 0.03930616f, 
    -0.03047165f, -0.07523570f, 0.02323252f, -0.03461307f, -0.05258461f, -0.02694115f, -0.02388696f, 0.04443713f, 
    -0.05947019f, -0.07144271f, -0.03947765f, -0.04191101f, 0.03172089f, -0.03511443f, -0.05256591f, 0.04693086f, 
    0.02861243f, -0.06221377f, -0.06093166f, 0.02375097f, -0.06722208f, 0.03273033f, -0.03864018f, 0.04537599f, 
    -0.02817274f, 0.02984756f, -0.02536182f, 0.01873518f, 0.01257248f, 0.03808592f, 0.03162701f, -0.06292406f, 
    0.04925305f, -0.01306511f, 0.02974990f, -0.01987293f, -0.05148033f, -0.04175609f, -0.02579389f, -0.01912311f, 
    0.06036084f, -0.06791399f, -0.04287761f, -0.07294735f, 0.01774031f, -0.07557727f, 0.04289555f, 0.02563754f, 
    0.01821055f, 0.02426611f, 0.01468629f, -0.06141811f, -0.05411340f, 0.01547015f, -0.07575729f, 0.02271171f, 
    0.04225751f, -0.01592827f, -0.02649482f, -0.02351384f, -0.02919629f, -0.06257400f, -0.00606494f, -0.01873226f, 
    -0.00029948f, 0.06355222f, -0.03845099f, -0.01625687f, -0.04386219f, -0.06781511f, 0.02960842f, 0.04896342f, 
    -0.05346528f, 0.04841838f, -0.00801495f, 0.01067986f, -0.01614548f, 0.05653211f, -0.03835773f, 0.01889878f, 
    -0.05941381f, 0.03021102f, 0.01476184f, -0.03690661f, -0.04610899f, 0.00076051f, -0.06431875f, 0.05705840f, 
    -0.01067182f, 0.01045335f, -0.05252462f, 0.03257912f, -0.00055770f, -0.02990078f, 0.01428259f, -0.04367889f, 
    -0.07038879f, 0.04762884f, 0.00957223f, -0.04177965f, 0.05824958f, 0.02389422f, -0.00718887f, -0.00584157f, 
    -0.05358535f, -0.06940493f, 0.01502419f, 0.03713311f, 0.00625419f, -0.06966814f, 0.00169563f, -0.05611959f, 
    -0.04661364f, -0.05615577f, 0.00665251f, -0.04657432f, 0.02662593f, -0.00144363f, -0.06388464f, -0.00946095f, 
    0.01157800f, 0.00095221f, -0.00343309f, 0.02171582f, 0.04265366f, 0.04235788f, -0.03546432f, -0.02192295f, 
    0.04775790f, -0.01871572f, -0.07483157f, 0.02843982f, -0.07130150f, -0.02884385f, -0.04273725f, -0.02440352f, 
    0.05257481f, 0.00076082f, 0.00457556f, -0.02209051f, 0.00428663f, -0.06721089f, -0.03055993f, 0.01501726f, 
    0.03917853f, -0.00414629f, -0.01654686f, 0.00941676f, 0.06031118f, -0.02132038f, -0.07234540f, -0.00584010f, 
    0.01716724f, 0.00832555f, -0.05916721f, 0.06046352f, -0.05748025f, 0.05364356f, 0.01128530f, 0.05586704f, 
    -0.05319845f, -0.06028430f, 0.03755978f, 0.03750003f, 0.01328990f, 0.02386176f, 0.02957110f, -0.05363754f, 
    0.00610742f, 0.02430494f, 0.01564298f, 0.05094415f, 0.00422298f, 0.03818586f, -0.05877658f, -0.01923866f, 
    0.05262237f, -0.05572136f, -0.04780683f, -0.02021775f, -0.04320422f, 0.00763783f, -0.06029687f, -0.01277191f, 
    0.07254028f, 0.06118781f, -0.00588139f, -0.01234901f, -0.01269066f, -0.01661697f, 0.05457596f, -0.06115517f, 
    0.03296831f, 0.06760535f, 0.04629968f, -0.07060459f, -0.05425151f, 0.00402281f, 0.00571133f, 0.00837445f, 
    -0.07529085f, 0.04309620f, -0.07367455f, -0.02762764f, -0.06295952f, -0.02711294f, 0.04072981f, -0.06458571f, 
    0.00940344f, -0.06683780f, 0.01905811f, -0.03541943f, -0.06553657f, 0.06422069f, 0.00406180f, 0.03172499f, 
    -0.07976209f, -0.01419577f, 0.00417192f, -0.05302133f, 0.03933186f, -0.02553459f, -0.06940463f, -0.05280194f, 
    0.00303279f, 0.02364673f, -0.06180630f, 0.01448444f, -0.03384886f, 0.02647501f, 0.03366310f, -0.01899034f, 
    0.05279470f, -0.04880398f, 0.00422999f, -0.01517516f, -0.07352401f, 0.04588005f, -0.05002005f, -0.00741122f, 
    -0.06384532f, -0.04907712f, -0.02475704f, 0.03492540f, 0.03478096f, -0.04079669f, 0.06271495f, -0.00389078f, 
    0.03851950f, -0.06567122f, -0.03475019f, -0.02722438f, 0.00914611f, -0.06113478f, 0.05561119f, -0.00254805f, 
    0.01671262f, 0.06200236f, -0.07174531f, 0.01809416f, 0.05054016f, -0.05292115f, -0.07602441f, 0.00544959f, 
    0.05475404f, -0.01733262f, -0.04739699f, -0.00167722f, 0.06852307f, -0.05936954f, -0.06349481f, -0.00592407f, 
    0.05882778f, 0.06411687f, -0.04455501f, -0.06892031f, -0.03991575f, -0.00009760f, 0.00581945f, 0.04870454f, 
    0.01848561f, 0.03609636f, -0.05056942f, 0.05641664f, -0.00265553f, -0.00929787f, -0.05984313f, 0.02766761f, 
    -0.04884527f, 0.02524845f, -0.04814563f, 0.06139740f, -0.01863192f, 0.00034580f, -0.02955315f, -0.01446325f, 
    -0.07383578f, -0.01324677f, -0.05158937f, -0.00691028f, -0.01770545f, -0.02213669f, -0.02610038f, 0.04350233f, 
    -0.01302545f, 0.04299643f, 0.05784503f, -0.05481681f, -0.05503728f, -0.02430602f, -0.01300530f, -0.00034845f, 
    0.00536190f, -0.06529535f, -0.01340973f, 0.04486335f, 0.03916638f, -0.05846703f, -0.03051847f, -0.02485214f, 
    -0.04506339f, -0.05555648f, -0.00572887f, 0.04199763f, 0.01391133f, -0.00495866f, -0.04641645f, -0.05560921f, 
    -0.04368138f, 0.02882854f, 0.00716325f, -0.04680466f, -0.02238886f, 0.02168992f, 0.00849565f, -0.03410633f, 
    -0.06137421f, 0.04998347f, -0.07346863f, -0.04527428f, -0.00955718f, 0.03476421f, -0.07205934f, 0.04032780f, 
    0.11971695f, 0.14959709f, 0.08691964f, 0.06168158f, -0.01294768f, -0.02579619f, -0.11414766f, -0.14244042f, 
    -0.03097516f, -0.03144640f, 0.04841905f, 0.07746967f, 0.14277075f, -0.18123755f, 0.19047365f, -0.09388933f, 
    -0.16178857f, -0.14041860f, 0.00388074f, -0.06422237f, 0.01353694f, 0.02684424f, -0.15262309f, -0.08789912f, 
    0.15722509f, -0.15231176f, 0.06422344f, -0.16326986f, 0.09715468f, 0.00879836f, 0.04023813f, 0.03404250f, 
    0.13895738f, -0.00592487f, 0.07367267f, 0.08322240f, 0.11030445f, 0.19447526f, 0.04801141f, 0.21571146f, 
    0.08647347f, 0.02453406f, -0.12592718f, 0.07033540f, 0.03981633f, 0.00806486f, 0.09847526f, 0.12866588f, 
    0.03748551f, 0.03603896f, -0.00695862f, 0.07954779f, -0.20925717f, -0.00571680f, 0.10673939f, 0.00624870f, 
    -0.10473011f, -0.04128374f, 0.06094115f, 0.12407156f, -0.14747751f, -0.20153657f, 0.12902044f, 0.06298175f, 
    0.10934125f, -0.02963474f, -0.09001307f, -0.07062106f, 0.02379603f, -0.00049940f, -0.00725406f, 0.03828309f, 
    0.16611494f, 0.13415115f, 0.06942658f, 0.11972681f, 0.09723360f, 0.03238364f, -0.01103037f, -0.06729414f, 
    0.07839078f, 0.10241102f, 0.10333944f, -0.00222929f, -0.00034601f, -0.17085987f, 0.10174643f, -0.13165568f, 
    -0.06961063f, -0.12582941f, 0.13852881f, -0.01804116f, -0.05336162f, -0.04470455f, 0.13979311f, -0.09318551f, 
    0.10941532f, 0.01460085f, -0.11173266f, 0.03095441f, 0.17538863f, 0.03832560f, -0.03820524f, 0.12704934f, 
    0.02086904f, 0.15630536f, 0.00234632f, 0.02517046f, 0.23493207f, -0.13304770f, 0.22502907f, 0.01841711f, 
    0.08874800f, 0.04756191f, -0.02987202f, 0.01119290f, 0.07428869f, -0.01368671f, 0.04680057f, 0.09682847f, 
    0.06177103f, 0.17362626f, -0.07065374f, 0.05892111f, 0.00549111f, 0.09495061f, 0.05316421f, 0.13596994f, 
    0.04732851f, -0.00732426f, -0.14025594f, -0.04253287f, 0.31617039f, 0.13593319f, -0.07440647f, 0.18877189f, 
    -0.01919423f, -0.01238734f, -0.09508881f, 0.06420401f, 0.02417339f, -0.06419700f, -0.10492807f, -0.02172091f, 
    -0.05453939f, 0.14591891f, 0.03372199f, 0.07959791f, -0.03451131f, -0.04151381f, 0.03770059f, 0.12107707f, 
    0.00617931f, -0.10342247f, 0.10975982f, 0.06374621f, -0.15752937f, -0.16626060f, -0.07371236f, -0.00518523f, 
    0.07612505f, 0.00910810f, 0.06211478f, 0.08433639f, -0.07723201f, 0.03497874f, 0.05809130f, 0.03504177f, 
    0.29533610f, 0.21503662f, 0.25130242f, 0.00762594f, 0.12172452f, 0.18370348f, 0.10554092f, -0.01377330f, 
    -0.03012660f, -0.05937975f, -0.01979241f, 0.06489859f, -0.13433732f, -0.11942029f, -0.28858590f, 0.01689708f, 
    0.20258285f, 0.08937912f, -0.07331013f, -0.06490603f, -0.01979114f, 0.02857308f, -0.02798696f, -0.01110863f, 
    -0.02070374f, -0.00113746f, -0.00350280f, -0.05013388f, -0.06267792f, -0.06929367f, 0.00627278f, -0.05096662f, 
    -0.04525356f, -0.02941385f, 0.02534282f, -0.04243048f, -0.04323369f, 0.00621134f, -0.00591238f, -0.02253512f, 
    -0.06658641f, 0.06604234f, -0.05880050f, -0.01630546f, 0.04610382f, 0.03292053f, -0.01607131f, 0.01986117f, 
    -0.07545307f, -0.05263917f, 0.03392839f, -0.07918191f, 0.01913869f, 0.00594553f, -0.00436459f, -0.05474653f, 
    -0.01533073f, 0.05979636f, -0.01465862f, -0.06475347f, 0.01159363f, 0.05622713f, -0.04693402f, -0.01801296f, 
    -0.00903397f, -0.00685345f, -0.03348983f, -0.00132423f, -0.07799827f, -0.05129017f, 0.00102175f, -0.04521755f, 
    0.04507248f, 0.04076781f, 0.03680795f, 0.02474733f, -0.01938367f, -0.00545097f, 0.04060835f, -0.00842596f, 
    0.05874616f, 0.05736159f, -0.04303091f, 0.03854634f, -0.05137474f, -0.02215541f, -0.06858099f, -0.00987191f, 
    -0.03413218f, -0.03424852f, 0.01005372f, -0.01531601f, 0.00625496f, -0.02324617f, 0.05145236f, 0.04458633f, 
    -0.03745436f, -0.04795644f, 0.05720011f, -0.00052808f, -0.00003397f, -0.03917439f, 0.02319593f, -0.00144621f, 
    0.00149984f, -0.07774045f, -0.07659941f, -0.06370161f, 0.01269885f, 0.04236319f, 0.03053801f, -0.05651606f, 
    0.03302625f, 0.02433787f, -0.06410390f, -0.01455764f, 0.01844461f, 0.02088377f, -0.02499605f, -0.00242314f, 
    -0.06120391f, -0.00112546f, 0.01180954f, -0.05211796f, 0.05920491f, -0.04201120f, -0.00713938f, 0.04548099f, 
    0.04495033f, 0.06408105f, -0.05047072f, 0.00507264f, 0.03248709f, -0.06212505f, 0.05742042f, -0.03803757f, 
    0.04286027f, -0.07330734f, 0.01970486f, 0.03196440f, 0.01785773f, -0.03306807f, -0.07684658f, -0.01619560f, 
    0.02198085f, 0.00277268f, 0.00573402f, -0.01473724f, 0.06267140f, -0.06193592f, -0.03413069f, -0.05700130f, 
    -0.00275269f, -0.02833763f, 0.06137507f, -0.01732742f, -0.06388680f, -0.00669138f, -0.00958686f, 0.02181760f, 
    -0.06673989f, -0.01418920f, -0.00277212f, 0.05543475f, -0.07125121f, -0.01163297f, -0.03696660f, -0.00879690f, 
    -0.06669717f, -0.07431284f, -0.03580953f, 0.06116617f, -0.03846454f, 0.00279273f, -0.06015576f, 0.02450415f, 
    -0.02961519f, 0.00869970f, -0.06950117f, -0.01522212f, 0.01850951f, -0.01941462f, -0.03019517f, -0.07494517f, 
    0.00230096f, 0.03269810f, 0.03081856f, -0.07875685f, -0.06760914f, -0.06766846f, 0.05787534f, -0.00655557f, 
    0.05716421f, 0.01210951f, 0.04855423f, 0.03078505f, 0.02524707f, 0.01108899f, -0.06755177f, 0.05488629f, 
    -0.00338144f, 0.01830785f, -0.02530975f, -0.05307725f, -0.04702792f, -0.03415760f, -0.03216921f, -0.05078203f, 
    -0.06483810f, 0.01335881f, 0.05688262f, 0.00836696f, -0.04257272f, 0.05039429f, -0.04991794f, -0.04722406f, 
    -0.02728092f, -0.00606327f, -0.04855520f, -0.04113950f, -0.01209277f, -0.04768045f, 0.00607575f, 0.00920896f, 
    -0.01927011f, 0.00119105f, 0.04498831f, 0.02559659f, -0.07394071f, 0.04540434f, -0.06448178f, 0.03187391f, 
    0.05444803f, 0.02813075f, 0.05646302f, 0.02799716f, 0.02818605f, -0.04617480f, -0.04047729f, 0.05614498f, 
    -0.01239494f, -0.06833873f, 0.02515171f, 0.02674040f, -0.00720091f, -0.05873035f, -0.05173022f, -0.01283033f, 
    -0.03510546f, -0.02288144f, -0.06595492f, -0.00893727f, 0.03142999f, -0.05825722f, -0.01840686f, -0.06679003f, 
    -0.00258594f, -0.00767454f, 0.02881017f, 0.06443289f, -0.05927873f, -0.04680027f, -0.04133386f, 0.02425236f, 
    -0.07550912f, -0.01950044f, -0.03612258f, -0.05030081f, -0.06410145f, 0.00556284f, 0.02536457f, 0.01967172f, 
    0.04745629f, -0.00851202f, 0.03170427f, -0.07302856f, 0.04168666f, -0.00036957f, 0.00469176f, 0.03703776f, 
    -0.03237332f, 0.02260616f, 0.03380002f, -0.07376844f, 0.06170915f, 0.01319606f, -0.02176001f, -0.01586349f, 
    0.02447205f, 0.02028583f, -0.00297777f, -0.01061744f, 0.02027972f, -0.03016865f, 0.05383689f, -0.04426622f, 
    -0.05470757f, 0.05948231f, -0.04498335f, 0.02227836f, 0.00885697f, -0.05330990f, 0.07186990f, 0.05124737f, 
    -0.00517595f, 0.03585602f, 0.03350758f, 0.01694384f, -0.04529171f, -0.04054833f, -0.07516991f, -0.08000915f, 
    -0.05848185f, -0.00534191f, -0.03755666f, -0.01153622f, -0.06495060f, 0.01338885f, -0.04667470f, -0.05742056f, 
    -0.04399247f, -0.02463462f, 0.03463830f, -0.05094837f, 0.02671206f, 0.03792414f, -0.04464673f, -0.03235000f, 
    -0.06698529f, 0.00762838f, 0.05340172f, -0.07033824f, 0.05538536f, 0.01429944f, 0.04575078f, -0.07089991f, 
    -0.06585220f, -0.06030228f, 0.05090612f, 0.05506806f, -0.07082028f, -0.04813444f, -0.05960005f, 0.02833367f, 
    -0.07633507f, 0.02213625f, -0.08296093f, 0.04113911f, 0.05778447f, 0.03716592f, -0.07520743f, 0.02987477f, 
    -0.03160856f, -0.00733243f, -0.01794297f, -0.07684741f, 0.02426277f, -0.05294372f, 0.01117873f, -0.03837184f, 
    0.03704806f, 0.00651600f, -0.00607223f, -0.05337689f, -0.04637076f, 0.02041610f, 0.02637584f, 0.04971261f, 
    0.05948041f, -0.00247744f, -0.02622355f, 0.01222021f, 0.06040627f, 0.06438973f, -0.00769098f, -0.02309167f, 
    0.00014934f, 0.04273361f, -0.00691045f, 0.01418721f, 0.03622854f, -0.06194255f, 0.00805935f, -0.03278218f, 
    0.03224653f, 0.05706765f, -0.05237788f, -0.02752603f, -0.00172962f, 0.04672831f, 0.03165922f, 0.00039498f, 
    -0.02010337f, 0.02904185f, 0.05885175f, 0.02172369f, -0.05456777f, -0.07180224f, 0.04577122f, 0.04035506f, 
    0.01124035f, -0.03390623f, -0.06194067f, -0.03735490f, 0.02991878f, 0.05089633f, -0.01439274f, -0.00659723f, 
    0.12104072f, 0.11633231f, 0.02182253f, 0.05991813f, -0.03829606f, -0.02749034f, -0.07776183f, -0.14018774f, 
    -0.03460991f, 0.01606835f, 0.03712794f, -0.00810904f, -0.14413072f, -0.12818922f, 0.10940036f, -0.23004058f, 
    -0.04096554f, -0.08330380f, 0.06184137f, -0.03339406f, 0.12742440f, 0.14769529f, -0.08597104f, -0.02047804f, 
    0.10991580f, -0.31513149f, 0.04317052f, -0.13045016f, 0.04478091f, 0.04862644f, 0.02197782f, 0.09716182f, 
    0.00225612f, 0.00576120f, 0.07360145f, 0.08221290f, 0.09887440f, 0.12800361f, 0.07916598f, 0.22555271f, 
    0.00920016f, 0.02672091f, -0.08175658f, 0.10562665f, -0.08592267f, -0.10279958f, 0.08810066f, 0.20030089f, 
    -0.27558866f, -0.06770832f, -0.04803739f, 0.21398507f, -0.08587414f, -0.02538846f, -0.09422147f, -0.20993577f, 
    0.00445860f, 0.05206041f, 0.03359349f, 0.14736322f, -0.03247336f, -0.02524924f, 0.19633491f, -0.00891628f, 
    0.13306974f, 0.04816634f, -0.02646001f, -0.00042186f, -0.00870536f, 0.05921431f, -0.07143346f, 0.03398178f, 
    0.12839432f, 0.16487962f, -0.06471334f, -0.01612588f, 0.04394169f, 0.06124498f, 0.12084376f, -0.10692367f, 
    -0.01894488f, 0.12870751f, 0.09249450f, -0.04684666f, -0.17796081f, -0.07950503f, 0.10317709f, -0.07984918f, 
    0.08360743f, -0.09755731f, 0.04876949f, -0.11293181f, -0.07526606f, 0.01350694f, 0.01583067f, -0.03256297f, 
    0.27031428f, -0.02825081f, -0.05971702f, 0.32334733f, 0.07517218f, 0.00172856f, 0.00129824f, 0.08461215f, 
    0.05955030f, -0.05401923f, -0.03390257f, -0.01087831f, 0.06303979f, -0.10301343f, 0.15565550f, -0.16572250f, 
    0.12970331f, 0.04072785f, 0.01738335f, 0.01575286f, 0.10222261f, 0.03826863f, -0.05575156f, 0.15108225f, 
    0.24812734f, 0.17345221f, -0.12465180f, 0.15517099f, -0.10208110f, -0.05257750f, 0.02910222f, 0.10425692f, 
    0.00707758f, -0.06346907f, -0.12381110f, -0.03672081f, 0.01570974f, 0.06145363f, -0.10702613f, 0.14796944f, 
    -0.08121771f, -0.07377142f, 0.00874827f, 0.10446620f, 0.07922921f, -0.13504690f, -0.12895362f, -0.03878334f, 
    -0.19392580f, -0.01334387f, -0.10239252f, 0.20397678f, -0.06937245f, 0.11368122f, 0.04608427f, -0.02079410f, 
    -0.02775645f, -0.07840560f, 0.07923263f, -0.01415216f, 0.05739851f, 0.01262725f, 0.04358952f, -0.09520209f, 
    0.03616145f, -0.02315674f, 0.07053319f, 0.02467192f, -0.14393038f, -0.04192324f, 0.11826029f, -0.02825144f, 
    0.24616325f, -0.03546981f, 0.15725355f, -0.04895755f, -0.02121542f, 0.17109184f, 0.09946473f, -0.12818168f, 
    -0.05713119f, -0.01137632f, 0.04051573f, -0.02368602f, -0.00448434f, -0.03299557f, -0.01023300f, 0.04233616f, 
    0.07398758f, 0.02367115f, -0.03133736f, -0.00966490f, 0.00406769f, -0.03333550f, -0.05666069f, 0.06146057f, 
    -0.04555733f, 0.04545777f, 0.08910554f, -0.03583512f, -0.09176939f, -0.05767792f, 0.04132182f, -0.03011303f, 
    -0.00632185f, 0.05839008f, -0.05709967f, -0.10921447f, 0.11002999f, -0.02841147f, -0.06951610f, 0.22924148f, 
    0.01925163f, -0.01500317f, -0.08471019f, 0.01451936f, -0.12208529f, -0.09989257f, -0.03217120f, -0.01160571f, 
    -0.13713451f, 0.10863356f, -0.18651119f, -0.14675575f, 0.04610477f, 0.02105244f, -0.12936813f, 0.03298897f, 
    -0.01994119f, 0.00697917f, 0.00732971f, 0.01459360f, 0.13709036f, -0.04313071f, -0.12309129f, 0.02891374f, 
    -0.00485505f, 0.06173438f, 0.12701231f, -0.14795145f, 0.03704308f, 0.01556042f, -0.19478747f, 0.12197411f, 
    0.10563099f, -0.03445066f, 0.10815379f, -0.24053420f, 0.05518422f, -0.02359917f, 0.13911532f, 0.07747419f, 
    0.02388235f, 0.04348170f, -0.04975240f, 0.00342447f, -0.00971317f, 0.02415366f, -0.16619100f, 0.12091184f, 
    -0.03880512f, -0.18695262f, -0.10287447f, -0.04439744f, 0.03603818f, 0.06372499f, 0.06856284f, 0.12651943f, 
    0.05473951f, 0.06192672f, 0.20851752f, 0.08483535f, -0.05707674f, 0.14683548f, -0.12871049f, 0.05705059f, 
    -0.03434934f, 0.01724957f, -0.03154807f, -0.09421198f, -0.06598618f, 0.16738713f, -0.09720457f, 0.05392422f, 
    0.12185729f, 0.03879165f, 0.01436877f, 0.23043971f, 0.03560527f, 0.05542010f, 0.13990726f, -0.12294978f, 
    -0.27768967f, 0.08562035f, 0.21229270f, -0.43861124f, 0.01061146f, 0.09461270f, -0.10189729f, -0.03539097f, 
    0.15763244f, 0.03837924f, 0.11026109f, 0.14839400f, -0.12028538f, 0.01765129f, 0.02610857f, 0.06296096f, 
    -0.01224429f, -0.04213138f, -0.01864809f, 0.00121615f, 0.10252746f, -0.14214489f, 0.04086606f, -0.01978870f, 
    0.24054037f, 0.03715519f, -0.00772524f, -0.06374098f, 0.02111576f, 0.09409844f, 0.12296075f, 0.09546662f, 
    0.16155115f, -0.03731123f, -0.05909664f, -0.05022007f, 0.18657261f, -0.03921853f, 0.10297467f, 0.07339071f, 
    0.04361499f, 0.13912149f, 0.03346748f, -0.02187828f, 0.15128922f, -0.00824466f, -0.09698315f, -0.03736113f, 
    0.26742199f, 0.20543653f, -0.05365726f, -0.27659407f, 0.11144446f, 0.13341041f, 0.05021899f, 0.09455959f, 
    0.04440657f, 0.04314921f, 0.01464541f, 0.00219752f, -0.04069803f, -0.08252004f, -0.07600749f, 0.08464101f, 
    -0.03619401f, -0.14925905f, 0.02823691f, -0.09401602f, 0.03032750f, -0.01188214f, -0.07158186f, 0.02511576f, 
    0.00989364f, 0.09098819f, 0.13126817f, 0.14137323f, 0.02972265f, 0.04101987f, -0.11268739f, -0.02389515f, 
    0.06383198f, 0.09253625f, 0.11354449f, -0.00150971f, 0.09893340f, -0.02289515f, -0.03342089f, -0.14488447f, 
    -0.19870821f, -0.28078097f, -0.17483775f, -0.04907285f, 0.16282579f, 0.06991392f, 0.13119288f, 0.03832296f, 
    0.05983956f, -0.01932598f, -0.05653314f, -0.05371027f, 0.04018555f, -0.06454614f, -0.06307970f, -0.06692494f, 
    0.03028799f, 0.00277040f, -0.06814305f, 0.01808495f, 0.02171657f, 0.03251510f, -0.00138561f, 0.00071402f, 
    0.00935256f, 0.02149258f, -0.01652494f, -0.02715859f, -0.01081063f, -0.06263620f, -0.05341958f, 0.02925675f, 
    0.06831025f, -0.06981050f, 0.00620652f, -0.01566614f, -0.03378736f, 0.01581732f, -0.02249154f, 0.02167024f, 
    -0.01532251f, -0.07819061f, -0.00345654f, -0.03643430f, 0.02342344f, -0.04867205f, -0.06612253f, -0.03527735f, 
    0.02577724f, -0.02838980f, -0.03303862f, 0.03573829f, 0.02953855f, 0.04522348f, -0.02113255f, -0.04001694f, 
    -0.02346962f, -0.07778560f, -0.07760200f, -0.03552278f, -0.06263858f, -0.03810709f, -0.04623972f, -0.03369933f, 
    -0.04212409f, -0.01992349f, 0.05968122f, -0.06098501f, 0.06273693f, 0.03777981f, 0.02646645f, -0.03186777f, 
    0.06675794f, -0.03153770f, 0.04980776f, -0.01671204f, -0.02862734f, 0.06066801f, -0.00229742f, 0.01198210f, 
    0.06411751f, -0.00889619f, 0.03324204f, -0.01356697f, 0.00958042f, 0.02900409f, -0.00994861f, -0.05536336f, 
    0.05548406f, -0.05389769f, 0.02682750f, -0.03809229f, 0.02617227f, 0.05838729f, -0.03751361f, -0.04336243f, 
    -0.00249778f, 0.01009990f, -0.02924487f, -0.03609937f, -0.07958940f, -0.00326671f, -0.07304452f, -0.05994875f, 
    0.00036721f, -0.04493743f, -0.02331466f, -0.01926246f, -0.01544146f, 0.00013724f, 0.02006519f, -0.06489816f, 
    -0.05757832f, 0.03819816f, -0.03322286f, 0.01399394f, 0.05681399f, -0.06600121f, 0.01559939f, -0.00326954f, 
    -0.00520434f, 0.04621702f, -0.06598461f, -0.00342678f, 0.02881782f, 0.05508367f, -0.06728184f, -0.06985136f, 
    -0.04510895f, 0.00481246f, -0.01076418f, -0.05891153f, 0.00886534f, 0.05065267f, 0.06257378f, -0.07104775f, 
    0.03683084f, 0.04176647f, -0.01597377f, 0.02484200f, 0.02246522f, 0.01096810f, 0.04870617f, 0.04233279f, 
    0.04449891f, -0.06531837f, 0.05182279f, 0.01602276f, -0.02072342f, 0.00400042f, 0.03844823f, 0.01221610f, 
    -0.06645141f, 0.05233125f, -0.07312793f, -0.01454080f, 0.00001068f, -0.03721818f, 0.00334774f, 0.01475434f, 
    0.02896476f, 0.00487959f, 0.05958273f, -0.07211755f, 0.04205257f, 0.01396025f, -0.05738558f, -0.06686269f, 
    -0.05248541f, -0.01379791f, -0.03930824f, -0.04986797f, -0.01773069f, 0.05743464f, -0.00108482f, 0.05192901f, 
    -0.05010423f, -0.00469442f, -0.07673419f, 0.02653046f, -0.05800260f, 0.02444794f, -0.04586873f, -0.04586938f, 
    -0.07834164f, -0.06267200f, 0.02124364f, -0.05169425f, -0.02365384f, 0.00162821f, 0.02924185f, 0.00875014f, 
    -0.05806229f, 0.05303415f, -0.02130858f, -0.03255964f, -0.06915052f, 0.01229840f, -0.04147936f, 0.02495193f, 
    -0.03600663f, -0.18608399f, -0.02813884f, -0.16358201f, 0.01758321f, -0.00327445f, -0.10002065f, -0.03668760f, 
    -0.13968642f, 0.01365278f, -0.02418726f, -0.00252098f, -0.09437612f, -0.11229616f, -0.13814744f, 0.11245342f, 
    0.10231553f, -0.03158500f, 0.00791426f, 0.11242365f, -0.01074712f, -0.05398611f, -0.10805178f, -0.06137516f, 
    0.19739044f, 0.09984878f, -0.12661366f, -0.01131915f, 0.10095407f, 0.13799542f, 0.08104645f, 0.13892157f, 
    -0.16583222f, 0.14825903f, -0.11382098f, 0.14675590f, -0.11146094f, -0.01400121f, 0.18396419f, -0.28781119f, 
    -0.15114772f, 0.05156438f, 0.02717374f, -0.00886684f, 0.08674009f, -0.11189932f, -0.08079600f, 0.02303746f, 
    -0.29688632f, -0.12600425f, 0.05710965f, 0.15271488f, -0.04163595f, -0.00985371f, 0.03941154f, 0.17775251f, 
    -0.09749304f, 0.03759487f, 0.00696967f, 0.06279231f, -0.17477074f, 0.04294144f, 0.14754055f, 0.06440359f, 
    0.00877845f, 0.02089911f, 0.14213094f, -0.09376448f, 0.03597666f, -0.08129048f, 0.09224490f, 0.04166759f, 
    0.18094094f, -0.15408967f, 0.05551638f, 0.11989894f, 0.03331119f, 0.06568022f, -0.06235849f, 0.07606309f, 
    -0.08607964f, 0.04652596f, 0.07178953f, 0.01027705f, 0.06034769f, 0.02207887f, -0.00206018f, 0.14406183f, 
    0.10907612f, -0.13827135f, 0.08297155f, 0.05880760f, -0.06722923f, 0.06705546f, 0.08372793f, -0.25428769f, 
    0.01316535f, -0.01661284f, 0.20136665f, -0.22901003f, -0.00891185f, 0.01276759f, -0.05932246f, 0.00667165f, 
    0.09947972f, 0.02812310f, 0.07197426f, 0.18592241f, -0.08193187f, -0.07221076f, -0.07065912f, 0.04063820f, 
    0.08904593f, 0.04558185f, -0.06010611f, 0.04255157f, 0.00436929f, 0.12041458f, 0.09339857f, 0.16680394f, 
    -0.10503995f, -0.06731112f, 0.06513953f, -0.01660553f, -0.12334426f, -0.00744911f, 0.13972682f, 0.19401194f, 
    0.15105735f, -0.12708159f, 0.04929122f, 0.09675791f, -0.09932585f, 0.04750929f, 0.12903652f, 0.08098889f, 
    0.05614461f, -0.03621724f, -0.07535789f, -0.05763141f, 0.05867940f, -0.03656541f, -0.11403452f, 0.08742850f, 
    -0.09606460f, -0.20542242f, 0.00352207f, -0.16666342f, 0.14257917f, 0.09087989f, 0.00523225f, 0.11212062f, 
    0.02257487f, 0.06146701f, 0.09069984f, -0.00929524f, -0.08626785f, 0.24163765f, 0.01064404f, 0.02165131f, 
    0.07982372f, 0.01230602f, -0.05793606f, -0.03970734f, 0.11025698f, -0.09733535f, -0.00626580f, -0.15874985f, 
    0.09323659f, -0.05372564f, 0.17120586f, 0.12537387f, -0.00454975f, 0.05488287f, -0.09454210f, -0.05668272f, 
    0.02844172f, 0.00045284f, 0.07492238f, -0.00545696f, -0.07118016f, 0.30328733f, 0.03499771f, -0.17863442f, 
    -0.06231858f, 0.02049899f, -0.13295850f, -0.07454430f, 0.01120221f, -0.07377073f, 0.04081421f, -0.06315546f, 
    -0.00407478f, -0.01249211f, 0.26263890f, 0.16029404f, -0.04734815f, 0.03880459f, -0.16984266f, 0.07017324f, 
    -0.00284394f, -0.01362374f, -0.04308185f, 0.15390071f, 0.27972704f, 0.07424252f, 0.08759478f, 0.23408785f, 
    -0.05174317f, -0.03629704f, 0.03206285f, -0.11333907f, 0.00972280f, -0.07915416f, -0.00370801f, -0.06642669f, 
    -0.27080509f, 0.10367765f, -0.03941508f, -0.19629119f, 0.08294757f, -0.05696306f, 0.00366240f, 0.07107138f, 
    0.00967835f, 0.02042202f, 0.00359512f, -0.07421024f, -0.13717982f, -0.08805774f, -0.10928845f, 0.07979298f, 
    0.12844133f, 0.04084631f, 0.03093547f, 0.06082709f, 0.03110919f, 0.00888012f, -0.04535963f, 0.08811649f, 
    0.28037339f, 0.09932225f, 0.11206115f, 0.23754673f, -0.00915147f, -0.00571370f, 0.12466195f, 0.07568021f, 
    -0.12151869f, 0.03770509f, -0.09970850f, -0.05143026f, -0.00781328f, -0.25594077f, -0.17329931f, -0.08545032f, 
    0.03536065f, 0.02475297f, -0.10800339f, -0.07458478f, 0.04066781f, 0.01221987f, 0.05304966f, 0.22817650f, 
    -0.25620979f, 0.24699938f, 0.16980858f, 0.02510249f, -0.05678921f, -0.03710428f, -0.07943569f, 0.03673397f, 
    0.02138314f, 0.03807105f, 0.01510138f, 0.10865399f, 0.10338477f, 0.06078625f, -0.09465721f, 0.10437675f, 
    -0.01094593f, -0.01588732f, -0.00764262f, 0.10283472f, -0.01942699f, -0.03245496f, -0.17255913f, 0.01423525f, 
    0.05704044f, 0.03890049f, 0.02268038f, -0.09999401f, 0.06655077f, 0.00664703f, -0.02740644f, 0.04892532f, 
    -0.03637140f, 0.09235691f, 0.03795730f, 0.03133018f, -0.17086987f, 0.04491232f, -0.22801709f, -0.00836263f, 
    -0.05178109f, 0.02829921f, 0.00181927f, 0.02700440f, 0.08719715f, -0.01214492f, -0.03025954f, 0.03209160f, 
    0.05568076f, 0.01422991f, 0.16149072f, 0.02697577f, 0.10766432f, 0.09687773f, 0.08453131f, 0.09065688f, 
    -0.01359824f, -0.08270556f, -0.06043750f, 0.07207417f, 0.25596976f, 0.09696866f, 0.02644946f, 0.20698874f, 
    -0.05023468f, -0.11124451f, -0.20609690f, -0.08479059f, 0.11279216f, 0.14521220f, 0.00848613f, -0.00701094f, 
    -0.09822447f, 0.05835434f, -0.01501289f, 0.09661239f, 0.17372261f, -0.02016004f, 0.02572566f, 0.16064337f, 
    -0.02838697f, -0.06574778f, 0.13339770f, -0.04360305f, 0.05220557f, -0.19016385f, -0.04754400f, 0.02250540f, 
    -0.05911160f, -0.05307139f, -0.13398914f, -0.01457407f, 0.13316870f, -0.02542218f, -0.05587404f, 0.09090036f, 
    0.10173097f, 0.09441222f, 0.15018345f, 0.00511936f, -0.04422579f, 0.06603085f, -0.07146643f, -0.02839991f, 
    -0.02625404f, 0.07594244f, 0.06904573f, 0.06739663f, -0.12839979f, -0.20951046f, -0.15299486f, 0.09525891f, 
    0.22226779f, 0.02309344f, -0.17573000f, -0.03737702f, -0.12328152f, 0.03759068f, 0.04157230f, -0.12865677f, 
    0.42229903f, -0.00462046f, 0.08184908f, -0.02592140f, 0.12292735f, 0.01193940f, 0.01460637f, 0.00483488f, 
    0.01617919f, 0.10637040f, 0.04701196f, -0.03878138f, -0.17422275f, 0.04387601f, -0.13353127f, -0.05973901f, 
    0.06256061f, -0.07052433f, -0.07342870f, 0.02388707f, 0.01826973f, 0.00861536f, -0.00070121f, -0.01938817f, 
    -0.02488879f, 0.25799885f, -0.08306279f, -0.15147351f, -0.02807001f, -0.06174605f, -0.00596159f, 0.12784037f, 
    0.04747194f, -0.04053249f, -0.05012536f, 0.03926918f, 0.14771815f, 0.05201501f, 0.05763790f, -0.26819229f, 
    -0.08347245f, 0.01213679f, 0.06090097f, -0.08052449f, -0.08089665f, 0.18802471f, -0.05307851f, 0.00110466f, 
    -0.15368991f, -0.00527641f, 0.14034283f, -0.08827288f, -0.03572951f, 0.11633639f, 0.14171040f, 0.12814897f, 
    0.00064055f, 0.06899454f, -0.01166950f, 0.07845911f, -0.25056708f, 0.15210634f, -0.16087148f, -0.00882791f, 
    -0.10505380f, 0.04746887f, 0.00160327f, -0.17331508f, -0.00598598f, -0.08642344f, -0.07053900f, 0.03153567f, 
    0.11475876f, 0.00032262f, -0.04290156f, 0.03714345f, 0.14303894f, 0.07955047f, -0.01760267f, 0.21890700f, 
    0.00312268f, 0.01130237f, -0.01953334f, -0.01474551f, 0.06382012f, 0.15476359f, -0.22231394f, -0.06878631f, 
    0.12485659f, -0.00646412f, 0.02718191f, -0.08802944f, 0.05669006f, -0.06437264f, 0.16227861f, -0.27983433f, 
    0.11427329f, 0.08544721f, 0.13724101f, -0.29457179f, 0.05485198f, 0.07837926f, -0.10304844f, -0.16265611f, 
    0.06477203f, -0.01647038f, -0.01852013f, 0.07062849f, -0.06816810f, -0.00246014f, 0.15132184f, -0.10086894f, 
    0.10000381f, -0.08645664f, -0.06418339f, 0.07727380f, -0.02540161f, -0.00827294f, 0.18553004f, 0.22132979f, 
    0.15391938f, 0.12905151f, -0.14722311f, 0.05703301f, -0.15522192f, -0.12591980f, 0.03644710f, 0.23009695f, 
    0.05476586f, -0.03124728f, -0.08852562f, 0.05941312f, -0.20459789f, -0.17911617f, 0.15410413f, 0.11373023f, 
    -0.07019659f, -0.11353379f, -0.00045901f, -0.05793557f, 0.08165513f, -0.03844564f, 0.05861783f, -0.00672869f, 
    0.11057466f, 0.11774240f, 0.07386680f, -0.44595730f, 0.08478347f, 0.15798199f, 0.04114448f, 0.12243374f, 
    0.01580136f, 0.01711871f, 0.12840296f, 0.03176083f, 0.08585822f, 0.11758696f, 0.02476043f, 0.10513163f, 
    -0.00650328f, -0.04949738f, 0.07551389f, -0.20356561f, -0.06212011f, -0.21080972f, -0.13532089f, -0.22637896f, 
    0.03824595f, -0.01014603f, -0.01109214f, 0.14070874f, 0.06174745f, 0.11097067f, -0.12153316f, -0.04554354f, 
    0.00800629f, 0.10861323f, -0.03507720f, -0.10858577f, 0.00216306f, 0.08678464f, 0.27601171f, 0.12544531f, 
    0.02677974f, -0.07164362f, -0.17284152f, -0.16599834f, 0.08291410f, 0.04211376f, -0.04473910f, -0.12698781f, 
    -0.20550002f, -0.12480486f, 0.02367184f, 0.14048499f, 0.25670740f, 0.12473388f, 0.05819086f, -0.06946005f, 
    0.12133406f, -0.07376856f, 0.12459891f, 0.03959899f, -0.41229570f, -0.13231386f, -0.06979279f, -0.22131442f, 
    0.07403189f, 0.07745160f, 0.06313765f, 0.03471810f, 0.12635438f, 0.10655560f, 0.00574529f, 0.04532977f, 
    0.12790641f, 0.19891171f, 0.12049492f, 0.13794835f, -0.04037160f, -0.06971664f, -0.15524182f, 0.01177827f, 
    -0.09394013f, -0.05695819f, -0.14893371f, -0.07916437f, -0.14516412f, 0.21880405f, 0.23878385f, -0.00805254f, 
    -0.15147369f, 0.01601934f, 0.03370613f, 0.27830651f, 0.02237433f, -0.01190607f, -0.05200844f, -0.05490863f, 
    0.08249111f, -0.06698170f, -0.29768580f, -0.30916137f, 0.04927221f, 0.12835295f, -0.07803167f, 0.13738231f, 
    0.07491781f, 0.00262050f, -0.15603259f, -0.13333198f, 0.13843690f, 0.06242914f, 0.00589920f, 0.24849977f, 
    0.12074415f, 0.08674663f, -0.02456320f, -0.02084754f, -0.20608804f, -0.00671605f, 0.12826286f, 0.03376117f, 
    0.11160273f, -0.13039035f, -0.07037999f, 0.12682235f, 0.05865390f, 0.06358760f, 0.09485698f, 0.04713504f, 
    -0.00096275f, 0.09401394f, -0.06381269f, 0.04967392f, -0.11915944f, -0.00216794f, 0.06769111f, -0.13697685f, 
    0.02119374f, 0.04032974f, 0.06061111f, -0.03297954f, -0.01709607f, 0.09785922f, 0.10708179f, 0.05372071f, 
    -0.07755310f, -0.22162905f, 0.29136717f, 0.11629735f, -0.00466567f, -0.02125030f, 0.05112817f, 0.11475812f, 
    -0.00348641f, -0.03229503f, -0.02803032f, 0.02007126f, -0.25892675f, 0.07817036f, 0.07436538f, 0.22096370f, 
    0.08782163f, -0.01518158f, 0.04474325f, 0.01376509f, -0.14058386f, -0.03708061f, 0.02465916f, -0.19860661f, 
    -0.01546961f, -0.11794679f, 0.08614235f, -0.11529856f, 0.11014139f, 0.01900694f, -0.13577160f, -0.03621092f, 
    0.11093029f, -0.01741124f, 0.02963969f, 0.07143841f, -0.11741196f, -0.06708673f, -0.06620976f, -0.02802216f, 
    0.03606686f, -0.00185504f, 0.02020905f, -0.13871558f, -0.04184498f, 0.10442353f, 0.05954383f, 0.17585798f, 
    -0.13906115f, -0.03416348f, -0.01418901f, -0.23283277f, -0.04828694f, -0.04880301f, 0.08338717f, -0.06278170f, 
    0.10438026f, -0.03465034f, 0.03252011f, -0.02502105f, 0.14576563f, 0.15228447f, 0.09348948f, 0.08179313f, 
    0.03267214f, 0.06744214f, -0.02230626f, 0.00155813f, 0.01355317f, -0.01102907f, 0.06129967f, 0.19111510f, 
    -0.11084950f, -0.10260241f, 0.05305642f, 0.28023791f, 0.03502167f, -0.03255461f, -0.05941372f, 0.16275224f, 
    -0.02826972f, -0.00882738f, 0.07903553f, 0.05901962f, 0.01909230f, 0.27620137f, 0.17960551f, 0.11384374f, 
    -0.03789431f, -0.03538959f, -0.03181721f, -0.10274734f, -0.10130166f, 0.04465488f, 0.02898992f, 0.04630307f, 
    0.01732996f, 0.04664220f, 0.12511104f, 0.18377727f, 0.10092571f, 0.09517065f, -0.07814819f, -0.07243488f, 
    0.00858346f, -0.02272001f, -0.02068287f, -0.10116109f, -0.00661195f, 0.04119934f, 0.28331545f, 0.02139375f, 
    0.05955881f, -0.05888435f, 0.03734965f, -0.05629703f, -0.02727904f, 0.00403656f, 0.03558446f, -0.07524101f, 
    -0.07977928f, -0.08669124f, -0.04203324f, -0.18555935f, 0.01895048f, 0.03239569f, -0.07996736f, 0.00472474f, 
    -0.00855160f, -0.06879722f, 0.02881667f, -0.02259077f, -0.21039967f, -0.14937127f, 0.08161654f, -0.02010709f, 
    0.15476920f, -0.02598059f, 0.05563681f, 0.03087502f, -0.03046914f, 0.09626555f, -0.01070368f, -0.04970272f, 
    0.07019889f, 0.15608075f, 0.10317581f, 0.14284752f, -0.06791603f, 0.05397741f, 0.12035617f, -0.10989890f, 
    -0.06269150f, -0.04564018f, -0.01592544f, -0.07403154f, 0.50091416f, -0.15003058f, -0.06680916f, -0.21062265f, 
    0.00333345f, -0.02124912f, -0.01746111f, -0.04379621f, 0.05870551f, -0.01396459f, 0.12899949f, 0.08575040f, 
    -0.15010570f, 0.24233763f, 0.10958505f, 0.13109764f, 0.01455962f, -0.04686919f, -0.03617349f, -0.02446248f, 
    -0.00403814f, -0.04532075f, 0.03304383f, 0.00004524f, -0.11546218f, 0.08441210f, 0.07050651f, -0.10303244f, 
    0.01292169f, -0.00425046f, -0.01069562f, 0.12870561f, -0.10996608f, 0.10501709f, -0.01983013f, 0.02819548f, 
    0.01949174f, -0.08997500f, -0.01314682f, -0.01938005f, 0.03774038f, 0.08937248f, 0.01080802f, 0.00164732f, 
    0.00225064f, -0.04825205f, -0.00901117f, 0.04129229f, -0.11656473f, -0.19608036f, -0.00165671f, -0.02673494f, 
    0.07611759f, -0.00939623f, 0.00730407f, -0.00538680f, 0.07056515f, 0.00096922f, -0.10331284f, 0.02231472f, 
    0.30186599f, 0.11788642f, -0.09563894f, 0.16502377f, -0.05455757f, 0.05127227f, 0.09119158f, 0.15057322f, 
    0.01919615f, 0.05629540f, -0.07650073f, -0.00926703f, -0.02273777f, -0.03711675f, -0.07614516f, 0.25640014f, 
    -0.09352508f, -0.08268138f, -0.09736874f, -0.00210348f, 0.04228573f, 0.00379147f, -0.17602077f, 0.04667652f, 
    -0.02175002f, 0.04179902f, 0.15172184f, 0.13804698f, 0.06771550f, 0.09979394f, 0.00448502f, 0.12087510f, 
    -0.18981907f, 0.09384895f, -0.03923995f, 0.00428847f, 0.11151836f, -0.15777850f, -0.11250640f, -0.19903441f, 
    -0.19800177f, -0.05607338f, 0.09151414f, -0.05015141f, 0.13325055f, 0.05883893f, 0.02893474f, 0.03423392f, 
    0.32187110f, -0.06225120f, 0.00128328f, -0.13580248f, -0.01853552f, 0.14008139f, -0.21622114f, -0.08122588f, 
    0.00543229f, 0.05832632f, 0.08389150f, 0.02871016f, -0.03445251f, -0.31853861f, -0.16184780f, -0.05403282f, 
    0.13172294f, 0.05865607f, 0.00161204f, -0.09654310f, 0.01281910f, 0.04052757f, 0.03856793f, -0.04359718f, 
    0.02991972f, -0.00600040f, -0.19322036f, 0.06996337f, 0.02107840f, 0.09054863f, -0.14121445f, -0.01779826f, 
    0.01447756f, -0.00633608f, -0.00168170f, -0.07151343f, 0.12042863f, -0.04733060f, 0.11158238f, -0.10722031f, 
    -0.11798874f, 0.12911385f, 0.06567407f, 0.00942559f, -0.02164822f, 0.05850054f, -0.04315588f, -0.02136310f, 
    0.16621941f, -0.19424838f, 0.16514434f, 0.05870117f, -0.13735875f, 0.11265080f, 0.01990888f, 0.03583923f, 
    0.02618096f, -0.02646251f, 0.02979242f, -0.00619255f, 0.08407573f, -0.02387549f, 0.13078149f, -0.24979129f, 
    -0.05242500f, -0.11094550f, -0.01635620f, 0.01616285f, 0.08791450f, -0.02146775f, 0.04939524f, 0.02252094f, 
    0.03889611f, 0.18057846f, 0.01080150f, 0.08878321f, -0.02876317f, 0.03870076f, 0.01758367f, 0.07272525f, 
    0.02081302f, -0.05976629f, -0.01172034f, 0.07361633f, 0.60591722f, 0.15464723f, 0.00007020f, -0.01189653f, 
    -0.09633683f, 0.07456706f, -0.04238919f, 0.01976522f, -0.00113179f, 0.14626114f, -0.08237358f, 0.05092368f, 
    -0.01781811f, -0.04863759f, -0.07635890f, 0.00628588f, -0.03255633f, 0.07081261f, 0.02155069f, -0.03361836f, 
    0.00771364f, -0.02022724f, 0.02915297f, -0.08031256f, 0.03086985f, -0.03960242f, 0.15207995f, 0.00233490f, 
    -0.03029133f, 0.06821754f, 0.05059453f, 0.02591253f, 0.05985370f, -0.13072489f, 0.14601007f, 0.02306905f, 
    0.06318159f, 0.01925991f, -0.06181218f, 0.19759442f, 0.04212353f, 0.01275345f, 0.06649716f, -0.05501109f, 
    -0.07959161f, -0.09162770f, -0.01423456f, 0.10101169f, 0.28421548f, -0.32134926f, 0.04766757f, -0.02466742f, 
    -0.02535160f, 0.10335388f, 0.11120862f, 0.09935400f, 0.10685378f, -0.00306789f, -0.13626999f, -0.11628132f, 
    -0.21135703f, 0.27771431f, -0.24101855f, 0.07608491f, 0.01897533f, 0.10597848f, -0.00251814f, -0.02044722f, 
    0.03281321f, 0.03340209f, 0.09110212f, -0.09765991f, -0.41941482f, -0.02761184f, -0.23695782f, -0.36494046f, 
    -0.05274906f, -0.00998448f, -0.02343136f, -0.18466429f, -0.00582603f, 0.01725552f, 0.02635838f, -0.01517584f, 
    0.52034706f, -0.00530468f, 0.23051728f, -0.03917386f, -0.08647951f, 0.09128562f, 0.03579373f, 0.05892671f, 
    0.05540769f, 0.01439330f, -0.02261384f, 0.01179099f, 0.29946649f, 0.15898062f, -0.31620029f, -0.07912921f, 
    0.04601696f, -0.01823673f, 0.08454186f, -0.06275231f, 0.03843027f, -0.04874045f, -0.05722566f, 0.03822403f, 
    -0.01636162f, -0.04932906f, -0.23557399f, 0.04287022f, 0.02042868f, 0.04771058f, 0.05236766f, -0.07818367f, 
    0.00891364f, -0.03932119f, -0.13789904f, 0.00605219f, 0.20560805f, 0.18982486f, 0.00625408f, 0.10254265f, 
    0.01860883f, -0.05421335f, 0.05690461f, -0.05137993f, 0.09680375f, 0.09234656f, 0.10983563f, 0.07659835f, 
    0.29204512f, 0.15551850f, 0.02456339f, -0.11045709f, -0.13231392f, -0.15076970f, -0.02702034f, 0.10093049f, 
    0.02399842f, 0.09131414f, -0.03053193f, 0.01125088f, 0.06903509f, 0.14123759f, -0.02127161f, 0.05873926f, 
    -0.04423026f, -0.12005185f, -0.02751516f, -0.01703349f, 0.03454474f, -0.04801489f, 0.04261339f, 0.01136836f, 
    -0.32613829f, 0.09253932f, -0.24177784f, 0.05678653f, 0.02353984f, -0.06863191f, 0.10747661f, 0.07871556f, 
    0.06078268f, 0.08221777f, 0.17734338f, -0.07459467f, 0.25923577f, -0.02251127f, -0.22891198f, 0.30817321f, 
    0.08975010f, 0.03668460f, 0.15582202f, 0.02683133f, -0.16426897f, 0.10313304f, -0.00335238f, 0.12091724f, 
    -0.03301460f, 0.01594033f, 0.15348946f, -0.01377702f, -0.10898562f, -0.10225169f, 0.11001185f, 0.04711565f, 
    -0.01691005f, 0.05084357f, -0.02564620f, 0.05433432f, -0.66205299f, -0.09244229f, 0.01199334f, 0.02224463f, 
    -0.08340137f, 0.05232338f, 0.06746417f, 0.15789390f, 0.08561774f, -0.02067826f, 0.03537700f, 0.01632940f, 
    0.00586562f, 0.07250437f, 0.02505962f, -0.15104721f, -0.07521402f, -0.02789250f, -0.01965210f, 0.02926256f, 
    -0.12620628f, -0.10014766f, -0.05223641f, 0.01005832f, 0.19988737f, -0.03899388f, -0.06523132f, 0.09970457f, 
    0.12227437f, 0.03584395f, -0.03104428f, -0.00756531f, -0.06566959f, 0.00179332f, -0.11484296f, -0.07048526f, 
    0.09442880f, 0.27984130f, -0.00033411f, -0.27809873f, 0.06486951f, -0.02908135f, -0.02694694f, 0.12036573f, 
    -0.00512919f, 0.06332309f, 0.04443134f, -0.08998732f, 0.02298565f, 0.11445390f, -0.05141928f, -0.01897208f, 
    -0.04956044f, -0.05092640f, 0.00006635f, 0.11645342f, 0.04427293f, -0.05206011f, -0.00331107f, 0.11992853f, 
    -0.06389957f, -0.04477080f, 0.09205442f, 0.03337261f, 0.08602429f, -0.12341481f, -0.04326896f, 0.02292738f, 
    -0.06788195f, 0.04646935f, 0.07959485f, 0.12960705f, 0.13243438f, -0.01103675f, 0.13538310f, 0.17364100f, 
    -0.02321469f, 0.05273720f, 0.01843614f, 0.17469016f, 0.07524169f, -0.00996013f, 0.02234622f, -0.07773240f, 
    -0.05627989f, 0.18602511f, -0.15678152f, -0.00424971f, 0.03360914f, 0.00557719f, -0.00652309f, -0.01377682f, 
    -0.05047090f, -0.06296846f, 0.01760780f, 0.02861352f, -0.29052973f, -0.15401387f, 0.10547597f, -0.02915190f, 
    -0.03967772f, 0.10101363f, 0.02833690f, 0.06182425f, 0.01531181f, -0.00410022f, 0.05342872f, -0.05163952f, 
    -0.20758699f, 0.19857846f, 0.09469356f, -0.04471551f, 0.00760822f, 0.00228254f, 0.06511481f, 0.02799580f, 
    0.04527206f, 0.03232730f, -0.05438793f, 0.02126603f, -0.00066808f, -0.30314556f, 0.18811199f, 0.10981369f, 
    -0.01584218f, 0.05313927f, -0.12910450f, 0.10142654f, 0.01293926f, -0.04337599f, 0.04301608f, -0.06089711f, 
    0.25515136f, -0.13792984f, 0.11267211f, 0.10363728f, 0.22532234f, 0.11094180f, -0.05188566f, 0.00346473f, 
    0.00877426f, -0.10162189f, 0.01268631f, 0.10291952f, 0.13954745f, -0.12184045f, 0.02730169f, -0.09035745f, 
    -0.11875312f, -0.03393644f, 0.02170389f, -0.01637798f, -0.04686329f, 0.07263192f, 0.02402879f, 0.01786714f, 
    0.10240126f, -0.05133565f, 0.11720969f, -0.08826507f, 0.00144131f, 0.07333509f, 0.05783242f, 0.04417697f, 
    0.10985942f, 0.08380731f, -0.06824271f, -0.07705073f, -0.44735283f, 0.09627677f, 0.19524091f, -0.08673379f, 
    -0.02030119f, -0.04962877f, 0.02192541f, 0.04403471f, -0.10177167f, -0.03353110f, 0.03460392f, 0.02244887f, 
    -0.05842065f, 0.07899346f, 0.12489254f, 0.34588948f, -0.11969637f, -0.07046659f, 0.00959194f, 0.02524178f, 
    -0.02025519f, 0.04491982f, 0.07152386f, 0.13920283f, -0.02959373f, 0.00558033f, 0.05749187f, -0.11853361f, 
    0.00482871f, 0.12941206f, 0.13239846f, 0.01482481f, 0.00951073f, 0.00405562f, 0.02278932f, -0.03587507f, 
    0.12369620f, -0.08992405f, -0.14058134f, -0.08692460f, 0.18328094f, 0.05569981f, 0.03026784f, 0.04158882f, 
    0.06684989f, -0.03016232f, 0.00728948f, 0.04341394f, 0.20777658f, -0.17884035f, 0.03316170f, -0.04051396f, 
    -0.13350920f, 0.04262308f, -0.10381439f, -0.15939061f, -0.00173070f, 0.08121038f, 0.04454899f, -0.14629376f, 
    0.22361587f, -0.08398803f, 0.02239693f, 0.02400029f, 0.02626969f, 0.01047564f, -0.10270108f, 0.03469301f, 
    -0.06125221f, -0.11439896f, -0.12675281f, -0.06737937f, 0.02158700f, -0.17155066f, -0.02725175f, -0.20278287f, 
    -0.01489333f, 0.05209764f, 0.10864032f, -0.08192190f, -0.04316976f, 0.09085721f, -0.08608916f, 0.07222123f, 
    -0.06864276f, 0.17377783f, 0.05626909f, 0.24550641f, 0.09095910f, -0.01807812f, 0.00207050f, 0.13336857f, 
    -0.10762291f, 0.13565834f, 0.01013841f, 0.02718602f, -0.09708812f, -0.06400663f, -0.01157033f, 0.06290305f, 
    0.01482104f, 0.03901333f, -0.10894603f, 0.01603076f, 0.05540749f, 0.01707081f, 0.03481217f, -0.07162234f, 
    -0.06253336f, -0.00444978f, 0.15750192f, 0.12841420f, 0.03947957f, -0.05272804f, -0.02324442f, 0.07429622f, 
    0.05264157f, -0.13332568f, 0.09985352f, -0.12933011f, -0.12530218f, 0.26178664f, -0.07031546f, -0.09928621f, 
    -0.09190380f, -0.05596754f, 0.04354610f, 0.12174422f, 0.02413965f, 0.05592431f, -0.01919774f, -0.07653461f, 
    0.26304230f, -0.02854413f, -0.01166864f, -0.09176335f, -0.05360644f, 0.04076762f, 0.01198292f, -0.10325948f, 
    -0.03164030f, 0.03874929f, -0.02131496f, 0.04327096f, -0.09648532f, 0.17255928f, -0.02161546f, 0.00074258f, 
    0.14332969f, -0.03662087f, -0.06411467f, -0.09452508f, 0.04616081f, -0.08773839f, -0.03558488f, 0.06446262f, 
    0.00600305f, -0.02684366f, 0.00657816f, -0.06653583f, 0.02490520f, 0.01324006f, 0.06307453f, 0.03250210f, 
    -0.04901522f, -0.05315490f, -0.04080744f, 0.06339298f, 0.05510587f, 0.00637344f, -0.06646467f, 0.00153608f, 
    0.00375549f, -0.02051569f, -0.04341355f, -0.01237529f, -0.03954942f, 0.03260766f, -0.00201140f, -0.04489595f, 
    -0.00580689f, -0.04050456f, -0.00496498f, 0.02999207f, -0.03221524f, -0.01705758f, 0.06089011f, -0.00389428f, 
    0.05170112f, -0.06892996f, -0.00489058f, 0.04973404f, -0.01570835f, 0.05773858f, 0.06820545f, 0.04244452f, 
    0.01141057f, 0.00795553f, 0.02862664f, 0.01088203f, -0.04009188f, 0.04409526f, -0.05175547f, 0.05989865f, 
    -0.04124140f, 0.00821564f, -0.05169184f, -0.06743722f, 0.06104376f, -0.05168657f, 0.04129596f, -0.04210710f, 
    -0.03324429f, -0.03198065f, -0.07259072f, 0.01186859f, 0.04411787f, -0.04205319f, -0.06481434f, -0.06819328f, 
    -0.02907114f, 0.03582068f, -0.06134780f, 0.03203420f, -0.06177508f, 0.06109801f, -0.07196803f, -0.07634822f, 
    0.00176340f, -0.06034089f, 0.06224690f, 0.02152649f, -0.05096278f, 0.06388296f, -0.06883886f, 0.03930841f, 
    0.02132845f, -0.02627399f, -0.06216379f, -0.03996428f, -0.03651658f, 0.05653077f, 0.05239755f, -0.01481347f, 
    -0.06721542f, -0.05999521f, -0.00602807f, -0.04608024f, -0.04911985f, 0.03152249f, -0.06938207f, -0.06366362f, 
    -0.04126226f, 0.02025070f, 0.04500243f, -0.07179034f, -0.04500820f, 0.03907891f, -0.07741357f, -0.03416663f, 
    -0.07782378f, -0.03401960f, 0.04010517f, -0.00078850f, 0.04027902f, 0.02454675f, -0.01905044f, 0.04284142f, 
    -0.03430915f, -0.01249842f, -0.01138895f, -0.00600503f, -0.07279597f, 0.02748787f, 0.00559075f, 0.04404891f, 
    0.04276529f, 0.02150722f, 0.01479299f, 0.01596358f, -0.07110452f, 0.00830920f, -0.06685308f, -0.07205610f, 
    -0.02430389f, -0.06874102f, 0.06142154f, 0.01912455f, -0.02191766f, 0.02516587f, -0.06868958f, -0.05455278f, 
    0.04302721f, -0.05181141f, 0.02528497f, 0.05435890f, 0.01135886f, 0.01793530f, 0.04232485f, -0.00040029f, 
    -0.03760803f, -0.05762111f, 0.01616647f, -0.04277402f, 0.04624434f, -0.07552195f, -0.02913637f, -0.01647860f, 
    0.00175833f, -0.02731034f, -0.07193168f, 0.05044337f, -0.01120894f, -0.05647514f, -0.00297633f, -0.06034666f, 
    -0.02273318f, 0.01326506f, -0.02868488f, 0.01637248f, 0.02596023f, 0.00503661f, -0.04482986f, 0.03919619f, 
    -0.05301542f, 0.06121203f, 0.00994242f, -0.03087236f, -0.07040881f, -0.01208057f, 0.03828728f, -0.03240625f, 
    0.01721647f, -0.05912340f, -0.03366676f, -0.02644380f, 0.00210561f, 0.01922226f, 0.04190329f, -0.01874324f, 
    0.03026214f, 0.04437440f, 0.02960896f, -0.01605982f, 0.03410860f, -0.02543022f, -0.04840609f, 0.04624606f, 
    -0.04133943f, -0.10648718f, -0.02765701f, 0.22645839f, 0.28529334f, 0.05902722f, 0.02507053f, 0.08998171f, 
    0.00336998f, -0.06136342f, 0.06519233f, 0.02143008f, -0.10637759f, 0.00802442f, 0.04100863f, -0.00558599f, 
    -0.04491653f, 0.06048327f, 0.10606108f, 0.11730006f, -0.02767769f, -0.02762845f, 0.08272603f, -0.01806822f, 
    -0.04070778f, 0.23083603f, -0.01546590f, -0.09476326f, 0.00307131f, -0.01232396f, -0.16981892f, -0.05396569f, 
    0.09253524f, 0.07461511f, 0.09333387f, 0.07310335f, -0.65889031f, -0.04071429f, 0.04241230f, -0.16830885f, 
    0.00365244f, -0.04177582f, 0.08664966f, -0.10527122f, 0.06575224f, -0.01440939f, 0.02640961f, -0.11072908f, 
    0.00940004f, -0.00544370f, -0.01689261f, 0.29120141f, -0.05624062f, 0.05581024f, -0.02417714f, 0.03670368f, 
    0.04989182f, -0.10893558f, 0.05712559f, -0.08980808f, -0.07174192f, -0.03849664f, 0.20505333f, -0.11101583f, 
    0.07761346f, 0.13711308f, -0.10671558f, -0.21119294f, 0.00655721f, -0.03634251f, 0.07852619f, 0.05687838f, 
    0.05369852f, -0.13492079f, -0.02006193f, 0.16706271f, 0.04992510f, 0.00876958f, -0.01085125f, 0.09619419f, 
    0.04440099f, 0.03382060f, -0.07829330f, 0.11378386f, -0.07946850f, -0.05282197f, -0.05820148f, 0.00533593f, 
    0.09673576f, 0.07404775f, -0.00572370f, 0.10796065f, 0.11330261f, 0.07699276f, -0.04676723f, 0.00645117f, 
    -0.12614445f, -0.15398592f, -0.02892933f, -0.02215785f, 0.04732072f, 0.00410549f, -0.06384818f, -0.20219624f, 
    0.00089191f, 0.00721298f, 0.06219650f, 0.08596075f, -0.13318212f, -0.02459237f, -0.03709032f, -0.00254404f, 
    -0.02390822f, 0.03844174f, -0.03972056f, -0.02925498f, 0.03073383f, 0.16172944f, -0.06547840f, 0.00205365f, 
    -0.03861570f, -0.00114106f, -0.03931073f, 0.03378718f, 0.10655475f, 0.02564000f, 0.09604310f, 0.04188665f, 
    -0.14382738f, 0.02251403f, -0.07672069f, -0.05622795f, 0.08955744f, -0.03158711f, 0.16269334f, 0.18341495f, 
    0.12994255f, 0.01404517f, 0.04079200f, 0.07609850f, 0.01207828f, 0.00918590f, -0.08625296f, 0.13308348f, 
    -0.27499822f, -0.11145290f, -0.05149193f, 0.20077002f, -0.01637341f, 0.01131819f, 0.05680078f, -0.00041839f, 
    0.11165108f, -0.05861390f, 0.06711046f, -0.14871143f, -0.11969782f, 0.16427784f, 0.18523151f, -0.06816547f, 
    0.11734675f, 0.04575439f, -0.15163288f, -0.05554709f, 0.12074983f, 0.09273271f, 0.12927394f, 0.07736317f, 
    0.19319968f, -0.09962467f, 0.08902904f, 0.02336572f, -0.06334317f, 0.02742180f, 0.03568692f, -0.05070248f, 
    -0.12461383f, 0.13148658f, -0.03393674f, 0.05691246f, -0.12631327f, 0.19751345f, -0.01117618f, -0.17572010f, 
    0.12857537f, -0.01696000f, -0.10744274f, -0.01560051f, 0.00386702f, -0.06467997f, 0.04246224f, 0.08975546f, 
    -0.06512632f, -0.06026819f, -0.27396795f, -0.23073153f, -0.06457866f, 0.03690971f, 0.04277032f, 0.20034882f, 
    -0.03739872f, 0.00098335f, -0.05064053f, -0.01408188f, 0.49561146f, -0.08579328f, -0.22603431f, -0.09746883f, 
    -0.02836553f, 0.04966301f, 0.10122158f, 0.05785478f, -0.03383470f, -0.00409368f, 0.00816832f, 0.03158328f, 
    0.09609060f, -0.03410302f, 0.04686850f, 0.08997978f, 0.00749853f, 0.05453321f, 0.03928186f, 0.07638155f, 
    0.00135628f, 0.06182376f, 0.17970501f, -0.07093630f, 0.00283023f, -0.26736462f, -0.08899389f, -0.01078260f, 
    0.14505787f, 0.00626304f, 0.00324180f, 0.09540734f, -0.03194134f, -0.05489264f, -0.08872249f, -0.02545745f, 
    0.17201883f, -0.20166890f, 0.10015780f, 0.16038595f, 0.07277800f, -0.11398292f, 0.09714595f, 0.16544230f, 
    -0.03264667f, -0.05511963f, 0.17322113f, 0.01420944f, 0.19771837f, 0.03298107f, 0.04005742f, 0.06929917f, 
    0.06547853f, 0.05901539f, 0.19557554f, 0.02047982f, 0.03309184f, -0.06193243f, -0.03750225f, -0.07016092f, 
    -0.54575545f, 0.02452725f, -0.33026627f, -0.24027252f, 0.05914658f, -0.04910482f, 0.07474531f, 0.03091352f, 
    -0.08934322f, -0.05052925f, 0.03433241f, 0.13957642f, 0.25715292f, -0.00948018f, -0.08872575f, -0.02793950f, 
    -0.08606393f, 0.09895217f, 0.02559253f, 0.06013959f, 0.03097619f, 0.06487469f, -0.17232604f, -0.02131773f, 
    0.12117609f, 0.15149142f, -0.08508109f, -0.02231110f, 0.00514176f, -0.05220849f, 0.00947127f, 0.00922229f, 
    -0.06250175f, 0.00232800f, -0.02378846f, 0.02964745f, 0.32942814f, 0.02036333f, -0.21880649f, -0.01908481f, 
    -0.03217849f, 0.07337661f, -0.13636993f, 0.00928929f, 0.11760049f, 0.16386162f, 0.01371581f, 0.05026311f, 
    -0.60424066f, 0.03772790f, -0.25175652f, -0.03590706f, 0.10025813f, 0.18549037f, 0.09048342f, 0.13368359f, 
    -0.02062247f, 0.12283570f, 0.02903548f, -0.04606354f, -0.21652102f, -0.06958386f, -0.06038333f, -0.28573582f, 
    -0.02199591f, 0.04255229f, 0.00161440f, -0.02536401f, 0.05261864f, 0.18611714f, 0.13042831f, -0.13203120f, 
    -0.07759018f, -0.17798309f, -0.00902085f, 0.07113580f, 0.01693299f, -0.07380191f, -0.11654119f, -0.00609553f, 
    -0.03662474f, 0.12929608f, -0.08881663f, 0.03247696f, -0.01609595f, -0.03173372f, 0.04481322f, 0.19834235f, 
    -0.00420090f, 0.11228149f, -0.00213739f, -0.07458558f, 0.11404772f, -0.00615893f, -0.00949747f, -0.04635316f, 
    -0.35094509f, 0.10111033f, -0.23700157f, -0.15763862f, 0.00981012f, -0.04166792f, 0.08453470f, 0.06545283f, 
    0.04561394f, -0.09892008f, -0.09672296f, 0.06978761f, 0.01911036f, 0.14113811f, 0.23876382f, 0.18056063f, 
    -0.07028384f, -0.03208519f, 0.05471939f, 0.00587007f, 0.01030606f, 0.04594214f, 0.05005205f, 0.02647196f, 
    -0.07573833f, 0.07730797f, -0.17514609f, 0.13474600f, -0.15885019f, 0.11633863f, -0.08168937f, -0.08711185f, 
    -0.10933610f, 0.05118348f, 0.03402609f, 0.02140266f, 0.54218531f, -0.05012824f, 0.07743328f, 0.12020606f, 
    -0.08325452f, 0.08756392f, 0.06143493f, 0.05373588f, -0.01299998f, -0.02882216f, -0.03135373f, -0.00513520f, 
    0.35071117f, -0.34664840f, -0.06814112f, -0.02171130f, -0.04223259f, 0.15101601f, 0.08364572f, -0.05187666f, 
    -0.01358424f, 0.06398209f, 0.11524089f, 0.10470571f, -0.06653762f, -0.29268849f, 0.15089831f, 0.22056811f, 
    0.06019364f, -0.03578119f, -0.01880473f, 0.04533463f, 0.07077637f, -0.02781374f, -0.02687964f, 0.08899204f, 
    0.22210163f, -0.09395236f, -0.00198583f, 0.07171198f, -0.05251200f, 0.04767453f, 0.09080829f, 0.05193364f, 
    -0.01886867f, -0.02208190f, 0.08979670f, -0.01484789f, 0.10549600f, 0.03394920f, 0.08989152f, -0.12276098f, 
    0.02080671f, -0.05591383f, -0.01058665f, -0.04930912f, -0.00740118f, 0.12440837f, -0.05360805f, 0.07166421f, 
    0.20973089f, 0.17862655f, -0.07993264f, 0.01737460f, -0.04225456f, 0.09155122f, 0.09494126f, -0.11753923f, 
    0.14537521f, 0.15008044f, 0.14959803f, 0.03712190f, 0.25997159f, -0.05757042f, -0.01324936f, -0.20086962f, 
    -0.03568482f, -0.03677322f, 0.02480516f, 0.11991148f, -0.00887669f, -0.05464223f, -0.05974059f, 0.02503341f, 
    -0.23138933f, -0.13861474f, -0.12572534f, 0.21837904f, 0.01095550f, 0.10573822f, 0.03770994f, -0.07068706f, 
    0.05216224f, 0.03358855f, -0.03627473f, -0.00034225f, 0.49910867f, -0.16315888f, 0.04294902f, 0.02556893f, 
    -0.08596807f, 0.00503309f, -0.07293880f, -0.09966796f, 0.07429688f, 0.13484111f, -0.09769909f, 0.08404800f, 
    0.01323633f, 0.03609814f, -0.15257558f, 0.13548961f, -0.00568643f, 0.06199177f, 0.04456660f, 0.01344183f, 
    0.09297964f, 0.01124326f, -0.10491074f, -0.08983491f, 0.23778136f, 0.02392638f, -0.21920696f, -0.06547860f, 
    -0.04650607f, -0.00229080f, -0.04274568f, -0.03443449f, 0.08033333f, -0.05721088f, -0.03760996f, -0.06503959f, 
    0.13307589f, -0.16732560f, -0.03623501f, 0.15859458f, -0.00454802f, -0.03841729f, -0.07644182f, 0.19614656f, 
    -0.01833653f, 0.00840243f, 0.01769084f, 0.01053484f, -0.11602275f, 0.08214766f, 0.03045891f, -0.07283464f, 
    0.09505868f, -0.01714155f, -0.15021233f, -0.04387718f, 0.04162125f, -0.02273403f, -0.01603664f, -0.02340316f, 
    0.18919948f, 0.05688531f, 0.02651111f, 0.02770087f, 0.07901648f, 0.09371798f, 0.03227687f, -0.02292790f, 
    -0.10056343f, -0.12748039f, 0.05656344f, -0.08622383f, 0.06341249f, 0.21628071f, -0.11016951f, -0.35451213f, 
    -0.05350729f, 0.02371460f, -0.01595120f, -0.06350059f, 0.02143040f, 0.07170192f, 0.08021300f, -0.10803128f, 
    -0.06213475f, -0.12728508f, -0.00254007f, -0.08449294f, 0.01885031f, 0.01690173f, -0.15082021f, -0.14893006f, 
    -0.10060023f, 0.01620695f, 0.11116992f, -0.00513721f, -0.14015785f, 0.01037059f, 0.07219061f, -0.11586498f, 
    0.05584995f, -0.09553583f, 0.08875412f, 0.03936931f, 0.03126360f, -0.02971957f, -0.13174365f, -0.08969924f, 
    0.22988182f, -0.03248101f, -0.16475563f, -0.14978643f, 0.02366685f, 0.05812594f, 0.07380151f, 0.13067384f, 
    -0.05491173f, 0.13765244f, -0.01039371f, 0.13268599f, -0.01790250f, 0.08068433f, 0.15508099f, 0.07268927f, 
    0.07117488f, 0.07681250f, 0.03874421f, -0.01717457f, -0.00283081f, 0.04074834f, -0.00024741f, 0.14650832f, 
    -0.25874409f, -0.03265226f, -0.12381063f, 0.15827255f, -0.01644980f, 0.06113824f, -0.05747257f, -0.08696263f, 
    -0.03684269f, -0.02079097f, 0.11989464f, 0.08852669f, 0.02977044f, 0.06502782f, 0.30711573f, 0.06374587f, 
    0.12274227f, 0.05846531f, -0.14645320f, -0.09591940f, 0.05214635f, -0.08077622f, 0.01167383f, 0.01654767f, 
    0.10592284f, 0.04777842f, -0.02252053f, 0.02478147f, 0.09453444f, -0.05197386f, 0.13340269f, 0.08325864f, 
    0.00587860f, 0.16016136f, 0.03038292f, 0.09321242f, -0.02478153f, 0.11187638f, -0.00779919f, 0.04487730f, 
    0.16697712f, -0.15816569f, 0.13180590f, 0.06380877f, 0.02920505f, 0.00548907f, 0.11351795f, -0.13631974f, 
    0.17903315f, -0.08880620f, -0.01167387f, 0.20171605f, 0.19396119f, 0.10626898f, -0.00901902f, 0.05489068f, 
    0.10333728f, 0.04503118f, 0.15378553f, -0.05572630f, -0.00843688f, -0.03064306f, -0.02728839f, -0.14750436f, 
    0.03489524f, 0.07194543f, -0.03638409f, -0.08222435f, 0.03617754f, 0.13133708f, 0.08429389f, 0.22436555f, 
    0.14570004f, -0.05601491f, -0.09862547f, 0.19468383f, -0.24068297f, -0.01142087f, 0.14665763f, 0.08830106f, 
    -0.04284992f, 0.02983689f, -0.06932645f, 0.04517186f, 0.05641528f, 0.08232222f, -0.01818144f, 0.18558948f, 
    -0.10210876f, -0.06912927f, 0.03165581f, 0.07835978f, -0.02622055f, -0.16159537f, -0.01895427f, 0.01504592f, 
    -0.21462321f, -0.26410437f, -0.14788480f, 0.06511129f, 0.05908214f, 0.10302104f, -0.01881502f, 0.01656390f, 
    -0.09918105f, -0.05240814f, 0.12791558f, 0.01565227f, 0.09849056f, 0.17530282f, 0.13778961f, -0.08103351f, 
    0.14898774f, -0.00046388f, -0.05345221f, 0.03714447f, -0.02677180f, -0.09464876f, 0.00854330f, -0.08731847f, 
    0.32547623f, 0.01224347f, 0.22751300f, -0.12640741f, 0.01027143f, 0.19465314f, 0.05499394f, -0.04607162f, 
    0.00602144f, 0.07468963f, 0.01617094f, 0.00429067f, 0.22829026f, 0.02674952f, -0.01177136f, -0.03541939f, 
    0.16372766f, 0.02809304f, -0.02805753f, -0.01028652f, 0.10314445f, -0.11563295f, -0.05608793f, 0.00466738f, 
    -0.12455104f, -0.11061390f, -0.00246482f, 0.19050896f, 0.20595944f, 0.05472146f, 0.05289677f, 0.01998172f, 
    -0.01163475f, -0.02425438f, -0.06631551f, -0.06235445f, -0.26890415f, 0.13201387f, -0.04616092f, -0.09764105f, 
    0.18927780f, 0.01004341f, 0.09870674f, 0.02140508f, 0.11436016f, 0.12439749f, 0.01866350f, 0.05848089f, 
    -0.35330963f, -0.06142789f, -0.02724759f, -0.22851112f, 0.00556560f, -0.05071939f, -0.15300147f, -0.04951689f, 
    0.01674021f, 0.07737152f, 0.03564825f, 0.01016249f, -0.26327392f, -0.07666877f, 0.04503908f, 0.01436062f, 
    0.04822827f, -0.03163883f, 0.00355641f, -0.08229416f, 0.01205188f, 0.06532092f, 0.05501217f, -0.07797386f, 
    -0.04381865f, 0.02432850f, -0.25813979f, 0.17485192f, -0.05452946f, 0.13066565f, -0.00719043f, -0.04774923f, 
    0.04084594f, 0.00348645f, -0.01366412f, -0.04436890f, 0.15782328f, 0.02729185f, 0.03298899f, -0.06714100f, 
    0.03295245f, 0.04165438f, -0.10484997f, -0.00467447f, 0.05584390f, 0.13199955f, 0.08257134f, -0.01666444f, 
    -0.12422599f, 0.05913638f, -0.09694122f, 0.26289159f, 0.03618993f, -0.09835091f, 0.07053337f, 0.03151017f, 
    0.09599601f, 0.07480815f, -0.03172905f, 0.06605177f, -0.13769364f, 0.02576502f, -0.06499112f, -0.09700865f, 
    0.18979567f, 0.02902218f, -0.01029437f, 0.11245743f, 0.10256562f, -0.11773732f, 0.01893507f, 0.09153475f, 
    -0.11896420f, -0.12955861f, -0.01459452f, 0.20618744f, -0.00950867f, 0.05720401f, -0.07786170f, 0.00698399f, 
    0.07214131f, -0.03016112f, 0.03467709f, -0.07127848f, -0.07663748f, 0.18706572f, -0.07925465f, -0.24263728f, 
    -0.01735407f, 0.06746546f, -0.05692936f, 0.00245316f, 0.05869163f, 0.05772061f, -0.01892943f, 0.02213931f, 
    0.12342695f, -0.13221164f, 0.04657896f, 0.28048939f, 0.07013854f, 0.00754418f, -0.03788214f, -0.09838596f, 
    -0.18421975f, -0.04872127f, -0.06992411f, -0.09987703f, 0.17246659f, 0.00334045f, 0.12135651f, 0.37799332f, 
    -0.08520808f, -0.04885668f, -0.04886469f, -0.09915881f, -0.08668347f, 0.03738644f, -0.04900087f, 0.08407712f, 
    -0.29117182f, -0.27491626f, -0.17721695f, 0.02331982f, 0.04592130f, 0.13327388f, 0.10655852f, 0.02873629f, 
    0.04853674f, -0.07109018f, -0.02019108f, -0.03337362f, 0.21578453f, 0.14713512f, 0.25796515f, -0.18716088f, 
    0.05937727f, -0.17136621f, -0.10757517f, 0.09841611f, 0.10540932f, 0.09217678f, 0.06943727f, 0.15691400f, 
    0.25162566f, 0.02161200f, 0.16969080f, 0.00145635f, -0.08575103f, -0.00475643f, -0.05946614f, 0.03849730f, 
    -0.04724568f, 0.13448474f, 0.03379248f, 0.05552285f, 0.13947365f, 0.04611586f, 0.03589322f, 0.01318028f, 
    -0.10349443f, -0.01977990f, -0.05091605f, 0.02070292f, 0.04167559f, 0.04953348f, 0.05317185f, 0.16325091f, 
    0.14903112f, 0.04471754f, 0.22509401f, 0.35785151f, 0.29018360f, 0.13738789f, 0.00789665f, 0.00598646f, 
    0.10503922f, -0.02968483f, -0.08689893f, -0.00344232f, -0.06426816f, 0.13272661f, 0.11928294f, -0.04991476f, 
    0.16606702f, 0.08681994f, 0.04071902f, -0.07500092f, 0.04362660f, 0.09269515f, 0.16312930f, 0.00730183f, 
    -0.24522167f, 0.08893710f, 0.15727113f, -0.08958388f, 0.00810761f, -0.02331610f, -0.13682556f, -0.00568526f, 
    0.11481210f, -0.04027627f, 0.02015614f, -0.12465862f, -0.33129391f, -0.08090869f, -0.04672743f, -0.07761903f, 
    0.00712234f, -0.05716464f, -0.07236126f, -0.04956444f, 0.04579712f, 0.01048704f, 0.14157757f, -0.08794230f, 
    0.09141150f, 0.16389970f, 0.13303968f, 0.30363053f, 0.09138431f, 0.08182194f, -0.06511587f, 0.03640528f, 
    0.06623743f, 0.02140504f, -0.05060852f, -0.08538142f, 0.28679764f, -0.15134497f, -0.12995255f, -0.09746771f, 
    0.07763840f, 0.04292072f, -0.11715414f, 0.01055623f, 0.12314898f, -0.03866255f, 0.17710985f, -0.04878758f, 
    -0.19418091f, 0.17754616f, -0.03875459f, -0.05295049f, 0.10863154f, 0.00443456f, 0.06657334f, -0.00703139f, 
    -0.07876600f, -0.00219004f, -0.04078491f, 0.00062666f, -0.22193520f, 0.00081990f, 0.01406050f, -0.09251790f, 
    0.03188114f, 0.05914647f, -0.11225586f, 0.07056156f, -0.07170376f, -0.05316084f, -0.08724963f, -0.06205678f, 
    0.17650530f, -0.06297930f, -0.03947778f, 0.05869560f, -0.07143688f, -0.00490317f, -0.10737393f, -0.04254458f, 
    -0.08748432f, -0.03318593f, 0.00347469f, -0.03585251f, -0.16827673f, -0.04953498f, -0.08082135f, -0.09035376f, 
    -0.04133951f, 0.06171315f, 0.02373944f, 0.10291001f, 0.01735718f, 0.04719059f, -0.06069400f, -0.03540250f, 
    0.06515295f, 0.03102825f, 0.08589316f, 0.20641039f, 0.15951623f, 0.12519401f, 0.02642917f, -0.04465126f, 
    -0.09242196f, 0.01889025f, 0.10919584f, -0.06083251f, -0.04313847f, 0.08076658f, 0.12646742f, 0.24117778f, 
    0.02494164f, -0.06600789f, -0.05510188f, -0.04882284f, -0.08830070f, 0.14116456f, -0.01679165f, 0.02533297f, 
    -0.26528940f, 0.00397110f, 0.05274921f, 0.04798197f, 0.04183281f, -0.01557895f, 0.00693723f, 0.01749916f, 
    -0.05396871f, -0.04625155f, -0.02691212f, -0.09242473f, 0.17603286f, -0.06557944f, 0.02890459f, 0.02944474f, 
    -0.15458752f, -0.04160253f, -0.01363167f, -0.05350735f, 0.13005292f, 0.01397106f, 0.04217536f, 0.03060470f, 
    0.19788019f, -0.05841341f, -0.04464184f, -0.03096612f, -0.02902182f, 0.07077314f, -0.15041731f, -0.01301285f, 
    -0.02177802f, 0.10330521f, 0.00385311f, -0.02418811f, -0.05828881f, -0.22763649f, 0.07175627f, 0.27308828f, 
    0.01246468f, -0.05676805f, 0.00081718f, -0.12509421f, -0.10885303f, 0.04522712f, 0.01524780f, 0.11569565f, 
    0.18959603f, 0.07936274f, 0.04810797f, 0.15443452f, -0.00158618f, 0.01369620f, -0.14391832f, 0.02317719f, 
    0.03297642f, -0.02965288f, -0.03498303f, 0.11231615f, 0.14902563f, -0.05514901f, 0.08364741f, -0.01729664f, 
    -0.07319543f, -0.08878988f, -0.06026780f, 0.08542836f, -0.00368729f, -0.06085452f, -0.05498493f, 0.04013584f, 
    -0.00411618f, 0.16553985f, 0.01508312f, -0.18883045f, 0.09844530f, 0.04305189f, -0.11375979f, 0.04884392f, 
    0.07750002f, 0.02189635f, 0.07400804f, 0.04731591f, -0.33719608f, -0.02379584f, -0.07413067f, 0.13451448f, 
    -0.03152098f, -0.01753817f, -0.00987604f, -0.02096750f, 0.00509427f, 0.04535177f, 0.05047932f, 0.12212286f, 
    0.05929789f, 0.14294501f, 0.08484362f, 0.29686192f, -0.21389318f, -0.04535924f, 0.18046629f, -0.00566464f, 
    -0.00978875f, -0.02597767f, -0.01651139f, 0.02026267f, -0.37414098f, -0.21310884f, 0.04911384f, -0.12998477f, 
    0.11057343f, 0.15637736f, -0.00457965f, -0.03768604f, 0.06929565f, 0.01959597f, -0.05167462f, -0.00593420f, 
    0.08714449f, 0.09408125f, -0.00625642f, 0.10556895f, -0.01381978f, 0.00817812f, 0.01168743f, -0.02100955f, 
    -0.03740650f, -0.00881885f, -0.03178398f, 0.04269572f, 0.09922221f, -0.07276192f, 0.04426459f, 0.04563639f, 
    0.10298946f, -0.14173070f, -0.07734439f, 0.08265480f, 0.07419176f, -0.04614012f, 0.03830207f, 0.08366956f, 
    -0.02190283f, 0.04889503f, -0.11308733f, -0.23097330f, 0.10339173f, 0.07829352f, 0.02364932f, -0.00788427f, 
    0.12403274f, 0.00241853f, 0.02143871f, 0.02190390f, 0.23264423f, -0.13343297f, 0.04230613f, -0.12689291f, 
    0.01754820f, -0.09714153f, -0.00127858f, 0.06388734f, 0.12703612f, 0.06107327f, -0.02044242f, 0.07655104f, 
    -0.05002088f, 0.09808826f, -0.15753300f, 0.08330411f, -0.09213892f, -0.00635181f, 0.13162270f, 0.06709947f, 
    -0.07351285f, 0.02429699f, -0.02273269f, -0.07171082f, 0.35020310f, 0.11081054f, 0.05461273f, 0.05603132f, 
    -0.08459046f, -0.06469985f, -0.13835916f, 0.02633578f, 0.04926905f, 0.02375312f, 0.07864083f, -0.00547521f, 
    0.03730856f, 0.20838270f, -0.08564591f, 0.14374226f, -0.00551927f, -0.09712171f, -0.01413381f, 0.14762804f, 
    -0.01868534f, 0.06731806f, -0.03841516f, -0.04732390f, -0.31557959f, -0.06451230f, 0.03359208f, -0.13585800f, 
    -0.03866877f, -0.01258511f, 0.01855168f, 0.01298427f, 0.11917018f, 0.10581579f, -0.00270420f, -0.06197621f, 
    0.10383648f, 0.01104603f, 0.22364786f, -0.03565576f, -0.07401436f, 0.06227528f, 0.08633065f, -0.09869167f, 
    -0.06932005f, 0.08236256f, -0.04938622f, 0.11863011f, -0.31813645f, 0.05078315f, -0.16654372f, -0.15267283f, 
    0.10491024f, 0.04286652f, -0.07941651f, -0.06586289f, 0.05661168f, 0.09746284f, -0.06467971f, -0.11021438f, 
    -0.15123792f, 0.11983083f, -0.07570920f, -0.08387399f, -0.04031163f, 0.02399951f, -0.03947961f, 0.00740088f, 
    0.07995991f, 0.00418268f, 0.08687662f, 0.03466648f, 0.09446182f, 0.05026601f, 0.05590743f, -0.08070277f, 
    0.04908014f, 0.04096029f, 0.01102980f, 0.11682338f, 0.06471841f, 0.01396294f, 0.06443165f, 0.06523300f, 
    0.13351057f, -0.22189464f, 0.11111548f, 0.10946045f, -0.06201588f, 0.00024801f, 0.04902314f, -0.01782531f, 
    -0.05953340f, 0.04613038f, 0.08988354f, 0.04285681f, 0.15979613f, 0.02700631f, 0.12488247f, -0.01211393f, 
    -0.01292834f, -0.02827320f, -0.03654370f, 0.06162593f, 0.10499743f, -0.07540195f, -0.05615031f, -0.03434778f, 
    0.12505743f, -0.00267832f, -0.12361663f, -0.09502251f, 0.07104705f, 0.02371552f, 0.07634829f, 0.09196301f, 
    0.09118605f, -0.06909348f, 0.04198086f, 0.09164108f, 0.50352520f, 0.11842269f, -0.07897098f, 0.08229290f, 
    0.08035722f, -0.02078662f, -0.03702312f, 0.04622596f, 0.07436594f, 0.13194396f, 0.02140044f, -0.05275606f, 
    -0.04381971f, -0.01144631f, 0.01004694f, -0.11095349f, -0.02063944f, 0.00604168f, 0.08520980f, 0.01983322f, 
    0.04948913f, 0.01699285f, 0.09395419f, 0.01384059f, -0.01597806f, 0.07558355f, 0.09273774f, -0.01155722f, 
    0.01905234f, 0.04405929f, 0.07401063f, 0.08698387f, 0.06695151f, -0.02756647f, -0.08399455f, 0.08612956f, 
    -0.06937078f, 0.03223555f, 0.01349585f, 0.25597078f, 0.01658081f, -0.01548498f, 0.08400344f, -0.06080845f, 
    -0.02612241f, 0.04629762f, -0.02587790f, 0.02794240f, 0.18088965f, 0.01097685f, -0.07323974f, 0.10679413f, 
    -0.03508305f, 0.14477798f, 0.01572183f, 0.09630820f, 0.05432423f, 0.12478364f, 0.04150292f, -0.06360441f, 
    -0.16391641f, -0.04425045f, -0.07603146f, -0.01586666f, 0.13485849f, 0.02140453f, 0.05894610f, -0.14160202f, 
    0.00777336f, 0.00646861f, 0.00550098f, -0.06962957f, -0.21750063f, -0.07619016f, -0.00676084f, -0.24781549f, 
    -0.04408986f, -0.00605123f, 0.06285458f, -0.02834412f, -0.00640976f, 0.05772458f, 0.14095393f, 0.12459452f, 
    0.31586850f, -0.10149435f, 0.05615114f, -0.01715203f, -0.06855889f, 0.08250754f, 0.07981258f, 0.02253461f, 
    0.02937289f, 0.06435124f, -0.01007547f, 0.07405492f, 0.33579296f, 0.10833868f, 0.03067499f, 0.06019217f, 
    0.07836533f, 0.07557415f, 0.07111841f, -0.03850518f, -0.05325320f, -0.01414009f, -0.08503058f, 0.12791876f, 
    -0.15224844f, 0.09027847f, -0.10285020f, 0.00158040f, 0.04445601f, 0.07937274f, 0.12113442f, 0.13554996f, 
    0.09958706f, 0.01499106f, 0.06915983f, 0.05290510f, 0.28313968f, 0.10590353f, 0.17295848f, 0.12134430f, 
    0.06033923f, -0.04373383f, 0.10535240f, -0.08039231f, 0.12799771f, 0.08817374f, 0.12689081f, 0.02260690f, 
    0.01677080f, -0.00210685f, 0.00670614f, 0.03450486f, -0.04794654f, -0.05192021f, -0.02179012f, -0.04377631f, 
    -0.04280975f, -0.01836193f, -0.03045907f, -0.00729986f, -0.04403989f, 0.00829330f, 0.01898679f, -0.02577015f, 
    -0.00389149f, 0.00874892f, -0.02904428f, -0.05079401f, -0.03233564f, -0.06115789f, -0.06877857f, -0.08090565f, 
    -0.06622911f, 0.05431369f, 0.00298594f, 0.02382058f, 0.05834327f, -0.05777292f, 0.02039014f, 0.05074731f, 
    -0.01309942f, -0.03612164f, 0.00366807f, 0.00742675f, -0.05974052f, -0.02888860f, 0.03313456f, -0.04811088f, 
    0.05827591f, -0.03132025f, 0.04579027f, 0.01022102f, 0.00303134f, -0.05016515f, -0.05159604f, 0.03464639f, 
    -0.01364535f, 0.04303528f, -0.03911408f, 0.01748283f, -0.02620432f, -0.05045339f, -0.07134733f, 0.05927182f, 
    -0.03688597f, -0.04278715f, 0.01084575f, -0.02406732f, 0.04255878f, 0.05317972f, 0.01005422f, -0.02369300f, 
    0.00986473f, -0.02048055f, 0.00539966f, 0.00975250f, -0.06159978f, 0.04351424f, -0.05010082f, -0.02765470f, 
    -0.01952463f, 0.04591896f, -0.05171030f, -0.03091086f, -0.03653642f, 0.04200399f, 0.01716310f, 0.04665365f, 
    0.00754000f, -0.01816558f, 0.02095310f, 0.03010365f, -0.07232481f, 0.03811592f, 0.04291153f, 0.02316685f, 
    0.04037597f, -0.03223672f, -0.04299671f, 0.04874935f, -0.04763706f, -0.06343433f, -0.04323445f, 0.01446480f, 
    -0.03979171f, -0.03259194f, -0.04434732f, -0.00892046f, 0.04534083f, -0.05074033f, 0.04734761f, -0.01199067f, 
    0.04502965f, 0.05877573f, -0.04578189f, -0.06101176f, 0.04347535f, 0.00768482f, -0.04087529f, -0.02346977f, 
    -0.02259449f, -0.04163339f, -0.02270772f, 0.00947911f, -0.02520032f, 0.05015005f, 0.01330941f, -0.00781187f, 
    -0.00811134f, 0.02841905f, 0.03803496f, -0.00336876f, -0.02014717f, 0.02225780f, 0.02204877f, 0.06247466f, 
    0.00764873f, -0.00587297f, 0.04955164f, -0.01552776f, 0.03813199f, -0.07426991f, -0.02677473f, 0.00319688f, 
    0.01243083f, 0.03916077f, -0.00556817f, -0.07160812f, 0.02612219f, -0.03108972f, 0.06213246f, -0.05647930f, 
    -0.03654822f, -0.00295844f, 0.06527706f, 0.03135166f, -0.07155726f, -0.07116749f, -0.05800990f, -0.00101338f, 
    -0.01770508f, 0.02492918f, 0.06173877f, -0.04178854f, -0.06682626f, -0.07507449f, 0.02116284f, -0.04179175f, 
    -0.00358690f, 0.00092038f, 0.06207621f, 0.06102812f, 0.05128399f, -0.00120684f, 0.00119040f, -0.02436874f, 
    -0.03622233f, -0.01176155f, 0.00347013f, -0.05458399f, 0.05474130f, -0.00830693f, -0.03060771f, -0.07966987f, 
    -0.02933877f, -0.06369175f, 0.06080082f, 0.03580664f, 0.02759285f, -0.04012891f, 0.06227916f, -0.03454138f, 
    0.04215713f, -0.01243067f, -0.05120415f, -0.07686881f, -0.04659466f, 0.06184198f, 0.03439797f, -0.02347497f, 
    -0.11693462f, 0.12236129f, 0.01083648f, -0.20945475f, 0.05258693f, 0.02951979f, 0.13510509f, 0.14109010f, 
    0.06524055f, -0.07798342f, 0.03814003f, -0.02498108f, -0.26547626f, -0.11042818f, -0.04727335f, -0.13294201f, 
    0.10763404f, -0.00007017f, 0.01453797f, 0.02218917f, -0.04736994f, 0.05671927f, 0.01471971f, 0.01632006f, 
    -0.16688031f, 0.09377698f, -0.04016979f, 0.10421335f, -0.01619480f, -0.06534112f, -0.02484935f, 0.01347887f, 
    -0.06611785f, -0.00613855f, -0.01918122f, 0.05532488f, 0.29356179f, 0.19839245f, -0.23997937f, -0.20532507f, 
    0.08632875f, -0.00393158f, 0.03732132f, -0.08082038f, 0.00583292f, -0.01602077f, 0.01628658f, -0.03201143f, 
    -0.03774752f, 0.07921825f, -0.05480796f, -0.13668792f, 0.08237524f, 0.01981726f, 0.08750228f, 0.05251178f, 
    -0.01163300f, 0.03889548f, -0.05804780f, -0.15565811f, 0.10720494f, -0.15697898f, -0.22228280f, 0.09872410f, 
    0.02994900f, 0.04687428f, 0.01353107f, 0.08458512f, 0.08198524f, -0.02588320f, 0.05818706f, -0.00319161f, 
    -0.34379846f, -0.06060798f, -0.00265542f, -0.13993655f, 0.02662983f, -0.10904706f, -0.01025691f, 0.04161531f, 
    0.05348691f, -0.01738786f, -0.06222018f, -0.02358306f, -0.10559423f, -0.06817745f, -0.04200166f, 0.22445665f, 
    0.10781828f, 0.05855034f, 0.01916814f, 0.07422250f, 0.02237735f, -0.02211007f, 0.05244276f, 0.15603666f, 
    0.10551509f, 0.39809448f, 0.12688638f, -0.23878554f, -0.02308795f, -0.00743939f, 0.06198270f, -0.05549254f, 
    0.02303747f, 0.07040015f, 0.09513141f, 0.10261831f, -0.11055787f, 0.06751501f, 0.03453026f, 0.02375824f, 
    0.08286046f, 0.08518998f, -0.07283249f, 0.10803317f, 0.10571142f, -0.06541134f, -0.00529898f, -0.08634030f, 
    -0.20192115f, -0.06063299f, -0.09403039f, -0.12863737f, 0.13863431f, 0.06687678f, 0.02879892f, -0.10781020f, 
    -0.04470191f, 0.02330368f, 0.20996045f, -0.02827909f, -0.19756897f, 0.11521545f, 0.16352707f, -0.31336197f, 
    -0.00699280f, 0.05503857f, 0.03114542f, -0.04362155f, -0.02251466f, 0.06801235f, 0.09738297f, -0.04463619f, 
    0.27435365f, 0.02677027f, -0.03532364f, -0.03308353f, -0.07522090f, -0.08436608f, 0.01023591f, -0.02960775f, 
    0.03993472f, -0.02439165f, 0.01876966f, 0.06563686f, 0.19691837f, -0.07149239f, -0.13649410f, 0.18178636f, 
    0.03745225f, 0.00339630f, 0.08940949f, -0.11232582f, 0.05020103f, -0.02808191f, -0.00367510f, 0.04356623f, 
    -0.23588564f, 0.10382191f, -0.16933225f, 0.00038415f, 0.00088591f, -0.04718469f, 0.08913811f, 0.20932080f, 
    0.18052232f, 0.10584407f, -0.02131768f, 0.13024281f, 0.13404833f, -0.07699819f, 0.17713866f, 0.41964406f, 
    0.01238120f, -0.05451664f, 0.05754305f, -0.00089524f, -0.00297219f, 0.08526343f, -0.01595958f, 0.14576404f, 
    -0.25531998f, -0.09483944f, -0.22677144f, 0.22096829f, 0.12091879f, 0.14256540f, 0.00743084f, -0.03213178f, 
    0.20304005f, 0.10155569f, 0.13594449f, 0.06398177f, -0.25875729f, -0.13153256f, -0.21562451f, -0.22676355f, 
    0.05620281f, 0.03146983f, 0.02863336f, 0.16276991f, 0.12249623f, 0.14541799f, 0.10740531f, 0.03007402f, 
    -0.00167527f, -0.12509197f, -0.08290274f, -0.05226804f, 0.03205187f, -0.13497065f, -0.11896870f, -0.11503797f, 
    -0.11050829f, -0.17103893f, 0.05668120f, 0.01786780f, -0.13240404f, -0.09512942f, 0.25549233f, 0.16001150f, 
    -0.01150418f, -0.01212762f, -0.03140805f, 0.09236319f, 0.11849585f, -0.06784021f, -0.04287583f, -0.04899629f, 
    -0.09124928f, -0.21931396f, -0.25884104f, -0.20940019f, 0.00947379f, -0.06139642f, -0.07568728f, 0.04057531f, 
    0.12684110f, -0.04413979f, -0.04918377f, 0.06223750f, -0.02518033f, 0.37747660f, 0.20320992f, 0.09729507f, 
    -0.07283408f, -0.02303514f, 0.02723964f, 0.03172323f, -0.03651468f, 0.11053272f, -0.05872787f, -0.02413394f, 
    -0.01636442f, 0.04209887f, -0.31339410f, 0.14351818f, 0.16822489f, 0.07870544f, 0.11303964f, -0.07072060f, 
    0.02722359f, -0.07088504f, -0.02658311f, 0.05660202f, -0.06844328f, -0.19933608f, -0.22833548f, -0.34551442f, 
    -0.00827582f, 0.07767828f, -0.01458057f, 0.03418646f, -0.03238823f, -0.04424607f, -0.04047228f, 0.17254616f, 
    -0.11524874f, -0.03518896f, 0.12491789f, 0.32566100f, -0.06544444f, -0.03053147f, 0.05055420f, 0.01081032f, 
    -0.08716742f, -0.06282762f, -0.10090470f, -0.03523714f, 0.25750104f, -0.02933197f, -0.04722441f, -0.08388744f, 
    -0.07854047f, 0.15669397f, 0.02956205f, 0.04481900f, -0.09449586f, 0.05560516f, -0.05409611f, -0.11527503f, 
    -0.19042298f, -0.10792910f, -0.03804214f, 0.07071089f, 0.12482183f, 0.05837322f, 0.08467720f, -0.21603732f, 
    0.01846105f, 0.06730273f, -0.04493472f, -0.06846818f, -0.03792879f, -0.17546536f, -0.06437591f, 0.13700600f, 
    0.09337240f, 0.07027791f, 0.02247750f, -0.05699429f, -0.00828495f, 0.12622084f, 0.12096070f, 0.13464621f, 
    -0.23556089f, -0.14702412f, -0.13671513f, -0.19384058f, -0.13490401f, 0.01552105f, 0.03084526f, 0.02118187f, 
    -0.00998808f, 0.00050132f, 0.03585374f, -0.05441801f, 0.14457414f, 0.23703355f, 0.24544263f, 0.07872223f, 
    -0.05892915f, -0.19232157f, -0.06044038f, -0.12080815f, -0.07603080f, -0.04606589f, 0.06141918f, 0.13369142f, 
    -0.05897847f, 0.17368817f, -0.21411955f, 0.12383242f, 0.03555439f, -0.07829195f, 0.13212238f, 0.07264946f, 
    -0.05245006f, -0.00439598f, 0.08109653f, -0.00625281f, 0.24413088f, 0.20615549f, 0.46764755f, 0.09850866f, 
    -0.19633414f, -0.01108335f, 0.06198421f, -0.00472611f, 0.04265418f, -0.10493287f, -0.06620934f, 0.20070419f, 
    0.13787369f, 0.10733190f, 0.30782038f, 0.19414018f, 0.03201717f, 0.02402479f, 0.11342599f, 0.02938146f, 
    0.06317458f, 0.01252064f, 0.02245934f, 0.17452066f, -0.43204278f, 0.26640806f, 0.15374430f, -0.12709397f, 
    0.16830248f, -0.03549298f, 0.18361272f, -0.06012156f, 0.02644560f, 0.05905101f, 0.03258838f, 0.08140315f, 
    -0.31272635f, 0.09774672f, -0.04607992f, 0.06901233f, 0.16169427f, -0.13995241f, -0.01713469f, 0.08088996f, 
    0.04749708f, 0.03683362f, -0.00002180f, 0.03974337f, 0.15405814f, 0.15119551f, -0.04260836f, 0.12649576f, 
    0.10789289f, 0.03807571f, -0.01671211f, 0.09577125f, -0.02972797f, 0.12014826f, 0.03599600f, 0.03085772f, 
    -0.18169428f, 0.10059897f, -0.00445694f, 0.07536237f, -0.01786674f, 0.05724123f, -0.10806040f, -0.03150362f, 
    0.03695635f, 0.09447932f, -0.02071470f, 0.08313269f, -0.02322882f, -0.14166173f, -0.07854786f, 0.01145237f, 
    0.17524146f, -0.08642951f, 0.01224507f, 0.04795155f, 0.12835926f, -0.11936518f, 0.12747282f, -0.05334590f, 
    -0.22266926f, 0.20589246f, 0.02311907f, 0.05127462f, 0.02701650f, 0.00989450f, 0.09026526f, 0.00507721f, 
    -0.05853492f, -0.03610621f, -0.03566466f, 0.05929172f, -0.21481915f, 0.05445478f, 0.06902662f, -0.19763578f, 
    0.10768038f, -0.07817563f, 0.09596608f, -0.04362604f, -0.04773791f, -0.02311284f, -0.03840918f, -0.01638839f, 
    0.27751842f, 0.03271845f, -0.00379861f, 0.08740241f, 0.00532614f, 0.04599978f, -0.00576067f, 0.05923017f, 
    -0.04798548f, 0.08619453f, -0.02251878f, -0.04032138f, -0.16685939f, 0.09540060f, -0.00446903f, -0.11382652f, 
    0.01536367f, 0.07430548f, 0.03290844f, 0.08238675f, -0.08666386f, 0.01582688f, 0.07849652f, 0.05059398f, 
    0.23258615f, 0.07022648f, 0.17619899f, 0.06156162f, 0.07563847f, -0.04208638f, 0.05298807f, -0.09660509f, 
    -0.12248127f, -0.00183812f, 0.09643410f, 0.09776179f, 0.21175228f, 0.02261190f, 0.08626676f, 0.27073342f, 
    -0.08980289f, -0.12872048f, 0.01356879f, 0.10965563f, -0.10250844f, 0.04355923f, 0.04142530f, 0.17254110f, 
    -0.43425152f, 0.12693323f, -0.10786506f, 0.05978612f, -0.01458580f, 0.07194139f, 0.09690925f, -0.14937605f, 
    -0.01401193f, 0.01266949f, -0.01737243f, 0.06990565f, 0.13756625f, -0.16194944f, 0.00186665f, 0.02877617f, 
    0.02376646f, -0.07653752f, 0.06425520f, -0.03959041f, 0.01241160f, 0.05254180f, 0.06001613f, 0.11160282f, 
    0.07737672f, -0.03305948f, -0.00743254f, -0.12165589f, 0.06627063f, -0.02393249f, -0.02915135f, -0.02028250f, 
    -0.00146316f, 0.13471949f, 0.00633906f, 0.06495002f, -0.02336064f, -0.20926067f, 0.03904082f, 0.32112411f, 
    0.01278683f, 0.09655375f, -0.02906337f, 0.17693001f, -0.08124829f, -0.06848467f, -0.06744616f, 0.09146837f, 
    -0.30458951f, -0.06720031f, -0.00527714f, -0.19598538f, -0.03785040f, 0.00115260f, 0.08265945f, -0.04080405f, 
    0.15426657f, 0.08493093f, 0.00817188f, -0.08910384f, -0.34326470f, 0.11785070f, -0.09731660f, -0.05535779f, 
    0.20467573f, -0.00826609f, -0.00933227f, 0.07092767f, 0.12243086f, 0.02009227f, 0.02553645f, 0.09807214f, 
    -0.20677306f, 0.19254564f, -0.14202960f, 0.01432316f, 0.05169674f, 0.04561856f, -0.03897744f, -0.04709866f, 
    0.02841521f, -0.09067254f, -0.04827406f, -0.02856060f, 0.10955367f, 0.16419882f, -0.00471397f, 0.01637645f, 
    0.05961736f, 0.03506330f, 0.13002372f, -0.01727682f, 0.01322080f, -0.03860357f, -0.10385551f, 0.04119258f, 
    0.00113388f, -0.10794083f, -0.22462013f, -0.23934063f, 0.12709834f, -0.00874198f, 0.00681858f, 0.04270774f, 
    0.09446497f, 0.01773593f, -0.05994241f, -0.08088587f, -0.10634580f, 0.26357976f, -0.02187817f, 0.04585695f, 
    0.03046439f, 0.08908872f, 0.00408471f, 0.00259585f, 0.03139887f, 0.12254835f, 0.15492053f, 0.05952434f, 
    -0.11059390f, -0.00374500f, -0.10453221f, 0.10747124f, -0.20009811f, -0.06903803f, -0.02473238f, 0.08471684f, 
    0.15122381f, 0.07220768f, 0.00648944f, -0.02696093f, -0.07652351f, 0.09715113f, -0.09212030f, 0.15922928f, 
    0.17667495f, 0.00464445f, 0.09275901f, 0.15146378f, 0.12757882f, 0.00684269f, 0.00086242f, 0.08258921f, 
    -0.13758019f, 0.05119320f, 0.20973849f, 0.06094890f, 0.00375261f, 0.01455462f, 0.05728867f, 0.06291091f, 
    0.08131770f, 0.06271465f, 0.03234179f, 0.06204023f, -0.25751197f, 0.24815330f, 0.03082357f, 0.08995237f, 
    0.07268674f, -0.02004463f, 0.00114460f, 0.12704624f, -0.05652704f, 0.03110672f, 0.17292629f, -0.08004046f, 
    -0.04184197f, -0.21590690f, 0.14748447f, -0.16514668f, 0.10319184f, 0.05054453f, -0.10688253f, -0.19900300f, 
    -0.03647356f, -0.03499205f, -0.04293387f, 0.01747589f, 0.06323166f, -0.12015174f, 0.06627030f, 0.10579541f, 
    0.10826551f, -0.01925083f, 0.06013434f, -0.02190561f, 0.02627225f, -0.06736440f, 0.07624144f, 0.20820384f, 
    -0.01829853f, -0.10429629f, -0.02913623f, -0.07421175f, 0.04403542f, -0.01059316f, 0.07615189f, -0.06180532f, 
    0.02703840f, 0.00922819f, 0.05417859f, -0.00286151f, 0.11400256f, 0.10326605f, 0.28501266f, 0.03373711f, 
    0.05207000f, 0.04043790f, 0.02602351f, -0.01006239f, 0.02525147f, -0.05052065f, 0.11880060f, 0.14965998f, 
    -0.16269119f, 0.10014941f, 0.07976959f, 0.13877796f, 0.02612194f, -0.02758129f, 0.09731012f, 0.10710242f, 
    0.13016133f, 0.04715123f, -0.01100902f, 0.04277957f, 0.25245175f, 0.04503547f, 0.19716546f, -0.03247039f, 
    -0.11225139f, -0.01565328f, 0.07764217f, 0.15876640f, 0.02077170f, 0.02730090f, -0.03681466f, 0.09624738f, 
    -0.09649184f, -0.05342297f, 0.06569727f, -0.10302818f, -0.03120414f, -0.05006482f, 0.04662278f, 0.05947998f, 
    0.09618691f, 0.00052559f, 0.03244090f, 0.12025975f, 0.32970384f, 0.06558101f, 0.02917779f, 0.07810264f, 
    -0.06016916f, -0.07314033f, 0.01180311f, -0.00141499f, 0.06508257f, 0.01048430f, 0.12739053f, -0.09608652f, 
    0.03772018f, 0.28191322f, -0.02938984f, -0.10909687f, 0.04390941f, -0.03074126f, -0.05297381f, 0.06296609f, 
    -0.02173092f, 0.08038360f, 0.05507206f, 0.03091745f, -0.11331202f, -0.11558997f, -0.14630632f, -0.20717344f, 
    0.14779274f, 0.05579090f, -0.03949254f, -0.04727523f, 0.09855270f, -0.01921938f, -0.03817981f, -0.05941324f, 
    0.25437433f, 0.11958977f, 0.07936046f, 0.08592957f, -0.07187361f, -0.16895278f, 0.06282751f, 0.20074335f, 
    -0.05458168f, 0.10451978f, -0.01966787f, -0.14989188f, 0.10596604f, -0.18215698f, -0.16027719f, 0.02288903f, 
    0.00604688f, 0.04264503f, -0.05443611f, -0.04803608f, 0.05874977f, -0.11794383f, 0.04292134f, 0.03119199f, 
    -0.41941175f, -0.04285906f, -0.00023523f, -0.19272019f, -0.04517896f, -0.16372946f, -0.05805266f, -0.06808166f, 
    -0.00715238f, -0.04040222f, 0.04294041f, 0.16659404f, 0.28602633f, -0.00374060f, -0.06851710f, 0.19781658f, 
    0.02254571f, -0.05798149f, -0.03706169f, 0.12364242f, 0.01618905f, 0.13993669f, -0.18596445f, 0.10999309f, 
    0.16984859f, 0.18093827f, 0.10744671f, -0.28693679f, -0.03660939f, -0.00182709f, 0.07210472f, -0.03446048f, 
    -0.01940331f, 0.08806663f, 0.13433608f, 0.07108817f, 0.01488551f, 0.06850632f, -0.09659643f, 0.02704412f, 
    0.03107119f, -0.07403334f, -0.04788047f, 0.06525478f, 0.13903433f, 0.07324918f, 0.02154863f, 0.00531621f, 
    -0.37076110f, -0.14448065f, 0.11596356f, -0.15563001f, 0.03080686f, 0.04824388f, 0.02051180f, -0.01473493f, 
    -0.05547382f, 0.20289692f, 0.09675325f, -0.02920928f, -0.11471418f, 0.05412443f, -0.02431973f, -0.23175927f, 
    0.06469005f, -0.10136563f, 0.03428147f, 0.11688248f, 0.13895379f, 0.14922664f, -0.01699101f, -0.06978872f, 
    0.11940003f, -0.10157634f, 0.05762458f, 0.09420551f, 0.05595067f, -0.15002874f, -0.01406859f, 0.03770570f, 
    -0.04379561f, 0.08532645f, -0.03188526f, 0.00518951f, 0.03224210f, -0.15074642f, -0.05677310f, 0.11298413f, 
    0.08337993f, 0.12112945f, 0.02929395f, -0.05932042f, 0.08267506f, 0.08923566f, 0.02749091f, 0.04439236f, 
    -0.19584990f, 0.01428762f, 0.02812205f, -0.06622907f, -0.03495061f, -0.06792281f, -0.07220859f, 0.03784615f, 
    -0.00415317f, 0.00500203f, 0.05845189f, 0.14907202f, -0.10634468f, 0.03170995f, 0.07243309f, 0.25753319f, 
    0.16145948f, 0.05620729f, -0.00970480f, -0.10029050f, -0.14624834f, -0.04216601f, 0.03497130f, 0.03267699f, 
    -0.06630761f, -0.15375341f, 0.01870199f, -0.16709878f, 0.13756925f, 0.12420428f, 0.12818985f, 0.09255390f, 
    0.01845727f, -0.00918687f, -0.00556719f, -0.09371509f, -0.02890932f, 0.03246040f, -0.10988624f, 0.14680108f, 
    0.12495282f, 0.09559256f, -0.02555321f, -0.02729754f, 0.02441167f, -0.01636472f, 0.00894944f, -0.06309134f, 
    0.01357284f, 0.35010669f, 0.08705547f, 0.06952909f, -0.06481963f, 0.13527089f, -0.01582003f, 0.08472718f, 
    -0.08552867f, 0.11502464f, -0.08638059f, -0.00608319f, 0.06019714f, -0.15713838f, -0.00213731f, -0.34555694f, 
    -0.03725899f, -0.03159489f, 0.17941637f, -0.18479528f, 0.02675384f, 0.09074847f, -0.02002161f, -0.10139813f, 
    -0.03034362f, 0.09315303f, 0.29181913f, -0.08570975f, 0.12777229f, 0.01890017f, 0.03167459f, 0.16778713f, 
    0.06299049f, 0.06765914f, -0.02008069f, -0.06853217f, 0.29351029f, 0.23091267f, -0.08912051f, 0.17916498f, 
    -0.16975170f, 0.09417622f, -0.01171643f, -0.01947135f, -0.03646377f, 0.01394001f, 0.03074611f, 0.07770833f, 
    -0.21679735f, -0.12680179f, -0.08010364f, 0.01238412f, -0.02210447f, -0.02890221f, -0.03890976f, 0.06737731f, 
    -0.08533005f, 0.02258583f, 0.07621764f, -0.02502526f, 0.06507547f, 0.17180453f, -0.11278883f, 0.30962542f, 
    0.13573340f, 0.11874123f, -0.12181539f, 0.17430516f, 0.06927531f, 0.06529123f, 0.02141365f, -0.01361217f, 
    0.11496606f, 0.17620711f, 0.19327466f, -0.25590959f, -0.05220926f, 0.02747597f, 0.08137139f, -0.07934856f, 
    -0.04858483f, -0.02866204f, 0.10950014f, 0.16784504f, -0.15351644f, 0.09969459f, 0.00046975f, 0.03854163f, 
    0.07716797f, -0.02259850f, -0.01849091f, 0.12061361f, 0.04965502f, -0.06581522f, 0.07606048f, 0.12931156f, 
    -0.07550976f, -0.01556139f, -0.01983964f, -0.10015190f, 0.02309038f, 0.10007252f, -0.01056874f, 0.12836154f, 
    0.04437307f, 0.15525678f, 0.09703732f, -0.02211503f, -0.51880741f, -0.15990926f, 0.12760550f, -0.15052886f, 
    -0.00390860f, 0.06923397f, 0.04648463f, -0.04079018f, 0.12730576f, -0.02820087f, 0.01957839f, -0.05723607f, 
    0.31747040f, -0.08075116f, 0.19431320f, -0.21913695f, 0.10764880f, 0.00117289f, -0.02853700f, 0.03510787f, 
    0.05440429f, 0.03752645f, 0.04575171f, -0.02694283f, 0.33305350f, 0.19326589f, -0.07794561f, 0.24302585f, 
    0.02947458f, 0.09368966f, 0.09666475f, 0.03807786f, 0.11648764f, -0.03755032f, -0.08413731f, -0.02022672f, 
    -0.05593745f, -0.23366643f, -0.15579392f, 0.14509016f, -0.07302982f, -0.04828495f, -0.09166985f, 0.05629719f, 
    0.17838329f, 0.08124975f, -0.00582897f, -0.09839255f, 0.15281643f, 0.16948718f, 0.07572835f, 0.18135785f, 
    -0.11085764f, -0.08176497f, 0.09282660f, -0.02660010f, -0.01388009f, 0.11654466f, 0.09265237f, 0.02583472f, 
    -0.14610183f, 0.04952931f, -0.22393157f, -0.08809500f, -0.18155596f, 0.04159506f, 0.02166876f, 0.04958924f, 
    0.01025280f, 0.01060602f, -0.01441552f, -0.03902021f, 0.25429061f, 0.06241387f, 0.10640740f, 0.00032454f, 
    0.01511511f, -0.03022896f, 0.10526861f, 0.19958922f, -0.02197898f, -0.06922060f, 0.05289548f, -0.01851264f, 
    0.03557349f, -0.16623770f, -0.09273334f, -0.02111891f, 0.00832635f, 0.05895482f, 0.13175930f, -0.01279022f, 
    -0.02015782f, 0.08299021f, 0.21656394f, 0.08238124f, 0.14339007f, -0.28410679f, -0.12623133f, 0.13372765f, 
    0.21965413f, 0.01861964f, 0.04849507f, -0.16367760f, 0.02621281f, 0.03507713f, -0.08027399f, 0.11510305f, 
    -0.04422780f, -0.02992525f, -0.07880443f, 0.03067968f, 0.03523024f, -0.06044408f, 0.10636456f, -0.06688399f, 
    0.15101837f, -0.05573212f, 0.11473662f, -0.02570029f, 0.23467518f, 0.11731005f, 0.07470418f, 0.00338811f, 
    -0.06813695f, -0.19522937f, -0.06200969f, -0.03031015f, 0.18746312f, 0.04687077f, -0.08221811f, 0.05779012f, 
    -0.26869106f, 0.09334465f, 0.01902389f, -0.12324403f, -0.07070399f, 0.03157875f, -0.00217404f, -0.13447550f, 
    0.04071287f, -0.01583871f, 0.16335252f, 0.05001038f, 0.10163653f, 0.10415108f, -0.02043386f, -0.00254997f, 
    0.04257863f, 0.00664591f, 0.08032569f, 0.22465906f, -0.00008771f, -0.04029557f, -0.05358651f, 0.08853310f, 
    0.00486209f, 0.08756342f, -0.17925961f, 0.14224221f, 0.04230231f, 0.12788156f, -0.01854132f, -0.11124820f, 
    0.05703728f, 0.01109589f, 0.08536410f, 0.10455248f, 0.23792179f, -0.08016018f, -0.15391998f, -0.06025746f, 
    -0.11886363f, -0.00430361f, -0.09094311f, 0.02357895f, 0.18893728f, 0.16954204f, 0.05370763f, 0.16475865f, 
    -0.20659906f, -0.21875747f, -0.11877291f, 0.05206464f, -0.05840993f, 0.09817654f, 0.10196114f, -0.08581942f, 
    0.03081239f, 0.11627344f, 0.06575557f, -0.03483456f, -0.09551133f, 0.01865417f, -0.09141051f, -0.09227145f, 
    0.01992887f, 0.09983372f, 0.15001652f, 0.07825042f, -0.01778379f, 0.00454890f, 0.11663523f, 0.01542660f, 
    0.15188935f, -0.23443890f, -0.18136625f, 0.09544415f, 0.04664309f, 0.04624856f, 0.02539113f, 0.06319665f, 
    -0.09485291f, 0.03343954f, -0.05081889f, 0.04878830f, 0.10510916f, -0.05653484f, 0.04227925f, 0.00831885f, 
    0.02765705f, 0.09507694f, -0.16334382f, -0.06749593f, 0.16617066f, -0.01296053f, -0.01795731f, -0.03902170f, 
    -0.11797485f, 0.11359452f, 0.02335767f, -0.07135791f, -0.00272607f, 0.02851937f, 0.16425134f, 0.06637500f, 
    -0.03339482f, -0.05365565f, 0.09649099f, 0.09097096f, 0.30979303f, 0.07544789f, 0.11742675f, -0.01410256f, 
    0.04269073f, -0.08211805f, 0.08793448f, -0.04348055f, 0.07116394f, 0.16268772f, 0.11350913f, -0.01663800f, 
    -0.00510074f, -0.15083978f, -0.18147512f, -0.14360069f, -0.08133428f, -0.06261168f, -0.19535525f, -0.02204357f, 
    -0.00375166f, 0.03727761f, -0.01969874f, 0.08929065f, 0.38563734f, -0.13553728f, -0.18709527f, 0.17915580f, 
    -0.14523946f, 0.07220879f, 0.00344156f, 0.07761782f, 0.11864494f, -0.07859866f, -0.06569596f, -0.00470068f, 
    0.35552147f, -0.02547776f, -0.07770514f, 0.09580866f, 0.01265156f, 0.13969880f, 0.18331631f, 0.07815134f, 
    -0.00039196f, 0.22308098f, 0.01546913f, 0.01090762f, 0.23767501f, -0.01652079f, 0.21007779f, -0.00584565f, 
    0.05151191f, 0.10970953f, -0.01634463f, 0.06584028f, -0.10092247f, -0.05694811f, 0.00022390f, 0.03518854f, 
    -0.13667318f, -0.21105422f, 0.00860417f, 0.02128945f, 0.05166539f, -0.14317156f, 0.11711695f, 0.10883933f, 
    0.03632523f, -0.03465319f, 0.11115409f, 0.10678507f, -0.09030199f, 0.22984236f, 0.14000794f, -0.02934073f, 
    -0.06706116f, 0.15602528f, 0.13086931f, -0.02911328f, -0.12155144f, 0.03611677f, -0.14019302f, 0.00709532f, 
    0.13222280f, -0.08642402f, -0.03477069f, 0.04620914f, 0.03380902f, -0.02565559f, 0.00351580f, 0.11620502f, 
    0.11801970f, 0.15696450f, 0.21660669f, 0.08992418f, 0.23793292f, 0.03400545f, -0.03068619f, 0.09850773f, 
    -0.07992788f, 0.09088702f, 0.01039798f, 0.02354297f, 0.09446190f, 0.08709759f, 0.00627132f, 0.00798732f, 
    0.04600144f, -0.11608581f, 0.07031274f, -0.01984688f, 0.07795980f, 0.10456242f, 0.04449143f, -0.07351957f, 
    -0.05876916f, 0.03018422f, 0.12029506f, 0.03287110f, 0.16622621f, -0.11987139f, 0.02349220f, 0.04278187f, 
    0.01860387f, 0.05658252f, -0.03885449f, 0.04647068f, 0.12979296f, 0.16253732f, 0.01620600f, 0.16989118f, 
    -0.19434573f, 0.04239383f, -0.01107072f, 0.02805863f, -0.13831098f, -0.01853721f, 0.11859313f, 0.09083806f, 
    0.18373206f, 0.04722523f, -0.09186474f, 0.03507996f, -0.22084817f, 0.03520696f, -0.00717366f, -0.20687017f, 
    0.10578015f, 0.10502123f, 0.06754141f, -0.01163862f, 0.02255738f, 0.03536220f, 0.09053979f, -0.04577809f, 
    0.14666007f, -0.06241225f, 0.10151909f, -0.10561652f, 0.07034793f, -0.11625102f, -0.09267747f, 0.07860385f, 
    -0.01479646f, 0.04575439f, 0.08646085f, 0.02353392f, -0.08313338f, 0.18930535f, 0.02693012f, 0.05151056f, 
    0.05715403f, 0.11311542f, -0.02351360f, 0.06055502f, -0.00009147f, -0.02059044f, -0.13134140f, -0.14078659f, 
    0.04331204f, -0.00967379f, 0.00188287f, 0.06839499f, -0.07546865f, 0.10593254f, 0.00182829f, 0.08841783f, 
    0.00362970f, -0.13134618f, -0.05237155f, -0.09260282f, 0.01695417f, 0.28688508f, -0.02049417f, -0.12266614f, 
    0.10136069f, 0.09115136f, -0.01410924f, -0.02823824f, 0.09203294f, 0.04183580f, 0.13001426f, -0.06700712f, 
    0.26232377f, 0.16579349f, 0.12496389f, 0.22136348f, -0.09464476f, -0.10458003f, -0.04690299f, -0.03418041f, 
    -0.06355035f, 0.03380578f, -0.03515330f, -0.10230554f, 0.35469732f, -0.09323480f, 0.13228607f, 0.06610209f, 
    -0.13149084f, -0.10222399f, -0.04651391f, 0.05766798f, -0.06163821f, -0.15097830f, -0.06458254f, -0.01510060f, 
    0.10552344f, -0.14844014f, -0.05666644f, -0.21669210f, -0.12876068f, 0.07682838f, 0.13337736f, 0.02411284f, 
    -0.00860805f, -0.01150156f, -0.00013565f, 0.01546736f, 0.28785330f, -0.08448306f, -0.06240647f, 0.23492043f, 
    -0.16506614f, -0.06203784f, 0.03508387f, -0.01905413f, -0.14269848f, -0.06553413f, 0.00108247f, 0.18071987f, 
    0.11247902f, -0.00200224f, 0.09669569f, -0.01560730f, 0.00239785f, 0.01674097f, 0.08932956f, 0.09648556f, 
    -0.00995249f, -0.03891541f, 0.01450566f, 0.00165484f, -0.05713905f, 0.07435612f, -0.09691065f, -0.11461009f, 
    -0.09827587f, -0.08242641f, -0.06908520f, 0.01451562f, -0.04529516f, 0.08209322f, -0.03944479f, 0.01489989f, 
    0.20121267f, 0.07460712f, 0.03455579f, 0.06156093f, -0.04908007f, 0.01733042f, -0.16280369f, -0.07503521f, 
    0.03669142f, 0.07506822f, 0.07197595f, -0.13154641f, 0.08275551f, -0.02818066f, -0.04952877f, -0.06493039f, 
    0.03673877f, 0.08122472f, -0.03865501f, 0.06799151f, -0.06893829f, -0.04024219f, 0.12463667f, -0.14205116f, 
    -0.10988861f, 0.19346040f, -0.04582632f, -0.09870290f, 0.04174699f, -0.00325733f, -0.04097338f, 0.02427859f, 
    0.00372867f, 0.01774053f, 0.01593639f, 0.11946677f, 0.27380207f, -0.08345322f, 0.06119809f, 0.04176626f, 
    -0.12627506f, -0.09197389f, -0.08867999f, 0.14542302f, 0.11395308f, -0.03733826f, 0.01341484f, 0.06917999f, 
    0.14974490f, 0.18218812f, -0.28516266f, 0.10001175f, -0.03573783f, 0.04989210f, 0.02540502f, 0.11249223f, 
    0.14324178f, 0.00325683f, -0.18587460f, -0.15537758f, 0.24260175f, 0.05301737f, 0.00950222f, 0.05815919f, 
    -0.05167085f, -0.03302065f, -0.09340671f, 0.06156266f, 0.12938221f, -0.09648836f, -0.02878184f, -0.02988038f, 
    0.42570367f, 0.30490360f, -0.04139611f, -0.02173555f, 0.06519689f, 0.02798439f, 0.06395517f, 0.14309578f, 
    -0.12859197f, 0.08639424f, -0.02545649f, 0.06696848f, -0.18067889f, -0.05149662f, -0.07152535f, 0.07938175f, 
    -0.06637191f, -0.10385521f, 0.04541123f, -0.19818476f, 0.03575729f, 0.04606576f, 0.00804366f, -0.11432631f, 
    0.14461423f, 0.14100386f, 0.03285183f, 0.21028936f, 0.02731407f, 0.14852984f, 0.08499441f, -0.00915495f, 
    -0.10382133f, -0.04784502f, -0.00380903f, 0.05228817f, 0.03014474f, -0.12586127f, 0.03055482f, -0.08210064f, 
    -0.15634906f, -0.18255004f, -0.12485247f, -0.14970423f, 0.08534786f, 0.21646141f, 0.09206328f, -0.16511227f, 
    0.00676545f, -0.01650383f, -0.06955531f, 0.02500325f, -0.04987408f, -0.03393399f, 0.04043338f, -0.07458155f, 
    -0.00991001f, -0.06617647f, 0.04577251f, -0.02762909f, -0.05716205f, 0.04454602f, -0.03381338f, -0.05339979f, 
    -0.07235094f, -0.01494078f, 0.03410039f, 0.05660834f, -0.04242362f, -0.01733941f, -0.08123204f, -0.02630773f, 
    -0.07770361f, 0.01264360f, -0.05116148f, 0.01013175f, -0.05134041f, -0.01116537f, 0.00979245f, 0.01914473f, 
    0.04138277f, -0.00867301f, -0.01867923f, -0.04002810f, -0.03516847f, -0.04345231f, -0.08573728f, 0.04841457f, 
    -0.01236149f, 0.03471117f, -0.02719280f, 0.06084286f, -0.07338600f, 0.02719892f, -0.06434648f, 0.01771525f, 
    -0.08175275f, -0.00247598f, -0.05474663f, 0.05972544f, 0.02661126f, -0.05472470f, -0.04167419f, 0.04300075f, 
    0.00289618f, -0.04150724f, 0.00443837f, 0.04838536f, 0.02160482f, 0.01932897f, 0.01897326f, -0.00821612f, 
    -0.07944938f, -0.07281546f, 0.04361899f, -0.04040387f, 0.01889584f, -0.05808751f, -0.06679524f, 0.00243679f, 
    -0.06660087f, -0.00965597f, -0.06175822f, 0.02984483f, -0.01225510f, 0.05186423f, -0.06172932f, 0.00938982f, 
    0.05201428f, 0.04330643f, -0.07013829f, -0.00826740f, 0.04434189f, -0.03972970f, 0.06400171f, -0.00038205f, 
    -0.07268684f, -0.04455451f, 0.05853513f, 0.03794425f, 0.00689769f, -0.02410484f, 0.04101847f, -0.00527116f, 
    -0.07306346f, 0.01486381f, 0.01360225f, 0.02454866f, -0.06074866f, -0.03513425f, 0.05053411f, -0.05734001f, 
    -0.04832450f, -0.00708724f, -0.01493891f, -0.01528457f, -0.05243647f, -0.02489491f, -0.04014776f, 0.05296446f, 
    -0.03537489f, 0.02991193f, -0.07854870f, 0.02547544f, -0.04124255f, -0.00819425f, 0.05167370f, 0.05897646f, 
    -0.00508989f, 0.05312439f, 0.04220043f, -0.07179470f, -0.03570861f, 0.03859465f, -0.06699671f, 0.04697968f, 
    0.04757132f, 0.03403469f, 0.01581412f, -0.01549721f, -0.05380022f, -0.04881949f, -0.05281660f, -0.04504307f, 
    -0.02640433f, -0.02663990f, -0.02569263f, -0.07399314f, -0.00520102f, -0.04019304f, -0.05829863f, 0.02766060f, 
    0.00712316f, -0.06491788f, -0.02204093f, -0.01546898f, 0.02767915f, 0.04494390f, -0.07701553f, 0.05904653f, 
    -0.01890366f, -0.06089305f, 0.01277172f, 0.05872906f, -0.05226459f, 0.05211543f, -0.02053347f, 0.01326265f, 
    0.02696667f, -0.07249784f, -0.02798417f, -0.00641844f, -0.06999625f, -0.00980207f, -0.01284437f, -0.01839137f, 
    -0.04422300f, 0.03439925f, 0.01578227f, 0.03432759f, 0.05703821f, -0.02016961f, -0.02962327f, -0.08040224f, 
    0.01662645f, 0.00189450f, -0.05406779f, 0.05246615f, -0.02941562f, 0.05991159f, -0.04637011f, -0.05179392f, 
    -0.08050381f, -0.03614625f, -0.03274899f, -0.01762656f, -0.06740718f, 0.03347189f, 0.03424683f, 0.04129222f, 
    0.23050599f, -0.06263167f, 0.11955595f, 0.26170486f, 0.10358513f, 0.00889347f, 0.08904950f, 0.12769969f, 
    0.02103078f, -0.02410896f, -0.01591019f, 0.04620718f, -0.13949731f, -0.10225409f, -0.06002803f, 0.04019878f, 
    -0.01253247f, 0.00530596f, -0.03926479f, 0.02207492f, -0.03696489f, -0.06212263f, 0.04746751f, 0.00618803f, 
    -0.12087424f, 0.37154821f, -0.05727366f, -0.03035259f, 0.15291332f, 0.07835050f, 0.04826015f, -0.04406794f, 
    -0.00300877f, -0.03083596f, 0.01303633f, -0.00667298f, -0.19662659f, 0.05756358f, 0.13729773f, 0.00576888f, 
    -0.10076341f, -0.04510378f, 0.10430079f, -0.03751110f, -0.17221434f, 0.12983859f, -0.03026231f, 0.00678502f, 
    -0.07269914f, -0.03164018f, 0.23193218f, 0.06327057f, -0.00203113f, 0.06147832f, 0.07395788f, 0.18261206f, 
    0.01425767f, 0.16491352f, 0.00428489f, -0.00674662f, -0.48262319f, -0.17168519f, -0.09558166f, -0.02724998f, 
    0.01270607f, 0.00377246f, 0.01969855f, -0.10987411f, -0.07248892f, -0.05165803f, -0.05659714f, 0.06440177f, 
    0.20867060f, 0.03836259f, 0.16811901f, 0.05575380f, 0.10494529f, 0.04618905f, -0.01961598f, 0.07051128f, 
    -0.09603333f, -0.04843083f, -0.13641478f, -0.02405212f, -0.04861017f, 0.00791714f, -0.06750013f, -0.05162081f, 
    0.01485491f, 0.10136789f, -0.18677916f, -0.01372505f, -0.03954388f, 0.05672872f, 0.14424123f, -0.14542432f, 
    0.04844380f, 0.01523112f, 0.19912216f, -0.20937271f, -0.03485975f, -0.10895620f, -0.00285857f, 0.01440796f, 
    -0.02782978f, -0.09491087f, 0.03615744f, 0.03026081f, -0.12845345f, 0.00367122f, -0.00312402f, 0.00271706f, 
    0.12713163f, 0.08461244f, -0.04483150f, 0.07404601f, -0.13514867f, -0.05507106f, 0.01352578f, -0.02164170f, 
    0.05053493f, 0.14361967f, 0.03565883f, -0.01572670f, 0.00338738f, -0.08899438f, 0.07866441f, 0.28387472f, 
    0.04414190f, 0.04511473f, -0.02722185f, 0.10048958f, 0.13766663f, 0.11668517f, 0.08918505f, 0.23128517f, 
    0.10110049f, 0.07454080f, -0.05072055f, 0.11702738f, 0.11522987f, 0.02145234f, 0.05488826f, -0.06167357f, 
    -0.33911133f, 0.27245972f, 0.04975013f, -0.00540578f, 0.08665918f, 0.05446868f, 0.05110582f, 0.06339955f, 
    0.08519068f, -0.04314100f, 0.02860929f, 0.06046664f, -0.22596288f, -0.02590436f, 0.05042007f, -0.01616923f, 
    -0.16772863f, -0.05583291f, 0.01377940f, 0.09101731f, 0.03422654f, 0.00894801f, 0.02875890f, -0.10279971f, 
    0.04255782f, -0.13274714f, 0.14543405f, 0.09992098f, -0.06027509f, 0.01148211f, -0.09460179f, -0.16280310f, 
    -0.01541120f, 0.04299458f, 0.06448369f, -0.01906653f, -0.27585322f, 0.08425214f, -0.03287582f, -0.15822616f, 
    -0.08353882f, -0.06056350f, -0.14069979f, 0.02147677f, -0.01915837f, -0.00759753f, -0.06500261f, 0.01321235f, 
    -0.18475980f, -0.00414547f, -0.13456213f, -0.13383269f, -0.24456510f, 0.00358986f, -0.14213112f, -0.08474894f, 
    -0.07564534f, 0.07561190f, 0.02106917f, 0.00395211f, -0.05256403f, -0.02401497f, 0.05332987f, -0.11784158f, 
    -0.05157979f, -0.08231056f, 0.06489666f, 0.00139406f, 0.14652382f, 0.02344032f, -0.07101761f, 0.03583861f, 
    0.25980484f, -0.03560869f, 0.01135514f, -0.14000994f, -0.01068457f, 0.10295407f, 0.14655809f, 0.09015316f, 
    -0.00853686f, 0.06176417f, 0.12309597f, 0.13852429f, 0.06522201f, 0.04259359f, 0.17986715f, 0.07152318f, 
    -0.05121880f, 0.01191464f, -0.03523030f, -0.13682123f, 0.06362547f, -0.09159491f, 0.00314460f, 0.06619791f, 
    -0.13932516f, -0.10604978f, -0.21431302f, 0.02008270f, -0.07714397f, -0.03717544f, 0.03223227f, -0.10360184f, 
    0.04396217f, -0.07818144f, 0.06465983f, 0.04021460f, 0.28119737f, 0.02172191f, 0.27536198f, -0.00976990f, 
    0.15267801f, -0.00039771f, -0.06578863f, -0.14786053f, 0.05557647f, 0.08256653f, -0.03796018f, 0.05328768f, 
    0.09916744f, -0.00494712f, -0.04764837f, -0.00449927f, -0.10901823f, 0.13304582f, 0.05236065f, 0.03282337f, 
    0.08040746f, 0.19052553f, 0.19113515f, 0.00863670f, -0.07184976f, 0.09406156f, 0.06571704f, -0.00773719f, 
    0.04209202f, -0.03886709f, 0.07054899f, 0.18482502f, 0.11085214f, 0.06148843f, 0.07477583f, -0.07281374f, 
    0.00739382f, -0.04585351f, -0.04879516f, 0.21024275f, 0.22456099f, 0.15978801f, 0.05500211f, -0.11150905f, 
    0.15955925f, 0.13994730f, 0.05419816f, 0.15358573f, -0.01130946f, -0.15670066f, 0.05841420f, -0.08972088f, 
    0.08182631f, 0.01986743f, 0.02543980f, -0.07131654f, 0.08983288f, 0.09415231f, 0.04168733f, 0.28364351f, 
    0.13033952f, -0.17370582f, -0.07867232f, 0.04308220f, -0.19732860f, -0.02018340f, 0.12578386f, 0.00986195f, 
    0.06927565f, 0.03504032f, -0.19422318f, 0.01397115f, 0.00388218f, 0.05980858f, -0.06259429f, 0.03031529f, 
    -0.04103639f, -0.02843873f, 0.02918236f, 0.04729824f, 0.08239643f, -0.15664746f, -0.09606992f, 0.03688472f, 
    0.07319731f, -0.19546063f, -0.01340912f, 0.04913488f, -0.00817907f, 0.12331317f, 0.08498722f, 0.11099491f, 
    -0.05036452f, 0.09410369f, 0.02600925f, 0.09751663f, 0.06501892f, 0.04786148f, 0.07896087f, 0.00023108f, 
    0.11132378f, -0.01283261f, -0.06694275f, -0.05244426f, -0.00489266f, 0.03782849f, 0.00736576f, -0.04944558f, 
    0.17755885f, -0.06898113f, 0.19185789f, 0.04956820f, -0.06582326f, 0.19699657f, 0.12856159f, -0.03367065f, 
    0.05378531f, 0.00621499f, -0.00498452f, -0.00628147f, 0.27433574f, 0.09406585f, -0.05238020f, -0.18870424f, 
    0.10258003f, 0.10110933f, 0.10894555f, -0.00857200f, 0.17656243f, 0.09099399f, 0.13075010f, -0.06093581f, 
    -0.03645417f, -0.10015482f, 0.04777082f, -0.05826677f, -0.05182476f, -0.05252684f, -0.18325251f, -0.11831393f, 
    -0.02301040f, -0.00969994f, 0.03152785f, 0.16126035f, 0.09449301f, -0.13640952f, 0.03593194f, -0.09282019f, 
    -0.04366027f, -0.01856836f, -0.02478828f, 0.05349263f, 0.05080375f, 0.04468961f, -0.07142448f, -0.06762873f, 
    0.32040200f, 0.03805736f, -0.07172561f, -0.09925903f, 0.10051292f, 0.01189632f, -0.06017337f, -0.00098405f, 
    0.09876457f, 0.01437007f, -0.02721353f, 0.11449039f, -0.04858870f, 0.30226412f, 0.14305022f, 0.30027297f, 
    -0.03770042f, -0.05566670f, -0.03100921f, 0.12939136f, 0.05178934f, 0.00612731f, -0.04084844f, 0.12655786f, 
    -0.07245431f, -0.03192147f, -0.20118967f, 0.00217225f, -0.15729468f, -0.00082046f, -0.00919962f, 0.05428547f, 
    -0.06776687f, -0.01267338f, -0.01916045f, 0.02989052f, -0.30350187f, 0.02351709f, 0.31324494f, -0.00027385f, 
    0.22192268f, 0.06783511f, -0.01579450f, -0.14160402f, 0.01133298f, 0.01620485f, 0.02439006f, 0.06539729f, 
    0.32435679f, 0.01698510f, 0.07317430f, 0.19103731f, 0.09012505f, 0.05375354f, -0.05181447f, 0.02508323f, 
    0.16459942f, 0.19672947f, 0.10544699f, 0.08262209f, 0.11833845f, -0.24645680f, 0.05010996f, -0.13697211f, 
    0.04511460f, -0.10686075f, 0.15534130f, -0.00882208f, -0.05316683f, -0.01529233f, 0.14393009f, 0.02648820f, 
    -0.01854897f, -0.13932684f, -0.01491039f, 0.04838344f, 0.26415581f, 0.03085271f, 0.03745080f, 0.00710095f, 
    0.14714217f, 0.05785628f, 0.00352705f, 0.04844790f, 0.10909128f, -0.06480528f, 0.05722419f, -0.07585382f, 
    0.02830110f, -0.16267605f, -0.03762684f, -0.01782509f, 0.02742232f, 0.08773729f, 0.01116690f, 0.05487976f, 
    0.13879642f, 0.02900649f, -0.10301078f, -0.02869539f, -0.17785770f, -0.04419317f, 0.06654339f, 0.05558628f, 
    0.08172812f, -0.08299199f, -0.25433734f, 0.06046314f, 0.34721199f, 0.14252868f, -0.00599679f, 0.17120528f, 
    -0.07239141f, -0.05668647f, -0.10704976f, 0.03405397f, 0.02162855f, -0.10873653f, -0.10806072f, 0.08208430f, 
    -0.16243100f, 0.07521471f, -0.16152482f, 0.12267695f, 0.03475196f, -0.03822954f, 0.12612958f, 0.20689273f, 
    0.06855015f, -0.05132206f, 0.00774013f, -0.00414575f, -0.34155124f, 0.01622040f, 0.15626727f, -0.00884659f, 
    0.10962448f, 0.00253369f, -0.05310131f, 0.14052117f, -0.01242866f, -0.00997094f, 0.03057466f, -0.00322088f, 
    0.30854401f, 0.07114492f, 0.34994283f, 0.12574631f, 0.07943324f, 0.09564528f, 0.02149361f, -0.00375626f, 
    -0.10727593f, 0.07410367f, 0.07991052f, 0.04362385f, -0.14386909f, 0.23174565f, -0.28598249f, -0.41796654f, 
    0.12504150f, 0.03851517f, -0.03804604f, -0.08861415f, 0.05443421f, -0.16268018f, 0.06914315f, -0.09401973f, 
    -0.00998094f, -0.01747421f, -0.06267767f, -0.05332205f, 0.06541847f, 0.01444602f, -0.00872692f, 0.00402476f, 
    0.00672862f, -0.07352789f, -0.08032649f, 0.02981556f, -0.07668317f, -0.07720920f, 0.00063288f, 0.05553157f, 
    -0.06316157f, 0.00019711f, -0.08141406f, 0.03537289f, 0.05256221f, -0.00099292f, -0.01711482f, -0.07383905f, 
    0.05049985f, 0.00624366f, 0.05779291f, -0.07325168f, -0.08244514f, -0.04161246f, -0.07053773f, -0.07865050f, 
    -0.04249635f, -0.08076989f, 0.01512196f, -0.00658187f, -0.06274725f, -0.00722984f, 0.02701736f, 0.05758917f, 
    0.05670687f, 0.05242998f, 0.00225490f, -0.03645679f, 0.03217158f, 0.01120066f, -0.04122946f, -0.05945389f, 
    -0.04240398f, 0.04690073f, -0.02928712f, -0.07196820f, 0.06483766f, -0.06558239f, -0.04119572f, 0.03934507f, 
    -0.00068610f, 0.02050858f, 0.00518186f, 0.00718514f, -0.01439322f, 0.00190816f, -0.02796415f, -0.01782092f, 
    -0.04746568f, 0.04095898f, -0.03680481f, -0.00712442f, 0.05528816f, -0.02087505f, -0.06748505f, -0.04818111f, 
    0.00785802f, 0.03027294f, -0.00241579f, 0.03396533f, -0.03012199f, -0.01276299f, 0.02498247f, -0.02915449f, 
    0.00790773f, -0.05646094f, -0.07470813f, 0.03616020f, 0.05629386f, 0.04002492f, 0.03482803f, 0.05875817f, 
    -0.02547575f, 0.04799693f, 0.05503374f, 0.06189219f, 0.05754347f, -0.05710879f, -0.06077196f, -0.07984994f, 
    -0.07237557f, -0.02941759f, -0.01962964f, 0.01808989f, -0.05938304f, 0.02891682f, 0.05592253f, -0.06570552f, 
    -0.02871513f, -0.06986509f, -0.07452367f, 0.01295727f, -0.05718732f, -0.00895067f, -0.07134151f, -0.00851039f, 
    -0.06442096f, -0.01513004f, -0.00827867f, -0.05991108f, 0.01687494f, -0.07517523f, 0.04031343f, 0.01653559f, 
    -0.07902363f, -0.04138926f, 0.01014407f, 0.01041865f, 0.06405152f, -0.07003482f, 0.01141206f, 0.03427777f, 
    0.02943556f, 0.04187090f, 0.04709958f, -0.00266503f, 0.02166343f, -0.04919741f, -0.06184555f, -0.02823695f, 
    -0.02122230f, 0.03486237f, -0.06977053f, -0.05460510f, -0.03813609f, -0.00634572f, 0.01286388f, -0.01225609f, 
    0.00762566f, 0.03725793f, -0.04805169f, 0.04153929f, -0.03273307f, -0.05263989f, -0.05475070f, 0.03525610f, 
    -0.08264743f, 0.03414421f, 0.00711786f, -0.03359143f, 0.05942044f, -0.04008272f, -0.07160110f, -0.01560616f, 
    -0.03038722f, 0.04309051f, -0.02169876f, 0.01269073f, 0.05466960f, -0.02024569f, -0.02541167f, -0.02766301f, 
    -0.02831958f, -0.00851674f, 0.03124878f, -0.02468290f, -0.00708143f, 0.01274300f, -0.07818002f, -0.02762819f, 
    0.00668703f, 0.03555148f, -0.00323831f, -0.00278367f, 0.05166982f, -0.05313228f, -0.05190241f, 0.05963996f, 
    -0.02652562f, 0.03621319f, -0.01530137f, 0.01517579f, 0.03540036f, 0.00398748f, -0.03691563f, 0.06164510f, 
    0.04120130f, 0.04448178f, -0.04414383f, -0.02883438f, -0.03034899f, 0.00911696f, -0.07943481f, 0.05061243f, 
    0.10561624f, 0.00025605f, 0.03245089f, 0.04584866f, 0.47209847f, 0.01638684f, -0.07468610f, 0.17402439f, 
    -0.07268345f, 0.01923468f, -0.04749558f, 0.00786558f, 0.07239104f, -0.01078744f, 0.01110740f, 0.08692817f, 
    -0.19456594f, 0.06351503f, 0.00273829f, 0.06255943f, -0.10270289f, 0.07493480f, 0.02716492f, -0.06077787f, 
    0.00316187f, 0.04507285f, -0.03416114f, -0.05937232f, 0.04829700f, -0.02400109f, -0.11288705f, 0.02122904f, 
    0.05126565f, 0.07680876f, 0.02061967f, 0.02735666f, 0.01278638f, -0.01454556f, -0.03235414f, 0.00705140f, 
    0.34074500f, 0.01568433f, 0.05065392f, -0.09552270f, 0.05156613f, -0.11968824f, 0.11761285f, 0.14542317f, 
    -0.00362309f, -0.03054762f, -0.02891852f, -0.08900443f, -0.16050276f, -0.03760118f, -0.24178614f, -0.11478594f, 
    -0.12607142f, 0.01122581f, -0.03842075f, 0.04052221f, 0.00476735f, -0.03755815f, 0.00880325f, 0.00526433f, 
    -0.10201570f, 0.19779335f, -0.11809319f, 0.06234332f, -0.08741220f, -0.03788573f, -0.10008568f, 0.06688084f, 
    -0.01443603f, 0.01618949f, 0.08594600f, 0.08694784f, 0.28095016f, 0.02354037f, -0.12935305f, 0.09690697f, 
    -0.08712717f, -0.04806187f, -0.07188574f, -0.06758747f, -0.02442888f, 0.02431336f, -0.17771776f, 0.00203676f, 
    -0.14817980f, 0.03164900f, -0.00619832f, -0.15344706f, -0.04376326f, -0.03019811f, 0.06527772f, 0.12003580f, 
    -0.12894762f, 0.03687374f, 0.04459137f, -0.02508676f, 0.31492925f, 0.12058139f, -0.12940761f, 0.16291189f, 
    -0.01390832f, 0.00664781f, 0.02697442f, 0.16193463f, -0.00669006f, 0.09661742f, -0.07282504f, -0.12645349f, 
    -0.23988293f, 0.02098443f, 0.02317099f, -0.08420189f, 0.08059184f, 0.09425507f, 0.03813072f, -0.06546296f, 
    0.02478832f, 0.01029089f, 0.01386529f, 0.00482016f, 0.16755272f, 0.12245287f, 0.04815146f, -0.09107810f, 
    0.08336331f, 0.00592482f, 0.02891542f, 0.02170060f, -0.04415676f, 0.10225087f, 0.08565092f, -0.06481898f, 
    0.29541779f, -0.01260565f, 0.01685873f, -0.06652317f, -0.04143081f, -0.14643171f, -0.13197669f, 0.02192336f, 
    0.09736443f, 0.08408203f, -0.05195142f, 0.00602533f, -0.03496020f, -0.16423140f, 0.02701306f, -0.00819530f, 
    -0.00865888f, 0.14976649f, -0.03503385f, -0.05671626f, 0.04539418f, 0.09278572f, -0.00926537f, 0.11645690f, 
    -0.25324985f, 0.27426496f, -0.13818637f, 0.16539787f, 0.03785164f, 0.03709022f, 0.04318443f, 0.12041237f, 
    -0.03479036f, -0.02005672f, 0.04182584f, 0.07422098f, 0.01793192f, -0.06187980f, -0.02480498f, 0.13261446f, 
    0.00832809f, -0.00477843f, -0.05199073f, -0.11751793f, -0.02117044f, 0.11438726f, 0.05018475f, -0.03424358f, 
    -0.25360909f, -0.01249758f, 0.00993818f, 0.08126166f, 0.10636842f, -0.04869251f, 0.10345326f, 0.05408970f, 
    0.16271591f, -0.00512025f, 0.12853467f, 0.17436782f, -0.24015981f, -0.09742292f, -0.00049209f, -0.18474850f, 
    -0.00508126f, -0.05966139f, 0.06076459f, -0.00786800f, 0.07046000f, 0.13845602f, 0.07006124f, 0.10316467f, 
    -0.09819846f, 0.08945193f, 0.09015104f, -0.15492451f, 0.04360382f, -0.13038234f, -0.22456795f, -0.03560200f, 
    0.07506956f, -0.11297229f, 0.03576412f, -0.03422525f, -0.21186854f, 0.16994013f, -0.02232894f, -0.15329601f, 
    0.10066459f, -0.07058028f, -0.05006810f, 0.05891964f, 0.16073655f, -0.10945742f, 0.00624661f, -0.06521469f, 
    0.06343701f, 0.10349331f, -0.17692745f, 0.05931216f, -0.12819086f, 0.00342027f, -0.01379924f, 0.06893321f, 
    0.02337361f, 0.05191635f, -0.11957572f, -0.12786551f, 0.04334560f, -0.13350129f, -0.02317966f, 0.00224940f, 
    0.17370628f, 0.14254647f, 0.01419978f, 0.00449566f, -0.01493149f, 0.08307631f, 0.17563164f, -0.05484246f, 
    -0.22754046f, -0.03930324f, -0.14342751f, -0.11227388f, 0.04193047f, -0.09408209f, 0.09717242f, -0.10996393f, 
    0.09913418f, -0.05177446f, -0.04558895f, -0.00287717f, -0.07631755f, -0.04807129f, -0.00418976f, 0.00624947f, 
    0.13482442f, -0.14534044f, 0.03844228f, 0.10414385f, -0.02590727f, 0.08076686f, -0.01949876f, 0.19774111f, 
    0.00292372f, 0.08702110f, 0.03694744f, 0.03584674f, -0.01020665f, 0.00853240f, 0.01651479f, 0.12202834f, 
    0.10338917f, 0.01189127f, -0.09411999f, -0.01508979f, -0.06714608f, 0.03982830f, -0.02352666f, -0.05632624f, 
    0.02818246f, 0.09610893f, 0.06846009f, 0.00191324f, 0.10643328f, 0.08293990f, 0.02354413f, -0.20997757f, 
    -0.25582016f, -0.10563637f, 0.01562298f, -0.07276084f, 0.12167799f, 0.12637973f, -0.07294066f, -0.09919602f, 
    -0.10987460f, -0.02640139f, 0.06702553f, -0.00203202f, 0.16714598f, 0.06178673f, 0.02642879f, 0.01651461f, 
    0.01606431f, -0.10153358f, 0.00176888f, -0.07177956f, 0.09395471f, 0.17923158f, 0.14490111f, 0.13825212f, 
    -0.12437217f, -0.06135196f, -0.10530441f, 0.09664435f, -0.08737619f, -0.14395681f, 0.00718003f, 0.06991039f, 
    0.03234534f, 0.01502250f, -0.09054900f, -0.03586312f, 0.04446871f, -0.13362704f, 0.17806387f, 0.04498933f, 
    0.11547328f, -0.00800161f, -0.04177692f, 0.03360986f, 0.00433327f, 0.03684113f, 0.19039598f, 0.23251586f, 
    -0.15934730f, 0.17598480f, -0.09473264f, -0.12806676f, 0.18342739f, -0.01361614f, 0.15436576f, 0.08699115f, 
    0.03685586f, 0.07051113f, -0.00042429f, 0.11442676f, -0.01788154f, -0.09060346f, 0.09625811f, 0.27478412f, 
    0.24336344f, 0.01912466f, 0.06739718f, -0.08209495f, -0.00574421f, -0.11982490f, -0.00624789f, 0.15300918f, 
    0.04120687f, -0.07439507f, 0.02788958f, -0.02951556f, 0.00974798f, -0.05953196f, -0.00060228f, 0.00174119f, 
    0.01623658f, -0.06626812f, 0.03168824f, 0.00452675f, 0.00972613f, -0.01068605f, -0.07737372f, 0.02185412f, 
    0.03333580f, 0.01416879f, 0.02153617f, -0.00471786f, -0.03358751f, -0.02552399f, -0.04119224f, 0.03769800f, 
    -0.07572187f, -0.04860203f, 0.06167169f, -0.05444345f, -0.01544027f, 0.04683932f, -0.04489765f, -0.05779750f, 
    -0.05816518f, 0.05553627f, 0.03946600f, 0.03592736f, -0.05031472f, -0.02178695f, -0.00088507f, 0.00527433f, 
    0.05038732f, -0.04772366f, -0.00834346f, 0.02457336f, -0.04141381f, 0.04583779f, -0.04001676f, -0.04388666f, 
    0.04675082f, -0.02569622f, 0.01323026f, -0.03360571f, 0.01624721f, -0.02939720f, -0.01208458f, 0.00555679f, 
    -0.04190303f, -0.00939545f, -0.02479796f, 0.03267789f, 0.04418968f, -0.02934315f, -0.03223524f, -0.07074136f, 
    -0.04986949f, -0.03650340f, 0.02187518f, -0.05109460f, -0.03284698f, 0.03234655f, -0.06928805f, -0.03020698f, 
    0.02195409f, 0.01769698f, 0.03346643f, -0.05982925f, 0.04737201f, 0.02978779f, -0.06876701f, -0.01231785f, 
    -0.01588663f, 0.04377642f, 0.05161383f, 0.02439366f, -0.05418178f, -0.00873509f, -0.02403325f, -0.06570097f, 
    0.01516342f, 0.02164342f, -0.06326965f, 0.03428251f, 0.05486126f, -0.03087706f, -0.02327538f, -0.00418185f, 
    0.00338882f, -0.07380780f, -0.00859919f, 0.01594665f, 0.01496418f, -0.07404704f, 0.00673628f, -0.01416011f, 
    0.01232507f, 0.03742182f, 0.04415343f, -0.05005594f, -0.08070193f, 0.05146644f, 0.03609264f, -0.06122293f, 
    -0.01699569f, 0.05633687f, 0.05489979f, -0.07281185f, -0.00712278f, 0.00320585f, -0.01379454f, 0.03715228f, 
    -0.00792598f, -0.03331373f, 0.02854701f, 0.06269775f, -0.04446058f, -0.03029516f, 0.06124632f, -0.06089818f, 
    -0.08082245f, -0.07430252f, -0.00588239f, 0.04819864f, -0.00049860f, -0.01434289f, 0.03110445f, 0.04054064f, 
    -0.00524458f, -0.03490511f, -0.02675788f, -0.05347619f, -0.07881879f, 0.05606501f, 0.00467894f, 0.03475374f, 
    0.01716450f, 0.06117578f, -0.01665491f, 0.00506579f, -0.01680765f, -0.01437149f, 0.02915361f, 0.03454240f, 
    0.01933783f, -0.03116903f, 0.05930186f, 0.04852107f, -0.03902731f, -0.02154545f, 0.01634698f, -0.07840928f, 
    -0.05064291f, 0.05504216f, -0.03825289f, 0.03455351f, -0.06730942f, -0.02763851f, 0.05781667f, -0.03732865f, 
    -0.00177932f, -0.07692511f, 0.00373679f, -0.01454590f, -0.01753431f, -0.07827676f, -0.00666296f, -0.06500410f, 
    -0.05947734f, -0.00778456f, -0.02886334f, 0.00043947f, 0.01936225f, -0.06537836f, -0.04425839f, -0.03775886f, 
    -0.00174651f, -0.00959253f, -0.05435715f, 0.06000828f, 0.02365347f, -0.00636952f, -0.05364704f, -0.02212548f, 
    0.13911673f, -0.00897795f, -0.10432326f, 0.13587174f, -0.00730811f, -0.03833795f, 0.12024857f, 0.01881854f, 
    0.10965219f, -0.05760486f, -0.08954324f, -0.01399119f, 0.07787404f, -0.30990842f, 0.09180287f, -0.16801585f, 
    -0.17270947f, -0.06313887f, 0.12732720f, 0.04624151f, -0.02803555f, 0.08027218f, -0.05301220f, 0.08999869f, 
    0.10100304f, 0.06528395f, 0.06603155f, -0.03254584f, -0.00749668f, -0.02442682f, -0.16571267f, 0.10300585f, 
    0.17710696f, -0.17942658f, 0.02810165f, -0.03046830f, -0.08842570f, 0.15403810f, -0.16515329f, -0.08572947f, 
    -0.12424453f, -0.12411868f, 0.03160739f, -0.07362113f, 0.13164617f, -0.03598833f, 0.09505585f, 0.02243746f, 
    0.07382818f, 0.26279706f, 0.10635476f, 0.13090543f, -0.14114650f, 0.01852820f, 0.00884263f, 0.04495726f, 
    0.05132106f, -0.02460152f, -0.05436943f, -0.14261888f, -0.18306693f, -0.02723498f, -0.15693049f, 0.12366488f, 
    0.00274678f, 0.11497325f, -0.10185342f, -0.09535679f, 0.05679785f, -0.08151441f, 0.03513383f, 0.13359685f, 
    0.00537548f, 0.02206089f, -0.15204181f, -0.09760664f, -0.03902277f, -0.04650169f, 0.10973374f, -0.14597479f, 
    0.02095373f, -0.00081411f, -0.14964175f, -0.05090374f, 0.02592378f, -0.14374620f, 0.13160060f, -0.04918245f, 
    -0.07223696f, -0.00063849f, -0.00930153f, 0.03391866f, 0.03475972f, 0.00813608f, 0.10217014f, 0.18182404f, 
    -0.10910717f, 0.26415101f, -0.01616290f, -0.11707471f, -0.03791924f, 0.07528329f, -0.09857775f, -0.01205883f, 
    0.15851375f, -0.03224301f, -0.06065065f, -0.00913550f, 0.07405970f, -0.15901361f, 0.04366163f, -0.07116054f, 
    -0.06203690f, -0.01044935f, 0.08563577f, 0.04215742f, 0.17868330f, 0.02414325f, -0.02541438f, -0.16774063f, 
    -0.02924168f, 0.12133737f, -0.25610662f, -0.01832528f, 0.13452581f, 0.01499044f, -0.10483652f, 0.00161758f, 
    -0.06397665f, 0.01411024f, 0.09837162f, -0.03900250f, 0.10919114f, 0.00477873f, -0.09813441f, -0.16346543f, 
    -0.00544181f, -0.07254379f, -0.00509633f, -0.07349302f, 0.09606158f, -0.04605045f, 0.05082778f, 0.08444475f, 
    0.37230161f, 0.25098047f, 0.03234790f, 0.11206977f, -0.09354030f, -0.01974941f, 0.15077369f, 0.06687701f, 
    0.03058643f, -0.12391621f, 0.03336781f, 0.02264533f, -0.15745047f, -0.15246436f, 0.07993951f, -0.01066319f, 
    0.01009535f, 0.01228995f, 0.12240196f, -0.05198843f, 0.07492511f, -0.00475763f, 0.09944417f, 0.16189477f, 
    -0.08215920f, 0.02319317f, -0.09974936f, -0.06961577f, 0.17457341f, 0.02337267f, 0.12045177f, 0.02045684f, 
    -0.00449802f, 0.03449970f, -0.11640037f, 0.15832800f, -0.24260440f, -0.02603258f, -0.05305217f, 0.33975253f, 
    0.16001488f, -0.03160683f, -0.03017192f, -0.14903542f, 0.06266568f, 0.06723397f, -0.00517442f, 0.10426626f, 
    0.02026213f, -0.02606470f, -0.07063379f, -0.04490865f, 0.04314002f, 0.01883611f, 0.00414005f, 0.02908469f, 
    -0.07359340f, -0.07157338f, 0.04279169f, -0.00417065f, -0.03295846f, 0.05526762f, 0.00425811f, -0.01200268f, 
    -0.00824091f, -0.07335063f, -0.06148291f, 0.00096135f, -0.00980921f, 0.01110367f, -0.04091163f, 0.04367276f, 
    0.03503523f, 0.06259445f, -0.01128872f, -0.07910755f, -0.02850626f, -0.05286257f, -0.07178691f, -0.04305258f, 
    0.03279532f, -0.03383452f, 0.02042938f, -0.00045133f, 0.02082108f, 0.01958838f, -0.07855240f, -0.06117651f, 
    -0.02435354f, -0.06496684f, 0.03513438f, 0.05902757f, -0.06380478f, -0.00212035f, 0.05390110f, -0.03411468f, 
    0.01459746f, -0.05632366f, 0.04711150f, 0.00569122f, -0.02426595f, -0.01844722f, -0.00188362f, 0.03455851f, 
    -0.03728082f, -0.07384589f, -0.04558860f, 0.03544310f, -0.05539860f, -0.06939758f, -0.00781993f, -0.06779359f, 
    0.01044129f, 0.03407694f, 0.02821148f, -0.00611128f, -0.01761507f, 0.04040746f, -0.03413388f, -0.05577764f, 
    0.03741910f, -0.05732210f, -0.04009468f, 0.03187562f, 0.00273386f, -0.06701246f, -0.02340444f, -0.07059260f, 
    0.01596697f, -0.06415132f, -0.02399084f, 0.00251748f, -0.02175211f, -0.03702990f, 0.01309697f, 0.01569973f, 
    0.00910204f, -0.02017429f, 0.02601193f, 0.04083292f, 0.03539313f, -0.05441831f, 0.04801816f, 0.04194484f, 
    0.05072451f, 0.03324028f, 0.05884549f, 0.01693428f, -0.05393972f, 0.05391888f, -0.06563205f, -0.06360675f, 
    -0.00615877f, -0.07182379f, -0.04091897f, 0.05357017f, -0.00982828f, 0.02440310f, -0.06779961f, -0.03468437f, 
    -0.06139737f, -0.04749563f, -0.05253637f, -0.00573657f, -0.05604853f, 0.04470837f, -0.07949544f, 0.00196087f, 
    -0.04633423f, 0.01483426f, -0.04872918f, 0.01261488f, -0.01813816f, 0.01095978f, 0.05702367f, 0.02222680f, 
    0.06232271f, -0.00711448f, -0.01140511f, 0.01700477f, 0.03896683f, -0.07575449f, -0.02450760f, -0.02515776f, 
    -0.07898160f, -0.07599968f, -0.06136438f, 0.03368103f, 0.02766844f, 0.02370443f, 0.03424793f, -0.00636576f, 
    0.02269011f, 0.01764948f, 0.01419490f, -0.02525372f, -0.01784550f, 0.06375447f, -0.04819427f, -0.06485946f, 
    -0.06319272f, 0.03493951f, -0.05595948f, -0.03305863f, -0.01192134f, 0.05671757f, 0.01344777f, 0.04969321f, 
    -0.03410847f, 0.02425102f, -0.01008843f, 0.01001939f, -0.02400368f, -0.05535979f, -0.04161278f, -0.00519735f, 
    -0.00449646f, 0.03810385f, 0.05797756f, -0.03463246f, -0.03342089f, -0.00014412f, 0.00393933f, 0.05164114f, 
    0.02927116f, -0.02705710f, -0.06867752f, -0.02732409f, 0.00181665f, -0.04351070f, -0.06762669f, 0.04136912f, 
    0.02911371f, -0.04280394f, 0.05982296f, -0.01083585f, 0.00986824f, -0.03009876f, 0.03721667f, -0.03886416f, 
    -0.26286957f, 0.13582653f, 0.14513406f, 0.09767536f, -0.15799536f, 0.06240571f, 0.00221870f, -0.07355607f, 
    0.03052079f, -0.09254342f, 0.00666347f, -0.00830243f, 0.40288195f, -0.08678363f, 0.21857478f, 0.04229064f, 
    -0.01714884f, -0.06169563f, -0.08040673f, -0.11579165f, 0.10000149f, -0.01062359f, 0.04187192f, 0.04523471f, 
    -0.00592251f, -0.20583349f, 0.07386299f, -0.10628709f, 0.04643641f, -0.05467736f, -0.05080462f, -0.05117568f, 
    0.14125836f, 0.03514585f, 0.00489088f, 0.04836736f, -0.13778397f, -0.04344557f, -0.02001967f, -0.10341066f, 
    0.06222661f, 0.01692738f, -0.02467435f, 0.10396031f, 0.16792531f, -0.17835388f, 0.05222576f, -0.10850462f, 
    0.40809405f, 0.20517248f, 0.01967006f, -0.06382129f, -0.02555488f, 0.03925366f, -0.03695519f, 0.14618021f, 
    0.00157980f, -0.09396206f, 0.01020213f, -0.08044207f, 0.54984003f, -0.09789869f, -0.31152534f, -0.15873928f, 
    0.05842537f, -0.00927598f, -0.13159645f, -0.07422289f, 0.07053227f, 0.08844611f, 0.05541330f, 0.12440790f, 
    -0.14965096f, 0.11097024f, 0.12447597f, -0.03233987f, -0.04941511f, 0.02909037f, -0.08087949f, -0.02010947f, 
    0.08034078f, 0.07592022f, 0.04000809f, 0.05017048f, 0.10477947f, 0.02126299f, -0.00745519f, 0.04706396f, 
    -0.07013816f, 0.04179479f, 0.05054591f, 0.13203153f, -0.03440208f, -0.01265286f, -0.15911576f, 0.14978139f, 
    -0.01331448f, -0.12225402f, -0.01250374f, 0.05127194f, -0.00251986f, 0.05483536f, 0.07258600f, 0.02489107f, 
    0.03727827f, 0.11836912f, 0.01344271f, 0.09321456f, -0.02153619f, -0.09379978f, -0.14280654f, 0.09122525f, 
    -0.03446428f, 0.06230397f, -0.00923297f, 0.02188228f, 0.04588429f, 0.03839114f, 0.02665822f, -0.09933336f, 
    0.00391065f, 0.01684223f, -0.01749505f, -0.02316013f, 0.07026784f, 0.11661147f, -0.00695796f, -0.16022301f, 
    -0.05858193f, -0.07389022f, -0.04635170f, -0.11496224f, 0.04310526f, 0.11175933f, -0.07638369f, -0.03097347f, 
    -0.13000827f, -0.17595980f, 0.01751459f, -0.07386116f, 0.01027033f, 0.10939065f, 0.00136317f, 0.00714483f, 
    0.26943076f, -0.03869767f, 0.07965466f, 0.07631888f, 0.01853407f, -0.00320572f, 0.00773505f, 0.11917120f, 
    0.01614070f, 0.01123584f, -0.03144757f, 0.02500515f, 0.18485296f, -0.21614580f, -0.09396510f, -0.10481960f, 
    0.16671239f, 0.11076454f, -0.06862210f, -0.10676574f, -0.07522355f, 0.04240290f, 0.02063931f, 0.26385301f, 
    0.07572236f, 0.02020715f, -0.05392982f, 0.08680111f, 0.09802379f, -0.00726096f, -0.02696536f, 0.09603850f, 
    0.03279234f, -0.05352263f, 0.00161638f, 0.02323814f, 0.04085422f, -0.14702775f, -0.12617350f, 0.11226156f, 
    0.21463208f, 0.04811121f, 0.07968244f, -0.18393625f, -0.04396547f, 0.05144998f, 0.10899405f, -0.03599973f, 
    -0.01732531f, 0.02939081f, 0.10597592f, 0.02184595f, -0.02448697f, 0.00618527f, -0.16389076f, -0.12220567f, 
    -0.04295713f, -0.00312787f, 0.09476371f, 0.24312614f, 0.62029213f, -0.08960135f, 0.03311401f, 0.21360105f, 
    -0.21781389f, -0.08162942f, 0.02498184f, -0.10485386f, 0.02657840f, -0.02533824f, -0.06862078f, -0.06929553f, 
    0.17580689f, 0.11902431f, -0.01844142f, -0.06311595f, 0.10812398f, -0.00592480f, -0.04909820f, 0.13914429f, 
    0.03727071f, 0.03843816f, -0.05048387f, 0.00708347f, -0.17922890f, -0.14997606f, 0.07209123f, 0.09388889f, 
    -0.00727728f, 0.08250284f, 0.02305533f, 0.12958612f, 0.03337019f, 0.02720708f, -0.05898385f, 0.10762440f, 
    0.22136685f, 0.01048055f, -0.07267145f, 0.03252174f, -0.16447915f, -0.05753027f, -0.04366466f, 0.11751141f, 
    -0.02224143f, 0.12372819f, 0.03536832f, -0.00285283f, -0.16543390f, -0.11320599f, 0.07217342f, 0.12006294f, 
    0.08857235f, -0.03853468f, 0.12692630f, -0.04873361f, -0.14440364f, -0.06762736f, -0.09110948f, 0.09029827f, 
    0.12698798f, 0.11815108f, 0.17505969f, 0.07877707f, -0.01755050f, -0.07339509f, -0.01359649f, 0.01239225f, 
    0.00214641f, 0.08646449f, 0.16997194f, 0.19522835f, 0.27714324f, -0.00289283f, 0.04082560f, -0.01066232f, 
    -0.14189763f, -0.12653105f, -0.05519914f, -0.02043012f, -0.06493551f, 0.03207072f, -0.02043099f, 0.02777413f, 
    -0.07960074f, -0.16020826f, -0.01048850f, -0.13127376f, 0.13198203f, -0.00179310f, -0.00841375f, 0.02972648f, 
    -0.06799703f, 0.09902404f, 0.06822616f, 0.05855980f, 0.06280895f, 0.00479873f, 0.03249257f, 0.15305659f, 
    -0.05194165f, -0.16147882f, -0.01213081f, -0.02332737f, -0.10186727f, -0.00128025f, 0.10612914f, 0.01592145f, 
    0.10462535f, 0.04945926f, 0.19877051f, -0.06768633f, -0.03043547f, -0.02202692f, 0.04482019f, 0.02613981f, 
    0.13905197f, 0.05228586f, -0.09670661f, 0.07797187f, 0.34566391f, 0.14430939f, 0.04152963f, -0.11041413f, 
    0.05557659f, 0.12061664f, -0.09991258f, 0.00124598f, 0.10960534f, 0.03621621f, -0.08655681f, -0.05960879f, 
    0.06695266f, 0.12802747f, -0.01704920f, 0.03853222f, 0.06827459f, -0.12213524f, -0.00956921f, -0.02553805f, 
    0.00704875f, -0.01454338f, 0.03065959f, -0.00967331f, -0.24095373f, -0.07776146f, -0.12991011f, -0.13730934f, 
    0.07083983f, 0.13205822f, 0.03267599f, 0.00687209f, -0.07288680f, 0.16387615f, -0.12452758f, -0.10806619f, 
    0.09309661f, 0.09767234f, 0.21238942f, 0.02702163f, 0.00332680f, 0.02908051f, -0.01359479f, 0.00684330f, 
    0.02318075f, -0.04290591f, -0.00437709f, 0.08750629f, -0.19168660f, -0.12307987f, -0.43843922f, -0.27172101f, 
    0.14873974f, 0.10670707f, 0.01295102f, -0.03785361f, -0.10221781f, -0.09094252f, 0.01958737f, -0.02991936f, 
    -0.12742761f, 0.15412502f, -0.03207849f, -0.02537847f, -0.10087491f, 0.05270880f, 0.07246231f, 0.06553443f, 
    0.05194720f, 0.07189241f, -0.00736151f, 0.04554415f, 0.32059702f, 0.07236359f, 0.13046189f, 0.07854335f, 
    0.07405559f, -0.00160348f, 0.02638729f, -0.01304093f, -0.06988868f, -0.01237439f, 0.05006702f, 0.07297055f, 
    -0.13358684f, -0.00799216f, 0.02399676f, 0.10410757f, 0.10735980f, 0.08981908f, 0.02457198f, -0.07835046f, 
    -0.02405834f, -0.11100076f, 0.09739940f, 0.09688172f, -0.01451785f, -0.33179209f, -0.14954287f, 0.09585608f, 
    0.11174556f, -0.00699653f, 0.02644692f, 0.15020946f, 0.08814444f, 0.01824016f, -0.02979477f, -0.02928250f, 
    0.26875395f, 0.04731168f, -0.09822235f, -0.24639711f, -0.02683066f, 0.01769503f, 0.01684994f, 0.05442831f, 
    0.01320691f, 0.04999369f, 0.00847240f, -0.01286090f, 0.11880454f, 0.00698304f, -0.07499126f, 0.03597473f, 
    -0.00690580f, -0.17341797f, -0.07458387f, 0.01612337f, 0.01801573f, -0.09730773f, 0.00950639f, 0.01025151f, 
    -0.17209585f, -0.02819604f, 0.01952510f, -0.06057012f, -0.08912108f, -0.04911442f, -0.03955118f, -0.05176854f, 
    0.03309812f, 0.00903789f, -0.02530636f, 0.16624615f, 0.06072925f, 0.11142670f, 0.01525435f, 0.07274115f, 
    -0.04899821f, -0.05477538f, -0.03069053f, 0.00779273f, -0.08271810f, 0.06515292f, -0.14515804f, 0.09524713f, 
    -0.24135795f, 0.00562369f, -0.06946599f, -0.11618281f, -0.04136920f, 0.06590175f, -0.01056103f, 0.07267866f, 
    -0.02087569f, 0.00144181f, 0.04627991f, -0.06641487f, 0.23652029f, 0.03456978f, -0.15611455f, 0.09337493f, 
    -0.04344895f, 0.04666676f, 0.07207222f, -0.05477578f, 0.03585231f, 0.08203765f, 0.08428034f, -0.15232293f, 
    -0.03034364f, -0.06328528f, 0.11191028f, -0.30081430f, 0.07695858f, -0.01427277f, 0.06375302f, -0.02261903f, 
    0.03673039f, 0.08381892f, 0.09110948f, 0.03324099f, 0.06184946f, -0.11396254f, 0.02012410f, -0.13976683f, 
    0.00956748f, 0.04334251f, 0.06923135f, -0.03860833f, 0.05218739f, 0.02228273f, 0.05906022f, -0.01816352f, 
    0.13412185f, -0.11728504f, -0.06301599f, 0.03519858f, 0.05900882f, 0.01552168f, -0.07998544f, -0.01440380f, 
    0.08187092f, 0.02804308f, -0.05079262f, -0.05609635f, -0.04068623f, -0.17556451f, 0.15690082f, -0.00912944f, 
    -0.03752070f, -0.00846373f, 0.03295022f, -0.05394519f, 0.04371375f, 0.06719282f, 0.00640423f, 0.17788778f, 
    -0.23653513f, 0.12297432f, -0.19986491f, 0.01262453f, 0.16084747f, -0.04516930f, 0.04961488f, -0.02562307f, 
    0.02926673f, -0.06624362f, -0.00374907f, 0.10923424f, -0.06878427f, -0.08064815f, 0.04842551f, -0.03879248f, 
    0.07136216f, -0.08086883f, 0.00579973f, 0.02004122f, -0.09185585f, 0.04607851f, 0.05424480f, -0.02943631f, 
    -0.04030118f, 0.01904036f, 0.09641561f, -0.10289432f, -0.00384175f, -0.11006821f, 0.12267555f, 0.16697551f, 
    0.16560648f, -0.01145925f, -0.02849813f, 0.10845926f, -0.17415750f, -0.04035642f, -0.04936794f, -0.00748599f, 
    0.00088744f, -0.01192003f, 0.15432042f, 0.14997441f, -0.03282966f, -0.02800267f, 0.04225149f, -0.00980196f, 
    0.07105237f, 0.18602288f, -0.04567909f, 0.01794629f, 0.04869926f, -0.09558870f, -0.08661149f, -0.00416190f, 
    0.06938515f, -0.07964472f, 0.20836331f, 0.00072312f, 0.03268561f, 0.24395055f, -0.17567810f, 0.11646234f, 
    -0.02464232f, 0.03340540f, 0.04627867f, 0.17869876f, 0.07696689f, -0.00628941f, 0.02749336f, 0.04377524f, 
    -0.06033522f, 0.09529164f, -0.03204517f, -0.09220031f, -0.08886833f, 0.03564143f, 0.07834612f, 0.12705529f, 
    0.04202249f, 0.13002132f, -0.02353082f, -0.13013619f, -0.42222628f, -0.05983634f, -0.04320376f, 0.13050754f, 
    0.09108195f, 0.02975094f, 0.01591421f, 0.05120105f, 0.03038277f, -0.12568547f, 0.11435763f, -0.05378850f, 
    -0.14271468f, -0.22114876f, 0.03607847f, -0.17403096f, 0.01243357f, -0.04028998f, 0.11942056f, -0.12057041f, 
    0.03667898f, -0.04761777f, -0.02408758f, 0.12057219f, -0.01784456f, -0.19802128f, 0.01521726f, 0.08567065f, 
    0.09721684f, -0.07572949f, -0.10260618f, -0.00973458f, 0.00898400f, 0.08071671f, -0.05756033f, 0.04262030f, 
    0.10353160f, 0.30389959f, 0.02295371f, -0.37928000f, 0.11921633f, 0.00900594f, 0.06001126f, 0.05877358f, 
    -0.00699905f, 0.10445426f, 0.03448449f, 0.08353813f, 0.04930156f, 0.12356903f, -0.02178936f, 0.08002353f, 
    -0.00229197f, -0.01884021f, -0.09305523f, 0.11896545f, 0.07843754f, -0.02770277f, 0.10346918f, -0.06368607f, 
    -0.19480428f, -0.04158831f, 0.09059305f, -0.12773386f, 0.18271884f, -0.00245893f, 0.07758290f, 0.16899323f, 
    -0.02246583f, -0.00335955f, 0.11736752f, 0.09196646f, 0.08865824f, 0.06677058f, 0.10946345f, -0.08459315f, 
    0.05233793f, -0.05480019f, 0.12604380f, 0.07524256f, 0.11392609f, 0.16282345f, -0.01011705f, -0.00101047f, 
    -0.19406068f, 0.27387536f, -0.23621991f, 0.03340182f, -0.09299697f, -0.14452399f, 0.06770407f, -0.05701951f, 
    0.06983693f, -0.05063036f, 0.04005857f, 0.04911098f, -0.18812320f, -0.09262177f, 0.15247139f, 0.09120005f, 
    -0.04616608f, 0.00287617f, 0.01363934f, -0.05908595f, -0.00500491f, 0.01628240f, 0.16336322f, 0.10643850f, 
    -0.30583176f, -0.00684232f, 0.05088846f, -0.04771204f, 0.19855040f, -0.17003955f, 0.17951837f, 0.02750850f, 
    0.01709381f, 0.22859171f, -0.03703279f, 0.15720591f, -0.17361727f, 0.00075342f, 0.17183673f, 0.02384031f, 
    0.13757999f, 0.00817302f, -0.03765458f, 0.01804041f, 0.00347820f, -0.02108789f, -0.02794966f, 0.13772358f, 
    0.06340830f, 0.11753765f, -0.00080991f, 0.12042607f, 0.09084706f, -0.00625237f, 0.10669372f, 0.08877394f, 
    -0.09127995f, -0.16163985f, 0.05727822f, -0.02896557f, -0.26638210f, -0.05178340f, 0.00215618f, -0.04278556f, 
    -0.02971255f, -0.04455688f, 0.06658528f, 0.03733771f, -0.08396932f, 0.03355790f, -0.09381115f, 0.07664163f, 
    0.42924929f, 0.11851862f, -0.01597211f, 0.11239254f, -0.00422919f, 0.01033459f, 0.09148052f, 0.05397289f, 
    0.01330566f, -0.03913264f, -0.04494304f, 0.09716748f, -0.00939696f, 0.11614243f, -0.00279706f, -0.02067181f, 
    -0.02675497f, -0.06512418f, 0.01209629f, 0.06528258f, 0.00828984f, 0.09120524f, 0.08629844f, -0.03639746f, 
    -0.27759695f, 0.11649802f, 0.12900403f, -0.00785745f, -0.03192703f, 0.06254134f, -0.11960033f, 0.06786935f, 
    -0.04345239f, 0.04943139f, -0.00949420f, -0.07060623f, -0.15647201f, -0.16645730f, 0.22411002f, 0.23616312f, 
    0.12676322f, -0.01083708f, 0.04523399f, -0.06309550f, -0.05266662f, -0.07733531f, 0.03921938f, -0.08312263f, 
    0.26554307f, -0.35681468f, 0.18984894f, -0.02456561f, 0.13349095f, 0.01280592f, 0.09894041f, -0.05657525f, 
    -0.01322781f, -0.08891981f, -0.12567660f, 0.01922867f, -0.19194126f, -0.05676258f, 0.27974328f, -0.04341955f, 
    -0.00373484f, 0.01241961f, 0.06711052f, -0.01955413f, -0.02936301f, -0.05481419f, 0.22893453f, 0.03338524f, 
    0.19047077f, 0.07153309f, -0.06071419f, -0.11673295f, 0.10745385f, 0.06114239f, -0.02732588f, 0.04310875f, 
    0.10895603f, 0.05067209f, 0.05581867f, 0.14510366f, -0.05856095f, -0.01753017f, 0.17562933f, 0.02200710f, 
    -0.00238281f, 0.00953862f, 0.10130742f, -0.07931273f, -0.07184829f, -0.05608582f, -0.05571910f, 0.04409445f, 
    0.01478896f, 0.14862692f, -0.02392177f, -0.22934210f, -0.05439378f, -0.05259797f, -0.00597801f, 0.15573023f, 
    0.04559455f, 0.06577656f, 0.04047271f, 0.11514276f, -0.06068767f, -0.01897897f, 0.00178288f, -0.11795868f, 
    0.07774475f, 0.04713640f, 0.10224461f, 0.08488560f, 0.04550992f, -0.03914920f, 0.00686011f, -0.03028306f, 
    -0.10464519f, 0.07442453f, 0.04668461f, 0.19790813f, -0.02437202f, -0.00421093f, 0.10129147f, -0.00334473f, 
    0.02951385f, -0.04523171f, 0.11146312f, 0.07183144f, -0.05406938f, 0.01557187f, 0.06442066f, 0.04112592f, 
    0.11940563f, -0.11885761f, 0.00616358f, 0.03088965f, -0.02211959f, 0.07014704f, 0.07179231f, -0.07023694f, 
    0.03653108f, -0.21698435f, 0.16223736f, -0.06569107f, 0.07209674f, -0.06382431f, 0.09667148f, -0.10740893f, 
    -0.03665541f, 0.02365975f, -0.00037176f, -0.02317640f, -0.19341956f, 0.29841349f, -0.13134801f, -0.31212842f, 
    0.07982017f, 0.04224247f, -0.09859117f, 0.07015708f, -0.04010335f, -0.04208642f, 0.04571933f, -0.06869058f, 
    0.25117186f, 0.15490006f, 0.09453466f, -0.13365582f, -0.08283391f, -0.00223995f, -0.06072156f, 0.10363841f, 
    0.01879404f, 0.12842162f, -0.08961162f, 0.07208809f, 0.24615724f, 0.04556653f, 0.01700382f, 0.03903250f, 
    -0.06544051f, -0.03322685f, 0.02012547f, 0.00538938f, -0.06625178f, -0.07674456f, 0.03846739f, -0.00521798f, 
    -0.40885076f, 0.01021272f, -0.12379482f, -0.12377023f, 0.06944415f, -0.05529206f, 0.04226351f, 0.13538280f, 
    0.10245367f, 0.03739807f, 0.01222413f, -0.02805944f, 0.16338043f, -0.05824161f, -0.28568330f, 0.13253403f, 
    0.04695569f, 0.01486881f, 0.14153324f, -0.00949606f, -0.19042477f, 0.00220641f, 0.09266911f, 0.06555013f, 
    -0.02822834f, -0.04828064f, 0.16284835f, 0.10662714f, -0.13894655f, 0.01136462f, 0.13747166f, 0.02289770f, 
    -0.06920412f, 0.11677966f, -0.02292606f, 0.07344218f, -0.47314203f, -0.09626896f, -0.15940385f, -0.12979349f, 
    -0.12229066f, 0.04502928f, 0.02946763f, 0.08344993f, 0.17871822f, -0.05944877f, -0.00954355f, 0.17014189f, 
    -0.21640007f, 0.21019296f, -0.02927014f, -0.07432979f, -0.00107378f, -0.03342829f, -0.00560546f, 0.03711710f, 
    -0.14671338f, -0.08292048f, 0.02578102f, 0.06011236f, 0.20239547f, 0.03952184f, -0.10659492f, 0.03455289f, 
    0.09108686f, -0.05676106f, 0.03465868f, 0.05714092f, 0.01436035f, -0.02339327f, -0.08983155f, -0.01607915f, 
    0.12009042f, 0.23005250f, -0.00125017f, -0.16655664f, 0.04477844f, 0.04798977f, -0.03159074f, -0.00102061f, 
    -0.01911016f, 0.02375347f, -0.02150086f, -0.12502994f, 0.11883635f, 0.04384134f, -0.03786614f, -0.03463634f, 
    -0.00758956f, -0.03427820f, -0.14234090f, 0.16659142f, 0.13487104f, 0.04859022f, 0.05835617f, 0.14672047f, 
    -0.06349891f, 0.09632329f, -0.06125980f, 0.08902431f, 0.02374099f, 0.01020270f, 0.05686834f, 0.07516947f, 
    -0.04138572f, 0.01271614f, 0.06519234f, -0.08943129f, 0.25540319f, 0.11062557f, 0.04543133f, 0.12491136f, 
    -0.01888447f, -0.05578124f, -0.11387566f, 0.15946065f, 0.16188151f, -0.05714285f, 0.01632336f, -0.15353402f, 
    0.05268331f, 0.05574737f, -0.05343921f, -0.07044083f, -0.01074777f, 0.03302628f, -0.03104731f, 0.11276077f, 
    -0.17277688f, -0.07116725f, 0.06018432f, 0.01421662f, -0.27031958f, -0.16004220f, -0.00086487f, 0.06932058f, 
    -0.05510098f, -0.04820175f, 0.00581834f, -0.06185691f, 0.05409618f, -0.05365497f, -0.08877303f, -0.09574371f, 
    -0.07078291f, 0.27913705f, -0.00321220f, -0.05890291f, 0.07980841f, 0.10143365f, -0.01998145f, 0.09892838f, 
    0.07612153f, 0.01534770f, 0.01528541f, 0.01490401f, 0.04930587f, -0.37270129f, 0.13283433f, 0.20769645f, 
    0.12663211f, 0.09213929f, -0.13030607f, -0.01238644f, -0.03826823f, 0.03356259f, 0.00345197f, 0.00038879f, 
    -0.17704490f, -0.12761293f, -0.07041632f, 0.02710529f, 0.16191205f, -0.00445902f, 0.09593722f, 0.05457817f, 
    0.06947595f, -0.11671410f, 0.03371174f, -0.05157022f, -0.21138866f, -0.05333111f, -0.13966569f, -0.03779487f, 
    -0.00674461f, 0.04806954f, -0.05606687f, 0.01179369f, 0.10702426f, 0.05533680f, 0.01673657f, 0.08247019f, 
    0.02524621f, 0.32090658f, -0.06092407f, 0.19054785f, -0.01371995f, -0.01676697f, -0.04868235f, -0.04747326f, 
    0.07969730f, -0.01359246f, -0.10033150f, 0.03992290f, -0.05713750f, 0.20950969f, -0.00806887f, -0.28006023f, 
    -0.13774510f, 0.01324971f, 0.09254687f, 0.07747450f, 0.14901885f, -0.08442792f, -0.01405989f, -0.07814478f, 
    -0.00504424f, 0.04528408f, -0.11592517f, -0.13052097f, 0.08780052f, 0.04667154f, -0.03115983f, 0.11706491f, 
    0.02582468f, -0.00368277f, -0.17900145f, -0.09423298f, -0.11758886f, 0.14177313f, -0.09438560f, 0.12681176f, 
    -0.00088702f, 0.23065110f, 0.03975640f, -0.02305666f, -0.05546032f, 0.10954904f, 0.09979015f, -0.01264996f, 
    0.01975762f, -0.29785320f, -0.02282597f, -0.00838579f, 0.02732396f, 0.02476444f, 0.01315927f, -0.04304820f, 
    0.14165086f, 0.00025662f, -0.06267981f, -0.11119948f, 0.00056797f, -0.04084341f, -0.01453929f, 0.16064061f, 
    0.03995177f, 0.10122443f, -0.03224794f, 0.02286241f, 0.11458262f, 0.09438722f, 0.01648787f, 0.25925121f, 
    -0.16964360f, 0.07818616f, 0.09907343f, -0.24478385f, 0.00589284f, 0.02179638f, 0.15643848f, -0.04658576f, 
    0.11434834f, 0.05360191f, 0.00735365f, 0.01762210f, -0.11023455f, 0.10537221f, 0.02459222f, 0.13694346f, 
    0.14309569f, -0.04951091f, 0.00704283f, -0.07063078f, -0.04070734f, -0.03954682f, -0.02041646f, -0.16603008f, 
    -0.17065382f, -0.06745001f, 0.00959451f, -0.29605514f, 0.01657216f, 0.05125486f, -0.00293318f, 0.00775358f, 
    -0.00557711f, 0.00721752f, 0.12353586f, 0.03718975f, -0.04599939f, -0.04880780f, 0.17995647f, -0.17979772f, 
    0.13575158f, 0.10424013f, 0.02452783f, -0.13380152f, 0.14885348f, 0.13137759f, 0.03315462f, 0.02610158f, 
    0.20543967f, 0.05289930f, -0.02850930f, -0.17779365f, -0.01948869f, -0.02665045f, 0.12431087f, -0.03288747f, 
    0.11854491f, -0.01894091f, 0.07318030f, 0.00339292f, -0.00666328f, 0.10727266f, 0.09960346f, 0.18826437f, 
    0.03427604f, 0.12328576f, 0.06398585f, 0.10133762f, 0.06002425f, 0.11645740f, 0.12740463f, 0.23788974f, 
    -0.23721845f, -0.02921844f, 0.05617120f, 0.16450134f, 0.04758343f, -0.06113565f, 0.06745771f, 0.16513932f, 
    0.00962436f, 0.05675235f, 0.05096267f, 0.07899673f, -0.03768392f, 0.29179606f, 0.14908229f, 0.00977767f, 
    0.00532263f, 0.02536166f, 0.03252578f, -0.06823816f, -0.04460174f, 0.01235751f, 0.03351876f, 0.15819545f, 
    0.01622976f, 0.03212578f, -0.01699983f, -0.03755501f, -0.06938920f, -0.04444410f, -0.03057671f, -0.06809486f, 
    -0.08519515f, 0.01028251f, -0.01732787f, -0.00236258f, -0.05842172f, -0.04269154f, -0.07226279f, -0.02785015f, 
    -0.00057031f, 0.01779130f, -0.06952746f, -0.07363214f, 0.03111601f, 0.00067398f, -0.07148970f, 0.05553120f, 
    -0.03829331f, 0.02627162f, 0.06678808f, 0.02727617f, 0.01872011f, 0.06124775f, -0.07205179f, 0.06084643f, 
    0.03743634f, 0.01680768f, -0.00739825f, -0.02263467f, 0.02693942f, 0.01178688f, -0.02111088f, -0.07145627f, 
    -0.05214047f, 0.03353814f, 0.00182645f, -0.00722717f, 0.03883518f, -0.00496750f, -0.02371867f, 0.03211845f, 
    -0.05060566f, -0.03116878f, 0.07138798f, -0.02371863f, 0.01629654f, 0.01802918f, -0.01363037f, -0.08600465f, 
    -0.11158533f, -0.05250379f, -0.08111669f, -0.01119843f, -0.04963151f, 0.04341121f, 0.03161968f, 0.02523561f, 
    -0.04777630f, 0.03289549f, -0.03329219f, -0.01293594f, -0.01538368f, 0.01772329f, -0.02936267f, 0.06588650f, 
    0.02290041f, -0.01227938f, -0.00332418f, -0.01721192f, -0.03608548f, -0.05501946f, 0.03647907f, -0.07210498f, 
    -0.05967243f, -0.04733174f, -0.05197729f, -0.07975860f, -0.01202144f, -0.04151307f, 0.00537315f, -0.01761715f, 
    0.02873445f, -0.02713299f, 0.05463641f, -0.02387289f, 0.02905716f, 0.02681064f, -0.08041898f, -0.01364877f, 
    -0.02624836f, -0.08643160f, -0.00592699f, 0.02674512f, -0.02808725f, 0.04279630f, 0.04199869f, -0.00495332f, 
    0.03913036f, 0.04725327f, -0.05036957f, -0.08447355f, -0.09024020f, 0.03367244f, 0.02814348f, -0.02879106f, 
    -0.00457414f, 0.03278042f, -0.05786363f, -0.01986622f, -0.08541497f, -0.00678703f, -0.07063990f, -0.04178314f, 
    -0.04119481f, 0.02467246f, -0.00743263f, -0.05435045f, 0.00766741f, -0.06797706f, -0.01955733f, -0.05484359f, 
    -0.07057732f, 0.01769949f, 0.00140697f, -0.05711840f, -0.03457858f, 0.04335665f, 0.03103388f, -0.08138507f, 
    -0.08588489f, -0.03156060f, -0.02198070f, -0.08255760f, -0.06990516f, -0.04264408f, -0.01314163f, -0.06617202f, 
    -0.05510664f, -0.06709873f, -0.02165599f, -0.04495536f, 0.00934368f, 0.02233049f, -0.04777690f, 0.02854129f, 
    -0.03059406f, 0.01104734f, 0.03962078f, -0.05691312f, -0.01059247f, 0.02179577f, -0.03758473f, -0.00601940f, 
    0.03264294f, 0.00359602f, 0.01296017f, 0.06231265f, 0.02820840f, -0.02495188f, 0.05491833f, -0.00765142f, 
    -0.06966857f, -0.01487452f, 0.05092449f, -0.05392944f, -0.00301851f, -0.03624835f, -0.00557651f, 0.05023212f, 
    -0.04838038f, -0.01902192f, 0.03580832f, 0.03602413f, 0.07071435f, 0.04959223f, -0.01455359f, -0.07799977f, 
    -0.00853263f, -0.01142438f, 0.05207404f, 0.00011191f, 0.06388600f, 0.01015820f, -0.02342380f, -0.06182821f, 
    -0.13161391f, -0.07132182f, -0.01942885f, -0.00152533f, -0.14036971f, 0.05622434f, -0.11049151f, -0.17635685f, 
    -0.09332044f, 0.19813038f, -0.00328915f, -0.05266729f, 0.14253500f, 0.23211880f, -0.01592342f, 0.19290897f, 
    0.18419287f, 0.04701847f, -0.02794865f, 0.03824053f, -0.05124175f, -0.02636788f, 0.03150161f, -0.09907522f, 
    -0.14487994f, -0.08188827f, -0.05500499f, -0.11767671f, 0.06213338f, 0.09449276f, -0.07050403f, -0.06730513f, 
    0.04840681f, 0.09439893f, 0.05743273f, 0.06955541f, 0.10083610f, -0.20720816f, 0.22646071f, 0.25165543f, 
    0.06500711f, 0.05003840f, -0.06457207f, 0.08519795f, -0.04958373f, 0.10357013f, -0.06549668f, 0.09928540f, 
    0.18819471f, -0.20100531f, -0.21938227f, -0.10255938f, 0.12723416f, 0.09336479f, -0.01068088f, -0.05184257f, 
    -0.04035591f, 0.07447985f, 0.06993949f, 0.06352720f, 0.22570454f, 0.10471998f, -0.04967972f, -0.07494437f, 
    0.01095147f, -0.10027904f, 0.04702142f, 0.08891050f, 0.01576340f, -0.00201762f, -0.00327143f, 0.14578752f, 
    -0.10460798f, 0.21860130f, 0.12481435f, 0.15037856f, -0.07420580f, 0.09991847f, -0.10971204f, 0.16296358f, 
    0.03303446f, 0.08553377f, 0.21000300f, 0.12955807f, 0.02519277f, 0.14145462f, -0.16623068f, -0.17002408f, 
    0.03538865f, -0.04298276f, 0.07156941f, 0.14821923f, -0.00538246f, 0.03801448f, -0.09302193f, -0.06459984f, 
    -0.13790862f, -0.30284008f, 0.00915843f, 0.30247700f, -0.06772482f, 0.05104924f, -0.05230983f, 0.01812355f, 
    0.06351052f, 0.06229757f, 0.13606313f, -0.03941993f, 0.05782453f, 0.16913931f, -0.11690473f, 0.12753335f, 
    -0.03585564f, 0.02500895f, -0.01658902f, 0.01063569f, -0.06787220f, 0.11638921f, 0.07653779f, 0.21311547f, 
    0.19718148f, -0.24349976f, 0.06761245f, 0.07670412f, 0.00457841f, 0.00333248f, 0.08829246f, -0.02654372f, 
    0.04389092f, -0.06405398f, -0.21908972f, 0.11596648f, 0.13199447f, 0.02461933f, -0.04401879f, 0.25756544f, 
    -0.08898865f, -0.00412530f, -0.05488583f, -0.09485059f, -0.04716668f, -0.06666715f, -0.11999341f, 0.08821872f, 
    -0.17521985f, -0.10814945f, -0.04341029f, -0.07254629f, 0.15957752f, 0.14997682f, 0.08165105f, 0.04099892f, 
    0.04377480f, 0.03907881f, 0.04164249f, 0.06681733f, 0.09244336f, -0.05177796f, 0.13056515f, -0.02996076f, 
    0.05310293f, -0.05325978f, -0.07137019f, 0.02011205f, -0.00151782f, -0.06417297f, -0.14135131f, 0.02528757f, 
    0.14398126f, 0.07726777f, 0.20081510f, 0.08008606f, -0.00451253f, 0.18083757f, -0.07700253f, -0.02164363f, 
    0.01329166f, -0.05356735f, 0.18508302f, -0.10552973f, 0.29273579f, -0.21324664f, -0.11253302f, -0.12156615f, 
    -0.13382761f, 0.02732805f, 0.04211234f, 0.04033089f, 0.07844938f, 0.13118534f, 0.10869273f, -0.04218059f, 
    -0.00612971f, 0.01774059f, 0.07399195f, -0.00189027f, -0.02943245f, 0.02859710f, 0.15378609f, 0.13577034f, 
    0.05943278f, 0.01273849f, 0.05254449f, 0.11698551f, -0.40808842f, 0.17824872f, -0.14375702f, -0.05469056f, 
    0.11832793f, 0.01053544f, 0.18134627f, 0.05626830f, 0.07308960f, 0.08474552f, 0.00083129f, 0.11790735f, 
    -0.26582572f, 0.20438027f, -0.13266760f, -0.02348546f, 0.10047548f, -0.05027831f, -0.11359114f, 0.06517330f, 
    -0.01168175f, 0.05615360f, 0.17242737f, 0.10288922f, 0.09928771f, 0.04947202f, -0.12493814f, 0.25909978f, 
    0.05910052f, 0.11992430f, 0.02810101f, 0.10312409f, 0.01259593f, 0.01265705f, 0.04360922f, 0.01995241f, 
    -0.16267253f, -0.13833000f, -0.16814655f, -0.09321173f, -0.04770937f, 0.06363440f, 0.05527107f, 0.08093531f, 
    0.10922305f, 0.11261646f, -0.07058579f, 0.02401728f, -0.27635264f, 0.09554881f, 0.10331735f, 0.09180135f, 
    0.02380929f, 0.10070489f, 0.03413758f, 0.11679804f, 0.13028863f, -0.00884478f, 0.09346065f, 0.08494692f, 
    -0.23929964f, 0.16563548f, -0.04175054f, -0.00444632f, 0.03150863f, -0.07488862f, 0.12646045f, 0.02053280f, 
    0.05272211f, -0.02724256f, -0.05499236f, 0.08767394f, -0.03178965f, 0.00715972f, -0.11663763f, -0.06668744f, 
    0.21680281f, -0.00309372f, 0.08957539f, 0.07980924f, 0.07594609f, 0.08001970f, -0.08619568f, 0.03585334f, 
    -0.01883507f, 0.25861716f, 0.12062215f, 0.12195159f, 0.09233867f, 0.00839055f, 0.07127833f, 0.11530423f, 
    -0.01624979f, 0.10335007f, -0.01295476f, 0.02655434f, -0.05597205f, 0.14710046f, -0.05295911f, 0.00209773f, 
    0.04930237f, 0.05778582f, -0.03201767f, 0.16274117f, 0.02319271f, 0.06041994f, 0.15189128f, -0.02974395f, 
    -0.00561066f, -0.08651759f, 0.16122349f, -0.01023489f, 0.12539075f, 0.02375536f, 0.03278197f, -0.03782911f, 
    -0.02339690f, 0.02019163f, 0.02901743f, 0.08172582f, 0.29367858f, 0.00994891f, 0.20152169f, 0.29763368f, 
    0.07285151f, -0.06396866f, 0.01305669f, 0.05642864f, 0.07428971f, -0.00638896f, -0.00052439f, 0.07165637f, 
    -0.35374105f, 0.01650876f, -0.22516495f, 0.00847910f, -0.05568299f, -0.05323603f, 0.18111157f, -0.05368450f, 
    -0.01614775f, -0.01899618f, 0.02883647f, -0.02184543f, -0.04316843f, -0.09839281f, 0.28734317f, 0.04413228f, 
    0.04077647f, -0.00472286f, -0.03673233f, 0.05552145f, -0.04352074f, 0.06669564f, 0.14258295f, 0.13523869f, 
    -0.05780205f, 0.25874731f, 0.05974527f, 0.01259468f, 0.15317348f, 0.03289524f, 0.05291614f, 0.06897734f, 
    0.10978609f, 0.14397576f, 0.03097235f, 0.18130599f, 0.04440294f, -0.19488391f, 0.34495491f, 0.17318830f, 
    0.04563304f, 0.00680674f, -0.01983890f, 0.16005930f, 0.05838542f, -0.08481250f, -0.02437737f, 0.16225940f, 
    0.04164724f, -0.03521403f, -0.00463143f, -0.04916457f, -0.04214483f, -0.05794727f, 0.01079021f, 0.01615158f, 
    -0.01124778f, -0.04932032f, 0.02895044f, -0.00390506f, -0.04749728f, -0.03761318f, -0.03988368f, 0.00700529f, 
    -0.06286939f, -0.01245136f, -0.01788005f, -0.00501923f, -0.03188441f, 0.04720799f, 0.05565205f, 0.02067180f, 
    0.00719434f, 0.06401038f, -0.06024470f, 0.02504835f, 0.03595293f, -0.06252177f, 0.03866626f, -0.05115623f, 
    -0.02231919f, 0.02661822f, -0.00609499f, 0.04064771f, -0.04218156f, -0.03392662f, 0.03923099f, 0.05721514f, 
    0.00752259f, -0.06944005f, -0.03807611f, -0.02644208f, -0.06329487f, -0.05997825f, -0.03587618f, -0.02257351f, 
    -0.04248312f, -0.05184993f, -0.04797877f, -0.02043424f, 0.05873805f, -0.01646529f, 0.03277715f, 0.00726157f, 
    -0.03006891f, 0.00254548f, 0.04463283f, 0.02052101f, -0.00821905f, 0.06201638f, -0.05483197f, 0.00199482f, 
    0.04959612f, 0.03432436f, -0.00303331f, 0.06160523f, 0.05641687f, 0.05620018f, -0.02500965f, -0.07683780f, 
    0.05115151f, 0.00132115f, -0.00828789f, 0.02254348f, -0.07835691f, 0.03483105f, -0.00855980f, -0.06405019f, 
    -0.04220006f, 0.00046425f, -0.07948162f, 0.04004040f, -0.05076201f, 0.05127379f, -0.07938509f, 0.01725410f, 
    -0.03081386f, 0.01386251f, -0.03320821f, -0.04408870f, -0.01571324f, -0.00398011f, 0.03813087f, -0.06154955f, 
    0.03576371f, -0.05921747f, 0.03739131f, -0.07810378f, -0.01730732f, 0.04331630f, 0.05044314f, 0.03963607f, 
    0.00445703f, -0.04435274f, -0.06759927f, -0.06666069f, -0.02965337f, -0.07227640f, 0.01491917f, 0.00074154f, 
    -0.00363182f, 0.04137575f, -0.01435236f, -0.04477593f, 0.03728756f, -0.06546041f, 0.03895889f, -0.07174043f, 
    -0.03017434f, 0.02991149f, 0.04631444f, 0.05455251f, -0.03820266f, 0.04124309f, 0.01024056f, -0.07197819f, 
    0.04167929f, -0.06976625f, -0.04617590f, -0.01813490f, 0.04916244f, -0.04783279f, -0.04740313f, 0.00085489f, 
    -0.00986709f, -0.07669229f, -0.02697060f, -0.01063505f, 0.01159304f, -0.02282118f, -0.07644163f, 0.00335304f, 
    0.05535375f, -0.03551238f, -0.01829117f, 0.05047891f, 0.00183185f, -0.07609969f, 0.01011320f, -0.03853112f, 
    -0.05462954f, -0.04353129f, -0.04165051f, -0.05384913f, -0.06200467f, -0.04501900f, -0.06531084f, -0.02501506f, 
    0.01199157f, 0.03021627f, 0.00070462f, 0.03616682f, 0.03107691f, 0.03431240f, -0.05097162f, -0.01327079f, 
    0.04916350f, 0.05315039f, -0.01013584f, -0.04904146f, 0.05825743f, -0.03082688f, -0.01152836f, -0.03162758f, 
    -0.01546259f, -0.04021051f, 0.03977640f, 0.06001996f, 0.01439850f, 0.04559030f, 0.01087556f, 0.00283020f, 
    -0.05604799f, 0.06398492f, -0.01654663f, 0.03399049f, -0.04080673f, 0.02903060f, -0.03810371f, -0.07619517f, 
    -0.06174816f, 0.01135949f, -0.02469829f, 0.03536365f, -0.07285593f, -0.01382151f, 0.01440330f, -0.01952549f, 
    -0.03965380f, -0.02811424f, 0.03934910f, 0.05288103f, -0.04244166f, -0.07159148f, -0.01401118f, 0.03040677f, 
    -0.06596726f, -0.04739838f, -0.02355325f, 0.01753834f, -0.01779264f, -0.05296702f, 0.01456614f, -0.07166418f, 
    0.03957222f, -0.04903089f, -0.05410276f, 0.03247408f, -0.03350997f, -0.05721283f, -0.07906141f, -0.03682673f, 
    0.01468571f, 0.01392626f, 0.02725005f, -0.01263126f, -0.05373318f, -0.00095429f, -0.02644299f, -0.02287920f, 
    -0.04014939f, -0.06161350f, 0.01816192f, -0.00017714f, -0.02346798f, 0.03063398f, 0.02601045f, -0.02934737f, 
    -0.08287079f, 0.04801257f, 0.05821654f, -0.03286123f, -0.00508582f, -0.06096803f, -0.05294144f, -0.05804195f, 
    -0.01822264f, 0.03765300f, -0.06561874f, 0.00260127f, -0.04716405f, 0.03199862f, -0.03553877f, 0.03846942f, 
    -0.05738235f, 0.03460979f, -0.07230321f, 0.05955627f, -0.02773943f, -0.01921866f, 0.04873993f, -0.05430524f, 
    -0.05075857f, -0.03565069f, -0.04344923f, -0.02688369f, -0.07457488f, -0.05211636f, -0.07429923f, -0.04272896f, 
    -0.05190276f, -0.07435548f, 0.02977669f, -0.00591510f, 0.00645057f, 0.05918692f, -0.03529476f, -0.06900650f, 
    -0.00341987f, 0.05661159f, -0.05638918f, -0.08349642f, 0.03825257f, -0.06432195f, 0.06344104f, 0.04212143f, 
    0.05672391f, -0.08070833f, 0.02329104f, -0.01601769f, -0.05882671f, 0.01107858f, -0.07559664f, -0.00699119f, 
    0.01169070f, 0.04706952f, 0.04517302f, 0.01146977f, -0.01662615f, -0.01553268f, -0.07522269f, -0.01530697f, 
    -0.03271143f, -0.00282681f, -0.03364767f, -0.04470181f, -0.01834905f, -0.07629050f, 0.01683437f, -0.01077232f, 
    -0.05940281f, -0.01969986f, -0.08381983f, -0.01352850f, 0.04625966f, -0.02611954f, 0.05523521f, -0.01913478f, 
    -0.06440856f, 0.04606297f, -0.07091857f, -0.03635200f, 0.00417600f, 0.02600762f, -0.06544757f, 0.02663989f, 
    -0.05655079f, 0.00557904f, -0.03497218f, 0.05535294f, -0.05278892f, -0.02468035f, 0.00276203f, 0.00978263f, 
    -0.07689437f, -0.04634206f, 0.06021867f, 0.00117584f, 0.04644281f, -0.08959938f, -0.06475422f, -0.03200109f, 
    -0.07367004f, 0.00374374f, -0.04406159f, -0.02260634f, -0.08114666f, 0.03048562f, 0.02058027f, 0.01315716f, 
    -0.07920943f, -0.01822268f, 0.00833553f, -0.03089495f, -0.07265132f, 0.02714145f, 0.02101251f, 0.03186944f, 
    0.03762873f, -0.07777306f, 0.00928986f, -0.00546487f, -0.09649605f, -0.01174451f, -0.05573941f, 0.01561162f, 
    0.06594680f, -0.08584522f, -0.05304153f, 0.06137172f, -0.00012286f, 0.05071511f, -0.00841383f, -0.03873032f, 
    -0.06938761f, 0.05239275f, 0.02212973f, -0.00576457f, -0.05358784f, 0.04879532f, -0.05636652f, -0.04249131f, 
    0.20821159f, 0.04195739f, 0.01578976f, 0.11498046f, 0.17794339f, 0.04277232f, 0.04373443f, 0.08717461f, 
    -0.05534185f, 0.08249090f, 0.04114419f, -0.02914940f, 0.17706572f, 0.01914703f, -0.05953618f, 0.09549619f, 
    0.04891401f, 0.07752203f, -0.12771118f, 0.02223458f, -0.07117734f, -0.04136002f, 0.07871954f, 0.05118424f, 
    -0.08266992f, 0.11173455f, 0.03550953f, 0.07427669f, -0.02009299f, -0.00205807f, 0.07912835f, -0.16548516f, 
    -0.06138467f, -0.03232515f, -0.01810305f, -0.00398392f, -0.03550018f, -0.04311124f, 0.03305615f, -0.10964231f, 
    -0.23449399f, -0.01517232f, 0.05313607f, 0.03984204f, -0.03530024f, 0.05801861f, 0.01045076f, -0.01322749f, 
    0.29907358f, 0.16439484f, 0.21056554f, -0.24731594f, 0.16385292f, 0.08315739f, 0.08504403f, 0.12192903f, 
    -0.05705319f, 0.06843318f, 0.03411455f, -0.09561189f, -0.13024753f, 0.13933407f, -0.08591840f, 0.14657104f, 
    -0.16601165f, 0.05387376f, -0.11859688f, 0.05927557f, -0.00689047f, 0.12712072f, -0.06847768f, -0.02730585f, 
    0.22196566f, -0.11267802f, 0.13040447f, 0.20798092f, 0.03233450f, 0.00984504f, -0.13120824f, 0.15513733f, 
    0.00284174f, 0.08367795f, -0.04318955f, -0.16711676f, 0.00252343f, 0.05577692f, -0.11089468f, -0.02496480f, 
    -0.03962888f, 0.11139970f, -0.11930270f, 0.07352862f, 0.08361007f, -0.03821760f, -0.00236034f, 0.13676372f, 
    -0.40701681f, -0.03969098f, 0.12687209f, -0.22084759f, -0.12146829f, -0.09625732f, 0.11191016f, -0.02303946f, 
    -0.02109536f, -0.01757076f, 0.14866231f, 0.03616399f, -0.03438565f, 0.09981541f, 0.17606346f, 0.10613239f, 
    -0.04235383f, -0.13229445f, 0.06458697f, 0.04641074f, -0.16569500f, -0.22579004f, -0.03006394f, -0.15590367f, 
    0.16444807f, 0.07791869f, 0.02594825f, -0.15333113f, 0.04179522f, 0.00240765f, -0.05001982f, 0.05926729f, 
    0.08823255f, 0.00964475f, -0.01995653f, -0.01560450f, 0.02220557f, 0.01105044f, 0.02546124f, -0.11553159f, 
    0.03939281f, 0.16082874f, 0.00944044f, -0.07380261f, -0.04777673f, -0.04067412f, 0.03127922f, 0.08996770f, 
    0.34027496f, 0.30597845f, 0.17277542f, -0.24545503f, -0.06756769f, 0.04229019f, 0.05541393f, 0.00871832f, 
    0.11102758f, 0.00880620f, 0.08196513f, 0.03974311f, -0.09894007f, 0.14475511f, -0.01193886f, 0.01500729f, 
    -0.02013251f, 0.02464891f, -0.01466246f, 0.02574728f, 0.08469469f, -0.03045672f, 0.03893141f, 0.02753532f, 
    -0.11583982f, -0.01601066f, 0.05261198f, 0.25469720f, 0.01102118f, -0.09486233f, -0.01485578f, -0.09043348f, 
    -0.04761727f, 0.02985773f, 0.03569233f, -0.11187305f, -0.09527709f, 0.13457009f, -0.03940020f, -0.20846422f, 
    -0.13724671f, -0.10937667f, 0.02290786f, -0.00194945f, 0.01888487f, 0.04518908f, 0.07620484f, -0.08687063f, 
    0.38115135f, -0.02749988f, 0.20459212f, -0.09215797f, 0.06199298f, -0.10297491f, -0.02016767f, -0.08084003f, 
    -0.03447472f, -0.02927019f, 0.03330895f, 0.04546347f, -0.10079537f, -0.14449833f, -0.08309937f, -0.01689979f, 
    0.09699968f, -0.10011598f, 0.06764457f, 0.01904503f, -0.05544699f, -0.15148254f, -0.16886628f, 0.01758598f, 
    0.04079500f, 0.14984633f, -0.08817407f, -0.04041878f, 0.00226105f, -0.00871004f, 0.01639262f, 0.11784679f, 
    0.03160933f, 0.14411241f, -0.01801522f, 0.02014644f, 0.16924390f, 0.34265494f, 0.06920169f, -0.12897781f, 
    -0.13774861f, -0.02785986f, -0.09455054f, 0.06551275f, -0.07504988f, 0.08611733f, -0.03393198f, 0.04654786f, 
    -0.31535974f, -0.06147487f, 0.09837377f, 0.02892055f, -0.03702984f, 0.07513981f, 0.09239939f, 0.06263189f, 
    -0.11051881f, 0.15232272f, -0.00017614f, 0.18576674f, -0.16725032f, -0.01660274f, -0.04516126f, 0.06506687f, 
    0.09446979f, -0.01076388f, 0.02431879f, -0.19402198f, -0.01884489f, -0.24261416f, -0.01234164f, 0.02894044f, 
    0.22162510f, 0.06782354f, 0.05686685f, 0.01945066f, 0.05286739f, 0.04232500f, -0.07520423f, 0.19692080f, 
    -0.08229332f, 0.14837602f, 0.06934270f, -0.00675916f, 0.02410537f, -0.03935824f, -0.08066280f, 0.00372133f, 
    0.00755795f, -0.08997098f, -0.01745084f, -0.12261236f, -0.11277284f, -0.17927350f, 0.14892727f, -0.23344035f, 
    0.31235453f, 0.16410814f, 0.15499261f, -0.09188761f, 0.00133478f, 0.07354231f, -0.04505921f, 0.05662014f, 
    0.04640745f, 0.01223268f, 0.03158771f, 0.04270024f, -0.08420105f, -0.00122711f, 0.18553239f, -0.16356108f, 
    0.10097324f, -0.00274281f, 0.09687506f, 0.04039039f, 0.01728027f, 0.08431394f, 0.21215767f, 0.32384980f, 
    0.04473700f, 0.19604836f, -0.14670871f, 0.10290491f, -0.05401275f, -0.00234788f, 0.08454232f, 0.26114371f, 
    0.03741977f, -0.04287542f, -0.01291411f, -0.00236692f, -0.08160479f, 0.02138497f, 0.10727628f, 0.06279784f, 
    -0.03753934f, -0.13533485f, -0.12404376f, 0.00524198f, 0.01589595f, -0.05228254f, -0.05323843f, -0.02129689f, 
    0.06373803f, 0.21776040f, -0.06440121f, -0.27164209f, 0.09814700f, 0.10315548f, 0.01044889f, 0.11783497f, 
    -0.02211046f, -0.00415605f, 0.11413356f, 0.07911944f, -0.00477339f, 0.04831676f, -0.06451039f, 0.10349672f, 
    0.07228717f, 0.06229182f, 0.12978782f, -0.13948804f, -0.05387364f, -0.22258919f, -0.09167247f, -0.24619719f, 
    0.17302750f, 0.10167917f, 0.02666993f, 0.02974420f, -0.01047780f, 0.16934942f, -0.08988420f, 0.00106284f, 
    0.03283164f, 0.12476397f, 0.00651512f, -0.08652112f, 0.04875926f, -0.12747359f, 0.04873278f, 0.25884891f, 
    0.15074117f, 0.15503684f, -0.15772413f, 0.01188821f, 0.06528483f, -0.02959093f, -0.02235082f, -0.01245266f, 
    0.02714880f, -0.20854852f, -0.10223628f, -0.00433699f, 0.06601386f, 0.02112882f, -0.12800908f, -0.03202840f, 
    0.02169677f, 0.01148425f, -0.06582220f, -0.02486800f, 0.14398755f, -0.11313534f, -0.10019792f, 0.03678712f, 
    -0.13611960f, 0.01640770f, 0.02180884f, 0.05965184f, -0.03652135f, -0.00864150f, -0.00103858f, -0.04895207f, 
    0.27861089f, 0.14027040f, -0.16830853f, -0.09524707f, 0.08170769f, 0.10927054f, 0.07871557f, 0.08307732f, 
    0.02904946f, 0.11280879f, 0.02387452f, 0.04821738f, -0.36762577f, -0.00151187f, 0.02889856f, -0.19082491f, 
    0.04231185f, -0.06143205f, -0.01947975f, -0.05571693f, 0.02148127f, 0.14142023f, 0.10164366f, 0.06402224f, 
    -0.11028636f, -0.04168467f, 0.08691460f, 0.26793185f, -0.04465690f, -0.08931597f, 0.03367019f, 0.05587092f, 
    -0.07270176f, -0.04468943f, 0.06548883f, -0.05741263f, -0.18373655f, -0.02083398f, 0.30483669f, 0.00620945f, 
    0.03963600f, 0.11431593f, -0.05853083f, -0.07839389f, -0.00104547f, -0.08235040f, -0.01677613f, 0.07204264f, 
    0.09707851f, -0.01689898f, -0.11368798f, 0.01153778f, 0.09763718f, 0.02226454f, 0.10532277f, 0.00967052f, 
    -0.02203402f, 0.04505603f, 0.03295412f, 0.11098141f, 0.09651845f, -0.07649580f, 0.05945171f, 0.14170974f, 
    0.07828552f, 0.04183823f, -0.08151817f, -0.01717336f, -0.00591498f, 0.03906545f, 0.04848969f, -0.11522061f, 
    0.12372356f, 0.03795690f, -0.03838716f, -0.23836352f, 0.10144950f, 0.10658666f, 0.00174157f, -0.02603767f, 
    0.03301127f, 0.03839124f, 0.14342432f, 0.09160600f, 0.10104659f, -0.01807979f, 0.11423939f, -0.17323424f, 
    0.05127978f, -0.03560572f, -0.01568831f, 0.01737598f, 0.10841154f, 0.11490162f, -0.07872660f, 0.18330817f, 
    -0.14337692f, 0.02014135f, -0.04214037f, 0.10619853f, -0.05396851f, -0.04104040f, 0.12240089f, 0.22622918f, 
    -0.03175887f, 0.05908335f, -0.01257334f, -0.12708296f, 0.04297514f, 0.08982833f, -0.04984429f, 0.02579723f, 
    0.09657219f, 0.05205276f, -0.01218308f, 0.02864620f, 0.03207254f, 0.05182382f, 0.04525748f, -0.06573018f, 
    0.01360149f, -0.00192219f, 0.06099423f, 0.19548243f, 0.06719370f, -0.04964251f, 0.01794873f, 0.12736927f, 
    0.05398013f, -0.07651477f, 0.04421015f, -0.11852545f, -0.17815776f, 0.20444815f, 0.12514344f, 0.03204979f, 
    -0.03299619f, 0.08632246f, -0.16085000f, 0.03808769f, 0.17245153f, 0.02706115f, 0.08093971f, -0.08278177f, 
    0.13496910f, -0.07031450f, 0.16177516f, -0.15240668f, -0.06257212f, -0.00771309f, -0.03690925f, -0.08137107f, 
    -0.07016183f, 0.00714067f, 0.00248069f, -0.04072863f, -0.20164706f, 0.19514668f, -0.07369517f, -0.18356195f, 
    0.13367707f, 0.02505682f, -0.19692540f, -0.07368243f, -0.00270270f, -0.02803851f, 0.15563785f, 0.04873301f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04032765f, -0.11623943f, 0.05488800f, -0.04156243f, -0.01797307f, -0.01611260f, 0.00850112f, 0.01201728f, 
    -0.03643332f, -0.03495576f, 0.06940043f, 0.00597686f, -0.01152715f, 0.07987895f, -0.00137501f, 0.04802045f, 
    -0.01273269f, -0.12522969f, 0.08065494f, 0.00771581f, -0.04233705f, 0.09382288f, 0.04212106f, 0.12178256f, 
    0.13003881f, 0.01494526f, -0.01035529f, 0.00152462f, 0.10224368f, 0.00738330f, 0.04072926f, 0.08766425f, 
    -0.01380077f, 0.04096595f, 0.06840035f, -0.04742895f, 0.15890282f, 0.07840529f, 0.04057549f, -0.05217763f, 
    0.02914281f, 0.00144469f, 0.06909608f, -0.03117087f, -0.01360198f, 0.15628031f, -0.01847780f, -0.04557330f, 
    0.05122789f, 0.09982406f, 0.11034244f, 0.05845763f, 0.14096394f, 0.00403330f, 0.04256397f, 0.10181062f, 
    -0.02510905f, 0.07269486f, 0.16350764f, -0.06126372f, 0.04966637f, -0.09958815f, -0.05185769f, 0.06429419f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.44710177f, -0.32187572f, 0.04890857f, 0.15955709f, 0.06423773f, 0.00834861f, 0.17845586f, 0.00234655f, 
    -0.03304256f, -0.13725047f, -0.15065022f, 0.00865117f, 0.07138742f, -0.03344752f, -0.14859648f, 0.26620108f, 
    -0.00001131f, 0.19088341f, -0.31137875f, 0.14032911f, -0.09713893f, 0.15980701f, -0.12165137f, 0.44326997f, 
    0.04795738f, -0.20212716f, -0.11379071f, 0.05009314f, 0.14686972f, 0.11669399f, -0.15869868f, -0.05874124f, 
    -0.15613389f, -0.09703225f, 0.04601426f, 0.03592418f, -0.09669709f, 0.19912860f, -0.13282061f, 0.10054411f, 
    -0.01962881f, 0.14834213f, 0.13777210f, 0.00768557f, 0.03211281f, -0.15364198f, -0.09664186f, -0.22690807f, 
    -0.10473882f, 0.44945076f, 0.26425520f, 0.09651075f, -0.12045486f, 0.21563800f, -0.38649157f, 0.18989189f, 
    0.05998985f, 0.14471267f, -0.17686424f, -0.00847464f, -0.04022460f, 0.23794377f, -0.04116985f, 0.22192660f, 
    -0.00054006f, 0.00275426f, -0.11702578f, 0.01005284f, 0.05922921f, 0.07107110f, 0.08320852f, -0.08314694f, 
    -0.05784157f, -0.04490457f, 0.01756378f, -0.10904059f, -0.12311924f, 0.00199999f, -0.03968163f, 0.07216273f, 
    0.09068247f, 0.04366204f, -0.01571512f, -0.02978897f, 0.09529345f, -0.07857899f, 0.00834540f, -0.05421371f, 
    -0.04064268f, -0.11804999f, -0.03806459f, -0.05725162f, -0.12452266f, 0.06450434f, 0.00649035f, -0.09076406f, 
    0.07437948f, -0.07329833f, -0.03509514f, 0.04097874f, -0.05476599f, -0.05651584f, 0.00577093f, 0.06891659f, 
    0.04976534f, -0.13664189f, 0.05159451f, -0.02420206f, -0.02827386f, 0.08622260f, 0.09021059f, 0.02334932f, 
    0.00116553f, -0.11608766f, -0.10311084f, 0.02798930f, -0.08411796f, -0.11295192f, -0.08082039f, -0.08805623f, 
    -0.04142267f, 0.00358846f, -0.04117697f, -0.08214784f, -0.05641824f, 0.04775715f, -0.05008437f, 0.05138691f, 
    -0.11409184f, 0.17939277f, 0.04820878f, 0.16630057f, -0.06232424f, -0.03855470f, -0.17432827f, 0.00850894f, 
    -0.06704988f, -0.01991190f, 0.23309296f, 0.09712122f, 0.07931828f, -0.30404606f, 0.25271341f, 0.09168175f, 
    -0.44777504f, 0.20353732f, 0.12680517f, -0.29838559f, -0.03963528f, -0.36786026f, -0.16194212f, 0.02518611f, 
    -0.11820519f, -0.01609839f, -0.29162091f, -0.33697072f, 0.12843153f, 0.09014221f, 0.12764424f, 0.22073860f, 
    0.01298520f, 0.16366701f, -0.40410700f, 0.12650576f, 0.19186220f, 0.04242224f, 0.26508087f, -0.12604763f, 
    -0.10057802f, 0.01445751f, 0.03030560f, 0.06090265f, 0.01583663f, -0.24623279f, -0.04417610f, 0.07437962f, 
    0.03863640f, -0.18615991f, -0.27987069f, 0.12875581f, 0.05543491f, 0.05399097f, -0.00580856f, 0.17879845f, 
    -0.05144589f, 0.06713562f, -0.00633051f, -0.10948943f, 0.08892825f, 0.18538007f, 0.11586038f, -0.38271642f, 
    -0.05530874f, -0.02126510f, 0.11030473f, -0.01643528f, -0.03568906f, 0.03896238f, 0.02427952f, 0.00296730f, 
    0.05106191f, 0.06541784f, 0.01167007f, -0.07982902f, -0.05658327f, 0.10563596f, -0.05947435f, -0.09029338f, 
    0.00782103f, 0.04993670f, -0.04040286f, 0.04945181f, 0.11895894f, 0.07328299f, -0.05922025f, 0.01584002f, 
    0.01000082f, -0.01699511f, 0.01512250f, 0.02235549f, 0.00633328f, -0.02100156f, 0.01007318f, 0.03555611f, 
    -0.04976470f, -0.12126507f, -0.07122982f, 0.08104263f, -0.14196925f, -0.01711586f, -0.13773081f, 0.01425761f, 
    0.11386856f, -0.05980593f, -0.09234701f, 0.06713508f, -0.12398192f, 0.04846628f, -0.00324479f, -0.08506724f, 
    -0.10089292f, 0.05884175f, 0.02486667f, -0.06673712f, -0.02699400f, -0.01454883f, -0.02243230f, -0.00302078f, 
    0.09174386f, 0.03140106f, -0.12270453f, 0.03610873f, 0.02869746f, -0.08223063f, -0.08291602f, -0.06860910f, 
    0.11019613f, 0.04755152f, -0.13824958f, 0.18477644f, -0.02889621f, -0.08053647f, -0.30114418f, 0.03144163f, 
    0.11894426f, -0.15830767f, 0.22233433f, 0.01649696f, 0.19480999f, -0.09159179f, 0.16563269f, 0.06031879f, 
    -0.00072045f, 0.21732098f, -0.07054733f, -0.11244913f, 0.08756815f, 0.03548327f, 0.12654044f, -0.03600936f, 
    -0.03551645f, -0.03352985f, -0.00134478f, -0.21030587f, 0.19513907f, -0.03427665f, 0.05285066f, 0.23246963f, 
    0.13081907f, 0.04007785f, -0.04292274f, 0.34907502f, 0.07188664f, 0.12015083f, -0.11776374f, 0.10262418f, 
    -0.00735154f, 0.18513554f, -0.05997167f, 0.10209721f, -0.10139350f, -0.22013521f, 0.07482512f, -0.48839676f, 
    -0.06950226f, 0.01293965f, -0.11871659f, 0.16867366f, -0.00728969f, -0.00422128f, -0.32394987f, 0.01441032f, 
    0.03311331f, 0.18941508f, -0.01073597f, 0.04294674f, -0.01035754f, 0.09532631f, -0.16161712f, 0.05777354f, 
    0.04170865f, -0.04156190f, 0.00209832f, -0.04897967f, 0.10435584f, -0.11884733f, -0.01980686f, -0.08528149f, 
    -0.07644957f, 0.08708832f, -0.05435580f, 0.01488884f, -0.08143264f, -0.04134877f, 0.05649199f, 0.10025391f, 
    0.00928913f, -0.12019119f, -0.10721251f, 0.03786790f, 0.01343448f, -0.08112307f, -0.07075302f, 0.10907131f, 
    0.08140677f, -0.01769756f, 0.10969400f, -0.06376664f, -0.08958559f, 0.03909191f, -0.02271184f, -0.10223947f, 
    -0.08464238f, -0.11392748f, 0.05539744f, 0.08435221f, -0.01303111f, -0.06587072f, -0.07300076f, -0.00352632f, 
    -0.12352756f, 0.10147485f, -0.11651990f, -0.08742386f, 0.01149923f, -0.12424113f, -0.06938177f, -0.06998622f, 
    0.10755889f, -0.08431552f, 0.08515446f, -0.10602525f, -0.05526628f, -0.07012345f, 0.11163779f, 0.02896553f, 
    0.04400638f, -0.10429563f, 0.10132442f, 0.10901026f, 0.00057314f, 0.01203409f, -0.07105926f, 0.00352533f, 
    -0.29257318f, 0.41145846f, -0.10465815f, 0.22962965f, -0.03007090f, -0.04213399f, 0.21311106f, 0.02486505f, 
    0.00263327f, 0.46971378f, -0.15969317f, 0.00280929f, -0.01648304f, -0.07267027f, 0.05982940f, -0.23579966f, 
    0.22942421f, -0.14521392f, 0.24662274f, 0.15848014f, -0.04985109f, 0.06947501f, 0.03606568f, 0.03751675f, 
    0.20542006f, 0.17566301f, -0.07827967f, 0.07331417f, -0.07675048f, -0.10493450f, -0.00645950f, 0.18140347f, 
    0.14121285f, 0.00085992f, -0.24880108f, -0.08896555f, 0.13363583f, 0.03300617f, -0.01992883f, -0.06203424f, 
    -0.18872748f, 0.15217449f, 0.21312226f, 0.04984157f, -0.15678917f, 0.09774256f, 0.04214188f, -0.08094860f, 
    0.02566162f, -0.21195257f, -0.00763786f, -0.25205746f, 0.09158746f, 0.00682609f, 0.05776453f, -0.25710833f, 
    -0.10427197f, 0.19926441f, 0.15907939f, -0.06249721f, 0.03672545f, -0.34541097f, 0.21667753f, 0.00788872f, 
    -0.21656609f, 0.32129315f, -0.00891559f, -0.16799530f, -0.02332434f, -0.07911696f, 0.31266364f, 0.00901586f, 
    -0.01516887f, 0.04183599f, 0.03974279f, 0.01030854f, -0.10003116f, 0.04810732f, 0.26405808f, -0.22483140f, 
    0.06433879f, -0.00892818f, 0.30243653f, 0.03725605f, -0.08877411f, -0.04435980f, 0.51200575f, 0.02044995f, 
    -0.15714954f, -0.19125924f, 0.00446530f, 0.34126809f, 0.02106883f, -0.04910797f, -0.05224358f, -0.08014417f, 
    0.06813072f, -0.24715489f, 0.06694660f, -0.03039694f, -0.13052727f, 0.08796138f, 0.43379366f, -0.10611842f, 
    0.25377652f, -0.10696192f, 0.07914501f, 0.03237971f, 0.16868629f, -0.13007805f, -0.05255929f, 0.28240028f, 
    -0.05628688f, 0.05956507f, 0.21733227f, 0.03124850f, 0.30290374f, 0.17680436f, 0.40324712f, -0.11756624f, 
    0.09839600f, -0.03601123f, 0.09599487f, 0.00644305f, 0.08730176f, 0.05359599f, 0.29169801f, 0.05166075f, 
    0.17660084f, -0.20883700f, 0.34225586f, -0.20022643f, -0.08488359f, -0.09481853f, 0.00237296f, -0.08794447f, 
    -0.03298613f, -0.07922532f, 0.00019368f, -0.03560753f, 0.10136777f, 0.21199405f, -0.23467858f, -0.00764809f, 
    0.31844217f, 0.03943494f, -0.09020885f, 0.13371469f, 0.07732579f, 0.40111610f, 0.24340209f, 0.02139325f, 
    -0.04928941f, 0.22498745f, 0.19545566f, 0.14826895f, -0.15178922f, 0.07325964f, -0.04268207f, -0.18769160f, 
    -0.00463525f, -0.17354430f, 0.39654744f, 0.14332320f, 0.00058379f, 0.07148799f, -0.16503587f, -0.12103844f, 
    0.09980001f, 0.01370579f, 0.09668715f, -0.05101420f, 0.06343232f, 0.20536897f, -0.07318255f, 0.04380110f, 
    -0.03109847f, 0.03216092f, 0.25038388f, 0.07133739f, 0.20719129f, 0.18328507f, -0.22678979f, 0.14613423f, 
    0.06932630f, -0.07946406f, -0.05277133f, -0.05286951f, 0.01600405f, 0.08515795f, -0.32526118f, 0.39438474f, 
    0.06530079f, 0.21946594f, -0.26280281f, 0.28987420f, 0.08310689f, -0.02265318f, 0.18297030f, 0.07139964f, 
    -0.05790633f, 0.38754717f, -0.10100065f, 0.00226404f, 0.04730591f, 0.12023420f, 0.16331290f, 0.32110533f, 
    0.13235974f, 0.05873620f, -0.11718096f, -0.00032706f, 0.02558060f, 0.01067756f, -0.52177978f, 0.10781120f, 
    0.11535132f, -0.03097503f, 0.15169218f, -0.14454132f, 0.04128552f, -0.10186118f, -0.30936339f, 0.12702730f, 
    0.19514020f, 0.02103423f, -0.17155384f, -0.03692470f, -0.22645217f, 0.13043797f, -0.14341570f, -0.01640174f, 
    0.20217536f, 0.17189774f, 0.23269102f, 0.04394360f, -0.18421890f, -0.12948389f, 0.08570002f, -0.27150774f, 
    0.08782707f, -0.04118323f, 0.18026216f, -0.32094792f, -0.08555226f, -0.06233338f, -0.12736291f, -0.07731673f, 
    0.05847408f, 0.25723413f, 0.10982433f, -0.07355797f, 0.10754693f, -0.10337663f, 0.29472467f, -0.16194054f, 
    -0.09010369f, 0.00719305f, 0.04271048f, -0.05327452f, -0.11998779f, 0.01280060f, 0.11212013f, 0.11815003f, 
    0.10800797f, -0.04624641f, -0.07277086f, -0.01097776f, -0.08161904f, -0.04832729f, -0.04629259f, -0.08968145f, 
    0.07943872f, -0.04805898f, -0.07593466f, 0.04135748f, -0.09718604f, -0.01323996f, -0.04247016f, -0.07882392f, 
    0.04358300f, 0.00144344f, 0.05071077f, -0.06367566f, 0.01661819f, 0.07157455f, -0.11565857f, 0.04351542f, 
    -0.02954109f, 0.09383447f, -0.09279197f, 0.06901478f, 0.06369670f, 0.02253622f, 0.05339697f, 0.03016916f, 
    0.02125307f, -0.08941708f, 0.00126018f, 0.05794035f, 0.00573936f, -0.02250272f, -0.09592021f, 0.05516501f, 
    0.07391503f, -0.06583919f, -0.00345611f, 0.10004484f, -0.11526187f, 0.02789663f, 0.08235903f, -0.11709920f, 
    0.11856399f, -0.06481875f, -0.06677803f, 0.03084169f, -0.00829427f, 0.02273219f, -0.05468292f, 0.07382707f, 
    -0.07426526f, -0.11541908f, 0.10360094f, 0.16424274f, -0.07454553f, 0.02454849f, 0.10801012f, 0.05901918f, 
    -0.07796253f, -0.14945312f, 0.27582172f, 0.11194515f, -0.05138721f, 0.08993508f, -0.21843205f, -0.14946805f, 
    -0.23273750f, 0.16398872f, 0.10753429f, -0.02914692f, 0.00976987f, -0.25270715f, 0.32787481f, 0.39945570f, 
    0.10548396f, -0.21809387f, -0.20051138f, 0.10739691f, 0.14982115f, 0.03328429f, 0.17859599f, -0.02897469f, 
    -0.19000560f, -0.05646534f, 0.21143614f, 0.20456421f, 0.30733857f, 0.29961586f, 0.38258702f, -0.04771765f, 
    -0.24416016f, 0.17724732f, -0.03222314f, -0.05879427f, 0.22582200f, -0.01736117f, 0.00062939f, 0.02525098f, 
    -0.06207247f, 0.19065736f, 0.26084492f, 0.15395056f, -0.06402402f, -0.17621420f, 0.28852797f, 0.10041744f, 
    0.00560809f, 0.03915446f, -0.01335100f, -0.01085260f, 0.08133595f, -0.01219574f, -0.00120583f, -0.01610608f, 
    -0.09282218f, -0.11164156f, 0.11307871f, 0.03183035f, 0.07720699f, -0.03473888f, 0.06810588f, 0.08778667f, 
    0.04806112f, -0.04527208f, -0.11546386f, -0.06148370f, -0.01870997f, 0.00213266f, 0.10213787f, 0.02794749f, 
    0.03997091f, -0.09282160f, 0.10117674f, -0.09896251f, -0.05193645f, -0.00240468f, 0.07167876f, 0.00691410f, 
    -0.01457925f, -0.06217147f, 0.04716528f, 0.00658276f, -0.05786225f, -0.01893943f, -0.08624014f, -0.05681816f, 
    -0.08596761f, 0.04226696f, 0.09980734f, -0.09925683f, 0.04996114f, -0.11980856f, 0.07107245f, 0.07287481f, 
    -0.00526063f, 0.09237814f, -0.07392491f, 0.01973723f, -0.04212989f, 0.01557976f, -0.06158640f, 0.02099233f, 
    0.01189192f, 0.01832471f, -0.10258923f, 0.05801066f, -0.10628675f, -0.04824856f, -0.06423991f, -0.12121638f, 
    0.04702646f, 0.08960932f, -0.01433302f, 0.00289863f, 0.05525554f, -0.04426381f, -0.05958093f, -0.12122259f, 
    -0.02476577f, 0.32953766f, 0.05007077f, -0.18107316f, 0.03120218f, -0.03197132f, 0.00776041f, -0.06498069f, 
    0.02498633f, 0.00111583f, -0.28287768f, -0.08263607f, -0.05516373f, 0.17915043f, 0.09444194f, 0.01399658f, 
    0.10253172f, 0.08047742f, 0.14984812f, 0.32219627f, 0.06160568f, -0.06494950f, 0.19682114f, -0.16600768f, 
    -0.00181931f, -0.01986522f, 0.41003451f, 0.07249092f, 0.11927070f, 0.10163049f, 0.22118127f, -0.02959248f, 
    0.12679559f, -0.05749782f, 0.21924502f, 0.16406009f, -0.13606679f, -0.05517220f, -0.15006220f, 0.07799961f, 
    0.15616654f, -0.04355068f, -0.19804411f, -0.07405172f, 0.10493688f, 0.28759673f, 0.09206782f, 0.30485061f, 
    -0.02688400f, 0.05012490f, -0.16255997f, -0.13040930f, 0.14034250f, -0.05473012f, 0.28183410f, 0.10852221f, 
    0.00096744f, -0.25509813f, 0.10425764f, 0.00076890f, 0.04921306f, -0.20574358f, 0.31380206f, 0.10742269f, 
    -0.15736605f, 0.03603682f, 0.11473725f, -0.00812986f, 0.00408630f, -0.02277401f, -0.07344214f, 0.02756359f, 
    0.09242982f, -0.07164362f, -0.04443364f, -0.02846397f, -0.15030813f, 0.16673017f, -0.17266560f, 0.16565768f, 
    -0.14478745f, -0.19781950f, 0.15865727f, -0.16028820f, -0.06747058f, 0.14914566f, 0.12081655f, 0.10080788f, 
    0.09053037f, 0.04315896f, -0.09650490f, -0.04315641f, 0.12707281f, -0.01090945f, 0.06235717f, 0.38480908f, 
    -0.01812769f, 0.19861750f, 0.00313485f, -0.11979151f, 0.10987576f, 0.17828624f, 0.05368932f, 0.01676556f, 
    -0.19872402f, -0.02707751f, 0.06180593f, -0.08456159f, 0.36158526f, 0.24711159f, -0.02419340f, -0.02640709f, 
    0.04926234f, 0.03655332f, -0.01449140f, 0.11730609f, 0.11718944f, -0.32224545f, 0.03795374f, 0.15307271f, 
    0.08782901f, 0.17887370f, 0.18389204f, -0.07232584f, -0.06459650f, 0.01642008f, -0.18512931f, -0.09171155f, 
    0.24365920f, -0.03675988f, -0.23786528f, 0.10384464f, 0.04111558f, -0.03997229f, -0.25390410f, -0.04550615f, 
    0.07495849f, -0.01659687f, 0.02953860f, -0.05654023f, 0.44315305f, -0.06680088f, 0.22374764f, -0.13789125f, 
    0.14128201f, 0.11667453f, -0.06511979f, 0.01860140f, 0.01249215f, 0.18775767f, 0.36393994f, 0.16873713f, 
    0.14962056f, 0.31476340f, -0.03371443f, -0.16098914f, 0.06867171f, -0.09027973f, -0.00739124f, 0.30807731f, 
    -0.07281288f, 0.23519059f, -0.04743187f, 0.25309226f, 0.07468896f, 0.18985467f, -0.13959704f, 0.07941072f, 
    -0.08756533f, 0.24981333f, -0.00119666f, 0.03810412f, -0.13437469f, -0.11803611f, -0.08053492f, -0.37430057f, 
    -0.03810035f, -0.07132772f, -0.21810378f, -0.05486067f, -0.18254210f, -0.23810458f, -0.03579168f, 0.04692525f, 
    -0.09473658f, 0.26361743f, 0.12995550f, 0.08342567f, 0.04103777f, -0.12446283f, -0.13837644f, 0.31814978f, 
    0.23257239f, -0.04359500f, 0.00795882f, 0.01286720f, 0.01480571f, -0.08403938f, 0.13934223f, -0.09217195f, 
    0.06250135f, 0.10905358f, -0.07584804f, 0.07623930f, 0.25987568f, 0.09401906f, 0.15485343f, 0.23945400f, 
    0.04792299f, -0.19434540f, 0.15103954f, 0.13195947f, 0.01371841f, 0.22121678f, -0.36843821f, -0.30718067f, 
    0.18838677f, 0.23838729f, 0.12400819f, 0.09924982f, -0.10789738f, 0.10523909f, -0.08611330f, -0.03156756f, 
    0.17552359f, 0.03597561f, -0.03304613f, -0.03100479f, -0.22312580f, 0.05364627f, -0.31617719f, -0.01629943f, 
    0.26688853f, -0.03167642f, 0.21052200f, -0.08323582f, -0.26170960f, 0.04083111f, 0.11494638f, -0.18623532f, 
    -0.10195816f, -0.21351467f, -0.06464883f, -0.25534108f, 0.13522053f, 0.23159775f, -0.22743310f, 0.03131787f, 
    -0.00086931f, -0.00534862f, 0.17335476f, 0.00514728f, 0.07113252f, 0.07963531f, 0.31071094f, 0.25819308f, 
    0.33825207f, -0.13686199f, 0.20500477f, -0.12104663f, -0.11069079f, -0.04994525f, 0.06939132f, 0.02296368f, 
    -0.07260985f, 0.10510219f, 0.21574742f, -0.08424652f, -0.02039156f, 0.23529583f, -0.15011062f, 0.33142021f, 
    0.19171399f, -0.01858384f, -0.07364298f, 0.24743424f, 0.07432148f, 0.30607536f, -0.45289785f, 0.24704762f, 
    0.09541787f, 0.19776390f, 0.29745883f, 0.27289307f, -0.18503882f, -0.06294385f, -0.49974915f, -0.08119399f, 
    -0.06173203f, -0.18408699f, -0.15284486f, -0.09673610f, -0.21364255f, -0.03554052f, 0.16231893f, 0.01833701f, 
    0.45630473f, -0.08638278f, 0.12622966f, 0.06487952f, -0.06732502f, -0.13702768f, 0.10012303f, -0.19228649f, 
    0.10049661f, 0.08765347f, 0.17288414f, 0.04247768f, -0.07250609f, 0.28597796f, -0.10311527f, -0.00445047f, 
    -0.00346536f, 0.08986261f, -0.04899471f, -0.11319695f, -0.09032302f, 0.44109344f, -0.11930906f, 0.19333009f, 
    0.38540754f, -0.35395822f, 0.27549326f, -0.08324086f, -0.11365570f, 0.03861877f, 0.15016958f, -0.05326895f, 
    0.06975541f, -0.22476122f, 0.11377840f, -0.00407593f, -0.01714535f, 0.15562706f, 0.06030930f, 0.02967078f, 
    -0.13037425f, -0.03008001f, -0.09954185f, -0.06168940f, -0.02413175f, 0.05851960f, 0.04102421f, -0.09604118f, 
    -0.13187878f, -0.30110574f, -0.19059424f, 0.25516412f, -0.08393946f, -0.05093385f, 0.26822907f, -0.46982181f, 
    -0.24169774f, 0.01568508f, 0.30730456f, 0.21641228f, 0.05064562f, 0.11916135f, 0.06194892f, -0.01433444f, 
    0.08437943f, 0.11502944f, 0.21216974f, -0.09718599f, 0.22202429f, 0.23767762f, 0.06379353f, 0.26212829f, 
    -0.05288935f, 0.19675878f, 0.30810624f, -0.00393322f, 0.24049316f, 0.06440668f, 0.10760872f, 0.26765537f, 
    -0.07617482f, -0.26904237f, 0.04251824f, -0.01838063f, -0.03602944f, -0.05350339f, 0.05628778f, 0.25443551f, 
    -0.12603463f, -0.06746759f, -0.32571009f, 0.07785248f, -0.04652655f, 0.03671283f, 0.06167369f, -0.10435146f, 
    0.05999634f, 0.00860098f, 0.03687157f, -0.02352424f, -0.16080156f, 0.15341794f, -0.09735841f, -0.14658715f, 
    -0.17336369f, 0.08126630f, 0.16160700f, -0.14519136f, -0.11086590f, -0.12199578f, 0.44926146f, 0.30554360f, 
    -0.15668008f, 0.01699621f, -0.14268856f, -0.09499835f, 0.21732685f, 0.05693293f, -0.04027698f, 0.24409893f, 
    -0.14871119f, 0.07412437f, 0.04584664f, -0.01266277f, 0.21386904f, 0.19747537f, 0.40714139f, 0.03102358f, 
    -0.20083371f, 0.05866314f, 0.03510065f, -0.07121224f, 0.48609325f, -0.18085557f, 0.12320915f, -0.11726993f, 
    -0.06400075f, 0.30016860f, 0.18969923f, 0.27937344f, -0.11907499f, -0.27078456f, 0.28396618f, -0.02855369f, 
    -0.02673407f, 0.32702488f, 0.14327627f, -0.10608947f, -0.02396208f, 0.18341929f, -0.11614830f, -0.06708644f, 
    0.13004009f, -0.09376602f, 0.22237302f, 0.05215024f, 0.09076512f, -0.11699788f, -0.12775452f, 0.01007384f, 
    -0.10194143f, -0.00064293f, -0.34219533f, -0.02939065f, 0.13940069f, 0.09265943f, -0.02332867f, 0.25070184f, 
    -0.18770586f, 0.03322493f, -0.20755254f, 0.21609604f, 0.10791294f, 0.23173365f, 0.48148730f, -0.01253190f, 
    0.09245096f, -0.07558230f, 0.16151769f, -0.07123677f, 0.13912591f, -0.09490044f, 0.02099361f, 0.22924444f, 
    -0.02838015f, -0.06085349f, 0.24068710f, -0.02889641f, 0.07582762f, 0.15424472f, -0.41119307f, 0.02681701f, 
    0.04285292f, -0.02384383f, 0.11959183f, 0.04176039f, -0.08876789f, 0.20365033f, -0.09624034f, -0.06792390f, 
    0.05316515f, -0.08612774f, 0.15561274f, 0.06233257f, 0.19301932f, 0.30052558f, -0.19018632f, 0.00567938f, 
    -0.06191159f, -0.14348201f, 0.02045261f, -0.00617473f, -0.07356501f, -0.19387682f, -0.17234850f, 0.32831612f, 
    -0.25781244f, -0.15242651f, 0.04940471f, -0.01491703f, 0.03925578f, 0.04147947f, -0.01869149f, 0.02581354f, 
    -0.04274310f, -0.03487716f, 0.10662002f, -0.06098516f, -0.03448313f, 0.26024500f, -0.37508622f, 0.15381046f, 
    0.24310000f, -0.04451709f, -0.05760545f, -0.34083733f, -0.04929928f, -0.14384148f, -0.02437191f, 0.00957576f, 
    0.16437224f, 0.01287027f, -0.07335265f, -0.13654846f, 0.21764694f, 0.06133416f, 0.11405358f, -0.05562967f, 
    0.08194426f, 0.15222165f, 0.22412798f, 0.05279989f, 0.20684627f, -0.09117421f, -0.01120909f, -0.03477128f, 
    -0.20418082f, 0.14304118f, -0.09059513f, -0.04900941f, 0.17957440f, 0.19301130f, 0.04666255f, -0.12362168f, 
    -0.08842433f, 0.31422603f, 0.16868952f, 0.33349091f, 0.05391996f, -0.00063013f, -0.10589205f, 0.06511650f, 
    0.08957428f, 0.23983981f, 0.08218887f, -0.01915586f, -0.09909347f, -0.17130184f, -0.25227210f, -0.22081068f, 
    -0.40371820f, 0.30152607f, 0.10684077f, -0.12985826f, 0.03538539f, -0.13431607f, 0.23500386f, -0.02033103f, 
    0.02022692f, 0.17688116f, 0.08063614f, -0.08580811f, -0.11896652f, 0.36549619f, -0.09546284f, -0.31031206f, 
    0.60731685f, -0.07698380f, 0.03271601f, 0.00451686f, 0.05327316f, -0.02205483f, -0.05570108f, -0.14586692f, 
    0.23809063f, 0.16365711f, 0.40900981f, 0.11812854f, -0.17877260f, 0.06760900f, 0.07290988f, -0.36812547f, 
    0.12322032f, -0.06955705f, 0.03118967f, 0.07849432f, -0.10954493f, -0.17767601f, 0.16493897f, -0.09025975f, 
    0.08197960f, 0.01830191f, 0.12666771f, -0.03969346f, -0.20667730f, -0.05132798f, 0.02914383f, 0.17497161f, 
    0.06378944f, 0.03324119f, -0.08139617f, -0.06964260f, -0.09264969f, 0.00347266f, 0.35778710f, -0.14913113f, 
    0.13303463f, 0.20604490f, 0.04834084f, -0.08152933f, -0.03674149f, -0.27331161f, 0.06451155f, 0.07053360f, 
    -0.07381338f, -0.09817806f, -0.04882830f, 0.02061610f, -0.03284176f, 0.00725357f, 0.08848236f, -0.07892902f, 
    0.07987320f, 0.09538945f, 0.06256583f, 0.04153915f, -0.08815370f, -0.13332905f, -0.11393450f, -0.01011008f, 
    0.04284424f, -0.00812447f, 0.02977004f, 0.03626850f, -0.02374707f, -0.00460033f, -0.08782282f, -0.06925660f, 
    -0.11194322f, -0.06932680f, 0.04219776f, -0.09027952f, 0.06704088f, 0.01799309f, -0.03089850f, 0.00088443f, 
    0.07845446f, -0.02440372f, 0.03730306f, -0.00207410f, -0.09051368f, 0.03644123f, -0.12618293f, -0.07872224f, 
    -0.01306210f, -0.10487150f, -0.04075018f, -0.00150147f, 0.02900005f, 0.08100986f, -0.04613107f, -0.11798872f, 
    -0.10276329f, -0.12596755f, 0.05716870f, -0.03846715f, -0.12132393f, -0.09645687f, 0.04888701f, 0.01744436f, 
    -0.05645509f, 0.02122320f, -0.12799345f, -0.00184195f, 0.10155932f, -0.11067092f, 0.01158543f, -0.11316866f, 
    -0.23199096f, -0.10812830f, 0.28152400f, -0.14933890f, 0.11638523f, 0.08430482f, 0.12722033f, -0.06308611f, 
    0.00165428f, 0.10428358f, 0.01198588f, 0.02587872f, -0.27228177f, 0.00005058f, -0.38216931f, 0.12518376f, 
    0.17724153f, 0.13566460f, -0.11883469f, -0.15293404f, 0.08903186f, 0.04513333f, 0.15365690f, 0.03883031f, 
    -0.08399264f, 0.14887489f, 0.18999848f, 0.09547541f, 0.18608077f, -0.01692906f, 0.13966884f, 0.26346788f, 
    0.12271004f, 0.21480255f, 0.08016115f, -0.12698232f, 0.17774794f, -0.13899761f, -0.11982267f, -0.05241400f, 
    -0.24363352f, 0.03966019f, -0.01272318f, 0.07602214f, -0.02167215f, 0.38467765f, -0.08907069f, 0.22980894f, 
    -0.04296261f, 0.33868411f, -0.19907510f, 0.16081801f, 0.13086163f, -0.17487636f, -0.12231064f, 0.10272088f, 
    -0.10739981f, -0.05859471f, 0.06799672f, -0.10905727f, -0.11492379f, 0.01137888f, -0.28773695f, -0.20437887f, 
    0.05270765f, -0.04133688f, 0.05461437f, -0.00467209f, 0.04877879f, 0.03971119f, -0.04982114f, -0.10319570f, 
    -0.07284409f, -0.10042246f, 0.10261603f, -0.06273243f, -0.11295080f, -0.04385667f, 0.09917705f, -0.11638264f, 
    0.11697840f, -0.00173152f, -0.08890012f, -0.10786720f, 0.07321957f, 0.11275853f, 0.08239483f, -0.08367763f, 
    -0.07813191f, -0.08260616f, -0.09261325f, 0.05206451f, 0.10298918f, -0.09484051f, 0.00553950f, 0.11021467f, 
    -0.02812462f, 0.04932709f, -0.12049443f, -0.02289292f, -0.10028486f, -0.04001156f, -0.12793304f, -0.07188076f, 
    -0.08150539f, 0.08917031f, 0.02913683f, -0.10339256f, -0.05075623f, 0.00992073f, 0.06600834f, 0.05782359f, 
    0.00654139f, -0.10539497f, -0.07589294f, -0.10638433f, -0.07851067f, -0.03114592f, -0.03043098f, 0.04536015f, 
    -0.02087323f, -0.07501675f, -0.12707041f, -0.04422939f, -0.03033724f, 0.00358558f, 0.10309345f, -0.03583942f, 
    0.14160495f, -0.02665874f, -0.07386922f, 0.19903083f, -0.10188172f, 0.09813444f, 0.22395141f, -0.02976146f, 
    -0.11785936f, 0.13418920f, 0.36203369f, -0.12153433f, 0.21582167f, 0.11936657f, 0.02479088f, -0.36487752f, 
    -0.16644213f, -0.03249785f, 0.13358139f, -0.13137086f, -0.00266305f, -0.09400300f, -0.11781860f, 0.28330103f, 
    0.24897572f, -0.22719732f, -0.18348840f, 0.15124787f, 0.00609209f, -0.04991105f, -0.07282472f, -0.46610668f, 
    -0.11484360f, -0.00896720f, 0.03744965f, -0.00909545f, 0.21921019f, 0.20690683f, 0.38861525f, 0.00889034f, 
    0.04423874f, 0.17926529f, 0.30798173f, 0.07767485f, 0.17786950f, -0.15299980f, -0.07895672f, -0.08895972f, 
    -0.02978918f, -0.00122546f, 0.31395081f, -0.19658472f, 0.02245670f, -0.10034957f, 0.27601677f, 0.04229722f, 
    -0.09599387f, 0.12722981f, -0.01261110f, 0.04033645f, 0.03640601f, -0.06387187f, 0.29587698f, 0.30478778f, 
    0.18350533f, 0.06366159f, -0.33289683f, 0.05524453f, 0.07701853f, -0.03502235f, 0.17195021f, -0.10000071f, 
    0.03428124f, -0.11484213f, -0.18670569f, -0.09731762f, -0.11292803f, 0.13677734f, 0.11419538f, -0.03370609f, 
    0.14526568f, 0.21940996f, 0.19990045f, 0.27200645f, 0.00175400f, -0.23573992f, 0.21605916f, 0.15308607f, 
    -0.22141600f, -0.29680967f, 0.11206159f, 0.08672556f, -0.08075848f, -0.05551779f, -0.17095308f, -0.24389942f, 
    0.23072562f, -0.39303741f, 0.10702661f, 0.01937096f, -0.08401454f, -0.04050478f, 0.13078840f, 0.10185267f, 
    0.02658997f, -0.33407623f, -0.29229558f, -0.00976401f, 0.07769461f, -0.39775714f, -0.04246061f, -0.10697184f, 
    0.10055038f, 0.08567435f, 0.33829209f, 0.24538775f, -0.10438421f, 0.24433102f, 0.18604489f, -0.27298084f, 
    0.05773430f, 0.10389017f, -0.10507264f, -0.09973875f, 0.00647083f, 0.24280842f, -0.08755150f, -0.03848669f, 
    -0.06727931f, -0.21785294f, -0.10232988f, -0.09351687f, -0.08454227f, -0.02908520f, -0.00592738f, -0.09613031f, 
    -0.07032088f, -0.26911262f, 0.01567881f, 0.08307402f, -0.21944122f, 0.25901675f, -0.34007028f, 0.16957347f, 
    0.15282042f, -0.03058846f, 0.04392798f, -0.18538597f, -0.12672482f, 0.16018422f, 0.24803613f, 0.32355112f, 
    0.00332243f, 0.24975584f, 0.07332997f, 0.08030380f, 0.10439719f, 0.10214071f, -0.11896314f, 0.18558082f, 
    -0.04904020f, 0.19254109f, 0.16333438f, -0.05526947f, 0.03653013f, -0.09075754f, 0.02668140f, -0.00830745f, 
    -0.20039357f, 0.02321229f, -0.05490822f, -0.06535598f, 0.30916646f, 0.23286393f, 0.02056259f, 0.09367374f, 
    0.01910003f, 0.30692053f, 0.06492755f, 0.26232085f, 0.07055137f, -0.23958673f, 0.15262368f, 0.03742785f, 
    -0.10043488f, 0.19633974f, 0.10002904f, 0.00890121f, 0.05697853f, -0.00293352f, -0.45692095f, 0.01061276f, 
    0.07577498f, -0.11230735f, 0.19332145f, -0.15490852f, -0.07562302f, 0.11465776f, 0.06862841f, 0.00640983f, 
    -0.00756353f, -0.08444234f, 0.22246279f, -0.04772600f, 0.21461992f, 0.37802812f, 0.10794380f, -0.17713067f, 
    0.19307218f, -0.18387306f, 0.10723896f, 0.11157490f, 0.07590699f, 0.34977791f, -0.09497692f, 0.15726253f, 
    -0.05822654f, 0.29588249f, 0.14539902f, 0.31811339f, -0.18903515f, -0.08424941f, -0.26010829f, -0.31019139f, 
    0.12587115f, -0.05015332f, -0.01205112f, -0.00502554f, 0.06518669f, -0.10893980f, 0.15658848f, -0.07926032f, 
    0.34843853f, -0.11668129f, 0.13809565f, 0.02864521f, 0.02806443f, -0.03294928f, -0.02771214f, 0.01939634f, 
    0.02916368f, -0.10511430f, 0.23274091f, -0.16959684f, 0.13864282f, -0.01455266f, 0.02581450f, -0.06436902f, 
    0.06551015f, 0.01941652f, 0.05558829f, 0.01439569f, -0.05280798f, 0.05763351f, 0.03663117f, 0.32223883f, 
    -0.08880538f, 0.08834508f, 0.06542756f, 0.02085583f, -0.10856606f, 0.11888936f, -0.04828340f, 0.04721712f, 
    0.08302192f, -0.03873950f, 0.02098748f, 0.05243272f, -0.02132809f, -0.04320504f, 0.03221262f, 0.06597024f, 
    0.06066853f, -0.10540944f, -0.04769620f, -0.04563233f, -0.10447279f, -0.02909479f, -0.07632440f, -0.11201179f, 
    0.06715684f, -0.06323773f, -0.07773963f, 0.11133090f, -0.02576174f, 0.07482278f, 0.01755452f, 0.08746485f, 
    -0.11737442f, -0.01418823f, -0.06626980f, -0.00893781f, -0.04934153f, -0.11369342f, -0.00862959f, 0.03577799f, 
    0.07767621f, -0.12143405f, -0.08719425f, -0.07593030f, -0.01963574f, 0.09169380f, -0.03985001f, -0.12357901f, 
    0.08728959f, 0.03244728f, 0.11257467f, -0.02789710f, 0.00688009f, 0.07748340f, -0.10550827f, -0.10867026f, 
    0.03553800f, -0.03926378f, -0.02326921f, 0.03447048f, 0.04410620f, 0.11930305f, -0.04298720f, 0.03914399f, 
    0.28217429f, -0.12141024f, 0.12940694f, -0.11328014f, -0.05320841f, 0.05465969f, 0.08658759f, 0.00880126f, 
    -0.09649330f, -0.18412922f, 0.08646949f, 0.01380964f, -0.32473132f, 0.16504566f, -0.41360694f, -0.52498978f, 
    0.04601887f, -0.22486167f, 0.06216003f, 0.02582888f, 0.02315859f, 0.28069156f, 0.12849966f, 0.07378949f, 
    -0.16788974f, 0.15322277f, -0.09069186f, 0.23473719f, -0.06761791f, -0.07195932f, -0.07386276f, -0.28393355f, 
    0.08481423f, 0.01006899f, -0.02446511f, -0.13178706f, 0.12330487f, -0.04661563f, 0.04131578f, -0.07921372f, 
    0.12773401f, -0.00580792f, 0.20517726f, 0.02060641f, 0.08377089f, -0.09548462f, 0.06399829f, -0.06608070f, 
    0.09283991f, 0.00092102f, 0.28025967f, 0.17528494f, 0.18514739f, 0.21073483f, 0.06529187f, -0.11851724f, 
    -0.00529942f, 0.17939816f, -0.06296968f, -0.02081843f, 0.07018865f, 0.20499820f, -0.32099614f, 0.08081462f, 
    -0.19939242f, 0.03257042f, 0.30488795f, 0.09038820f, -0.09751420f, 0.03671034f, 0.06748576f, 0.03912463f, 
    0.08452002f, 0.20933589f, -0.25909066f, -0.11026984f, -0.00059409f, -0.18882176f, -0.13615668f, -0.17251277f, 
    0.12585971f, 0.02077570f, -0.02738210f, 0.09058583f, -0.05760127f, 0.29364645f, 0.39848924f, 0.32491952f, 
    0.21729036f, 0.33142355f, -0.02076558f, 0.34835809f, -0.01877092f, -0.10210640f, -0.15654500f, 0.20531322f, 
    0.00459905f, -0.00981988f, -0.07029110f, -0.18041357f, 0.23311409f, 0.09188921f, 0.00428563f, -0.04715642f, 
    -0.02302527f, 0.18981652f, 0.19212697f, -0.05154683f, -0.06394169f, 0.10588690f, -0.03266022f, 0.15945078f, 
    -0.09366112f, -0.22700952f, -0.11448681f, 0.01376626f, 0.05036575f, 0.21660171f, -0.00395413f, -0.12645002f, 
    0.04183389f, -0.04498370f, 0.13256012f, -0.03904356f, 0.01367827f, -0.25135812f, -0.24693759f, 0.41876581f, 
    -0.23029353f, 0.16722156f, 0.27532494f, 0.07289658f, -0.08487362f, -0.10442678f, 0.13341008f, -0.10483398f, 
    0.06774697f, 0.32045513f, 0.23970242f, -0.01628406f, 0.03211521f, -0.13217905f, -0.06430811f, -0.34749147f, 
    0.19086221f, 0.37698963f, -0.15828632f, 0.03853526f, -0.00462252f, 0.05890000f, -0.15407939f, 0.38847852f, 
    0.19653155f, 0.03539987f, -0.08533066f, 0.17724226f, 0.18199210f, -0.08110728f, -0.11558137f, -0.18541573f, 
    -0.07764484f, -0.21347973f, -0.05666542f, 0.11956558f, 0.20858264f, 0.03073137f, 0.43383864f, -0.01720127f, 
    -0.29557523f, 0.25814268f, 0.04637099f, -0.02114912f, -0.20133546f, -0.21346299f, -0.04467179f, 0.23864751f, 
    0.09436980f, 0.13950065f, -0.06037415f, -0.11962253f, -0.18083785f, 0.19453236f, -0.13942510f, -0.15372030f, 
    0.00148517f, -0.00112362f, -0.07180712f, -0.01535007f, 0.01648201f, 0.06852149f, 0.07477419f, 0.10982487f, 
    -0.03903985f, 0.23426181f, 0.02455108f, -0.01434140f, 0.01189110f, 0.04276443f, 0.17852446f, -0.09495815f, 
    -0.02696779f, 0.25092807f, -0.10504540f, -0.04612707f, -0.22319284f, 0.02476252f, 0.08048715f, 0.00537939f, 
    0.46329236f, 0.32530078f, -0.25060278f, 0.30067545f, -0.03301364f, 0.18258491f, -0.17930433f, 0.12239992f, 
    0.13488096f, 0.21517007f, 0.41128537f, 0.04860717f, 0.02690994f, -0.10804123f, -0.06815616f, 0.10687119f, 
    0.02954466f, 0.02303427f, -0.08378045f, 0.10785273f, -0.12411457f, -0.08264140f, -0.04101010f, 0.01934411f, 
    -0.13384144f, 0.02149528f, 0.11528755f, -0.02517205f, 0.02907902f, 0.23446801f, -0.04460959f, 0.31511971f, 
    -0.06352167f, 0.35299206f, -0.25375170f, -0.16170594f, -0.24101686f, -0.27185187f, 0.07081220f, 0.02523920f, 
    -0.02414485f, 0.13830054f, -0.10555494f, -0.03957012f, 0.02014769f, 0.09059612f, 0.15931819f, 0.00679374f, 
    -0.15034014f, 0.03421272f, -0.30362484f, 0.08629070f, -0.03346957f, -0.00255998f, -0.06489012f, -0.09078453f, 
    0.06300005f, -0.22125466f, 0.24820471f, -0.08250780f, -0.18544674f, 0.23972110f, 0.15800944f, 0.06295311f, 
    0.11937521f, -0.21134226f, 0.12765408f, -0.12249247f, -0.05391248f, -0.02692049f, 0.17956385f, -0.30642262f, 
    0.00041268f, 0.26818821f, 0.29956564f, -0.13195871f, 0.00605842f, 0.06780513f, 0.18091708f, 0.16578765f, 
    0.27416077f, 0.09283357f, 0.19120392f, 0.21761256f, 0.15876886f, -0.07906320f, -0.05871898f, -0.05006263f, 
    -0.02256278f, -0.08622545f, -0.22333014f, 0.00725781f, -0.01279296f, -0.03120326f, -0.03844123f, -0.20644471f, 
    0.07511731f, 0.16007215f, -0.23985586f, 0.15412308f, 0.12775050f, -0.33991620f, 0.20262723f, -0.11817145f, 
    0.08359803f, 0.24958667f, 0.18316524f, 0.10602307f, -0.08704352f, 0.09510456f, -0.00271000f, -0.32184485f, 
    0.09557325f, -0.03129093f, 0.19571824f, 0.03371140f, 0.05869666f, 0.00720980f, 0.27149692f, -0.12086213f, 
    0.01856908f, 0.16022862f, 0.01873693f, -0.07990969f, 0.08107188f, -0.25160778f, 0.17263728f, 0.26971504f, 
    0.08580559f, 0.32463554f, -0.30121708f, -0.07207002f, 0.02355595f, -0.31300250f, -0.43651742f, 0.01777143f, 
    0.11092426f, -0.16583338f, -0.22348423f, -0.32363880f, 0.21688956f, -0.11482462f, 0.15976271f, -0.01266638f, 
    -0.04247550f, 0.07355395f, -0.27689946f, -0.03591406f, -0.08732492f, 0.09646583f, 0.18850777f, -0.07021439f, 
    0.00013327f, 0.02928880f, 0.16500099f, -0.09883744f, -0.13000430f, -0.05236045f, 0.08602843f, 0.17004134f, 
    -0.10578829f, 0.16009468f, -0.14522134f, -0.11840693f, 0.09585123f, 0.31984827f, -0.35457352f, -0.07297792f, 
    -0.08009395f, -0.02763730f, 0.00965217f, -0.02305768f, 0.05042681f, 0.09285284f, 0.19875690f, -0.28614759f, 
    -0.07399694f, 0.00894191f, 0.53520852f, 0.08254048f, -0.02255070f, 0.05644156f, -0.16082315f, -0.05165438f, 
    -0.08099861f, -0.13499086f, -0.06185424f, 0.04344879f, -0.18058605f, -0.41562155f, 0.26433381f, 0.11667895f, 
    -0.29927334f, 0.33513546f, 0.04609169f, -0.12331058f, -0.07172921f, -0.25191477f, 0.41521692f, -0.22342727f, 
    -0.17623234f, -0.37253115f, -0.06255686f, -0.06535690f, 0.06984890f, -0.11270896f, 0.33079505f, -0.10705168f, 
    -0.10947136f, -0.00576298f, 0.19456756f, 0.28563145f, 0.15166457f, 0.06105810f, 0.19723289f, 0.11483607f, 
    0.23917335f, 0.03289706f, -0.38886866f, 0.10712293f, 0.05866960f, -0.10777832f, -0.05141649f, 0.41426113f, 
    -0.01169732f, -0.29427770f, -0.04339525f, 0.11261152f, 0.09876524f, 0.19951619f, 0.11966024f, 0.14164609f, 
    -0.07831474f, -0.22730491f, -0.09828975f, 0.04931147f, -0.12097967f, 0.13279244f, 0.08925940f, 0.16186617f, 
    -0.27279228f, 0.27624431f, 0.29584348f, -0.18130909f, 0.01863271f, -0.05973572f, 0.26331326f, 0.00051215f, 
    -0.04078930f, 0.21879670f, -0.12338902f, -0.04550053f, -0.34778881f, 0.06771874f, -0.06528644f, 0.21052219f, 
    0.04972606f, -0.05895194f, 0.13526641f, -0.10319965f, -0.03558829f, -0.15059882f, 0.01420094f, -0.10816538f, 
    -0.01446550f, -0.12100623f, 0.00582405f, 0.08705399f, -0.10785774f, 0.06356745f, 0.15071337f, 0.28306666f, 
    0.30134326f, -0.05770291f, -0.15220937f, -0.20322266f, -0.15558912f, -0.18081361f, 0.21250327f, -0.00948356f, 
    0.15976234f, 0.01142491f, 0.18131065f, -0.05465578f, -0.11220128f, 0.15679747f, -0.06215039f, 0.41679439f, 
    0.02708219f, 0.08524466f, -0.14775264f, -0.03078204f, 0.38001117f, 0.18373314f, 0.10754996f, 0.17985722f, 
    -0.10181279f, 0.00273855f, 0.17745657f, 0.06700274f, -0.10800373f, -0.00845325f, 0.26196212f, -0.14639726f, 
    0.46717393f, 0.06292003f, 0.02997807f, 0.15335955f, 0.02311038f, -0.00926522f, -0.29464632f, -0.04797387f, 
    0.07200792f, -0.30587441f, 0.25005230f, -0.01684880f, 0.26480359f, -0.05281785f, 0.32961181f, 0.38766000f, 
    -0.07154743f, 0.27682689f, -0.23264478f, 0.17296351f, -0.04653519f, 0.05601284f, -0.24552967f, -0.28481358f, 
    -0.16353321f, 0.05152179f, 0.14475819f, -0.36987489f, 0.13689159f, -0.04288079f, 0.16281998f, 0.06757812f, 
    -0.15307610f, 0.20762575f, 0.09244089f, 0.33335632f, -0.15340622f, 0.14478754f, 0.09093722f, -0.13122135f, 
    0.10000647f, -0.08490630f, -0.04899330f, 0.02248149f, 0.07891402f, 0.02691212f, 0.03386646f, -0.11349342f, 
    -0.07143600f, 0.17725143f, -0.27726015f, -0.12579711f, -0.02869367f, -0.16975045f, -0.25184873f, 0.26011568f, 
    -0.02718367f, 0.08784521f, 0.02464430f, 0.02034667f, 0.02738727f, 0.37751603f, 0.03422582f, -0.00836560f, 
    0.01516187f, 0.08891509f, -0.11714624f, -0.03462984f, 0.04628673f, -0.10794768f, 0.06405059f, 0.00223703f, 
    0.05353534f, 0.01324776f, -0.11975134f, 0.06081701f, 0.06030985f, -0.08053922f, -0.04516771f, 0.10200593f, 
    -0.12068908f, -0.12664656f, -0.13411412f, -0.10130912f, -0.03714535f, -0.01257475f, -0.08787360f, 0.02438233f, 
    0.09858501f, 0.05385611f, -0.08476947f, 0.04166352f, -0.07236410f, -0.06515822f, -0.06895208f, 0.04797925f, 
    -0.01687101f, 0.06653135f, -0.05535697f, -0.11507847f, -0.07808410f, -0.07171672f, -0.08338638f, 0.10227703f, 
    -0.08431650f, -0.10918003f, -0.02502243f, 0.05855069f, -0.00778342f, 0.08802789f, 0.00336921f, -0.08288686f, 
    0.10049526f, 0.05766504f, 0.02809870f, 0.05375296f, -0.04282237f, -0.04308559f, 0.09429576f, 0.02408388f, 
    0.00828737f, 0.02109254f, -0.09064207f, 0.05986350f, 0.07630382f, -0.02435142f, -0.02403338f, 0.05715583f, 
    0.09296000f, -0.07790681f, 0.05374832f, -0.00928659f, 0.08128893f, -0.07236651f, -0.12586062f, 0.05717105f, 
    -0.09154797f, 0.09602951f, -0.07127790f, -0.06806631f, -0.07831168f, 0.01484007f, 0.00673436f, 0.03961418f, 
    -0.01451684f, 0.10744742f, -0.08820260f, -0.00586847f, 0.08210351f, 0.06382161f, 0.08033846f, -0.03445664f, 
    -0.03533778f, -0.12348711f, -0.11835826f, -0.11622000f, -0.04074384f, -0.02995251f, -0.09679629f, 0.07334883f, 
    -0.01340635f, -0.08194203f, 0.00516867f, -0.03418355f, -0.09616701f, -0.04414779f, -0.11020746f, -0.02317151f, 
    0.04586510f, -0.01963057f, -0.01312834f, 0.05894952f, 0.07994162f, -0.00795233f, 0.11819084f, 0.02830216f, 
    -0.03730534f, -0.00742433f, 0.06876946f, -0.05552094f, 0.03352978f, 0.04737497f, 0.03275874f, 0.10925046f, 
    0.10646683f, -0.12208626f, -0.13670479f, 0.01165882f, -0.09557049f, -0.02537481f, -0.09430376f, 0.01362825f, 
    0.20621870f, -0.07675634f, 0.05216842f, 0.09017809f, 0.05773911f, 0.07380368f, 0.22648023f, 0.05693956f, 
    -0.03705281f, 0.15585881f, 0.18343779f, -0.00310751f, 0.21493164f, 0.21256220f, 0.13984191f, -0.15632156f, 
    0.19315144f, -0.41181764f, 0.05821481f, -0.04413487f, -0.07693591f, -0.02315548f, -0.23515320f, -0.07008726f, 
    0.15956223f, -0.04768117f, -0.14992860f, 0.08152646f, -0.16637756f, -0.08951543f, -0.03675493f, -0.36634842f, 
    0.02327348f, 0.12182700f, 0.17254531f, -0.05891026f, -0.07163936f, 0.08946389f, -0.11611329f, -0.04093936f, 
    0.27030444f, 0.11944794f, 0.12881230f, 0.10470059f, -0.32056138f, -0.17801663f, -0.10515849f, -0.33714607f, 
    0.02488554f, -0.14007735f, 0.27181014f, -0.00636844f, 0.14343548f, 0.26636940f, 0.13978913f, -0.09767523f, 
    0.09714304f, 0.15305583f, 0.07920244f, 0.07894562f, 0.03027363f, -0.16841923f, 0.20360015f, 0.16525921f, 
    -0.08558553f, 0.39384499f, 0.08239303f, 0.05395600f, 0.00345785f, 0.01241591f, 0.28630480f, -0.05318980f, 
    -0.01931758f, 0.37222531f, 0.02396349f, -0.01636401f, -0.11581512f, 0.05084814f, 0.23344173f, -0.40684533f, 
    -0.09330431f, 0.01794817f, 0.29833356f, 0.15838389f, -0.00203641f, -0.01881626f, 0.22776657f, 0.04681030f, 
    0.20253411f, -0.03153288f, -0.03471313f, 0.15321714f, 0.04202166f, -0.03397682f, 0.08133975f, -0.21943842f, 
    0.21405195f, -0.05321731f, 0.07336693f, -0.17750458f, -0.09839543f, -0.00190630f, 0.10008727f, -0.05719518f, 
    0.06405939f, 0.00269343f, 0.05958487f, -0.04433608f, -0.08765464f, 0.08867377f, -0.00404700f, 0.32420972f, 
    0.11205495f, -0.05323473f, 0.00721836f, -0.08825745f, 0.07408855f, -0.03852704f, 0.31569824f, -0.09271868f, 
    0.07161710f, -0.06010647f, 0.02590576f, 0.11976353f, 0.09190016f, -0.16776407f, 0.38902155f, 0.26727819f, 
    0.18870182f, -0.08222504f, 0.01410380f, -0.09833533f, 0.02944820f, -0.06229315f, -0.19782279f, -0.05953341f, 
    0.08412433f, -0.26012745f, 0.04596994f, 0.08442964f, -0.00659922f, 0.12275075f, -0.07995047f, 0.25500402f, 
    -0.15747043f, -0.11230413f, 0.01141549f, -0.12315498f, -0.09916011f, 0.10472491f, 0.08281009f, -0.12161072f, 
    -0.11305366f, 0.11115846f, 0.05118507f, -0.10483385f, 0.03454810f, 0.05444907f, 0.26546595f, 0.02864993f, 
    0.12845273f, 0.15209588f, 0.37624997f, 0.11146276f, -0.09456336f, -0.05882346f, -0.28676999f, -0.12576096f, 
    0.12926987f, -0.16510534f, 0.04704776f, -0.10887253f, 0.27638462f, 0.31115261f, -0.01625676f, -0.12323827f, 
    -0.02421836f, 0.18446690f, 0.03692969f, 0.11082872f, 0.14089131f, 0.12839119f, 0.07545555f, 0.29853684f, 
    0.04579557f, 0.07155234f, 0.05948596f, -0.03612199f, 0.10025351f, 0.07933111f, -0.15249677f, -0.04698112f, 
    0.27836919f, -0.02765878f, 0.10389390f, 0.01594151f, 0.04688476f, -0.02354932f, -0.19052809f, -0.08392987f, 
    -0.05240918f, 0.01588427f, -0.06164159f, -0.03754939f, 0.22725102f, -0.10102578f, 0.27101767f, 0.28432691f, 
    -0.12381893f, 0.11837272f, 0.02436996f, 0.07528458f, 0.00794220f, 0.39413756f, -0.07529052f, -0.12010191f, 
    0.18117923f, 0.31103462f, 0.06829204f, 0.11739547f, 0.02215120f, -0.06226905f, 0.12139449f, 0.20934424f, 
    0.00039781f, 0.02039559f, 0.10958371f, 0.15968555f, 0.09445497f, 0.00976852f, -0.18732011f, 0.04562627f, 
    0.13274448f, -0.00840605f, -0.09569609f, -0.07573118f, -0.11584783f, 0.08211859f, -0.11411695f, -0.00548131f, 
    0.10752119f, -0.24853572f, -0.35294718f, -0.32183197f, 0.04080608f, 0.03905673f, 0.04382356f, 0.24828377f, 
    -0.03258105f, -0.11380901f, 0.00262452f, -0.10328351f, 0.13560593f, -0.04614553f, 0.07380100f, 0.14925238f, 
    0.17980242f, -0.10208354f, 0.04294242f, 0.16503586f, -0.00256538f, -0.12275818f, -0.11911279f, 0.09723890f, 
    -0.03298616f, -0.18586364f, 0.29074830f, -0.06203076f, 0.04827519f, -0.12589431f, 0.11294314f, 0.23888017f, 
    -0.23184696f, -0.31639877f, 0.20541067f, -0.25487536f, 0.04547186f, 0.02427053f, -0.27967578f, -0.15705143f, 
    0.01759306f, 0.05141141f, -0.14274822f, -0.07047331f, 0.06071594f, 0.03055744f, 0.15484120f, 0.32816496f, 
    0.13829505f, 0.30825186f, -0.04460407f, 0.01631363f, -0.17255147f, -0.03898577f, -0.11927806f, -0.01502177f, 
    0.16701336f, -0.03883630f, 0.05012603f, -0.09363300f, 0.14930254f, 0.25651583f, 0.12284146f, 0.14533846f, 
    -0.01427053f, -0.16363473f, -0.09959461f, 0.06012977f, 0.22414167f, -0.02052228f, 0.09976668f, 0.29887155f, 
    -0.12127855f, -0.01944455f, 0.17480527f, -0.08274250f, 0.03652972f, 0.35459098f, -0.00369953f, -0.19392590f, 
    -0.06931178f, -0.07645656f, 0.01124468f, 0.00776853f, 0.10541683f, -0.12287930f, -0.06402579f, -0.04260463f, 
    -0.12238222f, -0.04074928f, -0.12388542f, 0.11336023f, -0.05846620f, -0.11576539f, -0.05082823f, -0.00467233f, 
    -0.12075041f, 0.04017821f, 0.05287406f, 0.00083552f, -0.07139078f, -0.10865290f, -0.03389454f, -0.08985616f, 
    0.08615635f, -0.09274516f, -0.06763871f, 0.03494351f, -0.02951308f, -0.02018155f, 0.10307550f, -0.08956583f, 
    0.08027875f, -0.06964810f, -0.08834019f, -0.10120761f, -0.04900660f, 0.06107095f, -0.09424733f, 0.09447658f, 
    0.05969657f, -0.03752854f, -0.10232598f, 0.08965319f, 0.00367366f, -0.09885561f, -0.00005122f, 0.04143393f, 
    0.10538922f, -0.02523465f, 0.04637201f, 0.00481395f, -0.02877209f, -0.07824512f, 0.04163186f, -0.02268119f, 
    0.03627568f, -0.01615161f, -0.09322411f, 0.11366756f, 0.05626976f, -0.08768523f, -0.10753335f, -0.04913969f, 
    0.05128306f, 0.14420073f, -0.07836752f, 0.26825255f, -0.05857446f, 0.08917850f, 0.14211947f, -0.03552635f, 
    0.12880075f, 0.40602458f, 0.12871863f, 0.06497342f, 0.03896074f, -0.04963395f, 0.06983154f, 0.08793347f, 
    -0.03314450f, -0.35687542f, 0.10017508f, 0.03370065f, 0.10024955f, -0.10159744f, -0.52631408f, 0.00454524f, 
    0.19894814f, 0.06771576f, -0.31597370f, 0.01255134f, -0.10872590f, -0.10302592f, -0.19494510f, 0.06040514f, 
    0.14375113f, 0.14106134f, -0.21145637f, -0.15521175f, -0.00319007f, -0.05212587f, -0.05003392f, 0.06133283f, 
    0.19478516f, 0.25758579f, 0.41781086f, 0.01944441f, -0.18982783f, 0.12824686f, -0.04648799f, 0.00536853f, 
    -0.01507418f, -0.15946960f, 0.04235452f, -0.20473616f, 0.04942136f, 0.10765915f, -0.12417334f, 0.07040802f, 
    0.11896031f, 0.17908622f, 0.19265993f, -0.01859800f, -0.04804038f, -0.03370823f, 0.16399637f, -0.04573029f, 
    0.30389601f, 0.05187129f, 0.18358769f, 0.12303407f, 0.00133306f, 0.11501250f, 0.12836568f, 0.01026078f, 
    0.08325129f, 0.28679556f, -0.39636537f, -0.05436585f, 0.33386770f, -0.17538159f, 0.06071013f, -0.13788877f, 
    -0.26543313f, 0.08637144f, -0.14508551f, 0.34002534f, -0.06176020f, 0.22313727f, 0.00000992f, 0.01612557f, 
    0.28178459f, -0.14367200f, -0.24589133f, 0.09644882f, 0.09976771f, -0.00231545f, -0.05981918f, 0.16397929f, 
    0.01458317f, -0.07629104f, -0.07018247f, -0.02776902f, 0.08326058f, 0.24229065f, -0.10978387f, 0.01208934f, 
    -0.13012081f, 0.09112871f, 0.15436006f, 0.04443672f, -0.28134513f, -0.08647344f, 0.01690922f, 0.00918880f, 
    0.08784837f, -0.09363319f, -0.10654870f, -0.39782342f, 0.06348907f, 0.37709168f, -0.05910104f, 0.06406374f, 
    0.11124597f, -0.18784639f, -0.06223255f, -0.07542153f, 0.07116207f, -0.33567402f, 0.20395553f, 0.35740459f, 
    -0.08384936f, -0.17330824f, -0.36933193f, 0.23343168f, -0.07230461f, 0.06298127f, -0.06554383f, -0.04392410f, 
    0.09299365f, -0.03159455f, -0.17541812f, 0.05457112f, 0.19683672f, -0.35273612f, -0.23295189f, 0.25884390f, 
    -0.54663640f, -0.04926489f, -0.13891375f, 0.07366965f, 0.00690341f, -0.00389503f, 0.41018820f, 0.38106191f, 
    0.13495967f, 0.04342705f, -0.15030347f, -0.21756229f, 0.01710265f, 0.04199730f, -0.08544102f, 0.41235340f, 
    -0.17187680f, 0.04609226f, 0.00985033f, 0.04258059f, 0.19112639f, 0.14614533f, -0.17721613f, 0.01880656f, 
    -0.06287183f, -0.03615309f, 0.03355393f, -0.11323434f, -0.12411321f, 0.02467084f, -0.09727024f, -0.41858450f, 
    0.03052171f, -0.17703618f, -0.02812447f, 0.27715972f, 0.10315561f, 0.02927125f, -0.35296014f, 0.11764880f, 
    -0.09755908f, 0.11402532f, 0.10602903f, -0.01739816f, -0.05916629f, -0.08651530f, -0.22125033f, 0.00986555f, 
    0.08971571f, 0.24756601f, 0.25124174f, -0.02603427f, -0.01036574f, 0.11789589f, -0.35014769f, 0.08407208f, 
    0.06339143f, -0.16556770f, 0.21962230f, -0.08159721f, 0.09177089f, -0.24906287f, 0.41310546f, 0.15370043f, 
    -0.09946489f, -0.02613742f, 0.19443929f, 0.00833351f, 0.05878906f, 0.10001649f, -0.29810113f, -0.50998926f, 
    -0.00744237f, 0.09748714f, 0.06177582f, -0.08058556f, 0.03597632f, -0.10345683f, 0.10659373f, 0.14600746f, 
    0.02690664f, 0.19442405f, 0.02863286f, 0.23481515f, -0.11128201f, -0.04369232f, 0.01266991f, -0.09173569f, 
    0.33218348f, -0.02813694f, -0.21038207f, 0.05009508f, -0.05696369f, 0.03503697f, -0.00216376f, 0.09728320f, 
    0.04992557f, -0.36164436f, -0.48356417f, -0.08140780f, 0.12312652f, 0.18397813f, 0.02747555f, 0.25215772f, 
    -0.04959538f, -0.15281615f, 0.18525268f, -0.09712842f, -0.11509690f, 0.23339912f, 0.06755684f, -0.06417058f, 
    -0.33618557f, -0.08301701f, 0.22287676f, 0.04004479f, -0.11198533f, 0.05506765f, -0.02353007f, -0.08476728f, 
    -0.10634907f, -0.10376847f, -0.03111171f, 0.07929179f, -0.21746686f, 0.11953942f, -0.24633555f, 0.01251646f, 
    0.23562375f, -0.15698898f, 0.14267032f, -0.25224656f, 0.02076417f, 0.09484652f, 0.21984304f, -0.01250544f, 
    -0.00026495f, 0.42088613f, 0.05073452f, 0.00109899f, 0.17724185f, 0.03715697f, 0.10852556f, 0.24233353f, 
    0.22490868f, 0.10816891f, 0.13429342f, 0.05708714f, 0.24830131f, -0.17007534f, -0.14810172f, -0.06819689f, 
    -0.07099970f, 0.13199374f, -0.16819450f, 0.01900614f, -0.06526047f, 0.28863895f, 0.01966646f, 0.01701602f, 
    -0.11140548f, 0.12354257f, -0.14809002f, 0.13407841f, 0.06499936f, -0.06984233f, 0.06769100f, 0.02358628f, 
    0.01697595f, 0.16912909f, 0.07801177f, 0.10469692f, -0.06919859f, -0.12526767f, -0.34274542f, -0.02400490f, 
    0.20454027f, 0.13495450f, 0.00578484f, 0.06262849f, 0.00615752f, -0.09675967f, 0.03320546f, 0.07667911f, 
    0.09804895f, 0.01523732f, -0.19406983f, -0.03980851f, -0.08699822f, -0.14403395f, 0.12588993f, 0.47439912f, 
    0.06913022f, 0.34740931f, -0.38171387f, -0.02786071f, -0.01697572f, 0.00888370f, -0.34128210f, -0.14797713f, 
    -0.04429153f, 0.14205088f, 0.15445288f, -0.23787591f, 0.20093088f, 0.03949481f, 0.25330034f, 0.26069015f, 
    0.18912663f, 0.13039009f, -0.00865857f, 0.12368830f, -0.07589613f, -0.08243893f, -0.14279902f, 0.10882648f, 
    -0.16298102f, 0.16423512f, -0.01784836f, 0.08541493f, -0.13650823f, 0.22619554f, 0.04936400f, -0.05622981f, 
    -0.09294331f, 0.38083023f, -0.35828274f, -0.10396987f, -0.04159440f, -0.01523652f, -0.42290029f, 0.15262522f, 
    0.10316569f, 0.02705417f, 0.02434442f, 0.10426030f, 0.08662841f, -0.01908845f, 0.08641687f, -0.22592154f, 
    0.11347226f, -0.07531574f, 0.35009247f, 0.12409672f, 0.05471713f, -0.10527844f, 0.03338588f, -0.00568701f, 
    0.08212307f, -0.00853672f, 0.11259843f, 0.09708452f, 0.23626290f, -0.09600998f, -0.00002892f, -0.03162164f, 
    -0.30227089f, -0.07104944f, 0.21291305f, -0.14000019f, -0.01960706f, 0.04308087f, -0.19280846f, -0.23024052f, 
    -0.03459430f, -0.14956093f, -0.18112706f, 0.06026041f, -0.03433779f, 0.04763808f, 0.24217263f, -0.14962226f, 
    0.02534805f, 0.19338594f, 0.19417484f, 0.15405573f, -0.05233192f, -0.06791221f, -0.07104399f, -0.08138006f, 
    0.06178016f, -0.06052812f, 0.11022746f, -0.09763478f, -0.09097446f, 0.22297975f, -0.03642156f, 0.03769397f, 
    -0.01374891f, -0.18611230f, 0.08220901f, -0.07172355f, 0.19460283f, 0.37965554f, 0.11691771f, 0.24617089f, 
    -0.04540281f, -0.19780122f, 0.18054049f, 0.07296207f, 0.09823972f, -0.09303571f, 0.07571740f, 0.01380302f, 
    0.09655115f, -0.09719720f, 0.20345505f, -0.12388863f, -0.01013235f, 0.05923059f, 0.11611592f, -0.06185048f, 
    0.03069407f, -0.13363466f, 0.14686549f, -0.02318561f, -0.30727938f, 0.17700326f, -0.32677856f, -0.07489625f, 
    0.16914758f, 0.03383711f, 0.16344579f, -0.03890298f, 0.01672429f, 0.20319261f, -0.00299145f, 0.26631504f, 
    -0.23157340f, 0.12724265f, -0.10835455f, 0.18708633f, 0.04272047f, -0.01365749f, -0.12543209f, -0.14160599f, 
    -0.15290152f, 0.07216971f, 0.09676381f, -0.15417854f, -0.06252995f, -0.04546058f, 0.20283304f, 0.07516274f, 
    0.02803288f, -0.15476604f, 0.09925757f, 0.10522197f, 0.00034032f, -0.16861895f, -0.04575803f, 0.19866149f, 
    -0.09426577f, 0.09936894f, 0.19871870f, 0.13098121f, 0.13547079f, -0.07757421f, -0.11478363f, 0.02336933f, 
    -0.05598682f, 0.02647976f, -0.03825016f, -0.00689506f, 0.03402689f, 0.31744304f, -0.44506508f, 0.11782409f, 
    -0.12199669f, -0.08038747f, -0.04774258f, -0.07012998f, 0.07684393f, 0.02767643f, -0.07325253f, -0.05307165f, 
    0.00318666f, -0.11481369f, -0.05004735f, 0.12068374f, -0.08900338f, -0.01899643f, 0.04162338f, -0.12052205f, 
    -0.11807457f, 0.02707662f, -0.07106964f, -0.05661270f, 0.11798747f, 0.09458794f, -0.06987128f, -0.00659660f, 
    -0.07734910f, 0.06854543f, 0.04965666f, -0.08329178f, -0.06530596f, -0.02691463f, 0.02362163f, 0.10102054f, 
    -0.07466337f, 0.08422279f, 0.04032620f, 0.10286099f, 0.07668381f, -0.03639997f, 0.07897799f, 0.10271686f, 
    -0.03536260f, -0.07464310f, -0.00868959f, 0.09439708f, 0.01505582f, 0.00610951f, -0.07797667f, -0.06565769f, 
    0.08914728f, -0.09248292f, -0.00544973f, -0.13490215f, -0.09600291f, -0.09608729f, -0.07383095f, -0.04128249f, 
    -0.11644749f, 0.01419155f, 0.05556189f, -0.07358396f, 0.09409581f, -0.00005736f, 0.06458717f, -0.10539626f, 
    -0.10788666f, 0.19507585f, -0.21339253f, 0.16591710f, 0.06779669f, -0.02154237f, -0.02426758f, -0.00683981f, 
    -0.06368879f, 0.04491711f, -0.07125202f, -0.03142453f, 0.22287166f, 0.19561255f, 0.02081721f, -0.21273503f, 
    -0.24548528f, -0.08400295f, 0.21988745f, 0.08782569f, -0.08275884f, -0.31567949f, 0.52937865f, -0.13709792f, 
    -0.02442329f, -0.32863453f, -0.01816919f, -0.08672595f, 0.04308512f, -0.05994976f, 0.25069618f, 0.03358886f, 
    0.08177865f, 0.07065627f, 0.25139546f, 0.13730784f, 0.19719812f, 0.23824587f, -0.06670450f, -0.01755652f, 
    -0.13214669f, -0.07110217f, -0.21469420f, -0.06659620f, 0.21262787f, -0.03517053f, 0.08252545f, -0.29196218f, 
    -0.01595649f, -0.02020805f, 0.12478225f, -0.13567895f, 0.02428425f, -0.13780846f, 0.22123799f, -0.05182771f, 
    0.10381131f, 0.14184305f, -0.01230296f, 0.08933595f, -0.06652185f, -0.09580262f, 0.08261145f, -0.00680428f, 
    0.14777479f, 0.05989738f, 0.17967942f, 0.15873371f, -0.10005756f, -0.06044112f, -0.18109655f, -0.08587309f, 
    -0.10947635f, 0.08458272f, -0.02550382f, 0.07147136f, 0.33101735f, -0.16055830f, 0.22874194f, 0.30552331f, 
    0.00486009f, -0.12035035f, -0.26577368f, -0.29492557f, -0.01012613f, 0.29787228f, -0.32247469f, 0.00442632f, 
    0.35406992f, 0.38612410f, 0.08047635f, -0.28202960f, 0.08889253f, -0.06391072f, 0.03764411f, 0.28404337f, 
    0.08871260f, 0.21521986f, -0.19967431f, 0.16158757f, 0.17612863f, -0.06209638f, -0.21325412f, -0.00158803f, 
    -0.07080483f, 0.24574059f, -0.02808880f, 0.10160170f, -0.46110505f, -0.11403825f, -0.01318879f, -0.37018201f, 
    -0.04841054f, -0.06182519f, -0.34299538f, -0.27555218f, -0.04415986f, 0.23189385f, -0.26894248f, 0.12009813f, 
    -0.05329997f, 0.22913483f, 0.03755466f, -0.11454920f, 0.05927039f, -0.11739045f, 0.14472936f, 0.14452825f, 
    -0.25372857f, 0.11773757f, 0.10515948f, -0.08403313f, 0.08931956f, -0.06149204f, -0.12417013f, -0.02310085f, 
    0.07125706f, 0.11462224f, -0.20336452f, -0.05382614f, -0.15703921f, 0.26494601f, -0.03999267f, 0.12553953f, 
    0.43296841f, 0.19344589f, -0.04919399f, 0.00057228f, 0.08596490f, 0.06356622f, 0.38459605f, -0.04701813f, 
    -0.02492461f, 0.16720071f, 0.44834942f, -0.02958717f, 0.15497795f, 0.05805158f, 0.04281190f, 0.19697756f, 
    0.08760271f, -0.13367155f, 0.26305237f, -0.00466873f, 0.16449066f, -0.00932598f, -0.23800482f, 0.08424366f, 
    0.07535104f, -0.04178536f, -0.21300822f, 0.03526932f, 0.07031292f, 0.09300024f, -0.11886781f, 0.22440702f, 
    -0.06095675f, 0.20594837f, -0.08185064f, -0.05624351f, 0.08863463f, -0.14956175f, 0.06348144f, -0.08653566f, 
    0.06170997f, -0.09441710f, 0.14223248f, -0.09396411f, 0.06354006f, -0.24358431f, -0.03345108f, -0.09945232f, 
    -0.01260125f, 0.11312037f, -0.23663029f, 0.05597362f, 0.03698021f, 0.08370548f, -0.17202784f, -0.04828209f, 
    0.08895108f, -0.16577914f, -0.18579261f, -0.00282387f, 0.15196322f, 0.00714470f, -0.15394482f, -0.03759067f, 
    0.01399435f, -0.01692524f, 0.12046364f, 0.11026483f, -0.10126616f, -0.20985937f, 0.49605948f, -0.09716744f, 
    0.07612052f, -0.14628421f, 0.10105114f, -0.09994306f, 0.17947894f, 0.09008478f, 0.11693329f, 0.14825064f, 
    0.19776340f, 0.19627135f, 0.24247262f, 0.09268484f, 0.21592022f, 0.16649725f, -0.17638730f, -0.07230044f, 
    -0.19939698f, 0.11494336f, -0.23145904f, 0.07066587f, 0.14718986f, 0.09217428f, 0.04870478f, -0.22262868f, 
    -0.01410440f, 0.05024269f, 0.03553794f, 0.15472588f, 0.14598998f, -0.04806563f, 0.10834568f, 0.04735697f, 
    0.09457436f, 0.13227144f, 0.10534595f, 0.01638097f, -0.05192386f, -0.11173073f, 0.04664990f, -0.17447668f, 
    0.08999457f, -0.10935565f, -0.05751600f, 0.03639082f, 0.04339348f, -0.11354781f, -0.05104796f, -0.00577647f, 
    -0.00268250f, -0.07466269f, -0.01269113f, 0.00303547f, -0.09999505f, 0.01169575f, -0.13095982f, -0.10937377f, 
    -0.03463333f, 0.06315158f, -0.06536410f, 0.06367233f, -0.03370050f, 0.07420918f, 0.07560612f, -0.05436261f, 
    0.00576952f, 0.05133765f, 0.03009348f, 0.05503486f, -0.09540595f, 0.04447364f, 0.06542695f, -0.08740873f, 
    -0.04653417f, -0.12537093f, -0.05727268f, -0.03207896f, -0.00762581f, 0.05944203f, -0.10094793f, -0.03030579f, 
    0.02275500f, 0.01853416f, 0.05640485f, 0.03834561f, 0.04209369f, -0.08173072f, 0.07815560f, -0.06498440f, 
    -0.09860813f, -0.08613128f, 0.01307626f, 0.09784869f, 0.05945839f, -0.14091375f, 0.03839735f, -0.09594806f, 
    0.07561457f, -0.09770977f, -0.12581560f, -0.06684514f, 0.00012474f, -0.07769002f, 0.01718286f, -0.00612033f, 
    0.01798717f, 0.12982248f, 0.05637756f, 0.19671452f, -0.03466248f, -0.04874805f, 0.01815932f, -0.07892703f, 
    0.01449619f, -0.05292697f, 0.28890577f, 0.00365745f, 0.22661917f, -0.00007379f, 0.31092411f, -0.09886070f, 
    -0.34719348f, 0.16674377f, 0.21672462f, 0.01073551f, 0.12153476f, -0.15793589f, 0.12377023f, 0.14503312f, 
    -0.08102813f, -0.26191172f, -0.14418505f, 0.24855050f, 0.02910377f, 0.06392858f, -0.01042470f, -0.15934899f, 
    -0.10536025f, -0.07568069f, 0.00922493f, 0.16267221f, -0.05027238f, 0.21523438f, 0.35769033f, 0.00320985f, 
    0.32603303f, -0.00044191f, 0.03141814f, 0.08772568f, 0.04630134f, -0.29218388f, -0.04934249f, 0.10791622f, 
    0.04852363f, -0.38115421f, 0.12821348f, -0.21357253f, 0.11457085f, 0.06895856f, 0.17080626f, 0.11818811f, 
    0.10759190f, -0.13742562f, -0.07727014f, 0.11283701f, 0.09245628f, 0.31936657f, 0.31853795f, 0.24723327f, 
    0.05008139f, 0.04936845f, 0.00708146f, -0.02689186f, 0.04122204f, -0.01117512f, 0.09452129f, -0.00449845f, 
    0.06274528f, -0.09834392f, -0.06393634f, -0.10699014f, 0.03819892f, -0.02309824f, -0.07236026f, -0.07816155f, 
    -0.07433710f, 0.01079156f, -0.13947079f, -0.02401778f, -0.00259377f, -0.08552831f, 0.02819199f, 0.01283333f, 
    -0.06826077f, 0.08957532f, -0.04551069f, -0.13175514f, -0.14103718f, 0.12361570f, -0.10774247f, -0.04994711f, 
    0.03425366f, -0.02550777f, -0.09414392f, -0.03466853f, 0.01489777f, 0.04370987f, 0.06614620f, -0.08081447f, 
    -0.05380217f, -0.13607317f, -0.10048547f, 0.07821915f, -0.06538570f, -0.04928482f, 0.03951639f, 0.02627089f, 
    -0.09213383f, -0.14098670f, 0.08595300f, -0.12961878f, -0.04671366f, 0.07337943f, -0.11683229f, 0.00888473f, 
    0.11909030f, 0.02833620f, -0.05093395f, 0.00718786f, -0.11108544f, -0.06635116f, 0.10160017f, 0.13137804f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02445565f, 0.10124691f, -0.00718029f, -0.01292932f, 0.08694520f, 0.05967355f, 0.11759857f, -0.02843855f, 
    0.11870871f, 0.06808717f, -0.05382217f, 0.00286266f, 0.04504789f, -0.12679155f, 0.16433977f, 0.18078458f, 
    0.13963982f, -0.01527779f, -0.01769861f, 0.05564355f, 0.08519473f, 0.08128865f, 0.09275132f, -0.03970028f, 
    0.15345211f, 0.03019911f, -0.01642415f, -0.00670260f, 0.00137891f, -0.06347553f, -0.09267740f, 0.00759423f, 
    0.16601273f, 0.02439469f, 0.04025283f, 0.01658600f, -0.01195372f, -0.08140865f, 0.04588224f, -0.03445420f, 
    0.08549372f, -0.07438633f, 0.08362309f, 0.04733460f, 0.01917085f, -0.02503960f, -0.04721015f, -0.03981991f, 
    -0.09063327f, 0.13417745f, 0.13375404f, -0.09428343f, 0.22511266f, 0.15572609f, 0.18774480f, 0.13280664f, 
    -0.04537578f, 0.15647145f, 0.06044294f, -0.00657427f, 0.01466971f, 0.09040484f, 0.09103498f, -0.02162041f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.15001489f, 0.10479850f, 0.44359317f, 0.08113723f, 0.18113096f, -0.08493602f, -0.37349132f, -0.14801334f, 
    -0.40084651f, -0.03219141f, -0.02524322f, 0.08053855f, -0.03222567f, -0.10341676f, -0.04762024f, 0.04325911f, 
    -0.03086980f, 0.23296298f, -0.06373139f, -0.01603164f, -0.28434965f, -0.04767242f, -0.32112247f, -0.03350230f, 
    -0.23410697f, -0.10393518f, -0.01056731f, -0.44383159f, -0.28800711f, 0.03319975f, 0.05852510f, 0.04603063f, 
    -0.67111075f, 0.03696769f, -0.13348846f, 0.14361380f, 0.30757165f, 0.13008346f, -0.09970967f, 0.31875953f, 
    0.08486682f, -0.03391137f, -0.00318425f, -0.21949407f, 0.06760776f, 0.04973880f, 0.29582897f, 0.04364884f, 
    0.01075236f, -0.20129360f, -0.19596082f, 0.40641794f, -0.12286400f, 0.12112219f, 0.14867130f, -0.23582286f, 
    -0.04028230f, -0.00904925f, 0.07675813f, -0.30198935f, -0.06160165f, 0.05450072f, 0.18741101f, -0.06259996f, 
    -0.10546863f, -0.04156258f, 0.07522377f, 0.08940949f, 0.21835153f, -0.08946481f, -0.29091334f, 0.08679875f, 
    0.10943843f, -0.32785410f, 0.06428023f, 0.11409055f, 0.01864707f, 0.01196182f, 0.14333493f, 0.13232426f, 
    -0.38270259f, 0.33834410f, -0.11779918f, 0.20391507f, 0.20735422f, 0.19328640f, 0.07101026f, -0.01328204f, 
    0.08392777f, -0.04470726f, -0.28013417f, 0.40823114f, 0.20409419f, 0.09306555f, -0.10553080f, 0.24117339f, 
    -0.15104921f, -0.29807431f, -0.28178686f, 0.29338917f, -0.21981043f, 0.05646267f, -0.09416746f, 0.02814813f, 
    -0.07189989f, -0.11509198f, -0.19138095f, -0.27280030f, 0.22463788f, 0.03015918f, 0.08575238f, -0.12279758f, 
    -0.47491729f, -0.19790299f, 0.37244961f, -0.05441294f, 0.22470844f, 0.00320582f, -0.05040195f, 0.23284529f, 
    0.11281176f, 0.13012768f, -0.07702105f, 0.22856553f, 0.11012062f, -0.02338724f, -0.20420653f, 0.01501436f, 
    0.15927207f, -0.15092272f, -0.34581223f, 0.03667554f, -0.18815245f, 0.09735657f, -0.22460730f, 0.09985869f, 
    0.04548986f, -0.22019452f, 0.01487622f, 0.31874079f, -0.06856152f, 0.23378785f, 0.01990896f, 0.10819751f, 
    -0.42626035f, -0.26255789f, 0.22014584f, 0.27111229f, 0.11178743f, -0.32138357f, -0.27064365f, -0.03151695f, 
    -0.13324767f, -0.02237886f, 0.15369985f, -0.18586449f, 0.01821979f, 0.04702837f, 0.10460894f, -0.56153035f, 
    -0.00008703f, 0.17435865f, 0.26332620f, -0.31012926f, -0.13809521f, -0.05026340f, -0.31564167f, 0.13107800f, 
    -0.11184204f, 0.04258832f, -0.34813926f, 0.11478031f, -0.06990924f, 0.11481749f, -0.35300249f, 0.05432422f, 
    -0.50684565f, 0.19234481f, -0.39119378f, -0.29657018f, -0.29765552f, -0.10627271f, -0.13691898f, -0.18289295f, 
    -0.13017237f, 0.13998683f, -0.46981242f, 0.05701727f, 0.01227787f, -0.04719205f, 0.18755510f, -0.09239678f, 
    -0.65882236f, 0.08928902f, 0.08338609f, 0.10323654f, -0.74267107f, -0.10605986f, 0.20309317f, 0.17493007f, 
    -0.25640965f, 0.13480988f, -0.09502093f, 0.09413310f, -0.04096210f, 0.21829307f, 0.05533207f, -0.38305753f, 
    0.06515446f, -0.37589899f, 0.05569398f, 0.11772419f, -0.40105620f, 0.00462522f, 0.17702745f, 0.06161008f, 
    -0.22188914f, 0.09539582f, 0.19459362f, -0.20208304f, -0.05475778f, -0.07292599f, -0.09489347f, -0.29292861f, 
    -0.27986050f, -0.18005480f, -0.14289968f, 0.17931135f, 0.11282390f, -0.44612831f, 0.25286326f, -0.53720808f, 
    -0.00827497f, -0.09669250f, 0.15513919f, 0.24074513f, 0.04195080f, -0.58220977f, 0.13477407f, 0.05768786f, 
    0.19575085f, -0.19926037f, -0.26567510f, -0.15870088f, -0.09547481f, -0.33668688f, 0.12619250f, -0.37224233f, 
    0.05275185f, 0.28327096f, -0.59489256f, -0.09329443f, 0.06229590f, -0.07626151f, 0.00617806f, -0.04078254f, 
    -0.44645309f, -0.03571673f, -0.06313031f, -0.01053612f, -0.09668146f, 0.06944995f, 0.19169246f, -0.10707891f, 
    0.03355543f, -0.07657026f, -0.11499410f, -0.19664896f, 0.11794656f, 0.20284785f, -0.04468557f, 0.13887239f, 
    0.22995701f, -0.13705970f, -0.04865683f, -0.26742151f, 0.06137074f, -0.30425188f, 0.20016408f, 0.04626204f, 
    -0.28401035f, -0.12395380f, 0.01263605f, 0.27350447f, -0.33701941f, 0.17819180f, 0.03334923f, -0.04317111f, 
    0.20304291f, -0.07352816f, -0.12324876f, 0.01246039f, -0.29532266f, 0.44472417f, -0.02662787f, -0.17560588f, 
    -0.03813706f, -0.09506645f, 0.14440848f, 0.16471583f, -0.10545444f, 0.24012598f, 0.03778802f, 0.05770107f, 
    0.04691686f, 0.13796897f, -0.47165826f, 0.36281434f, 0.06803959f, -0.19647476f, 0.13155869f, -0.07383369f, 
    -0.00184356f, 0.06711259f, 0.11336430f, 0.00489541f, -0.02694538f, 0.02082021f, 0.07293960f, -0.08054631f, 
    -0.03703285f, -0.02687483f, -0.02856150f, 0.04279129f, -0.05700070f, 0.07298540f, 0.05100176f, -0.46445718f, 
    -0.04424176f, 0.18031617f, 0.09790261f, -0.30855405f, -0.03446824f, 0.12535940f, 0.19501744f, 0.08458995f, 
    0.18088844f, -0.26144546f, -0.25550699f, -0.06807996f, 0.10707934f, -0.04896580f, -0.12336982f, 0.00164327f, 
    0.19765267f, -0.10440844f, -0.37527409f, -0.04793991f, 0.11919824f, -0.38882861f, -0.03795770f, -0.14644647f, 
    0.02423355f, -0.34504098f, 0.26915923f, 0.12868690f, 0.11196259f, -0.69249749f, 0.15618357f, 0.10005679f, 
    0.05809202f, -0.15186211f, -0.39608461f, -0.19706741f, 0.08823346f, 0.19925544f, 0.24880257f, 0.07816344f, 
    0.11150537f, 0.02761057f, 0.06893183f, 0.08477560f, 0.16296341f, 0.31225550f, -0.09698801f, -0.01373000f, 
    0.05129379f, -0.10539284f, 0.13602109f, 0.13590312f, -0.02174509f, -0.04863988f, -0.41312173f, 0.07921988f, 
    0.07853873f, -0.09808678f, 0.31905559f, 0.00415196f, 0.12226711f, -0.00258113f, 0.28702974f, -0.05263320f, 
    -0.48334560f, 0.16735263f, 0.07684372f, 0.12753637f, -0.00622358f, -0.52473027f, 0.05724117f, 0.17464869f, 
    -0.16028099f, -0.57921362f, -0.54084057f, 0.17966636f, 0.02703490f, -0.03748374f, -0.40391585f, 0.01151559f, 
    -0.04347087f, -0.01968934f, 0.02501277f, 0.09342805f, -0.15923701f, -0.43224514f, -0.01412515f, 0.34935904f, 
    0.25387201f, 0.26266277f, -0.11127111f, -0.38821527f, 0.19354573f, -0.39661601f, 0.04455372f, -0.26619542f, 
    -0.11006922f, -0.10744289f, -0.09824777f, -0.03013890f, -0.45658740f, -0.08645870f, -0.10211979f, -0.08414131f, 
    0.20559792f, 0.21346559f, 0.28149468f, -0.32576120f, -0.03667285f, 0.00995838f, -0.14284870f, -0.13554665f, 
    -0.05193599f, -0.01143309f, 0.17604260f, -0.20378305f, -0.04796768f, 0.05259754f, -0.03368801f, 0.09420808f, 
    0.10628347f, 0.05166242f, 0.06952674f, -0.10427268f, -0.10944545f, -0.01108862f, 0.02360064f, 0.26797029f, 
    0.12044711f, 0.10921755f, -0.03450929f, -0.29931140f, -0.07519713f, 0.15069471f, -0.50663310f, -0.29329392f, 
    0.14426228f, 0.32535589f, -0.10527682f, -0.08867732f, -0.22357319f, -0.41434431f, 0.24999425f, -0.07328221f, 
    -0.08398461f, 0.03124123f, -0.07290571f, 0.17463577f, -0.04371151f, 0.20300581f, -0.05650258f, -0.00681888f, 
    -0.05272194f, 0.12068854f, 0.26092726f, -0.01880235f, 0.06706116f, 0.54613876f, 0.26647323f, -0.04896716f, 
    0.04707730f, 0.04245992f, -0.00496602f, 0.14564186f, -0.30112731f, -0.12072435f, -0.33546022f, -0.00110090f, 
    -0.04690129f, -0.38203523f, -0.05073827f, -0.02310587f, -0.32600924f, -0.04980470f, -0.42077458f, 0.12239978f, 
    0.09416722f, -0.48361191f, -0.05481575f, 0.14365244f, -0.46902308f, 0.10012133f, 0.06104531f, -0.09937947f, 
    -0.05562656f, -0.05262370f, -0.17261606f, -0.03948229f, -0.32124817f, 0.11884220f, -0.19370665f, -0.09552290f, 
    0.12275232f, -0.28721288f, 0.02542505f, -0.01188989f, 0.08536921f, 0.28348202f, -0.20147166f, -0.50052232f, 
    -0.11429877f, 0.04065575f, 0.13999383f, -0.45710015f, 0.25000668f, 0.21112743f, 0.03989646f, -0.06393006f, 
    0.31057695f, 0.03834474f, -0.31374294f, 0.00602010f, -0.13902298f, -0.21634436f, -0.00498398f, -0.14683658f, 
    0.09458859f, 0.22673827f, 0.11566381f, -0.30119413f, 0.32541743f, 0.17044145f, 0.26738036f, -0.22457621f, 
    -0.05043073f, 0.03638824f, -0.26501560f, -0.01715372f, 0.12437142f, 0.04002320f, -0.21581203f, 0.04093657f, 
    -0.23817024f, 0.19833785f, -0.34124601f, -0.06224645f, 0.15658313f, 0.31067881f, 0.20753683f, -0.14083040f, 
    -0.08658258f, -0.28064489f, 0.05429172f, 0.24187364f, -0.03899142f, -0.03880754f, -0.42340881f, -0.03160002f, 
    0.40503737f, -0.07795966f, -0.46719703f, 0.01054588f, 0.12241726f, 0.09697522f, -0.13810091f, -0.37157035f, 
    0.22254229f, 0.18706945f, -0.05906949f, -0.02998046f, 0.04803421f, -0.33854267f, -0.12011755f, 0.13509867f, 
    0.26493934f, 0.31931061f, 0.21041195f, -0.12715890f, 0.18433769f, -0.01692928f, -0.17343010f, 0.02331742f, 
    -0.44394058f, -0.10506885f, 0.10598630f, -0.32768658f, -0.04104166f, 0.09729841f, 0.00129926f, -0.10952948f, 
    -0.05649223f, -0.03569601f, -0.16922121f, -0.28105170f, 0.00636290f, -0.32684198f, -0.29831162f, 0.00890095f, 
    0.08058693f, -0.09477638f, 0.25159916f, -0.18215682f, 0.03242448f, 0.10293938f, 0.00070804f, 0.09511580f, 
    0.10928955f, 0.14456177f, 0.10044191f, -0.18635677f, -0.20174563f, -0.02194459f, 0.08047231f, -0.20305765f, 
    0.03348898f, -0.06576245f, 0.15849680f, -0.34588277f, -0.07516772f, -0.09986885f, -0.02648286f, 0.00425284f, 
    -0.08604122f, -0.12353192f, -0.36944446f, 0.01742229f, -0.55882478f, -0.11038716f, -0.10702076f, -0.00487542f, 
    0.20542924f, -0.33713582f, -0.10329892f, 0.22016154f, -0.04930424f, -0.29660985f, 0.28117159f, -0.26698411f, 
    -0.09618498f, 0.13108198f, 0.24343033f, 0.16387495f, -0.02691355f, 0.08630237f, 0.07279862f, 0.03034362f, 
    0.34358582f, -0.07524663f, 0.13931566f, -0.54979205f, 0.32121757f, 0.16064811f, 0.02443618f, 0.29761589f, 
    0.28039739f, 0.04349938f, -0.11853848f, -0.09545708f, -0.37406605f, -0.02083749f, 0.12708834f, -0.34549540f, 
    0.02611002f, 0.02478822f, -0.02287503f, -0.01936562f, 0.05445797f, -0.30530098f, 0.27744454f, 0.02618887f, 
    0.07585112f, -0.31434593f, 0.07093856f, -0.15784276f, 0.22841746f, -0.50598663f, 0.13583830f, 0.38210633f, 
    0.07131439f, -0.24887544f, -0.47629845f, -0.18286689f, -0.21708067f, -0.09775946f, -0.07598077f, -0.12950505f, 
    -0.14007530f, -0.03226152f, -0.24257722f, -0.04879592f, 0.03782867f, 0.09505589f, 0.18009897f, -0.23617896f, 
    -0.04228593f, 0.09201213f, -0.07063739f, 0.20227602f, -0.04951211f, -0.07755982f, 0.03386690f, 0.19448611f, 
    -0.24272685f, -0.44575456f, -0.19237161f, 0.19845855f, -0.38290173f, 0.29367623f, 0.30128565f, -0.11682307f, 
    0.08749281f, -0.02013275f, 0.12365006f, -0.39117044f, 0.17084011f, -0.08889017f, 0.04181688f, -0.56687993f, 
    0.01739162f, 0.29203811f, 0.36207530f, 0.31770262f, -0.06878963f, -0.53622931f, -0.23210405f, -0.19989415f, 
    0.01926787f, -0.13328463f, 0.02223880f, -0.00021018f, -0.21109140f, -0.26757452f, -0.38112846f, -0.11273374f, 
    -0.05097352f, -0.30057344f, -0.42012215f, -0.52457839f, 0.27677256f, 0.00693005f, -0.40822616f, -0.46366683f, 
    -0.09224327f, 0.04698621f, 0.02437794f, 0.24408737f, 0.03598791f, -0.05060921f, -0.32775626f, -0.00982272f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.07011792f, 0.09495187f, 0.04121112f, -0.02659553f, -0.02227962f, -0.08828638f, -0.06400461f, -0.13534996f, 
    0.02260730f, -0.05219400f, -0.02552270f, 0.04433837f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
