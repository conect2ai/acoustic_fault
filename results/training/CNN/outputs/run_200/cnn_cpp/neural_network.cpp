#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.77792233f, 0.81000769f, -0.17757386f, -0.82579362f, -0.22998632f, 0.36800629f, -0.10650128f, -0.14384964f, 
    -0.31399256f, -0.09266954f, 0.27763188f, 0.51075268f, 0.18689691f, 0.03747968f, -0.17747508f, 0.03481581f, 
    -0.23011731f, 0.29577604f, 0.35739759f, 0.20367216f, 0.05079128f, 0.16992135f, -0.23576979f, -0.24272960f, 
    0.08011666f, -0.77537680f, -0.88990319f, 0.37934977f, 0.63060552f, -0.15169230f, 0.38159779f, -0.07945232f, 
    0.53477353f, -0.11304824f, -0.58793664f, 0.24206851f, 0.08917189f, 0.43783906f, 0.51040012f, -0.15293661f, 
    -0.37731865f, 0.00490688f, -0.08842047f, -0.35283813f, 0.13134457f, -0.33981058f, -0.12655553f, -0.00860348f, 
    -0.26075453f, -0.16115272f, -0.76760936f, 1.03984594f, -0.53094518f, -0.44372365f, 0.36020252f, 0.21709999f, 
    -0.62241960f, -0.63046467f, -0.07449603f, -0.23481359f, -0.11973942f, -0.20822473f, -0.61374247f, -0.02644108f, 
    -0.33635497f, -0.23132710f, -0.15334749f, -0.01903042f, -0.50942969f, -0.20268928f, -0.37301132f, -0.11424206f, 
    0.14128679f, 0.03420952f, -0.12927113f, 0.76710004f, 0.57528710f, -0.93932599f, -0.54292023f, -0.08835771f, 
    -0.36050075f, -0.15769087f, 0.05770139f, 0.41719836f, 0.03039104f, -0.42940345f, -0.15183550f, 0.35793647f, 
    0.08629453f, -0.05201510f, 0.35802841f, -0.18743438f, 0.24400860f, 0.10798926f, 0.31015348f, 0.07066499f, 
    0.36361107f, -0.04500145f, 0.23052831f, -0.12652431f, 0.69651645f, 0.73276258f, 0.20208381f, 0.37120986f, 
    -0.21077855f, -0.04907195f, -0.64292550f, 0.43327135f, -0.36865732f, 0.76763022f, -0.02812707f, -0.07204560f, 
    -0.05337944f, -0.22422379f, 0.06624230f, -0.09765568f, -0.03765481f, -0.10384181f, -0.14108166f, -0.00132153f, 
    0.18189612f, 0.38849905f, 0.05948468f, 0.03362267f, -0.01443782f, -0.06324795f, 0.70667934f, 0.26709744f, 
    -0.32577243f, -0.22052129f, -0.62943804f, -0.25428063f, -0.72707772f, -0.93655181f, -0.56515545f, 0.12757070f, 
    0.34711772f, 0.23714203f, 0.08276030f, -0.20089899f, 0.14899734f, -0.04051963f, 0.05625241f, 0.21425308f, 
    -0.05503405f, 0.29772872f, 0.10197984f, -0.04597002f, 0.04912158f, 0.24785344f, 0.98285615f, 0.15766111f, 
    0.15418860f, -0.00958116f, -0.10136759f, -0.32385194f, 0.02189392f, 0.01755628f, 0.24625769f, 0.57880843f, 
    -0.09674075f, 0.13073148f, 0.25842369f, 0.22388807f, -0.22446400f, -0.26223925f, 0.14175282f, -0.25598007f, 
    -0.27777734f, 0.25131416f, -0.10272369f, -0.05924639f, -0.07296156f, 0.23381756f, -0.25819504f, 0.29956681f, 
    -0.63888484f, 0.21624094f, 0.30843419f, 0.93955666f, 0.51103145f, 0.60247725f, 0.62189651f, 0.34063539f, 
    0.10653325f, 0.02638030f, 0.16814356f, -0.16273664f, 0.23229124f, 0.02377252f, -0.20130359f, -0.23827352f, 
    -0.03045177f, 0.15696372f, 0.18603414f, 0.38095990f, 0.01681824f, -0.00747111f, -0.15689415f, 0.28180107f, 
    -1.30607343f, 0.75061256f, -0.30953008f, -0.13691510f, -0.80062288f, 0.36756548f, 0.34644589f, -0.58992064f, 
    0.61771190f, 0.16200250f, -0.30656511f, -0.15486830f, 0.22109649f, -0.10682922f, 0.26299217f, 0.02248930f, 
    -0.26651749f, 0.12511960f, 0.18419766f, -0.02079269f, 0.12784503f, -0.08891521f, 0.08095142f, 0.16181655f, 
    0.35606509f, -0.56972271f, -0.99203169f, -0.36070675f, 0.30412319f, -0.28783992f, -0.64012045f, -0.10174672f, 
    0.64736110f, -0.44062471f, -0.36591944f, 0.07425441f, -0.02270013f, -0.00100229f, 0.34030584f, 0.23931687f, 
    0.05345177f, 0.15922591f, -0.14584084f, -0.12255865f, -0.29718992f, 0.09806010f, -0.20942679f, -0.09806963f, 
    0.00421404f, -0.13405941f, 1.00475752f, 0.51039195f, 0.35031080f, 0.89579326f, 1.01117229f, 0.49847054f, 
    0.11741873f, -0.24129024f, -0.33933076f, -0.12998058f, 0.03033631f, 0.13881996f, -0.09535943f, 0.12019113f, 
    -0.08075151f, 0.11164399f, 0.01178123f, 0.17091046f, -0.10197455f, 0.14368689f, 0.08818176f, 0.02234294f, 
    0.18500960f, 0.05129193f, 0.10865205f, 1.12604237f, 0.35236439f, -0.10994849f, 0.91467988f, 0.72290653f, 
    -0.09769387f, -0.32183692f, 0.14919686f, -0.02853389f, 0.03947755f, -0.33121282f, -0.02644996f, 0.23209186f, 
    0.09609861f, -0.11326209f, -0.20935105f, -0.15917592f, 0.21416928f, 0.06208323f, -0.04713701f, 0.36465475f, 
    0.27646104f, 0.11622842f, -0.29562324f, 0.00124438f, 0.12536681f, -0.10615321f, -0.60366511f, -0.60756242f, 
    -0.56051791f, -0.07813536f, 0.55192828f, 0.35902214f, 0.26192564f, 0.50385439f, 0.19974232f, -0.04593606f, 
    -0.25839609f, -0.10491022f, 0.06916178f, -0.19680631f, -0.01976875f, -0.32318088f, 0.33444107f, 0.35203287f, 
    0.01142861f, -0.23233545f, 0.10898137f, 0.16070853f, -0.33184722f, -0.12596060f, -0.63084024f, -0.51939708f, 
    -0.53244752f, -0.29678053f, 0.42060387f, -0.35075736f, -0.44622481f, -0.34022400f, -0.32881659f, 0.46924323f, 
    0.43599546f, 0.38735610f, 0.45223048f, -0.24912150f, -0.29216346f, -0.07976394f, -0.10326978f, -0.17261192f, 
    0.48148650f, 0.23357540f, -0.12419613f, -0.02502005f, -0.06310470f, -0.26505217f, 1.02360988f, -0.62442321f, 
    -0.37996835f, -0.16528869f, 0.07130644f, -0.02015086f, 0.43217146f, 0.06572749f, 0.39109266f, 0.40338030f, 
    -0.16180423f, 0.50131243f, -0.40734723f, 0.36191323f, -0.02748329f, 0.10455494f, -0.28942129f, -0.39122185f, 
    -0.18375494f, -0.13181204f, -0.15371184f, 0.24595547f, 0.05345250f, 0.26788503f, -0.18480788f, 1.04936624f, 
    0.46315143f, 0.66325009f, 0.45865443f, -0.23669203f, 0.15269235f, -0.55033475f, -0.10586590f, 0.26703048f, 
    0.16421093f, -0.03200937f, 0.23288460f, 0.15080670f, 0.01394151f, 0.31232888f, 0.25941476f, 0.24623226f, 
    -0.08155641f, -0.34479690f, 0.25656798f, 0.01835224f, -0.03910952f, -0.08215524f, 0.10758402f, 0.34564647f, 
    0.46444204f, 0.19221085f, -0.85947371f, -1.02629256f, 0.04950443f, -0.26429278f, 0.43765667f, 0.29526636f, 
    0.03014493f, 0.40436503f, 0.30684489f, -0.48903912f, -0.11111896f, -0.46036947f, 0.26425096f, 0.10825646f, 
    0.31885430f, 0.03465365f, 0.11799293f, -0.27545515f, -0.18305704f, 0.04141483f, 0.06908113f, -0.22986887f, 
    0.13227689f, -0.30006924f, -0.74539214f, -0.41054383f, -0.39721122f, -0.61551756f, -0.52419472f, -0.05144268f, 
    -0.10025676f, -0.48862880f, 0.34422567f, -0.13808048f, 0.38808566f, 0.36176628f, 0.06450447f, 0.19486144f, 
    0.19763188f, -0.12913384f, 0.12361322f, 0.35951304f, 0.50031400f, 0.03902869f, 0.07020068f, -0.15682870f, 
    -0.10902857f, -0.09790416f, 0.75797111f, -1.20896101f, -0.21542823f, 0.45626739f, 0.54889107f, -0.79852629f, 
    0.60380906f, 0.06095178f, -0.68441302f, 0.42812151f, 0.45337266f, 0.12336842f, -0.18481061f, -0.03056433f, 
    -0.10131791f, -0.27708516f, 0.02650696f, 0.13929899f, 0.32373095f, -0.46202567f, 0.02060005f, 0.19184478f, 
    0.09354422f, 0.01805393f, -0.04892216f, 0.61689985f, -0.23614936f, 0.11197369f, -0.33571926f, -0.50356209f, 
    0.29050174f, 0.41856086f, 0.58030444f, 0.36081672f, 0.08085003f, 0.23767474f, 0.30230156f, 0.03763686f, 
    -0.16935354f, -0.29396236f, 0.35255706f, 0.05115217f, -0.27631330f, -0.05138376f, -0.09926926f, -0.17919357f, 
    -0.13246267f, 0.05371071f, 0.19271111f, -0.23647678f, 0.69755274f, -0.08955020f, 0.65807950f, 0.50698978f, 
    0.35512450f, 0.61334050f, 0.48052984f, -0.65168267f, -0.26285356f, -0.38571331f, 0.28467584f, 0.46615037f, 
    -0.31239641f, 0.38143650f, -0.27323774f, 0.36609554f, 0.09068208f, -0.07584029f, 0.21467492f, -0.06362617f, 
    -0.08988482f, -0.01781185f, 0.05593665f, -0.15675706f, 0.23942840f, -0.25117931f, 0.10937082f, -0.37518767f, 
    -0.78222692f, -0.48255607f, 0.33919984f, 0.44613653f, -0.40374932f, 0.08363736f, 0.61740124f, -0.16076535f, 
    -0.10405746f, -0.32486203f, -0.29075438f, -0.47808674f, 0.02729454f, 0.09330771f, 0.22936289f, 0.13864835f, 
    0.06496106f, 0.03580320f, 0.05362974f, -0.28880668f, -0.24012105f, 0.18767080f, 0.70552391f, 0.24754572f, 
    0.31214866f, 0.51356667f, 0.07346878f, 0.32984656f, 0.47555238f, 0.55098873f, 0.47706479f, 0.46846214f, 
    -0.12747492f, 0.28333247f, -0.16132340f, -0.28867850f, -0.10879791f, -0.14793707f, -0.17319131f, 0.11925677f, 
    -0.03493154f, -0.08699545f, -0.24011888f, -0.14653663f, -0.36493990f, -0.04022073f, -0.14288695f, -0.16921248f, 
    0.40326524f, -0.67908674f, -0.53259307f, -0.33881551f, 0.62532556f, 0.20858920f, 0.38985977f, 0.00100186f, 
    0.62767768f, -0.10651478f, -0.08445191f, 0.05031628f, -0.21285670f, -0.59432667f, -0.05269859f, 0.26922435f, 
    -0.02789752f, -0.10946024f, 0.04111199f, -0.05608943f, -0.16814435f, -0.20850632f, -0.17849825f, 0.16983329f, 
    -0.21276802f, 0.16497044f, 0.32863465f, 0.37758389f, -0.18624124f, -0.61591738f, -0.70095581f, -0.14886126f, 
    0.29404882f, -0.60912281f, 0.48274544f, 0.29154715f, 0.15703802f, -0.20991205f, -0.06384803f, 0.01132181f, 
    0.07774077f, 0.20756246f, 0.17583974f, -0.00458452f, 0.35319102f, 0.21245804f, -0.11849326f, -0.03498814f, 
    -0.28911576f, -0.84060127f, -0.15128490f, -0.46043137f, -0.00549684f, -0.24693923f, -0.76930916f, -0.39674529f, 
    -0.48367977f, -0.13941209f, 0.15464412f, -0.15000993f, 0.14456946f, 0.08062303f, 0.20056324f, -0.32233530f, 
    -0.13160971f, -0.22240196f, 0.36451113f, -0.31154761f, -0.44074991f, 0.04598173f, 0.11617885f, -0.21085498f, 
    -0.10816845f, 0.21511884f, 1.05144405f, 0.33937037f, 0.65480345f, -0.72080433f, -0.13307539f, 0.03445172f, 
    -0.58251464f, 0.21551250f, 0.07744800f, 0.23683928f, 0.15486391f, 0.22349960f, -0.35105297f, 0.20804445f, 
    0.15317698f, 0.21098198f, -0.06660763f, -0.10925663f, -0.03172274f, -0.16035022f, 0.27592537f, 0.50785643f, 
    -0.34627190f, 0.18538071f, 0.40918413f, -0.45572770f, -0.94073725f, 0.26914361f, 0.31018713f, 0.36847270f, 
    0.22409956f, 0.22110687f, 0.90132195f, -0.61153448f, 0.25965270f, 0.10835772f, -0.27242258f, 0.00200080f, 
    -0.05689946f, -0.11931214f, 0.02004570f, 0.50234318f, -0.32585478f, 0.05495350f, 0.25587174f, -0.04757327f, 
    0.12388527f, 0.26292771f, 0.09894493f, -0.02252447f, -0.85390776f, 0.35284799f, -0.08060078f, -0.82654983f, 
    -0.43309349f, 0.41677764f, 0.36268890f, -0.40834025f, 0.55380726f, 0.27424055f, -0.10108433f, 0.03909311f, 
    -0.39474100f, 0.08453993f, -0.47995365f, -0.11375600f, 0.29667544f, -0.16927783f, 0.20914789f, -0.08774392f, 
    0.11467601f, -0.00351898f, -0.16212299f, -0.00563177f, -0.06943202f, 0.29119268f, 0.29293737f, -0.69210047f, 
    0.36945841f, 0.28421414f, -0.16663289f, -0.50660753f, -0.44774929f, -0.33433372f, 0.12733981f, 0.02468360f, 
    0.33040455f, -0.04607946f, -0.11853407f, 0.35642138f, 0.29729730f, 0.24408455f, 0.22106552f, -0.32128164f, 
    -0.25320479f, 0.10019210f, -0.27330995f, -0.06714377f, 0.53914815f, 0.32653734f, -0.16768791f, -0.65776241f, 
    -0.80609161f, -0.67779523f, 0.24700436f, 0.21309052f, 0.45286122f, -0.09201404f, 0.34453034f, 0.24948111f, 
    -0.38729647f, -0.06387309f, 0.04545275f, -0.28726053f, -0.36748606f, 0.24611419f, -0.12684940f, -0.21612829f, 
    -0.25935352f, -0.08394130f, 0.09348979f, -0.26608935f, 0.12292989f, 0.09695507f, -0.23435237f, 0.65777028f, 
    0.19508901f, 0.00559124f, 0.01677803f, -0.80720764f, 0.18881479f, -0.63655847f, -0.59637100f, -0.51789397f, 
    -0.66150755f, -0.05694627f, -0.22080500f, 0.49382859f, -0.21215540f, -0.29967675f, -0.05552820f, -0.21129185f, 
    -0.00882775f, 0.12527631f, -0.34444055f, 0.15419982f, -0.04448453f, 0.21635664f, 0.10150568f, 0.36536008f, 
    0.59263825f, 0.07920626f, 0.36338994f, 0.76632077f, 0.59728879f, 0.61661726f, -0.18052396f, 0.23516831f, 
    0.25273657f, 0.32725033f, -0.32683536f, -0.37023261f, -0.37274006f, -0.09680505f, -0.49112129f, 0.10435515f, 
    0.20487031f, 0.31430471f, -0.20377262f, -0.29879808f, 0.08058979f, 0.00276141f, -0.09966325f, 0.27372584f, 
    0.32431072f, 0.05799419f, 0.37348419f, -0.26857838f, -0.27986255f, 0.20560023f, -0.04904117f, -0.30391696f, 
    0.59631330f, 0.52442932f, 0.62462080f, 0.04533694f, -0.48232847f, 0.10298810f, 0.35752809f, 0.27124900f, 
    0.34539497f, 0.14101669f, -0.31294575f, 0.21358457f, 0.30578592f, -0.25612536f, 0.16340820f, 0.07988093f, 
    0.26752457f, 0.27367833f, -0.61899275f, 0.92233270f, 0.03859062f, -0.47125101f, 0.43537441f, 0.00692500f, 
    -0.19007659f, -0.03313975f, -0.62024319f, 0.15383451f, -0.41394070f, 0.03157170f, 0.32324943f, -0.05624569f, 
    0.24361299f, 0.10323935f, 0.14870140f, -0.18427019f, 0.21240896f, 0.26663727f, 0.34555089f, -0.05550743f, 
    -0.16314644f, -0.30042452f, -0.27864981f, 0.72986615f, 0.17069350f, 0.37978581f, -0.09152961f, 0.20738263f, 
    0.32493699f, 0.53354007f, 0.38965315f, 0.48942262f, 0.54051608f, -0.21666849f, -0.19012183f, -0.34630388f, 
    -0.21905372f, 0.01406652f, -0.19077013f, 0.16615996f, 0.13544014f, 0.38627109f, 0.26893610f, -0.07413773f, 
    -0.12373201f, 0.05342114f, 0.18950829f, 0.18702884f, -0.75825584f, 1.19889510f, -0.39808014f, -0.65416247f, 
    -0.12433399f, 0.61750007f, 0.34793398f, -0.35878736f, 0.36869916f, 0.00829322f, -0.07820706f, -0.14197594f, 
    -0.01748159f, 0.42286864f, 0.19397193f, 0.19474478f, -0.11823945f, -0.10400613f, -0.09105464f, -0.09165719f, 
    0.09132402f, -0.10971119f, 0.20022671f, 0.19770518f, -0.14086169f, -0.97551501f, 0.78942567f, 0.27582327f, 
    -0.66060525f, 0.66049379f, -0.48037162f, 0.69281495f, -0.24629438f, -0.51266944f, -0.49121022f, -0.18195924f, 
    0.38820621f, 0.30814984f, 0.13990258f, -0.17251666f, -0.14111015f, -0.03842059f, -0.00518487f, 0.19204271f, 
    0.27073765f, 0.03599527f, -0.06555571f, 0.15875182f, 0.39396337f, -0.02644944f, 0.63380498f, 0.71906477f, 
    -0.21397263f, -0.07850361f, -0.26917201f, 0.39338335f, -0.03164500f, -0.11631908f, 0.40576646f, 0.37110701f, 
    -0.22305557f, -0.08826132f, -0.25627282f, -0.33214492f, -0.39576641f, -0.37121400f, -0.28898352f, -0.20815833f, 
    -0.14473766f, -0.38595998f, -0.48738045f, 0.14119586f, -0.38588381f, 0.18529175f, 0.10008255f, 0.49326900f, 
    0.01851604f, -0.33806619f, -0.53117281f, 0.45976683f, 0.74423093f, -0.08575906f, 0.42150024f, 0.22165315f, 
    0.21582438f, -0.47462544f, -0.29295444f, -0.52886438f, -0.36299434f, 0.22304307f, -0.08327807f, 0.04567728f, 
    -0.12084568f, 0.05925933f, 0.25667858f, -0.22066332f, -0.24253614f, -0.21620072f, -0.01075440f, -0.42161092f, 
    -0.31615832f, 0.28927147f, -0.23100604f, 0.36682430f, -0.40221861f, -0.17506522f, -0.69514894f, -0.55029297f, 
    0.07034110f, 0.18905720f, -0.05971488f, 0.36184424f, 0.00537554f, 0.20671374f, -0.22219524f, -0.13660313f, 
    0.51761407f, -0.28723407f, 0.09080201f, -0.19289620f, -0.52290577f, 0.15574336f, 0.33740887f, -0.26532021f, 
    0.08541896f, -1.03207624f, -0.20664005f, -0.78136605f, 0.33779982f, -0.15197861f, 0.51271665f, 0.39252758f, 
    -0.63363272f, 0.36436209f, -0.39670351f, 0.02630997f, 0.06907461f, -0.12465987f, 0.23577593f, 0.16403431f, 
    -0.19754925f, 0.22877645f, -0.02194181f, -0.24575558f, -0.16772711f, 0.04507828f, 0.18010804f, 0.21482754f, 
    -0.11601449f, 0.04576242f, -0.07348843f, 0.55824465f, 0.66279298f, -0.06321820f, 0.22965296f, -0.35690153f, 
    0.12707496f, 0.40433028f, -0.00486721f, 0.24303509f, 0.05445336f, -0.26714948f, 0.26405820f, 0.13815595f, 
    -0.25993612f, 0.24311596f, -0.10224194f, 0.03305078f, 0.16928515f, 0.26967987f, -0.24652080f, -0.47766304f, 
    -0.34904081f, -0.15865910f, 0.11420412f, -0.41331279f, -0.62009555f, -0.36235604f, -0.21182521f, -0.36564279f, 
    0.45125958f, 0.81975371f, -0.16778800f, 0.30642787f, 0.34272918f, 0.06250285f, -0.37087077f, -0.10170700f, 
    -0.33674645f, 0.34138539f, -0.08870663f, 0.30402920f, -0.07276458f, 0.24284405f, 0.02938613f, 0.04968752f, 
    -0.27278033f, -0.26966566f, 0.31142521f, -0.18563767f, 0.41175511f, -0.84779364f, -0.84944874f, 0.73104846f, 
    -0.25376233f, 0.23551165f, 0.74892265f, 0.17312990f, 0.55042768f, 0.04562512f, -0.09615509f, 0.18207619f, 
    -0.07989729f, 0.26195133f, -0.29284817f, 0.11325176f, -0.35304746f, -0.08104823f, -0.16605982f, -0.14336088f, 
    0.01254207f, 0.09617734f, -0.17911282f, 0.13328211f, 0.18036868f, -1.01798213f, 0.73883855f, 1.21605968f, 
    -0.41021654f, -0.22193766f, 0.64337361f, 0.04753382f, -0.23384979f, 0.29022482f, -0.50987619f, -0.02579523f, 
    0.23233940f, -0.18120404f, -0.09224153f, 0.18143094f, -0.06335907f, 0.17139632f, -0.17119037f, -0.31938338f, 
    0.04050986f, -0.10018305f, 0.02231675f, -0.26675770f, -0.05889317f, -0.19391970f, -0.32149231f, -0.80003619f, 
    -0.76497823f, -0.34843540f, -0.42271775f, -0.69204992f, 0.55275047f, 0.68489683f, -0.29778543f, 0.20674741f, 
    0.25254729f, -0.18661752f, 0.38171309f, 0.24510227f, -0.15486471f, -0.04430802f, -0.16350403f, 0.03451236f, 
    -0.23269057f, 0.01118731f, 0.18229093f, -0.04246196f, 0.18633859f, -0.11195663f, 0.03624182f, 0.80076498f, 
    0.65309691f, 0.81231821f, 0.52975577f, 0.62706840f, -0.31539324f, 0.17812708f, -0.16652140f, -0.32776380f, 
    -0.36909711f, -0.32386723f, -0.03422541f, -0.16946132f, 0.27287838f, 0.34695405f, 0.09255332f, -0.21296832f, 
    0.17214876f, 0.15289378f, -0.08245026f, -0.07666454f, -0.00765382f, -0.09720729f, 0.14170316f, 0.15829851f, 
    0.51352352f, -0.23114452f, -0.83301443f, 0.15575662f, 0.13059272f, -0.77514064f, 0.73188829f, 0.83547932f, 
    -0.45948797f, 0.16915517f, 0.32095572f, -0.33183542f, 0.36964303f, -0.62653863f, 0.40168080f, -0.28621799f, 
    -0.04561923f, -0.24534748f, -0.00316037f, -0.31131056f, 0.06358931f, -0.19891070f, -0.19516964f, 0.00685887f, 
    0.08845289f, 0.35472390f, 0.27954641f, 0.31721342f, 0.81495893f, 0.95998424f, 0.58762252f, -0.14669915f, 
    -0.40468770f, -0.00926147f, 0.15597409f, -0.37778440f, -0.05579470f, 0.03133352f, -0.01028674f, -0.04110701f, 
    0.09501792f, -0.02638565f, 0.15856145f, 0.47237226f, 0.41799873f, 0.09056491f, 0.30696976f, -0.25974679f, 
    -0.38355225f, -0.15329824f, -0.94044334f, 0.07949907f, 0.40420812f, -0.45861933f, -0.01910288f, -0.52569604f, 
    0.66755909f, 0.21801023f, 0.26057777f, -0.29254261f, -0.05699168f, -0.13734935f, -0.16590700f, -0.10823727f, 
    -0.22851835f, 0.19779935f, -0.30984750f, 0.43137908f, -0.06850164f, -0.33558911f, 0.26002029f, 0.20576553f, 
    -0.00592891f, -0.07202213f, -0.33561572f, 0.70809019f, -0.16329777f, 0.52922791f, 0.39761850f, 0.40593049f, 
    0.51154733f, -0.69931048f, -0.53432351f, -0.43443239f, -0.38521382f, 0.18139760f, 0.00213869f, -0.21093377f, 
    0.01068789f, 0.30157354f, -0.02644567f, -0.08655991f, -0.42501813f, 0.04579217f, 0.29378021f, 0.45213428f, 
    0.08444726f, 0.00019179f, 0.12223988f, 0.28319210f, 0.34357360f, -0.93129206f, 0.74686408f, 0.72734940f, 
    0.60953784f, -1.09488761f, 0.23774020f, -0.33241335f, -0.48479310f, 0.17652351f, 0.47872397f, 0.58960253f, 
    -0.24585918f, -0.13639823f, 0.18399282f, -0.49722543f, 0.12231007f, -0.24617563f, 0.05144317f, 0.09452883f, 
    0.03941099f, 0.11475603f, 0.13085738f, -0.11258188f, 0.02649049f, -0.52194434f, 0.15746838f, -0.55501932f, 
    -0.17576863f, -0.22947204f, 0.68256426f, -0.02688790f, -0.41183951f, -0.10794296f, 0.60905582f, -0.29830092f, 
    -0.21696274f, 0.09658502f, -0.37731948f, 0.23013881f, 0.20500325f, 0.42852822f, -0.00212128f, -0.12821521f, 
    0.16803320f, -0.26231733f, -0.41285250f, -0.20482191f, -0.27725399f, -0.13515280f, -0.45082396f, -0.94238847f, 
    -0.57988477f, -0.08268318f, -0.08945906f, 0.38237059f, 0.56770527f, 0.30465057f, 0.20810369f, 0.50302106f, 
    -0.04646264f, -0.24416119f, 0.01520720f, 0.19226079f, -0.01545934f, -0.03398824f, -0.13447553f, 0.24531871f, 
    -0.00198919f, -0.07584306f, 0.32032984f, -0.47779590f, 0.25369269f, 0.27595815f, 0.31892496f, 0.07765248f, 
    -0.19790767f, 0.63484925f, -0.01146943f, 0.64530492f, 0.45205876f, 0.15379563f, -0.03379510f, 0.21672039f, 
    -0.30159131f, 0.28613782f, 0.17532547f, 0.19705693f, 0.13799289f, 0.28411493f, -0.14359327f, -0.09502660f, 
    -0.08239509f, -0.16979115f, 0.41175291f, -0.32602316f, 0.15687132f, 0.38228300f, 0.07606072f, 0.33903888f, 
    0.24139871f, 0.07552513f, 0.80035812f, 0.19808184f, -0.00524419f, 0.07491583f, -0.09957059f, 0.07402664f, 
    0.47833803f, 0.02624074f, -0.32524091f, -0.12412673f, 0.12001073f, -0.31306332f, 0.01873151f, -0.42241743f, 
    0.31056875f, -0.34450108f, -0.29120252f, -0.19717512f, 0.24835072f, 0.01163489f, -0.22160876f, -0.32643780f, 
    -0.11872761f, -0.71877867f, -0.49363750f, -0.30473235f, -0.05538487f, 0.54039222f, -0.64850986f, -0.34448701f, 
    -0.19665250f, -0.34990576f, -0.13058855f, 0.19187950f, 0.36871287f, 0.31132883f, -0.03554625f, -0.01276787f, 
    0.36143142f, -0.18429005f, -0.03451123f, 0.31225550f, -0.05154425f, -0.21652339f, -0.01053730f, -0.04186543f, 
    0.17690653f, -0.33230376f, 0.26110497f, 0.14488333f, 0.65477580f, 0.62580746f, 0.20253749f, -0.27608112f, 
    0.04029054f, -0.21968763f, 0.49929565f, -0.06974242f, -0.36076826f, -0.25233936f, -0.29005164f, -0.01256074f, 
    -0.15450838f, 0.37244523f, 0.36918494f, -0.14938851f, 0.27450997f, 0.02844679f, -0.23015076f, -0.22150943f, 
    0.11393212f, 0.28692108f, 0.30928162f, -0.89921165f, -0.37867025f, 0.13888837f, 0.84274036f, -0.27907997f, 
    0.65144521f, 1.01530850f, 0.15817271f, 0.02260474f, 0.51599622f, -0.26743394f, -0.30036500f, -0.24513054f, 
    0.21712989f, 0.15807059f, -0.37016955f, 0.05512335f, -0.38231435f, 0.14342256f, -0.02918313f, -0.04524598f, 
    0.20176277f, 0.15125851f, -0.23351471f, -0.09076210f, -0.52370816f, -0.31792757f, 0.50095826f, 0.17322943f, 
    -0.22025459f, -0.55270773f, 0.37398627f, 0.06538253f, -0.21080075f, -0.43700916f, 0.40350831f, -0.09704116f, 
    0.16236928f, -0.44580802f, -0.01714429f, 0.24198341f, 0.37375647f, 0.05414483f, 0.32250863f, 0.35310575f, 
    0.24246652f, 0.28734121f, -0.43043897f, -0.31714401f, -0.22732377f, 0.54289103f, 0.82213044f, 0.61114454f, 
    -0.28485566f, -0.46142530f, -0.07793213f, 0.46156573f, -0.73116076f, 0.04278619f, 0.45360619f, 0.20865600f, 
    0.42626554f, -0.09632891f, -0.22048558f, 0.16667624f, -0.17900920f, -0.32756615f, 0.15047303f, -0.07153814f, 
    -0.04652910f, 0.05241681f, -0.00447977f, 0.34268495f, 0.23671164f, -0.28516626f, -0.08022977f, -0.09580810f, 
    0.20973867f, 0.61172622f, -0.51594663f, -0.66863149f, -0.33637133f, 0.05462223f, 0.42372289f, -0.20811029f, 
    -0.34450006f, -0.07218953f, 0.03892814f, 0.18904321f, -0.27627930f, -0.24276736f, -0.24387746f, 0.18534131f, 
    0.25406849f, 0.17366973f, -0.30739003f, 0.12245058f, -0.45807728f, -0.05986512f, -0.22367220f, -0.01381528f, 
    0.08384277f, 0.41940209f, 0.47471961f, 0.09670821f, 0.51003939f, -0.19195367f, -0.58190024f, 0.38480118f, 
    0.56285286f, -0.27637288f, -0.02907521f, -0.50643879f, 0.50475836f, -0.38144535f, 0.13799466f, -0.17400914f, 
    0.11631865f, -0.25429443f, -0.04836344f, 0.19944385f, 0.07556269f, -0.09541623f, -0.07029382f, -0.30255225f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06189800f, 0.06244059f, 0.20972836f, 0.10135963f, 0.25033504f, 0.31700870f, 0.09231763f, 0.26302132f, 
    -0.00367429f, 0.20899838f, 0.14638428f, 0.06941541f, 0.04241343f, 0.07195932f, -0.05561039f, 0.15668856f, 
    0.21721794f, 0.07359954f, 0.15259625f, 0.24689505f, 0.01925985f, -0.10561796f, 0.05599084f, 0.00685814f, 
    0.19522028f, 0.19849500f, 0.01515656f, 0.29161420f, 0.13223676f, 0.23875026f, -0.04330729f, 0.05719333f, 
    0.25468895f, 0.23685902f, 0.11691684f, 0.11768497f, -0.13564682f, 0.32868624f, 0.01358123f, -0.19731833f, 
    0.17570350f, 0.10699354f, 0.04155664f, 0.01727784f, 0.17554225f, 0.14379516f, -0.01324523f, -0.04857680f, 
    -0.07324932f, 0.18580742f, 0.25411558f, 0.35992074f, 0.03167937f, -0.13933262f, 0.11637220f, 0.26453662f, 
    0.10451824f, 0.06922707f, 0.21023238f, 0.12893444f, -0.02824143f, 0.02608226f, 0.02652265f, 0.12199954f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22302368f, 0.12268443f, 0.17158084f, -0.30524302f, -0.04509843f, 0.02590826f, 0.04210222f, 0.00788517f, 
    0.10334285f, -0.03545965f, -0.09273800f, 0.01602999f, -0.21949400f, 0.05704512f, -0.03773890f, 0.14528978f, 
    0.03581997f, 0.08589733f, 0.05088386f, -0.01566968f, 0.05781057f, -0.05008507f, -0.03559753f, -0.05613934f, 
    -0.01049912f, 0.00726982f, 0.17241119f, -0.09270409f, 0.04753618f, -0.03053493f, 0.04608680f, -0.05226094f, 
    0.04698985f, -0.07040442f, -0.02567025f, -0.05383841f, -0.14885989f, -0.05315271f, 0.09465455f, -0.33688754f, 
    -0.07780782f, -0.04373589f, 0.06506468f, -0.03649690f, -0.03136737f, 0.01666901f, 0.09196456f, 0.10148039f, 
    0.03835067f, -0.02371504f, 0.09163906f, -0.07156697f, -0.06026413f, -0.07797659f, 0.04404616f, -0.04999190f, 
    -0.01687558f, 0.02862364f, -0.05601766f, 0.03292816f, -0.25966701f, 0.18634047f, 0.14883734f, -0.14244576f, 
    -0.07501514f, 0.11338206f, -0.00715178f, -0.00405954f, -0.09035637f, -0.05341831f, -0.07783201f, -0.03521808f, 
    0.10430013f, -0.22598849f, -0.12649129f, 0.06290989f, -0.07852527f, -0.14151724f, -0.06912620f, 0.07646146f, 
    -0.11586624f, -0.00127003f, -0.04305976f, 0.05654498f, 0.02398055f, 0.07592408f, -0.02085109f, 0.02315642f, 
    0.02234443f, 0.06428589f, -0.01954692f, -0.01554746f, 0.06105089f, 0.00264911f, -0.02286130f, -0.00193828f, 
    0.66005015f, 0.11769113f, -0.03784408f, -0.08949425f, -0.05620003f, -0.00570967f, -0.02788804f, -0.12810670f, 
    0.05343879f, -0.08941076f, -0.01472527f, -0.00715546f, -0.22217388f, -0.04651001f, -0.16428579f, 0.13307971f, 
    0.01700014f, 0.02788190f, -0.05918407f, -0.03202318f, 0.04785082f, 0.03335213f, 0.01454374f, -0.05327072f, 
    0.17016657f, -0.10613770f, 0.00049084f, 0.11752548f, -0.21489739f, -0.03739930f, 0.03186347f, 0.09620420f, 
    -0.00920991f, 0.03548455f, 0.00748059f, -0.09667435f, 0.24864165f, 0.00944274f, 0.04358597f, 0.13717191f, 
    -0.13110024f, 0.10678158f, -0.10559973f, 0.06931370f, -0.08595533f, 0.08274019f, -0.04811501f, -0.02070208f, 
    -0.00710941f, 0.07714494f, -0.08291987f, -0.31915975f, 0.09332656f, 0.09787397f, 0.08523001f, -0.03471525f, 
    -0.01222284f, -0.03194425f, 0.10033274f, -0.05935846f, -0.33110818f, -0.25311550f, -0.05160582f, -0.03871216f, 
    -0.01379198f, -0.01578561f, 0.03035497f, -0.09547050f, 0.04086166f, -0.01181957f, 0.02276312f, 0.02055842f, 
    0.14662410f, -0.14072274f, -0.03966789f, -0.08592971f, 0.05585395f, -0.05687487f, -0.10719527f, 0.08837712f, 
    -0.11093952f, 0.16080713f, 0.16036302f, -0.16947043f, 0.15482216f, -0.16031039f, -0.07747503f, 0.01821353f, 
    -0.07988706f, -0.17036211f, 0.02971405f, 0.04503924f, 0.05837039f, 0.00636563f, -0.04452127f, 0.10057496f, 
    -0.25153866f, 0.07476048f, 0.12959847f, -0.37968051f, 0.00977671f, -0.09875756f, 0.07139553f, -0.18972680f, 
    0.08982123f, -0.04277935f, 0.00289814f, -0.10256604f, -0.17741834f, -0.38338566f, 0.00067818f, -0.17698134f, 
    -0.00941839f, 0.00339195f, 0.04700714f, -0.04119001f, 0.01605479f, -0.13215196f, -0.08537189f, 0.04937005f, 
    0.13406558f, -0.04282247f, 0.07181761f, 0.21528378f, -0.12505125f, -0.09197167f, -0.01336750f, -0.01487984f, 
    -0.07183674f, 0.11278113f, -0.06234738f, 0.02808643f, 0.00332454f, 0.03902229f, -0.05368407f, -0.12144354f, 
    0.00140581f, 0.07328710f, -0.08547176f, -0.05154697f, 0.01384696f, 0.09033021f, -0.02038230f, -0.13433497f, 
    -0.05948693f, 0.06300715f, -0.01691408f, 0.15094602f, -0.24729785f, -0.04596255f, 0.03401236f, 0.03913069f, 
    0.01169399f, 0.13069063f, 0.03791295f, 0.03451585f, 0.23473723f, 0.07146808f, 0.11572309f, -0.21983908f, 
    0.04341444f, -0.01984746f, 0.01268606f, 0.00220853f, 0.02524829f, 0.07976475f, 0.03830988f, -0.00720316f, 
    0.07159882f, -0.05380835f, -0.12805399f, 0.11953390f, -0.10931613f, 0.02458074f, 0.02561944f, -0.02500248f, 
    0.00376321f, -0.01620941f, -0.03508556f, 0.00149957f, 0.17439087f, 0.08182847f, -0.01494383f, -0.21271700f, 
    0.07902768f, -0.00346358f, 0.00150253f, 0.01759448f, -0.00997751f, 0.02065606f, -0.04090766f, -0.09445971f, 
    -0.05666465f, 0.03735474f, 0.01046203f, -0.01780489f, -0.01505066f, -0.02360828f, -0.01051466f, -0.02979767f, 
    0.06136944f, -0.07156189f, 0.02960557f, -0.01502492f, -0.12997405f, -0.24375491f, -0.19283026f, 0.06061381f, 
    -0.04894966f, -0.00466315f, 0.02168961f, 0.01845246f, -0.01844473f, 0.04461587f, -0.11845212f, -0.03537308f, 
    0.13577801f, -0.05586413f, 0.03516757f, -0.39364961f, 0.06059663f, -0.10725517f, -0.00377897f, 0.00072803f, 
    -0.05598091f, 0.09849385f, -0.07722767f, 0.00223790f, -0.30768454f, 0.15436439f, -0.00169914f, -0.03040193f, 
    -0.00104368f, 0.09884655f, -0.13583696f, -0.04737520f, -0.04599812f, -0.07033078f, 0.03331670f, -0.14144953f, 
    0.18281408f, 0.05667192f, -0.03575109f, -0.15664732f, 0.07126324f, 0.06426392f, -0.04124803f, 0.04882322f, 
    -0.01969923f, 0.00469691f, -0.05986175f, -0.05074580f, 0.04190728f, -0.13700958f, 0.15691523f, 0.03423785f, 
    -0.03815450f, -0.04703281f, -0.01459810f, -0.02627538f, -0.04180484f, 0.11691663f, 0.04219372f, -0.01507613f, 
    -0.04455063f, 0.18363783f, 0.02650107f, -0.22218359f, -0.01925340f, 0.05823958f, 0.10778695f, 0.02531439f, 
    -0.12749061f, 0.03797929f, 0.02118576f, -0.00389959f, -0.05823827f, 0.06831510f, 0.08894629f, -0.05006141f, 
    -0.05949622f, 0.08401158f, 0.00065196f, -0.01931118f, -0.24221310f, -0.00422166f, -0.12104021f, 0.10803213f, 
    0.08475848f, -0.00963000f, 0.09322826f, 0.25013310f, -0.06438410f, -0.00763253f, 0.02643741f, 0.00430472f, 
    -0.06628191f, 0.05205859f, -0.02476423f, -0.04879452f, 0.19028491f, -0.04292651f, 0.01144945f, -0.15777504f, 
    0.00301208f, -0.03675795f, 0.03164101f, -0.12829661f, 0.00806846f, -0.00552829f, 0.04987283f, -0.01041364f, 
    -0.29264164f, 0.13571498f, 0.15324257f, -0.11919420f, -0.00843862f, 0.05256615f, 0.04571656f, -0.14440745f, 
    0.09550826f, -0.11815356f, -0.09169455f, 0.02581954f, 0.09788451f, 0.01926668f, 0.04734438f, 0.03435294f, 
    0.00768242f, -0.01080480f, 0.00421637f, 0.02626242f, 0.00352335f, -0.00008612f, 0.05857702f, 0.07879131f, 
    0.39292687f, 0.04566665f, -0.02099244f, -0.13436504f, -0.03211668f, 0.02547961f, 0.10395399f, -0.05510490f, 
    0.06570119f, -0.04965685f, -0.00854390f, 0.06391048f, -0.33449891f, -0.15370931f, 0.02603122f, -0.09135631f, 
    0.03006076f, 0.02579304f, -0.05511178f, 0.02807689f, -0.02269239f, -0.13300093f, -0.06701431f, -0.09136925f, 
    0.12983491f, -0.02979949f, 0.00120965f, 0.03963686f, -0.02571999f, -0.04858160f, -0.00921926f, 0.04099099f, 
    -0.00960091f, -0.04232669f, -0.02661833f, -0.01483765f, 0.20427230f, 0.02821239f, 0.15346412f, -0.15911220f, 
    0.05348584f, 0.14627375f, 0.06056041f, 0.15772532f, -0.14324903f, -0.02026969f, 0.06953565f, 0.12513636f, 
    -0.06413633f, 0.07321408f, -0.03659167f, -0.03452582f, 0.03344121f, -0.05769204f, 0.00253881f, 0.09862880f, 
    -0.14089380f, 0.11623223f, -0.05325146f, 0.03748782f, 0.10572257f, -0.07530852f, -0.01322685f, -0.09074714f, 
    0.08249715f, 0.00584496f, -0.04989925f, 0.08651344f, 0.05098268f, -0.06402635f, -0.07308625f, 0.07961037f, 
    -0.09176606f, 0.01614015f, -0.00452030f, -0.08745134f, 0.04170986f, -0.01716853f, 0.03024457f, 0.00800732f, 
    0.08143803f, -0.09365401f, 0.09957300f, -0.02024697f, 0.17749244f, 0.06870172f, 0.15039000f, -0.19490252f, 
    0.15211797f, 0.11361060f, -0.00620878f, -0.01841882f, 0.04658949f, -0.01038913f, -0.00476275f, 0.02914060f, 
    0.00788984f, 0.09170676f, -0.20968419f, 0.06349377f, -0.03626971f, 0.04493337f, -0.03488954f, -0.12078222f, 
    0.01607656f, -0.05477023f, -0.00282916f, -0.06510787f, -0.23923944f, 0.10754453f, 0.25633597f, 0.16446257f, 
    -0.15852359f, 0.00203117f, 0.14704011f, -0.04717977f, 0.04685736f, 0.00025335f, 0.03185517f, 0.03616116f, 
    -0.37278098f, 0.09324630f, -0.11216455f, -0.13707271f, -0.12415160f, 0.01534576f, -0.06455525f, -0.02912075f, 
    0.05944888f, 0.06231096f, 0.00941908f, 0.09542420f, 0.16327198f, 0.09594815f, -0.12766612f, -0.02466418f, 
    -0.19631219f, -0.06341373f, 0.06538504f, 0.09532660f, -0.01418682f, -0.05677611f, -0.05042338f, -0.11802868f, 
    -0.56271392f, 0.17112847f, 0.07531171f, 0.01215611f, -0.01100447f, -0.15578677f, -0.04824685f, -0.07417629f, 
    0.04273799f, 0.00849358f, 0.10386170f, 0.12222550f, 0.11437221f, -0.11417861f, 0.00175272f, 0.20805450f, 
    -0.14685966f, 0.02323956f, -0.01578167f, -0.02733268f, 0.02093294f, -0.01795237f, 0.00028108f, 0.08245515f, 
    -0.02890319f, -0.06516100f, 0.07767464f, -0.05574099f, -0.06226445f, -0.12696137f, -0.04333082f, 0.07353113f, 
    -0.05597800f, -0.03824202f, 0.07977612f, 0.00267548f, 0.16714498f, -0.12733093f, 0.07686262f, -0.00542993f, 
    -0.02289769f, -0.04885836f, -0.02811746f, 0.01592948f, 0.00141736f, -0.02599453f, -0.05835729f, 0.07249519f, 
    0.22994015f, -0.22054513f, -0.20003694f, 0.32587695f, -0.22647831f, -0.10593031f, 0.02747196f, -0.12627403f, 
    -0.03115669f, 0.08104397f, -0.04806399f, 0.13198949f, 0.40323424f, -0.05785210f, 0.00181420f, 0.04982536f, 
    0.05133799f, -0.04852578f, -0.05628218f, 0.05711054f, 0.12529799f, 0.06962354f, 0.04489670f, 0.13205492f, 
    0.04924446f, 0.13892697f, -0.05557395f, -0.12939692f, 0.06066053f, 0.00704818f, -0.04427876f, 0.09316266f, 
    -0.06557966f, 0.03074137f, -0.08433285f, 0.03584405f, -0.02987932f, -0.10429851f, -0.03432654f, 0.02187537f, 
    -0.06062588f, -0.03622493f, -0.03881583f, -0.00905707f, 0.02988673f, -0.12532011f, 0.01392861f, -0.02643809f, 
    0.00367994f, -0.00937045f, -0.09498647f, 0.18082269f, -0.03961112f, -0.02381221f, 0.05885148f, -0.05435478f, 
    -0.00330479f, -0.04751921f, -0.04190611f, -0.01147688f, -0.25018385f, -0.25111619f, -0.12643260f, 0.05603898f, 
    0.05870615f, -0.01215423f, -0.02211164f, 0.05141525f, 0.05296448f, -0.07008576f, -0.10118473f, -0.09981898f, 
    0.05133010f, -0.00323864f, -0.11673869f, 0.17062660f, 0.02311173f, -0.13729084f, 0.05342856f, 0.02068108f, 
    0.00755179f, -0.04241110f, 0.04733131f, -0.04241589f, 0.14199373f, 0.10613696f, 0.09804868f, 0.11479469f, 
    -0.03395800f, 0.08952088f, -0.06084762f, -0.10588963f, 0.00278200f, -0.08754799f, -0.05704017f, 0.01325646f, 
    -0.02386847f, 0.03010124f, 0.12572716f, 0.12026950f, -0.00846797f, -0.02870283f, 0.00236663f, 0.03279280f, 
    0.01200173f, -0.09610226f, 0.02167552f, -0.08961242f, -0.17153823f, -0.02250445f, 0.07006487f, -0.04630903f, 
    -0.00825270f, -0.02058045f, 0.05757673f, -0.02144771f, -0.06011167f, 0.05365150f, 0.03603847f, -0.10344245f, 
    0.10173339f, -0.03635554f, -0.11568560f, 0.22135040f, 0.00546162f, 0.01556719f, 0.00203107f, 0.01092169f, 
    0.03535537f, -0.11317585f, 0.04850529f, 0.13294707f, -0.01702448f, -0.06384058f, -0.05568555f, 0.21621276f, 
    0.07108083f, -0.08787838f, 0.03839542f, -0.10233159f, 0.00267997f, -0.00137756f, -0.00973913f, -0.04590059f, 
    0.18883052f, -0.01284328f, 0.10942695f, -0.24650727f, -0.02270425f, -0.02036870f, 0.01392213f, -0.02864544f, 
    -0.10245938f, 0.02299196f, 0.08663142f, 0.02612903f, -0.24619384f, 0.20296568f, -0.09986386f, 0.05581090f, 
    -0.06129852f, -0.02527416f, -0.06378010f, -0.06685895f, -0.06275408f, -0.13588291f, 0.04057388f, -0.05576293f, 
    -0.05720404f, -0.11466593f, -0.31022155f, -0.50187647f, -0.05492729f, 0.00075407f, -0.06955551f, -0.11926334f, 
    0.04597683f, -0.14692661f, -0.05529969f, -0.08047163f, 0.22319837f, -0.21049207f, 0.04023803f, -0.23973885f, 
    -0.03494203f, -0.03373217f, -0.03503591f, 0.14869714f, -0.05420629f, -0.05744749f, -0.02914602f, -0.07366185f, 
    0.08753500f, 0.04913704f, 0.12687156f, 0.25484690f, -0.04141297f, 0.00509907f, 0.02181379f, 0.01317166f, 
    0.01317037f, -0.08103243f, 0.01425870f, 0.08719585f, -0.15249002f, 0.02623226f, -0.14225511f, -0.14514111f, 
    0.07526249f, 0.07053114f, 0.09903236f, 0.03098254f, 0.13337256f, 0.11642299f, 0.11897138f, 0.04337363f, 
    0.33109248f, 0.10227227f, 0.11496823f, 0.07809928f, 0.11685424f, -0.08782730f, 0.05756982f, -0.10023750f, 
    0.00028977f, 0.01124506f, 0.02899432f, -0.10203698f, 0.23106043f, -0.08904530f, -0.01022883f, 0.11099336f, 
    0.01522662f, 0.01016451f, 0.03261858f, 0.07999875f, 0.05235029f, 0.13897221f, 0.05031843f, 0.00208909f, 
    -0.57392174f, -0.05740992f, 0.05845834f, -0.19349842f, 0.01462435f, -0.00290065f, 0.00323006f, 0.15205468f, 
    0.05448348f, 0.04325071f, -0.02726712f, 0.03301474f, -0.08034161f, -0.00906739f, 0.06158252f, 0.19115971f, 
    -0.13531172f, -0.08090784f, -0.06101602f, 0.05292960f, -0.05788691f, -0.02082387f, -0.02361597f, 0.07106076f, 
    0.17705570f, -0.03484133f, 0.19344413f, 0.13611408f, -0.14098060f, -0.02673015f, -0.02808493f, -0.01669460f, 
    -0.05165644f, 0.05297877f, 0.02130478f, 0.03239867f, 0.16356780f, -0.16650984f, 0.14935675f, 0.23882209f, 
    -0.05312058f, -0.08357403f, -0.02249539f, -0.00994795f, 0.02889797f, -0.09533180f, -0.11060122f, 0.05176332f, 
    0.24682660f, -0.20076267f, -0.01374429f, -0.17835636f, -0.05799349f, -0.03822291f, -0.07449744f, -0.07566169f, 
    -0.04675579f, 0.07461286f, -0.01002759f, 0.08856945f, 0.08382841f, -0.13569605f, 0.04456996f, -0.02108668f, 
    -0.03131168f, 0.01452575f, -0.03592204f, 0.06676963f, -0.07833383f, 0.09143429f, -0.04729926f, -0.14512306f, 
    0.38116369f, -0.19881438f, 0.07312639f, -0.09759659f, 0.01430019f, 0.10923684f, -0.05556658f, -0.19453607f, 
    -0.06429671f, 0.01243658f, -0.27609199f, 0.09431084f, 0.09236768f, 0.05809912f, 0.11053438f, 0.03864602f, 
    -0.18176110f, -0.00760769f, 0.05964204f, 0.01955396f, -0.04281633f, 0.03879075f, 0.04064946f, 0.00610347f, 
    0.38845396f, -0.10511100f, -0.06524318f, -0.39849582f, 0.00192875f, -0.03137897f, -0.10864441f, 0.13163576f, 
    0.00314741f, -0.05065070f, 0.05381316f, -0.02220036f, -0.01186550f, -0.03095035f, -0.00033983f, 0.01141098f, 
    0.00062739f, 0.00638808f, 0.09888653f, 0.01879735f, -0.16289912f, 0.13231473f, 0.05921048f, 0.01779517f, 
    0.14742924f, -0.22228317f, 0.02178954f, 0.17205061f, -0.08363811f, -0.02473002f, -0.00484535f, 0.16376361f, 
    0.14236824f, -0.04908898f, 0.07068621f, -0.01724182f, 0.13190703f, -0.09298785f, 0.02840012f, -0.00381303f, 
    -0.07472809f, -0.08162801f, -0.06474698f, -0.00486337f, -0.09189909f, -0.07099119f, 0.06046089f, 0.01439507f, 
    0.17214660f, -0.20955442f, 0.23601329f, -0.00259016f, -0.08137007f, 0.01062800f, -0.07460298f, -0.02992900f, 
    0.01540309f, -0.11114727f, -0.11264197f, -0.01278171f, -0.28508517f, 0.02780146f, -0.04360705f, -0.16112132f, 
    0.03725124f, -0.12342034f, 0.02626702f, 0.03756091f, 0.08177410f, 0.04590874f, 0.02030738f, -0.08905116f, 
    0.16514912f, 0.10157274f, 0.13368565f, 0.10078613f, 0.13283433f, -0.01937484f, 0.01959746f, -0.02475115f, 
    0.07781360f, -0.02454494f, -0.07668188f, -0.01983864f, -0.08630841f, -0.19016375f, 0.06967939f, -0.14002338f, 
    0.02950300f, -0.04244764f, -0.02146682f, -0.01971651f, 0.05365810f, -0.09397336f, 0.03016848f, -0.07517591f, 
    -0.26727009f, -0.23332150f, -0.20256306f, 0.01102873f, -0.02688919f, 0.01175629f, 0.07304668f, -0.03137198f, 
    -0.08686499f, 0.06667545f, -0.04600555f, 0.06899687f, 0.04885896f, 0.05809451f, 0.01393833f, -0.05087003f, 
    -0.14616783f, -0.05072616f, -0.04148659f, 0.15210742f, 0.05238481f, -0.18909335f, -0.00280847f, -0.05815215f, 
    0.13113716f, 0.02584862f, -0.02721004f, -0.14932722f, -0.09741887f, 0.03437206f, -0.08500520f, 0.03662168f, 
    -0.00897824f, 0.02498693f, -0.00254053f, 0.05817549f, 0.03967345f, -0.02394485f, -0.07987909f, 0.14835206f, 
    -0.11734220f, 0.04377351f, 0.02587461f, 0.03783306f, 0.05896064f, 0.00570615f, -0.14926636f, 0.06008758f, 
    -0.38250694f, -0.06835172f, -0.06726390f, -0.04309096f, 0.01013380f, -0.00132469f, -0.10408874f, 0.03385777f, 
    0.06560940f, 0.04582873f, -0.00118426f, -0.15021738f, -0.02554441f, -0.00502286f, 0.00283704f, -0.07005725f, 
    -0.03151004f, 0.08143439f, -0.01628958f, 0.04761812f, 0.01790364f, -0.00394494f, 0.08155018f, 0.14126395f, 
    0.12337688f, -0.08116465f, 0.09207406f, -0.19106553f, 0.07025516f, 0.05038745f, -0.07020719f, -0.01186411f, 
    0.03734579f, -0.08592129f, -0.04191470f, 0.00073482f, 0.01062607f, -0.26636451f, -0.11914761f, -0.14560765f, 
    0.07288360f, 0.03395564f, 0.02251889f, 0.16179836f, 0.04512748f, 0.03471176f, 0.02380123f, -0.05804437f, 
    0.15576963f, 0.06187948f, 0.06759801f, 0.10179486f, -0.07909205f, 0.01710430f, -0.04029291f, -0.03704575f, 
    0.09018879f, 0.00935884f, 0.03748000f, -0.06378004f, -0.14083509f, 0.06697155f, 0.09728081f, -0.06237501f, 
    0.07740261f, -0.11557683f, -0.00208563f, 0.12790541f, -0.09805138f, -0.00207301f, -0.07823221f, -0.04844305f, 
    0.11822663f, 0.06228086f, -0.17649966f, -0.14306493f, 0.05125141f, -0.08703456f, -0.03396023f, -0.02565854f, 
    0.06135215f, 0.02923998f, 0.03373475f, 0.03151685f, 0.23899117f, 0.02446120f, 0.08777171f, 0.08973321f, 
    -0.00729455f, -0.11151662f, -0.04768177f, 0.00907470f, 0.03208619f, 0.06314112f, -0.09888907f, -0.06746919f, 
    -0.47004461f, -0.09422798f, 0.09938112f, -0.18071094f, -0.11267014f, 0.00688373f, -0.10003326f, -0.07676465f, 
    0.06344357f, 0.14234746f, -0.06783783f, -0.02709698f, -0.17058228f, 0.17982811f, -0.09317379f, -0.34391740f, 
    -0.06724543f, 0.04314649f, 0.04228797f, -0.07590460f, -0.03917859f, 0.06414507f, 0.08383635f, 0.01459686f, 
    0.10302112f, 0.02149925f, 0.06806538f, -0.01778482f, -0.07896754f, 0.03650596f, -0.01589243f, 0.05406504f, 
    0.00382816f, -0.00329161f, -0.09861657f, -0.05701429f, 0.11009947f, -0.21226522f, 0.12794706f, 0.00158885f, 
    0.08883650f, -0.00512711f, -0.14947082f, 0.00685214f, 0.12576850f, 0.01745893f, -0.10852903f, -0.00400899f, 
    -0.09182947f, -0.05728185f, -0.18932468f, -0.00067162f, 0.05058203f, -0.16204463f, 0.06207319f, 0.01380363f, 
    0.10550112f, -0.02556324f, 0.07953157f, -0.01369825f, -0.16133831f, 0.05141792f, -0.34412754f, -0.06036115f, 
    0.13642552f, -0.02270248f, 0.05252781f, 0.17426050f, 0.07282148f, 0.09998570f, 0.00113520f, 0.06298673f, 
    0.06660464f, 0.10067945f, -0.00588596f, -0.02840679f, 0.12605153f, 0.02702510f, -0.03951061f, -0.01202809f, 
    -0.12118279f, -0.09719263f, -0.08788735f, 0.02846147f, 0.05827048f, -0.13166587f, -0.16093104f, -0.08108779f, 
    0.13914216f, -0.09957130f, -0.00771233f, -0.06648591f, 0.08893166f, 0.08583828f, -0.13739522f, 0.11705422f, 
    0.20445269f, -0.35139641f, -0.06524584f, -0.01726063f, -0.02188644f, 0.07576054f, -0.07615209f, 0.10367136f, 
    -0.03227438f, 0.03867839f, -0.11028013f, 0.10743260f, -0.26082760f, -0.04612323f, -0.03848176f, -0.03435513f, 
    -0.09092397f, 0.03597297f, 0.00201129f, -0.14519426f, -0.01306817f, -0.01160581f, -0.02022281f, -0.02165638f, 
    0.18504390f, -0.13461185f, -0.05499307f, -0.01188421f, -0.08252193f, -0.08918647f, 0.01095709f, 0.05631062f, 
    0.03011771f, -0.15647168f, 0.09770456f, -0.02516522f, 0.15623561f, 0.11914036f, 0.12739512f, 0.19037336f, 
    -0.09701135f, 0.01069191f, 0.01194090f, -0.00547879f, 0.05149432f, 0.00574044f, -0.09679081f, 0.16850345f, 
    0.45128438f, -0.12246054f, 0.02914089f, 0.03276945f, -0.06410513f, 0.14199668f, -0.15119560f, 0.04172995f, 
    -0.03896366f, -0.02183360f, -0.15733421f, -0.06863072f, 0.20928463f, -0.11028147f, -0.01713607f, 0.11593883f, 
    -0.03333577f, 0.04279819f, -0.02676622f, 0.01609628f, -0.05568137f, 0.06661790f, 0.05227602f, -0.01076754f, 
    -0.18230055f, 0.15782291f, -0.14661109f, -0.11481742f, 0.02313041f, 0.11426596f, -0.05314389f, 0.12259150f, 
    0.07092852f, -0.02840819f, -0.07304619f, -0.00883824f, -0.06458036f, 0.00098821f, 0.15972036f, 0.02129842f, 
    -0.05470714f, 0.04589130f, 0.04634936f, 0.01691136f, -0.11348137f, 0.06573556f, 0.04971235f, 0.05790953f, 
    -0.31313759f, -0.19699094f, 0.11852022f, 0.16039255f, 0.02678227f, 0.02965757f, -0.02359719f, 0.08566074f, 
    -0.01103235f, 0.00364494f, 0.04209320f, -0.03705676f, -0.10763009f, 0.01008514f, 0.03041169f, -0.03057127f, 
    0.06770033f, -0.02795946f, -0.10940127f, -0.11410518f, 0.00620572f, -0.00085572f, -0.04544505f, 0.04938745f, 
    0.15171057f, -0.08630199f, -0.06674532f, -0.08041192f, 0.03388045f, 0.04618289f, -0.09095037f, -0.06591786f, 
    0.00563135f, 0.06388145f, -0.02242325f, 0.11032888f, 0.01341983f, 0.01699275f, 0.16799276f, 0.11937744f, 
    -0.05826078f, 0.02213254f, 0.04832899f, -0.00326792f, -0.02802502f, 0.05770686f, -0.00951639f, -0.03424067f, 
    -0.05441398f, 0.03069561f, -0.01825413f, 0.09481216f, -0.07105874f, -0.04340456f, 0.03457228f, -0.04072992f, 
    0.03380091f, -0.13551034f, 0.04313138f, -0.12701274f, 0.15002857f, 0.06471413f, -0.00140132f, -0.08711011f, 
    0.00847403f, -0.04860713f, 0.05839933f, -0.01380455f, -0.04778374f, 0.06857094f, 0.04815647f, 0.09288985f, 
    0.19288051f, -0.04604419f, -0.10689268f, 0.15341681f, -0.02979736f, 0.09813442f, -0.01870937f, -0.05026248f, 
    0.04377544f, -0.09444537f, -0.06548690f, 0.01398284f, -0.02561842f, 0.08525065f, -0.15373589f, 0.10528093f, 
    -0.03466282f, 0.05850728f, 0.10935865f, -0.10587709f, -0.02619464f, 0.12444890f, -0.03680097f, -0.01489735f, 
    -0.19643711f, 0.02525502f, -0.12898432f, 0.11649405f, 0.05381730f, -0.05224018f, -0.00633141f, -0.11993328f, 
    0.02262140f, 0.03899866f, -0.03258636f, -0.00609953f, 0.03090480f, 0.04028196f, 0.09596813f, -0.00467718f, 
    -0.08120965f, -0.03229543f, 0.07939192f, -0.00646935f, -0.04012091f, -0.04484243f, 0.01072687f, 0.04062542f, 
    -0.13528167f, -0.12948586f, -0.29481903f, -0.03517843f, 0.00439911f, -0.07799385f, -0.15407027f, 0.01087067f, 
    -0.12846613f, -0.07028464f, -0.07888570f, -0.00473962f, 0.12597741f, 0.08053685f, 0.03851233f, 0.02671024f, 
    -0.07054549f, 0.06273369f, 0.00170277f, -0.06667578f, -0.06520884f, -0.00960862f, 0.03346010f, -0.10281289f, 
    -0.18365259f, 0.03061980f, 0.12965040f, -0.18764633f, 0.00112620f, -0.08338512f, 0.10937663f, -0.08333912f, 
    -0.03804010f, -0.02181756f, -0.02232647f, -0.07598215f, 0.06331737f, 0.04068488f, -0.00944571f, -0.05067101f, 
    -0.10016568f, 0.09225842f, -0.10074463f, -0.03932193f, 0.09311088f, 0.05655781f, -0.03440795f, -0.14074934f, 
    -0.17256273f, -0.16837683f, -0.17502323f, -0.15604709f, -0.04181400f, 0.00769325f, 0.06154035f, -0.09741033f, 
    -0.04220898f, 0.05685782f, -0.00117334f, 0.00773269f, -0.24086644f, 0.00016331f, -0.03283498f, 0.09026756f, 
    0.02680957f, -0.02893756f, 0.06579130f, -0.03335789f, -0.03295061f, -0.07231944f, -0.04894157f, 0.05279555f, 
    -0.04415858f, 0.01268104f, 0.06638398f, -0.14244451f, -0.00939575f, -0.03020492f, 0.03589351f, 0.04672560f, 
    -0.06614409f, 0.01707387f, 0.01427738f, -0.03783375f, -0.07776513f, 0.10970555f, -0.10976974f, -0.17758232f, 
    0.05649266f, -0.01434740f, 0.02634368f, -0.02567056f, -0.08279324f, 0.00594875f, -0.12826835f, -0.10338625f, 
    -0.13380766f, 0.08781601f, 0.04759264f, -0.10208613f, -0.13089800f, -0.04628180f, 0.07401501f, 0.08794890f, 
    -0.10577288f, 0.03457054f, -0.11333150f, -0.06895895f, -0.02380757f, 0.02834329f, 0.05425434f, -0.02318869f, 
    0.00776643f, 0.03662709f, 0.03850414f, -0.02915152f, -0.01034894f, -0.10463610f, 0.01623617f, 0.04121762f, 
    0.18950582f, 0.09652057f, -0.18917847f, -0.05054890f, 0.08261838f, -0.00397283f, -0.05615211f, 0.06799471f, 
    -0.10272040f, 0.04868403f, 0.03855399f, -0.05669775f, 0.43658736f, -0.09665920f, -0.25945494f, -0.09353079f, 
    -0.16492538f, 0.00710756f, -0.04130615f, 0.01352598f, -0.00535539f, -0.03913707f, -0.01227949f, -0.09197569f, 
    0.16344175f, -0.02871572f, 0.01614991f, 0.06942515f, 0.14561071f, 0.00577117f, 0.00235494f, -0.03112423f, 
    0.04566420f, -0.01198934f, -0.03152732f, -0.00235327f, -0.13918249f, -0.00100314f, 0.05750915f, -0.15929936f, 
    0.10727515f, -0.05086703f, 0.01722196f, -0.12226854f, 0.02529812f, 0.08381000f, 0.00331817f, 0.00944491f, 
    0.03584332f, 0.03252875f, 0.11804403f, 0.18139295f, -0.18776344f, -0.00971183f, 0.06754196f, 0.04341390f, 
    -0.13276312f, -0.06739163f, 0.03538164f, -0.12494615f, -0.22744451f, -0.04154861f, 0.16610450f, -0.15768294f, 
    -0.15125060f, -0.01372564f, -0.06817496f, -0.01312453f, -0.07737906f, -0.02490647f, -0.07092869f, -0.18970051f, 
    -0.06570049f, -0.01912378f, 0.06574818f, 0.00656319f, -0.12193261f, -0.02135954f, 0.08915899f, 0.09579762f, 
    0.02570286f, -0.00560940f, 0.07175098f, -0.02556050f, -0.03078516f, 0.10160476f, 0.02577365f, -0.06125196f, 
    0.02358384f, 0.09211012f, -0.01365642f, -0.03189930f, 0.00944524f, 0.04561271f, -0.06414394f, -0.05486963f, 
    -0.07955642f, -0.13082424f, 0.07515406f, 0.11311225f, -0.06228821f, -0.13246256f, -0.00449585f, 0.01196938f, 
    -0.00455415f, -0.02204195f, -0.02101849f, 0.04662997f, 0.19108748f, -0.06523368f, 0.04769295f, -0.08227503f, 
    -0.22484568f, -0.04608892f, -0.02340299f, 0.04651979f, 0.03262792f, -0.05439567f, -0.10157026f, -0.03955984f, 
    0.41200531f, -0.08545575f, 0.10502894f, -0.06012830f, -0.02134412f, 0.03046864f, 0.05442783f, -0.07998881f, 
    -0.04094221f, 0.04082649f, -0.06762480f, 0.02640378f, -0.02967803f, 0.13200589f, 0.06791592f, -0.03254314f, 
    -0.06376781f, -0.07194043f, 0.01780705f, 0.11411545f, -0.01647289f, 0.00403252f, -0.01163471f, -0.02443825f, 
    0.10707625f, -0.07307087f, 0.00698840f, -0.05751178f, 0.02443800f, 0.04212638f, 0.02855275f, 0.01426021f, 
    -0.05463192f, -0.05328000f, -0.02443091f, -0.04063001f, 0.08908837f, -0.12525006f, 0.21530963f, 0.01087751f, 
    -0.00208180f, 0.02470270f, 0.02375896f, -0.06755442f, 0.03546206f, 0.05200568f, 0.07110132f, 0.02294360f, 
    0.11878832f, 0.07250254f, -0.00611564f, -0.06083086f, -0.02216248f, 0.00218827f, 0.07088485f, 0.04131645f, 
    -0.04896854f, 0.00414934f, 0.09447933f, -0.02850007f, 0.06433965f, 0.15755023f, 0.06132458f, 0.06418338f, 
    0.02527098f, -0.04492688f, 0.00653205f, 0.02160958f, 0.03932281f, 0.03065465f, 0.03487774f, -0.00492606f, 
    -0.03222286f, 0.02466554f, -0.13827366f, -0.01763917f, 0.02632568f, 0.05056646f, -0.03192786f, -0.03661241f, 
    -0.06163161f, -0.04172153f, -0.01036160f, 0.04907104f, -0.02863203f, -0.17128104f, -0.20953298f, -0.04922312f, 
    0.00271479f, -0.07444235f, -0.08966549f, -0.08871496f, 0.01259765f, 0.07994051f, -0.11517862f, -0.03563479f, 
    -0.45343193f, 0.09260581f, 0.10989055f, -0.17197798f, 0.00770793f, -0.07894011f, 0.06311207f, -0.03621509f, 
    0.00161934f, -0.00609298f, -0.01745929f, 0.00591922f, 0.07830303f, -0.07520873f, 0.03500776f, 0.11612798f, 
    -0.12997991f, -0.07247528f, -0.01285113f, -0.02855158f, 0.00001872f, -0.06100755f, 0.01566455f, -0.04149005f, 
    0.22914815f, 0.04381368f, 0.06387878f, -0.01068084f, -0.05401344f, -0.00499903f, 0.03522202f, -0.01685292f, 
    -0.06513106f, 0.03944020f, 0.02621773f, -0.01259691f, 0.02131548f, -0.15372404f, -0.01589518f, -0.15655470f, 
    0.04475685f, -0.05608211f, -0.03238487f, -0.00863557f, -0.08456739f, 0.07575970f, -0.05545009f, -0.15301175f, 
    0.00226736f, -0.02194203f, 0.06832768f, 0.11850312f, -0.13388321f, 0.08848564f, -0.01803800f, 0.03413411f, 
    0.00797196f, 0.04222157f, -0.02479207f, 0.05311071f, -0.34311876f, -0.11207483f, -0.04625665f, -0.37312198f, 
    0.00829412f, -0.03610413f, -0.02188679f, -0.05748208f, -0.01541880f, 0.12539804f, -0.00646671f, -0.04154444f, 
    -0.11121884f, -0.00843830f, -0.02142896f, -0.02168275f, 0.06937595f, -0.05192864f, -0.00052548f, -0.00640339f, 
    0.05163955f, 0.02589030f, -0.00270151f, -0.03332731f, -0.03545485f, 0.11959796f, -0.00074439f, 0.14748544f, 
    -0.01760769f, -0.03293940f, 0.02717050f, -0.00742433f, -0.08367725f, -0.07171284f, 0.04309800f, 0.03265122f, 
    0.11469695f, -0.07361201f, -0.06360463f, -0.08155768f, 0.00264494f, -0.02312966f, -0.01469252f, -0.03377563f, 
    -0.06552434f, 0.03817835f, -0.09480581f, 0.00370896f, 0.01742863f, 0.07676911f, -0.00598542f, -0.05414637f, 
    -0.00093275f, 0.00096794f, 0.04939975f, 0.09305623f, -0.04328012f, -0.09918544f, 0.00157946f, -0.02621369f, 
    0.16405742f, 0.22916082f, -0.09736367f, -0.02664984f, 0.08734494f, 0.03887255f, 0.09104592f, 0.07310309f, 
    -0.03799948f, 0.01731256f, 0.03430825f, -0.02422254f, 0.23068765f, 0.02753899f, -0.20551932f, -0.02763169f, 
    0.09179436f, 0.01665590f, -0.06301703f, -0.06257260f, -0.01556548f, -0.00464313f, 0.06274293f, 0.01379030f, 
    0.19617039f, -0.05567776f, 0.01111391f, 0.02474222f, 0.00337490f, -0.02921970f, 0.12367638f, 0.03281356f, 
    -0.06000404f, 0.10904504f, 0.04886558f, 0.04048599f, -0.17070638f, 0.10193571f, 0.01478179f, 0.09600630f, 
    0.06312387f, 0.03596574f, 0.04845861f, 0.13920809f, -0.03905598f, -0.10503198f, 0.05186626f, -0.00905346f, 
    -0.24204077f, 0.04495637f, -0.13624611f, -0.17355375f, 0.10092437f, -0.05477561f, -0.10672224f, 0.02469036f, 
    -0.06081217f, 0.00406743f, -0.01947792f, -0.13583840f, 0.26042068f, -0.21589994f, -0.08896789f, -0.13302614f, 
    -0.06362322f, -0.19198771f, -0.21125624f, -0.11019816f, -0.01420735f, -0.02788532f, -0.16281785f, 0.09184558f, 
    0.07533544f, 0.12743779f, -0.13706914f, 0.02995849f, -0.01267125f, 0.01935026f, 0.08262371f, -0.04755745f, 
    -0.03775469f, -0.01820086f, -0.02581741f, -0.03564188f, 0.24068156f, 0.04800368f, 0.20508844f, 0.06566546f, 
    -0.08463839f, -0.07000186f, 0.07721681f, 0.08070870f, -0.04123822f, -0.06451359f, 0.01998853f, -0.02177480f, 
    0.10110047f, -0.07612976f, 0.04060790f, 0.09829749f, -0.04868661f, -0.09596649f, -0.04992317f, 0.02719682f, 
    0.00644458f, -0.00251208f, -0.03589723f, -0.08692018f, 0.24338695f, -0.07356336f, -0.15642758f, -0.01159330f, 
    -0.08904523f, 0.01485023f, 0.06341571f, 0.02954451f, -0.03381098f, 0.01728889f, -0.09819764f, -0.01488967f, 
    0.26690334f, 0.08352053f, 0.01160893f, 0.23591249f, -0.24729678f, -0.07253479f, 0.00888058f, -0.00391948f, 
    -0.01569074f, -0.05947043f, -0.05375787f, -0.04848642f, -0.02232963f, -0.02615812f, -0.16382179f, -0.03557392f, 
    0.16137242f, 0.05498663f, -0.06196198f, -0.05792172f, 0.03716511f, 0.02726800f, -0.04165954f, -0.04637763f, 
    0.33095458f, 0.06439257f, -0.11118428f, 0.10207088f, 0.08731308f, -0.10611436f, 0.09909068f, 0.04562279f, 
    0.03541063f, 0.13142043f, 0.10719077f, -0.02639676f, -0.05278054f, -0.20391104f, 0.09662421f, 0.04957189f, 
    0.08070309f, -0.02476764f, -0.00444825f, -0.13258369f, -0.00025752f, -0.00302968f, -0.09428402f, 0.02108036f, 
    0.15326087f, -0.04843147f, -0.26874587f, 0.00280535f, -0.04938735f, -0.03063490f, 0.06609672f, -0.02764519f, 
    -0.05017889f, -0.01722236f, -0.00848995f, 0.00716833f, -0.17665493f, 0.00179421f, -0.04583867f, -0.05626797f, 
    0.03981668f, 0.02951326f, -0.08134555f, -0.02734126f, 0.12297211f, -0.13329792f, 0.00572733f, -0.08706853f, 
    0.34599352f, 0.10648024f, -0.05603143f, 0.08262024f, -0.03573425f, 0.07727158f, 0.02209912f, 0.02595479f, 
    -0.01272080f, 0.02685297f, 0.01077448f, -0.07612818f, 0.13332996f, -0.07980701f, 0.15622568f, -0.13345128f, 
    0.13526767f, 0.03573341f, 0.06412283f, 0.09044614f, -0.04696713f, -0.02873499f, -0.00387490f, -0.02319854f, 
    0.12115266f, 0.04685359f, 0.14667214f, 0.15818599f, -0.15229587f, -0.10830731f, -0.01782964f, 0.04885519f, 
    -0.01552882f, -0.00163564f, 0.00566689f, -0.10335742f, 0.12292438f, 0.02445460f, -0.08294250f, 0.03358740f, 
    -0.03298314f, 0.03295153f, -0.06100600f, -0.08909889f, 0.01182102f, -0.01645052f, -0.02800738f, -0.05855944f, 
    -0.09502999f, 0.04699922f, -0.12650582f, 0.02829171f, -0.04911287f, 0.05944690f, 0.06150104f, -0.08552418f, 
    0.10211132f, 0.07556316f, 0.02653669f, 0.05307423f, 0.23210239f, -0.28131726f, -0.06007057f, -0.04273231f, 
    -0.01179226f, 0.07791185f, -0.12246911f, -0.14858153f, -0.00926088f, -0.04337179f, -0.05725531f, -0.09572270f, 
    0.07852639f, -0.00024188f, -0.15140378f, 0.07596689f, -0.04776828f, -0.02808473f, -0.06098094f, -0.05141591f, 
    -0.02124348f, -0.05415117f, -0.02227738f, -0.11340846f, 0.30955675f, -0.06778740f, 0.03972470f, -0.05745703f, 
    -0.07283286f, 0.01167473f, -0.06721555f, 0.01563616f, 0.05167048f, 0.03952086f, 0.03226412f, -0.05134852f, 
    0.23322520f, -0.10972960f, -0.15489300f, 0.07271456f, -0.13149470f, 0.07430400f, 0.02394596f, 0.04153142f, 
    -0.07287906f, -0.01964721f, -0.15676571f, -0.11972945f, 0.14601202f, 0.10403827f, 0.02310006f, -0.29612252f, 
    0.01483817f, 0.10935198f, 0.08473814f, -0.04466004f, 0.09257674f, -0.08201157f, 0.05575267f, -0.10686184f, 
    -0.24677092f, -0.03674700f, -0.21447271f, 0.00864213f, -0.03386635f, 0.02387330f, -0.00782253f, 0.04219494f, 
    0.02859192f, 0.09771463f, -0.07800781f, 0.00706181f, 0.11405612f, -0.16050208f, -0.04596907f, 0.01134734f, 
    -0.00270859f, 0.01274743f, 0.02093558f, -0.07963264f, 0.02013519f, 0.11309490f, -0.00615080f, -0.04043891f, 
    0.05404419f, -0.07458635f, -0.00812817f, 0.10526680f, -0.12946497f, 0.05140853f, -0.07353260f, 0.06919138f, 
    -0.08237509f, 0.05244698f, -0.12330598f, 0.02523871f, 0.21200727f, -0.04590403f, 0.07254101f, -0.02799022f, 
    0.02059223f, 0.04693466f, 0.03080082f, -0.00126972f, 0.02407805f, 0.03022359f, 0.05470829f, 0.00249506f, 
    0.43646625f, 0.19997309f, 0.00443265f, -0.02307494f, -0.03489871f, 0.03119022f, 0.02206165f, 0.07039113f, 
    0.00720577f, 0.05058622f, 0.02188008f, -0.05131123f, 0.02262487f, -0.12701569f, 0.01391679f, -0.09832523f, 
    -0.18503192f, 0.02487674f, -0.04817508f, 0.03859543f, 0.01193023f, 0.01538887f, -0.05529943f, 0.06915107f, 
    0.16220310f, -0.25927219f, -0.24355435f, 0.12737741f, -0.06686763f, 0.08484259f, -0.04974793f, -0.03213079f, 
    -0.06249245f, -0.05456838f, 0.03760457f, 0.02349837f, 0.04636545f, 0.10484553f, 0.11449403f, 0.10004157f, 
    0.06827623f, 0.03108642f, 0.02199770f, 0.00859991f, -0.04198361f, 0.00748173f, -0.06347752f, -0.08459468f, 
    -0.15957376f, 0.04496588f, -0.25038874f, -0.03071767f, -0.08002791f, -0.01011696f, -0.01675601f, 0.10475285f, 
    -0.01417691f, -0.07049659f, -0.07443352f, 0.07430446f, -0.25781474f, -0.01158196f, -0.18499868f, -0.14353056f, 
    -0.02159006f, 0.02666634f, -0.02039453f, -0.11685631f, -0.04193764f, 0.02784311f, -0.01085106f, -0.05034610f, 
    0.05561204f, 0.28313306f, 0.06006406f, -0.16980220f, 0.01327136f, 0.01598970f, 0.00885929f, 0.06158359f, 
    -0.07790543f, -0.15214048f, 0.00734494f, 0.02164819f, 0.08867256f, -0.03398221f, 0.13872482f, -0.03450970f, 
    -0.01137688f, -0.01784554f, 0.08418318f, -0.02293260f, -0.02046296f, -0.06077765f, 0.03461222f, 0.00325188f, 
    -0.41933417f, -0.50158519f, 0.00787341f, 0.18572412f, -0.03806610f, 0.04809476f, 0.01512542f, 0.02308967f, 
    0.02281425f, -0.12900472f, 0.03575808f, 0.02270722f, 0.11535482f, -0.29294083f, -0.11685605f, 0.02371081f, 
    0.02351522f, 0.13775736f, -0.02637322f, -0.08901073f, 0.02376126f, -0.04726955f, -0.03609807f, 0.00099388f, 
    -0.11418007f, -0.11174975f, -0.08386062f, -0.06017167f, -0.06778290f, 0.08300593f, 0.09529137f, -0.00319498f, 
    0.03517871f, -0.07781798f, 0.09332699f, 0.01812784f, 0.15471365f, 0.14959191f, -0.07473286f, -0.00920128f, 
    -0.08075713f, 0.04786848f, 0.07036359f, 0.06959651f, -0.03378680f, -0.09565759f, 0.06637943f, 0.05671731f, 
    0.10038915f, -0.04731227f, -0.07665329f, 0.08390855f, 0.00256290f, 0.01671081f, -0.01371422f, 0.04659910f, 
    -0.08292941f, 0.08758856f, 0.06429188f, 0.02877436f, 0.03656455f, -0.42012200f, -0.37193841f, 0.08938258f, 
    -0.07096782f, -0.03335358f, 0.01216755f, -0.01848185f, 0.04481899f, -0.04666573f, -0.06623402f, -0.07198671f, 
    -0.09901407f, -0.01733506f, 0.03104685f, -0.04145809f, -0.02563179f, -0.02255462f, -0.00019377f, -0.05197471f, 
    0.04486655f, 0.02840433f, -0.07683181f, -0.00089030f, 0.07541973f, 0.02680178f, -0.03667124f, -0.12455422f, 
    -0.01708207f, -0.05788801f, -0.09992290f, -0.07533663f, -0.00053985f, -0.09635819f, -0.01544171f, 0.05869966f, 
    -0.20054531f, 0.00173913f, 0.14635603f, 0.15113541f, 0.01746900f, 0.14348477f, -0.01866804f, -0.01908755f, 
    0.02062340f, 0.04142484f, -0.03959508f, -0.00414725f, -0.00029338f, -0.15119927f, -0.08009472f, 0.00654924f, 
    -0.07834276f, 0.08558310f, -0.08722638f, -0.01413991f, -0.07057552f, 0.09202652f, -0.00905620f, -0.00759714f, 
    -0.11850278f, -0.19238175f, -0.00258600f, 0.22666568f, -0.07975861f, 0.04060367f, 0.02525231f, 0.02029737f, 
    -0.06865954f, -0.04420473f, 0.00565297f, 0.02351882f, -0.20836388f, 0.05468195f, 0.08715002f, -0.15913743f, 
    -0.07963775f, 0.01808104f, 0.02046575f, -0.01563648f, -0.03743840f, -0.02870722f, -0.09360678f, 0.06143394f, 
    -0.27661839f, -0.19255431f, -0.16420594f, -0.12755112f, -0.09836677f, -0.02241187f, 0.01430921f, -0.02291385f, 
    -0.05879165f, 0.11934725f, 0.01147577f, -0.00410424f, -0.17355427f, 0.15525074f, -0.00659158f, -0.04359366f, 
    -0.05296879f, -0.00248924f, -0.01916824f, -0.02440606f, 0.01991288f, 0.08302650f, -0.04293368f, -0.03869659f, 
    -0.06856885f, 0.06191138f, 0.01472724f, 0.15565000f, 0.01335687f, 0.10418186f, -0.08891720f, 0.03126233f, 
    -0.09959756f, 0.05214924f, -0.10824380f, -0.04031379f, 0.01261531f, 0.18557534f, 0.03901565f, 0.01494607f, 
    -0.04518044f, -0.11889946f, 0.02333543f, 0.00333383f, -0.00431377f, 0.00455472f, 0.08368002f, 0.13343073f, 
    -0.08991603f, -0.29887602f, -0.13042164f, -0.01932784f, -0.05984970f, -0.08924016f, 0.03191200f, -0.00039165f, 
    0.00375684f, 0.11732399f, 0.03085785f, -0.10033984f, 0.22371984f, -0.04866952f, 0.21614219f, -0.06604666f, 
    -0.02532268f, -0.04462718f, 0.01119461f, -0.01418380f, -0.00489948f, -0.11861092f, -0.06250464f, -0.11835846f, 
    0.00518390f, 0.16701661f, 0.06335142f, -0.06596643f, -0.06114541f, 0.04417381f, -0.03911859f, 0.00886355f, 
    0.01655285f, -0.01561122f, 0.01037783f, 0.02379479f, 0.15231891f, 0.04712374f, -0.04487952f, 0.20957860f, 
    0.00700056f, -0.08228472f, 0.06382704f, 0.02710745f, 0.05991267f, -0.03044636f, -0.02417135f, -0.07675637f, 
    0.04471817f, 0.11322830f, -0.11637367f, 0.13231556f, -0.05523167f, -0.09734382f, 0.01618226f, -0.00202006f, 
    -0.03495720f, 0.10693319f, 0.06833062f, -0.09589759f, 0.32544643f, -0.15458895f, -0.09131679f, 0.06295472f, 
    0.10061964f, -0.02259788f, -0.03024056f, -0.01418320f, 0.02319821f, 0.01210836f, -0.15126476f, 0.00661909f, 
    -0.32068983f, -0.13746855f, -0.19559227f, 0.14046372f, -0.12187292f, -0.04330194f, 0.02628527f, -0.06736289f, 
    0.02745634f, 0.00361469f, -0.02895196f, -0.00351839f, -0.08991197f, 0.07778075f, -0.08768663f, -0.23748900f, 
    -0.10503370f, -0.02836851f, -0.05065772f, -0.02038341f, 0.01696174f, -0.02776523f, -0.03014837f, 0.03495196f, 
    0.20893615f, 0.02171613f, 0.05134128f, 0.03521106f, 0.04782748f, 0.01261228f, 0.01188658f, -0.00854077f, 
    0.00447345f, -0.01910287f, -0.07265813f, 0.10473300f, -0.35001332f, -0.08530846f, -0.30470794f, -0.18037805f, 
    -0.09078562f, -0.05450334f, -0.04689548f, -0.00673096f, 0.00970524f, -0.02051205f, 0.11758743f, 0.04719312f, 
    0.34759304f, 0.31244349f, 0.07212253f, -0.04752108f, -0.01235590f, -0.05226652f, -0.00792995f, 0.05049673f, 
    -0.11753779f, -0.12185976f, 0.04767787f, -0.03628759f, 0.13189904f, 0.21328625f, 0.20845856f, -0.01097137f, 
    0.03414233f, 0.02896668f, 0.04393698f, 0.07399876f, 0.00260115f, -0.03524536f, -0.07782538f, 0.05104258f, 
    -0.04380608f, -0.07731184f, -0.17528838f, 0.03739955f, -0.07111757f, 0.08386517f, 0.03146842f, 0.05887041f, 
    0.00155958f, 0.13635519f, 0.01686770f, 0.04897396f, -0.44256613f, -0.00522904f, -0.07554098f, 0.02196049f, 
    -0.04348779f, 0.03087319f, 0.07923418f, -0.10767408f, -0.00906937f, -0.10510987f, 0.12915632f, 0.05583950f, 
    0.08208279f, 0.08470491f, -0.01732394f, 0.16624744f, -0.07679176f, 0.20825534f, 0.04830130f, 0.19202165f, 
    0.04331403f, -0.01143286f, 0.00024158f, 0.03124445f, 0.23402345f, 0.17337675f, -0.10904665f, -0.00423031f, 
    -0.00923628f, -0.07884540f, 0.06111826f, 0.04447746f, 0.00523849f, -0.00106179f, -0.02629005f, -0.03551252f, 
    -0.29582867f, -0.06820112f, -0.01837540f, 0.07861383f, -0.06906292f, 0.09978921f, 0.13544634f, -0.00489451f, 
    -0.01819383f, 0.06792676f, 0.05088534f, 0.01884857f, -0.15415151f, -0.17278025f, -0.11072663f, -0.12480133f, 
    -0.05797929f, -0.11767334f, -0.04642562f, -0.03045423f, 0.03131114f, -0.12340296f, 0.01372370f, 0.02473395f, 
    0.33238074f, -0.03791220f, -0.12276769f, 0.01607156f, 0.01542924f, -0.06294727f, 0.05610911f, -0.15467723f, 
    -0.00566380f, 0.07267615f, -0.02997963f, -0.05348961f, 0.12414640f, 0.05419910f, 0.09416092f, -0.02737497f, 
    0.01091872f, -0.01609182f, 0.03886187f, 0.13639511f, 0.06066866f, 0.04928932f, 0.02111619f, -0.01329937f, 
    0.11326386f, -0.21980804f, 0.00435755f, -0.07580769f, -0.05125117f, -0.01916818f, -0.03314307f, -0.01926373f, 
    -0.04034800f, 0.04837095f, -0.03371549f, 0.09584828f, -0.54297101f, -0.32186556f, -0.04171833f, 0.12114401f, 
    0.00385071f, 0.06173322f, 0.05448334f, -0.02172164f, -0.03158002f, -0.18831024f, 0.12522607f, -0.01502533f, 
    -0.00594664f, -0.36241058f, 0.12243304f, 0.03993217f, 0.10128190f, 0.00596279f, 0.14271377f, -0.04739874f, 
    -0.10776312f, -0.01074485f, -0.01279271f, 0.03428312f, 0.00258035f, -0.24554713f, -0.05329761f, 0.18628006f, 
    -0.01803536f, 0.01857030f, 0.01874320f, -0.10011199f, -0.03220564f, -0.04295266f, -0.03338449f, -0.00966783f, 
    -0.31138137f, 0.22562055f, 0.11229650f, 0.15532966f, 0.00470402f, -0.07180653f, -0.02827244f, 0.03204381f, 
    -0.00556533f, 0.00682067f, -0.00470418f, 0.00225737f, 0.05191656f, -0.15905523f, -0.06308229f, 0.13933383f, 
    -0.05643567f, 0.06470769f, -0.05073681f, -0.01773507f, 0.00652907f, -0.05998902f, 0.02449265f, -0.12043005f, 
    -0.41734457f, 0.21242450f, 0.03779536f, 0.22886978f, 0.09207664f, 0.14742097f, -0.01215012f, -0.01757379f, 
    -0.03831623f, 0.05027482f, 0.01232901f, -0.11646254f, 0.00293004f, 0.10886299f, -0.11678839f, 0.03848260f, 
    0.07593824f, -0.04477790f, -0.04642413f, -0.01411236f, 0.13270378f, -0.02724133f, 0.00904695f, 0.03516872f, 
    0.05511540f, 0.08623648f, -0.04127554f, -0.05304754f, -0.05833895f, -0.06411660f, 0.01661495f, -0.07703305f, 
    -0.09528527f, 0.02436016f, 0.01354961f, -0.11016005f, -0.23601012f, -0.10592125f, 0.02040640f, -0.07281221f, 
    -0.06860509f, -0.00170857f, -0.04340839f, -0.03178690f, 0.02942582f, -0.07654706f, 0.04089067f, -0.03605283f, 
    -0.16369085f, -0.15898202f, -0.04528442f, 0.02842163f, -0.04098424f, -0.05273772f, 0.07310179f, -0.00917385f, 
    -0.04944132f, 0.09121894f, -0.03897046f, -0.00432416f, -0.10771809f, 0.15427774f, 0.17097801f, 0.11901122f, 
    0.06148645f, 0.05975244f, 0.05670476f, 0.01880501f, -0.00049924f, 0.06434800f, -0.03798640f, -0.06104263f, 
    -0.23862202f, -0.12879363f, -0.12723349f, 0.03059603f, 0.01112703f, -0.07740382f, 0.00081838f, 0.02737133f, 
    -0.09293516f, -0.00391472f, -0.01253474f, 0.00552003f, -0.35107809f, -0.02030070f, 0.00804973f, -0.07856739f, 
    -0.05793820f, -0.06770042f, 0.03356816f, 0.02654028f, 0.08068372f, -0.17581567f, 0.12456816f, -0.04296515f, 
    -0.15069687f, 0.14145482f, 0.06865301f, 0.06457018f, 0.03729662f, -0.00783486f, 0.00131646f, 0.00945649f, 
    -0.02659170f, -0.06211092f, -0.02539662f, 0.02690652f, -0.19756690f, 0.05837715f, -0.06529022f, 0.07550673f, 
    -0.12781888f, 0.02249259f, -0.03466139f, 0.05467360f, -0.05110683f, -0.07226818f, -0.01100422f, -0.04814769f, 
    0.12847191f, 0.10439911f, 0.05991762f, 0.11966173f, -0.05093456f, 0.11281081f, 0.05149790f, 0.11735865f, 
    -0.00327026f, -0.03340763f, 0.07880432f, 0.06936550f, 0.17913891f, -0.00565069f, -0.05069756f, 0.04813004f, 
    -0.04131889f, -0.02420513f, 0.03599779f, -0.09339318f, 0.03000982f, 0.01284656f, 0.01079125f, 0.03571470f, 
    -0.14880970f, -0.12637003f, -0.06933541f, -0.03672872f, -0.01564833f, -0.04504433f, 0.01428411f, -0.00183809f, 
    -0.00359914f, -0.07454882f, -0.05521343f, -0.00440921f, -0.24229558f, 0.12967955f, -0.08158965f, -0.24478009f, 
    0.06780711f, -0.03075186f, 0.04020064f, -0.00398862f, 0.05932467f, 0.03712633f, -0.04749708f, 0.13561690f, 
    0.20803654f, -0.00148879f, -0.01324775f, -0.05723010f, -0.15685670f, 0.05615246f, -0.02211774f, -0.07227504f, 
    -0.03283707f, 0.01029111f, 0.07105542f, 0.01967751f, 0.24078526f, -0.19912411f, -0.23705307f, 0.12532786f, 
    -0.07608955f, -0.06230011f, 0.00806290f, -0.14560007f, -0.04597541f, 0.07723878f, -0.11907595f, -0.02842683f, 
    -0.06009883f, -0.32288876f, 0.10023813f, 0.07560164f, -0.10841668f, -0.02558259f, -0.02025934f, -0.07635593f, 
    0.06666563f, 0.03939395f, -0.05955449f, -0.01426505f, -0.17890945f, -0.11261098f, 0.15590106f, 0.01703063f, 
    0.01354726f, -0.07062697f, 0.05439303f, 0.01367490f, 0.10004301f, -0.05783590f, -0.03626812f, 0.01800500f, 
    -0.04582024f, -0.17625004f, 0.09411199f, -0.00756016f, -0.05706882f, 0.07544953f, -0.07528271f, 0.03030054f, 
    0.02102654f, 0.09363870f, -0.00036229f, -0.06700010f, -0.21742107f, 0.02023056f, -0.19708775f, 0.03671512f, 
    -0.07288807f, -0.08806223f, 0.07468765f, -0.12170574f, -0.05534430f, -0.14551626f, 0.13910829f, -0.09342158f, 
    -0.02534031f, -0.11870953f, -0.02590441f, -0.14331597f, 0.09791870f, -0.00971137f, -0.02535238f, -0.06408659f, 
    0.01126671f, -0.01520095f, -0.10634005f, -0.05797984f, -0.20199856f, 0.02867815f, -0.03761486f, -0.01362020f, 
    0.06434980f, 0.02552539f, -0.02675018f, 0.07872726f, -0.10115718f, -0.02439481f, -0.10137372f, -0.00922403f, 
    0.17988792f, 0.09923261f, -0.00652966f, 0.03279058f, -0.01744103f, 0.01293568f, 0.00286172f, 0.03059004f, 
    -0.00564949f, -0.03865006f, 0.02820327f, -0.04670342f, 0.24615809f, 0.05948703f, 0.00687776f, 0.25316820f, 
    -0.07077459f, 0.04723559f, 0.08817162f, -0.03922968f, 0.02486516f, 0.02562156f, 0.01626160f, -0.06479667f, 
    -0.16751724f, 0.05423955f, 0.05570719f, 0.17413792f, -0.03359357f, 0.16261676f, -0.07810526f, 0.05347464f, 
    0.04755773f, 0.07512988f, 0.04006619f, 0.06028886f, -0.10875706f, 0.18475387f, 0.07565547f, 0.02161715f, 
    0.10801655f, -0.02451568f, 0.05738588f, 0.00630011f, -0.01464479f, 0.04912832f, -0.01610184f, 0.10236884f, 
    -0.28003642f, 0.23750965f, 0.11377727f, 0.00734074f, 0.09381696f, 0.03339459f, 0.00568155f, 0.05685096f, 
    -0.05016193f, 0.04820566f, 0.00826822f, 0.13870624f, -0.12190948f, -0.12475523f, 0.04234092f, 0.08588050f, 
    -0.08178089f, 0.07700173f, 0.03134401f, -0.03315568f, 0.06313476f, 0.05461974f, 0.02471777f, -0.00737240f, 
    -0.07640570f, -0.12373683f, -0.06377839f, 0.06049025f, -0.06096872f, -0.03646504f, 0.06341266f, 0.01231496f, 
    0.01121153f, -0.00391107f, -0.02481556f, -0.00236265f, 0.13830076f, -0.02576357f, 0.14649639f, 0.24571639f, 
    -0.07949342f, 0.02609624f, 0.06722375f, 0.02487261f, 0.05307467f, 0.02823368f, 0.03588481f, -0.00559376f, 
    -0.46313402f, 0.12191159f, -0.05692653f, -0.11022159f, 0.06964757f, -0.02412108f, -0.05761945f, -0.11774429f, 
    -0.03089722f, -0.02342382f, -0.01887735f, 0.01380870f, -0.19100505f, 0.04514859f, 0.12727617f, -0.03133533f, 
    -0.00091096f, 0.07017902f, -0.05324440f, 0.06792912f, 0.02322136f, 0.03942454f, 0.10289150f, 0.12613823f, 
    -0.10255523f, 0.11934278f, 0.09576464f, -0.15649721f, 0.01716732f, -0.00023761f, -0.00178407f, 0.04785976f, 
    0.04195506f, 0.07505639f, -0.07738324f, -0.12359494f, -0.16929919f, -0.03535005f, 0.19117215f, 0.20435302f, 
    -0.03729371f, -0.07502828f, 0.04687732f, 0.00788909f, -0.10317312f, 0.08559892f, 0.05121000f, 0.09465159f, 
    -0.09277100f, -0.03620733f, 0.12561570f, 0.04453834f, -0.02525504f, -0.03218872f, 0.04411008f, 0.08799712f, 
    0.04109985f, -0.04041562f, 0.07232498f, 0.05912047f, -0.05272744f, -0.22618654f, -0.04063468f, 0.26813391f, 
    0.08188934f, 0.00593059f, 0.04418108f, -0.01959050f, -0.06885031f, 0.08059099f, 0.06433353f, -0.02173858f, 
    -0.15359393f, -0.18182792f, -0.02789753f, 0.08209907f, -0.00516724f, 0.03820290f, -0.00563343f, -0.06318235f, 
    0.08302724f, -0.07143425f, -0.03752903f, -0.01700674f, 0.04660467f, -0.08281235f, 0.15835947f, 0.03737582f, 
    0.14207642f, 0.09625464f, -0.09599709f, 0.04489166f, 0.14176612f, 0.04645916f, -0.00479648f, 0.12540279f, 
    -0.11926444f, -0.47065827f, -0.00895894f, -0.11284834f, 0.05999821f, -0.03500135f, 0.03342072f, -0.12782897f, 
    0.12782791f, 0.02708704f, -0.06085694f, -0.09693489f, -0.13277486f, 0.00734286f, -0.03977101f, -0.17586555f, 
    0.07979196f, 0.02381585f, -0.06129629f, -0.05322620f, 0.03326743f, -0.00514271f, 0.07493766f, -0.06483637f, 
    0.30899811f, 0.13764778f, 0.13208655f, 0.11090820f, 0.01030829f, -0.08550550f, 0.06097424f, 0.04633003f, 
    0.00447014f, 0.06622893f, 0.02088984f, 0.04996500f, 0.04474835f, -0.08780051f, 0.04912875f, 0.11935111f, 
    -0.08255575f, -0.04719949f, 0.05987778f, -0.03298924f, -0.07543477f, 0.03287077f, -0.09107254f, -0.04573276f, 
    -0.31318748f, -0.08538453f, 0.00388799f, 0.20073102f, 0.03409291f, 0.02050002f, -0.00489768f, 0.09703261f, 
    0.07559425f, 0.02027739f, -0.02656000f, -0.06025041f, -0.05672712f, 0.14910956f, 0.16913842f, -0.05754844f, 
    -0.19326963f, 0.10264090f, -0.02297021f, -0.07416688f, 0.09550082f, -0.05206184f, -0.02220554f, 0.05621455f, 
    0.04682506f, 0.05528373f, -0.01249944f, 0.04021487f, -0.07653830f, -0.08763441f, 0.00544756f, 0.03650003f, 
    -0.00375643f, 0.09680535f, -0.01437258f, 0.06032747f, 0.23952930f, -0.21930586f, -0.11438563f, 0.13078646f, 
    -0.03894740f, 0.01415372f, -0.15336463f, 0.03723565f, 0.03184223f, -0.01182260f, 0.00345417f, 0.04731635f, 
    -0.07306521f, 0.01229363f, -0.03944437f, 0.15787104f, -0.11072557f, 0.02590615f, 0.01954645f, 0.03846711f, 
    0.00934647f, -0.08464614f, -0.06751399f, 0.02777547f, -0.19615886f, 0.02516501f, 0.00836770f, 0.01812015f, 
    0.00359507f, -0.11983516f, -0.00866013f, -0.02317334f, -0.02097929f, 0.00963253f, 0.05390530f, -0.01747723f, 
    0.23864681f, 0.00819114f, -0.20333387f, 0.01427445f, 0.08148891f, 0.03539750f, 0.08152707f, -0.05205791f, 
    0.05958115f, -0.01685235f, -0.13560772f, -0.05569513f, -0.08849706f, 0.25405231f, 0.06422127f, -0.02685863f, 
    -0.03726616f, -0.16237347f, 0.10742731f, 0.02707926f, -0.01654972f, 0.00891981f, -0.03503833f, -0.06132582f, 
    -0.08918820f, -0.11456577f, 0.05618027f, 0.14601719f, 0.05699687f, -0.07228151f, 0.08863949f, 0.10898643f, 
    0.01890054f, -0.07912700f, 0.01018408f, 0.10630532f, -0.11207855f, -0.28941402f, -0.19067198f, 0.17974530f, 
    0.03237841f, 0.01207087f, 0.10784162f, -0.10059249f, 0.04653658f, -0.07178309f, 0.10362097f, -0.02264384f, 
    0.13876328f, -0.27482590f, 0.06380240f, 0.05312689f, -0.16857192f, 0.14811024f, -0.11289167f, -0.10058146f, 
    -0.02674506f, -0.04744454f, -0.04717395f, 0.05590082f, -0.07329578f, -0.03575270f, 0.01522318f, -0.30119187f, 
    0.00411829f, 0.05737455f, -0.01275300f, 0.01400779f, 0.04753679f, -0.09268913f, 0.03451898f, -0.05630074f, 
    -0.02821288f, 0.00159372f, -0.14711320f, -0.09481557f, 0.00069323f, -0.04790510f, -0.00411256f, 0.12542619f, 
    -0.15121774f, -0.04918992f, -0.01835561f, -0.13737306f, -0.37288162f, -0.01836006f, 0.07584596f, 0.19367550f, 
    -0.03297073f, -0.02640182f, 0.00142369f, 0.03656153f, -0.03622442f, -0.02457469f, 0.05061114f, 0.04560286f, 
    -0.26871040f, 0.21204294f, -0.03329853f, 0.01865287f, 0.01687734f, 0.01288907f, 0.04910742f, 0.06650518f, 
    -0.09857945f, -0.04819076f, 0.05780752f, 0.01485722f, 0.27959633f, 0.31457344f, -0.20538354f, -0.50531387f, 
    0.00052393f, -0.02799195f, 0.02166343f, -0.04221465f, -0.11041315f, 0.08530186f, -0.02529945f, 0.01903375f, 
    -0.09468997f, -0.02784323f, 0.05489558f, 0.00796045f, 0.04755137f, 0.03257703f, 0.02326041f, 0.00436117f, 
    -0.05514180f, 0.05154757f, -0.07209077f, 0.02985423f, 0.08677091f, 0.12451120f, 0.13062163f, 0.03859129f, 
    0.00918487f, -0.02419778f, -0.04032856f, 0.05304689f, 0.06867760f, 0.09631305f, 0.07855543f, -0.06947823f, 
    0.13649569f, -0.04206024f, -0.07845347f, -0.05314197f, -0.12003321f, -0.03290940f, -0.02314734f, -0.00287762f, 
    0.01423100f, -0.07436880f, 0.05754659f, -0.00153973f, 0.06529904f, 0.10633828f, -0.17496924f, 0.07776023f, 
    0.01562821f, -0.00148568f, 0.09727196f, 0.17457007f, 0.07588678f, -0.10529158f, -0.02911053f, -0.03340222f, 
    0.05042037f, 0.22057925f, 0.03838449f, -0.02396514f, -0.04372112f, 0.15972848f, 0.16695750f, -0.09553577f, 
    -0.01351214f, 0.01834232f, -0.05701299f, 0.08273468f, -0.10067792f, 0.16114460f, 0.25845808f, 0.02000931f, 
    0.03052428f, 0.01944592f, -0.09586002f, -0.12027407f, 0.08535303f, -0.11068699f, -0.00317397f, -0.04621142f, 
    -0.50189376f, -0.01967429f, 0.15801249f, -0.12268267f, -0.02187215f, -0.00218272f, -0.09136074f, -0.10410140f, 
    0.04261896f, 0.05923696f, -0.06701317f, -0.14313146f, -0.17828429f, -0.17239411f, 0.18922594f, 0.33753762f, 
    -0.07081436f, 0.03964389f, 0.04943362f, 0.01286033f, -0.11776387f, 0.08050536f, 0.04918759f, 0.03978622f, 
    -0.49137998f, 0.01771071f, -0.07461093f, 0.14793673f, 0.03906669f, -0.07232200f, -0.04014419f, 0.03126327f, 
    -0.04295553f, -0.08122240f, 0.04010172f, 0.01406011f, -0.13265736f, 0.04749935f, -0.11095542f, -0.15083231f, 
    0.07670253f, -0.19566303f, -0.05002272f, -0.03568242f, -0.05405434f, -0.18367440f, 0.05522293f, 0.02608718f, 
    0.03780682f, -0.00120040f, -0.00295952f, -0.02302889f, 0.08035186f, 0.09194662f, 0.07387673f, 0.00656700f, 
    -0.06960607f, 0.08985896f, 0.03989600f, 0.14318860f, -0.13331224f, -0.08098710f, 0.03156150f, 0.19492516f, 
    0.07664501f, -0.00870408f, 0.00748794f, 0.06079563f, 0.12890463f, 0.01903362f, -0.04782251f, -0.02030596f, 
    0.05972487f, 0.19926588f, -0.01614022f, 0.02748961f, 0.00442010f, -0.03992284f, -0.01878620f, 0.07462260f, 
    -0.10500075f, -0.02258232f, 0.03961793f, -0.07030436f, -0.38120836f, 0.11521010f, -0.04448581f, -0.01743482f, 
    0.01932677f, 0.08116702f, 0.03468131f, 0.20579752f, -0.01388286f, 0.03874924f, -0.01085343f, 0.03103776f, 
    -0.01676827f, -0.03261399f, 0.00666811f, -0.18887602f, -0.02611784f, 0.00188129f, 0.07078123f, 0.01375415f, 
    0.00422335f, 0.01717559f, 0.04193859f, -0.02382190f, -0.49502045f, -0.03091554f, 0.00728686f, -0.23277751f, 
    -0.06976518f, -0.06558145f, -0.10799368f, -0.03730004f, -0.02203974f, 0.05179741f, -0.17239578f, 0.02832951f, 
    0.00192301f, -0.06198453f, 0.02037625f, 0.05200087f, 0.01715021f, 0.08887751f, 0.03945724f, -0.01200909f, 
    0.06889360f, -0.09207701f, -0.08041418f, -0.09824827f, -0.14638180f, 0.22512078f, 0.00820732f, -0.04675426f, 
    0.10145619f, 0.11355767f, -0.06994520f, 0.11088279f, 0.01253585f, 0.00173162f, 0.00604182f, 0.17021577f, 
    -0.08058044f, 0.01165350f, -0.01581047f, 0.07866268f, -0.04199733f, 0.00243074f, -0.01245007f, 0.03386667f, 
    0.01913289f, -0.00877347f, 0.10482662f, 0.08621272f, -0.36505908f, -0.34941566f, -0.04082472f, -0.00485555f, 
    0.06374112f, 0.01176805f, 0.03273385f, -0.06774200f, -0.16597407f, 0.02936717f, 0.10924661f, 0.01794885f, 
    -0.04843128f, -0.01933705f, 0.24568971f, 0.42010096f, 0.00616070f, -0.00435248f, 0.09349575f, 0.09533238f, 
    -0.02826815f, -0.02048630f, -0.00210947f, -0.02217888f, 0.11520550f, 0.00363066f, 0.07357514f, -0.10941000f, 
    0.09090898f, -0.03501106f, -0.03127097f, -0.02283346f, 0.08731866f, -0.03257317f, 0.11079782f, 0.00289619f, 
    0.08401077f, 0.04488136f, -0.07150534f, -0.08317631f, 0.06166023f, 0.03967169f, -0.05108231f, 0.09633891f, 
    0.00118432f, 0.03641857f, -0.04320266f, -0.15519983f, 0.03733118f, 0.06510789f, 0.09172489f, 0.27158496f, 
    -0.13609730f, -0.06079597f, -0.01678802f, -0.02050312f, -0.10218378f, -0.01151403f, 0.10195747f, 0.16660418f, 
    0.05594524f, 0.06243868f, -0.01099004f, -0.12000337f, -0.07640910f, -0.04519471f, -0.02950418f, 0.02830364f, 
    0.02470149f, -0.08506874f, 0.00955466f, -0.08880185f, -0.19316007f, 0.19591655f, 0.10165963f, -0.28863379f, 
    0.05222825f, 0.05907279f, -0.15140317f, 0.02390630f, 0.11547010f, -0.04036251f, -0.10710760f, 0.01555725f, 
    -0.37006280f, -0.15522327f, 0.01348979f, 0.12824254f, 0.06637836f, -0.07348391f, -0.06755225f, -0.16864868f, 
    -0.02382656f, 0.02500993f, 0.20413196f, -0.00484385f, -0.16633932f, -0.13540557f, -0.15714116f, -0.17534831f, 
    0.14993618f, 0.02207589f, 0.02001639f, 0.05432208f, 0.02213309f, 0.03481740f, 0.01872539f, -0.05279205f, 
    -0.03769088f, -0.01397247f, 0.13532513f, 0.00505117f, 0.01145589f, 0.08050992f, 0.03185813f, -0.04498801f, 
    0.02350356f, 0.08368549f, 0.00487941f, 0.20376328f, -0.02613778f, -0.01605985f, 0.03350639f, -0.17384300f, 
    0.04060034f, -0.10603209f, -0.01612230f, 0.08545198f, -0.02134759f, -0.07030129f, 0.07461450f, 0.08985125f, 
    0.04959398f, -0.08464512f, -0.10238095f, -0.06253920f, 0.06080668f, -0.14595778f, -0.03791351f, 0.03568192f, 
    -0.06794149f, 0.03453411f, -0.10837475f, 0.01689154f, -0.33107060f, -0.29406059f, -0.00442104f, 0.14880797f, 
    -0.01284438f, 0.00292038f, 0.12395091f, 0.08441807f, 0.03769745f, 0.13992876f, 0.16256760f, 0.16972581f, 
    -0.32803452f, -0.18502577f, -0.05530357f, -0.15778027f, -0.06896621f, -0.14711016f, 0.06456431f, -0.07335770f, 
    -0.01946482f, -0.10240213f, -0.05998298f, -0.07508366f, 0.19478898f, 0.08874972f, 0.00230330f, 0.10250402f, 
    -0.03181191f, -0.02006718f, -0.04333435f, -0.00186112f, -0.12176757f, 0.03292207f, 0.00224652f, 0.04411241f, 
    -0.05877195f, -0.14738975f, -0.01216016f, 0.03958629f, 0.02138504f, 0.11965962f, -0.04029860f, -0.06989900f, 
    -0.06890120f, -0.00634488f, -0.07848813f, 0.10785536f, -0.22179550f, -0.18013667f, -0.21556737f, 0.09213678f, 
    0.02720282f, -0.18843612f, -0.08846474f, 0.09876258f, 0.10001981f, -0.03395877f, 0.12044834f, 0.02005267f, 
    -0.17508624f, -0.01194143f, 0.12155627f, -0.15643148f, 0.02242238f, 0.03858644f, -0.06622709f, 0.01331999f, 
    0.07131272f, -0.21121702f, 0.06877019f, -0.07018138f, 0.03815339f, -0.00849472f, -0.06646226f, 0.09723428f, 
    0.05339379f, -0.10382862f, 0.00327294f, -0.17436349f, 0.04701576f, -0.00704692f, -0.14568950f, 0.05916816f, 
    -0.13397506f, 0.01398869f, 0.04567464f, 0.20093764f, 0.00019964f, 0.08177959f, 0.08759519f, -0.04530862f, 
    -0.05476898f, 0.00744572f, 0.03722967f, 0.08214123f, 0.27019325f, -0.23815638f, -0.21172144f, 0.03696466f, 
    0.07951283f, 0.04020048f, -0.16831885f, 0.05820106f, 0.00329472f, -0.12915418f, 0.03263985f, -0.04102791f, 
    0.15647756f, 0.14249629f, 0.10985555f, 0.00113515f, -0.00560963f, 0.02017985f, -0.11237326f, -0.08850870f, 
    -0.08829651f, -0.10580393f, 0.05953195f, -0.02388288f, 0.14993596f, 0.13587636f, -0.09551381f, -0.04260138f, 
    -0.00490735f, 0.05082819f, -0.16422553f, -0.00138903f, 0.02840043f, -0.16893382f, -0.03827482f, -0.00871315f, 
    0.03892542f, 0.04392637f, 0.08310174f, -0.00645869f, -0.09277123f, -0.02185462f, -0.03587643f, 0.09264528f, 
    0.08296406f, 0.05724481f, 0.00884759f, 0.14350367f, -0.03353095f, 0.14386530f, -0.02164004f, 0.24395232f, 
    0.07992482f, 0.13037421f, -0.01491049f, 0.01657048f, -0.06002066f, -0.08131791f, 0.18131089f, -0.03900438f, 
    -0.02539230f, 0.21198995f, 0.06486180f, 0.20303401f, 0.00686973f, -0.02682348f, 0.05012704f, 0.07963394f, 
    0.11758894f, -0.12107413f, 0.12381000f, 0.02170373f, -0.30937377f, 0.04471280f, -0.06772443f, -0.11519770f, 
    0.18784925f, -0.04725195f, 0.12483151f, 0.00763871f, -0.00024132f, 0.12953940f, 0.06178949f, 0.09814423f, 
    0.06176745f, -0.29685369f, -0.00751348f, -0.08365402f, 0.07400927f, 0.05306499f, -0.03535284f, -0.11841036f, 
    -0.02489959f, -0.09488415f, -0.05031893f, 0.02420368f, -0.04424416f, -0.04078088f, 0.19540852f, -0.03243390f, 
    0.04943593f, 0.08525166f, -0.04785343f, 0.03860890f, 0.02566785f, -0.15941975f, -0.02346434f, 0.03446486f, 
    0.07802015f, -0.03761970f, -0.29297963f, -0.28373089f, 0.00779806f, 0.12337077f, 0.00354767f, -0.12110349f, 
    0.08659884f, -0.01135504f, -0.13302746f, -0.08973052f, 0.02547693f, 0.09048872f, 0.17998572f, 0.19347060f, 
    -0.03847085f, -0.02905305f, 0.06227887f, 0.10143516f, 0.00647876f, -0.11888172f, 0.00259193f, -0.11304699f, 
    0.04739794f, 0.04532973f, 0.04339542f, 0.04058556f, -0.00750460f, 0.00206813f, 0.02160989f, 0.02498647f, 
    0.16653603f, -0.05926724f, 0.00185775f, -0.02391554f, 0.09351601f, 0.03184005f, 0.02403611f, -0.07978770f, 
    0.05252546f, 0.05545218f, 0.06412501f, -0.15728165f, 0.01041804f, 0.08031027f, 0.06714630f, 0.16128844f, 
    -0.28899017f, -0.20568942f, 0.16628236f, 0.08190792f, 0.07101502f, -0.06214552f, 0.00621830f, -0.06999930f, 
    -0.17743905f, 0.07707419f, 0.14185300f, -0.03231464f, 0.14272073f, 0.01665570f, 0.06595933f, -0.13373095f, 
    -0.04724763f, 0.13588074f, -0.07403106f, 0.00776681f, 0.05485594f, 0.00221954f, 0.09748711f, 0.04370425f, 
    -0.09437004f, -0.17330532f, 0.15916193f, 0.05779686f, -0.19055575f, -0.03590099f, 0.02352213f, -0.03286213f, 
    0.04660854f, 0.05447051f, 0.04573824f, -0.08974301f, -0.00647079f, -0.12093743f, 0.03913182f, 0.18640308f, 
    0.07650974f, 0.01571858f, -0.03419888f, 0.05654722f, 0.09400491f, 0.14947665f, 0.03622724f, 0.11955560f, 
    0.21858343f, -0.10566501f, -0.11950757f, -0.02832014f, 0.07423119f, 0.03173300f, -0.03164013f, -0.08232638f, 
    -0.08504963f, -0.20513642f, 0.04190761f, -0.19325449f, 0.19849679f, 0.16525008f, 0.17276601f, -0.10209256f, 
    0.02067064f, -0.18310520f, -0.11903311f, -0.17633861f, -0.09406760f, 0.08992893f, -0.07005414f, -0.09489103f, 
    0.02384694f, 0.01082965f, 0.10295343f, -0.00803385f, 0.05998057f, -0.10501821f, 0.07795086f, -0.04375118f, 
    0.01472790f, -0.16374399f, -0.07566555f, 0.17789817f, -0.61465162f, -0.01725886f, 0.09906738f, -0.12576327f, 
    -0.12059818f, 0.05699587f, 0.04710788f, 0.01629885f, -0.09338190f, 0.01518174f, -0.02235662f, 0.00416003f, 
    0.10406668f, -0.02753784f, 0.13447976f, 0.02153831f, -0.11427481f, 0.06889816f, -0.03928022f, -0.08891771f, 
    -0.07790875f, 0.10205455f, 0.05950823f, 0.09511838f, -0.28261524f, 0.14607236f, -0.18244140f, -0.08307572f, 
    -0.00581776f, 0.04907941f, -0.13177182f, -0.04060496f, -0.01931432f, 0.02958538f, 0.01153347f, -0.06936627f, 
    -0.33233801f, 0.16012672f, -0.06844659f, -0.21376121f, 0.03999912f, -0.02642680f, -0.03867808f, -0.09012663f, 
    0.02539064f, -0.03914690f, 0.03050740f, -0.00270589f, -0.29137924f, -0.22799201f, 0.23830719f, 0.26019379f, 
    0.05165117f, -0.08262306f, -0.18786593f, -0.03813953f, 0.06345396f, 0.03875523f, -0.01510695f, 0.02679515f, 
    -0.43020508f, -0.24183890f, -0.22373249f, -0.01753080f, 0.17680292f, -0.02150291f, -0.00382658f, -0.00115131f, 
    0.10142906f, 0.06706700f, 0.05863251f, -0.03140289f, 0.08730330f, 0.00826576f, 0.16254918f, 0.02824699f, 
    -0.04776891f, 0.08111700f, 0.00609805f, -0.05607465f, -0.14302745f, 0.03216405f, 0.19310275f, 0.03168285f, 
    -0.38061669f, 0.21434213f, 0.09807307f, -0.07023794f, -0.13588949f, -0.07613491f, -0.09719662f, 0.02973271f, 
    -0.09012414f, -0.09416500f, -0.06557172f, -0.19985244f, 0.01288471f, 0.06185940f, 0.15288617f, -0.27204075f, 
    0.00890214f, -0.01267456f, -0.00923320f, -0.03228555f, -0.03770376f, 0.18316574f, 0.09847532f, 0.13905436f, 
    0.01210718f, -0.13960092f, -0.09005453f, 0.07514998f, 0.05140541f, -0.09193497f, -0.05985952f, -0.05484646f, 
    0.18551667f, 0.04974755f, -0.00923561f, -0.10843113f, 0.06155388f, -0.05135621f, -0.11657219f, 0.19072649f, 
    -0.02658294f, 0.03137434f, -0.02065125f, -0.00315588f, 0.04189500f, 0.11333567f, 0.01104087f, 0.05649617f, 
    0.01409867f, -0.00170447f, 0.12699266f, -0.18735792f, -0.00457203f, -0.05385781f, 0.07531328f, 0.03902973f, 
    -0.00987760f, -0.18423656f, -0.01720787f, -0.03583859f, -0.15412420f, 0.17629045f, 0.08708109f, -0.14355269f, 
    0.05567699f, 0.00608812f, -0.06113936f, -0.18102564f, -0.09893747f, 0.07930293f, 0.02970600f, -0.17081651f, 
    -0.21537238f, 0.01964110f, -0.19216442f, -0.04789406f, 0.04407701f, 0.08678529f, 0.09719808f, 0.03794730f, 
    0.15535153f, -0.09698226f, 0.06244307f, -0.08012762f, -0.05874328f, 0.05308694f, 0.14455666f, 0.00306936f, 
    -0.02558297f, 0.06849804f, 0.03790056f, 0.02668944f, 0.02162825f, 0.02635245f, -0.09480460f, 0.10746140f, 
    0.07570475f, -0.03267189f, 0.13716096f, 0.12382271f, 0.04623290f, -0.04579310f, -0.11243936f, 0.05522844f, 
    -0.02028695f, -0.09749990f, -0.14780758f, -0.05515559f, 0.06955096f, -0.06520006f, -0.10843831f, -0.13983257f, 
    0.03316662f, -0.02978398f, -0.12186047f, -0.13529032f, -0.16714694f, 0.01788047f, 0.09709825f, 0.26530340f, 
    -0.11899882f, 0.08817431f, 0.07425067f, -0.04979838f, 0.00043051f, 0.02912523f, 0.07734436f, 0.00060044f, 
    0.05569419f, 0.11516574f, -0.07708085f, 0.06626364f, -0.35097367f, 0.14268795f, -0.01691904f, -0.14943813f, 
    -0.00120730f, -0.05468473f, 0.06646746f, -0.03821157f, -0.04491983f, -0.14579540f, -0.00662306f, -0.16973847f, 
    -0.03835722f, -0.20250893f, -0.13403076f, -0.01973322f, 0.07222714f, -0.01752737f, 0.03172995f, 0.17797798f, 
    0.19919795f, 0.08873408f, 0.09279300f, 0.04162351f, -0.07408465f, -0.02199646f, -0.12376656f, 0.01258680f, 
    0.05304524f, -0.04611496f, 0.05545492f, 0.03786564f, 0.03490213f, -0.12414081f, -0.04464349f, -0.02315226f, 
    0.00357325f, 0.10213895f, 0.03780047f, 0.06194058f, -0.12936081f, 0.02132483f, 0.06170106f, 0.00789196f, 
    -0.04838481f, 0.11306036f, 0.14790078f, -0.09895333f, 0.03195072f, 0.03646583f, 0.05985753f, 0.04782856f, 
    0.15436967f, -0.13248006f, 0.02561053f, -0.08078312f, 0.10760647f, 0.01783486f, -0.09851470f, -0.04020884f, 
    0.06260254f, -0.14843394f, -0.20055126f, 0.24277292f, -0.05009909f, 0.08041008f, 0.03283318f, -0.00170303f, 
    0.04381543f, -0.09605969f, -0.18517455f, -0.08979705f, 0.12174339f, -0.29126987f, 0.01876208f, -0.10630222f, 
    -0.05139871f, 0.09439354f, 0.05645275f, -0.01276396f, 0.15664275f, -0.07717696f, -0.08122689f, 0.05424470f, 
    0.00563101f, -0.03260059f, -0.00780565f, 0.01733377f, -0.09857080f, -0.07764791f, -0.02296492f, -0.06857719f, 
    0.04298923f, 0.03417652f, 0.00638358f, 0.17279267f, -0.19241415f, 0.03035707f, 0.02074484f, 0.23757039f, 
    0.02335181f, 0.05878356f, 0.13980173f, 0.01911296f, 0.07972421f, -0.13416427f, -0.13064955f, -0.02706568f, 
    -0.19893663f, 0.19742325f, 0.03415421f, -0.02904112f, -0.00247423f, 0.16245602f, -0.13170600f, 0.02633659f, 
    -0.11834200f, 0.02228124f, 0.04746187f, 0.01729702f, 0.01912499f, -0.24544160f, -0.04634012f, -0.01737787f, 
    0.07104716f, 0.00335402f, -0.07804660f, 0.00778311f, -0.06349963f, -0.07804587f, -0.12015275f, -0.09305795f, 
    -0.23366849f, 0.12323680f, 0.12079886f, 0.19149537f, -0.03641428f, 0.07496943f, -0.11801486f, 0.00895318f, 
    -0.08125512f, 0.10241559f, 0.08766139f, 0.12551847f, 0.16649905f, -0.18450004f, 0.16416492f, 0.09268823f, 
    -0.03311428f, -0.07200307f, 0.06085969f, 0.10384859f, -0.02277460f, 0.00052701f, 0.01273626f, 0.02830057f, 
    0.25468165f, 0.01310624f, 0.09400194f, 0.14339402f, -0.12189655f, 0.14796893f, 0.02255392f, -0.00888478f, 
    -0.09992833f, 0.04439659f, -0.11840609f, -0.07645796f, -0.14661393f, 0.07660627f, -0.00920388f, -0.12615091f, 
    0.01157151f, -0.05397981f, 0.16840705f, -0.07788484f, 0.08771214f, -0.02767600f, 0.03401043f, 0.00599069f, 
    0.04975132f, 0.07537434f, 0.13746959f, -0.35229668f, -0.18642119f, -0.03945091f, -0.08046120f, 0.09893818f, 
    0.06334756f, -0.07414021f, -0.02026698f, -0.14268139f, 0.05804738f, 0.13822779f, 0.12615365f, -0.31809959f, 
    -0.02105655f, 0.16027020f, 0.00905434f, -0.01933783f, -0.05309753f, 0.06123969f, 0.03438999f, -0.01923524f, 
    -0.17099440f, -0.07899187f, -0.22733869f, -0.09591126f, 0.09859212f, 0.06242824f, -0.03633107f, -0.06695244f, 
    0.06096029f, -0.05159280f, 0.15701832f, -0.06090165f, 0.02009177f, 0.08325192f, -0.24429458f, -0.11039590f, 
    -0.09695426f, 0.03526114f, -0.00427190f, -0.07969157f, 0.00177895f, -0.24170709f, -0.16104154f, -0.05415429f, 
    0.05651552f, -0.01013835f, 0.03347352f, 0.02387444f, 0.08889928f, 0.01049956f, -0.04305892f, -0.10199337f, 
    0.06655063f, -0.00896292f, 0.11261146f, 0.08372322f, -0.23724279f, 0.19542307f, 0.12396631f, 0.10579585f, 
    0.02585440f, -0.00088416f, 0.06101684f, 0.03569376f, 0.08413527f, -0.03694621f, -0.07894748f, -0.17367774f, 
    -0.37921908f, -0.00084955f, -0.08237194f, 0.12926345f, 0.06866609f, -0.08138017f, 0.00046634f, 0.05910319f, 
    0.20416535f, 0.01298174f, 0.03247315f, -0.05842806f, -0.38769138f, -0.00961864f, -0.10604861f, -0.08007520f, 
    -0.06243682f, -0.01602790f, -0.14508341f, -0.02402943f, 0.02862454f, -0.10144211f, -0.00838375f, -0.07538280f, 
    0.55810815f, 0.10491820f, -0.00655241f, -0.23478249f, -0.08011515f, 0.00386337f, 0.05816771f, 0.05072688f, 
    0.01639433f, 0.05885081f, -0.03202488f, 0.09884114f, -0.05169845f, -0.07783116f, -0.02545124f, 0.12743579f, 
    0.06402836f, 0.07993178f, -0.00010442f, 0.07363337f, -0.02385224f, 0.09037328f, 0.07777514f, 0.03058842f, 
    0.10497738f, -0.02451549f, -0.04967970f, -0.17063603f, -0.01199867f, -0.03107209f, -0.04337746f, 0.00630239f, 
    0.04910527f, -0.00366621f, 0.05795542f, -0.12543619f, -0.14517383f, 0.00596851f, -0.37082800f, 0.08030424f, 
    -0.13868332f, -0.02117993f, 0.03039171f, -0.10497539f, -0.02813452f, 0.02130512f, -0.00177108f, -0.02956865f, 
    -0.11150203f, -0.04124113f, 0.10055824f, -0.02899407f, -0.10239049f, -0.02197270f, 0.00138870f, 0.09817638f, 
    -0.08057430f, 0.05283999f, -0.02180400f, 0.12027322f, -0.14135455f, -0.00548129f, -0.21998024f, 0.08597010f, 
    -0.05421017f, 0.03053535f, 0.12222556f, -0.08421136f, 0.01003645f, 0.01840880f, 0.06223297f, 0.10597017f, 
    0.03647286f, -0.01430715f, 0.03690278f, 0.03835532f, 0.11758485f, 0.09410726f, 0.07674922f, -0.06758824f, 
    -0.12421627f, -0.07253858f, -0.08978684f, -0.03628771f, -0.17124683f, -0.01011554f, -0.06317572f, -0.24996704f, 
    0.00763838f, -0.08626564f, -0.06542345f, -0.04818232f, -0.04414863f, 0.11087149f, -0.05212175f, 0.04793881f, 
    -0.36206567f, 0.19803423f, -0.11113300f, 0.30620593f, -0.03074886f, -0.01395671f, -0.07867795f, -0.02122479f, 
    -0.10121511f, -0.01549552f, -0.02405311f, -0.17736943f, 0.17030184f, -0.30444750f, 0.15827216f, 0.09608581f, 
    0.01506137f, 0.00948472f, -0.01719970f, 0.02729730f, -0.06165272f, -0.04835804f, -0.04917716f, -0.00117549f, 
    -0.02128297f, -0.04308292f, -0.16549572f, 0.03169293f, 0.01215659f, 0.04403860f, 0.07342318f, -0.05563550f, 
    -0.02491884f, 0.14357421f, 0.05505315f, 0.10908379f, 0.08895596f, 0.04401651f, -0.23818034f, -0.02205103f, 
    -0.02964964f, 0.04560893f, -0.05489793f, -0.07503171f, 0.03199255f, -0.00985480f, -0.07263900f, -0.08639652f, 
    -0.13347097f, -0.17527181f, -0.07270086f, -0.26265693f, -0.06930031f, -0.05627014f, -0.05101762f, -0.04341318f, 
    -0.01526936f, 0.00050706f, 0.04704398f, 0.22247915f, -0.05699722f, -0.11775592f, -0.15530846f, 0.20035863f, 
    0.11237556f, 0.04206092f, 0.01897980f, -0.03043299f, -0.04534686f, 0.01459952f, 0.03601891f, 0.16874504f, 
    -0.09327696f, 0.05814323f, 0.10299326f, -0.20490639f, -0.08464278f, 0.04401248f, 0.11310338f, 0.05949287f, 
    -0.12895176f, -0.01390269f, 0.06608144f, 0.10578080f, -0.40215072f, 0.03902530f, 0.14645708f, 0.03310926f, 
    0.07944013f, 0.00817092f, 0.05931951f, 0.05430548f, 0.03183315f, -0.12983102f, -0.13005421f, -0.11134239f, 
    -0.08534294f, 0.11277243f, -0.03591086f, -0.09448243f, -0.00062285f, 0.07111220f, 0.03595689f, 0.07833721f, 
    -0.06169279f, -0.04307414f, 0.10094626f, -0.08320723f, -0.08776114f, 0.13448964f, 0.08468900f, 0.00692939f, 
    -0.00979583f, -0.09826819f, -0.04016632f, 0.02108323f, -0.05665702f, -0.06914698f, -0.08857296f, -0.02644935f, 
    -0.06662247f, -0.17692171f, 0.04423513f, 0.19618151f, 0.10694624f, 0.02051728f, 0.05238626f, 0.06886698f, 
    -0.22595899f, -0.02084035f, 0.00080230f, 0.00449494f, 0.00137606f, -0.21127479f, -0.02273879f, 0.07886644f, 
    -0.00074656f, 0.09701535f, -0.10501673f, -0.01437682f, 0.01678247f, -0.01999416f, -0.16048881f, 0.06855766f, 
    -0.31385329f, 0.17960919f, -0.03057476f, 0.08980540f, 0.00496940f, 0.01106694f, 0.15110709f, 0.03974307f, 
    -0.05310841f, 0.15815277f, 0.03425058f, 0.12311295f, -0.27936262f, -0.05956713f, -0.14339599f, -0.06166394f, 
    -0.11581141f, 0.03744024f, 0.06648566f, 0.14785658f, 0.05096623f, 0.00276127f, -0.04984614f, 0.09821384f, 
    0.06542283f, 0.15653807f, 0.11714547f, 0.11900819f, -0.05801466f, 0.12765993f, 0.02293334f, 0.04392060f, 
    -0.05074613f, 0.07865465f, 0.06187936f, -0.13550903f, 0.12424628f, 0.04707315f, 0.12943135f, 0.09726656f, 
    -0.05474731f, -0.00015487f, -0.13876544f, -0.06166041f, 0.05745134f, -0.01018638f, -0.04169830f, -0.01659190f, 
    0.05115932f, 0.05702071f, 0.17416185f, 0.08711319f, 0.01353275f, -0.19277216f, 0.09183338f, -0.00374962f, 
    0.07306489f, -0.06952889f, -0.02679189f, -0.20910680f, 0.15699162f, -0.22359331f, -0.19965155f, -0.14119700f, 
    -0.05690334f, 0.10597222f, 0.01826236f, 0.00291826f, -0.09049714f, 0.02848790f, 0.07560626f, -0.03606739f, 
    -0.05259027f, -0.18041289f, 0.24749404f, -0.05031295f, -0.03200832f, 0.00891011f, 0.06207498f, -0.02142144f, 
    0.01602507f, 0.04117904f, 0.11595026f, -0.04326480f, 0.27267304f, -0.16349980f, -0.00222113f, 0.02451122f, 
    0.07313684f, -0.00040195f, 0.06878041f, 0.00839834f, -0.05560886f, 0.04295329f, 0.01375744f, -0.14991370f, 
    -0.26027912f, 0.08310490f, -0.15159672f, -0.19919068f, 0.02412433f, -0.06738111f, -0.00041359f, -0.20171537f, 
    0.03224112f, -0.13949005f, 0.11423074f, 0.13104469f, -0.08979863f, 0.15132189f, 0.18547903f, -0.26186660f, 
    0.08456917f, -0.06461664f, 0.05309665f, 0.07040523f, 0.00480698f, 0.04848073f, -0.14560269f, -0.02117882f, 
    -0.29656565f, -0.16968185f, 0.11788707f, -0.00130329f, 0.04712196f, 0.04677415f, 0.07359271f, -0.01005668f, 
    0.11497691f, -0.03860780f, 0.15015694f, 0.04860938f, 0.01738487f, 0.05100888f, -0.00283907f, -0.35452518f, 
    -0.04784402f, 0.10929473f, 0.03209026f, 0.03349116f, -0.01566769f, -0.17880686f, -0.13581154f, -0.20649660f, 
    0.07493524f, -0.25998059f, -0.03665354f, -0.10090011f, 0.06886652f, -0.04787745f, -0.02760926f, 0.00578150f, 
    -0.17695037f, -0.05768208f, -0.07276130f, 0.11839723f, 0.03868079f, 0.01460622f, -0.06538091f, -0.32975709f, 
    -0.08199852f, 0.03171905f, 0.05758284f, 0.02004204f, -0.00203395f, -0.06321653f, 0.06874945f, -0.02287493f, 
    0.49318889f, 0.07555553f, 0.13267313f, -0.04628923f, -0.07372114f, -0.00668434f, -0.03868265f, -0.02237571f, 
    0.00913603f, 0.02552366f, 0.01912128f, 0.02357046f, -0.08862433f, -0.02734943f, -0.24848877f, -0.01299124f, 
    -0.09586783f, -0.02563358f, -0.00591601f, 0.23605329f, 0.11602610f, -0.01021388f, 0.11311553f, 0.08966295f, 
    -0.01674134f, -0.18056513f, 0.01880987f, -0.32389131f, -0.01717682f, -0.06619127f, -0.03893739f, -0.04929255f, 
    0.01100663f, 0.04365023f, -0.02738894f, 0.13581614f, 0.19431563f, -0.01175935f, 0.03100517f, 0.11047188f, 
    -0.05597942f, -0.10535490f, 0.04349039f, 0.06623777f, 0.07842887f, 0.10525355f, 0.00850956f, -0.20013587f, 
    0.02589178f, 0.13122654f, 0.01351635f, -0.01581607f, -0.00610866f, -0.02309108f, -0.07388715f, 0.03159508f, 
    -0.00368630f, 0.02656482f, 0.12468361f, -0.00915126f, -0.20083654f, -0.01262476f, -0.06223923f, -0.11771430f, 
    -0.04689278f, 0.09974907f, -0.04217410f, 0.01558764f, 0.06031724f, -0.13039672f, -0.05234772f, -0.10028739f, 
    0.02066263f, 0.16592886f, 0.08357923f, -0.18167081f, 0.01054535f, 0.07750151f, 0.12304207f, -0.03505376f, 
    -0.02251931f, 0.11641041f, -0.05534621f, -0.13317820f, 0.31613621f, -0.47310656f, 0.14126749f, -0.03999412f, 
    -0.02901481f, 0.00619800f, -0.08761550f, 0.06387387f, -0.00802034f, -0.00293338f, 0.11907922f, 0.05192969f, 
    0.21433212f, -0.23743290f, 0.17954682f, -0.13252392f, -0.04103373f, 0.06277527f, 0.10620452f, 0.00459372f, 
    -0.20161478f, -0.03980519f, -0.01205003f, -0.09802329f, -0.24902095f, 0.05315022f, 0.08190370f, 0.20963535f, 
    0.11034919f, 0.04173253f, -0.05769728f, 0.00762950f, -0.00191870f, 0.09585031f, -0.07326506f, 0.08727905f, 
    -0.02321408f, 0.14683490f, 0.14846370f, -0.19126929f, 0.07630881f, -0.07139821f, 0.21962376f, 0.09113304f, 
    -0.01231644f, -0.03997172f, -0.10083373f, 0.00441278f, -0.08714527f, 0.00688543f, -0.02611897f, -0.01204176f, 
    -0.13569911f, 0.08751391f, 0.10633147f, 0.12474675f, -0.10295434f, 0.08958339f, 0.08381292f, -0.03094569f, 
    -0.16100304f, 0.04869603f, -0.06443463f, 0.06669647f, -0.00967905f, -0.03224806f, 0.00811476f, -0.01821023f, 
    -0.01526467f, -0.03307443f, -0.02860706f, -0.02891416f, 0.14542350f, -0.11115091f, 0.04672853f, 0.06938910f, 
    0.03317266f, -0.01240879f, -0.05794827f, 0.00369065f, -0.01308432f, 0.04045983f, -0.06986049f, 0.01039635f, 
    -0.09090646f, 0.09651105f, 0.08896298f, 0.12465025f, 0.01171530f, -0.00731333f, -0.09391560f, -0.00752665f, 
    -0.08826625f, -0.01454832f, -0.00211266f, -0.06094489f, 0.16235282f, 0.18800355f, -0.11295303f, 0.18968430f, 
    0.03456058f, 0.01093069f, -0.10608380f, -0.09044691f, -0.04607000f, 0.04726902f, 0.03412022f, -0.04275029f, 
    -0.16883479f, -0.05046606f, -0.08461706f, -0.28791928f, -0.02585633f, -0.06140029f, -0.00860138f, -0.05097197f, 
    -0.07599167f, 0.00041244f, -0.02588162f, -0.03653089f, 0.10621665f, -0.12836030f, 0.04735027f, 0.21926245f, 
    -0.05492802f, -0.11963315f, -0.10682476f, -0.03721088f, -0.03822845f, -0.02003247f, -0.05731350f, -0.06831684f, 
    -0.11695635f, 0.01055351f, -0.10527154f, -0.23740776f, -0.13482726f, 0.07474341f, -0.01907610f, -0.04839851f, 
    -0.01909274f, 0.06122156f, 0.01034712f, -0.01297286f, -0.06953549f, -0.09443452f, -0.05761691f, -0.06289513f, 
    -0.02421512f, -0.02581625f, -0.04463651f, -0.10482199f, 0.00333003f, 0.01083649f, -0.00635238f, -0.07262103f, 
    -0.10720919f, 0.07610103f, 0.00027130f, 0.12169703f, 0.13594347f, -0.06896733f, 0.07358671f, -0.00851225f, 
    -0.04004374f, 0.00136587f, 0.05013981f, -0.04295136f, 0.21584040f, 0.01546303f, 0.13465975f, 0.05428943f, 
    -0.04473404f, 0.02291317f, -0.02428509f, -0.02876240f, -0.00604294f, 0.02650977f, -0.10036534f, 0.02108802f, 
    -0.40284723f, 0.13220808f, -0.07882436f, -0.09972783f, -0.04370366f, -0.02797226f, -0.04216391f, -0.08714913f, 
    -0.01624509f, 0.01056676f, -0.03537639f, -0.09203448f, -0.19788939f, 0.14477952f, -0.07302856f, -0.08052476f, 
    0.02238826f, 0.00922927f, -0.05646182f, -0.07879750f, -0.12158151f, -0.01168853f, 0.01021439f, -0.03880292f, 
    -0.01171498f, 0.21301645f, 0.09426714f, 0.11302343f, 0.03568991f, 0.03361051f, -0.00852257f, -0.00932957f, 
    0.11949062f, 0.03031885f, 0.05737045f, -0.06684263f, 0.00287186f, 0.18649246f, 0.01944791f, 0.11025303f, 
    -0.03112548f, -0.02370656f, -0.01239417f, -0.00928561f, 0.01778536f, 0.01594488f, -0.05878036f, -0.02843250f, 
    -0.11624544f, 0.00262848f, -0.07791914f, 0.05295573f, -0.24104512f, 0.09198739f, -0.09069116f, 0.07253785f, 
    -0.01266808f, -0.04552840f, -0.00426498f, -0.05739801f, -0.24292074f, 0.12879334f, -0.08126115f, -0.14503255f, 
    0.00352891f, -0.00501074f, -0.02523955f, -0.00440385f, -0.01849190f, 0.00966197f, 0.02832223f, -0.06600396f, 
    -0.07956339f, 0.08908050f, 0.05283483f, 0.17733149f, 0.04469067f, -0.00761351f, 0.01554323f, -0.06954361f, 
    0.02885946f, 0.04298395f, -0.02389672f, -0.01345563f, 0.20252049f, 0.12273210f, 0.18164350f, 0.07468218f, 
    0.03129185f, 0.03179015f, -0.02930764f, -0.04465855f, -0.00548428f, -0.00554638f, -0.11421549f, -0.03889020f, 
    0.22773498f, 0.00821094f, 0.08855161f, -0.12695770f, -0.06986213f, -0.05933327f, 0.00000303f, -0.04261542f, 
    -0.04556642f, 0.00468915f, -0.07794271f, -0.06098009f, -0.03973977f, -0.01851307f, -0.02128367f, -0.01815943f, 
    -0.00566378f, 0.03589289f, -0.03914622f, 0.05823609f, 0.03912513f, 0.00253193f, -0.04410809f, -0.03476383f, 
    -0.17819118f, -0.05844536f, -0.04476712f, 0.02828371f, -0.07222592f, 0.02477700f, 0.02708086f, 0.00935750f, 
    -0.01177634f, -0.04018575f, -0.01707940f, -0.00301128f, 0.06005750f, 0.22524744f, 0.04532379f, 0.13572720f, 
    0.07398326f, 0.05208092f, 0.06069707f, -0.02827380f, -0.02576884f, -0.04061104f, 0.04321282f, -0.07333313f, 
    -0.10927106f, 0.04374965f, -0.03483190f, -0.03399480f, -0.10906141f, 0.00083175f, -0.02688287f, -0.08930743f, 
    -0.00910503f, 0.00418109f, -0.02683041f, -0.04598378f, -0.01156409f, 0.08918774f, 0.05497484f, 0.01335685f, 
    -0.00301248f, -0.00628069f, 0.03488501f, -0.01925869f, 0.06177701f, 0.07776152f, 0.03282529f, -0.07475177f, 
    0.05426097f, -0.08141677f, -0.04765255f, -0.05137179f, -0.05522864f, -0.07493157f, -0.02130387f, -0.08981434f, 
    -0.03495606f, -0.04906419f, 0.03510729f, -0.10102646f, 0.03038410f, 0.08350116f, 0.12813057f, 0.09838893f, 
    0.07672553f, -0.05650088f, -0.03891790f, -0.03260461f, -0.01326407f, -0.00767794f, -0.06145804f, -0.07686065f, 
    -0.24867946f, -0.06456786f, -0.29385388f, -0.07314168f, 0.09007090f, 0.02744708f, -0.06639297f, -0.04933510f, 
    -0.08223215f, 0.04817401f, 0.06877707f, -0.05679526f, 0.03458418f, -0.20075828f, -0.05143064f, -0.03256869f, 
    0.04159720f, 0.01621340f, -0.03409895f, 0.04326379f, -0.02673180f, 0.06895743f, 0.03299350f, -0.02727512f, 
    -0.06295050f, 0.17261642f, 0.04564266f, 0.13404934f, 0.09924199f, -0.01032248f, 0.10262384f, -0.03913856f, 
    -0.01424067f, -0.05257496f, 0.06584093f, -0.05864882f, -0.23907609f, 0.05972103f, 0.00513573f, -0.10173493f, 
    -0.02240230f, -0.06275969f, -0.08629189f, -0.03316160f, 0.04760522f, 0.00384735f, -0.03253842f, -0.02556931f, 
    0.04092645f, 0.16488053f, 0.09689218f, 0.10292837f, 0.08382288f, 0.09828706f, 0.05263662f, 0.01367251f, 
    -0.06153000f, 0.04066061f, 0.03072971f, 0.03957349f, -0.08984639f, 0.03330300f, -0.10202430f, 0.20927611f, 
    -0.13705069f, -0.06385496f, -0.08136042f, -0.02803075f, -0.16543622f, 0.05182293f, -0.00324665f, 0.00272882f, 
    0.01184868f, 0.02752035f, -0.09890921f, -0.19532534f, -0.02113687f, 0.01122498f, -0.07760879f, -0.06528636f, 
    -0.08445598f, 0.02738034f, -0.05539970f, 0.04648485f, -0.03187362f, 0.01285314f, -0.09450425f, -0.07236744f, 
    -0.05881718f, -0.01291449f, -0.01861992f, -0.09461468f, 0.08150128f, 0.00844655f, -0.03526963f, -0.02429568f, 
    0.10438204f, -0.02375726f, 0.07541381f, 0.15198325f, 0.01679313f, -0.04642362f, -0.02197263f, 0.02743506f, 
    -0.04544982f, -0.06115683f, -0.10789108f, -0.06201430f, -0.12084207f, -0.05555505f, -0.09922080f, -0.03006973f, 
    -0.11257911f, 0.01649390f, -0.02003116f, -0.04005166f, 0.05548452f, 0.04046870f, 0.00981394f, -0.02535860f, 
    -0.25290242f, 0.12725475f, -0.02398621f, 0.10880895f, 0.07654348f, -0.11628734f, 0.01426870f, -0.03860190f, 
    0.08464294f, 0.01724557f, -0.01009639f, 0.07274610f, 0.15838830f, -0.23194179f, 0.15227048f, 0.17191318f, 
    0.01595900f, 0.00266305f, -0.03226603f, -0.04546452f, -0.05092658f, -0.03602136f, -0.08857364f, -0.00374794f, 
    0.05697906f, 0.06495120f, -0.07071980f, -0.09382453f, -0.01062298f, -0.10129181f, -0.03434760f, -0.03151419f, 
    -0.04643750f, 0.06552908f, 0.02673212f, -0.03152126f, 0.15695743f, 0.03793142f, -0.06896766f, -0.04793492f, 
    -0.04082084f, 0.05213943f, -0.05098870f, -0.02787036f, 0.03336853f, 0.01221764f, 0.04966955f, 0.03923631f, 
    0.00729356f, 0.05385561f, -0.00071058f, 0.07203540f, -0.00995961f, -0.06402284f, -0.08690998f, 0.00446539f, 
    -0.03504416f, 0.02598562f, 0.01863080f, -0.11807470f, -0.17509285f, 0.17344989f, 0.23325203f, 0.07521074f, 
    0.06525045f, 0.09156594f, 0.02659128f, 0.02631519f, -0.10720181f, 0.02766875f, 0.05655197f, -0.03908395f, 
    0.07153586f, -0.18148488f, 0.01767312f, -0.06468014f, 0.04186098f, 0.01759231f, -0.01949540f, -0.01843210f, 
    0.05980701f, -0.00348513f, -0.07579154f, -0.01210719f, -0.09599155f, 0.22410503f, 0.13470571f, 0.07068833f, 
    0.05989590f, 0.09249632f, 0.08482146f, 0.04072272f, -0.02125672f, 0.04877977f, 0.10045480f, -0.01628364f, 
    -0.03207600f, 0.07052884f, 0.04582712f, -0.04579486f, -0.20296234f, 0.06454557f, -0.01352746f, 0.02538253f, 
    -0.05194963f, -0.02052304f, -0.07410474f, -0.02941249f, 0.09291755f, -0.01924478f, 0.07012656f, 0.03488693f, 
    0.04359296f, 0.00771349f, -0.01741513f, -0.02770231f, -0.13430713f, -0.00866602f, -0.03807520f, -0.00254389f, 
    0.20009306f, 0.10771761f, 0.18980488f, -0.00076133f, 0.01317392f, 0.08637141f, -0.00651170f, -0.04645398f, 
    0.03610341f, 0.04047795f, -0.07395829f, -0.01463857f, -0.04030233f, -0.24297875f, -0.00053283f, 0.09647741f, 
    -0.02374851f, -0.09970709f, -0.01752193f, -0.06372903f, -0.01515361f, 0.02247779f, 0.01182742f, -0.02946922f, 
    0.26186430f, 0.02521649f, 0.08034042f, -0.20875876f, -0.16288891f, -0.09706814f, 0.02303086f, -0.15698908f, 
    -0.00592953f, 0.03934916f, -0.02088207f, -0.07531063f, -0.16041283f, 0.20579115f, -0.08528303f, -0.11269495f, 
    0.01861475f, -0.01213194f, -0.00833253f, -0.08707360f, -0.03697020f, -0.00715083f, 0.06271348f, 0.02471364f, 
    0.12661026f, 0.02344642f, 0.12982552f, 0.08636238f, 0.06039457f, 0.09332404f, -0.03813652f, -0.08980133f, 
    -0.05458952f, -0.05048519f, -0.00905399f, -0.02440253f, -0.20200248f, 0.03030189f, -0.23268898f, 0.04174870f, 
    -0.07661381f, -0.09822852f, -0.05884520f, -0.08196728f, -0.04507731f, -0.03426061f, -0.02118932f, 0.05516390f, 
    0.29597536f, -0.14882733f, -0.20982201f, -0.12448869f, -0.05247054f, -0.04086477f, -0.07516471f, -0.03582855f, 
    -0.02225915f, -0.01776714f, -0.02526547f, 0.03448075f, -0.05894590f, 0.09475921f, 0.01269487f, 0.17316791f, 
    0.04031991f, 0.03422076f, 0.06038941f, 0.06308860f, -0.00383873f, -0.05212418f, 0.07981865f, -0.00595075f, 
    -0.10113568f, 0.05204982f, 0.13564520f, 0.05497686f, 0.00071940f, 0.09141503f, -0.02551038f, -0.03577940f, 
    -0.06462777f, 0.11480737f, 0.01527946f, -0.05436730f, -0.10571928f, -0.07059554f, -0.18401529f, -0.04421870f, 
    -0.07074887f, -0.01402099f, -0.01367247f, -0.02419700f, -0.05140535f, -0.03252230f, -0.09007808f, -0.04902877f, 
    -0.04325948f, 0.04695588f, -0.09908401f, -0.16984673f, 0.02423702f, 0.00235945f, -0.03666724f, -0.03405977f, 
    -0.04577362f, 0.01291914f, 0.00852062f, -0.00729992f, 0.05271420f, -0.07026561f, 0.16164394f, -0.01844233f, 
    0.08151452f, -0.07547773f, -0.02906322f, -0.00816695f, 0.02045180f, 0.02118084f, -0.01750679f, -0.05904489f, 
    -0.10218965f, -0.15352023f, -0.08235376f, -0.09941452f, -0.06372943f, -0.05402342f, 0.00393016f, -0.02953603f, 
    0.00964873f, 0.04555863f, 0.06919724f, 0.03085920f, 0.04730709f, 0.04849256f, 0.08842555f, -0.02698658f, 
    0.05036700f, -0.04488363f, -0.03434588f, -0.01958566f, -0.02430144f, 0.03281662f, -0.00484612f, 0.06138431f, 
    0.20689273f, -0.06531245f, 0.15008022f, 0.07087954f, 0.08220714f, 0.00062987f, 0.02395590f, -0.02302676f, 
    0.04925599f, -0.01530705f, 0.02104190f, -0.09850957f, 0.13009356f, -0.12736043f, -0.09603612f, -0.07919555f, 
    -0.02334339f, 0.06205712f, -0.02575177f, -0.02910161f, -0.02386162f, -0.05664213f, -0.00977191f, 0.04790377f, 
    0.23734716f, 0.06989748f, -0.02369181f, -0.02738263f, 0.00412654f, -0.04039764f, -0.01634056f, -0.07296014f, 
    -0.03797743f, 0.01625777f, 0.01892607f, -0.09722841f, -0.13822186f, 0.04728486f, -0.10799158f, -0.05406124f, 
    -0.02266056f, -0.02182269f, -0.03097044f, -0.10268202f, 0.01261404f, -0.01146411f, -0.08100110f, -0.01962967f, 
    0.11249346f, 0.29294175f, -0.27377501f, 0.00321476f, 0.04193212f, -0.04456178f, -0.19031319f, 0.04230365f, 
    -0.03115460f, 0.01853080f, 0.03854102f, 0.10388244f, 0.00156476f, -0.19501458f, 0.14689526f, -0.07413811f, 
    0.01142778f, -0.07791989f, 0.05376765f, -0.05528432f, -0.17106339f, 0.03143690f, 0.08780072f, -0.02957987f, 
    -0.13002488f, 0.06745305f, -0.20133153f, -0.13930450f, 0.07934243f, -0.01548838f, -0.18341866f, -0.04631970f, 
    0.00803430f, -0.01161744f, 0.01536024f, -0.12302683f, -0.27404562f, 0.12451352f, -0.15585032f, -0.16367835f, 
    0.04536186f, -0.09605656f, -0.12964289f, 0.02097307f, 0.10570619f, -0.01358332f, 0.02993954f, -0.05013176f, 
    0.06324280f, -0.02143570f, -0.15715712f, -0.06740453f, 0.00044284f, -0.00326655f, -0.09874543f, -0.03548468f, 
    0.00846651f, -0.00076099f, -0.03791131f, -0.05692853f, 0.05114032f, 0.05553405f, -0.23084959f, -0.21880515f, 
    0.01464761f, -0.09453095f, 0.02770217f, -0.06384690f, 0.04726246f, 0.02893055f, 0.03462680f, -0.00157467f, 
    0.08831296f, -0.02414232f, -0.03802166f, 0.02226819f, 0.06699596f, 0.07032903f, 0.00534946f, 0.03427166f, 
    0.03022589f, -0.07924631f, 0.04271457f, 0.06908792f, 0.13209452f, 0.04113460f, 0.04040621f, 0.12469330f, 
    -0.05373818f, -0.00803787f, -0.03945096f, -0.03244980f, 0.03268785f, -0.02561381f, -0.01215252f, -0.04359463f, 
    -0.02389365f, -0.08827236f, -0.00959475f, -0.09031408f, 0.03302170f, -0.00032945f, -0.03298956f, 0.02230533f, 
    0.09437814f, 0.03647158f, 0.08298773f, 0.05342288f, -0.23522606f, -0.14375702f, 0.08502806f, -0.18568495f, 
    0.13558047f, -0.13139427f, 0.01726173f, 0.02876545f, 0.00390147f, -0.02976397f, 0.02548135f, 0.01993243f, 
    -0.00907338f, 0.01990876f, 0.05841961f, 0.22895078f, 0.07081373f, 0.06332850f, -0.00888437f, -0.04670488f, 
    -0.01239000f, 0.06152752f, 0.02086731f, 0.09339722f, -0.04079450f, -0.10973854f, 0.01721565f, 0.17928596f, 
    0.05293678f, 0.01270878f, -0.03155726f, 0.03511055f, 0.04864860f, -0.05477339f, 0.12081625f, -0.12638533f, 
    -0.02110180f, 0.14914732f, -0.03334257f, 0.16786312f, -0.02278677f, 0.01157795f, 0.01787068f, -0.02719411f, 
    -0.00577225f, -0.01600414f, 0.00367415f, 0.00699584f, 0.07504899f, 0.16823906f, 0.08942977f, -0.14245774f, 
    -0.06677092f, -0.04296827f, 0.01770122f, -0.07756369f, -0.02108232f, 0.01071954f, 0.09762885f, 0.03240751f, 
    0.08053049f, 0.20029575f, -0.06043687f, 0.05067075f, -0.00919061f, 0.02447451f, -0.06560456f, -0.05279500f, 
    0.09756407f, -0.11035218f, 0.03984730f, 0.01022822f, 0.03188315f, -0.10438521f, -0.00629947f, 0.01954342f, 
    0.07881523f, 0.06564084f, 0.00777862f, 0.00180468f, 0.06072763f, 0.04418633f, 0.01965923f, 0.04711907f, 
    -0.09712293f, 0.23748136f, -0.11168049f, 0.03679001f, 0.08259697f, 0.05812706f, -0.07004856f, -0.07429939f, 
    -0.03090886f, 0.07746383f, -0.03475151f, -0.02807597f, -0.15581723f, 0.13025835f, -0.00128201f, -0.15220971f, 
    0.05237985f, 0.02637886f, 0.01481593f, -0.06423325f, 0.06661901f, -0.01577124f, 0.07259315f, 0.10066165f, 
    -0.13574769f, 0.04983958f, -0.19964352f, -0.09481169f, 0.02485873f, -0.03444998f, -0.03001750f, -0.02083912f, 
    0.03822369f, -0.08143203f, 0.08673488f, 0.05921699f, 0.10871375f, 0.11128113f, -0.03650274f, 0.07686005f, 
    -0.00788264f, 0.02266851f, 0.04201044f, -0.05875080f, 0.03794394f, -0.06753991f, -0.03243748f, 0.14192310f, 
    0.10776979f, 0.01461459f, -0.07277612f, 0.09801808f, 0.00381399f, 0.00408565f, 0.04770739f, -0.09417846f, 
    -0.08267909f, -0.13596414f, 0.10378790f, 0.16634294f, 0.07114033f, 0.10445668f, -0.12947242f, -0.07078407f, 
    0.01640749f, 0.04914001f, -0.07895619f, 0.04216803f, 0.00740293f, -0.09699154f, 0.02592411f, 0.02286616f, 
    0.16082764f, 0.00566785f, -0.04126935f, 0.10649772f, 0.02871778f, 0.00423337f, -0.03724179f, -0.10069889f, 
    -0.04435220f, -0.08795398f, -0.11361784f, -0.02984023f, -0.01009280f, 0.17370276f, -0.00535366f, 0.11439973f, 
    -0.05047449f, -0.00501964f, -0.13817352f, -0.01507995f, -0.05870357f, -0.08134354f, 0.00536620f, 0.09032176f, 
    0.03083852f, -0.12026150f, 0.05071742f, -0.18184537f, 0.06210923f, -0.14324321f, -0.04866530f, 0.11383431f, 
    0.05463741f, 0.03141935f, 0.02044357f, 0.01712905f, -0.17915201f, -0.11096640f, 0.09550975f, -0.16043268f, 
    0.00036149f, -0.04720112f, -0.07593178f, -0.00319904f, -0.00837366f, -0.10939410f, 0.02543608f, 0.00908314f, 
    0.00583800f, 0.16665779f, -0.29407701f, -0.10701140f, 0.03914995f, 0.05365471f, -0.17055203f, -0.07270333f, 
    0.14268999f, 0.02374776f, -0.01474692f, 0.16948254f, 0.00207251f, -0.06113922f, 0.10939796f, 0.02664473f, 
    -0.05960390f, -0.07822288f, 0.10302895f, -0.07339951f, 0.02495703f, -0.05284787f, -0.00209610f, 0.04987282f, 
    0.02879869f, -0.03369587f, -0.01256103f, 0.06245290f, -0.07390833f, -0.06692500f, 0.02479964f, -0.01360347f, 
    0.07857399f, -0.12014434f, -0.03378624f, 0.02409974f, -0.08511595f, -0.01225433f, -0.22422414f, -0.12331610f, 
    -0.00333485f, 0.04082199f, -0.02081520f, 0.04178422f, 0.00551629f, 0.02892347f, 0.01081881f, 0.08132195f, 
    -0.24763066f, 0.01526541f, 0.14720778f, 0.05052654f, -0.09933558f, 0.04421260f, -0.03675378f, -0.05422683f, 
    -0.00312780f, -0.07902569f, -0.11747205f, 0.00673421f, -0.07908565f, -0.02158240f, -0.30345646f, -0.14312272f, 
    0.00733039f, 0.01674774f, -0.02269228f, -0.01285569f, 0.10965268f, -0.03470140f, 0.07988746f, -0.10481773f, 
    0.13664974f, -0.03194712f, 0.09447712f, 0.08526285f, 0.01915175f, -0.01936632f, 0.00501183f, 0.01631802f, 
    0.03894548f, -0.05382939f, 0.02980116f, -0.07017034f, -0.01819873f, -0.00477983f, 0.03276519f, 0.12676096f, 
    -0.05544059f, 0.06589991f, 0.00848494f, -0.05586392f, -0.07635814f, -0.05008665f, -0.05580649f, -0.04631008f, 
    0.08828589f, 0.06219333f, -0.01256386f, -0.03047184f, 0.02303670f, -0.08403789f, -0.14051971f, -0.04058945f, 
    -0.01769675f, 0.03662280f, 0.02082617f, -0.12980598f, 0.19850449f, 0.05614283f, -0.11827391f, 0.09970918f, 
    0.03173803f, 0.03188534f, -0.02362949f, -0.07463069f, -0.06115697f, -0.01530962f, 0.06558546f, -0.00587124f, 
    0.03031556f, 0.17505710f, -0.09672587f, 0.02438452f, 0.08770218f, -0.12569398f, -0.15145396f, 0.03761393f, 
    -0.00243695f, 0.00230198f, 0.03870823f, -0.06638645f, -0.06027941f, -0.00125611f, -0.14563097f, -0.01958224f, 
    0.00832429f, -0.02061840f, -0.00219871f, -0.07130800f, 0.06473477f, 0.00942265f, -0.03917435f, -0.05808939f, 
    0.08191086f, 0.00322352f, -0.10384552f, -0.01953075f, 0.08079971f, -0.01869335f, -0.07668222f, -0.01998977f, 
    -0.07555924f, -0.05386582f, -0.12761779f, -0.13330427f, 0.18327500f, 0.19287126f, -0.08698157f, -0.04191162f, 
    -0.09622091f, -0.12117042f, 0.04154416f, -0.10639362f, -0.07734805f, 0.06638505f, 0.02026206f, -0.02767161f, 
    -0.12052708f, -0.12969457f, 0.00173344f, -0.24775091f, 0.01169750f, -0.10571677f, -0.11361333f, 0.06893788f, 
    0.02729656f, -0.08787942f, 0.01430206f, 0.05398467f, -0.11225324f, -0.22325544f, 0.16656242f, -0.17024976f, 
    -0.02586913f, -0.04596407f, -0.09547095f, -0.12108129f, 0.03858299f, 0.03691996f, -0.03921213f, 0.06300905f, 
    0.18949975f, -0.07126387f, -0.00161560f, 0.06195557f, 0.02572535f, 0.01418398f, -0.11440574f, -0.04067076f, 
    -0.05017077f, 0.10056336f, 0.08880174f, -0.04728016f, -0.06074157f, -0.02738349f, 0.12021665f, 0.03461396f, 
    -0.18615559f, 0.01411016f, -0.05825362f, -0.03792633f, -0.02667194f, 0.02672626f, 0.03709041f, -0.09458220f, 
    0.10245748f, 0.03069571f, 0.13000239f, 0.05930932f, 0.01336737f, -0.04817392f, 0.03103167f, 0.01330217f, 
    0.05175349f, -0.08026513f, 0.00037884f, -0.07589026f, 0.16762227f, -0.02759534f, -0.10871738f, -0.06723279f, 
    0.00388757f, -0.01154608f, -0.03506089f, 0.05976875f, 0.06094692f, 0.02709995f, -0.17805363f, 0.02311177f, 
    -0.00823816f, 0.02741732f, 0.13601571f, -0.01731633f, 0.04437800f, -0.01504915f, -0.01578352f, 0.08588671f, 
    -0.08238141f, 0.00582907f, 0.07536149f, 0.05153564f, -0.09970381f, -0.12696598f, -0.10919741f, 0.22855945f, 
    0.12384786f, 0.05365865f, -0.07010468f, -0.06077940f, 0.00992358f, 0.09052627f, 0.15644890f, 0.07922983f, 
    0.03871909f, 0.14483839f, -0.10204209f, -0.15278706f, -0.00826518f, -0.00882626f, 0.03661655f, 0.03822573f, 
    -0.01608079f, 0.06722707f, -0.03392796f, -0.05607717f, -0.02119221f, -0.00801172f, 0.08437939f, 0.26369292f, 
    0.03292292f, -0.09085912f, -0.01884353f, 0.05720063f, 0.02711897f, 0.02985770f, 0.03053572f, -0.09066083f, 
    -0.08262102f, -0.27284816f, 0.04402572f, -0.08491351f, -0.04995797f, -0.09064147f, -0.00983609f, -0.03720808f, 
    0.02654459f, 0.04590061f, 0.02611846f, -0.00542700f, -0.20478256f, -0.00028255f, -0.02509660f, 0.10050305f, 
    -0.03222424f, 0.08494157f, 0.01025091f, -0.03270832f, 0.07318578f, 0.15285811f, -0.06066943f, -0.01672168f, 
    -0.11206841f, -0.10110343f, -0.13199170f, -0.12669128f, 0.01615927f, -0.00339301f, -0.03357968f, 0.02273373f, 
    0.06229607f, 0.06761239f, -0.01460159f, 0.08843540f, -0.15231194f, 0.00252939f, -0.06552445f, -0.06227793f, 
    -0.00459440f, -0.06661811f, -0.06033118f, -0.09798699f, 0.00062149f, 0.04627806f, -0.13861242f, 0.10086646f, 
    0.01508738f, -0.12465558f, 0.16936052f, 0.10292207f, -0.13482051f, 0.11213433f, 0.07389439f, -0.05493192f, 
    -0.07820336f, -0.04057401f, 0.04793939f, -0.08747600f, 0.06463099f, -0.08564159f, 0.04356232f, 0.01928176f, 
    0.02183997f, 0.10009265f, -0.05784468f, -0.10616852f, -0.01439744f, 0.01607784f, 0.00075966f, 0.04321063f, 
    0.04469803f, -0.12162022f, 0.07766011f, -0.04684295f, 0.07166876f, -0.01158072f, -0.03408022f, 0.08173474f, 
    0.02088980f, -0.00724888f, -0.10097872f, -0.10243763f, -0.32247317f, -0.06410904f, 0.02595167f, -0.15776804f, 
    -0.10319850f, -0.04009533f, 0.00820782f, -0.08575482f, 0.00524757f, -0.02743906f, 0.05450711f, 0.07005613f, 
    -0.06110957f, -0.18417300f, 0.01342502f, 0.09531203f, 0.04116617f, -0.00302128f, -0.03641859f, -0.11497326f, 
    0.04333337f, -0.00883751f, -0.01720907f, 0.08936884f, 0.13040516f, -0.17455557f, 0.07226899f, 0.01231423f, 
    -0.06525884f, -0.13611592f, -0.03800002f, 0.07902557f, -0.01880263f, -0.00966654f, -0.07169136f, -0.08780627f, 
    -0.04935593f, -0.22366482f, 0.00455985f, -0.25278205f, 0.07648692f, -0.06162250f, -0.04392402f, 0.01209674f, 
    -0.02377985f, 0.09600683f, -0.01936929f, 0.07007359f, 0.26985848f, 0.05075042f, -0.33709294f, 0.00650870f, 
    0.05997242f, -0.04842639f, 0.08190320f, -0.04449881f, -0.06450368f, -0.08210293f, 0.05069821f, 0.02864254f, 
    0.03876430f, -0.17067280f, 0.06400349f, -0.04502048f, 0.07395263f, -0.20292266f, -0.11988322f, 0.02694026f, 
    0.02976534f, 0.03617044f, 0.09270146f, -0.02745706f, 0.03035526f, -0.15681566f, 0.06929184f, 0.03223595f, 
    -0.09859182f, 0.00136080f, -0.03161554f, 0.00158525f, 0.09523088f, -0.12456243f, 0.08609921f, -0.04433400f, 
    0.00907068f, 0.13124597f, 0.23316732f, 0.00940066f, 0.03824147f, 0.03343118f, 0.04954490f, -0.07557409f, 
    -0.10612182f, 0.14714880f, -0.03412551f, -0.08105046f, 0.46666762f, 0.13773610f, -0.19690387f, 0.20445888f, 
    0.01314728f, -0.10766249f, -0.11309727f, 0.10831453f, 0.00383232f, 0.07902181f, -0.09584181f, 0.02689928f, 
    -0.20250288f, -0.12919965f, -0.00273981f, -0.09823649f, -0.03486498f, 0.09064721f, -0.07922212f, 0.08250622f, 
    -0.05801381f, -0.02096999f, 0.06301178f, 0.01630846f, -0.19024044f, 0.09880365f, 0.18621504f, -0.03518524f, 
    0.00738767f, 0.00100704f, -0.07205948f, 0.09512534f, -0.03833161f, 0.04309674f, 0.04087114f, 0.05954529f, 
    0.03313093f, 0.05708275f, -0.01227534f, -0.11831142f, 0.01769290f, -0.01537866f, 0.09049998f, -0.17261210f, 
    0.01461151f, -0.02125120f, 0.07648108f, 0.00802505f, 0.05594169f, -0.08074878f, 0.04323732f, -0.29530415f, 
    0.02834212f, 0.01561003f, -0.05004684f, -0.01295642f, -0.02783548f, 0.02143887f, -0.07383532f, -0.07863121f, 
    -0.01028681f, 0.06226766f, 0.05740672f, 0.05918700f, 0.11246724f, 0.06819931f, 0.19524942f, -0.15158415f, 
    -0.00376317f, -0.03539617f, -0.05358054f, 0.03448835f, 0.11087034f, 0.10941608f, -0.19020239f, -0.00231060f, 
    0.13396814f, -0.01226029f, 0.01053856f, -0.14370555f, -0.06509072f, 0.02796605f, 0.02684758f, 0.02494880f, 
    -0.07833462f, -0.30593613f, 0.23604158f, 0.04864380f, 0.01801112f, -0.05498677f, 0.15181504f, 0.05552398f, 
    0.02996688f, -0.08254915f, 0.02139753f, 0.06895161f, 0.19896725f, -0.03717221f, -0.02557603f, 0.10146135f, 
    -0.10138136f, -0.00319898f, -0.00009637f, 0.00198700f, 0.01182194f, 0.07857966f, 0.02882498f, -0.06167846f, 
    -0.46935126f, 0.38407272f, -0.46299896f, -0.32876045f, 0.15973257f, -0.09321979f, 0.02023576f, 0.04808980f, 
    -0.10118974f, -0.11643511f, -0.05506498f, -0.17163236f, -0.42405817f, 0.15054788f, -0.20899580f, -0.13370186f, 
    -0.02106097f, -0.05871785f, 0.01662697f, -0.09395325f, -0.08780161f, -0.05263589f, -0.06429988f, 0.01983024f, 
    -0.22547123f, -0.05673346f, 0.06369165f, 0.08414525f, 0.02842054f, 0.02142210f, -0.06583545f, 0.09228002f, 
    0.00336328f, -0.12622492f, -0.00595294f, -0.07463546f, -0.07865840f, -0.11185287f, 0.02362768f, 0.08174259f, 
    0.09981453f, 0.00062531f, -0.12477268f, -0.07668858f, 0.08812122f, 0.01284660f, -0.04921916f, -0.09668965f, 
    -0.13837707f, 0.31461203f, -0.16633089f, 0.23621677f, -0.05664782f, 0.06007002f, -0.04438191f, 0.04865944f, 
    0.08862474f, -0.02588609f, 0.05428144f, 0.01084849f, 0.11122993f, 0.10138581f, 0.05562565f, -0.19037221f, 
    0.08357172f, 0.06316422f, -0.11117091f, -0.12413861f, -0.09088320f, -0.14248018f, 0.06194210f, -0.13621841f, 
    0.11190934f, 0.04885245f, -0.01218511f, 0.08389739f, -0.07259060f, -0.01236671f, -0.07098281f, 0.12456227f, 
    -0.08600513f, 0.12980758f, 0.10686931f, -0.00842163f, -0.24046089f, -0.19057330f, -0.15454915f, -0.16275336f, 
    0.09339125f, 0.07107764f, 0.02223054f, -0.13322139f, -0.18192732f, -0.01441277f, -0.15573245f, -0.07781726f, 
    -0.28006062f, 0.01101934f, -0.10435718f, 0.04361734f, -0.02846583f, -0.11564536f, 0.01486846f, -0.02836650f, 
    -0.03227882f, 0.14063554f, 0.05986711f, 0.06614079f, 0.19455251f, 0.04513644f, 0.00434924f, 0.10825393f, 
    0.07872421f, -0.06736593f, 0.04811992f, 0.03250862f, 0.05952403f, -0.00341280f, 0.01678683f, -0.06221946f, 
    -0.04888312f, 0.33921298f, -0.10599282f, -0.33083886f, 0.19801910f, -0.05773370f, -0.04765459f, 0.05413655f, 
    0.02524222f, 0.06695597f, 0.04913202f, -0.03567847f, -0.10926293f, -0.25004923f, 0.20058227f, -0.10478369f, 
    0.09107310f, 0.08707388f, 0.02091939f, 0.02652359f, -0.04817473f, 0.04688282f, -0.07592256f, 0.12375468f, 
    -0.15452704f, 0.04629987f, -0.07486677f, 0.01375786f, 0.00790065f, 0.02209804f, 0.11231688f, -0.09784891f, 
    0.07671029f, 0.06392033f, 0.01393076f, -0.01731609f, 0.00154679f, -0.21616204f, 0.15027373f, -0.14053690f, 
    -0.07556495f, 0.07710432f, 0.07457877f, 0.17815398f, 0.05388854f, 0.09513175f, -0.04196092f, -0.01287059f, 
    0.10328441f, 0.14481646f, 0.05733120f, -0.03319110f, -0.12464914f, -0.08587062f, 0.00298748f, 0.01993947f, 
    0.03746803f, 0.06460272f, 0.00359731f, -0.24172033f, -0.09888654f, -0.25714743f, 0.04492455f, 0.11339775f, 
    -0.06443673f, -0.00353915f, 0.07568424f, -0.05968364f, -0.09849272f, 0.07616486f, -0.08638293f, 0.02189747f, 
    0.45365864f, 0.12750441f, 0.23506911f, 0.03855542f, -0.04363228f, 0.15323724f, 0.09797308f, -0.06651185f, 
    -0.17390472f, -0.01503731f, -0.09116763f, -0.08726076f, 0.37701902f, 0.11200574f, -0.19109629f, -0.07436584f, 
    -0.00214305f, 0.00427546f, -0.07193699f, 0.08644000f, -0.11228760f, -0.07284471f, 0.00858893f, -0.01468650f, 
    -0.42663789f, -0.26094180f, 0.02967954f, -0.08605043f, 0.06393411f, 0.03346204f, 0.04879961f, 0.04431548f, 
    0.00869202f, -0.01772581f, 0.08193754f, 0.06312697f, -0.26387048f, 0.10720763f, 0.05827872f, -0.08320326f, 
    -0.07481782f, -0.01733303f, 0.01452781f, -0.11612272f, -0.01480732f, 0.05631545f, 0.10803175f, -0.06153327f, 
    -0.21773659f, -0.09427912f, -0.04963096f, 0.17816956f, 0.09472874f, -0.03887416f, -0.02841999f, 0.07998230f, 
    -0.01812178f, 0.00156334f, 0.09357982f, -0.01554044f, -0.11168013f, 0.08209819f, 0.08066526f, -0.19446845f, 
    0.00521543f, 0.02007158f, -0.07013392f, -0.10518003f, -0.10630578f, -0.07820094f, 0.06412482f, -0.02706404f, 
    -0.00729373f, 0.15903723f, -0.14303112f, -0.09744642f, 0.12818941f, -0.04288414f, 0.01838587f, -0.17370337f, 
    -0.06424836f, 0.00458653f, 0.07449207f, -0.02380085f, 0.10650844f, -0.02870490f, 0.05835687f, -0.07635546f, 
    -0.07535105f, -0.00660073f, 0.01191067f, 0.09527409f, 0.05067310f, -0.04253469f, 0.11485623f, -0.02734929f, 
    0.26438355f, -0.24258329f, 0.04852943f, -0.16824380f, -0.12383878f, 0.05979534f, 0.13472211f, 0.06973052f, 
    0.05001765f, -0.03446849f, -0.07069335f, 0.04695234f, -0.05856071f, -0.03067412f, -0.02105333f, 0.10561153f, 
    0.07299288f, 0.08028588f, 0.00971434f, 0.08721158f, 0.03629713f, -0.00898485f, -0.05559033f, 0.00128419f, 
    -0.10891254f, -0.15716599f, 0.24157882f, -0.01215863f, -0.00686609f, 0.01275502f, 0.02640557f, -0.02681590f, 
    -0.04165316f, -0.13097702f, 0.07242882f, -0.01735426f, 0.35502926f, -0.39479616f, -0.08694308f, -0.12408645f, 
    -0.04824125f, 0.01541653f, -0.03711694f, 0.11252285f, -0.06068703f, -0.12757502f, -0.01280593f, -0.14161047f, 
    -0.10881852f, 0.16717048f, 0.22633310f, -0.06763011f, 0.00812266f, -0.03555511f, -0.09246743f, -0.11541685f, 
    0.15936886f, 0.11122295f, 0.07445176f, 0.00532895f, 0.06025367f, 0.38552547f, -0.11067808f, 0.06190377f, 
    -0.05398247f, 0.06033998f, -0.03885514f, 0.14686793f, 0.03438071f, -0.01094233f, 0.06018222f, 0.04574719f, 
    -0.28373376f, -0.02881256f, 0.13662839f, -0.12157053f, 0.03362333f, 0.06854583f, -0.08806442f, 0.02031566f, 
    0.05836297f, 0.05234763f, -0.05474077f, -0.07936700f, -0.34011990f, -0.26910985f, -0.09105907f, 0.40917218f, 
    0.01543289f, -0.02591048f, 0.04168501f, -0.05924510f, -0.01745735f, 0.00029306f, -0.02036839f, -0.02354443f, 
    0.06788728f, -0.10807305f, 0.02446059f, 0.06764888f, 0.00809826f, 0.04577963f, 0.05189487f, -0.03156427f, 
    0.17172326f, -0.02938773f, -0.01838179f, 0.13379143f, -0.13788834f, -0.17142206f, 0.02357464f, -0.02422241f, 
    0.13913433f, -0.01512401f, 0.02712346f, 0.02138988f, 0.05560857f, -0.03512584f, 0.04950384f, 0.07387843f, 
    -0.16486807f, 0.11344651f, 0.04351676f, 0.04111947f, 0.06158341f, 0.08342016f, 0.02759147f, -0.04731961f, 
    0.04843690f, 0.09162486f, -0.07929999f, 0.09600829f, -0.15450470f, -0.04107349f, 0.05440626f, -0.04954540f, 
    0.02762381f, 0.03649522f, -0.00025499f, 0.03320200f, -0.01840037f, -0.12842508f, 0.09254776f, 0.05941811f, 
    -0.11169678f, -0.04256907f, 0.05875279f, 0.12362232f, -0.05352918f, 0.06514475f, -0.05466380f, 0.03982123f, 
    -0.08602308f, 0.15183783f, -0.16273189f, -0.09315109f, -0.11419316f, -0.02297717f, -0.13305996f, -0.16452289f, 
    0.05052169f, -0.02877959f, 0.01647734f, -0.01796711f, -0.12853037f, -0.08438786f, -0.07208876f, -0.07152933f, 
    -0.16095644f, -0.12279116f, -0.24409319f, 0.06985479f, 0.12589611f, -0.03865827f, 0.00978501f, 0.03843398f, 
    0.02742274f, 0.09698901f, 0.07103332f, 0.13259169f, -0.16384223f, 0.25510290f, -0.06455241f, -0.08052941f, 
    0.00981298f, -0.00658198f, 0.01460148f, -0.08060881f, -0.11637873f, 0.02186028f, -0.07687013f, -0.02127635f, 
    0.14999761f, -0.31850222f, 0.07695258f, 0.23315246f, 0.07171507f, 0.00805909f, -0.00540462f, 0.02986453f, 
    -0.02621707f, 0.09185084f, 0.07490207f, -0.07114822f, 0.06675696f, 0.15233642f, -0.30549446f, -0.22811514f, 
    0.01852226f, -0.03842186f, 0.00359701f, 0.03445286f, -0.19356631f, -0.06133366f, -0.01136033f, -0.03166025f, 
    -0.22796635f, -0.01366277f, 0.05951776f, -0.30484974f, 0.00274029f, -0.04177189f, 0.03328205f, -0.08797558f, 
    0.05105609f, -0.03151210f, 0.02176524f, 0.01303107f, 0.04999005f, -0.11683624f, 0.04219361f, -0.35335678f, 
    -0.03759301f, 0.06605999f, 0.05060168f, 0.06269037f, 0.13706128f, 0.02174412f, -0.06152965f, 0.06952824f, 
    0.07569645f, -0.06762830f, 0.02970842f, -0.00152391f, 0.11091958f, -0.04636779f, -0.01979049f, -0.07403912f, 
    -0.01279644f, 0.10401466f, -0.06300435f, 0.01364101f, 0.08380377f, 0.03802800f, -0.18990959f, -0.26614156f, 
    0.10969660f, -0.06683313f, -0.03662450f, 0.02074995f, 0.01065736f, 0.00664508f, -0.03780395f, 0.07474560f, 
    0.09514812f, 0.00268356f, 0.08730032f, -0.14829679f, 0.01269033f, 0.06850453f, 0.05818144f, 0.02646785f, 
    -0.05597853f, -0.03041632f, -0.06284869f, 0.11833300f, 0.06014829f, -0.22775057f, -0.05237798f, 0.20642577f, 
    0.00033840f, 0.04463925f, 0.11215122f, 0.03864000f, 0.05374766f, 0.07867238f, 0.02142333f, -0.15262286f, 
    0.00650001f, -0.16021359f, 0.12026391f, -0.04842053f, 0.05954200f, -0.05539837f, -0.10606968f, -0.01964127f, 
    0.00931145f, -0.02229631f, 0.04784003f, 0.02639981f, 0.07149505f, 0.01824452f, -0.01100389f, -0.07516558f, 
    0.06155066f, -0.05286922f, -0.10348411f, -0.09285502f, 0.08005193f, -0.05204922f, -0.00167842f, 0.09019552f, 
    0.18334545f, 0.20670579f, -0.14010179f, 0.20923787f, -0.01928091f, 0.02880883f, -0.09762386f, -0.04785841f, 
    0.05634104f, -0.04559607f, -0.01693994f, 0.07042804f, 0.11596733f, 0.02618298f, 0.20675875f, 0.07670913f, 
    0.00642499f, 0.04154886f, -0.05632039f, 0.02184947f, -0.03746342f, 0.07768808f, 0.13723041f, -0.00889045f, 
    0.01671380f, 0.01413444f, 0.08268692f, -0.04568625f, -0.08581018f, -0.00240677f, -0.01534068f, -0.07728143f, 
    -0.01074828f, 0.08965531f, -0.02048645f, 0.12984607f, -0.05555870f, 0.12676148f, 0.08081505f, -0.21041048f, 
    -0.06585412f, 0.04443287f, -0.03992870f, 0.02785538f, 0.00021878f, -0.03400839f, -0.07119213f, 0.04397462f, 
    -0.24336348f, -0.33105904f, -0.07979122f, -0.07873945f, 0.03057453f, 0.02026331f, -0.11838568f, 0.00471319f, 
    0.02972814f, 0.04128183f, 0.07651739f, 0.04781845f, 0.06745265f, 0.09420572f, -0.02176367f, 0.02885291f, 
    -0.01433036f, -0.07034032f, -0.00208681f, -0.01571787f, -0.00699810f, -0.05976738f, -0.09575513f, -0.08092555f, 
    -0.13941890f, -0.03412173f, 0.01282848f, 0.03017181f, 0.15144093f, 0.01540737f, 0.03300304f, 0.01112204f, 
    0.02651257f, 0.04713609f, -0.07884030f, -0.05440367f, -0.31140688f, -0.25711048f, 0.17981954f, 0.09579493f, 
    -0.00699671f, 0.12795180f, 0.07031844f, -0.06002630f, -0.01238915f, -0.02429232f, 0.08968187f, -0.04595615f, 
    -0.44203186f, 0.00366495f, -0.09714657f, 0.10318054f, 0.15886313f, 0.07230337f, 0.07254189f, -0.02112638f, 
    0.06886236f, -0.04685332f, -0.09962962f, 0.08088772f, 0.14547762f, 0.11608671f, 0.08883272f, -0.13680874f, 
    0.03682568f, 0.12135510f, 0.09355170f, 0.07414207f, -0.04131326f, 0.03679161f, 0.06342906f, 0.06350171f, 
    -0.35469028f, -0.30660456f, 0.02253110f, 0.10340545f, 0.09682369f, 0.01231725f, 0.03346120f, -0.11429133f, 
    0.12427340f, -0.00906469f, -0.03584974f, 0.02274290f, 0.14164598f, -0.03270680f, 0.01600994f, 0.00648853f, 
    -0.03041173f, -0.05230555f, -0.00455485f, 0.08781244f, -0.01445523f, 0.03040523f, 0.01618714f, 0.09101897f, 
    0.00807504f, 0.04391848f, -0.20566505f, 0.19110954f, -0.07053988f, -0.03879033f, -0.06131422f, -0.00321077f, 
    0.01808357f, 0.09717790f, 0.03112556f, -0.02934004f, 0.06455512f, 0.00002219f, 0.00706865f, -0.00210484f, 
    0.03614563f, 0.08408664f, -0.00138615f, 0.02987916f, -0.00074200f, 0.05311486f, -0.02476534f, 0.11452109f, 
    -0.37198320f, -0.32129446f, -0.32463053f, -0.28522789f, 0.01155136f, -0.10609394f, 0.02694051f, -0.01505189f, 
    0.02925989f, 0.07400734f, 0.07665494f, 0.04479599f, -0.33929300f, -0.27207762f, -0.11757153f, -0.21940437f, 
    -0.07317092f, -0.08396889f, 0.00910402f, 0.09399746f, 0.10883570f, 0.09013771f, 0.07002695f, 0.02874142f, 
    0.19117801f, -0.05482833f, 0.04363800f, -0.10576098f, 0.02806673f, -0.10135874f, 0.01994113f, 0.04834851f, 
    -0.02355200f, 0.00729568f, -0.09708425f, 0.04488779f, 0.19146080f, -0.00024749f, -0.04160121f, -0.02635361f, 
    0.02817918f, -0.03529002f, 0.02777672f, 0.01408242f, 0.10584783f, -0.03678170f, 0.05584323f, -0.01786450f, 
    -0.13447763f, -0.14695172f, -0.01570904f, 0.07448037f, 0.00672618f, -0.04266339f, 0.09592638f, -0.07560758f, 
    0.12565160f, -0.17402257f, -0.14797562f, -0.04606354f, -0.50819165f, -0.29893547f, 0.00514583f, -0.06066535f, 
    0.14624473f, -0.02415040f, -0.03431592f, -0.03610944f, 0.00695766f, 0.04416855f, -0.00055031f, 0.13973828f, 
    0.07612459f, -0.10673366f, 0.09115869f, 0.06479736f, -0.06210786f, 0.06808545f, 0.11176033f, -0.04413295f, 
    -0.01266887f, -0.10437906f, 0.01695813f, -0.04696480f, 0.10588378f, 0.05488978f, -0.07363987f, -0.02017942f, 
    0.04952168f, 0.15735993f, 0.05912171f, -0.03694358f, 0.09930574f, 0.06868042f, 0.08938326f, 0.02934620f, 
    0.05996082f, -0.12689973f, -0.05556036f, 0.09037708f, 0.03235014f, 0.05543504f, 0.01390768f, 0.08296169f, 
    -0.07263702f, -0.01056309f, 0.03181205f, -0.01366762f, -0.06972325f, 0.04660682f, 0.05959875f, -0.03982938f, 
    -0.01440354f, 0.00829587f, 0.11066576f, -0.06283659f, 0.05053712f, -0.12578002f, 0.04350735f, 0.08402242f, 
    -0.31695187f, -0.16309871f, -0.15661348f, -0.13372415f, -0.02277348f, 0.00359520f, -0.08276632f, 0.01169271f, 
    0.05346368f, 0.01437317f, 0.06840450f, 0.03816745f, 0.00641774f, 0.00166630f, -0.21192239f, 0.08989687f, 
    -0.04979554f, 0.02443814f, -0.10896551f, -0.02618071f, 0.05430075f, -0.03271048f, 0.01247934f, -0.07556003f, 
    -0.11715475f, -0.14315856f, -0.16261406f, -0.18223263f, 0.02871993f, 0.05309002f, -0.12541559f, -0.10891823f, 
    0.00798430f, -0.13458797f, -0.10774731f, 0.02514102f, -0.03751301f, 0.04448845f, -0.10671893f, -0.04801381f, 
    -0.07721071f, -0.03723755f, -0.01023765f, 0.08046354f, -0.07387865f, -0.16181785f, -0.00446518f, -0.00702161f, 
    0.13414815f, 0.26861680f, 0.12113570f, -0.11166601f, 0.02376073f, -0.04501261f, 0.06685805f, 0.09298056f, 
    -0.04137632f, -0.01099753f, 0.13208260f, 0.14217800f, 0.23090149f, 0.11583795f, -0.00459168f, -0.01656485f, 
    0.08042377f, 0.10078174f, 0.04994773f, 0.09342611f, -0.08810122f, -0.05179368f, 0.09434267f, -0.12078718f, 
    -0.44238141f, -0.10323400f, 0.12995581f, 0.24108584f, 0.11449143f, 0.06679625f, -0.06270668f, 0.06909066f, 
    0.07402746f, 0.02288672f, -0.09014235f, 0.21322857f, -0.07008671f, 0.09319509f, -0.17295824f, 0.08442429f, 
    0.00246282f, -0.07043883f, 0.08814669f, 0.07802157f, 0.01472287f, 0.06805868f, 0.05987550f, 0.13477632f, 
    -0.00003619f, 0.05788624f, -0.06799636f, 0.03184412f, -0.07553264f, -0.11217786f, 0.01112271f, 0.05273474f, 
    -0.07309605f, -0.04882748f, -0.03569776f, -0.11756966f, 0.11717606f, -0.05799419f, -0.01247493f, 0.02192507f, 
    0.08015142f, 0.12153509f, 0.02811477f, 0.07018466f, 0.07352199f, -0.00661540f, 0.07083340f, 0.18283342f, 
    0.16743855f, 0.02629223f, 0.02571574f, 0.00202536f, -0.10409100f, -0.18553084f, 0.00548804f, -0.03993029f, 
    -0.05473184f, -0.19355106f, -0.00926185f, -0.08003332f, -0.17017919f, 0.06244552f, 0.21438077f, -0.05714592f, 
    0.14102305f, -0.02155990f, -0.02706174f, -0.05282154f, 0.06005933f, 0.03955078f, 0.02312446f, 0.01801609f, 
    -0.29909658f, -0.18604623f, -0.13299090f, -0.19333449f, 0.05261723f, 0.02167045f, -0.07773109f, -0.00325297f, 
    0.01244461f, -0.04425690f, 0.08740704f, -0.02535141f, 0.01557094f, -0.10833178f, 0.02919891f, 0.05442716f, 
    0.07042521f, 0.10573398f, 0.05512783f, -0.01231018f, 0.02616426f, 0.11928507f, 0.05430830f, 0.07554340f, 
    0.04316878f, 0.11872001f, -0.12802425f, -0.05613457f, 0.08024248f, 0.02244228f, -0.11849640f, 0.03994428f, 
    0.09915186f, 0.12042592f, -0.01140877f, 0.01553511f, -0.15019581f, -0.18635221f, -0.01451138f, -0.04800820f, 
    0.05064560f, 0.06980394f, 0.04471610f, -0.10429803f, 0.05338248f, -0.00046501f, -0.03007704f, 0.01301094f, 
    -0.26520035f, -0.24819498f, -0.10832597f, 0.02782453f, 0.01979136f, -0.04754584f, -0.06776875f, -0.06112462f, 
    -0.05437200f, 0.17536600f, 0.02361822f, -0.01731905f, 0.01011589f, 0.07592306f, -0.13864294f, -0.03393983f, 
    -0.06997482f, 0.04770830f, 0.01839573f, -0.00763899f, 0.08668626f, 0.09955692f, 0.09671055f, 0.01966113f, 
    -0.35821766f, -0.09242246f, -0.08043718f, -0.02586630f, -0.00942687f, 0.07957115f, -0.03739673f, -0.17634721f, 
    0.03568964f, -0.25395101f, -0.15962464f, -0.07224469f, -0.02086089f, -0.14831530f, 0.01479280f, -0.09078929f, 
    -0.05427367f, 0.01687332f, -0.00265867f, 0.02338455f, -0.00236703f, -0.00616527f, -0.17489862f, -0.12054350f, 
    0.23760292f, 0.07542099f, 0.04670610f, 0.12472593f, 0.14369549f, -0.11236582f, 0.15004292f, -0.18399234f, 
    -0.04689992f, -0.00760243f, 0.04504179f, 0.04849936f, 0.22022569f, -0.02479916f, -0.13694683f, 0.19963871f, 
    -0.07321665f, 0.00550777f, 0.01462736f, 0.08218937f, 0.08155034f, 0.02638395f, -0.01726935f, -0.08326426f, 
    -0.26120088f, -0.00009139f, -0.06448986f, -0.19003752f, 0.11881796f, 0.01479542f, -0.16142698f, 0.02789707f, 
    -0.00318711f, -0.00554587f, 0.00324425f, 0.00839862f, 0.23210031f, 0.11330805f, -0.08379746f, 0.00789618f, 
    0.00878244f, -0.06059537f, -0.02508249f, -0.03700996f, -0.03448878f, 0.04104063f, -0.07334401f, -0.01194160f, 
    -0.02861083f, 0.03936433f, -0.03759974f, -0.01030781f, -0.02227028f, -0.04839932f, 0.00125076f, 0.11005034f, 
    -0.00995194f, -0.13338608f, 0.00968080f, 0.09549972f, -0.46216768f, 0.12697333f, -0.02908829f, -0.04833190f, 
    0.11629092f, 0.05960830f, -0.07264006f, -0.06595633f, 0.08730145f, -0.03517391f, 0.00700019f, -0.04042699f, 
    0.16761310f, 0.05123384f, 0.08247788f, -0.16951084f, -0.06362551f, 0.02134085f, 0.05839606f, -0.07294317f, 
    0.00934544f, -0.06107748f, 0.01263775f, -0.00859181f, -0.58620352f, -0.12111741f, -0.15861621f, -0.31977355f, 
    -0.07126959f, -0.03396619f, -0.05210571f, -0.00831765f, 0.00158477f, 0.00691903f, -0.05045600f, 0.02061124f, 
    0.02514400f, 0.00535285f, -0.16919014f, 0.09315981f, -0.07674554f, 0.16128416f, -0.13023348f, 0.02241191f, 
    -0.02541962f, -0.09474376f, -0.14302230f, -0.04652293f, -0.22253132f, -0.04535383f, -0.09382445f, -0.21929914f, 
    0.03968654f, -0.02542882f, -0.04188473f, 0.06755576f, 0.03996352f, 0.06293761f, 0.05450230f, 0.10892453f, 
    0.18011709f, 0.02756975f, -0.05263565f, -0.11240201f, 0.02882321f, 0.01738736f, 0.04377026f, -0.00939517f, 
    -0.05350609f, 0.09806856f, 0.06688046f, 0.01824807f, -0.08510862f, 0.08319021f, 0.11643520f, -0.07907774f, 
    0.09947039f, 0.00239960f, 0.13222727f, 0.04789585f, 0.07953109f, 0.12494758f, -0.00332238f, 0.14094795f, 
    0.07897917f, 0.13496882f, 0.02975491f, -0.10227269f, 0.01133547f, -0.01669632f, -0.02306122f, 0.00238603f, 
    -0.01259918f, 0.02846296f, -0.03097243f, 0.04956477f, -0.06839060f, 0.01723971f, -0.12198847f, -0.01086872f, 
    0.05805178f, -0.11238645f, 0.03070389f, -0.09564188f, -0.02311527f, -0.11938949f, -0.06311293f, -0.06792070f, 
    0.25344676f, 0.09453836f, 0.02674055f, 0.02181375f, -0.13090111f, -0.02914313f, 0.01351986f, 0.05957298f, 
    0.07412412f, 0.07291751f, 0.06437465f, 0.04899327f, -0.13262498f, 0.03318723f, 0.04900155f, -0.10310382f, 
    0.04005827f, 0.04752403f, 0.02526067f, 0.02963111f, 0.10919011f, 0.15594251f, 0.04137950f, 0.14136277f, 
    -0.14537439f, -0.18163352f, -0.00500756f, -0.12370800f, 0.03619379f, 0.00528801f, -0.18028688f, -0.06887715f, 
    -0.02458002f, -0.05775538f, -0.06775316f, -0.10922690f, 0.29175711f, 0.12841412f, -0.10563497f, -0.03274658f, 
    -0.05150595f, 0.00521042f, 0.00132368f, 0.10389762f, -0.04977044f, -0.01726649f, 0.01729229f, 0.11035305f, 
    -0.21659574f, -0.13097565f, 0.01966083f, -0.06926445f, -0.01557109f, 0.02829560f, 0.01878659f, 0.04552129f, 
    0.01440348f, 0.02737586f, 0.06612764f, 0.07698326f, 0.21423331f, 0.04770468f, -0.13650763f, 0.09516947f, 
    -0.12555425f, -0.12233744f, 0.01691795f, 0.04440832f, 0.04698626f, 0.14621550f, -0.11570217f, -0.04880079f, 
    -0.11871731f, 0.17631346f, 0.05631755f, -0.18983796f, -0.01204815f, 0.03770170f, -0.03951165f, -0.00609170f, 
    -0.04145259f, 0.00604184f, 0.00349914f, 0.15263529f, -0.34565637f, -0.20233594f, -0.07733530f, -0.03260148f, 
    0.12326509f, -0.05269012f, -0.02637273f, -0.01103596f, 0.06329904f, 0.10688685f, 0.01156737f, 0.00496120f, 
    -0.06381999f, -0.07862306f, 0.10465626f, 0.00166817f, 0.04115562f, -0.03904045f, -0.13217965f, 0.00188023f, 
    -0.03687217f, 0.15034021f, -0.09053622f, -0.00213713f, -0.19411652f, -0.07452910f, 0.06317905f, 0.00583871f, 
    0.09182721f, -0.06868504f, -0.05173205f, 0.04963945f, -0.04676354f, -0.08436101f, -0.01233996f, 0.02631739f, 
    0.26494819f, -0.05931599f, -0.11551178f, 0.19406024f, 0.09533651f, -0.01329153f, 0.01078944f, -0.04769985f, 
    0.07477765f, 0.01066832f, -0.07261875f, -0.00358839f, -0.06885266f, 0.04766798f, 0.16781171f, -0.05879908f, 
    0.01603853f, 0.01300470f, 0.00288929f, 0.01555713f, 0.05784570f, 0.06147581f, 0.13479829f, 0.01615983f, 
    -0.13526578f, -0.01172509f, -0.15345825f, 0.23518628f, 0.09334540f, -0.00043892f, -0.04694086f, -0.01400333f, 
    0.11406693f, 0.07799115f, 0.06918479f, 0.14580648f, 0.03609323f, 0.29836074f, -0.17891937f, 0.18153729f, 
    0.15923610f, 0.01454850f, -0.02906098f, -0.10944863f, 0.00727355f, 0.07529883f, -0.03083596f, 0.06729151f, 
    0.27641162f, 0.07031960f, -0.01308474f, -0.13001701f, 0.04500828f, -0.12391616f, -0.06130729f, 0.09788195f, 
    -0.02693217f, 0.01460930f, 0.04571725f, 0.04873998f, 0.22851883f, -0.07812086f, -0.13316938f, 0.20696470f, 
    -0.14183594f, -0.08133654f, 0.05296193f, -0.01375061f, 0.02536475f, -0.08527020f, 0.03926710f, -0.05131298f, 
    0.19016746f, 0.17833766f, -0.09805046f, -0.14288603f, 0.12190726f, -0.05160249f, -0.09145636f, 0.10002539f, 
    0.08410642f, 0.03815792f, -0.02073559f, 0.00047596f, -0.32086340f, -0.22994843f, 0.06766499f, -0.09603781f, 
    -0.06029191f, 0.09593154f, -0.01162594f, -0.02181965f, -0.05713508f, -0.04777191f, -0.01445897f, 0.00525593f, 
    -0.04340496f, -0.03153287f, -0.11602344f, 0.06469028f, -0.15613331f, 0.02709918f, -0.16146758f, 0.08771256f, 
    -0.03010453f, 0.00434726f, -0.16711487f, -0.00559108f, -0.07056603f, 0.20245169f, 0.05943441f, -0.02539541f, 
    -0.05638980f, 0.05305030f, -0.04853841f, -0.08271404f, 0.02148911f, -0.03877514f, 0.04849799f, -0.01169788f, 
    0.21535741f, -0.27504846f, -0.05922017f, 0.08656955f, 0.06681903f, -0.01223314f, -0.00853389f, -0.09429624f, 
    -0.01409045f, -0.02538948f, -0.08471631f, -0.06939822f, -0.03483737f, 0.21124144f, -0.18354587f, -0.12637554f, 
    0.13732705f, -0.03984559f, 0.01993559f, -0.00706213f, 0.10332862f, 0.00935133f, -0.05108157f, -0.00565667f, 
    -0.10801261f, 0.07289665f, 0.12418614f, 0.06571131f, -0.00719477f, -0.03306825f, -0.04644030f, -0.03245536f, 
    -0.03789207f, 0.03157928f, -0.03143069f, -0.01896399f, 0.11224470f, -0.09050337f, -0.15407942f, 0.06258765f, 
    0.07703549f, 0.04764297f, 0.02388553f, -0.02109458f, -0.01724062f, -0.02827883f, -0.11801878f, 0.03443063f, 
    -0.21165657f, 0.02634891f, -0.05322630f, -0.06260268f, 0.06428736f, -0.01800887f, 0.01227908f, 0.05679278f, 
    -0.03612170f, 0.10625122f, 0.06711202f, -0.09494120f, 0.18794399f, 0.04635441f, -0.05184136f, -0.16370074f, 
    0.08850349f, -0.00471388f, 0.00761861f, 0.11988269f, -0.00366078f, -0.02570456f, -0.03504873f, 0.11401346f, 
    0.15408126f, 0.18326518f, -0.00800007f, 0.14219445f, 0.03252969f, 0.07244758f, 0.02080967f, -0.08608687f, 
    -0.02894172f, 0.09830261f, 0.07421229f, 0.01184106f, 0.00551199f, 0.20616323f, -0.00551007f, 0.06554678f, 
    -0.06751534f, -0.02426694f, -0.04893254f, -0.02076029f, -0.02392410f, -0.04307429f, -0.14207464f, -0.05671370f, 
    -0.32762003f, 0.17513926f, -0.26176494f, 0.01542274f, 0.23318404f, 0.01456648f, 0.10580089f, -0.03156181f, 
    -0.09836656f, 0.02585881f, 0.00158271f, 0.04537365f, -0.27513316f, -0.04501688f, 0.00574451f, -0.13579445f, 
    0.09249561f, 0.03047814f, 0.01776228f, 0.05325594f, -0.05489482f, 0.01027310f, -0.00588321f, -0.18092044f, 
    0.20979069f, -0.20936596f, -0.03741362f, 0.01186332f, 0.10969675f, -0.05052195f, -0.09817328f, -0.07370308f, 
    0.00157367f, 0.08729392f, -0.10177723f, -0.00609926f, 0.16690469f, -0.02161637f, -0.09543885f, -0.00108360f, 
    -0.15521692f, 0.07092131f, 0.06395739f, -0.12994479f, -0.08723551f, -0.02519671f, -0.03685219f, -0.11531561f, 
    -0.38574818f, -0.21314839f, -0.23467334f, -0.29847100f, 0.05613469f, -0.00489464f, 0.01085879f, 0.07991333f, 
    0.05247216f, 0.04509680f, -0.02610420f, -0.00739825f, -0.08824494f, -0.19120921f, 0.02251572f, -0.04533397f, 
    0.04090599f, 0.08021159f, 0.03031071f, -0.06702942f, 0.02094943f, 0.02162805f, -0.00625011f, -0.02336447f, 
    0.00765156f, 0.00520959f, -0.07573016f, -0.10093606f, 0.02686694f, 0.05743884f, 0.05504801f, -0.00487653f, 
    0.03776641f, -0.03668166f, -0.08520352f, -0.11677457f, 0.01811662f, 0.04340434f, -0.19995010f, -0.17542949f, 
    -0.19486278f, 0.00538734f, 0.04754953f, -0.03046240f, 0.10428448f, -0.01710504f, -0.16768835f, -0.00128890f, 
    0.39513615f, 0.07191364f, -0.08910818f, -0.09262858f, -0.02313968f, -0.12036832f, 0.01254104f, 0.04567343f, 
    -0.00968756f, -0.00344619f, -0.02654955f, 0.01419497f, -0.32971340f, 0.07184711f, 0.01429711f, -0.01473308f, 
    -0.17914386f, 0.01388801f, 0.01185022f, 0.05090061f, 0.02529111f, 0.02305101f, 0.04091636f, -0.09113367f, 
    -0.06796060f, -0.03021882f, -0.02998997f, 0.00984172f, -0.15211090f, 0.03022381f, 0.02199051f, -0.00574069f, 
    -0.04771784f, 0.01453974f, -0.06841626f, -0.03281600f, 0.05553183f, 0.08897720f, -0.10006103f, 0.07759035f, 
    0.12563674f, -0.04089544f, 0.05898948f, 0.03124054f, -0.04070257f, 0.02575938f, -0.04373975f, -0.03442113f, 
    0.11797246f, -0.06875469f, -0.11009841f, 0.01463307f, -0.01177752f, -0.08039639f, 0.08051701f, -0.07383838f, 
    0.04689309f, 0.06423214f, 0.03270327f, 0.03265372f, 0.23058201f, -0.05085831f, -0.17191972f, -0.00262324f, 
    0.02665685f, -0.09063448f, -0.04091897f, 0.05976789f, 0.04147941f, 0.07781973f, -0.07249594f, -0.05077570f, 
    -0.01710561f, -0.24351928f, -0.04398220f, -0.28143564f, 0.05325379f, 0.01626921f, -0.03332147f, 0.11456092f, 
    -0.09485997f, 0.05571513f, -0.02990835f, -0.06749374f, 0.04459146f, 0.07329317f, -0.09662307f, 0.06575357f, 
    0.02790395f, -0.07816739f, 0.01879543f, 0.11819924f, -0.03547351f, 0.04248358f, -0.08178267f, -0.07952556f, 
    -0.11848319f, 0.04953722f, -0.03298883f, 0.21426725f, -0.08981460f, 0.08282142f, -0.00932323f, 0.15165108f, 
    0.03186254f, -0.12214109f, 0.00818594f, -0.06844717f, -0.19983138f, -0.13094456f, -0.16346565f, -0.09970926f, 
    0.04932005f, -0.02554403f, 0.10796454f, 0.09748187f, -0.06565286f, -0.03211924f, -0.08526994f, -0.02878271f, 
    -0.14276834f, -0.14938399f, -0.12590048f, 0.15095975f, 0.04845548f, 0.09343135f, -0.19449435f, 0.03244852f, 
    -0.01127370f, -0.03016986f, 0.01221962f, 0.18500827f, -0.22741951f, 0.09241560f, 0.06680670f, 0.24655823f, 
    -0.12687397f, 0.03382365f, -0.01462059f, 0.09703808f, -0.13623123f, -0.04320321f, 0.08252200f, -0.01075700f, 
    0.00146495f, 0.02199182f, 0.03238639f, -0.13279471f, 0.01768921f, 0.03347357f, -0.05416997f, 0.01315428f, 
    0.11611279f, 0.05000897f, 0.10045584f, 0.03742180f, -0.15230963f, -0.27171403f, -0.03108634f, 0.09367987f, 
    0.03103028f, 0.00472493f, -0.01506103f, 0.01157763f, -0.11289942f, -0.00554083f, 0.03304865f, 0.00389144f, 
    0.06836757f, -0.00623007f, -0.10327064f, -0.15765837f, 0.00076874f, -0.00322173f, 0.03294031f, -0.03387508f, 
    -0.00351794f, 0.06291461f, 0.01623895f, 0.02529377f, 0.38792399f, -0.06296619f, 0.07643564f, -0.02451526f, 
    -0.01195645f, -0.05786911f, 0.07664982f, -0.12043703f, -0.13034451f, -0.02996005f, 0.16705056f, 0.07486719f, 
    -0.11517883f, -0.02303524f, -0.00439616f, -0.00395939f, -0.11071527f, -0.01999807f, -0.01054555f, 0.05007280f, 
    -0.00700593f, -0.02237983f, -0.06961644f, 0.02861190f, 0.08703449f, -0.10425142f, 0.09491818f, 0.06207519f, 
    -0.10661811f, -0.02525097f, 0.05176684f, 0.15215184f, -0.11244477f, -0.05897693f, -0.01793469f, -0.04345712f, 
    -0.06770174f, -0.09343445f, 0.01685995f, 0.07398049f, 0.09717185f, -0.02061403f, -0.04827493f, -0.03856532f, 
    0.04078264f, 0.01761163f, -0.08450366f, -0.05119584f, -0.03946766f, -0.09791809f, -0.00470689f, 0.16670832f, 
    -0.06833738f, 0.03518998f, -0.00346965f, 0.00576292f, -0.01887828f, -0.09583823f, 0.09370743f, 0.10202762f, 
    -0.11936582f, 0.18242614f, -0.00635664f, 0.09824734f, 0.05429732f, 0.00611354f, -0.07892182f, -0.02105413f, 
    0.01454183f, -0.02063321f, -0.03031600f, -0.09423723f, 0.30888894f, -0.07362460f, -0.19207460f, -0.05037541f, 
    -0.00472333f, -0.12399377f, -0.00019840f, -0.01491217f, 0.11869324f, -0.09788286f, -0.05484355f, -0.00139463f, 
    -0.44351569f, 0.20973566f, -0.04132168f, 0.16988982f, 0.17861137f, 0.00703102f, 0.17670225f, -0.03530343f, 
    0.01739690f, -0.00358662f, 0.01281807f, -0.01833829f, 0.09000670f, -0.17039041f, 0.02107858f, 0.02920745f, 
    0.01928579f, -0.02265494f, -0.01217892f, -0.03947740f, 0.02061024f, -0.02370788f, 0.00755281f, 0.00341103f, 
    -0.25813240f, 0.22843312f, 0.04019389f, -0.12049726f, -0.10351732f, 0.02569379f, -0.12180026f, 0.03699283f, 
    0.05595508f, 0.05100330f, 0.19611371f, 0.06028875f, 0.18680865f, -0.17799965f, -0.01496042f, 0.13947356f, 
    0.00253109f, -0.11184299f, -0.04651193f, 0.00944995f, 0.07248855f, 0.05879290f, -0.01045925f, 0.02356699f, 
    0.10654915f, 0.13672066f, -0.35898146f, -0.08564594f, 0.18718059f, -0.11379719f, 0.04565367f, 0.14691877f, 
    0.00392122f, 0.01765643f, 0.03769948f, -0.01327866f, 0.20923443f, -0.13295068f, -0.03412759f, -0.10057274f, 
    -0.22306395f, 0.02076495f, 0.04812506f, -0.04451448f, -0.09148102f, -0.14892492f, -0.07776438f, -0.10695983f, 
    -0.04040512f, -0.03563533f, 0.04847159f, 0.04995341f, -0.07366797f, -0.03739092f, 0.02164795f, 0.07352943f, 
    -0.01954193f, -0.09946398f, -0.10571808f, -0.04788283f, 0.09015333f, -0.17828420f, -0.00854041f, 0.18958443f, 
    0.04848436f, -0.00719377f, -0.00261608f, -0.01033845f, -0.08175185f, 0.00192320f, -0.02342069f, -0.03872586f, 
    -0.01487370f, 0.05471888f, -0.04256959f, -0.18326786f, -0.07824602f, 0.01950582f, 0.11725686f, 0.08828894f, 
    0.06012844f, 0.06745473f, 0.12657842f, 0.10193405f, -0.24871115f, 0.14510171f, -0.23633894f, -0.11624659f, 
    -0.05593149f, -0.13310234f, 0.06051502f, 0.12727594f, -0.03205928f, 0.00673304f, -0.03336688f, -0.09159476f, 
    0.07573989f, 0.00334903f, 0.02961360f, -0.17732924f, -0.01759203f, 0.02769464f, 0.07518817f, 0.07311997f, 
    -0.01480888f, -0.03384342f, -0.01919484f, -0.07401460f, -0.29132509f, -0.15527795f, 0.10895626f, 0.05351410f, 
    0.09585803f, 0.00350731f, 0.01129831f, 0.03156436f, 0.04167183f, 0.01082784f, -0.02751723f, 0.08693140f, 
    -0.17983615f, 0.10357611f, -0.04230162f, 0.06487465f, -0.09063728f, -0.02011169f, -0.01774184f, -0.10987769f, 
    -0.08674086f, 0.03977742f, -0.02533750f, -0.15196557f, 0.48398027f, -0.06689587f, -0.02941327f, 0.10297458f, 
    -0.08027673f, -0.00617474f, -0.19055827f, 0.02069643f, -0.00564782f, -0.03231293f, 0.05759357f, 0.02850906f, 
    -0.05471715f, 0.07999161f, -0.03108965f, -0.18163927f, -0.01030525f, 0.07242773f, -0.02810148f, -0.01515750f, 
    0.19800110f, -0.06544204f, -0.01572953f, -0.00578056f, 0.12840220f, -0.23083970f, -0.04548936f, -0.17134678f, 
    -0.01189948f, 0.07457124f, 0.08323696f, 0.01904274f, 0.02027255f, -0.03697065f, -0.05472726f, 0.04211374f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02806009f, 0.02815821f, -0.00038098f, -0.01874488f, -0.00090450f, -0.02633688f, -0.00294170f, -0.07512259f, 
    -0.01272167f, 0.03595737f, 0.11048006f, -0.01616880f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
