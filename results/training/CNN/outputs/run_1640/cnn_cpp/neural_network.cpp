#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.19729984f, -0.80845684f, 0.33020172f, 0.80816776f, 0.48077559f, -0.96013021f, -1.24602568f, -0.47660151f, 
    0.48462391f, 0.33150914f, -0.31709090f, -0.62862074f, -0.39364523f, 0.66862077f, -0.75213909f, -0.25519332f, 
    -0.42741048f, -0.17091793f, -0.15714465f, -0.74929762f, -0.42460465f, -0.15041092f, 0.14814535f, -0.11154345f, 
    -0.08636494f, -1.86504126f, -0.90966582f, -0.51148874f, -1.32477283f, -1.26207900f, 1.29071844f, 0.35864222f, 
    -0.60340172f, -0.47048855f, 0.36412278f, -0.53895992f, -0.50034559f, -0.25676858f, -0.40629157f, -0.28508097f, 
    0.19911645f, -0.02211360f, -0.19622163f, -0.24138376f, -0.29366967f, -0.00676237f, -0.03083299f, -0.12305865f, 
    -0.08144340f, -0.04969432f, 0.67268145f, 1.39184022f, 0.83722335f, -0.00717453f, 0.26632980f, -0.58150047f, 
    -0.14901330f, -0.20084378f, -0.48603460f, -0.53395998f, 0.13199757f, 0.14779964f, -0.27142674f, 0.16245912f, 
    -0.35995635f, -0.51696163f, 0.21061687f, 0.33578846f, 0.05444894f, -0.04599649f, -0.06552315f, 0.10540577f, 
    -0.20471710f, -0.23247983f, -0.41337964f, -0.95840889f, -0.23659062f, 0.64114457f, 0.59026676f, 0.55518836f, 
    -0.71708524f, -0.82734925f, -0.72408152f, 0.35462800f, 0.81632012f, -0.19053094f, 0.29839122f, -0.36443239f, 
    0.53962582f, 0.03096681f, -0.20555605f, -0.02647245f, -0.09368439f, -0.23916993f, -0.29706576f, 0.18940592f, 
    0.20579876f, 0.26806018f, 0.40410468f, 0.02398697f, -0.05408711f, -0.67050630f, -0.06910055f, 0.62018883f, 
    0.30828521f, 0.68308431f, 0.36241299f, 0.19484916f, -0.51721275f, -0.15554708f, 0.88684970f, -0.24304785f, 
    -0.36501238f, -0.52198434f, -0.25333124f, 0.72403610f, -0.02487212f, -0.20066623f, -0.40268746f, -0.16449171f, 
    -0.37531137f, 0.08694100f, 0.27077845f, 0.07511680f, -0.05480261f, 1.58869898f, -0.56562793f, -0.30279490f, 
    0.53525531f, -0.44459790f, -0.38282448f, 0.96245360f, 0.00449994f, -0.84298128f, -0.28321999f, -0.16206543f, 
    0.01738505f, -0.26658174f, -0.49969420f, 0.49453580f, -0.15642114f, 0.11560375f, 0.25778928f, 0.08430140f, 
    -0.27386880f, -0.02986663f, -0.34552181f, 0.19581963f, 0.11118778f, 0.03455108f, 0.27077362f, 0.14834884f, 
    -1.39163744f, -1.49395394f, -1.16683543f, 0.05786160f, -0.19417034f, -0.16874637f, -0.00211506f, 0.58182305f, 
    0.24156046f, 0.37548658f, 0.85698622f, 0.12622225f, 0.17019391f, 0.00898476f, -0.19813102f, 0.00590415f, 
    -0.45153293f, -0.47429433f, 0.18568060f, -0.36414939f, 0.11569887f, 0.01397510f, 0.72286838f, -1.37801409f, 
    -0.52567810f, -0.33440736f, -0.62050605f, -0.12753436f, -0.36358157f, 0.00468381f, -1.10646939f, -1.29465103f, 
    0.38970578f, 0.19892344f, -0.23494774f, 0.47611433f, -0.59711546f, -0.33653694f, 0.18862033f, 0.27915639f, 
    0.21686612f, 0.44925416f, 0.26701355f, -0.02545084f, 0.10049514f, 0.47606164f, -0.13768995f, 0.11571504f, 
    -1.06721938f, -0.25224143f, 0.85561925f, 0.55953258f, 0.28675002f, 0.36375335f, 0.42386410f, 0.24423687f, 
    -0.60790932f, -0.24070980f, -0.01984886f, 0.26378441f, -0.58848423f, 0.50874448f, -0.22312045f, -0.27919748f, 
    -0.04393286f, -0.08397684f, 0.14466654f, 0.49220106f, 0.22073755f, -0.32406765f, -0.31865653f, 0.08415284f, 
    -0.11103997f, -0.06423379f, -0.49641678f, -1.00978291f, -0.67802525f, -0.99536645f, 0.05482862f, 0.16768052f, 
    -0.48759162f, -0.81955171f, -0.98338193f, 0.26524734f, 0.23887700f, 0.16528141f, -0.08319978f, -0.12717141f, 
    -0.21147104f, -0.00925583f, -0.31191701f, -0.00804757f, -0.15218855f, -0.24790764f, -0.35501340f, 0.12132745f, 
    -0.36865333f, -0.73188305f, -1.10701334f, -0.55175829f, -0.29784513f, 0.14950490f, 0.36415029f, 0.44096145f, 
    0.34098104f, 0.19044277f, 0.70439953f, 0.50411481f, -0.24215357f, 0.08184668f, -0.14207706f, 0.04654462f, 
    0.47071692f, -0.32152435f, -0.08120988f, -0.44985157f, 0.04909190f, -0.56188899f, -0.10068571f, 0.26105151f, 
    0.35677740f, 0.00650470f, 0.49995294f, -0.40943459f, 0.44844672f, 0.12953386f, -0.58681405f, -1.00567281f, 
    -1.35859740f, -0.75111932f, -0.70509112f, -0.99663556f, -1.34233725f, 0.80000424f, -0.26200274f, -0.13508816f, 
    -0.33772829f, 0.32174402f, 0.63160324f, -0.15846722f, 0.25803700f, 0.26158324f, -0.38124797f, -0.23676008f, 
    -0.06868483f, -0.16463681f, 0.03564506f, 0.49944744f, -1.32302320f, 0.28550622f, -0.46617195f, -0.47869191f, 
    -0.37698436f, 0.73153675f, 0.26785299f, 0.12279183f, 0.39569730f, 0.82182407f, 0.22671549f, 0.62924176f, 
    -0.13912445f, -0.25064930f, -0.59018153f, -0.21958546f, 0.06561692f, -0.10103703f, 0.23433638f, -0.14326747f, 
    0.06651130f, 0.12664631f, 0.03245170f, -0.32142013f, -0.02371766f, 0.04100524f, 0.83012199f, -0.81264400f, 
    -0.75519323f, -0.77183634f, -0.29670635f, -0.13614923f, 0.57834011f, 0.62762654f, 0.33115819f, -0.14900421f, 
    0.06227323f, 0.43257880f, -0.15316837f, -0.25892761f, -0.01387920f, -0.15974419f, -0.10621714f, -0.15929757f, 
    -0.27165213f, -0.17821151f, -0.34085694f, -0.46330810f, -0.54006016f, -0.90362936f, 0.78972292f, 0.19357777f, 
    0.54396057f, 0.70669407f, -0.04078046f, 0.60332394f, 0.28133956f, 0.31363520f, 0.32882547f, 0.05381489f, 
    0.17323028f, -0.02771982f, 0.02374345f, 0.23161110f, -0.23375216f, -0.19028100f, 0.01749476f, -0.13889265f, 
    -0.22723900f, -0.23543815f, 0.32575274f, -0.11476390f, -0.14640945f, 0.00272733f, -0.09990376f, -1.15390992f, 
    -0.44903368f, -0.28362158f, 0.30289787f, 0.67177808f, -0.42179084f, -0.11199457f, 1.28528774f, -0.22954117f, 
    -0.08889683f, -0.40064204f, 0.23721725f, 0.35953966f, 0.47780052f, -0.48777738f, -0.04108345f, 0.30645287f, 
    0.00871314f, -0.15460172f, 0.00549381f, -0.07489283f, 0.13179314f, 0.02229013f, -0.17067613f, 0.37491605f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.57830447f, -0.13779943f, 0.16601788f, 0.43352979f, 0.70933217f, 0.49942318f, 0.85622442f, -0.14076260f, 
    0.22257671f, -0.24111465f, 0.58286887f, 0.08237416f, 0.32221019f, 0.25090635f, -0.04095097f, 0.57272995f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.65984315f, 0.29826626f, 0.38219756f, -0.49844983f, -0.14924790f, -0.13204546f, -0.18800320f, -0.19094691f, 
    -0.11091277f, -0.28689900f, -0.23583153f, -0.06213521f, 0.48995012f, 0.36502206f, -0.24623720f, -0.27904069f, 
    0.09125733f, 0.48180136f, 0.14984494f, 0.20091480f, -0.00684813f, 0.05389332f, 0.07490698f, -0.06156605f, 
    -0.50914013f, -0.13302206f, -0.56938767f, 0.19878908f, 0.10780813f, 0.07964996f, -0.07929948f, -0.10460157f, 
    -0.05377999f, 0.07362857f, 0.03515465f, 0.15897636f, -0.33671460f, 0.31431416f, 0.47447470f, -0.88269782f, 
    0.25010011f, -0.18366942f, 0.06437394f, 0.00791380f, 0.02210670f, -0.14557849f, -0.07386787f, 0.09115783f, 
    0.06808845f, -0.95932949f, -0.35035968f, -0.18939088f, -0.03440537f, -0.14444551f, 0.02871171f, -0.01627968f, 
    -0.17816594f, -0.05593788f, -0.16313410f, -0.20810197f, -0.23657845f, -0.64130956f, 0.04273582f, -0.26274896f, 
    -0.03137324f, -0.02728722f, -0.01099566f, -0.05584817f, -0.16244358f, -0.01065368f, -0.08940995f, 0.02259727f, 
    0.35068595f, -0.00364884f, -0.22376278f, -0.23503371f, 0.02427306f, -0.05612123f, -0.26371211f, -0.54278725f, 
    0.02128233f, -0.10809974f, 0.03262267f, -0.01900152f, 0.69451183f, 0.51742584f, -0.32317051f, -0.31097031f, 
    0.04484628f, -0.01735595f, -0.11638243f, 0.05168469f, 0.05973357f, -0.01032237f, 0.02345268f, 0.04888203f, 
    0.23225836f, 0.06765939f, -0.01267799f, 0.05523011f, -0.08098911f, -0.16939080f, -0.04693284f, 0.04608079f, 
    -0.37913767f, -0.32105988f, -0.23346214f, 0.20809029f, 0.56062883f, 0.05520911f, -0.31601509f, -0.14583220f, 
    0.15555176f, 0.14416164f, -0.01609352f, 0.19606723f, -0.12817524f, -0.09411051f, -0.13147649f, -0.00148046f, 
    -0.41619554f, -0.05530277f, 0.02823739f, -0.07340000f, 0.05405919f, 0.05177553f, 0.12754256f, -0.13198918f, 
    -0.08410913f, -0.19553167f, -0.25121084f, -0.32155806f, 0.25702515f, 0.25358114f, -0.06113821f, -0.23765801f, 
    -0.05457903f, 0.05159286f, -0.25032628f, 0.10483970f, 0.03921840f, 0.10123606f, 0.03538376f, -0.12531945f, 
    -0.28136590f, -0.23726979f, -0.09477261f, -0.00204042f, -0.00088722f, 0.07687181f, 0.07565055f, 0.06062732f, 
    0.04824737f, 0.28409141f, -0.09246814f, -0.23816356f, -0.21564697f, -0.24277417f, 0.04427261f, 0.06661781f, 
    0.09725042f, 0.07853665f, -0.08313320f, -0.11414372f, 0.04108566f, 0.05515275f, 0.16391897f, 0.23215911f, 
    -0.48408070f, -0.48876652f, 0.00474495f, 0.15048116f, 0.12695247f, 0.15035981f, 0.11518084f, 0.06473449f, 
    -0.10607238f, -0.00487510f, -0.11834725f, 0.05118597f, 0.22063279f, 0.04247653f, 0.21370934f, -0.12684117f, 
    -0.14091061f, -0.08038803f, 0.10239585f, -0.08403842f, -0.33490014f, -0.30483937f, -0.00776169f, -0.23375486f, 
    -0.68226248f, -0.13878338f, -0.37298727f, -0.06522352f, 0.29510245f, -0.02511159f, 0.23790920f, -0.01304782f, 
    0.10184526f, 0.04682253f, -0.09046104f, -0.30888209f, 0.59689236f, 0.48984507f, 0.29701081f, 0.10549291f, 
    0.12565437f, 0.20954135f, 0.00334975f, 0.04312125f, 0.02733185f, 0.05725437f, 0.05545035f, -0.17611228f, 
    0.25752991f, 0.07325833f, -0.11245672f, -0.10794943f, -0.12770027f, -0.23181243f, -0.12749808f, 0.01688536f, 
    -0.04333836f, -0.05819186f, -0.00006055f, 0.08294200f, -0.68212456f, 0.02658325f, -0.30405110f, 0.02293697f, 
    0.10444830f, -0.24911223f, -0.03812333f, 0.32168090f, 0.03123363f, -0.08134599f, 0.01666790f, 0.03593954f, 
    0.46617946f, -0.28516111f, 0.01343950f, 0.32247961f, -0.06286826f, -0.02887790f, 0.07250618f, 0.10577617f, 
    0.06199821f, 0.24886671f, -0.08021720f, 0.40481648f, 0.97942054f, -0.00029067f, 0.19476861f, 0.33525687f, 
    -0.25346157f, -0.07055493f, -0.06846095f, -0.22764537f, -0.07490191f, -0.03726773f, 0.13919383f, -0.00932563f, 
    -0.28482667f, -0.64016652f, -0.08775222f, -0.20846978f, 0.23438589f, 0.25416526f, -0.01692350f, 0.20024160f, 
    0.18164581f, -0.06123815f, 0.10809993f, 0.02408447f, 0.25812310f, 0.12496227f, 0.25104061f, -0.06181686f, 
    -0.06869435f, 0.21657898f, 0.05209386f, -0.26866645f, -0.03073156f, 0.02548245f, 0.01393059f, -0.04461933f, 
    0.19972691f, 0.03797814f, -0.11023045f, -0.09739590f, -0.09385334f, -0.15395923f, 0.01521503f, 0.01506474f, 
    0.31282178f, 0.11711004f, 0.13266699f, -0.14725979f, 0.21220756f, -0.04033780f, 0.08495167f, -0.07957456f, 
    -0.35855374f, -0.08593760f, -0.19058956f, -0.12815811f, -0.02127279f, -0.02617832f, -0.01193734f, 0.17141712f, 
    -0.32291198f, 0.21584938f, 0.03535923f, -0.03522214f, -0.14367805f, 0.02138452f, 0.03543916f, 0.07707192f, 
    -0.14169012f, 0.14312047f, 0.04096153f, -0.08927009f, -0.16184056f, -0.13162157f, -0.04010358f, -0.43656132f, 
    -0.16887304f, -0.06407162f, -0.22054139f, 0.14623630f, -0.08207045f, 0.09733087f, -0.02347133f, 0.12876505f, 
    -0.02436829f, 0.21053949f, -0.09653196f, -0.24218100f, -0.13972901f, 0.00228204f, -0.17513037f, -0.05662977f, 
    -0.20621170f, -0.19251935f, -0.29115379f, 0.11618041f, -0.23765850f, -0.25080380f, 0.06996944f, -0.25474340f, 
    -0.00050968f, 0.03996697f, -0.17474163f, -0.17456986f, -0.29003045f, -0.25709900f, -0.34994957f, -0.03324179f, 
    0.35574219f, 0.17437989f, 0.20123115f, 0.38798910f, -0.19215016f, -0.01244047f, 0.00148711f, -0.07182941f, 
    0.13413721f, -0.02088442f, 0.13061799f, 0.11571965f, -0.68150431f, -0.13095082f, -0.18705207f, 0.06311443f, 
    -0.01274005f, 0.09553895f, 0.23600189f, -0.20026848f, 0.02049560f, -0.02272050f, -0.06682305f, 0.14932916f, 
    -0.25593102f, -0.13437673f, -0.26028830f, 0.21979690f, -0.00782207f, 0.12486226f, -0.06350429f, 0.11198731f, 
    -0.05126158f, -0.18961386f, 0.18200222f, -0.21194437f, -0.01879758f, 0.19583787f, 1.08439887f, 1.02287996f, 
    -0.20800059f, -0.03591031f, -0.09172726f, 0.03124161f, 0.03099689f, -0.01297800f, -0.02336393f, -0.02119720f, 
    -0.22377382f, -0.06769752f, 0.42279738f, -0.68606764f, -0.04501858f, -0.20521700f, 0.00610588f, 0.07342656f, 
    0.02267858f, -0.09472153f, 0.09990053f, 0.11638743f, 0.04837707f, -0.24201027f, -0.54299849f, 0.01841183f, 
    -0.16420300f, -0.01685366f, -0.04078567f, 0.05769961f, -0.05655905f, -0.11785070f, -0.00308367f, -0.03734490f, 
    -0.03284964f, 0.06663723f, -0.01121705f, 0.21539463f, 0.04011319f, -0.03609770f, 0.12347758f, -0.01475102f, 
    0.11820193f, 0.01307672f, -0.07014029f, 0.33668634f, -0.91356885f, -0.02851768f, 0.13910219f, 0.25569671f, 
    0.06995846f, 0.01765312f, -0.08785515f, -0.14119487f, 0.03686137f, 0.01007283f, 0.01819381f, -0.10262322f, 
    0.08290937f, 0.23344390f, -0.13768247f, 0.25049573f, -0.07730456f, 0.11510486f, 0.05388817f, -0.24624799f, 
    -0.05267917f, -0.06605695f, -0.08001889f, 0.05205061f, -0.35684535f, -0.61609435f, 0.11094713f, 0.11982635f, 
    -0.15137804f, -0.08293114f, -0.15120758f, 0.33192122f, -0.00166628f, 0.04476017f, 0.06330863f, -0.05532717f, 
    0.22403410f, 0.12640834f, -0.20362996f, -0.06285301f, -0.11811668f, -0.17418724f, 0.02773830f, 0.13521093f, 
    -0.19464068f, 0.10584325f, 0.01706944f, -0.02684612f, -0.39637661f, -0.05576756f, 0.17701712f, -0.62961590f, 
    -0.16719578f, -0.09418774f, 0.19330186f, -0.26528141f, -0.05486816f, -0.07812816f, -0.02746868f, -0.05470749f, 
    -0.26195619f, -0.27337629f, 0.12311562f, 0.42303470f, 0.07558235f, 0.13671784f, -0.01426217f, 0.06237676f, 
    -0.17738719f, -0.06362313f, -0.27175477f, 0.08371916f, -1.19264805f, -0.63359678f, -0.58074409f, -0.63296413f, 
    0.14642350f, -0.15628189f, -0.27610087f, -0.40591392f, 0.00302369f, -0.04527961f, -0.00520537f, -0.04489581f, 
    0.58491284f, 0.31504279f, 0.09424591f, 0.34732679f, 0.00333822f, 0.03660372f, 0.02885761f, 0.07283233f, 
    -0.08068845f, -0.39301801f, 0.19619572f, 0.26809394f, 0.18555415f, 0.40191582f, -0.05939237f, 0.44192570f, 
    -0.01626762f, 0.04624345f, 0.07336137f, -0.36686131f, 0.15114367f, 0.22636299f, 0.16163795f, 0.18130268f, 
    -0.53433651f, 0.22113796f, -0.23533194f, -0.11692498f, -0.02125509f, -0.11176912f, -0.00087841f, 0.03654105f, 
    -0.13620988f, -0.13192999f, -0.01771332f, 0.13061391f, 0.01533801f, -0.07014252f, -0.17543370f, 0.23219049f, 
    -0.37476903f, 0.27470401f, 0.12761888f, 0.09537887f, 0.17966758f, 0.02720131f, -0.05721852f, -0.02028041f, 
    -0.23525771f, 0.15025483f, -0.16127834f, -0.04278988f, -0.11831682f, -0.03354840f, -0.07364930f, -0.01820887f, 
    -0.25005347f, 0.05297138f, 0.15934964f, -0.16827281f, 0.12978166f, -0.27248472f, 0.02935080f, 0.27171528f, 
    0.24858832f, -0.01614498f, -0.03123903f, -0.01386655f, -0.07697051f, 0.06283352f, 0.07126547f, 0.15061618f, 
    -0.39615545f, -0.24841520f, 0.55103546f, 0.19452712f, -0.58252233f, 0.01519920f, -0.33679485f, 0.13561375f, 
    0.08348677f, 0.03827927f, 0.05191311f, 0.43928775f, 0.35757276f, 0.36040172f, -0.22509752f, -0.46254355f, 
    -0.16494836f, -0.29841334f, -0.11911978f, -0.08667043f, -0.04351523f, 0.04507354f, -0.21248040f, 0.23050712f, 
    -0.61155742f, 0.87997210f, -0.36399671f, -0.66323161f, 0.15014322f, 0.02744244f, 0.12106421f, -0.11328421f, 
    -0.38149774f, 0.16380741f, -0.03290932f, 0.10238958f, -0.90875900f, 0.59526294f, -0.64919657f, 0.44753197f, 
    -0.02960599f, -0.27783164f, 0.20908327f, -0.19500042f, 0.04730003f, 0.09004976f, -0.12430376f, -0.11639110f, 
    -0.18261081f, -0.11547619f, -0.00977821f, 0.55361456f, 0.00615354f, 0.12889856f, -0.03267063f, -0.09800176f, 
    0.00752574f, 0.19670238f, 0.12478425f, -0.06925590f, -0.01903754f, -0.30177540f, -0.21998158f, 0.12455873f, 
    0.16801021f, -0.03708927f, 0.00594056f, -0.02994401f, 0.04310535f, -0.02244951f, -0.01593757f, 0.10616995f, 
    -0.47412583f, 1.11087883f, -0.82604378f, -0.16169888f, -0.04395499f, 0.00076473f, 0.06759504f, -0.07274998f, 
    -0.10899292f, -0.20527732f, -0.04885497f, 0.06012046f, -0.24865252f, -0.32888800f, -0.14350882f, 0.36686555f, 
    0.15197212f, 0.00757075f, 0.29864997f, 0.10946656f, -0.01887912f, -0.07588256f, 0.12421112f, -0.04455166f, 
    0.43229690f, 0.10319225f, 0.09629724f, -0.23769709f, 0.26216176f, 0.17035067f, -0.08427109f, 0.02164303f, 
    -0.12738252f, 0.10571422f, -0.13759480f, 0.09709482f, 0.32001808f, -0.35947365f, 0.36337501f, 0.18161672f, 
    -0.07013244f, 0.23971185f, 0.01841919f, 0.06191659f, 0.06387121f, -0.19660881f, 0.02677374f, -0.28643394f, 
    0.82176715f, -0.45526010f, -0.02272726f, 0.09901159f, 0.38707340f, 0.19211774f, 0.10319147f, -0.12559034f, 
    -0.22531897f, -0.04241233f, -0.09983479f, 0.02849498f, 0.29699171f, -0.23484169f, -0.02731228f, 0.23091473f, 
    0.01116595f, 0.08360025f, -0.26271835f, 0.11101673f, -0.03902045f, -0.00871862f, -0.12749091f, 0.20548852f, 
    -0.32079497f, -0.67166030f, -0.32870960f, -0.17759003f, 0.02699729f, -0.01086610f, 0.09986205f, -0.00606983f, 
    -0.41385129f, 0.12256783f, -0.16128892f, 0.09610692f, -0.09478897f, -0.06510226f, -0.43925485f, -0.48606414f, 
    -0.13526835f, -0.02007558f, -0.12070683f, 0.01553688f, -0.14232861f, -0.04711793f, -0.33090192f, -0.14500007f, 
    0.12550636f, -0.04357379f, 0.27700531f, 0.10499151f, -0.28944513f, 0.00560824f, -0.09863172f, -0.34750721f, 
    -0.18685377f, 0.04267329f, -0.00595319f, 0.24147795f, -0.27066639f, -0.16827109f, -0.06703117f, 0.12690365f, 
    -0.13571888f, -0.15003458f, -0.10835616f, -0.18970029f, -0.03694721f, -0.07999170f, 0.04982600f, 0.07513206f, 
    0.56089735f, 0.20472237f, -0.42587176f, 0.60260308f, 0.15521218f, 0.03690797f, 0.15158026f, -0.29360062f, 
    0.12156112f, 0.03433319f, 0.11282288f, -0.10848450f, -0.31434113f, -0.12578830f, -0.11123720f, 0.26128751f, 
    -0.16470371f, 0.09610698f, -0.14140843f, -0.21013261f, -0.02443792f, -0.05118446f, -0.23169315f, -0.09484880f, 
    0.46894339f, -0.45836741f, -0.04617827f, -0.35615000f, -0.07675662f, -0.08506343f, -0.05587364f, 0.04282057f, 
    -0.11666662f, -0.18799056f, -0.14935799f, -0.48318416f, -0.11433439f, 0.17632356f, -0.35759068f, -0.40820706f, 
    0.15435648f, -0.12510943f, -0.03937729f, 0.04000007f, -0.08368811f, -0.10177372f, -0.14262895f, -0.16573925f, 
    0.25785974f, 0.31081375f, 0.11731357f, 0.15090570f, -0.06888830f, -0.15493053f, -0.40308830f, -0.13025475f, 
    0.08812813f, -0.19528548f, 0.00492432f, -0.10291366f, -0.15126602f, 0.10561326f, 0.00628278f, 0.29995856f, 
    -0.32025477f, -0.09794998f, -0.00637118f, 0.04428663f, 0.07920908f, 0.07700164f, 0.01017735f, -0.04161466f, 
    -0.02320005f, -0.28739825f, 0.33209729f, 0.36898413f, 0.13943310f, 0.00232782f, -0.11583684f, 0.07301293f, 
    -0.11308873f, 0.04565781f, -0.02554523f, 0.27968064f, 0.03270060f, 0.24529517f, 0.28643116f, 0.11879815f, 
    0.05063239f, -0.28502622f, -0.02985080f, 0.04494418f, 0.14498585f, 0.10369275f, 0.10909171f, 0.15977605f, 
    0.32605344f, 0.03560919f, -0.22191608f, 0.08093638f, -0.13673005f, -0.00174007f, -0.08588699f, 0.03806013f, 
    0.09846379f, -0.44513255f, -0.24371913f, -0.17067672f, 0.02536624f, 0.56307340f, 0.11657850f, 0.42368418f, 
    0.03597659f, 0.03007317f, 0.22940254f, 0.16200179f, 0.10535883f, 0.00620987f, -0.05557087f, -0.04512283f, 
    0.22757809f, 0.14266029f, -0.35145006f, 0.13744137f, 0.03393439f, -0.09033871f, -0.01486996f, 0.18033427f, 
    0.25502950f, -0.14445043f, -0.00974229f, -0.18531209f, -0.18987913f, -0.02488153f, 0.05074818f, -0.04702176f, 
    0.01543694f, -0.17944336f, 0.04130007f, -0.05089581f, 0.33025795f, -0.06735627f, 0.24845448f, 0.14939688f, 
    -0.05608265f, -0.09468225f, -0.18739451f, -0.16906880f, 0.18715085f, 0.09381780f, 0.10483381f, -0.00761806f, 
    0.19767024f, 0.15092443f, 0.08287858f, 0.19332221f, 0.17472386f, -0.81479239f, 0.23838785f, -0.44343123f, 
    -0.37383881f, -0.11643996f, -0.23493649f, 0.14676312f, -0.06162458f, -0.26923379f, 0.02408485f, -0.28379187f, 
    0.03648097f, -0.12746727f, 0.57353330f, 0.01376494f, -0.08063997f, 0.00624202f, -0.00404985f, 0.11164100f, 
    0.18207091f, -0.01656667f, -0.10974680f, 0.03511133f, -0.35359946f, 0.13692768f, -0.06702827f, -0.58367330f, 
    0.10322440f, -0.16504064f, 0.00966808f, -0.04565761f, -0.02504495f, -0.06435039f, -0.04253784f, 0.01600940f, 
    -0.25458503f, -0.21278384f, -0.21934782f, 0.27481681f, 0.31928062f, 0.04736020f, 0.02608583f, -0.00670474f, 
    0.00181890f, -0.08887692f, -0.14242081f, -0.18855114f, -0.03680528f, -0.49425977f, 0.78969723f, 0.02611509f, 
    -0.12389965f, 0.01939190f, 0.11424702f, 0.06591574f, 0.01453483f, 0.16062048f, -0.00238212f, 0.06815936f, 
    -0.12017924f, -0.07759265f, 0.00418209f, -0.09446400f, 0.07808361f, 0.10630735f, -0.00526009f, -0.15565695f, 
    0.13030984f, -0.14612600f, -0.25047085f, 0.11228482f, 0.00116267f, -0.66020477f, -0.04002403f, -0.21723749f, 
    0.26404354f, 0.17680843f, -0.05193503f, 0.13011891f, 0.18906203f, 0.00154938f, -0.17527114f, -0.18544750f, 
    -0.05582914f, -0.00142301f, -0.00949215f, -0.27070236f, -0.09515720f, 0.04529503f, 0.10294202f, 0.23456067f, 
    0.09067804f, -0.01103524f, -0.11819095f, 0.04390766f, -0.22515160f, 0.20543024f, 0.23596212f, -0.17507744f, 
    0.23712765f, 0.02824860f, 0.04978037f, 0.32222155f, -0.08348389f, 0.06726871f, 0.02035509f, 0.18939005f, 
    -0.04240336f, -0.17237210f, -0.02005032f, 0.30124590f, 0.16717775f, 0.05985605f, -0.10363678f, 0.12453635f, 
    0.23856147f, -0.02025792f, -0.19507356f, -0.14453605f, -0.00439543f, 0.37646037f, -0.09292217f, -0.25441232f, 
    0.06212023f, 0.25068292f, -0.11763129f, -0.13772811f, -0.16205649f, 0.05977258f, 0.02146347f, -0.14412445f, 
    -0.35212058f, -0.46020520f, 0.10306229f, 0.11419148f, -0.16035056f, -0.09103829f, -0.08912194f, -0.01144086f, 
    0.22465566f, 0.17422621f, 0.00550660f, 0.09231461f, 0.03990527f, 0.29585728f, 0.02243488f, 0.25799489f, 
    0.29848674f, -0.00697475f, 0.03185710f, -0.13863324f, -0.07205258f, 0.04213833f, 0.12596343f, 0.19770531f, 
    -1.28143203f, -0.58799285f, -0.47072130f, -0.32208750f, -0.01420915f, -0.10911944f, 0.13292404f, 0.04396747f, 
    0.07541918f, -0.20856552f, 0.24846832f, 0.01856962f, 0.21369313f, -0.05954512f, -0.17073981f, -0.06210576f, 
    -0.09328451f, -0.04860205f, 0.08264155f, 0.12618791f, -0.26259145f, -0.44612575f, -0.07038628f, -0.50278723f, 
    -0.09279801f, -0.15244783f, -0.14417779f, 0.06811152f, 0.01383061f, -0.01783332f, -0.08203109f, -0.04873089f, 
    0.07168686f, 0.05583882f, 0.12447461f, -0.31749326f, 0.33763433f, 0.08458887f, 0.03218495f, 0.27589965f, 
    0.36791241f, -0.23640017f, -0.05637930f, 0.11909071f, 0.07005742f, 0.12786542f, 0.11714373f, 0.09019785f, 
    0.17406246f, -0.67743003f, -0.80003017f, -0.31424198f, -0.25349051f, 0.06098880f, -0.18589817f, 0.04884332f, 
    0.02411092f, 0.14061435f, 0.13492548f, 0.24523634f, -1.25788629f, -0.51402694f, 0.74418020f, -0.67006725f, 
    -0.05630702f, -0.25322866f, 0.13803805f, -0.12618905f, -0.18948635f, -0.00948751f, -0.00970184f, 0.06532661f, 
    0.14282463f, -0.76947397f, -0.31065062f, -0.32016540f, 0.01996616f, 0.18547246f, 0.15530513f, 0.00063928f, 
    -0.01183657f, -0.02538805f, -0.09355089f, 0.04791170f, -0.19732764f, -0.61071080f, -0.78750765f, 0.31974950f, 
    -0.23876292f, 0.14067695f, -0.16608317f, 0.10302046f, 0.00429433f, 0.06951060f, -0.02449065f, -0.08761945f, 
    0.19545986f, -0.05317973f, 0.35924304f, -0.04044897f, 0.03441451f, -0.01103813f, -0.17761816f, 0.08498215f, 
    -0.01887634f, 0.08774349f, 0.24984236f, -0.31854811f, 0.04719699f, 0.12506676f, -0.07345235f, -0.07245167f, 
    0.04326503f, 0.05639651f, 0.15138060f, -0.01996233f, 0.09428253f, 0.04253962f, 0.04255396f, 0.20107085f, 
    0.66953093f, 0.50715429f, -0.15496832f, 0.21385929f, 0.01788702f, -0.41940540f, -0.32522416f, 0.23327273f, 
    -0.06790148f, 0.05605088f, 0.03461986f, -0.15612513f, -1.20671725f, -1.10015023f, 0.18898115f, -0.08725633f, 
    -0.09889482f, -0.19232877f, 0.02042496f, -0.14785221f, 0.01774542f, 0.07235691f, -0.12952867f, -0.02670598f, 
    -0.24473256f, -0.35695416f, 0.09225498f, 0.24196608f, 0.31701520f, 0.17588463f, 0.03849998f, -0.19829801f, 
    -0.08634107f, -0.11007124f, 0.00146991f, 0.15718886f, -1.17231095f, -0.25396985f, 0.60841537f, 0.01584459f, 
    -0.22895630f, 0.22608440f, 0.13764425f, -0.37987110f, 0.01278882f, -0.05531176f, 0.05071219f, 0.19311483f, 
    -0.29057130f, -0.04434112f, 0.25292319f, 0.17787424f, -0.13940942f, -0.14912280f, -0.00531562f, 0.18471891f, 
    -0.02564315f, 0.09787750f, 0.23561808f, 0.20558235f, -0.79394424f, -1.52726960f, -1.14932728f, -0.53440547f, 
    -0.09188946f, -0.21141919f, 0.13442340f, -0.44264007f, 0.07064863f, -0.04011969f, -0.06358051f, -0.04707666f, 
    -0.66684860f, 0.06055756f, 0.90640181f, 0.51811779f, -0.01940376f, 0.02730478f, 0.18378815f, -0.13087392f, 
    0.03612327f, 0.36664543f, 0.00655892f, 0.15282965f, 0.50180227f, 0.50088930f, 0.01344759f, -0.02466708f, 
    -0.10584980f, 0.07836467f, 0.10647233f, 0.25010508f, 0.22439013f, 0.23655234f, 0.05065170f, 0.10437442f, 
    0.20737268f, 0.23940958f, -0.01235593f, -0.27264571f, 0.03908938f, 0.04815782f, -0.08712608f, -0.04725030f, 
    -0.00085690f, 0.04551711f, -0.40302020f, -0.28152800f, -0.27473405f, 0.07811315f, 0.37840283f, -0.34851274f, 
    -0.18435881f, -0.19224331f, 0.10571189f, 0.06934426f, -0.21789075f, 0.22492209f, -0.12914439f, 0.08860627f, 
    0.55824459f, -0.88567817f, 0.29911682f, 0.41229317f, 0.16234946f, 0.18276414f, -0.16557126f, -0.10017222f, 
    -0.03159450f, -0.15234332f, -0.35720909f, 0.00240670f, -0.09315976f, -0.90276092f, 0.01869496f, -0.84757292f, 
    0.00121749f, 0.06559706f, -0.08553119f, 0.35235921f, 0.16445115f, 0.06048980f, 0.02186837f, 0.00120104f, 
    -0.15945104f, 0.07517876f, -0.09727617f, -0.07924833f, -0.13368666f, -0.07883463f, -0.01114416f, 0.08306305f, 
    0.08021687f, -0.03715711f, 0.12809235f, -0.04501459f, 0.40315703f, -0.77369583f, 0.28450340f, 0.23367766f, 
    -0.01022190f, 0.06355597f, -0.18776618f, -0.06706085f, 0.11143770f, 0.04253254f, -0.00972678f, -0.05127624f, 
    -0.00918595f, 0.06138745f, 0.00628950f, -0.41133717f, -0.11437253f, 0.06850581f, 0.12212662f, 0.04479639f, 
    0.06328971f, -0.23343994f, -0.03563163f, -0.61676627f, 0.19767240f, 0.14665125f, 0.09910268f, -0.09023952f, 
    -0.20988457f, 0.21189705f, -0.03593475f, -0.08665480f, -0.07949344f, -0.04934340f, 0.04661487f, 0.04595742f, 
    -1.10929275f, -0.96350861f, -0.19767611f, -0.06747889f, -0.25445977f, -0.01403020f, 0.06702552f, -0.06505352f, 
    0.08151487f, 0.04264892f, 0.08927023f, 0.10026874f, 0.16260694f, -0.49269304f, 0.11849056f, -0.61362219f, 
    0.21941976f, -0.05680568f, -0.37703514f, 0.14639078f, 0.07779750f, -0.02818203f, 0.05160575f, -0.01407415f, 
    0.08526255f, 0.33706686f, -0.10565377f, -0.15415791f, -0.07233484f, 0.08758213f, -0.08142386f, 0.00501837f, 
    -0.55390447f, 0.33839685f, 0.04035489f, 0.04351394f, -0.78322685f, 0.20595792f, -0.04334156f, -0.19839947f, 
    0.02775233f, -0.05894586f, 0.16442032f, 0.15522835f, -0.01291839f, -0.22352137f, 0.04586193f, -0.02851526f, 
    0.69603306f, -0.18820876f, -0.26005715f, -0.60098159f, 0.01035486f, 0.04099247f, 0.06842919f, -0.10488277f, 
    -0.05877135f, -0.08651248f, 0.22210319f, -0.09616130f, -0.73972160f, -0.21583924f, -0.59175819f, 1.03931069f, 
    0.02378374f, 0.03467633f, -0.02693795f, 0.16957575f, 0.05831876f, -0.01453778f, -0.11366466f, 0.01793285f, 
    0.65409833f, -0.01778948f, 0.18118492f, -0.27454334f, 0.02617330f, -0.00089790f, -0.11728511f, -0.00233167f, 
    0.17313264f, -0.11410162f, -0.11086670f, -0.04005393f, -0.31230083f, -0.32336348f, -0.22899696f, 0.02695814f, 
    -0.26813591f, -0.02212650f, 0.03669627f, -0.02252383f, 0.29481518f, -0.09570139f, 0.14264700f, -0.21306755f, 
    0.13115722f, 0.05329755f, 0.08798160f, -0.17200951f, 0.00448748f, -0.01327174f, 0.01357726f, -0.02976919f, 
    0.11776020f, -0.05883722f, -0.21621166f, -0.02739838f, 0.54575753f, 0.47852322f, -0.46649337f, -0.13377312f, 
    -0.07620174f, 0.11948460f, -0.20522019f, -0.31954300f, 0.09995636f, 0.00282532f, -0.07071404f, -0.16308333f, 
    0.71456760f, -0.04694150f, -0.61919129f, -0.45614508f, 0.27208862f, -0.04646233f, 0.21371515f, 0.37170649f, 
    0.14972727f, 0.08420578f, 0.26098517f, 0.21317114f, -0.35118943f, -0.95294023f, -0.92946458f, 0.13509296f, 
    0.09893287f, -0.09569087f, 0.18024017f, 0.00201778f, -0.21073598f, -0.09815583f, 0.04754554f, 0.02895433f, 
    -0.63544768f, 0.38163069f, 0.05772704f, 0.18160410f, -0.02549929f, -0.22453237f, 0.08594254f, -0.01818390f, 
    -0.42219749f, -0.06331413f, -0.22767758f, -0.09622132f, 0.85640299f, 0.12174652f, 0.12960581f, -0.49755716f, 
    0.33561397f, -0.14025301f, -0.15072656f, -0.17812821f, -0.05542966f, 0.37144241f, 0.35910085f, 0.25257289f, 
    0.02804138f, 0.16721560f, -0.10179058f, -0.11469641f, -0.11416057f, -0.09875584f, 0.00920639f, 0.17062685f, 
    0.27100727f, 0.01377076f, -0.05867172f, 0.05677929f, -0.55643094f, 0.02440290f, 0.32536680f, -0.02594985f, 
    -0.07666474f, 0.18189536f, -0.09743355f, 0.03002910f, 0.13117144f, -0.17294364f, -0.05128470f, 0.16706496f, 
    -0.73777175f, -1.14048457f, -0.56004333f, 0.13943930f, 0.07153086f, 0.19152632f, 0.09960194f, 0.19688514f, 
    -0.24708052f, 0.04203636f, 0.07774752f, 0.04026452f, 0.18568435f, -0.06142180f, -0.71321452f, -0.20789744f, 
    0.12391472f, -0.12910658f, 0.03525276f, 0.10100767f, -0.24007747f, -0.05311948f, -0.05544544f, -0.00120201f, 
    0.25322509f, 0.01058424f, -0.19908985f, -0.16891852f, -0.06721217f, -0.13961901f, -0.00138802f, 0.04833283f, 
    0.14815655f, 0.02999374f, 0.15929815f, -0.09858356f, 0.04680742f, -0.41235507f, -0.66123581f, -0.04934350f, 
    -0.28660312f, 0.10760677f, -0.06899954f, -0.17967384f, -0.06575625f, -0.32592377f, -0.21394241f, -0.22602288f, 
    -0.16874209f, -0.24103874f, -0.16452089f, -0.29445767f, 0.08543335f, 0.16594844f, 0.22819823f, 0.05521136f, 
    0.12223087f, 0.24990623f, 0.26729643f, 0.18225555f, -0.29310182f, -0.32423621f, 0.44565201f, -0.08046319f, 
    -0.04575158f, 0.00401556f, -0.29054254f, 0.07816708f, -0.11152758f, 0.17907740f, 0.16485703f, -0.01013791f, 
    -0.37284672f, -0.13127956f, -0.08313731f, 0.49100500f, -0.07245393f, -0.02208559f, 0.22060545f, -0.02053824f, 
    -0.02625584f, 0.30462807f, -0.25383994f, -0.11135753f, -0.28416136f, 0.11823062f, 0.00606806f, 0.29002473f, 
    -0.01501006f, 0.09173004f, 0.04381260f, 0.26769519f, -0.45335448f, -0.17223331f, -0.46202022f, -0.54794359f, 
    -0.56231165f, 0.06195518f, 0.05275181f, -0.28059903f, 0.00768636f, 0.02989803f, -0.03311988f, -0.13831052f, 
    -0.16591999f, -0.04842810f, 0.01616143f, 0.14977157f, 0.28847194f, 0.11216454f, -0.59884381f, 0.01058698f, 
    0.01185629f, -0.13037223f, 0.26004618f, -0.00536780f, 0.27423236f, 0.26399806f, 0.11539298f, 0.26285207f, 
    -0.43634245f, -0.09138436f, -0.45185366f, 0.49251670f, 0.01738281f, 0.13526905f, 0.09203872f, -0.04099097f, 
    -0.01361353f, 0.06326589f, -0.02031327f, -0.05325141f, -0.20265001f, -0.27451020f, -0.67104179f, -0.17481913f, 
    -0.35269886f, 0.08284879f, 0.05042117f, 0.18134053f, 0.22295961f, -0.03787641f, 0.10385611f, -0.01122461f, 
    -0.19547552f, 0.09983491f, -0.61563408f, 0.12211385f, 0.19704196f, 0.28552353f, 0.34352347f, 0.14682171f, 
    0.06234107f, 0.07696277f, 0.00795069f, -0.10320977f, -0.02771468f, -0.54353124f, 0.02093030f, 0.38826084f, 
    0.03716878f, 0.13155910f, 0.05089677f, -0.22483106f, 0.03843438f, -0.20382230f, -0.01748734f, 0.01462195f, 
    0.01532752f, 0.02081790f, 0.10144746f, 0.05598808f, 0.17511649f, 0.09431801f, -0.47400805f, 0.17312919f, 
    0.01678720f, 0.16343096f, 0.08185720f, -0.28828141f, 0.09522868f, -1.01574063f, 0.01768501f, -0.98419833f, 
    0.10833555f, 0.09634920f, -0.12166283f, 0.24462166f, -0.25890490f, -0.25912729f, -0.03790624f, -0.17259304f, 
    0.00194196f, 0.65544087f, 0.63386106f, -1.11036110f, -0.02766986f, -0.53584659f, 0.00928763f, -0.10036937f, 
    -0.22846107f, 0.09411744f, 0.06556372f, 0.16358833f, -0.52081168f, -0.24990754f, 0.13221180f, -0.22894838f, 
    -0.31465149f, 0.11456532f, -0.25491530f, -0.03929348f, 0.16224802f, -0.08632489f, 0.05693419f, 0.04874822f, 
    -0.58879852f, -0.25425416f, -0.12017449f, 0.02695122f, -0.06595652f, 0.21001798f, -0.08834056f, 0.00802161f, 
    -0.16256823f, -0.05410933f, -0.05299088f, -0.00811825f, -0.00031708f, 0.60627985f, 0.50143498f, -0.70013505f, 
    -0.07691938f, -0.12841043f, -0.24208747f, 0.40706518f, 0.15968184f, 0.11307386f, 0.02720181f, -0.03138078f, 
    0.42786223f, 0.57027876f, 0.28852570f, 0.50622261f, 0.12815461f, -0.34344393f, -0.25852573f, -0.22590081f, 
    -0.20855327f, -0.18358937f, 0.04555568f, -0.29947445f, 0.02034566f, 0.26223680f, -0.18580407f, -0.05389600f, 
    -0.28787890f, -0.25142124f, 0.41529313f, 0.16362633f, -0.04701464f, 0.08043531f, 0.03017410f, -0.02344787f, 
    0.30815411f, 0.06583940f, 0.31992239f, -0.14470688f, 0.10824284f, 0.00621017f, -0.19593874f, -0.39311057f, 
    0.08516346f, 0.04114887f, -0.00563865f, 0.11582102f, -0.42465645f, 0.54781646f, 0.51099163f, -0.30707189f, 
    -0.03623972f, -0.28621987f, -0.00393184f, -0.25547650f, 0.00353017f, 0.19988385f, 0.16139533f, 0.25553083f, 
    -0.11492430f, -0.42325050f, 0.13767031f, 0.19747411f, -0.04461978f, 0.11177461f, 0.02536359f, -0.00760523f, 
    0.18517092f, -0.03281494f, 0.18791528f, 0.03675431f, -0.32449621f, 0.23706995f, -0.52975893f, 0.91901273f, 
    0.04285306f, -0.15795568f, -0.28777829f, -0.10247052f, 0.02594042f, -0.24484925f, -0.07653727f, -0.12162484f, 
    -0.72842866f, 0.86879873f, -0.31667465f, 0.07467787f, 0.06577070f, -0.07336587f, 0.33271387f, 0.18354511f, 
    -0.12298869f, 0.17931323f, -0.36469361f, -0.00754473f, 0.11502086f, -0.43714842f, -0.30923674f, 0.14999892f, 
    0.08450411f, -0.24624220f, -0.06869354f, -0.02394760f, -0.17371278f, 0.24070975f, 0.13509117f, -0.23556481f, 
    -0.09181742f, -0.31037626f, 0.00709386f, -0.33472869f, -0.57819742f, -0.27820852f, 0.09846779f, -0.18106505f, 
    -0.08519849f, 0.20181501f, -0.07800831f, -0.17147176f, -0.79651725f, 0.24091056f, -0.02776798f, 0.00950214f, 
    -0.21694626f, -0.02702930f, 0.10609771f, -0.29481515f, 0.03876181f, 0.22871545f, 0.34736961f, 0.25172195f, 
    -0.29697055f, -0.13508300f, 0.12689020f, 0.55636179f, -0.14543085f, 0.14325666f, -0.23300730f, -0.09920695f, 
    -0.25462031f, -0.15136304f, -0.29455900f, 0.38141975f, -0.38506705f, 0.73250240f, 0.61078954f, 0.10007769f, 
    -0.17623693f, 0.11677380f, -0.43973428f, 0.24191198f, -0.10504685f, 0.14570521f, 0.19961829f, 0.13826142f, 
    -0.14153071f, -0.02947821f, 0.27820566f, 0.26150182f, -0.01161313f, -0.13581708f, 0.22248407f, 0.05434325f, 
    -0.14068155f, -0.23698014f, 0.28439677f, 0.07612837f, -0.43699285f, -0.30463740f, -0.01633335f, 0.23896810f, 
    0.16056629f, -0.21014689f, 0.25291997f, 0.13906956f, -0.30029649f, -0.00489055f, 0.33474278f, 0.35957986f, 
    -0.28186813f, 0.06197119f, 0.58866602f, -0.25279430f, 0.07382159f, -0.15791805f, -0.10951630f, -0.15713829f, 
    -0.20131211f, 0.15512446f, 0.08979706f, -0.43397871f, 0.02647666f, -0.40401372f, -0.19150437f, 0.42023426f, 
    -0.18192226f, 0.03950916f, -0.23240225f, -0.15113835f, -0.04575172f, -0.01664295f, -0.23874925f, -0.45832670f, 
    0.04655478f, 0.24589799f, 0.10621711f, -0.63236094f, -0.07495851f, -0.15892214f, 0.18613245f, -0.12546475f, 
    0.22150700f, 0.29236799f, 0.22888002f, -0.10453456f, -0.14987093f, -0.82542920f, 0.02578333f, -0.05577015f, 
    -0.19528170f, 0.15915346f, 0.13460918f, -0.06240587f, 0.04758132f, 0.14817457f, -0.02487558f, 0.16086015f, 
    0.38659656f, 0.28491658f, 0.20453329f, 0.07507391f, 0.13605364f, -0.07303467f, -0.16322874f, -0.02484172f, 
    -0.38372371f, -0.04446407f, -0.14282970f, -0.26594353f, 0.26311135f, -0.04641526f, -0.00696586f, 0.04639020f, 
    -0.01132734f, -0.51342022f, 0.03795195f, 0.00679915f, -0.11148154f, -0.33418244f, -0.73767841f, -0.70896292f, 
    -0.22054906f, -0.22928703f, -0.93091232f, -0.54970896f, -0.02751757f, -0.07130691f, -0.15232624f, 0.14581683f, 
    0.04997938f, 0.11596289f, -0.12289944f, -0.09023914f, -0.07715405f, 0.56988877f, 0.61829025f, 0.40755937f, 
    -0.02874008f, 0.12668872f, -0.08481944f, 0.08922328f, -0.03240175f, 0.16908015f, 0.27816477f, -0.06714090f, 
    0.18919764f, -1.12571478f, -0.30464420f, 0.34163201f, 0.19239871f, -0.24602367f, 0.01977476f, -0.01823600f, 
    0.11073285f, 0.17074148f, 0.30005050f, 0.12482025f, -0.33030945f, 0.63404799f, -0.10609686f, 0.15801923f, 
    -0.23593107f, -0.02050081f, 0.28900516f, -0.13553691f, -0.08288635f, -0.03525492f, -0.01695009f, -0.06665611f, 
    0.73751867f, 0.33601886f, 0.80807912f, -0.12762538f, -0.15167706f, -0.01543285f, -0.35184774f, 0.08067018f, 
    -0.14682874f, 0.05968904f, 0.16097941f, -0.09252037f, 0.00116304f, 0.46032944f, -0.48236442f, 0.00493740f, 
    0.25674275f, 0.02536542f, 0.26366878f, -0.23254274f, -0.03927398f, -0.09284315f, -0.00799016f, -0.24945875f, 
    -0.72786134f, 0.31772166f, -0.46446314f, 0.20343085f, 0.02070508f, -0.05597835f, 0.21767591f, 0.01977321f, 
    -0.05316640f, 0.16925232f, 0.52933949f, -0.16488124f, -0.02814317f, 0.64319032f, -0.49533725f, 0.59615999f, 
    0.09109250f, -0.15551849f, 0.31035942f, 0.48316291f, -0.09657285f, -0.09831476f, -0.05160668f, 0.03128807f, 
    -0.48281074f, -0.16335171f, 0.12814538f, -0.10266139f, 0.09704486f, 0.08235158f, 0.21208082f, 0.20556961f, 
    -0.11470773f, 0.00177921f, -0.19617541f, 0.05908877f, -0.10683274f, 0.23879328f, -0.50321186f, 0.19209616f, 
    -0.26290858f, -0.01256815f, 0.14432919f, -0.44053626f, -0.00339504f, -0.06835593f, -0.23015168f, -0.31875798f, 
    -0.65257591f, -0.10565728f, 0.27831802f, -0.52055192f, 0.22352542f, 0.12507206f, 0.31891358f, -0.18359980f, 
    0.11146210f, -0.00297597f, -0.05263342f, 0.15911642f, -0.39858186f, -0.36744347f, -0.16974780f, 0.17144565f, 
    -0.18478270f, -0.19595000f, -0.08052293f, 0.05005290f, 0.15492329f, 0.08974527f, -0.02246028f, 0.04653250f, 
    -0.64350653f, -0.18789017f, -0.77807373f, 0.14595094f, 0.28376180f, -0.08055364f, -0.13393401f, -0.15828176f, 
    -0.14830691f, -0.34135133f, -0.11894586f, 0.03816503f, 0.14390954f, -0.37007898f, -0.14385447f, -0.24706985f, 
    -0.25105417f, -0.17686155f, -0.32501805f, -0.07537865f, 0.06369765f, -0.04725568f, -0.07967663f, -0.02612899f, 
    -0.18334977f, 0.16218062f, -0.48905876f, -0.09840532f, 0.16349095f, -0.02682353f, -0.10097652f, 0.02525870f, 
    -0.16401768f, 0.11790142f, 0.27348474f, -0.04870754f, 0.07822275f, -0.46704572f, 0.34901455f, -0.52436519f, 
    0.14152624f, 0.17182638f, -0.06634045f, 0.20604512f, 0.05152680f, 0.44565329f, 0.11951525f, 0.09169964f, 
    -0.00038757f, 0.01401584f, 0.19402640f, 0.05598472f, 0.03958246f, -0.26608327f, 0.28748459f, 0.22547218f, 
    -0.13974190f, 0.08454575f, 0.00350300f, -0.22189571f, -0.22628781f, -0.41530746f, 0.71474975f, -0.17741875f, 
    0.20513323f, 0.32109648f, -0.30870616f, 0.24315099f, 0.11690146f, -0.14758179f, 0.18151745f, -0.08528384f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.35363215f, 0.18339750f, 0.14761527f, -0.24017504f, -0.25310177f, 0.07839016f, 0.17264172f, -0.23479261f, 
    0.23471341f, 0.05298128f, 0.02613853f, -0.07855190f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
