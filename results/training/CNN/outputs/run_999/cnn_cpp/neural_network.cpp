#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45777890f, -0.47709608f, -0.27341026f, 0.05635572f, -0.16693512f, 0.18439628f, 0.49397489f, 0.00212884f, 
    0.29758477f, 0.05715943f, 0.04209875f, -0.04296143f, -0.21718103f, 0.04272468f, 0.01192687f, -0.00206120f, 
    -0.28341910f, -0.26152074f, 0.31254682f, 0.04868272f, 0.47067562f, 0.49223632f, 0.46620417f, -0.10300069f, 
    -0.14746355f, 0.45085543f, -0.44402677f, -0.44474837f, 0.02696779f, 0.09516869f, 0.18841060f, 0.22915800f, 
    0.12366509f, -0.29571179f, -0.05712771f, -0.02027529f, 0.74384576f, -0.35694334f, -0.31032193f, 0.27464408f, 
    -0.41737467f, 0.06249353f, -0.30411568f, 0.10777955f, 0.17089555f, 0.07821915f, -0.29488802f, 0.12195737f, 
    0.45040843f, 0.11460133f, 0.24273643f, -0.02369078f, 0.34357175f, 0.51805556f, 0.52495992f, 0.40452942f, 
    -0.06103654f, 0.29745418f, 0.46604794f, 0.23850957f, 0.13728087f, 0.55157000f, -0.09905502f, -0.46103799f, 
    -0.42592520f, 0.16793685f, -0.24760169f, -0.18793693f, 0.21376109f, -0.17755814f, -0.08935396f, 0.10900305f, 
    -0.15269990f, -0.01463168f, 0.10708255f, -0.51429677f, -0.52230620f, -0.58783525f, -0.30662918f, 0.16310281f, 
    -0.58267456f, -0.61002767f, 0.84794533f, 0.20816991f, -0.18223009f, -0.29046988f, -0.18330266f, -0.25884941f, 
    -0.19162753f, -0.24844363f, -0.14955363f, -0.09057593f, 0.26175052f, -0.08832480f, -0.72230440f, -0.39043891f, 
    0.21634117f, 0.29403412f, -0.00275482f, 0.33539036f, -0.51000887f, 0.66825253f, -0.35622650f, -0.28811413f, 
    0.57899910f, -0.51111877f, 0.57867742f, 1.09815776f, -0.19101696f, -0.51702243f, -0.30404916f, 0.04973614f, 
    -0.12849720f, -0.08506254f, 0.02125486f, 0.32355061f, -0.26637164f, -0.20966110f, -0.00079792f, -0.13256048f, 
    0.10674427f, -0.17412893f, 0.02609045f, 0.10228582f, -0.17966874f, 1.08252263f, -0.58829612f, -0.10809630f, 
    0.57319683f, -0.30262211f, 0.05953309f, -0.08699050f, -0.29736245f, -0.03111963f, 0.30492175f, -0.23878948f, 
    0.00129825f, -0.43239579f, -0.37638766f, 0.29128039f, -0.16448516f, -0.09041653f, -0.16007811f, 0.33876804f, 
    -0.36275917f, -0.64071923f, -0.22212726f, -0.15133938f, -0.54303563f, -0.84539080f, -1.01646852f, -0.67071354f, 
    -0.29139423f, 0.39560020f, 0.52309012f, -0.53702927f, -0.47539034f, -0.11417398f, -0.30265999f, 0.44971865f, 
    0.35704091f, -0.00072571f, 0.58814180f, 0.45967105f, -0.27355421f, -0.13963529f, -0.16504054f, -0.14112957f, 
    -0.10860490f, 0.03697191f, 0.37951252f, 0.18427923f, 0.18974894f, 0.01184902f, 0.38247001f, -0.95240337f, 
    -0.54115170f, -0.81107742f, -0.41192609f, 0.54727012f, 0.37965062f, -0.37646225f, -0.87978601f, -0.41103449f, 
    -0.11450503f, -0.17047024f, 0.12959301f, 0.01972849f, 0.19312151f, -0.51245123f, 0.33209649f, -0.21412799f, 
    -0.16893895f, 0.27295506f, -0.25724205f, -0.00502983f, -0.31419143f, -0.18839879f, -0.35879487f, -0.49482200f, 
    0.44144303f, -0.04512794f, 0.19074100f, 0.34446287f, 0.24864973f, -0.17483149f, -0.25307417f, -0.42428011f, 
    -0.33018813f, 0.02491774f, 0.12998196f, 0.09836327f, 0.24225104f, 0.04493682f, 0.13427851f, -0.14311627f, 
    0.15140775f, -0.11109859f, 0.15963988f, 0.39250097f, 0.34882802f, 0.27093130f, 0.29116371f, -0.24695486f, 
    0.05425821f, 0.67803872f, 1.03687203f, 0.28316152f, 0.24440490f, -0.28595400f, -0.15023632f, -0.34555459f, 
    -0.44213700f, -0.18365654f, -0.02174834f, 0.08097138f, -0.00265376f, 0.25398415f, -0.35523880f, -0.62095267f, 
    -0.07567972f, -0.04209419f, 0.14569873f, 0.19392297f, -0.16239733f, 0.03804765f, 0.12281294f, -0.21863298f, 
    -0.02032137f, 0.28358606f, -0.01461457f, 0.10647821f, -0.02325532f, 0.07539301f, -0.13126393f, 0.04428279f, 
    0.26525888f, -0.54816663f, 0.27464670f, 0.18007509f, -0.21568432f, -0.48696640f, 0.17559151f, 0.81738693f, 
    -0.29605106f, -0.14975902f, -0.42123410f, -0.06423574f, 0.45870158f, 0.27214921f, -0.44957766f, -0.02428775f, 
    0.06070290f, 0.29101774f, 0.06921756f, 0.66938376f, -0.08880628f, -0.78384554f, -1.02147007f, -0.48804817f, 
    0.19541395f, -0.13001902f, 0.38549417f, -0.01748606f, -0.35759926f, 0.07627498f, -0.46292108f, -0.11528312f, 
    -0.01437737f, -0.36805135f, -0.60868746f, -0.34533438f, -0.13701688f, -0.05921181f, -0.34951544f, 0.33744028f, 
    0.22042957f, 0.17217489f, -0.00664945f, 0.26538149f, -0.90536106f, 0.05206329f, -0.42179722f, -0.14237507f, 
    -0.22484790f, -0.49465963f, -0.62607795f, -0.29320723f, -0.51583022f, -0.56182653f, 0.20265144f, -0.10066753f, 
    -0.24035521f, -0.73302525f, -0.17893569f, -0.03652139f, -0.15397947f, -0.36155051f, -0.08130350f, -0.14113344f, 
    -0.12021683f, 0.12975003f, 0.06738911f, -0.25298452f, -0.06522784f, -0.57263184f, -0.01822623f, 0.57726002f, 
    -0.19079232f, 0.53209060f, -0.00925042f, 0.33085108f, 0.20882277f, -0.02979478f, 0.04742306f, 0.04645980f, 
    -0.42741579f, 0.44493863f, -0.03817461f, -0.06676821f, -0.01306612f, -0.48880056f, -0.32217684f, 0.37551743f, 
    -0.48968393f, -0.09761705f, -0.15937023f, 0.35430038f, -0.19439839f, 0.10634939f, -1.07713246f, -1.21283698f, 
    -0.51502264f, -0.07840610f, 0.11054294f, 0.98226094f, 0.49896041f, 0.14933951f, -0.03549891f, 0.72507417f, 
    0.29340070f, 0.04658374f, -0.03897354f, 0.05616860f, 0.32027853f, -0.23785439f, -0.08100526f, -0.12360649f, 
    -0.09546226f, -0.22033890f, -0.25161895f, -0.11693485f, 0.01162997f, 0.14239874f, 0.02028919f, 0.65025276f, 
    0.97465956f, 0.08293471f, 0.20540296f, -0.57597476f, -0.64877993f, -0.32753125f, 0.08402147f, 0.46749613f, 
    0.08289799f, -0.05359743f, -0.14293867f, -0.09867781f, 0.21447268f, -0.22784422f, 0.09121872f, -0.05486596f, 
    0.11163878f, -0.35201418f, 0.02310604f, -0.13255516f, 0.12829655f, -0.11028452f, -0.10536485f, -0.11487868f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.19765927f, 0.44374460f, -0.03667837f, -0.05816713f, 0.41632706f, -0.03169586f, -0.07103869f, 0.21236049f, 
    -0.09373371f, 0.42321968f, 0.10361452f, -0.00133791f, -0.03224679f, 0.23205708f, 0.07689156f, 0.52582484f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02096394f, -0.06589361f, -0.06375673f, 0.01457130f, -0.03265056f, 0.03372929f, 0.01012854f, 0.06650818f, 
    -0.05758056f, -0.00174849f, 0.04021853f, 0.04303303f, -0.01372951f, 0.03927185f, 0.04908194f, -0.04612050f, 
    0.01370233f, -0.07620686f, -0.04353662f, 0.00207283f, 0.00881305f, 0.05737103f, 0.01153706f, -0.00903375f, 
    -0.01641876f, 0.06316806f, 0.04443689f, -0.06491106f, -0.05983387f, -0.06161841f, -0.04536651f, -0.04332137f, 
    -0.04978303f, -0.01265140f, 0.02062467f, -0.03367870f, -0.07205726f, 0.02565357f, -0.07612946f, 0.05851981f, 
    -0.01334913f, -0.04438122f, -0.05219129f, 0.03554680f, -0.00623730f, 0.07204143f, -0.03664270f, -0.03419842f, 
    -0.04801726f, -0.06771265f, 0.04347084f, -0.00843258f, -0.05939227f, -0.06991711f, 0.01412498f, -0.01584489f, 
    -0.04906698f, 0.02910485f, -0.00069332f, -0.02707946f, 0.03144309f, 0.01734564f, -0.03315657f, -0.06579933f, 
    0.04334561f, -0.02343394f, 0.02877060f, 0.00775126f, -0.04341374f, -0.05208509f, -0.03225027f, -0.01872511f, 
    -0.04698393f, -0.01001538f, -0.06569517f, -0.04992996f, 0.00966128f, -0.01832212f, -0.00006361f, 0.05085055f, 
    0.01210189f, -0.01081840f, 0.05314507f, 0.01241821f, -0.05356035f, 0.00662944f, -0.05315319f, -0.05008648f, 
    -0.00671937f, 0.04023085f, -0.05470135f, -0.01143020f, 0.01997410f, 0.01631223f, 0.05632123f, 0.00658812f, 
    0.02207550f, 0.04923623f, 0.03940042f, -0.04821551f, -0.04750864f, 0.05926267f, 0.02355821f, -0.02383366f, 
    0.05144225f, -0.07518190f, 0.00841671f, -0.06680964f, -0.04214929f, 0.04319267f, 0.06440755f, 0.05068929f, 
    -0.02381050f, -0.02954655f, 0.04216455f, -0.03793326f, -0.07036549f, 0.03757957f, 0.01069474f, 0.06280015f, 
    -0.02251664f, -0.07652515f, 0.03228277f, -0.04845866f, -0.02680978f, 0.03962943f, 0.01928551f, -0.02733790f, 
    0.06376380f, -0.01716485f, -0.06936044f, 0.05808537f, -0.04697421f, -0.03027391f, -0.07631379f, -0.07716341f, 
    -0.03423414f, -0.03925054f, -0.04598989f, -0.00452882f, 0.02840792f, 0.01753906f, -0.05480193f, -0.03511754f, 
    0.04293646f, 0.00738104f, -0.06129950f, -0.03093190f, -0.01704950f, 0.04752233f, 0.04641674f, -0.04308913f, 
    -0.03609284f, -0.00427876f, 0.01632356f, 0.05499267f, -0.07701731f, -0.07264236f, -0.00254308f, -0.03374433f, 
    0.03401147f, 0.01330357f, 0.06563962f, 0.02186933f, 0.01619215f, -0.01345062f, 0.05002441f, 0.05595297f, 
    0.05916327f, -0.04451558f, -0.05873665f, 0.00609587f, 0.01324802f, -0.03764534f, 0.04035309f, -0.04414234f, 
    -0.05139136f, -0.02883786f, -0.01999707f, -0.02268656f, 0.00171456f, -0.06686813f, 0.02070603f, -0.02733108f, 
    -0.07386927f, -0.03152403f, -0.05432877f, -0.03495263f, -0.01180882f, -0.02724253f, -0.06312186f, -0.01790360f, 
    0.04720835f, -0.00587749f, -0.05254240f, 0.08308633f, -0.06209022f, -0.04037372f, -0.17131428f, -0.15427738f, 
    -0.17616923f, 0.04758203f, 0.03784252f, -0.16267152f, 0.07826832f, -0.12705950f, -0.16738793f, 0.05722119f, 
    0.02098491f, -0.05113349f, -0.03305013f, 0.12287255f, 0.04033493f, 0.21773499f, -0.14795500f, 0.06639002f, 
    0.33204085f, 0.27550495f, 0.15837704f, 0.20440100f, -0.03006384f, 0.02815164f, -0.12295627f, -0.06857455f, 
    0.02705385f, 0.04279402f, -0.03514900f, 0.01115988f, 0.06291191f, -0.58069390f, 0.00899199f, -0.15751365f, 
    0.08331700f, -0.14297357f, -0.32419637f, 0.08802868f, -0.03463068f, 0.05231312f, 0.01122146f, -0.07990328f, 
    0.06243365f, 0.23985563f, 0.22460137f, 0.01144535f, -0.03330043f, 0.06359361f, 0.04938725f, -0.01932530f, 
    0.13337611f, 0.24372819f, 0.36132777f, 0.03337268f, 0.34372973f, 0.05371346f, -0.04860758f, 0.03007333f, 
    -0.10461273f, -0.01778370f, 0.09956174f, 0.01908610f, -0.12930028f, 0.10981765f, 0.27606231f, 0.07855298f, 
    0.00895114f, -0.00723145f, 0.02573850f, -0.12264188f, 0.19266362f, -0.15880883f, -0.13810648f, -0.22741455f, 
    -0.13435104f, -0.08993131f, -0.14714833f, -0.05928835f, 0.06171335f, -0.36971024f, -0.34040448f, -0.05836009f, 
    0.13660063f, 0.15935513f, -0.06216893f, -0.07120731f, -0.03831602f, 0.13119379f, -0.03563118f, -0.13610323f, 
    0.09502090f, 0.12234663f, 0.00224648f, -0.07782548f, 0.04099200f, -0.06222667f, -0.01009987f, -0.11851580f, 
    -0.17487817f, -0.09750929f, -0.07159311f, -0.03755034f, 0.75099272f, 0.30117252f, 0.24330239f, 0.18038066f, 
    -0.18454340f, -0.20265910f, 0.10832664f, 0.00191242f, -0.05581148f, 0.02031088f, -0.03132309f, -0.04811309f, 
    0.29751277f, 0.29374894f, -0.04553483f, -0.14565918f, 0.07256156f, 0.03957414f, 0.03203324f, 0.00237047f, 
    -0.08189375f, 0.09944287f, -0.28540251f, 0.14303866f, -0.19991131f, -0.50163686f, -0.11084289f, 0.20571433f, 
    -0.07791484f, -0.13571315f, 0.08737666f, 0.06350311f, 0.09399995f, 0.06881912f, -0.07258932f, 0.14921017f, 
    0.24757785f, -0.73344344f, -0.16136183f, -0.28228772f, -0.03890902f, -0.02855710f, -0.11253808f, -0.06038277f, 
    -0.02697011f, 0.08508949f, 0.20482706f, 0.05000027f, 0.01676906f, 0.01179391f, 0.25509965f, 0.01771025f, 
    0.03085130f, 0.06720773f, -0.07048232f, -0.15736954f, 0.19496560f, 0.13727461f, 0.06083165f, 0.22017187f, 
    0.09748203f, 0.03473200f, -0.71272659f, -0.48858178f, -0.05737983f, -0.17262697f, -0.01986487f, -0.09247364f, 
    0.03812678f, 0.14424901f, 0.07712336f, 0.11959749f, 0.71366549f, 0.21571079f, 0.23546280f, 0.06441711f, 
    -0.10897294f, -0.11990974f, 0.10156698f, 0.13872203f, -0.07072049f, 0.04126100f, 0.18822032f, -0.05280491f, 
    0.11466863f, 0.06611319f, -0.04361714f, 0.00215196f, 0.08035641f, -0.08974601f, -0.05894510f, -0.02281817f, 
    0.11027128f, 0.23855785f, -0.09190625f, -0.00720080f, -0.04011628f, 0.10387318f, 0.18954924f, -0.00414568f, 
    0.11592911f, 0.13865659f, -0.15047623f, -0.02279369f, -0.01747985f, 0.16281469f, 0.17125934f, 0.07876641f, 
    -0.17838973f, -0.24026205f, -0.26255620f, 0.04283929f, 0.02116340f, -0.02376952f, -0.12671232f, -0.04206481f, 
    0.14940500f, -0.10325773f, 0.01629302f, 0.07602809f, 0.05270145f, -0.18241546f, 0.32544363f, 0.16567880f, 
    -0.05766976f, 0.08945619f, 0.00076291f, -0.02476647f, -0.11326990f, -0.08929078f, 0.00156485f, 0.00214544f, 
    -0.29817712f, 0.14815494f, 0.16077597f, -0.32208532f, 0.07554356f, 0.12779419f, -0.28405291f, 0.12213597f, 
    0.02880483f, -0.03886449f, 0.11288159f, 0.04519838f, 0.05646269f, -0.09967436f, -0.22883043f, -0.20939180f, 
    -0.10155337f, -0.05521468f, -0.07850745f, 0.14779247f, 0.03520642f, -0.05732598f, -0.10650175f, -0.09031814f, 
    -0.22089042f, 0.49136385f, 0.48497337f, 0.21472844f, -0.06511009f, 0.26661444f, 0.14123492f, 0.27370426f, 
    0.14129972f, -0.05320024f, -0.05051835f, 0.01948606f, -0.16359316f, 0.17113507f, 0.30849946f, 0.00915698f, 
    0.18463790f, 0.02432702f, -0.04934021f, -0.00819866f, -0.05520779f, 0.11222971f, 0.01867830f, 0.12708013f, 
    -0.00740444f, -0.17332362f, -0.20881714f, 0.06379328f, 0.23067352f, 0.20605873f, 0.06837999f, 0.17394550f, 
    -0.07916785f, -0.02826430f, 0.02646499f, -0.04319550f, 0.08379769f, -0.20635033f, -0.37457752f, 0.31404558f, 
    -0.11463913f, 0.10392165f, 0.15998991f, -0.06822471f, 0.11935641f, -0.02749424f, -0.14752084f, -0.10499743f, 
    -0.13386533f, -0.01385995f, 0.05960068f, 0.00624158f, 0.10564015f, -0.13243032f, -0.08834162f, -0.11562016f, 
    0.12060731f, 0.24087209f, -0.11364274f, 0.11512440f, 0.38073066f, -0.28091452f, 0.01845899f, -0.10629855f, 
    -0.02708830f, -0.03564955f, -0.09070396f, 0.08558396f, -0.00466339f, -0.14296725f, 0.01572415f, 0.07492943f, 
    -0.02052759f, 0.01660161f, 0.34606048f, 0.09684107f, 0.05208021f, 0.18842775f, 0.14319588f, 0.16100335f, 
    0.08508910f, 0.07137529f, 0.05257555f, 0.04267277f, 0.17886475f, -0.00892829f, 0.48681527f, 0.37768945f, 
    0.05400149f, -0.06168910f, 0.06304591f, 0.00483552f, 0.00962337f, 0.05284100f, -0.08343053f, 0.06609312f, 
    -0.11022703f, 0.59928215f, 0.31930009f, 0.29320395f, 0.08332942f, -0.07586759f, -0.08661032f, -0.12375212f, 
    -0.01190604f, 0.06164098f, 0.09099240f, 0.00789814f, 0.27656108f, -0.08280028f, -0.50678998f, 0.16075476f, 
    -0.14434551f, 0.06717741f, 0.14431411f, -0.07931543f, 0.02200236f, 0.06811915f, 0.00197282f, -0.02729528f, 
    -0.25603873f, -0.17158988f, 0.04212408f, -0.03589870f, 0.00088519f, 0.05086073f, 0.16337121f, -0.14137404f, 
    0.16131006f, -0.08575046f, -0.10990411f, -0.02975444f, -0.24962434f, 0.06172751f, -0.06896465f, 0.01164878f, 
    0.02236551f, 0.03376439f, 0.23298210f, -0.06662931f, 0.06927545f, -0.04539953f, -0.02861694f, -0.11256198f, 
    -0.02419480f, 0.06886577f, -0.07505579f, -0.28638324f, -0.10913239f, -0.18734184f, 0.01804813f, 0.05595847f, 
    0.03142404f, -0.09937702f, -0.03133979f, 0.03023759f, 0.21663229f, -0.39652270f, 0.09049528f, 0.08805986f, 
    0.00908063f, 0.03030415f, -0.20610599f, -0.04088315f, 0.13316071f, -0.23244423f, 0.17374870f, -0.02426275f, 
    0.57227528f, 0.44057006f, -0.43075630f, -0.07260244f, 0.02479092f, -0.08064798f, 0.11155155f, 0.09954166f, 
    0.04969998f, 0.01192010f, -0.08339712f, -0.00371724f, -0.10708202f, -0.08941890f, -0.12873746f, 0.12482709f, 
    0.06471997f, 0.03881182f, 0.22159944f, 0.11030106f, 0.21463156f, 0.20076455f, -0.16373424f, 0.32487479f, 
    0.78065616f, -0.08656100f, 0.11024352f, 0.03916508f, 0.12986737f, 0.18096167f, 0.01626788f, 0.06943257f, 
    0.01441060f, 0.08028792f, -0.06257056f, -0.30015075f, -0.02566820f, -0.26971310f, 0.32498622f, -0.22620596f, 
    0.06504051f, -0.15398657f, 0.02528934f, -0.09933601f, 0.09146773f, -0.00365430f, -0.02751441f, 0.13633907f, 
    -0.25737947f, -0.05880073f, 0.28330824f, 0.20431072f, 0.05377932f, -0.10917117f, 0.04602744f, 0.18495168f, 
    -0.11297279f, -0.06877446f, -0.06167531f, -0.11584167f, 0.03939975f, 0.06215085f, 0.31312799f, 0.16113508f, 
    0.01867985f, -0.08722217f, -0.00108706f, 0.12415820f, 0.02028222f, 0.03751638f, -0.12635152f, -0.26901969f, 
    0.02945748f, 0.08540114f, 0.06602214f, 0.05881055f, 0.01874432f, 0.15224330f, 0.09476894f, 0.24410996f, 
    -0.00239668f, 0.07814810f, 0.09515799f, 0.08987872f, -0.37779605f, 0.07152338f, 0.16788834f, 0.19835959f, 
    0.01507077f, -0.01453555f, -0.20921071f, -0.20794608f, -0.00751650f, -0.02783496f, 0.14355186f, 0.11661723f, 
    0.13813335f, -0.01773046f, 0.06430542f, 0.04368775f, -0.03356541f, -0.07831385f, 0.06697403f, -0.13998042f, 
    0.08422469f, -0.07813955f, 0.03472891f, 0.02234864f, 0.21669602f, 0.16498803f, -0.03209905f, -0.26241145f, 
    0.00523866f, -0.09218028f, 0.04579430f, -0.00763027f, 0.12791629f, 0.01129561f, 0.27904338f, 0.06455071f, 
    -0.19739656f, -0.06702448f, 0.16078594f, -0.06596001f, -0.07001127f, -0.03507391f, 0.01294833f, 0.28536510f, 
    0.23769887f, 0.12353523f, 0.04735850f, 0.13914497f, 0.14553584f, -0.17534807f, 0.07689055f, 0.14711998f, 
    -0.03191682f, 0.00595342f, 0.00892225f, 0.06164378f, 0.04883488f, 0.03109805f, 0.12119247f, 0.00277982f, 
    0.22664398f, 0.03562222f, 0.06319255f, -0.01506818f, -0.10922504f, -0.13767736f, 0.05983231f, -0.03985040f, 
    0.04607573f, 0.16278462f, -0.13682564f, -0.01198677f, 0.23863471f, 0.04826131f, 0.05611980f, 0.01254544f, 
    -0.09681010f, 0.09003375f, 0.15802357f, -0.13219437f, 0.02878888f, -0.05754400f, 0.08447991f, -0.00245144f, 
    0.27111545f, 0.23772016f, 0.31537962f, 0.04947012f, -0.02566131f, -0.04807121f, -0.01664004f, 0.00675421f, 
    0.15421720f, 0.02403651f, 0.00541673f, 0.20815794f, -0.15041687f, 0.02835423f, 0.01822446f, 0.24828662f, 
    -0.01251600f, 0.22719747f, 0.09363755f, -0.03510047f, 0.03630361f, 0.09056797f, -0.08696553f, 0.04066303f, 
    -0.16642818f, 0.02562910f, -0.10554922f, 0.23076013f, -0.11436631f, 0.01974785f, 0.08737405f, -0.07889499f, 
    0.13955742f, -0.01144521f, -0.07650182f, -0.01151979f, 0.21392523f, -0.14022805f, -0.00978920f, -0.12242635f, 
    0.02299890f, -0.06414410f, 0.02392057f, 0.11085877f, -0.17903978f, -0.36002046f, -0.23834357f, -0.47206724f, 
    0.13682891f, 0.14553715f, 0.10924165f, -0.02281268f, -0.06986868f, 0.19964924f, 0.12856592f, 0.00180508f, 
    -0.06163365f, 0.12605649f, 0.09018108f, 0.15705837f, 0.05379190f, 0.17028213f, 0.42219922f, 0.01251152f, 
    0.13210613f, -0.07520275f, -0.04305561f, 0.13705483f, -0.14702842f, -0.20334865f, -0.19881731f, -0.09805424f, 
    0.05659422f, 0.02395320f, 0.01872869f, -0.08429849f, -0.08806060f, -0.18708369f, -0.02207219f, -0.03245669f, 
    -0.04205909f, 0.02887948f, -0.09204372f, 0.05573333f, 0.31052589f, 0.26231882f, 0.02283731f, 0.19797479f, 
    -0.11410388f, -0.17795345f, -0.03734899f, 0.01660369f, 0.01568315f, 0.06309924f, 0.04384081f, 0.07602322f, 
    -0.02564813f, 0.21635245f, -0.00908978f, -0.02731702f, -0.16408464f, 0.00869826f, -0.09430203f, -0.00949644f, 
    -0.12258654f, 0.15909776f, -0.05302556f, -0.06465280f, 0.12423549f, 0.33602235f, 0.06542225f, 0.19153178f, 
    0.09921628f, 0.06262071f, -0.05034763f, 0.10329051f, -0.02116523f, -0.10734976f, 0.06056352f, 0.05356827f, 
    0.00034359f, 0.20299473f, 0.21330431f, 0.38997236f, -0.06892332f, 0.02495885f, 0.09516328f, 0.06376094f, 
    -0.00573005f, -0.02808102f, -0.10008060f, 0.12486369f, -0.11877223f, 0.05027421f, -0.04082594f, 0.04894210f, 
    -0.00699831f, 0.02840626f, -0.01740353f, 0.03601186f, 0.10751553f, 0.09379759f, -0.28269339f, -0.10576544f, 
    0.22155088f, -0.14614354f, -0.70576060f, -0.62487525f, -0.14755431f, -0.10081161f, -0.04929569f, 0.03394658f, 
    0.07191689f, 0.08719291f, -0.11540218f, -0.07258687f, 0.23916972f, -0.03104600f, 0.16202545f, 0.20061670f, 
    0.06033626f, -0.04923152f, -0.08480801f, 0.04045130f, 0.07174569f, 0.04163206f, 0.14815012f, -0.08535397f, 
    -0.20671622f, -0.06757566f, -0.15314306f, -0.00666357f, -0.09778018f, -0.10337784f, -0.05589100f, -0.10944485f, 
    -0.09401879f, 0.19810832f, -0.01094690f, -0.01775537f, -0.36494160f, 0.10555816f, 0.01173775f, 0.11047627f, 
    -0.22582842f, 0.03141757f, 0.06884139f, -0.11405680f, 0.28730473f, 0.08238096f, 0.15218152f, 0.14916223f, 
    0.02315955f, -0.04909567f, 0.08364572f, -0.05777613f, -0.00703441f, -0.07657266f, -0.15754905f, -0.23159082f, 
    -0.07198434f, -0.22018649f, 0.05499386f, 0.12796098f, 0.38654229f, -0.10237847f, -0.13381036f, -0.10430037f, 
    0.12803763f, 0.19669379f, 0.07005900f, 0.10911306f, 0.10070164f, -0.10380121f, -0.06451920f, 0.15790300f, 
    0.36828890f, 0.19989026f, -0.08421915f, 0.02988796f, -0.01397313f, -0.01867989f, 0.09013719f, 0.03836451f, 
    -0.16386436f, 0.04962111f, 0.06695144f, 0.06048945f, -0.04481184f, -0.07396053f, 0.08308073f, 0.08533587f, 
    0.09923957f, -0.07809233f, 0.07892128f, 0.05519108f, -0.13181165f, -0.12264466f, -0.19389379f, -0.36361018f, 
    0.25687057f, 0.04090812f, 0.17943841f, -0.42596847f, 0.08357869f, 0.22554971f, 0.19400312f, 0.08098449f, 
    -0.06899598f, 0.00379581f, 0.15077673f, 0.09791901f, 0.32053897f, 0.30757990f, -0.18351480f, -0.34423324f, 
    0.02087565f, 0.06567298f, 0.20141728f, -0.06596942f, -0.05304941f, -0.03511808f, 0.08467087f, -0.02629627f, 
    -0.21017988f, -0.20461981f, -0.09188178f, -0.07496011f, 0.03370820f, 0.09746820f, 0.16802916f, -0.05454592f, 
    0.04303060f, 0.19296435f, -0.14619739f, -0.01723378f, -0.12053601f, 0.06639414f, -0.45024750f, 0.42686293f, 
    0.04969322f, 0.02539674f, -0.02242925f, -0.10832400f, 0.01901871f, -0.03225164f, -0.01549381f, 0.11870009f, 
    -0.06198372f, 0.03556142f, -0.06933910f, -0.00599726f, -0.00708641f, -0.05432969f, -0.09572476f, -0.25422439f, 
    0.24212627f, -0.04706810f, 0.21636906f, 0.04741472f, 0.22618750f, -0.16304435f, -0.20691219f, 0.18789904f, 
    0.04253989f, -0.06439153f, -0.11062460f, -0.09278542f, 0.06946696f, 0.16937000f, 0.09460341f, 0.11786645f, 
    0.25752801f, 0.15228944f, -0.08084124f, -0.20973220f, 0.03592101f, 0.11530841f, 0.03954175f, -0.02000505f, 
    0.00009802f, -0.09337547f, -0.00091408f, 0.02269355f, 0.26681593f, 0.17168404f, 0.04053940f, -0.04149119f, 
    -0.07348288f, -0.05637550f, 0.05128661f, 0.08731164f, 0.19349512f, 0.31830072f, -0.02198811f, 0.28230774f, 
    -0.36986396f, 0.14322737f, -0.28959224f, -0.43926099f, 0.00698307f, 0.26131272f, 0.08356665f, 0.04116530f, 
    0.22785658f, 0.06165401f, 0.00610449f, 0.16775167f, -0.04406228f, 0.11427808f, -0.06965571f, 0.13667317f, 
    0.05612741f, 0.01021132f, 0.08965664f, 0.08241682f, -0.19194944f, 0.03996947f, -0.16421252f, -0.02500432f, 
    0.00300478f, 0.00783163f, -0.16568045f, -0.10315891f, 0.06794623f, -0.02715117f, 0.07685094f, 0.02388559f, 
    -0.05871980f, 0.37593868f, -0.01658097f, -0.08440952f, 0.17283401f, 0.14630724f, -0.06686787f, 0.26075494f, 
    -0.04073396f, 0.36617425f, 0.09510993f, 0.21186890f, 0.32835057f, 0.22862470f, 0.02244169f, 0.10637904f, 
    -0.01297741f, 0.06587598f, -0.06369698f, 0.33070448f, -0.24450774f, -0.13311772f, -0.22425801f, -0.12707937f, 
    0.03238969f, -0.20362873f, 0.06791689f, 0.02923054f, -0.09225561f, 0.21803358f, 0.31487182f, -0.05042000f, 
    -0.12275608f, 0.08447329f, 0.10365127f, -0.08189649f, -0.15767293f, -0.07123856f, 0.19586442f, -0.01499359f, 
    0.21664368f, -0.09921614f, 0.36626521f, 0.30077171f, -0.23177800f, 0.14944668f, -0.06610825f, 0.05831558f, 
    -0.02060039f, 0.01563997f, -0.12328325f, 0.10056707f, -0.05462897f, 0.40711215f, 0.11909760f, -0.15482129f, 
    0.01020330f, -0.19970354f, -0.03321468f, 0.05040910f, -0.14408772f, -0.11035475f, -0.23337290f, -0.32283670f, 
    -0.11374132f, 0.19826765f, -0.03522100f, -0.07161115f, 0.08245167f, 0.24562757f, 0.08559255f, 0.09614824f, 
    0.12344199f, 0.00942528f, 0.04598708f, -0.10187973f, 0.00273309f, 0.33403489f, -0.04901417f, -0.06283704f, 
    0.13065679f, -0.06979249f, 0.23330253f, 0.06163020f, 0.00458484f, -0.10856660f, 0.00181946f, -0.01908995f, 
    0.00610435f, 0.30504555f, -0.07382288f, -0.20622885f, -0.09385078f, -0.10922361f, 0.11349591f, 0.20890273f, 
    -0.09255476f, 0.12342724f, -0.08063871f, -0.08163249f, 0.12311912f, 0.12262402f, 0.32829666f, 0.03227068f, 
    -0.15529075f, -0.09569121f, -0.29530162f, -0.03479290f, 0.03937272f, -0.15940116f, 0.16608326f, -0.01389111f, 
    -0.03495356f, 0.04344999f, 0.10503583f, 0.23572497f, 0.10651819f, -0.09088268f, 0.04340824f, -0.13032068f, 
    0.23963150f, 0.40073287f, 0.03673762f, 0.10225936f, 0.07237536f, -0.03636475f, -0.20787168f, -0.50016159f, 
    -0.13724728f, 0.20443109f, -0.07260562f, 0.20579615f, -0.03078506f, -0.01642165f, -0.05947443f, -0.12276189f, 
    -0.08833567f, 0.35326374f, 0.10423528f, -0.05589447f, 0.03775678f, 0.06947034f, 0.02316062f, 0.07995471f, 
    0.10122475f, 0.04615483f, -0.08963403f, 0.01762215f, -0.01989135f, -0.30244559f, 0.08643472f, 0.13681570f, 
    0.05010679f, -0.09349692f, 0.05957140f, -0.10318792f, 0.03061513f, 0.10420702f, -0.13896953f, -0.02124860f, 
    -0.21119343f, 0.13101645f, -0.05465244f, 0.06941488f, -0.14570695f, -0.06810090f, -0.14439538f, -0.10596853f, 
    0.09597884f, -0.02237207f, 0.00288567f, 0.00603622f, 0.22404553f, -0.18152097f, 0.37674260f, 0.15039782f, 
    0.06041171f, 0.03612202f, -0.03011221f, -0.06420960f, -0.04030539f, 0.03752023f, 0.01621772f, -0.09236292f, 
    0.12091887f, -0.07169329f, -0.05998846f, 0.04730808f, 0.06495041f, -0.04162920f, -0.07470076f, -0.05431752f, 
    -0.16136405f, 0.01962324f, -0.18993615f, -0.16035257f, 0.20219263f, 0.00471704f, -0.07704711f, -0.03585802f, 
    -0.10287219f, 0.07649518f, -0.02146566f, -0.00638989f, 0.03609719f, 0.12616920f, -0.20597003f, 0.02139301f, 
    0.20347075f, 0.16093092f, 0.12635912f, 0.42011589f, -0.02513517f, -0.01604565f, -0.08906558f, 0.05088197f, 
    -0.02148579f, -0.10129588f, 0.01627140f, 0.14958027f, -0.17547543f, -0.22127646f, 0.21984857f, -0.23933697f, 
    0.15182212f, 0.16870713f, 0.09268966f, -0.13367096f, -0.07084107f, -0.03575879f, 0.03592830f, -0.17494467f, 
    0.20857151f, 0.02206766f, 0.26919630f, 0.36110976f, -0.06640443f, 0.04881539f, -0.03337074f, -0.10609341f, 
    0.00488528f, 0.05920430f, 0.04948007f, 0.12770687f, 0.24062471f, 0.22445481f, 0.11669941f, 0.02425534f, 
    -0.10410357f, 0.04413108f, -0.03061796f, 0.00236051f, -0.06160626f, 0.10583923f, -0.15612614f, 0.02761598f, 
    -0.48916700f, 0.32249546f, -0.17493233f, -0.26696172f, -0.07734498f, 0.33579278f, 0.30477867f, 0.00588178f, 
    -0.14914137f, 0.01687488f, -0.01922653f, -0.14880352f, -0.42094812f, 0.39968887f, -0.55550444f, -0.76768959f, 
    0.13245335f, -0.06774779f, -0.14335538f, -0.27784133f, 0.02534658f, 0.10787664f, 0.00179939f, 0.07285583f, 
    0.08215749f, 0.08809647f, 0.07140270f, 0.01305287f, 0.15611979f, 0.10102913f, 0.15161385f, 0.04491372f, 
    -0.12381732f, -0.14834616f, -0.16848005f, -0.03832213f, 0.22255984f, 0.20041472f, 0.14716245f, 0.40668294f, 
    0.11075027f, 0.07796825f, 0.01981410f, 0.09475897f, -0.09978165f, -0.08265545f, -0.01759546f, 0.07200163f, 
    0.15616150f, -0.00125718f, 0.04553213f, 0.07819651f, 0.12742385f, -0.05020391f, -0.10481703f, -0.18017025f, 
    0.11718488f, -0.14125183f, -0.05528365f, -0.21497421f, 0.43052801f, -0.43565285f, -0.36699444f, 0.13570419f, 
    -0.06874152f, 0.13325281f, 0.10077901f, 0.12150346f, -0.06081759f, -0.15919945f, -0.06084595f, -0.00397796f, 
    -0.31555921f, -0.06972741f, -0.26863775f, -0.61862123f, 0.02063201f, -0.03972885f, 0.05245466f, 0.12456270f, 
    0.05073244f, -0.02527212f, 0.04887057f, 0.10770839f, -0.15209793f, -0.01970805f, 0.30260473f, 0.42312154f, 
    -0.04435613f, -0.06919172f, 0.05277268f, -0.06588840f, -0.15069252f, -0.17725390f, 0.11242228f, -0.01857060f, 
    0.08859213f, 0.01263893f, -0.44436190f, -0.11214876f, -0.07355648f, 0.02940885f, 0.06770132f, -0.07802811f, 
    0.07427277f, 0.01896832f, -0.19841614f, 0.03502161f, 0.02037190f, 0.07426182f, 0.14835627f, 0.31155539f, 
    0.18620498f, 0.03182288f, -0.06559119f, 0.08331580f, -0.01548341f, -0.00116034f, 0.00486373f, 0.13733380f, 
    -0.03552946f, -0.09874508f, -0.08737125f, -0.13300620f, 0.07444123f, 0.04357496f, -0.03598039f, -0.06358725f, 
    -0.13973702f, 0.08171195f, 0.25488350f, 0.23152861f, 0.20248851f, 0.06837751f, 0.18309273f, -0.08219960f, 
    -0.06425257f, -0.04251664f, -0.04855602f, -0.08691630f, 0.17252547f, 0.11597887f, 0.19291744f, 0.17604391f, 
    0.09460729f, 0.16915885f, 0.23773488f, -0.07471218f, -0.06959301f, -0.04395089f, -0.04010212f, -0.11391198f, 
    -0.08488889f, 0.10276206f, 0.02642908f, 0.06800300f, -0.05343708f, 0.36578056f, -0.24455974f, 0.12818334f, 
    0.12953125f, 0.05488209f, 0.21528213f, 0.00373600f, 0.06390174f, 0.24168575f, -0.22154856f, 0.15871781f, 
    0.33654040f, -0.20057756f, 0.29408103f, 0.32350156f, -0.08861934f, -0.06877933f, 0.12138785f, -0.07417125f, 
    -0.05863270f, -0.11258303f, 0.06348828f, 0.03526727f, -0.08880171f, 0.20665707f, 0.41431651f, -0.05666026f, 
    -0.10074028f, -0.11208411f, -0.14368223f, -0.19409715f, -0.03835860f, -0.05162410f, -0.21127261f, -0.18747626f, 
    -0.09593906f, -0.22754326f, -0.45409906f, -0.01586670f, 0.06721185f, 0.03676005f, 0.21976398f, 0.06995723f, 
    0.01670126f, 0.05050195f, 0.03375496f, 0.04566905f, 0.11221789f, 0.16537198f, -0.18444701f, 0.17502734f, 
    -0.00750188f, 0.01011907f, 0.03538452f, 0.10803857f, 0.02966734f, -0.14690840f, -0.01604541f, -0.13155361f, 
    -0.01047755f, 0.06982776f, -0.10684931f, -0.17447008f, 0.12211928f, 0.17104366f, 0.01323451f, -0.11487114f, 
    -0.02988182f, -0.04060249f, 0.07072564f, 0.05237613f, -0.19662997f, 0.19780865f, 0.24222448f, -0.10084145f, 
    -0.01534052f, 0.01435138f, -0.14784946f, -0.04641406f, -0.10766843f, -0.03435615f, 0.09065459f, 0.09017739f, 
    0.08620109f, -0.17015210f, 0.01110045f, -0.11873882f, -0.15455070f, 0.08910007f, 0.03187044f, -0.00615839f, 
    0.35410467f, -0.03679626f, 0.22054808f, -0.02219969f, 0.15580662f, 0.21407437f, 0.08345048f, 0.24547373f, 
    0.02366118f, 0.09631548f, 0.13425790f, 0.02272325f, -0.02282015f, -0.02543279f, -0.05517489f, -0.11833559f, 
    -0.01330717f, -0.15746120f, -0.21782196f, 0.06435514f, 0.19074997f, -0.06903450f, -0.02265817f, 0.07188942f, 
    -0.09036409f, 0.00514698f, -0.09771211f, -0.05162904f, 0.01897311f, 0.01116791f, -0.05567092f, 0.14355408f, 
    -0.24961525f, 0.04556089f, -0.15522847f, -0.03107296f, 0.06152532f, 0.00529101f, 0.08443667f, -0.18439159f, 
    0.50298506f, -0.29900745f, -0.00092872f, 0.03986514f, 0.08020025f, 0.06003013f, 0.05503396f, -0.15490083f, 
    0.02447377f, 0.13134147f, -0.10899886f, -0.02603984f, -0.42548373f, 0.30211726f, 0.14579695f, -0.15952682f, 
    -0.08619086f, -0.07053725f, -0.23087904f, -0.06759296f, -0.02925935f, 0.00443453f, -0.14229661f, 0.01928393f, 
    -0.24282262f, 0.02555586f, -0.06870822f, 0.04342844f, 0.03146677f, -0.00000803f, -0.14555936f, -0.01283638f, 
    -0.06620043f, 0.04371395f, 0.25493363f, -0.04523808f, -0.10274764f, 0.15846650f, 0.06749498f, 0.30847770f, 
    -0.10036504f, 0.19583781f, 0.06415893f, 0.17371239f, 0.26809585f, -0.05421163f, 0.21738796f, 0.22792263f, 
    0.03643850f, 0.19832300f, -0.16093516f, -0.15026626f, -0.06052951f, -0.17994057f, -0.08189328f, -0.10274286f, 
    -0.13789682f, 0.04989126f, -0.09500530f, -0.08837487f, -0.08617315f, 0.13380192f, 0.01958304f, -0.14312878f, 
    -0.03384272f, -0.04311640f, 0.06655737f, 0.18223910f, 0.05844710f, 0.10053944f, -0.04555927f, 0.10174056f, 
    0.23681565f, 0.04597233f, 0.29085052f, -0.04232236f, -0.04050197f, -0.09694111f, -0.02414046f, 0.19648485f, 
    -0.04178319f, 0.16728131f, 0.23871781f, 0.01385407f, -0.00947983f, 0.21267052f, -0.32351995f, -0.02259404f, 
    -0.01445049f, -0.09438077f, 0.08686425f, -0.02693795f, 0.02843221f, 0.06316977f, 0.13140120f, -0.35501951f, 
    -0.29805100f, -0.44659346f, -0.25123444f, 0.09159047f, -0.01225098f, -0.05080009f, 0.00133402f, 0.08857813f, 
    0.05711623f, -0.03813009f, -0.00872320f, 0.10331732f, -0.11295355f, 0.07298566f, -0.08872057f, 0.16404426f, 
    0.00870941f, -0.06717362f, 0.21905574f, 0.14058590f, 0.09250063f, -0.04230715f, 0.06251060f, -0.05058728f, 
    -0.04670055f, -0.14514682f, -0.15890284f, -0.14308821f, 0.05340406f, 0.10829707f, -0.04178670f, -0.13261771f, 
    -0.22284144f, -0.12095301f, 0.01965009f, -0.04505302f, 0.00794472f, -0.14972459f, 0.01819502f, -0.27086926f, 
    -0.17792317f, -0.12656455f, -0.09745369f, -0.20210645f, -0.10993609f, 0.03242942f, 0.01189715f, 0.05080579f, 
    0.22115254f, 0.10265946f, 0.06830002f, 0.16336788f, 0.08172749f, 0.00415782f, 0.21653406f, -0.00213266f, 
    0.34267521f, 0.05422765f, 0.14695403f, 0.15240481f, 0.03827188f, 0.10313233f, 0.19173940f, -0.46558225f, 
    0.09652913f, -0.05080716f, 0.07705196f, 0.02959853f, 0.02528904f, 0.05062619f, 0.12792327f, 0.05151086f, 
    -0.21915151f, -0.12287903f, -0.09310593f, -0.08687232f, -0.09654319f, -0.02735624f, -0.00054093f, -0.15963045f, 
    -0.03037958f, 0.05665932f, 0.03307535f, -0.08233930f, 0.37158826f, 0.01188875f, 0.04266483f, -0.08153804f, 
    -0.05681268f, -0.12616904f, -0.04890153f, 0.07519562f, 0.24564524f, 0.34008595f, 0.17800020f, 0.13891737f, 
    -0.33664241f, 0.11485661f, 0.08107653f, -0.09618828f, -0.09839119f, -0.07783449f, -0.06964190f, 0.14300251f, 
    0.15986997f, 0.13964868f, 0.18579207f, 0.05095014f, 0.43178204f, 0.04455332f, 0.20374046f, -0.16906048f, 
    -0.09540537f, 0.08066621f, 0.07840099f, -0.00441101f, 0.04135461f, 0.09022841f, -0.06939375f, -0.00739354f, 
    0.17469437f, 0.11055985f, 0.00937971f, -0.08347633f, -0.00709684f, 0.01511686f, 0.06818910f, 0.10278118f, 
    -0.01864605f, -0.10530803f, -0.26749796f, 0.07611313f, 0.08519521f, -0.09699589f, 0.04355225f, -0.15435770f, 
    0.14538421f, -0.00723172f, -0.07205939f, -0.03117852f, -0.06673041f, -0.07673687f, -0.19630367f, -0.16008177f, 
    -0.03909224f, 0.04572646f, 0.04380932f, 0.08165552f, 0.06669116f, 0.04345232f, 0.10378999f, 0.00890019f, 
    -0.01897846f, 0.01790287f, 0.01021881f, -0.11928706f, -0.15123485f, 0.16443177f, 0.14980052f, 0.15291345f, 
    0.12671582f, 0.03903247f, 0.05911013f, -0.08508550f, -0.04977729f, -0.06131703f, 0.02256549f, -0.06504804f, 
    -0.22732602f, -0.11299083f, 0.01602780f, 0.05356388f, 0.09229929f, 0.04948770f, 0.01385708f, 0.01551145f, 
    0.12354813f, -0.09312507f, -0.07066157f, 0.05543945f, 0.06501722f, -0.09155144f, 0.18290330f, -0.03769166f, 
    -0.04753885f, -0.05945349f, -0.10459118f, -0.17245771f, 0.08676631f, 0.09616648f, 0.20867936f, 0.39511922f, 
    0.12620962f, -0.17885211f, -0.00740459f, 0.14600261f, 0.07915493f, 0.13093336f, -0.13298473f, -0.12671730f, 
    0.12400904f, -0.04476046f, -0.13171779f, -0.07773712f, -0.02929400f, -0.12605684f, 0.27814680f, 0.11247292f, 
    -0.07281536f, 0.14122888f, -0.17978281f, 0.05631325f, -0.05441224f, -0.07803481f, 0.10522348f, -0.00069835f, 
    -0.02558420f, -0.01406931f, 0.11008422f, 0.07219057f, -0.14756109f, -0.14459901f, -0.00011424f, -0.03521706f, 
    0.02752614f, 0.01459520f, 0.03526817f, -0.07893477f, 0.15439498f, -0.01866080f, 0.31029835f, -0.03679250f, 
    0.10872027f, 0.16582489f, 0.06442705f, 0.05051435f, 0.06524167f, -0.12719768f, 0.02809968f, -0.08159242f, 
    0.10899477f, -0.06044134f, 0.01599420f, -0.13942693f, -0.06133584f, 0.13379435f, -0.00509634f, -0.00977881f, 
    -0.28053996f, -0.04903131f, -0.04919548f, -0.09411792f, -0.09287687f, 0.15701108f, 0.11972102f, 0.15460820f, 
    0.09811141f, 0.06945374f, 0.10720766f, -0.09623487f, -0.21429779f, -0.19631189f, -0.10228688f, 0.00693215f, 
    -0.07893252f, 0.05435455f, 0.07706880f, 0.19647479f, 0.05426813f, -0.03022895f, 0.04314096f, 0.11262156f, 
    -0.04086562f, -0.19273624f, 0.02580095f, 0.09907213f, -0.19943115f, 0.05002550f, 0.03791902f, 0.21926801f, 
    0.08005822f, 0.02396175f, -0.01030086f, -0.04036152f, -0.12213211f, -0.22184487f, -0.07979099f, -0.10689491f, 
    0.53064603f, -0.16474532f, 0.28776485f, 0.36146739f, -0.05749634f, 0.01595767f, -0.00832675f, -0.11882338f, 
    -0.14403974f, 0.08460547f, 0.06042764f, 0.06166271f, -0.13905652f, 0.29725751f, -0.09940231f, -0.06197415f, 
    -0.07185887f, 0.06931792f, 0.04771327f, -0.00705814f, 0.16388693f, 0.00414753f, 0.01527905f, 0.09528574f, 
    -0.28205580f, -0.06245612f, -0.06233563f, -0.13309284f, -0.05150693f, -0.03538926f, 0.07988975f, -0.06181936f, 
    0.06592631f, 0.11635406f, 0.21677119f, 0.08535732f, -0.33936721f, 0.23274316f, 0.15906708f, -0.09165196f, 
    0.02063022f, 0.01044250f, 0.05822277f, 0.06546891f, 0.06601425f, 0.13996026f, 0.21582574f, 0.02617264f, 
    -0.26799384f, -0.03538255f, 0.13439845f, -0.10256441f, -0.11416128f, -0.09322775f, -0.00591772f, -0.16517209f, 
    -0.07061739f, -0.19090089f, -0.05717674f, -0.11761082f, -0.03319557f, -0.32483035f, -0.08428064f, -0.13141307f, 
    0.10622406f, -0.05149331f, -0.02405528f, -0.16684279f, 0.03019896f, -0.02772051f, 0.17760415f, 0.17164131f, 
    0.70247388f, 0.30910328f, 0.05054385f, 0.04715828f, -0.04467997f, -0.00717935f, 0.02679360f, 0.08332460f, 
    0.03565983f, -0.14945468f, -0.11695749f, 0.20449495f, -0.19832523f, 0.06755341f, 0.16159822f, 0.15444775f, 
    -0.08113982f, 0.05369902f, -0.04424737f, 0.10518750f, 0.14274988f, 0.12439170f, -0.00603311f, -0.04567600f, 
    0.04205830f, -0.18194149f, -0.19948043f, -0.15510914f, 0.06270029f, 0.01529827f, 0.11157411f, 0.17811902f, 
    -0.03397093f, 0.08437277f, 0.17088518f, 0.03225474f, -0.21458432f, -0.27569863f, -0.25298935f, -0.16129535f, 
    -0.15113768f, 0.02308708f, -0.05363468f, 0.16852589f, 0.00023577f, 0.02174930f, 0.14644602f, 0.11877713f, 
    -0.26673645f, -0.19869871f, -0.05885913f, -0.13576214f, -0.15801373f, -0.07164954f, 0.08145355f, -0.00773920f, 
    -0.07875639f, 0.01084003f, 0.08642991f, -0.04901278f, 0.00196289f, 0.03757536f, 0.29945979f, 0.10632818f, 
    -0.06437948f, -0.08703727f, -0.10706963f, 0.03347792f, -0.00675421f, -0.02405144f, 0.09591156f, -0.06402060f, 
    -0.06010854f, 0.16233802f, 0.19075055f, 0.00910729f, -0.19240779f, 0.12528227f, 0.04335450f, -0.00994722f, 
    0.36512694f, 0.16572623f, 0.12322413f, -0.03734844f, -0.03652641f, -0.08294521f, 0.07917582f, 0.05319056f, 
    -0.13320076f, 0.03345533f, 0.01541832f, -0.00085202f, 0.02406511f, 0.25270346f, 0.20534983f, 0.14860089f, 
    -0.12536512f, -0.35383558f, -0.25441366f, -0.11399341f, 0.07648870f, 0.08621614f, -0.02303205f, 0.05265922f, 
    -0.01879093f, -0.01672619f, -0.03560308f, -0.03479052f, 0.56929743f, 0.38638905f, 0.19331948f, 0.00327878f, 
    -0.15186192f, 0.10064131f, -0.02273779f, -0.10717527f, 0.21103643f, 0.14782974f, 0.16175927f, -0.05299770f, 
    0.03472444f, 0.07683329f, 0.17091376f, -0.07527728f, -0.05912713f, -0.02922186f, -0.11079185f, 0.15837334f, 
    0.09219270f, 0.16652784f, 0.12339869f, 0.06019916f, 0.13279676f, 0.08724631f, 0.23057120f, 0.16342817f, 
    -0.21488853f, -0.11542350f, 0.06166792f, 0.07157607f, 0.05173642f, -0.01435725f, -0.00058154f, 0.21635276f, 
    -0.19341740f, 0.08543260f, 0.01513673f, 0.07655341f, -0.08791336f, 0.11694168f, -0.17220975f, -0.10559744f, 
    0.08469278f, -0.04632141f, -0.00766549f, -0.04132587f, -0.14674085f, 0.17796098f, 0.16943747f, 0.13642737f, 
    0.01290566f, 0.13699383f, 0.03045125f, 0.01853051f, -0.12008554f, -0.07772911f, 0.07103041f, -0.05000819f, 
    -0.04047350f, 0.10185053f, -0.33585230f, -0.22715969f, -0.12549849f, -0.13476227f, 0.02766665f, 0.00789695f, 
    -0.07641199f, 0.05760057f, -0.01653383f, -0.10535592f, -0.01761663f, -0.25013435f, 0.02813862f, 0.08618495f, 
    -0.06393291f, -0.02830475f, -0.07420498f, 0.09756222f, -0.02188668f, 0.06410718f, 0.05385348f, 0.15084665f, 
    0.47774398f, -0.02381962f, 0.18544453f, -0.35711423f, 0.04774122f, 0.08197086f, -0.04950628f, 0.15384127f, 
    0.12209606f, -0.07811667f, 0.07791591f, 0.17072168f, -0.13927564f, 0.35346681f, -0.46108508f, 0.11406570f, 
    -0.01671513f, -0.01333293f, 0.07985684f, -0.03104534f, 0.18024914f, 0.14150545f, -0.08492488f, 0.16615340f, 
    0.01011420f, -0.07341973f, -0.05045833f, 0.12714741f, -0.01034203f, -0.03992643f, -0.05974096f, 0.06193423f, 
    -0.00073944f, -0.06164125f, -0.02427034f, 0.01313597f, -0.16141523f, -0.24961752f, 0.17638952f, 0.28154331f, 
    -0.06758431f, -0.16390753f, -0.00882430f, -0.05749987f, 0.09125292f, 0.09469561f, 0.09737594f, 0.12217870f, 
    -0.11429735f, -0.05832009f, -0.04960134f, 0.03834332f, 0.11793447f, 0.06392881f, 0.07700051f, -0.05808622f, 
    -0.27447587f, -0.11824214f, 0.00432914f, -0.01678646f, 0.03376362f, -0.01502151f, 0.42726380f, -0.08267515f, 
    -0.17919768f, 0.04522415f, 0.12356520f, -0.09990471f, 0.01226492f, 0.01136429f, -0.00214173f, -0.19326118f, 
    0.08388081f, 0.12395314f, 0.16265593f, 0.08307534f, 0.01228877f, 0.00289198f, 0.12673515f, 0.21392263f, 
    0.09961887f, 0.11674687f, -0.17508411f, 0.18903285f, -0.19642158f, -0.23298149f, 0.35136753f, 0.16553821f, 
    0.01584486f, 0.03722411f, -0.07538371f, 0.04296789f, 0.04491541f, 0.03686497f, 0.11059625f, 0.03231186f, 
    -0.06967962f, -0.48527175f, 0.02127617f, -0.03726387f, -0.05855381f, 0.04083496f, -0.04460879f, -0.05760122f, 
    0.01961003f, 0.04392505f, 0.06138811f, -0.08951078f, 0.21466565f, -0.07389437f, 0.18533744f, -0.09455003f, 
    -0.07331644f, 0.01195293f, 0.02514233f, -0.02173072f, 0.08593820f, 0.02407806f, 0.13575311f, 0.18530624f, 
    -0.54126215f, 0.37693161f, 0.11028337f, 0.23970494f, -0.07265184f, -0.16587396f, 0.06085128f, 0.11308800f, 
    -0.03866762f, 0.16003969f, 0.17056219f, 0.10681176f, 0.15167503f, 0.01091746f, 0.11318190f, -0.07101073f, 
    -0.04504868f, -0.03287188f, 0.10266444f, -0.00443338f, -0.00259486f, 0.07584373f, 0.10652139f, -0.09070206f, 
    0.08975959f, 0.06066856f, -0.01681672f, 0.08962539f, -0.11193778f, -0.13920599f, -0.05643369f, 0.10327408f, 
    -0.17412995f, 0.04089255f, 0.14728507f, -0.07603677f, 0.17032498f, 0.09757972f, 0.07104082f, 0.03876181f, 
    0.00653600f, -0.12989914f, -0.06775306f, -0.09576865f, 0.01272593f, 0.17014770f, 0.03357148f, 0.06278922f, 
    -0.11744569f, -0.08042941f, -0.00466702f, 0.04209001f, -0.08861274f, 0.03573730f, 0.04061525f, 0.07023408f, 
    -0.07294140f, 0.11262967f, 0.06138164f, 0.18588240f, -0.11570302f, 0.41123474f, -0.15969619f, -0.06007098f, 
    0.05764274f, 0.07819010f, 0.39376602f, -0.09822175f, -0.07870011f, -0.01848444f, -0.15341631f, -0.05999313f, 
    -0.04298628f, -0.47375751f, 0.29495224f, 0.00975042f, 0.02400827f, -0.09471096f, 0.07160433f, -0.16612193f, 
    0.18246946f, 0.29927954f, 0.21524023f, 0.10195715f, -0.11156505f, 0.11767524f, -0.03846125f, -0.03917255f, 
    -0.08578882f, -0.02127489f, -0.10989069f, -0.05574655f, -0.08606870f, 0.07240941f, 0.09457795f, 0.15849139f, 
    -0.35064015f, 0.33313128f, 0.02874840f, 0.06988823f, 0.00668307f, -0.00757540f, 0.12221298f, -0.04926573f, 
    -0.03626496f, -0.15577324f, 0.06588276f, 0.12537901f, 0.15069899f, -0.02380962f, -0.37510771f, 0.25962496f, 
    -0.02499109f, 0.26769722f, 0.11426846f, 0.04633314f, 0.15915969f, -0.05877348f, -0.07362375f, 0.02634041f, 
    -0.08650623f, -0.15630671f, -0.13217174f, 0.09668656f, -0.02948611f, 0.02078676f, -0.26303682f, -0.15451396f, 
    -0.08877552f, -0.02420005f, 0.12892286f, 0.09985173f, -0.29651749f, -0.19682543f, -0.14237861f, -0.24287875f, 
    -0.07302084f, 0.11955831f, -0.03835193f, 0.01981649f, -0.04452522f, -0.05843648f, 0.11902176f, 0.19108151f, 
    0.00487837f, 0.09540714f, 0.09763767f, -0.06339178f, 0.03321999f, -0.06424004f, 0.06660780f, -0.02639386f, 
    0.11783680f, 0.09339619f, 0.15999746f, -0.23788963f, 0.18046795f, 0.06575626f, -0.03720054f, 0.23810028f, 
    0.10354877f, 0.03973993f, 0.17181300f, 0.15472481f, -0.04081633f, -0.06537326f, -0.09784388f, -0.16102077f, 
    -0.05435846f, -0.00278111f, -0.20207696f, -0.06926563f, 0.07212846f, 0.07038751f, -0.12441280f, 0.18411149f, 
    0.00272349f, 0.05753034f, -0.14970209f, -0.09238219f, 0.09992285f, 0.17083798f, 0.00425562f, 0.17200741f, 
    -0.03160512f, 0.17928107f, 0.01333895f, 0.03786077f, 0.04548539f, -0.09733046f, 0.23552983f, -0.00326055f, 
    0.45638904f, 0.25682914f, 0.22456951f, 0.17157783f, 0.03010411f, 0.09887498f, -0.02128158f, 0.01106564f, 
    -0.19525249f, 0.13238248f, 0.05542111f, -0.07378414f, -0.35609442f, -0.02670652f, 0.14283353f, -0.19704510f, 
    -0.08483415f, -0.10467231f, -0.04949827f, -0.03064771f, -0.00446903f, 0.04729406f, -0.11651964f, 0.06716094f, 
    -0.08785230f, -0.08314516f, 0.01795663f, -0.02710738f, -0.08214853f, 0.00583455f, 0.06661057f, 0.02203901f, 
    0.08947267f, -0.11364520f, -0.09202853f, -0.09807020f, 0.12416955f, -0.12436181f, 0.18316343f, -0.14555387f, 
    0.08274056f, -0.08621855f, -0.05567450f, 0.05236639f, 0.06186548f, -0.06857581f, -0.17655830f, -0.30741709f, 
    0.03258083f, -0.09505795f, -0.13860738f, -0.13953304f, 0.07975218f, -0.01640708f, 0.00388343f, 0.10831904f, 
    0.12147366f, -0.01244516f, 0.13267793f, -0.00633957f, -0.19845870f, -0.02757697f, 0.00970631f, 0.15631680f, 
    0.09666877f, -0.11878783f, -0.08713785f, -0.00358491f, -0.00143999f, -0.19194697f, -0.05335900f, -0.03808460f, 
    -0.27661982f, 0.25061512f, -0.16886210f, -0.05102962f, 0.04672933f, -0.09916968f, 0.03782593f, -0.01326263f, 
    0.24282037f, 0.15730335f, 0.08408462f, -0.01351168f, 0.27623773f, -0.22796883f, -0.02770104f, -0.14187750f, 
    0.07998368f, 0.13950828f, -0.09476252f, -0.04218157f, 0.22159739f, 0.18572484f, 0.20914754f, 0.22335689f, 
    -0.17750844f, -0.17313226f, 0.08020870f, 0.11988640f, 0.02075007f, 0.05345692f, -0.08545223f, 0.15162390f, 
    -0.13086778f, -0.02792702f, -0.13235225f, -0.15797409f, -0.31661254f, -0.31877777f, 0.37200618f, 0.04816542f, 
    -0.00089882f, 0.06418014f, -0.19742620f, 0.14309083f, 0.16397643f, 0.08125731f, 0.16030970f, 0.13242459f, 
    -0.13563013f, -0.38906804f, -0.02214556f, 0.04632007f, 0.07020039f, 0.14250661f, -0.01262622f, 0.09468176f, 
    -0.01420050f, -0.14353178f, -0.17990431f, -0.10632578f, -0.00990532f, -0.13006490f, -0.21176906f, -0.02098164f, 
    0.08358955f, 0.19765337f, 0.03257111f, -0.00614819f, -0.03113378f, -0.08679718f, -0.04979666f, -0.14900632f, 
    0.08560544f, 0.04313308f, -0.09564113f, 0.04621741f, 0.10023389f, -0.09611990f, 0.07972711f, 0.23526807f, 
    0.01921742f, -0.09792015f, 0.01989188f, -0.01111961f, -0.21795915f, 0.13951953f, -0.02932550f, -0.45319089f, 
    0.05913430f, -0.10128392f, -0.04595111f, -0.06386393f, 0.04232995f, 0.14913437f, -0.04028700f, -0.15436390f, 
    -0.33414203f, 0.12871017f, 0.03066962f, 0.06379776f, -0.00911264f, -0.01183761f, 0.09917010f, -0.12177065f, 
    0.09765422f, -0.11909394f, 0.10911250f, 0.16880970f, 0.11296076f, 0.23070917f, 0.11745322f, 0.29099759f, 
    -0.11863636f, -0.15714970f, -0.11173164f, -0.00968559f, -0.11980540f, 0.11022075f, 0.34346500f, 0.02891930f, 
    0.28673899f, -0.09879454f, 0.83179373f, 0.37691680f, -0.33814135f, -0.18347605f, -0.24398632f, 0.24085274f, 
    0.12207106f, 0.22160101f, 0.27098370f, 0.19594721f, 0.19673157f, 0.21224505f, -0.54176766f, 0.18670686f, 
    -0.06763999f, 0.10092685f, 0.00684621f, -0.05564558f, 0.08680642f, -0.08495436f, 0.17635415f, 0.21010137f, 
    -0.12617540f, -0.16246721f, 0.06814136f, -0.01202607f, 0.08977520f, 0.12637314f, 0.09262757f, -0.16140349f, 
    0.01099042f, 0.07620703f, 0.15788312f, 0.01679726f, 0.01768162f, -0.17336117f, -0.01126410f, -0.03684463f, 
    -0.10313062f, 0.12844746f, 0.23809233f, 0.09206405f, 0.23314410f, -0.15281685f, 0.07601435f, 0.18044354f, 
    0.21970999f, 0.07578515f, 0.10522410f, -0.13357143f, 0.05315690f, -0.03851541f, -0.08750435f, -0.10631509f, 
    -0.04262517f, -0.05654580f, 0.01590900f, 0.10717893f, 0.14368090f, -0.09565889f, -0.09131994f, -0.00816328f, 
    0.25685674f, 0.04572379f, -0.02130679f, 0.11101469f, 0.16344322f, 0.09918060f, -0.09454979f, 0.06031495f, 
    -0.11316501f, 0.47810349f, -0.23353635f, 0.36307588f, -0.07564186f, -0.05359327f, 0.10655440f, -0.03737814f, 
    -0.00010058f, 0.02972843f, -0.00373563f, -0.03446610f, 0.26495779f, -0.40107539f, 0.06011950f, -0.07783577f, 
    -0.01864484f, -0.04081279f, -0.05264819f, -0.04092599f, 0.00088871f, -0.09132204f, -0.03894708f, -0.37156802f, 
    0.32422644f, -0.30882445f, -0.05819181f, 0.08659025f, 0.04657285f, -0.03335697f, -0.02528306f, 0.05636113f, 
    -0.05609152f, 0.21131334f, 0.01290719f, 0.00861579f, 0.01070620f, -0.17370650f, 0.13437422f, -0.12893093f, 
    0.02291479f, -0.05716930f, -0.10418795f, 0.00831002f, 0.09984095f, 0.03234828f, -0.05824581f, -0.06926919f, 
    -0.08503567f, -0.06193883f, 0.06773447f, -0.17290217f, 0.15311606f, 0.15069436f, 0.29420620f, 0.00929196f, 
    -0.01337198f, -0.01558025f, -0.12082668f, 0.08455710f, 0.02803985f, 0.12748823f, 0.01650825f, 0.11513162f, 
    -0.01397136f, -0.04994569f, -0.11389842f, 0.03343417f, -0.08987914f, 0.03444548f, -0.02226825f, 0.00351894f, 
    0.31434700f, -0.10165595f, -0.05411752f, -0.00127872f, 0.00599747f, 0.08936612f, 0.05555812f, 0.14637241f, 
    -0.00191851f, -0.13983238f, 0.05891367f, 0.08645960f, -0.16369897f, 0.22659595f, 0.23266229f, -0.09845328f, 
    -0.00935739f, -0.02969423f, 0.04887158f, 0.07584848f, 0.00505639f, 0.02057549f, 0.09173670f, 0.13628258f, 
    -0.01397797f, 0.06666368f, 0.09832702f, 0.13178256f, -0.08893929f, -0.15041851f, 0.10720310f, -0.19150142f, 
    0.00068456f, -0.02357987f, 0.11982006f, 0.06262129f, -0.08558599f, 0.04224652f, -0.13653842f, -0.06419344f, 
    0.04086795f, -0.10157644f, -0.04620955f, -0.09399728f, 0.04962561f, 0.07533231f, 0.09939148f, -0.05590481f, 
    -0.02110315f, -0.48542914f, -0.17821769f, -0.21590258f, -0.10526648f, -0.00658880f, -0.03892313f, 0.10637157f, 
    0.38257214f, -0.14570284f, -0.05624824f, 0.00381022f, 0.15254375f, 0.13293342f, -0.12210909f, 0.20411390f, 
    0.06969108f, 0.08822666f, -0.00751135f, 0.03274880f, 0.03493156f, -0.03818892f, 0.03049712f, -0.05637893f, 
    -0.08299301f, -0.04219822f, -0.01764620f, -0.03716435f, -0.07564186f, -0.07330447f, -0.01187757f, 0.02822968f, 
    -0.07361996f, -0.02297210f, 0.01577119f, -0.06062470f, -0.07372860f, -0.06722233f, -0.04564937f, -0.04980034f, 
    -0.07585494f, -0.01400949f, 0.00809799f, -0.08178452f, -0.02284706f, -0.06489719f, -0.04164365f, -0.00929758f, 
    0.04522129f, -0.01219515f, -0.04106690f, 0.01579654f, 0.00764906f, -0.04245811f, 0.04337148f, -0.00592324f, 
    -0.04946246f, -0.00107116f, 0.05318616f, -0.04386050f, -0.03353136f, -0.05303502f, 0.00491318f, 0.04118380f, 
    0.03574945f, -0.08060557f, -0.09704998f, 0.01213042f, 0.02166047f, -0.07959595f, 0.02074365f, -0.06024135f, 
    -0.02826097f, -0.04448607f, -0.07084651f, 0.04252306f, -0.03680490f, 0.04109394f, 0.03331460f, -0.03019134f, 
    0.01143105f, 0.03526482f, 0.01612557f, -0.07465290f, -0.01392047f, 0.04410901f, 0.01055370f, -0.04054821f, 
    0.00919899f, -0.02863694f, 0.05161731f, -0.02731488f, -0.08768618f, -0.07917726f, -0.04919621f, 0.03692691f, 
    -0.07577557f, -0.00827115f, -0.03339435f, -0.06179633f, -0.04784517f, -0.01054972f, -0.07505161f, 0.00288700f, 
    -0.04844194f, -0.04111030f, -0.05385811f, -0.00445045f, -0.00612805f, 0.00153544f, 0.02426352f, 0.02330802f, 
    -0.04646940f, 0.01165243f, -0.03939097f, -0.01635878f, -0.07228521f, -0.02230909f, -0.01242149f, -0.07077727f, 
    0.04570944f, 0.05015644f, 0.03209424f, 0.01982523f, 0.02527386f, -0.07413325f, 0.05242664f, 0.04183042f, 
    -0.00655767f, -0.03227687f, 0.03577579f, -0.02954134f, -0.04062362f, -0.05202670f, 0.04158152f, 0.03085376f, 
    -0.06589173f, 0.04926455f, 0.05018721f, 0.02045002f, -0.03869261f, 0.04935167f, 0.01253198f, -0.06410355f, 
    -0.04858514f, -0.06526817f, -0.07422049f, -0.01859910f, -0.01960037f, -0.07020637f, 0.02211757f, 0.02358315f, 
    -0.03775817f, 0.02926834f, 0.04600178f, 0.02465003f, -0.03288178f, -0.01625721f, -0.05793054f, 0.03373135f, 
    -0.00345626f, 0.01426153f, -0.01102812f, -0.00665556f, -0.00684846f, 0.04905097f, -0.01893909f, 0.00424247f, 
    -0.05944958f, 0.01577833f, 0.01003993f, 0.02239943f, 0.04402122f, -0.06076235f, -0.00311646f, -0.04264373f, 
    -0.01569911f, -0.03965597f, -0.04015511f, -0.03739675f, -0.08384534f, -0.01609672f, 0.04158702f, 0.02407361f, 
    -0.00662426f, -0.03485416f, -0.00635357f, 0.03232376f, 0.00823873f, -0.07634211f, 0.01062210f, -0.08256087f, 
    -0.00802977f, 0.05385997f, 0.01983146f, 0.04055557f, -0.00155259f, -0.06855715f, -0.01866528f, 0.03599183f, 
    0.02644362f, 0.04454039f, 0.01215088f, -0.06269941f, -0.01928179f, -0.07640815f, 0.01017588f, -0.06927399f, 
    0.01842703f, 0.03887475f, -0.02666932f, -0.01604788f, -0.06696112f, -0.04982517f, 0.04443851f, -0.00437026f, 
    0.01570257f, -0.07531710f, -0.14803083f, -0.11034530f, -0.01184538f, -0.05471723f, 0.03236245f, -0.01292026f, 
    0.15329409f, 0.19110534f, 0.13483642f, 0.05677953f, 0.14840785f, -0.09481107f, 0.01007788f, -0.06038416f, 
    0.08155733f, -0.07553975f, -0.03841580f, 0.06495685f, 0.15233189f, 0.20610927f, 0.29368895f, 0.21658503f, 
    -0.27307910f, -0.39004686f, 0.05872692f, 0.20958963f, -0.06496181f, 0.04396507f, -0.11867345f, -0.00252709f, 
    0.04799677f, -0.10204961f, 0.02817771f, 0.17752635f, 0.18182430f, 0.36675355f, 0.18976383f, 0.16345973f, 
    0.15916128f, 0.15785286f, 0.11572190f, -0.10720943f, -0.03528948f, -0.04525150f, -0.10254933f, -0.05634235f, 
    -0.24388161f, 0.05460519f, 0.14595124f, 0.18938820f, 0.03097346f, -0.10765920f, -0.02826764f, -0.01861481f, 
    -0.02864418f, -0.00021629f, 0.05484651f, 0.04671831f, 0.00950009f, -0.11139536f, 0.31190029f, -0.06732537f, 
    -0.02699107f, 0.08887838f, -0.17833471f, -0.02597575f, 0.12303066f, -0.14274590f, 0.09753732f, -0.31450117f, 
    -0.04826324f, 0.39338222f, 0.32477462f, -0.08992618f, -0.04081109f, 0.21688989f, 0.16840979f, 0.40248665f, 
    0.08556141f, -0.00314554f, -0.00325760f, 0.10955898f, 0.17620921f, 0.49417719f, -0.11071534f, -0.15215100f, 
    0.23086949f, 0.16374202f, 0.04077108f, 0.07304160f, 0.05486116f, -0.08822367f, -0.02802996f, -0.01633239f, 
    -0.13065340f, -0.17712559f, -0.20278062f, -0.27992219f, 0.13408503f, -0.08320102f, -0.00907495f, -0.01196519f, 
    0.13223849f, 0.07677069f, 0.05059275f, -0.03013243f, -0.33114120f, -0.30124718f, -0.28320083f, 0.28288621f, 
    -0.02924374f, -0.02791338f, -0.10843740f, 0.07321509f, 0.05170387f, -0.04276993f, -0.04769623f, 0.11528438f, 
    -0.20257932f, -0.37132430f, 0.03577098f, -0.14233065f, 0.21401347f, -0.00838395f, -0.12039532f, -0.03636786f, 
    0.26401708f, 0.14791492f, 0.21473157f, 0.10983676f, 0.78197598f, 0.03029405f, -0.08095252f, 0.00386156f, 
    -0.08138566f, 0.06336150f, -0.02701232f, 0.05883018f, 0.05864834f, -0.04596251f, -0.04756792f, -0.05916210f, 
    0.09503528f, 0.36747140f, 0.02201404f, 0.09521152f, 0.26256466f, 0.19237605f, 0.20174688f, 0.31062904f, 
    0.05844330f, -0.04791266f, -0.03679004f, 0.00030649f, -0.03709558f, 0.01092662f, 0.26351732f, 0.25235191f, 
    0.12092817f, 0.01593056f, -0.07669915f, 0.02626135f, -0.05151224f, 0.07974029f, -0.03942924f, -0.02291079f, 
    0.25165343f, 0.08002715f, -0.10801676f, 0.12099402f, 0.19350590f, -0.02394638f, -0.12015314f, -0.26871789f, 
    -0.07080334f, 0.00848101f, 0.01387537f, -0.08064891f, -0.41987532f, -0.16880667f, -0.25132823f, 0.13495290f, 
    -0.05015052f, 0.01485554f, -0.12079210f, -0.14283705f, 0.02297083f, 0.08823264f, -0.09003242f, 0.02912886f, 
    0.00563994f, -0.17414744f, -0.13426557f, -0.16717398f, -0.00343581f, -0.15842468f, -0.04349999f, -0.00081983f, 
    -0.10592107f, 0.28456080f, -0.14233978f, 0.12417953f, 0.24770416f, 0.00559392f, 0.00630106f, -0.00877273f, 
    -0.09717239f, 0.19650570f, -0.10580806f, 0.11498985f, 0.37543425f, 0.09314568f, 0.21543470f, 0.04250416f, 
    0.21698937f, 0.01883256f, 0.03922613f, -0.13602062f, -0.23664144f, -0.16013229f, -0.07739207f, -0.18493950f, 
    0.00066090f, -0.15853231f, 0.19354987f, 0.12067361f, -0.23615645f, 0.27592996f, -0.04269794f, -0.00762199f, 
    -0.14431721f, 0.16764496f, 0.25406247f, -0.06892322f, 0.05372695f, 0.01361260f, -0.01316723f, 0.16126829f, 
    -0.28317016f, -0.49008086f, 0.17848411f, 0.22556965f, -0.24956132f, 0.01249909f, 0.04056017f, 0.05867800f, 
    0.07962072f, 0.13632192f, 0.23095462f, 0.06935018f, 0.20134427f, 0.13379426f, 0.19386433f, -0.24425496f, 
    0.11471476f, -0.12153648f, -0.11691330f, -0.19595404f, -0.15444998f, -0.16406164f, -0.15143394f, -0.30912960f, 
    -0.08334433f, 0.10255263f, -0.05332559f, -0.10111879f, -0.04746157f, 0.09161252f, 0.16813616f, -0.00149869f, 
    -0.05730619f, -0.01466112f, 0.08619352f, 0.16311254f, 0.23270941f, 0.08943722f, -0.03196468f, -0.05333076f, 
    -0.02973546f, 0.08008859f, 0.11732354f, 0.09099842f, 0.08527698f, -0.07086007f, -0.20577554f, -0.24494764f, 
    -0.23942126f, 0.01630376f, -0.17106786f, -0.20502353f, -0.02664984f, -0.10842341f, -0.02848475f, -0.01912778f, 
    -0.12044129f, 0.14665490f, -0.12087091f, -0.10189007f, -0.11588321f, 0.09805585f, -0.05570995f, -0.02882596f, 
    -0.02198121f, -0.08691931f, -0.11799826f, 0.10047256f, 0.00844574f, -0.11014793f, 0.17000632f, 0.16069621f, 
    -0.11222877f, 0.28972715f, 0.03767515f, -0.12559782f, -0.17740157f, 0.01549141f, -0.02918130f, -0.26994562f, 
    0.11105570f, 0.22224857f, 0.19698836f, 0.19039139f, -0.05480207f, 0.15479437f, -0.23630291f, -0.22409862f, 
    0.11226668f, 0.15087983f, 0.03247375f, 0.18612038f, 0.08251562f, -0.03731080f, -0.13942769f, -0.04166584f, 
    -0.03451905f, 0.27131119f, 0.02223283f, -0.09372125f, -0.01603003f, 0.08942922f, 0.09660389f, 0.08994295f, 
    0.03302851f, 0.03343768f, 0.07525859f, 0.16852058f, 0.08193588f, -0.07759751f, -0.04275871f, 0.06744115f, 
    -0.04457099f, -0.02348197f, 0.15907797f, 0.08336821f, 0.07847042f, 0.16583252f, -0.11884458f, 0.21091336f, 
    0.31813529f, 0.08512464f, 0.08383941f, -0.13267744f, -0.22346693f, 0.05607218f, 0.01291732f, 0.02570814f, 
    0.24645577f, -0.11357987f, -0.02870323f, -0.00928970f, -0.15029204f, 0.08838575f, 0.15348740f, 0.08223581f, 
    -0.01679460f, 0.01905641f, -0.23970205f, -0.06920237f, -0.02837853f, -0.10992318f, -0.03790336f, -0.00856664f, 
    0.13011979f, 0.11431906f, 0.05335116f, 0.10674869f, 0.15118945f, 0.27899775f, -0.09695914f, -0.06933933f, 
    -0.07493412f, -0.09329495f, 0.03504802f, -0.02987479f, 0.22220962f, 0.03080102f, 0.04918896f, 0.08288874f, 
    0.16533460f, -0.04640317f, -0.00001687f, -0.02378376f, -0.02969922f, -0.02149567f, 0.03110135f, -0.03478717f, 
    0.26624385f, 0.03558581f, -0.00962533f, 0.04622271f, 0.03665375f, 0.06704820f, -0.00096401f, 0.00313412f, 
    0.03372482f, 0.13797365f, 0.05810092f, 0.01879791f, -0.17550249f, 0.30724546f, -0.15891038f, 0.02884890f, 
    -0.04800975f, -0.00229536f, 0.18181147f, -0.17340222f, -0.10585061f, 0.06071470f, -0.14064434f, -0.00817550f, 
    -0.15093218f, -0.22128075f, 0.19877042f, -0.06250364f, 0.02196208f, -0.03194299f, -0.03311191f, 0.09910030f, 
    0.20828055f, 0.11638782f, 0.13052796f, 0.00766603f, 0.16307038f, -0.07663961f, -0.45471659f, -0.12398476f, 
    -0.15948932f, -0.05112600f, -0.23875554f, -0.36272264f, 0.14288889f, 0.12827092f, 0.06619401f, -0.07346387f, 
    -0.43536201f, -0.22206897f, -0.32235971f, 0.24287100f, 0.05102474f, -0.06105346f, 0.01929665f, -0.13869579f, 
    -0.10639556f, -0.05302992f, -0.10349672f, 0.05857383f, -0.24953762f, -0.15570538f, 0.18210164f, 0.44231173f, 
    0.12589332f, 0.08692547f, -0.12200268f, 0.04929735f, 0.00965445f, 0.13153405f, -0.00276290f, 0.07706472f, 
    0.07798603f, 0.01008095f, -0.10877825f, 0.11461827f, 0.10049094f, 0.18381779f, 0.02247852f, -0.03509214f, 
    -0.04028132f, -0.21683103f, -0.03668084f, 0.01327507f, 0.08954351f, -0.06626642f, 0.26280412f, -0.17364776f, 
    -0.11473624f, 0.05670813f, 0.15984909f, 0.01893597f, -0.08209550f, 0.04797729f, 0.00277135f, 0.04868522f, 
    0.05882734f, 0.09834131f, -0.00941408f, 0.17491500f, 0.03433116f, -0.03926339f, -0.10690806f, 0.39535731f, 
    0.16514631f, -0.09552749f, 0.13043979f, -0.06402687f, 0.12769195f, 0.17924473f, 0.28301769f, -0.10465124f, 
    0.08039326f, -0.08061591f, 0.05648681f, 0.09778316f, -0.04038092f, -0.00670559f, 0.01169417f, -0.10293929f, 
    -0.23355030f, -0.07291906f, 0.03580864f, 0.09335028f, -0.08886520f, -0.05799988f, -0.08777805f, -0.20326197f, 
    -0.10588779f, -0.11256585f, 0.16683099f, 0.08641623f, 0.02617979f, 0.13420507f, -0.01930323f, 0.13934432f, 
    -0.08948175f, -0.06864201f, -0.01723205f, 0.02979504f, -0.02759228f, -0.04530851f, 0.23387434f, -0.12926631f, 
    -0.07095098f, 0.01488557f, 0.51723272f, 0.16069958f, -0.17055316f, -0.14316742f, 0.01547654f, 0.06570377f, 
    -0.17030980f, 0.16551691f, 0.18977953f, 0.06906033f, -0.01645565f, -0.01512396f, 0.06250928f, -0.04284826f, 
    -0.04657764f, 0.01184225f, 0.08677587f, 0.04284293f, 0.18495390f, 0.09452926f, 0.02576590f, 0.10219027f, 
    0.00130027f, -0.15926783f, -0.06747093f, 0.04554460f, 0.04767237f, -0.03614436f, -0.03975799f, -0.12579143f, 
    0.06021401f, -0.02597938f, -0.04635984f, -0.08411871f, 0.08758823f, -0.03517929f, -0.10733812f, -0.00766877f, 
    -0.08216990f, 0.06173530f, 0.11456504f, 0.04910067f, 0.15015264f, -0.08482295f, -0.11817018f, -0.02028507f, 
    -0.02387936f, -0.16330612f, -0.13330436f, 0.27596673f, -0.00861125f, 0.01207118f, -0.01437400f, -0.03896901f, 
    -0.02144399f, -0.02879959f, 0.04856742f, 0.01376108f, -0.02574228f, 0.14183970f, 0.22053996f, -0.06599105f, 
    0.01040543f, -0.04596191f, 0.01240611f, -0.31310904f, -0.01525525f, 0.06684384f, 0.11011939f, -0.05357155f, 
    -0.23518278f, 0.10616933f, -0.04462337f, 0.18962869f, -0.04319929f, -0.13090354f, -0.01872110f, -0.07374247f, 
    0.00632793f, 0.12183839f, -0.11702290f, -0.00157381f, 0.28390729f, -0.17658517f, -0.14166020f, -0.13891973f, 
    0.01327316f, 0.00506686f, -0.11972255f, 0.01856722f, -0.02042541f, -0.05116166f, -0.03985843f, -0.28760946f, 
    -0.30372813f, -0.08153329f, 0.03711059f, 0.14319451f, -0.07222692f, 0.05300407f, 0.04990472f, 0.18540864f, 
    0.04877634f, 0.12444913f, 0.00113236f, -0.00248279f, -0.16517186f, -0.00132392f, 0.30694214f, -0.05133888f, 
    0.03988048f, -0.12213130f, 0.04876043f, 0.06310082f, 0.11459012f, 0.06810220f, 0.00700611f, -0.03708007f, 
    -0.04178385f, -0.08649590f, -0.04811332f, -0.02264750f, -0.03884427f, 0.04644760f, 0.13925044f, 0.01351305f, 
    -0.03586290f, -0.11740282f, -0.18092512f, -0.11155234f, 0.22688977f, -0.06275825f, -0.06545145f, -0.11307629f, 
    -0.00095376f, -0.06108958f, -0.03061736f, 0.09786350f, -0.03219859f, -0.09997906f, 0.01073761f, -0.05314551f, 
    -0.17515607f, -0.08527155f, -0.05797275f, 0.19300549f, -0.05523673f, -0.19612511f, -0.05557446f, 0.10642240f, 
    0.12270208f, 0.03899350f, 0.12457363f, 0.00593176f, 0.02242768f, 0.26188514f, 0.02722200f, -0.62406480f, 
    -0.13024476f, -0.00734663f, -0.18377812f, 0.11734276f, 0.01869816f, -0.01241210f, -0.01222211f, -0.08583911f, 
    -0.07348800f, 0.39212784f, 0.24944825f, 0.07819410f, -0.07297777f, 0.03131434f, 0.09339762f, 0.01509823f, 
    0.01390301f, -0.02077696f, 0.16384779f, 0.04953359f, -0.18990901f, 0.03341042f, 0.04569218f, 0.15771405f, 
    0.06084922f, -0.11781295f, -0.09212209f, 0.01218878f, -0.08607616f, 0.03991564f, 0.18441604f, -0.16098867f, 
    -0.21823297f, -0.30026421f, 0.18662807f, 0.02978407f, -0.04895444f, 0.03829664f, 0.01242846f, 0.10309356f, 
    0.22098678f, -0.11498476f, -0.08294094f, 0.03866024f, 0.18159927f, -0.22956717f, -0.00317347f, 0.30758667f, 
    0.05259515f, 0.07951927f, -0.03632284f, 0.02228354f, 0.05157151f, -0.07321616f, 0.04858648f, 0.04045377f, 
    0.02898287f, -0.13935405f, -0.11587650f, 0.03200874f, 0.06519445f, -0.11180123f, 0.01369513f, 0.11113157f, 
    -0.05045881f, 0.07682347f, -0.14115235f, -0.11889753f, 0.23734909f, -0.10620752f, 0.14539021f, -0.03066670f, 
    -0.02861662f, 0.06412898f, 0.08391365f, 0.06912141f, -0.00056977f, -0.04348357f, -0.03460003f, -0.06918482f, 
    0.11936864f, 0.02206422f, 0.05438379f, 0.30969009f, 0.01266614f, -0.03671274f, -0.08561515f, 0.04219382f, 
    0.00090714f, -0.07094584f, -0.04646799f, -0.10390359f, -0.24213155f, 0.25655904f, 0.06565592f, 0.12497465f, 
    0.07706859f, -0.03449377f, 0.10941355f, -0.26505452f, -0.02560252f, 0.07158176f, 0.10205520f, -0.16576988f, 
    -0.73802185f, -0.10542467f, 0.09726049f, 0.32904088f, -0.00289257f, -0.10263569f, 0.07591837f, -0.02684908f, 
    0.14434989f, 0.15988007f, -0.03986850f, 0.11218158f, 0.54778838f, -0.05590819f, 0.09686988f, -0.11724722f, 
    0.04501565f, 0.11278316f, 0.01824262f, 0.07610825f, -0.17161639f, -0.09840785f, 0.15884303f, -0.19806768f, 
    -0.25038600f, -0.16770566f, 0.12049757f, 0.26254594f, 0.08865584f, -0.06842656f, -0.05098237f, 0.12891473f, 
    0.02678507f, -0.06863949f, 0.05911335f, 0.02560692f, -0.27742323f, -0.12506559f, 0.21469954f, 0.06783266f, 
    -0.11374767f, -0.05410105f, -0.09545472f, 0.20051204f, 0.19559196f, 0.02216993f, 0.07381089f, -0.02130553f, 
    0.01120732f, -0.00424153f, -0.06520201f, -0.09394582f, 0.03817039f, 0.11210179f, 0.12178465f, 0.03339746f, 
    0.00224442f, -0.05547643f, -0.09658506f, -0.05268483f, 0.07822704f, -0.09465493f, -0.14133239f, -0.14973572f, 
    0.04044103f, 0.04043503f, -0.07172474f, 0.02671362f, 0.02065949f, -0.08248414f, 0.06343696f, 0.02583999f, 
    0.01608581f, 0.00572657f, -0.09925974f, 0.07118357f, 0.05548020f, -0.00246107f, 0.14786024f, 0.20536308f, 
    0.01828626f, 0.11050970f, 0.13422771f, 0.03449776f, 0.07905241f, 0.33457330f, 0.02906195f, -0.54703051f, 
    -0.08211675f, -0.11988498f, -0.00311351f, 0.11225025f, 0.03732267f, 0.08821815f, 0.00586628f, -0.15928522f, 
    -0.31550092f, 0.15286346f, 0.09973623f, 0.05390568f, -0.05008798f, -0.00748592f, 0.11632665f, -0.08703920f, 
    0.16733715f, 0.01663563f, 0.05186276f, 0.14348294f, -0.40664017f, -0.18049385f, 0.01457495f, 0.41618919f, 
    -0.02203565f, 0.03394189f, -0.03989347f, -0.07974219f, -0.05051675f, -0.06426220f, 0.15762544f, 0.03237379f, 
    0.36970398f, -0.34261569f, 0.29783314f, 0.11568551f, -0.15983391f, -0.09767321f, -0.09483062f, 0.01205448f, 
    0.01551400f, 0.04757128f, 0.13203539f, 0.06413615f, 0.45358679f, 0.02283493f, -0.23212166f, 0.22371951f, 
    0.00971831f, 0.02967297f, -0.07342675f, 0.06294272f, 0.12464643f, -0.10965328f, -0.03109016f, 0.08246220f, 
    -0.18992864f, -0.05962525f, -0.00275430f, 0.06964786f, 0.06416130f, 0.10860241f, -0.22690375f, -0.06524228f, 
    0.19961087f, -0.00877917f, 0.08280749f, 0.03151322f, -0.23423442f, 0.01322802f, -0.04951834f, 0.13341743f, 
    0.08892854f, -0.13288236f, -0.03096980f, -0.03631006f, -0.02334943f, 0.05057663f, 0.03957692f, -0.02720500f, 
    -0.05404482f, -0.07948849f, -0.16659975f, -0.08794326f, -0.02191666f, 0.00533328f, 0.00288648f, 0.01615559f, 
    -0.11122917f, -0.00745903f, 0.00096676f, 0.06631269f, 0.49846813f, -0.27570456f, 0.01078148f, -0.11598077f, 
    0.02220912f, 0.05375578f, -0.15082784f, 0.13558561f, 0.12258324f, 0.09784596f, 0.07235201f, 0.00395970f, 
    0.43020931f, -0.00674403f, -0.12823182f, -0.33871683f, 0.07182744f, 0.03000453f, -0.01981463f, 0.11747957f, 
    -0.11220829f, -0.09625134f, 0.16139230f, -0.05353522f, -0.22362486f, 0.22610641f, -0.27233598f, 0.28782442f, 
    0.05418061f, 0.09897398f, 0.09929060f, 0.07004102f, 0.16674264f, 0.09565712f, -0.00647860f, 0.01829956f, 
    -0.16467883f, 0.20902447f, 0.14631699f, -0.15905522f, 0.08279066f, 0.13891478f, 0.09277271f, -0.00168167f, 
    0.09654081f, 0.08064972f, -0.06996100f, -0.08962495f, 0.11383700f, 0.26017988f, -0.16703914f, -0.05824611f, 
    0.11360702f, 0.01746629f, 0.19282833f, -0.18996823f, -0.13121270f, 0.09118363f, 0.07213165f, 0.06327529f, 
    0.04515898f, -0.05415670f, -0.04851870f, 0.06587911f, 0.10904822f, 0.15100862f, 0.01394056f, -0.11283433f, 
    0.08655518f, -0.01799233f, 0.03053430f, -0.06773074f, 0.16162299f, 0.00724543f, -0.12894315f, 0.08450807f, 
    -0.02917461f, 0.03180728f, 0.09965064f, -0.11199006f, -0.02169734f, 0.12694240f, -0.07786978f, -0.03550573f, 
    -0.14003056f, -0.19287051f, -0.08908612f, 0.07342067f, -0.03462204f, -0.09242268f, -0.05960989f, -0.02203789f, 
    0.05788359f, -0.33056971f, -0.22250606f, 0.33925986f, 0.12518805f, -0.18176395f, 0.08678515f, 0.25558844f, 
    -0.08180051f, -0.05123442f, -0.08327131f, -0.00276975f, 0.14994544f, 0.07953514f, 0.07136922f, -0.02076403f, 
    0.29029551f, -0.04679250f, 0.07968201f, -0.21757758f, 0.06056834f, 0.09284742f, 0.09781067f, -0.03687723f, 
    0.01206932f, 0.06086555f, 0.19237721f, -0.07322552f, 0.24343975f, 0.13755518f, 0.22742903f, -0.13432437f, 
    -0.02258239f, -0.07347393f, -0.01936826f, 0.00677089f, 0.14658190f, 0.11016001f, 0.03881208f, 0.04930140f, 
    -0.71636486f, 0.33953896f, -0.16640244f, 0.08133798f, 0.16697787f, 0.08199088f, 0.09155099f, 0.07285130f, 
    0.09628890f, 0.06408776f, -0.04478824f, 0.11182616f, 0.09064724f, -0.27398077f, -0.00552742f, -0.00347193f, 
    0.04363199f, 0.03360420f, 0.09419571f, 0.08431619f, -0.04714606f, 0.04635337f, -0.01054857f, -0.08064486f, 
    -0.10428523f, 0.14825936f, 0.06946104f, 0.01827250f, -0.08769880f, 0.04364879f, -0.36440900f, -0.03296794f, 
    0.10473701f, 0.12051822f, 0.08377978f, 0.07995914f, -0.03457700f, 0.12365849f, 0.30199391f, -0.03862755f, 
    -0.05683299f, 0.02997470f, -0.08779284f, 0.03148263f, 0.03368623f, 0.04604096f, 0.12529859f, -0.00097492f, 
    -0.15969840f, -0.06204812f, -0.39148933f, -0.32892063f, -0.08142278f, -0.13690522f, -0.12731975f, -0.00372700f, 
    -0.10167169f, 0.02194264f, -0.02733338f, -0.09515434f, -0.07086854f, -0.11018890f, -0.13788776f, 0.14639570f, 
    0.00853687f, -0.03984154f, 0.13082495f, 0.21313253f, -0.02650975f, 0.01668899f, -0.00265987f, 0.09215564f, 
    0.48058486f, -0.02388057f, 0.15675648f, -0.34356782f, 0.01469186f, -0.02519245f, -0.09554844f, 0.11147852f, 
    0.01811904f, -0.03264797f, 0.18135263f, 0.20799957f, -0.19793263f, 0.24201876f, -0.30984953f, 0.18917103f, 
    0.07731113f, 0.16469713f, 0.04400953f, -0.06396033f, 0.10291460f, 0.24667862f, -0.03561252f, 0.24290513f, 
    -0.18928054f, -0.11950130f, -0.25351936f, -0.02007125f, -0.09231197f, -0.09455133f, -0.00100138f, 0.12882350f, 
    -0.05605566f, -0.04403420f, 0.05881231f, -0.04282643f, -0.24319610f, -0.12827934f, -0.00341004f, 0.27652538f, 
    -0.03870418f, -0.07551102f, 0.00950902f, 0.08503024f, 0.03819155f, 0.11274350f, 0.08393332f, 0.13531180f, 
    -0.08605259f, -0.24510798f, -0.16191584f, 0.00576286f, 0.18646388f, 0.15701413f, -0.17210241f, -0.19804907f, 
    -0.04187300f, -0.06413393f, 0.02028349f, -0.05181778f, -0.19925337f, -0.16699952f, 0.29113856f, -0.02011811f, 
    -0.08620986f, 0.00135016f, 0.13201894f, -0.09274612f, -0.02930551f, 0.08708979f, -0.03485570f, -0.09719692f, 
    -0.17866030f, 0.15000133f, 0.04161569f, -0.24720907f, -0.17078690f, 0.06652544f, 0.06383836f, 0.27315551f, 
    0.16494632f, 0.18826357f, -0.14414287f, 0.11695541f, -0.13584761f, -0.22296900f, 0.27526900f, 0.37383941f, 
    0.05422604f, 0.07842924f, 0.08224872f, 0.03746236f, 0.01458671f, 0.00074975f, 0.02445562f, -0.02271607f, 
    -0.09332562f, -0.51189232f, -0.13376783f, 0.02962370f, -0.02836005f, -0.07651674f, 0.02863649f, 0.02917770f, 
    -0.00846037f, 0.04325240f, 0.01728837f, -0.05252133f, 0.43285382f, 0.20359370f, 0.23488235f, 0.00627145f, 
    0.02867616f, 0.04220971f, 0.02429649f, 0.02189090f, 0.18975024f, -0.03305013f, 0.24523756f, 0.32849577f, 
    -0.29555586f, 0.29736334f, 0.60798573f, 0.38263816f, 0.03553806f, -0.17345662f, -0.06240704f, 0.07901297f, 
    -0.17696199f, 0.23722833f, 0.02896213f, 0.02656318f, -0.13465701f, 0.28921482f, -0.06219180f, -0.15188384f, 
    -0.10832657f, -0.06390581f, 0.11451197f, -0.06244126f, -0.03837143f, 0.01254588f, -0.03672004f, 0.01447766f, 
    0.00234765f, -0.13526177f, -0.07293507f, -0.11466069f, 0.06548572f, 0.10183723f, -0.06419376f, -0.12488826f, 
    0.00938327f, 0.24520557f, 0.25309122f, 0.14618188f, 0.12218705f, -0.27473387f, 0.23272769f, -0.14918107f, 
    -0.09814069f, 0.03423734f, 0.12643985f, 0.08514395f, 0.23073176f, 0.11760192f, 0.02504907f, 0.35745269f, 
    0.04386515f, 0.11187956f, 0.02429576f, -0.06368653f, -0.19398697f, -0.09961443f, -0.01054781f, -0.03792086f, 
    0.03102600f, 0.12002490f, -0.10262724f, 0.18447714f, 0.00484198f, 0.36184260f, -0.12449197f, 0.07905313f, 
    0.18903869f, -0.03265032f, 0.18814448f, -0.00345040f, 0.15211423f, 0.17872703f, -0.01552059f, 0.11619534f, 
    0.23501837f, 0.12099641f, 0.03708106f, 0.28306386f, -0.02621073f, -0.09408633f, 0.03142368f, -0.06729471f, 
    0.04472867f, 0.02267599f, 0.07059605f, -0.04476639f, -0.06873174f, -0.18286686f, 0.15755793f, 0.02078568f, 
    0.00737536f, 0.04242103f, -0.15876935f, -0.04164259f, 0.01710057f, 0.01356770f, -0.00310507f, -0.15839842f, 
    -0.04870518f, -0.48548162f, -0.44473296f, 0.15236801f, 0.10297171f, 0.07549303f, 0.04614592f, 0.07452370f, 
    -0.12413768f, 0.07614239f, 0.00793661f, 0.08243549f, -0.10331144f, -0.13370523f, 0.01559700f, 0.19216503f, 
    0.06557495f, -0.04174271f, -0.05115705f, 0.08926146f, 0.05729700f, -0.05553862f, -0.01702416f, -0.05296508f, 
    -0.10733892f, 0.07803105f, -0.12323113f, -0.27337238f, 0.19599459f, 0.05273885f, -0.00735473f, -0.13031441f, 
    -0.07332765f, -0.03369355f, -0.04080014f, 0.03520543f, -0.06500221f, 0.06977826f, 0.46483541f, -0.08222091f, 
    -0.07385301f, -0.09167071f, -0.15343910f, 0.06905416f, 0.07227848f, -0.05383834f, 0.09274828f, 0.13390017f, 
    0.05286459f, -0.28013453f, -0.06398455f, -0.10353525f, -0.05477753f, 0.03915962f, 0.03710641f, 0.04868618f, 
    0.06578163f, -0.03981556f, 0.14999186f, -0.04895152f, 0.05003318f, 0.29470029f, 0.28767630f, 0.14522868f, 
    -0.03502788f, 0.05595106f, 0.23607361f, 0.11219333f, -0.03728693f, 0.19356380f, 0.07996308f, -0.01284721f, 
    -0.22396083f, -0.08531601f, -0.12188414f, 0.20687751f, -0.04367609f, -0.08320379f, -0.07452572f, 0.00686393f, 
    0.03530524f, 0.03774398f, -0.07550601f, 0.11283259f, -0.21019761f, 0.08875719f, -0.08631201f, -0.04598254f, 
    -0.13970165f, -0.12694460f, -0.18121380f, -0.07757798f, 0.11648836f, -0.11451458f, 0.21045963f, -0.32817632f, 
    0.27832165f, -0.61439615f, 0.28836146f, 0.05825035f, 0.08526805f, 0.06289475f, -0.06211025f, 0.01339807f, 
    0.00401616f, -0.01261720f, -0.04279446f, -0.07562036f, -0.41947946f, 0.22732303f, 0.08660477f, -0.13716044f, 
    -0.00843291f, -0.03220249f, -0.22532551f, -0.05080206f, 0.09721354f, 0.02553725f, 0.01075997f, 0.17070366f, 
    -0.08649355f, 0.00731759f, -0.03012158f, 0.24539998f, 0.05909011f, 0.14125729f, -0.10801282f, 0.08471323f, 
    -0.05802832f, -0.20424303f, 0.04851960f, -0.02697367f, 0.20868275f, -0.12369990f, 0.06019339f, 0.08638276f, 
    0.19396563f, -0.02506334f, -0.01335887f, 0.25652739f, -0.15420626f, -0.02520233f, -0.03902541f, 0.04860211f, 
    0.12351793f, 0.09922408f, -0.14568689f, 0.19238828f, 0.08595102f, 0.04545910f, -0.03862777f, -0.05976190f, 
    -0.11451799f, 0.10430311f, 0.00312533f, -0.30590662f, 0.15585773f, -0.10799327f, 0.19501390f, -0.11736582f, 
    0.17783956f, -0.23123571f, -0.08930050f, 0.17012694f, -0.03367529f, 0.03951592f, 0.01947704f, -0.04991731f, 
    -0.52862614f, 0.22756580f, 0.19322702f, 0.08870694f, 0.10777109f, 0.00925339f, -0.04317760f, 0.08935907f, 
    0.15533704f, 0.05102911f, 0.20725618f, -0.02786185f, 0.36711854f, -0.01763347f, -0.15068471f, 0.10175587f, 
    -0.06686706f, -0.05486043f, 0.07794086f, 0.11532332f, 0.12594180f, 0.07268923f, 0.42866740f, 0.28236076f, 
    -0.42214012f, -0.20102568f, 0.32412478f, 0.11400325f, 0.12508133f, -0.38057956f, -0.04669558f, 0.01512925f, 
    -0.06065298f, -0.20235041f, -0.07018559f, 0.01389853f, -0.10974260f, -0.33437616f, 0.09820359f, 0.15353774f, 
    -0.02289068f, 0.08593928f, -0.05689579f, -0.06022957f, 0.10690607f, 0.07203649f, -0.03739624f, -0.01023302f, 
    0.11104900f, -0.03041789f, -0.00640956f, 0.01808479f, 0.21916778f, 0.17528738f, 0.03925183f, 0.02173918f, 
    -0.00938946f, -0.05367818f, 0.01687863f, -0.02470663f, -0.00266774f, -0.11829872f, -0.29782635f, 0.01047521f, 
    0.00096943f, 0.04903219f, 0.10651391f, -0.11681860f, -0.04670633f, 0.08270906f, -0.13369112f, -0.07736159f, 
    0.27041093f, -0.04221055f, 0.06367821f, 0.20757402f, 0.19155452f, -0.08533042f, 0.11808991f, 0.15108512f, 
    0.14965789f, -0.14330341f, -0.10472173f, 0.25366011f, -0.13370858f, -0.31250066f, -0.06668540f, -0.59046775f, 
    -0.01661989f, -0.14126986f, 0.16799958f, -0.00122970f, 0.01118751f, 0.26121438f, 0.04158876f, 0.04524347f, 
    -0.00512260f, 0.04424711f, 0.23083559f, -0.18694852f, -0.05823735f, -0.02940425f, 0.03287252f, -0.15442844f, 
    0.10343233f, 0.06270266f, -0.02645236f, -0.04587737f, -0.06528839f, -0.09533522f, 0.00547245f, 0.25761497f, 
    -0.06029557f, -0.11497295f, -0.11277968f, -0.04608133f, -0.06152080f, 0.04877707f, 0.24251153f, 0.34945238f, 
    -0.19084731f, 0.02321358f, 0.18550345f, 0.28470549f, -0.19046706f, -0.11267301f, -0.10794747f, -0.14141229f, 
    -0.05361396f, 0.00932889f, 0.27430284f, 0.19389448f, 0.51682317f, 0.01971950f, -0.18212278f, -0.03339708f, 
    0.02894042f, -0.00497281f, 0.14594832f, -0.03910637f, -0.16374262f, -0.06196989f, -0.08089043f, 0.12206806f, 
    -0.00080461f, 0.00792608f, 0.06563649f, 0.05357101f, 0.02441577f, 0.00534544f, -0.05250122f, -0.07660018f, 
    -0.06293714f, -0.02232300f, 0.03800080f, -0.07688063f, -0.00191946f, 0.00226202f, 0.02927397f, 0.05790224f, 
    0.05234566f, -0.07325213f, 0.02988755f, 0.04923561f, -0.07251258f, 0.01371349f, -0.01206208f, 0.00730287f, 
    -0.02147471f, 0.02756597f, 0.03237655f, -0.05622638f, -0.02179069f, 0.03949159f, 0.00571113f, -0.05925415f, 
    -0.04928000f, -0.03474303f, 0.01475127f, 0.04621507f, -0.00634648f, -0.02249945f, 0.02008319f, -0.02935426f, 
    0.05673975f, -0.05005213f, 0.03463843f, -0.05035657f, -0.04399692f, 0.01774655f, -0.07461961f, -0.01767945f, 
    -0.03632425f, -0.02045170f, -0.03408280f, 0.00384671f, 0.02472801f, -0.06552032f, -0.01495425f, 0.05031224f, 
    0.01042849f, 0.02667672f, 0.02718095f, 0.05731014f, 0.02029230f, -0.04301644f, -0.03438981f, 0.05123961f, 
    0.00343846f, 0.00862921f, -0.06499624f, 0.00949975f, 0.01551379f, -0.07394498f, -0.03771253f, -0.00744762f, 
    0.04156262f, -0.03723079f, -0.03930674f, 0.04791505f, -0.05243327f, 0.06148718f, -0.00809092f, -0.02646695f, 
    -0.00061437f, 0.04585882f, -0.05034243f, -0.00255155f, 0.02683008f, 0.02246395f, -0.02049795f, -0.04804497f, 
    0.06236437f, 0.01285965f, 0.01215705f, 0.01467322f, -0.05052454f, 0.01794851f, -0.04945671f, 0.04619244f, 
    -0.02303631f, 0.01272274f, 0.02605188f, -0.03563562f, -0.05565784f, -0.05347556f, -0.03771848f, -0.03296653f, 
    -0.01311110f, 0.04441108f, 0.04641269f, -0.04835795f, -0.04614732f, -0.06337642f, -0.02952356f, 0.02399885f, 
    -0.06036166f, -0.03024224f, -0.04507499f, -0.01543157f, -0.00147141f, -0.06976392f, 0.05765102f, -0.03845875f, 
    -0.05999061f, -0.02351701f, 0.01663737f, 0.01748048f, 0.02409525f, -0.05801218f, 0.02951257f, 0.06254817f, 
    0.06073215f, -0.02100573f, -0.01526167f, 0.06541700f, 0.02445763f, -0.06043757f, -0.02141570f, 0.00819049f, 
    -0.00212136f, -0.05213531f, 0.03655576f, -0.06610281f, 0.03198496f, -0.01276044f, 0.00366160f, -0.01905873f, 
    0.05306091f, -0.02517261f, 0.04060092f, -0.03177028f, -0.00421654f, -0.07159790f, -0.06340379f, 0.01623852f, 
    0.00794858f, 0.02655510f, -0.00673266f, -0.01120972f, -0.05786302f, -0.05247484f, -0.03538843f, -0.03747471f, 
    -0.06434512f, -0.07205939f, -0.02912815f, -0.02504644f, 0.04037413f, -0.04730473f, 0.05209461f, -0.04611226f, 
    0.06287377f, -0.04206603f, -0.03840547f, -0.00907764f, -0.05059529f, 0.04308365f, 0.02073737f, -0.06212357f, 
    -0.05707546f, 0.02162264f, 0.00507538f, 0.01545815f, 0.01865653f, 0.00615566f, 0.00558849f, -0.04035914f, 
    0.03421612f, -0.07481252f, 0.05667860f, -0.01664164f, -0.01948885f, -0.07233858f, -0.07379232f, -0.04953819f, 
    -0.01379882f, 0.06880876f, 0.04415679f, 0.03724230f, -0.01795967f, -0.20849231f, -0.07250763f, -0.06190275f, 
    -0.16655900f, 0.01985261f, -0.16091965f, -0.00847081f, 0.06622817f, 0.02017466f, -0.04363709f, 0.05023059f, 
    0.12255036f, -0.08095552f, -0.18121950f, -0.01057521f, -0.13803907f, 0.01205060f, 0.05202997f, -0.19352774f, 
    -0.17402816f, -0.18665940f, -0.21520309f, 0.11537535f, -0.02877904f, 0.00111959f, 0.02397799f, -0.00403423f, 
    -0.06242377f, -0.00272498f, 0.14771205f, 0.06097898f, 0.13325971f, -0.04222156f, 0.18258108f, -0.03905315f, 
    0.06353141f, 0.03377898f, -0.17847149f, -0.04452263f, 0.03717842f, -0.01144593f, -0.10480279f, 0.02422738f, 
    -0.46928114f, -0.16317363f, 0.33428758f, -0.12399770f, 0.09270152f, 0.05731313f, -0.12142004f, 0.02581945f, 
    0.10875730f, -0.01754813f, 0.20795952f, -0.04192028f, 0.07939516f, -0.01248158f, -0.03963457f, -0.22250323f, 
    -0.00797700f, 0.00414904f, 0.06795102f, 0.13380791f, 0.09861817f, 0.00973709f, 0.10012115f, 0.11135338f, 
    -0.27535179f, 0.47294247f, 0.34170261f, -0.06895838f, -0.01942990f, 0.12369754f, 0.16025467f, -0.08348183f, 
    -0.01793446f, -0.17654060f, -0.01718480f, -0.10253970f, 0.29215193f, 0.30869779f, -0.06018094f, -0.09469883f, 
    0.02352827f, 0.15392153f, 0.00105171f, -0.05192402f, -0.05552634f, -0.11682317f, -0.10484557f, -0.12666270f, 
    0.06148819f, -0.01148617f, -0.08648784f, 0.03195993f, -0.01791278f, -0.03421825f, -0.16740552f, 0.03892257f, 
    0.01258644f, -0.01473574f, -0.05589625f, 0.00099682f, 0.17874224f, -0.00810554f, -0.36430579f, 0.35701808f, 
    0.03777903f, -0.08335577f, 0.01512084f, -0.07938370f, -0.05739045f, -0.04854581f, -0.10750356f, 0.07091590f, 
    -0.07327395f, -0.14882042f, 0.08157399f, 0.07495595f, 0.19005989f, -0.12494734f, -0.12609886f, -0.11084649f, 
    0.19200911f, -0.05998788f, -0.18536772f, 0.33500376f, 0.05257620f, -0.23948193f, -0.34090927f, -0.22987837f, 
    0.05608396f, 0.07526539f, -0.20555526f, -0.12552769f, -0.01083530f, -0.18552737f, -0.15711309f, -0.02421287f, 
    0.16131105f, 0.26023918f, 0.13361105f, -0.06922292f, 0.10913943f, 0.20064527f, 0.17945316f, 0.09579092f, 
    0.01877357f, 0.07038396f, 0.07676902f, -0.00858079f, -0.02023029f, -0.21009217f, 0.33670813f, 0.37403324f, 
    -0.04093791f, 0.01458560f, 0.11473386f, 0.08426251f, 0.08525065f, 0.15173285f, -0.12772483f, 0.32789597f, 
    -0.05231994f, 0.27784061f, -0.22250743f, 0.14541236f, 0.03163258f, -0.02810271f, -0.03334744f, -0.04741884f, 
    0.01698114f, -0.07327991f, 0.09251358f, -0.00021453f, -0.00886469f, -0.20788866f, -0.19630341f, 0.14425223f, 
    0.03884136f, -0.03854488f, 0.02948461f, 0.02277744f, -0.10744696f, -0.00389477f, 0.02576061f, -0.01677680f, 
    -0.00932021f, 0.05879169f, -0.02395331f, -0.00007127f, 0.00241969f, -0.04874501f, 0.04105080f, -0.06364149f, 
    -0.00669219f, -0.05116119f, -0.04062225f, -0.03373918f, -0.06487189f, 0.00838430f, -0.07153750f, 0.03135103f, 
    0.04998242f, 0.06609489f, -0.04263835f, -0.00233515f, -0.01899392f, 0.04082418f, -0.07459430f, 0.03615562f, 
    0.05093222f, 0.04902636f, 0.00211249f, 0.03290296f, -0.04020046f, 0.02391674f, -0.03278026f, -0.02525768f, 
    0.01170033f, 0.01500243f, -0.02503059f, -0.05715705f, 0.05423294f, -0.07042468f, -0.04532268f, -0.00863075f, 
    0.04977789f, 0.04084562f, -0.04206632f, 0.00882081f, -0.05309971f, 0.03886443f, -0.04734462f, -0.00943556f, 
    -0.05600704f, 0.02019511f, -0.01421879f, 0.03952191f, -0.04503683f, 0.00509959f, 0.03860150f, -0.00703367f, 
    -0.07151683f, 0.04686417f, 0.02001042f, -0.05801855f, -0.06632432f, 0.05204719f, 0.04796429f, -0.00140287f, 
    0.05437223f, 0.05704796f, -0.07617033f, -0.04915332f, -0.03970934f, -0.06604674f, 0.00234235f, -0.05653779f, 
    -0.00807109f, -0.04553033f, -0.06784798f, 0.06130672f, -0.01171987f, -0.07135782f, 0.05719949f, -0.07292510f, 
    0.05514101f, 0.05153225f, -0.00122364f, 0.00752300f, 0.02282468f, -0.04317814f, 0.06131316f, -0.06986261f, 
    -0.08409862f, 0.02957644f, -0.02706933f, 0.01896740f, -0.02518168f, -0.04406067f, 0.03642545f, 0.02047727f, 
    0.03277585f, -0.03147016f, -0.03772939f, 0.02160141f, -0.03024233f, 0.05522800f, -0.01366168f, 0.02664219f, 
    -0.04490205f, 0.00217647f, -0.02095346f, -0.03109235f, -0.04990307f, -0.02605812f, 0.01063337f, -0.04152255f, 
    0.01754303f, -0.06394207f, 0.02423460f, 0.05194061f, 0.02821699f, 0.04358210f, -0.05080017f, -0.07346128f, 
    0.00366549f, -0.07803645f, -0.04065146f, 0.05999245f, 0.01248599f, -0.02277895f, 0.04204210f, 0.01391097f, 
    -0.03711665f, -0.04409003f, -0.02386594f, -0.06497462f, 0.06442802f, -0.05031858f, -0.01669488f, 0.02161023f, 
    -0.01512107f, 0.03820779f, 0.04659842f, 0.02891934f, 0.04000762f, -0.00475334f, -0.04200774f, 0.03655837f, 
    -0.02610007f, 0.00275952f, 0.01590439f, 0.04966995f, -0.06014311f, -0.06604345f, -0.03169525f, -0.06371159f, 
    -0.05778533f, 0.04222602f, -0.03778543f, -0.00551638f, -0.01671905f, -0.00378453f, 0.00973191f, -0.07328313f, 
    -0.04614413f, -0.04598987f, 0.01980132f, -0.06437372f, -0.05900542f, -0.07053532f, -0.02688072f, -0.04743168f, 
    0.02539433f, -0.01260254f, 0.01516023f, 0.00699939f, -0.06414329f, 0.05138457f, -0.00018122f, -0.02482230f, 
    0.01517525f, -0.01418946f, 0.04953097f, -0.06618709f, -0.05970683f, -0.02693637f, -0.05125447f, -0.05388309f, 
    0.03556182f, -0.05225653f, 0.02428742f, 0.05690558f, -0.01188998f, -0.03537352f, -0.06342393f, 0.02499929f, 
    -0.13478652f, -0.11332648f, 0.08077076f, -0.07298952f, -0.13695365f, -0.15022701f, 0.15311311f, -0.14206791f, 
    -0.09495989f, 0.18614855f, 0.06069669f, -0.07102641f, -0.37516063f, 0.21756847f, 0.01430498f, -0.00225051f, 
    -0.18457752f, 0.18286650f, 0.12259530f, 0.05581446f, 0.13534985f, 0.12643602f, 0.20511080f, 0.14449614f, 
    -0.02748316f, 0.10457844f, 0.12261298f, 0.03233293f, -0.04104333f, -0.17983940f, -0.28102672f, -0.41467911f, 
    0.13138048f, -0.13388160f, 0.13741399f, 0.05766718f, 0.28182724f, -0.23427066f, -0.00733697f, 0.02477575f, 
    0.02405633f, 0.13884246f, -0.07517801f, 0.18735336f, 0.12245446f, -0.20402850f, 0.02958092f, -0.02253923f, 
    0.35048869f, 0.51586741f, 0.04121812f, 0.05494106f, -0.04645117f, 0.13037258f, -0.01606432f, -0.07330184f, 
    -0.05321349f, 0.06710213f, -0.03775595f, 0.08127064f, -0.02961635f, -0.10836486f, 0.03222089f, 0.02547163f, 
    0.05768375f, -0.11581857f, 0.17782946f, 0.08313714f, -0.13389657f, -0.13617587f, -0.18615787f, -0.49526253f, 
    0.31400132f, -0.19297397f, 0.08591887f, -0.13933977f, 0.16113403f, 0.22754620f, -0.02933757f, 0.14473541f, 
    0.00494559f, -0.00676938f, 0.06805053f, -0.06478997f, 0.12319433f, 0.19438286f, -0.07509433f, -0.37529385f, 
    0.21084808f, 0.03735201f, 0.31163740f, 0.00974865f, -0.09069970f, -0.12686497f, -0.10821297f, -0.15121692f, 
    -0.16811652f, -0.13804327f, 0.05253518f, -0.23558275f, -0.02429524f, -0.06489015f, 0.16446553f, 0.11425632f, 
    0.07509623f, 0.16551559f, -0.10603831f, 0.05895404f, 0.03170824f, 0.16367418f, -0.31547853f, 0.28181529f, 
    -0.06135750f, -0.12655666f, -0.07036047f, 0.02517940f, 0.12417295f, 0.00765994f, 0.05676536f, 0.11044355f, 
    0.16505782f, 0.19522431f, 0.10547790f, 0.00743064f, 0.15645775f, 0.02710322f, 0.00748795f, -0.26532167f, 
    0.20051801f, 0.08750400f, 0.13755061f, 0.12984328f, 0.07567444f, -0.14355116f, -0.05271645f, 0.13603792f, 
    -0.01185510f, -0.12655041f, -0.07490633f, -0.00734922f, 0.02011902f, 0.11739313f, 0.17622159f, 0.09452467f, 
    0.16366889f, 0.07919011f, 0.03567948f, 0.03309615f, 0.11739069f, 0.18418725f, 0.22831474f, 0.12336163f, 
    0.02944951f, -0.02739828f, -0.10871444f, -0.11098840f, 0.19195913f, 0.12779309f, 0.10688339f, 0.00240775f, 
    -0.17664260f, -0.10442391f, -0.04025265f, -0.10456131f, 0.23359357f, 0.38574561f, -0.01050556f, 0.15206873f, 
    -0.23806073f, -0.19241533f, -0.44973174f, -0.43369558f, -0.14737408f, 0.14575253f, -0.16178752f, -0.08835643f, 
    0.24682818f, 0.02029415f, 0.01273125f, 0.07099945f, 0.19476777f, 0.20138893f, -0.01746330f, 0.03647944f, 
    0.04211367f, -0.08616231f, 0.01859614f, 0.28620708f, -0.06033177f, -0.03362596f, -0.05885647f, -0.16117494f, 
    0.05472563f, 0.10107085f, -0.03903081f, 0.03997844f, 0.04628390f, 0.06046171f, -0.24342100f, 0.01293409f, 
    0.03260971f, 0.05880076f, 0.12979105f, -0.08546635f, 0.06548087f, -0.17346346f, 0.11245145f, -0.10254374f, 
    0.19024502f, -0.07336813f, -0.15897559f, 0.10747530f, 0.00822172f, 0.01991929f, -0.09241866f, 0.09573651f, 
    0.26948500f, -0.02402321f, 0.18119544f, 0.12830107f, 0.13556346f, -0.00808854f, 0.00308566f, -0.01467573f, 
    0.09835194f, 0.07008343f, -0.02271453f, -0.16164517f, -0.09176334f, -0.36090130f, -0.41495097f, -0.19235744f, 
    0.03485968f, -0.19218090f, 0.04427939f, 0.12692189f, -0.13563213f, -0.00913539f, -0.01572431f, -0.06917803f, 
    -0.32452536f, 0.18815732f, 0.26208198f, -0.04691494f, 0.10672296f, -0.11286765f, -0.01355379f, -0.00857603f, 
    -0.12654379f, 0.19322713f, 0.28011984f, -0.03612019f, 0.47632700f, -0.15425870f, -0.05421937f, 0.13016085f, 
    -0.09384554f, 0.00678944f, 0.00084786f, 0.01190604f, 0.04410648f, -0.00294397f, 0.39503580f, 0.09041081f, 
    -0.75394148f, -0.07497623f, 0.15163916f, -0.16232792f, -0.24286158f, -0.25274286f, -0.07209561f, -0.19432782f, 
    -0.19655441f, -0.03828650f, -0.17123416f, 0.08616465f, -0.16179141f, -0.09874833f, 0.00322840f, -0.01789610f, 
    0.17574127f, 0.25994876f, 0.01468970f, 0.20367037f, 0.08162005f, 0.13628796f, -0.06349691f, 0.07743749f, 
    0.05714769f, -0.11849678f, -0.11359701f, 0.03920038f, 0.15993555f, 0.36988524f, 0.18250538f, 0.03002272f, 
    -0.02518442f, -0.10765305f, -0.08807110f, -0.10225166f, 0.32212374f, -0.11672947f, -0.27991858f, 0.12502816f, 
    0.07493831f, 0.08510845f, 0.24440035f, -0.04309746f, -0.01108793f, -0.01795172f, -0.12538284f, -0.01752427f, 
    0.06861912f, 0.17867249f, -0.25906304f, -0.16049446f, -0.02828567f, -0.05522277f, 0.05997647f, -0.09521316f, 
    0.10255871f, -0.14499880f, -0.17513672f, 0.06783669f, 0.07072499f, -0.19633278f, -0.17449650f, -0.44098690f, 
    0.16702132f, -0.29958287f, 0.09098446f, 0.03315336f, 0.01957798f, 0.08219316f, -0.00820210f, 0.07631902f, 
    -0.14499158f, -0.28161433f, -0.16006750f, -0.12861270f, -0.06945585f, -0.03598447f, 0.16295932f, 0.15334371f, 
    -0.05544291f, 0.04394749f, 0.12434614f, 0.09992656f, 0.00014049f, 0.31769344f, 0.24547875f, 0.22875206f, 
    -0.06647744f, -0.04171758f, 0.00734660f, -0.02943685f, -0.02600625f, 0.12411620f, -0.08584804f, 0.04321581f, 
    0.02412339f, 0.17408332f, 0.24034390f, -0.07992922f, -0.02052985f, -0.03347038f, -0.16426049f, -0.00268253f, 
    0.00418945f, 0.20349286f, 0.22782435f, -0.07210468f, 0.55406260f, 0.29149446f, -0.17284799f, -0.03270535f, 
    -0.09343930f, -0.06712272f, 0.20592444f, 0.07403759f, -0.02070460f, -0.05480949f, 0.00085567f, -0.08019322f, 
    -0.08309093f, 0.02171817f, 0.03029031f, 0.00514551f, 0.00062980f, -0.07258479f, -0.00184074f, 0.01974370f, 
    0.03653318f, -0.05393272f, -0.01217787f, -0.03622121f, -0.09038813f, -0.08975584f, -0.05422977f, -0.07727063f, 
    -0.02799589f, 0.02998185f, -0.05155269f, -0.07212665f, -0.09173368f, -0.09511691f, -0.06755845f, -0.00548914f, 
    -0.02706653f, 0.03269474f, 0.02798180f, 0.04043962f, -0.07696272f, -0.02743343f, -0.05649584f, 0.01634852f, 
    -0.01124181f, -0.06238158f, -0.00252619f, 0.00995999f, -0.04551807f, 0.01064746f, -0.04766194f, 0.01247050f, 
    -0.06097401f, 0.01322748f, 0.04440031f, -0.01585526f, -0.05093099f, -0.00493538f, -0.07481646f, 0.04848757f, 
    -0.03150274f, 0.02466775f, 0.00285669f, 0.01597236f, 0.00276349f, -0.00916039f, -0.07664347f, 0.00355998f, 
    -0.01845312f, 0.03910729f, -0.02157431f, -0.01371964f, 0.02435016f, -0.00314651f, -0.05453441f, 0.03259115f, 
    -0.03094224f, -0.02340003f, -0.05733065f, 0.02380379f, -0.02849243f, 0.00395930f, -0.06800698f, 0.04858584f, 
    -0.04923892f, -0.08922119f, -0.05134382f, -0.09816592f, -0.05474043f, -0.03163644f, 0.02686199f, 0.00772777f, 
    -0.09151661f, -0.08963454f, 0.00465606f, -0.00090029f, 0.03077820f, 0.02387328f, -0.05922890f, -0.01711706f, 
    0.06021710f, 0.06390411f, -0.05998209f, 0.00019068f, -0.07148397f, 0.02999193f, 0.00454172f, -0.05203808f, 
    -0.01058042f, -0.08098141f, -0.06984417f, -0.08229143f, -0.05579056f, -0.00884928f, 0.02567882f, -0.05055040f, 
    0.02366317f, 0.00622805f, -0.05792492f, -0.03564282f, -0.05515511f, -0.02777198f, 0.02985907f, -0.02410558f, 
    -0.02312069f, -0.08755786f, 0.01694576f, -0.10162009f, -0.04239755f, 0.01924908f, 0.01112477f, 0.02795587f, 
    -0.03929897f, -0.06772523f, -0.01985086f, -0.02253172f, -0.06606203f, -0.02680914f, -0.04623041f, -0.08582225f, 
    0.03157443f, -0.09692358f, -0.09268592f, -0.00905851f, 0.01698962f, 0.01476984f, 0.00674060f, 0.04846435f, 
    -0.04767186f, 0.06867264f, -0.03074397f, 0.00481301f, -0.06951181f, 0.00937384f, 0.03240908f, -0.06382727f, 
    0.06478842f, 0.00429933f, 0.05917525f, -0.01719594f, -0.04665587f, 0.01260670f, -0.05343297f, -0.05696240f, 
    0.05183914f, -0.05273739f, -0.05302183f, -0.00878711f, -0.05648883f, -0.07078199f, -0.07229672f, 0.03278195f, 
    -0.09385745f, 0.00844983f, -0.04549855f, 0.02147029f, -0.08563087f, -0.08936797f, -0.01082493f, -0.05435053f, 
    0.00059229f, -0.00188865f, 0.02430233f, -0.09927586f, -0.02795963f, -0.03434409f, -0.05965592f, -0.08682369f, 
    0.03314525f, 0.03818353f, 0.01200177f, -0.06588081f, -0.08560103f, -0.01813471f, 0.00812866f, -0.01869476f, 
    0.00159546f, 0.02475843f, -0.01353477f, -0.04961954f, -0.04149491f, -0.02100511f, 0.00612595f, -0.04925168f, 
    0.07804176f, 0.11155400f, -0.04751904f, 0.06191221f, 0.09313358f, 0.09300185f, -0.03375865f, 0.06182270f, 
    -0.00613192f, -0.01927028f, 0.04495566f, -0.20698555f, -0.01417653f, 0.08696543f, -0.24873781f, 0.07501985f, 
    -0.02026690f, -0.12585892f, 0.17954749f, -0.12293912f, -0.09300414f, 0.05702185f, -0.05300470f, -0.17097567f, 
    -0.15217368f, -0.16578187f, -0.26943371f, -0.00533498f, -0.06004340f, 0.10838729f, -0.00089441f, 0.17231983f, 
    -0.06399672f, 0.06612690f, -0.05295648f, 0.08261008f, 0.17956136f, 0.40780824f, 0.02744273f, -0.09139238f, 
    -0.04992080f, 0.14458868f, 0.28049412f, -0.25579160f, -0.06724612f, -0.01065407f, -0.05833095f, -0.18500178f, 
    0.60793376f, -0.31666383f, 0.04945340f, -0.07555374f, 0.02550634f, -0.01575924f, 0.15406463f, 0.03153840f, 
    0.19049203f, 0.18222257f, -0.03133174f, 0.06919913f, -0.35848102f, 0.18257023f, -0.13845372f, 0.10036343f, 
    -0.05855352f, 0.01562643f, -0.10488226f, 0.05632907f, -0.20467506f, 0.19629003f, 0.18665910f, 0.24603471f, 
    0.13160922f, 0.44154787f, 0.14462928f, 0.21999528f, 0.18730016f, 0.12868424f, 0.08413856f, -0.03630156f, 
    0.00245400f, -0.24721329f, 0.01665911f, -0.08469784f, 0.20405339f, 0.23370419f, -0.04265708f, 0.36533639f, 
    0.11537248f, 0.04767043f, 0.25274551f, -0.03202242f, -0.01947248f, -0.16454653f, 0.02460219f, 0.13638511f, 
    -0.08793924f, 0.13993122f, 0.05226232f, 0.01401368f, -0.09152841f, -0.02891620f, -0.03698598f, -0.07028066f, 
    -0.08276046f, -0.01769315f, 0.07217105f, -0.05083988f, -0.19358750f, -0.22116524f, 0.31416258f, -0.27882838f, 
    -0.02377954f, 0.03589629f, -0.07508016f, 0.04235665f, 0.00684251f, 0.02782293f, 0.17244489f, 0.07752897f, 
    -0.04095164f, -0.12148792f, -0.20288154f, 0.04219536f, -0.03411183f, -0.07858795f, 0.02649327f, -0.06302507f, 
    -0.09320697f, 0.09542391f, 0.15607719f, -0.41846707f, 0.25038865f, 0.20857149f, 0.04687696f, 0.20092106f, 
    0.04218444f, 0.03767546f, 0.01969414f, 0.00095704f, -0.16929482f, -0.09600120f, 0.02116659f, -0.01655132f, 
    0.18529810f, 0.16491026f, -0.02448335f, 0.02230121f, 0.14221963f, 0.10101619f, -0.14623626f, -0.00923271f, 
    -0.09995251f, -0.00610615f, -0.17399956f, 0.02820836f, -0.02255459f, -0.12603402f, -0.09953723f, -0.37262172f, 
    0.05268741f, 0.17243086f, 0.07330029f, 0.05645343f, -0.09831814f, -0.15486105f, 0.19762553f, -0.21974728f, 
    0.03265831f, 0.15191630f, -0.04011865f, 0.04538090f, 0.19707581f, 0.15328448f, 0.14170076f, -0.00339224f, 
    -0.12086803f, 0.08483078f, 0.01326090f, -0.11556740f, -0.46567544f, -0.54192907f, 0.34268174f, -0.35311541f, 
    -0.17239524f, -0.02478766f, -0.10183508f, -0.01789103f, 0.06780404f, 0.11426569f, -0.01148870f, 0.08413871f, 
    -0.34608346f, 0.12753966f, -0.05859749f, 0.13613410f, 0.04302106f, 0.08381676f, -0.06280819f, -0.10688494f, 
    -0.08648069f, 0.03859605f, 0.30913568f, -0.03564861f, -0.19472007f, 0.21144801f, 0.01864428f, 0.23497225f, 
    0.00100607f, 0.06742667f, 0.09242063f, 0.09092520f, 0.03666940f, 0.06493463f, 0.20283654f, 0.25215328f, 
    -0.09996378f, 0.18129814f, -0.08689820f, -0.11226562f, -0.07419430f, -0.07064752f, -0.02980095f, -0.04259818f, 
    -0.01327793f, 0.13498838f, -0.05937450f, 0.07807646f, 0.22998297f, -0.16635446f, -0.09257390f, -0.06983908f, 
    -0.04229655f, 0.04853535f, -0.07185777f, 0.12467583f, 0.03223084f, 0.09900742f, 0.01349341f, 0.07680889f, 
    0.76473039f, 0.08613637f, 0.12321862f, -0.17718066f, 0.01957321f, -0.03260334f, 0.05036663f, 0.01154742f, 
    -0.13678849f, -0.04587736f, 0.06800012f, 0.15383217f, -0.41155934f, 0.30815956f, -0.36961141f, 0.24025732f, 
    -0.06591981f, -0.02727281f, 0.18894532f, 0.05593770f, 0.14553219f, 0.11435649f, 0.00043619f, -0.01894713f, 
    0.18356490f, -0.08435601f, -0.34674937f, -0.16405524f, 0.14288986f, 0.05679543f, 0.06325521f, -0.00005427f, 
    -0.03985845f, -0.07533626f, 0.06291738f, -0.13611834f, 0.07561742f, 0.02024172f, -0.21044591f, 0.03735689f, 
    0.12049560f, -0.05336747f, 0.16251512f, 0.02244258f, 0.01417179f, 0.16314039f, 0.10564193f, 0.01569840f, 
    -0.09627037f, 0.08420751f, -0.11027198f, -0.01305296f, 0.06733122f, 0.12524207f, 0.12145388f, -0.09574175f, 
    0.00069072f, -0.05999605f, 0.12486935f, 0.06506814f, -0.11553974f, 0.06046499f, 0.24942516f, -0.06851210f, 
    -0.14808242f, -0.15636039f, -0.07079813f, -0.07795707f, -0.15160237f, 0.03861337f, -0.03656708f, -0.05878361f, 
    0.03697087f, 0.14022617f, 0.05466743f, 0.08716432f, 0.00166563f, 0.09781162f, 0.04653893f, -0.02599617f, 
    0.15365642f, 0.11159334f, 0.07629181f, -0.04549050f, -0.07032683f, -0.08174648f, 0.13261220f, 0.24783999f, 
    0.07713050f, -0.05388747f, 0.00863358f, -0.01258829f, 0.01088454f, 0.07240420f, 0.12365855f, 0.02982505f, 
    0.05387432f, -0.44198704f, -0.09678706f, -0.10848853f, 0.11586580f, 0.02617008f, -0.05552056f, 0.01481196f, 
    -0.00786664f, -0.01040661f, 0.01054306f, -0.10988826f, 0.29509214f, 0.07396095f, 0.00471804f, -0.33315557f, 
    -0.06187047f, -0.00325316f, 0.06080378f, -0.04239572f, 0.15132715f, 0.14700811f, 0.13108338f, 0.15181217f, 
    -0.64320290f, 0.24326026f, -0.23237091f, -0.11215619f, 0.15047401f, 0.01343702f, 0.10054767f, 0.09371039f, 
    0.08277047f, 0.05238705f, 0.07510868f, 0.04153889f, 0.15852895f, -0.18401460f, 0.32882676f, -0.29222983f, 
    -0.18213242f, -0.02686502f, 0.00589037f, 0.07325407f, -0.09091124f, 0.06603936f, -0.10301091f, -0.01257314f, 
    -0.01380993f, 0.04841968f, -0.02862970f, -0.07427448f, -0.05592892f, -0.06509581f, -0.07787189f, 0.06105319f, 
    -0.01856333f, 0.05857294f, 0.05155743f, 0.00429347f, -0.02629205f, 0.00030292f, -0.06452293f, -0.03363377f, 
    -0.00871277f, 0.05219192f, -0.05959801f, -0.04383526f, 0.00764066f, -0.05410970f, 0.06111871f, 0.05108140f, 
    -0.04406153f, -0.04912616f, -0.04747325f, -0.05588866f, -0.00166705f, 0.03071637f, -0.04141083f, -0.04511033f, 
    -0.04223849f, -0.01978066f, 0.04561117f, -0.05944433f, -0.03978845f, -0.05510740f, 0.00199834f, 0.04798450f, 
    -0.05092327f, 0.04197891f, -0.00095693f, 0.00945124f, -0.01336748f, -0.01876374f, 0.04659722f, -0.06595481f, 
    -0.01204995f, 0.01938876f, -0.01145944f, -0.02451492f, -0.05958055f, -0.07900935f, -0.05651864f, 0.05671880f, 
    -0.06305569f, -0.03428958f, -0.03638774f, 0.02712060f, 0.03858658f, -0.05692554f, 0.01134145f, 0.02771004f, 
    -0.02763794f, 0.05668250f, 0.01150371f, -0.02455783f, -0.06332379f, 0.06507806f, 0.01262012f, 0.03871721f, 
    0.04483851f, -0.06128569f, -0.01485509f, 0.03780726f, 0.05143126f, -0.05873977f, 0.02577832f, -0.01742436f, 
    0.00539804f, -0.04889939f, -0.05224177f, -0.02601340f, -0.04699884f, 0.00271495f, 0.05548963f, -0.01641340f, 
    -0.07504006f, 0.03518935f, -0.02733708f, 0.01555840f, -0.07625096f, 0.00665716f, -0.05977022f, -0.07305479f, 
    0.03134376f, -0.00392189f, -0.04970552f, 0.05660730f, 0.03404613f, -0.04801092f, -0.01551920f, 0.02462509f, 
    0.01805447f, -0.01403182f, -0.06951223f, -0.00104028f, 0.03010425f, 0.02417540f, -0.04918177f, -0.05152887f, 
    0.02320526f, -0.05520460f, -0.05845273f, 0.06499018f, 0.03137318f, 0.00648783f, -0.05903861f, -0.05751223f, 
    -0.02922522f, 0.02431842f, 0.05631323f, -0.04779022f, 0.01390434f, -0.07766427f, -0.01020943f, -0.05981000f, 
    0.05235659f, -0.02522826f, 0.05600985f, 0.05095666f, -0.06365124f, -0.00840018f, -0.04758334f, -0.00270714f, 
    0.01283052f, 0.00164176f, -0.00613885f, -0.03062058f, 0.04090127f, 0.03034965f, -0.00254527f, -0.01448929f, 
    0.00457798f, 0.00519985f, 0.05907471f, -0.05139533f, 0.03700827f, 0.03054566f, -0.04870502f, -0.03325887f, 
    -0.03441948f, 0.00572790f, 0.06005998f, 0.00999891f, -0.05635015f, 0.01808027f, 0.03130081f, -0.04808667f, 
    0.05677534f, -0.02728446f, -0.04708761f, 0.03459492f, -0.06795788f, 0.01105963f, 0.05301500f, 0.00767810f, 
    0.03267160f, 0.01263500f, 0.05525702f, -0.05165485f, -0.01644134f, 0.04974408f, 0.01602281f, -0.02809490f, 
    0.00648723f, -0.04391021f, -0.06689332f, 0.05227732f, 0.01030148f, 0.02479584f, 0.00299910f, -0.01333980f, 
    -0.03475158f, 0.05801699f, 0.05248589f, 0.01753068f, -0.02123144f, -0.02760182f, -0.00758818f, -0.03189956f, 
    -0.17116088f, -0.05990165f, 0.02887515f, 0.06008978f, 0.06380202f, 0.22038317f, -0.00285458f, 0.09981530f, 
    -0.06888572f, 0.02404571f, 0.39182350f, 0.13222130f, 0.02595119f, -0.01368198f, 0.13230273f, -0.07301760f, 
    0.00328424f, 0.02162039f, 0.15317850f, 0.17255121f, 0.09486627f, 0.05507845f, 0.03549940f, 0.20549704f, 
    0.01642889f, 0.04261005f, 0.21158548f, -0.02237846f, -0.10969216f, 0.06329758f, -0.08520383f, -0.04493377f, 
    -0.04755882f, 0.14201617f, -0.10183422f, -0.02893166f, 0.06624565f, 0.13976339f, -0.18063521f, 0.00542824f, 
    0.12582785f, -0.10247991f, 0.21343751f, 0.11108059f, 0.08975859f, 0.14808927f, -0.06940792f, 0.03159477f, 
    0.32959491f, 0.18094131f, 0.21860293f, 0.28441748f, 0.02421308f, -0.08320472f, -0.00962797f, -0.03041204f, 
    -0.11352859f, 0.03571634f, 0.02747987f, -0.01646502f, -0.00797656f, -0.07277933f, 0.24506645f, 0.26143804f, 
    -0.10466488f, 0.05893006f, -0.04680109f, -0.03260572f, -0.01243956f, 0.13083437f, 0.18014759f, 0.05262896f, 
    0.10361320f, -0.33701429f, -0.33496499f, 0.09351673f, 0.13668221f, -0.15965146f, -0.02477328f, 0.04165801f, 
    -0.07049782f, 0.00191813f, 0.03271497f, 0.02160663f, -0.05167102f, -0.19517556f, -0.28692174f, 0.11526999f, 
    -0.06008932f, 0.10812779f, -0.05736186f, 0.03478897f, 0.23069817f, 0.04062531f, 0.07411164f, -0.01122337f, 
    0.08499604f, 0.02208340f, -0.02611714f, -0.12494467f, 0.21635006f, 0.20098896f, 0.07213967f, -0.00339858f, 
    0.05980045f, -0.01643836f, 0.05419680f, 0.05977476f, -0.30831537f, 0.05286526f, 0.30023739f, -0.23677455f, 
    -0.11948635f, 0.06022889f, -0.09609049f, -0.02129168f, -0.03597410f, 0.03190177f, -0.04343189f, -0.00297110f, 
    0.26065803f, -0.06346805f, 0.07070941f, -0.10133436f, 0.15132236f, 0.15819088f, 0.17374349f, 0.20958716f, 
    0.22290806f, -0.02810378f, 0.21980850f, -0.08989718f, 0.02356455f, 0.02676849f, 0.23679033f, 0.16243869f, 
    -0.07936247f, -0.12703981f, 0.26665717f, 0.10068994f, -0.07579055f, 0.30011883f, 0.07099932f, 0.07931904f, 
    -0.09568064f, -0.32044262f, -0.14196272f, 0.04433724f, 0.01846920f, -0.09330434f, -0.12617351f, -0.01801799f, 
    -0.03565118f, 0.09049086f, -0.11808445f, -0.09388335f, -0.01592938f, 0.00379187f, -0.08565741f, -0.00272910f, 
    -0.10647786f, 0.01238360f, -0.17458101f, -0.09747356f, -0.02809396f, -0.15439628f, 0.35580584f, -0.03121198f, 
    0.23753139f, -0.26928532f, 0.14944358f, 0.12859583f, 0.05513826f, -0.06510057f, -0.03013945f, -0.09213097f, 
    -0.03651917f, 0.03125701f, 0.15036875f, 0.08767258f, -0.01121169f, 0.29668191f, 0.16696575f, -0.28238866f, 
    -0.07093324f, -0.01438211f, -0.08311798f, -0.03353701f, -0.03861883f, 0.02939186f, -0.00916991f, 0.08942485f, 
    0.12712710f, 0.06225969f, 0.10335125f, -0.10842334f, -0.07482269f, -0.03466375f, 0.03858571f, -0.06472640f, 
    -0.01829629f, 0.06047017f, -0.14018586f, 0.23050763f, 0.02861797f, -0.13753586f, 0.05808225f, -0.19089428f, 
    0.04569946f, 0.11415426f, -0.09069838f, -0.06463718f, 0.04456880f, -0.11893124f, 0.00940986f, -0.10084327f, 
    0.08888483f, 0.09778996f, 0.07026612f, -0.04238490f, 0.12004066f, 0.07297619f, -0.01482061f, 0.01681031f, 
    0.03440884f, -0.02834268f, -0.04458724f, -0.07505252f, 0.03493367f, -0.24935953f, -0.06807753f, 0.06363179f, 
    0.11903503f, 0.03532013f, -0.12116779f, 0.12107353f, 0.00421944f, -0.09576316f, 0.00542907f, 0.10395736f, 
    -0.51658553f, 0.29574248f, -0.10154376f, 0.18935172f, 0.07876532f, 0.13735518f, -0.03319759f, 0.10125028f, 
    0.03580393f, -0.10183838f, 0.12286209f, -0.12760656f, 0.15931870f, -0.54304326f, 0.30774122f, -0.09821344f, 
    0.05040830f, -0.03907200f, -0.01581865f, -0.05412142f, 0.27325845f, 0.06900977f, 0.13550213f, 0.26624769f, 
    0.55319023f, -0.14061478f, -0.04254396f, -0.20762211f, 0.00072907f, -0.02773066f, 0.01081209f, -0.06806377f, 
    -0.00622775f, 0.02901440f, -0.08585611f, -0.00029935f, 0.25433356f, -0.11056742f, 0.08863666f, -0.32492781f, 
    -0.00959335f, 0.19896875f, -0.13114791f, 0.03346211f, -0.06593029f, -0.10984460f, 0.02377418f, -0.06663951f, 
    -0.00006850f, -0.11631420f, 0.00686683f, -0.02748628f, 0.07077698f, -0.05444984f, 0.06353188f, 0.02934564f, 
    0.18115915f, 0.06619201f, -0.01704554f, -0.07332170f, -0.06044197f, -0.04646665f, -0.10520148f, 0.22639313f, 
    0.14197972f, 0.00268378f, 0.08117541f, 0.07453773f, 0.05876373f, 0.09835324f, -0.03026447f, -0.02264851f, 
    0.20034944f, -0.09652355f, -0.06778200f, -0.17451201f, -0.04776913f, 0.12909155f, -0.02742379f, -0.03759434f, 
    -0.12069834f, 0.02519271f, -0.03673056f, 0.22115150f, -0.32279986f, -0.02872195f, -0.19360033f, -0.14421982f, 
    0.24680537f, 0.05361266f, -0.00005442f, -0.22896092f, -0.02013007f, -0.06317792f, 0.08089032f, 0.24227783f, 
    0.09324690f, 0.26289478f, 0.04481630f, 0.03468632f, -0.05794027f, -0.03528222f, 0.24202013f, 0.02960991f, 
    -0.03006869f, -0.00360533f, -0.07084551f, 0.13370301f, 0.07923248f, 0.29729116f, -0.12145986f, 0.34437463f, 
    -0.03785000f, -0.06611516f, -0.01482756f, 0.00659192f, 0.00161072f, 0.03716645f, -0.23157722f, 0.17704576f, 
    0.66406220f, -0.30892661f, 0.37818184f, 0.01537904f, -0.04937266f, 0.03170424f, -0.06693346f, -0.04781408f, 
    0.15931588f, -0.01613188f, 0.01585987f, 0.20278558f, -0.07361977f, 0.56856757f, -0.26700339f, 0.13997622f, 
    0.04182577f, 0.06488157f, 0.00068914f, -0.00087808f, 0.05529862f, -0.06005576f, 0.01790764f, 0.05931654f, 
    -0.07581771f, -0.00844817f, -0.13616496f, 0.06699987f, 0.21066931f, 0.13051787f, 0.01838726f, 0.08963478f, 
    -0.18428460f, -0.02300478f, 0.06901749f, -0.08252273f, 0.30838540f, -0.09476537f, -0.17522132f, 0.18774706f, 
    -0.05474935f, 0.06134984f, 0.18432000f, 0.16019177f, 0.12135439f, 0.04873151f, 0.02510600f, -0.03982246f, 
    0.07795782f, 0.18472053f, -0.00459283f, 0.26212922f, -0.09588648f, 0.05267800f, -0.05075126f, -0.04536559f, 
    -0.10692285f, 0.06246879f, 0.06091210f, 0.09339501f, -0.07985599f, 0.44652772f, 0.00886556f, -0.32017288f, 
    -0.01594464f, 0.00591767f, 0.15039554f, 0.01487880f, -0.06011017f, -0.07563921f, -0.05089176f, -0.02879210f, 
    -0.09669501f, -0.47853944f, 0.30496126f, 0.46099022f, -0.11798834f, -0.03668236f, 0.04874239f, -0.02493427f, 
    0.13249397f, 0.23950741f, 0.18150464f, 0.16926534f, -0.06455647f, 0.15032406f, 0.01175926f, -0.02837112f, 
    0.01133922f, -0.21353653f, 0.04617861f, -0.03901434f, -0.08120325f, 0.02212136f, 0.16149585f, 0.05189232f, 
    -0.03610536f, -0.01028274f, -0.20693450f, -0.08389585f, 0.12841858f, -0.03377483f, 0.21165161f, -0.07993121f, 
    -0.06904654f, -0.08565074f, 0.00383685f, -0.11522195f, 0.32053888f, 0.03979247f, -0.29375181f, 0.08820146f, 
    0.11301847f, 0.14715919f, 0.30738756f, -0.00690286f, 0.13342938f, -0.00637469f, -0.02404392f, -0.10414019f, 
    0.06065466f, 0.29857835f, -0.00724261f, 0.00251519f, -0.00682858f, -0.05611637f, 0.02487553f, 0.03539250f, 
    -0.07892223f, -0.03112521f, -0.06160114f, 0.00936618f, -0.11456731f, 0.10355201f, 0.31334528f, -0.33224294f, 
    -0.06656785f, -0.09834260f, -0.24293341f, 0.02987605f, -0.10768366f, -0.14000213f, 0.00982247f, 0.05307480f, 
    0.21505067f, -0.03419954f, 0.04586576f, 0.24088605f, 0.23237714f, -0.16863853f, 0.13112064f, -0.01071395f, 
    0.24588892f, 0.00333321f, 0.16122448f, 0.07457580f, -0.00212691f, 0.05945837f, -0.25217518f, -0.42392269f, 
    0.02700497f, 0.08363786f, 0.03249240f, 0.17632797f, 0.01102947f, 0.05749692f, -0.04161496f, -0.02291199f, 
    -0.02416084f, 0.27110800f, -0.07773320f, -0.24258034f, -0.03789087f, 0.02850896f, -0.14483790f, -0.01127168f, 
    0.00778469f, 0.05457383f, 0.01246746f, 0.01474003f, -0.13493292f, -0.20173310f, -0.12541592f, -0.12044692f, 
    -0.08970977f, 0.04171120f, 0.07021632f, 0.05707033f, -0.04877439f, 0.09237827f, 0.20932217f, 0.03440293f, 
    0.13192146f, -0.18219726f, -0.06516866f, -0.04765134f, -0.05656510f, 0.05860846f, 0.05352391f, -0.01449994f, 
    0.12345251f, -0.00908383f, 0.11743446f, -0.00505513f, -0.03916782f, -0.18078397f, 0.42684808f, -0.08436675f, 
    0.02496762f, 0.02183118f, -0.17086531f, 0.03921501f, -0.00887477f, 0.06252577f, -0.02037468f, -0.02111240f, 
    0.06613011f, 0.02771378f, 0.02574358f, 0.03033949f, -0.07698698f, -0.03270229f, 0.02604617f, -0.03781047f, 
    -0.01328292f, 0.01757612f, -0.02017148f, -0.04720271f, 0.04953897f, -0.05033721f, 0.05832103f, -0.01625516f, 
    -0.04041067f, -0.04359937f, 0.01439271f, -0.00106665f, 0.06147713f, 0.02183961f, 0.03514781f, 0.02474808f, 
    -0.04770024f, 0.02438583f, -0.03925817f, 0.02864099f, -0.00325537f, 0.00820142f, -0.06103059f, 0.02182733f, 
    0.01424810f, -0.02664298f, 0.02217858f, -0.00253308f, -0.04794056f, -0.07801777f, -0.03150230f, 0.00209680f, 
    -0.01464576f, 0.00692660f, -0.07805242f, -0.07484104f, 0.05109659f, -0.01377959f, 0.01518688f, 0.01360983f, 
    -0.04357487f, -0.06740170f, 0.03290622f, 0.01861559f, -0.03492996f, 0.04924760f, -0.04325030f, -0.05045905f, 
    0.05668160f, -0.06318188f, -0.06008180f, -0.07375618f, -0.02899409f, 0.04994967f, 0.01722640f, 0.05488119f, 
    0.01044122f, -0.01367269f, 0.00063115f, -0.01810305f, 0.00682204f, -0.04792880f, 0.02777172f, 0.06368159f, 
    -0.02622249f, 0.05225207f, 0.01285186f, -0.00121432f, -0.03934153f, 0.05022072f, 0.05620515f, -0.05929229f, 
    -0.05383645f, -0.03260532f, -0.01384091f, 0.05411401f, -0.07551771f, -0.05775153f, -0.00929542f, -0.07088798f, 
    -0.00666407f, 0.05407383f, 0.00326992f, 0.05150837f, -0.04980515f, -0.02567106f, -0.05892733f, -0.01788120f, 
    -0.03839861f, 0.02701676f, -0.05609506f, 0.06197898f, -0.03689782f, -0.07714333f, -0.03754515f, 0.03343217f, 
    0.03003402f, 0.06022041f, -0.01695728f, -0.01117875f, -0.00308282f, -0.00937695f, -0.03428631f, 0.02105490f, 
    -0.03584408f, -0.03097032f, 0.02708296f, 0.04111468f, 0.05294968f, -0.03623589f, -0.03702072f, -0.02105331f, 
    -0.07102060f, -0.00115958f, -0.05239066f, -0.02673850f, -0.07563937f, -0.01464036f, -0.05228934f, 0.02575623f, 
    -0.03604937f, -0.01975949f, -0.05488116f, 0.02438498f, -0.04776568f, -0.03680033f, 0.05552542f, -0.02635935f, 
    -0.04625521f, 0.02848446f, -0.07003716f, 0.06136607f, -0.04589984f, -0.02136761f, 0.04825303f, -0.05287986f, 
    -0.02773162f, 0.01017998f, -0.03702574f, -0.03466978f, -0.05384484f, -0.07065058f, 0.02105857f, 0.03282654f, 
    -0.04405133f, 0.06457903f, -0.00003469f, -0.01519333f, -0.05033160f, 0.02265983f, -0.03777491f, 0.04965760f, 
    0.01417786f, 0.00778609f, -0.00056951f, 0.06345551f, 0.02488327f, 0.05826411f, -0.04357229f, -0.08117545f, 
    0.04081507f, 0.01068885f, 0.05288034f, 0.03877161f, -0.06862081f, 0.01672851f, -0.06066837f, 0.06237845f, 
    -0.04118896f, 0.02900578f, -0.04087886f, -0.02757122f, -0.06952112f, 0.01384804f, -0.01880013f, 0.06751982f, 
    -0.06206008f, -0.03926994f, -0.01971715f, -0.06148693f, -0.05737044f, -0.07005864f, 0.03509624f, 0.05486216f, 
    -0.23132430f, -0.08090308f, 0.07205726f, 0.14848904f, 0.11506109f, 0.01736738f, -0.01951009f, -0.09672301f, 
    -0.03063077f, 0.13364379f, 0.32172951f, -0.17173149f, 0.06723082f, -0.02649215f, 0.21363115f, 0.03284680f, 
    0.01868119f, -0.00196195f, 0.09531293f, 0.21989450f, 0.10995914f, 0.07607492f, 0.12282833f, 0.19115712f, 
    -0.20521097f, -0.00999348f, -0.13531247f, 0.32450661f, 0.01650484f, -0.04397477f, -0.15059197f, -0.00452422f, 
    0.18124154f, 0.02991678f, 0.02206608f, -0.00400232f, -0.05913935f, -0.04473737f, 0.24267288f, 0.04828539f, 
    0.04403188f, -0.08562700f, -0.08337225f, 0.02826961f, 0.04828376f, -0.05969882f, -0.00771573f, -0.04496066f, 
    -0.14132155f, 0.20416246f, 0.13880786f, 0.04334849f, -0.09321313f, -0.08967704f, -0.02927848f, 0.08673434f, 
    -0.05595002f, 0.01813808f, -0.05768819f, -0.01399224f, 0.22603521f, -0.16869743f, -0.22671431f, -0.15961154f, 
    -0.18598019f, -0.00140277f, -0.00521780f, 0.13378975f, -0.07211258f, -0.12391853f, -0.14563724f, -0.49089831f, 
    -0.21700053f, -0.17595397f, 0.19129117f, 0.13578676f, -0.09538423f, -0.11793076f, -0.03764996f, 0.21903171f, 
    -0.02836736f, -0.08506548f, -0.09291366f, -0.10810445f, -0.21313888f, 0.10889776f, 0.19907160f, -0.03567295f, 
    0.06176116f, -0.19338106f, -0.00230348f, 0.15292017f, 0.12223271f, 0.00250752f, -0.07319795f, 0.00513268f, 
    0.09717271f, -0.12728329f, -0.10237710f, -0.19682014f, 0.24109365f, 0.21892968f, 0.08552741f, 0.05992629f, 
    -0.01476790f, 0.08869682f, -0.14581481f, -0.02134274f, 0.09760026f, 0.03287031f, -0.40708983f, 0.09066977f, 
    -0.01862149f, -0.09910855f, 0.04429970f, -0.11507785f, -0.01932444f, 0.03420091f, -0.01960966f, 0.01767209f, 
    -0.02337473f, -0.09744152f, 0.07998912f, -0.04335397f, 0.14860459f, 0.04079462f, 0.08375730f, -0.10789380f, 
    0.23955242f, 0.08063926f, 0.00910792f, 0.16017894f, 0.14389452f, -0.06251115f, 0.08846728f, -0.56165445f, 
    -0.15650353f, -0.14727294f, -0.09201907f, 0.01231601f, 0.05472465f, 0.19404180f, 0.18617514f, 0.05449697f, 
    -0.23170044f, 0.00574098f, 0.12138009f, 0.07712386f, -0.01962484f, 0.05906175f, 0.16254243f, 0.04147605f, 
    0.11613458f, 0.09170063f, -0.03842549f, 0.02500219f, -0.08586879f, -0.19201671f, 0.17541926f, 0.25182420f, 
    -0.14307398f, -0.13081414f, -0.11312988f, 0.03902987f, 0.18247737f, 0.28929028f, 0.24352247f, 0.16607076f, 
    -0.43224570f, -0.04967934f, -0.01119350f, 0.29917341f, -0.08407949f, -0.05111308f, -0.03927224f, -0.04124148f, 
    -0.01630218f, -0.08987983f, 0.14505431f, -0.03444616f, 0.50476277f, 0.14055404f, -0.25969157f, 0.16217743f, 
    -0.02248197f, 0.05143687f, 0.20728168f, 0.09094210f, -0.09072258f, -0.04717587f, 0.12967852f, -0.10840928f, 
    -0.00508684f, -0.04793660f, -0.03322180f, -0.05008540f, 0.06444943f, 0.07490218f, 0.05629015f, -0.02323987f, 
    0.01595508f, 0.16551399f, -0.12376734f, 0.13542265f, 0.04733000f, -0.04898882f, -0.08860285f, -0.07106494f, 
    0.11944429f, 0.03785094f, -0.11659677f, 0.03644517f, -0.06242063f, 0.03972095f, 0.15051244f, 0.03854858f, 
    -0.13731456f, -0.43532428f, -0.03260596f, -0.23354232f, -0.10022985f, -0.05471993f, -0.06237528f, -0.06743320f, 
    0.01384843f, -0.02842674f, 0.04205709f, 0.05483731f, 0.04346311f, 0.26465523f, 0.24158356f, 0.22777800f, 
    0.05452480f, 0.17984667f, 0.15035865f, 0.13623659f, 0.00225295f, 0.02616454f, -0.06917582f, -0.03306226f, 
    -0.62907833f, -0.12702121f, -0.09492280f, 0.07556085f, -0.06170542f, -0.01821290f, -0.09514154f, -0.03422868f, 
    -0.02749497f, -0.03296285f, 0.21907869f, 0.02706180f, 0.22841991f, -0.07703426f, 0.05592360f, -0.14902912f, 
    0.08433371f, 0.05566728f, -0.00428662f, -0.02023665f, -0.09555961f, -0.11670836f, 0.03291380f, -0.02793488f, 
    0.02871640f, 0.40940538f, 0.51194513f, 0.15694241f, 0.06278854f, 0.11319748f, 0.17693196f, 0.28137946f, 
    0.17441855f, 0.07897256f, -0.06696224f, 0.08894334f, 0.35937473f, 0.39631876f, 0.15570912f, 0.01746441f, 
    0.14964199f, 0.21149783f, 0.11000134f, 0.13106690f, -0.03208826f, 0.01797633f, -0.00672597f, -0.16407056f, 
    -0.09384543f, -0.04285509f, -0.18238325f, -0.08136664f, -0.02655195f, -0.02332013f, 0.02721824f, 0.13194014f, 
    0.11944330f, 0.08586872f, 0.07519690f, -0.00071959f, -0.29046726f, -0.19541712f, -0.55875659f, 0.02975043f, 
    -0.10416698f, -0.07318240f, 0.10965378f, 0.02590406f, 0.07934909f, -0.11328523f, 0.03958122f, 0.04173858f, 
    -0.21572535f, 0.13814443f, -0.00926291f, -0.11772653f, 0.19694516f, 0.03545048f, -0.06078450f, 0.00476347f, 
    0.07007276f, 0.09170798f, -0.03609543f, 0.22531341f, 0.22844617f, 0.13424858f, -0.03326161f, 0.04742609f, 
    0.18271847f, 0.02586789f, 0.00403407f, 0.18785693f, 0.02875455f, -0.06300063f, -0.13177735f, 0.21329708f, 
    0.23476911f, 0.30318394f, 0.26470134f, 0.18931936f, 0.12501147f, 0.15069646f, 0.07670764f, 0.22771421f, 
    -0.04513696f, 0.00067608f, -0.04076088f, -0.02350076f, -0.28353485f, -0.08230264f, 0.04978294f, 0.23928481f, 
    0.00454435f, 0.05891595f, 0.04727346f, 0.00152931f, -0.12302297f, 0.05770523f, -0.18430795f, 0.12595080f, 
    0.41843364f, 0.32827753f, -0.33813754f, -0.06768839f, 0.01469524f, 0.02489409f, -0.03341926f, -0.20166205f, 
    -0.03288978f, 0.00448255f, 0.08857460f, 0.07695828f, -0.29952312f, -0.28290260f, -0.29387638f, -0.03839191f, 
    0.00233507f, -0.11369669f, -0.09184008f, -0.12780860f, -0.01682761f, -0.08976173f, -0.06396662f, 0.01475055f, 
    -0.19138591f, -0.14243838f, -0.00643850f, 0.00173501f, 0.07690485f, -0.02737628f, 0.07576016f, -0.04675021f, 
    -0.03001625f, -0.08992165f, 0.27316126f, -0.17838864f, -0.28265440f, 0.02780449f, 0.17285198f, 0.02066133f, 
    0.06518030f, -0.01350015f, 0.07147099f, -0.03027950f, 0.13107914f, 0.02730942f, 0.11604150f, 0.08663920f, 
    -0.12928395f, 0.04737973f, 0.12793802f, 0.08791307f, 0.08991323f, -0.02361919f, -0.13749056f, -0.08984263f, 
    -0.01739916f, -0.13435254f, -0.20534642f, -0.03859847f, 0.22258282f, -0.20639609f, 0.01591120f, 0.14635141f, 
    0.13966960f, -0.10007174f, -0.11026336f, 0.04234618f, 0.10181661f, 0.03234201f, 0.01277768f, 0.03286900f, 
    0.48515043f, 0.78978366f, -0.09082350f, 0.00934821f, 0.03090354f, -0.00040843f, -0.03110911f, 0.00153504f, 
    -0.04878911f, -0.03101441f, -0.09915099f, -0.02771233f, 0.03193330f, -0.31462511f, -0.02174950f, 0.11070126f, 
    0.03349351f, 0.07203937f, 0.17197262f, 0.11115541f, 0.17460606f, -0.03276267f, 0.16561408f, -0.07484090f, 
    0.20515846f, -0.30995113f, -0.05120081f, 0.01568270f, 0.19592603f, 0.05043252f, -0.15275612f, 0.16531625f, 
    0.14854637f, 0.07565985f, 0.01871387f, -0.09099223f, -0.20533587f, -0.06199086f, 0.08899020f, -0.07529188f, 
    0.02943616f, -0.03717080f, 0.07535382f, 0.07016107f, -0.10911033f, -0.00247976f, 0.04409258f, -0.04120325f, 
    -0.04697008f, -0.24334237f, -0.10455047f, -0.14515603f, 0.04386227f, -0.01851976f, 0.10808682f, -0.02946011f, 
    0.06735585f, 0.04643722f, -0.12092666f, -0.01258711f, 0.02865382f, 0.06673134f, 0.00186136f, 0.28696090f, 
    -0.07589307f, -0.09470907f, -0.03749261f, -0.11120604f, 0.02739482f, 0.11010307f, -0.03097072f, -0.05581234f, 
    0.06995955f, -0.20364992f, -0.01013821f, 0.06302368f, 0.09655903f, 0.06050162f, 0.06322210f, 0.05005090f, 
    0.16635391f, 0.01427073f, 0.00892873f, 0.00112132f, 0.02104924f, 0.00310978f, 0.16971871f, 0.02032906f, 
    -0.12450797f, -0.16586687f, -0.00462977f, -0.18495503f, -0.01685947f, 0.16060796f, 0.22511786f, 0.16496044f, 
    -0.07680315f, -0.04599473f, 0.03111010f, 0.03393927f, 0.02047006f, -0.01067752f, 0.10407124f, 0.00766398f, 
    -0.03508314f, -0.05766247f, 0.01974276f, -0.13245220f, 0.06108714f, 0.10340085f, 0.16083111f, 0.00641182f, 
    0.08939212f, 0.03539895f, -0.14283644f, -0.14858089f, 0.07291306f, 0.19222365f, 0.20118356f, 0.02656544f, 
    -0.31103349f, -0.31319085f, 0.07139981f, 0.01074537f, 0.10636324f, 0.00180595f, -0.17639884f, -0.00180739f, 
    0.06782777f, -0.01637143f, 0.11828509f, 0.14057420f, 0.42284510f, 0.09347533f, -0.07746751f, 0.12835443f, 
    -0.07008406f, -0.02197362f, 0.14668527f, 0.09319210f, 0.01866976f, -0.03599363f, -0.06769957f, -0.00742488f, 
    -0.06352244f, -0.02638789f, -0.01238208f, 0.06019909f, 0.08221158f, 0.01987612f, -0.06470919f, -0.09481850f, 
    0.25028363f, 0.05856033f, -0.17905806f, -0.01416909f, 0.10704282f, -0.07634157f, 0.02034133f, 0.08712326f, 
    0.02848091f, -0.06410899f, -0.00406954f, 0.13394269f, 0.05364488f, -0.13959654f, -0.00367145f, -0.08641339f, 
    0.19201727f, 0.08378156f, -0.20604922f, 0.09925168f, 0.14640433f, -0.04669359f, 0.05319230f, 0.02572727f, 
    0.03687862f, 0.07323119f, -0.04373628f, -0.14388832f, -0.05850405f, -0.20508705f, 0.13251849f, -0.02745136f, 
    -0.00505977f, 0.01698064f, -0.21281114f, 0.10489482f, 0.11900493f, -0.06787658f, 0.08539776f, 0.03797803f, 
    -0.40189961f, 0.12714429f, -0.24278635f, -0.12669793f, 0.13540891f, -0.02174858f, -0.11744659f, 0.04472022f, 
    0.03744791f, -0.01571665f, 0.06564867f, -0.00460202f, 0.26005197f, -0.11677158f, -0.15200177f, -0.12299399f, 
    0.04620012f, 0.04186131f, 0.18271333f, 0.08825318f, 0.05952277f, -0.06523781f, 0.10945807f, 0.01090488f, 
    -0.25631633f, -0.10968219f, 0.12205492f, 0.01199886f, -0.01140319f, -0.04589992f, -0.00345197f, -0.02039311f, 
    0.13759159f, 0.12534070f, -0.08473086f, -0.02852583f, -0.13948475f, -0.05080908f, 0.32684633f, -0.12064102f, 
    -0.08438688f, -0.10050388f, 0.05280606f, 0.00005151f, 0.01687279f, 0.10908932f, 0.05323370f, 0.03418353f, 
    0.01939397f, -0.04465019f, -0.01495483f, 0.12182138f, 0.03050332f, 0.16372828f, 0.11224777f, -0.01397202f, 
    0.05300770f, -0.02269322f, -0.11581231f, 0.05600903f, 0.46295029f, -0.00984534f, -0.48631161f, 0.10574339f, 
    0.14193502f, -0.07847039f, 0.10925243f, 0.02193304f, -0.00108821f, -0.01378358f, -0.13615467f, -0.03502362f, 
    -0.09317992f, -0.00097265f, -0.04287168f, 0.30419397f, -0.06515466f, -0.07847273f, -0.13617367f, 0.10160287f, 
    -0.05818814f, -0.12094738f, -0.28382540f, 0.50507611f, -0.05817223f, 0.08572970f, -0.03551424f, -0.36206377f, 
    0.09003311f, -0.01587776f, -0.09320945f, -0.07019400f, 0.11375958f, -0.00634217f, 0.08304676f, -0.03337518f, 
    0.00117228f, 0.16150908f, 0.23309651f, -0.04565167f, -0.03015381f, 0.07257453f, 0.10279839f, -0.14011438f, 
    0.03344050f, 0.02144144f, 0.15323460f, 0.04053226f, -0.08690025f, 0.04352878f, 0.11338372f, 0.09482712f, 
    -0.06520171f, -0.18970558f, 0.00203268f, 0.03065968f, 0.11254365f, 0.18053198f, -0.09829319f, 0.25194526f, 
    -0.52789664f, 0.03889767f, 0.02384419f, 0.01052401f, -0.05362185f, -0.03243255f, 0.01973859f, 0.08542653f, 
    0.17523231f, 0.04320807f, 0.12303890f, 0.07272085f, 0.52963930f, -0.16750503f, -0.27238262f, 0.26093188f, 
    0.06286626f, 0.01901261f, 0.09164752f, 0.04157174f, -0.03834447f, 0.05755088f, 0.06850575f, -0.02630563f, 
    -0.12357788f, 0.05255355f, 0.06967119f, -0.03440425f, 0.00991712f, 0.06277776f, 0.12755276f, -0.06510027f, 
    -0.03645525f, 0.05616979f, 0.01089686f, -0.04450070f, 0.07125320f, 0.15233171f, 0.09411196f, 0.10730513f, 
    -0.08414306f, 0.08906064f, 0.02419885f, 0.12654848f, -0.11027520f, 0.01571129f, 0.07879706f, 0.08928499f, 
    0.00408132f, 0.30581483f, 0.08413021f, 0.02151239f, -0.19869250f, -0.03894130f, -0.00103550f, -0.02887478f, 
    0.03584045f, 0.17303909f, -0.00836812f, -0.01638489f, -0.06562737f, -0.08610828f, 0.20077616f, 0.26699066f, 
    0.01751434f, 0.13092531f, -0.01928599f, 0.01187660f, -0.06706582f, 0.07591181f, -0.01902041f, 0.11240549f, 
    0.47258732f, -0.06648903f, 0.25723207f, -0.14142698f, -0.03683278f, 0.15935236f, -0.08279757f, 0.09646111f, 
    0.07788643f, -0.19931711f, -0.13717854f, 0.20713219f, -0.08711017f, 0.29781365f, -0.23879695f, 0.05054959f, 
    -0.07090063f, 0.01727957f, -0.04707980f, 0.18080382f, -0.08900175f, -0.09494439f, -0.20417830f, -0.02186507f, 
    0.23961739f, 0.00528918f, -0.16376187f, 0.05663673f, 0.04575949f, 0.10144849f, 0.04541371f, 0.00554193f, 
    0.08055048f, 0.08738068f, 0.02611582f, -0.01808858f, -0.04427386f, 0.07641117f, 0.21148552f, 0.27782255f, 
    0.06522696f, -0.06206902f, -0.04393402f, -0.03554920f, -0.03428582f, 0.05143313f, 0.05949254f, 0.04109304f, 
    0.14497492f, 0.19665229f, 0.03212964f, -0.15767968f, -0.01128971f, -0.08835176f, 0.15761970f, -0.09922604f, 
    -0.13972604f, -0.01266741f, 0.08790141f, 0.05414122f, 0.22021803f, 0.27482024f, 0.56062639f, 0.15937878f, 
    -0.29071912f, -0.18733241f, -0.03763442f, -0.02928156f, 0.03578814f, 0.05707029f, 0.03494822f, -0.10071892f, 
    0.26322308f, 0.12986262f, 0.11329788f, -0.10282198f, 0.13347903f, 0.09538650f, 0.03238309f, 0.06090593f, 
    0.03687865f, 0.31695083f, -0.06864129f, -0.05524201f, -0.01044825f, -0.17307623f, 0.36173460f, 0.36391523f, 
    0.03432642f, 0.11665884f, -0.02248307f, 0.00908045f, -0.04921399f, -0.05069870f, 0.04906568f, -0.01480196f, 
    0.01191561f, -0.42895630f, 0.11461716f, 0.30831200f, 0.01215348f, -0.02178274f, -0.10721215f, 0.14987214f, 
    0.03649737f, 0.06998140f, -0.01974704f, 0.08397453f, -0.19697867f, -0.45605564f, 0.23276167f, -0.06423667f, 
    0.05292479f, 0.01195681f, 0.10861655f, -0.06525186f, 0.15184206f, -0.12342179f, -0.19037300f, -0.07232335f, 
    -0.21824573f, 0.07170217f, -0.71205968f, 0.05053798f, 0.02941003f, -0.15649381f, 0.08755005f, -0.10936501f, 
    -0.03434232f, -0.04544809f, -0.02349797f, -0.05046511f, 0.10918842f, -0.14306581f, 0.34970415f, -0.07403807f, 
    -0.09823403f, -0.11278615f, -0.03419866f, 0.09912381f, -0.05006307f, -0.01622825f, 0.06026120f, -0.03182634f, 
    0.02275075f, -0.01360370f, -0.01229619f, -0.12309036f, -0.08514917f, -0.04595092f, -0.06872948f, -0.14282148f, 
    0.18324719f, 0.18937074f, -0.16531813f, 0.05864831f, -0.08885085f, 0.02564644f, 0.13708322f, -0.03431011f, 
    -0.10594220f, 0.13555944f, 0.09501741f, -0.10229987f, 0.30432248f, -0.04111062f, 0.10452648f, 0.05408718f, 
    0.25624153f, 0.07143981f, 0.15791248f, -0.30922383f, 0.01565798f, -0.16020308f, -0.03979177f, -0.11576261f, 
    0.05302360f, -0.04637109f, 0.09629530f, 0.08233812f, -0.26573098f, -0.20545764f, -0.19901799f, -0.02977058f, 
    -0.06127749f, 0.13089199f, -0.00747099f, 0.13014482f, 0.15175407f, -0.05851176f, 0.07171156f, 0.09066417f, 
    -0.04151277f, -0.03884225f, -0.21313065f, -0.10575747f, 0.01821950f, -0.04151639f, 0.12904941f, 0.05593687f, 
    -0.00058232f, 0.02612773f, 0.16215791f, -0.06879187f, 0.08507127f, 0.01992848f, -0.09767819f, -0.11419487f, 
    0.14445724f, -0.03457165f, 0.02505838f, -0.12693213f, 0.05323941f, -0.06484806f, -0.19443636f, -0.24372274f, 
    0.03891215f, -0.17095560f, -0.17443681f, -0.20464005f, -0.21391249f, 0.04332488f, 0.04416768f, -0.12650819f, 
    -0.09397490f, 0.18225585f, -0.06614371f, 0.15148184f, -0.01197159f, 0.14741845f, 0.29375204f, -0.10884805f, 
    0.13580129f, -0.10831709f, 0.14299519f, 0.03633508f, -0.11401775f, 0.09045836f, -0.09675957f, 0.00760637f, 
    -0.17163172f, -0.22468086f, 0.01708109f, 0.01844854f, 0.10783961f, 0.16497412f, 0.01971509f, -0.05428968f, 
    -0.00964807f, 0.09339467f, -0.11477588f, 0.04554397f, 0.12860177f, 0.15778995f, -0.20269603f, -0.00250703f, 
    0.07356440f, -0.08416111f, 0.14035435f, 0.04789361f, 0.05787775f, 0.09377418f, -0.05006386f, -0.08859692f, 
    -0.20608972f, 0.45251745f, 0.04841098f, -0.06175461f, -0.15584913f, -0.04557781f, -0.16242346f, 0.00776896f, 
    -0.06255423f, -0.04224066f, -0.07751295f, 0.21352760f, -0.31132662f, 0.19070509f, -0.09365520f, 0.01951702f, 
    0.17047672f, 0.06906862f, 0.01365548f, 0.15596554f, 0.12263338f, -0.07082293f, 0.12549536f, 0.16084695f, 
    -0.00634969f, 0.00358856f, 0.05365158f, -0.00643802f, -0.16769543f, 0.09982308f, 0.04955010f, -0.01888445f, 
    -0.11388291f, -0.00556146f, 0.14831860f, 0.15922946f, 0.29827079f, 0.26549900f, -0.08786821f, -0.13033739f, 
    -0.13500570f, -0.03313733f, 0.12489762f, 0.11768619f, 0.19637819f, 0.09836338f, -0.07496038f, 0.13720265f, 
    -0.09794118f, 0.01566201f, 0.20788117f, -0.32730418f, -0.12613317f, 0.04348708f, 0.03142527f, 0.26566431f, 
    0.21206178f, 0.01408334f, -0.14311543f, 0.00842563f, 0.07635925f, 0.16661735f, 0.00840082f, 0.05867209f, 
    0.00587264f, 0.03259004f, 0.09505799f, -0.02509975f, -0.01149216f, -0.01540851f, 0.09841302f, -0.10064340f, 
    -0.01849519f, -0.02147337f, -0.03600262f, -0.01082710f, -0.01999708f, 0.01068708f, -0.05979242f, -0.07977972f, 
    -0.06665806f, 0.03428926f, 0.04322645f, -0.06288654f, -0.05476757f, 0.00508469f, -0.00524944f, 0.00248582f, 
    -0.04006204f, 0.02144026f, 0.02561553f, -0.08136254f, -0.07993028f, 0.02325116f, 0.05105361f, -0.02725138f, 
    -0.00850609f, -0.01255610f, 0.05685171f, -0.02883829f, 0.05990805f, -0.07325345f, 0.02367471f, 0.04474670f, 
    -0.07298767f, 0.01500378f, -0.01697293f, -0.04835572f, 0.04999046f, 0.00472767f, -0.02192813f, 0.03848509f, 
    0.02767806f, -0.01151201f, -0.08243419f, -0.06239666f, -0.00291749f, -0.04734400f, -0.07254218f, -0.04138376f, 
    0.01566350f, -0.03663630f, -0.03696643f, 0.02048407f, 0.01824212f, 0.04746177f, -0.01891720f, -0.04229138f, 
    -0.00547722f, 0.04123348f, -0.06455676f, 0.02243473f, -0.05520745f, 0.05461487f, -0.02337222f, 0.05394147f, 
    0.05865937f, 0.02652907f, -0.06370425f, -0.05461984f, -0.01162894f, 0.04773711f, 0.01814793f, -0.07751235f, 
    0.01319018f, 0.02864930f, -0.00210681f, 0.01858693f, -0.04647842f, 0.04554111f, 0.04410606f, 0.00299536f, 
    0.03139440f, -0.08036688f, 0.03359042f, -0.04810809f, -0.04129035f, -0.02837746f, 0.03997253f, 0.04994275f, 
    -0.02069221f, -0.06659736f, 0.00200451f, -0.05136462f, 0.00914394f, -0.08103234f, 0.01345169f, -0.05877182f, 
    0.04203947f, -0.05578673f, -0.00325442f, -0.02863435f, -0.05301046f, -0.02833903f, -0.07317857f, -0.02039551f, 
    0.00086387f, -0.03264685f, 0.00777458f, 0.04435144f, -0.06936798f, -0.01699847f, 0.05203456f, -0.01934091f, 
    -0.05410446f, -0.02925775f, -0.07159875f, 0.03624106f, -0.01273228f, -0.03050888f, -0.07516485f, -0.00089039f, 
    -0.05924901f, -0.06454450f, 0.00632004f, -0.07681220f, 0.03657396f, -0.05189417f, -0.07323456f, -0.01087722f, 
    0.04374240f, -0.06380106f, 0.00038887f, 0.02715495f, 0.04595579f, -0.01149601f, 0.03129143f, 0.02003931f, 
    0.01779046f, -0.08000050f, 0.05191948f, -0.06851818f, -0.07743873f, 0.06528024f, 0.02224367f, -0.04452503f, 
    0.03954415f, 0.02619667f, 0.00179639f, -0.03295883f, -0.03003077f, -0.08395049f, -0.05030188f, -0.03719777f, 
    -0.01816835f, -0.04174387f, 0.04144989f, -0.06953666f, 0.03934276f, -0.00192485f, -0.06326501f, 0.04317665f, 
    -0.05073697f, -0.00428948f, -0.03272701f, -0.00130608f, -0.05445003f, -0.00531738f, -0.05437710f, 0.05329294f, 
    -0.00231985f, 0.01281743f, 0.00307576f, -0.06871154f, 0.03903764f, 0.03968957f, 0.04113324f, -0.04655878f, 
    0.00727973f, -0.08292878f, 0.01038650f, 0.04731756f, 0.04945343f, 0.04644729f, -0.00427288f, -0.06402190f, 
    -0.05954611f, -0.05326355f, -0.03918744f, -0.07244129f, -0.00693640f, 0.05078014f, -0.01579925f, 0.05365904f, 
    0.00638746f, -0.16698824f, 0.07789242f, -0.12369690f, -0.03182778f, 0.10354141f, 0.00920257f, -0.11463416f, 
    0.14125772f, -0.25337809f, 0.00296950f, -0.21711433f, -0.10690915f, -0.24946326f, -0.21061210f, -0.11723477f, 
    0.27778965f, -0.05361727f, 0.16879413f, 0.08694809f, -0.21821199f, -0.04895624f, -0.25822815f, -0.06867971f, 
    -0.28293103f, -0.47619921f, -0.23207043f, 0.11772460f, 0.09514908f, 0.08825929f, -0.02360885f, -0.02663626f, 
    0.04172414f, 0.10891487f, -0.27040333f, 0.30517563f, 0.23999196f, -0.08198425f, 0.28065947f, 0.10440074f, 
    0.05650342f, 0.00147582f, -0.25827616f, -0.09444025f, 0.12716362f, 0.08327739f, 0.03578620f, -0.00887238f, 
    -0.29834527f, 0.39960653f, -0.32115710f, -0.00797285f, 0.25135368f, -0.01779927f, -0.04620204f, 0.10596977f, 
    -0.01684973f, 0.00729557f, 0.02616103f, 0.09563388f, 0.06279647f, -0.35324627f, 0.07451268f, 0.05097147f, 
    -0.01446390f, 0.11594235f, -0.02269391f, 0.02158322f, 0.10088933f, 0.21164671f, 0.17659837f, 0.11833622f, 
    0.12343194f, -0.04540302f, 0.25239539f, 0.15108725f, -0.13063902f, -0.03461397f, 0.09486476f, -0.07779004f, 
    0.18998529f, -0.00349643f, -0.17680141f, -0.08301624f, 0.05567098f, 0.25132009f, 0.33525860f, 0.07104133f, 
    0.06540959f, 0.17008935f, -0.06304394f, 0.07843358f, -0.09904579f, 0.02280259f, -0.00660905f, 0.20347138f, 
    0.15914610f, 0.07705433f, 0.01609789f, -0.01592833f, 0.07744631f, 0.15708475f, 0.08569548f, 0.05313485f, 
    0.07895796f, -0.07298519f, -0.06516309f, -0.05730444f, 0.16344094f, 0.00929671f, -0.06549767f, 0.23188415f, 
    0.03646865f, -0.04632288f, -0.01943715f, 0.07491888f, -0.07988006f, -0.01643770f, -0.12240644f, 0.03483990f, 
    -0.24072646f, -0.47919402f, -0.08492173f, -0.06788050f, 0.36114204f, 0.09384876f, -0.01153596f, -0.03858273f, 
    -0.14730103f, -0.15649974f, -0.00605071f, 0.01462840f, 0.20081781f, 0.19837922f, 0.32447910f, 0.00739820f, 
    0.02700681f, -0.13004027f, -0.02249306f, 0.02249053f, 0.05428763f, 0.09771083f, 0.21363157f, 0.04571946f, 
    0.09307179f, 0.22205827f, 0.27660730f, 0.34124759f, -0.02474342f, 0.14373331f, 0.16804080f, 0.00667471f, 
    0.11743335f, 0.04158360f, 0.12918629f, 0.15270992f, -0.37744117f, -0.03439080f, 0.08144940f, 0.10024442f, 
    0.09509861f, -0.07644346f, -0.17043032f, -0.07285492f, 0.03032262f, -0.12900423f, -0.01060108f, -0.22705567f, 
    -0.03720670f, -0.43186995f, -0.20836423f, 0.15716249f, 0.13018522f, 0.00662136f, 0.08541568f, -0.01011596f, 
    -0.10320786f, -0.04358606f, 0.24092413f, 0.17418481f, -0.05214905f, -0.23620430f, -0.39834666f, 0.20557922f, 
    0.06038260f, -0.03859143f, -0.00608603f, 0.03295656f, 0.12453586f, 0.00565955f, 0.06171543f, 0.21868823f, 
    0.04554046f, 0.00163733f, 0.03647882f, 0.01635015f, -0.03056596f, -0.03297710f, -0.06570119f, 0.03679691f, 
    0.05440772f, 0.00192584f, 0.05382981f, 0.04402405f, 0.01507036f, 0.01893337f, 0.00598861f, 0.04144442f, 
    -0.00966781f, 0.06235043f, -0.04814608f, -0.00936744f, -0.02281426f, -0.04256985f, 0.02095879f, 0.06206080f, 
    -0.06349513f, 0.03351470f, -0.06621148f, 0.04032144f, 0.03951729f, 0.04756607f, -0.04905760f, -0.05938743f, 
    -0.00708569f, -0.05618476f, -0.07235622f, -0.02665425f, -0.07760452f, -0.03109978f, 0.03916483f, -0.01369891f, 
    0.05191541f, -0.03113768f, 0.02446339f, -0.05840123f, 0.00981848f, -0.04167432f, 0.03675573f, -0.03539884f, 
    -0.02234958f, 0.01448689f, -0.03168418f, -0.06309940f, -0.05352912f, 0.03314184f, 0.03247220f, -0.06168810f, 
    0.02998912f, -0.01003657f, -0.07850119f, -0.01132704f, -0.03957876f, -0.00575885f, 0.00411799f, 0.04793656f, 
    0.00479309f, -0.04087977f, -0.03354058f, -0.04808310f, 0.05280163f, -0.01872917f, -0.06523046f, -0.06834435f, 
    -0.05631828f, -0.02002845f, 0.04447004f, 0.02328408f, -0.04886012f, 0.00351641f, -0.08262791f, -0.03587320f, 
    0.01233336f, 0.05103552f, -0.04591486f, 0.00045105f, 0.05589535f, -0.03950483f, -0.00935994f, -0.05084516f, 
    -0.04082960f, -0.05574827f, -0.04578939f, 0.00426865f, -0.04149535f, 0.03194149f, -0.07584008f, -0.03749881f, 
    -0.07496091f, -0.04868034f, 0.00784594f, -0.06579189f, 0.01846658f, -0.00663299f, 0.04271819f, 0.00231433f, 
    0.03370357f, -0.05268276f, -0.01877579f, -0.05494915f, -0.04430304f, -0.04073374f, 0.02201210f, 0.04280805f, 
    -0.07834130f, -0.03209779f, 0.01976841f, -0.06206712f, -0.02832805f, 0.00065224f, -0.07707840f, 0.05063969f, 
    0.00413837f, -0.03489352f, 0.07003760f, -0.06271142f, -0.03886821f, -0.02926275f, 0.03394616f, 0.02373569f, 
    -0.00727983f, 0.05334263f, -0.02643453f, -0.01228721f, -0.03573398f, -0.03483179f, 0.02850700f, -0.06065539f, 
    -0.00113816f, 0.02191789f, -0.08113204f, -0.00720644f, -0.02732814f, -0.01026406f, -0.04973665f, -0.05711544f, 
    -0.05124844f, -0.03684947f, -0.01293411f, 0.00358637f, -0.03695339f, 0.02805478f, 0.05006262f, 0.03897037f, 
    0.04224959f, 0.00270627f, 0.02113681f, -0.07409055f, -0.00024796f, -0.03539729f, -0.01536468f, -0.00343401f, 
    -0.05218106f, -0.05906206f, -0.00059282f, -0.06343467f, -0.01494484f, 0.05645952f, -0.03709433f, -0.02929162f, 
    0.00205601f, -0.05950518f, -0.03144822f, 0.00299541f, -0.02425059f, -0.02759946f, 0.02430023f, 0.07175530f, 
    0.00257239f, -0.01685615f, 0.01607719f, 0.02030550f, -0.06010619f, -0.06326033f, 0.03240904f, -0.05394484f, 
    0.02070660f, -0.07774715f, 0.02119757f, 0.03008460f, 0.04689766f, 0.00601410f, -0.06855010f, 0.04035426f, 
    0.07914295f, 0.12977059f, 0.07245575f, -0.12000324f, -0.11507273f, -0.06978425f, -0.08313416f, 0.00424139f, 
    0.14766198f, -0.10086636f, -0.17233066f, 0.11654509f, 0.18788028f, 0.18140575f, 0.29169533f, -0.05086476f, 
    0.14318493f, 0.00630411f, -0.21866117f, 0.02492353f, -0.17804110f, 0.00303398f, 0.15343401f, -0.06793952f, 
    -0.11491384f, -0.22576886f, -0.22300649f, -0.25340948f, -0.01587955f, -0.05698143f, -0.02168709f, -0.02072585f, 
    0.06858574f, -0.02942136f, 0.01687749f, -0.06858516f, -0.22033711f, 0.00593991f, 0.02377776f, 0.29069585f, 
    -0.08827850f, -0.00579729f, 0.07703932f, 0.09356321f, -0.02438313f, 0.06624463f, -0.05643126f, 0.06051822f, 
    -0.25933865f, -0.02950349f, 0.26216257f, -0.37332141f, 0.11720973f, -0.01884945f, -0.18704970f, 0.05270806f, 
    0.14750722f, 0.04741352f, 0.01870256f, 0.08588786f, 0.23815353f, 0.12118926f, -0.11924531f, -0.00764138f, 
    -0.10309019f, 0.09486365f, -0.04109410f, 0.01351003f, 0.10274252f, 0.05916082f, -0.01765489f, 0.13953513f, 
    -0.39876726f, 0.08274726f, 0.06348965f, 0.35014510f, -0.09051587f, -0.02863725f, -0.03222664f, 0.17603169f, 
    -0.11318436f, -0.08943234f, 0.02838271f, -0.01493320f, -0.35008630f, -0.14414130f, 0.32190371f, 0.27127275f, 
    0.05730767f, 0.03963824f, -0.26795048f, 0.12392396f, 0.06681545f, 0.24478209f, 0.07759584f, 0.12862033f, 
    -0.00735760f, -0.24913661f, -0.27666676f, 0.04986948f, 0.27888438f, 0.20410095f, -0.06958684f, -0.06883330f, 
    -0.07241133f, -0.18707104f, 0.11597698f, -0.03839663f, 0.00260538f, -0.26844877f, -0.03917268f, -0.12569770f, 
    -0.02787143f, 0.18457505f, 0.14469565f, -0.10329925f, 0.08865817f, 0.04523873f, 0.00557162f, -0.03393665f, 
    -0.13719290f, 0.19833498f, 0.20106055f, -0.17448406f, -0.13441923f, -0.03110101f, 0.06290407f, 0.23789293f, 
    -0.08265775f, 0.22948632f, -0.01842895f, -0.04500820f, 0.03583106f, -0.05197524f, 0.21374397f, 0.20355420f, 
    0.14319007f, 0.06178345f, 0.06957525f, -0.00924043f, -0.04091180f, -0.09095200f, -0.16091214f, -0.09118047f, 
    -0.30728900f, -0.32647383f, 0.05349650f, 0.26231670f, 0.01645105f, -0.08054385f, -0.04231445f, -0.02928931f, 
    0.02725651f, 0.07141644f, 0.09670077f, 0.03151759f, 0.08528218f, 0.20432259f, 0.27336821f, 0.35995355f, 
    -0.01861044f, -0.00631088f, -0.03128679f, 0.00118253f, 0.00582401f, -0.07426353f, 0.02363554f, 0.05815336f, 
    0.13949627f, 0.45727307f, 0.47462404f, 0.38909006f, -0.07431958f, -0.17347451f, -0.15755947f, -0.06376445f, 
    -0.16414233f, 0.12734272f, 0.02436360f, 0.04254394f, 0.04593407f, 0.16387905f, -0.29520711f, -0.24990512f, 
    -0.06052080f, -0.07048853f, 0.15890998f, -0.07324843f, 0.03489976f, 0.02470277f, -0.01610856f, -0.00823123f, 
    0.33322737f, -0.21375251f, -0.09659775f, -0.36670139f, -0.07114903f, -0.05026808f, 0.18531755f, -0.13033503f, 
    0.14037763f, -0.01315688f, -0.15547654f, 0.08482055f, 0.08521698f, -0.31655431f, -0.01335717f, -0.39251074f, 
    -0.00146214f, 0.01851731f, 0.08894798f, -0.14675245f, 0.04558330f, -0.02093669f, -0.15126298f, -0.27816144f, 
    -0.04750555f, -0.03200135f, 0.31409609f, -0.00201577f, -0.12614414f, -0.08801834f, 0.01327207f, 0.13430695f, 
    0.20773470f, -0.10746820f, 0.06423234f, 0.15352400f, -0.11713224f, 0.00783143f, 0.10228878f, 0.31581202f, 
    0.11160388f, 0.07179575f, 0.00160834f, -0.00684531f, 0.11333105f, 0.05923107f, 0.12910531f, -0.02651777f, 
    -0.10936806f, 0.40106958f, -0.22204500f, 0.14271379f, 0.04468903f, -0.30374011f, -0.06351385f, -0.25221333f, 
    0.05986953f, 0.02475084f, -0.19439317f, 0.06912292f, 0.28280669f, -0.25798157f, 0.18196799f, 0.12208734f, 
    0.17786351f, 0.13712968f, -0.11028824f, -0.00933995f, 0.01851616f, 0.05744201f, -0.04698842f, -0.06542818f, 
    0.17737630f, -0.02962994f, 0.16169526f, 0.23140116f, 0.12539043f, 0.27160293f, -0.04812951f, 0.23527524f, 
    0.07967023f, 0.00346921f, -0.28580922f, -0.14321794f, -0.20639785f, -0.12169150f, 0.40087137f, 0.05901049f, 
    0.16135129f, 0.07284039f, -0.30390719f, 0.13592455f, 0.02417603f, 0.02295899f, 0.03769783f, 0.02087417f, 
    -0.35331994f, -0.18406777f, -0.01748357f, -0.28304598f, 0.04928507f, -0.02720123f, 0.05627780f, 0.11215832f, 
    0.09210344f, 0.04994955f, -0.22243203f, -0.08124430f, 0.19363831f, -0.01994698f, 0.00581036f, 0.02694803f, 
    -0.05882414f, -0.04745330f, -0.13758144f, 0.22579338f, 0.04486154f, -0.20699592f, 0.13618755f, -0.00413479f, 
    -0.15678236f, -0.09508958f, -0.16316336f, -0.16911721f, -0.15227357f, 0.18131837f, -0.13400365f, 0.07235536f, 
    -0.10071583f, 0.08685665f, 0.01432551f, -0.03203364f, 0.06271905f, 0.44964442f, 0.24719018f, 0.10496712f, 
    -0.08476930f, 0.12794891f, 0.16402428f, -0.09092990f, -0.03889421f, 0.02063165f, 0.06106119f, -0.01350177f, 
    0.01765646f, 0.15320149f, 0.28535005f, 0.45968422f, 0.09232444f, 0.06520311f, 0.19353868f, 0.09597824f, 
    0.24766548f, -0.12094320f, -0.00618619f, 0.22396678f, -0.08583898f, 0.24799186f, 0.10118005f, 0.16506113f, 
    -0.05317990f, -0.00190349f, -0.26717019f, -0.29789662f, 0.00712391f, 0.01359910f, -0.00125029f, -0.05984502f, 
    0.56191522f, -0.34410247f, 0.09269550f, 0.07258955f, -0.18470144f, -0.20827457f, -0.19352883f, 0.05413258f, 
    0.18050596f, 0.04442734f, 0.08523877f, 0.12160110f, -0.20413478f, -0.00453184f, -0.14293478f, 0.30680534f, 
    -0.18399093f, -0.13595928f, -0.16751745f, -0.12946038f, 0.14298429f, -0.06329010f, 0.10729634f, 0.13101882f, 
    0.00650901f, -0.09046087f, -0.06621547f, -0.01497471f, -0.08233804f, 0.03669173f, -0.04871276f, 0.01588356f, 
    -0.11003659f, -0.07052778f, 0.01391764f, -0.09839081f, -0.06307175f, -0.05059831f, 0.01336842f, -0.01060883f, 
    -0.09583817f, -0.09521580f, -0.00160040f, -0.03520893f, -0.03835176f, -0.01679950f, -0.01229968f, -0.05978383f, 
    0.05066759f, -0.01318128f, 0.00694694f, -0.05295412f, -0.06465479f, 0.00937915f, 0.04206756f, -0.07926399f, 
    -0.09249453f, 0.04131945f, -0.03509032f, -0.04934149f, 0.02134619f, -0.09652891f, 0.02658559f, 0.01647200f, 
    0.00386349f, -0.06547093f, -0.04570034f, -0.06843105f, -0.08171085f, -0.00233926f, -0.11941625f, -0.09603365f, 
    0.05790462f, 0.05999801f, -0.00608445f, 0.03839907f, 0.00046799f, 0.03947207f, -0.04578557f, -0.01554038f, 
    -0.03318367f, -0.01813152f, 0.07320942f, 0.05845239f, -0.08044992f, -0.07157957f, -0.06074940f, -0.00206693f, 
    -0.07873338f, 0.01279375f, 0.04727154f, -0.09906087f, -0.07420573f, 0.03100419f, -0.00027714f, -0.03004868f, 
    -0.05038811f, 0.02099728f, -0.06315054f, -0.11602761f, 0.04908329f, -0.02428606f, 0.00978911f, 0.01416706f, 
    -0.04160620f, -0.05006817f, -0.02273784f, -0.05070614f, -0.03738018f, -0.06174792f, 0.05098904f, -0.01739539f, 
    0.01056913f, 0.03867673f, -0.01709124f, -0.00540671f, -0.00936283f, -0.01635538f, -0.06143866f, 0.02156695f, 
    0.01477470f, 0.04238207f, -0.05512894f, -0.03279784f, -0.02252877f, -0.01273849f, 0.00231322f, -0.08355612f, 
    -0.00477813f, 0.04268802f, -0.01982050f, -0.05743598f, -0.02938777f, -0.02402279f, 0.00028932f, -0.04996519f, 
    -0.03585313f, -0.06019568f, -0.03164646f, -0.05601054f, -0.02773483f, 0.01673551f, -0.02041005f, 0.01902532f, 
    -0.07390136f, -0.07432365f, -0.07950531f, -0.03508626f, -0.03354729f, -0.06849074f, 0.03167662f, 0.02704165f, 
    0.00117253f, -0.00634173f, -0.01734336f, -0.12836969f, -0.05929971f, -0.02909389f, -0.06904085f, -0.04248644f, 
    -0.00172388f, -0.02845870f, -0.13067691f, -0.05385870f, -0.11056876f, -0.12111230f, -0.01662896f, -0.11986251f, 
    0.03641280f, -0.06298882f, -0.06473356f, -0.06596500f, 0.04955506f, 0.03317914f, -0.09709885f, -0.01334556f, 
    -0.10102781f, -0.08319285f, -0.10104250f, -0.07915439f, -0.08943702f, -0.02673092f, 0.00924645f, -0.01502425f, 
    0.01201861f, -0.00614641f, -0.10955810f, 0.01351460f, -0.05177176f, 0.01865129f, -0.02936217f, 0.01712400f, 
    0.04563867f, -0.03190820f, -0.03558032f, -0.09036274f, -0.02345054f, -0.11482409f, 0.02742656f, -0.08160181f, 
    -0.05362054f, -0.04691066f, -0.07120062f, -0.10805398f, -0.00027634f, -0.09558706f, -0.03083846f, 0.05221141f, 
    -0.09677403f, -0.05087156f, -0.03439047f, 0.04723473f, 0.00695493f, -0.02776024f, -0.06659146f, -0.00896357f, 
    -0.17940101f, -0.24519560f, -0.28523383f, -0.29248300f, 0.25311372f, 0.17597909f, 0.16774818f, -0.06830458f, 
    0.01562093f, -0.51286727f, -0.27691782f, -0.14977068f, -0.31574717f, -0.12780790f, -0.15315567f, -0.41741726f, 
    0.00465257f, -0.37119889f, -0.00974293f, -0.25021458f, -0.24669705f, -0.08097146f, -0.27675223f, -0.45482543f, 
    -0.05571755f, 0.00042110f, 0.24790207f, 0.04580863f, -0.07830732f, -0.10625108f, 0.12575030f, 0.03578373f, 
    -0.13339207f, -0.05539097f, -0.06888929f, -0.05294783f, 0.15218377f, -0.06524172f, 0.10778108f, 0.20059574f, 
    0.23072881f, 0.14301859f, 0.09931465f, 0.02195125f, -0.20466234f, -0.03481189f, 0.03810623f, -0.07362568f, 
    0.36174098f, 0.35708535f, -0.08679891f, 0.20942993f, 0.04871024f, -0.23313655f, 0.20372076f, -0.31827900f, 
    0.03899724f, 0.02235209f, -0.05538953f, 0.05208285f, -0.12831667f, 0.03093920f, 0.22238924f, 0.30301920f, 
    -0.28087476f, 0.21029060f, 0.03680350f, 0.08020704f, 0.20215134f, 0.37714466f, 0.17728266f, 0.62231076f, 
    0.17009464f, 0.47448677f, 0.18773128f, -0.17576736f, 0.20877045f, 0.12747841f, 0.07486199f, 0.10981710f, 
    -0.15917802f, -0.04842654f, -0.22707951f, -0.43176466f, 0.25853610f, 0.16740334f, 0.04755849f, 0.09304120f, 
    0.10182758f, 0.25685495f, 0.18055704f, 0.06333055f, 0.09320215f, 0.21033703f, 0.20470956f, 0.14024945f, 
    -0.54957730f, -0.02373324f, 0.38147581f, 0.18251291f, 0.20821615f, 0.08546565f, -0.00556906f, -0.01404322f, 
    0.14854115f, -0.59345955f, -0.31780016f, -0.41987395f, 0.06521068f, 0.19065090f, 0.24286687f, 0.16532783f, 
    0.24204378f, 0.07532898f, -0.09270402f, 0.04447563f, -0.19086467f, -0.23163924f, -0.15636471f, -0.24608506f, 
    -0.23907378f, -0.05747390f, -0.16895635f, -0.31130067f, -0.07193738f, -0.06723671f, -0.19691356f, -0.03521777f, 
    -0.16147420f, -0.12448693f, -0.06879730f, -0.51474345f, 0.09847436f, 0.10753538f, 0.00264618f, 0.56653333f, 
    0.00361359f, 0.20557664f, 0.08318605f, -0.00006905f, -0.13841981f, 0.04563205f, -0.05245913f, -0.11510652f, 
    0.20945399f, 0.04851503f, 0.13167450f, 0.17727686f, 0.19470787f, 0.18305691f, 0.03213808f, 0.21063127f, 
    0.02524837f, -0.09055755f, 0.02273440f, 0.03322996f, -0.03909265f, 0.25002182f, 0.08580792f, 0.04630128f, 
    -0.17618349f, 0.08754674f, -0.26081896f, -0.30439538f, -0.19366175f, -0.09503677f, 0.14841707f, -0.12267473f, 
    0.37441412f, 0.08296159f, 0.19111885f, 0.10039409f, 0.06033712f, 0.05640294f, -0.06818381f, -0.14124434f, 
    0.06260977f, 0.31218988f, 0.12532793f, 0.17125672f, -0.27626988f, -0.00595450f, 0.10461532f, 0.09668314f, 
    -0.25266245f, -0.01760877f, -0.12056374f, -0.10717385f, -0.07420724f, 0.00715320f, 0.09950622f, 0.10461135f, 
    -0.07929370f, -0.10689422f, 0.06265424f, -0.15576659f, 0.04455522f, 0.00210024f, 0.19518578f, -0.02230358f, 
    0.16581690f, 0.01512375f, -0.05615485f, -0.01220854f, -0.15076843f, 0.03520397f, 0.17981452f, -0.20901816f, 
    0.15958183f, 0.06705450f, -0.05052874f, -0.03660898f, 0.05655411f, 0.02756682f, -0.15094225f, -0.22581540f, 
    -0.19270176f, -0.19963817f, -0.06928643f, 0.06247295f, 0.12945390f, 0.04086491f, -0.07545231f, 0.02947718f, 
    0.19689786f, -0.21619037f, 0.10041292f, 0.00360297f, -0.08035875f, -0.26439831f, 0.24498095f, 0.24810833f, 
    -0.02604583f, -0.00448913f, -0.14370570f, -0.03609824f, -0.09045272f, -0.13923116f, 0.10495105f, 0.00270369f, 
    -0.32363874f, 0.60377908f, -0.25343966f, -0.02820614f, 0.00332281f, 0.02484888f, -0.09068695f, 0.03332731f, 
    0.04596885f, 0.03164873f, -0.09341267f, 0.00695209f, 0.24390681f, -0.24234568f, -0.03953141f, -0.05499534f, 
    -0.08113838f, 0.02837275f, -0.01039240f, -0.02394255f, 0.17493419f, 0.10792326f, 0.13550922f, 0.20414127f, 
    0.02262474f, -0.01239560f, 0.26139694f, 0.05996589f, -0.02693350f, 0.19347350f, -0.18384810f, 0.14307681f, 
    -0.02314631f, -0.07120672f, -0.15864012f, -0.21254490f, -0.29200181f, -0.11177757f, 0.46133086f, -0.09715105f, 
    0.13180219f, -0.09867048f, -0.09314974f, 0.12573245f, 0.04152982f, -0.04427589f, 0.09764259f, 0.05873539f, 
    -0.12479674f, -0.27729091f, 0.03508005f, -0.06379321f, 0.07904906f, 0.08207718f, 0.06293316f, 0.29399127f, 
    0.13274972f, 0.05514376f, -0.19500268f, -0.04347715f, 0.24427098f, -0.04145024f, -0.12904817f, 0.17798497f, 
    0.03434383f, 0.03578215f, 0.09861746f, 0.02142421f, 0.05951642f, -0.05980448f, -0.01932644f, -0.10646806f, 
    -0.02946837f, 0.03628013f, 0.04109210f, -0.04584743f, 0.00056488f, 0.06394879f, -0.12234677f, 0.00213393f, 
    0.00481652f, 0.19397929f, 0.00897776f, -0.00252483f, -0.06247097f, 0.11415379f, 0.04043759f, -0.18102163f, 
    -0.07780474f, -0.03744566f, -0.08816090f, -0.10437742f, 0.01589754f, 0.06835309f, 0.10131434f, 0.12990819f, 
    -0.21711764f, 0.11797867f, 0.25233302f, 0.15872194f, 0.01976751f, -0.04448371f, 0.23930286f, 0.04317274f, 
    0.09733938f, -0.06548676f, 0.00506314f, 0.15771024f, 0.06702976f, 0.24828759f, 0.15142913f, 0.37357143f, 
    0.02560924f, -0.04500675f, 0.00115565f, -0.05044869f, -0.10676818f, 0.06824365f, 0.11287528f, 0.06425857f, 
    -0.01895187f, -0.01217741f, 0.48441565f, 0.25275770f, -0.22482948f, -0.09308656f, -0.16874434f, 0.03875097f, 
    0.11114818f, 0.13622774f, 0.14024025f, 0.19755363f, 0.31987235f, 0.06530908f, -0.38000923f, 0.22538565f, 
    0.04314600f, 0.07048789f, 0.11060912f, -0.02889936f, -0.00156040f, -0.09634353f, -0.01081919f, 0.03629718f, 
    -0.06230570f, 0.01080315f, -0.23607023f, 0.14330478f, 0.04404331f, 0.18137866f, -0.00174171f, 0.03193474f, 
    0.02595630f, -0.26639253f, -0.14261955f, 0.10310493f, 0.24804272f, 0.03595458f, -0.37821996f, 0.16243313f, 
    -0.07499705f, -0.10892861f, 0.08625755f, 0.06593632f, -0.19454315f, 0.08632641f, -0.25477231f, -0.21514270f, 
    0.21917813f, 0.15422466f, -0.17383255f, 0.10386010f, -0.31660527f, -0.01512254f, 0.17259088f, 0.27335262f, 
    -0.25036478f, 0.15790322f, -0.18295099f, -0.06690148f, -0.08883875f, 0.28638563f, 0.19259726f, -0.09696100f, 
    -0.02259595f, 0.10774576f, 0.16566510f, -0.20425016f, -0.02287266f, 0.24045299f, 0.09250419f, -0.03438490f, 
    0.31308523f, -0.50992620f, 0.08206519f, 0.02751383f, -0.06554578f, 0.10333320f, 0.00173159f, 0.03839216f, 
    0.32072735f, 0.09243104f, 0.06584975f, 0.21585867f, -0.21013585f, 0.27035412f, -0.08248693f, 0.13196112f, 
    -0.01596596f, -0.05421596f, -0.06843086f, -0.04916860f, 0.12281954f, 0.22733767f, 0.05453052f, 0.53117752f, 
    0.17409298f, 0.26306948f, -0.18676789f, 0.05873981f, 0.08614095f, 0.06288254f, 0.17522508f, -0.22099268f, 
    0.04685628f, 0.04880955f, 0.03148925f, -0.11479870f, 0.21301779f, -0.06253245f, 0.07273694f, 0.38872692f, 
    0.06713499f, 0.02558425f, -0.06088968f, -0.13560073f, 0.05966697f, 0.07750139f, 0.01530105f, 0.15540563f, 
    -0.06851593f, 0.70903385f, 0.14200768f, 0.00602318f, -0.08613394f, 0.04205007f, -0.00258832f, -0.07069695f, 
    -0.23762891f, -0.40722889f, -0.03314301f, -0.23444435f, 0.04917673f, 0.17798491f, 0.71020484f, -0.28256553f, 
    0.02921316f, -0.01967873f, -0.09723160f, 0.14350784f, -0.25320676f, -0.14534657f, -0.00273598f, -0.24292693f, 
    0.14603215f, -0.15439622f, -0.05323849f, 0.22095209f, -0.07657818f, 0.03051019f, 0.03938637f, 0.18638693f, 
    -0.14249411f, 0.02813847f, 0.05951603f, -0.17193252f, -0.02015988f, 0.18531607f, 0.21381398f, 0.26196972f, 
    0.13694549f, 0.21053757f, 0.02477540f, 0.16156909f, -0.02760574f, -0.17339393f, -0.10959983f, -0.05867876f, 
    0.15245876f, 0.12766455f, 0.10676866f, 0.09022925f, 0.05399339f, -0.01322473f, -0.19774315f, 0.00211718f, 
    -0.01277129f, -0.02805921f, -0.09578736f, 0.07881535f, -0.06929745f, -0.16265216f, -0.02426730f, -0.19778970f, 
    0.01944264f, -0.07059894f, -0.04524139f, -0.13801329f, -0.04257403f, -0.22947203f, 0.11632591f, -0.13879904f, 
    0.34460747f, 0.34102553f, -0.04851792f, 0.30538166f, 0.02126510f, -0.11999785f, 0.08398891f, -0.06985489f, 
    -0.08292415f, 0.02116827f, 0.06037721f, 0.07443245f, -0.25179806f, -0.26969412f, 0.54507625f, -0.18938856f, 
    -0.00305385f, 0.08641227f, -0.17228884f, -0.00631901f, -0.06191545f, 0.02035289f, 0.03006207f, -0.07775171f, 
    0.14543094f, 0.10492994f, -0.01923654f, -0.03866844f, -0.01054488f, -0.05035138f, -0.03192424f, 0.15706334f, 
    0.19178331f, -0.07952124f, -0.05094116f, -0.02904774f, 0.01633886f, 0.11470759f, 0.12203784f, -0.02465468f, 
    0.15252440f, -0.09174607f, -0.03501792f, 0.02582534f, 0.13506904f, -0.01243816f, -0.15607221f, -0.00681132f, 
    0.26265213f, 0.18587823f, 0.27871403f, 0.06221673f, 0.01663054f, -0.01530605f, -0.03473516f, 0.04823862f, 
    0.00157317f, -0.11386627f, -0.07179954f, -0.29212171f, -0.69328946f, 0.31174403f, -0.38672572f, 0.03420934f, 
    -0.29231939f, 0.10211822f, 0.02631131f, 0.15721901f, -0.15864815f, -0.06974561f, 0.06565275f, -0.20626691f, 
    0.12800969f, 0.14767936f, -0.05311533f, 0.22418703f, 0.09603146f, -0.14182083f, 0.13539447f, 0.05134285f, 
    0.11917618f, 0.19095315f, -0.10620454f, 0.11264565f, 0.13875706f, 0.06869598f, 0.05882214f, 0.02458514f, 
    0.01445745f, -0.00545185f, -0.01946926f, -0.16685537f, 0.16145602f, 0.17641114f, 0.07758773f, 0.07348749f, 
    -0.23573765f, -0.26785001f, -0.03303943f, 0.05470878f, 0.02960110f, -0.03626474f, -0.28267577f, -0.04926960f, 
    -0.19542396f, -0.00065694f, -0.00977561f, 0.01210839f, -0.48166502f, -0.42040747f, 0.23503068f, 0.16063577f, 
    0.25668868f, 0.18166625f, 0.12052985f, 0.17899853f, -0.19457436f, 0.02329650f, 0.13173924f, 0.14821835f, 
    -0.02491911f, -0.14172508f, -0.04363205f, -0.02694490f, -0.00386410f, -0.00556339f, -0.03127965f, 0.08278345f, 
    -0.03420704f, -0.03527490f, 0.04704968f, -0.03157179f, 0.10977127f, -0.09993640f, -0.01487239f, -0.20183581f, 
    0.07692161f, 0.09409887f, 0.15959816f, 0.01118914f, 0.01127550f, 0.04342780f, 0.07238936f, -0.00547250f, 
    -0.15600224f, 0.44215924f, -0.09692685f, -0.05702626f, -0.23643816f, -0.02271633f, -0.02530631f, -0.01803054f, 
    -0.30543357f, 0.39131638f, 0.02754119f, -0.15343988f, 0.05354425f, 0.52857643f, -0.14261799f, -0.03158139f, 
    0.06311595f, -0.19355789f, 0.22676526f, 0.04141835f, 0.01274367f, 0.14906369f, 0.00413955f, -0.03612613f, 
    -0.66986233f, -0.12297461f, -0.25121006f, -0.03317998f, -0.12346546f, -0.06713835f, -0.19194783f, -0.13572530f, 
    -0.19269882f, -0.11337294f, -0.05801394f, -0.05225116f, 0.33714774f, 0.25427967f, -0.14195378f, -0.08343972f, 
    0.03048891f, 0.05970370f, 0.08689576f, -0.00149266f, -0.01020504f, 0.00488742f, -0.00860385f, 0.07537578f, 
    0.08877239f, 0.03787152f, 0.55693620f, -0.04151265f, -0.14007851f, -0.15446956f, -0.02857249f, 0.12899920f, 
    0.04991405f, 0.18921365f, 0.03901770f, 0.02533957f, 0.37782046f, 0.28172094f, 0.00552967f, -0.06377527f, 
    -0.15000680f, 0.05271179f, 0.12673888f, 0.09500358f, 0.05752999f, 0.03944845f, -0.04822724f, -0.03447247f, 
    -0.35133117f, -0.10744762f, -0.06250020f, -0.12410045f, 0.11839181f, 0.16042331f, 0.12796858f, 0.13622488f, 
    0.08371709f, -0.35687497f, -0.17119355f, -0.37639371f, -0.30287114f, 0.00641961f, -0.04714401f, -0.26630223f, 
    0.03177542f, -0.45537391f, -0.07891062f, -0.19186029f, -0.11549571f, -0.08809172f, -0.29518721f, -0.25796133f, 
    -0.10521873f, -0.03185364f, 0.01233505f, -0.10634900f, -0.04510301f, 0.10307389f, -0.04778592f, -0.02222924f, 
    -0.14839979f, -0.00353404f, 0.07563542f, 0.09974009f, 0.24514741f, -0.05863725f, -0.06410899f, -0.03948518f, 
    0.12317483f, 0.00741823f, 0.07883935f, 0.07700045f, -0.20927878f, -0.07443266f, -0.00057376f, 0.06940106f, 
    0.41367355f, 0.30833632f, -0.13622287f, 0.17206208f, 0.23941638f, -0.27906102f, 0.27075556f, -0.23407720f, 
    -0.03435403f, 0.11288223f, 0.03291766f, 0.01840306f, -0.17300069f, -0.05196671f, 0.25787145f, 0.31399500f, 
    -0.25439250f, 0.13623148f, 0.05321298f, 0.08059232f, 0.20985352f, 0.25887862f, 0.31081215f, 0.58790523f, 
    0.24740273f, 0.23083493f, -0.03602911f, -0.31334701f, 0.22383016f, 0.06758393f, -0.02713805f, 0.13256253f, 
    -0.16150223f, -0.05711020f, -0.12572800f, -0.35756671f, 0.14435431f, -0.02633888f, -0.12035844f, -0.01286565f, 
    0.00198815f, 0.16100267f, 0.15603784f, 0.02558978f, 0.09186233f, 0.14186488f, 0.20813611f, 0.20854795f, 
    -0.23981108f, -0.23037414f, 0.13862704f, 0.21628369f, 0.14559859f, 0.09095008f, -0.02923791f, -0.04464888f, 
    0.27749583f, -0.51660013f, -0.27493790f, -0.35055181f, -0.09386126f, 0.07235563f, 0.17603213f, 0.02387977f, 
    0.18697591f, 0.07199787f, -0.09352067f, 0.00437004f, -0.05243693f, -0.10524867f, -0.13420254f, -0.15978122f, 
    -0.17776345f, -0.08554919f, -0.07786103f, -0.08800473f, -0.01331747f, -0.04668488f, -0.23661037f, 0.12276698f, 
    -0.02438534f, -0.32297000f, 0.00373912f, -0.03815253f, -0.00684834f, 0.11828178f, -0.06407118f, 0.25618342f, 
    -0.02995078f, 0.10764980f, 0.25004107f, -0.03652696f, -0.02886379f, 0.17493831f, -0.08456656f, -0.14509524f, 
    0.23251456f, 0.12373712f, -0.11739650f, -0.02166078f, 0.14565602f, 0.07910908f, 0.05001029f, 0.05433091f, 
    -0.07793765f, -0.07206248f, -0.03612135f, 0.03071825f, -0.00360179f, 0.32471219f, -0.12440102f, 0.03188995f, 
    -0.20150706f, 0.06722049f, -0.22064826f, -0.17899144f, -0.09070659f, 0.11971998f, 0.16348755f, -0.00312264f, 
    0.16422850f, -0.03117973f, 0.59699458f, 0.10707390f, 0.05646202f, 0.00073235f, -0.06083758f, 0.02806159f, 
    0.16607785f, 0.18151493f, 0.19984934f, 0.16263554f, -0.11141559f, 0.09024651f, -0.04808869f, -0.02513892f, 
    -0.13135320f, 0.03099401f, -0.12151560f, -0.12158176f, 0.08072150f, 0.03149044f, -0.04193269f, 0.10954989f, 
    -0.06289883f, -0.06532472f, -0.04574550f, 0.00132169f, -0.04859837f, 0.06749886f, 0.03695387f, 0.03306504f, 
    -0.02783364f, -0.06353521f, -0.06051023f, -0.02403039f, 0.02896886f, -0.05134799f, 0.02192835f, -0.02065822f, 
    0.02632638f, -0.05401694f, -0.05906427f, -0.04304254f, -0.04857079f, -0.05989403f, 0.00871274f, -0.07742122f, 
    0.04729161f, -0.00221955f, -0.02619766f, -0.04404293f, -0.07426244f, 0.06317151f, -0.03603431f, -0.00934873f, 
    -0.05471804f, 0.04408219f, 0.05643110f, -0.02717031f, -0.04827160f, -0.04676829f, -0.04003732f, -0.04280284f, 
    -0.03552338f, -0.01168527f, 0.03697130f, 0.02189004f, -0.04456235f, -0.01222957f, -0.04498716f, -0.03947032f, 
    -0.03673347f, 0.01392634f, -0.06684269f, -0.02104435f, 0.04328836f, 0.01228273f, -0.01513882f, 0.05183978f, 
    -0.01993053f, -0.07247022f, 0.04876465f, -0.02945900f, -0.00432820f, 0.02297120f, 0.02506171f, 0.06000603f, 
    -0.02734354f, 0.00833404f, 0.05103029f, -0.00010185f, 0.05916925f, -0.00888269f, 0.02471363f, -0.00871392f, 
    -0.04668806f, -0.05602743f, -0.07825062f, 0.04746472f, -0.06789006f, -0.05426302f, -0.01552886f, 0.06295987f, 
    0.04111991f, 0.05462755f, 0.04436930f, 0.02001450f, 0.02235694f, -0.03481160f, 0.05407662f, -0.07780682f, 
    0.01414192f, 0.00513834f, 0.03561991f, -0.04192048f, -0.06356972f, -0.01243818f, -0.03662976f, 0.01361528f, 
    -0.00084293f, -0.01605437f, -0.01059932f, 0.03843632f, -0.00099066f, -0.02835752f, 0.00139571f, -0.01960902f, 
    -0.01159272f, 0.03795868f, -0.03634990f, 0.03945720f, -0.05467753f, 0.02335710f, -0.06625008f, 0.04366735f, 
    -0.02725269f, 0.01911057f, -0.06306621f, -0.03002498f, 0.01900611f, -0.04132994f, 0.00479273f, 0.00503571f, 
    -0.03838288f, 0.03615025f, 0.06498639f, -0.01402824f, -0.01419512f, -0.06362636f, 0.03602098f, 0.03547868f, 
    0.02661972f, 0.05622217f, 0.04952255f, -0.03786024f, 0.04498058f, 0.00109909f, -0.02749096f, -0.05917307f, 
    0.06363627f, 0.00605990f, -0.04343912f, 0.02277953f, 0.03520288f, 0.00856750f, -0.01318995f, -0.06064888f, 
    -0.06204671f, 0.06223628f, 0.02672904f, 0.02776846f, 0.03644870f, -0.06155468f, -0.02759647f, 0.00834947f, 
    -0.02760267f, -0.07307280f, -0.00591895f, 0.05214715f, -0.00971246f, -0.06186135f, 0.06225355f, -0.02490892f, 
    -0.04559350f, 0.00004390f, 0.00572453f, -0.02265316f, -0.04679054f, -0.07746111f, -0.03291574f, 0.01419216f, 
    -0.04129883f, -0.01944318f, -0.02733131f, 0.00590022f, -0.03257252f, 0.01626574f, 0.01413993f, 0.01995830f, 
    -0.04090298f, -0.04900846f, 0.04384011f, -0.03917265f, -0.04116328f, 0.03788413f, -0.02951967f, 0.06248831f, 
    -0.07341193f, -0.02363861f, -0.04234237f, 0.04860403f, -0.05144796f, -0.00159302f, -0.04176917f, 0.04336824f, 
    -0.06571171f, -0.04269987f, -0.03182692f, -0.04422242f, 0.00548384f, -0.02804540f, 0.02485271f, 0.04671735f, 
    -0.05413553f, -0.05945425f, 0.02069896f, -0.01236418f, -0.03447004f, 0.03608416f, -0.00555230f, -0.05539352f, 
    -0.03507304f, -0.01271428f, -0.02806700f, 0.01682617f, 0.04428546f, -0.04324390f, -0.07710314f, -0.00505466f, 
    -0.03750240f, 0.01583363f, -0.04350700f, 0.06047187f, -0.06131380f, 0.06872669f, 0.00195112f, -0.03035113f, 
    0.00051834f, -0.03490108f, -0.07181074f, -0.06104551f, -0.07635441f, -0.01139010f, -0.01591594f, 0.03265656f, 
    0.04915618f, 0.05559312f, 0.02914034f, -0.05324513f, -0.07136313f, -0.07906659f, -0.06422073f, 0.00871019f, 
    -0.01615823f, -0.00834190f, 0.04849730f, -0.00986571f, 0.00549383f, 0.03081206f, -0.04424687f, 0.06338901f, 
    0.01342923f, -0.00508219f, -0.06040873f, -0.04788749f, -0.02466091f, 0.02668118f, -0.03123391f, 0.04498617f, 
    0.05682506f, -0.05605825f, 0.05247544f, -0.05603715f, 0.02986798f, 0.03913794f, 0.01071819f, -0.00692245f, 
    -0.03595626f, -0.00999134f, -0.07664156f, -0.00765509f, -0.00936882f, -0.00150914f, -0.02980736f, 0.04563159f, 
    0.04330751f, -0.05825517f, -0.04222582f, -0.03453469f, -0.05867245f, 0.00361601f, 0.05670408f, 0.05701561f, 
    -0.07733245f, -0.06320433f, 0.01708083f, -0.06415007f, -0.03442612f, 0.05388502f, -0.01202280f, -0.01230409f, 
    0.06868681f, 0.02875300f, -0.00407493f, -0.00769300f, 0.01203372f, 0.02282708f, -0.02770474f, -0.02862616f, 
    0.07744068f, -0.05647705f, 0.00078740f, 0.00889700f, -0.03755618f, -0.00395755f, 0.05362529f, -0.03075585f, 
    0.03568117f, -0.03809815f, 0.00118088f, 0.01555812f, -0.03826709f, 0.02781604f, -0.04613261f, -0.06193634f, 
    -0.05009254f, 0.01600900f, 0.06643619f, 0.03918388f, -0.07916348f, -0.02243876f, -0.02054469f, -0.01892991f, 
    -0.02236247f, 0.04089074f, 0.03317986f, -0.07606024f, -0.06013274f, 0.01473019f, 0.03203081f, -0.00979374f, 
    0.00700615f, -0.07508727f, 0.02563335f, 0.05216384f, -0.03773195f, -0.07095215f, -0.01882476f, 0.02295580f, 
    -0.02761661f, 0.03245645f, 0.03686493f, -0.02232998f, 0.01855038f, 0.01596669f, -0.05020858f, -0.06724167f, 
    -0.07236043f, 0.02106717f, -0.02457866f, -0.05552063f, 0.05708235f, 0.02365363f, 0.04273207f, -0.05186262f, 
    0.04078581f, 0.05881685f, 0.03885263f, 0.00848056f, 0.05576761f, 0.03017004f, 0.01046771f, 0.04110635f, 
    0.03720617f, -0.07442368f, -0.07190806f, 0.01396174f, 0.03984075f, 0.05141387f, 0.00526825f, -0.05667008f, 
    0.01082362f, 0.06181334f, 0.05771734f, -0.05038243f, -0.01784098f, 0.05979429f, -0.07237835f, -0.03968149f, 
    -0.07611626f, 0.04654196f, -0.02983991f, 0.06078127f, -0.06225219f, -0.06765714f, -0.05831079f, -0.03255921f, 
    -0.01853296f, -0.05681091f, 0.03802426f, -0.16309659f, -0.02757474f, -0.14033298f, -0.02350431f, -0.17081854f, 
    -0.04505959f, 0.16767314f, 0.16831356f, 0.13955703f, -0.03152137f, 0.17116161f, 0.10972247f, 0.00637537f, 
    -0.17759216f, 0.03928020f, -0.09309874f, -0.05793409f, 0.41103426f, 0.06656364f, 0.28871411f, 0.24661545f, 
    -0.08772719f, 0.00619232f, 0.09045354f, -0.23816514f, -0.10256348f, -0.14258991f, -0.03618190f, -0.11172568f, 
    0.06738730f, -0.04488382f, 0.13353465f, 0.16483417f, 0.03066081f, 0.19823255f, -0.20367996f, 0.06729303f, 
    0.05042847f, 0.09886082f, 0.15480885f, 0.00419962f, 0.13176776f, 0.10108028f, 0.01328947f, 0.18316709f, 
    0.49633688f, -0.03302721f, 0.05107352f, 0.21588579f, -0.11337509f, -0.03606864f, 0.24624558f, -0.07019570f, 
    -0.07895695f, 0.16194312f, 0.05330676f, 0.17655365f, -0.35365057f, 0.11481367f, 0.21853265f, -0.16353075f, 
    0.07826921f, 0.10514724f, 0.02889463f, -0.07764871f, -0.05034692f, -0.05076896f, -0.22392358f, -0.42019215f, 
    0.18675674f, 0.18331067f, -0.17019363f, -0.21098174f, 0.00518245f, 0.10728177f, 0.13439856f, 0.03769838f, 
    -0.12042448f, 0.12936781f, 0.03274576f, 0.07614117f, 0.19321351f, 0.32262504f, -0.25414822f, -0.10632927f, 
    0.06906179f, 0.07420574f, 0.21382493f, 0.12358759f, -0.00855914f, -0.16805300f, -0.13145155f, -0.13921215f, 
    -0.26134962f, -0.12563579f, -0.05019158f, -0.16668175f, 0.01313538f, -0.03719342f, -0.00464209f, -0.22028616f, 
    0.04325264f, 0.13831680f, 0.03731186f, 0.01554442f, -0.17969027f, 0.04818998f, -0.05462536f, 0.02028704f, 
    -0.02594386f, -0.01038418f, -0.21586734f, 0.10573597f, 0.09714837f, -0.06068907f, 0.10236441f, 0.10640505f, 
    -0.15758575f, 0.10552145f, -0.01871224f, -0.06025295f, -0.18426804f, 0.00993646f, -0.06144387f, -0.19343065f, 
    0.22357094f, 0.07321845f, 0.17490873f, 0.00533117f, 0.23457995f, 0.09375460f, -0.16236068f, 0.23169941f, 
    -0.04551857f, 0.06636266f, -0.06849405f, -0.04413316f, 0.13721897f, 0.06953345f, -0.09014080f, -0.00600460f, 
    -0.01007025f, 0.10846511f, -0.11069062f, -0.13288952f, 0.02926362f, -0.01271372f, 0.06389432f, 0.12948583f, 
    -0.01762301f, -0.07671818f, -0.04048978f, 0.02867253f, 0.27894628f, 0.08037786f, -0.07154262f, -0.22496782f, 
    -0.06228591f, 0.11549484f, 0.03832255f, 0.10194141f, 0.16815145f, 0.22747843f, 0.08500500f, 0.18736477f, 
    0.03635190f, -0.14709114f, 0.04193551f, -0.39456686f, -0.01990705f, 0.18850556f, 0.11222419f, 0.07275647f, 
    0.17392977f, 0.01992365f, -0.10258470f, -0.07448944f, -0.27869999f, 0.11715924f, 0.10505111f, 0.06363446f, 
    -0.08148661f, -0.01056768f, -0.10043714f, -0.04077702f, -0.06262648f, -0.04113286f, -0.06123174f, 0.03512710f, 
    0.01620653f, -0.03660711f, -0.06459560f, -0.00472754f, -0.01354222f, -0.04898313f, 0.03385076f, -0.01703898f, 
    -0.07649507f, -0.01752865f, -0.00241671f, -0.00327797f, -0.01113269f, -0.03828594f, -0.04507071f, 0.03207763f, 
    -0.06336154f, -0.01484267f, 0.00252764f, 0.05255368f, 0.05206161f, 0.01775643f, -0.02409541f, -0.05560749f, 
    -0.04762936f, -0.04447757f, -0.07877758f, 0.01647480f, -0.02871817f, -0.03700891f, 0.02969107f, 0.05156868f, 
    -0.01586565f, -0.03150526f, -0.07058487f, 0.04588832f, -0.06528758f, -0.03943393f, 0.01893998f, 0.03422427f, 
    -0.03976832f, -0.07686770f, -0.07402392f, -0.02916162f, -0.02746902f, -0.02946218f, -0.02545217f, -0.02573517f, 
    0.04678955f, -0.01472295f, 0.02757100f, -0.04720509f, 0.05177140f, 0.05839664f, 0.01825154f, -0.02271370f, 
    0.02359533f, -0.03972951f, -0.04751506f, 0.05844376f, -0.01571699f, 0.06220341f, -0.03417757f, 0.02772442f, 
    -0.08281869f, -0.05118657f, 0.04212595f, 0.02899080f, -0.01598866f, 0.03016581f, 0.04121759f, 0.05099731f, 
    0.04494771f, 0.05269339f, -0.06980518f, -0.05127677f, 0.00542128f, -0.03287122f, -0.02682975f, 0.04387954f, 
    -0.02517770f, 0.04499205f, -0.06855894f, -0.07277174f, 0.02722741f, -0.04375811f, -0.01738177f, -0.02215524f, 
    -0.07971028f, -0.01801549f, 0.02628046f, 0.00503804f, 0.03077438f, -0.05979982f, 0.00103845f, 0.00719068f, 
    0.04971765f, 0.02194957f, 0.05386528f, -0.00872763f, -0.01678851f, 0.04335184f, -0.00185709f, 0.00795989f, 
    -0.06006294f, -0.05823368f, 0.05224177f, -0.04292289f, -0.05907392f, -0.03633884f, -0.07462752f, -0.03888113f, 
    0.05332859f, 0.05667667f, -0.04548260f, 0.00846364f, -0.06471150f, 0.03986217f, 0.04001626f, 0.02062460f, 
    -0.03359550f, -0.05299802f, 0.06460043f, -0.04356810f, -0.03466828f, -0.05680700f, 0.00410039f, -0.04276441f, 
    0.00150042f, 0.02260163f, 0.04754566f, 0.00492440f, -0.01637881f, -0.04950472f, 0.05501254f, -0.05967011f, 
    -0.00569357f, -0.00233146f, -0.01385891f, 0.03013912f, -0.05638714f, 0.00837350f, 0.05879788f, 0.05514862f, 
    -0.07555453f, -0.05346294f, -0.05401390f, 0.03625736f, 0.05221723f, -0.02470169f, 0.06056460f, 0.01282712f, 
    0.00666256f, -0.02595665f, 0.01860419f, 0.06013531f, -0.03691967f, -0.04042848f, 0.02018838f, -0.02695031f, 
    0.02180097f, -0.06504360f, -0.06185789f, 0.01994166f, -0.01146602f, -0.01492548f, -0.03084643f, 0.03602657f, 
    0.02283982f, -0.06112838f, -0.00968887f, -0.04604051f, -0.06164100f, -0.04795289f, -0.04602607f, -0.07921102f, 
    0.03800132f, 0.03873221f, 0.01492531f, 0.01870277f, -0.06150734f, -0.04431047f, 0.00307745f, 0.01546121f, 
    0.03179868f, 0.06041059f, -0.07868148f, 0.02876728f, -0.05012548f, -0.05310641f, 0.02355143f, -0.06290726f, 
    -0.16082121f, -0.15272626f, -0.05871060f, -0.00140626f, 0.04185522f, 0.05641893f, -0.10895894f, -0.14665991f, 
    0.05527255f, 0.11867676f, 0.13985695f, -0.04788088f, 0.10256050f, -0.07900785f, 0.04547191f, 0.20180497f, 
    -0.03873315f, 0.29048017f, 0.25739282f, 0.21425118f, 0.23539913f, 0.03848192f, -0.01330511f, 0.22435924f, 
    0.00328920f, 0.14776476f, -0.23715140f, 0.12434164f, -0.16746543f, -0.06711239f, -0.13668460f, 0.03926379f, 
    -0.05183065f, -0.08193156f, -0.14744407f, 0.07289630f, -0.04628967f, 0.30938339f, 0.06918160f, -0.00247848f, 
    0.11200053f, -0.02524791f, 0.09130903f, -0.13117923f, 0.11762360f, 0.10766910f, 0.04768243f, -0.07452568f, 
    0.46060061f, 0.10661566f, 0.17121166f, 0.10277598f, -0.00193326f, -0.09276054f, 0.01388866f, 0.06297524f, 
    -0.00053129f, 0.07182036f, 0.05220499f, 0.07553858f, -0.08128177f, 0.06003909f, -0.21296246f, 0.12907054f, 
    -0.00091208f, 0.02367005f, -0.06571706f, -0.05742343f, 0.03725880f, -0.03738816f, -0.14746217f, -0.27663121f, 
    -0.13521576f, -0.47265673f, -0.35559770f, 0.22992973f, 0.04338536f, 0.10009848f, -0.00800075f, 0.14004242f, 
    0.04764144f, 0.03439643f, -0.01906743f, -0.04479691f, -0.26654670f, -0.02045291f, 0.23592903f, 0.16355288f, 
    0.15199499f, -0.12199582f, -0.00991983f, -0.02902984f, 0.09214079f, 0.00406793f, 0.04293565f, 0.10812108f, 
    0.05194541f, 0.12882139f, -0.10263231f, -0.07832347f, -0.06230613f, -0.04010912f, 0.04082662f, -0.05648636f, 
    -0.11919668f, -0.03009984f, -0.01335238f, 0.03934490f, 0.13149893f, 0.02209596f, 0.47234032f, -0.18384583f, 
    -0.05050183f, -0.09107260f, -0.27614492f, 0.04942514f, 0.05952739f, -0.09694692f, 0.05694090f, 0.02401582f, 
    0.10060943f, -0.23465253f, 0.01849441f, 0.20810178f, -0.01091343f, 0.00835682f, 0.10086908f, 0.02291412f, 
    0.09263958f, 0.21785463f, 0.07622630f, 0.08850460f, 0.01437600f, 0.32972664f, 0.28838697f, -0.19170095f, 
    -0.06080208f, 0.04733289f, 0.08167119f, 0.03341675f, 0.07071141f, 0.03799883f, 0.06619027f, -0.00773965f, 
    -0.21388303f, 0.01981352f, 0.02461247f, 0.11058487f, -0.02433079f, -0.04695851f, 0.00467058f, -0.09257891f, 
    0.10090441f, -0.00083412f, 0.01162679f, 0.08659725f, -0.12754148f, -0.13663608f, 0.07090332f, -0.18516430f, 
    -0.03885589f, -0.19417299f, -0.11488155f, -0.01662163f, 0.04660436f, -0.00917266f, 0.16710752f, -0.24879244f, 
    -0.25001577f, -0.30922282f, 0.00835006f, 0.11096162f, -0.08021295f, -0.04318995f, 0.03214222f, -0.01525073f, 
    0.00117523f, 0.04906330f, -0.00545584f, 0.08847487f, 0.12460866f, -0.19531789f, 0.38889873f, 0.11173559f, 
    0.14480934f, 0.01581207f, -0.14075468f, -0.08101309f, 0.02830575f, -0.00044852f, 0.03621802f, 0.05638388f, 
    -0.15225127f, 0.01795029f, -0.01912615f, -0.01173674f, 0.05690213f, 0.22907147f, -0.08429499f, -0.13575377f, 
    0.17409174f, 0.04704634f, 0.17462300f, 0.01758770f, -0.17725758f, 0.04614116f, -0.00529421f, 0.15806681f, 
    -0.10806941f, 0.04909318f, 0.21414533f, -0.03900125f, 0.24353136f, -0.03233621f, -0.02229621f, 0.20634219f, 
    -0.16357160f, -0.02001779f, -0.18720293f, -0.01844585f, -0.10746480f, -0.17021164f, -0.01500206f, 0.03396352f, 
    0.06086778f, 0.02448328f, -0.20766874f, 0.15152824f, 0.19155277f, -0.12781933f, -0.04954274f, 0.11182781f, 
    0.11192595f, 0.05544121f, -0.06221180f, 0.04556815f, 0.07989804f, -0.02700763f, 0.11157994f, -0.05459725f, 
    0.74639833f, 0.41524124f, -0.12922563f, -0.29634818f, 0.07895255f, -0.12424915f, -0.11291751f, 0.12882140f, 
    -0.16512279f, -0.13977528f, -0.05873058f, -0.03489898f, -0.12304709f, 0.06456778f, -0.26990044f, 0.24147888f, 
    -0.06048613f, 0.01388596f, 0.04680829f, 0.03406943f, 0.13350452f, 0.01691568f, -0.22448340f, -0.16885997f, 
    0.11901841f, -0.17440721f, -0.17764451f, 0.22025794f, 0.02021262f, 0.11807176f, -0.00160956f, 0.06547488f, 
    0.10627412f, 0.24486715f, -0.02276768f, -0.03532185f, -0.18674782f, 0.00012398f, 0.15065645f, 0.09140671f, 
    0.11561731f, -0.21447086f, -0.00014450f, -0.14494668f, -0.05165148f, 0.12983790f, 0.10329365f, 0.21115588f, 
    -0.04045746f, -0.01389637f, -0.06311941f, 0.12052190f, 0.26191670f, 0.18147032f, 0.21538368f, 0.01470620f, 
    0.00515340f, -0.10023637f, 0.01603030f, -0.00482335f, 0.09061842f, -0.14684483f, 0.42069802f, 0.32560173f, 
    -0.03974797f, -0.00259342f, 0.07345551f, -0.02376311f, -0.05192702f, 0.02852060f, -0.10159405f, -0.04702314f, 
    -0.01707236f, -0.17090218f, -0.04533519f, 0.05662554f, -0.02304313f, 0.01164701f, -0.02108090f, 0.15716013f, 
    -0.02305505f, -0.10548586f, -0.05947821f, 0.05124942f, -0.00900670f, 0.08133406f, 0.39118069f, 0.21850811f, 
    -0.01896067f, -0.01484712f, 0.08647343f, -0.02678289f, -0.02062888f, 0.11456462f, 0.11536352f, -0.08102582f, 
    0.06267304f, -0.11109591f, -0.00077403f, 0.08939479f, -0.06496397f, -0.08888124f, -0.04711130f, -0.05156628f, 
    -0.07600560f, -0.15151729f, 0.00338425f, -0.08356404f, 0.18896917f, 0.13985822f, 0.12628189f, -0.20821898f, 
    0.00501352f, -0.14933367f, -0.12845905f, -0.15903944f, 0.01074943f, -0.16922979f, 0.15137078f, -0.22785722f, 
    -0.59276956f, 0.09093610f, 0.08924643f, 0.16781262f, 0.11767967f, 0.07482102f, 0.02010600f, 0.14649993f, 
    0.06650483f, -0.05391670f, -0.00946562f, 0.00908166f, 0.10041723f, -0.15300147f, 0.06148840f, 0.03317384f, 
    -0.02344438f, 0.04852810f, 0.05987414f, 0.03905365f, 0.07843935f, -0.06414521f, 0.00333550f, -0.03167031f, 
    -0.08650917f, 0.16655029f, 0.01645010f, 0.08337711f, 0.06247168f, -0.00171808f, -0.03895254f, 0.02820079f, 
    -0.02249450f, -0.01659213f, -0.16872784f, -0.03407281f, 0.20284101f, 0.14860311f, -0.02806367f, 0.24902835f, 
    0.08761451f, 0.22476265f, -0.03728757f, 0.11529358f, -0.14259149f, -0.10756497f, 0.07840998f, 0.01774315f, 
    0.19813204f, 0.11841292f, -0.09556849f, 0.06327260f, -0.05362127f, -0.05155146f, -0.06155509f, 0.04971115f, 
    -0.06195342f, -0.04909840f, -0.00804447f, -0.07694453f, -0.21105662f, 0.07306253f, 0.19711381f, -0.00394303f, 
    -0.14956547f, 0.00215636f, 0.06143135f, -0.01960682f, -0.14141916f, 0.01015945f, 0.04768878f, 0.03693461f, 
    0.00213794f, -0.34332219f, 0.32140818f, -0.18257064f, -0.11458078f, 0.11375131f, -0.10518006f, 0.16970254f, 
    0.14575151f, 0.11941546f, 0.01620192f, 0.07766258f, 0.02602262f, 0.33452004f, -0.31747830f, -0.04769729f, 
    -0.02383888f, -0.14743876f, -0.07735721f, -0.04995509f, 0.00303071f, -0.03408340f, -0.12728660f, 0.18009187f, 
    -0.39776990f, 0.07107995f, -0.01128068f, 0.20598391f, -0.10873274f, -0.02543100f, -0.07671303f, 0.01939366f, 
    -0.06032129f, -0.06932224f, 0.02217628f, 0.02689728f, -0.12103918f, -0.13734458f, 0.32451323f, 0.29288736f, 
    -0.03070428f, -0.03002437f, 0.02303248f, 0.17957018f, 0.08840622f, 0.11018792f, -0.02821348f, 0.03944963f, 
    0.02987827f, 0.15113690f, -0.04707284f, -0.05379868f, -0.03646696f, -0.05246524f, -0.04793981f, -0.00326272f, 
    -0.15262197f, -0.13297592f, -0.05777804f, -0.05189563f, 0.27677134f, -0.00211972f, 0.20800221f, -0.25425759f, 
    -0.06929259f, -0.05487113f, 0.04874730f, -0.01817946f, -0.04316851f, -0.03477195f, 0.01892577f, -0.08971806f, 
    0.11526208f, 0.42590421f, 0.20901111f, 0.11795574f, 0.06083270f, 0.06044795f, 0.00579116f, 0.03224069f, 
    -0.12172691f, 0.29884914f, -0.22870564f, 0.02658586f, -0.01405796f, -0.02937643f, 0.12294561f, -0.16031541f, 
    0.01373469f, 0.13633372f, -0.00139730f, 0.16520749f, -0.03691165f, -0.25191170f, -0.12607400f, 0.02060902f, 
    -0.24245821f, -0.11845334f, 0.21102999f, 0.15062492f, -0.01330025f, 0.03868506f, -0.11907989f, -0.06314339f, 
    -0.02565299f, -0.02069259f, 0.09367605f, 0.13349301f, 0.07085666f, -0.22487167f, 0.13158426f, 0.04615483f, 
    -0.08892804f, -0.05290852f, 0.05523188f, -0.01024609f, -0.05104477f, 0.00712853f, 0.03864836f, 0.14228240f, 
    -0.28808522f, 0.52697408f, -0.03420543f, 0.16513678f, -0.14578266f, -0.16997683f, -0.04561646f, -0.09839858f, 
    -0.01751013f, 0.10839495f, 0.00863259f, 0.07138442f, 0.44287008f, -0.27704513f, 0.28559813f, -0.03945029f, 
    -0.13375433f, -0.00709027f, 0.10959969f, 0.01219460f, 0.01337526f, -0.01574807f, 0.08076680f, -0.13441530f, 
    0.13120662f, -0.07466336f, 0.14663696f, -0.20969228f, -0.17392808f, -0.01118381f, -0.01127127f, 0.05609431f, 
    -0.03615936f, 0.18268456f, -0.19978730f, 0.13216369f, 0.11223470f, -0.12510112f, 0.30233994f, -0.25900722f, 
    0.07527840f, 0.07874743f, -0.26596799f, 0.04490124f, -0.00262708f, 0.07995908f, 0.21394788f, -0.02534264f, 
    0.07050817f, 0.04597307f, 0.17019397f, -0.26491043f, -0.07412469f, -0.03653065f, 0.08563815f, -0.05393247f, 
    0.10937960f, 0.03135553f, 0.15072377f, 0.05187517f, -0.24126881f, -0.15840188f, 0.01423688f, 0.15329131f, 
    0.03237422f, 0.04302543f, -0.01337909f, 0.21256894f, 0.01293699f, -0.09453816f, -0.05093846f, 0.12910171f, 
    -0.64643705f, -0.06661697f, 0.30186775f, -0.09665694f, -0.02920809f, 0.13693248f, -0.16282037f, -0.00611772f, 
    0.18166760f, -0.09377088f, 0.13927270f, 0.11790308f, 0.20701137f, -0.06722052f, 0.17367920f, -0.33365542f, 
    0.03740967f, 0.03144307f, 0.05817710f, -0.05021955f, -0.01600470f, -0.11807682f, -0.06155685f, 0.00214868f, 
    0.13730057f, 0.04974323f, 0.05401345f, -0.01353820f, -0.03955346f, 0.01147377f, 0.04220596f, -0.04349593f, 
    -0.20962414f, 0.00082632f, 0.03776973f, 0.06195650f, 0.10388590f, -0.03897178f, 0.10780039f, -0.06854740f, 
    -0.06559230f, 0.07163522f, -0.12717459f, 0.04455541f, -0.01094076f, -0.08848861f, -0.00186106f, -0.04735151f, 
    0.06511272f, 0.00496775f, -0.05640152f, -0.15851922f, 0.14338934f, 0.07638220f, 0.10985800f, 0.14467090f, 
    -0.05526847f, 0.05459538f, -0.00960233f, 0.06653482f, -0.05859336f, 0.20230064f, -0.16376372f, 0.38046813f, 
    -0.05776285f, -0.05256436f, 0.07525727f, -0.04616172f, 0.02533220f, -0.02813697f, 0.03617840f, -0.12715101f, 
    0.08883043f, 0.26807901f, 0.28494734f, -0.38370198f, 0.14075489f, 0.04038611f, 0.07244772f, -0.03167521f, 
    0.06504453f, 0.16931745f, 0.01831267f, 0.13337541f, -0.18652159f, -0.25239497f, -0.06487132f, 0.06062905f, 
    0.12907945f, 0.05526786f, 0.00331936f, 0.01234098f, 0.05926855f, 0.01297377f, -0.07281129f, 0.10188052f, 
    -0.04787332f, -0.00517614f, 0.02733405f, 0.15263757f, -0.06921832f, -0.10364012f, 0.13245936f, 0.02873376f, 
    0.10816872f, 0.10744391f, 0.00524343f, 0.18321253f, -0.02120150f, -0.01261723f, 0.11854924f, 0.38416678f, 
    -0.12198134f, -0.07036781f, -0.02118714f, -0.06869704f, 0.00929026f, -0.01558155f, -0.14747928f, 0.22318715f, 
    0.67989498f, 0.09476365f, -0.07083520f, 0.19131978f, -0.11917427f, -0.11436123f, -0.12098373f, -0.06791653f, 
    0.05759124f, -0.07932350f, 0.05587014f, -0.00270211f, -0.35379606f, 0.65105021f, -0.39098299f, 0.05847284f, 
    -0.02665282f, -0.12712932f, 0.03170269f, -0.01333590f, 0.06867376f, -0.07564664f, -0.01617422f, 0.09058417f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02904345f, 0.08831595f, 0.16963212f, 0.03768829f, 0.05362745f, 0.05401902f, 0.16216530f, 0.11766452f, 
    0.18451636f, 0.25585249f, -0.01209777f, 0.13991125f, 0.14131214f, -0.04466389f, 0.09701119f, 0.14925940f, 
    -0.02147200f, 0.06232787f, 0.18772580f, 0.26638606f, 0.16036943f, 0.11488045f, 0.01041357f, 0.16503404f, 
    0.20101373f, 0.03300181f, -0.07295820f, -0.05553489f, -0.05206143f, 0.09705872f, 0.06077574f, -0.06522246f, 
    -0.10421504f, 0.02473292f, -0.04076428f, 0.04742118f, -0.03475656f, 0.12924699f, -0.03188948f, 0.25668791f, 
    0.05085581f, 0.02803249f, 0.09398679f, 0.01282263f, 0.13382579f, -0.00254156f, -0.05991775f, 0.04711004f, 
    0.13232951f, 0.05139992f, -0.05552424f, -0.16892667f, 0.10613667f, -0.06514893f, 0.11626199f, -0.07964455f, 
    -0.01860630f, -0.06935869f, 0.08770423f, -0.02648126f, 0.29757720f, 0.05286109f, 0.19947034f, 0.17205194f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03624531f, 0.02522004f, 0.03964783f, -0.18102776f, -0.19179395f, 0.23969859f, 0.07197429f, -0.18260191f, 
    -0.13632932f, -0.46475938f, -0.00434050f, -0.51990491f, -0.48935345f, 0.24089117f, -0.22121716f, -0.29728764f, 
    -0.12053896f, 0.19547012f, 0.20760269f, -0.47710326f, -0.08784240f, -0.19040614f, 0.11141702f, -0.30863324f, 
    -0.55482739f, -0.15466264f, 0.01441451f, 0.22214299f, -0.11632258f, 0.01353359f, -0.11250781f, -0.03966895f, 
    0.26340994f, -0.14972866f, -0.04239709f, -0.30981094f, 0.04904843f, 0.30810758f, -0.07036000f, -0.39278421f, 
    0.25019905f, -0.46092486f, -0.17246541f, -0.31691334f, -0.11545127f, -0.04094798f, -0.04049909f, -0.10585923f, 
    -0.39808464f, -0.14067586f, -0.05645357f, 0.28715003f, -0.12631831f, 0.17495827f, -0.13513917f, 0.31613770f, 
    0.06850506f, -0.08690747f, 0.09938189f, 0.05372969f, -0.64018947f, -0.43315336f, -0.18422082f, -0.07604701f, 
    -0.02895014f, 0.47448900f, -0.03577558f, -0.69189155f, 0.23968084f, -0.22327664f, 0.16502072f, 0.41985261f, 
    0.32816437f, 0.11403871f, -0.14350373f, -0.26825222f, -0.30633274f, 0.22718449f, -0.22696401f, 0.01988563f, 
    -0.05800869f, 0.16638459f, 0.32449684f, 0.23042610f, 0.10898259f, 0.18473911f, -0.06764013f, -0.20581153f, 
    0.28063625f, -0.06769877f, -0.02691635f, 0.01725712f, 0.00948949f, -0.20526977f, 0.27895358f, -0.05769715f, 
    0.12726244f, -0.17075202f, -0.06409451f, -0.02969910f, -0.20683616f, 0.29406205f, -0.05802156f, 0.02080673f, 
    0.16841722f, -0.32151243f, -0.09752150f, -0.02129604f, -0.08031825f, 0.06652928f, 0.01817588f, 0.04579997f, 
    0.07950874f, 0.02231983f, 0.02646981f, -0.42729589f, -0.29596177f, 0.06542497f, -0.01832741f, -0.60106295f, 
    -0.05951369f, 0.00423587f, 0.01981938f, -0.03702314f, 0.27114058f, -0.17539549f, 0.11726359f, -0.07983775f, 
    -0.12093499f, -0.85166401f, -0.27319318f, 0.21547525f, -0.59174758f, -0.65627998f, 0.26491264f, -0.65723181f, 
    0.16558494f, 0.06986044f, 0.20396280f, 0.12236682f, 0.05736224f, 0.08969481f, 0.27674103f, -0.03309892f, 
    0.05395022f, -0.22423796f, 0.18811412f, 0.28711849f, 0.16964245f, 0.22530662f, -0.11226713f, 0.17322454f, 
    0.32685477f, -0.04387556f, 0.11525027f, -0.16236915f, 0.11324207f, -0.50650835f, -0.45151368f, -0.01304881f, 
    0.06374554f, -0.05746316f, 0.00762274f, 0.07505152f, -0.04247277f, 0.25233787f, 0.08108316f, -0.01387589f, 
    -0.52083153f, -0.11625008f, -0.08516834f, -0.27603337f, 0.03381112f, -0.04971599f, -0.36049035f, -0.12327212f, 
    -0.01313647f, 0.02442126f, 0.04286190f, -0.11020558f, 0.07191809f, 0.28715956f, 0.16177067f, 0.13463089f, 
    0.11407673f, 0.07388349f, 0.12767686f, 0.02692895f, 0.35059434f, 0.04314888f, 0.07510721f, -0.22654137f, 
    0.08949374f, -0.08571874f, -0.01951775f, 0.08796443f, -0.12163068f, 0.08488569f, -0.32132444f, 0.21645378f, 
    0.07758772f, -0.18089503f, -0.07316051f, 0.30327636f, 0.03385655f, 0.06887662f, -0.35581031f, -0.06830446f, 
    -0.08779261f, 0.10164197f, -0.53852069f, -0.10837255f, -0.17573178f, -0.63445336f, 0.27652571f, 0.28267977f, 
    0.18699667f, -0.58935404f, -0.07164125f, -0.17576100f, 0.07615878f, -0.10228340f, -0.01214959f, -0.06738584f, 
    0.24182761f, 0.36047930f, -0.07059126f, 0.16295509f, -0.39429575f, -0.36779308f, 0.01087378f, -0.38232121f, 
    -0.04159896f, 0.19958884f, -0.54838359f, 0.04826155f, -0.23065692f, -0.03230961f, 0.16849163f, -0.10434117f, 
    -0.02914880f, 0.01337698f, -0.05554601f, 0.24430594f, -0.16010886f, 0.09894138f, -0.73038089f, 0.22790363f, 
    0.02315453f, -0.11211688f, 0.09102388f, 0.11377279f, -0.00263508f, 0.52346277f, -0.34510365f, -0.68548834f, 
    0.09118031f, -0.29182032f, 0.20144802f, 0.20432919f, 0.19779888f, -0.35592452f, -0.19567090f, -0.18525988f, 
    -0.47485805f, -0.58948350f, 0.10768128f, -0.64556855f, 0.10893890f, -0.13006714f, 0.14273556f, -0.00421594f, 
    0.09772664f, -0.07119175f, -0.05312592f, 0.06102821f, 0.04902427f, -0.02246520f, 0.06058019f, 0.14671086f, 
    -0.25498617f, -0.10150899f, 0.10858332f, 0.03800182f, -0.08000433f, -0.40270975f, -0.69800454f, -0.09810350f, 
    -0.07441708f, -0.43401071f, 0.01902370f, -0.34136388f, 0.06869304f, -0.33391267f, 0.06584665f, -0.33659133f, 
    0.14305361f, -0.36960155f, 0.15320177f, 0.04665645f, 0.11066115f, 0.02283592f, 0.11860082f, 0.02570656f, 
    0.23690791f, 0.24555811f, -0.06633735f, 0.12484645f, 0.15343431f, 0.25845826f, 0.03723429f, -0.08903094f, 
    -0.11068804f, 0.05450334f, -0.28328675f, 0.02710925f, -0.18928222f, 0.13288487f, 0.11485896f, 0.16884595f, 
    -0.02788573f, -0.53596032f, 0.17155921f, 0.11508855f, 0.12897794f, 0.28991824f, 0.23748383f, 0.31847319f, 
    -0.39612228f, -0.00881101f, -0.22726819f, 0.03438157f, -0.36423230f, -0.26800486f, 0.03653505f, 0.11519934f, 
    -0.10066204f, 0.16761310f, 0.12621225f, -0.39140368f, 0.23467165f, 0.13200745f, 0.10138284f, -0.40990779f, 
    -0.10729295f, -0.02378242f, -0.06528368f, 0.08918023f, -0.07712395f, 0.40294024f, -0.05949296f, -0.01027514f, 
    -0.24153106f, -0.20912848f, -0.00763567f, -0.28918436f, 0.03085042f, -0.17559376f, -0.02968574f, 0.39479664f, 
    0.11178201f, 0.25387701f, 0.27024266f, -0.17985515f, 0.13203648f, 0.01854408f, 0.12539297f, -0.02022278f, 
    -0.26374561f, 0.20985176f, -0.05903539f, -0.31806102f, 0.29278761f, -0.55092287f, -0.12892884f, -0.38239801f, 
    0.04549704f, 0.01556201f, 0.05484659f, -0.09611446f, 0.10021248f, 0.12458703f, -0.17806837f, -0.12792827f, 
    0.01111058f, -0.04769561f, 0.07957902f, 0.10422939f, -0.32820180f, -0.08133265f, -0.58228028f, -0.58379835f, 
    -0.46817589f, 0.32791948f, -0.17464606f, -0.05072416f, 0.34845984f, -0.01171562f, 0.24520016f, 0.01462935f, 
    -0.03962782f, -0.81659335f, -0.14448462f, 0.33635595f, -0.03191533f, -0.00748710f, 0.12084590f, 0.32175994f, 
    -0.32856560f, 0.27197802f, -0.01255751f, -0.09841289f, 0.03584711f, -0.20296517f, 0.35717070f, 0.00778637f, 
    -0.33483252f, 0.13807249f, 0.01084657f, 0.03415868f, 0.02023944f, -0.08949048f, 0.08576827f, 0.14069434f, 
    -0.66051579f, 0.03890307f, 0.19964053f, -0.49955347f, 0.13221058f, -0.01072977f, -0.70161176f, 0.03614304f, 
    0.28878140f, -0.72392696f, 0.00072524f, -0.29968402f, 0.07347285f, -0.37255549f, 0.28056833f, -0.05381967f, 
    0.07154181f, -0.07913830f, -0.28767094f, 0.10559501f, -0.15940800f, 0.06952152f, 0.18962148f, -0.17660318f, 
    -0.08467457f, 0.11175163f, -0.80234313f, 0.32751918f, 0.26599512f, -0.18432492f, -0.42251721f, -0.39076710f, 
    0.15437555f, -0.06600939f, 0.21980204f, 0.21337852f, -0.39041311f, -0.25388306f, 0.05324632f, 0.19314736f, 
    -0.04344613f, -0.54342818f, 0.02017303f, -0.35090825f, -0.11017270f, 0.04841474f, -0.33928281f, -0.48149750f, 
    0.19656724f, -0.23726763f, 0.01882618f, -0.20310742f, -0.10302202f, 0.16022782f, -0.03701118f, -0.01007299f, 
    -0.09144960f, -0.12750126f, 0.07812929f, 0.09730737f, 0.32758793f, -0.10450064f, 0.01251019f, -0.28574902f, 
    -0.14438854f, 0.11357199f, -0.21662326f, -0.00323515f, 0.09953780f, -0.03725058f, -0.11535419f, 0.09788069f, 
    -0.25117102f, 0.64014280f, -0.12700702f, 0.24223144f, 0.07208895f, -0.26957518f, 0.08092252f, 0.22929969f, 
    -0.04988121f, -0.01251984f, 0.03410318f, 0.10627314f, -0.22980866f, -0.32451248f, -0.15812431f, 0.20726435f, 
    0.03809772f, 0.03645066f, -0.71627980f, 0.17889507f, -0.05432822f, 0.38424727f, -0.18838459f, 0.10202269f, 
    0.31097484f, 0.09125940f, -0.16933495f, 0.08594206f, 0.09907208f, 0.13647704f, -0.33607730f, 0.25815901f, 
    -0.04462544f, -0.30251816f, 0.21445751f, -0.13847317f, -0.16496676f, -0.20229036f, 0.07831716f, 0.26555732f, 
    0.27129310f, -0.06826456f, -0.01412057f, -0.05497729f, -0.10427885f, 0.28040734f, -0.37222576f, -0.07717832f, 
    -0.18823829f, 0.22606118f, 0.11635080f, 0.25334668f, 0.17968202f, 0.16099584f, -0.03305890f, -0.06470441f, 
    -0.25516453f, -0.01013501f, -0.17815155f, 0.02256821f, 0.15300582f, 0.03221235f, -0.29423904f, 0.11515120f, 
    -0.52034903f, -0.59391558f, 0.10018198f, -0.49825376f, -0.53126836f, -0.28138572f, -0.46921450f, -0.13573043f, 
    -0.02775072f, 0.05720996f, 0.24442624f, 0.04750371f, 0.04765317f, 0.12518670f, -0.64980626f, 0.32818744f, 
    -0.06922326f, -0.06258080f, 0.13048375f, -0.36972165f, -0.44201759f, -0.59403861f, -0.38065022f, 0.00227147f, 
    0.05947255f, -0.18560135f, 0.15805876f, -0.07754741f, -0.24197848f, 0.09454021f, 0.31700617f, 0.06859381f, 
    -0.12140661f, 0.15227313f, -0.34975782f, 0.12505983f, -0.00408530f, 0.32706350f, -0.23461632f, -0.00656927f, 
    0.20045359f, 0.33762491f, -0.10024360f, 0.05112025f, -0.13639411f, -0.28249541f, 0.21222687f, 0.01115663f, 
    -0.54398710f, -0.58600932f, 0.00554907f, 0.24339761f, 0.28047946f, -0.23158804f, 0.00815188f, 0.30488601f, 
    0.05609849f, 0.12698673f, -0.07644448f, -0.37395263f, -0.34334046f, -0.01547283f, 0.25404677f, -0.11639038f, 
    0.24727747f, 0.09565355f, -0.05679895f, -0.05329787f, 0.22764647f, -0.45122719f, -0.06358322f, 0.08550805f, 
    -0.09955606f, 0.01944683f, -0.49432972f, -0.11493265f, -0.22386694f, -0.33138558f, -0.26994324f, 0.41656518f, 
    -0.04838485f, -0.33677247f, 0.33595160f, -0.37664291f, 0.03730203f, 0.02248093f, 0.22523764f, -0.38030362f, 
    0.21507406f, 0.09176753f, -0.26760778f, 0.25649440f, 0.35872400f, 0.20267498f, -0.37290737f, -0.44169694f, 
    -0.04892965f, 0.08467236f, 0.20107780f, -0.18427455f, -0.50975823f, -0.36157304f, 0.07650960f, 0.43141660f, 
    -0.28560942f, -0.50584388f, -0.06988473f, 0.12789719f, -0.06280757f, 0.11983991f, -0.16059175f, 0.01350608f, 
    -0.15716513f, 0.23857731f, 0.03365809f, -0.18050583f, -0.60966897f, -0.48117718f, -0.03187564f, 0.21872690f, 
    0.11191416f, -0.15327242f, -0.38460493f, 0.34245747f, 0.09341602f, -0.06897182f, -0.66138995f, 0.02304235f, 
    0.47141486f, -0.47275415f, -0.10050800f, -0.25943217f, -0.11846159f, -0.44137761f, 0.14226295f, -0.70469975f, 
    0.04182290f, -0.00288233f, 0.21896838f, 0.04386715f, -0.26991048f, -0.00268402f, 0.33239901f, 0.33772618f, 
    -0.02457057f, 0.30878818f, -0.03700169f, 0.19632681f, -0.24811815f, -0.33168402f, 0.38032702f, -0.08128826f, 
    -0.33498809f, 0.23369467f, -0.11821564f, 0.01411609f, 0.35378549f, -0.53884465f, -0.24215677f, 0.01431583f, 
    0.06859415f, -0.54020441f, -0.45172778f, -0.15075321f, 0.03904834f, 0.04918372f, 0.12288081f, -0.08404277f, 
    -0.22715059f, 0.28136101f, -0.01730456f, 0.05834701f, 0.10525433f, -0.02415866f, -0.21976094f, 0.07717407f, 
    0.13098544f, 0.31494635f, 0.07180756f, 0.12353100f, -0.32838231f, 0.35569432f, -0.09507138f, 0.22053820f, 
    -0.23734087f, 0.14757060f, 0.14296009f, 0.40316924f, -0.45661551f, 0.10457701f, 0.05562173f, 0.00172848f, 
    -0.28216174f, -0.55027843f, 0.00391395f, -0.21663356f, -0.10848136f, 0.33609983f, -0.25662294f, -0.22539051f, 
    -0.02009444f, -0.07613783f, -0.57565653f, -0.03502337f, 0.31177303f, 0.19467160f, 0.36560866f, -0.42141464f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26476046f, 0.10853411f, 0.19606780f, 0.03663734f, 0.08853967f, 0.02349094f, 0.11306763f, -0.15071771f, 
    0.00733169f, -0.04445330f, -0.05450170f, 0.05524889f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
