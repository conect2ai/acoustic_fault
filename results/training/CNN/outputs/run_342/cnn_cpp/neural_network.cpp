#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.71192545f, -1.93784368f, -0.11280750f, 0.71730918f, 0.47251523f, 0.87229580f, 0.77364451f, 0.66939569f, 
    0.62264562f, 0.31308141f, -0.54005265f, 0.32352728f, -0.24731246f, 0.60762131f, 0.10776651f, 0.11172140f, 
    -0.03247523f, 0.07317060f, 0.15781234f, 0.09714798f, -0.12346914f, -0.04184962f, -0.17421459f, -0.19108833f, 
    -0.16605136f, 1.31984520f, 0.94382805f, -0.29108042f, 0.27283660f, 0.15098605f, 0.47537610f, 0.56744832f, 
    0.86606961f, 1.31956887f, 0.76843482f, -0.25394973f, 0.17490441f, -0.31432545f, -0.70849699f, -0.06133023f, 
    -0.35262874f, -0.41152173f, -0.49924693f, -0.12967426f, 0.06580383f, 0.04490763f, -0.36401480f, -0.06958808f, 
    -0.26654142f, -0.33636364f, 1.18482137f, 0.04468859f, 1.19689190f, -0.01471356f, 0.84819371f, -0.22514747f, 
    -0.32436386f, 0.29332590f, 0.49784958f, -0.04568308f, -0.62402475f, -0.58503354f, -0.06708663f, 0.83581364f, 
    0.46180576f, 0.08987655f, 0.06580064f, 0.32972693f, 0.54702389f, 0.48451781f, -0.49062461f, -0.25081831f, 
    -0.35209203f, -0.17354862f, -0.05257382f, 0.60541034f, 1.15645909f, 1.30924976f, 0.74662310f, -0.04983509f, 
    -1.17036545f, 0.77184403f, -0.83407402f, -0.59214717f, 0.41471356f, 0.65234154f, 0.29127285f, -0.03202911f, 
    0.44664666f, 0.10559290f, 0.35849163f, 0.03667475f, -0.17131287f, 0.41255292f, -0.30839279f, 0.18367873f, 
    0.16999522f, -0.17147219f, 0.10527673f, -0.11046465f, -1.41632164f, -1.03538692f, 0.09470971f, 0.79754949f, 
    0.87550688f, 1.10535896f, 0.72791368f, -0.25140229f, 0.39112490f, -0.99773473f, 0.03740164f, 0.19065362f, 
    0.03017365f, 0.53236413f, 0.09377332f, 0.41620544f, 0.08801129f, 0.42197126f, -0.10903763f, 0.10813722f, 
    -0.15096422f, 0.05076003f, -0.17415240f, 0.12104579f, -0.16344270f, 1.51466870f, 1.09138811f, 0.13939290f, 
    -0.12072786f, 0.29174384f, 0.04454832f, -1.24606395f, 0.43494633f, -0.46397913f, 0.88612503f, 0.32114294f, 
    -0.00111889f, 0.02424731f, -0.08139398f, 0.10346039f, 0.32413492f, 0.01850475f, -0.22872584f, -0.11589433f, 
    0.27029634f, 0.28502467f, 0.57053417f, 0.20585050f, -0.12079235f, 0.18297818f, 0.68347740f, -0.08129208f, 
    -0.61290854f, 0.83811283f, 1.17877281f, 0.31694096f, -0.25357968f, 0.25496882f, 0.84963822f, -0.11462696f, 
    -0.25608724f, -0.47706777f, -0.42396110f, -0.20134085f, -0.24259095f, 0.53238487f, -0.11973616f, 0.31667244f, 
    -0.38701794f, -0.07463532f, 0.59101176f, 0.35296735f, 0.21433079f, 0.64138287f, 0.48872632f, 1.86929739f, 
    -0.54978746f, -1.46487164f, -0.80993801f, 0.31094748f, 0.55965817f, 0.02128489f, -0.34929442f, -0.24398004f, 
    -0.10453393f, -0.78047955f, -0.17362316f, 0.22873166f, 0.10442429f, 0.02927690f, -0.51310682f, -0.39977551f, 
    -0.52460068f, -0.19876970f, -0.09018001f, 0.12896897f, -0.03245050f, 0.00377081f, -0.13165319f, -0.10381781f, 
    -1.20228374f, -1.45401430f, -0.94577968f, -0.47668782f, -0.08377711f, 0.05047520f, 1.15985727f, 0.53868371f, 
    -0.16582961f, 0.91809607f, -0.31279895f, 0.02936923f, 0.48342851f, -0.05377122f, 0.03342779f, -0.43978536f, 
    -0.11202545f, 0.17234924f, 0.01778346f, -0.21351010f, -0.07995734f, 0.14360191f, -0.01648619f, 0.00535359f, 
    0.09128287f, 0.62797040f, -1.67821538f, 1.56919670f, 1.02256334f, -0.30664989f, 0.45002389f, -0.53951985f, 
    0.48049605f, -0.13056937f, -0.24236138f, -0.04454372f, -0.66848844f, -0.04051939f, -0.12852536f, 0.12359134f, 
    -0.15818861f, 0.00409169f, -0.06567889f, -0.14682002f, -0.13186038f, -0.39142662f, -0.10160644f, 0.23483545f, 
    0.25466886f, 0.17169489f, -0.42679375f, 1.37587869f, -0.52790958f, -0.97041667f, -1.30479276f, 1.24745929f, 
    0.76359195f, -1.19815290f, 0.52996522f, 0.48009044f, 0.14356643f, -0.07622440f, 0.08873139f, 0.24819940f, 
    -0.14730798f, -0.05592101f, 0.02623802f, 0.23050249f, 0.19052550f, -0.07450003f, -0.20978706f, -0.36158547f, 
    0.18071158f, -0.23821138f, -0.01386182f, -1.50071549f, -1.05464041f, -1.13111627f, -0.33002967f, -0.62711871f, 
    0.49954978f, -0.93146950f, -0.53191757f, 0.45844951f, -0.16163833f, 0.01357046f, 0.17078619f, 0.09899751f, 
    0.10784002f, -0.05795028f, 0.05253485f, 0.25276664f, -0.37390998f, -0.05317338f, 0.14047107f, -0.19955319f, 
    -0.04155188f, -0.08294272f, -0.17842692f, -0.29245299f, -1.21849263f, 0.54014307f, 1.06781530f, -1.25120854f, 
    1.17722511f, 0.57897371f, -0.52038515f, -1.08172250f, -0.85128111f, -0.88637483f, 0.29887837f, 0.40324408f, 
    0.39559695f, 0.05500978f, -0.48564500f, 0.01445999f, 0.15078026f, 0.19901708f, -0.05286179f, 0.36289710f, 
    -0.06607471f, -0.06991294f, -0.20574975f, 0.22405958f, 0.03445521f, -0.47939152f, -0.75576347f, -0.85168558f, 
    -0.69123304f, -0.96193010f, -0.37692562f, 0.53889281f, 0.71467489f, 0.72379595f, 0.00676736f, -0.80908692f, 
    -0.42348006f, 0.03045146f, -0.31156483f, -0.79803818f, 0.06292333f, 0.13352858f, 0.07866616f, -0.37974942f, 
    -0.02940614f, -0.03121260f, -0.13682584f, -0.11828439f, -0.10331466f, 0.31744775f, -0.11663093f, 0.39634103f, 
    -0.68998367f, -0.46163344f, 0.23694015f, -1.01314509f, -1.26261568f, -1.14483035f, -0.60061824f, -0.19798110f, 
    0.21445382f, -0.17858474f, 0.59576392f, 0.67489284f, -0.21686520f, -0.25516695f, -0.10653932f, -0.03080880f, 
    0.10779522f, -0.12731187f, 0.70336646f, -0.01957090f, 0.06289680f, 0.38623959f, 0.02663728f, 1.52531409f, 
    0.82241273f, 0.92101854f, 1.54121065f, 1.00752819f, 0.47086304f, 0.05503870f, -0.16797106f, -0.53444934f, 
    -0.31783798f, 0.12487487f, 0.07126214f, -0.03737147f, 0.16250797f, -0.17549406f, -0.23312588f, -0.10248567f, 
    0.43650949f, -0.10145350f, 0.09147888f, 0.05543280f, 0.00512195f, 0.15543245f, -0.21132356f, 0.11653340f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24186084f, 0.37811935f, -0.09006366f, 0.12735975f, 0.44299605f, 0.31469551f, 0.10379360f, 0.55148953f, 
    0.07095736f, 0.16117997f, 0.20466274f, 0.12171912f, 0.48843187f, -0.18403737f, 0.30219507f, 0.26780197f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04993575f, 0.05203571f, -0.26994574f, 0.24700715f, 0.01560721f, 0.14802425f, -0.09351049f, -0.19585860f, 
    0.01526406f, 0.06534868f, 0.13878225f, 0.01264751f, 0.02571560f, -0.01918926f, -0.00314903f, 0.02848539f, 
    -0.08913122f, -0.06694447f, 0.02959705f, -0.04500020f, -0.14822721f, 0.16807619f, -0.01372442f, 0.07516079f, 
    0.37173060f, 0.17787568f, -0.11073014f, -0.13970032f, -0.28988340f, -0.18488367f, 0.05919278f, 0.15312180f, 
    0.08672858f, -0.15715224f, -0.19923136f, -0.09031887f, 0.15482800f, 0.10719705f, -0.09195831f, 0.28075564f, 
    -0.23844908f, 0.00580128f, -0.01103121f, -0.05225100f, -0.09928263f, 0.03721660f, -0.02180437f, -0.18131186f, 
    -0.69253045f, -0.06110409f, -0.06051316f, 0.09297706f, 0.23608872f, 0.04210027f, 0.04810853f, 0.05202657f, 
    0.16353695f, -0.16865365f, 0.03440795f, -0.09277352f, 0.36035028f, -0.15233518f, 0.46598592f, -0.49080801f, 
    -0.10366352f, -0.12997185f, -0.13407551f, 0.26220107f, -0.02224990f, 0.00918409f, 0.08775362f, -0.00698528f, 
    0.00679510f, 0.42231753f, 0.21730697f, 0.39202374f, 0.11853649f, 0.05326653f, 0.09508177f, 0.04591092f, 
    0.06626602f, -0.00303210f, 0.06804442f, -0.12579176f, -0.07430150f, -0.66627175f, 0.51685578f, -0.40560168f, 
    -0.03123083f, -0.13179000f, 0.07961474f, 0.00932642f, -0.24568132f, 0.06511174f, -0.10124490f, -0.04626333f, 
    -0.12080584f, 0.18604958f, -0.06555932f, -0.50670862f, 0.13626903f, -0.02259136f, -0.04803499f, 0.06624036f, 
    -0.01315814f, 0.02793140f, -0.22966991f, 0.29398814f, 0.24820815f, -0.29011846f, -0.14133015f, 0.67914248f, 
    0.04501919f, 0.00631848f, 0.13052414f, -0.05719211f, -0.34893996f, -0.06532221f, -0.08194382f, -0.10165362f, 
    0.75797832f, -0.00009670f, -0.06642403f, -0.59412271f, 0.04373059f, -0.01187037f, 0.05521102f, -0.22590537f, 
    0.03741712f, -0.04653219f, -0.06590684f, 0.13311613f, 0.03150494f, -0.76823884f, -0.20822184f, 0.00719999f, 
    -0.00217559f, -0.02962989f, -0.01710360f, 0.02453449f, -0.11123606f, -0.27075332f, -0.06336319f, -0.08495700f, 
    -0.77486420f, 0.07457733f, 0.33401543f, -0.44994649f, -0.04899838f, 0.01830028f, -0.09689414f, -0.11793482f, 
    0.05215093f, -0.00615106f, -0.01200120f, -0.02001312f, 0.16498695f, 0.48512661f, -0.21096483f, -0.58606875f, 
    0.18424760f, 0.20982352f, 0.10236519f, 0.00753582f, 0.14917874f, 0.16431473f, 0.04311093f, 0.01873195f, 
    -0.12460500f, -0.12978211f, 0.47599676f, -0.07111773f, -0.07314645f, 0.04737679f, 0.18491395f, 0.14372350f, 
    -0.02090500f, 0.00487688f, -0.13152260f, 0.05614990f, 0.32247537f, 0.09709594f, -0.17612530f, 0.27237600f, 
    -0.57432634f, -0.15656678f, -0.07395097f, 0.10226330f, -0.21374623f, 0.03496477f, -0.11189541f, -0.14030750f, 
    0.86704296f, -0.33158824f, -0.14455512f, 0.03616163f, -0.01018471f, 0.21601608f, -0.10597184f, 0.03180768f, 
    0.19936980f, 0.05920295f, 0.14616627f, 0.05652975f, 0.39291546f, 0.09034556f, 0.32756147f, 0.19857304f, 
    0.05187119f, -0.15084991f, 0.00392512f, 0.01311648f, 0.01624550f, -0.16280532f, -0.16294523f, -0.14860067f, 
    0.25928849f, -0.10261452f, -0.15811056f, 0.09249467f, -0.06839165f, -0.12287155f, -0.09888002f, -0.05117683f, 
    -0.10976998f, -0.05166369f, -0.09732243f, 0.02121159f, 0.09186095f, 0.07324661f, -0.10301498f, -0.01068913f, 
    -0.06106099f, -0.10789926f, -0.05235089f, -0.05521557f, 0.20762940f, 0.12480207f, -0.06921449f, 0.04465896f, 
    0.12193333f, 0.25897801f, -0.52061403f, 0.02183982f, -0.01509003f, 0.17665020f, -0.11696603f, 0.01399338f, 
    -0.18619071f, 0.05480462f, -0.03018156f, 0.18905702f, 0.12867521f, 0.02723223f, 0.12774071f, 0.27109334f, 
    -0.12996225f, -0.15803440f, 0.18395415f, 0.01839470f, -0.04249686f, 0.01509890f, 0.01460102f, 0.17962751f, 
    0.04693147f, -0.19112618f, -0.00637284f, 0.14702314f, -0.20434493f, 0.03971168f, -0.28060707f, -0.05106937f, 
    0.14827551f, 0.30484545f, -0.03602352f, 0.04477481f, 0.38332623f, -0.60141659f, 0.26895887f, -0.76050413f, 
    -0.08364709f, -0.17899476f, -0.30761355f, -0.04967031f, -0.07877235f, -0.09732506f, -0.10377585f, -0.19371352f, 
    0.23465174f, 0.11450876f, -0.17080489f, -0.03544643f, 0.01545434f, -0.04810753f, 0.14082308f, 0.03353760f, 
    -0.06862921f, -0.09792418f, -0.04706883f, -0.05555489f, -0.78239226f, 0.22748892f, -0.04780173f, 0.08610526f, 
    -0.18613359f, 0.16091380f, 0.09883522f, -0.06887618f, 0.27287257f, 0.03351619f, 0.13094325f, -0.13013031f, 
    -0.69312119f, -0.33283895f, 0.17700586f, -0.26365370f, 0.16988239f, -0.13902646f, -0.05707075f, -0.00025308f, 
    -0.01514525f, 0.00920682f, 0.00461037f, -0.00634081f, -0.05963692f, 0.52327979f, 0.33453029f, -0.01575614f, 
    0.12550287f, -0.07084590f, 0.06904785f, -0.09596395f, 0.05624759f, 0.09339108f, -0.06876817f, 0.11605129f, 
    -0.01752333f, -0.21857361f, -0.11300530f, -0.45633796f, -0.17105211f, 0.04444836f, -0.04412836f, -0.08956303f, 
    0.13915601f, 0.15806255f, 0.03281641f, 0.01361350f, -0.42678711f, -0.23487194f, -0.05612027f, -0.44149339f, 
    0.16485266f, -0.25288370f, -0.29077122f, 0.15705021f, 0.01579942f, -0.13137132f, -0.01989709f, -0.09511422f, 
    -0.32844326f, -0.17923419f, -0.09946150f, -0.34477529f, -0.02473574f, -0.00246325f, 0.13962410f, 0.04762713f, 
    -0.04352210f, 0.05717509f, 0.07514460f, 0.00240288f, 0.32559803f, -0.08449590f, 0.19784254f, 0.56526285f, 
    -0.12828299f, -0.03705461f, 0.15140359f, 0.01333675f, -0.04719743f, -0.01538284f, 0.07643428f, -0.03102977f, 
    -0.13633648f, 0.11802219f, 0.09289426f, 0.16499028f, 0.07578411f, -0.04275970f, -0.00887618f, 0.26042119f, 
    -0.13208506f, -0.00419041f, 0.05074929f, 0.06187372f, 0.49574476f, 0.16818798f, -0.20565727f, 0.02397216f, 
    -0.00665750f, -0.02897123f, 0.29509777f, 0.08564836f, 0.01576789f, 0.06764185f, 0.28246370f, -0.11088539f, 
    -0.77421927f, 0.36146033f, -0.29943931f, -0.21923313f, 0.36078051f, 0.07739460f, 0.02333269f, -0.00065393f, 
    -0.20996389f, -0.12671909f, -0.21724224f, -0.03718248f, 0.29271439f, 0.21064173f, -0.26785594f, -0.00812024f, 
    0.02822351f, 0.25965741f, 0.15901017f, -0.18285343f, -0.05822020f, -0.01742645f, -0.21889418f, -0.07409216f, 
    0.49965107f, -0.72717333f, -0.17794760f, -0.02376440f, -0.05853955f, 0.09756643f, -0.27979061f, 0.11065769f, 
    -0.08922789f, -0.12773545f, -0.28572282f, -0.13359769f, -0.19184245f, 0.18079132f, 0.08832151f, -0.21600100f, 
    0.07270108f, -0.17003487f, 0.24163142f, 0.17285734f, -0.19279303f, -0.09288871f, 0.17765109f, 0.08735292f, 
    -0.03314272f, -0.07970400f, -0.07472060f, 0.03937677f, 0.05296742f, -0.34792644f, -0.03933687f, -0.00684171f, 
    0.06847700f, -0.11925769f, 0.06120991f, -0.14490283f, -0.54741228f, -0.35862836f, 0.00399809f, -0.46933135f, 
    -0.03795721f, -0.24609779f, 0.02019186f, -0.05028615f, 0.12005684f, 0.09589397f, -0.22505310f, 0.05478909f, 
    0.92778504f, -0.04778483f, 0.20647714f, 0.58750403f, -0.12863740f, -0.14041728f, -0.23345365f, 0.11220936f, 
    0.14889567f, 0.00038192f, -0.14010528f, 0.03157559f, -0.47031701f, 0.16312207f, -0.14426620f, -0.15470679f, 
    -0.10608161f, 0.19209504f, -0.25856531f, 0.00914469f, 0.18622178f, 0.00909582f, -0.02256018f, -0.38121215f, 
    0.46840271f, 0.08254366f, 0.08688168f, -0.21563068f, 0.07307193f, -0.10515144f, 0.16482855f, 0.00656730f, 
    -0.12752552f, -0.03897395f, 0.07356482f, -0.07073392f, 0.07171569f, -0.10727025f, -0.27579901f, 0.02353670f, 
    0.04290743f, -0.32649997f, -0.26932007f, 0.07775857f, -0.08959430f, 0.22942522f, 0.00734102f, 0.07613547f, 
    0.49301264f, -0.09918679f, -0.45603594f, 0.03664823f, 0.17471202f, -0.03153096f, 0.01127464f, -0.26582783f, 
    -0.19166514f, 0.05468047f, 0.01255573f, -0.23440973f, 0.21310107f, 0.07008016f, -0.21903084f, 0.62092662f, 
    -0.07596473f, -0.28365681f, 0.27256572f, 0.10112569f, 0.11279920f, 0.02508742f, -0.13263947f, -0.01724300f, 
    -0.66383684f, -0.27340338f, -0.17723641f, -0.68108159f, 0.32456875f, 0.08894587f, -0.16189162f, -0.15247257f, 
    -0.01018767f, 0.11422626f, -0.15638857f, -0.25481781f, -0.03888160f, 0.09827598f, 0.00096072f, -0.06491588f, 
    0.32545540f, 0.08593563f, -0.00612860f, -0.05654613f, 0.07619714f, 0.06833695f, -0.10042457f, 0.13852112f, 
    -0.15357928f, 0.10196712f, -0.35341260f, 0.04812210f, 0.02134089f, 0.06355540f, -0.03225303f, -0.36272478f, 
    0.13646853f, -0.02820368f, 0.06887098f, -0.06741504f, -0.41793314f, -0.33970150f, -0.38756195f, -0.15554152f, 
    -0.12621826f, -0.15397482f, -0.05719538f, 0.01746153f, -0.16988778f, 0.08075743f, 0.00034655f, 0.00614882f, 
    -0.26575956f, -0.32525134f, 0.06048246f, -0.06544352f, -0.06700540f, -0.01712914f, 0.30192155f, 0.05902493f, 
    -0.05214015f, -0.21604066f, 0.20818861f, 0.11656681f, -1.43317962f, 0.02780584f, 0.00691977f, 0.13107730f, 
    -0.05260106f, 0.08133791f, 0.13096258f, -0.00955848f, -0.30052641f, -0.07444396f, 0.09752063f, -0.18677172f, 
    0.06663152f, -0.31314170f, 0.16924475f, 0.39561504f, 0.19527830f, -0.15367626f, 0.08025638f, 0.03693092f, 
    -0.09426424f, 0.05459967f, -0.03873498f, -0.02723699f, 0.32219204f, -0.43928170f, -0.93772054f, 0.49296126f, 
    -0.16319746f, -0.03699713f, -0.08559348f, -0.04366753f, -0.05336858f, -0.05950721f, 0.07603271f, -0.11718882f, 
    -0.00278895f, -0.10035907f, -0.19739917f, -0.19616655f, -0.27707040f, -0.05728590f, 0.17485553f, -0.23446414f, 
    -0.14276263f, 0.10774776f, 0.10663030f, -0.19393475f, 0.23840721f, 0.33287662f, 0.22512114f, 0.33728603f, 
    0.23702778f, 0.03413510f, -0.01220316f, 0.16056283f, -0.10900056f, 0.20344694f, 0.13142698f, -0.02544952f, 
    0.23459142f, 0.13009815f, -0.07852747f, -0.21131586f, -0.10571974f, -0.29190680f, 0.06196722f, -0.05225645f, 
    -0.01080484f, 0.05543824f, -0.25651547f, -0.01274757f, 0.19725379f, -0.36524358f, -0.19081967f, -0.06002900f, 
    -0.05122672f, 0.16985734f, 0.01291616f, 0.13457528f, 0.02339021f, 0.12358598f, 0.01623052f, -0.03446706f, 
    0.48392102f, 0.27836317f, -0.07570715f, -0.15572546f, -0.13400279f, 0.02068683f, -0.13641620f, 0.30225807f, 
    -0.09256259f, -0.06592589f, -0.06827243f, 0.15122016f, 0.20941831f, -0.02274331f, -0.32804787f, -0.18521871f, 
    -0.21405122f, -0.18911780f, -0.09373907f, 0.17922680f, -0.04789092f, 0.03413028f, 0.03765214f, -0.05314862f, 
    0.71610093f, 0.01239142f, 0.28013772f, 0.11881435f, 0.31479624f, 0.08387617f, 0.11350123f, 0.16460659f, 
    -0.00038118f, -0.06449564f, -0.15877439f, -0.30092138f, -0.04935258f, -0.14562276f, -0.04219424f, -0.21103476f, 
    -0.13461506f, 0.06482289f, 0.04839238f, 0.15881231f, -0.15481043f, 0.25695163f, -0.05587390f, -0.03925098f, 
    0.26786762f, 0.41485772f, 0.30934927f, 0.09716684f, 0.04467208f, 0.10591032f, 0.05883234f, -0.07621260f, 
    0.24131553f, 0.02868078f, -0.01449402f, 0.03310613f, -0.53337181f, -1.09066296f, 0.13984220f, 0.15131676f, 
    -0.12107509f, 0.04363612f, -0.03422607f, -0.07597600f, 0.12248010f, -0.19813983f, 0.02333717f, -0.04820691f, 
    -0.82991087f, 0.60747486f, -0.07321046f, 0.15350650f, 0.09614484f, -0.05991824f, 0.08893827f, 0.06276607f, 
    -0.08160633f, 0.10499762f, -0.04458129f, 0.09625138f, -0.15101749f, -0.16644150f, 0.02675888f, 0.08253445f, 
    -0.04176401f, 0.20471565f, 0.22618258f, 0.08367263f, -0.15335998f, 0.10911158f, 0.19562620f, 0.13640130f, 
    0.00134251f, -0.04256768f, -0.12881576f, 0.14439619f, 0.32721397f, -0.00127562f, 0.19230428f, 0.05596447f, 
    0.06924844f, -0.02140878f, 0.24686994f, -0.13460413f, -1.09320343f, -0.14681570f, -0.00823103f, 0.13576831f, 
    0.01052199f, -0.10230743f, 0.17205456f, 0.08871729f, 0.16109999f, 0.10014974f, 0.03344511f, -0.16868617f, 
    -0.27397197f, 0.27831888f, -0.22517835f, -0.68576962f, 0.08727916f, -0.02919791f, 0.09815177f, -0.03243740f, 
    0.10258701f, 0.00938141f, 0.10326959f, 0.08178932f, -0.17570308f, -0.56928033f, -0.07134002f, 0.16886920f, 
    -0.39381430f, -0.13361098f, -0.16767386f, -0.31142238f, 0.16851242f, 0.00083297f, -0.24193157f, -0.22799885f, 
    0.62988758f, -0.15772134f, -0.23992690f, 0.11790303f, -0.11969139f, -0.13812633f, 0.12769580f, -0.08551308f, 
    -0.14621268f, -0.12763996f, -0.02822800f, 0.11754990f, 0.39605525f, 0.32419705f, -0.29655668f, 0.00913317f, 
    -0.03153547f, 0.00186766f, 0.06194115f, 0.07594053f, -0.08251175f, -0.14443143f, 0.10595358f, 0.06591725f, 
    -0.97826594f, 0.10150777f, -0.10426404f, 0.16367544f, -0.18783684f, -0.11970452f, 0.07050227f, 0.16231753f, 
    -0.11112574f, 0.07911721f, -0.08916882f, -0.00116088f, -0.21538058f, 0.40042111f, 0.14131406f, -0.56261623f, 
    -0.00853376f, -0.00459839f, 0.03309400f, -0.02412164f, -0.03856082f, -0.13599174f, -0.18396659f, 0.21063980f, 
    -0.26698092f, -0.04471397f, 0.13243690f, -0.01742600f, 0.10718848f, 0.06182273f, 0.05546930f, -0.02968329f, 
    -0.12367383f, 0.12442800f, -0.02719940f, 0.03460795f, 0.25877380f, -0.19261906f, 0.01184241f, 0.27143353f, 
    0.01990516f, 0.16561534f, 0.04789753f, 0.24194971f, 0.11373216f, -0.01973593f, 0.11922751f, 0.01045559f, 
    -0.38996345f, 0.46751541f, 0.06965847f, -0.22179094f, 0.15430756f, -0.05989864f, -0.11775142f, 0.02643382f, 
    -0.03381358f, 0.03420481f, 0.00346152f, -0.07551382f, -0.64993590f, -0.39711314f, 0.14718463f, 0.33837342f, 
    0.01582072f, -0.12621245f, -0.10502315f, 0.12289377f, -0.20642102f, 0.06588162f, 0.17124674f, 0.11885859f, 
    -0.14582923f, -0.18543611f, 0.09330846f, 0.32679251f, -0.13546410f, 0.14866911f, -0.00728719f, -0.09438802f, 
    0.15337138f, -0.03472025f, -0.03613039f, 0.01880304f, 0.42201501f, 0.25510570f, 0.01174931f, 0.05500617f, 
    0.07959240f, 0.10286581f, 0.01718299f, 0.01794191f, 0.01802228f, -0.12511443f, 0.00077068f, 0.00141322f, 
    -0.78859168f, 0.44145235f, 0.08338665f, -0.10409532f, 0.01798142f, -0.24425404f, -0.37821931f, -0.26254243f, 
    0.10931772f, -0.11058099f, -0.15687066f, 0.07446395f, 0.48073277f, 0.15485042f, 0.10647693f, -0.43307737f, 
    -0.05115533f, 0.01792107f, -0.45026395f, -0.16568905f, -0.10856145f, -0.12373325f, -0.22585282f, -0.04401874f, 
    0.30344450f, 0.12873493f, 0.43808961f, 0.07853922f, -0.11580300f, 0.22310476f, 0.00115432f, -0.14842081f, 
    -0.02016089f, 0.07489239f, 0.27191615f, 0.24475645f, 0.07641069f, -0.02895395f, 0.23386794f, -0.04555285f, 
    -0.06172283f, -0.04462823f, 0.07263233f, 0.08262763f, -0.06446494f, -0.14432724f, 0.01829846f, 0.36323893f, 
    -0.46006706f, 0.10894356f, 0.36468858f, -0.18549149f, -0.02961970f, 0.02733339f, 0.16212964f, -0.13468021f, 
    0.18387382f, -0.00324065f, 0.06999596f, 0.07273852f, -0.01912384f, 0.23593335f, -0.00402047f, 0.09406285f, 
    -0.02796519f, 0.15706494f, -0.06772169f, 0.02088715f, 0.04233802f, 0.10344734f, -0.15761174f, 0.02558590f, 
    0.06059745f, -0.00779836f, 0.13247393f, -0.36625382f, 0.01579559f, 0.28827301f, 0.20252329f, 0.14274560f, 
    0.22759993f, 0.07566597f, -0.00920449f, 0.13797203f, 0.08042175f, -0.31566110f, -0.01879002f, 0.11553098f, 
    -0.11756020f, 0.00732214f, -0.01742937f, 0.07106981f, 0.08339217f, 0.06854056f, 0.17771052f, -0.16346765f, 
    -0.91427004f, -0.18383956f, -0.55266917f, -0.30336887f, 0.18233775f, 0.02014823f, 0.00904343f, -0.04991119f, 
    0.07474473f, -0.00247235f, 0.24430922f, -0.13435400f, -0.30962452f, -0.04838890f, 0.11070228f, 0.29214004f, 
    -0.15434439f, -0.08470496f, 0.03107313f, 0.02610995f, -0.10236208f, -0.05184051f, -0.03918988f, -0.16366243f, 
    -0.21286030f, 0.01659388f, -0.32480183f, -0.11505510f, -0.14335965f, -0.03492560f, -0.02691062f, -0.09639177f, 
    -0.00739242f, -0.25102502f, 0.19830720f, -0.22960341f, -0.70126981f, -0.31905329f, -0.17894880f, 0.01498000f, 
    -0.08362225f, 0.17457826f, 0.06328801f, -0.21068265f, -0.06280480f, 0.17530052f, -0.16051398f, -0.07852723f, 
    -0.27620327f, -0.24969807f, 0.18190016f, 0.34274131f, -0.07981916f, 0.12409914f, 0.08100774f, 0.12335722f, 
    -0.11330079f, -0.02885340f, 0.12001631f, 0.15516351f, 0.53185904f, -0.04321110f, -0.52050292f, 0.07976615f, 
    0.14656779f, 0.25874019f, -0.04563920f, -0.17614627f, -0.09797711f, -0.21497174f, -0.13252029f, 0.06895713f, 
    0.08791333f, 0.14423729f, -0.03785718f, 0.43773994f, -0.19581586f, -0.25488371f, 0.02841708f, 0.10743239f, 
    -0.10051782f, 0.16724347f, 0.21911490f, 0.22432862f, -0.02501773f, -0.08804140f, 0.26617423f, 0.03277487f, 
    -0.12626295f, 0.07346793f, 0.02819032f, -0.01676542f, 0.01282514f, 0.00408166f, 0.09350034f, 0.16692448f, 
    0.04442319f, -0.56967038f, 0.23958418f, -0.10355863f, -0.10351072f, -0.04456292f, 0.14484067f, 0.20812523f, 
    -0.06025627f, -0.03003388f, -0.01333062f, -0.02790218f, -0.98026007f, 0.13655916f, 0.13606498f, 0.13859424f, 
    -0.28651854f, -0.19370988f, -0.01582837f, 0.09843878f, 0.07225651f, 0.08835331f, 0.26914972f, 0.23133242f, 
    -0.11971252f, 0.50061643f, 0.39374188f, 0.16193943f, -0.29097825f, -0.12761755f, 0.00978974f, 0.12554103f, 
    -0.12042049f, 0.04272782f, -0.26820180f, -0.17239180f, 0.07282104f, 0.17738308f, 0.33045128f, -0.33044270f, 
    0.04539432f, 0.06817409f, 0.14814204f, -0.00298341f, -0.08145434f, -0.06651084f, 0.05885977f, -0.13273476f, 
    0.30453798f, -0.39193285f, -0.12899677f, -0.09166288f, 0.01236038f, 0.19634630f, -0.10444076f, 0.05624010f, 
    0.06811117f, 0.21264297f, -0.24711595f, -0.29452413f, -0.27555394f, 0.26719606f, 0.09668687f, 0.01996077f, 
    -0.13473435f, 0.29722089f, -0.26144105f, 0.06945656f, -0.05273524f, -0.05516249f, 0.17894424f, -0.15114596f, 
    -0.34059253f, 0.08612964f, 0.26598543f, -0.39962086f, -0.12194350f, -0.09388666f, 0.04636014f, -0.20508321f, 
    -0.25670680f, -0.22605261f, -0.03107668f, -0.08055405f, -0.18604130f, -0.13496402f, -0.33915806f, -0.07961620f, 
    0.00555746f, 0.05797100f, 0.14588140f, -0.09852672f, 0.22388749f, -0.16189414f, 0.03520111f, 0.25633296f, 
    -0.03784578f, -0.69144148f, -0.16589089f, -0.32995519f, -0.02888709f, 0.19431403f, -0.02295820f, -0.25704250f, 
    -0.08592045f, -0.03708467f, -0.01162674f, 0.40369025f, 0.53035599f, -0.68918723f, 0.05730660f, -0.42153588f, 
    0.22215948f, 0.21267419f, 0.06760154f, 0.14518943f, 0.05852352f, -0.04705306f, 0.05883792f, 0.05301464f, 
    0.19158161f, -0.08729542f, -0.03970699f, 0.73592913f, -0.03468675f, 0.32873628f, 0.03744145f, 0.13881807f, 
    -0.09399424f, 0.19901317f, -0.17529997f, 0.05688640f, -0.21738064f, 0.13359129f, -0.07814957f, -0.45645148f, 
    -0.01390733f, -0.02958040f, -0.09383171f, -0.08183208f, 0.19777441f, 0.21357018f, 0.10378148f, 0.16474599f, 
    0.41011256f, -0.10798903f, 0.06620140f, 0.04731048f, -0.15415640f, 0.09758577f, 0.07940406f, 0.04309480f, 
    0.16033365f, -0.07649591f, -0.26606229f, 0.15724893f, -0.20139924f, -0.27987519f, -0.28296095f, -0.22108336f, 
    -0.12778269f, -0.15218066f, 0.08793925f, -0.15584269f, 0.24797438f, 0.06942447f, 0.11876108f, 0.14699705f, 
    -0.26902521f, 0.03507074f, -0.02695854f, 0.06583207f, 0.11889333f, -0.00346738f, -0.32028100f, -0.01000888f, 
    -0.21365131f, -0.04364529f, -0.15515874f, -0.08278903f, 0.18212172f, 0.18695875f, 0.32741380f, -0.58482212f, 
    -0.28722969f, -0.02485778f, -0.15304042f, 0.05747131f, 0.07281425f, -0.05265812f, 0.01140055f, 0.08553050f, 
    -0.11972199f, -0.21554476f, -0.05616456f, -0.17949042f, -0.25715509f, 0.23259532f, 0.06387857f, -0.05099606f, 
    -0.15709347f, 0.07234108f, -0.16770171f, -0.15999241f, -0.25189269f, 0.09231343f, -0.09366149f, -0.08632997f, 
    0.06451563f, 0.06443983f, -0.11373393f, -0.08860993f, 0.07175648f, -0.00346289f, -0.07802305f, -0.07134231f, 
    0.11300447f, -0.05631511f, -0.06694730f, -0.00623044f, -0.12809055f, 0.02175256f, 0.09816947f, -0.09960800f, 
    -0.09554613f, -0.03486414f, 0.04300503f, 0.10840118f, 0.37118781f, -0.67838317f, -0.26055312f, -0.38639110f, 
    0.03519270f, -0.02070979f, -0.01983656f, -0.09375834f, -0.00001325f, -0.08350997f, -0.02387693f, 0.04508345f, 
    -0.26906797f, -0.00956025f, 0.43873742f, -0.47073340f, -0.08302826f, 0.06719396f, 0.00700291f, -0.20871310f, 
    -0.08651331f, 0.11253529f, 0.00854879f, -0.18290138f, -1.09703612f, 0.12639467f, -0.39962721f, -0.45240822f, 
    0.03807779f, -0.04720822f, -0.04224781f, 0.01456235f, -0.21379733f, 0.02622867f, 0.04465023f, -0.16612317f, 
    0.32865736f, 0.30985281f, -0.01869444f, -0.06972597f, 0.10757729f, 0.04319032f, -0.19074990f, -0.15918922f, 
    -0.12657201f, -0.06915472f, 0.02719394f, -0.09123973f, 0.08074027f, 0.03962779f, -0.28585142f, 0.40129936f, 
    -0.28016621f, 0.18217672f, -0.04065726f, -0.09568933f, -0.23379014f, 0.01447565f, -0.02758300f, -0.10104240f, 
    0.07041002f, 0.10707009f, 0.35230097f, 0.15731835f, 0.11159267f, 0.14390823f, 0.04652676f, -0.03809324f, 
    -0.06426563f, 0.16620800f, -0.02749264f, -0.01529211f, 0.51224101f, 0.16590536f, 0.14032649f, -0.05366981f, 
    -0.12780385f, -0.10910267f, -0.11310329f, -0.09815444f, -0.16974775f, 0.02384702f, -0.11880963f, -0.14761274f, 
    -0.50305289f, 0.42718324f, -0.25435871f, 0.46379572f, 0.17904116f, -0.17685218f, -0.03572509f, 0.18476146f, 
    0.04531530f, 0.17279671f, -0.01533335f, -0.05623654f, 0.03234629f, 0.48824230f, 0.04729664f, 0.32128268f, 
    0.18623826f, 0.13417971f, 0.10181788f, 0.01584050f, -0.05288728f, -0.12100201f, -0.04837979f, -0.20446818f, 
    0.12322495f, -0.04344841f, 0.10446502f, 0.54102397f, -0.10765076f, -0.25415415f, -0.04005041f, 0.00046708f, 
    0.04230683f, -0.02933643f, 0.06666692f, -0.13634279f, 0.15712564f, 0.29293942f, 0.31429949f, 0.39232954f, 
    0.19903633f, 0.07030285f, 0.22687207f, -0.09046209f, -0.07933446f, 0.19044937f, -0.08470520f, -0.03563549f, 
    0.03058317f, 0.19823648f, -0.18611926f, 0.20536919f, -0.01647848f, -0.37699020f, -0.31843728f, 0.06306030f, 
    0.00253708f, -0.05834385f, 0.11239907f, -0.11436694f, -0.65942585f, 0.01633955f, -0.17295392f, -0.27118391f, 
    -0.00155297f, -0.01153815f, 0.08940900f, -0.15713480f, -0.06714403f, 0.03591420f, -0.03859478f, 0.06951954f, 
    0.30536377f, 0.21809031f, 0.37037185f, 0.03418797f, -0.16956443f, -0.22707191f, -0.10340115f, 0.05529156f, 
    -0.15554821f, -0.01776648f, -0.01333357f, -0.15506867f, 0.35422102f, 0.04705170f, -0.14271614f, 0.24035531f, 
    0.07348862f, -0.01732181f, -0.19407345f, -0.13501097f, -0.23767641f, 0.08220468f, -0.33594999f, 0.00439231f, 
    -0.13269672f, -0.33922324f, -0.01661352f, 0.12395861f, 0.22631148f, 0.07614331f, -0.36999321f, -0.18790455f, 
    -0.00035687f, 0.27509382f, 0.32340473f, -0.21459663f, 0.10034739f, 0.05432300f, -0.72363079f, 0.03182055f, 
    0.19722715f, -0.12284119f, 0.12970264f, 0.01092992f, 0.11070798f, 0.22149840f, 0.23483221f, 0.09398672f, 
    -0.25188977f, -0.35772401f, 0.29075193f, 0.08355961f, -0.23414090f, -0.16276841f, -0.00543421f, -0.15381430f, 
    -0.10005529f, 0.13042864f, -0.12195257f, 0.10720766f, 0.01172414f, 0.00630041f, -0.26615357f, 0.01532798f, 
    0.08696176f, 0.05415212f, -0.09854383f, -0.04369846f, 0.11447945f, 0.09958998f, -0.04935035f, 0.17567161f, 
    0.09937349f, -0.24752448f, 0.18681455f, 0.05111685f, -0.14809927f, 0.11780934f, 0.07438718f, 0.29321623f, 
    0.07798099f, 0.05340897f, -0.07324915f, 0.27082783f, -0.39031684f, 0.42430934f, -0.25081223f, -0.22488506f, 
    -0.17659128f, 0.06411007f, -0.17639701f, -0.01630281f, 0.17967992f, 0.12298689f, -0.10143768f, -0.18146092f, 
    -0.25031653f, -0.06828216f, 0.49933252f, -0.00441567f, -0.17389952f, 0.02548027f, -0.23970102f, -0.15659627f, 
    0.15961994f, -0.08506230f, 0.03963678f, -0.22008730f, -0.30148730f, 0.36969429f, 0.12125874f, -0.13705167f, 
    0.14596622f, -0.24403189f, -0.11481592f, -0.20126133f, 0.19598347f, -0.05220522f, -0.13387723f, 0.15782928f, 
    0.36805147f, 0.40545401f, -0.46391127f, -0.07800914f, -0.12043419f, 0.06656587f, -0.15557759f, -0.05827059f, 
    0.12345254f, -0.18653579f, 0.23205844f, 0.19650787f, -0.43534902f, -0.11388092f, 0.53024662f, -0.25546813f, 
    -0.07794791f, -0.22097979f, -0.17795618f, -0.20766751f, 0.01327860f, 0.07738407f, 0.04906668f, 0.01691272f, 
    -0.09803706f, -0.31175426f, -0.31567207f, -0.33706021f, -0.11933614f, -0.06514847f, -0.11622760f, -0.01141992f, 
    0.09747665f, 0.06505932f, 0.03695804f, 0.00359974f, -0.25397903f, -0.18952763f, 0.36185947f, -0.20031287f, 
    -0.21109226f, 0.07041448f, -0.05453900f, -0.09559280f, 0.01631592f, -0.35056618f, -0.19249079f, 0.03413032f, 
    -0.11444160f, 0.21133889f, -0.27503011f, -0.56256747f, -0.21779770f, -0.22448032f, -0.07474899f, 0.00133641f, 
    0.08733704f, -0.06199133f, 0.28737652f, -0.11360329f, 0.11755520f, 0.15225485f, 0.03875572f, 0.52220631f, 
    0.19115280f, 0.07293020f, -0.06916624f, -0.09131583f, 0.11039186f, -0.09649902f, 0.23109719f, -0.13271640f, 
    0.32954362f, -0.15722884f, -0.10155026f, -0.25984704f, 0.16251470f, 0.14391935f, 0.14938796f, 0.17388964f, 
    -0.09425221f, -0.12703669f, 0.08173532f, 0.13613358f, -0.39412421f, 0.12332414f, 0.07929855f, 0.00058241f, 
    0.10567408f, 0.18133138f, -0.03418595f, 0.07562235f, 0.29083356f, 0.15013868f, 0.03716269f, 0.04919428f, 
    0.16593455f, -0.14014548f, -0.06034751f, -0.05932298f, 0.02535846f, 0.18869387f, 0.20487194f, -0.01519848f, 
    0.03498552f, -0.05181753f, -0.08387940f, 0.16779201f, -0.15153101f, -0.07575826f, 0.35226932f, -0.06252966f, 
    -0.05670633f, -0.22258246f, -0.26964363f, -0.00532919f, 0.13699509f, 0.00714689f, -0.07089430f, -0.08024313f, 
    0.37026644f, 0.30203649f, -0.25907615f, 0.66873151f, 0.04008348f, -0.16690455f, 0.04693465f, -0.01072500f, 
    0.09912466f, -0.10118015f, -0.05744679f, 0.15100619f, 0.10275345f, 0.10464285f, 0.12677030f, -0.17948744f, 
    0.05009297f, 0.15910406f, 0.28785604f, -0.24323402f, -0.16285141f, -0.28052166f, 0.06908125f, -0.07297352f, 
    -0.48455742f, 0.27480048f, -0.20695525f, -0.04974364f, 0.09949280f, 0.00460526f, -0.25702718f, -0.27613750f, 
    -0.21692583f, -0.01696219f, 0.05972168f, -0.04115497f, -0.66421801f, 0.80360550f, -0.13526416f, 0.48370230f, 
    0.14333032f, 0.17562149f, -0.09587578f, 0.17016536f, -0.02739740f, 0.08073649f, 0.09303649f, 0.08653960f, 
    -0.07959598f, -0.45551181f, 0.18177533f, -0.13250051f, -0.06935408f, 0.01968586f, -0.08378837f, 0.10510346f, 
    0.06020287f, 0.22544137f, 0.01992107f, -0.01462202f, 0.72970957f, 0.11713406f, -0.17441551f, -0.43142641f, 
    0.09674405f, 0.00868959f, -0.12426608f, -0.07491504f, -0.21536157f, -0.13544668f, 0.06597260f, 0.31936070f, 
    -0.61877745f, -0.13238695f, 0.62590981f, -0.14106701f, 0.03197674f, 0.02982080f, 0.03457575f, 0.16036592f, 
    0.10576646f, 0.03415095f, 0.05872750f, 0.11560168f, -0.81740081f, -0.53727108f, -0.28220373f, 0.26427212f, 
    0.08147901f, -0.05236768f, -0.05228893f, 0.18961586f, -0.20917718f, -0.20935614f, 0.03882465f, -0.05463331f, 
    -0.16030827f, -0.00804799f, -0.31889048f, -0.60858959f, 0.09372514f, -0.36193871f, -0.04313961f, 0.10538077f, 
    -0.00914333f, -0.22956908f, 0.11337300f, -0.17297618f, 0.35677454f, 0.16986054f, -0.05453510f, 0.03892829f, 
    0.12227087f, 0.04821303f, -0.05916313f, 0.18737207f, -0.11972459f, 0.23160219f, 0.02995181f, 0.12122630f, 
    -0.21771555f, -0.43063039f, 0.16595189f, -0.23048937f, 0.00890122f, -0.00262886f, 0.07192083f, -0.09185049f, 
    0.01736241f, -0.14559288f, -0.31246912f, 0.01630895f, -0.67950410f, 0.24753386f, -0.42358375f, -0.56079036f, 
    0.21082826f, -0.14957885f, 0.19717802f, -0.02617957f, 0.00735061f, -0.11999509f, -0.22032808f, -0.10948782f, 
    0.09182982f, -0.06555215f, 0.04536580f, -0.02237612f, -0.14526074f, -0.07663013f, -0.01515041f, -0.02101021f, 
    -0.02245139f, 0.08584529f, -0.00087462f, -0.03554067f, -0.30740082f, -0.51419371f, -0.34325415f, -0.22615980f, 
    0.08462886f, 0.14511578f, 0.03743629f, -0.22569099f, -0.00683657f, -0.17084038f, -0.24116245f, 0.03542812f, 
    -1.50027919f, -0.41304201f, -0.05067747f, -0.43089074f, 0.16696405f, -0.02353483f, -0.13467790f, -0.12672573f, 
    -0.02068302f, 0.38333270f, 0.10997111f, -0.21022633f, -0.11658086f, -0.02630537f, 0.09408217f, -0.04226088f, 
    -0.02163064f, 0.19416247f, -0.15631348f, 0.09915311f, -0.04529458f, 0.06910250f, -0.15136230f, 0.10591038f, 
    0.41745758f, 0.21015844f, -0.17653863f, 0.20672888f, -0.06419029f, 0.01849481f, -0.10132895f, 0.21619576f, 
    0.00134067f, -0.20702684f, 0.13709120f, -0.02058336f, -1.11193478f, -0.23100604f, 0.07682265f, 0.15054040f, 
    0.30954832f, 0.06678591f, 0.22345489f, -0.04345506f, 0.04643111f, 0.08114105f, -0.03169648f, 0.23822434f, 
    -0.13312580f, -0.74546677f, -0.17871214f, -0.13655178f, 0.18250652f, -0.00405806f, 0.08321981f, 0.41190934f, 
    0.36774269f, 0.12020598f, 0.18226825f, 0.30147299f, -0.36435154f, -0.33695340f, 0.14441417f, 0.14164516f, 
    -0.07083712f, 0.09555663f, 0.17733353f, 0.10711955f, 0.19452648f, 0.02787421f, -0.21198577f, -0.16636565f, 
    0.35059643f, 0.18196487f, -0.14840296f, 0.09117144f, -0.30959561f, -0.01393203f, 0.11324608f, 0.00914742f, 
    -0.02517257f, 0.06971463f, 0.05691265f, -0.22613943f, -0.59233636f, -0.03765541f, 0.19209814f, 0.36061859f, 
    -0.05160471f, -0.06948364f, 0.01823823f, 0.08999295f, 0.09206213f, 0.10926750f, -0.02281908f, 0.06666557f, 
    -0.56537062f, -0.09840476f, -0.35113794f, 0.11916944f, 0.06366560f, -0.33650696f, -0.00807385f, -0.15725674f, 
    -0.03271649f, -0.09030580f, 0.20420995f, -0.17626338f, 0.31340313f, 0.06689210f, -0.10202132f, -0.12661274f, 
    0.09425119f, -0.19121145f, 0.21765476f, -0.11582766f, 0.02038175f, -0.07524251f, 0.01512793f, 0.01882531f, 
    0.18752606f, 0.34508696f, -0.10770459f, -0.32530400f, 0.13950680f, 0.06807220f, 0.06086624f, 0.17445679f, 
    0.30277345f, 0.19822714f, 0.28650782f, 0.25655836f, 0.29642746f, -0.26736912f, 0.14649630f, -0.09691408f, 
    -0.28069320f, -0.04669722f, -0.11223549f, -0.17298344f, -0.05141134f, -0.26008338f, -0.04764547f, -0.15441923f, 
    0.59157157f, 0.05272694f, -0.05269599f, -0.09989496f, 0.36994252f, 0.32599282f, 0.19256005f, 0.01016571f, 
    0.04311163f, 0.16120601f, 0.09652784f, -0.12586214f, -1.16252637f, -0.15943468f, -0.31664401f, -0.71069932f, 
    -0.12024048f, -0.17407277f, -0.09244346f, 0.00366897f, -0.03755328f, 0.29284000f, 0.15543346f, -0.02413062f, 
    -0.32792753f, -0.36050302f, -0.02311073f, -0.09730751f, -0.08726593f, 0.01787098f, 0.13801956f, 0.00188030f, 
    -0.08250006f, -0.00960220f, -0.07710326f, -0.05778439f, -0.61576933f, -0.26684219f, -0.24113554f, -0.32765764f, 
    0.06213086f, 0.20368153f, 0.29128534f, 0.29188794f, 0.07071020f, -0.03689586f, 0.21629970f, 0.15908764f, 
    -0.08917768f, -0.25409770f, -0.28821695f, -0.06436287f, -0.10602545f, -0.20238675f, -0.10872645f, 0.35049206f, 
    0.03442115f, -0.29935566f, -0.16205928f, 0.01133971f, 0.89701754f, -0.02625856f, -0.38798437f, 0.03398672f, 
    0.07117038f, -0.06209362f, 0.01416382f, -0.00830347f, -0.23753728f, 0.13195051f, 0.14026943f, 0.11567751f, 
    0.18711965f, 0.02129651f, 0.14526725f, -0.00566298f, -0.08900159f, -0.02002398f, -0.04975104f, 0.02096105f, 
    -0.13596942f, -0.06582236f, 0.07062604f, 0.02274967f, 0.82192153f, 0.20482109f, -0.17702273f, -0.15348786f, 
    0.14787851f, -0.15117513f, -0.17752023f, 0.19274271f, -0.03067306f, 0.18269010f, 0.11995587f, -0.13083805f, 
    0.05647875f, 0.02286660f, 0.02541871f, 0.04209229f, 0.24979587f, -0.06025741f, 0.01304734f, -0.02241064f, 
    -0.14664237f, -0.16812770f, -0.14601280f, -0.23251480f, 0.12883633f, 0.06638949f, -0.30037928f, 0.27663583f, 
    0.04382050f, -0.32173243f, -0.05376716f, -0.24468243f, 0.12058173f, 0.08868963f, 0.04786797f, 0.09393153f, 
    -0.08225604f, 0.01273507f, -0.12828326f, 0.14549282f, 0.04705608f, 0.15445589f, 0.19909228f, -0.06137934f, 
    0.18684560f, -0.15401687f, 0.04314993f, -0.21879046f, -0.24669279f, -0.14227650f, 0.08275800f, -0.34903350f, 
    0.17970820f, -0.15668592f, 0.01317545f, 0.25965992f, 0.01874871f, 0.01214640f, 0.05518256f, 0.22962569f, 
    0.29727942f, -0.52827096f, -0.32763287f, 0.17016137f, -0.22976507f, 0.17385055f, -0.16385134f, -0.01257245f, 
    0.18638298f, 0.08306491f, -0.16272128f, 0.07048423f, 0.71853781f, -0.05541495f, -0.10067205f, -0.41230065f, 
    -0.12167528f, 0.14943090f, -0.02176579f, -0.28174216f, 0.01335564f, -0.23163582f, 0.06246926f, -0.11217854f, 
    -0.22442348f, -0.21966703f, 0.08172264f, 0.86111170f, 0.01036606f, 0.06067167f, 0.14396383f, 0.00080310f, 
    -0.04636462f, -0.11899311f, -0.14710672f, -0.04998704f, -0.41008508f, 0.25098267f, 0.20107199f, -0.00496541f, 
    -0.20658094f, -0.01026956f, -0.11148626f, -0.25457022f, 0.03710544f, 0.06076111f, 0.12540692f, -0.31476143f, 
    0.32479924f, -0.04529068f, -0.44263059f, 0.12266260f, 0.16131975f, 0.10028034f, -0.13244928f, 0.03265265f, 
    0.20570186f, -0.08288763f, -0.11998641f, 0.10414862f, 0.43604979f, -0.34229344f, -0.24850090f, -0.39173445f, 
    0.06380517f, 0.02230294f, -0.09696420f, -0.02000795f, -0.00008086f, 0.15818472f, -0.16681726f, -0.20348583f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19872157f, 0.07857496f, -0.15959027f, -0.01133347f, 0.08157438f, 0.04978841f, 0.02802033f, -0.08581816f, 
    0.02080187f, 0.05462710f, 0.30463278f, 0.12321849f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
