#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49055207f, 0.45971802f, 0.58893973f, -0.08612244f, 0.59633899f, 0.99288237f, -0.16044819f, -0.27403647f, 
    -0.39990741f, 0.18312110f, 0.65319538f, -0.51274610f, 0.11060325f, -0.28868040f, -0.34754893f, -0.41504607f, 
    -0.18969387f, -0.10470732f, -0.07016791f, -0.36412749f, 0.24777004f, 0.55959147f, -0.11251818f, 0.17664330f, 
    -0.27984679f, 1.36130595f, 0.35766831f, -1.59591293f, 1.09867728f, -0.52767587f, -0.21908897f, 0.37427476f, 
    0.08260252f, 0.41091406f, -0.10108133f, 0.19459347f, -0.12746473f, 0.26028562f, 0.05123523f, -0.32413033f, 
    0.24570845f, 0.29385835f, -0.06274046f, -0.22734144f, -0.18377371f, 0.11961617f, 0.19787918f, -0.03462631f, 
    0.10202603f, -0.02713179f, 0.98647684f, 0.58569711f, 0.92079401f, 0.98053032f, 0.66585010f, -0.11550492f, 
    0.76369035f, -0.29841426f, -0.03412601f, 0.51770395f, 0.53804946f, 0.25673783f, -0.05940650f, 0.15345928f, 
    -0.20916893f, 0.03985446f, -0.46181709f, -0.37336707f, 0.07525891f, -0.51751322f, -0.04043915f, -0.00391451f, 
    -0.09112465f, -0.09826843f, -0.18670894f, -0.61666352f, -0.72023910f, -0.51515228f, -0.65806949f, -0.79145974f, 
    0.31934968f, -0.13505052f, -0.42538223f, -0.29919598f, -0.11441331f, 0.59247404f, 0.20735095f, -0.40242842f, 
    0.24374235f, 0.02274923f, 0.13111658f, -0.17424768f, -0.32975540f, 0.24710819f, 0.57510287f, 0.22251302f, 
    0.07064772f, -0.22062503f, 0.15596339f, 0.21081693f, -0.60008377f, -0.53063446f, -0.54228038f, -0.35483003f, 
    0.41146716f, -0.07584271f, -0.97134280f, 0.10241686f, 0.15767159f, 0.24937288f, 0.49615696f, -0.16440742f, 
    0.44106779f, 0.36617622f, -0.32592869f, 0.13900967f, 0.35647714f, 0.39146659f, 0.66180426f, 0.03939329f, 
    0.25908506f, -0.05460430f, -0.42291322f, -0.29190421f, 0.15377572f, 0.64712721f, 0.78472513f, 1.18823016f, 
    -0.73634118f, -1.05589950f, 0.84280783f, -0.50720668f, 0.18512569f, -0.43621585f, -0.19371317f, 0.61127722f, 
    0.54378802f, -0.05422267f, 0.30508223f, 0.11795803f, -0.04725383f, -0.29024971f, -0.07686971f, 0.25917521f, 
    -0.15819068f, 0.07572478f, 0.12306238f, 0.01686685f, 0.12188382f, 0.13710575f, 1.03483284f, 0.97186261f, 
    0.99568439f, 0.61466330f, 0.39318100f, 0.51387012f, -0.26220879f, -0.12278952f, -0.15285888f, 0.19972688f, 
    -0.14589080f, -0.42421761f, -0.22265549f, 0.22844307f, 0.61930430f, 0.19193347f, 0.18651785f, 0.12371548f, 
    -0.24230610f, 0.27561149f, -0.11595581f, 0.40974772f, -0.01913485f, 0.35990837f, 0.35535130f, 0.71110147f, 
    0.25103393f, 0.59926569f, 0.07309493f, 0.40343466f, -1.05994260f, -0.70612663f, -0.72752917f, -0.72784126f, 
    0.44321188f, -0.25278109f, 0.83665872f, -0.11466253f, 0.34782273f, -0.25221610f, -0.16633084f, 0.14701143f, 
    0.06456383f, -0.01431012f, 0.09439476f, -0.13102838f, 0.16528086f, 0.06106796f, -0.20531352f, -0.18780831f, 
    0.35808557f, -0.72836393f, 0.80938107f, 1.10218608f, 0.90336263f, 0.97371620f, 1.20028067f, 0.57601303f, 
    0.44987324f, 0.50322634f, -0.41313437f, 0.62703544f, -0.16168541f, 0.48725891f, 0.02140191f, 0.13898267f, 
    -0.08014628f, 0.01863574f, -0.11903188f, -0.21260779f, 0.05626264f, 0.13996485f, -0.01409952f, 0.15819661f, 
    -0.29121399f, -0.91364163f, -0.45875385f, -0.36663815f, -0.32669941f, 0.15470371f, -1.26866615f, -0.57653618f, 
    -0.36540565f, -0.56297857f, -0.05504147f, -0.09966072f, 0.30157605f, 0.29599720f, -0.36421874f, -0.63788211f, 
    0.28616932f, -0.08809606f, -0.12322451f, -0.45153201f, -0.34639344f, 0.03287946f, -0.03154214f, 0.19067164f, 
    0.22795418f, -0.22753413f, 1.27419543f, 0.54370940f, -0.26683569f, -0.94514680f, -0.35427958f, -0.50387686f, 
    -0.62009341f, 0.02866092f, 0.51185244f, -0.23243320f, -0.47420549f, 0.02721911f, 0.43386191f, -0.35349798f, 
    0.11721867f, 0.14593172f, -0.21691273f, 0.29961738f, 0.03592018f, 0.16898155f, -0.33320865f, 0.05933153f, 
    -0.29615232f, 0.05340783f, -0.09629020f, -0.85635978f, -0.97297728f, -0.82085812f, -0.36452994f, -0.48318431f, 
    0.12599848f, 0.50521970f, 0.25580224f, 0.43714088f, 0.68714452f, 0.14961632f, -0.00834795f, 0.38951033f, 
    0.05752607f, -0.56679153f, -0.12089714f, -0.52867794f, 0.17896500f, -0.69228631f, -0.09108509f, -0.05375822f, 
    -0.39818388f, 0.12387635f, -0.19661894f, 0.15249440f, 0.88732237f, 0.75208455f, 1.00188732f, 0.90327120f, 
    0.70485479f, -0.41994196f, 0.00143846f, -0.58296067f, -0.84397560f, 0.19239099f, 0.50196528f, 0.29288340f, 
    -0.01188526f, 0.43356153f, -0.00323492f, 0.27271810f, -0.02228616f, 0.20996314f, 0.21759082f, 0.23676378f, 
    0.07578801f, -0.08130300f, 0.13107647f, 0.27631542f, 0.48180774f, -0.79261428f, -0.87363559f, -0.76426566f, 
    0.40879229f, 0.41584367f, -1.18462098f, 0.97286749f, 0.87769377f, -0.59972161f, 0.55026245f, -0.32905057f, 
    0.05663803f, 0.06249205f, -0.12380827f, 0.15873630f, -0.17699289f, 0.39080232f, -0.10662133f, 0.10616542f, 
    -0.15868255f, 0.58365470f, 0.11573240f, -0.13672741f, 0.20978348f, 0.17857645f, -0.30148554f, 0.86985070f, 
    1.11957014f, 0.18461832f, 0.08546653f, 0.86109418f, -0.06456346f, -1.01734710f, -0.09785017f, -0.08512948f, 
    -0.33695751f, 0.20527905f, -0.26844501f, -0.18905242f, -0.50380230f, -0.17787921f, 0.23650381f, 0.12568246f, 
    -0.42628658f, -0.32054746f, -0.04678039f, -0.20894118f, -0.30961433f, -0.09775955f, -0.35055697f, -0.54340404f, 
    -0.46037295f, -0.20492840f, 0.53277445f, -1.11897171f, -0.24122360f, 0.00839263f, 0.24783915f, -0.48737299f, 
    -0.83322495f, -0.38208041f, 0.24937597f, -0.05147200f, -0.25264758f, 0.33738476f, -0.72889519f, -0.24982294f, 
    0.37835878f, -0.16857590f, -0.63764733f, 0.43259075f, 0.04515594f, -0.00354873f, 0.60142750f, 0.15974972f, 
    0.54179096f, -0.91341072f, -1.20776391f, -0.50753415f, -0.59264904f, -0.91397357f, 0.62985909f, 0.41447374f, 
    -0.58817953f, 0.40734512f, 0.42102355f, 0.36836201f, 0.41429543f, -0.37317085f, 0.66782975f, 0.15764603f, 
    -0.14765942f, -0.20213716f, -0.06733885f, -0.00129720f, -0.09854197f, -0.10605588f, -0.05356400f, -0.14563768f, 
    0.07010254f, 1.26121259f, -1.46874654f, 0.38118792f, -0.85031044f, 0.32401761f, 0.98916507f, 0.04088288f, 
    0.69172490f, 0.00804634f, -0.23060884f, 0.27300328f, 0.42542467f, -0.35039583f, 0.14331630f, -0.13615732f, 
    0.00275756f, -0.11834042f, 0.14583395f, 0.16067263f, 0.13472790f, -0.09525919f, -0.02460247f, 0.17953521f, 
    0.12993568f, 0.26570588f, -0.60379630f, -0.22512415f, -0.59318411f, -0.51091611f, -0.19936508f, -0.53410274f, 
    -0.26456174f, -0.69950396f, -0.31204230f, 0.26736605f, 0.68466014f, -0.45723215f, 0.28740034f, 0.12358703f, 
    0.08362845f, -0.03991373f, 0.75528985f, 0.17566022f, -0.10715014f, 0.76169884f, -0.61334735f, 0.25285590f, 
    -0.01209542f, 0.27633923f, 0.31040615f, -0.00995564f, -0.27250478f, 0.69113642f, 0.51457405f, -0.16782519f, 
    -1.04393804f, -0.93392676f, -0.72197431f, -0.59524429f, -0.45728123f, 0.59219164f, 0.45554727f, 0.41351467f, 
    -0.00597305f, -0.09192035f, -0.39472210f, 0.28066513f, -0.13332704f, 0.12613703f, 0.17080940f, 0.24144073f, 
    -0.11956901f, -0.27208057f, -0.01122619f, 0.40172315f, 0.40316227f, -0.41533333f, -0.80158055f, -0.93872571f, 
    -0.24213822f, -0.31191349f, 0.71750283f, -0.09398530f, 0.50525337f, 0.65115589f, 0.03372680f, -0.38661385f, 
    -0.28820017f, -0.53150451f, -0.40440977f, -0.01275369f, 0.56005412f, -0.16012219f, 0.11925517f, -0.14725380f, 
    0.12577054f, -0.01585571f, -0.05734690f, -0.50482947f, -0.41386792f, -0.88898897f, 0.18393882f, -0.32419139f, 
    -0.06523941f, 0.82535827f, 1.09193480f, -0.28923687f, -0.64367223f, 0.44096020f, -0.57072991f, 0.15645717f, 
    0.17861341f, 0.15103988f, 0.46867082f, 0.28036138f, -0.35012159f, -0.52629125f, -0.06175176f, -0.59655493f, 
    0.41093147f, 0.51320845f, -0.21260564f, -0.20468101f, -0.10460591f, -0.26212487f, -1.04398608f, -1.43543053f, 
    -0.58547324f, 0.75425053f, 0.54234242f, 0.42326981f, 0.88396770f, 0.26002535f, 0.33623075f, -0.18381192f, 
    0.28876394f, 0.00514873f, -0.03998617f, 0.21241890f, 0.21493930f, -0.10819803f, 0.20903227f, 0.05027720f, 
    -0.32716140f, 0.10899556f, -0.15449199f, -0.10923685f, 0.09688699f, -0.23844318f, -0.02761833f, -0.73317319f, 
    -0.25065744f, -1.01809776f, -0.75325662f, -0.38430178f, 0.15033232f, 0.78777945f, 0.52097106f, 0.14767399f, 
    0.68153435f, -0.52055955f, -0.54220235f, 0.15850739f, -0.24441144f, -0.31123701f, -0.32012710f, 0.14349791f, 
    0.08594801f, 0.27473402f, -0.23291002f, -0.12779932f, -0.07046495f, -0.17571536f, 0.03848562f, 0.43184987f, 
    -0.77251440f, 0.62421328f, 1.23417878f, 0.63929963f, -0.59678030f, -0.47163984f, -0.34822839f, 0.28772587f, 
    -0.10090073f, 0.22665124f, -0.16649152f, 0.20213050f, 0.17979054f, 0.26873678f, -0.08722968f, 0.29945174f, 
    0.01442784f, 0.01060393f, 0.19168566f, 0.21781456f, 0.13953906f, -0.05930224f, 0.32633367f, -0.23994182f, 
    -0.70639670f, -0.31045419f, 0.99594241f, -0.19327420f, -1.08846927f, 0.22620389f, -0.13629676f, 0.78227568f, 
    0.56826019f, -0.74682200f, -0.11577958f, -0.40318066f, -0.32802862f, 0.32838902f, -0.16052970f, 0.55593586f, 
    0.40705755f, 0.18314199f, 0.32877028f, 0.40615842f, -0.24394718f, -0.30769739f, -0.02021692f, -0.17644216f, 
    -0.63016486f, 0.04977007f, 0.11228362f, 0.82299048f, 0.62819034f, 0.17907789f, 0.47790372f, -0.96822798f, 
    0.05384967f, 0.35930881f, 0.43112454f, -0.87354261f, 0.04576283f, -0.05923454f, -0.64481384f, 0.11968435f, 
    -0.07398180f, -0.36989120f, -0.30382454f, 0.25089958f, 0.12908882f, 0.27760705f, 0.50984102f, 0.27590179f, 
    0.25765777f, 0.28851339f, 0.38762960f, -0.38225737f, 0.09033053f, -0.71211523f, -0.86808842f, 0.30953559f, 
    -0.65987259f, -0.52205378f, 0.31121996f, -0.42153874f, 0.48089528f, -0.48553184f, -0.58526754f, 0.21043463f, 
    -0.25717667f, 0.10069358f, 0.24160156f, -0.13165329f, -0.41308230f, 0.24742360f, 0.56343490f, 0.38449433f, 
    0.30871004f, 0.39158317f, 0.12804754f, 0.20525931f, -0.33398533f, -0.31657848f, 0.51965672f, -0.58448792f, 
    0.93285716f, -0.94609118f, 0.16856045f, 0.25381336f, -0.88129735f, -0.82270741f, 0.17234081f, -0.12285953f, 
    0.17977326f, 0.48609120f, -0.19929941f, 0.45028037f, -0.67141843f, -0.40049285f, -0.02046960f, 0.13987625f, 
    -0.33828020f, 0.26315063f, 0.29339394f, 0.31258652f, 0.36708170f, -0.64956880f, -0.01591683f, -0.15927501f, 
    0.25270671f, 0.09815404f, 0.12847036f, 0.13324836f, 0.53752208f, -0.54327524f, -0.15911089f, -0.36680466f, 
    -0.37164354f, 0.57313848f, 0.38909668f, -0.20333740f, -0.48134127f, -0.49636722f, 0.51244766f, -0.47777435f, 
    0.55281693f, 0.84512019f, 0.28818166f, -0.07636417f, 0.09411132f, -0.38820294f, 0.52150154f, 0.25960433f, 
    0.26695809f, 1.54580331f, 0.65526938f, 0.32589898f, 0.02120302f, 0.16808499f, 0.33938023f, 0.15555081f, 
    -0.63774294f, -0.33032024f, -0.30507863f, 0.36752865f, -0.45369878f, -0.40177032f, -0.43295869f, 0.33786973f, 
    0.11351443f, -0.20310052f, 0.09852741f, -0.34792849f, -0.64004147f, -0.11941074f, -0.21189417f, 0.96495908f, 
    1.03485024f, -0.78358620f, -0.69545239f, -0.60902774f, 1.22133636f, 0.25970557f, 0.00333529f, 0.59971333f, 
    0.55786866f, -0.26948619f, -0.30161154f, -0.24796753f, 0.21918751f, -0.39186940f, 0.17216577f, -0.03965233f, 
    -0.13938518f, -0.07595245f, 0.08531465f, -0.11564223f, -0.07342929f, -0.29711217f, -0.09507275f, 0.17566469f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07589903f, 0.37371045f, 0.29631820f, 0.41665173f, 0.32738307f, 0.11233080f, 0.25261796f, 0.29473084f, 
    0.15105197f, 0.12112393f, 0.20248611f, -0.05498089f, 0.24937372f, 0.34865910f, 0.19975087f, 0.16862448f, 
    0.22491963f, 0.12165431f, 0.32099763f, 0.18230082f, 0.14272180f, 0.32346800f, 0.39241585f, -0.15780917f, 
    0.09145042f, 0.21758083f, 0.28882796f, 0.26290584f, 0.34429866f, 0.21930100f, 0.19180891f, 0.08365111f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.16830349f, -0.13136940f, 0.30387065f, -0.08830298f, -0.15499131f, -0.03227226f, -0.05109971f, -0.28444642f, 
    -0.13509618f, 0.11957731f, 0.21149288f, 0.12066817f, -0.19228292f, 0.11209072f, 0.07111172f, 0.27363470f, 
    -0.09255720f, 0.19878358f, 0.02884829f, 0.00441715f, -0.15560246f, 0.04371935f, 0.07689475f, 0.11800679f, 
    0.25123113f, -0.00192201f, -0.13305950f, 0.25043309f, -0.22341208f, -0.13731343f, -0.07695061f, 0.07453418f, 
    -0.06825396f, 0.17184678f, 0.02176628f, -0.06906277f, -0.28003296f, -0.17571454f, -0.17038020f, -0.22478107f, 
    -0.17644954f, 0.04361585f, 0.22778027f, -0.02970922f, 0.13884434f, -0.09759801f, 0.07823481f, 0.02266510f, 
    0.11296127f, -0.30161470f, 0.12504172f, -0.03234641f, 0.12192439f, 0.07137264f, 0.05768116f, -0.01544190f, 
    0.10111504f, 0.06413610f, -0.03791611f, -0.18409845f, -0.63939089f, 0.20465398f, 0.12834050f, -0.01949142f, 
    -0.03578783f, -0.08376045f, 0.17291738f, -0.22932935f, 0.00835467f, -0.02331432f, 0.07395644f, 0.13686834f, 
    0.16516040f, -0.12156212f, -0.10703000f, -0.00658201f, -0.30481446f, -0.10491402f, 0.11213093f, 0.11254863f, 
    0.02845578f, 0.06220346f, -0.21963520f, 0.01739254f, 0.26825902f, -0.11481550f, 0.18334380f, -0.18081576f, 
    -0.21324688f, -0.02813575f, 0.02980614f, 0.06713825f, -0.16372558f, 0.01407405f, -0.18631721f, 0.07797528f, 
    -0.15809432f, 0.05754790f, -0.09702881f, 0.31718335f, -0.11575265f, 0.02044318f, 0.04493196f, -0.01273981f, 
    0.01019238f, 0.07234740f, 0.19198473f, -0.15142046f, -0.27954656f, -0.45105574f, 0.00267713f, 0.31538743f, 
    -0.06607519f, -0.04695442f, -0.00693861f, -0.03911843f, 0.05684952f, 0.16214542f, 0.04890992f, -0.08905318f, 
    0.11090463f, 0.06053928f, 0.15632668f, -0.43726036f, -0.01517399f, 0.00524705f, -0.04261948f, 0.06692450f, 
    -0.00218154f, 0.01195964f, 0.03482504f, 0.00825852f, 0.21324256f, 0.41909960f, -0.19470392f, -0.28200519f, 
    0.02639197f, 0.09969740f, -0.10788343f, 0.14981338f, -0.06055620f, 0.15823860f, -0.13837337f, -0.00670018f, 
    0.12196770f, 0.06912197f, -0.14938301f, 0.07701360f, -0.25645623f, -0.16059317f, 0.00977517f, 0.16013981f, 
    0.00397807f, -0.07143245f, -0.15176219f, 0.02971397f, -0.44653663f, 0.33999789f, -0.09928815f, 0.04911142f, 
    -0.08594471f, 0.07351260f, -0.18442713f, 0.15420796f, 0.04033076f, 0.01735661f, -0.03351939f, 0.06705634f, 
    -0.28226146f, 0.16810764f, 0.11209602f, 0.07988477f, -0.10754225f, -0.15618853f, 0.12908255f, -0.16805747f, 
    -0.05880274f, 0.15329392f, -0.08384663f, -0.08597122f, -0.22096230f, 0.13330488f, -0.18864293f, 0.09334040f, 
    0.18444479f, 0.07303754f, -0.03689083f, 0.00979592f, 0.04027003f, 0.08848123f, -0.10974885f, -0.15207253f, 
    -0.87730032f, -0.18729939f, 0.15621749f, -0.09617464f, 0.07105593f, -0.12597562f, 0.06670552f, -0.06506007f, 
    0.10251560f, -0.11120792f, 0.00008104f, 0.05120913f, 0.53771460f, 0.00882696f, 0.05431942f, -0.44518152f, 
    0.01818711f, 0.08091673f, -0.09195215f, -0.08819687f, 0.06113337f, 0.01720794f, -0.03831518f, -0.04189097f, 
    -0.23560256f, -0.40586275f, -0.07260089f, 0.19370675f, -0.11233620f, 0.17504655f, 0.13288873f, 0.15703595f, 
    -0.00264135f, -0.05171782f, 0.03959608f, -0.03008301f, 0.02099955f, -0.16410276f, -0.02963860f, 0.30527583f, 
    0.09732711f, 0.03332494f, 0.01046101f, -0.21385062f, -0.00176511f, -0.03610025f, -0.19989224f, 0.02920878f, 
    -0.01136261f, 0.12277043f, 0.06536593f, -0.37201038f, 0.06975444f, 0.08752000f, -0.01209086f, -0.14539589f, 
    -0.15636532f, 0.00122565f, 0.05900974f, 0.04072665f, -0.07713831f, -0.22787316f, 0.30311504f, 0.03096553f, 
    0.09165378f, -0.11292171f, -0.01100785f, -0.25604412f, 0.21091232f, -0.05847862f, 0.00460857f, -0.01113022f, 
    -0.44007537f, 0.23458675f, -0.06670354f, 0.13002777f, 0.12552863f, 0.10563499f, -0.13913548f, 0.01239377f, 
    -0.03541270f, -0.06049987f, -0.08359306f, -0.04564336f, 0.28481540f, 0.34744021f, 0.00467110f, -0.39691007f, 
    0.16027983f, -0.03311983f, 0.05978763f, 0.10011810f, 0.04193763f, 0.04779828f, -0.04063495f, 0.04786122f, 
    -0.33982286f, 0.16080558f, -0.43034330f, 0.48987994f, 0.14709327f, 0.03995645f, 0.01033149f, -0.11957169f, 
    0.11668772f, -0.11834027f, 0.08563078f, -0.11696307f, -0.13185616f, 0.06438021f, 0.19894223f, -0.44569215f, 
    -0.09644309f, -0.01278473f, 0.01999261f, 0.09071789f, 0.13774657f, -0.04746652f, -0.09326579f, 0.09406053f, 
    0.10221992f, 0.25901338f, 0.01937867f, -0.18125468f, -0.28237471f, -0.17885071f, -0.05691583f, 0.02213267f, 
    -0.05204798f, -0.07385816f, 0.08195166f, -0.10817784f, -0.15724473f, -0.09825239f, -0.24970141f, -0.13239317f, 
    -0.10921149f, 0.04601682f, 0.13827497f, 0.07584500f, -0.08124722f, -0.00703017f, 0.05491227f, 0.05166005f, 
    -0.12892251f, -0.01085473f, -0.12270711f, -0.05059785f, -0.08838191f, 0.02150995f, -0.09443580f, 0.18906273f, 
    0.11249530f, -0.00776593f, 0.00453533f, -0.27567098f, -0.19715670f, 0.00686594f, -0.03686046f, 0.06153588f, 
    -0.14660685f, -0.02700022f, 0.02695878f, -0.05487858f, 0.11241397f, -0.10602372f, -0.06212782f, 0.10860239f, 
    0.20015876f, -0.04745729f, -0.09249899f, 0.49452248f, -0.13608953f, 0.08761427f, 0.07588834f, -0.10351509f, 
    0.03526721f, -0.09122875f, -0.02715687f, -0.02606373f, 0.38079697f, -0.10440010f, 0.01713713f, -0.25927615f, 
    0.07013435f, 0.09063616f, 0.11575876f, 0.07432380f, -0.04649159f, 0.17221197f, -0.03536751f, 0.10071898f, 
    -0.00856280f, 0.07253169f, 0.07089464f, 0.13450564f, -0.03017662f, 0.02624073f, 0.09894212f, 0.09194496f, 
    -0.09951719f, -0.10586961f, -0.10054453f, -0.13885315f, 0.46070379f, -0.76335168f, -0.21042435f, 0.00269295f, 
    -0.06369896f, -0.20185632f, -0.12683405f, 0.12282396f, 0.04577143f, -0.00573231f, 0.01734606f, -0.01529238f, 
    0.32377130f, -0.03936369f, 0.16522959f, 0.18701324f, -0.25361851f, 0.03358772f, 0.13476279f, 0.02699906f, 
    0.07567248f, -0.14717002f, -0.11831290f, -0.01858942f, -0.10020575f, -0.01761936f, -0.14293194f, 0.11806827f, 
    -0.12217894f, 0.03452623f, -0.09231091f, 0.05974191f, -0.05895887f, 0.04747627f, -0.06079511f, 0.11539900f, 
    0.00017544f, -0.04950171f, 0.04293425f, -0.10083668f, 0.01000500f, 0.07551377f, 0.02353868f, 0.20876192f, 
    -0.00763960f, -0.03108791f, 0.14269572f, 0.10207182f, -0.14042625f, 0.01469120f, -0.10354035f, -0.14350829f, 
    -0.21095966f, 0.01011449f, -0.02320860f, -0.02574519f, -0.01505191f, 0.03178548f, 0.02777795f, -0.02361281f, 
    0.20264469f, 0.04030158f, 0.27971497f, 0.15688650f, -0.25944856f, -0.09977502f, 0.09632842f, -0.03709435f, 
    -0.08126602f, 0.10385279f, 0.08407854f, 0.14352944f, 0.06504928f, -0.11766967f, -0.05871932f, -0.04980606f, 
    0.05361117f, -0.08661003f, 0.17774129f, 0.04249569f, 0.08934657f, -0.14076164f, 0.03371298f, -0.10114571f, 
    0.59291601f, 0.02278159f, 0.06557008f, 0.10575918f, -0.14236803f, 0.11760122f, -0.04278323f, 0.01796245f, 
    0.05702025f, -0.04603502f, -0.12683848f, 0.17854375f, 0.15886493f, -0.01302484f, 0.20260705f, -0.42235008f, 
    -0.11160051f, -0.08584298f, -0.03058628f, 0.07646261f, -0.05724406f, -0.20907864f, 0.05618313f, -0.02511607f, 
    0.24371710f, -0.24069101f, -0.01593691f, -0.14000782f, 0.10469708f, -0.12489985f, -0.00280670f, -0.03710275f, 
    -0.06462534f, -0.09113611f, -0.04149393f, 0.06835489f, -0.01678054f, -0.21247169f, -0.01066238f, -0.00879897f, 
    0.02355425f, -0.02347074f, 0.06056991f, -0.04314239f, -0.02468362f, -0.29448524f, -0.10098644f, 0.08314894f, 
    0.09443876f, -0.05814193f, 0.10639014f, 0.17410144f, -0.05085905f, -0.00787659f, 0.04119102f, 0.03337603f, 
    0.07038595f, 0.10473841f, 0.05208838f, 0.03753847f, 0.14468434f, -0.20180595f, -0.18463629f, 0.06092519f, 
    0.07926109f, 0.09822494f, -0.13816592f, -0.06672864f, 0.14735854f, 0.01323566f, 0.11440469f, 0.06464764f, 
    0.09040905f, 0.02070917f, -0.06945353f, -0.01488370f, -0.12753285f, -0.02346010f, 0.01885324f, -0.08862062f, 
    -0.06995690f, -0.31101683f, 0.06185665f, -0.28211379f, -0.30930236f, -0.18611130f, -0.31677565f, 0.44903564f, 
    -0.06534413f, -0.03910610f, -0.08377175f, -0.11563536f, 0.04118235f, -0.27400863f, -0.11762710f, 0.24178573f, 
    0.42069551f, -0.35646617f, -0.00896975f, 0.06538884f, -0.22524747f, 0.05749553f, -0.00663835f, 0.17237468f, 
    -0.20145032f, 0.05477002f, 0.00747990f, 0.00988986f, 0.33230534f, -0.73682302f, 0.15868591f, -0.24934347f, 
    0.03973430f, 0.08544102f, -0.01508877f, 0.04260706f, 0.08750530f, -0.14424044f, 0.03274636f, 0.02727065f, 
    0.03927585f, 0.03968642f, -0.11268690f, -0.09683920f, 0.25749910f, 0.00310918f, 0.08428064f, -0.06706886f, 
    0.05670881f, -0.02823801f, 0.13459341f, 0.08340897f, -0.44703734f, -0.21284150f, -0.18278913f, -0.03990928f, 
    0.05616170f, 0.06230690f, -0.17681234f, 0.13617097f, 0.00899478f, 0.30599439f, 0.18070447f, -0.01592495f, 
    0.30231562f, -0.14046766f, -0.15459275f, -0.30865610f, 0.09031717f, -0.22636476f, -0.12032095f, 0.11823305f, 
    0.17251045f, -0.03365437f, -0.23485419f, -0.13418739f, -0.23811267f, -0.02207577f, -0.13422339f, -0.01392780f, 
    -0.02534352f, -0.02976097f, -0.14249675f, -0.03925319f, -0.10950493f, 0.00932211f, -0.10893536f, -0.21851359f, 
    0.44378623f, 0.11231857f, -0.21386275f, 0.11030276f, 0.17418583f, 0.17928708f, -0.11287943f, 0.14207323f, 
    -0.12022931f, 0.04921511f, 0.03768032f, -0.00122934f, 0.04153886f, -0.22149721f, 0.05023749f, -0.17513315f, 
    0.07819435f, -0.02829124f, -0.03283739f, 0.08706427f, 0.03429214f, -0.05419496f, 0.01815543f, -0.14064707f, 
    -0.11617072f, 0.02996405f, -0.17398515f, -0.20108439f, 0.02428497f, -0.22205824f, -0.00475688f, -0.26287231f, 
    -0.07715511f, -0.08839203f, 0.05143220f, 0.13922223f, 0.02683751f, 0.28555176f, -0.03128150f, -0.38906321f, 
    0.18705548f, 0.35728711f, -0.15963529f, -0.00557501f, 0.06956907f, 0.04277205f, 0.21411183f, -0.07324812f, 
    -0.17332776f, 0.11128926f, -0.11289734f, 0.38608336f, 0.04744916f, 0.13953501f, -0.00202849f, 0.10085563f, 
    0.09309988f, 0.06457904f, -0.13906713f, 0.14874953f, 0.04441553f, 0.08896247f, -0.01970749f, -0.63114369f, 
    0.01790270f, 0.07310376f, -0.10664463f, 0.05269175f, -0.03664898f, 0.00801215f, -0.02920633f, 0.14255986f, 
    -0.31404373f, 0.12827566f, -0.00246247f, -0.22369462f, 0.07512766f, 0.03606425f, 0.11486156f, -0.12794131f, 
    -0.05458543f, 0.14320615f, -0.18040504f, 0.09174591f, 0.00070667f, -0.17340750f, -0.25893867f, 0.23880148f, 
    0.09094311f, -0.06472211f, -0.10516353f, 0.03758416f, 0.08077396f, 0.01310970f, 0.17249680f, -0.22035144f, 
    0.24792950f, 0.02545631f, -0.07040903f, 0.35321176f, 0.07206059f, 0.08310217f, -0.02516514f, 0.02996617f, 
    -0.01508108f, 0.03484616f, 0.03725856f, -0.21500087f, 0.04917108f, -0.31571367f, 0.09862364f, -0.24067858f, 
    -0.05543593f, -0.16218531f, -0.10671245f, -0.01337811f, -0.03826556f, 0.04692400f, 0.00764526f, -0.16967729f, 
    0.26649678f, 0.04781493f, 0.00060863f, 0.04060690f, -0.00387529f, -0.03934259f, -0.03653652f, -0.08672751f, 
    0.19379325f, 0.14720418f, -0.23210339f, 0.13934059f, 0.09441364f, -0.09378916f, -0.28280872f, -0.01264855f, 
    0.07922801f, -0.12010323f, -0.10739802f, 0.16743441f, -0.10987614f, 0.01439531f, -0.02459523f, -0.00184816f, 
    0.20120597f, 0.13263336f, -0.01585875f, -0.00420411f, 0.13731848f, 0.08248036f, -0.01291348f, -0.01376979f, 
    0.02660239f, 0.06957420f, 0.12734403f, 0.01549104f, -0.11353648f, -0.24899311f, 0.20794654f, -0.28503087f, 
    -0.10179619f, -0.08992346f, -0.08959530f, -0.06544542f, 0.08950273f, -0.16744718f, 0.06071956f, -0.06565870f, 
    -0.34221342f, -0.17205076f, -0.00223205f, 0.13433485f, -0.11188183f, -0.11363006f, 0.02370092f, -0.12738594f, 
    -0.09160508f, -0.02515463f, -0.11535666f, -0.03853207f, -0.34043244f, 0.04064428f, -0.05080293f, -0.30394641f, 
    0.00159414f, 0.12109162f, 0.11389551f, -0.03693034f, -0.04982217f, -0.10048158f, -0.08506218f, -0.02220160f, 
    -0.02716677f, 0.14579064f, -0.00941864f, 0.01300091f, 0.14428674f, -0.01475303f, -0.03293619f, 0.04014605f, 
    0.03574477f, -0.02294210f, -0.02339344f, -0.01281629f, -0.22084568f, 0.18681400f, 0.02559398f, -0.18869396f, 
    -0.00150092f, 0.07737622f, -0.03069990f, -0.09340334f, -0.05739572f, 0.16057755f, -0.03399087f, -0.04760548f, 
    0.15600692f, -0.17039852f, 0.02701849f, 0.01454395f, -0.04733757f, 0.05582917f, 0.04132409f, -0.03587658f, 
    0.01533125f, 0.05861886f, 0.06212470f, 0.02663613f, 0.33899158f, -0.37921855f, -0.39313412f, -0.21130878f, 
    -0.05152855f, 0.13520716f, -0.19019336f, -0.17929244f, -0.05171937f, 0.04783804f, -0.00865349f, -0.12919734f, 
    -0.63394105f, -0.02667744f, -0.24686110f, -0.05517757f, 0.12456790f, 0.05514173f, 0.15589660f, 0.02377270f, 
    -0.01203545f, 0.01629907f, -0.02754387f, -0.02868398f, 0.37864342f, 0.15859240f, 0.21469523f, 0.23278570f, 
    -0.32142273f, -0.29863846f, -0.06600666f, 0.17665067f, 0.00990256f, 0.11937792f, 0.00606385f, -0.17907912f, 
    0.10715870f, 0.13741186f, -0.17475319f, 0.06869806f, 0.04242289f, 0.14344499f, -0.02649433f, -0.01041971f, 
    -0.05067022f, -0.00329707f, -0.06708114f, -0.03306365f, 0.66987669f, -0.24975602f, -0.18086110f, 0.32103661f, 
    -0.06048651f, 0.02609971f, 0.00613161f, -0.05761529f, 0.02224061f, -0.07078030f, -0.13897429f, 0.13069588f, 
    0.20965458f, -0.25438696f, -0.14200488f, -0.00133260f, -0.02606345f, 0.03670633f, 0.08208264f, -0.09341030f, 
    -0.09261461f, 0.12027384f, -0.18427728f, -0.02114839f, 0.25357851f, 0.04374762f, -0.42380732f, -0.35292655f, 
    -0.22062504f, -0.07809495f, 0.02583098f, 0.14682014f, 0.12795335f, 0.11795423f, 0.00097684f, -0.09736028f, 
    0.67475939f, -0.05319861f, 0.07460738f, -0.03036996f, -0.15340728f, -0.08433946f, 0.09096738f, -0.12939213f, 
    -0.00737990f, 0.03845673f, 0.00526697f, -0.15661786f, -0.62395543f, 0.28060505f, 0.19453257f, -0.00311732f, 
    0.02273317f, -0.07367401f, -0.15927844f, -0.04233065f, -0.19603641f, -0.15318018f, -0.00184851f, -0.02362226f, 
    -0.05041464f, -0.13306478f, 0.19568393f, -0.22957817f, -0.20450316f, 0.00454955f, -0.06157358f, -0.07801891f, 
    -0.18405809f, -0.02112450f, 0.09053952f, -0.14518194f, 0.14830640f, 0.02914087f, -0.29677707f, 0.17365462f, 
    -0.05713092f, 0.05561301f, 0.03710224f, -0.03785805f, 0.10331003f, -0.01906761f, -0.02914681f, -0.06854035f, 
    -0.05702161f, -0.17089334f, 0.17901371f, 0.07496637f, -0.04714638f, -0.04114010f, 0.16084538f, 0.02275136f, 
    -0.02907012f, -0.04294433f, 0.05185221f, -0.07708310f, 0.17633949f, 0.01962274f, -0.08692464f, -0.06420540f, 
    -0.09308808f, 0.02505141f, 0.04029825f, 0.08556167f, -0.17447652f, -0.05113219f, -0.11099730f, 0.03975388f, 
    0.26120564f, -0.41416350f, 0.11032247f, 0.02896962f, -0.14086260f, 0.01651703f, -0.14644513f, 0.04452979f, 
    0.10089152f, -0.08771983f, -0.01706619f, 0.03875336f, 0.27252036f, 0.19090424f, 0.07897429f, 0.49010199f, 
    -0.10335191f, -0.10248505f, 0.03894193f, 0.11719059f, 0.07912759f, 0.06434041f, 0.03292536f, 0.13180076f, 
    0.17200272f, 0.15330417f, -0.35677803f, 0.07919996f, -0.13930404f, 0.08810702f, -0.04729697f, -0.04755307f, 
    -0.11400437f, -0.10149970f, 0.10550707f, -0.10498014f, -0.09913309f, 0.01725514f, -0.13472889f, -0.17931370f, 
    0.14669329f, -0.09119511f, -0.07788042f, 0.07178047f, -0.06833362f, 0.00013666f, -0.11719040f, 0.09452659f, 
    -0.03210897f, 0.08121259f, -0.39256221f, -0.05139013f, 0.05399755f, 0.05366497f, -0.08726218f, -0.07268921f, 
    -0.19544145f, -0.00954448f, 0.09652912f, 0.14186665f, -0.02372983f, -0.18103582f, -0.21170433f, 0.18870620f, 
    0.03176454f, 0.04909311f, -0.07526277f, -0.11898631f, 0.01440234f, -0.12828849f, 0.05669905f, 0.20825306f, 
    0.26505101f, -0.09249743f, -0.58022422f, -0.11538983f, 0.12975058f, 0.04404822f, -0.08303327f, -0.18313915f, 
    0.04148626f, -0.03358940f, 0.04073850f, -0.09862658f, -0.05790557f, 0.14325017f, 0.00849829f, -0.09510651f, 
    -0.06296601f, 0.00933525f, -0.08658871f, 0.03604867f, 0.06550019f, -0.06257519f, -0.02762238f, 0.04710111f, 
    -0.11574292f, -0.11455633f, -0.05070943f, -0.01116302f, 0.11989998f, 0.16215035f, 0.04652809f, -0.02873359f, 
    0.01871664f, 0.05086904f, -0.02644094f, -0.06126257f, 0.30194813f, 0.03758648f, 0.09600033f, 0.12514679f, 
    0.03736461f, -0.12134215f, 0.17000057f, 0.03402271f, -0.17784512f, -0.04907848f, 0.12595274f, -0.03688340f, 
    0.24147908f, 0.21764031f, -0.09697787f, 0.12303872f, -0.07902599f, -0.05512420f, -0.09158331f, 0.13980617f, 
    0.13900101f, -0.04948658f, -0.03664286f, 0.01423127f, 0.45283869f, -0.47844478f, -0.04701478f, -0.04125706f, 
    -0.05529911f, 0.13408305f, 0.13954042f, -0.06690509f, 0.07053202f, -0.08218770f, -0.06014289f, 0.03575354f, 
    -0.85730755f, -0.38358819f, -0.18445423f, 0.00925288f, -0.12332837f, 0.08988428f, 0.03671695f, -0.09972525f, 
    -0.04012624f, 0.14597587f, 0.10564251f, -0.01589263f, 0.12770131f, -0.01173555f, -0.00674313f, -0.28037649f, 
    -0.09453874f, -0.11187543f, -0.00330083f, -0.03076974f, -0.06098184f, -0.11291914f, 0.13511699f, -0.02322163f, 
    0.07193436f, 0.18484482f, -0.31156912f, 0.01066012f, -0.23067434f, 0.04062233f, 0.07986826f, -0.12035923f, 
    0.02142472f, -0.05357398f, -0.15643442f, -0.00450596f, 0.18586272f, -0.23241775f, 0.05438618f, 0.19000335f, 
    -0.04335222f, -0.08247411f, 0.06212288f, 0.06897472f, -0.04722322f, 0.09644940f, 0.01600216f, -0.05566560f, 
    -0.47840589f, -0.49814177f, -0.39768821f, 0.09551045f, -0.27744457f, 0.03416528f, -0.05453593f, -0.02782319f, 
    0.00977804f, -0.26682401f, 0.04259756f, -0.01944712f, -0.15376753f, 0.30236873f, -0.01560629f, 0.39066094f, 
    0.00215669f, 0.14336361f, 0.01824906f, -0.09391800f, -0.06265748f, -0.04973668f, -0.02550149f, 0.12899032f, 
    -0.80147028f, -0.18396543f, -0.54422349f, -0.23199503f, 0.00598778f, 0.00718006f, -0.07628497f, -0.16386651f, 
    -0.01155503f, -0.08750892f, 0.00930046f, 0.00745531f, 0.09343760f, 0.25487259f, 0.24920082f, 0.29129520f, 
    0.06351862f, -0.13385670f, -0.12619969f, -0.10794771f, 0.05215288f, 0.14387006f, 0.03416969f, -0.06322035f, 
    0.02177348f, -0.19438872f, 0.04309669f, -0.15892993f, -0.15028481f, 0.06136689f, 0.08253342f, 0.18614262f, 
    -0.02125548f, 0.04300862f, 0.04059245f, 0.06940292f, 0.18271710f, 0.00452430f, -0.08679342f, -0.20992112f, 
    -0.01811359f, -0.10479339f, -0.04408594f, 0.01576478f, -0.09948648f, -0.06914145f, 0.17570071f, -0.09953285f, 
    -0.76264423f, -0.62048703f, 0.00226317f, 0.27199563f, -0.00872526f, 0.07020283f, 0.08717750f, -0.04902614f, 
    0.01089506f, -0.07271084f, 0.00042239f, -0.16210920f, -0.04717881f, 0.06152567f, 0.17292295f, -0.03056773f, 
    0.03350507f, -0.26186460f, 0.08014696f, -0.13628468f, -0.15245256f, 0.05650214f, -0.15351628f, -0.00737327f, 
    0.58807111f, -0.13104087f, -0.24739456f, 0.26904580f, 0.06281347f, 0.05702399f, 0.10773541f, 0.13501765f, 
    -0.00322639f, 0.15644288f, -0.03845520f, -0.02818308f, 0.33798733f, 0.03465477f, 0.14886525f, -0.10085756f, 
    0.02640649f, -0.06373718f, -0.03330921f, -0.06921969f, -0.00357668f, 0.03149598f, -0.08742272f, 0.08769736f, 
    -0.00200664f, -0.12524582f, -0.00596045f, -0.05014535f, 0.00555582f, -0.11584051f, -0.04718075f, 0.02255283f, 
    0.11471473f, -0.00010108f, 0.05138977f, -0.04889689f, 0.02735546f, 0.06177257f, -0.28747043f, 0.03130364f, 
    -0.03688696f, 0.11581637f, 0.00388609f, 0.03429131f, -0.11081536f, 0.01120791f, 0.02503567f, 0.18461378f, 
    -0.09693827f, 0.18843414f, -0.09857481f, -0.05586476f, -0.24435632f, -0.06152615f, -0.14202926f, 0.10826724f, 
    0.09970969f, -0.10742477f, 0.05535913f, 0.00103628f, 0.02522846f, 0.17126469f, -0.03982272f, 0.32715288f, 
    -0.00704165f, 0.03971384f, 0.10012256f, -0.02642420f, -0.10428169f, -0.03293269f, -0.01387965f, -0.20066461f, 
    -0.08254949f, 0.07763430f, -0.09277658f, -0.06163029f, -0.18794362f, -0.06482164f, -0.02054615f, 0.06637712f, 
    -0.04576576f, -0.00292990f, -0.09086137f, 0.19549923f, 0.65891010f, 0.20238476f, -0.07256753f, 0.00761146f, 
    0.03601774f, 0.00687163f, 0.07757407f, -0.12348709f, -0.10564250f, -0.06860468f, 0.09661409f, -0.02225346f, 
    0.16853002f, 0.01602618f, -0.12319322f, 0.11021271f, 0.07468488f, -0.08905766f, 0.10229292f, -0.16523720f, 
    -0.10465433f, 0.00288701f, 0.03892518f, -0.08499094f, -0.31130847f, 0.00636487f, -0.12380911f, -0.21346934f, 
    -0.12159345f, -0.24722996f, 0.15531519f, -0.06144740f, -0.08628555f, 0.01669823f, -0.02589524f, -0.01077934f, 
    -0.38579583f, 0.09685034f, 0.09384932f, 0.24616349f, -0.05363014f, 0.10516922f, 0.21670769f, 0.09202684f, 
    0.05581636f, 0.10629405f, -0.17268856f, 0.08093256f, -0.30033013f, -0.07836232f, 0.13185483f, -0.10372487f, 
    -0.00425243f, -0.07767213f, 0.14312269f, -0.01632353f, 0.15232918f, 0.12160461f, -0.14129257f, 0.16429250f, 
    -0.31945822f, -0.01850213f, 0.08311994f, -0.05797877f, -0.06264885f, 0.04271770f, 0.07998600f, -0.08630178f, 
    -0.16958326f, 0.02461743f, 0.14817815f, -0.02702539f, 0.11305762f, 0.08965439f, -0.00088776f, -0.14035609f, 
    -0.03637741f, -0.02727774f, 0.04565825f, 0.02337058f, 0.06958871f, 0.12669136f, 0.00864374f, 0.04564853f, 
    -0.04588765f, 0.23462513f, 0.27466321f, 0.31905562f, 0.10940084f, -0.07795825f, -0.00870071f, 0.09654142f, 
    0.06856434f, 0.09472350f, 0.10097776f, -0.11400114f, 0.05817134f, 0.10553872f, 0.12608986f, -0.01329385f, 
    -0.13622785f, 0.08037743f, 0.08506818f, 0.05148333f, -0.00970146f, -0.00804325f, -0.15236868f, 0.04945805f, 
    -0.03875932f, -0.43823215f, -0.17425519f, 0.31493625f, -0.11852962f, -0.07519513f, 0.14480127f, -0.10139751f, 
    0.09228505f, -0.00427174f, 0.10102242f, 0.05240340f, -0.22587316f, 0.15524825f, -0.01567108f, -0.07545443f, 
    -0.13411678f, 0.06491418f, -0.13738579f, -0.00844137f, -0.06764778f, 0.06751180f, -0.10533183f, -0.06513383f, 
    0.06363196f, 0.39264634f, -0.16260017f, 0.02420280f, 0.02032945f, 0.00379815f, -0.04742188f, -0.00340002f, 
    -0.06251587f, -0.06850450f, -0.03842286f, -0.09241717f, 0.32270607f, 0.15559347f, -0.18935889f, -0.19149372f, 
    -0.04514259f, 0.05799545f, -0.05262338f, -0.01425322f, -0.07398738f, 0.11312707f, -0.01468883f, -0.00644612f, 
    -0.36110130f, 0.01996031f, -0.05411188f, 0.03353065f, -0.05204193f, -0.08087677f, 0.04756234f, 0.09047633f, 
    -0.00840802f, -0.00461919f, -0.05656131f, 0.03011463f, 0.14598009f, 0.07370061f, 0.15447029f, -0.02644831f, 
    0.12282407f, 0.01512418f, -0.01163570f, 0.25457624f, -0.10545389f, -0.08626278f, 0.03613527f, -0.00639341f, 
    -0.01114286f, 0.03629166f, -0.13036531f, 0.16531852f, -0.02458369f, -0.08877990f, -0.03759618f, 0.08151671f, 
    0.12060666f, 0.13373128f, 0.06117723f, -0.03878737f, 0.00572125f, 0.04968772f, 0.13120526f, -0.42753139f, 
    0.05583560f, 0.03870336f, -0.09304989f, -0.02481614f, -0.07328489f, 0.00497915f, 0.08199838f, -0.14067875f, 
    0.09452948f, 0.08695364f, 0.21153793f, 0.00164161f, -0.06592994f, 0.10823622f, -0.26328704f, 0.04633478f, 
    0.06149215f, 0.07916234f, 0.01858710f, -0.06063869f, -0.34513897f, -0.19420053f, 0.23325399f, 0.18665192f, 
    0.00691799f, 0.15997232f, -0.15137714f, -0.14646928f, 0.11638614f, 0.11833553f, 0.11845359f, 0.00367809f, 
    -0.28128549f, 0.24012525f, -0.15591595f, -0.02205709f, -0.08397778f, -0.17423698f, 0.06579747f, 0.17672095f, 
    -0.03222381f, 0.13126667f, -0.09030905f, -0.06891127f, -0.00152155f, -0.19843274f, 0.15754895f, 0.14212221f, 
    -0.02011891f, 0.00890392f, 0.11341349f, 0.00748369f, -0.02687894f, 0.15056656f, 0.01447557f, 0.03675549f, 
    0.08163921f, -0.26652762f, 0.02911228f, 0.02583743f, -0.14141555f, 0.03999910f, 0.19439779f, -0.19220383f, 
    0.00247891f, 0.07449624f, 0.13194062f, 0.00498973f, -0.51330334f, 0.01739621f, -0.02273267f, 0.24805024f, 
    0.31740779f, 0.09265354f, -0.09879770f, 0.18331297f, 0.07529368f, 0.05448481f, 0.12153541f, 0.04191452f, 
    -0.36738384f, -0.01429408f, 0.26362371f, 0.07151501f, -0.04769451f, -0.08710802f, -0.00385017f, 0.00930903f, 
    0.02917226f, -0.02797963f, -0.00942362f, -0.32077935f, -0.35689825f, 0.24438311f, 0.01642612f, -0.03169543f, 
    -0.01445136f, -0.11786575f, -0.00974358f, -0.03943371f, -0.04759531f, -0.04839066f, -0.00567865f, -0.04794231f, 
    -0.02217316f, 0.34195420f, 0.03872569f, -0.16299699f, -0.08763008f, 0.09433023f, -0.01060248f, 0.20670030f, 
    -0.09212042f, 0.01369147f, 0.05062689f, 0.28303853f, -0.14399272f, -0.27200583f, -0.09652007f, -0.55423146f, 
    0.07749630f, -0.07090218f, 0.03148166f, 0.19503045f, -0.21995871f, -0.04090765f, -0.03943666f, 0.10612674f, 
    -0.03825027f, 0.19727977f, 0.07682104f, -0.02811380f, 0.00781987f, 0.07128606f, 0.05965033f, -0.01346632f, 
    0.02592731f, -0.02397864f, -0.00296627f, -0.07648515f, -0.43615738f, 0.13856615f, 0.02262746f, -0.19242160f, 
    0.03723860f, -0.06241095f, -0.09566120f, -0.25030118f, 0.05178398f, -0.07887492f, -0.04133866f, -0.07855857f, 
    0.26249200f, 0.05346460f, 0.10930240f, 0.19032049f, 0.00343240f, 0.07543037f, 0.10510888f, 0.21256417f, 
    0.13332528f, -0.08177105f, -0.08155135f, -0.13142048f, -0.33117273f, -0.34799162f, 0.22428194f, 0.17151523f, 
    -0.09119924f, -0.01192625f, -0.05053411f, -0.12853335f, 0.03533907f, -0.07506839f, -0.04896783f, -0.03836502f, 
    -0.43568805f, -0.00670479f, 0.26251838f, 0.20102772f, -0.11210532f, -0.02071426f, 0.15441294f, -0.01605652f, 
    -0.02859145f, 0.07385257f, 0.25973359f, -0.12159453f, -0.24511713f, 0.26304656f, -0.26671258f, -0.31772926f, 
    0.16248699f, 0.10745668f, 0.00371365f, -0.21285658f, -0.07915638f, -0.09335802f, 0.10412166f, 0.04333287f, 
    -0.80490220f, 0.09887864f, -0.16906671f, -0.14233322f, -0.00473235f, -0.03366382f, -0.01535017f, 0.04952707f, 
    0.16428867f, -0.03693914f, 0.00643854f, 0.11386260f, -0.31303704f, -0.27839431f, 0.00677939f, 0.30471730f, 
    -0.01685306f, -0.09867611f, 0.08537348f, -0.02458660f, -0.02595861f, -0.05365107f, 0.05990364f, 0.13535060f, 
    -0.08645435f, -0.07737236f, 0.03339969f, -0.02987023f, -0.16398908f, 0.12923606f, 0.07942442f, 0.06532506f, 
    0.02120052f, -0.05584585f, -0.09400518f, -0.00324906f, -0.04724553f, 0.09708042f, 0.28450570f, 0.24402070f, 
    -0.13069765f, -0.15726621f, 0.12357608f, -0.04660076f, -0.05473765f, -0.08315032f, -0.07856216f, 0.17655465f, 
    0.15889537f, 0.03598457f, 0.14526993f, 0.03648882f, -0.04696679f, -0.22967987f, 0.02081496f, -0.14272033f, 
    -0.01400336f, -0.14789844f, 0.12295631f, -0.15850364f, 0.42740372f, -0.16327754f, -0.09925379f, 0.29239777f, 
    -0.10901101f, -0.08226116f, 0.09580962f, 0.02159199f, 0.06093556f, -0.01544731f, -0.01103994f, -0.00924645f, 
    -0.30963811f, 0.20946558f, 0.04247603f, -0.22654971f, 0.02423441f, -0.11653501f, 0.06649468f, 0.06624877f, 
    -0.09781725f, -0.19168901f, 0.13206811f, 0.05781643f, -0.04388743f, 0.03176241f, -0.16961025f, -0.10960917f, 
    -0.07230040f, 0.16193694f, 0.03753842f, -0.09121522f, -0.17534842f, -0.11062065f, -0.00033047f, -0.11867322f, 
    0.28017369f, 0.25710052f, -0.18589871f, -0.03164332f, 0.07278734f, 0.03164797f, -0.01173581f, 0.15953739f, 
    -0.10022097f, -0.01222695f, 0.15111707f, 0.09907938f, -0.31345990f, -0.26314527f, -0.03811339f, 0.33758906f, 
    0.04223251f, -0.12896495f, 0.07681986f, 0.12161344f, -0.00669466f, -0.13226195f, 0.02013953f, -0.02059663f, 
    -0.14384639f, -0.30544072f, 0.28309155f, 0.08535777f, 0.10471383f, -0.02887950f, 0.11624324f, 0.06131717f, 
    0.14473870f, -0.07229281f, -0.13567324f, -0.18769863f, 0.06679583f, 0.25025412f, 0.17344177f, -0.12625058f, 
    -0.10030453f, -0.02934597f, -0.02377341f, -0.07359979f, 0.01822893f, -0.09395077f, -0.06174135f, 0.10931876f, 
    -0.06012326f, -0.04830498f, 0.18288989f, -0.07521730f, 0.15405226f, -0.14476617f, -0.05717438f, -0.00147404f, 
    -0.06046399f, -0.13754335f, -0.14235492f, 0.04917263f, -0.23656549f, -0.31860378f, -0.24687712f, 0.20343134f, 
    0.16774818f, 0.00018003f, 0.07283648f, -0.13373208f, 0.07747544f, 0.20177141f, 0.01685495f, 0.06639872f, 
    -0.12579213f, -0.08715227f, -0.02077361f, -0.02529685f, 0.05589525f, 0.02274664f, -0.21588130f, -0.10316272f, 
    0.11760678f, 0.08706421f, 0.07510911f, 0.14999740f, -0.11023604f, 0.13146970f, -0.03891304f, 0.23335385f, 
    -0.05752644f, 0.17450178f, 0.10889707f, 0.13545367f, 0.00393443f, 0.08178381f, 0.04302273f, -0.02967248f, 
    0.16739359f, 0.12454977f, -0.02278592f, 0.10953495f, 0.07331038f, 0.12154379f, 0.17090410f, -0.09089281f, 
    -0.00679098f, 0.08514447f, 0.03905850f, 0.04615005f, 0.11856300f, 0.06121686f, -0.07528160f, 0.00546597f, 
    -0.05166776f, -0.19451663f, 0.02786938f, 0.06866182f, -0.02298917f, -0.15196370f, 0.13168387f, 0.01571151f, 
    -0.42869222f, 0.34245107f, 0.38164318f, -0.05955469f, 0.13458207f, -0.08279754f, -0.02744931f, -0.13317026f, 
    0.06605566f, -0.02736883f, 0.01574867f, -0.02961412f, 0.00279298f, -0.01632646f, -0.16555388f, 0.12952742f, 
    0.18642862f, 0.05224995f, 0.06906661f, 0.03654597f, 0.01900363f, -0.13501559f, -0.05720774f, 0.23508276f, 
    0.04678886f, -0.11606830f, -0.03181645f, -0.01469066f, 0.12505120f, -0.12614702f, -0.01989002f, -0.24534315f, 
    -0.13298604f, -0.02581897f, 0.05089710f, -0.03549425f, -0.35478333f, -0.41819003f, -0.44533786f, -0.00442183f, 
    0.13055719f, 0.12999603f, -0.05133155f, -0.14869890f, 0.01193255f, -0.08429971f, 0.14419590f, -0.07437328f, 
    0.07112331f, -0.05086168f, 0.13067684f, -0.04320877f, -0.06677972f, 0.05108866f, 0.14444987f, -0.10833485f, 
    -0.00207097f, -0.12965125f, 0.19401640f, 0.25074098f, -0.54081869f, 0.08113943f, -0.16381402f, -0.40848356f, 
    0.07219616f, 0.10418905f, 0.06786247f, 0.11832961f, 0.07118271f, -0.02435710f, 0.01620305f, -0.27767989f, 
    -0.16783868f, -0.17705040f, 0.23976666f, 0.29905471f, 0.28348738f, 0.01671004f, -0.19578701f, -0.08013323f, 
    -0.02274302f, 0.00075039f, -0.09905946f, -0.10799994f, 0.04526342f, 0.01999489f, 0.01816623f, 0.02414253f, 
    -0.06129329f, 0.20755847f, 0.06133621f, 0.29154187f, -0.11624505f, -0.02341287f, 0.24001187f, -0.38594806f, 
    -0.50267756f, -0.30275562f, 0.00800276f, 0.15581663f, 0.10975802f, -0.09661248f, -0.06568456f, 0.14452167f, 
    0.11857823f, 0.06595562f, -0.12710842f, 0.08519245f, -0.47360361f, 0.13947734f, 0.23986211f, 0.15514061f, 
    -0.16286604f, -0.03829008f, -0.01191004f, -0.01005944f, 0.21386707f, -0.05404567f, 0.03982365f, 0.09667831f, 
    -0.34365973f, -0.09566274f, 0.00191439f, 0.13928066f, -0.01839780f, -0.11142813f, -0.12956245f, -0.17392930f, 
    -0.19119009f, 0.14287788f, 0.06789352f, 0.27116922f, 0.05305890f, 0.10811099f, 0.31864569f, 0.12472457f, 
    -0.14478520f, -0.07831094f, 0.13041402f, 0.02713410f, -0.18048687f, 0.09948403f, 0.06341106f, 0.35011673f, 
    0.27931154f, -0.33881882f, -0.17149971f, -0.02535492f, -0.10759206f, 0.09120515f, -0.21732727f, -0.02494782f, 
    0.08888941f, -0.20490845f, -0.28185320f, -0.04222280f, -0.29776540f, -0.35159341f, 0.06900570f, -0.22451852f, 
    -0.08496158f, 0.03402534f, 0.05837775f, 0.17948405f, -0.11827777f, 0.22085744f, 0.05197614f, 0.04450555f, 
    -0.66612130f, 0.13537830f, 0.03769051f, -0.34944668f, 0.00241215f, 0.01004663f, 0.04905828f, -0.29181975f, 
    0.08785269f, 0.01240866f, -0.03603704f, 0.00804006f, -0.08807816f, 0.07618953f, -0.31628367f, -0.19513831f, 
    0.03933105f, 0.35430405f, -0.05951206f, -0.09421338f, 0.01229917f, -0.16732408f, 0.06643405f, -0.15930037f, 
    0.20949784f, -0.04841582f, -0.20352650f, -0.04203115f, 0.03021613f, -0.20120396f, 0.01789452f, 0.12076431f, 
    0.02434392f, 0.13827863f, -0.06965125f, -0.05686959f, -0.07674750f, -0.23455667f, 0.07816060f, 0.19634785f, 
    -0.03899110f, -0.00504776f, -0.17143293f, -0.24672571f, 0.01330874f, 0.18707359f, 0.17816682f, 0.06504161f, 
    0.18790865f, -0.13311917f, 0.03522288f, 0.04653804f, -0.20672354f, 0.04595736f, -0.07928067f, 0.05285748f, 
    0.13893911f, 0.14971432f, 0.05309496f, 0.00665047f, -0.33846092f, -0.12075856f, 0.25387299f, 0.05932665f, 
    0.04235147f, 0.17306517f, 0.10618439f, -0.11580955f, -0.08823543f, 0.11353126f, -0.03934757f, -0.29531384f, 
    0.21237883f, -0.12242028f, 0.23393482f, 0.20653073f, -0.03374290f, 0.04697821f, 0.03390689f, 0.08487054f, 
    -0.14658988f, 0.03731893f, -0.10110407f, 0.23894484f, -0.31045401f, 0.10769523f, 0.15082705f, -0.07328127f, 
    0.27372536f, -0.16839737f, 0.09081303f, 0.00888167f, -0.11536475f, 0.08129132f, 0.07908385f, -0.32833084f, 
    0.06372247f, 0.16827163f, 0.23940387f, -0.32935047f, 0.04939653f, 0.05761985f, -0.17355125f, -0.03001048f, 
    0.00403295f, -0.05855204f, 0.02090975f, 0.07325570f, 0.48305634f, 0.04825762f, -0.23064522f, -0.27429783f, 
    -0.08362764f, 0.10468654f, -0.15798850f, -0.26971433f, -0.01184358f, -0.17767161f, -0.08566305f, -0.09044068f, 
    0.34823084f, -0.32682705f, -0.19873396f, -0.07253955f, -0.00211627f, -0.04089157f, 0.09365154f, 0.05397123f, 
    -0.16063252f, 0.03659817f, 0.21092403f, 0.18142889f, -0.15141086f, 0.17559816f, 0.16980202f, 0.47556597f, 
    0.01440089f, 0.12270636f, -0.03174475f, 0.03494134f, -0.00038382f, 0.07941403f, -0.02826317f, -0.20962422f, 
    0.07647555f, 0.25399166f, 0.23702312f, -0.18787587f, -0.11894228f, -0.02609102f, 0.05213333f, 0.03680271f, 
    0.06366076f, 0.08835445f, 0.09847872f, 0.16264622f, -0.09613842f, 0.19738002f, -0.16645388f, -0.17015967f, 
    -0.07623268f, 0.04645783f, 0.03250035f, -0.10036620f, -0.08316707f, -0.07022633f, 0.00781510f, -0.11438253f, 
    -0.15956035f, 0.02008046f, 0.17720503f, -0.30573109f, 0.06456441f, 0.08024557f, 0.10622822f, -0.09500824f, 
    -0.28294072f, 0.01034022f, -0.26506931f, -0.04765513f, -0.33120999f, 0.07757875f, -0.20890199f, 0.52390778f, 
    0.04787678f, 0.08250382f, -0.08118015f, 0.14583564f, -0.11757574f, -0.10933004f, -0.10756507f, 0.03420708f, 
    -0.20922785f, 0.26051146f, 0.05984788f, -0.08218586f, 0.06269739f, -0.11107710f, 0.04099824f, 0.14825143f, 
    0.06844074f, -0.00411516f, -0.04996385f, -0.32166168f, 0.20571469f, 0.28284380f, -0.00056293f, 0.02348964f, 
    -0.04366140f, 0.13413686f, -0.08987684f, -0.05753196f, -0.09458955f, 0.03434436f, -0.06639534f, 0.13948080f, 
    0.24693680f, -0.66132468f, 0.20978110f, 0.04502440f, -0.12618963f, 0.06525386f, 0.04613082f, 0.07706670f, 
    -0.07903183f, -0.03290944f, -0.03524038f, -0.01957829f, -0.13982643f, 0.08907224f, -0.42922139f, -0.31164441f, 
    -0.01659950f, -0.05282690f, -0.19880834f, -0.06670081f, -0.05732610f, 0.08235871f, 0.11337566f, 0.02006700f, 
    -0.11784410f, 0.02809388f, -0.12350799f, 0.40017605f, 0.10463293f, 0.10480572f, 0.17647135f, 0.08776777f, 
    0.14445139f, -0.12428334f, -0.06636474f, 0.01783060f, -0.07902044f, -0.17213371f, -0.00111234f, -0.43649969f, 
    -0.27731577f, -0.12838583f, -0.01564631f, -0.18672663f, 0.03233626f, 0.14895234f, 0.11959529f, 0.25490326f, 
    0.17092410f, 0.32283518f, 0.16366470f, -0.39802498f, -0.08081800f, -0.14545798f, -0.11745969f, -0.00440211f, 
    0.05579593f, 0.04742530f, -0.19322519f, -0.16028851f, -0.06326095f, -0.35689723f, 0.16061856f, -0.21648555f, 
    0.07607771f, 0.06228307f, 0.14084488f, -0.12714913f, -0.16697200f, -0.07137630f, 0.13611430f, 0.13255332f, 
    0.30445004f, 0.09353986f, -0.10600428f, -0.05133285f, -0.09678311f, 0.06771185f, 0.27231824f, 0.14291418f, 
    0.12152304f, -0.02968254f, 0.10403590f, 0.14940217f, -0.09341736f, 0.11122436f, 0.21870223f, -0.25740415f, 
    -0.01275874f, -0.01856871f, 0.20205083f, -0.18660723f, 0.06980584f, 0.12851049f, 0.08964518f, 0.15481420f, 
    -0.22215018f, -0.02492969f, -0.08563742f, -0.05758376f, 0.02598685f, -0.10061158f, -0.01911420f, -0.04971061f, 
    0.06401802f, -0.09249555f, 0.20723066f, -0.13061416f, 0.21982417f, -0.09543402f, -0.26959446f, 0.30332381f, 
    0.00376825f, -0.09755038f, 0.13359395f, 0.01171596f, -0.21006176f, 0.04230443f, -0.00013101f, 0.00426418f, 
    -0.15357621f, 0.02705335f, -0.30161136f, -0.18128164f, -0.17517111f, 0.02289366f, 0.12957506f, 0.12046012f, 
    0.04667644f, -0.04407650f, -0.14529234f, -0.29211473f, 0.21755308f, -0.01667040f, -0.03518064f, -0.33265868f, 
    0.06812089f, 0.17467795f, 0.01183212f, 0.08020979f, 0.10829194f, -0.22074573f, -0.09446824f, -0.13559422f, 
    -0.42366305f, -0.12278458f, -0.10767525f, -0.07820074f, 0.15626232f, 0.07744827f, 0.08319013f, -0.06117688f, 
    -0.13157387f, 0.06858850f, 0.28438991f, 0.01157135f, 0.14753182f, -0.21881129f, 0.09884056f, 0.07617836f, 
    -0.10144772f, 0.12551340f, -0.14381239f, 0.06861616f, 0.16562052f, -0.08378787f, -0.11515842f, 0.00792634f, 
    0.23433821f, -0.54942870f, 0.01431045f, -0.03368234f, -0.02263162f, 0.00574838f, 0.03726519f, 0.12514831f, 
    0.04846931f, -0.02663095f, 0.01393643f, -0.07195970f, -0.33413973f, -0.18790570f, -0.19666161f, -0.08804385f, 
    -0.01308250f, 0.04004019f, -0.07271022f, -0.09951188f, 0.01390706f, 0.02774107f, -0.12122261f, 0.24012929f, 
    0.18355931f, 0.12643099f, 0.24335614f, -0.31637192f, 0.02663772f, 0.06156914f, 0.12336820f, 0.14229754f, 
    -0.07842250f, 0.11386664f, -0.01910590f, -0.13177362f, -0.34296733f, -0.07610320f, -0.34907451f, 0.18919006f, 
    -0.13470244f, -0.06041170f, -0.04122442f, 0.04647996f, 0.01786611f, -0.13763897f, -0.21684673f, 0.08170915f, 
    -0.13429913f, 0.11884584f, 0.13903034f, -0.11118600f, 0.26056027f, -0.02688000f, 0.05273397f, -0.00352994f, 
    -0.08803476f, -0.02449881f, -0.11882473f, 0.06129830f, -0.24633698f, -0.02272465f, 0.02439709f, -0.25373754f, 
    0.12007724f, -0.00899898f, 0.15833856f, 0.14415917f, -0.00863968f, -0.14778461f, 0.13982137f, -0.16496104f, 
    0.21426615f, -0.04102186f, -0.08853041f, 0.00891758f, -0.04724484f, -0.02583759f, -0.16906773f, -0.05784190f, 
    0.08334358f, -0.13090840f, -0.07761960f, -0.17888334f, 0.12524973f, -0.16168769f, 0.07283680f, -0.14667353f, 
    -0.01829363f, 0.03487108f, -0.14547199f, -0.06246170f, 0.03005945f, -0.07658852f, -0.01435420f, 0.19281197f, 
    0.04531408f, 0.01391376f, 0.18762499f, -0.49065992f, -0.21812804f, 0.08485126f, 0.23688221f, 0.19670498f, 
    0.10069029f, -0.01690620f, -0.06643408f, 0.05872349f, -0.43492255f, 0.03181495f, -0.24505542f, 0.44639656f, 
    -0.14465241f, 0.16951768f, 0.12414937f, -0.09740274f, 0.08864134f, 0.02941164f, -0.03439772f, 0.00915291f, 
    -0.28717431f, -0.03209430f, -0.02157069f, -0.07882419f, -0.00208999f, -0.01703498f, -0.03163354f, 0.00171030f, 
    -0.12196278f, -0.06186187f, -0.06327217f, -0.02457421f, -0.11776928f, 0.40414244f, -0.02245931f, -0.20920378f, 
    -0.14487991f, 0.13982482f, -0.00822641f, -0.03691385f, -0.07129660f, 0.10848712f, -0.06787515f, -0.11797047f, 
    -0.08509129f, -0.01084379f, -0.14071563f, -0.18927307f, -0.13099261f, 0.02097343f, -0.02380685f, -0.05676518f, 
    -0.14129092f, -0.14268413f, -0.04305994f, -0.06611516f, 0.13156427f, 0.21005097f, 0.06461652f, 0.33517805f, 
    0.08476950f, 0.07140096f, 0.07965007f, -0.04867907f, 0.07612634f, -0.07908799f, -0.03409423f, -0.12095875f, 
    -0.21141683f, -0.00964587f, 0.00710623f, 0.02391873f, 0.11536914f, -0.01362967f, -0.05068875f, -0.09347392f, 
    -0.03399071f, -0.08792578f, -0.07404989f, -0.01758260f, -0.08787794f, -0.19095612f, -0.25683168f, 0.11128459f, 
    0.05545964f, -0.08457550f, 0.02322977f, 0.04840005f, -0.07539278f, -0.01799014f, -0.03418269f, -0.17194873f, 
    -0.26614690f, -0.06805989f, -0.07052971f, -0.22860360f, -0.06291546f, -0.02610897f, -0.07607308f, -0.10225017f, 
    -0.06026764f, 0.03152733f, 0.07465360f, 0.03099537f, 0.00995536f, -0.11277184f, -0.14915720f, 0.00144338f, 
    -0.07741418f, -0.06497119f, -0.10895538f, 0.01397103f, -0.14632083f, 0.04805419f, -0.02772588f, -0.15194176f, 
    0.00442886f, -0.01342218f, -0.04927550f, -0.07512681f, -0.07116038f, -0.05554275f, -0.04705009f, -0.13775919f, 
    -0.04237561f, 0.06726442f, -0.09079336f, -0.15273745f, 0.22531611f, -0.02309780f, 0.18848252f, 0.16459908f, 
    0.06997195f, -0.04089887f, -0.14576572f, -0.07058337f, 0.02410902f, 0.04276755f, -0.05850452f, -0.19830970f, 
    0.13669100f, 0.09886976f, -0.26324680f, 0.19455031f, 0.07226191f, 0.08279215f, -0.19776107f, 0.00369886f, 
    0.01533887f, -0.00248132f, -0.01788689f, -0.17138658f, 0.04194050f, 0.16424382f, 0.10491174f, 0.23242368f, 
    0.03402086f, 0.07930705f, 0.14766821f, -0.08007754f, -0.04960386f, 0.07612263f, -0.06297701f, -0.02653170f, 
    0.08967463f, -0.22015390f, -0.21182413f, -0.16637923f, 0.00048108f, -0.07917974f, -0.04228862f, -0.05499951f, 
    -0.01233928f, -0.03996878f, 0.02958973f, -0.03263362f, 0.49329728f, -0.26327127f, 0.30131444f, -0.19032681f, 
    0.05952465f, 0.05008427f, 0.01751908f, 0.00649406f, 0.01515028f, 0.14243558f, -0.05427562f, -0.04568379f, 
    -0.12391080f, -0.01927067f, 0.02252446f, -0.02853902f, 0.02502494f, 0.00212634f, -0.01838415f, -0.04785301f, 
    -0.07312725f, 0.10344236f, -0.01360943f, 0.07842780f, 0.27887431f, -0.02562116f, 0.12979083f, 0.10469217f, 
    -0.04970799f, -0.04707280f, 0.08847524f, -0.08050478f, 0.03061253f, 0.14914425f, 0.00665149f, -0.08899385f, 
    0.35379145f, 0.16717392f, 0.23655923f, 0.00418378f, -0.09608877f, 0.09566529f, 0.06007216f, -0.02361164f, 
    -0.09113024f, 0.06580872f, -0.11786656f, 0.01691865f, -0.22478896f, -0.10399179f, -0.13946585f, -0.00093216f, 
    0.01483542f, -0.00258500f, -0.12235964f, 0.05410537f, 0.10184126f, 0.09286922f, -0.13797086f, -0.01486378f, 
    0.03212132f, 0.15725975f, 0.13734144f, 0.13003799f, 0.11033077f, -0.07694702f, -0.12975521f, -0.10944255f, 
    -0.08681513f, 0.00108105f, -0.00952537f, -0.16423722f, 0.18538256f, -0.16226619f, -0.04351250f, 0.09428839f, 
    -0.03500734f, -0.15381670f, -0.14071935f, -0.13012327f, -0.06164152f, -0.17121372f, -0.01061410f, 0.00864749f, 
    0.01646106f, 0.28241348f, 0.10855356f, 0.14700599f, 0.12872113f, -0.01638135f, 0.07251100f, 0.04894906f, 
    0.02715576f, -0.03435082f, -0.01620669f, -0.05852563f, -0.31132963f, 0.13470015f, -0.04234365f, -0.06281829f, 
    0.06852799f, -0.09306800f, 0.10272476f, -0.07864805f, -0.05431750f, -0.03223097f, -0.06914212f, -0.04212391f, 
    -0.04341082f, -0.17532073f, 0.22375984f, -0.23957419f, 0.01546405f, 0.08301720f, -0.04529450f, 0.03130222f, 
    -0.17989306f, 0.15455802f, -0.00680807f, -0.07652371f, 0.09401596f, 0.21202545f, 0.18169080f, 0.16953191f, 
    0.12027940f, 0.05965514f, 0.11350364f, -0.08572710f, 0.00568821f, 0.06259499f, -0.05319122f, -0.06941405f, 
    0.15081632f, -0.38727567f, -0.14082730f, 0.03933417f, 0.15549749f, 0.09614047f, -0.03096449f, -0.10402982f, 
    0.08894393f, 0.00348071f, 0.07035714f, -0.07029719f, 0.00678348f, -0.05042796f, 0.14573595f, 0.25746125f, 
    0.13515384f, -0.03432056f, 0.06378698f, 0.01247538f, -0.10567188f, -0.15566733f, -0.07241721f, -0.07830977f, 
    -0.07168622f, -0.58694106f, 0.07029355f, -0.21631578f, 0.00144222f, -0.05018155f, -0.09614749f, -0.12508990f, 
    -0.09156708f, -0.07468372f, 0.12386051f, -0.12857519f, 0.06756593f, 0.05125431f, 0.17568699f, 0.36328930f, 
    0.06103276f, -0.03607346f, -0.10505926f, -0.09383828f, -0.14067800f, -0.06919735f, -0.08660790f, -0.09230071f, 
    0.16857077f, -0.38262013f, 0.21528584f, 0.26170665f, -0.14461659f, 0.00411621f, -0.11397897f, 0.03833749f, 
    -0.15045093f, 0.01438079f, -0.09600566f, -0.08744079f, 0.05254336f, -0.19967748f, 0.05817452f, -0.04413725f, 
    0.04674084f, 0.06507534f, 0.03752428f, -0.01692177f, -0.13710435f, 0.10940107f, -0.13973765f, -0.00079884f, 
    -0.16260290f, 0.33447447f, -0.03180453f, -0.33238789f, -0.09461107f, -0.02521372f, -0.05798607f, -0.18603395f, 
    -0.08763867f, -0.08785715f, -0.11480975f, -0.07095200f, -0.01963571f, 0.21358508f, 0.02054873f, -0.02283690f, 
    -0.00110803f, -0.02982971f, -0.09859698f, 0.11750569f, 0.03442186f, 0.12900962f, -0.00951601f, 0.02518832f, 
    -0.00440603f, 0.09693775f, 0.01779372f, 0.14358246f, 0.16067818f, -0.09299358f, -0.03305886f, 0.03702194f, 
    0.04651793f, -0.00879293f, -0.25586277f, -0.10258327f, -0.02730078f, -0.10559066f, -0.03247754f, 0.03889896f, 
    -0.02469141f, -0.20143229f, 0.00141946f, 0.00776729f, 0.14210673f, -0.15251337f, 0.11901794f, 0.06674615f, 
    0.11186033f, 0.01345751f, -0.19360876f, 0.25292632f, 0.17337768f, 0.01796210f, -0.04604826f, -0.09115233f, 
    -0.09902809f, 0.08269174f, 0.04306681f, -0.03366372f, -0.10028733f, 0.05007539f, 0.15096772f, -0.23819329f, 
    -0.12976284f, -0.11591610f, -0.01989238f, -0.01974091f, -0.14289068f, -0.05181902f, 0.02490719f, 0.13455632f, 
    -0.34239426f, 0.02018879f, 0.13995858f, -0.13643223f, -0.12428076f, 0.04891005f, -0.20430009f, -0.04757647f, 
    -0.05876458f, -0.03561872f, 0.16234979f, -0.01397127f, 0.35558814f, 0.20746760f, -0.27857336f, -0.08904494f, 
    0.08279239f, -0.06532482f, 0.01591668f, -0.04554992f, 0.11204299f, 0.16526264f, -0.04011733f, 0.05456684f, 
    0.03139887f, -0.00454763f, 0.06609251f, 0.18493333f, 0.09069704f, 0.01989158f, -0.09414486f, -0.08027644f, 
    0.05484569f, 0.11004031f, 0.04174492f, 0.10664742f, -0.23595680f, -0.20998672f, -0.52272546f, -0.13748004f, 
    -0.05031260f, -0.06356826f, -0.07660899f, -0.05517816f, 0.16114235f, -0.04272809f, 0.10224367f, -0.01525529f, 
    0.36449686f, -0.06817033f, 0.13854583f, 0.10692296f, -0.04710799f, -0.05255754f, -0.02530979f, -0.04523963f, 
    0.00491513f, -0.11366016f, 0.03999541f, -0.05683883f, -0.35509995f, -0.17129330f, -0.00564393f, -0.34243083f, 
    0.02448112f, -0.03108552f, 0.03344129f, -0.03160891f, -0.00455353f, -0.07378151f, -0.07825477f, 0.15032399f, 
    -0.24726810f, 0.07713775f, -0.39795545f, -0.27155340f, -0.00571394f, -0.05897525f, -0.25102150f, -0.00514024f, 
    0.04752377f, 0.11355787f, 0.11937895f, -0.00401065f, -0.11175828f, -0.08022159f, 0.29962656f, 0.04540174f, 
    0.08748785f, 0.02617887f, -0.09623118f, -0.15322334f, -0.12246427f, -0.16257459f, 0.08827107f, -0.15754539f, 
    0.04353666f, -0.13599615f, -0.13498956f, 0.27377990f, 0.16200638f, 0.11503324f, 0.03554197f, -0.07550309f, 
    0.00322987f, 0.08551489f, 0.19977872f, 0.18148452f, -0.10356829f, -0.00461807f, 0.08540067f, 0.18769616f, 
    -0.04973305f, -0.00179364f, 0.11320779f, -0.04585364f, 0.07619850f, -0.02305771f, -0.07207466f, 0.00515391f, 
    0.16150874f, -0.13465405f, -0.08012351f, 0.04487014f, 0.00864048f, -0.26564804f, -0.17455283f, -0.05431476f, 
    0.10907017f, -0.21972069f, -0.14672446f, 0.00800486f, -0.01134344f, -0.20835716f, 0.01464638f, -0.34109777f, 
    -0.04053105f, -0.06758016f, 0.05999829f, 0.16447388f, -0.06162534f, 0.13938212f, -0.09592608f, -0.13460374f, 
    -0.04842271f, 0.30911767f, -0.13256525f, -0.21868235f, -0.01186687f, 0.10621297f, -0.03473468f, -0.00045354f, 
    0.04233307f, 0.09663536f, 0.09276012f, 0.06752743f, -0.01449635f, 0.44295228f, -0.14045303f, 0.09342732f, 
    -0.27778098f, 0.04088537f, -0.07256395f, -0.35902640f, 0.08417124f, -0.01182825f, 0.07246418f, 0.14259613f, 
    -0.27020380f, -0.04900444f, -0.07699700f, -0.30955335f, 0.12392615f, -0.10045426f, -0.00644818f, -0.06445395f, 
    -0.01711375f, 0.02413699f, 0.00249835f, 0.12804939f, 0.05831243f, -0.26196736f, -0.09243258f, -0.39177391f, 
    -0.12768202f, -0.13587055f, -0.10889389f, 0.03777369f, 0.06346826f, 0.04579010f, 0.04417906f, 0.08947336f, 
    -0.13155171f, 0.19401944f, -0.15350853f, 0.16206852f, -0.01832143f, 0.11217537f, -0.11787629f, 0.05393963f, 
    -0.00178434f, -0.06143476f, -0.08002805f, -0.05194294f, 0.07731923f, -0.12001715f, 0.12334215f, 0.03585700f, 
    -0.06104618f, -0.10678685f, -0.27645382f, 0.13016324f, 0.14561082f, 0.17841958f, 0.08076257f, 0.01163698f, 
    -0.16249020f, -0.12021103f, 0.21804056f, 0.05186995f, -0.18580259f, -0.06110900f, 0.04665897f, -0.04886585f, 
    0.04634650f, -0.04577893f, -0.11256640f, 0.10421833f, -0.11165763f, 0.09907445f, 0.16130866f, 0.19789977f, 
    -0.12093671f, 0.05396766f, -0.05294261f, -0.03102036f, -0.02447519f, -0.17729570f, -0.00414931f, -0.37160972f, 
    0.14518711f, -0.20367171f, 0.04276175f, -0.16141488f, 0.04722649f, -0.17640474f, 0.02984706f, 0.01555198f, 
    0.09138872f, 0.07915957f, 0.00671673f, 0.10512894f, 0.01329345f, 0.09500466f, -0.16997601f, 0.00892757f, 
    0.12658177f, -0.15623365f, -0.21210676f, -0.21142973f, -0.03942448f, 0.02582295f, 0.13091542f, -0.13030340f, 
    -0.02627556f, -0.29273012f, 0.00409189f, 0.07373352f, 0.08915441f, 0.10506711f, -0.10928171f, 0.02536876f, 
    0.08950198f, 0.07896005f, 0.03152002f, 0.16500577f, -0.07373120f, 0.05753032f, 0.03077304f, -0.25444117f, 
    -0.04378625f, -0.03127549f, 0.07898119f, -0.04983249f, 0.17678200f, 0.02501619f, -0.00204380f, -0.32968047f, 
    -0.12203620f, -0.07273884f, -0.16070783f, -0.29217482f, 0.07138964f, 0.13750975f, -0.09090582f, -0.13564466f, 
    0.03431552f, 0.06720146f, 0.00324605f, 0.11873356f, 0.12033115f, -0.13304579f, 0.05972094f, -0.14289036f, 
    -0.00393273f, -0.11238300f, 0.03774808f, 0.16542657f, -0.02025594f, -0.02493281f, 0.14449666f, -0.29120988f, 
    0.14672299f, -0.20517020f, 0.26413414f, 0.24314708f, 0.12203321f, -0.15976024f, -0.14151862f, -0.08695602f, 
    -0.04778506f, -0.05858071f, 0.29135922f, -0.36139634f, 0.01798212f, 0.33965620f, -0.10543173f, 0.08752137f, 
    -0.14790644f, 0.13612697f, -0.19678491f, -0.00488623f, -0.04056478f, -0.06097370f, -0.08604221f, 0.00928016f, 
    -0.41254750f, 0.21081144f, -0.00313687f, -0.51499057f, -0.06214975f, 0.07097078f, -0.06160942f, 0.02889416f, 
    -0.01933768f, -0.03126932f, 0.18033947f, 0.17719845f, -0.74348247f, 0.10178252f, 0.12357455f, -0.13007535f, 
    0.08793502f, -0.13796589f, 0.09898898f, -0.10355112f, 0.00190689f, -0.01498597f, -0.01278427f, 0.00039558f, 
    -0.29427466f, 0.13567294f, 0.01619639f, -0.28731552f, 0.00861226f, 0.00788367f, 0.01665559f, -0.05438051f, 
    0.01411754f, 0.01777854f, -0.00953624f, -0.05893984f, -0.35105339f, -0.12904334f, 0.05555739f, -0.08804080f, 
    0.17221388f, 0.03726788f, -0.08813854f, 0.09102197f, 0.03777721f, -0.00189680f, -0.03124205f, -0.02217171f, 
    0.11844306f, -0.34726870f, 0.06197347f, 0.08009535f, -0.08452246f, 0.00545324f, 0.08894221f, -0.02439743f, 
    -0.08868894f, -0.11290380f, -0.17748386f, 0.06410025f, 0.40244463f, 0.05626339f, 0.36695358f, -0.32189089f, 
    0.01841075f, -0.15004812f, -0.08275523f, -0.07518525f, 0.03494949f, 0.11351937f, 0.04605281f, 0.12479562f, 
    -0.06043412f, -0.01650933f, -0.17197791f, -0.22356507f, 0.13867678f, 0.22065380f, -0.16181494f, -0.09358711f, 
    -0.16795279f, -0.31553981f, 0.01785010f, -0.07045892f, -0.06777754f, -0.08704205f, 0.26198211f, -0.38390771f, 
    0.10190903f, 0.09643203f, 0.00668495f, -0.04382899f, -0.04905203f, 0.04949863f, -0.14334896f, -0.05410966f, 
    0.03787898f, 0.24261230f, -0.28947386f, -0.32062167f, 0.27299073f, 0.00701513f, -0.15490122f, -0.08861313f, 
    0.04461856f, -0.09171939f, 0.05465560f, 0.09427603f, -0.00336594f, -0.21698599f, -0.11765978f, 0.20346640f, 
    0.07810209f, 0.20855264f, 0.07757965f, 0.12672220f, 0.07221217f, -0.01215483f, -0.08742640f, -0.17828886f, 
    0.13104601f, 0.17595138f, 0.21365017f, 0.07096069f, -0.14459625f, -0.03239464f, -0.17985965f, 0.30919015f, 
    0.03566635f, 0.05580423f, -0.07735061f, 0.05249673f, -0.20084418f, -0.11306114f, 0.10835270f, -0.00560404f, 
    -0.03171139f, 0.06012338f, 0.12806815f, 0.04288644f, 0.09704536f, 0.12562267f, -0.12328390f, -0.08675767f, 
    -0.30367923f, 0.13760978f, 0.00455197f, -0.38801014f, 0.03623768f, 0.09990761f, -0.17320319f, 0.05435726f, 
    -0.05531554f, -0.05922000f, -0.09011473f, -0.19861764f, 0.20379250f, -0.51511425f, -0.10472348f, -0.10404588f, 
    -0.11555986f, -0.03681917f, -0.02031928f, 0.01259200f, -0.12980846f, 0.09431623f, -0.03235995f, -0.02698679f, 
    -0.11831325f, 0.06673527f, 0.16206169f, -0.35241956f, -0.00521181f, 0.07641798f, -0.10196861f, 0.10203516f, 
    -0.00425305f, 0.05222094f, 0.13614155f, 0.02342562f, -0.21191178f, 0.05399226f, 0.03008855f, 0.27287927f, 
    0.09703700f, -0.01282973f, 0.08909666f, -0.15010808f, -0.06298916f, -0.02560231f, -0.02134886f, 0.09981596f, 
    -0.48169222f, -0.04416270f, -0.25475737f, 0.21458268f, -0.00132431f, 0.09485964f, 0.02641242f, 0.05520578f, 
    0.00213667f, -0.04113718f, 0.00665563f, -0.06733978f, 0.67536014f, 0.20655635f, -0.43371439f, 0.41563654f, 
    0.13732851f, -0.04432159f, 0.25673997f, 0.24886744f, -0.06249174f, -0.03228772f, -0.09305986f, 0.06938371f, 
    -0.09474461f, -0.32022676f, 0.28486088f, -0.10752977f, 0.11832269f, 0.04349162f, -0.18966356f, -0.19034098f, 
    0.06423099f, 0.03906233f, -0.05125657f, -0.10726031f, -0.01341672f, 0.27728286f, -0.12906699f, -0.44968045f, 
    -0.18959355f, -0.12603310f, 0.03175784f, -0.05002719f, -0.04369302f, -0.04718504f, -0.01277355f, -0.11866648f, 
    -0.11509338f, -0.09525342f, -0.19367859f, 0.21239260f, 0.03682210f, 0.04330022f, -0.09777343f, 0.12685348f, 
    -0.19377455f, 0.03248831f, -0.02924880f, 0.17090058f, -0.38388789f, 0.22291870f, -0.13124745f, 0.18164201f, 
    0.02556079f, -0.16951981f, 0.08321657f, 0.07224098f, -0.00655475f, 0.03597988f, 0.14080535f, -0.03976450f, 
    0.18642263f, -0.14374076f, -0.03849214f, 0.33679512f, -0.00925159f, -0.04996245f, -0.02255450f, 0.00152173f, 
    0.01055359f, 0.08921119f, 0.07382600f, -0.01963231f, -0.00404130f, -0.33438239f, 0.16078314f, -0.14636214f, 
    0.09517008f, -0.15355544f, -0.04212642f, 0.18327598f, -0.08885026f, 0.15073191f, -0.01140379f, 0.07067042f, 
    0.13049179f, -0.07827040f, 0.30196542f, -0.00573358f, 0.07414945f, 0.20926844f, -0.12517866f, 0.17521380f, 
    0.03428296f, 0.06148590f, -0.02664912f, 0.03526396f, 0.67301279f, -0.41976070f, -0.30481237f, -0.04961943f, 
    0.07049839f, -0.10014617f, 0.23516281f, 0.09831050f, 0.03275372f, 0.08105682f, 0.00011000f, -0.10246497f, 
    0.04892894f, -0.30922002f, 0.03927937f, -0.05722107f, -0.11645374f, -0.12380780f, 0.11923071f, -0.07385533f, 
    -0.11385483f, 0.01523835f, -0.03554333f, -0.08065859f, 0.11965180f, -0.21067801f, -0.02179378f, 0.01090149f, 
    0.07947589f, -0.01968580f, -0.18052366f, -0.21066241f, -0.04522691f, -0.13771877f, 0.11354053f, 0.23098035f, 
    0.07513306f, -0.31482276f, -0.30034822f, 0.07405596f, -0.11337919f, 0.13644506f, 0.03632462f, -0.14735572f, 
    0.06264003f, 0.15576573f, 0.06145398f, 0.13552518f, 0.21300241f, -0.00948889f, 0.20771216f, -0.07860957f, 
    0.00964635f, 0.13020012f, 0.00214641f, 0.19400804f, 0.00590228f, 0.06868260f, -0.42613199f, 0.23123646f, 
    -0.61341900f, 0.05546565f, -0.08720586f, 0.11933820f, 0.09525877f, -0.03712842f, 0.11505224f, -0.08481524f, 
    0.06147472f, 0.05866713f, -0.09401984f, 0.26361233f, -0.44235608f, 0.41427276f, 0.46556026f, -0.05860562f, 
    0.16119462f, -0.10273490f, -0.00956737f, -0.04570783f, 0.25236180f, 0.03989463f, -0.07337314f, 0.07178652f, 
    -0.14008796f, -0.07669613f, -0.15552093f, -0.15113099f, 0.24000432f, -0.08978467f, -0.01717440f, -0.06211148f, 
    0.13167830f, 0.03481494f, -0.04129741f, -0.11296648f, -0.67624366f, -0.22677837f, -0.00474056f, -0.03440595f, 
    0.06185169f, -0.11391181f, 0.07661181f, 0.03802131f, 0.00793994f, -0.09793070f, 0.06999180f, 0.09492578f, 
    -0.45618260f, -0.45270598f, -0.23896256f, -0.23622975f, 0.17930263f, 0.04419778f, -0.16584387f, -0.05413182f, 
    -0.03350142f, -0.04498663f, -0.14516731f, 0.03731152f, 0.19576505f, -0.00825139f, -0.04826320f, 0.10289062f, 
    -0.08827203f, -0.06289922f, 0.01821810f, -0.00640736f, 0.04302791f, 0.05841747f, -0.05809961f, 0.19699696f, 
    0.22004688f, 0.27460486f, 0.21636929f, -0.19277309f, 0.13521895f, -0.11771350f, 0.00148074f, 0.18547870f, 
    -0.01436216f, 0.09973267f, 0.10967234f, 0.02497921f, -0.65867120f, -0.33293626f, -0.06567510f, 0.09504929f, 
    0.12809284f, -0.09303226f, -0.05759182f, -0.01028862f, 0.00079877f, 0.03007163f, -0.03949748f, -0.02801696f, 
    -0.88474083f, -0.32494208f, -0.17862999f, -0.20058237f, 0.22134066f, -0.08491141f, -0.03929430f, -0.03347745f, 
    0.06448524f, 0.14060865f, -0.00299835f, 0.28774846f, 0.08766855f, -0.17267838f, 0.12415629f, -0.11835628f, 
    0.09642877f, -0.11716966f, 0.07453752f, 0.02265491f, 0.02656535f, 0.10449953f, 0.06623527f, -0.05588424f, 
    0.14463903f, 0.05626449f, -0.15287279f, -0.06596851f, 0.02867523f, -0.09354791f, -0.08043695f, 0.06577323f, 
    -0.04222608f, -0.06920756f, 0.06672559f, 0.10139821f, 0.35526979f, 0.18697667f, 0.03985556f, -0.11152814f, 
    -0.01328679f, 0.05604793f, 0.21235183f, -0.00965946f, -0.12035966f, -0.25983614f, -0.04136208f, 0.04523855f, 
    -0.40547368f, -0.24007668f, 0.28393084f, 0.04971007f, 0.18456614f, 0.05402736f, 0.00620358f, -0.12141973f, 
    -0.01489954f, -0.02771832f, -0.03470043f, -0.01473366f, 0.24166977f, 0.23220913f, 0.06108597f, -0.07334138f, 
    -0.22238272f, -0.28072944f, 0.01368792f, -0.08853209f, -0.09184030f, -0.24533121f, -0.06214420f, -0.06021526f, 
    -0.19066940f, -0.14562209f, -0.05997578f, -0.28643230f, 0.08194822f, 0.04643808f, -0.02658400f, 0.01800722f, 
    0.02519383f, 0.11246678f, 0.10421507f, 0.21531479f, 0.20181449f, -0.10617129f, -0.17093819f, 0.05122281f, 
    -0.12488845f, 0.02585939f, -0.11131410f, 0.09744860f, 0.01293080f, 0.09648468f, 0.08023465f, 0.07004125f, 
    -0.68021971f, 0.00073159f, -0.03953455f, -0.24941418f, 0.16971421f, -0.09744132f, -0.14008634f, -0.23229074f, 
    -0.05398296f, -0.35162908f, 0.00695128f, -0.12074165f, 0.22234358f, 0.00057619f, 0.02456659f, 0.17493702f, 
    -0.10812324f, 0.13028130f, 0.09038854f, -0.03505408f, 0.11297435f, 0.08570433f, 0.01006617f, 0.01087904f, 
    -0.13761686f, 0.06160085f, 0.01308231f, -0.25192568f, 0.12233409f, 0.09913802f, 0.03780091f, 0.08896624f, 
    -0.04560259f, -0.09164757f, -0.07993054f, -0.05390098f, -0.03472870f, -0.18291266f, 0.35844964f, 0.03838888f, 
    -0.07889332f, -0.05149883f, -0.06556056f, 0.09591785f, 0.12319431f, 0.10065304f, 0.09542317f, -0.11550533f, 
    0.19609080f, 0.16465150f, -0.01657197f, -0.06193604f, 0.22295871f, 0.11355191f, 0.06698237f, -0.09429131f, 
    0.01009339f, 0.23368804f, -0.02130705f, 0.11490921f, 0.32491839f, 0.38263014f, 0.18831719f, -0.09797953f, 
    0.07985491f, 0.12367889f, -0.03916049f, 0.16148615f, -0.10990769f, 0.15592918f, 0.01527330f, -0.06509059f, 
    0.15752430f, -0.10558093f, 0.03141468f, -0.02163201f, -0.04082088f, -0.14057951f, 0.17261367f, -0.18327889f, 
    0.02757436f, -0.13722868f, -0.14149469f, -0.06436367f, 0.20151635f, -0.00132008f, -0.06090515f, 0.06371024f, 
    -0.02658563f, -0.04973919f, 0.04626097f, 0.18883032f, 0.10024758f, 0.11100079f, 0.04435081f, 0.07159054f, 
    0.32347268f, 0.10033229f, -0.07983073f, 0.22463998f, -0.16324706f, -0.18342257f, -0.09434745f, 0.11087719f, 
    -0.06338932f, -0.04745974f, -0.07025133f, -0.05571141f, 0.28811410f, 0.13057119f, -0.08954068f, -0.06262880f, 
    -0.20303477f, 0.00962543f, -0.03938045f, -0.06088464f, 0.00556629f, 0.00310462f, -0.00462683f, -0.17274860f, 
    -0.46128657f, 0.10253322f, -0.08528396f, 0.03150966f, -0.06329206f, -0.24456392f, -0.08401757f, -0.02109779f, 
    0.04238452f, -0.02015000f, 0.10974605f, 0.07908066f, 0.04225887f, 0.06201252f, 0.04962612f, -0.06197707f, 
    -0.10758471f, -0.00618355f, -0.19331461f, 0.07307027f, -0.14721420f, -0.01736137f, 0.01705137f, -0.08432284f, 
    -0.23562916f, 0.13236977f, -0.12971577f, -0.17790812f, 0.04097607f, -0.00337250f, -0.00638511f, 0.14222544f, 
    0.01112448f, 0.15507983f, 0.02931078f, 0.11362149f, -0.03054279f, 0.12923846f, -0.08850770f, 0.04419145f, 
    -0.02234008f, 0.08649314f, -0.10758077f, -0.10316717f, 0.09621452f, 0.25455037f, -0.08536925f, 0.04200689f, 
    0.27384675f, 0.23128830f, 0.04308451f, -0.32714632f, -0.00194788f, 0.06270147f, 0.04048820f, 0.05148867f, 
    0.07721145f, 0.06004736f, -0.09888467f, 0.09481631f, 0.27611598f, 0.03920300f, -0.05633620f, 0.16127114f, 
    -0.09234261f, -0.05539051f, 0.11848802f, 0.06339082f, 0.18654439f, 0.17510547f, 0.20326211f, 0.13771985f, 
    -0.59377182f, -0.32025668f, -0.09645581f, -0.41268557f, -0.05667382f, -0.19770913f, -0.21869421f, 0.02336872f, 
    0.05559126f, -0.05560626f, -0.03877196f, -0.10395055f, -0.38536793f, -0.24033582f, -0.25747555f, 0.02602067f, 
    -0.06887699f, 0.05576741f, 0.11188712f, -0.01990969f, 0.11718980f, -0.11741902f, -0.04396727f, -0.06109014f, 
    0.01928521f, -0.49419871f, -0.04592622f, 0.12354159f, -0.05959129f, 0.15653966f, -0.07106549f, -0.02841585f, 
    0.01911959f, 0.07697105f, -0.09998323f, 0.04134252f, -0.20967017f, 0.10049961f, 0.03838989f, -0.08706313f, 
    0.20553124f, 0.10203864f, 0.00076346f, -0.01007337f, 0.04168046f, 0.12395616f, 0.01552925f, -0.07529333f, 
    0.49953958f, 0.04358189f, -0.45068988f, -0.19001469f, -0.05976114f, -0.06287906f, -0.03799900f, -0.05205300f, 
    0.08183014f, 0.05358323f, 0.05153148f, 0.04266243f, 0.14435238f, -0.04104421f, -0.01693865f, 0.10313780f, 
    -0.20572768f, 0.01515101f, -0.15819325f, -0.17428651f, 0.09074920f, -0.08181369f, -0.05658695f, -0.18251182f, 
    0.40287519f, 0.16704322f, -0.14482762f, 0.11839285f, -0.07418079f, -0.00964374f, 0.10794009f, 0.02108283f, 
    0.03985405f, -0.14462079f, -0.20423761f, -0.18184984f, 0.53681129f, -0.49634597f, -0.12745866f, 0.12536351f, 
    0.07912745f, -0.12441004f, -0.17675309f, -0.02987564f, 0.12616333f, 0.05415767f, -0.02500509f, 0.04657925f, 
    0.35340032f, -0.18067370f, -0.16388041f, -0.00252722f, -0.03847455f, -0.11835422f, 0.13830464f, 0.04725031f, 
    0.11042411f, -0.07003868f, -0.06417917f, -0.00521258f, 0.25175881f, -0.03909113f, -0.45082146f, 0.11563703f, 
    0.07884388f, -0.21284954f, 0.01606142f, 0.05808315f, -0.05400404f, 0.08379414f, -0.01500234f, -0.06208132f, 
    -0.29816589f, -0.32126689f, -0.04917139f, -0.31935784f, -0.06234290f, 0.08917378f, 0.09153543f, 0.01945101f, 
    -0.14576651f, 0.00976710f, -0.02101414f, -0.02645809f, -0.50388491f, 0.30831790f, -0.39026281f, -0.38890016f, 
    -0.14616585f, 0.03782406f, 0.02226368f, 0.09713852f, -0.03145783f, 0.05303237f, 0.08479053f, 0.01648394f, 
    0.04697743f, 0.41311777f, -0.01652317f, 0.12856998f, -0.07057747f, 0.02240650f, -0.18369387f, -0.02964707f, 
    0.06767635f, 0.12880760f, -0.10442445f, -0.00674792f, -0.14872362f, -0.03803926f, -0.16830926f, -0.02914770f, 
    0.07949969f, -0.05318477f, 0.09204879f, -0.11626016f, 0.22176547f, -0.02915997f, -0.02707278f, -0.07664364f, 
    0.42952010f, -0.06093342f, -0.39953664f, 0.05619775f, 0.05772587f, -0.01234104f, -0.06811973f, -0.06941929f, 
    -0.13894936f, 0.00553284f, -0.04883667f, 0.09879184f, -0.35879362f, 0.37999526f, -0.10506013f, 0.19455348f, 
    0.16901310f, -0.11937410f, 0.10750447f, -0.04701074f, -0.01766084f, -0.12856255f, 0.07161868f, -0.03003964f, 
    0.08553555f, -0.24813864f, -0.16455491f, -0.01150258f, -0.15700296f, -0.00711167f, 0.10648283f, -0.09503152f, 
    0.05788340f, -0.00537151f, -0.02829248f, -0.04848251f, -0.32256800f, 0.01638584f, 0.08375691f, 0.13046135f, 
    -0.09726291f, -0.09458987f, -0.25887242f, -0.22739883f, -0.02548583f, 0.10582934f, 0.06672449f, -0.10965125f, 
    -0.05935151f, 0.20157541f, 0.02839720f, 0.09524938f, 0.20259750f, 0.00842577f, 0.09612703f, -0.23847099f, 
    -0.11075983f, 0.07215314f, -0.10998534f, 0.10394344f, -0.44474614f, -0.39820650f, -0.17058866f, 0.05949600f, 
    0.00706752f, -0.11382276f, -0.00555963f, 0.12681882f, -0.19814579f, 0.11012339f, -0.09094630f, -0.25699601f, 
    0.27670267f, 0.13372697f, -0.10207459f, -0.03732255f, -0.08726490f, -0.01984404f, -0.08148669f, -0.03477742f, 
    -0.04187606f, -0.08542939f, 0.05052525f, -0.06439396f, -0.00612429f, -0.01569972f, -0.22077721f, 0.10839415f, 
    0.18308209f, 0.03813080f, 0.06320745f, 0.04989360f, -0.03571003f, -0.09142653f, -0.04726209f, -0.08821385f, 
    0.21491621f, 0.21800563f, -0.01463799f, -0.02567143f, -0.02487312f, -0.10064583f, 0.09170880f, -0.07869598f, 
    -0.00074755f, 0.05379415f, 0.07499900f, 0.13353002f, 0.35431063f, -0.06535162f, 0.15233029f, 0.40260458f, 
    -0.02191421f, 0.16879088f, 0.01053466f, -0.00873755f, 0.02740399f, 0.00694522f, -0.07093936f, 0.12225720f, 
    0.22068146f, 0.10229319f, 0.18487158f, -0.20444745f, 0.02173172f, -0.23659478f, 0.07938094f, 0.04428206f, 
    -0.12998202f, 0.01837108f, 0.06230351f, 0.08537713f, -0.13733256f, -0.17507215f, -0.02575784f, 0.09008348f, 
    -0.17171033f, -0.11392033f, -0.04288392f, 0.07574707f, -0.02200238f, -0.01446116f, 0.12057682f, -0.12664004f, 
    0.13425133f, 0.12109753f, 0.37596121f, 0.00228375f, -0.17092802f, 0.09918834f, -0.10497507f, -0.00701394f, 
    -0.01330622f, -0.10455661f, 0.03353160f, -0.00042313f, -0.11049516f, -0.10443842f, -0.06490292f, 0.21293159f, 
    0.01448448f, 0.04615531f, 0.07708176f, 0.02464362f, -0.23973419f, -0.05495843f, 0.04470903f, -0.25568417f, 
    0.19179802f, 0.10422707f, 0.09415227f, -0.10316460f, 0.05786544f, 0.20029557f, -0.05277805f, 0.10218524f, 
    0.17212267f, -0.09571280f, -0.19712886f, -0.07217549f, -0.08413282f, 0.36848980f, -0.15225081f, 0.18233661f, 
    -0.05524217f, -0.20578565f, -0.21179001f, 0.18336146f, 0.15033270f, -0.09693174f, -0.08002701f, -0.01724784f, 
    -0.29992440f, 0.17453657f, 0.06221194f, 0.14094573f, 0.09286738f, -0.13836738f, 0.10607183f, 0.14823417f, 
    -0.01537104f, -0.08835529f, 0.11261729f, -0.04036826f, -0.30246162f, 0.10702682f, 0.12355261f, 0.21956931f, 
    -0.11307442f, 0.17763101f, 0.00054083f, -0.11401764f, -0.01892020f, -0.09138691f, -0.05325625f, 0.21902901f, 
    0.08163150f, -0.33514598f, 0.01221486f, -0.57272923f, -0.03756926f, -0.02991065f, 0.06856800f, 0.00017036f, 
    0.07136698f, 0.01114682f, -0.10373887f, -0.01418996f, -0.02294764f, -0.30993843f, -0.07411075f, 0.09014029f, 
    0.15005934f, 0.05282120f, 0.07437376f, -0.00779102f, -0.00458710f, 0.09822025f, 0.03383653f, 0.01157446f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13139294f, -0.01856367f, -0.06399198f, 0.00851661f, 0.03755183f, 0.01824464f, 0.01250694f, -0.03592050f, 
    -0.07858247f, 0.07019298f, 0.12273583f, 0.08774739f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
