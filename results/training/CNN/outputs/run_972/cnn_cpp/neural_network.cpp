#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46875247f, -0.65706372f, -0.04134882f, -0.93241978f, -0.72286719f, -0.93434983f, -0.18088982f, -0.26980940f, 
    -0.65362215f, -1.32934499f, -0.38670424f, 0.47108734f, 0.22955467f, -1.42083001f, -0.57599521f, 0.27912250f, 
    0.69669163f, 0.25666901f, -0.63747311f, -1.26186359f, -0.50920767f, 0.84552670f, 1.08068979f, -0.29161838f, 
    0.41310671f, -0.10725011f, 0.10511779f, 0.11104137f, 1.37669635f, 0.33146483f, -1.13814044f, -0.87287825f, 
    -0.52913386f, 0.49769256f, -0.05973435f, 0.50538170f, -0.44456172f, 0.05253669f, 0.52996069f, -0.93133581f, 
    -0.43953258f, 1.33132589f, -0.73902965f, -0.16446245f, 0.85889590f, -1.16078925f, -1.39665210f, -0.78226018f, 
    0.59321505f, 0.78531069f, 0.21511488f, -0.03639458f, -0.38733780f, 0.37246498f, 0.85094237f, -1.49223053f, 
    0.33564711f, -1.11776495f, -0.39695969f, -0.23371097f, -0.59615922f, -0.71277815f, 0.76216757f, 0.04061295f, 
    0.65116376f, 0.90268093f, -0.37736124f, -1.06014502f, -0.90367252f, -0.81120801f, -0.57449901f, -0.75625777f, 
    0.50306547f, -0.00377793f, -0.66790223f, 0.30772901f, 1.18674791f, 0.60772574f, -0.69631523f, 0.09928823f, 
    -0.63434303f, 1.59600019f, -1.38611996f, -1.21894193f, 0.22461399f, 0.21252029f, 0.47107404f, -0.00743917f, 
    -0.12481263f, 0.08935448f, -0.18120441f, -1.49429882f, -0.44867578f, -1.16556799f, -0.92507780f, -0.91263485f, 
    0.60214251f, -0.00312719f, -0.03280665f, 0.59966987f, 0.08956704f, -0.16695912f, 0.57809365f, 0.71299297f, 
    -0.21606012f, 0.45911410f, 0.21889567f, -0.07661103f, -1.46624529f, -1.27318287f, 0.14639261f, -0.58184129f, 
    0.15240654f, 0.01639885f, -0.50515258f, -0.40435329f, -1.17085481f, 0.88283789f, 0.47556517f, 0.68760389f, 
    0.18208501f, -0.42228580f, 0.38973814f, 0.32214451f, -0.07131481f, 0.52149445f, -1.24856734f, 0.97423810f, 
    0.19867794f, -0.76148278f, 0.85756445f, 0.36575934f, -0.19117570f, -0.26146749f, 0.19000930f, -0.70142800f, 
    -0.57607925f, -1.17981350f, 0.48105440f, -0.41649693f, -0.79610628f, 0.40920261f, -0.34679952f, 0.77498317f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.46123704f, 0.32952484f, 0.23287798f, 0.37772891f, 0.57731825f, 0.08704285f, 0.23534560f, -0.02091559f, 
    0.62813050f, 0.50816357f, -0.16698235f, 0.45207229f, 0.00232946f, 0.00865542f, 0.38012335f, 0.11820499f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.39720634f, 0.24156882f, 0.01013059f, -0.45047978f, -0.10434749f, 0.04824687f, 0.09300573f, 0.09715802f, 
    -0.03547868f, -0.00714930f, 0.01845749f, -0.04870314f, 0.01384253f, -0.06708620f, -0.19865847f, -0.08698300f, 
    -0.06999857f, -0.04490030f, 0.00615571f, -0.13617902f, 0.51560891f, 0.47122955f, 0.32379821f, -0.32211906f, 
    0.06252676f, -0.06145432f, -0.01669405f, -0.07805777f, 0.00844213f, -0.03121599f, 0.21038522f, -0.07555285f, 
    0.00077613f, 0.04584192f, -0.00254312f, 0.01622749f, -0.06036393f, -0.09480875f, -0.06419815f, -0.02627860f, 
    0.38232040f, 0.05464154f, -0.68121111f, 0.05553138f, 0.04797635f, 0.18402393f, 0.09460758f, 0.13622198f, 
    -0.17160212f, -0.02101236f, 0.02166265f, -0.02908081f, -0.10183246f, 0.06255682f, 0.09628540f, -0.02055609f, 
    0.13210368f, -0.02245998f, -0.01893024f, 0.00262907f, -0.04347967f, 0.07601799f, 0.10115484f, -0.23975863f, 
    -0.11468832f, -0.28786537f, -0.01044252f, -0.18574412f, 0.02566398f, -0.04171370f, -0.01734045f, 0.00551428f, 
    -0.00740484f, -0.01824496f, -0.04953939f, -0.04065275f, -0.00572656f, 0.00088176f, -0.21403113f, -0.10679403f, 
    -1.06367707f, -0.13533369f, 0.40720862f, 0.06878233f, 0.00742650f, -0.20905513f, -0.10496466f, -0.16349694f, 
    -0.10407393f, -0.11834289f, 0.04228771f, -0.18263437f, -0.04029883f, -0.08840197f, -0.04498654f, -0.10947985f, 
    -0.07937329f, -0.11260837f, -0.16737141f, -0.37514740f, 0.48669910f, 0.05097695f, -0.25688189f, -0.14841963f, 
    0.03569805f, 0.25036728f, 0.19561473f, 0.21293387f, -0.00422431f, -0.03287868f, -0.06426966f, -0.03478197f, 
    -0.00791466f, 0.06411897f, 0.07182516f, 0.01077568f, 0.07619791f, -0.00392658f, 0.07942265f, 0.01503796f, 
    0.22029439f, 0.16887508f, 0.27100202f, -0.49777782f, -0.23691198f, 0.04097757f, -0.03144687f, 0.03963758f, 
    -0.39294407f, -0.09411208f, -0.08786503f, -0.03096595f, -0.03749293f, 0.08776358f, -0.04312704f, -0.21145017f, 
    -0.09252903f, -0.07166082f, 0.03336221f, -0.21992245f, -0.04676054f, 0.41948417f, -0.07636586f, -0.41466346f, 
    0.02671407f, -0.21359031f, -0.33889824f, -0.28585085f, 0.10090384f, 0.02424912f, 0.09973709f, -0.08634600f, 
    0.02595283f, 0.06176431f, 0.03602333f, 0.13454536f, -0.02741095f, 0.12200655f, 0.24582002f, 0.10001952f, 
    -0.06011336f, -0.42857817f, -0.38571301f, 0.15351613f, -0.22802496f, 0.04157928f, 0.03001877f, -0.00321004f, 
    -0.03881527f, 0.09888974f, 0.03154834f, 0.15111558f, -0.22284913f, 0.00352883f, -0.23123398f, -0.11366810f, 
    0.01854086f, 0.04270760f, 0.00133788f, 0.14066157f, 0.16536960f, 0.04548360f, -0.80247706f, 0.10287985f, 
    -0.01809881f, 0.10415162f, -0.05470850f, 0.00929365f, -0.21626671f, 0.04226537f, -0.16081719f, -0.05983916f, 
    -0.24937002f, -0.06919657f, -0.09369275f, -0.04338656f, 0.06570507f, -0.05046715f, -0.04064658f, 0.02825868f, 
    0.36920699f, 0.36387056f, 0.04441625f, -0.63472706f, -0.03821791f, 0.24527064f, 0.17610404f, 0.04091351f, 
    -0.08116614f, 0.14044385f, -0.01559650f, -0.01134241f, -0.06128310f, 0.03631214f, 0.04870197f, -0.00189824f, 
    -0.07589259f, -0.07518779f, 0.08724454f, 0.10336347f, -0.01644052f, -0.03705760f, -0.10442048f, 0.11968452f, 
    0.08586083f, 0.01401570f, -0.03678576f, 0.04807711f, 0.09354229f, 0.02961322f, -0.32836574f, -0.04647147f, 
    -0.29755637f, -0.24568717f, -0.37352204f, -0.10428949f, -0.00275472f, -0.10524941f, -0.03337128f, 0.04216893f, 
    0.66308188f, 0.19496498f, 0.19116473f, -0.26398772f, -0.07601027f, 0.14659795f, 0.09644113f, 0.34653974f, 
    0.24968897f, 0.03606252f, -0.07759359f, 0.00724741f, -0.03653542f, -0.07898896f, -0.15094630f, 0.14773650f, 
    -0.18311828f, -0.07373155f, -0.02012580f, -0.00896392f, -0.03118550f, -0.00080392f, -0.07104667f, 0.06908626f, 
    0.10736369f, 0.02940717f, 0.02299733f, 0.04484235f, 0.07256676f, 0.06390778f, -0.01770773f, 0.06105894f, 
    0.04187446f, -0.01860359f, 0.03579998f, -0.22298878f, -0.08118689f, -0.15723053f, 0.00750624f, -0.05790306f, 
    -0.99300545f, -0.46932599f, 0.38942352f, -0.01329859f, 0.05770333f, -0.08782560f, -0.17572834f, -0.07969816f, 
    -0.00304410f, -0.08425166f, -0.17388155f, -0.03155167f, 0.06615999f, -0.10138856f, -0.10599265f, -0.30252150f, 
    -0.22415341f, -0.03481300f, -0.38312083f, -0.19167161f, 0.43871853f, 0.40709397f, -0.25699043f, -0.33427936f, 
    -0.11325853f, 0.09271519f, 0.15202919f, 0.17847373f, -0.25290349f, -0.16490546f, 0.03702502f, -0.02418375f, 
    0.00656875f, 0.02682378f, 0.06138644f, -0.05219575f, -0.05454691f, -0.04860163f, 0.14468360f, -0.03363518f, 
    0.00329134f, 0.18431178f, -0.18350661f, -0.06166068f, 0.21810658f, 0.14281474f, 0.00802302f, -0.05090947f, 
    0.05729792f, 0.06580221f, -0.02810069f, 0.05095567f, 0.09806399f, -0.02658911f, 0.16955283f, -0.02399607f, 
    0.00962533f, 0.09152959f, -0.44196388f, -0.01472583f, -0.67812747f, 0.08461352f, -0.26180142f, 0.31392145f, 
    0.09895702f, 0.04575161f, 0.13567156f, 0.07925612f, 0.37359485f, -0.09841769f, -0.15860994f, -0.05098545f, 
    0.02283648f, 0.04093636f, 0.01821668f, -0.11012454f, 0.05600424f, 0.05758645f, -0.09815743f, 0.11641088f, 
    0.41070244f, -0.77404368f, -0.43036905f, -0.16693276f, -0.18964003f, -0.07067045f, -0.07253938f, 0.10564777f, 
    0.07186528f, -0.19219591f, 0.00187983f, -0.16040793f, 0.21914694f, -0.07715210f, -0.09608745f, 0.07182229f, 
    -0.04597208f, 0.01837896f, -0.07120408f, -0.07324618f, -0.06832717f, -0.12804209f, 0.07911750f, -0.18965515f, 
    -0.04410033f, 0.14714202f, -0.13058254f, -0.35387483f, 0.00285402f, 0.10258663f, -0.09070977f, -0.03917267f, 
    0.06338292f, 0.20012787f, 0.10353146f, -0.00157252f, 0.02221192f, 0.01047404f, 0.11675902f, 0.15447661f, 
    -0.36395717f, 0.17317577f, 0.13945980f, 0.03899113f, 0.13317199f, -0.13979973f, -0.13452743f, 0.31771487f, 
    -0.12515609f, 0.07476103f, 0.17369261f, 0.20166163f, 0.06596472f, 0.08994975f, -0.12044760f, 0.02185963f, 
    0.22397338f, 0.09225255f, 0.12736200f, 0.08751576f, -0.14900757f, -0.24690199f, 0.23952742f, 0.05445806f, 
    -0.10043307f, 0.08643527f, 0.01894899f, 0.33387834f, -0.06733704f, -0.30595821f, 0.12880614f, -0.10506607f, 
    -0.01601901f, -0.14817730f, -0.11703891f, 0.07810993f, -0.00235994f, -0.06589612f, 0.02669833f, -0.02981556f, 
    -0.46803814f, 0.29809386f, -0.30177709f, -0.17808476f, -0.18794237f, -0.11886434f, 0.05130423f, -0.14843048f, 
    -0.26262978f, 0.22686945f, 0.02056683f, 0.06268121f, 0.07042051f, -0.09685322f, -0.03299967f, -0.01157573f, 
    -0.02228532f, 0.07179386f, -0.32119924f, -0.21656272f, -0.06139174f, -0.11824935f, -0.55621195f, -0.33714649f, 
    -0.46004432f, 0.10861770f, -0.20884192f, -0.27599168f, -0.08653302f, -0.22977331f, -0.08358226f, 0.02764176f, 
    0.04423608f, -0.01593334f, 0.04237357f, -0.15547131f, -0.32160509f, -0.22643191f, -0.09198872f, -0.26061365f, 
    0.76685828f, -0.02102483f, 0.32405362f, 0.30577385f, 0.06259826f, -0.07466393f, 0.03266304f, -0.05170136f, 
    -0.05331981f, -0.07272346f, 0.27117756f, 0.00080245f, -0.00452121f, -0.27200642f, 0.00695023f, 0.17013298f, 
    -0.05567726f, -0.30635077f, -0.03889790f, -0.07033782f, 1.28431356f, 0.07994371f, -0.11344781f, 0.17013733f, 
    -0.57046258f, 0.01887250f, 0.17533050f, 0.12273168f, -0.20831355f, 0.12214692f, 0.26376635f, -0.12681314f, 
    0.07248059f, -0.14662029f, -0.00280958f, -0.01855092f, 0.09435104f, 0.01869576f, -0.12924090f, 0.05865331f, 
    -0.30153808f, 0.38319644f, -0.03211466f, 0.20467754f, 0.37654045f, -0.24118020f, -0.08941912f, 0.01226269f, 
    -0.10058852f, 0.06695787f, 0.06348661f, -0.04074112f, 0.03668456f, 0.04789083f, 0.08352634f, -0.00176926f, 
    -0.07077064f, 0.09510913f, -0.26601306f, 0.10681036f, 0.25239918f, -0.01871261f, 0.01974889f, 0.09592862f, 
    -0.02319952f, -0.07215610f, -0.08649063f, -0.10082775f, -0.06616361f, -0.11992309f, 0.02382178f, 0.18306907f, 
    0.01782380f, 0.03822464f, 0.03209194f, -0.02158886f, -0.06267715f, -0.10728832f, -0.00433184f, -0.04066372f, 
    -0.12979099f, 0.26253721f, 0.26285261f, -0.08994351f, 0.22564276f, 0.21496271f, -0.00624070f, -0.15597813f, 
    0.17864153f, 0.11937653f, 0.06544065f, -0.00434690f, -0.06517112f, -0.02785369f, -0.04254150f, 0.02171517f, 
    -0.07062348f, -0.14672706f, 0.00284256f, -0.10140153f, 0.13149609f, 0.16540277f, 0.05934292f, 0.04532002f, 
    0.17868879f, -0.11489698f, -0.13314666f, -0.12739776f, -0.08287358f, -0.05011801f, -0.02403292f, 0.01595572f, 
    0.00648800f, 0.08072514f, -0.04042960f, -0.12095474f, 0.12336602f, -0.02881291f, 0.03828393f, 0.00005226f, 
    -0.46290639f, -0.92976165f, 0.09587918f, -0.02191418f, 0.25078371f, -0.05048759f, -0.10635711f, 0.07741565f, 
    -0.10616482f, 0.00718054f, 0.13176179f, 0.09065371f, 0.01003354f, -0.00984990f, 0.01982937f, 0.06428953f, 
    0.06612132f, -0.06369191f, 0.09395356f, 0.15247145f, -0.35310340f, 0.06047061f, 0.01151727f, 0.07737029f, 
    -0.12371822f, 0.14236565f, -0.01950440f, 0.18153255f, -0.06079854f, -0.20186678f, -0.09574378f, -0.02411092f, 
    0.10049910f, -0.09848273f, -0.06854163f, -0.03557927f, 0.05761763f, -0.02261027f, -0.04307633f, 0.09449165f, 
    -0.16421294f, -0.41033989f, -0.24630006f, 0.14111754f, -0.49553716f, 0.21848524f, 0.00446874f, -0.03316373f, 
    0.18665753f, -0.01969614f, -0.02190480f, -0.04463565f, 0.01521156f, 0.06608255f, -0.15245381f, -0.04964247f, 
    -0.02789978f, 0.02953629f, -0.11771502f, 0.24168321f, 0.27691773f, -0.09338544f, -0.39694372f, 0.29607210f, 
    -0.14028661f, 0.16219440f, 0.08182111f, -0.21541776f, 0.05116057f, -0.05652449f, 0.05672229f, 0.12527609f, 
    -0.04282070f, 0.08945775f, -0.05749483f, -0.00138075f, -0.04067689f, 0.05616879f, 0.00107455f, 0.01444592f, 
    -0.06663462f, -0.23070309f, 0.77319932f, 0.12520295f, 0.35442504f, -0.01897404f, -0.06936239f, 0.14524375f, 
    0.28468108f, -0.25634465f, 0.06266847f, -0.05087556f, -0.01370536f, -0.16894034f, 0.10960289f, 0.04623176f, 
    -0.08339687f, -0.06923170f, 0.11350967f, -0.11547181f, -0.28481209f, -0.28982714f, 0.24408591f, -0.26262504f, 
    -0.10734843f, 0.07626520f, -0.09843343f, -0.38824555f, -0.36587092f, 0.09760936f, 0.08856590f, -0.04643672f, 
    0.04240551f, 0.06790229f, -0.08140668f, 0.00654642f, -0.03968789f, -0.12533277f, -0.13733068f, -0.09908792f, 
    0.24978746f, 0.07113043f, -0.57119548f, 0.07921022f, 0.26937160f, -0.43770501f, 0.20943414f, 0.10230023f, 
    -0.18466014f, -0.12701149f, 0.00655534f, -0.11148576f, 0.06301096f, -0.11108615f, -0.15010077f, -0.01260187f, 
    -0.09401882f, 0.11922426f, -0.14074206f, 0.00752601f, -0.08923510f, 0.06972606f, 0.97229689f, 0.40503889f, 
    0.39194313f, -0.14381218f, -0.12244206f, 0.06379411f, 0.17245969f, 0.00404932f, 0.05465201f, 0.00133179f, 
    0.08317226f, -0.18326946f, 0.10617199f, -0.00044123f, 0.01811885f, 0.10155737f, 0.00830772f, -0.04354076f, 
    -0.13469280f, 0.12141743f, -0.68055809f, 0.10828806f, -0.21679851f, -0.15021914f, -0.11959695f, 0.08596837f, 
    -0.33792329f, 0.17665157f, -0.00333870f, -0.03262401f, 0.02825078f, -0.14584464f, -0.09370614f, -0.06441569f, 
    0.06899201f, -0.13178764f, -0.00201974f, -0.00345729f, -0.45813528f, 0.14782968f, 0.29189223f, -0.50077671f, 
    -0.10343017f, -0.01381463f, 0.02361008f, -0.07416800f, 0.10482587f, 0.01120384f, 0.00423758f, 0.01782844f, 
    0.08649036f, -0.03504906f, -0.02362074f, -0.05174423f, 0.13631763f, 0.31192622f, 0.10669246f, 0.07203986f, 
    -0.05990754f, -0.17840444f, 0.27862257f, -0.12120064f, 0.11550373f, 0.01093496f, -0.12770911f, 0.00748563f, 
    -0.00737622f, 0.17086028f, 0.05569657f, 0.01401717f, -0.12026593f, 0.04233310f, 0.14775589f, 0.16176018f, 
    0.08151597f, -0.00450724f, 0.19417325f, -0.08040243f, -0.32942212f, 0.68680066f, 0.57262635f, 0.12314750f, 
    0.21462587f, -0.08748146f, 0.05068843f, -0.04284450f, -0.25032708f, 0.10249671f, 0.04006677f, 0.02849230f, 
    0.20200329f, -0.00946211f, 0.02207254f, -0.02754233f, -0.00043161f, -0.08512335f, 0.11169828f, -0.14373721f, 
    -0.78778332f, -0.64808184f, -0.75026107f, 0.02673663f, -0.95466679f, 0.10520004f, 0.05273537f, -0.20490164f, 
    0.16285492f, -0.24652758f, -0.00274839f, 0.06895882f, 0.01228739f, 0.06257883f, -0.06171515f, 0.03624773f, 
    0.01621640f, -0.07933403f, -0.14910784f, 0.04972568f, -0.06643260f, -0.00133487f, 0.03891332f, -0.14590849f, 
    0.11593423f, 0.02583446f, 0.01257883f, 0.05247538f, 0.11188935f, 0.05304309f, -0.05039428f, -0.21580788f, 
    -0.00416542f, 0.09079807f, 0.04932418f, 0.09603473f, -0.03307218f, -0.10115832f, 0.13146661f, -0.00464794f, 
    0.02528938f, -0.01954212f, 0.57489002f, 0.39710733f, 0.50078964f, -0.06400424f, -0.03165935f, -0.13014983f, 
    0.08654147f, 0.10194313f, -0.05763063f, -0.04655096f, -0.09753920f, 0.06046371f, 0.00663243f, -0.10039698f, 
    0.07093035f, -0.10262834f, -0.35726434f, 0.21977387f, -0.37890419f, -0.12538840f, -0.04206502f, -0.12815867f, 
    -0.00372169f, -0.03061189f, -0.13578363f, -0.02025047f, 0.06106652f, 0.08400127f, 0.06877559f, -0.11725096f, 
    0.03816492f, 0.04599987f, -0.06513058f, -0.25749961f, -0.38688815f, 0.03133296f, -0.04612175f, -0.00218402f, 
    0.39578587f, -0.11564353f, -0.30741572f, -0.20604661f, 0.15957765f, 0.07381973f, -0.04203928f, -0.02561700f, 
    -0.06158603f, -0.00222047f, -0.03878004f, -0.01613640f, -0.06039731f, -0.00781405f, -0.00083203f, 0.05449808f, 
    0.12724274f, -0.05546377f, 0.27127421f, 0.05245227f, -0.05819052f, -0.78747422f, 0.10607272f, 0.56073928f, 
    -0.25256729f, 0.10579287f, -0.33937114f, 0.01717008f, 0.07703092f, -0.37058410f, 0.03974566f, 0.10414468f, 
    0.06347279f, -0.06835942f, 0.00130169f, -0.01001425f, -0.02763823f, -0.06043691f, 0.02112713f, -0.12953117f, 
    0.05658142f, -0.10545800f, -0.27965057f, -0.11482104f, 0.28160805f, -0.14532292f, -0.01011034f, -0.04002238f, 
    -0.10238321f, -0.05015143f, -0.05496480f, -0.07920873f, -0.10778989f, -0.10264148f, -0.22495134f, -0.03084950f, 
    -0.05200515f, 0.06509279f, -0.13309796f, 0.01869033f, 0.06116436f, 0.14855304f, -0.59172273f, -0.27788827f, 
    0.49416351f, 0.18580335f, -0.01265080f, -0.00363268f, 0.30265787f, -0.09622338f, 0.11320601f, 0.06114210f, 
    -0.37630475f, 0.20152688f, -0.12773854f, 0.05471305f, -0.21086907f, 0.26896653f, -0.06417474f, -0.05509794f, 
    -0.44746095f, 0.66599059f, -0.23559576f, -0.14732715f, 0.38703865f, 0.40119070f, 0.01648329f, 0.02473764f, 
    -0.11216535f, -0.04405522f, -0.16524035f, 0.00315194f, -0.00071280f, 0.02816086f, 0.05327024f, -0.04361900f, 
    -0.04715190f, -0.13762096f, 0.18110999f, 0.10869836f, 0.00033499f, -0.18128391f, 0.70412230f, -0.28570572f, 
    0.44894791f, -0.23584168f, 0.18225932f, -0.02887513f, 0.08684056f, 0.00631087f, 0.15073901f, -0.08072432f, 
    0.04396379f, -0.19189855f, 0.03252420f, -0.14286552f, -0.04327597f, -0.07489930f, 0.09927096f, -0.08983243f, 
    0.41626215f, 0.22913843f, -0.32153228f, -0.41970637f, -0.29916257f, -0.30565968f, -0.19280310f, -0.18689592f, 
    -0.01273962f, -0.44062784f, 0.06192686f, -0.00619696f, -0.12761422f, -0.12458150f, 0.15008935f, 0.10461419f, 
    -0.06276934f, -0.05362886f, -0.29128110f, -0.13942556f, -0.04937103f, 0.40898871f, -0.15208638f, -0.13093019f, 
    0.40004754f, 0.32703969f, -0.00098883f, -0.09002831f, -0.08553612f, -0.12225306f, -0.17992318f, 0.10751718f, 
    0.03422496f, 0.00049249f, 0.14000911f, -0.06225850f, 0.05515413f, -0.04272209f, -0.03718727f, 0.02666212f, 
    -0.41413683f, 0.14441870f, -0.46574551f, 0.23273692f, 0.02014218f, 0.04100055f, -0.13981712f, 0.09096926f, 
    -0.07439259f, 0.07021039f, -0.14027484f, 0.15356374f, -0.07187842f, -0.26790634f, -0.14418496f, -0.00335768f, 
    0.02070413f, 0.12055020f, -0.14792582f, -0.14450780f, 0.09740673f, 0.05380889f, 0.53564209f, -0.09081935f, 
    0.37796542f, -0.41690862f, 0.20893990f, 0.21418706f, 0.05437643f, 0.04792851f, 0.14767709f, 0.02152842f, 
    0.03008696f, 0.08041082f, 0.02048136f, 0.14206782f, -0.02446240f, 0.10561258f, -0.13628642f, -0.04239819f, 
    0.61947316f, 0.43185246f, -0.18945825f, 0.11958364f, -0.44227839f, 0.18119420f, 0.03134276f, 0.26602486f, 
    0.33652195f, -0.02309034f, -0.29395312f, -0.26077494f, 0.01986443f, -0.04821210f, -0.04893541f, -0.18868020f, 
    -0.03096740f, -0.26806664f, -0.06445116f, -0.07551850f, -0.49770018f, 0.39746481f, 0.26962075f, 0.29779205f, 
    0.55626404f, 0.01786570f, -0.06988262f, 0.01255677f, -0.25327218f, -0.09108329f, -0.18292235f, 0.04065690f, 
    -0.23140806f, 0.11549637f, 0.01293934f, -0.07641815f, -0.00141945f, 0.24870805f, -0.14289106f, -0.12372735f, 
    0.04271696f, -0.06349723f, -0.27955666f, 0.11705147f, 0.25624385f, 0.05290785f, 0.04956380f, -0.00112450f, 
    0.23572865f, 0.09165288f, -0.03547546f, 0.02865255f, 0.13988219f, -0.07062257f, -0.06354211f, -0.08480925f, 
    -0.10890666f, 0.13853513f, -0.19222458f, 0.03685230f, -0.58382183f, -0.07892156f, -0.54384601f, 0.23454781f, 
    -0.25972819f, 0.26643991f, 0.04570987f, -0.21181847f, -0.14644675f, 0.03221474f, -0.15227634f, -0.19646178f, 
    0.09993480f, -0.14850482f, -0.21089473f, 0.04740927f, -0.07782175f, 0.00563223f, 0.14313349f, -0.18880281f, 
    0.16126499f, 0.23912337f, -0.24240109f, -0.37126198f, 0.30888200f, 0.04457403f, 0.03084951f, -0.10513403f, 
    0.09368476f, 0.08002451f, -0.02669876f, 0.00488107f, -0.09784456f, 0.18215764f, 0.16219527f, -0.11537308f, 
    0.13083577f, 0.20270665f, -0.06697053f, 0.12133218f, -0.57528973f, -0.72733003f, 0.03084687f, -0.26374927f, 
    -0.46341172f, -0.18122178f, 0.02727405f, -0.17720743f, 0.03028548f, -0.14999522f, 0.12862581f, 0.17697848f, 
    0.15014613f, -0.00508755f, 0.03325954f, -0.09910370f, 0.14646713f, 0.30205774f, -0.37540641f, -0.28647372f, 
    1.20205104f, 0.47713056f, 0.00079790f, -0.38150397f, -0.52780271f, 0.08122272f, 0.03814053f, 0.04152395f, 
    -0.34569722f, -0.05920875f, -0.18490843f, -0.13213308f, 0.19201924f, -0.10713614f, -0.07348242f, -0.10011166f, 
    0.00226058f, -0.40276846f, 0.04300178f, 0.17189054f, -0.02625473f, -0.24265717f, -0.72166872f, -0.12369364f, 
    0.48895049f, 0.19283783f, 0.09818605f, -0.00723237f, -0.00326220f, -0.04618848f, 0.04564167f, 0.12779079f, 
    -0.06205790f, 0.33903709f, 0.00658178f, -0.05957253f, -0.10304631f, 0.22016944f, 0.22512689f, -0.02273572f, 
    -0.10794964f, 0.05312936f, 0.37157056f, 0.15305395f, 0.06589853f, -0.09221792f, 0.15863852f, -0.01744624f, 
    -0.13149440f, 0.05285904f, -0.04801001f, -0.00214134f, -0.04305891f, 0.07658515f, 0.06505137f, 0.01605129f, 
    0.09759330f, -0.12020940f, -0.03588651f, 0.22929387f, 0.02001084f, 0.12771074f, 0.16536285f, 0.27240109f, 
    -0.03722113f, -0.04230543f, -0.13403784f, 0.12750709f, -0.20676115f, 0.10476075f, -0.11694815f, 0.02377552f, 
    0.10073113f, -0.00012573f, 0.07810996f, 0.04725256f, -0.10922898f, -0.12895061f, -0.10770636f, -0.28590465f, 
    0.24763674f, -0.30729318f, 0.14076521f, 0.15221332f, 0.03044836f, -0.16877107f, -0.14221360f, -0.11536188f, 
    -0.07132124f, 0.05455788f, 0.00746129f, 0.01904063f, -0.07496297f, -0.12846145f, -0.03170960f, 0.00196250f, 
    0.04307765f, 0.08107086f, -0.08780321f, -0.06272845f, 0.00260065f, 0.16533810f, -0.15700576f, 0.36747029f, 
    0.10098665f, -0.04540450f, 0.19308604f, 0.08055481f, 0.15509146f, 0.19469498f, 0.09410527f, -0.02404988f, 
    -0.00907995f, -0.12028638f, -0.06876070f, -0.05181105f, -0.05659057f, -0.24958667f, -0.11371028f, -0.34505957f, 
    -0.30251044f, -0.08979766f, -0.04482445f, -0.25449970f, 0.01276065f, -0.07070574f, 0.00933687f, -0.21662451f, 
    0.22582208f, -0.15912651f, -0.01876034f, -0.30919963f, 0.01913333f, -0.11413753f, 0.01079059f, -0.25484714f, 
    -0.22061296f, -0.13720241f, -0.07109368f, -0.10176407f, 0.14668213f, -0.21020325f, 0.17252360f, 0.12256068f, 
    0.00333451f, -0.48953521f, -0.07837307f, -0.02930515f, -0.05800890f, -0.05428088f, -0.06336134f, 0.04604369f, 
    -0.04756453f, 0.02030360f, 0.05206666f, -0.06311939f, 0.01345984f, 0.08842020f, 0.09454980f, -0.07513808f, 
    0.05435643f, -0.05512183f, 0.46238399f, -0.14066140f, 0.23067634f, -0.11010285f, 0.44357851f, 0.04346385f, 
    0.13851884f, -0.15165314f, -0.10872351f, -0.09991390f, -0.00388345f, 0.09642807f, 0.06221072f, -0.16507564f, 
    0.03499716f, -0.02177190f, -0.00507076f, -0.14421111f, 0.47929382f, 0.01599176f, -0.26079622f, 0.39734012f, 
    0.27359295f, -0.04292299f, 0.05954292f, -0.00223268f, 0.14977309f, 0.27946332f, 0.05162644f, -0.04600201f, 
    0.02896075f, 0.03512871f, 0.03957203f, 0.12799105f, 0.28962129f, 0.08325329f, 0.34530291f, 0.29652670f, 
    -0.62847233f, 0.15729056f, 0.11103756f, -0.39623079f, -0.14822239f, 0.18280318f, 0.04125714f, -0.04705527f, 
    0.08885172f, 0.20342554f, 0.00051420f, 0.00034615f, 0.04653719f, -0.06249709f, -0.06615971f, -0.09830695f, 
    0.03150662f, 0.01438886f, -0.26832443f, 0.14131156f, -0.14877914f, -0.62499565f, 0.13078435f, -0.19248484f, 
    0.01735179f, -0.11317395f, -0.00320195f, -0.18023099f, -0.19604886f, -0.52162510f, -0.03896265f, -0.21772754f, 
    -0.10898025f, 0.19652359f, -0.12628502f, -0.08687662f, 0.04179125f, -0.06541315f, -0.09234528f, -0.18314974f, 
    0.11680645f, 0.13948065f, 0.45343313f, 0.15499222f, 0.13895684f, -0.28193918f, -0.05552679f, -0.02771412f, 
    -0.03560127f, 0.00073228f, 0.07544896f, 0.08260666f, -0.04705981f, 0.07927929f, -0.02067856f, 0.07607759f, 
    0.00039387f, -0.26126823f, 0.02568021f, -0.23829930f, 0.08674727f, 0.01749106f, -0.01037745f, -0.11285157f, 
    -0.03483682f, 0.08339798f, 0.00179526f, 0.08141308f, -0.00801440f, 0.06125282f, 0.00370701f, -0.13196048f, 
    0.02121472f, -0.11353530f, -0.04447201f, 0.17470181f, 0.00536837f, -0.02708502f, -0.13844019f, -0.02221180f, 
    -0.45843220f, -0.35577369f, 0.03010321f, 0.11356428f, 0.00508760f, -0.29992190f, 0.04430947f, 0.08921292f, 
    -0.41931409f, -0.27357394f, 0.05853903f, -0.00319883f, -0.05066791f, 0.04869976f, -0.01084099f, 0.08476385f, 
    0.13531934f, 0.05985168f, -0.01473104f, 0.22509025f, 0.00486185f, 0.07151044f, -0.03409198f, 0.05468925f, 
    0.06602913f, 0.09552787f, 0.20655413f, 0.10845746f, -0.01370389f, 0.12932476f, 0.10566131f, 0.07781064f, 
    -0.01550762f, -0.00764312f, 0.13661025f, 0.07741949f, -0.09580795f, -0.07576855f, 0.02269914f, 0.01391221f, 
    0.13382094f, -0.27472371f, -0.15101889f, -0.10295081f, -0.22885768f, 0.25744098f, -0.18325301f, -0.05073822f, 
    0.12129097f, 0.01404285f, 0.14977351f, -0.21264847f, -0.08318663f, -0.23475274f, 0.08539756f, 0.07144129f, 
    -0.19428426f, 0.05016684f, -0.34479269f, 0.02059038f, 0.33518600f, 0.33575505f, 0.40049708f, 0.14472240f, 
    0.09351586f, -0.09930075f, -0.05470887f, -0.20094548f, 0.19379117f, 0.05630703f, 0.04003588f, -0.01226253f, 
    0.09648301f, -0.02975305f, 0.02986340f, 0.03470100f, 0.04702392f, -0.19250163f, -0.00763460f, -0.16535710f, 
    0.11778330f, 0.10329061f, 0.44957876f, 0.19389744f, -0.21610829f, -0.01397541f, -0.00304171f, 0.10790299f, 
    0.14923409f, -0.08309359f, 0.09657859f, 0.03631713f, 0.01207792f, 0.07595967f, 0.00030645f, -0.01674335f, 
    -0.01008742f, -0.18280348f, 0.04268831f, -0.20022613f, 0.10349920f, -0.27666274f, 0.50507927f, -0.27816018f, 
    -0.40802330f, -0.06334122f, 0.00953261f, -0.12491757f, -0.17951643f, -0.11072462f, 0.13652854f, -0.05050036f, 
    -0.00312722f, -0.02346142f, 0.02423922f, 0.09701178f, 0.11755972f, -0.16262782f, 0.17628923f, 0.20970532f, 
    -0.49242234f, 0.10866621f, -0.29870582f, -0.45777860f, -0.22662905f, 0.06797361f, 0.10471545f, -0.06924360f, 
    -0.07122646f, 0.13167760f, 0.05606782f, 0.09879245f, -0.28346989f, -0.01737075f, -0.07756329f, -0.10431439f, 
    -0.00350330f, 0.08257103f, -0.06844375f, 0.11370171f, -0.08564655f, 0.28024289f, -0.27821687f, 0.15653467f, 
    -0.08416785f, 0.11845308f, -0.16929179f, 0.16835128f, -0.06025910f, -0.04822444f, -0.09847280f, 0.00402110f, 
    -0.07248074f, -0.02312709f, 0.05671678f, 0.13467479f, 0.01697186f, 0.32702136f, -0.17736498f, -0.00076811f, 
    0.07490132f, -0.54251236f, 0.04810793f, 0.28600264f, -0.38060081f, 0.43573213f, 0.07664345f, -0.17645024f, 
    0.06868631f, 0.41167390f, -0.18321587f, 0.12920919f, 0.05954869f, 0.04628295f, 0.05831746f, 0.14124689f, 
    -0.02983530f, -0.04310990f, 0.00020162f, 0.41819423f, -0.45255366f, 0.09685206f, -0.33995631f, -0.11138184f, 
    -0.28809288f, 0.06936200f, -0.01639804f, -0.11470130f, -0.22132120f, 0.24733415f, -0.00427565f, 0.01544107f, 
    -0.08152866f, 0.01641960f, -0.15024911f, -0.12576355f, -0.09434855f, 0.02001653f, -0.04492360f, 0.13225043f, 
    0.72073197f, -0.08261386f, 0.30069524f, 0.22805791f, -0.08779791f, 0.10665490f, -0.04542583f, -0.16667053f, 
    0.07318136f, 0.23982573f, 0.18968475f, -0.07282877f, 0.00461613f, 0.15563491f, -0.06197668f, 0.06493624f, 
    0.01773939f, -0.19821976f, -0.22438030f, 0.43302086f, -0.23936084f, -0.07508022f, 0.33631888f, 0.14683880f, 
    -0.17368811f, 0.08657549f, 0.09144536f, -0.11216502f, 0.03781982f, 0.07776358f, 0.08244246f, 0.08658522f, 
    -0.00763801f, -0.04344051f, 0.00608828f, -0.26162961f, 0.01685649f, -0.06064434f, -0.29416233f, -0.35081521f, 
    -0.24465613f, -0.04210976f, -0.41692245f, -0.14639157f, 0.28318456f, 0.06291197f, -0.11972468f, 0.05244042f, 
    -0.10269074f, -0.07017975f, 0.07418092f, -0.09889298f, 0.11691053f, 0.07431427f, 0.13031429f, -0.20111436f, 
    -0.19769499f, 0.31665531f, 0.04495316f, -0.20801720f, -0.12747481f, -0.26340085f, -0.10237528f, -0.52301294f, 
    -0.18957689f, 0.08781294f, -0.05010898f, -0.18352251f, 0.09039164f, 0.11183190f, -0.05374773f, 0.14946806f, 
    0.04779133f, -0.16687962f, 0.00458400f, 0.05341236f, -0.02762481f, 0.03906424f, 0.08958054f, 0.11102201f, 
    0.28917614f, -0.04339953f, 0.37135807f, 0.00448848f, -0.30375779f, 0.33301789f, 0.23356195f, 0.06720715f, 
    -0.17857796f, -0.18330400f, 0.00313938f, -0.06961053f, -0.03340553f, -0.00967967f, 0.01648392f, -0.05721690f, 
    0.06051249f, -0.04534728f, 0.12326837f, -0.16203342f, -0.07352310f, -0.04320114f, -0.29539734f, -0.13545780f, 
    0.14971730f, 0.20543985f, 0.05849434f, -0.11903211f, -0.13346563f, 0.05165236f, 0.17227899f, -0.01112585f, 
    -0.04465961f, 0.22622649f, 0.09222751f, -0.05459655f, 0.11912255f, 0.18661134f, 0.09100650f, 0.04262787f, 
    -0.17545840f, -0.08150005f, 0.15808101f, 0.27964738f, -0.36808750f, -0.06038334f, -0.14077350f, 0.06775708f, 
    -0.06032828f, -0.08948950f, -0.00390580f, -0.03023817f, 0.00857899f, -0.14605448f, 0.09314308f, -0.16526565f, 
    -0.01202234f, 0.00731249f, -0.15843840f, -0.33904168f, -0.14596388f, -0.20911953f, -0.11955465f, 0.06184543f, 
    0.13567108f, 0.11916570f, -0.04041744f, 0.01448851f, -0.00750110f, 0.10030501f, 0.02069085f, -0.31814563f, 
    0.05449608f, -0.04839702f, 0.03442318f, 0.13016477f, -0.21011178f, 0.00238333f, -0.12625629f, 0.02440530f, 
    -0.51693529f, 0.75641489f, -0.07623808f, 0.30440670f, 0.07068115f, -0.16951869f, -0.20295654f, -0.12756585f, 
    0.21039566f, -0.01441675f, 0.00416481f, -0.08754903f, -0.11797839f, 0.23636805f, -0.14030096f, 0.01918606f, 
    0.00623904f, 0.24062139f, 0.08661573f, -0.05426678f, -0.32593080f, -0.00905587f, 0.13913071f, -0.20465018f, 
    -0.23988149f, -0.00631069f, 0.13276607f, 0.01675636f, -0.01712977f, 0.29015091f, 0.06993271f, -0.06414901f, 
    -0.02586855f, 0.13653700f, 0.02242572f, 0.01485228f, 0.02520671f, -0.03673931f, 0.09893802f, 0.14970060f, 
    -0.90256208f, -0.80344564f, -1.06999826f, -0.06206933f, 0.32628089f, -0.15560257f, 0.02098686f, 0.01551706f, 
    -0.21335170f, -0.30621698f, -0.04101868f, -0.01728937f, -0.01064375f, -0.09540345f, 0.04263685f, 0.02964669f, 
    -0.02899715f, 0.00960202f, 0.34443128f, 0.17507087f, -1.18044436f, -0.63342148f, -0.07007015f, 0.08979093f, 
    -0.14759152f, -0.22228815f, -0.16529492f, -0.15689990f, -0.35717767f, -0.21459848f, 0.06352048f, -0.03863511f, 
    -0.05928843f, -0.09392929f, -0.02066957f, 0.02217116f, -0.00661887f, 0.10336763f, -0.04296062f, -0.24138369f, 
    -0.72718418f, 0.45369446f, 0.70778668f, 0.04352291f, 0.37674940f, -0.07753401f, -0.01303427f, -0.08873443f, 
    -0.12856878f, 0.13393375f, -0.20727460f, 0.21188380f, 0.11960866f, 0.12799178f, 0.10396518f, 0.03296807f, 
    0.00363608f, 0.00893681f, 0.01517851f, -0.02068650f, 0.16484632f, -0.43544778f, -0.63968176f, -0.30106547f, 
    0.32773566f, -0.12672150f, 0.11181155f, 0.30427247f, 0.16190703f, -0.25802472f, 0.07267337f, -0.00078156f, 
    -0.04138649f, -0.06024145f, 0.05573938f, -0.01331484f, 0.04015668f, 0.06110282f, 0.32418340f, 0.05484384f, 
    -0.13912885f, 0.40901369f, -0.42666990f, -0.22152178f, 0.31971824f, -0.08553737f, 0.17855278f, 0.09815823f, 
    0.09045792f, 0.18918392f, -0.10589429f, 0.03481083f, -0.09493508f, 0.02136762f, -0.00137754f, -0.05525315f, 
    0.13233158f, -0.16359833f, 0.21149814f, -0.10862406f, -0.50634593f, 0.60751879f, 0.72404015f, -0.15086055f, 
    0.42601407f, -0.25632823f, -0.01530673f, 0.05426595f, -0.06368665f, 0.09644185f, 0.01308851f, 0.10410585f, 
    -0.01391476f, 0.17627113f, 0.05186925f, -0.00198895f, -0.02411524f, 0.01245272f, 0.04068890f, 0.03199117f, 
    -0.19281892f, -1.08299673f, -1.21442449f, -0.13061757f, 0.25793141f, 0.02864455f, -0.01407300f, 0.09413141f, 
    0.11593561f, -0.41481614f, 0.06079449f, -0.02901395f, -0.21290897f, 0.14674780f, 0.15598443f, -0.03637410f, 
    0.03257284f, 0.26622421f, 0.25341073f, 0.15425880f, -0.63237405f, -0.93897074f, -0.74856055f, -0.07464523f, 
    0.04384330f, -0.09580979f, 0.31966004f, 0.16371407f, 0.03970313f, 0.00952791f, -0.00382146f, -0.07817603f, 
    -0.01170182f, 0.08007095f, 0.06911249f, 0.06780088f, 0.05572087f, 0.02734274f, 0.12302829f, 0.05524401f, 
    -0.08400147f, 0.05665850f, 0.14395952f, 0.01197843f, 0.19833890f, 0.00403536f, -0.00471141f, -0.07119339f, 
    0.00836587f, -0.00122549f, 0.01896187f, 0.05543024f, 0.20818177f, 0.06679825f, -0.06774119f, 0.03621988f, 
    0.07636543f, 0.05464682f, 0.04826357f, 0.10568872f, -0.30914029f, 0.82882416f, -0.19368404f, -0.06313329f, 
    0.46341437f, -0.09642126f, 0.15754670f, -0.15205887f, 0.19384627f, 0.12174765f, 0.21494766f, 0.05333949f, 
    0.11131844f, -0.01150644f, 0.10597996f, 0.12979177f, -0.04828048f, 0.09998538f, -0.02893893f, -0.01107071f, 
    -0.79326695f, -0.88909507f, -0.76312345f, -0.31244346f, -0.06240251f, -0.21682487f, 0.04659690f, -0.18181314f, 
    -0.18857986f, -0.55981296f, 0.03109637f, -0.09065189f, -0.04031656f, -0.07822617f, 0.09212342f, -0.04002126f, 
    -0.01521873f, 0.16795684f, 0.14331517f, -0.08521972f, -0.01880073f, 0.04005967f, 0.03558531f, -0.08828866f, 
    -0.04930557f, 0.01828729f, -0.01400950f, 0.02051241f, -0.00729688f, 0.00344896f, -0.08251810f, 0.08562457f, 
    0.18109310f, -0.11504359f, -0.03951750f, 0.02096206f, -0.05181038f, -0.05314985f, -0.28555676f, -0.10268082f, 
    0.03841692f, -0.48773649f, -0.79713041f, 0.17648576f, 0.47086391f, -0.33838865f, -0.02708946f, 0.14335036f, 
    -0.28883994f, 0.04718459f, -0.04409293f, -0.01816526f, 0.07668487f, -0.12093215f, -0.30141258f, -0.06007452f, 
    -0.05914573f, -0.11069427f, 0.31661782f, -0.07552779f, 0.13947262f, -0.15159601f, -0.16833571f, -0.13598607f, 
    0.06776962f, -0.01857923f, 0.08596092f, 0.01956855f, 0.05728451f, 0.10400020f, -0.09869596f, -0.01124481f, 
    -0.23225889f, -0.24619676f, -0.03848477f, -0.19958679f, -0.42671171f, -0.20337895f, -0.05516486f, 0.01236662f, 
    -0.25629193f, 0.08504174f, -0.06360692f, -0.19956517f, 0.15004463f, -0.16174453f, 0.22710225f, 0.14700864f, 
    0.04511295f, 0.25581032f, 0.00103454f, 0.05156834f, 0.06640312f, 0.06835270f, 0.04237907f, 0.01301008f, 
    0.16009685f, -0.09309217f, 0.03623844f, -0.06063094f, -1.14104271f, 0.45051596f, 0.65060061f, -0.16371351f, 
    -0.57884669f, -0.23129468f, -0.04135036f, -0.23944783f, 0.05948691f, -0.45610574f, 0.04313352f, -0.00223386f, 
    -0.15631336f, 0.08953995f, 0.00215916f, -0.01925827f, -0.11823324f, 0.08520698f, -0.08141501f, -0.13563608f, 
    -0.13592762f, -0.67685002f, 0.06809973f, 0.76362848f, 0.06561091f, -0.08474889f, 0.03145057f, -0.04870106f, 
    0.18066283f, 0.13850990f, 0.02820098f, -0.08414064f, -0.18596388f, -0.08079792f, -0.04927497f, -0.01563876f, 
    0.02918353f, -0.12029947f, 0.14482911f, -0.12250430f, 0.48672301f, -1.12528002f, 0.60673326f, 0.26139760f, 
    -0.02995643f, 0.15648484f, 0.24959032f, -0.14268833f, -0.01240783f, 0.09101953f, 0.03107278f, 0.04472010f, 
    0.12132512f, -0.08655822f, 0.03240973f, -0.00916272f, -0.00081854f, -0.14474411f, -0.08160283f, -0.16627043f, 
    0.48304537f, -0.03276534f, 0.10710876f, -0.32484889f, -0.22066408f, -0.04046972f, -0.06218033f, 0.02110509f, 
    0.06779494f, -0.03506407f, 0.16523021f, 0.04084998f, 0.11198234f, 0.11743623f, 0.17234799f, 0.02368488f, 
    0.04351736f, -0.03068475f, 0.11013445f, 0.03531849f, -0.26239395f, -0.23922841f, -0.19692938f, 0.28984064f, 
    -0.43503460f, 0.04722826f, -0.04176926f, -0.10777473f, 0.20299038f, 0.17312019f, 0.06334530f, 0.05754609f, 
    0.06757771f, 0.03595662f, -0.02338109f, 0.02225639f, 0.02269895f, -0.09512119f, -0.03843896f, -0.00236981f, 
    0.20500758f, 0.11259921f, -0.46050802f, 0.26854306f, -0.44617647f, 0.01160818f, 0.14698280f, -0.11519022f, 
    -0.36681673f, 0.11594065f, -0.13217261f, 0.05926433f, 0.06499449f, 0.01033165f, -0.01957434f, -0.09265760f, 
    -0.34073180f, 0.24229099f, -0.22265759f, -0.18984720f, 0.78630644f, -0.67589086f, -0.82809436f, -0.70869458f, 
    -0.37837496f, 0.01811796f, -0.04434060f, -0.32547686f, 0.31291768f, -0.15528187f, 0.01932550f, 0.11527111f, 
    0.02595882f, 0.02576417f, 0.05565032f, -0.05327462f, 0.02216812f, -0.00306875f, 0.06291356f, 0.02585346f, 
    -1.58486021f, -0.81413686f, 0.27441704f, 0.30009404f, 0.62670058f, 0.23040091f, 0.09437384f, 0.24608427f, 
    0.07535068f, -0.15592097f, -0.06937247f, 0.03443408f, -0.01458054f, -0.12833875f, -0.15973350f, 0.04810360f, 
    -0.05378052f, 0.03609547f, 0.04465874f, -0.05205709f, 0.10035148f, 0.28903645f, 0.14381310f, 0.23570807f, 
    -0.26696742f, -0.01042433f, -0.11210204f, -0.33331445f, -0.09972777f, 0.00471963f, -0.00189900f, 0.04510339f, 
    -0.00938244f, 0.00478075f, -0.00963578f, 0.13148242f, 0.02887085f, -0.10170504f, -0.08231680f, -0.00898563f, 
    -0.15211219f, 0.06429037f, -0.27555850f, 0.18835236f, -0.37738812f, 0.04869791f, -0.02202307f, 0.13336961f, 
    -0.01841916f, -0.03181842f, -0.17463402f, 0.00812442f, -0.19228803f, -0.13171326f, -0.13590449f, -0.04935571f, 
    -0.07869370f, 0.01365217f, 0.11672870f, 0.19270200f, -0.57065278f, -0.62116587f, 0.10209932f, -0.30741909f, 
    0.12721437f, -0.01671357f, -0.13488135f, 0.26645756f, -0.01643949f, 0.09077577f, -0.18582074f, 0.23824574f, 
    0.00226648f, 0.18819577f, 0.09138411f, -0.00995724f, -0.00573494f, -0.06388851f, -0.06821678f, -0.07053865f, 
    -0.39557302f, -0.77244300f, -0.55302894f, 0.37038001f, 0.24133401f, -0.08879647f, 0.04294012f, 0.12043458f, 
    0.20478010f, 0.15683557f, -0.03140381f, -0.01130986f, -0.04427652f, -0.06309059f, 0.00066589f, -0.05516881f, 
    0.11657334f, -0.09485879f, 0.04015144f, -0.14519545f, -0.01506122f, 0.21471612f, 0.09868368f, -0.13117740f, 
    -0.00449707f, -0.01986268f, 0.06505587f, 0.05388238f, 0.01581085f, -0.07549736f, -0.01903641f, -0.39808455f, 
    -0.26069382f, -0.12080376f, -0.14444669f, -0.02897215f, -0.01380091f, -0.05229009f, 0.07860533f, -0.06287205f, 
    0.65789324f, -0.83048195f, -0.88380611f, -0.63184935f, -0.12683813f, 0.03286599f, -0.07015953f, -0.11216626f, 
    0.38946491f, 0.07468341f, 0.03694449f, 0.03964489f, -0.09037642f, 0.06791005f, 0.13317616f, 0.02859307f, 
    -0.00567891f, 0.00286762f, 0.25203875f, -0.03759550f, 0.01351788f, 0.12690729f, -0.00401576f, 0.01185613f, 
    -0.12325910f, 0.04294743f, 0.05979721f, -0.02054951f, 0.05787375f, -0.04304931f, 0.13307452f, 0.01617408f, 
    -0.00606372f, 0.01583140f, 0.01461014f, -0.07582766f, -0.18139459f, 0.04185809f, 0.05233376f, 0.01502734f, 
    0.50931823f, 0.65655768f, -0.56776494f, 0.16210128f, -0.85623008f, 0.00846090f, 0.14991276f, 0.11574444f, 
    -0.24952270f, 0.02078021f, -0.13528517f, 0.03307842f, 0.11056868f, 0.04659754f, 0.00364830f, -0.02811415f, 
    -0.23503797f, 0.07721901f, -0.18946716f, -0.12643209f, 0.70858109f, -1.40816760f, 0.16968659f, -0.87879133f, 
    0.02268764f, -0.06882178f, 0.16918899f, -0.23893414f, 0.16390207f, -0.17324708f, 0.02743249f, 0.01177339f, 
    0.05724214f, 0.00295552f, -0.02455573f, 0.07270909f, 0.00660420f, -0.10541748f, -0.12176958f, 0.06738736f, 
    0.25657213f, -0.11709052f, -0.22995831f, -0.20327772f, -0.12388755f, 0.00838046f, -0.19386135f, -0.00784130f, 
    -0.16971502f, -0.30936927f, 0.08039881f, 0.00072272f, 0.02459665f, 0.13850372f, 0.04821848f, 0.07347405f, 
    0.04682909f, 0.08789725f, -0.04903176f, -0.25012729f, 0.43514568f, -0.39250422f, -0.56334388f, -0.39145443f, 
    -0.15240911f, -0.03158105f, -0.06317646f, -0.18233299f, 0.05376272f, 0.32547823f, -0.06245291f, 0.09500295f, 
    0.04539477f, -0.00528414f, 0.02825058f, -0.02833133f, 0.14386468f, 0.09201540f, 0.03540283f, 0.24313425f, 
    0.01485843f, -0.55684286f, -0.67493337f, -0.09230857f, -0.06867816f, -0.19753292f, 0.00328340f, 0.13901825f, 
    0.13627282f, 0.25132814f, 0.24384789f, -0.15958034f, 0.02648580f, -0.17444120f, -0.02813935f, 0.00237982f, 
    0.08115934f, 0.02455622f, 0.01361564f, -0.00330497f, 0.40223202f, 0.09470311f, 0.00959907f, -0.00432677f, 
    -0.13899551f, 0.12147614f, -0.29473072f, -0.14570272f, -0.12848765f, -0.44755203f, -0.10032251f, 0.16411205f, 
    0.07544325f, -0.02024860f, -0.01442588f, -0.17980200f, 0.07647643f, 0.31998944f, 0.16616939f, 0.18455793f, 
    0.51534653f, 0.19329347f, -0.18682832f, 0.08308502f, -0.30034983f, 0.27245480f, 0.13862570f, 0.21074405f, 
    0.08213509f, 0.05671277f, 0.13260582f, -0.16548903f, 0.11036228f, 0.04190570f, -0.01542535f, -0.10510473f, 
    -0.06901892f, -0.05073670f, 0.25050154f, -0.06517000f, -0.05454221f, -0.65480262f, -1.08959031f, -0.44236577f, 
    0.37626475f, -0.01672758f, 0.23738007f, 0.22846423f, 0.22169058f, 0.11450686f, 0.08065737f, -0.14689137f, 
    -0.17384458f, 0.07055972f, -0.00255852f, 0.05526036f, -0.04709873f, 0.00782215f, -0.10446566f, -0.08208952f, 
    1.49364436f, -0.41678408f, -0.47035334f, 0.15187183f, 0.07438786f, 0.23596819f, -0.03900504f, 0.03927492f, 
    -0.14540447f, -0.28613707f, -0.02209112f, 0.02961682f, -0.03823538f, 0.00682685f, 0.01856572f, 0.03425741f, 
    0.03611032f, 0.16545343f, -0.07658797f, -0.06157792f, -0.19921468f, 0.15769747f, 0.55003321f, 0.02531721f, 
    -0.41353375f, 0.11165131f, -0.28061536f, -0.02652654f, 0.01030093f, -0.17544205f, -0.02738064f, -0.01643621f, 
    -0.03675999f, -0.07682537f, -0.02848761f, -0.06471726f, -0.14829226f, -0.47097096f, -0.19517267f, -0.51425046f, 
    -0.33411059f, -0.00680971f, 0.20038053f, 0.04536981f, -0.16065452f, -0.17899530f, 0.05863930f, -0.10899079f, 
    -0.05992058f, -0.11524047f, -0.00169953f, 0.14473572f, 0.05010047f, -0.00371190f, 0.07784454f, 0.06480023f, 
    -0.09218445f, -0.17815129f, 0.06678435f, -0.10114774f, -0.19552797f, -0.88402218f, -0.18119399f, -0.02119331f, 
    0.61110979f, 0.09848093f, 0.11666631f, 0.17771411f, 0.01093407f, 0.10433187f, 0.19102353f, 0.10482766f, 
    0.01414642f, 0.15536879f, 0.09376063f, -0.05344340f, -0.03114349f, -0.06848183f, -0.01886152f, -0.02604251f, 
    0.43927351f, -0.72711980f, -0.88187903f, -0.20275959f, -0.08954791f, -0.20595893f, -0.31027904f, 0.00443463f, 
    0.03260736f, -0.08019780f, -0.10515054f, -0.06197366f, 0.04366097f, -0.03181673f, -0.02144174f, 0.00257311f, 
    -0.00533796f, 0.24485838f, 0.03149866f, 0.29474497f, -0.37028429f, -0.07393896f, -0.02390855f, 0.01368465f, 
    -0.16261722f, -0.09254789f, -0.03113028f, 0.01170087f, -0.02507403f, -0.04316595f, 0.03406632f, 0.06620790f, 
    0.06854090f, 0.01164661f, 0.12613289f, -0.06556504f, 0.08232975f, 0.05421988f, 0.13858174f, 0.13295764f, 
    0.17216343f, 0.12416300f, -0.94974953f, -0.45232013f, -0.21126950f, -0.02593172f, 0.20185301f, 0.01873768f, 
    0.02607982f, 0.02366219f, 0.01791451f, -0.05778130f, -0.05304822f, 0.15755524f, 0.09833875f, 0.07440466f, 
    0.02891097f, 0.05431938f, -0.36624855f, -0.30142072f, -0.24506681f, 0.09753384f, 0.01860105f, 0.02599186f, 
    -0.22805582f, -0.02196702f, -0.15798374f, -0.12711017f, -0.07153738f, -0.07065979f, -0.14095965f, -0.10532301f, 
    -0.09556834f, 0.02758571f, 0.05906503f, 0.09091715f, 0.19862857f, 0.08593269f, 0.00170928f, 0.12111886f, 
    0.51353180f, 0.16908410f, -0.10271949f, -0.20115593f, -0.23766884f, -0.09959655f, 0.19763587f, -0.09085993f, 
    0.23914059f, -0.08311187f, 0.05085342f, 0.12933452f, 0.01808655f, -0.04568901f, 0.17826052f, 0.11377862f, 
    0.11139219f, -0.17654803f, 0.12317478f, -0.11280317f, -0.25353384f, -0.91261405f, -1.04339302f, -0.26357973f, 
    0.26803204f, 0.23316978f, 0.04072635f, 0.08032472f, 0.05896517f, 0.24488001f, -0.07673719f, 0.01136472f, 
    -0.15972775f, -0.10588077f, 0.00610986f, 0.06893897f, 0.05143868f, 0.13355061f, 0.02029414f, 0.14141704f, 
    -0.04706085f, 0.06230117f, 0.03052540f, 0.26287192f, -0.37539640f, -0.00112935f, -0.28176489f, 0.09916823f, 
    0.01666655f, 0.27987078f, 0.01709505f, 0.05294224f, 0.08878119f, 0.02707599f, -0.02200287f, 0.00101130f, 
    0.07149375f, 0.25242066f, 0.24980843f, 0.11884490f, -0.13795051f, -0.23169491f, 0.13766439f, 0.08752979f, 
    -0.12305094f, -0.29131353f, 0.03067608f, 0.03850989f, -0.12420055f, -0.04474938f, 0.00604004f, -0.04759123f, 
    0.06180129f, -0.02106965f, 0.05639258f, 0.08535641f, -0.04577115f, 0.00277658f, -0.03151834f, -0.29514939f, 
    0.19858967f, 0.21105462f, 0.28181621f, 0.65435493f, -0.33229047f, -0.02760459f, 0.13998541f, -0.68765050f, 
    -0.22265050f, -0.41847682f, 0.05913536f, -0.05905192f, 0.09108239f, 0.14856698f, 0.07420909f, 0.07150369f, 
    0.04686977f, -0.08570410f, -0.04615513f, 0.09914444f, 0.07417994f, 0.71759462f, -1.08484399f, 0.07091273f, 
    0.03878180f, 0.01434467f, 0.01728644f, 0.27632761f, -0.12110544f, 0.19413759f, 0.14853202f, -0.00851505f, 
    -0.10906015f, -0.25280324f, -0.07965733f, 0.03805753f, -0.08839495f, -0.14458379f, -0.05489516f, -0.33437979f, 
    -0.58780855f, 0.35273704f, -0.61921656f, 0.28046417f, -0.26740050f, 0.11866459f, -0.42382881f, 0.10259598f, 
    -0.16760439f, -0.13053136f, -0.10278098f, -0.11063758f, -0.09376934f, 0.07605185f, -0.02743967f, -0.03298380f, 
    -0.04133538f, -0.00134696f, 0.02477553f, 0.01423982f, -0.03300519f, 0.14545251f, 0.01759241f, 0.72099429f, 
    -0.76781696f, -0.03799691f, -0.04750977f, -0.60588837f, 0.15464464f, -0.11819302f, 0.03870516f, -0.03084336f, 
    0.14538677f, 0.11819749f, 0.08936159f, 0.06782230f, 0.08741442f, 0.04697330f, 0.04884161f, 0.09593928f, 
    -0.20649312f, -0.24009790f, -0.84679508f, -0.22956493f, -0.42936546f, 0.06677720f, -0.29809520f, 0.04482810f, 
    -0.07900864f, 0.12656550f, 0.11413597f, 0.02481237f, -0.06772625f, -0.07675144f, 0.07474956f, -0.11491966f, 
    0.04904885f, 0.07088193f, 0.02837329f, 0.13540557f, -0.20702980f, -0.62461221f, -0.82715470f, 0.30471477f, 
    -0.02154740f, 0.06043232f, 0.18947269f, 0.37021214f, -0.00713288f, 0.16191491f, -0.01881304f, -0.02975011f, 
    -0.10053895f, 0.04575597f, -0.08275371f, 0.05653871f, 0.03840053f, 0.07967527f, -0.00267239f, 0.36229911f, 
    0.01518482f, 0.09092602f, -0.12374981f, -0.17483285f, 0.31690994f, 0.00163689f, -0.09177441f, 0.11030178f, 
    0.15677361f, -0.21771732f, 0.00462736f, 0.12278297f, -0.03892564f, -0.03834903f, 0.04206967f, 0.12011961f, 
    0.20475012f, 0.02837205f, -0.01661542f, 0.26153848f, -0.20620224f, -0.16820817f, 0.82202816f, -0.12581085f, 
    -0.86179894f, 0.13053431f, -0.47205466f, -0.08482905f, 0.09842982f, -0.04716384f, -0.11112896f, 0.13221794f, 
    -0.07379691f, 0.14776359f, 0.05163162f, 0.01272715f, -0.06705652f, -0.04804179f, -0.14585148f, 0.10531952f, 
    -0.44557041f, -0.54837006f, 0.66015887f, 0.17659310f, -0.36106065f, 0.23207045f, -0.54434514f, 0.17163615f, 
    0.10904855f, 0.24599570f, -0.03913328f, 0.02830852f, 0.04134946f, -0.06469737f, -0.12063170f, 0.07530226f, 
    0.02174268f, -0.02218779f, -0.04285193f, -0.04266001f, 0.11671616f, -0.16822048f, 0.34140962f, -0.08571026f, 
    0.26726705f, 0.00788429f, 0.17323638f, -0.07597345f, 0.01173913f, -0.07669880f, 0.03866738f, 0.11245377f, 
    0.02229437f, -0.12115216f, -0.04354104f, 0.02760310f, 0.04155568f, 0.05207912f, -0.17558421f, 0.08656286f, 
    -0.12996462f, 0.33804959f, 0.16728838f, 0.82452124f, -0.73031449f, 0.19410855f, -0.27756092f, -0.18327318f, 
    0.04507682f, -0.01115845f, 0.04064685f, -0.06767595f, 0.18052831f, -0.02800455f, 0.07007752f, -0.00642579f, 
    0.16090909f, -0.01649057f, 0.18435439f, 0.14046691f, -0.18288419f, -0.20829162f, -0.61196202f, -0.16544181f, 
    -0.22104321f, 0.13512802f, 0.26559785f, 0.55184072f, 0.18383752f, 0.00167831f, 0.10976347f, -0.03632088f, 
    -0.10610265f, -0.05322193f, -0.08685898f, 0.16632250f, 0.19962905f, -0.06931605f, -0.03122429f, -0.02052575f, 
    -0.94970518f, 0.20247950f, -0.23540269f, 0.37682915f, 0.03839350f, 0.03413926f, -0.25992930f, -0.05301008f, 
    -0.23050679f, -0.09153085f, -0.02889170f, 0.03116424f, -0.00686389f, -0.13561249f, 0.10532235f, 0.21103771f, 
    -0.07990508f, -0.11137047f, 0.05736013f, -0.00370875f, -0.11409225f, -0.05723459f, 0.17070934f, -0.42222404f, 
    -0.75025398f, -0.15382905f, 0.10729864f, -0.14957862f, -0.09308372f, 0.10998081f, -0.06787489f, -0.00965274f, 
    -0.03156964f, -0.09367494f, -0.06795406f, -0.15496664f, -0.16946511f, 0.06945660f, -0.18521968f, -0.30348140f, 
    -0.44093794f, 0.16075701f, -0.41534287f, -0.03062406f, -0.00059241f, 0.09827946f, 0.03521803f, -0.05652225f, 
    -0.07768463f, 0.15412788f, -0.04445061f, 0.07738989f, 0.05882020f, 0.07750092f, 0.01443482f, 0.20347093f, 
    -0.09120633f, -0.25175798f, -0.20591609f, -0.15700556f, -0.35281190f, 0.18050905f, -0.18373641f, -0.19106308f, 
    0.32433179f, -0.08395113f, 0.08348288f, 0.18160701f, 0.13579628f, 0.13562861f, -0.19935951f, 0.03325835f, 
    -0.02149285f, 0.02551938f, -0.05158968f, 0.20031716f, 0.04131727f, 0.07813939f, 0.24031025f, 0.33920175f, 
    0.06338618f, 0.43671036f, 0.30488440f, 0.02949115f, 0.13042247f, 0.03841768f, -0.06247769f, -0.11386570f, 
    -0.01045248f, -0.02301493f, -0.28778183f, 0.18591832f, -0.14057927f, -0.07061511f, -0.08063812f, -0.00248331f, 
    -0.10374518f, 0.02825364f, -0.09782574f, 0.04944992f, -0.52915263f, -0.44045657f, 0.09352588f, 0.18315910f, 
    0.07440576f, -0.05087968f, 0.08395952f, 0.42904127f, -0.29249826f, -0.01168546f, -0.13602789f, 0.16599861f, 
    -0.08828907f, 0.16163173f, 0.12892984f, 0.09479257f, -0.04726936f, 0.34015971f, 0.07435789f, 0.26718223f, 
    -0.11483540f, -0.49834573f, 0.52924782f, 0.14786264f, 0.21667653f, -0.16490026f, -0.08598402f, -0.15749826f, 
    0.13765077f, 0.06770907f, -0.12346835f, -0.15767828f, -0.02050962f, 0.13251503f, 0.00826868f, 0.14710544f, 
    -0.02702393f, 0.18527932f, 0.26700535f, -0.32590213f, -0.12497372f, 0.00058485f, -0.11518996f, -0.14079957f, 
    0.01303722f, 0.05343779f, -0.09310604f, -0.16347213f, 0.06200472f, 0.08625104f, -0.20919366f, 0.18050589f, 
    -0.04233077f, -0.23737808f, -0.24213606f, -0.02327692f, -0.07390757f, -0.04576295f, 0.00995445f, -0.12144803f, 
    -0.57321274f, -0.00219471f, 0.40916926f, 0.25407225f, 0.08007698f, -0.12745102f, 0.07500019f, -0.31788906f, 
    0.75219655f, 0.08277192f, 0.00179954f, 0.08726472f, 0.11910324f, 0.23067264f, 0.06214281f, 0.14627787f, 
    0.01527048f, -0.31306711f, 0.11348387f, -0.06226695f, -0.02792634f, -0.32164925f, -0.39036262f, 0.01375654f, 
    0.24191013f, -0.13507587f, 0.06395511f, 0.16592228f, -0.43343100f, -0.35729876f, -0.02494335f, -0.03418513f, 
    -0.05787304f, -0.01336434f, 0.04032736f, 0.23782998f, -0.49510324f, -0.53927559f, -0.46036720f, -0.41088668f, 
    -0.16497028f, 0.12130733f, 0.37326714f, 0.02130759f, -0.35477072f, 0.07771567f, 0.01955090f, -0.17420095f, 
    -0.20788400f, -0.24894896f, 0.02559579f, 0.03336072f, -0.05938689f, 0.07306764f, -0.09700691f, -0.18972221f, 
    -0.19013660f, 0.08270289f, -0.33167547f, -0.42797300f, -0.45852062f, 0.36303148f, -0.46006456f, 0.40151826f, 
    0.00545052f, 0.11805707f, 0.00993475f, 0.00971935f, 0.48755655f, 0.17298812f, 0.00050422f, -0.14482813f, 
    0.04229284f, -0.05486969f, 0.16010775f, -0.11160436f, -0.04484743f, -0.15791972f, 0.13196084f, 0.12967882f, 
    -0.58990484f, 0.10811664f, -0.81569165f, 0.08907539f, 0.08403476f, -0.13829064f, -0.14735736f, -0.38871205f, 
    0.09155164f, 0.08721115f, -0.07819822f, 0.08605774f, -0.08790828f, 0.00677159f, 0.02111366f, 0.05844744f, 
    -0.03537426f, -0.11996622f, -0.06869949f, -0.03960962f, 0.08512010f, -0.28913039f, 0.35639489f, 0.15015976f, 
    -0.37753302f, -0.27440107f, -0.06653056f, -0.04322809f, -0.09181194f, -0.10502534f, -0.10645984f, -0.11493757f, 
    -0.10030048f, 0.12177719f, 0.06898657f, -0.04401032f, 0.05210990f, 0.10256009f, 0.10296032f, 0.25638613f, 
    -0.20732562f, 0.14283849f, -0.24542394f, 0.20746587f, -0.16827875f, -0.09886156f, 0.04209319f, 0.00426310f, 
    0.07024051f, -0.08031669f, -0.03839233f, 0.06915075f, 0.07009432f, -0.22540297f, -0.05122438f, -0.08135517f, 
    -0.07941177f, 0.06024582f, -0.03858999f, -0.19715165f, -0.30448169f, -0.74581361f, -0.47674307f, 0.10368627f, 
    -0.60609770f, -0.17633054f, -0.22559197f, -0.00272952f, 0.29642144f, -0.06854612f, -0.20651524f, 0.15347321f, 
    0.03729375f, -0.01808158f, -0.02844825f, 0.23004892f, -0.00119141f, 0.16547105f, 0.27716768f, 0.16871753f, 
    0.42847410f, -0.49794394f, 0.54635209f, 0.07440271f, 0.05034637f, -0.28701243f, 0.15803726f, 0.25937495f, 
    0.19623715f, -0.02984994f, 0.01195406f, 0.06979840f, -0.32876143f, 0.07304444f, -0.03517389f, -0.24279685f, 
    0.11666588f, 0.27374282f, -0.02811342f, -0.01361995f, -0.27878419f, -0.06986223f, -0.05821553f, 0.55462486f, 
    0.44339165f, -0.05610087f, -0.03787147f, 0.26531136f, -0.26193663f, 0.03292741f, -0.16911578f, -0.08372776f, 
    0.08323730f, 0.11742596f, 0.04855803f, 0.10986415f, 0.04178597f, -0.23590003f, 0.14002804f, 0.23519848f, 
    0.12165125f, -0.36129946f, -0.08472515f, -0.27468112f, 0.08611082f, -0.02654054f, -0.39544934f, 0.15901041f, 
    -0.16932026f, -0.03461970f, 0.02434941f, -0.03458843f, 0.07125182f, -0.07509976f, 0.09228848f, 0.05880972f, 
    0.01997780f, -0.01785857f, 0.11981248f, 0.05796143f, -0.14424965f, -0.42293897f, -0.02102683f, 0.37234902f, 
    0.16569707f, -0.04479043f, -0.27933884f, 0.02441415f, -0.29207137f, -0.13042314f, 0.11314858f, -0.02880164f, 
    -0.16500342f, -0.02900752f, -0.18959372f, 0.13346250f, -0.22958383f, 0.08597382f, -0.08958565f, -0.26942652f, 
    -1.06035602f, 0.27222896f, -0.52223986f, 0.56028026f, -0.35283768f, -0.06674127f, -0.04054767f, -0.02938179f, 
    0.09129621f, 0.09625944f, -0.07128024f, -0.10636706f, 0.03532684f, 0.03395462f, -0.18682909f, 0.07824238f, 
    -0.12723936f, -0.01397983f, -0.02965548f, -0.01621311f, 0.58591384f, -0.00066609f, 0.68787760f, -0.12939897f, 
    -0.03467190f, 0.13728747f, 0.03961902f, -0.24544226f, 0.07020229f, -0.11369977f, -0.24539720f, -0.00922279f, 
    -0.01493557f, 0.07939395f, 0.08437154f, -0.09858460f, 0.08815339f, -0.24439041f, -0.01443862f, 0.22760491f, 
    0.74554980f, -0.23045331f, 0.72814786f, -0.67770141f, 0.52450454f, 0.16758087f, 0.33445027f, -0.12964346f, 
    0.14551838f, -0.10299236f, 0.01166756f, -0.01190297f, 0.16879085f, 0.00612376f, 0.08111162f, 0.13152671f, 
    0.32704180f, 0.02218327f, -0.13325158f, 0.00044889f, -0.49031264f, 0.10973434f, -0.39907780f, 0.23089437f, 
    -0.70548606f, 0.03015207f, -0.04770246f, -0.12639524f, -0.03535967f, 0.03699581f, -0.05932254f, -0.07068302f, 
    0.08805926f, 0.04192885f, -0.03869466f, 0.00817177f, -0.02857315f, 0.04440985f, -0.02658370f, 0.06208396f, 
    -0.21846510f, -0.16136037f, 0.23277052f, 0.02593811f, 0.02851308f, -0.16343251f, -0.53429198f, -0.05021646f, 
    0.28779146f, -0.16470265f, -0.02664320f, -0.00022747f, 0.06375311f, 0.04448899f, 0.11241920f, 0.25156528f, 
    -0.01082753f, 0.03726042f, 0.47914508f, -0.12779602f, 0.64480406f, -0.28094336f, 0.48840234f, -0.12934360f, 
    -0.06355444f, 0.10283002f, -0.26025316f, 0.12033651f, -0.12570433f, -0.00879962f, -0.03935274f, 0.17035113f, 
    -0.07334945f, -0.12038878f, -0.02276168f, -0.09427278f, 0.19399551f, 0.08873436f, 0.07727712f, 0.11824412f, 
    -0.24747476f, -0.06839736f, -0.57427555f, 0.13433994f, 0.15119147f, -0.05822450f, 0.12810758f, -0.05783590f, 
    -0.06221850f, -0.12471385f, -0.32232594f, -0.04793603f, 0.09365743f, 0.22725870f, 0.22409369f, 0.13402440f, 
    0.02704063f, 0.05353736f, -0.11963326f, 0.06784204f, -0.68428802f, -0.43894777f, -0.28308085f, 0.48774415f, 
    -0.53869134f, -0.07927977f, 0.21430646f, -0.10969868f, 0.45277157f, -0.12251692f, -0.18984039f, -0.00867179f, 
    0.06933038f, -0.07663476f, 0.13542895f, 0.00412974f, -0.05211055f, 0.14022604f, 0.03602750f, 0.10951253f, 
    0.14012226f, -0.52648330f, -0.56411386f, 0.11760508f, -0.22906233f, -0.28021094f, -0.18767789f, 0.05256316f, 
    -0.12525517f, -0.15914401f, 0.03855031f, 0.05474305f, 0.01782145f, -0.08886888f, 0.00401037f, 0.04686944f, 
    -0.09187146f, 0.06981579f, 0.19766128f, -0.03487508f, -0.33691359f, -0.00270231f, -0.17795488f, 0.08838128f, 
    -0.12324362f, -0.13370773f, 0.18761979f, 0.04217376f, 0.08859646f, 0.09753455f, -0.15747572f, 0.20131509f, 
    0.03069321f, 0.09212266f, 0.04024222f, 0.05108514f, -0.00668366f, -0.02135369f, -0.24445009f, -0.20803210f, 
    -0.07873790f, -0.51106483f, -0.04955913f, -0.48281828f, -0.19402766f, 0.04052288f, 0.07127392f, 0.03130873f, 
    -0.08753788f, 0.08066320f, 0.02640442f, -0.03288270f, 0.18738143f, 0.21461129f, 0.01928889f, 0.03295781f, 
    0.15399520f, 0.13585235f, -0.00324969f, 0.12598982f, 0.39657000f, 0.11076606f, 0.40398988f, -0.14194685f, 
    -0.43086144f, -0.11288381f, 0.08677946f, -0.02314349f, -0.02389802f, -0.08642672f, -0.13931836f, 0.06584688f, 
    0.01486282f, -0.02022213f, -0.20204885f, 0.03645501f, 0.24988961f, 0.05427132f, -0.22074006f, -0.06794499f, 
    0.06559782f, -0.03058244f, 0.13474484f, 0.21431640f, 0.69914663f, 0.03386424f, 0.30725512f, -0.00478238f, 
    0.13925643f, -0.03327542f, -0.15058759f, 0.02697313f, 0.00771707f, -0.07431734f, -0.12633483f, -0.16770399f, 
    0.05831259f, 0.08411860f, 0.04693987f, 0.09876686f, 0.04483328f, -0.11368764f, 0.16511771f, 0.24669848f, 
    -0.37074405f, -0.31842119f, -0.46676174f, -0.11570068f, -0.13481854f, 0.26109827f, 0.06673411f, -0.07607270f, 
    -0.02684049f, -0.17505632f, -0.12284385f, 0.02356293f, -0.21447940f, 0.03528293f, -0.19946574f, -0.23552227f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28260085f, 0.18433435f, 0.05053872f, -0.22207054f, 0.01757252f, 0.03932117f, 0.00836520f, -0.07342372f, 
    0.03056340f, 0.06611881f, 0.09965081f, -0.02652937f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
