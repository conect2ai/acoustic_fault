#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.82807958f, -0.08787601f, 0.49979815f, 0.29107574f, 0.14165314f, 0.21693046f, 0.09597520f, 0.02559015f, 
    -0.21479420f, 0.55469877f, 0.65890372f, -0.28501025f, -0.18565629f, -0.46642792f, -0.29835236f, -0.27958632f, 
    0.23098946f, 0.25948718f, -0.45538601f, 0.66511804f, -0.50483549f, 0.14810897f, 0.35143822f, -0.25797796f, 
    0.11191637f, 0.30190542f, -0.27225333f, 0.15258792f, -0.50303072f, 0.36370948f, -0.22338738f, 0.27114052f, 
    -0.21421108f, 0.24512072f, -0.32508823f, 0.29953393f, 0.04024147f, -0.59414381f, 0.62312454f, -0.33482337f, 
    -0.33694458f, -0.16078915f, 0.09762115f, 0.17636147f, 0.51025873f, 0.35099807f, -0.49333376f, 0.08481947f, 
    0.02782036f, 0.57012594f, -0.51065713f, -0.16569848f, -0.34016666f, 0.42294741f, -0.53318554f, 1.11195111f, 
    -0.10919885f, -0.52597237f, 0.25669131f, -0.08997297f, 0.07443129f, -0.03411959f, -0.01873836f, 0.28634205f, 
    -0.44946280f, -0.17303455f, -0.45628825f, 0.42403072f, -0.51575500f, 0.35482875f, 0.22707038f, 0.26358172f, 
    -0.59723163f, -0.28109372f, -0.56241739f, 0.17163847f, 0.14180718f, 0.20691720f, -0.39382142f, 0.20453671f, 
    0.50785947f, 0.07131217f, 0.10576604f, -0.37327293f, -0.76106238f, -0.21568829f, -0.83785313f, -0.43572891f, 
    -0.36495003f, -0.38660112f, 0.61480445f, -0.55720454f, -0.75011903f, 0.34004560f, 0.16152303f, 0.51269120f, 
    -0.47521177f, -0.07515483f, 0.27432266f, 0.17102633f, 0.17837889f, 0.28523722f, -0.39292213f, 0.40484616f, 
    -0.36904177f, 0.37393725f, -0.37249640f, -0.02777754f, 1.22392380f, -0.91053671f, -0.83250260f, 0.51747024f, 
    -0.32456708f, 0.62699151f, 0.08590410f, 0.10704680f, -0.37257594f, -0.73079437f, 0.17511594f, 0.20028494f, 
    -0.40201864f, -0.07603311f, 0.63910604f, 0.16195862f, 0.08030991f, -0.20568971f, -0.87027001f, -0.49767107f, 
    0.49873233f, -0.51880461f, 0.16167386f, 0.67473781f, -0.22545621f, 0.39382517f, -0.07838607f, -0.46807835f, 
    0.31859651f, -0.68898815f, 0.29498422f, -0.02392043f, -0.10545120f, 0.23395121f, 0.05203219f, 0.30892226f, 
    0.37852988f, 0.01623040f, 0.03451776f, -0.07397517f, 0.03525794f, 0.28127822f, -0.50437748f, -0.17692253f, 
    0.34893069f, 0.14478835f, -0.77622390f, 0.02641274f, -0.68111414f, -0.81318229f, -0.14099357f, -0.23649316f, 
    0.54882509f, 0.01887161f, 0.45277128f, -0.94715583f, 0.53230226f, 0.35187343f, 0.76016098f, -0.66527998f, 
    -0.20423241f, -0.23361734f, -0.36079159f, 0.38927838f, 0.26620403f, -0.05350963f, -0.53320241f, 0.10311116f, 
    0.48600847f, -0.19635019f, -0.43890649f, -0.04397093f, 0.38019553f, 0.06931999f, -0.20604318f, 0.05223006f, 
    0.13608605f, 0.13355792f, -0.27176562f, 0.42930314f, -0.23506515f, 0.40646362f, 0.02955307f, -0.05435926f, 
    0.05793360f, 0.28166980f, 0.05437628f, 0.04767669f, 0.16633779f, 0.15226044f, -1.26443589f, 0.70163131f, 
    0.53840983f, 0.17641540f, 0.14262629f, -0.04896034f, -0.14988574f, 0.25296548f, -0.35310671f, -0.46249607f, 
    -0.10231375f, -0.42066732f, 0.24386123f, 0.04391260f, 0.31593469f, 0.36238870f, -0.04895053f, -0.09791341f, 
    0.69639403f, 0.08647638f, -0.03289911f, 0.52571666f, -0.57437110f, -0.33195347f, 0.32573172f, -0.32760796f, 
    -0.05808008f, -0.18213980f, 0.09755845f, -0.05231500f, 0.13216907f, 0.24186087f, -0.53445339f, -0.32264480f, 
    0.23301876f, 0.48559991f, 0.41699877f, -0.17916299f, 0.36773375f, 0.00310301f, 0.07867415f, -0.04146326f, 
    0.15020449f, 0.01972605f, -0.14695521f, 0.44613042f, -0.65083766f, -0.62314397f, 0.19828171f, 0.16196203f, 
    0.06849264f, 0.15634830f, 0.25946692f, 0.04018868f, -0.70051336f, 0.10671346f, -0.42175353f, -0.67533630f, 
    -0.70045543f, 0.18733600f, -0.00883041f, -0.55221826f, -0.03713791f, -0.13228287f, 0.24760142f, -0.07131779f, 
    -0.19973440f, 0.12120295f, 0.10178644f, -0.48911130f, 0.55413580f, 0.11933307f, 0.07644324f, 0.05181529f, 
    -0.35012934f, 0.20881814f, 0.47624698f, 0.07135560f, 0.16784437f, -0.01016203f, -0.17639175f, -0.61095691f, 
    0.29531246f, 0.34268552f, -0.56933296f, 0.20677285f, 0.30334172f, 0.19405079f, 0.23731604f, -0.32986045f, 
    -0.38311520f, -0.71079689f, -0.68309689f, -0.29825974f, 0.19379336f, 0.53177208f, 0.31199577f, 0.29793796f, 
    0.09277563f, -0.87743944f, -0.64325708f, -0.21335913f, 0.53081220f, -0.20095772f, 0.59606814f, -0.08425201f, 
    -0.15562689f, 0.26241788f, 0.65448803f, -0.21362980f, -0.37603900f, 0.04576895f, -0.26882023f, -0.15024512f, 
    -0.47263077f, -0.19194992f, -0.63920408f, 0.49951172f, -0.58985204f, 0.38736731f, -0.16775951f, -0.32348078f, 
    0.16881074f, 0.06285996f, 0.07317485f, -0.10281898f, 0.31903318f, -0.19920948f, 0.13848267f, -0.28436187f, 
    0.11985844f, 0.31111157f, 0.22267863f, 0.08503319f, -0.29392627f, 0.32219112f, 0.43295231f, 0.19989249f, 
    -0.36259913f, -0.37942174f, -0.13185312f, 0.35487908f, 0.02803714f, 0.27770698f, -0.49609607f, 0.82789934f, 
    0.50926882f, -0.90396529f, -0.29111347f, 0.23836410f, -0.30495963f, 0.26605296f, 0.25395665f, -0.52861810f, 
    -0.36148196f, -0.31665847f, 0.59657395f, 0.41253197f, -0.01173097f, 0.16280314f, -0.21426328f, -0.07828161f, 
    0.13611640f, 0.09262209f, 0.21175446f, -0.22416450f, 0.34871733f, -0.39271536f, -0.01496734f, 0.01489169f, 
    0.23861118f, -0.29940462f, -0.40774739f, -0.61017489f, -0.45502612f, -0.28197578f, 0.30368459f, 0.16414039f, 
    -0.23240736f, -0.36694896f, 0.01640451f, 0.21676442f, 0.10926965f, 0.20172049f, -0.28324851f, -0.36758268f, 
    -0.01439562f, 0.12732525f, 0.32178089f, 0.75810105f, 0.91046596f, -0.78233278f, -0.34329239f, -0.22165233f, 
    -0.02479587f, -0.14602983f, -0.04924180f, 0.29605848f, -0.02939519f, -0.44584680f, 0.47547090f, 0.36906877f, 
    -0.18981035f, 0.01526850f, -0.40986145f, -0.25488201f, 0.37275124f, 0.19036798f, 0.25785959f, -0.31319061f, 
    0.11766408f, 0.20457216f, 0.30195838f, 0.17520587f, -0.42717916f, -0.29436052f, 0.46770668f, -0.13369770f, 
    0.07717522f, 0.15541229f, 0.00352346f, -0.20858714f, 0.09697982f, 0.20746179f, -0.06909747f, -0.52351028f, 
    0.17190048f, 0.35747701f, 0.56807148f, 0.21279749f, -0.32592636f, -0.36488137f, -0.30461717f, -0.14109100f, 
    -0.41120705f, -0.02083507f, 0.25693274f, -0.53314954f, 0.27607614f, 0.72878981f, -0.45241022f, -0.51155496f, 
    0.46512663f, -1.05230272f, -0.36387870f, -0.79709774f, 0.25641301f, 0.63831991f, -0.12005976f, -0.05364349f, 
    -0.52489132f, -0.52608728f, -0.84258592f, -0.65174592f, 0.24912572f, -0.63228375f, -0.90245008f, 0.09101970f, 
    0.33786884f, 0.43703851f, -0.02231393f, 0.20946719f, -0.47189572f, -0.59897774f, 0.87598985f, -0.62866110f, 
    0.02294591f, 0.26418272f, -0.09196891f, 0.12191007f, 0.53678882f, 0.43332312f, -0.67713356f, -0.06819016f, 
    0.43180287f, 0.32980081f, -0.34776127f, -0.16399862f, -0.16394155f, 0.89470679f, -0.55582833f, -0.90002847f, 
    -0.07197698f, 0.33549801f, 0.20994174f, -0.24151443f, 0.22561149f, -0.05272547f, 0.85765183f, -0.55138445f, 
    -0.79176253f, 0.02682083f, -0.52586788f, -0.70276892f, -0.59669626f, -0.32554349f, -0.08772666f, -0.82552820f, 
    -0.87729532f, -0.18129268f, 0.16336827f, -0.00338792f, -0.19089380f, 0.10819519f, -0.33093348f, -0.39581951f, 
    -1.01648569f, 0.05006056f, 0.76121634f, 0.01099484f, -0.30037344f, 0.21006906f, -0.20530500f, -0.52882868f, 
    -0.55571681f, -0.80592835f, -0.50218904f, -0.02343683f, -0.68709075f, -0.97493869f, -0.95904171f, 0.33644024f, 
    -0.02415754f, 0.43651021f, 0.40827054f, -0.20022431f, -0.01917880f, 0.11092731f, -0.27182996f, 0.33128759f, 
    -0.55146348f, 0.45653018f, 0.00821014f, 0.05717943f, 0.11165254f, 0.06026452f, -0.19550821f, 0.30330804f, 
    -0.14880683f, 0.00724950f, -0.19206668f, 0.24370170f, 0.47621629f, 0.48515108f, -0.64926809f, 0.12146914f, 
    -0.09904794f, -0.54999101f, 0.17670867f, 0.36190826f, -0.02333208f, 0.32480469f, -0.35944238f, 0.09030883f, 
    0.20215838f, 0.11580815f, -0.14701366f, -0.38941434f, 0.04240618f, 0.34376281f, -0.95329720f, 0.85798132f, 
    -0.69842774f, -0.09593443f, 0.48652422f, 0.65582448f, -0.20709360f, -0.04103181f, -0.21418943f, -0.09062684f, 
    -0.17570290f, 0.30307305f, -0.45650503f, 0.47411150f, 0.04078982f, 0.17966685f, -0.17956188f, 0.21808414f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02172443f, 0.06349888f, -0.01621256f, 0.00944182f, 0.01069180f, 0.00776282f, 0.14547162f, -0.01853066f, 
    -0.05606763f, -0.11545602f, 0.13264100f, 0.27447683f, -0.01905843f, -0.01956998f, -0.13749710f, 0.05640416f, 
    0.02669704f, 0.17893432f, -0.06648797f, 0.04535977f, -0.16069093f, -0.23565240f, -0.01545234f, 0.02297985f, 
    0.18154995f, -0.06812741f, -0.14888039f, 0.00797736f, -0.16587955f, -0.18339768f, 0.17396767f, 0.11727811f, 
    -0.00748992f, -0.16678558f, 0.00483930f, 0.10975707f, -0.08773152f, -0.08051345f, 0.24269943f, 0.09778260f, 
    -0.05624386f, -0.07507730f, -0.15969127f, 0.21644868f, -0.01648509f, 0.26959097f, -0.17116430f, -0.10514317f, 
    0.05379715f, -0.10211600f, 0.05251445f, 0.14052707f, 0.29313236f, 0.18741754f, -0.09149864f, 0.00712900f, 
    -0.10116343f, -0.23120645f, 0.13291731f, -0.02787503f, 0.15179744f, -0.01399770f, 0.07054774f, -0.11314038f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00455814f, -0.21961860f, 0.06721100f, -0.08458481f, 0.03626616f, -0.07000902f, 0.02953901f, 0.05127980f, 
    0.04115911f, -0.00057634f, 0.00064975f, -0.02046644f, -0.11476921f, -0.02264838f, -0.12892330f, -0.00488311f, 
    0.00054232f, 0.03349844f, -0.05398531f, 0.02618249f, -0.07899702f, -0.05624232f, -0.31155124f, 0.00359612f, 
    -0.28097740f, 0.03494878f, -0.12182391f, -0.17244428f, -0.12561832f, -0.15640946f, 0.03986555f, 0.04552748f, 
    -0.04525041f, 0.02296919f, 0.05433626f, -0.02812151f, 0.02097486f, -0.04890782f, -0.05015536f, -0.12546867f, 
    -0.00946331f, -0.04698603f, -0.11487119f, 0.02347535f, 0.04206148f, -0.02914719f, 0.00505628f, 0.00231479f, 
    -0.02423705f, 0.02948585f, -0.13572185f, -0.03761284f, -0.15761761f, -0.03411472f, -0.04466959f, -0.04622855f, 
    0.05729865f, 0.01860742f, -0.08506825f, -0.04908962f, -0.04303163f, 0.03534603f, 0.04189823f, -0.08690318f, 
    -0.00660605f, -0.01178101f, 0.00150143f, 0.06272252f, -0.06503770f, 0.01569207f, -0.08547646f, 0.04172080f, 
    -0.13912800f, -0.00724228f, -0.04384957f, -0.03474697f, -0.04808148f, -0.07038022f, -0.04491165f, -0.05613288f, 
    0.15088029f, 0.20884100f, 0.18211871f, -0.10637566f, 0.00754585f, -0.17860121f, 0.07879040f, 0.04107777f, 
    -0.14249182f, -0.05638246f, 0.16204555f, -0.00436744f, 0.01809874f, -0.02362361f, -0.02794288f, 0.00819450f, 
    -0.00351025f, -0.03674246f, -0.01091111f, -0.21599284f, 0.03019125f, -0.01236013f, -0.01107836f, -0.03328022f, 
    -0.02975365f, -0.07646661f, -0.19897839f, 0.06338412f, -0.20510902f, 0.07987194f, -0.11676365f, 0.00500413f, 
    -0.13081446f, -0.00577507f, -0.05174029f, -0.27936679f, -0.03598620f, -0.17679526f, -0.19391042f, -0.00127466f, 
    -0.47447374f, -0.23021823f, 0.17753492f, 0.23448665f, -0.17843020f, -0.01763697f, -0.27796668f, -0.13019936f, 
    0.01989844f, 0.02759833f, -0.00587251f, 0.05213672f, -0.01281431f, 0.02557707f, -0.01149700f, -0.20112358f, 
    0.09927510f, -0.00761753f, -0.25795466f, -0.02538978f, 0.18484308f, 0.27743584f, -0.01513086f, -0.09632734f, 
    -0.03455352f, -0.00722579f, -0.02195664f, 0.01977609f, -0.08717487f, 0.01810317f, -0.00845752f, 0.17048259f, 
    -0.01822102f, 0.02012316f, 0.01512580f, -0.00842623f, -0.01828573f, -0.05217623f, -0.08697098f, 0.02073928f, 
    0.21161091f, 0.11816644f, -0.05590307f, -0.00854283f, 0.08520439f, 0.18879411f, 0.17003812f, 0.13359457f, 
    -0.22199899f, -0.08002407f, -0.14914927f, -0.02863261f, 0.00913399f, 0.00298897f, 0.07875834f, 0.00469670f, 
    0.02232940f, -0.01952533f, -0.00568580f, 0.03694324f, 0.08679925f, 0.17847319f, 0.13968162f, -0.14585605f, 
    -0.13188794f, -0.03234965f, 0.02518888f, 0.03256188f, -0.06946446f, 0.02650396f, -0.04427806f, -0.02881125f, 
    0.00123743f, -0.01183238f, -0.01264308f, -0.05535270f, -0.08734509f, 0.00372679f, 0.03971700f, 0.05838044f, 
    -0.02804678f, -0.17314079f, -0.30132422f, 0.06784518f, 0.05895111f, 0.07377247f, 0.03727296f, -0.01761670f, 
    -0.08948950f, -0.06287275f, -0.02166024f, -0.01615595f, -0.03901530f, -0.07596614f, -0.02597387f, 0.05444685f, 
    0.06476087f, -0.07281283f, 0.00703783f, 0.00065581f, -0.41345376f, -0.40494084f, 0.07491372f, -0.18865044f, 
    -0.02712803f, -0.06462173f, -0.01299205f, -0.02470872f, -0.05505176f, 0.04638091f, -0.01342624f, 0.04090127f, 
    -0.00221965f, 0.01044296f, 0.03985570f, -0.07145144f, -0.03582802f, -0.18939485f, -0.10533222f, -0.01080711f, 
    0.07879428f, -0.18492040f, -0.54442459f, 0.04942671f, 0.01600950f, 0.01818510f, -0.03579625f, -0.00642092f, 
    -0.12723242f, 0.00383813f, -0.07667907f, 0.05104899f, -0.18039580f, -0.13635072f, -0.07832052f, 0.03248195f, 
    0.05438702f, -0.02488174f, 0.01192998f, 0.04871449f, -0.29145265f, 0.02269688f, 0.25437379f, -0.03446031f, 
    -0.03557342f, -0.05166173f, 0.01086554f, 0.11087383f, 0.05832955f, -0.09295726f, -0.03573526f, -0.03137371f, 
    -0.09972614f, 0.05112801f, 0.07879253f, 0.02011631f, -0.07281350f, 0.01622929f, -0.03403761f, -0.03509501f, 
    0.12820286f, 0.06467593f, 0.20563787f, -0.03402947f, -0.02541673f, 0.06498432f, 0.00935871f, 0.21903977f, 
    0.01640961f, -0.25414446f, -0.09775093f, -0.03253272f, -0.00241387f, 0.00497133f, -0.01848000f, 0.02351389f, 
    0.00479910f, 0.02525758f, 0.03969664f, -0.03255194f, 0.08823950f, 0.02407947f, -0.13564880f, -0.01967521f, 
    0.06626569f, 0.07220029f, 0.04012756f, 0.05499008f, -0.01819793f, -0.01356860f, -0.05686655f, -0.05823724f, 
    -0.05397063f, -0.01892248f, 0.02012320f, -0.06623911f, 0.03158268f, -0.03670865f, -0.02962209f, -0.04068711f, 
    -0.27240679f, -0.08306048f, 0.07283104f, -0.01593838f, -0.01267285f, 0.02629650f, -0.01604832f, -0.03634538f, 
    0.04435435f, 0.01818119f, 0.06532906f, 0.01593800f, 0.01780941f, -0.00524221f, -0.00195871f, 0.01504409f, 
    0.12861817f, -0.13491793f, 0.02102393f, -0.05897518f, 0.16890126f, 0.18157326f, -0.03101596f, -0.33433947f, 
    -0.15013169f, 0.04282563f, 0.04441598f, 0.03629422f, -0.09192199f, -0.04854029f, -0.02732673f, -0.06243717f, 
    0.02687624f, 0.01398036f, -0.04051521f, -0.02441786f, -0.06713507f, -0.03047479f, 0.11242399f, -0.04492263f, 
    0.42842758f, -0.31874114f, -0.18779734f, -0.20168856f, -0.07080451f, -0.01489959f, -0.12464389f, 0.06848513f, 
    -0.05692966f, 0.09050050f, -0.02343193f, 0.00188152f, 0.06147106f, 0.06727608f, -0.00380261f, -0.11931924f, 
    0.00996472f, 0.06830705f, -0.20125276f, 0.19963080f, -0.33942363f, 0.07352404f, 0.39798060f, 0.10866062f, 
    -0.00358611f, 0.01840227f, -0.04339528f, -0.06884440f, 0.03611244f, 0.01590102f, 0.06898991f, -0.02017163f, 
    -0.01508363f, 0.02957310f, 0.00426645f, 0.07242753f, 0.10340882f, -0.01993513f, 0.04507030f, -0.13827153f, 
    -0.08721679f, -0.05437767f, -0.03837483f, 0.01835618f, -0.00235387f, 0.04538010f, 0.06159256f, 0.03439840f, 
    0.04328503f, 0.07122106f, 0.00398444f, 0.05841190f, -0.01004400f, -0.19461980f, -0.02126513f, -0.05565470f, 
    0.03649690f, -0.08669697f, 0.03545934f, 0.01783682f, -0.03277254f, 0.00628735f, 0.03290439f, 0.02083047f, 
    0.02322210f, 0.02842696f, 0.04417988f, 0.03276887f, 0.06576290f, 0.05351003f, -0.14172739f, -0.17789407f, 
    -0.15685010f, -0.22012144f, -0.23145306f, -0.00635244f, -0.03447614f, -0.01064721f, 0.02264076f, 0.02418949f, 
    -0.56237620f, 0.19713750f, 0.07279269f, -0.08945440f, -0.06694446f, -0.13265350f, -0.02169406f, 0.14707714f, 
    0.06369951f, -0.04208563f, -0.02568165f, -0.02073844f, -0.09996689f, -0.08460239f, -0.08453774f, -0.05837229f, 
    0.05232967f, 0.04942943f, -0.09220447f, 0.14856298f, 0.06569685f, -0.02705418f, -0.08593297f, -0.01477697f, 
    0.02901564f, 0.05130745f, 0.08600380f, 0.04548965f, 0.00781756f, -0.05850240f, -0.00927174f, -0.03371087f, 
    -0.04984473f, -0.00381688f, 0.08077986f, 0.00414187f, 0.04656294f, -0.01255223f, -0.00227936f, -0.02692163f, 
    -0.48723507f, -0.30030739f, -0.29782268f, 0.10802434f, -0.02323466f, -0.06657013f, 0.01317018f, -0.00520101f, 
    0.06030638f, -0.01186146f, -0.03673518f, 0.00593410f, -0.01356233f, 0.02141515f, 0.00036479f, -0.06000232f, 
    0.03632224f, -0.02400951f, -0.04691132f, -0.14467087f, 0.13775854f, 0.04641342f, -0.09222268f, 0.02402277f, 
    -0.02503988f, 0.04987004f, 0.04026899f, 0.00799295f, 0.01099101f, -0.00990996f, 0.01491830f, 0.04037350f, 
    -0.03124734f, -0.04164932f, 0.03917136f, -0.08197660f, -0.06697474f, -0.06171474f, -0.00519498f, -0.02338550f, 
    -0.07891297f, -0.01638017f, -0.03494209f, 0.04758326f, 0.03815207f, -0.00241556f, 0.03618905f, 0.03458431f, 
    -0.01810819f, 0.00451857f, -0.00743324f, 0.03832234f, 0.09387010f, 0.05969363f, 0.05475610f, -0.05280166f, 
    -0.13923085f, -0.10927883f, -0.04475441f, 0.00957583f, 0.19569056f, 0.11782122f, -0.22921969f, 0.02602395f, 
    0.07305741f, 0.08557967f, 0.02603444f, 0.06855040f, -0.03544994f, -0.13904814f, -0.05611783f, -0.01156005f, 
    -0.07022847f, 0.00807706f, 0.02239728f, -0.00624221f, 0.03163315f, -0.01041931f, 0.01290921f, 0.02577488f, 
    0.16121130f, 0.22573183f, 0.23853491f, -0.24530533f, 0.00230341f, 0.06299113f, 0.21154027f, 0.11917557f, 
    -0.01831096f, -0.06911556f, -0.00715198f, -0.07713813f, -0.01423080f, -0.08702608f, -0.06786796f, -0.11330890f, 
    -0.04594919f, 0.02014036f, -0.11456892f, 0.02781353f, 0.01773248f, -0.06791928f, 0.04815985f, 0.05409811f, 
    0.01528260f, 0.01992793f, -0.00501749f, 0.04816302f, 0.02493964f, -0.00744786f, -0.21167248f, 0.05710749f, 
    0.07682185f, -0.08081917f, 0.02947131f, -0.10284521f, -0.07629108f, 0.01071499f, -0.02392466f, 0.03870699f, 
    -0.07310405f, -0.04845257f, -0.16006669f, 0.06104321f, 0.01826016f, -0.02164904f, -0.01003395f, -0.00718136f, 
    -0.00123468f, 0.01780853f, -0.02410421f, -0.07079174f, -0.14766166f, -0.00794665f, -0.04894589f, -0.00589053f, 
    0.05091845f, 0.04822182f, -0.00991419f, -0.01524446f, -0.20248608f, -0.02832747f, 0.19223501f, 0.01316983f, 
    -0.06278536f, -0.14673817f, 0.01204209f, 0.02851358f, 0.03014657f, 0.00396527f, -0.08376310f, -0.08835462f, 
    -0.13333975f, 0.00206049f, -0.03638728f, -0.06036635f, -0.03751833f, 0.01513215f, -0.05662524f, -0.02612927f, 
    0.33498242f, 0.26357797f, -0.01221863f, -0.05142882f, 0.03890176f, 0.18178210f, 0.08891825f, 0.16058040f, 
    -0.06969006f, -0.19610219f, -0.06617521f, -0.04957921f, -0.04933929f, 0.04665903f, 0.04311231f, 0.02873957f, 
    -0.00691615f, -0.04496282f, 0.02613941f, -0.00150072f, 0.41287792f, 0.14001642f, 0.12189395f, -0.16872661f, 
    0.06194855f, 0.13372383f, 0.18881452f, 0.14144224f, -0.02635261f, -0.06096439f, -0.07453465f, 0.03381781f, 
    -0.01939556f, -0.01781739f, 0.12142073f, 0.02707039f, 0.05412069f, 0.03646928f, -0.01446819f, -0.00822554f, 
    0.02294097f, 0.04936317f, 0.13983409f, -0.12936877f, -0.08528547f, -0.07761240f, -0.06886258f, -0.05468388f, 
    -0.01384050f, 0.03629288f, -0.04275269f, -0.04917691f, -0.02492793f, -0.00145549f, 0.01142514f, 0.09804101f, 
    -0.03246329f, 0.12695484f, 0.07489170f, 0.16226378f, -0.27761313f, -0.05287332f, 0.05996856f, -0.31117773f, 
    0.13305524f, -0.19265443f, -0.05001444f, -0.03513539f, -0.04780662f, 0.01979445f, -0.03634949f, -0.00559042f, 
    0.00064639f, 0.00138930f, 0.00365156f, -0.01611140f, -0.01406210f, -0.00648269f, -0.17590943f, 0.00203898f, 
    -0.06747549f, -0.05201899f, -0.00719070f, -0.01009471f, 0.02401011f, -0.00573840f, 0.05025522f, -0.00033762f, 
    0.00244704f, 0.00918736f, -0.07277215f, 0.00714277f, -0.02387959f, 0.06338841f, 0.01558532f, 0.05042870f, 
    -0.07599790f, 0.02673677f, -0.06057393f, 0.01354800f, 0.00961951f, 0.00442537f, 0.03899691f, -0.03563432f, 
    0.00151804f, -0.13101076f, -0.07764474f, -0.00365555f, 0.01083654f, 0.02481265f, 0.01403133f, 0.05787680f, 
    0.02352656f, 0.03228405f, 0.01295843f, -0.00112783f, 0.04114333f, 0.01381958f, -0.02742313f, -0.04200390f, 
    -0.20038332f, -0.06101805f, 0.17292778f, 0.01227763f, -0.11353706f, -0.16322826f, -0.18813902f, -0.11881937f, 
    -0.01864623f, -0.12098734f, 0.04680137f, 0.01404203f, -0.00276674f, 0.01993298f, -0.02325921f, -0.10454525f, 
    0.01577348f, -0.00215635f, -0.19480282f, -0.00603011f, 0.12926221f, -0.15254837f, -0.38919678f, -0.01952697f, 
    0.02837011f, 0.08055159f, 0.08206625f, 0.04521226f, -0.03021505f, 0.02232386f, 0.01390139f, 0.03078113f, 
    -0.01424911f, 0.01930658f, 0.05377574f, -0.02093761f, 0.04376597f, 0.04401760f, 0.00977516f, -0.02117776f, 
    0.00063485f, -0.00496636f, -0.03380260f, 0.02039021f, -0.00574178f, -0.04870318f, -0.03950658f, 0.01087945f, 
    0.03230958f, 0.02607294f, -0.02475193f, 0.08506692f, 0.03730950f, 0.02714639f, -0.03786027f, -0.06699532f, 
    -0.04450867f, -0.05903235f, -0.04862165f, -0.05028004f, 0.27406260f, 0.15906286f, 0.07600270f, -0.16643743f, 
    -0.13564827f, 0.10307895f, 0.13053697f, 0.12496944f, -0.04939985f, -0.04817048f, -0.01845086f, -0.04517158f, 
    -0.04479518f, -0.06869727f, -0.01358074f, -0.01363298f, -0.07216452f, -0.01204866f, -0.04238055f, -0.01302609f, 
    0.06997611f, 0.02581678f, -0.06577548f, 0.05055131f, -0.00001904f, -0.04494496f, -0.01256420f, -0.04150515f, 
    0.06400073f, 0.01680762f, 0.04943016f, 0.02673054f, -0.04956960f, -0.01699386f, -0.04022858f, -0.03773239f, 
    -0.00182146f, -0.03653842f, -0.00237504f, -0.05098751f, -0.44502765f, -0.20640045f, -0.15208922f, 0.01686442f, 
    -0.39479741f, 0.04159288f, -0.02812867f, -0.06384093f, -0.03149875f, -0.00216647f, 0.00673211f, 0.01050970f, 
    -0.03946062f, 0.07465244f, 0.08602657f, -0.07106343f, 0.06601716f, -0.03693660f, -0.05525265f, -0.16535628f, 
    0.11622380f, 0.06716237f, -0.03015507f, -0.18370378f, 0.08397415f, -0.01338928f, -0.06260816f, -0.00014692f, 
    0.03275136f, 0.00609813f, 0.01477225f, 0.01537483f, 0.04639673f, -0.00238383f, -0.03525780f, -0.12986717f, 
    0.06169511f, -0.00896418f, 0.10331239f, -0.17346847f, -0.16560577f, -0.14007080f, -0.12477291f, 0.04481035f, 
    -0.10686097f, -0.02337817f, -0.02465855f, -0.01552566f, 0.00505493f, 0.03327636f, 0.00145513f, -0.03903732f, 
    -0.07007900f, -0.00503852f, 0.01176635f, -0.03529246f, -0.02247288f, 0.06329031f, 0.03016941f, -0.01115429f, 
    -0.00931101f, -0.00009475f, -0.06768202f, 0.02792601f, 0.00227135f, -0.03265996f, 0.01781027f, -0.03902572f, 
    0.02473365f, 0.04473360f, -0.03037069f, 0.05299777f, 0.07176705f, 0.03773711f, -0.01702016f, -0.07894101f, 
    -0.05479421f, -0.14499296f, -0.06076388f, 0.02213766f, 0.40135920f, 0.29643807f, -0.41434988f, -0.08859944f, 
    0.10152076f, -0.01234284f, -0.05087208f, -0.02502623f, 0.03614334f, 0.02109630f, -0.02632368f, 0.06151331f, 
    0.05816419f, 0.05858376f, 0.08436557f, -0.05288950f, -0.03515804f, 0.11102550f, 0.17144959f, 0.07867178f, 
    -0.52052844f, -0.48958489f, 0.29360816f, 0.04060102f, 0.10626970f, 0.02382924f, -0.01998443f, -0.00728578f, 
    0.03052210f, 0.03268330f, -0.10150648f, 0.09390313f, 0.06184175f, -0.05148149f, -0.13438714f, -0.04456175f, 
    -0.03196777f, 0.01724328f, -0.12416829f, -0.15083177f, 0.34527227f, 0.11294318f, -0.14517702f, -0.15709284f, 
    -0.09425424f, 0.09638313f, 0.10443060f, 0.10631057f, 0.02362129f, 0.03905704f, 0.02965437f, 0.02224395f, 
    -0.03378557f, -0.00190243f, 0.08139005f, -0.01729054f, 0.03887597f, -0.08175790f, -0.02220592f, -0.01615717f, 
    0.23460975f, 0.32717672f, 0.18805768f, -0.39336750f, -0.04121484f, -0.00853359f, 0.01022233f, -0.01315697f, 
    0.04108911f, -0.08193161f, 0.04981900f, -0.00684469f, -0.04314806f, 0.02035994f, -0.00435175f, 0.01640946f, 
    -0.04016965f, -0.01585450f, -0.07423584f, -0.10900612f, 0.30155197f, 0.06143798f, -0.34158081f, -0.15832654f, 
    0.05039526f, -0.00309726f, 0.09209757f, 0.07501469f, -0.01043159f, -0.17067403f, -0.06494065f, 0.06474237f, 
    0.02104916f, -0.03536749f, -0.01452521f, -0.01994769f, 0.04176729f, -0.04609028f, 0.00002653f, 0.01093792f, 
    -0.38108870f, -0.27680570f, -0.14414892f, 0.16601931f, -0.22845955f, -0.00030609f, 0.00071078f, -0.01948832f, 
    0.04300629f, 0.06345487f, 0.06473305f, -0.04744423f, -0.09910773f, -0.02130516f, 0.02031896f, -0.02081519f, 
    0.06576813f, -0.05475372f, 0.02191609f, -0.01144713f, 0.04230488f, 0.11127894f, -0.31031877f, 0.08095620f, 
    -0.10526110f, 0.12597823f, -0.04052937f, -0.03587366f, -0.07271712f, -0.03735065f, -0.08418646f, -0.05391394f, 
    -0.12263749f, -0.04638788f, -0.09028253f, 0.03267792f, 0.06206360f, -0.01082570f, -0.03118416f, 0.05662528f, 
    0.14411870f, 0.08599734f, 0.04752913f, -0.07116330f, -0.03273420f, 0.11110670f, 0.06453414f, 0.12781760f, 
    -0.16408335f, 0.03600715f, -0.06843607f, -0.02759366f, -0.02563859f, -0.03780884f, -0.11184264f, -0.02495151f, 
    -0.08956151f, 0.07135124f, 0.09273182f, 0.11437790f, 0.33316424f, 0.11071475f, 0.04524556f, -0.22140621f, 
    -0.07234579f, 0.16976504f, 0.15556291f, 0.13760626f, 0.01093915f, -0.02282007f, 0.03424830f, -0.00901452f, 
    -0.03818902f, 0.02027615f, 0.02293544f, -0.02062809f, -0.04783824f, -0.01908659f, -0.03546429f, -0.00932658f, 
    0.27905244f, 0.24783500f, 0.32313398f, -0.38738003f, 0.22941850f, -0.07907896f, -0.07289229f, -0.00572120f, 
    0.09222446f, 0.00981573f, 0.04774810f, 0.04824975f, -0.07695404f, -0.01153804f, -0.00546251f, 0.13604085f, 
    -0.05701705f, -0.13961318f, 0.08853001f, 0.18708965f, 0.28688091f, 0.31887028f, 0.07877034f, -0.42731282f, 
    -0.07635972f, 0.06639322f, 0.11028273f, 0.01502883f, 0.15528406f, 0.16124639f, 0.05537401f, -0.02857008f, 
    -0.00621585f, 0.02165140f, -0.03142129f, 0.00521390f, -0.02642763f, 0.04583153f, -0.04369916f, -0.02366023f, 
    -0.51561177f, -0.24836820f, 0.01947622f, -0.01335060f, -0.02497106f, -0.03340064f, 0.01809877f, -0.00334488f, 
    -0.02656811f, 0.01423160f, -0.00950343f, -0.01104946f, -0.00832498f, -0.06235101f, -0.01763287f, -0.13651244f, 
    -0.05478656f, -0.19006851f, 0.03085734f, -0.03579380f, -0.07413966f, -0.04311359f, -0.01812721f, 0.00110378f, 
    0.01152463f, 0.01879577f, -0.00040762f, 0.00841388f, 0.03733261f, 0.02580921f, -0.02285987f, 0.07146914f, 
    -0.02948465f, -0.00175651f, -0.02276625f, -0.04245749f, -0.11073797f, 0.02621329f, -0.05004251f, -0.00514375f, 
    0.04929644f, -0.06047409f, -0.33723781f, 0.09370676f, -0.09417108f, -0.05586156f, 0.00059149f, -0.11446103f, 
    0.01234425f, -0.00103149f, -0.09440345f, 0.00552020f, -0.07040162f, -0.06174204f, -0.04265644f, -0.02438821f, 
    -0.01189369f, -0.13613190f, -0.06791905f, -0.12758885f, -0.07506862f, -0.07623579f, 0.04964519f, 0.04914103f, 
    0.01766655f, 0.03375566f, -0.02007320f, -0.04457982f, -0.02878414f, -0.01517305f, 0.03183158f, -0.09047534f, 
    -0.00844345f, -0.12769654f, -0.03752090f, -0.03235970f, 0.08136166f, -0.06370706f, 0.01602191f, -0.02539243f, 
    -0.39384669f, -0.51985109f, 0.03996355f, 0.06452502f, 0.01929018f, -0.00038251f, 0.04606974f, -0.05385151f, 
    0.02601276f, -0.01985565f, 0.04531431f, -0.00590225f, 0.10158394f, 0.13931365f, 0.00489087f, 0.01798248f, 
    0.09333796f, 0.04271151f, -0.08157460f, -0.00475565f, -0.03929006f, 0.02506676f, 0.12201703f, -0.01097341f, 
    0.04462442f, -0.00608414f, -0.01421442f, 0.04079238f, 0.01714231f, 0.01663743f, -0.17173402f, 0.08897290f, 
    -0.06860918f, 0.01311714f, 0.00435384f, 0.00606793f, -0.05728350f, -0.02604668f, -0.03957806f, -0.00302016f, 
    0.06532121f, -0.09586599f, -0.00052452f, 0.06442863f, 0.00344302f, 0.01900142f, -0.00425800f, 0.01979251f, 
    0.00288294f, 0.05629572f, 0.00548283f, 0.02191443f, -0.04627156f, 0.05821175f, 0.11852145f, -0.01263389f, 
    -0.04280791f, -0.04383957f, 0.04031239f, -0.07649004f, 0.02540062f, -0.01033241f, -0.02686065f, -0.05369415f, 
    -0.11064825f, 0.01914784f, -0.12309238f, -0.08454273f, -0.08221717f, -0.03905095f, -0.04175847f, -0.02479887f, 
    0.08499531f, 0.05469116f, -0.00935683f, -0.01807566f, 0.06765781f, -0.08421499f, -0.00854856f, 0.04101102f, 
    -0.03565376f, -0.06544833f, -0.03337517f, 0.00148857f, -0.08215412f, -0.01603443f, 0.01927743f, -0.05904983f, 
    0.03232662f, -0.01989087f, 0.01298227f, 0.02724760f, -0.07083137f, 0.08115222f, -0.08072287f, -0.03475990f, 
    -0.02851898f, -0.08488171f, 0.06435499f, 0.01226358f, -0.05914386f, 0.05071188f, -0.11073448f, -0.03492527f, 
    0.04222855f, -0.13902833f, 0.02835736f, 0.07813685f, 0.05098286f, 0.02874722f, 0.00410808f, -0.10565913f, 
    0.16327268f, -0.04810684f, -0.03643990f, -0.02100477f, -0.02376286f, 0.16978304f, -0.03308804f, -0.12141673f, 
    -0.24142733f, 0.01303433f, -0.10963187f, -0.05546151f, 0.00175728f, -0.03293405f, 0.11172279f, 0.16481034f, 
    0.05009880f, 0.18339710f, 0.00179794f, 0.07740075f, 0.09791816f, 0.01610482f, 0.02154980f, -0.02228822f, 
    -0.03249085f, 0.02330316f, 0.06591485f, -0.02334726f, 0.11931071f, 0.06810977f, 0.07530989f, -0.02395717f, 
    0.00984053f, 0.02274983f, 0.11427726f, 0.08592284f, 0.10695992f, -0.17344907f, -0.05650667f, -0.04892019f, 
    0.21379344f, -0.09102032f, -0.23359889f, 0.08689620f, 0.15031755f, 0.09259926f, -0.14515494f, -0.15718168f, 
    -0.03131627f, -0.34585944f, 0.20375484f, -0.15814503f, -0.01871089f, -0.08135960f, 0.02118210f, -0.23359340f, 
    -0.02000795f, 0.12231981f, 0.04986473f, 0.00335817f, -0.04473143f, 0.09180868f, 0.02216923f, -0.01811124f, 
    0.07376671f, -0.19778720f, 0.01805743f, 0.06483220f, -0.15257512f, -0.03193204f, -0.20751750f, -0.07122989f, 
    -0.04121269f, -0.05193507f, 0.10293480f, 0.09385022f, 0.02625656f, -0.07824461f, 0.13399740f, -0.00357289f, 
    0.07572609f, 0.06746894f, 0.01256203f, -0.00655423f, -0.02249005f, -0.00036934f, 0.01736858f, 0.05738237f, 
    -0.40321401f, -0.17956962f, 0.05743631f, 0.15329303f, -0.05836032f, 0.00829340f, 0.09113549f, 0.15323229f, 
    -0.02191434f, -0.37927482f, 0.04939684f, -0.07661854f, 0.00659337f, 0.03066459f, -0.02736372f, 0.01589764f, 
    0.05741281f, -0.06201315f, 0.01652501f, -0.00134744f, -0.06278373f, 0.06905036f, -0.17752387f, -0.18818811f, 
    -0.22421613f, 0.09244052f, -0.09872507f, -0.09902766f, -0.02783333f, 0.17475899f, -0.00949435f, -0.00106695f, 
    0.05395873f, 0.03570927f, 0.00881722f, -0.09159185f, -0.09482916f, -0.17443579f, -0.30657369f, -0.17458183f, 
    0.77306473f, -0.04024707f, 0.09955177f, 0.03782350f, -0.15350154f, -0.01832407f, 0.01986741f, 0.06399350f, 
    0.08291899f, -0.04078620f, 0.10132695f, -0.14508630f, 0.04794316f, -0.12309596f, -0.10540023f, 0.01773974f, 
    0.02972855f, -0.06500208f, -0.02093847f, -0.00197228f, 0.27146015f, 0.15345027f, 0.02074209f, -0.11869200f, 
    0.12442403f, -0.10765184f, -0.06324252f, -0.00346196f, -0.06210266f, 0.03735773f, -0.03027088f, 0.01941423f, 
    0.04344217f, -0.04222288f, 0.02594262f, 0.14299588f, -0.02188357f, 0.11994458f, 0.08281499f, -0.10330096f, 
    1.04501140f, 0.30345085f, -0.22230802f, -0.00164732f, -0.25548983f, -0.07915243f, 0.07140134f, -0.02575750f, 
    -0.05225398f, 0.01370062f, 0.10332698f, 0.00440673f, -0.17570803f, -0.08496440f, -0.05834195f, -0.05659970f, 
    -0.05158394f, -0.09375028f, -0.09898024f, 0.02342686f, -0.56437045f, -0.67478639f, -0.02833517f, -0.04615344f, 
    -0.00549527f, 0.03946616f, -0.04396553f, 0.05323237f, 0.06143937f, -0.10558054f, -0.10414544f, 0.04805967f, 
    -0.04797506f, -0.00366053f, -0.15930440f, 0.00531233f, -0.03081466f, 0.01918506f, 0.06444521f, 0.08388580f, 
    -0.66248411f, -0.15114681f, -0.12546781f, 0.08791854f, 0.04557374f, -0.11314505f, -0.02678991f, -0.00584226f, 
    -0.09670395f, -0.00609382f, -0.00585858f, 0.09442969f, -0.03971478f, -0.02062940f, -0.15065899f, -0.01710022f, 
    0.00848169f, -0.00422101f, 0.01900003f, 0.01291428f, -0.15810320f, -0.10256946f, -0.10203138f, -0.01754363f, 
    -0.06327567f, 0.03026653f, -0.01843937f, 0.02536258f, 0.06371521f, -0.08653111f, -0.09744768f, 0.13803953f, 
    0.01009584f, 0.03967012f, -0.05512068f, 0.01130007f, 0.02371262f, -0.04737688f, 0.02575566f, 0.01706993f, 
    0.28683394f, 0.10165337f, 0.07161695f, 0.03635480f, 0.15423770f, -0.04384755f, 0.01080409f, 0.00405569f, 
    -0.02400387f, -0.04312991f, -0.03376302f, 0.02864261f, -0.00635069f, 0.02234886f, -0.04319153f, 0.17288482f, 
    0.09179320f, -0.04276879f, 0.01229507f, 0.03189178f, -0.31543931f, 0.13409720f, -0.25710565f, 0.04100563f, 
    0.11836670f, -0.15492302f, 0.03959654f, -0.20195790f, -0.01214649f, 0.01774106f, -0.02731011f, 0.00509715f, 
    0.01540346f, 0.03379543f, 0.05392400f, -0.01087187f, 0.02996531f, -0.01676704f, -0.20196533f, 0.10534719f, 
    0.26874694f, -0.56802911f, -0.01901166f, 0.15708560f, 0.17798854f, -0.03489901f, -0.01827997f, -0.02110261f, 
    0.00492812f, -0.01538741f, -0.00098417f, 0.05418965f, 0.00180984f, -0.02101426f, -0.02297615f, 0.05239826f, 
    -0.11103976f, -0.10806111f, -0.05188455f, -0.34454373f, 0.32980075f, 0.23478515f, 0.15057437f, 0.15237956f, 
    0.07587584f, -0.05337278f, -0.03630744f, 0.04607196f, -0.01828422f, 0.00390010f, -0.04985645f, 0.01885304f, 
    -0.00046069f, -0.00134255f, 0.04470652f, 0.06600704f, -0.16228284f, 0.07035441f, 0.04948812f, 0.04683314f, 
    0.28352261f, 0.12030130f, 0.12830022f, 0.02169653f, 0.04411586f, 0.02390246f, 0.00755399f, 0.01908022f, 
    -0.00578681f, -0.04113334f, -0.00357947f, 0.06046898f, -0.09553887f, -0.00987362f, 0.01556157f, -0.23096733f, 
    -0.09303666f, 0.01655413f, 0.05666958f, -0.02651104f, 0.09299239f, 0.04840150f, 0.03848169f, 0.08294450f, 
    0.05568930f, -0.01569461f, -0.01302943f, -0.00770781f, -0.01502698f, -0.04110658f, 0.09023636f, 0.11423647f, 
    0.03261196f, -0.02021147f, 0.06035559f, -0.09420054f, -0.06891888f, -0.04187717f, -0.01016410f, 0.00710308f, 
    -0.20722811f, -0.34089202f, 0.03685953f, 0.15904172f, 0.19491223f, 0.00238175f, -0.01255637f, -0.02856111f, 
    0.08014026f, -0.01721394f, 0.04865837f, -0.01485857f, 0.11963668f, 0.13369296f, 0.22377580f, -0.02778676f, 
    0.01201182f, -0.00734155f, 0.10536526f, -0.14240186f, -0.00809145f, -0.15313281f, -0.11668088f, -0.00908748f, 
    -0.11860155f, -0.01418910f, 0.00198542f, -0.00969078f, 0.00856715f, -0.04577706f, -0.09941570f, 0.00308190f, 
    0.06844810f, -0.00069801f, -0.01812998f, -0.03001184f, -0.01050279f, -0.02735742f, 0.00852811f, 0.01585137f, 
    0.22219451f, 0.21876815f, -0.04686413f, -0.00200941f, -0.02387027f, -0.05973372f, -0.10454082f, -0.07252723f, 
    0.01992866f, -0.10977925f, 0.01827794f, 0.00532949f, -0.00578566f, 0.00536781f, 0.02426054f, 0.18363532f, 
    0.00089221f, -0.02386284f, 0.10167869f, 0.00256916f, -0.06273422f, -0.08972269f, -0.00784064f, 0.00099529f, 
    0.02618809f, 0.07829955f, -0.03612024f, 0.07841839f, 0.03019148f, 0.00333453f, -0.07173145f, 0.00168650f, 
    0.02259114f, 0.06087413f, -0.11604226f, -0.08106685f, 0.09968620f, 0.01148982f, 0.05683607f, 0.03879451f, 
    0.15337914f, 0.07128695f, 0.10297161f, 0.09458490f, 0.10882983f, -0.04606680f, 0.01376499f, -0.05407089f, 
    0.00498884f, -0.01731565f, -0.03043880f, 0.02091366f, 0.03742272f, 0.02401305f, 0.00290402f, -0.07111223f, 
    -0.01322278f, 0.00374530f, 0.03279559f, -0.04255777f, 0.21834983f, -0.07612853f, -0.24137640f, -0.02657729f, 
    -0.07528470f, -0.03240051f, 0.02159198f, 0.02475037f, -0.16874453f, 0.05608037f, 0.12771426f, 0.10845454f, 
    -0.00234717f, 0.00314605f, -0.00626787f, -0.00794847f, -0.01539617f, -0.01450405f, -0.00671465f, 0.00769860f, 
    -0.27101865f, 0.24396656f, -0.00129314f, 0.16275537f, 0.07079434f, 0.08076620f, -0.05806011f, -0.02405158f, 
    -0.28768903f, -0.03236718f, -0.03609209f, 0.01802952f, -0.01050471f, -0.02306314f, 0.07128744f, 0.03119585f, 
    0.03132668f, 0.05897940f, -0.22498281f, 0.04161793f, 0.00110890f, -0.02651538f, 0.02235024f, -0.01735468f, 
    0.02360513f, 0.00345175f, -0.04808345f, 0.03522974f, -0.02118145f, 0.03299157f, 0.19734988f, 0.06085477f, 
    -0.03811638f, 0.00237034f, 0.05558097f, -0.14206375f, 0.13527690f, -0.08219889f, 0.05963276f, -0.00246263f, 
    0.15949218f, -0.00833737f, 0.04176551f, 0.04578651f, -0.03935343f, -0.00807958f, -0.01255375f, -0.03111514f, 
    0.01131146f, 0.00583198f, 0.14273793f, -0.06118533f, 0.04142330f, -0.09650006f, -0.05037463f, 0.01317578f, 
    -0.05512734f, -0.07227646f, 0.03977321f, 0.02854655f, -0.04765020f, -0.22204246f, 0.07017729f, -0.02649771f, 
    0.05867206f, 0.03857282f, -0.03432963f, -0.04317825f, 0.03230041f, 0.01034361f, 0.08528177f, -0.01745273f, 
    0.05749709f, 0.01148541f, -0.06718044f, -0.02397639f, 0.03765864f, 0.02249215f, 0.13511610f, 0.03690985f, 
    -0.20617878f, -0.03088484f, -0.13388045f, 0.05344225f, 0.00344193f, -0.00877484f, 0.11777294f, 0.13410489f, 
    -0.28185779f, -0.07786446f, -0.06689872f, -0.01769957f, -0.04032161f, -0.02880415f, -0.02409240f, -0.00129846f, 
    0.00335682f, -0.02017894f, -0.03005726f, 0.03234815f, -0.33062971f, 0.06111826f, -0.16929998f, -0.06560967f, 
    -0.06170129f, -0.05619526f, 0.00841534f, 0.07756946f, -0.02359344f, -0.13653629f, 0.03569131f, -0.03949566f, 
    -0.01558653f, -0.08677834f, -0.01533917f, 0.00128051f, 0.03207323f, -0.03677689f, -0.03452497f, 0.00938499f, 
    0.31582206f, 0.18060166f, -0.21087132f, -0.04609294f, -0.28929484f, -0.00611635f, -0.01242983f, -0.04806733f, 
    -0.03397689f, -0.02006491f, 0.01972765f, 0.01792538f, -0.05351872f, -0.01284915f, 0.04388331f, -0.15704706f, 
    -0.26720619f, -0.19071579f, -0.17452422f, -0.17941505f, -0.12667646f, 0.14014757f, -0.01166581f, -0.10531186f, 
    0.06289876f, -0.06688469f, 0.09511562f, -0.12299999f, 0.05025133f, 0.03811903f, -0.04080662f, -0.02178830f, 
    -0.01328135f, 0.05542840f, -0.00656633f, 0.02895531f, 0.05488765f, 0.01283068f, -0.00034361f, -0.04171890f, 
    0.13844894f, 0.05216715f, 0.08012587f, 0.04924520f, 0.03167313f, -0.01163347f, 0.00753815f, 0.03438497f, 
    -0.01562594f, 0.01314678f, 0.01926958f, -0.04230324f, 0.03020800f, 0.07225741f, -0.06896460f, -0.16637506f, 
    -0.00325043f, 0.01869298f, 0.02783547f, -0.02439308f, 0.04518588f, 0.01455538f, 0.06652793f, -0.03018707f, 
    0.03435455f, 0.02797472f, 0.02841793f, -0.05867475f, -0.01361104f, 0.01680711f, 0.04937554f, -0.06991901f, 
    0.02387482f, 0.08397362f, -0.01189155f, 0.00481417f, -0.08855917f, -0.10934434f, 0.05133999f, 0.01734936f, 
    -0.01137007f, -0.19063273f, 0.10061750f, -0.09659594f, 0.00770381f, 0.12182199f, -0.06029631f, -0.17960164f, 
    0.00162453f, 0.13069622f, 0.03878529f, -0.06830645f, 0.06030042f, 0.05346140f, -0.00753399f, -0.05607694f, 
    0.10184113f, -0.08406188f, 0.06115779f, 0.07054216f, 0.23036303f, -0.07189683f, -0.04509306f, -0.02643273f, 
    -0.08801679f, -0.02385430f, -0.01480217f, -0.02506305f, 0.07156768f, -0.08843147f, 0.10130613f, -0.11893319f, 
    0.01215088f, -0.10472156f, -0.05410217f, -0.00638246f, -0.01665036f, -0.06080373f, 0.00730477f, 0.00902680f, 
    0.13261095f, 0.04130790f, 0.02318692f, -0.00158528f, 0.03239098f, -0.04756980f, -0.00454913f, -0.04911206f, 
    0.01215123f, -0.01240075f, -0.00933439f, -0.02017334f, 0.06432892f, -0.03702005f, -0.00147626f, -0.02566911f, 
    -0.00040128f, 0.02030709f, 0.03739948f, -0.04029544f, -0.07510318f, 0.28651395f, 0.07127832f, 0.13388017f, 
    0.08507192f, 0.05089768f, -0.11673724f, 0.08623137f, -0.14905699f, 0.05465159f, -0.04118418f, -0.03596270f, 
    0.00981074f, 0.02829736f, 0.04267421f, 0.05564150f, -0.00080007f, 0.03074381f, -0.13012721f, 0.03576900f, 
    -0.00615278f, 0.03283371f, -0.01277300f, -0.03970292f, 0.02115700f, 0.19663240f, -0.06379636f, -0.01969964f, 
    -0.00149299f, -0.04595448f, -0.02386053f, -0.02368332f, 0.07386753f, 0.07379887f, 0.01639665f, -0.07504694f, 
    0.00059854f, 0.01320012f, 0.01215240f, 0.01368654f, -0.01838460f, -0.01927516f, 0.12312456f, -0.00442295f, 
    -0.08823088f, 0.03932541f, -0.10868658f, -0.04624478f, -0.04081392f, 0.00325621f, -0.04235591f, -0.02963571f, 
    -0.00394924f, 0.05464186f, -0.06105721f, 0.05338068f, 0.08510888f, 0.02707176f, 0.05407489f, 0.07821020f, 
    -0.20713675f, -0.00845375f, 0.01135665f, 0.14595802f, 0.09811991f, -0.01580372f, 0.04460890f, 0.03096486f, 
    0.02523594f, -0.03967005f, -0.02496707f, 0.02622181f, 0.04740331f, -0.06833380f, -0.14706074f, 0.18079697f, 
    0.10665863f, 0.00446894f, -0.17666911f, 0.15418632f, 0.10195107f, 0.08499114f, 0.16101907f, 0.08487151f, 
    0.04263432f, -0.00668950f, -0.03456851f, 0.02377225f, -0.01032093f, -0.00422951f, -0.01982533f, 0.01095545f, 
    0.02978811f, 0.01097623f, 0.01928657f, 0.05215980f, -0.07976051f, -0.02267535f, 0.07503854f, 0.00257553f, 
    0.05792408f, 0.06448338f, 0.05030007f, 0.02821432f, 0.07271984f, 0.00379650f, -0.04592260f, -0.03316349f, 
    0.02765152f, -0.03726156f, -0.01344496f, 0.07213946f, 0.00086329f, 0.04384995f, 0.03201760f, -0.00993225f, 
    -0.04079049f, 0.02558921f, 0.06166239f, -0.01689444f, -0.03732132f, -0.11336948f, 0.11594171f, 0.21676293f, 
    0.20152220f, -0.00912868f, -0.03830004f, 0.01332695f, -0.00642946f, -0.03220052f, 0.08768202f, 0.07641088f, 
    0.12522547f, -0.08584193f, 0.05608612f, 0.04310228f, -0.09079167f, -0.02070060f, -0.05733673f, -0.10677844f, 
    -0.46243882f, -0.21157058f, 0.17805028f, 0.08087195f, 0.07585488f, 0.00624476f, -0.08016491f, 0.07593381f, 
    -0.07347995f, -0.04658704f, 0.04992800f, -0.01863918f, 0.00373278f, -0.07693516f, 0.07468829f, 0.19737110f, 
    0.02697630f, 0.04872122f, 0.12812832f, -0.05835665f, 0.37228948f, 0.06639336f, 0.21938270f, -0.03909918f, 
    -0.13333315f, 0.13201153f, -0.02147474f, -0.02734475f, 0.04328574f, -0.00343616f, 0.07672672f, -0.04977252f, 
    -0.03048769f, -0.08651201f, -0.06787986f, 0.14333484f, -0.00959420f, -0.22153823f, -0.00912441f, 0.07474550f, 
    -0.51258510f, 0.06020978f, -0.20276842f, 0.09127903f, 0.19974244f, -0.07978803f, 0.05036637f, -0.05326629f, 
    0.15982707f, -0.07311486f, -0.06155248f, 0.02935039f, 0.03827918f, 0.02082329f, 0.00143837f, 0.01285714f, 
    -0.00225602f, -0.01812866f, -0.01738343f, 0.11438400f, 0.23012915f, 0.06526493f, -0.42102543f, -0.17188179f, 
    -0.02231238f, -0.04412467f, -0.00295148f, 0.03317212f, 0.06391180f, -0.11786657f, 0.01528359f, 0.04909789f, 
    0.04554705f, -0.05366549f, 0.00394800f, -0.01911815f, -0.02288775f, -0.02997183f, -0.06724065f, 0.05996333f, 
    0.36581373f, 0.04251729f, 0.26728997f, 0.08565612f, -0.03939947f, -0.00780183f, -0.00735761f, 0.00484005f, 
    -0.00193013f, 0.02111402f, -0.11032362f, 0.05706571f, -0.01883211f, 0.01814711f, -0.03966273f, 0.09663336f, 
    -0.05355724f, 0.00944582f, 0.13219739f, 0.01471017f, 0.62342238f, 0.08849540f, -0.10481907f, 0.06077024f, 
    -0.28999576f, -0.08340172f, 0.08701278f, -0.01674720f, 0.00409515f, 0.15502782f, 0.12616310f, -0.07870771f, 
    -0.01336495f, -0.12851253f, 0.03377032f, -0.00058763f, -0.00145975f, -0.03858765f, 0.00466073f, 0.05994945f, 
    0.27256331f, 0.14611633f, -0.12720849f, 0.15186597f, -0.40186790f, 0.01647816f, -0.09272879f, -0.13615942f, 
    -0.18318750f, 0.01492964f, 0.06123090f, -0.02746236f, 0.05060175f, 0.09080722f, 0.02432307f, -0.13345669f, 
    0.04884297f, -0.05907015f, -0.18591833f, 0.04923921f, 0.17823814f, 0.17417860f, 0.12802546f, 0.00264030f, 
    0.04991834f, 0.02718582f, -0.06191288f, -0.02706528f, 0.04175965f, -0.05082018f, 0.02782522f, -0.01975011f, 
    0.01425377f, -0.06267667f, 0.00547703f, 0.07706671f, 0.04329454f, -0.00866764f, -0.06488332f, 0.00587813f, 
    -0.51940763f, -0.37063953f, -0.24000034f, -0.29014373f, 0.07460321f, 0.04095780f, -0.08723690f, 0.02380533f, 
    -0.10075512f, 0.01250819f, 0.11103521f, 0.03663446f, 0.06055872f, -0.06436791f, 0.07672149f, -0.04351796f, 
    -0.19238736f, -0.04947732f, -0.04098182f, -0.36956617f, -0.33579630f, 0.18745692f, -0.09716011f, 0.27279434f, 
    0.09460903f, -0.14411508f, -0.10523178f, -0.06098456f, 0.03278802f, -0.12743099f, -0.01725955f, 0.02023896f, 
    0.02888521f, 0.00924510f, 0.03795160f, -0.01100392f, 0.01353464f, 0.06595132f, -0.23175284f, 0.01863950f, 
    0.46340811f, 0.05930576f, 0.04640252f, 0.03474244f, 0.06785900f, -0.00167921f, 0.01209248f, -0.00330704f, 
    0.04915028f, 0.00970594f, -0.06827032f, -0.01230003f, 0.01883554f, 0.00854704f, -0.03669326f, -0.11624009f, 
    0.25287688f, 0.05392522f, -0.02495137f, 0.01464117f, 0.11977187f, 0.04578785f, 0.05181894f, -0.00140784f, 
    0.06127230f, 0.00943737f, 0.04592545f, 0.00613522f, -0.01595767f, -0.01314000f, -0.00488772f, -0.03408311f, 
    0.00624903f, -0.03701346f, 0.03753047f, 0.04164734f, -0.00047793f, -0.03641813f, -0.00566632f, -0.00739312f, 
    -0.05245330f, -0.03681883f, -0.04471836f, 0.00917373f, -0.17804241f, 0.06871983f, -0.07024663f, -0.03049401f, 
    0.06728235f, -0.07179143f, 0.06892107f, 0.00821131f, 0.01075301f, 0.06952418f, 0.05879191f, 0.02039701f, 
    -0.03234970f, 0.04173370f, 0.12188502f, 0.03618343f, 0.15597883f, 0.04894414f, 0.10277135f, 0.02726593f, 
    0.00934665f, -0.02116337f, 0.00549011f, 0.05704115f, 0.06073457f, -0.02381022f, -0.12649472f, 0.08731905f, 
    0.12672646f, 0.02930576f, -0.09518503f, 0.06042566f, 0.09302875f, -0.03053989f, -0.02311568f, -0.00342579f, 
    -0.98506391f, -0.52603883f, 0.32770807f, -0.04808162f, -0.17393002f, 0.07313544f, -0.01977087f, 0.00724263f, 
    -0.17161702f, -0.00353130f, -0.01639031f, 0.00458682f, -0.13614753f, 0.03887103f, 0.07753523f, 0.07721025f, 
    -0.02175589f, -0.10812303f, 0.06455575f, 0.00853607f, 0.07375385f, -0.03107545f, -0.02889088f, -0.03290427f, 
    0.05105423f, -0.07121100f, 0.01663099f, 0.01460972f, 0.00196449f, 0.03147686f, 0.04443805f, -0.03696125f, 
    0.10826612f, -0.07856299f, -0.07485991f, -0.09762944f, -0.01903195f, 0.09326778f, -0.00144721f, -0.02285098f, 
    0.21136194f, -0.06402313f, -0.02842775f, 0.05662927f, 0.17325591f, 0.00012375f, -0.02623521f, 0.01945977f, 
    0.03301064f, -0.05675225f, -0.09497815f, 0.01508292f, -0.03985211f, 0.05570670f, 0.01010542f, 0.00646799f, 
    0.00741635f, 0.07375494f, -0.02748815f, 0.01090910f, -0.29967034f, -0.12510234f, 0.26993006f, -0.16010846f, 
    0.00471075f, -0.11807732f, 0.04367438f, -0.26109642f, -0.06328270f, 0.09143563f, 0.00874898f, 0.02077018f, 
    0.03964199f, -0.00656610f, -0.00389637f, 0.07418476f, -0.08088765f, -0.11426894f, -0.11202817f, -0.04411620f, 
    0.22055477f, -0.11032975f, 0.06629058f, -0.03480099f, 0.05429923f, 0.04071847f, -0.04858949f, -0.02433933f, 
    0.01594494f, -0.00585326f, -0.11092667f, -0.14761543f, -0.03773148f, 0.04966779f, -0.01560534f, 0.05706017f, 
    -0.03436431f, -0.13141885f, 0.06758846f, -0.01251202f, 0.02029162f, -0.01270380f, -0.02471479f, 0.00276409f, 
    0.05838173f, -0.02806983f, -0.01703119f, -0.02539580f, -0.03617372f, 0.04118126f, 0.01582276f, -0.05684449f, 
    0.12179145f, 0.01314318f, -0.00093004f, 0.00047908f, 0.06473532f, -0.06138871f, 0.04092955f, 0.05594263f, 
    0.03465650f, -0.04653621f, -0.09230385f, 0.09342142f, 0.00778641f, -0.10780074f, -0.05672203f, -0.24403746f, 
    -0.24800955f, 0.01713140f, -0.08722521f, -0.07462993f, 0.07268001f, 0.02198145f, -0.01373731f, 0.01183001f, 
    -0.02421672f, 0.03447391f, -0.11426118f, -0.10255317f, -0.01555324f, 0.04464343f, -0.03616405f, -0.11906433f, 
    -0.10618580f, 0.14218676f, -0.08785565f, -0.00761615f, -0.00884028f, 0.05830977f, -0.04445247f, 0.04929536f, 
    0.06702076f, -0.14483634f, 0.10852239f, 0.04906996f, -0.06622165f, -0.08046202f, 0.21830684f, 0.03216649f, 
    0.27336904f, -0.27050057f, 0.27811921f, -0.36443469f, 0.14406173f, 0.15834276f, -0.01020482f, -0.09375936f, 
    -0.10957268f, 0.06749110f, -0.04149612f, -0.03840373f, 0.03185546f, 0.04420916f, -0.06012989f, 0.15021580f, 
    -0.06432881f, -0.29723412f, 0.13481085f, -0.02244204f, -0.05356679f, -0.10776421f, -0.14174351f, -0.00463984f, 
    0.00879583f, -0.07772639f, -0.10837717f, -0.24959725f, 0.05189142f, -0.26444808f, -0.03122906f, -0.08837233f, 
    0.05871203f, 0.02729316f, 0.02790186f, 0.06912592f, 0.00360276f, -0.07459392f, 0.09345287f, -0.07776608f, 
    0.03837542f, -0.10222293f, 0.12492552f, 0.31835511f, 0.02496883f, -0.07980603f, -0.14924188f, 0.10580672f, 
    0.01263710f, -0.16710828f, 0.04132472f, 0.04692347f, 0.04984953f, 0.04042960f, 0.06412008f, -0.00501857f, 
    -0.00109695f, 0.01976195f, 0.06325269f, -0.04986036f, -0.42010671f, -0.70472467f, 0.01258508f, -0.00295171f, 
    -0.30123249f, 0.01197735f, -0.00525973f, -0.04225596f, 0.00705742f, -0.09352890f, -0.02138293f, -0.03375583f, 
    -0.03796253f, -0.04917556f, -0.02237311f, -0.04839531f, -0.00062043f, 0.04941221f, 0.11897593f, 0.16846038f, 
    -0.12271766f, 0.18293786f, 0.21763374f, 0.13675584f, 0.00689917f, -0.06883071f, -0.01966820f, 0.11651544f, 
    -0.06838756f, 0.06114466f, 0.10477046f, 0.02320280f, 0.06124322f, 0.05847673f, 0.00196780f, -0.02319026f, 
    0.04030604f, 0.11571658f, 0.05306870f, -0.09926271f, -0.11544318f, -0.02740205f, 0.02570144f, -0.09194468f, 
    -0.06811240f, 0.10417821f, 0.00880309f, 0.01757643f, 0.01031418f, 0.04487142f, 0.02405719f, 0.01141475f, 
    0.00602406f, 0.05658305f, -0.03337635f, 0.10739221f, -0.06466676f, -0.15263624f, 0.04900225f, -0.03359276f, 
    -0.39018261f, 0.50965798f, 0.12318321f, 0.00822925f, 0.00590204f, -0.06630930f, -0.00162006f, -0.05371978f, 
    -0.07097501f, 0.12200586f, -0.01358379f, 0.05246239f, -0.03407728f, 0.06138735f, 0.02095416f, 0.03296655f, 
    -0.02518705f, 0.02723496f, -0.03569276f, -0.09426756f, 0.20217799f, 0.26663849f, -0.18113691f, 0.01095391f, 
    0.15774174f, -0.06210822f, 0.11969845f, -0.05107968f, -0.13166089f, 0.09030330f, -0.06385089f, -0.02527105f, 
    -0.13258550f, 0.07070217f, -0.11378201f, 0.00580727f, 0.02566274f, 0.05372193f, -0.07175612f, 0.09071893f, 
    0.46233672f, 0.07988481f, -0.08249753f, 0.05491756f, 0.23692617f, -0.23361911f, 0.04616358f, 0.03363179f, 
    -0.07381229f, 0.12755588f, -0.09438539f, -0.02417339f, -0.07609820f, 0.00423145f, -0.00267061f, 0.04013691f, 
    0.00026515f, 0.01414617f, -0.04243914f, 0.07966635f, 0.10690214f, -0.00430677f, 0.11440291f, 0.12719035f, 
    0.00950478f, 0.02938548f, -0.07446953f, -0.01225380f, 0.01942712f, -0.23142524f, -0.01917202f, -0.01500651f, 
    0.03831895f, 0.05600530f, 0.06199160f, 0.01207258f, -0.04827300f, -0.07058519f, 0.04746719f, -0.06039653f, 
    -0.11924228f, -0.03541780f, -0.14873798f, -0.07638463f, -0.07191908f, -0.02565126f, -0.01527932f, 0.02885465f, 
    -0.00156994f, 0.05944087f, -0.04488731f, 0.00502856f, -0.00804922f, -0.03656351f, -0.03195931f, -0.04073397f, 
    -0.03179307f, 0.07394721f, 0.00270007f, 0.00657825f, -0.04200782f, -0.28312242f, -0.42789131f, 0.12107275f, 
    -0.28140825f, -0.06473623f, 0.16319914f, 0.03189468f, -0.06813553f, 0.01752326f, -0.02026486f, 0.06717245f, 
    -0.01071751f, -0.00411329f, -0.02631328f, -0.01141733f, -0.01808470f, -0.00887026f, -0.09480039f, -0.05667039f, 
    -0.27290305f, 0.05014726f, -0.11184350f, -0.07217081f, -0.20102800f, 0.05341147f, -0.03376646f, -0.08252279f, 
    0.02479438f, 0.01114912f, -0.02493410f, -0.05465272f, 0.04406804f, -0.06589337f, 0.04346554f, 0.16062599f, 
    0.12961391f, 0.00702117f, 0.15417983f, 0.02648902f, -0.16441324f, -0.27451962f, -0.28950554f, 0.08627910f, 
    -0.25596952f, 0.02689366f, 0.04595717f, 0.03146167f, -0.02183643f, 0.06185138f, 0.01040180f, 0.01157349f, 
    -0.04540941f, 0.03224564f, -0.03319499f, -0.03437584f, -0.00188558f, 0.11457811f, 0.05715011f, -0.16004883f, 
    -0.23911923f, -0.20653002f, -0.03923720f, -0.11946870f, -0.03395339f, -0.01672166f, -0.05622584f, -0.00615070f, 
    0.01482418f, 0.06300932f, -0.05348396f, -0.06804551f, -0.20108519f, 0.14432876f, 0.05539830f, 0.16027986f, 
    -0.12735891f, 0.04221660f, 0.07787121f, -0.04570335f, -0.12297903f, -0.09453805f, -0.02179337f, -0.01680316f, 
    0.04711782f, -0.02673577f, 0.00833652f, 0.00197631f, 0.03659609f, 0.05880579f, -0.00888705f, -0.07775733f, 
    -0.00049848f, 0.02626844f, 0.00259679f, 0.02041012f, -0.02748186f, -0.00696469f, 0.01225753f, 0.01410128f, 
    0.46468359f, 0.01368643f, -0.19516917f, 0.09759524f, 0.21691488f, 0.07360664f, 0.07065597f, -0.11355741f, 
    -0.00845560f, -0.02009354f, -0.11157479f, 0.04649647f, 0.00581301f, 0.08057640f, -0.11716189f, -0.05253454f, 
    0.04418644f, -0.02571975f, 0.09424855f, 0.02474965f, -0.10966077f, 0.06220201f, 0.15160516f, 0.01707063f, 
    0.14824922f, -0.00384306f, -0.02365245f, 0.02606964f, 0.07362757f, -0.17575687f, 0.05348368f, -0.01550479f, 
    -0.04535562f, 0.05576605f, 0.06647377f, 0.02897086f, -0.01103902f, 0.03507189f, 0.02102456f, -0.03111442f, 
    -0.62260407f, 0.24909800f, 0.11052889f, -0.43036282f, -0.25433692f, 0.02093579f, 0.03538048f, -0.01599973f, 
    0.02427919f, 0.03582422f, 0.00799097f, 0.00023413f, 0.00858362f, 0.00390291f, -0.02748194f, -0.02526111f, 
    -0.05684821f, 0.03265224f, -0.00212387f, 0.03494108f, 0.08185937f, -0.06802353f, 0.00313260f, 0.02308040f, 
    0.09406653f, 0.07274859f, -0.17861846f, -0.00473108f, 0.01910063f, 0.03786211f, -0.13542806f, 0.00963889f, 
    0.03753175f, -0.00694101f, 0.02247142f, 0.06058585f, -0.02698406f, -0.05829295f, 0.16336717f, -0.17854582f, 
    -0.19207330f, -0.04989019f, -0.05983298f, -0.08198901f, -0.01701968f, -0.03995893f, -0.06916209f, -0.03983163f, 
    0.01817439f, 0.07836221f, 0.01833834f, -0.02734910f, 0.01058827f, 0.02423302f, -0.02359644f, -0.02621115f, 
    0.00515752f, 0.08987167f, 0.04213700f, -0.01066955f, 0.02392199f, 0.09190436f, 0.27444309f, -0.00909373f, 
    0.11935298f, -0.05272763f, -0.09729604f, 0.03091882f, 0.12220228f, -0.27796841f, 0.05206392f, -0.04848366f, 
    0.04349564f, -0.01235227f, 0.04901349f, -0.00560471f, -0.05559529f, -0.01498223f, 0.04499745f, -0.03549936f, 
    -0.50893897f, -0.13961843f, -0.67982846f, 0.14012125f, -0.28051120f, 0.00812733f, -0.05484380f, 0.04457058f, 
    -0.05825518f, 0.09634233f, -0.02257823f, -0.04154284f, 0.01605595f, 0.00812975f, 0.02896054f, -0.01616252f, 
    -0.00725919f, -0.04074500f, 0.01840989f, 0.17285946f, 0.02193669f, -0.05433645f, -0.00612002f, -0.00710199f, 
    0.06592824f, -0.01039139f, -0.02303671f, 0.05596868f, 0.00929833f, -0.02291053f, 0.03205803f, -0.06048412f, 
    -0.07071459f, 0.08583537f, -0.00363459f, 0.10651347f, -0.19170573f, -0.04296034f, 0.01756494f, -0.07383177f, 
    -0.00565505f, -0.02953857f, 0.16356143f, -0.05330746f, 0.09556454f, -0.00747897f, 0.01489114f, 0.04912090f, 
    0.02126209f, -0.02616558f, -0.04618179f, -0.03361235f, 0.00968895f, -0.00497821f, 0.07597256f, 0.04847934f, 
    -0.00223431f, 0.01789865f, 0.01767495f, -0.05310526f, 0.18658949f, 0.01061932f, -0.11230264f, -0.02945520f, 
    0.08660910f, 0.05606085f, 0.09123655f, -0.09215289f, -0.02410272f, -0.00581787f, -0.02155416f, 0.04283569f, 
    0.05051396f, 0.06548474f, -0.08000126f, 0.06865022f, -0.07848618f, -0.00935646f, 0.00160794f, 0.05556642f, 
    -0.01512951f, 0.24867451f, 0.27231789f, 0.08756106f, 0.23127575f, -0.13681453f, -0.04788187f, 0.05131650f, 
    0.13844347f, -0.05634275f, 0.02619636f, 0.11856510f, -0.02707637f, 0.01663310f, 0.06668878f, 0.00077517f, 
    0.01089994f, -0.01863559f, 0.01564652f, -0.03209513f, -0.21975546f, -0.09342231f, 0.14196640f, 0.35590690f, 
    0.16444695f, -0.03508072f, -0.08441979f, 0.09157424f, 0.03177477f, -0.08234079f, 0.06118554f, 0.05978645f, 
    0.04672633f, 0.01652950f, -0.02574267f, -0.03724173f, 0.00666557f, 0.06411673f, -0.06217061f, 0.01260857f, 
    -0.12916321f, -0.00869305f, 0.13965589f, 0.15301123f, -0.26296750f, 0.05313849f, -0.02250364f, -0.00907036f, 
    -0.04613623f, 0.09347865f, 0.01736246f, 0.02939874f, 0.00900322f, -0.04401491f, -0.02276493f, 0.17694938f, 
    0.11394748f, 0.13703430f, 0.14199215f, 0.11506934f, -0.24055682f, 0.18290929f, -0.06013111f, 0.15054102f, 
    -0.07006028f, -0.13280223f, 0.00517295f, 0.01058125f, -0.03975413f, -0.00006213f, 0.05542998f, 0.01923675f, 
    -0.02793051f, 0.02749251f, -0.03535656f, -0.04342484f, 0.00516309f, 0.07058866f, -0.08115234f, -0.06994770f, 
    -0.10466871f, -0.11667813f, -0.05132514f, -0.00044654f, 0.06534740f, -0.02156587f, -0.03249774f, -0.00220825f, 
    -0.02290897f, 0.03802786f, 0.14209603f, 0.07342450f, -0.06162688f, 0.05497557f, -0.07379142f, 0.10638450f, 
    0.08265108f, 0.08739657f, 0.02405570f, -0.01054890f, -0.25151095f, -0.08111595f, 0.07133567f, -0.04392631f, 
    0.00861869f, -0.07210747f, -0.10425897f, -0.24696331f, -0.05007005f, 0.06237954f, 0.04363458f, -0.03181519f, 
    -0.00139833f, 0.04177544f, -0.06119199f, 0.03819950f, -0.07199211f, -0.06484471f, -0.07825435f, -0.03852978f, 
    -0.03510483f, -0.00399806f, -0.03599698f, -0.04879897f, 0.10968646f, -0.09338305f, 0.06434257f, -0.11910787f, 
    -0.10388613f, 0.03836540f, 0.03131168f, -0.04032490f, -0.01786821f, -0.01547953f, -0.02356675f, 0.01991810f, 
    -0.06601534f, 0.00881208f, -0.00435010f, -0.04793840f, -0.11105449f, -0.09772624f, 0.37045929f, 0.08344564f, 
    0.13696350f, -0.02558052f, -0.01234708f, 0.07130367f, 0.12169749f, -0.15234029f, 0.07947039f, 0.03290467f, 
    0.03863569f, -0.03519691f, 0.02007869f, 0.01607211f, -0.02039217f, 0.04206568f, 0.03469995f, -0.03520630f, 
    -0.11856334f, -0.03654890f, 0.09029568f, -0.10502665f, 0.07344081f, 0.04154505f, -0.09146720f, -0.07810897f, 
    -0.01652617f, 0.08372661f, -0.04075895f, -0.06649539f, 0.05200353f, -0.04675090f, -0.00473749f, 0.04975923f, 
    -0.09510023f, -0.07385755f, 0.04052278f, 0.00480921f, -0.19618790f, 0.25087923f, 0.08157212f, 0.09990693f, 
    0.08116691f, 0.03587113f, -0.01842891f, 0.08572160f, -0.01856083f, 0.06198253f, -0.00009449f, 0.04518170f, 
    0.03114734f, 0.01056877f, -0.00010972f, -0.01821746f, -0.01562002f, -0.02970876f, -0.01756819f, 0.03298911f, 
    -0.07295255f, -0.05069748f, 0.03948424f, -0.03791245f, 0.05773782f, 0.06804387f, -0.21700852f, -0.17778924f, 
    -0.02527638f, 0.09023757f, 0.09251343f, -0.03986410f, 0.03880484f, -0.04193727f, -0.03842574f, 0.02093713f, 
    -0.03371629f, -0.01281456f, -0.04838061f, 0.02650443f, -0.29103535f, -0.10078090f, 0.22979169f, -0.14044444f, 
    0.01344901f, -0.03949838f, 0.00673342f, -0.03212293f, -0.03763530f, 0.08152378f, -0.01177894f, -0.01902312f, 
    -0.00296853f, 0.01524103f, 0.02936582f, 0.04713281f, -0.11127304f, -0.12062437f, 0.00017581f, -0.00735965f, 
    0.09761670f, 0.24526246f, -0.23596431f, 0.01182695f, 0.06232901f, 0.04855847f, 0.03984365f, -0.00290598f, 
    0.00203587f, -0.06425150f, 0.00123186f, 0.05284909f, 0.05980841f, -0.15277442f, 0.04224196f, -0.09702992f, 
    0.07406149f, 0.00421641f, -0.03164880f, -0.02221579f, -0.00069922f, -0.09014937f, -0.08338048f, -0.08845846f, 
    0.07683075f, 0.03351197f, -0.02921883f, 0.01215937f, -0.02032363f, 0.05590305f, -0.04733766f, 0.04242668f, 
    -0.06783587f, 0.06605471f, -0.06972332f, 0.11823699f, 0.07568225f, 0.03425650f, 0.11564872f, -0.05250530f, 
    -0.21828833f, -0.00839397f, -0.00742013f, -0.08192762f, -0.02159523f, -0.02598953f, -0.04896542f, -0.04684573f, 
    -0.00354015f, 0.05247056f, -0.01442243f, -0.05888151f, -0.02915128f, -0.01665924f, -0.09373202f, 0.00320409f, 
    -0.10639147f, -0.03530130f, 0.04125999f, -0.00686400f, -0.25583547f, 0.00293088f, -0.15321401f, 0.14546715f, 
    0.08665766f, 0.09038495f, 0.00857741f, -0.02629900f, 0.02801091f, -0.04806181f, -0.02626322f, -0.00800165f, 
    -0.01450352f, -0.08808152f, 0.07853652f, 0.04660282f, 0.21555775f, 0.06266759f, -0.07572141f, 0.03070142f, 
    0.08451032f, -0.05884193f, -0.41123328f, 0.01104186f, 0.06735849f, -0.03232446f, 0.00675371f, 0.03626266f, 
    -0.02520279f, -0.02797858f, -0.01245831f, -0.12460285f, 0.00931881f, -0.13280080f, -0.06335159f, -0.00455863f, 
    0.08503035f, 0.05696779f, 0.07985972f, -0.03744303f, -0.13385691f, -0.16766024f, 0.53659397f, 0.22002868f, 
    0.26679319f, 0.01700211f, -0.07790828f, -0.07286646f, 0.08490296f, -0.08406211f, 0.01965698f, 0.01396601f, 
    0.02707708f, -0.07234047f, 0.02819197f, 0.02967110f, 0.02317516f, -0.00152859f, -0.01772649f, 0.01316350f, 
    0.02434141f, 0.04944776f, -0.43434522f, 0.13497503f, -0.08581893f, 0.04492179f, 0.06876471f, 0.03469314f, 
    0.07009236f, -0.00741478f, -0.01696921f, 0.03540918f, -0.04848798f, 0.06350344f, -0.04773872f, 0.03189082f, 
    0.00762062f, 0.01323473f, -0.15585645f, 0.09023327f, -0.21520397f, 0.16483441f, 0.04740365f, 0.07905749f, 
    -0.11052740f, 0.06604742f, -0.13725929f, -0.02400397f, 0.06064048f, -0.36644050f, -0.05915090f, 0.09432436f, 
    -0.00748368f, 0.00022073f, -0.00455084f, 0.01522719f, -0.01278394f, 0.02533735f, 0.03251024f, -0.05131818f, 
    -0.01825055f, -0.02650876f, 0.02518900f, -0.08338141f, -0.06401886f, 0.00375733f, -0.03224706f, 0.01732291f, 
    0.01758769f, 0.09344079f, -0.03815579f, -0.02539130f, -0.06697433f, 0.03236566f, 0.03612614f, 0.04848605f, 
    0.01818478f, -0.05117866f, 0.20033121f, -0.06924624f, -0.15289086f, 0.31962079f, 0.39035007f, 0.01653906f, 
    0.07171433f, -0.04846540f, 0.00522339f, -0.04384405f, -0.07234174f, 0.13812150f, 0.00496309f, 0.02653250f, 
    0.05465441f, -0.00885181f, 0.07249311f, 0.01151956f, 0.01618640f, -0.06562089f, 0.08624782f, -0.14256571f, 
    -0.34863502f, 0.02073783f, -0.02672677f, 0.15902552f, -0.72390687f, -0.01523742f, -0.08884998f, 0.01233789f, 
    -0.12995784f, -0.03264764f, -0.01195009f, 0.00936106f, -0.00076258f, -0.08720317f, -0.05077784f, -0.00702766f, 
    0.07269060f, 0.04115746f, 0.09405097f, 0.06153349f, -0.10846995f, 0.01123727f, 0.49640188f, 0.29703411f, 
    0.31347558f, -0.03336119f, -0.02153713f, -0.02333775f, 0.21364796f, 0.03047453f, 0.00631862f, -0.01092401f, 
    0.04267246f, -0.00092101f, -0.03119996f, -0.00299467f, -0.00312442f, -0.00033905f, -0.06184503f, 0.05991429f, 
    0.10562754f, 0.11950112f, -0.23051296f, 0.24550538f, 0.25872838f, 0.03886670f, 0.00355545f, -0.04259988f, 
    -0.02432249f, -0.03018547f, -0.06953488f, 0.00370563f, -0.00696499f, -0.04721008f, -0.04621009f, 0.02031319f, 
    0.20747857f, 0.17052713f, -0.09861450f, 0.09589683f, -0.36200887f, -0.94244635f, -0.69463503f, -0.08300963f, 
    -0.53039569f, 0.02811067f, -0.04015703f, -0.15530434f, -0.01714251f, -0.11998067f, -0.00457846f, -0.00414104f, 
    -0.01682438f, -0.02160963f, -0.07383712f, 0.00048381f, -0.01655153f, 0.01458222f, -0.23543791f, 0.01023229f, 
    -0.12976521f, 0.04318938f, -0.07363774f, -0.05480882f, 0.00558747f, -0.08581150f, 0.04830303f, -0.02836693f, 
    0.02783548f, 0.04947666f, 0.04463815f, 0.03594662f, -0.12311574f, 0.04989473f, 0.08338182f, 0.09859708f, 
    -0.11865571f, -0.01128339f, 0.05209257f, -0.08265582f, -0.05925998f, -0.08909027f, -0.00474287f, -0.04206424f, 
    0.01615788f, 0.02224972f, -0.07179866f, -0.01712189f, -0.01589634f, 0.07763897f, -0.08256248f, -0.05718546f, 
    -0.02478750f, 0.00419038f, 0.04166040f, 0.01395708f, -0.04496694f, -0.08810651f, 0.05400731f, 0.00335786f, 
    -0.09890598f, -0.03725131f, 0.15047143f, -0.09531113f, -0.01310735f, 0.05279392f, -0.14364380f, -0.26518029f, 
    -0.09150800f, 0.03544375f, 0.02848511f, 0.00179642f, 0.04896730f, 0.03646884f, -0.04154717f, 0.09721541f, 
    -0.01260346f, -0.18018365f, 0.02575731f, 0.08004938f, -0.06075536f, 0.04326366f, -0.10465711f, -0.04011876f, 
    -0.00425713f, 0.02789924f, -0.01438639f, 0.03231631f, 0.02282949f, -0.01470179f, -0.05920026f, -0.02697570f, 
    0.08139807f, 0.05614973f, 0.00666609f, -0.00207001f, -0.07910172f, 0.00661861f, 0.07192773f, -0.01893673f, 
    0.18455054f, 0.14078839f, 0.37598589f, 0.07043082f, 0.12152341f, -0.01684953f, -0.06578448f, -0.01190927f, 
    -0.15269808f, 0.02018954f, 0.02396129f, -0.17271087f, -0.02418021f, 0.05589322f, 0.18981238f, 0.05586514f, 
    0.02619144f, -0.02599023f, 0.02098946f, 0.04428250f, 0.02738532f, -0.05897781f, -0.04349276f, 0.00473013f, 
    0.07956516f, -0.00554258f, 0.02755127f, 0.00212344f, 0.01152275f, 0.02985874f, -0.11691393f, 0.04637068f, 
    0.10861956f, 0.03672238f, 0.01988781f, 0.07285351f, -0.02557208f, -0.02967681f, 0.01048883f, 0.00699126f, 
    0.01701438f, 0.53508961f, -0.04132599f, -0.21041848f, -0.06199287f, 0.22675490f, 0.03392740f, -0.03365443f, 
    -0.00021239f, -0.13158062f, -0.13028437f, -0.08561531f, -0.04952894f, -0.11964229f, 0.02410234f, 0.02454060f, 
    0.01703937f, -0.12900330f, 0.08559029f, -0.03761249f, -0.15171257f, 0.00130404f, 0.31461003f, 0.10732581f, 
    0.27315676f, -0.03821442f, -0.00302961f, 0.01782661f, -0.10870297f, 0.03295657f, 0.15097713f, 0.08676329f, 
    -0.10644620f, -0.03729477f, 0.07135295f, -0.12926804f, -0.07092983f, 0.09995943f, -0.03606132f, 0.04812184f, 
    0.03793879f, -0.08089171f, -0.45399860f, 0.19069737f, -0.04882321f, 0.08041839f, -0.03727785f, -0.05951290f, 
    -0.18402022f, 0.01638724f, -0.14471114f, -0.21481395f, 0.10041531f, -0.10029534f, -0.05056351f, 0.08430151f, 
    -0.02980863f, -0.15575790f, 0.02809221f, 0.04550377f, -0.14343706f, 0.02785711f, 0.00539182f, 0.03259254f, 
    -0.16154326f, 0.14963566f, -0.04874842f, -0.00435523f, 0.05317564f, -0.13195325f, 0.05375699f, -0.05661133f, 
    0.07880375f, -0.17378157f, -0.18815421f, 0.11264949f, 0.08689354f, 0.06619097f, 0.05770388f, -0.00817343f, 
    -0.02035658f, -0.04751534f, -0.18998861f, 0.03259601f, 0.12614229f, 0.15560851f, -0.00255205f, -0.00459517f, 
    0.13878913f, -0.02903564f, 0.10089056f, -0.01185049f, -0.12985142f, -0.13487118f, -0.01669699f, 0.16183235f, 
    -0.10998036f, 0.15772100f, -0.18922494f, -0.03929225f, -0.68591124f, 0.48987594f, -0.23903143f, 0.11087669f, 
    -0.22446039f, 0.20603226f, -0.22873148f, 0.17143020f, 0.02498520f, 0.02079567f, 0.05065482f, -0.08650195f, 
    -0.07510856f, -0.24958019f, -0.12887517f, 0.14109676f, -0.05156083f, 0.02350034f, -0.01946853f, -0.17340036f, 
    0.14911388f, 0.11596987f, 0.39681783f, -0.50825441f, 0.23548171f, -0.20111467f, 0.06043096f, -0.09780001f, 
    -0.07355818f, -0.12146039f, -0.13544036f, -0.18300630f, 0.02352055f, -0.09661455f, 0.03306860f, -0.19994451f, 
    -0.11428569f, -0.17917769f, 0.09624919f, -0.01492151f, -0.16805062f, 0.14716168f, -0.21216843f, 0.05351306f, 
    0.07766148f, 0.10154085f, -0.03672406f, 0.20123860f, 0.13403785f, 0.14611557f, -0.00931341f, -0.00713502f, 
    0.05632060f, -0.15142371f, -0.16124095f, 0.15820348f, -0.03991667f, 0.00831993f, 0.12184625f, 0.07796441f, 
    -0.18637535f, -0.07619512f, -0.20188503f, -0.02043870f, 0.32688159f, 0.08819047f, 0.08566923f, 0.04076803f, 
    0.02852574f, 0.00065870f, -0.03929757f, 0.04718362f, -0.02696264f, 0.04043964f, 0.04687744f, -0.02665769f, 
    -0.04589080f, 0.06015906f, -0.07361511f, -0.03435358f, 0.03965636f, -0.11341061f, -0.09086902f, 0.07740220f, 
    0.22685023f, -0.13713016f, 0.03684430f, 0.10244258f, 0.10252877f, 0.08715997f, -0.07906567f, 0.01018616f, 
    -0.04932408f, -0.12423308f, -0.07838015f, -0.02464369f, 0.06101259f, 0.01419629f, 0.04014170f, -0.09908359f, 
    0.04231516f, 0.34377608f, 0.02051841f, 0.07456420f, 0.14869112f, 0.12768231f, 0.09410559f, -0.00789873f, 
    0.04839031f, -0.00892104f, 0.01142276f, -0.03862276f, -0.04673025f, -0.06833692f, 0.00938188f, -0.03853031f, 
    -0.09402039f, -0.01461617f, 0.04463616f, -0.06192010f, -0.01856264f, -0.11070278f, -0.02115024f, 0.00077523f, 
    -0.09611423f, -0.13489167f, -0.06194076f, 0.03425545f, 0.03903859f, -0.06045886f, 0.07246422f, -0.01736231f, 
    0.10040060f, -0.09782736f, -0.11827337f, -0.12525310f, 0.01851983f, -0.02086715f, 0.10963704f, -0.08000545f, 
    -0.50051075f, 0.28054735f, 0.35382026f, -0.06569039f, 0.43074834f, 0.08235577f, 0.00345202f, -0.03720382f, 
    -0.12574832f, -0.12245573f, -0.10419028f, -0.03906257f, 0.01298265f, 0.09890993f, 0.03566729f, 0.09659147f, 
    0.08360407f, 0.16719106f, -0.04200686f, 0.00430297f, 0.71366507f, 0.38233927f, -0.20821944f, -0.38875914f, 
    -0.16167003f, 0.15103048f, 0.06779435f, 0.11982661f, 0.10883915f, -0.29545686f, -0.15811452f, -0.03430948f, 
    -0.15002096f, -0.05998618f, 0.05265774f, 0.04787433f, 0.02290238f, 0.00554022f, 0.01786646f, -0.03484773f, 
    0.03650372f, 0.36724055f, -0.07064662f, -0.22818983f, 0.11672896f, 0.09310180f, 0.04717822f, -0.10955472f, 
    -0.13013643f, -0.19767606f, -0.14191854f, 0.03216598f, -0.13740392f, -0.04612353f, 0.10933328f, 0.09177835f, 
    0.08664981f, -0.03089422f, -0.00439131f, 0.05586605f, -0.17869933f, -0.19558525f, -0.17801410f, 0.09854042f, 
    0.21961692f, 0.09764173f, 0.08902632f, 0.09386944f, -0.03726942f, 0.03790340f, 0.02617232f, 0.03180713f, 
    0.05064575f, -0.00647892f, -0.13651043f, 0.04579600f, -0.07152107f, 0.16807199f, 0.00872718f, -0.05187623f, 
    -0.23201412f, -0.14050350f, -0.28409213f, -0.07753495f, -0.25177392f, -0.04227331f, -0.00333176f, -0.15090971f, 
    0.07312880f, -0.06175494f, 0.08646417f, 0.00961404f, 0.10187890f, 0.05431694f, 0.00412557f, -0.06055849f, 
    -0.02759657f, -0.15580724f, -0.03746735f, -0.05997491f, -0.03329864f, -0.06744017f, -0.12407760f, 0.04394611f, 
    0.13064069f, 0.02199218f, -0.05600172f, 0.13743767f, 0.04777138f, 0.07266426f, 0.04177307f, -0.03317288f, 
    -0.00544448f, -0.07042007f, -0.05909688f, -0.06560887f, -0.14036606f, 0.14525560f, -0.15818550f, 0.00855568f, 
    -1.15310061f, 0.55671775f, -0.27721956f, 0.21443351f, -0.22376603f, 0.13814841f, 0.01588894f, 0.11093137f, 
    -0.04224295f, 0.09088491f, -0.09144115f, 0.05982813f, 0.01646922f, -0.04890575f, -0.08822010f, 0.08557972f, 
    0.04915660f, 0.12772442f, 0.04273230f, 0.01592574f, 0.09636109f, -0.25386459f, -0.07302482f, 0.04400905f, 
    -0.14689685f, -0.17151339f, -0.05840915f, -0.06015371f, 0.15966396f, -0.02817867f, 0.07077967f, 0.07116935f, 
    0.01903238f, -0.05099928f, 0.00382238f, -0.09443194f, -0.07357236f, -0.02784387f, 0.07494894f, -0.00640714f, 
    -0.20873450f, -0.06701229f, 0.01605228f, -0.03090342f, -0.03286293f, 0.16750880f, 0.11235817f, 0.04044165f, 
    0.08191987f, -0.19149935f, 0.00006518f, 0.01757073f, 0.10162821f, 0.09613692f, -0.14743502f, 0.08731706f, 
    0.03361155f, 0.17999260f, -0.08749104f, -0.09523575f, -0.06476550f, -0.39634714f, -0.37644035f, -0.00252523f, 
    0.01555247f, 0.04993221f, -0.10828210f, 0.11292411f, 0.00989380f, -0.00350430f, -0.06247818f, -0.00563205f, 
    -0.03399240f, -0.12028565f, -0.02449224f, 0.17517211f, 0.11373976f, 0.12050534f, -0.20465137f, -0.09970210f, 
    0.56977504f, 0.77776152f, -0.08173069f, -0.43696356f, 0.37485033f, -0.04446593f, -0.06769743f, 0.04663746f, 
    -0.22446373f, 0.02269478f, -0.18281572f, -0.20307615f, 0.07780807f, 0.02673477f, -0.00600143f, -0.01298707f, 
    -0.02937976f, -0.09066322f, 0.07602897f, 0.14704180f, -0.11361682f, -0.18841502f, -0.09514731f, -0.04887513f, 
    0.08881845f, 0.17063934f, -0.01654038f, 0.03856792f, -0.03629130f, -0.07983093f, -0.04238138f, 0.03689639f, 
    0.04390720f, -0.00499430f, 0.00625131f, -0.03102906f, 0.06412669f, 0.00047014f, -0.04741057f, -0.00523598f, 
    -0.57859987f, -0.32630685f, 0.17922181f, 0.00473277f, 0.11778311f, -0.26827925f, 0.04309994f, -0.07241215f, 
    -0.10004390f, -0.03083034f, 0.02131233f, 0.03143237f, -0.04648705f, 0.06580325f, 0.17344829f, -0.05843152f, 
    0.12577534f, 0.08918180f, -0.12342556f, -0.06347305f, -0.24772775f, 0.00680664f, -0.03086081f, -0.14803390f, 
    -0.04160306f, 0.09109705f, -0.05632215f, 0.04404727f, 0.08009838f, 0.11843389f, -0.07811315f, -0.08109812f, 
    -0.15966918f, 0.01773352f, -0.09558331f, -0.03393727f, -0.14126162f, 0.03604700f, -0.07485200f, -0.04450198f, 
    -0.40022153f, -0.40378046f, -0.21026336f, -0.08018330f, -0.25929117f, 0.06791097f, -0.09948387f, -0.02470467f, 
    -0.04756404f, -0.13201699f, 0.01992851f, 0.07011022f, 0.02124458f, 0.04858925f, -0.15243535f, 0.00246063f, 
    0.03852011f, 0.12952779f, -0.08580273f, -0.27904415f, -0.22651646f, 0.20391995f, -0.03589255f, 0.14641891f, 
    0.34318915f, 0.03339950f, -0.01469028f, 0.00823592f, -0.06882726f, 0.07519956f, 0.00059092f, 0.03876908f, 
    0.06630935f, -0.01145323f, 0.04479857f, 0.09187972f, -0.00464179f, 0.08363835f, 0.06165761f, -0.02035801f, 
    0.21594426f, -0.08984050f, -0.22246726f, -0.15000094f, 0.16371572f, -0.05158679f, 0.01830232f, -0.03744984f, 
    0.00979837f, -0.07899392f, -0.00032863f, -0.06916444f, -0.05190707f, -0.00653998f, 0.05146735f, -0.04794981f, 
    -0.07652558f, 0.04818208f, 0.01638298f, -0.10171849f, -0.03987360f, 0.00627394f, 0.15327337f, -0.25968686f, 
    -0.07731965f, 0.09026983f, -0.08985340f, 0.04865156f, -0.26120582f, -0.01505498f, -0.02877182f, -0.06453805f, 
    -0.01253147f, 0.01646099f, 0.07437138f, 0.00360078f, 0.06790369f, 0.13745733f, -0.16267230f, 0.05820541f, 
    0.07822217f, 0.13991952f, -0.34839779f, -0.01932181f, -0.22179359f, 0.15672655f, -0.02018289f, 0.06522540f, 
    -0.06023420f, 0.01348168f, -0.09405738f, -0.05968473f, 0.05783087f, -0.05854894f, -0.04151067f, -0.06740741f, 
    -0.12017109f, -0.16295889f, 0.04229334f, -0.00589547f, 0.34778050f, 0.13732500f, -0.10268788f, -0.49627343f, 
    -0.22116692f, 0.00394237f, -0.08716480f, 0.02330243f, -0.04309607f, -0.06439254f, -0.03321449f, -0.07338898f, 
    -0.07136810f, -0.13207194f, -0.03026194f, -0.04344995f, -0.03167198f, -0.04863997f, 0.01479211f, -0.00223045f, 
    -0.05623474f, 0.00590588f, -0.11593152f, -0.00868051f, 0.24514246f, 0.07617331f, -0.01852683f, 0.00889151f, 
    -0.04995641f, -0.04284653f, -0.06232908f, 0.05616805f, 0.02321977f, 0.03973778f, 0.06560122f, 0.03809255f, 
    -0.08564418f, 0.05276123f, 0.05220441f, 0.08524484f, -0.32192361f, 0.07694999f, -0.16272368f, -0.17699422f, 
    0.26339141f, 0.25457153f, 0.04672651f, -0.06701047f, 0.11113649f, -0.37954867f, -0.10639494f, 0.07968904f, 
    0.05828318f, 0.09683529f, 0.15131970f, -0.08218751f, 0.13742675f, 0.14105575f, 0.08045253f, -0.13724950f, 
    -0.11617258f, -0.02456115f, -0.08597571f, 0.10808777f, 0.08586179f, 0.01726455f, 0.00288775f, 0.01050637f, 
    0.11467526f, 0.01751745f, 0.05243399f, 0.02745861f, 0.00148334f, -0.04738490f, -0.00584156f, 0.03876787f, 
    0.04233039f, -0.04691987f, 0.04964406f, 0.00734570f, -0.56540740f, -0.08358720f, 0.03542970f, 0.08900843f, 
    -0.19691919f, -0.03117662f, -0.01178521f, -0.05294392f, -0.08645181f, -0.07646386f, -0.05113633f, 0.11034398f, 
    -0.16552694f, 0.04821821f, 0.04829409f, 0.06660861f, -0.01877010f, 0.16056535f, -0.17182095f, -0.11953036f, 
    -0.43333918f, -0.18997581f, -0.07630082f, -0.21730562f, -0.22399910f, 0.12575653f, -0.07322779f, 0.06781910f, 
    -0.07940715f, -0.14922455f, -0.01205261f, 0.09414012f, -0.11682610f, 0.00990329f, -0.13440871f, -0.12150288f, 
    -0.01225250f, 0.05369356f, 0.02841018f, -0.03390848f, -0.02880910f, 0.02656976f, 0.28115481f, -0.03854866f, 
    0.21018660f, -0.07251666f, 0.05613323f, -0.04097402f, 0.09052377f, 0.02535510f, 0.09013834f, 0.05270077f, 
    -0.00394292f, 0.02152198f, 0.14555202f, -0.05447043f, 0.06200439f, 0.02764950f, 0.03375366f, -0.06119867f, 
    0.20266207f, 0.34493110f, 0.24089798f, -0.58833748f, 0.10962780f, -0.16620208f, -0.06218672f, 0.08534204f, 
    -0.08348283f, -0.10357422f, 0.02940922f, -0.03982523f, -0.01792555f, -0.00604367f, 0.08752573f, -0.04830796f, 
    -0.11498948f, -0.07190420f, -0.00751508f, -0.04394023f, -0.20510972f, 0.14830215f, -0.04457770f, -0.10078105f, 
    0.12243763f, 0.18833666f, 0.01836918f, 0.03219944f, -0.05732334f, 0.01781341f, -0.15517126f, 0.01602177f, 
    0.02557205f, -0.07775936f, 0.05547187f, -0.09997478f, 0.03195211f, -0.12440167f, 0.10625707f, 0.04923129f, 
    -0.04101399f, -0.16992003f, -0.14589925f, -0.13049616f, -0.27862865f, -0.02901109f, -0.11418410f, 0.14806759f, 
    0.08682816f, -0.08492338f, 0.04507304f, -0.10073622f, 0.02316698f, -0.03634940f, -0.00674198f, 0.02385724f, 
    0.00841887f, 0.02098379f, 0.01587951f, -0.09892782f, 0.04659675f, -0.08892688f, -0.10403004f, -0.05762582f, 
    0.15505223f, -0.01010640f, -0.04531244f, -0.04135085f, -0.02487792f, -0.09802712f, 0.05851441f, -0.03582970f, 
    0.07120907f, 0.04317030f, 0.11075483f, -0.08567926f, -0.02010521f, 0.10021083f, -0.02436143f, 0.03027429f, 
    0.04217255f, 0.14012383f, 0.28611770f, -0.02059668f, 0.16526386f, 0.00520884f, 0.12816285f, 0.05280451f, 
    0.03681656f, 0.11012589f, 0.10817972f, -0.03921355f, -0.12915145f, -0.02273534f, 0.14660180f, 0.01179712f, 
    -0.11649796f, 0.12784806f, -0.09193836f, -0.09302322f, -0.35876125f, -0.06771646f, 0.38258708f, 0.38715407f, 
    0.40924102f, -0.07844795f, -0.06561697f, -0.07230962f, -0.07792782f, -0.08113761f, 0.03958569f, 0.02552900f, 
    -0.01231986f, -0.03783270f, -0.00209489f, -0.05514710f, 0.02659901f, 0.06622715f, 0.03077730f, -0.09868761f, 
    -0.49156499f, 0.23259820f, 0.16424330f, -0.20030110f, -0.17555094f, -0.01263456f, 0.06611297f, -0.02505807f, 
    -0.02272697f, 0.00818557f, -0.14960045f, -0.07871574f, -0.01208317f, -0.07108224f, 0.16805780f, 0.04482567f, 
    0.00432563f, -0.00561826f, -0.13875413f, -0.20055594f, -0.08514734f, -0.11651034f, -0.12419007f, 0.05638377f, 
    -0.41827863f, 0.03493898f, -0.03349585f, -0.01489490f, 0.06528219f, 0.10834290f, -0.02949675f, -0.02170041f, 
    0.00333148f, -0.06143188f, -0.07185983f, -0.09686992f, -0.07877196f, -0.11899579f, -0.12497511f, -0.00994334f, 
    -0.17233330f, -0.34157449f, -0.25773373f, -0.02983342f, -0.11721234f, -0.03800840f, 0.06933060f, 0.11783699f, 
    -0.04138596f, -0.08915427f, -0.01630166f, 0.03906291f, -0.08614743f, 0.09509905f, -0.05643957f, 0.14288734f, 
    -0.00809977f, 0.06045368f, -0.06925795f, -0.16018021f, 0.16905247f, 0.33992648f, 0.19817644f, -0.00426915f, 
    -0.06977241f, 0.12015699f, 0.26379770f, 0.00876701f, -0.00939250f, 0.13932015f, -0.17677316f, -0.00739988f, 
    0.13246959f, -0.13113074f, 0.04315714f, -0.07118638f, -0.04888206f, 0.04799858f, 0.11315814f, -0.05024799f, 
    0.60216355f, 0.35641375f, -0.10987169f, -0.15069154f, -0.40485033f, 0.09103964f, -0.02548571f, -0.08809007f, 
    0.06724487f, -0.01398518f, 0.00849308f, -0.04731736f, 0.10431232f, -0.06591270f, -0.02765723f, -0.01677122f, 
    -0.00570871f, -0.29474393f, -0.03442318f, -0.03675589f, 0.04225286f, 0.03556631f, -0.09312112f, -0.01715622f, 
    0.22047283f, 0.09309136f, 0.01323415f, -0.00819046f, -0.03459014f, 0.03088582f, -0.08319036f, 0.05279824f, 
    0.14465161f, 0.06903109f, 0.12046295f, 0.00805491f, 0.06654478f, -0.00265877f, 0.07084593f, 0.06210747f, 
    0.05595534f, -0.04534967f, -0.14733006f, -0.12347330f, 0.18902738f, 0.05873057f, 0.02706356f, -0.00229917f, 
    0.06444457f, 0.00448295f, 0.05225492f, -0.04514796f, -0.08105185f, 0.00612319f, -0.02946289f, 0.00699274f, 
    -0.05805066f, 0.12036855f, -0.01063349f, 0.04165594f, -0.31329891f, -0.12304730f, 0.13723901f, -0.11041152f, 
    0.43114123f, 0.10775357f, -0.01963600f, -0.13155299f, -0.08332331f, -0.06345928f, -0.14477620f, 0.00298715f, 
    -0.04804208f, 0.02399617f, 0.07064021f, -0.07429405f, 0.05454005f, 0.21026774f, 0.11172734f, -0.09260463f, 
    0.30952370f, -0.03731184f, -0.04377132f, 0.17859350f, -0.23964556f, 0.09155289f, -0.01326680f, -0.05433991f, 
    0.08343109f, -0.07514563f, -0.07722382f, -0.08681329f, 0.02288046f, -0.01960796f, -0.04399964f, -0.06272197f, 
    -0.05457492f, 0.02208624f, 0.01078957f, -0.00767726f, 0.01911920f, 0.08992706f, -0.03115602f, 0.18726924f, 
    0.20189825f, -0.12325505f, -0.14634049f, -0.03107224f, -0.04824993f, -0.07767609f, -0.03221489f, 0.00780866f, 
    0.03108438f, -0.05952674f, -0.01345355f, 0.03277030f, 0.02001161f, 0.00544319f, -0.01515036f, -0.05287473f, 
    -0.15465100f, -0.02138340f, -0.27026990f, 0.25624862f, 0.27013549f, -0.10448419f, 0.01764335f, 0.05964112f, 
    0.01427901f, 0.06788260f, -0.00143446f, 0.08695465f, -0.05145277f, -0.08969091f, -0.06172059f, -0.02011734f, 
    0.03671593f, -0.10699400f, 0.06343393f, 0.00069853f, -0.22524656f, 0.07958561f, -0.10834669f, -0.06423133f, 
    0.27759451f, 0.03344624f, -0.00503581f, -0.02552209f, 0.00115975f, -0.03063808f, -0.05728383f, 0.12686962f, 
    0.02556079f, 0.10241091f, 0.15389307f, -0.04222719f, -0.00797987f, 0.08892883f, -0.01312527f, 0.05927113f, 
    0.28055894f, 0.33529648f, 0.18824467f, -0.50491363f, 0.07966296f, 0.02818156f, 0.12181777f, -0.00252043f, 
    0.06250355f, 0.09136683f, -0.02417781f, -0.04068309f, 0.04788760f, 0.06116864f, 0.06328238f, 0.03044198f, 
    -0.00860642f, 0.03635608f, 0.02576060f, -0.05145580f, 0.03196913f, -0.12833481f, -0.21844493f, 0.01942527f, 
    0.25800511f, 0.16908252f, 0.05728577f, 0.00153300f, 0.08712458f, 0.13851854f, -0.06730814f, -0.03321151f, 
    -0.05519971f, -0.05622127f, -0.04371621f, -0.05038942f, -0.09013017f, 0.04030769f, -0.04888279f, 0.00992947f, 
    -0.25991726f, -0.07807247f, 0.06773745f, -0.21924993f, -0.30767965f, -0.14168148f, 0.02040106f, 0.07288167f, 
    -0.00206826f, -0.27514118f, 0.07770336f, 0.04309141f, -0.01824840f, -0.07994720f, 0.03511999f, -0.08662266f, 
    -0.03603122f, 0.17746057f, -0.08845534f, -0.00421594f, -0.10456516f, -0.14520523f, -0.19387542f, -0.02033339f, 
    -0.29496241f, 0.05310551f, -0.18135570f, 0.03489535f, 0.04990984f, -0.02279075f, 0.05331295f, -0.05042561f, 
    0.11214685f, -0.12604553f, -0.04240352f, -0.00385507f, -0.00552274f, -0.01669479f, 0.06347198f, -0.12560630f, 
    -0.29811609f, 0.12044828f, 0.20701930f, 0.12706421f, 0.26176417f, 0.00987457f, 0.04741162f, -0.04322948f, 
    -0.04187727f, -0.05048766f, -0.01752722f, -0.11721566f, -0.07591233f, -0.02087945f, -0.04826975f, -0.02843289f, 
    -0.04192980f, 0.04867258f, -0.06306985f, -0.00635576f, -0.26126322f, -0.17238279f, -0.20272960f, -0.04901996f, 
    -0.17892613f, 0.19569787f, 0.05193093f, 0.10542017f, 0.01121652f, 0.09927706f, -0.00532306f, -0.10631724f, 
    -0.16210300f, -0.06527995f, -0.03742218f, -0.05457231f, -0.08894482f, -0.14042732f, -0.17231236f, -0.19283392f, 
    0.93786955f, -0.20572354f, -0.21828012f, 0.17275847f, -0.11868718f, 0.24612506f, 0.02876440f, 0.16752028f, 
    -0.05826811f, -0.09900779f, -0.25105706f, -0.03264156f, 0.04600773f, 0.05951162f, -0.09022840f, -0.08747903f, 
    0.00858128f, 0.05569322f, -0.05153724f, 0.07779682f, 0.01562151f, -0.01932937f, 0.15510878f, -0.27942279f, 
    -0.34311673f, 0.12977150f, -0.05623524f, 0.03666820f, -0.00284412f, -0.08216798f, 0.13922349f, 0.00821914f, 
    0.16076691f, -0.17351359f, -0.19104463f, 0.06920264f, 0.07718925f, -0.06837185f, 0.17002696f, 0.07748334f, 
    0.06006715f, -0.37157378f, -0.11819059f, -0.05319394f, -0.01895398f, -0.03710707f, -0.11261513f, 0.07889441f, 
    -0.02541033f, 0.07505918f, -0.06403685f, 0.08296765f, 0.00110627f, -0.11023393f, -0.13431455f, 0.02721929f, 
    -0.02064159f, -0.01375432f, -0.00481157f, -0.00171335f, 0.00556216f, 0.05833430f, 0.04450277f, 0.02113209f, 
    0.26983112f, -0.00129878f, 0.04607914f, 0.02375876f, 0.03674559f, -0.05632439f, 0.01603689f, -0.00200922f, 
    -0.02347154f, -0.08888153f, -0.00353818f, -0.00073052f, -0.10783239f, 0.02398487f, -0.01419540f, -0.13580404f, 
    0.06485420f, -0.04222931f, -0.00319180f, 0.02988739f, -0.03465445f, 0.02825937f, -0.05198492f, 0.12005755f, 
    0.00356539f, 0.03524200f, 0.02273636f, -0.12187869f, 0.05606373f, -0.06237937f, -0.01770259f, 0.02201675f, 
    -0.02249367f, 0.05387050f, -0.13510375f, 0.00011949f, 0.01570499f, -0.03678406f, 0.02566769f, 0.07575766f, 
    -0.00547319f, 0.02518019f, -0.02361161f, -0.03363496f, -0.06645454f, 0.03591017f, -0.12197130f, 0.04875041f, 
    -0.15344225f, 0.07437363f, 0.08353348f, -0.04313627f, -0.09370927f, -0.00778923f, -0.14113331f, -0.16536176f, 
    -0.04410196f, 0.05172332f, 0.10929670f, 0.06621263f, 0.10693052f, 0.05576836f, -0.09427106f, -0.13238764f, 
    -0.00454698f, 0.18308666f, -0.16405700f, 0.00089467f, -0.05261092f, 0.04590502f, 0.07676285f, -0.01368087f, 
    -0.07218686f, -0.07932326f, -0.11150321f, -0.26295355f, -0.00453573f, -0.34100735f, 0.02041025f, -0.07361512f, 
    -0.03828868f, -0.06359993f, 0.02052780f, 0.01675319f, -0.02245235f, -0.10322412f, -0.14299875f, -0.04345039f, 
    0.03854800f, 0.04180912f, 0.04595335f, -0.16990682f, -0.20416778f, -0.00707914f, -0.02825418f, -0.40300196f, 
    0.47224736f, 0.15474397f, -0.45377755f, 0.25080201f, -0.00479168f, 0.17704636f, 0.01326761f, 0.13548337f, 
    -0.04010820f, -0.15193580f, 0.13664798f, -0.09279400f, -0.00226429f, -0.01879027f, 0.06811041f, -0.06400939f, 
    0.08639301f, 0.07251159f, -0.28606093f, -0.11693446f, 0.15507419f, -0.00915809f, 0.19081509f, 0.10828172f, 
    0.03692601f, 0.07270345f, -0.04129432f, -0.01589317f, -0.18078917f, 0.04313879f, 0.03666768f, 0.02781971f, 
    -0.03519218f, 0.04063809f, 0.05435955f, 0.02429076f, -0.01684070f, 0.01100107f, -0.08336712f, -0.23924521f, 
    0.24584506f, -0.06468489f, 0.15721826f, 0.02958206f, -0.00198427f, -0.15818554f, -0.14533578f, -0.15133101f, 
    0.17877848f, 0.01752110f, 0.03092435f, -0.09975544f, 0.06611342f, -0.01173187f, 0.08467243f, 0.03354069f, 
    -0.00430052f, 0.02283864f, -0.00786758f, -0.04082323f, 0.00830306f, 0.11941935f, 0.11934156f, 0.11799925f, 
    0.16831480f, -0.00678723f, 0.18232380f, 0.02261016f, 0.05746714f, 0.07499377f, 0.00572603f, -0.05354580f, 
    -0.00414763f, -0.00506342f, -0.02687312f, 0.10158528f, 0.12667690f, 0.03322418f, 0.05440723f, 0.28081667f, 
    -0.38861677f, -0.22263618f, 0.09294458f, -0.10271300f, -0.05286596f, -0.10303564f, 0.00599646f, -0.08881251f, 
    -0.05095990f, 0.02920524f, -0.08917534f, -0.12117545f, 0.03387935f, 0.12579021f, -0.01686390f, -0.04145865f, 
    0.01728475f, -0.05764057f, -0.08399171f, -0.04393617f, -0.01649866f, 0.18030681f, -0.09750932f, 0.18725643f, 
    -0.05621593f, 0.05012909f, 0.01312452f, -0.00518620f, 0.01338299f, 0.02928494f, 0.08313394f, -0.01059967f, 
    -0.06193951f, 0.03334252f, 0.00090363f, -0.03378876f, 0.07509853f, -0.07019681f, -0.07145062f, 0.02393346f, 
    -0.06881730f, -0.32533729f, 0.11863779f, -0.03346350f, -0.04354454f, -0.07550094f, -0.03351942f, 0.06989798f, 
    -0.02007666f, -0.18533085f, -0.01035846f, -0.16921660f, -0.17569926f, 0.12575407f, 0.08580850f, 0.03023908f, 
    0.05085588f, -0.06387176f, -0.07267586f, -0.08502664f, -0.00541266f, -0.18294221f, 0.03073080f, -0.09934402f, 
    0.03736862f, -0.13991757f, 0.00974422f, -0.10013566f, 0.05341619f, 0.07217512f, 0.11358328f, -0.05639811f, 
    0.11659487f, 0.02228676f, -0.08913517f, 0.03891215f, -0.09197961f, -0.07470186f, -0.01898386f, -0.01997947f, 
    -0.09633729f, -0.16199337f, 0.03998401f, -0.14539167f, 0.04713775f, -0.19420762f, -0.17190802f, -0.04022868f, 
    0.06141851f, 0.07545970f, 0.00685605f, -0.04654831f, 0.06814374f, -0.04770939f, 0.02768379f, -0.06392079f, 
    -0.10834383f, -0.02510174f, -0.06462388f, 0.02202479f, 0.09868082f, 0.12745968f, 0.07232607f, 0.02782269f, 
    -0.03377154f, -0.03358657f, -0.03362130f, -0.11443093f, -0.00006414f, 0.03505930f, 0.17819968f, -0.05718984f, 
    0.08188590f, 0.07292746f, 0.06480590f, 0.11591990f, 0.03555501f, -0.09986253f, -0.10028996f, 0.00149481f, 
    -0.01761835f, 0.04228067f, -0.03913173f, -0.05387315f, -0.03345408f, 0.00498062f, 0.00471444f, -0.01177224f, 
    0.05646468f, 0.02577265f, 0.02827737f, 0.03058859f, 0.00609647f, -0.05694150f, 0.03551583f, -0.10426296f, 
    0.03378382f, 0.04502941f, -0.02826434f, -0.02068321f, 0.11330438f, 0.08729584f, 0.32865784f, 0.16908751f, 
    0.21232949f, -0.01082506f, -0.03093653f, 0.07705875f, 0.10466722f, 0.14816546f, -0.02639490f, -0.02080980f, 
    0.00553685f, -0.02366655f, -0.00459181f, -0.03841986f, -0.03949906f, -0.06358515f, -0.02549177f, -0.13755356f, 
    0.03386345f, -0.04142986f, 0.07239760f, -0.31010881f, 0.17591944f, 0.07150110f, 0.08074648f, 0.00214523f, 
    0.06446902f, 0.00867349f, -0.00908691f, -0.00423792f, 0.01280371f, -0.04491620f, -0.05707292f, -0.06168099f, 
    0.05830384f, 0.03242117f, 0.03674935f, 0.16601819f, -0.32960308f, 0.28789735f, -0.22000290f, -0.33470342f, 
    -0.17360140f, 0.07151310f, 0.07860605f, 0.00109699f, 0.07493597f, -0.00598833f, 0.05146154f, -0.00379907f, 
    0.03535467f, 0.00775746f, 0.06091975f, 0.03277412f, 0.04617608f, 0.15129861f, -0.10869265f, 0.07650842f, 
    0.13101792f, 0.07705539f, 0.00589154f, -0.03336721f, -0.02058104f, 0.08385505f, 0.03563168f, 0.04530270f, 
    0.03401094f, 0.03194115f, 0.06829936f, 0.14603406f, 0.00357038f, -0.19869278f, 0.08943592f, 0.11401808f, 
    0.07255137f, -0.14348122f, -0.12489114f, 0.02518932f, 0.02922231f, 0.00952403f, 0.02494360f, 0.02519911f, 
    0.02577786f, 0.07924654f, 0.08863191f, 0.05398136f, 0.02117411f, 0.02342309f, 0.08632989f, 0.02966597f, 
    0.01591653f, 0.03985592f, 0.08851303f, 0.14368853f, 0.03465062f, -0.03042326f, -0.02569001f, 0.00887642f, 
    0.39945927f, -1.12180519f, -0.39503911f, 0.35747302f, -0.38392478f, 0.14640389f, -0.06645089f, 0.05892036f, 
    -0.11622630f, 0.02408920f, -0.02982576f, -0.11770407f, -0.09919111f, 0.11277650f, -0.04870484f, -0.04583376f, 
    -0.14714466f, 0.01513798f, -0.27342987f, -0.05641067f, 0.07901091f, 0.01928906f, 0.06554911f, 0.04559503f, 
    0.05284069f, -0.03527043f, -0.01966428f, -0.02418112f, 0.00450431f, 0.16269760f, 0.04390309f, 0.00561070f, 
    -0.17075758f, -0.04336382f, -0.08187591f, 0.06615923f, 0.03045964f, 0.02875219f, -0.01629875f, -0.02647380f, 
    0.27618721f, 0.07442126f, -0.00737755f, 0.06039816f, 0.08360706f, 0.15926528f, 0.01670774f, 0.00671971f, 
    0.04425041f, 0.04404893f, 0.05075531f, 0.01079587f, -0.00661986f, -0.03942049f, -0.06185941f, -0.04911013f, 
    -0.12023419f, -0.11283464f, -0.10050251f, -0.03325168f, 0.02787279f, 0.12606806f, 0.06259127f, -0.06584262f, 
    -0.06901217f, 0.05453947f, -0.06500198f, -0.04228559f, 0.01767427f, 0.12993459f, 0.06878725f, -0.03837955f, 
    0.02633758f, -0.02188950f, 0.08424222f, 0.05200958f, -0.19266044f, 0.00118206f, -0.18739620f, -0.18666847f, 
    0.03590729f, 0.00855135f, 0.03942633f, 0.02035440f, 0.01636596f, 0.06418254f, 0.05856700f, 0.04125309f, 
    0.03796474f, -0.00514588f, 0.11036809f, 0.07101922f, -0.01562910f, 0.01211870f, 0.09398183f, 0.05757386f, 
    -0.00012706f, -0.03348486f, 0.00848571f, 0.07776487f, 0.08648404f, -0.13949607f, 0.15562281f, 0.01861547f, 
    0.06876477f, -0.05546287f, -0.02603829f, -0.04673526f, -0.16988352f, -0.08709946f, 0.05023531f, -0.15174671f, 
    -0.00593722f, 0.07285695f, 0.03400533f, 0.08034864f, 0.04152052f, 0.00251627f, -0.01816916f, -0.08272495f, 
    -0.03819814f, -0.06750575f, 0.10328295f, 0.20234217f, 0.10549750f, -0.08277758f, 0.01412869f, -0.11305963f, 
    0.14052449f, 0.10265617f, 0.04896032f, 0.01381915f, 0.03311260f, 0.04621850f, 0.00706486f, 0.01811047f, 
    0.06245304f, -0.02957560f, 0.08446752f, 0.00368260f, 0.09426862f, 0.09122653f, -0.09722394f, 0.03044532f, 
    -0.02511066f, 0.11054104f, 0.00502881f, -0.03605730f, 0.05608672f, 0.07151294f, 0.01374821f, -0.07068518f, 
    0.04141171f, -0.22000803f, 0.07354388f, 0.04160071f, -0.23601878f, -0.03578795f, -0.07304745f, -0.05877112f, 
    0.00332923f, 0.03019056f, 0.06824566f, -0.02290620f, -0.02754223f, 0.00319111f, -0.02954307f, 0.00905465f, 
    0.05989328f, 0.07299837f, -0.03391149f, -0.05552721f, 0.01926757f, -0.06134631f, -0.06411574f, 0.02375692f, 
    0.00037868f, 0.04716636f, -0.06956627f, -0.03205846f, -0.08877642f, -0.03082963f, -0.10224050f, 0.04300449f, 
    -0.03261791f, 0.06273741f, 0.01918581f, -0.06119277f, -0.01849854f, -0.01360658f, 0.04169844f, -0.10696188f, 
    0.11573298f, 0.07884523f, -0.03058157f, 0.01397037f, -0.16548210f, -0.06462841f, -0.18012477f, 0.03286630f, 
    0.06797069f, -0.05781094f, 0.15267721f, 0.01635265f, 0.10690422f, -0.11217527f, -0.01661119f, -0.08668978f, 
    -0.03285569f, 0.02492684f, 0.11831123f, 0.00932417f, -0.00869311f, -0.00708151f, 0.02887463f, 0.04994487f, 
    0.01103010f, 0.03618211f, -0.03442143f, -0.02151552f, 0.09738079f, -0.21627192f, 0.21741238f, 0.17081764f, 
    0.04389207f, -0.28119853f, -0.10278244f, 0.02007668f, 0.06756776f, 0.10898203f, 0.03788375f, 0.00985423f, 
    -0.02035567f, -0.02353638f, 0.01036270f, -0.01313845f, 0.03093743f, -0.00446484f, 0.01485315f, -0.00661245f, 
    -0.07224119f, 0.07930516f, 0.00827101f, -0.10683405f, 0.08821232f, -0.06422880f, -0.01296080f, -0.01435279f, 
    0.03519289f, -0.04285055f, 0.03124189f, -0.02686761f, 0.00842726f, 0.08555505f, -0.00110947f, 0.01996957f, 
    0.15849937f, 0.06495854f, 0.03858203f, 0.23249435f, 0.13055210f, -0.16843688f, 0.04383389f, -0.14639436f, 
    0.13892782f, -0.04179648f, -0.11507905f, 0.06092618f, 0.02049111f, -0.12723616f, 0.02174419f, 0.04433572f, 
    0.02667073f, -0.03906241f, 0.01760180f, 0.01059289f, -0.05743738f, -0.09237131f, -0.05064623f, 0.07583538f, 
    0.03861354f, 0.04038837f, -0.01522275f, -0.06202943f, -0.04935537f, 0.04224315f, -0.03132246f, 0.01123432f, 
    0.10094397f, -0.01853684f, 0.07663318f, 0.01806759f, -0.05555927f, -0.10146686f, 0.05164249f, 0.05377289f, 
    0.01886572f, -0.06005958f, -0.06713936f, 0.04804573f, -0.00184637f, 0.03987490f, 0.02968442f, 0.13809414f, 
    0.12369893f, 0.09398768f, 0.24413548f, 0.07005253f, -0.00020543f, 0.04762597f, 0.08229654f, -0.00457681f, 
    0.01161647f, -0.01649856f, 0.04894757f, -0.01014036f, -0.00884053f, -0.10249881f, -0.02176384f, -0.04489481f, 
    0.00815592f, 0.04343532f, -0.09924848f, 0.19810267f, 0.12773375f, -0.01689103f, 0.03327369f, -0.11357989f, 
    -0.01122345f, 0.00973923f, 0.10315203f, -0.14496708f, -0.02648298f, -0.07096411f, 0.02630608f, -0.06986934f, 
    -0.01369673f, -0.03744196f, -0.10801374f, -0.09353738f, 0.04038535f, -0.17266208f, 0.16335636f, 0.05031005f, 
    -0.04252736f, -0.07227980f, -0.02331396f, -0.01264753f, -0.03991884f, 0.07809795f, -0.00288613f, 0.00738533f, 
    -0.05144379f, -0.09748641f, -0.07581428f, 0.01264484f, 0.00767780f, 0.04413410f, -0.01683683f, 0.01584903f, 
    -0.02189969f, 0.03666502f, -0.03913835f, 0.07568406f, 0.07812568f, 0.08005670f, 0.10186678f, -0.01348563f, 
    -0.02838630f, 0.04956550f, 0.07221208f, 0.04727680f, -0.04308450f, -0.01320058f, 0.05204874f, 0.03248620f, 
    -0.07155313f, -0.06490774f, -0.05663814f, 0.00132226f, -0.11234704f, -0.02904484f, 0.11415250f, 0.07678011f, 
    0.11238759f, -0.10329600f, 0.02091127f, -0.08434975f, -0.07454345f, -0.01284164f, -0.00014517f, 0.03514645f, 
    -0.03386537f, 0.05334528f, -0.01699070f, 0.02832181f, 0.03097057f, -0.03660087f, 0.01233754f, 0.09413638f, 
    0.00980105f, 0.12327014f, 0.00741818f, -0.02069200f, 0.07095783f, 0.08351651f, 0.09773923f, 0.03029282f, 
    0.05309036f, 0.10355688f, 0.03129817f, 0.04349526f, 0.01930213f, 0.00860316f, 0.04335607f, 0.05231846f, 
    -0.10600759f, -0.07847194f, -0.03385936f, -0.11916415f, -0.02604342f, -0.03467896f, -0.07644155f, 0.02910475f, 
    0.26288751f, -0.02591490f, 0.01230827f, -0.01142646f, -0.02853964f, -0.07257725f, 0.04306747f, 0.00563447f, 
    0.04388653f, -0.08493157f, -0.02153535f, -0.08668841f, -0.06805109f, 0.03966792f, -0.01039749f, 0.00390670f, 
    0.02021484f, -0.41492176f, -0.06035881f, -0.19926757f, -0.19711111f, -0.03057628f, 0.05482781f, 0.04167676f, 
    0.00618038f, 0.03930022f, 0.06902604f, -0.09866899f, -0.04054482f, 0.00904122f, -0.04796174f, -0.30287346f, 
    -0.16268955f, 0.04310519f, 0.01951618f, -0.01228801f, -0.08327577f, 0.10901736f, -0.06039327f, -0.21729636f, 
    -0.18110207f, 0.08976343f, 0.00768043f, -0.02316142f, 0.05675536f, 0.03607047f, 0.04655547f, 0.01464692f, 
    -0.01735700f, -0.01427289f, -0.10115917f, -0.01249795f, -0.04965749f, -0.00948527f, -0.03567649f, 0.06370449f, 
    0.05168218f, 0.03364749f, 0.06095925f, 0.01893489f, 0.05102091f, 0.09141687f, 0.07949069f, 0.10986853f, 
    0.00454966f, 0.03979392f, 0.07330927f, 0.11736968f, 0.03168146f, -0.01699911f, 0.01356128f, 0.08363719f, 
    0.00586122f, -0.07089736f, -0.04177646f, -0.00782888f, -0.00230801f, -0.46374613f, 0.09304886f, -0.23765233f, 
    -0.18235147f, 0.06502660f, -0.00111997f, 0.09165504f, -0.02107748f, 0.08313086f, 0.06973323f, -0.02000816f, 
    -0.01060676f, -0.01572762f, -0.18613134f, -0.14041793f, 0.08298100f, -0.01888841f, 0.09249410f, 0.18644364f, 
    -0.25925955f, -0.04164961f, -0.08269008f, -0.37449220f, -0.24323687f, 0.08619753f, -0.04152472f, -0.01759815f, 
    0.13528943f, 0.02537140f, -0.06470132f, -0.18002577f, -0.04910998f, -0.13189811f, 0.09970715f, -0.19689588f, 
    -0.10445502f, -0.03262218f, -0.13055375f, -0.01085487f, -0.22062151f, -0.18206710f, 0.09900948f, 0.13462457f, 
    0.14810364f, -0.09798893f, -0.00003971f, -0.03735384f, -0.14891055f, -0.00761414f, -0.07656952f, 0.05939231f, 
    -0.03828806f, -0.03663079f, -0.13006449f, -0.06891060f, 0.01298466f, 0.11031017f, -0.01306271f, 0.02105539f, 
    0.07568198f, 0.11061668f, 0.18706647f, 0.22543623f, 0.09629929f, -0.02939856f, -0.09448846f, -0.02057972f, 
    -0.00361538f, 0.10580203f, 0.07805624f, -0.00806937f, 0.05472597f, -0.02586117f, 0.01802616f, -0.00290167f, 
    -0.07927418f, -0.05038656f, -0.05504323f, -0.08118753f, 0.14086215f, -0.05102347f, 0.27088100f, 0.24456018f, 
    -0.10029750f, -0.02524121f, -0.06506595f, -0.17866267f, -0.10523099f, -0.02882365f, 0.07328805f, -0.04913514f, 
    -0.05176482f, 0.07394098f, -0.01720445f, 0.06291007f, 0.04588324f, -0.06074183f, -0.04184720f, -0.08291389f, 
    -0.51355898f, 0.18917553f, -0.17656080f, -0.38436711f, -0.13343756f, 0.07074147f, 0.00739416f, -0.01264382f, 
    0.07968699f, 0.04731854f, 0.03769107f, 0.01440825f, 0.08109623f, -0.00156650f, 0.00767357f, -0.02568041f, 
    0.01406178f, 0.01810251f, -0.16797122f, 0.09752249f, -0.15970361f, -0.16569002f, 0.13079874f, -0.10161743f, 
    0.02533806f, -0.04395740f, 0.03048646f, -0.07218576f, -0.17480130f, -0.15719134f, -0.05192709f, -0.11367067f, 
    0.05454011f, 0.02986795f, -0.03427945f, -0.01224143f, 0.00195453f, -0.03515999f, -0.02315037f, -0.09755919f, 
    0.04027611f, 0.02416881f, 0.37348887f, -0.03281992f, 0.13473105f, -0.02384458f, 0.19145210f, -0.04867963f, 
    0.06717269f, 0.02676837f, -0.03659077f, -0.03620731f, -0.00798315f, 0.03022540f, -0.03473113f, 0.02331761f, 
    0.12269880f, -0.15302579f, -0.06147757f, 0.09544002f, -0.08018272f, -0.10635889f, 0.02260129f, 0.11580899f, 
    0.12927113f, -0.09648019f, -0.03576918f, -0.06754323f, -0.16488114f, -0.06538992f, -0.06084726f, 0.01237231f, 
    -0.04361972f, 0.03294767f, -0.00125712f, 0.05147418f, -0.01194385f, -0.01366640f, 0.02082701f, 0.05116807f, 
    -0.14199308f, -0.42706397f, -0.32183734f, 0.19764902f, -0.33438051f, -0.05454302f, -0.03912224f, 0.05965827f, 
    -0.12702434f, -0.04390939f, -0.02085555f, -0.07927530f, -0.00786297f, 0.08216504f, -0.11166190f, -0.01326040f, 
    0.22159360f, 0.00643852f, 0.18093131f, 0.23268750f, 0.08860729f, 0.21352969f, 0.23799056f, 0.34897771f, 
    0.20016499f, -0.13435024f, 0.04219053f, 0.02555082f, 0.03880156f, 0.18635368f, 0.01315189f, -0.00266134f, 
    -0.00765247f, 0.02716501f, 0.03621205f, -0.03151367f, -0.01976592f, -0.10031945f, 0.03558220f, -0.18994594f, 
    0.08189399f, -0.08546268f, -0.12705384f, -0.10519646f, -0.05310706f, 0.04882019f, -0.03217306f, 0.02530306f, 
    0.05798881f, 0.00751520f, 0.02215251f, 0.03828895f, -0.00650682f, -0.07502827f, 0.01793792f, -0.05603201f, 
    -0.06851723f, 0.05409942f, -0.19401136f, -0.04102867f, -0.01960808f, 0.03164209f, 0.01144571f, 0.04355480f, 
    -0.01282182f, 0.01152143f, 0.06904705f, -0.02289663f, -0.00031928f, -0.01094205f, 0.08124556f, 0.03011374f, 
    -0.06575081f, 0.01051192f, 0.09333329f, 0.00950662f, -0.04185242f, 0.03352682f, -0.01647902f, -0.03897686f, 
    -0.05771510f, 0.03790655f, -0.01336048f, -0.08934223f, 0.01967540f, 0.09479892f, 0.01870462f, 0.16471818f, 
    -0.08836878f, 0.11055329f, 0.01598215f, -0.00911692f, 0.14388701f, -0.01775453f, -0.06447785f, -0.00451774f, 
    -0.01730354f, -0.07641149f, 0.00049473f, -0.09250914f, 0.07830610f, 0.00922323f, 0.00389086f, -0.06358121f, 
    -0.03247961f, 0.04196512f, 0.02546783f, 0.02621550f, 0.00101187f, 0.02878509f, 0.06733591f, 0.00996134f, 
    -0.09348086f, 0.07660943f, -0.01971850f, 0.03833605f, -0.14992492f, 0.03109262f, -0.05056905f, -0.12630038f, 
    0.09661426f, -0.34295687f, 0.01226183f, -0.26964536f, -0.02576066f, 0.04585427f, -0.10265304f, -0.04371514f, 
    0.25543618f, 0.15353377f, -0.02318060f, -0.00581593f, 0.03007719f, -0.21561010f, 0.04421733f, -0.00345528f, 
    -0.06647853f, 0.06013759f, -0.05012564f, 0.08787227f, -0.01475838f, 0.02887550f, -0.04128191f, 0.02145477f, 
    -0.01940073f, 0.05096519f, 0.03803491f, -0.00411186f, 0.02254388f, 0.03806494f, -0.01484497f, -0.11841169f, 
    -0.24126178f, 0.03136871f, 0.08515946f, 0.04054682f, -0.02707862f, -0.02389280f, -0.10159691f, -0.11238217f, 
    -0.31745124f, 0.16505189f, -0.15754393f, 0.01589644f, -0.06732549f, -0.00848023f, -0.03260102f, -0.09142904f, 
    0.03191768f, -0.06403136f, 0.16036040f, -0.08927654f, -0.02861379f, 0.03103614f, 0.06916058f, -0.05058628f, 
    0.08676522f, 0.08808236f, 0.01901882f, -0.01618057f, 0.32667533f, 0.06837817f, -0.16837761f, 0.05582829f, 
    0.07468213f, -0.10044805f, 0.12403543f, 0.13570875f, -0.05163462f, 0.02896164f, -0.01507038f, -0.01382532f, 
    -0.01651536f, -0.02284813f, -0.00880991f, -0.00879072f, -0.01630170f, 0.01240273f, -0.00017575f, -0.03136967f, 
    -0.19695131f, 0.27873448f, -0.08639847f, -0.14750378f, 0.01773569f, 0.02836111f, 0.01450788f, 0.09522872f, 
    0.00347728f, -0.00729719f, 0.10594936f, 0.12236145f, -0.01268603f, -0.01526199f, 0.04539876f, 0.01166822f, 
    -0.01009180f, 0.18954986f, 0.04026557f, -0.04713394f, 0.09386641f, -0.12313033f, 0.06165447f, -0.07087787f, 
    -0.01742825f, 0.11548503f, -0.06580833f, -0.03484321f, 0.05120056f, 0.00446382f, 0.04495258f, 0.10831230f, 
    -0.05716148f, 0.06359187f, 0.03451461f, 0.07653292f, 0.06745618f, -0.11370630f, 0.05416270f, 0.24709594f, 
    0.17471273f, -0.10262393f, 0.12766154f, -0.00321327f, -0.13674122f, -0.05225365f, -0.02777429f, -0.00412238f, 
    0.11263053f, -0.10011724f, -0.04464114f, -0.09681633f, 0.01055836f, 0.00867711f, -0.01282030f, -0.00604646f, 
    0.08818185f, -0.06201966f, 0.06005809f, 0.40973911f, 0.08291359f, -0.09436188f, -0.16377540f, -0.13489358f, 
    0.16326635f, -0.24156316f, -0.08422568f, -0.18928985f, -0.18482243f, 0.26640937f, 0.13543500f, 0.09241195f, 
    -0.07327165f, 0.09787123f, 0.12352145f, 0.03766019f, -0.03162505f, 0.04538026f, 0.06776815f, 0.33183038f, 
    -0.75196570f, 0.55168486f, -0.30071384f, 0.31703755f, 0.06601458f, 0.11673082f, -0.14180325f, 0.00274106f, 
    0.15253969f, 0.00759687f, -0.16359702f, 0.03688922f, 0.02447251f, -0.03225101f, -0.06361151f, 0.18030483f, 
    -0.09937530f, 0.34105992f, 0.05688200f, -0.05985458f, 0.10746630f, -0.10544889f, 0.24408337f, -0.10756594f, 
    0.01620172f, 0.09678831f, -0.04738500f, -0.00981741f, -0.02826558f, 0.06291189f, -0.13207179f, -0.09990480f, 
    -0.03297521f, -0.03135063f, -0.03556002f, -0.03899947f, 0.08641706f, 0.06933533f, 0.01958680f, 0.09438630f, 
    -0.22945054f, 0.09023726f, -0.09551229f, -0.15466645f, -0.13627204f, 0.08760744f, -0.04274920f, -0.06279943f, 
    -0.10243893f, 0.26818505f, 0.05883827f, 0.15780561f, -0.07901952f, -0.01240392f, -0.11998060f, -0.00987052f, 
    -0.05097542f, 0.03306846f, -0.05485443f, 0.12259171f, 0.14685406f, 0.10403756f, 0.25843284f, 0.19740546f, 
    -0.09303110f, 0.10482234f, -0.00835764f, 0.04494349f, 0.06207384f, -0.05540908f, 0.09101104f, -0.00413299f, 
    0.03418979f, 0.02032185f, 0.00796673f, 0.04978390f, -0.04016351f, -0.20178659f, -0.16330190f, -0.31922743f, 
    -0.38611779f, -0.05975502f, -0.12391707f, -0.19158264f, 0.02967807f, 0.12821427f, -0.04990697f, -0.07834295f, 
    -0.07792203f, 0.07677813f, -0.04189719f, 0.15866576f, -0.05655959f, -0.09872518f, 0.06443766f, -0.00781217f, 
    -0.06616671f, 0.04488594f, 0.00478790f, 0.13172044f, -0.15548709f, -0.07899387f, -0.06214102f, 0.06870279f, 
    0.06305329f, 0.18320820f, 0.03924622f, 0.03109560f, 0.09245338f, -0.05195031f, -0.03405939f, -0.05011547f, 
    -0.02492369f, 0.05152805f, 0.06884822f, -0.01328135f, -0.08432886f, 0.12328474f, -0.10611830f, -0.00762121f, 
    -0.33337241f, -0.32316619f, 0.08297350f, -0.28236780f, 0.06495822f, 0.03964414f, 0.09207278f, -0.05359496f, 
    0.02863716f, -0.11974771f, 0.07588306f, -0.02038301f, 0.21365872f, -0.09547977f, -0.03220065f, -0.02365746f, 
    -0.05267650f, 0.01228790f, 0.16996196f, -0.02063850f, -0.10852513f, 0.31113020f, -0.16805582f, 0.19883665f, 
    -0.10216537f, 0.01222723f, -0.17490418f, -0.09924222f, 0.00058397f, 0.19924799f, 0.13374440f, -0.05696044f, 
    0.03053965f, -0.00923531f, 0.06853977f, 0.00066156f, 0.10160880f, 0.01625247f, -0.06560500f, -0.05002707f, 
    -0.21601139f, -0.35796836f, -0.18976274f, 0.13179587f, -0.24538094f, 0.18303731f, -0.04738107f, -0.05618140f, 
    0.21330513f, 0.05186021f, 0.07094657f, -0.07137929f, -0.02087317f, 0.09678051f, 0.06839898f, -0.00777280f, 
    0.07296841f, 0.07789370f, -0.01813440f, -0.00880457f, -0.06487259f, 0.14476413f, -0.05546994f, -0.16096532f, 
    -0.07149119f, -0.07352757f, 0.04421784f, 0.07607006f, -0.03640047f, 0.17518209f, -0.01798732f, -0.08487580f, 
    -0.08666297f, -0.05810511f, -0.03285449f, -0.00512480f, 0.02155225f, 0.06817633f, 0.02407125f, 0.06865846f, 
    -0.09756371f, -0.17169102f, -0.01683536f, 0.14913589f, 0.03635233f, 0.04926632f, 0.01272839f, -0.02692325f, 
    -0.07425345f, 0.10454088f, -0.00549620f, -0.00263713f, 0.06337123f, 0.00568483f, 0.06849492f, -0.11120358f, 
    -0.07778352f, 0.13577786f, 0.01373052f, 0.05360399f, 0.27399689f, -0.00200303f, 0.27282295f, 0.10397683f, 
    -0.14817035f, 0.16846944f, 0.11256998f, -0.05074019f, -0.07076837f, -0.09464251f, 0.07340088f, 0.02303014f, 
    -0.00887892f, 0.03526491f, -0.00725097f, -0.03308713f, 0.05460817f, -0.09754023f, 0.10554539f, 0.04338470f, 
    0.28554302f, 0.31126824f, -0.05565294f, -0.35142443f, -0.10548577f, -0.00775223f, -0.03768853f, -0.00545032f, 
    -0.05159944f, -0.01045250f, 0.00744767f, 0.01548776f, -0.10305676f, 0.01643167f, 0.10321123f, -0.09981972f, 
    -0.11862060f, 0.02016518f, 0.17867069f, -0.02298314f, 0.21996149f, -0.28883916f, 0.02640839f, -0.14595330f, 
    0.17700168f, 0.09300294f, 0.01750590f, -0.06040552f, -0.00020479f, 0.05438613f, 0.01985127f, 0.00875523f, 
    0.05742588f, 0.01046453f, -0.00976899f, -0.14718382f, -0.03528730f, -0.00084633f, 0.09147760f, 0.01561786f, 
    -0.09250508f, -0.08435561f, -0.25942004f, 0.06015498f, 0.09508739f, 0.02370075f, 0.02474343f, 0.04115793f, 
    -0.08556429f, 0.01482682f, 0.14325675f, -0.14998543f, 0.12510008f, 0.08609559f, 0.03538320f, 0.05416290f, 
    -0.06143968f, 0.11024966f, 0.01182249f, -0.04951914f, 0.03281856f, -0.00439486f, -0.08844588f, 0.00356683f, 
    0.02426064f, 0.05544308f, 0.03213044f, 0.01321939f, -0.00657288f, 0.03736609f, -0.00808889f, -0.04439209f, 
    0.05191162f, 0.08349837f, -0.03600138f, 0.00053932f, 0.05760583f, 0.11165675f, -0.05579141f, -0.00516833f, 
    -0.72914660f, 0.30046082f, 0.36245424f, -0.03000798f, -0.34904167f, -0.00014740f, -0.18378727f, -0.13902795f, 
    0.16242711f, 0.00237232f, 0.15469719f, -0.10003799f, -0.12894736f, -0.13007601f, -0.19365947f, 0.05939779f, 
    0.07369079f, 0.03240519f, 0.03210063f, -0.07414185f, -0.28670529f, 0.18345049f, -0.25238037f, -0.09915023f, 
    -0.01956904f, 0.00596001f, 0.04228181f, 0.00454636f, -0.03962825f, -0.04868141f, 0.06080821f, -0.01827411f, 
    0.02352711f, -0.08467110f, -0.07450274f, -0.09516918f, 0.00724359f, 0.04401875f, -0.01111837f, 0.02045899f, 
    0.13405831f, -0.00959697f, -0.21107689f, -0.23981200f, 0.12593633f, 0.09486027f, 0.12376658f, -0.04629062f, 
    -0.01314509f, 0.05027022f, 0.07436987f, 0.00239608f, 0.01671732f, -0.00827324f, -0.00496211f, -0.06138024f, 
    0.01084045f, -0.05559787f, -0.01462477f, 0.04411783f, 0.05618853f, 0.02342742f, 0.03900263f, 0.01142179f, 
    0.07510881f, -0.14061616f, -0.04122147f, -0.07905137f, 0.04672070f, -0.14435916f, 0.05342867f, 0.01743575f, 
    -0.00069485f, -0.11784572f, -0.02030039f, 0.10715134f, 0.06772386f, -0.06763527f, 0.02080978f, 0.28344244f, 
    -0.14553477f, -0.10089375f, -0.08422413f, 0.05566023f, 0.03646901f, 0.10562633f, 0.00955352f, -0.03758410f, 
    -0.00649881f, -0.02393184f, 0.04541764f, -0.07396068f, -0.05023033f, 0.02576680f, 0.04204097f, 0.02456342f, 
    0.03338525f, 0.03964787f, 0.02384719f, 0.00513364f, -0.04671901f, -0.04924513f, -0.03033215f, -0.22051305f, 
    -0.09926045f, 0.04491049f, 0.04669272f, 0.03115445f, 0.05929784f, 0.02629613f, -0.07813418f, 0.01678867f, 
    -0.05271557f, -0.05258970f, -0.13390835f, -0.02357377f, -0.01273964f, 0.05336763f, -0.03802960f, 0.02836091f, 
    0.02570636f, 0.03205416f, 0.19178160f, 0.12580717f, -0.13633867f, 0.01859209f, 0.04581755f, 0.09738371f, 
    0.08009171f, 0.03239576f, 0.05038745f, 0.02156623f, 0.02553199f, 0.06179766f, 0.04074023f, 0.01739792f, 
    -0.02269423f, -0.04780053f, -0.06744862f, -0.08707646f, 0.02109321f, 0.01729223f, -0.16763534f, 0.11635908f, 
    -0.00340527f, 0.02001131f, -0.02122882f, -0.07019516f, 0.03878562f, -0.04611049f, -0.08354494f, -0.07415021f, 
    -0.03428560f, 0.11264524f, -0.18809448f, 0.28683516f, -0.01285200f, 0.06149553f, -0.05493907f, 0.00929429f, 
    -0.09580905f, -0.02035439f, -0.25069699f, -0.09494190f, 0.06787332f, 0.08016444f, 0.00679371f, 0.00808314f, 
    -0.06805654f, -0.04530995f, -0.00343100f, 0.11065567f, -0.06101359f, 0.17355561f, 0.12564051f, -0.04887494f, 
    0.02219654f, 0.20956475f, -0.00202404f, 0.02839422f, -0.11040963f, 0.09533924f, -0.04735696f, 0.21474852f, 
    -0.05004705f, -0.00861784f, -0.15243851f, -0.00651268f, 0.02740502f, 0.09774362f, -0.05530288f, 0.10132726f, 
    -0.11069763f, 0.05959104f, 0.09668081f, 0.04037498f, 0.07276352f, 0.09989506f, -0.09389708f, -0.08220417f, 
    -0.11252691f, -0.16805965f, -0.22772227f, -0.07538625f, -0.23763998f, 0.04726490f, 0.00026938f, -0.03022142f, 
    0.07877373f, 0.11951482f, 0.03599686f, -0.07401495f, 0.01172211f, 0.03394075f, -0.11329106f, -0.03458282f, 
    0.07236364f, 0.04650218f, -0.06682097f, 0.00413143f, -0.48817530f, -0.06921372f, -0.27153349f, -0.09480769f, 
    -0.18025140f, 0.13417429f, -0.06880860f, -0.16885570f, -0.12042350f, 0.05439620f, 0.02332327f, 0.04669567f, 
    -0.00740305f, -0.01197726f, -0.13177177f, -0.05938361f, -0.04742710f, 0.00503263f, 0.02404666f, 0.05994248f, 
    -0.01192338f, 0.06766061f, 0.12170036f, -0.03559470f, 0.17329559f, 0.02415401f, 0.02133575f, -0.06841514f, 
    0.00743070f, -0.02053095f, -0.00079126f, 0.03418043f, 0.06092893f, -0.04307133f, -0.02575867f, -0.15108266f, 
    -0.12713933f, -0.27776814f, -0.06255881f, -0.34014061f, 0.30922949f, -0.15310729f, 0.04709102f, 0.17105591f, 
    -0.19695069f, 0.14314939f, 0.00691200f, 0.05547532f, -0.12126942f, 0.03340328f, 0.04951395f, -0.04101839f, 
    -0.00568665f, -0.05694878f, 0.13096835f, -0.02249514f, -0.10073199f, 0.01357858f, 0.16695917f, 0.04467791f, 
    -0.01961619f, -0.13672727f, -0.07880310f, 0.04222206f, 0.09352749f, 0.06359307f, -0.06621930f, -0.06986654f, 
    -0.04232690f, 0.04603926f, -0.06747732f, -0.00118289f, 0.00293917f, 0.06620800f, 0.10980321f, -0.01123814f, 
    -0.03740713f, -0.02813255f, 0.08272442f, -0.03593885f, -0.07398054f, -0.04129066f, -0.09454422f, 0.03565357f, 
    -0.00100731f, 0.03087540f, -0.27506903f, 0.01077485f, -0.03646138f, 0.04781187f, -0.11502269f, -0.02996859f, 
    -0.03306049f, -0.09138462f, -0.01034050f, 0.03279770f, 0.08350745f, 0.16685382f, -0.14921184f, -0.03112017f, 
    -0.36635900f, -0.26774696f, -0.04540044f, 0.34717268f, -0.17029445f, -0.01447624f, -0.03545463f, 0.09178296f, 
    0.08317208f, 0.11215462f, -0.11341314f, 0.10738314f, -0.03984011f, -0.04550395f, 0.04891976f, 0.07564564f, 
    -0.07444499f, 0.20298693f, -0.10605311f, -0.00459317f, -0.42574802f, 0.16275033f, -0.25919110f, -0.20845768f, 
    -0.05486682f, -0.02242186f, 0.02720091f, 0.00276950f, -0.07072624f, 0.00952428f, -0.02926812f, 0.06853238f, 
    -0.12757069f, 0.11516099f, 0.05102445f, -0.05317248f, -0.03359114f, 0.05497646f, -0.02626147f, 0.01569969f, 
    -0.08996058f, -0.10628878f, -0.09577501f, 0.05548283f, 0.12488773f, 0.00982524f, -0.08382624f, -0.01948345f, 
    0.00789023f, -0.02861832f, 0.02143799f, -0.03209032f, 0.00249225f, 0.07732300f, -0.00613394f, -0.00059465f, 
    0.06067130f, -0.01130994f, -0.01245618f, 0.06071999f, 0.09405144f, -0.01810056f, 0.00933885f, 0.03955377f, 
    -0.10644288f, -0.07362465f, 0.04462647f, -0.01359082f, -0.00228920f, -0.02155154f, 0.05265031f, 0.02935917f, 
    0.00422254f, 0.02782075f, -0.02394935f, -0.11629801f, -0.00205669f, 0.00226340f, 0.04848747f, -0.13292576f, 
    0.01678987f, 0.03358389f, 0.04082877f, -0.01766550f, 0.03667125f, -0.28210780f, 0.00485614f, 0.06318627f, 
    -0.01352608f, -0.03753361f, 0.03600912f, -0.07343535f, 0.07438320f, -0.07694731f, 0.02221794f, 0.04221649f, 
    0.06738279f, -0.12746410f, -0.01807764f, 0.10077258f, 0.62810016f, -0.01612757f, -0.51267523f, -0.01093664f, 
    0.07144000f, -0.02422124f, 0.26770401f, 0.04874594f, -0.06414492f, 0.07940586f, 0.00953093f, -0.00672863f, 
    0.03628807f, -0.03325866f, -0.02009387f, 0.03577248f, 0.01018321f, -0.03468854f, -0.10704470f, -0.00787148f, 
    0.24222067f, -0.23067677f, 0.05980619f, 0.13378517f, -0.01979444f, 0.01062457f, -0.04536685f, -0.12513386f, 
    -0.07928029f, 0.13891993f, 0.02181700f, 0.02318457f, -0.08404337f, 0.04191068f, 0.17683351f, 0.03006856f, 
    -0.06761843f, 0.00036650f, 0.06360062f, 0.10498175f, 0.22080433f, -0.10687800f, -0.21291925f, -0.11229543f, 
    0.20198928f, 0.00026306f, 0.04432451f, -0.05068392f, -0.04313014f, -0.01037975f, 0.04251477f, -0.02159046f, 
    0.03821626f, 0.08931624f, 0.12242847f, -0.09008323f, 0.12284104f, 0.00239022f, -0.03370262f, -0.08096752f, 
    -0.01523256f, 0.00675586f, -0.03437318f, 0.02883599f, 0.10650840f, 0.05620529f, 0.03537649f, 0.00577355f, 
    -0.09059786f, -0.01932968f, 0.12378103f, -0.13896948f, 0.00112821f, -0.05357524f, 0.07584663f, -0.00943896f, 
    0.06110217f, -0.03772779f, -0.03051086f, -0.00016808f, -0.39346364f, 0.15842856f, -0.02224037f, -0.13611211f, 
    -0.12427597f, 0.00408854f, -0.02933940f, -0.01332600f, 0.00666926f, -0.05156424f, -0.00162749f, -0.14255935f, 
    -0.14392608f, 0.04297384f, -0.04043427f, 0.00893986f, -0.08017085f, -0.13430890f, -0.08166245f, -0.03713585f, 
    0.22863951f, -0.44200090f, 0.04387241f, -0.01527208f, 0.14830893f, -0.10843442f, -0.01152243f, -0.02432575f, 
    -0.06879622f, 0.07715961f, 0.10683637f, 0.08773692f, -0.12051728f, 0.11055313f, -0.02630384f, -0.05015824f, 
    0.00652794f, 0.06573654f, -0.01896368f, 0.15839991f, -0.44147664f, 0.27897871f, -0.17989589f, -0.08032932f, 
    -0.08546358f, -0.13297389f, -0.08430517f, 0.01996063f, -0.01766570f, -0.00253760f, -0.03479260f, -0.00775486f, 
    -0.05432628f, 0.00571187f, 0.03442627f, -0.19338851f, -0.11705688f, 0.06086177f, -0.00927251f, -0.15407208f, 
    0.21952824f, -0.17463957f, 0.26380348f, 0.10322744f, -0.31270251f, 0.04231990f, 0.13973229f, -0.00141036f, 
    -0.20690539f, -0.01632942f, 0.05072049f, -0.01154453f, -0.03029335f, 0.00220027f, 0.00874780f, -0.07285488f, 
    0.04051067f, 0.02716097f, 0.12550427f, 0.14857107f, -0.29366237f, -0.01800476f, 0.12300616f, -0.09676530f, 
    -0.11262530f, 0.00507573f, 0.12111006f, 0.08640131f, -0.11798501f, 0.08018044f, 0.06202930f, 0.00445487f, 
    -0.01108330f, -0.01736597f, -0.01884465f, 0.05037092f, -0.02854296f, 0.01256392f, 0.08213519f, 0.07570334f, 
    0.24331763f, 0.05371166f, -0.33374920f, -0.03988659f, 0.21696058f, 0.00058675f, -0.00728817f, 0.01393089f, 
    -0.06407189f, 0.00571632f, 0.18770979f, -0.06522556f, -0.00039360f, 0.01345878f, 0.04927844f, -0.12105400f, 
    0.01422837f, 0.02307942f, -0.00980251f, -0.09720466f, -0.09312958f, -0.11246409f, -0.05905786f, -0.15887746f, 
    0.03674266f, 0.15765250f, -0.09250579f, 0.07672726f, 0.09091537f, -0.02554726f, -0.01503685f, 0.10874411f, 
    -0.07827995f, 0.02187865f, -0.07176036f, 0.01025602f, -0.06239846f, 0.06624236f, -0.01689785f, 0.06872141f, 
    0.02893670f, 0.10685003f, 0.23789497f, -0.08019955f, 0.05399435f, 0.13910021f, 0.01959039f, -0.06149425f, 
    0.11877909f, 0.09092564f, 0.07235534f, -0.00601637f, 0.05335997f, -0.01280680f, -0.04298162f, 0.04794118f, 
    -0.09726717f, -0.16365707f, -0.02847167f, -0.10480057f, -0.13415028f, 0.03743826f, 0.00363077f, 0.00467404f, 
    -0.17985830f, -0.00314774f, 0.04614317f, 0.07249936f, -0.09522010f, -0.06044846f, 0.07200013f, -0.07704080f, 
    -0.03452460f, 0.02070127f, -0.01525915f, -0.13705619f, -0.05265614f, 0.00481647f, 0.03117477f, -0.01872377f, 
    -0.26956275f, 0.08996008f, 0.25859481f, -0.01140389f, -0.34924790f, 0.01611596f, 0.02294043f, -0.05043020f, 
    0.06657717f, 0.02457603f, -0.08907437f, 0.00705880f, -0.01293200f, -0.05028888f, -0.00533139f, -0.08121951f, 
    -0.10672026f, -0.00937149f, -0.31907395f, -0.24392878f, 0.14160967f, -0.16174601f, 0.35752580f, -0.07220505f, 
    -0.29656851f, 0.16330393f, 0.12320292f, 0.04151414f, -0.07804346f, -0.32141390f, 0.08834329f, -0.00019062f, 
    0.01520952f, -0.01273869f, 0.04990937f, -0.00148374f, 0.07027043f, -0.05449943f, 0.06144954f, 0.13368675f, 
    -0.36572614f, -0.11444806f, -0.06757343f, 0.17373691f, -0.00476958f, 0.06602278f, 0.05504820f, -0.02753382f, 
    -0.04531640f, 0.05502311f, 0.07706415f, 0.01620945f, 0.12306083f, 0.04967411f, 0.06605999f, 0.19774699f, 
    -0.08267924f, -0.12994346f, 0.15214612f, 0.01007220f, -0.05845180f, -0.13477916f, -0.14835371f, 0.00935850f, 
    0.10331240f, -0.01513844f, -0.03115797f, -0.02038081f, -0.05485496f, 0.03755117f, 0.00724298f, -0.01049515f, 
    0.10819319f, 0.13404350f, -0.03302897f, -0.04072706f, 0.02525105f, 0.04398096f, 0.02317451f, 0.07894464f, 
    0.25383669f, 0.13167389f, -0.00970456f, -0.23638049f, 0.20632611f, -0.08183096f, -0.01289777f, 0.06675216f, 
    -0.08072809f, -0.07645723f, -0.07839120f, -0.01765899f, -0.05325229f, -0.00938785f, 0.00230028f, -0.00296678f, 
    0.00937383f, -0.04190021f, -0.04163500f, -0.05189650f, -0.04053793f, -0.17377281f, -0.15098310f, 0.06700999f, 
    0.08463473f, -0.00432186f, -0.06261968f, -0.11387449f, -0.11321726f, 0.05263288f, 0.11121402f, 0.03371052f, 
    -0.10663024f, -0.11273742f, 0.12707092f, -0.05183418f, -0.13537541f, 0.11590040f, 0.07519868f, 0.16231711f, 
    -0.10135273f, 0.91949916f, -0.68174130f, 0.05356216f, 0.05748204f, -0.10091611f, -0.12532632f, -0.05028150f, 
    0.06222518f, -0.04563714f, 0.12095036f, -0.07164542f, -0.05689601f, -0.05125075f, -0.11119369f, -0.07977704f, 
    0.00735687f, 0.14596726f, -0.03923314f, -0.07474282f, 0.00333936f, -0.02053641f, -0.05848719f, 0.07987007f, 
    -0.01915753f, 0.07094462f, -0.08666964f, -0.11328982f, 0.00185203f, 0.00502339f, -0.05609255f, 0.08756999f, 
    -0.00824877f, 0.16912812f, 0.01307469f, 0.00416652f, 0.08491478f, -0.03905561f, -0.00749546f, 0.13781185f, 
    -0.15093794f, 0.01830667f, 0.10172264f, 0.08458162f, 0.00082827f, -0.05553757f, -0.02350775f, -0.05395720f, 
    -0.05009060f, 0.12340797f, 0.04181368f, 0.06301922f, 0.07315010f, 0.04340646f, -0.07319345f, -0.00730686f, 
    0.05186218f, -0.07066122f, -0.02636800f, 0.04184395f, 0.20899853f, -0.19104514f, -0.36610833f, -0.11138217f, 
    0.13418251f, -0.10840095f, 0.04524379f, 0.22933365f, 0.17877835f, -0.20272993f, 0.03198055f, 0.00136171f, 
    -0.07230249f, -0.00814555f, 0.03887480f, 0.02032648f, 0.02877264f, 0.15688354f, -0.03245632f, 0.08470210f, 
    -0.10525823f, -0.05540972f, 0.23899674f, 0.05228395f, -0.04927628f, 0.03127187f, -0.04984827f, -0.01509044f, 
    0.02999385f, 0.03510334f, 0.01413785f, 0.05532429f, -0.00474305f, -0.02231712f, 0.07646909f, 0.03650589f, 
    0.00070987f, -0.03571149f, -0.05397563f, 0.00187333f, 0.02242765f, 0.05740497f, 0.02944074f, 0.01378652f, 
    0.08250368f, 0.00251748f, -0.01023093f, -0.07880499f, 0.02635702f, 0.05595386f, 0.07666423f, -0.05223898f, 
    -0.12601452f, 0.02576238f, 0.03501936f, -0.00903273f, 0.00308390f, -0.02808272f, -0.00120355f, -0.01684320f, 
    -0.12484001f, -0.09178079f, -0.15829930f, -0.06515356f, 0.17764615f, -0.10293727f, -0.10692754f, -0.18368445f, 
    0.10584754f, -0.16867223f, -0.05226814f, -0.04720876f, -0.09161779f, 0.02549398f, 0.04785634f, -0.00938111f, 
    -0.01072983f, -0.00507471f, 0.04275623f, -0.23552696f, -0.05629019f, -0.01179912f, -0.12424538f, 0.18737879f, 
    -0.01875509f, 0.03383057f, 0.00549159f, -0.00814465f, 0.11125438f, -0.14795926f, 0.12198413f, 0.02605215f, 
    -0.13941167f, 0.18355323f, -0.01100521f, 0.11720189f, -0.03580178f, 0.04179348f, -0.02474957f, 0.00770957f, 
    -0.17212187f, -0.34579697f, -0.05573787f, -0.19037913f, 0.22386047f, -0.04715948f, 0.10730071f, 0.28389698f, 
    0.12800658f, -0.09384912f, 0.01117796f, 0.03712617f, 0.03823918f, -0.04559095f, 0.04252424f, 0.05485534f, 
    -0.06805408f, 0.09352653f, 0.07183304f, -0.00018080f, -0.20809704f, 0.08229253f, 0.02983242f, 0.05962444f, 
    0.02245059f, -0.16348611f, 0.02318535f, -0.26582614f, -0.05807263f, -0.06876324f, 0.02839323f, 0.04151313f, 
    -0.13214070f, 0.00458016f, 0.02807317f, -0.00840276f, -0.00002751f, 0.04702698f, -0.08064384f, -0.19396609f, 
    -0.53491539f, 0.55793124f, 0.14370616f, -0.23734042f, 0.06108526f, 0.01495077f, 0.02757522f, 0.02365293f, 
    -0.10663079f, 0.23239988f, -0.00607136f, 0.10344647f, -0.01091332f, 0.11151183f, 0.01268122f, -0.01100452f, 
    -0.04915219f, -0.02311576f, -0.05768803f, 0.00225906f, -0.54665244f, -0.36421463f, -0.69363219f, -0.02675638f, 
    0.15611228f, -0.18291511f, 0.08041911f, -0.01097956f, -0.04727161f, -0.33196610f, -0.00173350f, -0.01052275f, 
    -0.01517955f, 0.02761348f, 0.11058027f, -0.02749923f, 0.00441472f, 0.11938685f, 0.16374910f, 0.10202616f, 
    -0.11777692f, 0.32878557f, -0.00150247f, -0.11054840f, 0.24587093f, -0.02220450f, -0.03376392f, -0.04486703f, 
    0.07801209f, -0.03784060f, 0.04693970f, 0.10415640f, 0.07372504f, 0.09187528f, 0.01813762f, 0.04722575f, 
    0.01927542f, -0.01650390f, -0.03098356f, 0.00148453f, 0.01765982f, -0.10585173f, -0.09000483f, -0.02998888f, 
    0.00331713f, 0.04515817f, -0.00605501f, 0.12209509f, 0.00304664f, -0.00309573f, 0.01124075f, 0.00305427f, 
    0.01247637f, -0.01523095f, 0.00005886f, -0.04871215f, 0.05547396f, 0.01633216f, -0.02151257f, 0.12674946f, 
    -0.17182887f, 0.51673388f, 0.01734607f, -0.01527804f, 0.04547202f, -0.02677517f, 0.09205454f, 0.01059864f, 
    0.07299037f, 0.03528068f, 0.11369906f, -0.03310513f, 0.21356888f, -0.10969366f, 0.01471995f, 0.02185024f, 
    0.09267994f, -0.00128482f, 0.04702291f, -0.01418487f, -0.45003304f, 0.04824542f, -0.10114099f, 0.02062809f, 
    0.11271705f, -0.15263785f, -0.07169262f, -0.12608603f, -0.01037039f, 0.16226630f, 0.06473727f, 0.00395766f, 
    0.15962750f, -0.07371058f, 0.06976265f, -0.08906946f, 0.06882391f, -0.10885569f, 0.13762510f, -0.10546681f, 
    -0.35310304f, -0.10358772f, 0.11392475f, 0.07438283f, 0.21507746f, -0.25660101f, -0.05754015f, -0.06098735f, 
    -0.15132283f, 0.23006673f, -0.04031643f, 0.05784402f, 0.14673419f, 0.05701678f, 0.06027632f, -0.00960054f, 
    0.08453448f, -0.06149725f, 0.07857254f, -0.00108402f, -0.20689267f, 0.16464387f, 0.30365321f, -0.06432576f, 
    -0.01174855f, -0.03307484f, -0.06135900f, -0.07604754f, -0.04406646f, 0.00682761f, 0.01266757f, -0.04815450f, 
    0.00206231f, 0.02464659f, 0.07747881f, 0.00060719f, -0.03165030f, -0.00401778f, -0.08688458f, -0.02000061f, 
    -0.01855912f, 0.05639686f, 0.04732841f, -0.16403058f, 0.03068556f, -0.00029480f, 0.00571064f, 0.06460633f, 
    0.02256874f, -0.01188417f, -0.01122741f, -0.09578329f, -0.06058691f, -0.01430563f, 0.00000387f, 0.04124748f, 
    0.00629566f, -0.07900364f, -0.02266040f, 0.02803287f, -0.52611619f, -0.55117738f, -0.69229192f, -0.17190808f, 
    0.00777233f, -0.08202880f, 0.08887463f, -0.10591774f, -0.01542736f, -0.25999269f, 0.00694462f, -0.06119853f, 
    -0.04677823f, -0.04541560f, -0.00694976f, -0.00726093f, -0.04032935f, 0.09514642f, 0.17588013f, 0.03900100f, 
    -0.12914816f, -0.17714833f, -0.00360588f, 0.15875643f, -0.23932393f, 0.03546887f, 0.10886723f, -0.03927418f, 
    -0.00783896f, -0.02526915f, 0.01567186f, -0.04484918f, -0.01939330f, 0.01897881f, -0.02609029f, 0.16089942f, 
    0.11384372f, 0.07292835f, -0.03043108f, 0.02356133f, -0.20516323f, 0.06443564f, -0.23257002f, -0.19575523f, 
    -0.05393498f, -0.02325573f, 0.00886134f, 0.07609697f, 0.01739354f, 0.02376284f, 0.01138708f, -0.01973793f, 
    0.04535928f, 0.00090400f, -0.02053359f, 0.04087083f, 0.16925676f, -0.09679966f, 0.08419381f, 0.14558674f, 
    0.04408006f, 0.02141053f, -0.07043191f, -0.19563077f, -0.00138658f, 0.02694433f, -0.07051737f, -0.02823704f, 
    -0.06777606f, -0.05020940f, -0.14401349f, -0.06446909f, -0.05737691f, -0.06650692f, -0.05040815f, 0.02577685f, 
    -0.13834742f, -0.14393871f, -0.11003669f, 0.05698744f, 0.05170547f, 0.04350417f, -0.03633011f, -0.10052653f, 
    -0.02731598f, 0.02226531f, -0.07268532f, -0.03715677f, -0.02170811f, 0.04087937f, -0.21274273f, -0.05449368f, 
    -0.14825787f, -0.21437392f, -0.10424307f, 0.01533459f, -0.13030496f, -0.04273512f, -0.08125598f, -0.01642501f, 
    -0.35249072f, -0.05390151f, 0.09285805f, 0.17662831f, -0.06237195f, 0.01574279f, 0.01939714f, -0.01886536f, 
    -0.04506199f, 0.11752699f, 0.17484012f, 0.00537780f, 0.01378850f, -0.06651072f, -0.12171665f, -0.01333310f, 
    0.07940867f, -0.02361524f, 0.08051889f, 0.04996654f, -0.35004279f, 0.20962490f, 0.24265234f, 0.05849269f, 
    0.11393494f, -0.06273661f, -0.05480804f, -0.04389065f, -0.06029201f, 0.18608607f, -0.03574910f, -0.00252836f, 
    0.00350759f, -0.05148318f, 0.09735849f, 0.03166504f, 0.01830415f, -0.03881863f, 0.01123233f, -0.03087603f, 
    0.16811948f, -0.16412744f, 0.06273565f, 0.00918208f, -0.00040611f, 0.04260356f, 0.11055077f, 0.11236313f, 
    -0.02955318f, -0.03781939f, 0.02416203f, -0.01761779f, 0.02229775f, -0.00785369f, 0.02785444f, 0.03152496f, 
    -0.01086224f, 0.03252956f, -0.08315247f, 0.01505700f, -0.11176907f, 0.04346114f, 0.08412948f, 0.06668569f, 
    -0.01395240f, 0.01480393f, -0.04859203f, -0.04905709f, -0.02045088f, -0.15895563f, 0.00382125f, -0.02887376f, 
    -0.04995098f, 0.07034741f, -0.00290550f, -0.03756075f, -0.01956163f, 0.04524828f, -0.13578422f, 0.00144691f, 
    0.05276692f, -0.09369053f, -0.10310010f, -0.13458157f, -0.06811399f, 0.04447059f, 0.01996235f, 0.05625130f, 
    -0.01936901f, 0.07495593f, -0.04728217f, -0.06501348f, -0.04387918f, -0.07368509f, -0.05319252f, -0.05772903f, 
    -0.10910506f, -0.11666916f, -0.03272695f, 0.03669445f, -0.27550414f, 0.40812945f, 0.21516690f, -0.01760050f, 
    0.05017796f, -0.08264372f, 0.04452935f, -0.11964742f, -0.02507762f, -0.00832015f, -0.06053308f, -0.06380764f, 
    0.01008246f, 0.02630880f, 0.01639887f, 0.05931100f, -0.02959187f, 0.01019044f, -0.04683039f, -0.02265667f, 
    -0.61947018f, -0.75055432f, -0.63182765f, -0.37609267f, -0.08553537f, -0.20650117f, -0.13462490f, -0.07534891f, 
    -0.12561311f, -0.12989339f, -0.00353015f, -0.01904705f, -0.00138719f, -0.03039879f, -0.08693398f, -0.00624756f, 
    0.03538242f, -0.02415382f, 0.10605695f, 0.03161469f, 0.00352777f, 0.01637556f, -0.00958535f, -0.10157606f, 
    0.03827246f, 0.03334666f, 0.00954910f, -0.02112960f, 0.01167662f, 0.00561334f, -0.05744050f, -0.04006988f, 
    0.01376749f, 0.08203398f, 0.00824194f, -0.06751657f, 0.09889727f, -0.03006956f, -0.07045030f, -0.01406161f, 
    -0.04333802f, 0.03700953f, 0.08423093f, 0.03181113f, 0.05178759f, -0.02274999f, -0.03508915f, -0.03668077f, 
    0.02861353f, 0.01682381f, 0.02137444f, 0.05255628f, 0.06154284f, 0.07374059f, 0.00122751f, 0.01388683f, 
    0.02693556f, -0.00553401f, -0.05059580f, -0.02124288f, -0.08703870f, 0.00977224f, 0.04902397f, -0.03098522f, 
    0.10730387f, -0.05661362f, -0.04590333f, -0.02528263f, -0.03551357f, 0.10410131f, 0.02757068f, 0.00944731f, 
    0.02265753f, -0.07853109f, 0.12458821f, -0.04899900f, -0.03302355f, -0.09585243f, 0.05157732f, -0.06363630f, 
    -0.59856623f, 0.47767854f, 0.25191098f, -0.06716961f, -0.08738056f, -0.26039171f, -0.03504104f, -0.14134169f, 
    0.06994251f, 0.20882267f, -0.05156716f, 0.00905550f, 0.06106131f, 0.00943283f, 0.02489389f, -0.00627183f, 
    -0.01074506f, -0.02531195f, 0.05143213f, -0.04711819f, -0.46681124f, 0.35929993f, 0.28635839f, -0.20107628f, 
    0.10761444f, -0.10122292f, -0.04173943f, -0.00230349f, -0.22244924f, 0.31706533f, -0.12838103f, 0.06856072f, 
    -0.00054752f, 0.08982224f, 0.04944048f, 0.01193720f, 0.00001224f, -0.06353129f, 0.06162147f, 0.03546643f, 
    -0.17832272f, -0.17170022f, 0.05110404f, -0.16059668f, -0.05873837f, 0.01685517f, 0.06572821f, 0.05770956f, 
    0.00597625f, -0.06517503f, 0.05281154f, -0.03376594f, -0.00140494f, 0.04396316f, 0.03406375f, 0.03619559f, 
    0.09193011f, 0.16318621f, 0.11845981f, 0.12697099f, 0.13802004f, -0.04815996f, -0.13376188f, -0.09428686f, 
    0.07016587f, 0.02164590f, 0.07927910f, 0.16043711f, 0.07518885f, 0.05456263f, -0.00723395f, -0.00233152f, 
    0.02908945f, -0.02342432f, 0.04866716f, -0.02929531f, 0.01104461f, 0.00314661f, 0.07262213f, 0.04221712f, 
    0.03849857f, 0.12731139f, -0.07555123f, -0.07880114f, -0.04614288f, 0.02435618f, -0.07535096f, 0.03095381f, 
    -0.04170788f, 0.10673974f, 0.03764365f, -0.06156253f, -0.00565701f, -0.00139986f, -0.05719290f, -0.12435261f, 
    0.06420425f, -0.11602386f, -0.00889749f, 0.05735144f, 0.20904861f, -0.16686599f, -0.22235511f, -0.14139645f, 
    0.12117024f, -0.06991124f, 0.03016076f, 0.17275879f, 0.07968038f, -0.00521158f, 0.01788613f, -0.01196986f, 
    -0.09000493f, -0.14602867f, 0.01328317f, -0.04708270f, 0.02625556f, 0.01413164f, 0.06491158f, 0.00850040f, 
    -0.03625613f, -0.25394821f, -0.56296653f, -0.25757071f, 0.25518221f, 0.02761534f, 0.10521294f, 0.24901311f, 
    0.11472615f, 0.01332537f, -0.00824441f, -0.00737197f, -0.00621825f, -0.02150566f, 0.01984137f, -0.00819794f, 
    0.03226350f, -0.02343528f, 0.23118055f, 0.02046136f, -0.18672241f, 0.11864907f, 0.29216984f, -0.01262377f, 
    0.15901230f, -0.01712771f, -0.09292816f, 0.02977059f, -0.07867470f, 0.10717925f, 0.01819156f, 0.06648455f, 
    0.05103229f, 0.08066618f, 0.01081227f, 0.02442016f, 0.01590530f, 0.00197132f, -0.02099567f, 0.04481560f, 
    0.10244708f, -0.16634637f, -0.08810450f, 0.06942480f, 0.02131223f, 0.00437292f, 0.06338745f, 0.11440301f, 
    0.03860170f, 0.02899091f, 0.00508311f, -0.01580534f, -0.14945827f, -0.04630934f, 0.00968477f, 0.00485982f, 
    0.02562845f, 0.03824065f, -0.05785643f, -0.04250241f, -0.49991223f, -0.56723249f, -0.61888593f, -0.14083657f, 
    -0.14709784f, -0.16613890f, 0.01872841f, -0.09190161f, -0.04144543f, -0.10397742f, 0.02704247f, 0.01141818f, 
    0.00862219f, -0.11283726f, -0.06720734f, -0.01503437f, 0.01707028f, 0.02351541f, 0.17829520f, -0.07292645f, 
    0.02217317f, -0.11464969f, -0.06012362f, 0.00758878f, 0.11779369f, -0.06576474f, -0.03285478f, -0.00007983f, 
    0.01394721f, -0.08117031f, 0.06664813f, -0.03113914f, -0.15164578f, 0.04411184f, -0.05717834f, 0.00769615f, 
    -0.02577451f, -0.00956651f, -0.00633716f, -0.07121962f, 0.30752653f, -0.03249152f, -0.22965336f, -0.22853312f, 
    0.04822380f, -0.04733314f, -0.02872433f, 0.19210109f, 0.09432358f, -0.12043671f, 0.00716358f, -0.01132493f, 
    -0.05600510f, -0.07291133f, 0.03972082f, -0.01591474f, -0.09686343f, 0.03662839f, -0.00159105f, 0.09334245f, 
    -0.08987166f, 0.04587120f, -0.03163923f, -0.06320068f, -0.08608470f, -0.01781404f, 0.08044349f, -0.07101752f, 
    0.06337707f, 0.02900470f, 0.03385242f, 0.00503450f, -0.05445778f, 0.07180287f, 0.00825707f, 0.07493369f, 
    -0.01586398f, -0.02604171f, 0.18182243f, 0.14656554f, -0.07279156f, 0.07922998f, 0.00279648f, 0.03045215f, 
    0.03755183f, 0.00919790f, -0.03144307f, -0.00813776f, 0.03326128f, 0.01991360f, -0.00725981f, -0.02046276f, 
    -0.01050286f, -0.07695089f, -0.06306812f, -0.01245876f, 0.06224107f, -0.07963803f, -0.05646788f, 0.04851658f, 
    0.10990788f, -0.06801783f, -0.06241721f, -0.04255952f, -0.04272303f, 0.03454320f, 0.01506930f, 0.08361060f, 
    -0.06855555f, 0.02317861f, -0.05113219f, -0.02720979f, -0.10058131f, -0.09673747f, -0.05239338f, -0.05741956f, 
    -0.15060003f, -0.04272501f, -0.06183512f, -0.02735276f, 0.02750231f, -0.04216446f, 0.14336221f, -0.17322874f, 
    -0.24085996f, -0.01224977f, 0.03361003f, -0.04832419f, -0.02700045f, 0.00284145f, 0.01068986f, 0.05020490f, 
    -0.02154146f, 0.07390721f, -0.04994582f, 0.04567672f, 0.04429085f, 0.12688078f, 0.06895122f, 0.01329381f, 
    -0.04582197f, 0.27169183f, -0.10196766f, -0.17417178f, 0.12461301f, -0.14910179f, 0.03758916f, -0.00609833f, 
    -0.02920022f, 0.15890843f, 0.04542484f, 0.08049008f, 0.00251352f, 0.09292707f, 0.06134298f, 0.08377736f, 
    0.13511512f, -0.02120266f, 0.08797120f, -0.02627505f, -0.32392988f, -0.41649291f, -0.07655035f, -0.07586301f, 
    0.45398560f, -0.06617641f, -0.17002198f, -0.05235526f, -0.03908010f, 0.05583020f, 0.01688559f, 0.04254942f, 
    0.10823660f, 0.03134558f, -0.08767698f, 0.02227941f, 0.02370146f, 0.03450484f, 0.07353626f, -0.00782492f, 
    -0.66138792f, -0.50951564f, -0.24466732f, -0.10129175f, -0.13531338f, -0.23919302f, -0.04940426f, 0.01405316f, 
    -0.11855329f, -0.11971632f, -0.04608355f, -0.01307148f, 0.03577033f, -0.05018658f, 0.00561963f, -0.01457235f, 
    0.01810632f, -0.00227970f, 0.14305586f, -0.22857566f, -0.47282720f, 0.54480880f, 0.35787401f, 0.08080214f, 
    0.00937954f, -0.06600350f, -0.07982465f, -0.16290295f, 0.07763845f, 0.08921500f, -0.03125918f, -0.01959210f, 
    0.05395461f, 0.04256210f, 0.08094497f, 0.01023997f, 0.08284339f, -0.02910776f, -0.05439843f, 0.01564937f, 
    -0.06671229f, 0.01705218f, 0.14739084f, -0.08940807f, 0.07171530f, 0.00549479f, -0.03649532f, 0.00887193f, 
    0.04542406f, -0.04829919f, 0.00069275f, -0.03663039f, 0.00818918f, -0.05049349f, -0.05520514f, -0.02230329f, 
    -0.00106620f, -0.05168837f, -0.10256942f, 0.01525054f, 0.02461539f, 0.49274728f, -0.07943574f, -0.05163661f, 
    0.33743051f, -0.07367761f, 0.11389106f, -0.09597921f, 0.02620747f, -0.06883280f, 0.08373237f, 0.01855882f, 
    0.04711664f, -0.06366473f, -0.01743187f, 0.09034134f, -0.05846448f, -0.00175451f, 0.01163908f, 0.00807211f, 
    -0.52955943f, -0.71133256f, -0.83874661f, -0.17242719f, -0.41865879f, -0.01958273f, -0.03208367f, -0.15437753f, 
    -0.11460233f, -0.53411883f, 0.01869263f, -0.00272470f, -0.05870743f, 0.05371110f, 0.09299437f, -0.08601780f, 
    -0.03536934f, 0.21261746f, 0.04218505f, 0.10348970f, -0.44954076f, -0.42511627f, -0.03093421f, -0.08253853f, 
    0.03344639f, -0.11001334f, -0.07257269f, -0.01202168f, -0.18701112f, -0.01206226f, -0.03408122f, 0.02689970f, 
    0.01604468f, -0.05124347f, -0.05647542f, -0.00808035f, -0.00377625f, 0.02611210f, 0.07605720f, -0.02467055f, 
    0.14378744f, 0.27293244f, -0.31154045f, 0.12268614f, 0.07015561f, 0.00378656f, 0.03513767f, -0.08156127f, 
    -0.00603059f, 0.05296855f, -0.07987198f, 0.01558717f, 0.10701939f, 0.06837128f, -0.01056705f, 0.04268174f, 
    0.00223570f, -0.05377014f, 0.12074101f, -0.04022690f, -0.98453355f, -0.76685768f, -0.47687116f, -0.49614424f, 
    0.34025908f, -0.15820818f, -0.22903498f, -0.26566023f, -0.32722640f, -0.51465845f, -0.03558793f, -0.04131536f, 
    -0.03138235f, -0.03406594f, 0.02593548f, 0.00418243f, 0.02933604f, 0.07334337f, 0.12010530f, 0.13145381f, 
    -0.03626512f, 0.09653214f, 0.04561004f, -0.14377370f, 0.08843672f, -0.02304942f, -0.03767589f, 0.08256714f, 
    0.05205995f, 0.03091272f, -0.03374924f, -0.11325737f, -0.01661146f, 0.04617472f, 0.05963736f, 0.04814879f, 
    -0.01314086f, 0.01509054f, -0.08112904f, 0.06233848f, 0.04506477f, -0.03755138f, -0.04669226f, 0.00025365f, 
    -0.02968220f, -0.03424133f, 0.00158758f, 0.06785492f, 0.03251432f, 0.05296550f, 0.01725190f, -0.01163940f, 
    -0.07976539f, -0.07002017f, -0.06209673f, 0.03911676f, -0.04276476f, -0.00803198f, -0.05012390f, 0.00762868f, 
    0.16965391f, -0.05361644f, -0.07477839f, -0.00755181f, -0.06191934f, 0.06522390f, 0.04779798f, 0.05524969f, 
    0.00392233f, -0.14440949f, 0.08785695f, -0.00531970f, -0.10486822f, -0.03977185f, 0.00809811f, -0.02260106f, 
    -0.01194550f, 0.12297166f, -0.10670407f, -0.03961496f, -0.03910457f, 0.05073912f, -0.00895748f, -0.06280337f, 
    0.01719049f, 0.02008498f, -0.03957899f, 0.01504681f, 0.06914506f, -0.01160695f, 0.01970889f, -0.01177993f, 
    -0.01942106f, 0.05485561f, 0.08092956f, 0.03306367f, -0.09518821f, 0.00055335f, -0.07753073f, -0.05563005f, 
    -0.31559139f, -0.04659353f, 0.17816478f, -0.00843818f, 0.40871894f, -0.14460939f, -0.01393107f, -0.04122074f, 
    0.16904040f, 0.17999874f, 0.13700618f, 0.17306623f, 0.14337851f, 0.05409446f, 0.09457365f, 0.04204633f, 
    0.05262845f, -0.00936798f, 0.03302209f, 0.03345314f, 0.00805830f, 0.00821492f, 0.07369735f, -0.03129127f, 
    0.02647620f, -0.08243726f, -0.04428976f, -0.07360125f, -0.04863521f, 0.10868642f, 0.12222583f, 0.01006766f, 
    -0.05426429f, 0.02103173f, 0.06551626f, -0.05102092f, -0.00394193f, -0.05623039f, -0.02020843f, -0.06326275f, 
    0.11353162f, 0.18179850f, 0.02265300f, -0.11253928f, -0.11883992f, 0.01139028f, 0.01177842f, -0.00566758f, 
    0.01241540f, 0.01153323f, -0.03048934f, -0.01040616f, -0.06186659f, -0.14031635f, -0.07448011f, -0.01539973f, 
    0.03033779f, -0.01384273f, 0.03381142f, -0.00116593f, -0.31386274f, 0.07607850f, 0.03770380f, 0.00302077f, 
    -0.08349687f, 0.00190287f, -0.11157959f, -0.03564244f, 0.15154156f, 0.07331815f, 0.07466229f, 0.03370199f, 
    0.04324692f, 0.01386687f, -0.01787495f, 0.08728934f, -0.07420370f, -0.09845688f, -0.02220054f, 0.14485052f, 
    0.20274487f, 0.08436489f, 0.01040727f, -0.08263824f, -0.04043367f, -0.00226817f, 0.01480311f, 0.01509124f, 
    -0.05874955f, -0.02428683f, -0.01812870f, -0.21313328f, 0.02558868f, -0.03923773f, 0.01008533f, 0.05401833f, 
    -0.02147252f, 0.02340870f, -0.02654680f, -0.05617360f, 0.00674929f, -0.05880903f, 0.01397233f, -0.03547158f, 
    0.00636794f, 0.01386767f, 0.02579779f, -0.02607749f, -0.01721337f, -0.10313988f, 0.00953199f, -0.02378440f, 
    -0.03174983f, 0.03705903f, -0.01083451f, 0.00230878f, -0.02102874f, -0.00819535f, 0.03318369f, -0.04008231f, 
    -0.11220451f, -0.25808159f, -0.09854481f, 0.23885152f, 0.05625904f, 0.12583497f, 0.13341090f, 0.07030396f, 
    0.01489758f, -0.04972141f, 0.01794947f, -0.00221878f, -0.01936630f, 0.01740225f, 0.00222346f, 0.03923733f, 
    0.02869792f, 0.00020608f, -0.11645310f, -0.05350171f, 0.01623126f, 0.06669696f, 0.18074764f, -0.16208982f, 
    0.13916562f, 0.05615725f, 0.05795318f, 0.00136225f, -0.03853283f, -0.04536468f, 0.02586757f, 0.04165459f, 
    -0.01975159f, -0.06243868f, -0.03076812f, -0.02536436f, 0.00654362f, -0.07149643f, -0.01744957f, 0.00928865f, 
    0.21515156f, 0.13843694f, -0.22115541f, 0.06312629f, -0.37689632f, -0.17049216f, 0.11648363f, -0.05480998f, 
    -0.11042619f, -0.00411280f, -0.03443786f, 0.02290781f, 0.04075950f, -0.05253484f, -0.01142749f, -0.10109696f, 
    -0.08993327f, 0.13156535f, -0.17341214f, -0.01768427f, -0.28814861f, -0.25405133f, 0.06316395f, -0.04767958f, 
    0.09992476f, 0.14742824f, -0.03458647f, 0.09389083f, 0.06564099f, -0.01311138f, 0.05700931f, 0.07877250f, 
    0.03583936f, 0.03919793f, 0.05444670f, 0.01509475f, -0.00176470f, 0.01805655f, -0.08069907f, -0.07809474f, 
    0.63860691f, -0.72006959f, -0.19562477f, -0.25418735f, -0.20852235f, -0.09660697f, -0.01796292f, -0.12241683f, 
    0.08785407f, -0.26183629f, 0.00300285f, -0.02216876f, 0.05088103f, 0.01536216f, -0.00572065f, -0.00229498f, 
    -0.01938506f, 0.03866369f, -0.00194919f, 0.04261759f, -0.25730515f, -0.28159812f, -0.11674099f, 0.21669477f, 
    0.12835756f, 0.10398414f, -0.04445029f, -0.01771143f, 0.01291776f, 0.08293634f, -0.02325487f, -0.04739885f, 
    -0.07910884f, -0.04225586f, -0.05115348f, 0.04793582f, 0.08270805f, 0.00406474f, -0.01082241f, 0.03448103f, 
    -0.07836611f, -0.06392039f, -0.18111517f, 0.03156914f, -0.00648520f, -0.01145878f, 0.04744495f, 0.04792001f, 
    -0.00479702f, -0.00412279f, -0.12600337f, 0.05414162f, 0.00042486f, -0.00230978f, -0.00868455f, -0.02309805f, 
    -0.01406690f, 0.00023187f, 0.02227875f, 0.05663561f, -0.01600597f, -0.00056705f, 0.00844655f, -0.03903146f, 
    -0.12337855f, -0.09565215f, 0.03555344f, -0.06016657f, -0.02969064f, 0.00384361f, 0.04648839f, -0.00204880f, 
    0.01925161f, 0.02108847f, -0.03234615f, -0.09993758f, -0.08617299f, -0.09120046f, 0.03841202f, -0.00214424f, 
    -0.09025855f, -0.22873110f, -0.00066385f, -0.19423826f, 0.20330927f, 0.07687464f, -0.07309702f, 0.16765080f, 
    -0.07868388f, 0.08859187f, -0.12388831f, 0.08525546f, -0.02888438f, 0.16943493f, -0.02984872f, 0.00144473f, 
    -0.00936523f, 0.07456154f, 0.08175319f, -0.03580599f, 0.44741404f, 0.43095183f, -0.12262989f, 0.07734988f, 
    -0.29960358f, 0.10366167f, -0.05546812f, 0.10755400f, -0.08154023f, 0.12660545f, -0.03811354f, 0.00772526f, 
    -0.00459560f, 0.01139138f, 0.03247670f, 0.02246210f, -0.07184289f, 0.03159384f, 0.00950220f, -0.14890580f, 
    0.55414915f, 0.32795650f, -0.00885068f, -0.04783290f, -0.34695715f, 0.07534851f, -0.13036123f, 0.01473917f, 
    -0.06121666f, 0.03550002f, 0.06133278f, 0.03318727f, 0.15902875f, -0.05973479f, -0.05264226f, 0.01366239f, 
    -0.07817484f, 0.01202120f, 0.03009841f, -0.05509654f, 0.30442065f, -0.05742241f, -0.09177736f, -0.09361155f, 
    -0.02124979f, -0.02371614f, 0.01305332f, -0.01709506f, -0.04558990f, -0.07629340f, 0.01394025f, -0.08266351f, 
    0.06167064f, 0.04742365f, 0.01883025f, -0.00169983f, -0.04358181f, 0.01667614f, 0.02726250f, 0.00255192f, 
    0.06099351f, 0.07585935f, -0.12724096f, 0.07343216f, -0.04841235f, 0.00115615f, 0.07139518f, 0.04687125f, 
    -0.03887187f, -0.03101120f, 0.02678127f, 0.03694261f, 0.01540114f, 0.01540523f, -0.01208013f, -0.15974505f, 
    -0.11366408f, -0.08122812f, -0.02296566f, 0.08710288f, -0.67772210f, -0.45991242f, -0.06779345f, 0.16921315f, 
    0.18744247f, -0.02312144f, -0.02626606f, 0.08891805f, 0.01414337f, 0.02815621f, 0.05721495f, -0.02800819f, 
    -0.02945283f, -0.04911030f, -0.02569765f, 0.02233680f, -0.01570016f, -0.05412417f, 0.05425934f, 0.00783895f, 
    0.13586713f, -0.13915916f, 0.12605864f, -0.10152306f, 0.10418585f, 0.05578502f, -0.00448755f, 0.05511222f, 
    -0.00173773f, 0.01851914f, -0.00106844f, 0.04409069f, 0.00026083f, 0.04782950f, -0.04920591f, -0.01416278f, 
    -0.03581324f, -0.26743469f, -0.01859556f, 0.01375051f, -0.12554666f, 0.06246172f, -0.03769334f, 0.13960542f, 
    -0.12428037f, 0.01509737f, 0.10869141f, 0.05712553f, -0.07216215f, -0.03270928f, 0.02121784f, 0.03058104f, 
    0.03931485f, 0.03149888f, 0.04423474f, 0.00576432f, 0.04751704f, -0.01262413f, -0.08982961f, 0.11407866f, 
    -0.03360207f, 0.07399035f, 0.03138962f, 0.07590123f, -0.06433016f, -0.00666041f, 0.00739440f, 0.06373479f, 
    -0.00143671f, -0.01267099f, 0.09874253f, -0.02755579f, 0.02826588f, -0.00986598f, -0.00547368f, 0.00891515f, 
    -0.03423168f, -0.00420207f, -0.00863823f, 0.06694757f, 0.01756448f, 0.10432085f, 0.06579317f, 0.02634508f, 
    -0.01312405f, 0.00474675f, 0.02691269f, -0.00792197f, -0.02562850f, -0.03266822f, -0.01500897f, -0.14730801f, 
    -0.04447314f, -0.06102354f, -0.12825345f, -0.00698647f, -0.00276434f, 0.00921750f, 0.04588638f, 0.01546345f, 
    0.30807561f, 0.14720187f, -0.04567627f, -0.12621048f, -0.29150629f, 0.05149023f, 0.08462051f, -0.02125499f, 
    -0.01218323f, 0.00148908f, -0.21721831f, 0.12117552f, 0.00171787f, -0.18914057f, 0.02364339f, -0.12129319f, 
    -0.03165220f, 0.04891113f, -0.09878410f, -0.22180991f, 0.33142436f, 0.03547715f, -0.13895325f, -0.16854812f, 
    -0.10446510f, -0.05210044f, -0.07443947f, 0.01435088f, -0.02599563f, -0.01880820f, 0.03131894f, 0.01436021f, 
    -0.06096902f, 0.02298374f, 0.04694572f, 0.00804357f, 0.01023751f, -0.03228065f, 0.07318012f, 0.02138007f, 
    -0.01258675f, 0.01879006f, 0.16770539f, -0.20035246f, 0.03025133f, -0.02307810f, -0.04556038f, -0.05292201f, 
    -0.03241610f, 0.01834813f, 0.02477003f, -0.01035719f, 0.07251117f, 0.01959006f, -0.04024999f, -0.03363433f, 
    -0.12874170f, -0.10981085f, 0.19024210f, -0.06746536f, 0.01312549f, 0.05622071f, -0.04248409f, -0.06821189f, 
    -0.02450969f, -0.08005495f, 0.19411829f, 0.06420752f, 0.00253203f, -0.00125340f, -0.07185952f, -0.02445844f, 
    0.05263964f, -0.03627261f, 0.00835332f, 0.02736101f, -0.05607955f, 0.00792648f, -0.14306249f, -0.00632006f, 
    0.07165364f, 0.03459058f, 0.05185986f, -0.04385972f, -0.00491552f, 0.01077375f, -0.00758630f, 0.00627430f, 
    -0.00640790f, -0.03169633f, 0.06788242f, 0.00535950f, 0.01742942f, -0.01644604f, -0.00732603f, -0.03116662f, 
    -0.07758788f, -0.02292723f, 0.06188919f, 0.02185046f, -0.09073583f, -0.22578759f, -0.07330194f, -0.16089775f, 
    -0.09888270f, -0.01537071f, -0.06678476f, 0.07387514f, 0.05543089f, 0.01812089f, -0.10083411f, -0.02023673f, 
    0.06828581f, 0.04902976f, 0.08213324f, -0.00031653f, 0.00772882f, -0.00875954f, 0.03500080f, 0.01991495f, 
    0.10337178f, -0.49025908f, -0.47731280f, 0.12516266f, -0.30060285f, 0.19769558f, 0.08740983f, -0.04128125f, 
    0.06661814f, 0.07133032f, -0.00523936f, -0.02447976f, -0.05337288f, -0.06981388f, -0.06311525f, -0.06250392f, 
    -0.01451628f, -0.03044033f, 0.04554401f, -0.03679953f, 0.04074397f, 0.09676402f, -0.10897279f, 0.08298375f, 
    -0.12611893f, -0.05973152f, 0.04955063f, 0.03814558f, -0.04344788f, 0.00447372f, -0.15196547f, -0.02874829f, 
    0.15395439f, -0.03841782f, -0.10849213f, -0.01396036f, -0.05719574f, 0.10635272f, -0.04676535f, 0.05324940f, 
    0.01252838f, 0.05424070f, -0.00573109f, -0.01432565f, -0.05009170f, 0.00760008f, -0.02360250f, 0.00064674f, 
    -0.01773115f, -0.02987823f, -0.08792272f, -0.08161052f, -0.10693257f, -0.10113522f, -0.06778515f, -0.00286386f, 
    0.02281713f, -0.01562448f, -0.00606522f, 0.01929578f, 0.12385093f, 0.18877028f, -0.06547409f, 0.04530761f, 
    -0.10915297f, 0.08202812f, 0.02269425f, 0.10738657f, -0.05379428f, -0.00589015f, -0.09700537f, 0.01690936f, 
    -0.05424398f, -0.07163892f, -0.02814024f, -0.05233756f, -0.04855980f, -0.00723093f, -0.10088748f, -0.03192137f, 
    0.38976806f, -0.45048237f, -0.18437059f, -0.10770544f, -0.31149858f, -0.00428397f, -0.12554021f, 0.03080386f, 
    0.14590229f, 0.03224594f, -0.03713566f, 0.04430320f, 0.08697625f, 0.04867292f, 0.05284553f, 0.05371716f, 
    -0.01739083f, 0.04747563f, 0.02799439f, -0.02138098f, 0.61252743f, -0.58678669f, -0.46367270f, -0.17692454f, 
    -0.07027195f, -0.00962083f, -0.05045774f, -0.31493467f, 0.12548429f, -0.20922615f, 0.00355291f, -0.01452274f, 
    0.02566742f, -0.01626937f, -0.02041924f, 0.00923991f, -0.02585296f, -0.01076750f, 0.08401224f, 0.00768140f, 
    -0.07811423f, -0.01903339f, 0.14428537f, 0.05100476f, 0.11495969f, 0.00340670f, -0.03594346f, 0.10055900f, 
    -0.08247074f, -0.03053499f, 0.00203263f, 0.01174245f, 0.02589281f, 0.01969486f, -0.03916352f, 0.10479243f, 
    0.05960191f, 0.09294189f, -0.02521730f, -0.01984064f, 0.06006728f, -0.15526752f, 0.02756084f, -0.01794917f, 
    0.05139288f, 0.01094824f, -0.03928795f, -0.04032243f, -0.08817557f, 0.02615456f, 0.04553729f, 0.02657154f, 
    -0.00899846f, 0.00841015f, -0.02759448f, -0.05012989f, -0.00531014f, -0.04655813f, 0.06820506f, 0.00159687f, 
    0.08880796f, 0.07311186f, -0.00576135f, -0.00988862f, -0.06114816f, -0.03992139f, 0.03917360f, -0.00721306f, 
    -0.05560403f, -0.04957243f, 0.03712396f, 0.01283172f, 0.02232508f, -0.01049239f, 0.01523537f, 0.05441241f, 
    -0.07561547f, 0.00201064f, 0.06388820f, 0.06206023f, -0.06345013f, -0.00404831f, -0.01004793f, 0.07081225f, 
    -0.04682425f, 0.07439607f, 0.03607077f, 0.04357154f, 0.01009612f, 0.00978056f, 0.02698393f, 0.01465733f, 
    0.01321106f, 0.00123061f, 0.00815209f, -0.03633406f, 0.00958328f, -0.03148474f, 0.06828849f, 0.05657967f, 
    -0.01406877f, 0.15016341f, -0.35214555f, 0.17028610f, -0.26479083f, -0.03628969f, 0.02579175f, 0.10291765f, 
    -0.12077857f, 0.02669165f, 0.01178663f, 0.08419523f, 0.01791957f, -0.00067141f, -0.04089509f, -0.01460478f, 
    -0.01380218f, 0.11230972f, -0.10349762f, -0.00572622f, 0.19189431f, -0.06645062f, -0.13562877f, -0.09603360f, 
    -0.05252822f, -0.02404042f, -0.07062326f, -0.01824049f, -0.02133246f, -0.07616543f, -0.00436230f, -0.03913286f, 
    -0.02768873f, 0.05296101f, 0.01825296f, 0.02664674f, 0.01067689f, -0.05380052f, 0.06711021f, 0.02090157f, 
    -0.00425333f, 0.07460729f, 0.03442603f, 0.00963093f, -0.06491801f, -0.01819816f, 0.01179512f, 0.04877411f, 
    -0.00177738f, -0.00866250f, 0.01855369f, 0.02027036f, 0.01580892f, -0.02022699f, -0.05037650f, -0.00850478f, 
    -0.08066830f, -0.00482127f, -0.00828697f, 0.04258278f, 0.06151152f, -0.40698621f, -0.39324185f, -0.21859595f, 
    -0.19018371f, 0.05257834f, 0.06253631f, -0.04690276f, 0.11493079f, 0.02153610f, 0.02348698f, -0.01113130f, 
    -0.08289673f, -0.00707437f, -0.01292719f, -0.07210268f, -0.02916871f, -0.00590251f, -0.05411911f, -0.09976591f, 
    -0.04955086f, 0.01963988f, 0.04363089f, 0.02570011f, -0.04340328f, -0.02762937f, 0.06433963f, 0.03468967f, 
    0.08018329f, 0.03552812f, -0.00838801f, 0.04424739f, 0.03336734f, 0.01075941f, 0.00664982f, 0.03782572f, 
    -0.01338215f, 0.03770880f, 0.07602017f, 0.04868897f, -0.17786622f, 0.10047855f, 0.00291000f, 0.05450571f, 
    -0.01093628f, -0.00420787f, -0.02180278f, -0.01605855f, -0.05333451f, -0.00198594f, 0.09811196f, 0.00652852f, 
    0.03780066f, -0.02072012f, 0.01211954f, 0.05689061f, -0.17232469f, -0.08353163f, -0.07072310f, 0.08756108f, 
    0.12489701f, 0.02153403f, -0.05477046f, -0.08469459f, 0.10490279f, 0.05055562f, 0.02660622f, 0.00313506f, 
    -0.01307453f, -0.00531068f, -0.02738723f, 0.07715651f, 0.04513148f, 0.01536098f, -0.05520803f, -0.01217256f, 
    0.06518514f, 0.04628872f, -0.15942207f, -0.04342044f, -0.00810471f, 0.02543863f, 0.02967922f, 0.05579665f, 
    -0.03542034f, 0.00099062f, 0.06655333f, 0.03461330f, -0.04298691f, -0.01243595f, 0.05746508f, -0.00006793f, 
    0.01187144f, -0.02220678f, 0.03617654f, 0.02458147f, -0.08237683f, -0.12130190f, -0.00962022f, 0.04055775f, 
    -0.00902977f, 0.02135800f, 0.10747996f, -0.00765038f, 0.00570757f, 0.02699941f, -0.01910104f, 0.02113314f, 
    -0.00921997f, 0.01709974f, 0.03856341f, 0.00083396f, 0.03760822f, 0.00750224f, -0.05040015f, -0.01196543f, 
    -0.07089540f, 0.01674354f, 0.07498396f, 0.03724620f, 0.20523094f, -0.01900593f, -0.12129116f, -0.09479488f, 
    -0.03740072f, 0.02353745f, 0.01871005f, -0.00051144f, 0.04992916f, 0.03755426f, -0.11211678f, -0.00373895f, 
    -0.07951300f, -0.06745821f, 0.01144332f, 0.08984160f, 0.01580894f, -0.18079491f, -0.08111269f, 0.11086662f, 
    0.13513577f, 0.20899500f, -0.44131288f, 0.15604772f, -0.23512945f, -0.00268201f, 0.10256179f, 0.03888315f, 
    -0.05843172f, -0.02387205f, -0.13362639f, -0.05794117f, 0.07350725f, 0.05550101f, -0.08459634f, -0.12337413f, 
    -0.14254254f, 0.01796379f, -0.15479079f, 0.07037545f, 0.18392882f, -0.62324625f, -0.46492517f, -0.47237670f, 
    -0.39077497f, -0.04954137f, -0.08179576f, -0.15422365f, 0.14319918f, 0.03723336f, -0.03183573f, -0.00151904f, 
    -0.03800206f, 0.06040236f, 0.01862393f, -0.08338042f, -0.01062361f, 0.01381226f, 0.02756899f, -0.00608023f, 
    0.17877796f, -0.48420072f, -0.32154599f, 0.28779399f, -0.05712299f, 0.04848485f, 0.06520110f, 0.10025506f, 
    0.04936672f, 0.12168071f, 0.03237350f, 0.03345851f, 0.06750549f, 0.00270995f, 0.02132590f, -0.02686168f, 
    0.00603003f, 0.00826436f, -0.09141023f, -0.15650545f, -0.14955837f, -0.69331515f, 0.37920216f, -0.34207913f, 
    0.06994275f, -0.19603609f, 0.04412452f, 0.08032808f, 0.20075595f, -0.02478577f, 0.06578077f, 0.02880518f, 
    -0.00427280f, 0.08582015f, 0.04598070f, -0.00844820f, -0.01500438f, -0.02540814f, 0.05011873f, -0.01762011f, 
    -0.06749927f, 0.08146469f, -0.03939519f, 0.13146897f, -0.04323032f, 0.03394656f, 0.05166095f, 0.07922801f, 
    -0.08071025f, -0.04680587f, 0.06409813f, 0.01773859f, 0.05122269f, 0.03988943f, 0.03664849f, -0.07073399f, 
    -0.07091938f, -0.08771373f, -0.14187704f, 0.08232014f, -0.50094885f, -0.25850824f, 0.02373549f, -0.08992913f, 
    0.12292923f, 0.02423694f, -0.16248234f, 0.12702873f, -0.04682694f, -0.07197304f, -0.09143121f, 0.07065581f, 
    0.00371090f, 0.01180846f, -0.01446192f, 0.00206847f, -0.04345683f, 0.02150409f, -0.12570076f, 0.02304877f, 
    -0.76689464f, -0.55153519f, 0.55293155f, -0.31377226f, 0.35926405f, 0.04200254f, -0.03376154f, 0.21796589f, 
    0.07985641f, 0.04026519f, -0.03904158f, 0.01309079f, -0.05824707f, -0.06359623f, -0.13471989f, 0.12605120f, 
    -0.00745598f, 0.10974126f, 0.04082755f, -0.10453254f, 0.24015403f, -0.55016690f, -0.41718131f, -0.37038645f, 
    -0.20424953f, -0.00545964f, 0.00458203f, -0.07669484f, 0.22388288f, 0.05804396f, 0.00594923f, 0.03436444f, 
    -0.03541744f, -0.01572528f, 0.03328900f, -0.07969407f, -0.01205907f, -0.10746003f, 0.03200281f, -0.07949395f, 
    0.18596159f, 0.05917678f, 0.05424599f, 0.12101819f, 0.01596417f, 0.00836460f, 0.07045981f, -0.12507515f, 
    0.04548148f, -0.02335430f, -0.04536817f, 0.00231353f, -0.01318046f, -0.00925236f, -0.00031882f, -0.00882834f, 
    0.08100967f, -0.12136177f, 0.12740757f, 0.08742881f, 0.01702995f, -0.48779008f, 0.12168745f, 0.42190877f, 
    0.06019470f, 0.00130461f, 0.19687195f, 0.03788361f, 0.14509735f, 0.21994376f, 0.05145013f, -0.01883307f, 
    0.00659794f, -0.01560031f, -0.05209279f, 0.00733108f, -0.00602490f, -0.07797912f, 0.18165658f, -0.01727036f, 
    -0.01010084f, 0.03269685f, 0.05715590f, 0.04255269f, -0.02015815f, -0.00886197f, 0.01294849f, 0.05911604f, 
    -0.05149875f, -0.03169417f, 0.00506769f, 0.00535508f, 0.00558047f, -0.00078040f, -0.06231017f, -0.18179362f, 
    -0.17415620f, 0.05307585f, -0.00363897f, 0.03301075f, 0.05064992f, 0.06376717f, 0.03296626f, 0.01579306f, 
    -0.07037532f, 0.02316544f, 0.02456570f, -0.01942826f, -0.00842710f, -0.03200039f, 0.02869592f, -0.01449098f, 
    0.03052108f, -0.04203065f, -0.01908282f, -0.09202109f, -0.01182675f, 0.03652930f, 0.02826962f, 0.00867415f, 
    -0.12538011f, -0.00420254f, 0.06353355f, -0.02571931f, 0.03221168f, -0.02627386f, -0.03352053f, 0.01759002f, 
    -0.03056554f, 0.06769060f, 0.02410109f, -0.01601178f, 0.09361690f, 0.02709322f, -0.04085842f, 0.00941124f, 
    -0.03724403f, -0.09899474f, -0.01846003f, 0.02760674f, 0.04970974f, 0.08812672f, 0.08121869f, 0.01342259f, 
    0.02261686f, -0.00349849f, 0.02248539f, -0.01957473f, 0.00653690f, -0.02398893f, -0.02861957f, -0.01570261f, 
    -0.03178364f, -0.05099682f, -0.08708038f, -0.13804208f, -0.00116632f, 0.02320767f, 0.00270309f, 0.00766360f, 
    0.55019683f, 0.34524477f, -0.43211403f, 0.06897315f, -0.35177070f, -0.03193131f, 0.00528203f, 0.13129537f, 
    -0.07828414f, 0.01938924f, -0.04315566f, -0.07464506f, -0.13801605f, -0.02042049f, -0.07246729f, 0.03906023f, 
    -0.05150562f, 0.00415045f, 0.00863136f, 0.06468771f, 0.03109357f, 0.07268537f, -0.09379556f, -0.01764718f, 
    -0.07748746f, 0.05466060f, 0.00630176f, 0.04647831f, -0.03165609f, -0.07003637f, -0.09392898f, -0.09028542f, 
    -0.00793028f, 0.04505333f, -0.03501913f, 0.03226770f, 0.00007773f, 0.00977617f, -0.03249068f, -0.04888407f, 
    -0.04193233f, -0.01176147f, -0.12593186f, -0.10653733f, -0.14266364f, -0.03200236f, -0.00256440f, 0.00108264f, 
    0.04482026f, -0.02957636f, 0.08526292f, 0.00091105f, 0.08008356f, 0.01711276f, -0.00106722f, -0.02651137f, 
    -0.02119123f, -0.00523786f, 0.03278198f, 0.07245248f, -0.26889345f, -0.06395473f, 0.14425947f, 0.08023419f, 
    -0.16821913f, 0.07162037f, 0.03569329f, -0.09833857f, 0.09040649f, 0.01454182f, 0.00734122f, 0.03323756f, 
    0.02289558f, 0.00542912f, -0.01224803f, 0.01294651f, 0.04877740f, 0.07236454f, 0.06008882f, -0.00034830f, 
    -0.02789875f, -0.12636642f, -0.00560369f, -0.02654245f, -0.06341459f, -0.08579020f, -0.00584636f, 0.04198091f, 
    0.04593670f, -0.00992011f, 0.00877771f, 0.09616572f, 0.04800342f, 0.01328821f, 0.06751389f, -0.05156277f, 
    0.04480344f, -0.00948489f, 0.06941129f, 0.08552332f, 0.21285799f, -0.04295120f, -0.06667243f, -0.02487617f, 
    -0.00682784f, -0.03156754f, -0.02502488f, -0.07972267f, -0.04965261f, -0.00354354f, 0.03535276f, 0.04679298f, 
    0.06684016f, 0.00787473f, 0.03928439f, 0.00222866f, 0.05066966f, 0.07880913f, 0.01807391f, 0.13595451f, 
    0.50627089f, -0.08166297f, -0.09923838f, -0.04256200f, -0.17938675f, -0.07287766f, -0.14621168f, -0.13649377f, 
    -0.12470227f, -0.06983668f, -0.01166187f, 0.13301972f, 0.00592460f, -0.04908048f, -0.00514077f, -0.02872314f, 
    0.09861507f, 0.07877499f, 0.11789599f, 0.18511219f, 0.19318059f, -0.20265040f, -0.02245095f, 0.17243324f, 
    -0.02978401f, 0.04382236f, 0.14387913f, -0.03798565f, -0.09184980f, 0.14993553f, 0.07941028f, 0.05704354f, 
    -0.04751131f, 0.14719038f, 0.12554929f, 0.19246787f, 0.01554783f, 0.06605209f, -0.04974022f, 0.08280859f, 
    0.46089748f, 0.22723697f, 0.01119380f, -0.07266273f, -0.07486916f, -0.00641792f, 0.07187311f, -0.01800035f, 
    0.11487276f, -0.22100520f, 0.04183673f, 0.06260953f, 0.03970354f, -0.01395049f, 0.04033481f, -0.01023927f, 
    0.07803065f, -0.09703583f, 0.13784631f, 0.07029618f, 0.27765775f, -0.19605321f, -0.18194042f, 0.06478766f, 
    -0.01731994f, -0.12051810f, 0.01974082f, -0.03857530f, -0.09263371f, 0.04616493f, -0.00753692f, 0.06099550f, 
    -0.02013430f, -0.04642915f, -0.02208832f, -0.03188333f, 0.06162659f, 0.06659964f, 0.12073100f, 0.10337997f, 
    -0.00063378f, -0.48735183f, -0.51047790f, -0.04323937f, 0.08804899f, -0.04573752f, 0.11363797f, 0.12627371f, 
    0.09273218f, 0.09841977f, 0.02215683f, -0.09637977f, -0.05027417f, -0.05306251f, -0.02739345f, -0.00696346f, 
    0.05345818f, 0.01946922f, 0.03572347f, -0.03093389f, 0.09787019f, -0.16314924f, -0.05759284f, -0.13521028f, 
    -0.08741371f, -0.09448957f, -0.05236457f, -0.16136566f, -0.09507597f, -0.32385269f, 0.00001512f, -0.00413603f, 
    0.01205353f, 0.05104583f, 0.03236467f, 0.08325210f, 0.03391703f, 0.02592772f, -0.07344164f, -0.21879046f, 
    -0.12469761f, -0.34382272f, -0.05864957f, 0.03716183f, 0.13806571f, 0.00830076f, 0.10222092f, 0.08384856f, 
    -0.00561446f, 0.02680966f, 0.06774014f, 0.07311947f, -0.01121807f, 0.14213665f, -0.02362068f, 0.01004497f, 
    -0.02264167f, 0.04294766f, 0.01959092f, 0.00568808f, -0.08986704f, 0.15682800f, 0.05820662f, 0.04210652f, 
    -0.05330753f, -0.00130890f, -0.02722193f, -0.03852713f, 0.06319726f, -0.05614323f, -0.05956497f, 0.01689016f, 
    0.05156648f, -0.05461792f, 0.06398143f, -0.02781487f, 0.07537404f, 0.00911573f, -0.00348703f, 0.08114333f, 
    -0.31553900f, -0.42161143f, -0.10491282f, 0.02252954f, 0.14379834f, 0.09422783f, 0.03605582f, 0.06657975f, 
    -0.03075317f, 0.10456863f, 0.13539691f, 0.06606520f, 0.01640941f, 0.07818781f, -0.00217835f, -0.07625487f, 
    0.04683267f, -0.00101937f, -0.02473746f, -0.02400606f, 0.24186277f, -0.16651364f, -0.14787871f, -0.09340719f, 
    0.02384763f, 0.01142072f, 0.14223240f, 0.03591220f, 0.03349460f, -0.01516892f, -0.00928204f, -0.04459757f, 
    0.04984310f, 0.11109624f, -0.00092062f, -0.00693196f, -0.06856877f, -0.02339881f, 0.11384640f, -0.01266778f, 
    0.12815414f, -0.25481009f, -0.27738959f, -0.12270597f, -0.19948053f, -0.01196644f, 0.12688719f, 0.07640732f, 
    0.13008919f, 0.08634679f, 0.12847449f, -0.07931918f, -0.07381854f, -0.01497906f, -0.02357337f, 0.01934144f, 
    0.04367397f, -0.03962920f, 0.05878977f, -0.07619350f, -0.01443785f, -0.20221391f, -0.16822289f, -0.06557651f, 
    0.02285412f, -0.04781249f, -0.03008416f, 0.02315684f, 0.02498671f, 0.07623622f, 0.00632255f, 0.02936591f, 
    -0.02662709f, -0.07587482f, -0.00223969f, -0.00436509f, 0.06605706f, 0.05364199f, 0.02853658f, 0.03326278f, 
    -0.21873987f, -0.01778249f, 0.07675098f, 0.01668514f, -0.07660300f, 0.00815390f, -0.05067378f, -0.02001673f, 
    -0.02682060f, -0.01719487f, -0.04252120f, -0.03544370f, 0.00793156f, -0.01350227f, -0.04298397f, 0.02554690f, 
    0.01524373f, 0.10297513f, -0.03955490f, -0.00145003f, 0.53724349f, -0.31321418f, -0.32391590f, -0.03733643f, 
    -0.07737915f, 0.07261755f, -0.00147130f, -0.09520684f, 0.09484044f, -0.02465631f, 0.02644918f, 0.01311503f, 
    0.02169625f, -0.03534040f, 0.03533144f, -0.01132015f, 0.07880913f, 0.02291887f, 0.04939689f, 0.05510424f, 
    0.32777885f, 0.03334985f, 0.17521127f, 0.15679719f, -0.05874175f, -0.11986618f, -0.03084733f, -0.16154252f, 
    0.00316534f, -0.00440080f, 0.00761012f, -0.05818490f, 0.04172904f, -0.02663534f, 0.01717733f, -0.05747650f, 
    -0.15473352f, -0.12172223f, -0.35445532f, -0.21138111f, -0.37147495f, 0.05710695f, 0.22678597f, 0.17871942f, 
    0.09238804f, -0.00566217f, -0.01315358f, -0.04927085f, -0.04598416f, -0.03276592f, -0.06635712f, -0.03767221f, 
    0.01661438f, -0.03009131f, -0.04098530f, -0.08777428f, -0.14356861f, -0.11528919f, -0.15840374f, -0.15514410f, 
    -0.34075159f, -0.10391573f, 0.11344798f, 0.00787113f, -0.14461942f, -0.08958994f, -0.00499923f, -0.05146185f, 
    -0.08749795f, 0.00214550f, -0.06917308f, -0.03070969f, -0.01833693f, 0.09083936f, 0.01261743f, 0.00964560f, 
    0.05840486f, 0.03302893f, 0.00584858f, 0.01279813f, -0.15100150f, -0.04188393f, 0.02665907f, -0.05305716f, 
    -0.10022213f, -0.06055675f, -0.05871551f, -0.05847803f, -0.04550016f, -0.05637467f, 0.02346708f, 0.00380983f, 
    0.04441366f, 0.08912090f, 0.06693516f, -0.02983804f, 0.00113790f, 0.04817635f, 0.05813301f, 0.06532692f, 
    0.37968665f, 0.09775218f, -0.05186879f, -0.19941038f, -0.20255747f, 0.07276072f, 0.02253409f, -0.10501152f, 
    -0.00577655f, -0.20029022f, 0.02242584f, 0.10319740f, -0.06062463f, 0.10634568f, 0.02900845f, -0.12551372f, 
    -0.09867503f, -0.05961915f, -0.04215996f, 0.09676041f, -0.02965333f, -0.29665712f, -0.22394076f, -0.12678652f, 
    0.04142755f, -0.02407630f, 0.07835954f, 0.08340158f, 0.07384513f, 0.03669627f, 0.02018075f, -0.02652927f, 
    -0.00348318f, -0.03528440f, -0.04195102f, 0.00874253f, 0.02237550f, -0.01296936f, 0.01870423f, 0.00828732f, 
    -0.34168333f, -0.05473429f, 0.11555420f, 0.09107254f, 0.00926612f, 0.06924085f, -0.07570491f, 0.01550972f, 
    0.06615835f, -0.07956933f, -0.01317895f, -0.03619344f, -0.02068780f, -0.08945011f, -0.04908326f, -0.11187875f, 
    0.06771745f, 0.02795521f, -0.16491626f, 0.13313779f, 0.01886121f, -0.08781009f, -0.11292881f, 0.01074769f, 
    -0.12656859f, -0.06071721f, 0.03674214f, 0.03846272f, 0.01498230f, 0.07426724f, 0.10240943f, 0.02465471f, 
    -0.07187335f, 0.01818931f, 0.03859213f, 0.03790353f, 0.19405593f, 0.13901511f, 0.12584929f, 0.07303856f, 
    -0.08805778f, 0.04489237f, 0.01468493f, 0.00327796f, -0.13090982f, -0.01784353f, -0.05671688f, -0.05014665f, 
    -0.00336651f, 0.01006947f, -0.02926564f, -0.08884787f, -0.05876422f, -0.03387403f, 0.01646400f, -0.00964193f, 
    0.06380717f, 0.02598150f, -0.02141824f, 0.02685376f, -0.10425511f, -0.24819517f, -0.17357659f, -0.01828649f, 
    0.10397722f, -0.05501408f, 0.03784240f, 0.03613981f, 0.02590596f, 0.11684734f, 0.01884425f, -0.01075510f, 
    -0.06062310f, -0.08152482f, -0.06635009f, -0.05155980f, 0.03359840f, 0.04043468f, 0.04069076f, 0.02174461f, 
    0.17042366f, -0.36193484f, -0.42692539f, -0.32491043f, 0.00032254f, -0.01837539f, -0.08607084f, -0.10860000f, 
    0.04512274f, -0.22816011f, 0.02787520f, -0.02600580f, -0.01089620f, 0.03699053f, -0.02457862f, 0.08885588f, 
    0.01584477f, 0.01605469f, -0.02599453f, -0.01012025f, -0.03450669f, -0.01285440f, -0.02343727f, -0.02685942f, 
    -0.17836218f, -0.03106632f, 0.00586078f, -0.02501024f, -0.02620198f, -0.06831016f, 0.03183654f, -0.00826341f, 
    -0.07178624f, 0.03473585f, 0.06129637f, -0.02450186f, 0.18838121f, 0.02264604f, 0.14459769f, 0.05497693f, 
    -0.10997427f, -0.05738687f, 0.06925269f, -0.04538020f, -0.02128723f, -0.04589190f, 0.04503683f, 0.02161087f, 
    0.00911593f, -0.05006030f, 0.05038479f, 0.10037073f, 0.07149483f, 0.02598121f, 0.04572980f, 0.00711924f, 
    0.01208140f, -0.00941697f, 0.08459871f, 0.02474486f, 0.17607808f, 0.06782694f, -0.05890308f, -0.11424223f, 
    -0.05377870f, 0.01471190f, 0.13223085f, -0.03939066f, -0.01666039f, -0.12211403f, 0.05234763f, -0.01585158f, 
    0.05017695f, 0.06288461f, 0.07795159f, -0.00699051f, 0.03753394f, 0.03267068f, 0.11528627f, 0.01796607f, 
    -0.11480772f, -0.41601434f, -0.35475546f, -0.16182216f, 0.01607348f, -0.05650942f, 0.12013931f, 0.10372827f, 
    0.05927370f, 0.04298581f, 0.04957941f, -0.09524750f, -0.05891803f, -0.04292539f, -0.06408662f, -0.01516491f, 
    -0.01959598f, -0.00505467f, 0.01494800f, -0.04190544f, -0.04867058f, -0.72970867f, -0.82114077f, -0.35094786f, 
    0.04077256f, -0.01440588f, 0.04276540f, 0.16807891f, 0.02992016f, 0.02662338f, 0.05635249f, 0.00091725f, 
    -0.06030385f, 0.04400297f, -0.04581910f, 0.02762566f, 0.00449082f, -0.02293945f, -0.02527650f, -0.04379256f, 
    -0.02130002f, -0.20740657f, 0.13720886f, 0.09267756f, 0.15585113f, 0.03311092f, -0.02963613f, 0.05016860f, 
    -0.01300766f, 0.01991410f, 0.07203835f, 0.01633215f, 0.01530372f, -0.00409283f, -0.02397984f, -0.15776765f, 
    -0.11502968f, -0.09378368f, -0.15325093f, -0.18684466f, 0.39539656f, 0.13102911f, -0.04122586f, 0.07106356f, 
    -0.09726597f, 0.10556418f, -0.02275415f, -0.07465257f, 0.04250250f, 0.06247488f, 0.08344793f, 0.02071397f, 
    0.03489958f, -0.00252209f, 0.01476616f, -0.10412718f, 0.08651712f, 0.01048322f, 0.03664888f, 0.02623309f, 
    -0.07018600f, 0.08649881f, 0.04252865f, -0.08268023f, -0.08948410f, -0.04904586f, -0.01789141f, -0.08026705f, 
    0.01717373f, 0.02329058f, 0.06603662f, -0.04954507f, -0.00249999f, 0.03780621f, 0.05920306f, -0.03627957f, 
    0.04921206f, 0.05643198f, 0.01627356f, -0.03376094f, -0.06886741f, 0.06421144f, 0.00786602f, -0.01173834f, 
    -0.11391151f, 0.04648491f, -0.08054651f, -0.12608822f, -0.05857136f, -0.11939172f, -0.07131700f, -0.02581907f, 
    0.02480933f, -0.01423325f, 0.00754351f, -0.05374644f, 0.04946150f, 0.12686472f, 0.11108911f, 0.06406326f, 
    0.48043180f, 0.25690570f, 0.05794170f, -0.04398300f, -0.21947557f, 0.07876404f, -0.01277301f, 0.00068435f, 
    0.00168297f, -0.22211863f, -0.01590776f, 0.04800308f, 0.05002722f, -0.01148215f, 0.03667693f, 0.00239752f, 
    0.09265480f, -0.00411926f, 0.13172281f, 0.07301638f, 0.01303445f, -0.13104548f, -0.22185577f, -0.01658045f, 
    0.01121841f, -0.06053800f, 0.03823567f, 0.11560050f, 0.09581633f, 0.06573830f, 0.08716801f, -0.03384649f, 
    0.03333102f, 0.00346576f, -0.00651817f, -0.00729554f, -0.00445530f, 0.04461321f, -0.01778157f, -0.02164330f, 
    -0.13309388f, 0.02836721f, 0.02979276f, 0.05505693f, -0.14439090f, -0.06359725f, -0.01894562f, -0.04010016f, 
    0.00482611f, -0.01943328f, -0.07598184f, 0.01732479f, -0.01473145f, -0.00902664f, 0.04846374f, 0.02459678f, 
    0.10979664f, 0.02261819f, 0.05394552f, 0.09350735f, 0.00819896f, -0.35772368f, -0.47831458f, -0.25781861f, 
    0.09485145f, -0.05997089f, 0.10702485f, 0.00569669f, 0.04177035f, -0.04201695f, 0.04584701f, -0.00563609f, 
    -0.03766000f, 0.08135754f, -0.01149907f, 0.09837401f, -0.03594242f, 0.03154867f, -0.03063749f, 0.05000307f, 
    -0.04000177f, -0.08037644f, -0.01095135f, -0.02805995f, -0.16688035f, -0.04552666f, -0.09113507f, -0.06583516f, 
    -0.02062630f, -0.06956681f, -0.01833568f, 0.06624803f, 0.03902700f, 0.00847226f, 0.04767153f, 0.02602274f, 
    0.09501844f, 0.14400148f, 0.10169800f, 0.15481657f, -0.45232597f, -0.05575855f, 0.12013196f, 0.15870941f, 
    0.00080246f, 0.00415675f, 0.08782402f, -0.06582566f, 0.06028666f, 0.00171630f, -0.05705439f, -0.00367734f, 
    0.04533288f, -0.00579166f, -0.03349379f, 0.01961347f, -0.03464977f, 0.00026921f, 0.07196501f, 0.06341968f, 
    0.22309317f, 0.10089503f, 0.06425534f, 0.01157830f, -0.05170558f, 0.03370249f, -0.06373405f, -0.01565980f, 
    0.03167544f, -0.04113391f, -0.06158692f, 0.00646904f, -0.04496133f, 0.03384418f, -0.00511022f, 0.00216290f, 
    -0.10373545f, -0.08893204f, -0.05149181f, -0.02720165f, -0.17300744f, 0.07274319f, 0.13345639f, 0.03881670f, 
    0.03842564f, -0.07690049f, -0.02180457f, -0.07042370f, -0.00297951f, -0.05481433f, -0.11077308f, 0.00158992f, 
    0.02974169f, -0.04079932f, 0.04291557f, -0.02379506f, 0.02112645f, -0.06014726f, -0.02334135f, -0.06346767f, 
    -0.11964267f, -0.04726500f, 0.01805420f, 0.00519297f, -0.09820779f, -0.05439947f, -0.02749836f, -0.09809577f, 
    -0.05188806f, 0.00119146f, -0.03996013f, -0.04215680f, -0.01511953f, -0.03817399f, 0.05510367f, 0.00800746f, 
    0.11189903f, 0.06647776f, 0.03066433f, 0.03960264f, 0.03565550f, 0.07351329f, 0.03482770f, 0.04308902f, 
    -0.17635676f, -0.01880769f, -0.08299001f, -0.05788753f, -0.02468692f, -0.07440034f, 0.02615445f, 0.06051377f, 
    -0.06723401f, 0.08833850f, -0.01200058f, -0.07386622f, -0.14265317f, -0.03809980f, -0.27308699f, -0.24585366f, 
    0.24846439f, 0.08736477f, -0.06517644f, -0.08733790f, -0.05376369f, 0.03950159f, 0.05945266f, -0.01564820f, 
    0.04234783f, 0.00370274f, -0.02118564f, 0.04318502f, -0.01426223f, 0.03356684f, -0.02988769f, 0.14209794f, 
    0.00328819f, -0.01347607f, 0.08060221f, -0.15567464f, 0.06713808f, -0.12218568f, -0.49576664f, -0.17117795f, 
    0.08737821f, -0.02608844f, 0.13184531f, 0.14355247f, 0.09360856f, -0.10183905f, -0.06044889f, -0.03640881f, 
    -0.03547194f, 0.09040788f, 0.11047968f, 0.06567369f, -0.01806994f, 0.04059722f, -0.10391586f, -0.10130193f, 
    0.09518062f, -0.22186016f, -0.37697861f, -0.19394308f, 0.01962042f, 0.04644679f, -0.01735482f, 0.01392640f, 
    0.05121445f, 0.06238626f, -0.01691040f, -0.00061623f, 0.01649927f, 0.00982996f, 0.01410599f, 0.01517322f, 
    0.05028412f, 0.01735612f, 0.06699008f, 0.06816179f, -0.07765635f, -0.40577388f, -0.54366636f, 0.01299243f, 
    0.22207855f, 0.13750015f, 0.00180695f, 0.09895351f, 0.04650000f, 0.12974404f, 0.11616802f, -0.05216279f, 
    -0.02590533f, -0.02125911f, -0.05987488f, -0.08676368f, 0.09484670f, -0.00609125f, -0.15823363f, 0.05593893f, 
    -0.43433285f, -0.10147581f, 0.19484735f, 0.07717153f, 0.08857246f, -0.08568463f, 0.01098067f, -0.10337259f, 
    -0.02166804f, -0.02568936f, -0.13807045f, -0.02892894f, 0.05585230f, -0.02853587f, -0.02581037f, -0.05132872f, 
    -0.02662797f, -0.03995180f, 0.01973639f, -0.03016303f, -0.08962383f, -0.51885420f, -0.02094800f, 0.01011126f, 
    0.35582173f, 0.02773701f, 0.25079381f, 0.06204948f, 0.02152247f, 0.03916197f, 0.04048496f, 0.02157392f, 
    0.04240447f, 0.16476415f, -0.04601449f, -0.00883937f, 0.05091456f, -0.01184255f, 0.08417118f, 0.01185491f, 
    0.25691754f, -0.57326198f, -0.38794902f, -0.22844933f, 0.08146916f, -0.02251471f, -0.02737477f, -0.06344479f, 
    -0.22942422f, -0.18637182f, 0.00718641f, -0.02574492f, 0.00580026f, 0.02068576f, 0.11326910f, 0.05120803f, 
    -0.00140428f, 0.08270361f, -0.09157176f, -0.23734091f, -0.11134861f, -0.17717761f, -0.56723452f, -0.32791260f, 
    0.01765741f, 0.03524790f, 0.00834061f, 0.14343221f, 0.07075080f, -0.03340198f, -0.01588532f, -0.06250867f, 
    -0.01364146f, 0.05173945f, 0.04446644f, 0.08036398f, 0.02084213f, 0.05330677f, -0.02132742f, 0.00570246f, 
    0.25339347f, 0.28967434f, -0.13710880f, -0.07194424f, -0.20014735f, 0.01400654f, -0.04459701f, 0.00793073f, 
    0.06078976f, 0.00951485f, 0.03402432f, 0.06188121f, 0.03487921f, 0.03782238f, 0.02073899f, -0.17431284f, 
    -0.13264334f, -0.20384605f, -0.10198224f, -0.37776327f, -0.03645017f, -0.58785039f, -0.45167550f, -0.24551524f, 
    -0.29666230f, -0.01088961f, -0.18011777f, -0.05971699f, -0.02909782f, -0.14048728f, -0.04264008f, 0.02599427f, 
    -0.01591586f, 0.00030275f, -0.00687899f, 0.02484323f, 0.03250887f, 0.05576158f, 0.09688158f, 0.16169702f, 
    -0.08834486f, -0.03229496f, 0.00528652f, 0.03022672f, -0.03364380f, -0.00450032f, -0.00190094f, -0.04305619f, 
    -0.00830607f, 0.06801624f, -0.01893552f, -0.00365847f, 0.00343991f, -0.04694965f, 0.06384858f, 0.05670802f, 
    0.07041369f, 0.01214513f, -0.02908675f, 0.09380671f, -0.17281902f, 0.06210221f, 0.00641560f, -0.00272888f, 
    -0.09153100f, -0.06184785f, -0.02082967f, 0.00515658f, -0.00039632f, -0.00794733f, -0.03819045f, 0.01514184f, 
    -0.03858322f, 0.03097167f, 0.03711591f, 0.08730736f, 0.06093204f, 0.03947368f, 0.01793717f, 0.04306810f, 
    -0.26346174f, -0.08916816f, 0.04830972f, 0.07519226f, 0.00652863f, -0.01188221f, -0.01465809f, -0.03457535f, 
    0.03722210f, 0.00100572f, 0.00835649f, 0.00576436f, 0.06938305f, 0.00503875f, 0.02230473f, -0.09533007f, 
    0.05675697f, 0.09699515f, 0.12568013f, 0.10348792f, -0.04042182f, -0.09548832f, -0.01403915f, 0.00264513f, 
    -0.05491680f, -0.01214733f, 0.00835136f, -0.01874010f, -0.02773431f, -0.00026581f, -0.00966590f, 0.00867694f, 
    0.02280001f, 0.09477700f, 0.06905581f, 0.08306892f, 0.03588588f, 0.03199297f, 0.01498043f, 0.03998238f, 
    0.21725588f, -0.48854759f, -0.11349112f, -0.09215065f, 0.07440318f, -0.12168141f, 0.14274633f, -0.04786360f, 
    0.11573941f, -0.07093566f, 0.01105955f, 0.13557497f, 0.08564954f, -0.08813642f, -0.03828989f, 0.00608159f, 
    -0.00358629f, -0.14062247f, 0.00629139f, -0.11833075f, 0.00034818f, -0.01951218f, -0.09009009f, -0.04812265f, 
    -0.07852829f, -0.07450571f, 0.00280977f, -0.03973521f, -0.05038680f, -0.01710172f, 0.06088156f, 0.01343646f, 
    0.06599395f, -0.00951286f, 0.06279100f, 0.03040911f, 0.05830447f, 0.04026714f, 0.10412477f, 0.03311575f, 
    -0.16957621f, 0.14202437f, 0.08986063f, 0.32895598f, 0.16967244f, -0.06547173f, 0.02155000f, -0.16660452f, 
    -0.02621000f, -0.04259484f, 0.06634581f, -0.05365422f, 0.05367298f, -0.11317845f, 0.05739417f, 0.05923519f, 
    0.00640353f, -0.04472284f, 0.01898353f, 0.08373701f, -0.02875984f, 0.27269343f, -0.32261056f, -0.01416471f, 
    -0.16508746f, 0.11294708f, 0.03793044f, 0.12318932f, -0.02588597f, 0.11448371f, -0.01397770f, -0.03231020f, 
    -0.06794992f, -0.05502235f, -0.07114644f, 0.00648072f, 0.02127885f, -0.05471336f, -0.01632651f, -0.09389814f, 
    -0.10379548f, 0.12036531f, 0.12403198f, -0.03108899f, 0.16309814f, -0.03688240f, 0.12749857f, -0.06531000f, 
    -0.16946749f, 0.04198416f, 0.03351394f, 0.10517486f, 0.04606885f, -0.01963673f, 0.08016126f, 0.01959264f, 
    0.09668961f, -0.04905046f, -0.02761208f, 0.02274883f, 0.03944695f, -0.02102626f, -0.01475568f, -0.01226008f, 
    -0.00597382f, 0.11583238f, 0.07018916f, -0.06671017f, 0.03465693f, -0.03310114f, 0.08181956f, 0.02288510f, 
    -0.02968453f, -0.03168816f, 0.00889886f, -0.02091915f, -0.00890877f, -0.07514010f, -0.10548974f, 0.00220532f, 
    0.13886227f, 0.18219228f, -0.07137308f, 0.07660868f, -0.18378448f, -0.01173560f, 0.10866309f, 0.02621503f, 
    0.02891096f, -0.02179559f, 0.05130438f, -0.12592250f, 0.00154187f, -0.09202980f, -0.03649388f, 0.00972527f, 
    -0.01695999f, -0.09639491f, -0.08830563f, -0.15446264f, 0.00951930f, -0.21168800f, -0.06463025f, -0.26400334f, 
    0.02066764f, -0.02536941f, 0.18527645f, -0.12034944f, -0.09048553f, 0.06513526f, 0.12748532f, -0.07166871f, 
    -0.07829670f, -0.06540868f, -0.03838912f, -0.20350447f, 0.02182158f, 0.00790250f, -0.14739542f, -0.05444052f, 
    -0.71467400f, 0.40513036f, -0.68194002f, -0.21231735f, 0.04809314f, -0.04988217f, -0.05628468f, 0.05942337f, 
    -0.35309464f, 0.14620209f, 0.01992083f, -0.03592608f, -0.05609861f, 0.03024202f, -0.01715697f, 0.06465491f, 
    0.05494420f, -0.05001333f, -0.02271532f, -0.06731175f, 0.08948442f, 0.15960607f, 0.29387155f, -0.25461203f, 
    -0.06003755f, 0.01003521f, -0.10757788f, -0.02206318f, -0.00003066f, -0.00430329f, 0.07928868f, -0.05752261f, 
    0.08391178f, -0.02100186f, -0.09054373f, 0.01543278f, 0.01606268f, -0.15021037f, -0.13919270f, 0.01636379f, 
    0.00928839f, 0.10802934f, -0.07275043f, 0.18534996f, -0.14613280f, -0.16399081f, -0.15985683f, -0.32785970f, 
    -0.01288102f, -0.10712466f, -0.00257083f, -0.04137052f, 0.03476465f, 0.01970239f, 0.00955785f, -0.01286682f, 
    -0.00658188f, 0.09282134f, -0.03863857f, -0.08763463f, -0.08506760f, -0.19534118f, -0.26544264f, -0.16551082f, 
    0.05744642f, 0.08465859f, -0.12262863f, -0.06788071f, 0.04496853f, 0.14570068f, 0.02427930f, 0.01741547f, 
    0.01015509f, 0.02088086f, -0.03531412f, -0.00886651f, 0.07520116f, 0.16062431f, 0.05737490f, 0.14813602f, 
    0.04469933f, -0.04675765f, 0.08380588f, 0.01769460f, -0.15239558f, -0.02593993f, -0.15092236f, -0.04186672f, 
    0.06709850f, -0.10670596f, -0.04430497f, 0.02701077f, 0.01242222f, 0.11153164f, 0.01267350f, 0.08851681f, 
    -0.04139898f, 0.00653045f, -0.00152798f, 0.02311739f, 0.00429986f, -0.06055264f, -0.19187216f, -0.08516026f, 
    0.09351154f, 0.02963354f, 0.15103900f, 0.18730864f, 0.05473883f, 0.03394567f, 0.02948685f, 0.03625900f, 
    -0.03231318f, -0.03608579f, -0.02953457f, 0.00727930f, 0.02947300f, -0.00330361f, -0.04018065f, 0.01234612f, 
    -0.11824042f, -0.49940354f, 0.29575378f, -0.27170816f, -0.32960156f, 0.04493404f, -0.25580388f, -0.16510411f, 
    0.12742659f, -0.08258086f, -0.10900696f, 0.02216619f, 0.07501187f, -0.13239096f, 0.05140232f, 0.08331144f, 
    -0.00751497f, -0.00608284f, -0.08433629f, 0.04396152f, -0.60400754f, 0.05243739f, 0.03095868f, 0.52823842f, 
    -0.33055586f, 0.12395823f, -0.09067735f, -0.01545575f, -0.31674802f, -0.26158968f, -0.00092908f, 0.13530742f, 
    -0.03226614f, -0.11292117f, 0.10428957f, -0.11053605f, -0.09267643f, -0.14999035f, 0.07302247f, 0.09844036f, 
    -0.42133236f, 0.26973236f, -0.19378525f, 0.39738658f, -0.25760502f, 0.09989878f, -0.18296860f, -0.21093187f, 
    -0.15685840f, -0.24869509f, 0.04290917f, -0.02399161f, -0.04249230f, -0.02453219f, 0.00086742f, 0.05824542f, 
    -0.09012043f, -0.05314435f, 0.00675225f, -0.02174108f, 0.02466401f, 0.19443256f, 0.22728634f, -0.05122763f, 
    -0.04247377f, -0.03707305f, 0.06714872f, -0.16302148f, -0.09305473f, -0.01187971f, -0.00635376f, 0.01181612f, 
    0.07285438f, 0.05342630f, 0.03344888f, -0.00804313f, -0.05499814f, -0.02710079f, -0.03533968f, -0.07858773f, 
    -0.15035759f, 0.03707943f, -0.12933962f, -0.03933722f, 0.02812214f, 0.10881305f, -0.08019178f, 0.12362365f, 
    -0.00298343f, -0.02010560f, 0.05545641f, 0.00458769f, -0.00600947f, 0.04963154f, 0.00490448f, -0.02187657f, 
    0.01575524f, 0.04347369f, -0.00889458f, 0.06350750f, -0.18881714f, -0.14450006f, 0.14647810f, -0.12810388f, 
    -0.13867371f, -0.03270288f, -0.21565638f, 0.15306814f, -0.01351488f, 0.10308571f, -0.05071442f, 0.03368073f, 
    0.01922212f, -0.05073636f, -0.08518631f, 0.04243758f, 0.05172774f, -0.01002336f, -0.02539941f, -0.01055324f, 
    -0.14923716f, -0.25515544f, 0.05828260f, -0.12164126f, 0.15541913f, -0.03017022f, 0.07243558f, -0.11765172f, 
    0.09678820f, -0.00202697f, 0.04129776f, -0.06402681f, 0.12558921f, -0.03352300f, -0.02217023f, -0.06502421f, 
    0.08691891f, -0.02508972f, 0.03777853f, 0.07298505f, -0.22269164f, -0.09396698f, -0.44079202f, -0.07108823f, 
    0.19686036f, 0.03904263f, -0.02069098f, 0.14546376f, 0.03494602f, -0.06116709f, -0.04351414f, 0.03286474f, 
    -0.09568378f, 0.04009751f, 0.03984898f, 0.02138006f, 0.14295027f, 0.03068250f, -0.04772062f, 0.09088102f, 
    -0.14131390f, -0.04421560f, -0.01427432f, -0.34077483f, 0.06550126f, 0.00080828f, 0.03376492f, 0.04468630f, 
    0.12202600f, -0.03367944f, 0.08881834f, -0.01983366f, 0.09431928f, -0.05781810f, 0.01732995f, 0.14055817f, 
    0.11532826f, -0.11543492f, 0.01852171f, 0.07822067f, -0.04967049f, 0.04342042f, 0.11046996f, -0.06998391f, 
    0.08299721f, -0.00961406f, 0.00354749f, 0.03695932f, 0.04365921f, -0.01436637f, 0.17622826f, 0.09030547f, 
    0.07333027f, 0.08675494f, -0.00916167f, 0.10609497f, 0.05542499f, 0.03284989f, 0.02104065f, 0.06779796f, 
    -0.82219517f, -0.17852321f, -0.38699368f, 0.08190331f, 0.24433900f, -0.16628571f, 0.05035644f, -0.06245976f, 
    -0.27242708f, 0.18732297f, 0.06622023f, -0.04307856f, -0.00103983f, -0.09522367f, -0.02887446f, 0.14471395f, 
    0.00387694f, -0.00989533f, 0.05752191f, -0.00662692f, 0.22076246f, 0.14190124f, 0.35857457f, 0.27330232f, 
    -0.18267870f, 0.13738246f, -0.05572939f, -0.18053129f, -0.14499420f, -0.12902211f, 0.04246877f, 0.06102462f, 
    0.07134992f, 0.06794181f, -0.00902127f, 0.08414160f, -0.03200977f, -0.02034291f, 0.02359778f, 0.03650047f, 
    0.21416186f, -0.35098904f, -0.17905730f, 0.08064427f, 0.00483214f, -0.04943061f, 0.07246575f, 0.19265215f, 
    0.05846839f, 0.18041433f, -0.04468146f, -0.02142252f, -0.13887134f, -0.03075404f, 0.03447708f, 0.05621208f, 
    0.07819533f, 0.14973964f, -0.00139267f, -0.01852762f, -0.01295494f, 0.03843251f, 0.02285576f, -0.04255052f, 
    0.08072487f, -0.16666189f, 0.13021530f, -0.09474892f, -0.08120894f, -0.00128888f, 0.03478257f, -0.01168627f, 
    0.02390000f, 0.01304190f, 0.07184051f, 0.04192932f, -0.13699909f, 0.00644231f, -0.12945130f, -0.09615085f, 
    -0.08276668f, -0.10385200f, -0.13722838f, -0.07516885f, 0.10870759f, -0.00552846f, 0.14955698f, 0.00250894f, 
    0.05093746f, -0.01261111f, 0.09070423f, 0.10268535f, 0.02327570f, 0.01564047f, -0.04241063f, 0.14091894f, 
    0.02704138f, -0.02085608f, -0.03770722f, 0.00978375f, 0.06979850f, -0.01250154f, 0.44044447f, 0.03765585f, 
    -0.30772981f, 0.13669191f, -0.10878266f, -0.14021382f, 0.02721290f, 0.02918942f, 0.05936750f, 0.07507275f, 
    -0.01558039f, 0.08104363f, 0.06390362f, -0.00417369f, -0.02654924f, -0.05018027f, -0.04792590f, 0.06070015f, 
    -0.37399814f, -0.19200023f, 0.08450012f, 0.14037630f, -0.33245823f, 0.09706387f, -0.27392560f, -0.00413244f, 
    -0.01760738f, 0.16583104f, 0.02270591f, 0.06426445f, 0.02215586f, 0.02840849f, -0.01883379f, -0.04380791f, 
    -0.02317067f, 0.09300620f, 0.07997299f, 0.06210274f, -0.25199908f, 0.08612294f, 0.08625818f, -0.15852071f, 
    0.02214299f, 0.00953432f, -0.10675987f, 0.04344727f, -0.00795980f, -0.02405393f, 0.10222693f, -0.01987584f, 
    0.01007698f, -0.02939127f, 0.00243595f, 0.02640991f, -0.14151514f, -0.04761244f, 0.00236276f, -0.00351008f, 
    0.12954396f, 0.11798101f, 0.11995596f, 0.08789278f, 0.08651916f, 0.01382696f, -0.00167241f, -0.04187422f, 
    0.00067391f, -0.07549106f, -0.00198438f, 0.05584405f, 0.02606414f, -0.04693944f, -0.00923115f, 0.09925814f, 
    0.08428147f, -0.07130361f, -0.01934510f, 0.08590128f, -0.35022557f, 0.00722055f, -0.08589684f, 0.16014607f, 
    0.06369792f, 0.01487439f, 0.08772222f, 0.06038586f, -0.12011357f, -0.01786033f, -0.01641710f, 0.06675596f, 
    -0.04521316f, -0.08011082f, 0.01212663f, -0.02645974f, -0.00953326f, -0.11370111f, 0.03109721f, -0.00670093f, 
    -0.08816084f, -0.14616181f, 0.26524746f, 0.27770716f, -0.49331489f, 0.29685697f, -0.18235920f, -0.22089551f, 
    -0.05803059f, -0.12179703f, -0.02502735f, 0.06259100f, 0.05292487f, 0.04300956f, 0.04634299f, 0.02440818f, 
    -0.05078387f, -0.02157416f, -0.02041029f, 0.00237479f, 0.08385606f, 0.17734633f, -0.16497594f, 0.31034675f, 
    -0.46378294f, -0.22611873f, -0.08421792f, -0.37338254f, 0.03402366f, -0.12874363f, 0.11156631f, -0.09058115f, 
    0.06124637f, 0.10096139f, 0.02733922f, 0.11559000f, 0.07375884f, 0.02068425f, 0.00867891f, 0.00222089f, 
    0.09615930f, -0.32242981f, -0.26374361f, -0.03603484f, 0.01653680f, -0.01591328f, -0.03808186f, 0.10372380f, 
    0.04435553f, 0.06568212f, -0.08149790f, 0.03076716f, 0.01962115f, -0.00447104f, 0.01187928f, 0.03332193f, 
    0.14856510f, 0.12846367f, 0.04449356f, 0.12033972f, -0.01914095f, -0.04407440f, -0.20636287f, 0.03818680f, 
    -0.03375489f, 0.04219351f, 0.04912993f, -0.03789125f, -0.01260540f, -0.05410926f, 0.01564524f, -0.10760432f, 
    0.02004877f, -0.03573364f, -0.08596650f, 0.03448731f, 0.03809452f, -0.19281393f, -0.03044787f, -0.03403988f, 
    -0.21998106f, -0.14717478f, -0.04366484f, -0.01939625f, 0.19095555f, -0.04341517f, 0.12126379f, 0.01005642f, 
    0.01486978f, -0.15913221f, -0.06208040f, 0.07211759f, 0.02782662f, -0.20338307f, 0.02817569f, 0.18851785f, 
    -0.03000605f, -0.08113930f, -0.05426623f, -0.06890354f, 0.05237615f, 0.18421175f, -0.39984435f, 0.06043378f, 
    -0.01242222f, 0.05471260f, 0.13341203f, 0.28776425f, 0.06626469f, 0.03060746f, -0.00682248f, 0.02066672f, 
    -0.04262595f, -0.08339228f, -0.04551740f, 0.06602955f, 0.02791886f, -0.15663795f, 0.00072875f, -0.02049571f, 
    -0.33194610f, 0.34445924f, -0.74308348f, 0.13886018f, -0.16016628f, 0.02518745f, -0.03528112f, 0.09173474f, 
    -0.06970091f, 0.00318249f, 0.08514219f, -0.08600861f, -0.02157592f, -0.05918354f, -0.11774944f, 0.11835300f, 
    -0.05335649f, -0.06086079f, 0.07401248f, -0.05385398f, 0.12115244f, 0.15977263f, 0.13107863f, 0.31688932f, 
    -0.06891564f, -0.06103886f, 0.06680939f, -0.22855471f, -0.06676633f, -0.07894214f, 0.05842716f, -0.05015394f, 
    0.01984936f, 0.06122620f, -0.00369379f, 0.05591007f, 0.05295007f, -0.00170364f, 0.02147585f, 0.03917198f, 
    0.07629151f, 0.01232791f, -0.10995820f, -0.14542487f, 0.08473758f, 0.10565193f, 0.13479184f, 0.14291079f, 
    0.06204491f, -0.02149987f, 0.02413716f, 0.05475836f, -0.04401138f, 0.02380423f, 0.03248950f, 0.01175086f, 
    -0.08555286f, 0.02478356f, -0.07228613f, 0.02025152f, -0.17889006f, -0.15308803f, 0.30329853f, 0.25850832f, 
    -0.45758945f, 0.14494969f, -0.23260111f, -0.02563770f, 0.09724701f, 0.15588689f, 0.01676569f, 0.07029619f, 
    0.03664279f, 0.01431081f, 0.05400660f, -0.01462710f, 0.07720654f, 0.05317742f, -0.00775649f, 0.10812414f, 
    0.14822698f, 0.07728468f, -0.12991942f, 0.07973574f, -0.09827797f, -0.02545498f, 0.23639284f, 0.12119991f, 
    0.03555206f, 0.03899023f, -0.05842520f, -0.07465246f, -0.05696164f, -0.12473847f, 0.00943436f, 0.08244052f, 
    -0.10293084f, 0.00044949f, -0.09376425f, -0.07855557f, -0.23314635f, 0.39195737f, -0.41368923f, -0.17138198f, 
    -0.14830959f, 0.05224413f, -0.09538320f, 0.11293115f, 0.00000637f, 0.15847377f, 0.04165043f, 0.00656485f, 
    -0.06415368f, 0.00947260f, 0.07551859f, -0.09990557f, 0.12080020f, -0.02113976f, -0.00807238f, -0.08062149f, 
    -0.09141627f, -0.04269117f, -0.17665213f, 0.00843367f, 0.02639737f, -0.00297050f, 0.07433179f, 0.05215297f, 
    0.04125939f, -0.00649920f, 0.05711535f, -0.07558184f, -0.00675367f, 0.10017911f, -0.07844363f, 0.05130081f, 
    0.14288619f, 0.01108329f, -0.09424374f, -0.00177808f, 0.00218979f, -0.02330231f, -0.01495375f, -0.05883807f, 
    0.13660537f, -0.04161325f, 0.04648101f, 0.09750394f, 0.02995062f, -0.04608913f, -0.04739284f, 0.07149468f, 
    0.00517773f, -0.06575304f, 0.03789938f, 0.01431710f, 0.07528008f, -0.00160331f, 0.01315059f, 0.17439628f, 
    0.06604722f, -0.07532118f, -0.05516368f, -0.01598809f, 0.00814723f, 0.00074131f, 0.10650847f, 0.00098167f, 
    0.07663417f, 0.00029907f, 0.05844273f, 0.01985117f, 0.05162774f, 0.00339620f, 0.00733508f, 0.07697097f, 
    -0.01004675f, 0.03423009f, -0.01459266f, 0.03184639f, -0.05701351f, 0.00184729f, 0.10848662f, 0.09779594f, 
    0.16424517f, -0.00794536f, 0.01712156f, 0.00265517f, 0.00094561f, 0.12385219f, 0.05973217f, -0.07547922f, 
    0.04017033f, 0.09267657f, -0.09755228f, 0.02453280f, 0.08377396f, 0.01898607f, -0.01241908f, 0.07259676f, 
    -0.21933869f, 0.23490241f, -0.13311447f, 0.33509588f, -0.08269692f, 0.07268409f, -0.30487326f, -0.00753034f, 
    0.00268918f, -0.11152325f, -0.00086569f, 0.10765458f, -0.03786661f, -0.01649983f, -0.01176120f, -0.03611366f, 
    -0.00069944f, -0.01819216f, 0.00491637f, 0.12869515f, -0.03019850f, 0.12218571f, 0.06701937f, 0.31361672f, 
    -0.65788448f, -0.05254085f, 0.02055240f, -0.16843207f, -0.00325075f, 0.01974904f, 0.06433059f, -0.06532205f, 
    0.01668368f, 0.00979771f, -0.02668723f, 0.07345069f, 0.09310597f, 0.07293578f, 0.06946404f, 0.12454602f, 
    -0.23157774f, -0.14457215f, 0.14088733f, 0.12206660f, -0.29546636f, 0.05242323f, -0.23162667f, 0.10331495f, 
    -0.01332138f, 0.07082600f, 0.02504872f, -0.01112015f, 0.03223699f, -0.01952424f, -0.01944380f, 0.03048994f, 
    -0.00645271f, 0.00833539f, -0.00873519f, -0.06170658f, 0.30598038f, -0.24065067f, 0.23132603f, -0.53981084f, 
    -0.34968042f, -0.05474373f, -0.06692282f, -0.22603028f, 0.02115572f, 0.00525270f, 0.03920335f, -0.05284628f, 
    0.04043051f, 0.03507106f, 0.00318841f, 0.08701000f, -0.05583198f, -0.02297268f, -0.03809229f, -0.02023719f, 
    -0.11122781f, -0.05983510f, -0.09969873f, -0.20528036f, 0.07003682f, 0.01534308f, -0.04590838f, 0.07720443f, 
    0.00994751f, 0.02341991f, -0.04137100f, 0.10590239f, -0.05428067f, 0.03095031f, 0.01447782f, 0.11737949f, 
    0.11604375f, 0.01861904f, 0.00960496f, 0.16133192f, -0.17928468f, -0.22427325f, 0.35643202f, -0.40004641f, 
    -0.45450768f, -0.03155970f, -0.24374087f, -0.00215332f, 0.11006466f, -0.05697848f, -0.09760335f, 0.07421668f, 
    -0.01717622f, 0.08013032f, 0.02624547f, 0.04828804f, 0.01835503f, -0.00190464f, -0.06554340f, 0.01401827f, 
    0.11488558f, -0.66896176f, -0.07708250f, -0.22732848f, -0.10569083f, -0.30760506f, -0.06999500f, -0.01626509f, 
    0.12847222f, 0.15229627f, -0.01649811f, 0.06348418f, -0.02168479f, -0.02030566f, 0.02116287f, -0.02411479f, 
    0.04434954f, 0.03202063f, 0.04399734f, -0.02687569f, -0.16312455f, 0.01381304f, 0.13069630f, 0.33425015f, 
    -0.66029698f, 0.03801158f, 0.01339758f, -0.08566369f, 0.08542433f, 0.09447933f, 0.10254252f, -0.01797196f, 
    0.05804136f, 0.04250175f, 0.04171789f, 0.00171240f, 0.06924715f, 0.00038367f, 0.05683248f, 0.05468341f, 
    -0.40974912f, -0.02849440f, -0.33243233f, 0.32665974f, -0.19924922f, 0.00272978f, 0.02641083f, -0.00091703f, 
    -0.03347307f, 0.05990167f, 0.08390088f, -0.08522114f, 0.01066569f, -0.01174014f, 0.05070794f, -0.06549498f, 
    0.07578984f, 0.03952025f, 0.16625416f, 0.33492976f, -0.24152432f, -0.30238199f, -0.17877132f, 0.19221559f, 
    -0.26721272f, -0.10208558f, -0.11871472f, 0.28391340f, 0.15709823f, 0.22267699f, 0.04507750f, 0.02272903f, 
    0.02427261f, 0.02061005f, -0.01150797f, 0.07273499f, -0.01896920f, 0.05999125f, 0.09769695f, -0.22488417f, 
    -0.00987362f, 0.01344064f, -0.13252209f, -0.07317924f, 0.01751367f, 0.15949252f, -0.06584400f, 0.08487082f, 
    -0.13259453f, -0.11762695f, 0.04139563f, -0.04511690f, -0.04380482f, -0.05342294f, -0.06856585f, 0.06843971f, 
    -0.05657903f, -0.07497524f, -0.01314186f, 0.04898751f, -0.11092781f, -0.00080893f, -0.01125039f, -0.12190682f, 
    0.03970844f, 0.06660905f, 0.04042594f, 0.07988859f, 0.01953644f, -0.06237900f, 0.06667640f, 0.07200027f, 
    -0.08201354f, 0.01307498f, 0.02679836f, -0.02232875f, -0.03729557f, 0.02625081f, -0.03964093f, 0.00453882f, 
    0.08640278f, 0.17352115f, -0.00569773f, -0.10634422f, -0.01084865f, -0.12046622f, 0.04513222f, 0.03749956f, 
    0.11702696f, 0.14656523f, -0.06451355f, 0.05951572f, -0.06986713f, -0.07601423f, 0.02515017f, -0.00361347f, 
    0.07959087f, 0.03306706f, 0.00606570f, -0.03243167f, -0.16237105f, -0.07098014f, 0.04520158f, -0.00824392f, 
    0.13299334f, -0.02737662f, 0.04287128f, -0.01773219f, -0.13365449f, -0.05102443f, 0.07759450f, -0.05329924f, 
    -0.04195698f, 0.04078725f, -0.09524090f, -0.05034999f, 0.04129381f, 0.00489170f, -0.11268564f, 0.04533605f, 
    -0.14084707f, 0.22125106f, 0.05543724f, 0.41733837f, -0.13256608f, 0.13035281f, -0.21996729f, -0.09199082f, 
    -0.31434613f, -0.11230507f, -0.01661100f, -0.04816462f, 0.05049156f, 0.01312372f, -0.03125802f, 0.01906297f, 
    0.07653689f, -0.05031196f, -0.00610760f, 0.14772749f, -0.08483936f, 0.04365229f, 0.07101490f, 0.08859261f, 
    0.08692323f, 0.17067577f, -0.02226543f, -0.00590411f, -0.01283829f, -0.17586194f, 0.00423312f, 0.04791076f, 
    -0.03958552f, -0.06681941f, -0.02791455f, 0.01527526f, -0.08917256f, -0.07863048f, -0.02311036f, -0.02960589f, 
    0.29301247f, 0.01937963f, 0.16502698f, -0.06578979f, -0.11432470f, 0.04867693f, -0.09798873f, 0.01738734f, 
    -0.05879946f, -0.01362905f, -0.07578803f, 0.07948177f, 0.00477790f, -0.04862753f, 0.00054966f, -0.03888146f, 
    -0.07449345f, 0.02824747f, 0.03974449f, -0.03087833f, -0.14102963f, -0.21504560f, -0.13192280f, -0.08786240f, 
    -0.02105870f, 0.09061189f, 0.01468436f, 0.06100755f, -0.06213468f, -0.00270248f, -0.10157558f, -0.00235959f, 
    0.04114034f, -0.03539001f, -0.05437305f, 0.02191509f, 0.01911308f, 0.04482292f, 0.02434918f, 0.01339242f, 
    0.25931776f, -0.19202369f, 0.22875544f, 0.00334178f, -0.13406761f, -0.01485536f, -0.03207914f, 0.17440800f, 
    0.13941093f, -0.02494267f, -0.01352320f, -0.01313199f, 0.00629712f, -0.05577818f, -0.16786776f, -0.08043598f, 
    0.04876975f, 0.14910915f, -0.01786459f, 0.03174696f, -0.27978131f, 0.03396270f, 0.08629337f, 0.13105565f, 
    0.01229852f, -0.02638301f, 0.07919370f, 0.07643188f, 0.09020285f, 0.09797813f, -0.04001118f, 0.03114650f, 
    0.07311369f, 0.07178568f, -0.01615437f, -0.01158423f, 0.06561686f, 0.00730714f, 0.10579481f, 0.11203556f, 
    -0.50153404f, -0.21520965f, 0.21633233f, -0.03444653f, 0.04181378f, 0.09886219f, 0.05328669f, 0.08961589f, 
    0.14388894f, 0.08843020f, 0.06416509f, -0.01671283f, -0.02930443f, 0.07208469f, -0.00326237f, 0.00740006f, 
    0.09630983f, 0.04025116f, 0.18381962f, 0.21039885f, -0.14250985f, 0.14659901f, 0.18992113f, 0.11060677f, 
    -0.07383879f, 0.04528990f, 0.01246698f, -0.07245252f, 0.27158880f, 0.00812745f, -0.18088600f, 0.00840384f, 
    0.03348248f, 0.07029409f, 0.12399847f, -0.07092803f, 0.17836310f, 0.07188155f, 0.20087531f, 0.14788860f, 
    0.03735101f, -0.45457068f, 0.23191445f, 0.18383878f, -0.02270345f, -0.19884594f, 0.06489921f, 0.31301999f, 
    -0.05438997f, 0.07321874f, -0.10016876f, 0.05064465f, -0.13279778f, 0.09659375f, 0.02654138f, -0.00016005f, 
    0.01561219f, 0.16146874f, -0.02339767f, 0.09113589f, -0.35402247f, 0.06840097f, 0.08509278f, 0.19443853f, 
    -0.00069299f, -0.01151989f, 0.11869799f, -0.08925470f, 0.05620157f, 0.04607122f, -0.10860678f, -0.04775667f, 
    0.01874958f, 0.02041414f, -0.05187958f, -0.00171925f, 0.06661979f, 0.08413459f, 0.07033976f, 0.27969706f, 
    -0.01048184f, -0.05099621f, 0.02411165f, -0.08034480f, -0.02485474f, 0.05700835f, 0.00898345f, -0.04512633f, 
    0.14017078f, 0.19932410f, -0.06563168f, 0.12580208f, -0.05442630f, -0.09613512f, -0.19007891f, 0.07131338f, 
    0.03541624f, -0.05455467f, 0.14218304f, -0.06011324f, -0.06658961f, -0.04156100f, -0.07471441f, 0.04058523f, 
    -0.01690683f, -0.06295192f, 0.06209250f, 0.02391198f, -0.19289371f, -0.19062330f, 0.05693877f, 0.05552292f, 
    -0.01337728f, 0.07256211f, -0.01228713f, 0.06066127f, -0.05102034f, -0.08055260f, -0.22087145f, -0.26967227f, 
    -0.20912343f, 0.08591110f, -0.06754655f, 0.07227118f, -0.02616720f, 0.03288668f, -0.04397166f, -0.05413639f, 
    0.03138508f, 0.11875848f, 0.09028924f, -0.00642747f, -0.01593194f, 0.07273842f, 0.00067749f, 0.03054316f, 
    -0.00797389f, -0.04680597f, 0.06798394f, -0.07944885f, 0.02734227f, -0.11800473f, 0.22807018f, 0.07548372f, 
    -0.00977539f, -0.03678299f, -0.01733245f, -0.00323727f, -0.05561539f, -0.04667948f, -0.09389290f, 0.04649007f, 
    -0.10522518f, 0.07212351f, -0.01286771f, 0.01113867f, -0.01830738f, -0.00066541f, -0.06330185f, 0.02069139f, 
    -0.34326726f, 0.15414387f, 0.01262317f, 0.25245780f, 0.20614681f, -0.06878889f, -0.04707211f, -0.12698498f, 
    0.08891204f, 0.14099009f, -0.02887691f, 0.01535438f, 0.03491646f, -0.12502375f, 0.07741114f, -0.01824947f, 
    -0.06984958f, -0.04806701f, 0.07706090f, 0.10021203f, 0.25355005f, -0.10499205f, 0.23968208f, -0.29983500f, 
    0.05187841f, -0.15009166f, -0.00357800f, -0.04283519f, 0.13332213f, -0.08806658f, 0.01340252f, -0.09055144f, 
    0.01627336f, -0.05870170f, 0.23641348f, 0.04077427f, 0.08613618f, 0.06795210f, 0.02851418f, -0.03796942f, 
    0.17258221f, 0.07377426f, 0.18549384f, -0.09948312f, -0.04032187f, -0.07707053f, -0.03087158f, -0.07769214f, 
    0.09884115f, -0.07853299f, 0.02397917f, 0.05795485f, -0.02947068f, -0.00950088f, -0.04056498f, 0.06345901f, 
    0.05874132f, 0.03766403f, 0.04689638f, -0.08652126f, 0.16346690f, -0.07740860f, -0.03850913f, 0.11567867f, 
    0.06938987f, -0.02156442f, 0.08674092f, 0.15660851f, 0.05267889f, 0.01812165f, -0.04289439f, -0.01047803f, 
    0.04341254f, -0.03999345f, -0.03898780f, 0.02875503f, 0.08939690f, 0.19509965f, 0.13314424f, 0.17052567f, 
    -0.08847059f, -0.10419038f, -0.01567865f, -0.07889258f, -0.10189814f, -0.15484586f, -0.05415289f, -0.06965395f, 
    0.07063953f, -0.06750353f, -0.06759363f, -0.02099001f, -0.03008024f, 0.01514206f, 0.05689950f, 0.14536445f, 
    -0.03917034f, -0.01708106f, 0.08156091f, -0.09947973f, -0.42295986f, -0.02588038f, 0.00434642f, 0.05439511f, 
    0.10200009f, -0.04985024f, -0.11564442f, -0.11338432f, -0.02753471f, -0.08257428f, -0.01582654f, 0.04297398f, 
    -0.00648140f, 0.01718794f, 0.01618147f, 0.05619489f, 0.04948216f, -0.12635112f, -0.00536452f, 0.00133222f, 
    -0.28841081f, 0.33027422f, 0.31664854f, 0.16031066f, -0.06652986f, 0.07818274f, 0.01741132f, 0.08560129f, 
    0.08135675f, -0.05658959f, -0.10060836f, -0.01319626f, -0.11218814f, -0.04157327f, 0.01805715f, -0.15265152f, 
    -0.03835259f, -0.11782200f, -0.14775142f, -0.13072276f, -0.03138446f, -0.07892259f, -0.00492947f, -0.09252821f, 
    0.07910621f, -0.07544742f, -0.02047523f, -0.00581625f, -0.06516428f, -0.17824031f, -0.17486009f, 0.03161692f, 
    -0.08285669f, 0.04952119f, 0.02967977f, 0.11877261f, -0.04761492f, -0.06879294f, -0.27125731f, -0.14107932f, 
    -0.11412290f, -0.15282694f, 0.25171518f, -0.11671291f, -0.15639193f, -0.05287145f, -0.06846539f, -0.27260834f, 
    -0.10207610f, 0.09046447f, -0.04785690f, 0.05480205f, 0.08830986f, -0.05816448f, -0.01233874f, -0.09113692f, 
    0.12273660f, -0.00966978f, 0.03213055f, -0.04062656f, -0.12694749f, -0.30306190f, -0.25345173f, -0.22532997f, 
    -0.15886526f, -0.08884476f, -0.07711296f, -0.14499874f, 0.07424004f, -0.02248100f, -0.12462769f, -0.04960870f, 
    0.05474212f, -0.07292892f, -0.05413999f, -0.01270965f, 0.02382966f, -0.03245411f, 0.11886426f, 0.00648231f, 
    0.45652357f, -0.03263235f, 0.29783493f, 0.00753993f, 0.06723443f, 0.05068876f, -0.13509625f, 0.08089954f, 
    0.00046359f, 0.01605147f, 0.05223145f, 0.01387785f, 0.12850909f, -0.11312282f, 0.16492231f, 0.02067610f, 
    -0.08867221f, -0.08008523f, 0.03422778f, -0.07646952f, 0.05801492f, -0.06613580f, 0.11399813f, 0.12946948f, 
    -0.00348929f, -0.06401377f, 0.03700554f, -0.04912395f, -0.00456633f, 0.01912254f, 0.01570343f, 0.03910542f, 
    -0.07306559f, -0.01797574f, -0.03274207f, -0.06299353f, -0.02208197f, 0.07607834f, -0.04942712f, 0.03465671f, 
    0.04120930f, -0.11742374f, -0.48738024f, 0.26264843f, 0.10065535f, -0.04813935f, -0.18252604f, -0.07191376f, 
    -0.05929336f, 0.15704398f, -0.07834148f, 0.02884899f, -0.13871735f, -0.01107458f, 0.05799158f, 0.03158315f, 
    -0.03364129f, -0.11467343f, 0.03692118f, 0.15830944f, -0.04359752f, -0.12279340f, 0.09291653f, -0.07272662f, 
    -0.02108500f, 0.04529171f, 0.09495049f, -0.02209049f, 0.00820619f, 0.04595319f, -0.01187033f, 0.05014138f, 
    0.01051725f, 0.04700959f, -0.00948409f, 0.00412420f, 0.20397288f, 0.01597082f, 0.12311995f, 0.12979265f, 
    -0.16091891f, -0.26680318f, -0.24254647f, -0.25786906f, -0.20040776f, -0.07360730f, -0.04853931f, 0.07103731f, 
    0.07852295f, 0.05119091f, -0.13861613f, 0.09425161f, -0.03573203f, -0.10593963f, -0.05224311f, 0.05039087f, 
    -0.01966718f, 0.05478955f, 0.06807833f, 0.06741045f, -0.08945354f, 0.20164724f, -0.13595621f, 0.09459423f, 
    0.00946379f, -0.02257811f, 0.01515815f, -0.08492827f, 0.05771125f, 0.08169991f, 0.02861252f, -0.02712062f, 
    -0.02890512f, -0.10145985f, -0.03157050f, -0.02477993f, -0.03318997f, -0.06254481f, 0.05692891f, 0.09909625f, 
    -0.22695853f, -0.08296256f, -0.03932844f, -0.18721016f, 0.13814208f, -0.06864664f, -0.01327774f, 0.08724663f, 
    0.04097218f, -0.02139006f, -0.08408756f, 0.07133024f, -0.04333998f, 0.07329676f, 0.08570751f, 0.07882985f, 
    -0.05916227f, 0.01004687f, -0.08689061f, -0.06845985f, -0.07855328f, -0.21408479f, 0.17964758f, -0.15231979f, 
    0.10441826f, 0.02051259f, 0.06243017f, -0.06772023f, 0.03933093f, 0.01061530f, -0.07049140f, -0.02508214f, 
    -0.01267479f, -0.11506515f, -0.02321665f, -0.09212609f, 0.22491637f, 0.08614375f, 0.23070325f, -0.09427728f, 
    0.07780581f, -0.11468454f, 0.06904031f, 0.03137621f, -0.07513504f, -0.02447497f, -0.01924490f, -0.00473802f, 
    -0.06907772f, -0.01186480f, -0.02451047f, -0.01747042f, -0.03939882f, 0.02579232f, -0.00429729f, -0.09422181f, 
    -0.04363228f, 0.00905520f, -0.09298543f, -0.02706230f, 0.10476568f, -0.14301293f, 0.13179456f, -0.12347658f, 
    0.00315433f, -0.08569933f, -0.01877469f, 0.08753058f, 0.09179261f, -0.01929701f, 0.00261097f, -0.02419643f, 
    0.10503409f, 0.00142568f, 0.10760880f, 0.02132584f, 0.02467365f, 0.07460137f, -0.00717039f, -0.02258450f, 
    -0.21821555f, -0.08466637f, 0.04081335f, -0.02172797f, -0.02022981f, -0.01865720f, -0.01628791f, -0.26160181f, 
    0.10648187f, 0.01435250f, 0.11265010f, -0.00272356f, -0.06250145f, -0.01012996f, -0.03127309f, 0.01618360f, 
    0.01471969f, 0.01151242f, 0.00371413f, 0.04185897f, 0.10757785f, 0.10956930f, 0.23681371f, 0.13420771f, 
    0.05135247f, 0.03255023f, -0.04317087f, -0.15949279f, 0.00073765f, 0.10015427f, -0.15290885f, 0.16100904f, 
    -0.08391631f, -0.08169345f, -0.12683541f, 0.03117099f, -0.02743230f, -0.00698843f, 0.03032332f, 0.02554301f, 
    -0.11718986f, 0.09759898f, -0.18189751f, 0.05487020f, -0.03375378f, -0.00450296f, 0.04302949f, -0.02517825f, 
    -0.00570712f, -0.03162444f, 0.01754189f, 0.03818504f, -0.08112303f, 0.02410227f, -0.04445772f, -0.06870159f, 
    -0.14027272f, -0.30387571f, -0.30304348f, -0.07153020f, -0.37150341f, -0.04928902f, -0.06354892f, 0.11639605f, 
    0.05664018f, 0.03107610f, 0.02403920f, 0.11923746f, 0.18488704f, 0.05552451f, -0.15008789f, -0.03844821f, 
    -0.02256016f, -0.05725843f, 0.00256244f, 0.03416550f, -0.08012518f, -0.00955401f, 0.07809573f, 0.11266284f, 
    -0.14700064f, -0.25490507f, 0.00736591f, -0.07277427f, -0.06121247f, 0.02330354f, 0.04637878f, 0.04689725f, 
    0.01248310f, 0.03973840f, -0.11472694f, 0.01707983f, 0.11560328f, -0.03364117f, 0.10833417f, 0.06870299f, 
    0.01267703f, 0.04025925f, -0.02703357f, -0.00309195f, -0.22936673f, -0.38713399f, -0.21453150f, 0.01144208f, 
    -0.10243428f, -0.10369696f, -0.02502955f, 0.10633628f, -0.05212094f, -0.06610548f, -0.09977300f, 0.10988111f, 
    -0.02946398f, 0.05775612f, 0.04639171f, 0.09400173f, -0.06857859f, 0.04564025f, -0.00464807f, 0.09759033f, 
    -0.14879715f, -0.47307900f, 0.14823762f, -0.02052893f, 0.07845657f, -0.00948723f, 0.00994852f, 0.08251763f, 
    0.02659039f, -0.01629400f, -0.14056414f, 0.01027745f, -0.03055020f, -0.01064941f, 0.03933803f, 0.02200256f, 
    0.08130444f, 0.06745608f, 0.11390966f, -0.07910962f, 0.07763354f, -0.00921021f, -0.01656998f, 0.04646880f, 
    0.01664959f, 0.11103192f, 0.00675203f, -0.03920189f, -0.01904961f, -0.00354572f, -0.11930028f, 0.11118966f, 
    -0.04714664f, -0.05526903f, -0.02511308f, -0.02733874f, -0.04347992f, -0.02529301f, 0.00008028f, -0.08416611f, 
    -0.14557619f, -0.27807787f, 0.16843964f, -0.08683656f, -0.23492910f, -0.02376639f, -0.01701860f, -0.01039639f, 
    -0.02777014f, -0.10800780f, -0.05499576f, 0.01069920f, 0.02958927f, 0.01150797f, -0.10365029f, -0.00876906f, 
    0.09485183f, 0.08471876f, 0.08307566f, 0.02623639f, -0.25374794f, -0.05087879f, -0.06408321f, -0.02934559f, 
    0.04427573f, -0.08549855f, 0.00801293f, -0.13065568f, 0.00906141f, -0.02577110f, 0.03776626f, -0.00842471f, 
    -0.11541814f, -0.04859817f, 0.02823547f, 0.03980473f, -0.04565831f, -0.00359279f, -0.07461077f, -0.05346842f, 
    -0.18629490f, -0.32973003f, -0.06204719f, -0.03347059f, -0.08150326f, 0.04553726f, 0.01346947f, 0.08421370f, 
    -0.12423061f, -0.02584540f, -0.00370299f, 0.00529289f, 0.07530749f, -0.02169993f, 0.05396026f, 0.02142044f, 
    0.02685659f, -0.01037285f, 0.05939078f, 0.10207878f, -0.06555010f, -0.14652498f, -0.23679522f, 0.06703404f, 
    -0.17444080f, -0.02115881f, 0.01035524f, 0.15319327f, -0.01460668f, -0.06163545f, -0.09974652f, -0.02670834f, 
    0.04607663f, 0.02083326f, -0.01416995f, 0.03601719f, 0.00154118f, 0.10282935f, 0.03683790f, -0.06052365f, 
    -0.11484074f, -0.22383668f, 0.10589233f, 0.12636669f, 0.02178597f, -0.08064763f, -0.07242928f, 0.04555564f, 
    0.09373137f, 0.06014752f, -0.00984641f, -0.07660242f, -0.02267807f, -0.00616434f, 0.06737848f, 0.01045078f, 
    -0.07132784f, -0.07138707f, 0.06455512f, -0.05502617f, 0.04774234f, -0.12490980f, -0.02945392f, 0.11117094f, 
    -0.12010621f, -0.06694986f, -0.04899892f, 0.01551592f, -0.11260277f, -0.09492747f, 0.06822412f, 0.04102845f, 
    -0.10703173f, 0.08949644f, 0.01717064f, 0.00692090f, -0.06250645f, 0.05136339f, -0.15145019f, -0.03667377f, 
    -0.09920463f, -0.26005384f, -0.22514719f, -0.14835598f, -0.18170355f, -0.07484392f, -0.04068031f, -0.06848599f, 
    0.03963820f, 0.04961302f, -0.16016066f, 0.04494327f, 0.00095487f, -0.09201998f, -0.10450186f, -0.09613881f, 
    0.01802470f, 0.06766138f, 0.09216607f, 0.10464820f, 0.15047926f, -0.24498880f, 0.06254993f, 0.06823352f, 
    -0.00440126f, 0.03362268f, 0.06997182f, 0.05280092f, -0.07362963f, -0.07672743f, -0.03224172f, -0.02242360f, 
    -0.04349013f, 0.02809755f, 0.03941634f, -0.00176968f, -0.07157699f, -0.17292756f, -0.10138458f, -0.30000144f, 
    -0.02272849f, -0.37058833f, 0.20978765f, -0.13398445f, -0.05565203f, -0.07387072f, -0.06298160f, -0.07983945f, 
    0.05460552f, -0.03362171f, -0.00987681f, 0.00305683f, -0.11257946f, 0.01560975f, -0.00826695f, 0.03956684f, 
    -0.03580706f, -0.02132506f, -0.03784141f, -0.12691748f, -0.07166184f, -0.05057018f, 0.03443806f, -0.01670818f, 
    0.05544332f, 0.12631896f, -0.04704321f, 0.03537998f, 0.06542822f, 0.03716617f, -0.02504613f, 0.06709568f, 
    -0.03558303f, -0.15312502f, -0.14169671f, -0.03639201f, -0.04344154f, 0.05050682f, -0.09056603f, -0.06151769f, 
    -0.27709270f, 0.07092509f, -0.00453884f, -0.15858842f, 0.10941696f, -0.13889809f, -0.04390123f, 0.02612137f, 
    0.04567761f, 0.00390428f, -0.11431938f, 0.05961202f, -0.07694454f, 0.00664110f, 0.02995735f, 0.07726344f, 
    -0.02049890f, 0.02631650f, 0.07798052f, 0.14785454f, 0.05265848f, 0.22863498f, -0.51053149f, 0.27713823f, 
    0.34010047f, -0.02893000f, 0.05627161f, 0.02311330f, -0.18276338f, 0.13864467f, -0.21449383f, -0.02435152f, 
    -0.04068634f, -0.00955932f, 0.01344129f, 0.04707738f, 0.05984967f, -0.21645701f, 0.14518768f, 0.13117002f, 
    -0.02973839f, -0.08680155f, -0.00146625f, -0.08447464f, -0.09990089f, -0.02754150f, 0.04105232f, 0.07519758f, 
    -0.07510792f, -0.07742959f, 0.10139471f, 0.08885103f, -0.07529474f, 0.09114812f, 0.01318709f, 0.03058217f, 
    0.00701039f, 0.00720179f, -0.21072799f, -0.09174972f, -0.10145435f, 0.14006123f, 0.02596615f, 0.13660957f, 
    0.01013802f, 0.04858482f, 0.08011939f, -0.04579502f, 0.05195223f, 0.03649246f, 0.04565510f, -0.02477396f, 
    -0.07483148f, 0.00851664f, 0.01457623f, -0.01391923f, -0.00754103f, -0.03274343f, -0.03947596f, -0.04205309f, 
    -0.34037080f, 0.09828020f, -0.73542196f, 0.07059591f, -0.03010100f, -0.00202073f, -0.08530412f, 0.02248619f, 
    0.17923695f, 0.02534188f, 0.05172660f, 0.03390463f, -0.07611533f, 0.01796555f, 0.00873532f, 0.00220493f, 
    -0.00774018f, -0.33982059f, -0.10033308f, -0.11709491f, -0.24143301f, 0.12930763f, -0.34373835f, 0.04801882f, 
    0.05517280f, -0.06386369f, -0.08133318f, -0.06455949f, -0.05006902f, 0.07717845f, -0.05421428f, 0.02006744f, 
    0.01588945f, -0.04763975f, -0.00254295f, 0.03127868f, -0.03708856f, -0.05410874f, -0.02496453f, 0.00550338f, 
    0.11427914f, -0.07291700f, 0.15051803f, 0.05574311f, 0.12326732f, 0.03514977f, 0.08856563f, 0.04046739f, 
    0.03723208f, -0.02374142f, -0.09456946f, -0.02201913f, 0.03598487f, -0.03677486f, 0.00997013f, 0.00938769f, 
    -0.47404701f, -0.08380090f, -0.03209382f, -0.21235068f, -0.42314595f, -0.10543592f, -0.07824851f, -0.16304602f, 
    0.10978980f, -0.08519784f, -0.08544839f, -0.09746179f, -0.17238055f, -0.02816735f, -0.05498882f, 0.19459875f, 
    0.00447693f, 0.06955646f, 0.05857962f, 0.09695508f, -0.04786981f, -0.08948853f, 0.02794160f, 0.06304382f, 
    -0.21778551f, 0.00636570f, 0.07752050f, 0.13990252f, -0.00888093f, -0.03352963f, 0.01302502f, -0.09008946f, 
    0.06731474f, 0.11961869f, -0.04144647f, -0.03468673f, 0.00980722f, 0.04603509f, -0.02039545f, -0.01894247f, 
    0.11900141f, -0.09420119f, 0.08937795f, 0.00281388f, 0.01294318f, -0.21348202f, 0.09571502f, -0.05169662f, 
    -0.12259748f, -0.10989437f, -0.01863618f, -0.03423270f, -0.03757123f, -0.11573975f, -0.03850865f, -0.02770087f, 
    0.03473342f, 0.03596193f, 0.02372859f, 0.05431975f, 0.06734045f, 0.02597684f, 0.05704204f, 0.02229956f, 
    -0.00792820f, -0.15212560f, 0.05678283f, 0.02814494f, -0.07187828f, -0.00577240f, -0.01839241f, 0.08512494f, 
    -0.03678321f, -0.04558866f, 0.01536586f, -0.04165723f, 0.06561922f, -0.03525422f, 0.01706510f, -0.03184221f, 
    -0.01941585f, 0.18287030f, 0.04555012f, 0.10175932f, -0.18962193f, -0.08857373f, -0.13929580f, 0.01340158f, 
    -0.10631196f, -0.02881248f, -0.10564537f, -0.08380865f, 0.14186972f, 0.07050225f, -0.05143110f, 0.01277858f, 
    0.02241806f, 0.06382494f, 0.05787582f, -0.05066760f, 0.15491496f, -0.03798603f, 0.14998448f, 0.04243907f, 
    0.52114671f, -0.51951343f, 0.20450233f, -0.21694990f, -0.08072046f, 0.01600163f, 0.10611467f, 0.16067985f, 
    0.13156928f, -0.05399071f, 0.02281759f, -0.01343588f, -0.12128711f, 0.00237385f, -0.27510482f, -0.07119567f, 
    -0.06727692f, 0.10681906f, -0.03323088f, -0.18059915f, -0.14569777f, -0.18168271f, 0.19943027f, 0.01599667f, 
    0.03928124f, -0.05495683f, 0.07126474f, 0.05109898f, 0.00747335f, -0.01883676f, 0.01134360f, 0.01766069f, 
    0.00366075f, 0.07662003f, 0.00365327f, -0.12786187f, 0.07823224f, 0.04109537f, 0.00223468f, 0.05562407f, 
    -0.30144510f, -0.24517548f, -0.11870089f, -0.07235453f, 0.02130128f, 0.10586298f, 0.11369149f, 0.11470941f, 
    -0.04666480f, 0.07557020f, -0.01053680f, -0.00166503f, 0.06944507f, 0.13812970f, 0.05188800f, 0.03327198f, 
    0.00249158f, -0.01658177f, 0.06792781f, 0.03979638f, 0.44925126f, 0.09163270f, 0.39886418f, 0.24361317f, 
    -0.03867663f, 0.04517182f, 0.03947970f, -0.18569426f, 0.11066168f, 0.02404482f, -0.03822960f, 0.03729797f, 
    0.01699479f, 0.08787736f, 0.05855015f, -0.08693480f, 0.08282893f, 0.07818975f, 0.14074017f, 0.08263233f, 
    -0.26999429f, 0.06832844f, -0.20852137f, 0.03185859f, 0.14990087f, -0.00627189f, 0.04799257f, -0.09524777f, 
    0.04341033f, 0.10321100f, 0.04778086f, 0.09871439f, 0.02713790f, -0.01600654f, -0.00255684f, 0.07036602f, 
    -0.06421185f, -0.05337344f, 0.01030127f, -0.03498950f, -0.14166199f, 0.02562113f, 0.01516707f, 0.15148817f, 
    -0.08354422f, -0.00875128f, -0.02775481f, 0.02113950f, -0.03497929f, -0.03220873f, -0.00350657f, 0.02566056f, 
    -0.03175756f, -0.00992128f, -0.01059442f, 0.05595956f, -0.15252101f, -0.08459037f, 0.06156682f, -0.07475389f, 
    -0.08845401f, -0.01595607f, 0.03910055f, 0.01962982f, -0.05860784f, 0.00887302f, -0.08198254f, 0.14466122f, 
    -0.13991603f, -0.16854288f, -0.02433908f, 0.06180581f, 0.02424244f, -0.00573629f, -0.02948461f, 0.00947757f, 
    -0.13085535f, -0.16451067f, -0.06947762f, -0.14013094f, -0.19780418f, 0.24623686f, -0.04671342f, 0.28117448f, 
    -0.11766438f, 0.04923106f, -0.02526060f, 0.07016659f, 0.06979728f, 0.00224334f, -0.11165678f, -0.07459788f, 
    -0.11243691f, -0.00535899f, 0.01188457f, 0.06458598f, -0.08006280f, 0.05012855f, 0.14443763f, -0.00816577f, 
    0.34310839f, -0.06289766f, 0.22473197f, 0.09952204f, 0.13555358f, 0.06507014f, 0.00848697f, -0.29922742f, 
    0.22576600f, 0.11435559f, -0.06204644f, 0.08837511f, -0.01053177f, 0.02624474f, -0.03767153f, 0.00389585f, 
    0.03240436f, -0.10039733f, 0.02414176f, 0.07940381f, -0.15545079f, -0.15140593f, -0.36487639f, 0.26488656f, 
    0.05176750f, -0.06015250f, -0.05800774f, 0.02840801f, 0.00077547f, -0.07327200f, -0.10217137f, -0.02140501f, 
    -0.12707879f, -0.09998826f, -0.01118459f, 0.03104826f, -0.09357758f, -0.04238001f, 0.03729734f, -0.11486897f, 
    -0.02486968f, 0.01522257f, 0.10616463f, 0.03325535f, -0.17226507f, -0.12970294f, -0.04254383f, -0.12684709f, 
    -0.11647181f, 0.04193758f, -0.08178590f, -0.07836047f, -0.04138310f, -0.11256336f, 0.08607112f, -0.01710810f, 
    -0.12656172f, -0.06034169f, -0.13328381f, -0.01017724f, 0.01606015f, -0.17570885f, -0.25225320f, -0.08007786f, 
    0.10801110f, -0.12589917f, -0.31012952f, -0.02175377f, -0.05906431f, -0.18375038f, -0.02082869f, 0.06537369f, 
    0.04876023f, -0.05163976f, -0.00405610f, 0.10209171f, -0.09058837f, -0.06054682f, 0.13795394f, 0.05959119f, 
    -0.31905818f, -0.05216594f, -0.00927548f, 0.05938078f, -0.15738018f, -0.09952846f, 0.09655727f, -0.01793407f, 
    0.05791737f, 0.04571551f, -0.08965686f, -0.09305215f, -0.03577438f, 0.00214490f, 0.10395575f, 0.03772212f, 
    -0.06011896f, -0.00656194f, -0.07427279f, 0.02329949f, 0.11532138f, 0.09949357f, 0.04860149f, 0.10396507f, 
    -0.03951241f, -0.04118834f, -0.05718802f, -0.04966930f, -0.04498692f, -0.00955793f, 0.00541333f, -0.03437487f, 
    -0.01297967f, -0.08036507f, -0.04437659f, 0.11802538f, -0.03797052f, 0.06276709f, 0.11067866f, 0.08373976f, 
    -0.48674440f, -0.35757923f, 0.04528033f, 0.37017626f, -0.24251305f, -0.00874927f, 0.07838190f, 0.01572526f, 
    0.12581511f, 0.06590755f, -0.13739042f, -0.04984341f, 0.07522984f, 0.19689190f, -0.00806517f, -0.06806488f, 
    -0.08536506f, 0.18627392f, 0.02324164f, -0.06517667f, 0.20990148f, -0.18328032f, 0.31799310f, -0.11558015f, 
    0.19489263f, 0.12557361f, 0.21216039f, -0.06858639f, 0.03071508f, 0.03762870f, 0.00552974f, 0.04998332f, 
    -0.05217133f, 0.04340115f, 0.00538497f, 0.03977904f, 0.15642360f, 0.05829402f, -0.04032868f, -0.06124093f, 
    0.07514721f, -0.25730997f, 0.30996874f, -0.19284815f, 0.04014445f, 0.22622181f, 0.25927246f, -0.05028053f, 
    -0.04175410f, -0.00691929f, -0.02279026f, 0.03960537f, 0.10863194f, 0.01347152f, 0.03774890f, -0.10098891f, 
    0.09094542f, 0.10035389f, -0.07774705f, 0.04246627f, -0.23811567f, -0.17442292f, -0.02009080f, 0.11382066f, 
    0.03884613f, -0.04694971f, -0.02081495f, -0.06738183f, 0.06401593f, 0.07962521f, -0.01226805f, 0.04359841f, 
    -0.18932578f, -0.12641884f, -0.08088289f, -0.02030816f, -0.09941469f, -0.05603627f, -0.07538554f, -0.12905312f, 
    0.20701964f, -0.04713752f, 0.03647489f, -0.09025767f, 0.02007936f, -0.05453064f, 0.04564429f, -0.06771014f, 
    0.00421118f, -0.04788500f, -0.05233844f, 0.03875699f, -0.03804430f, -0.04592680f, -0.03968825f, 0.05954155f, 
    0.00326748f, -0.02136587f, 0.00665191f, -0.10877139f, -0.01737346f, -0.17493044f, 0.03616785f, 0.14186543f, 
    -0.07314219f, 0.07380287f, -0.34034079f, -0.01106643f, 0.01899211f, -0.16038489f, -0.01693800f, 0.02828139f, 
    -0.02347021f, 0.04391447f, 0.03649495f, 0.04927084f, -0.01268147f, 0.07866583f, 0.08494163f, -0.08407672f, 
    -0.82566458f, 0.25769767f, -0.35164648f, 0.18820906f, -0.00876735f, 0.05418987f, -0.06108255f, 0.14678553f, 
    -0.09844501f, -0.07283974f, -0.01726464f, -0.11093282f, -0.09307418f, 0.07465410f, -0.04778506f, 0.12481169f, 
    -0.05217047f, 0.16753207f, 0.05427314f, 0.01436811f, 0.47022706f, -0.28438747f, 0.21510234f, -0.01199853f, 
    0.07329202f, -0.05191568f, -0.00489320f, -0.19590937f, 0.05280308f, -0.21036538f, -0.13592808f, -0.06696369f, 
    -0.08283231f, -0.06413755f, -0.08614942f, 0.12696385f, 0.00881263f, -0.00091860f, 0.04079916f, -0.04412897f, 
    0.11858709f, -0.15419540f, -0.29639414f, 0.28626850f, 0.04899301f, -0.07786781f, 0.11719717f, -0.08827168f, 
    0.14014421f, 0.00305211f, -0.20860465f, -0.03243108f, -0.02161045f, 0.10999704f, -0.04127389f, -0.00228191f, 
    0.03919324f, 0.07579502f, -0.14604998f, 0.00357345f, 0.04293343f, 0.03877075f, -0.04459831f, 0.00753857f, 
    -0.06866103f, -0.04690742f, 0.05632399f, 0.01670641f, 0.05759604f, -0.03400667f, -0.08951722f, 0.01109092f, 
    0.05001895f, 0.00360014f, 0.01098859f, 0.00637241f, -0.01463945f, -0.01600649f, -0.15162739f, -0.06186672f, 
    -0.47608665f, -0.25045225f, -0.16504337f, -0.33721644f, 0.29349381f, -0.04664539f, 0.11976973f, 0.15504149f, 
    -0.04827210f, 0.15260099f, -0.15266912f, 0.14646116f, 0.02484856f, 0.07896499f, 0.08152250f, 0.10736360f, 
    0.10729150f, 0.03633511f, -0.09122447f, 0.09023222f, -0.19287233f, -0.04047950f, 0.00850843f, 0.05888394f, 
    -0.17414498f, 0.03270150f, -0.05346244f, -0.00520932f, 0.02315413f, 0.02330130f, -0.14019129f, 0.01751149f, 
    0.04230678f, 0.02703414f, -0.07182422f, -0.06037215f, -0.07287806f, -0.01178791f, 0.00603501f, -0.02084450f, 
    0.27036592f, 0.10121609f, 0.16375707f, 0.09641906f, -0.29631394f, -0.10374922f, -0.03958990f, 0.00448708f, 
    -0.07626453f, 0.01646225f, -0.06915372f, -0.01014189f, 0.06752428f, 0.03499038f, -0.08144856f, 0.07289107f, 
    0.09275630f, 0.17161526f, 0.06554617f, -0.00860995f, -0.12609835f, 0.02322735f, 0.03697475f, 0.14395037f, 
    0.01992056f, -0.05166207f, 0.03149113f, -0.00391049f, -0.10887446f, 0.00213046f, 0.02492508f, 0.03996570f, 
    -0.05211696f, 0.03286664f, 0.03486969f, -0.16215254f, -0.21491542f, 0.05241309f, -0.07065270f, -0.16293047f, 
    0.04742003f, 0.14972992f, 0.07185777f, 0.05185752f, -0.19824772f, -0.06962293f, -0.03980329f, 0.05802882f, 
    0.06678735f, -0.02545573f, -0.06835643f, -0.04458125f, -0.01321682f, -0.04371271f, -0.06852076f, 0.10959006f, 
    0.01959955f, -0.01235349f, -0.06938767f, -0.02864007f, -0.34737509f, -0.17640589f, -0.27773780f, 0.24395025f, 
    -0.13403152f, -0.06821539f, 0.02357920f, 0.00527059f, 0.15247670f, 0.02239745f, 0.00710054f, -0.04361558f, 
    -0.08299638f, -0.12056768f, -0.01258324f, -0.00187508f, -0.07557482f, 0.03055791f, -0.09572832f, -0.05716825f, 
    0.19514969f, -0.34765002f, 0.13694817f, -0.55138457f, 0.12651943f, -0.13974814f, -0.29491720f, -0.06743264f, 
    0.17870338f, -0.11145958f, -0.03406216f, 0.00891900f, 0.06033558f, -0.02700093f, -0.05092042f, 0.12038172f, 
    0.06828140f, -0.00674774f, 0.16427927f, -0.05191848f, 0.09246996f, -0.05812714f, -0.00121915f, 0.09791186f, 
    0.14179464f, -0.08609568f, 0.16593769f, -0.04554066f, 0.03817366f, -0.03580890f, -0.00435571f, 0.16106050f, 
    0.04883900f, -0.00097251f, 0.10214408f, -0.09246425f, -0.20524801f, 0.04807187f, -0.15554461f, -0.00005509f, 
    -0.23901019f, 0.01698026f, -0.15135764f, 0.01378460f, -0.06664392f, -0.01110926f, 0.05598201f, -0.00215740f, 
    0.03972638f, 0.01968431f, -0.07492030f, 0.01226673f, 0.05071357f, 0.07313117f, 0.00568743f, 0.02630985f, 
    0.00167204f, -0.05608409f, -0.01537178f, 0.05969534f, 0.02193775f, 0.03423538f, 0.01757422f, -0.06827570f, 
    0.09534619f, -0.02607740f, 0.06048310f, 0.04448048f, 0.02992979f, 0.02911575f, -0.06438621f, 0.06898119f, 
    0.02107519f, -0.01229655f, -0.03723723f, 0.09554171f, 0.03890763f, 0.01302843f, -0.03263889f, -0.03103409f, 
    -0.01449085f, -0.27044934f, -0.01655321f, 0.01142977f, -0.18452941f, 0.01807306f, -0.00484809f, -0.06698398f, 
    -0.01454996f, -0.12105352f, 0.05457613f, -0.00848115f, 0.02682918f, -0.10522672f, -0.03318897f, 0.01540153f, 
    -0.04666388f, -0.00011823f, -0.00452111f, -0.01437235f, -0.34224930f, -0.42922699f, 0.21989290f, -0.03782593f, 
    -0.38782910f, 0.07499838f, -0.01598357f, -0.02130291f, -0.05104573f, 0.08368637f, -0.11360706f, -0.18955430f, 
    0.03378146f, -0.06956964f, 0.00370088f, -0.00954191f, -0.02701067f, -0.04313635f, 0.06151054f, -0.03054902f, 
    -0.15081853f, -0.20514794f, -0.11999469f, 0.08945681f, 0.00276054f, 0.05910499f, 0.00611660f, 0.03683069f, 
    0.01743148f, -0.05465962f, -0.06407912f, 0.00969133f, 0.04531743f, -0.00069694f, -0.00370754f, 0.14099869f, 
    -0.03346361f, 0.06019070f, 0.11791530f, -0.06248875f, 0.03042700f, 0.14482036f, 0.17174068f, 0.22486503f, 
    -0.13414809f, 0.07480949f, -0.04832931f, 0.04624739f, 0.11617258f, -0.09157465f, -0.01487152f, -0.06434602f, 
    -0.04859383f, 0.04932997f, -0.01884999f, 0.07483941f, -0.00110986f, 0.01197397f, -0.05549570f, -0.03702079f, 
    -0.04713683f, -0.01916674f, 0.02341386f, 0.10868192f, -0.05334232f, -0.06046370f, 0.01464846f, -0.00356182f, 
    0.10813700f, -0.00753358f, -0.09207720f, -0.06556924f, 0.02010581f, -0.00646763f, -0.13986881f, 0.05474389f, 
    0.03722735f, 0.06957917f, -0.05973322f, 0.01602978f, 0.30276030f, 0.11184390f, 0.28308111f, -0.04855630f, 
    -0.16134001f, -0.03854151f, 0.01942860f, -0.13658528f, -0.01883263f, -0.08277074f, -0.10177597f, 0.00374497f, 
    0.04611255f, 0.05059814f, -0.00579865f, -0.05479577f, -0.03146163f, -0.06296981f, -0.00562887f, 0.08458964f, 
    0.41763261f, 0.01407511f, 0.34720889f, -0.16167320f, 0.10270940f, 0.12003218f, 0.11083233f, -0.07933846f, 
    0.16624197f, 0.01174560f, -0.07723178f, 0.08995917f, 0.06669109f, 0.13183814f, -0.04867867f, -0.02894199f, 
    0.06230962f, -0.07741889f, -0.13222837f, 0.14769427f, -0.40838113f, 0.06651746f, -0.28948730f, 0.05947750f, 
    -0.18794551f, 0.02507594f, 0.01460923f, 0.03302997f, -0.02725605f, 0.05583863f, -0.12331804f, -0.05940161f, 
    0.07058661f, 0.00106538f, -0.05983288f, 0.02192202f, -0.00856877f, -0.02781546f, 0.03360253f, 0.01987960f, 
    0.11284667f, 0.13484469f, 0.06744166f, 0.00914338f, -0.10770931f, 0.02303072f, 0.06377231f, -0.04382839f, 
    -0.04437666f, -0.03833537f, -0.10208417f, 0.03422006f, -0.00937749f, 0.04773706f, -0.05153060f, -0.02631197f, 
    -0.02689290f, 0.02967359f, 0.04039454f, 0.02498976f, 0.13979852f, -0.19968025f, 0.18821195f, -0.20872352f, 
    -0.10849734f, -0.09357306f, -0.15932798f, 0.02031764f, 0.03876714f, -0.04421651f, 0.01316390f, 0.05689305f, 
    0.09657656f, -0.01265328f, -0.01752714f, 0.00687723f, 0.01664961f, 0.04709164f, 0.08177952f, -0.01294044f, 
    0.13631810f, 0.07275788f, 0.11127590f, 0.02284214f, -0.10686285f, -0.12432480f, 0.07883318f, -0.01910597f, 
    -0.09227268f, -0.05514144f, -0.12788506f, 0.07753675f, -0.06407927f, 0.12975240f, 0.03810131f, -0.04960914f, 
    -0.07005054f, -0.00845324f, -0.03136083f, -0.07038116f, 0.48754090f, -0.05106058f, 0.41122252f, 0.09528510f, 
    -0.03652392f, -0.02048179f, 0.05476166f, -0.19402863f, 0.16515900f, -0.03583489f, -0.13345176f, 0.04960692f, 
    -0.01224221f, -0.01385153f, 0.03760684f, -0.04522484f, 0.15299225f, 0.05997222f, 0.11074315f, -0.01544227f, 
    -0.05200052f, -0.01645057f, 0.03985864f, -0.00225867f, -0.03216447f, 0.04604721f, -0.02333543f, 0.16985232f, 
    -0.07100864f, -0.12307344f, -0.00461846f, -0.01382731f, 0.05704446f, -0.01669662f, 0.11357170f, 0.07845824f, 
    -0.03511698f, 0.00150016f, 0.08854215f, -0.07449797f, -0.01553052f, -0.05766129f, -0.07556540f, -0.03915694f, 
    -0.02599821f, -0.03073832f, 0.03040295f, -0.05411783f, 0.02091300f, -0.06382332f, -0.10221817f, -0.05901933f, 
    0.06538311f, 0.02694490f, 0.00771644f, 0.05656515f, -0.00788670f, 0.04831896f, -0.02074094f, -0.03033341f, 
    0.04724371f, 0.07329644f, 0.00921742f, 0.13475423f, -0.10664275f, -0.05694359f, 0.02915010f, 0.04609308f, 
    0.02754224f, -0.00832941f, -0.10175721f, -0.03595314f, -0.01205433f, 0.02061459f, -0.04436732f, 0.03758142f, 
    0.03819431f, 0.01854460f, -0.05693628f, -0.06300664f, -0.47132137f, -0.16047935f, -0.26942497f, -0.00777560f, 
    0.18336767f, 0.03364755f, 0.03274684f, 0.04211713f, -0.12129464f, -0.02883483f, -0.06566991f, 0.02544996f, 
    -0.02811744f, 0.01892558f, 0.13081895f, 0.01708993f, -0.01160346f, 0.12659137f, 0.15853453f, 0.01349861f, 
    0.24349087f, -0.13348995f, 0.14967029f, -0.02455940f, 0.22050673f, 0.08094107f, 0.11975046f, -0.00467362f, 
    0.06291870f, -0.14720626f, -0.00147510f, -0.14050834f, 0.07090724f, 0.04433118f, 0.00788227f, -0.12353849f, 
    0.01847494f, -0.02757946f, -0.04745058f, 0.05021283f, -0.30963412f, -0.08546481f, -0.26561072f, 0.13137221f, 
    -0.37267891f, 0.00978569f, 0.10412172f, 0.07191303f, -0.11051352f, -0.00410374f, -0.01998112f, 0.02363543f, 
    0.13240874f, 0.10420414f, 0.01699363f, 0.03162092f, 0.11120533f, 0.04960173f, 0.06495377f, 0.10007538f, 
    0.16001628f, -0.27603674f, -0.00535105f, -0.12002618f, 0.13243440f, 0.00310179f, -0.11540981f, -0.11135807f, 
    -0.11360434f, -0.16953669f, 0.01863686f, -0.00936025f, -0.03120532f, 0.01029228f, -0.07136174f, 0.04915917f, 
    0.00785098f, 0.01412948f, -0.07064997f, -0.15141201f, -0.31288514f, -0.27257746f, -0.00524547f, 0.26637626f, 
    -0.24210332f, -0.04240682f, -0.11675155f, 0.10517101f, 0.06275549f, 0.30247569f, -0.05547486f, -0.08309834f, 
    -0.11006917f, -0.09876306f, -0.10452925f, 0.03938306f, -0.01229831f, 0.15792616f, 0.09001634f, -0.17478208f, 
    0.13243479f, -0.11175504f, -0.07821210f, 0.06605174f, 0.12539232f, -0.04447567f, 0.07120495f, -0.14500386f, 
    0.01240993f, -0.08072514f, -0.17177202f, 0.02196311f, 0.00958696f, 0.01712019f, -0.00244865f, 0.06921501f, 
    0.00118189f, -0.00717110f, 0.00819741f, 0.00176079f, -0.26469681f, -0.15938109f, -0.27355799f, 0.37769896f, 
    -0.04729408f, -0.08789884f, 0.20278175f, -0.00737651f, 0.22087748f, -0.02046041f, -0.12735520f, -0.05718816f, 
    -0.03689807f, -0.06839447f, 0.11819302f, -0.00425400f, -0.08023109f, 0.11241172f, 0.04288483f, 0.12275342f, 
    -0.50189614f, -0.34651133f, -0.21410698f, 0.11358731f, 0.03505331f, -0.12230162f, -0.16263092f, -0.04854736f, 
    0.05218410f, -0.00308215f, 0.00652152f, 0.06061749f, 0.01095328f, 0.00091551f, 0.05153519f, 0.14287652f, 
    -0.01818961f, 0.18308817f, 0.13790667f, -0.00664074f, -0.04513518f, -0.14662844f, -0.15997572f, -0.05405316f, 
    -0.33284718f, -0.06972845f, 0.02979223f, -0.04376424f, -0.05311279f, 0.05018146f, -0.06216922f, 0.08110360f, 
    0.14925516f, 0.05446646f, -0.01636900f, -0.00999936f, 0.01959960f, 0.08791663f, 0.04656032f, 0.03048744f, 
    -0.07150493f, -0.61192620f, 0.15354216f, -0.14474075f, 0.30183482f, 0.08579437f, 0.11860530f, 0.17221773f, 
    0.01571498f, 0.05672471f, 0.12945963f, 0.01698392f, 0.04905274f, 0.10969597f, 0.15694411f, -0.02029506f, 
    0.10569911f, 0.09092856f, -0.04167047f, 0.03216406f, -0.04613264f, -0.43661201f, -0.24138281f, -0.12373158f, 
    -0.04725582f, -0.10936207f, -0.40160209f, 0.04823617f, -0.35471699f, -0.17896956f, -0.04136281f, 0.00122639f, 
    0.01538098f, -0.04446369f, -0.09279082f, 0.02124345f, -0.08079002f, -0.01022301f, -0.02572974f, -0.11451102f, 
    0.09582687f, -0.06341600f, 0.03730956f, 0.15991133f, -0.01224506f, -0.00510779f, 0.05444569f, -0.08100163f, 
    0.08582312f, -0.06400061f, -0.01676160f, 0.03955125f, -0.03624330f, 0.04542742f, 0.00480881f, 0.02188763f, 
    -0.06244484f, 0.06708131f, -0.02623874f, -0.08440360f, 0.08163521f, 0.05395738f, 0.09502274f, 0.02338309f, 
    -0.04976152f, 0.03988666f, 0.05299816f, -0.03898667f, -0.02872967f, 0.00684250f, -0.04176185f, 0.00490871f, 
    -0.04563722f, -0.04975221f, -0.01368702f, -0.00312109f, 0.01516863f, -0.03431567f, 0.01028742f, -0.05174051f, 
    0.11246546f, -0.01252616f, 0.03865986f, 0.22692658f, 0.12536815f, -0.08632395f, 0.11832569f, -0.02079404f, 
    0.06463322f, 0.07857801f, -0.09914736f, 0.01613613f, -0.02539741f, 0.04282644f, 0.06288186f, -0.04217635f, 
    0.01910744f, 0.03403207f, -0.00699669f, 0.00663126f, -0.04047044f, 0.07506272f, -0.00795005f, -0.01687232f, 
    -0.08642709f, -0.04185973f, 0.04930919f, 0.02141281f, 0.01544204f, 0.01078996f, -0.02962537f, -0.04696934f, 
    -0.02058526f, -0.03527742f, 0.03839590f, 0.06652242f, -0.04911512f, -0.02501669f, 0.02095239f, -0.10580904f, 
    -0.23996474f, -0.14767262f, 0.02955401f, -0.21641217f, 0.11173388f, 0.09928637f, 0.21383832f, -0.19233491f, 
    0.10884949f, -0.06297833f, -0.14229703f, -0.00319577f, 0.03578015f, 0.05304991f, -0.00502973f, -0.08334664f, 
    -0.02223277f, 0.04712311f, 0.14539339f, 0.08212255f, -0.08046023f, 0.00699193f, -0.06345194f, 0.08564369f, 
    0.06181214f, 0.01441489f, 0.06672246f, -0.00502290f, -0.05158645f, -0.05216334f, 0.01174152f, 0.03096865f, 
    -0.01842444f, -0.01888130f, -0.10899507f, 0.00245911f, -0.00299346f, -0.09185020f, 0.04825651f, -0.04447643f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13780989f, 0.08892417f, 0.02881888f, -0.08627474f, -0.02059925f, 0.03510041f, 0.02193785f, -0.08723617f, 
    0.06366764f, 0.02234302f, 0.00978823f, 0.01024468f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
