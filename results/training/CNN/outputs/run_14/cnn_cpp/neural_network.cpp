#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37669221f, -0.81468296f, -0.64728171f, -0.28890052f, -0.49917591f, -0.49409825f, 0.03450819f, 0.20611072f, 
    0.22846547f, -0.58373356f, -0.42121926f, -0.43050450f, 0.53882241f, 0.00990007f, -0.36983103f, -0.36104429f, 
    0.17626880f, -0.02232446f, -0.45143175f, -0.26109871f, -0.16576923f, -0.53099459f, -0.09438046f, 0.00615524f, 
    0.30248362f, 0.62844396f, -0.51710010f, -0.97259176f, 0.31721133f, -0.14663604f, -0.17640384f, 0.12732014f, 
    0.22903681f, -0.36457390f, 0.22457127f, 0.46685714f, 0.12443001f, -0.84736961f, 0.28425765f, -0.68360400f, 
    0.56670684f, -0.42525238f, -0.30971649f, 0.24107112f, 0.04295488f, 0.63987631f, 0.79480344f, 0.81322604f, 
    -0.71069205f, 0.63295597f, -0.28772476f, -0.03957784f, -0.10919810f, -0.10464443f, 0.55166161f, 0.69576102f, 
    0.61988348f, -0.47481591f, -0.74312234f, -0.43088526f, 0.16798128f, 0.13567515f, -0.27207622f, -0.37289065f, 
    0.30251107f, 0.74605167f, 0.73116100f, 0.48068193f, 0.04763496f, 0.42819333f, -0.23861836f, 0.17509504f, 
    0.37103000f, 0.29006973f, -0.11897415f, 0.42166504f, 0.49028897f, -0.55954444f, 0.19120705f, 0.24536230f, 
    0.28942654f, 0.84407473f, 0.03869045f, -0.90330535f, 0.00747490f, -0.69607747f, 0.16899517f, -0.28625381f, 
    0.32632542f, 0.46974927f, -0.04792500f, -0.78512728f, -0.45853773f, 0.63883448f, 0.80796134f, -0.08448981f, 
    0.09057485f, -0.24274527f, -0.19576289f, -0.34524491f, -0.16545783f, 0.57688689f, -0.72106260f, -0.60958803f, 
    -0.60463810f, 0.11550605f, 0.06362532f, 0.27168199f, -0.63867271f, -0.90715587f, -0.57002759f, 0.29438314f, 
    -0.14741787f, 0.59359127f, 0.04433398f, 0.02446466f, 0.18550740f, 1.05517423f, 0.50705469f, -0.28678924f, 
    0.29906175f, 0.49127170f, 0.13231483f, -0.15514301f, -0.11693694f, -0.16020173f, -0.53463560f, 0.05904754f, 
    0.07585905f, 0.64958423f, 0.68511373f, 0.44649917f, -0.11265562f, -0.39515972f, -0.21100773f, -0.56838113f, 
    -0.58648616f, 0.52358770f, -0.45943218f, -0.29108179f, 0.32783023f, 0.04733578f, -0.33387873f, -0.40707704f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42820376f, -0.04246595f, -0.09827928f, 0.06017572f, -0.11422718f, 0.05343104f, 0.14930296f, -0.03913881f, 
    0.34546578f, -0.15102121f, 0.14711113f, 0.30775702f, 0.23198213f, 0.01818112f, -0.11657111f, 0.24245857f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12868351f, 0.01047433f, 0.03949098f, 0.07302880f, 0.14893614f, 0.06562766f, 0.03013967f, -0.00493040f, 
    0.07195415f, 0.04926363f, -0.08832020f, -0.00752235f, 0.11239067f, 0.11594633f, 0.03068049f, 0.02792863f, 
    0.04349183f, -0.00860914f, 0.03716188f, -0.02017143f, 0.16835083f, 0.23458132f, -0.03499159f, 0.03582121f, 
    -0.00969936f, 0.12775142f, 0.18681321f, -0.02467288f, -0.05314476f, -0.00020855f, -0.05140585f, 0.05954154f, 
    0.05924874f, 0.02390121f, -0.02875374f, 0.01679261f, 0.02208222f, 0.07861548f, -0.01545211f, -0.00651321f, 
    -0.08924945f, 0.04398880f, -0.16853538f, 0.02421371f, 0.11259100f, -0.06424190f, -0.10268905f, -0.13685322f, 
    0.03216134f, 0.08999923f, -0.06418651f, -0.00737457f, -0.02847904f, -0.12691934f, 0.03362675f, 0.14425020f, 
    -0.07948648f, 0.04802881f, -0.02815950f, -0.04600318f, -0.31517881f, 0.10002633f, -0.03574355f, -0.05141233f, 
    -0.02437143f, 0.07658385f, 0.11389044f, -0.03889447f, -0.02271752f, -0.14567807f, 0.06627425f, -0.00493084f, 
    0.03120415f, -0.05590716f, -0.09471045f, -0.05901239f, 0.00440555f, 0.05213713f, 0.09443883f, 0.05640777f, 
    0.03085169f, -0.33814380f, 0.06286035f, 0.15530500f, 0.18990231f, 0.14036040f, -0.08153260f, -0.08924783f, 
    0.09297196f, 0.04585758f, 0.01316591f, 0.03388074f, -0.04814290f, -0.04048170f, 0.02539951f, -0.11787924f, 
    -0.08129120f, 0.03868755f, -0.07869940f, -0.02093241f, 0.52649385f, 0.14308329f, -0.07116650f, -0.04830009f, 
    0.07970572f, -0.16915537f, -0.07197785f, 0.02432025f, 0.06577779f, -0.01305407f, 0.01939059f, -0.05903243f, 
    -0.01940440f, -0.04267218f, -0.02452469f, 0.00411286f, -0.01896602f, -0.02878299f, -0.00294475f, 0.04477242f, 
    0.33242503f, 0.08836831f, -0.15165098f, 0.14517206f, 0.21997921f, -0.10629909f, -0.07524628f, 0.01096930f, 
    0.00704491f, -0.03102740f, -0.10136100f, -0.15134959f, -0.08006864f, 0.13108414f, 0.01205624f, 0.04400063f, 
    0.02697513f, -0.06137973f, 0.01091134f, 0.05391753f, -0.33950615f, -0.09350422f, 0.29127046f, -0.05904287f, 
    -0.09437297f, -0.16773011f, 0.04940770f, 0.05446456f, 0.00964066f, -0.02219168f, -0.17202143f, 0.02036135f, 
    -0.05577220f, -0.00655637f, 0.01020038f, -0.00962652f, -0.09052693f, 0.05687558f, -0.05279732f, -0.00873643f, 
    0.04461871f, -0.05560290f, 0.07076821f, -0.03111506f, 0.05698168f, 0.03212183f, -0.08963163f, -0.02847171f, 
    -0.07164281f, 0.04045234f, 0.05113627f, -0.01029741f, -0.10183818f, 0.02371462f, -0.02468365f, -0.09068933f, 
    -0.01837068f, -0.09636974f, -0.04048946f, -0.03846907f, 0.31585303f, 0.07099497f, 0.10893268f, -0.08187933f, 
    0.12711558f, 0.07798789f, -0.12592708f, -0.02847110f, -0.05584216f, -0.07165419f, -0.09447193f, 0.02020474f, 
    -0.04300654f, -0.05262959f, -0.02334600f, -0.08949713f, -0.07288173f, 0.01092516f, -0.22454099f, -0.08174870f, 
    -0.02590557f, 0.17092566f, -0.10172164f, -0.04814570f, -0.15584692f, 0.09842239f, 0.11723035f, 0.00051554f, 
    0.05143344f, -0.08759099f, -0.02687703f, 0.02642297f, 0.00255000f, -0.14562711f, -0.04551037f, 0.02830221f, 
    0.14037883f, -0.00950368f, -0.03285923f, -0.07879943f, -0.15236548f, -0.11016889f, 0.11178123f, 0.04528137f, 
    0.12999569f, 0.04260319f, -0.08013402f, -0.00916833f, 0.00772064f, 0.00263740f, -0.03426870f, -0.03850345f, 
    -0.03100144f, 0.18493810f, 0.02009693f, -0.04745946f, 0.00478695f, -0.05001608f, 0.04802040f, -0.01699784f, 
    0.08815897f, 0.09913655f, -0.03079698f, 0.04368843f, -0.21689531f, 0.10744511f, 0.14758210f, 0.02791912f, 
    0.04562788f, 0.05493851f, 0.05310832f, 0.06211430f, 0.00680552f, 0.00478004f, -0.10894911f, 0.04901775f, 
    -0.00376216f, 0.03515411f, 0.05051495f, 0.01751948f, 0.36669597f, -0.15083922f, 0.19921425f, -0.05441520f, 
    0.12175356f, 0.06899153f, 0.02595184f, -0.02705701f, -0.02164981f, 0.01468707f, -0.00712095f, 0.02629690f, 
    -0.09877144f, 0.10613550f, 0.03369575f, -0.02166258f, 0.08039922f, 0.00256163f, 0.00490008f, -0.00952835f, 
    -0.28106552f, 0.26149118f, 0.19036423f, 0.00452861f, -0.23535949f, 0.12218023f, 0.14909129f, 0.05254104f, 
    -0.00515492f, -0.12895237f, 0.08536635f, 0.17420536f, -0.00700822f, 0.08560728f, -0.06014733f, 0.03272693f, 
    -0.01594962f, -0.00002841f, 0.02645081f, 0.07730652f, -0.17640290f, 0.18661554f, -0.02506256f, 0.15287733f, 
    0.04938051f, -0.04800179f, 0.06260239f, -0.11726020f, 0.12452760f, 0.08058608f, -0.01713122f, 0.08476580f, 
    0.05429361f, -0.01153593f, 0.01095034f, -0.05661524f, -0.09009146f, -0.05064328f, -0.03898867f, -0.06986544f, 
    -0.21859370f, -0.07812559f, -0.23129167f, -0.03977340f, 0.12970693f, 0.09744956f, 0.10834409f, 0.04126185f, 
    -0.10665447f, 0.06679802f, 0.00578661f, 0.04659738f, 0.01157103f, 0.08242001f, -0.01300491f, -0.00615304f, 
    -0.01697587f, 0.10377566f, 0.08407509f, 0.01922847f, -0.15261230f, -0.03855418f, -0.17216809f, -0.25467265f, 
    0.01129757f, 0.07610080f, 0.14955199f, -0.03773197f, -0.08618000f, 0.09505599f, 0.08598214f, 0.18579338f, 
    0.08824508f, 0.07734372f, 0.01139969f, 0.13460730f, 0.05489971f, -0.00846883f, -0.01240597f, 0.09553853f, 
    -0.01747898f, -0.07827199f, 0.06881764f, 0.06311049f, 0.09181640f, -0.01851740f, 0.08304976f, 0.05012019f, 
    0.07878501f, 0.04290432f, 0.10161363f, -0.02985315f, -0.02637971f, -0.09418201f, 0.03730169f, -0.11091395f, 
    -0.07689907f, 0.14297627f, 0.01462773f, 0.01336441f, -0.01282357f, -0.13439435f, -0.04675763f, 0.00055171f, 
    0.01649134f, 0.03996524f, 0.13918242f, 0.01408415f, 0.07915930f, 0.05939810f, 0.03281525f, -0.01974848f, 
    -0.04928343f, -0.00369810f, -0.02497396f, 0.01005019f, -0.02391503f, 0.03341115f, 0.04541863f, -0.05896902f, 
    0.02401591f, -0.03875294f, -0.04018378f, 0.02851027f, -0.01745602f, 0.10079458f, 0.05539729f, 0.03412547f, 
    -0.06881950f, -0.03655699f, 0.06938846f, -0.06697474f, -0.01669032f, 0.09172149f, -0.00525209f, -0.08832185f, 
    -0.07855152f, 0.02210167f, 0.10823784f, -0.03701928f, 0.02985306f, 0.21061584f, 0.34955618f, 0.14783952f, 
    -0.09867921f, -0.00054166f, -0.06579002f, 0.10895405f, 0.04719673f, 0.00589772f, -0.06932871f, 0.00071101f, 
    0.08597133f, -0.07346546f, -0.01719646f, 0.02283657f, -0.09055854f, -0.05319150f, -0.02533799f, -0.09711231f, 
    0.07104604f, 0.23250197f, 0.14214920f, 0.14171217f, -0.09857971f, -0.03524601f, 0.05824769f, 0.14060308f, 
    0.02801944f, 0.11688128f, -0.05784341f, -0.04658178f, -0.00615829f, -0.06405967f, 0.03232331f, 0.05361193f, 
    0.03331405f, -0.02200943f, 0.11986000f, 0.01720577f, 0.08905525f, -0.14778833f, 0.05742711f, 0.21662882f, 
    -0.03878625f, -0.09076194f, -0.01914078f, -0.00451951f, -0.00272076f, -0.00541364f, 0.07942663f, -0.01689359f, 
    -0.02343930f, -0.08619015f, 0.03133936f, -0.03962614f, 0.10721944f, 0.00132946f, -0.13647309f, -0.00751237f, 
    -0.11562090f, -0.00863626f, 0.09516966f, 0.06710829f, 0.16291152f, -0.07328052f, 0.07110374f, 0.06864844f, 
    0.06779224f, -0.00537275f, -0.06615556f, 0.02314437f, -0.01305593f, -0.01980487f, -0.09478667f, 0.04794750f, 
    -0.00310003f, 0.00978913f, -0.11110315f, -0.04119977f, 0.16545330f, -0.00856737f, 0.19872150f, 0.02285824f, 
    -0.07986584f, -0.13546787f, 0.08054648f, 0.01301546f, 0.01395355f, 0.04290329f, -0.06749356f, -0.04193226f, 
    -0.04786106f, -0.04138691f, -0.02573853f, -0.00739174f, 0.02882265f, 0.04361174f, -0.01170570f, 0.00267884f, 
    -0.04840683f, 0.03823451f, -0.28970629f, -0.17273147f, 0.05088029f, 0.07811394f, 0.12314005f, -0.13812526f, 
    0.04351383f, -0.06150684f, 0.06524594f, 0.12588738f, 0.10103726f, 0.03938702f, -0.01981677f, 0.06623062f, 
    -0.02711907f, 0.00065370f, -0.09802447f, 0.11234183f, -0.03982629f, 0.06458087f, 0.02936134f, -0.04314112f, 
    -0.00439540f, 0.10926208f, 0.11584287f, 0.00161035f, -0.00745898f, 0.04002164f, -0.01309683f, 0.04043946f, 
    -0.07885320f, 0.03646449f, 0.11150834f, 0.06644854f, 0.00622409f, 0.08516374f, 0.02127164f, -0.00663867f, 
    -0.06283015f, -0.10036632f, -0.24327350f, -0.20469108f, -0.11940202f, 0.09095921f, 0.09819242f, 0.02821706f, 
    -0.04200776f, -0.02972615f, 0.06557634f, 0.05656266f, -0.00588891f, 0.07885320f, 0.05747300f, -0.06935664f, 
    -0.06513359f, -0.05550335f, 0.02302718f, 0.02278302f, -0.08838324f, 0.16468319f, 0.14113808f, 0.20903106f, 
    0.17458341f, -0.06296765f, -0.08716524f, 0.08685050f, 0.08966227f, -0.00210672f, -0.04529101f, -0.11013020f, 
    0.03290212f, -0.05818610f, -0.00047072f, 0.06020184f, 0.02273786f, -0.05442947f, -0.11871182f, -0.00633405f, 
    0.03019374f, -0.10347096f, 0.01473925f, 0.01673317f, -0.15476134f, -0.01651708f, 0.09345656f, 0.10039456f, 
    -0.01189721f, 0.03363419f, 0.01436992f, 0.04709244f, 0.01811538f, 0.05612972f, 0.05147223f, 0.10790056f, 
    -0.05415862f, 0.01477769f, 0.00578405f, -0.02857810f, 0.12130110f, 0.01474508f, -0.13205989f, -0.07411221f, 
    -0.06778535f, 0.08043667f, 0.06624081f, 0.04375793f, 0.03816245f, 0.01765721f, 0.06662586f, -0.03442983f, 
    0.07653658f, -0.02257128f, 0.06333419f, 0.09515885f, 0.03779219f, 0.07057738f, 0.17902175f, 0.03742469f, 
    0.00501631f, -0.04953413f, -0.00470870f, 0.01910351f, 0.04341252f, -0.00463683f, -0.02864952f, -0.05878523f, 
    -0.04406952f, 0.01856372f, 0.00372219f, -0.03556689f, 0.04277001f, -0.02440681f, -0.05515927f, 0.01047019f, 
    -0.04552325f, -0.05402289f, -0.05958849f, 0.03069047f, -0.05305876f, -0.01214646f, 0.03780480f, 0.00076099f, 
    0.00605156f, -0.03364973f, -0.04097489f, -0.01287662f, -0.05615773f, 0.01622895f, -0.02106266f, 0.02872477f, 
    0.00648424f, 0.01370629f, 0.04837708f, 0.01075255f, 0.03436563f, -0.05305160f, 0.00802151f, -0.01609498f, 
    0.03458620f, -0.02716127f, -0.05292752f, 0.04181869f, -0.05052014f, -0.06212331f, 0.04102100f, -0.00726765f, 
    -0.03639251f, 0.01122751f, -0.00831825f, -0.04615909f, 0.04338573f, -0.04490314f, -0.04915393f, 0.00272250f, 
    -0.03170761f, -0.05857659f, 0.00700456f, -0.01685255f, 0.00837018f, -0.05364796f, 0.02030170f, 0.04296130f, 
    0.02009024f, 0.01151834f, -0.04997170f, -0.01892965f, -0.01442797f, 0.04071797f, -0.01025362f, -0.00247595f, 
    -0.00862415f, 0.01823246f, 0.04222205f, -0.01282311f, 0.03596028f, 0.04042365f, -0.01913228f, 0.00091518f, 
    0.03675917f, -0.02483722f, -0.02401567f, 0.03125358f, -0.05046849f, 0.02893512f, 0.05307638f, -0.05496871f, 
    -0.02470613f, -0.00477793f, 0.01940042f, 0.00587551f, -0.05165798f, -0.03251875f, -0.02175485f, -0.00007635f, 
    0.00222076f, 0.04250360f, -0.04505959f, -0.01636003f, -0.00925322f, -0.03827635f, 0.03150585f, -0.03010890f, 
    0.00540277f, -0.03389153f, 0.02890752f, 0.03154343f, -0.04344611f, 0.04187302f, 0.03594989f, -0.02927254f, 
    -0.06231391f, 0.00946294f, -0.03365767f, 0.00681808f, -0.01882259f, 0.02303784f, -0.01943744f, -0.04701602f, 
    -0.04511619f, 0.00082439f, 0.01763655f, -0.03706855f, -0.05159634f, -0.04385268f, -0.01685633f, 0.04261551f, 
    -0.00650970f, 0.04933248f, 0.02549639f, 0.00124868f, -0.00149455f, -0.00613166f, -0.00164709f, 0.04530796f, 
    0.00427930f, -0.00497092f, 0.04651129f, -0.05101307f, -0.04259006f, -0.02127736f, 0.01478921f, -0.03770181f, 
    0.00509127f, -0.05000838f, 0.01051737f, -0.04037860f, -0.03736165f, -0.05344447f, -0.06800160f, 0.02804084f, 
    -0.03625306f, -0.04999220f, -0.05617194f, 0.01779730f, -0.02394694f, -0.00240037f, 0.00106031f, 0.00990740f, 
    -0.03178959f, -0.01473400f, 0.05470640f, 0.04904078f, 0.02037350f, -0.04717577f, 0.01343654f, 0.01457246f, 
    -0.06861292f, -0.02954657f, 0.02060515f, -0.01249848f, 0.04331174f, 0.04644806f, 0.03537813f, -0.00701933f, 
    -0.05835104f, -0.02436342f, -0.02836984f, -0.01915118f, -0.04116638f, -0.04670440f, 0.03319746f, -0.02112766f, 
    -0.03130360f, -0.00957081f, 0.02688517f, -0.05953110f, 0.01799570f, 0.02529801f, 0.02485056f, -0.05920604f, 
    -0.03661005f, 0.03846886f, -0.04616058f, -0.00209705f, -0.04695520f, -0.02586591f, -0.01389613f, -0.05941556f, 
    -0.04657922f, 0.03841582f, 0.04663952f, -0.02130259f, -0.02852492f, 0.02252275f, -0.03086269f, 0.01597064f, 
    -0.03988128f, -0.02939514f, -0.05884564f, 0.03502959f, 0.04027137f, 0.02698493f, 0.02309655f, -0.00054817f, 
    -0.03706237f, -0.01353045f, -0.03163603f, 0.04444416f, -0.01840216f, -0.01838377f, 0.00054013f, 0.00622436f, 
    0.02483845f, 0.04105907f, -0.02360072f, -0.03866697f, -0.02327496f, -0.02834541f, 0.03823336f, 0.03807271f, 
    0.03709680f, -0.00161548f, -0.01370458f, -0.06493926f, -0.01770689f, 0.01882439f, 0.03813602f, -0.04654991f, 
    -0.03667243f, -0.03302528f, 0.01441464f, 0.02034379f, -0.06255393f, 0.02329133f, -0.04010654f, -0.01216636f, 
    -0.00971134f, -0.01377345f, 0.00867408f, -0.05561309f, 0.01082363f, -0.03451588f, -0.06079031f, -0.03029521f, 
    -0.01853739f, -0.02622781f, 0.02674510f, 0.02363555f, 0.01701850f, -0.03716344f, -0.00947311f, 0.04022222f, 
    0.02988577f, 0.01596461f, 0.03294613f, -0.01247726f, -0.02078137f, 0.04844931f, -0.04824851f, 0.04772596f, 
    -0.05382217f, 0.01033425f, 0.01283532f, -0.00009068f, 0.05446000f, 0.04089119f, 0.04854603f, -0.01412366f, 
    0.01792328f, -0.04993368f, -0.05397592f, -0.03520244f, -0.01296234f, -0.00493425f, 0.00386352f, -0.01356049f, 
    -0.02177904f, 0.00271551f, -0.04012031f, 0.04893148f, -0.03222436f, -0.00813310f, 0.00892697f, 0.02044622f, 
    -0.06013329f, -0.03106330f, -0.03305172f, -0.05107018f, -0.04688044f, 0.04028575f, -0.03824465f, -0.01360722f, 
    -0.04710877f, -0.05433158f, -0.00623059f, -0.00389180f, -0.02731693f, 0.02938000f, 0.02148114f, -0.00689701f, 
    0.01773264f, -0.01575676f, 0.04285184f, -0.01842275f, -0.02054518f, 0.02990822f, -0.03970680f, -0.03870250f, 
    -0.18147622f, -0.20849763f, -0.04770612f, -0.28090096f, 0.06466053f, 0.01124860f, 0.07203875f, -0.02342210f, 
    -0.10842443f, 0.03450810f, -0.02281055f, -0.00824921f, 0.01854981f, 0.02371980f, -0.07279979f, 0.05262762f, 
    -0.03113442f, 0.12161052f, 0.11556333f, 0.08361199f, -0.09530678f, -0.31399626f, -0.03899273f, -0.10583095f, 
    0.10206225f, 0.00641678f, 0.13862592f, -0.04103053f, -0.12163842f, 0.05228896f, -0.02809846f, -0.03694206f, 
    0.02210466f, -0.01880067f, -0.02640111f, -0.01951990f, 0.07832752f, -0.04148164f, -0.06566939f, 0.07958434f, 
    0.20678920f, -0.04571327f, -0.08314986f, -0.22315973f, 0.00348790f, -0.01317316f, -0.01578791f, 0.11043384f, 
    -0.02414347f, 0.04769883f, -0.05327436f, -0.10223179f, -0.03236217f, 0.00819014f, -0.06056242f, -0.00430328f, 
    0.02127464f, 0.16329649f, 0.09142534f, 0.04776903f, -0.21466988f, -0.07537672f, -0.25161746f, -0.15379922f, 
    0.01280835f, 0.04845935f, 0.01706018f, 0.10413881f, 0.00385428f, 0.10539915f, -0.13099255f, 0.06380868f, 
    -0.00763931f, 0.00262438f, -0.13809860f, -0.01654233f, 0.10179976f, -0.12415759f, 0.03489151f, 0.01368294f, 
    0.17420965f, 0.00506495f, -0.08080084f, -0.06040771f, 0.17088827f, -0.01028880f, -0.01125687f, 0.03268590f, 
    -0.12737226f, 0.09405582f, -0.00082148f, -0.18833403f, 0.13081896f, 0.06992737f, -0.06084408f, 0.03957591f, 
    0.01673501f, 0.11544278f, 0.08272111f, 0.08842940f, 0.28522128f, 0.30903381f, 0.23138773f, 0.24429739f, 
    -0.04865366f, 0.23215163f, 0.05753927f, 0.19741939f, -0.05786676f, -0.08580616f, -0.02176288f, -0.02332174f, 
    0.01073475f, 0.19486499f, -0.01624890f, 0.00699991f, 0.07002224f, 0.04463807f, -0.05740273f, -0.03876316f, 
    0.10492359f, 0.26543796f, 0.00991847f, 0.16776200f, -0.02443281f, 0.00374337f, 0.06403967f, 0.13317525f, 
    0.02528887f, -0.11946661f, -0.00883911f, -0.04323702f, 0.07496376f, 0.00952066f, 0.00558319f, -0.02931384f, 
    0.09593266f, -0.04690515f, -0.04097632f, 0.10001097f, 0.14862527f, 0.17390472f, 0.00536533f, 0.16896632f, 
    -0.08321853f, 0.05622349f, 0.21205406f, 0.01845399f, -0.01225471f, 0.10999283f, 0.05957771f, 0.03072368f, 
    -0.02263504f, -0.12312964f, -0.06147777f, 0.00769490f, -0.02782468f, -0.05127857f, 0.00647102f, -0.01296480f, 
    0.12922996f, -0.05602631f, 0.22994263f, 0.16512045f, -0.11764799f, 0.17736344f, 0.22272801f, 0.12805758f, 
    0.04130828f, 0.10898864f, -0.04427743f, -0.00429013f, -0.04568581f, -0.08968630f, -0.02621000f, 0.06973739f, 
    -0.05744739f, 0.00819194f, 0.01545976f, 0.04656591f, -0.39314720f, 0.20755976f, 0.03606876f, -0.21832328f, 
    -0.08888694f, 0.12839495f, -0.11880650f, 0.16233322f, 0.02504933f, 0.04411969f, -0.02426316f, -0.07431185f, 
    -0.13466775f, -0.12991934f, -0.21649423f, 0.06728037f, -0.03567635f, 0.08196764f, 0.02759082f, -0.06499838f, 
    0.13254626f, -0.31725398f, -0.03313143f, 0.01884015f, 0.31846029f, 0.05180383f, 0.02584854f, -0.06562404f, 
    0.08858127f, 0.15007955f, -0.01984564f, 0.00446384f, 0.00381737f, -0.07729836f, -0.00491668f, 0.06062560f, 
    -0.07580286f, -0.08088913f, -0.05928771f, 0.08800899f, 0.16784212f, 0.00652868f, -0.03653121f, -0.09296370f, 
    0.01836952f, 0.03748861f, -0.04743382f, 0.05311197f, -0.03720826f, -0.01647381f, -0.02844216f, -0.02465396f, 
    0.04080513f, 0.05720742f, 0.12423979f, 0.02911478f, 0.04445953f, 0.05756395f, 0.04244500f, 0.00696960f, 
    -0.16727984f, -0.16977978f, 0.01446592f, -0.06325656f, 0.24804591f, 0.02132275f, 0.03004440f, 0.00742649f, 
    -0.05488908f, 0.07071032f, -0.05467523f, -0.08061964f, -0.04276312f, 0.02637702f, -0.08475149f, 0.00075964f, 
    0.02229816f, -0.05603725f, -0.00431282f, 0.06835463f, -0.07285286f, 0.16139343f, 0.14943945f, 0.09854871f, 
    -0.32981619f, 0.05511953f, 0.05937522f, 0.18266074f, -0.08645482f, -0.00937529f, -0.03128411f, -0.11731739f, 
    -0.05379413f, -0.00553587f, 0.06978758f, -0.09024962f, -0.04809735f, 0.15776522f, 0.01167200f, -0.21154684f, 
    -0.02400591f, -0.01583402f, -0.21575174f, 0.01946636f, 0.06918260f, -0.12146956f, 0.00104263f, -0.04216649f, 
    -0.04945847f, 0.20460020f, -0.05118827f, -0.03523358f, -0.03047044f, -0.05483904f, -0.06421518f, -0.08114351f, 
    -0.06565761f, -0.03413501f, -0.20354663f, -0.10556049f, -0.04183524f, -0.09443967f, -0.11295938f, -0.19743355f, 
    0.01358086f, 0.03207789f, 0.03280314f, 0.05233586f, -0.05102679f, -0.05854791f, -0.07352193f, -0.12228389f, 
    -0.00746444f, 0.04880544f, 0.12710285f, 0.05410808f, -0.00129807f, 0.08772194f, 0.00207914f, -0.02391832f, 
    -0.01540873f, -0.10578568f, 0.00796398f, -0.08630172f, -0.17820238f, 0.08280483f, -0.06048142f, 0.09562993f, 
    0.08292179f, -0.04060680f, 0.07118095f, 0.00177095f, 0.12045600f, 0.14076841f, 0.00184678f, 0.08857346f, 
    0.02437467f, -0.07475039f, 0.05227221f, -0.00632674f, 0.07882819f, -0.10873690f, 0.00354610f, -0.11197852f, 
    -0.18281469f, 0.02241931f, -0.03603693f, -0.01721811f, 0.00752815f, -0.04501322f, 0.06869976f, 0.02391553f, 
    0.06530350f, 0.10670885f, 0.05127274f, -0.04572262f, -0.04484003f, -0.00946402f, -0.16203173f, 0.03654511f, 
    -0.08703359f, 0.00719659f, -0.21876210f, -0.03469165f, -0.04660279f, -0.00962887f, 0.00218228f, 0.09587301f, 
    0.10862467f, 0.06554890f, 0.05359869f, 0.03884745f, -0.09680583f, -0.08164451f, 0.04115711f, 0.17076193f, 
    -0.01626146f, 0.04959132f, -0.03469993f, -0.01808703f, -0.27005494f, 0.14063586f, -0.05380947f, -0.16751398f, 
    0.09672172f, 0.00659259f, 0.14056973f, 0.00148199f, -0.03392247f, -0.08821388f, 0.00082065f, -0.08133139f, 
    0.04761391f, -0.03598993f, -0.00515265f, -0.04911031f, 0.03393123f, 0.02508539f, -0.02205565f, 0.00021265f, 
    -0.10323018f, -0.09828286f, -0.13229193f, 0.00802148f, 0.02686366f, 0.06653443f, -0.07253901f, 0.00092674f, 
    -0.09364589f, 0.05557822f, 0.09657606f, 0.10975860f, 0.04914009f, -0.07517084f, 0.01939566f, -0.05019177f, 
    -0.02953776f, 0.09514877f, -0.16261238f, 0.00648076f, 0.32249939f, 0.33466837f, -0.06915876f, -0.03082214f, 
    0.16957508f, 0.06800858f, -0.06992973f, 0.10104463f, 0.07978732f, 0.10395976f, 0.09122378f, 0.11365629f, 
    -0.01865022f, -0.02556505f, 0.02973939f, 0.09890852f, 0.03753752f, 0.12511452f, -0.06042899f, 0.06747592f, 
    0.15996331f, 0.13475014f, -0.07308135f, 0.03472146f, 0.02107576f, -0.02724328f, 0.05045568f, 0.05863583f, 
    0.05861776f, 0.04293760f, 0.05823116f, 0.02266215f, 0.04281433f, 0.09610080f, 0.01924026f, 0.03944473f, 
    -0.00334194f, -0.00910467f, 0.02038159f, 0.01910098f, 0.09151991f, 0.07452733f, 0.13803783f, -0.04337487f, 
    0.16513483f, -0.06714924f, 0.16528796f, 0.09325477f, 0.10093547f, 0.07919215f, -0.07423298f, 0.05114432f, 
    0.05224725f, 0.02712936f, 0.09715830f, 0.08117904f, 0.00362558f, 0.01393031f, 0.04052583f, 0.04755243f, 
    0.28764576f, -0.07909871f, 0.11909974f, 0.04140617f, 0.06557356f, 0.03039518f, 0.04676206f, 0.05790935f, 
    -0.01791892f, 0.11472724f, 0.07645355f, -0.01575697f, 0.10070717f, 0.01503517f, 0.08893082f, 0.07083294f, 
    0.02807091f, 0.00686658f, 0.08767869f, 0.00532453f, -0.11385257f, -0.13896826f, 0.01103403f, -0.08854449f, 
    0.02214672f, 0.17325237f, -0.12644275f, 0.15550147f, -0.00510809f, -0.00982378f, 0.08167429f, -0.01457683f, 
    0.00108176f, 0.00872016f, 0.07107143f, -0.01772900f, -0.02408926f, 0.05892994f, -0.12114699f, -0.08437985f, 
    0.20814042f, -0.15342961f, 0.07608702f, 0.00761038f, -0.14815585f, 0.05677134f, -0.01056474f, -0.01017560f, 
    -0.00723170f, 0.07908386f, 0.02614294f, -0.05376785f, 0.01378926f, -0.02055160f, 0.00498952f, 0.07450595f, 
    0.07458436f, -0.00884668f, -0.05738830f, 0.00418705f, -0.08951580f, -0.17305100f, 0.10271768f, -0.02881480f, 
    0.01943882f, -0.00351652f, 0.10173417f, 0.05467210f, 0.05310310f, -0.00750069f, 0.15342955f, 0.04980749f, 
    0.00702638f, 0.13188018f, 0.08451603f, -0.04329897f, 0.02040929f, -0.01822385f, 0.04255087f, 0.08156000f, 
    0.04053307f, 0.07616030f, -0.01152830f, 0.02304621f, -0.07792580f, 0.01899432f, 0.03499149f, 0.07761827f, 
    0.05749702f, 0.09513126f, 0.07455389f, -0.00817266f, 0.03539646f, 0.10791173f, 0.00811126f, 0.07698808f, 
    0.09405228f, 0.03671161f, 0.01028389f, 0.03704185f, 0.37214482f, -0.00716823f, 0.02439029f, 0.04207254f, 
    0.03946160f, 0.02933151f, 0.02771997f, 0.04612761f, 0.07365308f, 0.09384006f, -0.00070078f, -0.05094245f, 
    -0.05006402f, -0.02621683f, -0.02526653f, -0.08102936f, 0.09304592f, 0.01843646f, 0.02627283f, 0.02341661f, 
    -0.05044346f, 0.06937741f, 0.03132385f, 0.06318293f, 0.13597788f, 0.02250273f, 0.10608702f, -0.04561388f, 
    0.04539132f, 0.09911005f, -0.02622172f, 0.12039203f, -0.02882489f, 0.00495290f, 0.06818286f, 0.00611966f, 
    -0.04609437f, 0.03919880f, -0.02383333f, 0.02307009f, -0.28014323f, 0.09312674f, -0.03957842f, -0.08881081f, 
    -0.14539704f, -0.05321470f, -0.01375414f, 0.01434791f, 0.08243893f, 0.04894099f, 0.04619541f, 0.06505275f, 
    -0.10856153f, 0.06028362f, 0.12701991f, 0.06989491f, -0.05492809f, 0.05839387f, 0.06171738f, -0.03042913f, 
    0.27847335f, 0.24549510f, 0.19637346f, -0.07706210f, -0.04796841f, 0.00791907f, 0.03310690f, 0.11995519f, 
    -0.00134671f, 0.02833796f, -0.00337422f, -0.06042748f, 0.08942347f, 0.09826276f, -0.01479492f, 0.01375886f, 
    -0.02657953f, -0.10374809f, 0.05233845f, -0.00252643f, 0.22761376f, -0.00263433f, -0.00612233f, 0.04089329f, 
    0.03406352f, -0.09251420f, -0.05008804f, -0.02781866f, 0.03796265f, -0.08484203f, 0.07067987f, 0.05169857f, 
    0.01178062f, 0.02883733f, 0.00967629f, -0.02845310f, -0.02689782f, -0.00011216f, -0.04517754f, 0.00930339f, 
    0.16297802f, 0.04161652f, -0.13019674f, -0.09897089f, -0.09567247f, 0.11166915f, 0.09718155f, 0.06116570f, 
    -0.04855018f, 0.09504042f, -0.10989688f, -0.04320941f, 0.07075442f, 0.10479955f, -0.08192555f, 0.02703805f, 
    -0.01385170f, 0.21247950f, 0.07179412f, 0.05529237f, -0.12329065f, 0.17973576f, 0.03053076f, -0.24477722f, 
    0.16885519f, -0.04476915f, 0.03369902f, 0.10718980f, -0.06830256f, 0.11088476f, -0.09085347f, 0.06243803f, 
    0.02445235f, -0.06457474f, -0.02070550f, 0.02220894f, 0.12968491f, -0.03606229f, -0.00514092f, -0.00441758f, 
    0.07744718f, 0.03327337f, -0.08883114f, -0.18325691f, 0.16345340f, -0.04044164f, 0.03453533f, -0.08693018f, 
    -0.15347871f, -0.01091864f, -0.03253048f, 0.01867951f, 0.14946023f, -0.04115603f, 0.04272803f, 0.10406778f, 
    0.11080478f, 0.01241106f, -0.02465857f, 0.21071121f, 0.06805055f, 0.03264376f, -0.05315200f, 0.06821023f, 
    -0.02509310f, 0.18033364f, -0.02600111f, 0.10360581f, 0.01314196f, 0.01681520f, 0.05489198f, 0.02019256f, 
    -0.03142410f, 0.12410061f, -0.01236225f, 0.14179151f, -0.00239065f, 0.00252355f, -0.00880979f, -0.00437143f, 
    -0.14881456f, -0.02718901f, -0.03789838f, -0.09207755f, -0.15089917f, 0.10714892f, 0.01919268f, 0.02122257f, 
    -0.04409331f, -0.03101417f, 0.05575982f, 0.03342672f, 0.08322027f, 0.03426649f, -0.07437710f, 0.02427093f, 
    -0.00123026f, -0.06367725f, -0.04862429f, 0.01787883f, 0.08330200f, 0.24360909f, -0.20426509f, -0.01297499f, 
    0.24684638f, 0.01761571f, 0.04011090f, -0.11020079f, 0.12734519f, -0.04986165f, -0.05765038f, 0.10704281f, 
    -0.00781390f, -0.04686065f, 0.03156052f, 0.09261019f, -0.04130805f, -0.04262794f, 0.03859808f, -0.01675315f, 
    0.18724456f, -0.04743202f, 0.00083624f, -0.00663302f, -0.12588702f, 0.14586487f, 0.06051975f, -0.08931914f, 
    0.02709847f, 0.01643275f, 0.04017157f, -0.09991801f, 0.07946335f, -0.05233220f, 0.09650434f, 0.04364357f, 
    -0.00846714f, 0.01051245f, 0.12038455f, -0.01157658f, -0.16620447f, -0.08464882f, -0.08840474f, -0.07343221f, 
    0.01449322f, 0.06416287f, -0.07177883f, 0.07580575f, -0.01463455f, -0.00979611f, 0.07953992f, 0.05945440f, 
    -0.03437836f, -0.10468069f, -0.07841510f, -0.07012546f, -0.03372692f, 0.00350808f, 0.02900264f, -0.08445964f, 
    0.22270411f, -0.18202452f, 0.06578886f, 0.06306329f, 0.00299169f, -0.10748707f, -0.05747927f, -0.01388257f, 
    0.06717675f, 0.05257884f, 0.09293845f, 0.07146703f, -0.09029009f, -0.02849293f, 0.01467692f, -0.00453349f, 
    0.01704439f, 0.01960729f, 0.06695991f, -0.08120375f, -0.07765634f, -0.09554750f, -0.00948324f, -0.16130953f, 
    -0.12133718f, 0.11583126f, -0.00071426f, 0.04611679f, 0.06164676f, -0.03241060f, 0.11103947f, -0.00057380f, 
    0.02997358f, -0.02958139f, 0.04788663f, -0.03857050f, -0.03164256f, 0.01269131f, 0.05995859f, 0.01210622f, 
    0.01577001f, 0.10484989f, 0.17374471f, 0.13037939f, 0.23303986f, -0.09371676f, -0.14906177f, 0.07350137f, 
    -0.02883937f, 0.04737795f, -0.01061493f, -0.02021168f, 0.04792318f, 0.06149150f, 0.05815614f, -0.09174025f, 
    0.09941812f, -0.04823412f, 0.03158117f, -0.06287057f, 0.09549711f, 0.01514607f, -0.10331595f, 0.08634697f, 
    -0.25940531f, -0.02334649f, 0.07413763f, -0.06751288f, -0.06451750f, 0.05668188f, 0.02273788f, -0.14403315f, 
    0.01329458f, 0.05793147f, -0.04691121f, -0.07886286f, 0.03760453f, -0.08158769f, 0.00705496f, -0.04967873f, 
    -0.03545881f, -0.13914961f, -0.34514222f, 0.01971917f, 0.14520681f, -0.14224243f, -0.01003268f, -0.20465712f, 
    -0.08073721f, -0.02320961f, -0.09987436f, 0.14694758f, 0.01494957f, -0.00914585f, 0.13221943f, 0.03050420f, 
    0.03656930f, 0.01774251f, -0.09206519f, 0.00771344f, -0.06788767f, 0.00788506f, 0.06755598f, -0.10101953f, 
    -0.01049758f, 0.05216608f, 0.02772175f, -0.03757573f, 0.00971450f, 0.00800441f, -0.07086223f, 0.01534808f, 
    -0.10915778f, 0.13226502f, 0.03953935f, 0.00104727f, 0.03076515f, 0.07910520f, 0.01947426f, 0.02661555f, 
    -0.05119703f, -0.04876046f, -0.02649754f, 0.01645762f, 0.01726519f, 0.05039925f, -0.04816705f, -0.06135583f, 
    0.02295606f, 0.03944071f, 0.03002720f, -0.04571691f, 0.03867132f, 0.04841455f, 0.00561088f, -0.05470545f, 
    -0.05014772f, -0.00797835f, 0.02863836f, 0.00230605f, -0.00223114f, -0.03877467f, 0.03883984f, 0.01396111f, 
    -0.05057834f, 0.02498695f, -0.00097144f, -0.02416773f, -0.02358445f, -0.04894947f, 0.04024183f, 0.01577117f, 
    0.05256034f, -0.05726067f, -0.04548530f, -0.05091878f, 0.01113986f, 0.03806224f, -0.04531052f, -0.03084727f, 
    0.01087769f, -0.04172464f, -0.01941415f, 0.01595018f, -0.01444590f, -0.00108582f, -0.01138460f, 0.02733614f, 
    -0.05769295f, 0.01734264f, 0.00105898f, -0.00451597f, -0.01402166f, -0.02938530f, 0.04651527f, 0.05431881f, 
    0.03418060f, -0.03569415f, 0.00869891f, -0.03202515f, 0.02665002f, -0.01321266f, -0.04407541f, 0.02040896f, 
    -0.00129897f, -0.03853968f, -0.01565688f, -0.03983376f, -0.04956185f, -0.04049833f, 0.00588254f, -0.04162963f, 
    0.03620989f, 0.00692400f, 0.02285413f, -0.04881502f, 0.01089426f, 0.04039892f, 0.00066506f, 0.02764514f, 
    0.03414982f, -0.03708690f, -0.04251779f, -0.02354778f, 0.05077675f, 0.03735593f, -0.05308978f, -0.00075112f, 
    0.04441296f, 0.02127315f, 0.03119861f, 0.04608560f, 0.01304839f, 0.03389586f, -0.05183793f, -0.03269570f, 
    0.02757339f, 0.01225235f, 0.01918196f, -0.03647272f, -0.03540714f, 0.04984267f, -0.02211767f, -0.00432891f, 
    -0.04494674f, 0.00982035f, -0.01626658f, -0.04425354f, -0.03330548f, 0.01692467f, -0.04356903f, 0.04006085f, 
    -0.01818791f, -0.00015485f, -0.02773526f, 0.02849836f, 0.04058965f, -0.04695611f, -0.05663876f, 0.01796536f, 
    0.04906621f, 0.04446457f, -0.05368637f, -0.05094176f, -0.01994368f, 0.00412914f, -0.02750613f, -0.01101805f, 
    -0.02531714f, -0.04988595f, 0.04357402f, -0.03410953f, -0.04744010f, 0.00491861f, -0.00832138f, -0.04917594f, 
    0.03004849f, -0.03453778f, 0.00470783f, 0.01552101f, 0.03160761f, -0.05201858f, -0.03088789f, 0.02976847f, 
    0.01957221f, -0.01288218f, -0.00028091f, 0.02608109f, 0.02001974f, -0.03990003f, 0.03910587f, 0.01167783f, 
    -0.00243303f, 0.04251805f, -0.05837575f, -0.05811061f, -0.05099560f, 0.02537687f, -0.01746225f, -0.01795475f, 
    -0.05829428f, -0.06011011f, -0.00233645f, 0.03229714f, 0.02355774f, 0.00501579f, 0.00517439f, 0.03101179f, 
    -0.03841071f, -0.03688587f, -0.01446536f, -0.01003055f, -0.02701310f, -0.02477923f, -0.00196141f, -0.00483932f, 
    0.02229327f, -0.00315201f, -0.03491127f, -0.03117189f, 0.04136013f, 0.00891548f, -0.04256674f, 0.04945362f, 
    -0.02163827f, -0.05639261f, 0.04155426f, -0.02264615f, -0.03412684f, 0.00667896f, 0.00222255f, 0.00743733f, 
    0.04188861f, 0.04935444f, -0.06191944f, -0.04302809f, 0.01024600f, 0.03959827f, -0.04833724f, -0.03928925f, 
    0.01061635f, 0.04749368f, -0.02913530f, -0.02718203f, 0.03356611f, -0.01987457f, -0.03825647f, -0.04687439f, 
    0.02159011f, -0.00447149f, 0.05313675f, 0.05065638f, -0.05463986f, -0.00442420f, -0.05347640f, -0.03306039f, 
    0.04399805f, -0.00124776f, 0.04575338f, 0.03096972f, -0.01703181f, -0.02550529f, -0.03747549f, -0.03488882f, 
    0.01903573f, -0.03412674f, 0.01376441f, -0.02055508f, -0.01035670f, 0.01693816f, -0.05562552f, -0.00815917f, 
    -0.04590762f, 0.04359167f, -0.04759816f, -0.01625874f, -0.01889747f, -0.04133463f, -0.00554691f, -0.03542699f, 
    0.02632731f, 0.03337713f, -0.00448243f, 0.05011078f, -0.02452479f, -0.03545145f, 0.04918706f, 0.00056606f, 
    -0.01500126f, 0.00449477f, -0.00253412f, 0.03973283f, 0.01430679f, -0.05859439f, -0.00800817f, -0.02143746f, 
    -0.02328611f, 0.01350555f, 0.03884535f, 0.01109307f, 0.02873728f, -0.01535054f, -0.04987789f, 0.03235968f, 
    -0.00469082f, -0.02990598f, -0.02861010f, -0.01074844f, -0.04228802f, 0.05967715f, 0.01402113f, -0.04971538f, 
    0.03823331f, 0.02749447f, 0.00807901f, -0.03350763f, 0.02302771f, -0.00336670f, 0.03378172f, 0.02859799f, 
    0.01695539f, -0.04146662f, -0.02285828f, -0.03808133f, -0.02665292f, 0.00483188f, -0.00397025f, -0.02216030f, 
    0.00774870f, -0.01796601f, -0.01883781f, -0.03627633f, -0.05258493f, 0.04165159f, 0.00869589f, 0.01386961f, 
    -0.03096744f, 0.04199200f, 0.04694786f, -0.03312962f, 0.03373269f, -0.04006117f, 0.04348011f, 0.02663008f, 
    -0.02300062f, -0.00249605f, -0.03888293f, -0.02749100f, 0.01622759f, 0.00809948f, -0.02098110f, -0.04259949f, 
    0.03926066f, 0.04299056f, 0.00557137f, -0.03126703f, -0.00078645f, 0.02990696f, -0.05414656f, -0.00249270f, 
    0.22421654f, 0.07842382f, 0.03760300f, -0.04567138f, 0.01421441f, 0.01334589f, -0.13537541f, 0.07701156f, 
    0.08555387f, 0.01233272f, -0.03065629f, -0.08254210f, -0.01040483f, -0.05417684f, 0.00872765f, 0.05613270f, 
    -0.03842995f, -0.04030844f, 0.08092418f, 0.02585437f, 0.31453100f, 0.22797939f, -0.01027150f, 0.10893793f, 
    0.10097866f, -0.00807185f, -0.00150353f, 0.01878532f, 0.09917171f, -0.10881045f, 0.00318546f, -0.07361528f, 
    -0.01896368f, 0.10690965f, -0.03483023f, -0.07824954f, 0.05353534f, 0.04441332f, -0.09367899f, 0.10199274f, 
    -0.05059313f, 0.08392059f, -0.01134221f, 0.12145583f, -0.09070802f, 0.05611022f, -0.00149262f, 0.02537775f, 
    -0.05916994f, 0.11009479f, -0.14856559f, -0.05076408f, 0.05911515f, -0.12229697f, 0.02816500f, 0.10365646f, 
    0.04079437f, -0.01703348f, 0.08835503f, -0.04437658f, -0.03655466f, 0.24190150f, -0.02310154f, -0.07996610f, 
    0.12012284f, -0.02271691f, -0.09245092f, 0.01221155f, -0.09681602f, -0.05247391f, -0.04004857f, 0.03927855f, 
    0.00441377f, -0.00010723f, 0.03121682f, 0.02224645f, 0.05195935f, 0.09358246f, 0.06654992f, 0.05146185f, 
    0.29589394f, -0.20802101f, 0.16793633f, 0.17079307f, 0.18252699f, 0.00232651f, 0.02207556f, 0.09904386f, 
    0.06668776f, 0.03965020f, 0.10347451f, 0.10820586f, -0.04462609f, -0.09496962f, 0.04345178f, 0.04854456f, 
    0.00969895f, 0.05677021f, -0.11437450f, 0.06075002f, 0.16930543f, 0.10956103f, -0.14145435f, -0.12965722f, 
    0.04574338f, -0.07934575f, -0.09552345f, 0.03762600f, 0.03655531f, -0.00889010f, 0.06235712f, 0.05592242f, 
    -0.00484538f, -0.09115112f, 0.02753241f, 0.13029186f, 0.01265410f, -0.03047578f, -0.06387847f, 0.01383133f, 
    0.10983539f, 0.04506164f, -0.09145424f, 0.06427576f, 0.16629174f, 0.03497016f, -0.09481292f, 0.00313135f, 
    0.02969346f, -0.05086134f, 0.09136207f, 0.01508121f, -0.08323900f, 0.01022148f, -0.10408176f, 0.06113537f, 
    -0.10984188f, 0.03123059f, 0.06757059f, 0.06118641f, -0.11865737f, -0.18404756f, 0.17631607f, -0.00924100f, 
    0.10016001f, -0.10863532f, 0.05993446f, 0.03664807f, 0.01855766f, -0.04177234f, -0.00116592f, 0.10869287f, 
    0.09871486f, 0.08050992f, 0.09537109f, 0.03983486f, -0.02228982f, -0.03099798f, 0.05192357f, 0.03310999f, 
    -0.03820803f, 0.00450852f, 0.04665541f, -0.05724632f, -0.04462742f, -0.02580849f, -0.02677209f, -0.08961478f, 
    0.06715507f, -0.06377482f, 0.00142402f, 0.11604677f, -0.10326903f, 0.10360247f, -0.01804542f, -0.04522316f, 
    -0.05749509f, 0.05436676f, -0.04073075f, -0.11716882f, 0.32456219f, -0.13887388f, 0.06568520f, 0.01993704f, 
    0.28580284f, 0.16061774f, 0.05460960f, -0.06085863f, 0.08997702f, -0.01078954f, -0.05577761f, 0.09169524f, 
    0.05409832f, -0.04515616f, 0.08018745f, -0.04015193f, 0.02963630f, 0.15325008f, -0.02470143f, -0.02545667f, 
    0.15362869f, -0.04920825f, 0.05503301f, 0.06417765f, -0.12621626f, -0.03302015f, 0.04041259f, 0.10406099f, 
    0.00624598f, -0.11345144f, 0.00787741f, 0.11877988f, 0.03836771f, 0.01206887f, -0.02995082f, -0.00886654f, 
    0.01651680f, 0.01911039f, -0.01856262f, -0.04634158f, -0.07005926f, -0.09421259f, 0.05209341f, 0.05599333f, 
    0.07542559f, 0.12751731f, 0.05796270f, -0.02481211f, 0.01292062f, 0.05742864f, -0.01135727f, 0.09819369f, 
    -0.06811109f, -0.00011846f, -0.10369965f, 0.08472213f, -0.02955257f, 0.02067106f, 0.19872898f, 0.05281698f, 
    0.27460697f, 0.04469600f, 0.02779145f, 0.03990516f, -0.20796444f, 0.03608599f, 0.04932768f, -0.02168771f, 
    0.04968925f, 0.00542353f, 0.01013459f, -0.05333599f, 0.02942869f, 0.05840497f, -0.05872191f, -0.06784855f, 
    -0.02144320f, 0.04415486f, 0.02304127f, 0.03154596f, -0.15676683f, -0.14776546f, 0.05707191f, -0.05900545f, 
    0.03520226f, -0.12208476f, -0.06061060f, -0.05069335f, 0.14765674f, 0.03269955f, -0.05495933f, -0.02210950f, 
    -0.07320932f, 0.05071714f, -0.10703270f, -0.05383952f, 0.07964934f, -0.04738710f, -0.03489877f, 0.08045568f, 
    0.02917019f, -0.09798561f, 0.04517559f, -0.01485067f, -0.24989823f, 0.03922918f, 0.13149035f, -0.03635349f, 
    0.01351435f, -0.09210898f, -0.12241460f, 0.15397376f, 0.03230773f, 0.02887003f, -0.00187120f, -0.03289482f, 
    0.01851308f, -0.00925940f, -0.03810383f, 0.02698488f, -0.14266849f, 0.13536882f, 0.09056674f, 0.06475033f, 
    0.09844581f, 0.01834475f, -0.00478189f, -0.06332321f, 0.04180510f, -0.00857379f, 0.01822544f, -0.02968497f, 
    -0.05989006f, 0.00055468f, 0.08120546f, 0.09403923f, 0.02171110f, -0.00877000f, 0.12242223f, 0.05696023f, 
    0.09555284f, 0.03172730f, -0.18949784f, -0.08373054f, 0.13366857f, -0.02740615f, -0.02847654f, -0.02204041f, 
    -0.01990923f, 0.06979747f, 0.02123878f, 0.07992827f, 0.05901690f, -0.00891492f, 0.05902715f, -0.00075394f, 
    0.03759486f, 0.05064444f, 0.00536408f, 0.03384650f, 0.02445854f, 0.28461030f, -0.05325828f, 0.02873387f, 
    0.08805120f, -0.12424225f, 0.12153079f, 0.03770566f, -0.06145616f, -0.07731092f, -0.06084390f, 0.05339179f, 
    0.02332137f, -0.06936581f, 0.08124842f, -0.00779944f, 0.03155955f, -0.06577154f, -0.10847948f, -0.14322589f, 
    0.12872753f, 0.22576214f, 0.01665372f, -0.11562739f, -0.00973388f, 0.05268653f, -0.07931618f, 0.04900568f, 
    0.05019028f, 0.00406890f, -0.08312540f, 0.08330969f, -0.20027149f, 0.05036036f, 0.13892709f, 0.02231206f, 
    -0.08134627f, 0.02388773f, -0.07985508f, 0.00536101f, -0.22603221f, -0.02941285f, -0.18369831f, 0.20587979f, 
    -0.02340108f, -0.08989669f, 0.01806678f, -0.04443718f, 0.03015362f, -0.04616446f, 0.00026188f, 0.08977921f, 
    0.04309478f, -0.02821588f, 0.05541373f, -0.07878029f, 0.09301024f, 0.05629336f, -0.22188930f, 0.12156348f, 
    -0.04502413f, 0.19872531f, -0.01349359f, 0.25460938f, 0.15068366f, 0.06757450f, 0.01075162f, 0.13142556f, 
    0.08659705f, -0.00215409f, 0.07368935f, -0.07359686f, 0.03453705f, -0.07330378f, 0.00144038f, 0.08624511f, 
    0.03819554f, -0.08108674f, 0.00658088f, 0.05344632f, -0.04196899f, -0.16012448f, -0.03987575f, -0.06280030f, 
    -0.22656775f, 0.05133995f, 0.09847158f, -0.08625229f, 0.04026473f, 0.00537829f, -0.07482843f, 0.05125010f, 
    0.01550222f, 0.12613937f, 0.04544381f, 0.01717150f, -0.10595245f, -0.02502756f, -0.02484496f, 0.06753962f, 
    0.12743460f, 0.20340879f, -0.12047426f, -0.04469688f, 0.07394863f, 0.10125976f, -0.03068390f, -0.03315314f, 
    0.05167005f, -0.03535859f, 0.01092805f, -0.03900524f, -0.00522454f, 0.19474754f, 0.08128238f, 0.05000308f, 
    -0.01292514f, 0.00123577f, 0.00041333f, -0.04999277f, -0.09265429f, -0.44862297f, 0.05724512f, 0.09026431f, 
    -0.25861335f, 0.07108364f, -0.00746625f, -0.03794616f, -0.03569073f, -0.01497778f, 0.10054807f, -0.01433940f, 
    -0.03422625f, 0.01111881f, 0.01471654f, -0.07943759f, 0.06537583f, 0.18796697f, 0.05350792f, 0.00123373f, 
    -0.04705691f, 0.05499537f, -0.00282204f, 0.11084651f, -0.03154011f, 0.01054470f, -0.00946330f, 0.08107891f, 
    0.09216300f, 0.13176897f, 0.02566219f, 0.00984867f, -0.05101060f, -0.04598760f, -0.02235263f, 0.03979191f, 
    0.13662975f, -0.09499122f, 0.09491635f, -0.02050485f, 0.10327157f, 0.10785028f, -0.06612916f, 0.03362958f, 
    0.43702334f, 0.05748122f, 0.02367820f, 0.01704609f, -0.03522894f, 0.13344130f, -0.01529724f, 0.01161329f, 
    -0.03441650f, -0.01381828f, -0.01833097f, 0.09730200f, 0.05621998f, -0.04906616f, -0.03179061f, 0.12402218f, 
    0.23492675f, 0.15863506f, -0.20176312f, -0.12766065f, -0.00429949f, 0.02655059f, -0.01535382f, 0.06506604f, 
    0.09302320f, -0.10084449f, 0.02266078f, 0.00473879f, 0.03060026f, -0.03981073f, -0.03280564f, -0.03493225f, 
    0.03420635f, -0.05135495f, 0.03892128f, 0.06751809f, 0.29405087f, 0.24879879f, 0.04629052f, 0.18489771f, 
    0.27115241f, 0.03456707f, -0.04620204f, -0.00515268f, 0.03084398f, 0.08482611f, -0.00688494f, 0.06168206f, 
    0.06017607f, 0.12046362f, 0.04808107f, 0.18288346f, 0.09981146f, -0.05567476f, -0.08993856f, 0.09914173f, 
    0.02905248f, -0.10211531f, -0.02152188f, -0.14030944f, -0.15119328f, -0.03669251f, 0.02763027f, 0.05484169f, 
    -0.02290606f, -0.05714324f, 0.01599048f, 0.08535320f, 0.03194390f, -0.01446181f, -0.05006294f, -0.03845683f, 
    0.01457583f, 0.13241379f, -0.08766109f, 0.03889475f, -0.38567898f, -0.08927589f, -0.23361678f, -0.02322361f, 
    -0.03720909f, -0.03593350f, 0.06663327f, 0.09616505f, -0.08193059f, 0.05641237f, 0.06361805f, -0.00261724f, 
    0.02979653f, 0.08960155f, 0.06560012f, 0.00202809f, 0.05777721f, 0.02133933f, -0.02331425f, 0.09851374f, 
    -0.08600410f, -0.13836604f, 0.14776005f, -0.13198783f, -0.30047706f, 0.01684219f, 0.09576966f, 0.09368657f, 
    -0.01772257f, -0.12323132f, 0.00589759f, -0.01657056f, -0.02053386f, -0.11057900f, -0.07426415f, 0.04505178f, 
    -0.02052689f, 0.03490302f, -0.02013875f, 0.01862478f, -0.11535600f, 0.08537369f, 0.05143956f, -0.00398008f, 
    0.15582727f, -0.01455370f, -0.04655988f, -0.05491141f, -0.01371225f, 0.03587739f, -0.02130151f, -0.01475000f, 
    0.06017770f, -0.03280696f, 0.05051051f, 0.01317570f, 0.05201738f, 0.04436203f, -0.06369875f, 0.08531889f, 
    -0.05315389f, 0.04212452f, -0.04751267f, -0.06167909f, 0.00214153f, -0.00836304f, -0.02871934f, 0.02481846f, 
    -0.03374283f, -0.01758850f, -0.03165383f, -0.05278935f, 0.01274426f, 0.01270808f, 0.00522432f, -0.03496327f, 
    -0.04610830f, -0.03378456f, 0.00285330f, -0.02027842f, -0.05349761f, -0.00971329f, -0.00903677f, 0.02907773f, 
    -0.04818232f, 0.00277004f, 0.00149229f, -0.00092923f, 0.05473701f, 0.03993289f, -0.03479925f, 0.01234461f, 
    0.04394764f, 0.04087795f, -0.03912349f, -0.01484026f, -0.03031627f, -0.03603368f, 0.04611177f, 0.02409408f, 
    -0.04805102f, 0.01530174f, 0.04110276f, -0.00687831f, -0.05060043f, 0.02111308f, -0.05225051f, -0.03495212f, 
    -0.02127071f, -0.00942120f, -0.05919637f, 0.01836967f, 0.00872242f, -0.05448422f, -0.02326046f, 0.00075036f, 
    0.01491610f, -0.03094527f, -0.05889633f, -0.04968359f, -0.02610196f, -0.00458937f, -0.05445152f, 0.01382481f, 
    -0.01313763f, 0.04693474f, 0.02330214f, 0.01444162f, 0.02785583f, 0.04407274f, -0.05636791f, 0.01876972f, 
    0.01476575f, 0.03022219f, -0.05493878f, -0.00927655f, -0.03466168f, 0.01193511f, -0.04858582f, 0.01515906f, 
    0.03052745f, 0.02236832f, -0.04201732f, -0.00711598f, -0.02867956f, -0.05600124f, -0.06399822f, 0.00286813f, 
    -0.02760850f, 0.02240198f, -0.02986760f, -0.00026495f, 0.02247996f, -0.03470435f, 0.00050407f, -0.03462304f, 
    0.03678634f, -0.03261221f, 0.03317036f, 0.04559747f, -0.05836518f, -0.02652403f, -0.01660042f, -0.00188956f, 
    0.01166436f, -0.00828526f, 0.00246050f, -0.00807227f, -0.02617337f, -0.06316331f, -0.01312000f, -0.05020553f, 
    0.01103926f, -0.03597760f, -0.05990117f, -0.00509839f, 0.02438827f, 0.02228408f, -0.02786660f, 0.01240166f, 
    0.01380784f, 0.02180232f, 0.03443247f, -0.03657946f, 0.00817711f, 0.00123682f, 0.02325661f, -0.00655317f, 
    -0.02059634f, -0.04691792f, 0.00304477f, -0.01514312f, -0.03461979f, -0.05369136f, 0.01662658f, -0.04329008f, 
    -0.01704836f, -0.01924061f, -0.01588931f, -0.03493098f, 0.01109262f, -0.06272219f, -0.03502838f, 0.04561226f, 
    -0.04762807f, -0.01508681f, -0.06007103f, -0.00421947f, 0.03937441f, 0.03196904f, -0.02097283f, 0.02876042f, 
    0.01569386f, -0.01966036f, 0.04168143f, 0.03495609f, -0.00589762f, 0.00199098f, -0.01525905f, 0.01978425f, 
    -0.03715494f, 0.03459821f, 0.01437730f, -0.01781149f, 0.01731936f, -0.03652350f, -0.05177183f, 0.04583044f, 
    0.00035299f, -0.04756381f, -0.03203225f, 0.00939804f, -0.00543233f, -0.02182326f, 0.00989967f, 0.00325309f, 
    -0.06013809f, -0.01720371f, -0.05567098f, -0.05648925f, -0.03169946f, 0.02937226f, -0.01940754f, -0.02591450f, 
    -0.00637769f, 0.01974927f, -0.01397252f, -0.02698092f, -0.00157355f, 0.02278154f, -0.05830019f, 0.04413677f, 
    0.02839308f, -0.06047667f, -0.04045870f, 0.03239084f, -0.00261532f, 0.04424194f, 0.04026784f, 0.02529808f, 
    -0.02202468f, 0.01875396f, -0.01870378f, 0.02126935f, 0.00725226f, -0.02295001f, 0.03807216f, 0.02173662f, 
    0.03029006f, 0.03946646f, -0.01690235f, 0.02215663f, -0.03900254f, -0.05560390f, -0.03741206f, -0.01410384f, 
    -0.01814243f, -0.05316909f, 0.03641347f, -0.00134148f, -0.02512489f, -0.04418321f, -0.04013328f, 0.02107991f, 
    -0.00268754f, 0.02489166f, 0.04062162f, -0.02931868f, 0.04221155f, -0.04506669f, 0.03941752f, -0.05538679f, 
    0.02363030f, -0.02268744f, 0.00928951f, -0.02472836f, -0.00830738f, 0.01264720f, -0.03978520f, -0.01510215f, 
    -0.06131259f, -0.01821685f, -0.05371074f, -0.01139131f, -0.01884821f, 0.04192229f, 0.02855200f, 0.01075213f, 
    -0.01970238f, -0.01292413f, -0.00171428f, -0.01525335f, 0.00757072f, -0.05209117f, 0.02786535f, -0.06480458f, 
    0.03663810f, 0.02551619f, 0.04346256f, -0.03607788f, 0.03421792f, -0.03584943f, 0.00303463f, 0.05067999f, 
    0.01793814f, -0.04619558f, -0.00387831f, -0.04423451f, 0.01878083f, -0.03885222f, 0.02815242f, -0.04465576f, 
    0.04869791f, -0.00375238f, 0.00540436f, -0.04341679f, 0.02619596f, 0.01618887f, -0.03326721f, -0.03819375f, 
    -0.03340094f, -0.04401282f, -0.04118493f, 0.04522058f, -0.02874896f, -0.05093167f, 0.02370485f, 0.00994276f, 
    -0.04077954f, -0.01133023f, 0.00784418f, -0.00447631f, -0.01350967f, 0.04783652f, 0.01803097f, 0.01170721f, 
    -0.00781791f, 0.03361894f, 0.01752476f, -0.05008249f, 0.01303562f, 0.02144214f, -0.02848339f, 0.03036206f, 
    0.04675594f, 0.03685677f, -0.00868590f, 0.03806116f, -0.01924206f, -0.02732188f, 0.04184677f, 0.01185235f, 
    0.04384140f, -0.03720187f, -0.00482414f, -0.00706960f, -0.00004318f, -0.03889776f, -0.00233708f, 0.03438282f, 
    -0.32282665f, -0.22506040f, 0.15828599f, -0.07326340f, -0.13358274f, -0.06467002f, -0.07931638f, 0.12683365f, 
    0.01656679f, -0.09820286f, -0.06721506f, -0.05811919f, 0.03269511f, -0.03565653f, -0.03389390f, 0.05962766f, 
    -0.01766052f, 0.04408913f, -0.01761268f, 0.05255046f, -0.11502396f, -0.28926715f, 0.14905523f, -0.12878574f, 
    -0.23863937f, 0.07741646f, -0.04379706f, 0.06730250f, -0.07587440f, -0.08120348f, -0.00185793f, -0.07371212f, 
    -0.01836222f, -0.01305536f, -0.01420877f, 0.03243987f, 0.04846828f, 0.07458312f, -0.04571879f, 0.04055564f, 
    -0.33574438f, -0.06863464f, -0.05183221f, 0.09601772f, -0.10096432f, -0.00181552f, 0.01679971f, 0.00608051f, 
    0.03311323f, 0.10844235f, 0.08337873f, -0.10225558f, -0.02479326f, -0.01962205f, -0.09645253f, 0.09409705f, 
    0.11957208f, -0.07946444f, 0.14467996f, 0.12461232f, -0.13433068f, -0.03571545f, 0.08570374f, -0.11529664f, 
    0.05846695f, 0.16383784f, -0.04595282f, 0.01442755f, 0.01452442f, -0.08341887f, 0.06305502f, -0.08227269f, 
    0.02973047f, -0.05341064f, -0.07982320f, 0.09990170f, -0.07491317f, 0.05709327f, 0.15845497f, 0.06028328f, 
    0.08947502f, -0.26106775f, 0.01113519f, 0.00132065f, -0.18808274f, -0.02002747f, -0.09834338f, 0.04482006f, 
    -0.13171372f, 0.02326511f, 0.11590987f, 0.03883379f, -0.08051844f, -0.05505130f, -0.04486490f, -0.08909284f, 
    -0.13190946f, 0.06769816f, -0.02802943f, 0.00226529f, 0.35487098f, 0.26370862f, -0.02738236f, 0.19468084f, 
    0.23515972f, 0.07129270f, -0.04804540f, -0.13256663f, -0.06861991f, -0.03962558f, 0.14430428f, 0.07840727f, 
    0.03861844f, 0.01249083f, -0.01556073f, 0.07061896f, 0.04392254f, 0.04284206f, 0.06314410f, -0.03718755f, 
    0.16873091f, 0.04218015f, 0.19898087f, 0.03255609f, 0.17013951f, -0.11717712f, -0.09521618f, -0.00734329f, 
    0.02877368f, -0.05061485f, 0.02790968f, -0.02906440f, -0.00022658f, -0.01361950f, 0.03336544f, 0.08494638f, 
    0.06167518f, -0.00486749f, 0.03688662f, -0.05051453f, 0.13771528f, -0.05996629f, 0.06244816f, 0.02569108f, 
    0.18964885f, -0.00958657f, 0.16068287f, -0.00506779f, 0.00770488f, 0.11425404f, -0.01271958f, 0.07374022f, 
    0.11710575f, 0.10208376f, 0.04739386f, -0.00014512f, 0.07762912f, -0.03614729f, 0.00845321f, 0.00050383f, 
    0.19460106f, 0.01369854f, -0.06516485f, 0.03135879f, 0.11387841f, 0.00427519f, 0.16693978f, 0.03625722f, 
    -0.04890000f, 0.08284525f, -0.08540045f, 0.11101005f, 0.04890732f, 0.05970087f, -0.00463203f, 0.02956342f, 
    -0.06987265f, 0.01254168f, -0.08710274f, 0.02931800f, -0.17780222f, 0.07683352f, 0.16235223f, -0.01836888f, 
    -0.07214227f, -0.04377274f, 0.01156773f, -0.02280904f, 0.10538846f, -0.08278868f, 0.08351046f, -0.02298142f, 
    -0.05076389f, 0.03448699f, 0.01925510f, 0.02303458f, -0.05189139f, 0.03254084f, 0.07322539f, -0.01532141f, 
    0.05497627f, -0.03971561f, -0.01152554f, -0.05524485f, -0.15448515f, 0.10796586f, 0.16237874f, 0.02594229f, 
    -0.05457326f, 0.10765023f, -0.07201967f, 0.03270346f, 0.03489348f, 0.05287097f, 0.11468545f, 0.07243530f, 
    0.12914723f, -0.04478629f, -0.05894932f, -0.03144054f, -0.17438218f, -0.23175980f, 0.12444271f, -0.03458770f, 
    -0.16243826f, 0.00678682f, -0.09091417f, 0.03757535f, 0.03028024f, -0.03061803f, 0.05751427f, -0.04484888f, 
    -0.08730049f, 0.01653567f, 0.02148172f, 0.06205348f, -0.07969426f, 0.08454610f, 0.17301813f, -0.02609335f, 
    -0.12819733f, -0.09257863f, 0.08225611f, -0.07625403f, -0.16347232f, 0.03129100f, 0.08233002f, 0.09132865f, 
    0.03191292f, -0.04096649f, 0.00482493f, -0.04681036f, 0.01556593f, 0.03256818f, -0.02850872f, 0.08092675f, 
    0.05520105f, -0.03933967f, 0.00479878f, 0.10107938f, 0.31952754f, 0.19196962f, 0.02783153f, 0.16854711f, 
    0.22507568f, 0.01259998f, 0.08574148f, -0.13294803f, 0.03853979f, -0.03452245f, -0.06803917f, 0.04382883f, 
    -0.03504807f, -0.01468226f, -0.04798969f, -0.05330053f, -0.03559821f, 0.00100980f, 0.01684143f, -0.06857477f, 
    0.18934424f, 0.00289705f, -0.00632839f, -0.03785494f, 0.03678633f, 0.00225660f, 0.14507881f, -0.04033772f, 
    0.00135939f, 0.15169041f, -0.12111133f, -0.05110177f, 0.00141013f, 0.13101929f, 0.16200891f, -0.07886156f, 
    0.02486469f, -0.00264109f, 0.05917202f, 0.04532607f, -0.26520920f, -0.07047122f, 0.17317078f, 0.07989957f, 
    -0.30584893f, 0.00597665f, -0.09163943f, 0.02077031f, -0.00412236f, -0.05839639f, 0.01139570f, -0.03420644f, 
    -0.03016086f, 0.00386691f, 0.04890838f, -0.00425021f, -0.00974360f, 0.15437882f, 0.17495997f, 0.15367284f, 
    0.05807986f, 0.11185998f, 0.07916548f, 0.05138164f, 0.09559990f, 0.08728418f, 0.09152559f, -0.03208358f, 
    0.05647441f, 0.00028243f, -0.01922878f, 0.05142322f, 0.06874808f, -0.00828231f, 0.00436575f, -0.01297684f, 
    0.03898745f, 0.02223313f, 0.04414549f, -0.00507317f, 0.00802718f, 0.08541155f, 0.08982792f, -0.07070211f, 
    0.08269771f, 0.04800075f, 0.12347722f, 0.09354882f, 0.07479008f, 0.00718236f, -0.00466369f, -0.01357187f, 
    -0.02682076f, 0.00588378f, 0.02172150f, -0.05108279f, 0.04237523f, 0.09515556f, 0.12362961f, 0.06065458f, 
    0.10650540f, 0.00124300f, 0.03839461f, -0.00843012f, 0.12416323f, 0.03868909f, 0.01321266f, -0.06198256f, 
    0.02218218f, -0.02222315f, 0.05341402f, 0.10194117f, -0.00160289f, 0.11005684f, 0.06662156f, 0.00281133f, 
    0.00274842f, -0.03745092f, -0.08438673f, -0.03017395f, 0.12326781f, 0.08603732f, 0.16479689f, 0.05421923f, 
    0.11343568f, 0.01143467f, 0.01519841f, -0.03045698f, -0.00523071f, -0.00253561f, 0.02877295f, 0.01365454f, 
    -0.07732227f, -0.00412605f, 0.02363377f, -0.02945007f, 0.02568340f, -0.07361842f, 0.05341262f, 0.02732890f, 
    -0.00820117f, 0.04360586f, 0.13861743f, 0.02539066f, 0.10828354f, 0.04202600f, -0.02427241f, -0.08297564f, 
    0.13931565f, -0.03006763f, -0.01920672f, 0.02017891f, -0.01159421f, -0.03289993f, 0.10040716f, -0.03176875f, 
    0.01381218f, 0.01384937f, -0.00593715f, -0.07415022f, -0.01810887f, -0.02862311f, -0.02405267f, 0.06915218f, 
    0.04269743f, -0.16687669f, -0.08920149f, -0.04527699f, -0.05961715f, 0.06775339f, 0.03906995f, 0.06780735f, 
    0.03675421f, -0.04866635f, 0.13698934f, 0.00310043f, 0.13323751f, 0.02009288f, 0.06573172f, 0.04944054f, 
    -0.05498021f, -0.18889497f, 0.03036764f, 0.21040191f, 0.20702869f, -0.14700752f, -0.01987006f, -0.09411941f, 
    -0.00695110f, -0.05822570f, -0.08244196f, -0.00256086f, -0.03887671f, -0.02543725f, 0.06968544f, -0.04684504f, 
    0.01681274f, 0.04259065f, 0.01857659f, 0.03461046f, -0.00491497f, 0.36844176f, -0.04053420f, -0.09947984f, 
    0.07403941f, 0.13792256f, -0.01107764f, 0.04145660f, 0.02900351f, 0.04323659f, -0.06447457f, -0.04536273f, 
    0.00028154f, -0.05335871f, 0.09398799f, 0.05756041f, 0.01826118f, -0.09183773f, 0.07148632f, -0.05002272f, 
    -0.15211324f, -0.06105828f, -0.00030966f, -0.08595493f, -0.04337184f, -0.05139957f, -0.02902133f, -0.07292801f, 
    0.03805812f, -0.06641638f, 0.03293841f, -0.02350212f, 0.00625821f, -0.01926148f, 0.02751837f, -0.09953949f, 
    0.07629559f, -0.08726066f, 0.03661809f, -0.01707254f, 0.06194266f, 0.18146418f, -0.19374135f, 0.10090623f, 
    -0.18428208f, -0.06321993f, 0.04756575f, -0.01438611f, -0.06427473f, 0.00608143f, 0.00058556f, 0.12070131f, 
    0.03538350f, -0.01907673f, -0.07578549f, -0.04116407f, 0.05980850f, 0.04872345f, -0.01362600f, -0.00753845f, 
    -0.53473955f, 0.16797942f, 0.25855619f, 0.05509976f, 0.16185117f, -0.03043547f, 0.04348150f, 0.01109001f, 
    0.01657283f, -0.12332486f, -0.08777004f, -0.05163869f, 0.00162780f, 0.10764571f, 0.07042941f, -0.04275494f, 
    -0.02046818f, 0.13117228f, 0.06035629f, -0.05365930f, -0.01560981f, -0.22332993f, 0.03849654f, 0.08337083f, 
    0.05676493f, -0.03920961f, -0.00290747f, -0.07833971f, -0.11422251f, -0.08432688f, -0.04965284f, -0.04733866f, 
    -0.05888382f, 0.05264069f, -0.05519284f, -0.02823204f, 0.00739756f, -0.03780693f, -0.02927531f, 0.00583086f, 
    -0.14371838f, 0.05036172f, 0.13716321f, 0.01441947f, 0.17871083f, 0.14157128f, 0.03067269f, 0.02865042f, 
    0.10749762f, -0.04994342f, -0.01986772f, 0.09767614f, -0.05056533f, -0.08786374f, -0.04122964f, 0.12837371f, 
    -0.02100156f, 0.06190591f, 0.06087079f, -0.07427588f, 0.23000112f, -0.07857224f, 0.00565657f, -0.09076286f, 
    -0.08381653f, 0.01053200f, 0.02640674f, -0.05624083f, 0.01905718f, 0.05502164f, -0.00522948f, 0.12094932f, 
    0.05127890f, -0.02717234f, -0.08307260f, 0.02573612f, -0.07627781f, -0.10097983f, -0.02083565f, -0.00340152f, 
    0.03630759f, 0.22381179f, 0.20774651f, 0.13103162f, 0.11495190f, 0.13110951f, -0.04975815f, 0.06893332f, 
    0.08183765f, -0.06425443f, 0.09712712f, 0.00027666f, 0.06029157f, 0.07563946f, -0.00146429f, -0.02147811f, 
    0.06845667f, -0.03885422f, 0.03615164f, -0.02826673f, -0.00817444f, -0.01921269f, 0.09211361f, -0.03594193f, 
    0.27478072f, 0.05461001f, 0.07320951f, -0.04095266f, 0.05415629f, -0.00152386f, 0.01024964f, 0.09680907f, 
    -0.00267131f, 0.01136807f, 0.00533507f, -0.02542249f, 0.02040862f, -0.11294912f, -0.00071749f, -0.05345228f, 
    -0.02278583f, -0.05844019f, -0.01089766f, -0.01650058f, 0.03161306f, 0.00942634f, -0.02764606f, 0.03623560f, 
    0.03578402f, -0.03878350f, -0.03456064f, 0.00406161f, -0.03947363f, 0.03803891f, -0.05130671f, 0.00840409f, 
    0.04272391f, 0.01926281f, -0.06462406f, 0.02137549f, 0.02809353f, 0.00327942f, -0.03471840f, -0.01072016f, 
    0.04625484f, 0.03331575f, 0.00355036f, 0.00245918f, 0.01886909f, 0.00389556f, -0.05028385f, -0.03268478f, 
    -0.01157301f, -0.00448882f, 0.01528996f, 0.00751761f, 0.04684143f, 0.00673083f, -0.05431395f, 0.04587020f, 
    0.04167862f, -0.03131954f, -0.05055148f, -0.02092682f, -0.04196288f, -0.03082086f, -0.03134697f, -0.00431962f, 
    0.01099509f, 0.04415917f, -0.00740446f, 0.02028117f, -0.01068046f, 0.02040979f, 0.02260511f, 0.03689599f, 
    0.02677552f, -0.02595358f, 0.04436845f, -0.02918124f, 0.01127828f, -0.05063305f, 0.02289873f, -0.06302172f, 
    0.02898524f, 0.04550866f, -0.02028587f, 0.00424589f, 0.00405436f, 0.03352502f, 0.04020773f, 0.00789344f, 
    -0.03814420f, -0.01281508f, 0.04161734f, 0.04437868f, -0.03919865f, 0.01035520f, 0.00916258f, -0.06025737f, 
    -0.02421778f, 0.01279659f, 0.00486485f, -0.02908737f, 0.00226938f, -0.04562838f, -0.02725337f, 0.00819032f, 
    -0.03639227f, -0.03421008f, 0.01141544f, -0.03879416f, -0.05312802f, -0.05252947f, -0.03450703f, -0.01479205f, 
    -0.01499044f, 0.04381018f, -0.01599904f, 0.03559769f, -0.03732960f, -0.05678050f, -0.04820617f, 0.03468056f, 
    0.02758412f, -0.01101289f, 0.02466497f, 0.00612760f, -0.00301964f, 0.03909172f, -0.02439975f, -0.03295121f, 
    -0.01815642f, -0.04400733f, 0.01717697f, 0.04644916f, -0.01807800f, -0.04741186f, 0.02428082f, -0.01771698f, 
    -0.02719636f, -0.01754200f, -0.05025929f, -0.03054733f, 0.04608564f, 0.04246387f, 0.03664310f, -0.06151641f, 
    -0.05563023f, -0.01198300f, -0.05406101f, 0.02198236f, 0.01586228f, 0.04687046f, -0.00987267f, 0.03799959f, 
    0.00140611f, -0.04491791f, 0.03740486f, -0.04775082f, 0.01700292f, 0.04574772f, 0.02961188f, 0.01500202f, 
    -0.05922569f, -0.03547760f, -0.04467285f, 0.02046476f, -0.00674699f, 0.04242659f, 0.02974959f, -0.00263308f, 
    -0.06099427f, 0.01858828f, -0.02701990f, -0.02917345f, 0.04295108f, -0.01225762f, -0.04184739f, -0.05385957f, 
    -0.03940514f, -0.01791740f, 0.00195791f, -0.04857972f, -0.00617404f, -0.00882857f, 0.01538601f, -0.06499944f, 
    -0.03615998f, 0.04382287f, -0.00373153f, -0.05370039f, -0.04419822f, -0.01402546f, -0.00704136f, -0.00101452f, 
    -0.04697951f, -0.05477183f, -0.06008001f, -0.05392163f, 0.05538251f, -0.00481636f, -0.01380829f, -0.03503794f, 
    0.03772566f, -0.04065128f, -0.02843486f, -0.00238348f, -0.04174728f, 0.02465559f, -0.00770191f, 0.01839835f, 
    -0.04548113f, -0.01213506f, 0.00172692f, -0.02490899f, 0.03695980f, -0.02308806f, -0.01090560f, -0.06000545f, 
    -0.05672513f, 0.00238242f, -0.04370005f, 0.04334449f, -0.04894222f, -0.03416148f, -0.05718109f, -0.03053449f, 
    0.02196808f, 0.04758075f, -0.03879635f, -0.03117974f, 0.02772633f, -0.04968116f, -0.00090937f, 0.00144463f, 
    -0.01224589f, 0.00241888f, -0.04253063f, -0.04812371f, -0.00384110f, 0.03764684f, -0.02621552f, -0.01337804f, 
    -0.00928774f, -0.03858813f, -0.02653685f, 0.01022625f, 0.04011187f, 0.01951391f, 0.03559627f, 0.04656651f, 
    -0.03494713f, -0.06037402f, 0.03019850f, 0.04615889f, 0.04347335f, -0.01902979f, -0.05981334f, -0.04933601f, 
    -0.00870994f, -0.05622277f, -0.02456023f, 0.02374685f, -0.05890688f, 0.04430122f, -0.05247115f, 0.02451787f, 
    0.02268149f, -0.06318197f, -0.02690722f, 0.00760370f, -0.05887007f, -0.03194652f, -0.02686246f, -0.04816515f, 
    -0.01667596f, 0.03644885f, 0.00962960f, -0.03114733f, -0.03352021f, 0.03781466f, 0.00812438f, -0.04379600f, 
    -0.00931486f, 0.04004309f, 0.05008716f, 0.01647344f, -0.04645834f, -0.02242626f, 0.00530093f, -0.03854758f, 
    -0.00178005f, -0.01341903f, -0.03737266f, 0.05317118f, 0.03886817f, 0.00201141f, -0.04547692f, 0.00650945f, 
    -0.02500273f, -0.04412962f, -0.05107688f, -0.03501657f, -0.00865813f, -0.05965297f, -0.04749933f, -0.01924699f, 
    -0.06063367f, -0.05381073f, -0.03786214f, 0.02768802f, -0.03439520f, 0.03581451f, 0.00694370f, -0.01911494f, 
    -0.01968585f, -0.03243065f, -0.01695887f, 0.02767459f, -0.00982104f, -0.02031658f, -0.02796425f, -0.06177956f, 
    -0.04795618f, 0.02087316f, 0.01330007f, -0.01810632f, 0.03761580f, -0.03815138f, -0.01925841f, -0.04557486f, 
    -0.00484090f, 0.04300684f, 0.02834031f, 0.03196631f, 0.02755576f, -0.01323238f, -0.04052296f, -0.00649881f, 
    0.02586542f, -0.04704826f, -0.03260262f, 0.00499370f, 0.03102432f, -0.02971892f, -0.06349840f, -0.01850816f, 
    -0.03453116f, 0.00501580f, 0.00978381f, -0.00644940f, 0.04375471f, -0.05869746f, -0.05880627f, 0.03057891f, 
    -0.04821230f, -0.03051526f, -0.02836058f, -0.01612099f, -0.00786265f, 0.01585965f, 0.02310964f, 0.01491986f, 
    0.03690030f, -0.04810884f, -0.03352020f, -0.01386713f, -0.01867085f, -0.02904696f, 0.03617945f, 0.02845387f, 
    -0.05801270f, 0.00014220f, -0.06202145f, 0.04186568f, -0.01888873f, -0.02321291f, 0.02475533f, 0.04603931f, 
    -0.00879352f, -0.02119277f, -0.04614162f, 0.03138865f, -0.00197123f, 0.02476886f, 0.01439678f, 0.02546858f, 
    0.02001542f, -0.02587282f, -0.00783653f, 0.01336661f, 0.00037424f, -0.04393175f, -0.00090063f, -0.02676983f, 
    -0.02857168f, -0.05171449f, 0.03997665f, 0.03719668f, -0.01451445f, -0.04474685f, -0.04697973f, -0.03687343f, 
    -0.03923766f, 0.00402788f, -0.01317698f, -0.03785856f, -0.05622845f, -0.00362495f, -0.04788983f, -0.06084651f, 
    0.03756284f, 0.01577047f, -0.02807262f, 0.02177944f, -0.05761929f, 0.00718055f, 0.03659453f, -0.04461957f, 
    0.01208043f, -0.05581016f, 0.01781108f, -0.00459962f, -0.06260430f, -0.06221567f, 0.01017767f, -0.03804804f, 
    -0.02521305f, 0.02868780f, -0.01733412f, 0.01130181f, -0.02021194f, 0.04448932f, 0.04544015f, -0.05179767f, 
    -0.00761103f, -0.05941383f, -0.04161914f, 0.02608516f, 0.04721077f, 0.00930075f, -0.01076366f, -0.06044554f, 
    0.03206417f, 0.02937108f, -0.01235804f, -0.01558511f, -0.05412683f, 0.02077199f, -0.02207370f, -0.02846029f, 
    0.02367290f, -0.05994742f, 0.02286622f, 0.02144504f, -0.05622838f, 0.04487589f, -0.03229129f, 0.01570613f, 
    -0.00743045f, 0.00665257f, -0.04397551f, -0.05004279f, 0.02017913f, 0.04714137f, -0.02898662f, 0.02982760f, 
    -0.01429959f, -0.04668871f, 0.04478325f, 0.02802148f, 0.04382640f, -0.02796938f, 0.01397603f, -0.05228527f, 
    -0.00180391f, 0.03684288f, -0.00285933f, -0.00767954f, -0.03386245f, 0.01603954f, 0.00980520f, -0.03603624f, 
    -0.03750242f, -0.00284180f, 0.02507224f, -0.05125433f, -0.00778390f, 0.02697447f, -0.01423532f, 0.01056612f, 
    0.00106606f, 0.02044600f, 0.01808370f, -0.03569862f, -0.03262461f, -0.05309783f, 0.01532293f, -0.04929166f, 
    -0.05338427f, -0.02903849f, -0.04420730f, -0.04346746f, -0.05993152f, -0.00902667f, 0.01672368f, 0.01497669f, 
    -0.02285670f, 0.01507139f, -0.00056780f, -0.01158616f, -0.04825442f, 0.02957663f, -0.00367049f, 0.03033876f, 
    -0.00542399f, 0.02673679f, 0.00575917f, 0.01478339f, -0.04575683f, -0.02330442f, -0.02805905f, -0.00259447f, 
    -0.00606895f, 0.02707420f, -0.00097905f, 0.04461103f, -0.03666328f, -0.01248745f, 0.03633283f, 0.01865606f, 
    -0.05801701f, 0.00539079f, 0.01902230f, 0.00590118f, 0.02196004f, 0.03504568f, 0.02773811f, -0.00312950f, 
    -0.05080171f, -0.05090285f, 0.01586157f, 0.01555910f, -0.00770406f, -0.00726921f, -0.02449574f, -0.00105551f, 
    0.04558962f, 0.02905462f, -0.02108688f, 0.04264027f, 0.01980397f, -0.05158375f, 0.04088573f, -0.05823869f, 
    -0.02508277f, 0.02629239f, 0.02832887f, -0.02119044f, 0.01457916f, -0.01360618f, 0.03808641f, -0.02413835f, 
    -0.05221958f, 0.03596212f, 0.04774476f, 0.00679798f, -0.05223459f, -0.03553638f, 0.03781382f, -0.02065712f, 
    -0.04250098f, -0.03246498f, -0.02958438f, 0.00484414f, -0.04208798f, 0.03102414f, 0.02021931f, -0.01497354f, 
    0.03042390f, 0.04262649f, -0.01909543f, -0.01167432f, -0.00881019f, 0.01386015f, 0.02666028f, 0.03485726f, 
    0.00804446f, -0.01368965f, 0.02280406f, -0.01659741f, 0.01663068f, -0.01596571f, -0.01377608f, -0.05143356f, 
    -0.03601162f, -0.04423826f, -0.05539765f, 0.01082264f, 0.05028097f, 0.05556585f, 0.04951407f, -0.04231057f, 
    -0.03766568f, 0.04991318f, -0.04421188f, -0.03196283f, -0.05461464f, -0.03531208f, 0.00595974f, 0.03357705f, 
    0.04065737f, 0.00256660f, 0.01903939f, -0.05612184f, -0.02881619f, -0.04653824f, -0.05980993f, 0.01808328f, 
    0.01503562f, 0.02584829f, -0.04834207f, -0.04199415f, -0.05681390f, 0.03694619f, 0.04722050f, -0.03256174f, 
    -0.00968884f, -0.00298690f, -0.04857754f, -0.01520745f, -0.05068545f, -0.00327311f, 0.02149421f, -0.02832823f, 
    -0.04478686f, -0.00781688f, 0.01507266f, -0.00269928f, 0.00922010f, -0.02404858f, -0.03805297f, -0.02372417f, 
    -0.03821952f, -0.05813870f, 0.04339193f, -0.01545428f, 0.04275264f, -0.04327338f, 0.01198163f, 0.03844005f, 
    -0.01721902f, -0.04577890f, 0.03338141f, -0.02771178f, 0.02733635f, 0.00875877f, 0.04895950f, 0.03274778f, 
    -0.20223169f, 0.06904913f, 0.00402767f, -0.01641712f, -0.04001930f, 0.00946292f, 0.14656027f, 0.00340889f, 
    0.01320759f, -0.09537611f, 0.05103963f, 0.04100731f, 0.00470735f, -0.01565231f, -0.01921877f, 0.08649892f, 
    -0.06001496f, 0.10030972f, 0.02510804f, 0.13361903f, -0.19816755f, -0.23178673f, 0.09721839f, -0.13250461f, 
    -0.07457469f, -0.03569139f, 0.00012585f, 0.02141483f, 0.07023706f, -0.00923963f, 0.13581105f, 0.08916668f, 
    -0.07271065f, 0.07396319f, -0.03071452f, 0.08439087f, 0.03540349f, -0.01505005f, 0.10946034f, 0.10162276f, 
    -0.02355874f, -0.01209089f, -0.07166864f, -0.01794538f, -0.10605792f, -0.04221305f, 0.14013524f, 0.03216776f, 
    -0.01059569f, 0.01624831f, 0.14106308f, -0.02324634f, 0.13126950f, -0.00162954f, -0.05319360f, -0.03184904f, 
    0.03142471f, 0.02356266f, 0.12811159f, 0.06852755f, 0.26141462f, -0.03119453f, 0.12251452f, -0.06032882f, 
    0.03845615f, 0.01108825f, -0.03678380f, 0.07364647f, 0.10647156f, 0.07342505f, 0.05309365f, 0.00521526f, 
    -0.07424547f, 0.03972078f, -0.03358214f, 0.16011465f, -0.05626044f, -0.05012075f, 0.13526429f, -0.08095142f, 
    -0.17574634f, 0.08332764f, -0.09796199f, -0.26494354f, -0.09071441f, -0.06644952f, 0.01328366f, -0.13865456f, 
    -0.09152387f, -0.06575278f, -0.07045168f, -0.00240509f, 0.18240163f, 0.19632134f, 0.01334607f, -0.01066924f, 
    0.06075139f, 0.02837493f, 0.09995965f, -0.00783288f, 0.04798383f, 0.14788514f, 0.20404740f, 0.08207709f, 
    0.01786278f, 0.13865438f, -0.08133218f, 0.03816586f, -0.00051650f, 0.05378119f, 0.04826699f, -0.01155527f, 
    -0.00203173f, -0.05013987f, -0.01012595f, -0.02711551f, 0.08144966f, -0.04135168f, 0.00027009f, -0.01052002f, 
    -0.14682849f, -0.06129794f, 0.16353598f, -0.04000093f, -0.17407137f, -0.04444708f, 0.15782459f, 0.06237351f, 
    -0.00204471f, -0.05201509f, 0.05638717f, 0.01039133f, 0.01780388f, -0.15769976f, -0.07721578f, 0.01072952f, 
    0.09994228f, 0.09288460f, -0.02128683f, 0.09259316f, 0.34571579f, 0.24250656f, -0.25663671f, -0.01638945f, 
    0.24645388f, -0.01858151f, -0.04039279f, -0.02578763f, 0.01534942f, 0.00415816f, 0.05707301f, -0.01235832f, 
    -0.03043164f, -0.05092711f, -0.02233111f, 0.01647287f, 0.13562258f, -0.08775668f, -0.08992637f, -0.05834756f, 
    0.10541118f, -0.03232328f, 0.02614364f, 0.03785196f, 0.01995427f, 0.04104539f, 0.11332368f, 0.02536372f, 
    -0.03694348f, -0.09802979f, -0.08403283f, -0.01560225f, 0.03573499f, 0.07871208f, 0.00126096f, -0.00053327f, 
    0.02528611f, 0.09517340f, -0.02546239f, 0.00847022f, -0.21853738f, 0.13644286f, -0.01414294f, 0.07983532f, 
    -0.39401633f, -0.07084539f, 0.00306035f, -0.01591929f, -0.01915404f, -0.01313009f, 0.04574694f, 0.03485562f, 
    0.02587507f, 0.00665962f, -0.02463214f, -0.05821564f, 0.12366710f, 0.08699466f, 0.03976376f, 0.01734586f, 
    -0.21653599f, -0.05053714f, 0.11781746f, 0.12034171f, 0.11579220f, 0.03534197f, 0.03364253f, 0.04163842f, 
    -0.01881466f, 0.14605947f, -0.07265734f, -0.02618792f, 0.02704135f, 0.15774673f, 0.01628875f, -0.05883220f, 
    -0.04936798f, 0.03027612f, 0.01818049f, -0.01266744f, -0.24097002f, -0.15933718f, -0.02490142f, -0.13523087f, 
    -0.13702206f, -0.06725356f, 0.07163566f, 0.05967417f, -0.08803082f, -0.01758624f, 0.00823510f, -0.00963619f, 
    -0.01854434f, -0.04804408f, -0.03318392f, 0.01074451f, -0.05997836f, 0.13366561f, 0.04446914f, 0.02006542f, 
    -0.05545346f, 0.03133613f, -0.03471407f, 0.00982454f, 0.19131112f, 0.05709939f, -0.01917857f, 0.01592369f, 
    0.02116945f, 0.05314524f, 0.03405684f, 0.01645167f, -0.00163132f, 0.09929440f, 0.02893327f, 0.05271836f, 
    -0.03429237f, -0.04417531f, 0.04042608f, -0.02471874f, 0.13739449f, 0.31504533f, 0.10301667f, 0.21095340f, 
    -0.07309983f, 0.18125071f, 0.11947715f, -0.01005613f, 0.02810482f, -0.07203518f, 0.00456635f, 0.05293715f, 
    0.16196431f, -0.04631430f, 0.04335184f, 0.05724474f, -0.00281610f, -0.03568425f, -0.11812706f, -0.03603725f, 
    0.16077095f, -0.15819845f, -0.15317737f, 0.05490590f, 0.31962684f, 0.00256469f, -0.04226302f, -0.02821963f, 
    0.00379362f, 0.05691140f, -0.01661160f, -0.03572224f, 0.07945149f, 0.10228810f, 0.08496100f, -0.05279151f, 
    0.05131783f, -0.06616120f, -0.01259995f, -0.02173742f, 0.03429335f, -0.05948752f, -0.01620444f, -0.09351659f, 
    -0.00710428f, -0.01398772f, 0.02940186f, 0.03593390f, -0.09744994f, -0.00420062f, 0.08073855f, 0.02996521f, 
    0.07090319f, 0.03268825f, 0.06503211f, 0.04439009f, 0.07583419f, 0.10136945f, 0.12838456f, 0.05356563f, 
    -0.02366221f, 0.01414993f, -0.05164851f, 0.01324239f, 0.01573489f, 0.02157814f, 0.04109976f, -0.01602201f, 
    0.02119248f, 0.01891439f, 0.03593272f, -0.03621569f, -0.00159956f, -0.02604471f, -0.01730529f, 0.04575951f, 
    0.03598832f, 0.01200197f, -0.05053458f, -0.00588299f, -0.01490781f, -0.00640569f, -0.05201551f, -0.04796438f, 
    0.02894492f, -0.05980699f, -0.00753194f, 0.02871811f, -0.00018877f, -0.03034791f, -0.05837800f, -0.01602594f, 
    0.01427393f, -0.04599059f, -0.00343800f, -0.05035055f, -0.06057798f, 0.01498254f, 0.01542169f, 0.01242339f, 
    -0.06030197f, 0.01934237f, 0.03755797f, -0.02629485f, 0.02909260f, 0.00704479f, -0.06466085f, -0.02143016f, 
    -0.01429864f, -0.04692169f, 0.02507116f, -0.05101069f, -0.02940222f, -0.03832338f, -0.01967627f, -0.06200128f, 
    0.01694904f, 0.03474914f, -0.01886561f, -0.00361708f, -0.01922852f, 0.01835195f, 0.03145321f, -0.03291129f, 
    0.00238289f, 0.00388455f, -0.04078530f, -0.02604752f, 0.01265374f, -0.05096142f, 0.02625108f, -0.01133102f, 
    -0.00866235f, -0.03848507f, 0.01869113f, 0.00275920f, -0.01203136f, 0.03334223f, -0.00513533f, -0.06198125f, 
    0.02954913f, 0.03257035f, 0.00548004f, -0.05744864f, 0.01459751f, -0.00877801f, -0.00625239f, -0.04622492f, 
    0.00725210f, -0.05301237f, 0.03150598f, 0.02196625f, 0.01137251f, -0.04341871f, -0.03818687f, -0.01505249f, 
    -0.01798072f, -0.00263692f, 0.03077518f, -0.03275117f, -0.02596354f, -0.03034456f, 0.00667370f, -0.05201845f, 
    -0.04892372f, -0.00763721f, 0.00198673f, -0.06109168f, 0.03644106f, 0.02698231f, -0.06350841f, -0.06020941f, 
    -0.02253190f, -0.04297216f, 0.02353961f, -0.01259162f, 0.00859137f, -0.04052372f, 0.02322015f, -0.05829209f, 
    0.00733982f, 0.02862255f, 0.02573712f, 0.03895067f, -0.03559518f, -0.03305030f, 0.03027144f, -0.03934943f, 
    -0.06007865f, 0.00864864f, -0.03639926f, -0.00474403f, -0.03295161f, 0.02226874f, -0.04498645f, -0.04839673f, 
    0.02604388f, -0.04020515f, -0.03407788f, -0.06149665f, -0.04573454f, 0.03363716f, 0.04367970f, 0.04701165f, 
    -0.01513190f, 0.03262774f, 0.00416606f, -0.06118933f, 0.01892452f, 0.03537669f, -0.01772854f, 0.05042727f, 
    -0.01979592f, -0.03752124f, -0.04677043f, -0.05399202f, 0.00130150f, 0.01595038f, -0.02401365f, -0.01357413f, 
    -0.05044936f, -0.01165329f, -0.02733023f, 0.02300118f, -0.03959364f, 0.01277557f, 0.03153732f, 0.00965650f, 
    -0.01997746f, -0.02083100f, 0.03557727f, 0.04212920f, -0.02801835f, -0.00857151f, 0.03850470f, -0.03982119f, 
    -0.03893068f, -0.05528276f, -0.00811849f, 0.01905263f, 0.00729780f, 0.02380842f, -0.02503007f, -0.03678110f, 
    0.01435300f, -0.04951518f, -0.00161195f, -0.00680703f, 0.00261809f, -0.00826608f, 0.01631419f, 0.00685705f, 
    -0.05481111f, -0.02085321f, -0.03722965f, -0.02495550f, -0.04890072f, 0.01397836f, -0.05512867f, 0.03809090f, 
    0.01321423f, -0.04741610f, -0.00675647f, 0.03102122f, 0.02613839f, -0.00169167f, 0.02864174f, -0.05573080f, 
    -0.03962176f, -0.04672110f, -0.02816098f, -0.05092845f, -0.05366500f, 0.01227244f, 0.00822825f, -0.04700458f, 
    0.02544339f, 0.02584113f, 0.00123859f, 0.02371280f, -0.00471422f, 0.01228123f, -0.06268128f, 0.00150043f, 
    -0.06243025f, 0.04074518f, -0.02041559f, -0.04141578f, -0.01376043f, -0.06037303f, -0.05297725f, 0.02407770f, 
    -0.04106066f, -0.02917125f, 0.02996444f, 0.01334057f, -0.01804041f, 0.02959650f, -0.04319208f, -0.05589812f, 
    0.04122474f, -0.06039419f, 0.02341873f, -0.01815871f, 0.01433879f, 0.04104282f, 0.01189434f, -0.00220592f, 
    -0.05388137f, -0.02568265f, 0.01496582f, 0.04129421f, -0.01838014f, -0.01279999f, 0.03702614f, -0.00812381f, 
    -0.00994061f, 0.00991903f, 0.01830402f, -0.00635392f, 0.01238329f, 0.02654788f, -0.03281072f, -0.03391092f, 
    -0.03860778f, -0.02051275f, 0.00359931f, 0.01041370f, -0.03269755f, -0.02609578f, 0.01950147f, -0.00287272f, 
    -0.04949797f, -0.02888147f, -0.05915350f, 0.01818393f, 0.03699809f, 0.04265149f, -0.05633014f, -0.06445142f, 
    0.01213513f, 0.03790718f, 0.00166342f, 0.04348314f, -0.01476412f, 0.05160752f, -0.05577680f, -0.04875299f, 
    -0.04815659f, 0.01344898f, 0.02971604f, -0.02245804f, 0.02145868f, -0.02573101f, 0.01532213f, -0.01154830f, 
    -0.02709999f, 0.02659648f, -0.06130454f, -0.01068974f, -0.04782767f, 0.00669319f, -0.00361263f, -0.03745207f, 
    -0.00812560f, 0.01840735f, 0.02597884f, 0.02817367f, -0.01364923f, -0.00095053f, -0.03833031f, -0.00358386f, 
    -0.05278910f, 0.04735165f, 0.04202357f, 0.00205761f, 0.01536498f, -0.00695404f, -0.02211026f, -0.02578728f, 
    0.20803651f, 0.12283968f, 0.05182404f, 0.06788144f, -0.13873655f, -0.03350110f, -0.03980298f, 0.13108496f, 
    0.08791666f, 0.08508414f, -0.08960119f, -0.04904146f, 0.06077962f, 0.11836073f, 0.07195409f, -0.02217700f, 
    -0.05619662f, -0.05190986f, -0.03536007f, -0.09225534f, 0.22640291f, 0.06347363f, -0.17066665f, 0.04544686f, 
    -0.15536755f, 0.02128460f, -0.07284287f, -0.03531481f, -0.10817070f, 0.02387035f, -0.02476052f, 0.02916719f, 
    0.10558167f, -0.06822553f, 0.01303600f, 0.05019792f, -0.00968550f, -0.02300429f, -0.10042545f, -0.06482089f, 
    -0.15864110f, 0.14578128f, -0.07336172f, -0.00868691f, 0.00835942f, 0.06773717f, -0.10003996f, -0.01754805f, 
    -0.00265573f, 0.07110575f, -0.03456566f, -0.13478392f, -0.00711491f, 0.07031319f, -0.09632213f, 0.10716081f, 
    0.00562424f, -0.02114767f, 0.05024276f, 0.01981052f, -0.20807073f, 0.12341856f, 0.02561959f, -0.11657356f, 
    -0.01160943f, 0.01674549f, 0.06447716f, 0.07953718f, -0.12025807f, -0.07060593f, -0.08799328f, -0.06976249f, 
    0.02891031f, -0.06411234f, -0.01149903f, 0.03330618f, 0.05100005f, -0.02037175f, 0.06260056f, -0.01894106f, 
    -0.19041766f, 0.03996756f, -0.07114838f, 0.15364634f, -0.01675354f, 0.00591428f, -0.00925501f, -0.04940613f, 
    -0.04258632f, 0.06064020f, 0.05700031f, 0.01525735f, -0.05391664f, 0.01969092f, 0.01766769f, -0.01044545f, 
    -0.04892294f, 0.02061074f, 0.05356591f, 0.19061095f, 0.13932948f, 0.04010697f, -0.23435341f, 0.06281030f, 
    0.22605363f, 0.04104678f, 0.04465171f, 0.06096155f, 0.01296684f, -0.00981593f, 0.10873135f, 0.01312081f, 
    0.03294801f, 0.10387124f, -0.11365396f, 0.10545753f, 0.08041971f, 0.09267517f, -0.02518597f, 0.05781038f, 
    0.12313770f, -0.05506440f, -0.13927907f, -0.08501117f, 0.09881013f, 0.13199738f, 0.00997012f, 0.00898971f, 
    -0.04388443f, 0.04903544f, -0.01551630f, -0.02444856f, 0.03833883f, 0.14983107f, 0.00807882f, 0.07713108f, 
    -0.03064595f, -0.09379695f, -0.10497124f, -0.09951340f, -0.24890742f, 0.06567774f, 0.08742570f, -0.00189644f, 
    0.08936670f, -0.03033086f, 0.13794860f, 0.04656570f, 0.03618065f, -0.02102959f, -0.01206079f, 0.05229222f, 
    0.11035967f, -0.04617272f, 0.01375403f, 0.07118719f, 0.02445406f, -0.01898080f, 0.00560197f, -0.00999260f, 
    0.17108008f, 0.04610479f, 0.01223047f, 0.02395534f, 0.00231758f, 0.06380731f, 0.00966692f, 0.03179326f, 
    0.01731271f, 0.05992027f, -0.03879517f, -0.03897229f, 0.02554268f, -0.05316916f, -0.02136042f, 0.03271987f, 
    0.04642555f, 0.00317845f, 0.04518787f, -0.04324043f, 0.08993261f, -0.15131854f, 0.10995926f, -0.13341272f, 
    0.07783516f, 0.01593307f, -0.08618086f, -0.01008233f, 0.06762642f, -0.16706780f, 0.02066218f, -0.04364202f, 
    -0.07142825f, 0.02539592f, 0.02832257f, 0.03949529f, -0.07413489f, -0.05907530f, -0.04477748f, -0.06347190f, 
    0.36150569f, -0.08255558f, -0.24166057f, -0.00818893f, -0.24942581f, -0.01428754f, -0.03484500f, 0.07402387f, 
    0.01772017f, 0.08192957f, 0.06205640f, 0.00564121f, -0.04049050f, -0.06057881f, 0.08901236f, 0.01800031f, 
    0.08121465f, -0.11267107f, -0.01233010f, -0.05500368f, -0.11231966f, -0.02775801f, 0.19337697f, 0.05460889f, 
    -0.04096583f, 0.06691234f, -0.01602351f, 0.09126843f, 0.05331259f, -0.02536858f, 0.08116745f, 0.04617624f, 
    0.01404687f, 0.06466566f, 0.03929853f, 0.02659117f, 0.01051340f, -0.09697241f, -0.03086578f, 0.01832866f, 
    0.24601533f, 0.08362849f, 0.06444980f, 0.06287432f, -0.17696147f, -0.08216252f, -0.01468731f, 0.06571472f, 
    -0.01561430f, 0.08401062f, 0.00842412f, -0.03648328f, 0.04522206f, 0.02175660f, 0.01612862f, 0.01817442f, 
    0.13432714f, -0.02988010f, -0.00954761f, 0.00647551f, 0.12499609f, 0.01612090f, 0.02205796f, 0.05859848f, 
    0.06992532f, 0.03344642f, 0.03291213f, -0.11646776f, 0.02048701f, -0.05135673f, -0.03844281f, 0.00245452f, 
    -0.04945877f, 0.14770804f, 0.00059508f, -0.12761828f, 0.06376362f, 0.12428332f, 0.05961841f, 0.05580104f, 
    -0.28529632f, -0.04169425f, -0.21249196f, -0.07117419f, -0.07586951f, -0.03506731f, 0.05588608f, -0.03982235f, 
    -0.11500804f, -0.02202484f, 0.06564143f, 0.14407372f, -0.07921187f, -0.10196419f, 0.12901443f, 0.03801334f, 
    -0.03412265f, 0.05178746f, -0.07329495f, 0.04852961f, -0.09298433f, 0.07406991f, 0.16970852f, 0.06239752f, 
    -0.17007001f, 0.00875010f, -0.07517169f, -0.04898157f, -0.02356003f, 0.07675534f, -0.02812471f, -0.01101681f, 
    -0.01742487f, 0.11733367f, 0.03901358f, 0.06358779f, -0.06826703f, 0.00298497f, -0.06149030f, -0.10952665f, 
    0.20433901f, 0.11121824f, 0.00680755f, -0.02579204f, -0.22249117f, -0.04132942f, -0.00121403f, 0.01773083f, 
    0.08981343f, 0.04221485f, 0.03227745f, 0.04063776f, 0.05517583f, -0.03736457f, 0.03322176f, 0.04230008f, 
    0.03862837f, 0.02399220f, -0.00438244f, 0.01935350f, 0.28894114f, -0.10088788f, -0.03928469f, -0.06670401f, 
    -0.06817475f, -0.18671791f, -0.11368124f, -0.08762183f, 0.16620886f, 0.03555228f, -0.01000880f, -0.08745410f, 
    -0.00100769f, -0.00628191f, 0.03720315f, 0.00881424f, -0.13668784f, -0.00850927f, -0.01136753f, 0.04849866f, 
    0.00880910f, 0.19735080f, 0.05733567f, -0.04108543f, -0.08908319f, 0.13875484f, 0.02331560f, 0.00091758f, 
    -0.02918351f, -0.02778534f, -0.05792484f, -0.04813797f, 0.17219645f, 0.11212233f, 0.01040519f, 0.00773083f, 
    0.14411557f, 0.01811233f, 0.01029652f, 0.04900629f, -0.12974739f, 0.27471790f, 0.04841691f, -0.16617630f, 
    0.00141801f, 0.00856109f, -0.05051010f, -0.01674421f, 0.00553391f, 0.04688196f, 0.01093477f, 0.04972950f, 
    -0.11028277f, 0.03905037f, 0.05813260f, 0.03256331f, -0.00209786f, -0.10480046f, 0.08086513f, 0.00646607f, 
    -0.01618188f, 0.36876404f, -0.02620514f, 0.01701037f, -0.10230526f, 0.01627581f, 0.07995967f, 0.00215481f, 
    -0.00408435f, -0.07155347f, 0.03093022f, 0.00467021f, 0.09394406f, 0.01148411f, -0.01820463f, 0.02272999f, 
    0.03309818f, -0.06352395f, 0.07549892f, 0.10911464f, -0.37824535f, 0.14651340f, -0.21272638f, 0.08550581f, 
    0.11727707f, 0.04867994f, 0.09874699f, 0.09725463f, -0.00315400f, -0.04338112f, -0.00364867f, 0.03127543f, 
    0.00167134f, 0.00381306f, 0.00318365f, 0.09884468f, 0.02104522f, -0.05794128f, -0.09792235f, 0.00916904f, 
    -0.13613904f, -0.04239130f, -0.07764763f, 0.14189559f, 0.16729112f, 0.18348272f, 0.16735467f, 0.03178577f, 
    -0.04197228f, -0.03509683f, 0.07589950f, 0.07731074f, 0.00097815f, 0.00490416f, -0.05058947f, 0.04976016f, 
    0.02182891f, 0.08929232f, -0.03369971f, -0.05758821f, 0.01038500f, 0.27470902f, -0.06987737f, -0.02118710f, 
    0.09670072f, 0.12187029f, 0.09446190f, -0.02229969f, 0.05690779f, -0.00946642f, 0.03985539f, -0.01273608f, 
    0.02533224f, 0.04116292f, 0.10069649f, 0.02923025f, 0.02349574f, -0.03646565f, 0.07169821f, 0.00421335f, 
    0.12870879f, -0.04938874f, -0.09762755f, 0.02369850f, -0.12361094f, 0.06588292f, 0.05869299f, 0.06864116f, 
    0.02656018f, -0.09191607f, -0.03386479f, -0.04812866f, 0.09850401f, 0.04403230f, 0.13748345f, -0.00458616f, 
    0.02313631f, 0.04019810f, 0.06887997f, 0.06485694f, 0.01360227f, -0.04330413f, -0.19661151f, 0.03586895f, 
    -0.00903357f, 0.07909735f, -0.06264218f, 0.02011216f, -0.01605045f, -0.03138554f, 0.11510773f, -0.02078382f, 
    -0.04314579f, -0.05035061f, 0.01297605f, -0.02565373f, 0.01809543f, 0.05089821f, 0.07156730f, 0.09309588f, 
    0.19432591f, -0.15116701f, 0.16910437f, -0.00521254f, 0.04217202f, -0.05925196f, -0.09623856f, 0.14451300f, 
    0.09904565f, 0.11806197f, 0.00889214f, -0.03230928f, 0.00488296f, 0.11484707f, 0.02090853f, -0.00128396f, 
    -0.01563029f, 0.03468396f, 0.00644503f, 0.00141014f, 0.07647465f, 0.09128421f, 0.02271254f, 0.06340299f, 
    -0.06197314f, 0.02431202f, 0.07510680f, 0.05253501f, 0.03546904f, -0.05558473f, 0.04672815f, 0.06187152f, 
    0.06453370f, 0.04718793f, 0.00225151f, 0.01952653f, -0.02523889f, -0.04043366f, 0.02262747f, -0.02172126f, 
    -0.02753569f, -0.02240689f, 0.08771411f, -0.01029576f, 0.10628217f, -0.04045932f, -0.01986553f, 0.07042332f, 
    0.04089501f, 0.05164499f, 0.02775349f, 0.01807546f, 0.01910675f, -0.00389928f, 0.02889372f, -0.03322578f, 
    0.01284963f, 0.00628454f, 0.02543134f, 0.06437751f, 0.01870695f, -0.15996554f, -0.11031807f, -0.19709460f, 
    -0.12785140f, 0.02461195f, -0.06960503f, 0.02165176f, -0.09723154f, 0.07412010f, -0.00705292f, -0.01507364f, 
    0.02752761f, 0.01492757f, -0.08828089f, -0.08355591f, 0.01610821f, 0.01340936f, 0.02219356f, 0.00816008f, 
    0.13877943f, 0.07749743f, -0.19596797f, -0.00272325f, 0.16127308f, -0.05317422f, -0.08898131f, -0.12033414f, 
    0.14941688f, 0.05892252f, -0.00308043f, -0.07024116f, -0.00190123f, -0.03356033f, 0.06631722f, -0.02519232f, 
    -0.00342179f, 0.09229297f, -0.01975203f, 0.00449087f, -0.00056630f, -0.13078955f, 0.20814696f, -0.07758844f, 
    -0.04338533f, -0.04028425f, -0.01452575f, -0.02024157f, 0.01655263f, 0.03262011f, -0.02381476f, -0.03177566f, 
    -0.01416716f, 0.11751324f, -0.01428443f, -0.02379040f, 0.08532877f, -0.08232303f, -0.03652278f, 0.01924603f, 
    -0.11274332f, 0.04320282f, -0.02901549f, 0.04609758f, 0.05632418f, 0.11221244f, 0.00696378f, -0.00913716f, 
    -0.01813836f, -0.02490687f, -0.02146265f, 0.06053026f, -0.10925718f, -0.06135384f, 0.06839932f, 0.01444647f, 
    -0.03219566f, 0.02247794f, -0.01601211f, 0.09801052f, -0.12794675f, -0.01008945f, 0.16943403f, 0.04736583f, 
    0.12873091f, 0.03895433f, -0.02800585f, 0.09502111f, -0.00180504f, 0.02965566f, -0.00884867f, 0.00249726f, 
    -0.04594566f, 0.11801720f, 0.02869610f, 0.16354938f, 0.04020951f, 0.07226183f, 0.07725871f, 0.09887323f, 
    -0.02271578f, -0.04385658f, 0.02167162f, -0.05115801f, -0.05948100f, 0.02897519f, 0.12167901f, 0.05758842f, 
    -0.07951216f, 0.01088221f, 0.02869861f, 0.07595903f, 0.01200856f, -0.08453342f, 0.07219178f, -0.06047268f, 
    -0.04688923f, -0.07864144f, 0.05096583f, 0.04283101f, 0.51361680f, -0.11608849f, 0.06585798f, 0.27020642f, 
    -0.01007809f, -0.02699226f, 0.00687029f, 0.01199192f, 0.10650736f, -0.02366417f, 0.07788678f, 0.00781332f, 
    -0.06935716f, 0.05710611f, 0.08954116f, 0.08424743f, -0.00239805f, -0.02185321f, -0.10314617f, 0.04689498f, 
    0.07893472f, -0.11806481f, 0.00381293f, 0.01405574f, -0.13235782f, -0.01456798f, 0.00253442f, 0.09591164f, 
    0.08323852f, -0.06813691f, -0.14611666f, 0.06317958f, -0.01807018f, 0.02419576f, 0.04076936f, -0.06370441f, 
    0.00075435f, -0.04519215f, 0.05170447f, -0.02572028f, 0.09505832f, -0.11987852f, 0.23897259f, -0.00917213f, 
    -0.15385647f, -0.01889873f, 0.07769220f, -0.19617477f, -0.06223496f, -0.00351391f, -0.04589344f, -0.01842187f, 
    -0.03741305f, -0.04918070f, 0.00329686f, -0.01196502f, -0.03330683f, -0.04869476f, -0.04077508f, -0.03855996f, 
    0.06741463f, 0.05014361f, 0.15877160f, -0.18766209f, -0.14359409f, 0.00045967f, 0.00161148f, -0.09433734f, 
    -0.04031354f, 0.01075810f, 0.02057395f, 0.07433340f, -0.08183995f, -0.08079801f, 0.00066096f, 0.07007097f, 
    0.10894012f, 0.03709595f, 0.11487993f, -0.08812717f, 0.34904134f, -0.18329348f, -0.01964312f, 0.03560699f, 
    -0.01654798f, -0.02379422f, -0.09318455f, 0.02277349f, -0.04053814f, -0.01904763f, 0.06615576f, 0.07195342f, 
    -0.06296557f, -0.02268909f, -0.04396131f, -0.05028280f, 0.10334226f, 0.00963579f, -0.14446172f, -0.18648358f, 
    -0.16721174f, 0.12487277f, -0.08192357f, -0.06038547f, 0.04837437f, 0.01591894f, -0.01423108f, -0.00988857f, 
    0.08823477f, -0.00799085f, 0.07184252f, 0.07889108f, -0.01680727f, -0.02909323f, -0.09059360f, -0.01015230f, 
    -0.02315090f, 0.09303935f, -0.14924251f, -0.06040980f, 0.11296845f, 0.23212145f, -0.01997394f, 0.18721011f, 
    -0.00138951f, -0.00279374f, 0.11527691f, -0.05892435f, -0.04526637f, 0.00230191f, -0.03659207f, 0.07157994f, 
    0.02296336f, 0.05786702f, 0.04317363f, 0.03225028f, 0.10811336f, 0.02290666f, -0.03151629f, -0.00964701f, 
    -0.24652153f, 0.20576599f, 0.17244425f, -0.06039800f, 0.03268447f, 0.09713364f, 0.09152778f, -0.00046456f, 
    -0.01858845f, 0.07308579f, 0.00652927f, 0.02382775f, 0.02999531f, 0.12543203f, 0.03038784f, -0.00031952f, 
    -0.04615915f, -0.04130820f, -0.07074974f, -0.00531081f, 0.04486203f, -0.00469814f, -0.17040870f, -0.11410385f, 
    0.09549040f, -0.08083498f, -0.03264005f, -0.05371360f, 0.01466238f, 0.03321153f, -0.03283782f, -0.01415390f, 
    -0.11770442f, -0.01969517f, -0.00530657f, 0.05407357f, -0.02380185f, 0.01680071f, 0.08977471f, -0.00297033f, 
    0.05322413f, 0.01018667f, -0.08650460f, -0.06600446f, -0.01897316f, 0.05285759f, 0.03514429f, -0.01789101f, 
    0.08207493f, -0.00839739f, -0.06449199f, 0.07310720f, 0.06070262f, 0.09119537f, 0.08736274f, -0.07346892f, 
    -0.10134465f, 0.02251034f, -0.06857345f, 0.00359200f, -0.32121515f, 0.19632311f, -0.05909144f, 0.15503827f, 
    0.15467672f, 0.09508093f, -0.01657922f, -0.01328626f, -0.02497242f, -0.09621444f, 0.08613917f, 0.01180434f, 
    0.00130397f, -0.07798218f, 0.07729506f, 0.20077224f, 0.02213448f, -0.05075458f, -0.26398450f, -0.06521226f, 
    0.19350561f, -0.23673412f, 0.05127132f, -0.12979229f, -0.11250820f, 0.23547599f, -0.01469381f, 0.14806978f, 
    0.08681192f, 0.00612795f, 0.00511365f, -0.09982553f, 0.00293781f, 0.12361203f, -0.03780011f, 0.07326478f, 
    0.10473663f, -0.20375533f, -0.04805423f, -0.07911843f, 0.09538531f, -0.03076605f, -0.10974313f, 0.05738660f, 
    0.11488752f, -0.04937278f, 0.00951353f, 0.03513455f, 0.01606016f, -0.03049815f, 0.09074073f, 0.00994698f, 
    0.14251801f, -0.02762999f, 0.07683647f, 0.07248285f, 0.08669957f, -0.05791074f, 0.10263101f, 0.10628597f, 
    0.08012171f, 0.09066613f, -0.02961128f, -0.13233161f, -0.16338372f, -0.14624195f, 0.06116882f, -0.06792243f, 
    -0.04827606f, 0.05420393f, 0.07299630f, 0.07637890f, 0.05207248f, 0.01131801f, 0.05050988f, -0.02857391f, 
    0.00178119f, 0.13161361f, -0.11019190f, 0.02197909f, 0.10365420f, -0.10841165f, 0.01400289f, -0.13961048f, 
    0.06879302f, -0.19046457f, -0.05225153f, -0.07910663f, 0.06182901f, -0.13298751f, 0.04241377f, -0.03338495f, 
    -0.04068278f, 0.00787161f, 0.05113783f, -0.03436524f, 0.06483305f, -0.03657847f, -0.06897042f, 0.05503184f, 
    -0.13414617f, 0.22946575f, 0.14720486f, -0.04834924f, -0.07387675f, 0.06653824f, 0.04961738f, 0.11396267f, 
    -0.11416725f, -0.01089832f, 0.03083349f, 0.01263801f, 0.08072740f, 0.11648378f, 0.02079470f, -0.06440435f, 
    0.12834398f, -0.01506412f, 0.07860698f, -0.08421458f, -0.08085118f, 0.13849762f, 0.09998381f, -0.06064955f, 
    -0.07374185f, -0.09743114f, -0.08903341f, -0.03909733f, -0.00349610f, -0.00479254f, -0.06083408f, 0.05475843f, 
    -0.10759542f, -0.02269405f, -0.07566539f, -0.02929932f, 0.03773672f, -0.05523368f, 0.00477529f, -0.06833793f, 
    -0.01174040f, 0.50067914f, -0.01082867f, 0.06531902f, -0.04729927f, -0.03208906f, 0.00043236f, 0.01825747f, 
    -0.10122957f, 0.01441441f, 0.04978072f, -0.02742773f, 0.10212058f, -0.03152595f, -0.10787253f, 0.07936255f, 
    -0.04511268f, -0.02548468f, 0.11521000f, 0.16492102f, -0.38701418f, 0.29293320f, -0.21517168f, 0.17300349f, 
    0.09509863f, 0.13337047f, 0.01426655f, 0.06460223f, -0.05239908f, -0.07444525f, -0.04468559f, -0.00637010f, 
    0.10832594f, 0.08707155f, 0.05764413f, 0.08825701f, 0.02008391f, -0.05203721f, 0.01363075f, -0.02491134f, 
    -0.06076593f, 0.07722775f, -0.13021877f, 0.28157347f, 0.17020310f, 0.05650545f, 0.19030705f, 0.06542587f, 
    0.03003928f, 0.00989644f, 0.06490032f, 0.13941084f, 0.07962926f, -0.05421863f, 0.06587058f, 0.09839409f, 
    0.07288857f, 0.13698986f, -0.01099311f, 0.02971941f, 0.06756578f, -0.12777947f, -0.10193312f, 0.15370923f, 
    -0.02910832f, 0.04360633f, -0.02669215f, -0.13649878f, 0.03278336f, -0.01215092f, 0.06435998f, 0.01892089f, 
    0.02448121f, 0.03551250f, 0.08760730f, -0.01085966f, 0.08654784f, -0.03687977f, 0.06254610f, -0.01949988f, 
    0.18234713f, -0.01708182f, -0.08196343f, 0.15963665f, -0.11035269f, 0.08129460f, 0.05021755f, 0.02192965f, 
    0.06996634f, -0.01118433f, 0.02239945f, -0.03087373f, -0.01795397f, 0.04222106f, 0.03545373f, 0.05109834f, 
    -0.02368772f, -0.01139113f, -0.05939116f, 0.03860565f, 0.15491395f, 0.08402231f, -0.10754377f, 0.05991499f, 
    -0.02589784f, -0.05032461f, -0.01672817f, -0.04229934f, 0.01834243f, 0.09815144f, 0.09795762f, -0.00032008f, 
    -0.05628392f, 0.03617162f, -0.07104182f, 0.04168302f, 0.11312214f, 0.00490576f, 0.01232066f, 0.06352419f, 
    0.05025040f, -0.14019637f, -0.11836686f, -0.01380736f, 0.16299701f, -0.14371248f, -0.17165431f, 0.07010625f, 
    -0.08280914f, 0.08619614f, -0.06475723f, -0.03056785f, 0.04149994f, 0.13816035f, -0.03316068f, 0.02679310f, 
    -0.02838743f, 0.04504756f, 0.03245494f, 0.06330375f, 0.03732950f, 0.10821639f, 0.11557358f, 0.11155578f, 
    -0.06821030f, -0.00163972f, 0.04436278f, 0.14053205f, -0.03708423f, -0.01324144f, -0.00965288f, 0.02327068f, 
    -0.03681712f, -0.05482861f, -0.03056753f, -0.00376838f, -0.02212343f, 0.11458514f, -0.05954838f, -0.04248060f, 
    -0.11795950f, -0.13198386f, 0.13064831f, -0.16929987f, 0.13523889f, -0.16312535f, -0.08023532f, -0.04032553f, 
    -0.07051114f, -0.01526098f, -0.06966272f, 0.01926313f, 0.01572615f, -0.03718419f, 0.09702236f, -0.07900941f, 
    -0.02213766f, 0.03507240f, 0.03865627f, 0.05870755f, -0.05944929f, -0.16778502f, -0.22234021f, 0.01173263f, 
    -0.00200545f, -0.02583667f, -0.05789743f, -0.01552478f, -0.00973645f, -0.01048790f, 0.00211160f, -0.00608184f, 
    0.07951995f, -0.03835035f, -0.05062342f, -0.05021895f, -0.11623985f, -0.09606850f, 0.07873899f, 0.06907913f, 
    0.00661313f, -0.26213095f, -0.08038571f, -0.09064668f, -0.04642024f, -0.16573720f, -0.07484481f, -0.10059901f, 
    0.04591432f, 0.03434392f, -0.07762908f, -0.08927711f, 0.07933840f, -0.00572487f, 0.02074619f, 0.04835571f, 
    0.12010936f, 0.13362782f, 0.03864511f, -0.00064407f, -0.03606270f, -0.09898605f, 0.27061644f, -0.11618600f, 
    -0.08289108f, -0.09716592f, -0.05129475f, 0.11044776f, -0.17565116f, -0.08081137f, 0.00907025f, -0.00944878f, 
    -0.04881099f, -0.03880888f, 0.10748858f, -0.02855526f, 0.12933196f, 0.06915380f, 0.11725256f, 0.05481644f, 
    0.10837559f, 0.18333595f, 0.18090725f, 0.14496614f, 0.08529405f, 0.04459603f, 0.07028736f, 0.01122998f, 
    0.00954881f, 0.04641750f, 0.02441338f, -0.04411304f, -0.01722140f, -0.00367144f, -0.11645075f, -0.02016337f, 
    -0.00134772f, 0.02258664f, 0.04020256f, -0.00435160f, -0.05635103f, 0.13488649f, 0.02296586f, 0.26060295f, 
    0.15725036f, 0.11156636f, -0.05759707f, 0.05450294f, -0.03412409f, 0.14294516f, -0.04614547f, 0.04318255f, 
    0.11595572f, -0.03777730f, -0.12136099f, 0.04751675f, 0.01602142f, 0.01936423f, 0.05888905f, -0.07660715f, 
    0.23851329f, -0.10395031f, -0.01723583f, 0.03011366f, -0.10869751f, -0.07706694f, 0.03373853f, 0.04216388f, 
    0.00323892f, -0.00431583f, -0.06062101f, -0.02934478f, -0.03188302f, 0.06983081f, -0.06236479f, 0.02862257f, 
    0.03178500f, -0.04312509f, 0.15291044f, 0.05439776f, 0.29813361f, -0.10302097f, -0.01538442f, -0.02655149f, 
    -0.07463206f, -0.00393103f, 0.01122499f, 0.06299172f, -0.04769174f, 0.06612173f, -0.05726145f, 0.03955936f, 
    0.03889576f, 0.10038707f, 0.03391804f, 0.07390838f, 0.03390045f, 0.03037195f, 0.09552413f, 0.03488608f, 
    -0.01541480f, 0.00621261f, 0.05435601f, -0.26307708f, 0.16136953f, -0.03962720f, 0.08732984f, -0.01155915f, 
    0.07133605f, 0.05199845f, -0.01747500f, 0.07670052f, -0.02029811f, 0.09144815f, 0.02495961f, 0.06553970f, 
    0.09413944f, 0.00235653f, 0.05813332f, 0.15618148f, 0.09537839f, -0.47252306f, -0.09648028f, -0.09752036f, 
    -0.06260957f, 0.17359027f, 0.15709360f, 0.04477806f, -0.01738419f, -0.07891174f, 0.03784391f, -0.04816547f, 
    -0.02711478f, 0.15919727f, -0.08335530f, -0.01241683f, 0.03948595f, 0.03479394f, 0.02440064f, -0.00554084f, 
    -0.08150079f, -0.24300943f, -0.04231951f, -0.24730951f, -0.07456513f, 0.11372815f, 0.01905251f, -0.01721539f, 
    -0.02343543f, -0.02271454f, -0.04961162f, -0.00600178f, 0.15292163f, 0.06376884f, 0.03178713f, -0.07377760f, 
    0.01924991f, -0.02381192f, -0.10672951f, -0.05549397f, -0.08056816f, 0.19110581f, -0.03971779f, -0.10296863f, 
    0.11326201f, 0.09983891f, 0.05176505f, -0.03170379f, 0.01187815f, 0.04767936f, -0.04338850f, 0.02953501f, 
    -0.05214909f, 0.01667547f, -0.14973582f, 0.09140404f, -0.06191209f, 0.03620915f, 0.00492819f, -0.04002021f, 
    0.05174468f, 0.16213289f, 0.06622067f, 0.02237568f, -0.08604690f, 0.06266052f, -0.02006728f, 0.00455667f, 
    0.03887796f, 0.00787542f, -0.02790528f, -0.00156762f, 0.09720926f, -0.09755655f, 0.02302445f, 0.02858019f, 
    -0.00262187f, 0.01567909f, 0.17617148f, 0.02555583f, -0.19068791f, 0.13876052f, -0.00480367f, 0.00530937f, 
    0.05680705f, 0.05522354f, 0.00033266f, 0.00971239f, -0.00489835f, -0.08990756f, -0.02576599f, -0.00200066f, 
    0.05036852f, 0.01640968f, -0.01038569f, 0.06157977f, -0.02035508f, 0.04216501f, -0.02889356f, 0.06350412f, 
    0.05627532f, 0.09902720f, 0.06326021f, 0.11491347f, 0.01941424f, 0.07322619f, 0.03748773f, -0.03631818f, 
    0.05189572f, 0.21061775f, -0.01663800f, 0.08904924f, -0.02722741f, -0.12754621f, -0.03273635f, 0.02320873f, 
    0.02573462f, -0.04524959f, 0.12692767f, -0.03759522f, -0.02364506f, 0.00818418f, -0.09819882f, -0.15043144f, 
    0.06570703f, 0.00972281f, -0.00170558f, 0.05616525f, 0.00937558f, 0.02867938f, 0.04099562f, -0.00099618f, 
    0.06875118f, 0.01812332f, -0.03588307f, 0.11844286f, 0.06968054f, 0.05649955f, 0.02165281f, 0.04052752f, 
    0.22729783f, 0.11566052f, 0.10590865f, 0.30407402f, 0.18269040f, -0.01481826f, -0.09613664f, -0.00041607f, 
    0.03636296f, 0.07163644f, -0.01744264f, -0.05152696f, -0.01726372f, -0.01035949f, 0.04083799f, 0.07573350f, 
    0.08445506f, 0.04622320f, -0.02614426f, 0.07758628f, -0.26582637f, 0.25021577f, 0.18821186f, 0.00160098f, 
    -0.18469740f, 0.12865259f, 0.15331626f, -0.04046867f, -0.09213959f, -0.05364211f, 0.03107931f, -0.04175922f, 
    0.00689066f, 0.10222661f, 0.09776292f, -0.00538733f, 0.03334607f, 0.09037173f, -0.02315841f, 0.01958443f, 
    -0.11937976f, 0.07968704f, -0.18381682f, -0.01149365f, 0.11762973f, 0.00224055f, -0.06202391f, -0.05166728f, 
    -0.07181114f, -0.03101448f, 0.08732119f, 0.11563250f, 0.05459347f, -0.07748239f, 0.04123328f, -0.03756254f, 
    0.02068893f, -0.03891997f, 0.00846289f, 0.02085791f, 0.17086901f, 0.01235718f, 0.04664628f, 0.04724813f, 
    0.20094508f, 0.07371308f, 0.04833398f, 0.03125743f, 0.02211174f, 0.12157057f, -0.05654205f, 0.06996614f, 
    0.07760297f, 0.04950028f, -0.13070975f, 0.04731242f, -0.01306815f, 0.06969389f, -0.08111466f, -0.06355330f, 
    -0.18314090f, -0.35216457f, 0.03998829f, -0.01843242f, -0.24698135f, -0.00943273f, 0.07466968f, 0.02772392f, 
    0.01433465f, -0.07777110f, 0.03249171f, -0.02535933f, 0.06508621f, 0.02684296f, 0.00825569f, 0.00176190f, 
    0.04904682f, 0.06687154f, -0.05031445f, 0.02130385f, -0.06768605f, -0.38081762f, -0.10990937f, -0.19619808f, 
    -0.17445974f, 0.09846971f, -0.05999352f, 0.02840090f, -0.02161443f, 0.02793636f, 0.02522339f, -0.05037385f, 
    0.02346979f, 0.07251024f, -0.00402884f, -0.07728700f, 0.08654711f, 0.13409305f, -0.08168872f, 0.07865375f, 
    -0.13898449f, -0.19157009f, -0.13128197f, -0.03880538f, -0.11952156f, -0.02512261f, 0.03234660f, 0.03332304f, 
    0.06617665f, -0.01832815f, 0.06020257f, 0.03909202f, 0.03703712f, -0.03105682f, 0.00194062f, 0.13117042f, 
    0.13972530f, 0.05148758f, 0.05964927f, 0.05235233f, -0.16779096f, 0.02020939f, -0.08219876f, -0.25113219f, 
    -0.17319031f, 0.07929047f, 0.05774732f, -0.06691624f, -0.08116091f, -0.02005986f, 0.07352956f, -0.12185796f, 
    0.03685954f, -0.05658070f, -0.06897444f, -0.03259793f, -0.02244654f, 0.04163276f, 0.19522090f, 0.05879006f, 
    0.11828637f, -0.10583103f, -0.14254040f, -0.09892736f, -0.16126724f, -0.11258087f, 0.00911895f, -0.01523135f, 
    -0.01213158f, -0.00573064f, 0.08877227f, 0.08900473f, -0.05200295f, -0.00640537f, 0.00820619f, 0.02808976f, 
    -0.03078187f, 0.15599427f, -0.03193907f, -0.05730893f, 0.07390652f, 0.26233438f, -0.01949848f, 0.08334310f, 
    0.27707464f, 0.03668986f, -0.00014644f, -0.00333150f, -0.00520950f, -0.08083896f, 0.04413884f, -0.00690299f, 
    0.02470655f, -0.02495227f, 0.06807984f, -0.02314558f, -0.00010359f, 0.05492404f, -0.00722645f, 0.00798210f, 
    -0.06080346f, -0.01225582f, 0.03241473f, 0.12193575f, 0.18154705f, 0.03833158f, -0.04229115f, -0.03820573f, 
    -0.04153900f, -0.01464543f, -0.02330569f, 0.09270369f, 0.07853211f, 0.03371050f, 0.03103760f, 0.00933433f, 
    -0.01584559f, -0.01784763f, -0.08584593f, 0.01364759f, 0.03732355f, 0.23130473f, 0.17608224f, -0.11503024f, 
    0.12721056f, 0.05073388f, 0.09489783f, 0.06069584f, -0.01944393f, 0.04601650f, -0.01872751f, -0.02499482f, 
    0.05836580f, 0.03532412f, -0.00369582f, 0.05250611f, 0.00433656f, -0.08171229f, -0.02727855f, 0.04081367f, 
    0.15024777f, -0.07334201f, 0.14444251f, -0.11360765f, 0.06015003f, -0.05859287f, -0.01316005f, -0.00293990f, 
    -0.01862480f, 0.00890003f, -0.02713164f, 0.00446060f, 0.04904198f, 0.06652990f, 0.07709952f, 0.06414367f, 
    -0.00793554f, 0.04772653f, 0.03580729f, 0.05278058f, -0.29602459f, -0.21995252f, -0.06168119f, -0.12898928f, 
    -0.18105417f, -0.03811425f, -0.03360061f, 0.02416871f, -0.02840562f, 0.02470178f, 0.00651751f, -0.03032640f, 
    -0.03036088f, -0.03157492f, -0.08363897f, 0.07510330f, -0.06904658f, 0.01074664f, 0.03248290f, 0.02837796f, 
    0.04349113f, -0.11615535f, 0.05753324f, -0.01493182f, -0.00973582f, 0.10333145f, 0.06087968f, 0.06530046f, 
    0.09741180f, 0.10598796f, 0.03974140f, -0.00056225f, -0.08652192f, 0.04695722f, 0.03794672f, 0.05518027f, 
    0.04095762f, 0.06438281f, -0.07760420f, -0.05714656f, -0.02260712f, -0.16696310f, -0.03915083f, -0.09408773f, 
    -0.24990563f, 0.03907516f, 0.05686975f, -0.03244841f, -0.00802035f, -0.08050648f, 0.07846233f, 0.01670604f, 
    0.02916686f, -0.00066176f, 0.00810071f, -0.04032627f, 0.04252591f, 0.03131561f, 0.00745717f, -0.00161238f, 
    -0.06447172f, -0.04848374f, -0.05482922f, 0.00432800f, -0.05671556f, -0.02917751f, 0.03727635f, 0.01420419f, 
    0.04840446f, 0.10814395f, 0.05966626f, 0.00604384f, 0.03767078f, 0.05322337f, 0.03146444f, 0.06981587f, 
    0.05350900f, 0.06717350f, -0.00653568f, 0.05212773f, 0.41386154f, 0.00574249f, 0.18356825f, -0.01960479f, 
    0.10475437f, 0.02452513f, 0.02899772f, 0.00247262f, -0.08060498f, -0.03490754f, -0.01282531f, 0.02168399f, 
    -0.01441890f, 0.07050078f, -0.11654821f, 0.04726847f, -0.01430636f, 0.06138054f, 0.06823479f, -0.03701765f, 
    0.22726066f, 0.29102185f, 0.07607942f, -0.01166944f, 0.15949374f, 0.02033743f, -0.02656047f, -0.09643507f, 
    0.02184498f, 0.12064198f, 0.10639189f, -0.02809983f, -0.09289306f, 0.09847236f, 0.12132856f, 0.00674072f, 
    -0.04273897f, -0.06064794f, 0.03739478f, 0.04508262f, 0.00601271f, -0.11034331f, -0.11261563f, -0.01154938f, 
    -0.25111476f, -0.05533162f, 0.02374567f, -0.04742879f, 0.00321077f, 0.07402010f, 0.07879066f, 0.02542014f, 
    -0.00753960f, 0.01734639f, 0.05980068f, -0.01123705f, 0.03444089f, 0.03228298f, -0.01803913f, -0.01804222f, 
    -0.26559684f, -0.07800426f, -0.17584641f, 0.15881337f, 0.13227083f, 0.06644372f, 0.01084132f, 0.01599290f, 
    0.02876651f, 0.07320400f, -0.04379964f, 0.13641486f, 0.01370145f, 0.00143108f, -0.01407281f, 0.05805798f, 
    -0.01699507f, 0.04013962f, 0.07943043f, 0.08521108f, -0.33651516f, 0.01375640f, -0.15128376f, -0.04474051f, 
    -0.11050837f, 0.04111915f, 0.04736777f, -0.02077127f, -0.09672210f, 0.20371823f, -0.04313267f, 0.19076434f, 
    0.02437355f, -0.08614508f, -0.03994513f, 0.16543142f, 0.03272418f, -0.03045409f, 0.03108048f, -0.04329814f, 
    -0.13334234f, -0.08141401f, -0.01211197f, 0.07284814f, 0.04329228f, -0.11680548f, -0.03560280f, -0.02769908f, 
    0.13305700f, 0.02794055f, 0.07898451f, 0.04734480f, -0.09706447f, -0.12348783f, 0.05327117f, -0.04905665f, 
    -0.05789333f, -0.05709177f, 0.03230313f, 0.04587978f, 0.14609057f, -0.24986361f, -0.03374345f, 0.12074307f, 
    -0.06801922f, 0.04886920f, 0.12034063f, 0.00080819f, 0.07125535f, 0.06088592f, 0.06164619f, -0.01964441f, 
    -0.02656117f, 0.08334409f, 0.01863466f, 0.02469163f, -0.11679340f, 0.04502797f, 0.00024828f, -0.09929927f, 
    -0.42287675f, -0.05029675f, 0.04494715f, 0.14211881f, -0.19063590f, 0.12748744f, -0.07826690f, -0.00989046f, 
    0.07886493f, -0.02424857f, -0.04556387f, -0.00619867f, -0.08107917f, 0.02639321f, 0.08661924f, -0.01666949f, 
    -0.04317374f, 0.06448326f, 0.05415800f, -0.00564949f, 0.04027835f, -0.00323652f, 0.18877900f, 0.14172427f, 
    -0.02168695f, 0.01707174f, 0.09783074f, -0.01533076f, -0.05903138f, 0.02715899f, -0.01958754f, -0.05752813f, 
    0.10550861f, 0.00693275f, -0.06479249f, -0.13098381f, -0.05121085f, -0.07178708f, 0.13025884f, 0.02661097f, 
    -0.00185527f, 0.00616032f, 0.27592096f, 0.02212927f, -0.11386386f, -0.06917923f, 0.00834391f, 0.00009747f, 
    0.04199691f, 0.05408368f, -0.04423384f, -0.16048597f, -0.02329137f, 0.05365685f, 0.09322535f, -0.02825088f, 
    0.08803616f, -0.07174673f, 0.04152218f, 0.05578633f, -0.11825833f, 0.00377188f, 0.09251192f, 0.01731882f, 
    -0.14460270f, 0.07545864f, -0.08259673f, 0.00562490f, -0.07908356f, 0.02624384f, 0.01416117f, -0.01902642f, 
    -0.05740415f, 0.02121065f, -0.08968239f, -0.05865433f, 0.09316751f, -0.00685398f, -0.04550876f, -0.01721947f, 
    -0.11436646f, 0.08494117f, 0.01251020f, 0.03859992f, 0.16177475f, -0.05169883f, 0.01537415f, -0.01261435f, 
    0.03995270f, 0.06195837f, -0.03891888f, 0.02740765f, -0.09715412f, 0.01083310f, -0.02374367f, 0.00568386f, 
    0.02066204f, -0.02126688f, 0.01783914f, 0.07461563f, 0.08307134f, -0.03040563f, 0.08569483f, 0.03520362f, 
    -0.19378982f, -0.11472720f, -0.06487962f, -0.03329474f, 0.06709296f, -0.02108400f, -0.03160572f, -0.08022683f, 
    0.04280015f, 0.07884019f, 0.04574442f, -0.00115546f, -0.03172981f, -0.04199085f, 0.01762303f, 0.07775187f, 
    -0.17985451f, 0.17609155f, -0.21825062f, -0.02431636f, -0.15802616f, 0.15581831f, -0.01653024f, -0.06242668f, 
    -0.00571492f, -0.02999105f, -0.04910882f, -0.02552808f, 0.02463468f, -0.05533442f, -0.00181723f, 0.13454549f, 
    0.02844505f, -0.07782041f, -0.00841750f, 0.03113811f, -0.06473865f, 0.04780253f, 0.16652380f, 0.05834828f, 
    0.02109394f, -0.06492943f, 0.04351832f, -0.07732522f, -0.02019968f, 0.06416371f, -0.04711446f, -0.00608783f, 
    0.02735266f, 0.09073965f, 0.11630223f, 0.03407359f, -0.02465528f, 0.03133515f, -0.13691576f, 0.05628453f, 
    -0.02321761f, -0.03495919f, -0.25682509f, -0.08677014f, -0.11978355f, 0.11614770f, 0.04765341f, 0.01336592f, 
    0.03498748f, -0.01079634f, -0.01995237f, 0.10440442f, 0.02279264f, 0.01529930f, 0.02071264f, 0.13321222f, 
    -0.05355043f, 0.04354912f, 0.06743984f, 0.02463151f, -0.02519571f, 0.23945820f, 0.16472158f, 0.12963367f, 
    0.21684729f, 0.13026099f, 0.06076838f, 0.01686405f, 0.00490372f, -0.15752357f, 0.00342689f, 0.01444745f, 
    0.00176665f, -0.00370020f, 0.10177626f, 0.05315372f, 0.00756120f, 0.12068398f, -0.08408854f, 0.01285354f, 
    -0.09758877f, 0.03470040f, 0.11823014f, -0.00376316f, -0.02257601f, 0.02149985f, 0.04254885f, 0.11137235f, 
    -0.06937320f, 0.03451655f, 0.05323609f, -0.04486587f, -0.02441563f, -0.04512073f, -0.03643605f, 0.10124015f, 
    0.02892521f, 0.06440987f, 0.05571921f, 0.03050455f, 0.13680488f, 0.01710076f, -0.14037551f, 0.15377058f, 
    -0.02317103f, 0.01152159f, -0.06464139f, 0.06383498f, 0.04637126f, 0.06812949f, 0.04390982f, -0.01407788f, 
    0.02866112f, -0.09412341f, -0.01780885f, -0.03804260f, 0.07044508f, -0.00315685f, 0.05227312f, 0.05216078f, 
    0.18296205f, -0.00359405f, -0.11614271f, -0.00723195f, -0.11993989f, 0.12349744f, -0.02190468f, 0.03369355f, 
    0.02926647f, -0.07980740f, 0.07570838f, -0.03504017f, -0.09871471f, -0.03779835f, -0.06902594f, 0.09820437f, 
    -0.01829825f, 0.11071941f, 0.09317360f, 0.07181165f, 0.24335493f, -0.05717139f, 0.21245617f, 0.08762397f, 
    0.04761961f, 0.00735317f, -0.03058941f, 0.01771886f, 0.12823394f, -0.06947021f, 0.00634758f, -0.10206957f, 
    -0.13616307f, 0.04098966f, -0.07099693f, 0.02695361f, -0.07749548f, 0.10015884f, -0.01037807f, 0.12018344f, 
    0.05277008f, 0.07525986f, -0.04407430f, -0.01773188f, -0.10352702f, 0.05478498f, 0.01732199f, -0.01276724f, 
    -0.04858911f, 0.05444464f, -0.07431439f, 0.00674182f, 0.01877493f, -0.11595861f, 0.02265755f, -0.02426933f, 
    0.07118776f, 0.07154010f, 0.16421881f, -0.05738110f, 0.39444762f, 0.17997725f, -0.01094717f, -0.06971515f, 
    0.21843079f, -0.16497843f, 0.01487910f, 0.01261064f, 0.08564257f, 0.07825734f, -0.01124029f, 0.01907872f, 
    -0.07452225f, 0.03737133f, 0.09051975f, 0.09414642f, 0.06233341f, 0.01400843f, 0.04701686f, 0.05938543f, 
    0.19946402f, -0.12465522f, -0.02472634f, -0.08860920f, 0.01209412f, -0.05521196f, -0.03500204f, 0.02904202f, 
    0.00720831f, -0.05129083f, -0.07403699f, 0.13240954f, -0.00971534f, -0.04912915f, 0.05356807f, 0.11608159f, 
    0.04674427f, -0.10131890f, -0.07412362f, -0.00081737f, -0.01571511f, 0.08585335f, 0.06283890f, -0.16692477f, 
    -0.06082940f, -0.07330542f, -0.09769125f, -0.19884162f, -0.04441298f, 0.09663576f, 0.03164104f, 0.00955940f, 
    0.00299347f, -0.13152826f, 0.13346088f, 0.05742949f, 0.03395907f, -0.12379379f, -0.03341055f, -0.03123077f, 
    0.06416753f, 0.00736922f, 0.17057824f, -0.02262447f, -0.02686096f, -0.08164182f, 0.03618000f, -0.15624091f, 
    -0.21449707f, -0.04409704f, 0.04217314f, 0.13232097f, -0.03872969f, -0.03002212f, 0.02985485f, 0.12268687f, 
    -0.01550711f, 0.01585199f, 0.01842280f, 0.09486703f, 0.30864143f, 0.03249964f, -0.19584297f, -0.32062721f, 
    0.09847769f, -0.05615465f, -0.01863645f, -0.00667389f, 0.12315785f, 0.12704885f, 0.04133830f, 0.05654729f, 
    0.00941677f, -0.01827462f, 0.11081644f, -0.02773699f, -0.04292079f, -0.05539317f, -0.10597396f, -0.00831191f, 
    -0.05767769f, 0.01425805f, -0.11763225f, -0.23026150f, -0.12678510f, 0.03453349f, -0.00043062f, 0.02484684f, 
    0.04746315f, -0.00392635f, 0.01406221f, 0.06589423f, -0.05760724f, 0.12147738f, 0.04651248f, 0.01722877f, 
    -0.00586038f, 0.12166371f, -0.20528063f, -0.02123323f, 0.03968590f, 0.01322909f, -0.16597825f, 0.08493989f, 
    -0.00312320f, 0.09954484f, 0.04547063f, 0.05760616f, -0.07316047f, -0.11165081f, 0.05590428f, 0.13904646f, 
    0.05010327f, 0.03858416f, 0.14138992f, -0.04389013f, 0.14534847f, 0.08282482f, -0.05824279f, -0.06092440f, 
    -0.14364898f, -0.02637541f, 0.31498918f, 0.06882753f, 0.02226137f, -0.04431285f, -0.06368399f, 0.15765297f, 
    0.02750242f, -0.00670786f, -0.05143765f, -0.07092208f, 0.00136926f, 0.10984013f, -0.09237113f, -0.00701127f, 
    0.03130610f, 0.08001743f, -0.11989821f, -0.00414252f, 0.05872715f, -0.00245720f, -0.05007278f, 0.08334131f, 
    0.04341487f, 0.04687735f, 0.07300835f, -0.10126053f, -0.00493269f, -0.06187027f, 0.00222409f, 0.09943508f, 
    -0.08230812f, -0.03280728f, -0.09793759f, 0.00291061f, 0.06216637f, 0.02892955f, 0.22288798f, 0.02147400f, 
    0.10141835f, 0.07849266f, -0.07690629f, -0.12617388f, 0.12459031f, -0.00885415f, -0.01604832f, -0.03655729f, 
    0.15357426f, 0.03921384f, 0.03174219f, -0.04936549f, -0.08088661f, 0.04457842f, 0.00411766f, -0.02180551f, 
    -0.01096904f, -0.01084730f, 0.02561361f, -0.01397695f, -0.12736452f, -0.04903689f, -0.07933023f, -0.08746052f, 
    -0.07523440f, 0.05491122f, -0.03919586f, 0.01106418f, 0.01483438f, -0.00955484f, 0.00845934f, 0.00590267f, 
    0.07305105f, -0.06092564f, 0.02815230f, 0.12485772f, 0.02577800f, -0.23395297f, -0.33542976f, 0.00691173f, 
    0.21505857f, -0.16938002f, -0.15610667f, -0.02170011f, 0.16884477f, 0.03765230f, -0.03216112f, 0.05571773f, 
    0.08664671f, 0.12265837f, -0.07972744f, -0.03695006f, 0.08156075f, 0.19625503f, 0.05867669f, 0.04309696f, 
    0.09656447f, -0.15179089f, -0.09498153f, -0.03340650f, 0.03103439f, 0.03732287f, -0.13876005f, 0.09275052f, 
    0.16411407f, -0.07924204f, 0.00845548f, -0.02473935f, 0.09644367f, 0.00428789f, 0.01248784f, 0.09828591f, 
    0.01305084f, 0.01680213f, 0.03413919f, 0.03843686f, 0.07484201f, -0.07692736f, 0.13836327f, 0.12790762f, 
    -0.09207311f, 0.05405089f, 0.21662281f, 0.13938537f, -0.05409514f, 0.05711685f, 0.07512909f, -0.05596048f, 
    0.07447810f, -0.06464709f, -0.02406864f, 0.03254600f, 0.08608455f, 0.03949158f, 0.02318074f, -0.04422744f, 
    0.05277891f, -0.01303058f, -0.00964593f, 0.00233409f, -0.07119164f, 0.12333130f, 0.09968757f, 0.07348242f, 
    -0.14449964f, 0.14246802f, -0.10500554f, 0.15178123f, -0.05059325f, 0.23070024f, -0.05838232f, 0.08010087f, 
    0.04748810f, -0.01583968f, -0.06309012f, 0.03785989f, 0.04966840f, 0.04105463f, 0.10194905f, -0.03051480f, 
    0.06810645f, -0.20814210f, 0.01338396f, -0.02839694f, -0.01553102f, -0.04603874f, -0.02455737f, -0.06305619f, 
    0.04602631f, -0.01527283f, 0.05707064f, 0.09916189f, -0.01605783f, 0.13509166f, -0.06396082f, 0.09457419f, 
    0.05544873f, -0.10888394f, -0.08653741f, 0.13512175f, 0.15395305f, -0.21182142f, 0.08188024f, 0.12735736f, 
    -0.07217632f, 0.05164389f, 0.01963271f, 0.00016073f, -0.01981884f, 0.08167542f, -0.03860897f, 0.07000405f, 
    0.09388736f, 0.01196880f, 0.05071849f, 0.06956901f, 0.00039027f, -0.00603624f, 0.12300739f, 0.01658691f, 
    0.01671609f, -0.01427371f, -0.04896054f, -0.09978697f, -0.13548633f, -0.07975720f, 0.06929453f, 0.05775767f, 
    0.03249379f, 0.05488829f, -0.03353043f, 0.13920125f, -0.08390945f, 0.12078633f, -0.00748584f, -0.06404052f, 
    -0.03248413f, 0.02684409f, -0.03819821f, 0.04076575f, -0.03926679f, -0.32063013f, -0.19818529f, -0.04725327f, 
    0.12093026f, 0.00619691f, 0.11476126f, -0.10510764f, -0.08259546f, -0.04867432f, -0.04509653f, 0.01174400f, 
    0.06191804f, -0.09921503f, -0.01804326f, 0.02686544f, 0.07558431f, 0.00269739f, -0.00312364f, 0.00219618f, 
    -0.18678421f, -0.21312290f, -0.03505087f, -0.08018211f, 0.10226583f, 0.01494128f, -0.09176960f, -0.07136969f, 
    -0.11382871f, 0.04202164f, -0.04679416f, -0.09248417f, 0.04745171f, 0.01986043f, 0.04043771f, -0.04787255f, 
    0.07665808f, -0.04767440f, -0.05563419f, -0.12868103f, -0.08876081f, 0.27588779f, 0.12355424f, -0.15124218f, 
    -0.02079631f, 0.07130227f, 0.01111735f, -0.04696590f, -0.10683876f, 0.00739952f, -0.04592508f, -0.01789146f, 
    0.05248620f, -0.04659539f, -0.13848364f, 0.03799139f, 0.02995395f, 0.02327642f, 0.11487886f, -0.03861158f, 
    0.02983641f, 0.11331370f, -0.04552811f, -0.18334632f, 0.05696384f, -0.06683638f, -0.08169284f, -0.00558745f, 
    -0.09498659f, -0.05392655f, 0.03616208f, -0.04121317f, 0.06994373f, -0.02913842f, 0.00902111f, -0.07503974f, 
    0.10659659f, -0.01073049f, 0.17033473f, 0.05854673f, -0.07456327f, 0.03484511f, -0.01368529f, -0.07085709f, 
    -0.14570662f, -0.09663237f, -0.01144207f, 0.00874983f, 0.05824365f, -0.08471090f, -0.00578825f, 0.06250669f, 
    0.04254757f, 0.05032193f, -0.01415588f, 0.11222773f, -0.02303563f, -0.00350190f, 0.07949848f, 0.00332876f, 
    -0.12716322f, 0.30417308f, 0.02279117f, 0.03154897f, -0.02899550f, 0.02752587f, -0.01752736f, -0.03781333f, 
    0.05467278f, 0.12244039f, -0.00029298f, -0.00394474f, -0.04316102f, -0.06029942f, 0.12999344f, -0.01778244f, 
    0.06312498f, -0.07868657f, 0.11106852f, -0.06098373f, 0.02298206f, -0.06014124f, -0.08075392f, -0.12046780f, 
    -0.11137751f, -0.08688299f, 0.02586950f, 0.03196300f, -0.04159397f, -0.03986517f, -0.03953879f, 0.01867875f, 
    0.09826430f, -0.02649460f, 0.01448805f, -0.00812170f, 0.06876251f, -0.02406598f, -0.07932439f, 0.01250629f, 
    0.05311036f, 0.19633137f, 0.13698640f, 0.21533933f, 0.09727655f, -0.02548371f, 0.01903418f, 0.03270504f, 
    0.05575304f, -0.01145029f, 0.00758942f, 0.10216624f, -0.03579776f, 0.03865631f, 0.10108863f, 0.07595970f, 
    0.06855728f, 0.01923690f, -0.03594781f, 0.07746089f, 0.27178782f, 0.18076862f, 0.08934302f, -0.05933308f, 
    0.05122397f, -0.07502215f, 0.01623356f, -0.07689942f, -0.17044038f, -0.17212476f, -0.00117653f, 0.06531122f, 
    -0.02345835f, 0.00860424f, 0.05665440f, 0.06281610f, -0.02039496f, 0.11867401f, 0.07256789f, -0.03756875f, 
    0.14310104f, 0.41425106f, 0.05344200f, -0.08364638f, 0.07412481f, -0.06644039f, -0.10746320f, 0.03913930f, 
    0.00216920f, 0.00863104f, 0.11848900f, -0.03320820f, -0.00122581f, -0.07924527f, 0.03497304f, 0.07254767f, 
    0.01108391f, 0.05004154f, 0.11931500f, -0.00563410f, 0.16067326f, -0.05976042f, 0.09594619f, 0.10942277f, 
    -0.02391025f, 0.09074409f, 0.09941596f, -0.01598014f, 0.05723384f, 0.12256273f, -0.00723883f, 0.15827556f, 
    0.03652791f, 0.04268375f, -0.08284552f, -0.00161837f, -0.05625882f, -0.00225808f, -0.15758495f, -0.06924859f, 
    -0.00943332f, -0.11420644f, 0.09568159f, 0.15792042f, -0.03187999f, 0.10419123f, 0.08808997f, -0.00200483f, 
    0.07838070f, -0.03453502f, -0.01589997f, 0.02435292f, -0.01103052f, -0.00701827f, -0.06294443f, -0.03406242f, 
    0.06658380f, 0.07384888f, 0.03259185f, 0.00160156f, -0.12067234f, -0.08645982f, 0.04656472f, 0.22399887f, 
    0.04301682f, 0.14269605f, 0.00348987f, 0.06025675f, 0.06366307f, 0.28259271f, -0.00478286f, -0.03378117f, 
    0.03758062f, 0.04568745f, -0.09483721f, 0.05451557f, -0.02502416f, 0.06197728f, 0.18285401f, 0.04952570f, 
    0.23494932f, -0.29443789f, 0.01526992f, 0.09500094f, -0.05698591f, -0.02991810f, 0.10464769f, -0.02141604f, 
    0.01912336f, 0.00181115f, 0.03946481f, 0.03366564f, 0.03296976f, -0.05050098f, -0.08039813f, -0.02555189f, 
    0.02203554f, -0.08501907f, 0.11208929f, 0.02778369f, 0.34246910f, -0.21657369f, 0.05126374f, 0.05901524f, 
    -0.13533738f, 0.10410486f, 0.05133180f, 0.00892710f, -0.02705478f, 0.11573733f, -0.00412905f, 0.02017593f, 
    -0.02743445f, 0.05261990f, 0.01811725f, 0.09976502f, -0.03313734f, -0.03726593f, 0.11156966f, -0.11108877f, 
    0.15253495f, -0.05431752f, 0.06526648f, -0.17920348f, -0.10418225f, 0.01468564f, 0.19246241f, -0.03435386f, 
    0.06769255f, 0.06848364f, -0.06189933f, 0.02291776f, -0.10591298f, 0.17090853f, -0.01383330f, -0.07590460f, 
    0.10041258f, 0.03744717f, 0.04968129f, -0.01838184f, 0.02455039f, -0.22528540f, 0.03574720f, -0.05366950f, 
    0.07504924f, 0.06949713f, 0.02288665f, 0.06378765f, -0.03095280f, -0.07213788f, -0.01644944f, -0.04642375f, 
    -0.03516816f, 0.00448046f, -0.06704187f, 0.00514808f, 0.04349116f, -0.05411144f, -0.04761503f, 0.05859642f, 
    -0.22857137f, -0.17414604f, 0.08997651f, -0.10521853f, 0.04430671f, -0.00181690f, -0.00447742f, -0.00767461f, 
    -0.01733181f, 0.01463350f, -0.17832756f, -0.06080374f, 0.08926635f, -0.04795713f, -0.05974252f, -0.06002126f, 
    0.08331555f, 0.00708968f, -0.00242791f, -0.03865005f, -0.08386305f, 0.46522817f, 0.08601237f, -0.12267390f, 
    0.13073914f, -0.00257958f, -0.01421213f, -0.02322281f, -0.07442260f, 0.00050647f, -0.12751584f, -0.00457314f, 
    -0.09660856f, -0.12218142f, -0.07908120f, 0.07869469f, -0.04447943f, -0.06055078f, -0.01640595f, 0.00428844f, 
    -0.06795926f, 0.05402393f, 0.08658646f, -0.23631707f, 0.10300254f, 0.02551660f, -0.08579628f, -0.01938285f, 
    -0.07963720f, -0.08763902f, 0.00169836f, 0.01710727f, 0.02515621f, -0.10393343f, 0.07498375f, -0.04126056f, 
    0.03220059f, 0.11024294f, 0.02201866f, 0.00246860f, -0.22318195f, -0.03331009f, 0.05077873f, -0.05825464f, 
    -0.21523926f, -0.10544136f, -0.06343310f, 0.08940514f, -0.04586952f, -0.00744894f, -0.12121576f, -0.05270880f, 
    -0.00258151f, -0.04283116f, -0.02021914f, 0.07163412f, -0.06967277f, 0.04781538f, -0.00877814f, 0.04615914f, 
    -0.17373681f, 0.11377225f, 0.05323102f, 0.16378839f, 0.03673564f, 0.06016425f, -0.00272085f, -0.09115942f, 
    0.04700784f, 0.18512911f, -0.01962730f, 0.01652596f, 0.01313690f, 0.03944541f, 0.01764333f, 0.00101863f, 
    0.02684880f, -0.00281564f, 0.04010084f, -0.13544859f, -0.02610939f, 0.00425674f, -0.06069798f, -0.12405805f, 
    -0.18937336f, -0.00058691f, 0.04270112f, -0.05268376f, -0.01844033f, -0.06062037f, -0.07006322f, 0.06469149f, 
    0.11254118f, -0.02391422f, -0.03597413f, -0.05884038f, -0.01841529f, 0.07326584f, -0.03171186f, 0.03957328f, 
    0.23106317f, 0.16820005f, -0.07863807f, 0.26756960f, 0.14564399f, 0.05491946f, -0.03034518f, -0.06619159f, 
    0.05027856f, 0.10561403f, 0.05248800f, 0.02199075f, -0.06886075f, -0.01158205f, 0.09749766f, 0.08513052f, 
    -0.04384544f, 0.00649042f, 0.09821212f, 0.07133355f, 0.06308506f, 0.30083379f, 0.29872328f, -0.09527935f, 
    0.00961789f, -0.01275245f, -0.05945306f, 0.10038361f, -0.05948251f, -0.12027413f, -0.07228443f, -0.02096556f, 
    -0.03184287f, 0.05867170f, -0.01785650f, 0.10925319f, 0.01599143f, 0.00572956f, -0.07403856f, -0.01153335f, 
    0.10103555f, 0.38066876f, -0.00793466f, 0.07893799f, 0.29539984f, 0.04936251f, -0.12307753f, -0.03568828f, 
    -0.03045003f, 0.00811844f, 0.12786044f, 0.08842586f, 0.02274435f, 0.01887429f, 0.01420387f, 0.06127484f, 
    0.04765387f, -0.04600843f, 0.11618255f, -0.05788075f, 0.33367839f, -0.05197038f, -0.04125392f, 0.09729195f, 
    0.11426010f, 0.03926776f, 0.09373374f, -0.01095435f, 0.00584393f, 0.04362455f, 0.07704622f, 0.07397578f, 
    0.08978748f, 0.02068995f, -0.02985165f, 0.11016163f, -0.06185520f, -0.10078420f, -0.04581786f, -0.03569292f, 
    0.24247606f, 0.18100272f, 0.02202628f, 0.15651353f, 0.13865948f, 0.01322850f, 0.06038150f, 0.03771330f, 
    -0.01661187f, -0.08679415f, 0.04353972f, -0.06514134f, -0.02313114f, -0.03985681f, -0.07485978f, 0.01823117f, 
    0.05826131f, 0.04914774f, 0.06907899f, 0.06097206f, -0.02619400f, 0.10432073f, -0.11413636f, 0.20256549f, 
    0.14344347f, -0.07151490f, -0.02884592f, 0.06235520f, 0.08879382f, 0.04010308f, -0.07183698f, -0.04198305f, 
    -0.00537319f, -0.05805056f, -0.15805557f, 0.03838797f, -0.08369129f, 0.14940648f, 0.17337738f, 0.02937820f, 
    0.08495551f, 0.20182769f, 0.03117403f, 0.04454416f, -0.01025071f, -0.04410185f, 0.00060511f, 0.04266784f, 
    -0.12545812f, 0.00439483f, -0.00559995f, 0.05593912f, 0.04523889f, -0.08929325f, 0.01578883f, -0.10442281f, 
    0.02987723f, -0.02424269f, 0.18812601f, -0.04231564f, 0.32510906f, -0.00822736f, 0.05737057f, 0.03516669f, 
    0.01666122f, -0.02841691f, 0.01313623f, 0.04076591f, 0.05905815f, 0.12027317f, 0.03338400f, 0.04256867f, 
    -0.07232548f, -0.01210837f, 0.04912894f, 0.11256298f, -0.03773166f, 0.11651787f, 0.03047061f, -0.01505585f, 
    -0.11313462f, 0.16997035f, 0.13642602f, 0.00287687f, 0.24222110f, 0.03662096f, 0.05175484f, -0.03662714f, 
    0.03571321f, -0.05130253f, -0.07663484f, 0.04142951f, 0.08014623f, 0.06779420f, 0.06296256f, 0.11331697f, 
    -0.01663372f, 0.01824925f, 0.15984291f, 0.06433517f, -0.18867040f, -0.26184458f, -0.07506746f, -0.15458927f, 
    -0.24065611f, 0.01123575f, -0.02364216f, 0.02820120f, 0.02726495f, 0.01583337f, 0.09964275f, 0.02907167f, 
    -0.09542780f, 0.02915611f, 0.01832566f, 0.06564981f, 0.08723024f, -0.01905168f, 0.00019781f, 0.05543052f, 
    -0.00580029f, -0.19630016f, 0.05580034f, -0.11712273f, -0.10024783f, 0.01492968f, -0.02076290f, -0.02367948f, 
    -0.00438912f, -0.04133357f, -0.06638778f, 0.07466616f, -0.00050409f, -0.04852084f, 0.03359522f, 0.04878354f, 
    -0.03468701f, 0.04780835f, 0.02555914f, 0.07194068f, -0.10430330f, 0.10302583f, -0.20244749f, -0.22623029f, 
    0.07237504f, 0.11448859f, -0.06624082f, -0.09242385f, 0.04746096f, 0.01951577f, -0.03212309f, 0.02068952f, 
    -0.01221848f, 0.00883167f, 0.03312511f, 0.03294252f, -0.08988383f, -0.03162276f, 0.00239110f, -0.04839312f, 
    -0.18924470f, 0.06896804f, -0.03506165f, -0.00266938f, -0.15082856f, 0.06919120f, 0.07549189f, -0.12034485f, 
    0.06544895f, -0.01669274f, 0.01646003f, 0.03189176f, 0.01791524f, 0.02559381f, 0.00733040f, -0.08959004f, 
    0.02032890f, 0.07809000f, 0.01340703f, -0.04574972f, -0.08472230f, 0.10491176f, -0.08307653f, 0.22632676f, 
    0.12254249f, 0.04633407f, 0.14577027f, -0.01434643f, -0.00486980f, 0.02821401f, -0.04967275f, 0.03795316f, 
    0.07127497f, -0.04236329f, 0.00030816f, -0.10158338f, 0.04000460f, 0.08214736f, 0.00578340f, -0.05579291f, 
    -0.22537303f, 0.02111428f, 0.05660622f, 0.11318868f, 0.02289304f, -0.03166095f, -0.04755877f, -0.00693582f, 
    -0.03472636f, 0.07699263f, -0.12905949f, -0.03180714f, 0.09210262f, 0.01724115f, -0.12184033f, -0.10216956f, 
    -0.12662274f, 0.05791143f, 0.07067758f, -0.03425398f, 0.00654908f, 0.16277966f, 0.01969438f, 0.13000651f, 
    0.15297019f, -0.01003869f, -0.02404922f, 0.07787267f, 0.03071674f, 0.02077471f, 0.05445986f, -0.07777717f, 
    0.03184967f, -0.01129266f, -0.05398764f, 0.01203219f, -0.00097757f, 0.05093079f, 0.08841553f, 0.11321817f, 
    0.14765786f, 0.03800642f, -0.10847374f, 0.09003198f, 0.14059755f, 0.02210352f, -0.10232517f, 0.00807525f, 
    -0.01271406f, -0.00455458f, -0.02465067f, -0.04329097f, -0.05166061f, -0.10946217f, 0.03798090f, -0.06158334f, 
    -0.08989628f, 0.10036734f, 0.02218233f, -0.04316340f, -0.48256287f, -0.01766946f, -0.11539424f, -0.02878422f, 
    -0.35541666f, 0.07840782f, 0.07788163f, 0.06231717f, 0.04388956f, 0.01316382f, 0.12637416f, 0.05021576f, 
    -0.01801038f, -0.00035530f, 0.07218433f, 0.04736503f, 0.01497072f, -0.09405051f, -0.09806821f, 0.08028053f, 
    -0.12921222f, -0.21984154f, -0.20032756f, 0.01019961f, -0.01443335f, 0.04150056f, -0.03686487f, -0.00057289f, 
    -0.00829302f, -0.06537215f, -0.07667015f, 0.13165921f, 0.09590909f, -0.01347803f, -0.01954625f, -0.08576634f, 
    -0.05931834f, 0.01270056f, -0.01759807f, 0.00863721f, 0.13297738f, 0.03462753f, 0.12962888f, 0.01516209f, 
    0.34081590f, 0.07264166f, 0.01546135f, 0.01942077f, 0.03346559f, 0.06730600f, -0.00597345f, -0.01752654f, 
    0.01977822f, 0.03083364f, -0.00992737f, 0.04815335f, -0.00028246f, -0.04557541f, 0.09381299f, 0.03199559f, 
    -0.06367403f, 0.23328257f, -0.04815861f, -0.02345745f, 0.24844259f, 0.04197238f, 0.04105818f, -0.15037976f, 
    -0.01925290f, 0.01668116f, 0.08505809f, 0.18288988f, 0.02464283f, 0.05105449f, -0.04181359f, 0.01530283f, 
    0.01996969f, 0.03764319f, 0.03760572f, 0.10154002f, -0.14397404f, 0.08268491f, 0.04219360f, -0.21478561f, 
    0.08609366f, 0.00565282f, 0.28892428f, -0.04540887f, 0.03968729f, -0.00007520f, -0.00709190f, 0.11127244f, 
    -0.00920307f, 0.07739387f, 0.09422630f, 0.12027881f, 0.14192590f, 0.02199827f, 0.09696475f, 0.06401657f, 
    0.02925456f, 0.22528510f, -0.02570014f, -0.10956128f, 0.16502696f, -0.06867292f, -0.07910427f, -0.05906180f, 
    0.04590977f, -0.03060284f, 0.09845029f, 0.07855896f, -0.08028027f, 0.13112289f, 0.08641114f, -0.05912901f, 
    -0.05803473f, 0.16223562f, -0.05887807f, 0.00124923f, -0.00914669f, 0.11458292f, 0.10007826f, 0.06705478f, 
    0.06604128f, -0.01637094f, 0.02609275f, -0.00447651f, 0.06373103f, 0.00612902f, 0.07490798f, 0.09328606f, 
    -0.08573610f, 0.04690119f, -0.04473390f, 0.02158266f, 0.08502524f, -0.02866177f, -0.05974743f, 0.02673326f, 
    -0.40482187f, 0.20880315f, 0.03425197f, -0.05219513f, 0.22010340f, 0.10787553f, -0.09796695f, -0.08284745f, 
    0.06142264f, -0.07042506f, -0.05955143f, -0.04917563f, 0.07868537f, 0.01048023f, 0.02691947f, 0.02045109f, 
    0.05118371f, 0.08066548f, 0.12944527f, -0.09591045f, 0.13961327f, 0.08002104f, 0.13650870f, 0.06817734f, 
    -0.17284362f, 0.05896027f, -0.04802815f, 0.11401322f, 0.05367324f, 0.04887613f, -0.05816873f, 0.05042899f, 
    0.00509871f, 0.09996242f, 0.03799977f, -0.01644506f, 0.00730087f, -0.06765372f, 0.02958378f, 0.02174041f, 
    0.05943910f, -0.03838374f, -0.06416851f, 0.17401254f, 0.00103855f, -0.02749935f, 0.15556021f, -0.02563224f, 
    -0.03389822f, -0.03821608f, -0.01249815f, -0.07831322f, -0.03710194f, 0.06221269f, 0.05065128f, 0.02868606f, 
    0.14166240f, 0.05989570f, 0.03338366f, 0.05669323f, 0.12706487f, 0.10839331f, -0.14446628f, 0.18582864f, 
    -0.04595620f, 0.11921201f, -0.05118543f, -0.05623276f, 0.06438407f, 0.03079729f, -0.01801293f, -0.06566209f, 
    -0.05565193f, -0.06056362f, 0.02198365f, -0.04838951f, 0.03966382f, -0.05995668f, 0.00572767f, -0.08402128f, 
    -0.01838746f, -0.01088798f, -0.02423580f, 0.10124982f, 0.00126641f, -0.04192232f, 0.06414006f, -0.07309765f, 
    -0.01384204f, 0.02406170f, 0.01333656f, -0.07799903f, -0.07611623f, 0.03681881f, -0.04651458f, -0.07095864f, 
    0.08240549f, -0.16885149f, 0.02907819f, -0.02970916f, 0.18157697f, 0.43947920f, -0.17915557f, 0.14917783f, 
    -0.18690166f, -0.03095826f, 0.05800660f, 0.02138831f, 0.00811432f, 0.07660055f, 0.08664596f, 0.09511083f, 
    0.10775590f, 0.00049817f, -0.12749200f, -0.14859152f, 0.05757088f, 0.10674436f, -0.04193081f, 0.04426377f, 
    -0.39515349f, 0.12215299f, -0.00862897f, 0.03587195f, 0.20035958f, -0.03945250f, 0.00800555f, -0.05018351f, 
    -0.05937409f, -0.12964484f, -0.10020295f, -0.05423386f, 0.00731218f, 0.01901835f, -0.04411012f, -0.04068357f, 
    -0.00887208f, -0.02289204f, 0.06091696f, 0.07096718f, -0.08156029f, -0.17860554f, -0.02656921f, 0.06186622f, 
    0.22124048f, -0.08903417f, -0.00733045f, 0.03150469f, -0.06883537f, -0.01030978f, -0.02774779f, -0.08110801f, 
    -0.05203449f, 0.06962462f, 0.14118297f, -0.02377743f, -0.09177867f, -0.00814686f, -0.07803044f, -0.00411852f, 
    -0.34672537f, -0.00809539f, -0.04068362f, -0.12010451f, 0.18428285f, 0.05820737f, 0.11528081f, -0.01399611f, 
    0.00307497f, -0.01869759f, 0.03205319f, 0.10350323f, 0.02501237f, -0.07163931f, -0.02300599f, 0.03708230f, 
    -0.05951966f, 0.00957736f, 0.00154473f, -0.13914366f, 0.13802731f, 0.05076738f, -0.06939646f, 0.10058945f, 
    -0.26777861f, 0.15396850f, 0.08150421f, 0.06976754f, -0.06487447f, 0.07403166f, 0.09928989f, -0.01614822f, 
    0.01657532f, -0.06995973f, 0.08940140f, 0.00661902f, -0.09743685f, -0.06489484f, 0.01237291f, -0.08619352f, 
    -0.24714762f, -0.15460728f, 0.02409544f, 0.00881334f, 0.01000029f, 0.01789816f, -0.05756171f, 0.11301939f, 
    0.01077285f, -0.09554310f, -0.02753089f, -0.04022122f, 0.08556970f, 0.00184949f, -0.12008464f, -0.00302448f, 
    0.00283861f, 0.06758039f, -0.02333793f, -0.15139604f, -0.04529548f, 0.06835170f, 0.02143004f, -0.16182107f, 
    0.32217118f, 0.03802115f, 0.01899500f, 0.00280824f, -0.09837845f, 0.00662968f, 0.03337871f, -0.03011717f, 
    0.02941774f, 0.00496713f, 0.01963586f, -0.02750421f, 0.09300635f, 0.08203088f, 0.02534527f, -0.02112795f, 
    -0.23505369f, -0.11793834f, -0.04790755f, -0.03123496f, 0.08407016f, 0.05526815f, 0.02483297f, 0.03921852f, 
    -0.08804045f, 0.01205097f, 0.03471003f, -0.06260042f, -0.05226692f, 0.00855864f, -0.02776625f, 0.02295212f, 
    0.00998737f, -0.02791441f, 0.04323261f, 0.00160216f, -0.33856997f, -0.23303342f, -0.04325943f, 0.08381423f, 
    0.11482009f, 0.07989714f, -0.08642632f, 0.01629108f, -0.10264071f, 0.12452135f, 0.05250494f, 0.02410471f, 
    0.06433085f, -0.05299868f, 0.03167352f, 0.10368297f, -0.00331996f, -0.11414345f, 0.03639754f, 0.00755676f, 
    0.27237380f, -0.19708857f, 0.03157394f, -0.02494300f, -0.08524404f, -0.03641724f, 0.08347135f, 0.06114422f, 
    0.03475519f, 0.00297874f, 0.08388135f, 0.04808919f, 0.04578545f, -0.05337642f, -0.07481822f, -0.14151861f, 
    0.02077706f, 0.05834520f, 0.08498662f, 0.13171493f, 0.23722924f, -0.30520701f, -0.16452082f, 0.10963764f, 
    -0.08308607f, 0.05199608f, 0.05805351f, 0.11544649f, 0.08668202f, 0.08781047f, 0.01454048f, 0.04263231f, 
    -0.00625215f, 0.02032702f, 0.02275302f, 0.05209076f, 0.09082755f, -0.01028252f, -0.00568187f, 0.02493237f, 
    0.23547387f, -0.16243052f, -0.08548683f, -0.13272208f, -0.14079741f, -0.11194900f, 0.05688744f, 0.06377257f, 
    -0.06849619f, 0.09772880f, 0.01830907f, 0.02569034f, 0.01997037f, 0.05720114f, -0.05503550f, 0.00661383f, 
    0.01769133f, -0.02633746f, 0.07267067f, 0.11415832f, -0.05961216f, -0.10344949f, 0.30565542f, 0.06998885f, 
    -0.19071369f, 0.19767688f, 0.15363172f, 0.01347676f, -0.00831039f, -0.08280355f, -0.06480481f, 0.00037290f, 
    -0.02532074f, 0.06185195f, -0.05943343f, 0.06609900f, -0.05267277f, 0.04299649f, -0.06421652f, -0.01891464f, 
    -0.11895742f, 0.17866518f, 0.25578260f, -0.23750286f, -0.27688348f, 0.14774293f, 0.08429589f, 0.04319328f, 
    0.00881069f, -0.02107350f, -0.06824798f, 0.04272278f, 0.04257960f, 0.05235288f, -0.07960495f, -0.00312791f, 
    0.07670312f, -0.04281658f, 0.03199093f, 0.00346826f, 0.23919567f, -0.09184783f, -0.12401004f, -0.04685561f, 
    -0.10949458f, 0.01502985f, 0.02480243f, -0.00004565f, -0.08097365f, -0.04413040f, 0.05188756f, -0.01634708f, 
    -0.03625019f, -0.02200778f, -0.03188279f, 0.02622654f, 0.05350505f, 0.05805902f, -0.01153620f, -0.04812191f, 
    -0.09552794f, 0.08892366f, 0.07863960f, -0.03580926f, -0.03274223f, 0.07709841f, 0.04910582f, 0.06537126f, 
    0.05006170f, 0.05301821f, 0.00206169f, 0.05677985f, 0.06752358f, -0.12091889f, -0.02680101f, 0.09607287f, 
    0.01574180f, 0.07842416f, 0.01304463f, 0.01025053f, -0.41589907f, -0.23029187f, 0.22182140f, -0.15991290f, 
    0.17649196f, -0.10091582f, 0.09236794f, 0.01129981f, 0.04355017f, 0.03537054f, -0.00680860f, -0.13940792f, 
    -0.00774092f, 0.02901601f, -0.04046830f, 0.06769428f, 0.00872566f, 0.02940564f, 0.05470942f, -0.06045621f, 
    0.15195929f, 0.00731498f, -0.00676735f, -0.03498515f, 0.06692407f, 0.05007099f, 0.06672531f, -0.05794252f, 
    0.12587385f, 0.11437865f, 0.08426902f, 0.07101143f, -0.02687281f, -0.03545894f, 0.05058678f, 0.00404573f, 
    -0.05209540f, 0.00673121f, -0.09659308f, 0.02738155f, 0.29826194f, 0.21079870f, -0.09143997f, -0.16915035f, 
    0.01439467f, 0.09107619f, 0.04235810f, 0.03504492f, 0.02728825f, 0.07688465f, -0.00485964f, 0.08873451f, 
    0.06011168f, -0.02649744f, 0.05285035f, 0.14717983f, 0.07778991f, 0.06964155f, -0.02867002f, -0.00461623f, 
    0.01433904f, -0.11753748f, 0.02939421f, -0.03031386f, 0.02153702f, -0.04251672f, 0.01432251f, -0.00145585f, 
    0.04476361f, 0.09472580f, 0.00634225f, 0.00915375f, -0.06626821f, 0.08671326f, 0.16559646f, -0.01563165f, 
    0.04635233f, -0.02756836f, 0.07770031f, 0.04602965f, -0.68474656f, 0.26408744f, 0.10081606f, 0.07924074f, 
    0.09839119f, 0.02241351f, 0.06376307f, 0.21110772f, -0.04216607f, -0.21816812f, 0.05580039f, -0.06055953f, 
    0.00442830f, 0.03798977f, 0.01405555f, 0.00602347f, 0.07736248f, 0.17788339f, -0.06606809f, -0.08572768f, 
    0.34601313f, -0.09158502f, -0.09871864f, -0.11483190f, -0.05345849f, 0.00666436f, 0.11556561f, -0.10315694f, 
    -0.07678039f, 0.07849488f, 0.03176013f, -0.02710700f, -0.00114824f, -0.06483924f, 0.07709737f, 0.08558565f, 
    -0.02568374f, -0.04568412f, -0.10744059f, -0.05076277f, 0.17032823f, -0.08951174f, -0.14037892f, -0.01182099f, 
    -0.02571327f, 0.09808880f, -0.03017719f, 0.06335983f, 0.00622607f, 0.11717573f, 0.00563363f, -0.08849060f, 
    0.03666882f, 0.00999690f, -0.00088230f, 0.09989015f, -0.01670326f, 0.06019643f, 0.07026436f, 0.05016131f, 
    0.10322537f, 0.20338657f, 0.22202274f, -0.04231515f, 0.01556384f, -0.03751291f, -0.05492537f, 0.08219420f, 
    -0.03427438f, 0.05570936f, -0.00729263f, -0.02749714f, 0.07449755f, 0.03065143f, 0.00020773f, -0.05384172f, 
    0.04890546f, -0.05915729f, -0.00412005f, -0.00736611f, 0.27276197f, 0.34085006f, 0.24999316f, 0.03244720f, 
    0.01932149f, -0.00849287f, 0.09504475f, 0.09380409f, -0.10378202f, 0.01405997f, 0.03418966f, 0.02584473f, 
    -0.01690718f, -0.07110053f, 0.13082607f, -0.12331253f, 0.04422491f, 0.03695510f, -0.04376223f, -0.11968938f, 
    0.19054715f, -0.00327371f, 0.08276298f, -0.00827716f, 0.00477099f, 0.05971025f, -0.02829796f, 0.00543861f, 
    0.11209461f, -0.00287848f, -0.05374223f, 0.01474627f, -0.07456070f, 0.16580743f, 0.00142979f, 0.07402926f, 
    -0.02611860f, 0.12227050f, -0.10196584f, 0.12933701f, -0.04060771f, -0.03802824f, 0.09293669f, 0.14170030f, 
    -0.05662924f, -0.00563742f, -0.06863272f, -0.03910028f, -0.04671080f, -0.01010282f, -0.03755047f, -0.02942485f, 
    -0.02443182f, 0.03175129f, 0.04236526f, -0.02810844f, 0.03302434f, -0.03089005f, -0.01420572f, 0.17564555f, 
    0.39483216f, 0.03054645f, 0.13447158f, 0.05481284f, -0.04651036f, -0.03987425f, 0.13896833f, 0.11135868f, 
    0.00685834f, -0.04505415f, 0.03809336f, 0.01675202f, -0.06418201f, -0.01441278f, -0.04389948f, -0.08479229f, 
    -0.00308983f, -0.16492255f, -0.03818894f, 0.06823017f, 0.02862893f, -0.20422012f, -0.17643225f, 0.06539488f, 
    0.04951846f, 0.07298070f, 0.01351617f, -0.03248326f, -0.03081243f, -0.06664371f, -0.09483692f, 0.02732763f, 
    -0.03841054f, 0.08146428f, 0.06899710f, 0.00064982f, -0.06967855f, 0.07387751f, -0.05763774f, -0.06651396f, 
    -0.11654834f, 0.03544412f, -0.14299081f, 0.00406581f, 0.15483619f, 0.17384645f, -0.06988849f, 0.00146582f, 
    -0.03654334f, -0.02255445f, -0.06745730f, -0.06532142f, 0.04117368f, 0.09921867f, 0.02624879f, -0.02080597f, 
    0.00879446f, -0.02933151f, -0.03537842f, -0.11903352f, 0.02342454f, -0.13737230f, 0.09504706f, 0.07503264f, 
    -0.04838959f, 0.03830487f, -0.10234664f, 0.02167608f, -0.04339133f, -0.11873601f, -0.04866797f, -0.03112249f, 
    0.08045673f, -0.03605806f, 0.02843664f, 0.02918928f, 0.01104825f, 0.03684690f, 0.08294640f, 0.07394817f, 
    0.08470725f, 0.17680249f, -0.10376482f, -0.02195512f, 0.04822442f, -0.09291602f, -0.10962240f, 0.04907773f, 
    -0.10827619f, 0.13770123f, 0.01885487f, 0.05138602f, 0.03862676f, -0.01304120f, 0.01399312f, 0.09020554f, 
    0.07259057f, -0.15860562f, 0.04623061f, -0.07119519f, 0.13576178f, 0.00346304f, 0.08025487f, -0.16346334f, 
    0.16705219f, -0.02594506f, 0.10577127f, -0.08563732f, -0.06686153f, 0.08021547f, 0.07617244f, 0.01850459f, 
    -0.05448876f, 0.00249842f, -0.02670206f, 0.07578740f, -0.07830357f, -0.09027919f, 0.06010409f, 0.07169453f, 
    0.25249347f, 0.21808377f, 0.01905368f, -0.13900477f, -0.03846886f, -0.14109541f, -0.00182266f, -0.01088564f, 
    0.00461055f, 0.01652098f, 0.10477844f, 0.01440754f, -0.00778405f, -0.00097456f, 0.07707433f, 0.05186468f, 
    0.04212547f, -0.05288468f, 0.02796363f, 0.04466860f, 0.08094161f, 0.01817946f, 0.09659018f, -0.10171791f, 
    0.02887024f, 0.04023510f, -0.02577161f, -0.02118574f, -0.01456911f, -0.00167352f, -0.02583818f, -0.04669825f, 
    0.05958287f, 0.01607911f, 0.00467315f, 0.00785002f, 0.05631782f, -0.06349139f, 0.00490355f, -0.03092015f, 
    0.01548227f, 0.07410467f, 0.22138354f, 0.11297001f, -0.08289344f, -0.11266831f, -0.03998407f, 0.06080587f, 
    0.00670491f, -0.14584114f, 0.03391151f, 0.06040521f, 0.03800688f, 0.03544069f, 0.06868779f, -0.00799281f, 
    0.08788040f, 0.06316103f, 0.06786570f, 0.09032437f, 0.15807933f, -0.02208307f, -0.18269493f, 0.02801814f, 
    0.09644977f, -0.08203539f, -0.06155131f, -0.21055189f, -0.12618749f, 0.04474301f, -0.06567229f, 0.04655223f, 
    -0.08445790f, 0.15340346f, -0.07367573f, -0.05003228f, -0.00450625f, 0.01789390f, 0.07713943f, -0.02792107f, 
    0.14787477f, 0.19519919f, 0.00353906f, -0.00172701f, -0.11172295f, -0.10104246f, -0.01354996f, -0.05723971f, 
    -0.14035191f, -0.10958735f, -0.04292372f, -0.04787903f, -0.02133258f, -0.10214453f, 0.05605830f, 0.08934700f, 
    -0.03694985f, 0.01629068f, 0.01533901f, 0.01874040f, -0.03026366f, 0.02097195f, 0.17440897f, 0.01892395f, 
    -0.01306578f, 0.04229452f, -0.03128705f, -0.02284432f, -0.04157093f, -0.04270495f, -0.05156805f, -0.00640431f, 
    0.05301799f, -0.01360519f, -0.05288674f, 0.00104299f, -0.09576742f, 0.07381231f, -0.10765781f, 0.00495403f, 
    0.01112502f, 0.03975702f, 0.02302227f, -0.04233525f, -0.05969491f, -0.03027862f, 0.02241798f, -0.05101303f, 
    -0.00372842f, -0.03607399f, -0.01258885f, 0.02153145f, 0.00696544f, 0.00164861f, -0.05762262f, 0.00117941f, 
    0.00606893f, 0.03880468f, 0.00857307f, -0.03911037f, 0.00240238f, 0.02034704f, 0.00096848f, 0.02962623f, 
    -0.02430130f, -0.03391416f, -0.01617464f, -0.05984639f, -0.02723290f, 0.04666335f, 0.04369806f, -0.04423887f, 
    0.00817516f, -0.03607959f, -0.04234556f, 0.02849985f, 0.00301852f, -0.06087777f, -0.03485289f, -0.01368051f, 
    0.01414964f, -0.01638909f, -0.05033671f, -0.03691628f, -0.04414254f, -0.00360713f, -0.05287984f, -0.05551239f, 
    0.04965437f, 0.03161689f, -0.00492912f, 0.01589550f, -0.01007699f, 0.01657826f, -0.04858772f, 0.04951192f, 
    0.02755859f, -0.02923798f, 0.00252808f, 0.03714272f, 0.04823144f, -0.05745122f, 0.01753223f, 0.02195245f, 
    -0.05586551f, 0.00238242f, -0.03865916f, 0.01679074f, 0.04193895f, -0.02810415f, 0.00369857f, 0.00268153f, 
    -0.05968030f, -0.05167307f, -0.04610297f, -0.02771833f, -0.04857214f, 0.04360279f, -0.02660882f, -0.01432031f, 
    0.01340114f, -0.02786533f, -0.02560888f, -0.01492884f, -0.03618819f, -0.05375858f, -0.06014423f, -0.05156038f, 
    0.01235301f, -0.06117875f, 0.03636047f, -0.00132763f, 0.03873296f, 0.01079138f, 0.00402630f, 0.04575982f, 
    0.00092442f, 0.04817255f, 0.00046555f, 0.01364867f, 0.02398961f, 0.00797354f, 0.02117017f, 0.01387776f, 
    -0.01882183f, 0.00096271f, -0.00590831f, 0.00718326f, -0.00187172f, 0.00775381f, 0.03608335f, 0.02262815f, 
    -0.03408922f, -0.01254164f, -0.00682989f, 0.04115921f, 0.04381638f, -0.05344479f, 0.01328589f, -0.04179758f, 
    0.03447452f, -0.03186101f, 0.02151859f, -0.02679360f, 0.03451757f, -0.01063816f, -0.06122384f, -0.04220928f, 
    0.01990417f, -0.03382097f, -0.04578296f, -0.03957878f, 0.00940931f, 0.01855668f, -0.04367179f, -0.03590129f, 
    -0.03430149f, 0.03721465f, 0.03381751f, 0.00558813f, 0.01411991f, -0.04229462f, -0.05612411f, 0.01185754f, 
    -0.03120644f, -0.04568775f, -0.05369583f, -0.00493696f, -0.02124971f, 0.04275036f, -0.03911959f, 0.01156284f, 
    -0.06087324f, -0.02970002f, -0.01493314f, -0.00232831f, -0.03184718f, 0.02280395f, -0.01022014f, -0.02207469f, 
    0.00578954f, 0.03296962f, 0.00830245f, 0.02510870f, 0.00550970f, 0.00050908f, 0.01583203f, -0.02906068f, 
    -0.05113831f, 0.01097746f, 0.00543857f, 0.03964178f, -0.01162496f, -0.01877785f, -0.00688468f, -0.01080125f, 
    0.01047779f, 0.03930439f, 0.03669956f, -0.02580620f, -0.04765137f, -0.00756213f, 0.03194202f, -0.02608381f, 
    0.02447601f, -0.05795864f, 0.03549817f, 0.01776681f, 0.03520244f, -0.03032270f, -0.01301040f, -0.03829431f, 
    -0.01964870f, -0.04814860f, 0.04009889f, 0.01385636f, 0.04625340f, -0.02206742f, -0.01785888f, -0.01579296f, 
    -0.02900168f, 0.01732199f, -0.04772395f, 0.01874343f, 0.01352074f, -0.02526557f, -0.03650308f, 0.01741452f, 
    -0.05540321f, -0.06158937f, -0.03870168f, 0.02790046f, -0.05144885f, 0.04794031f, 0.03158939f, -0.01259591f, 
    0.04841197f, -0.01027275f, -0.00112837f, 0.00223725f, -0.03478564f, 0.04835543f, -0.01103585f, -0.00902819f, 
    -0.00718776f, 0.04012402f, 0.01674264f, -0.06148682f, 0.03267524f, -0.04403454f, -0.01524024f, -0.05153779f, 
    -0.04647305f, -0.00625641f, -0.00783465f, -0.01337430f, -0.05641586f, -0.04471239f, 0.04386431f, -0.02327916f, 
    -0.00455578f, 0.01154978f, -0.05336769f, -0.01018140f, -0.01836158f, -0.00321028f, -0.03292797f, 0.01458781f, 
    -0.00422156f, -0.05748700f, -0.05263095f, 0.00312290f, -0.00858532f, -0.01600663f, -0.03794037f, -0.05875594f, 
    0.00136660f, 0.04019961f, -0.02540375f, -0.00323504f, -0.02744594f, -0.04059267f, -0.02312787f, -0.02513587f, 
    -0.05890087f, 0.04448595f, 0.04214659f, -0.03914318f, 0.00322454f, 0.00735723f, -0.01144516f, 0.01148354f, 
    0.01949450f, -0.00796050f, -0.01895208f, -0.02455404f, -0.02664386f, -0.05355278f, 0.04749941f, 0.04745545f, 
    -0.05838366f, 0.02429686f, -0.01910096f, -0.03568350f, 0.04440404f, 0.04974934f, -0.00324335f, -0.02835840f, 
    0.01937116f, -0.02984238f, 0.03499121f, -0.04705643f, -0.00880870f, -0.04549192f, 0.04931435f, -0.02222692f, 
    0.01524449f, 0.01539884f, 0.01692677f, -0.01380076f, 0.00374918f, 0.04952943f, -0.04876725f, -0.04869500f, 
    -0.04030923f, -0.00352083f, -0.00209467f, -0.05524042f, 0.00946397f, -0.04053872f, 0.02132956f, 0.02008540f, 
    -0.03324813f, 0.02204826f, -0.03099453f, -0.02362698f, 0.03239897f, -0.01534787f, -0.01133530f, -0.05995364f, 
    -0.01001657f, -0.04870177f, 0.01764373f, -0.02956336f, 0.04847122f, 0.04644713f, -0.01133003f, 0.02911563f, 
    0.01784624f, -0.00347374f, 0.00753690f, -0.01485039f, -0.05710629f, -0.03834635f, 0.02710664f, 0.01886564f, 
    0.02958165f, -0.00863904f, -0.03033066f, 0.01564256f, -0.06145044f, -0.05405035f, 0.02864891f, -0.05648204f, 
    -0.02598353f, -0.00081807f, 0.01064048f, 0.03298751f, 0.02348014f, 0.04371354f, 0.03548520f, -0.02874489f, 
    -0.03010419f, -0.01496630f, -0.04728664f, 0.03391249f, -0.00068665f, 0.02568293f, -0.01876689f, -0.00948693f, 
    0.02754332f, 0.01688533f, 0.04042879f, 0.02212475f, -0.05016423f, 0.01286994f, 0.02809965f, 0.04080280f, 
    0.00087997f, -0.04087000f, -0.04499690f, 0.01320083f, 0.00700588f, -0.03352054f, 0.00844009f, -0.04398099f, 
    -0.00432126f, 0.01343470f, -0.02863933f, 0.02198551f, 0.00930976f, 0.03505468f, -0.03904514f, 0.03699921f, 
    -0.03066024f, 0.02398604f, 0.02024275f, -0.04092214f, -0.02533730f, -0.02013949f, 0.02719195f, 0.02525951f, 
    0.05303190f, -0.00114872f, -0.02869205f, 0.04526006f, -0.01659186f, 0.00269553f, -0.05967912f, 0.03992250f, 
    -0.02427992f, 0.02860954f, -0.02318688f, -0.02352827f, 0.00438612f, -0.01114479f, -0.03551383f, 0.02683455f, 
    0.04541344f, 0.03306358f, 0.03319590f, 0.05480877f, -0.00063265f, 0.03219335f, 0.04350048f, 0.03689633f, 
    -0.02525828f, 0.03137510f, -0.06311506f, 0.02290593f, 0.01299228f, -0.02183540f, 0.02726733f, -0.01188647f, 
    0.00581850f, -0.01146790f, 0.00398460f, -0.00700527f, -0.05974638f, -0.03274696f, 0.03625369f, -0.04365052f, 
    -0.04007296f, 0.00105089f, 0.02162719f, -0.01493717f, 0.02222013f, -0.00276575f, -0.04051739f, -0.01507867f, 
    0.02402324f, -0.02758728f, -0.04922311f, -0.01438225f, 0.04726999f, 0.01259142f, 0.01057009f, 0.03308346f, 
    0.01484842f, -0.05573443f, -0.04547514f, -0.04037657f, -0.00434605f, -0.05896569f, -0.00965272f, 0.00514374f, 
    -0.00131889f, -0.04789310f, -0.05982977f, 0.00869850f, -0.00062250f, -0.02430924f, 0.04539351f, -0.02509823f, 
    -0.02830225f, 0.03984525f, -0.02621577f, 0.01302284f, -0.02556502f, -0.04121945f, -0.03994647f, 0.02943834f, 
    0.03071527f, 0.03018819f, -0.00028056f, 0.04503679f, -0.01690716f, -0.04171127f, 0.02124723f, 0.00901909f, 
    0.04115570f, 0.04865820f, -0.00629940f, -0.03478350f, 0.02048173f, 0.00754174f, 0.00163586f, -0.00382097f, 
    0.02934598f, -0.02291962f, -0.04280575f, -0.03928479f, 0.00524045f, -0.02386095f, -0.04684944f, -0.06258298f, 
    -0.03036160f, -0.01741399f, -0.03186571f, -0.02052226f, 0.00587229f, -0.00508183f, -0.00244364f, -0.01420287f, 
    0.00029264f, 0.03382328f, 0.02077601f, -0.00546128f, -0.00265073f, 0.03988596f, -0.02752124f, 0.02775927f, 
    0.00036034f, 0.00943408f, -0.01183994f, -0.04969957f, -0.01397870f, 0.00952078f, -0.02800327f, 0.00026821f, 
    -0.05894674f, -0.04262931f, -0.04780683f, -0.00789826f, 0.02149778f, -0.03675386f, -0.02891150f, 0.03379761f, 
    0.04138291f, 0.00719465f, 0.03248186f, -0.02356048f, -0.01323555f, -0.01174241f, 0.00230001f, 0.03239374f, 
    -0.00218096f, -0.06191981f, 0.02775118f, 0.01949856f, 0.02680977f, -0.03828514f, -0.05655257f, -0.01465255f, 
    0.02991364f, -0.02936197f, -0.01030824f, 0.03263026f, -0.02444426f, -0.05970071f, 0.00416634f, 0.03846824f, 
    -0.06002877f, 0.04155705f, -0.05370049f, -0.02382332f, 0.03953622f, -0.00869432f, -0.01928431f, -0.06059520f, 
    0.01401056f, -0.02776955f, 0.04438937f, -0.03065878f, 0.02903720f, 0.03896521f, -0.04650934f, -0.04499973f, 
    0.00883100f, -0.01412269f, 0.00806651f, -0.04845802f, -0.00249656f, -0.04373743f, -0.05142463f, -0.04044928f, 
    -0.01181293f, 0.01580720f, -0.04595973f, -0.02116203f, 0.00749757f, -0.02858117f, -0.02797616f, -0.04708496f, 
    -0.00275472f, -0.02599704f, 0.00030036f, -0.04510584f, 0.00027832f, 0.05053938f, -0.06248814f, -0.03294049f, 
    -0.05275463f, 0.02165501f, -0.03654538f, -0.03992147f, -0.03537904f, -0.01441107f, -0.03998008f, -0.00393007f, 
    0.00485539f, -0.00975478f, -0.01531817f, -0.03947542f, 0.00126156f, 0.03230620f, -0.02012754f, 0.01186072f, 
    -0.02950056f, 0.02841171f, 0.01189495f, -0.01412062f, 0.03623609f, 0.03413414f, -0.01740069f, 0.02616547f, 
    -0.05754369f, -0.00042683f, 0.04876355f, -0.01197709f, 0.03600489f, -0.05793666f, 0.01827160f, -0.03162788f, 
    0.01435828f, 0.04616903f, -0.01747832f, 0.00052077f, -0.04238042f, -0.03017900f, 0.03676860f, -0.04161106f, 
    -0.05108105f, -0.01473156f, -0.00902998f, -0.00769114f, -0.02142187f, 0.03326524f, -0.01115208f, -0.06435820f, 
    0.02255995f, -0.05867437f, -0.12128010f, 0.16418636f, -0.07631119f, -0.06562661f, 0.01049061f, 0.07578320f, 
    0.03871811f, 0.05154893f, 0.00518509f, -0.03244821f, -0.03909602f, -0.08395071f, 0.02812521f, 0.02660614f, 
    -0.08883330f, 0.13008398f, 0.07692327f, 0.12979682f, -0.09218930f, -0.15874426f, -0.28477436f, 0.15984136f, 
    0.07332692f, -0.09763162f, -0.26574275f, -0.06342964f, 0.02915876f, 0.14727275f, 0.02887825f, 0.01696786f, 
    0.07040119f, 0.06669185f, -0.05575360f, 0.11721464f, -0.10859274f, 0.09131573f, -0.03788153f, 0.11729091f, 
    -0.28610334f, 0.16486134f, 0.08589912f, 0.18834014f, -0.02925181f, -0.01047309f, 0.13758291f, 0.05189613f, 
    -0.08881705f, 0.09770125f, 0.04301444f, -0.10376801f, 0.10334235f, -0.17072697f, -0.01946436f, -0.11078516f, 
    0.07075856f, -0.07534379f, 0.33271623f, 0.03586879f, 0.19314487f, 0.03391347f, -0.02819898f, -0.14158724f, 
    -0.09709689f, -0.01005152f, -0.01907861f, 0.18768091f, 0.10112196f, 0.04549202f, -0.06690024f, -0.07729688f, 
    -0.01518441f, 0.09018274f, 0.06207620f, 0.15065329f, -0.04709971f, -0.01764959f, 0.04156263f, -0.19126418f, 
    -0.22616509f, 0.24173485f, 0.04262534f, 0.04672327f, -0.04679979f, -0.03110895f, -0.11804050f, -0.02382309f, 
    -0.09078337f, 0.02366923f, -0.06301866f, 0.01921706f, -0.04289766f, 0.11700479f, -0.00318572f, 0.11819471f, 
    0.05357952f, 0.03084010f, 0.14037798f, 0.03005848f, -0.16237526f, 0.12887475f, 0.02471981f, -0.10364551f, 
    0.09056436f, 0.18315804f, 0.09526291f, 0.10518416f, 0.08932358f, 0.07129636f, 0.01478239f, -0.04014595f, 
    -0.00237456f, 0.04890135f, -0.19948165f, 0.03614757f, 0.03920304f, 0.03016454f, -0.03036926f, 0.03063609f, 
    0.07415438f, -0.05743957f, 0.08271861f, -0.10681649f, -0.08966199f, 0.04821090f, 0.11460530f, 0.13379879f, 
    0.01100209f, 0.08470663f, 0.02932961f, -0.00062916f, -0.06133651f, -0.18337069f, -0.07366284f, 0.07734790f, 
    0.08412704f, -0.00790478f, 0.02158359f, 0.03862431f, -0.02390418f, -0.05077217f, -0.08384905f, -0.12681131f, 
    0.18398030f, -0.05823662f, -0.01411887f, -0.08690726f, -0.00609524f, 0.02556446f, 0.01323688f, -0.01249346f, 
    -0.02871005f, 0.05047941f, -0.01343649f, -0.01081341f, 0.01093375f, -0.09076467f, -0.04377523f, -0.08097023f, 
    -0.03666279f, 0.06149178f, 0.02564834f, 0.10346349f, 0.02159677f, 0.07547577f, 0.03339776f, 0.01694344f, 
    0.05192408f, -0.04261880f, -0.12130735f, 0.00299057f, -0.05979595f, 0.11528575f, 0.00149822f, -0.02973188f, 
    -0.06974674f, 0.19826987f, -0.04362567f, 0.04108879f, 0.04782987f, -0.05645278f, 0.11299492f, 0.10184693f, 
    -0.06210469f, 0.05688291f, -0.04753224f, 0.02448917f, 0.06335031f, -0.09086946f, -0.01098801f, -0.05605478f, 
    0.00726404f, -0.05826041f, 0.04403018f, -0.07213130f, -0.02903596f, 0.08917162f, 0.01320442f, -0.03590700f, 
    0.28007123f, -0.20185570f, -0.23991121f, 0.17051667f, -0.18817051f, 0.14698526f, -0.13727379f, -0.04819247f, 
    -0.08075684f, 0.18028064f, 0.02812514f, 0.01491144f, 0.04960153f, 0.04510687f, -0.07495293f, -0.03289076f, 
    -0.07513452f, -0.01698049f, -0.04222640f, -0.06187223f, -0.14767635f, 0.15467158f, 0.07594714f, 0.16322826f, 
    -0.05341423f, 0.07813790f, 0.13309667f, 0.17305827f, 0.05951702f, 0.04823026f, 0.08258914f, -0.03222854f, 
    -0.08111287f, -0.16744579f, -0.04799633f, 0.04269193f, 0.05635400f, 0.11673813f, 0.08687485f, 0.01083390f, 
    0.32084978f, 0.00766006f, -0.14865406f, 0.00340239f, -0.05618420f, -0.12829264f, -0.05155756f, -0.06289366f, 
    -0.08865810f, 0.13168539f, 0.02961121f, -0.08001237f, 0.06942919f, 0.05927556f, 0.05495612f, -0.09803766f, 
    0.01847336f, -0.00128446f, 0.01295062f, 0.07992236f, -0.32662767f, 0.10741240f, 0.07603484f, 0.06531793f, 
    -0.08736359f, 0.06268053f, 0.01915568f, 0.05875287f, 0.18935910f, -0.12021858f, 0.03408589f, -0.08090121f, 
    0.09157390f, 0.05287702f, 0.00417817f, -0.03021237f, -0.00142098f, -0.06914666f, -0.08476547f, 0.08651254f, 
    -0.13631426f, -0.32357165f, -0.26382411f, -0.00621257f, 0.06450915f, 0.05171633f, -0.00001686f, -0.09017220f, 
    0.00730702f, 0.11516235f, 0.01866214f, 0.09625662f, 0.03348090f, 0.03632055f, 0.03906433f, -0.02541918f, 
    0.03506885f, -0.04994575f, -0.05032256f, 0.05862664f, 0.18093680f, 0.01017915f, 0.02291198f, 0.04483668f, 
    -0.07847622f, -0.08529160f, -0.08159333f, 0.10856374f, 0.02505901f, 0.01503408f, 0.02841258f, -0.03591577f, 
    0.06391401f, 0.08253885f, -0.02533208f, 0.12113716f, 0.09136750f, 0.04176663f, 0.14598463f, 0.00330390f, 
    0.02597434f, 0.00987150f, 0.00258485f, 0.03614881f, 0.13850719f, 0.09159284f, 0.06298967f, -0.03204890f, 
    0.01450607f, 0.07672611f, -0.03590815f, -0.07112292f, -0.02002653f, -0.02952834f, -0.04326643f, 0.04432344f, 
    0.07897726f, 0.02519868f, 0.09209234f, 0.04803489f, 0.01379017f, 0.21319436f, -0.01784896f, -0.00444336f, 
    0.09786540f, 0.12523778f, 0.13348988f, 0.00743088f, 0.06102607f, 0.03812866f, -0.03102149f, -0.07448364f, 
    0.02876838f, -0.01655825f, 0.07606939f, 0.01844979f, 0.05747871f, 0.03384684f, 0.08366928f, -0.01754308f, 
    0.06020845f, 0.05146534f, 0.10930987f, 0.13057978f, 0.03887806f, 0.07768850f, 0.05867211f, -0.08316680f, 
    0.02572379f, 0.07027465f, -0.01602286f, 0.07640821f, -0.02177698f, -0.00729355f, 0.05617765f, -0.03299039f, 
    0.03682349f, 0.01296405f, 0.01154289f, -0.01234125f, 0.14683080f, -0.01235451f, 0.01787160f, 0.20493875f, 
    0.04361017f, 0.07263461f, 0.00491897f, -0.04745091f, 0.10560342f, 0.01258050f, 0.07965475f, 0.00904015f, 
    0.02610908f, 0.05627971f, 0.06200520f, 0.00096740f, -0.05644098f, 0.04941815f, -0.04025475f, 0.02097237f, 
    0.20135309f, -0.09272981f, 0.18114930f, 0.28446361f, -0.00527961f, 0.08473471f, 0.13372937f, 0.06950174f, 
    0.21469422f, -0.01013481f, 0.04309247f, 0.01627957f, -0.00555049f, -0.05512146f, 0.02463005f, 0.04894643f, 
    -0.05934813f, -0.02641251f, 0.00443143f, 0.04628924f, -0.20465660f, -0.08231047f, 0.11942627f, 0.02368706f, 
    -0.09711219f, -0.19337191f, -0.07234848f, -0.04710447f, 0.06991054f, 0.02288060f, -0.10660546f, -0.00338209f, 
    0.01456345f, -0.06129647f, 0.03032145f, -0.02921302f, 0.04219468f, -0.05069741f, -0.00616481f, -0.03022445f, 
    -0.10390445f, 0.07521629f, 0.03799383f, 0.11654495f, 0.08546064f, -0.00689771f, -0.09308025f, -0.00114575f, 
    0.02829381f, 0.01027978f, -0.04435657f, 0.00379249f, -0.06810359f, -0.02125845f, -0.01798466f, 0.07207230f, 
    0.08351845f, -0.03305800f, 0.16720448f, -0.01883204f, -0.02139567f, -0.24400645f, 0.14539061f, 0.08162369f, 
    -0.19001757f, -0.07916947f, -0.12216912f, -0.02273641f, -0.03936721f, -0.04656089f, 0.08359364f, 0.01648693f, 
    0.08004365f, -0.02731779f, 0.02456896f, 0.00554005f, 0.08039729f, 0.07028990f, -0.01541803f, -0.03275490f, 
    -0.22933282f, 0.01003941f, -0.04630581f, -0.05856152f, 0.06919307f, -0.07864543f, -0.12256920f, -0.02558678f, 
    0.03368257f, -0.02687018f, -0.04852179f, 0.08462862f, -0.10867827f, -0.05260542f, -0.08550923f, 0.04536943f, 
    -0.01390281f, 0.04047770f, -0.08862010f, -0.04353633f, 0.24829346f, -0.15362498f, 0.09404075f, 0.01199289f, 
    0.23320964f, -0.08583011f, 0.13792108f, -0.08467527f, 0.01503692f, 0.05344753f, -0.13308211f, 0.05536450f, 
    0.03983112f, 0.02627427f, 0.05379052f, 0.03050787f, -0.03269542f, 0.06493372f, 0.05629122f, 0.04841498f, 
    -0.16615708f, 0.16148221f, -0.10036986f, -0.10115656f, 0.00390208f, -0.03130842f, 0.04171881f, 0.03040406f, 
    0.02469941f, -0.18079668f, -0.04352503f, 0.12343805f, 0.17787585f, 0.01073374f, 0.01772085f, -0.04845957f, 
    0.04872160f, 0.06960934f, 0.00713246f, 0.04587488f, 0.16261545f, 0.05828930f, 0.07635211f, 0.18681982f, 
    0.19793183f, 0.08992691f, -0.04212375f, -0.02957742f, -0.04965208f, 0.08404548f, -0.01844677f, 0.01579984f, 
    -0.02704694f, 0.01593207f, 0.03253942f, 0.01015080f, 0.04090501f, 0.05881507f, 0.05111178f, 0.07549340f, 
    -0.01519047f, -0.08442887f, -0.03943607f, -0.11157531f, -0.14443552f, 0.08940167f, 0.10187058f, 0.06986684f, 
    0.10836293f, -0.03084300f, -0.04567885f, 0.10182765f, 0.03113243f, 0.04872714f, -0.06713214f, -0.04762501f, 
    -0.03106133f, -0.01736134f, 0.03718298f, 0.04858132f, -0.16461362f, -0.11069535f, 0.01014283f, -0.07652891f, 
    0.14422174f, -0.17154199f, -0.05648391f, 0.03144121f, -0.01299096f, -0.13044846f, -0.06224549f, 0.07545765f, 
    0.02389190f, -0.08880840f, -0.01523580f, 0.10653373f, -0.04988368f, -0.07538986f, -0.08417334f, 0.05810057f, 
    0.06604093f, -0.02855455f, 0.21238777f, -0.04390443f, -0.29276505f, 0.06391120f, -0.02447028f, 0.14910279f, 
    0.01364172f, -0.14530952f, -0.02859878f, 0.00870240f, 0.07817502f, 0.05766972f, -0.05396161f, 0.09579355f, 
    0.01938992f, 0.01898511f, 0.00461709f, -0.02090379f, 0.15161264f, 0.08511805f, 0.01601827f, 0.14490955f, 
    0.15205467f, 0.06849689f, 0.08573846f, -0.02082675f, 0.03022761f, 0.07077162f, 0.04039630f, -0.02392468f, 
    0.04369220f, -0.08126154f, 0.06763718f, -0.06200128f, 0.08388504f, -0.06612569f, 0.09217860f, 0.08733387f, 
    -0.04901770f, 0.00665133f, 0.00771222f, -0.02648119f, -0.02035021f, -0.04993440f, -0.03844355f, -0.00458146f, 
    -0.00490227f, 0.02393642f, -0.01274472f, -0.02845900f, -0.02310473f, 0.00209813f, -0.01741290f, 0.01176170f, 
    0.01169521f, 0.02621219f, 0.00480637f, 0.00382667f, -0.00631393f, -0.03253370f, -0.00537199f, -0.00754781f, 
    -0.05129308f, -0.02993907f, 0.00765840f, -0.00078868f, -0.00984771f, -0.01747779f, -0.03838887f, -0.00699889f, 
    0.01526890f, 0.00883865f, -0.01185548f, -0.02805818f, 0.03258316f, 0.04581994f, 0.05073499f, 0.04367483f, 
    0.02264599f, 0.02097446f, 0.01283233f, -0.00749842f, -0.02180324f, -0.04664074f, -0.04214735f, -0.02240361f, 
    -0.05192369f, -0.04319967f, 0.01832373f, 0.01579862f, -0.04034339f, 0.02604117f, -0.05865701f, -0.02689526f, 
    -0.01822424f, 0.03033607f, -0.01459994f, 0.02136619f, -0.01887119f, -0.03359101f, 0.04015499f, -0.01903301f, 
    0.02917605f, 0.00879511f, 0.01361420f, 0.00238891f, 0.04808772f, -0.00362973f, -0.02057711f, 0.01853804f, 
    0.01931279f, -0.01517685f, 0.00389822f, 0.02041725f, -0.04536285f, 0.04990491f, 0.03779571f, -0.02517964f, 
    -0.01929845f, 0.02070544f, -0.02678642f, 0.02096379f, -0.00794945f, -0.04946729f, 0.00816728f, 0.01092389f, 
    -0.04793436f, 0.02635256f, -0.03637255f, -0.03053750f, 0.01957726f, 0.02884644f, 0.01528307f, -0.02689859f, 
    0.06252153f, -0.01864857f, 0.04270765f, 0.00577592f, -0.00631090f, -0.04973338f, -0.00568049f, -0.05064062f, 
    0.02914238f, -0.01964776f, -0.04171377f, 0.01309836f, -0.04776443f, 0.02282721f, -0.00184897f, 0.00250907f, 
    0.01603166f, 0.05118236f, -0.04341911f, -0.06022074f, -0.02234996f, -0.04354509f, -0.00532844f, 0.00599273f, 
    0.04111971f, -0.00878163f, -0.00382398f, 0.00941851f, 0.04098539f, 0.01055649f, 0.02529369f, -0.02005368f, 
    0.01281813f, 0.03503559f, 0.04788459f, 0.01637801f, -0.02801822f, -0.02694449f, -0.04550900f, -0.05078379f, 
    -0.05350721f, -0.04012960f, 0.03886719f, -0.05782756f, 0.00528190f, 0.03666215f, 0.00529289f, -0.02822022f, 
    -0.03812129f, 0.04411329f, 0.00171067f, 0.00064140f, -0.02497332f, -0.00391649f, 0.04480127f, -0.01702215f, 
    0.00685622f, -0.02179291f, 0.04018713f, -0.00643124f, -0.03158044f, -0.02336701f, -0.04469073f, -0.04008534f, 
    -0.02103040f, -0.02484709f, -0.03060273f, -0.05191530f, 0.03409890f, -0.05565336f, -0.05347529f, 0.00919973f, 
    -0.03914303f, 0.01683428f, -0.01564661f, 0.00922385f, 0.05010670f, 0.04626017f, 0.03921602f, -0.04872674f, 
    -0.05561354f, 0.02902434f, -0.03723419f, -0.05317073f, -0.00085010f, -0.05880016f, -0.05668315f, 0.00011453f, 
    0.03181853f, -0.05683672f, -0.02999338f, -0.05088857f, -0.03624156f, -0.03441902f, -0.04333135f, -0.01338899f, 
    0.04842721f, 0.04168738f, -0.02868188f, 0.04161169f, -0.00953575f, -0.05777819f, -0.00984089f, 0.01706466f, 
    0.03972421f, 0.05117317f, 0.01422149f, -0.01791603f, -0.04896721f, 0.00510989f, -0.04399867f, -0.00628693f, 
    -0.00581298f, -0.01200170f, -0.02130402f, 0.04760810f, 0.01239573f, -0.05972502f, 0.04691923f, -0.04718468f, 
    -0.03603803f, -0.02156240f, 0.03448137f, 0.05226757f, -0.05454361f, -0.00799205f, 0.03823974f, -0.04543673f, 
    -0.03206106f, -0.00181243f, -0.03266687f, 0.04312813f, 0.00411381f, -0.00007385f, -0.00077966f, 0.01863967f, 
    -0.03432157f, 0.00441612f, 0.04869216f, -0.05035331f, -0.03303420f, -0.04155272f, 0.02860726f, 0.01206274f, 
    0.00441917f, -0.02257239f, 0.03796798f, 0.02394701f, -0.04696309f, -0.05524372f, -0.02205370f, 0.04259765f, 
    -0.01557914f, -0.05896633f, -0.04609240f, 0.02606353f, -0.03188445f, 0.03854261f, -0.04743427f, -0.04496520f, 
    -0.04711224f, 0.03787082f, -0.01873693f, 0.03577643f, 0.06320227f, -0.03082523f, 0.00419207f, 0.05998166f, 
    -0.03155243f, 0.01670525f, -0.01609420f, 0.02748412f, 0.01165940f, -0.01094290f, -0.02237576f, -0.03740509f, 
    0.04752597f, 0.02138974f, -0.03936409f, -0.04055101f, 0.05419604f, -0.02472757f, -0.03475227f, 0.01672255f, 
    0.04175261f, 0.05807733f, 0.00664084f, -0.02431464f, 0.02053510f, 0.01819145f, -0.03642842f, -0.02367111f, 
    0.01450904f, -0.03366781f, 0.03306377f, -0.00259049f, 0.04063796f, -0.02730627f, 0.03211064f, 0.06232480f, 
    0.03289811f, 0.01803264f, -0.02629639f, -0.04001249f, 0.03737685f, 0.02236689f, -0.05851856f, -0.03738477f, 
    -0.03235652f, -0.05000590f, -0.01056296f, -0.05634301f, -0.03466833f, -0.02443890f, 0.00861676f, 0.04771205f, 
    -0.00069152f, -0.02082467f, -0.03537767f, -0.05383440f, -0.05008611f, 0.00769136f, -0.02227522f, 0.03805561f, 
    0.09679314f, 0.08107297f, 0.08700152f, -0.17292531f, -0.13937789f, 0.00796575f, -0.03018099f, 0.08039490f, 
    0.03056730f, -0.02844993f, 0.01348615f, -0.00371924f, 0.06385384f, 0.02721031f, 0.02855917f, 0.02269348f, 
    -0.08128937f, -0.06398115f, -0.04578599f, 0.04753875f, 0.22130683f, -0.17438026f, -0.03219964f, -0.14926797f, 
    -0.09029671f, -0.08700764f, -0.00059123f, -0.08441252f, -0.01033024f, -0.15380567f, 0.08163809f, 0.00516826f, 
    -0.05947485f, 0.01988523f, 0.12793496f, 0.02205540f, -0.00004740f, -0.10840739f, -0.06624075f, 0.11502976f, 
    0.00054177f, 0.10005128f, -0.02153714f, -0.08411446f, 0.01743157f, 0.12692396f, -0.00359183f, 0.08640322f, 
    -0.03014887f, 0.03229549f, -0.03525700f, -0.01937789f, 0.08177971f, -0.00565888f, -0.01404731f, 0.05145498f, 
    0.02013284f, 0.11233214f, 0.00146553f, 0.02783324f, -0.11370255f, 0.16214766f, 0.00724570f, -0.15661025f, 
    0.19650114f, 0.01851859f, 0.03427613f, 0.07835402f, 0.02182020f, -0.00267840f, 0.01192360f, -0.02647967f, 
    -0.00053478f, -0.05291834f, -0.06771757f, 0.08110330f, 0.09865843f, -0.05739587f, 0.01255313f, 0.01455403f, 
    0.07706298f, 0.01576610f, -0.07702263f, -0.02847074f, -0.06655855f, 0.00843370f, 0.04721391f, 0.03827801f, 
    -0.13624826f, 0.05259327f, 0.01589702f, 0.00160902f, 0.11565860f, -0.07190658f, -0.04300096f, 0.07035618f, 
    -0.02361476f, -0.03459746f, -0.05458207f, 0.15391007f, -0.10928647f, 0.26215160f, 0.09521219f, 0.16905965f, 
    0.05250967f, 0.14010899f, 0.00135213f, 0.07709447f, 0.04387882f, 0.03727750f, 0.05755287f, 0.00714085f, 
    0.06556433f, 0.03087953f, 0.00730728f, 0.15740359f, 0.06225143f, -0.03249811f, -0.00063610f, -0.06136182f, 
    -0.06797718f, 0.11635952f, -0.00274541f, 0.04348995f, -0.10240602f, 0.08606181f, 0.06089697f, 0.05899981f, 
    0.01200445f, 0.01186098f, 0.14322379f, 0.03849645f, -0.00454428f, -0.04972535f, -0.11416888f, 0.07624266f, 
    0.03234045f, -0.00191470f, 0.00999904f, -0.05354863f, 0.22406030f, -0.00200241f, -0.24782920f, 0.10700828f, 
    0.12022751f, -0.01629849f, 0.05117719f, -0.05303635f, 0.11947612f, -0.03951699f, 0.02600997f, 0.11225729f, 
    0.05769370f, 0.01140439f, 0.08364820f, -0.02210695f, -0.04530604f, 0.00860336f, -0.00513904f, 0.05733138f, 
    0.17683296f, -0.06871425f, -0.06439681f, 0.09909531f, -0.05234963f, -0.03005176f, 0.03166214f, -0.00338605f, 
    0.00471819f, -0.02626338f, 0.02551004f, -0.02584973f, 0.04370295f, 0.01214879f, 0.12848797f, 0.10841063f, 
    -0.04753612f, -0.05765497f, -0.01946278f, -0.02123246f, -0.03004873f, -0.17683548f, -0.01755360f, -0.05644123f, 
    0.03926352f, -0.02740500f, -0.01176013f, -0.02811392f, -0.00998907f, -0.03096846f, 0.12544152f, 0.03780051f, 
    -0.02560130f, 0.02684578f, 0.00847872f, -0.03385040f, 0.00804999f, 0.03971476f, 0.09785006f, 0.00633257f, 
    0.28137183f, -0.18851568f, 0.01409914f, -0.01838193f, 0.04438873f, -0.12596439f, -0.08796210f, 0.06992739f, 
    0.05029492f, -0.02174514f, 0.08640131f, -0.00104923f, -0.05228159f, 0.08300747f, 0.00578087f, 0.03722581f, 
    -0.00401985f, 0.03257925f, -0.06023800f, -0.00373470f, 0.00256214f, 0.03336880f, 0.11385732f, -0.04262619f, 
    -0.05016584f, 0.14754276f, 0.08206335f, 0.04218347f, -0.02939443f, 0.04457525f, 0.07247822f, 0.04708832f, 
    -0.05706334f, -0.06780123f, 0.05494088f, 0.03133019f, 0.03515952f, -0.04874305f, 0.08274137f, -0.01715867f, 
    -0.02986845f, -0.09087172f, 0.16442829f, -0.10952675f, -0.02094069f, -0.08186801f, 0.00041200f, -0.03500457f, 
    -0.04986434f, 0.01543984f, 0.00259413f, -0.06193772f, -0.01709377f, 0.07606354f, 0.02137823f, -0.07965759f, 
    0.06127069f, -0.04854036f, -0.00983196f, 0.00488430f, 0.11883137f, -0.09164356f, -0.17276986f, 0.10094669f, 
    0.04817824f, -0.12897187f, 0.01264313f, -0.12161259f, 0.02415133f, 0.06739965f, -0.02440474f, -0.07682907f, 
    0.07604398f, -0.03176648f, -0.09271216f, -0.14430052f, 0.00208522f, 0.01171133f, 0.12606475f, -0.00654750f, 
    0.18174569f, -0.25503427f, -0.23282509f, 0.02226693f, 0.09568955f, -0.06789770f, 0.03864031f, -0.07753888f, 
    -0.02519651f, -0.02134406f, -0.04576963f, -0.03062624f, -0.00802593f, -0.02745531f, 0.13309556f, -0.01491443f, 
    0.05797310f, -0.00773375f, -0.03175980f, 0.08571720f, -0.06296080f, -0.07099163f, 0.07915294f, -0.06332837f, 
    -0.15504286f, -0.05189417f, 0.00607675f, -0.01219855f, 0.00497807f, 0.00019780f, -0.05709433f, -0.04337820f, 
    -0.11201795f, 0.10587093f, 0.07815344f, -0.00693066f, 0.07238574f, 0.13812324f, 0.08734336f, 0.10737970f, 
    0.18881090f, -0.08286663f, -0.04317164f, 0.01200256f, -0.05753865f, 0.01033237f, 0.07502533f, 0.00638057f, 
    -0.02626085f, 0.06289747f, -0.01323449f, -0.05310079f, 0.14933753f, 0.03916012f, 0.01933714f, -0.02257996f, 
    0.00759023f, -0.01718622f, -0.05566337f, -0.00280239f, 0.24424735f, -0.15905261f, -0.12989929f, -0.25914189f, 
    -0.04647817f, -0.01530378f, 0.05376486f, -0.11931451f, 0.13712859f, 0.04725589f, 0.03039182f, -0.05884504f, 
    0.04522235f, -0.00177743f, 0.12168989f, 0.06653344f, 0.01452556f, 0.04181596f, -0.06019767f, 0.10190526f, 
    0.11841100f, 0.11329301f, 0.21619521f, 0.00078025f, 0.15128197f, 0.12755062f, -0.00852978f, -0.06200685f, 
    0.05565229f, 0.04155790f, -0.04420765f, 0.00259794f, 0.18063453f, 0.07998348f, -0.02393005f, -0.04248367f, 
    0.00698235f, 0.04691487f, -0.07556148f, 0.02356464f, -0.13265900f, 0.16162524f, 0.00150598f, -0.08985491f, 
    0.08864016f, 0.00026673f, 0.01985751f, -0.04938322f, 0.03442252f, -0.01331643f, -0.00485920f, -0.09864185f, 
    -0.08240559f, -0.04204766f, -0.08022418f, -0.11035097f, 0.02157904f, -0.09001171f, 0.09378068f, -0.04696643f, 
    0.09197089f, 0.26037186f, 0.04360949f, 0.03865320f, -0.13981052f, -0.03255207f, 0.10643885f, 0.03895966f, 
    -0.02301283f, -0.06832995f, 0.08197440f, -0.05696450f, -0.02483084f, -0.03846594f, -0.03733723f, -0.03227885f, 
    -0.03249254f, -0.05600623f, -0.00464904f, 0.14041917f, -0.41945031f, 0.40711001f, 0.05081452f, 0.18136448f, 
    0.11706213f, -0.05982485f, 0.03166640f, 0.13036600f, 0.03937155f, -0.03483426f, -0.02701329f, 0.02730671f, 
    0.06250521f, 0.05225883f, -0.01532885f, 0.08682697f, 0.07607152f, -0.09233280f, -0.03506029f, 0.05435066f, 
    -0.26849526f, 0.02859795f, 0.00480350f, 0.39176467f, 0.19983520f, 0.02122368f, 0.04680470f, 0.06649872f, 
    0.02192977f, 0.09050368f, -0.06861245f, -0.04222478f, -0.03852591f, -0.00320035f, -0.00261884f, 0.09768207f, 
    0.03367003f, 0.06968843f, -0.00259041f, -0.00786744f, -0.01183181f, 0.25709561f, 0.00311132f, 0.06168534f, 
    0.02928143f, 0.10455971f, 0.06089271f, 0.05302664f, 0.01871789f, -0.00892359f, -0.04211794f, -0.11797386f, 
    0.02441994f, -0.09538200f, 0.08102182f, 0.06038706f, 0.00640516f, -0.00913704f, -0.04608266f, 0.01776938f, 
    0.05775939f, -0.07110379f, 0.07656535f, -0.06792758f, -0.05547396f, 0.01469952f, 0.01408339f, 0.07713476f, 
    -0.00767217f, -0.04929770f, 0.01882879f, -0.02667153f, 0.05649647f, -0.04362214f, 0.11064247f, 0.00326272f, 
    -0.04678186f, -0.06700506f, -0.01670686f, -0.01097257f, 0.28181487f, -0.22615483f, -0.01219260f, -0.06725703f, 
    -0.20483299f, -0.03748206f, -0.09180875f, 0.01909558f, -0.04551125f, 0.02301338f, 0.05721227f, -0.03086979f, 
    -0.03196156f, -0.10464245f, 0.04705383f, -0.00708803f, 0.00907615f, -0.06603543f, 0.03406838f, 0.00235136f, 
    -0.04868134f, -0.06524944f, -0.04734536f, -0.08034888f, 0.10484681f, -0.08574750f, -0.03146672f, 0.03335636f, 
    0.01651976f, -0.09392510f, 0.01361105f, 0.02319133f, 0.00323708f, 0.05074935f, 0.05248063f, 0.06977324f, 
    0.03302005f, 0.09771645f, -0.02019668f, 0.03775110f, 0.13150552f, 0.06049167f, 0.10362529f, 0.11483189f, 
    -0.16800477f, 0.12319512f, 0.15057246f, 0.05231891f, -0.12293158f, 0.00309820f, -0.04054288f, 0.02674820f, 
    0.03952187f, 0.01560722f, -0.03741550f, -0.03733365f, 0.02008251f, -0.02725368f, 0.00965363f, -0.02300070f, 
    -0.08969667f, -0.00480950f, -0.07147299f, -0.01919437f, 0.06044750f, -0.02687638f, 0.02059525f, 0.05690986f, 
    0.06183735f, 0.14832921f, -0.00859554f, 0.00088424f, 0.03548020f, -0.03266945f, -0.00348794f, 0.05498018f, 
    0.03539827f, -0.07779957f, 0.12567137f, 0.05656476f, 0.47307429f, -0.18488564f, -0.00376612f, -0.18029651f, 
    0.04080688f, -0.14779371f, -0.18090260f, 0.03558750f, 0.00228336f, 0.08339119f, -0.14177270f, -0.05203616f, 
    0.06939368f, 0.02260331f, -0.11763543f, -0.05770554f, -0.11203546f, 0.01829765f, 0.07819567f, -0.10131274f, 
    0.14040287f, 0.11787498f, -0.00238569f, -0.01236267f, 0.10522430f, -0.08335094f, -0.05836996f, -0.04643212f, 
    0.12152776f, 0.01102596f, 0.12804547f, -0.07254614f, -0.00698135f, 0.00048215f, 0.06153729f, 0.04469245f, 
    0.06414164f, 0.05417184f, -0.02833985f, 0.01480838f, 0.19406599f, -0.08164237f, 0.03025519f, -0.02085514f, 
    -0.14407955f, -0.07738529f, 0.00681534f, 0.00770051f, -0.04246556f, -0.05597467f, 0.02559855f, -0.07687206f, 
    -0.07810509f, -0.02909794f, 0.07971872f, -0.00235495f, 0.01457436f, -0.04828598f, 0.05859840f, -0.06606407f, 
    -0.20780134f, -0.15206215f, -0.20255792f, 0.17406793f, 0.04928249f, 0.02039623f, 0.06313404f, 0.05386125f, 
    0.02451004f, 0.06137336f, -0.09339684f, 0.03583134f, -0.00731483f, -0.06574421f, 0.05536066f, 0.04537213f, 
    -0.02251995f, 0.07179309f, -0.01260216f, 0.08100959f, -0.17012921f, -0.00757909f, -0.17345941f, -0.08100063f, 
    -0.05547458f, 0.03280554f, -0.02950465f, -0.00617995f, 0.14637102f, 0.01749264f, -0.00189422f, 0.00166217f, 
    0.01031763f, -0.01479590f, 0.04871969f, 0.12405467f, 0.07988779f, 0.07663550f, 0.05215985f, 0.08664666f, 
    -0.17136538f, -0.09201117f, 0.09254339f, 0.16816045f, 0.09879515f, 0.01264096f, 0.03431985f, -0.02941155f, 
    -0.01157297f, 0.05062813f, 0.00518601f, -0.01048929f, 0.07681829f, -0.05518988f, -0.02001638f, -0.04595709f, 
    0.06220433f, 0.00577449f, 0.07601777f, -0.01950513f, 0.25253609f, -0.02159918f, -0.01436063f, 0.05365164f, 
    -0.03008454f, -0.05594140f, -0.04558340f, 0.03178463f, 0.10974608f, -0.03396057f, -0.03720325f, -0.04469432f, 
    0.00941774f, 0.04337484f, 0.01318378f, 0.01229662f, -0.03146806f, 0.15315568f, 0.10522384f, 0.02081530f, 
    -0.00657221f, -0.08973386f, 0.06586526f, 0.11692208f, -0.28057787f, 0.05262846f, -0.06518034f, 0.03580221f, 
    0.13045245f, 0.00728570f, 0.02556773f, 0.06594269f, -0.07543015f, 0.10775390f, 0.07746047f, 0.02454984f, 
    -0.11096109f, 0.01955687f, 0.03489901f, -0.04930302f, -0.25920194f, 0.14800496f, 0.21771435f, -0.01093753f, 
    0.01708597f, -0.07631940f, -0.03157995f, -0.05006500f, 0.12180001f, -0.00174658f, -0.04014292f, -0.02339713f, 
    0.04766423f, -0.06104599f, -0.00321286f, -0.06006933f, 0.06461457f, 0.01275869f, 0.03503363f, 0.07190014f, 
    -0.04166322f, 0.01058068f, 0.12962447f, 0.14188124f, 0.02683197f, -0.10113834f, -0.04424690f, 0.03488843f, 
    0.08870567f, 0.13056429f, 0.02845567f, 0.01034333f, -0.12592395f, -0.07187699f, 0.03834558f, 0.09734177f, 
    0.01469242f, 0.01516046f, 0.09127723f, 0.02965413f, 0.02891980f, -0.07110965f, 0.11441737f, 0.03621212f, 
    -0.08634049f, -0.01569720f, -0.13067247f, 0.06674756f, -0.02025859f, 0.01252318f, 0.02431208f, 0.03250041f, 
    0.05715980f, 0.00929975f, 0.06926427f, -0.03047207f, 0.04666148f, -0.03119377f, -0.06354354f, -0.08363998f, 
    -0.16535527f, 0.05845086f, 0.03824538f, -0.00578648f, 0.11677426f, -0.07704347f, 0.02787188f, 0.01594216f, 
    0.10330100f, -0.10658135f, -0.06411946f, 0.04828771f, -0.06199638f, 0.06693979f, 0.02143856f, -0.08611958f, 
    0.01932927f, -0.00949322f, -0.07749102f, -0.07291768f, 0.31781632f, -0.12162145f, 0.16166623f, 0.07277954f, 
    -0.14826107f, -0.14445539f, 0.06975957f, -0.03971818f, 0.08004521f, 0.05264499f, -0.11375643f, 0.01793502f, 
    0.04058510f, 0.02176346f, 0.13670656f, -0.04091980f, 0.01865727f, -0.00645203f, 0.05081901f, 0.03247850f, 
    -0.18091905f, 0.10579868f, -0.09714091f, -0.00191978f, -0.10425649f, 0.01811009f, 0.07146766f, -0.00604016f, 
    0.01572431f, -0.14701195f, 0.04464057f, 0.08668869f, 0.05459395f, 0.06554335f, 0.04593482f, 0.00185413f, 
    0.09349701f, 0.13686809f, -0.00038096f, 0.05489831f, -0.13326496f, -0.06103773f, 0.09760666f, 0.19622432f, 
    0.02493809f, -0.00359130f, 0.05179251f, -0.02732687f, 0.02832884f, 0.03067140f, -0.01644678f, 0.00576408f, 
    -0.09000593f, -0.03583732f, 0.02619032f, -0.02020186f, -0.01586091f, 0.06712613f, 0.14557320f, 0.09810945f, 
    0.05458511f, -0.06635299f, -0.23450895f, -0.05889858f, -0.18676242f, 0.05881176f, 0.11322851f, 0.02656076f, 
    0.01486575f, 0.02001915f, -0.06438812f, 0.04830706f, 0.02883171f, 0.04135801f, -0.00320070f, 0.00530636f, 
    -0.09375528f, 0.05260100f, 0.05563989f, 0.04219212f, -0.01060642f, 0.00549840f, 0.08632901f, -0.06030388f, 
    0.32556778f, -0.08173646f, -0.11633990f, -0.04888848f, 0.16719091f, -0.06834733f, -0.02783549f, 0.07789636f, 
    0.00866555f, -0.05053211f, -0.07096647f, 0.18950285f, 0.01201807f, -0.09896392f, -0.08538469f, 0.01069710f, 
    0.04640315f, -0.03944663f, 0.15668069f, 0.03689963f, -0.12603527f, 0.13881224f, -0.00333866f, 0.17510574f, 
    0.06738555f, -0.00485629f, 0.03766331f, 0.02565542f, 0.07663701f, 0.04525938f, -0.01905387f, 0.08662340f, 
    0.07221587f, -0.07114772f, 0.12443828f, 0.03204887f, 0.24854088f, -0.04525342f, -0.03363252f, 0.14355978f, 
    -0.04861261f, -0.08946117f, -0.00134115f, 0.05763368f, -0.00869601f, 0.07919974f, 0.08095551f, -0.05632325f, 
    0.03229049f, -0.06439371f, 0.00877615f, 0.01101723f, 0.08989619f, -0.06472118f, 0.16196671f, 0.14769506f, 
    0.16775821f, 0.12107468f, 0.14558311f, -0.03324220f, 0.02228612f, 0.08042930f, 0.00962978f, 0.14683655f, 
    0.07210580f, 0.08097246f, -0.07173438f, 0.01312658f, 0.08855306f, 0.06204829f, -0.03631001f, -0.07078211f, 
    0.07667067f, -0.14599957f, 0.00135676f, -0.02420575f, 0.09919390f, 0.09688587f, 0.12690106f, 0.07886867f, 
    -0.11408770f, 0.08330680f, 0.00114396f, 0.09492513f, -0.10755739f, 0.01961871f, -0.01060728f, 0.05412715f, 
    0.02390594f, -0.08819089f, -0.02954666f, 0.04377109f, -0.00798301f, -0.07720476f, -0.06243233f, -0.13081260f, 
    0.14391111f, -0.16229223f, -0.19999725f, -0.09935532f, -0.00286974f, 0.14760716f, -0.01583101f, -0.04188137f, 
    0.08838670f, -0.03100040f, -0.01360395f, -0.04520688f, -0.03789309f, 0.05075441f, -0.04988672f, 0.12383904f, 
    -0.00349611f, 0.09279426f, -0.11739312f, 0.06558958f, -0.07223437f, -0.10448592f, 0.03762365f, 0.03020517f, 
    0.09712695f, 0.06936675f, 0.09134492f, -0.04435628f, -0.01024788f, 0.00568122f, 0.04930394f, 0.00214151f, 
    0.13284203f, -0.05022578f, 0.04594423f, 0.00831582f, 0.07952507f, 0.01852002f, -0.03583606f, 0.07152492f, 
    0.19537850f, -0.26777405f, -0.05212782f, -0.06849717f, -0.00415607f, -0.00771788f, 0.04739743f, -0.02381089f, 
    0.03893385f, 0.10180484f, 0.08252495f, 0.01658749f, -0.02340490f, -0.01242505f, 0.08151247f, -0.03383578f, 
    0.02314767f, -0.00600740f, -0.13182698f, 0.05271921f, 0.25852564f, -0.18289344f, 0.00546113f, 0.02955959f, 
    -0.01569039f, 0.04343713f, 0.05747201f, 0.00885930f, -0.06537306f, 0.05983638f, 0.03670485f, -0.00678050f, 
    -0.02391311f, 0.07299587f, -0.04975192f, 0.05759119f, -0.01340436f, 0.07638849f, -0.00696555f, -0.01866666f, 
    -0.03679906f, 0.02390989f, 0.13903937f, -0.19079280f, -0.09609732f, 0.03100362f, -0.10958198f, -0.03065323f, 
    0.03375221f, 0.05400472f, 0.02709053f, -0.08351231f, 0.08382627f, 0.17233770f, 0.05382877f, -0.04857614f, 
    -0.03648695f, -0.05687451f, -0.03962247f, -0.07866000f, -0.09959795f, 0.12138500f, -0.05453045f, -0.01027976f, 
    0.03225674f, -0.04118675f, 0.10053736f, 0.02906968f, -0.03727340f, 0.05444216f, -0.03001158f, 0.11314290f, 
    0.03943349f, -0.02292254f, -0.04880150f, 0.03441574f, -0.06101281f, 0.01970268f, 0.01764563f, 0.06977919f, 
    0.11518405f, 0.01656411f, -0.01035123f, -0.07985149f, 0.08469561f, -0.01462682f, 0.00565715f, -0.03276603f, 
    -0.02331241f, 0.10677858f, 0.10057139f, -0.01187762f, 0.05646737f, -0.04013518f, 0.11107489f, 0.07858394f, 
    0.12226225f, -0.03223294f, 0.04546659f, 0.02897452f, -0.09067105f, -0.27300838f, 0.07796460f, -0.15149908f, 
    0.17556733f, 0.00315919f, -0.06129795f, 0.07812750f, -0.03007242f, -0.12160931f, 0.07595427f, 0.02661913f, 
    0.05560743f, 0.05958432f, 0.01116567f, 0.04101364f, -0.03534542f, -0.06607882f, -0.01130718f, -0.08879794f, 
    0.25652474f, 0.02084170f, 0.05411952f, -0.03428002f, -0.06648470f, 0.06675926f, 0.03431278f, 0.01964987f, 
    0.05782278f, 0.07231925f, 0.14510685f, -0.01074760f, -0.07169285f, -0.12609398f, 0.03784893f, 0.09952526f, 
    0.01612901f, -0.06647483f, -0.00278987f, -0.01984944f, 0.07387275f, 0.03409516f, -0.02282112f, -0.25917161f, 
    -0.01942529f, 0.03582225f, -0.04733507f, 0.02109613f, 0.06306234f, -0.05505482f, -0.00500326f, 0.07265202f, 
    0.15262456f, 0.12958650f, 0.09519522f, 0.00626967f, 0.01870269f, -0.05284806f, -0.04663073f, 0.04416736f, 
    0.08395920f, 0.09038714f, 0.16268989f, 0.12183083f, 0.05597129f, 0.02109514f, -0.03448500f, 0.10727200f, 
    0.01484419f, 0.01042455f, 0.10278229f, 0.05990656f, -0.04778163f, 0.08810326f, 0.05908259f, 0.06384104f, 
    0.09300263f, -0.05658093f, 0.01733437f, 0.06642628f, 0.14384304f, 0.12996228f, 0.03456362f, 0.09167940f, 
    0.08840058f, -0.04919275f, 0.03411034f, -0.10520760f, -0.16118619f, -0.03676265f, 0.04802573f, -0.03714400f, 
    -0.03898910f, 0.01994289f, 0.07378098f, -0.00498921f, 0.11807754f, 0.03055600f, 0.03185695f, -0.02244763f, 
    0.08217093f, 0.19303271f, -0.05404035f, -0.00132376f, 0.06897507f, -0.06936499f, 0.11269694f, -0.11316217f, 
    -0.13985994f, -0.06042242f, 0.08346541f, 0.16020343f, -0.11464071f, 0.00064742f, 0.06138214f, 0.03593339f, 
    -0.07825106f, -0.03528950f, -0.08329615f, 0.01999709f, -0.11414586f, 0.03160815f, -0.03178116f, 0.02419995f, 
    -0.09549692f, 0.13534872f, 0.01743267f, -0.03904637f, 0.05475455f, 0.09323657f, -0.03610140f, 0.11683304f, 
    -0.07099812f, 0.02851669f, -0.02362849f, 0.05984757f, -0.11388030f, -0.01556619f, -0.10443445f, -0.02987308f, 
    0.13096082f, 0.13987571f, 0.03957493f, 0.21418950f, 0.06145971f, 0.09469207f, 0.09657758f, 0.01931108f, 
    0.06818811f, -0.02298211f, 0.02194819f, -0.00067728f, 0.11822229f, 0.00424556f, 0.02317759f, 0.05754945f, 
    0.05137046f, 0.00669838f, 0.05657706f, 0.04934258f, 0.04637481f, -0.03815641f, -0.05244127f, -0.07137634f, 
    -0.04418419f, 0.08324278f, 0.04088844f, 0.01562100f, 0.14505334f, 0.05623155f, -0.02272499f, -0.07011424f, 
    0.06585361f, 0.02340605f, 0.12384427f, 0.03702025f, 0.07424100f, 0.02213034f, 0.03120160f, 0.04581052f, 
    -0.16699016f, 0.10679790f, 0.07799435f, 0.09765863f, 0.15285404f, 0.03225171f, -0.06026652f, -0.08730026f, 
    0.09574618f, -0.01779425f, 0.01040889f, 0.03831688f, 0.10942724f, 0.00181160f, -0.00633586f, -0.02583366f, 
    0.06063912f, -0.02145080f, -0.03618513f, 0.00245506f, -0.16335726f, 0.10841337f, 0.08425844f, -0.13655499f, 
    0.13005455f, -0.03418051f, 0.05491547f, -0.08978196f, 0.10178949f, 0.00189116f, -0.01637502f, -0.02289092f, 
    -0.07835761f, -0.00796829f, -0.01362880f, -0.02904729f, -0.04770065f, -0.11678602f, 0.04661976f, -0.03697656f, 
    -0.32679403f, -0.00550412f, 0.12300760f, 0.16174395f, -0.05318638f, 0.08419514f, -0.12171298f, -0.05074534f, 
    0.04149899f, -0.08987708f, -0.00636194f, 0.06780632f, 0.02121585f, -0.08232650f, 0.01520002f, -0.01549367f, 
    -0.07389047f, -0.04299077f, 0.08528125f, 0.01109997f, -0.16531226f, 0.20152873f, 0.03573127f, 0.08472984f, 
    0.18442850f, -0.14087595f, -0.14254749f, -0.00942032f, -0.06250706f, 0.01409600f, 0.09107517f, -0.01163167f, 
    0.03841525f, -0.01207840f, -0.01505668f, 0.07203398f, 0.07805619f, -0.05740086f, -0.04182024f, -0.01241052f, 
    -0.06260389f, -0.19121774f, 0.09247638f, 0.27932206f, 0.19883169f, -0.02241804f, 0.04077134f, 0.03765382f, 
    -0.04703582f, 0.00661300f, 0.01794681f, 0.01779104f, -0.01207467f, 0.00267079f, 0.11992106f, 0.07084325f, 
    -0.05034436f, 0.03311072f, 0.05224237f, -0.06384215f, -0.32974207f, 0.39769411f, -0.04493807f, -0.08803876f, 
    -0.05626902f, 0.07704271f, -0.07933792f, -0.06053863f, -0.05544429f, 0.10778486f, -0.12947439f, -0.10803553f, 
    -0.00151730f, -0.03640776f, 0.10214496f, 0.01886148f, -0.04119904f, -0.10430923f, -0.08569729f, -0.02877837f, 
    -0.11869910f, -0.14468357f, -0.05768483f, -0.10506809f, -0.06899288f, -0.04476300f, 0.04196192f, -0.06305004f, 
    -0.02069975f, -0.16874149f, 0.03809556f, -0.01567758f, -0.04134325f, 0.03928973f, 0.08829670f, -0.06315457f, 
    0.07721127f, -0.04951014f, -0.00794477f, 0.00585415f, 0.36979610f, -0.18401140f, -0.19932316f, 0.01892051f, 
    -0.27496937f, -0.08704221f, 0.00199843f, 0.08163507f, 0.02990142f, -0.05234856f, 0.02269337f, 0.01886532f, 
    -0.03364944f, -0.03912662f, 0.03486372f, -0.07792472f, 0.00629868f, -0.02483887f, 0.08525208f, -0.00715203f, 
    -0.49040934f, 0.04151104f, -0.03617788f, 0.03037755f, -0.05562335f, -0.03212473f, -0.01998497f, 0.08648844f, 
    0.01793282f, -0.12233735f, -0.00868536f, -0.04720045f, 0.05168376f, 0.00606744f, 0.08763603f, 0.00529061f, 
    0.00788812f, 0.05757282f, 0.07965077f, -0.11184677f, -0.12154248f, -0.13934980f, 0.09088113f, 0.13256291f, 
    -0.03066748f, -0.04217195f, 0.03140476f, -0.07130779f, -0.04763673f, -0.05327512f, 0.07573657f, -0.08020901f, 
    -0.02864810f, 0.07101510f, -0.04169625f, -0.02353690f, -0.08965109f, -0.04446201f, 0.07875054f, 0.03219603f, 
    -0.17563316f, 0.08888438f, -0.08046300f, 0.04222929f, 0.14443991f, 0.15271918f, 0.05960285f, -0.02579017f, 
    0.13905622f, 0.07995437f, 0.01576120f, 0.09178167f, 0.00606630f, -0.09965784f, -0.05389157f, 0.10347811f, 
    -0.00939458f, -0.02821309f, -0.00500564f, 0.00496159f, 0.54195285f, -0.30099261f, 0.04659090f, -0.12668931f, 
    -0.03519194f, -0.03439673f, -0.00988829f, -0.14071219f, 0.01615036f, 0.05068781f, -0.06711669f, 0.03939416f, 
    0.01042207f, -0.04894558f, 0.00252875f, 0.04702944f, -0.04204676f, -0.04833572f, -0.07885855f, -0.05836075f, 
    -0.15799876f, 0.08622030f, 0.03050326f, 0.12413193f, 0.10355139f, 0.05015454f, -0.01661372f, 0.05140389f, 
    0.01823334f, -0.04044765f, 0.10858081f, 0.04978853f, 0.06478705f, 0.05873835f, 0.00581808f, 0.03396657f, 
    0.04388756f, 0.01884911f, 0.02429067f, -0.08241589f, -0.05408924f, -0.04537619f, 0.04392195f, 0.03141305f, 
    0.07762215f, 0.01781156f, 0.10172436f, 0.00970782f, 0.08904887f, -0.03475600f, 0.08694982f, 0.08361721f, 
    -0.01745736f, 0.07610253f, 0.05129863f, -0.05141841f, 0.09175329f, -0.03261455f, -0.02641205f, 0.01461931f, 
    -0.00761412f, -0.04494132f, 0.01273444f, 0.01251913f, 0.01131348f, 0.07100601f, -0.06524026f, 0.10285408f, 
    0.03313188f, 0.04987333f, 0.00423422f, 0.07936556f, 0.11303056f, 0.05239616f, -0.02172459f, 0.07012884f, 
    0.06326050f, -0.13257094f, -0.02171275f, 0.01619140f, -0.13040179f, 0.05144293f, -0.13497758f, -0.14598055f, 
    -0.19517800f, -0.00769804f, 0.06314440f, 0.00783762f, -0.13268042f, 0.04581304f, 0.03872426f, 0.11280265f, 
    0.08537935f, -0.08459248f, 0.01947758f, 0.11016353f, 0.05136393f, -0.01628039f, -0.08838847f, -0.12635683f, 
    -0.09364875f, 0.09531406f, -0.16135107f, -0.10438695f, 0.04703632f, 0.02301508f, -0.08120407f, 0.00652349f, 
    0.14138183f, 0.01044945f, 0.03904193f, 0.04772859f, -0.13551834f, 0.01875379f, 0.00021036f, -0.00000135f, 
    -0.18384540f, 0.17724630f, -0.17871100f, 0.07871120f, -0.41337696f, 0.00293240f, -0.12125786f, -0.03492048f, 
    0.07202964f, 0.00529609f, 0.19189496f, 0.00178455f, 0.04805896f, 0.01995919f, -0.01059250f, -0.01868539f, 
    0.10602479f, -0.04380537f, 0.00979464f, -0.01292359f, 0.01086142f, 0.03728930f, -0.04121004f, 0.10153665f, 
    -0.34130690f, -0.06955340f, -0.05932884f, 0.06715143f, 0.12662213f, 0.07394483f, -0.02568044f, -0.09903480f, 
    -0.05341262f, 0.03152213f, 0.07674101f, 0.03938144f, 0.03555782f, -0.08899399f, 0.07753901f, -0.04340028f, 
    0.02427258f, 0.01392929f, -0.08149301f, 0.05711100f, 0.28343192f, 0.10965207f, 0.11143224f, 0.09066323f, 
    0.01865507f, -0.03772048f, 0.03654610f, -0.00106149f, -0.03321390f, 0.00309456f, 0.01303560f, -0.00438427f, 
    0.07185769f, 0.12814136f, -0.00524376f, -0.05430765f, -0.06133821f, 0.07232832f, 0.03193503f, 0.02604839f, 
    0.09276298f, 0.13843019f, 0.12120149f, 0.05588207f, -0.06112929f, -0.03566189f, 0.02075726f, 0.06778015f, 
    0.06537043f, 0.04802059f, -0.02118370f, -0.09355737f, 0.14715676f, 0.16832830f, 0.16285583f, 0.01035353f, 
    0.04687419f, -0.09083936f, -0.08135613f, -0.04530501f, -0.19482079f, 0.00703555f, 0.00693649f, 0.04759327f, 
    -0.04964938f, 0.00116218f, 0.09908259f, -0.00810898f, -0.03555879f, 0.07263373f, -0.07023873f, 0.07593160f, 
    0.02099906f, -0.06422141f, -0.01210529f, -0.00446946f, 0.05406633f, 0.03913299f, 0.01826130f, 0.00263120f, 
    0.02044812f, -0.02191719f, 0.05779722f, 0.07221705f, 0.11800439f, 0.04304013f, 0.07000315f, 0.07402658f, 
    0.01684570f, 0.15550558f, 0.13374300f, -0.01749538f, 0.10083508f, -0.06631502f, 0.02929122f, 0.08351250f, 
    0.09822934f, -0.11692129f, 0.13034552f, 0.08988095f, -0.12911431f, -0.12657839f, 0.04611818f, -0.07582277f, 
    0.06370030f, 0.00802039f, -0.08913167f, 0.04376587f, -0.02372498f, -0.00054348f, 0.08830759f, -0.00586145f, 
    0.00744115f, 0.04816236f, 0.01013707f, -0.02210800f, -0.09268620f, -0.09499592f, -0.04125115f, -0.02450790f, 
    0.09559117f, 0.02396800f, -0.20673357f, -0.08134335f, -0.10224382f, 0.08300737f, 0.02829180f, -0.04075838f, 
    -0.02098455f, -0.06115937f, 0.00045185f, 0.02950898f, -0.02960787f, -0.12534876f, 0.02889763f, 0.02605006f, 
    0.10927466f, -0.10655876f, -0.00767530f, 0.04887380f, 0.00640120f, -0.03967727f, 0.08252681f, 0.00279659f, 
    0.05084486f, -0.00616494f, -0.01200357f, 0.06009207f, 0.05487622f, 0.00310652f, -0.00148879f, 0.01668524f, 
    0.05379800f, 0.16118467f, 0.12137359f, 0.06100739f, 0.00463320f, -0.06784225f, -0.08821761f, 0.00425207f, 
    -0.15503530f, -0.02982888f, -0.05267934f, -0.04631693f, -0.09544923f, 0.10503788f, 0.03859603f, 0.12667061f, 
    0.07033983f, -0.03507145f, 0.05170990f, 0.00908971f, -0.02682914f, -0.02935022f, 0.01553023f, 0.04688103f, 
    0.13020627f, 0.03354495f, -0.01510787f, -0.00757334f, 0.07862907f, 0.12079451f, 0.02623241f, 0.10355697f, 
    -0.04747277f, 0.05235032f, 0.10971484f, -0.04473649f, -0.05422820f, 0.09280708f, 0.08548797f, -0.06912601f, 
    -0.01592737f, 0.04518065f, 0.03558682f, -0.07217592f, 0.09126998f, 0.12048453f, 0.06354529f, -0.02975934f, 
    -0.26427788f, -0.00625065f, -0.04459747f, -0.04622734f, -0.02284797f, -0.04507320f, 0.14211988f, 0.03279854f, 
    -0.13749433f, -0.03262593f, 0.00933416f, 0.06825060f, -0.04385909f, -0.00114222f, 0.00841412f, 0.04364702f, 
    -0.03520173f, 0.05768342f, 0.00294468f, 0.04733913f, -0.21074294f, 0.14124236f, -0.13079004f, -0.08566634f, 
    -0.06251176f, 0.07603543f, 0.00674212f, -0.06896359f, 0.07180005f, 0.10055386f, -0.06685090f, 0.01522270f, 
    -0.05315199f, 0.03826952f, 0.03268856f, 0.05898753f, 0.01341658f, 0.05735063f, -0.13421309f, -0.03282365f, 
    0.10492457f, 0.07141582f, -0.06917944f, 0.07045519f, 0.04591606f, -0.02195589f, -0.01072405f, 0.02437135f, 
    -0.02346728f, 0.03011188f, -0.05969115f, 0.02881091f, 0.16605277f, 0.02673083f, -0.00467803f, 0.05271010f, 
    0.06593942f, -0.00057545f, 0.08104122f, 0.06124545f, -0.03954080f, 0.31056026f, -0.28686577f, 0.11499192f, 
    -0.02866511f, 0.07863151f, 0.02990558f, 0.04661110f, -0.05249161f, 0.20750029f, -0.00981333f, 0.02715950f, 
    0.06946963f, -0.14358735f, -0.08403435f, 0.00389097f, -0.01305929f, 0.08321715f, 0.06319772f, -0.04721162f, 
    0.01713068f, 0.13804562f, 0.03734104f, 0.02581039f, 0.04976822f, -0.00320217f, -0.02103728f, 0.00822691f, 
    0.08572662f, 0.01226303f, -0.00081043f, 0.06463193f, -0.12616883f, 0.10425227f, 0.04207776f, 0.07587560f, 
    0.01903347f, 0.05426928f, -0.04084594f, 0.04746611f, -0.28312072f, -0.11544666f, -0.19179662f, -0.00317400f, 
    -0.13181999f, 0.05309028f, 0.05168657f, 0.01382348f, 0.01973512f, 0.01456257f, -0.04695133f, -0.00955750f, 
    0.01383009f, 0.07519545f, -0.00336372f, -0.00772109f, 0.00194362f, -0.00485244f, -0.00301186f, 0.03767005f, 
    -0.35193008f, 0.31370190f, -0.01075238f, 0.06872327f, 0.23325139f, 0.13406175f, 0.11409813f, -0.03962224f, 
    0.07619765f, 0.11708901f, 0.04044342f, -0.03848762f, -0.07128211f, 0.05265229f, -0.10189556f, 0.01109226f, 
    0.09045196f, 0.03102835f, 0.10328545f, 0.15043476f, -0.08355011f, -0.18210045f, -0.11754363f, 0.01143857f, 
    0.11248045f, -0.02251351f, 0.09673316f, 0.06578371f, -0.10235739f, -0.05854063f, 0.07060438f, -0.01358249f, 
    0.05222812f, 0.19621865f, -0.05100583f, -0.03468168f, 0.07810766f, 0.07803983f, -0.01343007f, 0.06374915f, 
    0.04890153f, -0.10902058f, -0.08240473f, 0.09263743f, 0.16437724f, 0.08362193f, 0.09607290f, 0.02292408f, 
    -0.00747760f, -0.03987705f, -0.09891020f, -0.03466081f, 0.04029356f, 0.24809559f, 0.12335162f, -0.03402830f, 
    0.02589303f, -0.04879552f, -0.05701837f, -0.04463540f, -0.45862836f, 0.15841405f, 0.13408864f, -0.07088866f, 
    -0.14715774f, 0.11213040f, 0.04535218f, 0.02458710f, -0.09811754f, 0.02837687f, -0.06219932f, -0.10280520f, 
    -0.04306347f, 0.00641268f, -0.03807331f, 0.10502103f, 0.03206890f, 0.05630876f, 0.09098370f, 0.00673105f, 
    -0.02659239f, 0.14156778f, 0.09084196f, 0.06885333f, 0.05117553f, 0.07751016f, -0.02039239f, 0.00216946f, 
    0.00066386f, 0.07541688f, 0.01754339f, 0.01750386f, 0.03734007f, -0.11458007f, -0.06844051f, 0.03495953f, 
    0.15751526f, -0.10255496f, 0.15894398f, 0.05365349f, 0.02284506f, 0.03985021f, 0.01863281f, -0.05999580f, 
    0.09805877f, -0.04547163f, -0.07287445f, 0.06815095f, 0.10339227f, 0.00838140f, -0.00861491f, -0.02624322f, 
    -0.01229374f, -0.08188009f, -0.06906390f, 0.01324504f, -0.11231330f, 0.01829719f, -0.04141118f, 0.05930457f, 
    0.18744129f, 0.11626451f, -0.33493701f, 0.02181417f, -0.10627044f, 0.02938936f, -0.02290309f, 0.07028903f, 
    0.07638861f, 0.01243884f, -0.02180772f, 0.07227156f, -0.08949643f, -0.13936239f, 0.00914035f, 0.02215031f, 
    0.02011739f, -0.08842407f, 0.01540320f, -0.06165261f, 0.12370057f, 0.21410443f, 0.08327119f, 0.16925943f, 
    0.06665958f, 0.06390477f, -0.02832935f, 0.04281540f, 0.05718436f, -0.00373612f, -0.00467240f, -0.04858584f, 
    0.20362380f, 0.14757992f, 0.04071511f, 0.05678605f, 0.09864556f, 0.00445308f, -0.07378671f, 0.07749571f, 
    0.06039951f, 0.06468237f, -0.16776283f, 0.16486301f, -0.07657553f, 0.05298343f, 0.01999975f, 0.12655121f, 
    0.01967816f, 0.01886504f, 0.01745333f, 0.03479835f, 0.02114994f, -0.04362105f, -0.03318215f, 0.08243055f, 
    0.04571738f, 0.08430113f, 0.02388063f, -0.01759292f, -0.20743427f, -0.08962322f, 0.10891509f, -0.05584391f, 
    -0.17453022f, 0.00261825f, 0.04642757f, 0.04996393f, -0.12195697f, -0.11117048f, 0.05342777f, -0.00897048f, 
    -0.04599517f, 0.11598089f, 0.11719627f, 0.00783906f, 0.09265659f, 0.11267456f, 0.04841572f, 0.05449587f, 
    -0.33582342f, 0.16617116f, -0.08704123f, -0.10331077f, -0.25654691f, -0.04472374f, -0.02285434f, 0.06724523f, 
    -0.11012260f, -0.09916127f, 0.11575002f, 0.05123401f, -0.05032041f, -0.16486886f, -0.05427082f, 0.01386780f, 
    -0.02795411f, 0.07334227f, 0.02078537f, -0.05723757f, 0.10361711f, 0.06669962f, 0.07391100f, 0.01494798f, 
    0.13150021f, 0.14836894f, 0.02430617f, -0.08393949f, -0.03131983f, 0.10391238f, -0.05157321f, 0.02018515f, 
    0.07543465f, -0.01138296f, -0.06466603f, -0.04657186f, 0.00343561f, -0.04915269f, -0.07690609f, -0.06758064f, 
    0.00619878f, 0.00187888f, -0.01228237f, -0.03444625f, 0.08090343f, 0.15001103f, 0.11779375f, 0.04980362f, 
    0.06650581f, 0.08807050f, 0.00467688f, 0.03499375f, 0.09019447f, 0.07092097f, 0.06065706f, -0.08548510f, 
    0.03796393f, -0.09171913f, -0.06282348f, 0.05371182f, -0.12196910f, 0.00395288f, -0.05497323f, -0.23375908f, 
    -0.05437984f, 0.01695034f, 0.09282447f, 0.03825260f, -0.04853376f, 0.09920926f, -0.01200349f, 0.17156917f, 
    0.00759936f, -0.10405584f, 0.13017578f, 0.02996707f, -0.01176768f, -0.11191656f, -0.02209024f, -0.10983457f, 
    0.16505551f, -0.06501406f, 0.02705109f, -0.01141589f, 0.07632755f, 0.11788489f, -0.07622407f, 0.01428933f, 
    0.08055174f, -0.07147695f, 0.05143612f, 0.02998696f, -0.03333745f, 0.10058966f, 0.01884407f, -0.04869207f, 
    -0.06462999f, 0.22056584f, -0.22882381f, 0.07060986f, -0.00969904f, -0.09628733f, -0.05433993f, 0.15454660f, 
    0.06175169f, 0.03363696f, 0.14699574f, -0.02085263f, 0.11398543f, 0.14655255f, 0.03648912f, 0.00871448f, 
    -0.02840202f, -0.00939131f, 0.02762774f, -0.00413391f, 0.08689288f, -0.00883571f, -0.05004741f, 0.12950072f, 
    0.04915424f, -0.02800355f, -0.03747752f, 0.07596130f, -0.14943823f, 0.05407663f, 0.13162360f, 0.04573428f, 
    -0.00537976f, -0.00369104f, 0.04904335f, -0.09321984f, 0.12845480f, 0.01842670f, 0.04137613f, -0.04841610f, 
    0.00152447f, -0.04943440f, -0.01883282f, 0.07781111f, -0.31895101f, -0.03812005f, 0.19289634f, 0.19928789f, 
    -0.09868679f, 0.05813587f, 0.11336223f, -0.01156394f, -0.01300098f, -0.02494948f, -0.04283001f, -0.04294574f, 
    0.03815032f, 0.07818239f, 0.09999745f, 0.03539158f, -0.06568910f, 0.04031787f, 0.00558324f, 0.04683905f, 
    -0.24540363f, 0.03943451f, 0.17035352f, 0.05225854f, -0.10794663f, 0.00105927f, -0.04673250f, -0.00971848f, 
    0.01913679f, 0.10345042f, -0.09775183f, -0.00654363f, 0.00013546f, 0.08340561f, 0.05482759f, -0.03555834f, 
    0.05799896f, -0.03440261f, 0.04220002f, -0.07328884f, 0.02652265f, 0.03298464f, -0.06342527f, 0.16730560f, 
    -0.16572621f, 0.11234818f, 0.02422583f, -0.02491308f, -0.00571868f, 0.03708501f, 0.05705268f, 0.00559039f, 
    0.04955786f, -0.09025982f, 0.00701683f, -0.01418346f, 0.09883281f, 0.05759103f, 0.04508904f, 0.03165461f, 
    -0.09332113f, 0.01886589f, -0.04755261f, 0.00654026f, 0.10269341f, -0.05084791f, 0.04247826f, 0.07037297f, 
    -0.02351428f, 0.03590069f, 0.04355479f, 0.03021812f, 0.02169267f, -0.03000713f, 0.06772721f, 0.04925507f, 
    0.17804119f, -0.14569829f, 0.10781379f, 0.10331242f, -0.00502704f, -0.22246450f, 0.05136587f, -0.13439092f, 
    -0.01260935f, -0.06498160f, 0.08240481f, 0.08078004f, -0.06082230f, 0.14525487f, -0.01019222f, -0.08270247f, 
    0.05232845f, 0.01936148f, -0.03150936f, 0.01036679f, -0.07521266f, -0.05210114f, 0.05603157f, 0.02204309f, 
    0.07780232f, 0.13758354f, -0.10401225f, -0.11433376f, 0.15284617f, -0.00360735f, -0.04860627f, -0.01965496f, 
    0.11692788f, -0.09186817f, 0.06318818f, 0.07394870f, 0.01649146f, 0.06783964f, 0.10510759f, 0.01927189f, 
    0.07888121f, 0.06925319f, 0.04493918f, 0.02983167f, 0.24229205f, 0.09125316f, -0.03542108f, -0.04743367f, 
    -0.04721987f, 0.04459272f, 0.03470608f, -0.01912701f, 0.02412990f, 0.02995925f, -0.04090901f, 0.02284726f, 
    0.10189373f, 0.06086924f, 0.07742862f, 0.02876781f, 0.09717792f, 0.01584784f, -0.16423626f, -0.07452966f, 
    -0.28546593f, -0.09275750f, -0.05450286f, -0.11375884f, 0.09309843f, 0.09690201f, -0.03329413f, 0.05904888f, 
    0.01568391f, 0.05530856f, -0.05057154f, 0.08880938f, 0.01542072f, 0.06237181f, 0.00002919f, 0.01508774f, 
    -0.00551993f, -0.06009270f, 0.03471812f, 0.03614137f, 0.09468693f, 0.02964161f, -0.00127522f, -0.03710210f, 
    0.21958484f, -0.14258897f, -0.08745147f, -0.01174902f, -0.15014620f, -0.04747251f, 0.02022745f, -0.08120698f, 
    -0.00051394f, -0.00106505f, 0.06172428f, 0.04153960f, 0.01134585f, 0.10609989f, 0.12469114f, -0.07545706f, 
    0.20123407f, 0.12744433f, -0.04846672f, 0.03225949f, -0.04749165f, -0.12299298f, -0.06869749f, -0.04171623f, 
    -0.01542838f, -0.04250174f, 0.10291205f, -0.06565647f, -0.03060399f, -0.06934206f, 0.04325252f, 0.16499044f, 
    -0.01457511f, 0.14447950f, -0.00419910f, -0.00233215f, 0.22232452f, -0.00341529f, -0.02863059f, -0.09053554f, 
    -0.04724092f, 0.08354706f, -0.02412890f, 0.05915051f, -0.04182588f, 0.02593243f, 0.02113276f, 0.02927949f, 
    0.00663959f, 0.03520819f, 0.00451521f, 0.04212839f, 0.01466527f, 0.07195928f, -0.05772128f, 0.06686576f, 
    -0.04054568f, 0.18560615f, -0.07065617f, 0.10102635f, 0.09445669f, -0.00377534f, 0.04750613f, 0.04238046f, 
    -0.02619999f, -0.07716388f, 0.10196935f, 0.11069250f, 0.00912654f, -0.01823111f, 0.02987100f, 0.09021179f, 
    -0.07227715f, 0.02508319f, 0.05670891f, 0.05952020f, -0.27156493f, 0.12553422f, 0.01065620f, 0.08898532f, 
    0.08997357f, 0.04388741f, 0.11286180f, 0.13354486f, 0.00041867f, -0.05504334f, -0.04899844f, 0.05069047f, 
    -0.02111394f, 0.04355311f, -0.03901536f, 0.07781407f, 0.00089374f, 0.05175037f, 0.07520692f, -0.04251647f, 
    -0.13192265f, 0.10709190f, -0.09097243f, -0.01592684f, -0.08020007f, -0.10858779f, 0.06006152f, 0.04528306f, 
    -0.02056180f, -0.03187032f, 0.05044463f, 0.02102282f, -0.05865161f, -0.06483427f, 0.11472402f, -0.04210886f, 
    -0.07026538f, -0.12110361f, 0.03469577f, 0.02911360f, 0.09798344f, -0.14797744f, 0.01177069f, 0.10520880f, 
    -0.07443100f, -0.00150100f, 0.01397757f, 0.02549947f, 0.10865102f, -0.04781654f, 0.02463176f, 0.06333605f, 
    0.00807553f, 0.06639288f, -0.00731882f, 0.01779660f, -0.04486089f, 0.03633931f, -0.11299963f, -0.06389537f, 
    -0.41679040f, 0.14778990f, 0.05589385f, 0.00336617f, 0.15586320f, 0.07792759f, -0.08885086f, -0.06642614f, 
    0.05413155f, -0.00070579f, -0.08384788f, 0.07064456f, -0.00583962f, 0.05208237f, 0.09348975f, 0.05354154f, 
    0.01690969f, -0.03076634f, 0.06801867f, -0.05013045f, 0.20670269f, -0.25915208f, -0.00080284f, -0.10849782f, 
    -0.07342672f, 0.04733698f, -0.00638313f, -0.07601559f, -0.04442318f, 0.03770041f, 0.00366303f, 0.00857922f, 
    -0.00121984f, 0.03118785f, 0.03400396f, -0.04431920f, 0.04414549f, 0.04459911f, -0.02425104f, -0.00174888f, 
    0.31232944f, -0.04056876f, 0.00800941f, -0.13898411f, -0.10444833f, -0.01928836f, 0.04840190f, -0.10998417f, 
    -0.00949871f, -0.03505191f, 0.08438026f, -0.00884726f, -0.01082648f, -0.02677415f, 0.07363659f, 0.01817625f, 
    0.07037430f, 0.02337627f, 0.01484366f, 0.02636611f, -0.02023072f, -0.07847416f, -0.10738297f, -0.01272915f, 
    -0.08636160f, 0.00732932f, -0.06274457f, -0.04458842f, -0.03236900f, -0.04543805f, 0.09415904f, 0.07095379f, 
    -0.06803872f, 0.07010029f, -0.06415044f, 0.03830517f, 0.03729415f, -0.04789295f, -0.00126018f, -0.06284021f, 
    0.02269030f, 0.10817596f, -0.05202433f, 0.05392630f, 0.04574667f, 0.09069955f, 0.07824539f, -0.03737633f, 
    0.01848120f, -0.00691635f, -0.03426920f, 0.09516536f, -0.03533152f, -0.03262566f, -0.04292515f, -0.06807075f, 
    0.04654762f, 0.01599392f, -0.01068933f, 0.02243019f, -0.06963824f, 0.42360166f, -0.04269849f, 0.20066273f, 
    0.00278958f, 0.09948359f, 0.03011665f, -0.01874073f, -0.00194714f, -0.03598466f, 0.00742667f, 0.14883693f, 
    -0.00248558f, 0.02461617f, 0.01264519f, -0.08940390f, 0.04998787f, 0.01207715f, 0.00557290f, 0.06720967f, 
    -0.15028375f, 0.10481390f, 0.00812136f, 0.12459618f, -0.01968006f, 0.13353455f, 0.06437490f, 0.00262555f, 
    -0.01936508f, 0.04871952f, -0.05940688f, -0.03814375f, -0.01658826f, 0.00584634f, -0.07123031f, -0.00726456f, 
    -0.08812801f, -0.14856233f, -0.06070946f, -0.00665578f, -0.08828150f, -0.01834336f, 0.00954970f, 0.03716130f, 
    0.19559897f, -0.08336262f, 0.03431138f, 0.00249007f, 0.07715734f, 0.02675466f, 0.07095136f, 0.00871106f, 
    0.00549402f, 0.01145562f, -0.00065327f, 0.03766415f, 0.01976493f, 0.05926328f, 0.05430360f, 0.10630995f, 
    0.05202237f, 0.03123693f, -0.05992878f, -0.00363401f, 0.03763030f, 0.08530427f, 0.03392081f, 0.03311452f, 
    0.03697478f, -0.15021923f, 0.04649337f, -0.00313165f, -0.01559942f, 0.00360433f, 0.07180489f, -0.01198619f, 
    -0.05370476f, 0.06168791f, 0.00368439f, -0.06178541f, -0.34171158f, 0.22912836f, -0.01219445f, 0.10911441f, 
    -0.12367295f, 0.16781898f, 0.16878630f, 0.00583015f, 0.02202397f, -0.03591160f, 0.12875776f, 0.07818578f, 
    0.05787974f, -0.06828073f, 0.19808748f, 0.05250830f, 0.06162566f, -0.04663080f, -0.10090712f, 0.02052834f, 
    -0.18715297f, -0.19287950f, 0.01934510f, -0.07134953f, -0.01605693f, 0.06478899f, -0.01229171f, 0.12349542f, 
    -0.03494938f, -0.03293750f, -0.06210304f, 0.05791961f, 0.09003300f, -0.04092655f, -0.06473263f, -0.04742519f, 
    -0.03362251f, -0.03927129f, -0.02073325f, -0.01093230f, -0.11755219f, 0.04968605f, 0.03421453f, -0.00454982f, 
    0.20629072f, 0.06044518f, -0.00983587f, 0.08286200f, 0.01734383f, 0.06930951f, 0.01784399f, 0.08595439f, 
    0.13121457f, 0.06754699f, 0.03971539f, 0.04055560f, 0.01124062f, 0.03201268f, 0.11851949f, 0.07068064f, 
    0.06030387f, 0.22519161f, -0.19284362f, 0.10500009f, 0.24974310f, 0.04217149f, -0.05466191f, 0.04104845f, 
    -0.04176602f, 0.02585284f, 0.05906317f, -0.05483300f, -0.01316328f, -0.10059321f, -0.03186096f, 0.00308396f, 
    0.00454999f, 0.06330967f, 0.03714215f, 0.10589066f, -0.21832569f, 0.20098259f, -0.11821668f, 0.02367871f, 
    0.20172937f, 0.00588677f, 0.07571550f, 0.00083605f, -0.03045425f, 0.01386107f, -0.04698515f, 0.08510947f, 
    -0.01147078f, -0.03598388f, -0.02722923f, 0.13999112f, -0.01601157f, 0.01218038f, 0.03196570f, -0.03005626f, 
    0.10819633f, 0.15309960f, -0.00626417f, 0.03972151f, 0.05724454f, -0.01208736f, 0.03263242f, 0.11803620f, 
    0.04065819f, -0.02273271f, 0.02500610f, 0.06824198f, -0.14899543f, 0.00563040f, 0.07631665f, -0.15719327f, 
    -0.05438953f, 0.07496137f, -0.03979212f, -0.00578639f, 0.09317945f, -0.08659019f, -0.02401871f, 0.19705586f, 
    0.03561877f, 0.01052711f, -0.01877016f, 0.01173655f, 0.05252347f, 0.02578883f, -0.05598548f, 0.14362779f, 
    -0.07909756f, 0.04036452f, 0.03960727f, -0.02078386f, 0.01021706f, 0.12422863f, -0.16054319f, 0.02615830f, 
    -0.23465925f, 0.11049366f, 0.06037604f, 0.05846982f, 0.17993490f, 0.12497399f, 0.05564051f, 0.05197162f, 
    0.07787025f, 0.01494662f, -0.02107041f, -0.08778832f, 0.04741829f, -0.03571186f, 0.01656564f, 0.08821930f, 
    0.05518609f, -0.04398960f, 0.06731454f, 0.02496327f, -0.26245943f, -0.18331163f, 0.20876950f, -0.01371094f, 
    -0.30000746f, 0.05569506f, 0.04969067f, -0.03649874f, -0.00249019f, -0.00619942f, -0.00897315f, -0.00841928f, 
    0.00462781f, 0.19792521f, 0.08801664f, 0.02333162f, -0.07347988f, 0.04730161f, 0.06192436f, 0.04504148f, 
    0.07301564f, 0.04756097f, 0.12163024f, 0.00652452f, -0.22238764f, 0.05713709f, -0.03222518f, 0.02222668f, 
    0.04095895f, 0.07144696f, 0.00466797f, -0.02883366f, -0.06354412f, 0.03218891f, 0.05516337f, 0.04786585f, 
    0.02529386f, -0.04824804f, 0.00946812f, 0.04127711f, -0.06326692f, -0.14931005f, -0.10468181f, -0.01469747f, 
    -0.22664781f, 0.04651958f, 0.00427302f, -0.04516891f, -0.00136811f, 0.05366950f, 0.06814451f, -0.01259766f, 
    -0.03494875f, 0.06891359f, -0.04418141f, -0.00773811f, 0.01961613f, 0.06796455f, 0.02043486f, 0.00496987f, 
    -0.08200139f, 0.05607518f, -0.00816429f, 0.09753075f, -0.00029780f, 0.13029602f, 0.16157611f, 0.09842483f, 
    0.10622605f, 0.05157197f, 0.01632405f, -0.02049474f, 0.01321416f, -0.04039686f, -0.00678041f, 0.05889604f, 
    0.06673723f, -0.01894968f, 0.03662741f, 0.01524510f, -0.08601325f, 0.12771343f, -0.02878804f, 0.11403657f, 
    0.23119973f, 0.04710671f, 0.12005492f, -0.01976453f, 0.08092164f, 0.03007121f, 0.00798570f, -0.08814303f, 
    0.03843295f, 0.01755896f, -0.01222975f, -0.05669497f, 0.06654587f, 0.00393564f, 0.06118285f, 0.01952145f, 
    -0.07142921f, 0.06803444f, -0.16718900f, -0.02365263f, 0.09629542f, 0.01247433f, -0.02942855f, -0.01318385f, 
    0.01570469f, -0.02185605f, -0.09056177f, -0.05191031f, 0.06057549f, -0.05104944f, -0.06784330f, -0.03633433f, 
    -0.04840828f, 0.00986000f, -0.02548044f, 0.07781112f, 0.17615227f, 0.16073161f, 0.03411726f, 0.09490423f, 
    0.24225551f, 0.00194697f, -0.00983924f, 0.02541614f, -0.01616370f, 0.09698346f, 0.04419877f, -0.05690164f, 
    0.01592267f, 0.00232610f, 0.02476336f, 0.10375638f, 0.08537155f, 0.06116378f, -0.01765759f, 0.01957797f, 
    -0.13363697f, -0.16015533f, -0.17176262f, -0.12359731f, 0.02817467f, 0.02726196f, -0.00472432f, 0.02923373f, 
    0.03355239f, 0.00435479f, 0.00125784f, 0.07929341f, -0.00126090f, -0.05714278f, -0.00054553f, -0.02979089f, 
    -0.06774841f, 0.07101286f, -0.03080032f, 0.01791994f, -0.56946439f, 0.00254976f, -0.13634415f, 0.08190460f, 
    -0.15635380f, 0.05046556f, 0.10722200f, 0.05828993f, -0.01307305f, 0.01434988f, 0.08011029f, 0.01678697f, 
    0.03840722f, -0.02419940f, 0.12564836f, 0.04794344f, 0.01411872f, 0.01676561f, -0.01776895f, 0.05625138f, 
    -0.15394020f, -0.33169630f, -0.13750727f, -0.11312173f, -0.12866370f, 0.07778980f, 0.05442715f, 0.00857358f, 
    -0.04961426f, -0.03974620f, -0.08583055f, 0.01013526f, 0.08905461f, -0.07984497f, -0.06348882f, -0.04672462f, 
    0.01519039f, 0.11443114f, -0.00676929f, -0.05493656f, 0.05605802f, 0.05734583f, -0.00474266f, -0.03891210f, 
    0.25841236f, 0.05557028f, -0.05729167f, 0.01127710f, -0.03682210f, -0.00724825f, 0.02791895f, -0.00633007f, 
    0.10204256f, -0.01500595f, -0.01596458f, 0.04171058f, 0.12305917f, 0.05130629f, 0.02258127f, 0.10884631f, 
    0.06054008f, -0.02714399f, -0.14465815f, 0.09248791f, -0.05800580f, 0.09650888f, 0.10719944f, 0.07289945f, 
    0.13358122f, -0.00111130f, 0.05397422f, 0.05948606f, 0.15934028f, 0.05417916f, 0.02772163f, 0.03163924f, 
    0.01691980f, 0.02842664f, 0.05620442f, 0.03168445f, -0.06746466f, -0.16011986f, -0.16881670f, -0.12924476f, 
    -0.09531268f, -0.07761891f, -0.02281539f, -0.02457900f, -0.02053658f, 0.06035658f, -0.00289381f, 0.00656522f, 
    0.08449825f, -0.00616845f, 0.10847162f, 0.09797803f, -0.02108801f, -0.00755900f, 0.03596686f, -0.02126501f, 
    -0.14118059f, 0.24170692f, 0.01636310f, 0.00232301f, 0.15347317f, 0.05888766f, -0.10963328f, 0.01320726f, 
    0.10613360f, 0.00499798f, 0.05781025f, 0.13297813f, -0.05682121f, 0.04427195f, 0.15393251f, -0.03890905f, 
    -0.07344346f, 0.13157408f, -0.05655856f, -0.01581814f, -0.21051882f, 0.16513750f, -0.18549216f, 0.07392449f, 
    0.15601106f, -0.09936026f, 0.10912727f, -0.03870170f, 0.22444850f, -0.03244536f, 0.01468724f, 0.01328481f, 
    -0.04664411f, 0.02807248f, 0.02345778f, -0.05968606f, 0.02575233f, 0.00215805f, -0.03035734f, -0.01079711f, 
    -0.46462318f, 0.22705753f, -0.11298653f, 0.17275833f, 0.03924409f, 0.16513872f, -0.04710386f, -0.07145803f, 
    0.12203898f, 0.04448028f, 0.01624722f, 0.06011325f, 0.01865887f, -0.08379916f, 0.08712091f, 0.10206641f, 
    0.00359651f, 0.04140282f, 0.05319907f, -0.05437797f, -0.30754936f, 0.23589520f, 0.10617102f, 0.07087701f, 
    -0.01980366f, -0.00527697f, 0.07307085f, 0.00791102f, -0.02979922f, 0.07021431f, 0.10032710f, 0.04742056f, 
    0.10918137f, 0.05530737f, 0.11042634f, 0.08365761f, 0.08635433f, 0.06192809f, -0.02336104f, 0.15996507f, 
    0.15783498f, 0.11241672f, 0.16774431f, 0.21302348f, -0.02935351f, 0.01997858f, 0.19799656f, -0.00600614f, 
    -0.00911702f, 0.05910464f, 0.03948677f, -0.05225866f, 0.06282908f, 0.13365451f, 0.14948557f, 0.03914507f, 
    0.06646504f, 0.09110961f, -0.03832938f, 0.07163852f, -0.13592477f, 0.17490251f, -0.15907319f, -0.09165552f, 
    -0.13296877f, 0.17743307f, 0.05929176f, -0.04484583f, 0.04659544f, 0.11619938f, 0.02529546f, -0.06378591f, 
    -0.03919338f, 0.00623889f, 0.02639307f, -0.06702191f, 0.01838279f, 0.00368743f, -0.01853677f, 0.13459551f, 
    -0.04140272f, -0.06737325f, -0.03932342f, 0.00271652f, -0.02586544f, 0.13190831f, 0.12428072f, 0.05794485f, 
    0.03915829f, 0.04802826f, 0.11524915f, -0.01305569f, 0.00505567f, 0.01757960f, 0.05405937f, 0.04190629f, 
    0.13336374f, -0.08439420f, 0.11399551f, 0.11155304f, -0.11673456f, -0.11481875f, -0.20950967f, 0.09617155f, 
    -0.10454373f, -0.01907801f, -0.09720779f, 0.12739660f, -0.05548623f, 0.00930521f, 0.07279904f, 0.07816339f, 
    -0.01465880f, 0.00188735f, 0.03110656f, -0.02936461f, 0.06220663f, -0.07767840f, 0.05051228f, 0.03047402f, 
    -0.04799049f, -0.05238625f, -0.07690772f, 0.01088732f, -0.09194022f, 0.00898809f, -0.08993017f, 0.13369347f, 
    -0.01732911f, -0.03471417f, -0.06148743f, -0.04482747f, 0.04198928f, 0.01724458f, 0.09946813f, 0.08249163f, 
    0.01425976f, 0.07148815f, 0.07115942f, 0.08035572f, 0.11251320f, 0.13699417f, 0.14646085f, 0.24143429f, 
    0.05314935f, -0.05170939f, 0.09034728f, 0.05416556f, 0.10395978f, 0.08548431f, 0.11180311f, 0.00219966f, 
    0.02800707f, 0.16772602f, 0.14345345f, -0.01088914f, 0.02335265f, -0.07065988f, -0.03767926f, 0.06890340f, 
    -0.27561873f, -0.05251187f, -0.21806839f, -0.17320089f, 0.08353864f, 0.14272034f, 0.11797347f, 0.06262667f, 
    0.08540317f, 0.05674158f, 0.09821174f, 0.10749586f, -0.01879669f, 0.00049549f, 0.02841847f, 0.14085101f, 
    -0.00749072f, 0.02014520f, 0.00423616f, 0.06922625f, 0.01472677f, -0.22792497f, -0.09248842f, -0.15732059f, 
    -0.16888283f, 0.12653030f, 0.04945378f, 0.03007170f, -0.13974300f, 0.11117401f, 0.01561446f, 0.06470146f, 
    0.01275927f, -0.05242155f, 0.15704755f, 0.06585755f, 0.02955359f, 0.10177345f, -0.01286637f, -0.01995290f, 
    -0.09926306f, 0.01088759f, -0.01135212f, -0.09293690f, -0.00951822f, -0.01567550f, -0.03499238f, 0.11084815f, 
    0.14273712f, 0.11049160f, 0.00718306f, -0.03670778f, 0.08098166f, 0.01201327f, -0.02412603f, -0.00936977f, 
    -0.04837479f, 0.07894600f, 0.00962365f, -0.03744389f, -0.13974662f, 0.11981820f, -0.07866296f, -0.04806368f, 
    0.06476556f, 0.07301736f, -0.01452676f, 0.07646380f, 0.05321874f, 0.09933612f, 0.00930993f, -0.04019363f, 
    -0.01150463f, 0.07232749f, 0.05843803f, -0.02058128f, 0.07600734f, 0.03425273f, 0.08541125f, 0.05716993f, 
    0.04051334f, -0.04453274f, -0.00240815f, 0.06305279f, 0.02147484f, 0.05065125f, 0.02035140f, -0.06572492f, 
    -0.03518137f, -0.02544502f, 0.06196124f, 0.03985080f, 0.01135210f, -0.00881216f, 0.07798590f, -0.05044942f, 
    0.09157783f, 0.13911943f, 0.09431455f, 0.15075602f, 0.12100653f, 0.03614604f, 0.14115137f, -0.07687491f, 
    0.09113441f, -0.04218289f, -0.00924982f, -0.01061175f, 0.19861452f, 0.01896344f, -0.00922463f, -0.05573195f, 
    -0.06315508f, 0.12615235f, 0.01766232f, 0.00411037f, 0.07257555f, 0.19533098f, 0.04360784f, 0.05298695f, 
    -0.11514082f, 0.02285185f, 0.02387763f, -0.03147948f, -0.14170331f, -0.05717778f, 0.05822089f, -0.00105076f, 
    -0.07433007f, -0.06413804f, -0.04849841f, 0.03184282f, 0.10027400f, -0.12512179f, -0.02838581f, 0.07196803f, 
    0.01287586f, -0.10449935f, 0.13474517f, -0.03104885f, 0.23802125f, 0.22048117f, -0.01269845f, 0.01726196f, 
    -0.02450014f, -0.06200962f, -0.02181688f, -0.03084115f, 0.12840973f, -0.04724906f, -0.00501265f, -0.02568048f, 
    -0.09988761f, 0.00926123f, -0.01044739f, -0.00351995f, -0.09338708f, -0.04956612f, 0.02904352f, 0.08525789f, 
    0.06696189f, 0.01494559f, -0.02837500f, -0.11318792f, -0.00969973f, 0.00804225f, -0.09774806f, 0.01379646f, 
    0.06238569f, 0.00852577f, -0.12578462f, 0.03298479f, -0.09399585f, -0.04261052f, 0.10321426f, 0.05463876f, 
    0.08816750f, 0.00712000f, 0.10477784f, -0.10651485f, 0.12481059f, 0.09229162f, -0.18943422f, -0.19402264f, 
    0.11794382f, -0.04892831f, 0.00298190f, -0.16299488f, -0.11322694f, -0.01399445f, 0.00356898f, -0.01325219f, 
    -0.03197268f, -0.16571745f, 0.07971102f, 0.04889812f, -0.02017009f, -0.05330904f, -0.12396426f, -0.15238093f, 
    0.20381936f, -0.03997019f, -0.05042768f, 0.09318985f, 0.18181680f, -0.04243974f, 0.10561433f, -0.16802156f, 
    -0.05803411f, -0.06824006f, 0.08829241f, 0.11519565f, -0.05793727f, -0.03211835f, 0.02852708f, 0.04654824f, 
    0.02186741f, 0.10707637f, 0.02313635f, 0.01837730f, 0.15692531f, -0.08834904f, 0.02858153f, -0.17783649f, 
    -0.00079755f, -0.06606564f, -0.10409672f, -0.12708040f, 0.02011538f, -0.02030645f, -0.00002866f, 0.02799260f, 
    -0.03562521f, 0.00435091f, -0.02502146f, 0.04404278f, 0.02247411f, -0.06225440f, -0.22291280f, -0.05226074f, 
    0.08596274f, 0.04984810f, -0.02872685f, -0.18449509f, -0.03342685f, -0.03311541f, -0.13976961f, -0.01003567f, 
    0.04170011f, -0.02128289f, 0.00453878f, 0.09327116f, -0.09640788f, 0.01454812f, -0.11586542f, -0.00772039f, 
    -0.16976298f, 0.02620343f, -0.22214727f, -0.11359420f, 0.27409303f, 0.36543638f, -0.20025559f, 0.13726744f, 
    -0.02036042f, 0.12864891f, -0.06568649f, 0.02911696f, -0.08874443f, -0.03992062f, -0.08138978f, 0.08443013f, 
    -0.12725528f, 0.00491156f, 0.17519768f, -0.01668574f, 0.11545864f, 0.12083114f, 0.00159781f, 0.04578385f, 
    -0.18206565f, 0.05278398f, 0.25181535f, -0.01899681f, 0.03986408f, 0.01757316f, -0.05002513f, 0.05033857f, 
    -0.04849628f, 0.11210904f, -0.05368442f, -0.00345873f, 0.03739154f, 0.04829484f, 0.00286837f, 0.01351690f, 
    -0.05003197f, 0.10471375f, -0.03157091f, -0.07004920f, -0.08600188f, -0.04349187f, -0.07966425f, 0.10643356f, 
    0.10341230f, -0.04246555f, 0.02937886f, -0.04713675f, -0.00012884f, 0.03132505f, -0.05807561f, 0.00740218f, 
    -0.09621102f, -0.06388172f, -0.06379747f, 0.01614675f, -0.00250412f, 0.04073931f, 0.16283630f, 0.03901743f, 
    0.11982445f, 0.13157053f, -0.07630288f, -0.06530200f, -0.00834205f, -0.00206846f, 0.09085000f, -0.11136813f, 
    0.09642000f, 0.07751970f, 0.00068668f, -0.07102901f, 0.09851267f, 0.00438493f, 0.07386456f, 0.02027346f, 
    -0.06795368f, 0.01257749f, -0.07029381f, -0.01473794f, 0.17770368f, 0.01538830f, -0.03568708f, -0.13762465f, 
    0.08589111f, 0.09342112f, -0.00151287f, 0.05962391f, 0.03735983f, -0.02490035f, -0.03633713f, 0.12257143f, 
    0.05664093f, 0.07579928f, 0.08223763f, 0.12199935f, -0.06319056f, -0.12349573f, -0.35764506f, 0.03263634f, 
    0.14256917f, 0.01655532f, 0.09034345f, -0.25504640f, -0.02636489f, 0.09942245f, -0.07226474f, 0.11248736f, 
    0.12131280f, 0.10095742f, -0.00524213f, -0.08963208f, 0.03219130f, 0.22459181f, -0.02315278f, 0.00640069f, 
    0.07190540f, -0.14334236f, -0.04638286f, -0.06529560f, -0.02774540f, 0.01251107f, 0.05579067f, 0.12255237f, 
    0.08434627f, -0.03549736f, -0.01395698f, -0.04567210f, 0.00371934f, -0.00102072f, 0.00999254f, 0.11619896f, 
    0.08228839f, 0.09897581f, -0.03858174f, 0.06867238f, 0.02844403f, -0.03902935f, 0.15362681f, 0.05076040f, 
    -0.00747235f, 0.03261642f, -0.01083480f, -0.04065705f, 0.02422548f, 0.05572733f, 0.01235066f, -0.00375246f, 
    -0.05005083f, -0.04448848f, 0.00525146f, -0.00814145f, -0.01746555f, -0.03744781f, 0.00595167f, 0.04145345f, 
    -0.02283868f, -0.03820331f, -0.04525197f, -0.05604146f, 0.00202712f, 0.00071438f, 0.00889853f, 0.04331372f, 
    0.02604353f, -0.02263728f, 0.02949842f, 0.01618436f, 0.03703054f, -0.04692058f, -0.02972501f, -0.04868897f, 
    0.02159641f, -0.02616743f, 0.00544994f, 0.02845246f, 0.04091409f, 0.03168396f, 0.03463962f, 0.01909629f, 
    0.03995992f, 0.00486241f, -0.03603235f, 0.03398061f, -0.05543193f, -0.05889992f, -0.03534599f, 0.01742986f, 
    0.00650095f, -0.04913135f, -0.02588812f, 0.02692435f, 0.00571028f, 0.00941297f, -0.00615700f, -0.00963022f, 
    -0.01897913f, -0.01653315f, -0.02830640f, -0.04408920f, -0.05335013f, -0.03648089f, 0.02803448f, 0.04329347f, 
    -0.02069384f, 0.00505899f, 0.01457585f, -0.02822401f, 0.00004297f, 0.02303457f, 0.01794717f, -0.02198395f, 
    0.02858811f, 0.01771865f, -0.03131988f, -0.00037611f, 0.04991295f, -0.05299228f, -0.00784712f, -0.03559199f, 
    -0.00462992f, -0.04668475f, -0.03170614f, -0.01999500f, 0.05261440f, 0.02319492f, 0.03898344f, 0.02268333f, 
    -0.04302418f, -0.05558063f, -0.01800949f, 0.01645283f, 0.03422884f, -0.00934007f, -0.01578373f, -0.01297183f, 
    -0.01163532f, -0.00059973f, 0.01542892f, -0.00114586f, -0.00997165f, -0.03264287f, -0.05358659f, 0.02349118f, 
    -0.03673498f, 0.01131760f, 0.03323527f, 0.01404644f, -0.01221461f, 0.00267230f, -0.03834560f, 0.02258188f, 
    -0.02786610f, 0.02630571f, -0.00325168f, -0.02361919f, 0.04817988f, 0.00143935f, 0.02599065f, -0.01752032f, 
    -0.03073392f, -0.04819653f, 0.02265288f, -0.01801951f, 0.00971927f, -0.04967150f, -0.02288973f, -0.03961173f, 
    -0.05590634f, 0.01978759f, -0.00696220f, -0.01156420f, 0.03540179f, -0.01746249f, -0.02586586f, -0.02452942f, 
    -0.02317939f, -0.05994118f, 0.00423355f, -0.00137504f, 0.01149932f, -0.04532534f, -0.05637684f, 0.02279856f, 
    -0.02585196f, -0.04110691f, -0.02821059f, 0.02316655f, -0.02703121f, 0.04059616f, -0.02646973f, 0.04586345f, 
    0.00567532f, 0.04923469f, 0.00362951f, -0.00974939f, 0.02033884f, -0.02674283f, -0.03515562f, 0.04208105f, 
    0.04893183f, -0.05128939f, -0.05610911f, -0.04433399f, 0.02728002f, -0.04202319f, -0.05375926f, -0.00225512f, 
    -0.00585736f, 0.03704792f, -0.00592064f, -0.04347494f, -0.03693909f, 0.00582717f, 0.01489579f, -0.03041009f, 
    0.03727312f, 0.00106080f, -0.02485861f, -0.05040969f, -0.04976255f, 0.01547296f, -0.00130333f, -0.02800606f, 
    0.01758529f, -0.02382593f, 0.01638108f, -0.00672796f, -0.01147761f, -0.04103082f, 0.01932175f, 0.02706129f, 
    -0.03546213f, -0.05599649f, -0.00628894f, 0.00975810f, -0.04007573f, 0.03314858f, -0.03035337f, -0.00988401f, 
    -0.03632887f, 0.00744709f, 0.04293200f, 0.03335451f, -0.01048928f, -0.01205746f, 0.04367626f, -0.00485329f, 
    -0.00717569f, 0.01532234f, 0.03515505f, -0.01187786f, -0.06009001f, 0.04234088f, -0.04202107f, 0.00936999f, 
    0.01006073f, -0.04723294f, 0.04057110f, -0.04559941f, -0.05210219f, -0.01602479f, -0.05203845f, 0.01637713f, 
    -0.01109640f, 0.00643932f, -0.05574242f, -0.04769025f, -0.03893326f, -0.05667979f, 0.04773292f, -0.00362462f, 
    -0.02277677f, -0.05549537f, -0.00670947f, 0.04474774f, -0.01970146f, 0.03154333f, 0.00695441f, -0.01296188f, 
    0.03646761f, -0.03857528f, 0.03389974f, -0.01931197f, 0.04321838f, 0.03271634f, -0.05749499f, 0.02465235f, 
    -0.03687645f, -0.01260841f, -0.04174456f, 0.00355394f, -0.01433260f, 0.00512583f, -0.05713626f, -0.05173432f, 
    -0.02185454f, -0.05504080f, -0.03294582f, -0.05625666f, 0.05234779f, 0.04972572f, -0.04415059f, 0.03879555f, 
    0.04621198f, 0.04610462f, -0.00177280f, -0.02313735f, 0.00242923f, -0.00833779f, -0.00497479f, -0.03994519f, 
    -0.03413201f, 0.01026531f, 0.03025308f, 0.00749687f, -0.05815734f, 0.00726218f, -0.06077502f, 0.04006113f, 
    0.00384344f, 0.01216020f, 0.01415614f, 0.00222673f, 0.04197277f, 0.04519026f, -0.03334702f, -0.04342207f, 
    0.01005273f, 0.00244648f, -0.02987774f, 0.03063819f, -0.02535823f, 0.01092978f, 0.01009394f, -0.03186310f, 
    -0.04732218f, -0.05513081f, 0.02783388f, -0.02350441f, 0.04427041f, 0.02934751f, 0.03052054f, -0.04255913f, 
    0.01701804f, -0.01075096f, -0.05119888f, 0.03148840f, 0.04707830f, 0.02055442f, -0.01212501f, 0.04395847f, 
    -0.04253042f, 0.02772156f, -0.01419912f, -0.03200449f, -0.01782315f, 0.02671418f, -0.05246930f, 0.00272240f, 
    0.04160335f, 0.02287813f, 0.15459439f, -0.08494552f, -0.13259029f, -0.07423280f, -0.06098652f, -0.01010418f, 
    -0.05355160f, -0.06975949f, 0.02827546f, -0.02203670f, -0.10970868f, -0.09616655f, 0.03129277f, -0.02484420f, 
    -0.06166700f, 0.06375366f, 0.01602440f, 0.07085610f, 0.15020819f, 0.06144076f, 0.19206741f, 0.22037765f, 
    0.19632806f, -0.03441788f, -0.02661732f, 0.02115147f, 0.11605008f, -0.04458179f, -0.02026326f, -0.14747785f, 
    -0.03369419f, 0.12378065f, -0.07910886f, -0.04774079f, -0.13481015f, 0.05365637f, 0.08328316f, 0.03537903f, 
    0.15764329f, -0.05906306f, 0.10535135f, 0.01919306f, -0.21118273f, -0.01212638f, 0.04447889f, 0.16080296f, 
    -0.07347196f, -0.02066978f, 0.00125067f, 0.00287349f, 0.14059940f, 0.02969924f, 0.02569152f, -0.02682110f, 
    0.06559497f, -0.21394283f, 0.09987618f, -0.04998376f, 0.23491396f, 0.05846309f, 0.11778270f, 0.03203063f, 
    -0.02189654f, 0.06323957f, -0.15644901f, 0.06393482f, -0.06927443f, -0.07795338f, 0.00791814f, 0.05769904f, 
    -0.02711244f, -0.01791587f, 0.02703083f, 0.11894800f, -0.00107985f, 0.01669906f, 0.03763489f, -0.01954585f, 
    0.41155243f, 0.10366556f, 0.07491965f, -0.11705404f, -0.01261423f, -0.09581375f, 0.09848448f, 0.14761735f, 
    0.02463531f, -0.00238526f, -0.02921134f, 0.01704768f, -0.01985247f, 0.10461942f, -0.03139960f, 0.01566725f, 
    0.07458006f, 0.01783664f, 0.02108424f, 0.05484768f, -0.09970467f, -0.14474586f, -0.18568963f, -0.13298649f, 
    0.02069430f, 0.10927100f, 0.03410335f, -0.03719585f, -0.06952464f, -0.06385696f, -0.01104812f, 0.01526114f, 
    -0.01445274f, -0.08475719f, -0.01125731f, 0.02179616f, 0.06346428f, -0.04748571f, -0.07517586f, -0.00573376f, 
    -0.00947692f, -0.05356987f, 0.00197515f, -0.19154198f, 0.00230041f, 0.09229373f, 0.05633881f, -0.07591657f, 
    -0.03991441f, -0.04984625f, 0.10320228f, 0.08933148f, -0.03878821f, -0.10049454f, -0.08402566f, 0.04099687f, 
    0.04573693f, 0.07696331f, -0.03139094f, -0.03946465f, 0.15984255f, -0.09481490f, 0.02800861f, -0.03824262f, 
    0.10130965f, -0.02712895f, -0.02762173f, -0.05686054f, 0.00467586f, -0.02633888f, 0.02718204f, 0.00952825f, 
    -0.01936298f, 0.11669271f, -0.00454711f, -0.00684783f, -0.02241517f, 0.00937669f, -0.01602551f, -0.03447768f, 
    0.02580745f, 0.05238665f, -0.04006149f, -0.05117705f, -0.07936290f, -0.02989342f, 0.02138404f, 0.02764750f, 
    0.01834039f, -0.00133447f, -0.04536848f, 0.14801195f, -0.02415971f, 0.09778391f, -0.01523155f, 0.00217279f, 
    -0.06605043f, 0.18539926f, -0.01059341f, -0.02158032f, -0.17159778f, 0.19960237f, -0.07591519f, 0.06461430f, 
    0.11331359f, 0.13147107f, 0.04210881f, -0.04073609f, 0.04186239f, -0.02331312f, -0.03870372f, 0.03211594f, 
    -0.06632856f, 0.05264198f, 0.12951969f, 0.09503740f, 0.02682193f, 0.11476659f, 0.07617480f, 0.01939079f, 
    0.14563665f, 0.00525007f, 0.35260931f, 0.16857302f, 0.07118948f, 0.00311481f, 0.02891522f, 0.07907684f, 
    0.05293209f, 0.10509063f, -0.01607969f, -0.02008731f, -0.00253925f, 0.07502028f, 0.00699298f, -0.09594762f, 
    -0.06935663f, 0.01859752f, -0.03049099f, -0.03466348f, 0.15960686f, 0.17536230f, -0.03692520f, -0.01794614f, 
    0.01269544f, 0.00586872f, 0.03453302f, 0.06505027f, 0.00066781f, 0.03689900f, 0.05639599f, 0.02776649f, 
    -0.08799962f, -0.08949693f, -0.09692952f, 0.08236289f, 0.05110523f, 0.09549272f, 0.17273840f, 0.06887002f, 
    0.16389056f, 0.02022881f, 0.23518814f, 0.06972495f, 0.08395108f, -0.10149309f, 0.01799506f, -0.09849766f, 
    0.05677193f, 0.01501903f, -0.05276747f, 0.00272470f, 0.05499228f, -0.00461193f, 0.02758148f, -0.04511997f, 
    -0.03084258f, 0.06819834f, 0.03346799f, 0.03595286f, -0.21973675f, -0.05427064f, -0.10508543f, -0.03479668f, 
    -0.00495356f, 0.05209689f, 0.03848242f, 0.06829890f, 0.02092619f, -0.05052320f, 0.01221309f, 0.07631440f, 
    0.05468440f, -0.08626200f, -0.01326211f, 0.07176749f, -0.04430588f, -0.07020318f, -0.03774271f, 0.01176525f, 
    0.28810379f, -0.01046146f, 0.01093224f, -0.09424102f, 0.01712004f, 0.02664461f, -0.05607073f, -0.07107715f, 
    0.10132280f, 0.10194491f, -0.09701779f, -0.04899395f, 0.00961546f, -0.00001325f, 0.00530051f, -0.05922677f, 
    0.05149848f, -0.07363212f, -0.02415972f, 0.00601234f, 0.07222059f, -0.01543330f, 0.20401037f, 0.08304842f, 
    0.15576640f, -0.07200329f, -0.02127149f, 0.06908379f, 0.00247531f, -0.01256905f, 0.09084421f, -0.05001502f, 
    -0.00974272f, -0.00778466f, -0.04039066f, 0.02352172f, 0.04691687f, 0.01995314f, 0.11043417f, 0.04463629f, 
    0.00350981f, 0.00066407f, 0.02179650f, 0.02513700f, 0.00071992f, 0.04390341f, -0.01503102f, -0.03820007f, 
    0.00190682f, -0.03955819f, -0.04226258f, -0.03727226f, 0.00460258f, -0.05706717f, 0.03783027f, 0.01864113f, 
    0.04560757f, -0.05586492f, -0.04095616f, -0.00076386f, 0.00901146f, -0.01661272f, -0.03372118f, 0.04781505f, 
    -0.03532005f, -0.02377269f, -0.03327977f, 0.00522941f, 0.05870302f, 0.00810049f, -0.03879512f, -0.01881698f, 
    -0.05674883f, 0.04046839f, -0.00705301f, -0.02228281f, -0.02201958f, 0.02250977f, -0.03993367f, 0.00204519f, 
    -0.04919455f, 0.04663661f, -0.00835495f, 0.06068334f, -0.00187943f, -0.03193823f, -0.04485043f, 0.00380848f, 
    0.01777132f, 0.00003627f, 0.04240198f, -0.01853651f, -0.02413811f, -0.00488669f, 0.01437365f, 0.03145980f, 
    0.01571723f, -0.01404346f, -0.01752086f, -0.00119394f, 0.00956399f, 0.04720461f, -0.01980097f, -0.02151527f, 
    -0.03928715f, -0.05681714f, -0.01346354f, 0.03896069f, 0.04269412f, 0.03538273f, 0.04126170f, 0.02239374f, 
    -0.00765672f, 0.01056052f, -0.04104325f, 0.03785872f, 0.00891008f, -0.04280350f, 0.02790343f, -0.04029109f, 
    0.00289982f, -0.03760882f, 0.00093318f, -0.04879108f, -0.02905322f, -0.01064983f, 0.03002959f, -0.03598670f, 
    0.02798072f, -0.02224515f, 0.00160483f, 0.01317794f, -0.04742375f, 0.03288477f, -0.03586718f, 0.00354806f, 
    0.01901792f, -0.01657193f, 0.03220915f, -0.03984098f, 0.02222396f, 0.00803386f, -0.03698533f, 0.04869236f, 
    0.00804889f, -0.05543691f, -0.03908672f, 0.01519795f, -0.00663737f, 0.03728684f, 0.03648318f, -0.02546353f, 
    0.01506352f, 0.01870829f, 0.03593639f, -0.05400214f, 0.04122091f, 0.01919319f, 0.01869655f, -0.04893580f, 
    -0.05806915f, 0.02382481f, 0.02819433f, -0.04528220f, 0.04596321f, 0.01365178f, -0.03198999f, 0.02746255f, 
    -0.01670514f, 0.04619345f, -0.05216400f, -0.01880765f, -0.05910324f, -0.05068752f, 0.02797449f, 0.00192620f, 
    0.01963759f, 0.01904318f, -0.02108738f, -0.05210210f, -0.01450517f, 0.04556829f, -0.01367665f, -0.00064249f, 
    -0.01935650f, 0.01869362f, 0.03489932f, 0.02093332f, -0.05734904f, -0.05587105f, -0.01781476f, -0.04777214f, 
    -0.04546090f, 0.03481253f, -0.05462872f, 0.02391179f, 0.00345769f, -0.04089084f, -0.04981613f, -0.00594860f, 
    -0.00909545f, 0.01649214f, -0.04713729f, -0.03943110f, -0.03033013f, 0.00314534f, 0.01847602f, 0.01115227f, 
    0.04487504f, 0.04518981f, -0.02374125f, -0.06171523f, -0.04848057f, -0.02482120f, 0.04211487f, -0.04401412f, 
    0.01269885f, -0.03240887f, -0.04671227f, 0.04183219f, -0.04771036f, -0.01254507f, -0.00493257f, 0.00067855f, 
    -0.01037973f, -0.06096127f, 0.04922723f, -0.04280744f, 0.04151624f, -0.04056184f, 0.00320602f, -0.02583602f, 
    -0.01283976f, -0.01691792f, -0.03643028f, 0.03094261f, 0.02020891f, 0.00210157f, -0.05215141f, -0.00162951f, 
    -0.01058249f, -0.03205798f, -0.04303556f, -0.00580991f, -0.01223451f, -0.05580672f, 0.01533110f, -0.04617471f, 
    -0.03611452f, 0.04548541f, -0.02935257f, -0.04733019f, 0.02811072f, -0.02546812f, -0.01042777f, 0.01635384f, 
    0.05303794f, 0.00689604f, 0.05391984f, -0.03716007f, 0.04576297f, -0.02161627f, 0.04942244f, -0.02228837f, 
    0.01594011f, 0.04499092f, -0.00334661f, 0.02001133f, 0.03183524f, 0.01533594f, 0.02758960f, -0.01399995f, 
    -0.00416906f, 0.03346794f, 0.03430064f, -0.00705847f, 0.00905941f, 0.02925035f, -0.02807957f, -0.03980291f, 
    0.02335439f, 0.03192762f, -0.00821697f, -0.05099147f, 0.02475104f, 0.03931622f, -0.01792563f, 0.02986082f, 
    -0.00950990f, 0.02264192f, -0.05315080f, 0.04888492f, -0.04481750f, 0.04233068f, -0.05687126f, -0.04853642f, 
    -0.00417019f, 0.04006116f, -0.03643700f, -0.03511444f, -0.04168044f, -0.01659248f, 0.01526529f, 0.03747787f, 
    -0.00259398f, 0.00190489f, 0.05280678f, 0.00691763f, 0.00104621f, 0.01751822f, -0.04065256f, -0.01812730f, 
    0.01131183f, -0.01346355f, -0.03685882f, 0.01681931f, -0.04470339f, -0.03051862f, -0.02311576f, -0.02053754f, 
    -0.04486974f, 0.04036838f, -0.05370903f, 0.03346276f, 0.02308011f, -0.00951238f, -0.04168824f, -0.05693720f, 
    0.02854171f, 0.00675300f, -0.04818795f, -0.00522614f, 0.00951840f, -0.01249394f, -0.03126637f, -0.05848878f, 
    -0.03737236f, -0.01913940f, -0.01196251f, -0.02316081f, -0.03729364f, -0.04828426f, 0.01222325f, -0.03721607f, 
    0.02971118f, -0.03214942f, -0.02117438f, -0.03706241f, -0.01066840f, 0.00884746f, -0.04046910f, -0.05439886f, 
    -0.05225023f, -0.02802646f, -0.06072663f, 0.02698302f, -0.00358514f, -0.00817652f, -0.01482363f, 0.03084748f, 
    -0.12132738f, -0.00520583f, -0.07385551f, 0.05267868f, 0.12222192f, 0.05961752f, 0.03269982f, -0.08235160f, 
    -0.03298100f, -0.11382399f, 0.21504782f, 0.17130619f, 0.02987905f, 0.05611656f, -0.04859698f, 0.00173649f, 
    0.02220905f, 0.11199944f, 0.03763371f, 0.12260000f, -0.30222049f, -0.17772517f, 0.09269550f, 0.02194502f, 
    0.00385122f, 0.05278802f, 0.14311218f, 0.00459212f, -0.11062410f, 0.05836460f, 0.03328663f, 0.11295871f, 
    -0.01532402f, 0.01432482f, -0.00428988f, 0.01114779f, 0.00914443f, -0.04034868f, 0.12235310f, -0.08421025f, 
    0.00570271f, 0.07631115f, -0.06617843f, -0.11778756f, 0.01493934f, -0.07960942f, -0.05787906f, 0.02839258f, 
    0.03619282f, -0.07661248f, 0.17947954f, 0.16285327f, -0.01615940f, -0.00797851f, 0.12908831f, -0.07355744f, 
    -0.13021271f, -0.11228782f, 0.00886493f, 0.00792998f, 0.10443252f, -0.06459923f, -0.07121485f, 0.11250491f, 
    -0.04145182f, -0.09503960f, 0.09174188f, -0.01618820f, 0.08305982f, 0.08931994f, 0.03294389f, 0.05707323f, 
    0.00448702f, 0.06739861f, -0.07121912f, 0.00480081f, -0.06006684f, -0.05728423f, -0.08946443f, -0.01904898f, 
    -0.47231323f, 0.30531627f, -0.15327904f, -0.08620920f, 0.06736356f, 0.06751938f, -0.06250235f, -0.12206155f, 
    0.02297429f, 0.07718776f, -0.05164817f, -0.00570259f, 0.08678480f, 0.02466022f, -0.00498864f, -0.03186563f, 
    0.10093468f, 0.02791880f, 0.15870515f, -0.07796875f, 0.19339302f, -0.13925424f, 0.10985559f, 0.04438172f, 
    -0.07806845f, 0.14023893f, 0.11366868f, 0.10192692f, -0.07387827f, -0.00052882f, -0.01254958f, 0.04299457f, 
    0.09544528f, 0.08286513f, 0.01777774f, -0.04052421f, -0.01248427f, -0.00999527f, 0.04136853f, -0.02198417f, 
    0.12869006f, 0.00433348f, 0.07388002f, -0.09884169f, -0.11663438f, -0.04860773f, 0.16571122f, 0.03122967f, 
    0.01711971f, -0.00060192f, 0.03755337f, -0.04992241f, 0.09059191f, 0.04822541f, 0.14238007f, -0.08564907f, 
    0.10691977f, 0.12662338f, -0.01806476f, 0.07735870f, 0.09372487f, 0.12748452f, -0.11150359f, 0.04791658f, 
    -0.03593560f, 0.15264735f, 0.05350317f, -0.06488319f, -0.02260464f, 0.07892908f, 0.11915536f, -0.00580490f, 
    -0.11694747f, 0.00351394f, -0.05970272f, 0.04585129f, 0.03807691f, 0.01627146f, 0.02450688f, -0.01019117f, 
    0.10256957f, 0.08561023f, 0.01688506f, 0.09049908f, -0.01577803f, 0.11374122f, 0.18159620f, 0.02034761f, 
    0.04687835f, 0.08473752f, 0.11632746f, -0.04460487f, 0.03013492f, 0.00053047f, -0.00145571f, -0.00948382f, 
    0.14250927f, 0.04427687f, 0.07480595f, 0.17150773f, -0.40628761f, 0.43063077f, -0.12472265f, 0.04004566f, 
    -0.25805771f, 0.08683380f, -0.03547043f, 0.07084069f, -0.01839068f, -0.00933617f, 0.07130104f, 0.06148674f, 
    0.02851818f, -0.00647328f, -0.01163980f, 0.01138247f, 0.09796510f, -0.01265677f, 0.03097949f, 0.06609125f, 
    -0.13634026f, 0.04721729f, 0.17854662f, 0.09929310f, 0.14523634f, 0.16809654f, -0.04605248f, -0.00864603f, 
    0.00729226f, 0.14918812f, -0.02558142f, -0.06755622f, -0.02163373f, 0.00754500f, -0.01287210f, 0.01094907f, 
    -0.12493032f, -0.03305886f, 0.06741855f, 0.07061830f, 0.08802398f, 0.06195734f, -0.02901181f, 0.02359465f, 
    0.09573572f, -0.08098875f, 0.01744027f, 0.06041225f, -0.01888959f, 0.03969311f, 0.07932622f, -0.04954218f, 
    -0.00391982f, 0.12513447f, 0.13201278f, 0.03303614f, 0.01904446f, 0.10188945f, -0.12539564f, 0.03404302f, 
    -0.17580660f, -0.03242367f, -0.04811499f, 0.06122158f, 0.34208161f, 0.12171615f, 0.11514002f, -0.02152716f, 
    0.08914077f, 0.03103722f, 0.04525866f, 0.00788006f, -0.00296573f, -0.00717357f, -0.00658104f, 0.08678561f, 
    -0.05267366f, 0.06622849f, -0.04494067f, 0.02649452f, -0.11462542f, 0.25184032f, -0.03667684f, 0.05840812f, 
    -0.27938497f, 0.31449822f, 0.21036328f, 0.23008178f, -0.06053454f, 0.03082578f, 0.11703107f, 0.05827682f, 
    0.03109904f, 0.01775219f, 0.13145493f, 0.08427498f, -0.04018934f, 0.11732463f, -0.09953223f, 0.02834341f, 
    -0.11386500f, -0.05254526f, -0.08286539f, -0.09331974f, 0.19262783f, 0.02191911f, -0.03914231f, 0.08039159f, 
    -0.00052890f, 0.13190749f, 0.02262886f, -0.06690422f, -0.01288696f, 0.01667996f, -0.12984613f, -0.07075718f, 
    -0.02813010f, 0.10856072f, -0.05851436f, -0.07443185f, -0.03830022f, 0.01864666f, -0.17439716f, -0.11773609f, 
    0.25208598f, 0.04784268f, 0.01766603f, 0.12799272f, -0.00286998f, -0.00391009f, 0.02214384f, 0.08934972f, 
    0.08452202f, 0.09560002f, 0.01326019f, 0.01484635f, 0.03464207f, 0.01688069f, -0.04549602f, 0.02955581f, 
    0.00237182f, 0.01011978f, -0.01379297f, -0.03929204f, 0.02925039f, -0.04969657f, 0.02187365f, 0.02438268f, 
    -0.05563802f, -0.02465903f, 0.00052913f, 0.03668363f, 0.02990070f, 0.04963849f, -0.04843580f, -0.04380199f, 
    -0.05466032f, 0.02953782f, 0.01823441f, 0.04159120f, 0.04346444f, -0.01860495f, -0.00842363f, -0.02347561f, 
    -0.03329510f, 0.04961994f, -0.04359690f, -0.04237911f, -0.04785350f, -0.01760165f, -0.00794008f, 0.05231671f, 
    0.00173021f, -0.01864796f, -0.03701862f, 0.01789885f, -0.02105674f, 0.02239468f, 0.01987404f, -0.00334209f, 
    -0.00709623f, -0.00494753f, -0.04852081f, -0.05428016f, 0.01084343f, 0.04676481f, 0.01846608f, -0.01432057f, 
    -0.05133383f, -0.05106455f, 0.04404380f, -0.04268520f, 0.01987270f, -0.01140432f, -0.03620688f, -0.01473145f, 
    -0.01740318f, 0.00770742f, 0.00604367f, -0.03205660f, 0.02416242f, -0.03936223f, -0.01638804f, 0.04253854f, 
    -0.05546833f, -0.00190763f, -0.03504746f, -0.00067857f, 0.04002593f, -0.04102975f, -0.02467943f, -0.04961292f, 
    0.03171332f, -0.00845085f, 0.01059478f, -0.05820672f, -0.03783143f, -0.03953489f, -0.02925663f, -0.01315011f, 
    0.01056839f, -0.04600182f, 0.04762108f, -0.00994741f, -0.01865521f, -0.03492369f, 0.03904458f, 0.04907396f, 
    -0.04024994f, -0.03283801f, -0.04768383f, 0.02541607f, -0.02344248f, -0.01191436f, -0.02773700f, 0.03533586f, 
    -0.05875139f, -0.00068466f, -0.04044805f, 0.03627837f, -0.03263990f, -0.04922704f, -0.06135537f, -0.05465711f, 
    -0.04297873f, -0.01810229f, 0.00563123f, -0.02273952f, -0.05087814f, 0.01264044f, 0.00044692f, -0.02915485f, 
    0.02240960f, 0.04072186f, 0.04962042f, -0.00076153f, -0.05682885f, 0.00453677f, -0.04110720f, -0.05219899f, 
    -0.02210855f, 0.04268872f, 0.03247202f, 0.02050035f, -0.04419453f, -0.00623390f, -0.05581526f, -0.00345052f, 
    -0.02667270f, -0.00556117f, -0.01121773f, -0.02588403f, 0.03263596f, 0.02173322f, -0.05096237f, 0.01003320f, 
    0.00933980f, -0.05018267f, -0.02621354f, -0.03435130f, 0.01084617f, 0.00385365f, 0.01752507f, -0.05804552f, 
    0.04464291f, -0.03508785f, -0.01501087f, 0.03018434f, -0.05781056f, -0.05646333f, -0.04972384f, 0.03733589f, 
    -0.03471189f, 0.03256973f, 0.01738906f, -0.05645948f, 0.04764201f, -0.05781448f, 0.01823526f, -0.00381388f, 
    -0.03213946f, -0.05960933f, 0.03368357f, -0.02715571f, -0.03208958f, -0.03332321f, -0.03625288f, -0.00524036f, 
    0.02823540f, -0.02789264f, -0.00529891f, 0.02842378f, 0.00118407f, -0.04055975f, -0.00570983f, -0.00140617f, 
    0.02551289f, -0.01499143f, -0.02212403f, 0.02557077f, 0.04895854f, 0.03069406f, 0.00743859f, 0.02928682f, 
    -0.05139909f, -0.03216571f, -0.00938922f, -0.06185544f, -0.02425669f, 0.04911809f, 0.03201631f, 0.00282616f, 
    0.04459755f, 0.02105935f, -0.00825233f, -0.02558703f, -0.03281092f, -0.03358038f, -0.03399688f, -0.04075462f, 
    -0.06137844f, 0.03513151f, 0.03082227f, 0.00796832f, 0.00714918f, -0.04800437f, 0.01911649f, -0.01497769f, 
    -0.05207419f, -0.04296929f, -0.01397270f, 0.02867891f, -0.01415130f, 0.04839022f, -0.04502111f, -0.01076854f, 
    -0.04886925f, -0.02132817f, 0.01212598f, -0.05768784f, -0.00262168f, -0.04167671f, -0.01090148f, -0.02867943f, 
    0.03600392f, 0.03976197f, -0.01754644f, -0.04547194f, -0.00982602f, -0.01273493f, 0.00004782f, 0.02807587f, 
    0.03231056f, 0.01703715f, -0.05438849f, 0.03830963f, -0.00114844f, 0.02908738f, 0.00098016f, 0.03007174f, 
    0.00381705f, 0.00019060f, 0.03500761f, -0.04297451f, -0.03811111f, -0.00983466f, -0.00313135f, 0.04251823f, 
    0.01796153f, 0.00018667f, 0.00573686f, -0.02056443f, -0.05860443f, -0.00807383f, 0.00658964f, -0.02113952f, 
    0.00874756f, 0.03750841f, -0.02439935f, -0.03467345f, 0.02042537f, -0.01057716f, -0.01148393f, -0.00645273f, 
    -0.00052738f, 0.00178849f, 0.04854918f, -0.05368514f, -0.04866479f, 0.03856272f, -0.02666703f, 0.02014147f, 
    -0.00376437f, -0.01458318f, -0.01582741f, -0.01079263f, -0.04367449f, -0.03280429f, -0.01250550f, -0.02829568f, 
    -0.03789410f, -0.00396204f, -0.01862425f, -0.00338337f, -0.00280895f, 0.00644780f, 0.00089112f, -0.00053141f, 
    -0.03181428f, 0.00637752f, 0.01617506f, 0.03306424f, 0.02574684f, -0.03935883f, 0.01057564f, -0.03460411f, 
    0.01374871f, -0.05897639f, -0.02786219f, 0.03613481f, -0.00011443f, -0.05869327f, -0.02112025f, -0.04387240f, 
    0.04198393f, 0.00178467f, 0.02567921f, -0.04315101f, 0.03409020f, -0.02052829f, -0.05507096f, 0.03118567f, 
    0.01285121f, -0.01982753f, -0.02500921f, -0.04977997f, -0.00544437f, -0.00950919f, -0.02006957f, -0.03216443f, 
    0.00472255f, -0.03704228f, -0.03539741f, -0.05134956f, 0.03960640f, 0.04161904f, -0.02067729f, -0.03515103f, 
    -0.03135922f, -0.04086690f, -0.00196761f, -0.00904750f, 0.02009656f, -0.05947445f, -0.05392841f, -0.03359584f, 
    0.04581193f, 0.04087703f, 0.04272643f, 0.01445472f, -0.03370159f, 0.00571436f, -0.04936413f, -0.05731165f, 
    -0.05947548f, 0.02137861f, -0.04681429f, -0.01615673f, -0.05167782f, -0.02548498f, 0.01512609f, -0.03705207f, 
    0.03262736f, 0.01564330f, 0.04976008f, 0.02673787f, -0.04447252f, -0.00454800f, -0.06258336f, -0.00607005f, 
    0.00062023f, -0.01169964f, -0.03274403f, 0.03429658f, -0.00962635f, -0.04968766f, -0.01772268f, 0.03418117f, 
    -0.05627415f, -0.02242759f, 0.01473362f, 0.01735362f, -0.00617535f, 0.00181363f, -0.00773620f, 0.04406893f, 
    0.00975643f, 0.02854030f, -0.04393795f, -0.00425479f, -0.00694100f, -0.02742085f, -0.02972835f, -0.00093147f, 
    0.04277445f, 0.00451562f, -0.04440197f, 0.03668309f, 0.00135738f, -0.00724251f, 0.01133914f, -0.02434992f, 
    0.01949022f, -0.05769796f, 0.01940946f, 0.04443209f, -0.00152566f, -0.00203280f, -0.01815668f, 0.04465838f, 
    0.01186701f, -0.04926699f, -0.05377020f, -0.06749802f, 0.00537195f, 0.01260374f, -0.04174254f, -0.00810805f, 
    -0.02206167f, -0.06925693f, 0.04294672f, 0.02664188f, 0.03168045f, -0.01313000f, 0.02198790f, -0.01635650f, 
    -0.06158586f, 0.04146171f, 0.03734431f, 0.05005011f, 0.01993011f, 0.00976376f, -0.04870348f, -0.00973003f, 
    -0.04560560f, -0.02188592f, 0.01651931f, 0.01751757f, -0.02538588f, -0.04951954f, -0.01676356f, -0.00715508f, 
    -0.01785459f, -0.00590593f, -0.03439310f, -0.01039131f, 0.01926917f, -0.04629560f, -0.00652114f, -0.00060913f, 
    -0.04219945f, -0.05577299f, 0.01477091f, 0.00345813f, 0.02514615f, -0.04657692f, -0.05777111f, -0.02237175f, 
    0.04217353f, 0.01051744f, -0.05431805f, -0.01011324f, -0.03340108f, -0.03109981f, -0.05127552f, -0.06160999f, 
    0.01541628f, -0.00149058f, -0.04641004f, -0.01982489f, -0.04834498f, -0.01938731f, -0.04279842f, -0.05740974f, 
    -0.02952353f, -0.04660920f, -0.01318986f, -0.05496250f, 0.01859308f, -0.01664262f, -0.05507915f, -0.02242669f, 
    -0.03189919f, -0.01649831f, 0.02593835f, -0.04623885f, -0.03412691f, -0.00571345f, 0.03412059f, 0.02443923f, 
    -0.00116135f, -0.00696609f, -0.03526714f, -0.04896264f, -0.04023561f, -0.00418706f, -0.03038126f, 0.00903265f, 
    0.00721772f, -0.00485639f, 0.02713414f, 0.01072287f, 0.03465250f, 0.04615807f, -0.01623411f, -0.01324315f, 
    0.01855948f, 0.03833635f, -0.04310632f, 0.04849735f, -0.05932321f, -0.03070919f, -0.00397604f, 0.04349370f, 
    -0.01278950f, 0.03152813f, -0.04461829f, -0.03244456f, -0.04095795f, 0.00184027f, -0.00951307f, 0.02889297f, 
    0.04499470f, -0.02534401f, 0.00537947f, 0.00663483f, -0.02881711f, 0.02335747f, 0.04744350f, 0.03501161f, 
    -0.03845978f, 0.04570724f, -0.04991803f, 0.01865702f, 0.00461699f, 0.02858100f, -0.04543260f, 0.03800457f, 
    0.03841161f, -0.00415069f, 0.03373861f, -0.05062813f, -0.02998787f, -0.04283632f, -0.01478975f, 0.00139037f, 
    0.03944147f, 0.03099495f, 0.01774246f, 0.04014407f, -0.02425416f, 0.04154108f, -0.03679876f, -0.01584498f, 
    0.00625453f, 0.02089822f, 0.00373050f, 0.00486420f, 0.01410811f, -0.01443225f, -0.03928798f, 0.01348100f, 
    -0.01240394f, 0.04055493f, 0.02341403f, -0.06166467f, -0.04313449f, -0.02195605f, -0.05514339f, -0.05220998f, 
    0.03125845f, -0.03095163f, 0.00103019f, 0.03990846f, 0.00123647f, 0.00120074f, -0.02116938f, 0.02787709f, 
    -0.01863269f, -0.04656696f, -0.00468346f, -0.05800207f, -0.04154111f, -0.02991071f, 0.02337165f, 0.03016335f, 
    -0.04016510f, 0.04387645f, -0.01387838f, -0.05110165f, -0.02521810f, -0.00651227f, -0.05283017f, 0.04093372f, 
    -0.03155437f, -0.01462207f, 0.00201257f, -0.07638618f, -0.04219315f, 0.03768380f, 0.03828783f, 0.00879960f, 
    -0.02893197f, -0.00184919f, -0.04209655f, -0.03744749f, -0.00167149f, -0.00615553f, 0.01761750f, -0.01547482f, 
    -0.01061139f, 0.02161322f, -0.02017781f, 0.01936845f, -0.00665890f, -0.03911528f, -0.02247310f, 0.02387020f, 
    -0.01130923f, -0.03360806f, -0.05057955f, -0.04948992f, 0.00972057f, -0.05484830f, 0.00856265f, -0.06003134f, 
    -0.04514509f, 0.02629715f, 0.03344152f, -0.01091104f, 0.03654579f, 0.04281179f, -0.05444523f, -0.03369750f, 
    -0.02729011f, -0.05044605f, -0.01801094f, 0.01677902f, -0.03832405f, -0.05188227f, -0.04557069f, -0.00835350f, 
    0.02753876f, -0.03129947f, -0.01155109f, 0.01302720f, -0.04476535f, -0.02975999f, -0.00796334f, 0.03056838f, 
    -0.07835644f, -0.36544344f, -0.01064052f, -0.12725197f, -0.01636962f, -0.04390078f, -0.09590717f, 0.07633262f, 
    -0.03699288f, 0.04903227f, -0.02894120f, -0.03915404f, -0.01158791f, 0.05566859f, -0.05864103f, 0.01831814f, 
    0.00846766f, 0.06443367f, 0.10397096f, -0.00573438f, 0.21205823f, -0.05719784f, 0.04159103f, 0.03974696f, 
    0.03911944f, -0.02007778f, -0.08058982f, -0.08519536f, -0.05139183f, -0.02508989f, 0.00425901f, -0.01757272f, 
    0.05656829f, 0.05035860f, -0.02417738f, 0.03075657f, 0.04270496f, 0.01010421f, -0.02026077f, -0.00824112f, 
    -0.06509446f, -0.14534691f, -0.18531759f, 0.09057530f, -0.16091686f, -0.04244396f, 0.00765719f, 0.05932083f, 
    -0.02065994f, 0.03587050f, -0.04594855f, -0.14437573f, 0.08294158f, -0.16741768f, -0.02674191f, 0.05515565f, 
    -0.00147265f, -0.06247475f, 0.18266433f, 0.01565568f, -0.07256562f, 0.12551339f, -0.15985630f, -0.02166375f, 
    0.00227663f, 0.00902752f, -0.08970806f, 0.06817260f, 0.00848114f, -0.02898629f, -0.04210758f, -0.02023026f, 
    0.04844085f, 0.01413135f, -0.02021664f, -0.08316150f, 0.01763253f, 0.14445731f, 0.07015683f, 0.01467552f, 
    0.46566373f, -0.34765163f, -0.06197683f, -0.04544436f, 0.05998543f, -0.05924011f, 0.05752663f, 0.05431880f, 
    -0.03722073f, 0.13264367f, 0.09269955f, 0.00907122f, -0.09411037f, -0.01924700f, -0.11120450f, 0.01050333f, 
    0.01217662f, 0.10721675f, -0.11133705f, 0.05690984f, 0.38223979f, 0.22624965f, 0.04214376f, -0.10486491f, 
    0.07493610f, 0.04783529f, -0.05828793f, 0.04136111f, 0.13137229f, 0.01547254f, 0.06945937f, -0.00065787f, 
    -0.06506300f, -0.02769167f, -0.04552557f, -0.02156902f, 0.03884239f, 0.07366230f, -0.04683514f, -0.06524106f, 
    0.15614159f, 0.22602947f, -0.00290607f, -0.24321952f, 0.00557479f, 0.02466298f, 0.00343809f, 0.05547998f, 
    0.05896257f, -0.00736978f, 0.00998980f, 0.00179025f, -0.04746163f, -0.00889012f, -0.06450064f, 0.07522373f, 
    -0.10879991f, -0.04859593f, 0.02256165f, -0.00508894f, 0.10248217f, -0.19908203f, 0.24012043f, 0.05919970f, 
    0.06547832f, -0.17594598f, 0.09780331f, 0.10366056f, 0.02777198f, 0.03514894f, 0.00308348f, 0.07373913f, 
    0.06029928f, 0.07170027f, -0.01728630f, -0.01209293f, -0.09542815f, 0.06198959f, -0.03870656f, -0.02022588f, 
    0.16612063f, -0.03100300f, 0.23744039f, -0.06055202f, 0.05036150f, 0.04315162f, -0.04998164f, -0.00179251f, 
    0.02840160f, 0.06283149f, 0.00060306f, 0.04468595f, -0.04969823f, 0.02096535f, 0.01358868f, -0.00466922f, 
    -0.15837416f, 0.12814732f, -0.11362369f, -0.11242887f, -0.06081494f, -0.18401100f, 0.23573236f, -0.15927930f, 
    0.30454919f, 0.20013490f, -0.04121405f, 0.02809142f, 0.06552621f, 0.04039305f, -0.06485554f, -0.00155096f, 
    -0.05379570f, 0.04125104f, 0.04345396f, 0.05382917f, -0.02175167f, 0.04658386f, -0.01216866f, -0.09851171f, 
    0.45530471f, -0.19518277f, 0.06282476f, -0.04856972f, -0.03997360f, -0.00301555f, 0.05449653f, -0.05132572f, 
    0.07559489f, -0.00563363f, 0.06493716f, 0.17552850f, 0.01259424f, -0.01587797f, -0.04764460f, 0.11513757f, 
    0.04272770f, -0.01566186f, -0.14263718f, 0.05236321f, -0.03853272f, 0.00031773f, -0.11362679f, -0.12638186f, 
    -0.08329158f, 0.04902092f, -0.02478605f, -0.00577600f, 0.10235493f, 0.10074791f, 0.07020469f, 0.10131282f, 
    0.04998912f, -0.07054575f, -0.05799016f, 0.03754975f, 0.04110344f, 0.00873841f, 0.18447369f, -0.00304540f, 
    0.30410612f, 0.08074635f, -0.03207954f, -0.00776778f, -0.28057352f, -0.15115064f, -0.04058270f, -0.08546419f, 
    -0.06499743f, 0.07071166f, 0.07355339f, -0.03092978f, 0.09963280f, 0.07697545f, -0.01276906f, 0.00987020f, 
    0.07704321f, 0.02358753f, 0.03579843f, -0.00686468f, -0.07279285f, -0.04241474f, 0.25069472f, 0.08444355f, 
    0.18539055f, -0.08605620f, -0.03952248f, 0.10574547f, 0.12841630f, 0.03509107f, -0.03142443f, -0.11475833f, 
    -0.09695203f, 0.07672913f, -0.07625573f, -0.05929613f, 0.05439845f, -0.00198750f, -0.00074117f, 0.02486625f, 
    0.11195128f, 0.01965619f, 0.14304346f, -0.05348173f, -0.13891958f, -0.05024147f, 0.13393889f, -0.07607289f, 
    0.04327369f, 0.04671599f, -0.01936221f, 0.07220980f, -0.06991419f, 0.06048467f, 0.03872312f, -0.01150351f, 
    -0.10079617f, -0.08791211f, -0.04127719f, 0.06300788f, -0.12553205f, 0.03659030f, -0.13466692f, 0.10752944f, 
    -0.15585709f, -0.07877923f, 0.03624188f, 0.01011910f, 0.07840437f, -0.00893118f, 0.03803975f, 0.01177174f, 
    0.01416373f, 0.04432033f, 0.11021987f, 0.12781481f, -0.03932597f, 0.08460087f, 0.07804954f, -0.00989217f, 
    -0.10671763f, -0.20255893f, -0.10425314f, -0.05670474f, 0.07329199f, 0.05823714f, 0.06476390f, 0.04182292f, 
    0.03964574f, 0.05362695f, 0.01782068f, 0.00304816f, 0.02828824f, 0.05040052f, -0.01546395f, -0.00643762f, 
    0.02998741f, -0.01166339f, 0.07349677f, -0.00749037f, -0.02695772f, -0.21120784f, -0.00906994f, -0.21986993f, 
    -0.09299946f, 0.02748063f, 0.11822926f, -0.13076277f, -0.11614343f, -0.03535642f, 0.05953986f, 0.00648064f, 
    0.00578041f, -0.03014316f, 0.06824648f, 0.01646752f, 0.09498540f, -0.07476553f, -0.05586676f, 0.02606566f, 
    -0.03314833f, 0.05852230f, -0.17615950f, -0.09805817f, 0.08767484f, 0.01709204f, -0.03120696f, -0.01985632f, 
    0.10983023f, -0.00549403f, -0.06761881f, 0.02884052f, -0.11900482f, -0.05597516f, 0.00124725f, 0.01208780f, 
    -0.14586052f, 0.18880866f, 0.00301740f, 0.02256352f, -0.43482032f, 0.12959588f, -0.14045876f, -0.15674379f, 
    0.13493617f, -0.02580799f, 0.09984379f, -0.03417478f, 0.00575832f, -0.00469623f, 0.01313201f, 0.02943469f, 
    0.00016057f, -0.01061520f, -0.14526612f, -0.10277949f, 0.01561546f, 0.08167147f, -0.07246138f, 0.03912940f, 
    -0.11744805f, -0.22804689f, -0.02708163f, 0.11730928f, 0.15114293f, 0.08392270f, -0.09120313f, 0.02087884f, 
    -0.04606938f, 0.07874330f, 0.07775671f, -0.06033592f, 0.03010959f, -0.13887757f, 0.06746154f, 0.02551334f, 
    -0.03247358f, 0.15915354f, -0.10308009f, -0.02865982f, 0.28537083f, 0.42550397f, 0.18892264f, 0.14094920f, 
    -0.05207974f, 0.02296999f, -0.14365757f, 0.06758508f, 0.01900839f, 0.03263270f, 0.09355646f, 0.07428752f, 
    0.08870960f, 0.04340540f, 0.05905996f, 0.06725245f, 0.02896240f, 0.06028900f, 0.01088117f, -0.07176723f, 
    0.17589137f, 0.27330467f, 0.14006470f, 0.26333547f, 0.02827170f, -0.15178987f, -0.13558927f, -0.03972020f, 
    0.03714935f, 0.01769148f, 0.05021642f, -0.04509641f, -0.00354865f, 0.13788906f, 0.11410264f, 0.09483862f, 
    0.01343214f, -0.04837499f, 0.02810244f, 0.06566929f, -0.02174306f, -0.03154521f, 0.07952675f, 0.06507309f, 
    -0.10150991f, 0.01560134f, 0.20554534f, 0.13312359f, 0.03307800f, 0.15932295f, -0.06346875f, 0.00984219f, 
    0.00499315f, 0.02509667f, 0.08902827f, -0.05118724f, -0.02860399f, 0.07757871f, 0.01561362f, 0.00983315f, 
    0.02222915f, -0.20184585f, 0.14546195f, 0.00922434f, 0.07393239f, 0.02611412f, 0.07039602f, 0.06359965f, 
    -0.02591259f, 0.08392268f, 0.07102446f, -0.01026489f, 0.05721041f, 0.06946903f, 0.12217017f, 0.08701425f, 
    -0.03468154f, -0.03779314f, -0.05208398f, -0.03533966f, -0.10488266f, -0.16099137f, 0.02829416f, -0.06617472f, 
    0.04822367f, 0.02308175f, -0.00545594f, 0.06209709f, -0.06129197f, -0.06714173f, 0.04967403f, 0.00165700f, 
    0.03110823f, -0.06531629f, -0.08366437f, -0.05739169f, -0.01214327f, 0.08658858f, -0.06778198f, -0.01073292f, 
    -0.08519313f, -0.22357231f, -0.04761915f, -0.09489139f, -0.03792942f, 0.03567838f, 0.03094279f, 0.01471916f, 
    0.01223665f, -0.12992160f, 0.02715806f, -0.01289031f, 0.01330093f, -0.06209121f, -0.04235018f, 0.08490559f, 
    0.03853039f, 0.00539599f, -0.08686068f, 0.01505219f, -0.03848446f, -0.11408950f, 0.03460285f, 0.11165366f, 
    0.14795761f, -0.03646889f, -0.09559813f, -0.01617359f, -0.07006999f, -0.01156839f, 0.00155151f, -0.04248299f, 
    0.03433607f, 0.14934158f, 0.08356890f, 0.00904885f, -0.04557455f, -0.03992842f, 0.04445770f, 0.04304598f, 
    -0.30096099f, -0.16794118f, -0.12521566f, -0.12479679f, -0.03120949f, 0.16744259f, 0.07445992f, 0.05697434f, 
    0.07889286f, 0.07795294f, 0.08219974f, -0.03170100f, -0.05342612f, -0.00819813f, -0.09097783f, 0.06771645f, 
    0.04061715f, -0.02025672f, -0.03621140f, 0.01351863f, 0.25943866f, 0.01098594f, 0.08118897f, 0.07017490f, 
    -0.08533489f, 0.04255168f, 0.07933611f, 0.04976602f, 0.04962710f, 0.10326071f, 0.11228868f, 0.02272780f, 
    0.04084646f, 0.01578145f, -0.02612705f, -0.03118767f, 0.05490301f, 0.13327767f, 0.08866839f, -0.06239136f, 
    -0.13021511f, -0.06318001f, 0.04129511f, 0.03279017f, -0.08747043f, -0.01203058f, 0.07344364f, 0.04811970f, 
    0.10656289f, 0.13541478f, -0.01303803f, 0.03430757f, 0.05689845f, 0.10897519f, 0.01389914f, 0.01773066f, 
    -0.01870434f, 0.06699593f, -0.06080426f, -0.06057568f, -0.29360497f, 0.05653800f, -0.13077235f, -0.02918266f, 
    -0.02798535f, 0.00184631f, -0.03647535f, -0.04177202f, 0.02973982f, -0.00523918f, -0.08708156f, 0.01407586f, 
    -0.06675653f, 0.03323126f, 0.16903946f, -0.00041053f, 0.06927745f, 0.11413229f, 0.01661531f, 0.08366598f, 
    0.25084490f, -0.02539603f, -0.16119947f, -0.11997576f, -0.10497855f, -0.02181374f, -0.01710682f, 0.06454746f, 
    -0.03053538f, 0.04851132f, 0.03018771f, -0.02931411f, 0.05260667f, -0.03498245f, -0.02758638f, -0.02340874f, 
    -0.04307318f, -0.04037562f, 0.00997912f, -0.02661062f, 0.20701711f, -0.03174436f, -0.27627689f, -0.15363723f, 
    0.02001537f, -0.13418972f, -0.02169725f, -0.13045341f, 0.07450898f, -0.03151675f, 0.05821292f, -0.01553008f, 
    -0.01332913f, -0.03094002f, 0.02110475f, 0.02592608f, -0.01606935f, 0.00673578f, -0.08531588f, 0.07439218f, 
    0.07965203f, 0.20160806f, 0.02047316f, -0.07017906f, -0.02296594f, 0.04543177f, 0.00702172f, 0.08386125f, 
    -0.03593426f, 0.05998603f, -0.18062146f, -0.06528754f, 0.06347004f, 0.04404145f, -0.00978805f, 0.05803910f, 
    0.07064099f, 0.15918051f, 0.06415940f, 0.02042227f, -0.26959205f, 0.16888948f, -0.16119690f, -0.16868731f, 
    0.11575019f, -0.08630481f, 0.03828354f, 0.03107904f, -0.01200789f, 0.04195518f, -0.04160044f, 0.05220075f, 
    -0.05522369f, -0.06676909f, -0.12316041f, 0.02936891f, 0.03712605f, 0.03464307f, -0.03827942f, -0.09155829f, 
    -0.07971955f, 0.24769033f, -0.01714848f, 0.08297543f, 0.10286713f, 0.07658140f, 0.08760360f, 0.01863637f, 
    -0.12003906f, 0.05080979f, 0.12338330f, -0.00190202f, 0.00055727f, -0.06797869f, -0.10883830f, 0.09035382f, 
    0.07592949f, 0.05722201f, 0.08016912f, 0.12481107f, -0.16281287f, 0.36729947f, -0.08571035f, 0.05979246f, 
    0.08713280f, 0.04631363f, 0.01564231f, 0.14915827f, -0.02893624f, -0.01155054f, 0.11675042f, -0.00171271f, 
    0.02307045f, 0.07549480f, 0.05151163f, 0.10023715f, 0.08683857f, 0.07043669f, -0.05348546f, 0.11633428f, 
    0.04031058f, 0.13287915f, -0.07577313f, 0.16682068f, 0.04756910f, 0.12113671f, 0.12675448f, 0.11527145f, 
    -0.04913766f, 0.04158647f, -0.01079885f, -0.00823451f, -0.02778121f, 0.06453109f, 0.03064793f, 0.05264428f, 
    -0.01213427f, 0.03691180f, -0.10118448f, 0.04746768f, -0.06381498f, 0.12105373f, -0.06634507f, -0.01352608f, 
    -0.04313406f, 0.02795165f, 0.11029489f, 0.02909694f, 0.07780508f, 0.06004721f, 0.03203221f, -0.02981541f, 
    0.03090921f, -0.00281763f, 0.10650977f, 0.00348054f, -0.07230528f, -0.02553419f, 0.05100782f, 0.10455079f, 
    0.10945301f, -0.12359594f, 0.06222396f, 0.05439632f, -0.15613475f, 0.10360704f, 0.02677047f, 0.06970948f, 
    0.02206156f, -0.03866901f, -0.04266622f, -0.03521420f, 0.06578835f, 0.07658479f, 0.09312405f, -0.00130143f, 
    -0.01682938f, 0.01959811f, 0.08893191f, 0.02958390f, -0.00480483f, -0.20350620f, -0.05644320f, -0.16529949f, 
    0.12104110f, 0.15635566f, -0.03570393f, 0.10445242f, 0.00434125f, -0.01826921f, 0.08394417f, -0.00556953f, 
    -0.03070853f, -0.09573185f, -0.08613234f, 0.02580992f, -0.00332328f, 0.09377396f, -0.08672790f, 0.00932004f, 
    0.27895844f, -0.26713666f, -0.19994316f, -0.00750189f, -0.10287175f, -0.11793839f, -0.05190997f, 0.04264188f, 
    0.09964242f, 0.03289755f, -0.01860062f, 0.02067115f, 0.03270553f, 0.00338698f, -0.09172999f, 0.01752569f, 
    0.03123404f, 0.05604751f, 0.01729108f, 0.05803078f, 0.08439450f, 0.13548575f, 0.03754713f, 0.07808492f, 
    -0.04590149f, 0.19239876f, 0.08566342f, 0.10154388f, 0.02927382f, 0.05025919f, 0.05455621f, -0.01594162f, 
    0.10531880f, -0.01241037f, 0.07564980f, 0.05914884f, 0.01098591f, -0.02776620f, 0.06703003f, -0.01616528f, 
    -0.02149263f, -0.04590287f, -0.10073864f, -0.06433736f, -0.03424633f, -0.13848910f, -0.03644261f, -0.01277751f, 
    -0.08767393f, 0.14442348f, -0.02429307f, 0.02211090f, 0.03341441f, 0.00173735f, -0.01000686f, 0.02862706f, 
    0.03716758f, 0.01392869f, 0.05200441f, -0.02119503f, -0.25212020f, -0.19260298f, -0.00453500f, -0.03281506f, 
    -0.24391472f, -0.03880779f, -0.04216969f, 0.07730760f, 0.00059283f, 0.12615532f, 0.01766336f, -0.17245734f, 
    0.05334499f, 0.06666377f, 0.00085746f, -0.11341117f, -0.00749681f, 0.03201571f, 0.09272272f, -0.02949609f, 
    -0.12594573f, -0.06176092f, -0.23796056f, -0.00316319f, -0.06447562f, -0.15367115f, 0.04373935f, -0.13697423f, 
    0.00537194f, -0.05447898f, -0.05732510f, 0.00014879f, -0.02101219f, -0.02008370f, 0.01583208f, 0.07891799f, 
    -0.10567559f, 0.07883868f, -0.12739497f, 0.08915395f, -0.02886393f, 0.03384713f, 0.06594105f, -0.07767791f, 
    -0.03179838f, -0.01278969f, -0.01318287f, -0.06608421f, 0.04225124f, 0.00394368f, -0.07402015f, -0.00520064f, 
    -0.05466572f, 0.07472005f, 0.01571493f, 0.04786428f, 0.05577775f, -0.01458015f, -0.05993007f, 0.03004970f, 
    -0.08542156f, -0.09456918f, -0.18956466f, -0.00725586f, 0.10680253f, -0.00192153f, -0.00262449f, -0.04423064f, 
    -0.04250102f, 0.00536344f, -0.05655437f, 0.13731013f, -0.02522948f, 0.03005695f, 0.07536209f, 0.02934395f, 
    -0.01329116f, 0.19670221f, 0.02169634f, 0.10316270f, 0.12028655f, -0.02061907f, -0.15988465f, -0.28095001f, 
    0.10185745f, -0.06238304f, 0.05218961f, -0.08578265f, 0.17213903f, 0.00176295f, 0.06535702f, 0.03367713f, 
    0.03585205f, 0.06892673f, 0.12660679f, 0.14904858f, 0.11596008f, 0.06277148f, -0.03244042f, 0.17875648f, 
    -0.25485012f, 0.09533960f, 0.09032010f, 0.05471040f, 0.01955382f, 0.05702577f, -0.00161955f, -0.12953714f, 
    -0.06169155f, 0.06791416f, 0.00148341f, -0.00616604f, 0.05510921f, -0.03085352f, -0.03295074f, -0.00894067f, 
    0.02836735f, 0.04634013f, 0.18459806f, -0.07136866f, 0.08709075f, 0.12672460f, -0.06694299f, -0.00813576f, 
    0.00068930f, -0.13916227f, -0.10942393f, -0.02147616f, 0.02032131f, 0.00691129f, -0.07130051f, 0.01627016f, 
    -0.08637792f, -0.00188077f, 0.01405141f, 0.06753943f, 0.05400289f, 0.06474774f, 0.07740197f, -0.08509844f, 
    -0.04561634f, 0.14981441f, 0.09788667f, 0.23594664f, -0.17524379f, 0.01978366f, -0.04418033f, 0.01817824f, 
    -0.04164847f, -0.04309844f, -0.01285344f, 0.00669954f, 0.02380481f, 0.03557252f, 0.02651392f, 0.09732613f, 
    -0.01937124f, 0.03935628f, 0.13139145f, 0.01151643f, -0.13855863f, 0.34373793f, 0.08808450f, 0.09821721f, 
    0.08881972f, 0.05149423f, 0.08409625f, -0.08576509f, 0.07846118f, -0.03820640f, -0.06948178f, -0.00783800f, 
    0.00071799f, -0.06596728f, 0.02566885f, 0.04179189f, 0.06972218f, -0.22301172f, -0.08062019f, -0.12882656f, 
    0.08684823f, 0.09222938f, 0.02053292f, 0.12206525f, 0.04256564f, 0.01245242f, 0.06433295f, -0.00070123f, 
    0.02929715f, 0.09488463f, 0.00354038f, 0.09861289f, -0.02522867f, -0.13127691f, -0.03851980f, 0.12784536f, 
    0.04216941f, -0.03455042f, 0.06669472f, 0.05137821f, 0.14689860f, -0.20967308f, -0.00572453f, 0.02407872f, 
    -0.00610106f, -0.02220875f, -0.06047158f, -0.02944870f, 0.11080105f, -0.02869779f, 0.03960895f, 0.00159135f, 
    0.03930629f, -0.00796173f, 0.01038997f, 0.00397736f, 0.07201663f, -0.01466983f, -0.14551257f, -0.02844344f, 
    -0.01101596f, -0.00324878f, 0.00668410f, 0.01119633f, 0.06781350f, -0.03377003f, 0.01163797f, -0.04456142f, 
    0.04180310f, -0.03164082f, 0.01559777f, 0.01033900f, -0.09250000f, 0.05621826f, 0.04499320f, 0.00837778f, 
    -0.11360130f, 0.05577734f, -0.21769969f, -0.05092144f, 0.46610433f, -0.06480812f, 0.01811284f, 0.13283126f, 
    -0.03878570f, -0.02711612f, 0.02158733f, -0.12084325f, -0.01433476f, 0.00782514f, 0.04419599f, 0.01248370f, 
    -0.08569492f, 0.08749823f, 0.05229754f, -0.02722459f, 0.07265130f, 0.05466634f, -0.05006005f, 0.03417640f, 
    -0.09568402f, -0.02253589f, -0.17253818f, -0.26853439f, -0.04462611f, -0.02764367f, 0.03056501f, -0.04685789f, 
    0.01584764f, -0.06030749f, 0.03736154f, 0.00697504f, 0.02413303f, 0.05851523f, 0.03679566f, -0.01216489f, 
    0.03894612f, 0.11903381f, -0.18011218f, 0.01317422f, -0.10684606f, 0.00849950f, -0.01148861f, 0.13226546f, 
    -0.03554648f, 0.09305334f, 0.08980178f, -0.02612826f, -0.06143393f, 0.09689469f, -0.02759467f, 0.04670492f, 
    -0.09917337f, 0.00661179f, -0.03526319f, 0.03509472f, -0.04898070f, 0.02725122f, 0.09278671f, 0.00063172f, 
    0.13815916f, -0.00629488f, -0.21447958f, -0.20061614f, -0.18736735f, -0.01653141f, 0.08533270f, -0.07880867f, 
    -0.00639998f, 0.05791926f, 0.00947879f, 0.01706817f, 0.03213611f, -0.00564909f, 0.07002022f, -0.00407844f, 
    -0.08802949f, -0.08037367f, 0.06114535f, -0.02864301f, -0.06107489f, -0.00103928f, -0.07134927f, 0.06070794f, 
    0.32795790f, 0.01445488f, -0.00448167f, 0.00044243f, 0.08543269f, -0.00685710f, -0.01240589f, -0.02061959f, 
    -0.00311513f, 0.01121466f, -0.07918213f, 0.12558435f, -0.01047317f, -0.25304589f, -0.27277869f, 0.08948351f, 
    0.03589766f, -0.22225122f, 0.04743394f, -0.12404130f, -0.16731761f, 0.04861045f, 0.06638549f, 0.16086690f, 
    0.11856540f, 0.02259589f, -0.03144851f, -0.11736192f, 0.10969064f, 0.11823408f, 0.00410044f, 0.03996478f, 
    0.13937157f, -0.10762786f, 0.00571236f, -0.10934085f, 0.13597587f, -0.04681840f, 0.01398650f, 0.09486721f, 
    -0.08349519f, -0.01992016f, -0.00623020f, -0.04872709f, 0.01220441f, 0.08398502f, 0.04291463f, -0.01053252f, 
    0.09847242f, 0.04128268f, 0.02896798f, 0.07368012f, 0.06198953f, -0.00848758f, 0.25854447f, 0.18068235f, 
    0.04449991f, 0.00142255f, -0.01493091f, -0.01788333f, 0.05471320f, -0.02970205f, -0.05677428f, -0.03448875f, 
    -0.00971469f, -0.05626095f, -0.05385605f, -0.05706125f, -0.05699537f, 0.01446622f, 0.03949418f, 0.01996146f, 
    0.02107982f, -0.04794767f, -0.04517415f, 0.04582846f, 0.05105143f, -0.03838920f, 0.02638288f, 0.00256062f, 
    -0.05035670f, -0.01085264f, 0.01908292f, -0.03216180f, -0.03962122f, 0.01079148f, 0.01148862f, 0.01054792f, 
    -0.04697334f, -0.03514479f, 0.00417298f, -0.01453333f, -0.00074674f, -0.01096504f, 0.01675476f, 0.02047610f, 
    -0.01549263f, -0.01693339f, -0.05896925f, 0.00053143f, -0.00748248f, -0.04147078f, 0.00255375f, 0.04236102f, 
    -0.03916214f, 0.04102588f, 0.02353636f, 0.00690620f, -0.03909789f, 0.00827244f, -0.02357918f, -0.05448292f, 
    -0.03867527f, -0.04804945f, -0.01016162f, -0.00452477f, 0.01622749f, -0.01178363f, -0.05841789f, 0.00227573f, 
    -0.00848512f, 0.02994425f, 0.01540118f, -0.02448939f, -0.05655124f, 0.00394980f, 0.04666226f, -0.01437582f, 
    0.02155636f, -0.01042666f, 0.00028327f, -0.05359300f, -0.05311782f, 0.02615872f, 0.04210791f, -0.06004377f, 
    -0.06501632f, -0.04665679f, -0.02913816f, -0.02890857f, 0.00365592f, -0.02336928f, -0.00310154f, 0.00884887f, 
    0.04414817f, -0.00475462f, -0.04735998f, -0.03727897f, 0.03851384f, -0.05838801f, -0.01015663f, -0.02161452f, 
    0.00343946f, -0.02348977f, -0.03173929f, 0.03797965f, -0.03602093f, -0.02694027f, -0.04796952f, 0.02041706f, 
    0.01491935f, -0.02583794f, -0.01072754f, 0.02284160f, -0.00709938f, -0.04058251f, -0.03615072f, 0.04487680f, 
    0.00581375f, -0.02122760f, 0.00554436f, -0.05013250f, 0.04253040f, 0.04612410f, 0.04610957f, -0.05535196f, 
    0.03990072f, -0.02958362f, 0.03997440f, -0.03031080f, 0.04032359f, -0.05162671f, -0.00777742f, -0.05721774f, 
    0.01178636f, -0.01960847f, 0.02493426f, -0.01433228f, -0.02260924f, -0.03787807f, -0.00100013f, -0.03260123f, 
    -0.05550564f, 0.00434699f, -0.00931879f, -0.05578760f, -0.00186240f, 0.01510140f, 0.03480387f, -0.03218577f, 
    -0.04355063f, -0.01351892f, -0.03938204f, -0.05573611f, -0.05507150f, -0.00011534f, -0.00886577f, 0.03854754f, 
    -0.01287922f, -0.00923949f, -0.02597558f, -0.01083131f, -0.01948302f, -0.00822771f, 0.01444287f, 0.02894622f, 
    0.04896786f, 0.01522907f, 0.05117804f, 0.00641517f, -0.03843404f, -0.02340277f, -0.04152233f, 0.00723146f, 
    -0.00064168f, -0.02814744f, -0.01423825f, -0.01146899f, -0.01454880f, -0.01852609f, 0.04183934f, -0.04341768f, 
    -0.00286980f, -0.06225285f, 0.00700520f, -0.02867905f, -0.00598116f, -0.05048200f, -0.03356045f, 0.00517744f, 
    0.01153464f, 0.02675101f, -0.04561101f, -0.02826497f, 0.01927563f, -0.05512364f, 0.04287099f, 0.03206568f, 
    0.01404401f, -0.01873560f, 0.02861919f, 0.00541181f, 0.01828341f, 0.01916819f, 0.01265638f, -0.00730985f, 
    -0.02986242f, -0.04451210f, -0.00933366f, 0.03333462f, -0.01948778f, -0.00142534f, 0.02051865f, 0.01548827f, 
    -0.04090840f, -0.01110026f, -0.03421311f, 0.03442497f, 0.04372140f, -0.05108184f, -0.06402370f, 0.01022827f, 
    -0.05094896f, -0.05736283f, -0.03104361f, 0.03186600f, -0.01679558f, -0.00294467f, 0.01377643f, -0.03666686f, 
    0.02748080f, 0.03049710f, -0.05031991f, 0.01274813f, -0.01860607f, 0.00328365f, 0.01755165f, -0.04526890f, 
    0.01606857f, -0.02920396f, -0.04864351f, -0.00942662f, 0.04633870f, -0.03818952f, -0.02425088f, 0.03276289f, 
    -0.05352525f, 0.03522195f, -0.01619481f, -0.03129559f, 0.01371104f, 0.04982242f, 0.04126587f, -0.00589819f, 
    0.02388044f, 0.01890533f, -0.05450329f, 0.05018759f, -0.03117903f, 0.04268902f, -0.04514373f, 0.00628322f, 
    -0.05170903f, -0.01807457f, 0.00526321f, -0.06429066f, -0.01731520f, 0.00768243f, 0.02556878f, 0.00988130f, 
    0.04240596f, 0.00627639f, -0.05911935f, 0.03880793f, 0.02374629f, -0.04620266f, -0.01871902f, -0.02821677f, 
    0.04787998f, 0.01522231f, 0.00655651f, -0.03666083f, -0.06101546f, 0.01903962f, -0.05095818f, 0.03273929f, 
    -0.02086712f, 0.03544058f, 0.02725243f, -0.04431329f, 0.03318891f, -0.01154139f, -0.05462659f, -0.06035550f, 
    -0.03993896f, 0.01400023f, 0.00833252f, -0.01639118f, -0.00562509f, -0.01535967f, 0.02540240f, -0.00797681f, 
    -0.03169407f, 0.02507895f, -0.00767123f, 0.03252568f, -0.00833494f, 0.02051533f, 0.03346095f, -0.05283671f, 
    -0.05106955f, 0.02469112f, -0.03837557f, 0.01768316f, 0.00865185f, -0.05942824f, 0.02940858f, 0.03064076f, 
    0.03594824f, -0.00481922f, -0.00561106f, -0.03754918f, 0.04685974f, -0.02501850f, 0.01056220f, -0.02916846f, 
    0.21173157f, -0.44677243f, -0.11629136f, -0.08664467f, -0.16797046f, -0.01746590f, -0.02343888f, -0.03231860f, 
    -0.00935937f, 0.07262745f, 0.11616593f, 0.00610913f, 0.07644722f, 0.02296672f, 0.01300831f, 0.02072080f, 
    0.12139212f, -0.02287067f, -0.04485265f, -0.06931148f, 0.24988070f, 0.01264772f, -0.02956783f, 0.07464101f, 
    -0.07642996f, 0.06178275f, -0.01793023f, 0.00255812f, -0.04451049f, -0.00330860f, 0.05189881f, 0.00014147f, 
    0.11936080f, -0.00952454f, -0.03560156f, -0.17012106f, -0.06858039f, 0.03764462f, 0.01694040f, -0.10343714f, 
    0.01234335f, -0.04782671f, -0.09695990f, -0.02973066f, -0.11187833f, -0.03360195f, -0.03586039f, 0.06176413f, 
    0.03265519f, -0.05190866f, -0.04298490f, 0.04173343f, -0.01655187f, -0.06407671f, 0.09344262f, 0.13644561f, 
    0.04400368f, -0.12777218f, -0.01625508f, 0.02323540f, -0.25243554f, 0.20182146f, -0.26794949f, -0.09375842f, 
    -0.13752204f, 0.04755306f, 0.07416479f, -0.06860977f, -0.01174408f, -0.18759491f, 0.02452933f, 0.02380441f, 
    0.12907092f, 0.00443587f, -0.07528982f, -0.14671032f, -0.03028110f, 0.09645508f, 0.07573351f, 0.14161210f, 
    0.32564276f, -0.11384540f, -0.17191246f, 0.14920205f, 0.05111679f, -0.01229787f, 0.00944445f, 0.03303495f, 
    0.01237247f, 0.07669834f, 0.10962752f, 0.11012990f, -0.05228349f, -0.11434877f, -0.04919969f, 0.03156317f, 
    -0.00259501f, -0.00501259f, -0.12026940f, -0.07147304f, 0.19993193f, 0.13976127f, -0.28879425f, -0.18085912f, 
    0.17393477f, -0.10684113f, 0.02589455f, 0.01575940f, 0.01416526f, -0.03777967f, -0.04165492f, 0.08518393f, 
    -0.06511382f, -0.04323490f, -0.02911734f, -0.08051521f, 0.04511586f, 0.10633861f, -0.03059817f, -0.04706632f, 
    0.21202135f, 0.11765575f, -0.13892207f, -0.04837883f, 0.27197281f, 0.00227343f, 0.03693914f, -0.01319376f, 
    -0.02328134f, -0.05535252f, 0.01964605f, -0.00372978f, 0.02586925f, 0.13728683f, 0.06320558f, 0.02056665f, 
    -0.07961797f, -0.06191087f, -0.13780361f, 0.05236600f, -0.12752473f, -0.01794723f, 0.31016818f, -0.18791959f, 
    -0.13315961f, -0.06254244f, 0.06096722f, -0.00133678f, 0.00608218f, -0.05089254f, -0.04551229f, -0.03213089f, 
    -0.00553088f, 0.05417591f, 0.07057941f, 0.09006827f, -0.12482026f, 0.09303971f, 0.05581059f, 0.10325085f, 
    0.16652276f, -0.09467580f, 0.18198034f, -0.22011262f, -0.04306718f, -0.04470576f, -0.09204704f, 0.02413294f, 
    -0.02531106f, -0.01638065f, 0.00841884f, 0.03322773f, -0.06370971f, 0.05599263f, -0.02213897f, 0.02634609f, 
    -0.04111281f, 0.10154967f, 0.07357252f, -0.07235720f, -0.02834012f, -0.08449380f, -0.00919540f, -0.08643005f, 
    0.24284075f, 0.13442585f, -0.06360738f, 0.05307527f, -0.05868756f, 0.05842882f, 0.00323741f, 0.01368822f, 
    0.00324768f, 0.03478189f, 0.01724510f, 0.15908296f, -0.04405602f, -0.00962424f, 0.02103311f, -0.08852801f, 
    0.21610913f, -0.11212797f, 0.08788782f, -0.15946561f, -0.13763747f, -0.00458863f, 0.02839536f, 0.04957085f, 
    0.05066572f, -0.03078157f, 0.01631522f, -0.05147908f, 0.05542201f, -0.07990605f, -0.03663517f, 0.13333060f, 
    0.00566194f, -0.05073454f, 0.02113046f, -0.04147791f, 0.18799528f, 0.19104041f, -0.12377249f, 0.17968613f, 
    -0.09722119f, 0.02796220f, 0.06966316f, 0.02708645f, 0.05760572f, -0.01191577f, 0.04513698f, 0.11381353f, 
    0.08870694f, 0.06135240f, 0.01866094f, -0.04527762f, 0.08422646f, 0.01055322f, 0.09350014f, 0.00081752f, 
    0.11498317f, 0.08799714f, 0.06402502f, -0.00696069f, -0.16378827f, -0.06938586f, 0.04078962f, -0.03427132f, 
    0.02420848f, 0.01620630f, 0.09187397f, 0.09519116f, 0.15027209f, -0.01350544f, -0.02861915f, 0.07035339f, 
    0.00370734f, 0.10749672f, 0.01659658f, 0.01542351f, 0.13273880f, -0.19205116f, 0.09412234f, -0.24969706f, 
    -0.00985465f, -0.02398945f, -0.06024708f, 0.07712028f, 0.02791902f, 0.08357183f, -0.05041871f, 0.07033793f, 
    -0.03278496f, 0.01344780f, -0.10774133f, 0.05255911f, -0.03771184f, 0.07948378f, 0.02813634f, 0.04321347f, 
    0.15057069f, 0.31854853f, 0.24590877f, -0.24781641f, -0.14641710f, 0.02484445f, 0.03649674f, 0.00806631f, 
    0.14017421f, 0.09884930f, 0.01435022f, 0.03329596f, -0.02106844f, 0.01867857f, 0.05220484f, 0.05093210f, 
    -0.06807411f, 0.03760307f, -0.01990733f, 0.09597100f, -0.22209308f, 0.15137984f, -0.17454277f, 0.18726063f, 
    -0.13255107f, -0.07981676f, 0.07498506f, -0.06256400f, 0.13217433f, -0.01223048f, 0.04447414f, 0.05410815f, 
    0.04158987f, 0.01888491f, 0.08009931f, 0.00118609f, -0.03037911f, -0.13211191f, -0.05778764f, 0.01746922f, 
    -0.04830577f, 0.00102313f, 0.04742228f, 0.04227546f, -0.03490569f, -0.00806299f, -0.01763042f, -0.03310900f, 
    0.03896704f, -0.00424028f, 0.03251313f, -0.03039750f, -0.05161139f, 0.02994110f, -0.03412212f, -0.06421602f, 
    -0.05944815f, -0.05424960f, 0.04276540f, 0.01465174f, -0.01249629f, -0.04348367f, 0.04339127f, -0.03688757f, 
    0.03036270f, 0.02939345f, 0.03533499f, -0.03804356f, -0.01520370f, 0.03032702f, -0.01331537f, -0.03695789f, 
    -0.05834352f, 0.04620900f, 0.03455288f, 0.04629473f, 0.03919095f, 0.01671554f, -0.02477773f, 0.01036715f, 
    0.00306616f, -0.02178046f, -0.00317361f, 0.02770292f, -0.01313916f, -0.05825708f, -0.01309870f, -0.01975362f, 
    0.02991623f, -0.02180446f, -0.00802384f, -0.05353943f, -0.01248694f, -0.00294638f, 0.03222084f, 0.00223697f, 
    -0.04292842f, -0.01416036f, 0.03261264f, 0.04188956f, 0.01862278f, 0.01757956f, -0.02913936f, -0.02075573f, 
    0.02309932f, 0.00630186f, -0.01760370f, 0.01758249f, -0.01408585f, 0.01830943f, -0.01795451f, -0.03533196f, 
    -0.00479553f, 0.02689953f, -0.03811113f, 0.00427968f, -0.01608384f, 0.01907887f, 0.00363150f, 0.01666120f, 
    0.01258388f, -0.04739638f, 0.01125603f, -0.02682919f, -0.04034156f, 0.03168485f, 0.03182101f, -0.02478680f, 
    0.01095665f, 0.03131308f, 0.04249928f, 0.02536401f, -0.01275840f, 0.02394750f, -0.06028995f, 0.02384333f, 
    -0.05958093f, -0.01810577f, 0.02124486f, 0.00490372f, -0.01964690f, -0.01679769f, -0.03175487f, -0.00274319f, 
    0.02421927f, -0.05781707f, 0.04045792f, -0.05637569f, 0.03755863f, -0.06149598f, -0.01287529f, -0.01643293f, 
    -0.03194503f, -0.01261940f, 0.00229948f, 0.00061797f, 0.00397759f, 0.01301413f, -0.04250204f, 0.00921328f, 
    -0.05763409f, 0.03480032f, -0.00067027f, -0.00148346f, 0.03493314f, 0.02808253f, 0.00314752f, -0.05900717f, 
    -0.03943104f, -0.04360495f, 0.00163933f, 0.02835953f, -0.00430301f, 0.04529505f, 0.00360768f, -0.03339045f, 
    -0.00536211f, 0.01331617f, -0.04307070f, -0.03946501f, 0.00180452f, -0.01641636f, 0.00186290f, -0.02047144f, 
    -0.02040415f, -0.04304729f, -0.02715134f, -0.00979272f, 0.01691937f, -0.01230167f, 0.00882707f, 0.00518275f, 
    -0.00681820f, -0.00781401f, 0.00041293f, 0.00343513f, 0.03008763f, 0.03904462f, 0.01300834f, 0.02986532f, 
    0.01567052f, 0.01184543f, 0.00176042f, -0.00915863f, 0.02564781f, 0.02470228f, -0.02391123f, -0.01957934f, 
    -0.02157621f, -0.04513659f, 0.02746130f, -0.05339669f, -0.05563125f, -0.04521012f, 0.01458632f, -0.02490190f, 
    0.04110732f, 0.02839146f, -0.03978468f, -0.05007876f, 0.00169362f, 0.01974780f, 0.00313101f, -0.01431404f, 
    -0.03396208f, -0.03555880f, 0.00519417f, -0.04217489f, 0.03976694f, 0.04280071f, -0.05735964f, -0.02946981f, 
    -0.04805842f, 0.04458398f, 0.00379646f, 0.04149773f, -0.00739392f, 0.04140466f, 0.03819920f, 0.00640733f, 
    0.01753844f, -0.03176527f, -0.05434549f, -0.02292380f, -0.01536741f, 0.00244684f, -0.03726678f, 0.01853459f, 
    -0.03049865f, 0.04564810f, -0.01911474f, 0.02758455f, -0.04876067f, 0.02840450f, -0.01689241f, 0.03309546f, 
    -0.05369050f, -0.02039296f, 0.02801740f, 0.03606457f, -0.02118661f, -0.00880758f, -0.05450406f, 0.03546371f, 
    -0.05427952f, 0.04218071f, -0.02148932f, 0.03162562f, -0.03102274f, 0.02321010f, -0.06403290f, -0.05889591f, 
    0.00890549f, 0.03685596f, -0.04678382f, 0.01023722f, -0.02740494f, 0.03123769f, -0.00442084f, -0.04683255f, 
    -0.01005704f, -0.04340941f, -0.04338691f, -0.02101746f, -0.02579921f, 0.01032105f, 0.02056566f, 0.02810395f, 
    -0.02809194f, -0.02365320f, -0.06070827f, -0.05240975f, -0.04664382f, -0.02968688f, -0.05297152f, 0.00299884f, 
    -0.03442712f, -0.00711826f, 0.00090951f, 0.00037315f, -0.00306038f, -0.03548162f, -0.03160675f, -0.00317749f, 
    -0.05279294f, 0.01295277f, -0.04935953f, 0.02773318f, 0.00904834f, 0.04151047f, -0.06118324f, -0.01525510f, 
    -0.02732916f, -0.04388265f, -0.05725417f, 0.01523881f, -0.02277778f, -0.05687875f, 0.04458334f, -0.04970617f, 
    0.04543797f, -0.05900801f, 0.03225859f, 0.00348600f, 0.04475745f, -0.02359192f, -0.01585905f, 0.01849283f, 
    -0.03914918f, -0.05989258f, 0.00778070f, -0.01656838f, -0.02360624f, -0.04503110f, -0.00084936f, 0.03175068f, 
    0.03337121f, 0.01208692f, 0.04410178f, -0.03929067f, -0.02301366f, -0.03487274f, -0.05575243f, -0.01204213f, 
    -0.02448272f, -0.00820241f, 0.00904808f, -0.02089136f, 0.03686110f, -0.00811749f, -0.04851288f, 0.01946304f, 
    -0.02962034f, -0.00542912f, -0.02362492f, 0.04606277f, -0.00170845f, 0.03487305f, -0.02740137f, -0.03236643f, 
    0.05217889f, -0.19342181f, -0.06633738f, -0.07424330f, -0.08392139f, -0.01389056f, -0.03636380f, -0.02984914f, 
    -0.04155980f, -0.06508911f, 0.15858790f, -0.04768361f, -0.07047959f, -0.03164504f, 0.03402262f, 0.01522391f, 
    0.01521740f, 0.17226902f, 0.12103443f, 0.10030255f, 0.21358028f, -0.15488563f, 0.18361546f, 0.06398374f, 
    0.14222513f, -0.09035361f, -0.13052836f, -0.05985809f, 0.02243873f, -0.03338208f, -0.08480409f, -0.06466679f, 
    -0.05469477f, 0.06936017f, 0.02372464f, -0.01215186f, -0.10032219f, 0.01739422f, 0.02316626f, 0.06648298f, 
    0.15220760f, -0.01448971f, -0.06174621f, -0.08904899f, -0.20358385f, -0.03310497f, 0.07779080f, 0.07992253f, 
    -0.14389373f, 0.01309474f, -0.00582857f, -0.00244385f, -0.07013445f, -0.14138576f, -0.04420017f, -0.03453141f, 
    -0.00287192f, -0.08933645f, 0.14198966f, -0.04619378f, 0.30436972f, 0.13437654f, -0.18081309f, 0.03343347f, 
    0.13463339f, -0.12921263f, -0.04826851f, 0.10275832f, 0.03671897f, -0.00487575f, 0.01971076f, -0.01614632f, 
    -0.08319372f, 0.07694439f, 0.00167206f, 0.06732860f, 0.03056448f, -0.00346329f, -0.01172645f, 0.03137379f, 
    0.44607595f, 0.02138079f, -0.11195402f, -0.08007482f, -0.10116044f, -0.12312215f, -0.00615997f, 0.01428654f, 
    -0.05608362f, 0.00281893f, -0.10795444f, 0.02140125f, -0.01493759f, 0.07224265f, -0.05676500f, 0.05467661f, 
    0.03665322f, -0.00259275f, 0.01233618f, 0.04980834f, 0.05241089f, 0.05867291f, -0.09524643f, -0.18679346f, 
    -0.08593682f, 0.01322853f, 0.00092416f, -0.08050188f, 0.03197599f, 0.06271716f, -0.05531583f, -0.02216190f, 
    -0.13424899f, -0.05838176f, 0.03268980f, 0.11174855f, 0.06497090f, -0.04558950f, -0.02901044f, -0.02106502f, 
    0.14406525f, 0.22372167f, 0.04984490f, -0.18694876f, -0.07987134f, -0.01479829f, 0.07936320f, -0.00136212f, 
    -0.02146452f, -0.04667757f, 0.01105600f, 0.05931105f, -0.07349227f, -0.14141786f, -0.10954041f, 0.09009119f, 
    -0.00023713f, -0.06918919f, 0.06940460f, 0.03208159f, 0.40476504f, -0.26084191f, -0.02862336f, -0.02249880f, 
    -0.08115278f, -0.11947424f, -0.08522521f, 0.03221339f, 0.02972598f, 0.03998883f, 0.11447672f, 0.10760074f, 
    -0.01780810f, 0.00588317f, -0.08028029f, 0.02566526f, 0.00290104f, -0.06075129f, -0.08352504f, -0.12702860f, 
    0.15403309f, -0.03054512f, 0.00335049f, -0.02580639f, 0.00347480f, 0.08488724f, 0.00382716f, 0.02359521f, 
    0.08598686f, 0.08386583f, -0.04501873f, 0.04820026f, -0.01933883f, 0.09687562f, -0.05390967f, -0.01605860f, 
    -0.07505138f, 0.17070055f, -0.19901356f, 0.00075643f, -0.11002307f, 0.17639290f, 0.06368484f, 0.03079318f, 
    0.09457349f, 0.15175037f, -0.05955981f, -0.01485752f, -0.01346793f, 0.00957884f, -0.06244054f, 0.06060163f, 
    -0.09423925f, 0.01106296f, 0.10483376f, 0.07829117f, 0.12523982f, 0.05400556f, -0.00744406f, -0.13336475f, 
    0.16885130f, -0.12451889f, 0.25746292f, -0.07639437f, 0.09124061f, 0.03342468f, -0.05471132f, 0.03057772f, 
    0.05995652f, 0.10574753f, -0.04791098f, -0.01670770f, 0.07455898f, 0.04722954f, -0.01687990f, 0.06349675f, 
    -0.08252696f, -0.02429326f, -0.08291150f, 0.11601206f, 0.13239039f, 0.06762899f, -0.07771008f, 0.03084470f, 
    0.09287329f, 0.04912120f, 0.04826568f, -0.03645338f, -0.00622178f, 0.06664354f, -0.00386633f, 0.00134449f, 
    -0.04231745f, -0.05921394f, -0.10735331f, 0.10663214f, 0.00996340f, 0.08697994f, 0.10571538f, 0.03726645f, 
    0.22025925f, 0.07069194f, 0.02198549f, -0.08672597f, 0.07686345f, -0.09219836f, -0.07745855f, -0.05619163f, 
    0.03988235f, 0.01593705f, 0.00316130f, 0.00961653f, 0.04763152f, 0.04619792f, 0.02305459f, 0.01541229f, 
    -0.03897946f, 0.01744449f, 0.01962616f, -0.00970245f, -0.19958888f, -0.01971617f, -0.10538375f, -0.04706009f, 
    0.04595138f, 0.07046447f, -0.09493335f, 0.12914385f, -0.00411088f, -0.01479423f, -0.00346386f, 0.05455503f, 
    -0.00025709f, 0.00617034f, 0.03791787f, -0.02943752f, 0.06351174f, -0.01957663f, -0.27383703f, -0.05563864f, 
    0.26813853f, -0.12618004f, 0.03547413f, -0.14390138f, 0.07348257f, 0.05128241f, -0.01022692f, 0.01401195f, 
    0.11472990f, 0.09791077f, -0.17799643f, -0.01411108f, -0.02320798f, 0.10858783f, -0.03336777f, -0.01402650f, 
    -0.07858967f, -0.11966762f, -0.07661939f, -0.02682038f, 0.00970032f, 0.07197897f, -0.18551123f, 0.06691180f, 
    0.05572722f, -0.11462494f, -0.00492755f, 0.09219373f, 0.02704964f, -0.10435647f, 0.07408999f, 0.02366690f, 
    0.01238012f, 0.03062486f, 0.01124630f, 0.14181161f, 0.01255414f, -0.10615098f, 0.09037182f, 0.11021310f, 
    -0.02714050f, -0.05988449f, 0.02526248f, -0.03401041f, 0.01886262f, 0.00728087f, -0.04633831f, 0.01076518f, 
    -0.03454996f, -0.04120022f, -0.00773085f, -0.05176800f, 0.01308608f, -0.02528275f, 0.03253220f, -0.01148871f, 
    -0.03072526f, 0.04676861f, 0.01549065f, -0.05569704f, -0.03425841f, 0.03906485f, -0.01522942f, -0.01363471f, 
    0.03149588f, -0.03757111f, 0.00743100f, 0.01477327f, 0.00356204f, -0.04766379f, -0.05711960f, -0.03646110f, 
    0.00088160f, -0.01882253f, -0.02976639f, -0.04388305f, -0.04861183f, 0.03986313f, 0.01186202f, -0.04595818f, 
    0.04725327f, -0.01065105f, -0.05546145f, -0.04872742f, -0.00891704f, 0.01180864f, 0.04599328f, -0.00988567f, 
    -0.04314545f, -0.04181728f, 0.01523345f, -0.03772143f, -0.02123201f, 0.03323540f, 0.00997240f, -0.01395356f, 
    -0.04939571f, 0.04528181f, 0.01779467f, -0.01645419f, 0.03563382f, -0.00098575f, 0.03849467f, 0.01213393f, 
    0.01899789f, 0.00483266f, 0.04980432f, -0.00420786f, 0.00469738f, -0.03254019f, 0.02687422f, 0.01521178f, 
    0.05444772f, -0.05749093f, -0.05264169f, 0.03383160f, -0.04383693f, -0.00827061f, 0.00718544f, -0.02596152f, 
    -0.03772927f, -0.03993731f, 0.04401587f, -0.02009794f, -0.04587293f, -0.00489864f, -0.05052784f, -0.01623200f, 
    0.04727941f, 0.01896423f, 0.02510701f, 0.02415354f, 0.00004942f, 0.02259891f, 0.03830908f, -0.04121057f, 
    -0.00117126f, 0.02910819f, 0.00762362f, 0.00714744f, 0.02915228f, -0.04458297f, -0.03817055f, -0.03338981f, 
    0.03197972f, -0.03987756f, 0.03421419f, 0.03273543f, -0.03035344f, 0.02232560f, -0.00030936f, 0.01880904f, 
    -0.00285324f, 0.04648620f, -0.01261470f, -0.04495811f, -0.03636061f, -0.04261011f, 0.00294037f, -0.05034056f, 
    -0.00605826f, 0.01642353f, 0.01020674f, -0.00232154f, -0.03031907f, -0.04010120f, -0.04769641f, -0.01258831f, 
    0.04758214f, -0.00609081f, 0.04821838f, -0.04926451f, -0.02159700f, -0.01983623f, -0.01959774f, -0.06187588f, 
    -0.04195623f, -0.03992813f, 0.02936571f, 0.04560217f, -0.05425444f, -0.04465631f, 0.00528583f, 0.01784098f, 
    -0.05255333f, 0.02807636f, 0.02705193f, 0.01315800f, -0.02906120f, -0.03646497f, 0.01234964f, -0.05695757f, 
    0.01506401f, 0.03234083f, 0.04202669f, -0.03847913f, -0.03345472f, -0.00036652f, -0.02010022f, -0.00452942f, 
    0.00450628f, 0.02010418f, 0.00503889f, -0.03497303f, 0.00918664f, 0.01125475f, -0.03705686f, 0.00340835f, 
    0.04581913f, 0.02878553f, -0.03554673f, -0.01398051f, 0.03080112f, -0.04780313f, -0.01700019f, -0.00060048f, 
    -0.04195784f, 0.04719933f, -0.00696111f, -0.01253611f, -0.04205870f, 0.00615093f, -0.02759854f, 0.01887815f, 
    0.00655759f, 0.01259519f, -0.04560671f, -0.05056365f, -0.05416477f, -0.03639801f, -0.02324935f, -0.04371336f, 
    -0.04205523f, -0.03278346f, -0.05610221f, 0.03105235f, 0.02219450f, -0.05371893f, -0.00786329f, 0.04752645f, 
    0.04194465f, 0.00857536f, 0.04991791f, 0.01393412f, 0.04185366f, 0.02239202f, 0.00269772f, 0.00897630f, 
    -0.05037947f, 0.00859793f, -0.03844324f, 0.02940746f, 0.02076270f, -0.06083858f, -0.04394719f, -0.05397173f, 
    -0.04285975f, 0.03052980f, -0.00910197f, -0.02947055f, 0.04330184f, 0.00121174f, -0.02628907f, 0.05073675f, 
    0.02088715f, -0.02877565f, -0.05887862f, -0.02927102f, -0.03211229f, -0.02400345f, 0.01931280f, 0.04820351f, 
    0.02479973f, -0.05560910f, -0.04892769f, -0.06229703f, 0.03650844f, 0.00613139f, 0.03094381f, 0.04739643f, 
    -0.02752381f, 0.02391544f, 0.00665728f, -0.03780614f, -0.00370536f, -0.02068946f, 0.00438077f, -0.05404876f, 
    0.00176161f, 0.04798619f, 0.03318698f, 0.01647003f, -0.04491848f, 0.03002844f, -0.03920528f, -0.03234380f, 
    0.04577072f, -0.05501756f, -0.00599347f, -0.03161230f, -0.05088104f, 0.03377433f, -0.03330227f, -0.03475837f, 
    -0.04173511f, -0.05004090f, -0.04035110f, -0.01477247f, 0.00913665f, 0.02094172f, -0.02641703f, 0.01766191f, 
    0.04405056f, -0.01460839f, 0.05194619f, 0.04058865f, -0.02404286f, 0.04516650f, -0.00630869f, 0.00775739f, 
    -0.02659104f, -0.02376384f, -0.02896874f, -0.00678321f, -0.01071221f, -0.05676841f, 0.03534612f, 0.01925025f, 
    -0.04292969f, 0.02318129f, 0.04401424f, 0.01805411f, -0.03107423f, -0.04236307f, -0.05145125f, -0.02954282f, 
    -0.04323236f, -0.02695162f, -0.05616390f, -0.01862190f, -0.03239651f, -0.01204319f, -0.01281308f, 0.02548594f, 
    -0.03501318f, 0.03372873f, 0.00703929f, 0.04664823f, 0.01511677f, -0.03622733f, 0.04366981f, -0.04813815f, 
    0.03675435f, -0.02616921f, 0.03359042f, -0.03549527f, 0.01980172f, -0.03477358f, 0.02488033f, 0.04068456f, 
    -0.26859245f, -0.43612939f, 0.08017598f, 0.19557096f, -0.16060261f, -0.05778949f, -0.09772402f, -0.11417788f, 
    0.09545230f, -0.00093016f, 0.02622527f, 0.07777578f, -0.03710107f, 0.01553347f, 0.09328517f, -0.00965698f, 
    0.03009289f, 0.04399149f, 0.00190043f, -0.02989416f, -0.20785181f, -0.12225611f, -0.00131410f, 0.03764195f, 
    -0.13574654f, 0.10889481f, -0.21609178f, -0.02324421f, 0.03187708f, 0.10654425f, 0.01100598f, 0.01296710f, 
    0.03899973f, -0.03214286f, -0.00854642f, -0.03102361f, -0.03074216f, 0.05671490f, 0.10955466f, -0.01181555f, 
    -0.14477359f, -0.31905833f, 0.04853291f, 0.12975478f, -0.10694604f, -0.13855775f, -0.13176484f, -0.09282272f, 
    -0.02954348f, -0.01897486f, 0.14873876f, 0.05113241f, -0.03901801f, 0.00036748f, 0.03502958f, 0.08215313f, 
    0.04346289f, -0.19404155f, -0.00588057f, 0.04546176f, 0.25071061f, -0.14709112f, -0.05945523f, 0.09431607f, 
    -0.14257178f, -0.00928392f, 0.05716400f, -0.09477495f, -0.06238097f, -0.03580091f, 0.09415469f, 0.02184785f, 
    0.09601633f, 0.07123648f, 0.08476190f, 0.04232593f, -0.12108082f, 0.04062753f, 0.12985374f, 0.12126197f, 
    -0.03430738f, -0.13003688f, -0.04685486f, -0.12545902f, -0.29240733f, -0.11467017f, 0.00558982f, 0.03300888f, 
    0.15698634f, 0.06479805f, -0.05663380f, 0.05757254f, -0.13207397f, 0.05856666f, 0.07153518f, -0.04267580f, 
    -0.07101160f, 0.03541616f, -0.01539341f, -0.03666028f, -0.12423249f, -0.14397205f, -0.08186531f, -0.19117542f, 
    0.19996813f, -0.14934091f, 0.09852378f, -0.05279814f, -0.06342191f, 0.03367092f, -0.01647036f, -0.04546963f, 
    0.07806244f, -0.18164745f, 0.00591116f, -0.07520596f, -0.04624600f, 0.01770142f, -0.02450816f, 0.08765297f, 
    -0.15342762f, -0.14890203f, -0.02950319f, -0.13693388f, 0.05173832f, -0.03798854f, 0.07128697f, 0.00044953f, 
    0.01778666f, 0.04092567f, -0.07333799f, -0.03880861f, -0.00122510f, -0.03511314f, 0.08224540f, -0.06769779f, 
    0.03613079f, 0.01017039f, -0.07755293f, -0.03894422f, -0.08355640f, 0.09266269f, 0.28933850f, -0.14666849f, 
    0.04240610f, 0.05780748f, 0.06147646f, 0.08959875f, -0.03968775f, 0.06679755f, 0.03252055f, 0.01626278f, 
    0.00981678f, 0.00840970f, -0.12039954f, -0.00318853f, 0.07003542f, 0.06477812f, 0.09219712f, -0.01125938f, 
    0.07700413f, 0.10558420f, 0.07908671f, -0.22088394f, 0.16195457f, -0.04990553f, -0.04271760f, 0.02494922f, 
    0.06066178f, 0.00042213f, 0.02640592f, 0.08623127f, 0.00910108f, 0.00586292f, 0.03242548f, -0.08989211f, 
    0.03226823f, 0.12564358f, 0.06931093f, 0.15695025f, -0.11257403f, -0.06281204f, 0.09791588f, 0.01235216f, 
    -0.20170856f, -0.04888641f, -0.11101364f, 0.06897642f, 0.00697792f, -0.00354566f, -0.02484683f, -0.05065395f, 
    -0.04994071f, 0.07408611f, 0.12703879f, 0.14497003f, -0.01998362f, 0.01900214f, 0.01836516f, 0.08239208f, 
    -0.09405815f, 0.26643291f, 0.09090483f, 0.05325705f, -0.09541161f, 0.01956688f, 0.00813116f, 0.05272269f, 
    -0.08135680f, 0.10386889f, 0.07782319f, -0.04475418f, 0.03476411f, -0.02539841f, 0.07043673f, 0.06450360f, 
    0.06026726f, 0.02245573f, 0.06776977f, -0.00643398f, -0.04775997f, -0.04600363f, -0.09881135f, 0.03575625f, 
    -0.12623166f, -0.04968498f, 0.00186196f, -0.03013871f, -0.02770001f, 0.08117954f, -0.03969241f, 0.11405548f, 
    0.01288113f, -0.02155346f, 0.03286128f, 0.04764251f, 0.07082331f, 0.12020465f, -0.03352993f, 0.04250047f, 
    0.10466462f, 0.15330167f, -0.14173838f, 0.04903751f, -0.12140764f, -0.04729239f, -0.03645451f, -0.07723670f, 
    0.10699106f, -0.02137907f, 0.09365587f, 0.06014197f, -0.05044850f, -0.06931638f, 0.10513205f, 0.06196790f, 
    0.01454699f, 0.16037096f, 0.03522944f, 0.08646543f, 0.15562053f, 0.10849930f, 0.13133116f, -0.12594713f, 
    0.28186110f, 0.06192748f, 0.02030032f, 0.08803498f, 0.00484357f, -0.13454397f, -0.01000888f, 0.11965877f, 
    0.05984439f, 0.05712994f, 0.03265488f, 0.11810874f, 0.04710282f, 0.12025695f, -0.03292386f, 0.06768579f, 
    0.13124403f, 0.40507910f, 0.20746543f, -0.12482251f, 0.20438878f, 0.09391782f, -0.07027242f, 0.09056744f, 
    0.01741595f, 0.14018309f, 0.18086836f, -0.11129823f, -0.08577493f, -0.02357811f, -0.01307340f, 0.03227016f, 
    0.10274489f, -0.02448189f, 0.21200180f, 0.07819822f, 0.16180424f, -0.10192414f, -0.13349918f, 0.20341708f, 
    -0.07535161f, -0.05122738f, 0.02498847f, 0.00169325f, 0.04618610f, 0.13989796f, 0.10927111f, 0.08785721f, 
    0.10026142f, 0.02870277f, -0.02901130f, 0.00127091f, -0.03276168f, -0.04401327f, -0.05106253f, 0.00879347f, 
    -0.03432380f, 0.03430064f, -0.01880520f, 0.03321473f, -0.03516255f, 0.02780831f, 0.02123313f, 0.02220276f, 
    -0.02696361f, 0.02342026f, -0.01205640f, 0.02898844f, -0.02354441f, -0.00120076f, 0.00256710f, -0.04447109f, 
    0.00413839f, -0.01822274f, 0.03007216f, 0.00793347f, -0.04345463f, 0.02808827f, -0.02019729f, 0.04890027f, 
    -0.00311781f, 0.04606042f, -0.02450576f, -0.01101844f, -0.04627601f, 0.02595524f, -0.01426027f, 0.01225314f, 
    -0.03470119f, 0.00840790f, -0.02960750f, -0.03652099f, -0.03567529f, 0.00694803f, -0.02873163f, -0.00349884f, 
    -0.05070834f, -0.01270480f, 0.01407189f, -0.03125240f, -0.05061544f, -0.03930383f, 0.04113790f, -0.03534566f, 
    0.03429125f, -0.04257857f, -0.05012582f, 0.00399341f, 0.02220417f, -0.04722100f, 0.01432735f, -0.03749655f, 
    0.02961007f, 0.01281201f, -0.01382017f, -0.01497889f, -0.02945562f, -0.04508020f, 0.03355117f, -0.05492145f, 
    0.01628699f, -0.01301319f, -0.02604417f, -0.02611809f, -0.02890514f, 0.01069195f, 0.05159713f, 0.02642058f, 
    -0.01228869f, 0.01700004f, 0.05224591f, -0.00242826f, -0.04880097f, 0.00972700f, 0.04102072f, -0.04314000f, 
    0.03830750f, 0.01469717f, 0.04988056f, -0.01674856f, 0.03844133f, 0.01969486f, 0.02476085f, 0.03668684f, 
    -0.04043045f, -0.01123364f, 0.04871053f, 0.03251819f, 0.05473874f, -0.04146895f, -0.02327027f, -0.01990167f, 
    0.05389396f, -0.04803535f, 0.02551541f, 0.02729851f, 0.02818412f, -0.04083651f, -0.00799486f, -0.03300462f, 
    -0.05281043f, -0.04724629f, -0.04754632f, 0.04317227f, -0.00341423f, 0.04360717f, -0.05055035f, 0.04086350f, 
    0.02498556f, -0.00158899f, 0.04761138f, 0.00856992f, 0.01829665f, -0.02914560f, 0.00351943f, -0.05532176f, 
    0.03989870f, 0.02015721f, -0.00765726f, -0.02993081f, 0.00143811f, -0.02207618f, 0.04454099f, 0.03391896f, 
    0.04647143f, 0.00063091f, 0.05319012f, -0.03358987f, -0.04230674f, 0.04788058f, 0.00779317f, 0.03692428f, 
    -0.00999256f, -0.04607064f, -0.02555707f, 0.00479007f, 0.04288178f, -0.05505328f, 0.02028951f, 0.01863721f, 
    0.01094814f, 0.04091315f, -0.05286658f, 0.00942110f, 0.02249771f, -0.02993581f, 0.02185729f, -0.01562422f, 
    0.02767091f, 0.05000488f, 0.00376176f, 0.00958698f, -0.02683638f, -0.00260098f, 0.03852019f, -0.04310810f, 
    -0.02095274f, 0.03412919f, -0.05386306f, -0.05358168f, -0.01625203f, -0.03315599f, -0.03194711f, -0.01014583f, 
    -0.02094495f, -0.01190548f, 0.03986688f, -0.04147475f, 0.01412809f, 0.01496851f, -0.02640610f, -0.00485823f, 
    -0.03569295f, 0.00613403f, 0.04427331f, -0.03047194f, -0.03974598f, 0.04717321f, 0.01688541f, 0.01416208f, 
    -0.04203794f, 0.03312234f, 0.00623557f, 0.04575548f, 0.02221820f, 0.01387040f, -0.04071354f, -0.00257771f, 
    0.02348429f, 0.04102502f, 0.00471812f, -0.04037016f, -0.02592787f, 0.02023605f, -0.04858391f, 0.03378748f, 
    -0.03057513f, -0.02184202f, -0.02234825f, -0.03924968f, 0.02983001f, -0.02568267f, -0.01962987f, -0.04641627f, 
    0.03960153f, 0.02521890f, 0.04417221f, 0.03079576f, -0.03962240f, 0.03530049f, -0.00142615f, -0.05347515f, 
    -0.05280193f, -0.01368773f, -0.02252967f, 0.02202396f, -0.05199971f, 0.04895162f, -0.02147938f, 0.01030731f, 
    0.05498851f, -0.01769887f, -0.00973333f, 0.01687501f, -0.00465930f, 0.01975369f, -0.03862864f, -0.01622190f, 
    -0.03284487f, -0.03631416f, -0.04969646f, 0.03646570f, -0.03045216f, -0.01118978f, -0.05399734f, 0.01648857f, 
    0.03929603f, -0.00632873f, -0.02124977f, -0.02947638f, 0.01305719f, -0.01286491f, -0.05331785f, -0.00934654f, 
    0.01339898f, 0.04061858f, 0.03112015f, -0.02677505f, -0.03590301f, -0.04406280f, -0.05485630f, -0.04864482f, 
    -0.01998989f, -0.05466751f, 0.04865818f, -0.05612719f, -0.04706412f, 0.02423810f, -0.02427102f, 0.02493930f, 
    0.02415299f, -0.03825439f, 0.00464401f, -0.03395998f, 0.04063372f, -0.03125839f, -0.02074570f, -0.04758372f, 
    -0.04376719f, 0.00563850f, -0.02034031f, -0.03787658f, 0.01790507f, 0.00731432f, -0.00822353f, -0.01139164f, 
    -0.02798168f, -0.00172143f, -0.03843224f, 0.03349362f, -0.00079423f, -0.01581333f, -0.00290714f, 0.03802445f, 
    -0.01133873f, -0.02931314f, 0.03525301f, 0.05083170f, 0.04889690f, -0.02235334f, 0.05395627f, -0.04709232f, 
    -0.04866545f, -0.04813811f, 0.01605664f, 0.01374299f, -0.01374904f, -0.03671281f, -0.02403262f, 0.01822496f, 
    -0.01432494f, 0.01003176f, -0.03794605f, -0.00804989f, -0.02089438f, -0.05261536f, -0.03631148f, 0.00988045f, 
    -0.01811814f, -0.01713800f, 0.02198401f, 0.04056333f, -0.04243674f, -0.02972437f, -0.02529847f, -0.02478459f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00428776f, -0.01130951f, 0.02206418f, 0.10843407f, 0.06897286f, 0.08085972f, 0.01609139f, -0.00864705f, 
    0.01896778f, 0.00391898f, -0.00430901f, -0.03339557f, -0.04989894f, -0.01248604f, -0.03556110f, 0.00073928f, 
    0.02858332f, 0.08268631f, 0.03418266f, 0.00924409f, 0.03465138f, 0.00270995f, 0.03160045f, 0.00831867f, 
    0.02529002f, 0.00261825f, -0.02346846f, 0.03882165f, 0.08040293f, -0.00823233f, -0.00968175f, 0.00918304f, 
    0.04451646f, 0.00060130f, -0.00831611f, 0.07153591f, 0.01268105f, 0.01630250f, 0.10225223f, -0.02447062f, 
    0.10325705f, 0.04581647f, 0.00288116f, 0.06449698f, 0.04833632f, 0.13682029f, -0.00114982f, -0.00134415f, 
    -0.04232926f, 0.04115597f, 0.08871525f, 0.03018351f, -0.02474837f, -0.01506923f, 0.09714884f, 0.04640637f, 
    -0.01096690f, -0.04779033f, 0.01746877f, -0.04613188f, 0.05241916f, 0.04297892f, 0.01369831f, 0.01377223f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10129555f, 0.10805916f, 0.01095365f, -0.15057214f, 0.05832306f, -0.06050669f, 0.05806823f, 0.26250595f, 
    0.08886430f, 0.12871194f, -0.11864164f, -0.02186226f, -0.07756963f, 0.03738075f, -0.17797571f, 0.07717051f, 
    0.04368772f, 0.01285922f, -0.09504989f, 0.02025033f, -0.07154984f, 0.03206373f, -0.02670116f, 0.17563742f, 
    -0.19807154f, -0.11823911f, 0.13887820f, 0.05235395f, -0.03096491f, -0.06857751f, 0.09872914f, -0.01927174f, 
    0.04309186f, 0.25715259f, 0.06850432f, 0.10583320f, 0.23007807f, 0.21677038f, -0.04721402f, 0.33346346f, 
    0.10038303f, 0.03126598f, 0.10824234f, -0.19978228f, 0.10241605f, 0.13488948f, 0.11782877f, 0.12820753f, 
    0.01115550f, 0.02365525f, -0.08589201f, 0.00513709f, -0.11175046f, 0.06059678f, 0.29633620f, 0.28198275f, 
    0.27422506f, 0.07125724f, 0.22471024f, 0.07322894f, 0.11785552f, 0.00213208f, -0.26374432f, -0.07009296f, 
    0.04830064f, -0.11559514f, -0.05212880f, 0.25854838f, 0.19994360f, 0.24544308f, 0.10369230f, -0.25322220f, 
    -0.06752001f, 0.04256887f, 0.03913847f, 0.16708334f, 0.07941285f, 0.07335933f, 0.20810992f, -0.04913207f, 
    0.00028606f, 0.03409018f, -0.43423802f, -0.02887636f, 0.09801123f, 0.26627249f, -0.03460464f, -0.29028669f, 
    0.25210443f, 0.09420924f, -0.21599296f, 0.15406089f, -0.11331947f, 0.09849967f, 0.07050426f, -0.04187672f, 
    -0.17628148f, -0.26998869f, 0.10270031f, -0.06987627f, 0.21157312f, -0.00033222f, 0.14441499f, 0.08378057f, 
    0.12473918f, 0.03914291f, 0.15019551f, -0.18652613f, -0.21133792f, 0.05876260f, -0.19800857f, -0.12018113f, 
    -0.08704939f, 0.05784458f, 0.14407153f, -0.00783989f, -0.11046015f, -0.11044906f, 0.17674181f, 0.17297052f, 
    -0.30871680f, 0.11869182f, 0.12958112f, -0.00719108f, -0.26039314f, 0.01565086f, 0.20754224f, 0.05046852f, 
    -0.03242309f, -0.06556074f, -0.05608019f, -0.10321716f, -0.08810212f, -0.07975354f, 0.05290490f, -0.00280826f, 
    0.08083982f, 0.03522441f, 0.04696321f, 0.07401913f, 0.06585847f, 0.08225816f, -0.00847977f, 0.04705238f, 
    0.04129958f, 0.01908706f, 0.09216374f, 0.00534193f, -0.10486483f, 0.03682252f, 0.00441436f, 0.01839227f, 
    0.07094044f, -0.00840682f, -0.12860706f, -0.06990007f, -0.08144162f, -0.07646640f, -0.08615284f, -0.05488752f, 
    -0.07929843f, -0.11231180f, -0.03360976f, -0.04409675f, -0.12340543f, 0.07437290f, 0.04980838f, 0.04296640f, 
    -0.10850468f, 0.03225521f, 0.00942919f, -0.08491098f, -0.11750437f, 0.10550281f, 0.01320503f, 0.02057125f, 
    0.02452252f, -0.00063826f, -0.11937118f, 0.11600471f, -0.11368145f, 0.01507982f, -0.04417147f, -0.08660103f, 
    -0.07012176f, -0.03599153f, 0.00968047f, -0.00477141f, -0.04673627f, -0.06537318f, 0.08194547f, 0.05298205f, 
    -0.13440432f, 0.05903526f, -0.07610591f, 0.04507307f, -0.08760395f, -0.08507560f, -0.01338741f, -0.05472731f, 
    -0.04661565f, -0.05707675f, -0.06827018f, -0.06029234f, -0.07402393f, -0.02903384f, -0.10824864f, 0.10328051f, 
    -0.00824697f, -0.01994730f, -0.03291958f, -0.00661221f, -0.04092665f, 0.07746916f, 0.04906250f, -0.03719008f, 
    0.08199971f, -0.10130926f, -0.09746782f, 0.07011263f, -0.03643176f, 0.05115846f, -0.09052852f, -0.08271332f, 
    -0.10452010f, -0.11194779f, 0.02838087f, -0.00502188f, 0.03774947f, 0.08436099f, -0.03206389f, -0.05843629f, 
    -0.05830878f, -0.10104988f, 0.02537169f, 0.05004748f, -0.03135369f, -0.05868348f, 0.01861627f, -0.02885456f, 
    0.09028907f, 0.01919885f, 0.06076517f, 0.07144316f, -0.02559202f, -0.10983311f, -0.11017175f, 0.10586334f, 
    0.04538742f, -0.07839042f, 0.11521297f, 0.01160417f, 0.07954755f, -0.11902416f, 0.09768839f, -0.12091076f, 
    0.05094596f, -0.08907814f, 0.07233247f, -0.18714514f, 0.15248984f, 0.04210191f, 0.11957166f, 0.01849860f, 
    -0.22560935f, -0.08423690f, 0.14708377f, 0.21731655f, 0.00330030f, 0.11006121f, 0.26947516f, 0.11119547f, 
    -0.03359260f, 0.12407989f, 0.16612947f, 0.06376936f, 0.15495986f, 0.22527251f, -0.06147254f, 0.33911234f, 
    0.05889719f, 0.07297327f, 0.12515485f, 0.05614792f, -0.18313594f, 0.00311793f, -0.04966468f, -0.10562199f, 
    0.10870958f, -0.18117566f, 0.10500675f, -0.02760448f, -0.00709169f, -0.08809639f, 0.04704123f, 0.15153626f, 
    -0.16948433f, -0.13959880f, -0.17784649f, 0.05846029f, -0.17627604f, 0.12550387f, 0.29591367f, -0.05379339f, 
    0.20957075f, -0.06156580f, 0.16046341f, -0.08847054f, -0.11802725f, -0.08511398f, 0.01457201f, -0.18305358f, 
    -0.10232895f, -0.11329945f, 0.15460463f, 0.00694720f, 0.26565745f, -0.05707142f, 0.13980766f, -0.06314947f, 
    0.12047087f, 0.25238019f, -0.06155081f, 0.19224593f, 0.04134135f, -0.10122865f, -0.00536659f, 0.05170292f, 
    0.18606181f, 0.03482375f, -0.08035871f, -0.05885264f, 0.05364783f, 0.04709951f, 0.16909516f, 0.05007988f, 
    -0.21438365f, -0.07010790f, 0.27735043f, -0.18960366f, -0.13087672f, -0.11934397f, 0.01960310f, 0.24109541f, 
    -0.30264506f, -0.08203290f, -0.15361594f, 0.04557496f, 0.19834363f, -0.16482002f, 0.00725741f, 0.10244845f, 
    0.18153904f, 0.08414059f, 0.10322699f, 0.07274386f, 0.01770798f, 0.26006931f, -0.01486536f, -0.14206460f, 
    0.02317316f, -0.17158905f, 0.13792235f, 0.02347779f, 0.08405828f, 0.17044377f, 0.11416570f, -0.09142245f, 
    -0.15970981f, 0.07577464f, 0.10711984f, 0.09236659f, -0.08519340f, 0.22911149f, 0.21538062f, -0.05836599f, 
    0.27770689f, 0.04973211f, -0.06305992f, 0.04534813f, 0.46412021f, -0.07807441f, -0.09960462f, -0.02049112f, 
    0.07484620f, 0.07623845f, -0.09813078f, 0.17858422f, 0.16132863f, 0.10656460f, 0.05264363f, -0.11344136f, 
    0.01383118f, 0.04870792f, 0.17931981f, 0.12942356f, -0.10357003f, 0.09455377f, 0.08661600f, 0.10075460f, 
    0.04108495f, -0.10109351f, -0.10473081f, -0.01267775f, 0.07715113f, 0.11483034f, 0.14331537f, -0.26207626f, 
    0.19010779f, 0.06698856f, -0.13319045f, 0.24953856f, 0.05068857f, 0.07049111f, 0.06329650f, 0.00376171f, 
    -0.20957644f, -0.11726557f, -0.02409684f, 0.08926866f, -0.02674902f, -0.09642678f, 0.22117938f, 0.22170919f, 
    0.29849252f, 0.14441440f, 0.13771418f, 0.04837701f, -0.01681984f, 0.11164595f, -0.32883501f, -0.07885236f, 
    -0.28586987f, -0.02528067f, 0.06277577f, -0.04923047f, -0.09520802f, -0.04967579f, 0.25498280f, -0.04142222f, 
    -0.17602907f, -0.02352349f, -0.15145160f, -0.04800916f, -0.44707951f, -0.01608662f, -0.02494557f, 0.01929341f, 
    0.10084270f, -0.15803319f, -0.01335437f, -0.17384760f, -0.03724037f, -0.11539497f, -0.02108512f, -0.02538116f, 
    0.05533901f, -0.12562980f, -0.11338762f, 0.25159341f, 0.01625039f, 0.10175163f, -0.08624848f, -0.11029595f, 
    -0.00171789f, 0.26355273f, -0.14843345f, 0.05059924f, 0.03476673f, 0.15932515f, -0.13646773f, 0.18336569f, 
    0.21963525f, 0.09538555f, 0.08380598f, 0.07848401f, -0.25213280f, -0.13351668f, 0.10652576f, -0.07519925f, 
    -0.09377614f, 0.04543143f, -0.05211658f, -0.00577482f, 0.03305846f, 0.04601401f, -0.15417436f, 0.30893078f, 
    -0.00897500f, 0.22778037f, 0.00165515f, -0.04733373f, -0.00388402f, 0.14277166f, 0.26930702f, 0.10492393f, 
    0.07241841f, -0.08682353f, 0.07887383f, 0.09050180f, 0.12079839f, -0.02755822f, -0.00917338f, 0.22817403f, 
    -0.18600287f, -0.06031569f, 0.40440115f, -0.05164390f, -0.00082244f, 0.10640208f, 0.19154769f, -0.01815096f, 
    0.14277063f, -0.04306863f, -0.09130782f, -0.19351564f, -0.15028384f, 0.17144369f, 0.03346811f, 0.06561714f, 
    0.08957516f, 0.02394386f, -0.53336662f, 0.22934130f, 0.07634228f, 0.00642142f, -0.16530640f, -0.10877699f, 
    -0.09632885f, -0.12352069f, 0.12123378f, -0.32114726f, 0.23213063f, -0.46522832f, -0.05129028f, 0.18597318f, 
    0.10417284f, 0.22786213f, 0.12121592f, -0.03097137f, 0.26471707f, 0.12033648f, -0.07484445f, -0.09256893f, 
    -0.20723632f, 0.22467542f, 0.07595012f, -0.21142201f, -0.10192243f, 0.02706120f, 0.36133146f, 0.13544583f, 
    0.01031110f, -0.03098989f, 0.12764555f, 0.08941054f, 0.17642379f, -0.02897479f, -0.14985979f, 0.06934774f, 
    0.20165783f, 0.11534819f, 0.04617099f, -0.04798466f, -0.10153421f, -0.05535277f, -0.20644170f, -0.21368340f, 
    -0.33393145f, -0.07926385f, -0.20379813f, 0.02840689f, 0.02384537f, 0.02933186f, -0.09326328f, -0.02244316f, 
    0.08480617f, 0.26419219f, -0.05665548f, 0.13044670f, 0.11919253f, -0.09242182f, -0.02980641f, 0.07179310f, 
    0.12700567f, -0.00843562f, 0.09153683f, -0.00386117f, -0.00499108f, -0.06148776f, -0.05392689f, -0.06263661f, 
    0.02626794f, 0.12867439f, 0.03005036f, 0.32569200f, -0.11331166f, -0.16997382f, 0.23565488f, -0.16915281f, 
    -0.10781987f, -0.11875776f, -0.22503169f, 0.07331645f, 0.13552356f, 0.09338973f, 0.10314228f, 0.00405483f, 
    0.09220121f, 0.10966168f, 0.05509165f, 0.00981627f, 0.07855933f, 0.14244623f, -0.13111788f, -0.01171517f, 
    0.15827435f, 0.06801853f, 0.07351756f, 0.01190474f, 0.08264043f, 0.01031091f, -0.08366180f, -0.02008057f, 
    -0.17583777f, -0.07376576f, -0.04404791f, -0.07078625f, -0.11508267f, -0.11624356f, 0.15088768f, -0.05057196f, 
    0.19753329f, -0.09025883f, -0.09456120f, -0.09209640f, -0.00005826f, 0.00336904f, -0.09595684f, 0.10173807f, 
    -0.08112223f, 0.06237392f, -0.07600370f, 0.15335293f, -0.02362419f, -0.12341748f, 0.07968710f, -0.30579865f, 
    0.04704487f, 0.11925567f, -0.20992538f, 0.15459555f, 0.05773419f, -0.06768598f, 0.19225167f, 0.08731362f, 
    -0.21369508f, 0.03149537f, 0.02424974f, -0.04998480f, 0.13357583f, -0.04561346f, 0.19501421f, -0.22439428f, 
    0.17896071f, 0.21834634f, 0.03830850f, 0.20419651f, 0.14774406f, -0.09797986f, -0.03408292f, 0.09844192f, 
    -0.08794565f, 0.04382779f, -0.06735312f, -0.20834073f, 0.09761159f, 0.05023732f, -0.13310112f, 0.01914276f, 
    0.14868551f, 0.14102183f, 0.19109146f, 0.03049679f, 0.17430019f, 0.19109513f, -0.13362253f, 0.06673191f, 
    -0.19354272f, -0.01196562f, 0.27080369f, 0.07979733f, 0.06084439f, -0.28855410f, -0.09267009f, -0.03049549f, 
    0.08737046f, 0.00646424f, -0.20751648f, -0.03406876f, -0.15561582f, -0.00664641f, 0.12863337f, -0.01643730f, 
    0.25371045f, 0.00566074f, -0.05865756f, 0.14370659f, 0.20972842f, 0.21773569f, 0.09092098f, 0.08411298f, 
    0.11672531f, -0.02330895f, 0.11084914f, -0.03700169f, 0.05835090f, -0.11392460f, -0.16998556f, 0.10900151f, 
    0.25557193f, -0.01148868f, -0.17442726f, -0.12057576f, -0.08913695f, -0.06964296f, -0.06898322f, -0.01595103f, 
    0.00313149f, -0.02251531f, -0.09016955f, 0.05207243f, -0.03813517f, 0.17641431f, -0.06524840f, -0.00843332f, 
    -0.14193591f, -0.02050007f, -0.06323174f, 0.21070307f, -0.08601083f, -0.09624305f, 0.21880572f, 0.09911814f, 
    0.30259243f, -0.04574950f, 0.02733413f, 0.08886797f, 0.10917930f, 0.00587839f, -0.28043473f, -0.10021442f, 
    -0.22154905f, 0.05703835f, 0.12004408f, -0.04343915f, 0.12739241f, -0.04914969f, 0.29334962f, 0.22615828f, 
    -0.11993094f, -0.09666213f, -0.03893223f, 0.07622624f, -0.20797178f, -0.07467531f, -0.10649323f, -0.01932195f, 
    -0.17724651f, 0.10424875f, -0.05272954f, 0.10467539f, 0.11304265f, 0.00004327f, 0.11261258f, -0.21176983f, 
    -0.04365132f, 0.11694047f, 0.30571964f, 0.10161363f, 0.09151947f, -0.04093427f, 0.30546159f, -0.04521998f, 
    -0.30463654f, -0.04316504f, 0.22501990f, 0.23123859f, -0.17115580f, 0.19125082f, 0.09158415f, 0.27170405f, 
    -0.02029360f, -0.02463248f, -0.05791732f, 0.04922459f, 0.13747658f, -0.02823798f, -0.02822879f, 0.00219100f, 
    -0.18752740f, -0.08544520f, -0.11227157f, 0.26823929f, 0.08270866f, 0.09177114f, 0.14205077f, 0.16868362f, 
    -0.03857284f, -0.09153803f, 0.08209178f, -0.04639990f, -0.11631081f, 0.19789904f, 0.07521622f, 0.08431950f, 
    -0.07462183f, 0.03812315f, 0.17413002f, 0.00437147f, 0.06453410f, 0.04067081f, 0.22068223f, -0.14798419f, 
    -0.00649347f, 0.09562389f, -0.13221972f, -0.08950781f, 0.23078068f, 0.08264164f, -0.06819720f, -0.04803637f, 
    0.24838363f, -0.08155276f, 0.12890714f, -0.17217630f, -0.07489015f, 0.07652488f, -0.00348733f, -0.00330719f, 
    -0.05845284f, 0.02971170f, -0.09046382f, 0.03158867f, 0.11939920f, -0.11935363f, 0.08628499f, -0.07742309f, 
    0.16590959f, 0.09113906f, -0.30480367f, 0.03031529f, -0.01009443f, -0.19203761f, 0.14470176f, -0.02073563f, 
    0.05373517f, 0.01379790f, 0.07766842f, 0.10377206f, -0.40855449f, 0.09699728f, -0.02062994f, -0.00579720f, 
    0.29288161f, -0.04083133f, -0.00931545f, 0.10314982f, 0.19338849f, 0.16781040f, -0.02707691f, 0.19734722f, 
    0.00763986f, 0.23418364f, -0.11318109f, 0.17707378f, -0.12870947f, -0.05226322f, 0.18954882f, -0.10436915f, 
    0.01209231f, -0.11358785f, -0.09313510f, -0.03984530f, -0.10935456f, -0.10914803f, -0.17220688f, 0.02661692f, 
    0.16468491f, -0.09817009f, -0.25682214f, 0.05217692f, -0.14692079f, -0.07188307f, 0.09368598f, -0.06761754f, 
    0.33841464f, 0.02456568f, -0.00069457f, 0.18266235f, 0.17132957f, -0.12857503f, 0.08031369f, 0.08995625f, 
    -0.14745642f, -0.08167649f, 0.17659380f, -0.07052295f, -0.02046812f, -0.08835565f, 0.09854537f, 0.07996292f, 
    0.05353439f, -0.15272471f, -0.17972410f, -0.05668843f, -0.07393409f, 0.10742510f, 0.15296204f, 0.02842696f, 
    -0.10175045f, -0.03090147f, -0.08462747f, 0.12180202f, -0.15146853f, -0.20365259f, -0.11099993f, 0.08826107f, 
    0.09465335f, -0.07015201f, 0.01864292f, -0.07246116f, -0.11587017f, 0.18988791f, -0.00397631f, -0.03230941f, 
    0.13243730f, 0.11428623f, -0.19513784f, 0.04002764f, -0.14572445f, 0.08649843f, 0.26873213f, -0.01641402f, 
    -0.09038245f, -0.11871338f, 0.10736275f, -0.11069597f, 0.11700268f, 0.28331152f, 0.30091581f, 0.20501935f, 
    0.19875723f, 0.00769544f, 0.22802542f, -0.12302437f, -0.05628234f, -0.06555340f, 0.02701338f, -0.05741960f, 
    -0.04370850f, 0.00457207f, -0.09438734f, -0.22201759f, 0.00741737f, 0.08502784f, -0.09184609f, -0.03791926f, 
    -0.07864106f, -0.11403138f, -0.02626303f, 0.17752744f, 0.02890381f, 0.01828784f, 0.17200610f, -0.05483402f, 
    -0.25816128f, 0.09322835f, 0.33091587f, -0.05824493f, 0.01995291f, -0.04129745f, -0.00689220f, 0.37199408f, 
    -0.03829578f, 0.15256172f, 0.30590525f, 0.14650249f, 0.08732583f, -0.04916469f, 0.00170375f, -0.00829291f, 
    0.02490164f, 0.19437663f, 0.07959814f, 0.02728007f, 0.00285944f, 0.22175565f, -0.10953378f, 0.05740601f, 
    -0.05572260f, -0.09131201f, 0.03190752f, 0.17217170f, 0.10619397f, -0.07030783f, 0.35080761f, -0.02226500f, 
    0.22693792f, 0.03232304f, 0.01803707f, 0.03347124f, 0.07737933f, -0.10487722f, -0.20384616f, -0.01963925f, 
    0.13523780f, 0.06967577f, -0.15719338f, -0.06941260f, 0.04598027f, 0.11123741f, 0.05974265f, 0.03864417f, 
    0.08308303f, 0.19887061f, -0.06421254f, 0.36891094f, -0.08303941f, -0.01030620f, -0.07513520f, 0.08292504f, 
    0.10751645f, 0.03279106f, -0.15267624f, 0.01880558f, 0.03892564f, 0.02233133f, 0.00327364f, 0.01946735f, 
    -0.04247963f, -0.03035541f, 0.00466203f, 0.18175471f, 0.05386905f, -0.12438571f, -0.04633404f, -0.18645737f, 
    -0.16211128f, 0.09414466f, -0.13978508f, 0.17940767f, 0.20486732f, 0.17782427f, 0.08553066f, 0.09798971f, 
    -0.13070999f, 0.17984027f, 0.07978890f, 0.05093509f, 0.14621539f, 0.09634826f, -0.00232191f, -0.21302189f, 
    -0.07471070f, 0.17452137f, 0.18685147f, -0.03192357f, 0.03724507f, -0.10599679f, -0.24451065f, 0.10332669f, 
    -0.03741380f, -0.06011137f, -0.09788235f, -0.08580084f, 0.03799162f, 0.09527653f, 0.06235923f, 0.04115225f, 
    0.01771546f, 0.07157347f, 0.07345085f, -0.05167060f, -0.04755783f, -0.00423146f, -0.24475867f, -0.08909997f, 
    -0.02188666f, 0.00821835f, -0.01764849f, 0.40080526f, -0.01536450f, -0.02202451f, -0.09987397f, -0.14744040f, 
    0.03531300f, 0.01091614f, -0.21330042f, 0.03004600f, -0.03632210f, 0.05519818f, -0.09538226f, 0.10864992f, 
    -0.13894145f, -0.09584528f, 0.13345985f, -0.29595417f, 0.21667153f, 0.10734212f, 0.16241986f, -0.06812708f, 
    0.08814224f, 0.21536760f, 0.12525810f, 0.04673161f, 0.40344399f, 0.01458844f, 0.06954283f, 0.03908517f, 
    -0.01384356f, -0.01254269f, 0.00755356f, -0.14296347f, -0.05462305f, -0.20414229f, 0.24294047f, -0.33439609f, 
    0.11009277f, 0.11697763f, 0.15639099f, 0.01837966f, 0.02640630f, 0.02399413f, -0.17618872f, 0.10659081f, 
    0.00197305f, 0.02287185f, 0.22346112f, -0.02203199f, 0.01312523f, 0.15036976f, 0.06690344f, 0.01340523f, 
    -0.28107673f, -0.02667686f, 0.13478942f, 0.04149413f, 0.21076144f, 0.00410842f, 0.15576875f, 0.04553939f, 
    0.02245775f, -0.09667379f, -0.01440053f, -0.01842012f, 0.06639840f, -0.09870118f, -0.07060412f, -0.11827610f, 
    0.11492035f, 0.06618850f, -0.13953741f, 0.10486881f, 0.02835271f, 0.10935195f, 0.01999588f, 0.11233217f, 
    -0.07834593f, -0.10465830f, -0.13081385f, -0.10600936f, -0.07206526f, 0.01031648f, 0.01710693f, -0.00402554f, 
    -0.09813268f, -0.03093308f, 0.05869668f, 0.05735696f, -0.11912914f, -0.08214847f, 0.06630996f, -0.01380972f, 
    -0.07196585f, -0.05029552f, -0.10300222f, -0.05117305f, 0.04065014f, -0.04000853f, -0.08217820f, 0.13106598f, 
    0.04190908f, -0.04380960f, -0.02219665f, -0.12868954f, -0.08942065f, -0.10924186f, 0.12946139f, -0.00659840f, 
    0.11002585f, -0.04138266f, -0.01631301f, 0.01833805f, 0.02919015f, 0.10806126f, -0.02100770f, 0.01644392f, 
    0.10422637f, -0.04268500f, -0.07379913f, 0.06825374f, 0.05872490f, 0.08473581f, 0.04106714f, 0.10130151f, 
    -0.07519277f, 0.12229209f, -0.10267174f, 0.07629001f, 0.03400932f, -0.05583153f, 0.10322518f, -0.12146936f, 
    0.02360369f, 0.08357727f, -0.06573921f, 0.20139544f, -0.08275775f, 0.03897485f, 0.22372302f, 0.02063853f, 
    -0.10460123f, -0.11365485f, 0.44323742f, -0.10243341f, 0.10693458f, -0.18916477f, 0.26043335f, 0.03246396f, 
    -0.03821695f, 0.11417262f, 0.16501744f, 0.33856174f, 0.15271315f, -0.06072048f, 0.06062823f, 0.01546171f, 
    -0.08717567f, 0.09500203f, -0.04626068f, -0.10229475f, -0.25747991f, 0.12751552f, -0.12130092f, -0.09861021f, 
    -0.03544096f, 0.01186334f, -0.03378147f, 0.34438884f, 0.18812065f, -0.08722648f, 0.16306907f, 0.11488789f, 
    0.08916106f, -0.04180859f, 0.26058832f, -0.00077851f, 0.07615613f, -0.16608532f, 0.10806833f, -0.12404661f, 
    0.06339312f, 0.01477325f, -0.19364658f, -0.02063331f, 0.12309477f, -0.05964431f, 0.03586084f, -0.01159364f, 
    -0.11927752f, -0.13982664f, 0.06881332f, 0.10911030f, -0.12143762f, -0.06535155f, 0.09870432f, -0.14952371f, 
    -0.10006910f, 0.09570626f, 0.02005157f, -0.08185956f, 0.06233329f, -0.02315499f, 0.07902041f, -0.09124607f, 
    -0.05221251f, -0.03995848f, -0.19497664f, -0.05953234f, 0.03325692f, 0.15805653f, -0.04414574f, 0.02376525f, 
    -0.01010664f, 0.03733015f, 0.01035379f, 0.06786730f, -0.03230951f, -0.08698043f, -0.05702597f, -0.09439293f, 
    0.00619075f, 0.02756507f, 0.07614987f, -0.06437946f, 0.00046547f, -0.10331015f, -0.07158029f, 0.06558540f, 
    -0.03772051f, -0.02065767f, -0.06561629f, -0.02340070f, 0.03525176f, -0.09065755f, -0.05819374f, -0.12098416f, 
    -0.07532472f, 0.07293767f, 0.12016094f, 0.07436599f, -0.07492116f, -0.12265170f, 0.04881402f, -0.03004413f, 
    0.04858342f, -0.11703441f, 0.09631392f, 0.10469592f, -0.03369837f, 0.11045839f, 0.02731305f, 0.01700552f, 
    0.23346402f, -0.00566202f, 0.04519754f, -0.09919183f, 0.12776697f, 0.27490267f, -0.00254890f, 0.17075704f, 
    0.17756878f, 0.08760197f, 0.10001224f, 0.23217061f, 0.00674789f, -0.00715944f, 0.16015415f, -0.00463694f, 
    0.09121024f, 0.06704327f, 0.02032706f, 0.08225573f, 0.22643797f, -0.22336453f, -0.19043925f, -0.05252116f, 
    0.18803473f, -0.01507913f, -0.06035339f, 0.28443906f, -0.36087853f, 0.20328714f, -0.07074705f, -0.06721118f, 
    -0.22237699f, -0.09258928f, -0.06869711f, -0.09621084f, -0.18589872f, -0.03498749f, -0.01288038f, -0.02325145f, 
    -0.08221226f, 0.01658428f, -0.25865829f, 0.24024561f, -0.12851067f, -0.14660582f, 0.11468195f, 0.03164874f, 
    0.05391362f, 0.06752190f, -0.03052128f, 0.02194235f, -0.01785955f, -0.06545442f, -0.16660203f, -0.09142008f, 
    -0.00892286f, -0.00912380f, -0.21160088f, 0.04999022f, -0.00877748f, 0.01797074f, 0.05155377f, 0.05447590f, 
    0.39230871f, 0.08174328f, -0.07334734f, -0.10565647f, -0.10678271f, -0.30879435f, 0.06140136f, 0.02737941f, 
    0.09951766f, 0.04119133f, -0.15567976f, 0.22400813f, -0.00964662f, -0.10698825f, -0.04898791f, 0.08386953f, 
    -0.04735011f, 0.07428841f, -0.06037407f, 0.04264485f, -0.09005857f, 0.02596576f, 0.18416853f, -0.17614204f, 
    -0.01449484f, -0.00034439f, 0.14790604f, 0.20380995f, -0.31687203f, 0.01849042f, 0.03634673f, 0.10594991f, 
    -0.11444841f, 0.20053290f, 0.01978790f, -0.22859220f, 0.16928174f, -0.07847074f, -0.00445325f, 0.43535653f, 
    0.02061962f, 0.14846200f, 0.06112262f, 0.22051771f, 0.04012024f, 0.15730849f, 0.25317758f, -0.02458027f, 
    0.00713746f, -0.00464464f, 0.09621573f, -0.05609988f, -0.12543206f, -0.30828270f, 0.03095881f, -0.05245449f, 
    -0.01269273f, -0.08753922f, 0.17619090f, -0.10346912f, -0.31475440f, 0.00276791f, -0.02122538f, -0.09396102f, 
    -0.11975706f, -0.07582602f, 0.06397527f, -0.02160305f, 0.00148326f, -0.07869249f, 0.08385102f, 0.12742129f, 
    -0.06141314f, -0.05808149f, -0.07222953f, -0.06496802f, 0.12487143f, 0.00005171f, -0.03857402f, -0.08505876f, 
    0.11337998f, -0.01070398f, 0.05826590f, -0.06530654f, 0.00200673f, 0.04283847f, 0.09324222f, -0.01744368f, 
    -0.04817897f, 0.05198734f, -0.07346779f, 0.07773940f, -0.10735828f, -0.10900599f, -0.05179952f, 0.00751719f, 
    0.04635169f, -0.08104637f, -0.09125508f, 0.02881193f, -0.10281134f, -0.04581147f, -0.06633082f, 0.07239080f, 
    0.05454169f, -0.00995428f, -0.07718850f, -0.00015242f, 0.01692824f, 0.10392582f, 0.01833443f, 0.05125777f, 
    -0.03358932f, 0.00131698f, -0.07930741f, 0.01166160f, 0.05142757f, 0.11827605f, -0.00545419f, -0.01896366f, 
    0.04240042f, 0.08407661f, -0.10442148f, 0.06504630f, -0.08022197f, 0.06058869f, -0.00932070f, -0.11976786f, 
    0.22256023f, 0.15750980f, 0.05749623f, -0.22924387f, 0.07021475f, -0.36685658f, -0.05781608f, 0.21073574f, 
    0.34051239f, 0.02271743f, -0.07917544f, -0.01028120f, -0.00888861f, -0.06350703f, -0.13878864f, -0.12322820f, 
    0.08895555f, -0.17134312f, 0.17307451f, -0.19274388f, -0.05647242f, -0.08054629f, 0.05404867f, -0.21524389f, 
    0.10587403f, 0.02352460f, -0.14408606f, 0.04079400f, 0.03849800f, 0.17709273f, -0.06479331f, -0.01714566f, 
    -0.13608593f, 0.19347936f, 0.04372520f, -0.20030187f, -0.14617036f, 0.08665821f, 0.02905282f, -0.19860151f, 
    0.09033339f, 0.17942385f, -0.01803450f, 0.19305876f, 0.03835605f, -0.01480459f, 0.17012759f, 0.11145213f, 
    0.11839139f, -0.11403138f, 0.14178938f, -0.02831374f, -0.06421189f, 0.08265355f, -0.03317279f, -0.23432192f, 
    0.08661170f, 0.04745558f, 0.21680015f, -0.12217920f, 0.20585853f, 0.11929142f, 0.21146138f, 0.09494841f, 
    0.11388373f, 0.12888853f, 0.08189390f, -0.23776861f, -0.07786907f, -0.06374855f, 0.06092096f, 0.09700277f, 
    -0.22123006f, 0.01532969f, 0.02810819f, 0.17404622f, -0.02571355f, 0.11890186f, 0.06511256f, -0.07859894f, 
    0.09712425f, -0.10348029f, -0.04223629f, -0.18351169f, 0.14346674f, 0.23895809f, 0.19222942f, -0.07703735f, 
    0.17896122f, 0.17506680f, 0.09670934f, 0.03716387f, -0.13111687f, -0.03608436f, -0.04362230f, 0.08071374f, 
    0.07512232f, 0.09259605f, -0.01710536f, -0.01314391f, 0.15408966f, 0.25346240f, 0.08746939f, 0.49452302f, 
    0.00045831f, 0.17987436f, 0.01702487f, -0.15594210f, 0.02500887f, 0.04173477f, 0.02266824f, -0.08139064f, 
    -0.21631975f, -0.08106648f, 0.00954734f, 0.05003388f, -0.00919686f, -0.07984280f, 0.08180430f, -0.12958583f, 
    0.19560614f, 0.06609760f, -0.19068751f, -0.02106890f, -0.42593768f, 0.09405791f, 0.08732952f, 0.08064266f, 
    -0.15227814f, -0.02356669f, 0.04282361f, -0.12546347f, -0.08045088f, -0.05287139f, 0.09041087f, 0.10675326f, 
    0.39143953f, 0.03903538f, -0.07779611f, -0.00695480f, -0.03643984f, -0.08036215f, -0.06073901f, 0.04617361f, 
    -0.14166982f, 0.22590065f, 0.30965295f, 0.30448049f, 0.05067999f, -0.27233538f, -0.04562338f, -0.09869263f, 
    -0.07557472f, -0.17073233f, -0.03280331f, -0.02633587f, 0.21793456f, 0.12438758f, -0.10768656f, 0.04517439f, 
    0.00181783f, 0.14065447f, 0.00853866f, 0.15642858f, -0.08405647f, -0.09436596f, 0.03888090f, -0.39776695f, 
    -0.08749842f, 0.02421771f, 0.19276778f, 0.05850454f, 0.25864071f, 0.14546910f, 0.08163313f, 0.10753176f, 
    0.31151834f, 0.03976150f, 0.15549827f, 0.01937133f, 0.01709612f, 0.04259573f, -0.12516320f, 0.10744204f, 
    -0.07634974f, 0.09722783f, 0.18241973f, 0.08534195f, 0.35620382f, -0.01699367f, 0.01967284f, -0.07413238f, 
    0.03768365f, -0.02187410f, 0.10522552f, -0.00737694f, 0.03772664f, -0.02824635f, -0.10120855f, -0.02251540f, 
    0.09266886f, 0.10880405f, 0.02790161f, -0.12119438f, 0.01663147f, 0.06952374f, -0.10804287f, 0.11646497f, 
    -0.07043379f, -0.04469296f, 0.00909625f, -0.12326818f, 0.00260332f, -0.00350484f, -0.02923003f, -0.10166498f, 
    -0.09977112f, -0.12509695f, 0.08024053f, 0.07285707f, 0.06919575f, 0.03938074f, 0.01918981f, 0.11463141f, 
    0.01385897f, 0.00093591f, -0.03573316f, 0.10486282f, -0.12051018f, -0.12657732f, 0.03118527f, 0.02123645f, 
    -0.09784301f, -0.12885705f, 0.07417595f, 0.09199443f, 0.02028779f, 0.01556492f, -0.05809874f, 0.07376871f, 
    -0.03081338f, 0.02714326f, -0.07613827f, -0.07862684f, -0.01588960f, -0.02016092f, -0.08555015f, -0.09466840f, 
    -0.06313393f, -0.01856527f, 0.05878418f, -0.01359279f, -0.00506571f, -0.04647338f, -0.02658068f, -0.05504771f, 
    -0.05902997f, 0.12565786f, -0.10783432f, 0.28937554f, 0.11862808f, -0.15720484f, 0.09906996f, -0.25098675f, 
    -0.01965694f, -0.11595389f, -0.06715172f, -0.12974311f, 0.13185726f, 0.00418613f, -0.08653921f, -0.02147040f, 
    -0.04906591f, 0.12231101f, -0.18925028f, -0.19580758f, 0.02723753f, 0.22586744f, 0.15532908f, -0.12145604f, 
    0.11121156f, 0.17057113f, -0.10041710f, -0.12921666f, 0.29307735f, -0.08657841f, -0.03919265f, 0.02673730f, 
    -0.03434210f, -0.10550401f, -0.04962247f, 0.00004305f, 0.18083398f, -0.09148980f, 0.15271774f, -0.09853551f, 
    0.17482221f, 0.12268108f, 0.21773778f, -0.08756242f, 0.10895659f, 0.23728971f, -0.16307679f, 0.08882879f, 
    -0.00950965f, -0.00472327f, 0.30860549f, 0.09176808f, -0.00116927f, -0.06478295f, 0.13665174f, -0.00068521f, 
    -0.23217447f, 0.07199768f, 0.22298144f, -0.11090910f, 0.00319468f, 0.02365963f, 0.28928801f, 0.04570989f, 
    0.00039252f, -0.05500307f, -0.12564693f, -0.23762988f, -0.03753554f, -0.02451081f, -0.07723291f, 0.11836948f, 
    0.14294651f, -0.00376814f, -0.01978314f, 0.26817846f, 0.03134742f, -0.08650314f, 0.02526976f, -0.05965962f, 
    -0.22013037f, -0.03927607f, 0.28268158f, 0.08646734f, -0.06936400f, 0.06368516f, -0.13182016f, 0.36719525f, 
    0.01021143f, -0.02830712f, 0.14150302f, -0.00015433f, -0.03949133f, 0.15152746f, -0.05967050f, -0.05639761f, 
    -0.18317373f, 0.26557350f, -0.00655000f, -0.05135595f, 0.13662463f, 0.12648094f, -0.01549989f, 0.00603838f, 
    -0.17486006f, -0.07804386f, 0.16162366f, -0.00450934f, 0.20533690f, -0.09937199f, 0.27637923f, -0.07010955f, 
    0.07448231f, -0.08541133f, -0.19603471f, 0.12730742f, 0.08965497f, 0.08757627f, -0.12608242f, 0.02516907f, 
    0.06106981f, 0.09981618f, 0.23427394f, -0.03911427f, 0.28285915f, -0.03752999f, 0.18702285f, 0.08858169f, 
    -0.12271689f, 0.08901788f, -0.08256932f, -0.12524123f, -0.02332898f, -0.01628738f, 0.09485058f, 0.01310660f, 
    -0.12374436f, -0.12019331f, -0.08411115f, 0.07952538f, 0.07502830f, -0.06715082f, 0.03985079f, 0.01124985f, 
    0.08524091f, 0.10030068f, 0.02918543f, -0.10760711f, -0.10590590f, -0.06582597f, -0.08201049f, -0.00582048f, 
    -0.06006982f, -0.10481651f, -0.10071442f, -0.04695860f, -0.06780541f, -0.07667910f, -0.09258512f, -0.00185554f, 
    -0.01726076f, -0.08732857f, -0.11152162f, -0.11330608f, -0.08018178f, 0.01409581f, 0.12007862f, 0.02169918f, 
    0.10987162f, -0.10405844f, -0.02060915f, -0.02860583f, 0.09035426f, -0.05803587f, 0.09299646f, 0.08831318f, 
    -0.05053039f, -0.10226926f, -0.12410060f, -0.00998415f, 0.08026521f, 0.05928287f, 0.05910673f, 0.04280249f, 
    0.11746406f, -0.03808873f, -0.04216867f, 0.04222668f, -0.09271968f, 0.07294446f, -0.11150875f, 0.02612387f, 
    0.15964304f, 0.19990017f, 0.09882669f, 0.02906077f, 0.13805731f, -0.06948975f, -0.00762287f, 0.05939858f, 
    -0.22361214f, 0.09776154f, 0.09238347f, 0.03120851f, -0.00438465f, -0.10955695f, -0.01739053f, -0.11909448f, 
    0.02144425f, 0.01287027f, -0.22963868f, -0.26128846f, -0.02700328f, 0.32046756f, 0.15771694f, 0.15681763f, 
    -0.01804163f, 0.21820652f, -0.13096261f, -0.25254676f, 0.16083682f, -0.22963548f, -0.01402885f, -0.01813849f, 
    0.28853649f, -0.05032634f, -0.04347405f, -0.13587826f, 0.09723818f, 0.15959489f, 0.03856155f, 0.28557658f, 
    0.06836350f, 0.01126305f, -0.10744464f, -0.20335333f, -0.00082272f, -0.05593572f, 0.00431719f, 0.08367527f, 
    -0.24213074f, -0.11172035f, -0.01970426f, 0.05844893f, 0.00078452f, 0.13970119f, 0.18408716f, 0.04762280f, 
    0.18268584f, 0.07979321f, 0.17793410f, 0.08507254f, -0.02966472f, 0.01595708f, 0.34069917f, 0.05830477f, 
    0.05743002f, -0.03103261f, 0.08091937f, -0.09840305f, -0.05142342f, -0.08297224f, -0.02502331f, -0.01105849f, 
    -0.02519475f, -0.06783901f, 0.03069348f, -0.01472685f, 0.11180665f, -0.00825525f, 0.01027989f, -0.02367245f, 
    0.03685496f, -0.08356041f, -0.05907234f, -0.02345037f, -0.12458397f, -0.01574726f, -0.05698663f, 0.04991499f, 
    0.00136739f, -0.02631847f, -0.12241841f, -0.05286218f, 0.11205463f, 0.07732235f, -0.03251439f, 0.12309694f, 
    -0.08158324f, 0.05402466f, -0.05432409f, 0.07973880f, -0.12037545f, 0.05044476f, 0.05296145f, -0.02719133f, 
    0.02508200f, -0.09392493f, -0.10633758f, 0.00773384f, -0.06035708f, -0.07121620f, 0.00736655f, 0.08711204f, 
    -0.06882642f, 0.11182534f, -0.11909372f, 0.04252908f, -0.09558120f, 0.11654700f, -0.00291295f, 0.09212961f, 
    -0.11390077f, 0.03110052f, -0.11429433f, -0.06760591f, 0.02739781f, 0.01259933f, -0.01758202f, 0.01590236f, 
    -0.26737490f, -0.00184521f, -0.12649614f, 0.04560363f, 0.00090509f, 0.21522196f, 0.07322600f, -0.06069236f, 
    0.30810484f, 0.05438872f, -0.32952487f, -0.15080802f, -0.09487426f, 0.04547824f, -0.03081932f, -0.00371023f, 
    0.12787475f, 0.24063680f, -0.05156922f, 0.43683884f, 0.12780017f, -0.37759796f, -0.09723446f, 0.16438761f, 
    -0.20651625f, -0.18443750f, 0.31374136f, 0.11800013f, -0.03414957f, -0.01629927f, -0.05021562f, -0.07956804f, 
    0.22925825f, -0.05153014f, 0.12774864f, 0.09810743f, -0.11617277f, -0.16731741f, -0.09920290f, -0.10356428f, 
    0.09348718f, 0.15549110f, 0.00946036f, 0.26251593f, 0.36781800f, 0.21402623f, -0.05275792f, -0.05472856f, 
    0.08672500f, 0.09547150f, 0.29602566f, 0.12515250f, 0.10157006f, -0.27024260f, -0.16098744f, 0.32623395f, 
    0.06972315f, 0.05112880f, -0.00536619f, 0.03077755f, 0.22163272f, 0.11346141f, -0.02201921f, 0.06278905f, 
    0.12821881f, 0.10977034f, 0.12757440f, 0.13640137f, -0.05436635f, 0.05060242f, -0.10033146f, -0.02715239f, 
    0.09824558f, -0.05223542f, 0.24132422f, -0.06128372f, -0.03274105f, -0.04548393f, 0.01270391f, 0.01599189f, 
    0.24239279f, -0.06767192f, -0.01968143f, -0.25035438f, 0.14464955f, 0.17698269f, -0.04274575f, -0.21357363f, 
    0.25506887f, 0.14006899f, -0.00376383f, 0.01508872f, 0.19679604f, 0.26226088f, -0.11567554f, 0.00433588f, 
    -0.04021518f, 0.10636842f, -0.05572575f, 0.01203897f, -0.13193838f, -0.09174856f, 0.25587085f, -0.16239041f, 
    0.06842177f, 0.18309861f, 0.06237126f, 0.00568796f, -0.12515368f, -0.15730947f, -0.06343729f, 0.04292060f, 
    0.04191596f, -0.01868085f, 0.06252608f, 0.10282204f, -0.09344947f, 0.24354541f, -0.10202201f, -0.22137545f, 
    -0.19994839f, -0.07040548f, 0.16139296f, -0.07753407f, -0.13721798f, -0.02558262f, 0.22940384f, 0.09674523f, 
    0.12877199f, 0.11812242f, 0.07731756f, 0.32128489f, 0.03210876f, 0.16371736f, -0.03381367f, 0.08394220f, 
    0.17859739f, -0.10253445f, -0.21688628f, 0.03812158f, -0.12085053f, 0.06148810f, -0.17315191f, -0.08153838f, 
    -0.03165976f, 0.10116296f, -0.18439414f, 0.11845060f, 0.04906140f, -0.18200822f, -0.13100331f, -0.08023803f, 
    -0.18266256f, -0.10984654f, 0.08622640f, -0.04223799f, 0.23698115f, 0.15039308f, 0.04997051f, 0.07732310f, 
    -0.15195104f, 0.12442930f, -0.03331505f, 0.00623888f, 0.18710168f, -0.03460596f, 0.09525976f, -0.14099665f, 
    -0.06283506f, 0.07308650f, 0.11689220f, -0.14139441f, 0.14349501f, 0.08050656f, -0.15235470f, -0.10930970f, 
    -0.10050996f, 0.09275881f, -0.00766998f, 0.11607717f, 0.03694929f, 0.21036036f, 0.05170747f, 0.30246571f, 
    0.02614192f, 0.07292350f, 0.15709567f, 0.11169761f, -0.02834457f, -0.00762010f, -0.23655407f, 0.09800489f, 
    -0.05042923f, 0.09330352f, 0.01495271f, 0.15970775f, 0.11133678f, 0.17619973f, -0.00475076f, -0.04656241f, 
    -0.19362916f, -0.04138546f, 0.39898750f, -0.09271497f, 0.04313333f, -0.11395316f, 0.25572523f, -0.07070827f, 
    0.27629620f, -0.07925686f, 0.14953193f, -0.25280258f, 0.16252658f, 0.18363230f, 0.12885645f, -0.01597309f, 
    0.09263124f, 0.12158106f, -0.12749316f, -0.11381251f, 0.36332723f, 0.04245229f, -0.08955737f, -0.02781128f, 
    0.17224710f, -0.13861348f, 0.12739396f, 0.21619399f, -0.12841572f, 0.07324348f, 0.27317950f, -0.22308528f, 
    0.07261802f, -0.11492405f, 0.08470006f, -0.01320663f, -0.10049563f, -0.00545333f, -0.10112118f, -0.08212765f, 
    0.20826831f, -0.00015881f, 0.06964134f, 0.08955268f, 0.06313797f, 0.15880266f, 0.03086681f, -0.14242044f, 
    -0.03334081f, 0.11320115f, -0.26768580f, -0.06610239f, 0.11143117f, -0.09440676f, 0.12611270f, -0.08464283f, 
    -0.04632526f, -0.11415903f, 0.05974316f, -0.30896226f, -0.01064926f, -0.15383190f, -0.11804768f, 0.15564291f, 
    -0.14609371f, -0.09152295f, -0.04756607f, 0.19322193f, -0.06802499f, 0.03457879f, -0.03423876f, -0.03969948f, 
    -0.00610070f, 0.14817712f, 0.07421669f, 0.01527115f, 0.24798776f, 0.14942928f, -0.09771609f, 0.10540342f, 
    0.31327847f, 0.26535842f, 0.09536996f, -0.26520762f, 0.06837924f, 0.24448146f, 0.09049770f, 0.01844129f, 
    -0.02536256f, 0.12068575f, 0.07133512f, -0.01134801f, 0.07096452f, 0.13190301f, 0.06740613f, -0.08391791f, 
    -0.10281346f, 0.03495851f, 0.10439647f, -0.11981352f, -0.15041886f, -0.10000869f, 0.27033997f, -0.06017369f, 
    0.27138469f, -0.10814998f, -0.06193046f, 0.03291616f, -0.12980248f, 0.14508891f, -0.22644351f, -0.16672990f, 
    0.17116174f, -0.09640633f, 0.20597067f, -0.03984071f, 0.16436762f, -0.05453175f, 0.33299509f, 0.04914212f, 
    -0.18778637f, -0.03213993f, -0.04431473f, 0.21468082f, -0.00162147f, 0.17833582f, -0.06623822f, -0.07032406f, 
    -0.41256189f, 0.09912531f, -0.05189869f, -0.06861078f, -0.03155228f, 0.04544823f, 0.17269528f, -0.04513487f, 
    -0.05386247f, 0.30817083f, -0.02555112f, 0.05316683f, 0.00779850f, 0.37318769f, -0.12121598f, -0.01103351f, 
    0.11353161f, 0.22851509f, 0.06132716f, -0.04962096f, 0.15852468f, -0.32840034f, 0.03439267f, 0.10361941f, 
    0.03438092f, -0.24895680f, 0.05094625f, 0.01946075f, 0.19454649f, -0.02367354f, 0.10878120f, 0.05319611f, 
    -0.10840576f, -0.05484236f, -0.06278683f, -0.12573883f, -0.49905324f, -0.04021291f, 0.12366625f, -0.10943791f, 
    0.15060863f, 0.04134199f, 0.08087169f, -0.05181019f, 0.12082282f, 0.07151032f, -0.17075302f, 0.07183463f, 
    -0.01139106f, -0.09922248f, 0.12562719f, -0.06953771f, 0.17956690f, 0.02102691f, 0.19738027f, -0.07310408f, 
    0.18242519f, 0.20527804f, -0.12000674f, -0.08112025f, 0.00651313f, -0.14862238f, -0.03577775f, -0.09508681f, 
    0.11312237f, -0.01066048f, 0.14992462f, -0.21384059f, -0.07797928f, -0.06035863f, 0.12136693f, -0.10133071f, 
    0.33884370f, -0.14846811f, -0.02155368f, -0.14280374f, 0.04804897f, 0.05091362f, 0.43323901f, -0.20557444f, 
    -0.03980344f, 0.01011320f, 0.10205525f, -0.05343271f, -0.00500642f, -0.18381570f, 0.02233101f, 0.09684568f, 
    0.32835111f, 0.14054309f, 0.03629066f, -0.17969392f, 0.03451288f, 0.17185353f, -0.06986392f, 0.02108950f, 
    0.11552200f, 0.22228919f, 0.05643023f, 0.17529535f, 0.13746846f, 0.04837860f, -0.11479570f, -0.07338730f, 
    -0.23323649f, -0.10957598f, -0.06047760f, -0.00007809f, 0.01084047f, 0.05590970f, 0.00512168f, 0.13881654f, 
    0.32228887f, -0.02074978f, 0.03039708f, 0.09540352f, -0.29127684f, -0.05779392f, 0.18214409f, 0.03167661f, 
    0.00136460f, -0.04087169f, -0.06854885f, 0.03392437f, -0.01193658f, -0.10026777f, 0.06882139f, -0.01660000f, 
    -0.06130658f, 0.07375947f, -0.04378521f, 0.08199834f, -0.01182540f, -0.04202481f, -0.09093609f, -0.12351280f, 
    0.02582885f, 0.01323651f, -0.12385227f, -0.01415033f, 0.07199368f, 0.08240286f, 0.01538156f, -0.02334714f, 
    -0.03453564f, 0.03469295f, -0.07705845f, -0.08493213f, 0.02749384f, 0.02221441f, 0.01976627f, -0.04439954f, 
    -0.03653945f, -0.02465735f, -0.05637819f, 0.09238003f, -0.11111198f, -0.02080722f, -0.00628604f, -0.07521340f, 
    0.00185064f, 0.03463661f, -0.13010012f, -0.03895401f, -0.08454454f, -0.03112577f, 0.01339499f, 0.05499603f, 
    -0.04346031f, -0.08423185f, -0.10471031f, 0.06140749f, -0.12720309f, 0.04347198f, -0.03334985f, 0.08249251f, 
    -0.05161068f, -0.11510306f, -0.05324986f, 0.04863614f, 0.03506837f, 0.04486154f, -0.02738179f, -0.05042265f, 
    0.01629020f, -0.03921014f, 0.10445533f, 0.11853148f, 0.18442628f, 0.14476372f, -0.02410042f, 0.28068087f, 
    0.15906888f, -0.09288041f, -0.24846196f, 0.04670062f, -0.05779038f, -0.05381735f, 0.00255300f, -0.01271431f, 
    -0.07528841f, 0.13867085f, -0.16367620f, 0.23069189f, 0.04045787f, -0.22111474f, -0.37392643f, 0.23175393f, 
    -0.29736391f, -0.11788765f, 0.08586527f, 0.20000185f, -0.25282022f, -0.08067508f, 0.09712562f, -0.02065974f, 
    0.11636690f, 0.02277810f, -0.08739883f, 0.17855780f, 0.07057840f, -0.04735291f, -0.06102686f, -0.06614063f, 
    0.00774100f, -0.05384256f, -0.24136780f, 0.00987300f, 0.08440364f, 0.06865092f, 0.24167246f, -0.07084927f, 
    0.23505773f, -0.07577264f, 0.00732603f, -0.06934518f, 0.04464280f, 0.27345851f, 0.11048173f, 0.18249716f, 
    0.24150430f, -0.05014365f, 0.32217708f, -0.05586587f, 0.32918051f, -0.10433502f, -0.28752944f, 0.08644057f, 
    0.02611818f, -0.05070082f, -0.07462806f, -0.09954093f, 0.12246166f, 0.00043844f, -0.03082305f, -0.13456680f, 
    0.10471621f, 0.03638674f, 0.07705759f, 0.03459840f, -0.12979829f, 0.11547533f, -0.15452076f, 0.11809635f, 
    0.32435846f, 0.19948660f, -0.36244872f, 0.26957712f, 0.10733142f, 0.31468797f, 0.10883787f, -0.26631752f, 
    0.04627363f, 0.09078836f, -0.22116897f, -0.19406310f, -0.03356680f, 0.18745071f, 0.08623295f, 0.00214633f, 
    0.05733781f, -0.05871836f, 0.07446671f, 0.11543648f, 0.30905050f, 0.14834259f, 0.07901435f, 0.27996364f, 
    0.04931764f, 0.16347039f, 0.06254192f, -0.16136736f, -0.13778040f, 0.12524332f, -0.12472174f, -0.04554120f, 
    0.03626038f, 0.01288334f, -0.00624811f, 0.03494060f, 0.01680027f, -0.05155998f, -0.08876164f, 0.18213634f, 
    0.00099667f, 0.02311709f, 0.25562075f, 0.04242263f, -0.27809808f, -0.05841968f, 0.27121574f, 0.01403022f, 
    0.20474486f, 0.02053010f, -0.13223463f, -0.10869580f, 0.05315646f, 0.08908016f, 0.01371359f, 0.09044909f, 
    0.09774866f, 0.01289716f, 0.16585499f, -0.00150202f, 0.03157456f, 0.03198998f, -0.07893997f, 0.06240936f, 
    0.10743868f, 0.13545164f, -0.01533639f, -0.33170965f, 0.25281635f, -0.02756669f, -0.11963211f, 0.21050443f, 
    0.25362161f, 0.16329961f, 0.12916519f, -0.21160561f, -0.16338037f, 0.03447317f, -0.03002139f, -0.11866323f, 
    -0.17681244f, -0.05094975f, -0.07412262f, -0.16514260f, -0.16832684f, -0.14924380f, 0.21373749f, -0.00586956f, 
    0.04389840f, 0.14829487f, -0.13404721f, 0.14604431f, -0.06296356f, 0.13085347f, 0.14996512f, -0.05492955f, 
    0.03948965f, -0.01884985f, -0.11905956f, 0.07602721f, -0.05581050f, 0.22339210f, -0.01731274f, 0.00853709f, 
    -0.18317102f, 0.09713285f, 0.29267472f, -0.03591542f, -0.00833047f, -0.03277795f, 0.04185435f, -0.08647422f, 
    0.08535118f, 0.13122270f, -0.01502060f, 0.33062735f, 0.18772836f, 0.07002576f, -0.02378982f, 0.08410557f, 
    -0.05656805f, -0.07727343f, 0.24985880f, -0.17077766f, 0.01799180f, 0.09861418f, -0.00402565f, -0.04104814f, 
    0.17374158f, -0.16240758f, -0.06909376f, -0.05705436f, 0.05358996f, 0.01037013f, 0.06792084f, 0.11496203f, 
    -0.31734177f, -0.05281803f, 0.01621287f, -0.08366810f, 0.01279617f, -0.17085579f, 0.11198473f, -0.13092645f, 
    0.22881383f, -0.16921091f, 0.02254262f, 0.02420399f, -0.11788907f, -0.17273697f, -0.12766618f, -0.29238784f, 
    0.11734499f, -0.03626356f, -0.28208354f, 0.20625252f, 0.01276737f, 0.01265733f, 0.23519546f, 0.06475249f, 
    0.08383577f, -0.07950599f, 0.12400940f, -0.11957635f, -0.12616219f, 0.40659600f, 0.23841034f, 0.19621462f, 
    0.05511937f, -0.06615930f, 0.16495895f, 0.02329336f, 0.28333038f, 0.03043963f, -0.24790385f, 0.05460244f, 
    -0.04514995f, 0.09147253f, 0.08089593f, -0.08567297f, 0.00176008f, -0.15286377f, 0.02586102f, 0.14624770f, 
    -0.13653992f, 0.04300686f, 0.07146713f, 0.15943868f, 0.10057382f, 0.12527740f, 0.13447283f, 0.06492962f, 
    -0.30276942f, -0.19956753f, 0.34735835f, -0.26095882f, 0.11417157f, -0.08142090f, 0.23218635f, 0.29633948f, 
    0.11099181f, 0.11858410f, 0.02880361f, 0.23028660f, -0.07412685f, -0.10509416f, 0.07351656f, 0.05981809f, 
    -0.07383438f, 0.13530143f, -0.11111362f, -0.12260399f, -0.07111958f, 0.22085926f, 0.01273095f, 0.21762645f, 
    -0.03069695f, -0.18428068f, -0.07436453f, 0.18422325f, 0.08424835f, 0.08526648f, 0.19950527f, -0.02479040f, 
    -0.01289028f, 0.00651497f, 0.13846102f, -0.05114899f, 0.07868733f, -0.09215453f, -0.03014188f, -0.28013462f, 
    0.17048219f, -0.02008023f, -0.15202181f, 0.02988329f, 0.09270094f, 0.01662602f, 0.13598722f, -0.00466564f, 
    -0.18451807f, 0.18024641f, -0.09677607f, -0.04206240f, -0.00803759f, -0.25066736f, 0.01353116f, -0.16063459f, 
    -0.10733339f, -0.01229565f, 0.00337707f, -0.12145877f, 0.04886358f, 0.12338019f, 0.17088568f, -0.08501913f, 
    -0.16471346f, -0.11020204f, 0.18662144f, -0.19592343f, 0.00475553f, -0.05828186f, 0.25991952f, 0.12553085f, 
    0.11424063f, 0.17878814f, 0.16357905f, 0.01711869f, 0.26001140f, -0.25124264f, -0.02945908f, 0.08615582f, 
    0.29318377f, 0.04045247f, -0.02320355f, -0.06181855f, -0.04171030f, 0.27896610f, -0.18256161f, 0.01185220f, 
    -0.09841157f, 0.00773425f, 0.07362010f, 0.13493554f, 0.12022318f, 0.16153669f, -0.09217549f, 0.10872819f, 
    -0.15724315f, 0.06765080f, 0.05411545f, 0.02075480f, 0.08949163f, 0.03591676f, 0.00648099f, -0.05041118f, 
    0.06498585f, -0.09714080f, -0.02048964f, -0.00968687f, 0.13980195f, 0.01779985f, 0.25581080f, 0.00294903f, 
    0.05673489f, 0.14298126f, -0.10881741f, 0.01627005f, 0.18382870f, 0.07490999f, -0.02406457f, 0.23688143f, 
    -0.19154392f, -0.08719337f, 0.00858329f, -0.05492753f, 0.10394229f, -0.12609427f, 0.03326574f, 0.03990398f, 
    -0.01363067f, 0.17149279f, -0.13484441f, -0.12807587f, -0.14658965f, 0.27513999f, -0.14707819f, 0.26514563f, 
    0.02663034f, 0.19919772f, -0.25939578f, -0.50451577f, 0.03418614f, -0.06912325f, -0.02987255f, -0.05901779f, 
    0.03681969f, 0.01663788f, -0.06839860f, 0.10250461f, 0.21938525f, 0.03615984f, 0.06388907f, -0.13882406f, 
    -0.09131075f, -0.05086049f, 0.06092001f, -0.34851518f, -0.45807403f, -0.08616688f, 0.00568467f, -0.08410731f, 
    0.10871144f, -0.02307868f, -0.26030144f, 0.03822716f, 0.08605059f, 0.31286269f, 0.00537468f, 0.13760707f, 
    0.08344484f, -0.02054239f, 0.41122895f, -0.08725052f, 0.09502588f, 0.10034294f, 0.15235071f, 0.00938511f, 
    -0.04317700f, 0.10005345f, 0.09528661f, 0.16830823f, 0.09986592f, -0.08989485f, -0.05701335f, 0.03260862f, 
    0.08453401f, -0.03495523f, 0.19848305f, -0.24173789f, 0.00517612f, -0.05879776f, -0.00895625f, -0.03910538f, 
    0.12564543f, 0.07914120f, 0.01168724f, 0.16747043f, -0.22469623f, 0.10858499f, 0.07297763f, 0.00092132f, 
    0.02824563f, -0.02508930f, -0.19738160f, -0.09890450f, 0.20917051f, 0.20097432f, 0.05552705f, 0.07486021f, 
    -0.00553205f, 0.18185270f, -0.02604383f, 0.25268936f, 0.30098099f, 0.19238427f, -0.00787000f, -0.11883018f, 
    0.07226387f, -0.15896684f, 0.17260244f, -0.16790660f, -0.09917655f, 0.13441342f, -0.06183473f, -0.03133107f, 
    0.04236519f, 0.00651316f, -0.14301950f, -0.01663807f, 0.04393918f, 0.25096485f, 0.14428847f, 0.17736609f, 
    0.29808772f, 0.03270225f, 0.13586849f, -0.05359065f, 0.21694115f, 0.11230743f, 0.15199830f, 0.12335430f, 
    0.18882263f, 0.15295589f, 0.00492942f, -0.34304523f, -0.07341131f, -0.08925452f, 0.07061696f, 0.15960532f, 
    0.11579394f, 0.11362127f, -0.02751230f, 0.15641522f, 0.12467497f, -0.08627947f, -0.08994004f, 0.05245241f, 
    -0.10372270f, -0.10218037f, 0.12002542f, 0.13121027f, 0.01202536f, -0.08349685f, 0.03123460f, 0.13748051f, 
    0.00911281f, 0.09003839f, 0.15923330f, 0.10752668f, -0.33203143f, 0.06520214f, 0.08654805f, 0.03132065f, 
    0.05655311f, 0.04865160f, -0.03669425f, -0.03811567f, 0.09699325f, 0.16670349f, -0.27562106f, 0.06007041f, 
    -0.12741761f, 0.20734929f, -0.06378274f, 0.05208955f, 0.06181346f, 0.13971627f, 0.40077490f, 0.09133692f, 
    0.06395102f, -0.04569410f, 0.04292455f, -0.04421172f, -0.10589608f, 0.13221824f, -0.15893608f, 0.06243673f, 
    0.33825296f, -0.01126147f, -0.06262476f, 0.01244273f, 0.04028041f, -0.01643142f, -0.11699750f, -0.07533271f, 
    -0.21102929f, 0.07189688f, -0.02360310f, -0.03813793f, -0.07529709f, 0.19681898f, 0.11317156f, 0.08964396f, 
    0.01590650f, -0.01569688f, -0.23589921f, -0.04568056f, -0.03822227f, -0.04371719f, 0.14701876f, 0.09107575f, 
    0.07539828f, 0.19928275f, -0.14197288f, 0.15243889f, 0.23903728f, -0.02632243f, 0.12138349f, 0.07950691f, 
    -0.03037949f, 0.23034373f, 0.26495638f, -0.08861017f, 0.20323649f, -0.12944277f, -0.03593120f, 0.00829849f, 
    0.40400818f, 0.05878666f, -0.06678189f, 0.07895022f, 0.18214048f, 0.14848706f, -0.07316399f, 0.30621964f, 
    -0.15699384f, 0.19726634f, 0.10543171f, -0.02745805f, 0.01879464f, 0.15087011f, -0.19436066f, -0.08074315f, 
    -0.05672158f, 0.08855742f, 0.05676800f, -0.04059078f, 0.12075401f, -0.21176733f, -0.00438613f, 0.22448610f, 
    0.00782585f, -0.13836816f, -0.24410699f, 0.07186620f, -0.16852322f, 0.02213283f, -0.04374546f, 0.08655003f, 
    0.13904817f, 0.08306263f, -0.02241919f, 0.27747750f, 0.17374879f, 0.21984948f, -0.08725563f, -0.00461974f, 
    -0.21780951f, 0.07519951f, 0.12471806f, 0.22918169f, 0.08579671f, 0.05478077f, 0.27389783f, -0.01238824f, 
    -0.09966878f, 0.18479005f, -0.13210078f, 0.33161202f, -0.13821675f, 0.20395760f, -0.23430860f, 0.11213885f, 
    -0.12423237f, 0.02233260f, 0.03253064f, 0.29013595f, -0.13471903f, -0.12717882f, -0.01655302f, 0.03181301f, 
    -0.06405949f, -0.14598069f, -0.09628847f, 0.22462466f, 0.22653027f, -0.14767641f, -0.13129459f, 0.32614091f, 
    0.03077886f, -0.14281426f, 0.00215886f, 0.09735710f, -0.23502274f, -0.03876505f, 0.22823039f, 0.04365906f, 
    -0.03868093f, 0.00049902f, 0.22897659f, 0.02726951f, -0.02774379f, -0.16853137f, 0.23947853f, 0.07493223f, 
    -0.02726323f, -0.04113914f, 0.04630132f, -0.11625334f, 0.09953355f, 0.02981468f, -0.14916156f, -0.03234528f, 
    -0.07047646f, -0.02643148f, -0.09787481f, -0.06133307f, -0.01079152f, 0.08537858f, 0.06032421f, 0.06196093f, 
    0.02696135f, -0.04275194f, -0.01418027f, 0.00996854f, 0.11416721f, -0.11745323f, -0.10708338f, 0.02108848f, 
    0.03704138f, -0.05575440f, -0.11318562f, -0.06257888f, 0.02234942f, 0.00521321f, -0.12548801f, -0.08401667f, 
    -0.03767232f, -0.07236230f, 0.10571036f, -0.05221351f, -0.01596603f, -0.02739816f, -0.01681039f, -0.07881822f, 
    -0.10760215f, -0.06977957f, -0.03277396f, 0.01316668f, 0.01691322f, 0.10847061f, 0.07962456f, 0.13607930f, 
    -0.06814672f, -0.12167898f, -0.09044002f, 0.02155650f, 0.06371194f, -0.06562219f, -0.12289849f, 0.12348375f, 
    -0.02240423f, -0.02076828f, -0.08500583f, 0.10726437f, -0.07581291f, -0.10370851f, -0.06774285f, -0.05723162f, 
    -0.01113563f, 0.01434675f, 0.05146092f, 0.10431701f, 0.06376923f, -0.02925166f, -0.11947013f, -0.11483788f, 
    -0.23846883f, 0.00311391f, 0.11451898f, 0.27424985f, 0.08760869f, 0.37406290f, 0.03112183f, 0.13432476f, 
    0.03867115f, 0.11622651f, -0.11049987f, -0.14551371f, 0.07498913f, 0.06857751f, 0.18610631f, -0.03709147f, 
    0.06625755f, 0.20592402f, -0.11431339f, 0.12601657f, 0.11215320f, -0.05344848f, -0.31555027f, 0.26899263f, 
    0.04954120f, 0.02258077f, 0.20568408f, -0.13835159f, 0.19490123f, 0.07466121f, 0.03303108f, -0.03929584f, 
    0.03942922f, -0.10600562f, -0.08778977f, 0.20573691f, 0.11781333f, -0.17092527f, 0.11591672f, -0.16871452f, 
    -0.06193143f, 0.14346445f, 0.00612458f, -0.10640988f, 0.05402887f, 0.13091467f, -0.17807008f, -0.05016226f, 
    0.21994504f, 0.06750604f, -0.04661439f, 0.05310681f, -0.02835204f, 0.08930961f, -0.09795913f, 0.34002143f, 
    -0.12411282f, -0.09078649f, -0.08081935f, -0.00378161f, 0.19555728f, 0.04897164f, -0.29850936f, -0.06281242f, 
    0.09502345f, -0.03149749f, -0.12149581f, -0.02922210f, -0.06366695f, -0.02222387f, -0.04385012f, -0.14295992f, 
    -0.11047433f, 0.11592995f, -0.07801619f, 0.05202892f, -0.10360673f, 0.10215251f, -0.09493772f, -0.03742124f, 
    0.06114772f, -0.00258383f, -0.04493658f, 0.02876995f, -0.00140025f, 0.04595463f, -0.10962142f, -0.08248828f, 
    -0.14237060f, -0.05911927f, -0.09970884f, -0.01887061f, -0.03275245f, -0.06635321f, -0.12480150f, -0.07977670f, 
    -0.12824167f, -0.01869678f, -0.01627406f, 0.05818475f, 0.02130759f, 0.00347101f, -0.11344866f, -0.06052743f, 
    0.00296892f, -0.10346277f, -0.10735105f, -0.03336269f, -0.01047248f, -0.02411097f, -0.10724239f, -0.03176683f, 
    -0.09044489f, 0.08537179f, -0.10192087f, -0.11372900f, -0.06266694f, 0.03686065f, -0.08341661f, -0.03675334f, 
    -0.04372902f, -0.08698893f, -0.12943366f, 0.11312245f, -0.07327770f, 0.00257772f, 0.00342610f, -0.01379849f, 
    -0.05550549f, 0.01822260f, -0.01387695f, -0.08704922f, -0.09087758f, -0.09787887f, -0.13106526f, 0.05355419f, 
    0.01212238f, -0.01803670f, -0.06427157f, 0.04216450f, -0.10715921f, 0.11471308f, 0.09408683f, -0.05583341f, 
    -0.09808869f, 0.10368624f, 0.05696693f, -0.14118829f, -0.14765717f, -0.03059747f, 0.02754338f, 0.08113628f, 
    0.10449318f, -0.04362729f, 0.02172632f, -0.09353470f, -0.10555387f, 0.06872002f, -0.00860950f, 0.01186820f, 
    -0.11937750f, -0.11483771f, -0.08269878f, 0.09660884f, 0.05987922f, 0.01595723f, 0.03976149f, -0.06754309f, 
    0.06515202f, -0.12137877f, 0.01078334f, -0.02340806f, -0.10422848f, -0.01949980f, 0.06511790f, 0.04945354f, 
    -0.04110796f, 0.02214084f, -0.10315477f, 0.09123197f, 0.01032505f, 0.05484141f, 0.04629345f, 0.05415597f, 
    -0.09439776f, -0.03241979f, -0.05781829f, -0.11351242f, 0.10746256f, -0.10842655f, -0.03643313f, 0.00567335f, 
    0.21221571f, -0.14509200f, -0.07509706f, 0.05627462f, 0.16239077f, 0.26163858f, -0.04921410f, 0.10263135f, 
    -0.07572440f, -0.09004780f, 0.04706349f, 0.10434636f, -0.08504123f, 0.00493806f, 0.10758710f, -0.09828797f, 
    0.23806706f, -0.00956149f, -0.01662145f, -0.28373516f, 0.03586726f, 0.02008857f, -0.05266867f, 0.03872368f, 
    -0.09926883f, -0.09800871f, 0.14710325f, -0.01615616f, 0.01885693f, -0.07073102f, -0.04004004f, 0.10620448f, 
    0.04967136f, -0.14391604f, 0.02673327f, 0.16647016f, -0.08106850f, -0.12654470f, 0.27005225f, 0.09670623f, 
    0.29608828f, 0.09231952f, 0.12543726f, 0.20449248f, -0.00722073f, 0.12193381f, -0.29922307f, -0.11600196f, 
    -0.22029077f, -0.02023421f, -0.03815504f, 0.08409905f, -0.00704551f, 0.02580872f, 0.28873691f, 0.03256139f, 
    -0.21358097f, 0.09334924f, 0.06704083f, -0.05746116f, -0.25961614f, 0.01345970f, -0.19041486f, -0.03900753f, 
    -0.09511355f, -0.13201736f, 0.01478383f, 0.03745320f, -0.09326064f, -0.10674971f, 0.08397204f, -0.03689487f, 
    -0.13388045f, 0.05533373f, 0.01733841f, 0.03372599f, 0.05765344f, 0.04571912f, -0.04527042f, -0.02451356f, 
    0.08027295f, 0.05446267f, 0.04886355f, -0.05561518f, -0.12357826f, -0.02115584f, 0.01770667f, 0.05923552f, 
    -0.04602668f, -0.10367405f, -0.00832870f, -0.07422634f, 0.07660702f, -0.05430812f, 0.08096762f, 0.07330850f, 
    -0.03160268f, -0.01392414f, -0.00702438f, 0.09260790f, -0.00487388f, -0.11454772f, -0.09723336f, -0.07102489f, 
    0.07765887f, -0.09456681f, 0.05999622f, -0.08167208f, -0.05308238f, -0.00796345f, -0.02188137f, 0.00088890f, 
    -0.01871950f, 0.05216426f, 0.02720444f, 0.01992536f, -0.04010893f, -0.06769393f, -0.04029499f, -0.13547885f, 
    0.03472536f, 0.09621170f, -0.05557016f, -0.11595824f, -0.01194367f, -0.05061376f, -0.05472444f, -0.08718419f, 
    0.32672960f, 0.04362821f, -0.09312340f, 0.08524970f, 0.05534783f, -0.04614042f, -0.03031898f, 0.16206995f, 
    0.10335205f, 0.04443412f, 0.09573233f, -0.01313009f, -0.08897178f, -0.07437156f, 0.04534654f, 0.11883871f, 
    0.08234520f, -0.12009423f, 0.03360217f, 0.09399667f, -0.02212143f, 0.18328403f, 0.03824520f, -0.21544132f, 
    -0.10439254f, -0.09021380f, -0.35592693f, 0.10933029f, 0.04634944f, 0.24187584f, 0.11047672f, 0.03736208f, 
    -0.27595434f, 0.21006359f, 0.08655439f, 0.14209653f, 0.08290245f, 0.07864358f, 0.15198569f, -0.04213567f, 
    0.07474349f, -0.07205258f, 0.20591757f, -0.16850556f, -0.20695113f, -0.02342891f, -0.14670585f, 0.12191489f, 
    -0.16153923f, 0.07300302f, -0.04132079f, 0.02576625f, -0.12250930f, 0.28525746f, 0.35561368f, -0.04608219f, 
    0.04624818f, 0.06994113f, 0.23935407f, 0.08979760f, -0.06478573f, -0.11530218f, -0.05506297f, 0.04710953f, 
    -0.12101912f, 0.14238746f, -0.10564361f, -0.17667495f, 0.08954640f, -0.06967849f, 0.01026889f, 0.03564151f, 
    0.11505813f, 0.07639945f, -0.01803769f, 0.13838270f, 0.10066503f, -0.06531638f, 0.01140743f, -0.10665791f, 
    -0.11305629f, 0.19592112f, -0.06908704f, 0.12260652f, -0.17665039f, 0.00687457f, 0.11227504f, 0.11629868f, 
    0.00999774f, -0.15682936f, 0.01445421f, 0.13847026f, 0.00246510f, -0.00105408f, -0.07785812f, 0.03279190f, 
    -0.17528497f, 0.22378364f, 0.08208836f, 0.08494401f, 0.16827238f, 0.13266481f, 0.06850205f, 0.26933107f, 
    0.18685175f, -0.05987548f, 0.16502737f, -0.04337741f, 0.15936144f, 0.21110711f, -0.04073943f, 0.07619619f, 
    -0.05790209f, -0.00036529f, -0.05552050f, -0.09266154f, -0.05441903f, -0.28255427f, 0.10820964f, 0.01189283f, 
    0.19232215f, 0.03857456f, -0.14096248f, -0.07541268f, -0.25776210f, 0.12116024f, -0.13996834f, 0.04007844f, 
    0.09593773f, -0.05223881f, 0.06424011f, -0.18622810f, 0.14708325f, -0.22032973f, -0.10288905f, 0.15697835f, 
    0.29461649f, -0.03312806f, -0.10643271f, -0.21626160f, 0.01112929f, 0.09449695f, -0.04483066f, 0.10712966f, 
    0.08449846f, -0.21241869f, 0.01504583f, -0.26136786f, 0.13899381f, -0.15771875f, 0.14440489f, 0.01805035f, 
    0.05148031f, -0.00818507f, 0.03976104f, -0.21191394f, 0.19848818f, -0.01813404f, 0.08168138f, 0.04143167f, 
    0.05875001f, 0.04430907f, 0.03156422f, -0.13935912f, -0.36690035f, 0.11727269f, 0.22466657f, -0.36188379f, 
    0.12222058f, 0.17294204f, -0.13101947f, 0.26708364f, 0.09129480f, 0.01460808f, 0.11080740f, -0.04771945f, 
    0.07681841f, -0.11393012f, 0.07541297f, 0.06823912f, -0.05602558f, 0.28790790f, 0.02578300f, -0.14105541f, 
    -0.13004680f, 0.10223018f, 0.24855229f, -0.07828138f, 0.14753373f, 0.10839941f, 0.22915755f, 0.07077430f, 
    -0.17785290f, 0.10713612f, -0.08758030f, -0.01255754f, -0.04384983f, 0.27537596f, -0.12940043f, 0.00916239f, 
    0.02913039f, -0.05786674f, 0.06832606f, -0.26083055f, -0.09628905f, 0.05534196f, 0.21791795f, 0.10955311f, 
    0.23757337f, 0.28142834f, 0.10477548f, 0.39472339f, 0.13841960f, -0.19655117f, -0.04746566f, -0.01113863f, 
    -0.02857013f, 0.07494184f, 0.14785555f, -0.02873437f, 0.26866475f, -0.03907564f, -0.02681505f, 0.05281033f, 
    0.44422647f, -0.11760230f, 0.05933261f, 0.25572532f, 0.04486548f, 0.04672455f, 0.05285547f, -0.28557879f, 
    -0.01686617f, 0.06735765f, 0.05703272f, 0.16199881f, 0.20222111f, -0.07684734f, 0.04266546f, 0.07701438f, 
    0.22639638f, -0.09460783f, 0.17144981f, 0.01708375f, 0.01685903f, 0.00113163f, -0.19683217f, 0.19507550f, 
    0.11073773f, 0.11909170f, -0.32222122f, 0.10081413f, 0.25330913f, -0.07045076f, -0.25512856f, 0.08214623f, 
    0.20762727f, 0.00547659f, 0.02383663f, -0.32682374f, 0.00725042f, -0.31816718f, -0.11169480f, 0.06734336f, 
    0.04919526f, 0.01522237f, 0.16529214f, 0.14180893f, 0.09815058f, -0.02041915f, -0.13018079f, 0.07853466f, 
    0.14210261f, 0.13794027f, 0.06173050f, 0.21332286f, -0.19347651f, -0.11658977f, 0.13341674f, -0.00142685f, 
    0.06868687f, -0.06986256f, -0.10084661f, -0.00840157f, -0.24443622f, -0.07485635f, 0.05212462f, 0.07837470f, 
    -0.08490110f, 0.08780710f, -0.01565585f, -0.07454631f, 0.21853383f, 0.23904200f, -0.10223617f, 0.34228033f, 
    -0.06664130f, 0.07503133f, 0.00576322f, 0.01176235f, -0.09353808f, 0.06672992f, 0.22403218f, -0.08439460f, 
    0.03731432f, 0.11104475f, -0.00964411f, 0.01819217f, 0.08300109f, -0.20018114f, 0.08814062f, 0.06199783f, 
    0.15842830f, 0.04779871f, 0.17214718f, 0.02499846f, -0.03514141f, 0.02623028f, 0.09865960f, 0.11603086f, 
    0.25253046f, -0.13003986f, -0.01238283f, -0.15738994f, 0.18503273f, 0.16827759f, 0.10036936f, 0.28965694f, 
    0.12826103f, 0.04892722f, -0.05217393f, 0.05354881f, -0.02310696f, 0.11289991f, -0.12896253f, 0.05527805f, 
    0.43852749f, 0.15610024f, -0.26665834f, -0.02172175f, 0.03731578f, -0.04701263f, 0.00074055f, -0.13351990f, 
    -0.04839507f, -0.07725386f, 0.10524020f, 0.09011823f, -0.32088900f, -0.03677513f, 0.08976346f, 0.05622202f, 
    0.19730760f, 0.02482992f, -0.09454666f, 0.03814561f, 0.02962918f, 0.00682599f, 0.08172841f, 0.24517043f, 
    0.03583016f, 0.19843149f, -0.15268566f, 0.05959826f, -0.07447113f, 0.16681255f, 0.12565996f, 0.09630778f, 
    -0.13093016f, 0.02528937f, 0.01285018f, -0.06558901f, 0.03384714f, 0.06531726f, -0.01337125f, 0.29818603f, 
    -0.09480455f, 0.10450293f, 0.23778011f, 0.01966530f, -0.29687664f, 0.00874531f, -0.01478877f, -0.06849363f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.04367266f, 0.14804399f, 0.01396958f, -0.05661399f, -0.11770560f, -0.09651805f, -0.01382993f, 0.10341230f, 
    -0.09273502f, 0.05348678f, 0.09317642f, 0.16810608f, 0.00616511f, -0.09778689f, -0.07847911f, -0.06682819f, 
    -0.09204414f, 0.00128756f, -0.08925719f, 0.07247134f, 0.02141578f, -0.02449693f, 0.12513159f, 0.07322134f, 
    -0.10105923f, 0.05549832f, -0.07468727f, -0.07879103f, 0.16444089f, 0.00429434f, 0.06289138f, -0.03693832f, 
    -0.00414747f, 0.17848711f, 0.08295074f, 0.12203266f, 0.11834839f, -0.10005631f, -0.01582620f, -0.05144614f, 
    0.02361942f, 0.06439567f, 0.14419714f, -0.08110169f, -0.10547763f, 0.05730107f, -0.02787739f, -0.12638545f, 
    0.10578253f, 0.00249805f, -0.03456920f, 0.03846556f, -0.11348571f, 0.12943283f, 0.06592258f, -0.10686226f, 
    0.09535525f, -0.07316227f, 0.04260499f, 0.09065954f, 0.06890799f, 0.05929615f, -0.12691201f, 0.01237801f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.14936048f, -0.19957876f, 0.08573392f, 0.05351511f, 0.07167441f, 0.14508939f, -0.19852214f, 0.02326301f, 
    -0.43620881f, 0.02193050f, -0.37017798f, -0.08982427f, 0.05663415f, -0.13204755f, 0.10696548f, 0.01285415f, 
    -0.27333143f, -0.21897300f, 0.02237078f, -0.16290569f, -0.12287173f, -0.33372569f, -0.03307826f, -0.00625904f, 
    0.23900381f, 0.12906341f, -0.08645952f, 0.08982788f, -0.08472150f, 0.24998222f, -0.05690354f, 0.23782001f, 
    -0.03698092f, -0.48689345f, -0.04585411f, -0.22306684f, -0.01087748f, 0.19124298f, -0.42182180f, 0.03179711f, 
    0.01685235f, -0.12768923f, 0.08736838f, 0.14622095f, -0.05732026f, 0.13684709f, -0.01267647f, 0.29056445f, 
    0.20156495f, 0.05039768f, -0.30893570f, -0.15070394f, 0.06799877f, -0.41993946f, 0.09072118f, 0.03102163f, 
    -0.08171275f, -0.08039856f, 0.19626819f, 0.01779663f, 0.19184519f, -0.34576359f, 0.32898837f, -0.05732621f, 
    0.03601354f, 0.18660821f, -0.01504344f, 0.01350046f, -0.15605281f, -0.13747953f, 0.15734051f, -0.07415903f, 
    0.33812365f, -0.04097896f, -0.20977926f, 0.21853259f, -0.17651074f, 0.27524516f, 0.24428196f, -0.32502612f, 
    0.08383020f, 0.00933311f, 0.06359675f, -0.36869484f, 0.02557735f, 0.20673010f, -0.01571516f, -0.12273043f, 
    -0.17677730f, 0.18586588f, -0.46073946f, 0.10807747f, 0.02122383f, -0.26838824f, -0.06416865f, 0.30356699f, 
    0.00602315f, -0.34741399f, 0.10910590f, 0.06718189f, 0.05901202f, -0.06016625f, -0.18551280f, 0.12484454f, 
    -0.04227785f, -0.14005183f, 0.15321009f, 0.11328805f, 0.21973808f, -0.26041275f, -0.17167456f, 0.21845116f, 
    0.03533637f, -0.17801441f, 0.09572455f, -0.05517647f, 0.10905881f, 0.03107242f, 0.01556305f, -0.05519551f, 
    0.24960236f, -0.00549628f, 0.12310122f, -0.13283090f, -0.06570653f, -0.07202759f, -0.17893353f, 0.23545749f, 
    -0.13028052f, 0.16433419f, -0.05153183f, 0.07769801f, 0.21924877f, 0.02440132f, -0.31286043f, 0.17752309f, 
    -0.46697369f, -0.25255853f, -0.09666072f, -0.33714569f, 0.03247927f, -0.16949156f, -0.05272070f, -0.05205980f, 
    -0.03623505f, 0.22603941f, 0.00933544f, -0.16850713f, 0.08858524f, -0.40975857f, -0.30904534f, 0.03730235f, 
    -0.13413849f, -0.28165710f, 0.02144038f, -0.05166799f, 0.20258303f, 0.12120748f, -0.05597604f, 0.11952440f, 
    -0.04916918f, -0.12066150f, 0.00247751f, 0.05616199f, -0.01791675f, 0.18239278f, 0.32190341f, -0.52408326f, 
    0.03201005f, 0.11923875f, 0.10734694f, 0.05559598f, 0.06472498f, -0.15423091f, -0.08278970f, 0.36466438f, 
    0.11586383f, -0.12973559f, -0.07503622f, 0.17367922f, 0.07889589f, 0.14727628f, -0.00554300f, 0.11014190f, 
    -0.32502690f, 0.02620816f, -0.08419892f, -0.49743190f, -0.13555297f, -0.07381719f, -0.12032639f, -0.24052347f, 
    0.11375947f, -0.27539545f, -0.05095763f, 0.00255171f, -0.02105611f, -0.17403066f, -0.45519856f, 0.15972689f, 
    -0.50328559f, 0.10335780f, 0.01436136f, -0.30292392f, -0.35519004f, 0.29135701f, -0.24273722f, 0.00976026f, 
    0.01028717f, -0.56894648f, 0.09763056f, -0.16520721f, 0.07920151f, -0.02831124f, 0.19994217f, -0.09360310f, 
    0.02325852f, 0.07314412f, 0.07924611f, -0.02527607f, -0.29600158f, 0.05413906f, -0.02417539f, -0.33742967f, 
    0.02957490f, 0.15491603f, -0.32514945f, -0.02947408f, -0.44355220f, 0.15218812f, -0.30521223f, 0.16263999f, 
    -0.12602688f, 0.13018450f, 0.22522467f, -0.09342999f, -0.29717749f, -0.16635425f, -0.05632155f, -0.15554294f, 
    0.00643193f, 0.24629727f, 0.20528153f, -0.11255655f, -0.07108823f, -0.04243888f, -0.08382277f, -0.05183128f, 
    -0.39319524f, 0.02260393f, -0.30542895f, 0.07518330f, -0.22544082f, 0.22831826f, 0.35583755f, 0.24357420f, 
    0.10790356f, 0.07875667f, -0.02992367f, 0.03784394f, 0.16741779f, 0.11025469f, 0.01155268f, 0.12536980f, 
    0.07325605f, -0.03052971f, 0.21777634f, -0.05683015f, 0.18770202f, -0.07122479f, -0.03774849f, 0.19872068f, 
    -0.25944608f, -0.16146503f, 0.04764551f, 0.06266098f, 0.06298066f, -0.18344133f, 0.24464232f, -0.01797998f, 
    -0.25143966f, 0.21986243f, -0.26629493f, 0.10362691f, -0.01054910f, 0.02312891f, 0.00468727f, 0.08972967f, 
    -0.00275996f, 0.05545325f, -0.40805110f, -0.20152245f, -0.15466116f, -0.20968820f, 0.16347520f, -0.01682132f, 
    0.01908654f, -0.14219838f, -0.05694169f, -0.16788636f, -0.29466218f, 0.23721369f, 0.10651948f, 0.02491245f, 
    -0.17870428f, 0.01968166f, 0.19276519f, 0.22943790f, 0.04468500f, -0.11647126f, -0.09307321f, 0.03268582f, 
    0.10848733f, -0.08422514f, -0.21540220f, 0.18241391f, -0.37282854f, -0.10058447f, 0.07966723f, -0.11218268f, 
    -0.00658699f, 0.23451665f, -0.07618481f, -0.09124517f, -0.34963945f, 0.09152563f, 0.22646911f, -0.05845971f, 
    -0.44588703f, 0.21636711f, 0.33262402f, 0.15460680f, -0.03047868f, 0.06543712f, -0.02262732f, -0.32154939f, 
    0.21575427f, 0.18640627f, 0.07400176f, -0.00221583f, 0.16166726f, 0.06100298f, 0.31837043f, 0.09962266f, 
    0.23086777f, 0.04117510f, 0.02415521f, 0.05450067f, 0.22323874f, -0.15117435f, -0.03668134f, -0.00629126f, 
    -0.02958847f, -0.05524639f, 0.05114972f, 0.12490649f, -0.15476845f, -0.26974931f, -0.57842946f, 0.14138348f, 
    -0.07503074f, -0.28562266f, 0.12194301f, -0.22092839f, -0.24040808f, -0.07912148f, 0.06217913f, -0.63997030f, 
    0.03768144f, -0.04041526f, -0.10979324f, -0.14460357f, -0.04028566f, -0.32914454f, 0.01848113f, -0.09047561f, 
    -0.00871101f, -0.05077615f, 0.19341293f, 0.08762992f, 0.09987930f, -0.26153639f, 0.09253090f, -0.14252797f, 
    0.19835602f, -0.44963470f, -0.11142143f, 0.03944946f, -0.24756950f, 0.32095695f, -0.10496341f, -0.51201844f, 
    -0.47508922f, 0.22254442f, -0.05590112f, 0.01922033f, 0.18812142f, -0.02457616f, -0.05955051f, -0.01172191f, 
    0.29075271f, -0.03969255f, 0.09214344f, 0.03816192f, -0.01811708f, -0.06679332f, -0.59795225f, 0.08082914f, 
    -0.14174969f, -0.16824774f, 0.12185057f, 0.05062985f, -0.09995402f, 0.02620323f, -0.05477331f, -0.09185842f, 
    0.10977407f, 0.02896636f, -0.23331197f, 0.24915814f, 0.10479461f, -0.26424336f, -0.49000022f, -0.05128508f, 
    0.08461803f, 0.09384788f, -0.20676656f, -0.50893623f, 0.10571238f, -0.04410374f, 0.02868195f, -0.03162209f, 
    0.23698618f, -0.00186182f, 0.03530365f, -0.00993100f, 0.05499131f, 0.16387308f, 0.07263344f, 0.13334224f, 
    -0.05978335f, -0.01973009f, 0.15173419f, 0.11694255f, -0.19629455f, 0.27418467f, -0.42053899f, -0.44231126f, 
    -0.07616753f, -0.11466703f, 0.03952264f, -0.10350464f, 0.06834432f, -0.25449094f, -0.15751830f, 0.05491339f, 
    0.30715805f, -0.29581439f, 0.02860184f, -0.23998208f, -0.29949018f, -0.14614974f, -0.27233887f, 0.23611522f, 
    0.12163465f, 0.11640713f, -0.02607570f, 0.18220587f, -0.04144895f, 0.21849798f, 0.18973373f, -0.07737654f, 
    0.16349009f, 0.17120305f, 0.00516922f, -0.06923629f, -0.44174600f, 0.25357181f, -0.07600435f, -0.01727721f, 
    0.06498305f, -0.21911743f, 0.13416940f, 0.04581436f, -0.14752123f, 0.24278124f, 0.17282172f, -0.18930511f, 
    0.00755157f, -0.11157164f, -0.32207581f, 0.17760070f, -0.25082451f, 0.24853802f, -0.20787206f, 0.18044105f, 
    -0.38880354f, 0.14747959f, -0.00435058f, -0.27369958f, -0.08135485f, -0.07243906f, 0.01845233f, 0.02912777f, 
    -0.24553379f, 0.04173556f, 0.08873279f, -0.05852394f, 0.08259317f, -0.13984041f, -0.29609030f, -0.11707079f, 
    -0.45404065f, 0.30656159f, -0.11509429f, -0.03632203f, 0.20965508f, -0.42743638f, 0.25885448f, -0.08783685f, 
    -0.29344472f, -0.03766048f, 0.01810248f, 0.16547436f, 0.22851494f, -0.21414603f, -0.23723756f, -0.14739035f, 
    -0.21273075f, -0.00869686f, 0.05893576f, -0.04790720f, 0.06805063f, 0.23479733f, -0.12308354f, 0.09320628f, 
    -0.25232661f, -0.04847273f, 0.02054481f, 0.03662992f, 0.11468664f, -0.19952665f, 0.09306320f, -0.40351868f, 
    -0.01472398f, -0.09467099f, 0.17493647f, -0.31029555f, 0.28385478f, 0.06979489f, -0.00647107f, -0.39551753f, 
    -0.05339083f, -0.38512710f, 0.21058051f, 0.07199436f, -0.14577860f, -0.10853655f, -0.27038538f, -0.14060098f, 
    0.00840256f, -0.41581488f, -0.11263901f, 0.19956021f, -0.02323104f, 0.12263034f, 0.03774315f, -0.09728580f, 
    0.11586727f, -0.12483232f, 0.03247075f, 0.01867028f, -0.33770967f, 0.19081879f, -0.08570706f, -0.12391895f, 
    -0.21519414f, -0.33353916f, 0.08459518f, 0.05643829f, 0.07044208f, 0.12374149f, -0.14703096f, -0.21484831f, 
    0.19212237f, -0.03491380f, 0.17899513f, -0.33307466f, -0.08198581f, -0.24787197f, 0.00242222f, 0.09413918f, 
    -0.20953038f, 0.17213054f, -0.08041066f, 0.20850606f, -0.02949902f, -0.20450258f, -0.16437471f, -0.05400252f, 
    0.12229587f, 0.02060327f, 0.02127687f, -0.07698094f, 0.08179985f, -0.09955423f, 0.04284337f, 0.08179890f, 
    -0.09201575f, 0.04103789f, 0.08662244f, -0.27643737f, 0.18691659f, 0.06582818f, -0.02062698f, 0.22956166f, 
    -0.02699950f, -0.27619216f, -0.16927828f, -0.00851405f, 0.04858373f, 0.16703302f, 0.27157718f, -0.33011118f, 
    -0.08177910f, -0.00317791f, 0.09390948f, -0.28424728f, 0.01715075f, -0.11923628f, 0.09053554f, -0.01468092f, 
    -0.10836998f, -0.04641275f, -0.48882312f, -0.23722276f, 0.32894197f, 0.19957110f, -0.36682519f, -0.32646388f, 
    0.15486775f, -0.04256424f, -0.10994877f, 0.07403027f, -0.15562242f, -0.15225008f, -0.16939099f, 0.13839264f, 
    0.24393356f, -0.21757574f, -0.01865227f, 0.14453129f, -0.20735221f, -0.32627735f, -0.69749695f, -0.05969007f, 
    -0.03104296f, 0.15447210f, -0.13062885f, -0.24780445f, -0.04630133f, -0.41155750f, -0.16302668f, 0.06588385f, 
    -0.02937317f, -0.17784816f, 0.24955617f, -0.00339856f, 0.13882554f, 0.10134141f, -0.12310614f, -0.35153210f, 
    0.12647761f, 0.22112882f, -0.09185987f, 0.18796231f, -0.12610735f, -0.01291499f, 0.01324582f, -0.18847027f, 
    0.03133750f, -0.04197501f, 0.07402636f, 0.18084773f, -0.34549195f, -0.32298422f, -0.14143960f, 0.23526779f, 
    -0.03259020f, -0.13759719f, 0.16883756f, -0.48457438f, -0.06651480f, 0.26913404f, 0.07795940f, 0.09028424f, 
    0.23179515f, 0.09298383f, -0.31213138f, 0.10253138f, 0.25758043f, 0.10547514f, -0.28069156f, 0.11047386f, 
    0.04055039f, -0.00904194f, 0.06039252f, -0.00292582f, 0.15313777f, 0.15477769f, -0.12305825f, 0.07877573f, 
    -0.51535755f, -0.01749426f, -0.28543741f, 0.21075231f, -0.07413148f, -0.15599525f, 0.26775187f, -0.14429742f, 
    -0.21672441f, -0.07670108f, 0.02817288f, 0.11144766f, 0.10215745f, 0.27037567f, 0.06014172f, 0.06807089f, 
    0.15859081f, -0.44769531f, 0.09038430f, -0.05604785f, -0.13483116f, -0.10003905f, -0.02888325f, -0.48129806f, 
    -0.02242850f, 0.19141807f, -0.22119205f, 0.03580714f, -0.22422723f, -0.39582497f, -0.50725973f, -0.16905223f, 
    0.02384466f, 0.32882434f, -0.29504916f, 0.15179448f, 0.41617873f, -0.01355178f, -0.28389412f, -0.30917475f, 
    -0.17737380f, 0.07764687f, -0.33843067f, 0.15643600f, 0.05069061f, 0.00463493f, -0.00825872f, 0.08193690f, 
    0.17419107f, -0.07616764f, -0.08334893f, -0.17180023f, 0.28530714f, -0.02577582f, -0.08406945f, 0.21922623f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03006137f, -0.04536085f, 0.04360120f, 0.05319345f, 0.03091604f, 0.01662949f, -0.08501108f, 0.07732186f, 
    -0.02453803f, -0.10374913f, 0.00538112f, 0.04260474f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
