#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.59541988f, -0.15349913f, 0.73407483f, 0.61948049f, 0.45022386f, -0.26614293f, 0.26009259f, 0.43540120f, 
    0.23596859f, 0.25426662f, -0.23101045f, -0.06464537f, 0.48410347f, 0.22151434f, -0.03800767f, 0.13701546f, 
    -0.08361206f, 0.23274887f, 0.34989935f, 0.10376791f, 0.16182218f, 0.06805250f, -0.45122141f, -0.07897432f, 
    -0.19978514f, -0.31618741f, 0.85329545f, 0.38108245f, 0.24931094f, 0.09213718f, 0.16745786f, 0.66663462f, 
    0.15882178f, 0.15610178f, 0.47206998f, -0.18441829f, 0.00270705f, 0.11326269f, -0.56967032f, 0.50283992f, 
    0.04988050f, -0.02136480f, -0.12727818f, -0.08514162f, -0.00348279f, -0.21131258f, 0.47513577f, 0.36372948f, 
    0.39713266f, 0.38196272f, 0.40263009f, 0.03857499f, 0.67716485f, 0.85514456f, -0.65440440f, -0.31865206f, 
    -0.41189456f, 0.22565132f, -0.02903339f, 0.09375910f, -0.20227115f, -0.22664094f, -0.48572540f, 0.22444025f, 
    -0.27339393f, -0.10042106f, 0.33121207f, 0.28405756f, -0.43041930f, -0.40669796f, 0.16415243f, -0.03107931f, 
    -0.46100312f, -0.10538349f, -0.29008710f, 0.75998539f, 0.37290245f, 0.73625827f, 0.25419956f, -1.09704077f, 
    0.01837593f, -0.65036184f, 0.38651121f, -0.10306358f, 0.55745614f, 0.28150943f, 0.13158128f, -0.19670461f, 
    -0.18198217f, 0.03567402f, -0.26079965f, -0.11607144f, 0.13741742f, -0.17640945f, -0.08091979f, -0.04296636f, 
    -0.08853584f, -0.24180534f, 0.12511200f, 0.00286860f, -0.32908636f, -1.31606925f, 0.02090040f, 0.71589202f, 
    0.07342111f, -0.13353343f, 1.10224855f, 0.49382135f, -0.49028483f, 0.38071901f, -0.22627565f, 0.28630051f, 
    0.16069067f, 0.27621084f, 0.09925121f, -0.39806932f, -0.05372827f, -0.13766684f, 0.16400895f, -0.18030681f, 
    -0.01247561f, 0.09117664f, -0.05214222f, -0.11800759f, -0.06105805f, 0.42870897f, 0.48365951f, 0.18998887f, 
    -0.69808030f, -0.70457309f, -0.17995572f, -0.25702408f, -0.19236611f, -0.02489848f, -0.54347724f, 0.24073943f, 
    0.55149400f, 0.08922298f, 0.27084905f, 0.11749287f, 0.07241087f, -0.08258613f, 0.38595855f, 0.05699309f, 
    0.52223670f, 0.07462521f, 0.15946260f, 0.03679883f, 0.39375132f, -0.03547116f, 0.73119467f, 0.91336197f, 
    -0.45119858f, 0.32520741f, -0.72014898f, 0.18447654f, 0.17987353f, -0.58103675f, 0.20714274f, -0.36124432f, 
    0.29916158f, -0.11929608f, -0.33484045f, -0.18426515f, 0.13275960f, 0.36825129f, 0.09763676f, 0.32901502f, 
    0.26919082f, -0.09826466f, -0.20864414f, -0.22784616f, -0.25062981f, -0.13998722f, 0.11159570f, -0.41719741f, 
    -0.97349381f, -0.60957235f, 0.23976943f, -0.16569869f, -0.40801579f, -0.30217919f, 0.08565264f, 0.17175722f, 
    0.02328583f, 0.31255931f, 0.22385298f, 0.13881767f, 0.30589607f, 0.12208541f, 0.40431508f, 0.29217827f, 
    -0.16519293f, 0.13086003f, 0.03680967f, 0.15939406f, -0.12221142f, 0.16675659f, -0.15424268f, 0.30967531f, 
    0.94140577f, 0.01312093f, 0.01336663f, 0.59349483f, 0.23172151f, -0.48968455f, 0.12260765f, 0.21748319f, 
    0.06109845f, 0.41909432f, 0.21286826f, 0.16743913f, -0.11304100f, -0.22966826f, -0.10959627f, -0.16979110f, 
    -0.13044885f, 0.17111124f, -0.41595483f, 0.33081713f, 0.14686181f, -0.16366594f, 0.52155280f, -0.22301519f, 
    0.07500455f, 0.94171625f, -0.62121147f, -0.04337230f, 0.24890150f, -0.04741930f, 0.56096059f, -0.04016724f, 
    0.39344251f, 0.16590172f, -0.35522717f, 0.06066255f, 0.40202528f, -0.40351599f, 0.33870301f, -0.15327987f, 
    0.19652684f, -0.17740703f, -0.55633122f, 0.01063326f, 0.31993064f, -0.20820205f, -0.27975723f, -0.20297889f, 
    -0.14542948f, 0.29864654f, 0.21510746f, 0.24978234f, 0.38133764f, 0.81856751f, -0.13012576f, -0.00859017f, 
    0.43069857f, 0.06610321f, 0.57526839f, 0.26262748f, -0.21111861f, 0.12154375f, -0.37541425f, -0.31571734f, 
    -0.05984172f, -0.15389019f, -0.22557154f, 0.07191027f, -0.08017515f, 0.18221673f, -0.27432632f, 0.37549132f, 
    0.18248527f, -0.14540242f, -0.17597878f, 0.42158148f, 0.20838098f, -0.49087954f, 0.62869030f, 0.51656383f, 
    0.16205718f, -0.72375077f, -0.30687952f, -0.58831918f, -0.47611153f, 0.11408068f, 0.42032421f, 0.05569421f, 
    -0.07019628f, -0.39684483f, -0.20307446f, -0.17974912f, 0.21081351f, 0.26394171f, -0.44493374f, -0.01747217f, 
    0.20149893f, -0.23138480f, 0.12963653f, 0.34907070f, -0.09406346f, -0.26983601f, -0.57802784f, -0.62531376f, 
    -0.35092282f, -0.34960419f, 0.62338585f, 0.54350585f, -0.03487296f, 0.31824449f, -0.12504956f, -0.03688824f, 
    0.13446492f, -0.02260114f, -0.36470625f, 0.08609588f, 0.32596067f, 0.21598171f, 0.06087433f, -0.22042106f, 
    -0.39085773f, 0.26293150f, -0.01349282f, -0.18997425f, 0.11677553f, 0.93665951f, 0.38773376f, -0.94194007f, 
    0.07191710f, -0.71916473f, -0.40138608f, 0.03457050f, -0.21392064f, 0.41378036f, -0.38490000f, -0.05406688f, 
    -0.01920968f, 0.52904862f, -0.04538996f, -0.26032856f, -0.09150384f, 0.22769926f, 0.14284828f, 0.09527490f, 
    0.21619393f, -0.18698783f, 0.18406111f, -0.09681740f, 0.00987251f, 0.05291053f, 0.24915437f, 0.45803291f, 
    -0.23542365f, 0.18368426f, -0.56132483f, -0.42374608f, 0.01482128f, 0.04835134f, 0.29831126f, -0.60385889f, 
    0.07031771f, -0.00190421f, 0.47967091f, 0.13120344f, 0.60153913f, -0.27989319f, -0.63170987f, 0.38342047f, 
    -0.21349593f, -0.06832425f, 0.14142396f, -0.40029040f, -0.15601555f, -0.27005839f, 0.00801457f, -0.48439780f, 
    0.34712687f, 0.71053368f, -0.21984072f, 0.72594905f, 0.53580981f, 0.22351356f, 0.71832788f, 0.43803334f, 
    -0.14339836f, -0.31508279f, 0.19751054f, -0.18625812f, -0.00756437f, 0.04401621f, -0.04378205f, 0.12190370f, 
    -0.32502732f, 0.16337276f, 0.03829452f, 0.10655829f, 0.04961512f, -0.34140036f, 0.14386369f, 0.33665916f, 
    -0.36088112f, -0.40060639f, -0.31082419f, -0.54538840f, 0.10584331f, 0.01583691f, -0.29742852f, 0.17172892f, 
    0.34208471f, -0.54725444f, -0.30795908f, -0.53067172f, 0.31290501f, 0.07335356f, -0.11936820f, -0.11857096f, 
    -0.22733058f, -0.14903969f, -0.64865273f, -0.27764213f, -0.28386027f, -0.06221789f, 0.37882569f, 0.45552769f, 
    0.05798813f, -0.33044118f, 0.18205373f, 0.89802694f, 0.35234058f, -0.40036860f, -0.16042474f, 0.17014278f, 
    -0.27209863f, 0.11523069f, -0.01441804f, -0.09153677f, 0.45038751f, -0.47056243f, 0.21721542f, 0.33807477f, 
    0.13685475f, 0.31143394f, 0.02693860f, -0.33007205f, -0.26385295f, -0.28400496f, -0.29125381f, 0.15544614f, 
    -0.36345997f, -0.05004187f, 0.09358836f, 0.05027556f, 0.66668814f, 0.71440512f, 0.58778429f, -0.75194281f, 
    0.42942637f, -0.64845514f, -0.59042442f, -0.09654891f, 0.35367939f, -0.12390201f, 0.22056542f, 0.13184032f, 
    0.12642749f, -0.26214463f, 0.23434463f, 0.06452174f, 0.14354746f, 0.00822892f, 0.17785302f, 0.42423338f, 
    0.05469133f, 0.17204696f, 0.28290609f, -0.60501009f, -0.47954980f, -0.73152077f, -0.50322801f, -0.47010785f, 
    0.19516064f, -0.34842572f, 0.10727684f, 0.05994007f, 0.53593463f, -0.32590345f, -0.17185582f, 0.05889593f, 
    -0.10491410f, -0.09897671f, -0.02414561f, 0.42726168f, 0.37011644f, 0.01189788f, 0.33292460f, -0.08715121f, 
    0.19518122f, -0.10864977f, 0.09773649f, 0.54651964f, 1.07122457f, 0.43433973f, 0.74428058f, -0.73795229f, 
    -0.45455995f, 0.37537903f, -0.08056849f, 0.35209581f, 0.26246008f, 0.27553475f, -0.00442475f, 0.26953295f, 
    -0.22341035f, -0.22303277f, -0.22379433f, 0.11602685f, 0.17054059f, 0.07565201f, 0.17254607f, -0.12319438f, 
    0.24309219f, 0.15333129f, -0.17575389f, 0.02472074f, 0.02833653f, 0.12854183f, -0.92794657f, -0.07254839f, 
    0.53199250f, 0.10716342f, -0.76218063f, 0.15515339f, -0.34972543f, -0.51666123f, 0.44754526f, 0.24049772f, 
    0.51545876f, -0.10844740f, -0.28222737f, 0.24938132f, 0.04962405f, 0.20478204f, 0.38652027f, 0.07531012f, 
    -0.48440066f, -0.02604712f, -0.37037438f, -0.25105035f, 0.10680695f, -0.07822000f, -0.62966126f, -0.74912959f, 
    -0.22200577f, 0.30076748f, 0.10681321f, -0.61552733f, 0.07513135f, 0.60813743f, -0.58290970f, 0.03786628f, 
    0.52787411f, 0.28260383f, -0.02229074f, -0.26037806f, 0.12527530f, -0.40681866f, 0.29142419f, 0.03567307f, 
    0.25230470f, -0.24895893f, -0.18297344f, -0.35726094f, 0.02829399f, 0.01332326f, 0.13910769f, -0.50449187f, 
    0.08353733f, 0.67915750f, -0.80245167f, 0.44995749f, 0.28349113f, -0.45720637f, -0.51806897f, -0.10330038f, 
    -0.28088060f, 0.38656905f, -0.09892049f, -0.39299998f, -0.46736854f, -0.16058317f, 0.33935684f, -0.05859630f, 
    -0.34248647f, -0.29159662f, -0.27259922f, 0.17084098f, 0.10028190f, -0.09780792f, 0.25619984f, -0.06959528f, 
    -0.61349088f, -0.77902603f, 0.06366629f, 0.86880881f, -0.74023235f, -0.21447480f, 0.71840197f, 0.53628176f, 
    0.24725230f, -0.19361861f, 0.30846936f, -0.27779862f, -0.08367418f, 0.12680897f, -0.01300447f, -0.10964774f, 
    -0.09668511f, 0.02107395f, -0.49410096f, -0.12746620f, -0.03277130f, 0.11388414f, 0.25810695f, 0.30300692f, 
    0.12594219f, 0.80986428f, 0.03203353f, 0.55726528f, 0.85636318f, 1.00698376f, 0.94513661f, 0.19993615f, 
    -0.42257527f, -0.36711133f, -0.32140973f, -0.15527192f, 0.08471674f, -0.10931449f, 0.22797816f, -0.11264135f, 
    0.10461617f, 0.16812772f, 0.28928959f, 0.32122025f, -0.03182297f, 0.00759207f, 0.31417552f, 0.04935851f, 
    0.06267774f, 0.05386307f, 0.34819651f, -0.40510529f, -0.51859617f, -0.47568843f, -0.60134923f, 0.38152358f, 
    0.12684144f, 0.44785905f, 0.63980472f, 0.31386042f, 0.21427996f, 0.00637845f, -0.23695052f, -0.17439124f, 
    -0.09777881f, 0.17493078f, -0.11163856f, -0.24738759f, -0.14624701f, 0.28914744f, 0.15882389f, -0.32573253f, 
    0.26678243f, 0.14863916f, -0.47406691f, 0.03643418f, -0.07889832f, 0.41326642f, 0.33566192f, 0.32232556f, 
    -0.83450389f, -0.46545157f, -0.18006423f, -0.49568340f, -0.38136345f, -0.09608628f, 0.47952497f, -0.29082271f, 
    -0.21868244f, -0.41563904f, 0.23038052f, -0.04908712f, -0.00221203f, 0.07186959f, 0.06046558f, -0.35264021f, 
    -0.11426536f, 0.03454733f, -0.30228066f, -0.39710516f, -0.34210032f, -0.69552231f, -0.86975360f, -0.41876784f, 
    -0.30667073f, -0.65822119f, 0.24687587f, 0.35852179f, -0.20453291f, 0.20040305f, 0.36419138f, -0.27740160f, 
    0.40636578f, 0.18789035f, 0.19112243f, -0.28132436f, -0.09155814f, 0.13930629f, -0.00396598f, 0.12994477f, 
    0.21463047f, 0.13484628f, -0.24113762f, 0.09388354f, -0.08250801f, 0.78123569f, 0.43932766f, 0.37638146f, 
    0.55893898f, -0.00662010f, -0.34860560f, -0.08843884f, -0.41975823f, 0.12618940f, -0.22736689f, -0.31260484f, 
    -0.07351774f, -0.12082174f, 0.25712100f, 0.13538706f, 0.05523521f, -0.30920902f, 0.18226667f, -0.25918868f, 
    0.10435242f, -0.31116056f, -0.08957347f, 0.06972688f, 0.13975666f, -0.11052311f, -0.67908949f, -0.53112847f, 
    -0.40540418f, -0.55646968f, -0.03303053f, -0.00700464f, -0.74000973f, -0.20239532f, 0.06311430f, -0.69414526f, 
    -0.03164870f, 0.34318218f, -0.02878997f, 0.13943172f, 0.06260736f, 0.04041136f, 0.41940734f, -0.35649183f, 
    -0.11470170f, 0.04033707f, -0.11348505f, 0.10333939f, 0.20860095f, -0.03934411f, 0.18929382f, -0.00653098f, 
    -0.19349556f, 0.68539089f, 0.72452313f, 0.06073912f, 0.08883472f, 0.15572919f, 0.36701509f, 0.36024114f, 
    0.03410926f, -0.34178531f, 0.19412412f, -0.52219063f, 0.27099806f, -0.11715655f, 0.11634494f, 0.36779490f, 
    -0.36038414f, 0.13160670f, -0.05638129f, -0.04036345f, 0.03913720f, 0.36521977f, 0.05698559f, 0.18238641f, 
    -1.10066450f, 0.18644831f, 0.16352434f, -0.49044806f, 0.12507808f, 0.54555291f, 0.04420292f, 0.34371042f, 
    0.44652569f, 0.54770327f, 0.35270986f, 0.01420250f, 0.38777053f, -0.28730133f, -0.15337712f, 0.17636092f, 
    0.03570234f, 0.02480734f, 0.04131573f, -0.17917176f, 0.00620506f, -0.20783772f, -0.14422753f, 0.26800159f, 
    0.07743350f, 0.37411946f, 0.59897381f, -0.70285511f, -0.15102288f, 0.45813736f, 0.16638510f, -0.50662172f, 
    0.64972615f, 0.61748791f, 0.47773674f, -0.47030869f, -0.00650347f, -0.16002488f, -0.55932295f, -0.40884998f, 
    -0.15880841f, 0.19824986f, -0.18739732f, 0.17144172f, 0.16605109f, 0.17452511f, -0.08781534f, -0.12805234f, 
    -0.31268415f, -0.00846374f, 0.37146524f, 0.25791189f, -0.49499521f, -0.61373246f, 0.16851525f, 0.81534243f, 
    -0.55564016f, 0.46566525f, 0.36580440f, 0.24654117f, -0.55655897f, -0.01527504f, -0.03560241f, -0.02624526f, 
    -0.13165586f, 0.10818414f, -0.13906023f, -0.11112745f, -0.05759503f, 0.45575869f, -0.14948826f, -0.01590670f, 
    -0.37597188f, 0.07488567f, -0.38851172f, -0.97195601f, 0.07786289f, 0.82733619f, -0.16150717f, 0.01248796f, 
    -0.31962785f, 0.48205918f, 0.24708997f, -0.59406418f, 0.01890335f, -0.67393100f, 0.25154170f, 0.21007223f, 
    -0.12221806f, -0.18569472f, -0.01768073f, -0.25256586f, -0.22790222f, -0.00834965f, 0.19270220f, 0.09302731f, 
    0.02618217f, 0.25226486f, -0.17088266f, 0.21946485f, 0.15760082f, -0.13465498f, 0.34150368f, 0.83987778f, 
    -0.13782328f, -0.34406716f, -0.62697387f, 0.72174257f, 0.46381241f, -0.54465824f, -0.13782179f, -0.12413231f, 
    -0.21626252f, -0.13074367f, -0.14674374f, -0.37865630f, -0.04476182f, -0.09038465f, 0.36420119f, 0.25603685f, 
    0.02265019f, 0.02828933f, 0.13787700f, 0.25308824f, -0.21184726f, 0.69274020f, -0.82972419f, 0.72864205f, 
    -0.19855429f, -0.33249843f, 0.69076180f, 0.51555896f, 0.70992661f, 0.46903127f, -0.05212655f, -0.12324052f, 
    -0.38516736f, -0.02646093f, 0.00132952f, -0.16337371f, 0.23865061f, 0.03215899f, -0.16362219f, -0.28531340f, 
    -0.31408486f, -0.30127475f, -0.07877549f, -0.01764560f, -0.14947461f, 0.08325002f, 0.18258236f, 0.60824269f, 
    0.79480851f, -0.23603261f, -0.58116162f, -1.07061791f, -0.04648194f, -0.47591919f, -0.36147931f, -0.47624609f, 
    0.39395976f, 0.36392838f, -0.29941866f, -0.14245288f, 0.27597663f, 0.08778737f, -0.22117026f, -0.16170365f, 
    0.40537769f, -0.21823660f, 0.10607465f, -0.17731380f, -0.09814855f, 0.29358739f, 0.08559638f, -1.39017141f, 
    0.93712324f, 0.19666600f, -0.54410487f, -0.42460483f, 0.47583264f, 0.55952740f, -0.33415908f, 0.30783033f, 
    0.16538668f, -0.27406940f, -0.19899334f, -0.05975852f, 0.17084533f, 0.12353043f, -0.33790901f, -0.20051588f, 
    -0.02939335f, -0.14205891f, -0.39570659f, 0.23200114f, 0.18914595f, 0.26980963f, 0.12974089f, 0.03459828f, 
    0.78110093f, 0.54533154f, 0.32453880f, 0.86832947f, 0.76939487f, 0.49627739f, 0.16861537f, -0.06013669f, 
    0.08506934f, 0.03025101f, 0.02462273f, -0.41786453f, -0.32029963f, 0.00152056f, -0.51188868f, -0.09483872f, 
    -0.20826089f, -0.17701535f, -0.21143450f, -0.28552377f, 0.13955314f, 0.15914318f, 0.14585544f, -0.11164536f, 
    0.25722900f, 0.54809451f, 0.09454115f, -0.18775241f, -0.62110293f, 0.06065980f, -0.42666063f, -0.09733344f, 
    0.32556486f, 0.49238312f, -0.12496995f, -0.58595592f, -0.15312102f, -0.15305057f, -0.24903041f, -0.60304874f, 
    0.38062564f, 0.12811954f, -0.01944627f, -0.66183209f, -0.52542710f, -0.13308203f, -0.20854959f, 0.30206016f, 
    0.12221929f, -0.03202035f, -0.42107582f, 0.86618012f, 0.46858153f, -0.57812905f, -0.38963446f, -0.71795195f, 
    0.55046594f, -0.46559092f, -0.21132809f, -0.04047769f, -0.15069248f, 0.27556914f, -0.63866973f, -0.18367825f, 
    0.11675897f, -0.42166641f, -0.25871876f, 0.52868915f, -0.19645916f, -0.07351075f, 0.38375282f, -0.06722523f, 
    -0.29031709f, -0.13496199f, -0.14740218f, 0.86017323f, 0.15987633f, -0.83024693f, -0.57945651f, -0.58832502f, 
    0.60083628f, 0.33458847f, -0.16912708f, 0.43289140f, 0.17319629f, -0.48022735f, -0.05624445f, -0.43364796f, 
    0.05426984f, 0.06236675f, -0.09481671f, -0.04742587f, -0.38416961f, 0.15123414f, 0.08537839f, -0.14473565f, 
    -0.09786466f, -0.22735059f, -0.17037882f, -0.00696760f, -0.63855195f, -0.36621082f, 0.13709648f, -0.32501787f, 
    -0.70764130f, 0.06197912f, -0.58361167f, -0.01377882f, -0.40011877f, -0.15287666f, -0.10346673f, 0.14453086f, 
    -0.23537889f, 0.44318885f, 0.10497072f, -0.07669843f, 0.35140580f, 0.10585067f, 0.10496521f, 0.23226042f, 
    0.01307383f, -0.08627877f, 0.21672553f, -0.11803748f, 0.05235364f, -0.67740089f, -0.49505460f, -0.33560556f, 
    0.59840375f, 0.68433750f, 0.72634655f, -0.16567926f, -0.53983611f, 0.21348485f, -0.36656156f, 0.17596307f, 
    0.21710749f, -0.01597709f, 0.29687276f, 0.26529345f, -0.29093748f, -0.25604996f, -0.09969332f, 0.18344511f, 
    0.25709248f, 0.30457464f, 0.43319112f, 0.11725577f, 0.37258545f, -0.45878541f, 0.37761080f, 0.50053060f, 
    0.58997148f, 0.56507182f, -0.01802141f, 0.19150054f, -0.25011158f, -0.05534675f, 0.34167758f, 0.45540813f, 
    -0.20486963f, 0.10630538f, 0.19464388f, 0.07377332f, -0.51088947f, -0.41353247f, 0.00909294f, -0.24810795f, 
    0.08617280f, -0.12048487f, 0.16500884f, -0.06423272f, -0.28752330f, 0.01536920f, 0.30838665f, -0.17687276f, 
    0.49802750f, 0.71425056f, 0.04310573f, 0.61468661f, -0.86765283f, 0.06109893f, 0.07789394f, -0.56730956f, 
    -0.01577100f, 0.24312806f, -0.09961054f, 0.16094819f, 0.29556236f, 0.23266226f, 0.43795764f, -0.08142387f, 
    0.06718013f, -0.05237176f, 0.31170669f, 0.24750772f, 0.01437780f, 0.23323172f, 0.05441387f, -0.16358589f, 
    -0.36027494f, -0.66061938f, -0.57590145f, -0.51418090f, -0.49815047f, -0.19050330f, 0.85756803f, 0.39293024f, 
    -0.29516247f, 0.48551786f, -0.37652037f, -0.38197774f, 0.07812344f, -0.08101985f, -0.29837790f, -0.11706305f, 
    -0.25003573f, -0.09445190f, 0.16205758f, -0.31671980f, -0.00556946f, -0.15068854f, 0.03247903f, 0.05381077f, 
    0.36603871f, -1.04796195f, 0.51592910f, 0.05220622f, -0.79873711f, -0.72686183f, 0.70373154f, 0.25034046f, 
    -0.39882705f, 0.64230281f, 0.62598920f, 0.17741087f, -0.10714676f, -0.40262234f, 0.04336467f, 0.01420116f, 
    -0.04325439f, 0.27690691f, -0.26622903f, 0.13237770f, -0.11857551f, -0.14512447f, -0.02930743f, 0.14670193f, 
    -0.01049801f, 0.23206809f, 0.84080350f, -0.19366217f, 0.54114664f, 0.84524071f, 0.18775371f, 0.30737936f, 
    0.28703025f, -0.00371011f, -0.67827195f, 0.34132740f, 0.40908888f, 0.31196222f, -0.09517946f, -0.31008172f, 
    -0.35426152f, -0.33576009f, -0.07784560f, 0.32980347f, -0.14415453f, -0.44368511f, -0.02540213f, -0.00449129f, 
    0.17520511f, -0.00962409f, -0.10139496f, -0.61610383f, 0.32542506f, -0.80085903f, -0.02176059f, 0.50560075f, 
    -0.07539978f, 0.84233850f, 0.65792346f, 0.38862824f, 0.27465168f, 0.11817481f, -0.02980952f, 0.09953023f, 
    -0.40469757f, 0.43599060f, 0.01606991f, -0.02276213f, -0.26497793f, 0.14234194f, -0.05808065f, -0.20968902f, 
    0.08110227f, -0.25756219f, 0.01972990f, -0.32581365f, 0.32418209f, 0.49146673f, -0.51438004f, 0.44019970f, 
    -0.04829874f, -0.33866468f, -0.43035322f, 0.35825893f, -0.08574028f, 0.24003340f, -0.05011521f, 0.42508736f, 
    -0.19059187f, 0.01214011f, 0.20232677f, 0.26599631f, -0.10782178f, 0.16372757f, -0.21694091f, 0.54355562f, 
    0.48334822f, -0.11290950f, 0.22774410f, -0.51239794f, 0.54391277f, -0.38633883f, -0.61120462f, -0.47854677f, 
    -0.02590739f, -0.09651542f, 0.60902178f, 0.22541229f, 0.07811365f, 0.34771043f, 0.55783665f, 0.18927552f, 
    0.39150149f, 0.21698901f, -0.35024741f, -0.14559381f, -0.35649917f, 0.29184487f, 0.18900949f, 0.27696982f, 
    0.06751711f, 0.02490487f, 0.04037053f, -0.23794754f, 0.53718257f, -0.08542584f, 0.21294981f, -0.37634924f, 
    -0.61657816f, -0.78885299f, -0.17598945f, -0.00460109f, 0.30339003f, 0.30234936f, -0.14428580f, -0.11109201f, 
    0.05596035f, -0.50781822f, -0.02172670f, 0.11187940f, 0.03165507f, -0.16735627f, 0.17280911f, -0.09480391f, 
    -0.23280104f, -0.06439682f, 0.22378549f, -0.11141037f, 0.54457384f, 0.00414187f, -0.15242527f, -0.31559607f, 
    -0.33896315f, 0.50695771f, 0.14671598f, -0.25271669f, -0.68325716f, -0.08824758f, -0.49163035f, -0.61118096f, 
    -0.58902138f, -0.28347000f, 0.05266690f, 0.37610480f, -0.20788558f, 0.23857264f, -0.05582650f, -0.38255349f, 
    0.34360558f, -0.46323276f, -0.33195379f, -0.10994567f, -0.14337204f, 0.08393653f, 0.40834022f, 0.06197072f, 
    0.81776279f, 0.44558111f, 0.60200143f, 0.62152255f, 0.71427560f, 0.10941178f, -0.01637736f, -0.40400669f, 
    -0.30881813f, -0.33355796f, -0.14882618f, -0.16394314f, -0.17521758f, 0.26410529f, 0.10987584f, -0.07466581f, 
    -0.15744090f, -0.21411929f, -0.05581352f, 0.04910947f, -0.17695722f, -0.14973220f, -0.24393569f, -0.25174177f, 
    -0.04772158f, -0.09526924f, -0.80263579f, -0.52271146f, 0.04800350f, 0.48478004f, -0.24905685f, -0.40221852f, 
    -0.42305988f, -0.39299738f, -0.01437438f, 0.31247246f, 0.31312168f, 0.12169076f, -0.09743531f, 0.16365981f, 
    -0.06300917f, -0.25709242f, 0.11250277f, -0.34524992f, -0.25800222f, -0.05077257f, 0.16118652f, 0.35477909f, 
    -0.04707202f, -0.18235992f, 0.23586486f, 0.69574416f, 0.53293896f, 0.41617739f, 0.43143928f, 0.13334243f, 
    0.02985503f, 0.35131240f, -0.12037291f, 0.48960084f, -0.68053007f, 0.06011736f, 0.28302947f, 0.17819335f, 
    0.31572005f, 0.05421125f, 0.34072900f, 0.12807111f, 0.41347671f, 0.13392083f, 0.24878389f, -0.13207857f, 
    0.15162338f, -0.11343196f, 0.28679711f, -0.55570996f, -0.66943872f, -0.43081859f, -0.27669898f, 0.45388904f, 
    0.35371649f, 0.47327811f, 0.29367903f, 0.00232811f, 0.07851245f, -0.06327427f, -0.24846362f, 0.30154765f, 
    -0.17202994f, 0.14421581f, 0.17920661f, -0.04887562f, 0.44663477f, 0.35080710f, -0.47143796f, -0.08919801f, 
    -0.40889162f, -0.32489240f, -0.42204505f, -0.16193816f, 0.92540818f, 0.61992937f, 0.19266705f, 0.69920361f, 
    0.16063738f, -0.61229920f, -0.02076064f, -0.19524801f, 0.57961375f, -0.02599627f, 0.06955853f, -0.30233535f, 
    0.05373265f, 0.11524168f, -0.22862108f, -0.24958585f, 0.01203471f, -0.04601979f, -0.18100660f, -0.14747457f, 
    0.49367660f, 0.19155593f, -0.03418512f, 0.19967008f, -0.27450415f, 0.07198648f, 0.79377168f, -0.33306840f, 
    -0.25089177f, 0.35715887f, -0.33214161f, -1.01400423f, -0.05583898f, -0.49426827f, 0.08267120f, 0.27202839f, 
    -0.18687242f, 0.21914507f, 0.40229985f, -0.23161238f, 0.04650646f, 0.21184115f, -0.37535143f, 0.04001233f, 
    0.20544654f, 0.09452584f, 0.26878977f, 0.28530332f, 0.17327321f, -0.19990656f, 0.27522570f, -0.80162317f, 
    -0.60451919f, 0.12024333f, 0.22850491f, -0.19808204f, 0.92111003f, 0.20258525f, 0.52199459f, 0.53892291f, 
    -0.40502894f, -0.26001149f, -0.37610748f, 0.02014454f, 0.03534815f, -0.12838773f, 0.09552561f, -0.22555810f, 
    -0.38288492f, -0.28296518f, -0.04239906f, -0.29402897f, 0.15979768f, -0.08891822f, 0.25075519f, 0.49452281f, 
    1.00911164f, 0.45012227f, 0.07472575f, -0.08544654f, 0.45489028f, 0.07958946f, -0.22771552f, -0.57023919f, 
    -0.11161849f, 0.40727267f, -0.10651212f, -0.04297948f, 0.22589502f, -0.18217550f, -0.07113161f, -0.13265751f, 
    -0.12733269f, -0.14268200f, 0.30102167f, -0.48770007f, 0.24901538f, 0.13683802f, -0.27085772f, 0.21919814f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15928957f, 0.00065662f, 0.09471614f, 0.24496071f, 0.35486388f, 0.20532478f, 0.19018230f, 0.26551366f, 
    0.11115743f, 0.18086204f, 0.02995477f, 0.04205101f, 0.12643017f, 0.06051051f, -0.02703971f, 0.25588122f, 
    0.35212556f, 0.25650668f, 0.14874323f, 0.04518189f, 0.14742626f, 0.16982755f, 0.12118365f, 0.30716285f, 
    0.06100512f, 0.12106861f, 0.20602125f, -0.02688046f, 0.18089472f, 0.16850656f, 0.13061725f, 0.01639859f, 
    -0.04808265f, -0.09466384f, 0.04415005f, 0.21059391f, 0.05448220f, 0.19072083f, 0.21912926f, 0.11223856f, 
    0.05654833f, 0.08201057f, 0.10930444f, 0.21280208f, 0.35540086f, 0.07392253f, 0.33640322f, 0.26247206f, 
    0.04613328f, -0.08128244f, 0.14765210f, -0.07207521f, -0.01600476f, 0.08079144f, 0.16400220f, 0.01640175f, 
    -0.07468032f, 0.36025098f, 0.11668471f, 0.09309679f, 0.25716114f, 0.14208014f, -0.02592806f, 0.08313639f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13953313f, 0.03777286f, -0.06177690f, 0.20049803f, -0.08389893f, 0.12865460f, 0.05078633f, 0.03289360f, 
    0.03715752f, -0.04949882f, -0.02720311f, 0.03649706f, 0.11433178f, 0.06509044f, 0.12072238f, 0.00530132f, 
    -0.02009275f, -0.04822614f, -0.00045785f, -0.11711890f, -0.00339224f, 0.03022149f, -0.04355066f, 0.09872247f, 
    0.12037049f, -0.09264797f, -0.26773065f, 0.29229411f, -0.13080369f, -0.05652820f, 0.10127451f, -0.04081128f, 
    -0.06378931f, -0.04841609f, -0.10813601f, 0.08138906f, -0.17378573f, -0.04651665f, -0.08695288f, 0.14235099f, 
    -0.06578624f, -0.03246557f, -0.05632397f, -0.06120108f, -0.10228465f, -0.02168974f, -0.08762857f, 0.03589173f, 
    -0.25302392f, 0.08551834f, -0.06449950f, 0.06197257f, -0.05164218f, 0.01420811f, -0.12515263f, 0.01278307f, 
    0.03595337f, 0.05528242f, 0.01062546f, -0.02245354f, -0.30050966f, 0.16242708f, 0.18712777f, -0.05114640f, 
    -0.04690705f, 0.15207426f, 0.01901117f, -0.03357575f, -0.02234114f, -0.12289786f, -0.01056979f, -0.03234908f, 
    -0.03863792f, 0.21054493f, 0.02294207f, -0.07378360f, -0.21295014f, -0.01829971f, 0.02050022f, 0.02222145f, 
    0.02972619f, 0.04607603f, 0.08083386f, 0.00334252f, -0.12604153f, -0.06489386f, -0.09910709f, 0.07297200f, 
    -0.01354150f, -0.07014840f, 0.02579867f, 0.04309774f, 0.04536631f, -0.05782970f, -0.01074471f, -0.07269012f, 
    0.16277006f, -0.13190340f, -0.02635101f, 0.22814806f, -0.19997254f, -0.02425206f, -0.09403508f, 0.02075183f, 
    0.07976711f, 0.04100770f, -0.08769387f, -0.15107012f, 0.16009825f, -0.08751279f, -0.08008321f, 0.00596290f, 
    0.01554830f, -0.04780060f, -0.06261818f, 0.04673170f, 0.06735393f, 0.06950069f, 0.07382680f, -0.03077674f, 
    -0.01184308f, 0.03465956f, -0.07570588f, 0.21972096f, -0.05336472f, -0.02012611f, -0.02317459f, 0.00521001f, 
    -0.04127254f, 0.00982596f, 0.11354578f, 0.00607140f, 0.21804541f, -0.11983135f, 0.11521143f, -0.07889272f, 
    -0.20111479f, 0.02024352f, -0.03652113f, 0.03889620f, -0.05446124f, -0.01849341f, -0.01811849f, 0.07620056f, 
    -0.11519785f, 0.17079030f, 0.05295140f, -0.37429500f, 0.09968649f, 0.03331295f, 0.04436304f, -0.03075816f, 
    -0.01370971f, -0.04918772f, -0.00599596f, 0.05678903f, -0.15817344f, 0.00789852f, 0.11787089f, 0.03713536f, 
    -0.08465170f, -0.02164686f, -0.05583388f, 0.06940573f, 0.10279982f, -0.05754169f, 0.07195614f, 0.08459052f, 
    -0.25117868f, 0.10039004f, -0.06117016f, -0.11370809f, -0.05936949f, -0.01765862f, 0.05879751f, 0.04666366f, 
    -0.13529480f, 0.10496001f, 0.01280178f, 0.07747079f, -0.07593892f, 0.04987431f, 0.19075847f, 0.03127631f, 
    -0.05336093f, 0.00157382f, 0.06244156f, -0.05480957f, -0.01262173f, -0.01293693f, 0.05935847f, -0.00529766f, 
    0.05931484f, 0.05870257f, 0.05465264f, -0.12103391f, -0.01323311f, -0.00435090f, -0.05693084f, 0.01801067f, 
    -0.02814734f, 0.02823614f, -0.04768943f, 0.00040742f, -0.21636897f, 0.01489725f, -0.08084612f, 0.06478585f, 
    0.07429854f, -0.09467870f, 0.15044469f, -0.01073307f, 0.08075492f, 0.06810842f, 0.03316138f, -0.05921644f, 
    0.16082883f, 0.03753442f, -0.09262580f, 0.20735085f, -0.10140182f, -0.08876076f, 0.02510886f, -0.07376809f, 
    -0.07610701f, -0.05359815f, -0.09295997f, -0.03085314f, 0.25943166f, -0.03942074f, -0.24132036f, -0.21033949f, 
    0.07983682f, -0.07948773f, 0.09610473f, 0.04147650f, -0.02315914f, 0.01244703f, 0.05905486f, 0.03411930f, 
    0.07133581f, 0.10684480f, -0.04659769f, -0.22305219f, 0.02689735f, -0.04805762f, -0.08876450f, -0.05372715f, 
    -0.06835739f, 0.13491389f, -0.04447178f, 0.05206883f, -0.07093485f, -0.33359629f, -0.04665697f, 0.20208126f, 
    -0.13420509f, -0.09822332f, -0.01540995f, -0.03111332f, 0.02547891f, 0.09653515f, -0.12721954f, 0.01378843f, 
    -0.48669633f, 0.01661573f, -0.14351608f, 0.12377018f, 0.02321719f, -0.09472171f, -0.06170805f, 0.01419450f, 
    0.04896957f, 0.02375572f, -0.10870188f, 0.04072165f, -0.44654408f, -0.05226846f, 0.15693744f, -0.22710651f, 
    -0.11894552f, -0.06669474f, -0.07389454f, -0.04879924f, 0.10999402f, -0.04894665f, 0.03839410f, 0.04393551f, 
    0.04003032f, 0.20260033f, -0.06085193f, 0.11258480f, -0.08540062f, 0.08553438f, -0.08643521f, -0.00055263f, 
    -0.00391188f, -0.04265408f, -0.06033622f, 0.05957744f, 0.14684618f, -0.12830807f, -0.08752576f, 0.24217756f, 
    -0.15616983f, -0.05047637f, 0.06988383f, 0.03264997f, -0.08783817f, 0.00592172f, -0.00291852f, -0.03176142f, 
    0.13086669f, 0.05511260f, -0.12745850f, -0.22561325f, -0.00803288f, 0.06199501f, -0.02147307f, -0.04332588f, 
    -0.13079402f, -0.04614215f, 0.01175146f, -0.01392253f, 0.08764803f, 0.01751621f, -0.09284138f, 0.11929876f, 
    -0.08504605f, -0.06044864f, -0.03376615f, 0.10793547f, 0.06115352f, -0.02149448f, -0.01471473f, -0.04073697f, 
    -0.35078067f, -0.01866793f, -0.10404821f, -0.04159231f, 0.02082176f, -0.04450207f, -0.00918720f, 0.00854715f, 
    -0.03853864f, -0.07516333f, -0.02664020f, 0.11042078f, 0.16459924f, 0.05918056f, -0.14531989f, 0.05384095f, 
    -0.06954280f, -0.11516276f, -0.03064397f, 0.08397130f, 0.00841873f, -0.06565031f, -0.08726954f, -0.07059520f, 
    -0.27177423f, -0.21571112f, 0.03437820f, -0.02911909f, 0.03853558f, 0.03556030f, 0.00623889f, -0.03371065f, 
    -0.03515572f, -0.07425185f, 0.08378070f, -0.15793896f, -0.07055558f, -0.03220983f, -0.10812731f, 0.22602217f, 
    -0.00949561f, 0.04493903f, 0.03941297f, -0.04474385f, -0.01604465f, -0.01569679f, 0.09456388f, -0.06830680f, 
    0.29802015f, 0.00441409f, 0.01141679f, -0.07432991f, 0.04710007f, 0.00346673f, -0.09480430f, -0.05235091f, 
    -0.01704986f, -0.07594098f, -0.04988087f, -0.08662015f, 0.17794548f, 0.01181264f, 0.06818271f, -0.10780391f, 
    -0.04053614f, 0.10841661f, 0.10271925f, 0.06298529f, -0.07152943f, 0.03121966f, -0.01603667f, 0.02393197f, 
    0.37671947f, -0.15380143f, 0.07994681f, -0.18349260f, -0.03590397f, 0.04383784f, 0.08160480f, -0.10347441f, 
    -0.00361958f, -0.01440931f, -0.08943474f, 0.20405841f, -0.33934286f, 0.05439235f, 0.12273046f, 0.09359694f, 
    0.08242467f, 0.05572375f, 0.01293814f, 0.03412671f, 0.05929556f, -0.06811298f, -0.05675353f, 0.04358057f, 
    0.14323500f, 0.01323769f, -0.03009416f, 0.35964891f, -0.02133165f, 0.05247127f, 0.00206456f, -0.17769539f, 
    0.08576722f, -0.18066099f, 0.04068391f, 0.01352124f, 0.10808995f, -0.00604862f, 0.05928763f, 0.02987752f, 
    0.09757310f, 0.01897283f, 0.13516940f, -0.05881152f, 0.05420853f, 0.01410719f, -0.09482697f, -0.11093480f, 
    -0.14433926f, 0.19599639f, 0.02668326f, 0.09349251f, -0.00691705f, 0.06391530f, -0.09656031f, -0.05639763f, 
    0.01649111f, 0.06427742f, 0.07394759f, -0.15525459f, 0.46169806f, -0.03558358f, 0.10267041f, -0.11608097f, 
    0.07196692f, 0.08836252f, 0.03544784f, 0.03061058f, -0.05943641f, -0.07429319f, -0.00096064f, 0.04098617f, 
    0.12524757f, -0.02009398f, 0.03294629f, 0.17301680f, -0.19519109f, 0.04182301f, 0.00053133f, 0.11122159f, 
    -0.14073591f, 0.03119542f, -0.02397000f, -0.16175394f, 0.02510751f, 0.09619609f, -0.02970802f, -0.21811512f, 
    -0.02918664f, -0.03266619f, -0.03088116f, -0.02060146f, 0.05679012f, 0.08018242f, 0.10862687f, -0.14967944f, 
    -0.32429433f, -0.03082381f, 0.09736328f, -0.08732385f, 0.04901684f, 0.01624804f, 0.04754749f, -0.13223827f, 
    -0.11663391f, -0.00165796f, 0.11030634f, -0.07298870f, 0.14113814f, -0.23886049f, 0.01249972f, -0.22607929f, 
    -0.09219431f, -0.04083960f, 0.02220727f, -0.01574156f, -0.10292166f, 0.04095962f, 0.02912361f, 0.12766153f, 
    -0.23282507f, 0.07838000f, -0.11849906f, 0.02402788f, 0.00999256f, 0.01972752f, -0.04596776f, 0.02826535f, 
    0.01623889f, 0.01742779f, 0.01961702f, -0.04805674f, -0.25722009f, -0.10428364f, 0.10539825f, 0.06937581f, 
    0.09121067f, -0.08041830f, -0.02586371f, -0.05785105f, 0.03240730f, -0.07840916f, 0.05892412f, -0.01712333f, 
    0.02243239f, 0.01638236f, -0.06730890f, 0.13225959f, 0.04901404f, -0.08773813f, -0.00898564f, -0.05350254f, 
    -0.05156792f, -0.07815443f, -0.09400994f, -0.01043028f, -0.05746793f, 0.06068342f, -0.14950886f, -0.08084409f, 
    0.03258649f, -0.00818857f, -0.05004208f, -0.13894267f, 0.02112186f, -0.11642805f, 0.10246536f, -0.04550782f, 
    -0.09142511f, 0.09336907f, 0.10087883f, -0.31838667f, 0.01855519f, 0.01284724f, 0.02886080f, 0.11603070f, 
    0.05504421f, 0.03820356f, -0.07601100f, 0.01540066f, 0.49197468f, 0.00059869f, 0.00153913f, -0.08042880f, 
    -0.00540147f, 0.05367419f, -0.05883362f, -0.08455442f, 0.11746402f, 0.00950409f, -0.04144214f, 0.06184312f, 
    0.07996736f, 0.11254232f, -0.11092979f, 0.09300406f, -0.26367930f, -0.04936329f, 0.07702012f, 0.07223797f, 
    -0.09560093f, 0.12917326f, -0.13872229f, -0.02741907f, 0.11109608f, 0.30853376f, 0.09316756f, -0.10261080f, 
    0.00068095f, 0.04248844f, 0.00399350f, -0.14950021f, -0.06078447f, 0.01271643f, -0.07328169f, 0.10031039f, 
    0.13877453f, -0.01221710f, 0.02866040f, -0.11186419f, 0.03469777f, -0.00349369f, 0.02632531f, 0.01255629f, 
    0.05429702f, -0.02026030f, 0.05330810f, -0.09082267f, 0.11089900f, 0.09103960f, -0.22783236f, -0.10432930f, 
    0.04491178f, 0.04828638f, 0.01548028f, 0.00556455f, -0.01217062f, 0.00496374f, -0.04555658f, -0.06627711f, 
    -0.25592545f, 0.09339407f, 0.05171920f, -0.27147764f, -0.07593289f, 0.04855863f, 0.05474643f, -0.06331891f, 
    -0.07358400f, 0.03227204f, -0.02007259f, -0.03479709f, -0.08656829f, 0.00368110f, -0.08726218f, 0.21768297f, 
    0.07541323f, -0.03512644f, 0.07611891f, -0.04563346f, -0.08570363f, 0.07641000f, -0.05779475f, -0.04269832f, 
    0.15036111f, 0.09849934f, -0.04695105f, 0.00403382f, -0.15998007f, -0.09469251f, 0.05515265f, 0.12743360f, 
    0.01526601f, -0.05585603f, -0.02695291f, -0.01510591f, -0.01778137f, -0.20586221f, 0.07420909f, 0.15402247f, 
    0.02568907f, -0.12949154f, 0.02744842f, 0.07682522f, -0.11372011f, 0.01279641f, -0.05527713f, -0.04544882f, 
    -0.09279090f, 0.05012420f, -0.17251651f, 0.01965271f, -0.05304639f, -0.02356844f, -0.04446219f, 0.03164723f, 
    0.09289103f, 0.00362153f, -0.10556546f, 0.06883035f, -0.05560643f, -0.02634429f, 0.11129282f, -0.08766405f, 
    0.11315086f, 0.02816055f, -0.02068866f, 0.05373558f, 0.06568810f, 0.05257276f, -0.04387448f, 0.09395821f, 
    0.01225675f, 0.12683851f, -0.18184313f, 0.12892634f, -0.00743406f, -0.06127746f, -0.07126053f, -0.05876769f, 
    0.00769657f, -0.07361840f, -0.00521091f, -0.09013712f, 0.07649969f, -0.03086197f, 0.20859140f, -0.18927342f, 
    0.02477888f, 0.16219714f, -0.02710244f, 0.00274744f, 0.01907679f, 0.00745681f, 0.02151316f, -0.11399280f, 
    -0.10246840f, 0.09536641f, 0.04074409f, 0.03156840f, 0.00208912f, -0.00471527f, 0.02566470f, -0.21336110f, 
    -0.05880649f, 0.03793454f, 0.06515698f, -0.02908095f, 0.08237173f, 0.00625107f, 0.06951378f, -0.15635474f, 
    -0.18690372f, 0.04903831f, 0.07462752f, 0.15889131f, -0.05045936f, -0.08191852f, -0.09201636f, 0.03425310f, 
    -0.02639261f, 0.11403596f, -0.09326331f, 0.06319746f, 0.05110668f, -0.07877506f, -0.11928300f, -0.08632945f, 
    -0.12976336f, 0.06373975f, 0.06515194f, 0.00035018f, 0.04758780f, 0.18149869f, 0.05848997f, 0.06684935f, 
    0.00280322f, 0.01095315f, -0.00509597f, -0.10096993f, 0.02170514f, -0.06737171f, 0.13400693f, 0.00703858f, 
    -0.07414308f, 0.04572317f, -0.03533351f, 0.12160976f, -0.04221727f, -0.05846594f, -0.07163658f, -0.08450699f, 
    0.02030568f, -0.11958248f, 0.12182884f, -0.12498480f, -0.09317428f, 0.17781007f, -0.03826342f, 0.06560653f, 
    -0.17292047f, 0.02043921f, 0.04176302f, 0.01118951f, 0.05899709f, 0.00532014f, 0.10080381f, 0.05684286f, 
    0.11565280f, 0.05213244f, -0.05156576f, 0.10680301f, -0.07142058f, 0.04153627f, 0.00983295f, -0.00807065f, 
    0.00462865f, -0.08940255f, -0.07230406f, 0.01409541f, 0.10263423f, -0.19979268f, -0.10713250f, -0.12150836f, 
    0.02563917f, -0.04735178f, 0.01535471f, 0.04939424f, -0.06410150f, 0.16824211f, 0.02060708f, 0.12802587f, 
    0.20651044f, -0.22312300f, -0.08531122f, -0.01574831f, 0.04098352f, 0.00341797f, 0.01186805f, 0.06961109f, 
    -0.05659921f, -0.00563472f, -0.08381750f, 0.01307277f, -0.06052819f, 0.08152539f, -0.09948526f, 0.07177860f, 
    0.00333022f, 0.06923635f, -0.00273495f, 0.10867997f, -0.11926017f, 0.05872288f, 0.03747209f, 0.13869259f, 
    0.21180744f, 0.00919697f, 0.14296894f, 0.17438897f, -0.08755220f, -0.06424873f, 0.12433864f, 0.00147248f, 
    -0.16419461f, 0.01767603f, 0.01156036f, 0.14808585f, 0.26283798f, -0.23524477f, 0.08355463f, 0.06183428f, 
    -0.01735016f, -0.05326996f, -0.02030752f, 0.05368280f, -0.14126353f, 0.02674138f, -0.06527695f, -0.01816729f, 
    0.18643335f, 0.01175924f, 0.01567020f, 0.13179666f, -0.08733952f, -0.01090259f, 0.06830411f, -0.02846556f, 
    -0.03896221f, -0.01720236f, 0.01498803f, -0.00497141f, -0.12796500f, -0.21910150f, 0.14698000f, 0.11674708f, 
    0.07497565f, 0.07702426f, -0.04191920f, 0.03165203f, 0.08580345f, 0.02357347f, -0.06420603f, -0.04942912f, 
    0.06221521f, -0.07155658f, -0.05185037f, -0.23123693f, -0.06634380f, -0.07712533f, 0.01265689f, -0.00874605f, 
    0.02564572f, -0.06945721f, 0.05135037f, -0.12025339f, 0.38348410f, -0.41611749f, -0.09851778f, -0.12057106f, 
    -0.02475744f, -0.03705557f, 0.00616328f, -0.00140214f, -0.16314180f, -0.07134151f, 0.03502285f, -0.01967797f, 
    -0.00651296f, -0.09929509f, -0.00924409f, 0.10665688f, 0.04881559f, 0.04315101f, -0.06608924f, 0.09055132f, 
    -0.03429860f, -0.12983167f, -0.04666524f, 0.23766139f, -0.03595430f, 0.08249362f, -0.10085484f, 0.03143074f, 
    -0.03621540f, -0.00528982f, -0.03180337f, 0.07274954f, 0.02688559f, 0.06659057f, -0.03267789f, 0.02271958f, 
    -0.04823012f, -0.02914339f, -0.01808794f, -0.14998022f, 0.04701660f, -0.01873771f, 0.02385869f, 0.00882255f, 
    -0.04039726f, -0.07095505f, -0.08426551f, -0.02239359f, 0.02113655f, 0.11402136f, -0.11660436f, -0.01153790f, 
    -0.07290693f, 0.01318386f, 0.03927736f, -0.10485221f, -0.02026460f, -0.09154045f, -0.05572512f, 0.04897229f, 
    0.05726147f, -0.02023414f, 0.04813556f, 0.06211077f, -0.06869769f, 0.09938768f, 0.01106829f, 0.03298398f, 
    0.15131907f, 0.16032796f, 0.03422996f, -0.09314456f, -0.07372719f, 0.01636403f, 0.07989053f, -0.10787342f, 
    0.05573525f, -0.03576460f, 0.06294522f, 0.04621081f, 0.15205012f, 0.02040132f, 0.11429602f, 0.02658386f, 
    0.09547560f, 0.04405932f, 0.00934810f, -0.06695893f, 0.05270604f, -0.12233062f, -0.03174460f, -0.06717325f, 
    0.05685522f, -0.09259237f, 0.00066530f, -0.07449530f, -0.07219307f, 0.00264812f, -0.11100169f, 0.10428144f, 
    -0.16933455f, 0.05261284f, -0.04479137f, -0.03228106f, -0.05837331f, -0.07884970f, 0.11739419f, 0.09279127f, 
    0.22915515f, 0.02927766f, -0.00759887f, 0.16445599f, -0.01910857f, -0.07421065f, -0.16075417f, 0.07789611f, 
    -0.08308665f, -0.13706791f, 0.04104952f, -0.03078906f, -0.06070511f, -0.18403545f, -0.04949531f, -0.19034249f, 
    -0.11152489f, 0.07441520f, -0.04821102f, 0.06475546f, -0.01680525f, -0.02978116f, -0.26356614f, -0.04964987f, 
    -0.20241548f, -0.04021917f, -0.14817981f, 0.13744277f, 0.01002652f, 0.06254445f, -0.03946218f, 0.00557428f, 
    0.01635224f, -0.06694879f, -0.02468707f, 0.10949422f, 0.24510132f, -0.02194732f, 0.17995825f, 0.01940931f, 
    -0.18429282f, 0.00554183f, -0.04380304f, 0.04163782f, 0.02189405f, 0.07497824f, 0.04921334f, 0.07165489f, 
    0.11403041f, -0.20365803f, 0.05248210f, -0.19627765f, -0.08599693f, 0.05950816f, 0.07447925f, 0.03493033f, 
    0.06473625f, 0.01104543f, -0.03247147f, 0.09303562f, -0.19590439f, -0.07765123f, -0.24580303f, 0.00404588f, 
    0.12036023f, -0.01395374f, -0.00626353f, -0.05609216f, -0.14156415f, -0.10612763f, -0.02570640f, 0.01439601f, 
    0.30537993f, -0.06898215f, -0.05253611f, -0.02966231f, 0.05949375f, 0.02422226f, 0.05028289f, 0.04562731f, 
    0.05368755f, -0.07212432f, 0.04177703f, -0.05015054f, 0.19178343f, -0.05784118f, -0.00571109f, 0.10297251f, 
    -0.05824125f, -0.05819846f, 0.07631252f, 0.05569297f, -0.01364480f, -0.02132467f, 0.05660369f, 0.11614428f, 
    -0.01626064f, 0.07918394f, 0.16370472f, -0.14406180f, -0.00351268f, -0.01432320f, 0.13861409f, 0.08550173f, 
    0.09577778f, 0.13615546f, 0.05465396f, 0.01415829f, 0.16610757f, 0.10307445f, -0.01945636f, 0.16584566f, 
    -0.15504898f, -0.00863317f, -0.00184889f, -0.05328333f, 0.03359587f, -0.03754142f, -0.01471815f, 0.04517793f, 
    -0.18695906f, 0.02974102f, -0.02397862f, -0.02498297f, 0.00682010f, 0.00571274f, 0.03111356f, 0.13382870f, 
    0.02880422f, -0.00797437f, 0.04383449f, 0.07936433f, -0.03374152f, -0.06361428f, 0.13972361f, -0.08327228f, 
    0.00790080f, -0.17085209f, -0.00927115f, 0.07828291f, 0.08533922f, -0.14499578f, -0.08204836f, -0.07383299f, 
    -0.08020001f, -0.16593973f, 0.08108769f, -0.19205157f, 0.15862605f, 0.04872166f, -0.06182325f, 0.03387181f, 
    0.05128416f, 0.12581256f, 0.09205289f, -0.09967923f, -0.13336512f, 0.11086912f, -0.20101687f, -0.11531214f, 
    0.01066523f, -0.05993737f, 0.03016609f, 0.01307983f, -0.00269524f, 0.08338147f, -0.00325726f, -0.15194026f, 
    -0.29041138f, 0.11145572f, -0.06123213f, 0.11225314f, -0.11593388f, -0.14102162f, -0.09732452f, 0.04288966f, 
    0.03360521f, -0.02539860f, -0.11386900f, 0.01170417f, 0.01902262f, -0.10778833f, -0.02993328f, 0.01690994f, 
    0.04219668f, 0.03483918f, -0.06762782f, -0.05869629f, 0.07689244f, -0.10228937f, 0.06960368f, -0.10607792f, 
    -0.30511484f, -0.01768239f, -0.41083610f, -0.08407506f, 0.03216105f, -0.03659465f, -0.01408912f, 0.00637220f, 
    0.02930132f, 0.12253992f, -0.02832586f, 0.11828969f, -0.61395013f, 0.05244937f, -0.09600462f, -0.17338891f, 
    -0.04884873f, 0.04250303f, 0.05203005f, -0.01484000f, 0.05815016f, 0.01727615f, -0.05113867f, 0.01524135f, 
    0.18676785f, -0.02049126f, 0.10142361f, 0.12771486f, -0.08501458f, 0.05892915f, 0.00887071f, -0.03864558f, 
    -0.10760092f, -0.04263121f, -0.04196725f, -0.01598780f, 0.13300505f, -0.03758829f, 0.09959646f, -0.18702607f, 
    0.03713672f, -0.07361394f, -0.07278993f, -0.04646185f, 0.01228314f, -0.32663462f, -0.16794693f, 0.02812388f, 
    -0.23983322f, 0.14801022f, -0.36321315f, -0.26777670f, 0.01235939f, 0.01954908f, 0.01162435f, 0.01080067f, 
    -0.00211255f, -0.03529008f, -0.00409942f, -0.00240241f, 0.17312732f, -0.25812337f, 0.11331303f, -0.19126669f, 
    0.14631252f, -0.03890295f, -0.02402934f, 0.01798695f, -0.09605080f, -0.00611500f, -0.04270133f, -0.08732978f, 
    -0.16952839f, 0.09521239f, -0.07544708f, -0.00242216f, -0.02525606f, 0.02024304f, 0.08846689f, 0.00421081f, 
    0.07250474f, 0.06826319f, 0.02327489f, 0.05478558f, 0.15182668f, 0.02342100f, -0.37163711f, 0.02235927f, 
    0.05606068f, 0.01823054f, -0.08617021f, -0.05328598f, -0.09058163f, 0.02352575f, 0.04113598f, 0.01484883f, 
    0.12365257f, 0.08900204f, 0.06426488f, 0.16914353f, -0.09565210f, 0.09516525f, 0.05950382f, 0.06548011f, 
    -0.03642198f, 0.00899676f, 0.04817460f, -0.13108739f, -0.07553944f, 0.11631972f, 0.01800806f, -0.00224608f, 
    0.09548350f, -0.01331287f, -0.02173362f, -0.07647520f, 0.01876678f, 0.05861168f, -0.04556889f, 0.07520860f, 
    0.17819905f, -0.04703525f, -0.04354575f, -0.10759423f, 0.02364574f, -0.10836524f, -0.05501798f, -0.08772100f, 
    -0.05384996f, -0.06134923f, -0.05567477f, 0.06531229f, -0.66860157f, -0.00550733f, -0.10838796f, -0.12306568f, 
    0.03377508f, -0.13766111f, -0.09328992f, 0.05049819f, 0.07948653f, 0.08242168f, -0.07272851f, -0.10157397f, 
    0.04627328f, 0.07105434f, 0.08865685f, 0.21906698f, -0.12658285f, 0.08157086f, 0.03495517f, 0.05479354f, 
    -0.01793491f, -0.25285637f, 0.14276090f, -0.02086687f, 0.29707393f, 0.04254784f, -0.00281627f, -0.09424159f, 
    0.21304509f, 0.09645539f, 0.00006536f, 0.14859021f, 0.07482896f, -0.03733765f, 0.03518557f, -0.03700503f, 
    -0.09023322f, -0.21195489f, -0.17322887f, -0.06311855f, -0.03057836f, -0.08934986f, -0.11839322f, 0.02270964f, 
    0.01776512f, 0.03634555f, 0.01241526f, 0.16356480f, 0.10545117f, -0.08335160f, 0.04344237f, -0.00043709f, 
    0.17215049f, -0.07391767f, -0.00244243f, -0.05915998f, 0.11405277f, -0.03349990f, 0.00967200f, 0.19016632f, 
    0.24113673f, -0.17343013f, 0.01855325f, -0.28894177f, 0.11152852f, -0.02106229f, -0.05017661f, -0.02004402f, 
    0.01520189f, -0.05168103f, 0.02476150f, 0.00949735f, -0.35943651f, -0.06767306f, -0.12528570f, -0.25409031f, 
    -0.08485281f, 0.06961171f, -0.02639382f, 0.03449707f, 0.13723449f, -0.18920033f, 0.03060677f, 0.14130062f, 
    0.18594338f, -0.09452958f, 0.06900225f, 0.16249241f, -0.10224225f, -0.05270169f, 0.06655102f, -0.04664267f, 
    -0.01068404f, 0.01763404f, -0.10578091f, -0.02292454f, 0.02318001f, -0.10336005f, 0.02812383f, -0.08509791f, 
    0.09277869f, 0.10173621f, 0.01925484f, -0.00816771f, 0.04764518f, -0.08345565f, 0.01433856f, 0.03247073f, 
    0.29839984f, 0.13122816f, -0.04349045f, 0.18895315f, -0.06930722f, -0.03088105f, 0.01271766f, -0.04077422f, 
    0.04181333f, -0.00923881f, 0.02678664f, -0.07956790f, 0.22988746f, 0.07839569f, -0.01268770f, -0.08920817f, 
    0.10002388f, 0.11682384f, -0.15045670f, 0.07290995f, -0.06995349f, -0.04047998f, 0.05220434f, -0.05485912f, 
    0.19188599f, -0.09945599f, -0.04077381f, 0.18628903f, -0.04764920f, -0.05896513f, 0.02526309f, -0.00918317f, 
    -0.02284566f, -0.03710959f, -0.07378576f, 0.06929331f, -0.05005981f, -0.07628304f, 0.03151085f, -0.23677449f, 
    0.07963468f, -0.09506312f, 0.11360090f, 0.06415375f, -0.03245613f, 0.07638192f, -0.00440515f, 0.04595360f, 
    0.29791024f, -0.23598367f, -0.03776791f, -0.01549653f, 0.01943582f, 0.10940220f, -0.09521150f, -0.00681759f, 
    -0.03385450f, 0.09768719f, -0.03384014f, -0.11027132f, 0.14569016f, 0.07339542f, 0.10922972f, -0.08875218f, 
    -0.16901296f, -0.03958410f, 0.01058005f, -0.07855562f, -0.07074311f, 0.05363493f, 0.05418274f, 0.00123087f, 
    0.11656831f, -0.08586572f, -0.08955451f, 0.08971997f, -0.06549543f, 0.10886602f, 0.06860486f, -0.14892007f, 
    0.05921713f, -0.02178198f, -0.05861874f, -0.03517027f, 0.17251903f, -0.02106480f, -0.02863831f, -0.00048903f, 
    -0.04783943f, -0.01598946f, -0.04277308f, 0.02349542f, -0.10470525f, 0.02392916f, -0.03622504f, -0.04715607f, 
    -0.32120001f, -0.01162992f, -0.09072948f, -0.05217019f, -0.00045860f, 0.02190459f, 0.05489926f, 0.01579679f, 
    0.05646485f, 0.05471550f, -0.08571825f, 0.01865190f, -0.18905070f, -0.02072495f, 0.09249718f, -0.13146763f, 
    -0.11305559f, 0.05171797f, 0.01955419f, 0.06585191f, -0.07315447f, 0.02218724f, 0.01355672f, -0.07180811f, 
    0.32786918f, -0.04775326f, 0.08458223f, -0.01274260f, -0.14947134f, 0.05712749f, 0.03120024f, 0.02970045f, 
    0.07170326f, 0.01588914f, -0.01559978f, -0.04245604f, -0.33298352f, 0.05186342f, -0.01390112f, -0.21860357f, 
    0.02823436f, 0.10933809f, 0.02625777f, -0.07153811f, -0.03729992f, -0.07281117f, -0.00856689f, -0.06144715f, 
    0.18126033f, -0.16030954f, -0.03680412f, -0.03591343f, 0.05273674f, -0.05959498f, 0.01269944f, 0.03714342f, 
    -0.02469070f, -0.00460881f, -0.01461325f, -0.05413620f, 0.24355240f, -0.22937429f, -0.06653193f, 0.00071337f, 
    -0.11525258f, -0.03297560f, -0.03496394f, -0.01427080f, -0.03943623f, -0.05280305f, 0.02258418f, -0.04203572f, 
    0.10080392f, 0.06480771f, 0.04883135f, 0.01601453f, -0.00555739f, -0.01430792f, -0.00154278f, 0.10160612f, 
    -0.05862902f, -0.01942613f, 0.01590375f, 0.01440329f, -0.24025545f, 0.04859387f, -0.02119410f, -0.11454709f, 
    0.02768696f, -0.02838886f, 0.00573880f, 0.12330329f, -0.02159623f, -0.06858517f, -0.00661641f, -0.05221390f, 
    0.04879914f, 0.00588591f, -0.07345047f, -0.10904993f, 0.01796352f, 0.09928838f, -0.06240220f, 0.04596850f, 
    -0.11356600f, 0.08604201f, -0.00235270f, 0.01912330f, -0.22799434f, -0.05665363f, -0.04609456f, -0.20227282f, 
    0.16659501f, -0.10435702f, 0.03742798f, -0.05623125f, -0.09124700f, 0.08242132f, 0.00029332f, -0.14780714f, 
    0.12937213f, 0.09632854f, -0.00575663f, 0.19245748f, -0.08092666f, -0.10006681f, 0.05195661f, 0.05116119f, 
    -0.07228945f, 0.08951106f, -0.00525007f, 0.05003172f, -0.17997181f, 0.03801051f, -0.14738238f, -0.07798941f, 
    0.00666616f, -0.03568061f, 0.01744924f, 0.00420744f, -0.04265466f, 0.02309528f, -0.00095454f, -0.09332556f, 
    0.02937178f, 0.04188021f, -0.10381983f, -0.12421912f, -0.10476763f, -0.07332528f, 0.15176004f, -0.11157139f, 
    -0.00099835f, 0.12579557f, -0.06977978f, -0.05410306f, 0.13742313f, 0.02397829f, -0.00238907f, 0.05241392f, 
    -0.04441040f, 0.06218264f, 0.06183058f, -0.06617524f, -0.00160884f, -0.03572965f, -0.04529489f, 0.02580460f, 
    -0.19306004f, -0.02113578f, -0.10692338f, 0.01555506f, -0.05293756f, -0.04407869f, -0.06210206f, -0.04098351f, 
    -0.00507181f, 0.07362988f, -0.05142996f, -0.03324471f, 0.14568615f, 0.00833284f, -0.20114157f, -0.08143304f, 
    -0.01522905f, 0.01686770f, -0.03726531f, 0.05455572f, -0.04888906f, -0.02772393f, -0.09226749f, -0.05253443f, 
    0.17648903f, 0.07419641f, -0.07402773f, 0.05525262f, 0.06499855f, 0.04644145f, -0.04934753f, -0.07259662f, 
    -0.02542682f, -0.00400005f, -0.07058959f, 0.02700077f, 0.00564195f, 0.02588313f, 0.12419364f, 0.16722834f, 
    -0.09756169f, -0.16103850f, 0.00019042f, -0.09430054f, -0.08015613f, -0.00339386f, 0.00295019f, 0.08640098f, 
    -0.26684758f, 0.08340045f, 0.06137322f, -0.10283151f, -0.00170731f, -0.02432838f, 0.08662043f, -0.00937021f, 
    -0.08344858f, -0.03789223f, -0.00113198f, -0.03317844f, 0.47961608f, -0.23892918f, 0.09276701f, 0.00873486f, 
    -0.00078225f, 0.11431751f, 0.01914349f, 0.03067461f, -0.03518584f, 0.02789075f, 0.05776682f, -0.13603377f, 
    0.38543764f, -0.15016402f, -0.02282644f, 0.15443544f, -0.10267004f, 0.02242728f, 0.01745316f, -0.04926973f, 
    -0.06749938f, 0.01890085f, 0.03008178f, -0.10081865f, 0.16189466f, -0.24073583f, -0.09722411f, -0.07290354f, 
    0.00092908f, 0.00923648f, 0.05018277f, -0.04554320f, 0.00268131f, -0.02578229f, -0.06947120f, -0.05765010f, 
    0.29834220f, -0.09769654f, -0.00427573f, -0.04510362f, -0.09680766f, 0.00463051f, -0.12510505f, -0.02772870f, 
    0.04571449f, 0.02761161f, 0.03948694f, -0.00598034f, -0.06083038f, -0.10790571f, 0.10769685f, -0.03334133f, 
    0.06156119f, 0.04690723f, -0.03947425f, -0.04608244f, 0.00883714f, 0.00310213f, -0.09824125f, -0.00723369f, 
    0.02173845f, 0.11837953f, 0.11774275f, 0.18057007f, -0.13422790f, -0.02071561f, 0.03565518f, 0.06695231f, 
    -0.02972226f, 0.04451796f, 0.03149040f, -0.09389557f, 0.10911030f, 0.15253605f, -0.15092781f, 0.01576223f, 
    0.05310893f, 0.09681296f, -0.04343601f, -0.09266108f, -0.16051742f, -0.08716714f, -0.01444508f, -0.12673829f, 
    0.28703874f, 0.02364936f, -0.03431939f, 0.16377787f, -0.15441625f, -0.06022869f, 0.02288602f, -0.01109088f, 
    0.00141163f, -0.02558305f, 0.03460572f, -0.04274633f, -0.03738349f, 0.01145222f, -0.12017491f, -0.03381775f, 
    0.11348943f, 0.00135950f, -0.00303828f, -0.00947864f, -0.05394603f, 0.08623070f, -0.06473154f, -0.07000934f, 
    -0.38247705f, -0.18755552f, -0.07306109f, -0.17393267f, 0.00443841f, -0.12401196f, -0.08706620f, -0.03809389f, 
    -0.03707303f, -0.01617045f, 0.01365437f, -0.08551923f, 0.07053877f, -0.03086348f, -0.11052001f, 0.02275516f, 
    -0.07437612f, 0.04638620f, -0.07821320f, 0.01719348f, 0.01334563f, 0.01593935f, 0.01235572f, -0.07312507f, 
    0.23150949f, 0.14096098f, 0.07526578f, 0.10048391f, -0.03020316f, -0.02887683f, 0.03234011f, 0.02537008f, 
    -0.06207613f, 0.05408968f, -0.05543248f, -0.06360658f, 0.02898902f, -0.03563131f, -0.02874171f, 0.07928204f, 
    0.07107873f, -0.00712327f, 0.17729177f, 0.03660713f, -0.05715115f, -0.00550613f, -0.03991895f, 0.03326668f, 
    -0.17528406f, 0.16949570f, 0.03949626f, 0.05492492f, 0.10160761f, 0.00634820f, 0.08823103f, -0.01216469f, 
    -0.09371150f, -0.03001960f, -0.06319436f, -0.06534015f, 0.29253870f, -0.10077179f, -0.24758011f, 0.04915891f, 
    0.01320553f, -0.04010348f, 0.03231726f, 0.05792351f, 0.04405479f, 0.08963168f, -0.04767878f, -0.02549033f, 
    -0.31303638f, 0.15035354f, -0.17076606f, -0.03090064f, -0.03480378f, 0.02942056f, -0.03205202f, 0.06016250f, 
    -0.06049880f, -0.03656694f, 0.06148629f, -0.05514775f, -0.16479576f, 0.07037676f, -0.07693329f, 0.04525043f, 
    0.08044868f, -0.06475599f, 0.07413115f, 0.02814567f, -0.05819842f, -0.00555933f, -0.03029394f, -0.03776159f, 
    0.08944758f, 0.05341858f, -0.20545611f, -0.11453396f, -0.01196090f, 0.12276667f, -0.05129505f, -0.00597573f, 
    0.01284584f, -0.13267180f, 0.00289067f, -0.14930721f, 0.29294011f, 0.11947779f, -0.11740090f, -0.09730911f, 
    0.01434307f, 0.00908115f, -0.08454715f, -0.00970462f, -0.05122753f, 0.02727957f, -0.00380122f, 0.03903069f, 
    0.11878673f, -0.03324239f, -0.03475806f, -0.04354598f, 0.09562105f, -0.06671130f, -0.01489270f, -0.01268079f, 
    0.08593721f, 0.12489820f, 0.04428819f, 0.03547696f, -0.17927784f, 0.02914365f, -0.18020123f, 0.06260856f, 
    0.06981421f, -0.01650187f, 0.01909826f, 0.06797819f, -0.02882640f, 0.12243910f, -0.03708825f, -0.01800806f, 
    0.05392569f, -0.00975548f, -0.19329676f, -0.29476407f, 0.01740282f, 0.00677619f, 0.05403716f, -0.11921905f, 
    0.00301813f, -0.12118989f, -0.01067741f, -0.01876567f, -0.05704422f, -0.05254718f, -0.04646993f, 0.01605563f, 
    0.04237587f, -0.05638234f, 0.06132690f, 0.04686366f, -0.02506504f, -0.06122348f, 0.04501516f, -0.05320343f, 
    -0.26299417f, 0.04891729f, -0.15519519f, -0.22861597f, -0.03971019f, -0.10153911f, -0.06629302f, 0.00408857f, 
    0.00305448f, -0.10220875f, -0.01660121f, -0.08015396f, 0.07577458f, -0.17240749f, -0.06380094f, -0.04737726f, 
    -0.09215838f, 0.06969125f, -0.11530928f, -0.02941879f, -0.03028705f, -0.13293535f, -0.06101778f, -0.03980502f, 
    0.06968559f, -0.01728081f, -0.09204555f, 0.00418459f, -0.05329691f, 0.06198739f, 0.00508707f, -0.02033008f, 
    -0.00235232f, 0.13472942f, -0.03200629f, -0.01247828f, 0.16367207f, 0.09167434f, -0.24100348f, 0.06021023f, 
    0.04738102f, -0.02575031f, -0.02744602f, -0.12133849f, -0.07349516f, -0.03374004f, 0.00175331f, -0.07897661f, 
    0.19707781f, 0.04143201f, 0.01472224f, 0.19279686f, -0.02727940f, -0.07882825f, 0.08072396f, 0.00869466f, 
    0.01209780f, 0.09420907f, 0.03383894f, 0.00709936f, 0.38718110f, 0.08137105f, 0.12339503f, 0.05548764f, 
    -0.04253531f, -0.00506009f, 0.03207739f, 0.01439474f, -0.12114625f, 0.04245343f, 0.02836982f, -0.10004603f, 
    -0.09045397f, 0.08100389f, -0.00171146f, -0.00308439f, -0.01359550f, 0.05975114f, -0.04984863f, 0.02107715f, 
    -0.06814578f, 0.07069786f, -0.00538789f, 0.01318441f, 0.14206150f, 0.05776562f, -0.00109824f, 0.09475125f, 
    -0.04484217f, 0.07049511f, -0.02514608f, 0.04638093f, -0.02392611f, -0.00934391f, 0.07975584f, -0.03422027f, 
    0.00041025f, -0.18143857f, -0.03462140f, -0.07897914f, -0.10532432f, -0.00235100f, 0.03632888f, -0.03321400f, 
    -0.01727629f, -0.03363378f, -0.10100690f, -0.03429689f, 0.06836113f, 0.08929659f, 0.13192379f, -0.00618574f, 
    -0.11177781f, -0.01599237f, 0.01461107f, 0.05432618f, -0.02054857f, 0.00684600f, -0.05296363f, -0.02704491f, 
    -0.05468699f, 0.00708621f, -0.00276331f, 0.13601606f, -0.08795962f, -0.07061186f, 0.01061942f, -0.04503676f, 
    0.00805390f, 0.00435099f, -0.04880049f, 0.00346994f, 0.17190300f, 0.00586277f, -0.35606593f, -0.13871783f, 
    0.01057326f, 0.07836065f, -0.11026599f, 0.04540420f, 0.07004391f, 0.08895026f, -0.07438447f, -0.08300309f, 
    0.00665620f, 0.00465090f, -0.05470007f, 0.06391732f, 0.14423086f, 0.03921617f, -0.04804601f, -0.00030341f, 
    0.05892682f, 0.04405227f, -0.02062589f, -0.01556267f, 0.16780254f, -0.17665386f, 0.05445556f, -0.09489878f, 
    -0.10290992f, 0.04814496f, -0.13532838f, -0.07553894f, -0.04893053f, -0.04388110f, -0.01162800f, -0.07588051f, 
    0.04470751f, -0.06526566f, 0.01870138f, 0.00827170f, 0.04602041f, 0.12198789f, 0.02502830f, -0.05797079f, 
    -0.02726864f, 0.01069076f, -0.01975931f, 0.06215445f, 0.02725568f, 0.04239869f, 0.08626720f, 0.06223344f, 
    -0.06638917f, -0.04823705f, -0.00390898f, 0.00023899f, -0.03443915f, -0.07678583f, -0.12302922f, 0.07651167f, 
    0.00624077f, 0.11693565f, -0.04400689f, -0.05581141f, 0.00366395f, -0.07390726f, 0.01236839f, -0.00031594f, 
    -0.00103830f, 0.08889155f, -0.03670905f, 0.00577563f, -0.19582973f, 0.18277991f, 0.02857693f, -0.05297531f, 
    0.06125515f, 0.11803600f, 0.01428402f, -0.06074309f, -0.02369712f, -0.05795649f, 0.07448854f, -0.09691027f, 
    0.24437210f, -0.05526046f, 0.02711884f, 0.08369041f, 0.00909296f, -0.07601995f, 0.04575963f, 0.07219864f, 
    0.02737283f, 0.03530622f, 0.02709275f, 0.01698839f, -0.02518658f, 0.10493952f, -0.01909836f, -0.06233269f, 
    0.06405459f, 0.02709817f, 0.02449695f, -0.03241829f, 0.01026791f, 0.05398169f, -0.05458114f, 0.01265240f, 
    -0.29644936f, 0.08594524f, 0.13259989f, 0.01277946f, -0.15488498f, -0.02076223f, 0.15212236f, -0.02152253f, 
    -0.02129269f, -0.03417523f, -0.11046891f, 0.03656837f, -0.53560358f, -0.14964528f, -0.13344994f, -0.27300140f, 
    -0.01985407f, -0.00394458f, -0.10645694f, 0.09950933f, 0.06635281f, -0.07107590f, 0.01552338f, -0.02569561f, 
    0.01459346f, -0.21566020f, -0.00866457f, 0.09708668f, -0.06526640f, 0.04914845f, 0.15461166f, 0.14169139f, 
    -0.00042094f, 0.08160630f, 0.02882612f, 0.05925824f, 0.11279100f, -0.19390638f, -0.10302138f, 0.08501160f, 
    -0.04917926f, 0.09181024f, 0.05761332f, 0.06640551f, -0.00930506f, -0.02459454f, -0.01570334f, 0.00896889f, 
    -0.00543264f, 0.02811487f, 0.05963673f, -0.00765605f, -0.02613674f, 0.03009602f, 0.04357096f, -0.02354205f, 
    -0.10733410f, -0.00172512f, -0.02896846f, 0.07355434f, -0.11221994f, -0.04418997f, -0.01817630f, -0.08306286f, 
    0.04721745f, 0.01868498f, -0.01691632f, 0.06780003f, 0.03600508f, -0.05726503f, -0.06265837f, -0.07716209f, 
    0.21285217f, -0.01909938f, -0.15560234f, 0.00675466f, 0.01741735f, 0.07425174f, -0.02438694f, 0.03081646f, 
    -0.04992112f, 0.01685212f, 0.03432195f, -0.05378323f, 0.10647064f, -0.04375629f, -0.03177408f, -0.04049698f, 
    -0.11822196f, -0.05549273f, -0.00134057f, -0.06759956f, 0.00835440f, -0.11001416f, 0.02701454f, -0.11542413f, 
    -0.02222881f, -0.23382930f, -0.22252423f, -0.01748733f, -0.02633235f, 0.05198318f, -0.05356014f, 0.03738797f, 
    -0.00998749f, 0.04811461f, -0.07192910f, -0.03871698f, 0.17023052f, -0.15219738f, 0.01045064f, 0.08610452f, 
    -0.04197076f, -0.01734267f, 0.04964278f, 0.05804184f, 0.02601337f, 0.01217876f, 0.07150920f, 0.05805229f, 
    -0.17450888f, -0.08292120f, -0.09142564f, -0.13153267f, -0.10508217f, 0.02204832f, 0.02982417f, 0.07358798f, 
    -0.01878006f, 0.06808874f, 0.08000492f, -0.08815432f, 0.31251764f, -0.00979287f, -0.00570690f, 0.24131867f, 
    -0.00522235f, -0.02421372f, 0.05277489f, -0.00044482f, 0.04269542f, -0.02314349f, -0.08410702f, -0.02768993f, 
    0.01522510f, -0.15529811f, -0.05609398f, 0.00023215f, -0.05035758f, 0.03254534f, -0.01358543f, 0.00245552f, 
    -0.09546332f, 0.08411749f, -0.05879802f, 0.06542407f, 0.31812236f, -0.10793398f, -0.00420059f, 0.02866734f, 
    -0.13226029f, 0.10456817f, 0.03318108f, 0.10903346f, 0.04493784f, -0.02927018f, -0.06715311f, 0.06107087f, 
    0.16568056f, 0.06370723f, -0.11491499f, -0.17226787f, -0.03857388f, -0.02835068f, 0.01986866f, -0.00162593f, 
    -0.03925752f, 0.00655100f, 0.15228851f, 0.02037333f, -0.35629460f, -0.07802200f, -0.05649219f, -0.11409330f, 
    -0.06716479f, -0.06611267f, 0.02591656f, -0.08863817f, 0.00041317f, -0.02807403f, 0.04399306f, -0.01373915f, 
    0.11186936f, 0.12005735f, 0.08416022f, 0.14601207f, -0.06035237f, -0.09377109f, -0.03263094f, -0.07219870f, 
    -0.04293970f, 0.08193865f, 0.00788743f, 0.02168755f, -0.28495067f, 0.08510658f, 0.00615849f, 0.02133842f, 
    -0.06266262f, -0.01802823f, 0.07574468f, 0.10384097f, -0.02543851f, 0.04796624f, 0.04194253f, 0.09602978f, 
    -0.63011003f, -0.13016203f, 0.15643558f, 0.13597694f, 0.06271855f, 0.07889491f, 0.01686111f, -0.03379903f, 
    -0.07677595f, -0.04739694f, -0.08099598f, -0.07459065f, 0.06532899f, 0.02525110f, -0.04343818f, -0.23662743f, 
    -0.12710300f, -0.05491628f, -0.01183857f, 0.01239244f, -0.04467294f, -0.04287137f, -0.10763242f, -0.00891919f, 
    -0.17151113f, -0.09166966f, -0.15719438f, -0.11490317f, -0.13953067f, -0.01088219f, 0.04680775f, 0.04627849f, 
    -0.09708478f, 0.16146560f, -0.03337885f, 0.02943546f, -0.21752556f, 0.17008696f, 0.12537536f, 0.21924256f, 
    0.04195461f, 0.04116736f, 0.00570284f, 0.00352879f, 0.01909663f, 0.05240227f, -0.06664985f, -0.05694258f, 
    0.08413320f, 0.05496771f, 0.17702417f, -0.08395379f, 0.03798469f, -0.03474518f, 0.10787045f, 0.03027166f, 
    -0.04375682f, -0.03824430f, -0.06906680f, -0.01273794f, 0.15896629f, 0.09674145f, 0.09018084f, 0.13044879f, 
    0.10265112f, -0.04912196f, 0.08057061f, 0.05928433f, 0.04309542f, 0.05762035f, 0.01861717f, -0.07758472f, 
    0.21578324f, 0.02417899f, -0.00770336f, -0.04161556f, 0.10722820f, 0.00834370f, 0.04738025f, -0.01624462f, 
    -0.10985009f, -0.06568768f, 0.00364073f, -0.05014924f, -0.23826919f, -0.50420505f, 0.01758310f, 0.31343916f, 
    -0.00873435f, 0.06503320f, -0.08038370f, 0.00278951f, -0.00743134f, -0.09759878f, -0.01968730f, 0.11814691f, 
    -0.04845435f, -0.05007232f, -0.11916441f, -0.13162392f, -0.07706621f, 0.07628217f, -0.02515769f, -0.00692855f, 
    0.01380989f, 0.05491829f, 0.07436543f, 0.00905912f, 0.02081296f, 0.21082990f, 0.13113743f, 0.20580454f, 
    0.05555479f, 0.15428750f, -0.03583685f, 0.01793461f, 0.01953237f, 0.03167550f, -0.05279548f, -0.06230997f, 
    0.07390045f, -0.03193691f, -0.08431606f, -0.06506036f, -0.10712935f, -0.06932423f, 0.03746537f, 0.05254856f, 
    -0.08002283f, 0.04433983f, 0.00501342f, 0.07627553f, -0.01901844f, -0.19242579f, -0.15524738f, 0.00867698f, 
    -0.05043240f, -0.00331345f, 0.02698757f, 0.02507169f, -0.03008161f, -0.00827140f, 0.05965038f, -0.07648015f, 
    0.14886308f, 0.08720099f, -0.05878063f, 0.12830426f, -0.15602101f, -0.10210880f, -0.11293683f, -0.03743334f, 
    0.02325376f, 0.03353843f, -0.02597763f, -0.01695499f, -0.29396257f, -0.06652434f, -0.01051235f, -0.06367218f, 
    -0.12673175f, -0.16675204f, 0.00830099f, -0.04882760f, 0.00413782f, -0.02333940f, 0.01181468f, 0.08132264f, 
    -0.11172669f, 0.17788097f, 0.02406602f, -0.14836448f, 0.01600797f, -0.09537339f, -0.00262627f, 0.01092373f, 
    -0.00585501f, -0.03556136f, -0.00463880f, 0.03012783f, -0.05213181f, 0.14580390f, -0.14538167f, 0.05119352f, 
    -0.09819165f, 0.01749888f, 0.06357560f, -0.00744603f, -0.09069113f, 0.05873839f, -0.14319152f, 0.02549909f, 
    -0.13174367f, 0.09990438f, -0.09420221f, 0.16376850f, -0.06738114f, 0.00282297f, 0.00715470f, -0.01279142f, 
    -0.01941620f, 0.05226382f, -0.03470812f, -0.00349408f, -0.11524007f, 0.21234174f, 0.16493677f, 0.02759921f, 
    0.08193790f, 0.02312229f, -0.01773931f, 0.15676488f, -0.05340833f, -0.09991778f, -0.00416362f, 0.06459504f, 
    0.15012226f, -0.16557050f, 0.13792644f, 0.11572395f, 0.02272161f, -0.05709763f, 0.08550608f, 0.00981747f, 
    0.01283109f, -0.02505489f, 0.05050622f, 0.00028382f, -0.06689299f, -0.17860857f, -0.03769051f, -0.04991797f, 
    0.01577532f, 0.06156781f, -0.07268910f, 0.08203080f, 0.00034222f, 0.09981828f, -0.02946563f, -0.09094132f, 
    -0.23306035f, 0.32424957f, -0.00711730f, 0.10584625f, -0.00493163f, -0.05764156f, 0.06214263f, -0.00904464f, 
    -0.05818466f, -0.02831140f, 0.00620464f, -0.18146235f, 0.06903744f, 0.28697121f, 0.06341824f, -0.16636942f, 
    -0.10323503f, -0.06463841f, -0.04393400f, -0.03610368f, -0.00607621f, -0.04916262f, -0.06932358f, 0.00938861f, 
    -0.16455054f, -0.34322780f, -0.20044021f, -0.05265994f, -0.13663167f, -0.05228147f, -0.09859658f, -0.02279102f, 
    0.06985670f, 0.01477834f, 0.13419253f, -0.01340967f, -0.06244110f, -0.04907580f, 0.14511068f, 0.00222032f, 
    -0.05383101f, 0.03022764f, -0.15039945f, 0.00668946f, -0.02263780f, 0.18168205f, -0.03265648f, 0.01056282f, 
    -0.07341845f, 0.24820948f, 0.18521135f, 0.05226648f, -0.04225106f, 0.16459739f, -0.04474452f, 0.04592328f, 
    -0.07727096f, 0.03383281f, 0.01965240f, 0.16245180f, 0.04508878f, -0.14222233f, 0.15596054f, 0.06998593f, 
    -0.02219342f, 0.08561092f, -0.01232547f, -0.01706167f, -0.03502082f, 0.00504831f, 0.04295933f, 0.04785813f, 
    0.07084177f, -0.06316010f, 0.08836126f, -0.14885901f, -0.08467610f, 0.00524202f, 0.01747244f, 0.08623963f, 
    -0.02128241f, 0.01209422f, 0.04978880f, 0.07045335f, 0.21510729f, 0.09766731f, 0.01828540f, 0.11094391f, 
    0.04935562f, 0.06592771f, -0.05203719f, 0.03940647f, -0.02308238f, -0.12088311f, 0.11337301f, -0.06936064f, 
    -0.15257685f, -0.19747496f, -0.40059072f, 0.09159531f, -0.05367158f, -0.07347288f, 0.10455100f, -0.00505440f, 
    -0.01185496f, -0.02501091f, 0.00784871f, 0.00026046f, -0.47367510f, 0.01314177f, 0.12691674f, 0.09775420f, 
    0.05322718f, 0.09181807f, -0.01455561f, -0.05572736f, 0.01656949f, -0.03285299f, -0.05085687f, -0.11361226f, 
    0.01767434f, -0.04669632f, 0.01758517f, -0.01649315f, -0.05593455f, -0.01095858f, 0.07329457f, -0.02268966f, 
    -0.06953557f, 0.04759241f, -0.00808033f, -0.00608988f, -0.10721073f, 0.18422180f, 0.09378806f, -0.27598879f, 
    -0.00521279f, 0.08321426f, -0.03203465f, 0.03519267f, 0.07865420f, -0.13658436f, 0.00163722f, -0.06254412f, 
    -0.21842094f, -0.40414873f, -0.03171388f, 0.12254945f, 0.05418162f, 0.09324800f, -0.10877158f, 0.01643542f, 
    0.13116230f, 0.06986299f, -0.01282665f, 0.04711669f, -0.34107846f, 0.05857363f, -0.12530981f, -0.16189806f, 
    -0.02965016f, -0.04053766f, -0.00868476f, 0.01954499f, 0.00454263f, -0.03804011f, 0.02217686f, 0.00769063f, 
    0.30692595f, -0.14238091f, -0.06519494f, 0.10203585f, -0.05501377f, 0.14471568f, 0.06362246f, 0.08126312f, 
    0.14922826f, -0.03809871f, -0.09488506f, -0.09315996f, -0.00216512f, 0.08185907f, -0.04360550f, -0.19137666f, 
    -0.13676137f, -0.05129533f, 0.03069562f, -0.05391014f, -0.06048240f, -0.05457493f, 0.04018624f, 0.04818686f, 
    -0.00929708f, -0.05001831f, -0.03696426f, 0.09796230f, -0.05304949f, 0.07338542f, 0.05549188f, 0.07142814f, 
    -0.08549996f, 0.02198316f, -0.03701564f, 0.04640447f, 0.01766795f, 0.14285590f, 0.10608976f, 0.00356579f, 
    0.06200373f, -0.09784961f, -0.09294678f, -0.00419397f, 0.04406362f, 0.08170941f, -0.11033454f, 0.00512613f, 
    -0.07367315f, -0.40626010f, 0.00746409f, 0.15836726f, -0.05022971f, 0.12033436f, 0.01744920f, -0.03118148f, 
    0.00617047f, -0.11331759f, 0.05735762f, -0.09365167f, 0.15356691f, 0.12168414f, 0.01102378f, 0.13284557f, 
    0.02859658f, 0.12925334f, -0.03314763f, 0.04987065f, 0.02692620f, 0.08173621f, 0.08315928f, -0.03001187f, 
    -0.29182866f, -0.38919839f, -0.12552136f, 0.07904276f, -0.12211246f, -0.09769202f, 0.08276260f, -0.06267995f, 
    0.06521802f, -0.08384163f, -0.02363421f, 0.09603439f, -0.08616686f, -0.08575664f, -0.06091366f, 0.06491667f, 
    -0.08190028f, -0.07594136f, 0.00165333f, 0.03730406f, 0.03860404f, 0.01139555f, -0.05906136f, 0.00699832f, 
    -0.06755616f, -0.27391633f, -0.23302582f, -0.04170322f, -0.02974775f, -0.03616029f, -0.00750530f, -0.11132254f, 
    -0.04519995f, 0.06074838f, -0.00569159f, -0.02369155f, 0.33080417f, 0.11462215f, 0.01303129f, 0.12684290f, 
    0.05068246f, 0.10567954f, -0.14748450f, 0.01859418f, 0.11993698f, -0.00940359f, -0.01439721f, -0.03706784f, 
    0.00075654f, 0.05103927f, -0.02508366f, 0.11166985f, -0.04846546f, 0.05202115f, -0.02820983f, -0.16094421f, 
    -0.04465383f, 0.13886552f, -0.03568889f, -0.05420034f, 0.09122474f, -0.19900849f, -0.09941749f, 0.06628758f, 
    -0.07276392f, -0.00474721f, -0.16087994f, 0.10300538f, 0.06658477f, -0.07835818f, 0.01191519f, -0.02327988f, 
    -0.15679008f, -0.02525006f, -0.17371230f, 0.04294047f, -0.00439760f, 0.00045825f, 0.22689331f, 0.06166919f, 
    0.07885738f, -0.07974866f, -0.07297307f, -0.06611241f, -0.15098864f, 0.07220762f, -0.06544728f, 0.02018448f, 
    -0.02546313f, -0.14696543f, -0.03509603f, -0.00328239f, -0.02935440f, 0.07133046f, -0.02170692f, -0.11149251f, 
    -0.04121866f, -0.06317162f, 0.12987395f, -0.15857430f, -0.07175543f, 0.14404790f, 0.13854350f, 0.09484984f, 
    0.04568584f, 0.04113591f, 0.02177787f, 0.18675317f, -0.14397234f, -0.37386614f, 0.19628622f, -0.24283804f, 
    -0.03776623f, -0.08606605f, -0.03583103f, -0.04019555f, 0.13329799f, 0.08441207f, -0.00884486f, -0.01345550f, 
    -0.75986314f, 0.29855648f, 0.02430211f, -0.09683650f, 0.03848239f, -0.01493085f, 0.00008635f, 0.00768880f, 
    0.01547473f, 0.04047244f, -0.08678266f, 0.08397684f, -0.04786178f, -0.14059705f, -0.00027269f, -0.05434671f, 
    0.03034811f, -0.00005956f, 0.01983572f, -0.07056358f, 0.01840221f, 0.04640496f, 0.00665891f, -0.04590689f, 
    -0.08619411f, 0.15537925f, 0.09155668f, -0.22713754f, -0.04933310f, -0.01700643f, 0.07493117f, 0.02534293f, 
    0.00993536f, 0.02192218f, -0.03668042f, -0.01574014f, -0.00867177f, 0.13642095f, -0.10600136f, 0.14157850f, 
    0.04588532f, 0.00328063f, 0.00905575f, 0.10710274f, 0.07242731f, 0.09506452f, -0.02791618f, -0.09138878f, 
    -0.05801715f, -0.18622451f, 0.04720361f, -0.09354488f, -0.03707987f, 0.01971743f, -0.00602009f, -0.13557008f, 
    0.01173637f, 0.01414060f, -0.06467822f, -0.06570137f, -0.21803707f, 0.28347957f, -0.00860042f, -0.13075504f, 
    -0.08237024f, 0.00931121f, 0.06620940f, -0.05486339f, -0.05312990f, -0.04823697f, 0.08855635f, -0.00361035f, 
    -0.11438206f, 0.13409580f, 0.09708937f, 0.00344089f, -0.06965390f, 0.05597538f, 0.09820139f, 0.10034169f, 
    0.04761732f, -0.02649082f, -0.00321577f, -0.05543080f, -0.05788971f, 0.04581954f, 0.09295550f, 0.03638535f, 
    -0.12906249f, -0.11635845f, -0.01473276f, 0.03840752f, 0.09207159f, -0.03171088f, 0.04413422f, 0.00948094f, 
    -0.17332917f, -0.02707421f, 0.14658943f, 0.18144147f, 0.02031174f, 0.04307627f, 0.00665022f, 0.01260976f, 
    0.01112818f, 0.03238434f, -0.00798458f, 0.02327608f, 0.03115126f, 0.06680740f, -0.12470832f, -0.02635068f, 
    -0.11850408f, 0.08483163f, 0.05057849f, -0.05426843f, -0.01839172f, 0.04235659f, 0.00714907f, -0.06347804f, 
    0.12801705f, -0.17762223f, -0.03484465f, -0.20551391f, 0.11703218f, 0.00150915f, -0.12007866f, -0.28841895f, 
    0.04858031f, 0.05548391f, -0.02909348f, -0.03228084f, 0.32226825f, -0.01127171f, -0.31636584f, -0.13893092f, 
    -0.01911751f, -0.06208910f, 0.14998701f, 0.00351364f, -0.05117540f, -0.10638817f, 0.06703459f, -0.12960686f, 
    0.08342564f, -0.03727211f, -0.20570171f, 0.02139756f, 0.04267493f, -0.00995805f, 0.11312287f, 0.04650007f, 
    -0.07816474f, -0.00431046f, 0.01567218f, 0.00826973f, 0.06637623f, 0.03456482f, -0.08349764f, -0.12802194f, 
    -0.00543300f, 0.04163510f, -0.14909573f, -0.02649196f, 0.00078493f, 0.04795550f, -0.00664902f, 0.12460454f, 
    -0.35824212f, 0.10173339f, 0.16127051f, 0.07046758f, -0.06257431f, 0.05422040f, -0.10320833f, -0.07302472f, 
    0.05112153f, -0.08579607f, -0.07160582f, 0.03030928f, -0.05533594f, -0.20872836f, 0.06991541f, 0.30149603f, 
    0.02571547f, -0.03099228f, -0.01353891f, 0.07725991f, -0.00052902f, 0.04716061f, 0.08121364f, 0.03355289f, 
    -0.18827753f, -0.17923473f, 0.21585873f, -0.22587907f, 0.00099197f, 0.01058351f, -0.03431353f, -0.00526117f, 
    0.07365169f, 0.01899921f, 0.03171565f, -0.02802929f, -0.24816507f, -0.09025688f, 0.12292596f, 0.04283372f, 
    0.10602779f, -0.14208922f, -0.05537461f, 0.05534124f, 0.15753004f, 0.01670717f, -0.02546971f, 0.01147097f, 
    -0.23206948f, -0.09831361f, -0.01218980f, -0.07610510f, 0.17930743f, 0.01047920f, -0.03479524f, 0.03445615f, 
    -0.03547450f, 0.08597320f, 0.03807532f, -0.05863365f, 0.18926620f, 0.23406550f, -0.01849539f, -0.05679222f, 
    0.02177326f, 0.04012923f, 0.00224426f, -0.06861692f, -0.06565748f, -0.00226557f, 0.05490191f, 0.04210844f, 
    -0.48703656f, -0.25605014f, -0.18427514f, -0.08516457f, 0.12636821f, 0.04089599f, -0.00461555f, 0.10803242f, 
    -0.09147362f, -0.08264814f, -0.10288946f, -0.00343110f, 0.02939419f, 0.20843235f, -0.02530512f, -0.15400453f, 
    -0.00630087f, 0.01470600f, -0.00892805f, 0.09798101f, 0.04596118f, -0.05158189f, -0.02264353f, -0.02237837f, 
    -0.17816189f, 0.06278386f, 0.06081299f, 0.20186207f, 0.04317892f, 0.04279757f, -0.06945648f, -0.01728630f, 
    0.03592215f, 0.02735943f, 0.01504447f, -0.04962830f, -0.10485639f, -0.19602790f, 0.19815530f, 0.10839717f, 
    -0.10341010f, 0.05974772f, 0.03640707f, -0.00491991f, 0.17302144f, 0.04682273f, -0.04900620f, -0.02428298f, 
    0.14231932f, 0.05989351f, 0.07116406f, 0.07640410f, 0.02057878f, 0.09217586f, 0.00936939f, 0.10234681f, 
    -0.00171580f, -0.07327128f, -0.03501009f, 0.00128790f, -0.01149580f, 0.08945762f, 0.15988600f, 0.06811790f, 
    -0.02588123f, 0.03963350f, 0.02216933f, -0.02820095f, 0.02305937f, -0.02152603f, -0.02710531f, -0.03530217f, 
    0.11213680f, 0.00490845f, 0.01929876f, 0.00203318f, 0.01212697f, 0.04691346f, -0.01067171f, 0.07879122f, 
    0.02909954f, -0.04533144f, 0.02765274f, -0.04142047f, -0.02945202f, 0.17212160f, -0.11646357f, -0.10050590f, 
    0.05897509f, 0.02097009f, -0.10746586f, 0.05013703f, -0.01175391f, -0.00814647f, -0.13824044f, -0.00110171f, 
    0.10141755f, 0.24076964f, -0.13068183f, 0.03910242f, 0.09288241f, -0.08335004f, -0.03612556f, -0.03646097f, 
    -0.02713523f, 0.07554534f, 0.06681187f, -0.03751898f, 0.09691641f, -0.32522818f, 0.04581507f, 0.11136825f, 
    -0.05311508f, 0.03859436f, 0.10234436f, -0.07019771f, -0.00527205f, 0.03171068f, 0.11483407f, -0.01174792f, 
    -0.09363896f, -0.17807975f, -0.31160188f, 0.19414920f, 0.06057928f, -0.04349978f, 0.04390427f, -0.00766494f, 
    -0.08523767f, -0.01320937f, 0.04878484f, -0.05110442f, -0.06609389f, 0.08403635f, -0.03677336f, -0.13573574f, 
    -0.05109689f, -0.04234257f, -0.06397269f, 0.05300387f, -0.09434564f, -0.05198674f, 0.04475334f, 0.02714353f, 
    0.04191380f, -0.09000774f, 0.04103250f, -0.02575362f, 0.06819502f, 0.09953600f, 0.04172924f, -0.01973672f, 
    -0.04016036f, -0.02027786f, 0.09527986f, -0.03287870f, -0.38592306f, 0.03994999f, 0.08133350f, -0.06489120f, 
    -0.00544615f, 0.05353953f, -0.01774697f, 0.06670397f, 0.10526145f, -0.04701223f, 0.03958867f, 0.14665847f, 
    -0.24091171f, -0.31840703f, 0.16912065f, 0.02611304f, -0.03727799f, 0.02287159f, 0.08668622f, -0.17271453f, 
    0.05450821f, -0.05313908f, 0.08858097f, -0.08052574f, 0.22633548f, 0.09744563f, -0.01641898f, -0.07580572f, 
    0.10763103f, -0.01350289f, 0.06984545f, -0.02712670f, 0.10678436f, -0.05601755f, -0.11524396f, -0.03915220f, 
    0.23501362f, 0.06490937f, -0.01380496f, 0.13765414f, -0.10822693f, 0.03624714f, 0.04023430f, 0.09573967f, 
    -0.02540772f, 0.02680347f, 0.11529782f, 0.15913422f, 0.12059747f, -0.15387167f, -0.02787686f, 0.06382114f, 
    -0.08702814f, -0.07782268f, 0.02654311f, 0.05743447f, -0.06120145f, 0.12220971f, 0.01246557f, 0.15528579f, 
    -0.12094919f, 0.03558378f, 0.27990013f, -0.02798705f, -0.01065020f, -0.07682249f, -0.03458265f, -0.00125658f, 
    0.00870197f, 0.01113487f, -0.07387363f, 0.08041774f, -0.23094682f, 0.09519313f, 0.02689311f, 0.21278675f, 
    -0.04265834f, 0.05307998f, 0.11010514f, 0.05031462f, 0.02060146f, -0.01486204f, 0.01657786f, 0.00837142f, 
    0.32160711f, -0.05157700f, 0.15337163f, -0.06470212f, 0.01214114f, 0.11513791f, 0.02489869f, 0.03709161f, 
    0.00179646f, -0.06079912f, -0.05283662f, 0.02543022f, -0.25019264f, 0.01001093f, -0.05342927f, -0.16106048f, 
    0.05267327f, 0.16024667f, 0.01268669f, -0.02495500f, 0.03078001f, -0.15774071f, -0.10593154f, 0.03285569f, 
    -0.08607230f, 0.02176568f, 0.04806306f, 0.02518466f, -0.01946580f, -0.00908216f, 0.03993663f, 0.04935235f, 
    -0.03640248f, 0.03597982f, 0.02218855f, -0.00795917f, -0.20369348f, -0.06483178f, 0.05559696f, 0.14677480f, 
    -0.10108764f, -0.12154756f, -0.03215586f, 0.02413686f, -0.06969953f, 0.00656409f, -0.03736473f, -0.07878853f, 
    -0.51406562f, -0.12342706f, 0.16862835f, 0.10968611f, 0.06713207f, -0.00935177f, -0.05715437f, 0.08279494f, 
    -0.04468191f, -0.09342253f, 0.01840570f, 0.06607444f, 0.36286131f, 0.04014793f, 0.01508071f, 0.07907625f, 
    -0.02813407f, -0.00856050f, 0.01085835f, 0.07695954f, -0.06204044f, 0.06448992f, 0.01864184f, 0.05632298f, 
    -0.20054112f, 0.14420533f, 0.03670460f, -0.09243926f, -0.00858097f, -0.02605658f, -0.06855651f, -0.01099610f, 
    -0.01227227f, -0.11536436f, -0.15763374f, -0.01647096f, -0.07081135f, -0.15586552f, 0.00952962f, 0.11128569f, 
    -0.04076243f, 0.11514892f, 0.09608988f, -0.05852047f, 0.01477025f, 0.00211453f, 0.05323782f, 0.07736120f, 
    0.09002392f, -0.25584060f, -0.05097246f, 0.09070068f, -0.11507417f, -0.06156304f, 0.15520255f, -0.09426591f, 
    0.00900881f, -0.18057594f, -0.11636421f, -0.08782554f, -0.29896379f, 0.07646818f, 0.02857974f, 0.13211147f, 
    0.07966016f, 0.02704898f, -0.03539114f, -0.11274109f, -0.03168419f, 0.03804658f, 0.05835011f, -0.10665708f, 
    -0.04171409f, -0.08103634f, 0.00465711f, 0.04148009f, 0.01837897f, -0.06159360f, 0.08176149f, 0.19251181f, 
    -0.03240429f, -0.10172181f, 0.09622890f, 0.04695717f, -0.07567101f, -0.12780724f, 0.22161716f, -0.02943314f, 
    -0.04879902f, 0.06415249f, -0.03675497f, -0.08580917f, -0.01505864f, -0.03005641f, -0.02836848f, 0.08261958f, 
    0.09729615f, 0.10763754f, 0.07131290f, 0.02033004f, 0.08993004f, 0.03460030f, 0.05611764f, 0.11344186f, 
    0.02263420f, -0.01886309f, 0.08688241f, 0.00813389f, -0.16543035f, 0.03608219f, -0.05944916f, 0.08287019f, 
    0.06695210f, -0.06382677f, 0.00972845f, -0.05410228f, 0.00051578f, -0.01057950f, -0.04889132f, 0.01771022f, 
    0.02998165f, -0.10662277f, -0.10924076f, 0.02505020f, -0.10978569f, -0.09730672f, 0.06806969f, 0.04498630f, 
    -0.02611941f, -0.03938345f, -0.01466160f, -0.00107042f, -0.26043928f, 0.05877763f, -0.09162965f, 0.01427632f, 
    -0.03600477f, -0.11408458f, 0.22728981f, 0.03354453f, 0.03055699f, 0.07106177f, 0.00188662f, 0.06127679f, 
    0.06796338f, -0.10416789f, 0.13977477f, 0.15262049f, -0.10840591f, 0.04975660f, 0.06272438f, -0.06815045f, 
    0.10417802f, 0.02019008f, -0.00066853f, -0.01351893f, -0.06339215f, -0.18752888f, -0.17548135f, 0.21148826f, 
    -0.25292808f, -0.01636049f, -0.12697499f, -0.17449781f, -0.09297793f, -0.00496212f, -0.10954827f, -0.00775323f, 
    -0.42020565f, 0.11324627f, 0.00997925f, 0.13623698f, 0.02099589f, -0.11172573f, -0.06028717f, 0.09248460f, 
    -0.07176328f, -0.15273899f, 0.04818492f, 0.14442112f, -0.23780887f, 0.09816711f, 0.06813625f, -0.04802401f, 
    0.02205676f, -0.03734931f, -0.05622144f, 0.04547802f, -0.02346906f, -0.06193111f, 0.14005227f, -0.09932286f, 
    0.06307400f, 0.05157175f, 0.07064759f, -0.19846259f, 0.12043367f, 0.02081833f, -0.07330349f, 0.04872316f, 
    0.04880022f, 0.06307147f, 0.05034289f, -0.05613856f, -0.14088103f, 0.04366897f, -0.01648981f, -0.07717720f, 
    -0.12732023f, 0.07705641f, 0.17829680f, 0.07091311f, 0.11405687f, 0.08028688f, -0.02334234f, 0.07419124f, 
    0.09964309f, 0.04803172f, -0.04763270f, -0.04102000f, 0.10533191f, -0.05017731f, -0.29666451f, 0.11359224f, 
    -0.07197073f, 0.03667402f, 0.08518235f, -0.05719913f, 0.29157215f, 0.02859088f, -0.18329315f, 0.02064527f, 
    0.04491528f, 0.08146203f, 0.02374388f, 0.05910799f, -0.11041312f, -0.02390354f, 0.06886441f, -0.16326693f, 
    -0.36043417f, 0.11325323f, -0.01323257f, -0.24478568f, 0.09122189f, -0.04553223f, -0.06007474f, 0.03704189f, 
    -0.07997889f, -0.01891558f, 0.12710758f, -0.24229479f, -0.07898396f, 0.22768652f, 0.01345560f, 0.15500604f, 
    -0.13975854f, -0.12452605f, 0.12546197f, 0.04078211f, 0.04637140f, -0.06470930f, 0.06178980f, 0.06223177f, 
    0.00625072f, 0.04924929f, -0.04816548f, 0.00170091f, 0.14407080f, 0.05027303f, -0.08124255f, -0.17218913f, 
    -0.07557441f, 0.03152034f, 0.16602957f, 0.04424327f, -0.33295968f, -0.22635292f, -0.09709716f, -0.02681323f, 
    0.10800055f, 0.00022384f, -0.03409101f, -0.06843669f, 0.11551663f, 0.07120989f, -0.00298876f, 0.12649186f, 
    -0.09849100f, -0.00206540f, -0.07332823f, -0.13593154f, -0.03401822f, -0.05527246f, -0.12415309f, 0.02238250f, 
    0.13065714f, -0.03396130f, -0.04035267f, -0.11778592f, -0.31837213f, 0.18792577f, -0.05547731f, 0.16277245f, 
    -0.05077231f, 0.11822584f, -0.08715419f, -0.22770971f, -0.04922715f, -0.02540093f, -0.18188687f, 0.02945701f, 
    -0.02075751f, 0.15615068f, 0.07877152f, -0.02660452f, 0.01764902f, -0.11459854f, -0.03668290f, 0.10130952f, 
    0.04020343f, 0.06036233f, 0.00310381f, -0.07695849f, -0.03628445f, -0.03477712f, 0.02050203f, -0.03290065f, 
    -0.02430904f, 0.10213496f, 0.04625771f, -0.08265522f, -0.09315527f, -0.11730038f, 0.12013295f, 0.13720734f, 
    -0.00631750f, -0.13533479f, -0.21135366f, -0.02905814f, 0.06089468f, 0.09311602f, -0.07201841f, 0.06194896f, 
    0.00193453f, 0.02448139f, -0.06022417f, 0.22957046f, -0.10613294f, 0.16100240f, -0.02360279f, 0.08009750f, 
    -0.03889536f, -0.07770891f, 0.04647174f, 0.02669428f, -0.05356164f, -0.06518095f, -0.02604052f, 0.04738424f, 
    0.06562723f, 0.17030765f, 0.06155809f, 0.12402995f, -0.03194007f, -0.05613597f, 0.01487659f, 0.12053411f, 
    -0.11133088f, -0.11443542f, 0.06260365f, -0.08247687f, -0.02477317f, -0.00187732f, 0.29529619f, 0.01643389f, 
    0.14339399f, 0.12686440f, -0.13080023f, -0.10471895f, -0.06208389f, 0.00745799f, -0.05287869f, 0.05851344f, 
    -0.12820543f, -0.19808841f, 0.03491060f, 0.14055426f, -0.00907740f, 0.15922664f, 0.09114225f, -0.00426318f, 
    0.01005711f, -0.18089968f, 0.02386780f, -0.03458069f, 0.05271483f, 0.03278561f, 0.06922350f, -0.01247890f, 
    -0.01729110f, 0.11411711f, -0.11708626f, -0.00349380f, -0.00918234f, -0.07373726f, -0.07069365f, -0.06421124f, 
    0.05901184f, 0.05581668f, 0.11778723f, -0.13789158f, -0.06485187f, -0.06710577f, -0.01135870f, 0.03848043f, 
    -0.09069387f, 0.04596854f, 0.09196388f, 0.12731244f, -0.18880951f, 0.04379281f, -0.13281122f, 0.10955578f, 
    0.10816321f, 0.14234240f, -0.05991079f, 0.04008981f, -0.06199060f, -0.02520357f, -0.00408353f, 0.02571892f, 
    0.14327155f, -0.10345531f, -0.00725319f, 0.12697707f, 0.02737392f, 0.04389885f, -0.05363264f, 0.07711513f, 
    0.13596509f, -0.03977680f, 0.03210560f, 0.05253444f, -0.04398457f, 0.14279142f, -0.03168653f, -0.15530957f, 
    0.10519470f, 0.07663406f, 0.06502046f, 0.01995898f, 0.07308013f, -0.09849858f, 0.04096108f, 0.00047149f, 
    -0.17702539f, -0.04543216f, -0.18626200f, -0.29737633f, 0.05021237f, 0.09658745f, 0.04015186f, 0.00520217f, 
    0.06072930f, -0.06006095f, -0.00968156f, 0.17076844f, -0.07545190f, 0.01575923f, 0.06756465f, 0.32958838f, 
    0.15041502f, 0.04290377f, 0.01883638f, 0.03458874f, -0.00240511f, 0.05919506f, -0.13378198f, 0.03011187f, 
    -0.29403946f, 0.06510641f, -0.10191281f, -0.06281379f, 0.04776761f, -0.05172621f, 0.10119402f, 0.12106786f, 
    0.07146998f, -0.04020978f, 0.00611325f, -0.05042481f, -0.02581680f, 0.14431632f, 0.18274845f, 0.09160301f, 
    -0.02552532f, 0.05182523f, 0.01327539f, -0.02984265f, 0.12651601f, 0.06784144f, 0.06526820f, 0.13361725f, 
    0.07428543f, -0.08561336f, -0.22918580f, -0.02746435f, 0.07547167f, -0.22904323f, -0.02680032f, -0.19214217f, 
    -0.04101431f, -0.00217738f, -0.14562041f, -0.03031709f, 0.05518670f, 0.01549244f, -0.15722497f, -0.01382660f, 
    -0.13265453f, -0.08698041f, -0.00070011f, -0.03669672f, 0.06262604f, 0.01213695f, 0.08908011f, 0.28696242f, 
    -0.60531425f, -0.14274661f, -0.11719821f, 0.07459985f, 0.09918981f, -0.02635160f, -0.02416859f, 0.04487227f, 
    -0.01511750f, 0.11426762f, 0.07660902f, 0.02417732f, 0.03826818f, -0.00396661f, -0.02822103f, 0.05593122f, 
    -0.01813410f, -0.01224861f, 0.01299937f, -0.09960373f, -0.10700545f, 0.10353736f, 0.08867499f, -0.01280903f, 
    -0.30477080f, -0.12106688f, 0.00339744f, 0.19292291f, 0.12456918f, 0.02283862f, -0.06803705f, -0.01827590f, 
    -0.09076916f, 0.01714172f, -0.19417423f, 0.21026030f, -0.18107788f, 0.05999241f, 0.03519839f, -0.07926186f, 
    0.08863869f, 0.06810484f, 0.13866241f, 0.07039764f, -0.07309499f, 0.05651286f, -0.11115458f, 0.06895352f, 
    -0.24234824f, -0.21961564f, 0.01338971f, -0.03110649f, 0.03312857f, 0.12894182f, -0.10782757f, -0.20757876f, 
    0.14212647f, -0.05289400f, -0.04277393f, 0.02980180f, 0.20342016f, 0.10181910f, 0.10162075f, -0.26364270f, 
    -0.07797758f, -0.01317407f, -0.21947102f, -0.06748261f, -0.13507757f, 0.07024300f, -0.07818602f, -0.12754369f, 
    0.21686293f, 0.07863730f, 0.22892661f, -0.00169109f, -0.03711911f, -0.12099123f, -0.22160468f, -0.16803481f, 
    -0.06455690f, 0.01277790f, -0.06277779f, -0.11696552f, -0.11554514f, -0.18042663f, -0.15263999f, 0.06008918f, 
    -0.05185055f, -0.01832318f, 0.06469683f, -0.04824570f, -0.04916836f, -0.01252771f, 0.13354178f, 0.01427308f, 
    0.07664382f, -0.00908780f, -0.04170805f, -0.07418644f, -0.04020737f, -0.03555748f, -0.04716465f, 0.01074800f, 
    -0.00154721f, 0.13077587f, 0.06858671f, -0.03018307f, 0.04726526f, 0.20029551f, -0.00173080f, 0.08303151f, 
    -0.12824506f, 0.04526330f, 0.01063830f, -0.14967304f, -0.13815828f, -0.01035649f, -0.14094926f, 0.06324458f, 
    0.01015086f, 0.12810715f, 0.07949482f, 0.12276446f, -0.12514389f, -0.02188405f, -0.02839305f, 0.14134990f, 
    -0.16687137f, -0.11457342f, -0.02885075f, 0.15258248f, -0.33139163f, -0.27227134f, -0.00299119f, 0.19868533f, 
    -0.00970035f, -0.02947948f, 0.13714135f, 0.07373190f, 0.06737592f, -0.02596787f, 0.04610703f, -0.12024182f, 
    -0.11423184f, 0.00826871f, 0.09490760f, -0.03508599f, -0.08081986f, -0.04756728f, 0.01381531f, -0.02774121f, 
    0.19378915f, -0.14536756f, -0.17329167f, 0.00201267f, 0.07331768f, -0.10457459f, -0.02912956f, 0.07782573f, 
    0.11872385f, 0.22472954f, 0.15981896f, -0.18361004f, 0.10804329f, -0.19482125f, 0.01957311f, -0.07718504f, 
    -0.04686160f, -0.10922055f, -0.10638210f, 0.19094640f, 0.00550128f, -0.03455329f, -0.05404839f, 0.13188511f, 
    0.03422828f, 0.15352274f, 0.03428565f, -0.08451924f, 0.16253649f, -0.12682548f, -0.16924219f, -0.16190819f, 
    -0.03831807f, 0.01305383f, -0.11900413f, -0.11568718f, -0.05946023f, 0.07962672f, -0.09805526f, -0.05576153f, 
    -0.35503265f, -0.15015133f, -0.10572433f, 0.16602309f, 0.09322945f, -0.12681438f, 0.05345931f, -0.06023448f, 
    0.03517858f, 0.08686393f, 0.05387523f, 0.12739491f, -0.14550766f, -0.13261662f, 0.20733346f, -0.28256452f, 
    -0.03882638f, -0.06605054f, 0.08854574f, 0.01305483f, -0.06506445f, 0.30664983f, 0.05659086f, 0.07520135f, 
    0.06155679f, -0.04577652f, 0.11214253f, 0.02213405f, 0.08266298f, -0.04946455f, 0.02335379f, -0.00917809f, 
    -0.03957529f, -0.08977908f, 0.04114506f, -0.00385673f, 0.18345752f, -0.03825971f, 0.06284904f, -0.02785108f, 
    -0.13659997f, -0.07434411f, 0.10403360f, 0.10977945f, 0.00313266f, 0.06785109f, 0.08241602f, 0.13463658f, 
    -0.15335451f, -0.03993570f, -0.37790880f, -0.03382132f, 0.03372646f, 0.16431679f, -0.00820965f, 0.03666494f, 
    -0.03349552f, -0.04123849f, 0.08406831f, -0.11631038f, -0.12431031f, -0.26462674f, -0.03440689f, -0.01146846f, 
    0.13749722f, 0.05250303f, 0.05953252f, -0.21785089f, -0.01820144f, -0.08054775f, -0.06045170f, 0.07263002f, 
    -0.00316518f, -0.03896486f, 0.18500417f, 0.10379840f, 0.05026815f, 0.00765532f, 0.01930579f, -0.02740746f, 
    0.10349356f, -0.01910632f, 0.10322518f, -0.05711588f, -0.45094392f, 0.11469006f, 0.03519928f, -0.21878064f, 
    -0.02343106f, -0.10594767f, -0.01256958f, -0.26733297f, 0.03893469f, 0.07807755f, -0.10981143f, 0.06985479f, 
    0.03633566f, 0.12742932f, 0.06869456f, -0.08297487f, -0.03435869f, 0.00067792f, -0.01514545f, 0.00573756f, 
    -0.05794448f, 0.12921882f, -0.08718336f, 0.08340757f, -0.19598410f, 0.03541917f, -0.09758310f, 0.03178230f, 
    0.02430556f, 0.05017851f, -0.01848216f, -0.02850644f, 0.04311431f, -0.08012812f, 0.07580147f, -0.08366558f, 
    -0.09711824f, -0.21423140f, -0.15387158f, 0.01803339f, 0.06999766f, 0.00813659f, 0.14068449f, 0.02551716f, 
    0.14300612f, 0.08508436f, -0.09496996f, -0.01024724f, 0.11207254f, 0.05115999f, 0.07937118f, 0.22413981f, 
    0.03302525f, -0.05753153f, 0.04318738f, 0.03296260f, -0.18734974f, -0.06141730f, 0.02920851f, -0.07103371f, 
    0.06116656f, 0.02094533f, 0.10409652f, 0.04272924f, -0.00371033f, 0.11217333f, -0.00825276f, -0.09017400f, 
    -0.12475047f, 0.09278586f, 0.00754786f, 0.11484569f, -0.07218241f, -0.08627415f, 0.02087877f, -0.04505670f, 
    0.00093867f, 0.10817928f, -0.01684087f, 0.03724045f, 0.05061943f, -0.00352179f, 0.05599769f, 0.05355634f, 
    -0.03601809f, 0.03011201f, 0.19434473f, -0.16728123f, 0.08607531f, 0.04483564f, 0.01926672f, -0.04658049f, 
    -0.12599948f, 0.08422653f, 0.07602917f, 0.08497877f, -0.22964194f, 0.00164623f, -0.08794922f, -0.14795610f, 
    0.06597884f, -0.00540627f, -0.20962398f, -0.20026095f, 0.07843631f, -0.08169293f, 0.04168930f, -0.00273755f, 
    -0.05425697f, -0.04005601f, 0.10642775f, -0.09372181f, -0.03420759f, -0.08056726f, 0.03593997f, 0.10971069f, 
    0.08715829f, 0.00045406f, -0.00940262f, -0.00865721f, -0.05440746f, -0.03170775f, 0.23922379f, 0.34920999f, 
    -0.15669659f, -0.18496686f, 0.01003835f, 0.09944841f, 0.09227265f, -0.09232108f, -0.04947180f, 0.12793307f, 
    -0.07391370f, 0.17568277f, -0.12482364f, -0.23484907f, -0.05002344f, 0.10593028f, 0.04643890f, -0.06308600f, 
    0.11837186f, -0.13036035f, -0.18375608f, -0.06788261f, -0.13333619f, 0.01909365f, 0.06728087f, 0.23908740f, 
    -0.01959962f, -0.01976871f, 0.09241942f, -0.06838393f, -0.07282907f, -0.00155024f, -0.02284607f, 0.01731865f, 
    0.14511183f, -0.28798407f, 0.17560945f, 0.02630868f, -0.05230442f, 0.03879045f, 0.08313332f, 0.01155238f, 
    -0.00011016f, -0.04903331f, -0.11243378f, -0.08499464f, 0.04929361f, 0.01923699f, 0.01776008f, 0.13833548f, 
    -0.04004904f, 0.00599562f, 0.01417253f, 0.04347229f, -0.11659130f, -0.05625232f, -0.03471418f, -0.04568088f, 
    0.05883200f, 0.05208139f, 0.15704276f, -0.20869036f, 0.07532905f, 0.03403264f, 0.19195181f, 0.01363072f, 
    -0.00542348f, -0.03976138f, -0.10521103f, 0.10463801f, -0.28899336f, 0.20170651f, 0.11516172f, 0.21175413f, 
    0.01329739f, -0.08899396f, -0.03949567f, 0.06876860f, 0.03172519f, -0.04982428f, -0.18473950f, -0.02462320f, 
    0.33892876f, -0.47825322f, 0.09786400f, 0.02762404f, -0.00299742f, 0.04441316f, 0.07410971f, -0.02537951f, 
    0.08192199f, 0.04607303f, 0.02806015f, 0.12479816f, -0.16492812f, -0.10777301f, -0.10507571f, 0.24528374f, 
    0.08317352f, 0.06313951f, 0.05075575f, -0.07328489f, -0.01291994f, -0.13527422f, -0.26088062f, -0.08247775f, 
    0.11566707f, 0.05955629f, 0.02611003f, 0.31502160f, 0.11485524f, -0.01269899f, 0.02653058f, 0.10400657f, 
    0.16674224f, -0.03407869f, -0.16882153f, -0.08235910f, -0.19913204f, 0.11328228f, 0.04065966f, -0.20824733f, 
    -0.05307774f, -0.04421023f, 0.07990830f, -0.01689094f, 0.00284359f, -0.14829126f, 0.07102552f, -0.16121151f, 
    0.18204655f, 0.16133599f, 0.12371911f, -0.02804591f, 0.01392994f, -0.04474209f, -0.07113830f, 0.03793117f, 
    -0.11078463f, 0.04167903f, 0.10949820f, 0.10987036f, 0.10411025f, 0.02569315f, 0.11413164f, 0.00398894f, 
    -0.03238558f, -0.07056143f, 0.00561325f, -0.04974006f, -0.02960741f, -0.13398328f, 0.08439635f, 0.02569075f, 
    0.09302319f, 0.00523474f, 0.14180456f, -0.08083763f, -0.03225981f, 0.02186243f, 0.03567649f, -0.08836599f, 
    -0.17611058f, -0.05978868f, 0.06319673f, -0.00837731f, 0.15702531f, -0.04730327f, -0.14814040f, -0.02434072f, 
    -0.02511993f, -0.04019590f, 0.13561739f, 0.05320936f, 0.11140031f, -0.01917252f, -0.12384849f, -0.00575325f, 
    -0.17467484f, -0.10920076f, -0.13719398f, 0.02716042f, 0.01176424f, -0.01720665f, 0.05352622f, -0.01570294f, 
    0.13494654f, -0.06256296f, 0.04699687f, -0.00128877f, -0.00703468f, -0.05657262f, 0.11823541f, 0.19359493f, 
    0.05119582f, 0.03554585f, 0.08388304f, -0.05183584f, 0.05734359f, -0.07542591f, 0.02520919f, 0.00894915f, 
    -0.01537432f, 0.02280707f, 0.16756725f, 0.12460044f, 0.07629178f, -0.01897200f, -0.00571116f, 0.06622852f, 
    0.09957026f, -0.02611644f, -0.03785487f, 0.01072347f, -0.03385403f, -0.07964629f, -0.12655331f, 0.18168564f, 
    -0.13877578f, -0.03993919f, 0.00359806f, 0.10798798f, 0.01446526f, 0.03025988f, -0.08516923f, -0.00154101f, 
    0.03920500f, -0.01986577f, -0.07789242f, -0.20283860f, -0.04189714f, -0.07318097f, 0.00251541f, -0.11888555f, 
    0.04198292f, 0.15190987f, -0.08329996f, 0.06304958f, 0.04784692f, -0.07059041f, 0.06406313f, -0.00093248f, 
    0.04282577f, -0.08158288f, 0.09485196f, 0.03046121f, -0.09946094f, 0.14311230f, -0.02156276f, -0.13269936f, 
    0.27980855f, 0.04688502f, 0.09179671f, -0.17896429f, 0.14787699f, 0.05084842f, 0.06463578f, 0.02139155f, 
    0.00479678f, -0.07738413f, 0.09594627f, -0.04944057f, -0.05138120f, -0.03819503f, -0.30185336f, -0.21190847f, 
    -0.09860199f, -0.02500660f, 0.05441284f, -0.17232889f, -0.00798908f, -0.01089364f, -0.09083110f, -0.05198348f, 
    -0.32382414f, 0.20937271f, -0.19494282f, 0.33884394f, -0.11965449f, -0.02474733f, 0.08664092f, -0.00372311f, 
    -0.00114661f, 0.08446298f, -0.00723395f, -0.10326446f, 0.25398868f, 0.10443657f, -0.04654071f, -0.24750908f, 
    -0.03887344f, -0.01677614f, -0.04581047f, 0.06902118f, 0.01282485f, 0.04676613f, -0.07994415f, 0.07396314f, 
    0.06965239f, -0.01652716f, 0.06780493f, -0.00771694f, -0.06663159f, -0.04448876f, 0.09140463f, 0.11506461f, 
    0.15749966f, 0.04607977f, -0.07084722f, -0.06050039f, 0.02502201f, -0.04563500f, -0.14958863f, -0.00000802f, 
    0.02435034f, 0.02708052f, 0.01871870f, -0.10874141f, -0.11190485f, 0.04414292f, 0.14518768f, 0.09948295f, 
    0.36785269f, -0.24722716f, 0.26891401f, -0.34734392f, 0.01081890f, -0.01036067f, 0.07494907f, -0.15359987f, 
    0.00772295f, -0.08505892f, 0.12302784f, 0.04519251f, 0.07302282f, -0.12204019f, 0.02156180f, -0.36765698f, 
    0.04319048f, 0.01461195f, 0.02262236f, 0.01782238f, -0.03704958f, 0.00111975f, -0.01752458f, -0.11076196f, 
    -0.28272271f, -0.04918864f, -0.07026149f, 0.01457573f, 0.01685192f, 0.06327529f, 0.06016354f, 0.04091191f, 
    0.02769520f, -0.04355395f, 0.13405448f, 0.02825614f, 0.08303224f, 0.10435773f, 0.06302210f, -0.29672584f, 
    -0.00483520f, 0.16082722f, 0.02206585f, 0.08351091f, -0.15092851f, -0.07569313f, 0.05018702f, -0.02689218f, 
    -0.40685228f, 0.06523295f, -0.09152667f, -0.22851014f, -0.03777439f, -0.03382953f, 0.10512687f, -0.03694392f, 
    0.02578160f, -0.08489601f, 0.04847517f, -0.07708640f, -0.15511139f, 0.22026099f, 0.09110816f, -0.14355733f, 
    0.03206116f, 0.03684982f, 0.05756101f, 0.06878653f, 0.03644047f, 0.01168448f, -0.14562488f, 0.05748931f, 
    0.06283875f, -0.12561889f, -0.15394366f, -0.17126897f, -0.11738106f, -0.11310808f, -0.08874638f, -0.12388521f, 
    -0.02589618f, 0.01372947f, 0.05340119f, 0.04058304f, 0.00509260f, -0.06462076f, 0.15983677f, -0.16076964f, 
    0.02183476f, 0.00049767f, 0.02094522f, 0.00609802f, -0.02872263f, -0.00887108f, 0.02687952f, -0.10992972f, 
    -0.06106282f, -0.30967221f, -0.16881166f, 0.01472984f, -0.02393658f, -0.06813843f, -0.02666072f, -0.00657280f, 
    -0.15259644f, 0.07294626f, -0.03938391f, 0.10238746f, -0.51194483f, 0.14427039f, 0.01122138f, -0.07722468f, 
    0.01428147f, 0.05544014f, 0.12492362f, -0.03019132f, -0.06584375f, -0.02812417f, -0.03117224f, 0.08243825f, 
    -0.35412636f, -0.11623733f, -0.07520640f, 0.05155179f, -0.14853980f, 0.15104239f, 0.20021816f, 0.11012595f, 
    0.11395410f, 0.03341626f, -0.06743912f, 0.04603362f, 0.17786960f, -0.25717136f, -0.14521560f, 0.14214256f, 
    0.03738836f, 0.11803547f, 0.01373500f, -0.01421546f, -0.05280802f, 0.03369005f, -0.02176045f, 0.06988057f, 
    -0.01338649f, -0.10665831f, 0.12883893f, -0.36196622f, 0.07450152f, 0.11240260f, 0.17494224f, -0.00828550f, 
    -0.05297552f, 0.03085375f, -0.12210159f, 0.02666395f, -0.00760476f, -0.15401435f, -0.05772301f, 0.19036670f, 
    -0.04151037f, 0.11999611f, -0.07028415f, -0.02105149f, 0.07042605f, 0.00507839f, 0.07494964f, 0.05334612f, 
    -0.05161322f, -0.16000858f, 0.04476361f, -0.05859922f, 0.12838252f, 0.03437974f, 0.00632338f, 0.06223422f, 
    0.02818877f, 0.09228881f, -0.11311874f, -0.05604665f, 0.29359958f, 0.01823617f, 0.02262277f, 0.06513175f, 
    -0.12759016f, 0.05974812f, -0.07668287f, 0.05109337f, -0.17941087f, 0.09496975f, -0.05242182f, 0.02758221f, 
    -0.21416339f, 0.10807721f, 0.10365440f, -0.17827566f, -0.02937352f, -0.16075675f, -0.01157787f, 0.10287962f, 
    -0.06992472f, 0.07430258f, 0.09893627f, 0.05089523f, -0.23242633f, 0.09745733f, 0.02436848f, 0.11601203f, 
    -0.05923197f, -0.13911353f, 0.00670149f, 0.10194905f, -0.00522783f, 0.19152382f, -0.00334775f, 0.02383525f, 
    0.06051505f, -0.13088244f, -0.03057408f, -0.01951594f, 0.22603658f, -0.14571603f, 0.07717117f, -0.13030535f, 
    -0.05757941f, -0.08344218f, -0.10435249f, 0.05658706f, -0.07404337f, 0.02143279f, -0.08040214f, 0.13683848f, 
    -0.00483435f, 0.01719990f, -0.00235740f, 0.00154840f, 0.08157675f, -0.03001290f, 0.07124214f, 0.02630980f, 
    -0.00939216f, 0.01985317f, -0.00532573f, 0.01131030f, -0.08688215f, -0.05106298f, -0.02080641f, 0.00667258f, 
    -0.14960164f, -0.04793772f, -0.03569818f, -0.00910555f, 0.27107245f, -0.02930834f, -0.15677372f, -0.07062582f, 
    0.03990637f, 0.10359197f, -0.06905387f, -0.11414082f, 0.06590886f, -0.12721448f, -0.10093109f, -0.15024406f, 
    -0.03891667f, 0.16336285f, 0.07293113f, -0.08167223f, -0.12533715f, 0.00020549f, 0.05036538f, -0.04833353f, 
    0.02412425f, 0.14184147f, 0.04752829f, 0.03964644f, 0.08086282f, 0.13434272f, 0.19812118f, -0.14478521f, 
    0.00719574f, -0.02629283f, 0.01583227f, -0.00671838f, -0.10556296f, -0.11361157f, -0.05220914f, -0.15872130f, 
    0.01661730f, -0.15275452f, -0.12331090f, -0.05969439f, -0.00700516f, 0.03502621f, 0.02788032f, -0.18620098f, 
    0.02993885f, -0.01278823f, 0.03196724f, 0.19336703f, 0.08065390f, 0.04161590f, -0.20858982f, 0.24036632f, 
    -0.17236835f, -0.01174184f, -0.09883368f, -0.04103781f, -0.16783167f, 0.03579849f, -0.01191592f, 0.02440003f, 
    0.36689594f, -0.04668902f, 0.07093948f, -0.24956493f, -0.01709360f, 0.01649182f, -0.02989283f, 0.10147220f, 
    -0.03023161f, 0.17296107f, 0.00776788f, 0.14201812f, -0.41651568f, -0.26696375f, -0.01448776f, 0.16922165f, 
    0.06500452f, 0.00245983f, -0.00373690f, 0.14465021f, -0.00098997f, -0.02643619f, 0.10790430f, 0.01347412f, 
    -0.03842469f, 0.15481627f, 0.19396578f, -0.00535011f, -0.03961375f, 0.02418861f, 0.00128957f, -0.01648629f, 
    -0.00044365f, -0.06340256f, 0.21633217f, -0.14494126f, 0.05518207f, -0.24254119f, -0.10825572f, -0.22198959f, 
    -0.06621077f, 0.03589726f, 0.01955568f, -0.06977411f, -0.08048013f, 0.04591877f, -0.03464101f, 0.06227558f, 
    -0.06713925f, 0.07187343f, -0.25219765f, -0.03244259f, -0.02231368f, -0.05973621f, -0.11361667f, -0.11167064f, 
    0.01234100f, 0.01627288f, -0.02709928f, -0.09620979f, 0.04025809f, 0.00076408f, -0.09038786f, -0.28215143f, 
    0.11885557f, -0.10943803f, 0.01783740f, -0.03635077f, -0.00941030f, 0.10917531f, -0.01460125f, -0.07605466f, 
    0.02839457f, 0.18456577f, 0.14001752f, -0.36802217f, -0.05890010f, -0.06464503f, -0.04691326f, 0.10109960f, 
    0.04700510f, -0.03461280f, 0.03992940f, -0.00849744f, 0.09051901f, 0.12370066f, -0.12368643f, -0.22062011f, 
    -0.04130791f, -0.03317152f, 0.02815387f, 0.00318242f, -0.08680486f, -0.03317529f, -0.04130949f, 0.08618924f, 
    -0.03634967f, 0.25205842f, 0.16994062f, -0.05501732f, -0.00799054f, 0.04327458f, -0.04596987f, 0.05438459f, 
    0.00576514f, -0.00834421f, -0.08296975f, -0.14089917f, -0.18552276f, -0.36969897f, -0.13365893f, -0.05001887f, 
    0.00813914f, 0.09579618f, -0.05268851f, 0.12500738f, 0.01356083f, 0.04620834f, -0.08790670f, 0.17236862f, 
    -0.20142882f, 0.22745052f, 0.03929408f, -0.04086975f, 0.09457667f, 0.07127060f, 0.04942177f, -0.04347028f, 
    -0.16170736f, 0.12451457f, 0.11665700f, -0.02222361f, -0.10195874f, 0.06151633f, -0.17119129f, -0.12515821f, 
    0.06627668f, 0.01704375f, -0.07502381f, -0.02119769f, -0.20132005f, 0.01960453f, 0.00336993f, -0.17737319f, 
    0.07153969f, -0.30535969f, 0.11175869f, -0.11601296f, -0.00750491f, -0.00282299f, 0.02308917f, -0.00298794f, 
    -0.01405466f, -0.06563369f, 0.13100900f, 0.12719108f, 0.03280209f, 0.06848776f, -0.08928484f, 0.12664075f, 
    -0.04105246f, 0.02635929f, -0.08469109f, 0.07142214f, 0.10914715f, 0.00041386f, -0.01651167f, -0.12346320f, 
    -0.07096544f, 0.01846307f, -0.08763614f, -0.16676450f, 0.06678853f, -0.02803860f, -0.00610361f, -0.08243567f, 
    0.00081161f, -0.06816779f, -0.02717644f, 0.02565407f, -0.07120779f, -0.08029007f, -0.00494968f, -0.06124351f, 
    0.04363813f, -0.02115103f, -0.02040857f, 0.05509834f, -0.04226393f, 0.02409645f, -0.03245623f, -0.00309409f, 
    0.13005283f, 0.07265635f, -0.05692495f, -0.03306860f, -0.09325496f, -0.02220159f, -0.04299983f, -0.05430137f, 
    0.01118172f, -0.03611724f, -0.03382714f, 0.00599484f, -0.11457299f, -0.02471298f, -0.15035887f, -0.18489595f, 
    -0.01753136f, 0.00006214f, 0.03461943f, 0.02411484f, -0.02456328f, 0.01004942f, -0.09720326f, -0.06373222f, 
    0.21038124f, -0.16710047f, 0.09194008f, -0.18291633f, 0.00862155f, 0.03389052f, -0.03558056f, 0.05887692f, 
    -0.04393572f, 0.05284124f, -0.08792450f, 0.00138750f, -0.00376094f, -0.02820828f, -0.03147561f, 0.13627453f, 
    -0.08906444f, -0.00768402f, -0.05617315f, -0.04473833f, -0.04893753f, -0.03462499f, -0.02821526f, -0.14613728f, 
    -0.26452518f, 0.09526737f, -0.08756254f, 0.08094610f, -0.09089626f, -0.01726360f, 0.01980763f, 0.04036573f, 
    0.03329252f, 0.03972795f, -0.01662794f, -0.03872093f, 0.09692662f, 0.07310580f, 0.13065717f, -0.02886854f, 
    -0.01210884f, 0.05204101f, -0.06611092f, -0.01674067f, -0.04351337f, -0.05825336f, -0.02324726f, -0.02781986f, 
    -0.12328899f, 0.06787639f, -0.07462877f, -0.15084846f, -0.06350878f, 0.00591407f, -0.11265756f, -0.06826945f, 
    -0.04887303f, -0.03403277f, 0.00052480f, -0.02854359f, -0.09324388f, 0.07002099f, -0.10250932f, 0.02846370f, 
    -0.01781398f, 0.08704808f, -0.00201397f, 0.05803685f, -0.01973502f, -0.04985990f, -0.06114214f, 0.02527936f, 
    -0.08627471f, 0.08682830f, -0.13383591f, -0.10167906f, 0.01075806f, -0.03406081f, -0.03660045f, -0.04427750f, 
    0.07953040f, -0.04058204f, 0.03572091f, -0.06610222f, -0.23513645f, 0.07463028f, -0.00619277f, 0.05937128f, 
    -0.04877597f, -0.11015649f, -0.06902685f, -0.14252597f, -0.03585774f, 0.10572497f, -0.00278170f, -0.01105387f, 
    0.07836591f, 0.13456012f, 0.20942666f, 0.03831247f, 0.07696490f, 0.08062462f, 0.05327490f, -0.01840504f, 
    -0.01482463f, 0.01763642f, -0.09081754f, 0.04886541f, 0.04083067f, 0.20868689f, -0.04925832f, 0.02391023f, 
    -0.03474255f, 0.01570728f, -0.00839826f, 0.03669278f, -0.02300666f, 0.14696434f, -0.04617512f, -0.09323597f, 
    0.02391126f, 0.03037155f, -0.01499437f, -0.01334394f, -0.14654177f, 0.02784664f, 0.03712257f, 0.00899418f, 
    -0.04220280f, 0.01459406f, 0.01972817f, 0.03800940f, -0.03955960f, -0.02935638f, -0.04936533f, -0.05363043f, 
    -0.05457181f, -0.03308713f, -0.03872861f, -0.09891327f, 0.05849660f, -0.07465453f, -0.06014539f, -0.04134093f, 
    0.07470995f, 0.13823147f, 0.05658982f, 0.11948431f, 0.10050090f, 0.01261285f, 0.05421403f, 0.01131374f, 
    -0.04796854f, -0.01610531f, 0.02303742f, 0.01075660f, 0.01947818f, -0.15710334f, 0.02340913f, 0.02629853f, 
    0.03540694f, -0.05804795f, 0.02855053f, 0.04603137f, -0.08068332f, -0.04486714f, -0.03959691f, -0.04918005f, 
    0.07157163f, -0.28800565f, 0.00708528f, -0.06238996f, -0.02503580f, -0.04458418f, -0.01809124f, -0.06183516f, 
    0.03521597f, -0.01300038f, 0.00197899f, -0.03281257f, 0.06137326f, 0.13615906f, 0.07944928f, 0.18206358f, 
    0.09535211f, 0.01739269f, 0.04953275f, -0.04058405f, -0.04607454f, 0.05852128f, -0.00879556f, 0.01249941f, 
    -0.00931569f, -0.19634998f, -0.07703826f, -0.12087978f, 0.04634511f, -0.14603694f, 0.03601946f, -0.00844236f, 
    0.05210469f, -0.03165393f, -0.06147058f, -0.01924337f, 0.25131381f, 0.06166147f, 0.15032203f, -0.14430499f, 
    -0.13861190f, -0.07118572f, 0.06956466f, 0.02862107f, 0.02780132f, -0.02234987f, -0.08374965f, -0.06822635f, 
    0.21024455f, -0.19148807f, 0.13957900f, -0.00435149f, -0.01146685f, -0.06619991f, -0.00150132f, -0.05539185f, 
    0.00682251f, 0.10722227f, -0.03629350f, -0.05320093f, -0.03144941f, 0.09550337f, 0.04852519f, 0.17874336f, 
    -0.03755555f, -0.04353473f, -0.03211355f, -0.04645761f, -0.04682610f, -0.07451195f, -0.02353883f, -0.06512062f, 
    0.13862954f, 0.02066130f, 0.15421151f, 0.02271159f, 0.04120518f, -0.02805914f, -0.04980898f, 0.05546827f, 
    -0.00619023f, 0.09600618f, -0.01491027f, 0.07025538f, -0.23875614f, 0.07439815f, -0.15246250f, -0.03694507f, 
    -0.03923371f, -0.01551137f, 0.02489684f, -0.10718428f, -0.05218188f, 0.06496321f, -0.03926931f, -0.08478801f, 
    -0.03373065f, 0.18448237f, -0.03135104f, 0.14443935f, -0.01660830f, -0.01131556f, -0.01756656f, -0.00784971f, 
    0.03673611f, -0.03400556f, -0.05891814f, -0.17058235f, 0.02226622f, -0.18295400f, -0.02978692f, 0.09643563f, 
    -0.06103388f, -0.03176462f, 0.03325699f, 0.06624220f, -0.04313710f, 0.03934670f, 0.06740285f, -0.06936389f, 
    0.11309233f, 0.13497671f, 0.12960924f, 0.02499168f, -0.08362671f, 0.02441107f, -0.03242514f, -0.04058319f, 
    0.03473420f, 0.04867873f, -0.02027315f, 0.01255409f, -0.10312396f, -0.01492498f, -0.05350654f, 0.08004995f, 
    0.00865253f, -0.06754686f, 0.01512166f, -0.04013731f, -0.03732713f, 0.01601275f, 0.01345591f, -0.00186731f, 
    0.07231674f, 0.14013770f, 0.10381284f, 0.15789621f, 0.12174127f, 0.08274013f, -0.01140997f, 0.04952284f, 
    -0.00948639f, -0.07337123f, -0.00719707f, -0.02373440f, 0.09783924f, -0.20429963f, -0.04599969f, -0.06256028f, 
    -0.00588007f, 0.03990860f, -0.00670604f, 0.00171279f, -0.02914481f, 0.01212179f, 0.02499196f, -0.00686279f, 
    -0.11913805f, 0.09468120f, 0.05406183f, 0.05588057f, 0.10363388f, -0.02622345f, 0.08874094f, 0.00594545f, 
    0.01847156f, -0.02714678f, 0.05490515f, -0.09045254f, 0.21136855f, 0.11233401f, 0.02151935f, -0.05255651f, 
    -0.01039802f, -0.01561754f, -0.06227687f, -0.03816415f, 0.01443447f, 0.07358278f, -0.02343885f, -0.02535958f, 
    0.23896827f, 0.08682259f, -0.12032063f, 0.01406618f, 0.01746754f, 0.00579522f, -0.05219359f, 0.01716676f, 
    -0.02216440f, -0.00680601f, -0.02688475f, 0.01071772f, 0.20226057f, -0.21398644f, 0.10500842f, 0.04266535f, 
    0.07968192f, -0.02126856f, -0.02895047f, -0.06823584f, -0.06296279f, -0.01210897f, -0.08332457f, -0.06159222f, 
    0.27834278f, -0.01733893f, -0.02528647f, -0.03816747f, 0.01548022f, 0.03777514f, -0.04346680f, -0.05422740f, 
    -0.01863123f, -0.01041475f, 0.09722221f, -0.17900877f, -0.00877704f, 0.01028462f, -0.03072565f, -0.08641291f, 
    -0.04816608f, -0.02655772f, -0.02005925f, -0.04432293f, 0.01360502f, -0.03994651f, -0.05753102f, -0.04193361f, 
    0.12991615f, -0.29373258f, 0.07028965f, 0.06714810f, 0.01301713f, -0.06353652f, -0.02108831f, -0.01514357f, 
    -0.02346385f, -0.02775500f, 0.01569759f, -0.04219022f, 0.09528942f, 0.08650371f, 0.04055609f, 0.13599707f, 
    0.10792829f, 0.02700485f, 0.04272980f, 0.05367053f, -0.04467124f, 0.01510231f, -0.00478617f, 0.01764641f, 
    -0.22516371f, 0.05221375f, -0.04499945f, -0.09075183f, -0.08900768f, -0.00725885f, -0.02475231f, -0.09651448f, 
    -0.00534609f, -0.04374404f, -0.09516237f, -0.03969048f, 0.12285666f, 0.02197094f, -0.05131430f, 0.04981041f, 
    -0.02043928f, -0.05553044f, -0.07470699f, 0.02312532f, -0.03394060f, 0.00256478f, -0.01318118f, -0.03029467f, 
    0.25065023f, -0.00823017f, 0.11049835f, 0.03192612f, 0.15527335f, -0.00121389f, 0.02631333f, -0.10655174f, 
    -0.11034350f, -0.14524499f, -0.01184934f, 0.01811882f, 0.04772536f, 0.08910510f, -0.20541194f, 0.02889117f, 
    -0.10931434f, 0.00734361f, 0.05562498f, 0.04184492f, -0.03106297f, 0.03957976f, 0.01251252f, -0.00263887f, 
    0.16723679f, 0.07295806f, 0.00999963f, 0.17252788f, 0.12374535f, -0.06664547f, 0.01334462f, -0.07507202f, 
    -0.02171998f, -0.05374679f, -0.10000527f, -0.05850698f, -0.23613109f, 0.10499022f, 0.08007263f, -0.13357374f, 
    -0.12751545f, 0.00056816f, 0.04453592f, -0.05469739f, -0.07335983f, -0.01882111f, -0.03441716f, -0.11144186f, 
    -0.10010670f, 0.04058231f, -0.07595076f, -0.23718551f, 0.01860854f, 0.00210541f, -0.01347603f, -0.07401511f, 
    -0.00991081f, -0.02575777f, -0.03625831f, -0.02365116f, 0.13544306f, -0.35287839f, 0.01823032f, 0.04161406f, 
    -0.04925080f, -0.01690660f, -0.03545577f, -0.02307215f, -0.05123136f, -0.00496145f, -0.02221315f, -0.02073947f, 
    0.16798149f, 0.09844974f, 0.19507985f, 0.05209454f, 0.04742522f, 0.09315258f, 0.05559151f, -0.03945410f, 
    -0.00390856f, 0.00477945f, -0.08719775f, -0.07420363f, -0.04352197f, 0.24192291f, 0.10654999f, 0.20767058f, 
    0.09951203f, -0.03518703f, 0.10539714f, 0.06432818f, 0.05039234f, -0.01652636f, 0.11433986f, 0.02997769f, 
    -0.02990448f, -0.06544552f, -0.18955335f, -0.09599338f, -0.02999555f, -0.07749832f, -0.03987325f, -0.10447809f, 
    0.00201181f, -0.03161759f, -0.11970513f, -0.09410422f, -0.16157688f, -0.04181008f, 0.09366634f, -0.03847770f, 
    0.01073267f, -0.04694648f, -0.00257387f, -0.01543487f, 0.02641427f, 0.00121131f, -0.02805201f, -0.06461436f, 
    -0.12795152f, 0.15310286f, 0.00871264f, -0.11502179f, -0.01303360f, -0.06604861f, -0.03173764f, 0.02023778f, 
    -0.06664544f, -0.01831686f, 0.08029856f, -0.03062107f, -0.00918914f, 0.05666345f, 0.05288385f, 0.04539678f, 
    -0.00007192f, 0.00919161f, 0.01908067f, -0.00117772f, -0.07768230f, 0.03224458f, -0.04223120f, -0.07143874f, 
    -0.03227451f, 0.18654388f, 0.09337230f, 0.14345221f, -0.00683316f, 0.06601260f, -0.03732888f, 0.02465103f, 
    0.00508558f, 0.04141317f, -0.01591531f, -0.01469897f, 0.19405888f, -0.10876065f, 0.07128422f, 0.03349326f, 
    -0.01967171f, -0.02936700f, -0.07227231f, -0.10231396f, -0.02447526f, 0.08878822f, -0.04927689f, -0.10503939f, 
    -0.22471303f, 0.02478442f, -0.04187242f, 0.13914348f, -0.06252111f, 0.00670448f, 0.03281101f, -0.03857599f, 
    -0.06876301f, -0.00406704f, 0.04965878f, -0.02828629f, -0.04054141f, -0.05493800f, 0.06697682f, -0.00467612f, 
    -0.10076335f, -0.03535781f, -0.02482299f, -0.01423238f, -0.09789819f, 0.04058799f, -0.07604615f, 0.00375807f, 
    -0.15501328f, 0.03487056f, -0.08594263f, -0.13231114f, 0.05281586f, 0.00599736f, -0.03604918f, -0.04052942f, 
    -0.04445017f, -0.01555551f, -0.03358617f, 0.01069391f, -0.08863838f, 0.02471528f, 0.04399832f, 0.02399029f, 
    0.00731083f, 0.02557856f, 0.07527369f, -0.02214235f, -0.07828063f, -0.05015110f, -0.02583859f, -0.00979727f, 
    -0.12084739f, -0.01573066f, -0.05100783f, -0.26897398f, -0.01907882f, 0.00922907f, -0.04133401f, -0.05050270f, 
    -0.02489818f, -0.03726144f, 0.06721455f, -0.08750174f, -0.17221989f, 0.02051067f, 0.00661448f, 0.07251000f, 
    0.04278335f, -0.08859010f, -0.15279227f, -0.05004968f, -0.09177331f, 0.00238909f, -0.00619172f, -0.03886810f, 
    -0.06525704f, 0.00654824f, 0.08292001f, -0.05856794f, -0.11207674f, -0.02387690f, -0.02612018f, -0.00899696f, 
    -0.04169805f, 0.00076615f, -0.01926342f, -0.02432032f, -0.18595810f, -0.16734132f, 0.03476364f, -0.06599976f, 
    -0.02096733f, -0.01988921f, 0.01164379f, -0.04703174f, -0.07945789f, -0.00562555f, 0.01649922f, 0.05603295f, 
    0.15508223f, -0.08066665f, 0.08788576f, 0.11173315f, -0.02103460f, -0.06726406f, -0.07833380f, -0.01833469f, 
    0.00916980f, -0.01832413f, 0.07072360f, -0.08688487f, 0.14202487f, 0.01454558f, -0.07325231f, 0.11127391f, 
    0.07395766f, 0.02172348f, -0.01318171f, -0.01486518f, 0.02840339f, -0.06724213f, -0.14988029f, -0.03048193f, 
    -0.06695548f, -0.19364923f, 0.11927243f, -0.02140398f, 0.06427406f, -0.17325445f, -0.09538788f, 0.07711531f, 
    0.07991734f, -0.14715821f, -0.00618297f, -0.14844295f, 0.08302509f, -0.02623565f, -0.15419085f, -0.12281316f, 
    0.06577502f, -0.06106527f, -0.01345809f, -0.09190677f, -0.02584844f, -0.05884736f, -0.02200999f, 0.03364505f, 
    0.11043850f, -0.06343163f, 0.07473660f, 0.02339051f, 0.00985787f, -0.01770569f, 0.03521924f, 0.07650264f, 
    0.06586348f, -0.05261850f, 0.02732421f, -0.01302258f, 0.21536426f, 0.10819888f, -0.21283898f, -0.12216523f, 
    -0.01649889f, -0.07903362f, -0.01167589f, -0.05788049f, 0.10398409f, 0.05016490f, 0.06327081f, 0.12384455f, 
    0.10416532f, 0.03665755f, -0.14656259f, -0.07468247f, -0.03270704f, -0.00248979f, -0.14293607f, -0.05025989f, 
    -0.03016732f, -0.03727486f, 0.03572758f, 0.04547946f, -0.21360964f, -0.07816834f, 0.20684336f, -0.12706184f, 
    -0.05605752f, 0.01298762f, -0.07650222f, 0.03140450f, 0.00080815f, -0.00281584f, -0.02099471f, 0.11058921f, 
    0.08851484f, -0.01171250f, -0.05211217f, 0.03410004f, 0.11890436f, -0.01073891f, 0.01090092f, -0.07618883f, 
    -0.01515586f, 0.04111356f, -0.01536866f, -0.05272359f, 0.04619264f, 0.07308033f, -0.04623101f, -0.03783591f, 
    -0.00881066f, -0.03033081f, 0.03825838f, -0.08278529f, 0.01833463f, 0.03161392f, 0.06611431f, 0.03309611f, 
    0.13430443f, -0.14902262f, -0.00737292f, 0.13842504f, 0.03688020f, -0.16131766f, -0.00784427f, -0.09920396f, 
    0.09722557f, 0.05816702f, -0.17683063f, -0.03908963f, -0.19447039f, -0.09847686f, -0.17536739f, 0.02891291f, 
    0.00645488f, 0.03356077f, -0.08781432f, 0.12867324f, 0.04666496f, -0.02599333f, 0.00014857f, 0.05489361f, 
    -0.09663211f, 0.05951316f, 0.02246455f, 0.01788815f, 0.02225463f, 0.05961510f, -0.10003082f, -0.06770096f, 
    0.02211292f, -0.01177851f, 0.03509082f, 0.01387430f, -0.10094966f, -0.03825078f, -0.13393517f, -0.12570755f, 
    0.08540659f, -0.01386366f, -0.15860608f, -0.06261987f, 0.11366466f, 0.05153732f, 0.12307293f, 0.05047816f, 
    0.11699084f, -0.10920858f, -0.21252367f, -0.15188818f, 0.11079631f, -0.11481312f, -0.04671231f, 0.01264552f, 
    0.04527087f, 0.04213629f, 0.05033898f, -0.07698549f, 0.16599335f, 0.00053561f, 0.01554153f, 0.09496029f, 
    -0.05816197f, -0.08295488f, -0.05437928f, -0.02584599f, 0.01083792f, 0.01708567f, 0.05329463f, 0.01078344f, 
    -0.24029687f, 0.00646047f, 0.13142377f, -0.20706983f, 0.03695939f, 0.02776431f, 0.07345352f, -0.15587071f, 
    -0.02827313f, 0.01588334f, 0.00545358f, -0.04568891f, 0.05428804f, -0.20901988f, -0.01351985f, 0.00317712f, 
    -0.00879307f, -0.09299411f, 0.03860166f, -0.00132875f, 0.08725502f, -0.01610164f, 0.00877372f, 0.05419073f, 
    -0.09310839f, -0.07421050f, -0.15793419f, 0.07207997f, 0.08689374f, -0.06150718f, 0.01972695f, -0.01691005f, 
    0.04219889f, 0.04958335f, 0.03923346f, 0.08675963f, -0.21701720f, -0.05112625f, 0.11176059f, -0.06466103f, 
    -0.07615212f, 0.07028991f, -0.11292834f, -0.04204654f, 0.03058972f, 0.00574257f, -0.00615861f, -0.00021300f, 
    0.22933047f, 0.30342585f, -0.24205133f, -0.02549329f, 0.05801549f, 0.04855265f, -0.05325237f, -0.07251777f, 
    0.00925728f, 0.04941950f, 0.02272496f, 0.08862048f, -0.12713900f, 0.03161012f, -0.13173446f, -0.10055953f, 
    -0.04281300f, -0.03965126f, -0.07071531f, -0.05566531f, 0.08037049f, -0.01726299f, 0.11623096f, 0.03724499f, 
    -0.15463181f, -0.08502609f, 0.13473430f, -0.05660683f, -0.03268482f, -0.00209576f, 0.02391990f, -0.19708402f, 
    -0.02050718f, 0.01030078f, 0.06539534f, 0.12968062f, -0.13252835f, 0.01386053f, -0.09457634f, -0.13952284f, 
    -0.00085495f, -0.07598584f, -0.00949755f, -0.00911319f, 0.01260014f, 0.06087637f, -0.06071809f, 0.03206833f, 
    0.10377807f, -0.20094189f, 0.21297483f, -0.07024294f, -0.04275593f, -0.14387028f, 0.08883888f, -0.05507636f, 
    -0.12573624f, 0.09246623f, -0.07973680f, -0.04103689f, 0.02825381f, -0.01304687f, 0.12646359f, 0.20239116f, 
    0.04053301f, -0.01110248f, -0.03618776f, -0.07004723f, 0.10808994f, -0.00996956f, 0.10200722f, -0.02503462f, 
    -0.01761801f, 0.07486469f, 0.10395648f, 0.07512052f, -0.05523315f, 0.02785936f, 0.02575490f, 0.01903992f, 
    -0.06430811f, -0.04482694f, -0.03805184f, 0.14421836f, -0.14342412f, -0.23781916f, -0.19431554f, -0.19701432f, 
    0.02128728f, -0.06070099f, 0.01876491f, -0.08686335f, -0.02318959f, 0.09782397f, -0.05215751f, 0.13736761f, 
    -0.15711522f, 0.05714157f, 0.13891636f, -0.07872245f, 0.06243323f, 0.00776211f, -0.01028433f, 0.04550318f, 
    0.05189081f, -0.01191258f, 0.02010171f, -0.03111735f, -0.07074842f, -0.29520503f, 0.01061315f, 0.16519806f, 
    0.04566804f, 0.02627125f, -0.04092275f, -0.10011310f, -0.06431168f, 0.07265887f, 0.12063817f, -0.16493906f, 
    -0.27274320f, -0.05024607f, 0.01602630f, -0.34982112f, -0.01755013f, 0.03903562f, -0.11467011f, -0.11752065f, 
    -0.00505157f, -0.00795879f, -0.03322243f, 0.07873922f, 0.03441753f, -0.14264773f, 0.04447922f, 0.07737545f, 
    0.09871844f, -0.02220630f, -0.00265887f, -0.04645168f, 0.10941834f, -0.09821407f, -0.10499571f, 0.16025105f, 
    0.04279141f, -0.00954548f, 0.13066649f, 0.17375854f, -0.13467862f, 0.02114524f, -0.01656551f, -0.05757662f, 
    0.02659233f, -0.08590347f, 0.07513883f, 0.06583978f, 0.02739122f, 0.04021501f, -0.07398342f, 0.14283198f, 
    -0.00894638f, -0.08706217f, -0.16752280f, -0.03708047f, 0.04250183f, 0.02560558f, 0.03249602f, -0.09266493f, 
    -0.08817216f, 0.19813412f, -0.05583220f, -0.04537738f, -0.16330023f, -0.12498404f, -0.03159067f, 0.02506412f, 
    -0.01328821f, 0.01560456f, 0.00361694f, 0.00611219f, 0.05215065f, -0.09311882f, 0.04004079f, -0.08077711f, 
    0.00712801f, 0.04426420f, 0.08314466f, -0.08598012f, -0.01452884f, -0.00697367f, 0.02188776f, -0.05417044f, 
    -0.08697180f, -0.12410691f, 0.06596304f, -0.01835746f, 0.03344237f, -0.03471152f, 0.04376759f, 0.03156019f, 
    -0.08524670f, 0.09337916f, 0.04557095f, 0.13925734f, 0.13009568f, 0.11225277f, 0.01384087f, 0.03364205f, 
    -0.08035513f, 0.04634935f, -0.03044026f, -0.08187570f, -0.02767241f, -0.03507770f, -0.09372321f, -0.02834545f, 
    0.20577414f, -0.10941563f, -0.12007900f, -0.27805763f, 0.07043768f, -0.04742206f, 0.00474119f, -0.05962981f, 
    0.06688228f, 0.02369808f, 0.04436440f, 0.06604182f, 0.00627238f, -0.04362649f, -0.06638772f, 0.04246633f, 
    0.04942025f, 0.00018191f, 0.02417910f, 0.05619488f, 0.07771327f, -0.03024150f, -0.01983336f, -0.13534679f, 
    0.14395505f, -0.01982723f, 0.06811447f, 0.25023818f, 0.13686271f, 0.01088781f, -0.07287742f, -0.03037465f, 
    0.05077557f, -0.04868571f, 0.00369980f, -0.12976655f, -0.09090585f, 0.00473431f, -0.13707519f, -0.09285234f, 
    -0.00189517f, -0.05707291f, 0.02776079f, -0.00584563f, 0.06155564f, -0.05277565f, -0.11620083f, 0.11502651f, 
    0.11548368f, -0.04258617f, -0.20728680f, -0.18673089f, -0.06626582f, 0.00245581f, -0.02622475f, -0.01279687f, 
    0.05183148f, -0.01403585f, 0.02482308f, 0.05359202f, 0.01185392f, 0.22111788f, 0.01867540f, -0.08688942f, 
    -0.06488252f, 0.02088267f, -0.17160143f, -0.01687906f, -0.03117471f, 0.01431596f, -0.06486177f, -0.09409715f, 
    -0.08085790f, -0.15226205f, 0.09098155f, -0.26308107f, -0.02452459f, -0.12754475f, -0.01808095f, -0.08129233f, 
    -0.02426731f, 0.03648888f, 0.00644888f, -0.04766786f, -0.14414349f, -0.05294050f, 0.11463473f, 0.03718076f, 
    -0.10009117f, -0.06818162f, 0.01798948f, 0.06419829f, 0.12875628f, 0.13667990f, 0.00927765f, 0.06616081f, 
    0.07277980f, -0.08362772f, -0.00525207f, 0.05296054f, 0.10361377f, -0.00393502f, -0.06078535f, 0.03047688f, 
    -0.00295191f, -0.01324465f, 0.05175209f, -0.06330008f, 0.06718434f, 0.00046155f, -0.04717255f, 0.04751261f, 
    0.05896108f, 0.01305995f, 0.02688566f, 0.05311474f, 0.02456160f, 0.10776141f, 0.04822898f, -0.00403499f, 
    -0.06370664f, -0.05397984f, -0.01596835f, 0.00007948f, -0.04776670f, 0.05413361f, 0.07446511f, -0.03144961f, 
    -0.01691920f, -0.04449155f, 0.04705865f, -0.11357853f, 0.14234416f, -0.01603721f, 0.02594917f, 0.10435603f, 
    0.00725163f, 0.05885542f, 0.07397833f, 0.00021376f, 0.03013260f, -0.15470172f, -0.00159506f, 0.08209021f, 
    0.05392479f, -0.05620686f, -0.10165797f, 0.12162758f, 0.14969474f, -0.09615676f, -0.04117034f, -0.08872766f, 
    0.09958306f, -0.05740272f, 0.03875039f, -0.06884687f, 0.03120858f, 0.02177916f, 0.00766997f, 0.21563877f, 
    -0.19015747f, -0.07791232f, -0.12159081f, -0.05248933f, 0.00725679f, 0.03845714f, -0.08503204f, -0.08128396f, 
    0.01919996f, 0.09673704f, -0.11978497f, -0.04561007f, 0.01991895f, 0.04129730f, -0.14490505f, -0.05721075f, 
    0.02401109f, 0.08617506f, -0.12430838f, -0.01887620f, -0.01828353f, -0.00987322f, 0.12005106f, 0.09870896f, 
    -0.20163198f, -0.00593034f, -0.02484415f, 0.10716984f, 0.02563608f, -0.05466868f, 0.01047906f, 0.04267814f, 
    -0.26337859f, 0.24341480f, 0.09301068f, -0.09632427f, 0.04925987f, -0.08877739f, 0.09774067f, -0.05121756f, 
    0.01367832f, -0.02400123f, -0.03977383f, -0.08150461f, -0.20955549f, -0.15129948f, -0.17651781f, -0.11795941f, 
    -0.05711966f, -0.07446674f, 0.05147110f, -0.04223512f, 0.03899711f, 0.02813900f, -0.01087835f, 0.03126093f, 
    -0.16761476f, -0.17813128f, 0.01814981f, 0.26152331f, 0.13301039f, -0.00062696f, -0.04215616f, -0.03977815f, 
    -0.06020908f, 0.11686474f, 0.10604260f, -0.05094054f, -0.16835652f, 0.08967599f, -0.05714776f, -0.07220158f, 
    -0.06864850f, -0.03294229f, -0.06352746f, -0.06062578f, 0.04535709f, 0.06126444f, -0.00534638f, -0.04905920f, 
    0.11331031f, -0.00891755f, 0.07692501f, 0.06793782f, 0.15985361f, -0.00285246f, -0.05868540f, -0.00663912f, 
    0.03850702f, 0.08424304f, 0.02853383f, -0.03692404f, -0.17467310f, -0.06313432f, 0.07435068f, 0.05764975f, 
    -0.13386491f, 0.01707709f, -0.10278474f, -0.18938892f, -0.00395102f, -0.07423601f, 0.09973425f, -0.15420525f, 
    0.12197059f, -0.25732216f, -0.02465461f, 0.04390965f, 0.05978342f, -0.07071543f, -0.02381918f, 0.00784784f, 
    -0.04206822f, -0.02069337f, -0.00397041f, -0.18996902f, -0.13330369f, 0.14301358f, -0.15397291f, -0.18197322f, 
    -0.02175198f, -0.02161620f, 0.02684928f, 0.08353348f, 0.00938222f, 0.00398199f, 0.04038244f, 0.01966424f, 
    -0.02552678f, 0.08926974f, 0.02082543f, 0.06191488f, -0.03842282f, -0.02856639f, 0.04012698f, -0.06198965f, 
    0.03044403f, 0.05513526f, -0.16892512f, -0.05257738f, 0.07331023f, 0.04164523f, -0.14206325f, 0.11513127f, 
    0.12095016f, 0.06894050f, -0.05099090f, -0.02661933f, -0.00536772f, -0.04976049f, -0.01743229f, 0.00785897f, 
    0.21575747f, -0.00565664f, 0.11461622f, 0.00419692f, 0.06573471f, 0.07925940f, 0.01505948f, -0.05436650f, 
    -0.10211820f, -0.04638618f, -0.09634173f, 0.17106159f, 0.24034503f, -0.27551228f, 0.08012093f, -0.14366664f, 
    0.15775503f, 0.04664162f, -0.07828791f, -0.16356786f, 0.05034486f, -0.06076105f, -0.04358168f, 0.02679945f, 
    0.07557730f, 0.10872962f, 0.08793499f, 0.05922682f, -0.00969971f, -0.09591042f, 0.01882276f, -0.03516704f, 
    0.02359256f, 0.06364572f, 0.02811782f, -0.11351866f, 0.26777968f, 0.17237879f, 0.03230835f, -0.03100969f, 
    -0.02417467f, 0.08232061f, 0.10535958f, -0.07874765f, -0.01882439f, 0.02217880f, 0.09446138f, 0.01410305f, 
    0.08490057f, -0.28091457f, -0.15760340f, 0.00598485f, -0.01373843f, -0.03780819f, 0.01244450f, -0.08123767f, 
    -0.04269258f, 0.02841241f, -0.00465220f, -0.01421633f, 0.10074536f, 0.02140900f, 0.21404302f, -0.11129569f, 
    0.02735472f, -0.03513673f, -0.04687579f, 0.01177211f, 0.01319690f, -0.03555761f, -0.04853409f, -0.02785128f, 
    -0.37386346f, 0.04308936f, 0.26159468f, 0.00712737f, -0.05640406f, -0.06129266f, 0.02181146f, 0.02128078f, 
    0.01376872f, 0.03050836f, 0.02903683f, -0.14639530f, 0.02297836f, -0.24834283f, -0.08040328f, 0.08329629f, 
    -0.04574075f, 0.06682817f, 0.08423003f, -0.06174645f, -0.08137859f, -0.00114927f, -0.08732981f, -0.05125260f, 
    -0.28319868f, 0.07304195f, 0.05380837f, -0.03987905f, 0.09791307f, 0.11416000f, 0.06449187f, -0.01813821f, 
    0.02719156f, -0.04240624f, 0.02622266f, 0.01955129f, 0.23890111f, 0.07089331f, -0.01307179f, 0.02196478f, 
    0.09499840f, 0.03172895f, 0.07783311f, 0.13806255f, 0.05640334f, 0.04704921f, 0.08504958f, 0.04249538f, 
    -0.14113550f, -0.06506184f, 0.01669701f, 0.05935422f, 0.06682599f, 0.16097295f, -0.02798473f, -0.12196169f, 
    0.04880678f, -0.04095783f, 0.03755256f, 0.06487031f, -0.23247422f, 0.25367165f, -0.17017934f, -0.20955610f, 
    0.08931205f, 0.00736352f, 0.00595411f, -0.04846175f, -0.09852744f, 0.08271345f, -0.00373696f, -0.06321568f, 
    0.05913846f, -0.22159937f, -0.01860480f, 0.09931081f, -0.06740975f, -0.04161099f, -0.00765510f, 0.11959600f, 
    -0.14940314f, 0.05130506f, -0.03951330f, -0.04725017f, -0.25548014f, 0.08760709f, 0.13911393f, -0.11765610f, 
    0.03224096f, -0.02521539f, -0.07166831f, -0.04917479f, -0.04323964f, 0.02630331f, -0.11879117f, -0.04649736f, 
    -0.19133793f, -0.01116121f, 0.16333392f, 0.10404008f, -0.03273167f, 0.03222117f, 0.07192256f, 0.00815285f, 
    0.19947442f, -0.01050406f, 0.00434417f, -0.07770573f, -0.04374508f, -0.03605225f, -0.00096148f, -0.10846925f, 
    0.13998112f, -0.05728098f, 0.02969323f, 0.00834882f, 0.00880969f, -0.10076195f, 0.08025780f, 0.00311222f, 
    0.00272751f, -0.14886360f, -0.02378897f, 0.15447940f, 0.00183598f, -0.06661735f, -0.15467495f, 0.08465867f, 
    0.11813583f, -0.04938531f, 0.11263841f, 0.11568050f, -0.02411149f, -0.06729489f, 0.20414694f, 0.00992748f, 
    0.02447199f, 0.05127249f, -0.14304438f, 0.03020711f, 0.04289413f, -0.03281413f, 0.08110414f, -0.08162049f, 
    -0.03312880f, -0.01664454f, -0.14750588f, -0.31599009f, -0.06392650f, -0.10195706f, -0.02909271f, 0.03391385f, 
    -0.00140293f, -0.10034496f, -0.06448203f, -0.05710363f, -0.14968552f, -0.28756556f, 0.13432230f, -0.23506038f, 
    0.04157037f, -0.04758785f, -0.01542365f, -0.07118849f, -0.11085790f, -0.05985809f, -0.09919442f, -0.00225943f, 
    0.38572410f, 0.05024774f, 0.17572588f, 0.10551012f, 0.02924922f, 0.15427133f, 0.07261214f, 0.07825401f, 
    -0.15377668f, 0.04312043f, -0.03670228f, -0.06314068f, -0.23268022f, -0.12403329f, -0.04236770f, -0.03449961f, 
    0.03737650f, -0.00751053f, 0.13146897f, -0.14679804f, -0.02708285f, 0.10614693f, 0.06299018f, -0.12441620f, 
    0.04505717f, -0.04436320f, -0.09441189f, 0.05976861f, -0.03408409f, -0.02546939f, 0.01775963f, -0.03315578f, 
    -0.00774948f, -0.02743315f, 0.10888512f, -0.06298416f, -0.02861936f, -0.11047307f, -0.12445683f, -0.19223946f, 
    0.01047932f, -0.14146538f, 0.06553093f, -0.02794646f, -0.01338631f, -0.03745486f, 0.20817785f, -0.09370727f, 
    0.00336195f, 0.31712943f, -0.10949475f, 0.22801651f, -0.06642855f, 0.03621687f, -0.08013389f, -0.11697516f, 
    -0.03089582f, 0.14350554f, -0.05633574f, 0.03385255f, -0.08856820f, 0.44489533f, -0.44748315f, -0.32140455f, 
    0.25099102f, -0.07236277f, -0.00535890f, 0.00416102f, -0.18660168f, -0.07562561f, -0.15407148f, -0.15560579f, 
    0.05234616f, 0.08585536f, 0.07818374f, 0.00396897f, 0.04029117f, -0.03184906f, 0.02153526f, 0.14670379f, 
    -0.01030821f, -0.00644226f, 0.09647812f, 0.01053342f, -0.04923362f, 0.00777000f, 0.16718042f, -0.14190538f, 
    -0.11646380f, -0.08102679f, -0.03253341f, 0.07367653f, 0.10616954f, 0.02431216f, -0.00252362f, -0.07801076f, 
    -0.16585997f, -0.23108031f, 0.06095327f, 0.03473279f, 0.02367382f, -0.05778850f, -0.07144675f, -0.04162960f, 
    -0.11052161f, 0.00631978f, -0.09206467f, -0.03498369f, -0.16109978f, -0.04461277f, 0.05187088f, -0.21732038f, 
    -0.03558012f, 0.05108394f, -0.07654422f, 0.05516064f, 0.04010167f, -0.12496556f, -0.00462423f, 0.03929855f, 
    0.01044532f, 0.01418528f, -0.29156452f, 0.31266430f, -0.08725987f, 0.05372867f, 0.05642186f, 0.15597692f, 
    -0.01176484f, -0.05184356f, -0.01110852f, 0.00701743f, 0.21386698f, -0.05648459f, 0.17310594f, -0.08131083f, 
    0.13675109f, 0.00105858f, -0.09787116f, -0.15849201f, -0.02005710f, -0.00312949f, 0.13520901f, 0.01052790f, 
    -0.06240597f, -0.33985552f, -0.10851130f, -0.01814516f, 0.00113986f, -0.00616979f, 0.12583522f, 0.03407506f, 
    0.00907143f, -0.00412156f, 0.10691536f, -0.05717617f, -0.01925447f, 0.03756041f, 0.00414692f, 0.06535516f, 
    -0.05955719f, 0.03288983f, -0.10526197f, 0.03186575f, -0.00791858f, 0.02104070f, 0.08042653f, 0.00276833f, 
    -0.09989276f, 0.25928620f, 0.05977407f, -0.00453820f, -0.01365397f, 0.03585653f, -0.04324652f, 0.18001935f, 
    0.12302892f, 0.00442112f, 0.02470692f, 0.06526681f, 0.22238423f, -0.08750913f, 0.17593630f, -0.09129459f, 
    0.05599219f, 0.00217403f, -0.04645021f, -0.04050149f, 0.03550972f, -0.01806598f, -0.06069209f, 0.01065997f, 
    0.15703809f, 0.11288168f, -0.01252109f, 0.09598671f, 0.01585942f, -0.11012795f, -0.06319538f, -0.01022943f, 
    -0.01255974f, -0.06282683f, 0.03482304f, 0.04056147f, 0.50677401f, -0.05223735f, 0.03588076f, -0.02232997f, 
    0.17747718f, -0.07277262f, -0.01871036f, 0.05813088f, 0.03022980f, 0.06429941f, -0.03705942f, 0.09651935f, 
    0.14527383f, -0.00200395f, 0.10857534f, -0.20379043f, -0.07158188f, 0.07611451f, -0.14675754f, -0.04957100f, 
    0.02955548f, 0.00380650f, 0.10665792f, -0.03621052f, 0.00970846f, -0.35299399f, 0.14333872f, 0.00301413f, 
    0.04227942f, -0.02900687f, -0.11555772f, -0.10079128f, -0.04215723f, -0.03344316f, 0.04168500f, 0.15774295f, 
    -0.32090718f, 0.21738982f, -0.12590073f, -0.21478511f, 0.08154552f, 0.01391012f, -0.05647892f, -0.06170565f, 
    -0.06636232f, -0.04336730f, -0.02245524f, -0.03101003f, 0.10912260f, 0.06569371f, -0.04307760f, 0.03270676f, 
    0.03921914f, 0.07662472f, -0.20851742f, 0.10752618f, -0.05021004f, -0.01208986f, 0.14149919f, 0.05253817f, 
    0.13012521f, -0.46700820f, 0.11201414f, 0.09781766f, -0.15118559f, 0.07132061f, 0.04283854f, 0.05569332f, 
    0.00797730f, -0.03038343f, 0.04611629f, -0.03648214f, -0.38431308f, 0.31026563f, 0.23321304f, 0.07878985f, 
    0.06365529f, 0.00339901f, -0.00523381f, 0.18359223f, 0.07784801f, 0.01147298f, 0.03460485f, 0.04925145f, 
    0.07038531f, -0.06893869f, -0.08045927f, -0.05779179f, 0.10609268f, -0.04727376f, -0.08557388f, 0.03927885f, 
    -0.09851975f, -0.03433335f, 0.02792817f, -0.05073364f, -0.18288432f, 0.09526352f, -0.19218040f, 0.16938558f, 
    -0.00991886f, -0.10001143f, 0.01771708f, 0.06596175f, 0.05678814f, 0.01896778f, -0.07025536f, -0.03254968f, 
    -0.15787366f, 0.06034376f, 0.04978443f, -0.18032330f, -0.02350360f, 0.04979319f, 0.02422688f, -0.10255967f, 
    0.05182572f, 0.02289076f, 0.00398612f, 0.07283276f, 0.10722021f, -0.15006597f, -0.02915974f, -0.11136106f, 
    0.06402728f, 0.05952008f, -0.06532267f, -0.08166687f, 0.08369974f, -0.03211613f, -0.06133613f, -0.04662028f, 
    -0.03369144f, -0.05000550f, 0.04998865f, -0.02068970f, -0.00287704f, -0.07614310f, 0.00740946f, 0.03748658f, 
    -0.00051288f, 0.18950903f, -0.06602587f, 0.00305680f, -0.48306188f, -0.22856247f, 0.05709853f, -0.15031056f, 
    0.07882411f, -0.07891215f, 0.00685138f, 0.06421760f, 0.05246124f, -0.08311834f, 0.10389142f, -0.03734890f, 
    -0.11957925f, 0.10592569f, -0.20463592f, -0.17976233f, 0.00791599f, 0.01970951f, 0.09105330f, 0.00244599f, 
    -0.01583713f, 0.08981883f, 0.02693975f, 0.01348666f, 0.31299478f, -0.39692014f, -0.09648596f, 0.06755725f, 
    0.06414906f, -0.01625314f, -0.01880895f, 0.11843956f, 0.00213781f, -0.00373521f, 0.03342098f, -0.12447104f, 
    -0.31312114f, -0.16563646f, 0.17322654f, 0.00872977f, -0.02936390f, 0.05967575f, -0.01734463f, -0.01677820f, 
    -0.06738134f, 0.01982817f, -0.02818482f, -0.03382687f, -0.15421298f, -0.22107714f, 0.03067526f, -0.00602307f, 
    0.08102992f, 0.09404529f, 0.00339612f, 0.04314289f, -0.01619374f, -0.00676275f, 0.01213957f, -0.02590108f, 
    -0.08898977f, 0.03383347f, 0.04614027f, 0.24995148f, -0.11467838f, 0.07694329f, -0.23893309f, -0.04407300f, 
    -0.02824793f, 0.04809482f, 0.09818457f, -0.01325611f, 0.14737892f, 0.03533026f, -0.10140592f, -0.00171617f, 
    0.00911507f, 0.05126973f, -0.07146617f, 0.07081772f, 0.01757135f, -0.01447240f, 0.01591761f, 0.04298314f, 
    -0.32905549f, 0.13754551f, -0.18250473f, -0.27462730f, 0.04945944f, -0.02870789f, 0.02712603f, 0.05813461f, 
    -0.06470457f, -0.09161874f, -0.04050957f, 0.00656630f, -0.18430477f, 0.00948094f, -0.05069014f, 0.14467734f, 
    -0.02912009f, 0.05293401f, 0.02520279f, 0.02723003f, 0.08186299f, 0.03287151f, -0.04578202f, -0.03771658f, 
    0.06454670f, -0.10214958f, -0.06802237f, -0.07483620f, 0.00581387f, 0.07746869f, 0.01073062f, -0.09668186f, 
    -0.08684415f, 0.02541165f, -0.06064443f, -0.01428523f, 0.23159565f, -0.11813793f, -0.09970401f, 0.12643783f, 
    0.01058893f, -0.05301786f, 0.07767203f, 0.00344932f, 0.09884970f, 0.02644616f, 0.08205128f, -0.07102106f, 
    -0.20390198f, 0.05741557f, 0.19320604f, -0.11782178f, 0.01620985f, 0.00530476f, -0.02884514f, -0.04109668f, 
    -0.03360834f, -0.04966795f, -0.09026586f, 0.06541283f, -0.02181032f, -0.25792575f, 0.04509586f, -0.18414216f, 
    -0.04399345f, 0.04271257f, 0.08134796f, -0.04928404f, -0.00348020f, -0.08671397f, -0.00969693f, 0.12331516f, 
    -0.27060625f, 0.04951109f, -0.02211200f, 0.02433194f, 0.10538883f, -0.02568100f, -0.02313590f, 0.02539806f, 
    -0.05139617f, 0.08284350f, 0.03347171f, 0.01775012f, -0.12664141f, -0.00416020f, 0.02726179f, -0.13115728f, 
    -0.00382615f, 0.03454519f, 0.00414697f, 0.02044569f, 0.07760996f, 0.01695648f, -0.09250107f, 0.06261056f, 
    -0.16148366f, -0.03113898f, -0.12194540f, -0.07320077f, -0.03489755f, -0.07808123f, -0.17896312f, 0.07414465f, 
    0.04734126f, 0.11276489f, 0.10812376f, 0.00093864f, -0.16127871f, 0.00188293f, -0.15516487f, -0.03001630f, 
    -0.02368544f, 0.02486398f, -0.00040033f, -0.08394407f, 0.16119072f, 0.05704008f, 0.06748322f, 0.14996342f, 
    -0.41814321f, -0.07051556f, -0.04863862f, 0.08453595f, 0.09604558f, -0.06786441f, -0.13622728f, -0.12190577f, 
    -0.16967985f, -0.13013449f, 0.00242651f, -0.04114481f, -0.51032203f, -0.00234260f, -0.02497597f, 0.25845841f, 
    0.12971888f, -0.02284233f, -0.00114870f, -0.08141614f, 0.02256687f, -0.00010349f, -0.10180099f, 0.09501695f, 
    0.23867162f, -0.00945752f, -0.08820302f, 0.14416540f, -0.03756393f, -0.06767827f, -0.01646518f, 0.05737848f, 
    0.01730244f, -0.00435846f, -0.01227423f, -0.09472539f, -0.03941721f, -0.00501248f, 0.11592180f, -0.05111769f, 
    0.04669118f, -0.04742160f, -0.00901682f, 0.05674088f, 0.08337437f, 0.14968975f, 0.03450931f, 0.17006879f, 
    -0.42235833f, -0.22309923f, 0.11576206f, 0.06498517f, 0.05040254f, 0.01213797f, -0.02860886f, -0.12298888f, 
    0.05322887f, -0.04584185f, -0.01305244f, 0.06470156f, 0.09815436f, 0.07443135f, 0.07554352f, -0.08252051f, 
    0.06020094f, 0.05176658f, 0.10972317f, 0.05283133f, 0.01215804f, 0.10990696f, 0.02150000f, 0.11441871f, 
    -0.33944887f, -0.09940368f, -0.14141469f, 0.02096750f, 0.07268527f, 0.01341325f, 0.03695876f, -0.03558052f, 
    0.07839924f, 0.01912894f, 0.06866895f, 0.12287663f, -0.24397278f, -0.15866758f, -0.01814550f, -0.04470058f, 
    0.08129780f, 0.02944373f, 0.01478880f, -0.03358759f, 0.02457830f, 0.05148632f, -0.08534225f, 0.05252326f, 
    -0.27066579f, -0.20349954f, -0.11064350f, -0.13484666f, 0.08873517f, -0.10569704f, -0.00580596f, -0.09105597f, 
    0.02399829f, 0.03195494f, -0.13462394f, 0.06271306f, 0.18512361f, 0.01317702f, 0.06022089f, -0.05826616f, 
    -0.00127974f, 0.02557255f, 0.01877285f, 0.15447880f, 0.09951213f, 0.00852518f, 0.13552180f, 0.07154163f, 
    0.11814134f, 0.07950490f, 0.06467454f, -0.09177647f, 0.01328278f, 0.06753958f, 0.02390553f, -0.01815080f, 
    0.00397916f, -0.02835782f, 0.13562472f, -0.10199886f, -0.40022027f, -0.20240398f, 0.18855496f, -0.01085508f, 
    0.16430067f, 0.01741697f, -0.08330959f, -0.02611145f, 0.03700784f, -0.04723881f, 0.05847870f, 0.02117092f, 
    -0.05691108f, -0.18974967f, 0.09146436f, 0.06678997f, -0.02289909f, 0.10539608f, -0.01811512f, -0.02495844f, 
    -0.03135085f, 0.01114414f, -0.11942514f, 0.08321218f, 0.00425328f, 0.09660110f, -0.01453874f, -0.09019972f, 
    0.02826357f, 0.04350885f, -0.04982634f, -0.00282186f, 0.12475476f, 0.05396540f, -0.00732685f, 0.02018442f, 
    0.10887001f, 0.00607074f, 0.08847282f, -0.07065858f, -0.01914442f, 0.11421651f, -0.01635475f, 0.03645430f, 
    0.04709315f, -0.00529733f, -0.04083891f, -0.10277051f, -0.17491803f, 0.02133820f, -0.02990835f, 0.14516561f, 
    0.06679318f, 0.04348234f, 0.02098871f, -0.03344859f, 0.06680340f, -0.05736282f, 0.11301700f, -0.05757954f, 
    0.01082196f, 0.07209712f, -0.10414708f, -0.06149921f, -0.04334762f, 0.06282177f, -0.00939300f, 0.11123095f, 
    -0.03488826f, 0.02560367f, 0.13518161f, 0.07953782f, 0.05982853f, 0.06795169f, -0.04852851f, 0.03630373f, 
    -0.01577794f, 0.08141693f, 0.02499717f, -0.01831222f, 0.06455409f, 0.04073619f, 0.04030108f, -0.03876109f, 
    -0.48776576f, -0.36188483f, 0.05219353f, 0.09877763f, 0.06298433f, 0.06518784f, -0.12958860f, -0.12741244f, 
    0.04384937f, -0.13640578f, 0.01145901f, 0.11079835f, 0.03084559f, -0.09172715f, -0.06451108f, 0.03076140f, 
    0.04947742f, 0.04201603f, -0.04209171f, 0.06460626f, -0.15299711f, -0.01852546f, 0.00249129f, 0.10899745f, 
    0.00902131f, 0.19587135f, -0.04422721f, 0.02123678f, 0.02157753f, 0.09613276f, -0.03277852f, -0.01485453f, 
    0.01163783f, -0.03952048f, -0.00073141f, 0.08663582f, -0.08396843f, 0.07815586f, 0.06097234f, -0.09555849f, 
    0.07563689f, -0.01713289f, -0.08833639f, 0.02690039f, 0.04199989f, -0.05314608f, -0.07325165f, 0.08479646f, 
    0.13483378f, -0.03074986f, -0.00036347f, 0.03379714f, -0.04318415f, -0.04879995f, 0.00287180f, 0.06789136f, 
    0.08134478f, 0.03207240f, 0.03047282f, 0.05902832f, -0.38363183f, -0.26850992f, -0.21733242f, -0.25175512f, 
    0.02796142f, -0.06526420f, -0.01165091f, -0.01816429f, 0.01700336f, 0.01966678f, 0.14551599f, 0.05716363f, 
    0.07396434f, -0.06857774f, 0.16327098f, -0.07314978f, -0.00437324f, -0.05667941f, 0.02601081f, -0.03737760f, 
    0.05150079f, -0.11366028f, -0.11736701f, 0.00351634f, 0.09972112f, -0.01264986f, 0.02145937f, -0.13936657f, 
    0.01905584f, -0.09880117f, 0.00298298f, -0.08605476f, 0.03475225f, -0.08299221f, -0.06605720f, 0.06638301f, 
    0.20024168f, 0.00854739f, 0.02810673f, -0.07145235f, 0.02293088f, 0.16259730f, -0.00501121f, -0.01507261f, 
    0.04924040f, 0.03581234f, 0.08438107f, 0.02729568f, -0.41349512f, -0.16766898f, 0.15972759f, -0.07346403f, 
    0.11795853f, 0.02463678f, 0.02536005f, -0.04904001f, 0.11313063f, 0.10751776f, -0.02536640f, 0.02544298f, 
    0.25192443f, 0.05985092f, 0.01508719f, -0.22192012f, 0.21278082f, 0.14942233f, 0.18733284f, -0.02646450f, 
    -0.01515729f, 0.04228068f, -0.04239651f, -0.01301962f, -0.15147996f, -0.17993955f, -0.11772516f, -0.05399886f, 
    -0.02197413f, 0.04313514f, 0.00784237f, 0.04887544f, -0.01155504f, 0.03215164f, 0.02115338f, 0.02262194f, 
    0.00197927f, 0.11823155f, 0.00038539f, -0.03762203f, -0.07874621f, 0.05165856f, -0.05045975f, -0.02102840f, 
    -0.05130012f, -0.05351200f, -0.01098897f, -0.01622984f, -0.31881729f, -0.32475007f, -0.17217368f, -0.03337455f, 
    0.02824167f, -0.01490165f, -0.01032596f, 0.04911596f, 0.06594934f, -0.08033516f, -0.06772807f, 0.01615848f, 
    -0.21028054f, -0.12727679f, 0.00316368f, -0.11631089f, -0.02283935f, 0.02529825f, -0.02658899f, -0.00005610f, 
    -0.02760306f, -0.01086030f, -0.00646235f, -0.06954244f, -0.01441455f, 0.11706416f, -0.10517865f, -0.04948425f, 
    -0.08220247f, 0.06554534f, 0.01535138f, -0.04239676f, 0.14346653f, 0.05031869f, 0.04662248f, -0.05157892f, 
    -0.23901987f, -0.06099262f, -0.02795354f, -0.13027035f, -0.05166874f, -0.00606594f, -0.02312985f, -0.01765157f, 
    0.00966261f, 0.12932646f, -0.03289946f, 0.02405320f, -0.02204983f, 0.01796613f, 0.08504684f, -0.07214229f, 
    -0.08614692f, 0.00919261f, 0.05976205f, -0.05348875f, -0.04170432f, -0.05251900f, 0.03453352f, -0.03879498f, 
    -0.02652703f, 0.14581542f, 0.10995787f, 0.00302727f, 0.07398107f, 0.05376405f, -0.05858496f, 0.01554679f, 
    -0.07434918f, -0.02202154f, -0.02660519f, 0.11805012f, -0.18359567f, 0.02021912f, -0.17853950f, 0.02498122f, 
    -0.00993070f, -0.07499813f, -0.01404971f, -0.03863055f, -0.01380009f, 0.00656914f, 0.06785630f, -0.13638298f, 
    -0.12219572f, -0.17964421f, -0.23681283f, -0.22786994f, 0.03195220f, 0.01642202f, 0.02442949f, 0.00169554f, 
    0.00595694f, -0.09301369f, -0.12817729f, 0.02251960f, -0.26593161f, -0.04107867f, 0.19600616f, 0.00499205f, 
    -0.07972974f, 0.04792157f, 0.05614056f, -0.04191596f, -0.07346733f, -0.27169210f, -0.01521248f, 0.00827531f, 
    -0.16032302f, -0.04351647f, -0.15262988f, 0.07543369f, -0.01074964f, -0.07698654f, -0.01388806f, 0.00511326f, 
    -0.00861340f, 0.13735597f, -0.08192571f, -0.15910615f, -0.22709000f, -0.08106980f, -0.05188264f, -0.04690649f, 
    -0.03942902f, 0.01213618f, 0.04130872f, -0.07437123f, 0.00535598f, -0.14152530f, -0.04988429f, -0.02546193f, 
    0.12406161f, -0.03287021f, -0.06337498f, 0.08269837f, 0.01242402f, 0.06690098f, 0.09746963f, 0.01577502f, 
    0.01834710f, 0.09180460f, 0.05399508f, 0.01129401f, 0.29951748f, 0.06618663f, -0.03251825f, 0.06119374f, 
    0.04153907f, -0.16835304f, 0.08273236f, 0.03901471f, 0.14353240f, 0.11077440f, -0.00073398f, 0.06243706f, 
    -0.22776730f, -0.14823531f, -0.07235091f, -0.04462326f, 0.08452763f, -0.00892344f, -0.06606002f, 0.02332125f, 
    0.07720170f, -0.06023426f, 0.01805171f, -0.00882965f, -0.16347784f, 0.13248338f, -0.10046725f, -0.15954737f, 
    0.00946667f, -0.03754513f, 0.07852980f, 0.11880632f, 0.11988419f, 0.09304470f, 0.09311631f, 0.17911907f, 
    0.24083197f, 0.06567726f, -0.03152896f, 0.02439538f, -0.14701039f, 0.06249968f, -0.07490773f, -0.05550832f, 
    0.12011199f, -0.06885479f, -0.05412151f, -0.09764635f, -0.11871376f, -0.00334872f, -0.04157189f, 0.06078298f, 
    -0.00414627f, -0.09729324f, 0.02962922f, -0.08174925f, -0.01450507f, 0.00129437f, 0.01963764f, 0.01738385f, 
    -0.27610171f, -0.19416827f, -0.07084330f, -0.03923406f, -0.03337079f, 0.00239734f, -0.02824124f, -0.05244124f, 
    0.00195102f, -0.04565648f, 0.03624733f, 0.02199499f, 0.29380241f, -0.06863323f, 0.03999009f, 0.05523266f, 
    -0.10122145f, -0.13702106f, -0.09536941f, -0.01668825f, -0.18894084f, 0.01521965f, -0.13293597f, 0.04530969f, 
    -0.14856559f, 0.11237093f, -0.01558439f, 0.12828395f, 0.15334788f, -0.08422482f, -0.06950877f, 0.09746491f, 
    0.03767305f, 0.11882670f, 0.05943517f, 0.18503395f, 0.10345743f, 0.08668430f, -0.00823509f, 0.05616143f, 
    -0.07987978f, -0.09827172f, 0.00770450f, 0.03915344f, 0.14720410f, -0.03655350f, 0.05506146f, 0.03936685f, 
    0.20751505f, 0.00647244f, 0.11526643f, -0.11904189f, -0.08604892f, -0.05994461f, 0.02871704f, -0.09630431f, 
    0.04491661f, 0.08415550f, -0.03305066f, -0.04260146f, 0.11252930f, 0.13307761f, 0.06615686f, 0.05308410f, 
    0.08377153f, 0.14354821f, 0.16381159f, -0.07354396f, 0.03480777f, -0.05277820f, 0.07435899f, 0.02792152f, 
    -0.58273381f, -0.13131064f, -0.18978599f, -0.38459072f, 0.06314639f, -0.09671035f, -0.07021616f, -0.06824549f, 
    0.00695234f, 0.00689095f, -0.11186513f, -0.04020649f, 0.25013727f, 0.02765738f, -0.02979400f, 0.03577643f, 
    0.06509907f, -0.05760837f, 0.08676343f, 0.05693437f, 0.02880926f, 0.04512416f, 0.01167190f, 0.05438788f, 
    -0.36145434f, -0.06445774f, -0.09313726f, -0.07196146f, 0.09105128f, -0.04777731f, -0.08530445f, -0.01657172f, 
    0.03289757f, 0.06696517f, 0.14282505f, -0.00596134f, 0.26982254f, 0.12850785f, 0.01548285f, 0.03805256f, 
    -0.09954350f, -0.08994658f, 0.01030015f, 0.03175690f, -0.11720130f, 0.04125286f, 0.05703578f, -0.02327128f, 
    -0.27228874f, -0.15692879f, 0.08560172f, -0.03353463f, 0.05340927f, 0.01891838f, -0.07147243f, 0.07026581f, 
    0.03550596f, -0.00997870f, 0.03529954f, 0.11920020f, 0.03378776f, 0.10411873f, -0.04124238f, -0.00285492f, 
    0.17074391f, 0.13784598f, 0.19549918f, -0.04097649f, 0.08951093f, 0.15550260f, 0.05730795f, 0.01238999f, 
    0.17205928f, -0.12804742f, -0.17389493f, -0.04679093f, -0.07737888f, 0.04306780f, 0.02606053f, 0.07001000f, 
    0.02929809f, -0.07923300f, -0.04652692f, -0.04675574f, -0.45848101f, -0.09113786f, -0.17583436f, -0.12207591f, 
    0.11169797f, -0.01120050f, 0.03595210f, -0.06580502f, 0.08190864f, 0.03629816f, -0.08400316f, -0.04805164f, 
    -0.26805964f, 0.08560302f, 0.05417209f, -0.14166246f, -0.09835725f, -0.02876055f, -0.04042669f, 0.04055605f, 
    0.04977009f, -0.02345881f, -0.01877367f, 0.09738617f, -0.19813006f, -0.13621718f, -0.00183658f, 0.04570813f, 
    0.08918931f, 0.07527182f, 0.01941948f, 0.13080943f, -0.16703515f, -0.01694389f, -0.01353978f, -0.14138083f, 
    0.14133228f, 0.14336850f, -0.00566323f, -0.36331502f, 0.06555128f, 0.00489130f, -0.04833027f, -0.01035783f, 
    0.07582998f, 0.00553882f, -0.01858399f, -0.04830758f, 0.27656332f, -0.03035560f, 0.04911683f, -0.16698992f, 
    0.11424606f, -0.06261167f, -0.16284041f, 0.08105374f, 0.06043541f, 0.04483281f, 0.10895344f, 0.08894038f, 
    -0.25257331f, 0.09270862f, -0.04877705f, 0.07740163f, 0.11598712f, -0.04848797f, 0.04305042f, -0.03367960f, 
    0.06034699f, -0.03921072f, 0.01921888f, 0.10298414f, 0.21374242f, -0.04666935f, -0.10232209f, 0.13431932f, 
    0.00710931f, 0.02164580f, -0.15768214f, -0.05103013f, 0.01565325f, 0.07888937f, -0.09551802f, -0.08660702f, 
    0.23003858f, -0.16310506f, -0.11202697f, 0.01430628f, 0.03141058f, 0.02468986f, 0.01466514f, -0.00109588f, 
    -0.06558783f, -0.00720610f, -0.09521730f, 0.02479904f, 0.06403843f, 0.22596371f, -0.08809345f, -0.19093658f, 
    -0.04982546f, -0.02616043f, -0.06229067f, -0.08239028f, 0.00134292f, -0.08381524f, 0.03634722f, -0.10952956f, 
    -0.03070963f, 0.21940528f, -0.00273463f, -0.05480975f, 0.13633640f, 0.02114048f, 0.01355385f, 0.10500856f, 
    0.07713018f, 0.05160616f, -0.02497633f, -0.05898705f, -0.16163455f, -0.42335209f, 0.09040250f, -0.14039120f, 
    0.13756672f, -0.04502806f, -0.07816205f, 0.00591416f, 0.13732117f, 0.10078537f, -0.03580814f, -0.05147609f, 
    0.02797826f, -0.17289655f, 0.02140704f, -0.22729230f, 0.04060166f, 0.09934217f, 0.02626001f, 0.09572842f, 
    -0.02854179f, -0.05652782f, 0.01806722f, 0.05310153f, -0.13940519f, 0.04230614f, -0.10588683f, 0.10125217f, 
    0.18924175f, 0.03076014f, -0.04328274f, -0.17480388f, -0.08744449f, 0.03909569f, -0.08632553f, -0.09024080f, 
    -0.03274935f, 0.15231848f, -0.09273667f, 0.07888656f, -0.01142749f, -0.13910854f, 0.00242780f, -0.09007533f, 
    -0.03784733f, 0.00065036f, 0.03756296f, -0.13725607f, -0.12915923f, 0.16330703f, -0.04837982f, -0.00679366f, 
    0.12654524f, -0.00459905f, 0.00501964f, -0.04594943f, -0.00696890f, 0.08322974f, -0.06691721f, -0.03530111f, 
    -0.13395090f, -0.00485812f, -0.01966736f, 0.01714327f, 0.05677809f, -0.06745477f, -0.07750338f, 0.02890089f, 
    0.05814037f, 0.06814602f, 0.00570555f, -0.18609311f, -0.24633652f, -0.18050697f, 0.14416538f, -0.03881289f, 
    -0.05490812f, 0.04123932f, -0.00066212f, 0.15771823f, 0.02573440f, -0.01766961f, -0.04150465f, -0.01157417f, 
    0.03258175f, 0.04504178f, 0.07201640f, 0.04566312f, 0.01997655f, -0.07409377f, 0.01045627f, 0.03835974f, 
    -0.06102345f, 0.07152095f, 0.05009976f, 0.08809470f, 0.14037898f, -0.01083120f, 0.13640763f, 0.01388359f, 
    -0.08129443f, -0.14063364f, 0.05495844f, -0.00054066f, -0.05154358f, 0.00722033f, -0.00570980f, 0.10838223f, 
    0.15774219f, 0.03311076f, -0.16132692f, 0.06999817f, 0.11507875f, -0.08298761f, -0.02398981f, -0.00423095f, 
    -0.09625524f, 0.03655080f, 0.00738314f, 0.01346652f, 0.17166412f, -0.03019090f, -0.12341916f, -0.04283710f, 
    -0.27229285f, -0.07187882f, -0.08759899f, -0.09912303f, 0.04414292f, -0.05522808f, -0.06222292f, -0.17291807f, 
    0.01493414f, 0.04815679f, -0.08846852f, -0.15419447f, 0.01833924f, 0.03426031f, -0.02708492f, -0.01389145f, 
    -0.02598547f, -0.05587228f, 0.02348966f, -0.03582254f, -0.08723204f, 0.24263690f, -0.08379672f, -0.07872760f, 
    0.11558694f, -0.02959111f, 0.07325830f, -0.04810749f, -0.07326069f, -0.12567036f, -0.01734582f, 0.07748359f, 
    -0.29552981f, 0.22505778f, -0.09493223f, -0.06521886f, -0.15844406f, -0.01311806f, 0.10757716f, -0.12101854f, 
    -0.05011997f, 0.06558920f, -0.03064237f, -0.08506331f, 0.09771951f, -0.13090372f, 0.02487300f, 0.22956420f, 
    -0.10103402f, 0.01499104f, 0.06659820f, 0.04078954f, -0.02612916f, 0.01137871f, 0.07464328f, 0.02184992f, 
    -0.32573703f, 0.02791118f, 0.14797436f, -0.09966131f, -0.02730044f, -0.08840381f, -0.05845163f, -0.02080698f, 
    -0.03684450f, 0.07670363f, 0.03785069f, -0.22555014f, 0.08778293f, -0.40082303f, 0.04966082f, 0.06471799f, 
    0.01621013f, 0.11789516f, -0.00708799f, -0.05905326f, 0.06086344f, 0.04869524f, -0.06437748f, -0.09368949f, 
    -0.02520034f, -0.03804270f, -0.01412236f, -0.00091202f, 0.08259091f, 0.02476798f, -0.10171992f, 0.08153206f, 
    -0.04140668f, 0.00351056f, 0.03191026f, -0.03629072f, 0.00635911f, -0.01560493f, -0.15807100f, -0.04531316f, 
    0.01936643f, -0.06602124f, 0.00062905f, 0.00142501f, 0.02523026f, 0.00611175f, 0.04342684f, -0.14637867f, 
    0.00900446f, 0.15107837f, -0.01584438f, 0.04126230f, -0.04180787f, -0.00309881f, -0.00261136f, -0.13229506f, 
    0.05470296f, -0.04492446f, -0.05837981f, -0.06558141f, 0.18501933f, -0.01127148f, -0.13206492f, -0.04641789f, 
    0.06488444f, 0.02727249f, -0.07242817f, -0.01596218f, 0.10828138f, -0.04555900f, 0.01858867f, 0.04939592f, 
    0.10567891f, 0.02975248f, -0.05147691f, -0.08248855f, -0.19292131f, 0.00458791f, 0.01585624f, 0.02036879f, 
    -0.04307612f, 0.01519307f, -0.02130169f, -0.06117970f, -0.14515547f, -0.07147609f, 0.03591900f, -0.29845113f, 
    -0.02856018f, 0.01896840f, -0.04763322f, 0.11588950f, -0.02898356f, 0.07932561f, -0.02028596f, -0.04327238f, 
    -0.12744339f, -0.10256644f, 0.04866663f, -0.05138374f, -0.05094890f, 0.13540815f, 0.04200354f, 0.16424841f, 
    0.01060770f, 0.08426631f, -0.10585024f, -0.13180318f, -0.26254442f, 0.22131298f, -0.25274763f, 0.11368559f, 
    0.15802126f, 0.01081746f, -0.02325272f, -0.04273433f, 0.12038565f, -0.07632387f, 0.11917443f, 0.08917847f, 
    0.08420235f, -0.03351231f, -0.01629214f, 0.10812376f, 0.12200773f, -0.01765557f, -0.01749264f, -0.05558429f, 
    -0.09494407f, -0.02788343f, -0.02210006f, 0.04370163f, -0.33490053f, 0.15766808f, 0.05756132f, 0.09569008f, 
    -0.17339849f, 0.00390423f, -0.04037907f, 0.03446046f, -0.00977663f, 0.12185995f, 0.04253990f, -0.00798859f, 
    -0.24140823f, 0.01591626f, -0.01249772f, -0.34321594f, 0.10535384f, 0.09782964f, 0.05027540f, 0.07244911f, 
    0.05477042f, -0.07180464f, -0.00326498f, -0.05918270f, -0.39676267f, -0.18037421f, -0.02808962f, -0.10241864f, 
    0.05947865f, -0.08890586f, 0.06165754f, 0.13265410f, -0.03921051f, 0.01104097f, 0.00235937f, -0.00311783f, 
    0.48204401f, -0.05768180f, -0.04850763f, 0.14437659f, -0.04144165f, -0.05655942f, 0.05295159f, 0.03395694f, 
    0.11462668f, 0.06354076f, -0.10416795f, 0.03345282f, -0.32702968f, -0.16975154f, -0.04658022f, 0.15137599f, 
    -0.06270654f, 0.12203512f, -0.18548638f, 0.03825801f, -0.02782540f, 0.07657963f, 0.11077923f, 0.08933330f, 
    0.16024029f, -0.25603330f, -0.14536928f, -0.18247360f, 0.03960801f, -0.02517419f, -0.01858666f, -0.01963746f, 
    0.02095195f, 0.11537173f, 0.00946279f, -0.07483067f, -0.18926977f, 0.22577243f, -0.13254777f, 0.01585514f, 
    0.10003851f, -0.10207982f, 0.03708224f, 0.01623786f, -0.04977136f, 0.10945968f, 0.07702348f, -0.03492448f, 
    0.32761839f, 0.11437342f, -0.03670425f, 0.16388957f, -0.16456959f, 0.03826571f, -0.08064534f, 0.01953818f, 
    0.06117704f, -0.02801461f, 0.12401865f, -0.00123358f, -0.01003002f, -0.03658067f, -0.03983681f, 0.12057140f, 
    0.03037697f, -0.01756823f, -0.02146261f, -0.05289487f, 0.06041581f, 0.04502109f, 0.05636788f, -0.03480221f, 
    -0.07102747f, 0.03488077f, -0.02301552f, -0.03503415f, -0.21353887f, 0.05808600f, -0.10098475f, 0.01921664f, 
    0.01283893f, -0.01160750f, 0.03589585f, -0.13059524f, 0.11711758f, -0.03347646f, 0.21116389f, 0.24652854f, 
    -0.06092026f, 0.09141330f, 0.02793204f, 0.06205742f, -0.04471877f, -0.13363183f, -0.11256606f, 0.08809107f, 
    0.18312332f, -0.02975263f, -0.05627237f, -0.22643244f, 0.05591306f, 0.01005716f, -0.04780411f, 0.14064419f, 
    0.04000621f, -0.03018938f, -0.00188532f, 0.06835587f, 0.05065512f, 0.02183843f, -0.14740454f, 0.11882935f, 
    -0.01808458f, -0.02405056f, -0.00068000f, 0.08983319f, -0.05419010f, -0.06026271f, -0.03104553f, -0.06578059f, 
    -0.09086300f, 0.05527129f, -0.03463623f, 0.15612485f, 0.01511549f, -0.11002905f, -0.02663358f, -0.00741059f, 
    0.00623945f, -0.01587049f, 0.02397431f, -0.04884740f, -0.04165885f, -0.26470724f, -0.01099045f, 0.03776661f, 
    -0.16406426f, 0.08069873f, -0.04284283f, 0.00412544f, -0.02447268f, 0.04043001f, -0.07684255f, -0.01288759f, 
    0.23446774f, -0.07021300f, -0.10337906f, -0.25590888f, 0.14465977f, -0.12564683f, 0.03782562f, -0.05146275f, 
    0.03354692f, -0.02576960f, 0.02104798f, 0.05277070f, -0.19842274f, -0.14326178f, -0.06137019f, -0.01400109f, 
    0.04665799f, -0.01426114f, 0.06759285f, 0.11713198f, -0.12702230f, 0.00739863f, 0.07360414f, -0.07042366f, 
    -0.08631996f, 0.25878179f, -0.08205951f, 0.05663057f, 0.15149437f, 0.01304892f, 0.02789244f, -0.13887726f, 
    -0.09930097f, -0.06793531f, -0.05476440f, -0.11127244f, 0.09641124f, -0.06555051f, 0.01221775f, -0.01251458f, 
    0.04555811f, 0.05149385f, 0.00799783f, 0.11172679f, -0.03860018f, -0.07190568f, -0.15093844f, -0.03663770f, 
    0.07248281f, 0.00749873f, 0.08874851f, -0.00181595f, 0.08803588f, -0.03650456f, -0.09737126f, -0.13004947f, 
    -0.07896011f, -0.04631342f, 0.12726016f, 0.08154390f, -0.24996249f, -0.02551236f, 0.00228682f, 0.10851055f, 
    -0.10090081f, -0.06431002f, 0.06594574f, 0.09170444f, -0.00386993f, 0.01045488f, 0.03417119f, -0.05821417f, 
    0.28552619f, -0.10223506f, -0.13749720f, -0.04064070f, -0.02974076f, -0.06063518f, -0.04279941f, -0.04651457f, 
    0.13775310f, 0.02701424f, -0.02182589f, 0.07320308f, -0.01101676f, -0.00622119f, -0.10106416f, -0.01559075f, 
    0.09469375f, -0.00990162f, 0.03645011f, 0.03152416f, 0.02272122f, -0.00496914f, -0.00351580f, -0.03997652f, 
    -0.10770765f, -0.10037514f, -0.02669209f, -0.14500083f, -0.06029552f, 0.07674915f, -0.02497507f, 0.10641162f, 
    0.04038771f, -0.12852243f, 0.02558091f, -0.05340333f, 0.08685523f, 0.03352923f, 0.08399156f, 0.03266132f, 
    -0.10159110f, -0.00727827f, 0.02086379f, -0.03197699f, -0.07153892f, 0.02370468f, -0.00641318f, -0.04923409f, 
    0.37912673f, 0.21320450f, -0.20545428f, -0.23254983f, 0.04299219f, 0.05772882f, -0.04717401f, 0.02799675f, 
    -0.02321902f, 0.01074530f, -0.03029498f, 0.11246211f, 0.24033381f, -0.00088644f, -0.18465614f, 0.16091469f, 
    0.07588346f, -0.01283790f, -0.12579574f, 0.16613175f, 0.03675589f, 0.05207160f, -0.02103194f, 0.00209901f, 
    -0.13529773f, 0.07185432f, -0.01297542f, 0.02064740f, 0.04736980f, -0.14330857f, 0.06837240f, 0.11832496f, 
    0.05898930f, 0.10130776f, 0.06229059f, 0.02057308f, 0.45033500f, -0.25267917f, -0.17200732f, 0.06442835f, 
    0.09029273f, -0.02816005f, 0.01426365f, -0.07895948f, 0.09720495f, 0.08454465f, 0.10248666f, 0.01620900f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08728605f, 0.03699403f, -0.06819130f, 0.00028218f, 0.01159741f, 0.01405021f, 0.03158450f, -0.08351209f, 
    0.00609689f, 0.03405211f, 0.08772669f, 0.03233226f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
