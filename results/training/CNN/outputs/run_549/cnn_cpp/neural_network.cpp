#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.79136992f, -0.53331804f, 0.27277219f, -0.79773200f, -0.41039172f, -0.35973763f, -0.43429548f, -0.00894540f, 
    -0.46519992f, -0.59936547f, -0.84566188f, -0.66243559f, 0.75772244f, -0.26114869f, 0.50356674f, -0.24433523f, 
    -0.06919890f, -0.03525913f, 0.14129259f, 0.30028093f, 0.33775580f, 0.76850778f, 0.78397268f, 0.84007937f, 
    -0.03903373f, -0.17213555f, -0.20017798f, -0.90624928f, -0.56019288f, -0.19125409f, -0.18998936f, 0.22136213f, 
    -0.55873424f, 0.27890375f, 0.11319466f, -0.47144467f, 0.95598257f, 0.57567936f, 0.86619759f, -0.25236225f, 
    0.54977316f, -0.32123625f, 0.28488010f, -0.27017802f, 0.16100559f, 0.76296777f, 0.88471305f, 0.75500840f, 
    -0.29774451f, -0.35319623f, -0.26402271f, -0.22918522f, -0.08215798f, -0.19956066f, -0.72662377f, 0.15081182f, 
    0.40644556f, -1.05660248f, 0.37857124f, -0.02477542f, 0.12166699f, -0.32767978f, 0.70507848f, 0.02040891f, 
    -0.92500019f, -0.58164811f, -0.04058458f, -0.34711054f, -0.19596455f, -0.28851879f, 0.09962311f, -0.50071168f, 
    0.81885934f, -0.48493263f, 0.33273384f, 1.06695342f, 0.12330238f, 0.01307458f, -0.08277247f, 0.36535093f, 
    -0.37474287f, 0.77021790f, -0.81609190f, 0.19905560f, -0.55453485f, 0.30912480f, -0.26715279f, 0.36110017f, 
    0.48369056f, 0.18224226f, 0.52997786f, -0.84556502f, 0.59527493f, 0.67549020f, -0.13894489f, 0.44243416f, 
    0.29705942f, -0.56467485f, 0.07211655f, -0.91801453f, 1.05795109f, -0.03991703f, 0.02514824f, 0.27728572f, 
    -0.51582235f, -0.13335821f, 0.13288993f, -0.37819126f, 0.15314011f, 0.23854885f, -0.01213681f, -0.74538422f, 
    -1.00954533f, -0.77500194f, 0.35612747f, -0.02936953f, 0.11879961f, -0.99458599f, -0.52808636f, 0.13946350f, 
    0.57815796f, 0.86105120f, -0.06553411f, -0.10982491f, 0.10156934f, -0.16705440f, 0.85825634f, 0.93616533f, 
    -0.55525619f, 0.12563728f, 0.47666124f, -0.30141705f, 0.26533794f, 0.60319585f, 0.08714341f, 0.44672713f, 
    -0.18079883f, -1.04724777f, 0.53459984f, -0.56133610f, -0.08784683f, -0.06421220f, 0.05881748f, 0.44079071f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.30647588f, -0.00063282f, 0.25169513f, 0.22387634f, 0.08123083f, 0.47399145f, 0.44145867f, 0.27547243f, 
    0.00677039f, -0.24627930f, -0.24324103f, -0.10759282f, 0.02066918f, 0.03744075f, -0.16163674f, -0.16156837f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.57104021f, 0.02104281f, 0.08550914f, -0.01253361f, 0.00018385f, 0.07184075f, -0.05225853f, 0.13315894f, 
    0.10662316f, -0.01539052f, 0.34099191f, -0.40125489f, 0.20214194f, 0.11063997f, -0.12071542f, 0.10591777f, 
    -0.17271240f, -0.13214730f, 0.12597820f, 0.20166709f, -0.04688122f, -0.08924001f, -0.05804653f, -0.05095337f, 
    0.22702999f, 0.17695852f, 0.05228153f, -0.44069469f, -0.59646881f, -0.05973950f, -0.09597035f, 0.32456917f, 
    0.11633991f, 0.12299901f, 0.02072929f, -0.22217983f, -0.09695311f, 0.17877087f, -0.02252018f, 0.22965893f, 
    0.19036686f, 0.08837123f, -0.15254132f, 0.10928920f, 0.18589313f, -0.18759197f, 0.05699454f, 0.06485731f, 
    0.06221318f, -0.02464357f, 0.13726862f, -0.03912466f, 0.05691340f, 0.10728076f, 0.10096452f, -0.04360805f, 
    -0.13208044f, 0.14047000f, -0.10882968f, 0.06357244f, 0.14925404f, -0.09654602f, 0.08907682f, -0.28186411f, 
    0.10535410f, -0.09400693f, 0.02447764f, -0.25834215f, 0.21489055f, -0.09651294f, 0.08690699f, -0.30212054f, 
    -0.04525201f, 0.29672444f, -0.07469369f, 0.05416902f, -0.34316307f, 0.15857406f, -0.01630466f, 0.23478188f, 
    0.25491050f, -0.56135565f, -0.20893750f, -0.01477284f, -0.04929254f, 0.15083905f, 0.05066925f, 0.10822295f, 
    -0.31761712f, 0.17799400f, 0.26783830f, -0.00606852f, -0.04472142f, -0.20674483f, -0.02104200f, -0.15243827f, 
    0.19454241f, 0.05321270f, 0.00014645f, -0.12621883f, -0.11260707f, 0.05993026f, 0.15518789f, 0.08725516f, 
    -0.16659722f, 0.01584473f, -0.15053131f, -0.11655344f, 0.10363982f, -0.01989556f, 0.16337880f, -0.08138504f, 
    0.16951135f, 0.13773212f, -0.17287755f, 0.17867225f, 0.35489282f, 0.01096979f, -0.12923869f, -0.36795259f, 
    0.07422256f, 0.00340195f, -0.10128507f, -0.18108729f, -0.07563687f, -0.06103942f, -0.19688171f, 0.08184607f, 
    0.23993011f, 0.04168356f, -0.00900798f, 0.05037083f, 0.05187625f, 0.08694300f, 0.09695794f, -0.66580397f, 
    0.05915182f, 0.21743919f, -0.07893933f, -0.00828237f, -0.03043527f, 0.16033536f, 0.12002774f, -0.03578650f, 
    -0.22258151f, -0.08697761f, -0.60973489f, 0.04401733f, 0.00181166f, -0.01101240f, 0.04465466f, 0.17589955f, 
    0.05758186f, 0.15861414f, 0.51283514f, -0.01175396f, 0.20073701f, 0.16306502f, -0.06085201f, 0.10506549f, 
    -0.03688458f, -0.41121334f, 0.23230729f, -0.15906975f, 0.13257946f, 0.12557930f, 0.00844103f, -0.03211312f, 
    0.13541128f, 0.14164212f, -0.03744600f, 0.06152590f, 0.47007611f, -0.25384837f, 0.12833327f, 0.00600532f, 
    -0.13634789f, 0.05041650f, 0.05329245f, 0.01596335f, -0.27149007f, -0.10432080f, -0.00953823f, 0.12438022f, 
    0.03103067f, -0.10876904f, -0.22046071f, -0.01655204f, 0.03207013f, -0.22739710f, -0.30608106f, 0.11753009f, 
    0.00063767f, -0.03431672f, 0.05988576f, -0.01201237f, -0.00244001f, 0.18601766f, -0.23586057f, 0.25361568f, 
    -0.15013470f, 0.05890287f, -0.20301419f, -0.08476806f, 0.02298957f, 0.05276881f, -0.07205612f, 0.14971337f, 
    0.45883784f, -0.18672989f, 0.13551854f, -0.00933615f, 0.12216339f, -0.03279209f, 0.05158757f, -0.04143061f, 
    0.17824531f, 0.10249425f, 0.22503507f, 0.04477024f, 0.02835896f, -0.16153719f, 0.02733032f, -0.06407433f, 
    -0.08198418f, -0.14361086f, -0.30457410f, -0.08369546f, -0.04767875f, -0.19725882f, -0.06374665f, 0.26435444f, 
    0.07795739f, 0.18626952f, 0.17300929f, -0.00614110f, 0.21245705f, 0.05361168f, 0.25126514f, -0.03164498f, 
    -0.04963813f, 0.04588116f, -0.08257857f, -0.08665470f, -0.27530307f, 0.01027660f, -0.04384358f, -0.20640254f, 
    -0.01099181f, -0.18625131f, -0.21182749f, 0.10009032f, -0.22308782f, -0.71239120f, -0.15715384f, -0.05220168f, 
    -0.00465174f, 0.02049636f, 0.06874019f, -0.08752812f, 0.03525288f, -0.19974205f, 0.28193429f, -0.04078428f, 
    -0.10144213f, 0.13685939f, -0.16580534f, 0.00958169f, 0.03198327f, 0.10328075f, 0.06503719f, -0.22534542f, 
    0.15165873f, 0.03766580f, -0.14470953f, -0.28452224f, -0.06608891f, 0.08591688f, 0.06562085f, 0.11092270f, 
    0.22374044f, -0.26475599f, 0.04643266f, -0.03180191f, 0.20233974f, -0.01622263f, 0.02827740f, 0.12790932f, 
    -0.13270575f, 0.07296570f, -0.18759876f, 0.32092938f, 0.10292634f, -0.05021504f, 0.17984420f, 0.08167021f, 
    -0.17429832f, 0.37273216f, 0.01738140f, -0.58883482f, 0.11754469f, 0.20481163f, 0.14944693f, -0.08476679f, 
    -0.15049098f, -0.02405326f, 0.23291951f, 0.29275173f, -0.00223038f, 0.06198591f, 0.05520359f, -0.16291456f, 
    0.10437980f, -0.10998223f, 0.21731192f, -0.08555961f, -0.10611811f, 0.10994869f, -0.20611385f, -0.00837964f, 
    0.08796705f, -0.13292828f, -0.08868242f, 0.09124928f, 0.24475563f, -0.11428800f, -0.04523090f, -0.26551962f, 
    0.23003842f, 0.05999374f, 0.03402271f, -0.01845752f, -0.03443231f, 0.29323071f, 0.36248538f, 0.00722824f, 
    -0.15618546f, -0.09727196f, -0.27750015f, 0.01729616f, 0.04307557f, 0.01268955f, -0.27016786f, -0.20070544f, 
    -0.10887319f, 0.11199303f, 0.06783578f, -0.08196218f, -0.15208024f, 0.10021427f, -0.05374791f, 0.09714761f, 
    -0.03590615f, -0.02561878f, -0.15899746f, -0.04164533f, -0.23320356f, 0.03902165f, 0.12390904f, -0.10812808f, 
    0.31730780f, -0.11414436f, -0.22058165f, -0.30786198f, 0.00134782f, 0.05792229f, 0.15915567f, -0.05488369f, 
    0.00824467f, 0.07309437f, -0.28445420f, 0.13520145f, 0.14995445f, 0.22914167f, -0.21386480f, 0.08910812f, 
    -0.17332189f, -0.15360495f, 0.05936757f, -0.10109947f, 0.19161439f, -0.00011359f, -0.01683039f, 0.06564788f, 
    -0.17452790f, 0.22953308f, -0.36828068f, 0.15844709f, 0.09417257f, -0.03603268f, 0.06369903f, -0.05927038f, 
    -0.31168094f, -0.08746100f, 0.01950118f, -0.10836452f, 0.21269478f, -0.01697947f, -0.06465241f, -0.09404728f, 
    0.13952348f, -0.04637552f, 0.13424873f, 0.14780214f, 0.14567441f, 0.23300052f, 0.50558394f, 0.31429356f, 
    0.13596706f, -0.02715085f, -0.01353935f, -0.16842745f, 0.03549053f, -0.09117392f, 0.23838528f, 0.20706779f, 
    -0.14826098f, -0.20378777f, 0.06753293f, -0.03494497f, 0.03024457f, 0.10445164f, 0.21354747f, -0.32470378f, 
    -0.06418533f, -0.12608612f, -0.05605384f, 0.17791530f, -0.21781324f, -0.08644188f, 0.04500397f, 0.06420385f, 
    -0.56712019f, -0.48739395f, -0.09613385f, 0.09943744f, 0.01536126f, 0.23896910f, 0.06067358f, 0.11869533f, 
    -0.25673220f, 0.36962435f, 0.17710857f, -0.39652631f, 0.18362717f, -0.20125632f, -0.10971946f, 0.06542806f, 
    -0.06144708f, -0.01963735f, -0.09174921f, 0.23628303f, 0.10016841f, -0.19746621f, 0.20437798f, -0.11229080f, 
    0.01286418f, -0.05552829f, -0.01913036f, 0.29460257f, -0.20685600f, -0.19833189f, -0.02645259f, 0.03617097f, 
    0.00909322f, -0.05129268f, -0.06085107f, 0.01471610f, -0.01996223f, 0.06284629f, 0.12193609f, -0.18688478f, 
    -0.06679533f, 0.04459863f, 0.09646162f, 0.14031881f, 0.00518480f, -0.04754971f, -0.09994466f, 0.06262850f, 
    0.05438971f, 0.13470092f, 0.02967985f, 0.08763766f, -0.11435430f, -0.10213070f, -0.08163523f, 0.22837061f, 
    -0.47614747f, 0.01278879f, 0.15950547f, 0.33531249f, -0.18833901f, -0.15776432f, 0.02280132f, 0.05526367f, 
    0.05299360f, 0.44546324f, 0.06871760f, 0.10651686f, 0.01027665f, -0.01129392f, -0.05503100f, -0.00947534f, 
    0.48811230f, -0.25232011f, -0.02063229f, 0.11282611f, 0.20036156f, -0.13176642f, -0.02828740f, -0.04239976f, 
    -0.07374549f, -0.30245504f, -0.51127791f, 0.09753305f, 0.03405043f, 0.14319059f, 0.00922689f, 0.02364551f, 
    -0.00274119f, -0.06137311f, -0.74028486f, 0.12203280f, 0.06300662f, 0.17531714f, 0.12648167f, 0.07697792f, 
    0.02316587f, 0.07947283f, 0.01056995f, 0.21961106f, -0.03244438f, -0.38008061f, 0.00851781f, 0.24941067f, 
    0.09249988f, 0.12195025f, 0.02769959f, -0.04639632f, -0.10779298f, 0.00934162f, -0.08797468f, 0.06064447f, 
    -0.04480387f, -0.01096690f, 0.05385640f, 0.04682123f, 0.31170499f, 0.11062189f, 0.03753734f, -0.06270249f, 
    0.02317355f, 0.08411746f, -0.10922379f, 0.09002440f, 0.09468889f, 0.04278280f, -0.00804846f, -0.20306253f, 
    0.07632402f, -0.20407306f, -0.10824025f, 0.16340686f, -0.14164026f, -0.02673618f, -0.07750517f, -0.43421692f, 
    -0.21413799f, -0.08476370f, -0.33707905f, 0.03181182f, -0.08683685f, -0.02738526f, -0.06240001f, -0.10879395f, 
    0.05512728f, -0.07285953f, 0.06214206f, 0.00116066f, -0.05955619f, -0.03228889f, 0.03753340f, -0.08784042f, 
    0.00185034f, 0.00257638f, 0.04262295f, 0.03903893f, -0.01565500f, -0.07182030f, -0.02203231f, 0.01152626f, 
    0.07002690f, -0.04857063f, -0.02000051f, -0.01986202f, -0.04225017f, -0.04545081f, -0.06044750f, -0.07031818f, 
    -0.07634931f, 0.07704294f, -0.07037158f, -0.03554716f, 0.07036164f, -0.04085755f, 0.03127036f, -0.05151929f, 
    -0.06613069f, -0.08791226f, 0.04274163f, 0.00477708f, 0.02521258f, -0.03091074f, -0.05240914f, -0.03432293f, 
    -0.07433882f, 0.04176130f, -0.00163069f, -0.05558857f, 0.02752812f, -0.01626709f, 0.02221298f, 0.02175546f, 
    -0.08815551f, 0.00593059f, 0.03597484f, -0.06481899f, -0.05439759f, -0.00932140f, 0.02084312f, -0.00163943f, 
    0.05977299f, -0.08640931f, -0.00508765f, -0.07356889f, -0.03179184f, 0.04894702f, -0.01941330f, 0.05048003f, 
    0.07237523f, 0.04120585f, -0.03265398f, -0.03994636f, 0.01358473f, 0.05112395f, -0.06800570f, 0.05076735f, 
    -0.08761493f, 0.01199730f, -0.01215578f, -0.07982226f, 0.05975896f, -0.05330458f, 0.02679039f, -0.02878634f, 
    -0.02539811f, -0.01058127f, -0.08522794f, 0.03362476f, -0.02998156f, 0.00517878f, 0.03509453f, -0.02781411f, 
    -0.06219314f, -0.01454101f, -0.07496199f, -0.06573880f, -0.04336339f, 0.02918003f, -0.01000051f, -0.06369928f, 
    -0.02047529f, -0.01473165f, -0.00398028f, -0.01086933f, 0.07735488f, 0.07560402f, 0.02089688f, 0.07075151f, 
    0.05812505f, 0.01480402f, -0.00336295f, -0.06562659f, -0.07304049f, -0.07550316f, -0.08775360f, 0.03816207f, 
    -0.03286168f, 0.06941014f, -0.06225020f, 0.02140169f, -0.02568852f, -0.05983604f, -0.08427419f, 0.04269997f, 
    0.07517806f, -0.08655735f, -0.07012168f, -0.01903989f, -0.06882535f, -0.02212393f, 0.02255807f, -0.04258994f, 
    0.00227898f, 0.03886565f, -0.03107284f, -0.05616373f, 0.03242835f, -0.06542931f, -0.01147674f, 0.01292429f, 
    0.01990092f, -0.00737219f, -0.04301938f, -0.02596012f, -0.06633385f, 0.04489065f, -0.01807871f, -0.02268355f, 
    0.11780307f, -0.40555593f, -0.08154721f, 0.20467530f, -0.06794791f, 0.11009563f, -0.09889739f, -0.13052027f, 
    -0.01952726f, 0.37390864f, 0.17756662f, 0.35989571f, 0.27946520f, 0.16838625f, 0.06539705f, 0.28490394f, 
    -0.04673866f, -0.05661429f, 0.10426050f, -0.15277487f, 0.06788228f, 0.04772698f, 0.20383321f, -0.14307933f, 
    0.06381501f, -0.11893966f, 0.25492400f, 0.47419670f, 0.07914766f, 0.17170471f, -0.06261066f, -0.08832706f, 
    0.12629195f, -0.16127294f, 0.06227272f, 0.01712419f, -0.11135486f, -0.13218215f, 0.07179071f, -0.16371514f, 
    0.00623139f, -0.00494297f, 0.04947761f, 0.11459628f, 0.15003297f, -0.08933493f, -0.09561144f, -0.04627185f, 
    -0.30912730f, -0.02801418f, -0.08923678f, -0.10621938f, -0.08003635f, -0.00131911f, -0.02083857f, -0.37461331f, 
    0.00340547f, 0.03134526f, -0.28841841f, 0.02486104f, -0.18495865f, 0.04276856f, -0.06151681f, 0.17746262f, 
    0.11646570f, 0.07369520f, 0.05686474f, -0.04945510f, 0.08369469f, 0.01950175f, 0.10712077f, -0.16459808f, 
    0.05925439f, 0.10848944f, -0.01554051f, -0.06133099f, -0.28770861f, -0.06331610f, 0.02684923f, 0.02460840f, 
    -0.03914019f, 0.21982823f, 0.16883075f, 0.53680372f, -0.20066902f, 0.01913237f, -0.02691148f, -0.17842939f, 
    -0.17343295f, -0.10872073f, 0.02975691f, -0.11993027f, -0.18290965f, 0.00078742f, -0.14836456f, -0.16516829f, 
    -0.00229285f, -0.10785300f, -0.00809427f, -0.03653586f, 0.10463423f, -0.24343592f, 0.01825631f, -0.13530584f, 
    0.19041859f, -0.01170367f, 0.00358763f, -0.08472615f, -0.44202596f, -0.05863512f, -0.08027412f, -0.20186767f, 
    -0.08312567f, 0.13344017f, -0.13055207f, 0.11047310f, -0.10919089f, 0.12902297f, 0.29400948f, 0.07827239f, 
    0.14277449f, -0.00421408f, 0.06871458f, 0.08813871f, -0.01101873f, 0.03980995f, -0.14090127f, 0.16040850f, 
    -0.01534009f, -0.04940164f, -0.24069840f, -0.03945289f, 0.11320513f, 0.13640751f, -0.11725648f, 0.03051407f, 
    0.15445147f, -0.16651101f, 0.07455181f, 0.12783526f, 0.06717377f, -0.11178605f, 0.02739575f, -0.08767756f, 
    0.24495676f, 0.31066164f, 0.50248408f, -0.04653656f, -0.05279468f, 0.02258916f, -0.21502537f, 0.11051656f, 
    -0.29080269f, 0.22598286f, 0.20470421f, -0.14823790f, -0.02561164f, 0.10430434f, 0.04694870f, -0.04921296f, 
    0.25990707f, -0.04026581f, -0.05208738f, 0.14115565f, -0.10964287f, 0.09078558f, -0.04168636f, -0.24176063f, 
    0.21823160f, 0.00499684f, -0.04449735f, -0.23159011f, 0.14711046f, 0.17326768f, 0.06439123f, -0.08274261f, 
    0.00085383f, 0.01690117f, 0.03957483f, 0.10036117f, -0.69146651f, -0.21030757f, 0.03079949f, -0.01040143f, 
    0.21860200f, 0.00983289f, 0.04175359f, -0.07918131f, 0.00983300f, -0.06966447f, -0.46401376f, 0.10995208f, 
    0.14883333f, 0.01726231f, 0.17451476f, -0.21951640f, -0.10171655f, 0.07691046f, -0.16208301f, -0.07020176f, 
    0.02625181f, 0.01337710f, 0.06414667f, 0.00689627f, 0.17247778f, -0.18990315f, -0.05320902f, 0.10414199f, 
    0.02548022f, -0.07954672f, 0.15120709f, 0.13852897f, -0.14808524f, 0.14112163f, -0.27828884f, -0.18836936f, 
    0.12417233f, -0.37363109f, -0.10899638f, -0.06394526f, 0.03674046f, 0.03759589f, 0.09547947f, -0.06094613f, 
    -0.04515852f, 0.05303944f, -0.08233297f, 0.11958690f, 0.00450660f, -0.08990585f, 0.05939467f, 0.04875369f, 
    0.13529971f, 0.04567107f, -0.10509975f, -0.12908700f, 0.00437915f, 0.23535973f, 0.01044614f, -0.14690381f, 
    0.08336295f, 0.03663583f, -0.05870659f, 0.14506149f, -0.05080881f, -0.23825249f, 0.12619311f, 0.26150724f, 
    0.08309246f, -0.04090929f, -0.03538128f, -0.11387154f, 0.39351898f, -0.09968346f, -0.09687844f, 0.05587978f, 
    -0.01787877f, 0.00952259f, -0.26065356f, 0.01512727f, 0.05786207f, 0.16074698f, 0.13914080f, -0.10184272f, 
    0.02732047f, 0.03174274f, -0.23472798f, -0.07337835f, 0.07733626f, 0.19165599f, -0.11230018f, -0.27544338f, 
    -0.24712227f, -0.11580819f, -0.11866573f, -0.08123681f, -0.11403171f, 0.13144813f, 0.05601843f, 0.12891166f, 
    0.15284948f, 0.02440664f, -0.09738047f, -0.17131662f, -0.00600004f, -0.00375761f, 0.03961277f, 0.21639124f, 
    0.03953557f, 0.01092860f, 0.04228715f, 0.27937266f, -0.06846847f, -0.15245090f, -0.07262167f, -0.11321817f, 
    -0.05064957f, 0.04304521f, 0.03307936f, 0.11361787f, 0.13958165f, 0.07341542f, 0.06673900f, 0.10378548f, 
    0.08322570f, -0.10334907f, -0.02549829f, 0.24227054f, -0.15471421f, 0.32420889f, 0.23576717f, -0.07276981f, 
    0.10523909f, 0.04433296f, 0.11147364f, -0.16057959f, -0.07433027f, -0.00804148f, -0.16511686f, 0.12350820f, 
    0.06868286f, 0.00569203f, -0.11736434f, 0.01782289f, -0.34872630f, -0.11888489f, 0.03647222f, 0.01764254f, 
    -0.01368466f, -0.02206944f, 0.20757684f, 0.02684407f, -0.09583998f, -0.20370549f, 0.15217432f, -0.26234785f, 
    0.13659382f, 0.06065606f, 0.09032605f, 0.21403280f, 0.07720906f, 0.04481595f, -0.04566646f, 0.00960556f, 
    -0.14048304f, 0.03545688f, 0.10655139f, 0.04697165f, 0.00958916f, 0.33942413f, 0.06569595f, 0.35276699f, 
    -0.19235022f, 0.00138434f, -0.15051538f, -0.00856636f, -0.03921161f, 0.11351065f, 0.07400564f, 0.11098595f, 
    -0.57918441f, 0.20386691f, -0.03364066f, 0.29128030f, 0.13400255f, -0.06672957f, -0.02141984f, 0.00943077f, 
    0.17947739f, -0.44433883f, -0.43323258f, 0.19273202f, 0.03886756f, -0.14543959f, -0.10889525f, 0.03952823f, 
    -0.18297708f, -0.24702980f, -0.32451639f, -0.03241215f, -0.26551664f, 0.09422269f, -0.14087614f, 0.01051662f, 
    0.06677628f, -0.00924135f, 0.05709040f, -0.19785850f, 0.11103598f, -0.11956518f, 0.11125757f, -0.42082769f, 
    -0.11632115f, 0.12085947f, 0.01879100f, -0.12548482f, 0.16095808f, -0.10724214f, 0.20367317f, -0.02259656f, 
    -0.10490625f, 0.06591769f, 0.13788825f, 0.13036996f, 0.10954682f, -0.23248661f, 0.05837395f, -0.14443019f, 
    -0.05644339f, -0.11549488f, -0.08422663f, 0.03067492f, 0.16499539f, 0.09071479f, -0.53573376f, 0.00494453f, 
    -0.15299809f, 0.16211665f, -0.10305744f, -0.12438992f, 0.06340547f, 0.00998554f, 0.02210970f, -0.04913336f, 
    -0.12208799f, -0.10637884f, -0.00746736f, 0.03517796f, 0.23400190f, 0.15935868f, 0.20469177f, -0.06659437f, 
    0.21526657f, -0.00832035f, -0.14988136f, 0.04899090f, 0.06050823f, -0.04147714f, 0.03237194f, -0.01662594f, 
    -0.13123930f, 0.09465779f, -0.12660208f, 0.51160663f, 0.15016362f, -0.12339482f, 0.29412016f, -0.07280520f, 
    -0.03219045f, 0.12622112f, -0.00154543f, 0.17628130f, 0.16763331f, -0.17278995f, 0.14023909f, 0.19625239f, 
    -0.14142454f, 0.11530360f, -0.37653762f, -0.00463892f, -0.00495536f, 0.17442523f, -0.05752472f, -0.14472097f, 
    0.14217602f, -0.23010747f, -0.07223354f, 0.14120713f, -0.04964668f, -0.05696163f, -0.29264292f, 0.03241459f, 
    -0.05160067f, 0.09349066f, -0.07035112f, -0.12441569f, -0.03884660f, -0.20815703f, 0.02447502f, -0.24643028f, 
    -0.11276440f, -0.00090459f, -0.06617103f, 0.17657524f, -0.01305031f, -0.36808771f, -0.11824280f, -0.02284337f, 
    -0.00207999f, 0.02469583f, 0.04346605f, 0.03393413f, -0.17250933f, 0.14085971f, -0.05949339f, 0.09163120f, 
    0.07518730f, 0.23532254f, -0.03002402f, -0.14547196f, 0.02445853f, 0.10951678f, -0.03378927f, 0.24724443f, 
    0.20629698f, -0.05387544f, -0.17378327f, -0.00527214f, 0.11518627f, 0.16680989f, -0.15715642f, 0.04769869f, 
    -0.15655524f, 0.23972367f, 0.09682242f, -0.03142884f, -0.08754428f, 0.18827415f, 0.06829935f, -0.03377345f, 
    0.07140580f, -0.15898721f, 0.06644822f, 0.07084589f, -0.18350884f, -0.21134454f, -0.13795364f, -0.10878580f, 
    0.16675907f, 0.03974036f, -0.35854402f, -0.04993146f, 0.31372085f, -0.16985779f, 0.09307058f, 0.04569395f, 
    0.04597752f, 0.24374169f, 0.08805855f, 0.05144068f, -0.36616093f, 0.20849539f, -0.23693761f, -0.02785992f, 
    -0.05996335f, -0.26822078f, -0.17462042f, 0.05351822f, 0.06552973f, 0.03708683f, -0.08740088f, 0.05223944f, 
    0.06362501f, -0.23936132f, 0.20066281f, 0.00560196f, 0.13035268f, 0.05359692f, -0.25194401f, 0.15731457f, 
    0.32045469f, -0.05075408f, 0.10734099f, -0.04669603f, 0.10074374f, -0.09135851f, 0.18710041f, 0.06843898f, 
    0.25877705f, 0.02310262f, -0.13343205f, 0.06590501f, -0.18624432f, -0.06140162f, 0.36880466f, -0.11969462f, 
    -0.06035703f, -0.09816369f, 0.30187464f, 0.09267531f, 0.03910065f, -0.10782206f, 0.06024412f, -0.08555863f, 
    0.07193212f, 0.07562744f, -0.07579216f, -0.03473057f, 0.18546529f, -0.09091033f, 0.18038203f, -0.05569443f, 
    -0.02853466f, 0.12554753f, -0.37492639f, 0.02671266f, 0.03599606f, 0.10747845f, -0.02451312f, 0.02825577f, 
    0.15646249f, -0.00892041f, 0.19455820f, 0.01905499f, 0.15708883f, 0.20638011f, 0.05993399f, 0.03591900f, 
    -0.10790364f, 0.05279863f, -0.07534378f, 0.08064681f, -0.23003472f, 0.24624881f, 0.16859524f, 0.11583605f, 
    0.01592883f, -0.09265964f, -0.10817410f, 0.05819919f, 0.00470090f, -0.09181398f, -0.51104361f, 0.09569098f, 
    0.15223899f, 0.04838474f, 0.00564695f, -0.02870829f, 0.04171005f, 0.00011063f, -0.32045951f, 0.14450647f, 
    -0.00504391f, -0.12139796f, -0.07402743f, -0.02215976f, -0.06496423f, -0.14927970f, 0.05970426f, 0.01999165f, 
    0.05571901f, 0.29769790f, 0.11561093f, -0.02849489f, -0.06912803f, 0.03817673f, 0.01179286f, 0.11225209f, 
    -0.08969233f, 0.00630674f, -0.48427185f, 0.01950442f, -0.09125318f, 0.01930687f, 0.09355318f, 0.01683666f, 
    0.03186743f, -0.04028300f, 0.16122249f, 0.10269427f, -0.11940958f, -0.07399064f, -0.14449315f, 0.16714360f, 
    0.02419727f, -0.03723009f, -0.01806410f, -0.04910163f, -0.49893236f, 0.08695958f, -0.01173486f, 0.03088387f, 
    0.11671838f, 0.02053683f, -0.04214353f, 0.85066456f, 0.02081262f, -0.01693599f, 0.02303473f, -0.09730468f, 
    -0.11117119f, 0.05697532f, 0.07522417f, 0.01086975f, 0.29042488f, -0.19165838f, -0.26565742f, 0.05239300f, 
    0.06473789f, -0.10849385f, 0.17443550f, 0.05395963f, -0.05737728f, -0.25457877f, 0.25286785f, -0.14644419f, 
    -0.01205041f, -0.03086317f, -0.07392958f, -0.23066373f, -0.10385168f, 0.16806707f, -0.17621996f, 0.18577000f, 
    0.08373838f, -0.03114234f, -0.02411852f, -0.09073903f, 0.02137449f, 0.04927261f, -0.10028479f, 0.09068955f, 
    0.09525096f, -0.13680057f, -0.42575398f, -0.03781441f, -0.00999796f, -0.12271177f, -0.15487644f, 0.04327370f, 
    -0.46382403f, 0.08781530f, -0.05140874f, 0.26184514f, -0.00969265f, 0.12215323f, -0.01887323f, -0.12443794f, 
    -0.10574689f, 0.04843413f, 0.00197392f, 0.14261732f, -0.09276970f, 0.22432037f, 0.10580621f, 0.04820359f, 
    -0.03290778f, 0.14509767f, -0.57337129f, -0.00204110f, 0.01819738f, -0.01722837f, 0.15688221f, 0.15003073f, 
    -0.20657219f, 0.06304692f, -0.12465434f, -0.11384065f, 0.06660493f, -0.04972333f, -0.11771537f, -0.05595967f, 
    -0.00105449f, -0.26008314f, 0.09134227f, 0.17154974f, 0.39361915f, 0.27311614f, 0.08292570f, 0.14985341f, 
    0.04190880f, 0.03295520f, 0.11051294f, 0.04130608f, 0.08267144f, 0.43933547f, -0.06993588f, -0.08281445f, 
    0.07478291f, -0.03181256f, 0.01340615f, 0.18122692f, 0.01937903f, 0.14390543f, -0.39884132f, 0.07336176f, 
    -0.02850027f, -0.11750493f, -0.02146744f, -0.04787594f, 0.02500222f, -0.00403463f, -0.13508677f, 0.05206851f, 
    0.00012715f, -0.24177074f, -0.03983643f, -0.26826590f, -0.21934830f, -0.19259387f, 0.02969814f, -0.05774330f, 
    -0.32601184f, -0.27625987f, -0.13543440f, 0.18300900f, 0.04648368f, -0.09622309f, -0.12948577f, -0.07511166f, 
    -0.04996005f, -0.08060376f, 0.16330339f, 0.03358753f, 0.19157724f, 0.03335841f, 0.01085516f, 0.04378844f, 
    0.06085050f, 0.09067094f, -0.25242615f, -0.12904239f, -0.19472471f, 0.01248898f, 0.12009244f, 0.18780062f, 
    -0.05942068f, -0.04720750f, -0.13797389f, 0.59740233f, -0.12904494f, -0.15240073f, -0.06735825f, 0.00849566f, 
    0.09304386f, -0.13467050f, -0.08292490f, 0.19091000f, 0.11476707f, -0.01072068f, -0.04498114f, 0.09207521f, 
    -0.15208186f, 0.20648579f, 0.05825951f, 0.06971337f, -0.04781558f, -0.12971839f, -0.01622647f, 0.15622850f, 
    -0.12008179f, 0.06574574f, -0.00051812f, -0.15356319f, 0.00216583f, -0.00772640f, 0.11836571f, 0.17594640f, 
    -0.05714780f, 0.09917883f, 0.07144736f, 0.22399689f, -0.01054407f, -0.07755018f, -0.12216698f, 0.31343010f, 
    -0.08335248f, -0.13711606f, 0.16194732f, -0.14863160f, -0.18612590f, 0.09273785f, 0.29534230f, -0.14909483f, 
    0.04148144f, -0.04874774f, -0.17649424f, 0.15968515f, 0.10736536f, -0.22710104f, 0.14640331f, 0.06441131f, 
    -0.18444239f, -0.48726991f, -0.08544633f, -0.45404357f, 0.14077343f, 0.13942719f, -0.06102464f, -0.06044222f, 
    -0.10875992f, -0.09089293f, 0.27468768f, 0.17083803f, 0.15957268f, 0.31162462f, 0.25273123f, 0.17918971f, 
    0.18524896f, -0.18708007f, 0.07314470f, -0.26862928f, 0.12956363f, -0.31379905f, 0.25009513f, -0.09015791f, 
    0.14242463f, 0.01743899f, 0.01912733f, -0.00215144f, 0.03584857f, 0.26780620f, 0.44273043f, 0.17043181f, 
    0.28516468f, -0.02532296f, 0.03708800f, -0.02951255f, -0.18878147f, -0.03035689f, 0.32623759f, 0.45106840f, 
    -0.14210579f, 0.00418198f, -0.01695401f, 0.24963032f, 0.04804054f, 0.15128842f, -0.19143571f, -0.09571626f, 
    -0.06264355f, 0.07901813f, 0.15104170f, 0.15116930f, 0.13630186f, -0.11219834f, -0.05181452f, -0.01566201f, 
    0.11871141f, -0.10468721f, -0.05728189f, -0.01941255f, 0.00843949f, 0.08661491f, -0.03860832f, 0.04795230f, 
    -0.23680037f, -0.17539421f, -0.14289795f, 0.02607787f, 0.05227690f, -0.05936071f, -0.02041190f, -0.02873740f, 
    -0.03027095f, -0.03919091f, -0.11599052f, -0.16259274f, -0.16434886f, -0.02365301f, -0.08703598f, -0.14195025f, 
    0.08930373f, 0.01795002f, -0.31981903f, -0.22743584f, -0.37557742f, -0.05981388f, 0.02671125f, 0.17549218f, 
    -0.03959619f, -0.09754429f, -0.00911715f, 0.02712940f, 0.12112927f, 0.07846892f, -0.09911440f, 0.19496053f, 
    -0.01702289f, -0.00815983f, -0.09309740f, 0.05819917f, 0.07020013f, 0.14973928f, 0.08265065f, 0.01903320f, 
    0.24695066f, -0.00196394f, 0.11485901f, 0.13935457f, 0.12394792f, -0.28832826f, -0.12364115f, -0.35567153f, 
    0.03298905f, 0.09610581f, 0.07368273f, 0.01955210f, 0.15416811f, -0.21735255f, -0.26715162f, 0.02694169f, 
    -0.06288130f, -0.19187771f, -0.28946501f, -0.19444481f, -0.00988883f, 0.06656980f, -0.12177153f, -0.01922915f, 
    -0.26739594f, -0.06018353f, 0.07911399f, -0.06937402f, -0.02077287f, -0.08868606f, -0.00541447f, -0.00914208f, 
    -0.15397632f, 0.14242622f, 0.05507666f, 0.05610434f, 0.00441224f, -0.00219711f, -0.11256209f, -0.05739551f, 
    0.03713534f, 0.36933184f, 0.34355295f, -0.08042069f, -0.21825856f, -0.19759122f, -0.05524296f, -0.14056920f, 
    0.34905571f, 0.03978582f, -0.14156298f, -0.12956364f, -0.12514000f, 0.00930964f, 0.08652281f, 0.05061353f, 
    0.08171972f, 0.26149359f, 0.09062835f, -0.04332120f, -0.01275561f, 0.01083751f, -0.00215095f, -0.02932265f, 
    0.08460685f, 0.19047056f, 0.04978708f, -0.07519174f, -0.64395487f, -0.41268447f, 0.06968375f, 0.25578785f, 
    0.14969802f, 0.24786115f, -0.24311303f, 0.20441261f, -0.20207635f, -0.24539737f, -0.18923970f, 0.02652947f, 
    0.30286396f, 0.18422472f, 0.09242745f, -0.14157118f, -0.16447011f, -0.05919623f, 0.11076859f, 0.15645038f, 
    -0.19901790f, -0.06021223f, -0.17925413f, 0.01018211f, 0.26470411f, 0.14267282f, 0.12398591f, -0.15785320f, 
    -0.15195626f, -0.10059062f, 0.07634009f, 0.07717612f, 0.09384877f, -0.00262996f, -0.15963520f, -0.04320327f, 
    -0.25523019f, -0.07473341f, -0.16754729f, 0.14820723f, 0.15754382f, -0.06814528f, 0.08867083f, -0.06009641f, 
    0.02933472f, 0.22229220f, 0.10777397f, -0.05170638f, 0.09811642f, -0.10032994f, 0.05093516f, 0.09747751f, 
    0.09579340f, -0.10737536f, -0.46848997f, -0.10533039f, -0.03392912f, 0.05621273f, 0.01444651f, -0.24069700f, 
    0.01973628f, 0.02943759f, 0.04916088f, 0.33093572f, -0.35112017f, -0.28815514f, -0.05823113f, -0.16651453f, 
    0.02578634f, -0.07189441f, -0.03376726f, -0.02341984f, 0.30647302f, 0.10931687f, 0.12128707f, 0.17466377f, 
    0.08117664f, 0.09839664f, -0.01500235f, 0.05731362f, 0.13107097f, 0.49874726f, 0.37462917f, 0.05834862f, 
    -0.20567408f, 0.09455261f, -0.13155648f, 0.09341113f, 0.05773924f, -0.06000591f, -0.25278246f, -0.29601428f, 
    -0.12401695f, -0.19427244f, -0.02431470f, 0.10926446f, 0.05976827f, -0.14023952f, 0.01551294f, 0.32025114f, 
    -0.12413067f, 0.19185822f, 0.09661863f, -0.01641646f, -0.06521093f, -0.07604861f, 0.11551306f, 0.05526891f, 
    -0.26315057f, 0.30838430f, -0.24889232f, -0.13740075f, -0.05286432f, 0.15824103f, 0.00220668f, -0.00926641f, 
    0.14588158f, 0.01817344f, -0.11059999f, 0.04102002f, 0.13759601f, 0.13352735f, 0.01553927f, -0.17690714f, 
    0.07111934f, 0.04355624f, -0.06611086f, -0.21283953f, -0.04242833f, 0.15947881f, 0.05623524f, 0.08806738f, 
    -0.05091671f, 0.04523310f, -0.09312458f, -0.18039097f, 0.14422718f, -0.35761744f, 0.14808521f, 0.05232456f, 
    0.03143154f, -0.04762996f, 0.02360328f, 0.22402498f, 0.09150553f, 0.11496893f, 0.21932623f, 0.15315758f, 
    -0.01634649f, -0.17837678f, -0.04163418f, -0.15316378f, 0.11546773f, -0.04475623f, 0.39439148f, -0.09152400f, 
    0.20049992f, 0.18472821f, -0.10457298f, -0.10196410f, -0.12842911f, 0.17404808f, 0.40931571f, 0.06499469f, 
    0.18864888f, -0.12206192f, -0.20948051f, 0.20546019f, 0.01013239f, 0.15701480f, -0.17797701f, 0.17537542f, 
    0.27564773f, -0.30690479f, 0.00612449f, 0.04627801f, -0.04770289f, 0.11231749f, 0.04361929f, 0.18684919f, 
    -0.11564422f, 0.35251203f, -0.36541039f, 0.05335411f, -0.01120924f, 0.11553541f, 0.08735886f, 0.02273070f, 
    -0.00690209f, 0.07657141f, -0.06808748f, -0.29810545f, 0.08290897f, -0.04049711f, 0.01635295f, 0.08371362f, 
    0.20928420f, -0.04175556f, 0.49520841f, -0.06687471f, -0.50011784f, 0.16092484f, -0.11244938f, 0.18655145f, 
    -0.10333671f, -0.16545127f, -0.12869406f, 0.20993005f, -0.17417344f, -0.03667266f, -0.23163418f, -0.15925929f, 
    -0.10298098f, -0.07793318f, -0.07870109f, 0.27527669f, 0.18292034f, 0.24401663f, -0.03356908f, 0.00589897f, 
    -0.30400503f, -0.02281593f, 0.11973135f, 0.05919258f, 0.07120162f, 0.24025263f, -0.37414625f, 0.03209214f, 
    -0.05317910f, -0.12223285f, 0.16297837f, -0.01802471f, -0.00954298f, -0.11235550f, -0.52597445f, 0.13177674f, 
    0.24963997f, -0.03148393f, 0.04157341f, 0.05715085f, -0.19053613f, 0.17179479f, -0.10614584f, 0.10016342f, 
    0.05697360f, 0.22782560f, 0.20948210f, -0.18480898f, 0.06116733f, 0.17493546f, -0.20868325f, -0.04778323f, 
    0.01848598f, 0.12565739f, -0.30323589f, 0.07683052f, 0.06223195f, 0.07326905f, 0.14423695f, -0.21469957f, 
    0.02496919f, 0.28162420f, 0.05260082f, 0.35040799f, -0.21672373f, -0.12020992f, 0.19481847f, 0.03359049f, 
    0.03484370f, 0.04969873f, 0.08879012f, 0.10813861f, 0.10299791f, -0.05626470f, -0.04699276f, -0.03240704f, 
    -0.06668111f, 0.23883523f, -0.10943265f, -0.35501894f, -0.33594343f, -0.06224081f, 0.08365697f, 0.11325420f, 
    -0.04364447f, 0.01752688f, -0.14382802f, 0.11062441f, -0.11125771f, 0.09613661f, -0.05324731f, 0.24894728f, 
    0.02554458f, 0.10097946f, 0.15429199f, 0.02651745f, 0.12808107f, -0.04076204f, -0.03961078f, 0.18411906f, 
    0.08634231f, 0.10818137f, -0.09888711f, -0.05447156f, -0.01030000f, 0.05949082f, -0.17686404f, -0.41941792f, 
    -0.08546140f, -0.00095952f, -0.01927345f, -0.04238923f, -0.07812340f, 0.01137284f, 0.14430803f, 0.13132742f, 
    0.26784536f, 0.22236143f, 0.12592489f, -0.24864981f, -0.01198106f, 0.03885976f, 0.16169752f, 0.00189327f, 
    0.20708892f, 0.01934543f, -0.06002877f, 0.04405767f, -0.04078103f, 0.08941807f, 0.16314030f, -0.03124429f, 
    -0.13231722f, 0.32267013f, 0.00248100f, -0.35644740f, 0.08584593f, 0.13694638f, -0.00230769f, -0.11882750f, 
    0.00747574f, -0.22244136f, 0.46170706f, 0.25751555f, 0.03802276f, -0.08714128f, -0.07390203f, -0.00766442f, 
    0.13794470f, 0.13418825f, -0.10266100f, -0.23325138f, -0.51743388f, -0.63123631f, 0.05282838f, 0.09178724f, 
    -0.15011524f, -0.07945434f, 0.07203856f, 0.03874991f, 0.05200841f, 0.00202849f, -0.50641578f, 0.07765087f, 
    0.13340190f, -0.12718980f, 0.13551146f, -0.00242113f, -0.10426976f, -0.19566801f, -0.35325170f, 0.02733228f, 
    -0.18743341f, 0.01868155f, -0.03827745f, 0.05060365f, -0.03154323f, 0.13133121f, 0.28197286f, 0.31467149f, 
    -0.35685849f, -0.08931845f, 0.06008585f, -0.03161892f, -0.00346908f, 0.03840122f, 0.04412505f, -0.13537639f, 
    0.39037660f, 0.14463343f, -0.03553896f, 0.12705773f, -0.12397956f, -0.08391844f, -0.11599891f, 0.04587473f, 
    0.08877588f, -0.20905748f, -0.24413832f, -0.20138855f, 0.17090909f, 0.16909808f, -0.08829258f, 0.11627291f, 
    -0.06969708f, -0.47057801f, 0.28539285f, -0.50782311f, -0.06567972f, 0.05872019f, -0.06074232f, 0.10976152f, 
    -0.10096176f, -0.02707160f, -0.02788592f, -0.09502639f, 0.14674273f, -0.16324566f, 0.01270644f, -0.09026878f, 
    0.15197285f, -0.08062038f, 0.09596070f, 0.13930671f, -0.07049982f, 0.04571795f, -0.07150200f, 0.10524062f, 
    0.10490670f, 0.07229644f, 0.02339816f, -0.00143123f, 0.49287340f, 0.35816079f, 0.23040795f, -0.07189424f, 
    0.05701659f, 0.06610475f, -0.02477277f, 0.22489960f, 0.06259999f, 0.35760581f, 0.18173581f, 0.00026968f, 
    -0.10785785f, -0.08773012f, -0.00841834f, 0.00035379f, -0.13261466f, 0.08952313f, 0.20752276f, 0.06383377f, 
    -0.22469154f, 0.02783993f, 0.02785774f, -0.00031556f, 0.00711816f, -0.11788805f, 0.03392284f, -0.03400990f, 
    0.00014506f, -0.58804101f, -0.22174850f, 0.13474704f, -0.12377392f, -0.00656495f, 0.22405063f, -0.13834248f, 
    -0.36045137f, -0.30352935f, 0.01558101f, -0.01800071f, 0.13851169f, -0.04921304f, 0.07517077f, 0.08842082f, 
    -0.07925002f, -0.08609157f, 0.07104328f, 0.01435543f, -0.01315742f, -0.05396242f, 0.11572371f, -0.00368279f, 
    -0.03530295f, 0.03624419f, -0.08715936f, -0.11522844f, 0.19851010f, -0.02480050f, 0.20190603f, 0.17683508f, 
    0.23690552f, -0.05453938f, 0.09071968f, -0.50656486f, -0.21357559f, 0.00415905f, 0.06159976f, 0.10499783f, 
    -0.20786853f, 0.01965127f, 0.09085464f, -0.02495352f, 0.13226195f, 0.21781412f, -0.29315093f, 0.02337265f, 
    -0.04450854f, 0.01238109f, 0.06892267f, -0.05350684f, 0.15110384f, -0.20792693f, -0.33887565f, -0.31713659f, 
    0.05142538f, 0.12247459f, -0.12265491f, 0.00902268f, -0.09900477f, 0.05983618f, 0.46013403f, -0.10637195f, 
    0.33654422f, -0.08074516f, 0.05171913f, -0.08733302f, -0.08183673f, -0.00748265f, 0.11072674f, -0.23896900f, 
    0.08924261f, -0.21350259f, 0.02551970f, -0.00677223f, -0.24407476f, 0.13695170f, -0.33078426f, 0.08206668f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20305237f, -0.04256950f, -0.01921007f, 0.06628261f, -0.02164715f, -0.13707745f, -0.17182693f, 0.39421502f, 
    -0.02888411f, -0.10462745f, -0.01453062f, 0.18959193f, 0.06750618f, 0.34695038f, 0.09632981f, 0.07626553f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09474513f, 0.27127776f, 0.36390728f, 0.12121106f, 0.19201222f, 0.42076325f, 0.37402526f, 0.00331097f, 
    0.16475412f, 0.18218154f, -0.05968677f, 0.52918071f, -0.37245351f, -0.50661236f, -0.10298339f, 0.01730682f, 
    -0.25540417f, -0.06411441f, -0.01930448f, -0.00443927f, -0.02743736f, -0.00513855f, 0.19232209f, -0.23667672f, 
    0.06616669f, 0.09894937f, 0.03640730f, -0.23675776f, -0.17854157f, -0.18043049f, -0.19868205f, 0.01478993f, 
    0.26437280f, -0.31846958f, -0.01512275f, -0.67081726f, -0.20773748f, -0.53613788f, -0.04836662f, -0.11872899f, 
    0.43692169f, -0.07975021f, -0.39634830f, 0.38569176f, 0.15171063f, 0.46370909f, 0.15270755f, -0.14467931f, 
    0.03208153f, -0.42362469f, -0.15265654f, -0.58902752f, 0.23669645f, -0.28941214f, -0.03682650f, -0.11871795f, 
    0.12680049f, -0.07213529f, -0.03657654f, 0.20968994f, 0.41857776f, 0.46366706f, -0.33065087f, 0.39344075f, 
    -0.12896118f, 0.85340565f, 0.27780086f, -0.14319333f, -0.09117032f, -0.00185526f, 0.41223079f, 0.22586307f, 
    0.28148219f, 0.31834462f, 0.03571041f, -0.07653214f, 0.13277946f, -0.42034456f, 0.17461738f, -0.26840249f, 
    0.40648162f, 0.10056436f, -0.39714926f, -0.58874470f, -0.20988178f, -0.25842616f, 0.17940950f, -0.01025410f, 
    -0.52797568f, -0.36611080f, 0.17741947f, -0.03688674f, 0.23047233f, 0.57003874f, 0.06205413f, 0.47608435f, 
    0.37135914f, 0.18242987f, 0.02911983f, -0.05598144f, 0.05961033f, -0.09636297f, -0.07541100f, 0.03153162f, 
    0.16903290f, 0.21438359f, -0.21277045f, 0.31350389f, -0.32957530f, 0.09753816f, 0.47169396f, -0.24482501f, 
    0.03876320f, 0.19647725f, 0.16115879f, -0.24298124f, -0.01218894f, 0.16137812f, -0.10036829f, -0.39475200f, 
    -0.26000553f, -0.22042407f, -0.00394166f, -0.04623065f, -0.21076554f, -0.07959168f, -0.22104935f, -0.19306652f, 
    0.01930771f, -0.19428931f, -0.21904990f, -0.20036824f, -0.06185654f, -0.16910918f, 0.11182311f, -0.04085817f, 
    -0.23854218f, -0.12506722f, 0.16475746f, 0.15201867f, -0.22054996f, -0.26050535f, 0.13115035f, -0.01614811f, 
    -0.16732982f, 0.42687386f, 0.07189766f, -0.65874124f, 0.12537889f, -0.48922053f, 0.02928539f, -0.54689723f, 
    0.35617399f, 0.60405755f, 0.40645072f, 0.16143063f, -0.17849226f, 0.38857180f, 0.34216693f, 0.10230262f, 
    0.06719533f, -0.17942165f, 0.14770627f, 0.37266305f, 0.24059542f, -0.13383299f, 0.07493744f, 0.22013107f, 
    0.30926648f, -0.81940973f, -0.36123118f, -0.05392044f, 0.32335365f, -0.15775177f, 0.56427026f, -0.20266975f, 
    -0.16472512f, -0.74491668f, 0.08157831f, -0.02804380f, -0.09781246f, -0.43067434f, 0.01816033f, -0.28957343f, 
    0.57828104f, 0.33079648f, -0.04633444f, 0.27955523f, 0.30875555f, 0.29473218f, 0.12769413f, 0.05626018f, 
    -0.16177030f, -0.30672812f, -0.31027311f, -0.18640506f, -0.21672484f, -0.56544715f, -0.09457377f, 0.25182569f, 
    0.09674820f, 0.32988101f, 0.16249245f, 0.73133099f, -0.18866432f, 0.52066886f, 0.01114801f, 0.20895447f, 
    -0.21260355f, 0.38746950f, 0.31794232f, -0.02135091f, -0.20870534f, 0.59610444f, -0.06556083f, 0.33725780f, 
    0.37906668f, 0.56130755f, 0.42317539f, -0.00203813f, -0.20842046f, -0.10565460f, -0.32378268f, -0.19433582f, 
    0.01516624f, 0.26424193f, 0.08352908f, -0.05993392f, 0.11541717f, 0.04675886f, -0.35226247f, 0.36201879f, 
    0.51271862f, 0.24690054f, 0.29892945f, 0.42137018f, -0.23545904f, 0.21001874f, -0.32809582f, -0.36076877f, 
    0.44882011f, -0.30048895f, -0.16860233f, 0.35756403f, -0.24696235f, 0.31483555f, 0.60259694f, 0.14314175f, 
    -0.54980487f, 0.45176876f, -0.14543000f, 0.23902403f, 0.00018425f, -0.08438376f, -0.51937330f, 0.36849433f, 
    0.04538327f, 0.34052709f, 0.14446342f, 0.78389961f, 0.19815804f, 0.21469218f, -0.40744811f, -0.31492290f, 
    -0.04794373f, -0.60326660f, -0.11385562f, -0.01397876f, -0.11135934f, -0.12891147f, 0.36220714f, -0.34617478f, 
    -0.07757974f, 0.31080619f, 0.18732648f, 0.17090039f, -0.20285894f, -0.36232525f, 0.50567764f, 0.46388969f, 
    -0.17845905f, 0.38473436f, 0.46410632f, -0.25458968f, 0.18316090f, 0.00795285f, -0.56414402f, -0.29238510f, 
    0.02706790f, -0.18923661f, 0.33572671f, 0.63924158f, -0.08352738f, 0.26303896f, 0.40451559f, 0.71153873f, 
    0.15494889f, -0.32732919f, -0.23635501f, -0.29959771f, 0.23379225f, 0.11955276f, -0.29624265f, -0.58622360f, 
    0.16270520f, 0.34046668f, -0.44339988f, 0.25541174f, 0.18658194f, 0.09724726f, 0.15572952f, 0.05098026f, 
    -0.53714991f, -0.05795305f, -0.38110712f, 0.25212467f, 0.24917217f, 0.10012475f, 0.15391381f, 0.38352358f, 
    -0.55523950f, -0.30743700f, -0.58691841f, 0.12930384f, 0.22911978f, -0.10842287f, -0.33277330f, 0.54639024f, 
    0.11870872f, 0.32879940f, 0.26826754f, -0.02374817f, 0.19266422f, 0.41886252f, 0.52470070f, -0.49027607f, 
    0.06530294f, 0.42856091f, -0.26935872f, -0.36108837f, 0.23178490f, 0.20634560f, 0.57305902f, 0.57432455f, 
    -0.30085164f, 0.08785818f, 0.75226402f, 0.24122235f, 0.13775527f, -0.01673183f, -0.34989446f, 0.35095051f, 
    0.11456195f, 0.37038323f, -0.20081091f, -0.37937412f, -0.15319896f, -0.29776201f, 0.49512634f, -0.37530372f, 
    -0.09573306f, 0.52971292f, -0.00398916f, -0.38979092f, 0.53489840f, -0.25446409f, 0.43514767f, 0.37919706f, 
    0.20425911f, -0.22946104f, 0.38187885f, 0.47095442f, 0.11622620f, 0.93752164f, -0.12691221f, 0.30070981f, 
    -0.15032570f, -0.24621193f, -0.43543696f, 0.11515237f, 0.05770518f, -0.13389343f, 0.29290116f, -0.08182225f, 
    -0.13824885f, -0.13112287f, -0.51098996f, 0.22984652f, -0.12170497f, -0.29047179f, 0.09087493f, 0.14428921f, 
    -0.36497891f, 0.01943922f, 0.73203355f, -0.11471862f, 0.52252400f, 0.08239774f, 0.10611007f, 0.59819525f, 
    0.06378123f, -0.13292654f, 0.16495715f, -0.00086661f, -0.17564508f, 0.36699796f, 0.41251123f, 0.17640057f, 
    0.15581053f, -0.08421583f, 0.70358586f, -0.33210963f, -0.03770937f, 0.06358019f, -0.59968215f, 0.04977211f, 
    0.26435399f, 0.24906781f, 0.06446025f, 0.54948401f, 0.07013974f, -0.02071136f, 0.11063900f, -0.15797742f, 
    -0.41365397f, -0.28948808f, -0.13833721f, -0.28857324f, 0.35865247f, -0.17622027f, 0.48950666f, 0.20910774f, 
    0.16053936f, -0.40581003f, 0.12314607f, -0.56229216f, -0.03481671f, 0.10047384f, 0.34909755f, 0.23047099f, 
    0.09140780f, -0.61587870f, -0.19031991f, -0.24443740f, -0.16683203f, 0.52996433f, -0.25612479f, 0.52652848f, 
    -0.00722913f, -0.62856495f, 0.51799691f, 0.76294667f, -0.01768324f, 0.46600747f, -0.35253358f, 0.37262374f, 
    0.23906599f, -0.16484796f, -0.08636255f, 0.58257765f, -0.22554088f, -0.01171789f, -0.27644658f, 0.00142903f, 
    0.06879818f, -0.14024958f, -0.03079665f, 0.00258705f, 0.17005256f, -0.12168154f, -0.08089155f, -0.10368586f, 
    0.04719105f, -0.20391092f, -0.10835554f, -0.18681499f, -0.21129444f, 0.00837773f, -0.13701802f, -0.08121899f, 
    0.39454606f, 0.21955675f, -0.22717224f, -0.36281592f, -0.21691719f, 0.46216795f, 0.35862631f, 0.04366628f, 
    0.18127117f, 0.28905675f, -0.26276907f, -0.49591964f, 0.52831364f, -0.14217205f, 0.09452042f, 0.06515985f, 
    -0.11983849f, 0.41436157f, 0.12434079f, -0.18770948f, -0.08609454f, 0.75715321f, 0.22793944f, -0.20582940f, 
    0.12065989f, -0.00580136f, -0.64086819f, 0.05718455f, -0.21413465f, 0.15299892f, -0.28072494f, -0.18387647f, 
    -0.13055509f, -0.29190543f, 0.13223706f, 0.37664244f, 0.17056167f, 0.30877790f, -0.05351363f, -0.47872555f, 
    0.01451476f, 0.81776875f, 0.40226081f, 0.18486527f, -0.27618167f, 0.45857680f, 0.00031562f, 0.16015850f, 
    -0.02710825f, 0.08138498f, -0.00594023f, -0.14795087f, 0.20587450f, -0.27466655f, -0.11858664f, -0.20336713f, 
    0.03462679f, -0.00195957f, -0.10168652f, -0.00164956f, 0.10451468f, -0.23740061f, -0.11383875f, -0.22458176f, 
    0.39063704f, 0.37076116f, -0.44193852f, 0.31196365f, 0.18326595f, -0.56009483f, 0.45953381f, -0.20607032f, 
    0.00082297f, -0.42059812f, -0.00170350f, 0.10499460f, 0.22935645f, -0.11357263f, -0.29773539f, -0.16858952f, 
    -0.63754827f, -0.30972257f, -0.90443468f, 0.17731747f, -0.12464394f, 0.18077756f, 0.06125743f, 0.33835891f, 
    0.37313733f, 0.29242170f, 0.61101979f, 0.14608331f, 0.35142806f, -0.04453654f, -0.05881842f, -0.51660359f, 
    0.67005092f, 0.48251316f, 0.11748922f, -0.23388110f, -0.03136665f, 0.55324715f, 0.04055014f, 0.26085424f, 
    -0.07933933f, 0.16293372f, -0.39952329f, 0.47984579f, -0.36300576f, 0.05146110f, 0.02853208f, -0.41212285f, 
    0.56305927f, 0.01481247f, -0.34022456f, 0.50253808f, 0.15341999f, 0.37173539f, 0.07934274f, -0.05154805f, 
    -0.27186027f, -0.30039608f, 0.15558265f, -0.21252948f, -0.01631581f, -0.22254133f, 0.84018832f, 0.18490508f, 
    -0.11592831f, 0.06775269f, 0.35033736f, 0.24057239f, 0.09417980f, -0.20000909f, -0.60902232f, 0.44476840f, 
    0.34402841f, -0.38515857f, 0.46408257f, -0.02395998f, -0.09952920f, 0.22738898f, 0.17361046f, -0.44369659f, 
    0.13369729f, -0.06912874f, 0.23400964f, 0.50381953f, 0.03276191f, 0.30036506f, -0.19621509f, -0.39557505f, 
    -0.13322985f, -0.35779753f, -0.10866020f, 0.35269141f, 0.26985759f, -0.37999460f, -0.22687535f, 0.64903224f, 
    0.57685959f, 0.28885704f, -0.48390809f, 0.15019721f, 0.05456990f, -0.29638556f, -0.00177706f, 0.45245868f, 
    0.01442331f, 0.03302554f, 0.27637663f, -0.27922532f, 0.23143840f, -0.01562351f, 0.00377921f, -0.46892691f, 
    -0.37799937f, -0.12929355f, 0.22314523f, 0.50552297f, -0.22381714f, 0.65493429f, -0.43969977f, 0.12597039f, 
    0.14308970f, -0.00360664f, 0.37905762f, 0.54684204f, -0.02394787f, 0.11695340f, -0.02329089f, 0.12323046f, 
    -0.02239889f, -0.50462043f, 0.12797315f, -0.46200749f, -0.10917279f, -0.40025863f, -0.08613791f, -0.10517910f, 
    0.13607520f, 0.68379551f, -0.23418567f, 0.21476673f, 0.04154680f, 0.41974199f, 0.22485745f, -0.36551625f, 
    0.38839963f, 0.13258581f, 0.28919688f, -0.49940419f, 0.05859232f, -0.14814347f, 0.58435893f, 0.16956781f, 
    -0.05320115f, -0.03272033f, -0.02837049f, -0.26041174f, 0.00694425f, 0.04789241f, -0.32329896f, 0.43356502f, 
    -0.00346029f, 0.31297535f, -0.57602972f, -0.16309845f, 0.23177677f, 0.38027781f, 0.55049521f, 0.09839419f, 
    0.45144156f, -0.13144626f, 0.13397571f, -0.37029278f, 0.53979737f, -0.19184357f, 0.13152872f, -0.15335543f, 
    0.41796842f, 0.43651262f, 0.40988770f, 0.52938193f, -0.24880604f, 0.80708647f, 0.28597695f, -0.16783938f, 
    0.20622350f, -0.29529971f, -0.59741086f, 0.34419233f, -0.30369070f, 0.06715881f, 0.13305520f, -0.41359025f, 
    0.36234713f, 0.33305353f, -0.15494765f, 0.31995535f, 0.04765989f, 0.33749631f, 0.30638206f, -0.01895824f, 
    0.31441870f, 0.61350983f, -0.30345657f, 0.71709114f, -0.25322735f, -0.17235020f, -0.13020630f, -0.18714000f, 
    -0.04148066f, 0.18528371f, 0.43561271f, 0.71676743f, -0.11322296f, -0.31590384f, -0.12556808f, 0.00285941f, 
    0.47377232f, 0.40204290f, 0.57536763f, -0.23156825f, 0.20197761f, 0.01088201f, -0.36199245f, -0.18989146f, 
    -0.58188885f, 0.08210989f, 0.17137820f, 0.05941668f, 0.06051205f, 0.18296844f, 0.13831085f, 0.52238250f, 
    0.12009016f, 0.67785329f, 0.52595848f, 0.10160057f, 0.07658043f, 0.07545558f, -0.40602466f, -0.51656199f, 
    -0.26272500f, 0.97325259f, -0.35335004f, -0.11191552f, 0.09772874f, -0.12089473f, 0.34770772f, 0.15774298f, 
    0.28433621f, 0.46111667f, 0.53628790f, 0.02284282f, 0.07241618f, -0.12072819f, 0.31697485f, -0.06998924f, 
    -0.42102206f, 0.09824903f, 0.44306460f, 0.16095500f, 0.21727376f, 0.31602600f, 0.51913244f, 0.13040546f, 
    0.20638157f, 0.02891060f, 0.36918220f, -0.42478210f, -0.22302227f, -0.07448609f, 0.04728474f, -0.29301116f, 
    -0.19064981f, -0.11878201f, -0.13911867f, -0.02055848f, 0.00945500f, -0.10939214f, -0.06750336f, -0.15868127f, 
    0.03206456f, 0.20867983f, 0.07694441f, -0.03221568f, -0.13711256f, -0.07791537f, -0.02617237f, -0.13149220f, 
    -0.05351166f, 0.15748009f, -0.19677983f, -0.24556303f, 0.05341158f, 0.33427280f, 0.41019264f, -0.34431624f, 
    0.39639825f, 0.75920391f, -0.14092053f, 0.42957291f, 0.35551283f, -0.30923051f, -0.07984492f, -0.24572560f, 
    0.42764196f, -0.04987731f, 0.19021036f, -0.42512190f, -0.22717179f, 0.44314080f, 0.59473240f, 0.36493027f, 
    -0.52522993f, -0.24530886f, -0.64949429f, 0.37527975f, -0.32673618f, 0.25347733f, -0.14803730f, 0.02975781f, 
    -0.28742000f, 0.01629585f, -0.25054479f, -0.26837003f, -0.23337916f, -0.19335176f, -0.06124355f, 0.13673024f, 
    -0.20300439f, -0.13087356f, 0.16410266f, 0.04630319f, 0.07958046f, -0.17887764f, -0.14428629f, 0.00708090f, 
    -0.20165391f, 0.20348777f, 0.24383590f, -0.25920507f, 0.17075446f, -0.37272209f, 0.03703710f, -0.07190581f, 
    -0.08688688f, -0.61480993f, -0.04455258f, -0.18761855f, 0.15173434f, 0.40044069f, 0.67881328f, 0.46232498f, 
    0.03919934f, -0.04103989f, -0.08910481f, 0.11336508f, -0.15468672f, -0.09833486f, 0.08306340f, -0.22428232f, 
    0.06261570f, 0.03609694f, -0.24379930f, -0.08815878f, 0.16209386f, -0.26916233f, -0.00441298f, -0.22343680f, 
    -0.39599568f, 0.31173906f, 0.10257274f, 0.17764218f, -0.19132310f, 0.16207975f, 0.07982872f, -0.29067683f, 
    -0.29171386f, -0.75935614f, -0.17179838f, -0.02804227f, 0.37989736f, 0.11325463f, 0.51471889f, 0.52410758f, 
    -0.39671868f, -0.21502215f, 0.33672991f, 0.74466550f, -0.01088851f, -0.12087930f, -0.11414613f, 0.21293074f, 
    -0.05531206f, -0.22580351f, 0.48919219f, -0.50411093f, 0.56645453f, -0.15313455f, 0.43757713f, -0.01618652f, 
    -0.07701123f, 0.14135076f, 0.12367957f, -0.53350353f, -0.15089837f, -0.41835716f, -0.26181245f, 0.04638863f, 
    -0.06175872f, -0.39516729f, 0.00033720f, 0.31123176f, 0.44400230f, 0.32328114f, 0.23337770f, -0.23022927f, 
    -0.09112950f, -0.02042243f, 0.11855604f, 0.15820451f, -0.14942440f, 0.20365803f, -0.06379182f, 0.09015759f, 
    -0.22727662f, 0.07534596f, -0.25317860f, 0.10916407f, -0.19143541f, -0.14573118f, -0.17509878f, -0.34910250f, 
    -0.15383835f, -0.60567486f, 0.36718929f, 0.62761158f, 0.21199466f, -0.40491968f, -0.32180086f, -0.07621895f, 
    0.43552545f, 0.06469471f, -0.16605131f, 0.07923429f, 0.38202828f, 0.12945786f, 0.21406415f, -0.04665523f, 
    0.05349774f, 0.45158061f, 0.13754182f, -0.12571689f, -0.06090868f, -0.05068891f, -0.59004158f, -0.76742649f, 
    0.59788352f, 0.04786652f, -0.04579566f, -0.06971474f, 0.10059742f, -0.39138684f, 0.46535027f, 0.49912250f, 
    0.31295618f, -0.19971505f, -0.29206425f, 0.62552780f, -0.20090126f, 0.00636962f, 0.61574233f, 0.31723750f, 
    -0.03083006f, 0.88762707f, -0.21530357f, -0.33607563f, 0.21937531f, -0.21716772f, -0.12710197f, 0.07909358f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09146784f, -0.00126367f, 0.42463139f, 0.56519258f, -0.05008127f, 0.24630114f, 0.24678743f, -0.22167899f, 
    -0.17911100f, -0.11603932f, 0.20008554f, -0.12581427f, 0.30711269f, -0.29108918f, -0.00180700f, -0.01022072f, 
    0.24389169f, 0.28357205f, 0.07984287f, 0.33159089f, 0.23897161f, -0.06362901f, -0.02798669f, 0.07972188f, 
    0.41988900f, 0.09862262f, -0.05262574f, 0.25896031f, 0.18765719f, -0.27586257f, -0.22154003f, 0.07301123f, 
    -0.11652727f, 0.12888788f, 0.01995734f, 0.46848607f, 0.14595823f, 0.08844312f, 0.22021689f, 0.12594655f, 
    0.27103272f, -0.09960096f, -0.01405062f, 0.17106272f, 0.25637001f, -0.06343397f, 0.42336383f, -0.10864600f, 
    -0.39553741f, 0.01293683f, 0.13376261f, -0.11029989f, -0.30829850f, 0.27765802f, -0.24167427f, 0.30932066f, 
    -0.24485189f, 0.37639859f, -0.04092894f, 0.33788931f, -0.26393285f, 0.27937412f, -0.46505877f, -0.20720604f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.25474477f, -0.06543495f, -0.02185581f, -0.32454512f, 0.14200662f, -0.77918023f, 0.02684722f, 0.17556489f, 
    -0.17050183f, -0.49978006f, 0.16621834f, 0.07892852f, -0.38442868f, 0.30651385f, 0.24081203f, -0.00803632f, 
    -0.17561059f, 0.14749175f, 0.54329139f, -0.35340336f, -0.13608097f, -0.30075678f, -0.39240804f, 0.30080265f, 
    -0.76869428f, 0.08748026f, -0.15393515f, -0.15503626f, 0.36132500f, 0.07186954f, -0.17681611f, -0.59931147f, 
    -0.17014588f, 0.02061322f, 0.66777873f, -0.13325444f, 0.03303193f, -0.34761626f, 0.26262152f, -0.08676034f, 
    -0.04380868f, 0.07913325f, 0.11711483f, 0.09534287f, -0.45026383f, 0.35299018f, 0.10979521f, 0.33377030f, 
    0.15980543f, -0.32093909f, 0.18744698f, -0.00212519f, -0.30936134f, 0.06447615f, -0.06853591f, -0.20542978f, 
    -0.01575387f, -0.29205850f, -0.00230790f, -0.01736249f, 0.17151953f, 0.19252521f, -0.14849783f, 0.21474253f, 
    0.12696749f, 0.04711076f, -0.38131490f, -0.41215056f, 0.04549922f, -0.21041153f, 0.08558666f, -0.25025198f, 
    -0.01045448f, -0.57054764f, 0.14049527f, -0.36189139f, -0.10095048f, -0.08809640f, -0.22292049f, 0.20643193f, 
    0.55383021f, -0.42917049f, 0.10348007f, 0.40818155f, -0.54573882f, -0.23022068f, -0.14967433f, 0.30630499f, 
    0.10819510f, -0.37929213f, 0.39990160f, -0.50434393f, 0.22265643f, 0.01733754f, -0.05601424f, 0.33252555f, 
    0.08919170f, -0.06467712f, -0.52096242f, 0.09374003f, -0.03717854f, 0.36967432f, -0.01285262f, 0.15453328f, 
    -0.07963081f, 0.12011918f, -0.53339952f, -0.47316337f, 0.30649507f, 0.37769154f, 0.24321543f, -0.01862198f, 
    -0.34829986f, 0.04200601f, 0.49225986f, -0.06834587f, 0.01416109f, 0.03590926f, -0.13141041f, -0.03424493f, 
    -0.00316488f, 0.31266510f, 0.15115710f, -0.25118136f, -0.20895696f, 0.06739276f, -0.28344086f, 0.26819187f, 
    -0.22128308f, 0.04824453f, 0.15875098f, 0.15613604f, -1.32035756f, -0.03177809f, -0.13987193f, -0.15193887f, 
    -0.03594683f, 0.10446065f, 0.37644234f, 0.46457410f, -0.00244629f, -0.67599696f, -0.36430833f, -0.97677463f, 
    0.52609915f, -0.68818343f, -0.15095262f, -0.12040795f, 0.44303522f, -0.64784247f, 0.27861768f, 0.02245688f, 
    0.33341646f, -0.11264002f, 0.12684649f, -0.04372118f, 0.13381523f, -0.13457626f, -0.11920267f, -1.34458947f, 
    0.06581414f, -0.07726686f, -0.81523550f, -0.21732785f, -0.85181636f, 0.16672276f, 0.11543606f, 0.13685492f, 
    -0.19140206f, 0.11092210f, 0.20209357f, -0.52556950f, -0.64943564f, -0.31253347f, -0.65195256f, 0.02309864f, 
    -0.17020589f, -0.60039729f, -0.77392638f, 0.08442160f, -0.09602746f, -0.76120335f, -0.03542534f, 0.32924950f, 
    -0.05608301f, 0.37497675f, 0.50869930f, 0.24968451f, 0.04731459f, 0.41466635f, 0.34909859f, -1.21120572f, 
    -0.29748404f, 0.00061497f, -0.17023861f, 0.07069764f, -0.00299487f, -0.07194884f, -0.20656532f, 0.09275378f, 
    -0.00399406f, 0.07076395f, -0.49537531f, 0.17082803f, -0.12338971f, -0.02185694f, -0.30540624f, 0.23271599f, 
    -0.56200922f, 0.27616858f, -0.04317037f, -0.11086074f, 0.28453797f, 0.07092552f, 0.41401821f, -0.56141222f, 
    0.26475045f, 0.13059750f, 0.28280783f, -0.16511950f, -0.38693026f, -0.05060940f, 0.14242715f, -0.44459206f, 
    0.24373965f, 0.02819025f, 0.08828312f, 0.36101320f, -0.55752194f, 0.15351017f, -0.63480812f, 0.34016392f, 
    0.33554125f, -0.34698024f, 0.33701783f, 0.28351650f, 0.03784809f, -0.80143082f, -0.03719701f, 0.24819145f, 
    0.11852409f, 0.14229597f, -0.12059791f, -0.02934572f, 0.11033791f, -0.35326120f, 0.06877279f, -0.26645690f, 
    0.07180706f, -0.50624716f, -0.04221645f, -0.37223551f, -0.13847907f, -0.09341796f, 0.54001224f, 0.40502125f, 
    0.19198167f, 0.02341413f, 0.20179413f, 0.01410286f, 0.09109734f, -0.37412465f, 0.09989434f, -0.25979033f, 
    -0.09828729f, 0.05893775f, 0.07321163f, 0.07321060f, 0.25601864f, 0.17264615f, 0.40591034f, -0.11768384f, 
    -0.03001634f, 0.05354472f, -0.12232430f, -0.24917956f, 0.40794948f, 0.03844079f, -0.40551332f, -0.19988354f, 
    -0.29047373f, -0.11708822f, -0.13024755f, -0.47032028f, 0.15834907f, 0.00838300f, -0.59227675f, -0.38613605f, 
    -0.06878876f, -0.12905297f, 0.09929317f, 0.49279782f, 0.25515708f, -0.35560396f, 0.14324594f, -0.32597467f, 
    0.24370268f, 0.00328031f, 0.21095136f, -0.47639984f, -0.25151852f, -0.05997192f, 0.38451353f, 0.06333669f, 
    0.24108675f, 0.15038440f, -0.95009798f, -0.01795997f, 0.30525219f, -0.13697535f, -0.16544543f, -0.32867488f, 
    -0.12037288f, -0.56091905f, -0.63155156f, 0.12439112f, -0.01205858f, 0.06279366f, 0.56467229f, -0.19993933f, 
    0.20277166f, 0.06368890f, -0.03175841f, 0.01898596f, -0.02944834f, 0.33986169f, -0.00972086f, -0.60389131f, 
    0.06054433f, -0.31735048f, -0.29531476f, -0.31463191f, 0.04161995f, 0.17177665f, -0.09311523f, 0.39253584f, 
    -0.35610548f, -0.05987198f, -0.12768798f, 0.17496578f, -1.30689764f, 0.23130442f, -0.33967268f, 0.21934609f, 
    -0.04234359f, 0.18790899f, -0.08004706f, 0.24712834f, 0.22509214f, -0.00476047f, -0.10025784f, 0.41802508f, 
    0.01235227f, -0.10610767f, -0.13211797f, -0.86353314f, 0.32650161f, 0.29581404f, -0.24918148f, -0.08686345f, 
    -0.08530242f, 0.07470372f, -0.23874907f, 0.25421989f, -0.44345057f, 0.11132640f, 0.09230866f, -0.47347292f, 
    0.13364109f, -0.25888139f, 0.41995928f, -0.06925492f, 0.10013776f, 0.49156982f, -0.13814178f, -0.08133527f, 
    0.02247416f, -0.09789181f, -0.80319899f, -0.09373906f, -0.23996152f, -0.31028020f, -0.85884970f, -0.15311264f, 
    0.14184356f, 0.03300473f, 0.26873258f, 0.50649983f, -0.08623787f, 0.18464002f, -0.10449202f, -0.18763719f, 
    0.01248718f, 0.27093038f, -0.35039091f, 0.17665000f, 0.30794778f, -0.21771519f, 0.08546539f, 0.19728720f, 
    -0.23795927f, -0.16117878f, -0.31815752f, 0.18180932f, -0.16255116f, 0.10976379f, -0.11351866f, -0.32576084f, 
    0.14658216f, -0.09524956f, -0.38494459f, 0.37390965f, 0.13705112f, -0.07161506f, -0.64038765f, -0.35386479f, 
    0.24415198f, -0.08562880f, -0.67185622f, -0.46162444f, -0.37884903f, -1.15242863f, -0.23395663f, 0.31739256f, 
    -0.76786566f, 0.12431835f, 0.09713147f, 0.20311560f, -0.37394008f, -0.16549921f, 0.11816216f, 0.00176119f, 
    -0.41840810f, 0.03902356f, 0.07253263f, 0.05912541f, -0.70683259f, 0.04927721f, 0.09406160f, 0.08588214f, 
    -0.02266617f, 0.18719344f, -0.58825684f, 0.12564304f, -0.04458865f, 0.01670420f, -0.84033692f, -0.17149083f, 
    0.33655676f, -0.01303391f, -0.64232928f, -0.54775834f, 0.15821224f, -0.91926461f, -0.29301676f, -0.50696814f, 
    0.04589698f, -0.07536996f, -0.49948958f, -0.06667628f, -0.96731466f, 0.31613907f, -0.15567805f, -0.01167833f, 
    0.08520741f, -0.23101200f, 0.05179817f, -0.39560324f, -0.01820625f, 0.08327910f, 0.22841124f, 0.10685709f, 
    -0.46800065f, 0.14280890f, -0.27751487f, 0.08662973f, 0.02936785f, -0.09464093f, 0.38206816f, 0.39036289f, 
    0.16856857f, -0.11388172f, 0.18143289f, 0.27100816f, -0.08635080f, 0.04394894f, -0.40138897f, 0.40281266f, 
    -0.39850014f, 0.01589796f, -0.34224069f, 0.00395873f, 0.28209543f, 0.27968401f, 0.18338117f, 0.04486107f, 
    0.08142664f, 0.17199969f, 0.05663689f, 0.12490921f, 0.39317960f, -0.50423133f, -0.04627944f, -0.54216135f, 
    -0.02557815f, -0.24685808f, -0.12280947f, -0.77921218f, -0.08073507f, -0.43266064f, 0.82527971f, 0.19845903f, 
    0.10749904f, -0.01855271f, 0.10088816f, -0.40417069f, 0.50023782f, 0.09610271f, 0.26709235f, -0.07882277f, 
    -0.02140335f, 0.33152053f, 0.12108016f, -0.48700681f, -0.25159159f, -0.19760275f, -0.26669365f, -0.08493704f, 
    -0.07811926f, -0.43796647f, -0.87276596f, 0.20510833f, 0.11787817f, -0.11117978f, 0.66696936f, -0.14812414f, 
    -0.29553843f, -0.58526903f, 0.30585194f, -0.55178261f, -0.67888731f, -0.01588689f, 0.23348261f, -0.18980917f, 
    -0.84277678f, 0.02628909f, 0.26619607f, -0.76760101f, 0.18599537f, 0.20800717f, -0.19373305f, 0.01327385f, 
    0.08360966f, -0.35665703f, -0.07886567f, 0.22838609f, -0.09792677f, 0.18982270f, -0.06948378f, -0.34821144f, 
    -0.56993306f, 0.28445065f, -0.27621087f, -0.02178320f, 0.12301984f, 0.00309065f, -0.00363232f, 0.20602544f, 
    -0.04951820f, 0.23863460f, -0.25792402f, 0.28763217f, -0.05659433f, -0.35412440f, 0.52454036f, -0.36077568f, 
    -0.37631723f, -0.12034205f, 0.38761786f, 0.17155553f, -0.28316084f, 0.10833484f, 0.26492602f, -0.33735138f, 
    -0.00223965f, 0.19799444f, -0.04251789f, 0.20590495f, 0.10662346f, -0.12293947f, 0.03330873f, -0.55019408f, 
    -0.63515323f, -0.16859323f, -0.03464810f, -0.02624696f, -0.25364777f, -0.23519045f, -0.42258322f, 0.01153910f, 
    -0.54414237f, -0.25752276f, -0.38302547f, 0.35728979f, -0.05331152f, 0.03596852f, 0.14800352f, 0.36241660f, 
    0.16843577f, 0.09034923f, 0.37329707f, -1.34413302f, 0.13615337f, 0.05026184f, 0.11934264f, -1.15847647f, 
    -0.02055157f, -0.13195296f, 0.44159418f, 0.02502367f, 0.19299360f, 0.17845015f, -0.00382823f, -0.30392188f, 
    -0.15914163f, -0.36586237f, -0.50586611f, -0.02120623f, 0.35989162f, 0.32624647f, -0.12565699f, 0.21827087f, 
    0.00759034f, 0.00100384f, -0.61039013f, 0.13719898f, -0.13654289f, 0.05523394f, -0.60342592f, -0.07533524f, 
    -0.51224500f, -0.05160763f, 0.04426342f, 0.31939679f, -0.08761696f, 0.25802907f, -0.50536883f, 0.07471852f, 
    -0.00887810f, -0.74290293f, 0.43003058f, -0.13725816f, -0.35689101f, -0.44879282f, -0.51772302f, 0.00135882f, 
    -0.19054799f, 0.14431706f, 0.36135000f, 0.20250361f, 0.11972199f, 0.11340842f, 0.14055429f, -0.10202961f, 
    0.29334125f, 0.15638451f, 0.22664191f, 0.41463867f, -0.48731732f, -0.04326067f, 0.28042805f, -0.15290941f, 
    -0.73119169f, 0.05811200f, 0.08994915f, 0.23257212f, -0.39897084f, -0.10562640f, -0.14834823f, 0.13756093f, 
    0.35736957f, -0.39349094f, -0.17895386f, 0.25785327f, 0.41949114f, -0.30826867f, -0.47411558f, -0.16041435f, 
    -0.23266979f, 0.00926761f, 0.28908503f, 0.08599608f, -0.60774547f, 0.06825451f, -0.01055646f, 0.08119096f, 
    -0.00275344f, 0.21437880f, 0.18041183f, 0.13053261f, 0.02473887f, -0.06002335f, -0.40205580f, 0.11572371f, 
    -0.51480651f, -0.05568379f, -0.35305950f, -0.15864176f, 0.00401934f, 0.06291621f, -0.15457918f, -0.22836587f, 
    -0.05976347f, 0.25617829f, -0.34797981f, -0.23801845f, 0.04488041f, 0.35636434f, 0.24991438f, -0.35480517f, 
    -1.01836133f, 0.33750725f, -0.18198195f, -0.27694598f, 0.29012734f, 0.38458076f, -0.23319453f, -0.27578703f, 
    0.34873945f, 0.28048804f, -0.04429309f, -0.07582957f, -0.10155914f, 0.05186959f, -0.42625985f, -0.14073183f, 
    0.03491563f, -0.10863066f, -0.78804278f, -0.08972152f, -0.67446232f, -0.13394235f, 0.40947956f, -0.36606270f, 
    0.07845242f, 0.16054665f, -0.24623315f, -0.05832833f, -0.30470869f, -0.69232619f, -0.66819328f, 0.34453985f, 
    0.27966917f, 0.26468447f, 0.00437012f, 0.09774604f, -0.65877151f, -0.57385898f, 0.07066567f, 0.19566990f, 
    -0.11965337f, 0.06804455f, 0.38501999f, 0.12118788f, 0.03260717f, -0.07617475f, -0.20312382f, -0.35258859f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02212957f, 0.10443491f, -0.02020920f, 0.02936792f, -0.00831701f, 0.01497412f, 0.08476168f, -0.40197587f, 
    -0.12666267f, 0.05633293f, 0.20964915f, -0.19310078f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
