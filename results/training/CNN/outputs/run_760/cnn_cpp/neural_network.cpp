#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.35072339f, -0.20572099f, -0.44447064f, 0.85637587f, -0.37496823f, 0.71921754f, 0.50974786f, -0.43271008f, 
    0.20935723f, 0.41872773f, -0.63436913f, -1.26381671f, -0.35919830f, -1.20602834f, -0.35554758f, -0.39920667f, 
    0.45731089f, -0.14562477f, -1.05785668f, -0.22002693f, -0.15240067f, 0.06246005f, 1.51625836f, -0.59198105f, 
    -0.08790608f, -0.37359482f, -0.49713498f, 0.97202307f, 0.62553775f, 0.96448320f, 0.33705851f, -0.97713858f, 
    0.04426590f, 0.37610105f, 0.55232418f, 0.72011888f, 0.31717804f, 0.44652268f, -0.27165976f, 0.14213605f, 
    0.71466225f, 1.34320831f, 0.07975470f, -0.73666739f, 0.06705664f, 0.54322749f, 1.22738945f, -0.23362188f, 
    0.84275728f, -0.47615033f, -0.77173895f, -0.59672052f, -0.20586564f, -0.36725187f, 1.72126400f, 0.64118427f, 
    1.05682802f, 0.41243541f, 0.21985267f, 0.57264209f, -0.07357357f, 0.39788058f, 0.12377959f, 1.05044293f, 
    -1.06292284f, -0.78239864f, 1.11079299f, 0.22948140f, -0.02471210f, -0.39191875f, -0.29092076f, 0.07259290f, 
    0.44670996f, -0.66335815f, 0.93065530f, 0.68006307f, -1.19383764f, 0.09043969f, -0.68458706f, -0.83894664f, 
    -0.45293984f, -1.88132203f, 0.74339461f, 0.75152582f, 0.44078279f, 0.38094655f, -0.33441743f, -0.17907892f, 
    0.08168495f, 0.33415455f, -1.02648938f, -1.60778677f, -0.70903522f, -1.06665432f, 0.04853101f, -0.25607577f, 
    0.29868466f, 0.23098780f, 0.10703868f, -0.92939991f, -0.95151061f, -1.20033658f, 0.43160677f, 0.99359453f, 
    1.03807998f, -0.03308969f, -0.04364125f, -0.72534901f, -0.16438054f, -0.16753891f, 0.57337666f, 1.15506995f, 
    1.03074312f, 0.53140467f, 0.75031400f, 0.67012805f, 0.53083527f, 0.43771386f, 0.94381154f, -0.07764859f, 
    -0.71367973f, -1.37150741f, -0.02816521f, -0.53041112f, -0.54754865f, -0.02787328f, -0.08162715f, 0.60779661f, 
    -0.64222342f, -0.35849720f, -0.32900348f, 0.42099181f, 1.27112365f, 0.29489097f, -0.53267682f, 0.27330688f, 
    1.09292555f, 1.21265185f, 0.28734285f, 0.28540188f, -1.36566949f, 0.33998901f, 0.36562535f, -0.04178539f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09112246f, 0.56452560f, -0.21456508f, -0.20525205f, 0.50524658f, 0.08957512f, 0.91095448f, -0.02250648f, 
    0.42530942f, 0.16972506f, 0.35341081f, 0.24568918f, 0.06714213f, 0.62286067f, 0.39581990f, 0.04450800f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04918712f, 0.05954855f, 0.04171914f, 0.00322536f, 0.01978302f, 0.06557055f, 0.00558956f, 0.02878916f, 
    0.07481493f, -0.00317050f, -0.08517487f, 0.03233501f, 0.02607126f, -0.06175378f, -0.08062374f, 0.01655495f, 
    0.04419211f, 0.01513147f, 0.01589872f, 0.04335743f, -0.06617226f, 0.04989511f, -0.08082569f, -0.07895201f, 
    -0.03672167f, -0.05302185f, -0.05243838f, -0.03071644f, 0.01230299f, 0.02473498f, -0.02439283f, 0.01968683f, 
    -0.04491145f, -0.00676123f, -0.03353800f, 0.00597372f, 0.06664880f, -0.02046846f, 0.06620388f, -0.04318514f, 
    0.04550100f, 0.06663369f, 0.04520335f, -0.08965136f, -0.01789886f, -0.09335644f, -0.04421645f, 0.03260456f, 
    0.03431045f, -0.05508992f, -0.01659727f, -0.00564730f, -0.06354167f, 0.01210672f, 0.06717507f, -0.04532166f, 
    -0.03001610f, -0.04381542f, 0.02793555f, -0.08364594f, -0.03043072f, -0.00048867f, -0.06252015f, -0.04386904f, 
    -0.05457940f, -0.03718477f, -0.05399879f, 0.04098711f, -0.01083031f, -0.03842009f, -0.07393210f, 0.06954095f, 
    0.05513494f, 0.03471881f, -0.08390292f, -0.01600372f, 0.03295445f, 0.01775994f, -0.03086224f, 0.05950436f, 
    -0.05056605f, 0.05480832f, 0.00916746f, 0.01942114f, -0.01286265f, -0.04677025f, 0.04091678f, -0.03827359f, 
    -0.02284163f, -0.08523405f, -0.06785090f, 0.06612392f, -0.00236510f, -0.00974819f, -0.00848216f, -0.04116942f, 
    -0.05316066f, 0.03107207f, 0.04665532f, 0.01911295f, -0.05199764f, 0.00848876f, 0.07255665f, -0.02120578f, 
    0.03125849f, -0.09319789f, -0.06981717f, -0.04549994f, 0.01861325f, -0.06441927f, -0.07060613f, 0.04255712f, 
    -0.08430755f, -0.05995131f, 0.00589999f, -0.01854363f, 0.04995298f, 0.02156428f, -0.03895639f, 0.06987323f, 
    -0.05593677f, 0.02883828f, -0.04426417f, 0.00234156f, 0.03285319f, 0.07447138f, -0.05629073f, -0.07641335f, 
    -0.02478812f, -0.00146648f, -0.05133666f, -0.08001668f, -0.07430413f, 0.05303245f, -0.06870022f, 0.04501611f, 
    -0.03569038f, 0.03477136f, -0.03917095f, -0.00373567f, -0.04155909f, 0.04088149f, 0.05625094f, 0.05566653f, 
    -0.32720277f, 0.19161195f, -0.03316280f, 0.26179823f, 0.20589395f, 0.06064484f, 0.25532225f, -0.21009214f, 
    -0.21205381f, -0.05467806f, -0.23179661f, -0.24162829f, 0.35467908f, 0.10235199f, 0.09575655f, 0.04940530f, 
    -0.05422394f, 0.10523193f, -0.68713880f, -0.47426659f, -0.54707021f, -0.01581901f, 0.19851853f, 0.09973986f, 
    -0.19140156f, 0.03557517f, -0.16773321f, 0.39196298f, 0.05017984f, 0.27864754f, 0.01888493f, -0.13027529f, 
    0.08586459f, 0.22983123f, -0.08863877f, -0.13614598f, 0.31486294f, -0.11711577f, 0.15048032f, 0.15418668f, 
    0.10385997f, -0.07189180f, -0.24544463f, -0.15138845f, 0.33571580f, 0.30893317f, -0.10860252f, 0.17509423f, 
    0.01570422f, 0.25626007f, 0.19172353f, -0.03716943f, -0.21756624f, 0.03635570f, 0.68673372f, 0.21510828f, 
    0.43440256f, 0.03065124f, -0.24369624f, -0.15401806f, 0.16346844f, 0.25065333f, 0.10153515f, -0.37238732f, 
    -0.52325308f, -0.18313953f, 0.07229637f, 0.23978132f, -0.02545570f, -0.23595394f, -0.26046437f, 0.25605774f, 
    -0.52417779f, 0.24223672f, -0.08063354f, 0.18857755f, -0.04829317f, 0.23526697f, -0.06996104f, 0.05998362f, 
    0.13210048f, -0.40918842f, -0.08520024f, -0.37821427f, 0.10091041f, 0.15815601f, 0.01141114f, 0.16993889f, 
    -0.24313040f, 0.18456495f, 0.09707905f, 0.33960956f, -0.10824738f, 0.10432082f, 0.22880110f, -0.11646543f, 
    -0.11641963f, -0.12408683f, -0.15080117f, -0.25048992f, -0.19250460f, 0.08882812f, 0.11344390f, 0.15586457f, 
    0.10793266f, -0.04437973f, 0.17565413f, 0.03086013f, -0.59513170f, -0.41824767f, -0.06135167f, -0.04809394f, 
    -0.01916561f, -0.18436907f, -0.00985476f, -0.14978926f, -0.28987017f, 0.10239323f, -0.02667385f, 0.08564827f, 
    0.06896928f, -0.05063556f, -0.21667385f, 0.16866872f, -0.22554833f, 0.05347682f, -0.05317511f, -0.43954575f, 
    -0.12881035f, 0.02944407f, 0.17453463f, -0.02545583f, 0.19017535f, 0.10123101f, -0.04967284f, 0.60343164f, 
    0.13210258f, 0.13445182f, -0.25928700f, 0.15872219f, 0.04329726f, 0.09254577f, -0.04570659f, 0.07392171f, 
    -0.17454679f, -0.13609937f, 0.10746293f, -0.12348960f, -0.02401743f, -0.12223583f, -0.21377529f, 0.16523947f, 
    0.07478792f, 0.31247288f, 0.28140068f, -0.40602392f, -0.04698295f, -0.10954494f, 0.14540018f, 0.09951067f, 
    0.13823092f, 0.07040410f, -0.10942449f, -0.01873013f, -0.14373338f, -0.14968494f, -0.13089338f, -0.08561137f, 
    0.16450509f, -0.03014227f, -0.14842682f, -0.06978757f, -0.21254805f, 0.26356411f, 0.09773704f, -0.01739199f, 
    0.41445464f, 0.07344412f, 0.34883356f, 0.17570925f, -0.22340795f, -0.08399134f, 0.07301074f, 0.12575738f, 
    0.15540913f, -0.01950325f, -0.08525272f, 0.00703410f, 0.06055432f, -0.06230428f, 0.26724693f, 0.05009405f, 
    0.15258124f, 0.26823866f, -0.17048717f, 0.00714308f, -0.12853324f, 0.06837046f, -0.33485851f, 0.15403563f, 
    0.06023587f, 0.25919589f, 0.21154112f, -0.01949763f, 0.10031266f, 0.11298299f, 0.12010474f, 0.00651830f, 
    -0.21878737f, -0.43907532f, -0.00943563f, -0.07276265f, -0.07736383f, 0.08451875f, -0.02214979f, 0.08486741f, 
    -0.30230200f, -0.23024790f, -0.12307346f, 0.15752986f, 0.23251420f, 0.47600496f, 0.07041840f, -0.17269579f, 
    -0.25956488f, -0.17395225f, -0.46400559f, -0.02216093f, 0.01203270f, -0.11028206f, 0.04196881f, -0.03745124f, 
    -0.15781368f, 0.03807501f, -0.01899088f, -0.00273785f, -0.47600868f, 0.10595322f, 0.14667596f, 0.07766524f, 
    -0.18524523f, 0.18200874f, -0.02714377f, 0.32705149f, 0.15354483f, -0.16608043f, -0.16459097f, -0.19699576f, 
    -0.29958108f, -0.16082533f, 0.07385296f, -0.24163349f, -0.52008015f, -0.47488907f, -0.04275975f, 0.05789885f, 
    0.12878866f, 0.07594834f, -0.03371630f, -0.01774221f, -0.33605561f, 0.36506405f, 0.43169704f, 0.01102364f, 
    0.29809788f, 0.12641750f, 0.11286844f, 0.01697523f, -0.15820816f, 0.12803204f, 0.03995006f, -0.03497811f, 
    -0.06618019f, 0.07779881f, -0.13594528f, 0.00904602f, 0.20513418f, 0.07842843f, 0.03510443f, 0.16975273f, 
    -0.06414685f, 0.10783527f, 0.15663873f, -0.06357804f, -0.09123015f, 0.18808457f, 0.12255896f, 0.26507476f, 
    -0.22480731f, -0.26541063f, -0.72153497f, 0.11692516f, 0.24801549f, 0.34182996f, 0.20326638f, -0.07584979f, 
    -0.08587286f, -0.25440228f, -0.49074543f, 0.01558968f, -0.08084885f, -0.07574739f, -0.37500641f, -0.01256753f, 
    0.03478673f, 0.31424186f, 0.10453323f, -0.42690563f, -0.35530385f, 0.13982162f, 0.05646036f, 0.22328816f, 
    -0.18254086f, -0.08794988f, -0.14686260f, 0.22660285f, 0.13835140f, 0.15877092f, -0.53974998f, 0.02082039f, 
    -0.08612909f, -0.21720064f, -0.20867215f, -0.08767712f, -0.20588647f, 0.39839172f, -0.24835278f, 0.25820231f, 
    0.02437220f, 0.22043392f, 0.25968763f, -0.09270851f, -0.12165558f, -0.11143206f, 0.05931778f, 0.22347774f, 
    -0.13491355f, 0.00937066f, -0.26394954f, 0.09471833f, -0.16077395f, -0.00132339f, 0.14597367f, 0.36262143f, 
    0.44186354f, -0.14931332f, 0.05360042f, 0.13295704f, 0.13258021f, -0.16021882f, -0.06713941f, 0.24357238f, 
    -0.36905235f, -0.22257720f, 0.21516320f, 0.08043796f, 0.21692662f, 0.01548880f, 0.11715067f, 0.14531577f, 
    0.08784281f, 0.02043393f, 0.24778797f, -0.29686940f, 0.12007885f, 0.04860544f, 0.09990209f, 0.16184123f, 
    -0.15965867f, 0.17275886f, -0.97495252f, 0.57217461f, -0.10464123f, -0.18576361f, -0.24483123f, 0.10031849f, 
    0.25019935f, 0.22673286f, -0.54182673f, -0.30390251f, -0.47041488f, 0.31619284f, 0.05294479f, 0.35497653f, 
    -0.02963804f, 0.15894592f, -0.11087935f, 0.53965038f, 0.42853567f, -0.98681277f, 0.32127830f, 0.32635325f, 
    -0.01168996f, -0.00668192f, -0.17353255f, -0.18516740f, -0.26217991f, 0.14972621f, 0.37312263f, 0.14491375f, 
    0.11283311f, 0.09102950f, 0.16545358f, -0.16090567f, -0.07770695f, -0.20546916f, 0.45188460f, 0.41556081f, 
    0.19899143f, 0.02732492f, -0.03461542f, -0.04633949f, 0.19428575f, 0.28590617f, -0.59019005f, 0.10236322f, 
    0.05214400f, -0.33888340f, -0.02702190f, 0.07747614f, 0.14240494f, 0.22841331f, 0.08625278f, -0.09800875f, 
    -0.10717069f, 0.15334539f, 0.08827314f, 0.00940153f, 0.05721394f, -0.22838594f, 0.22014348f, 0.14706896f, 
    0.09638475f, 0.78205687f, -0.41691023f, 0.45294753f, 0.14245537f, -0.07884330f, 0.04703883f, 0.18149886f, 
    -0.10025159f, -0.60533559f, -0.28739762f, 0.02086407f, 0.03477186f, 0.25779831f, 0.19232075f, 0.08759830f, 
    -0.07671940f, -0.24085006f, 0.15681833f, -0.39980528f, -0.49444559f, -0.15587482f, -0.01149439f, 0.11103086f, 
    -0.07334907f, 0.01065820f, -0.28582516f, -0.07627098f, -0.08716172f, 0.01669732f, -0.08794464f, 0.01166644f, 
    -0.12041718f, -0.00259528f, -0.16902375f, 0.37376389f, 0.42412964f, 0.31492880f, 0.04962698f, 0.10201285f, 
    -0.13613360f, -0.12487185f, 0.14093132f, 0.22766396f, 0.17405678f, -0.13055184f, -0.78762174f, -0.18742830f, 
    0.22993605f, 0.12306750f, -0.13651691f, -0.15485512f, 0.20098045f, -0.00769550f, 0.07579897f, 0.03621979f, 
    -0.13991868f, 0.15383938f, -0.14448848f, -0.06001994f, -0.07774385f, 0.04805835f, 0.14377996f, -0.23662786f, 
    -0.23663229f, 0.02687324f, -0.12937525f, -0.04804368f, 0.07460975f, 0.05843665f, 0.02552228f, 0.07931724f, 
    -0.38272655f, 0.33848479f, -0.02847528f, -0.22193536f, 0.07670771f, 0.03124544f, -0.23076268f, 0.18132132f, 
    0.09513865f, -0.63304365f, 0.01342627f, -0.19526392f, -0.05928160f, 0.07237925f, -0.04817176f, 0.31138951f, 
    -0.08738050f, 0.07467979f, 0.42412812f, -0.49306914f, 0.08115053f, 0.16574620f, 0.05653340f, 0.16013992f, 
    0.10286423f, -0.01887861f, 0.03317938f, 0.51681125f, 0.02769019f, -0.02597184f, 0.01402554f, -0.13937530f, 
    -0.12582736f, 0.15904336f, -0.03131322f, -0.16138434f, 0.28323567f, 0.50281858f, 0.74250519f, -0.36072537f, 
    -0.00704623f, 0.06911886f, -0.09619670f, -0.13765927f, 0.07382964f, 0.15033841f, -0.32484421f, -0.03953881f, 
    0.32950190f, -0.15958644f, 0.35344425f, 0.01686593f, -0.04122620f, 0.11059871f, 0.12834132f, -0.16683862f, 
    -0.33526853f, 0.23162422f, -0.17201422f, 0.19062337f, 0.07767175f, -0.00878508f, 0.14891130f, 0.19591358f, 
    -0.33592564f, -0.08266006f, -0.04231238f, 0.17144848f, -0.21400172f, 0.02790613f, 0.04837251f, 0.14817588f, 
    0.55565107f, 0.41675058f, -0.40463606f, 0.10268894f, 0.22814091f, -0.07216825f, -0.01805133f, -0.13189246f, 
    -0.13256173f, -0.76790148f, -0.00009367f, 0.12300491f, -0.12520006f, 0.12131479f, -0.09549582f, -0.08472744f, 
    0.09700015f, 0.11384470f, 0.15361714f, -0.35064825f, -0.31892797f, 0.20073743f, -0.12041303f, 0.16491286f, 
    -0.04079060f, -0.03615307f, -0.15632008f, -0.38226911f, 0.19947277f, 0.23488131f, 0.01263377f, 0.22306521f, 
    -0.03866445f, -0.13789736f, 0.13010904f, 0.01490811f, -0.20292473f, 0.12257247f, -0.10417043f, 0.46587554f, 
    -0.11693768f, 0.11207409f, 0.04522956f, -0.02828423f, 0.22555289f, 0.21897528f, -0.43187559f, 0.03131057f, 
    0.05479762f, 0.14959200f, -0.02781658f, -0.13107495f, 0.05530590f, -0.01558368f, -1.05527711f, 0.01029838f, 
    0.13168724f, -0.04872093f, 0.07615194f, 0.30009934f, 0.05295235f, 0.00741226f, 0.07206584f, 0.09557474f, 
    -0.46820298f, 0.19137500f, -0.03860362f, -0.18072230f, -0.09115355f, 0.09293074f, 0.03450703f, 0.01209063f, 
    -0.24537361f, 0.27190796f, 0.26588199f, 0.11404151f, 0.20161112f, 0.11960949f, 0.05171835f, 0.01238741f, 
    -0.16000795f, 0.47401986f, 0.08245546f, -0.54898900f, -0.00370082f, 0.03280059f, -0.07602929f, 0.08164635f, 
    -0.05741708f, 0.05361394f, 0.20477545f, -0.40429911f, 0.37931043f, -0.00889553f, -0.14709659f, 0.11218170f, 
    -0.29385093f, 0.09553305f, 0.17872339f, 0.44861680f, -0.02825591f, -0.01986228f, -0.10254107f, 0.00359635f, 
    -0.19253004f, -0.00822610f, 0.02637561f, 0.19380338f, 0.01548416f, -0.11841015f, 0.29835528f, -0.29935634f, 
    0.04808223f, -0.35221124f, 0.00839515f, -0.04179705f, -0.03155259f, -0.21381079f, 0.09373318f, 0.36024687f, 
    0.16289847f, 0.08757719f, -0.02442973f, -0.10025486f, -0.05830916f, 0.21094191f, -0.47526163f, -0.12748706f, 
    0.11124425f, 0.08383081f, -0.32362050f, -0.12349056f, 0.17909318f, 0.10428926f, 0.02975706f, 0.08049768f, 
    -0.17803772f, -0.04571052f, -0.00630656f, 0.07494674f, 0.16176240f, -0.00122882f, 0.04484298f, 0.05566503f, 
    0.10125149f, 0.08952120f, -0.24755315f, -0.05216631f, -0.00865193f, 0.07801216f, -0.18871774f, 0.28868434f, 
    0.10591128f, 0.35703352f, 0.05350429f, 0.06476288f, -0.23457128f, -0.13196322f, -0.18375652f, 0.06741479f, 
    0.27191165f, 0.20258632f, -0.47170481f, -0.05011114f, 0.22252515f, -0.02296387f, -0.06403809f, -0.05529729f, 
    0.06431016f, 0.04030816f, -0.16402984f, -0.36582923f, -0.63612550f, -0.06204002f, 0.18819703f, 0.16092467f, 
    0.19394718f, -0.02801763f, -0.08467501f, -0.15161677f, 0.04856428f, -0.24625057f, -0.03883924f, -0.09459452f, 
    0.03286321f, -0.12699582f, -0.02751472f, 0.23574314f, 0.18976900f, 0.30908036f, -0.76999652f, -0.08949266f, 
    0.13697372f, -0.23199031f, -0.27481934f, -0.16433322f, -0.04818419f, -0.05850954f, -0.47070202f, -0.77561545f, 
    0.04993268f, 0.15013090f, 0.26650229f, 0.04866988f, 0.21726072f, -0.08746655f, -0.17330253f, 0.20919505f, 
    0.39454237f, 0.34632325f, -0.08155428f, 0.14038871f, -0.13702090f, 0.20680800f, 0.40727222f, -0.01476297f, 
    -0.17237644f, -0.07778052f, 0.41907856f, -0.02338022f, 0.07280197f, 0.17832461f, 0.13472958f, -0.28486955f, 
    0.12410779f, -0.09560230f, -0.16420858f, -0.21722732f, 0.01126402f, -0.29375765f, -0.02573090f, 0.00736739f, 
    0.01077151f, 0.04448304f, -0.56320900f, -0.07416290f, 0.15644164f, -0.03642559f, -0.04474602f, -0.14014061f, 
    -0.00345281f, 0.22718237f, -0.04063002f, 0.35503754f, 0.20263670f, 0.08631058f, -0.45191404f, -0.01743603f, 
    -0.00871493f, 0.04596186f, 0.13462630f, 0.11899155f, -0.10300429f, 0.37753370f, 0.25049767f, 0.00731570f, 
    0.19247988f, -0.07904983f, -0.06489905f, 0.06260207f, 0.04010177f, 0.46444410f, -0.04927567f, 0.17875443f, 
    0.33216569f, 0.22086234f, -0.01411869f, 0.36579224f, -0.07396849f, -0.16595453f, 0.36764508f, -0.17370534f, 
    -0.13848484f, 0.17669462f, 0.16700637f, 0.10737094f, 0.08491682f, 0.15862146f, -0.08687335f, -0.21181953f, 
    -0.14695148f, -0.13188250f, -0.09399723f, -0.06945322f, 0.22235876f, -0.06669118f, 0.13891016f, 0.08239923f, 
    -0.35831699f, -0.04549534f, 0.05203075f, -0.11573700f, 0.06576522f, 0.28769711f, -0.18243156f, 0.11384244f, 
    0.00429083f, 0.35783228f, 0.06008096f, -0.11057567f, 0.13229649f, 0.01335824f, -0.01871708f, -0.08830608f, 
    -0.08151618f, 0.01070321f, -1.37141573f, -0.42273214f, -0.04042047f, 0.12775543f, -0.08927594f, 0.03101227f, 
    0.04790328f, 0.18435644f, 0.14455277f, 0.42318055f, 0.09450567f, -0.38852027f, 0.19523540f, 0.19835502f, 
    -0.04136490f, 0.26461965f, -0.14498208f, -0.22855999f, 0.02234495f, -0.22637762f, -0.01287872f, 0.01371168f, 
    0.01136724f, -0.04981451f, -0.02669798f, -0.04215088f, 0.13780187f, 0.37433860f, 0.16460249f, -0.23485686f, 
    0.01792953f, -0.08616575f, -0.00582615f, 0.19559675f, -0.09589722f, 0.03343072f, 0.29248360f, 0.24329184f, 
    0.66868478f, 0.16632794f, 0.19446942f, -0.21766935f, 0.04122970f, 0.12788790f, -0.19928186f, 0.64256495f, 
    0.02177853f, 0.71094215f, 0.11763427f, 0.08322453f, 0.21621852f, -0.19704601f, -0.05562055f, -0.06674850f, 
    -0.01717255f, -0.16938175f, -0.46439770f, -0.14135769f, -0.04280284f, -0.08654890f, -0.06244438f, 0.06469460f, 
    0.22021537f, -0.66900659f, 0.32401222f, 0.08117584f, -0.14281024f, -0.02545057f, -0.06174338f, 0.00887169f, 
    -0.17187847f, 0.16156673f, -0.50161320f, -0.13812383f, 0.18948993f, 0.24086617f, 0.02800514f, -0.07067030f, 
    -0.02110795f, -0.06017703f, -0.07138605f, -0.27519113f, -0.07757287f, 0.42321360f, -0.08285306f, -0.11228769f, 
    0.08203797f, -0.11211152f, -0.03956359f, 0.04817645f, 0.13560182f, -0.39722031f, 0.15812539f, -0.30706942f, 
    -0.20877925f, 0.09383041f, 0.01736083f, -0.04457717f, 0.24296337f, -0.31094006f, 0.07286529f, -0.19352165f, 
    0.05411132f, 0.15773109f, -0.05498619f, 0.11941949f, 0.25324181f, 0.18257849f, -0.23267913f, 0.21851493f, 
    -0.06855556f, -0.01263718f, 0.07017549f, 0.13060960f, -0.09626737f, 0.25458401f, -0.34591168f, 0.38846588f, 
    0.08434512f, -0.83080584f, -0.04824461f, -0.11178926f, -0.08688214f, 0.05481508f, -0.09651650f, -0.06183155f, 
    -0.09164983f, 0.02364779f, -0.03150990f, 0.00940962f, -0.06671768f, 0.03003602f, -0.02688590f, 0.03439529f, 
    -0.02211261f, -0.08970386f, -0.00561481f, 0.01809068f, -0.07131793f, -0.01929592f, -0.09410137f, -0.08810738f, 
    -0.02959582f, -0.01494668f, 0.01688892f, 0.02502205f, -0.04941805f, 0.00854818f, 0.06057651f, -0.03047352f, 
    -0.07481926f, 0.02602692f, 0.01435127f, 0.06129425f, -0.07473738f, -0.03606075f, 0.05164021f, -0.06420141f, 
    -0.04952370f, -0.00203798f, 0.00223595f, -0.03446084f, 0.01308592f, -0.06606153f, -0.05915341f, -0.00689938f, 
    -0.08624830f, 0.02855888f, 0.07197995f, -0.07794812f, -0.09112153f, 0.01470838f, -0.03684134f, 0.02788263f, 
    -0.05072404f, 0.05138953f, -0.05794687f, 0.05810051f, 0.03475736f, 0.04397961f, 0.04705399f, 0.03119130f, 
    -0.05669167f, -0.00861742f, -0.00854392f, 0.05108847f, 0.06762731f, 0.06751388f, -0.01412367f, -0.00486450f, 
    -0.09376168f, 0.00801901f, 0.04729630f, 0.03854459f, -0.02203451f, 0.07397723f, -0.07950848f, -0.03175918f, 
    -0.04414703f, -0.07064491f, 0.04017036f, -0.05489639f, -0.06709012f, -0.03705732f, 0.00091477f, 0.00222931f, 
    -0.02869198f, -0.07088830f, 0.05024407f, 0.04078236f, 0.07088264f, -0.07461732f, 0.02396803f, 0.00405847f, 
    0.06498171f, 0.01751191f, 0.00073918f, 0.01189809f, -0.02080005f, 0.05432526f, 0.02103381f, 0.03805137f, 
    -0.07891317f, 0.04474393f, -0.07629640f, -0.07942709f, -0.04492700f, -0.02669847f, -0.08248857f, -0.08233286f, 
    -0.05117169f, 0.00608574f, 0.04845951f, 0.00360995f, -0.07591265f, 0.03417097f, 0.02286127f, -0.06632680f, 
    -0.00324115f, -0.04680680f, 0.03851260f, 0.02114560f, -0.07069740f, 0.04471635f, 0.05216860f, 0.02130274f, 
    -0.05084598f, 0.00613427f, 0.05010455f, -0.03123168f, -0.08801134f, -0.06953350f, 0.01242186f, -0.03673884f, 
    -0.07305558f, -0.07498255f, -0.04867625f, 0.05025990f, -0.02528360f, 0.00083390f, -0.04334453f, 0.04103592f, 
    -0.06200140f, 0.03625474f, -0.05459209f, 0.01512629f, 0.05930322f, -0.02453228f, -0.02619077f, -0.00075777f, 
    -0.02037042f, 0.30100295f, 0.15167738f, -0.02128434f, -0.12052278f, 0.35682258f, -0.02018565f, 0.16226783f, 
    0.11173472f, 0.31023052f, 0.38602784f, -0.14391468f, 0.24699533f, -0.06523802f, 0.12687390f, -0.15840039f, 
    -0.12812217f, -0.32629803f, 0.29515022f, 0.24729849f, -0.03620294f, 0.31330207f, 0.12898520f, 0.17614706f, 
    -0.11161558f, -0.06833524f, 0.02827359f, 0.07606728f, -0.07829174f, -0.08143170f, -0.00157956f, 0.04036235f, 
    0.00728955f, -0.04410577f, 0.11835954f, -0.14922714f, -0.03595932f, -0.38250226f, -0.00578232f, 0.15067424f, 
    0.01682458f, -0.30794320f, 0.16935687f, -0.07986809f, -0.07876617f, 0.05409124f, -0.15603405f, 0.43068543f, 
    -0.49993184f, 0.03496835f, -0.10457627f, 0.02218961f, -0.05221570f, 0.00900170f, -0.44005615f, -0.28592145f, 
    0.40816501f, 0.29051873f, -0.03152629f, -0.22148252f, 0.07704423f, -0.14331426f, 0.12631673f, 0.30561689f, 
    0.35003909f, -0.08410159f, 0.29807723f, 0.03394195f, 0.04730158f, -0.04837704f, -0.00000794f, -0.07596022f, 
    -0.09773410f, -0.14267214f, -0.04100180f, -0.04374193f, -0.02602428f, -0.04572789f, -0.16251376f, 0.01759185f, 
    -0.09674359f, 0.03505788f, -0.34069189f, -0.20296785f, -0.05630637f, -0.10465136f, -0.08645655f, -0.21056011f, 
    -0.11757587f, -0.04368245f, 0.20551127f, 0.49907535f, 0.20984583f, 0.26660874f, -0.15055518f, -0.26945922f, 
    -0.11313897f, 0.08356681f, 0.21605676f, 0.13196510f, 0.33749327f, 0.48390725f, 0.16828394f, -0.00142270f, 
    -0.08704547f, 0.22530529f, 0.08178353f, -0.07361133f, 0.38531542f, -0.23990794f, 0.22949991f, -0.32896978f, 
    0.15888795f, -0.27049649f, 0.26864895f, 0.03531338f, 0.29112032f, -0.27682778f, -0.50900519f, -0.25348035f, 
    -0.02351754f, -0.19071740f, 0.17389463f, -0.22403765f, -0.03124000f, -0.04803123f, -0.12397338f, -0.30456594f, 
    -0.40088218f, 0.09639601f, -0.24373482f, 0.07193547f, 0.21605986f, 0.22188562f, -0.13814302f, -0.20220287f, 
    -0.16724232f, -0.23882863f, 0.19829483f, -0.21700366f, -0.10572601f, -0.26963905f, -0.09756393f, 0.22131571f, 
    0.03014183f, 0.07956702f, 0.18599467f, 0.01178574f, 0.03318268f, 0.13536964f, 0.03343527f, 0.06995265f, 
    -0.00834003f, -0.03128454f, 0.05721433f, -0.14208990f, -0.25823587f, -0.15200552f, 0.04620287f, 0.09189348f, 
    0.39051607f, -0.08439284f, 0.16881673f, 0.29376101f, 0.12165304f, 0.03962583f, 0.09449799f, 0.16912942f, 
    0.09305091f, -0.12064358f, -0.02213358f, -0.49178228f, -0.12076660f, -0.16415684f, -0.39352718f, 0.25270578f, 
    -0.06491391f, -0.04166574f, -0.18060909f, -0.19496092f, 0.07875618f, -0.01351949f, -0.54824179f, -0.10853169f, 
    -0.03752919f, -0.11208698f, -0.02042205f, -0.04941142f, 0.09604234f, 0.22169572f, 0.22802520f, 0.11251900f, 
    -0.05680284f, -0.16710699f, -0.34135243f, -0.02163658f, 0.07203584f, -0.10677718f, 0.21876943f, 0.10450932f, 
    0.14058977f, -0.00906956f, 0.05132964f, 0.16861394f, 0.00347957f, 0.11309141f, 0.14575140f, 0.42088312f, 
    0.09045810f, -0.55629212f, -0.07307862f, -0.08115539f, -0.00760030f, 0.08178779f, 0.03019456f, -0.02007965f, 
    0.21520443f, 0.00201628f, 0.18849434f, 0.12729575f, 0.23496862f, -0.03506244f, 0.01042060f, -0.04351818f, 
    0.18737155f, 0.42193079f, 0.15105109f, -0.13419740f, -0.06929228f, -0.12950224f, -0.13158360f, 0.06448027f, 
    0.10809681f, 0.05967338f, -0.26076454f, 0.35489172f, 0.17587633f, 0.43086252f, 0.41560355f, -0.07247692f, 
    0.12396066f, -0.43631795f, 0.23243824f, 0.01475431f, 0.35747921f, -0.06799727f, 0.24338298f, 0.28273523f, 
    0.10940710f, 0.15108076f, 0.19007492f, 0.30547965f, -0.01758863f, 0.45467880f, -0.24588308f, 0.30757916f, 
    0.15472275f, -0.03291788f, 0.04345257f, 0.18374267f, 0.00363969f, 0.19938250f, -0.11702612f, 0.12188521f, 
    -0.59594923f, -0.19119336f, 0.04407514f, 0.02108911f, 0.09601665f, 0.07600519f, -0.20189585f, -0.74507368f, 
    -0.35691264f, -0.28066930f, -0.00952418f, -0.08405949f, 0.23936993f, -0.07978179f, -0.13839145f, -0.94895005f, 
    0.32216412f, -0.00180870f, -0.22637242f, 0.01990261f, -0.26161781f, 0.20359083f, 0.27857378f, 0.11274254f, 
    0.27242592f, 0.24365890f, -0.07367597f, -0.11417977f, 0.27837813f, 0.35941172f, -0.24353044f, 0.02120057f, 
    -0.07599604f, 0.21071225f, 0.32548237f, -0.02931856f, 0.05362489f, -0.12148177f, -0.40269962f, -0.01490526f, 
    0.10752515f, -0.11129817f, -0.12671064f, 0.52678549f, 0.19341822f, -0.03678077f, 0.16307816f, 0.33933067f, 
    -0.24543168f, 0.16145870f, 0.14187013f, 0.27967507f, -0.12093334f, 0.10562816f, 0.29400846f, -0.03793281f, 
    0.10226533f, 0.34067550f, -0.03573297f, -0.31306994f, -0.43981317f, -0.18614979f, -0.31798935f, 0.00371017f, 
    0.12079006f, -0.16963398f, -0.38622746f, -0.11346266f, 0.06702852f, 0.48010305f, -0.38623422f, -0.12466139f, 
    0.18065636f, 0.04518653f, 0.03082445f, 0.18603279f, -0.05019329f, 0.20903255f, -0.09996320f, 0.07082240f, 
    0.06284770f, -0.08251427f, -0.06431933f, 0.08657953f, -0.08806382f, 0.00396735f, 0.07978723f, 0.17872833f, 
    -0.15928517f, -0.34271377f, 0.07877102f, -0.06028076f, -0.02064677f, -0.06101983f, 0.09998400f, -0.06620762f, 
    -0.07254927f, -0.58800632f, -0.17973648f, -0.01535458f, -0.09408740f, -0.03880219f, -0.18372974f, 0.01284535f, 
    0.28709781f, 0.19559404f, -0.03101774f, 0.08724208f, -0.07914157f, -0.11170999f, -0.25192246f, -0.19414189f, 
    -0.29466152f, -0.02095411f, -0.48819953f, 0.29334801f, -0.28289306f, 0.12654179f, -0.07028197f, -0.04381935f, 
    -0.07407743f, 0.00085263f, 0.00936099f, -0.05255612f, 0.36835414f, 0.20311065f, 0.14991148f, 0.14913543f, 
    -0.08640407f, -0.13464096f, 0.17266509f, 0.36260036f, -0.22263940f, 0.02374462f, 0.05723629f, 0.12118255f, 
    0.16253187f, 0.10454679f, -0.09166809f, 0.19013707f, 0.14912464f, 0.11248235f, 0.17947434f, -0.15295616f, 
    0.03731336f, 0.00029155f, -0.00075565f, 0.11519086f, -0.07956902f, -0.06890567f, -0.08510884f, -0.14607795f, 
    -0.06922266f, -0.20356028f, -0.02121261f, 0.00066918f, 0.07656116f, 0.08244784f, -0.36723387f, 0.79120451f, 
    -0.39044851f, 0.23014362f, -0.09633312f, -0.21030141f, -0.01849959f, -0.04826217f, 0.20332472f, 0.17171095f, 
    0.05439625f, 0.05018927f, -0.03690966f, 0.00806016f, 0.02618922f, 0.07553988f, 0.06709827f, -0.03828770f, 
    -0.02409528f, -0.08854993f, 0.03009811f, -0.02855963f, -0.07963435f, 0.03071190f, 0.02762510f, 0.00920265f, 
    -0.03465445f, -0.08216853f, -0.02266762f, 0.00800711f, -0.05914819f, -0.06550328f, -0.06887217f, 0.03639656f, 
    0.06090439f, -0.06152261f, -0.06439295f, -0.07479032f, 0.05116872f, 0.02291593f, 0.00733344f, -0.02628341f, 
    -0.01861865f, 0.01919719f, -0.05762106f, -0.09613166f, 0.07475578f, 0.02431180f, 0.05222115f, 0.01679341f, 
    -0.06606874f, 0.03151192f, -0.02860812f, -0.07349081f, -0.03206545f, -0.07673986f, -0.00010089f, -0.00011896f, 
    -0.06265326f, -0.05521259f, -0.07586266f, -0.02644031f, 0.06490345f, -0.06794427f, -0.00777480f, -0.06327283f, 
    -0.01772495f, -0.06838422f, 0.07270057f, -0.08655989f, -0.03201349f, 0.01799176f, -0.01970176f, 0.05326878f, 
    -0.04214018f, -0.07623837f, -0.02209359f, -0.03444308f, -0.05305818f, -0.03118873f, 0.02297933f, 0.02427032f, 
    0.02833401f, 0.02146844f, 0.03660060f, -0.05879811f, 0.03058404f, -0.04064790f, 0.03221634f, -0.04024959f, 
    0.03926907f, -0.02801965f, -0.04284030f, 0.06311781f, -0.01497349f, 0.07154130f, -0.07396314f, 0.02586300f, 
    -0.07963859f, 0.05015527f, 0.03113031f, -0.06022517f, 0.04792151f, 0.06134892f, 0.04476475f, -0.07482492f, 
    -0.04157716f, 0.03243718f, -0.08056070f, -0.02944042f, -0.03693806f, -0.03805239f, -0.01747863f, -0.04252494f, 
    0.00012329f, -0.07702485f, -0.08600037f, -0.07201008f, -0.01909416f, 0.06406081f, 0.04771195f, -0.06820416f, 
    0.03254103f, -0.07268018f, 0.05653678f, -0.03247372f, -0.02830897f, -0.03531960f, -0.06730027f, -0.09043790f, 
    0.06899153f, -0.03112455f, 0.06391189f, -0.06700397f, -0.04479546f, -0.02605507f, 0.02451811f, 0.03781164f, 
    -0.05032020f, 0.03984973f, 0.01703776f, -0.01270862f, -0.08157046f, 0.06536350f, -0.08064457f, 0.03265695f, 
    -0.02951842f, 0.00276068f, -0.07927778f, -0.09228676f, -0.02766390f, 0.01826471f, -0.06350937f, -0.06151559f, 
    -0.20017087f, -0.42096359f, 0.20870003f, 0.23261288f, -0.16442634f, 0.14043812f, -0.11968593f, -0.19503370f, 
    -0.10748158f, -0.18640272f, 0.02454502f, -0.04333374f, 0.08906452f, 0.00839370f, 0.12255829f, 0.09580301f, 
    0.01289252f, -0.11994725f, -0.17435865f, -0.23805439f, 0.12438424f, -0.11118294f, -0.03672755f, 0.16427973f, 
    -0.05477219f, -0.19975790f, -0.22690423f, -0.20580752f, 0.38478106f, 0.07940698f, -0.06784286f, 0.03152123f, 
    -0.00074577f, -0.06551142f, -0.06722256f, -0.03227256f, -0.23547593f, 0.11798662f, 0.24443577f, -0.21381082f, 
    -0.00636967f, -0.17927612f, -0.06228319f, 0.25242013f, 0.30337691f, -0.11951253f, 0.08536886f, -0.08018853f, 
    -0.31913733f, 0.21791190f, -0.02975179f, -0.04123993f, 0.04605595f, 0.04124849f, -0.03585686f, 0.13816500f, 
    0.23119691f, 0.20220490f, -0.05081173f, 0.08510256f, 0.02044981f, -0.00354481f, -0.10174055f, 0.18752936f, 
    0.16929968f, 0.58229274f, -0.15429759f, -0.20917179f, -0.08168593f, -0.09712981f, 0.19618361f, 0.36546251f, 
    0.04931849f, 0.18408085f, -0.53404307f, 0.13147303f, 0.14280859f, -0.02716858f, 0.03151603f, 0.11008648f, 
    -0.06779449f, 0.06013826f, -0.08973371f, -0.58025312f, 0.04534642f, 0.01604754f, -0.05205205f, 0.02798080f, 
    0.09919816f, 0.01905057f, -0.33667931f, -0.18695962f, 0.26811922f, 0.19575991f, 0.01851156f, 0.11545195f, 
    -0.05759519f, -0.07582110f, 0.12185470f, 0.04861605f, -0.16194040f, 0.56731850f, 0.14377889f, -0.12434519f, 
    -0.03045936f, -0.01512703f, 0.11115575f, 0.01178864f, 0.45394346f, -0.17514789f, 0.02156656f, -0.11262792f, 
    0.00600458f, 0.11856073f, 0.01297703f, 0.07899213f, -0.04935206f, -0.73437947f, -0.13344787f, 0.04627465f, 
    0.00291308f, 0.26672059f, -0.14443627f, -0.03621292f, 0.27534166f, -0.01713921f, 0.01922422f, -0.33875608f, 
    -0.19320534f, 0.02520330f, -0.06337040f, 0.04803446f, 0.11737376f, -0.14143655f, 0.06311245f, -0.15101551f, 
    -0.14840728f, -0.39517727f, 0.28810433f, 0.18209554f, -0.02504546f, -0.02495574f, -0.01773237f, 0.15337105f, 
    0.16913949f, 0.21842735f, 0.19233747f, 0.26809147f, 0.00452934f, 0.12552370f, -0.01052383f, -0.08225385f, 
    0.07323030f, 0.00989068f, -0.24257924f, -0.09639394f, 0.02300547f, 0.02717444f, -0.04301887f, 0.02149078f, 
    0.05372110f, 0.09837998f, 0.46466285f, 0.34507889f, -0.17510654f, -0.31668776f, -0.12170977f, 0.04258052f, 
    0.10971908f, 0.33321279f, -0.05291256f, -0.55262154f, -0.29787853f, -0.02005616f, 0.07151373f, -0.11928315f, 
    -0.10335550f, -0.46547997f, 0.15275945f, -0.04234592f, -0.15017079f, -0.38119140f, -0.27765504f, 0.04352268f, 
    -0.06053078f, 0.05453945f, -0.07930607f, 0.10034561f, -0.11376080f, -0.08124983f, 0.05736047f, 0.10576006f, 
    0.18248311f, 0.14167705f, 0.05355687f, 0.25167388f, -0.00168093f, -0.08678012f, -0.98660392f, -0.17917554f, 
    -0.33706203f, 0.13672975f, 0.26190090f, 0.18856993f, 0.13465607f, -0.01701580f, 0.09578714f, -0.02529528f, 
    0.48831886f, 0.16602042f, 0.04432577f, -0.13138747f, -0.03887245f, 0.11031409f, 0.04935141f, 0.04173861f, 
    -0.62186164f, -0.11246168f, 0.18293734f, 0.10568890f, 0.16261506f, -0.01711015f, 0.02848435f, -0.05611041f, 
    0.10407967f, 0.34528551f, -0.12660263f, -0.58654302f, -0.19248636f, -0.07396323f, -0.03658446f, 0.07297593f, 
    0.11860679f, 0.13760585f, 0.28444719f, -0.08818497f, -0.25231063f, -0.11083848f, -0.36519814f, -0.30152860f, 
    -0.16411361f, -0.02433162f, -0.12264942f, 0.54647368f, 0.44773790f, 0.22842373f, 0.06148115f, -0.08782899f, 
    0.04012642f, 0.01227373f, 0.03463114f, 0.16710715f, 0.12033910f, 0.13609357f, 0.07035378f, -0.09840941f, 
    0.02191472f, 0.06316184f, 0.33858091f, -0.07565998f, 0.09171668f, -0.22679253f, 0.39550540f, -0.12692229f, 
    0.12579966f, 0.18513161f, 0.01049410f, 0.01397207f, 0.04413742f, -0.09919478f, -0.03645421f, -0.45286131f, 
    0.13631248f, -0.15628825f, 0.08050101f, -0.11256571f, -0.21201329f, 0.44477478f, -0.06167090f, 0.13717307f, 
    -0.07094912f, -0.38448906f, 0.27494770f, 0.08930733f, -0.09844376f, -0.13911615f, -0.01573169f, 0.01368895f, 
    -0.17283219f, -0.18099281f, -0.05500715f, 0.15555173f, 0.51684606f, -0.23023023f, 0.25483871f, -0.11432388f, 
    -0.08315783f, 0.34512210f, -0.20459968f, 0.19770554f, 0.21410538f, -0.11975243f, -0.03056036f, 0.13593012f, 
    0.01918360f, 0.06873561f, -0.06541167f, 0.18337470f, 0.06076391f, 0.13611805f, -0.36507317f, -0.06442169f, 
    -0.17070855f, 0.08190091f, 0.24855274f, -0.39931405f, -0.24206096f, -0.15459900f, -0.03075487f, 0.06006967f, 
    -0.16215253f, 0.02354145f, 0.02670630f, -0.27420878f, -0.59851843f, 0.00512509f, 0.17963146f, 0.14462654f, 
    0.18526155f, 0.00716342f, 0.13040721f, -0.16877356f, -0.51567906f, 0.36802003f, 0.37726888f, -0.51878870f, 
    0.03619176f, -0.14069614f, 0.15505563f, -0.07009243f, 0.22088595f, -0.18445873f, -0.06955195f, 0.04709288f, 
    -0.03144846f, 0.15016174f, 0.34331700f, 0.25094488f, -0.11046764f, 0.03545496f, -0.17879386f, 0.16458556f, 
    0.15402852f, 0.27345470f, -0.03600543f, -0.11151002f, -0.18988860f, -0.33033144f, 0.14043845f, -0.03276471f, 
    0.35600466f, -0.07299114f, 0.02479308f, -0.27000758f, 0.09016842f, 0.00305461f, 0.11718009f, -0.11560025f, 
    -0.10482478f, 0.27717030f, 0.19675384f, -0.13281229f, -0.07292543f, -0.01157621f, 0.24360603f, 0.14138862f, 
    -0.08224522f, -0.39826715f, -0.18098009f, -0.16275677f, 0.30527467f, -0.05541042f, 0.20457546f, -0.19719097f, 
    0.07449006f, -0.02395363f, 0.23099133f, -0.17317049f, -0.10825808f, 0.16285264f, -0.01398878f, 0.11081013f, 
    0.24156566f, -0.19784662f, 0.08399075f, 0.01831525f, 0.09373832f, -0.18690841f, -0.14759305f, 0.35896286f, 
    0.00452031f, 0.11058369f, -0.28760085f, 0.19011372f, -0.46267262f, 0.22333123f, 0.02283516f, 0.11357881f, 
    -0.17303364f, 0.16762429f, -0.15630482f, -0.00632557f, 0.20434175f, -0.19254783f, -0.05879603f, -0.13478112f, 
    -0.26099297f, -0.01188703f, -0.13306771f, 0.28007281f, -0.03466729f, 0.18878755f, 0.11919298f, -0.10036753f, 
    0.23221748f, 0.08134910f, 0.13739343f, -0.03062693f, 0.00578585f, -0.18318906f, -0.06773842f, -0.17857300f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08909519f, 0.18266273f, 0.30260348f, 0.22968651f, -0.00593291f, 0.29318461f, 0.43107602f, -0.01735042f, 
    -0.09012811f, -0.13827781f, -0.04441080f, -0.27743125f, 0.05230769f, -0.10196633f, 0.04730217f, 0.03205916f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03373652f, -0.62851679f, -0.80504340f, 0.52896774f, 0.04371062f, -0.30145064f, 0.25854239f, -0.57893682f, 
    0.20629947f, -0.65957248f, 0.50751334f, 0.02863159f, 0.14874843f, -0.49651170f, -0.07383164f, -0.01957850f, 
    -0.11845184f, 0.19425927f, -0.50230360f, 0.02697102f, 0.63825572f, 0.56083655f, -0.14751372f, -0.36188951f, 
    -0.18873154f, 0.26493248f, 0.16645859f, -0.51306999f, -0.06411009f, -0.42983532f, -0.59026927f, -0.66687316f, 
    -0.07690357f, 0.01183195f, -0.66837585f, -0.48622525f, 0.58786047f, 0.89434499f, -1.07861125f, 0.36166704f, 
    -0.19869496f, -0.98007286f, -0.55992728f, -0.01300482f, 0.00042641f, 0.10973414f, 0.68560284f, 0.19722255f, 
    -0.07354028f, -0.46100238f, 0.08910282f, -0.42804810f, -0.73335332f, 0.59734696f, 0.82157713f, -0.05933116f, 
    0.00942440f, 0.07102482f, -0.46674559f, 0.66460007f, 0.23755579f, -0.23046847f, -0.10885360f, 0.21880905f, 
    -0.13489388f, 0.15679483f, -0.20694602f, -0.25504750f, -0.37662280f, -0.08487162f, -0.19732523f, -0.31482854f, 
    0.13918772f, -0.24717362f, 0.38882902f, -0.32077393f, -0.19523278f, 0.80786771f, 0.13566181f, 0.31116769f, 
    -0.09880494f, 0.05448441f, 0.43204299f, 0.50614023f, 0.05023994f, -0.52735168f, -0.46627885f, -0.28173745f, 
    -0.22310695f, 0.26511559f, 0.20324843f, -0.40145504f, 0.12506883f, -0.12112399f, -0.17961906f, -0.64122540f, 
    -0.22772864f, 0.50323695f, 0.64521521f, 0.35031274f, -0.57094723f, 0.05098397f, -0.18306121f, 0.24963686f, 
    -0.18163624f, -0.76292491f, -0.20508918f, -0.32193616f, 0.04433026f, -0.68907392f, -0.16901441f, 0.03557754f, 
    -0.23332052f, -0.58063078f, -0.73937917f, -0.40951040f, -0.13847038f, -0.41577503f, -0.32148480f, -0.90500337f, 
    -0.08317421f, 0.65442246f, 0.36417136f, 0.28473449f, 0.21069631f, 0.67411917f, 0.48919421f, 0.14788543f, 
    -0.13280709f, 0.41711944f, -0.00852852f, -0.37576643f, 0.40689784f, -0.69182479f, 0.02836545f, 0.53882581f, 
    0.05557432f, 0.97298181f, -0.12696686f, -0.06613801f, -0.00583252f, 0.43972892f, -0.75391257f, -1.45200181f, 
    0.05151591f, -0.28513294f, -0.04978424f, 0.24784599f, -0.53027731f, -0.28074566f, -0.06717579f, 0.97781944f, 
    0.13998571f, -0.28393266f, 0.09973834f, -0.42070201f, 0.21526954f, 0.07764390f, -0.24703763f, 0.37458935f, 
    -0.03734560f, -0.28673211f, 0.53553945f, -0.84498245f, 0.24779075f, 0.15848462f, 0.48733628f, -0.13981071f, 
    0.20817181f, 0.29764357f, -0.46128795f, -0.63716155f, 0.15060619f, 0.11826400f, 0.83903062f, -0.57895869f, 
    -0.10837383f, 0.15575878f, 0.42224047f, -0.37638628f, 0.15174532f, -0.29034561f, 0.44589430f, 0.21556987f, 
    0.08740120f, -0.66205961f, -0.44343543f, 0.92114574f, 0.05871947f, -0.84818822f, -0.24928346f, 0.13325410f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.24204661f, -0.14399818f, -0.08119924f, -0.12233298f, 0.22095960f, 0.41899729f, -0.32977575f, -1.10716081f, 
    -0.25229624f, -0.13163336f, 0.52578980f, -0.20398694f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
