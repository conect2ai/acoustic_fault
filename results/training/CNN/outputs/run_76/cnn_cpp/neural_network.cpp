#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92122245f, 1.02358937f, 0.18416210f, 0.55077988f, -0.56136245f, -0.04400120f, 0.52584356f, 0.11495402f, 
    0.05681734f, 0.81845701f, -0.17387079f, 0.89203697f, 0.82862502f, -0.43821645f, 0.02957497f, 0.04213897f, 
    -0.30292565f, -0.09157057f, -0.87657398f, 0.70816821f, -0.14079331f, -0.94380635f, -0.05017009f, 0.60660297f, 
    -0.02291507f, 0.32936475f, -0.61227041f, 0.91415113f, 0.96004021f, 0.49690214f, -0.16306430f, 0.09029239f, 
    0.24685441f, -0.47061074f, -0.45938343f, 0.26749220f, -0.29538679f, -0.07837208f, 0.02812120f, 0.30392185f, 
    0.80035025f, 0.51737005f, 0.00473564f, 0.38645461f, 0.40645400f, 0.03393162f, 0.02869429f, 0.77954638f, 
    0.62698126f, 0.61800230f, 0.06041273f, -0.03750926f, -0.64874214f, 0.36217359f, 0.63152063f, 0.57168555f, 
    0.50415117f, 0.56738436f, 0.46050411f, 0.65269727f, -0.42538643f, 0.29598376f, -0.28441697f, 0.75037038f, 
    -1.08956015f, 0.80894494f, -0.82800567f, -0.14276867f, 0.43497899f, 0.06427636f, 0.10465690f, 0.19734578f, 
    -0.78979802f, 0.79542160f, 0.24919026f, -0.76043123f, 0.85817081f, -0.51451123f, -0.20306197f, -0.26137936f, 
    0.07903065f, 0.77350992f, 0.82342070f, 0.49380675f, -0.21084902f, -0.84640390f, -0.71154737f, 0.12228301f, 
    0.33717415f, 0.13266149f, -0.28777176f, -0.70458388f, -0.12627232f, 0.17917509f, -0.56387180f, -0.95770156f, 
    0.04596673f, 0.31125012f, 0.49437866f, -0.36614606f, -1.09350264f, -0.33414367f, -0.21273172f, 0.99705654f, 
    0.11858878f, -0.05649743f, -0.10222110f, -0.30940995f, 1.08639932f, 0.40446457f, 0.54767972f, -0.28406435f, 
    -0.90130949f, -0.11721059f, 0.15568246f, 0.22952962f, 0.25140563f, 0.65023196f, 0.82835120f, -0.05894545f, 
    0.05745410f, -0.06060025f, 0.62717551f, -0.66122633f, 0.12554458f, -0.55686510f, -1.14346766f, 0.39574611f, 
    0.49620610f, 0.54018891f, 0.69645178f, 0.33697480f, -0.26837283f, -0.23901540f, -0.11357969f, 0.02051670f, 
    0.14418174f, -0.00562733f, -0.65250379f, 0.23213667f, 0.45991921f, 0.31665763f, 0.79887950f, -0.53983736f, 
    -0.96749985f, 0.64989567f, 0.58644313f, 0.46009129f, -0.00007046f, 0.67396009f, -0.20627664f, 0.21625604f, 
    0.28311056f, 0.63455230f, -1.12735188f, 0.48401165f, 0.44435972f, 0.36798584f, 0.70629823f, -0.12921657f, 
    0.04970756f, -0.55451041f, -0.81560665f, 0.28844666f, 0.83850676f, 0.92994857f, -0.47701916f, -0.60455573f, 
    -0.14696433f, 0.37154213f, 0.20887138f, -0.35029498f, -0.54970121f, -0.68236756f, 0.48240140f, 0.59836084f, 
    -0.20904337f, -0.27549022f, 0.04464506f, -0.39865482f, -0.63444263f, -0.74058110f, -0.74639058f, -0.31303728f, 
    -0.03861411f, 0.38611805f, -0.32590365f, 0.06944915f, 0.25785360f, 0.08033517f, -0.53749496f, 0.98494560f, 
    -0.94692665f, 0.28286910f, -0.65182674f, 0.52734542f, 0.01809666f, 0.32899618f, -0.56428403f, -0.63331121f, 
    -0.86774278f, -0.46517351f, -0.19408491f, -0.51168269f, 0.75199270f, 0.02682942f, 0.18416524f, 0.82303035f, 
    0.56207621f, 0.42897549f, -0.30313012f, 0.68606305f, -0.62767678f, -0.05307709f, 0.49235833f, -0.47038063f, 
    0.87487566f, 0.69197857f, 0.82746005f, -0.56891179f, 0.50048310f, -0.35478577f, 0.10201715f, 0.24870442f, 
    0.21088548f, 0.53180593f, 1.02637053f, -0.96947855f, 0.13105868f, 0.54315829f, -0.00816417f, 0.65226519f, 
    0.05108218f, -0.43998611f, -0.03484624f, 0.71072286f, 0.55613470f, 0.59364372f, -0.52915877f, 0.36050981f, 
    0.31546608f, 0.07651582f, 0.30974653f, -0.13815892f, -1.07269728f, 0.18048307f, -0.71452081f, -0.48716891f, 
    -0.62481391f, 0.13059071f, 0.23521985f, -0.48393258f, -0.22348019f, -1.17038608f, 0.12295131f, 0.59523898f, 
    -0.18770474f, 0.27747786f, 0.22868523f, 0.17335188f, -0.20192423f, 0.52949297f, -0.76293933f, 0.07232920f, 
    0.73035711f, -0.49170414f, -0.36416039f, -0.46400404f, -0.25448787f, -0.49667531f, -0.39418805f, -0.57610202f, 
    0.37730023f, -0.84789073f, -0.63679636f, -0.34930941f, 0.05960387f, -0.57838535f, -0.47983521f, 0.30567393f, 
    -0.49784636f, -0.33671930f, 0.74319595f, 0.64581710f, 0.55562025f, -0.53329384f, 0.10835154f, -0.34335354f, 
    -0.41643542f, -0.52443039f, -0.93491292f, -0.73554069f, 0.74419194f, 0.86138010f, 0.52335787f, 0.09017865f, 
    0.15895891f, 0.36719462f, -0.70468372f, -0.57278293f, 0.05012449f, -0.55279130f, 0.32581592f, -0.47016534f, 
    0.26646864f, -0.69037706f, 0.93795663f, -0.66405314f, -0.69693166f, 0.05685915f, -0.83030277f, 0.49072951f, 
    -0.28226224f, -0.62832350f, 0.22689418f, -0.09416237f, 0.35099995f, -0.63994753f, -0.83940065f, -0.65521109f, 
    -0.87997717f, 0.04643941f, 0.02303845f, 0.50429755f, 0.45157313f, 0.36758578f, 0.78566074f, -0.85935837f, 
    -0.87963349f, -0.35236248f, -0.10787335f, -0.11836709f, -0.59373510f, 0.30247751f, 1.03421974f, -0.41142705f, 
    -0.11417323f, 0.50895119f, 0.87261730f, -0.22470623f, -0.40024012f, -0.20687582f, 0.90964025f, -0.16301458f, 
    0.67327994f, 0.54582113f, 0.25956300f, 0.13720082f, -0.34230295f, 0.20400080f, 0.31912461f, -0.85081363f, 
    -0.23383856f, -0.43706724f, 0.75468796f, 0.94354248f, 0.41223922f, 0.33812159f, -0.48872581f, 0.21518797f, 
    -0.83818775f, 1.05231798f, 0.64064747f, -0.34478292f, 0.05805125f, 0.07760058f, -0.34158644f, -0.23912139f, 
    -0.26028880f, 0.01729710f, 0.07328995f, 0.89577377f, -0.97346556f, 0.46847168f, -0.09896369f, 0.24412841f, 
    0.50511891f, 0.08512864f, 1.19733977f, -0.17136826f, -0.94377077f, -0.44270444f, -0.13916826f, 0.47078371f, 
    -0.49839431f, 0.10204745f, 0.40429765f, 0.59997141f, -0.64864278f, -0.17885828f, 0.40027362f, 0.68527430f, 
    0.11191038f, -0.38823265f, 0.68226206f, -0.45495906f, -0.47181594f, -0.54198545f, -0.41102138f, 0.37260717f, 
    0.83532476f, 0.30349815f, -0.37422961f, -0.27095476f, -0.71838808f, 0.84159935f, -0.62807506f, 0.77872866f, 
    0.34964666f, -0.87598318f, 0.33618069f, 0.36935249f, 0.42492795f, -0.47779810f, -0.56606841f, -1.05334973f, 
    -0.70425391f, -0.17764339f, 0.52792585f, 0.55132490f, 0.11367789f, 0.27110025f, 0.49092188f, -0.70455956f, 
    -0.82935804f, -0.13610627f, -0.65568745f, -0.54501516f, 0.60516822f, 0.26332769f, -0.18181229f, 0.37973219f, 
    -0.94220114f, 0.38607144f, 0.65560025f, -0.66244990f, 0.95607102f, -0.35953355f, 0.26385710f, 0.38437337f, 
    0.14711030f, -0.79468280f, -0.71909803f, 0.66352028f, 0.74695730f, 0.38267672f, -0.55883962f, 0.39550647f, 
    0.25155836f, 0.01441263f, 0.62879193f, 0.29585230f, 0.28532779f, -0.54923826f, 0.34646821f, -0.54459554f, 
    -0.28655845f, -0.44106492f, -0.54356384f, -0.59662282f, -0.92563957f, -0.41745734f, -0.31238040f, 0.40038264f, 
    0.52949208f, 0.04481270f, -0.35917398f, -0.30768919f, -1.42701685f, 1.11975503f, 0.02858615f, 0.22061910f, 
    0.39067128f, 0.00311328f, 0.02251561f, -0.17108528f, 0.10712931f, 0.52588147f, -0.85765135f, -0.56653363f, 
    -0.55732423f, 0.49606895f, -0.71387523f, -0.05322180f, 0.42890847f, 0.38537300f, 0.31289077f, 0.72848308f, 
    0.64704788f, 0.65539622f, 0.54998767f, 0.09824654f, 0.20651978f, -0.45550600f, -0.33109140f, -0.05370399f, 
    0.70225263f, 0.94757164f, -0.17489472f, 0.58849168f, 0.39860183f, -0.13673142f, 0.42239234f, 0.37069321f, 
    0.57229197f, 1.06287587f, 0.74132770f, -0.72731793f, 0.21526518f, -0.13871269f, 0.37446862f, 0.03410159f, 
    -0.46116376f, -0.64673394f, -1.35577929f, 0.35118726f, 0.52963930f, 0.42682970f, 0.56056583f, -0.04872011f, 
    -0.26176661f, -0.07843933f, 0.11705267f, 0.95724928f, -0.17987539f, 0.48523879f, 0.56353259f, -0.08756727f, 
    -0.33899429f, -0.02285543f, 0.40855595f, 0.24047098f, 0.76871485f, 0.35752410f, 0.72435969f, -0.56502122f, 
    0.03417266f, 0.45437101f, 0.37178370f, 0.11212254f, 1.11106491f, 0.03986837f, -0.88902050f, 0.35217181f, 
    0.41050825f, -0.38057157f, -0.22008172f, -0.39091924f, 0.29911974f, 0.71774089f, -0.93911111f, -0.51375347f, 
    0.89448571f, -0.12462403f, -0.26455495f, -0.17117670f, -0.16824046f, -0.33987445f, -0.30525383f, 0.71837342f, 
    0.27647063f, -0.83088505f, -0.24351928f, -0.60825354f, -0.43874729f, 0.47259054f, 0.38461646f, 0.75557333f, 
    0.42421639f, -0.92055470f, 0.72841668f, -0.34671611f, -0.74108768f, -0.40445280f, 0.47121471f, -0.06614813f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22416158f, 0.22277629f, 0.09112075f, 0.14682256f, 0.33254829f, 0.09261351f, 0.31370312f, -0.09705000f, 
    0.28426215f, 0.22245006f, 0.03376671f, 0.15741625f, 0.04352329f, 0.00463201f, -0.02251809f, 0.20414618f, 
    0.17245837f, -0.01217646f, 0.14732561f, 0.26035523f, 0.22128077f, 0.01551987f, 0.16561466f, 0.15624470f, 
    0.16399726f, 0.12134465f, 0.21895914f, 0.34515280f, 0.26619151f, 0.31580672f, 0.09526374f, -0.09357096f, 
    0.19992752f, -0.01966754f, -0.10267615f, 0.15132248f, 0.05433022f, -0.01101045f, 0.18646775f, -0.13848069f, 
    0.07630071f, 0.07501295f, 0.04897953f, -0.02253280f, -0.13763347f, 0.05526527f, 0.24314742f, 0.19013426f, 
    -0.12151576f, 0.18229230f, 0.11430134f, 0.16769116f, 0.01862595f, 0.26003602f, 0.24616438f, -0.00548067f, 
    -0.01302230f, 0.24778531f, -0.19136551f, 0.09105555f, 0.21039857f, 0.25949931f, -0.04329749f, 0.27290824f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15542264f, -0.04364645f, 0.04180470f, -0.17331460f, 0.10772622f, -0.12637983f, -0.00161782f, 0.02408629f, 
    0.05710524f, -0.03172180f, 0.03124177f, 0.00800430f, -0.05405984f, 0.03339767f, -0.01931388f, 0.08239654f, 
    -0.00254427f, 0.06037616f, -0.01480753f, 0.00981687f, 0.20367579f, -0.23852527f, 0.03949526f, -0.00169309f, 
    -0.12053952f, -0.07423969f, -0.11841780f, -0.01928513f, -0.02855825f, 0.00008679f, -0.13722922f, 0.01260964f, 
    -0.08729484f, -0.06086741f, 0.01674743f, -0.00510507f, -0.01450633f, 0.11431094f, -0.02697687f, 0.05636237f, 
    -0.27997297f, 0.08268570f, 0.08600976f, 0.00023940f, 0.17280543f, -0.01934941f, -0.07584498f, -0.00217432f, 
    -0.04942346f, 0.00287524f, -0.03642601f, -0.03282544f, 0.08490031f, 0.01140133f, -0.01169190f, 0.00487969f, 
    0.00001317f, -0.09130562f, 0.01051978f, -0.06896690f, 0.07863933f, 0.09525615f, -0.05071443f, -0.09844614f, 
    0.19194260f, -0.11948564f, -0.16374795f, -0.03683287f, 0.04333116f, 0.00607947f, 0.02722807f, 0.02103532f, 
    0.03704579f, -0.00382657f, 0.01372355f, 0.06960461f, 0.13055114f, -0.04525280f, 0.00924246f, 0.08847401f, 
    -0.00810279f, 0.12030651f, 0.01631866f, -0.09287721f, -0.08673944f, 0.01436264f, 0.02573715f, 0.00379295f, 
    0.03117189f, -0.07318868f, 0.02850347f, -0.05772490f, -0.03768924f, 0.02228952f, 0.03197146f, 0.00914501f, 
    -0.01570538f, -0.00579833f, -0.00862252f, -0.00850835f, 0.03626109f, -0.08429258f, 0.18977302f, 0.03375485f, 
    0.00454369f, -0.12304519f, -0.05821450f, 0.00227353f, -0.03404118f, 0.01501035f, 0.00098889f, 0.00045486f, 
    -0.02536765f, -0.03286669f, -0.04308710f, -0.05725203f, 0.09593599f, -0.03542455f, -0.03307385f, 0.11496647f, 
    0.03204580f, 0.02544516f, -0.08913729f, -0.04292814f, 0.08095347f, -0.05509312f, -0.03971866f, -0.01754678f, 
    0.00636984f, -0.01518029f, -0.00275406f, -0.03103358f, 0.02417054f, 0.03204270f, -0.03287150f, 0.04845729f, 
    -0.01008893f, -0.04281726f, -0.05303790f, 0.02770842f, 0.33543083f, -0.11540113f, -0.01035402f, 0.03151454f, 
    -0.35491553f, -0.00383661f, 0.04832314f, 0.00824171f, 0.00148460f, 0.02116723f, 0.01093786f, 0.02380277f, 
    0.03403775f, -0.05024367f, 0.01165889f, -0.02570924f, -0.01185499f, 0.03953202f, 0.01140654f, 0.05305128f, 
    0.09677619f, -0.03615663f, 0.12479530f, -0.05908412f, 0.01925254f, -0.03715285f, -0.01586144f, -0.01479822f, 
    -0.04439986f, 0.01114445f, -0.01361479f, 0.00263228f, -0.04628981f, 0.00072429f, 0.00645681f, -0.04768028f, 
    -0.07071709f, 0.06511997f, -0.02768646f, -0.01833102f, 0.01742503f, 0.04118646f, 0.06999931f, -0.09316256f, 
    0.08093835f, -0.09878722f, -0.07974599f, -0.01312212f, 0.02993532f, -0.00500799f, 0.01199011f, -0.02855936f, 
    -0.04122713f, -0.02273210f, -0.06564949f, 0.00587211f, 0.00572463f, 0.04825176f, 0.05836776f, -0.08174991f, 
    -0.27349856f, -0.39732128f, 0.07012337f, 0.00270248f, -0.01816705f, 0.00941131f, -0.07042182f, -0.00716033f, 
    -0.00581587f, 0.00481002f, -0.13243513f, -0.04521081f, 0.02772388f, -0.03022389f, 0.04526255f, 0.05593976f, 
    0.00235062f, 0.05559707f, -0.10196038f, -0.23509550f, -0.22779223f, 0.13628431f, 0.06261596f, -0.13364172f, 
    -0.33474445f, 0.01352679f, 0.05797073f, 0.01394275f, 0.02720604f, -0.01923386f, -0.01728488f, 0.04584933f, 
    -0.01750838f, -0.01458385f, -0.00972013f, -0.04656104f, 0.00779562f, 0.05124006f, -0.05663302f, -0.01547888f, 
    0.20404470f, -0.01522708f, 0.02770209f, -0.14761929f, 0.00789487f, -0.04090944f, -0.06314708f, -0.11529420f, 
    0.03874104f, -0.01111993f, -0.05087481f, -0.04457699f, -0.00625487f, -0.00219848f, 0.00144672f, 0.05350927f, 
    -0.00414224f, -0.00606994f, 0.10616627f, 0.00823871f, 0.16242538f, 0.07230593f, 0.03961438f, -0.11669637f, 
    0.23995221f, -0.12633739f, -0.03278900f, -0.04982865f, 0.03010867f, -0.01192027f, -0.09503345f, 0.02346846f, 
    0.01050063f, -0.05186258f, 0.04300107f, 0.05972665f, 0.06375659f, -0.10700991f, 0.01338964f, 0.01890678f, 
    0.29157346f, 0.13005382f, 0.21211174f, 0.10460802f, 0.05889111f, 0.00933048f, 0.01280339f, 0.04412376f, 
    0.03423002f, 0.00368477f, 0.02779173f, -0.05196856f, -0.00459411f, -0.03824282f, 0.01943555f, 0.07829595f, 
    -0.00822491f, -0.08137543f, 0.04614967f, 0.06118417f, -0.23603979f, -0.01221329f, -0.07034718f, -0.02322134f, 
    0.06917156f, -0.03044294f, -0.00169085f, -0.08962420f, -0.09491873f, 0.04404010f, 0.00430823f, -0.07989205f, 
    0.09955898f, -0.00047776f, -0.00825036f, -0.03467133f, -0.01127474f, -0.12910604f, -0.04292675f, -0.08253627f, 
    -0.06736601f, 0.04760664f, 0.08372953f, 0.09014127f, 0.04829160f, -0.02161709f, -0.03404330f, 0.03585263f, 
    0.01063377f, -0.07663190f, 0.05536256f, -0.05790002f, -0.00712098f, -0.04164046f, 0.05084711f, -0.03856103f, 
    -0.03477332f, 0.03783882f, -0.04245960f, 0.07073042f, 0.18741813f, 0.10818313f, -0.00835924f, -0.08031091f, 
    -0.18400289f, -0.01117198f, 0.06232730f, -0.01547097f, -0.06696257f, 0.00450297f, -0.01235317f, -0.01147083f, 
    -0.01429320f, -0.05386986f, -0.02425482f, 0.04481064f, -0.00449344f, -0.02249225f, -0.01440212f, 0.00906137f, 
    -0.32232675f, -0.05896990f, 0.14299618f, 0.07987890f, -0.00576998f, 0.01161527f, -0.17980507f, 0.00315464f, 
    -0.12629302f, 0.00346071f, -0.05412513f, 0.03447832f, -0.02515648f, -0.00686977f, -0.04085902f, -0.03776200f, 
    0.00144644f, 0.02647320f, -0.03308885f, -0.08735416f, 0.00283810f, 0.01659435f, 0.03044188f, -0.10620985f, 
    -0.17392886f, 0.01644514f, -0.02522564f, 0.05605001f, -0.04090986f, -0.06261018f, 0.03225185f, -0.00833263f, 
    0.01185780f, -0.02609088f, 0.00928106f, -0.03700842f, 0.04131873f, 0.01055275f, -0.01151261f, -0.04649884f, 
    -0.15504505f, 0.10772982f, -0.18840541f, -0.04274277f, -0.22669269f, 0.03805304f, -0.01074922f, -0.04844645f, 
    0.05993281f, -0.05151305f, 0.05553247f, -0.01475898f, -0.00931946f, 0.03082676f, -0.03624295f, 0.01413521f, 
    -0.09948994f, 0.04251977f, -0.04435118f, 0.00904645f, 0.23948506f, -0.10120843f, -0.02219939f, 0.17447972f, 
    -0.21438190f, -0.11992453f, -0.04161526f, -0.00218658f, 0.03480008f, -0.03480243f, 0.01515673f, 0.07650626f, 
    -0.03456909f, 0.01744574f, -0.08085948f, -0.03324090f, -0.02893241f, -0.00296811f, 0.02652534f, -0.00805644f, 
    -0.18310073f, -0.37080586f, -0.04291508f, 0.09012835f, -0.03497395f, -0.04925335f, -0.06957244f, 0.05045420f, 
    0.11041802f, 0.02623509f, 0.07185901f, -0.06690454f, -0.07397268f, 0.01903790f, 0.14115945f, 0.07200594f, 
    0.04039940f, 0.02325016f, 0.02960269f, -0.06277135f, 0.05692720f, 0.00535171f, 0.01374384f, -0.16664381f, 
    0.08865961f, -0.08242611f, -0.09538840f, -0.14021796f, 0.03713343f, 0.07119278f, -0.02246824f, 0.07791372f, 
    0.02999000f, -0.06818222f, 0.00516108f, 0.02907489f, -0.03717529f, -0.06918874f, 0.03136795f, -0.07118231f, 
    0.06709316f, 0.10237253f, -0.04549592f, -0.09715565f, 0.01940607f, -0.12898880f, -0.07386576f, -0.13688435f, 
    0.07759441f, 0.03810009f, -0.05102959f, 0.02622568f, -0.09056409f, -0.01790348f, 0.02678435f, -0.06354396f, 
    0.03556897f, -0.00114042f, -0.01959212f, -0.02333510f, -0.04143146f, 0.08278847f, 0.15211381f, -0.12288939f, 
    0.28121999f, -0.06720743f, 0.02755933f, 0.11736638f, 0.04253993f, -0.05246761f, -0.10814309f, 0.02957121f, 
    -0.01666489f, 0.02447502f, 0.08775256f, 0.00179479f, -0.01672441f, 0.00793085f, -0.01427995f, -0.11497328f, 
    -0.17045726f, -0.03076166f, 0.04087070f, -0.01317807f, 0.01982807f, -0.04915811f, -0.08386681f, 0.04373067f, 
    -0.09523805f, 0.01189512f, 0.01291263f, -0.04086518f, -0.01171531f, 0.00929258f, 0.04632965f, -0.01878676f, 
    -0.01459764f, -0.01293539f, -0.11466892f, -0.03138012f, 0.01442896f, -0.35659769f, -0.04696715f, 0.09196413f, 
    -0.24116150f, -0.09351045f, -0.04562724f, 0.05473577f, -0.03455881f, -0.00051105f, 0.01586415f, 0.02039864f, 
    -0.07349651f, -0.07522487f, -0.05528738f, 0.05732167f, -0.04575080f, 0.00724931f, -0.03122365f, 0.02789156f, 
    0.06317225f, -0.02963345f, 0.00237897f, -0.14048561f, -0.25048128f, 0.09125819f, 0.06238198f, -0.00991832f, 
    0.05116904f, 0.00493526f, -0.01526850f, 0.04973398f, -0.01910156f, -0.03084755f, 0.00609444f, -0.00764036f, 
    -0.04185038f, -0.03665516f, 0.02532032f, -0.00278724f, 0.13150761f, -0.14651325f, 0.13654652f, 0.02699773f, 
    -0.09135816f, 0.11654861f, -0.03265641f, -0.03495454f, -0.03103764f, -0.04609241f, -0.10009395f, 0.05402378f, 
    -0.02774027f, 0.07603872f, 0.01272497f, 0.08668161f, 0.03682414f, 0.03130497f, -0.08065616f, 0.02086157f, 
    0.00534061f, -0.26094270f, -0.17041801f, 0.19429256f, -0.03315794f, -0.09268837f, -0.07953424f, -0.00196246f, 
    0.06029428f, -0.00271383f, 0.04409005f, 0.01936535f, -0.09446839f, -0.01968454f, -0.00102241f, 0.07091611f, 
    -0.03274240f, -0.02100057f, -0.01813367f, 0.02814722f, 0.13211264f, 0.12548012f, -0.04676801f, -0.06608967f, 
    -0.04380741f, 0.05521019f, 0.07116926f, 0.02772143f, -0.06951326f, -0.06916685f, 0.01801396f, 0.01352557f, 
    0.08292624f, 0.02168334f, -0.00709593f, 0.09026556f, 0.10784642f, 0.00424871f, -0.03072439f, 0.10717060f, 
    -0.33466449f, 0.25377283f, -0.06837218f, -0.07501440f, -0.17044725f, -0.00750352f, -0.00131216f, -0.07114495f, 
    0.03974085f, 0.00028645f, 0.03464657f, -0.00347568f, -0.01204070f, 0.11274259f, 0.04189746f, 0.02081616f, 
    -0.03908604f, -0.00421482f, 0.01809626f, -0.04737632f, 0.27558750f, -0.36545193f, 0.07775557f, -0.01398904f, 
    -0.14606655f, -0.03718065f, 0.05158268f, -0.03951867f, -0.07898204f, -0.02533858f, -0.12285364f, -0.17411108f, 
    0.06673140f, 0.00289381f, -0.05859093f, 0.03599233f, -0.08409825f, -0.02666978f, -0.03366731f, -0.05065178f, 
    0.18170652f, -0.46726802f, 0.15812716f, 0.24281836f, -0.08638993f, 0.10030568f, 0.13429011f, -0.01676196f, 
    0.08780818f, -0.07956298f, -0.21176264f, 0.03523014f, 0.01801434f, -0.01106752f, 0.12727283f, 0.03834385f, 
    0.05584853f, 0.09980700f, -0.00189235f, -0.07919519f, -0.12218715f, -0.19900657f, 0.14495026f, 0.03806278f, 
    0.06073932f, -0.03570708f, 0.00466667f, -0.04454517f, 0.04209226f, 0.05562811f, -0.01413612f, -0.00459813f, 
    0.00844640f, 0.01505840f, -0.05175157f, 0.00476803f, -0.01302177f, 0.02372354f, 0.02592442f, -0.14697030f, 
    0.14320374f, 0.06824351f, -0.03961283f, 0.10286818f, 0.05829608f, -0.02556840f, -0.11214311f, -0.03940687f, 
    0.03497783f, 0.04874734f, -0.01272266f, -0.03140002f, -0.02019448f, -0.03326799f, 0.04344530f, 0.04157478f, 
    0.05113792f, -0.01535456f, 0.04721364f, 0.05812104f, -0.06211983f, 0.01446998f, -0.00104188f, -0.21484143f, 
    0.31438091f, -0.05151219f, -0.01873606f, 0.03622675f, 0.06490471f, -0.09018024f, -0.03114849f, 0.06396952f, 
    -0.03317563f, -0.07102892f, 0.08554422f, 0.00464868f, 0.12870112f, -0.12320211f, -0.07606747f, 0.02624431f, 
    0.20525600f, -0.07089078f, -0.00358493f, -0.05541055f, 0.01219483f, 0.02963897f, -0.06064351f, 0.02095503f, 
    0.05226441f, -0.02629104f, -0.07963756f, 0.04305869f, -0.02128601f, 0.04448363f, 0.03109962f, -0.04028485f, 
    -0.01885378f, 0.02959070f, -0.04544592f, 0.03200051f, 0.32338163f, 0.06291030f, 0.16409560f, -0.17479323f, 
    -0.15456226f, 0.01240374f, 0.10339032f, -0.08108864f, 0.05877323f, -0.06899801f, -0.01183525f, -0.02331202f, 
    -0.04023254f, 0.10320313f, 0.06640390f, 0.16949339f, 0.12426275f, -0.01981702f, 0.05759516f, -0.03852935f, 
    -0.10887136f, 0.13921982f, 0.11044016f, 0.12392112f, 0.23219801f, -0.01127169f, -0.11367574f, -0.01595595f, 
    0.04380924f, 0.00055095f, 0.07856037f, -0.00992955f, 0.01193879f, -0.00260759f, -0.04079670f, 0.09170653f, 
    -0.01221175f, 0.01743500f, 0.10068182f, 0.04595956f, 0.04266576f, -0.04476902f, -0.06030953f, 0.13521795f, 
    -0.09285873f, -0.02071363f, 0.02020914f, -0.03632327f, 0.01795261f, -0.02187877f, 0.03389093f, 0.02606854f, 
    0.05529859f, -0.01093789f, -0.04833376f, -0.05971830f, -0.03746162f, -0.01252722f, -0.07730369f, -0.06720953f, 
    -0.04488371f, -0.15193158f, -0.03098743f, 0.05677282f, 0.06122930f, 0.06311654f, 0.02573724f, -0.03479255f, 
    0.06304853f, -0.04862966f, -0.08057158f, 0.01504840f, 0.05106181f, 0.04850636f, -0.00549583f, -0.00175640f, 
    -0.03142703f, -0.09583330f, 0.03522702f, -0.00639277f, 0.07587441f, 0.05037903f, -0.01934578f, -0.10605969f, 
    -0.02237149f, 0.00131336f, -0.00932479f, -0.05501723f, -0.02588581f, 0.05850115f, -0.05140859f, 0.05633227f, 
    0.12816705f, -0.01822025f, -0.03237130f, -0.04123171f, 0.07327111f, 0.02403804f, -0.05236425f, -0.00904735f, 
    -0.04509894f, 0.15883042f, 0.14229761f, -0.10235743f, -0.25044858f, 0.08701329f, 0.06459913f, 0.02258982f, 
    0.00600087f, -0.00460447f, 0.06423777f, -0.00004040f, 0.03280670f, 0.07232064f, -0.04352047f, -0.03149393f, 
    0.09735455f, 0.02984065f, 0.01191057f, -0.00094953f, 0.15976962f, -0.15667690f, -0.04374601f, -0.07709432f, 
    -0.23166715f, -0.07669923f, 0.06140153f, -0.01602191f, -0.00616419f, -0.02008117f, -0.07740947f, 0.00251360f, 
    -0.01023385f, 0.01968529f, -0.01378884f, -0.04172160f, -0.07215659f, 0.02539386f, 0.01415978f, -0.00353815f, 
    -0.16712444f, 0.14228185f, -0.20506255f, -0.10121989f, -0.18323003f, 0.00311754f, -0.05091690f, 0.04067623f, 
    0.02626371f, -0.01217428f, 0.04701664f, 0.00236060f, -0.04341246f, 0.03842676f, 0.00830590f, 0.01300995f, 
    -0.04291607f, 0.00359172f, -0.01530134f, -0.00600256f, -0.17824890f, -0.09087572f, -0.13074064f, 0.12636152f, 
    -0.12932746f, -0.02948342f, -0.02525316f, -0.12598926f, 0.04165200f, -0.01129446f, -0.00438447f, 0.02666031f, 
    -0.04551314f, -0.10972802f, 0.02652832f, -0.05717814f, 0.07327415f, -0.01785228f, 0.06001279f, 0.00038842f, 
    -0.01418095f, -0.12359219f, 0.12118649f, 0.06064770f, -0.06705564f, 0.05939757f, -0.03366401f, -0.03257877f, 
    -0.02609359f, 0.03828096f, 0.03557621f, 0.11287589f, -0.00277436f, 0.04032975f, 0.01620603f, 0.04723457f, 
    -0.07732271f, -0.00423404f, 0.00504806f, -0.14939651f, -0.30011916f, 0.00292749f, 0.17505075f, -0.03854981f, 
    -0.23599048f, -0.09191083f, -0.08986256f, 0.03175496f, 0.05629034f, -0.04895584f, -0.06118308f, 0.06336029f, 
    0.05109470f, -0.01929069f, -0.04994325f, 0.01029888f, 0.04091474f, 0.01462046f, 0.02854147f, 0.04485112f, 
    0.11410011f, 0.04555609f, 0.02924281f, 0.05428570f, 0.05994169f, -0.04667164f, -0.00706964f, -0.05079854f, 
    -0.00806845f, 0.01399247f, 0.01891612f, 0.05476373f, -0.00841689f, -0.06676306f, 0.02920810f, 0.04085633f, 
    0.01027759f, -0.03376712f, 0.00310379f, 0.03054714f, -0.21442476f, 0.15350330f, -0.04188289f, -0.10642059f, 
    -0.22300218f, 0.00988804f, 0.04104339f, -0.02892190f, 0.09570100f, -0.00272100f, 0.00471800f, -0.02098045f, 
    -0.04234168f, 0.02009786f, -0.02964825f, -0.03324853f, -0.07496227f, -0.04932374f, 0.02815751f, 0.01607018f, 
    0.52327698f, 0.05522472f, 0.15191300f, -0.03728667f, 0.17169894f, -0.01580423f, -0.11953594f, 0.04802760f, 
    -0.01067746f, -0.08048901f, 0.03079450f, -0.02976542f, -0.03218108f, -0.00823786f, 0.03702790f, -0.01038174f, 
    -0.07985079f, 0.06023008f, -0.03680823f, -0.02704265f, -0.20600781f, -0.32410312f, 0.06312638f, 0.03426650f, 
    -0.06284089f, -0.01561876f, -0.10482348f, 0.03304011f, -0.04915066f, 0.07698567f, -0.02842702f, 0.13757753f, 
    -0.06415441f, 0.02394600f, -0.02756389f, -0.06100551f, -0.07098837f, -0.06657740f, 0.03659603f, -0.04241354f, 
    0.04537334f, -0.02959020f, 0.10589986f, -0.03878333f, 0.06648654f, -0.09703953f, -0.11950637f, 0.08888756f, 
    -0.00077163f, -0.00884982f, 0.06100599f, 0.01592147f, -0.02308782f, -0.02709140f, -0.02954041f, -0.00331954f, 
    -0.01813902f, -0.04524312f, -0.05289509f, -0.00542907f, -0.30554330f, 0.02020884f, -0.00575304f, 0.15135394f, 
    0.16400637f, 0.06264903f, 0.00345856f, 0.05404811f, -0.01658301f, -0.01851848f, 0.05937155f, -0.03982377f, 
    0.09116904f, 0.03450016f, 0.00015769f, -0.04309654f, 0.00230465f, -0.00470607f, -0.01038920f, 0.00364832f, 
    0.08725828f, 0.15788354f, 0.02536052f, -0.13506567f, 0.26838562f, -0.10286678f, -0.15702036f, -0.04016839f, 
    0.01719068f, 0.02042726f, 0.00905473f, 0.03360641f, -0.02829235f, -0.01988389f, 0.10511977f, -0.00670831f, 
    -0.00145518f, -0.01017203f, 0.02172021f, -0.03160155f, -0.13300993f, 0.09004723f, 0.08126298f, -0.06715126f, 
    -0.28158200f, 0.06142192f, 0.04343003f, 0.04025412f, 0.06949668f, -0.05937816f, -0.00988973f, -0.00884183f, 
    -0.05232416f, -0.07332640f, -0.07133462f, -0.00529454f, 0.02717315f, -0.02586403f, 0.03930363f, 0.04839623f, 
    0.26735386f, -0.05032643f, 0.04257852f, -0.02024534f, 0.21784560f, -0.00549784f, -0.10495380f, 0.03896019f, 
    0.00683234f, -0.04108649f, 0.08594788f, -0.03476376f, -0.01927490f, 0.05768659f, 0.03014149f, -0.03847285f, 
    0.06073923f, 0.11281854f, -0.06766042f, 0.07930263f, -0.13199185f, 0.01310991f, 0.08955831f, -0.04991761f, 
    0.02970175f, -0.09158043f, -0.05024867f, 0.06979698f, -0.03612272f, 0.01408713f, 0.01850410f, -0.04777884f, 
    -0.00965235f, 0.01820481f, 0.00980483f, -0.01775885f, 0.00531982f, 0.02077158f, -0.06697635f, -0.03403999f, 
    -0.08941863f, -0.10946752f, 0.07942590f, 0.07708064f, 0.33081716f, -0.11352190f, -0.01006336f, 0.01834879f, 
    0.06084118f, -0.07530056f, -0.00043287f, 0.06235152f, 0.06122341f, 0.01256834f, -0.09023846f, 0.07939107f, 
    -0.03545712f, -0.04611491f, -0.08230937f, -0.01102936f, 0.13661586f, -0.12177943f, 0.12155035f, 0.05445252f, 
    -0.01127083f, 0.05209066f, -0.01420803f, 0.02189079f, -0.03525504f, -0.03620625f, -0.04132640f, 0.02910120f, 
    0.05409899f, -0.00991410f, 0.07848665f, 0.04914223f, 0.09838755f, 0.02419041f, -0.04588578f, -0.00789255f, 
    -0.11782873f, -0.05440781f, 0.09068553f, 0.00529250f, 0.11593901f, -0.01467595f, -0.00374178f, -0.05001163f, 
    0.01177607f, 0.01039347f, -0.06484931f, 0.00753561f, -0.09608714f, -0.02551931f, -0.01419671f, -0.11790481f, 
    0.05033558f, 0.05740770f, 0.07207042f, -0.03787542f, 0.10507958f, -0.17701997f, 0.11038064f, -0.01491112f, 
    0.17700352f, -0.03424711f, 0.01102272f, 0.03348142f, -0.00800176f, 0.01181151f, -0.04861182f, 0.04843357f, 
    -0.01295180f, 0.03058490f, -0.09192753f, 0.00578553f, 0.05423650f, 0.01208245f, 0.00837541f, 0.03149717f, 
    0.00172870f, 0.02572032f, 0.14283846f, 0.12161782f, 0.13438530f, -0.01948615f, -0.09122822f, 0.04784503f, 
    -0.00467750f, -0.00477041f, -0.07036772f, 0.00396738f, 0.07017957f, 0.05852848f, -0.02881933f, -0.05985144f, 
    0.02274225f, -0.08642469f, 0.01204819f, 0.01235756f, -0.03906468f, 0.15816212f, 0.12695920f, -0.02306059f, 
    -0.01291780f, -0.08647931f, -0.00659557f, 0.03961734f, -0.01666603f, 0.04365434f, 0.06825783f, -0.00198443f, 
    0.09369320f, 0.00566463f, 0.05336297f, 0.05557845f, -0.01270362f, -0.00817861f, 0.01332458f, 0.08066563f, 
    -0.15906516f, -0.04377451f, -0.14096272f, -0.28915304f, 0.00518907f, 0.02699281f, 0.07275666f, -0.07794836f, 
    0.03135138f, -0.01928085f, 0.06594374f, -0.01098342f, -0.02377455f, 0.06003075f, -0.05826928f, -0.06980271f, 
    0.00311186f, 0.07221577f, -0.05052265f, 0.00320418f, 0.22726460f, 0.06185319f, 0.09214585f, 0.10665419f, 
    0.10601301f, -0.02326506f, -0.01652343f, 0.04944059f, 0.00915673f, 0.00583099f, -0.05302019f, -0.02682610f, 
    -0.10699809f, 0.07073718f, 0.01420929f, 0.01469177f, 0.02399317f, 0.05422974f, -0.01755975f, -0.05066046f, 
    -0.06298964f, 0.09876956f, 0.01281255f, 0.01557552f, -0.05379138f, -0.02624580f, 0.04097355f, 0.00142978f, 
    -0.01670604f, 0.06292877f, -0.10604114f, 0.02210401f, 0.00490761f, -0.04164615f, 0.01706188f, 0.05679971f, 
    0.03199298f, 0.00650168f, -0.03432430f, 0.01620905f, -0.10617405f, 0.07320281f, 0.01907290f, 0.03654983f, 
    0.12065566f, -0.00842189f, 0.04212924f, 0.02743201f, 0.00450534f, 0.02147669f, 0.01058505f, 0.11075472f, 
    0.01487724f, -0.02868602f, 0.03006284f, 0.02612255f, -0.05838063f, -0.01592075f, 0.01732104f, -0.04195672f, 
    0.20658758f, 0.14758569f, 0.06141516f, 0.04451487f, 0.09078228f, 0.04081846f, -0.02529701f, -0.03007687f, 
    -0.02366782f, 0.09426797f, -0.02080121f, 0.01926035f, -0.04149484f, 0.01882000f, -0.05713849f, -0.03809599f, 
    0.07270943f, 0.04093121f, 0.06590058f, 0.01681415f, -0.20054610f, -0.13984600f, -0.03202445f, 0.00180203f, 
    -0.05419377f, 0.04125086f, -0.01874351f, -0.05542779f, 0.00847766f, 0.00539843f, -0.01575890f, 0.01923889f, 
    -0.06822935f, -0.04862662f, -0.07159950f, 0.00541798f, -0.10981143f, 0.01130429f, 0.02716101f, -0.01251821f, 
    -0.10819182f, -0.00179118f, -0.23733810f, -0.20918106f, 0.06921384f, -0.05830837f, 0.08056485f, 0.00592203f, 
    -0.00114967f, 0.01726519f, 0.04486836f, -0.02552529f, 0.11346368f, -0.03747867f, -0.00886974f, 0.02968583f, 
    0.03342845f, 0.05344373f, -0.09563949f, -0.00028862f, -0.02299765f, -0.05389028f, 0.01093201f, 0.04569184f, 
    0.07082903f, 0.03983805f, -0.00250945f, 0.05338163f, 0.01339558f, 0.00067487f, -0.01005408f, 0.00987148f, 
    0.07698274f, 0.07756511f, -0.00601327f, -0.02151188f, -0.04160777f, -0.11889458f, -0.08858180f, -0.01348449f, 
    -0.22231495f, 0.01700427f, 0.01079234f, 0.03636383f, -0.06305590f, -0.03206839f, -0.07562482f, 0.14676732f, 
    -0.01660475f, -0.05421593f, 0.04994514f, -0.04932492f, 0.07427303f, -0.00364603f, 0.06661405f, -0.08703757f, 
    0.06217267f, -0.18975642f, -0.03919055f, 0.05004088f, 0.25142094f, -0.21937701f, -0.14249727f, -0.00929088f, 
    -0.07069369f, -0.06868684f, 0.00720424f, 0.01726177f, -0.02389596f, 0.05460736f, 0.07147913f, 0.04902981f, 
    -0.07455335f, -0.01857250f, 0.02189515f, 0.05749206f, -0.01490250f, -0.08625676f, -0.09330516f, 0.03767846f, 
    0.05763086f, 0.01783944f, 0.05887093f, 0.08682077f, 0.00933037f, -0.00728679f, -0.10277101f, 0.05290109f, 
    0.01841760f, -0.01134065f, 0.05877040f, -0.01041067f, 0.09849219f, 0.10677805f, 0.01153100f, 0.05933961f, 
    -0.07492869f, -0.08489737f, -0.05162094f, -0.02386380f, 0.11501800f, 0.04144208f, 0.08669744f, 0.10352629f, 
    0.14938648f, 0.02888286f, -0.08298923f, 0.00107005f, -0.02114645f, -0.00181026f, -0.00694658f, -0.04009398f, 
    -0.08648881f, 0.01564535f, -0.10860901f, -0.06772646f, -0.01979438f, 0.02150137f, 0.07551081f, -0.10030671f, 
    -0.35616314f, 0.02849881f, -0.07566743f, -0.04054313f, 0.02226662f, 0.00036763f, 0.01471672f, -0.05567734f, 
    -0.04813372f, -0.01912283f, 0.00312278f, 0.12873137f, 0.01746908f, -0.02450471f, -0.03472003f, 0.06785715f, 
    -0.16501559f, 0.08230028f, 0.03022466f, -0.02256566f, -0.00533929f, -0.08929433f, 0.00149769f, 0.06888042f, 
    0.00662489f, -0.01582536f, -0.00895312f, 0.01995704f, 0.05626895f, -0.04544028f, -0.03268237f, -0.01003038f, 
    -0.07895846f, 0.04026092f, -0.07655463f, -0.00476667f, -0.01054254f, 0.09429663f, 0.03587501f, 0.05366993f, 
    -0.05067310f, 0.03660307f, -0.10336453f, -0.05065049f, -0.00452943f, -0.03065822f, -0.05760488f, 0.00732458f, 
    -0.12415977f, 0.01005733f, 0.01322279f, 0.07740772f, 0.04015746f, -0.01650029f, 0.04544832f, 0.05116658f, 
    -0.02345273f, 0.03946368f, 0.05243123f, 0.03200793f, 0.21575297f, -0.23139147f, 0.05247322f, 0.06350382f, 
    -0.02091876f, 0.01392129f, 0.03821838f, 0.04854788f, 0.01918400f, 0.09382027f, 0.16871029f, 0.00375188f, 
    0.03431678f, -0.01355360f, -0.10528195f, 0.01138627f, 0.03998997f, -0.01650328f, 0.02000779f, -0.00792271f, 
    -0.00797987f, -0.04609650f, -0.04288398f, -0.01110105f, 0.04452699f, -0.10636882f, 0.05130551f, -0.01884745f, 
    -0.04281618f, 0.06855336f, 0.02175757f, 0.03028323f, 0.02578996f, -0.00486870f, -0.03115564f, -0.02136355f, 
    -0.06004679f, 0.00035541f, -0.02966859f, 0.11321290f, 0.08997102f, -0.09337473f, -0.16243435f, -0.03604088f, 
    -0.10913324f, 0.01059555f, -0.06465796f, -0.01969922f, 0.03637919f, 0.13594738f, 0.00420070f, 0.03536308f, 
    -0.00966221f, -0.03489935f, -0.01885338f, 0.00921865f, 0.04412258f, -0.02011467f, -0.04903730f, 0.04577965f, 
    0.11008006f, -0.02754306f, 0.02898531f, 0.03428498f, -0.08988272f, -0.03726882f, -0.06132662f, 0.09519793f, 
    0.02330606f, 0.03236301f, -0.05887118f, -0.11739796f, 0.07696027f, 0.01705366f, 0.00715062f, 0.03575408f, 
    0.09444457f, -0.08161022f, 0.04719153f, -0.07348018f, -0.30561000f, -0.22255766f, -0.12224948f, -0.01641462f, 
    -0.03171790f, 0.06936422f, -0.00245697f, -0.04153363f, -0.05506057f, -0.04632724f, 0.12271766f, 0.01373962f, 
    0.01376746f, -0.01182619f, 0.03725740f, -0.08902758f, -0.04483525f, -0.07411448f, -0.00775662f, -0.03607145f, 
    0.15317781f, 0.14352159f, -0.14926220f, 0.01122097f, -0.02174102f, 0.11706911f, 0.06513287f, 0.07956946f, 
    0.04098628f, 0.02760065f, -0.01509365f, -0.02175408f, 0.09034153f, 0.00107921f, 0.01826940f, 0.12018964f, 
    -0.00738846f, -0.13159733f, -0.05391305f, -0.08324329f, 0.17155792f, 0.01130122f, 0.05916597f, 0.08199354f, 
    0.19208635f, 0.03709963f, -0.05249339f, 0.03722607f, -0.03588074f, -0.00318239f, 0.05135467f, -0.10935463f, 
    -0.02978783f, 0.06505973f, -0.03676720f, -0.03677819f, 0.14633407f, 0.04164825f, -0.02179052f, 0.08054647f, 
    0.18532379f, 0.14154342f, 0.02104320f, 0.11088029f, 0.10431803f, -0.00307151f, -0.10102712f, 0.03110703f, 
    -0.02394247f, -0.02686846f, 0.12250603f, -0.00334373f, 0.03393385f, 0.06764990f, 0.01703687f, 0.03536335f, 
    0.09738810f, -0.00083208f, -0.05075575f, 0.00419223f, 0.14269346f, -0.21801466f, -0.02314075f, -0.11331819f, 
    0.02794549f, -0.12868606f, -0.06898338f, -0.01742279f, -0.06292132f, 0.05716833f, 0.11363889f, -0.02318203f, 
    -0.02200306f, 0.02464620f, 0.02827511f, -0.04560628f, 0.03321543f, 0.00741205f, -0.01091465f, 0.07074542f, 
    0.12745327f, 0.03915282f, 0.06001924f, 0.04294714f, 0.16676125f, 0.00756973f, -0.05343705f, 0.05897705f, 
    -0.06288377f, 0.07567301f, 0.00060099f, 0.07887933f, 0.04244082f, -0.01523930f, 0.02426891f, 0.03389950f, 
    0.00827920f, -0.00002364f, 0.04882396f, 0.07175352f, -0.08387371f, -0.01675414f, -0.02953058f, 0.04540996f, 
    -0.12473368f, 0.07447764f, 0.04636804f, 0.00282529f, 0.00919993f, 0.00448110f, -0.04065746f, -0.10611578f, 
    0.09842312f, 0.09355798f, 0.00934832f, -0.06184618f, 0.03863919f, -0.07820490f, -0.11450584f, -0.00093331f, 
    0.11421726f, 0.01718973f, -0.07245640f, 0.10094251f, -0.16681613f, 0.01940456f, 0.01499002f, 0.03979571f, 
    0.00805527f, 0.06898531f, 0.01040180f, -0.08582824f, 0.03630031f, 0.04412030f, -0.03987176f, -0.02909274f, 
    0.15014008f, 0.01973053f, -0.02321600f, 0.00408887f, 0.14993396f, -0.04141629f, 0.06079157f, -0.09972328f, 
    -0.09436509f, 0.00112849f, 0.07588081f, 0.00724880f, -0.02317811f, -0.00519934f, 0.00477648f, -0.04286881f, 
    0.05676126f, -0.05139368f, 0.05228975f, -0.04227872f, -0.07361641f, -0.10511344f, 0.08008976f, 0.07663852f, 
    -0.14061312f, 0.02674227f, -0.03652651f, -0.21087167f, -0.52005273f, 0.05951785f, 0.00462970f, -0.04322122f, 
    0.01933776f, 0.00998262f, -0.03787786f, -0.02548951f, 0.05152496f, 0.02458289f, -0.12495999f, -0.03928879f, 
    -0.07306290f, -0.07916281f, -0.09235384f, -0.17535090f, 0.21971375f, -0.22004475f, 0.01838361f, 0.02294494f, 
    -0.08023460f, 0.05329689f, 0.02525898f, -0.08745522f, 0.00881775f, -0.01939299f, 0.08220717f, 0.06975396f, 
    -0.04895860f, 0.05152729f, -0.15160671f, 0.00163717f, -0.00021873f, -0.04626619f, 0.03359755f, 0.00140711f, 
    0.28620827f, -0.06466772f, -0.05388888f, 0.04530470f, -0.06329004f, -0.07475206f, 0.04455937f, 0.03699536f, 
    0.06158082f, 0.02630916f, -0.02402467f, -0.07541063f, 0.08335881f, -0.05701207f, 0.05657342f, 0.07593063f, 
    -0.07545288f, 0.03798111f, -0.08491021f, 0.07661194f, 0.03478208f, -0.07176349f, 0.14279619f, -0.16599099f, 
    0.03182814f, 0.03486023f, 0.04793003f, -0.01922938f, 0.09076216f, 0.03680590f, 0.03683552f, 0.01386071f, 
    0.04623645f, -0.03103342f, -0.16877685f, -0.02961330f, 0.02489836f, -0.04933202f, -0.01481214f, 0.00864062f, 
    -0.15238211f, -0.18284295f, 0.06271989f, -0.35465774f, 0.07675353f, -0.12260725f, -0.05140146f, 0.08599663f, 
    -0.07479056f, 0.03439867f, 0.08545516f, -0.01504269f, -0.03174645f, -0.01025612f, -0.13809828f, -0.07399189f, 
    -0.07519630f, -0.06187456f, 0.11464932f, -0.07958364f, -0.00556969f, -0.14139611f, -0.06049976f, -0.17311269f, 
    0.05521331f, 0.02932761f, -0.09706317f, 0.12586980f, 0.02070483f, 0.01404702f, -0.15739977f, -0.04790938f, 
    0.01777478f, 0.00490194f, 0.12824193f, -0.10463161f, -0.01855920f, -0.11916132f, -0.03508829f, -0.04530462f, 
    -0.10429334f, 0.01353441f, -0.15089647f, -0.00232491f, -0.16509649f, -0.00189919f, 0.04930731f, 0.03446215f, 
    0.02663067f, -0.01873103f, -0.05403791f, -0.05526070f, -0.03541480f, -0.02748154f, -0.06208586f, -0.02336105f, 
    -0.08144176f, -0.05718407f, -0.04898870f, 0.02424663f, 0.13562198f, 0.11592782f, 0.10393056f, 0.03099029f, 
    0.09721079f, -0.09298281f, -0.05149281f, -0.09055780f, 0.04754261f, -0.08030757f, 0.09505188f, -0.00148626f, 
    0.00787632f, 0.12439841f, 0.01020376f, -0.04728295f, 0.04644892f, 0.10161641f, 0.04634922f, -0.00264253f, 
    0.22851534f, 0.07907318f, 0.03677339f, 0.06161663f, -0.00574558f, -0.16876106f, -0.02165093f, -0.02449405f, 
    -0.03876901f, 0.08300950f, 0.19444300f, -0.05654578f, 0.06887302f, -0.07437612f, 0.00933289f, -0.05578793f, 
    0.07169545f, -0.01489300f, 0.01657858f, 0.06374209f, -0.06973333f, 0.12801050f, -0.14196874f, 0.01294610f, 
    -0.06310848f, 0.02694586f, 0.09004313f, -0.00449305f, -0.10250159f, -0.00204261f, 0.03517566f, 0.01419041f, 
    -0.08900984f, -0.04946537f, 0.05079643f, 0.07304548f, -0.00573903f, -0.03397733f, -0.03188566f, 0.03944198f, 
    -0.01035485f, -0.00405998f, -0.31172502f, -0.21896034f, -0.08419459f, 0.01224524f, 0.11886632f, 0.03969227f, 
    -0.04752649f, -0.00906612f, -0.03222533f, -0.04899660f, 0.04545331f, -0.02586119f, -0.03283748f, -0.01463800f, 
    -0.07837216f, 0.04037266f, -0.08906180f, -0.06453229f, -0.25374961f, 0.06701332f, -0.04330722f, -0.01819649f, 
    0.03967293f, -0.01102135f, -0.03857581f, -0.04266230f, -0.01392857f, -0.02941045f, 0.05151491f, -0.03610494f, 
    -0.03442816f, -0.00253116f, -0.05297569f, -0.02213363f, -0.02554100f, 0.01798118f, -0.03548118f, 0.05267850f, 
    0.12942012f, -0.38257518f, 0.09400692f, -0.20702121f, -0.07245164f, -0.00154359f, -0.07137706f, -0.05123805f, 
    0.04569180f, -0.03287358f, -0.07517864f, -0.02413683f, -0.07398143f, 0.01245847f, 0.01809788f, 0.00631141f, 
    -0.08510853f, 0.04458791f, -0.02617471f, -0.14156568f, 0.33104262f, -0.11284867f, 0.05236246f, -0.01099603f, 
    -0.04895528f, 0.10160612f, 0.01766009f, 0.04772250f, -0.00139646f, 0.03852403f, -0.01507089f, -0.06096829f, 
    -0.08096011f, 0.09845144f, -0.11474141f, 0.11530958f, 0.10107739f, -0.03498282f, 0.01888043f, 0.07233195f, 
    0.07217731f, -0.10183072f, -0.08742645f, 0.01454565f, -0.08668002f, -0.00510483f, -0.07333332f, -0.02964416f, 
    -0.05102745f, 0.03908984f, 0.11597886f, 0.17400454f, -0.11477223f, -0.09564722f, 0.03068328f, 0.03615570f, 
    -0.02908940f, 0.02964712f, -0.03285133f, 0.08177497f, -0.01114068f, 0.17935370f, 0.10714101f, 0.02043535f, 
    -0.11915437f, -0.05642475f, -0.06653304f, -0.02376260f, -0.02184079f, 0.01316731f, 0.00890776f, 0.00050439f, 
    0.07342131f, -0.00436549f, -0.01262250f, 0.00249019f, -0.04874105f, -0.00546275f, -0.00520123f, 0.05689263f, 
    0.16087198f, 0.01983645f, 0.00912926f, 0.06147954f, -0.04529246f, -0.06817473f, 0.01892998f, 0.09896924f, 
    0.07798469f, 0.09856284f, -0.02219187f, -0.04996729f, 0.00653922f, 0.05554967f, 0.02125759f, 0.08848306f, 
    0.08815948f, 0.01743581f, -0.02387546f, -0.01577110f, 0.02879025f, 0.06121312f, 0.01850907f, 0.00196449f, 
    -0.11818833f, 0.00665145f, -0.02273409f, -0.01837222f, 0.17226981f, 0.06228630f, -0.06561333f, -0.04513035f, 
    -0.04015831f, 0.09095903f, -0.02860032f, 0.01525554f, -0.01822773f, -0.05284809f, -0.04256453f, -0.08251178f, 
    -0.39484325f, 0.05386698f, -0.12545735f, -0.06166754f, 0.05078416f, -0.13729972f, 0.00404244f, -0.01469939f, 
    -0.05917085f, 0.09106944f, 0.00313439f, -0.11316611f, 0.08478241f, -0.06908328f, -0.13816641f, -0.02284258f, 
    0.06821752f, 0.02958675f, -0.16518536f, 0.00662990f, -0.09666307f, -0.00829783f, -0.06514662f, 0.06069709f, 
    -0.04279469f, -0.00170661f, 0.01893322f, -0.01547853f, -0.01875300f, 0.00211888f, -0.01541176f, -0.09166687f, 
    -0.04615638f, -0.00099859f, 0.04372086f, 0.03025739f, 0.05875515f, -0.06340974f, 0.00312779f, -0.04142025f, 
    0.19007069f, -0.00931335f, -0.08064191f, -0.01128617f, 0.13710450f, 0.02647042f, -0.08012966f, 0.07297920f, 
    0.00433076f, 0.01306561f, 0.01287193f, -0.06260522f, -0.08932241f, 0.02017448f, -0.03634388f, -0.07066579f, 
    0.04534407f, 0.00645901f, 0.03089983f, 0.02717268f, 0.16821805f, -0.00903454f, -0.06653953f, 0.09312814f, 
    -0.15048701f, -0.05367982f, -0.02276153f, -0.02736242f, 0.03849139f, 0.00118628f, 0.08542950f, 0.00292137f, 
    -0.08848263f, -0.03679385f, 0.01860974f, 0.02118581f, 0.01508190f, 0.04187271f, -0.10551892f, -0.02187096f, 
    -0.49560937f, 0.03622475f, -0.19438849f, -0.15785649f, 0.06722433f, -0.01784490f, 0.04829978f, -0.03780434f, 
    -0.05506069f, 0.00284717f, 0.02515471f, 0.04577665f, -0.00004144f, -0.01809549f, 0.03295736f, 0.09415300f, 
    -0.09742901f, -0.00676631f, 0.11064279f, -0.07502485f, 0.22020018f, -0.34748909f, -0.04352333f, -0.02482890f, 
    -0.00879422f, -0.04228473f, 0.01402649f, -0.01529186f, 0.07369176f, 0.07914536f, 0.01505584f, -0.02345266f, 
    0.07023839f, -0.02500240f, 0.04228800f, 0.12563890f, -0.04371702f, 0.05739332f, -0.04190917f, 0.00363065f, 
    0.00642664f, 0.05886141f, 0.07850095f, 0.02238179f, 0.18551056f, -0.02432950f, 0.04873950f, -0.02550458f, 
    0.00736986f, -0.00973711f, -0.07270821f, 0.00700439f, -0.00069404f, 0.00509709f, 0.00468582f, 0.02285300f, 
    0.01056908f, -0.00167611f, 0.02818328f, -0.00558599f, -0.03594759f, 0.28192088f, 0.00138153f, -0.12110903f, 
    -0.00560838f, -0.06593500f, 0.01929923f, 0.01938515f, -0.05693874f, -0.02706069f, -0.01154975f, -0.04549871f, 
    -0.04861678f, -0.05589722f, 0.02640660f, -0.01157171f, 0.03197879f, 0.04720979f, -0.13497353f, 0.05720287f, 
    0.03037128f, 0.13271593f, -0.07556573f, 0.06741272f, 0.04150936f, -0.01768447f, -0.00432792f, 0.05145912f, 
    0.02410923f, -0.00127504f, 0.00254903f, -0.02079350f, 0.04030714f, 0.07883822f, -0.12938248f, 0.00026200f, 
    0.06020777f, -0.01866248f, -0.05241100f, -0.00697050f, 0.05567509f, 0.08418852f, -0.13288577f, 0.08632817f, 
    -0.20346174f, -0.03209318f, 0.01650802f, -0.04375989f, -0.07669438f, 0.04606648f, 0.02816632f, 0.00719039f, 
    -0.10873011f, 0.05080463f, 0.06388605f, 0.03940098f, 0.07728194f, 0.04378134f, 0.01379650f, -0.04098767f, 
    -0.08063907f, 0.24179165f, 0.05525498f, -0.00081925f, 0.13172750f, -0.07917428f, 0.07005320f, -0.10148192f, 
    -0.01155011f, -0.00257671f, -0.00788955f, -0.01800611f, -0.00354975f, -0.00254698f, 0.19983512f, 0.01231649f, 
    -0.04625155f, -0.01100813f, 0.02889923f, -0.09912227f, 0.03996946f, 0.06083177f, 0.07325822f, 0.07765212f, 
    0.13855077f, -0.01773898f, -0.05309214f, 0.00115258f, -0.06053612f, 0.04816252f, 0.00949247f, 0.08559645f, 
    0.04437685f, 0.02239648f, -0.00960688f, -0.05398067f, 0.03230212f, -0.03691310f, 0.00657236f, 0.09155980f, 
    0.21217626f, -0.48125485f, 0.07496783f, -0.20328447f, -0.15212387f, -0.00455108f, -0.10224319f, -0.08073129f, 
    0.03771618f, -0.04757326f, -0.05138392f, -0.01597919f, -0.05330339f, -0.01173799f, 0.10633143f, -0.15390202f, 
    0.03336800f, -0.13381457f, 0.05319406f, -0.03897551f, 0.16806971f, -0.25177437f, 0.02253385f, -0.12295739f, 
    -0.10170623f, 0.01165138f, 0.04203748f, -0.04845605f, -0.02627907f, 0.01055714f, 0.05957524f, -0.05357382f, 
    -0.02846204f, -0.05485303f, -0.04621771f, -0.01182266f, -0.02936680f, -0.14039166f, 0.05128435f, 0.02730039f, 
    -0.07897402f, 0.08663408f, -0.14581190f, -0.21295454f, -0.10452147f, -0.03548904f, -0.01214188f, 0.00673692f, 
    -0.04514344f, 0.10643976f, -0.03507723f, -0.06008571f, 0.04139293f, 0.03903751f, 0.12562007f, -0.10249634f, 
    0.00322162f, -0.07155177f, -0.16505119f, 0.08499058f, -0.02936244f, -0.28403795f, 0.01410130f, -0.24559221f, 
    0.09027311f, 0.03138607f, -0.09308855f, 0.02287626f, -0.00612810f, -0.05197085f, -0.03192819f, -0.03723010f, 
    0.00573233f, -0.07852271f, 0.05575345f, 0.02736964f, -0.00669839f, -0.07802108f, 0.02792294f, -0.07903221f, 
    0.05451172f, 0.00849241f, 0.00338341f, -0.07119752f, 0.02327797f, 0.06006343f, 0.00073337f, 0.08841541f, 
    -0.05580877f, -0.02556089f, -0.04225484f, 0.06042253f, -0.01267156f, -0.03435818f, -0.02704190f, 0.06588465f, 
    0.00610392f, 0.00474576f, -0.06701819f, 0.00380941f, -0.20603421f, 0.04659278f, -0.00006184f, -0.00521667f, 
    0.05519468f, 0.02661936f, 0.04111592f, 0.02196484f, 0.04142155f, -0.05082909f, -0.03720428f, -0.03034094f, 
    -0.02302980f, 0.01434668f, 0.00246734f, -0.02570319f, 0.02780333f, -0.03680024f, -0.13439924f, 0.01825791f, 
    0.10186384f, -0.05461895f, -0.19733168f, -0.09052735f, -0.14093108f, 0.02618685f, 0.07384817f, 0.01754461f, 
    -0.03962235f, 0.02452943f, -0.10385238f, -0.08516859f, 0.06593903f, -0.01401311f, -0.06876827f, 0.01182823f, 
    -0.00231976f, -0.08199268f, 0.06970064f, 0.00498396f, -0.04702925f, -0.01203775f, -0.04361120f, -0.09499860f, 
    0.05446365f, 0.04573964f, -0.00601019f, 0.09369656f, 0.03145969f, -0.04273058f, -0.02964057f, 0.04031706f, 
    0.03273116f, -0.04783325f, -0.06075412f, -0.08048157f, -0.00790776f, 0.07822240f, -0.02716729f, 0.00718124f, 
    0.16488577f, -0.00729918f, 0.08179349f, 0.00920102f, 0.07467426f, -0.05611804f, -0.07073589f, -0.05706953f, 
    0.04059671f, -0.05037547f, 0.07605118f, -0.04887377f, 0.01603889f, -0.02570056f, -0.01690318f, -0.04062085f, 
    -0.06101819f, -0.01213454f, 0.02337218f, -0.01405937f, -0.00510535f, -0.02643430f, 0.09004052f, -0.04156705f, 
    0.00389740f, 0.01347961f, -0.02089874f, 0.06548486f, 0.07193725f, 0.01233391f, 0.03410327f, 0.02912192f, 
    0.01786171f, 0.02094510f, 0.02790660f, -0.01559739f, -0.06485470f, 0.05811808f, -0.05585265f, -0.03472405f, 
    0.00889395f, -0.02716693f, 0.01544132f, -0.06044288f, 0.01857479f, 0.02190301f, -0.04238291f, 0.02635244f, 
    -0.00049941f, 0.02990642f, -0.02278562f, 0.01712862f, 0.05980248f, 0.01488983f, -0.01544792f, -0.02488401f, 
    -0.06113406f, -0.07056044f, -0.02278585f, -0.03399858f, 0.20074891f, 0.08973748f, -0.14528282f, -0.09650439f, 
    -0.11427556f, -0.00608066f, 0.04144163f, 0.03884423f, 0.01937969f, -0.02898728f, -0.00674688f, 0.00135122f, 
    -0.05607799f, -0.04302522f, -0.02255306f, 0.06787931f, 0.02239180f, -0.03319627f, 0.07821427f, 0.03399644f, 
    0.07529557f, 0.00403090f, -0.17343566f, -0.12280592f, -0.14537250f, 0.02095010f, -0.01389626f, -0.05370157f, 
    -0.04526986f, -0.00144648f, -0.01034192f, -0.00290959f, 0.00156105f, -0.04551671f, 0.06977899f, 0.01556474f, 
    -0.01872571f, -0.03807954f, -0.00557108f, -0.05067457f, -0.03579026f, 0.05765261f, -0.01590505f, -0.11162771f, 
    -0.05067047f, 0.07000189f, 0.08110412f, 0.10553145f, -0.05609505f, -0.01514221f, -0.01462184f, 0.08410872f, 
    -0.01894618f, -0.11831323f, -0.02949599f, 0.01307387f, -0.02026844f, 0.02372787f, -0.06218184f, 0.00767961f, 
    0.08182731f, -0.28668869f, 0.01025922f, -0.17555127f, -0.28046745f, -0.00669993f, 0.04178839f, -0.10732207f, 
    0.05569967f, 0.04474287f, -0.05478701f, 0.00288635f, 0.01944959f, -0.08835240f, 0.04524578f, -0.00610534f, 
    -0.05388056f, 0.14862710f, 0.02292976f, -0.07045191f, 0.23023991f, -0.07825657f, 0.11842950f, 0.02749148f, 
    0.12638156f, -0.10050639f, -0.01091086f, -0.04389850f, 0.03168172f, -0.00251445f, 0.04178430f, -0.03595807f, 
    0.04434018f, 0.07939366f, -0.03316290f, 0.02308938f, -0.05703797f, 0.07092189f, -0.02318607f, -0.01917059f, 
    -0.25815073f, 0.14682062f, -0.05062103f, -0.19539566f, 0.05174451f, 0.03728709f, 0.04287913f, 0.07512221f, 
    0.00882224f, -0.04377324f, -0.08989804f, 0.04880017f, -0.01844052f, -0.12094096f, -0.01156398f, -0.02471660f, 
    0.02072102f, 0.00226313f, 0.01051855f, 0.01654114f, 0.02965634f, -0.05009102f, -0.05659517f, -0.11937652f, 
    -0.04480119f, 0.01964275f, -0.03370899f, 0.06542061f, 0.06246168f, 0.06888924f, -0.03896083f, 0.03175218f, 
    0.12378889f, 0.04308954f, -0.06937224f, -0.01211780f, -0.01668627f, 0.05749970f, -0.11419290f, 0.00966958f, 
    0.28198284f, 0.03170437f, -0.02162879f, 0.01055978f, 0.13279341f, -0.03203946f, -0.08940183f, 0.00037176f, 
    0.04327000f, 0.08769792f, 0.02157536f, 0.07546648f, -0.00029057f, 0.01036726f, 0.02796627f, -0.01385593f, 
    -0.02152398f, -0.10164735f, -0.02836067f, -0.05816624f, 0.09005623f, 0.01420130f, 0.04111415f, -0.04559226f, 
    0.02062966f, -0.00820790f, 0.00491540f, 0.02208760f, -0.06332752f, 0.00661158f, -0.04580227f, -0.03083532f, 
    0.08264401f, 0.00738602f, -0.03953891f, 0.01265896f, -0.02222764f, -0.10271242f, 0.03042375f, -0.06552432f, 
    0.18180649f, 0.10589682f, -0.06553339f, 0.00840035f, 0.01114599f, -0.07762335f, 0.00006291f, -0.00311039f, 
    0.01519550f, 0.01297518f, -0.02623995f, 0.07382242f, -0.00606966f, 0.05872400f, 0.01989297f, -0.01756301f, 
    0.01277546f, -0.08403101f, 0.09102882f, 0.02593770f, -0.18816608f, 0.15138701f, 0.09315895f, -0.05849449f, 
    0.07539517f, 0.01600161f, -0.02782928f, -0.01116901f, 0.07469957f, 0.00467159f, -0.03782832f, -0.05342784f, 
    -0.01519103f, -0.04209295f, 0.08440571f, -0.01073556f, -0.00552141f, -0.05059211f, 0.00893534f, 0.04314168f, 
    0.15141973f, 0.00988672f, 0.00379255f, 0.02182017f, -0.04896023f, -0.02536970f, 0.04931680f, -0.01089534f, 
    0.03988071f, 0.04066414f, -0.05309770f, 0.05444179f, -0.02068299f, 0.00026864f, 0.05003101f, -0.02321151f, 
    0.00889001f, 0.06129049f, 0.03747210f, 0.01014228f, 0.12827650f, -0.11230220f, 0.06725680f, 0.04555438f, 
    0.10094074f, -0.05703104f, -0.06662969f, -0.03913830f, 0.02534909f, 0.03387072f, 0.07625327f, -0.07263554f, 
    -0.01759377f, 0.05479707f, 0.03033649f, -0.03683001f, -0.00601741f, -0.03607802f, 0.02016610f, -0.03551833f, 
    0.29641810f, -0.08115657f, -0.13510527f, 0.16701096f, -0.04869014f, -0.13140996f, -0.02421386f, -0.07105129f, 
    0.01957420f, -0.01108325f, 0.05066952f, 0.00770824f, -0.00042259f, -0.04263409f, -0.04513390f, -0.02625579f, 
    -0.02739248f, 0.05981253f, 0.02460649f, 0.05006427f, 0.19969593f, 0.09200241f, -0.14091359f, 0.06891070f, 
    -0.20959187f, -0.02875877f, 0.09022727f, 0.01001705f, 0.00406895f, -0.02262963f, 0.00428459f, -0.06727936f, 
    -0.01206619f, 0.01184012f, -0.04452429f, 0.03934437f, 0.07866739f, 0.04006672f, 0.06692978f, -0.03740660f, 
    0.09755821f, -0.32083508f, 0.01372052f, -0.01172561f, -0.18256290f, -0.08759920f, 0.01352361f, -0.05851858f, 
    -0.01651817f, 0.05160127f, -0.05357208f, 0.02609436f, 0.00065667f, -0.04938378f, 0.01174060f, 0.00663151f, 
    -0.04492470f, 0.03988528f, -0.00646763f, 0.07499702f, 0.07669542f, 0.06438206f, 0.01318751f, -0.18776891f, 
    0.06877813f, 0.01582263f, 0.03933202f, 0.02157879f, 0.00447714f, -0.05306373f, 0.00309675f, -0.03740450f, 
    0.00138315f, -0.10986242f, -0.00796082f, 0.00869855f, -0.04975974f, -0.04423742f, -0.01311897f, -0.08165066f, 
    -0.00143732f, 0.12302090f, -0.05091564f, -0.11176527f, 0.04866034f, -0.01516521f, 0.06797899f, 0.02742361f, 
    0.00381609f, -0.08017901f, -0.02964701f, 0.00976241f, -0.02687884f, -0.04292989f, -0.01492624f, -0.02480657f, 
    -0.04070603f, -0.02743104f, -0.02117828f, 0.01820728f, 0.18448721f, -0.09133152f, 0.01871775f, -0.11261980f, 
    -0.04322057f, 0.01559995f, -0.06146662f, 0.11058292f, -0.03330446f, -0.00539580f, 0.01997933f, -0.03608646f, 
    0.06522354f, 0.01206615f, -0.02248611f, 0.03853236f, -0.10174204f, 0.01955062f, 0.03287814f, -0.01659460f, 
    0.02197395f, 0.11868478f, 0.02531739f, 0.02839936f, -0.03174695f, -0.04490105f, 0.03556223f, 0.02391702f, 
    -0.04588009f, -0.05450059f, -0.03978311f, -0.01443214f, -0.03234606f, 0.05778238f, -0.01096130f, -0.00793099f, 
    -0.04365770f, -0.00546865f, -0.00633090f, 0.01114976f, 0.09142125f, -0.16837285f, -0.07524318f, -0.10487191f, 
    -0.17582236f, -0.11425710f, 0.08143088f, -0.09309946f, 0.02988489f, -0.07962019f, 0.04704616f, -0.02936257f, 
    0.02679677f, -0.02929764f, -0.03065177f, 0.05403870f, 0.01462979f, -0.00648491f, 0.06497835f, -0.02049347f, 
    -0.06673107f, -0.02367699f, 0.10528890f, 0.02150818f, 0.06959030f, -0.05618262f, -0.01592228f, -0.08688228f, 
    0.00248285f, -0.02631177f, 0.04408410f, -0.00418865f, 0.03522334f, -0.10643569f, 0.07265572f, 0.02981066f, 
    0.02456709f, -0.07060748f, -0.00099766f, 0.05713340f, -0.27105349f, -0.05095801f, 0.00920767f, -0.04301292f, 
    -0.03606947f, 0.02485891f, 0.00520532f, -0.05445870f, -0.04155246f, 0.02579322f, -0.00662498f, -0.05497275f, 
    0.00306698f, -0.01206591f, 0.01683569f, -0.03581500f, -0.01528777f, -0.02644494f, -0.03688870f, -0.00880236f, 
    -0.12924705f, -0.24384221f, -0.15284723f, -0.10763992f, -0.29075781f, -0.13409959f, 0.05433855f, -0.10078108f, 
    0.04490852f, -0.08389553f, 0.00377046f, 0.02971790f, 0.05315903f, 0.05215024f, -0.03427478f, 0.03255409f, 
    -0.04246130f, 0.01527957f, 0.03678323f, -0.03532958f, 0.07374364f, 0.03003701f, 0.12803213f, 0.10248317f, 
    0.12210589f, -0.02003855f, -0.10910465f, -0.07639370f, 0.01122611f, 0.06070758f, 0.05857913f, -0.04185486f, 
    0.00790748f, -0.01136447f, 0.03134351f, -0.02466282f, -0.02295685f, -0.03392104f, -0.05210659f, 0.00538896f, 
    0.19656144f, 0.06845799f, 0.09273830f, 0.12121727f, 0.01200022f, -0.04994506f, 0.01021163f, -0.00572919f, 
    -0.01206345f, 0.05704650f, -0.00623509f, -0.01884160f, 0.05712514f, 0.03148899f, -0.04653260f, -0.00106967f, 
    -0.06501307f, -0.02307278f, 0.02415611f, -0.00284210f, -0.19897021f, -0.07731728f, -0.05038384f, 0.10699128f, 
    -0.18239720f, 0.00359462f, -0.02470841f, 0.00486892f, 0.12394842f, 0.00655161f, 0.05355388f, -0.01806555f, 
    -0.04186776f, 0.06184670f, 0.01304686f, 0.02584577f, 0.04536720f, 0.04036514f, -0.00606079f, -0.02158121f, 
    -0.09563951f, 0.02608803f, -0.17040253f, 0.06049510f, -0.32440147f, 0.00696164f, -0.13282828f, 0.03328941f, 
    0.04646055f, 0.09803709f, -0.04075794f, -0.01504600f, -0.05119118f, -0.06556401f, -0.08343609f, -0.09649397f, 
    0.08391155f, 0.05441577f, 0.03597949f, 0.00169255f, -0.14046456f, 0.00522613f, -0.03122971f, -0.16723514f, 
    -0.19430624f, 0.10987335f, 0.04409327f, -0.01775312f, -0.02562253f, 0.04356048f, 0.00802348f, 0.01326331f, 
    -0.01996708f, -0.05227560f, -0.04457741f, -0.02919528f, -0.04030312f, 0.08219413f, 0.02859684f, -0.08250084f, 
    -0.12671241f, 0.01755280f, -0.16332260f, -0.02145604f, 0.02802401f, -0.01795997f, 0.06872094f, -0.00518492f, 
    -0.02711279f, -0.09179933f, -0.04562865f, -0.00610256f, -0.01611437f, 0.01950460f, -0.00125775f, -0.04971645f, 
    0.06698164f, 0.03558968f, -0.05808604f, -0.01253049f, 0.03092459f, 0.02403157f, -0.12716842f, 0.00878071f, 
    -0.10915541f, 0.07121588f, -0.02956980f, 0.09496843f, 0.06951754f, 0.08308309f, -0.04126067f, 0.05859188f, 
    0.04373733f, 0.05395407f, -0.05167845f, -0.10776938f, -0.00265130f, -0.00052748f, -0.06485464f, -0.07041530f, 
    -0.23564585f, -0.03035058f, 0.07037742f, -0.03657221f, -0.03226147f, 0.06875707f, -0.01590086f, 0.02356530f, 
    0.03399529f, 0.00155577f, -0.03716520f, 0.03570789f, -0.02791995f, 0.00040382f, 0.05521722f, -0.05300795f, 
    -0.06943590f, 0.03381966f, -0.01747116f, -0.03953759f, 0.22355351f, 0.06133543f, 0.16741562f, 0.02216638f, 
    0.20277379f, -0.00086387f, -0.10108065f, -0.11860482f, 0.05715734f, 0.05804616f, 0.08019244f, -0.01872736f, 
    0.02325284f, -0.02930504f, 0.01363427f, 0.04008827f, -0.12671873f, 0.05661749f, -0.00739385f, -0.01775409f, 
    0.16196260f, -0.00250623f, -0.31553361f, -0.05783771f, -0.06985177f, -0.03053525f, 0.02853028f, 0.07328151f, 
    -0.03214538f, 0.01818989f, -0.05512818f, -0.01129903f, -0.03234537f, 0.01150422f, -0.02374985f, -0.06151746f, 
    0.06865668f, -0.01205590f, -0.00293310f, 0.04248796f, 0.19490014f, 0.14210738f, -0.13575910f, 0.02103981f, 
    -0.05589294f, 0.00124625f, 0.06953599f, -0.00994828f, -0.04487454f, -0.07375621f, -0.04107525f, -0.01836212f, 
    -0.05831251f, -0.00759152f, -0.02406825f, 0.05224616f, 0.01879120f, -0.04984033f, 0.04939090f, -0.02973510f, 
    0.06344707f, -0.05200283f, -0.06564740f, 0.03403326f, -0.20780474f, -0.02265386f, -0.05757528f, 0.09418841f, 
    0.09560451f, 0.08587423f, -0.01665260f, -0.02586957f, -0.07728206f, -0.01660079f, -0.04093435f, 0.03088965f, 
    0.00939018f, 0.01261185f, 0.04640995f, 0.02124743f, -0.01711652f, -0.01501636f, 0.12303636f, -0.05141283f, 
    0.05910285f, -0.04787480f, -0.03738790f, -0.00922383f, 0.01548800f, 0.06260942f, 0.05616552f, -0.01935714f, 
    0.07293267f, -0.06486138f, 0.01121907f, 0.01076325f, -0.04107895f, -0.07247815f, -0.01730014f, -0.06316567f, 
    0.20617083f, -0.01438893f, 0.06763772f, 0.12724687f, 0.16447854f, -0.05243385f, -0.09584010f, -0.05466571f, 
    0.03331440f, 0.07401604f, 0.10555053f, -0.05876619f, -0.04163285f, 0.03436440f, 0.05300016f, -0.06778067f, 
    -0.01344669f, -0.04246123f, -0.04912247f, -0.03940774f, -0.35139412f, 0.08466904f, 0.05375924f, -0.06000598f, 
    0.05963622f, 0.00110378f, 0.07728834f, 0.02412338f, 0.01150200f, -0.04120456f, -0.00217416f, -0.03176587f, 
    0.05118771f, -0.01345700f, 0.07597619f, -0.01767904f, -0.02220665f, -0.04042715f, 0.04782753f, 0.02780646f, 
    0.19897380f, -0.00417418f, 0.08505121f, 0.13036282f, 0.09452796f, -0.11181456f, -0.00061597f, -0.03725985f, 
    -0.00647128f, -0.00768710f, 0.06331056f, -0.02274131f, 0.04012695f, -0.03961236f, -0.03379538f, -0.03715336f, 
    -0.01819270f, 0.01150768f, 0.04161892f, 0.02706268f, 0.33908281f, -0.28150824f, -0.12633100f, 0.06269699f, 
    -0.31033489f, -0.13919042f, 0.01244307f, -0.08236649f, -0.09461712f, 0.02275658f, -0.03422416f, 0.00678097f, 
    0.03289612f, -0.09293928f, 0.00058692f, 0.05385567f, -0.07248463f, 0.02539238f, 0.09163161f, -0.02133734f, 
    0.29889387f, -0.03667212f, -0.16544937f, -0.00475373f, -0.21816784f, 0.00757496f, 0.07061065f, -0.05706427f, 
    -0.04373812f, 0.01250276f, -0.01077402f, -0.10066859f, 0.05303228f, -0.04492022f, -0.00737570f, 0.04652310f, 
    0.00298990f, -0.09095851f, 0.11192606f, -0.03856399f, 0.30108413f, -0.25027505f, 0.05110423f, -0.02968814f, 
    -0.00308630f, -0.09820879f, -0.00699388f, -0.02851040f, 0.02296769f, -0.01131527f, 0.03870780f, 0.01799037f, 
    -0.04482407f, -0.06314886f, 0.01445975f, 0.03673061f, -0.00339661f, 0.02808014f, 0.03679651f, 0.01585945f, 
    -0.04262848f, 0.03185705f, -0.05257271f, -0.10162576f, -0.01038027f, 0.04738821f, -0.04233165f, -0.05272807f, 
    -0.00329255f, -0.01616060f, -0.08200974f, -0.04036792f, -0.03582152f, -0.01463193f, -0.01690423f, -0.01704222f, 
    -0.01945644f, -0.00684257f, -0.05132231f, -0.09617150f, 0.17876224f, -0.10050616f, 0.01183410f, 0.12412698f, 
    0.06951996f, -0.09637298f, 0.04438504f, 0.00090508f, 0.04036840f, 0.01802367f, 0.02620389f, 0.00624601f, 
    0.06115526f, 0.02487064f, 0.01912976f, 0.04473796f, -0.06704058f, -0.02359604f, 0.01324251f, -0.03390437f, 
    0.21795096f, 0.10058159f, -0.26938838f, -0.11349604f, -0.02935805f, -0.01752972f, 0.02449672f, 0.03426063f, 
    -0.06820902f, 0.02543157f, -0.08055761f, 0.02759653f, -0.01195106f, -0.01475438f, -0.00359208f, -0.03697636f, 
    0.07004485f, -0.01659141f, -0.06982454f, 0.08088908f, 0.21634521f, 0.00891382f, 0.03288348f, -0.14469948f, 
    -0.11572213f, -0.11301671f, 0.06699280f, -0.00723976f, -0.03428538f, -0.04033712f, 0.02344227f, -0.04239754f, 
    -0.03077313f, -0.04168338f, -0.02795369f, 0.02419177f, 0.06385764f, 0.05162659f, 0.00851301f, -0.06345536f, 
    -0.00009685f, -0.03043891f, 0.02951727f, -0.03319913f, 0.01799356f, 0.06554718f, -0.02831556f, 0.03647567f, 
    0.03198402f, -0.01438686f, -0.00992072f, -0.00950805f, -0.02533005f, -0.00445675f, -0.02370184f, -0.01496195f, 
    -0.05909966f, -0.02923107f, -0.14529066f, -0.03386335f, 0.15354630f, 0.01991405f, -0.21339932f, 0.07864223f, 
    -0.03909285f, -0.06971510f, 0.04535456f, 0.07780540f, 0.00269976f, -0.06386904f, 0.03847881f, 0.03212821f, 
    0.04180332f, 0.00795116f, 0.04802087f, 0.00898835f, 0.01368288f, -0.07825033f, 0.01179414f, 0.03394079f, 
    -0.00163098f, 0.05696761f, -0.13516690f, -0.08795373f, 0.06124477f, 0.03728976f, 0.07764012f, 0.07767141f, 
    -0.03623404f, -0.04535846f, -0.02818914f, -0.00901250f, -0.04154655f, 0.01476022f, -0.00101155f, -0.02620783f, 
    0.02939227f, -0.02579218f, -0.00797467f, -0.03492420f, 0.06025456f, -0.06119407f, 0.04971492f, 0.00195553f, 
    0.14040712f, -0.13016482f, -0.07604387f, -0.02923696f, -0.01129041f, -0.02973242f, 0.04809889f, -0.02262187f, 
    -0.03904543f, -0.08946890f, 0.05252900f, 0.01090936f, -0.04188942f, -0.05544341f, 0.02618385f, 0.04454224f, 
    0.16631345f, -0.09391505f, 0.07336055f, -0.08873773f, -0.11046457f, 0.05412491f, -0.03307631f, 0.11312402f, 
    -0.02091026f, 0.03195630f, -0.03357199f, 0.04867390f, 0.06678564f, 0.09103087f, -0.04175318f, -0.09610654f, 
    -0.09546503f, 0.01473947f, -0.06867885f, -0.05991281f, 0.05737007f, 0.05217737f, 0.03037352f, 0.00416428f, 
    -0.00903091f, -0.04868400f, 0.01520787f, 0.04252150f, -0.09600393f, -0.00676632f, -0.03520848f, 0.03120346f, 
    0.00956867f, -0.01579255f, 0.00000977f, 0.06356868f, -0.04596506f, 0.00147480f, -0.01894402f, 0.00006284f, 
    -0.04498618f, -0.23511107f, 0.08159926f, -0.08809241f, -0.12440915f, -0.00339075f, -0.19340336f, 0.04515814f, 
    0.03087469f, 0.03727775f, -0.09049115f, -0.02917437f, 0.02594529f, 0.05397758f, -0.06783235f, -0.01239051f, 
    -0.10720224f, 0.03900551f, 0.06038225f, -0.06671301f, -0.21458855f, -0.07629451f, 0.02361627f, 0.03480061f, 
    0.01294442f, -0.01663341f, -0.01536302f, -0.05567126f, 0.02079613f, 0.02173764f, 0.00552309f, -0.02605309f, 
    -0.06412242f, -0.01236936f, -0.01138129f, -0.01476208f, 0.00754399f, -0.07178397f, -0.05864587f, 0.02348051f, 
    0.08077607f, 0.09996136f, -0.12722971f, -0.08220250f, -0.08227523f, 0.07114391f, 0.09113636f, -0.01948850f, 
    -0.06780853f, 0.01502250f, 0.01406850f, 0.00664657f, -0.00284194f, -0.05002292f, -0.01571022f, -0.04689473f, 
    0.09524296f, -0.04864738f, -0.05399117f, -0.02637500f, 0.03682802f, -0.25417894f, 0.03387661f, -0.16259943f, 
    -0.17619862f, 0.03853589f, -0.06937452f, 0.05702795f, -0.01211233f, 0.02398749f, -0.02734269f, 0.05006097f, 
    0.03013207f, -0.02704637f, -0.03367575f, 0.10889145f, -0.04997557f, 0.01963305f, -0.02745849f, -0.06726019f, 
    0.06017380f, -0.19130565f, -0.29963160f, 0.09840841f, 0.00991383f, -0.06068878f, 0.02959271f, -0.00801395f, 
    0.02779920f, -0.01229591f, 0.04591416f, -0.02392695f, -0.03644113f, -0.04432027f, -0.01861731f, -0.00689705f, 
    -0.04561630f, 0.06748388f, -0.02184274f, -0.04433945f, -0.23036289f, -0.20986842f, -0.33836988f, 0.07131357f, 
    0.06116696f, -0.00429805f, 0.02846669f, -0.04081286f, 0.01967524f, -0.10977536f, 0.03742253f, -0.00300791f, 
    0.01086194f, 0.01481632f, -0.04234498f, -0.02614532f, 0.05199389f, 0.06593779f, -0.02460427f, -0.03142050f, 
    -0.38680500f, 0.16570817f, 0.18908818f, 0.07547485f, 0.06497997f, -0.01331595f, 0.07350929f, 0.03511224f, 
    -0.01536785f, 0.01482662f, -0.02987267f, 0.05241579f, -0.10182674f, 0.02067607f, 0.02509401f, -0.00225266f, 
    0.05500736f, -0.03849062f, 0.13175720f, 0.04819180f, -0.16164076f, -0.45116723f, -0.30855322f, -0.02778417f, 
    -0.00037992f, -0.07247280f, -0.02440315f, 0.00025339f, -0.03303163f, -0.03830076f, 0.03829684f, -0.01123834f, 
    -0.00467832f, 0.06501829f, -0.00823630f, 0.05816097f, 0.00148831f, -0.02391981f, -0.01279369f, 0.01113576f, 
    -0.15010785f, -0.04412440f, 0.02230384f, -0.03443525f, -0.14297631f, 0.01377107f, -0.03794430f, -0.03233361f, 
    -0.04068143f, -0.01488636f, -0.03716788f, -0.00577446f, 0.00447929f, 0.01655215f, -0.00659453f, 0.05921901f, 
    0.02089630f, -0.04653797f, 0.00982669f, 0.02505470f, -0.37640122f, -0.30423650f, -0.02241422f, -0.02722649f, 
    -0.09913317f, 0.02442752f, -0.06796321f, 0.00459111f, 0.02555640f, -0.12924336f, 0.00750725f, -0.03218520f, 
    0.04065691f, -0.00119014f, -0.00237088f, 0.07440237f, 0.05131154f, 0.02707388f, -0.07407862f, 0.04510620f, 
    -0.22220747f, -0.30775204f, -0.09589054f, -0.07535892f, -0.09410273f, -0.10835812f, -0.08572540f, 0.01317332f, 
    0.00563228f, -0.04183390f, -0.06599908f, 0.00728977f, 0.04533865f, -0.02189669f, 0.09020624f, 0.03640702f, 
    -0.02721655f, 0.00875047f, -0.01971935f, 0.05851845f, 0.04155690f, 0.19840102f, 0.08256637f, 0.19952439f, 
    0.19930397f, 0.04158530f, 0.08985140f, 0.02888226f, 0.11926261f, -0.05107281f, 0.01668178f, -0.00046056f, 
    -0.02636007f, -0.02098282f, 0.03324644f, 0.03077335f, -0.02667767f, -0.01245914f, 0.09942913f, -0.04272506f, 
    -0.00895096f, 0.28032914f, -0.00706680f, 0.05286887f, 0.06842440f, 0.05941675f, 0.00548758f, -0.01634409f, 
    0.03393312f, -0.00991573f, -0.03502053f, -0.02458215f, 0.00799672f, 0.01935627f, -0.05187895f, 0.01239098f, 
    0.00151793f, -0.01194548f, 0.12765948f, 0.03817249f, 0.03042977f, -0.23274411f, -0.17019178f, 0.13601050f, 
    0.17878336f, 0.06804550f, 0.02936227f, 0.05820696f, -0.00446442f, -0.03265080f, 0.04900637f, 0.00496578f, 
    -0.08192562f, -0.09494036f, -0.04381761f, -0.03461805f, 0.00263999f, 0.10941991f, 0.03991444f, -0.04781958f, 
    0.04691486f, 0.22627687f, 0.05868367f, 0.08750459f, -0.04030713f, 0.08044493f, 0.09662543f, -0.01261601f, 
    0.01985087f, 0.01108457f, -0.09090006f, 0.05138862f, -0.02500158f, -0.09292015f, -0.01724635f, 0.02139547f, 
    -0.07104178f, 0.13786294f, -0.00752594f, -0.02677769f, 0.00126317f, 0.03366092f, -0.01175546f, 0.04725156f, 
    -0.01584293f, -0.03999931f, -0.13897727f, 0.01511852f, 0.01228066f, 0.03063122f, -0.04572199f, 0.05537648f, 
    0.01647110f, 0.00467394f, 0.04000232f, -0.00207270f, -0.01148031f, 0.00090877f, 0.10421497f, 0.03967649f, 
    0.16824439f, -0.36478242f, -0.19896495f, 0.14125770f, 0.16061735f, 0.08880580f, 0.07852153f, 0.08308236f, 
    0.00419306f, -0.06605401f, 0.03173800f, -0.00934501f, -0.08747108f, -0.11831493f, -0.02150424f, -0.02342637f, 
    0.00371626f, 0.09520011f, 0.02243788f, -0.01027259f, -0.17656656f, -0.43776852f, -0.19564794f, -0.04484151f, 
    0.09594004f, -0.12017088f, 0.01280447f, -0.02075872f, 0.03559403f, -0.00487026f, -0.07376592f, 0.01272334f, 
    0.03259411f, 0.03150721f, 0.07848238f, -0.04691884f, -0.09769218f, -0.02805124f, -0.05640599f, 0.07608663f, 
    -0.27945304f, 0.10219573f, 0.02096034f, -0.09216487f, -0.09356719f, 0.00691267f, -0.09199809f, -0.06642534f, 
    0.05117286f, -0.02355779f, 0.02022192f, -0.11569188f, -0.02895574f, -0.04388516f, -0.02074061f, 0.00502272f, 
    0.03043229f, -0.05931112f, 0.02887680f, 0.01398794f, -0.12900892f, 0.03106922f, 0.10271767f, 0.02720241f, 
    0.09404849f, 0.03339841f, 0.02113321f, -0.00845674f, -0.01638419f, -0.07880244f, -0.03703805f, 0.00723241f, 
    -0.02402097f, 0.06089140f, 0.09601121f, -0.00711369f, 0.02951244f, -0.14897718f, 0.01887872f, -0.12132441f, 
    -0.12457056f, -0.06534753f, -0.01294864f, -0.08364300f, -0.04447135f, -0.01673929f, -0.05821986f, -0.00832291f, 
    0.04070268f, -0.04304755f, 0.06869715f, -0.01291464f, -0.03081941f, 0.02019559f, 0.02654760f, 0.01026717f, 
    -0.01107494f, -0.06980470f, -0.01866635f, -0.01517942f, 0.01083609f, -0.05043678f, -0.11678813f, -0.10161232f, 
    -0.26071560f, -0.02413460f, 0.01541589f, -0.09658191f, -0.00907401f, -0.02686894f, -0.05389830f, 0.02440562f, 
    -0.01823510f, -0.05088593f, -0.02396512f, 0.01312317f, -0.00372860f, 0.02518792f, -0.04773890f, 0.07428340f, 
    0.24151276f, -0.00599716f, 0.07603822f, 0.09809027f, -0.01174262f, 0.08439755f, 0.02993692f, 0.01536427f, 
    0.11512841f, -0.01244281f, 0.00215011f, 0.08150238f, -0.10477922f, -0.00282744f, -0.10311221f, -0.04628715f, 
    -0.01485216f, -0.01821686f, -0.03587547f, -0.09926986f, -0.03524913f, 0.04341987f, -0.04510069f, -0.04836840f, 
    0.02709471f, -0.05470870f, -0.08152889f, 0.02545394f, -0.00583187f, -0.00187369f, -0.02801951f, -0.00885195f, 
    0.09088215f, -0.00258400f, 0.00032647f, 0.02416178f, -0.01706325f, 0.03580904f, 0.03356127f, 0.01739351f, 
    0.09702267f, -0.04128232f, -0.03546783f, 0.02518018f, -0.07899708f, -0.05971806f, -0.08227883f, 0.00815743f, 
    -0.04644845f, -0.02357547f, -0.07627995f, -0.02793796f, 0.00243348f, -0.01975558f, 0.04831381f, -0.02117311f, 
    0.02364481f, 0.08706798f, 0.04006773f, 0.00196086f, -0.30884987f, 0.29898202f, 0.04152948f, 0.13378453f, 
    0.06929468f, 0.03182422f, 0.01966843f, 0.02129512f, 0.00608101f, 0.01518685f, -0.03906325f, -0.05930888f, 
    -0.02962951f, -0.01776647f, -0.02168352f, 0.03723783f, 0.03161244f, 0.01167767f, 0.00358754f, -0.02491595f, 
    0.03698827f, 0.08893416f, -0.05112796f, -0.01978575f, -0.03757542f, -0.04198071f, -0.02468190f, -0.01305826f, 
    0.01107650f, 0.01769775f, -0.07243408f, -0.06368968f, 0.00175278f, -0.04976552f, 0.02341898f, -0.07848735f, 
    0.05939854f, 0.11992610f, -0.01501748f, -0.01302183f, -0.27313891f, 0.09255542f, -0.31311414f, 0.01510437f, 
    0.08392966f, -0.10138273f, -0.00476492f, -0.07907008f, 0.02195909f, 0.05496701f, -0.04452470f, 0.05793708f, 
    0.02799976f, 0.00700163f, 0.06400257f, -0.07962065f, 0.01126233f, -0.05620240f, -0.02036531f, 0.04719186f, 
    -0.37652972f, 0.00066066f, -0.15264507f, 0.03738482f, 0.08275560f, -0.06073857f, 0.04921281f, 0.04376053f, 
    0.02979063f, -0.04447794f, -0.03155085f, -0.00786219f, -0.01814258f, -0.05401653f, 0.01327858f, -0.04050140f, 
    -0.03716121f, 0.00433231f, 0.00145352f, -0.01923285f, 0.03105227f, 0.01756746f, -0.13916115f, -0.03730975f, 
    0.03032562f, -0.05918775f, -0.02937032f, 0.02809328f, 0.06606578f, 0.00762837f, -0.05890204f, -0.03758086f, 
    0.01287832f, 0.03670433f, 0.03301997f, -0.12075531f, 0.06220210f, -0.10931322f, 0.05460623f, -0.04723522f, 
    0.07946555f, -0.10156427f, -0.09494750f, 0.08025029f, -0.02850387f, 0.05948281f, -0.04455790f, 0.02561380f, 
    0.03437876f, -0.01439350f, 0.05596059f, -0.00921798f, -0.03429735f, -0.00654747f, -0.04400698f, 0.05591970f, 
    -0.03897058f, -0.02759458f, 0.02871730f, -0.07359710f, -0.01954181f, 0.17584759f, 0.11353144f, 0.08840910f, 
    0.00234072f, -0.03805947f, 0.01533663f, -0.01703810f, -0.03425663f, 0.00961598f, 0.02098517f, -0.03001061f, 
    0.01290838f, -0.05325592f, -0.06523462f, -0.02388112f, -0.01695457f, 0.06614971f, 0.09041931f, 0.01624508f, 
    0.15004089f, 0.00571733f, -0.03918501f, -0.07875820f, -0.05945211f, -0.06358087f, -0.00210184f, -0.07043484f, 
    0.00155036f, -0.01237305f, 0.03662933f, 0.04057414f, 0.02643873f, 0.02585269f, -0.01282099f, -0.03905116f, 
    -0.00591641f, -0.05824485f, -0.00467801f, -0.03197318f, -0.04948469f, -0.00571792f, -0.08825898f, 0.07911282f, 
    0.02189000f, -0.02595151f, 0.05126636f, -0.02728054f, -0.01761698f, 0.05411763f, 0.02100433f, -0.00736483f, 
    -0.03552996f, 0.01555383f, 0.00621361f, 0.02273880f, 0.04103466f, -0.00335072f, -0.00656957f, -0.02490888f, 
    -0.07873354f, 0.17443389f, 0.17750570f, 0.14757442f, 0.00197025f, 0.03694962f, 0.00657851f, 0.00811569f, 
    -0.04570435f, 0.06806878f, -0.10855594f, 0.01391959f, -0.02703516f, -0.07687081f, -0.00735610f, -0.02755176f, 
    0.06585919f, 0.08986262f, 0.14476728f, 0.01909140f, -0.10508271f, -0.07410564f, -0.19606073f, -0.10432867f, 
    -0.19661713f, 0.03306621f, -0.04955262f, 0.04574510f, -0.09518761f, 0.05715653f, -0.07721125f, -0.03655555f, 
    0.11261311f, -0.04567374f, 0.02428753f, 0.04620931f, -0.05284545f, 0.02052549f, -0.06456495f, 0.04511088f, 
    -0.01435715f, -0.14423724f, 0.00791981f, -0.09175052f, -0.11885089f, -0.04321889f, -0.10746608f, 0.00681637f, 
    -0.05830925f, -0.02824848f, -0.01190020f, 0.06762426f, -0.06854457f, 0.02895079f, 0.07441198f, 0.02919223f, 
    0.01807366f, -0.00677360f, 0.08196570f, -0.02632185f, 0.05824381f, 0.08074746f, 0.03022079f, 0.13350861f, 
    -0.01975483f, 0.02466689f, 0.02003353f, 0.02083392f, -0.03629665f, 0.01597747f, 0.01201482f, -0.01731381f, 
    -0.06744584f, 0.04436794f, 0.01196851f, 0.03774953f, 0.01620637f, 0.02199951f, -0.04169081f, 0.09109915f, 
    0.19970773f, 0.14787742f, 0.11904091f, 0.10733368f, 0.03035403f, -0.05852440f, 0.13849349f, 0.01584347f, 
    -0.03903041f, 0.01777516f, -0.01812449f, -0.02118027f, -0.09879426f, 0.01532619f, -0.01403427f, -0.05654091f, 
    0.08152480f, 0.00694564f, 0.00887961f, 0.06946907f, 0.19238771f, 0.15804452f, 0.08778741f, 0.06176121f, 
    0.02898452f, -0.00003141f, 0.05670244f, 0.02372648f, -0.01806161f, -0.03806577f, -0.00074121f, -0.09473780f, 
    -0.00504522f, -0.08133063f, -0.00548554f, 0.04195021f, -0.05415562f, 0.17247382f, 0.04221308f, 0.08517692f, 
    -0.04384583f, -0.04152163f, -0.08016604f, 0.14013892f, 0.17211650f, 0.11643324f, 0.03870005f, 0.02033142f, 
    -0.04934603f, 0.07553782f, -0.04369092f, -0.00099789f, -0.00017152f, -0.01250987f, -0.02929539f, 0.00964377f, 
    -0.00183290f, 0.05451638f, 0.07014136f, -0.03475223f, -0.16205101f, -0.10029024f, -0.02848396f, -0.15604952f, 
    -0.14085637f, -0.13035598f, 0.07510587f, 0.06665942f, 0.01036976f, 0.02986316f, -0.01584104f, 0.00900628f, 
    0.02989547f, -0.01575971f, -0.08175667f, 0.00962611f, -0.02099214f, -0.03510643f, 0.04788757f, 0.03623400f, 
    -0.11757319f, -0.16912110f, -0.23502202f, -0.00652913f, -0.12295801f, -0.00623667f, 0.02338099f, 0.08510420f, 
    0.02299241f, -0.06810850f, -0.06090130f, -0.04226431f, -0.02537308f, 0.00639111f, 0.00704681f, 0.01101588f, 
    -0.02371315f, 0.04337472f, -0.05687110f, -0.04149767f, -0.13723800f, -0.05473443f, -0.07466150f, -0.08646053f, 
    -0.06687757f, 0.01071491f, -0.12354241f, 0.06220460f, -0.03348748f, -0.07259391f, -0.01231257f, -0.04392799f, 
    -0.04040631f, -0.02255192f, -0.03255256f, 0.02649043f, -0.04797776f, 0.05808995f, 0.02668613f, 0.05518092f, 
    0.03960726f, 0.16785710f, 0.02207220f, -0.04164179f, 0.05717044f, 0.02797475f, -0.00318760f, 0.02621629f, 
    0.06035071f, 0.06369010f, -0.02615429f, 0.03018270f, -0.02253786f, 0.03039816f, -0.07218052f, -0.00798223f, 
    0.05462027f, -0.08914195f, 0.09586076f, 0.06636959f, -0.31782949f, 0.37036556f, -0.02935268f, 0.06259575f, 
    0.10862542f, 0.05324265f, 0.05835670f, 0.03702036f, -0.02125181f, -0.04380130f, -0.03753314f, -0.06977604f, 
    -0.00270269f, -0.01390324f, 0.00770703f, 0.00674609f, -0.00720989f, -0.07899632f, 0.00552980f, -0.03574726f, 
    0.15480600f, 0.02475473f, 0.07724611f, 0.10391296f, 0.01127470f, 0.02566603f, -0.00191432f, -0.02361901f, 
    -0.01134638f, 0.00386599f, -0.00159586f, -0.00829360f, -0.00904865f, -0.01628829f, 0.03813462f, -0.03724362f, 
    -0.04270235f, -0.03409467f, 0.03892848f, 0.08372830f, -0.08560345f, -0.03219580f, -0.10444868f, -0.00257194f, 
    -0.08039958f, 0.00405974f, -0.00930005f, -0.04831354f, -0.01977000f, 0.01234683f, -0.03500880f, 0.00512560f, 
    0.09706130f, 0.07239623f, 0.00687008f, 0.01616039f, -0.04753789f, -0.02714369f, -0.07623301f, 0.04368105f, 
    -0.18779998f, -0.08269878f, -0.03255549f, -0.06430525f, -0.11707641f, -0.11144690f, -0.14421707f, 0.10892987f, 
    -0.02478010f, 0.07007645f, -0.05693289f, -0.06556242f, 0.11162228f, -0.05580966f, 0.01047292f, 0.04153920f, 
    0.04661613f, 0.00782920f, 0.08333289f, 0.10427272f, 0.05830257f, -0.11690598f, -0.20860253f, 0.10913093f, 
    0.06586178f, -0.01741231f, 0.07602243f, 0.05719298f, 0.00757726f, -0.01901370f, -0.03055219f, 0.08537775f, 
    -0.04531146f, -0.01163365f, -0.00531824f, -0.01185266f, -0.07836265f, 0.06174824f, 0.05779075f, -0.09213000f, 
    0.08106539f, -0.07838617f, -0.01183102f, -0.05326532f, -0.16654323f, -0.04018546f, -0.08657045f, -0.01684430f, 
    -0.07085711f, 0.01074959f, -0.02026533f, 0.02449891f, 0.01057672f, 0.02964150f, 0.08226639f, -0.00746245f, 
    0.03546612f, -0.01955614f, -0.01742904f, -0.00307487f, 0.13196105f, -0.00736077f, 0.13535078f, 0.04593329f, 
    0.03165356f, -0.09033366f, -0.01488922f, -0.02757929f, -0.14036061f, -0.05085426f, -0.11696894f, -0.06498045f, 
    -0.02568320f, -0.04153285f, 0.04612195f, 0.00295700f, 0.07939497f, 0.05167150f, 0.00407738f, 0.01889634f, 
    -0.40313360f, 0.37720653f, 0.09935109f, 0.02902539f, -0.00615560f, 0.02144489f, 0.04824184f, -0.02384990f, 
    0.03628242f, -0.05324825f, -0.02805841f, -0.05744595f, -0.07390685f, 0.03548691f, -0.06280653f, -0.06989102f, 
    0.03366004f, -0.13505191f, 0.09752174f, -0.00445368f, -0.06562795f, -0.03480366f, 0.04806674f, 0.02380362f, 
    0.04344165f, 0.05781767f, -0.07285766f, -0.11255038f, 0.08232414f, -0.06989434f, -0.00094858f, 0.04063659f, 
    0.01504687f, -0.00235114f, -0.01774376f, -0.08751469f, -0.02806360f, -0.02749056f, 0.00672285f, -0.03033296f, 
    -0.06761419f, 0.04524181f, -0.04017482f, -0.00872255f, 0.13730575f, -0.00702475f, 0.10046191f, -0.01645211f, 
    -0.00491936f, 0.09431870f, -0.03761321f, -0.02324998f, 0.07791527f, 0.06900198f, 0.03188322f, 0.00950820f, 
    0.02037382f, -0.02741519f, 0.04185557f, 0.05710194f, 0.03538081f, -0.07954403f, 0.06270759f, 0.01396646f, 
    0.00495974f, -0.08234245f, -0.06809997f, 0.03638484f, -0.03351585f, 0.02308396f, -0.04610351f, 0.00969417f, 
    -0.03329260f, -0.02534914f, 0.01815274f, 0.00330547f, 0.01322349f, 0.05373230f, 0.06211963f, 0.01701602f, 
    0.19655161f, 0.42314285f, -0.03470335f, -0.20126121f, -0.16383977f, 0.00685080f, -0.02721633f, -0.10252117f, 
    0.10075345f, -0.00577652f, 0.10036242f, -0.02971083f, -0.11280853f, 0.00037380f, -0.05916815f, -0.05301838f, 
    0.01273688f, -0.08552109f, 0.03943470f, 0.09974998f, 0.02875958f, 0.14220756f, 0.07115161f, 0.04626250f, 
    -0.01365157f, -0.06463434f, 0.00249664f, -0.02645954f, -0.03291921f, 0.05504602f, 0.01988340f, 0.06516752f, 
    0.03378621f, -0.02402065f, -0.00656401f, 0.06219609f, 0.01059944f, 0.04351664f, -0.05503177f, -0.00057744f, 
    -0.26411638f, -0.22597162f, -0.05370046f, 0.03445181f, -0.10289230f, -0.08832684f, -0.08139893f, -0.05666816f, 
    0.01972045f, -0.04701598f, -0.03156967f, -0.06900503f, 0.09326360f, -0.04363761f, 0.01062051f, -0.01047050f, 
    -0.00586253f, -0.06905729f, 0.02168144f, 0.05846958f, -0.38924798f, -0.21062015f, 0.07388515f, -0.03936999f, 
    -0.01688586f, -0.06904757f, -0.04621088f, 0.06631622f, -0.00060356f, -0.05645834f, 0.00784714f, -0.00433720f, 
    0.01568319f, 0.01985157f, 0.07820693f, -0.01016297f, -0.03855925f, -0.04027853f, -0.01286867f, 0.03244185f, 
    -0.41462374f, -0.05009196f, -0.15728341f, 0.05150655f, 0.20752418f, -0.03148513f, 0.09555797f, 0.01547334f, 
    0.06304438f, -0.01069350f, -0.02189041f, 0.02081235f, 0.04948903f, -0.10635276f, 0.04678009f, -0.08567515f, 
    0.02960558f, -0.04716122f, 0.03446463f, 0.01936780f, 0.21902339f, -0.12206034f, 0.07772598f, -0.07881904f, 
    -0.06965147f, -0.02747495f, -0.06713188f, -0.10968936f, -0.00379306f, -0.01601893f, -0.00011628f, -0.04423077f, 
    0.04094719f, -0.03052843f, 0.00714447f, -0.00041914f, 0.00134937f, -0.03452414f, -0.00833134f, -0.00373358f, 
    0.18261035f, -0.09618113f, 0.00820230f, 0.05276679f, -0.11066077f, 0.00128974f, -0.04441869f, -0.05499747f, 
    0.06317780f, 0.05083091f, -0.03788433f, -0.04260231f, -0.07707289f, 0.11251678f, -0.04118785f, 0.03563496f, 
    -0.02603540f, -0.05938302f, -0.02913022f, 0.04862418f, 0.12329660f, -0.09709553f, -0.20806214f, 0.13672501f, 
    -0.03291272f, 0.04915971f, -0.01661020f, 0.02803363f, 0.06546035f, -0.00440148f, -0.03204022f, 0.00798806f, 
    -0.02436645f, -0.03315429f, -0.00497517f, 0.02443928f, -0.00721834f, 0.03399487f, 0.01592989f, -0.07063472f, 
    0.07969943f, -0.04323752f, 0.02629039f, 0.02716934f, -0.12092551f, -0.02923628f, 0.10021596f, 0.04323038f, 
    -0.03140285f, 0.03341851f, -0.04904256f, -0.01776448f, -0.05109414f, 0.05882121f, -0.03927694f, 0.00350469f, 
    0.03438514f, -0.02529455f, 0.00199889f, 0.01521203f, 0.00495407f, 0.08405813f, -0.11409296f, 0.02578226f, 
    -0.04125889f, -0.02931414f, 0.04966704f, -0.00121701f, -0.01909750f, 0.02207749f, -0.01507555f, 0.00973507f, 
    0.00482748f, 0.00177349f, 0.02364869f, 0.03647862f, -0.02191848f, -0.02930930f, -0.06717222f, -0.02165807f, 
    -0.10652238f, 0.11929198f, 0.03563881f, 0.09729535f, 0.11222281f, 0.04179141f, 0.11241364f, 0.03514494f, 
    0.05658713f, -0.01722215f, 0.03614867f, 0.04209776f, -0.12510866f, 0.06286366f, -0.10861558f, 0.06266531f, 
    -0.05500315f, 0.07809806f, 0.00785292f, -0.03168841f, 0.09502211f, 0.03598789f, -0.04315836f, 0.14502341f, 
    0.05089051f, 0.02075825f, -0.00748660f, -0.03159065f, -0.00418746f, 0.03024561f, -0.06164378f, -0.00938078f, 
    -0.03505141f, 0.01516900f, 0.03770510f, 0.01962603f, -0.00221136f, 0.03643293f, -0.00027406f, 0.00031441f, 
    -0.16655581f, -0.08026829f, 0.06520432f, 0.06486762f, -0.01770703f, -0.05987419f, -0.02715310f, -0.08295825f, 
    0.01962597f, 0.07755464f, 0.01709596f, -0.06108788f, -0.00968185f, -0.02034923f, -0.00352243f, 0.02199305f, 
    -0.01020728f, -0.00560500f, 0.01923277f, 0.01361952f, -0.06180732f, 0.23876418f, 0.09593484f, -0.11458973f, 
    -0.02290726f, 0.18261980f, 0.00592686f, -0.07458282f, -0.00492416f, 0.01758021f, -0.01842338f, -0.04461988f, 
    -0.03611058f, 0.03820129f, -0.08912268f, -0.04548987f, 0.00669894f, -0.02522253f, -0.04154721f, -0.03047001f, 
    0.22668171f, -0.00613086f, -0.03670180f, 0.06036650f, -0.01131431f, -0.10784535f, -0.00738561f, 0.17358793f, 
    0.02774791f, -0.08918644f, 0.02372412f, -0.07414562f, -0.07161810f, 0.01182993f, 0.09195459f, -0.05248808f, 
    -0.07782643f, 0.09729186f, -0.01000325f, -0.01222691f, 0.11477222f, 0.05392491f, 0.15169813f, 0.01274469f, 
    -0.08776933f, -0.02015076f, 0.00399172f, 0.01936435f, 0.04592486f, 0.02683922f, -0.02237403f, 0.09635411f, 
    -0.01727974f, -0.04984937f, -0.05307524f, -0.06467852f, 0.04203935f, -0.05398764f, 0.05604563f, 0.02069516f, 
    -0.27974191f, -0.00451524f, 0.02335919f, 0.02546073f, 0.07526483f, 0.05486495f, 0.03685333f, 0.09942734f, 
    0.05764467f, 0.06203476f, -0.04933015f, 0.01202163f, -0.02280053f, 0.03721869f, 0.06337829f, 0.07376998f, 
    0.04638926f, 0.07369722f, -0.01656629f, -0.06047828f, -0.06078251f, 0.24152029f, -0.22297603f, -0.12338219f, 
    -0.04871539f, 0.04696895f, -0.00916902f, 0.00019700f, 0.14886706f, -0.00245980f, -0.03760799f, -0.06369157f, 
    0.01265136f, 0.09307757f, 0.04054259f, -0.10714912f, 0.10803799f, -0.00746968f, 0.00452580f, -0.02732754f, 
    -0.00110205f, -0.00358421f, -0.01017058f, -0.03180337f, 0.02391336f, -0.00331644f, -0.02111343f, -0.00901924f, 
    0.04766024f, 0.02176860f, 0.04389600f, 0.01159842f, 0.07761979f, 0.01630508f, -0.05053899f, 0.05867004f, 
    -0.00325270f, -0.05220338f, -0.00194951f, -0.02566389f, -0.25358513f, -0.07539416f, -0.00234832f, -0.14588407f, 
    -0.00926154f, 0.00761282f, -0.03382508f, -0.02635516f, -0.09025963f, 0.03938327f, -0.09015413f, 0.01929561f, 
    0.04071632f, 0.01625115f, -0.01549248f, -0.07586562f, -0.02225385f, 0.02267933f, 0.01173677f, -0.06473342f, 
    -0.26532194f, 0.16530794f, 0.12006947f, 0.03275253f, -0.10871286f, 0.09682903f, 0.00485955f, 0.04779720f, 
    -0.05092515f, 0.02163320f, 0.07425086f, 0.03345947f, -0.01116361f, 0.04684183f, 0.05856613f, 0.00947044f, 
    0.05496281f, -0.07730345f, -0.07881567f, -0.03807674f, -0.18447950f, -0.20115975f, 0.09307450f, 0.15334320f, 
    -0.00354827f, -0.08567309f, 0.03049522f, -0.04450750f, -0.03622922f, -0.00496280f, 0.02993682f, 0.01684377f, 
    0.00313947f, -0.01578538f, 0.03327523f, -0.04599882f, -0.01157738f, 0.02023469f, 0.04507569f, 0.01993489f, 
    -0.16579482f, -0.11073975f, 0.10620389f, 0.07222494f, 0.00013241f, 0.00514766f, 0.00136855f, -0.08250876f, 
    0.05810196f, 0.00917055f, 0.11428853f, -0.05543942f, -0.11542650f, 0.09740818f, -0.00123736f, -0.01393542f, 
    -0.02216441f, -0.05964094f, -0.08787215f, 0.11713510f, -0.60439342f, 0.06580677f, 0.08950799f, 0.10915060f, 
    0.13035306f, 0.01787031f, -0.03288735f, -0.01312152f, 0.04506188f, 0.02700913f, -0.05069175f, -0.02856440f, 
    0.05527352f, 0.06162888f, 0.05216095f, -0.01714831f, 0.11248884f, 0.07983852f, 0.11682196f, -0.04325564f, 
    -0.17010465f, -0.24299911f, 0.14545241f, 0.18911304f, 0.02448965f, -0.12099623f, 0.05384082f, -0.04196083f, 
    -0.06094085f, 0.01304909f, 0.08109589f, 0.04514615f, -0.01818738f, -0.04779219f, 0.01071000f, -0.15646128f, 
    0.03811879f, 0.03147603f, 0.05685460f, 0.06342083f, 0.12846151f, -0.20554723f, 0.14164650f, 0.01480832f, 
    -0.03321755f, -0.06920908f, 0.01142308f, 0.16305348f, -0.02560992f, 0.07902590f, 0.10292764f, -0.05595297f, 
    0.06502181f, 0.00147786f, -0.02710722f, 0.00801974f, 0.02413427f, 0.01926037f, -0.05405046f, -0.01323703f, 
    0.22001380f, 0.14814930f, -0.23198152f, 0.03315810f, 0.03153234f, 0.06444650f, -0.02597471f, 0.13983051f, 
    0.07723221f, -0.01611513f, -0.00650268f, -0.00934103f, -0.03417178f, 0.03422688f, 0.02473651f, -0.02369981f, 
    0.10570959f, -0.01625764f, -0.00069689f, -0.02195077f, -0.13426863f, -0.13986968f, 0.02699653f, -0.00952634f, 
    -0.00551385f, -0.06014439f, 0.03317875f, 0.08478376f, -0.08026596f, -0.02109968f, 0.00794706f, 0.04267827f, 
    0.01785677f, -0.01461952f, 0.01043140f, -0.02396846f, -0.07100210f, 0.02413195f, -0.10708584f, 0.00839060f, 
    0.33570352f, 0.09767722f, -0.12421840f, -0.06804274f, 0.09391347f, 0.00789514f, 0.05760729f, 0.04432621f, 
    0.07208218f, 0.03489551f, -0.04298712f, -0.04281558f, -0.02671634f, -0.00721336f, 0.01706437f, 0.05667134f, 
    -0.02159599f, -0.03266263f, 0.02445124f, -0.01286249f, -0.50268888f, 0.02053650f, 0.08350054f, -0.01455002f, 
    -0.03167626f, 0.06308734f, 0.02015904f, -0.04707532f, -0.14610009f, -0.03109500f, 0.00437192f, -0.00434342f, 
    0.05169600f, -0.04979135f, -0.00160377f, 0.09582473f, 0.01717420f, -0.15989214f, 0.00331964f, -0.01447907f, 
    0.09343806f, 0.17537154f, -0.04182969f, -0.32105455f, -0.11395069f, -0.01826754f, 0.04978095f, -0.01813139f, 
    0.02194081f, -0.06653643f, -0.03686902f, -0.07212195f, -0.04098112f, 0.05086518f, 0.00206423f, -0.02429219f, 
    0.05113321f, 0.00545635f, -0.00430946f, 0.04095164f, -0.23106541f, 0.05992107f, 0.07471628f, 0.10618871f, 
    0.03511728f, -0.01553391f, -0.03544527f, -0.01142128f, 0.08815350f, 0.04934797f, -0.01869894f, 0.00698286f, 
    -0.02393824f, 0.05049660f, 0.01432627f, -0.05810224f, 0.04997036f, 0.06250624f, 0.06206777f, 0.01309061f, 
    -0.09122785f, 0.08481234f, -0.07549288f, 0.05830004f, 0.08747622f, 0.09337024f, -0.02835723f, -0.06846040f, 
    0.10608224f, 0.11708710f, 0.00058927f, 0.04773813f, -0.00876384f, -0.00858821f, -0.01427328f, 0.02758378f, 
    -0.07703267f, 0.02806782f, 0.11400588f, -0.06340701f, -0.28940281f, -0.19080354f, 0.08599886f, -0.05228344f, 
    0.05809032f, -0.02521900f, -0.03104534f, 0.01648255f, -0.03042857f, 0.03723938f, -0.07053379f, -0.06079807f, 
    -0.03035945f, -0.00192442f, -0.00900339f, -0.01772419f, -0.00588722f, -0.06373578f, 0.05293613f, 0.00909160f, 
    0.02497006f, 0.11221258f, -0.00732228f, 0.03470216f, -0.00027396f, 0.08925806f, 0.04247530f, 0.02817072f, 
    0.10103434f, -0.00314845f, 0.07005984f, 0.00606146f, 0.07960957f, -0.01768628f, 0.02938347f, -0.12172298f, 
    -0.15826242f, 0.08585423f, -0.04874453f, 0.04688692f, -0.10106208f, 0.00437785f, 0.19223084f, 0.00840381f, 
    -0.07083323f, -0.00464132f, 0.02045019f, -0.05844727f, -0.02767006f, -0.02307629f, 0.11324204f, 0.02178814f, 
    -0.00092156f, -0.11212181f, 0.10381222f, 0.02496343f, -0.04896835f, -0.07199675f, -0.02520950f, -0.00440733f, 
    -0.16546261f, -0.07114255f, 0.06196836f, 0.06492960f, 0.01664022f, 0.00442437f, -0.06764070f, -0.03494265f, 
    0.04665507f, 0.00239309f, 0.08959327f, 0.00053901f, -0.02836553f, -0.08167565f, -0.02362338f, 0.02345199f, 
    0.01576311f, -0.07773199f, 0.04241299f, -0.00558053f, -0.09353630f, -0.07737138f, -0.14783640f, -0.08476069f, 
    -0.13927779f, 0.00456796f, 0.02624406f, 0.00894440f, -0.00434747f, -0.04457298f, -0.04542823f, 0.01093793f, 
    -0.06567290f, -0.01275172f, -0.10170818f, 0.06800048f, 0.00385395f, 0.01590385f, -0.06801745f, 0.09534346f, 
    0.08067932f, -0.03031124f, -0.05039410f, -0.03042897f, 0.11461666f, 0.03106973f, -0.03273736f, -0.08545560f, 
    0.02246639f, -0.00126986f, -0.09636785f, -0.00402923f, -0.01050339f, -0.02732216f, -0.05328807f, 0.02898101f, 
    -0.08932574f, -0.07505131f, -0.01397765f, -0.02753630f, -0.07692842f, -0.03151582f, 0.04095371f, 0.10768688f, 
    -0.03800102f, 0.06593665f, -0.01879492f, -0.06526162f, 0.03990309f, 0.07173415f, -0.00657026f, 0.07074542f, 
    -0.03203426f, -0.02553117f, 0.00988649f, 0.01525475f, -0.05437247f, 0.05495390f, 0.09837745f, -0.02432601f, 
    -0.22360629f, 0.03796397f, -0.02565321f, -0.02255013f, 0.07648893f, 0.00399829f, -0.03656981f, -0.05423262f, 
    0.00753984f, 0.02317321f, 0.00193261f, -0.03411001f, -0.05400037f, -0.08291725f, -0.02082581f, 0.00462674f, 
    -0.04631510f, -0.07528003f, 0.02480513f, 0.01119590f, -0.10421908f, 0.11222848f, -0.04955908f, 0.11061983f, 
    0.01635889f, 0.01745884f, -0.01966261f, 0.05364610f, -0.00799950f, -0.11400916f, 0.04157364f, -0.05626829f, 
    -0.04772744f, 0.03613670f, -0.02332027f, -0.02309641f, -0.02252374f, 0.03440380f, -0.06538930f, 0.08560413f, 
    -0.01479065f, -0.10586317f, 0.03742165f, 0.15845449f, 0.07814258f, -0.01211035f, 0.01157111f, 0.03837154f, 
    -0.07503041f, 0.01145653f, 0.16475983f, 0.04938542f, -0.04157887f, 0.01554044f, 0.13175739f, 0.01243071f, 
    0.07002322f, 0.07005566f, 0.09546751f, 0.06788920f, -0.48537135f, 0.01251814f, 0.01657427f, 0.13472737f, 
    0.02773307f, 0.04761418f, -0.08628969f, 0.10753513f, -0.11945592f, 0.06569488f, -0.00776990f, 0.02766846f, 
    -0.00034065f, -0.00183822f, 0.02788503f, 0.06300359f, -0.02405023f, 0.03826860f, 0.05021670f, -0.09887569f, 
    -0.19281290f, 0.02008865f, -0.02311354f, 0.00127272f, 0.13112798f, 0.05107789f, 0.06112857f, 0.03619727f, 
    -0.02064825f, 0.05927258f, 0.00302809f, 0.03469458f, 0.00879734f, 0.00815993f, -0.08868432f, -0.02818288f, 
    -0.01833805f, 0.05127494f, 0.02657038f, -0.13532461f, -0.20999134f, -0.03770845f, -0.23923832f, 0.15649395f, 
    0.00693655f, 0.06092998f, -0.02919295f, 0.09672558f, 0.01128101f, 0.06531373f, -0.04431373f, 0.04435381f, 
    0.01151414f, 0.02473510f, 0.00608343f, 0.02069083f, -0.00709344f, -0.02450942f, 0.06573391f, 0.06836054f, 
    0.07792111f, 0.15202907f, -0.15393676f, 0.09250846f, -0.28452861f, -0.05020372f, -0.10224616f, -0.07335906f, 
    -0.03443146f, -0.03670457f, -0.00678353f, 0.06271059f, 0.02230251f, -0.01135972f, 0.05056497f, -0.10651349f, 
    0.04476487f, 0.14529997f, 0.01049275f, -0.00044058f, 0.00966915f, -0.21445049f, 0.04850723f, 0.08532868f, 
    -0.15474768f, 0.02647357f, 0.09067289f, -0.03113348f, 0.02154989f, -0.09525418f, 0.11421801f, 0.04771336f, 
    0.01472644f, -0.00041266f, 0.06788278f, -0.06609114f, 0.00561788f, -0.05882679f, 0.04241861f, 0.05138588f, 
    -0.10056186f, -0.18128619f, 0.11570918f, 0.19335695f, -0.02442381f, -0.02414989f, -0.02749997f, 0.01604208f, 
    -0.10214014f, -0.02723682f, 0.08660697f, 0.04191396f, -0.03021818f, -0.06219567f, 0.03650606f, 0.08971399f, 
    -0.07855772f, 0.08231014f, 0.01180298f, 0.04549023f, 0.16503215f, -0.27955952f, 0.05499163f, 0.08439778f, 
    -0.05266991f, 0.02550592f, 0.00612931f, 0.05677190f, -0.05314745f, 0.02557043f, -0.04484555f, -0.05652302f, 
    0.01186609f, -0.00059866f, -0.00568944f, -0.01115107f, -0.00571557f, -0.06306902f, 0.02823809f, -0.07590716f, 
    -0.07078471f, 0.16948219f, -0.02597655f, -0.10866951f, -0.07050222f, 0.05062550f, 0.06225715f, -0.11952768f, 
    0.05356695f, -0.05319922f, 0.03981132f, 0.00818412f, 0.05929726f, 0.06631678f, -0.02236042f, 0.03280685f, 
    0.07453801f, -0.05068242f, 0.02514156f, -0.00636261f, -0.30433515f, -0.01520111f, -0.10246695f, 0.07536458f, 
    0.13305287f, 0.02627715f, 0.02490129f, 0.10323670f, -0.06441136f, -0.02517718f, 0.02626998f, -0.06286268f, 
    0.08454394f, 0.02826987f, -0.03075926f, -0.04560757f, 0.02039665f, -0.00697462f, 0.07283819f, -0.00118750f, 
    0.22131310f, 0.22829612f, -0.00839963f, -0.06215147f, -0.06809541f, -0.03522612f, 0.00100857f, 0.05810514f, 
    -0.02514716f, 0.03596726f, 0.04093808f, -0.00116445f, -0.04072635f, 0.06580855f, 0.02502884f, -0.07678933f, 
    0.00817986f, 0.02822499f, 0.00446855f, 0.10253666f, -0.33369374f, -0.13575387f, 0.06253076f, -0.07357443f, 
    0.09149610f, -0.04858968f, -0.04647540f, 0.04430108f, -0.00111014f, -0.01301139f, -0.04179220f, 0.01419558f, 
    0.01315357f, -0.05026706f, 0.01319193f, 0.00454412f, -0.01035095f, -0.03305740f, 0.06374493f, -0.08550444f, 
    0.19998905f, 0.08905432f, -0.14999829f, -0.03865172f, -0.28280830f, -0.06666952f, -0.04714802f, 0.02051854f, 
    -0.07052799f, -0.02195496f, -0.01334566f, 0.00847180f, 0.05488634f, -0.08505169f, -0.02550826f, 0.00249296f, 
    0.01945525f, 0.05706659f, 0.00272356f, -0.06172264f, -0.24694189f, 0.15409251f, 0.08762105f, 0.04938528f, 
    -0.03506446f, 0.05438289f, -0.08000750f, 0.00656416f, -0.10248749f, -0.06365150f, 0.00990480f, 0.11734220f, 
    0.02060079f, -0.05347596f, 0.07328262f, 0.02038182f, -0.05457823f, -0.08475432f, -0.04061717f, -0.05475365f, 
    -0.36206567f, -0.16452919f, -0.02723163f, 0.08676540f, 0.15839446f, 0.01730159f, 0.01458409f, -0.03143660f, 
    0.03933152f, 0.09923884f, -0.05925181f, -0.05338747f, 0.04920214f, 0.17438920f, 0.08215778f, -0.02454427f, 
    0.09260291f, 0.09796100f, 0.06903450f, -0.02620443f, -0.03071843f, -0.21690969f, 0.03438938f, -0.07122393f, 
    -0.00925518f, 0.05657523f, 0.02064596f, -0.04018387f, -0.09055063f, -0.00553570f, 0.11932259f, 0.01108224f, 
    -0.03720622f, -0.03524038f, -0.09483219f, 0.01944353f, -0.04128265f, -0.11386698f, -0.08414147f, -0.08972187f, 
    -0.27235407f, 0.11993214f, -0.02304736f, 0.02632997f, 0.09061328f, 0.02800971f, 0.01736262f, -0.00471972f, 
    0.07808217f, 0.07386395f, -0.02949573f, 0.04087919f, 0.01815758f, -0.01886322f, -0.06627462f, 0.06323561f, 
    -0.03633243f, 0.03002040f, 0.03614881f, -0.12991932f, 0.00642687f, 0.01460040f, -0.08889696f, 0.02688751f, 
    0.21087271f, 0.06367002f, 0.00384766f, 0.00699265f, 0.07297408f, 0.00346276f, 0.08288614f, 0.12372538f, 
    -0.04706702f, -0.02420794f, -0.05009488f, -0.06363560f, -0.01063893f, -0.04276528f, 0.04692331f, -0.05531082f, 
    -0.34258467f, 0.03907216f, 0.05976040f, 0.04821902f, 0.00693086f, 0.01540621f, -0.06989028f, 0.04371125f, 
    -0.01624697f, -0.04770702f, -0.00347338f, -0.01227348f, -0.14458594f, 0.04783534f, 0.03531400f, 0.02053917f, 
    0.05850231f, -0.09241639f, 0.01806994f, -0.02137195f, -0.01681191f, 0.25945485f, -0.12427188f, -0.37199122f, 
    -0.05774047f, 0.00192130f, -0.04868982f, -0.06702904f, 0.00545915f, -0.08113443f, 0.02046946f, -0.01766787f, 
    -0.08991493f, 0.04859093f, -0.03073487f, 0.01022826f, -0.07990427f, -0.11748035f, -0.01940826f, -0.01289264f, 
    0.01436504f, 0.13038002f, 0.19129868f, 0.05794449f, -0.04657689f, -0.06540995f, 0.00140040f, -0.02251281f, 
    0.02283612f, 0.01528467f, 0.03963735f, 0.00758576f, 0.03239156f, -0.01595568f, 0.05580886f, 0.02226076f, 
    0.06582387f, 0.00079105f, -0.03276799f, 0.03172404f, -0.32967377f, -0.06014357f, -0.08317083f, 0.06014727f, 
    0.18754663f, 0.04392413f, 0.04792273f, 0.02343774f, 0.06481396f, 0.07337641f, -0.02438364f, -0.07326344f, 
    0.05770036f, 0.02979834f, 0.01599141f, -0.04934838f, 0.14587454f, 0.03448994f, 0.10861976f, -0.08385424f, 
    0.29932800f, 0.23408949f, -0.00319589f, -0.16761923f, -0.08763210f, 0.12818836f, 0.13043839f, 0.12977266f, 
    0.01682525f, -0.00088082f, -0.01596184f, 0.03605014f, -0.05071829f, -0.01394417f, -0.07926684f, 0.00700271f, 
    0.11993484f, -0.02979903f, -0.01048913f, 0.05087671f, -0.04816820f, 0.22192295f, -0.04488797f, 0.07962722f, 
    -0.03592111f, 0.04374577f, -0.01155959f, -0.03201104f, 0.06810775f, -0.27214155f, -0.00671109f, -0.01102360f, 
    -0.00300100f, -0.00297392f, -0.01251040f, 0.01226440f, -0.03999088f, -0.04231411f, 0.03935752f, -0.02289994f, 
    -0.00220830f, 0.09607532f, -0.04754374f, -0.00053803f, 0.05462620f, -0.01222291f, 0.00307241f, -0.01089766f, 
    0.02146078f, 0.08419293f, -0.02906289f, 0.01496562f, 0.03862371f, -0.02530287f, 0.04241401f, -0.00306248f, 
    0.03384125f, -0.02422258f, 0.04312545f, 0.04781325f, -0.23749927f, 0.06840204f, -0.06088014f, -0.07448385f, 
    0.11017575f, -0.03821971f, -0.09342586f, 0.07155070f, 0.10851252f, -0.03795262f, -0.05382884f, 0.04058018f, 
    0.00649267f, -0.05831477f, -0.01637412f, 0.08764819f, -0.05874748f, -0.14675285f, -0.01829662f, -0.07629745f, 
    -0.33382201f, -0.10150322f, 0.15313376f, 0.12510391f, 0.03562752f, -0.08009177f, -0.04082870f, 0.07655858f, 
    -0.01007163f, 0.03847557f, 0.06442481f, 0.02708573f, -0.00978736f, -0.13812451f, 0.00032721f, 0.09927165f, 
    0.03923104f, -0.00974397f, 0.03298858f, 0.03498675f, -0.28724772f, 0.02423576f, -0.10109303f, -0.04694746f, 
    0.12965414f, 0.01199600f, 0.03702535f, 0.01792750f, 0.08582820f, -0.02672711f, 0.00332494f, -0.00396000f, 
    -0.03176045f, 0.05098980f, 0.00940454f, -0.01197019f, 0.04066202f, -0.00178367f, 0.05320187f, -0.02077210f, 
    -0.28506526f, 0.02053134f, -0.17126411f, 0.06715531f, -0.01171657f, 0.09741879f, -0.13826923f, 0.11688092f, 
    0.05175307f, 0.00533561f, -0.02998947f, 0.00848645f, -0.01358297f, -0.07949197f, 0.06566573f, -0.07185936f, 
    0.03580569f, -0.07442012f, -0.00209185f, 0.01581488f, -0.07841641f, -0.04503617f, -0.03973790f, -0.10406124f, 
    0.06043524f, -0.02300637f, -0.06182439f, -0.07324652f, 0.01537712f, 0.00944675f, -0.03192533f, -0.11305691f, 
    0.01977975f, -0.01878051f, 0.00830500f, 0.03599742f, -0.05249406f, -0.04806454f, -0.06339598f, -0.02038070f, 
    0.26256555f, 0.09793214f, -0.20400029f, 0.04154182f, -0.27723449f, -0.01175399f, -0.02689683f, 0.07977358f, 
    -0.00868617f, -0.04128570f, -0.10927044f, -0.02067507f, 0.05084473f, 0.04249616f, 0.02259326f, -0.08173186f, 
    0.01628953f, 0.08307450f, -0.03744755f, 0.01609185f, -0.23116277f, 0.17603357f, -0.02731518f, 0.10953598f, 
    -0.09599184f, -0.02836233f, -0.08013701f, 0.01162237f, -0.05180755f, -0.08374736f, -0.01393832f, -0.01258326f, 
    0.00211751f, 0.06799315f, 0.03530506f, -0.04897179f, -0.07837512f, 0.05528163f, -0.10363926f, 0.05705621f, 
    -0.15720674f, -0.14801157f, 0.20524034f, 0.14602408f, 0.00189570f, 0.01459947f, -0.02835577f, 0.05333267f, 
    -0.07198601f, -0.11999045f, 0.03340251f, 0.00182364f, -0.02590614f, -0.00354753f, 0.08990709f, -0.00736460f, 
    -0.09434873f, 0.00185199f, 0.03043509f, -0.08393397f, -0.01758626f, 0.07897709f, -0.06413095f, 0.05342845f, 
    -0.26377875f, -0.08606485f, -0.04334568f, 0.04136188f, 0.09071431f, -0.04329767f, 0.00694476f, -0.09329900f, 
    -0.00331707f, 0.02857356f, 0.04733271f, -0.02494475f, 0.01041390f, -0.08308791f, -0.05872578f, 0.03649475f, 
    0.03142600f, 0.07211286f, -0.00237754f, 0.05209601f, -0.07273047f, 0.03542485f, 0.03698913f, 0.00859224f, 
    -0.05011915f, 0.06051105f, 0.01262024f, -0.07217594f, -0.03166926f, -0.02054613f, 0.07832131f, 0.01566398f, 
    0.02350697f, 0.00892007f, 0.07993388f, 0.00766080f, 0.04633042f, -0.09708992f, 0.00865405f, 0.22107907f, 
    0.03730129f, -0.00002506f, 0.04085548f, 0.06813145f, -0.04177388f, -0.00546584f, 0.06758015f, -0.04144087f, 
    -0.01135096f, -0.00541989f, 0.04355446f, -0.00085545f, -0.00070220f, -0.05208783f, 0.03731649f, -0.06235734f, 
    0.07223820f, -0.07442484f, -0.08285633f, 0.21341722f, 0.13581093f, -0.03660650f, -0.03113579f, -0.07976172f, 
    0.13018605f, 0.07786123f, 0.08585510f, 0.08018237f, -0.10539933f, 0.09099864f, 0.00671566f, -0.09441003f, 
    -0.09982424f, 0.06962524f, -0.16551095f, -0.02108480f, 0.13396779f, 0.04077705f, 0.09662434f, -0.01422866f, 
    0.04152058f, -0.00666756f, -0.00981307f, -0.03853028f, -0.07860650f, 0.07433286f, -0.00320798f, 0.01040221f, 
    0.05963983f, 0.01987609f, -0.01157958f, 0.06132158f, -0.10991533f, -0.01917025f, 0.10107131f, -0.00119273f, 
    -0.11045075f, 0.04192609f, 0.01460769f, -0.01507599f, 0.01069678f, -0.02390674f, 0.00045020f, 0.07052824f, 
    0.06704963f, -0.11417858f, 0.14013849f, 0.07782226f, 0.05146650f, -0.02537161f, 0.00905086f, 0.00141984f, 
    -0.03760379f, -0.06632058f, 0.09164390f, 0.01167520f, 0.05749948f, 0.13640311f, 0.07445776f, 0.11714208f, 
    -0.11517951f, -0.03653651f, 0.04603362f, -0.00872619f, -0.04861984f, -0.07191447f, -0.00820487f, -0.03495671f, 
    -0.03160874f, -0.03685183f, -0.08258718f, 0.13423702f, -0.05286884f, 0.08883804f, 0.05915814f, 0.06052130f, 
    0.12215092f, 0.01941424f, 0.16883001f, 0.00793330f, -0.02445553f, 0.04653821f, 0.05664979f, 0.00512853f, 
    -0.00019036f, -0.00958132f, 0.06265360f, -0.03206494f, -0.08116044f, 0.03023309f, 0.05122884f, 0.06132187f, 
    0.03769304f, 0.08649655f, 0.01387178f, -0.01251903f, -0.09439914f, -0.07733434f, 0.04688445f, 0.16919315f, 
    -0.07833613f, -0.07482307f, -0.07726073f, -0.07468829f, 0.02787946f, 0.05063203f, 0.05766658f, -0.15742299f, 
    -0.04336613f, -0.04472322f, -0.04018224f, 0.03140108f, 0.01148751f, -0.03452618f, -0.14752907f, 0.00429321f, 
    -0.05208325f, -0.01871286f, 0.02229336f, 0.05699768f, -0.18366729f, -0.03773468f, 0.02784464f, -0.02058597f, 
    0.01839973f, -0.01628166f, 0.03686215f, 0.07520907f, 0.04669419f, 0.08575616f, -0.01828654f, -0.08556351f, 
    -0.08383060f, 0.00107710f, -0.05714507f, -0.01857379f, 0.09716756f, 0.03474980f, -0.03626895f, 0.13386825f, 
    0.02444573f, -0.02903810f, -0.04317372f, -0.01335654f, -0.00734398f, 0.04777148f, -0.08359101f, -0.06858604f, 
    0.01443898f, 0.08911384f, 0.09495911f, 0.00981353f, 0.06529053f, -0.00268440f, 0.03243522f, 0.01700481f, 
    -0.06552405f, -0.04520920f, -0.15298778f, 0.03696223f, 0.11353084f, -0.10765345f, 0.08487639f, 0.02485085f, 
    0.04527571f, 0.16275732f, -0.04282562f, 0.23751462f, 0.16658916f, 0.05233320f, 0.05116071f, 0.03073685f, 
    0.08990343f, -0.05083282f, 0.11147596f, -0.11973557f, -0.21442957f, 0.18611564f, -0.24171978f, -0.09623194f, 
    -0.02624963f, 0.10954065f, 0.02635758f, 0.00911766f, -0.02836555f, -0.08106421f, 0.02654439f, -0.05561876f, 
    -0.08321986f, -0.06850094f, -0.04767366f, -0.03977091f, -0.06141860f, -0.03439185f, 0.03527144f, -0.02123637f, 
    0.11850535f, 0.09005370f, 0.02019264f, 0.20020631f, 0.16889927f, -0.11023612f, -0.03644196f, 0.03077303f, 
    -0.00776024f, 0.04423545f, -0.04809419f, -0.11491842f, 0.01094856f, 0.08105137f, 0.06664576f, 0.06805027f, 
    0.00113848f, 0.04520850f, -0.03374959f, -0.01512400f, 0.13155393f, 0.09701554f, 0.11782875f, -0.01697251f, 
    -0.11124021f, -0.00568779f, 0.09898140f, -0.05854233f, -0.10149545f, 0.00391626f, -0.02197652f, -0.00334194f, 
    -0.02464880f, -0.00933191f, 0.08598572f, -0.01584923f, 0.02318698f, 0.10844252f, 0.00099974f, -0.01717776f, 
    -0.25000310f, 0.06015651f, 0.13254717f, -0.00667189f, -0.18790224f, 0.01920825f, 0.05390499f, -0.00651212f, 
    -0.08251341f, -0.09677348f, 0.08834107f, -0.11677773f, 0.01761772f, -0.04375632f, -0.08384467f, -0.02020506f, 
    0.01952577f, 0.07819802f, 0.04413502f, -0.01416338f, 0.05883402f, 0.07103222f, -0.02404949f, -0.06591485f, 
    0.07418486f, -0.05699052f, -0.08308508f, -0.07094355f, 0.07114568f, 0.03462644f, -0.04624876f, 0.10211273f, 
    -0.15381551f, 0.03189651f, -0.02770101f, 0.06467610f, -0.05085256f, 0.10988721f, -0.08376889f, 0.07641253f, 
    -0.38945645f, -0.12773833f, 0.20871595f, 0.00980878f, -0.13203739f, 0.05465973f, 0.09338436f, -0.05347974f, 
    0.05153525f, -0.02534014f, -0.03668505f, -0.04084242f, -0.03569489f, 0.00302615f, -0.09120851f, -0.08165495f, 
    0.06497549f, 0.05486682f, 0.00664579f, 0.06338762f, -0.37594184f, 0.23315665f, 0.02422326f, 0.06501243f, 
    -0.04341698f, -0.18057251f, 0.02946736f, -0.04853044f, -0.01587966f, -0.00947789f, -0.08162005f, -0.00793954f, 
    -0.02900129f, 0.08095518f, -0.02040162f, -0.01014884f, -0.04194438f, 0.01550890f, 0.09261229f, -0.04087552f, 
    -0.18439056f, -0.18851222f, 0.05841077f, 0.14388952f, -0.03102070f, -0.01398092f, 0.01010404f, -0.03992021f, 
    -0.00318598f, -0.00855399f, -0.03897966f, -0.01346372f, 0.02135966f, 0.01478346f, 0.13285553f, -0.01647632f, 
    0.02933510f, -0.07622684f, 0.00175663f, -0.07301994f, -0.10686786f, 0.09658404f, -0.15508226f, -0.11632409f, 
    0.05659912f, 0.11184003f, 0.08253635f, 0.01365661f, -0.02486184f, -0.09804676f, 0.04395781f, -0.04318887f, 
    -0.01957253f, -0.05227237f, 0.05715344f, 0.02094233f, 0.01988065f, -0.10458487f, -0.01696515f, -0.02264268f, 
    -0.41221380f, -0.16396575f, -0.24056219f, -0.13881454f, 0.07069169f, 0.04863885f, 0.19407530f, 0.02309508f, 
    -0.04474052f, -0.05392645f, 0.00432016f, 0.09010060f, -0.04421290f, -0.01279825f, -0.06107461f, -0.06753514f, 
    0.05963341f, 0.03351361f, -0.03945490f, 0.06136243f, 0.03307932f, 0.06545179f, 0.03308868f, -0.05432406f, 
    -0.07108679f, -0.08853880f, -0.01600385f, 0.01194208f, 0.06228178f, 0.06636386f, -0.04243982f, 0.00096313f, 
    0.03533429f, 0.02356021f, 0.10998068f, 0.08144157f, -0.01378875f, 0.07146826f, -0.17914674f, -0.00106805f, 
    -0.32072729f, -0.18580197f, -0.01852755f, 0.02287451f, 0.08967057f, 0.00450438f, -0.07841256f, -0.10574111f, 
    -0.03857003f, 0.05454924f, -0.04708023f, 0.05407532f, 0.03049736f, 0.14459905f, -0.09919839f, -0.00024701f, 
    0.04341960f, -0.07568508f, -0.11481892f, 0.00011776f, -0.09690825f, -0.11883759f, -0.07655162f, 0.13682820f, 
    0.10136562f, -0.00084899f, 0.02753512f, 0.07772030f, 0.03489598f, -0.06608703f, -0.09280162f, -0.03204672f, 
    -0.00450639f, 0.03442587f, 0.02422997f, -0.09533797f, -0.04032858f, -0.00254280f, -0.03276516f, 0.00822458f, 
    -0.02532511f, 0.00521533f, 0.02951962f, 0.09901114f, -0.02991808f, -0.02816476f, 0.06625749f, 0.08339581f, 
    -0.01055574f, 0.07445677f, -0.06821886f, -0.09143527f, 0.07459982f, 0.03353370f, 0.05791790f, -0.00763402f, 
    -0.05855871f, -0.02152909f, 0.07196181f, 0.06327092f, -0.00238791f, 0.12804100f, 0.03064179f, 0.08544599f, 
    -0.00978968f, -0.02978549f, -0.05302866f, -0.10123413f, 0.00097198f, 0.04388521f, -0.07674329f, -0.00115202f, 
    -0.03205864f, -0.01923529f, 0.04370109f, 0.04264187f, -0.01169214f, -0.00716638f, 0.07221057f, -0.00073728f, 
    -0.12368561f, -0.07895205f, 0.01627531f, 0.08011722f, -0.16847323f, -0.04591003f, 0.05048900f, 0.03448350f, 
    0.02133086f, 0.03691798f, -0.00580798f, 0.04181360f, -0.06255911f, -0.01296302f, 0.02928586f, 0.00283793f, 
    -0.00520122f, 0.04746484f, -0.02968254f, 0.02049564f, -0.06361543f, 0.05345733f, -0.02099510f, 0.08656725f, 
    0.16339849f, 0.05418150f, -0.04255810f, -0.02949136f, 0.04902548f, -0.02759543f, -0.01580184f, 0.02873344f, 
    0.00837779f, -0.00373292f, 0.11791069f, -0.01203276f, 0.01470107f, 0.00596649f, -0.18837149f, -0.03019142f, 
    -0.43550485f, 0.01462162f, -0.17921814f, 0.04958380f, -0.03225225f, 0.04570803f, -0.01388047f, 0.06355030f, 
    0.01415369f, -0.01056539f, 0.07585491f, 0.08064676f, 0.06325402f, -0.01454396f, -0.04407240f, 0.13224554f, 
    0.00582435f, 0.00315205f, -0.06007914f, -0.05719533f, -0.09748746f, 0.02602609f, -0.10492124f, 0.07739419f, 
    -0.00361520f, 0.00770820f, -0.07229557f, 0.04560423f, 0.03338939f, 0.05808138f, 0.07777413f, 0.08891400f, 
    0.03996668f, -0.04029366f, -0.02447599f, 0.01005435f, -0.00971546f, 0.02144059f, 0.08859545f, -0.16164030f, 
    0.06109348f, 0.11624986f, 0.00467434f, 0.08983444f, 0.23630854f, 0.10648169f, 0.04193429f, 0.00176653f, 
    0.08228559f, 0.08060889f, -0.05878964f, -0.06033459f, 0.09665474f, 0.01836601f, 0.10006635f, -0.05824116f, 
    0.00724240f, -0.02173546f, -0.29998159f, -0.00775092f, -0.00405776f, 0.11498360f, 0.01562740f, -0.07584959f, 
    0.02365578f, -0.02112454f, 0.02978706f, 0.00968693f, 0.00762487f, -0.10211893f, -0.04078115f, 0.01754547f, 
    -0.03145452f, -0.09438593f, 0.04644350f, -0.05318193f, 0.03279820f, -0.01750181f, 0.06469711f, 0.00712151f, 
    -0.40823108f, -0.03147346f, -0.05432234f, -0.12709768f, -0.00824617f, 0.10954186f, -0.09953502f, -0.01906762f, 
    0.03952821f, -0.14992644f, 0.07312974f, 0.04226400f, -0.10040741f, 0.02104885f, -0.01466787f, 0.03007506f, 
    0.00133734f, -0.02230638f, -0.03357482f, -0.00658818f, -0.20008408f, 0.07134403f, -0.08671634f, -0.04428405f, 
    -0.01176702f, 0.03258846f, -0.06486773f, -0.05652491f, -0.06308214f, 0.08782665f, -0.04635184f, 0.08621913f, 
    -0.05254917f, -0.18335158f, 0.05189520f, -0.17199180f, 0.00893492f, -0.02560922f, -0.07501289f, -0.08906084f, 
    0.09375783f, -0.17636022f, -0.02420755f, -0.11710621f, 0.07714664f, 0.00736705f, -0.07178885f, -0.18521048f, 
    0.03535949f, 0.10570330f, 0.03827580f, 0.01361330f, 0.02498069f, -0.02130438f, -0.04744510f, 0.14076126f, 
    -0.18743385f, -0.07375623f, -0.10666789f, 0.09115872f, 0.03551672f, 0.06331503f, 0.06680359f, 0.23955035f, 
    0.04586961f, -0.05464408f, -0.08284602f, -0.01614328f, -0.08121300f, 0.08619156f, 0.03625203f, -0.09978620f, 
    0.00290100f, 0.08496840f, -0.05036770f, 0.04427614f, 0.04833147f, -0.18424495f, -0.11436342f, 0.01251948f, 
    0.00267889f, 0.07400724f, -0.01071685f, 0.01644042f, 0.15685782f, -0.13373075f, 0.02461914f, -0.03141756f, 
    0.11035089f, 0.00216991f, -0.01949022f, -0.04784457f, 0.06576622f, 0.15808004f, 0.15778838f, -0.11855776f, 
    0.04529865f, -0.00374713f, 0.03200760f, -0.13134710f, 0.09360331f, 0.25571209f, 0.06054150f, 0.01900073f, 
    -0.03100669f, -0.05845387f, 0.04223768f, -0.04340902f, -0.16448195f, 0.12190581f, 0.07538844f, -0.00732322f, 
    -0.02216697f, 0.05589655f, -0.12240247f, 0.06108237f, -0.06010877f, 0.06518865f, 0.08544718f, -0.03789784f, 
    0.12324744f, 0.02473796f, 0.21518834f, 0.09384792f, 0.13972126f, 0.09120721f, 0.02909908f, 0.04466513f, 
    -0.04496632f, -0.05063844f, 0.00243680f, -0.01305600f, -0.06046270f, 0.01376239f, 0.02734485f, 0.11695309f, 
    -0.07007081f, 0.01844363f, 0.04642943f, 0.05101465f, -0.39634368f, 0.08370883f, -0.08002019f, -0.05160065f, 
    -0.05835507f, 0.05221693f, -0.03511108f, 0.08423521f, 0.02889306f, -0.09256648f, 0.09418505f, -0.03884277f, 
    0.00445348f, -0.09858014f, 0.01943024f, 0.04694305f, -0.00948570f, 0.02001867f, -0.07534774f, 0.02506528f, 
    -0.13602732f, -0.06093892f, 0.14096498f, 0.24072835f, -0.23275456f, -0.05390246f, -0.07674189f, -0.05483854f, 
    0.01029300f, -0.00957115f, 0.00075906f, 0.04537277f, 0.00527870f, -0.04848919f, 0.08055877f, -0.03510581f, 
    -0.01772889f, 0.00250166f, -0.01951461f, -0.18366911f, 0.14766335f, 0.02667833f, -0.03996528f, -0.06669442f, 
    -0.15129077f, -0.08823711f, -0.01316037f, 0.05052348f, 0.00648488f, 0.04112428f, -0.05008601f, -0.00844324f, 
    0.04506865f, -0.03805758f, 0.04727220f, -0.01602489f, 0.00044846f, 0.03464337f, -0.00132960f, 0.08124977f, 
    -0.06825833f, 0.02857652f, 0.02954452f, -0.04041913f, 0.05456618f, -0.01844406f, -0.02867795f, 0.02330237f, 
    -0.06724928f, 0.06092382f, -0.01925757f, -0.03530500f, 0.01043829f, -0.04399726f, -0.05506442f, -0.02781872f, 
    -0.04681951f, -0.00211153f, -0.04743275f, 0.09240965f, -0.25689167f, 0.04855007f, -0.00030997f, -0.02361455f, 
    0.02477195f, -0.01306532f, -0.07571357f, -0.03529139f, -0.02031357f, -0.04978767f, 0.05114049f, -0.07469751f, 
    -0.08508677f, -0.04613990f, 0.02859072f, -0.04927455f, 0.04385652f, 0.03949665f, -0.00965448f, -0.06589250f, 
    0.09585512f, 0.26505780f, -0.15365468f, -0.14690275f, -0.04785540f, 0.10187551f, 0.08952272f, 0.05613188f, 
    -0.07760219f, -0.09780341f, 0.02641019f, -0.11065388f, -0.08283928f, -0.09057092f, -0.03637021f, -0.01049278f, 
    0.00526569f, -0.03721341f, 0.03185872f, -0.02181070f, -0.07426882f, 0.01403817f, 0.03448580f, 0.24203444f, 
    0.12443980f, -0.04073428f, -0.00382349f, -0.07002985f, 0.03347705f, 0.08533782f, 0.11984174f, -0.06771129f, 
    0.04939802f, 0.04349772f, 0.03116219f, -0.05365136f, 0.09855313f, -0.02726677f, -0.08264484f, -0.14129615f, 
    -0.45780963f, -0.16525641f, -0.20198323f, -0.11070444f, -0.04399645f, 0.04596812f, 0.01887381f, -0.03314677f, 
    0.02203282f, -0.16481416f, 0.01958868f, 0.00226280f, 0.05282407f, -0.03730936f, -0.04100434f, 0.01357685f, 
    0.03484173f, 0.02913588f, 0.05077875f, 0.07656960f, -0.24835302f, -0.36082259f, -0.17780532f, -0.06838293f, 
    0.00331755f, 0.13726988f, 0.03121481f, 0.08187667f, -0.04160750f, 0.02622157f, 0.02573749f, 0.07232211f, 
    0.01344661f, 0.09116105f, -0.06020131f, 0.03886487f, 0.06017896f, 0.06064361f, -0.26970428f, 0.09510431f, 
    0.08306912f, -0.10766826f, -0.07603092f, -0.10756389f, -0.07698208f, 0.03438868f, -0.06055359f, 0.06090025f, 
    0.07293761f, -0.15048400f, 0.01931215f, 0.10398979f, -0.01712199f, 0.03715021f, 0.05959396f, -0.06317744f, 
    -0.03855495f, 0.03570144f, -0.11646355f, -0.01194372f, -0.32763320f, -0.07457374f, -0.03887898f, 0.06664190f, 
    -0.02638092f, -0.02689443f, 0.04187700f, 0.01921252f, -0.04474157f, 0.06387079f, -0.01856144f, 0.04944603f, 
    0.09188670f, -0.02545055f, 0.02028156f, 0.05431010f, 0.07846202f, 0.07251804f, 0.00027256f, -0.08696323f, 
    -0.02471829f, -0.09643512f, -0.05353757f, 0.05326065f, 0.08544660f, -0.04042964f, 0.07394351f, -0.00522452f, 
    0.00197863f, -0.01574405f, -0.05888920f, 0.08756949f, 0.07181352f, 0.03898916f, 0.05661400f, -0.13087116f, 
    -0.02477836f, 0.04248014f, -0.02396877f, -0.03331348f, -0.16416624f, 0.10987325f, -0.32027075f, -0.13156720f, 
    -0.09719630f, 0.11045890f, 0.03608991f, 0.10011112f, -0.07321040f, -0.04659611f, -0.04174184f, 0.03885124f, 
    -0.12083864f, -0.00147440f, -0.02453447f, 0.02609115f, -0.05178803f, -0.00846570f, -0.09135598f, -0.00435575f, 
    -0.52141029f, -0.20389266f, 0.22194161f, 0.22235052f, -0.26742899f, -0.00529107f, -0.08090921f, -0.03324670f, 
    -0.07357486f, 0.00503922f, 0.01805958f, 0.00824892f, 0.05349090f, -0.00611275f, -0.03343271f, -0.10635588f, 
    -0.01853228f, 0.00912759f, -0.00779949f, 0.04685260f, -0.20781414f, -0.11564407f, 0.00785019f, 0.10959211f, 
    0.05618832f, 0.05327040f, -0.09707376f, 0.05843506f, 0.07833914f, 0.11496425f, -0.00384895f, -0.05890711f, 
    0.00393758f, 0.03453423f, 0.04448400f, -0.18264858f, 0.04727215f, -0.18902357f, -0.03106230f, -0.00993435f, 
    0.14749800f, 0.05315556f, 0.04183865f, 0.07048590f, -0.18763497f, 0.01745407f, -0.02974278f, 0.02713815f, 
    -0.01809558f, 0.00178153f, 0.00726049f, 0.03212192f, 0.01835554f, -0.04273753f, -0.02719361f, 0.02614623f, 
    -0.06323874f, 0.05877087f, 0.08294581f, 0.01933522f, 0.01611122f, -0.07815341f, 0.04823061f, 0.08089485f, 
    -0.30825484f, 0.03034614f, 0.06118878f, -0.06431067f, -0.00219491f, 0.04381036f, 0.00517728f, -0.02706338f, 
    0.01043607f, 0.11213704f, -0.05599075f, 0.00559162f, -0.00165843f, 0.02244132f, 0.12664968f, 0.02828788f, 
    0.05912640f, -0.05794701f, -0.00278545f, 0.09033249f, -0.18271333f, -0.16875206f, 0.00583633f, -0.09550556f, 
    0.00593696f, 0.03461625f, -0.10524961f, -0.00815509f, 0.13730593f, 0.03790405f, 0.12562625f, -0.03007861f, 
    -0.02344511f, 0.02457001f, 0.00199622f, 0.03823617f, -0.30173075f, 0.05441461f, -0.18304585f, -0.03947468f, 
    -0.10694351f, 0.06039144f, 0.00084098f, 0.06030830f, -0.03160996f, -0.04579416f, -0.04166182f, -0.01885307f, 
    0.06369283f, -0.03343057f, -0.05162621f, 0.03254721f, -0.06161034f, 0.03042780f, 0.00556813f, -0.01691360f, 
    -0.00350474f, 0.00434336f, 0.05730372f, 0.02421538f, -0.01588442f, -0.11080571f, 0.03292496f, 0.03667071f, 
    -0.08222154f, 0.07827657f, 0.13027316f, -0.04239814f, 0.11368975f, -0.09094337f, -0.14788225f, 0.11052382f, 
    0.07646015f, -0.13583733f, 0.14605600f, 0.11344106f, -0.07539424f, -0.00812159f, -0.02107934f, 0.09045690f, 
    -0.09771527f, -0.02150197f, 0.09267379f, 0.04550151f, 0.06160417f, 0.08632549f, -0.03150764f, 0.04985788f, 
    -0.09215033f, -0.00787498f, 0.03400605f, -0.02475759f, -0.00019279f, 0.03284577f, 0.02702062f, -0.00751572f, 
    0.04435267f, 0.10977720f, -0.08484140f, -0.06283374f, 0.15721744f, -0.01441193f, -0.03639910f, -0.05317111f, 
    -0.07067860f, 0.03708924f, 0.10974424f, 0.04385968f, 0.03359634f, 0.02309415f, -0.03692879f, -0.03259484f, 
    0.01807633f, -0.01313393f, 0.04812318f, 0.01760949f, -0.14162505f, 0.03085118f, -0.18933062f, -0.04516372f, 
    0.03052862f, 0.06328649f, 0.03214928f, -0.05070877f, 0.02279752f, 0.03552136f, 0.09143434f, 0.05377263f, 
    0.03608708f, 0.03119866f, 0.01277986f, 0.06247259f, 0.02827877f, -0.00385419f, 0.11133866f, -0.07331134f, 
    0.21931009f, -0.00356028f, 0.00420331f, 0.10540243f, -0.02268935f, -0.03423062f, -0.10649028f, 0.03652816f, 
    0.00590658f, 0.02366774f, 0.00057190f, -0.06509865f, 0.03460075f, 0.10857048f, -0.01731872f, 0.07134814f, 
    0.00152265f, -0.12448900f, 0.00501367f, -0.01169893f, 0.00511390f, 0.02266864f, 0.05408602f, -0.03901768f, 
    0.01253994f, 0.05124784f, -0.00988655f, -0.06249865f, -0.02051570f, 0.04956086f, 0.05504953f, 0.00031188f, 
    0.02756823f, -0.01109573f, -0.09984775f, -0.07351395f, -0.01007861f, -0.01627179f, 0.06684610f, -0.02585509f, 
    -0.06738362f, 0.15542786f, -0.10536788f, 0.12156720f, -0.16733649f, -0.06952699f, 0.04939757f, -0.01325630f, 
    0.05204459f, -0.02019754f, 0.00629993f, 0.08745277f, -0.02433440f, -0.04392134f, -0.04710561f, -0.05341672f, 
    -0.05829873f, 0.04806483f, -0.08107164f, -0.00755255f, -0.20870346f, 0.14623265f, -0.04069702f, 0.05674334f, 
    0.10792685f, -0.07159907f, -0.06114833f, 0.00515552f, 0.05541969f, 0.05044927f, -0.02119360f, 0.05592275f, 
    0.00794284f, 0.02236668f, 0.08977072f, -0.04402643f, 0.00847889f, 0.07862509f, 0.01237585f, 0.03526982f, 
    -0.12549463f, -0.02614407f, 0.12386978f, -0.08237135f, 0.01579143f, 0.01269669f, -0.06593800f, 0.08884823f, 
    -0.15630752f, -0.06874292f, -0.02419183f, -0.05847417f, 0.09474549f, -0.11766416f, -0.01494739f, 0.10774931f, 
    -0.03515869f, 0.01081007f, 0.21360295f, 0.10746330f, -0.38719133f, 0.21262729f, 0.03432349f, 0.10616218f, 
    -0.31175581f, 0.00091975f, -0.00541466f, -0.00134282f, 0.08833711f, 0.03179925f, -0.01061000f, 0.00084258f, 
    0.04161748f, 0.02250533f, 0.06046253f, -0.03550935f, 0.01615846f, -0.02817089f, -0.00853965f, -0.04369210f, 
    0.05041737f, -0.35261506f, -0.09697957f, 0.07643347f, -0.09773548f, -0.02549918f, 0.02929489f, 0.03118083f, 
    -0.02823361f, -0.02115611f, 0.07506476f, -0.05690830f, 0.01841143f, 0.08164789f, -0.00491593f, -0.05570501f, 
    0.03865791f, 0.02833974f, -0.05777441f, -0.10281185f, 0.20164411f, -0.21206440f, -0.11166425f, 0.04229486f, 
    0.03195899f, -0.03983450f, 0.01407826f, 0.05925815f, 0.00730835f, 0.10207808f, 0.00253059f, 0.01826889f, 
    0.13225590f, 0.02842405f, 0.11642203f, 0.03945726f, 0.00137757f, -0.05326426f, -0.07942124f, -0.01339287f, 
    -0.21890494f, 0.03959856f, -0.04186496f, 0.16654265f, 0.03929567f, -0.06859872f, -0.00096582f, 0.01922961f, 
    0.06916451f, 0.05886414f, -0.05721913f, -0.03147429f, 0.03456341f, 0.00277210f, -0.00028877f, -0.08797324f, 
    0.01901816f, -0.09754667f, -0.08504941f, -0.08272079f, 0.33208138f, 0.01914210f, 0.11212429f, 0.11781467f, 
    0.16147867f, -0.01232999f, 0.00469729f, 0.02503365f, -0.05291025f, -0.04822850f, 0.04082579f, 0.01942357f, 
    0.07175730f, -0.00198779f, 0.13448630f, -0.02080938f, 0.01283296f, -0.06258467f, 0.08421656f, -0.16239555f, 
    0.06009952f, -0.03430537f, 0.07396585f, -0.03929674f, 0.10782388f, 0.06763305f, 0.04718024f, 0.09111906f, 
    0.07473017f, -0.03548102f, -0.12097894f, 0.00587986f, -0.12414941f, -0.01508276f, -0.03201352f, -0.00776059f, 
    0.07340498f, 0.15430298f, 0.11944468f, 0.08071682f, -0.09935240f, 0.20988290f, 0.02988825f, 0.00623776f, 
    -0.24183242f, 0.03725164f, 0.05671885f, 0.04972334f, 0.05292658f, 0.04368819f, 0.04072504f, 0.04793989f, 
    -0.03543589f, -0.06813488f, -0.10490090f, 0.03221883f, -0.02250807f, 0.02611594f, -0.02701116f, 0.01921330f, 
    0.12413358f, -0.07530022f, -0.07843854f, -0.13806142f, 0.06898753f, 0.10864968f, -0.01699166f, -0.00841339f, 
    -0.19420682f, -0.15079880f, -0.01955299f, -0.13639434f, -0.12172125f, -0.05412791f, -0.01022512f, -0.03048017f, 
    -0.03833204f, 0.10516403f, -0.03902247f, 0.09358825f, 0.32036078f, -0.19183359f, -0.03263453f, -0.21883117f, 
    0.02654717f, 0.03648171f, 0.07460780f, 0.02602670f, -0.00788810f, -0.15205565f, -0.00674284f, -0.03651668f, 
    0.17095888f, 0.01200150f, -0.03419729f, 0.06529604f, -0.01307544f, 0.01246693f, -0.10163965f, 0.14187503f, 
    -0.10622477f, 0.19679321f, 0.08744570f, -0.01123217f, -0.19629864f, 0.03763879f, 0.06600442f, -0.01209065f, 
    0.04092592f, 0.06459961f, -0.04620017f, 0.06696060f, 0.04415937f, -0.00221765f, -0.08669106f, 0.02331987f, 
    -0.01148502f, 0.01786230f, 0.01347449f, -0.04061494f, -0.31362006f, 0.19693814f, -0.05658801f, 0.12078016f, 
    -0.17200397f, -0.07440671f, -0.08475419f, 0.00229211f, 0.07810271f, 0.05701397f, 0.04025531f, -0.00194304f, 
    -0.01711438f, -0.00016647f, -0.01278751f, 0.09706892f, 0.00973170f, -0.09334937f, -0.04161501f, 0.05045302f, 
    0.22371604f, -0.36016414f, -0.12227454f, 0.02877058f, -0.11983347f, -0.02295347f, 0.05612309f, 0.02452603f, 
    -0.03073390f, 0.04677561f, -0.05886360f, -0.00017839f, -0.08012912f, 0.02539022f, 0.05118715f, 0.07817011f, 
    -0.01678640f, -0.00842686f, -0.13615589f, 0.02625254f, 0.09859693f, 0.06060893f, 0.06494021f, 0.05278787f, 
    0.01933936f, 0.05676245f, 0.04033781f, 0.05059569f, 0.01028008f, -0.00128671f, -0.02311516f, -0.04229046f, 
    0.14998572f, -0.03513222f, -0.00766049f, -0.05720604f, 0.10018827f, 0.07532674f, 0.03143114f, -0.02127099f, 
    0.17239533f, -0.13017535f, -0.02622050f, 0.11218956f, -0.00249743f, -0.06088748f, -0.06809217f, 0.03232650f, 
    0.04921995f, 0.09390400f, 0.00404994f, 0.03985740f, -0.02980286f, 0.00333460f, 0.04276898f, 0.02394212f, 
    -0.00480945f, -0.07047618f, -0.04523384f, -0.12338052f, 0.20432146f, -0.29470366f, -0.02113887f, 0.00868169f, 
    0.41317430f, 0.07456501f, -0.03760409f, 0.00867300f, 0.04508507f, -0.08727069f, -0.10211125f, -0.00993350f, 
    0.01190574f, -0.00741618f, 0.18812940f, -0.07845242f, -0.08970293f, -0.06135768f, -0.13845047f, -0.05205344f, 
    0.19558479f, -0.08970840f, 0.02022770f, 0.02670277f, 0.01903208f, 0.02114878f, 0.03763381f, 0.06807691f, 
    0.03114435f, -0.07885672f, 0.08500901f, 0.00992288f, 0.01648992f, -0.00292088f, -0.16591868f, 0.08058602f, 
    -0.01987619f, 0.02344722f, 0.00462761f, 0.07418853f, -0.02164535f, -0.13613391f, -0.01916584f, -0.10880451f, 
    0.02905490f, -0.04265698f, 0.05797398f, -0.08468491f, 0.01230678f, -0.06451347f, 0.04528252f, 0.04251730f, 
    -0.03999939f, -0.00212192f, 0.10242052f, 0.04670584f, -0.02995066f, -0.00253294f, -0.07296832f, 0.05232991f, 
    -0.20071685f, 0.01715126f, 0.05181806f, -0.35040471f, 0.16845824f, -0.04112431f, -0.11920330f, 0.02490362f, 
    0.00889155f, -0.06199897f, 0.03938557f, -0.10681447f, 0.04713218f, 0.03225688f, -0.02522072f, -0.04760911f, 
    -0.03691351f, -0.09254368f, 0.04744815f, 0.03866741f, 0.25135034f, 0.03073120f, 0.09917480f, 0.03239607f, 
    -0.00136939f, 0.03053693f, 0.03960698f, 0.00948924f, -0.02559053f, -0.03824486f, 0.02556976f, 0.03626542f, 
    0.02158986f, -0.00103582f, 0.01355530f, 0.03029675f, -0.00833324f, 0.00911961f, 0.00623516f, -0.00731208f, 
    -0.24537924f, 0.09684142f, -0.08843043f, -0.15282442f, 0.10398757f, -0.06837670f, 0.00326450f, 0.04878892f, 
    -0.08929853f, -0.04740860f, -0.01812208f, -0.05346054f, -0.03696937f, -0.00441661f, 0.03696175f, -0.06587570f, 
    0.00793559f, 0.00044446f, 0.09501570f, 0.07510787f, -0.14162989f, 0.08857892f, 0.08668526f, -0.00316776f, 
    -0.30073094f, 0.03741061f, 0.02819736f, 0.06307579f, 0.00811937f, 0.08718806f, -0.04848371f, -0.00262405f, 
    0.07213240f, 0.06314347f, -0.00352001f, 0.08137502f, 0.00046325f, -0.02696346f, -0.04014810f, -0.05028192f, 
    -0.08176032f, 0.18156072f, 0.17454472f, 0.03123957f, -0.20624912f, 0.03524731f, 0.01436002f, -0.06670164f, 
    -0.01866543f, 0.04199453f, -0.04092439f, -0.02319496f, 0.02596345f, 0.06695365f, -0.03951697f, 0.05046142f, 
    -0.04780287f, 0.00552783f, -0.03674867f, -0.13751312f, -0.16632393f, 0.08500336f, -0.15026183f, 0.27856693f, 
    -0.13729420f, 0.13495538f, 0.00467355f, -0.03340363f, 0.08474351f, 0.01517325f, 0.00744684f, -0.02906421f, 
    0.10320359f, -0.03679702f, 0.01763914f, -0.04026705f, 0.08783774f, -0.00978197f, -0.10304812f, -0.03128108f, 
    0.02353760f, 0.11353464f, -0.09341506f, 0.10301572f, -0.10573358f, -0.03837853f, 0.02043590f, 0.01388593f, 
    0.05001045f, -0.02448039f, -0.03506261f, -0.00461050f, 0.02858697f, 0.02908910f, -0.04372196f, 0.01730927f, 
    0.01586534f, -0.06221686f, -0.00431310f, -0.05738229f, 0.10270976f, 0.16553484f, -0.15041153f, -0.20163836f, 
    -0.05402650f, -0.00727846f, -0.01217633f, 0.01961461f, -0.06994300f, 0.01557686f, 0.00627242f, 0.00202906f, 
    -0.03944254f, -0.11177183f, -0.02065138f, 0.01409416f, -0.05627664f, 0.08623248f, 0.01594503f, 0.10510103f, 
    0.03528099f, -0.05858009f, -0.02360231f, -0.04956512f, 0.06239963f, -0.00762036f, 0.03350235f, 0.03895992f, 
    -0.02980920f, -0.03329387f, -0.07126325f, 0.01311796f, -0.02310435f, -0.03731316f, 0.06432661f, -0.09380227f, 
    -0.05028345f, 0.06761056f, -0.03984033f, 0.11177298f, -0.08855316f, 0.00242249f, -0.15584312f, -0.15846851f, 
    0.16959792f, -0.10055625f, 0.01684140f, 0.02454735f, 0.03563904f, -0.02939769f, 0.01330448f, -0.04915687f, 
    -0.04248357f, 0.02314362f, 0.10487636f, -0.06633210f, 0.06500480f, 0.06345697f, -0.04899934f, 0.14411670f, 
    0.01210178f, -0.06202419f, -0.13202260f, -0.36001903f, -0.04239101f, -0.03530013f, -0.00429026f, 0.03540007f, 
    -0.06767756f, 0.04283710f, -0.05075404f, -0.03518574f, -0.18772560f, -0.05489838f, 0.00783993f, -0.04531569f, 
    0.02624295f, 0.03597629f, 0.16447939f, 0.07971225f, -0.10180215f, -0.26522881f, -0.04369475f, -0.07410433f, 
    0.12790065f, -0.01176069f, -0.01639393f, -0.01431753f, 0.12156770f, -0.02269849f, 0.01692442f, -0.03843760f, 
    -0.02486633f, 0.10803978f, 0.07211028f, -0.01191008f, 0.02584031f, -0.09632640f, -0.12869336f, -0.05078156f, 
    -0.13278221f, -0.11097766f, 0.01336518f, -0.08916879f, 0.06661087f, 0.06501663f, 0.06202443f, 0.09210922f, 
    -0.07197926f, 0.06749733f, 0.00195735f, -0.03052534f, 0.11148112f, -0.01315813f, 0.06215607f, -0.00761551f, 
    -0.01125010f, -0.09367360f, 0.03036994f, 0.07862680f, -0.02442154f, 0.06555046f, 0.00295424f, -0.29365075f, 
    0.19894877f, -0.01537752f, -0.06239192f, 0.16784666f, 0.05316104f, -0.09679747f, -0.00414938f, -0.10787136f, 
    -0.08322497f, -0.03638606f, 0.09980589f, 0.00079414f, -0.00724460f, 0.13077180f, 0.10225519f, 0.06927607f, 
    -0.09949180f, -0.25231227f, -0.06473061f, -0.19247578f, 0.19944181f, 0.14881071f, 0.13147819f, 0.15797485f, 
    -0.11618561f, -0.04008816f, -0.00179747f, -0.02069290f, 0.04171024f, 0.08589528f, -0.16349007f, 0.07298318f, 
    0.13216032f, 0.04808708f, 0.13268761f, -0.04498327f, -0.10100576f, 0.03163342f, -0.07195640f, 0.00763988f, 
    0.07170138f, 0.06503438f, 0.01624498f, -0.05360236f, -0.03379437f, -0.01921296f, -0.12765983f, -0.02945103f, 
    -0.05832014f, 0.02493789f, -0.06606410f, 0.01575614f, 0.01303693f, 0.13477901f, 0.09520973f, -0.04381515f, 
    -0.07103150f, 0.17783533f, -0.02381223f, -0.15479051f, -0.20470661f, 0.06889991f, 0.05436036f, 0.09881314f, 
    0.01483595f, 0.02867734f, -0.03270102f, 0.01752913f, -0.13934891f, -0.10578607f, -0.09017034f, 0.06861822f, 
    -0.03914611f, -0.07354769f, 0.08882220f, 0.09536299f, -0.41001192f, 0.16954593f, -0.10002542f, 0.11869837f, 
    -0.12882917f, 0.01479485f, -0.12818658f, 0.06002298f, 0.01698266f, -0.10691775f, -0.01670573f, 0.04183758f, 
    -0.05144827f, 0.03642173f, 0.00212067f, 0.05038775f, -0.03927648f, -0.10041469f, -0.09689680f, -0.01352696f, 
    -0.18068998f, -0.03487789f, 0.02695987f, 0.04252300f, 0.15244734f, -0.13245489f, 0.00269277f, -0.07713751f, 
    -0.07637391f, 0.06134633f, -0.16679835f, -0.03366856f, 0.05521012f, -0.11854514f, 0.08565260f, 0.02758270f, 
    -0.01363894f, -0.02644473f, -0.05457515f, -0.07695980f, 0.00964061f, -0.38307762f, -0.03203213f, -0.03160099f, 
    -0.03190826f, -0.11553258f, 0.04068570f, -0.02210635f, -0.06875667f, 0.04571240f, -0.01567279f, 0.08792139f, 
    0.02083026f, 0.05679790f, 0.08180616f, -0.08468542f, 0.02857530f, 0.00216927f, -0.02793334f, 0.02024449f, 
    0.12316027f, -0.03051738f, 0.10975861f, -0.14806148f, 0.15537277f, -0.00298897f, -0.03038176f, 0.08847935f, 
    -0.01529195f, 0.06960394f, -0.04763232f, -0.00806632f, -0.05290067f, -0.07968982f, -0.04839686f, 0.04026055f, 
    -0.01626821f, 0.03871843f, 0.09895949f, 0.05548827f, 0.17775255f, -0.01342995f, 0.07794877f, 0.06576859f, 
    -0.06249208f, 0.08856765f, 0.05143755f, -0.04233546f, -0.02922808f, -0.03253236f, -0.00293274f, -0.00642380f, 
    0.04791998f, 0.07512943f, 0.02752482f, 0.01498218f, 0.01437637f, 0.03245012f, -0.06101516f, -0.09623855f, 
    0.01961583f, -0.20231815f, 0.07598543f, -0.02692118f, 0.14153475f, 0.01996060f, -0.02446926f, 0.05921144f, 
    0.03667183f, -0.01699796f, 0.00671153f, -0.02519113f, 0.06588847f, 0.03250913f, -0.17325415f, 0.01683460f, 
    0.08798826f, -0.03135102f, 0.01718597f, -0.01366959f, 0.04085362f, -0.25797805f, -0.00754571f, -0.00406971f, 
    0.13552366f, 0.01878347f, 0.03144255f, 0.03296655f, 0.08597323f, -0.01247030f, -0.04415050f, -0.04192245f, 
    -0.04041579f, 0.02146030f, 0.04928404f, -0.07755377f, -0.03418707f, 0.02217007f, -0.00291165f, 0.03306334f, 
    -0.01284853f, -0.40019852f, -0.05281562f, -0.11145341f, -0.04652992f, -0.00153749f, 0.05983771f, -0.08041369f, 
    0.02624681f, -0.03547904f, -0.05131683f, 0.04691638f, 0.08082458f, 0.09165229f, 0.01941019f, 0.06270349f, 
    -0.02565248f, -0.04879260f, -0.12354032f, -0.00615526f, 0.03062585f, 0.10172811f, 0.01811189f, 0.02956250f, 
    0.15180203f, -0.01439847f, -0.03352155f, 0.06360672f, -0.01265347f, -0.13019331f, -0.12978075f, 0.08306523f, 
    -0.10161869f, -0.02078771f, 0.01006983f, -0.04009189f, -0.04333440f, 0.14107513f, 0.04849730f, -0.01125584f, 
    0.00602920f, -0.12339833f, 0.04645522f, -0.18414573f, 0.10196168f, -0.00903940f, 0.00425918f, 0.05528114f, 
    -0.07549489f, 0.03595676f, 0.06319940f, -0.04881381f, 0.03361372f, 0.09066182f, 0.02818982f, -0.04225048f, 
    0.00230263f, -0.02891744f, -0.03632957f, 0.02045823f, -0.33691710f, 0.01458828f, -0.08830818f, -0.22507469f, 
    -0.09704509f, 0.00755082f, -0.00298755f, 0.05490146f, -0.10790765f, 0.01828395f, 0.03990724f, -0.13487165f, 
    -0.05372991f, -0.01161583f, 0.02962391f, -0.06433474f, -0.06145006f, 0.04552771f, 0.16815840f, -0.07864864f, 
    0.15954131f, -0.20223470f, 0.10071578f, 0.12929532f, 0.01796569f, 0.11357360f, -0.01041980f, 0.00542051f, 
    -0.05924839f, -0.10998508f, 0.00982854f, -0.03830937f, 0.02612331f, -0.07502910f, 0.00028303f, -0.04160776f, 
    0.08257680f, 0.13785493f, 0.03998511f, -0.06588802f, 0.27222931f, -0.12737092f, -0.14630967f, 0.11596917f, 
    -0.01481081f, 0.00290004f, 0.05012377f, -0.00976893f, 0.03557527f, -0.03236871f, 0.05029695f, 0.01079067f, 
    -0.01900697f, -0.05992139f, -0.05364001f, 0.00037018f, -0.07354472f, 0.06395495f, -0.14202353f, 0.11971599f, 
    -0.04567552f, 0.08782990f, 0.12772906f, -0.06482653f, -0.27560312f, 0.07608589f, 0.03840887f, 0.07229505f, 
    0.04176152f, -0.04320260f, -0.00252250f, 0.00141442f, 0.00580028f, 0.05719628f, 0.01165031f, 0.08451045f, 
    0.00024703f, -0.07562934f, 0.00854302f, 0.02126149f, -0.01636744f, -0.19743970f, 0.00618588f, -0.26118755f, 
    0.08315018f, 0.00391032f, -0.07766015f, -0.00902301f, -0.05651504f, -0.03862085f, -0.04226336f, -0.02738639f, 
    0.12552921f, 0.03628513f, -0.01395694f, -0.02864867f, -0.02774840f, -0.05121115f, 0.00461879f, 0.06186922f, 
    0.17736426f, -0.20342091f, 0.04820740f, 0.11722636f, 0.16435778f, -0.02263065f, -0.09889117f, 0.06466825f, 
    0.01061145f, 0.04488306f, -0.02630283f, -0.01145176f, -0.00903537f, -0.05659880f, -0.09377872f, -0.00193500f, 
    -0.00457078f, 0.07199196f, 0.01619108f, 0.00229053f, -0.00655624f, 0.02714255f, 0.05986178f, -0.20076311f, 
    0.14245085f, -0.03856874f, -0.01629784f, -0.00068360f, -0.10096788f, -0.07327040f, 0.02082099f, -0.12967266f, 
    0.02819428f, -0.03877980f, -0.14188692f, 0.10369814f, 0.03487068f, 0.15903156f, 0.03860580f, 0.02600858f, 
    0.02759847f, 0.01790253f, -0.03870505f, 0.11142320f, -0.14664783f, -0.01325773f, -0.01990981f, -0.02439928f, 
    0.05231806f, 0.03693855f, -0.00201178f, -0.05531377f, 0.04512888f, 0.06491220f, 0.02701070f, -0.02758588f, 
    0.01147854f, -0.02962631f, -0.06845368f, -0.05868672f, 0.06137292f, -0.01194464f, 0.06199054f, 0.05974434f, 
    -0.05186568f, 0.00545631f, -0.11423258f, -0.02005650f, -0.01991472f, 0.13388537f, 0.03772271f, 0.04618875f, 
    -0.05184790f, -0.11694993f, -0.04022685f, -0.12896799f, -0.01834122f, -0.05638015f, -0.12191906f, -0.18725407f, 
    -0.12734805f, 0.24278480f, 0.18830581f, -0.01054295f, -0.34231654f, 0.11887079f, -0.08151319f, 0.02041632f, 
    0.03209974f, -0.01134440f, 0.05335290f, 0.04319290f, -0.11353591f, 0.00522996f, -0.13946204f, 0.00533359f, 
    -0.02205488f, -0.06943768f, 0.00205772f, -0.04137013f, 0.06076996f, -0.39200890f, -0.03732130f, -0.08598483f, 
    -0.03978990f, 0.00935787f, 0.04872305f, -0.02823166f, -0.00436742f, 0.01830691f, -0.01418392f, 0.04171550f, 
    0.03625510f, 0.07086574f, 0.03291979f, -0.01447539f, -0.00447120f, -0.01538616f, -0.03708878f, 0.06205689f, 
    -0.15075234f, 0.01836041f, -0.07579201f, 0.14335741f, -0.23345622f, -0.03991927f, 0.08274588f, 0.03619090f, 
    -0.01886917f, -0.00462550f, -0.12515289f, 0.09469295f, -0.15421680f, -0.02700761f, -0.02729407f, 0.02973376f, 
    -0.06382205f, 0.03049245f, -0.15006235f, -0.03829070f, 0.03125243f, 0.15066136f, -0.14766981f, 0.17845395f, 
    -0.10705852f, -0.07303183f, 0.02444923f, -0.00020472f, 0.04189213f, -0.12378636f, 0.00206341f, 0.02876967f, 
    0.00462321f, -0.02199172f, -0.04369025f, -0.07000829f, -0.00891211f, 0.00567814f, -0.06109640f, -0.00229274f, 
    -0.15505329f, -0.20052513f, -0.14938059f, 0.10620130f, 0.13743697f, -0.02854805f, 0.05401006f, -0.06374605f, 
    -0.02209870f, -0.00726076f, -0.01225967f, -0.00746431f, -0.00686979f, 0.01935110f, -0.23062912f, 0.13242149f, 
    -0.05473861f, 0.07120178f, -0.02375043f, 0.07242710f, -0.02747623f, -0.11300128f, -0.14981695f, -0.27484661f, 
    0.23647279f, -0.07799000f, -0.01402725f, 0.03238404f, 0.03725348f, 0.03845412f, -0.05121762f, -0.00297959f, 
    0.01010994f, -0.01940486f, 0.01543851f, -0.02535142f, 0.00801577f, 0.07611027f, -0.12302153f, 0.11732942f, 
    -0.10754204f, 0.03313515f, 0.03130945f, -0.13686739f, 0.02663178f, 0.13111445f, 0.03158863f, 0.01119510f, 
    -0.03029988f, 0.00835893f, -0.07210864f, 0.02412463f, -0.01712745f, 0.02797607f, -0.11192892f, 0.04730597f, 
    0.01975935f, 0.05920012f, 0.03620660f, -0.03743985f, 0.08671947f, -0.12446874f, -0.20471486f, 0.12011236f, 
    -0.02307520f, -0.10952364f, 0.11289040f, -0.04226812f, -0.00120608f, -0.00036662f, 0.06001757f, -0.02687215f, 
    -0.08314152f, 0.00548494f, 0.09193782f, -0.06060743f, -0.00379733f, 0.18755300f, -0.13509291f, 0.04318284f, 
    -0.29541543f, 0.03403654f, -0.07473481f, -0.18912929f, -0.09800817f, 0.00287962f, -0.05829455f, -0.03838016f, 
    0.02840804f, -0.04191252f, -0.08165203f, 0.02907561f, -0.01978086f, -0.00825494f, 0.03116102f, -0.01711665f, 
    -0.02227211f, -0.00608531f, -0.00289950f, 0.04646399f, -0.04100781f, 0.01834206f, -0.13399558f, -0.09745796f, 
    0.02265418f, -0.04659524f, -0.04091922f, -0.04876322f, -0.03428384f, -0.05582887f, -0.09052520f, 0.02122951f, 
    -0.04928622f, -0.02568578f, -0.04703377f, -0.01049114f, -0.04526539f, -0.03821860f, -0.03316896f, -0.00263797f, 
    0.16513073f, -0.16729927f, 0.09378723f, 0.00884824f, -0.06766713f, 0.08497147f, -0.06293674f, -0.03233346f, 
    -0.04846106f, 0.02510705f, -0.02399050f, -0.04115263f, 0.01656495f, -0.06633651f, -0.03109362f, -0.02997905f, 
    0.06119753f, -0.02637464f, -0.00658054f, -0.06168912f, -0.14312176f, -0.08160160f, -0.09549720f, -0.19612306f, 
    -0.21353471f, -0.07505998f, -0.03623462f, 0.00546227f, -0.04021776f, -0.04901392f, -0.00424880f, -0.04332838f, 
    0.02569152f, -0.03459449f, 0.02461600f, 0.00844955f, -0.00397876f, -0.01343380f, -0.01823039f, -0.02869168f, 
    0.05771452f, -0.05443094f, -0.00830889f, -0.04269495f, -0.01196585f, -0.04075063f, -0.03902264f, -0.02850011f, 
    -0.04895099f, -0.04323979f, 0.03052232f, 0.01081515f, -0.02260268f, 0.02085638f, -0.08100477f, -0.02008498f, 
    0.01527339f, -0.00657846f, -0.01097923f, -0.04276490f, 0.13291167f, 0.00458903f, -0.05031672f, -0.07476209f, 
    -0.02312821f, -0.03296628f, -0.02989399f, -0.05924138f, -0.03209589f, -0.05884238f, -0.00041169f, 0.00616428f, 
    -0.02836304f, 0.02014667f, -0.03811288f, -0.01902027f, -0.02045725f, -0.02867558f, 0.02617619f, 0.00061754f, 
    -0.01836056f, -0.10186468f, -0.08195996f, -0.11371975f, -0.12485008f, -0.07400150f, -0.05875786f, -0.01576912f, 
    -0.05521083f, -0.04376975f, 0.03060267f, 0.01402357f, -0.05754180f, -0.05355555f, -0.03318841f, 0.00328768f, 
    -0.02586839f, -0.00988999f, -0.05118665f, -0.02744793f, 0.11307061f, 0.17566197f, -0.10225916f, -0.02518417f, 
    0.14684679f, -0.16304706f, -0.05843674f, -0.00069664f, 0.02285235f, 0.01229367f, -0.00448907f, -0.01621823f, 
    -0.00730225f, 0.09045502f, 0.01222351f, -0.05056786f, -0.03577032f, 0.00265226f, -0.01221693f, 0.03650774f, 
    0.11513985f, -0.06294258f, 0.10064038f, 0.09994793f, -0.04287058f, 0.05366322f, -0.00651654f, -0.06261668f, 
    0.04380036f, 0.01034078f, -0.06655060f, 0.01936132f, -0.01886604f, -0.02616569f, -0.01579194f, -0.01325165f, 
    -0.00837392f, 0.00169740f, -0.01491837f, -0.03346150f, -0.18144776f, -0.02687505f, -0.17161536f, -0.00998402f, 
    0.01352816f, -0.00574990f, -0.08318118f, -0.08975069f, 0.01200967f, -0.05231621f, -0.06823478f, 0.04520331f, 
    0.03916531f, -0.03297798f, -0.01258584f, -0.00345348f, -0.00129604f, -0.01866314f, 0.03156538f, 0.04712674f, 
    -0.00272910f, 0.10553100f, 0.10525604f, 0.05076763f, 0.09215184f, -0.03025133f, 0.03572806f, -0.03835003f, 
    -0.00071803f, -0.04624110f, 0.02879056f, 0.04748613f, -0.05930770f, -0.00506011f, -0.04796932f, 0.00617486f, 
    -0.03277668f, 0.07961192f, 0.10928918f, -0.09114324f, 0.06248622f, 0.08888531f, 0.16776980f, 0.05772087f, 
    0.14727738f, 0.00395593f, 0.09193855f, -0.02754868f, 0.03041378f, 0.02331735f, -0.02428215f, 0.01758689f, 
    0.00244196f, -0.01905897f, -0.05241972f, -0.00031271f, -0.00679013f, 0.01962335f, 0.03720272f, -0.06760933f, 
    -0.15955716f, 0.02899459f, -0.27442384f, -0.02294390f, 0.03536348f, -0.02622935f, -0.03935966f, -0.09025428f, 
    -0.00865695f, -0.03099890f, -0.10991228f, 0.03555836f, 0.07111558f, -0.08355201f, -0.00991727f, -0.02964480f, 
    -0.03146206f, 0.00467600f, 0.01556943f, 0.03220084f, 0.02042565f, -0.02708660f, -0.10881953f, -0.14842930f, 
    -0.19852364f, -0.04466071f, -0.03801409f, -0.04281108f, -0.01816861f, -0.01245292f, 0.02989775f, -0.01360347f, 
    0.00688603f, 0.02548329f, -0.02132230f, 0.04125328f, 0.02664649f, -0.06686851f, 0.01773577f, 0.02281699f, 
    0.06277804f, -0.10567844f, 0.02566367f, 0.02872623f, -0.04351838f, 0.07398739f, -0.04079618f, -0.00162351f, 
    -0.02818945f, 0.01496185f, 0.00003954f, 0.00917846f, 0.02141696f, -0.02782752f, -0.00390779f, 0.00033041f, 
    0.02969923f, -0.02112569f, -0.01646442f, -0.01807313f, 0.14468695f, -0.06094508f, 0.02650997f, -0.06415122f, 
    -0.06459235f, -0.01208168f, -0.03957976f, 0.01198923f, -0.05421683f, 0.00349407f, -0.04265102f, 0.00146846f, 
    0.04344060f, -0.00687715f, 0.00261947f, -0.05180449f, 0.01719210f, -0.01918224f, 0.01533546f, -0.03051727f, 
    0.06529502f, -0.04854278f, -0.02591505f, 0.00985511f, -0.10963829f, 0.06811249f, -0.08231363f, 0.03510282f, 
    -0.06482276f, -0.00147295f, 0.01496996f, -0.02271807f, -0.02317230f, 0.00272539f, -0.01912445f, -0.00495918f, 
    0.04466613f, -0.02956485f, -0.02657409f, -0.01242917f, -0.07576307f, -0.12629701f, 0.00233506f, 0.01843383f, 
    0.03579001f, -0.12408908f, -0.01155127f, -0.06082359f, 0.10020154f, 0.03512036f, 0.03773005f, 0.06478893f, 
    -0.04733915f, 0.04154431f, 0.05072551f, -0.01390595f, -0.05931506f, 0.04443249f, -0.01772885f, -0.02172768f, 
    -0.02309869f, 0.04356684f, -0.12263142f, 0.05803683f, 0.04508433f, 0.03844585f, -0.03424407f, 0.01461888f, 
    -0.00175139f, -0.02645220f, -0.06835345f, -0.00348656f, -0.00224260f, -0.07804381f, 0.01768472f, 0.06489348f, 
    0.01017630f, 0.02531209f, 0.04566084f, -0.02222433f, -0.01917197f, 0.07587592f, 0.16173133f, 0.02049726f, 
    0.08400241f, -0.00321886f, 0.03144265f, -0.01382755f, 0.03662970f, -0.00639543f, -0.00173434f, -0.00480149f, 
    0.00379396f, -0.01326021f, -0.06402811f, -0.02413230f, -0.05037628f, -0.00181130f, 0.02065542f, -0.03299840f, 
    0.10098255f, 0.08954737f, 0.18414065f, 0.04981107f, 0.12534635f, 0.08519575f, 0.05889659f, -0.02327104f, 
    -0.01254049f, -0.03485943f, -0.00301222f, 0.04188200f, -0.08781459f, -0.00262005f, -0.01494460f, -0.02170814f, 
    0.01265977f, 0.00749234f, 0.01651094f, -0.01250725f, 0.21566163f, -0.18320599f, 0.04921020f, -0.04438445f, 
    0.10413714f, -0.09143862f, -0.00195272f, -0.04734412f, -0.00017316f, 0.00535414f, -0.01875724f, -0.05409055f, 
    -0.02794935f, 0.02981487f, -0.00480428f, -0.02006629f, 0.03599584f, 0.00093085f, 0.02998057f, 0.05027356f, 
    -0.00469953f, 0.06217907f, 0.14509006f, 0.02978978f, 0.06422635f, -0.01515603f, 0.02264234f, -0.00815701f, 
    -0.03678516f, 0.03294322f, 0.05051187f, 0.01942991f, -0.00368726f, -0.06843538f, -0.02474579f, 0.00135325f, 
    -0.08906049f, 0.01271558f, 0.08987502f, 0.00331743f, -0.13173290f, -0.21435627f, -0.20424591f, 0.05699097f, 
    -0.12021644f, -0.01551538f, -0.01037379f, 0.00795583f, -0.00845079f, -0.06138103f, -0.00357575f, -0.04051125f, 
    0.00377801f, 0.00631283f, 0.02403483f, 0.01567329f, -0.01862459f, -0.04669143f, -0.03071214f, -0.01936847f, 
    -0.06910076f, -0.24559323f, -0.13088591f, -0.10562234f, -0.10623942f, -0.03843982f, -0.03650640f, -0.01936618f, 
    -0.02947661f, -0.03990204f, -0.01761591f, -0.02586697f, -0.04079110f, -0.01878720f, -0.00303003f, -0.01324534f, 
    0.06311931f, -0.03101356f, -0.01815423f, 0.01014662f, -0.27368152f, 0.11221503f, 0.07577167f, -0.01620844f, 
    -0.06653374f, -0.00023013f, -0.03835516f, -0.00980994f, 0.01369670f, -0.11047336f, 0.04832835f, 0.02847068f, 
    0.00087483f, 0.01560689f, -0.03693355f, 0.04510908f, -0.01117669f, 0.02335069f, 0.00355985f, -0.06882714f, 
    -0.10926194f, -0.04794833f, -0.04051946f, -0.06015971f, -0.12999676f, 0.07149451f, -0.02979433f, 0.00753702f, 
    0.03983823f, -0.01507380f, -0.03049643f, -0.03303900f, -0.05406043f, -0.02008561f, 0.02905588f, -0.03575491f, 
    -0.00396896f, -0.02899627f, -0.00023828f, -0.00302236f, 0.10010345f, 0.03100601f, 0.05239132f, 0.04445214f, 
    0.15981111f, -0.03841015f, 0.01247857f, -0.02114249f, -0.02419718f, 0.01107106f, -0.05715760f, 0.00543613f, 
    -0.04150119f, -0.02737792f, -0.02553299f, -0.00450770f, -0.02937977f, 0.02512073f, -0.02849682f, -0.03150067f, 
    0.00894075f, 0.02880336f, 0.05440072f, 0.03893195f, 0.16198958f, -0.00699080f, 0.02869388f, -0.04160176f, 
    -0.00047977f, -0.05390466f, -0.02207759f, -0.00507780f, -0.01617509f, -0.03792102f, -0.01888795f, -0.01293315f, 
    -0.05080832f, 0.02048150f, 0.01091919f, -0.00445195f, 0.03990589f, 0.03780129f, -0.02746245f, 0.07592360f, 
    0.04031774f, -0.06029358f, 0.04421913f, -0.03590629f, -0.04109039f, -0.04050439f, -0.07239530f, 0.01494701f, 
    -0.05114481f, -0.01212938f, -0.08082457f, -0.03289415f, -0.03730026f, -0.02963117f, -0.04242118f, 0.01954357f, 
    0.14047143f, 0.02326217f, 0.08840264f, 0.03834489f, 0.22742790f, 0.03944091f, -0.00494994f, -0.01376316f, 
    -0.08171488f, -0.06917080f, -0.01527172f, 0.10289065f, -0.06727422f, 0.00076002f, -0.06998398f, -0.04237625f, 
    -0.01596358f, -0.01979715f, 0.01244092f, 0.05100819f, 0.02062702f, -0.07504616f, 0.12792256f, -0.04131123f, 
    -0.01912401f, -0.11056057f, 0.05214778f, -0.04133883f, -0.02600159f, 0.03836458f, 0.05188714f, 0.05240659f, 
    0.00241687f, 0.00240344f, 0.05670821f, -0.02863671f, 0.01488325f, 0.02892293f, -0.02853769f, -0.00764094f, 
    0.19906999f, -0.08811162f, 0.17682235f, -0.02675990f, 0.02805268f, -0.02246071f, 0.01380656f, 0.00875287f, 
    -0.03144358f, -0.01314275f, -0.00855525f, 0.05546182f, 0.01564030f, 0.04343529f, -0.07071179f, -0.00217196f, 
    -0.03193745f, 0.01003396f, 0.03574829f, -0.03940338f, 0.07978523f, 0.04399704f, 0.12754171f, 0.20431443f, 
    0.13730663f, 0.00198956f, 0.11232636f, -0.03709190f, 0.06198861f, -0.01003045f, -0.04725442f, -0.00802881f, 
    -0.03176817f, -0.00686728f, 0.02302427f, -0.00597390f, -0.00245068f, 0.07917105f, -0.03606663f, -0.04760409f, 
    0.02020908f, 0.17586803f, 0.04461651f, 0.05808447f, 0.11238307f, -0.02210985f, 0.07117493f, -0.02427602f, 
    0.04740100f, 0.04782446f, -0.09816017f, -0.03478699f, 0.01047153f, -0.00665496f, -0.00808266f, -0.01493783f, 
    -0.00821005f, 0.08412775f, -0.02283661f, 0.01124566f, 0.03112188f, 0.02165332f, -0.02877370f, 0.00499869f, 
    0.10096699f, 0.04211236f, -0.03982897f, -0.09377825f, 0.03196051f, -0.02732703f, -0.00301160f, 0.03289288f, 
    -0.00185153f, -0.01508177f, -0.07557375f, -0.06990570f, -0.02948118f, 0.08554843f, 0.01864376f, -0.01530750f, 
    -0.00985478f, -0.04440223f, -0.04311735f, -0.00178466f, 0.12096895f, -0.02647743f, -0.15885773f, -0.03958361f, 
    -0.02474691f, -0.03885701f, -0.06910346f, 0.09628091f, -0.00003438f, 0.01028437f, -0.05292998f, -0.03899962f, 
    -0.03416345f, -0.02433146f, -0.01142088f, 0.03306615f, -0.00225848f, -0.11957686f, -0.03500224f, -0.04129938f, 
    -0.15143731f, -0.00266915f, -0.07751769f, -0.02460725f, -0.02399400f, 0.02089188f, -0.01317879f, 0.01977907f, 
    -0.02583694f, -0.00609520f, -0.03268382f, 0.03496828f, 0.00912018f, -0.03577738f, -0.06396449f, 0.01857168f, 
    -0.16128330f, -0.00951422f, -0.10235929f, -0.04503501f, -0.02786934f, -0.02123975f, -0.02407837f, -0.02582174f, 
    -0.03058432f, -0.02694851f, 0.00044327f, 0.02428837f, -0.04429175f, -0.06469839f, -0.01135119f, 0.00025720f, 
    0.01965536f, -0.04687074f, -0.01541591f, -0.04370409f, -0.10560515f, 0.06987159f, 0.16230577f, 0.02521078f, 
    0.02067355f, 0.03326307f, 0.02890842f, -0.03832512f, 0.07956795f, 0.00605326f, -0.03365671f, -0.00137094f, 
    0.09204719f, -0.00842828f, -0.00400979f, 0.03302477f, -0.03866124f, 0.01569062f, 0.03038138f, -0.00192223f, 
    0.06585129f, -0.16309276f, 0.15376793f, 0.04701693f, -0.11172378f, 0.07987306f, -0.00572334f, -0.02745545f, 
    -0.03111934f, -0.01523799f, -0.01420895f, -0.03860657f, -0.08782994f, -0.00950445f, -0.04675633f, 0.01216079f, 
    0.05071289f, 0.00542456f, -0.01016864f, -0.03441292f, 0.16095226f, -0.30901173f, 0.01093448f, -0.02174010f, 
    -0.01451535f, -0.01407862f, -0.02228973f, 0.00463671f, 0.00709818f, 0.02611785f, -0.00387792f, -0.06441622f, 
    -0.05450615f, 0.00997671f, -0.03545453f, -0.06505244f, 0.04899199f, 0.00570448f, -0.01222660f, 0.00962329f, 
    0.02864661f, 0.15714759f, 0.05534142f, -0.03971019f, 0.13234109f, -0.04862808f, 0.14853030f, -0.03245543f, 
    -0.02240243f, 0.05886831f, -0.01891667f, 0.01878142f, -0.05402848f, -0.06365269f, 0.00482980f, -0.00762985f, 
    -0.00694840f, 0.02707155f, -0.03083633f, 0.03078207f, -0.06492452f, -0.05875206f, 0.01393500f, -0.02682661f, 
    -0.01001771f, -0.12568331f, 0.03042742f, -0.01579625f, 0.01408079f, 0.03049590f, 0.06142091f, 0.01960448f, 
    -0.06493445f, -0.03036414f, -0.01229762f, -0.05495514f, -0.00415704f, 0.07619470f, -0.04216100f, -0.04773914f, 
    0.06904096f, 0.11063766f, 0.20689110f, 0.06008033f, 0.03580024f, 0.03377684f, 0.02505011f, -0.03526513f, 
    0.07443506f, -0.04395428f, -0.01642306f, 0.00213274f, 0.04085528f, 0.01605569f, -0.02985104f, -0.01695300f, 
    -0.00727618f, 0.04424870f, -0.01912621f, -0.01699595f, -0.07959890f, 0.14053731f, -0.20835260f, -0.03081520f, 
    0.09950078f, 0.02323599f, -0.06855773f, -0.06337810f, 0.06245831f, 0.00090768f, -0.12913330f, 0.00281048f, 
    -0.03924482f, 0.01468566f, 0.00032369f, -0.01670363f, -0.06513979f, -0.00316158f, -0.03661997f, 0.01619746f, 
    0.11549992f, -0.04364413f, 0.14828943f, 0.00067622f, 0.04273283f, 0.00656044f, 0.04898857f, -0.03976306f, 
    -0.05835557f, -0.05705450f, -0.01740748f, 0.04733578f, -0.05216780f, 0.01796287f, -0.03949778f, -0.03957208f, 
    0.00275041f, 0.04592082f, 0.03587301f, -0.00347271f, 0.14863437f, -0.02470046f, 0.16315909f, 0.08753942f, 
    0.14040267f, 0.00353632f, -0.00248223f, -0.02107567f, -0.05889213f, -0.00240462f, -0.01714342f, 0.06674562f, 
    -0.04855729f, -0.02979344f, -0.03551716f, -0.02698087f, 0.07965958f, 0.00016543f, 0.05808137f, -0.05424739f, 
    0.28273535f, -0.12672246f, 0.14492914f, 0.05841755f, -0.06125049f, 0.04440597f, -0.01419782f, -0.00864267f, 
    -0.00443735f, 0.01701971f, -0.04894564f, -0.00980607f, 0.02030340f, 0.01842866f, -0.02347915f, 0.00653528f, 
    0.04968264f, 0.02055106f, 0.04930272f, 0.00466195f, 0.03937499f, 0.10890501f, 0.13326459f, 0.01393544f, 
    0.13151006f, 0.02764473f, 0.08153561f, -0.05558555f, -0.00814488f, -0.01273839f, 0.01669011f, 0.01155670f, 
    -0.04248545f, -0.00221800f, 0.02024464f, 0.00603329f, -0.00455188f, -0.00896608f, 0.00549774f, 0.00590837f, 
    0.00688384f, -0.08473568f, -0.05681245f, -0.02307502f, 0.01561925f, -0.01974660f, -0.11469039f, -0.00975948f, 
    -0.00370107f, -0.03947118f, -0.00517610f, 0.02552180f, -0.00773030f, -0.00975742f, -0.00673491f, 0.02656215f, 
    -0.10496320f, -0.02314441f, -0.01721867f, -0.05084040f, 0.07951079f, 0.04014201f, 0.18280995f, 0.07630006f, 
    0.10249601f, 0.07315121f, 0.03282724f, -0.02144954f, 0.02181225f, -0.00896897f, -0.01446873f, 0.06113686f, 
    0.05714874f, -0.02763931f, -0.04197875f, -0.01660396f, -0.00435922f, -0.02849652f, 0.05460257f, -0.05493413f, 
    0.08251657f, -0.21516736f, 0.13331200f, 0.12431151f, -0.18710610f, 0.17808953f, -0.04340117f, 0.02542158f, 
    -0.06338497f, 0.03122823f, -0.03355690f, -0.00419891f, -0.02487558f, -0.03354350f, -0.03711571f, 0.01285649f, 
    0.03558354f, 0.00359907f, -0.05733531f, -0.06772474f, 0.08247966f, 0.10761071f, 0.11763722f, -0.05648261f, 
    0.17576756f, -0.07818190f, 0.08275557f, -0.02846323f, 0.00617203f, -0.00334096f, -0.02613650f, 0.03999182f, 
    -0.09447853f, 0.00926779f, -0.02314098f, -0.01492362f, -0.00166312f, 0.07334085f, -0.01876836f, -0.03870347f, 
    0.01718356f, -0.05346529f, -0.02881297f, -0.11898972f, -0.10012863f, -0.05724942f, -0.01345364f, -0.03079673f, 
    -0.05663066f, -0.08588485f, 0.02263614f, -0.01082650f, -0.04202288f, 0.04600488f, -0.02202887f, 0.00697681f, 
    -0.03784147f, 0.00099937f, -0.04940464f, -0.06265154f, 0.16029397f, -0.18902436f, 0.06283695f, -0.07268921f, 
    -0.05261882f, 0.03687827f, -0.00416851f, -0.02113727f, -0.03224305f, -0.03404341f, 0.05278222f, -0.02313674f, 
    -0.03287834f, 0.02291108f, -0.07521504f, 0.01974892f, 0.13109386f, -0.01934077f, 0.01374434f, 0.00277071f, 
    -0.03021080f, -0.38255271f, -0.00804988f, -0.14951256f, -0.14159511f, -0.01209107f, -0.04782973f, -0.00321109f, 
    -0.04853519f, -0.06206147f, -0.00945790f, -0.04381033f, -0.08051582f, -0.02035071f, -0.04720728f, -0.03995503f, 
    0.06577978f, 0.00191365f, 0.01235598f, 0.00092981f, -0.03263792f, -0.00007633f, 0.10543226f, 0.09911640f, 
    0.15292324f, 0.02891375f, 0.05315334f, -0.00182053f, -0.00537404f, -0.03812946f, -0.01174420f, -0.01081636f, 
    -0.00323159f, -0.03308740f, -0.02078328f, -0.04516877f, -0.00870206f, -0.02519541f, -0.01556058f, -0.03964707f, 
    -0.10282212f, 0.17898898f, 0.07157151f, -0.08033350f, -0.07310689f, -0.05304313f, -0.08320437f, 0.00633584f, 
    0.00663303f, -0.01210987f, 0.02673879f, 0.06778856f, 0.00955330f, 0.02530736f, -0.08934034f, -0.03044007f, 
    0.01937552f, 0.02554107f, -0.04430811f, 0.06814547f, -0.18021025f, 0.04853218f, -0.03192369f, -0.06810732f, 
    -0.05690143f, 0.04898404f, -0.03301163f, 0.03113837f, 0.02106477f, -0.01356680f, -0.08140060f, 0.02757710f, 
    -0.04115333f, -0.03524536f, 0.06018624f, 0.01741535f, -0.00672735f, -0.01894589f, 0.01862701f, 0.02068573f, 
    -0.06792203f, 0.17316988f, -0.02992989f, -0.02686357f, 0.06625853f, -0.03296170f, 0.07004476f, 0.02003403f, 
    -0.04264607f, -0.01615861f, -0.07482831f, 0.02062497f, -0.03893958f, -0.07354395f, -0.06897148f, -0.01587146f, 
    -0.03016755f, 0.03408485f, -0.01822362f, -0.02450283f, -0.05262629f, 0.09616918f, 0.02183351f, 0.05567579f, 
    0.08220693f, -0.07915313f, 0.02400430f, -0.02392722f, -0.02669493f, 0.01234418f, -0.09698165f, 0.06028559f, 
    -0.05352970f, -0.01331326f, -0.04541547f, -0.01466647f, -0.01180523f, -0.00440406f, 0.00580488f, -0.00382045f, 
    0.05955829f, -0.16358776f, 0.03455231f, 0.02918646f, -0.00344054f, 0.02577299f, -0.06378747f, -0.06252542f, 
    0.00064822f, 0.00445021f, -0.06039696f, 0.04454048f, 0.05890453f, -0.00631915f, -0.02111745f, 0.00608008f, 
    0.05219484f, 0.01322831f, 0.03898354f, 0.00548624f, -0.00876667f, 0.15642704f, -0.06398175f, 0.00989742f, 
    0.06404904f, -0.12245064f, 0.01055068f, -0.02885401f, -0.00755336f, -0.03900885f, -0.02637591f, 0.06386638f, 
    0.00951662f, -0.03845131f, -0.09002029f, 0.01330704f, -0.00464096f, 0.05363420f, 0.02674383f, -0.05495455f, 
    0.05616477f, 0.07993148f, -0.05012119f, 0.02661835f, 0.02013656f, 0.05832229f, 0.06367474f, -0.05030946f, 
    0.00128076f, -0.07518277f, 0.03087589f, 0.01130324f, 0.04828601f, 0.02651878f, -0.02077598f, -0.01533717f, 
    0.03810390f, 0.00828092f, 0.06250533f, -0.07204553f, 0.00235059f, 0.15483460f, 0.06383048f, 0.08336509f, 
    -0.00023821f, 0.03537588f, 0.01812022f, -0.05770902f, -0.04580468f, -0.06438706f, 0.07961877f, 0.01348571f, 
    0.01511579f, -0.00098726f, -0.06669366f, -0.05695920f, 0.00080091f, 0.02978970f, 0.04035698f, -0.10057288f, 
    -0.15982626f, -0.03078508f, -0.02213349f, -0.00535232f, -0.05205484f, 0.02597415f, -0.03918146f, -0.03322358f, 
    -0.11281701f, -0.02542177f, 0.02137618f, 0.02312877f, -0.03231529f, 0.07848208f, -0.00874519f, -0.00874226f, 
    -0.02060548f, -0.04887233f, -0.08877124f, 0.11548608f, 0.06600219f, -0.04067257f, -0.08683184f, 0.10958426f, 
    0.11364780f, 0.03987223f, 0.04283480f, -0.11167819f, -0.04559296f, -0.04403570f, 0.00398790f, -0.01831559f, 
    0.02525993f, -0.01613042f, 0.05944133f, -0.08004649f, 0.00701228f, 0.03142624f, 0.07820469f, -0.03364086f, 
    0.06023055f, -0.08451080f, 0.04691246f, 0.09280565f, 0.08962107f, -0.07990018f, -0.02128959f, -0.01843381f, 
    -0.05103479f, 0.03097813f, -0.00128053f, -0.02863686f, -0.02620613f, -0.02714689f, -0.00660093f, 0.07348203f, 
    -0.01854478f, 0.00473256f, 0.01433371f, 0.03184104f, 0.12814474f, 0.07511267f, -0.05216385f, 0.04177023f, 
    0.10382394f, -0.01461995f, -0.03052939f, -0.11251187f, -0.01125637f, -0.03719840f, 0.00207060f, -0.02602377f, 
    0.00854062f, -0.06149775f, 0.02251067f, -0.00013995f, -0.02576170f, -0.00542060f, 0.06061621f, 0.02634170f, 
    0.14101739f, 0.11084688f, -0.03180320f, 0.02789075f, 0.06735617f, 0.00658475f, -0.01193542f, -0.02156778f, 
    0.00670777f, -0.03183879f, -0.04223866f, 0.01450905f, -0.04308848f, -0.03948898f, 0.01337751f, -0.08250976f, 
    -0.04985035f, 0.05859171f, 0.01680459f, -0.01955526f, -0.04982325f, -0.07467724f, 0.02151966f, -0.18721531f, 
    -0.07555936f, 0.07510000f, -0.00223668f, -0.05618512f, -0.06498217f, -0.11931281f, 0.09707399f, 0.04962622f, 
    0.04109437f, 0.06444243f, -0.00676145f, 0.04479967f, 0.09613781f, 0.06167769f, -0.05209732f, 0.04786176f, 
    -0.12631249f, -0.02766633f, -0.23501018f, 0.01081020f, -0.02333298f, 0.02307702f, -0.06669569f, -0.03223061f, 
    -0.13965526f, 0.03179140f, 0.04760683f, -0.03480640f, -0.03417250f, 0.02669444f, 0.04917661f, 0.03252720f, 
    -0.01563825f, -0.06144930f, 0.06663708f, -0.01902798f, -0.01774410f, -0.07521220f, -0.18186967f, -0.09183822f, 
    0.02658529f, 0.06542344f, -0.01764813f, -0.05506886f, 0.04193296f, -0.00230948f, 0.04315849f, -0.02107835f, 
    0.04840135f, -0.00248251f, 0.03886459f, 0.00915082f, 0.05513330f, 0.03620785f, 0.05279219f, -0.00366761f, 
    -0.05541181f, -0.02180399f, 0.02136544f, -0.12420565f, -0.16271870f, -0.12943514f, -0.02043408f, -0.01365787f, 
    -0.00924477f, -0.07655010f, -0.00573197f, 0.05887600f, 0.06883268f, 0.02364222f, 0.01143018f, 0.04363747f, 
    -0.04149606f, -0.16502318f, -0.05804452f, -0.00975342f, -0.14934459f, -0.02075766f, 0.09034476f, 0.03506579f, 
    0.07898155f, -0.02466478f, 0.00038352f, 0.07582942f, -0.07809278f, 0.03431712f, 0.06031642f, -0.00793744f, 
    -0.10091073f, 0.02452278f, 0.07299889f, 0.02169890f, 0.01143601f, -0.04548948f, 0.06899667f, -0.03606836f, 
    -0.01442589f, -0.02915688f, -0.11689227f, -0.09025723f, 0.01915573f, 0.05485611f, 0.01311831f, -0.01884824f, 
    -0.04271067f, -0.05880101f, 0.10149603f, 0.02664303f, 0.06294462f, 0.06145163f, -0.02066450f, -0.03228405f, 
    0.09092313f, 0.10080767f, -0.00600983f, 0.01814393f, 0.03089646f, 0.04119572f, -0.14527272f, 0.06243999f, 
    0.07044212f, 0.01947676f, 0.07396572f, -0.14981905f, -0.00292198f, 0.00654429f, -0.03163688f, 0.04580178f, 
    -0.09823569f, -0.02000961f, 0.05551307f, -0.10583624f, -0.00497695f, -0.02031156f, 0.10337313f, -0.07951902f, 
    0.05411789f, -0.00452639f, 0.06311796f, 0.01352828f, 0.10197974f, -0.05711606f, -0.05597519f, -0.05487024f, 
    -0.02740364f, 0.05576569f, -0.08332896f, -0.02164652f, -0.00273279f, -0.10387876f, 0.00705203f, -0.01699330f, 
    0.02908648f, 0.01728646f, 0.07632580f, -0.00386728f, -0.00095839f, 0.04310820f, -0.15293996f, -0.00234726f, 
    0.00662002f, 0.06480674f, 0.01148188f, 0.01892691f, -0.06947764f, 0.04350759f, 0.02507055f, -0.00764101f, 
    -0.06240700f, 0.11343071f, -0.00881267f, 0.01488566f, 0.00567946f, -0.05544516f, -0.04999011f, 0.01905158f, 
    0.04551564f, 0.01970545f, 0.05027865f, -0.01599358f, 0.10172444f, -0.01613964f, -0.03400313f, -0.05559924f, 
    -0.00599432f, 0.03232108f, -0.00255315f, -0.05582233f, 0.03992402f, -0.02582013f, -0.05769121f, 0.04174393f, 
    -0.01996613f, 0.01597839f, -0.03514406f, 0.05306164f, -0.00805016f, 0.18935910f, 0.00499928f, 0.03748922f, 
    0.10592028f, -0.06238849f, -0.09028222f, -0.06060850f, -0.08190976f, -0.05937506f, 0.13366848f, -0.05643211f, 
    -0.03448778f, 0.01776175f, 0.06822931f, -0.00438603f, 0.04909557f, 0.05837090f, 0.01755363f, -0.09625483f, 
    0.01395505f, -0.09506930f, 0.00215444f, -0.14015858f, -0.12905441f, 0.03476376f, -0.05541999f, 0.04697558f, 
    0.02042650f, -0.01436014f, 0.10025754f, -0.03675150f, 0.04387685f, -0.05473091f, 0.05725113f, -0.00819002f, 
    -0.04452166f, 0.00259795f, -0.02780521f, 0.01741922f, -0.04353930f, 0.00543009f, 0.10215796f, 0.00544241f, 
    0.01003403f, -0.05288363f, -0.04399464f, 0.01853844f, -0.02015748f, -0.05054307f, 0.02636741f, -0.01637669f, 
    -0.05276778f, -0.00335321f, 0.05323577f, 0.04324965f, -0.02280397f, -0.06644253f, 0.00516666f, -0.02910148f, 
    -0.26386067f, -0.02128814f, 0.18038817f, -0.07326516f, 0.02464377f, -0.00490241f, 0.03014135f, 0.00389423f, 
    -0.05803043f, -0.08025495f, -0.01338695f, -0.02318375f, -0.02866928f, 0.00459861f, 0.05167247f, 0.01263033f, 
    -0.00529229f, 0.00975758f, -0.04358093f, -0.00211662f, 0.00714904f, -0.14999448f, -0.11515232f, -0.14435624f, 
    -0.01294981f, 0.04486269f, 0.02022464f, 0.01916146f, -0.09990069f, -0.05336916f, -0.05884948f, 0.07349039f, 
    0.02112485f, 0.00138675f, 0.03608938f, 0.02719465f, 0.01608552f, -0.00859326f, -0.09091496f, 0.06994972f, 
    -0.14690696f, -0.03867762f, 0.13322556f, -0.15871643f, -0.11455952f, 0.04855029f, 0.02317888f, -0.00715177f, 
    -0.02814445f, -0.03675884f, 0.00114833f, 0.07396687f, 0.04960290f, 0.09597447f, -0.01104663f, -0.02155256f, 
    -0.00939336f, 0.01379109f, -0.16328208f, -0.00610417f, 0.14596426f, 0.01598860f, -0.24814731f, 0.04926863f, 
    0.07135824f, 0.03896302f, -0.01755587f, 0.01402761f, -0.04570251f, 0.00260507f, -0.03576064f, -0.03444036f, 
    0.00611871f, 0.05920105f, -0.02397382f, -0.02023234f, -0.04086161f, -0.02121047f, 0.05134911f, -0.06817821f, 
    0.07652761f, -0.16255054f, -0.16358805f, 0.08703068f, 0.12646702f, 0.04837715f, 0.08389862f, -0.00147807f, 
    -0.02182498f, -0.02193992f, -0.08587887f, 0.01943095f, 0.03026680f, 0.02417090f, -0.00800348f, -0.00115834f, 
    0.00607346f, 0.07011807f, 0.06923597f, -0.00751561f, 0.00764827f, 0.15099514f, -0.20805757f, 0.04281804f, 
    0.01450322f, 0.06145960f, -0.02092150f, -0.08378347f, -0.02487576f, -0.00022142f, -0.03077433f, -0.02720050f, 
    0.00090475f, 0.02516496f, 0.05542354f, 0.03054869f, -0.02770570f, -0.01520947f, 0.04700974f, -0.03317571f, 
    0.07301232f, 0.10893473f, -0.00798575f, -0.03950061f, 0.01736335f, 0.04070223f, -0.01849079f, -0.08010424f, 
    0.05460203f, -0.05604599f, 0.06577457f, 0.00635923f, 0.03829832f, 0.00535375f, -0.03719389f, 0.00421487f, 
    -0.03072180f, 0.01555885f, 0.01341747f, -0.01840242f, -0.14542420f, -0.07667968f, 0.05142228f, -0.24180992f, 
    -0.14247105f, -0.00108648f, 0.00609276f, -0.04338664f, -0.03731718f, 0.01038074f, -0.01815446f, 0.02923979f, 
    -0.04532212f, 0.01219017f, -0.03977337f, -0.07274967f, 0.01681524f, 0.00125049f, -0.19875015f, -0.04084332f, 
    -0.15279077f, -0.00517387f, 0.14332850f, 0.04766719f, 0.06290147f, -0.07709913f, 0.00238740f, -0.03030677f, 
    0.00477825f, 0.01478223f, 0.00179346f, 0.03092449f, -0.03883204f, 0.03067888f, 0.00622563f, -0.00575867f, 
    -0.00606174f, -0.05886728f, 0.00915339f, -0.01284529f, -0.04731381f, 0.04016633f, 0.11662036f, -0.09186776f, 
    -0.08112212f, -0.07146704f, -0.00435725f, -0.02402380f, -0.05141153f, -0.04660356f, 0.05310381f, 0.02439630f, 
    0.00797208f, -0.00487860f, -0.04630410f, -0.11156107f, -0.03305384f, -0.10412664f, -0.00667207f, -0.13097124f, 
    -0.11209838f, -0.15272391f, -0.05622737f, -0.45272174f, -0.20099236f, 0.02930152f, -0.01386944f, 0.01574848f, 
    0.00000715f, -0.04964535f, 0.03837289f, 0.07045200f, -0.01402687f, -0.02134005f, -0.07180358f, -0.08238783f, 
    0.03209127f, 0.06575610f, -0.25842294f, -0.11777810f, 0.09756514f, 0.12641653f, 0.00898900f, -0.03348311f, 
    0.06309249f, -0.07422863f, -0.08631692f, 0.02862406f, 0.01237804f, -0.06948240f, 0.00716016f, 0.00112740f, 
    -0.13159886f, -0.06136233f, 0.10054119f, 0.03417469f, -0.01024598f, 0.05849692f, 0.04124992f, -0.03922034f, 
    -0.02147646f, -0.01587344f, 0.10846489f, 0.02471492f, 0.11604213f, -0.09314954f, -0.03759678f, 0.03069602f, 
    -0.03968978f, 0.01529303f, -0.02832325f, 0.02062413f, -0.04400365f, 0.06244182f, 0.04002393f, 0.03989708f, 
    0.00803978f, 0.05284635f, -0.00755984f, 0.07484757f, -0.17054036f, 0.06076401f, -0.01857387f, -0.27655810f, 
    -0.14209296f, -0.05557949f, -0.00276269f, -0.05842348f, -0.02922275f, -0.08373907f, 0.03866340f, 0.06857729f, 
    -0.02198965f, 0.07174933f, 0.01881790f, -0.08464530f, 0.01663604f, -0.04177972f, -0.04519733f, 0.01379440f, 
    -0.24346182f, 0.11555436f, 0.04199072f, -0.20387271f, -0.30765989f, -0.02180219f, 0.05804113f, -0.03810886f, 
    0.03694953f, -0.14085488f, 0.12339353f, -0.04289612f, 0.00596680f, 0.02690065f, 0.01518752f, -0.11616545f, 
    -0.00415724f, -0.06492877f, 0.01517246f, -0.02916883f, -0.15301692f, 0.09666835f, -0.16504724f, -0.20856705f, 
    -0.24675578f, -0.05006648f, -0.09177969f, -0.06911872f, 0.04766072f, -0.02107393f, 0.06763564f, 0.01527614f, 
    0.07913981f, -0.00849819f, 0.00774024f, 0.05612623f, -0.00129622f, -0.18046714f, -0.09487779f, 0.06098101f, 
    -0.20031813f, -0.17548954f, 0.03093086f, -0.17743284f, 0.10651173f, 0.04392319f, 0.06720286f, -0.05438976f, 
    -0.03207298f, -0.09661394f, 0.09048682f, 0.06207827f, 0.04197216f, 0.01283639f, 0.03848962f, -0.01145347f, 
    0.09422655f, 0.08716281f, -0.04733667f, -0.14290294f, 0.10735810f, 0.08159380f, -0.15219314f, 0.08887398f, 
    0.03820894f, 0.04342360f, 0.04946604f, -0.08726332f, -0.01894938f, -0.03346734f, -0.07239410f, 0.03686650f, 
    -0.00859693f, -0.10036623f, 0.00501862f, 0.01089806f, -0.05651532f, 0.03522941f, 0.04186014f, -0.06587955f, 
    0.11263209f, 0.05271571f, 0.02925884f, 0.08480664f, 0.04715667f, 0.02856696f, 0.00914437f, -0.05023362f, 
    -0.07309607f, -0.03729946f, 0.04238715f, 0.04714697f, 0.05931330f, 0.01591472f, -0.04228535f, -0.09236167f, 
    0.00237782f, 0.00787397f, 0.08572954f, 0.03609092f, 0.05141804f, -0.06074103f, 0.07922153f, 0.04786408f, 
    0.14342222f, -0.06396769f, -0.05291205f, -0.01424804f, -0.02020114f, 0.09681692f, -0.07562277f, -0.05295740f, 
    -0.01963866f, 0.02218330f, 0.02967532f, -0.02776943f, 0.03121867f, -0.00548494f, 0.00867821f, 0.00805925f, 
    -0.11277665f, -0.00103146f, 0.06071084f, -0.02817872f, 0.05225318f, 0.03783357f, -0.04610548f, -0.08979604f, 
    -0.00884520f, -0.01198558f, -0.01080101f, 0.03259174f, 0.04195536f, -0.06767981f, 0.05624147f, -0.04771564f, 
    0.02142636f, 0.00171302f, 0.01989548f, -0.05656232f, 0.09350669f, -0.08386887f, -0.05377395f, -0.03102922f, 
    0.04275449f, 0.03758835f, 0.04496479f, 0.00815237f, -0.02600706f, -0.06160346f, 0.00756632f, 0.08290014f, 
    0.00925278f, 0.04075131f, -0.01141622f, 0.06318189f, -0.00308711f, 0.00009186f, 0.00431487f, 0.01644743f, 
    -0.16162385f, 0.18357456f, -0.10013526f, -0.11208469f, -0.15819411f, -0.04347768f, -0.00552724f, -0.05197114f, 
    0.02947019f, -0.05224644f, 0.12106868f, 0.01367159f, -0.03450147f, 0.07746428f, 0.05117248f, -0.06298155f, 
    -0.01707013f, -0.09730960f, 0.06660010f, 0.04874079f, 0.10246035f, 0.10418186f, -0.05646864f, 0.00747847f, 
    0.02174600f, -0.05049903f, 0.01784352f, 0.05516297f, -0.04322748f, -0.02785745f, 0.03244779f, 0.00397351f, 
    -0.04106219f, 0.02963130f, 0.04121071f, -0.02824154f, 0.00361649f, -0.05452436f, 0.06837194f, -0.02149523f, 
    0.04889702f, -0.01413454f, 0.04083791f, 0.03777920f, 0.09960467f, -0.07126125f, -0.02347540f, 0.05703818f, 
    -0.00942800f, 0.04564111f, -0.00105030f, -0.03672283f, -0.14062449f, -0.04969604f, 0.10487811f, 0.03991853f, 
    0.01163615f, -0.02220557f, 0.07750195f, -0.01210177f, -0.01280283f, 0.08357929f, -0.03605451f, -0.09634290f, 
    0.02799741f, 0.01654408f, 0.00456795f, -0.03034825f, -0.02316169f, -0.03771389f, 0.04586437f, 0.01199925f, 
    -0.03104087f, 0.04866678f, -0.07352621f, -0.00216780f, 0.06589131f, 0.03373500f, -0.03715975f, -0.02602915f, 
    -0.10339411f, 0.01506758f, 0.14983134f, 0.03499273f, 0.10204715f, -0.05258683f, 0.04085097f, -0.00461569f, 
    0.00250679f, 0.01464685f, 0.06532478f, -0.04493994f, 0.00512169f, 0.01931291f, 0.01550015f, 0.00101678f, 
    0.00924049f, -0.01430861f, 0.03221842f, 0.04805864f, -0.22377704f, -0.10990858f, 0.16673967f, -0.08531649f, 
    -0.00468000f, -0.03347115f, 0.02370008f, 0.06593594f, -0.01291077f, -0.12940487f, 0.02293314f, -0.03774679f, 
    0.10859399f, 0.09751558f, 0.04718620f, 0.00620206f, 0.03964041f, 0.07922839f, -0.27770799f, 0.02212809f, 
    0.00431780f, -0.08796093f, -0.06726600f, 0.00010121f, -0.02194264f, -0.09324592f, 0.03305223f, 0.01033466f, 
    -0.02768087f, -0.03667026f, 0.03270629f, 0.03799861f, 0.03391216f, 0.07735549f, 0.02880784f, 0.08746119f, 
    0.00703179f, -0.10407019f, 0.04094091f, 0.04439434f, -0.03516579f, -0.21114914f, 0.11345061f, -0.05110428f, 
    -0.06715063f, -0.01236676f, -0.03893432f, 0.03738042f, -0.02641620f, 0.00183477f, 0.01669333f, 0.03087725f, 
    0.02473547f, 0.01291186f, 0.04604446f, -0.03587816f, -0.04466793f, -0.06407299f, 0.03257344f, 0.00050586f, 
    -0.00667120f, -0.05195798f, -0.16373938f, 0.10901800f, -0.00598964f, 0.05928009f, 0.03261935f, -0.01198519f, 
    -0.05018798f, -0.02146146f, 0.03221915f, 0.00530364f, 0.04741699f, 0.00363525f, 0.01977633f, -0.02970108f, 
    -0.06927701f, -0.06865679f, -0.00799323f, -0.13579723f, -0.12987790f, -0.14873697f, 0.19489707f, -0.02620865f, 
    0.10920393f, -0.00560908f, -0.01748384f, 0.02831129f, -0.03741223f, 0.01314746f, 0.00952539f, -0.02256668f, 
    -0.07848085f, -0.01589769f, 0.04892886f, -0.07438024f, -0.02622574f, 0.04317588f, -0.00949202f, 0.02277610f, 
    -0.10899571f, 0.05651850f, 0.02567496f, 0.00244413f, 0.05544262f, -0.07837630f, -0.09145941f, -0.10532346f, 
    -0.02034646f, 0.09597808f, -0.01669959f, -0.01749823f, 0.03697157f, -0.07946365f, -0.05028666f, -0.06072706f, 
    -0.00496267f, -0.03570423f, 0.02285548f, 0.01146147f, -0.04963536f, 0.19538270f, -0.06312586f, -0.13886596f, 
    -0.22166786f, -0.13557777f, 0.09185811f, -0.01036954f, -0.08019756f, 0.02496812f, 0.04424340f, -0.06815521f, 
    0.06130454f, 0.00091850f, 0.02306546f, -0.05272596f, -0.05340597f, -0.15989459f, -0.01674440f, 0.06020681f, 
    0.12769094f, 0.14554703f, -0.06492145f, 0.07642824f, 0.10997608f, 0.02654822f, 0.00968419f, -0.05725323f, 
    -0.03480984f, -0.05837582f, 0.02145673f, -0.02747535f, -0.02770752f, -0.03033924f, 0.04257520f, -0.01848587f, 
    -0.01218949f, -0.00042099f, 0.08287429f, -0.01760268f, 0.13812076f, -0.03916944f, 0.06598855f, 0.10437758f, 
    0.15668724f, 0.05946338f, 0.01612889f, -0.02900288f, -0.03226965f, -0.00724456f, 0.00359766f, 0.05258224f, 
    -0.01037460f, -0.05112786f, 0.00714435f, 0.04164103f, -0.01352393f, 0.08978152f, 0.04243049f, 0.04540339f, 
    0.01100311f, -0.13361424f, -0.13570641f, 0.09733374f, 0.14499259f, 0.15760823f, 0.04724973f, -0.03043442f, 
    -0.04773409f, -0.01497176f, 0.00494274f, -0.00121791f, 0.00963686f, 0.03123071f, -0.00842449f, 0.04611393f, 
    -0.04811558f, 0.00863918f, 0.04901016f, -0.08689280f, -0.07748758f, -0.11750251f, 0.16354881f, 0.05503338f, 
    0.12056375f, -0.03862883f, -0.04846520f, 0.00908130f, -0.04389193f, -0.02619874f, 0.05142171f, -0.01566030f, 
    -0.00881562f, -0.08772492f, -0.00780785f, 0.02812096f, -0.03292281f, 0.02250498f, 0.02951400f, 0.05160439f, 
    0.14802137f, 0.06058838f, -0.14345489f, 0.08094475f, 0.06456486f, 0.04268683f, 0.00826073f, -0.19581518f, 
    -0.07116194f, 0.06001174f, 0.01815683f, 0.00161564f, 0.04320631f, -0.11368007f, -0.03756445f, -0.10546748f, 
    0.01669645f, -0.01707235f, 0.14617674f, -0.02334451f, 0.09036691f, 0.11147909f, -0.06109866f, -0.01997910f, 
    0.02334141f, 0.03323515f, -0.01699390f, -0.01040737f, 0.04921117f, -0.02535088f, 0.03589333f, -0.01817956f, 
    -0.02381550f, 0.03657871f, -0.00644084f, 0.02064409f, 0.03721756f, 0.00417369f, 0.07419046f, -0.01776539f, 
    -0.01110143f, 0.08543296f, 0.00772407f, 0.03298677f, -0.13322408f, -0.12013917f, -0.03747277f, -0.01433487f, 
    -0.09016458f, -0.01829833f, 0.08431955f, -0.00671677f, -0.02805174f, -0.08374871f, 0.01680908f, -0.07108592f, 
    -0.06951177f, -0.07463452f, 0.11800312f, -0.01647098f, -0.06768156f, 0.13436739f, 0.11491682f, 0.01043104f, 
    -0.11830611f, -0.13010690f, -0.00610270f, -0.00976866f, -0.03854372f, -0.06491867f, 0.04652908f, -0.00590835f, 
    0.03098960f, -0.00812834f, -0.01252194f, -0.11021364f, -0.01538510f, -0.05949081f, 0.06317235f, -0.07386658f, 
    -0.06532351f, 0.05788869f, -0.16045563f, -0.10811402f, -0.03515898f, 0.00975056f, -0.09893513f, -0.07436629f, 
    -0.01587653f, -0.00831523f, 0.11837320f, 0.03136806f, 0.01560874f, 0.00372616f, 0.05013230f, 0.03557355f, 
    -0.03823723f, 0.00780888f, -0.01940024f, -0.05374971f, 0.01141053f, 0.05802633f, -0.11844518f, -0.02085729f, 
    -0.05525290f, -0.02364830f, 0.03180461f, -0.04078660f, -0.06122278f, 0.00210382f, 0.03008967f, -0.03107308f, 
    0.01213208f, -0.03391321f, 0.07645794f, -0.05059357f, -0.04555103f, -0.08808722f, 0.10696512f, 0.00544058f, 
    0.01731823f, 0.06587180f, 0.18118191f, -0.18446046f, -0.19231105f, 0.00498294f, 0.03304813f, -0.00296848f, 
    -0.04063841f, -0.00680839f, -0.01559924f, -0.02840957f, -0.00466581f, -0.11289009f, 0.06885367f, -0.02311242f, 
    0.09611297f, -0.03521287f, -0.09604015f, -0.06020080f, 0.26285875f, -0.01232090f, -0.07097286f, -0.17097780f, 
    -0.09658525f, -0.02890987f, 0.03875105f, -0.01205430f, 0.04128667f, -0.06369849f, -0.05185423f, -0.00594625f, 
    -0.00000616f, -0.04450867f, -0.02304508f, 0.08266327f, 0.04776780f, -0.04045243f, -0.08741773f, 0.01327075f, 
    0.15121806f, -0.46696979f, 0.01781779f, 0.12503311f, -0.15246712f, -0.10354272f, 0.03076415f, -0.07799325f, 
    0.09945771f, 0.05706491f, 0.00703251f, 0.06077876f, 0.14385970f, -0.12352580f, -0.00010290f, 0.02602833f, 
    0.05534523f, -0.06049276f, -0.00499628f, 0.01678080f, -0.03861232f, -0.20483658f, 0.03153592f, 0.04272910f, 
    0.00125879f, 0.04403709f, 0.16200607f, 0.02238479f, -0.02381989f, -0.10506164f, 0.00111148f, -0.03353374f, 
    -0.04089862f, -0.00131258f, -0.10386028f, -0.00300443f, -0.04620501f, -0.08919242f, -0.18520069f, -0.08807609f, 
    0.11908799f, -0.06126641f, -0.00153211f, 0.00904932f, 0.00933118f, 0.05819938f, -0.01269372f, -0.06516857f, 
    -0.05703078f, 0.08031066f, -0.04580976f, 0.05016734f, -0.00324417f, -0.08012580f, 0.00444496f, -0.06976493f, 
    -0.06597096f, -0.05736771f, -0.00173285f, 0.08151792f, 0.01247847f, 0.02819087f, 0.08976135f, -0.15349451f, 
    0.00600297f, 0.10966685f, 0.01506843f, -0.04945036f, -0.04907230f, -0.03177523f, 0.07511465f, 0.02074425f, 
    -0.07785255f, 0.03806085f, -0.13726966f, -0.01488348f, 0.02089368f, -0.03437089f, -0.08102866f, -0.13328543f, 
    -0.08839576f, 0.06144750f, -0.02522157f, 0.07686565f, -0.02908149f, 0.06580315f, 0.06111336f, 0.01593117f, 
    -0.03878832f, -0.14349607f, 0.01828698f, 0.03988878f, -0.02673065f, 0.02645156f, 0.06271918f, 0.02744556f, 
    -0.05234937f, -0.00878369f, 0.04185086f, 0.00392630f, 0.12866488f, -0.22970752f, -0.07496089f, -0.03391619f, 
    -0.23404744f, 0.04091053f, 0.08539406f, 0.02840954f, 0.00439148f, -0.07191727f, -0.08861566f, -0.05699695f, 
    -0.02956282f, 0.05637778f, 0.00177694f, 0.01627848f, 0.07249475f, 0.02768385f, 0.07176892f, 0.12294679f, 
    0.29354224f, -0.29783100f, 0.11170878f, -0.04547230f, 0.19865787f, -0.01739423f, -0.06589611f, -0.02790798f, 
    0.04256199f, -0.07615912f, 0.04946423f, -0.04177740f, -0.01954507f, -0.03002647f, -0.02873914f, 0.06160814f, 
    0.00359159f, -0.05008225f, 0.04338446f, 0.07515731f, -0.03344605f, 0.08755133f, 0.11336696f, -0.31901497f, 
    -0.19449268f, -0.05469324f, 0.05530726f, -0.09190108f, -0.02080100f, 0.08402187f, -0.01316812f, -0.04008491f, 
    -0.07950091f, -0.08010614f, 0.02531972f, 0.01863778f, 0.04619525f, -0.00339189f, 0.01178933f, -0.03581108f, 
    -0.04327195f, 0.03707764f, -0.10506599f, -0.04224661f, 0.07511947f, 0.02124707f, 0.01626439f, -0.03926165f, 
    -0.03409758f, -0.01412767f, 0.03796903f, 0.09851304f, -0.07393994f, -0.04129644f, -0.12438057f, 0.01315147f, 
    -0.05154428f, 0.13313264f, -0.00812529f, 0.08834155f, -0.05129578f, -0.16260558f, -0.04301963f, 0.04957194f, 
    0.01641548f, -0.00114563f, -0.00170682f, -0.06757002f, -0.04122870f, 0.13800025f, -0.07125297f, 0.03947428f, 
    -0.05022776f, 0.02092361f, 0.01171766f, 0.01602316f, -0.04979693f, -0.05063618f, 0.05129120f, -0.07049299f, 
    0.01428875f, -0.00485807f, 0.12070343f, -0.22423714f, -0.34726995f, -0.01278445f, 0.03928047f, 0.07015941f, 
    -0.09089984f, 0.02143191f, -0.05786348f, -0.03050847f, -0.11251288f, -0.12244737f, -0.00884439f, -0.06707686f, 
    0.00521503f, -0.09912261f, 0.03564959f, 0.01143501f, -0.01432598f, -0.00821018f, 0.01462731f, 0.13773735f, 
    -0.13635872f, 0.03653018f, -0.01417951f, -0.03434183f, 0.04306362f, -0.14093083f, 0.00547044f, 0.06194263f, 
    -0.00711647f, -0.03310908f, 0.06006003f, -0.03756043f, -0.02467489f, 0.02825459f, -0.06231470f, 0.07517630f, 
    0.06277452f, -0.16352712f, 0.03207761f, -0.02494884f, 0.03325789f, 0.01244945f, -0.00240656f, 0.04196072f, 
    -0.05281123f, 0.02850116f, -0.02037447f, 0.03471738f, 0.05688477f, 0.11435030f, 0.06167855f, -0.07210241f, 
    0.04800928f, -0.13188948f, -0.02563165f, -0.07819484f, -0.00615819f, -0.04757424f, 0.07631494f, 0.05470210f, 
    -0.12073863f, 0.06399848f, -0.02188795f, -0.01949082f, 0.01335283f, -0.00811228f, 0.08223215f, -0.03252490f, 
    0.04602509f, -0.12501043f, 0.09721759f, 0.00061112f, -0.01644275f, -0.13937117f, 0.02247817f, 0.02200944f, 
    0.07545886f, -0.09142216f, 0.00184419f, 0.03519582f, -0.19007522f, 0.06795699f, -0.05848364f, -0.01684680f, 
    -0.05505835f, -0.03628267f, 0.00495625f, -0.01772975f, 0.07194196f, 0.10677403f, 0.00480244f, 0.02006344f, 
    0.01877798f, -0.09763330f, -0.01754166f, -0.10938903f, 0.47513020f, -0.04765718f, -0.26217872f, 0.03832965f, 
    -0.03539318f, 0.02096264f, -0.00306075f, 0.14039914f, 0.04814557f, -0.07141921f, 0.00467193f, -0.01989521f, 
    0.00051332f, 0.15060841f, -0.04949178f, 0.05459552f, 0.03275059f, 0.09006029f, 0.04077090f, 0.08782874f, 
    -0.16121988f, 0.11922541f, -0.11413159f, -0.12942381f, 0.00202131f, 0.01311747f, -0.11192256f, -0.04833387f, 
    0.06936008f, 0.11319468f, -0.04774634f, -0.04575412f, 0.02924624f, 0.03528092f, -0.03157765f, 0.08256740f, 
    -0.01688956f, 0.03376453f, -0.03177749f, -0.15509823f, -0.32289934f, -0.02983854f, 0.01908764f, 0.14080422f, 
    0.05208405f, 0.00713850f, 0.02835659f, -0.00767123f, -0.03343173f, 0.05535547f, -0.04849328f, -0.00662905f, 
    0.05209590f, -0.01236117f, -0.02106484f, 0.00769982f, -0.10743912f, 0.00075869f, 0.03595056f, -0.03673768f, 
    0.05837245f, -0.15937966f, -0.02802605f, 0.11743779f, -0.00169552f, 0.00586012f, 0.02561592f, -0.04074971f, 
    -0.06470464f, 0.03583315f, -0.03548288f, 0.06182288f, -0.02037957f, 0.01399065f, 0.14518544f, -0.01545380f, 
    -0.04099833f, 0.08929972f, -0.04528361f, 0.07477647f, -0.10145725f, 0.00216074f, 0.08599985f, -0.20683827f, 
    -0.07973567f, 0.04369206f, 0.04494523f, -0.01724548f, 0.01670575f, 0.02877867f, -0.02006022f, 0.03402828f, 
    -0.04753094f, 0.03556729f, -0.02855310f, -0.06241917f, -0.05805864f, 0.01699192f, 0.03058169f, 0.03085664f, 
    -0.09269410f, -0.25998366f, 0.03128863f, 0.13193783f, 0.06622339f, -0.08771499f, 0.03921669f, -0.04796236f, 
    -0.08694245f, -0.00420930f, -0.00213987f, 0.08909109f, -0.14431925f, -0.08891124f, -0.05056025f, -0.10558632f, 
    0.03137317f, -0.05190508f, 0.13122280f, 0.01960514f, -0.19481690f, 0.02210062f, 0.06005249f, -0.10789105f, 
    -0.14539090f, -0.03154930f, 0.01300879f, -0.05870419f, 0.02608297f, -0.02849371f, -0.02882425f, 0.05513549f, 
    -0.05966702f, 0.04848213f, 0.00510525f, 0.01046372f, 0.00553138f, 0.10612059f, 0.10161225f, 0.03383610f, 
    -0.05940474f, -0.12438172f, 0.09603799f, -0.15604658f, -0.15558924f, 0.05446759f, 0.11803167f, -0.06661899f, 
    -0.01061109f, -0.03044004f, -0.08544897f, 0.07079711f, -0.03808740f, 0.00091503f, -0.02255507f, -0.05109905f, 
    -0.02288343f, 0.07246152f, 0.02993641f, -0.03050265f, -0.12843399f, 0.00953989f, 0.30894533f, -0.12990056f, 
    0.06999864f, 0.07368049f, 0.04950439f, -0.06350849f, 0.04329837f, -0.01660835f, 0.03558139f, -0.00110431f, 
    0.10121285f, 0.00409395f, -0.11261278f, 0.05859808f, -0.03518049f, -0.00619479f, -0.14707297f, 0.01060109f, 
    -0.02035514f, 0.01030576f, 0.06790938f, -0.19771233f, -0.22529142f, -0.05924312f, 0.03988439f, -0.02234666f, 
    0.01441347f, -0.08146536f, 0.07435153f, -0.05534701f, 0.05738315f, 0.02094268f, 0.00344298f, -0.02152883f, 
    0.05173375f, -0.08163635f, 0.00919795f, -0.10107201f, 0.02893522f, -0.14804937f, -0.02169509f, -0.06983604f, 
    0.00129822f, -0.05604245f, 0.08991191f, 0.05590988f, -0.02394545f, -0.05743362f, 0.08973652f, -0.04794119f, 
    -0.00989419f, 0.05987242f, -0.00562476f, -0.03690602f, 0.02521062f, -0.05835773f, 0.08353776f, -0.01100814f, 
    0.32726958f, -0.07126123f, -0.13667378f, -0.02246678f, 0.13448626f, 0.07686707f, -0.03621466f, 0.03485151f, 
    -0.00238238f, -0.01664729f, -0.01393414f, 0.06066682f, 0.04598476f, 0.07154053f, -0.00420190f, -0.02269189f, 
    -0.01297647f, 0.00860235f, 0.06291308f, -0.00569434f, 0.14069910f, 0.11029799f, 0.00494676f, -0.07422313f, 
    0.00356488f, 0.02846230f, 0.01337543f, -0.02110342f, 0.04175792f, 0.08127062f, -0.07197446f, 0.01567298f, 
    0.01232191f, -0.01407835f, -0.00030558f, 0.10686362f, 0.03960888f, 0.05277673f, -0.00878737f, -0.01671985f, 
    0.09523081f, -0.13950178f, -0.05470780f, 0.00022701f, -0.11535317f, -0.15260510f, 0.01713780f, 0.02678474f, 
    0.00536436f, 0.01701307f, 0.04390078f, 0.08222634f, 0.07772670f, -0.01595134f, -0.08009995f, 0.04046024f, 
    0.02362452f, 0.00598690f, 0.04724100f, 0.04605445f, -0.14401761f, 0.20253144f, -0.05749490f, 0.10688547f, 
    -0.00228101f, 0.04669347f, 0.00911800f, 0.01457913f, 0.06778030f, 0.03797821f, -0.08521766f, 0.00418259f, 
    0.05858254f, 0.01285779f, 0.05325210f, -0.00448772f, -0.07215246f, 0.05548447f, 0.01105664f, 0.08044084f, 
    -0.02787827f, -0.18406050f, -0.06357911f, 0.15746723f, -0.09722964f, -0.00542020f, -0.00976396f, -0.12396148f, 
    0.06389104f, -0.04405293f, -0.03865783f, 0.06952922f, -0.03400725f, -0.08060933f, 0.01728125f, -0.07641155f, 
    0.06081595f, -0.02320258f, -0.00437953f, -0.01407273f, 0.16069125f, 0.08508204f, -0.04466558f, 0.04998590f, 
    -0.17246988f, -0.15362005f, 0.02206609f, -0.05261665f, -0.07997593f, -0.04600664f, 0.03454930f, 0.00294586f, 
    0.08760777f, 0.09595650f, 0.09638654f, 0.01851255f, 0.02411284f, -0.00685114f, -0.06447156f, 0.02456203f, 
    -0.02690713f, 0.08607028f, -0.01986897f, 0.15555084f, -0.01831030f, -0.08181311f, 0.03298615f, -0.01905162f, 
    0.00679012f, -0.07703871f, -0.00513061f, -0.06674642f, 0.07705333f, -0.00020858f, 0.16298218f, 0.09192614f, 
    0.00010766f, 0.02579395f, -0.14241393f, 0.06315362f, -0.12290164f, -0.08865611f, 0.02299392f, -0.02287455f, 
    -0.03269730f, -0.10666378f, 0.04651551f, 0.06280931f, -0.02818539f, -0.03011496f, 0.05075849f, -0.03333055f, 
    -0.03778538f, -0.06491220f, -0.02411607f, 0.00878456f, 0.03105641f, 0.11977760f, 0.06386191f, 0.05334778f, 
    0.05061497f, -0.23907146f, 0.14454938f, -0.20577015f, -0.23176566f, -0.10665041f, 0.03372556f, -0.04114072f, 
    -0.04621474f, 0.09414089f, -0.03562203f, 0.08642732f, 0.08948313f, -0.02588333f, -0.04945258f, 0.00094811f, 
    0.11933212f, 0.01772024f, 0.03534925f, -0.01128187f, 0.10866582f, -0.18943654f, 0.05213008f, -0.00453241f, 
    -0.03638479f, 0.04621521f, -0.02387540f, 0.13364522f, 0.07015166f, 0.02851439f, -0.03136875f, 0.03071394f, 
    0.02566961f, -0.12580034f, -0.00113992f, 0.04588697f, -0.00701182f, -0.00484553f, -0.15581666f, 0.14284936f, 
    0.07923109f, 0.04805596f, -0.15998319f, -0.00941592f, -0.13795103f, 0.04577836f, 0.04330667f, 0.06912039f, 
    0.07384417f, -0.10018443f, -0.02962040f, 0.02713265f, 0.01137763f, -0.00501611f, -0.03681023f, -0.08328928f, 
    -0.04249440f, -0.07963204f, 0.00140996f, -0.01399805f, -0.02617441f, -0.11836561f, -0.06986375f, 0.08616153f, 
    -0.05277081f, 0.07791027f, -0.02563565f, -0.04909131f, 0.07251226f, 0.13071452f, -0.06545275f, 0.06181445f, 
    -0.01753311f, 0.02725022f, -0.04630351f, -0.16001973f, -0.07869297f, -0.04972670f, -0.02550664f, 0.02124470f, 
    0.03023673f, -0.43280303f, 0.03479813f, -0.01818947f, 0.05268716f, 0.07119522f, -0.02244976f, -0.06891986f, 
    0.07062002f, -0.02280881f, 0.02413877f, 0.02592875f, 0.06092359f, 0.03324367f, -0.03914156f, 0.05370675f, 
    0.06942923f, -0.08252730f, -0.04967655f, -0.03655638f, -0.08603442f, -0.12083150f, 0.22940624f, -0.13648927f, 
    -0.10857217f, 0.05525165f, -0.01769574f, 0.05582988f, -0.01936364f, 0.00988994f, 0.03147957f, -0.02766685f, 
    0.02931531f, 0.00544827f, 0.06763022f, -0.04506718f, 0.00326661f, 0.05424498f, 0.03073184f, 0.00514468f, 
    -0.41702759f, 0.16288970f, -0.10023345f, 0.12664451f, -0.03407950f, 0.02216440f, 0.11201320f, -0.03912816f, 
    -0.01447701f, 0.04838883f, 0.04018470f, -0.07297509f, -0.01179916f, 0.04841375f, 0.06071778f, 0.03565322f, 
    -0.03139108f, 0.08910139f, 0.01486764f, 0.03833637f, -0.17845285f, 0.11819904f, -0.19493610f, 0.13679630f, 
    -0.11902656f, 0.04422940f, 0.03279493f, 0.05598455f, 0.06758220f, -0.00300117f, -0.05332096f, 0.07479265f, 
    0.02384337f, 0.03031683f, 0.06364621f, 0.03175850f, -0.05899465f, 0.06134677f, 0.02582574f, -0.03161903f, 
    -0.16553237f, 0.02382381f, -0.05689651f, 0.12475450f, 0.02222357f, 0.06569717f, 0.05171677f, 0.01729132f, 
    -0.01469315f, 0.04522317f, -0.07288416f, -0.11517227f, 0.06572928f, 0.06362090f, -0.02928478f, 0.01917640f, 
    -0.09496178f, 0.02752587f, -0.03282088f, 0.00640630f, 0.30218178f, -0.05565674f, -0.05426027f, -0.13573113f, 
    -0.12930921f, -0.02615212f, 0.00380395f, 0.14308992f, 0.04447990f, -0.03717579f, -0.03609555f, -0.00829316f, 
    -0.02859748f, -0.00178067f, 0.06468728f, 0.03221293f, 0.11144339f, -0.05797886f, 0.08057333f, 0.14147174f, 
    0.02739878f, -0.09108337f, -0.09945639f, 0.14533217f, 0.02214936f, 0.03465985f, -0.01017310f, -0.08692206f, 
    -0.00128468f, 0.03187035f, -0.04199227f, 0.05007358f, -0.11037192f, -0.03888211f, 0.02628211f, -0.09499305f, 
    -0.05846045f, -0.02845597f, 0.02090467f, 0.01545843f, 0.22802289f, -0.06647725f, -0.13819085f, 0.05131613f, 
    0.00672172f, -0.10213897f, -0.06702091f, 0.03073429f, -0.04367353f, -0.00716415f, -0.10082190f, -0.02849744f, 
    0.03693660f, -0.06803212f, 0.08258960f, 0.14763314f, -0.05184012f, -0.05775969f, 0.09432996f, 0.14118825f, 
    0.18393597f, -0.18702997f, 0.04649349f, -0.07660605f, 0.25384375f, -0.02934224f, 0.03325690f, -0.03119068f, 
    -0.04292447f, 0.05410808f, 0.02048495f, -0.06374192f, -0.00502383f, -0.06499029f, 0.08133574f, -0.04955336f, 
    -0.15734270f, -0.04656211f, 0.05849754f, 0.18243207f, -0.00637286f, -0.04309544f, -0.08967797f, 0.03531864f, 
    0.22211608f, 0.11475848f, -0.07078273f, 0.02111032f, -0.11166681f, 0.17427672f, -0.00824433f, 0.05019810f, 
    0.00668464f, 0.06088861f, -0.08923610f, -0.07752633f, 0.03112493f, 0.00742347f, 0.01450440f, -0.07575384f, 
    -0.19142292f, -0.07117712f, -0.01413940f, -0.05742944f, -0.11487889f, -0.07491453f, -0.04638762f, -0.10246065f, 
    -0.04052710f, 0.02768589f, -0.02375085f, -0.06011929f, -0.04886837f, 0.01193137f, -0.05102691f, 0.01961681f, 
    0.01615028f, 0.01831682f, 0.00922984f, -0.00047023f, 0.20490579f, -0.01394460f, -0.05687621f, 0.08365127f, 
    0.00405273f, -0.03207931f, 0.00115234f, 0.00191326f, 0.00749482f, 0.05797719f, -0.01709308f, 0.02704871f, 
    0.04099315f, -0.05278702f, 0.07874031f, 0.05189398f, -0.01948975f, 0.01579369f, 0.00320841f, 0.00820786f, 
    0.08953372f, -0.44739851f, -0.17818972f, -0.00545011f, -0.01656486f, -0.14427288f, -0.01707279f, -0.00560690f, 
    0.01071856f, -0.08044066f, -0.02989677f, -0.03088445f, -0.02589067f, 0.11425207f, 0.10455069f, 0.06371592f, 
    0.01230943f, 0.01830056f, -0.00379983f, -0.00254197f, -0.31726387f, -0.03198065f, -0.15048105f, 0.04740070f, 
    -0.08200351f, 0.00469909f, 0.03273258f, -0.08805849f, -0.03199286f, 0.01059452f, -0.16202313f, 0.05149496f, 
    -0.05169510f, 0.10099555f, 0.06930029f, 0.03620046f, -0.06949294f, 0.05291149f, 0.01815933f, 0.05877880f, 
    -0.14295040f, 0.02181789f, 0.07195387f, -0.05523369f, 0.05358326f, 0.05768557f, 0.05194457f, -0.06685841f, 
    -0.09622040f, -0.07507838f, 0.08735316f, -0.03877814f, -0.12130541f, 0.01459086f, -0.02688656f, 0.01580608f, 
    0.01434110f, -0.05693410f, -0.04143480f, -0.00103552f, 0.18778004f, -0.28849924f, 0.29416507f, -0.00149527f, 
    -0.06250685f, 0.08012182f, 0.08727327f, -0.05866960f, -0.06179790f, -0.09614792f, -0.08103365f, 0.03712541f, 
    -0.02889412f, 0.02411497f, 0.04227896f, -0.00482554f, 0.01139063f, -0.07978678f, 0.01480681f, 0.02979223f, 
    0.06120739f, -0.16865590f, 0.18880981f, -0.12173871f, -0.19044091f, 0.01719332f, 0.07674313f, -0.10540226f, 
    -0.07072250f, 0.07936093f, -0.04351665f, -0.01949468f, 0.03757721f, -0.08615118f, -0.05428937f, -0.02450807f, 
    -0.01878066f, 0.03294253f, 0.01174438f, -0.01150619f, 0.36982408f, -0.01440432f, -0.07536235f, -0.02844884f, 
    0.06713676f, 0.08249672f, -0.12134786f, 0.02566032f, -0.04112542f, 0.11090923f, 0.03250544f, 0.02360135f, 
    0.00516517f, 0.04701324f, 0.03640622f, 0.02611198f, -0.01500074f, -0.03032240f, 0.02131383f, -0.05651528f, 
    0.19741556f, -0.15144643f, 0.13910808f, -0.12795687f, 0.02244757f, 0.02604890f, -0.03186079f, 0.06530116f, 
    0.01677085f, -0.15717691f, 0.02810458f, 0.09536505f, 0.00354959f, 0.10959250f, -0.11460709f, -0.00923431f, 
    -0.00656539f, 0.02582381f, -0.19779381f, 0.01293275f, 0.03291979f, 0.06090732f, 0.10161168f, -0.30070484f, 
    -0.14583966f, -0.00012130f, -0.01308139f, 0.01283864f, 0.02950788f, -0.00205427f, -0.07072741f, -0.02689089f, 
    0.08214362f, -0.07144886f, 0.00363566f, -0.02060663f, 0.09190051f, -0.05279779f, -0.02294924f, -0.04596514f, 
    -0.65207744f, 0.30625218f, 0.17914195f, 0.03084971f, 0.00202954f, 0.17216340f, 0.07859527f, -0.00029877f, 
    0.05957210f, 0.01096417f, -0.01164328f, -0.00430270f, 0.02323720f, 0.00567551f, 0.13206615f, 0.13877143f, 
    0.06318351f, 0.10344386f, -0.14536622f, 0.05443491f, 0.14535198f, 0.10071906f, 0.05708323f, 0.12611766f, 
    -0.01262797f, 0.06209390f, -0.00854402f, 0.01062465f, 0.02212180f, 0.09021788f, -0.10031397f, -0.01060664f, 
    0.06194890f, 0.05767507f, 0.04409891f, 0.07815873f, 0.00542592f, 0.04068420f, -0.08939327f, -0.09023608f, 
    0.10310552f, -0.25626227f, 0.03795050f, -0.15694234f, -0.04645327f, -0.16591150f, 0.04825787f, 0.04309465f, 
    0.12636910f, -0.08825491f, 0.02884583f, -0.02490955f, 0.00356636f, -0.15104336f, -0.08142082f, 0.01314773f, 
    -0.03013481f, 0.05453070f, 0.04554697f, 0.05634188f, -0.40404779f, 0.34036654f, 0.15457748f, 0.00363338f, 
    0.06199959f, 0.01675900f, 0.05104882f, -0.00765149f, 0.01221566f, 0.06599992f, -0.05264012f, 0.09926891f, 
    0.04400397f, 0.04132581f, -0.01022355f, 0.07882964f, 0.00816832f, 0.05368804f, 0.05309862f, 0.07781084f, 
    -0.42311570f, -0.23037745f, -0.10612806f, -0.08945622f, 0.04444065f, 0.09366268f, -0.00238176f, -0.02957593f, 
    -0.02055492f, -0.04139109f, 0.08308441f, 0.01675783f, -0.01727837f, 0.05250485f, -0.02188024f, 0.09182282f, 
    -0.00261935f, -0.00905638f, 0.02645961f, -0.02936566f, -0.37366131f, -0.17869303f, 0.02456153f, -0.00399937f, 
    -0.18541835f, 0.08718470f, -0.01290527f, 0.00003429f, -0.04331775f, 0.10230163f, 0.02096255f, 0.00790709f, 
    -0.00946647f, 0.04501303f, 0.05989638f, -0.02315836f, -0.04805851f, 0.02052734f, 0.07610167f, 0.01588406f, 
    0.05996200f, 0.12509733f, -0.00519815f, -0.02682120f, 0.07837097f, 0.08211803f, 0.07140055f, 0.00905847f, 
    0.02724908f, -0.01889886f, -0.05179785f, 0.07391384f, -0.05888801f, 0.03597642f, 0.06226869f, -0.01086369f, 
    0.04549414f, -0.02202832f, -0.14385647f, 0.07697008f, -0.41905773f, -0.24529363f, 0.00770265f, -0.08997101f, 
    -0.17995389f, 0.08549535f, 0.01851355f, -0.03580929f, -0.03461057f, 0.00966290f, 0.00785128f, -0.09833781f, 
    -0.06958746f, 0.06698333f, 0.04079551f, -0.02870746f, -0.10264256f, 0.01413799f, 0.01223157f, 0.04304821f, 
    0.14029887f, 0.07835240f, -0.07115074f, -0.00584463f, 0.02148532f, -0.05071520f, -0.00559284f, -0.00615083f, 
    0.03977382f, 0.01324455f, -0.00134819f, 0.01212842f, 0.01062227f, 0.00307637f, 0.01768094f, -0.03542050f, 
    0.05461159f, 0.03956490f, 0.03739382f, 0.04000815f, -0.09488048f, 0.01473052f, -0.12482983f, -0.05945211f, 
    -0.09674680f, 0.03605065f, 0.03073462f, -0.03227293f, -0.03268376f, -0.01108213f, 0.02068317f, -0.10226969f, 
    0.01135957f, -0.06727119f, 0.03144640f, -0.05754148f, -0.04197235f, 0.06442552f, 0.10058405f, 0.06437396f, 
    -0.15792821f, -0.13457656f, -0.10268556f, -0.05001213f, -0.07609911f, 0.03846710f, 0.07381470f, -0.00485133f, 
    -0.03347855f, 0.02935508f, 0.00546090f, -0.04687765f, -0.05061784f, -0.02492592f, -0.01008941f, -0.00222147f, 
    0.02276296f, 0.08473981f, 0.08699583f, 0.01843346f, -0.23471038f, -0.04529655f, 0.10402554f, -0.08815484f, 
    -0.06658311f, 0.05825936f, 0.01058436f, 0.01105590f, -0.02951880f, -0.02844949f, -0.00783549f, 0.04042213f, 
    0.01160006f, 0.05575677f, 0.06521615f, 0.04248869f, -0.02347953f, -0.01575051f, -0.06429963f, 0.10135286f, 
    -0.17311613f, -0.05503175f, -0.03854458f, 0.10501899f, 0.12405371f, -0.00002873f, 0.02506363f, -0.05093490f, 
    0.02067306f, 0.04799577f, 0.05633175f, 0.00142139f, 0.03138908f, 0.00610194f, 0.11395954f, 0.06187458f, 
    -0.02215423f, 0.01879243f, -0.08859725f, -0.04800298f, -0.08963039f, -0.02752707f, 0.09471165f, -0.07400729f, 
    -0.05458846f, 0.04322218f, -0.02882795f, -0.00779252f, 0.00060023f, 0.03908830f, 0.02338378f, 0.04630320f, 
    0.01213442f, 0.09264414f, -0.04860188f, 0.04049108f, 0.02253954f, -0.07569510f, -0.04107736f, -0.03596813f, 
    0.24635020f, 0.24383479f, -0.14003393f, -0.04452479f, -0.11066569f, 0.10180763f, -0.06579117f, 0.09564962f, 
    -0.00310106f, 0.03897908f, -0.05874074f, -0.05901513f, 0.01065408f, -0.10718229f, -0.05292073f, 0.04622410f, 
    0.16794062f, -0.20247610f, -0.04488858f, 0.05453203f, 0.25129965f, -0.03994953f, -0.13551395f, 0.04307315f, 
    0.01192507f, -0.10348852f, -0.04598900f, -0.00307152f, -0.00920682f, -0.02515997f, 0.02833819f, 0.05169073f, 
    -0.09745635f, -0.07578082f, -0.01821132f, -0.05711405f, 0.00513597f, -0.04002645f, -0.09930637f, -0.04702781f, 
    -0.37972340f, -0.14336118f, 0.09043705f, -0.06187050f, -0.09643719f, 0.08624233f, -0.01810017f, -0.00042243f, 
    -0.05897346f, 0.04268773f, 0.03987933f, 0.04000038f, 0.04652447f, 0.14017709f, 0.01073453f, 0.10642234f, 
    -0.04637747f, 0.02029565f, -0.09043680f, -0.04452383f, -0.35018486f, -0.21958275f, -0.11778904f, -0.06169588f, 
    -0.06764852f, 0.04320131f, 0.06142997f, -0.06788618f, -0.11102683f, -0.01457844f, 0.01330032f, -0.10257622f, 
    -0.08090015f, 0.04343302f, -0.00398286f, -0.01605363f, 0.05421237f, 0.01763000f, 0.07864195f, 0.06970163f, 
    -0.04685450f, 0.02317302f, -0.19739695f, -0.06918772f, 0.01432536f, -0.04220189f, 0.00542752f, -0.10033102f, 
    0.03962327f, -0.01613904f, 0.02322675f, 0.04248734f, 0.05956620f, -0.09584533f, 0.05800986f, -0.04602531f, 
    -0.04255560f, 0.05776164f, -0.01038160f, 0.02477868f, -0.00749678f, 0.07522706f, -0.05791864f, -0.00614076f, 
    0.00060258f, 0.04875196f, 0.00821618f, 0.02115382f, 0.02985115f, 0.00550431f, 0.00088330f, -0.02187533f, 
    -0.06210943f, 0.03540189f, -0.02224027f, 0.03615487f, 0.10302700f, 0.07525828f, 0.06360512f, 0.12116905f, 
    -0.18208526f, -0.02061991f, -0.09172641f, -0.02068398f, 0.02493144f, -0.01564617f, 0.07191985f, -0.07910670f, 
    -0.02200390f, 0.06514642f, 0.04192286f, 0.01317274f, 0.04364781f, -0.02297065f, 0.05644606f, -0.01441642f, 
    0.03602973f, 0.14925200f, 0.01271002f, 0.07675058f, 0.05554994f, 0.00238964f, 0.11181068f, 0.03857913f, 
    0.06126785f, -0.05786476f, -0.01888840f, 0.01744184f, -0.01819878f, 0.02324394f, -0.02713729f, -0.07619040f, 
    0.00188752f, -0.11403684f, -0.06047738f, -0.12897952f, -0.01440006f, 0.07363585f, -0.00344987f, 0.02950609f, 
    -0.06219291f, 0.09852777f, -0.09569126f, 0.05133637f, 0.04595153f, 0.06125544f, -0.01608333f, -0.00851830f, 
    -0.10183159f, 0.04631816f, -0.03328988f, -0.01869371f, 0.09549510f, -0.03436363f, 0.02837352f, -0.07716383f, 
    0.08123726f, 0.02248262f, 0.04209814f, 0.13072607f, 0.20023677f, 0.04478289f, 0.00087193f, 0.08212762f, 
    -0.02716208f, -0.06262706f, -0.07458068f, -0.01815862f, 0.00401467f, -0.00992949f, 0.02365713f, 0.01857932f, 
    0.00513830f, -0.03742122f, -0.00397874f, 0.02346512f, 0.02340765f, -0.03572151f, -0.03015213f, -0.03822058f, 
    0.08050922f, -0.01177181f, 0.05242867f, -0.02252739f, -0.01351674f, 0.04014885f, 0.03469525f, 0.01813431f, 
    0.05089065f, 0.01230032f, 0.00549734f, 0.03980819f, 0.02664298f, -0.01779899f, -0.02652643f, -0.04279693f, 
    0.02074965f, -0.08294249f, -0.07278451f, 0.04653588f, 0.06861397f, 0.08662255f, 0.08069045f, -0.07984267f, 
    -0.08130375f, 0.03372588f, 0.08439701f, 0.03262659f, 0.07628042f, 0.07994577f, 0.00151785f, 0.02313480f, 
    0.00992040f, -0.00393697f, 0.01729146f, 0.15133774f, 0.05562289f, 0.01289094f, -0.00197174f, 0.08261759f, 
    0.20540690f, 0.06623963f, 0.06902828f, -0.00276260f, -0.08920236f, 0.05416729f, 0.02975963f, 0.09696090f, 
    0.02520053f, -0.04814801f, 0.03637895f, -0.02506233f, -0.00491810f, 0.03520130f, -0.00403190f, 0.05545395f, 
    0.03867495f, -0.08171887f, -0.02006320f, 0.01133295f, -0.39795804f, -0.21228467f, -0.01888967f, -0.01455901f, 
    -0.20502687f, 0.04819058f, 0.03305263f, 0.01376530f, -0.02204308f, 0.11086427f, 0.09189929f, 0.05449201f, 
    0.02767119f, -0.00405002f, -0.02703365f, 0.02625727f, 0.03890478f, 0.03606533f, 0.04027106f, -0.01680350f, 
    -0.36334378f, -0.31493837f, -0.08004279f, -0.11187996f, -0.15851018f, 0.02240385f, 0.06784645f, -0.03660363f, 
    0.01411004f, 0.03161695f, 0.06809639f, 0.05134541f, 0.03001436f, 0.08205035f, -0.03392185f, 0.06987438f, 
    -0.00644960f, 0.07918504f, -0.01497763f, 0.00964999f, -0.12691113f, -0.12602533f, -0.17423131f, 0.00002456f, 
    0.02966466f, 0.03567810f, 0.02484403f, -0.01753967f, -0.03066272f, -0.01170076f, 0.09575526f, 0.04537178f, 
    -0.07504049f, 0.03423535f, 0.06339779f, 0.03422781f, 0.06540712f, 0.10781496f, 0.06611723f, 0.02025857f, 
    -0.19796173f, -0.01911059f, -0.03739173f, -0.08602832f, 0.06836101f, 0.04602523f, 0.00421980f, -0.02632570f, 
    -0.01534305f, 0.03222572f, 0.03077749f, -0.00007363f, 0.03094881f, 0.02587002f, -0.00322797f, 0.00566531f, 
    0.05357036f, 0.07692520f, 0.01551085f, 0.02892728f, 0.18445686f, 0.10631371f, 0.06982958f, -0.05276329f, 
    -0.09215876f, 0.07791768f, -0.01823257f, 0.00825951f, 0.00025118f, 0.00523155f, 0.01258268f, -0.01210783f, 
    0.02229349f, 0.01579068f, -0.01883784f, 0.05318917f, 0.04210478f, -0.08419570f, -0.11743423f, 0.06507260f, 
    0.03641190f, 0.08878243f, 0.11910798f, 0.06414669f, 0.01706681f, 0.07783728f, -0.05211883f, 0.02469322f, 
    0.00525649f, 0.01849944f, 0.02370222f, 0.03330695f, -0.02165211f, 0.01963496f, -0.02860942f, 0.03180374f, 
    0.04925745f, 0.10329753f, 0.01487201f, 0.03446622f, -0.07902528f, 0.00097697f, 0.08437598f, 0.06200068f, 
    -0.06471802f, 0.04794882f, 0.03425727f, 0.05586261f, -0.05996660f, 0.01134814f, 0.03070774f, 0.03769486f, 
    0.02593749f, -0.03423167f, -0.04269370f, -0.05080540f, -0.05168214f, -0.02693799f, 0.03741649f, -0.00931177f, 
    0.23637633f, 0.17057671f, 0.11217064f, 0.00331264f, -0.00628931f, 0.03622526f, 0.00194309f, -0.02792979f, 
    0.02634210f, -0.01440647f, -0.07840700f, -0.02106006f, -0.03030711f, -0.02349190f, -0.05905552f, 0.05706506f, 
    -0.06467736f, -0.18069652f, -0.10626921f, -0.01244086f, 0.15484443f, 0.07023734f, -0.03845157f, -0.00069918f, 
    -0.04495515f, -0.15263237f, -0.01273674f, -0.02092112f, 0.10368855f, -0.02529225f, -0.03659814f, -0.09523384f, 
    -0.01393275f, -0.11533639f, -0.05217111f, -0.07517733f, -0.00136191f, 0.03781021f, 0.08185023f, 0.02055021f, 
    0.13747497f, -0.00025088f, -0.01558086f, 0.01754829f, 0.01452488f, -0.01477599f, -0.01128657f, -0.06562109f, 
    0.04999215f, -0.03127515f, -0.06818517f, -0.00607063f, -0.02347310f, 0.02357406f, -0.02866559f, -0.06518430f, 
    0.09378069f, 0.06250612f, -0.06922303f, 0.05921315f, -0.09546036f, -0.08730412f, 0.00935998f, -0.05752195f, 
    0.05782652f, 0.02373868f, 0.04489708f, 0.03079560f, -0.02017687f, 0.05427586f, 0.01956825f, -0.00876101f, 
    -0.02391934f, -0.06197688f, -0.03112111f, -0.01300963f, -0.07204752f, -0.22335638f, 0.00899425f, -0.01607979f, 
    -0.28902391f, -0.29508293f, 0.04847959f, 0.06433646f, 0.16808641f, 0.00049307f, -0.01002472f, 0.03998630f, 
    -0.08600128f, -0.01865989f, 0.01708878f, 0.01044514f, -0.04173655f, 0.02084083f, 0.09114490f, -0.01810541f, 
    -0.08923627f, -0.19069467f, -0.04136605f, 0.01258875f, 0.17331174f, 0.07550890f, 0.10697352f, 0.09075030f, 
    0.01161369f, 0.08564181f, 0.03074927f, -0.00795836f, 0.02239088f, -0.02649678f, -0.07848503f, 0.03848580f, 
    0.02663102f, -0.00235977f, -0.00267367f, 0.02042584f, 0.08539508f, -0.16878879f, -0.10171492f, -0.08886057f, 
    -0.11620779f, 0.16462448f, 0.12331981f, -0.05983641f, -0.16386800f, 0.10380594f, -0.05179307f, 0.00796962f, 
    -0.01973459f, 0.04700349f, -0.05819714f, 0.00603962f, -0.03079312f, 0.05469190f, -0.04223773f, -0.04091080f, 
    -0.03720042f, -0.13425823f, -0.10842719f, -0.08887342f, -0.10747884f, -0.16667695f, -0.08873627f, -0.04811016f, 
    0.04824080f, 0.01126136f, 0.03106644f, -0.13680038f, -0.05171513f, -0.10788322f, -0.03442221f, -0.08935927f, 
    -0.06266317f, -0.01622731f, 0.13180524f, -0.07057708f, 0.00203708f, 0.05932019f, -0.00521084f, 0.04344172f, 
    -0.32438955f, -0.29094261f, 0.00737730f, -0.01354114f, -0.06602305f, 0.04340791f, 0.00276037f, 0.00952426f, 
    -0.08763994f, 0.02980372f, 0.04596809f, -0.01653356f, 0.01904308f, 0.02375323f, 0.00369032f, 0.00655211f, 
    -0.00862464f, 0.06056565f, 0.08233333f, 0.08093352f, 0.20768575f, 0.08925852f, -0.09067123f, 0.03968388f, 
    -0.06295973f, -0.11978154f, -0.11148469f, 0.00527068f, -0.02623138f, -0.06502774f, -0.04168775f, -0.00160824f, 
    -0.09713095f, -0.06412919f, -0.02963194f, -0.01014055f, 0.01063282f, -0.00885009f, -0.05352672f, -0.06775974f, 
    -0.42366198f, 0.08695745f, -0.13449466f, -0.04682092f, 0.04820758f, 0.08786200f, 0.01924425f, -0.08726577f, 
    -0.00873161f, -0.00427460f, 0.07700471f, -0.00985795f, 0.01821806f, -0.05724351f, 0.10565786f, -0.01660151f, 
    -0.06217930f, -0.01447922f, -0.09108835f, -0.02091477f, -0.08764603f, 0.01725471f, -0.03373148f, -0.05113694f, 
    -0.02255905f, -0.01695769f, 0.01071302f, -0.00893060f, 0.10299268f, 0.08622120f, -0.01555241f, 0.03616804f, 
    0.01545998f, 0.05681363f, -0.02191028f, 0.10709559f, 0.01558428f, 0.07082465f, 0.03257936f, 0.07482844f, 
    -0.22881673f, -0.23348258f, 0.00633471f, 0.00511257f, 0.20829628f, 0.00578712f, 0.01564410f, 0.01906595f, 
    -0.02245563f, -0.07251707f, 0.05866703f, -0.07963953f, 0.02032853f, 0.03305726f, 0.03474460f, 0.03328304f, 
    -0.00882054f, -0.03059309f, -0.01761129f, 0.00267390f, 0.03602532f, 0.01056055f, -0.01308084f, -0.00682871f, 
    -0.01534632f, -0.05637276f, 0.05154159f, -0.03940515f, 0.02795016f, 0.07582533f, 0.03277527f, -0.07424269f, 
    -0.01398096f, -0.09223052f, -0.05484530f, -0.02235242f, 0.01548859f, 0.04356344f, 0.12535524f, 0.05286122f, 
    0.25959229f, 0.01187724f, -0.04045607f, 0.00789688f, 0.01213023f, -0.12117324f, -0.07769111f, -0.15132725f, 
    0.02077243f, -0.05949894f, 0.01245578f, 0.08036476f, -0.14058253f, -0.12410680f, -0.07058808f, -0.07122974f, 
    -0.04601832f, -0.03728515f, -0.06086356f, -0.08138056f, -0.23238610f, -0.09812253f, 0.10041656f, 0.03339110f, 
    -0.08288350f, 0.07836769f, -0.00509424f, -0.06008432f, -0.03558451f, 0.06478225f, 0.03042478f, -0.02102635f, 
    0.03695370f, 0.05193415f, 0.01602099f, 0.01066253f, 0.07038540f, 0.05080218f, 0.00758510f, 0.09023431f, 
    0.12734777f, 0.04415116f, -0.01306726f, -0.04425768f, -0.02115195f, -0.07229832f, -0.03345867f, 0.06696185f, 
    0.03176113f, -0.05666732f, -0.01218043f, -0.01808779f, -0.03312186f, -0.00958905f, -0.01019385f, -0.01356177f, 
    0.04559769f, 0.06681940f, 0.01359662f, 0.01153605f, -0.02734100f, 0.14257568f, -0.02127373f, -0.14628445f, 
    -0.06807336f, 0.12613545f, 0.02280643f, 0.07047409f, 0.03950808f, 0.04825864f, -0.02303035f, 0.03511193f, 
    0.00496492f, 0.05385667f, -0.02956796f, 0.01467035f, 0.05908361f, -0.01183445f, -0.16760471f, 0.08768034f, 
    -0.01855306f, 0.04461376f, -0.11026160f, -0.00327885f, 0.03616944f, -0.04414111f, -0.06364338f, 0.02952853f, 
    0.02211113f, 0.10622230f, 0.02503736f, 0.03343305f, -0.02052943f, -0.02281625f, -0.04307430f, 0.14688683f, 
    -0.02274724f, 0.08346538f, -0.06048780f, 0.06057156f, 0.07044774f, 0.11461243f, -0.11157381f, 0.10392173f, 
    -0.08613784f, 0.03781747f, -0.02181224f, -0.01107803f, -0.00434139f, 0.04324742f, 0.02811015f, 0.02576270f, 
    0.04042662f, -0.02639233f, -0.00863704f, 0.01841109f, 0.02446278f, 0.06818473f, 0.01873398f, 0.01244203f, 
    -0.22903864f, -0.05828044f, 0.10291882f, 0.02698093f, -0.12030973f, 0.03021671f, 0.03033026f, 0.03966230f, 
    -0.01711102f, 0.02957717f, -0.00566085f, 0.00612897f, -0.00781707f, -0.07473903f, -0.01655317f, 0.00548430f, 
    -0.01740975f, -0.02047091f, -0.04197797f, -0.05903173f, 0.15087497f, -0.05713800f, -0.01379106f, 0.02251764f, 
    0.00580128f, -0.04875941f, -0.02896272f, -0.07791976f, 0.01668109f, -0.06540129f, 0.01632614f, 0.01622876f, 
    -0.03212823f, 0.02865731f, -0.06350892f, -0.08073169f, 0.00910014f, -0.05804329f, -0.12719813f, -0.00331663f, 
    -0.46120751f, 0.02115778f, -0.22156455f, 0.03028082f, 0.18351223f, 0.06343504f, 0.06332591f, -0.17439310f, 
    -0.03957345f, 0.06522281f, 0.07124982f, 0.04162385f, 0.04388113f, -0.10395417f, 0.10814846f, -0.03525627f, 
    -0.02920742f, 0.06070102f, -0.05182872f, -0.03798561f, 0.01723024f, -0.06365916f, -0.04991713f, 0.02929217f, 
    -0.08695105f, 0.02466490f, 0.05902335f, 0.00878579f, 0.05076598f, 0.07710617f, -0.00284844f, -0.00925671f, 
    0.01674808f, 0.00965842f, -0.01102986f, -0.00804806f, 0.11476198f, -0.05649859f, 0.01910610f, 0.08024412f, 
    -0.21789424f, -0.12865928f, -0.17763822f, -0.13720024f, -0.10452795f, 0.09155124f, 0.03264796f, -0.04531693f, 
    -0.04785927f, 0.01402103f, 0.00892662f, -0.00044388f, -0.06954472f, 0.02818147f, 0.01073403f, -0.05549074f, 
    -0.02122249f, 0.09875359f, 0.05465911f, -0.00792676f, -0.38628444f, -0.18397227f, -0.20882098f, -0.13618034f, 
    -0.05224363f, 0.01760188f, -0.00245887f, -0.13895054f, 0.00002335f, 0.02477892f, -0.00171595f, -0.02536448f, 
    -0.03919730f, -0.01263248f, -0.03884734f, -0.01072514f, -0.01424493f, 0.10406249f, 0.02647508f, 0.10933761f, 
    -0.34441003f, -0.11161561f, -0.14355569f, -0.17738476f, -0.22826500f, 0.03809206f, -0.04749601f, -0.04506398f, 
    -0.02986767f, 0.04567484f, -0.06642531f, 0.02506525f, -0.00503474f, 0.14245616f, 0.03176551f, 0.03675204f, 
    -0.05766957f, 0.01387539f, -0.05990399f, -0.03112861f, 0.09251014f, 0.07664799f, -0.04573972f, 0.03142449f, 
    0.01975561f, -0.06025352f, -0.05674667f, 0.03457535f, 0.04870442f, -0.01857800f, -0.00829485f, 0.02347824f, 
    0.00529689f, 0.00405313f, -0.02497643f, -0.00636858f, -0.00628735f, 0.06638096f, -0.01947527f, -0.01762271f, 
    -0.42396757f, -0.16298994f, -0.22216421f, -0.07168239f, -0.07531091f, 0.03929896f, 0.02238517f, -0.14995585f, 
    -0.00388552f, -0.05557072f, -0.00557721f, -0.10193339f, 0.01433030f, -0.16792375f, 0.06670136f, 0.00197973f, 
    -0.04358012f, 0.01893953f, 0.03863676f, -0.07052086f, -0.26808375f, -0.13111743f, -0.05254728f, -0.13439254f, 
    0.02811027f, 0.04249619f, -0.00142225f, -0.01749669f, 0.02872595f, 0.01500076f, 0.03795617f, 0.05978891f, 
    0.03405510f, 0.02887165f, -0.02055214f, 0.01146989f, 0.01811065f, 0.05233433f, 0.07859466f, 0.06321211f, 
    -0.21408163f, -0.08380795f, 0.01573301f, -0.01920336f, 0.05020990f, 0.06525245f, 0.12094507f, 0.07017214f, 
    0.02541766f, -0.07771917f, 0.13184415f, 0.02042333f, 0.00957881f, -0.07389598f, 0.10049848f, 0.04038668f, 
    0.01421430f, -0.04503798f, 0.08924828f, -0.01361291f, -0.02966162f, 0.01812545f, 0.09881034f, 0.09208685f, 
    -0.03771364f, 0.03931547f, -0.03016279f, 0.07896457f, 0.01958278f, 0.01383442f, 0.03610555f, 0.03089859f, 
    0.02381431f, -0.01592975f, -0.01645798f, -0.01772626f, -0.04849445f, -0.02691280f, 0.07934450f, -0.04624894f, 
    0.14781818f, 0.01301401f, -0.02286435f, 0.02653229f, 0.06638653f, 0.03993135f, -0.02162878f, -0.08554101f, 
    0.01504629f, 0.03585293f, -0.01370206f, 0.05874310f, 0.04038960f, 0.00699240f, -0.02689641f, 0.06472246f, 
    0.03331817f, -0.08542882f, -0.12345608f, 0.04665888f, -0.13980146f, -0.11654574f, -0.01325133f, 0.01137165f, 
    0.11507059f, 0.05272729f, 0.05706086f, 0.04676550f, -0.02966551f, -0.03746122f, 0.06625129f, -0.00155701f, 
    0.01871479f, -0.04677024f, 0.00798848f, 0.05532406f, 0.00153611f, -0.06928920f, 0.11187720f, 0.07653289f, 
    0.28278166f, -0.11359868f, -0.05580655f, -0.06480684f, -0.05914906f, 0.10156512f, -0.00088359f, -0.03256812f, 
    0.03087705f, -0.00366010f, 0.05033217f, 0.06075761f, 0.00296292f, 0.03376576f, -0.00386602f, 0.04777086f, 
    -0.02778556f, -0.02311842f, -0.00695189f, 0.07226967f, 0.22738059f, -0.26040086f, -0.08113668f, -0.07047745f, 
    -0.04274035f, -0.00976800f, -0.03334727f, 0.00830387f, 0.04894456f, 0.06907030f, 0.01855340f, -0.01246671f, 
    0.01310916f, 0.01278940f, -0.01215328f, 0.08584126f, 0.01207995f, -0.05699383f, 0.03802316f, -0.10847746f, 
    -0.19139034f, 0.18544836f, -0.00998109f, -0.06112246f, -0.10100703f, 0.00695774f, 0.06054902f, 0.02612204f, 
    0.05679705f, -0.01640562f, -0.01351867f, -0.04681543f, -0.03968490f, -0.06705920f, 0.09747165f, 0.09106910f, 
    0.01655926f, -0.05377147f, -0.03276023f, 0.00264697f, 0.10811969f, 0.13112032f, -0.15086953f, -0.04453121f, 
    -0.16984275f, 0.01423579f, -0.00799249f, -0.00625808f, -0.00338789f, 0.05915698f, 0.03470009f, -0.00260507f, 
    -0.01062214f, -0.00540043f, 0.05126638f, -0.06514487f, -0.01854593f, 0.02760142f, -0.03649362f, 0.05622018f, 
    -0.13703015f, -0.01089103f, -0.01170052f, -0.02652925f, 0.01023508f, 0.03489900f, 0.02002438f, -0.01411415f, 
    0.02829077f, 0.07907228f, -0.05258956f, -0.03364058f, 0.05479175f, -0.00538202f, -0.00332828f, -0.06330073f, 
    -0.05293765f, 0.01881702f, -0.06721922f, 0.00963902f, -0.13601358f, -0.23496823f, -0.05220070f, -0.07088576f, 
    -0.02497929f, -0.03589141f, 0.00998270f, 0.08127414f, -0.01867318f, 0.04746770f, -0.03863301f, 0.03918054f, 
    -0.03471672f, -0.01900961f, -0.03295479f, -0.04273831f, -0.00896387f, -0.07988910f, 0.02055263f, -0.07252830f, 
    -0.10456064f, -0.21846063f, -0.09807210f, -0.12552376f, -0.17798634f, 0.03514662f, -0.00589618f, 0.03446431f, 
    -0.00074250f, 0.09189848f, -0.00448598f, 0.00402671f, -0.00096498f, -0.09891081f, -0.02299627f, -0.03153383f, 
    0.02270545f, -0.02772120f, -0.03588181f, -0.02276125f, -0.31423154f, 0.20940439f, -0.01827691f, -0.17459585f, 
    0.28908756f, 0.06896653f, -0.14247701f, 0.06713655f, 0.06466151f, 0.09827741f, -0.01413655f, 0.07785521f, 
    0.04654504f, -0.00363876f, -0.00760689f, 0.01721346f, 0.05932384f, -0.02461142f, -0.06304953f, -0.06091888f, 
    0.00043941f, 0.05012373f, -0.05313905f, 0.05864160f, -0.16278005f, -0.09197635f, -0.00584628f, -0.01883325f, 
    -0.03750833f, -0.03904255f, -0.06977320f, 0.01084927f, 0.01854642f, 0.02567200f, 0.01208293f, 0.07795525f, 
    0.04826646f, 0.01002064f, 0.00162875f, -0.06924558f, 0.29626465f, 0.10431752f, -0.16313694f, 0.04476927f, 
    0.01114351f, 0.04521771f, -0.00740593f, -0.08352126f, -0.03550757f, -0.01055461f, 0.10268179f, 0.04010650f, 
    0.03662203f, 0.06992590f, 0.00746377f, 0.05388565f, -0.00592573f, 0.05565679f, 0.01136067f, 0.10510007f, 
    0.06150456f, -0.07323049f, -0.04360316f, 0.04304065f, 0.04485372f, 0.02991376f, -0.01858085f, 0.01852354f, 
    0.07595357f, -0.00882157f, 0.09852137f, -0.19264460f, -0.09145905f, 0.11136352f, -0.03921480f, 0.00402893f, 
    -0.05439857f, 0.06735371f, 0.12297103f, -0.02475668f, -0.12590303f, 0.10515667f, -0.01753931f, 0.05172210f, 
    -0.04603560f, 0.03624382f, -0.08513217f, 0.03404570f, -0.00544518f, -0.02454153f, -0.00563296f, -0.06013613f, 
    0.05854628f, -0.06305387f, 0.02114491f, -0.02645694f, 0.01210259f, 0.03227482f, -0.04299528f, -0.00615124f, 
    0.25232157f, 0.20770951f, -0.14976346f, -0.15456653f, 0.07078644f, 0.04365211f, -0.03741577f, -0.05311221f, 
    0.07094229f, 0.02114712f, 0.09038424f, 0.03354568f, -0.02748697f, -0.03088406f, 0.02462451f, 0.02072490f, 
    -0.01335530f, 0.05313096f, -0.01521566f, 0.08272654f, -0.14193134f, 0.08606464f, -0.01596653f, -0.07381181f, 
    -0.28321239f, 0.15256409f, 0.07074429f, 0.02964933f, 0.01010298f, -0.01004880f, 0.01263104f, -0.00944409f, 
    0.03550931f, -0.05687186f, -0.02282793f, -0.05755901f, 0.02557534f, 0.02290234f, -0.00546789f, 0.01012955f, 
    -0.42305726f, -0.11204910f, 0.05409812f, -0.06391441f, -0.00340818f, -0.07245326f, 0.08976381f, -0.02996700f, 
    0.04078759f, -0.04274057f, -0.10215717f, 0.02955129f, 0.02880932f, 0.07404393f, 0.01976494f, -0.06087922f, 
    -0.01711933f, -0.03369085f, -0.16995743f, 0.00895652f, 0.06397326f, 0.15180926f, -0.02922931f, -0.08317788f, 
    -0.01954685f, 0.04395614f, 0.09745587f, 0.05904989f, 0.06003449f, 0.08866599f, 0.01522174f, 0.00607840f, 
    -0.01188798f, -0.08983527f, 0.05763140f, 0.02387807f, -0.05399308f, -0.07139963f, 0.01666378f, -0.09817361f, 
    -0.37864208f, 0.07407059f, 0.07333909f, 0.01818781f, 0.13707876f, 0.03053810f, 0.06218747f, -0.00310152f, 
    0.02435748f, -0.00861420f, 0.00987273f, -0.03217835f, -0.01124674f, 0.03959987f, -0.02960326f, -0.10546046f, 
    -0.01326903f, -0.02705022f, -0.05705848f, 0.00438301f, -0.48774529f, -0.14369956f, -0.16226043f, -0.11375055f, 
    -0.01048259f, 0.03008797f, -0.05470862f, 0.05439879f, 0.03454569f, 0.08375043f, -0.06845950f, 0.01364318f, 
    -0.04617684f, 0.04605792f, -0.04840850f, 0.03111218f, -0.00484772f, -0.02244379f, -0.10637917f, -0.05579615f, 
    0.01032831f, -0.06957147f, 0.05481439f, 0.10905617f, 0.08646490f, -0.04652807f, 0.11688591f, 0.08090784f, 
    -0.04264435f, -0.07444760f, 0.06231052f, -0.04868004f, -0.11015075f, 0.05397658f, 0.03459575f, 0.04059419f, 
    0.03564783f, -0.02569818f, 0.07695701f, 0.00808582f, 0.12777114f, -0.02430527f, 0.01907569f, 0.02470347f, 
    -0.06402208f, -0.07329909f, -0.00108560f, 0.01102382f, -0.07842863f, -0.11634619f, -0.06727784f, -0.01565644f, 
    0.02234438f, 0.00978757f, -0.10572574f, -0.02561029f, -0.02053673f, -0.02449192f, -0.00720411f, 0.01875058f, 
    0.08557294f, 0.14490919f, -0.05261658f, -0.02675385f, -0.01111553f, 0.00947976f, -0.05697059f, 0.01035432f, 
    -0.12174346f, -0.09971508f, 0.00025945f, 0.00522025f, 0.08291803f, 0.00038530f, -0.03573089f, 0.03837822f, 
    0.07723664f, -0.04559678f, -0.04447458f, -0.03793454f, 0.09389199f, 0.13872196f, -0.11814995f, 0.06897441f, 
    0.33967414f, 0.10164496f, -0.06005943f, 0.01139213f, 0.03178801f, -0.02641181f, 0.01344433f, 0.02055896f, 
    0.06284451f, 0.01766284f, -0.01090888f, -0.03692510f, 0.07271358f, 0.06297865f, 0.07923711f, -0.04496582f, 
    0.08990077f, 0.02877118f, -0.00929421f, -0.14609899f, -0.05989269f, -0.07905174f, -0.05669723f, 0.05174499f, 
    -0.09529984f, -0.05931607f, 0.05454398f, -0.07198215f, -0.01713439f, -0.05507927f, -0.10052831f, 0.00733014f, 
    -0.07719264f, 0.00294708f, 0.09928946f, -0.03136443f, 0.38433701f, 0.03623501f, -0.18633519f, 0.04325287f, 
    -0.13450947f, -0.04974559f, -0.04143456f, 0.02691157f, -0.02392532f, 0.04240384f, 0.04999680f, -0.04125390f, 
    0.05277268f, -0.04840410f, -0.12618800f, -0.00141829f, -0.03767996f, 0.00711937f, -0.01177301f, -0.02517363f, 
    0.39089519f, 0.07120262f, -0.16477489f, 0.04306273f, 0.06383252f, 0.00093731f, -0.05728227f, -0.00626217f, 
    0.00849178f, 0.04940285f, 0.02365628f, 0.05276546f, -0.04427218f, 0.03047283f, 0.04374166f, 0.00816255f, 
    0.01879087f, -0.00676147f, -0.00937080f, 0.03422524f, 0.10412911f, -0.04857770f, 0.01883562f, 0.09330298f, 
    -0.03436254f, 0.05215254f, 0.07922111f, 0.06645464f, -0.04864346f, 0.04439831f, 0.00460697f, 0.04572407f, 
    0.03175541f, -0.00359965f, -0.06661370f, -0.08071107f, -0.03802496f, -0.05881983f, -0.05777350f, -0.00444058f, 
    0.15880355f, -0.16095132f, 0.01178314f, -0.02642293f, 0.04470252f, 0.02927674f, 0.03664486f, -0.03754520f, 
    -0.01102432f, -0.04197907f, 0.04093915f, -0.04110129f, -0.06835356f, 0.03355377f, 0.03649146f, -0.02843629f, 
    0.01588053f, -0.02342048f, 0.02148344f, -0.04954486f, -0.12581898f, 0.09030059f, -0.06780884f, -0.13461132f, 
    0.23975275f, 0.04217259f, -0.09252303f, 0.02202521f, -0.01757232f, -0.03141784f, -0.03281023f, -0.04016802f, 
    -0.01551953f, -0.02055003f, 0.09487391f, 0.01172526f, 0.02843831f, 0.01489018f, 0.09688700f, -0.00218730f, 
    -0.03007574f, 0.06274972f, 0.05095548f, -0.03154267f, 0.06174483f, -0.04482120f, -0.00200036f, -0.02465789f, 
    0.02513431f, -0.07445296f, -0.05020993f, 0.02379909f, -0.01868543f, 0.01757323f, 0.02139620f, -0.03696592f, 
    -0.06519052f, 0.01673803f, -0.08066453f, -0.07278423f, 0.07280445f, -0.20308825f, 0.00390460f, -0.03182188f, 
    0.04603964f, -0.05742040f, -0.05557025f, -0.00146340f, -0.00171080f, 0.00273779f, -0.02724692f, -0.00587975f, 
    0.01336956f, -0.00217864f, -0.03902446f, 0.00940239f, 0.04792096f, 0.02723698f, 0.05129031f, -0.03350569f, 
    -0.14477468f, -0.00658855f, -0.08954625f, -0.20085718f, 0.24317433f, 0.02697594f, -0.11999778f, -0.00121386f, 
    0.06614569f, -0.10063314f, 0.02072102f, -0.06996287f, 0.00316773f, 0.09417153f, 0.07294721f, -0.00449235f, 
    -0.01975402f, -0.04612470f, 0.10105574f, 0.06091147f, -0.12314238f, -0.18372276f, -0.04317093f, 0.00055324f, 
    -0.09706898f, 0.01678631f, -0.01067194f, 0.04735162f, -0.02144202f, 0.02088974f, -0.06391308f, -0.03166932f, 
    0.00889225f, -0.03828036f, -0.05485149f, -0.11578769f, -0.00497339f, -0.01890058f, -0.08754178f, 0.02113912f, 
    -0.17790112f, 0.13510235f, 0.00558869f, 0.00213472f, -0.02438198f, 0.02443415f, -0.00921755f, 0.09074439f, 
    -0.10259357f, 0.05456045f, -0.08150742f, -0.01551445f, 0.06144559f, -0.09518582f, -0.06499919f, 0.02345084f, 
    0.05125175f, -0.05707280f, 0.02313240f, -0.04642318f, 0.04924111f, 0.09405782f, -0.09808827f, -0.06615046f, 
    0.07691262f, -0.00209547f, -0.12742282f, -0.04333830f, -0.03299809f, -0.10563340f, -0.04054295f, 0.03713383f, 
    0.02231095f, 0.02798418f, -0.03805416f, 0.03626768f, 0.02786988f, 0.08428021f, 0.08256819f, -0.05322120f, 
    -0.01620782f, 0.20817986f, -0.03066966f, 0.05372602f, 0.07755192f, 0.07263720f, -0.13703838f, 0.05040346f, 
    0.10917694f, 0.05789908f, 0.07448549f, 0.02267770f, 0.02466093f, -0.01833266f, 0.01043157f, -0.03439466f, 
    0.11936156f, -0.03490070f, -0.04665198f, 0.02263439f, -0.01690510f, 0.05507112f, -0.17768581f, -0.05945606f, 
    0.11754910f, -0.04984303f, -0.00470649f, -0.03885448f, 0.02121637f, -0.01165460f, 0.09516516f, 0.04730474f, 
    -0.04780645f, -0.01272125f, -0.01358472f, -0.01932517f, 0.02285735f, 0.08373044f, 0.07532217f, 0.01991885f, 
    0.28692219f, 0.06169454f, -0.05849592f, -0.16643728f, 0.12499694f, -0.03090735f, 0.03944945f, 0.05162840f, 
    0.03575317f, -0.07996391f, 0.07647070f, -0.08870183f, -0.08064368f, 0.02178826f, 0.01514960f, 0.00086472f, 
    -0.06840070f, -0.00181864f, 0.02619502f, 0.08368777f, -0.36856732f, -0.12652633f, -0.09952670f, 0.00437492f, 
    -0.29778159f, 0.07702228f, 0.07394423f, 0.00962656f, 0.04372833f, 0.04267852f, -0.07029895f, -0.05048798f, 
    -0.01041693f, -0.04393035f, 0.02432897f, -0.09481321f, -0.02351153f, -0.07278056f, -0.06229709f, 0.00448767f, 
    -0.03049488f, -0.13994946f, -0.10991132f, -0.08469792f, -0.04373721f, 0.05778834f, -0.04789766f, 0.02605822f, 
    0.02725668f, 0.10337906f, 0.04039388f, 0.05126986f, -0.02385097f, 0.01306557f, 0.03415431f, 0.02694380f, 
    0.01026483f, -0.01575513f, -0.00471959f, -0.07816750f, -0.00263072f, -0.21509480f, 0.07857664f, -0.08030283f, 
    0.00975157f, -0.01422733f, 0.11205276f, 0.02053024f, 0.07409023f, 0.03292203f, -0.05958575f, 0.00194943f, 
    0.05949003f, 0.00714486f, -0.10232081f, -0.09082475f, -0.10543297f, -0.08732275f, -0.08807771f, -0.01882399f, 
    -0.14856075f, -0.04447537f, 0.00539494f, 0.07867004f, -0.03713648f, -0.10282003f, 0.04408928f, -0.01979122f, 
    0.06572378f, -0.04122692f, -0.01468901f, -0.05654675f, 0.05060211f, 0.11557881f, 0.01612566f, 0.03095457f, 
    0.04452868f, -0.06061207f, 0.00283457f, 0.04427154f, 0.23763239f, 0.05298183f, -0.09783989f, 0.05174335f, 
    0.15713455f, -0.02869910f, -0.03106977f, -0.00208702f, 0.05735084f, 0.07851862f, 0.00061756f, 0.05049067f, 
    -0.02373943f, 0.01052854f, 0.00724735f, 0.03086630f, 0.02812819f, 0.01467767f, 0.00754477f, -0.02361353f, 
    -0.21918149f, 0.28373158f, -0.10311966f, 0.10055429f, 0.05521651f, 0.12022617f, 0.01538204f, -0.00602991f, 
    -0.02943829f, -0.00169616f, 0.05445456f, 0.07202461f, -0.01294205f, -0.03886548f, 0.09908404f, -0.00787564f, 
    0.10152732f, -0.02638849f, -0.04634639f, -0.00233405f, -0.15896943f, -0.12187446f, -0.03022253f, -0.00386720f, 
    -0.03207338f, -0.00525632f, -0.01684147f, 0.07464774f, 0.02738824f, 0.08852841f, -0.04568190f, 0.05373676f, 
    -0.03913353f, -0.00835112f, -0.03682199f, -0.03413010f, -0.02762916f, -0.00212728f, -0.11109450f, -0.07458101f, 
    -0.12956090f, -0.01683798f, -0.01015341f, -0.03597380f, -0.09885967f, -0.07003721f, -0.03113106f, 0.01295122f, 
    0.04145061f, -0.10013081f, -0.09662699f, 0.01815147f, 0.00394564f, 0.03315935f, -0.00871961f, -0.08788962f, 
    -0.09724658f, -0.03327874f, -0.03616027f, 0.00291786f, 0.02041474f, -0.10368927f, -0.01683502f, -0.14927699f, 
    0.09114030f, 0.08869571f, -0.05924322f, -0.03063660f, 0.09496354f, 0.06425132f, -0.00052166f, -0.01750376f, 
    0.06032306f, 0.03650221f, 0.05584868f, 0.06354976f, 0.03369105f, 0.06292196f, -0.02200088f, -0.04469792f, 
    -0.08809944f, 0.07903931f, -0.01389815f, 0.01382656f, -0.00422283f, 0.01596338f, -0.03992399f, 0.03445870f, 
    -0.08384961f, 0.00608574f, 0.00605238f, -0.04129101f, 0.06147400f, -0.06546579f, -0.01358458f, 0.00766584f, 
    0.00946450f, -0.01915281f, -0.06785377f, -0.05195983f, -0.19216663f, 0.23574547f, -0.06944985f, -0.18656582f, 
    0.04982866f, -0.13550605f, -0.02230759f, 0.02084316f, -0.15900312f, 0.02499763f, 0.01392911f, -0.01309513f, 
    0.02263005f, -0.12612115f, 0.03211263f, 0.01219001f, -0.07975785f, -0.08160710f, 0.03450399f, -0.04568633f, 
    0.09226842f, 0.11214139f, -0.06626089f, 0.03443375f, -0.01247445f, -0.01708461f, 0.03222661f, -0.02545445f, 
    0.01773222f, 0.00435973f, -0.09004325f, 0.04310677f, 0.08936380f, 0.01754990f, 0.01193111f, 0.08569203f, 
    -0.03847997f, 0.01057120f, -0.01163265f, -0.07144637f, 0.00753071f, 0.01191243f, 0.03385636f, 0.08394314f, 
    0.09501111f, -0.04878182f, 0.05374513f, 0.05875800f, 0.02708458f, -0.04077747f, 0.00531347f, -0.05085868f, 
    -0.00557672f, 0.07653075f, 0.00746828f, 0.03838158f, 0.03169835f, 0.01294575f, -0.04585194f, 0.03266278f, 
    0.15334351f, 0.08562912f, -0.08110549f, -0.07189851f, -0.08358832f, 0.02153021f, -0.04892687f, 0.05001537f, 
    -0.00140954f, -0.01116179f, 0.06909215f, -0.00540701f, -0.10905139f, 0.01545030f, -0.04879494f, 0.01803979f, 
    -0.02934330f, 0.04111646f, 0.00156805f, 0.02014897f, -0.15911920f, 0.17426558f, 0.05058914f, -0.08484408f, 
    -0.05311158f, -0.02460524f, -0.01015459f, -0.05790749f, -0.06570755f, -0.04497896f, -0.01429289f, 0.00440109f, 
    0.00764633f, -0.06301567f, 0.02420075f, -0.01573696f, 0.00352632f, -0.05334334f, 0.01479158f, 0.02724441f, 
    -0.45768946f, 0.02627626f, -0.01518927f, 0.11780202f, 0.07458064f, -0.08830509f, 0.08067078f, -0.02377907f, 
    0.04693708f, -0.08578024f, -0.04539397f, 0.01220940f, 0.08047166f, 0.10197486f, 0.08703101f, 0.03442061f, 
    -0.03542754f, -0.00848914f, -0.04474112f, -0.06022345f, -0.04548187f, 0.06697324f, -0.05405785f, -0.04382205f, 
    0.13712056f, 0.12502581f, -0.03997875f, -0.03685025f, 0.00009754f, -0.00440418f, 0.03764972f, 0.09054251f, 
    0.00504110f, -0.01671090f, 0.00211243f, -0.01008479f, 0.06861947f, 0.02733290f, -0.01778551f, 0.01196041f, 
    0.05059123f, -0.20887274f, -0.11304989f, -0.02714147f, -0.16582021f, -0.01267522f, 0.02381048f, 0.05042680f, 
    0.00940824f, 0.05979771f, -0.01332061f, 0.02715944f, 0.01950337f, -0.02375955f, 0.00565242f, -0.00583034f, 
    -0.01203124f, -0.04920767f, -0.05977416f, -0.03609433f, 0.08071536f, -0.07579624f, -0.13704191f, -0.03927678f, 
    0.00864936f, -0.01292732f, -0.03232945f, -0.01105340f, 0.03743360f, 0.06458887f, 0.01390609f, -0.02394603f, 
    0.01771733f, -0.07961472f, 0.00725436f, -0.01263896f, -0.04940546f, -0.09234260f, 0.00039636f, 0.01473396f, 
    0.42644197f, 0.03795696f, -0.24485567f, -0.03334197f, -0.11135353f, -0.04925966f, 0.04414881f, -0.00837890f, 
    0.01667131f, 0.00900691f, 0.11868258f, 0.00494712f, 0.02021134f, 0.02467904f, 0.02566470f, 0.00004019f, 
    -0.04887723f, -0.03540269f, 0.00155284f, -0.00311425f, -0.18995139f, 0.07447138f, 0.03577143f, -0.02870805f, 
    0.04727403f, -0.05263535f, 0.02808656f, 0.03861506f, 0.01476501f, -0.05657538f, -0.02076088f, -0.00536357f, 
    0.08260608f, -0.00081442f, -0.02794475f, -0.07988545f, -0.06380304f, -0.01298616f, -0.09821374f, 0.02204272f, 
    -0.14082968f, -0.29269892f, -0.10118976f, 0.01287873f, -0.27393728f, 0.05168694f, 0.05895148f, 0.00718203f, 
    0.04012669f, -0.02611249f, -0.07966810f, -0.11809308f, -0.03687608f, 0.04151108f, 0.07430205f, -0.01476933f, 
    0.04093369f, -0.00581587f, -0.06222776f, -0.07095654f, 0.21967381f, -0.20618291f, 0.03879860f, -0.00148642f, 
    0.00196090f, 0.03253179f, 0.02480266f, -0.04410083f, -0.04840295f, -0.02663175f, 0.07461285f, -0.02190364f, 
    0.01728057f, 0.04465172f, 0.04514160f, 0.05153945f, 0.00067008f, -0.04148731f, 0.01483145f, 0.02624228f, 
    0.05311045f, -0.01232594f, -0.09005778f, 0.15551585f, -0.07348399f, 0.09899555f, 0.07671272f, -0.00430046f, 
    -0.00352804f, 0.04740805f, -0.02693716f, -0.01303650f, -0.07604434f, -0.00850120f, -0.01928447f, -0.04562252f, 
    0.07645813f, -0.01299579f, -0.05131770f, -0.00535316f, 0.06419187f, -0.23264156f, 0.01658722f, 0.01399369f, 
    0.02374754f, 0.00838755f, -0.07146439f, 0.02908873f, -0.01793549f, -0.01670755f, -0.07908660f, 0.01433560f, 
    -0.04362048f, -0.02203698f, -0.04949839f, -0.09909993f, 0.04396347f, 0.03485360f, -0.02028828f, -0.02085894f, 
    0.01889048f, 0.08616051f, -0.13730451f, 0.04088553f, -0.09395877f, -0.04432578f, -0.04806685f, -0.00750455f, 
    0.05639982f, -0.07120329f, 0.12189555f, 0.01211404f, 0.01448041f, -0.06988818f, 0.02636328f, 0.07744554f, 
    0.05873306f, -0.00210035f, 0.03834799f, 0.01718264f, 0.09430325f, 0.04410910f, -0.08007638f, 0.12429444f, 
    -0.02723293f, 0.10028509f, 0.01680896f, -0.02274246f, -0.00508013f, -0.07553571f, 0.04241144f, 0.01749564f, 
    0.03705660f, 0.00970517f, -0.03334700f, 0.00351109f, 0.01564283f, 0.02141398f, -0.10489609f, 0.01620232f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02866475f, 0.02469756f, -0.00676009f, -0.01394188f, 0.00257395f, 0.02355798f, 0.00750097f, -0.05451445f, 
    -0.03302639f, 0.01627641f, 0.05514162f, -0.00876859f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
