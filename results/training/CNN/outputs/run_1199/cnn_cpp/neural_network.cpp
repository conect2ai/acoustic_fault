#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.43484756f, -0.50766212f, -0.28998062f, 0.96970189f, 0.21059766f, -0.32385862f, -0.38198423f, -0.15092956f, 
    -0.32266727f, 0.18876354f, 0.25876656f, 0.49970707f, -0.86981791f, -0.54540545f, -0.36576635f, 0.69907522f, 
    -0.17169827f, -0.16042636f, 0.87655032f, -1.18178761f, 0.59415704f, -0.31748131f, -0.27407321f, 0.47335064f, 
    -0.00116414f, -0.00117608f, -0.09691358f, -0.06813620f, 0.04851302f, -0.54949272f, -0.28003764f, -0.29241315f, 
    -0.54745132f, -0.18137476f, -0.52489591f, -0.03002476f, -0.59356916f, 0.28979155f, 0.32993254f, -0.31837353f, 
    0.53825992f, 0.57302451f, 0.00293576f, -0.53254372f, -0.28661615f, -0.33296847f, -0.20432268f, 0.31387976f, 
    -0.58206892f, -0.57438898f, -0.33135998f, 0.28280112f, 0.46133569f, 0.14374071f, 0.36569288f, 0.58429360f, 
    0.42786863f, -0.70578825f, 0.60756856f, -0.41521040f, 0.22869463f, 0.10806622f, 0.52037120f, 0.30344564f, 
    0.33903489f, -0.04853246f, 0.44777620f, -0.48443002f, 0.39942899f, 0.14168680f, -0.49109450f, -0.46514270f, 
    -1.07969272f, -0.54659468f, 0.39183637f, 0.35225213f, -0.45164302f, -0.07366369f, 0.08054588f, -0.41858664f, 
    -0.55890906f, -0.40561122f, 0.08038695f, 0.01811696f, -0.59877688f, -0.29831153f, 0.36709958f, -0.52059019f, 
    -0.08656817f, 0.47498199f, -0.51002491f, 0.20792867f, 0.90892655f, -0.13869789f, -0.39313236f, 0.39338830f, 
    -0.17638002f, 0.04219698f, 0.20869713f, -0.11658811f, -0.46539906f, -0.58089048f, -0.36162636f, -0.36528796f, 
    -0.47916022f, 0.52340293f, 0.39814797f, 0.39903420f, -0.62001526f, 0.00159498f, -0.28563467f, -0.38104275f, 
    1.08047354f, 0.31816930f, 0.22503847f, -0.05249835f, 0.34479767f, -0.41912317f, -0.19473699f, -0.84037453f, 
    0.36211473f, 0.10306635f, 0.24424860f, -0.04887356f, -0.04050834f, 0.23604244f, 0.96968478f, -0.14957485f, 
    -0.64809358f, -0.06603812f, 0.28275675f, -0.04265437f, 0.08859735f, 0.47236457f, 0.43042901f, 0.64188868f, 
    0.64156842f, -0.43599632f, -0.47475737f, 0.24848069f, -0.42844290f, -0.45574057f, -0.05898311f, 0.12502155f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.27616757f, 0.10033671f, 0.00138564f, 0.03931036f, 0.08477550f, -0.14523362f, 0.01876701f, 0.17436083f, 
    -0.03592316f, 0.10467419f, 0.46299639f, 0.16886365f, 0.00355842f, 0.59184444f, -0.21403119f, 0.04386317f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.30585200f, -0.19457443f, -0.39966288f, -0.12337750f, 0.04643819f, 0.31691065f, -0.06776199f, 0.06985743f, 
    0.22182529f, 0.17152992f, 0.21876651f, 0.31723756f, 0.01227404f, -0.05607500f, -0.11190102f, 0.09919135f, 
    0.07923938f, 0.03650222f, 0.25704703f, -0.25618890f, -0.02262542f, 0.17302158f, 0.19758877f, -0.04115482f, 
    0.17933898f, -0.12370934f, 0.07084341f, 0.06663989f, 0.10546656f, 0.11093323f, -0.01986793f, -0.10085218f, 
    0.00328978f, -0.05868772f, 0.02358886f, 0.15163691f, 0.18397063f, 0.09750884f, -0.17834046f, -0.03672670f, 
    0.00495205f, 0.16776817f, -0.07558567f, 0.13360789f, 0.22814415f, -0.12933978f, -0.52371514f, 0.12337970f, 
    0.25021911f, -0.10844536f, -0.11097642f, 0.10083102f, -0.02364163f, 0.15698645f, 0.12281068f, 0.06335283f, 
    0.06144390f, 0.13474679f, -0.02993776f, -0.15580295f, -0.15621454f, 0.20242400f, -0.16378087f, 0.07506955f, 
    0.04380778f, 0.11373803f, -0.00097433f, -0.09663230f, 0.06252871f, 0.17307511f, 0.10850457f, 0.13525352f, 
    0.03229354f, -0.06476022f, -0.08485904f, 0.05160138f, -0.05040127f, 0.38427201f, -0.01706758f, -0.00049682f, 
    0.09596303f, 0.02265849f, -0.15815251f, 0.32333109f, 0.04301498f, 0.04405245f, 0.03047320f, 0.00778868f, 
    -0.00149115f, -0.00706895f, 0.47595254f, 0.15587413f, 0.06333446f, 0.02865759f, -0.00202923f, -0.02098541f, 
    0.14172865f, 0.12515697f, -0.31014600f, -0.03767069f, -0.32656580f, -0.20051442f, 0.09513858f, -0.03737510f, 
    -0.23118103f, 0.01898544f, 0.07215764f, -0.09588154f, 0.08375416f, -0.27271241f, -0.17682222f, -0.01461058f, 
    -0.03715613f, -0.00474186f, -0.32866648f, -0.01049797f, -0.15553685f, -0.05329391f, -0.41430607f, -0.02892164f, 
    0.13070066f, 0.06463091f, 0.04976602f, -0.18297830f, 0.14861204f, 0.01287700f, -0.22765988f, -0.02583998f, 
    0.01238484f, -0.13992791f, -0.10014629f, -0.07934675f, -0.15015763f, -0.02232012f, -0.17056212f, 0.18808356f, 
    0.36501810f, 0.42667639f, -0.20270044f, 0.36091796f, 0.03615208f, 0.01576135f, 0.05984258f, -0.15114853f, 
    0.12986809f, 0.24514791f, 0.54085010f, -0.00409818f, -0.05028113f, -0.30095822f, 0.09924655f, 0.00578717f, 
    -0.17136882f, -0.39335778f, -0.15797080f, 0.10689406f, -0.17286655f, -0.05161412f, 0.08250087f, -0.16471665f, 
    -0.01371393f, 0.29082310f, 0.28208908f, 0.38121963f, -0.39444149f, -0.26614341f, 0.08864529f, -0.08555418f, 
    0.07162265f, 0.17618415f, 0.18313286f, -0.22319397f, -0.14355099f, 0.11263307f, 0.04270066f, 0.02486377f, 
    -0.24050193f, 0.05237769f, 0.02114908f, 0.11165360f, -0.05830441f, -0.08126984f, -0.04472450f, 0.29702392f, 
    -0.05442995f, 0.03926355f, 0.11510186f, -0.14771931f, 0.09399327f, -0.23945414f, -0.45835698f, -0.10375369f, 
    0.05116513f, -0.05767111f, -0.05326217f, -0.11973365f, 0.03233413f, 0.03768216f, -0.72845089f, -0.62003207f, 
    0.15635222f, -0.01604017f, 0.02928087f, -0.28695962f, -0.16445602f, -0.08508548f, 0.17283525f, -0.04281594f, 
    0.01324542f, -0.06929733f, -0.01357240f, -0.02730264f, 0.09500588f, 0.11154693f, -0.10715754f, 0.31233585f, 
    0.17138444f, 0.13465501f, 0.06645746f, -0.09086773f, 0.11291315f, -0.12038729f, -0.12307202f, 0.04657619f, 
    -0.25320125f, 0.00501816f, 0.01751764f, -0.00622520f, -0.06162450f, 0.06457633f, -0.17068969f, 0.12922937f, 
    0.09158403f, 0.14770164f, 0.27137455f, 0.21390763f, -0.09170002f, 0.09176682f, -0.03870153f, -0.03939740f, 
    0.22744371f, 0.38255933f, -0.00551230f, -0.27539188f, -0.13617070f, 0.10276159f, 0.05207672f, 0.19114323f, 
    0.03037817f, 0.10280984f, -0.01437830f, 0.08554450f, -0.20243254f, -0.10195946f, -0.11542598f, 0.12025505f, 
    -0.06872117f, -0.15065841f, 0.20034364f, 0.00717340f, 0.02748384f, 0.32974020f, 0.40557864f, 0.32834187f, 
    0.11334030f, 0.17816208f, 0.10144293f, 0.19925903f, -0.03641348f, 0.06117610f, 0.06748736f, -0.28419554f, 
    -0.28593072f, 0.09330666f, -0.12816037f, -0.12461881f, -0.03196306f, 0.03359002f, 0.06885218f, -0.14434347f, 
    -0.00854939f, 0.18469401f, -0.22811072f, -0.03807182f, 0.04887547f, 0.02487423f, 0.00700218f, 0.10407876f, 
    0.00190648f, 0.03928475f, -0.00870250f, 0.02732288f, -0.04355464f, -0.11355010f, -0.04228989f, -0.09999917f, 
    -0.00925206f, -0.00336583f, -0.11387508f, -0.09559947f, -0.01091104f, 0.04201668f, 0.01858582f, -0.01485420f, 
    0.01378053f, -0.00236297f, -0.08071427f, -0.01131893f, -0.10889924f, -0.05317064f, 0.04907832f, -0.04290944f, 
    -0.03208143f, 0.00615861f, -0.06690595f, -0.05217988f, -0.02756179f, -0.08278331f, 0.01280423f, -0.02152069f, 
    -0.07795052f, 0.06058044f, -0.08267936f, -0.08270030f, -0.05336057f, -0.08955208f, -0.03073487f, 0.03380154f, 
    0.02997367f, 0.00334349f, -0.06872027f, -0.01163788f, -0.02141039f, -0.10059398f, -0.05943121f, -0.01653296f, 
    -0.08413115f, 0.02467997f, -0.06227747f, 0.03411708f, -0.06438728f, -0.00914024f, 0.00820237f, 0.01950241f, 
    -0.06681310f, 0.01117329f, 0.02018402f, -0.08840065f, 0.00508840f, -0.09625331f, 0.00535116f, -0.05359583f, 
    0.04004045f, -0.02891147f, -0.07075222f, 0.01869751f, -0.08984452f, -0.01459788f, -0.08398548f, -0.04659797f, 
    -0.00012709f, 0.04419352f, 0.02191757f, 0.01325561f, -0.10480395f, 0.02225972f, -0.08821917f, 0.05051921f, 
    -0.08409461f, -0.08183126f, 0.01085663f, 0.03325991f, -0.07190827f, 0.03924261f, -0.10704581f, -0.03698710f, 
    -0.04855533f, -0.00957827f, 0.05124153f, -0.04783360f, -0.11249906f, -0.01711437f, -0.09527905f, -0.10381065f, 
    -0.09924711f, -0.02155353f, 0.00077262f, -0.05542900f, -0.02638915f, -0.09564465f, 0.00887476f, -0.03990336f, 
    -0.09192399f, 0.01142205f, 0.04282421f, -0.04328206f, -0.08068635f, 0.05655638f, -0.06167910f, 0.00147955f, 
    -0.04167439f, -0.08014499f, -0.04552136f, 0.02884948f, -0.04060788f, -0.00861748f, -0.01412302f, 0.02521882f, 
    -0.06088689f, -0.10352737f, -0.06680599f, -0.05660110f, 0.03512087f, -0.06982279f, -0.00729862f, 0.04073071f, 
    -0.11112116f, -0.11250430f, 0.01400355f, -0.01058323f, 0.05582802f, 0.02992700f, -0.04681989f, -0.00551669f, 
    0.01104285f, -0.05403123f, 0.01057541f, -0.08417019f, -0.09225643f, 0.01952344f, 0.00961010f, -0.04860127f, 
    -0.04659861f, -0.24599442f, 0.02375198f, -0.21844387f, -0.20844440f, -0.03778878f, 0.13922212f, 0.05309493f, 
    0.08292042f, 0.24155308f, -0.60982949f, -0.60926330f, -0.14170426f, 0.15445569f, -0.07779656f, 0.02323901f, 
    0.10147873f, -0.00290737f, 0.02511713f, -0.35149458f, -0.39060178f, -0.16038452f, 0.01186134f, 0.13719314f, 
    0.06525180f, -0.08887597f, 0.10929980f, -0.14616242f, -0.09800023f, -0.29112053f, -0.02825963f, -0.16532445f, 
    0.02734425f, 0.00128266f, 0.12728478f, -0.02516773f, -0.17899574f, -0.10524453f, 0.00677983f, -0.09922201f, 
    0.09686741f, -0.00470920f, 0.07260609f, 0.07752907f, 0.24462616f, -0.18935028f, -0.33741984f, -0.37612894f, 
    -0.17605089f, -0.00702340f, -0.06475708f, -0.09745027f, -0.07570568f, 0.06910259f, 0.14017633f, -0.36445960f, 
    -0.06544128f, -0.00746581f, 0.00576747f, 0.10298209f, -0.00393232f, 0.06099745f, -0.12561287f, -0.17671466f, 
    -0.02695137f, 0.02344174f, 0.02299263f, -0.03946130f, -0.00603555f, 0.09939370f, 0.03165408f, 0.21436962f, 
    0.01055311f, 0.06986151f, 0.39341965f, -0.06836393f, -0.02733896f, -0.04333854f, 0.00186791f, 0.05156956f, 
    -0.09694187f, -0.49663213f, -0.32329839f, -0.34062204f, -0.04797931f, 0.13678119f, 0.03876553f, 0.08658493f, 
    0.04101517f, 0.05814751f, 0.01261400f, -0.05079589f, -0.09215252f, 0.19751686f, 0.14033158f, 0.23805641f, 
    0.04384761f, 0.17974201f, -0.04410669f, -0.28201658f, 0.31938165f, -0.04769066f, 0.00197675f, 0.10606054f, 
    -0.02845767f, 0.01848819f, -0.03750709f, 0.10520527f, -0.40718555f, -0.11936709f, 0.05865948f, -0.15306033f, 
    0.16076779f, -0.22013964f, 0.12689912f, 0.12509494f, 0.04159878f, 0.00159110f, 0.48572364f, 0.47314134f, 
    0.14633712f, 0.06880891f, 0.25781602f, 0.02050916f, 0.21848984f, 0.22011955f, 0.30504391f, 0.17782834f, 
    -0.31824788f, -0.16195476f, -0.12191467f, -0.07443830f, -0.02630877f, 0.11163419f, 0.02142639f, -0.06470519f, 
    -0.58472687f, -0.39557171f, 0.05370570f, 0.16793853f, -0.10446621f, 0.02448345f, -0.05075863f, 0.04268322f, 
    -0.05508624f, -0.02832139f, 0.14352123f, -0.10919310f, -0.03119338f, -0.18592943f, -0.08349335f, -0.12587792f, 
    0.08749956f, 0.07163378f, -0.25063711f, -0.34636346f, 0.09593022f, 0.00266088f, 0.07569225f, -0.01879154f, 
    0.09584261f, 0.02228502f, 0.62468833f, 0.07917889f, -0.24977894f, -0.03733160f, 0.04858503f, 0.31027970f, 
    0.07668620f, -0.01311014f, -0.03055686f, -0.15199745f, -0.16713320f, -0.55150002f, 0.09374961f, 0.12504822f, 
    0.04856734f, 0.01962015f, 0.17782535f, 0.04020336f, 0.02204546f, 0.25234374f, -0.22034162f, 0.00975222f, 
    -0.00146783f, 0.00294632f, -0.23959842f, 0.12112125f, 0.21719612f, -0.20067815f, -0.24929525f, -0.07459786f, 
    -0.06794405f, -0.03645126f, 0.02711321f, -0.23792225f, -0.13147402f, -0.16725680f, 0.28279883f, 0.00599698f, 
    0.10169063f, 0.14026377f, 0.14967553f, -0.16360052f, -0.14499019f, 0.10027411f, -0.01370042f, -0.12257639f, 
    0.14526841f, 0.06712518f, -0.12276816f, 0.04734596f, -0.11550961f, 0.09688170f, 0.07133065f, 0.11440197f, 
    -0.07277456f, 0.15147719f, -0.41797236f, 0.07911289f, 0.03062771f, 0.09351390f, -0.05399588f, 0.05021698f, 
    0.09175291f, 0.18573508f, -0.29987851f, -0.14713694f, -0.13354735f, 0.08829463f, 0.08565649f, 0.03570976f, 
    -0.06338929f, -0.02340556f, -0.00647226f, 0.03585090f, 0.39410427f, 0.13997668f, 0.18245453f, 0.08696737f, 
    0.21165572f, -0.17078890f, 0.06863104f, -0.14943184f, 0.21612184f, -0.15354468f, -0.13187483f, 0.14869785f, 
    -0.04466142f, 0.00335396f, 0.04834117f, -0.00458222f, -0.08464681f, -0.17633899f, 0.02162904f, -0.13060011f, 
    0.17328453f, -0.00557317f, 0.18448555f, -0.16099624f, -0.27109331f, -0.15431105f, 0.01370294f, -0.16626230f, 
    -0.00529003f, 0.16395332f, -0.22165230f, 0.10327791f, 0.00296792f, 0.02943477f, 0.25159398f, -0.07118243f, 
    -0.06626373f, 0.02963928f, -0.02859820f, -0.09924562f, 0.01997995f, -0.02679834f, -0.20376354f, 0.00038221f, 
    -0.29263303f, 0.04532369f, -0.03696804f, 0.00822669f, 0.11303140f, 0.05581183f, -0.05042383f, 0.02341647f, 
    0.09355072f, -0.11250044f, -0.83100796f, -0.26449630f, -0.19595073f, 0.06592429f, 0.01996640f, -0.12790404f, 
    0.06772554f, 0.17163822f, 0.22382025f, -0.01930274f, -0.02803507f, -0.06798226f, 0.06456509f, -0.07360948f, 
    0.17373236f, 0.06580058f, 0.62169397f, -0.24628851f, 0.04701497f, -0.13657428f, -0.20541796f, -0.08681074f, 
    0.04626765f, 0.11150204f, 0.00966592f, -0.03938096f, 0.00227811f, -0.04465229f, -0.19458981f, -0.35183263f, 
    -0.01038830f, 0.06826558f, -0.07883876f, 0.17684102f, -0.08290672f, -0.14183185f, -0.06409578f, -0.09856692f, 
    -0.00822128f, 0.03597976f, 0.08951312f, 0.05882099f, 0.17717153f, -0.03270567f, -0.31244874f, -0.24385729f, 
    -0.09670530f, 0.00767465f, -0.24026093f, 0.04161642f, 0.05640153f, 0.15325542f, -0.06972412f, -0.00370967f, 
    0.14747469f, -0.15273666f, -0.01498226f, -0.06857967f, -0.05133067f, 0.10963766f, 0.08018221f, -0.32128975f, 
    -0.07400963f, 0.10190232f, 0.01298732f, -0.17600769f, -0.03503287f, -0.00192797f, -0.09320883f, 0.07216497f, 
    0.02388109f, -0.16874297f, -0.54482394f, -0.17868435f, -0.26319247f, 0.11249723f, 0.04036366f, 0.00992535f, 
    0.08052374f, 0.11676477f, 0.01605809f, -0.11595915f, 0.08768120f, -0.12396763f, -0.11433754f, 0.13122658f, 
    0.04056210f, 0.10669281f, 0.35213539f, 0.11594984f, 0.27247739f, 0.18832190f, 0.12353376f, 0.21004722f, 
    0.03057697f, 0.02114487f, 0.21518952f, -0.00275543f, 0.00617738f, -0.12286799f, 0.27180317f, 0.08450169f, 
    0.02833230f, 0.02437695f, 0.10288598f, 0.06917781f, -0.35524982f, -0.38081387f, -0.13563679f, -0.16735433f, 
    0.00441313f, -0.08569101f, 0.12880200f, 0.13060284f, -0.07682595f, -0.25428244f, -0.16289355f, -0.46417776f, 
    0.06510273f, 0.35027409f, 0.25401717f, 0.16320170f, -0.01422708f, -0.00604638f, 0.19039558f, -0.39373469f, 
    -0.17948578f, -0.18289188f, -0.10020404f, -0.10388011f, 0.11581323f, -0.03634032f, -0.09268886f, -0.27567703f, 
    -0.12462088f, 0.24427199f, 0.20051625f, 0.16035052f, 0.00058471f, -0.06001640f, -0.07446393f, 0.00420355f, 
    -0.28527132f, -0.06898053f, -0.02348665f, -0.10074577f, -0.12317824f, -0.02882414f, -0.05332504f, -0.02933994f, 
    0.17199141f, 0.17138308f, -0.00196313f, 0.44948986f, -0.13060142f, -0.12649451f, 0.00123747f, -0.18283814f, 
    0.00332016f, -0.23479757f, -0.56979394f, -0.06060239f, -0.01399420f, 0.21250495f, -0.25649485f, 0.00950510f, 
    -0.04263856f, 0.14518383f, -0.09258521f, 0.09666978f, 0.08280344f, 0.16572410f, 0.10671686f, 0.17658192f, 
    0.00319403f, -0.02710482f, 0.00263843f, 0.06607921f, 0.23911820f, 0.08756950f, -0.38072419f, -0.06705485f, 
    -0.18264934f, -0.05263161f, 0.16851746f, 0.02215571f, 0.20482427f, 0.27340373f, 0.29088587f, 0.28379595f, 
    0.08889061f, -0.03835956f, 0.03917487f, 0.03263594f, -0.06498273f, -0.27200344f, -0.01042232f, 0.16882841f, 
    0.03150560f, 0.20607023f, -0.16096875f, 0.13637118f, -0.03904193f, -0.08404338f, -0.27112818f, -0.00082806f, 
    -0.11594422f, -0.09964059f, -0.13286801f, -0.06088983f, -0.00883203f, 0.26690310f, 0.25577140f, 0.22707731f, 
    -0.17113879f, -0.09887955f, 0.15421779f, 0.13723487f, -0.07275824f, 0.00782795f, 0.07978321f, 0.00621283f, 
    0.15823717f, 0.00666677f, 0.01030392f, -0.17946029f, 0.07321797f, -0.03168283f, -0.00787876f, -0.15397650f, 
    0.09483209f, -0.09915382f, -0.22551185f, 0.04810094f, -0.31866974f, -0.04056631f, 0.01994845f, -0.08601122f, 
    0.05599688f, -0.03005516f, -0.03022535f, 0.28084609f, 0.34462935f, 0.33556268f, 0.11125341f, 0.03647476f, 
    -0.24588858f, 0.04295275f, 0.03034081f, -0.16434397f, 0.00107607f, 0.10068772f, 0.14296889f, -0.01077754f, 
    -0.15206793f, -0.19455564f, 0.01843122f, 0.03837639f, 0.09775505f, -0.03370102f, 0.09059513f, 0.14285836f, 
    -0.11279542f, 0.05828372f, -0.00047449f, -0.00206980f, -0.02794220f, 0.07081704f, -0.09624028f, -0.11211950f, 
    0.08227111f, 0.02356312f, 0.11462963f, 0.07306926f, 0.02055952f, 0.05252157f, -0.11175348f, 0.12367233f, 
    0.12658638f, 0.09395853f, 0.09747018f, -0.06339759f, -0.01537587f, 0.14595751f, 0.06427550f, -0.12072475f, 
    -0.19206451f, 0.43466964f, -0.40334731f, -0.06344436f, -0.09048882f, 0.15131450f, -0.07951922f, 0.19041184f, 
    0.04505051f, -0.03133630f, -0.43144831f, 0.09357098f, -0.15796161f, 0.10004546f, -0.00782852f, -0.05644506f, 
    -0.07692466f, 0.06531770f, -0.73543155f, -0.04943299f, 0.08103532f, -0.00187215f, -0.05896558f, -0.32015431f, 
    0.01613551f, 0.23587644f, -0.02645273f, 0.28648618f, 0.01149379f, 0.03791353f, -0.05235421f, 0.10947827f, 
    0.15045370f, 0.12602559f, 0.01657070f, 0.05701532f, 0.22577608f, -0.00973054f, 0.11332260f, 0.09581968f, 
    0.00250669f, -0.05969707f, 0.01196209f, 0.11977057f, 0.02811092f, 0.26129299f, -0.03233784f, -0.03457886f, 
    -0.08841792f, -0.06109741f, -0.05288281f, -0.05482122f, -0.12997355f, 0.03909067f, -0.17620789f, -0.21896909f, 
    -0.12192739f, -0.22551526f, -0.15729655f, 0.13372545f, 0.10217695f, 0.06482769f, 0.08947631f, -0.21747079f, 
    -0.05310839f, -0.11697203f, -0.04566507f, 0.05906389f, -0.03608333f, 0.23075272f, 0.11198273f, 0.18175411f, 
    0.25113407f, 0.55817199f, 0.00520073f, 0.20635027f, -0.18167402f, 0.29058683f, 0.04046222f, 0.13191971f, 
    0.04757297f, 0.34245384f, 0.11996181f, 0.25912336f, -0.01778064f, 0.10741918f, 0.06257942f, 0.17861696f, 
    0.11354549f, -0.07300489f, 0.28639939f, 0.08924068f, 0.29443371f, -0.09240082f, 0.02579604f, -0.14612186f, 
    0.12152870f, 0.03112781f, -0.03854210f, 0.17776930f, 0.31927115f, -0.05285367f, 0.06554695f, 0.09019815f, 
    0.07717210f, -0.04162537f, -0.02581149f, -0.07094283f, 0.09813106f, -0.20037735f, 0.17832775f, 0.07405979f, 
    -0.17309485f, 0.09135315f, -0.10496937f, 0.20684865f, 0.10960865f, -0.09177365f, 0.04770914f, 0.03372337f, 
    0.25789452f, 0.17994888f, -0.04721892f, 0.06100205f, 0.14274517f, 0.10182390f, -0.09610791f, 0.09762606f, 
    -0.44168547f, -0.17947166f, -0.04442785f, 0.10650987f, 0.08785296f, 0.27639815f, -0.02220008f, -0.00055979f, 
    -0.26154330f, 0.03318707f, -0.20266280f, -0.14835180f, -0.06345571f, 0.10855141f, -0.16205303f, -0.17051001f, 
    -0.07826722f, -0.26015976f, -0.23360355f, -0.13281816f, -0.19061191f, -0.01630716f, -0.01212702f, 0.05663111f, 
    -0.12759759f, -0.11367772f, -0.30805805f, 0.15580934f, 0.00608556f, 0.10926014f, -0.05609258f, 0.01024658f, 
    0.07718543f, 0.06327601f, -0.35711968f, -0.64217138f, -0.24414274f, -0.04848536f, 0.08162314f, 0.03348399f, 
    -0.12146583f, -0.08097795f, -0.13938218f, 0.19239599f, 0.31330109f, 0.03845867f, -0.06458894f, 0.10929645f, 
    0.23761860f, 0.03618957f, -0.03928746f, -0.10807265f, -0.11796482f, 0.01484644f, 0.25435433f, -0.10628466f, 
    -0.14006442f, -0.14166324f, -0.03818534f, -0.14812371f, -0.03517026f, 0.09188819f, 0.24946123f, 0.24001472f, 
    -0.11145844f, 0.12269445f, -0.07255153f, -0.04599403f, 0.11198894f, 0.11390075f, -0.10646909f, -0.07094271f, 
    -0.15122698f, 0.24216661f, -0.02930461f, 0.08716776f, 0.12916008f, 0.17296962f, 0.02704579f, -0.05127164f, 
    -0.06911311f, 0.07564613f, 0.14831334f, 0.28478259f, -0.08662184f, -0.00456746f, 0.08548445f, 0.12335823f, 
    0.12689225f, -0.05988389f, 0.08234685f, 0.04579220f, -0.10718780f, 0.19999160f, 0.05970548f, -0.13224787f, 
    -0.18253903f, -0.02778317f, -0.00907514f, 0.28280291f, -0.07150699f, -0.02374372f, 0.00640052f, 0.07815845f, 
    0.06726722f, 0.07332219f, -0.36994645f, -0.29454947f, 0.17452395f, -0.05425119f, -0.04240177f, -0.05090164f, 
    -0.02033503f, 0.06489231f, 0.06364520f, 0.19186792f, 0.33379307f, 0.02142117f, 0.12506181f, 0.00626417f, 
    -0.03383128f, 0.09054152f, 0.07134417f, 0.09442604f, 0.14228366f, 0.07763420f, 0.16264576f, -0.16196810f, 
    -0.25070494f, -0.28308132f, 0.07512568f, 0.04348074f, 0.06811714f, 0.26113710f, 0.12555502f, -0.24925078f, 
    -0.13588293f, -0.12097086f, 0.00698444f, -0.05839068f, 0.15087818f, 0.10084557f, 0.07848435f, 0.25950587f, 
    -0.23642135f, -0.30943462f, -0.08004645f, 0.01369369f, 0.20169380f, 0.00303667f, 0.08161291f, 0.25036076f, 
    -0.36790147f, -0.49661314f, -0.04504853f, 0.08680613f, -0.00765866f, 0.03933748f, -0.09799851f, 0.05594797f, 
    -0.30202806f, -0.07685464f, 0.29157779f, -0.06121174f, -0.00671280f, -0.21338907f, -0.02615105f, -0.01578295f, 
    0.00499475f, -0.35896116f, -0.35149190f, 0.15944946f, 0.12037570f, 0.06051401f, -0.05887515f, 0.01725143f, 
    0.02126167f, -0.02454869f, -0.20165108f, 0.04732004f, -0.51634556f, -0.06088462f, -0.11187621f, 0.36574998f, 
    -0.01901174f, 0.14802477f, -0.09200619f, 0.02713095f, 0.16529882f, 0.19968358f, 0.17776942f, 0.16726787f, 
    0.01514286f, 0.07103044f, 0.05687755f, -0.02195403f, -0.48200983f, -0.02592056f, -0.47145903f, 0.09315184f, 
    -0.19961278f, -0.10466283f, 0.05322407f, -0.00646275f, -0.03560784f, 0.12697375f, 0.00395116f, 0.33500132f, 
    0.12003150f, 0.09641528f, 0.02792261f, 0.08249520f, 0.05178699f, 0.04516340f, -0.37717021f, 0.37875316f, 
    0.06113160f, 0.09159171f, 0.07434165f, -0.15273133f, -0.01034468f, 0.08209233f, -0.04973567f, -0.33344170f, 
    -0.10935511f, 0.40418735f, -0.06312425f, -0.20898652f, -0.13667764f, 0.00387807f, 0.04301512f, 0.02713642f, 
    -0.08268930f, -0.62781668f, 0.23426238f, -0.14267166f, 0.16230471f, -0.15660267f, 0.05948071f, -0.07890646f, 
    0.08456648f, -0.01422748f, 0.25869593f, 0.14727026f, -0.02062045f, -0.21837698f, 0.14094457f, 0.15358394f, 
    -0.00189989f, 0.05848998f, -0.24556255f, 0.24765512f, -0.15632552f, -0.07437633f, 0.08134961f, -0.01321151f, 
    -0.00417219f, 0.15855294f, 0.10540275f, 0.07435203f, 0.10310280f, 0.35498312f, 0.07043105f, -0.08874679f, 
    0.13699804f, 0.04105192f, 0.08721215f, 0.13789484f, -0.48842153f, 0.28012460f, 0.03448803f, -0.15439768f, 
    0.00083157f, -0.09799476f, -0.01965744f, -0.11286638f, -0.00787122f, 0.05753222f, 0.00454179f, 0.21272886f, 
    0.00666518f, 0.04546087f, 0.13627774f, 0.15476793f, 0.24766131f, -0.07799757f, -0.40932414f, -0.29295808f, 
    0.00460227f, 0.11705591f, -0.02292056f, 0.12648210f, 0.00340075f, -0.03153056f, 0.07068785f, -0.33203188f, 
    0.07791299f, 0.06903919f, 0.10057843f, -0.09496208f, -0.17998542f, 0.01104732f, 0.04646682f, 0.10667401f, 
    -0.25445169f, 0.05031977f, -0.10968807f, -0.12419814f, -0.13617374f, -0.06193526f, -0.02339900f, -0.12311659f, 
    -0.07004970f, -0.38419488f, 0.09315334f, 0.15683126f, 0.16457827f, 0.10368419f, 0.04347489f, 0.00452174f, 
    0.10917820f, 0.30340847f, -0.14439030f, -0.30914271f, -0.38781315f, 0.10650940f, 0.34488755f, -0.29807836f, 
    -0.06176177f, 0.09745118f, 0.00747677f, -0.71593928f, -0.04380700f, 0.23548430f, 0.01226744f, 0.08758876f, 
    0.07673527f, -0.03964505f, 0.02621568f, 0.00021530f, 0.10300549f, 0.15641828f, -0.01210621f, 0.10264158f, 
    0.01325055f, -0.20169248f, 0.17976142f, 0.03097141f, 0.03768756f, -0.75504476f, -0.38079494f, 0.77227491f, 
    -0.04137087f, 0.05293130f, -0.02840494f, -0.03347430f, 0.01083000f, 0.03760244f, -0.05656284f, 0.00396079f, 
    0.14662398f, -0.00891983f, -0.01651513f, -0.00039429f, 0.09447037f, 0.18359892f, 0.10714003f, 0.14579175f, 
    0.32570407f, -0.01022675f, 0.08005270f, 0.16243081f, -0.01207449f, 0.07968836f, 0.13530946f, -0.21818818f, 
    -0.41766688f, 0.12333926f, -0.31618705f, -0.16139449f, -0.32097018f, 0.16630895f, 0.26659921f, -0.01192493f, 
    -0.02627334f, -0.73860395f, -0.07310692f, -0.00306217f, -0.08205625f, -0.03650308f, -0.10027912f, -0.07265291f, 
    -0.12412364f, 0.02579129f, 0.10541712f, -0.19853850f, 0.11705697f, 0.10986637f, -0.05658634f, -0.02695633f, 
    -0.01243399f, 0.12751713f, 0.15717538f, 0.06154795f, 0.10777108f, -0.31246185f, 0.06418394f, 0.13109742f, 
    0.07659121f, -0.04182953f, -0.08430385f, -0.10338894f, 0.27921566f, -0.22064626f, -0.13820124f, -0.60625619f, 
    -0.06995074f, -0.33443922f, 0.11003482f, -0.04582938f, 0.07571125f, 0.09990443f, -0.27872902f, -0.66230023f, 
    0.00260485f, -0.01897164f, 0.02644791f, 0.17441632f, 0.04337098f, 0.01476944f, -0.04654291f, -0.05368047f, 
    -0.19980708f, -0.31565234f, -0.10118720f, -0.13549253f, 0.27078316f, -0.09254791f, 0.08737195f, 0.15769756f, 
    0.47017428f, -0.10015810f, 0.07300108f, 0.17561404f, 0.01187263f, 0.16100675f, -0.03857944f, -0.15941505f, 
    0.05847788f, -0.27239826f, 0.14205794f, 0.04450459f, 0.26925299f, -0.08418760f, 0.03575301f, -0.00643407f, 
    0.11312933f, -0.26804811f, 0.29770002f, 0.20382975f, -0.28457195f, -0.25248018f, -0.14617403f, -0.01007669f, 
    0.12087237f, -0.01575598f, -0.15396520f, 0.16002479f, 0.54685593f, -0.01632406f, -0.10082074f, 0.11831833f, 
    -0.03862149f, -0.05570785f, 0.05101168f, -0.08708566f, -0.07737907f, -0.06593491f, -0.15466830f, 0.04675290f, 
    -0.08125761f, -0.01604438f, 0.08658204f, -0.15986389f, -0.34980616f, 0.04791630f, 0.22815613f, -0.01743238f, 
    -0.16425146f, -0.06966381f, 0.10140781f, 0.06767727f, 0.07032655f, -0.44509390f, -0.54575920f, 0.08648098f, 
    -0.02674935f, 0.05514872f, -0.48093295f, -0.08531179f, 0.03229539f, -0.00777781f, 0.07233189f, 0.13656452f, 
    0.03436629f, 0.07899936f, 0.03108508f, -0.04813732f, 0.06745442f, 0.02477539f, -0.05695957f, -0.02658927f, 
    -0.05426406f, 0.39527559f, -0.01817666f, -0.07311992f, 0.13810414f, 0.03950959f, -0.01329495f, 0.10791843f, 
    -0.30733442f, 0.21063454f, 0.24935904f, -0.01394452f, 0.04490423f, -0.11134858f, -0.18466379f, 0.11733013f, 
    -0.02616778f, -0.22498409f, 0.24374524f, -0.18285738f, -0.32153425f, -0.18991648f, -0.08146538f, 0.25011906f, 
    -0.07730732f, 0.21113193f, -0.18722510f, 0.26767969f, -0.05964743f, 0.09673114f, 0.26076049f, 0.08107054f, 
    0.16408893f, -0.08464014f, -0.06937707f, -0.22811006f, -0.22318867f, 0.01743741f, 0.13792713f, 0.01205856f, 
    0.02260119f, 0.05564711f, 0.02509422f, -0.15286739f, -0.24050452f, -0.09537489f, 0.27112246f, -0.06263462f, 
    -0.28631780f, -0.00544382f, 0.02979022f, 0.15691747f, 0.05534917f, -0.06586687f, -0.07595266f, -0.35212019f, 
    0.06203397f, -0.08767986f, 0.05910648f, 0.16459964f, -0.00720656f, -0.00467665f, 0.02076617f, -0.02879778f, 
    -0.11923335f, -0.04779778f, 0.13282834f, 0.37472773f, -0.00647168f, -0.12348212f, -0.19095768f, 0.21236475f, 
    0.38137525f, 0.08106991f, 0.10703956f, -0.15643512f, 0.03331523f, 0.18825610f, 0.02682709f, 0.13410901f, 
    -0.05128761f, 0.24600221f, 0.02596187f, 0.08145394f, 0.05474050f, -0.04387105f, -0.18537384f, -0.41733468f, 
    -0.35699463f, -0.00605533f, -0.05088714f, -0.00301288f, 0.02672846f, 0.17154798f, 0.09000684f, 0.12040253f, 
    0.14034061f, 0.06407669f, 0.26484159f, 0.32391554f, 0.32367894f, 0.23809244f, 0.04407514f, -0.02263952f, 
    -0.20291749f, 0.02278845f, 0.16344501f, 0.15212102f, 0.00377618f, -0.10552292f, 0.04222697f, 0.00096299f, 
    -0.02427706f, -0.04995061f, -0.05698518f, -0.36861891f, -0.09905536f, -0.31372523f, 0.03170351f, 0.16288574f, 
    0.11701554f, 0.09334246f, -0.13546796f, -0.21388705f, -0.38985729f, -0.06625265f, 0.00088230f, 0.01464387f, 
    0.14752914f, 0.07888348f, 0.10142893f, 0.10036477f, 0.28669816f, 0.12361219f, 0.00433978f, -0.04681381f, 
    0.07591174f, 0.01220105f, 0.15758359f, -0.04858373f, 0.06355630f, 0.21821575f, 0.31082323f, -0.13650993f, 
    -0.10925189f, 0.02051668f, 0.01871140f, 0.01639787f, -0.04056164f, -0.36554116f, -0.09538679f, -0.33811402f, 
    -0.06686184f, 0.01279448f, 0.16691765f, 0.15325381f, -0.04033022f, 0.00321965f, -0.13446242f, -0.23076956f, 
    -0.29122597f, 0.34375250f, 0.15904716f, 0.23883450f, -0.03015983f, 0.19555174f, -0.14762996f, 0.14393458f, 
    0.06582814f, 0.09018999f, -0.02511970f, -0.12239315f, 0.42781967f, 0.14373335f, 0.10519925f, -0.10461739f, 
    0.15929975f, -0.15986896f, -0.03074224f, -0.00613539f, 0.00131177f, 0.00534230f, -0.28765261f, -0.17890890f, 
    -0.06061016f, 0.08395580f, 0.15201935f, 0.10959448f, 0.09460254f, -0.04413996f, -0.02230870f, 0.10667636f, 
    0.16853331f, 0.14480485f, -0.01302984f, 0.09516960f, 0.13600259f, 0.00595282f, 0.20238179f, -0.06973314f, 
    -0.10933746f, -0.02530202f, -0.25285804f, -0.01151512f, -0.02412077f, -0.06951602f, -0.07281662f, -0.11501952f, 
    0.04301513f, 0.27570921f, -0.03221677f, -0.00150985f, 0.06821908f, -0.00824164f, 0.18167983f, -0.16593838f, 
    -0.09010538f, -0.19901662f, -0.04448162f, 0.12379173f, 0.12289461f, 0.09861395f, 0.13091430f, -0.17649229f, 
    -0.46492085f, 0.21403995f, 0.12264457f, -0.08277891f, -0.05387329f, -0.04077655f, 0.13423784f, -0.00664652f, 
    -0.09618132f, -0.12609336f, -0.13870600f, -0.26266092f, -0.06045204f, -0.20875868f, 0.04898047f, 0.04416742f, 
    0.10631603f, 0.17088048f, 1.05928123f, -0.69314116f, 0.04197115f, 0.10246076f, -0.20004645f, -0.03458240f, 
    0.13433073f, 0.04028559f, 0.01501369f, -0.21844363f, 0.05551306f, 0.03663865f, 0.06522154f, -0.08878760f, 
    0.13539098f, 0.06426784f, 0.09786461f, -0.07867114f, -0.17885549f, 0.12263122f, -0.24957043f, 0.02216870f, 
    -0.10883126f, -0.17631644f, 0.05436829f, 0.00943026f, -0.19185683f, 0.03595657f, -0.15971826f, 0.27539578f, 
    -0.26523986f, -0.03505009f, -0.09958442f, -0.09004152f, -0.04305529f, 0.00148648f, -0.60045058f, -0.34135786f, 
    -0.48137057f, 0.12784328f, -0.09838045f, 0.06899285f, -0.07815019f, 0.17032759f, 0.02012341f, 0.12520552f, 
    -0.17287014f, -0.04910622f, -0.00905695f, 0.00339273f, -0.07429952f, 0.05380526f, -0.09542914f, 0.07676958f, 
    -0.29213136f, -0.12941231f, 0.14238216f, -0.02388712f, 0.04121967f, 0.19539975f, -0.20588274f, 0.12150227f, 
    0.04141850f, -0.03856987f, -0.11657681f, 0.04642349f, 0.14545967f, -0.01671249f, 0.11805716f, 0.10456417f, 
    0.14597020f, 0.07358008f, 0.21587218f, -0.32960165f, -0.05327132f, 0.08875511f, 0.06090787f, 0.14454293f, 
    -0.07117887f, -0.01778091f, 0.04200016f, 0.04861861f, -0.11412263f, 0.19754238f, -0.06452185f, -0.05747170f, 
    0.02693212f, 0.08589814f, -0.05903732f, 0.04130197f, -0.33995256f, -0.02000008f, -0.23693928f, -0.08382029f, 
    0.01281804f, 0.07739578f, 0.20591851f, 0.10787041f, 0.14892691f, 0.00502185f, 0.34502932f, 0.14825428f, 
    0.08137605f, -0.01934671f, 0.16076043f, 0.13112189f, 0.08355924f, 0.12139029f, -0.18644731f, -0.26830268f, 
    -0.20857179f, 0.06471341f, 0.14155193f, -0.06978098f, 0.16793095f, 0.13386056f, 0.03614523f, 0.27171174f, 
    -0.12049349f, -0.32231700f, 0.06717815f, -0.02476399f, 0.11470283f, 0.06976374f, -0.13454352f, -0.01036393f, 
    -0.09515344f, -0.03399726f, -0.08884184f, -0.07413904f, 0.01968410f, 0.16470037f, -0.00920591f, 0.17921224f, 
    0.18269400f, 0.10005625f, 0.15820929f, -0.06958561f, 0.10122716f, -0.01988294f, 0.04077857f, 0.05978248f, 
    0.08588798f, 0.08451449f, -0.34781969f, 0.07560506f, 0.03370629f, 0.01455884f, -0.20527160f, -0.02158762f, 
    -0.14938104f, 0.17031291f, 0.06291345f, -0.08918868f, -0.07714706f, 0.14483373f, 0.13800496f, 0.21058398f, 
    -0.26981828f, -0.16071646f, 0.00451959f, 0.07483225f, 0.23478839f, -0.14816822f, -0.41594246f, 0.09667502f, 
    0.18802874f, 0.08861618f, -0.12208100f, -0.12651452f, 0.10285109f, -0.11119029f, -0.08863037f, -0.18969850f, 
    0.14930281f, 0.03258271f, 0.15965591f, -0.10765453f, -0.19380510f, -0.31112045f, 0.05643622f, -0.00133122f, 
    0.10329768f, -0.09614129f, 0.17529066f, -0.03826705f, -0.08755618f, 0.12409963f, -0.10499620f, -0.15010479f, 
    -0.21682650f, -0.44267082f, 0.00853813f, 0.16024627f, 0.30118376f, 0.10483538f, 0.21690087f, -0.13874906f, 
    -0.00532116f, 0.09808695f, -0.03295732f, -0.16163564f, 0.08775499f, 0.01085341f, -0.06261148f, 0.10698563f, 
    0.00402323f, -0.17648955f, 0.05484474f, 0.02751962f, 0.05889637f, 0.07189932f, -0.14740273f, -0.05460650f, 
    -0.16895722f, -0.12957399f, 0.27986944f, 0.01334975f, -0.18659818f, -0.30261186f, 0.00922409f, 0.04004364f, 
    0.16337989f, 0.02168548f, -0.15155409f, -0.18217947f, -0.08022896f, -0.04928470f, 0.19797705f, 0.14464626f, 
    0.04725212f, 0.14751630f, -0.02816288f, -0.27587315f, -0.03827964f, 0.05352890f, 0.41221225f, 0.15323406f, 
    0.10236284f, 0.08465290f, -0.09319964f, -0.28081983f, 0.01461414f, -0.15191518f, -0.16508488f, 0.10403532f, 
    0.05857684f, 0.06348586f, 0.12087291f, -0.00782568f, 0.18112637f, 0.03710987f, -0.07644258f, -0.07881442f, 
    0.20698929f, -0.04996932f, -0.01089965f, 0.01684873f, 0.07368363f, -0.06632651f, -0.22197562f, 0.11721368f, 
    -0.07868066f, 0.27562425f, 0.29321793f, -0.15359136f, -0.09200499f, 0.28100142f, 0.06144959f, 0.10055405f, 
    0.46300390f, 0.05150640f, 0.20113315f, -0.07040382f, 0.01231262f, -0.02692065f, 0.22571294f, 0.12339138f, 
    0.17327590f, -0.05346149f, 0.23993005f, 0.14090513f, -0.12987137f, 0.02586535f, -0.18506639f, -0.13028294f, 
    -0.03831143f, 0.03777207f, 0.19750427f, -0.31416249f, -0.61475503f, -0.02008541f, -0.06957923f, -0.10478532f, 
    0.08619753f, 0.05560794f, 0.01643075f, 0.01535729f, 0.14530045f, 0.24985391f, 0.00618411f, -0.00967245f, 
    0.18484975f, 0.02688420f, -0.09116936f, 0.02916459f, -0.44950849f, -0.31963450f, 0.46551451f, -0.06896321f, 
    -0.14601004f, 0.05057614f, 0.09790079f, 0.13660014f, 0.10320868f, 0.26496515f, 0.37273932f, 0.29598242f, 
    -0.13851993f, -0.07536128f, -0.12868866f, 0.08572357f, 0.07418713f, 0.05035715f, 0.10264196f, -0.49418724f, 
    -0.03672072f, -0.10987662f, -0.12964420f, -0.08443066f, 0.01303731f, 0.00251346f, -0.01388305f, 0.01103293f, 
    0.38695627f, 0.02781245f, -0.06905395f, -0.01996594f, 0.11129207f, 0.07063872f, -0.05191166f, 0.00902005f, 
    0.44059893f, -0.05163626f, 0.02274234f, -0.01126860f, 0.13550216f, 0.08166730f, 0.04304678f, 0.05141975f, 
    -0.03872620f, -0.02474094f, 0.15424488f, 0.17998563f, 0.12048314f, 0.01408880f, -0.09754246f, 0.08623781f, 
    -0.03990859f, 0.02961309f, -0.44938606f, -0.30600521f, -0.09721608f, 0.04945814f, -0.03183601f, 0.08067403f, 
    0.09125407f, 0.27059752f, 0.05229236f, 0.17031872f, 0.21089584f, 0.06483008f, -0.03871642f, 0.09284889f, 
    -0.04341217f, 0.00829467f, -0.03939011f, -0.08771421f, -0.32134202f, -0.55417663f, -0.06745028f, 0.00191135f, 
    -0.22075419f, 0.18973915f, 0.00412075f, 0.20688754f, 0.03852310f, 0.08499188f, 0.04572768f, -0.13602449f, 
    -0.07034743f, 0.09289677f, 0.08209693f, 0.08661213f, 0.01660938f, -0.00262728f, -0.10565695f, -0.03129504f, 
    -0.37583375f, -0.11155467f, -0.15855886f, 0.02406065f, 0.12844759f, 0.04491790f, 0.03000987f, -0.09960002f, 
    -0.35321543f, -0.55287224f, -0.07638522f, -0.25488797f, 0.05929121f, 0.04856870f, 0.10393530f, -0.07955672f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11621222f, 0.17435305f, 0.02600973f, 0.24273552f, 0.30934215f, 0.30716798f, 0.03817823f, 0.12775001f, 
    0.06998460f, 0.15171073f, 0.10386943f, 0.24148637f, 0.00006731f, 0.34678420f, 0.08457511f, -0.13222240f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25336155f, 0.29202887f, -0.15346549f, 0.17544873f, -0.30200619f, -0.52507216f, 0.43185264f, 0.48917407f, 
    0.16015679f, -0.14255601f, -0.07385883f, 0.34224531f, -0.11788764f, -0.18945590f, 0.24720778f, -0.04870946f, 
    -0.53822428f, 0.03374492f, -0.02808967f, 0.11643290f, -0.29106390f, -0.46392265f, 0.40510163f, 0.35155684f, 
    0.23398612f, 0.12423348f, -0.04211963f, -0.26680541f, -0.05112734f, 0.15837830f, 0.20346649f, 0.33187497f, 
    0.18148068f, 0.06843214f, 0.26297748f, -0.41498879f, -0.17032190f, 0.39674070f, 0.10461417f, -0.12172470f, 
    -0.14166622f, -0.24868970f, 0.28464192f, -0.46606088f, 0.39922038f, 0.15227228f, 0.13984361f, 0.33046323f, 
    0.25497112f, 0.07084522f, 0.10936989f, 0.21068344f, -0.14370395f, 0.41689834f, 0.00578357f, -0.19094573f, 
    0.03588030f, 0.21046123f, -0.21130016f, -0.45143947f, 0.25002551f, 0.26103258f, 0.17835331f, -0.12545148f, 
    0.45144328f, -0.30541176f, -0.40738913f, -0.32738146f, -0.00252466f, 0.45190927f, 0.17660004f, 0.18823823f, 
    -0.16331926f, -0.35948095f, 0.33055368f, 0.36847568f, -0.09410410f, -0.11653885f, 0.08454975f, -0.15392400f, 
    -0.12048879f, -0.21135896f, -0.12323740f, 0.05906901f, -0.20424676f, 0.21726131f, -0.01992294f, 0.08846813f, 
    -0.19150925f, -0.07996672f, 0.00573546f, -0.08224133f, -0.09083408f, -0.20161146f, -0.06052965f, 0.02051556f, 
    0.18634383f, 0.06421103f, -0.19866312f, -0.04136968f, 0.05288295f, -0.47872803f, 0.23418534f, -0.27662882f, 
    -0.07379809f, 0.57784611f, 0.24345513f, 0.32548410f, 0.07701828f, 0.20365062f, 0.10008251f, -0.05162932f, 
    -0.22752187f, 0.56883913f, 0.05622129f, 0.34508404f, 0.31964555f, -0.21727504f, -0.09776849f, -0.19505826f, 
    -0.45516798f, -0.06489510f, 0.14078195f, 0.04959513f, -0.20402361f, 0.14294301f, 0.19877703f, 0.14510266f, 
    -0.37012359f, -0.01142339f, -0.11058919f, 0.04150977f, 0.02037989f, 0.15057200f, -0.26647374f, 0.13326293f, 
    0.09209096f, 0.58422011f, -0.19632247f, -0.16610834f, 0.21119922f, 0.58695471f, -0.50598735f, -0.04077704f, 
    -0.38053685f, 0.42279938f, -0.00993043f, 0.38559473f, -0.29353082f, -0.47445351f, -0.07591191f, 0.32205322f, 
    0.11703221f, -0.14170629f, -0.16445878f, -0.34916529f, -0.12495661f, 0.29639587f, -0.13050464f, 0.16728702f, 
    -0.25476906f, -0.06856079f, -0.06627175f, 0.07006439f, -0.00102275f, 0.21991074f, 0.18260922f, -0.26093546f, 
    0.09904434f, 0.04389172f, -0.20458147f, -0.09978402f, -0.16260391f, -0.04829993f, 0.01233370f, 0.15081194f, 
    0.42477682f, 0.62288457f, -0.20591471f, 0.19989015f, -0.21653117f, -0.48268226f, -0.15996690f, -0.08420105f, 
    -0.60199201f, 0.02849172f, 0.41921708f, -0.28194040f, -0.36530218f, 0.18588845f, 0.10439786f, -0.23066135f, 
    0.00836051f, 0.02189120f, -0.00615120f, -0.04050770f, 0.02893672f, 0.42425671f, -0.26728886f, 0.09993698f, 
    -0.13359126f, -0.22622477f, 0.09326041f, 0.28421175f, -0.08436190f, -0.88121724f, 0.04090923f, -0.22370282f, 
    0.09255211f, 0.35788727f, 0.06363446f, 0.17231944f, 0.38553631f, 0.59343791f, -0.35116574f, -0.17193970f, 
    0.12353397f, 0.23833932f, -0.17380793f, -0.38581753f, 0.21757890f, 0.45257384f, -0.49013618f, 0.21623993f, 
    -0.05368951f, 0.32833597f, 0.05174330f, -0.47293043f, -0.03554257f, 0.59049863f, -0.02420375f, -0.15589777f, 
    0.11931170f, 0.50990540f, -0.25777110f, 0.02558655f, 0.22589324f, 0.35252678f, -0.07545084f, -0.24690652f, 
    0.55777794f, -0.13060279f, 0.16256827f, -0.06229563f, -0.45537046f, -0.27414182f, 0.63364410f, 0.06144465f, 
    0.23066287f, 0.02213061f, -0.12286647f, -0.40560499f, -0.53732568f, 0.15362552f, 0.46224886f, 0.00960104f, 
    0.04221305f, -0.19147900f, -0.00981089f, 0.05536545f, 0.22426133f, 0.27454081f, -0.01476664f, 0.32228681f, 
    -0.18938722f, -0.49864060f, -0.11283826f, 0.38276005f, -0.08963614f, -0.14668307f, 0.26105613f, -0.22572187f, 
    0.03187837f, 0.41460437f, -0.08457045f, 0.29912746f, 0.24558486f, -0.15173928f, -0.28435796f, 0.18857543f, 
    -0.17887184f, -0.30611351f, 0.24213922f, -0.25575453f, -0.12574145f, 0.05555598f, 0.08163755f, 0.03015137f, 
    0.03084110f, -0.02613380f, 0.18994474f, -0.15169618f, -0.76822364f, -0.01928063f, 0.26059976f, 0.08678330f, 
    -0.24220911f, 0.46537867f, -0.28520820f, 0.12176859f, -0.00952097f, 0.50872022f, 0.26325849f, -0.43888390f, 
    -0.01784751f, -0.37857917f, 0.24829341f, -0.33255115f, 0.08495983f, 0.02810091f, 0.38308087f, 0.25917727f, 
    -0.14289589f, 0.03494228f, -0.08795151f, 0.13722071f, 0.10637404f, 0.14642349f, 0.12527168f, -0.10857522f, 
    0.28992704f, -0.15958923f, 0.08970172f, 0.15202437f, -0.00291228f, 0.09172107f, -0.60725111f, -0.20532626f, 
    0.18164428f, -0.16487767f, -0.27258077f, 0.30429336f, -0.15053670f, 0.28230914f, 0.00178274f, -0.05869913f, 
    0.28917572f, -0.19150373f, -0.02179865f, 0.31730771f, 0.27961105f, -0.22440715f, 0.11902474f, -0.28684112f, 
    0.16324860f, 0.20250696f, 0.17653984f, 0.21032350f, -0.27047238f, 0.00448045f, 0.07262244f, 0.48740649f, 
    -0.23064104f, -0.05209592f, 0.20025462f, 0.03386415f, -0.08303358f, 0.07286758f, -0.05879696f, -0.16732001f, 
    -0.19318460f, -0.06951242f, -0.10791776f, -0.14244229f, -0.10459659f, -0.15542303f, 0.12666909f, 0.21227251f, 
    0.09342736f, 0.46863410f, 0.21926005f, -0.18576945f, 0.05012817f, 0.15435207f, -0.27803001f, 0.00770673f, 
    -0.26819250f, 0.27194059f, 0.11002542f, 0.36769459f, -0.14299871f, -0.29471770f, 0.10450450f, -0.11223415f, 
    0.09015607f, -0.06452160f, -0.20500845f, -0.21376558f, 0.23000817f, 0.45590860f, 0.13877374f, -0.20603795f, 
    0.01397489f, -0.25299981f, -0.40581957f, 0.31923813f, 0.11034659f, 0.26520482f, 0.04541958f, 0.22247213f, 
    0.31722823f, -0.16983740f, 0.10139953f, 0.12618896f, 0.12332536f, 0.19845957f, 0.03252086f, 0.39195898f, 
    -0.27207065f, -0.02467614f, 0.32110810f, -0.57508570f, -0.37628320f, -0.31484035f, 0.11919562f, -0.05249566f, 
    0.06919570f, 0.09103509f, -0.05475864f, -0.11669503f, -0.21639000f, -0.20052589f, -0.18023868f, 0.18780343f, 
    0.07256078f, 0.59851843f, 0.46930534f, 0.15711120f, 0.25714159f, -0.39137986f, -0.28299814f, 0.24239472f, 
    0.36403301f, -0.22539158f, -0.06327871f, -0.25745732f, 0.20151223f, 0.29517862f, 0.33889666f, -0.14421450f, 
    0.08211268f, 0.10973335f, -0.14425132f, 0.37403849f, 0.20449661f, 0.57651621f, -0.30647045f, -0.20565403f, 
    -0.10819815f, 0.22795714f, -0.01754914f, -0.36095682f, 0.03039494f, 0.42940471f, -0.03031768f, 0.27934268f, 
    0.29143047f, -0.29536623f, -0.03677811f, -0.30668959f, 0.06025156f, -0.23227073f, 0.10682530f, 0.16229738f, 
    -0.27255759f, 0.20204854f, 0.09848808f, -0.48558792f, -0.07839496f, 0.59439766f, 0.00897205f, 0.33447230f, 
    0.21915658f, 0.67553848f, 0.10391656f, -0.27969056f, 0.20018983f, 0.00881140f, -0.23751111f, 0.61826116f, 
    -0.03779886f, 0.12701267f, 0.00982820f, -0.41823804f, 0.15554388f, 0.83947158f, 0.36315075f, 0.08467957f, 
    -0.53044564f, -0.15147364f, 0.04964696f, 0.19382757f, -0.07217792f, -0.07428200f, 0.20772739f, -0.11294167f, 
    0.17531301f, 0.25262141f, 0.23031238f, 0.47327295f, 0.39014691f, 0.02654825f, -0.31590804f, -0.24243484f, 
    -0.28767234f, 0.46077722f, 0.06993036f, -0.00577680f, 0.07743914f, 0.36693117f, 0.01674936f, 0.01730995f, 
    -0.11713821f, 0.40785381f, -0.20830220f, 0.09964629f, -0.05166699f, -0.37064159f, -0.05498172f, 0.26207781f, 
    -0.38252410f, -0.07145000f, -0.02974231f, 0.19089708f, -0.04289823f, -0.41798210f, 0.22877142f, 0.02127331f, 
    0.18247126f, 0.64992046f, 0.16698456f, 0.20095395f, -0.16108121f, -0.46010229f, 0.06544679f, 0.26712400f, 
    -0.56599706f, -0.07253987f, -0.68779099f, -0.02593697f, -0.64322948f, 0.25810283f, 0.11163051f, 0.04508912f, 
    -0.14960933f, -0.21778542f, -0.14814816f, -0.18752390f, -0.22655982f, 0.24217829f, 0.28721330f, 0.18705440f, 
    -0.13367033f, 0.29043716f, -0.48375252f, 0.20687746f, -0.14476866f, 0.41181812f, 0.29789138f, -0.24378556f, 
    0.05919006f, 0.01413758f, 0.04445488f, 0.04326364f, -0.10808875f, -0.04334496f, -0.01396328f, -0.11653730f, 
    0.22481297f, 0.72807598f, -0.17246328f, -0.36873218f, 0.20123206f, 0.30679592f, -0.19672076f, 0.06723543f, 
    0.46640247f, -0.37143612f, -0.17812994f, 0.09042817f, 0.14889483f, 0.03119750f, 0.17349193f, 0.09664105f, 
    0.19480285f, -0.10424539f, 0.40702558f, -0.18964776f, -0.01584399f, 0.25704914f, -0.34328464f, 0.17538720f, 
    -0.20537032f, 0.48917094f, 0.04855025f, 0.37067276f, -0.00443973f, 0.40553790f, -0.12721273f, 0.06343002f, 
    0.00288991f, -0.17749313f, 0.34290665f, -0.27901655f, -0.09012667f, 0.13256910f, -0.19883519f, 0.32046112f, 
    0.00845758f, 0.07704592f, 0.10320644f, 0.67653477f, 0.40684220f, -0.26441136f, -0.12817441f, 0.04815362f, 
    -0.09380219f, -0.08933064f, 0.00499767f, 0.09721109f, 0.19037679f, 0.20268230f, -0.35598728f, 0.04578336f, 
    -0.15960096f, 0.35623381f, 0.21065921f, -0.19746681f, -0.55003607f, 0.00874688f, 0.00766646f, 0.10055324f, 
    -0.28814930f, 0.23332302f, -0.17470467f, 0.25678939f, 0.29919684f, 0.61178112f, -0.12630969f, -0.37481809f, 
    0.01346400f, 0.14853328f, -0.19985367f, -0.24408926f, 0.12279467f, -0.15878576f, 0.19798753f, 0.30493155f, 
    -0.41057366f, 0.18963271f, -0.58182812f, 0.39974037f, -0.26284763f, -0.25463441f, 0.39175341f, -0.00602162f, 
    0.11341741f, -0.21641643f, 0.08902013f, -0.03844750f, -0.13365880f, -0.23489383f, 0.24300544f, 0.22580068f, 
    -0.02742664f, 0.12683225f, -0.55488807f, 0.30439359f, 0.06741403f, 0.62502146f, -0.14461896f, -0.46671173f, 
    -0.52442735f, 0.35397553f, 0.11501092f, -0.37498146f, -0.30078125f, -0.59761536f, -0.18520822f, 0.29439235f, 
    0.20755455f, 0.07531249f, -0.17464577f, -0.11940698f, 0.10385296f, -0.06425641f, -0.21526076f, 0.25492877f, 
    -0.28991589f, 0.13668920f, -0.16464771f, 0.30354246f, -0.68149841f, 0.06023950f, 0.09550602f, 0.26383767f, 
    -0.14070749f, 0.29366112f, -0.10258554f, 0.01378927f, -0.07385057f, 0.56614095f, -0.18237318f, -0.38997361f, 
    -0.12558502f, 0.52434415f, 0.10570731f, 0.46272817f, 0.32853115f, 0.17449553f, 0.04700231f, 0.00897402f, 
    -0.34118718f, -0.19654505f, -0.27181640f, 0.23112620f, -0.14074510f, 0.41945261f, -0.29211912f, -0.09645354f, 
    0.20010048f, 0.10929177f, -0.03638054f, 0.38851914f, -0.36877483f, -0.34307960f, 0.29451206f, 0.18273327f, 
    -0.21677536f, -0.29183993f, -0.36877418f, -0.00893387f, 0.25343874f, 0.56607360f, -0.09164887f, -0.24677126f, 
    0.21772410f, 0.04089830f, -0.19254027f, -0.11235710f, 0.20087382f, 0.20152397f, -0.18488891f, -0.20367390f, 
    0.02982660f, 0.45841390f, 0.07769290f, 0.45515275f, 0.17540871f, 0.41995054f, -0.43425956f, 0.30565906f, 
    -0.20228049f, -0.05202367f, 0.02145594f, -0.27441740f, 0.11267613f, 0.23184596f, -0.02003989f, -0.21484658f, 
    0.01108124f, 0.10612738f, -0.12942097f, -0.03987495f, -0.03622612f, -0.24977294f, -0.14418072f, 0.15199760f, 
    -0.20212287f, 0.28812662f, 0.03339214f, -0.57878774f, 0.03264042f, 0.49196139f, 0.04212070f, 0.11613408f, 
    0.21481289f, -0.13825113f, -0.34108061f, 0.38088632f, -0.02709368f, 0.28824809f, 0.09658810f, 0.61675733f, 
    0.32128587f, 0.11456123f, 0.23836008f, -0.25302991f, -0.37980837f, -0.33318880f, 0.56854159f, 0.20945024f, 
    0.26130271f, -0.41970998f, 0.31145829f, -0.29160756f, -0.19807085f, 0.18960765f, -0.14751849f, 0.37604758f, 
    -0.19361961f, 0.21967021f, -0.13920185f, -0.18962580f, 0.20513451f, -0.16662493f, -0.06790116f, 0.05925927f, 
    -0.00899398f, -0.14155099f, 0.01502138f, -0.18985507f, -0.24509746f, 0.04907256f, -0.22076431f, -0.16578999f, 
    -0.17313705f, -0.15971696f, 0.10812600f, 0.28420386f, 0.39033362f, 0.19178811f, 0.01354616f, 0.20942529f, 
    0.20496620f, 0.24435844f, -0.49236637f, 0.12092399f, 0.01995091f, 0.22044419f, 0.09873819f, -0.09954844f, 
    0.09488235f, -0.09996623f, -0.10057477f, 0.17991063f, 0.63957393f, 0.20506544f, 0.32473680f, -0.20737758f, 
    -0.48660594f, 0.49316001f, -0.37496009f, 0.27452531f, -0.23966897f, 0.11137755f, 0.18153252f, 0.07421570f, 
    0.04093872f, 0.16094890f, -0.12156034f, 0.03258964f, -0.02484733f, 0.56030130f, 0.06648971f, 0.04239395f, 
    -0.24978286f, 0.26351169f, 0.18499164f, -0.47947955f, 0.29574746f, 0.28410861f, -0.07150646f, -0.18440592f, 
    0.19544382f, -0.25927424f, -0.13519832f, -0.09745774f, 0.16362146f, -0.27354801f, -0.00099234f, -0.11960752f, 
    0.32594034f, -0.04234728f, 0.04979302f, -0.04178398f, 0.12020192f, 0.30647108f, -0.17557336f, 0.40323710f, 
    0.30851319f, -0.28767160f, -0.04100491f, -0.27701846f, 0.23112510f, 0.68188018f, 0.16711268f, 0.26655227f, 
    -0.23850696f, 0.24144948f, -0.83917290f, 0.02140760f, -0.07878413f, -0.05388185f, 0.19764560f, -0.45315087f, 
    -0.03747268f, -0.58777088f, 0.21903598f, -0.00012368f, 0.13352691f, -0.19116153f, -0.19441983f, -0.28996131f, 
    0.01996731f, -0.12983008f, -0.03080547f, 0.13457513f, 0.11004806f, 0.16701142f, 0.38399282f, 0.91604722f, 
    0.35390824f, 0.13898994f, -0.03290045f, -1.22842121f, -0.16360918f, 0.00804349f, 0.19151880f, 0.07411699f, 
    0.01659561f, 0.32968137f, -0.47067958f, -0.03640165f, -0.21929061f, -0.38953820f, 0.01752188f, 0.38353330f, 
    0.35784337f, -0.09368062f, 0.08678719f, 0.14069635f, -0.37593091f, -0.54972357f, 0.42690700f, 0.28291023f, 
    0.13676549f, 0.16386200f, 0.16938432f, -0.02837910f, -0.48314744f, 0.03801633f, 0.14855418f, 0.03259218f, 
    0.18835111f, 0.16914751f, -0.18181288f, 0.40736002f, 0.36611718f, -0.34000027f, 0.17013565f, -0.28555793f, 
    -0.17669860f, 0.24035053f, 0.25637525f, 0.23121068f, -0.48760861f, 0.15059316f, 0.28540480f, 0.02376952f, 
    0.11093871f, 0.04541365f, -0.06286199f, 0.02035655f, 0.12290930f, -0.36059329f, 0.12758477f, -0.11261524f, 
    0.17885455f, -0.21296345f, 0.45189273f, 0.21778592f, -0.16666712f, 0.52666903f, -0.15719937f, 0.34070703f, 
    0.12626737f, 0.22411361f, 0.21548022f, -0.42965025f, 0.25996134f, 0.42792055f, -0.13359027f, 0.02855714f, 
    -0.07179444f, -0.33379444f, -0.46240765f, 0.07507115f, 0.07312994f, 0.46317804f, 0.17022598f, 0.16909215f, 
    0.20826015f, -0.10386754f, 0.18061303f, 0.43900815f, -0.02779552f, 0.25422150f, 0.19140804f, 0.32537282f, 
    -0.24949622f, 0.04963627f, 0.21857089f, 0.30110586f, -0.00856849f, -0.03273824f, -0.18186094f, -0.42592397f, 
    0.55163199f, 0.30351216f, -0.06343786f, -0.47545359f, -0.58364278f, 0.62365168f, -0.14349982f, -0.02423793f, 
    -0.34183732f, -0.18576708f, -0.37433314f, -0.15625574f, 0.26021308f, 0.37887257f, 0.30245999f, -0.28710991f, 
    0.21840887f, 0.35609263f, 0.13938583f, -0.02003499f, 0.00215326f, -0.20533401f, -0.19443719f, 0.24971284f, 
    -0.44088525f, 0.22565225f, -0.00241424f, 0.32040673f, -0.00665427f, 0.12376700f, 0.40746224f, -0.50756103f, 
    -0.29880714f, 0.03903419f, -0.19239567f, -0.20302130f, -0.03645578f, -0.40697494f, 0.17965707f, -0.06968785f, 
    0.37084377f, 0.42927778f, -0.13135405f, -0.41531786f, 0.16020377f, -0.45999935f, 0.08097711f, 0.62440550f, 
    0.44856471f, -0.34452704f, 0.19369650f, -0.49496982f, -0.46066958f, -0.21785970f, 0.10908407f, 0.41645855f, 
    0.24484469f, 0.06014096f, -0.15422899f, 0.14774998f, -0.28575331f, -0.33950323f, 0.21784587f, 0.10316269f, 
    0.14767626f, 0.24408193f, -0.14915819f, -0.09963977f, 0.33557644f, 0.06534388f, 0.35616943f, -0.02617704f, 
    -0.17601332f, -0.54115450f, 0.45740455f, 0.29257709f, -0.02941266f, -0.21405655f, -0.15108250f, 0.02970116f, 
    -0.07113938f, -0.12658510f, 0.24153365f, -0.17243285f, -0.36523044f, -0.15789275f, 0.38431439f, 0.26332414f, 
    0.46985880f, 0.05730044f, -0.08475638f, -0.32160044f, 0.12083444f, 0.11127028f, 0.17672387f, 0.36656961f, 
    0.36716896f, -0.10922135f, 0.10997742f, 0.09063239f, 0.03188473f, -0.10184051f, 0.49168453f, 0.02409391f, 
    -0.09238953f, -0.24973015f, -0.06801338f, -0.01478973f, -0.19417214f, 0.35628790f, 0.32033545f, -0.19126497f, 
    0.48326772f, 0.02647705f, 0.19032848f, 0.36272588f, -0.33092219f, -0.30928752f, 0.49291006f, 0.34599447f, 
    -0.05732772f, -0.26944163f, 0.11667868f, 0.05874723f, -0.62599808f, -0.25010160f, -0.02974259f, 0.22136612f, 
    -0.23835795f, 0.14380975f, 0.16487041f, 0.02307461f, -0.03129594f, 0.00605025f, 0.11379419f, 0.28115210f, 
    0.14634514f, -0.52071172f, 0.20545545f, -0.11249501f, -0.01825509f, -0.33979282f, 0.22548686f, 0.00500246f, 
    -0.25357285f, -0.16991693f, -0.05703986f, -0.23704436f, 0.33929792f, 0.20512089f, 0.09153263f, 0.17601237f, 
    0.39729023f, -0.14059019f, -0.45790783f, -0.37158027f, -0.33799604f, -0.37760890f, -0.11234491f, 0.50070155f, 
    0.05889660f, -0.13397086f, -0.22200957f, -0.51893795f, -0.23256701f, 0.17030440f, 0.46049127f, 0.16913451f, 
    -0.03638671f, 0.29344124f, -0.00346404f, 0.47929704f, -0.01690730f, 0.06709786f, 0.15618390f, -0.01250153f, 
    0.09130244f, -0.47405043f, 0.06633981f, -0.12013356f, 0.12451885f, 0.55978549f, -0.00027135f, 0.17678094f, 
    0.14212558f, -0.11911613f, -0.35732231f, -0.01347889f, 0.06948436f, 0.18697539f, 0.17580992f, 0.21120037f, 
    0.26421815f, -0.13850494f, 0.15963222f, 0.59405208f, 0.11315177f, -0.42401463f, 0.52655959f, -0.25409323f, 
    0.29689974f, -0.17109178f, -0.22820066f, -0.00693119f, -0.29261744f, 0.63303411f, 0.03960613f, 0.15153219f, 
    0.18723451f, 0.23048408f, 0.03610581f, -0.04028922f, 0.19637381f, 0.45412838f, -0.19428705f, -0.03911981f, 
    -0.05918126f, -0.42683345f, 0.17818357f, -0.31307292f, 0.19326924f, 0.18932913f, -0.13023841f, 0.38836488f, 
    -0.25104141f, 0.14195038f, 0.16506022f, 0.50263542f, -0.01245440f, 0.28695160f, 0.29301581f, -0.12616958f, 
    0.13190234f, -0.26306915f, -0.04955092f, -0.34601536f, -0.08025667f, 0.54462278f, 0.30863565f, 0.02525600f, 
    0.14704049f, -0.34846437f, -0.20954089f, 0.18346065f, 0.43312925f, 0.11379360f, 0.03201707f, 0.06333156f, 
    0.13569942f, -0.23254678f, -0.62423581f, 0.45197597f, -0.26314589f, -0.14288713f, 0.16903643f, 0.28873608f, 
    0.44124946f, -0.01698082f, -0.08026924f, 0.52872658f, -0.21979333f, -0.46658128f, -0.01537545f, 0.38568631f, 
    -0.22039568f, 0.14614467f, -0.46427056f, 0.22343946f, -0.35367450f, -0.31667405f, 0.15873565f, -0.40237415f, 
    0.05740159f, -0.42422599f, -0.18182659f, -0.03702433f, 0.26965007f, -0.09961401f, 0.31319451f, -0.24527137f, 
    0.13172428f, 0.00912383f, 0.16829085f, -0.15309760f, 0.26739484f, -0.34534678f, 0.16063040f, -0.24559991f, 
    -0.47715756f, 0.02305794f, 0.22318463f, 0.04675874f, 0.14711949f, -0.39863184f, 0.20832503f, 0.33624974f, 
    0.39665884f, -0.26671034f, -0.45466021f, -0.25700197f, 0.05221158f, 0.03720593f, -0.02041074f, 0.46159708f, 
    -0.03328922f, -0.28733820f, -0.12849078f, 0.22738183f, 0.15936093f, 0.28600967f, 0.02088329f, 0.13558285f, 
    0.14081143f, -0.04292522f, -0.08286604f, -0.18881148f, 0.30090871f, -0.07808365f, -0.23299731f, 0.32387069f, 
    -0.20683874f, 0.48580486f, -0.19338971f, 0.26990888f, 0.13626279f, -0.43397307f, -0.20037140f, -0.00948827f, 
    0.15847155f, -0.15292996f, 0.15490337f, -0.21988796f, -0.23977581f, -0.06037318f, 0.16829208f, 0.36699980f, 
    -0.21102370f, 0.05314117f, 0.19057241f, -0.21280667f, 0.06224844f, -0.00516875f, 0.09042654f, -0.27384079f, 
    0.20732479f, -0.03392995f, -0.06936915f, -0.01441973f, -0.15917683f, -0.24640688f, -0.18706283f, 0.11555519f, 
    -0.29502466f, 0.69189769f, -0.19815588f, -0.54912084f, -0.18617722f, 0.38165104f, 0.37407175f, 0.43499827f, 
    -0.32525060f, 0.09561786f, 0.35023460f, -0.06935409f, 0.09195084f, 0.25765967f, -0.31526637f, 0.41719300f, 
    -0.12815072f, 0.03336964f, -0.07092008f, -0.02855740f, 0.26723278f, -0.11052973f, 0.30454013f, -0.32004976f, 
    -0.36986169f, 0.67502081f, 0.14447668f, 0.24128588f, -0.20922241f, -0.26150736f, 0.04433484f, -0.20791800f, 
    -0.05683694f, 0.15461920f, 0.09961617f, -0.38509744f, -0.18395384f, -0.04365990f, 0.36091530f, 0.23317149f, 
    0.21290845f, 0.62223101f, -0.15791351f, 0.32626152f, -0.16474131f, -0.24523634f, -0.02809889f, 0.09783896f, 
    -0.05618338f, -0.22104844f, 0.19746609f, -0.48952290f, 0.20231278f, 0.51863533f, -0.00854778f, 0.31480411f, 
    0.19419795f, 0.35984465f, -0.42593440f, -0.08079796f, 0.11640055f, -0.22980979f, 0.19590455f, 0.26547825f, 
    0.07921963f, -0.10455165f, -0.03484644f, -0.28215933f, 0.12195937f, 0.36739856f, 0.12065143f, -0.15530315f, 
    0.25970870f, 0.27132669f, -0.46322167f, -0.34036329f, 0.28010154f, 0.43078250f, -0.29196206f, 0.14063253f, 
    0.39716989f, -0.07015342f, -0.10884358f, 0.11979552f, -0.18452121f, -0.23458959f, 0.52938426f, 0.06898190f, 
    0.08049867f, -0.11275749f, 0.21341757f, -0.08397725f, -0.28995386f, 0.38119766f, 0.46469051f, -0.33731869f, 
    0.42055398f, -0.28830725f, 0.13315618f, 0.17814907f, 0.26487404f, 0.35101169f, 0.31458879f, -0.22353616f, 
    -0.24052508f, -0.05868306f, 0.18211891f, 0.25279805f, -0.36785254f, 0.29508176f, -0.21726885f, -0.12500003f, 
    -0.09842448f, 0.03021790f, 0.15332344f, 0.14218326f, -0.29524383f, -0.18486011f, -0.37416264f, -0.02486107f, 
    0.25897130f, -0.03477958f, -0.17628160f, 0.14093278f, 0.30673787f, -0.23173216f, -0.28394985f, 0.17954165f, 
    0.01036764f, 0.43389145f, 0.24494335f, 0.09026558f, 0.38811377f, 0.35249472f, -0.20521928f, 0.06249951f, 
    -0.10204294f, -0.35635543f, -0.39793947f, 0.41291541f, 0.00599521f, 0.28229305f, -0.19779684f, 0.05155860f, 
    0.16637310f, 0.10179118f, -0.03153586f, 0.17206866f, 0.24766144f, 0.37648743f, -0.33929744f, -0.20497313f, 
    0.00139052f, -0.33453345f, 0.01491393f, 0.02856312f, -0.26987651f, 0.07709205f, 0.21610312f, -0.57717991f, 
    -0.17475502f, -0.09709466f, 0.15513618f, -0.33826506f, -0.07084197f, 0.43891233f, 0.04045958f, 0.15179780f, 
    0.42573032f, 0.12421299f, -0.17649506f, -0.09426240f, -0.00837851f, -0.61217898f, 0.25046128f, 0.17065859f, 
    0.01422992f, 0.51978236f, 0.00973864f, -0.49439982f, -0.02553893f, 0.20018309f, -0.17255943f, 0.45941114f, 
    -0.03668656f, 0.44261584f, 0.00981414f, -0.38602901f, 0.38872021f, -0.33780232f, -0.26934183f, -0.04708850f, 
    0.08497209f, 0.40044689f, 0.10200347f, 0.07428069f, 0.25294361f, 0.21450111f, 0.05010924f, -0.17697920f, 
    -0.43517327f, 0.07917909f, 0.12816952f, -0.07983410f, 0.16197966f, 0.18029325f, -0.10693768f, 0.04549098f, 
    0.25391433f, 0.31712225f, -0.19831750f, 0.30138788f, 0.01379190f, 0.31148991f, -0.12246443f, 0.42993227f, 
    -0.26049408f, -0.42662966f, -0.35314676f, -0.47859514f, 0.15183353f, 0.11323630f, -0.02061170f, -0.28534058f, 
    -0.32013097f, 0.21698780f, 0.19695218f, -0.19169864f, 0.10588390f, -0.40972358f, 0.14247848f, 0.19300844f, 
    0.42743257f, -0.03511382f, -0.65594769f, -0.26079112f, -0.01391745f, -0.00354358f, -0.35054746f, 0.63321453f, 
    0.45024922f, -0.34283960f, 0.22568052f, -0.19024126f, -0.10128146f, 0.18933351f, 0.17548610f, 0.17803855f, 
    0.47826350f, -0.00971699f, -0.63652909f, 0.13976657f, -0.24968779f, -0.20409413f, 0.00750719f, 0.16591053f, 
    -0.07955327f, 0.13507545f, -0.02911219f, -0.20732272f, -0.07162026f, -0.21549769f, 0.06781425f, -0.26014641f, 
    0.00741287f, -0.23507902f, 0.12831752f, -0.19273214f, -0.26675546f, -0.02844979f, 0.15313967f, -0.11370011f, 
    0.31944475f, 0.53653973f, -0.07106522f, -0.20209029f, 0.07989465f, 0.30410957f, 0.10557383f, -0.14814202f, 
    -0.52051091f, -0.00709674f, -0.59096426f, 0.05992257f, -0.20785816f, 0.16692320f, 0.41538325f, -0.37412032f, 
    0.17761590f, -0.45966953f, 0.23517117f, -0.24985534f, 0.04010148f, 0.03945592f, -0.02757517f, 0.28910792f, 
    0.33659852f, 0.16178201f, -0.19698577f, 0.38636228f, 0.12118252f, -0.02982117f, -0.26145327f, 0.16768520f, 
    0.30452761f, -0.12906553f, -0.22317754f, 0.45761535f, 0.03169891f, 0.34319067f, 0.28749111f, 0.10063656f, 
    0.27834013f, -0.51617807f, -0.35175830f, -0.31010386f, 0.18354389f, 0.15782121f, -0.09336442f, -0.21529026f, 
    -0.26667139f, 0.21716285f, -0.05911757f, 0.76023990f, 0.08078624f, -0.06662418f, -0.05107117f, 0.10724478f, 
    0.22317553f, 0.10474510f, -0.05570003f, -0.34561554f, -0.12824591f, 0.41223249f, 0.16836034f, -0.41109067f, 
    -0.12460408f, -0.18779095f, -0.25184393f, -0.01573206f, -0.23295929f, -0.14429699f, 0.14354928f, -0.00103338f, 
    0.15139182f, -0.27623364f, -0.05182413f, 0.11164446f, -0.24271111f, -0.11098418f, -0.06870943f, -0.15278402f, 
    0.25885212f, -0.16144259f, -0.16344461f, -0.05621890f, 0.11080702f, 0.78847170f, 0.10147028f, -0.01217337f, 
    -0.23425056f, 0.16635258f, -0.01809643f, 0.36415887f, -0.33725619f, -0.11320707f, 0.03353120f, -0.11448000f, 
    0.13055420f, 0.16492708f, -0.17928296f, 0.23756707f, 0.10373450f, 0.51114106f, 0.19094151f, 0.19141558f, 
    -0.42266139f, 0.07910150f, -0.40793735f, 0.14546572f, 0.02613008f, 0.21204247f, 0.23226513f, -0.43493840f, 
    0.34258425f, 0.08069481f, 0.18570425f, 0.22656122f, -0.53448504f, -0.26026914f, 0.27100357f, 0.11885031f, 
    -0.24477535f, -0.38667238f, 0.05418412f, 0.07015990f, -0.09502717f, 0.07652486f, 0.22667177f, 0.04585291f, 
    0.23512137f, 0.04817001f, -0.01939086f, -0.05442856f, -0.80737197f, 0.06888407f, 0.42726123f, -0.02036541f, 
    -0.05701296f, 0.04046617f, -0.07482944f, -0.03962225f, -0.21311046f, 0.62179047f, 0.25509328f, -0.27884406f, 
    -0.33249032f, 0.26237133f, -0.04721937f, 0.16168007f, -0.07087477f, 0.49833155f, -0.12613681f, -0.21296637f, 
    0.40848026f, -0.24533381f, -0.20229833f, -0.06823615f, 0.43088597f, -0.23175405f, 0.14439118f, -0.10939180f, 
    -0.19383641f, -0.20502228f, -0.18346806f, -0.21043888f, 0.19164696f, 0.01700623f, 0.30362150f, 0.33191925f, 
    0.07049429f, -0.22823662f, -0.01191203f, 0.20506789f, -0.20832723f, -0.00019402f, 0.18089782f, 0.21109083f, 
    0.30039018f, -0.44929707f, 0.23242226f, 0.23150045f, 0.06111773f, 0.57361329f, 0.46130517f, -0.11662401f, 
    -0.02502531f, -0.26244265f, 0.02637734f, 0.43484873f, -0.14666168f, -0.26656130f, 0.16934791f, -0.06149986f, 
    -0.12539077f, 0.53043252f, 0.02374361f, 0.53887945f, 0.33885494f, -0.44950220f, -0.06632265f, 0.06143388f, 
    -0.31429070f, 0.35554111f, -0.23182254f, 0.12242603f, -0.50916368f, -0.22679168f, 0.43674430f, -0.25389433f, 
    -0.02914514f, -0.22800952f, -0.09652370f, -0.14096524f, -0.12232485f, -0.30416521f, 0.19961007f, 0.33180058f, 
    0.07616436f, -0.28218457f, 0.58177722f, -0.06865614f, -0.01975184f, -0.18762448f, 0.08479744f, 0.37522727f, 
    0.01139984f, 0.18003343f, 0.10607970f, 0.46552566f, 0.23551197f, 0.28312340f, -0.11922669f, 0.20829368f, 
    -0.41598117f, 0.20750734f, -0.36581749f, -0.33803892f, 0.07281189f, 0.18423183f, 0.19330485f, -0.29493171f, 
    0.33837232f, -0.08400963f, -0.12867801f, -0.28661227f, -0.32076469f, 0.29951715f, -0.00115506f, 0.28389245f, 
    0.05822562f, -0.17599279f, -0.06413908f, -0.21924911f, 0.17287923f, -0.10324229f, 0.12080335f, -0.25911328f, 
    -0.30474928f, 0.17613073f, 0.17559585f, -0.04902016f, -0.65553916f, -0.46708941f, 0.35240334f, 0.43765619f, 
    0.17184725f, 0.36367056f, -0.07675060f, 0.00385669f, -0.33327475f, 0.26619864f, 0.32503235f, -0.20089029f, 
    -0.09017044f, 0.50087959f, -0.15529104f, 0.44161126f, 0.15245482f, -0.02844175f, -0.23126362f, -0.20010741f, 
    -0.31067514f, -0.05680362f, 0.00905705f, 0.13839331f, 0.14736350f, 0.37905711f, 0.03371666f, 0.04408820f, 
    0.25618866f, -0.33602217f, -0.04247976f, 0.74513286f, 0.12703127f, -0.57766789f, 0.06664479f, 0.22663489f, 
    -0.05704390f, 0.14863245f, -0.02029218f, -0.37250549f, -0.02210009f, -0.23455234f, 0.26972336f, -0.43049058f, 
    0.19021970f, -0.33145615f, -0.24199632f, 0.11175234f, 0.13212977f, 0.31901503f, -0.51983666f, -0.20116033f, 
    0.17713761f, -0.47434098f, 0.10026723f, 0.09605674f, 0.04062081f, -0.35511538f, -0.16193761f, 0.75251704f, 
    0.04059952f, 0.07575296f, -0.10060831f, 0.05237931f, 0.26832432f, 0.04062347f, -0.42802945f, 0.05297238f, 
    0.04691742f, -0.11907838f, -0.30476353f, -0.13604577f, 0.38237768f, 0.50622422f, -0.34485331f, -0.07436320f, 
    0.12613837f, 0.22830884f, -0.11322880f, -0.90097570f, -0.15725555f, 0.50544059f, 0.47984856f, -0.23105547f, 
    -0.02948064f, 0.48249516f, -0.42352691f, -0.23120542f, -0.44886693f, -0.23155048f, 0.12650129f, 0.18863834f, 
    0.07289802f, 0.43811083f, 0.02563587f, -0.21681920f, -0.22627385f, 0.36575535f, -0.23728669f, 0.40913391f, 
    0.20594969f, -0.41499880f, -0.26849467f, -0.33413947f, 0.23886818f, -0.22039393f, -0.42249647f, 0.37177312f, 
    0.09329306f, -0.41399056f, -0.20230499f, 0.43940774f, 0.37881875f, 0.44316956f, 0.41607881f, 0.06375644f, 
    -0.29527450f, -0.40578339f, -0.17596981f, 0.37186569f, -0.02953641f, -0.10033111f, 0.29492614f, -0.20989263f, 
    0.30412394f, 0.15160722f, 0.11503400f, -0.42929870f, 0.23581897f, 0.37918538f, 0.16120805f, 0.04781878f, 
    -0.30455649f, -0.34586468f, 0.30908468f, 0.16765723f, 0.07921027f, 0.02234434f, -0.02473797f, -0.09830701f, 
    -0.06223796f, 0.10892674f, -0.03615409f, -0.21913883f, -0.09604877f, 0.05859680f, 0.15763472f, -0.18840683f, 
    -0.08322102f, -0.09042289f, 0.07056907f, 0.02525487f, -0.07089577f, -0.27354616f, -0.05009012f, -0.05173545f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.35471728f, 0.31357372f, 0.14209729f, -0.03799414f, -0.02651626f, -0.19519258f, 0.13194786f, 0.04525663f, 
    0.05762091f, 0.11166992f, -0.16596158f, 0.29449555f, 0.00552969f, 0.33723983f, 0.48401234f, -0.02010957f, 
    0.12449910f, 0.20131961f, 0.42825285f, -0.24323663f, -0.04175577f, -0.09625351f, 0.14157949f, -0.30304125f, 
    0.07452679f, 0.08010856f, -0.22067471f, 0.35888615f, 0.02840815f, 0.11710731f, 0.23007789f, 0.25737146f, 
    0.24114046f, 0.21285646f, 0.05089639f, 0.09514567f, 0.05911260f, 0.28361753f, 0.31246760f, 0.22191739f, 
    0.21087866f, 0.25937110f, 0.02621673f, 0.18500178f, -0.05041221f, 0.01397052f, 0.38196829f, -0.16796835f, 
    0.21470051f, 0.10009459f, -0.16990441f, 0.30569237f, 0.10263540f, -0.11875195f, -0.03737053f, 0.29528043f, 
    -0.14887060f, 0.01786521f, 0.25715610f, 0.17465910f, -0.11486620f, -0.14724882f, 0.04204922f, 0.11952621f, 
    0.20134301f, -0.01503755f, 0.19348313f, -0.01317031f, 0.09964529f, 0.22902386f, 0.04323309f, 0.03708260f, 
    -0.13575824f, -0.01728150f, 0.01969971f, 0.33002514f, -0.05199601f, 0.12309401f, 0.47737759f, 0.46313980f, 
    0.11386602f, 0.13073204f, 0.28016225f, -0.20510484f, 0.08950806f, -0.00617683f, 0.07747936f, 0.05670528f, 
    -0.00371150f, -0.16159487f, 0.26745233f, 0.28272018f, 0.10512576f, 0.31445357f, -0.19296885f, -0.24555413f, 
    0.08411720f, -0.26970890f, 0.19390623f, -0.33065525f, 0.05710692f, 0.02179984f, 0.03454598f, 0.13209508f, 
    0.23137699f, 0.08740011f, 0.00654066f, -0.09592334f, -0.02982695f, 0.11405443f, -0.11230719f, -0.13792649f, 
    -0.32634372f, 0.26687965f, 0.34923387f, -0.06171523f, 0.21694230f, 0.18901971f, 0.06855888f, 0.35647979f, 
    0.17193997f, -0.14901236f, 0.36325124f, 0.10991072f, 0.27820444f, 0.17594752f, -0.26249620f, -0.30005026f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07788255f, 0.13549531f, 0.05537074f, -0.09109746f, -0.43836230f, 0.01149919f, -0.20126615f, 0.08239327f, 
    -0.36302492f, 0.05383900f, -0.04788966f, -0.24857248f, -0.38264531f, -0.06805471f, -0.41649196f, -0.05991056f, 
    0.03322497f, 0.01514190f, -0.71080482f, -0.06444626f, 0.00544220f, 0.14391451f, 0.06961992f, 0.16611500f, 
    0.08879735f, -0.28579578f, 0.11420107f, -0.32074252f, 0.17977574f, 0.12567177f, -0.36030957f, -0.15026215f, 
    0.06709760f, 0.03207033f, -0.26234367f, -0.07287511f, 0.04528909f, -0.03440748f, -0.02199297f, -0.65477556f, 
    0.04248303f, -0.69559449f, 0.10160131f, -0.68453199f, 0.12107056f, -0.59650922f, -0.19933914f, 0.05026195f, 
    0.09477442f, 0.15497282f, -0.04885390f, -0.09556197f, -0.35171467f, -0.27968809f, 0.12565517f, -0.76094949f, 
    -0.02589319f, 0.24888889f, -0.07286024f, -0.42550835f, -0.01173800f, 0.00318547f, -0.43019190f, -0.72374845f, 
    -0.48144069f, 0.24949904f, 0.19761944f, 0.04809060f, 0.08797852f, -0.23934121f, 0.14309366f, 0.10640076f, 
    0.51260978f, -0.04653998f, 0.10126993f, -0.22760296f, 0.10963259f, -0.18067972f, 0.46065789f, -0.08904876f, 
    0.07403614f, 0.17109226f, 0.12305046f, 0.21120581f, -0.04573533f, 0.05062115f, -0.49287578f, 0.12318476f, 
    0.15554304f, -0.06309296f, -0.30909601f, -0.01933230f, -0.26246887f, 0.41280138f, -0.21322657f, 0.41907316f, 
    0.04424693f, 0.09793339f, -0.26955539f, 0.24883503f, 0.32811299f, 0.07812432f, 0.10911983f, 0.13744430f, 
    -0.08896621f, -0.27765852f, -0.07148764f, -0.59070414f, -0.41126448f, -0.08644010f, -0.56898701f, -0.11467322f, 
    0.19481254f, -0.37947553f, -0.38395175f, 0.24798065f, -0.42145696f, -0.01641372f, -0.02868975f, -0.15250947f, 
    -0.10963742f, -0.10329987f, -0.24396011f, 0.06096418f, 0.25026155f, 0.00620194f, -0.05951483f, -0.02750689f, 
    -0.00378520f, 0.13071737f, -0.06581973f, -0.09709438f, 0.09633406f, 0.00685609f, -0.04674457f, 0.14954497f, 
    0.20229715f, 0.19686279f, -0.08037683f, -0.10667378f, -0.18305551f, 0.24847940f, -0.00318924f, -1.11565673f, 
    0.14028986f, 0.01295280f, -0.49546209f, -0.18505473f, 0.53573614f, 0.11134790f, -0.04725287f, -0.00496342f, 
    0.05318051f, 0.16585392f, -0.02025544f, -0.06506908f, 0.12446171f, 0.28645143f, 0.50656968f, -0.00719851f, 
    0.12356915f, -0.17822008f, -0.38577619f, 0.03793262f, -0.08171278f, 0.31001720f, 0.15013422f, -0.08395961f, 
    -0.19204517f, -0.38287705f, 0.50686032f, -0.18047951f, 0.23840815f, -0.27370679f, 0.12658733f, 0.00617918f, 
    0.16825594f, -0.08783047f, -0.01708862f, 0.10931582f, 0.27550364f, 0.00266989f, 0.06690826f, -0.24477680f, 
    0.10203155f, -0.43864557f, -0.19594006f, 0.05492862f, 0.05152286f, 0.04821163f, -0.09848146f, -0.98087180f, 
    -0.15683581f, 0.29634899f, -0.47663587f, -0.02317508f, 0.09722501f, -0.25816357f, -0.26620355f, 0.06387510f, 
    -1.13051271f, -0.23627228f, -0.07495098f, -0.13531037f, 0.09570310f, -0.04532166f, 0.19093399f, -0.69819361f, 
    -0.05627268f, 0.27603829f, 0.12338107f, 0.20267791f, 0.01567448f, 0.37375998f, 0.42431888f, -0.02059300f, 
    0.04798155f, -0.01797276f, -0.50797743f, 0.23127125f, 0.19515310f, 0.29183406f, -0.14028350f, -0.62097150f, 
    0.24302337f, 0.07274099f, -0.10865178f, 0.29900688f, -0.72557735f, -0.01455872f, -0.62267631f, 0.04300415f, 
    -0.07079242f, -0.02179365f, -0.04876786f, 0.31297067f, -0.10381260f, -0.41194603f, -0.67657387f, -0.10504374f, 
    -0.10753489f, 0.25100860f, 0.09184093f, -0.10340439f, 0.00157218f, -0.29120794f, -0.15809619f, 0.10018657f, 
    -0.13195087f, 0.04538693f, 0.08411241f, -0.29403886f, 0.32010242f, 0.19920202f, 0.00321043f, -0.04810812f, 
    0.11436763f, 0.02104970f, 0.16975704f, 0.07321702f, -0.57692826f, 0.03111792f, 0.04675090f, 0.33977708f, 
    -0.67946249f, 0.27932823f, 0.04628925f, 0.60309011f, -0.02652272f, 0.08913125f, -0.03035780f, -0.04186228f, 
    -0.11268486f, 0.13850293f, 0.12741914f, -0.13118348f, -0.14800051f, -0.12981267f, 0.04369081f, -0.04141332f, 
    -0.14089990f, -0.62274480f, -0.17276859f, -0.16031560f, -0.13133882f, -0.29873118f, -0.19521241f, 0.17548627f, 
    0.17877376f, 0.65254784f, 0.02585407f, -0.15694876f, -0.20779262f, 0.20247471f, 0.04904018f, 0.20116490f, 
    0.21921080f, -0.03290710f, -0.81504601f, 0.19081669f, 0.32802624f, 0.09334378f, -0.15349840f, -0.05234105f, 
    -0.15006715f, 0.00610841f, -0.06217636f, -0.07758272f, -0.07497959f, 0.01090729f, -0.13869174f, -0.30890647f, 
    0.18854734f, -1.03652489f, -0.00000055f, 0.12367671f, 0.10304065f, -0.00888522f, -0.11512811f, -0.00359616f, 
    0.11357880f, -0.44564810f, -0.47552666f, -0.06157636f, 0.00028439f, -0.01509316f, 0.02969205f, 0.06509013f, 
    -0.06914140f, -0.36533177f, -0.22237524f, 0.04524947f, -0.00971656f, 0.23364475f, -0.29057151f, 0.28061178f, 
    0.32840934f, -0.73575979f, -0.14984651f, 0.22531562f, -0.02312056f, 0.01909969f, -0.08089938f, -0.24058859f, 
    -0.46369416f, -0.29463062f, 0.16912487f, -0.33850232f, -0.02458753f, 0.19914831f, -0.12186179f, -0.50860858f, 
    -0.12223221f, 0.04841475f, 0.07012844f, -0.50753385f, -0.98282367f, 0.00371763f, 0.47474447f, -0.47294587f, 
    -0.15295047f, 0.17870036f, 0.03272536f, -0.60329294f, -0.05690425f, 0.06895585f, 0.13267696f, 0.07966761f, 
    -0.24900237f, -0.46682489f, 0.29886994f, -0.00992795f, -0.02280035f, -0.11684106f, 0.19671720f, 0.22715385f, 
    -0.02030625f, 0.09297039f, 0.02832679f, -0.62067676f, -0.18090396f, -0.31579927f, -0.09320249f, -0.09184366f, 
    0.14366347f, 0.12346757f, 0.09418730f, -0.10266787f, -0.49748567f, -0.06259549f, -0.36077204f, -0.74753380f, 
    -0.49379030f, 0.03888446f, -0.01092438f, 0.11201560f, 0.23484288f, -0.56285661f, -0.12124185f, 0.15959059f, 
    -0.40605494f, 0.03059254f, 0.15658347f, 0.07471021f, -0.21010637f, -0.71631122f, 0.05275047f, 0.12430204f, 
    -0.44901279f, 0.42494425f, -0.10773191f, -0.49862894f, 0.21089959f, 0.04385444f, 0.15223528f, -0.58103311f, 
    0.30542758f, 0.18666573f, 0.15268128f, -0.24006167f, -0.27803397f, -0.04296303f, -0.77915365f, 0.04482521f, 
    0.27866957f, -0.14550380f, -0.03956573f, 0.06500719f, -0.36255017f, 0.01624514f, -0.69859141f, -0.01777264f, 
    0.06385961f, 0.14537612f, -0.04201128f, -0.11543962f, -0.29808822f, 0.04432727f, -0.42731225f, 0.22158195f, 
    -1.07436848f, 0.10523985f, 0.11599071f, -0.24046324f, -0.45395371f, 0.01659984f, 0.02257496f, 0.42181867f, 
    0.05144517f, -0.02304770f, 0.16210048f, -1.00676191f, 0.11525251f, 0.01853124f, 0.14940318f, 0.34325498f, 
    0.09191848f, 0.06444719f, 0.04554372f, -0.47418138f, -0.15725996f, 0.00006067f, -0.38845018f, 0.15350361f, 
    0.17149605f, -0.02241924f, -0.15337624f, -0.08301110f, -0.01975479f, 0.18954140f, -0.34790513f, 0.03292349f, 
    0.15302996f, -0.09922142f, 0.05095176f, -0.33431008f, 0.28341866f, -0.27743080f, -0.64256018f, 0.03925771f, 
    0.13505359f, -0.42242950f, 0.30483490f, -0.00448191f, -0.12701471f, -0.06021244f, 0.41209748f, -0.15204068f, 
    -0.14539433f, -0.12228296f, -0.00098447f, 0.02095191f, 0.04908977f, 0.21816932f, 0.10484061f, 0.66373789f, 
    0.10407358f, -1.22483599f, 0.11048883f, 0.08662271f, 0.09263725f, 0.40480006f, 0.23578118f, -0.33651578f, 
    -0.04308781f, 0.08044173f, -0.36762023f, 0.14576754f, 0.14184710f, -0.85462129f, -0.27290511f, 0.06554948f, 
    -0.01884403f, 0.12673797f, -0.08660883f, -0.04099500f, -0.01273037f, -0.06435851f, 0.22898938f, 0.05192245f, 
    0.01043111f, -0.10031056f, -0.08052366f, -1.03489804f, 0.07389733f, -0.05193225f, 0.03953445f, 0.27491170f, 
    0.16640973f, -0.32208097f, 0.24249230f, 0.04151973f, -0.27608696f, 0.22760767f, 0.04188956f, -0.13557599f, 
    -0.04396390f, -0.88823092f, -0.01547835f, 0.11389729f, -0.13909157f, 0.05884850f, -0.49514171f, -0.16387419f, 
    -0.32927239f, 0.00483156f, 0.20773207f, 0.18757471f, 0.04921451f, -0.13009070f, -0.24217834f, -0.03868874f, 
    0.09710223f, 0.09718555f, -0.19563597f, -0.08238355f, -0.34088770f, -0.35841641f, 0.01643972f, -0.02472434f, 
    0.15819167f, 0.10916989f, -0.00915790f, 0.02893442f, 0.34285101f, -0.16190432f, 0.10075178f, -0.42188236f, 
    -0.08482727f, 0.10688920f, 0.16312635f, 0.22321515f, 0.13326861f, -0.09160142f, -0.12064868f, -0.89427090f, 
    -0.13464868f, 0.09507746f, 0.11609601f, 0.09156523f, 0.12613769f, 0.09951882f, 0.03433866f, -0.14122336f, 
    -0.30096853f, 0.16510868f, 0.03743416f, 0.28920662f, -0.24052279f, -0.04759232f, -0.05282033f, -0.26051086f, 
    0.08943339f, -0.00882953f, -0.10901323f, -0.04739727f, -0.03432164f, -0.01050016f, -0.76050574f, 0.24818921f, 
    0.11724284f, 0.15640701f, 0.22122072f, -0.64696574f, -0.60877669f, -0.59674639f, 0.09761590f, -0.23000729f, 
    -0.19168928f, -0.18233420f, -0.98002118f, 0.01611113f, 0.01893938f, 0.03137443f, -1.04546440f, 0.04286193f, 
    -0.27779335f, -0.10214402f, -0.10901465f, -0.45230776f, -0.14262372f, -0.15190907f, 0.18328324f, -0.17065366f, 
    0.08990962f, -0.04971124f, -0.07239337f, 0.01690640f, -0.22043203f, -0.19365454f, 0.16967186f, -0.30705437f, 
    -0.05916169f, 0.05892399f, -0.63290030f, 0.40571555f, -0.31459594f, 0.06200243f, 0.07432483f, -0.09481919f, 
    -0.00042484f, 0.13059959f, 0.17798334f, 0.07339095f, 0.20637418f, -0.04184350f, -0.13515428f, -0.50382632f, 
    0.34391418f, 0.16886601f, -0.02295507f, -0.62362862f, 0.32838309f, 0.17833531f, -0.05528016f, -0.15092252f, 
    -0.05285725f, -0.09915712f, 0.10896393f, -0.02246626f, 0.03923858f, -0.13722432f, 0.03425664f, 0.03099339f, 
    -0.08002926f, -0.16815253f, -0.08045504f, 0.17477246f, 0.03457723f, 0.02878313f, -0.19417065f, -0.17751329f, 
    -0.49042904f, -0.13151221f, 0.02811570f, 0.06320186f, 0.17304292f, 0.02029361f, 0.03211470f, 0.24248932f, 
    -0.37769714f, 0.31628940f, -0.16193746f, 0.26978409f, 0.10839847f, 0.38541082f, 0.03675089f, -0.04895269f, 
    0.08574083f, 0.23848116f, 0.04224370f, -0.03232373f, -0.83939391f, 0.12033649f, 0.14758722f, -0.46491501f, 
    -0.03647823f, -0.19846442f, 0.04872035f, -0.46715453f, 0.12561686f, 0.11533406f, 0.04869917f, 0.29276511f, 
    -0.18909793f, -0.26828146f, -0.04976248f, 0.17797045f, 0.13114706f, 0.01238561f, -0.03947607f, 0.00733004f, 
    0.10317860f, 0.00358918f, 0.05856019f, 0.09104561f, 0.13875678f, 0.07968193f, -0.35448569f, -0.27714664f, 
    -0.04845152f, 0.00007615f, 0.10712554f, -0.28321475f, -0.08478620f, 0.09697295f, -0.22304283f, -0.14665446f, 
    -0.03630423f, 0.09091604f, 0.04835760f, -0.37649274f, -0.52496809f, 0.03489595f, 0.09203562f, -0.50242794f, 
    0.01419942f, -0.06446465f, 0.11551293f, -0.01929583f, -0.10057525f, -0.00333924f, -0.56374103f, 0.10479491f, 
    0.20327631f, -0.02135309f, -0.02512693f, -0.02172635f, -0.08855767f, 0.08731586f, 0.24523139f, -0.35558996f, 
    -0.04497321f, 0.05370925f, -0.83676994f, 0.04082044f, -0.06711672f, 0.16780259f, 0.03109050f, -0.08834749f, 
    -0.10408694f, 0.09446006f, 0.09833469f, -0.90674937f, 0.07459006f, -0.19368333f, 0.23235886f, -0.07520396f, 
    -0.11211817f, -0.74328321f, -0.17816691f, 0.09596717f, -0.33940238f, -0.03984070f, -0.03533811f, 0.33500007f, 
    -0.42466316f, -0.23455760f, -0.02335306f, 0.29349822f, -0.04403788f, 0.01929750f, -0.77617067f, -0.08582486f, 
    0.06605624f, 0.25721520f, -0.26792178f, -0.25002286f, 0.00693082f, 0.10252387f, -0.00701615f, -0.00060429f, 
    -0.25846869f, 0.27836698f, -0.31512365f, -0.15000878f, -0.35106915f, -1.09549952f, -0.03736127f, 0.18624105f, 
    0.05243634f, 0.21395390f, -0.15561429f, -0.73600096f, 0.07235456f, 0.28827032f, 0.22980957f, -0.35800359f, 
    -0.10352476f, -0.12537716f, -0.04305664f, -0.40738624f, 0.46861121f, 0.25441819f, -0.15765022f, -0.05613838f, 
    -1.25749540f, -0.34327155f, -0.03109445f, 0.08581664f, 0.31653869f, 0.01019065f, -0.15468656f, 0.02980309f, 
    -0.24408965f, 0.05538388f, 0.02212543f, 0.21314202f, 0.00909639f, -0.27635181f, 0.13818295f, -0.41106027f, 
    0.08272240f, -0.22010165f, -0.68450755f, -0.00116500f, -0.42230198f, 0.15525903f, 0.11248028f, 0.06459509f, 
    0.00363206f, -0.51374698f, -0.01786471f, 0.25722438f, 0.06861495f, 0.32996792f, 0.15291315f, 0.16714840f, 
    -0.12806714f, -0.62818432f, -0.09031741f, 0.22431804f, -0.03766528f, -0.98439974f, 0.16738237f, -0.80320543f, 
    -0.68713349f, -0.45759773f, 0.10476160f, 0.19400361f, 0.13133904f, 0.09090417f, 0.24695037f, -0.03248641f, 
    -0.83935064f, 0.13445528f, 0.29066396f, -0.13951263f, -0.76990980f, 0.03054382f, 0.32682127f, -0.38232920f, 
    0.19344176f, 0.28314570f, -0.09871231f, 0.00513433f, 0.18566781f, 0.15968406f, -0.00666900f, 0.05137474f, 
    -0.15200360f, -0.01261996f, 0.32561123f, -0.20346764f, 0.30841988f, -0.07533037f, -0.51868993f, 0.21332434f, 
    0.23131900f, 0.05924743f, -0.05749140f, -0.03523417f, -0.78336686f, 0.22426870f, -0.11575625f, -0.03465725f, 
    -0.15096669f, -0.96912414f, 0.12267338f, -0.13137835f, -0.07587517f, 0.07630622f, 0.15054961f, 0.00864739f, 
    0.00008382f, -0.51724207f, -0.07442443f, 0.87042910f, -0.07231983f, -0.27503842f, 0.01639415f, 0.41595769f, 
    -0.20053451f, 0.10369706f, 0.08845057f, -0.01963065f, -0.32821757f, 0.05469081f, 0.06284441f, 0.09182978f, 
    -0.15267433f, 0.26063037f, 0.23121046f, 0.07603317f, -0.28260219f, -0.13154936f, -0.15228103f, 0.04714240f, 
    -0.02835464f, -0.43107083f, -0.23135091f, -0.02385816f, 0.10355390f, -0.14489047f, 0.01389709f, 0.14333825f, 
    -0.51708859f, -0.43456468f, -0.08133636f, -0.13156413f, -0.80017483f, -0.46507034f, 0.15383711f, 0.06210848f, 
    -0.68036634f, 0.58817631f, -0.00124778f, -0.30071580f, -0.32634854f, 0.09734733f, -0.01391508f, -0.55793738f, 
    0.01191955f, 0.07791981f, 0.27204815f, 0.19252759f, 0.19086513f, -0.28805900f, 0.16091534f, 0.31132671f, 
    0.11972991f, -0.30115661f, 0.04355649f, 0.03699345f, -0.43823960f, 0.10932523f, 0.12921463f, 0.05123110f, 
    -0.04036240f, 0.08799659f, -0.16662531f, -0.27737850f, 0.05433076f, -0.58266664f, -0.40022501f, -0.53222245f, 
    -0.15131204f, -0.28570098f, -0.03525805f, -0.19357640f, 0.01072338f, 0.10994093f, -0.26312599f, -0.12003063f, 
    -0.47640181f, -0.22945903f, 0.14392370f, 0.13127284f, 0.24854630f, -0.67918259f, -0.06726537f, -0.64578551f, 
    0.19482890f, 0.16377914f, -0.23726976f, -0.18225653f, -0.78717721f, -0.02455514f, 0.06794300f, -0.02585823f, 
    -0.27535382f, -0.54316658f, 0.07766995f, -0.08528709f, -0.13500248f, 0.16634674f, 0.33073437f, 0.12438791f, 
    -0.11666163f, -0.15328898f, -0.43108788f, 0.08703437f, -0.21659628f, 0.02902842f, -0.10784838f, 0.05366573f, 
    -0.10749458f, 0.03981492f, -0.04880814f, 0.25103495f, -0.55623221f, -0.14983644f, 0.23459120f, 0.01512219f, 
    -1.04343987f, -0.80993009f, 0.34109676f, 0.30057374f, -0.08560957f, 0.06563086f, -0.10305060f, -0.46866408f, 
    0.09594755f, -0.38943645f, -0.09291174f, -0.65535110f, -0.02395766f, 0.42065945f, 0.38761613f, -0.41877273f, 
    -0.11804345f, -0.08308405f, -0.03655383f, 0.04481818f, -0.38228413f, -0.21517359f, 0.05383912f, -0.27207875f, 
    0.15932675f, -0.15633775f, -0.15430872f, 0.21317717f, 0.00373089f, 0.16021070f, 0.17291547f, 0.14200243f, 
    -0.50073123f, -0.80412418f, 0.19367857f, 0.27846301f, 0.03609431f, 0.00993992f, -0.00711783f, 0.09876391f, 
    -0.37660718f, -0.03461082f, -0.57691813f, -0.18183069f, -0.28259212f, -0.12034365f, 0.11537277f, -0.00266104f, 
    -0.03723300f, -0.34792992f, -0.04425427f, 0.11254986f, -0.12614560f, 0.28409439f, 0.09343037f, 0.44316801f, 
    -0.36833489f, 0.08215049f, -0.61847478f, -0.23442943f, -0.23565669f, 0.18754387f, -0.01747975f, 0.54787916f, 
    -0.05188689f, -0.26682892f, -0.37002534f, -0.28496066f, -0.07226548f, -0.00936771f, -0.92334604f, -0.49826097f, 
    -0.07778487f, -0.17511514f, 0.20795633f, 0.03714919f, 0.16360070f, 0.12229554f, 0.03447643f, -0.90488458f, 
    0.00196851f, -0.48835132f, 0.21960771f, -0.32280597f, 0.03964047f, -0.27115321f, -0.03629681f, -0.37090561f, 
    0.23783369f, 0.49209929f, -0.12646399f, -0.01691418f, 0.08259056f, 0.04706400f, 0.17170626f, -0.17553462f, 
    0.05603370f, 0.05154968f, 0.02987337f, -0.39894053f, -0.18793088f, -0.04570220f, 0.07382978f, 0.06125385f, 
    0.22259018f, -0.04380600f, 0.00506159f, 0.02008669f, 0.08377369f, -0.38541624f, 0.05656869f, 0.04394221f, 
    -0.56461430f, -0.04539530f, -0.69833779f, -0.46378702f, 0.07030758f, 0.26346514f, -0.65853959f, 0.00281044f, 
    -0.09874501f, -0.17915614f, 0.31713098f, 0.55929381f, 0.06929050f, -0.05602440f, 0.09290462f, -0.09046425f, 
    0.25855786f, 0.11119289f, -0.59623969f, 0.02591616f, -0.23694059f, -0.00749076f, -0.02009763f, -0.42295295f, 
    -0.08535098f, 0.25202441f, -0.11070411f, -0.24476063f, 0.05034420f, -0.07443592f, -0.23892218f, 0.35785785f, 
    -0.11252587f, 0.02338092f, 0.04176472f, 0.07687104f, -0.62609959f, 0.08608469f, -0.07110739f, -0.51669985f, 
    -0.11508163f, 0.13930334f, -0.16549897f, 0.08626720f, -0.24329156f, -0.32795906f, -0.42175213f, -0.00431145f, 
    -0.01433596f, -0.12122399f, 0.06882618f, -0.00728538f, 0.10033876f, -0.05354127f, 0.11340433f, -0.55791241f, 
    0.08331578f, 0.18931283f, -0.56360942f, -0.05672824f, -0.36937076f, -0.01387287f, -0.12594923f, -0.03303202f, 
    -0.37518847f, 0.08837783f, 0.01424053f, 0.21424088f, 0.00673212f, -0.25423348f, 0.03304453f, 0.23994896f, 
    -0.84690499f, -0.71488976f, 0.26812276f, 0.06158468f, 0.00111312f, -0.14805865f, 0.15686260f, -0.58868563f, 
    -0.00915762f, -0.72223026f, 0.33932480f, -0.22993696f, 0.08418719f, 0.19448702f, 0.35104614f, 0.21386582f, 
    0.04238272f, -0.16539581f, 0.04949630f, 0.32346109f, -0.37367293f, 0.06799978f, 0.43009150f, 0.43224451f, 
    0.05336036f, 0.31346521f, 0.18503748f, 0.07815708f, -0.11826899f, -0.78055441f, 0.12908499f, -0.10410186f, 
    -0.06750853f, -0.15305749f, 0.15846229f, 0.18592270f, -0.23513527f, -0.32568154f, -0.65642190f, -1.40718794f, 
    -0.45425016f, -0.43216813f, -0.01301293f, -0.29755279f, 0.51300496f, 0.01653407f, -0.54838866f, 0.28293964f, 
    0.26328456f, 0.17945157f, -0.06884067f, -0.15748881f, -0.05811019f, 0.09865444f, -0.02473472f, -0.15882353f, 
    0.07225345f, 0.07168292f, 0.15041351f, 0.01077688f, 0.02890627f, 0.01788053f, 0.04533008f, -0.08017043f, 
    0.32691738f, -0.71564645f, 0.00120589f, -0.15386748f, 0.26287457f, 0.08551664f, -0.45631754f, -0.02236285f, 
    0.05272195f, -0.19078097f, -0.15066193f, 0.21065837f, -1.02409649f, 0.06317753f, 0.31454182f, 0.06752787f, 
    0.29440206f, -0.19598278f, -0.00216028f, 0.03329606f, -0.95980084f, 0.06888279f, 0.30794328f, -0.78179514f, 
    -0.79393500f, -0.01559854f, 0.25342697f, 0.02625769f, 0.13027672f, -0.12558129f, -0.02328644f, 0.40082231f, 
    -0.67480457f, -0.31944957f, 0.41340575f, 0.05514582f, -0.21700010f, 0.26942852f, -0.49241072f, 0.23495056f, 
    0.09414634f, -0.45226020f, 0.06247776f, 0.22915156f, -0.17744547f, -0.24396691f, 0.08179174f, 0.28087595f, 
    0.09245902f, 0.14970516f, 0.09331701f, 0.10053401f, -0.24780717f, -0.08385384f, 0.14759479f, -0.01822168f, 
    -0.30328739f, -0.72322035f, 0.05301634f, 0.17749284f, 0.09922388f, 0.24732709f, -0.33246854f, 0.12975605f, 
    -0.54305381f, 0.03487723f, -0.04165566f, 0.07613852f, -0.60281086f, -0.41717550f, 0.15880194f, -0.30365530f, 
    0.23875247f, -0.00730477f, 0.06905427f, -0.61212313f, -0.02873000f, -0.24518789f, -0.47582176f, -0.29503635f, 
    -0.58398569f, 0.18899345f, -0.10412627f, -0.70268148f, -0.34638685f, -0.48526806f, -0.35661513f, 0.16441953f, 
    0.13663083f, -0.41650119f, 0.06859934f, -0.79581809f, -0.03940656f, -0.01140130f, 0.14210179f, 0.37735337f, 
    0.24845378f, 0.03751262f, -0.21243075f, -0.04515161f, -0.24849416f, -0.29490012f, -0.74821812f, 0.28496450f, 
    0.43199807f, 0.13501310f, -0.03916311f, -0.54824555f, -0.11339789f, -0.07232635f, -0.70681649f, 0.14654975f, 
    -0.23181450f, 0.00532957f, -0.02226474f, -0.09298299f, 0.08100197f, -0.35784402f, -0.17774321f, -0.24613008f, 
    -0.36198953f, -0.69539291f, 0.13468097f, -0.38806820f, 0.13824676f, 0.16498588f, 0.03722705f, 0.02490149f, 
    0.13557358f, -0.22610196f, 0.10417899f, -0.09102037f, -0.15480793f, -0.39081079f, -0.60763693f, 0.05194917f, 
    0.03204633f, -0.35749114f, -0.45647883f, -0.23520611f, -0.05938955f, -0.00504111f, -0.05412210f, 0.01428246f, 
    -0.24543893f, -0.45665607f, 0.01397896f, -0.70449638f, 0.15971269f, -0.83655751f, 0.06510617f, -0.30406865f, 
    0.21200699f, -0.16047926f, 0.18749268f, 0.10765114f, 0.27052745f, -0.20623568f, 0.03160955f, 0.14916600f, 
    0.20194289f, -0.42024857f, -0.54211026f, 0.18726967f, -0.42795837f, -0.36499628f, 0.19485943f, -0.06702112f, 
    0.09413531f, 0.14166127f, 0.29420027f, -0.36439496f, -0.34191379f, -0.87172496f, -0.05260998f, 0.16270021f, 
    0.45189533f, 0.37775877f, -0.51631433f, 0.13534993f, 0.23753834f, 0.17878917f, 0.07815107f, -0.07495608f, 
    0.35141319f, -0.41993648f, 0.07993287f, 0.18120192f, 0.17647988f, -0.41273004f, -0.40265068f, 0.44320214f, 
    -1.04541016f, -0.01034677f, -0.19581737f, 0.09785984f, -0.13333353f, 0.28558776f, 0.08744447f, 0.14067242f, 
    0.16423142f, -0.50299519f, -0.02158063f, -0.25113198f, -0.32318294f, 0.06367404f, -0.30579829f, -0.56199718f, 
    -0.07491050f, 0.29876140f, 0.09853458f, 0.04060365f, -0.38435295f, -0.29672015f, 0.44008148f, 0.01404198f, 
    -0.70087105f, -0.28174946f, -0.27317813f, -0.64464438f, -0.09840664f, -0.35189331f, -0.49500683f, 0.05426829f, 
    0.09586044f, -0.13047901f, -0.10959186f, 0.05224353f, 0.49293616f, 0.47071761f, -0.01035877f, -0.64343077f, 
    -0.36149377f, -0.06825087f, 0.11589739f, -0.61445224f, 0.00861045f, -0.03583229f, 0.40662107f, 0.19193594f, 
    -0.10653354f, -0.32631996f, 0.05334952f, 0.15965676f, 0.17495783f, -0.09772845f, -0.00892517f, -0.43721175f, 
    0.07687641f, -0.04837773f, 0.12970260f, -0.69598716f, 0.07498245f, -0.07718686f, -0.03511266f, 0.07707620f, 
    -0.33196500f, -0.19061078f, -0.09515651f, 0.16504464f, -0.67140710f, 0.21350741f, 0.11263695f, 0.06148022f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.24576102f, 0.13685720f, 0.05063767f, -0.14922848f, 0.08631866f, 0.01006644f, -0.07186589f, 0.01603075f, 
    0.13689643f, 0.20251623f, 0.17176855f, -0.11945213f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
