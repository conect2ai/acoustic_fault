#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48652649f, 0.66672486f, 0.39687788f, -1.29779315f, -1.01290953f, -0.64874291f, 0.23206241f, 0.49344066f, 
    -0.10955030f, 0.86974698f, -1.66118014f, -1.08374178f, 0.17068815f, 0.89632851f, 0.28956762f, 0.05414366f, 
    0.12482149f, 0.00208716f, 0.45862293f, -1.18631351f, -0.22201194f, 0.76460993f, -0.43237031f, -0.88652128f, 
    -0.14787200f, 0.55383551f, 0.57762802f, -2.06807876f, -0.02562338f, 1.18487120f, -0.70209843f, 0.37237522f, 
    0.85759544f, 0.22285183f, -0.13580793f, -0.26799196f, 0.06012601f, -1.50301147f, 0.40997961f, -1.18400407f, 
    -1.16158521f, -1.05801332f, -0.55745453f, -0.48984963f, -1.02173042f, -0.01417036f, 1.38887882f, 0.27693835f, 
    -0.83001542f, -0.38992238f, -0.31899813f, -0.25080180f, 0.18509457f, 0.74757260f, -0.10951205f, -0.24085344f, 
    0.52959073f, -0.05125590f, -0.39457190f, 0.59666103f, 0.32562625f, -0.12396545f, 0.61275125f, -1.58491266f, 
    -0.85599101f, -1.30184031f, 0.80493879f, 0.22997715f, -0.12816229f, -0.53067666f, -0.73686546f, -0.66477931f, 
    0.23855074f, 0.46463954f, 0.38491866f, -0.72510445f, -0.20342994f, -0.44920889f, 0.91444713f, 0.15860708f, 
    -0.35884398f, -0.21871117f, -1.15001202f, -1.15661633f, 0.89406604f, 0.38929352f, 0.20788066f, 0.16763659f, 
    0.50546867f, 0.55174398f, 0.81417739f, 0.58207411f, 0.41811845f, -0.41459608f, 0.19875260f, 0.27756491f, 
    -0.09416132f, -0.09866885f, -0.84212720f, 1.40532088f, -0.43681073f, -0.63019407f, 0.61449224f, -0.18154553f, 
    0.30858365f, -0.52927721f, -0.34558669f, -0.05016719f, 0.20108719f, 0.28036159f, 0.02165856f, 0.28562343f, 
    -0.09694677f, 0.42799720f, -0.57166040f, 0.87927908f, -0.31261346f, -1.01617050f, -0.76221365f, -0.54915053f, 
    -1.00597334f, -1.22074783f, -1.10262167f, 0.68827790f, -0.27444884f, 0.61010784f, 0.46671295f, -1.54376912f, 
    0.86661464f, 0.38915440f, 1.22226059f, -0.61796528f, -0.23578182f, -0.31558624f, -0.11524893f, 0.73372549f, 
    0.26210070f, 0.17939065f, -0.19095889f, 0.49552146f, 0.17377639f, 0.08851776f, 0.53975880f, -0.08415382f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35951006f, 0.26132122f, 0.59230590f, 0.00715235f, 0.26666206f, 0.13502006f, 0.26530254f, -0.29650983f, 
    -0.18439899f, 0.31521931f, -0.18902528f, 0.41846398f, 0.81127435f, 0.02825035f, 0.26406601f, 0.00430723f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22501607f, 0.41893241f, 0.01156107f, -0.40385014f, -0.19285762f, -0.25265494f, 0.03393699f, -0.10724264f, 
    0.02364409f, -0.06449842f, 0.05456305f, -0.09954228f, -0.07757469f, -0.03530897f, -0.05147628f, -0.04610175f, 
    0.00192271f, -0.01816053f, -0.11910237f, 0.02072655f, 0.29695350f, 0.15154149f, -0.66287732f, 0.16174412f, 
    0.03519906f, 0.22869436f, -0.01522365f, 0.09662278f, -0.15503101f, 0.10237384f, -0.16145474f, 0.05645059f, 
    -0.30395070f, 0.01425905f, -0.07592760f, 0.11486509f, 0.07966205f, -0.08175186f, -0.02818220f, 0.07843953f, 
    0.31169602f, 0.39175054f, -0.31383008f, 0.01095150f, 0.01280779f, -0.19170181f, 0.01219676f, -0.06798252f, 
    -0.34721246f, -0.25002304f, -0.04367872f, -0.21495049f, -0.02206321f, -0.03184101f, 0.03721448f, -0.10718451f, 
    -0.04308995f, -0.25895318f, -0.16071753f, 0.05832931f, 0.17293252f, -0.06257913f, 0.67960352f, -0.36326876f, 
    0.09551644f, -0.34515101f, 0.05587196f, 0.30558783f, 0.19508894f, -0.25493389f, -0.20213772f, -0.08730508f, 
    -0.11675461f, -0.13188510f, -0.01978909f, -0.02968700f, -0.10645334f, -0.04686644f, -0.04726614f, 0.03940438f, 
    0.45484427f, 0.39550117f, 0.14291635f, -0.65338093f, 0.01082991f, 0.07172894f, 0.11148642f, 0.18600740f, 
    -0.17232215f, 0.01895569f, 0.04334864f, -0.11268246f, -0.04237117f, -0.10505937f, -0.22306594f, -0.02453631f, 
    -0.19480227f, -0.21526258f, 0.13347894f, -0.03872391f, -0.04548240f, -0.14439082f, -0.03807640f, 0.06834061f, 
    -0.27710268f, -0.07906947f, -0.42573664f, -0.24015318f, 0.06607586f, -0.10333982f, 0.03665601f, 0.04163991f, 
    0.05957980f, 0.11256763f, -0.04888101f, -0.03146710f, 0.00864366f, -0.02564803f, -0.10616887f, -0.21698655f, 
    -0.07580808f, 0.00487369f, 0.13696764f, -0.07675394f, 0.09792607f, -0.04054718f, 0.01411854f, 0.05659285f, 
    0.01795770f, 0.08400455f, -0.02720264f, -0.20623422f, -0.11580233f, -0.17494294f, -0.12903967f, -0.07216629f, 
    -0.18195207f, -0.06362713f, -0.02781153f, -0.14296025f, 0.60815579f, 0.32898360f, -0.01258917f, -0.22986625f, 
    0.02425543f, 0.10316839f, 0.30685076f, 0.34416661f, -0.02768412f, 0.11482939f, 0.01523473f, 0.05622992f, 
    -0.04397026f, -0.19491312f, 0.08741060f, 0.02470294f, 0.01679040f, -0.01447229f, -0.11905547f, -0.07603345f, 
    0.01804334f, 0.00366707f, 0.11537373f, -0.23080207f, -0.02194545f, -0.12714820f, 0.18047437f, -0.19683643f, 
    0.00218454f, 0.04233718f, 0.03957274f, -0.00373474f, 0.10376202f, -0.00717520f, 0.06427172f, 0.05116708f, 
    0.05699776f, -0.18568175f, -0.23232928f, -0.03574963f, 0.11059077f, 0.12482585f, -0.35882059f, 0.15918632f, 
    0.13353300f, 0.12753582f, 0.07193962f, 0.09482709f, -0.07051139f, -0.04520898f, -0.07468152f, 0.07712794f, 
    0.00212481f, 0.01815570f, 0.05083926f, 0.03858101f, 0.11764770f, 0.01292907f, 0.02833667f, 0.03254050f, 
    -0.16284542f, -0.33098575f, -0.46450481f, -0.05137421f, 0.29029003f, 0.08732087f, 0.07384985f, 0.03489661f, 
    0.12850459f, 0.13085595f, -0.02214297f, 0.03292157f, 0.04305783f, 0.07742418f, 0.08206470f, 0.22857034f, 
    0.09975278f, 0.13570645f, 0.07586832f, 0.02200227f, -0.70936054f, -0.56998843f, -0.39537427f, 0.32680401f, 
    -0.29556236f, 0.05268396f, -0.01922753f, -0.09067661f, 0.05993014f, 0.01416942f, 0.05491618f, -0.05961107f, 
    -0.11024833f, 0.02642060f, -0.02103523f, -0.19981447f, 0.04774416f, 0.12714863f, -0.07851137f, -0.11463013f, 
    -0.44185847f, -0.54077584f, -0.16760440f, 0.01038275f, -0.06006590f, -0.00957860f, -0.05879643f, -0.05028709f, 
    -0.06740101f, 0.02573911f, -0.28349367f, 0.09896808f, -0.21439908f, -0.46749070f, -0.22173762f, -0.17445262f, 
    -0.14717793f, -0.11964869f, -0.04289807f, -0.05349080f, 0.43021488f, 0.56185085f, 0.15655544f, -0.64395583f, 
    -0.17821023f, 0.13301545f, 0.18153910f, -0.03377958f, 0.12201972f, 0.15082654f, 0.04956757f, -0.04040621f, 
    -0.06148516f, 0.05790566f, 0.01925541f, -0.01693184f, -0.07015062f, -0.01311437f, 0.01828040f, 0.00547739f, 
    0.38269228f, -0.92068940f, -0.51171499f, -0.19648018f, -0.14998189f, -0.10822436f, -0.23315772f, 0.28329760f, 
    -0.08778418f, 0.06137350f, -0.08307218f, 0.13790622f, -0.13571197f, 0.03369101f, -0.15522356f, -0.11620528f, 
    0.17105851f, 0.05561281f, -0.18934621f, 0.20504218f, -0.04670587f, -0.10463234f, 0.00359573f, 0.05777293f, 
    0.09184667f, 0.02309689f, 0.10315942f, 0.08755041f, 0.08086845f, 0.03746605f, -0.13697942f, 0.03796672f, 
    0.04158016f, -0.08704017f, -0.10589570f, -0.09997754f, -0.09475322f, -0.00064551f, 0.00548047f, 0.05468458f, 
    -0.26973990f, -0.20779273f, -0.01332464f, -0.32664692f, -0.04983505f, -0.00789134f, -0.14134528f, -0.28380421f, 
    0.13254748f, 0.11157432f, -0.08463006f, -0.07478952f, 0.04930776f, 0.16706359f, 0.07559352f, -0.06711146f, 
    -0.00679115f, -0.02849315f, 0.04604102f, 0.02782628f, 0.71015263f, -0.22107500f, -0.27564207f, -0.05701380f, 
    -0.17515576f, -0.14209566f, 0.10791263f, 0.09105475f, -0.33896223f, 0.07559387f, 0.18459383f, -0.21859479f, 
    0.00492556f, -0.15788502f, 0.01425925f, -0.06726358f, 0.00586328f, -0.15715432f, -0.08530547f, -0.00170781f, 
    -0.02994263f, 0.03932235f, -0.15698250f, 0.07939085f, -0.03616527f, 0.39894199f, 0.20429608f, 0.18568212f, 
    0.01660468f, -0.14212859f, 0.03234752f, 0.03389092f, 0.00996413f, 0.01608200f, -0.02043229f, -0.08157448f, 
    0.11150621f, 0.10114283f, 0.19671153f, 0.17944422f, -0.98094368f, -0.88939881f, -0.11739796f, -0.11321174f, 
    0.34729156f, 0.09183554f, -0.08955082f, 0.07722759f, -0.00277871f, 0.04527055f, -0.02977156f, 0.06830651f, 
    -0.13692264f, 0.01508722f, -0.05768467f, 0.16163795f, -0.00394164f, 0.02737156f, 0.10840548f, -0.17757286f, 
    -0.19940025f, 0.29084590f, -0.33445585f, -0.00835649f, 0.12546374f, 0.08632132f, -0.12092999f, -0.26295629f, 
    -0.01622128f, -0.11439603f, 0.00456258f, 0.00304765f, 0.10058552f, -0.02026426f, 0.13572308f, -0.10971868f, 
    -0.01092881f, 0.09351108f, -0.51915479f, -0.12487820f, -0.02919919f, -0.21062337f, -0.05581420f, -0.16270067f, 
    -0.14798953f, -0.03280728f, -0.10091440f, -0.19721603f, -0.01863798f, 0.12973644f, -0.10092461f, -0.02653562f, 
    0.15155168f, 0.05086148f, 0.03209971f, -0.10155946f, 0.05786439f, -0.28999183f, 0.04320600f, 0.19162962f, 
    -0.10986623f, -0.05661343f, 0.04672295f, 0.01082815f, 0.08417230f, -0.12370092f, 0.01474303f, 0.08422044f, 
    0.05094511f, 0.09459531f, 0.21534675f, 0.17794615f, 0.01702452f, 0.13374884f, -0.13219295f, -0.20830771f, 
    0.04449430f, 0.08318990f, -0.02628903f, 0.01330078f, 0.39154574f, 0.29544461f, 0.65956599f, 0.22712584f, 
    -0.41452169f, 0.07468362f, -0.05263545f, 0.14418222f, 0.09936126f, -0.11667187f, 0.09360049f, -0.03463510f, 
    -0.06041716f, -0.38233519f, 0.07460136f, 0.21193731f, -0.03173424f, -0.27379242f, 0.00014893f, 0.03845536f, 
    0.04716008f, -0.24105024f, 0.15148701f, -0.10897454f, -0.02921453f, 0.04134069f, -0.08631440f, -0.46137044f, 
    0.04040063f, -0.11237638f, -0.05577885f, -0.18558834f, -0.02191021f, 0.05191660f, -0.05709131f, 0.07447775f, 
    -0.15871863f, 0.04645937f, 0.15149876f, -0.32158944f, 0.21060535f, -0.21787335f, -0.19127256f, -0.02576766f, 
    -0.16072077f, 0.02678032f, 0.07559039f, 0.10653225f, 0.01532131f, -0.23870289f, 0.03353428f, 0.20295751f, 
    0.00763175f, -0.04601604f, -0.03745810f, -0.01592831f, 0.04169732f, 0.00001614f, 0.02377218f, 0.00417781f, 
    0.52622759f, 0.18938230f, 0.10113776f, 0.17101590f, 0.21150129f, -0.08198205f, -0.12937468f, 0.03084658f, 
    -0.04395674f, -0.01852327f, 0.02888179f, 0.01923702f, -0.02583991f, 0.00547465f, 0.00424601f, -0.04062552f, 
    -0.11495743f, 0.05509824f, 0.19808781f, -0.18843524f, 1.34875309f, 0.20593244f, 0.05241160f, 0.21052645f, 
    -0.05364509f, -0.10525729f, -0.02661982f, -0.13289423f, -0.04808068f, -0.03260749f, -0.02998458f, -0.02019958f, 
    -0.04675657f, -0.02309417f, -0.06776232f, 0.08100986f, 0.02649777f, 0.00660476f, 0.01631762f, 0.01425030f, 
    0.34188855f, -0.06859273f, 0.13097513f, -0.01717398f, 0.16543511f, 0.02706222f, 0.01492900f, 0.07699578f, 
    0.09577806f, 0.00972676f, -0.07833625f, -0.06207882f, -0.02061654f, 0.08203270f, -0.03259102f, -0.24578588f, 
    0.03765063f, -0.03680734f, 0.07569470f, 0.03945730f, -0.48812142f, 0.18549359f, -0.20060433f, 0.26794836f, 
    0.16326681f, -0.19697244f, -0.02264187f, 0.07387549f, -0.29122177f, -0.18087636f, -0.00383228f, -0.00461253f, 
    -0.02289495f, 0.02028858f, 0.01072276f, -0.01799721f, 0.04404135f, 0.06415071f, -0.36142257f, 0.02223798f, 
    0.34732583f, -0.75393355f, -0.06063741f, 0.22224741f, 0.18684880f, -0.08656193f, 0.07881510f, 0.00562111f, 
    0.01122454f, -0.13348287f, 0.09146126f, -0.05723152f, 0.22472714f, 0.06432420f, -0.28277436f, 0.10244223f, 
    -0.10552587f, -0.03596484f, -0.17887086f, -0.26987019f, 0.11010963f, 0.11398862f, 0.16017903f, 0.04591068f, 
    0.13311733f, -0.02930478f, -0.05235462f, -0.01578492f, 0.03094121f, 0.00010407f, 0.08165140f, -0.02505582f, 
    0.03213217f, 0.07197549f, 0.08373871f, -0.20838027f, 0.09134145f, -0.12125175f, 0.08357847f, 0.01417453f, 
    -0.29029620f, -0.37970564f, 0.12540127f, -0.27231026f, -0.15416823f, 0.16576822f, 0.09956524f, -0.21070230f, 
    -0.05570869f, 0.05921193f, -0.00263857f, -0.05820761f, 0.00063407f, 0.03928272f, -0.15233895f, 0.01698508f, 
    -0.02505522f, -0.03336998f, 0.00514620f, 0.07397559f, -0.02334761f, 0.30274808f, 0.61185890f, -0.03513816f, 
    0.30427805f, -0.13982169f, -0.00156327f, 0.09349927f, 0.05084509f, -0.23053665f, 0.10049590f, -0.02488106f, 
    -0.06589416f, -0.01419938f, 0.13487098f, 0.02672277f, -0.06415810f, -0.11890399f, 0.05953281f, -0.17322122f, 
    0.06212654f, 0.08339049f, -0.07586429f, 0.22739111f, -0.03155087f, 0.15446100f, -0.22566879f, -0.27067640f, 
    -0.06028679f, -0.22569425f, 0.04235089f, 0.09225954f, -0.00382568f, 0.08161209f, -0.05195891f, 0.02767953f, 
    0.01826809f, 0.07514960f, 0.25193262f, -0.05876050f, 0.83540219f, 0.14909838f, -0.65742177f, -0.01310952f, 
    0.56230116f, -0.12609878f, 0.28663525f, -0.29758555f, -0.03303882f, 0.02209595f, -0.10296556f, 0.02135787f, 
    0.10362753f, 0.10591559f, -0.08001623f, 0.14413022f, 0.11977886f, 0.12564607f, -0.13931909f, 0.20342349f, 
    -0.53629136f, -0.42394421f, -0.42098895f, -0.01978055f, -0.72907925f, 0.02783572f, 0.13806239f, -0.03288251f, 
    0.19267724f, 0.09031330f, -0.06352872f, -0.01450630f, -0.05151697f, -0.05386441f, -0.07284436f, -0.07229193f, 
    0.04718538f, 0.04457566f, -0.09018699f, 0.27056935f, -0.24160941f, -0.23278272f, 0.15497227f, -0.14424527f, 
    0.18944746f, -0.08375068f, 0.07684156f, -0.40695566f, -0.22352305f, 0.17640936f, -0.03966555f, -0.07552597f, 
    0.12321360f, -0.08707856f, -0.01174987f, 0.08401310f, -0.07881866f, -0.10862654f, 0.04871457f, -0.02638101f, 
    0.10734076f, 0.00046818f, -0.23808841f, 0.04281857f, 0.13823791f, 0.01606154f, -0.05889639f, 0.02548082f, 
    -0.00046894f, 0.02466677f, -0.23102050f, -0.10645317f, 0.19066405f, 0.02337679f, -0.01429738f, 0.04627343f, 
    -0.07061270f, 0.01615861f, -0.08009240f, -0.07304388f, -0.52764148f, -0.16470844f, 1.32161844f, 0.84889776f, 
    0.39309299f, -0.03108483f, -0.05427887f, -0.02133259f, 0.09962790f, -0.12285593f, 0.05577422f, 0.02930715f, 
    0.05104568f, -0.15144327f, -0.02249567f, -0.04704774f, 0.08889161f, 0.05894198f, -0.03162695f, -0.04318422f, 
    -0.34748319f, -0.17531405f, 0.11327408f, -0.25063822f, -0.10166333f, -0.19185530f, -0.26717719f, -0.42184716f, 
    -0.06113315f, 0.07583449f, 0.13887911f, -0.05092974f, -0.00595165f, 0.15530333f, -0.19911084f, 0.08959434f, 
    -0.08113887f, -0.19554582f, -0.10755137f, -0.04216272f, 0.14133002f, 0.09153007f, 0.42364147f, 0.24588209f, 
    0.18228851f, -0.04560011f, -0.05418528f, 0.12329856f, 0.11450382f, -0.44681945f, -0.05336526f, -0.19356535f, 
    0.03147778f, 0.10376398f, 0.03275532f, -0.02216138f, -0.14106405f, 0.08309290f, 0.07108434f, -0.09410021f, 
    -0.34558955f, -0.68875223f, -0.32036790f, -0.78274584f, -0.79097557f, 0.04370974f, 0.00895776f, -0.03515634f, 
    0.01127543f, 0.14832489f, 0.07743553f, -0.02688400f, -0.03206260f, 0.12308896f, -0.05986230f, 0.03073685f, 
    -0.19290049f, 0.27404606f, 0.12888579f, -0.10200600f, -0.83797443f, 0.38129279f, 0.16785689f, -0.14594901f, 
    -0.29835936f, 0.00084813f, 0.07206866f, -0.06015450f, -0.06529083f, 0.14030260f, 0.06517331f, 0.09634428f, 
    0.05134227f, -0.08922718f, -0.04266799f, -0.01684594f, -0.08532105f, 0.08377251f, 0.23409997f, -0.00719775f, 
    0.06919365f, 0.01852667f, -0.09470683f, -0.06286853f, 0.14548796f, -0.06929663f, -0.00412141f, 0.07133380f, 
    0.06421014f, 0.07868765f, 0.17042279f, 0.04792163f, -0.20739841f, 0.29511699f, 0.19294281f, 0.32548061f, 
    0.00241841f, 0.05027144f, 0.11939099f, 0.04022822f, -0.60373658f, -0.92599678f, -0.68595672f, 0.10641161f, 
    -0.72020131f, 0.00016483f, 0.18140514f, 0.01749278f, -0.01824600f, -0.13485445f, -0.01062841f, 0.01181882f, 
    0.01916022f, -0.06343329f, -0.04481652f, -0.01373239f, -0.01435852f, 0.01333060f, -0.32435229f, 0.10808799f, 
    0.19377649f, 0.22987542f, 0.06833442f, -0.15557274f, 0.29564923f, 0.15012859f, -0.11998188f, -0.16402252f, 
    0.06064550f, 0.02368610f, 0.11000434f, 0.07410526f, 0.16236904f, -0.35600877f, 0.18616280f, 0.09685965f, 
    -0.01657466f, 0.03634558f, 0.24306762f, -0.04262540f, -0.35496935f, -0.24566825f, -0.04589151f, -0.17604788f, 
    0.03486148f, -0.11648518f, -0.10590333f, -0.02126482f, 0.03512068f, 0.03659926f, -0.01548019f, -0.19778301f, 
    -0.12505180f, 0.12518659f, -0.11749063f, -0.00484922f, -0.32385975f, -0.03093961f, 0.00137746f, -0.05315270f, 
    0.29018012f, 0.02444854f, 0.18483014f, -0.18167660f, 0.47852457f, 0.04983362f, 0.10143865f, 0.04850004f, 
    -0.04461840f, 0.02223707f, 0.07345758f, -0.16402562f, -0.05335343f, -0.05102458f, 0.09212223f, -0.07999729f, 
    -0.16979891f, -0.14560118f, -0.28023636f, -0.06948739f, -0.57666653f, 0.90946734f, -0.16235384f, 0.17311236f, 
    0.50142545f, 0.15617824f, -0.18824977f, 0.08817106f, -0.33379734f, 0.16211355f, -0.28495571f, 0.06008489f, 
    0.09315985f, 0.03360631f, -0.05808674f, 0.10696577f, -0.05043085f, 0.16714220f, -0.07778277f, 0.05897435f, 
    -0.54629958f, -0.28671023f, -0.55244702f, -0.05261819f, 0.23428161f, 0.02040136f, -0.16528645f, 0.22996409f, 
    0.01456255f, -0.03705202f, -0.21851319f, 0.07826944f, -0.26538324f, 0.02323242f, -0.22434220f, -0.02314455f, 
    -0.28307486f, 0.17965785f, -0.04417926f, -0.12042493f, 0.86103815f, 0.96222037f, 0.06165309f, -0.76414073f, 
    -0.17978993f, 0.33143952f, 0.11060653f, -0.35320184f, -0.13840239f, -0.15111241f, -0.25556359f, 0.11221147f, 
    -0.05513534f, -0.13995518f, 0.13228561f, 0.16092858f, 0.11359189f, -0.14854831f, 0.20219764f, 0.15242329f, 
    -0.37002996f, -0.17405957f, -0.17345664f, 0.20945437f, 0.28176799f, -0.11004696f, 0.01031304f, -0.00731062f, 
    -0.11230245f, 0.02279890f, -0.04411594f, 0.09574478f, -0.11977785f, -0.16951208f, -0.14764565f, 0.01500784f, 
    -0.05924266f, 0.34539849f, -0.28364515f, -0.04920955f, -0.16850494f, 0.37121227f, 0.72459453f, -0.37150386f, 
    0.50107783f, -0.14540020f, -0.02502847f, -0.04001741f, -0.11168714f, 0.12548488f, 0.19756749f, 0.08727568f, 
    -0.04741688f, -0.01997420f, 0.15008821f, -0.08387799f, -0.02222107f, 0.05679012f, -0.00702828f, -0.07444779f, 
    -0.11954268f, -0.17562085f, -0.22827321f, -0.56394678f, -0.50917852f, 0.07364630f, 0.01395382f, -0.23421317f, 
    0.02918520f, -0.27766627f, 0.04372971f, 0.11121404f, -0.10280251f, -0.15210839f, -0.19703282f, 0.45548666f, 
    0.20792416f, 0.08925486f, -0.19226216f, -0.42758775f, 0.18767279f, 0.06688782f, -0.41538543f, -0.00866853f, 
    0.48679510f, 0.28819910f, 0.19517900f, -0.02966708f, 0.17270252f, -0.00764771f, -0.21134840f, 0.12974653f, 
    0.10809030f, 0.24836896f, 0.32698068f, -0.13274921f, 0.05732044f, 0.11681891f, 0.00381344f, 0.09825354f, 
    0.11989950f, -0.16209963f, 0.03643449f, -0.14707313f, 0.33014581f, -0.00538571f, 0.26745823f, -0.15611893f, 
    0.26362029f, -0.01910291f, 0.19101287f, 0.02393875f, -0.06195418f, -0.03458870f, 0.00259070f, -0.09509468f, 
    0.17371492f, -0.17198120f, 0.03491394f, 0.14872362f, -0.39463374f, 0.16408783f, -0.05214345f, -0.05190196f, 
    0.49381578f, 0.36815405f, 0.14262891f, 0.03202200f, -0.05212744f, 0.11741369f, -0.09981596f, 0.05488261f, 
    -0.00858995f, 0.05533907f, 0.06395864f, 0.12668924f, -0.02258513f, -0.00937065f, 0.00289740f, 0.03574693f, 
    -1.60547519f, -0.14096993f, 0.60436666f, 0.03568588f, -0.33756283f, -0.03506339f, -0.12422312f, 0.28985599f, 
    0.25816807f, 0.06360077f, 0.05710999f, 0.10687079f, 0.16166134f, 0.13280015f, 0.07727408f, -0.08107421f, 
    -0.10090339f, -0.19790305f, 0.02881870f, -0.14590889f, -0.48888814f, -0.02858301f, -0.03232742f, 0.28409830f, 
    -0.24095950f, -0.17747113f, 0.03993980f, -0.04904643f, 0.09900181f, -0.02019886f, 0.06989618f, -0.00379677f, 
    0.05020413f, -0.08178818f, 0.06675949f, -0.18785608f, 0.18857841f, -0.05134211f, -0.08961430f, -0.03714490f, 
    -0.33121315f, 0.15287516f, 0.05774936f, -0.20791672f, -0.69691908f, -0.09278908f, -0.08725843f, -0.00391294f, 
    -0.00454885f, -0.18155167f, -0.08552578f, -0.05603305f, -0.00222233f, 0.04999902f, -0.14462511f, -0.09314139f, 
    0.03228028f, 0.31171054f, -0.10949196f, -0.04399074f, 0.11356657f, -0.24967933f, -0.43534750f, -0.00661745f, 
    0.29828858f, 0.18766037f, 0.11555072f, -0.00781849f, 0.15281317f, 0.16560636f, 0.00255211f, 0.07396424f, 
    0.03606527f, -0.00222172f, -0.05131515f, 0.02431925f, -0.12801467f, 0.16735722f, -0.05583054f, 0.08407498f, 
    -2.51789689f, 1.67307770f, -0.57073003f, -0.33329546f, -0.35904181f, 0.36419070f, -0.06394434f, 0.03784351f, 
    -0.20152994f, 0.15107368f, -0.27100962f, -0.31221998f, -0.04415229f, -0.28676066f, -0.23251460f, 0.00567407f, 
    0.11241081f, 0.01957119f, -0.01186533f, -0.12417925f, -0.98101401f, -0.32593235f, -0.25544730f, 0.03400070f, 
    -0.29643321f, -0.15420939f, -0.35991839f, 0.04935227f, -0.06039714f, -0.02983001f, 0.04144398f, 0.16860509f, 
    0.03562880f, 0.03143764f, -0.09356883f, 0.23017159f, 0.07711206f, 0.00948246f, -0.19957078f, -0.12192611f, 
    -0.09019873f, 0.26843813f, 0.00712874f, 0.44034904f, 0.23537964f, 0.03981237f, 0.20274884f, 0.11204561f, 
    0.04201091f, 0.37089619f, 0.01071391f, -0.09308481f, 0.04198136f, -0.09859163f, 0.01384464f, -0.08040018f, 
    -0.06054299f, -0.19788167f, -0.02709408f, -0.22987898f, -0.11550558f, -0.52423012f, 0.28042361f, -0.05095523f, 
    0.03729653f, -0.12314979f, -0.11932480f, -0.09238535f, 0.07271327f, -0.08885688f, 0.06461111f, -0.20973718f, 
    -0.15911773f, 0.06904671f, -0.04651333f, 0.06665484f, 0.01034835f, -0.00275621f, -0.00653100f, -0.21000957f, 
    0.26067314f, -0.04367773f, 0.33304358f, -0.29087415f, -0.12679550f, 0.13360777f, -0.24254163f, -0.14310715f, 
    -0.10409432f, -0.06071155f, 0.03225084f, -0.07199258f, -0.00013080f, 0.15885159f, -0.00395132f, 0.03965412f, 
    -0.12511340f, -0.22291782f, -0.26439056f, -0.24689494f, -0.26343703f, -0.94702995f, -0.28272942f, -0.26839203f, 
    -0.31174934f, -0.14422622f, -0.39897141f, 0.05900863f, -0.32215220f, 0.03770252f, 0.00484774f, -0.15536161f, 
    0.09579129f, 0.19358689f, -0.25161710f, -0.05813289f, -0.35235977f, -0.00780594f, -0.09425719f, -0.01206655f, 
    -0.08582100f, -0.01473166f, 0.32097507f, 0.12433589f, 0.11000072f, -0.08821048f, 0.25131243f, 0.06006571f, 
    0.07212794f, -0.05973201f, -0.03994924f, 0.02462362f, -0.11278191f, 0.06247064f, -0.01397575f, 0.13234282f, 
    0.16973329f, -0.18803880f, 0.14046678f, 0.26548952f, -0.01346011f, 0.22158289f, -0.06836581f, 0.02211334f, 
    0.35506234f, -0.02250890f, 0.27088439f, -0.06799897f, -0.03777909f, 0.11989772f, 0.19423264f, -0.04483294f, 
    -0.10774242f, -0.20498890f, 0.07813332f, -0.09490711f, -0.16793977f, 0.03552094f, -0.08359505f, -0.17227761f, 
    -0.06818783f, 0.05493860f, 0.01869075f, -0.00044693f, 0.00972147f, 0.00882252f, 0.09562567f, 0.01088752f, 
    -0.03132029f, 0.05496689f, -0.18924300f, -0.10328448f, -0.27496728f, -0.00669151f, 0.09665934f, 0.11330168f, 
    -0.07859607f, -0.10005287f, -0.00493432f, -0.03856182f, -0.22036941f, -0.43485498f, 0.09925953f, 0.13604401f, 
    0.19617409f, -0.22001114f, -0.03916257f, -0.13884123f, -0.18631470f, 0.02197003f, -0.00948341f, 0.10064680f, 
    -0.02474225f, 0.07818142f, -0.13490647f, -0.07199225f, 0.06657416f, 0.03886853f, 0.00337958f, 0.06779471f, 
    -0.06668755f, 0.00870265f, 0.00135176f, 0.22294427f, 0.10667084f, -0.01834850f, -0.00393376f, 0.20978260f, 
    0.00658701f, 0.07106215f, 0.13236925f, -0.03349923f, 0.06159532f, -0.10818187f, 0.12290529f, -0.04306302f, 
    0.07384534f, -0.33882400f, -0.33387613f, 0.09218741f, 0.31437612f, -0.02792547f, 0.21550369f, 0.09235509f, 
    -0.05121672f, -0.11205687f, -0.12226409f, -0.19422495f, -0.06631602f, 0.11170363f, 0.22030982f, -0.19872376f, 
    0.09332596f, 0.02133360f, -0.00286607f, 0.09934905f, 0.03344046f, 0.05931010f, -0.07072971f, -0.06672553f, 
    0.07648820f, 0.13973001f, -0.08455624f, -0.05191269f, 0.21176314f, 0.07794831f, 0.04283318f, 0.04663265f, 
    0.10348365f, 0.10041662f, 0.15777417f, 0.08973854f, 0.00117248f, -0.03681290f, 0.11289102f, 0.08903693f, 
    0.22101885f, 0.23361379f, -0.25698060f, 0.39762866f, -0.45710549f, 0.07815152f, 0.06043970f, -0.47008029f, 
    -0.42247519f, 0.15509790f, 0.03907189f, -0.01564391f, 0.11184169f, 0.01247427f, 0.05195300f, 0.01449002f, 
    -0.01587935f, 0.03089257f, -0.04674884f, -0.37796399f, 0.09449892f, -0.12254641f, -0.04006767f, -0.09481686f, 
    0.06389444f, -0.13252394f, -0.19691075f, -0.23488179f, -0.13547780f, 0.04658275f, -0.06994040f, 0.03384924f, 
    -0.00405721f, 0.02869759f, 0.01943229f, 0.07408265f, -0.09599269f, -0.37614539f, -0.00044458f, -0.01645329f, 
    -0.04106588f, -0.05108007f, -0.16646415f, -0.06802407f, 0.26111236f, 0.43246612f, 0.43533707f, 0.47087076f, 
    0.26443395f, -0.22123170f, -0.19777465f, -0.17716758f, -0.12444434f, 0.13038644f, 0.05415279f, 0.01753060f, 
    0.01658489f, 0.06010986f, 0.07214601f, 0.02100263f, 0.02010174f, -0.26751009f, 0.00831782f, -0.22337453f, 
    -0.03086364f, -0.42722371f, 0.22936705f, -0.15276812f, -0.17718561f, 0.00391094f, 0.10855914f, -0.04514508f, 
    0.10149426f, 0.16273165f, -0.05361803f, 0.12342156f, -0.04759590f, 0.05639294f, -0.05951922f, -0.13004832f, 
    -0.16374731f, 0.06477732f, -0.07137877f, -0.05898952f, 0.09309164f, -0.04398538f, 0.01851765f, -0.01340365f, 
    -0.04356242f, 0.15628548f, 0.09292272f, 0.14052394f, -0.01724977f, 0.00280218f, 0.08437745f, 0.04144988f, 
    0.03383269f, -0.06756891f, 0.15812662f, 0.19764546f, -0.00176628f, -0.14639233f, -0.00343677f, 0.06657016f, 
    -0.13074653f, -0.02029708f, 0.24976116f, 0.13877901f, -0.44799286f, -0.08486503f, -0.20847322f, 0.03749754f, 
    -0.03704023f, -0.09628388f, 0.03003979f, 0.07732808f, -0.06961939f, -0.15202533f, -0.01798397f, 0.05358787f, 
    0.04456435f, 0.12006690f, -0.10949506f, 0.03310561f, -0.08268309f, -0.15140413f, -0.21221158f, -0.37176001f, 
    -0.09312368f, 0.19248985f, -0.04662645f, -0.09889540f, 0.08260307f, -0.05508367f, -0.06902396f, 0.22344394f, 
    0.09098967f, 0.04467282f, -0.19252165f, -0.05372505f, -0.02579518f, 0.17534132f, -0.01616389f, 0.19075532f, 
    0.14206220f, -0.04271629f, 0.28240418f, -0.19166991f, 0.06009968f, -0.21303846f, 0.05804019f, -0.18978408f, 
    -0.05061349f, 0.21026824f, 0.19951463f, 0.05438272f, -0.00482879f, -0.11307318f, -0.00275945f, 0.10739356f, 
    -0.00846963f, -0.16866659f, 0.13823804f, 0.11477170f, -0.79728550f, 0.25718901f, -0.28467134f, 0.46947905f, 
    -0.62548858f, 0.06875388f, -0.19231488f, -0.18913309f, 0.26201254f, 0.05545554f, 0.19461538f, 0.01590422f, 
    -0.30895111f, -0.07039612f, 0.25038749f, -0.06959578f, 0.19829151f, 0.09331275f, -0.11399270f, -0.06008848f, 
    0.36526856f, -0.01942687f, 0.63591927f, 0.22658908f, -0.32597885f, 0.14422920f, -0.03911780f, 0.04585630f, 
    0.13609247f, 0.04196351f, 0.11894931f, 0.00244595f, 0.06847829f, 0.13553204f, 0.07515784f, -0.12179071f, 
    0.01759581f, -0.12464047f, -0.13656051f, -0.38441005f, -0.10709225f, 0.11220606f, -0.42248821f, 0.27669218f, 
    0.09634320f, -0.02671557f, -0.01735293f, 0.15834813f, 0.06712253f, -0.15657294f, -0.13747458f, -0.02278918f, 
    -0.04123008f, -0.03727511f, -0.08408032f, 0.11936630f, -0.04434724f, 0.25231022f, -0.19087249f, 0.09252588f, 
    0.11524217f, -0.08966051f, -0.04074859f, 0.10061814f, -0.16459222f, 0.15687887f, -0.15220810f, -0.09411859f, 
    -0.05296752f, 0.09998389f, 0.12814467f, 0.06080773f, 0.06735174f, -0.06107382f, 0.12554672f, 0.14388606f, 
    0.14357610f, -0.01910501f, 0.00402287f, 0.07684252f, -0.92971772f, 0.27515554f, -0.22901134f, -0.35222438f, 
    -0.21026768f, 0.07739133f, -0.08438738f, -0.03252915f, -0.12597753f, -0.05129585f, -0.01680317f, -0.02817736f, 
    0.03505526f, 0.02933983f, -0.13496667f, -0.19544040f, -0.23962444f, -0.12250371f, -0.04378593f, -0.12445763f, 
    -0.13224235f, 0.29980308f, -0.09137279f, -0.03394101f, 0.06007791f, 0.24945207f, -0.14474949f, 0.01543803f, 
    -0.15707631f, 0.01341943f, -0.19251539f, 0.08425117f, -0.10721482f, -0.00509404f, 0.11396670f, 0.05557398f, 
    -0.11869591f, 0.23082042f, -0.12251995f, -0.02225927f, -0.29322812f, -0.02999326f, -0.16959918f, -0.28326508f, 
    -0.17652932f, 0.04934530f, 0.08409598f, -0.07173680f, 0.04653849f, 0.17323168f, -0.03072326f, -0.03713664f, 
    -0.13533983f, -0.06825570f, -0.17315161f, -0.01362729f, -0.03254248f, 0.05224210f, -0.03868262f, 0.06532717f, 
    -0.19657500f, -0.45971254f, 0.00117629f, 0.02754660f, 0.03891319f, 0.13627398f, 0.07139011f, -0.07567453f, 
    -0.00189538f, 0.03212474f, 0.01829579f, 0.02992839f, 0.02549738f, 0.03441872f, -0.04351711f, -0.27129731f, 
    -0.31972191f, 0.21789776f, -0.03755866f, -0.16398601f, -0.25276047f, -0.04131241f, -0.23777542f, -0.50223893f, 
    0.25355053f, -0.00223777f, 0.08576763f, -0.13005327f, 0.06803487f, -0.00090415f, 0.09908212f, -0.03589988f, 
    -0.01944119f, -0.05480321f, 0.20138250f, 0.10797198f, -0.24417613f, -0.16252659f, 0.10384162f, 0.14830601f, 
    -0.25529301f, -0.04529164f, -0.40443766f, 0.15719722f, 0.13462669f, -0.03880277f, -0.02897840f, -0.18947674f, 
    -0.11628735f, -0.09771667f, 0.19108801f, -0.04985222f, 0.31974027f, 0.17080639f, 0.10498119f, 0.23812313f, 
    -0.09666006f, -0.01208311f, 0.05739877f, -0.05094650f, 0.16773246f, -0.08545148f, 0.42899880f, -0.13887960f, 
    -0.19805919f, 0.33531162f, 0.20771751f, 0.07001951f, 0.03159356f, -0.25586656f, 0.07565095f, -0.05719355f, 
    0.05910449f, 0.07443343f, 0.00140865f, 0.01258399f, 0.13449156f, -0.02630990f, 0.21157138f, 0.15515426f, 
    0.44513980f, 0.28400645f, -0.37979341f, -0.45874220f, -0.07960558f, -0.16347721f, -0.07619584f, -0.01538540f, 
    -0.13736995f, -0.01609550f, 0.11051395f, 0.06049807f, -0.25600803f, -0.00390545f, 0.33870864f, 0.04844078f, 
    -0.11736364f, 0.07357226f, 0.40654385f, 0.21669096f, -0.06356968f, -0.11668307f, -0.32859987f, 0.06940903f, 
    0.12425712f, 0.12722361f, -0.00224516f, -0.00873012f, -0.06752529f, 0.03914681f, 0.07258918f, -0.09378841f, 
    0.06174143f, 0.22395021f, -0.05121461f, 0.16324380f, 0.01295198f, 0.22626834f, -0.09515025f, -0.05870417f, 
    -0.22531798f, -0.87890041f, -1.02220881f, -0.36926466f, 0.31845859f, -0.07286921f, 0.27327654f, 0.10890127f, 
    -0.11571503f, -0.42780766f, 0.02815423f, 0.04471384f, -0.02840997f, -0.07946189f, 0.10109697f, 0.04516101f, 
    0.05497630f, -0.03560580f, 0.20900466f, -0.07386296f, -0.57294834f, 0.87051910f, 0.38315913f, -0.10369296f, 
    0.24624439f, -0.17339049f, 0.01778208f, -0.07924519f, 0.17394336f, 0.15299369f, 0.18870720f, 0.03805099f, 
    0.25352299f, -0.00928079f, 0.06502387f, 0.09897117f, -0.13687716f, -0.07708680f, -0.04144993f, -0.09431127f, 
    -0.30855393f, 0.35607633f, -0.11633854f, 0.09887326f, -0.29234645f, 0.07846036f, -0.09327317f, -0.09699265f, 
    0.19909748f, -0.19778284f, 0.02049455f, -0.07125128f, -0.02065813f, 0.05130517f, 0.06616984f, -0.05073404f, 
    -0.08960441f, 0.28625983f, -0.36814097f, -0.15739745f, -0.73502988f, 0.13814665f, -0.05199388f, 0.17603219f, 
    0.26741895f, -0.38823581f, -0.03725607f, -0.14672618f, -0.27896029f, 0.62185735f, -0.03756530f, 0.10244489f, 
    0.29332435f, -0.01372897f, 0.10079055f, -0.14492416f, 0.24939719f, -0.20864841f, 0.22639330f, -0.02408657f, 
    -1.04351270f, -0.87623346f, -1.34988272f, -0.00067336f, 0.27957255f, -0.18517813f, 0.03198284f, 0.01682387f, 
    -0.31594044f, -0.39142489f, -0.00470951f, -0.09892336f, -0.02775741f, 0.02500442f, 0.07812217f, -0.08520262f, 
    -0.03277322f, 0.03054267f, 0.45490712f, 0.06889527f, 0.13983603f, -0.35057300f, -0.46216679f, -0.09747787f, 
    0.36418682f, -0.12087206f, 0.24111326f, 0.56480646f, 0.17083709f, -0.14886221f, -0.00317997f, -0.03341711f, 
    -0.19798753f, -0.00824320f, 0.06585534f, -0.02670476f, 0.02975049f, 0.06455301f, 0.21964690f, 0.05581608f, 
    0.04180372f, 0.13400254f, 0.12087611f, 0.01463004f, 0.07994209f, -0.09819471f, -0.04329972f, -0.12704149f, 
    0.05519829f, 0.15734452f, -0.05444866f, -0.00416345f, -0.06924983f, 0.01698546f, 0.19785798f, 0.09456399f, 
    -0.02684404f, -0.19754174f, -0.05637962f, -0.11563896f, -0.26768026f, -0.62834406f, -0.30481040f, -0.39563733f, 
    0.76653028f, -0.15861307f, -0.26255110f, -0.26845786f, -0.07551825f, 0.14890407f, -0.01218725f, 0.13417600f, 
    0.09137700f, 0.19032668f, -0.32902095f, 0.01348623f, 0.02113412f, 0.10539891f, 0.07338683f, 0.07174744f, 
    0.40437117f, -0.33926824f, -0.29742602f, -0.31106147f, 0.06547096f, 0.03148681f, 0.11335538f, 0.21062550f, 
    -0.09270191f, 0.10056107f, 0.02909449f, -0.00802167f, -0.02320892f, -0.18181369f, 0.01918599f, -0.02000835f, 
    0.08184183f, 0.01203251f, 0.07352691f, 0.07867393f, -0.35169283f, 0.64150435f, 0.34808615f, -0.06807926f, 
    0.10266470f, -0.05443686f, -0.09164456f, -0.08138028f, -0.07358052f, 0.01817933f, -0.12169218f, 0.09003072f, 
    0.00843524f, 0.16382980f, 0.08599150f, 0.05622360f, -0.03597691f, -0.06484769f, -0.13743958f, -0.06699553f, 
    -0.14154457f, -0.06391728f, -0.50727773f, -0.47013810f, -0.35800502f, 0.03719990f, 0.02144250f, 0.13619454f, 
    -0.06678217f, 0.00648051f, -0.10825925f, -0.00084444f, 0.01964100f, -0.06606828f, -0.04501437f, -0.12665945f, 
    0.04437925f, -0.41247317f, 0.11403115f, 0.19533554f, -0.17571229f, 0.10969288f, 0.42435756f, -0.38156846f, 
    0.19924335f, 0.01043608f, 0.10851822f, 0.06326842f, 0.05356026f, -0.13471039f, 0.05728007f, -0.00033092f, 
    0.05735222f, -0.01020297f, 0.08484235f, 0.14451054f, 0.15739274f, 0.00493877f, -0.25671315f, 0.13540445f, 
    0.06193059f, 0.06118287f, 0.01833868f, -0.00890773f, 0.08798571f, 0.08298193f, -0.00478489f, 0.05526822f, 
    -0.05307955f, 0.11412829f, 0.08611834f, -0.05902221f, 0.07802959f, -0.07782886f, -0.02182028f, 0.12323121f, 
    0.20577638f, -0.09742476f, -0.09257461f, 0.06613470f, -1.54782915f, -1.00398624f, -0.26247090f, -0.62983811f, 
    -0.22460404f, -0.37569669f, -0.13461861f, -0.27022991f, -0.20229906f, -0.50033212f, 0.01025252f, 0.00891858f, 
    -0.05652805f, -0.04387732f, -0.02580409f, -0.03536410f, -0.00628961f, 0.03958439f, 0.16921099f, -0.11541221f, 
    0.00907841f, -0.12903430f, -0.01714665f, 0.26881224f, 0.07403433f, 0.05368480f, 0.17060712f, -0.03488306f, 
    0.12740146f, 0.08151568f, 0.05501897f, 0.06362434f, 0.16609715f, 0.19826740f, -0.02982570f, 0.20615883f, 
    0.12897646f, -0.00526788f, 0.06534768f, 0.19891220f, 0.25666276f, -0.04108690f, -0.12444538f, -0.19171511f, 
    -0.07831450f, -0.00190085f, -0.03837115f, 0.10418595f, -0.12861750f, 0.06901806f, -0.14624532f, -0.09250506f, 
    -0.15673301f, -0.24217413f, -0.14376295f, -0.24148007f, -0.29120481f, -0.11281775f, -0.08468555f, 0.01519008f, 
    -0.72410572f, -0.62323195f, -0.26765963f, 0.62011737f, -0.14978941f, 0.07343692f, 0.04333413f, -0.04333064f, 
    -0.10514860f, 0.01338969f, 0.02564259f, -0.03083732f, 0.02683854f, 0.00803015f, -0.04167017f, 0.04718859f, 
    0.04684794f, -0.14765695f, 0.00447777f, -0.08779856f, -0.17708388f, -0.23432393f, -0.13760921f, -0.21105765f, 
    -0.06910752f, 0.00735490f, -0.08870847f, 0.22569521f, 0.03643030f, -0.06707183f, -0.30089819f, 0.07943611f, 
    0.03349401f, 0.12668405f, 0.13779570f, 0.06309976f, 0.01618635f, 0.08702110f, 0.02994622f, 0.03909847f, 
    -0.89008760f, -0.43192726f, 0.56557620f, -0.53902680f, 0.42730194f, -0.48446381f, 0.18185008f, 0.14328566f, 
    -0.09838947f, -0.29533023f, -0.03715139f, 0.03250909f, 0.04640644f, 0.00493597f, 0.06444507f, 0.03449052f, 
    -0.01469172f, -0.06299053f, -0.12896442f, -0.02458814f, 0.86299378f, 0.98027587f, -0.11254159f, 0.30336925f, 
    -0.50480115f, 0.37764186f, 0.05232473f, -0.00242788f, -0.06743222f, -0.27945113f, 0.03933010f, 0.06168688f, 
    0.13689035f, -0.09287613f, -0.07284379f, -0.04220758f, -0.20289201f, -0.01496398f, -0.08927430f, -0.23430513f, 
    -0.84644169f, -0.92252839f, 0.24171795f, 0.60485911f, 0.31415296f, -0.02716296f, 0.07496241f, -0.00529293f, 
    0.09275397f, 0.07859026f, 0.00959244f, -0.05799018f, -0.20433615f, -0.13751620f, -0.06256237f, 0.08559682f, 
    0.11159113f, -0.02253577f, 0.19550580f, -0.11383546f, -0.17342196f, 0.19339736f, -0.24693918f, 0.17477956f, 
    -0.39725903f, 0.04211676f, 0.05632883f, -0.05589206f, 0.06354458f, -0.03080126f, 0.04476451f, 0.04516884f, 
    0.03687863f, 0.05996258f, -0.08856896f, 0.16816814f, -0.08066930f, 0.11244953f, -0.00592606f, 0.01749975f, 
    0.06472399f, 0.10058211f, -0.15940316f, -0.10529510f, -0.12645224f, 0.06815819f, 0.04434361f, 0.00677588f, 
    -0.08715871f, -0.06336175f, -0.36691648f, -0.40496022f, -0.09062503f, -0.10504312f, -0.10126349f, 0.02240913f, 
    -0.08165554f, 0.07978401f, -0.02832984f, -0.01318056f, 0.99257183f, -1.32589197f, -1.32364488f, -1.31425214f, 
    -0.40690380f, -0.02594186f, -0.02256669f, -0.18608722f, 0.46066156f, -0.04455108f, 0.00547406f, 0.08605022f, 
    0.01330373f, 0.05768102f, 0.12945503f, -0.23335169f, -0.11562253f, -0.15881266f, 0.05379808f, 0.12944736f, 
    -0.24067105f, -0.05757780f, 0.09861019f, 0.07183781f, -0.11691237f, 0.13217030f, -0.02518333f, 0.25494274f, 
    0.19905919f, 0.05473662f, 0.04354496f, -0.00209428f, 0.08244836f, -0.01298756f, -0.02340983f, -0.13697527f, 
    0.17096820f, -0.11449222f, 0.12070653f, 0.01143570f, 0.08266236f, -0.06816943f, -0.19384757f, -0.23112810f, 
    -0.12016136f, -0.02396806f, -0.02606729f, 0.05115984f, -0.03665579f, 0.00363019f, 0.00023139f, -0.07744444f, 
    0.13381808f, 0.06032625f, 0.13138464f, 0.00656098f, -0.00097482f, 0.03395326f, 0.04370724f, 0.04541110f, 
    -0.16628768f, 0.11090816f, -0.01353830f, 0.09860636f, -0.35942763f, 0.09806474f, 0.14824776f, 0.04965977f, 
    -0.00958361f, -0.03677834f, 0.08114179f, 0.03293373f, 0.04752285f, 0.00085930f, 0.01088270f, 0.20194760f, 
    0.00675179f, -0.33056316f, 0.08780191f, 0.01491429f, -0.02127817f, -0.09049871f, -0.12380701f, -0.01995062f, 
    0.14052188f, 0.13627137f, 0.08972187f, 0.18019879f, -0.09359760f, -0.03083778f, 0.06387687f, -0.02724835f, 
    0.07021223f, 0.06588403f, -0.06508768f, 0.02644152f, -0.22471514f, -0.19046004f, -0.28033867f, -0.07632224f, 
    0.05147703f, 0.18435958f, 0.13791057f, -0.05439381f, -0.10692000f, -0.06720889f, -0.03221305f, 0.03573826f, 
    -0.05528184f, -0.10137920f, -0.04693089f, -0.12849817f, -0.08594241f, -0.18271022f, -0.08274891f, -0.11005098f, 
    -0.10529610f, 0.06712431f, -0.11566032f, -0.01504641f, 0.38901398f, -1.15028918f, 0.07066386f, 0.41848314f, 
    -0.03987285f, 0.03511556f, 0.25468120f, -0.12079186f, 0.11140682f, 0.12237644f, 0.04408533f, 0.08774827f, 
    -0.06077945f, -0.00422572f, -0.00807517f, -0.00613154f, 0.04830856f, -0.05222163f, 0.09196654f, -0.11131870f, 
    0.03708813f, 0.11202612f, 0.09213110f, -0.04219123f, 0.08027624f, 0.03982909f, -0.01913394f, 0.04081191f, 
    -0.06005910f, 0.01740933f, -0.05183938f, -0.05822240f, -0.05430062f, -0.23832709f, -0.17161848f, -0.14394455f, 
    0.14313032f, -0.17065017f, -0.08969377f, 0.13265769f, 0.08499057f, 0.13541727f, 0.09955233f, 0.00882313f, 
    -0.19291027f, 0.05734630f, 0.01658605f, 0.01741324f, -0.08637338f, -0.04406545f, 0.02453502f, -0.05996298f, 
    -0.02504980f, -0.07217217f, -0.05004587f, -0.01408755f, -0.09302437f, 0.13362221f, 0.05752628f, -0.00223306f, 
    0.72406602f, 0.14910430f, 0.26390865f, -0.03149206f, -0.16037171f, 0.19826140f, 0.02939755f, -0.13902053f, 
    -0.03730073f, -0.35828105f, 0.01214876f, 0.08379390f, 0.11317392f, -0.05214394f, -0.03431287f, -0.03761449f, 
    0.15139660f, 0.10811426f, 0.02744539f, 0.03231832f, -0.17787442f, -0.67539924f, -0.21371916f, -0.06134831f, 
    0.15000819f, -0.06498901f, 0.18729860f, 0.26182154f, 0.03382298f, 0.04127769f, 0.11695687f, 0.05439764f, 
    -0.01266853f, 0.05042737f, -0.08024048f, -0.12900265f, 0.02603885f, 0.01350464f, 0.14311418f, -0.00491715f, 
    0.61107498f, -0.68768424f, -0.27739477f, 0.14241551f, -0.01272945f, 0.16153863f, -0.03452687f, -0.11150306f, 
    0.03287151f, 0.31511000f, 0.03299428f, -0.02528360f, -0.01981985f, -0.07052243f, 0.08251116f, -0.04999215f, 
    0.22023778f, 0.18577954f, 0.09287203f, 0.01911589f, 0.37767166f, 0.04775215f, -0.58059919f, -0.74710244f, 
    -0.24452576f, -0.06532695f, 0.31438765f, 0.14560048f, 0.33414572f, -0.10389846f, 0.26988730f, 0.04224754f, 
    0.17054746f, 0.08230520f, 0.09595378f, 0.08324283f, -0.15684722f, -0.14498988f, 0.08796905f, -0.14011739f, 
    0.68463922f, -0.21483013f, -0.15953772f, -0.29547438f, -0.35844615f, 0.05227897f, -0.36163777f, 0.05197664f, 
    -0.08147003f, -0.21251099f, 0.02845811f, -0.00564350f, 0.04033271f, 0.15206598f, 0.07317345f, 0.19137689f, 
    0.06786273f, 0.09342295f, -0.35562950f, -0.47890484f, 0.21172982f, 0.12155814f, 0.06395223f, 0.19538240f, 
    -0.40374422f, 0.02337600f, -0.11015236f, -0.05483149f, 0.04704436f, -0.43159866f, -0.13767420f, 0.14189295f, 
    0.01420894f, 0.00430932f, 0.03639989f, 0.02387530f, 0.15790410f, 0.06615917f, 0.18699799f, 0.05442433f, 
    0.08686266f, -0.06343235f, -0.21406119f, -0.06558221f, -0.09163444f, -0.09768045f, -0.03186429f, -0.04093772f, 
    -0.02328832f, -0.02597465f, 0.03705977f, 0.06051880f, 0.06501564f, 0.03628755f, 0.01816319f, -0.00125517f, 
    0.11881573f, 0.17315550f, 0.29473472f, 0.14790536f, -0.05850456f, -0.53284180f, -1.67415619f, -0.62625915f, 
    0.12759741f, 0.03371896f, -0.11019646f, 0.20177762f, 0.00621388f, 0.03099979f, -0.00515371f, -0.16036640f, 
    -0.07210854f, 0.00382124f, 0.00435418f, 0.18613045f, -0.20792775f, -0.00771078f, -0.26697367f, -0.19686925f, 
    -0.04064092f, 0.21229441f, -0.16782682f, -0.06419912f, -0.05424295f, 0.12241339f, -0.14311445f, -0.10345793f, 
    -0.21665764f, -0.53277153f, -0.01397036f, 0.10442901f, 0.13861971f, -0.08749067f, 0.03443296f, -0.37312120f, 
    0.05816085f, 0.31411418f, 0.37021136f, 0.18718766f, -0.23180671f, -0.45468765f, -0.32331553f, -0.05868057f, 
    0.06717897f, -0.04635834f, 0.09118919f, 0.12837407f, 0.04855552f, 0.22814506f, 0.12922287f, -0.08101492f, 
    -0.02339189f, -0.08849142f, -0.09356935f, -0.01034635f, 0.11886747f, 0.02754301f, 0.07617381f, 0.02707125f, 
    -1.01290190f, 0.40885359f, 0.27396595f, 0.02201375f, -0.31340471f, -0.10611408f, -0.12205821f, -0.11840630f, 
    -0.07722152f, -0.11768924f, -0.18373783f, -0.09271111f, -0.05431041f, -0.15052849f, -0.01763420f, -0.11499590f, 
    0.03758408f, -0.40044433f, -0.26655883f, -0.17773952f, -0.71668375f, -0.23084415f, 0.35650301f, 0.23779464f, 
    0.26871893f, 0.02902561f, -0.10454379f, -0.06773607f, -0.17827822f, -0.09990857f, 0.00695787f, -0.09951390f, 
    0.01695588f, 0.05591641f, -0.05152918f, -0.06099135f, -0.30115488f, -0.06769009f, -0.34243065f, 0.04298311f, 
    -0.26757061f, 0.11255552f, 0.17308983f, 0.11238895f, -0.10710811f, -0.04723563f, 0.02876045f, 0.13716462f, 
    0.03930308f, 0.12161237f, -0.02047032f, 0.11475394f, -0.02554811f, 0.11974085f, 0.08133861f, 0.03284822f, 
    0.06748980f, -0.04518085f, -0.00630692f, 0.13873862f, -0.11085807f, -1.11184788f, -0.97140992f, -0.45804709f, 
    -0.12278827f, -0.02389078f, -0.21543309f, 0.19517282f, 0.12357526f, 0.04728015f, -0.16085438f, -0.02192135f, 
    -0.03359427f, 0.01833704f, -0.01906485f, 0.00628817f, 0.11271272f, 0.16519257f, 0.05833632f, 0.31905466f, 
    0.39135224f, 0.06541993f, 0.05556417f, 0.15622717f, -0.13585238f, -0.20371698f, -0.00562325f, -0.21045932f, 
    0.03239309f, 0.00938418f, 0.12308495f, -0.01010614f, 0.23894820f, 0.17304505f, 0.23676264f, -0.00078026f, 
    -0.06871942f, -0.12019896f, -0.16736947f, -0.02988394f, -0.42105410f, 0.04628890f, 0.11573949f, -0.03154259f, 
    -0.26123065f, -0.16653168f, -0.06787395f, -0.08358452f, -0.06494797f, 0.02317959f, -0.12743254f, -0.02340805f, 
    -0.03401342f, 0.15107584f, 0.01144035f, -0.06305309f, 0.18672501f, 0.03077391f, 0.08088966f, 0.03652839f, 
    0.07429349f, 0.53305858f, -0.91837400f, 0.18637435f, -0.28917208f, 0.08255028f, 0.01041177f, 0.31009415f, 
    -0.16029225f, 0.16796011f, 0.15598837f, -0.05146128f, -0.07024433f, -0.07039867f, -0.19152774f, 0.06635877f, 
    0.02613568f, -0.07584195f, 0.09033879f, -0.11856280f, 0.08350386f, -0.13005473f, 0.73917091f, 0.11917222f, 
    -0.74014032f, 0.21153824f, -0.38403696f, -0.30885804f, -0.01781448f, -0.13700151f, -0.19031337f, 0.04741739f, 
    0.07161561f, 0.22633648f, -0.01258520f, 0.02524922f, -0.11697516f, -0.02314533f, -0.10366447f, 0.14740455f, 
    0.01520868f, -0.26225108f, 0.36452103f, -0.29750738f, -0.17900363f, -0.31890738f, 0.01500272f, -0.02515015f, 
    -0.02248718f, -0.06492776f, -0.02756565f, -0.04922852f, 0.03008552f, -0.02901106f, 0.05045172f, -0.00018470f, 
    -0.04595024f, -0.07373593f, -0.19547689f, -0.15111873f, -1.25706446f, 0.08794592f, -0.08222005f, 0.87796521f, 
    -0.40733603f, 0.10770719f, -0.17434900f, -0.43731135f, -0.00421070f, -0.16329727f, 0.16521050f, -0.10696393f, 
    0.09903289f, -0.26003578f, 0.06851085f, -0.01899111f, -0.11706334f, -0.18325804f, 0.04801511f, 0.16709258f, 
    -0.12729244f, -0.55729550f, -0.14945246f, 0.16426918f, -0.35109353f, 0.03819516f, -0.34886721f, -0.03725672f, 
    0.06637429f, 0.14145005f, 0.02119213f, 0.11186428f, 0.14162132f, 0.02357303f, -0.02154684f, -0.02687367f, 
    0.09552316f, 0.09105261f, 0.16994539f, 0.26361415f, -0.46627292f, 0.59848595f, -0.82437861f, 0.08385339f, 
    -0.22847985f, 0.06924184f, 0.02683872f, 0.29267260f, -0.14273587f, 0.04256374f, 0.20272607f, -0.11874266f, 
    -0.13967520f, -0.13153605f, -0.15199821f, 0.02350622f, -0.12399343f, -0.18055461f, -0.05875119f, -0.18716426f, 
    0.18367819f, 0.18133004f, 0.07793378f, 0.15454009f, 0.01721875f, -0.03742985f, 0.01735365f, -0.06931916f, 
    0.03765681f, -0.29137582f, -0.04222186f, -0.02894259f, -0.09471643f, 0.05651825f, -0.04666757f, -0.11128217f, 
    -0.06705231f, -0.16354576f, 0.04911155f, -0.15883650f, 0.27265981f, 0.04777515f, -0.16107662f, 0.66779268f, 
    -1.02727640f, -0.19516280f, -0.01233632f, -0.34306559f, 0.12501138f, -0.01161933f, 0.11628078f, -0.12405144f, 
    0.16743337f, 0.07255144f, -0.00018386f, 0.15423438f, 0.19202627f, 0.27252474f, 0.09399608f, 0.14861187f, 
    -0.09300054f, -0.17306451f, -0.95563453f, 0.04910045f, 0.15278387f, -0.10759182f, 0.20139083f, 0.32619047f, 
    -0.06554720f, 0.27400437f, 0.06749192f, 0.04388576f, -0.26717794f, -0.12488493f, -0.17551529f, 0.13931690f, 
    0.03665163f, -0.28234506f, 0.00823150f, -0.11002562f, 0.37047526f, 0.22483294f, 0.67943203f, 0.02505081f, 
    -0.32554844f, 0.03323668f, -0.13164164f, -0.47574872f, 0.00841113f, -0.08555119f, -0.05681799f, 0.10624910f, 
    0.16756877f, 0.10442726f, 0.04885709f, 0.02224874f, -0.03423371f, -0.05251803f, -0.00910897f, 0.04691350f, 
    -0.33585608f, -0.23662233f, -1.01570165f, -0.11972813f, 0.52632713f, -0.18547064f, 0.46262076f, 0.41689178f, 
    0.14082198f, -0.04667339f, -0.03605251f, -0.10026484f, -0.07088760f, -0.02749006f, 0.01900856f, -0.00367542f, 
    0.44164467f, -0.08183592f, 0.10433958f, 0.09244584f, 0.09924629f, -0.31581599f, -0.42837384f, -0.41321716f, 
    0.04722125f, 0.11383100f, -0.20893250f, 0.33395499f, 0.13560268f, 0.09403979f, -0.04313689f, 0.04107675f, 
    -0.03360749f, -0.06840108f, -0.09536243f, 0.14102001f, 0.07353108f, 0.25472069f, 0.02574950f, 0.03868767f, 
    0.09433619f, 0.30163038f, -0.08155195f, -0.21646494f, 0.23261322f, 0.11322527f, 0.09289543f, 0.15999645f, 
    0.07538968f, -0.06352352f, 0.02467252f, 0.01446846f, -0.14405175f, -0.15439786f, -0.05701908f, 0.05283185f, 
    0.03430561f, 0.01340827f, 0.03829457f, 0.06575129f, -0.22824030f, -0.43808120f, 0.23984097f, 0.13285993f, 
    -0.28458476f, 0.04545515f, -0.34862894f, 0.20179242f, 0.19940826f, 0.35970637f, -0.06332204f, 0.02228138f, 
    0.04876285f, -0.05345777f, -0.11839498f, -0.00013934f, -0.02092765f, -0.02215456f, -0.00190534f, -0.33125168f, 
    -0.38589820f, -0.49505714f, 0.12823799f, -0.06096021f, 0.12454558f, -0.24665239f, 0.17766520f, -0.70804650f, 
    0.08502301f, -0.30463329f, 0.27263635f, -0.10972390f, 0.09055924f, 0.02668282f, 0.00433166f, 0.10143412f, 
    0.05509360f, -0.06381553f, -0.13131988f, 0.03733086f, -0.20822857f, -0.06938037f, -0.10691991f, -0.31238741f, 
    0.24155350f, 0.08909605f, 0.36846516f, 0.31203789f, 0.13593714f, 0.02061045f, 0.24027810f, -0.02890330f, 
    0.05577174f, -0.16446549f, -0.00112100f, 0.29551977f, 0.00285465f, 0.06220733f, 0.00925926f, 0.05094862f, 
    -0.46086735f, -0.15663826f, 0.22628756f, -0.17078145f, 0.11782057f, 0.03591331f, -0.22714444f, 0.21350627f, 
    -0.03261462f, -0.03892035f, -0.00971454f, 0.15432660f, 0.05383208f, 0.12535349f, 0.04671089f, 0.11327876f, 
    -0.01066973f, 0.08945363f, 0.15482756f, 0.02402554f, -0.53935987f, 0.57157302f, 0.10339788f, 0.11771584f, 
    0.14669530f, 0.00989895f, -0.12931190f, -0.19490345f, 0.21247055f, 0.07965811f, 0.04340838f, -0.06897920f, 
    0.01351377f, -0.15721579f, 0.12234800f, -0.04485703f, -0.09268760f, -0.10112176f, 0.13740806f, 0.09930936f, 
    -0.61560845f, 0.40589178f, -0.24396473f, 0.16302682f, 0.11155438f, 0.12160599f, 0.05876682f, 0.09632545f, 
    0.32451594f, 0.33835900f, -0.13528514f, -0.05033920f, -0.00059205f, -0.06700221f, -0.06604485f, -0.10845496f, 
    0.15025017f, -0.30107471f, 0.07883958f, 0.30881399f, 0.59760082f, -0.19182628f, 0.45474565f, -0.41728723f, 
    0.01077432f, -0.09220484f, -0.15022080f, 0.19375904f, 0.09566899f, -0.13521622f, -0.20943835f, -0.13819325f, 
    -0.21739484f, 0.15537685f, -0.05141477f, 0.02760276f, -0.10479821f, 0.08375492f, 0.01623921f, -0.14679132f, 
    -0.66169071f, 0.14740875f, -0.58176118f, 0.21898790f, -0.05307977f, 0.06032079f, -0.07021005f, 0.07146486f, 
    0.06792755f, 0.12450948f, -0.07717814f, 0.06532482f, 0.13148046f, 0.01157134f, -0.07951038f, 0.15282829f, 
    -0.17089537f, -0.39037514f, -0.22975698f, -0.36024079f, -0.34709239f, -0.69960076f, 0.19078374f, -0.02197849f, 
    -0.12724775f, -0.04812071f, 0.08482987f, 0.36352324f, -0.26752734f, -0.07510585f, -0.20122401f, -0.01460572f, 
    -0.13277631f, -0.00863787f, -0.01960658f, -0.05944332f, -0.12824386f, 0.19352484f, 0.10151949f, 0.05827018f, 
    -0.24931425f, -0.56217235f, 0.34012526f, 0.26642087f, -0.15494516f, -0.12939198f, 0.11999177f, 0.02193563f, 
    0.03473046f, -0.04111746f, 0.04005031f, -0.19018130f, 0.00154612f, 0.14921872f, 0.00405551f, 0.07943728f, 
    0.22921354f, 0.20630601f, 0.36734217f, 0.43625697f, -0.12357229f, 0.06619660f, -0.75766301f, 0.06299526f, 
    -0.04727360f, 0.04906936f, -0.08981650f, 0.05841013f, -0.05727865f, 0.04799743f, -0.11313917f, 0.21742100f, 
    -0.12130680f, -0.37999755f, -0.30989891f, 0.07623173f, -0.10771347f, 0.01389074f, -0.05234652f, -0.26288944f, 
    -0.02088170f, -0.34151849f, -0.16759118f, -0.04793717f, -0.04157780f, 0.11615536f, -0.14267983f, 0.35053402f, 
    -0.38842770f, -0.12005940f, -0.19509672f, 0.12238135f, -0.07684746f, 0.21533121f, 0.25253806f, 0.26689616f, 
    -0.16946374f, 0.22618882f, -0.07909220f, 0.25370547f, 0.01219506f, 0.21463068f, -0.29398823f, 0.09840017f, 
    0.09671038f, 0.15807822f, 0.04035995f, -0.16604893f, 0.05719785f, 0.10473759f, -0.09479663f, 0.12021719f, 
    -0.09715621f, -0.11405240f, -0.10514835f, 0.09088714f, 0.05189697f, -0.16522141f, 0.13202022f, 0.00898428f, 
    0.14116946f, -0.57574219f, 0.23314163f, -0.61046851f, -0.21636827f, 0.08819687f, -0.08922906f, -0.13821226f, 
    -0.25491020f, -0.27952594f, -0.17916314f, -0.00745719f, 0.03301457f, 0.04082233f, 0.02373977f, 0.14049427f, 
    -0.19871654f, -0.19610754f, -0.62188619f, -0.23678678f, -0.35551745f, 0.10298065f, -0.41549006f, 0.64906919f, 
    0.06053025f, -0.02910668f, 0.03197769f, -0.13767518f, 0.20109862f, 0.06175128f, 0.04887078f, 0.10773478f, 
    0.03462297f, 0.08342556f, 0.05025097f, -0.06839117f, -0.05411653f, -0.25649422f, 0.03575579f, 0.03775469f, 
    -0.12629193f, -0.00060060f, 0.44285315f, 0.19523278f, -0.09367870f, -0.02004326f, 0.05106644f, -0.10431408f, 
    -0.05921186f, -0.01840429f, -0.06899268f, 0.00639761f, 0.26930860f, 0.03143001f, -0.09793514f, -0.03362089f, 
    0.13011900f, 0.01126267f, 0.11624250f, -0.08505213f, -0.59390765f, 0.04904395f, -0.09806564f, 0.19139369f, 
    0.33778068f, -0.20840010f, -0.09005550f, 0.00010913f, -0.17365202f, -0.17086695f, -0.14144266f, 0.12101588f, 
    0.08309875f, 0.17161702f, 0.00927723f, 0.17607965f, -0.10679565f, -0.27283546f, 0.04074705f, 0.15538540f, 
    -0.53223616f, 0.46960512f, 0.84288305f, -0.17031361f, -0.14814210f, 0.29457888f, -0.27672252f, 0.09715560f, 
    0.40490147f, -0.07602357f, -0.11102173f, 0.02836888f, -0.11142670f, 0.02420476f, 0.06897143f, -0.48848087f, 
    0.02130289f, -0.02067684f, -0.03738986f, -0.03735697f, -0.04326974f, -0.61477423f, 0.05890314f, -0.68570215f, 
    -0.53210473f, -0.13732372f, -0.12764791f, -0.22359028f, 0.09176026f, -0.14253086f, -0.27669689f, 0.08461774f, 
    0.11233942f, -0.32928279f, -0.01881522f, 0.14731508f, 0.15529573f, 0.03869214f, 0.13499492f, 0.02765140f, 
    0.50150263f, -0.06802323f, 0.32190934f, -0.07395979f, 0.22005793f, 0.02557207f, -0.24108329f, -0.10945448f, 
    0.01368999f, -0.24361901f, -0.07765523f, 0.11726617f, 0.02093595f, 0.11694606f, 0.01661977f, 0.01948098f, 
    -0.22245878f, -0.05187128f, -0.02525918f, 0.20394915f, -0.80357659f, -0.09684230f, -0.56397408f, 0.63746130f, 
    -0.44772601f, -0.18418978f, 0.15465200f, -0.22106148f, 0.35662258f, 0.01406467f, -0.04235241f, -0.11271956f, 
    0.09945241f, -0.11188982f, 0.05501672f, -0.04599557f, -0.13297988f, 0.09566863f, -0.05292857f, 0.15049316f, 
    -0.53060704f, -0.13350700f, -0.17100714f, 0.67298472f, -0.26555672f, -0.02731793f, -0.18398429f, 0.10332900f, 
    0.10120963f, -0.07651863f, -0.01007973f, -0.20894040f, -0.16964266f, -0.04196049f, 0.14718181f, 0.28995785f, 
    -0.02053556f, 0.09865451f, -0.09428560f, -0.28626561f, -0.14042421f, -0.61551523f, 0.38637412f, -0.21053639f, 
    0.80335873f, 0.28567788f, 0.48561308f, 0.31344634f, -0.16650631f, 0.17032315f, 0.03596310f, -0.03115061f, 
    0.06488399f, 0.11080150f, 0.01617195f, -0.02111563f, 0.26452130f, 0.16309218f, 0.05713725f, 0.19445547f, 
    0.30946761f, -0.42837572f, -0.43611917f, -0.15373254f, 0.24013668f, -0.04587263f, -0.49903968f, 0.13271397f, 
    -0.12516882f, -0.23039946f, -0.03547987f, 0.02267496f, 0.01903145f, -0.12945807f, -0.00888852f, 0.08832090f, 
    -0.09856371f, 0.16151673f, 0.12586276f, 0.05838360f, 0.69480991f, -0.04177800f, 0.83415276f, -0.33134693f, 
    -0.01980354f, 0.20519878f, 0.02366394f, -0.26768434f, 0.13424526f, 0.04543217f, -0.13875690f, 0.15870191f, 
    0.16452906f, 0.08150640f, -0.00747896f, -0.26156181f, 0.11938894f, -0.01051624f, -0.03415237f, 0.08532339f, 
    -0.03795993f, -0.16183168f, 0.18335223f, -0.09633865f, -0.09710907f, 0.10294562f, 0.10977513f, 0.06627180f, 
    -0.03983449f, -0.03601852f, 0.18620434f, 0.03640210f, 0.18720120f, -0.00584375f, 0.05466646f, -0.05876861f, 
    -0.04998969f, -0.30378282f, -0.44224524f, -0.34960669f, -0.35585734f, -0.48052481f, -0.33508840f, -0.17553364f, 
    -0.61798936f, 0.16491182f, 0.07181614f, 0.12800352f, -0.30829751f, -0.06157114f, -0.10770153f, -0.19198570f, 
    0.19502953f, 0.15698762f, 0.02439860f, -0.01966754f, 0.16336779f, 0.06129271f, 0.19047932f, 0.27597237f, 
    0.29704145f, 0.34372956f, 0.42157125f, 0.36940402f, -0.14739074f, -0.42787477f, -0.21964878f, -0.02624795f, 
    -0.10553820f, -0.18450396f, -0.14641269f, -0.03468352f, 0.03060583f, -0.11075334f, 0.21633644f, 0.05391510f, 
    -0.03097274f, -0.14738937f, 0.09835426f, 0.14860262f, -0.48556229f, -0.17401271f, -0.19798155f, 0.33118165f, 
    -0.29417375f, -0.06751367f, -0.16145204f, -0.08875103f, 0.04582939f, 0.00588539f, 0.07466502f, -0.15639739f, 
    0.02010109f, -0.11926844f, 0.00419731f, -0.03831090f, -0.15696712f, -0.25391406f, -0.17887169f, -0.14431490f, 
    0.64075828f, -0.29003736f, 0.16684040f, 0.11214194f, -0.08455950f, -0.06984492f, -0.05651769f, -0.41093680f, 
    -0.14823909f, -0.09380569f, -0.09798471f, -0.12341306f, 0.17708151f, -0.18680741f, -0.15466648f, 0.10495590f, 
    0.06380031f, 0.10158975f, 0.09395782f, 0.12987036f, 0.18399100f, -0.18104513f, -0.04851781f, 0.18609959f, 
    -0.23681664f, -0.14916925f, 0.18219167f, -0.11354231f, 0.17403726f, -0.19316146f, -0.29634336f, 0.03545944f, 
    0.16779511f, 0.00675649f, 0.09346125f, 0.10403541f, 0.08693659f, 0.26234096f, 0.10170648f, -0.24398671f, 
    0.05056566f, -0.08626930f, -0.13192442f, 0.26714477f, 0.11168695f, -0.14294802f, 0.23257145f, -0.07824887f, 
    0.11039469f, 0.16422205f, -0.06489819f, 0.07255840f, 0.05397304f, 0.10981142f, -0.02253903f, -0.00995635f, 
    -0.15205759f, 0.13285932f, -0.29608569f, 0.01844325f, 0.01284780f, -0.46167678f, -0.44413820f, 0.05151359f, 
    -0.03588041f, -0.13188064f, -0.75256240f, 0.08444449f, -0.26870808f, -0.05910686f, 0.04260007f, 0.03124459f, 
    0.04112872f, -0.07657731f, -0.12297491f, 0.00298879f, -0.06946628f, 0.02387254f, -0.03255541f, -0.15861519f, 
    -1.22022367f, 0.31479722f, -0.76712960f, 0.64538229f, -0.11811155f, 0.34314588f, 0.17210498f, 0.30952191f, 
    -0.14158435f, -0.01779917f, -0.11047274f, -0.16905190f, -0.14790986f, 0.31926784f, 0.01360037f, 0.19650789f, 
    -0.13160557f, 0.13656543f, 0.09732662f, 0.08355445f, 0.28716055f, 0.10580749f, 0.01775917f, 0.29089946f, 
    -0.11392009f, -0.23059896f, 0.21946625f, -0.05977391f, 0.15470408f, 0.02673860f, -0.31465474f, 0.05913856f, 
    0.10204422f, 0.03054974f, -0.20209068f, -0.01231981f, 0.00369496f, 0.08439738f, -0.17499778f, 0.06479351f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24263875f, 0.23037633f, 0.05933039f, -0.17676057f, -0.05339817f, -0.04421598f, 0.05540112f, -0.22244798f, 
    0.06695610f, 0.01794326f, -0.02560971f, -0.01466905f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
